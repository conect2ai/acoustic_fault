#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.13678765f, -0.34933197f, -0.79417437f, -0.60751176f, -0.90783304f, 0.77803636f, 0.11380243f, 0.29374272f, 
    0.06169529f, 0.05262545f, 0.18726206f, 0.02452883f, -0.34512213f, -0.15281054f, 0.00099331f, 0.05533486f, 
    -0.23543115f, 0.19523476f, -0.00102323f, -0.17428873f, -0.15789838f, -0.03633101f, 0.21814166f, -0.02616661f, 
    0.34439182f, -0.41724330f, 0.18863957f, -0.34675792f, -0.12631573f, -0.33932081f, -0.07285642f, -0.23755090f, 
    -0.08700837f, 0.23124796f, -0.35434940f, 0.48359656f, 0.12161411f, 0.42560858f, 0.33818856f, -0.25202495f, 
    -0.01949664f, -0.13073429f, -0.18045424f, -0.29934090f, -0.05411940f, 0.35985392f, 0.19297139f, 0.01090656f, 
    0.30273455f, 0.40973598f, -0.77918631f, -0.31774187f, -0.41172868f, -0.28655624f, 0.32735011f, 0.30636132f, 
    -0.42310348f, -0.53458434f, -0.33576453f, -0.32687840f, 0.27124637f, 0.38029099f, 0.31352422f, -0.08814005f, 
    0.21258844f, -0.04768497f, -0.24760149f, 0.09046981f, 0.10349182f, -0.21972249f, -0.14272109f, -0.15944867f, 
    -0.16157205f, 0.07955663f, -0.26623663f, 0.02794039f, -0.19745432f, -0.05957673f, 0.23901358f, 0.25516841f, 
    0.41128153f, 0.16115762f, 0.04551453f, -0.12232637f, -0.16261366f, -0.16413260f, 0.16642074f, -0.03604567f, 
    -0.52494955f, -0.00664383f, -0.30948812f, 0.33550537f, -0.08674652f, -0.09788062f, -0.32064149f, -0.13540588f, 
    0.23374815f, -0.16091587f, 0.31106973f, 0.31960377f, 0.45454946f, 0.53046197f, -0.43201640f, -0.46270713f, 
    -0.83521092f, -0.61848205f, -0.33982548f, 0.36394531f, 0.65461779f, 0.43726274f, 0.35933223f, 0.25577706f, 
    0.02227486f, 0.27296683f, -0.00166692f, 0.02896214f, 0.20037583f, 0.16813144f, -0.35549983f, -0.14645424f, 
    -0.07231374f, 0.04104503f, -0.10842078f, -0.27369916f, 0.10146684f, 0.30273718f, -1.11765015f, -0.66887981f, 
    0.20469742f, 0.20411761f, 0.13748395f, 0.21962042f, 0.07973026f, -0.03407165f, 0.40337077f, 0.27850223f, 
    -0.17916238f, -0.17193517f, -0.12115341f, 0.29262540f, 0.04648506f, -0.24876091f, 0.05485398f, 0.42537937f, 
    -0.17350376f, 0.10341059f, -0.26770347f, 0.05096855f, -0.05082412f, -0.00995115f, -0.79684937f, -0.65121478f, 
    -0.45293617f, -0.61798906f, -0.41788656f, 0.73076177f, 0.43650511f, 0.22127163f, 0.06174148f, 0.77518064f, 
    0.20996100f, 0.13658026f, 0.00377372f, -0.04275318f, 0.16760819f, 0.01722164f, 0.02406251f, -0.06103364f, 
    -0.20501710f, -0.04803331f, 0.01884341f, -0.15362211f, 0.23194973f, 0.08623611f, -0.21891330f, 0.44886461f, 
    -0.19310743f, 0.45684707f, 0.24479091f, -0.26390314f, 0.15134855f, 0.14604971f, -0.45720479f, -0.30319619f, 
    -0.21413766f, 0.41407996f, -0.18151116f, -0.10164516f, -0.08013210f, -0.27743742f, -0.18051158f, -0.05824100f, 
    -0.02890271f, -0.16031788f, 0.01003703f, -0.20284629f, -0.37816817f, -0.41720438f, -0.29575568f, -0.32525760f, 
    -0.95406628f, 0.01946587f, 0.35286063f, 0.71626234f, 0.30808645f, -0.79878980f, -0.52990675f, -0.07288396f, 
    0.62850296f, 0.37097368f, 0.10967366f, -0.29094225f, -0.13751413f, 0.61002725f, 0.08244674f, -0.02194619f, 
    0.07429593f, 0.11037179f, -0.21289796f, -0.19353791f, -0.07490142f, -0.06670706f, 0.10217938f, -0.00720834f, 
    0.02241723f, -0.66283613f, -0.55370080f, -0.29812503f, -0.06014413f, -0.21761312f, -0.06197535f, -0.49625438f, 
    -0.50514483f, -0.12354912f, 0.12147570f, -0.28539234f, -0.26790565f, -0.35380989f, -0.50938630f, -0.27577612f, 
    -0.04253072f, -0.03016645f, -0.37593693f, 0.03552463f, -0.01513712f, -0.05309830f, -0.12277880f, -0.21659303f, 
    0.10442029f, 0.06809007f, 0.89428735f, -0.70438433f, -0.19856608f, 0.11121322f, 0.27544677f, 0.30883539f, 
    0.43493465f, 0.02925379f, -0.11674428f, -0.11225650f, -0.30952948f, -0.33615375f, 0.16098467f, -0.39937234f, 
    0.37820867f, 0.03435560f, 0.01239494f, 0.19265139f, -0.14578514f, -0.08078385f, -0.16362034f, -0.42162099f, 
    -0.40250045f, -0.39822242f, -0.27797961f, 0.07746661f, -0.30870879f, -0.21769896f, -0.21219623f, -0.48129281f, 
    -0.25574207f, -0.33128190f, 0.02071694f, -0.06644707f, -0.27510691f, -0.19137053f, -0.31848612f, 0.30087155f, 
    -0.41339606f, 0.33965951f, -0.23348211f, 0.02619797f, 0.00595474f, -0.05892366f, 0.00603803f, 0.10209759f, 
    0.32866752f, 0.31580976f, 0.30203533f, 0.37386629f, 0.42077053f, -0.17268637f, -0.14949620f, 0.05923754f, 
    0.24958533f, 0.51298457f, -0.33295637f, -0.01135892f, 0.17310411f, 0.49114299f, -0.11601926f, 0.16596548f, 
    0.01130183f, 0.13736552f, 0.26474112f, -0.09477241f, -0.12762921f, 0.27515012f, 0.16934305f, -0.31262442f, 
    0.10997158f, -0.07103891f, 0.30184078f, -0.11363098f, 0.02651287f, -0.18272460f, -0.59590846f, -0.55895561f, 
    -0.45997000f, -0.65636003f, 0.41904134f, -0.19032700f, -0.06335738f, 0.50248164f, 0.01021740f, 0.04234737f, 
    0.11382561f, -0.32711023f, 0.02259561f, -0.47457126f, -0.06582167f, 0.09028403f, -0.09349985f, 0.18087363f, 
    0.33557647f, -0.14631288f, 0.00237249f, -0.06569519f, -0.05280625f, -0.50645709f, -1.11750424f, 0.38634044f, 
    0.46942955f, -0.42603314f, -0.55490810f, -0.16424806f, 0.48099178f, 0.32387397f, 0.59009928f, 0.11203017f, 
    -0.24212328f, -0.14354573f, 0.29117700f, -0.26226985f, -0.12013931f, 0.00554641f, -0.31100965f, -0.21307498f, 
    0.24252930f, 0.35792440f, 0.01085441f, -0.04281325f, 0.06995925f, -0.18655731f, 0.19356894f, 0.07017753f, 
    0.52090222f, 0.68886894f, -0.11360619f, 0.29680327f, -0.60406590f, -0.08362134f, -0.02757674f, -0.13072401f, 
    -0.25889587f, -0.20639016f, 0.16661999f, 0.08108268f, -0.21988888f, 0.13141248f, -0.09977695f, -0.40154004f, 
    -0.00811181f, 0.21840425f, 0.24230759f, -0.02273055f, 0.15939154f, -0.10194485f, -0.01407597f, -0.00412321f, 
    0.29035288f, 0.61508858f, -0.10027943f, 0.27055845f, 0.09374494f, -0.38540190f, -0.37619719f, 0.17576022f, 
    -0.17686844f, -0.27501792f, -0.03934019f, 0.18284406f, -0.13179557f, -0.08282048f, -0.23101322f, 0.20338768f, 
    -0.11283634f, -0.35400701f, 0.21448924f, 0.03734001f, -0.28929356f, 0.13857953f, -0.12476297f, 0.12380602f, 
    -0.25984460f, -0.11225095f, 0.16754055f, 0.36521307f, 0.34039420f, 0.32721740f, 0.31982797f, 0.38949245f, 
    0.14742120f, 0.33193436f, 0.29876047f, 0.03369625f, -0.31902972f, 0.02061990f, 0.09124972f, -0.24149933f, 
    0.18408442f, -0.09397769f, -0.24256754f, -0.19850641f, -0.23236835f, 0.07416317f, 0.24677892f, -0.12772492f, 
    -0.22464612f, -0.27388406f, -0.03283486f, -0.03162028f, 0.13873503f, 0.12922908f, 0.04390351f, 0.21324420f, 
    -0.22170667f, 0.10189184f, 0.32403666f, 0.35409099f, 0.03921511f, 0.18750007f, -0.43431458f, 0.06785691f, 
    0.46773216f, -0.15347321f, 0.10016772f, -0.51246083f, 0.05317153f, 0.21597889f, 0.27942899f, 0.18708670f, 
    -0.16250212f, 0.33340400f, -0.06023486f, -0.29743838f, -0.16217694f, -0.46146378f, -0.06468324f, 0.67727220f, 
    0.16380477f, -0.19618008f, -0.69168627f, -0.67291135f, -0.81325197f, 0.11791990f, 0.34614366f, 0.32016173f, 
    -0.39533371f, -0.23495275f, -0.17803791f, -0.22426544f, 0.06735905f, 0.01372441f, 0.30697867f, 0.10850397f, 
    0.12354307f, -0.15099010f, 0.11780128f, -0.31359366f, 0.21763600f, 0.63393325f, 0.29439300f, -0.30590752f, 
    0.11956751f, -0.61438859f, -0.52083963f, -0.20161985f, -0.19469406f, -0.57930511f, -0.10270672f, -0.07129908f, 
    -0.03424165f, 0.33833298f, 0.22828096f, 0.02346863f, 0.13087755f, -0.11424241f, -0.23717530f, 0.28632370f, 
    0.03373990f, 0.12893730f, 0.00022571f, -0.06431379f, -0.02382133f, -0.35029614f, 0.00557116f, -0.39773512f, 
    0.24420625f, -0.19523838f, 0.64877778f, -0.50268823f, -0.40712968f, 0.32425806f, 0.50176018f, 0.04640916f, 
    -0.11561604f, -0.13971251f, 0.42009723f, 0.07739521f, -0.14737885f, 0.18925193f, 0.23779404f, -0.34747404f, 
    -0.39359984f, 0.08149849f, -0.11322819f, -0.20295331f, 0.32631063f, 0.01994642f, 0.85357225f, 0.60514623f, 
    -0.04664562f, -0.07058705f, -0.34426045f, 0.14287861f, -0.19217539f, -0.10766488f, -0.33922642f, -0.46925706f, 
    -0.00057005f, 0.25059134f, -0.10291750f, 0.16059014f, 0.07235478f, -0.05664155f, -0.08411168f, 0.39890665f, 
    0.03838895f, -0.11963726f, -0.04784875f, 0.13856642f, 0.17371021f, -0.00138227f, -0.05040346f, 0.60142118f, 
    0.45614061f, 0.31643564f, 0.26889169f, 0.33001685f, 0.14868583f, -0.10699963f, 0.06104851f, -0.11635911f, 
    0.06667284f, -0.11241929f, -0.09049485f, -0.12867722f, -0.22871985f, -0.12528510f, 0.24256997f, 0.19073747f, 
    0.05191924f, -0.07316227f, -0.10407243f, -0.01126487f, -0.07418815f, 0.01550892f, 0.10540229f, -0.06258038f, 
    0.10432278f, -0.18323185f, -0.43407980f, -0.14414351f, -0.30375251f, -0.51430660f, -0.41592166f, -0.34008875f, 
    -0.36257908f, -0.62720215f, 0.22894070f, 0.50342959f, 0.25846559f, 0.15275709f, -0.07463130f, -0.18518187f, 
    0.05450439f, -0.09325846f, 0.02881135f, -0.00710151f, -0.34492201f, -0.13769528f, 0.06886382f, -0.14635578f, 
    0.04696433f, -0.59277838f, -0.19129401f, 0.00289764f, 0.31051943f, 0.14665112f, -0.26250187f, 0.33759421f, 
    0.23951524f, -0.05124848f, -0.18232509f, -0.12693328f, 0.11439712f, 0.07437699f, -0.12465327f, -0.07898059f, 
    -0.03509307f, 0.05667308f, -0.24128245f, -0.22286883f, 0.02158193f, 0.25882801f, 0.14406496f, 0.24444467f, 
    0.29549047f, -0.12757561f, 0.02362123f, -0.31052601f, -0.24900079f, -0.51360494f, -0.47995690f, -0.29299983f, 
    -0.46218199f, -0.05184339f, -0.03198974f, -0.11228687f, -0.03514862f, -0.24149990f, 0.37037036f, 0.22489955f, 
    0.04126226f, -0.02523268f, -0.07013551f, -0.17857300f, -0.25128350f, -0.35876831f, -0.30500096f, -0.21719959f, 
    -0.03007402f, -0.15867531f, -0.27154559f, 0.21692419f, 0.52645260f, -0.05018311f, 0.06000315f, 0.10156534f, 
    -0.16901192f, -0.31309962f, -0.07191923f, -0.08904202f, 0.33687654f, 0.12178079f, -0.32701144f, 0.01338661f, 
    -0.14139652f, -0.41531688f, 0.22298111f, 0.16854940f, -0.14573823f, 0.23160820f, -0.25164488f, -0.23073085f, 
    0.09119715f, 0.14037290f, 0.08835939f, 0.20788266f, -0.21709721f, -0.11372269f, -0.40537730f, 0.20544238f, 
    0.48075756f, -0.28212017f, 0.03422439f, 0.37275821f, 0.38894030f, 0.07557075f, -0.50345773f, -0.52705896f, 
    0.05209442f, 0.43584734f, -0.36890370f, 0.16190529f, -0.08712760f, 0.21177000f, 0.18370977f, -0.06044914f, 
    -0.19211376f, -0.26018840f, -0.06917400f, -0.09968339f, -0.27809343f, -0.43841308f, -0.24386863f, 0.01265558f, 
    -0.04287709f, -0.52835786f, -0.45040742f, -0.41993332f, -0.16731983f, -0.26571593f, -0.71072209f, 0.24332397f, 
    -0.08395701f, -0.22776246f, 0.21759272f, -0.10789856f, -0.03942905f, 0.18658738f, -0.37626645f, -0.57188046f, 
    -0.69821060f, -0.05205563f, -0.04635383f, 0.17146099f, -0.27096415f, 0.11131717f, -0.39907250f, -0.67564362f, 
    0.24551125f, 0.38006151f, 0.15000252f, 0.22509708f, 0.98315018f, -0.71821499f, -0.64687085f, 0.31776097f, 
    -0.23819633f, -0.20396963f, -0.08772616f, -0.11612117f, -0.07014544f, 0.01665818f, -0.21389909f, -0.15225062f, 
    0.30365923f, 0.12240735f, -0.00007949f, -0.12075430f, -0.15120915f, 0.08769085f, -0.08351389f, -0.49621561f, 
    0.20897953f, -0.11494296f, 0.07359663f, 0.53028744f, 0.44721225f, 0.27865794f, 0.12480166f, -0.26624256f, 
    -0.13089861f, 0.02642698f, -0.25044882f, -0.38459647f, 0.14730182f, 0.45049423f, -0.28964895f, -0.13479254f, 
    0.06696556f, -0.27784127f, 0.18932594f, -0.17416227f, -0.07935919f, 0.28284675f, -0.02301255f, -0.15857567f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.36393300f, 0.07456927f, 0.26388398f, 0.33758938f, 0.20639123f, 0.36207849f, 0.19508545f, 0.04055333f, 
    0.28252220f, 0.12960327f, 0.03886572f, 0.01875816f, 0.11096839f, 0.08881665f, 0.21686594f, 0.19691400f, 
    0.14486916f, -0.11557385f, 0.20635882f, 0.08734358f, 0.11559273f, 0.37563947f, 0.28278607f, -0.17158030f, 
    -0.19105272f, 0.25587854f, 0.08018077f, 0.22979760f, 0.03730983f, 0.20793919f, 0.08914352f, 0.27018872f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.35902333f, 0.01124131f, 0.23322393f, 0.25298294f, 0.00222221f, 0.05499530f, 0.11779834f, 0.02554676f, 
    -0.04792661f, 0.12032232f, 0.17597072f, 0.11970965f, 0.00538181f, -0.23729537f, -0.11475565f, -0.08176452f, 
    0.10517322f, -0.02629993f, 0.06061754f, 0.10166901f, 0.05357284f, 0.12317279f, -0.07914351f, -0.08075482f, 
    -0.05947778f, 0.00153140f, -0.24977690f, -0.01430001f, 0.04635264f, -0.02827635f, 0.04893000f, 0.03259267f, 
    -0.02234967f, -0.05820410f, -0.00880932f, -0.00967098f, -0.24736972f, 0.24940771f, -0.10890142f, 0.08247701f, 
    -0.02727814f, -0.06617726f, -0.06086912f, -0.01144187f, -0.04931127f, 0.10745379f, 0.00617838f, 0.13597709f, 
    0.00038990f, 0.17730020f, 0.00919221f, 0.08634722f, 0.07323867f, 0.05555320f, 0.02196036f, -0.06376168f, 
    -0.12377188f, 0.06237829f, 0.02211132f, 0.15072660f, -0.09172384f, 0.22591287f, 0.00306648f, 0.11219152f, 
    0.07067776f, -0.05330303f, 0.07798389f, -0.01365407f, 0.03762667f, 0.00165080f, 0.26264694f, -0.01337017f, 
    -0.16520128f, -0.06751989f, 0.17848764f, 0.24260162f, 0.05679880f, 0.12916425f, 0.15797640f, -0.03793351f, 
    -0.06912664f, 0.06257385f, -0.02043542f, -0.03035064f, -0.25045380f, 0.11969323f, 0.13959774f, -0.02428049f, 
    -0.09562245f, -0.00297813f, -0.03149231f, -0.08045752f, 0.15176769f, 0.00450614f, 0.24738829f, 0.17266051f, 
    0.54603964f, 0.31404632f, -0.07496353f, -0.14365666f, 0.17845142f, -0.01039539f, 0.02593812f, 0.05706837f, 
    0.13413665f, -0.00010514f, 0.27031830f, 0.10059296f, 0.08816241f, 0.07632869f, -0.06381476f, -0.11500829f, 
    0.13901339f, -0.04811167f, 0.08042044f, -0.01316644f, -0.01372609f, 0.02350850f, 0.03395869f, -0.11698600f, 
    -0.24356900f, 0.21756138f, -0.23117074f, 0.11816092f, 0.07950054f, 0.15523112f, 0.09982774f, 0.02725439f, 
    0.06837322f, 0.16396968f, 0.07316605f, -0.01445597f, -0.03923821f, -0.15978651f, -0.10828392f, 0.03022463f, 
    -0.08049981f, -0.01245527f, -0.04755047f, -0.06635062f, -0.01724458f, -0.06786249f, -0.11481339f, -0.07009369f, 
    -0.07790948f, -0.01244072f, -0.15252462f, 0.02992321f, 0.00057218f, 0.02815979f, -0.08728075f, -0.01785053f, 
    -0.00760113f, 0.01058957f, -0.04944462f, 0.04259454f, 0.11039070f, 0.03634259f, 0.02172558f, 0.10970348f, 
    0.01700108f, 0.04681659f, 0.16262615f, 0.04364049f, 0.05270849f, 0.02585709f, 0.07248700f, 0.07202461f, 
    0.49039501f, 0.14419967f, 0.20446390f, -0.00239222f, 0.03812720f, 0.04659174f, 0.04314024f, -0.01553284f, 
    0.00961766f, -0.01297721f, 0.11722799f, -0.01808406f, 0.30814466f, 0.18123914f, 0.32197151f, -0.20766290f, 
    -0.10615654f, -0.01837340f, -0.11616757f, -0.04179305f, -0.09376231f, -0.06031786f, -0.03228341f, 0.06984112f, 
    -0.00101674f, 0.13219450f, 0.15903790f, 0.04610447f, 0.00584351f, -0.02742134f, -0.09242871f, 0.09059034f, 
    0.00355428f, -0.02307200f, 0.05704671f, 0.16651790f, -0.27919030f, 0.06789944f, -0.06895217f, -0.16342418f, 
    0.00764024f, 0.03207694f, 0.02909154f, -0.01181541f, 0.03915401f, -0.05418653f, 0.14575168f, 0.01245864f, 
    -0.11491478f, 0.04861487f, -0.03405555f, -0.02721570f, -0.07070093f, -0.04431204f, -0.04815271f, -0.09199342f, 
    0.00446169f, -0.12377987f, -0.02701695f, 0.06343757f, 0.08742954f, 0.11879339f, -0.21892557f, 0.10025779f, 
    -0.07749101f, 0.03425086f, -0.02688803f, 0.06524771f, 0.00215162f, -0.02098974f, -0.02964321f, -0.03989853f, 
    0.03895633f, -0.21118492f, 0.33633709f, -0.28215340f, 0.12135724f, -0.02700017f, -0.01178637f, 0.03723814f, 
    0.09701254f, -0.00152725f, 0.01779536f, 0.00605136f, 0.13626380f, -0.15192233f, 0.16041283f, 0.13021581f, 
    0.22368328f, -0.00189007f, -0.01415023f, 0.10558709f, 0.04394968f, 0.10509957f, 0.06066586f, 0.08752242f, 
    -0.35751909f, -0.13810961f, 0.27816537f, -0.07761986f, -0.01368753f, -0.04023303f, -0.18268155f, -0.01153038f, 
    -0.06670649f, 0.06056227f, -0.07063629f, 0.08099765f, -0.22034688f, 0.06321564f, 0.06512799f, -0.14308360f, 
    -0.11841656f, -0.13156073f, -0.18797812f, -0.04730247f, -0.20653935f, 0.04624003f, -0.06295727f, -0.06293534f, 
    -0.07927366f, -0.27551207f, -0.20051402f, -0.04032722f, -0.00405848f, 0.04838805f, -0.01422997f, -0.00308802f, 
    0.07994761f, 0.09040083f, 0.01087450f, 0.00791653f, 0.00993037f, 0.08388893f, -0.07409751f, -0.04602709f, 
    0.00068283f, 0.10258039f, -0.06531667f, 0.02825711f, -0.00688244f, 0.01646937f, -0.13700698f, -0.02724216f, 
    -0.03925360f, -0.15214831f, -0.03503789f, -0.08394454f, -0.03307137f, 0.00911527f, 0.05505248f, 0.02171627f, 
    0.03613987f, 0.09336667f, -0.02224819f, 0.02279176f, -0.11673842f, 0.12576911f, 0.26686847f, 0.04064850f, 
    -0.10942080f, -0.05281817f, -0.12093102f, -0.09012216f, -0.18971568f, -0.10771146f, 0.09621292f, -0.08369262f, 
    0.38733575f, 0.03908491f, -0.18835858f, 0.12372694f, 0.03257763f, -0.00874110f, 0.09920693f, 0.03487350f, 
    0.10248997f, 0.12419533f, 0.19886418f, 0.09449035f, 0.02862930f, -0.18869668f, -0.05004727f, -0.19451524f, 
    -0.04265954f, -0.02061085f, -0.06917622f, 0.08237411f, 0.02290248f, 0.10491972f, -0.04176905f, -0.00188142f, 
    0.11391095f, 0.34928119f, -0.16682298f, 0.17801072f, 0.03455034f, -0.02021541f, 0.04187898f, 0.10507287f, 
    0.07528497f, -0.09725756f, 0.12904419f, 0.01809921f, 0.02426596f, 0.05629634f, -0.12999061f, -0.16013716f, 
    0.04910798f, 0.11163029f, 0.09514114f, 0.09311655f, -0.06511018f, 0.02545914f, -0.01522641f, 0.17072745f, 
    0.01834021f, -0.02047287f, 0.02534438f, -0.04222100f, 0.04141581f, -0.03255094f, 0.00839277f, 0.00499752f, 
    -0.02897377f, 0.02009240f, -0.01839829f, -0.02737935f, -0.04962959f, -0.01034611f, 0.00080721f, -0.04240698f, 
    0.02149935f, 0.01224949f, -0.01370905f, -0.00748342f, 0.02509857f, -0.04551188f, 0.01979849f, -0.00556098f, 
    -0.00152960f, -0.00871199f, -0.01321213f, 0.04297603f, 0.02596024f, 0.00855077f, 0.04962831f, -0.01679636f, 
    0.00537167f, -0.04373068f, -0.04252908f, 0.04274844f, 0.03333369f, -0.01263589f, 0.01411572f, -0.04489596f, 
    -0.00016776f, 0.01790053f, -0.02600681f, 0.03507721f, -0.00822031f, -0.05119440f, 0.04121443f, -0.03024373f, 
    0.03963358f, 0.00496371f, 0.01861096f, -0.01866995f, 0.00269251f, -0.03347911f, -0.00674931f, -0.01341757f, 
    -0.03463961f, -0.00257775f, 0.04046041f, 0.03920509f, -0.00171420f, -0.04733977f, -0.01000304f, 0.02376224f, 
    0.03547719f, -0.02763769f, -0.04578914f, -0.03517161f, -0.00671009f, -0.00682010f, -0.04859117f, 0.00557326f, 
    0.02857105f, 0.03773974f, -0.00461136f, -0.03037368f, 0.03338799f, -0.03915281f, 0.00962762f, -0.01468302f, 
    0.00289378f, -0.01530686f, -0.00446789f, 0.02461991f, -0.03101258f, -0.02458984f, -0.05204104f, -0.00300446f, 
    0.03624985f, -0.05084541f, -0.04727240f, 0.03500998f, 0.02144454f, 0.01815704f, 0.02342431f, -0.02255774f, 
    -0.00693600f, -0.03461314f, 0.02120566f, 0.02273820f, -0.02515810f, -0.00004486f, -0.05280134f, 0.00128679f, 
    -0.03260614f, -0.02611217f, -0.02695134f, -0.01888405f, -0.04146174f, 0.01026857f, 0.02305996f, 0.01881816f, 
    -0.04310236f, -0.03051924f, -0.02742412f, -0.03609683f, -0.01815149f, 0.00401731f, 0.01130542f, 0.02277572f, 
    0.03258752f, -0.03837203f, 0.00437091f, -0.03768321f, 0.03317279f, -0.03028871f, -0.01844825f, -0.02065084f, 
    -0.04719979f, -0.05342757f, -0.02814927f, -0.04707292f, 0.00603655f, -0.03932459f, -0.02397591f, -0.00401973f, 
    -0.04465108f, -0.03268303f, -0.01147639f, -0.00232791f, -0.02833030f, 0.03674917f, 0.03219554f, -0.03970670f, 
    -0.01089354f, 0.03164045f, -0.03260207f, -0.02482513f, 0.00280079f, -0.04278749f, -0.05433094f, 0.02917540f, 
    -0.04234090f, -0.03305013f, -0.01530669f, 0.03138420f, 0.00477275f, -0.06387599f, -0.04243360f, -0.02153954f, 
    -0.05217807f, -0.01442751f, 0.01168837f, 0.00527811f, 0.02324717f, -0.04666360f, 0.02530340f, -0.05252754f, 
    0.01624332f, -0.00669292f, 0.03273628f, 0.04332593f, -0.03682509f, -0.06087684f, 0.01460447f, -0.03829980f, 
    0.01121419f, -0.02213943f, 0.03485312f, -0.03305777f, 0.02439555f, 0.02671324f, 0.04248816f, 0.00619789f, 
    -0.03723267f, 0.01456551f, 0.03875290f, 0.00524429f, -0.05614791f, 0.01597525f, 0.02696963f, 0.01323866f, 
    -0.01429856f, 0.00820788f, 0.01358123f, 0.04404761f, -0.02642380f, 0.04459655f, 0.01066569f, -0.06118169f, 
    -0.06555298f, -0.01876523f, -0.05795642f, -0.00898222f, -0.00003975f, 0.03738438f, -0.03855513f, 0.02042397f, 
    -0.00039543f, 0.01757967f, 0.01908111f, 0.00348526f, 0.01761953f, 0.03213051f, 0.01748887f, -0.01716896f, 
    -0.04264486f, -0.01916879f, 0.01447288f, -0.04781010f, -0.04360194f, 0.01225538f, 0.03173408f, -0.00931544f, 
    -0.00516672f, 0.03452080f, -0.02433897f, -0.04700398f, -0.04322737f, -0.02413746f, -0.05899812f, -0.04493567f, 
    -0.01612920f, 0.01261922f, 0.03542261f, -0.04454484f, 0.03439936f, 0.01395112f, -0.01391633f, -0.04638442f, 
    0.00546460f, 0.01455734f, 0.03623266f, -0.00838571f, 0.04964558f, -0.02877088f, 0.00151511f, 0.01368649f, 
    0.02338181f, 0.04236600f, -0.04853718f, -0.03953697f, 0.02018402f, 0.03038448f, 0.04936870f, -0.03298321f, 
    -0.00537450f, -0.01524003f, 0.03821278f, -0.03836312f, -0.00955293f, -0.02006894f, -0.04614182f, 0.03436165f, 
    -0.05292135f, -0.01069668f, 0.01704709f, -0.01140952f, -0.01466291f, 0.04360331f, 0.00691054f, -0.03270010f, 
    -0.03422025f, 0.01740979f, -0.00273569f, -0.02861337f, -0.03410503f, -0.04522871f, -0.00923201f, 0.00218878f, 
    -0.00842638f, 0.04054553f, 0.00089371f, 0.01716700f, 0.02339897f, -0.03602269f, 0.03083866f, 0.01534250f, 
    -0.00639804f, -0.04289313f, 0.00706315f, -0.03415336f, 0.02103610f, -0.04613531f, -0.03054117f, 0.04071593f, 
    0.03056228f, -0.00489215f, 0.00898122f, 0.03311899f, 0.01453059f, 0.04184571f, -0.03693997f, -0.02987002f, 
    0.01341093f, -0.02801653f, -0.02256330f, -0.00587920f, -0.04416046f, -0.03012156f, -0.03506395f, -0.05349099f, 
    0.03025610f, -0.03288103f, 0.00014235f, -0.04164343f, 0.00868219f, -0.00310300f, -0.04548903f, -0.05154211f, 
    0.00937338f, -0.00474821f, -0.01036780f, -0.04955561f, 0.02086119f, -0.02054049f, 0.03589031f, -0.02781033f, 
    -0.04139560f, 0.02121445f, 0.02757816f, -0.00186443f, -0.04703929f, -0.04975941f, -0.02556299f, -0.00268205f, 
    -0.04760939f, 0.03514296f, -0.00400031f, 0.04531586f, -0.05356616f, 0.02795695f, -0.04473212f, -0.04251028f, 
    -0.01976595f, -0.01256669f, 0.02510469f, -0.05065345f, 0.00378888f, 0.02239158f, -0.04423722f, -0.00974671f, 
    -0.01808447f, -0.00646862f, -0.02022612f, -0.02029012f, 0.00757063f, -0.01480585f, 0.03326768f, -0.04150344f, 
    0.00726406f, -0.02141969f, -0.04161950f, -0.04623018f, 0.04050121f, 0.03051328f, 0.00707802f, 0.00493430f, 
    0.01747180f, -0.02825214f, -0.00546800f, -0.03081975f, 0.02351131f, -0.00334938f, -0.04739702f, -0.02065723f, 
    -0.00929878f, 0.04047045f, 0.03929903f, -0.01817833f, 0.00213818f, -0.03601896f, 0.03638475f, 0.00580786f, 
    0.43486199f, 0.29809260f, -0.00629957f, -0.16248770f, -0.00910174f, -0.02263758f, 0.18499146f, 0.11279199f, 
    0.11454868f, 0.14798263f, 0.15617147f, -0.06441497f, -0.28995645f, -0.10050803f, -0.03053793f, -0.18832387f, 
    0.12596589f, -0.13975707f, 0.13761985f, 0.05431785f, -0.02171809f, -0.04040421f, 0.05725589f, 0.03662793f, 
    -0.34563008f, -0.19078200f, 0.10690638f, 0.10023469f, -0.02614427f, 0.20175417f, 0.17004968f, 0.04564422f, 
    -0.07539640f, -0.01390053f, 0.07113221f, -0.02646789f, 0.02079079f, 0.04024618f, 0.02912743f, 0.06180242f, 
    -0.02123064f, 0.00412252f, -0.01044134f, 0.04937128f, 0.03414313f, 0.02541736f, -0.01499146f, 0.12318715f, 
    0.12118673f, 0.06365918f, -0.05011790f, -0.06988581f, -0.00292341f, -0.01204095f, 0.01691441f, 0.04701582f, 
    0.16355051f, 0.11449098f, 0.01126236f, 0.07316715f, -0.05149098f, 0.08337289f, 0.05036874f, 0.02739055f, 
    0.01507542f, 0.08350181f, 0.10308249f, 0.04535106f, 0.10830022f, 0.05864925f, 0.14041519f, 0.05252364f, 
    -0.01346136f, -0.01809718f, 0.01708781f, -0.16459933f, -0.00963686f, -0.08699179f, -0.03645726f, -0.02537951f, 
    -0.04064651f, 0.08135299f, 0.06427274f, -0.00443858f, 0.10124457f, 0.04307764f, 0.23893581f, -0.12003835f, 
    0.03077848f, 0.07715843f, 0.11937396f, -0.00725913f, -0.03674245f, -0.01945006f, 0.03523752f, -0.09552924f, 
    -0.20775366f, 0.10696682f, -0.15111741f, 0.16570844f, 0.16076800f, -0.00492386f, 0.07842933f, 0.13164212f, 
    -0.00866045f, 0.05459410f, 0.03549584f, -0.04459932f, -0.02538096f, 0.01458208f, 0.00768191f, 0.15262815f, 
    0.03306716f, -0.00402311f, -0.01715461f, 0.01743931f, 0.07067169f, -0.01122261f, 0.05434698f, -0.04183746f, 
    0.15259609f, 0.13571791f, 0.04409214f, 0.13157518f, 0.05195315f, -0.00183571f, -0.07430628f, -0.01333201f, 
    -0.00787930f, -0.14491634f, 0.05363592f, 0.01595250f, -0.14570922f, -0.01066440f, -0.02229191f, -0.08188424f, 
    -0.02002331f, -0.05830755f, -0.00590672f, 0.00250531f, -0.02374034f, 0.00060142f, 0.02341917f, -0.07020707f, 
    0.10763881f, 0.12921730f, -0.05406775f, 0.05452421f, -0.02199008f, -0.03814106f, -0.02044440f, -0.00130817f, 
    -0.02142072f, 0.19483133f, 0.04171618f, -0.04897271f, -0.09574647f, 0.14162391f, -0.00707738f, -0.06568622f, 
    -0.07920533f, 0.04673379f, 0.09578441f, 0.00695270f, 0.02429616f, -0.05072074f, 0.02868102f, 0.00203729f, 
    -0.19275728f, 0.11824514f, -0.01605886f, 0.05833155f, -0.01640780f, 0.14619565f, -0.04499356f, -0.16674478f, 
    0.11918062f, 0.07238759f, 0.02768910f, 0.16393256f, 0.20935716f, -0.04082438f, -0.17624351f, -0.25617510f, 
    -0.10149189f, -0.08522219f, 0.01398929f, -0.06683555f, -0.07801982f, 0.00897513f, -0.01613155f, 0.00840622f, 
    0.26941133f, -0.16220632f, -0.08238224f, -0.31125239f, 0.03115808f, -0.01791023f, 0.05044303f, 0.11063581f, 
    -0.10481022f, 0.02594027f, 0.04081628f, 0.02968671f, 0.24504924f, 0.13630483f, 0.11746804f, 0.02949916f, 
    -0.09912840f, -0.06093267f, -0.11579909f, -0.05007228f, -0.06717212f, -0.01600503f, 0.07708181f, -0.04221481f, 
    -0.03521119f, 0.06099049f, -0.00336062f, 0.00615647f, 0.00463448f, -0.00583884f, -0.02398118f, -0.08650375f, 
    0.12443621f, 0.05216048f, 0.11209252f, 0.01857100f, -0.27399996f, -0.12134989f, -0.01466953f, 0.19626406f, 
    0.03936786f, 0.03294336f, 0.02252098f, -0.07161668f, -0.06955040f, 0.04312592f, -0.04958431f, 0.03907692f, 
    0.06843686f, -0.15853079f, -0.15863007f, -0.22971980f, -0.01481564f, -0.04360078f, 0.03362555f, -0.08309960f, 
    -0.09739839f, 0.00770777f, -0.01939185f, 0.09024439f, 0.04632820f, 0.13357395f, 0.14627346f, -0.02151233f, 
    -0.00920226f, -0.03172776f, 0.09940409f, 0.05889419f, 0.13320301f, 0.14574318f, 0.13355604f, -0.04166045f, 
    0.28340229f, 0.03453153f, 0.01297088f, -0.05733154f, -0.03455896f, 0.01162769f, 0.04549256f, 0.04851225f, 
    0.01849907f, 0.01180365f, -0.09364932f, 0.03612053f, 0.13642506f, 0.04514993f, -0.08836620f, -0.02602947f, 
    -0.07769393f, -0.00004404f, -0.05262098f, -0.12810670f, -0.08121018f, -0.04869431f, -0.10512637f, -0.04313759f, 
    -0.31689271f, -0.07374498f, -0.12870491f, -0.01476065f, -0.03790645f, -0.02885875f, -0.05396073f, -0.13907182f, 
    -0.04953898f, -0.19320619f, -0.07347467f, 0.12993924f, -0.13086437f, 0.03409718f, -0.02736345f, 0.03389755f, 
    0.03814871f, 0.05300602f, 0.02895765f, 0.03436995f, 0.09340857f, 0.13633703f, 0.16498488f, 0.03253868f, 
    -0.07028257f, -0.01855896f, -0.02803205f, 0.01672524f, 0.06871204f, 0.05854347f, 0.10493034f, 0.02883078f, 
    0.09790144f, -0.03387110f, -0.02868593f, -0.00413505f, 0.08605833f, 0.05007600f, 0.01815918f, -0.12296490f, 
    0.01408239f, 0.08308848f, 0.03135736f, 0.00182090f, -0.02152317f, 0.03685315f, -0.04308048f, 0.06012344f, 
    0.03305331f, 0.22738971f, -0.09095413f, 0.08126318f, 0.00812105f, -0.01874255f, -0.05061909f, -0.09170125f, 
    0.14691336f, 0.04821936f, 0.03170069f, -0.05106639f, -0.32985482f, -0.06241143f, -0.01984101f, 0.01036266f, 
    0.09610015f, 0.00184065f, 0.06906683f, -0.01408894f, 0.03079354f, 0.04776050f, -0.00592140f, -0.02345390f, 
    -0.00888452f, -0.27082461f, 0.02109980f, 0.11197016f, 0.12578203f, 0.01554269f, -0.04486294f, 0.18265250f, 
    0.20339124f, 0.05044559f, 0.25006109f, 0.04207706f, -0.03294114f, 0.00997066f, 0.15451209f, 0.09979118f, 
    0.09824342f, 0.01440207f, -0.06745283f, 0.02593613f, 0.12760451f, 0.05835947f, 0.22181636f, 0.03520228f, 
    -0.10004782f, -0.26295611f, 0.03096429f, -0.19997655f, -0.08927770f, -0.00745121f, -0.04482102f, 0.07141507f, 
    -0.15007418f, -0.10741024f, 0.06861455f, 0.06658256f, 0.18327810f, 0.11079121f, 0.09612922f, 0.06188247f, 
    -0.05009396f, -0.00149090f, -0.00395655f, 0.14675912f, -0.03026479f, -0.05414233f, -0.34394133f, -0.20784715f, 
    0.25407338f, 0.16983786f, 0.22219746f, 0.00950238f, 0.04632752f, -0.07804412f, -0.10630839f, -0.02477711f, 
    0.12051623f, 0.08944520f, 0.08077007f, 0.09912479f, -0.04042953f, -0.11146124f, 0.02225398f, -0.04574764f, 
    -0.01894068f, 0.07124101f, -0.10665866f, -0.11895031f, -0.17312206f, -0.08473428f, 0.04275202f, -0.24884175f, 
    0.04369985f, -0.12290321f, 0.12011778f, 0.02097304f, -0.00259560f, -0.08633072f, 0.08588732f, 0.03086046f, 
    -0.11957127f, 0.08733919f, 0.18326904f, -0.09814838f, -0.02789168f, -0.27980882f, 0.01477086f, -0.10470857f, 
    0.07376025f, -0.05358600f, 0.05782197f, -0.01152219f, -0.04533832f, 0.04552229f, -0.12275761f, 0.01200860f, 
    -0.13786185f, 0.08467002f, -0.18910219f, -0.15730861f, -0.03619513f, -0.05233384f, -0.14682689f, -0.02358339f, 
    0.00886824f, 0.01431185f, -0.02329793f, 0.06337509f, -0.03219079f, -0.11286533f, -0.02557177f, 0.25410852f, 
    0.05308221f, 0.04886693f, 0.13997267f, 0.13732970f, 0.09511753f, 0.12139966f, 0.12145679f, 0.23748671f, 
    -0.03723168f, -0.41163066f, 0.44566807f, 0.31345129f, 0.03904720f, 0.07199737f, -0.05834480f, -0.12991777f, 
    0.04122382f, 0.10507339f, 0.04939496f, 0.04153081f, 0.07011192f, 0.03053831f, 0.28461778f, -0.02700779f, 
    0.13661060f, 0.03450639f, -0.05816428f, -0.02556655f, 0.05251213f, 0.04581248f, 0.13531816f, 0.12223364f, 
    -0.23259071f, -0.35594448f, 0.03395230f, -0.18256564f, -0.02542955f, -0.09351531f, 0.16094881f, 0.06543498f, 
    0.00001446f, 0.27220744f, -0.00739608f, 0.18300517f, 0.26701635f, 0.01473421f, 0.04435958f, -0.09493151f, 
    0.09862372f, -0.01487614f, 0.05089093f, 0.06930910f, -0.02637592f, -0.11433730f, -0.12556091f, -0.19075091f, 
    0.11274972f, -0.28417718f, 0.09314921f, 0.01414670f, 0.00336197f, -0.07055947f, 0.00117993f, -0.09402183f, 
    0.18481149f, 0.05976763f, 0.02984102f, -0.04885047f, 0.15856968f, -0.14185272f, 0.10477753f, -0.11997343f, 
    0.03205866f, 0.06458469f, 0.04712279f, 0.12105526f, 0.06993603f, 0.10176605f, 0.15219621f, 0.23195173f, 
    -0.33420241f, -0.08363619f, -0.06603299f, -0.10818461f, 0.22389720f, -0.06718065f, -0.09538197f, 0.02610817f, 
    -0.01409694f, 0.00562205f, -0.05320835f, 0.14910558f, -0.07282940f, -0.09999347f, -0.04908688f, 0.03544234f, 
    0.08905402f, 0.14749886f, -0.00687455f, 0.00041723f, -0.00335557f, -0.10036584f, -0.16494332f, 0.04636573f, 
    0.37009376f, 0.17511564f, -0.11580312f, 0.15406784f, 0.03628466f, 0.14229815f, -0.11732236f, 0.05348631f, 
    0.11175663f, 0.01921164f, -0.04726959f, 0.04922014f, -0.01868660f, -0.02238922f, 0.00872768f, 0.21876231f, 
    0.01825878f, -0.00328951f, 0.06173928f, -0.06856262f, 0.19629535f, 0.09217919f, 0.03043660f, 0.11171214f, 
    0.03499893f, -0.05839548f, -0.04820024f, 0.04339228f, -0.00374805f, -0.02847813f, -0.00714022f, -0.08665787f, 
    0.05249178f, 0.04468217f, -0.14947501f, -0.11776786f, 0.17725554f, 0.20951138f, 0.27769199f, -0.16650768f, 
    -0.11782780f, 0.12972730f, 0.07246515f, 0.20458353f, 0.01433478f, 0.04800293f, -0.00424313f, -0.00362997f, 
    0.19529745f, 0.27964476f, 0.07979276f, 0.12237284f, 0.02891672f, 0.03623272f, -0.07921286f, 0.05091598f, 
    0.04599674f, -0.03517082f, -0.11658277f, -0.09940182f, 0.00014587f, -0.04124109f, -0.01674466f, 0.06041652f, 
    -0.14539403f, -0.12668122f, -0.17372243f, -0.03682791f, 0.00271147f, 0.05318455f, -0.03261625f, -0.10430641f, 
    0.15544644f, 0.23101988f, -0.25895202f, 0.09745108f, -0.03506991f, 0.13476840f, 0.01708949f, 0.03054101f, 
    -0.05375873f, -0.00342482f, 0.02664728f, -0.19014227f, 0.18059681f, -0.12104005f, -0.19773744f, 0.10534021f, 
    0.10643961f, 0.00814490f, 0.04312287f, 0.18513876f, 0.03563838f, 0.04341112f, 0.07470665f, -0.01203757f, 
    0.29658797f, 0.12791184f, 0.24135152f, 0.12859765f, 0.06160524f, -0.02760782f, 0.07643089f, 0.18300746f, 
    0.08341224f, 0.11389129f, 0.02357951f, -0.05615323f, 0.04281756f, 0.05898564f, -0.00553113f, 0.08398516f, 
    0.11776612f, -0.01557768f, -0.11955944f, 0.00253186f, -0.04114109f, -0.26587930f, -0.08940933f, -0.28837949f, 
    0.17614353f, 0.10810206f, 0.20911318f, -0.03929931f, 0.07106235f, -0.06724664f, 0.02890071f, 0.12554081f, 
    0.04170689f, 0.08748857f, 0.06309467f, 0.22396186f, 0.17501011f, -0.13195129f, -0.12599204f, 0.06928960f, 
    0.08255069f, -0.00368341f, -0.16089076f, 0.11392622f, -0.06455750f, -0.12448718f, -0.03588236f, -0.14587019f, 
    0.15712439f, -0.23818216f, -0.03032781f, 0.16398495f, 0.20358999f, -0.03171824f, 0.02262486f, 0.07359626f, 
    0.08951309f, 0.19101214f, 0.06850970f, 0.16903099f, 0.27610207f, 0.24620517f, 0.18894204f, 0.24995966f, 
    -0.01103333f, -0.02461855f, -0.03211638f, -0.03784478f, 0.09600981f, -0.05914780f, 0.05479774f, 0.10121007f, 
    -0.26802826f, 0.02808904f, -0.31094080f, 0.16153634f, 0.11466626f, -0.11326811f, -0.03009772f, -0.01345581f, 
    0.11543196f, 0.12544371f, -0.14783283f, 0.10637005f, -0.05312044f, -0.00362867f, -0.26474935f, 0.08870473f, 
    -0.09094449f, 0.04251003f, -0.11678884f, -0.24688739f, 0.07679439f, 0.04781467f, -0.06138380f, 0.13255678f, 
    0.24580579f, 0.38829336f, -0.02783271f, 0.00380203f, -0.02867960f, 0.00789085f, 0.00857354f, 0.01351481f, 
    0.09785173f, -0.04787738f, -0.31593671f, 0.00742060f, 0.14373350f, 0.03824044f, -0.04458060f, -0.01120970f, 
    -0.04953342f, 0.12269783f, 0.07382549f, 0.11706258f, -0.07461949f, -0.18925835f, 0.04721365f, 0.15461080f, 
    0.21408997f, 0.00321203f, 0.06181952f, 0.10955044f, 0.03193611f, 0.00759163f, -0.01326880f, 0.06713374f, 
    0.03488440f, 0.05912358f, 0.14304134f, 0.03697164f, 0.05101974f, -0.12182803f, -0.09682796f, 0.17344375f, 
    -0.03652031f, -0.06318294f, 0.04804960f, -0.01405338f, 0.13471326f, -0.08812519f, 0.07238504f, 0.04309270f, 
    -0.27627873f, -0.03300308f, 0.07601538f, -0.15373263f, -0.01118792f, -0.02489134f, 0.02114025f, -0.05818867f, 
    0.10535621f, -0.06000600f, -0.03310536f, 0.21550816f, -0.02971513f, 0.14111124f, 0.06619480f, 0.05155038f, 
    -0.06000144f, 0.02801174f, -0.16379003f, 0.16324808f, 0.08784347f, 0.07524130f, 0.05430289f, 0.07920106f, 
    0.07921512f, 0.17418855f, 0.20768926f, 0.12258847f, -0.10587586f, -0.19132431f, -0.07192297f, -0.00118725f, 
    0.09372709f, -0.04863394f, 0.02749274f, -0.05590996f, 0.18110655f, 0.17699817f, -0.06421508f, -0.13226978f, 
    0.03250286f, -0.08449330f, -0.03561743f, 0.08358131f, -0.13742742f, -0.11927740f, -0.10917453f, -0.03095662f, 
    -0.43119159f, 0.06308423f, 0.02972835f, 0.02211518f, 0.04320735f, -0.05291336f, 0.08407909f, 0.04966777f, 
    -0.03219404f, -0.00074104f, -0.24494585f, -0.04064840f, 0.08418711f, 0.17633750f, 0.08219612f, 0.08505756f, 
    0.04287086f, 0.20711841f, 0.03889779f, -0.01215107f, -0.01874355f, -0.01744991f, -0.15842406f, 0.02276944f, 
    0.08952146f, -0.15231091f, 0.04365332f, -0.07388746f, -0.01730983f, -0.08194756f, -0.18883835f, 0.01807744f, 
    0.02390737f, -0.05167762f, 0.05830242f, -0.06193905f, -0.12711884f, 0.13939154f, 0.14453480f, 0.14557607f, 
    0.00799108f, 0.22687994f, 0.09201111f, 0.01200654f, -0.04590071f, 0.01861256f, 0.14025272f, 0.06348210f, 
    -0.27345237f, 0.15761240f, -0.12280360f, -0.03081163f, -0.12732667f, -0.05961389f, -0.03711572f, 0.01829940f, 
    -0.04848491f, 0.02666064f, 0.11066379f, -0.05005136f, 0.03937740f, 0.37315944f, 0.01504070f, 0.07922849f, 
    0.04561185f, -0.02195274f, -0.00233746f, 0.01274031f, -0.01853418f, 0.04476042f, -0.07607175f, -0.08167552f, 
    0.06057169f, 0.03781692f, 0.11685197f, 0.00363885f, -0.11530983f, 0.04656411f, -0.07648223f, -0.07611513f, 
    0.05346404f, 0.11184230f, -0.15193835f, 0.04787083f, 0.13914736f, 0.02740656f, -0.01947145f, -0.06173817f, 
    -0.01131182f, -0.13922764f, -0.08705667f, 0.02599613f, -0.03315521f, 0.07687180f, -0.01513851f, -0.14727235f, 
    -0.05655776f, -0.22719491f, 0.03682271f, -0.03552276f, -0.09155147f, 0.01284434f, 0.06973372f, -0.02158983f, 
    -0.03462967f, -0.04895848f, -0.06730681f, -0.00555839f, -0.01853822f, -0.12443027f, -0.08691593f, -0.03107439f, 
    -0.11955895f, -0.12769552f, -0.09512256f, -0.07911045f, -0.05716013f, -0.01122580f, -0.06666490f, 0.06086087f, 
    -0.15730239f, -0.01201186f, -0.05672035f, 0.03795552f, 0.02310864f, -0.01036873f, -0.01362033f, -0.04834839f, 
    -0.02214385f, 0.03452899f, -0.11039037f, 0.11071324f, 0.17652948f, 0.05046692f, -0.19315341f, -0.08807110f, 
    0.08447158f, -0.18983622f, 0.13104521f, 0.11020748f, -0.00145442f, 0.05237983f, -0.01937575f, -0.03260355f, 
    -0.16089392f, 0.04678773f, -0.13784224f, 0.02719264f, 0.01841324f, 0.01941560f, -0.04127276f, 0.01877637f, 
    -0.03069124f, 0.10261298f, 0.02820016f, 0.04682045f, -0.11903355f, 0.24234964f, -0.10970335f, 0.09823356f, 
    0.06835912f, 0.09887376f, 0.09957977f, 0.00509497f, 0.03781623f, -0.08696327f, 0.14442506f, 0.06789504f, 
    -0.16473660f, -0.11315906f, -0.12568912f, -0.13024393f, 0.04459243f, -0.09429152f, -0.02865269f, 0.03000818f, 
    -0.03670078f, 0.04985875f, 0.10343610f, 0.01395903f, 0.00219002f, -0.09216541f, -0.01266118f, 0.10059999f, 
    -0.18010904f, -0.12473444f, -0.04841814f, -0.11138291f, 0.00438419f, -0.15726811f, -0.06392945f, 0.00398356f, 
    0.06618779f, 0.11848651f, 0.02245746f, -0.04004992f, -0.02765499f, -0.01851148f, 0.01576799f, -0.12166186f, 
    -0.00658773f, 0.00608837f, 0.15197454f, 0.03989332f, -0.01901694f, -0.15966730f, 0.06929059f, 0.00888897f, 
    0.05095655f, -0.01339428f, 0.13739666f, 0.01717493f, 0.07016351f, 0.01999746f, 0.08996993f, 0.08117940f, 
    0.10509282f, 0.14564209f, 0.21612804f, 0.12200008f, 0.14702201f, 0.03799477f, 0.03828558f, -0.01796150f, 
    0.05249367f, 0.03101453f, 0.06480609f, -0.07029562f, -0.13700545f, -0.06727074f, 0.04543602f, 0.01628662f, 
    0.04720853f, 0.06963511f, 0.12748235f, -0.05022688f, 0.12820908f, 0.01897249f, 0.00114324f, 0.09673186f, 
    -0.38417155f, -0.03407132f, 0.14934976f, -0.01560066f, -0.07487163f, -0.07627349f, -0.16843459f, -0.11942354f, 
    0.12995768f, -0.03180629f, 0.02911218f, -0.11597676f, -0.03687961f, 0.05652652f, 0.17141324f, 0.03916382f, 
    0.17083304f, 0.01068443f, 0.21653502f, 0.00355274f, -0.07560012f, -0.02683590f, -0.04911492f, 0.14898501f, 
    0.40073904f, 0.00307842f, 0.33804199f, -0.04663404f, 0.05857294f, -0.03336599f, -0.04929325f, 0.04017666f, 
    -0.00722301f, 0.21870500f, 0.01663635f, -0.07501390f, 0.01875746f, -0.01662683f, 0.02247794f, 0.02098375f, 
    -0.08535782f, -0.14271009f, 0.08649714f, 0.03919006f, 0.07713234f, 0.11618227f, -0.13807502f, -0.14766301f, 
    0.14285593f, 0.19933455f, 0.26028889f, -0.23212451f, -0.07128417f, 0.20206662f, -0.05857876f, 0.15453273f, 
    0.06977250f, 0.03649919f, -0.12491903f, 0.02436285f, -0.15030904f, 0.00135523f, -0.05039599f, -0.11830591f, 
    -0.00718360f, -0.07613555f, -0.01060823f, 0.07248140f, -0.05206500f, -0.05042697f, -0.08923519f, -0.02573607f, 
    -0.01955586f, -0.08756320f, 0.23234831f, 0.01963839f, -0.03786404f, -0.03233794f, -0.03358508f, 0.01365427f, 
    -0.03333372f, 0.08986321f, 0.04945003f, 0.02181637f, -0.04597450f, -0.09742305f, -0.04319463f, 0.13213032f, 
    -0.07298124f, -0.03804150f, -0.01888362f, 0.01258055f, 0.11332066f, 0.01825741f, 0.00856856f, -0.02777606f, 
    0.08850818f, 0.16128710f, -0.00021065f, 0.02977225f, 0.03335834f, 0.02240450f, 0.05634573f, -0.04171243f, 
    0.19756092f, 0.05504315f, 0.02457391f, 0.08163913f, 0.05200900f, -0.18774883f, 0.13392146f, 0.06333515f, 
    0.03739465f, 0.04621973f, 0.08401446f, 0.22341621f, 0.09292649f, -0.01116999f, 0.09589084f, -0.01228264f, 
    -0.41542277f, 0.07462980f, 0.16235453f, 0.02669239f, -0.17378527f, -0.04628267f, -0.00023899f, 0.11671256f, 
    0.03832107f, -0.10698590f, 0.00449349f, -0.07236397f, 0.12764651f, 0.07321279f, 0.00062848f, -0.10057027f, 
    0.06834905f, 0.03509850f, 0.12349986f, 0.00555750f, -0.01277088f, -0.06352254f, -0.01220330f, 0.07353313f, 
    -0.09705169f, -0.40732369f, 0.03346970f, 0.52759260f, 0.13392884f, 0.02380918f, 0.05885479f, 0.02568329f, 
    0.07932816f, 0.11870809f, 0.17013983f, 0.16769004f, -0.08844209f, -0.04703446f, 0.11999878f, 0.11610290f, 
    -0.08854408f, -0.01998870f, 0.08030089f, -0.02117313f, 0.10824758f, 0.04289117f, 0.13256228f, 0.09072663f, 
    0.05068238f, -0.32572383f, 0.09642257f, -0.05467570f, -0.03682764f, 0.01267726f, -0.06454552f, 0.00319963f, 
    0.04698646f, -0.00532944f, 0.11257587f, -0.08440918f, -0.17408723f, -0.05619568f, 0.06017502f, -0.10003718f, 
    0.03301558f, 0.07774384f, 0.05959164f, -0.02949737f, -0.00648241f, 0.02708066f, -0.00757739f, -0.02429965f, 
    0.04350209f, -0.04194950f, 0.04854368f, 0.10843296f, -0.01143701f, -0.01549841f, -0.03304124f, 0.05701437f, 
    0.10796164f, 0.13941874f, 0.15898061f, 0.05925874f, -0.08108202f, 0.08744123f, 0.06936730f, -0.00059576f, 
    0.01289993f, -0.01778524f, 0.01560129f, 0.00533601f, -0.01749749f, -0.00752749f, 0.10293565f, -0.02298586f, 
    -0.53696322f, 0.03698285f, -0.29331252f, 0.11060032f, 0.05055603f, 0.03702003f, 0.08779666f, -0.03698289f, 
    0.07465602f, 0.10212228f, -0.19501740f, 0.16065457f, 0.17077887f, 0.08538289f, -0.09982731f, 0.06180205f, 
    0.09396499f, -0.01309367f, 0.02980105f, -0.00496893f, -0.12053833f, -0.04336024f, -0.04133742f, 0.03279950f, 
    0.46799824f, 0.21931463f, 0.01131756f, 0.06581717f, 0.09491262f, 0.11029344f, 0.13080217f, 0.07223456f, 
    0.01118235f, -0.04990460f, -0.01741208f, 0.02069717f, -0.06627464f, 0.09675279f, -0.08167383f, 0.20199710f, 
    -0.04421810f, -0.02291580f, -0.04139910f, -0.09102160f, 0.09528281f, -0.00682217f, 0.05889043f, 0.12742606f, 
    0.06199517f, 0.09215820f, 0.00470804f, 0.11220120f, -0.02068178f, 0.05863236f, 0.03761623f, -0.03396677f, 
    0.11318695f, 0.09414200f, -0.01794518f, 0.11430285f, -0.10966831f, -0.01449971f, -0.00860997f, -0.08236989f, 
    -0.15263411f, -0.01504011f, 0.09608021f, 0.01407494f, 0.00069639f, 0.05061615f, -0.08886216f, -0.05497997f, 
    -0.03312886f, 0.07236291f, -0.06710683f, -0.09174732f, 0.03114556f, -0.03165388f, -0.06833774f, -0.05513195f, 
    -0.12099238f, -0.00901090f, -0.05097121f, 0.04615945f, -0.14121036f, 0.09843085f, 0.10704564f, 0.20948239f, 
    0.03214081f, 0.00216300f, 0.07297419f, 0.11366929f, 0.19826947f, -0.02602275f, 0.01737189f, 0.04903669f, 
    0.08468923f, 0.09101616f, -0.03419710f, -0.08800551f, 0.16844140f, -0.03904336f, 0.20677812f, 0.14553183f, 
    -0.00599753f, -0.06237437f, 0.03550887f, -0.03260274f, 0.11236168f, 0.03923294f, 0.13267623f, 0.08357541f, 
    -0.03864403f, -0.06453608f, -0.01612840f, 0.03058798f, -0.00639473f, -0.08774215f, -0.02039977f, -0.06941327f, 
    -0.13623929f, -0.05910274f, -0.01997765f, -0.07298611f, -0.07867530f, -0.02335731f, -0.13771099f, -0.20976502f, 
    0.00010500f, -0.02528526f, -0.10408187f, 0.03027679f, 0.01620071f, -0.13315131f, 0.00719545f, 0.09664537f, 
    0.04028725f, 0.04171181f, 0.08710969f, -0.03046886f, 0.07831170f, -0.06979959f, 0.00990058f, -0.01964096f, 
    -0.11368349f, -0.02607520f, -0.00259846f, -0.05642822f, 0.10704354f, 0.05851715f, 0.05593895f, -0.10091095f, 
    0.06927352f, -0.02086180f, 0.03600885f, -0.04209878f, 0.22072634f, -0.05496212f, 0.21337144f, -0.02313429f, 
    0.07581298f, -0.04076391f, 0.03531785f, 0.12166018f, 0.02710122f, -0.03549739f, 0.08314026f, 0.04296038f, 
    -0.06897801f, -0.20480004f, 0.05054986f, 0.07649707f, -0.03465654f, -0.06816938f, -0.08541053f, 0.03870232f, 
    0.09693673f, -0.07803698f, 0.12603706f, -0.05416569f, -0.16828439f, -0.02098238f, 0.11792960f, 0.01874120f, 
    0.06862900f, -0.07398137f, 0.01885756f, -0.14699635f, 0.11677881f, -0.00562931f, 0.00164370f, 0.13716854f, 
    -0.06933857f, -0.31184569f, -0.10097016f, 0.26603907f, 0.01808305f, 0.03080744f, -0.06501748f, 0.21751328f, 
    0.08902862f, 0.21455440f, 0.02586585f, -0.01728094f, -0.11328135f, 0.20405799f, 0.04241856f, 0.10436756f, 
    -0.02963522f, -0.04845146f, -0.02128097f, 0.02959443f, 0.21934871f, 0.26022196f, -0.02991758f, 0.11225659f, 
    0.01180380f, 0.29784685f, 0.07163958f, 0.22254694f, 0.09227905f, 0.06346436f, 0.12196124f, -0.02278664f, 
    0.03056042f, 0.09823218f, 0.20543522f, -0.00205461f, -0.05225192f, -0.10804783f, 0.04310938f, 0.17204684f, 
    0.09060200f, -0.03774892f, 0.03782304f, 0.13521551f, 0.05831860f, 0.13610516f, 0.06588776f, 0.04666108f, 
    -0.28921744f, -0.19679680f, 0.00075580f, 0.25275925f, 0.12300123f, 0.10853904f, 0.12320429f, 0.02761229f, 
    0.04123494f, 0.03686837f, 0.03251996f, 0.03073335f, 0.07141942f, 0.22945993f, -0.03378917f, -0.03261184f, 
    0.07780842f, -0.03230954f, -0.02978710f, -0.01882507f, -0.13574484f, 0.02733364f, -0.09857327f, -0.02198529f, 
    -0.10452954f, -0.18459164f, 0.12866235f, 0.06506097f, -0.03340844f, 0.09478748f, -0.03335701f, -0.05539239f, 
    0.06386735f, 0.05895594f, 0.02198802f, 0.11813214f, -0.30165288f, 0.15616569f, -0.21884303f, 0.02775811f, 
    -0.00637752f, -0.00644031f, 0.04202170f, -0.06588931f, 0.01490972f, 0.05558337f, 0.17884427f, -0.06397223f, 
    0.12071940f, 0.04601398f, -0.05806979f, -0.05377734f, 0.08887014f, -0.07721112f, 0.07674409f, -0.00969650f, 
    -0.04959304f, 0.01990474f, -0.03506104f, 0.00844795f, -0.04501734f, 0.25352404f, 0.23455364f, 0.07579717f, 
    -0.04091623f, -0.02362414f, -0.01324565f, -0.05513807f, 0.16469376f, 0.01454804f, 0.07204765f, 0.10052632f, 
    -0.12487493f, 0.22366858f, -0.21731612f, -0.17004657f, -0.01150644f, -0.00813032f, 0.00550846f, 0.00177995f, 
    -0.05319949f, 0.08041730f, 0.14651172f, -0.03991048f, -0.15195872f, -0.06317390f, -0.07258145f, 0.10961992f, 
    -0.02522660f, 0.03316034f, -0.00200069f, 0.01089694f, -0.01138869f, 0.09043452f, 0.00397781f, -0.00948768f, 
    0.04689097f, 0.47815529f, -0.09045224f, 0.03928943f, 0.00207094f, 0.00548566f, -0.00649149f, 0.01152469f, 
    -0.03683364f, -0.00166891f, 0.08594973f, 0.00668502f, -0.03273325f, 0.13175558f, 0.10275024f, 0.13734473f, 
    -0.15013006f, -0.01001538f, -0.04746319f, -0.03231097f, 0.02539749f, 0.03513634f, -0.06074158f, -0.06592454f, 
    0.00355904f, 0.09862601f, -0.13624017f, 0.03574945f, -0.00977311f, -0.00378104f, -0.06408348f, -0.08455395f, 
    -0.04533954f, 0.06074204f, -0.05504527f, -0.13910939f, -0.17580703f, 0.03961153f, 0.09057546f, 0.22255903f, 
    -0.05192279f, 0.00751835f, 0.06940703f, -0.02730997f, 0.07687414f, 0.00782814f, -0.08284124f, 0.08504360f, 
    0.65617955f, -0.06081880f, 0.05255314f, -0.15375145f, 0.05917695f, 0.16657133f, 0.06947190f, -0.25652981f, 
    -0.02442351f, 0.14945023f, 0.05106185f, -0.03637552f, 0.41327631f, 0.04039472f, 0.06951340f, -0.21414046f, 
    -0.14573520f, -0.02763797f, -0.12357268f, -0.13815920f, 0.06426930f, 0.01733832f, 0.03313835f, -0.02383226f, 
    0.21306601f, 0.03575867f, 0.21650168f, -0.16516490f, -0.05785741f, -0.12698092f, -0.07378993f, 0.09005873f, 
    -0.05848416f, 0.08684277f, -0.04050553f, 0.11026181f, 0.12349553f, 0.00578596f, -0.09892730f, -0.07741211f, 
    -0.05313332f, -0.01627199f, -0.04022221f, 0.03709074f, 0.00768491f, -0.18357848f, 0.09381848f, -0.05496904f, 
    -0.01662506f, 0.10408513f, -0.00647325f, -0.06873064f, 0.11039880f, -0.06341618f, 0.03722798f, -0.05108402f, 
    -0.00065029f, -0.09717195f, -0.01268218f, 0.01600068f, -0.23029886f, -0.03462045f, 0.16928782f, 0.35496834f, 
    0.09197488f, 0.08563189f, 0.00697166f, 0.00848661f, 0.01409439f, 0.02799262f, -0.00353759f, 0.01926289f, 
    0.16605036f, -0.28928888f, 0.19144963f, -0.03976104f, -0.03918897f, -0.01994294f, -0.02300077f, 0.00948337f, 
    -0.04988651f, -0.05119364f, -0.04215637f, 0.05571736f, -0.04016913f, -0.02745223f, 0.07559822f, 0.13412793f, 
    0.04468273f, -0.01127450f, -0.00175534f, 0.01837508f, -0.01488704f, 0.17073260f, -0.01527926f, 0.04049686f, 
    0.15624233f, -0.04257072f, 0.27362442f, 0.08472967f, -0.05264624f, 0.00828884f, -0.00066612f, -0.01200964f, 
    -0.05800572f, -0.00771162f, -0.06903598f, 0.05629471f, 0.21542998f, -0.01079210f, -0.05464359f, -0.08957395f, 
    -0.09144346f, -0.07594595f, -0.02498612f, -0.09436101f, -0.09810494f, 0.00301656f, -0.08709082f, -0.02981046f, 
    -0.21993658f, -0.10356090f, 0.04044798f, 0.24027030f, 0.03556978f, 0.19748923f, 0.03751398f, -0.00145079f, 
    -0.03261307f, -0.04441740f, -0.02147530f, -0.00084812f, -0.00251575f, 0.08170509f, -0.05654347f, -0.09019300f, 
    0.00083181f, 0.01293635f, -0.03950314f, 0.03906197f, -0.03114871f, 0.06659354f, 0.00667933f, -0.01547876f, 
    -0.11389285f, -0.10172871f, 0.05583752f, 0.13581251f, 0.02006520f, 0.00140938f, 0.03602224f, 0.09948338f, 
    0.14792778f, 0.10307574f, 0.07548175f, 0.09166219f, 0.10772908f, -0.03751644f, 0.12361975f, -0.10596312f, 
    -0.03135427f, 0.02547221f, -0.06585952f, -0.05309321f, -0.08855911f, -0.04012866f, -0.04996948f, -0.08003900f, 
    0.11524335f, 0.08827616f, -0.25370944f, -0.08849887f, -0.01307992f, 0.07663393f, 0.02773433f, 0.01622349f, 
    -0.17194384f, 0.02717879f, 0.08569486f, -0.02700022f, -0.21031402f, -0.09138163f, 0.07387461f, 0.18756816f, 
    0.01717127f, -0.01393386f, 0.09465594f, 0.03304784f, -0.08382932f, 0.08936644f, 0.06086722f, 0.03107078f, 
    -0.28564772f, 0.30279949f, -0.11350843f, 0.31053171f, 0.13432696f, 0.08144035f, 0.16006643f, -0.10583458f, 
    0.01515776f, -0.01491649f, 0.12515961f, -0.04169424f, 0.08176131f, 0.10646967f, -0.03798850f, -0.14601831f, 
    0.12197383f, 0.04814276f, -0.01819357f, -0.00363779f, -0.04304970f, -0.02717954f, 0.21229452f, -0.02097329f, 
    -0.42909041f, -0.00516047f, -0.02797423f, 0.61351794f, 0.04286173f, 0.04240445f, 0.09031857f, -0.08363178f, 
    -0.13066566f, 0.02557289f, -0.02971878f, 0.18031640f, 0.07067250f, -0.15177491f, 0.02497711f, 0.07185988f, 
    0.06844296f, 0.15722653f, 0.12737311f, 0.08375087f, -0.01262735f, 0.04992589f, -0.03535269f, 0.04406828f, 
    0.14674106f, 0.06898062f, -0.17795479f, 0.13526867f, 0.07116835f, -0.08389378f, -0.03021592f, 0.01460421f, 
    -0.02602064f, -0.05890340f, 0.02334234f, -0.06106221f, -0.13146995f, 0.08633533f, -0.09192733f, -0.06232756f, 
    0.00841167f, -0.02102217f, -0.03873489f, -0.06429946f, -0.01809240f, 0.05255094f, 0.03330355f, 0.01109472f, 
    -0.22864304f, -0.25800321f, 0.11538732f, 0.02135612f, -0.02212141f, 0.05845747f, 0.05135245f, -0.07093719f, 
    -0.10643633f, -0.04262619f, 0.01524822f, 0.21854042f, -0.20763884f, 0.26600775f, -0.25198710f, 0.11027876f, 
    0.06516112f, 0.02887392f, -0.02219884f, -0.02187432f, 0.05674314f, -0.01536316f, 0.08917932f, 0.06829241f, 
    -0.03650940f, 0.00743847f, 0.00463682f, 0.16091792f, 0.06083738f, 0.04941584f, 0.14529537f, 0.01551445f, 
    -0.07378864f, 0.12957822f, -0.03319621f, 0.03418171f, -0.14417405f, 0.18947490f, 0.08307908f, 0.12523870f, 
    -0.03816116f, -0.06045458f, -0.01560960f, -0.02117518f, -0.04125033f, -0.04293807f, 0.00858763f, -0.00026375f, 
    0.44259167f, 0.53011626f, 0.06347001f, -0.37015006f, 0.10116439f, 0.05789484f, -0.00462193f, -0.00601676f, 
    -0.00295778f, 0.00668578f, -0.07303712f, -0.01803550f, 0.11267179f, 0.02727999f, -0.17669722f, -0.15472940f, 
    0.10335854f, -0.05885983f, 0.00114464f, -0.04011932f, 0.01147764f, -0.03822413f, -0.10140061f, -0.05397702f, 
    -0.15026470f, 0.08428445f, -0.13773288f, -0.01237111f, -0.04081565f, 0.01136540f, -0.07119936f, 0.02717225f, 
    0.00910057f, 0.04953076f, 0.14659354f, -0.01424701f, 0.03440675f, -0.01842213f, 0.06737004f, 0.12283840f, 
    -0.07026216f, 0.07683865f, -0.03048410f, 0.02853389f, -0.05204898f, -0.01529275f, -0.02277876f, 0.08338203f, 
    -0.09098607f, 0.10200886f, -0.09942146f, 0.05290645f, -0.00762410f, 0.05604311f, 0.03914138f, -0.02530760f, 
    -0.06961071f, -0.04683718f, -0.02855578f, 0.10239305f, 0.17534485f, 0.06260110f, -0.05799797f, 0.21744289f, 
    0.09166759f, 0.04357991f, 0.03914420f, -0.01769666f, -0.03757017f, 0.03302538f, -0.00759022f, -0.00697191f, 
    0.78984225f, -0.01887852f, 0.34283388f, -0.16546942f, -0.03519482f, 0.11554772f, 0.05731814f, 0.00716491f, 
    0.00029114f, 0.07414367f, 0.04359737f, -0.19226725f, 0.32587901f, 0.11444543f, 0.29301506f, -0.12310552f, 
    -0.03052035f, 0.08253048f, -0.07460232f, 0.08518251f, 0.02928320f, 0.05245468f, 0.02021702f, -0.04658756f, 
    -0.19602001f, 0.11469724f, 0.39238548f, 0.03732244f, -0.07587051f, 0.04954574f, 0.02288110f, 0.10564706f, 
    -0.03677950f, -0.04990570f, -0.09840450f, 0.09647372f, -0.27391511f, -0.07704912f, -0.10123123f, -0.22748484f, 
    -0.03282522f, -0.06226693f, 0.03702215f, -0.02728038f, 0.01071729f, 0.07179768f, 0.00679595f, 0.09046220f, 
    -0.05827291f, 0.02442374f, 0.01527777f, -0.14558640f, -0.01829658f, 0.01044239f, -0.03646417f, 0.03288877f, 
    -0.02773850f, 0.01053372f, -0.04650161f, 0.01971391f, 0.21501841f, 0.12875125f, -0.18196908f, 0.07658765f, 
    -0.03590320f, 0.02074932f, 0.10391743f, 0.05393909f, 0.10047124f, 0.00074923f, 0.02779735f, -0.01933909f, 
    0.03104190f, -0.05823994f, 0.27240893f, -0.11149475f, -0.00769432f, 0.07675856f, -0.01877743f, 0.11081430f, 
    -0.02639426f, 0.01509156f, 0.01920276f, -0.01247085f, -0.13305549f, 0.07311084f, -0.10894875f, 0.16418843f, 
    0.17223917f, -0.01253252f, 0.08002359f, 0.08830452f, -0.02806696f, -0.02435122f, -0.00776627f, 0.08146574f, 
    -0.26752466f, -0.10178956f, 0.18152434f, 0.10097720f, 0.05260169f, -0.00050168f, -0.12403896f, -0.05536358f, 
    -0.10637315f, 0.12616569f, 0.07587619f, 0.07816705f, -0.09538384f, 0.01529633f, 0.05996930f, -0.10011972f, 
    -0.12114475f, -0.10327708f, -0.08510204f, 0.04477922f, -0.02140630f, 0.01568402f, -0.04697956f, -0.02363159f, 
    0.08151178f, -0.16861895f, -0.03097696f, -0.00166178f, 0.01104650f, 0.06281907f, -0.05158503f, 0.04386182f, 
    0.08974024f, 0.10392229f, 0.04619939f, -0.02877666f, 0.10416663f, -0.05143203f, -0.02051675f, -0.17199270f, 
    -0.05690692f, 0.04888001f, -0.03329295f, 0.02476186f, -0.02461581f, -0.00517336f, -0.03965509f, -0.03420623f, 
    -0.00186762f, -0.08778191f, 0.08051783f, 0.03067458f, 0.08840504f, -0.02328436f, 0.04151706f, 0.06655250f, 
    0.01795483f, -0.01694182f, -0.05549201f, 0.11224187f, -0.10001057f, 0.04786469f, 0.17517248f, -0.01258342f, 
    -0.10565976f, -0.00408234f, 0.01137206f, -0.06010106f, -0.03833023f, -0.03244845f, -0.01124456f, -0.06343009f, 
    0.09007262f, -0.00875012f, -0.00494049f, -0.09037499f, -0.01591278f, 0.04211053f, 0.01155513f, -0.01526491f, 
    0.05729089f, 0.11388996f, 0.08866674f, 0.05824810f, 0.05767571f, -0.04039468f, 0.00563905f, -0.01807983f, 
    -0.02116211f, 0.06322606f, -0.04493625f, 0.02772777f, 0.00015925f, 0.01451227f, 0.06212555f, 0.13851805f, 
    0.33565241f, 0.55689931f, 0.20051838f, 0.31596226f, 0.04306721f, 0.00009710f, 0.11323209f, -0.08147947f, 
    -0.01445136f, -0.01018909f, 0.06266982f, 0.01928860f, 0.05953519f, 0.01040539f, -0.23829968f, -0.25777739f, 
    0.02010264f, 0.04836373f, 0.06356496f, 0.05171816f, -0.08359586f, 0.10914248f, -0.02147644f, 0.07092652f, 
    0.03953061f, 0.05100674f, 0.00536555f, -0.01858783f, 0.01039027f, -0.01293646f, 0.01390723f, 0.01146083f, 
    -0.01554201f, 0.00103283f, -0.01293609f, 0.02345918f, 0.03927359f, -0.02520302f, -0.01371997f, -0.02190037f, 
    0.03192507f, 0.04115070f, 0.03392617f, -0.05525176f, -0.04492983f, 0.04229273f, -0.02993880f, 0.01558346f, 
    -0.04620439f, -0.03412223f, -0.03115613f, 0.03437214f, -0.01471583f, -0.00653935f, -0.04049847f, -0.03463434f, 
    0.02831946f, 0.01523137f, -0.01604640f, 0.02665804f, 0.03512977f, -0.00802931f, -0.04642394f, -0.02890882f, 
    0.02887973f, -0.01495342f, -0.04656447f, -0.00893059f, -0.03338879f, 0.04384166f, 0.00543715f, -0.03101701f, 
    -0.05616650f, -0.05086627f, -0.04930614f, -0.01708752f, 0.02010989f, 0.02559409f, -0.02584540f, -0.00215645f, 
    -0.04217270f, -0.05776088f, -0.04326849f, -0.04321226f, -0.03082183f, 0.02446266f, 0.02752125f, -0.00884786f, 
    -0.00544240f, 0.00288189f, -0.00005222f, 0.01193834f, 0.00417107f, 0.01433278f, 0.00406675f, -0.02314559f, 
    -0.04207373f, 0.03865377f, -0.03065367f, 0.01516118f, -0.02579754f, 0.03692294f, 0.03858373f, -0.02025660f, 
    0.03218617f, -0.00278411f, 0.03695287f, 0.00580058f, -0.01061008f, -0.02244406f, -0.00492846f, -0.03328598f, 
    -0.03524405f, -0.04251847f, 0.03365951f, -0.03098792f, 0.00344688f, -0.00733772f, -0.00866960f, -0.05797828f, 
    0.02652114f, -0.00365156f, -0.00387290f, -0.03167344f, -0.03043422f, 0.02323784f, 0.02741620f, 0.02028190f, 
    -0.02450290f, 0.02679399f, -0.01646867f, 0.03589819f, 0.03074368f, 0.04870936f, 0.01183665f, -0.04111714f, 
    -0.00120754f, 0.03367861f, -0.01168895f, -0.01210634f, 0.05034720f, 0.01759798f, 0.02152603f, 0.00601809f, 
    0.00421636f, 0.00875033f, 0.01850360f, -0.02640802f, 0.02445223f, -0.04376345f, -0.04762112f, -0.03533703f, 
    -0.01420626f, -0.04041819f, -0.04765583f, -0.02179563f, 0.01777172f, -0.00366917f, -0.01518555f, -0.04545878f, 
    0.01948112f, -0.03001358f, -0.04310495f, -0.01876175f, -0.00681366f, -0.00518329f, -0.03349253f, 0.03395767f, 
    -0.00774932f, 0.03238253f, 0.00357504f, 0.03201031f, -0.01598366f, -0.04723033f, -0.03265902f, -0.01433074f, 
    0.00331422f, -0.02403403f, 0.04083863f, -0.03364203f, 0.04835099f, -0.05142929f, -0.02990999f, -0.04827780f, 
    0.01605441f, 0.04475018f, -0.03414896f, -0.02288035f, 0.03652114f, -0.02988441f, -0.01570438f, -0.04736565f, 
    -0.03773540f, 0.03318256f, -0.02902756f, 0.01802538f, -0.03255781f, -0.00578063f, 0.04161686f, -0.03749353f, 
    -0.03394018f, 0.03808612f, 0.04400975f, -0.00102329f, -0.03040423f, 0.01754694f, 0.01489043f, -0.02287463f, 
    -0.02448166f, -0.04883097f, 0.00047822f, 0.03313062f, -0.03255443f, 0.01716497f, -0.03603259f, -0.04181778f, 
    -0.00243273f, -0.02364158f, -0.03446724f, 0.03716728f, 0.03783844f, -0.05085230f, -0.03132804f, -0.04516795f, 
    -0.00049661f, -0.01504135f, -0.05147598f, 0.02644568f, 0.04374859f, -0.01808868f, -0.01942195f, -0.02389728f, 
    -0.01269131f, -0.02100840f, -0.02684082f, 0.00932784f, -0.01658264f, -0.02627522f, -0.02902877f, -0.04164532f, 
    0.03847240f, 0.04096638f, -0.00396763f, 0.00522385f, -0.02119892f, 0.04263305f, -0.04792239f, -0.00729864f, 
    -0.04578283f, 0.04210734f, 0.03978230f, -0.05171822f, -0.05100086f, -0.02040981f, 0.00209932f, -0.04924403f, 
    0.03005403f, -0.05808444f, -0.02113775f, -0.04111081f, 0.02617866f, 0.04607515f, 0.01840613f, 0.03332666f, 
    0.02086843f, 0.00967150f, -0.02952489f, -0.04928120f, 0.02999137f, 0.02114444f, -0.00033861f, 0.00376570f, 
    -0.01528996f, 0.00647146f, 0.02745998f, -0.02858328f, -0.00302754f, 0.03306580f, -0.01585005f, -0.05287322f, 
    -0.04741105f, 0.03150731f, -0.03458829f, -0.01692574f, -0.04007038f, -0.05130744f, 0.03809931f, 0.04119736f, 
    0.02551902f, 0.01797127f, -0.01207302f, 0.02924902f, 0.01246359f, 0.01130431f, 0.03908551f, 0.02876836f, 
    -0.03865803f, -0.03683684f, 0.02403603f, -0.04151625f, 0.04379233f, -0.01398912f, -0.05038695f, 0.00823495f, 
    -0.04381432f, 0.03896847f, 0.00400123f, -0.04157550f, -0.02730494f, -0.04639979f, 0.02790461f, -0.02019574f, 
    0.02185679f, -0.03384444f, 0.04647682f, 0.04386378f, -0.00881999f, 0.02817033f, 0.00171784f, -0.03875899f, 
    0.00097182f, 0.02372298f, 0.00547811f, 0.02514728f, -0.00385842f, -0.01043515f, 0.03204535f, -0.05272747f, 
    -0.01832568f, -0.04071840f, 0.02416237f, 0.04716739f, 0.03469249f, 0.00005216f, 0.00939258f, -0.02097737f, 
    -0.04584100f, -0.02353803f, -0.03184479f, 0.01901291f, 0.02333554f, 0.04929990f, -0.03801221f, -0.03692168f, 
    0.01998976f, -0.03288839f, 0.00657016f, 0.03143607f, 0.04232740f, -0.04529246f, -0.03120000f, -0.02425015f, 
    0.00594952f, 0.00190463f, 0.02337584f, -0.01331150f, 0.00762410f, 0.03683741f, -0.02737135f, -0.01357586f, 
    -0.01150359f, -0.04927409f, -0.03803378f, -0.04896791f, 0.03145100f, 0.02365384f, 0.01802861f, -0.03748027f, 
    0.04021129f, 0.01817346f, -0.05499851f, -0.01153643f, -0.04164860f, -0.05444128f, -0.03065798f, -0.00781765f, 
    -0.02696382f, 0.03159978f, -0.02848017f, 0.03093175f, -0.01678932f, -0.02855041f, -0.00957750f, -0.00392199f, 
    -0.02910743f, 0.05105600f, 0.00947001f, 0.00942079f, -0.02276572f, -0.04131239f, -0.04344302f, -0.00397500f, 
    -0.04994133f, -0.03943919f, 0.00520141f, -0.01431177f, -0.05217047f, 0.03200556f, -0.02056574f, 0.01172733f, 
    -0.01778355f, -0.04200511f, -0.03594861f, 0.00791927f, -0.03596924f, -0.03465899f, 0.00669331f, -0.04663566f, 
    0.57566971f, 0.17170487f, 0.03254085f, -0.07395925f, -0.01355634f, -0.07196138f, 0.06657136f, 0.12587912f, 
    0.07545888f, 0.14085183f, 0.04848312f, -0.05978682f, -0.11827364f, 0.25020191f, 0.09714179f, -0.15566614f, 
    -0.05366898f, -0.12164681f, 0.06814902f, -0.08127651f, -0.07576523f, -0.06302100f, 0.02779073f, -0.01814945f, 
    -0.24910870f, -0.12116269f, 0.22709373f, 0.10344917f, -0.13017359f, 0.02522347f, 0.09325734f, 0.07814656f, 
    0.01622323f, 0.05846632f, 0.03124904f, -0.05610696f, 0.05972666f, -0.02252754f, 0.13234916f, 0.16794275f, 
    0.04240414f, 0.02383580f, 0.00421023f, -0.03851319f, 0.03011598f, 0.00282032f, -0.00854754f, 0.06384391f, 
    0.20877756f, 0.21749726f, 0.05384040f, -0.02524118f, 0.02709149f, 0.00603758f, 0.07500754f, 0.13199265f, 
    0.22654513f, 0.10012839f, 0.10189345f, -0.01792376f, 0.01610250f, 0.06974819f, 0.21021704f, 0.12921022f, 
    0.04675364f, 0.07242060f, 0.01941103f, 0.14459009f, 0.17324188f, 0.04643803f, 0.04160938f, 0.08048549f, 
    -0.00719280f, 0.29945552f, 0.15952040f, -0.04401476f, -0.08066338f, -0.09460476f, -0.16943595f, 0.09123765f, 
    0.00500023f, 0.09994337f, 0.08053547f, -0.01236260f, 0.19641127f, -0.09453313f, 0.04003852f, -0.07142987f, 
    -0.02313797f, 0.06074301f, 0.08792211f, 0.05897157f, 0.01363272f, 0.08249039f, -0.10524388f, -0.02582445f, 
    -0.39378646f, 0.00138065f, -0.28411439f, 0.21904461f, 0.05807963f, 0.02768202f, 0.05399185f, 0.08237790f, 
    -0.01945752f, 0.02238961f, -0.05177418f, 0.14513950f, -0.08996343f, -0.06664570f, -0.09077273f, 0.15565693f, 
    -0.01779653f, 0.11884078f, 0.05099852f, -0.05903612f, -0.01809730f, 0.06442042f, 0.10652071f, 0.02137605f, 
    0.06079891f, -0.06645655f, 0.09453467f, -0.03267053f, 0.00176193f, -0.03834021f, -0.06261019f, 0.00855228f, 
    0.06118927f, -0.14478050f, 0.12547937f, 0.16754524f, -0.14025339f, 0.05890333f, 0.00164242f, -0.17528909f, 
    -0.00923526f, -0.19822195f, -0.03891838f, 0.11498020f, -0.07388938f, -0.06038554f, -0.02059755f, -0.04636894f, 
    0.10466973f, 0.07084433f, -0.00803219f, 0.11437753f, 0.01614976f, -0.04215695f, -0.03497783f, 0.06769130f, 
    0.07111663f, 0.10755865f, 0.11853958f, 0.00974431f, -0.13523631f, 0.12380453f, 0.10389143f, 0.03206684f, 
    0.00338118f, 0.00138722f, -0.02304720f, 0.00885302f, -0.00994725f, -0.00336798f, -0.06542028f, -0.14848159f, 
    -0.49623612f, 0.05954350f, 0.15770726f, 0.12135871f, -0.08199183f, -0.01126240f, -0.04201003f, -0.02752291f, 
    0.06639456f, 0.05583241f, -0.08473055f, 0.17892535f, 0.04100598f, -0.10489630f, -0.18305902f, -0.01942605f, 
    0.09587743f, 0.00563481f, 0.08210142f, -0.04340561f, -0.08406489f, -0.04779439f, -0.02843020f, 0.00727227f, 
    0.09914986f, -0.11906074f, -0.06029031f, -0.09101059f, 0.03924584f, 0.09087180f, 0.13031045f, -0.03480632f, 
    -0.01619587f, 0.00055905f, 0.01211646f, -0.08936793f, 0.14470237f, 0.11565551f, 0.06071996f, 0.12958482f, 
    -0.09445709f, -0.07832970f, -0.07668643f, -0.02485804f, 0.10505750f, 0.08810360f, 0.07780179f, 0.21093811f, 
    0.03365409f, 0.13321897f, 0.02001770f, 0.04026058f, 0.01162609f, 0.03445248f, 0.05938916f, 0.00849578f, 
    0.07910785f, -0.05584979f, 0.11874265f, -0.06128991f, -0.21276669f, -0.37595898f, -0.01821357f, 0.16104516f, 
    0.08261443f, 0.04377778f, -0.00005033f, -0.17778695f, -0.00539001f, 0.04052660f, -0.00179267f, 0.01013295f, 
    0.10166809f, 0.02046957f, -0.36072314f, -0.10668039f, 0.02271477f, -0.00180693f, 0.15195540f, -0.12393713f, 
    -0.12878987f, -0.10337900f, -0.02355302f, -0.04551220f, -0.00356639f, 0.31503537f, -0.06342989f, 0.21095255f, 
    0.04672599f, -0.02473592f, 0.15814637f, 0.04752166f, 0.13584054f, 0.13500990f, 0.13386658f, -0.01512380f, 
    0.30404490f, -0.05859340f, -0.08770664f, 0.02637753f, 0.08060991f, 0.16050684f, 0.23228779f, -0.04263049f, 
    0.00312530f, 0.03920934f, -0.08160835f, -0.00079841f, 0.06621259f, -0.05019345f, -0.04374913f, -0.00650560f, 
    -0.10201918f, 0.04033497f, -0.03760920f, -0.08548936f, 0.03100380f, -0.01727112f, -0.05339723f, 0.02577326f, 
    -0.25238514f, 0.02165740f, 0.11129189f, -0.09430896f, -0.08108615f, -0.01431360f, -0.08307057f, -0.01056591f, 
    0.02740168f, -0.03455802f, -0.05950987f, 0.00648374f, -0.12768918f, -0.06176667f, 0.16473053f, 0.06071363f, 
    -0.01529850f, 0.04348074f, -0.04080539f, -0.02157470f, -0.01479886f, -0.07276104f, 0.06834411f, 0.07370667f, 
    -0.05271877f, 0.12493217f, 0.04371801f, -0.05027212f, 0.06956001f, -0.01880153f, 0.07623622f, 0.10852484f, 
    0.07442078f, 0.00567985f, -0.05576068f, 0.01012086f, 0.07709195f, -0.02583296f, -0.17582415f, 0.05859644f, 
    0.06628700f, 0.04501141f, 0.08083074f, 0.03413450f, -0.04988144f, 0.13328829f, 0.00724697f, 0.01493177f, 
    -0.20864603f, 0.19404727f, 0.01288381f, -0.06262740f, -0.10330921f, -0.06519591f, -0.08283431f, -0.02088885f, 
    0.07495973f, 0.07194091f, -0.03149104f, 0.09837007f, -0.18680957f, 0.09810778f, -0.00753450f, -0.13425398f, 
    0.06124323f, 0.02215353f, 0.06150281f, 0.01952941f, 0.05494503f, 0.01218927f, 0.08414067f, -0.00204973f, 
    -0.10217077f, -0.48694894f, 0.22442956f, 0.01340933f, -0.00177028f, 0.05379920f, 0.01931472f, 0.00132336f, 
    0.06133256f, 0.12121177f, 0.09060778f, 0.10685739f, -0.09215717f, -0.03491972f, 0.21224728f, 0.27926904f, 
    -0.04930203f, 0.04064348f, -0.04615953f, -0.04154556f, 0.08706212f, 0.14374495f, 0.21576874f, 0.06922595f, 
    0.31317508f, 0.08701725f, -0.23216134f, 0.07426343f, 0.00834455f, -0.01139724f, 0.05177524f, -0.00533942f, 
    0.07446033f, -0.01761302f, -0.17932646f, 0.03865547f, 0.09958662f, 0.19223246f, 0.04731742f, 0.06260144f, 
    -0.05437846f, 0.16751383f, 0.00241000f, 0.03316472f, -0.02390813f, -0.09900413f, 0.00174173f, 0.04020478f, 
    0.18232229f, 0.27548939f, 0.06791743f, 0.04599682f, -0.04623754f, 0.05981449f, -0.03069597f, 0.07248024f, 
    -0.03917313f, -0.10965490f, -0.03265908f, 0.02360607f, 0.22173232f, -0.11251703f, -0.06442743f, 0.06144826f, 
    -0.07632967f, 0.05037014f, 0.00243342f, 0.01804854f, 0.06314840f, 0.00539783f, 0.01301982f, 0.08822352f, 
    0.04540670f, -0.24945229f, 0.09766285f, -0.00099942f, 0.02364350f, 0.08939220f, 0.00289242f, 0.17417069f, 
    0.01030477f, 0.01642626f, 0.04496072f, -0.09448590f, 0.00311339f, 0.17485207f, -0.01245592f, 0.05849527f, 
    -0.02446614f, 0.03932389f, 0.03812565f, 0.02990325f, -0.08203908f, -0.05467029f, -0.11590076f, 0.11213648f, 
    0.05176293f, 0.17051882f, -0.03957353f, -0.04239605f, 0.06987477f, 0.02051373f, -0.05105998f, 0.14178789f, 
    -0.02377051f, 0.06620942f, 0.03683204f, -0.05608220f, 0.11164533f, -0.09522346f, -0.22772512f, -0.18705319f, 
    0.01699451f, -0.07226550f, -0.03538252f, 0.06773745f, -0.15479338f, -0.06152209f, -0.26007718f, -0.10243254f, 
    -0.59737849f, -0.00290305f, 0.25558671f, -0.01636671f, -0.07041638f, -0.04724865f, 0.09871975f, 0.20981815f, 
    0.01587710f, 0.03447704f, -0.29767898f, 0.04682707f, 0.06667561f, 0.12003392f, 0.06672309f, 0.05876336f, 
    0.02520524f, 0.03322772f, -0.01369872f, 0.03262053f, -0.06569203f, -0.02487072f, -0.11920743f, -0.08824929f, 
    -0.05302196f, -0.18373035f, 0.02678488f, -0.04176548f, -0.07502837f, 0.06657397f, -0.01852239f, -0.01457144f, 
    0.00749504f, -0.14588331f, 0.11751848f, -0.00425436f, 0.15110858f, 0.24664071f, 0.21611965f, 0.13070588f, 
    0.10284334f, 0.13880631f, 0.05573910f, 0.01515006f, -0.01122318f, 0.07304602f, 0.06649494f, 0.10192843f, 
    -0.06047415f, 0.05139101f, -0.10784753f, 0.00619408f, -0.09380059f, -0.04981113f, -0.02176426f, 0.10033365f, 
    -0.14343238f, -0.12323464f, -0.00164827f, -0.10649756f, 0.12677486f, 0.13777840f, -0.00819924f, 0.06727434f, 
    0.08841299f, 0.03245347f, -0.00453949f, 0.00737199f, -0.11247087f, 0.03622571f, -0.15428993f, -0.12318993f, 
    -0.26294973f, -0.07632454f, 0.28000987f, 0.00249281f, -0.03351860f, -0.04464249f, -0.02490283f, 0.09794679f, 
    -0.00144653f, 0.01120497f, -0.09119118f, 0.11644398f, -0.19533862f, -0.09507003f, -0.11179399f, 0.20655069f, 
    -0.00166531f, -0.05208495f, -0.02331848f, -0.04948270f, 0.06956191f, 0.08198521f, 0.02734826f, 0.04661953f, 
    -0.23460175f, -0.07928140f, 0.01148754f, -0.10392652f, -0.10312764f, 0.01289975f, 0.02890831f, -0.10868561f, 
    -0.00992982f, 0.05605678f, -0.02276147f, 0.00513981f, 0.09913689f, -0.18571121f, -0.11757322f, -0.18387163f, 
    -0.00078720f, -0.00742206f, -0.07432686f, 0.04768477f, 0.04781263f, 0.08588880f, -0.11262428f, 0.01900698f, 
    -0.03512366f, -0.07957013f, 0.02435343f, -0.08741448f, -0.11936720f, -0.01370117f, -0.00875561f, 0.04657117f, 
    -0.00544671f, 0.06388135f, -0.02228485f, -0.11718483f, 0.16080315f, 0.15561698f, 0.02718853f, -0.01403576f, 
    0.15047267f, -0.02923862f, 0.08495379f, 0.00190595f, -0.05878898f, -0.02146758f, 0.00909465f, 0.04743769f, 
    -0.05485596f, 0.11567504f, -0.11564319f, 0.14353056f, -0.08201034f, 0.12329120f, 0.07637659f, 0.13218771f, 
    -0.01881455f, 0.12508807f, 0.00944201f, -0.03536309f, -0.10944753f, 0.22565146f, -0.15693508f, -0.02507974f, 
    -0.06889260f, 0.03949034f, 0.12371241f, 0.06053214f, 0.05877047f, -0.08774532f, 0.12041648f, 0.00575198f, 
    0.07367661f, -0.02569261f, -0.18768977f, 0.03034316f, -0.02717295f, -0.06078473f, 0.01775607f, -0.07268230f, 
    -0.03383063f, 0.14605109f, 0.07109174f, -0.02625250f, 0.02764688f, -0.11293204f, -0.06860158f, 0.12919457f, 
    -0.02849629f, -0.00479265f, -0.00831638f, -0.04086597f, 0.03193256f, -0.05212919f, 0.05759835f, 0.00013692f, 
    0.22540858f, 0.32462195f, 0.07777850f, -0.00916964f, 0.02110946f, -0.01884336f, -0.01568542f, 0.07229781f, 
    -0.06159554f, -0.00835910f, 0.02549622f, -0.03447837f, -0.05911925f, 0.00672870f, 0.12834820f, 0.12290227f, 
    -0.02739392f, -0.04065605f, 0.05649277f, 0.05087990f, 0.04757385f, 0.00077542f, 0.03847939f, 0.02937960f, 
    0.13258396f, 0.08038874f, 0.09696315f, 0.08601663f, -0.00320783f, -0.00524180f, -0.07129946f, 0.03267606f, 
    -0.04369218f, -0.08772065f, -0.11782841f, -0.01764099f, -0.06911280f, 0.05838959f, -0.05798097f, 0.06851243f, 
    -0.09862486f, -0.00161437f, 0.03343576f, -0.02659649f, 0.04273866f, 0.12784843f, 0.00284079f, 0.03755801f, 
    -0.46593431f, -0.04100282f, 0.20572397f, -0.10711303f, -0.05909348f, -0.00919124f, -0.03472667f, 0.03802593f, 
    0.14068335f, 0.04500992f, -0.13979043f, -0.00657891f, 0.15338071f, 0.14674994f, 0.09454885f, 0.02613780f, 
    0.02420984f, 0.07701037f, 0.07655623f, 0.06145659f, -0.05957903f, -0.09795433f, -0.15629609f, -0.07418765f, 
    0.45591193f, 0.07539575f, 0.43642294f, 0.01336152f, -0.08326239f, -0.02813076f, 0.11705870f, -0.05306505f, 
    -0.08597188f, 0.04969374f, -0.09799763f, -0.01287811f, 0.01923911f, -0.11258128f, 0.04207249f, 0.16361284f, 
    -0.01233978f, -0.09356577f, -0.02351823f, 0.01899035f, -0.00461180f, 0.14168344f, -0.05940008f, -0.08597542f, 
    0.50192934f, -0.13744228f, -0.10733515f, -0.13340257f, 0.11076316f, 0.04071350f, -0.04319066f, 0.12759800f, 
    0.16193479f, 0.09980120f, 0.03932500f, -0.02054573f, -0.07113034f, -0.12766473f, -0.13282807f, -0.17426442f, 
    0.16170897f, 0.09150703f, 0.12011069f, -0.09472548f, 0.02575269f, -0.07459059f, 0.11619246f, 0.07694325f, 
    0.04093197f, 0.09625486f, -0.12059042f, -0.09985027f, -0.04166161f, 0.16315366f, 0.23811942f, 0.05655310f, 
    0.09939088f, 0.01613115f, -0.00675753f, 0.08627747f, -0.04943299f, -0.00358113f, 0.13486406f, 0.08869758f, 
    -0.13348119f, -0.02191368f, -0.04078701f, 0.00353595f, 0.09645449f, -0.03774970f, 0.07439090f, 0.28355137f, 
    0.04807063f, 0.04953917f, -0.16674766f, -0.08267231f, 0.05363144f, -0.15797636f, 0.03445709f, 0.13331954f, 
    0.06512979f, 0.01941015f, -0.04739144f, -0.04689793f, 0.25346711f, -0.03069524f, 0.03935855f, -0.02722776f, 
    0.04659308f, 0.02907725f, 0.00128288f, 0.02684245f, 0.10811432f, -0.00461496f, -0.05619566f, 0.09797016f, 
    -0.25527388f, -0.21728019f, -0.12873052f, -0.11787748f, 0.04347813f, 0.10679917f, -0.06380094f, -0.06488629f, 
    0.13932273f, 0.03848350f, 0.10177279f, -0.01293753f, 0.08972827f, -0.08526251f, -0.05201883f, 0.02684921f, 
    0.03012832f, 0.04093244f, 0.05250197f, -0.05103722f, -0.10471714f, -0.04636635f, -0.07103584f, -0.26252687f, 
    0.02610544f, 0.09460571f, 0.15578067f, -0.14206661f, 0.03642382f, -0.08692326f, -0.02697855f, 0.06266809f, 
    0.05495225f, 0.05802947f, -0.01756750f, 0.03511243f, 0.21385926f, 0.28060517f, 0.12367322f, -0.05158355f, 
    0.09243932f, 0.03795658f, 0.12950793f, 0.07684159f, 0.13842770f, -0.03693371f, 0.10143427f, 0.15885404f, 
    0.11012943f, -0.20604602f, 0.06386703f, 0.08066210f, -0.06398871f, -0.01188096f, -0.08067129f, -0.08074253f, 
    -0.07548756f, -0.18003497f, -0.08358874f, -0.16713975f, 0.02710899f, -0.09782147f, -0.04487762f, 0.01151349f, 
    0.14523676f, 0.06416171f, 0.01536879f, 0.06757675f, 0.01374920f, 0.01934125f, 0.08517049f, 0.06461830f, 
    0.03999099f, -0.03358090f, -0.01313265f, -0.13283901f, -0.12131398f, -0.07842974f, -0.07930030f, -0.03485514f, 
    0.12106388f, 0.12157536f, 0.04804181f, 0.10570211f, 0.14276187f, -0.08039698f, -0.16134106f, -0.16187423f, 
    0.10646793f, 0.10526099f, 0.03384212f, -0.05675332f, -0.01205673f, -0.07349143f, 0.14119463f, -0.03296159f, 
    -0.51078993f, -0.08069634f, -0.05183848f, 0.10543524f, -0.08962923f, -0.05349489f, 0.01102447f, 0.11127629f, 
    0.12947473f, 0.01683687f, 0.04829316f, 0.00080116f, -0.19401059f, -0.12777397f, -0.09154188f, 0.06695590f, 
    0.12944056f, -0.01924634f, 0.00616471f, 0.01956051f, -0.08206183f, -0.00928017f, -0.00254864f, 0.01085260f, 
    -0.09130566f, -0.08853166f, -0.00695150f, 0.09087694f, 0.01340917f, 0.02561237f, 0.11451384f, 0.00470526f, 
    0.00334745f, -0.07926225f, 0.00598212f, -0.11335275f, -0.03694469f, 0.14564143f, 0.14269979f, 0.07434722f, 
    -0.01590825f, -0.07602161f, -0.11491819f, -0.09192311f, -0.15331937f, 0.14019839f, 0.03460693f, -0.03160864f, 
    -0.05842854f, -0.09421332f, -0.06566627f, -0.03192219f, -0.07420040f, -0.03833579f, -0.09631307f, -0.07103671f, 
    0.02823905f, 0.04977364f, 0.37154984f, 0.04010946f, 0.17467840f, 0.10398114f, -0.19474956f, 0.01362314f, 
    0.03893478f, -0.01925117f, 0.00987392f, -0.09034641f, -0.02369097f, 0.00672014f, 0.07006454f, 0.17563449f, 
    -0.00947549f, 0.02402692f, -0.17254743f, -0.00187316f, 0.10383600f, -0.09533498f, 0.13062511f, 0.07454550f, 
    -0.09139599f, 0.00406662f, 0.06251101f, 0.02657964f, 0.02277313f, 0.07341554f, -0.05262109f, -0.19370441f, 
    0.03495518f, -0.00993727f, 0.11407910f, -0.08507549f, 0.11457139f, 0.04831479f, 0.16307373f, 0.08187732f, 
    0.02773427f, -0.10323718f, -0.15185080f, -0.15766963f, 0.02701513f, -0.02420649f, 0.05402392f, 0.06143426f, 
    0.00081071f, 0.01407851f, -0.11376819f, -0.00776640f, -0.15337011f, 0.11593819f, 0.07327928f, 0.09942435f, 
    -0.00584852f, -0.04663950f, -0.02928759f, -0.10681233f, -0.03320791f, -0.15528162f, -0.04829513f, 0.00185569f, 
    0.16272128f, 0.14922227f, -0.13858828f, -0.15480280f, 0.09131851f, -0.05900896f, 0.02845584f, -0.01256177f, 
    -0.02218208f, -0.01771058f, 0.02471854f, 0.08312093f, -0.11893897f, -0.10989852f, -0.02056419f, 0.08665281f, 
    0.12680051f, 0.10728635f, 0.01070013f, 0.01564232f, 0.07309213f, 0.10546961f, 0.04637293f, 0.14294970f, 
    0.14151841f, 0.00505880f, -0.10231062f, -0.11786573f, 0.08726986f, 0.10277324f, -0.02416987f, 0.08534496f, 
    0.03442512f, -0.07670725f, 0.01380496f, -0.14226647f, -0.11496389f, 0.19196361f, -0.16382393f, 0.04422372f, 
    0.03559050f, -0.06493329f, 0.01780878f, -0.00691449f, 0.07488763f, 0.00513045f, -0.03529393f, 0.14297427f, 
    0.03967521f, 0.06881714f, 0.12142755f, 0.06486130f, 0.00148325f, -0.11238893f, -0.05473575f, -0.12502530f, 
    0.03602523f, -0.11376087f, -0.06058392f, -0.01328530f, 0.10179643f, -0.02597875f, -0.03689158f, -0.31447417f, 
    0.12452024f, 0.10482401f, 0.04678246f, 0.15328382f, 0.07125670f, 0.12363516f, 0.04908819f, 0.00168654f, 
    0.41678965f, -0.09581111f, 0.09554143f, -0.36329496f, -0.08048170f, -0.05365293f, -0.09381323f, 0.08291308f, 
    0.13803256f, -0.04817703f, 0.07083742f, 0.09090024f, -0.03567351f, 0.08203738f, 0.22223151f, 0.12214193f, 
    0.00848663f, -0.02071304f, -0.02212778f, -0.03564737f, 0.13456851f, -0.08867775f, 0.00020903f, 0.08226391f, 
    -0.02631773f, -0.04526572f, -0.02032612f, 0.01375476f, -0.00126866f, 0.00664424f, 0.03415393f, 0.01314954f, 
    0.01009760f, -0.04858965f, -0.00486058f, 0.01446036f, -0.04294033f, -0.02034839f, -0.02622421f, 0.01491024f, 
    -0.07491889f, -0.01178042f, -0.03884902f, 0.01329110f, -0.01878129f, -0.03790256f, -0.01816791f, -0.02303242f, 
    0.00953005f, -0.00234300f, 0.01593441f, -0.00368258f, 0.00910569f, 0.02982076f, 0.01186538f, -0.01192846f, 
    -0.02607096f, -0.00309904f, -0.00739106f, -0.01595201f, -0.00628152f, 0.00978685f, 0.00462280f, -0.01011517f, 
    0.01400046f, 0.00516453f, -0.03588527f, 0.02546401f, 0.00759369f, 0.00526397f, 0.03244762f, 0.00582345f, 
    0.00711952f, -0.01236713f, -0.03250623f, -0.03169986f, 0.00169877f, -0.04831117f, 0.00836865f, 0.02974696f, 
    -0.05960734f, 0.01510680f, 0.02065451f, -0.06030321f, 0.02126312f, -0.00765674f, -0.02999907f, 0.01371964f, 
    -0.01045887f, -0.03515290f, -0.05706625f, -0.02770179f, 0.01171667f, 0.02956725f, -0.04827226f, 0.01109629f, 
    0.02876422f, -0.02788533f, -0.02225465f, 0.00814777f, -0.03660341f, -0.03561688f, 0.01995723f, -0.04623171f, 
    -0.02879821f, -0.01803937f, -0.01058822f, 0.01287307f, -0.05450676f, -0.00688285f, -0.02986153f, 0.03601407f, 
    -0.04703732f, 0.04111629f, -0.03062208f, 0.00254456f, -0.02431041f, -0.00641080f, 0.01329727f, -0.02400184f, 
    -0.06461400f, -0.00977692f, -0.03378595f, 0.00502643f, -0.03544680f, -0.05677251f, -0.03671022f, -0.02708622f, 
    0.03630358f, -0.04616898f, -0.01818139f, -0.03748218f, 0.03736764f, -0.05425374f, -0.01568936f, -0.00378422f, 
    -0.05346528f, 0.03964788f, -0.01034948f, 0.02464423f, -0.03841887f, -0.05027118f, -0.02862547f, 0.01781052f, 
    0.03788592f, -0.00584259f, -0.02928818f, -0.02192285f, 0.00393606f, 0.03564829f, 0.03234468f, 0.03337594f, 
    -0.05734105f, -0.00193814f, 0.01322501f, -0.01851867f, -0.03370996f, -0.05105666f, -0.03519339f, -0.02926486f, 
    -0.05497692f, 0.00227985f, 0.01284439f, -0.03995606f, 0.04274615f, -0.00549248f, 0.00400617f, -0.01642130f, 
    0.00241912f, 0.00449966f, -0.03873518f, -0.04407381f, 0.02929438f, -0.05129728f, 0.00805727f, -0.05260964f, 
    0.01893334f, -0.05499136f, -0.06820727f, 0.01739686f, -0.04171209f, -0.05009181f, 0.01662046f, -0.04435151f, 
    -0.01727525f, -0.00510556f, 0.03564250f, 0.00426321f, 0.00312129f, -0.05290358f, -0.04366044f, 0.01615644f, 
    0.01270068f, -0.07243768f, -0.05587576f, -0.02693490f, -0.04165943f, -0.04576113f, -0.03056087f, 0.02022407f, 
    -0.06257026f, 0.00179223f, -0.01747153f, -0.03768537f, -0.00531863f, -0.03817831f, 0.00571077f, -0.04871900f, 
    0.02988741f, -0.00009077f, 0.01749838f, 0.01953542f, 0.04355080f, -0.05379930f, -0.01033521f, -0.04121560f, 
    -0.04346944f, -0.02541024f, -0.03356842f, -0.05356031f, 0.00734587f, -0.02044826f, 0.02079682f, -0.03790460f, 
    -0.01818913f, 0.02388687f, -0.04820436f, -0.02295972f, -0.06707471f, -0.01675295f, -0.04233333f, -0.07211205f, 
    -0.02402995f, -0.02635164f, -0.02509793f, 0.03771394f, -0.01779695f, -0.00599468f, -0.05388828f, 0.01431018f, 
    -0.06893019f, -0.02473698f, -0.03140086f, -0.01838527f, 0.00698272f, -0.02377992f, -0.07282154f, 0.04471201f, 
    -0.06287394f, -0.02512303f, -0.04492382f, -0.00112769f, -0.04036117f, 0.01863368f, -0.03493359f, 0.02268896f, 
    -0.00291145f, -0.04706869f, 0.01437937f, -0.01826832f, -0.01264856f, -0.02670027f, -0.01477403f, -0.00360902f, 
    0.02135115f, -0.02187069f, -0.02110620f, 0.01936029f, 0.00590298f, -0.00867051f, -0.04223031f, -0.03458479f, 
    0.00794218f, 0.05013430f, -0.03950589f, 0.01277934f, -0.02786799f, -0.00258568f, 0.00862253f, -0.00779578f, 
    0.04164116f, 0.01574606f, 0.03378549f, -0.02706641f, -0.03165117f, 0.02352560f, -0.00251425f, 0.02998921f, 
    0.01042245f, -0.01004642f, 0.01246660f, -0.01080035f, -0.04941559f, -0.02379332f, -0.02276614f, 0.00574491f, 
    -0.03304952f, -0.02894800f, 0.02854777f, -0.03559713f, 0.00233948f, 0.03375440f, -0.04019079f, -0.02602305f, 
    0.00499833f, -0.03828220f, -0.06930228f, 0.02082929f, -0.00526542f, -0.02467497f, -0.08158676f, -0.02466532f, 
    -0.03174205f, -0.03815237f, 0.01353560f, 0.00960692f, 0.01414562f, -0.01756735f, -0.06093943f, -0.04779235f, 
    0.03046804f, -0.02114957f, 0.02292395f, 0.00258801f, -0.04316368f, 0.00490497f, 0.02141483f, -0.01640714f, 
    -0.04359770f, 0.00829153f, -0.01605104f, 0.03797647f, -0.00940260f, -0.05047613f, -0.01671045f, -0.03607760f, 
    -0.02028596f, -0.05275628f, 0.02413570f, -0.01748591f, -0.01065558f, -0.01802207f, 0.01988048f, -0.05458558f, 
    -0.03873158f, -0.04991073f, -0.04652020f, 0.01050524f, -0.05188461f, -0.00614883f, 0.04177427f, 0.02384974f, 
    -0.04457128f, -0.00313879f, -0.06081324f, 0.03931896f, -0.05545033f, 0.04302539f, -0.02317009f, -0.04396900f, 
    -0.01097173f, -0.05125767f, -0.02137528f, -0.05281167f, 0.02937571f, -0.05763640f, 0.02119776f, 0.01714416f, 
    -0.05499782f, -0.00219589f, -0.03538608f, -0.05055869f, 0.00242676f, -0.02440157f, 0.01131441f, -0.00214851f, 
    -0.03427869f, 0.04429441f, -0.03923535f, 0.03827473f, 0.04221747f, -0.00995264f, -0.03236194f, 0.01950478f, 
    0.01374569f, 0.03959356f, 0.01701193f, -0.00775626f, -0.00311932f, -0.02561358f, -0.02013337f, -0.01295087f, 
    -0.02238103f, 0.00284300f, 0.00648118f, 0.02081459f, 0.02035916f, 0.01161548f, -0.00370240f, -0.04082216f, 
    0.03387117f, -0.00496498f, -0.04821189f, -0.05910600f, -0.03798434f, -0.00831328f, -0.06785394f, 0.03486018f, 
    0.03377323f, -0.01128739f, -0.03978579f, 0.04162380f, 0.04320720f, 0.00884424f, 0.00990103f, 0.02029068f, 
    -0.00726501f, 0.04253740f, 0.01578278f, -0.03163695f, -0.01374896f, 0.00147260f, -0.05110661f, 0.01864038f, 
    -0.04971262f, -0.01482033f, -0.02996789f, -0.04226801f, 0.02799753f, 0.01693351f, 0.00404709f, 0.03179000f, 
    0.00760487f, 0.00319825f, -0.04441379f, 0.01883356f, -0.03668551f, -0.02924286f, -0.02604031f, 0.00843497f, 
    0.04428941f, 0.01042100f, 0.03730469f, -0.01538637f, -0.00698864f, 0.02157487f, -0.00715129f, -0.04984904f, 
    0.01712556f, 0.03587085f, -0.00538616f, 0.02420315f, 0.02792404f, 0.01381107f, 0.04067905f, -0.01347159f, 
    -0.00668487f, -0.00901890f, -0.00968216f, 0.02019607f, -0.02854981f, -0.00405929f, -0.02860162f, 0.01670336f, 
    0.01807262f, 0.02519896f, -0.01076378f, -0.04536506f, 0.01784277f, -0.01340392f, 0.03662068f, -0.05185938f, 
    -0.00869619f, -0.02211566f, -0.03029083f, 0.02685270f, 0.01778400f, -0.00568595f, -0.00765063f, -0.01043117f, 
    0.02664460f, -0.04231225f, 0.03540133f, 0.04525498f, -0.01415294f, -0.05442868f, 0.00155946f, 0.02359741f, 
    -0.03061960f, -0.03275445f, 0.01273348f, -0.00195651f, -0.02407906f, 0.03383095f, 0.03481316f, -0.01551133f, 
    0.02450237f, -0.01271617f, -0.01408406f, -0.03110687f, 0.00387615f, 0.04285493f, 0.05406614f, -0.03189055f, 
    -0.05222708f, 0.03051401f, -0.01428434f, -0.04257124f, -0.05546790f, -0.05349043f, -0.00802845f, 0.04618749f, 
    -0.03504980f, 0.02037371f, 0.00267522f, -0.03712318f, 0.02402546f, 0.03735998f, 0.04971776f, -0.04627293f, 
    -0.03358684f, -0.00012243f, -0.03043786f, 0.04036233f, -0.01659257f, -0.01568714f, 0.00935526f, 0.01430253f, 
    -0.01843380f, -0.02024904f, -0.04869891f, -0.05537557f, 0.03211434f, 0.03183237f, 0.03881611f, -0.01694617f, 
    -0.01040838f, -0.04350610f, 0.04117468f, 0.02508906f, -0.03815125f, -0.00844110f, 0.03609983f, 0.05158138f, 
    -0.01029688f, 0.01271954f, -0.00594716f, -0.03443985f, 0.00262040f, 0.02317310f, -0.03547976f, -0.02536992f, 
    -0.02421518f, -0.00220030f, 0.00697094f, -0.03325232f, -0.04222528f, -0.02265657f, -0.03099889f, 0.04341889f, 
    -0.04236066f, -0.03488121f, 0.04128166f, 0.00705400f, -0.03462982f, -0.04045264f, 0.00070602f, 0.00511965f, 
    -0.01019118f, 0.02520492f, -0.03586046f, -0.00654677f, 0.00572867f, -0.04311904f, -0.00773295f, -0.02000717f, 
    0.00159249f, -0.04927021f, -0.03584505f, 0.02193145f, 0.02277228f, -0.01019771f, 0.02922172f, -0.00590662f, 
    0.02495780f, 0.04453958f, -0.03412753f, -0.04344922f, -0.00021355f, -0.05502523f, -0.00630325f, -0.05043731f, 
    -0.00212129f, -0.01600840f, -0.03473387f, -0.04203277f, 0.02245531f, -0.02373536f, 0.03865030f, 0.02766190f, 
    0.01086599f, -0.02655102f, 0.04088758f, -0.03742035f, -0.01535069f, -0.05302381f, -0.00344082f, -0.01375260f, 
    0.03762155f, -0.03363749f, 0.02393020f, -0.00696645f, 0.01608836f, -0.00803885f, -0.00808589f, -0.00677304f, 
    0.00636184f, -0.03275504f, -0.00669895f, -0.04202945f, -0.04932860f, -0.01328698f, -0.01914325f, -0.05093090f, 
    -0.01373522f, -0.02890357f, -0.01202576f, 0.02041309f, 0.03671268f, -0.02973066f, -0.04477958f, -0.02385512f, 
    0.01318732f, -0.05247967f, 0.00393992f, 0.00131828f, -0.01883501f, -0.00478850f, 0.03496056f, -0.04289698f, 
    -0.00979326f, -0.00798820f, -0.04986975f, 0.01452179f, -0.02090560f, -0.02715325f, -0.00565458f, 0.03126065f, 
    -0.01925189f, -0.03440496f, 0.05062282f, -0.03704941f, -0.01571300f, -0.02515422f, -0.04552945f, -0.03488246f, 
    -0.00405574f, 0.04546029f, -0.00776662f, -0.03510577f, -0.03742095f, 0.04454315f, -0.01840414f, -0.00658523f, 
    -0.00300433f, 0.03889298f, 0.03446439f, 0.03717136f, 0.02075630f, -0.02802356f, 0.02339096f, -0.05550975f, 
    -0.01325424f, 0.03974081f, -0.03354070f, -0.02900682f, -0.04343209f, -0.03150708f, 0.02854258f, -0.01051968f, 
    0.04467304f, -0.00885865f, -0.00133207f, -0.04915432f, 0.01134865f, -0.00777774f, -0.04513860f, -0.04013972f, 
    0.05148230f, 0.01095310f, -0.00977322f, -0.00908752f, -0.00319202f, -0.00401508f, -0.03305639f, -0.00652782f, 
    0.04714070f, -0.04915327f, -0.00886132f, -0.01389803f, 0.03054857f, -0.01587012f, -0.00421754f, -0.04060707f, 
    -0.00424348f, -0.01222112f, 0.03207617f, -0.04402913f, -0.05150544f, -0.00467899f, -0.01842230f, -0.00583773f, 
    0.01901111f, -0.04479837f, -0.00836893f, -0.00056806f, -0.02991242f, -0.01574062f, 0.03280094f, -0.03640382f, 
    -0.03471050f, -0.01442826f, -0.05148189f, -0.02739894f, -0.02041441f, -0.03554122f, -0.02658652f, 0.02978216f, 
    0.03741749f, 0.00391215f, -0.01611277f, 0.03550522f, 0.01627223f, -0.04412587f, 0.04464189f, 0.00496633f, 
    -0.04087757f, 0.01625572f, -0.04374189f, 0.02171727f, 0.00657232f, -0.04808170f, 0.03680056f, -0.04497961f, 
    0.03214338f, -0.00539840f, -0.01330088f, -0.02548141f, 0.03848911f, 0.01009668f, -0.01787361f, -0.04480538f, 
    0.02734188f, -0.00901074f, -0.03206367f, -0.01668627f, -0.01529378f, 0.00332799f, -0.04512341f, -0.02832817f, 
    -0.05088149f, 0.03281116f, 0.01352207f, 0.02202116f, 0.01146419f, -0.00519527f, 0.01876258f, -0.05263528f, 
    0.00875381f, -0.04847002f, -0.02304422f, -0.05272313f, -0.03018228f, -0.01901096f, -0.01808786f, -0.05411624f, 
    -0.01268727f, -0.05386000f, -0.01614032f, -0.04190406f, -0.00126948f, 0.01296382f, -0.01623709f, -0.04412211f, 
    -0.02279952f, -0.02945762f, -0.00450497f, 0.03105587f, 0.00165071f, 0.03831223f, 0.03816874f, -0.04064891f, 
    -0.11263598f, 0.02150708f, 0.14138502f, 0.03592492f, 0.15461811f, -0.03916486f, -0.12579820f, -0.01934950f, 
    0.05276817f, 0.05909558f, 0.22188002f, 0.06778757f, 0.04053893f, 0.02707759f, -0.13148998f, -0.14905150f, 
    0.05927778f, 0.00982658f, 0.00869259f, -0.08305633f, 0.11412465f, 0.04780836f, -0.14522837f, -0.23020814f, 
    -0.03496013f, 0.16069750f, -0.15077481f, -0.07461119f, 0.09165923f, 0.01597338f, 0.06808320f, -0.04530148f, 
    0.09033887f, 0.00221868f, 0.02710536f, 0.10179710f, -0.09388535f, 0.05116207f, 0.19415548f, 0.01221852f, 
    0.08756229f, -0.12786061f, -0.11769146f, 0.00232175f, -0.23538041f, -0.00707678f, -0.12645836f, 0.10720520f, 
    0.43199158f, 0.57228410f, -0.08530812f, 0.08529068f, -0.03354789f, 0.00214089f, 0.02241581f, 0.02694302f, 
    0.06445324f, 0.14421177f, -0.07386974f, -0.08722822f, 0.02357915f, 0.23445402f, 0.37936771f, 0.03666374f, 
    0.02196557f, -0.04230541f, -0.04443447f, -0.08272339f, 0.00872601f, -0.08100969f, 0.04821170f, -0.00808039f, 
    0.07575873f, 0.05774374f, 0.32546675f, 0.27036929f, 0.10414826f, 0.10954776f, -0.00293305f, -0.11290060f, 
    -0.02134926f, 0.10003493f, 0.10166520f, 0.12080640f, -0.15222055f, -0.07544984f, 0.05312437f, 0.05734038f, 
    -0.01815150f, 0.00873473f, -0.01901769f, -0.01840592f, 0.17187786f, 0.18342003f, 0.21009895f, 0.10541979f, 
    0.17429191f, 0.01093089f, -0.06241255f, -0.05165672f, -0.09821157f, -0.05650396f, -0.17035340f, 0.02578714f, 
    0.03426768f, -0.07460670f, 0.11726928f, 0.07919909f, 0.06330968f, 0.09495183f, -0.04039817f, -0.09051959f, 
    0.06605305f, 0.01154860f, 0.12737262f, 0.01692001f, -0.03671055f, 0.01123948f, 0.09288233f, 0.00383598f, 
    -0.15115838f, 0.10434759f, -0.07563113f, -0.04591639f, -0.06992032f, 0.07334314f, 0.18747456f, -0.10436741f, 
    0.17262651f, 0.25530854f, 0.00426024f, 0.20684974f, 0.03024438f, -0.11745321f, -0.19611815f, -0.09982131f, 
    0.04586802f, -0.06827196f, 0.01816102f, -0.02648456f, -0.07097171f, -0.07277466f, -0.11665872f, -0.09859664f, 
    -0.09919238f, -0.20184548f, 0.04442246f, -0.22252305f, 0.01000226f, 0.04268390f, -0.05768142f, -0.15667513f, 
    0.06214747f, -0.02623611f, -0.01658496f, 0.22933841f, -0.01557890f, -0.13013460f, 0.04548100f, 0.00129637f, 
    0.02697414f, 0.07557385f, -0.00822370f, 0.05442890f, -0.02409335f, 0.06028111f, 0.15804182f, 0.17318574f, 
    0.00283553f, 0.20574829f, 0.08567160f, 0.29140434f, -0.01650602f, -0.17563120f, 0.02367549f, 0.00802916f, 
    -0.10489929f, -0.01548423f, 0.11020517f, -0.04422344f, -0.31284344f, -0.11078201f, 0.17067677f, 0.12033893f, 
    0.13849862f, 0.19085281f, 0.10257603f, 0.03795531f, -0.08035147f, -0.21879782f, 0.00051338f, -0.08505212f, 
    -0.34212920f, -0.04334444f, -0.02446412f, 0.22691168f, 0.02241259f, 0.04210153f, 0.03060842f, -0.05156322f, 
    0.07995924f, 0.04974124f, 0.10795333f, -0.07227419f, -0.03843350f, 0.05700184f, -0.03985392f, -0.00572336f, 
    -0.05703618f, 0.08057383f, -0.01361359f, 0.01507923f, -0.04389544f, 0.04038585f, 0.14521705f, -0.02155780f, 
    0.02124330f, -0.05514846f, -0.05830706f, 0.10509423f, -0.18818222f, 0.01383035f, -0.07700086f, -0.01608695f, 
    -0.07591282f, -0.10800782f, 0.08584642f, -0.06554412f, 0.02681851f, -0.01923621f, -0.12768778f, 0.01679329f, 
    0.16079006f, 0.06955419f, -0.07405984f, -0.01368584f, 0.02175809f, -0.02406109f, 0.04822943f, 0.12939313f, 
    -0.06421235f, -0.09757586f, -0.00273023f, -0.05417366f, 0.09826179f, 0.12341860f, 0.08295941f, 0.01856486f, 
    0.13080576f, -0.19099152f, -0.05393612f, -0.10652975f, 0.26220641f, -0.02671660f, 0.06630229f, 0.03594990f, 
    -0.01831184f, 0.03043190f, -0.05544392f, -0.06781723f, -0.01823639f, 0.09990967f, 0.00496345f, 0.16817842f, 
    -0.20915361f, -0.25528425f, -0.04638403f, -0.03003495f, 0.14576328f, 0.06457277f, -0.05056560f, -0.07596648f, 
    0.07326359f, -0.12428703f, -0.16719998f, -0.08672514f, -0.34687924f, -0.12999959f, -0.06283055f, -0.03780499f, 
    0.03116165f, 0.07508376f, 0.04198332f, 0.02987126f, -0.10545981f, 0.01526229f, -0.06962007f, -0.08645076f, 
    0.12799013f, -0.00004843f, -0.06175720f, -0.02172073f, 0.02042454f, 0.08264615f, 0.03902252f, 0.08009346f, 
    0.11837795f, 0.14507468f, 0.06402653f, 0.02912418f, -0.04610570f, 0.04548142f, -0.07511484f, -0.02358500f, 
    0.13940509f, 0.00621873f, -0.09819216f, -0.04704068f, -0.16311589f, -0.07832963f, -0.23087789f, -0.04371414f, 
    0.13316517f, 0.09739183f, -0.02592520f, 0.02752138f, -0.00790488f, 0.04798442f, 0.06980859f, 0.05049256f, 
    0.03122241f, 0.11355884f, 0.11421955f, 0.11524129f, -0.16987433f, -0.08090644f, -0.13849765f, -0.00141636f, 
    0.05910259f, 0.02804494f, -0.02647037f, 0.06578115f, -0.13551131f, -0.12587500f, -0.04434148f, -0.23422408f, 
    0.28065729f, 0.02942884f, -0.01578358f, 0.04057633f, -0.08872749f, -0.10717276f, 0.04080611f, 0.02434020f, 
    -0.06539301f, -0.01520982f, 0.13432434f, 0.09065816f, 0.22080620f, -0.06551302f, -0.08697172f, -0.16036040f, 
    0.01973206f, 0.06243098f, -0.05433351f, 0.04662747f, 0.02237022f, 0.12851238f, 0.06557451f, -0.10371046f, 
    -0.03127947f, 0.10822061f, -0.18017280f, -0.30519688f, -0.00600050f, 0.06704448f, -0.05760203f, -0.02128109f, 
    0.07610827f, -0.07034928f, 0.06319533f, 0.10811774f, -0.03426642f, 0.09325232f, 0.02688250f, 0.09191705f, 
    0.01184981f, 0.01569345f, -0.01473917f, 0.08450700f, -0.09507082f, -0.13380069f, -0.03854033f, 0.01407819f, 
    0.23703881f, 0.49420324f, 0.04269710f, 0.13184631f, 0.09710885f, 0.10371482f, -0.05967800f, 0.02021777f, 
    0.17736696f, -0.02227961f, 0.01853987f, 0.08132719f, 0.07107280f, -0.08548860f, -0.14358582f, -0.07727498f, 
    0.09938841f, 0.08410088f, 0.05717224f, 0.06805094f, -0.00154696f, -0.21959284f, -0.05200556f, 0.09993947f, 
    -0.19224048f, 0.08125982f, -0.14212160f, 0.18443991f, 0.10554670f, 0.09651051f, 0.09739058f, 0.02551113f, 
    0.05531041f, 0.02813315f, 0.04172896f, 0.09201138f, -0.06403305f, 0.02593323f, -0.05081703f, 0.17905055f, 
    0.13544343f, -0.09057065f, 0.04446447f, -0.00635714f, 0.00386232f, -0.04750973f, -0.13936420f, 0.02514545f, 
    0.23017560f, 0.18877575f, -0.06112725f, 0.00824604f, 0.00092356f, 0.15863356f, -0.01017005f, -0.06588266f, 
    0.12844555f, 0.05984320f, -0.06871533f, 0.14385219f, -0.03957069f, 0.35205334f, 0.09468411f, -0.01762058f, 
    -0.09314949f, 0.05111573f, 0.00144872f, 0.02231769f, 0.04136585f, -0.04488968f, 0.09959099f, -0.05437851f, 
    0.14658444f, 0.16021141f, 0.30330732f, 0.25565937f, 0.05518303f, 0.03079933f, 0.14014827f, 0.04558387f, 
    0.01036768f, 0.03233747f, -0.02153280f, 0.02496687f, -0.02567563f, 0.18132141f, -0.06367554f, -0.03395470f, 
    0.00454631f, -0.02308967f, -0.12477623f, -0.05993044f, 0.09398986f, 0.00623764f, 0.17154732f, 0.13398610f, 
    -0.25483155f, 0.05513990f, -0.17879789f, -0.15539597f, -0.04413412f, -0.11699353f, -0.12247700f, 0.04990648f, 
    -0.06635097f, -0.00898657f, -0.01140818f, -0.09957916f, 0.06638700f, 0.17007232f, -0.10070204f, 0.13965420f, 
    0.02147425f, 0.04303056f, 0.13028033f, 0.05847076f, -0.10496704f, -0.04599307f, -0.07494090f, -0.00383520f, 
    0.09684093f, 0.18442431f, -0.06779585f, 0.06480004f, -0.03130827f, 0.09929504f, -0.13593104f, -0.10443272f, 
    0.15693839f, 0.16005838f, 0.04708588f, 0.05600644f, -0.14142258f, 0.09692455f, -0.06079886f, 0.18966241f, 
    0.00746603f, 0.14172475f, 0.04447999f, -0.12587444f, -0.08199858f, -0.09027032f, -0.01256254f, -0.19054668f, 
    -0.21956767f, 0.03624932f, -0.09706450f, -0.02276515f, -0.02791592f, 0.09581975f, -0.04974411f, -0.07299842f, 
    -0.00642489f, -0.05077893f, 0.04401481f, 0.00579858f, -0.05207774f, 0.26236656f, 0.05501461f, 0.25749111f, 
    -0.02591828f, 0.08437377f, 0.11337012f, 0.02101406f, 0.10047775f, 0.02366282f, -0.00500842f, 0.06883233f, 
    0.24787371f, -0.04976002f, -0.09397136f, 0.18213537f, -0.16981092f, -0.10108627f, -0.07147820f, -0.24287948f, 
    -0.02241717f, 0.09627536f, 0.10059337f, -0.00117873f, 0.16161753f, 0.03172194f, 0.02335983f, -0.07622318f, 
    -0.01656316f, -0.04609157f, -0.11670673f, -0.05910588f, -0.07904911f, -0.03320331f, -0.00934009f, -0.04929044f, 
    -0.25512955f, -0.20498364f, 0.10390148f, 0.00250585f, -0.01139669f, -0.06328481f, -0.06055108f, -0.06588726f, 
    -0.04554412f, -0.02120385f, 0.01261263f, 0.06446139f, 0.06844670f, -0.11582140f, -0.05913305f, -0.03392899f, 
    0.04289787f, -0.03131996f, -0.08274831f, 0.12254783f, -0.07357860f, -0.04864064f, 0.21381791f, 0.02475327f, 
    -0.09836488f, -0.02759667f, -0.20703067f, 0.05931357f, -0.00989634f, -0.04606080f, -0.06879287f, 0.06266063f, 
    -0.10894734f, -0.07463364f, -0.02452298f, 0.08080108f, -0.04213897f, 0.00516443f, -0.34900892f, 0.33462584f, 
    0.28144136f, -0.15406337f, -0.00498883f, -0.07019377f, 0.00104958f, -0.02478782f, 0.02570293f, 0.10277499f, 
    -0.20535176f, -0.43534708f, 0.15934955f, -0.17941524f, 0.01242320f, 0.05434376f, 0.03558470f, 0.09457434f, 
    -0.03071312f, -0.05555492f, -0.01586642f, -0.00432995f, -0.03365418f, 0.01128965f, 0.11611191f, 0.01879469f, 
    0.07795852f, -0.03465613f, -0.02747464f, 0.02779546f, 0.04180672f, -0.00012571f, 0.02412253f, 0.18114419f, 
    -0.08165132f, -0.33493161f, -0.08222492f, -0.29755270f, 0.05180397f, -0.06097328f, 0.03430011f, -0.05600499f, 
    -0.02529231f, -0.12409535f, -0.05852554f, 0.06395412f, -0.14278480f, -0.10425532f, -0.02529677f, -0.07571521f, 
    -0.14891852f, -0.05713909f, -0.06196127f, 0.01232380f, -0.13364178f, -0.05145969f, -0.08736117f, 0.03681788f, 
    -0.11329933f, -0.13207906f, -0.13998245f, -0.10983072f, -0.10922449f, 0.19110429f, -0.05288948f, -0.10344427f, 
    0.03636721f, -0.05470049f, 0.08383198f, 0.12474235f, -0.02629456f, -0.04419132f, -0.03810934f, 0.02413502f, 
    0.05013410f, -0.00569217f, 0.14582962f, -0.03938275f, -0.07887146f, 0.12297128f, -0.08193457f, -0.04638385f, 
    0.05069923f, 0.10361367f, -0.00200861f, 0.22519431f, 0.06265187f, 0.17397973f, 0.11087438f, -0.13272651f, 
    0.05965007f, 0.05327497f, 0.16757257f, 0.04242703f, -0.11532369f, -0.03029500f, 0.17000611f, -0.18122923f, 
    0.00283613f, -0.05543622f, 0.00089410f, 0.05385651f, -0.03677886f, -0.11335818f, -0.12556387f, -0.01217930f, 
    -0.04789006f, -0.01527101f, -0.00699761f, -0.12324966f, -0.08371464f, -0.05252289f, -0.04695071f, 0.01927578f, 
    -0.04036966f, -0.05411354f, 0.16992931f, -0.08742054f, -0.08076642f, -0.20898423f, 0.08572023f, -0.21977319f, 
    0.08953815f, 0.06159661f, 0.10133817f, 0.02557525f, -0.10450771f, 0.01450587f, -0.02249279f, 0.16400306f, 
    0.38835230f, 0.29966262f, -0.13963777f, -0.11434826f, 0.06426424f, -0.01945575f, 0.08592133f, -0.05307740f, 
    0.07269711f, 0.07621937f, 0.15829699f, -0.02104052f, -0.03163724f, -0.03209711f, 0.06689660f, -0.03698396f, 
    0.22021501f, -0.14703791f, 0.07653198f, 0.09060912f, -0.04128973f, 0.01769733f, -0.01437752f, -0.04335375f, 
    -0.10431829f, -0.10261435f, 0.11003327f, -0.23764403f, -0.06781170f, 0.02740764f, 0.03363260f, 0.08026099f, 
    0.08502557f, 0.05180598f, -0.02305515f, 0.07791604f, -0.06973938f, 0.08064814f, 0.04811727f, -0.08580142f, 
    -0.08294038f, 0.00059087f, -0.02014113f, -0.16657661f, -0.00126662f, 0.01629492f, -0.07637619f, -0.07170931f, 
    0.09085158f, 0.04739391f, 0.21418507f, -0.24490634f, 0.05179688f, -0.01985198f, -0.06653357f, -0.01317229f, 
    0.12062763f, -0.02738239f, -0.01747032f, -0.01057067f, 0.09064344f, -0.13607906f, 0.09566668f, -0.13385324f, 
    -0.16933982f, 0.05039696f, -0.06347787f, -0.02367646f, 0.05560106f, -0.05092084f, 0.20762776f, 0.02960763f, 
    0.18667905f, 0.21853283f, -0.29988569f, 0.13867941f, -0.12154630f, -0.03855038f, 0.12061419f, 0.11028581f, 
    0.03836257f, 0.02175177f, 0.09896695f, -0.21682456f, 0.20629685f, -0.33407313f, 0.27396601f, -0.16428049f, 
    -0.06222809f, 0.05166399f, -0.03669218f, 0.08576246f, -0.06658187f, 0.08878414f, -0.01785290f, 0.01041060f, 
    -0.01316670f, -0.19499278f, 0.05655814f, -0.08280674f, -0.10330290f, -0.01955687f, -0.08258408f, 0.15157716f, 
    0.15627062f, 0.03849421f, 0.08710890f, 0.03248881f, 0.14885685f, -0.07652804f, -0.06596477f, 0.05774247f, 
    0.00465136f, 0.05499353f, 0.15239173f, 0.07431114f, -0.02595348f, 0.09722009f, -0.07124073f, -0.06316830f, 
    0.28299296f, -0.42466128f, 0.28985515f, 0.32807568f, -0.08628342f, 0.15443686f, -0.01915899f, 0.04754042f, 
    0.02317107f, 0.04361429f, -0.02021744f, 0.08453055f, -0.10661922f, -0.12868504f, 0.18286364f, -0.02754788f, 
    0.02498773f, -0.02715055f, 0.01805171f, 0.16977456f, 0.04916489f, -0.02259172f, 0.04742287f, 0.14884533f, 
    -0.08443173f, -0.31390381f, 0.03575049f, -0.22733082f, -0.03476329f, -0.09395603f, 0.04480505f, 0.05928276f, 
    -0.00776300f, 0.07713781f, -0.02951944f, -0.13118845f, 0.00241926f, -0.07256144f, 0.05525273f, -0.02814579f, 
    0.09052528f, 0.08541938f, 0.03025143f, 0.00966145f, 0.00225642f, -0.01029853f, -0.00488656f, 0.14695601f, 
    0.00666260f, -0.19016914f, 0.18210520f, -0.15659173f, -0.01479292f, 0.00085130f, 0.00649896f, 0.02867324f, 
    0.10136470f, 0.02343014f, 0.09628382f, 0.03696309f, -0.12734415f, -0.08484375f, 0.04589921f, -0.13859487f, 
    0.00411584f, 0.00255125f, 0.02127189f, 0.02264548f, -0.11202148f, 0.06163689f, 0.08304270f, 0.04151871f, 
    -0.26331854f, 0.22918180f, -0.29717427f, 0.27408159f, 0.06646176f, -0.03776480f, -0.08202700f, 0.16439644f, 
    0.07214943f, -0.00894317f, 0.01332388f, 0.15404397f, -0.49466279f, -0.12847137f, -0.29017162f, 0.18029888f, 
    0.11651379f, -0.00832612f, 0.15198570f, 0.15625666f, 0.00235786f, -0.04978412f, -0.09165443f, 0.06560317f, 
    0.03256437f, 0.05904996f, -0.25418422f, 0.13550372f, 0.03980329f, 0.17483608f, 0.23874143f, 0.03097673f, 
    0.05852176f, 0.00294084f, 0.04088485f, -0.10765697f, 0.12536716f, 0.11081393f, 0.02781993f, -0.02230686f, 
    -0.12294056f, -0.05606886f, 0.00107231f, -0.02102639f, 0.05499734f, 0.05315375f, -0.04444404f, 0.01491942f, 
    0.02780814f, -0.10088087f, 0.05961905f, -0.03605244f, -0.23023257f, -0.05237372f, -0.05484155f, -0.05296778f, 
    -0.04346761f, 0.16239938f, 0.15848616f, -0.02868229f, -0.00807588f, 0.11892521f, 0.35062855f, -0.31567293f, 
    0.06706091f, 0.05268010f, 0.00063136f, 0.13415176f, 0.04805648f, 0.03271762f, 0.07103772f, 0.05244850f, 
    -0.31175792f, 0.24172260f, -0.19844012f, 0.23806916f, 0.09086217f, 0.09820013f, 0.07824205f, -0.06732053f, 
    0.01944017f, -0.04146929f, -0.01047073f, -0.09512452f, 0.11611509f, -0.04665147f, 0.06134073f, -0.10178134f, 
    -0.12481844f, 0.10495199f, 0.02961858f, -0.00202650f, 0.09666820f, 0.00439687f, -0.01976141f, 0.01668277f, 
    -0.04068559f, 0.14980724f, -0.30083454f, -0.05560493f, 0.05196371f, 0.06829465f, 0.06177141f, 0.06356553f, 
    0.08081044f, -0.08120979f, 0.08235336f, -0.12287122f, -0.07341726f, -0.06043909f, -0.04626602f, 0.01491068f, 
    0.03321256f, -0.05736752f, 0.01475479f, 0.05385920f, 0.02626274f, -0.08560851f, 0.06112759f, -0.08051682f, 
    -0.02404579f, 0.11140185f, 0.05159815f, -0.03359626f, 0.13884112f, -0.05334052f, 0.05783637f, -0.04494069f, 
    0.05617637f, -0.01136487f, 0.02727530f, -0.05827617f, 0.09190773f, -0.01201942f, -0.05575790f, 0.18350443f, 
    -0.05349615f, 0.05436418f, 0.07072788f, 0.04113938f, 0.08312038f, -0.05446175f, 0.03710769f, 0.02117703f, 
    -0.05383699f, 0.10147437f, 0.00289011f, -0.01805688f, 0.01857311f, 0.04690545f, 0.09990609f, 0.02505238f, 
    -0.01497652f, -0.05588194f, -0.03424712f, -0.07278718f, 0.07439910f, -0.01281876f, -0.19370380f, 0.00211869f, 
    0.11616378f, -0.02997136f, -0.02347658f, 0.08407811f, 0.07117703f, 0.07682581f, 0.00890629f, 0.07081132f, 
    0.01561619f, 0.02696232f, 0.06359958f, -0.00319831f, -0.01241583f, -0.11939661f, -0.04939718f, 0.00346015f, 
    0.11021790f, -0.01829059f, -0.07832849f, 0.01514339f, 0.00649925f, 0.20080125f, -0.07066076f, 0.14022566f, 
    -0.00611926f, 0.03933967f, 0.01778116f, -0.00828280f, 0.12042892f, 0.00090573f, 0.03139518f, 0.00182299f, 
    -0.09831277f, -0.45120302f, 0.32754949f, -0.17367595f, -0.01318418f, -0.11449594f, -0.17422873f, 0.16961865f, 
    0.02824243f, 0.13018261f, -0.14236166f, 0.02922937f, 0.13004985f, 0.11583630f, 0.00405052f, 0.15169573f, 
    -0.20122090f, -0.07168394f, -0.10358518f, -0.10419170f, 0.25130674f, 0.13184789f, -0.03620898f, 0.07050860f, 
    -0.27786607f, -0.06049829f, 0.03106806f, 0.31690267f, -0.04280877f, -0.11092451f, 0.07659525f, -0.22942401f, 
    -0.05638555f, 0.03266130f, 0.05490288f, 0.12472654f, 0.02246099f, 0.01825315f, 0.13704950f, 0.22615562f, 
    -0.09175944f, -0.00801381f, -0.06087975f, 0.08716195f, -0.08166380f, 0.14604647f, -0.08706950f, -0.20140210f, 
    0.33399996f, 0.04575879f, 0.10234521f, 0.02304149f, 0.05796658f, 0.00960366f, -0.01082308f, 0.06285693f, 
    0.25393954f, 0.12771824f, 0.10996939f, 0.03427413f, 0.19941173f, 0.01820145f, 0.04338123f, -0.14666291f, 
    0.16174251f, -0.10501625f, -0.17379688f, -0.08158448f, -0.31879410f, -0.00422615f, -0.19899112f, -0.46054268f, 
    -0.35695091f, -0.43500331f, 0.26872113f, 0.02701638f, -0.08249498f, 0.08085749f, -0.17637807f, -0.24823914f, 
    -0.00665091f, 0.04438251f, 0.12870744f, 0.21767002f, 0.01899153f, -0.16337527f, -0.33622816f, -0.21947800f, 
    -0.18930142f, -0.11267447f, -0.05740563f, -0.22461718f, 0.02002212f, 0.03445891f, -0.03630098f, 0.04443906f, 
    0.49557427f, 0.01663518f, -0.09410702f, 0.16747408f, -0.05128958f, -0.09458943f, -0.01613662f, -0.23909904f, 
    0.07215015f, 0.08534376f, 0.01880814f, 0.17526889f, 0.09843634f, 0.08268961f, 0.17722905f, 0.18413039f, 
    -0.00129737f, -0.08518126f, 0.04415529f, 0.06532072f, 0.12986398f, 0.23979382f, 0.06328453f, 0.18702401f, 
    0.22141980f, 0.07536791f, 0.18346339f, -0.11273707f, -0.18472041f, 0.08972013f, -0.11634943f, -0.28197446f, 
    -0.03580861f, -0.01763380f, 0.00649482f, -0.00463107f, 0.04088217f, -0.05595116f, 0.04879103f, 0.05833517f, 
    -0.01421650f, 0.00544358f, -0.02222568f, 0.06287801f, -0.07444244f, 0.09966314f, 0.01808313f, -0.03933033f, 
    -0.04592947f, 0.13927555f, -0.05722093f, 0.02981794f, -0.01103897f, -0.08567362f, 0.10802529f, -0.07745867f, 
    0.08813175f, 0.22761220f, 0.13228093f, 0.24714661f, -0.04550140f, 0.03994276f, 0.04552349f, 0.14004295f, 
    -0.01720282f, 0.04683720f, 0.11085859f, 0.13233790f, -0.19924629f, -0.12841880f, -0.22283840f, -0.11825220f, 
    0.05030640f, -0.18202578f, 0.13607739f, -0.16292015f, -0.10575862f, -0.08939332f, 0.00768606f, -0.34096581f, 
    -0.13401115f, -0.15363638f, -0.08498274f, 0.02224768f, -0.03054661f, -0.07029944f, 0.06540322f, 0.08185679f, 
    -0.02292383f, -0.05527834f, -0.05408803f, 0.07766042f, 0.16411829f, 0.09147634f, -0.01608651f, 0.14230847f, 
    0.47159779f, 0.03436873f, -0.05132048f, -0.29889470f, -0.13679235f, -0.04425054f, -0.13661964f, -0.04201541f, 
    -0.06419848f, 0.11103895f, 0.05581599f, -0.01771340f, -0.01112161f, 0.23569866f, 0.09884055f, 0.06399268f, 
    0.07991309f, -0.02707349f, -0.01726041f, -0.07164214f, 0.08240923f, -0.15032585f, -0.03822956f, -0.22324272f, 
    -0.18069088f, 0.35338527f, 0.10954258f, 0.12553547f, 0.08863729f, 0.15936521f, -0.01482409f, 0.06475888f, 
    -0.02034351f, -0.06395543f, -0.04019801f, 0.05547581f, 0.13476917f, 0.07943976f, 0.06727191f, 0.09139323f, 
    -0.15928073f, 0.02965491f, 0.01321649f, -0.04108128f, -0.00444343f, 0.06175563f, -0.05104087f, 0.10876098f, 
    0.11602818f, -0.09233209f, 0.12702443f, -0.43813545f, -0.06020286f, -0.19687498f, 0.06330353f, -0.21563379f, 
    -0.21471253f, -0.14332460f, -0.38632870f, -0.12514070f, 0.15169978f, 0.12453364f, 0.28411281f, 0.06264266f, 
    0.15711673f, 0.04395820f, 0.06623779f, 0.20381719f, 0.02809897f, 0.04386470f, 0.01289374f, -0.05728428f, 
    -0.04707206f, 0.32917666f, 0.09361134f, 0.30194104f, -0.02518490f, 0.18379891f, -0.02801252f, 0.22658214f, 
    0.01032861f, -0.13130882f, -0.12357775f, -0.10315542f, 0.13163075f, -0.19308749f, 0.17015226f, -0.02638119f, 
    -0.15782905f, 0.02638990f, -0.22311290f, -0.14574383f, 0.01052671f, -0.00234368f, -0.03197112f, 0.06016882f, 
    -0.20207928f, 0.26841271f, 0.10789826f, 0.20386361f, 0.03633333f, -0.04922212f, -0.03992422f, 0.00710433f, 
    -0.17374080f, -0.23561022f, -0.04629947f, -0.30761069f, 0.18587647f, 0.04315441f, 0.01653490f, 0.09795443f, 
    0.26763657f, 0.00705452f, 0.09065675f, 0.08953828f, -0.17163622f, -0.00793107f, -0.01172972f, -0.00756656f, 
    0.30666077f, 0.10489197f, 0.20049168f, 0.30117786f, 0.02852438f, 0.05001434f, 0.07533427f, 0.26879993f, 
    0.16969302f, 0.26895523f, 0.06050279f, -0.20303838f, 0.05696200f, -0.02367178f, -0.04515424f, -0.27713415f, 
    0.10486840f, -0.04423874f, -0.00899461f, 0.01300254f, -0.23824434f, -0.15191822f, -0.20543067f, -0.14972439f, 
    0.13757721f, 0.12378211f, 0.14453846f, 0.21860965f, 0.02119474f, 0.08405174f, 0.01218766f, 0.06899770f, 
    0.07353250f, 0.16925390f, 0.11065128f, 0.18346608f, -0.12502104f, -0.07716985f, 0.06054073f, -0.03996766f, 
    0.14586800f, 0.06647612f, -0.14783444f, -0.05798075f, -0.35646185f, -0.20914488f, -0.08788912f, -0.35306475f, 
    0.00831151f, 0.03245141f, 0.13181025f, 0.13957995f, -0.04096556f, 0.07573327f, 0.08038028f, -0.12987845f, 
    -0.02249403f, 0.20209396f, 0.18053868f, 0.20653237f, 0.18705146f, 0.16461800f, 0.09266311f, 0.35853001f, 
    -0.01874492f, 0.07751538f, -0.00091114f, 0.07615192f, 0.04208397f, -0.03687305f, 0.13882431f, -0.06443681f, 
    -0.01571555f, 0.25646579f, 0.04081810f, 0.01910094f, 0.18366578f, 0.10179023f, 0.16152306f, 0.04076805f, 
    -0.07580797f, 0.10388423f, 0.00043278f, 0.04545603f, 0.32798356f, -0.05269300f, -0.04789654f, -0.22905339f, 
    -0.25218096f, -0.15384874f, -0.03962499f, -0.10557815f, -0.10483297f, -0.05789880f, 0.07991876f, -0.03323786f, 
    0.03565455f, 0.19580266f, -0.11325099f, 0.20385009f, -0.07720786f, 0.08166515f, 0.10467552f, 0.18034129f, 
    0.15833680f, -0.03634823f, 0.12689619f, 0.08448812f, 0.05408083f, -0.04600880f, 0.18813425f, 0.01110946f, 
    -0.06827152f, -0.01188445f, 0.01676168f, -0.06196472f, -0.06823064f, 0.16690838f, -0.18508282f, -0.10423844f, 
    -0.32426170f, 0.10524263f, 0.14015426f, 0.03263747f, 0.05965822f, -0.08299852f, -0.00711183f, -0.05057023f, 
    -0.01124287f, -0.06138599f, -0.00731917f, 0.05942479f, -0.09472970f, 0.05780887f, 0.01060547f, -0.03583837f, 
    -0.03105334f, 0.03410589f, -0.05331321f, -0.06809620f, 0.01417101f, -0.07007510f, 0.09442984f, 0.05431226f, 
    0.57841051f, 0.14695810f, -0.23919949f, 0.17288525f, -0.13758934f, -0.03454142f, 0.04088239f, 0.14263341f, 
    0.09091739f, -0.02160200f, 0.00807076f, -0.13907254f, -0.41216022f, 0.26049662f, 0.07251246f, -0.02688539f, 
    0.08132937f, 0.10820380f, 0.03319921f, 0.18764925f, 0.00506315f, 0.11127252f, 0.01893676f, -0.01903701f, 
    -0.38650295f, 0.12494268f, 0.10486674f, -0.05268292f, -0.04070064f, -0.11969167f, -0.02476150f, 0.21416700f, 
    0.03843688f, 0.06585277f, 0.04629549f, -0.00475777f, -0.00892274f, -0.01222667f, -0.00544517f, 0.14702125f, 
    0.05166559f, 0.03430209f, 0.13713342f, 0.04333519f, 0.13632171f, 0.10344268f, 0.01462972f, -0.04843621f, 
    -0.07042589f, -0.19187249f, 0.09011842f, 0.26821691f, -0.01041700f, 0.04513688f, -0.00318326f, 0.06835133f, 
    -0.03650843f, 0.09144963f, 0.03354317f, 0.02538688f, -0.27408013f, -0.26364681f, -0.01573454f, 0.05128202f, 
    0.04052769f, -0.04093501f, -0.02901214f, 0.03629705f, -0.01377580f, 0.00530886f, 0.07041533f, 0.02033699f, 
    -0.15841377f, 0.23805864f, -0.00659733f, -0.15053821f, -0.04166106f, -0.02317871f, 0.00796289f, 0.22104412f, 
    -0.02836529f, 0.08561911f, 0.02299537f, -0.09711339f, -0.07351284f, -0.04174613f, 0.05171483f, 0.06312070f, 
    -0.00930352f, 0.04219759f, -0.01358743f, -0.02304483f, -0.01870619f, 0.03308424f, 0.04333257f, -0.04197606f, 
    -0.07727563f, 0.08292682f, -0.08054391f, -0.02852595f, -0.03485501f, 0.00804093f, -0.07854383f, 0.05332446f, 
    0.11627407f, 0.15433504f, 0.07745609f, 0.01209268f, -0.17193002f, -0.10661392f, 0.18158969f, 0.12625408f, 
    0.05131021f, 0.05064293f, 0.00345900f, 0.01448852f, -0.07043745f, 0.08037387f, 0.07503026f, -0.01237489f, 
    0.14325260f, -0.22956511f, 0.06598014f, 0.21793142f, 0.16628624f, 0.00488414f, -0.01198687f, -0.05543298f, 
    0.02491094f, 0.08360628f, -0.00212546f, 0.12831083f, -0.34445438f, -0.21930572f, -0.12266386f, 0.03154819f, 
    0.03560054f, 0.11381131f, 0.12163436f, -0.05507942f, -0.04307727f, -0.06540793f, -0.10255750f, 0.01540195f, 
    0.33789206f, 0.02547173f, -0.00524416f, -0.07363933f, 0.01882274f, 0.06466645f, 0.18536972f, 0.02003947f, 
    0.04919350f, 0.07791866f, 0.01513270f, -0.00651776f, 0.08287293f, -0.16433248f, -0.03440972f, -0.27316144f, 
    -0.00584052f, -0.03501628f, -0.05599710f, -0.06742755f, 0.03744381f, -0.06486714f, 0.05395484f, -0.02158981f, 
    -0.02334979f, -0.05871609f, -0.09486056f, 0.03055920f, -0.05784140f, -0.02329274f, -0.00716535f, 0.01043208f, 
    0.10546526f, 0.10224456f, 0.02797040f, -0.02046327f, -0.28620386f, -0.02360298f, 0.36942407f, 0.11443172f, 
    0.11167589f, 0.24110338f, -0.07776264f, -0.01134922f, 0.04938668f, -0.00630565f, -0.00310636f, 0.05272625f, 
    -0.05774262f, -0.41078791f, 0.14629409f, 0.08012011f, 0.06663302f, 0.15716752f, 0.09326147f, -0.01238817f, 
    -0.00143370f, -0.08155848f, -0.02665843f, -0.04780520f, -0.05145003f, 0.08057305f, -0.00072216f, 0.11317037f, 
    0.03583000f, -0.02260578f, 0.11520673f, 0.07421120f, 0.20444536f, 0.12682512f, -0.08204871f, 0.09260917f, 
    0.10353055f, -0.11386061f, -0.02684043f, -0.02833030f, 0.11345322f, 0.12583196f, 0.25918728f, -0.08382548f, 
    0.00535632f, -0.08643627f, 0.01665844f, -0.13335955f, 0.03185893f, -0.18823369f, -0.15719618f, -0.15407622f, 
    -0.02924028f, -0.02891442f, -0.03883215f, -0.02485523f, -0.03567837f, -0.05391114f, -0.01859797f, -0.04186524f, 
    -0.29183635f, -0.19881302f, 0.04901747f, 0.08397669f, 0.07094643f, 0.13826416f, 0.02874385f, -0.13862763f, 
    -0.06520328f, -0.12122536f, -0.02602522f, -0.05482943f, 0.04017170f, -0.02416995f, -0.05092882f, -0.00489287f, 
    -0.08184759f, 0.01084147f, -0.02238560f, 0.07526104f, 0.01231381f, 0.01018395f, 0.03996544f, -0.07958262f, 
    -0.07984837f, 0.02775230f, 0.01178083f, 0.02331620f, -0.01977294f, -0.07861666f, 0.00683019f, 0.01597293f, 
    0.07559886f, 0.02679483f, -0.08781125f, 0.09652396f, 0.32718867f, -0.14229062f, -0.05478520f, -0.08982480f, 
    0.02066452f, 0.03213707f, -0.14462081f, 0.05299887f, 0.01751795f, 0.06313179f, 0.05440858f, -0.08915035f, 
    0.17417657f, 0.06537048f, -0.05971596f, -0.26174694f, -0.09159401f, 0.00233128f, -0.05585551f, 0.11824603f, 
    -0.00920502f, 0.06660431f, 0.01731097f, -0.03422735f, -0.02944569f, 0.05548697f, 0.11569414f, 0.17180632f, 
    0.00033106f, 0.03671863f, 0.00675954f, -0.13078268f, 0.05959653f, -0.02564481f, 0.04445880f, 0.05776263f, 
    -0.51887387f, 0.20263678f, 0.04630661f, 0.32835540f, 0.13651733f, -0.12019768f, 0.05707018f, -0.04399317f, 
    -0.07005853f, 0.08197425f, -0.00103376f, 0.07686920f, -0.00758785f, 0.19395535f, -0.14411472f, 0.12042404f, 
    -0.02344925f, -0.07101072f, -0.07174698f, 0.05314299f, 0.11610492f, 0.09348407f, 0.06049382f, 0.13747697f, 
    -0.00708439f, -0.05354916f, -0.01199768f, 0.01378062f, 0.00586483f, -0.04758259f, -0.02465836f, -0.03660436f, 
    -0.01901643f, -0.00935239f, -0.01757313f, -0.05247345f, 0.04233163f, 0.03973607f, 0.01876830f, -0.03471556f, 
    -0.04053828f, 0.00711093f, -0.05742919f, -0.00846325f, -0.00885660f, -0.01804997f, -0.01754755f, -0.05216608f, 
    0.01082885f, -0.02181275f, -0.01602229f, 0.01839191f, -0.01305369f, 0.00917299f, 0.00589520f, -0.00707954f, 
    0.02926796f, 0.01061722f, 0.03189196f, -0.02429523f, 0.00705438f, 0.01712336f, -0.02478395f, 0.02155424f, 
    -0.01215742f, 0.03445697f, 0.03837233f, -0.02983726f, -0.01476767f, -0.05167629f, -0.03816722f, -0.00772685f, 
    -0.02712511f, -0.03323710f, -0.05433129f, 0.00331125f, -0.03234057f, 0.00595384f, -0.05314984f, 0.00443470f, 
    0.02014958f, 0.02898590f, 0.02980788f, -0.02009179f, 0.00926290f, -0.05593384f, -0.05525819f, -0.03591945f, 
    0.00514284f, -0.02312439f, -0.01802950f, -0.00391040f, -0.03122154f, -0.03233825f, -0.00269105f, -0.01630539f, 
    -0.02526236f, -0.03688679f, -0.02965032f, -0.05401557f, 0.03405195f, -0.03055662f, -0.02197829f, 0.02789553f, 
    0.01123283f, -0.00010512f, -0.02732288f, -0.01150953f, 0.03344480f, -0.02682892f, 0.03183956f, -0.00454211f, 
    -0.01562078f, -0.03082376f, 0.04081664f, -0.04515570f, 0.00553227f, 0.03438723f, -0.03031812f, 0.03887215f, 
    0.01138182f, -0.05469070f, 0.03070330f, -0.01094982f, -0.04844883f, 0.00923978f, -0.05030090f, 0.02336118f, 
    -0.01856860f, 0.01420773f, -0.03906735f, -0.02796094f, 0.00798339f, 0.03356973f, -0.00591235f, -0.05355481f, 
    0.02582461f, -0.05760127f, -0.05377786f, -0.05172211f, -0.02418214f, -0.03745291f, 0.04316132f, -0.00291411f, 
    -0.00336042f, 0.02914306f, -0.02306044f, -0.00429992f, -0.02572171f, -0.02936765f, 0.02608053f, -0.01538691f, 
    -0.05373098f, -0.01927730f, -0.00663669f, -0.02279838f, 0.03524411f, 0.01702862f, 0.02150073f, -0.05366705f, 
    0.04340243f, -0.03853210f, 0.02097051f, 0.00096224f, 0.04201471f, 0.02730100f, -0.03099073f, -0.02396750f, 
    0.03298731f, -0.03150877f, 0.00680320f, 0.01229337f, -0.03162587f, 0.01179702f, 0.03993882f, -0.01498234f, 
    -0.01923418f, -0.00220387f, 0.03197628f, -0.01966392f, -0.02172672f, -0.01082973f, -0.03702885f, 0.02471181f, 
    0.02977072f, 0.01716211f, -0.05042655f, -0.02529355f, -0.05846422f, -0.00546020f, -0.03426063f, 0.01063536f, 
    0.01019185f, -0.03924609f, 0.02257629f, -0.02746264f, -0.01498780f, 0.03644625f, -0.03079540f, -0.00290210f, 
    -0.03438243f, 0.00044286f, -0.02191975f, 0.03284230f, -0.03487789f, 0.01175593f, 0.02068063f, -0.01570265f, 
    -0.01271860f, -0.01926710f, -0.03118044f, 0.04262599f, 0.01914705f, -0.03928884f, -0.02199524f, -0.01266139f, 
    0.00175406f, 0.01878474f, 0.03679136f, -0.00283155f, 0.00963828f, 0.03394771f, -0.03585617f, -0.01457707f, 
    0.02635193f, 0.01142941f, 0.00935477f, 0.03063300f, -0.04103804f, -0.00211336f, -0.03826360f, 0.02410468f, 
    -0.04638769f, 0.00304997f, 0.02218398f, -0.03159849f, 0.01183408f, -0.03075868f, 0.00115173f, 0.03793057f, 
    -0.04415971f, -0.05401316f, 0.00973671f, 0.01714431f, -0.00822849f, -0.02239928f, 0.03358050f, 0.00723152f, 
    -0.01691800f, -0.01523921f, 0.04075568f, 0.01422504f, -0.00152709f, 0.00557071f, 0.04197836f, -0.01653952f, 
    0.02260599f, -0.05094826f, 0.02130869f, -0.03299459f, -0.01786533f, -0.04654306f, 0.04051702f, 0.00135089f, 
    0.03231672f, -0.03232934f, 0.02536054f, -0.00844274f, 0.00339031f, 0.01265379f, -0.04017243f, -0.04441362f, 
    0.00811039f, -0.02229189f, 0.02692889f, 0.01983315f, 0.01607042f, -0.01596388f, -0.00093682f, 0.03542549f, 
    0.01229350f, 0.00884450f, 0.01401759f, -0.02507670f, 0.01011523f, 0.03964369f, -0.05512189f, -0.00711356f, 
    -0.02429561f, 0.00097179f, 0.02982315f, 0.00952049f, -0.02905645f, -0.00858719f, -0.03942347f, -0.03545658f, 
    0.04113468f, 0.00006846f, -0.00192243f, 0.00136287f, 0.04102938f, 0.00731472f, 0.02243092f, -0.02999363f, 
    -0.04007843f, -0.00443946f, 0.01057344f, 0.00132982f, -0.03724314f, 0.01156480f, -0.00715036f, 0.00644494f, 
    0.00452849f, 0.03038941f, -0.03872258f, -0.00452025f, -0.02237060f, 0.02667364f, -0.03877875f, -0.01779899f, 
    0.01544304f, 0.00641117f, 0.01800833f, -0.04193369f, -0.03298687f, -0.04103022f, -0.02238143f, 0.01092003f, 
    -0.04947221f, 0.00842339f, 0.01460223f, -0.01947122f, -0.03867714f, 0.00447469f, 0.03407742f, -0.03675384f, 
    -0.00003954f, -0.04787517f, 0.00346849f, 0.00373692f, 0.01598762f, -0.05826024f, 0.01742302f, 0.02464429f, 
    -0.03727768f, 0.02008622f, -0.02717753f, -0.05169309f, 0.00990419f, -0.05380200f, 0.00795871f, 0.01197897f, 
    -0.00690823f, -0.04682843f, -0.01424106f, -0.02272922f, -0.00576022f, -0.02674991f, -0.03411528f, 0.04112474f, 
    0.00340859f, -0.04452728f, 0.02283538f, 0.01945069f, 0.01493179f, -0.02786410f, 0.01584108f, 0.04146017f, 
    -0.05716605f, -0.04157471f, 0.03062330f, -0.03005522f, 0.03515700f, 0.03471414f, -0.05291941f, 0.01803611f, 
    0.00181492f, -0.01698771f, -0.03461560f, 0.01599065f, -0.03950145f, -0.00173739f, 0.00264737f, -0.05459847f, 
    -0.05589626f, -0.01894256f, -0.02617540f, -0.01582573f, 0.04141690f, 0.04136717f, -0.01402173f, -0.01189924f, 
    -0.02618631f, -0.04189746f, 0.02478129f, 0.02892073f, 0.03838049f, -0.02089890f, 0.00066228f, -0.00788779f, 
    0.02001526f, -0.01482154f, -0.05647409f, 0.04302962f, -0.02014607f, -0.02734270f, -0.05686759f, -0.03798573f, 
    0.02130004f, -0.01282401f, 0.02294982f, -0.01153694f, -0.01408309f, 0.01151855f, -0.02338419f, -0.03906454f, 
    -0.05722927f, -0.02664678f, -0.02751490f, -0.00440351f, -0.05491827f, -0.04516388f, -0.02127364f, 0.00180884f, 
    0.03902388f, 0.01106916f, -0.03599468f, 0.00707938f, -0.04298484f, -0.02073159f, 0.02616197f, -0.04652205f, 
    -0.05268155f, 0.03436487f, -0.00263870f, -0.00679452f, 0.02830644f, 0.03720443f, 0.00763996f, 0.01247495f, 
    -0.02790774f, 0.01881627f, -0.06011492f, 0.01460472f, 0.02828663f, -0.00270339f, 0.00109979f, 0.03392584f, 
    -0.01767565f, -0.02665025f, -0.03454785f, -0.01714815f, 0.01304438f, -0.05841791f, -0.04847850f, 0.00168662f, 
    -0.01267963f, 0.01952212f, 0.01962882f, -0.00694682f, 0.01647892f, -0.03623689f, -0.04822632f, 0.00022764f, 
    0.02846235f, 0.03075032f, -0.02245984f, -0.03477167f, 0.02958623f, 0.03139726f, -0.02319538f, 0.03048123f, 
    0.02031957f, 0.00784295f, 0.04139273f, 0.00472763f, -0.03507851f, -0.02844170f, 0.02327521f, -0.04783736f, 
    -0.04546630f, -0.00592601f, 0.03413634f, -0.03554825f, 0.04246479f, -0.00628347f, 0.01326068f, -0.01916990f, 
    -0.03654225f, 0.00373478f, 0.00533100f, -0.00370593f, 0.03877584f, -0.01109084f, 0.03291697f, -0.01201208f, 
    -0.02876889f, 0.02244752f, 0.01454356f, 0.02343996f, -0.02522753f, -0.00776469f, -0.04759445f, -0.02553280f, 
    -0.02295597f, -0.04197024f, -0.03336013f, 0.01579603f, -0.00547967f, -0.04956360f, -0.00508845f, 0.01653866f, 
    -0.04894131f, -0.00320862f, -0.04937588f, -0.00236863f, 0.01448505f, -0.03134342f, 0.02965311f, -0.01068044f, 
    0.03116492f, 0.03738236f, 0.02417285f, 0.03589015f, -0.03571074f, -0.01017081f, 0.03985048f, -0.04426292f, 
    -0.04789104f, 0.03432431f, -0.02715883f, 0.00105645f, 0.02490625f, 0.02548264f, 0.02551167f, 0.04108293f, 
    0.00335014f, 0.00745398f, -0.00027494f, -0.02609188f, -0.02103076f, -0.04571563f, -0.04965338f, -0.01864234f, 
    -0.03424856f, -0.04149401f, -0.01216331f, -0.05325415f, -0.05755355f, -0.01340038f, 0.03886633f, -0.04122183f, 
    0.01708979f, -0.05376368f, 0.00551693f, -0.04789204f, 0.00622241f, -0.00131217f, -0.02038119f, -0.02323383f, 
    -0.04445065f, -0.05188211f, -0.02484760f, 0.03349728f, 0.02758322f, -0.03372518f, 0.00117670f, 0.02735443f, 
    -0.01757757f, 0.01094720f, 0.00937518f, -0.03553660f, -0.03796770f, 0.01000150f, -0.03705269f, 0.03569055f, 
    -0.03466627f, 0.01019994f, 0.02739394f, -0.00289627f, -0.01229124f, 0.00953192f, -0.00134683f, -0.01559825f, 
    0.03093678f, -0.03694514f, -0.03753237f, 0.03973130f, 0.01313255f, -0.02093000f, 0.02238876f, 0.01502634f, 
    -0.05630444f, -0.03337078f, -0.01062505f, -0.03949057f, 0.01961298f, 0.02623116f, 0.01041628f, -0.01645452f, 
    -0.01468118f, -0.04562519f, 0.02436174f, -0.02261027f, 0.00729989f, -0.01555858f, 0.00996808f, -0.05792271f, 
    -0.02457847f, -0.01771969f, 0.02834282f, 0.04001921f, 0.03002510f, -0.00193341f, 0.01085182f, 0.03697846f, 
    -0.05269005f, 0.04237444f, -0.05199543f, -0.05179916f, -0.03806733f, 0.00981170f, 0.01402550f, 0.00461376f, 
    0.03863537f, 0.00866038f, 0.02694450f, 0.00349570f, -0.01774958f, -0.05730079f, 0.02118285f, -0.05367867f, 
    -0.00965216f, -0.04169011f, -0.03817252f, 0.02886593f, -0.02437647f, 0.01411936f, -0.04419334f, -0.03124896f, 
    -0.03419574f, -0.03795121f, -0.03361823f, -0.05214797f, 0.01150651f, 0.04104764f, -0.04426381f, -0.04922511f, 
    -0.04640036f, 0.00747654f, 0.01459323f, 0.02914746f, -0.05526949f, -0.04774097f, -0.00427855f, 0.01454876f, 
    0.01410795f, 0.02354181f, 0.03702359f, -0.03258806f, -0.00636544f, 0.03179774f, 0.00302228f, 0.00233398f, 
    0.00709033f, 0.02941782f, -0.05774162f, -0.04973877f, -0.01155094f, 0.02734819f, 0.03605394f, 0.02192887f, 
    -0.01932148f, 0.02417492f, -0.00220070f, -0.00638267f, -0.04828054f, 0.01841297f, 0.00776985f, 0.01255706f, 
    0.02895870f, -0.03206503f, -0.03467653f, 0.00416322f, -0.04955351f, -0.05863327f, -0.02858819f, 0.00931576f, 
    0.03486183f, -0.05916205f, -0.01277415f, 0.01304107f, -0.05073502f, -0.03877453f, -0.03194265f, -0.00911482f, 
    -0.03120292f, 0.00062802f, -0.01308362f, -0.02536358f, -0.00204354f, -0.04059685f, 0.00746753f, 0.03412328f, 
    -0.04432629f, 0.00495907f, -0.04968307f, -0.03791187f, -0.02964775f, -0.00780449f, 0.01543699f, 0.00456236f, 
    0.03466233f, 0.00836477f, 0.00314004f, -0.00365786f, 0.00855654f, -0.02771831f, 0.03068850f, 0.02523482f, 
    -0.04338453f, -0.04568860f, -0.03262390f, -0.02288548f, -0.05550324f, -0.04700036f, -0.03652383f, -0.02965444f, 
    -0.01056718f, 0.03281726f, -0.02851427f, -0.04870438f, 0.02257415f, 0.00468058f, -0.05583091f, 0.01477969f, 
    -0.03174520f, -0.03554193f, 0.02521492f, -0.01947960f, -0.01307089f, 0.02292269f, 0.04241967f, -0.03693539f, 
    -0.00504787f, -0.04501967f, 0.01802229f, -0.00768927f, -0.04814009f, 0.01123906f, -0.00437113f, 0.02154942f, 
    0.02883767f, -0.02217370f, -0.00218033f, -0.04422837f, -0.02157153f, -0.05433271f, 0.02429939f, 0.03922492f, 
    -0.03521747f, 0.03415165f, -0.05289463f, 0.03767162f, -0.01692576f, -0.05483405f, -0.00158259f, 0.01575814f, 
    -0.04488724f, 0.00872110f, 0.03857550f, -0.01253841f, 0.03991467f, 0.03174683f, -0.00010168f, -0.02561503f, 
    0.03313939f, 0.02071310f, -0.05261313f, 0.00192765f, -0.02831698f, -0.04567630f, -0.01802365f, -0.02661748f, 
    0.02416824f, 0.03134202f, -0.01951610f, -0.02345740f, -0.05335527f, -0.02733720f, 0.01623456f, -0.02296501f, 
    -0.20838211f, -0.12996499f, -0.07468739f, 0.32889533f, -0.00247673f, 0.03196505f, 0.06856529f, 0.03081227f, 
    -0.01472786f, -0.02337024f, 0.06192353f, 0.03401383f, 0.08009493f, -0.03354910f, 0.15512149f, 0.17765237f, 
    0.00689005f, 0.06009897f, 0.01923751f, 0.10544134f, 0.06867788f, 0.21041271f, -0.04818815f, 0.02279874f, 
    0.03064205f, 0.09478102f, 0.16563794f, 0.11228380f, 0.09222042f, -0.08283599f, 0.02979710f, 0.01151299f, 
    0.01717947f, 0.05668158f, -0.02367376f, -0.02316951f, -0.02412365f, 0.00624621f, 0.00692431f, -0.04160954f, 
    -0.01336101f, -0.02605965f, -0.05801201f, -0.05382594f, -0.04356756f, -0.10767794f, 0.11166126f, 0.06356210f, 
    -0.06712035f, -0.07403473f, -0.07021406f, 0.07568502f, -0.06954275f, -0.14819147f, 0.01741746f, 0.11361941f, 
    -0.13336745f, -0.06620692f, 0.05888082f, -0.09534327f, -0.26363614f, -0.01996378f, -0.16814966f, -0.01100465f, 
    -0.02285686f, 0.00642708f, -0.06530464f, 0.09866231f, -0.02293281f, -0.01541957f, -0.05229944f, -0.11525842f, 
    -0.20641172f, 0.02984076f, -0.20221952f, -0.05439660f, -0.00064934f, -0.09558583f, 0.10775246f, 0.10370250f, 
    0.11367351f, 0.01778547f, -0.00359553f, -0.03339744f, -0.05939198f, 0.06941929f, -0.02470254f, 0.27155140f, 
    0.06329750f, -0.03164641f, 0.04216496f, -0.01098554f, 0.07376764f, 0.01019399f, -0.11410487f, -0.16905050f, 
    0.22246854f, -0.01733591f, -0.02053649f, -0.04229261f, -0.07627659f, -0.00266797f, 0.05723200f, -0.13956296f, 
    -0.06926205f, 0.14308214f, 0.02762260f, 0.08018019f, -0.21140681f, -0.25397643f, 0.00093937f, 0.03372042f, 
    0.01690535f, -0.03159273f, 0.00209162f, -0.03966178f, 0.00309499f, 0.00578284f, 0.09662168f, 0.12627801f, 
    -0.24972491f, 0.08963537f, -0.07732486f, -0.23334241f, -0.01106967f, -0.09188644f, -0.00483292f, 0.14375621f, 
    -0.14747091f, -0.06879459f, -0.02840794f, -0.09451566f, 0.12001109f, 0.09621426f, 0.17250392f, 0.22078510f, 
    -0.00063749f, -0.07537080f, -0.00915197f, 0.11251713f, 0.06616848f, 0.02653365f, 0.04542917f, 0.09119210f, 
    -0.10019360f, -0.04152991f, -0.10177738f, -0.02600768f, -0.03420088f, 0.00119767f, 0.05101234f, 0.02071249f, 
    0.08655301f, 0.10887060f, 0.02700809f, 0.15018967f, -0.01313576f, -0.16956429f, 0.11516084f, 0.17722940f, 
    0.12153153f, -0.09592500f, -0.05398669f, -0.00046939f, -0.05978071f, 0.04977271f, -0.07501618f, -0.06506930f, 
    0.53865361f, -0.24394651f, 0.12280644f, -0.19453801f, 0.12344144f, 0.04391506f, -0.02148431f, 0.12085723f, 
    0.02037888f, 0.02916142f, -0.02802209f, -0.03334034f, -0.08133411f, -0.08914019f, 0.14122374f, 0.07859163f, 
    -0.07807865f, 0.06058252f, 0.03115863f, -0.04248890f, 0.04268229f, -0.07038265f, -0.03591340f, 0.03571851f, 
    0.35663825f, 0.20224993f, 0.15923266f, 0.02326993f, -0.08402824f, 0.02520010f, -0.02386235f, 0.06892760f, 
    0.09745035f, -0.08696162f, -0.09250731f, -0.01022288f, -0.05323307f, -0.02260973f, -0.01492303f, -0.23013686f, 
    0.00816900f, 0.00161606f, 0.06130992f, -0.02675940f, 0.04727099f, -0.02576482f, -0.06691378f, -0.02981025f, 
    -0.04648744f, -0.06425559f, 0.00592567f, -0.06787486f, 0.01251250f, -0.08513281f, 0.03217052f, 0.01469898f, 
    0.12507513f, 0.09880824f, 0.12365970f, 0.11115141f, -0.00179078f, 0.05700995f, 0.27424383f, 0.05539227f, 
    -0.16090240f, 0.13116355f, -0.05652330f, 0.04084126f, 0.04250034f, 0.00911595f, 0.04472146f, -0.01630129f, 
    0.06057597f, -0.00793850f, 0.13728009f, 0.27761945f, -0.01703781f, 0.02752658f, 0.05550849f, 0.11641616f, 
    -0.00953923f, 0.01577001f, 0.03992195f, -0.02855026f, -0.12043665f, 0.09478945f, -0.15021659f, 0.11749799f, 
    0.04670573f, 0.03541640f, 0.08900491f, -0.08846233f, 0.05129928f, 0.04138079f, -0.11255082f, 0.00520246f, 
    -0.10030343f, 0.07127504f, 0.08752456f, 0.11937999f, 0.09002154f, 0.12237088f, 0.09044449f, 0.06222980f, 
    0.03649544f, 0.07201762f, 0.06832902f, -0.06379595f, 0.06978785f, 0.01416595f, -0.00030784f, -0.01286565f, 
    -0.09602307f, -0.00018177f, -0.07306397f, -0.00614277f, 0.00594735f, -0.03783728f, 0.00107358f, -0.04593809f, 
    0.03626635f, 0.04596026f, 0.31853509f, 0.24696940f, 0.03077299f, 0.01504961f, 0.11954569f, 0.00932723f, 
    0.02968858f, 0.09831523f, -0.03396682f, -0.06218205f, 0.14656270f, -0.05243162f, -0.02615846f, -0.13220838f, 
    -0.03735797f, 0.06074924f, -0.08407556f, 0.03940873f, 0.04807473f, -0.03243080f, 0.09741036f, 0.10085584f, 
    -0.06744621f, -0.00224635f, 0.09160540f, 0.09381882f, 0.06566079f, -0.09401742f, 0.05915531f, 0.20941654f, 
    -0.01773345f, 0.01024355f, -0.09269212f, -0.01862512f, 0.19791467f, 0.01377461f, -0.04258372f, 0.04369012f, 
    -0.04407138f, -0.02474577f, -0.12876405f, -0.04596340f, 0.06373893f, 0.10963153f, 0.03806017f, -0.05573181f, 
    0.22680338f, -0.07809575f, -0.12774412f, -0.32065055f, 0.01344764f, 0.02856269f, -0.05660249f, -0.00895286f, 
    -0.08398664f, -0.00157786f, -0.13309497f, 0.05633033f, 0.10819342f, 0.17726320f, 0.07218136f, 0.31775266f, 
    -0.01983100f, -0.00914832f, -0.02439580f, 0.06893916f, 0.02393567f, 0.00800314f, 0.10550714f, 0.00397076f, 
    -0.49315417f, 0.12679024f, 0.14812326f, 0.33183774f, -0.00988600f, -0.00080874f, 0.07636086f, -0.08819203f, 
    -0.07079346f, -0.02365451f, -0.15711209f, 0.07165270f, 0.02875002f, 0.23423199f, -0.19612467f, -0.13165635f, 
    -0.06424087f, 0.01481429f, -0.07459190f, 0.01032101f, 0.02281769f, 0.06977092f, -0.06293818f, 0.13656351f, 
    -0.05112053f, 0.03569482f, -0.05591729f, 0.02072956f, 0.00376959f, -0.02919449f, -0.02106509f, -0.03646741f, 
    -0.00732647f, -0.03136891f, -0.03313149f, -0.03514484f, -0.01819305f, -0.02381247f, -0.04029792f, 0.00007780f, 
    0.00944651f, -0.01530752f, -0.04016904f, -0.03838369f, 0.00492740f, 0.01690644f, -0.04789417f, 0.00303818f, 
    0.03853402f, 0.03228808f, -0.01474408f, 0.04311313f, 0.01236242f, -0.04407788f, 0.03477814f, 0.03138586f, 
    -0.01149906f, -0.01175776f, -0.01687429f, -0.04399276f, -0.00699708f, 0.01259962f, 0.02351214f, -0.00001320f, 
    0.03136392f, 0.04086103f, 0.00891151f, 0.02604861f, -0.05636379f, -0.03798582f, 0.03706845f, -0.01121079f, 
    0.00166636f, -0.02544746f, -0.02790406f, 0.00819594f, -0.04684741f, -0.05001586f, 0.01927834f, -0.04853419f, 
    0.04018598f, -0.00029260f, 0.01737932f, -0.05819621f, -0.05565461f, 0.04315151f, 0.00468667f, 0.02379143f, 
    -0.00549303f, -0.01524856f, -0.04615461f, 0.03525662f, -0.05368626f, -0.05658569f, -0.01294386f, -0.03147612f, 
    -0.01329985f, 0.01382491f, 0.00392822f, -0.04330159f, 0.04341333f, -0.04649936f, -0.03414653f, 0.04181654f, 
    -0.03162332f, -0.01156363f, -0.04666236f, 0.03925839f, 0.01211881f, -0.02620534f, -0.00028319f, -0.02497789f, 
    0.02747533f, -0.00265902f, 0.02574561f, -0.02399668f, 0.02141074f, 0.00831368f, -0.01751336f, 0.01087865f, 
    0.01195082f, 0.02698886f, -0.02059858f, -0.01002115f, 0.01662495f, 0.01415065f, 0.01677339f, -0.05413849f, 
    -0.03637190f, -0.02862255f, 0.03464512f, 0.03954059f, -0.03532770f, -0.04932067f, -0.02572911f, -0.03185140f, 
    0.02162572f, -0.05026442f, -0.02955585f, 0.01075979f, 0.00091229f, -0.00175071f, -0.00633236f, 0.01453297f, 
    -0.01370317f, -0.02330845f, -0.05201279f, -0.00418578f, -0.02100414f, -0.03439765f, -0.03231124f, 0.01542611f, 
    0.04058807f, 0.01980602f, 0.03206319f, 0.00990027f, -0.04171233f, 0.02348037f, 0.00534730f, -0.03110206f, 
    0.01945157f, 0.01684236f, -0.05658124f, -0.03577330f, -0.03462536f, -0.02310432f, 0.02288971f, 0.00219206f, 
    0.02457367f, -0.00236917f, -0.00074406f, 0.02533218f, -0.01583125f, 0.04195427f, -0.01638378f, -0.04862146f, 
    0.03807868f, -0.05701355f, 0.03246955f, 0.02464194f, 0.03953684f, -0.02257374f, 0.03636792f, -0.03065488f, 
    -0.05245385f, -0.05758259f, -0.02942790f, 0.01522033f, -0.00422023f, -0.02211895f, -0.04800631f, 0.01996846f, 
    0.03795599f, -0.02062219f, -0.03865706f, -0.05241584f, -0.02892249f, -0.03699589f, -0.02318651f, 0.00079236f, 
    -0.01275386f, 0.02884959f, 0.00687504f, -0.04563445f, -0.03200391f, -0.00835005f, 0.01057579f, -0.01261146f, 
    0.03058301f, -0.00442485f, -0.00934030f, -0.05343423f, -0.01908688f, -0.04786378f, 0.00452857f, 0.01559652f, 
    -0.01782630f, -0.00234754f, -0.04760640f, 0.02266123f, -0.05283106f, -0.01354894f, -0.04021705f, 0.00843782f, 
    0.01702510f, 0.02758888f, 0.01513645f, 0.03393546f, -0.02428991f, 0.03578406f, -0.00588206f, 0.03995724f, 
    0.02917382f, 0.04206265f, -0.05084308f, -0.03962493f, 0.01259771f, -0.03194125f, -0.00101321f, 0.03968588f, 
    -0.00285023f, 0.02858558f, -0.04725398f, -0.00901123f, 0.00954540f, 0.04315661f, 0.01401378f, -0.00118959f, 
    0.04224410f, 0.00529049f, -0.01398399f, 0.00998838f, -0.02970200f, -0.00465175f, -0.04424432f, -0.02243017f, 
    -0.05821207f, -0.02558173f, -0.04786777f, 0.01337043f, -0.01460658f, 0.03704882f, 0.04411994f, -0.01492290f, 
    0.03356610f, 0.03063245f, -0.01488317f, -0.02510514f, -0.00145219f, 0.00084942f, 0.03404110f, 0.02938430f, 
    -0.00687982f, -0.04185063f, -0.02825469f, 0.00169657f, 0.03391122f, 0.01600419f, -0.05026669f, 0.02155915f, 
    -0.02944602f, -0.02279273f, -0.04763794f, -0.04003212f, -0.05499022f, -0.02839248f, -0.03033720f, -0.04921331f, 
    0.03092579f, 0.03305738f, -0.02789069f, -0.04855175f, -0.02356704f, 0.00501616f, -0.00468247f, 0.04173786f, 
    -0.02361513f, 0.01445514f, -0.04284099f, 0.02046919f, -0.00471702f, -0.05220493f, 0.00813431f, 0.02902379f, 
    0.01467268f, -0.04446967f, 0.03029530f, -0.00958878f, -0.03879158f, 0.03227078f, -0.03218836f, -0.04174079f, 
    0.02208660f, -0.00691726f, 0.01744324f, 0.02757890f, 0.01247973f, 0.01384122f, 0.01548329f, -0.02277266f, 
    -0.02590958f, -0.00747946f, -0.04302775f, -0.01854257f, -0.01064115f, 0.03257540f, -0.03590285f, -0.00181617f, 
    -0.02406630f, -0.01427833f, -0.00095605f, -0.03145548f, -0.03980440f, -0.01762082f, -0.03007651f, -0.03021068f, 
    -0.00951102f, -0.03231627f, -0.04884417f, 0.03899112f, -0.02978773f, 0.02638696f, 0.03551232f, 0.03667410f, 
    -0.04743864f, 0.02288789f, 0.01044171f, -0.02585433f, -0.05015315f, -0.02548872f, 0.00103716f, 0.03606381f, 
    0.01342267f, 0.01474125f, 0.03791960f, -0.04679598f, 0.02826236f, -0.00785227f, -0.02209121f, 0.03447970f, 
    0.02658849f, -0.03771824f, -0.02744887f, -0.03858998f, -0.02926932f, 0.04038433f, -0.02606932f, -0.05219597f, 
    -0.00593658f, 0.03922116f, 0.03486867f, 0.03826798f, -0.00855835f, 0.02240350f, 0.01728232f, -0.05200559f, 
    -0.03310510f, 0.01479567f, -0.04267466f, 0.00444441f, -0.00184278f, -0.04915304f, -0.01444576f, -0.05670336f, 
    0.03021912f, -0.04403456f, 0.02687477f, -0.03778528f, 0.02930115f, -0.02232400f, -0.03798064f, 0.00397853f, 
    0.01552107f, -0.00696333f, -0.02202863f, 0.02847936f, 0.01713721f, 0.04083667f, -0.01186651f, -0.01800887f, 
    0.02461554f, 0.00104053f, -0.01092997f, 0.03065043f, 0.01876412f, 0.04340515f, 0.02716751f, -0.04375395f, 
    0.39364460f, -0.17763442f, -0.30918857f, -0.26120776f, 0.02610519f, 0.06059171f, -0.06319854f, 0.01214188f, 
    0.05664371f, -0.03927255f, -0.02787614f, -0.09607410f, 0.05755813f, 0.04233868f, 0.05261529f, 0.06632513f, 
    0.00880134f, 0.02418475f, -0.00458534f, 0.09913249f, 0.02197274f, -0.01340352f, 0.08203032f, 0.06812615f, 
    0.26196167f, 0.16085704f, 0.05399943f, -0.05439074f, 0.02013644f, 0.29645112f, 0.06941744f, 0.10287327f, 
    0.13836542f, 0.05367621f, 0.06327248f, 0.01441311f, 0.17923234f, -0.08006475f, 0.11656720f, -0.03148336f, 
    0.03172963f, 0.00243340f, -0.00986358f, -0.00979522f, -0.02181438f, 0.00473986f, 0.04521440f, -0.03820252f, 
    -0.18589078f, -0.54282361f, 0.10093840f, -0.03651717f, 0.09229541f, 0.02855036f, 0.03596743f, 0.05673645f, 
    0.04852504f, 0.00334929f, 0.00197635f, -0.03015218f, 0.29481328f, -0.18822673f, -0.22725959f, -0.14235811f, 
    0.06056025f, -0.06865117f, 0.06265970f, -0.09730477f, -0.03596435f, -0.01707371f, -0.13763431f, 0.08911358f, 
    0.48328689f, -0.26414156f, -0.32871547f, -0.24836157f, 0.13530330f, 0.05593502f, -0.02242922f, -0.02380795f, 
    0.02654303f, -0.00476911f, -0.05197264f, -0.01742725f, 0.11877059f, 0.05358976f, 0.04890039f, 0.02632605f, 
    -0.09225123f, 0.01621652f, 0.01061623f, 0.05563066f, -0.05248855f, -0.07822356f, 0.02419750f, 0.09250948f, 
    -0.11532345f, 0.04913148f, 0.41158348f, -0.02823055f, -0.00959040f, 0.03177837f, -0.04656467f, -0.00217665f, 
    -0.04552580f, -0.05797173f, -0.15282498f, -0.12708940f, 0.30431035f, 0.26075950f, 0.24371743f, -0.11126384f, 
    0.12808275f, 0.08015312f, -0.02628544f, 0.08196217f, -0.02691736f, -0.04921026f, -0.03863942f, 0.07534137f, 
    0.16237295f, -0.06028139f, 0.06836875f, 0.04378435f, -0.04553352f, -0.01150483f, 0.00905496f, -0.07528154f, 
    -0.01948095f, -0.08679450f, -0.10072464f, 0.00689804f, 0.22401574f, 0.18210182f, 0.07782266f, 0.09141947f, 
    0.10386965f, 0.11885511f, 0.11578191f, -0.03613603f, -0.04644132f, -0.01840349f, -0.03483279f, 0.03810642f, 
    0.13652812f, -0.06510067f, 0.17596336f, -0.06491201f, -0.07211465f, -0.07092147f, -0.05563978f, -0.08360437f, 
    -0.00824278f, -0.06544177f, -0.00544111f, -0.14591564f, 0.24506555f, -0.04948701f, -0.15446967f, -0.21068791f, 
    -0.01508503f, 0.12439434f, 0.05728805f, 0.08061466f, -0.05218520f, -0.02997005f, 0.05739859f, 0.10256952f, 
    -0.29486176f, 0.04080205f, -0.09895904f, -0.15387970f, 0.11108011f, 0.06711610f, 0.05170619f, -0.02781943f, 
    0.01575407f, 0.07107040f, 0.04597971f, 0.08217705f, -0.04155073f, 0.03833415f, -0.25886977f, -0.04167134f, 
    0.02880795f, -0.06624170f, -0.03157260f, -0.07512547f, -0.00990272f, 0.01876887f, 0.03552070f, -0.02247330f, 
    -0.14955184f, -0.00677273f, -0.04265558f, 0.07313985f, 0.05356158f, -0.09851086f, -0.03762279f, 0.00061955f, 
    -0.04902888f, 0.02571300f, -0.10753006f, -0.02677972f, 0.21563318f, 0.08875085f, 0.14573625f, 0.16212341f, 
    -0.04885364f, 0.06075331f, -0.04346792f, 0.00174908f, 0.01385410f, 0.07078194f, 0.01322050f, -0.02803076f, 
    -0.02137171f, -0.04334661f, 0.07978550f, -0.06901950f, -0.04397677f, 0.01195103f, -0.04049831f, -0.13330595f, 
    -0.02622549f, -0.03725186f, -0.09883127f, -0.06770594f, 0.27475619f, 0.28794500f, -0.04293013f, -0.06671025f, 
    0.01775899f, -0.04165423f, 0.05206221f, 0.20163150f, 0.00117019f, 0.05752720f, 0.03135490f, 0.03395629f, 
    0.13558441f, 0.22719322f, -0.05089715f, 0.06206339f, 0.00401642f, -0.03039262f, -0.01427515f, 0.15882742f, 
    -0.06139114f, 0.12855682f, 0.07611575f, 0.02669466f, 0.09397011f, -0.11844836f, 0.27903983f, -0.35696954f, 
    -0.13110350f, 0.04636366f, -0.12681644f, -0.07958937f, -0.00811461f, 0.01018028f, 0.12366613f, -0.08386287f, 
    0.08874688f, 0.05444085f, -0.15105504f, -0.09341473f, -0.15568139f, -0.03118121f, 0.00881005f, 0.12194169f, 
    -0.09513656f, 0.02943358f, 0.01090189f, -0.08912193f, 0.24425288f, 0.05708501f, 0.06356289f, 0.21318264f, 
    0.09081418f, -0.03032691f, -0.00511961f, 0.02263925f, 0.00192024f, -0.02135306f, 0.03082663f, 0.03502795f, 
    0.32539979f, 0.25822851f, 0.04199230f, 0.03432230f, 0.16315715f, -0.06122372f, 0.05791926f, 0.16829853f, 
    -0.02081733f, 0.02543784f, -0.00220162f, 0.09533487f, -0.02941595f, 0.02011440f, -0.02090026f, -0.02405922f, 
    0.19654150f, 0.00643803f, 0.05925358f, 0.01184822f, -0.11875900f, -0.00327343f, 0.04836470f, 0.03343663f, 
    0.09885558f, 0.05084538f, 0.06883312f, 0.05240257f, 0.03133894f, 0.16458221f, -0.04198217f, 0.07411993f, 
    0.03193327f, 0.02688832f, -0.03014222f, -0.05995766f, -0.20856105f, 0.08377463f, 0.07889820f, 0.05145576f, 
    0.05919357f, -0.01249915f, -0.06836152f, -0.07917617f, -0.00575841f, -0.11293204f, -0.00605952f, 0.04915897f, 
    -0.02421791f, 0.04178610f, 0.17380612f, 0.15495311f, 0.00631146f, -0.01486863f, 0.01181188f, -0.05565846f, 
    0.05469022f, 0.02843788f, -0.02475797f, 0.02561557f, 0.16093329f, 0.05989061f, 0.06811044f, 0.16353121f, 
    0.09846573f, 0.12980308f, 0.12816873f, 0.16119547f, -0.09451538f, 0.07812178f, -0.01447985f, -0.02633162f, 
    0.53887910f, 0.19999228f, 0.03845413f, -0.24642682f, 0.08581638f, -0.09834893f, 0.12011956f, 0.04726289f, 
    0.02529884f, -0.01465160f, 0.00353535f, 0.04588096f, 0.20510180f, -0.04829814f, 0.05725876f, -0.13282731f, 
    -0.03794502f, -0.03592572f, 0.00277239f, -0.09195326f, 0.11729832f, -0.03411156f, 0.01543733f, -0.08103652f, 
    0.03107752f, 0.26135406f, 0.17202434f, -0.26296726f, 0.05379737f, 0.05828136f, 0.15333748f, 0.06886923f, 
    0.12152117f, 0.11282104f, 0.05046444f, 0.01205854f, -0.03633576f, -0.07849835f, 0.06725372f, 0.03045280f, 
    0.03904725f, -0.26484057f, -0.13221699f, -0.10618313f, 0.04287434f, -0.04126347f, 0.04685176f, 0.03381635f, 
    -0.09967965f, -0.19315413f, 0.23676704f, -0.07101484f, 0.06208398f, -0.04788342f, -0.00255352f, 0.00349571f, 
    0.01178072f, 0.02012221f, 0.04674195f, -0.00836307f, -0.01211572f, 0.00238679f, 0.07706609f, -0.13970976f, 
    0.06311951f, -0.01133924f, 0.06198350f, 0.00154303f, 0.03106605f, -0.02386178f, -0.09334711f, -0.02249238f, 
    0.12149538f, 0.32084885f, -0.13780870f, 0.05350213f, 0.06739733f, 0.00665800f, -0.04146627f, -0.06403837f, 
    0.12821668f, 0.10582201f, 0.13379794f, 0.08060595f, 0.21050124f, -0.25182635f, 0.30938917f, -0.11998797f, 
    -0.00627997f, 0.06608639f, 0.05253137f, 0.03698125f, -0.07480109f, 0.18357202f, 0.13441609f, 0.00599095f, 
    0.23991328f, -0.14023709f, 0.31035030f, 0.00243225f, -0.10324334f, -0.04655372f, -0.08236070f, -0.18242916f, 
    0.02216791f, 0.04210063f, 0.14821835f, 0.26938471f, 0.06425755f, -0.09586724f, 0.09219104f, -0.09012765f, 
    -0.01642225f, -0.05815635f, -0.01611708f, -0.02691897f, 0.02978554f, 0.11479400f, 0.17667660f, 0.11942237f, 
    0.39527190f, -0.25849411f, -0.06033899f, 0.21216138f, 0.10319220f, 0.15050723f, -0.11108463f, 0.01450563f, 
    -0.09756479f, 0.03061881f, 0.18956971f, 0.01472308f, 0.02313879f, 0.02152211f, 0.18406887f, 0.25676161f, 
    -0.18209204f, -0.07297943f, 0.00587631f, 0.08715010f, -0.11339702f, -0.04131542f, -0.07003473f, -0.00822380f, 
    0.16163239f, 0.00455951f, 0.04045853f, 0.01710812f, 0.04327776f, -0.00887572f, -0.01548137f, -0.05521486f, 
    0.08399551f, 0.14253654f, 0.04656341f, 0.06089242f, -0.26013595f, -0.11284043f, -0.13946645f, -0.13622414f, 
    0.07438806f, 0.01777289f, 0.06894292f, -0.00960878f, -0.00289921f, -0.05209139f, 0.01587535f, -0.05972827f, 
    0.04240953f, -0.06837337f, 0.09874235f, -0.04094573f, -0.00284834f, 0.05210201f, -0.01068507f, -0.00789454f, 
    0.10329642f, -0.07028370f, 0.15089585f, -0.01173271f, -0.19971016f, 0.02471542f, -0.02930590f, -0.11263842f, 
    -0.13081869f, -0.06854334f, 0.10721578f, 0.02869479f, 0.00364870f, -0.03174572f, 0.10282498f, 0.09485635f, 
    0.10502213f, 0.35483974f, -0.35260659f, 0.21077397f, 0.05168910f, 0.12972872f, -0.05527214f, -0.09965959f, 
    0.05079116f, -0.01981677f, 0.15646668f, 0.15898137f, -0.11394338f, 0.01436291f, -0.37141109f, -0.09672151f, 
    0.02084572f, 0.12274384f, 0.03661123f, 0.06593809f, -0.04094389f, 0.03643260f, 0.00938257f, 0.03979757f, 
    -0.00115991f, -0.07655703f, -0.31222957f, 0.03771673f, 0.09316625f, 0.08171200f, 0.06538086f, 0.07579809f, 
    0.03407323f, 0.04250164f, -0.01301831f, -0.01394129f, 0.20218007f, 0.03693338f, 0.03599738f, 0.12971202f, 
    0.01668555f, 0.03960699f, -0.00198714f, 0.02488881f, 0.00494346f, -0.09905078f, -0.02382983f, -0.02238417f, 
    0.12711687f, -0.03565637f, -0.06197210f, 0.01629648f, 0.10054526f, 0.03298819f, -0.01216112f, 0.03691224f, 
    -0.13478188f, 0.04526082f, -0.01789697f, 0.01280899f, -0.18827531f, -0.03713756f, 0.22998407f, -0.10666946f, 
    0.15609802f, -0.04939946f, 0.02623248f, 0.05029641f, -0.04688392f, 0.06111150f, 0.03167015f, -0.03892434f, 
    -0.13578267f, 0.01318103f, -0.08604185f, -0.01030017f, -0.00221803f, 0.01858978f, 0.01254212f, -0.01562742f, 
    0.11833417f, 0.05258236f, 0.08324067f, 0.02013692f, 0.25909591f, -0.07629098f, 0.29357156f, -0.12798704f, 
    0.02898245f, 0.10992200f, -0.11691045f, 0.05738038f, 0.07620675f, 0.22349733f, -0.03523447f, 0.09226156f, 
    -0.03926959f, 0.13631885f, -0.01526821f, -0.15482318f, -0.04236556f, -0.07745738f, 0.15029731f, 0.22782716f, 
    0.15301150f, -0.01946781f, -0.00436462f, 0.08124980f, -0.02095119f, -0.08651166f, 0.01420600f, -0.01949961f, 
    0.14061503f, 0.08742091f, 0.04679329f, 0.01947417f, 0.06296775f, 0.01844193f, 0.03596606f, 0.04711079f, 
    -0.23032549f, -0.06975591f, -0.08479322f, 0.07644951f, 0.00168839f, 0.00822900f, 0.03303665f, -0.12107741f, 
    -0.07868262f, -0.10235284f, -0.02220284f, 0.01585981f, 0.10208454f, 0.05390674f, -0.06335221f, 0.08736062f, 
    0.04806203f, -0.01515022f, 0.09434724f, 0.01105519f, 0.05599081f, 0.06211343f, 0.07235128f, -0.05272308f, 
    -0.07806279f, 0.03045295f, -0.06670002f, 0.03892737f, -0.05168895f, 0.18528731f, 0.09177608f, -0.17402190f, 
    -0.04848222f, -0.01688747f, 0.13064499f, -0.07303113f, -0.06621759f, -0.16492826f, 0.00216760f, -0.10721537f, 
    0.11907984f, 0.08138900f, 0.08343478f, 0.05756043f, 0.01220922f, -0.00978883f, 0.05810511f, 0.00104633f, 
    0.11212821f, 0.07873178f, 0.01755365f, 0.09969660f, 0.04733805f, -0.00551928f, 0.02824177f, -0.03759339f, 
    0.01873145f, -0.05819472f, 0.05176286f, -0.04894920f, -0.19442101f, -0.03179853f, -0.02656018f, 0.10596947f, 
    -0.03924521f, 0.01842106f, 0.03321320f, -0.14070402f, -0.00582974f, -0.09819163f, -0.02262502f, -0.09070897f, 
    0.14899713f, -0.48903757f, -0.11105933f, -0.16948670f, 0.14831938f, 0.04142620f, -0.20444548f, 0.18938519f, 
    0.04531046f, 0.07565229f, 0.05507433f, -0.07215049f, 0.13767141f, -0.03593654f, 0.15886879f, 0.06851315f, 
    0.03551501f, 0.08601253f, 0.00762223f, 0.03709644f, 0.09942524f, 0.05074729f, -0.05920181f, -0.10943880f, 
    0.00133913f, 0.02598622f, -0.05453708f, 0.01647875f, -0.00773161f, -0.02202845f, -0.04021719f, 0.01868019f, 
    0.00500524f, -0.00561424f, -0.05782094f, -0.04437238f, 0.02069620f, 0.04150728f, 0.03340531f, -0.00792258f, 
    -0.02209919f, 0.03203376f, 0.00249627f, 0.02386557f, 0.03775085f, -0.03689877f, 0.04287590f, -0.03134784f, 
    -0.04101910f, -0.04166281f, 0.02685336f, -0.04082518f, -0.05427738f, 0.01954875f, -0.01722397f, 0.03147927f, 
    -0.04663258f, -0.01821451f, 0.00719542f, -0.03358059f, -0.00668283f, -0.01715815f, -0.00667561f, -0.03428532f, 
    -0.02602244f, -0.03629231f, -0.05136974f, -0.04607787f, -0.05225382f, 0.00318396f, -0.02624798f, -0.04935935f, 
    -0.04280187f, 0.02818571f, -0.00699150f, -0.01835922f, -0.04336004f, 0.04227860f, -0.05821947f, 0.02627470f, 
    0.02051562f, 0.01265573f, 0.03871935f, 0.01013087f, 0.00604526f, -0.02480069f, -0.02259844f, 0.03559216f, 
    -0.04797517f, -0.03944773f, -0.05631464f, -0.01321069f, -0.04396960f, 0.00507147f, -0.05248920f, 0.00471248f, 
    0.00041736f, -0.00402242f, 0.03248073f, -0.01137351f, 0.00997067f, -0.00403448f, -0.00549421f, -0.01174382f, 
    0.03777255f, 0.02151997f, -0.02758569f, -0.04124659f, 0.01662495f, 0.01756382f, 0.02416236f, -0.05256250f, 
    -0.01050630f, -0.03173812f, 0.03414479f, -0.00723148f, -0.01491977f, -0.01907053f, 0.00197449f, 0.03715108f, 
    -0.02812843f, 0.02169676f, -0.03557462f, -0.00846470f, 0.02670593f, -0.00647498f, -0.03681100f, 0.00857603f, 
    -0.01475636f, -0.00889644f, -0.05007742f, -0.03031917f, 0.03833308f, 0.03350796f, 0.02207184f, -0.02828041f, 
    0.02640028f, -0.00410300f, 0.03971859f, -0.03664158f, -0.01454202f, 0.03251738f, -0.03186828f, 0.02762127f, 
    -0.04039131f, 0.02913007f, -0.01158211f, -0.04331058f, 0.00342955f, -0.00496617f, -0.03207431f, -0.00830543f, 
    -0.00873873f, 0.02209909f, 0.03857227f, -0.01992529f, 0.00095039f, -0.03731593f, 0.02858257f, -0.05722609f, 
    -0.04989513f, -0.04773052f, 0.03491874f, 0.00822389f, 0.02114545f, 0.00070828f, -0.01332851f, -0.02462591f, 
    0.01037505f, -0.00251263f, -0.01443736f, -0.03855032f, 0.02406510f, 0.01305813f, -0.04096844f, -0.02321104f, 
    -0.05009916f, 0.00243335f, 0.04115219f, -0.00918668f, 0.00787451f, 0.02289058f, 0.02496753f, -0.00522187f, 
    -0.02412355f, -0.04582969f, -0.05915420f, -0.03900540f, -0.01439733f, 0.00117299f, -0.02110594f, 0.01530769f, 
    0.01641385f, 0.01270041f, 0.02120502f, 0.01381242f, 0.02839216f, -0.03358440f, 0.00729463f, -0.01625888f, 
    -0.01071612f, 0.01969489f, 0.04190644f, -0.01009679f, -0.04069502f, 0.00121250f, -0.03191158f, 0.01918307f, 
    -0.04787766f, -0.01124133f, 0.04231656f, -0.05299633f, -0.00572137f, 0.04098633f, -0.03729211f, -0.03498823f, 
    -0.04779131f, -0.00780794f, 0.02468608f, 0.04071691f, -0.01725115f, 0.03576016f, 0.01832565f, -0.00766988f, 
    0.00549274f, -0.04966809f, 0.02090129f, -0.03802463f, -0.05714855f, -0.00386167f, -0.02498369f, 0.03652900f, 
    -0.00464118f, -0.04383542f, 0.01551440f, -0.04909987f, -0.04716602f, 0.02377705f, -0.04153056f, 0.01026880f, 
    0.00051762f, 0.00728512f, 0.01486645f, -0.05169807f, -0.02741147f, 0.04054871f, -0.02844854f, 0.02872686f, 
    -0.03724613f, 0.03440038f, 0.03088555f, -0.00877913f, 0.01940209f, 0.01776830f, 0.00746183f, -0.02016766f, 
    -0.03261771f, -0.02599748f, 0.01789717f, 0.03551672f, 0.00425585f, -0.03508553f, 0.00251180f, -0.05577164f, 
    0.05015878f, 0.02979860f, 0.00301121f, 0.00344410f, -0.05711583f, -0.04230587f, -0.02325627f, -0.04201281f, 
    -0.04469560f, 0.03193213f, -0.04354194f, 0.01204837f, 0.02049619f, 0.03585903f, -0.02548606f, -0.02956378f, 
    0.01866752f, -0.03676470f, -0.01166351f, -0.02761323f, -0.01425258f, -0.00900786f, -0.04189216f, 0.00901185f, 
    -0.05605002f, 0.04201972f, 0.00214747f, -0.04634729f, -0.03348072f, -0.01239997f, -0.00882336f, -0.05290373f, 
    -0.01269060f, -0.00332108f, 0.00278340f, -0.05065958f, -0.01390445f, 0.03192859f, -0.01712962f, 0.02673856f, 
    -0.03525905f, -0.01937656f, -0.00217569f, -0.01320572f, -0.05898934f, 0.01622638f, 0.00660979f, -0.04272810f, 
    -0.02208936f, -0.00704242f, -0.03302041f, 0.02880839f, -0.00582130f, -0.00806884f, -0.03372574f, -0.03936660f, 
    0.02177040f, 0.00183038f, 0.02843632f, -0.05171799f, -0.00968724f, 0.01076009f, -0.04814365f, 0.02581639f, 
    0.01179378f, 0.03315377f, 0.03996824f, 0.02423932f, -0.02599238f, -0.00358028f, -0.05267448f, 0.00528942f, 
    -0.05141645f, -0.04386066f, -0.05541213f, -0.02164402f, -0.02165594f, -0.01485478f, -0.02912833f, -0.01475492f, 
    -0.04677347f, 0.00505065f, -0.01367770f, 0.02072526f, -0.02715203f, -0.04368466f, -0.05670984f, 0.01214216f, 
    0.04245161f, 0.01298342f, 0.00647384f, 0.04133060f, -0.05103850f, 0.00316934f, -0.04842240f, -0.02735729f, 
    0.03034824f, -0.05639119f, 0.02497626f, 0.00886655f, -0.03653156f, 0.02833166f, 0.03579387f, 0.02301000f, 
    -0.01418822f, 0.01092711f, -0.05231399f, 0.02390464f, 0.03749921f, -0.02595396f, -0.04251023f, -0.00484427f, 
    -0.00134982f, -0.03791183f, -0.02157767f, 0.00469858f, -0.01122957f, 0.03716959f, -0.05430470f, -0.00890756f, 
    0.03930388f, -0.02268012f, 0.00034613f, -0.03554025f, 0.03936316f, -0.00620396f, -0.05441596f, -0.05216786f, 
    0.03927941f, 0.00696950f, -0.04919902f, 0.04853214f, 0.03197448f, 0.00896926f, 0.04045972f, 0.03311346f, 
    -0.02984947f, 0.01189045f, -0.04428434f, -0.00817615f, 0.00971076f, 0.04111600f, -0.00107784f, -0.00146720f, 
    -0.12232687f, -0.32263207f, 0.08951783f, -0.16075228f, -0.01488843f, 0.02363674f, 0.05924746f, 0.06446508f, 
    0.03511274f, 0.05795521f, 0.11622571f, -0.02898281f, 0.06950302f, 0.05449523f, -0.02785232f, 0.07743189f, 
    0.01493707f, 0.09245574f, -0.03261789f, -0.08663221f, 0.03342308f, 0.05406824f, -0.01137950f, 0.11196049f, 
    0.07072202f, 0.09553680f, 0.00801985f, -0.23213522f, 0.11618200f, 0.07185192f, 0.03680264f, 0.02114224f, 
    0.01674756f, -0.08358057f, -0.02617635f, -0.01781413f, 0.07401951f, 0.05042553f, 0.17060025f, -0.07996098f, 
    -0.21699584f, 0.00900167f, -0.06721675f, -0.05134479f, 0.07575498f, -0.04600393f, 0.21373841f, 0.19601689f, 
    0.05350773f, 0.16659781f, -0.22942427f, 0.12448237f, -0.08457993f, -0.11353345f, 0.06232164f, 0.13942654f, 
    -0.14547656f, -0.10945684f, 0.05353625f, -0.10854504f, 0.26570693f, -0.26079637f, 0.18088138f, -0.24542797f, 
    0.09050192f, -0.07993966f, -0.02286067f, 0.03860148f, -0.09439629f, 0.08149935f, -0.02635979f, -0.03172935f, 
    -0.06830710f, -0.42261794f, -0.07209605f, -0.13997200f, 0.03259543f, 0.03119208f, -0.04166713f, 0.02403291f, 
    0.09028590f, 0.00066597f, 0.05227757f, -0.01211927f, -0.08259445f, -0.09488708f, 0.01925839f, 0.17315994f, 
    -0.06751316f, 0.08000772f, 0.06521440f, -0.03738338f, -0.05968479f, 0.06044281f, -0.07334748f, -0.17460099f, 
    0.59282464f, -0.07358268f, 0.36619699f, 0.06348158f, 0.06606793f, 0.24503261f, 0.00672979f, 0.00589995f, 
    0.01837335f, 0.05672445f, -0.05693935f, -0.15384597f, 0.03070505f, -0.00567560f, 0.15165451f, -0.07452647f, 
    0.12492006f, -0.05099118f, -0.09076382f, 0.17241929f, 0.05628524f, -0.00013623f, 0.06515168f, 0.14627157f, 
    -0.10439701f, 0.02571307f, -0.08493037f, -0.08434357f, -0.02696890f, -0.06618435f, 0.10987968f, 0.01556493f, 
    -0.06999209f, -0.00378820f, -0.07785514f, -0.14543754f, 0.11054407f, -0.15976566f, -0.08918935f, 0.11460193f, 
    0.12322394f, 0.04540517f, 0.00264234f, -0.01490658f, 0.07490692f, 0.09033483f, 0.02882284f, 0.15400058f, 
    -0.05393469f, -0.17995635f, 0.18714134f, -0.24445966f, -0.09720206f, -0.02048002f, -0.08539689f, -0.13864812f, 
    0.13803735f, 0.06124585f, 0.13022770f, 0.11109480f, 0.07557298f, -0.20327742f, -0.11571541f, -0.14168727f, 
    0.04908282f, 0.06441852f, 0.06077429f, 0.09223855f, -0.12531778f, 0.03950245f, 0.10996653f, 0.07285213f, 
    0.10236100f, 0.25617689f, -0.11066286f, 0.20730028f, 0.12835474f, 0.07363547f, -0.05796566f, 0.11869650f, 
    0.06890788f, 0.03180247f, 0.10691807f, 0.02719179f, -0.53905958f, -0.13436717f, -0.06325817f, 0.08914694f, 
    -0.00581960f, 0.01493088f, 0.03728539f, 0.03597488f, -0.01022420f, -0.04493373f, -0.02794217f, 0.03925136f, 
    0.00538732f, -0.01939907f, -0.12538844f, 0.25837842f, 0.07552072f, 0.02938015f, 0.08672040f, 0.08524882f, 
    0.03290703f, -0.05246698f, -0.04832533f, -0.08369767f, 0.00297629f, 0.13628784f, 0.06442263f, 0.09044693f, 
    -0.09489711f, 0.01365460f, -0.01559050f, -0.03128128f, 0.05576975f, 0.01190017f, 0.03300461f, -0.10937899f, 
    -0.00697401f, -0.13081630f, -0.00078826f, -0.16414408f, -0.18866354f, -0.04011874f, -0.12068442f, -0.11065505f, 
    -0.03676394f, 0.21333669f, 0.20045656f, 0.05856038f, 0.04172660f, 0.19368905f, 0.23979990f, -0.22777821f, 
    -0.05963208f, 0.20134810f, 0.05679030f, 0.19232118f, 0.05808134f, 0.02360059f, 0.09900219f, -0.01803136f, 
    -0.15112542f, 0.05572423f, 0.05000625f, 0.14837489f, 0.12613191f, -0.06017780f, 0.16236387f, -0.02266722f, 
    0.01285409f, 0.10116459f, -0.01549667f, 0.01930532f, 0.27577510f, -0.19839938f, 0.17037843f, -0.22999349f, 
    -0.13023332f, 0.10640558f, -0.07797933f, -0.03406987f, -0.00131512f, 0.03793474f, -0.00848379f, 0.03997764f, 
    -0.31493470f, 0.08067723f, -0.04939091f, -0.11406475f, -0.05026339f, 0.05737376f, 0.01750658f, 0.09410494f, 
    0.14221378f, -0.03675086f, 0.07510025f, -0.02511245f, -0.22140212f, -0.09942730f, 0.03057923f, -0.01470635f, 
    0.03293978f, -0.11840928f, -0.01617086f, 0.05793481f, 0.00241093f, -0.16061454f, 0.01489279f, -0.02620847f, 
    0.01181291f, 0.05682307f, -0.08169968f, 0.00141453f, 0.23965885f, -0.02797321f, 0.16197972f, 0.12379419f, 
    -0.03696901f, -0.06976698f, 0.01893299f, -0.08926336f, 0.04377886f, 0.14006798f, -0.12699845f, 0.04958820f, 
    0.07806917f, -0.08000759f, -0.01987436f, 0.05422894f, 0.10069415f, 0.03051220f, 0.04969998f, 0.01923272f, 
    -0.07244952f, -0.12149489f, 0.00374543f, -0.05793795f, 0.01551471f, 0.01655532f, -0.00124367f, 0.12482295f, 
    -0.12696411f, -0.07605591f, -0.08440685f, -0.05223653f, -0.08136471f, 0.14136176f, -0.07736018f, 0.07744198f, 
    -0.01682171f, -0.00875712f, -0.05748625f, -0.14193270f, 0.11606123f, 0.01421150f, 0.05092904f, 0.03430266f, 
    0.35615912f, 0.12602749f, -0.13621530f, -0.00144433f, 0.05835943f, -0.08189555f, 0.01933715f, -0.10161470f, 
    0.05002562f, -0.00293984f, -0.05638411f, -0.17072448f, 0.12351126f, 0.02479333f, -0.07241612f, 0.07501382f, 
    0.04707731f, 0.05587630f, -0.00776126f, 0.12705885f, 0.00333445f, 0.03694175f, -0.04730001f, -0.03890134f, 
    -0.16150905f, 0.09395541f, 0.21228085f, -0.25910848f, -0.00243584f, -0.19651350f, -0.16653776f, 0.04377117f, 
    -0.01961806f, 0.02540766f, -0.23378031f, 0.03187209f, 0.24793051f, 0.40093455f, -0.07563099f, 0.06102123f, 
    -0.19083378f, -0.00857696f, -0.06584825f, -0.08274750f, 0.16076046f, 0.02463732f, -0.11568028f, 0.03009954f, 
    0.52477843f, 0.06272231f, -0.10492066f, -0.03326136f, 0.08737790f, 0.06682829f, 0.06260103f, -0.01726909f, 
    0.11890553f, -0.02114843f, 0.00311799f, -0.05399144f, 0.08044305f, 0.24275425f, 0.14140552f, 0.20494406f, 
    0.12286070f, 0.07599360f, 0.08355481f, 0.21030530f, 0.11855772f, -0.06138708f, 0.09504049f, 0.10945544f, 
    0.06428878f, 0.18723038f, 0.13472615f, 0.23612222f, 0.10625664f, 0.14795044f, 0.06943887f, 0.09960899f, 
    -0.05626100f, 0.01579679f, -0.03354762f, -0.03154234f, 0.03835053f, -0.09602788f, 0.04064208f, -0.06520438f, 
    0.08502319f, -0.10824413f, -0.01942569f, -0.05253362f, 0.02309209f, -0.06818134f, 0.00592663f, 0.01725654f, 
    -0.05842643f, -0.29799229f, 0.07640476f, -0.05535109f, -0.00974485f, -0.01328563f, -0.09904034f, 0.05347998f, 
    0.02721524f, 0.04778565f, 0.00807952f, -0.04189865f, -0.18164827f, 0.03092347f, 0.00766396f, 0.02123047f, 
    0.00498693f, 0.05334617f, -0.05031187f, 0.04172712f, -0.06797554f, 0.09198216f, -0.06371628f, 0.08611700f, 
    0.23568429f, 0.03861383f, -0.07774104f, -0.12263187f, 0.11302651f, 0.00537148f, 0.10782345f, 0.05064406f, 
    -0.01663633f, 0.01206047f, 0.11469420f, 0.03172761f, 0.00539260f, -0.04363255f, -0.10057285f, -0.07495923f, 
    -0.00098761f, -0.02020635f, -0.10967848f, -0.02774131f, -0.13780831f, -0.11664569f, -0.32330620f, -0.11830322f, 
    -0.47147971f, 0.04066870f, -0.04602319f, -0.02468505f, -0.01279984f, -0.06461310f, -0.09959678f, 0.10199886f, 
    0.02660898f, 0.04602071f, -0.11590377f, 0.05222538f, 0.08290552f, 0.22768527f, 0.15889806f, 0.16371995f, 
    0.10198840f, 0.23142281f, 0.02833437f, -0.00632867f, 0.02304859f, -0.03066602f, -0.13256866f, -0.10544153f, 
    0.06718185f, -0.01073439f, -0.04262172f, -0.11868989f, -0.04901801f, -0.00786841f, -0.06456427f, -0.06414999f, 
    -0.06020118f, -0.31219709f, -0.10043086f, 0.02914883f, 0.25500971f, 0.37908804f, 0.19853137f, 0.35351035f, 
    -0.08050435f, 0.02292838f, 0.03454969f, -0.03982222f, -0.00534749f, 0.03027525f, 0.10463046f, 0.06039328f, 
    -0.10781059f, -0.08874444f, -0.04731011f, -0.14356297f, -0.06559613f, -0.08315344f, -0.02820409f, 0.01919271f, 
    -0.03104301f, -0.00719002f, 0.10554814f, 0.00733488f, 0.19792378f, 0.17304882f, 0.16215162f, 0.13150685f, 
    0.17079060f, 0.08247966f, 0.13224995f, 0.09899446f, -0.00353994f, -0.02511216f, -0.14043739f, -0.06819585f, 
    -0.09751760f, -0.16582242f, 0.06002630f, -0.07069080f, 0.01934545f, 0.18158016f, 0.09358496f, 0.09469458f, 
    0.06963542f, 0.02829903f, 0.00628789f, 0.18520825f, -0.29005453f, -0.46563956f, -0.33085516f, -0.05954684f, 
    -0.00851876f, 0.06856384f, -0.01884349f, -0.05264701f, 0.10434388f, 0.01558258f, 0.09654610f, 0.00538674f, 
    -0.34800556f, -0.38045347f, -0.05283610f, -0.19400367f, -0.08288784f, -0.02437870f, -0.02180302f, -0.07696065f, 
    -0.02893185f, -0.05641200f, -0.07199800f, -0.08126765f, -0.06128765f, -0.24946201f, -0.09470612f, -0.16561548f, 
    0.01838973f, -0.06808886f, -0.08254302f, -0.00158504f, -0.08492403f, 0.04395200f, 0.10628331f, 0.02224098f, 
    -0.13391079f, -0.22468702f, -0.06881207f, -0.09514021f, -0.02098797f, 0.05963460f, 0.01339340f, 0.02292897f, 
    0.08586829f, 0.06888565f, 0.12259255f, 0.11143498f, 0.04587289f, 0.10679897f, 0.25511426f, 0.12145925f, 
    0.23100056f, -0.16959806f, 0.09354620f, 0.10926764f, 0.01141338f, -0.03373043f, 0.00286587f, -0.00202163f, 
    0.13229829f, 0.09541748f, -0.20519975f, 0.23915362f, -0.04391108f, 0.00490706f, 0.12026559f, 0.18090779f, 
    0.01467974f, 0.06827845f, 0.03422321f, -0.02473252f, -0.03012921f, 0.00378023f, 0.03060524f, -0.14447111f, 
    -0.05123388f, 0.01991000f, -0.01989166f, -0.02793848f, -0.09122135f, -0.05599303f, 0.06112111f, 0.05768918f, 
    0.07222637f, -0.12312628f, -0.25128216f, -0.10509831f, -0.11729658f, 0.11050288f, 0.19795993f, 0.05313618f, 
    0.07391618f, 0.11956403f, 0.03791035f, 0.08618622f, -0.26865369f, -0.26609391f, -0.22413801f, 0.02890460f, 
    -0.01681683f, 0.02731898f, -0.07240672f, -0.02073736f, 0.05864500f, -0.05595563f, -0.01448330f, -0.04530752f, 
    0.21879852f, 0.41112813f, 0.34244692f, 0.36191872f, 0.11886618f, 0.20166628f, 0.06319328f, 0.23677289f, 
    -0.07944924f, -0.03418881f, -0.06396332f, 0.01718765f, -0.09946128f, 0.02684240f, 0.07814669f, -0.02480008f, 
    0.12989013f, -0.02010461f, -0.09558581f, -0.02266473f, 0.04214921f, 0.08531699f, 0.10540656f, 0.17050907f, 
    0.12755810f, 0.23433828f, 0.23787458f, 0.31367463f, 0.03680736f, 0.04546488f, 0.00820337f, 0.10673165f, 
    -0.01815193f, -0.08343711f, -0.16169095f, -0.03049022f, -0.27591750f, -0.22512273f, -0.13682748f, -0.02669861f, 
    -0.08017078f, 0.00671682f, 0.01288768f, 0.00913348f, 0.08118135f, 0.09115212f, -0.08613171f, -0.04533241f, 
    -0.23505192f, -0.03777027f, -0.03015959f, -0.07742546f, -0.02501760f, -0.03810589f, -0.12560490f, -0.05540306f, 
    0.01721419f, -0.08489174f, -0.03904646f, -0.00837888f, 0.12263981f, 0.28631303f, 0.25503346f, 0.39555326f, 
    0.07472737f, 0.07368556f, 0.10362090f, 0.15498462f, -0.12497853f, 0.00150332f, -0.07501074f, -0.01280659f, 
    0.16876873f, 0.12670794f, 0.36353999f, -0.17428945f, 0.12173203f, -0.05497875f, 0.01640572f, -0.11292018f, 
    -0.03068997f, 0.02314324f, -0.08599924f, -0.11116927f, -0.11953711f, -0.15104674f, 0.04577608f, -0.01142654f, 
    0.06486632f, -0.10937127f, -0.07348175f, -0.06442542f, -0.16395566f, -0.00499129f, 0.07891200f, -0.02954359f, 
    0.11825197f, -0.19368063f, -0.15495346f, -0.25107777f, 0.07329486f, -0.05284925f, -0.13873260f, 0.13680710f, 
    0.08306280f, 0.02537918f, 0.01294267f, -0.02601967f, -0.08500342f, 0.00171212f, -0.13284886f, -0.02301198f, 
    -0.02870856f, -0.04609534f, -0.06157573f, -0.06566602f, -0.05950973f, -0.04780738f, -0.08248342f, -0.09398793f, 
    -0.27129388f, -0.20463875f, -0.09747921f, 0.07553107f, 0.00396583f, 0.06324109f, 0.00007234f, -0.01102005f, 
    0.12780544f, 0.19851992f, 0.02771668f, -0.04293802f, 0.00930136f, 0.05327582f, 0.02319775f, 0.23827651f, 
    0.09391844f, -0.05391278f, -0.00352372f, -0.04470146f, -0.03941621f, 0.03483228f, -0.14989179f, 0.03807515f, 
    -0.19035529f, -0.25381774f, 0.15930328f, -0.09725055f, -0.03065269f, 0.03615680f, -0.00203439f, 0.12348890f, 
    0.13943519f, 0.08131393f, 0.08803012f, -0.02752676f, 0.08361424f, 0.16928078f, -0.13042071f, -0.00666743f, 
    0.01209331f, -0.06133475f, 0.05729692f, -0.06223358f, 0.02358140f, 0.05199683f, 0.04600979f, -0.02633517f, 
    -0.14132892f, 0.05110725f, -0.09395522f, -0.29123428f, -0.10595191f, -0.06078329f, -0.07227902f, -0.06535031f, 
    -0.08872342f, 0.06155041f, -0.02021128f, -0.07152454f, 0.05017271f, 0.10740561f, 0.12759323f, 0.24393412f, 
    -0.08557428f, -0.01593805f, 0.01777564f, -0.00275343f, 0.03916126f, 0.03635675f, 0.15902157f, 0.21301652f, 
    -0.16896136f, 0.23044793f, 0.14403994f, 0.20120022f, 0.00624058f, 0.02983308f, 0.07726676f, 0.02848531f, 
    0.01081975f, 0.03261339f, 0.11291632f, 0.09799089f, -0.24146231f, -0.36799997f, -0.37521771f, -0.17882122f, 
    -0.00541718f, -0.02354517f, -0.09127662f, 0.04995336f, 0.01877967f, 0.01454793f, 0.10599006f, 0.09636442f, 
    0.09115715f, -0.02778196f, 0.09287345f, -0.01068620f, -0.03176611f, 0.08788647f, 0.01288988f, 0.03149599f, 
    0.04161153f, 0.22695486f, -0.02036275f, 0.10177910f, 0.07048526f, -0.08882169f, -0.19765308f, -0.27566206f, 
    -0.08727165f, -0.11021317f, -0.20331763f, -0.10395169f, -0.13341270f, -0.04372024f, -0.08518797f, -0.10761274f, 
    0.09648060f, 0.13052103f, 0.03987689f, 0.12455878f, -0.00606694f, 0.03098682f, -0.01238129f, -0.00158491f, 
    -0.00010976f, 0.02456708f, 0.03399971f, 0.00520863f, -0.16002889f, -0.26005200f, -0.17773792f, -0.12631835f, 
    -0.23333237f, -0.17079599f, -0.13862321f, -0.14974740f, 0.00814784f, 0.01548434f, 0.08727751f, 0.03990394f, 
    -0.27067247f, -0.01018373f, 0.12063679f, -0.08544938f, 0.08966143f, -0.02641968f, 0.03800110f, -0.08586602f, 
    -0.00228454f, 0.04540615f, -0.06198449f, 0.11810613f, 0.37385744f, 0.17538399f, 0.16317211f, 0.05525836f, 
    -0.04759390f, 0.01230366f, 0.04955704f, 0.00349712f, -0.03576221f, -0.10293336f, -0.06230777f, -0.09087868f, 
    0.37175804f, 0.15519162f, 0.38518664f, 0.03459436f, -0.01844826f, -0.05913178f, 0.01774926f, 0.20258515f, 
    0.01393555f, 0.03308566f, 0.08249578f, 0.01368842f, 0.27367404f, 0.10684080f, 0.13095865f, 0.33704814f, 
    -0.06080482f, -0.00863735f, 0.03912513f, -0.00839345f, 0.10762662f, 0.03446145f, 0.10105187f, 0.11011323f, 
    0.01802385f, 0.16747986f, -0.01614051f, 0.14661942f, 0.05568288f, -0.02247814f, 0.03863041f, 0.01737897f, 
    0.05085708f, -0.09640232f, -0.09770204f, 0.05023086f, -0.17194213f, -0.28083923f, -0.23219673f, -0.08332837f, 
    0.00473801f, 0.06259501f, -0.06734278f, 0.06518239f, -0.00150955f, 0.00311623f, -0.08906347f, -0.00821659f, 
    0.47061321f, 0.13315326f, -0.02747852f, -0.10430096f, -0.00461815f, -0.12924735f, -0.01369128f, 0.03172452f, 
    -0.21437544f, -0.07042912f, 0.01060765f, -0.03674774f, -0.12564780f, 0.36714187f, 0.02808622f, 0.19793054f, 
    -0.03395722f, 0.01229054f, -0.00537142f, -0.00457695f, 0.07405168f, 0.07708047f, 0.19197874f, 0.01792488f, 
    0.25119936f, 0.02316169f, -0.02106352f, 0.01401111f, 0.10237752f, 0.13887951f, 0.03472238f, 0.06491042f, 
    -0.13677227f, -0.05934405f, -0.01036573f, -0.01651215f, 0.30046380f, 0.13363573f, 0.08179893f, 0.15172231f, 
    -0.07795899f, 0.01686544f, 0.00614548f, 0.00145288f, -0.03394650f, -0.01559867f, 0.00833174f, 0.03749547f, 
    -0.04031031f, -0.08723234f, 0.09555309f, -0.13799699f, -0.09140049f, -0.13340040f, 0.05863052f, -0.01336954f, 
    0.11077099f, -0.01490803f, -0.03544485f, -0.05202057f, -0.05902099f, -0.07428798f, 0.07210171f, 0.02724323f, 
    0.12692322f, -0.04701190f, -0.03979215f, -0.12971683f, -0.13020043f, -0.13904180f, -0.07475013f, -0.06360059f, 
    0.06239631f, -0.13313089f, -0.00655316f, -0.22638415f, 0.02867015f, 0.03488892f, 0.03961131f, 0.05643244f, 
    0.03333011f, 0.15412720f, 0.08578055f, 0.23950994f, 0.08325832f, 0.10112092f, 0.03639867f, 0.05470011f, 
    0.03356661f, -0.03570066f, 0.00099338f, -0.02268669f, -0.06670475f, -0.10806847f, -0.09991118f, -0.01149109f, 
    0.09253556f, 0.03905125f, 0.02583024f, 0.07394458f, -0.01483720f, 0.06714893f, 0.00357043f, 0.07036668f, 
    -0.02458552f, 0.04974753f, 0.14395812f, 0.01148006f, -0.21669650f, -0.33502394f, -0.17121370f, -0.11052168f, 
    0.04523543f, -0.00678610f, 0.10669892f, -0.00482231f, 0.04652552f, 0.06953067f, 0.11515940f, 0.01548305f, 
    -0.29686767f, -0.15871306f, -0.54552895f, 0.02304577f, -0.05078571f, 0.17861809f, 0.10856583f, 0.06883878f, 
    0.06150613f, 0.09155758f, 0.17585672f, 0.18035544f, 0.17680028f, 0.12425078f, 0.08795229f, 0.17728907f, 
    0.06801362f, 0.10502160f, 0.00952674f, -0.03017791f, 0.10937448f, 0.11191514f, 0.10970572f, 0.06762500f, 
    -0.03500856f, -0.01408294f, -0.03330740f, 0.02285339f, 0.02447826f, -0.04084060f, -0.03927466f, 0.02324146f, 
    0.01560431f, 0.00164898f, -0.04064111f, -0.00221826f, -0.00291190f, -0.04773299f, 0.01440564f, 0.02999220f, 
    0.02552098f, 0.02793957f, 0.01569541f, -0.02001231f, 0.02159817f, -0.02712438f, -0.04174795f, -0.00180218f, 
    -0.00505502f, 0.00890532f, -0.03645384f, 0.00627370f, -0.02511129f, 0.00769464f, 0.01265754f, 0.04340554f, 
    -0.02190273f, -0.03142298f, 0.01779582f, 0.03874973f, -0.02159241f, -0.00934064f, -0.02895725f, -0.04856133f, 
    0.02449835f, -0.03225476f, -0.03065357f, -0.04786015f, -0.04907467f, -0.01901921f, -0.04461483f, -0.00163842f, 
    0.03480164f, 0.02584357f, -0.02943858f, 0.00460258f, -0.02793919f, 0.02172931f, -0.05273061f, -0.00285223f, 
    0.03697542f, -0.05611905f, 0.01499143f, -0.03152571f, 0.00426474f, 0.03857802f, -0.02486768f, 0.00844976f, 
    -0.04978075f, 0.03887263f, 0.00577651f, -0.02146612f, -0.03056591f, -0.01425810f, -0.04677124f, -0.01365184f, 
    0.03216103f, 0.03866564f, 0.00840084f, -0.04207837f, -0.00014904f, -0.05343250f, -0.02006727f, 0.02619023f, 
    -0.05229067f, -0.02111904f, -0.03488281f, 0.04344582f, -0.03799049f, 0.03616414f, -0.05122697f, 0.01531997f, 
    0.02713938f, 0.01733626f, -0.00240314f, -0.05087393f, 0.00996813f, -0.03879769f, 0.02600509f, -0.04422367f, 
    0.00291773f, 0.00034347f, 0.02029329f, 0.00653491f, 0.03367333f, -0.01763527f, 0.01451307f, 0.00881720f, 
    -0.04129000f, -0.04814316f, -0.05850652f, 0.00177079f, 0.00155897f, -0.02441166f, 0.03410541f, 0.01336181f, 
    0.00577570f, 0.03399897f, -0.04072937f, -0.00336108f, -0.03704656f, -0.03002783f, -0.05817243f, 0.03086173f, 
    0.02294523f, 0.00496584f, -0.01926814f, -0.03391079f, -0.05487100f, 0.00410031f, -0.05165755f, 0.02519382f, 
    0.02920452f, -0.02661754f, -0.02072046f, 0.02459238f, 0.02634353f, 0.01958903f, -0.05797004f, 0.00616068f, 
    -0.01589403f, -0.04597766f, -0.03666631f, -0.01084262f, -0.05579346f, 0.00263994f, -0.03244522f, 0.01230075f, 
    -0.00038680f, -0.05147204f, -0.02893927f, 0.03601054f, -0.04244280f, -0.02123510f, -0.00774887f, -0.03961985f, 
    0.04050136f, -0.04765268f, -0.02337799f, -0.03204631f, -0.02893723f, 0.00488598f, 0.03853483f, -0.05062497f, 
    0.02826210f, -0.02648108f, -0.04279362f, -0.04024973f, -0.01916034f, -0.00748700f, -0.02434472f, 0.00424773f, 
    0.02772007f, -0.04256180f, 0.03662700f, 0.02530289f, -0.02983434f, 0.00606768f, 0.01073063f, -0.02808064f, 
    0.02000689f, 0.04034976f, -0.05137609f, 0.00206800f, 0.03943642f, -0.05334967f, 0.04853336f, -0.03408513f, 
    -0.04274292f, 0.02984404f, 0.00878365f, -0.02724349f, -0.05214318f, 0.01281710f, 0.02260774f, -0.01549584f, 
    -0.00003075f, -0.02934735f, 0.01699712f, -0.03468108f, 0.01971874f, -0.00070302f, 0.03380511f, -0.04166118f, 
    0.02334257f, 0.02060582f, -0.01751724f, -0.05267243f, -0.05134457f, -0.01480478f, -0.04825668f, -0.04978630f, 
    0.01437669f, 0.03259522f, -0.02061561f, -0.02612002f, -0.02516650f, 0.03866598f, 0.04065879f, -0.03091216f, 
    -0.01601130f, 0.02578369f, -0.00484341f, -0.03362330f, 0.02148928f, 0.02778194f, 0.05071834f, 0.00230190f, 
    0.04029862f, -0.03291288f, -0.02403747f, 0.00501816f, 0.01674966f, -0.05914852f, 0.02117670f, 0.00789331f, 
    0.00321182f, -0.00793695f, 0.00055196f, -0.03095636f, 0.00991210f, -0.04944598f, -0.04689185f, -0.03736056f, 
    -0.00808634f, 0.03803924f, 0.03318648f, 0.01983574f, -0.03856599f, 0.03607424f, 0.03599924f, -0.01577103f, 
    0.02037062f, -0.04500692f, 0.02991312f, 0.04167208f, 0.01718435f, 0.03469965f, 0.02421124f, 0.01398618f, 
    0.03473295f, 0.04425808f, 0.00018226f, 0.02513175f, -0.01929522f, -0.04842889f, -0.01688217f, 0.02985633f, 
    0.00282093f, -0.05183543f, 0.00874682f, 0.03441574f, -0.00472144f, 0.02385871f, -0.00546017f, -0.03938608f, 
    -0.03032499f, -0.02087043f, 0.05373081f, -0.04261265f, -0.05181969f, -0.04257205f, 0.01143864f, 0.01214091f, 
    0.00265212f, -0.02399939f, -0.01789887f, -0.01473073f, -0.02462582f, -0.03041822f, 0.01070191f, -0.01523478f, 
    -0.02315977f, -0.00358070f, 0.01474986f, 0.01161620f, -0.00313043f, -0.03746563f, -0.02160982f, 0.00057019f, 
    0.01421882f, -0.05872940f, 0.02222556f, -0.03353765f, 0.02222809f, 0.03032283f, 0.01109234f, -0.04591964f, 
    -0.05873263f, 0.02029101f, -0.05508612f, -0.04738009f, -0.00304654f, 0.03348440f, -0.05598912f, 0.01078976f, 
    0.01823778f, -0.03370274f, -0.00205859f, 0.00262550f, -0.01130175f, -0.00167304f, 0.02410604f, -0.00591065f, 
    -0.06034265f, 0.03205557f, -0.01129830f, 0.00114467f, -0.02794826f, 0.00723419f, -0.04935338f, -0.04545955f, 
    -0.04340054f, -0.02142756f, -0.04360080f, 0.01284252f, -0.02519811f, -0.01502400f, -0.04915324f, 0.00832875f, 
    -0.01081343f, 0.02858567f, -0.05742720f, -0.02134420f, 0.01047493f, 0.00849672f, -0.00453410f, 0.03239413f, 
    -0.04411815f, 0.03961881f, -0.03659942f, -0.00311124f, -0.02701280f, 0.04162769f, 0.03567227f, 0.00838818f, 
    0.00294829f, -0.03785302f, -0.01400425f, 0.00151584f, -0.01594719f, 0.00393900f, -0.05266343f, 0.04097618f, 
    -0.05669194f, 0.00009858f, 0.04735493f, 0.02914019f, 0.03498127f, -0.05998744f, 0.02755216f, -0.04373747f, 
    -0.00867979f, -0.04782346f, -0.01777780f, -0.02201834f, -0.02234316f, -0.02768330f, 0.04949209f, -0.02283442f, 
    0.01586603f, -0.03380116f, 0.01361033f, -0.00777366f, 0.01094893f, -0.00697202f, 0.04510777f, 0.02883812f, 
    0.15824005f, -0.01658239f, 0.21154556f, -0.22896203f, -0.09444227f, -0.07367119f, 0.06773511f, 0.03863550f, 
    0.03429266f, 0.09103774f, -0.23390998f, -0.02491921f, -0.00226916f, 0.04634567f, -0.10701296f, -0.02521591f, 
    0.00613009f, 0.04764026f, 0.07409412f, -0.04694862f, -0.09017099f, -0.12240126f, 0.13871129f, 0.16876975f, 
    0.15545994f, -0.20252497f, 0.11006449f, -0.12868698f, -0.00002431f, 0.15718165f, 0.05628962f, 0.13182002f, 
    -0.03035246f, 0.00628812f, -0.03433546f, -0.04439765f, 0.10887086f, -0.08244786f, 0.05686170f, 0.04731236f, 
    -0.08041456f, 0.03711969f, 0.05503804f, -0.00563591f, 0.18323459f, 0.06115636f, 0.09957565f, 0.15549414f, 
    -0.37402561f, 0.19013543f, -0.02902127f, -0.14616542f, 0.07729540f, 0.01208662f, 0.07072906f, -0.04282020f, 
    0.06951725f, -0.01392146f, 0.08501174f, 0.15087730f, 0.45629114f, -0.32820091f, 0.33430147f, 0.02546145f, 
    0.01761877f, -0.05187580f, -0.00575808f, 0.13870297f, -0.00136507f, -0.06101480f, 0.08965512f, 0.02146105f, 
    0.26658812f, -0.21322018f, 0.18785049f, -0.03574587f, -0.06306133f, -0.03533797f, -0.16351752f, -0.00571729f, 
    0.04435273f, 0.01972041f, 0.03962575f, -0.04035610f, 0.21052885f, -0.02310517f, 0.03722907f, -0.11256348f, 
    -0.02890847f, -0.04286241f, -0.06164446f, 0.07923502f, -0.15821517f, -0.12926498f, -0.08928341f, -0.13683964f, 
    0.20912679f, 0.14655109f, -0.01240878f, 0.05837464f, 0.10133792f, 0.22813982f, 0.03143256f, -0.03728003f, 
    -0.00404150f, -0.01177685f, -0.05168591f, -0.10678783f, 0.10262033f, 0.21454006f, 0.11347789f, 0.08215123f, 
    0.06051098f, 0.06096724f, 0.02321169f, 0.07188269f, 0.15300770f, 0.06794469f, -0.02736757f, -0.04565867f, 
    0.15080710f, -0.16908187f, 0.17366414f, 0.00858410f, 0.05196884f, -0.11159585f, -0.09684184f, -0.13445783f, 
    -0.02421398f, -0.15647872f, 0.08130270f, -0.11214520f, -0.09586247f, 0.01939819f, 0.02556187f, -0.03782004f, 
    0.01601025f, 0.11848865f, 0.00643589f, 0.06144093f, 0.02106686f, 0.00654521f, 0.06544820f, 0.06624579f, 
    -0.04157726f, -0.04467136f, 0.15821515f, -0.11568344f, -0.05293489f, 0.02164599f, 0.01796514f, -0.07358146f, 
    0.00667048f, 0.08404901f, 0.25026110f, 0.00844470f, 0.02356205f, 0.17969064f, -0.09067459f, -0.15006459f, 
    -0.04957310f, -0.02634051f, 0.03100895f, 0.08428776f, -0.07061995f, -0.05289045f, 0.02692822f, -0.07843517f, 
    -0.06523466f, 0.38626245f, -0.01943924f, 0.03621867f, -0.14980285f, 0.15253197f, 0.01761359f, 0.11545499f, 
    0.09187859f, -0.07702389f, 0.07116114f, -0.00814487f, 0.03702700f, 0.02498100f, -0.05215359f, -0.09351823f, 
    -0.04392617f, -0.05186669f, -0.03708843f, 0.11882245f, -0.02067479f, 0.09117359f, 0.01891724f, -0.10530200f, 
    -0.02438703f, -0.11177073f, -0.13817939f, 0.03679508f, -0.05185943f, 0.09560896f, 0.03694085f, -0.03500610f, 
    -0.00806091f, -0.05763632f, -0.10753623f, -0.03822877f, 0.08469313f, 0.11272495f, 0.07875562f, 0.12923779f, 
    -0.05655191f, -0.09618667f, -0.00645677f, -0.07241828f, 0.02077657f, 0.05061663f, -0.10681851f, 0.00511619f, 
    -0.01219045f, -0.00135808f, 0.02300591f, -0.10719481f, 0.01669522f, 0.02438553f, 0.03636182f, -0.00515997f, 
    0.00740646f, 0.09906057f, 0.20453797f, 0.03498706f, 0.08286091f, -0.00626982f, -0.06001980f, -0.26377296f, 
    -0.02714421f, -0.06297315f, 0.16151120f, 0.22127452f, -0.03597375f, -0.00425357f, -0.04205446f, -0.03739455f, 
    -0.19638096f, 0.34873173f, -0.26668999f, 0.08057299f, -0.02733289f, -0.16156173f, -0.00460752f, -0.08262001f, 
    -0.08398280f, 0.02871724f, 0.03300103f, 0.00601677f, 0.27023172f, 0.11639367f, 0.18458466f, -0.16044736f, 
    -0.06282129f, 0.08166102f, 0.06789434f, -0.05429528f, 0.05639360f, -0.01106752f, 0.05908022f, -0.00738833f, 
    -0.18243738f, 0.09481249f, 0.02658228f, -0.07943684f, -0.10239138f, -0.08958353f, -0.09102786f, 0.21953785f, 
    0.05461007f, -0.04646372f, 0.06115849f, 0.03403346f, -0.00985418f, 0.06119446f, 0.05514345f, 0.03007084f, 
    0.01127493f, -0.04861699f, -0.00751273f, -0.00710698f, 0.01308589f, -0.10191625f, -0.01118344f, 0.00073987f, 
    -0.02929873f, 0.06286161f, -0.12539183f, -0.12719525f, 0.06640904f, -0.14602576f, -0.01186119f, 0.06266094f, 
    -0.03253172f, 0.00082494f, 0.05315579f, -0.06023947f, 0.09655399f, 0.00298061f, 0.10662043f, 0.11240076f, 
    -0.02370668f, -0.00532586f, 0.16630344f, 0.02052715f, 0.12700918f, 0.01835253f, 0.14926952f, 0.08728656f, 
    0.00973532f, 0.05595336f, 0.04366561f, 0.04351153f, 0.09183405f, 0.03582348f, -0.00855720f, -0.05843800f, 
    -0.03070750f, 0.00911768f, -0.00382187f, -0.24136759f, -0.18403977f, 0.10717232f, 0.01760269f, 0.05876762f, 
    0.02166809f, -0.02245184f, 0.09089836f, -0.08265109f, 0.00047393f, 0.04007770f, -0.01034492f, 0.20403452f, 
    -0.16395555f, 0.19434088f, 0.07341160f, 0.19277161f, 0.01461683f, -0.07120547f, -0.02447496f, -0.23351882f, 
    0.17580003f, -0.10072973f, -0.11259464f, -0.15250675f, -0.14929362f, 0.09077913f, -0.09184387f, -0.00189192f, 
    0.10911544f, 0.01565393f, 0.04233067f, 0.17310633f, 0.01022204f, 0.01880543f, -0.10765079f, -0.03893152f, 
    0.45181331f, -0.47808367f, 0.46014136f, -0.27127311f, -0.03235892f, 0.11851978f, -0.18433927f, 0.22984399f, 
    0.13853794f, 0.03475063f, -0.00188971f, -0.12778747f, 0.22242101f, 0.03248250f, 0.23309562f, -0.00910955f, 
    -0.10137232f, -0.01455724f, 0.03395632f, -0.10097750f, 0.23764268f, 0.25882459f, 0.02145711f, -0.10588319f, 
    -0.27560881f, 0.04233317f, 0.26381740f, 0.10467016f, 0.00775322f, -0.12873144f, -0.00782358f, 0.02300062f, 
    -0.01055882f, 0.05241138f, 0.10965083f, 0.15615322f, 0.11304578f, 0.13997498f, 0.07140276f, 0.11132907f, 
    0.03120084f, -0.02619096f, -0.06013536f, -0.05810984f, 0.12019251f, 0.09417604f, -0.11791119f, -0.14735115f, 
    -0.03549326f, -0.01098827f, 0.14356983f, 0.00613793f, 0.08809742f, -0.14745034f, -0.05322123f, 0.00894542f, 
    0.10480586f, 0.02530890f, 0.08043758f, 0.02776417f, 0.01938407f, 0.09180027f, 0.11431891f, -0.05222211f, 
    0.09020126f, 0.06237010f, -0.07313057f, -0.07101662f, -0.17816663f, -0.04621537f, 0.01851679f, -0.11447925f, 
    0.11623918f, 0.47750261f, 0.00329814f, 0.06507773f, -0.09541875f, -0.13754547f, 0.03782580f, 0.01095459f, 
    0.00007026f, 0.06857161f, 0.09080883f, -0.11562234f, -0.14417586f, 0.00734257f, 0.33200419f, 0.08919698f, 
    0.06688865f, 0.06538235f, -0.17454194f, 0.05891960f, -0.05007045f, 0.03202547f, -0.01597868f, -0.04278626f, 
    0.16303845f, 0.26295534f, 0.40485084f, 0.19448544f, 0.05068577f, -0.04702668f, 0.01606399f, 0.06267262f, 
    -0.06835386f, 0.06621993f, 0.07421296f, 0.15534545f, -0.10342186f, -0.13692559f, 0.10213161f, 0.28231707f, 
    0.05585127f, 0.01039827f, 0.03720368f, 0.05000681f, 0.18556336f, 0.29006398f, 0.07511602f, 0.10165288f, 
    0.10320326f, -0.08554251f, -0.26341671f, 0.15999387f, -0.16393146f, 0.03424098f, -0.11567551f, -0.15129019f, 
    0.00834045f, 0.04200877f, 0.01389664f, 0.05782847f, -0.20216325f, -0.17724583f, -0.09886557f, 0.03211905f, 
    0.01009065f, -0.00746266f, -0.02093505f, 0.03943539f, -0.03391398f, 0.02990436f, 0.18039015f, 0.13167500f, 
    -0.27220190f, 0.17841606f, 0.00651797f, -0.20251092f, -0.03293453f, -0.03987523f, 0.03773289f, 0.12598796f, 
    0.09008021f, 0.25109547f, 0.04682241f, 0.26326868f, 0.11897732f, 0.02794771f, -0.00759653f, 0.00257845f, 
    -0.00518480f, -0.18291326f, 0.05494804f, 0.07527547f, 0.02942623f, -0.05964385f, -0.11463737f, -0.03948195f, 
    -0.06025189f, -0.13142619f, -0.11386207f, -0.12083729f, 0.14153059f, -0.07869044f, 0.04134952f, -0.08533193f, 
    0.09261625f, -0.01445532f, -0.03207495f, 0.14200145f, -0.18289250f, -0.03523875f, 0.19139488f, 0.06668550f, 
    0.04456950f, 0.00180656f, 0.00101206f, 0.11487754f, 0.06137982f, 0.05017228f, 0.08540154f, 0.11287175f, 
    0.30401284f, 0.16337077f, 0.05577790f, 0.03261105f, 0.10788345f, -0.08646490f, -0.11216141f, 0.11095010f, 
    0.02194808f, -0.01134364f, 0.05224819f, 0.06461231f, -0.38364586f, -0.19124129f, 0.08796468f, 0.13710277f, 
    0.09998246f, 0.22218066f, 0.09686173f, 0.04433060f, 0.07337616f, -0.12469292f, -0.07440871f, -0.03362065f, 
    0.04124952f, 0.10413866f, 0.01935180f, 0.17243993f, 0.05034582f, 0.19079095f, 0.06937167f, 0.04422794f, 
    0.13857965f, 0.06284340f, 0.01622300f, -0.01693941f, -0.05417880f, -0.10203637f, -0.08528174f, 0.00600860f, 
    0.02889326f, 0.01333118f, 0.08680406f, -0.01652118f, 0.10195354f, -0.04901632f, 0.04587993f, 0.06509101f, 
    0.01485851f, -0.07761152f, -0.07645357f, 0.06563316f, -0.00223723f, -0.07874907f, 0.00615655f, 0.06020738f, 
    0.00588443f, -0.02911196f, -0.03719181f, -0.08460453f, -0.12408629f, -0.16092357f, 0.31053987f, -0.06322706f, 
    0.14492849f, 0.13831176f, -0.08494503f, 0.14167437f, 0.05426237f, 0.01944491f, 0.00126991f, -0.04290723f, 
    0.04381742f, 0.05370670f, -0.02497739f, 0.14309868f, 0.03463198f, 0.13329312f, 0.08213753f, -0.00673207f, 
    -0.00915358f, -0.11193077f, -0.13105549f, -0.19034618f, 0.26736209f, 0.11256938f, -0.11221677f, 0.27334550f, 
    0.01223746f, 0.07749553f, -0.03839954f, -0.11993950f, -0.00042496f, 0.05190873f, -0.05572040f, 0.13745674f, 
    -0.04015126f, -0.03533743f, 0.00512362f, 0.12669322f, 0.13018887f, 0.23814772f, 0.08758166f, -0.05034609f, 
    0.07961749f, -0.01299535f, -0.02836126f, -0.22118670f, -0.20603682f, -0.27811077f, -0.23460020f, -0.07049201f, 
    0.04734074f, 0.02887590f, 0.10737654f, 0.10956974f, 0.04924583f, 0.02416527f, 0.01099974f, -0.02985710f, 
    -0.08999248f, -0.00831224f, 0.18523078f, 0.11848718f, 0.08767579f, 0.09951843f, 0.20110330f, 0.15254301f, 
    0.04436454f, 0.09783102f, 0.09921066f, -0.12039477f, 0.12321395f, 0.09657691f, 0.07390842f, 0.01430910f, 
    0.00781905f, 0.00200683f, -0.13741204f, -0.05893725f, -0.04624647f, -0.07808616f, -0.11042040f, -0.11406139f, 
    0.08900509f, 0.12897880f, 0.03799525f, 0.07998813f, -0.07088372f, -0.14122117f, 0.07939167f, 0.15225035f, 
    0.02481773f, 0.15161528f, -0.00888942f, 0.11655885f, 0.11278094f, -0.24903491f, -0.22167329f, 0.09269182f, 
    0.08672169f, 0.00397532f, -0.11257208f, 0.02780503f, -0.06338407f, -0.02459237f, -0.05376413f, -0.20408820f, 
    0.24526587f, 0.02436809f, -0.12286051f, -0.04539090f, 0.01223685f, 0.04295557f, -0.02337513f, 0.05067522f, 
    -0.07104609f, 0.10133396f, 0.06728695f, 0.13649932f, 0.11030474f, 0.09189366f, -0.04511812f, 0.10883620f, 
    -0.05676929f, -0.00000316f, -0.01100673f, 0.02076935f, 0.10091452f, -0.04460062f, 0.15598020f, 0.01399980f, 
    -0.63415289f, -0.10104325f, 0.04073317f, 0.01487398f, -0.00105756f, -0.02859025f, -0.07041109f, -0.08911014f, 
    -0.00730521f, 0.00063338f, -0.11083391f, 0.04162079f, -0.04092392f, 0.01287290f, -0.03967078f, 0.17737399f, 
    -0.00778868f, -0.01241507f, -0.09789593f, -0.07020715f, -0.02375284f, 0.02836752f, 0.01251837f, 0.11051315f, 
    0.06726223f, -0.06972501f, 0.26984659f, -0.01939247f, -0.04630019f, -0.02351371f, 0.13645051f, -0.03376671f, 
    -0.08522997f, 0.08487841f, 0.22382702f, -0.02981525f, 0.05628405f, 0.02116841f, 0.01021604f, 0.13353448f, 
    0.12067246f, 0.02674812f, 0.13731062f, 0.10631603f, 0.10746242f, 0.25553241f, 0.15804318f, 0.07008956f, 
    -0.14401390f, -0.14616163f, 0.02181550f, 0.09415475f, 0.04717351f, 0.14951855f, 0.12580368f, -0.00019526f, 
    -0.07786742f, -0.02251256f, 0.02486134f, 0.04419259f, -0.12751217f, 0.20763835f, -0.05219275f, 0.04067807f, 
    -0.09754460f, 0.00493582f, 0.00172646f, -0.01595771f, -0.04627744f, 0.07003863f, 0.06372369f, 0.16601995f, 
    -0.16872144f, 0.06668597f, 0.07016511f, -0.05569917f, -0.05947042f, -0.02052578f, 0.01184779f, -0.09419845f, 
    0.06296167f, 0.01818389f, -0.00945878f, 0.06330579f, -0.17579243f, -0.00365349f, 0.04730824f, 0.09901405f, 
    0.04973590f, -0.08891023f, 0.01644053f, -0.08733036f, 0.00476282f, 0.00459867f, 0.09191098f, -0.00899196f, 
    0.03154337f, -0.10910272f, -0.01052617f, -0.04563694f, 0.09294438f, 0.00540407f, 0.06633989f, -0.00309197f, 
    -0.03806733f, 0.01134689f, -0.04158127f, -0.05826757f, -0.19233131f, 0.08582382f, 0.20251320f, 0.18011265f, 
    -0.09012747f, 0.06291827f, 0.06062796f, -0.03623635f, 0.06216564f, -0.04214714f, 0.01561623f, -0.07683996f, 
    0.11574074f, 0.19864771f, -0.20346059f, -0.02740912f, -0.00976830f, -0.05055035f, 0.04486238f, 0.01710737f, 
    0.10170791f, 0.07326222f, 0.06258074f, -0.09417503f, -0.02864690f, 0.05918260f, 0.01380316f, 0.06349505f, 
    -0.01912811f, -0.02836453f, -0.03556974f, 0.08946510f, -0.02709597f, 0.07236090f, 0.08353171f, 0.07140754f, 
    -0.12771088f, 0.36617279f, -0.20399822f, -0.01760686f, 0.01013800f, -0.03648845f, 0.00490826f, -0.00894756f, 
    -0.16158339f, -0.04185386f, -0.13977383f, -0.06396103f, 0.02864203f, 0.04830705f, 0.02911595f, 0.06434376f, 
    -0.04020029f, 0.01491719f, -0.09641488f, -0.12046687f, -0.00027202f, 0.12382735f, -0.00061505f, -0.03038531f, 
    -0.02425034f, 0.04578199f, 0.05812237f, -0.10579980f, 0.04043106f, 0.04433169f, -0.03770467f, -0.08857501f, 
    0.22807917f, 0.16941136f, 0.11803602f, 0.02981217f, -0.05344163f, -0.00197497f, 0.07399023f, 0.09450210f, 
    -0.01773241f, -0.06000823f, 0.06754928f, -0.05243680f, -0.06367133f, -0.08678579f, 0.05286467f, 0.09588891f, 
    0.50669307f, 0.17762601f, -0.00572455f, 0.03602802f, 0.10794863f, 0.13668960f, -0.01305711f, 0.03022037f, 
    -0.02643637f, -0.03792283f, 0.06699058f, -0.09760157f, 0.23495109f, -0.09403010f, 0.10000757f, -0.39340177f, 
    -0.15781426f, -0.06756062f, -0.09063032f, -0.09307656f, -0.07520231f, 0.01840231f, -0.08264378f, -0.01321917f, 
    0.15201938f, -0.07829314f, 0.06964222f, -0.02900431f, 0.00724058f, -0.13290136f, -0.07154079f, 0.06140302f, 
    -0.04194484f, -0.06870067f, -0.03200608f, 0.02478732f, -0.32868052f, -0.14633901f, -0.18949103f, -0.01777047f, 
    -0.10057435f, -0.04142116f, 0.01676574f, -0.03827192f, -0.05356011f, -0.11048412f, 0.17378236f, -0.00170839f, 
    -0.03504216f, 0.07457826f, 0.03162453f, -0.04492344f, 0.03323680f, -0.00710141f, 0.01263358f, -0.05999622f, 
    0.15503652f, 0.15793565f, 0.22366032f, 0.16444071f, -0.10125169f, 0.02311280f, 0.09225942f, 0.15528178f, 
    -0.08055667f, 0.15242629f, -0.07033546f, 0.03484606f, -0.00699051f, 0.01533236f, 0.01438117f, 0.08196007f, 
    0.12131472f, -0.14109349f, 0.10513529f, -0.10904655f, 0.05666366f, -0.01762229f, 0.07506252f, -0.00569444f, 
    -0.04290743f, -0.08467973f, -0.02508336f, -0.00367508f, 0.06018448f, -0.10294208f, 0.11357342f, -0.02743198f, 
    0.02123883f, 0.05915682f, -0.08773489f, -0.11680210f, 0.01909037f, 0.10373957f, -0.00776886f, -0.01095255f, 
    -0.07298832f, -0.09258572f, 0.22144702f, 0.01505463f, 0.02858654f, 0.09540158f, -0.13555188f, 0.04744774f, 
    -0.00555098f, -0.02703123f, 0.00343235f, 0.05927833f, -0.02456878f, -0.04428324f, -0.10638002f, -0.30573788f, 
    -0.08245559f, -0.03613335f, -0.03609884f, -0.09046875f, -0.06744247f, 0.04878397f, -0.00866675f, -0.01446361f, 
    -0.13784808f, -0.14043014f, 0.02194486f, 0.13299485f, 0.02568678f, 0.09172492f, 0.11081477f, 0.01971923f, 
    -0.07902213f, -0.02509393f, -0.01855809f, 0.01351954f, -0.03109130f, 0.11911351f, 0.00408786f, -0.03000265f, 
    0.08591677f, -0.00411087f, -0.02373510f, 0.02690793f, -0.00428827f, 0.11249483f, 0.08184107f, 0.03498110f, 
    -0.00481186f, -0.04270965f, -0.02231453f, 0.15101023f, -0.00150604f, -0.02278372f, 0.00158268f, 0.11456862f, 
    -0.02552093f, 0.03872913f, -0.05801826f, -0.08891165f, 0.06955513f, 0.02368955f, -0.00345938f, -0.06191981f, 
    0.02815763f, 0.00615798f, -0.05110782f, -0.21428040f, 0.02450019f, 0.09271044f, 0.10877039f, 0.05361243f, 
    0.22583753f, 0.00180427f, -0.42202535f, -0.01252954f, -0.05804983f, -0.06415491f, 0.01014622f, -0.19631083f, 
    -0.11294846f, -0.09510270f, -0.03670688f, -0.09830076f, -0.07140287f, 0.03426570f, 0.01424081f, 0.12115872f, 
    -0.02791596f, 0.07246833f, -0.04009250f, 0.12010806f, -0.00863046f, 0.05971739f, 0.05423968f, -0.00793222f, 
    -0.53070837f, 0.07859245f, 0.07043856f, 0.08073660f, 0.02680027f, 0.05732724f, -0.09327220f, 0.02538753f, 
    0.09129353f, -0.12379764f, 0.00996735f, -0.00008565f, -0.18216978f, 0.16330513f, -0.07091903f, -0.28723028f, 
    -0.03436607f, 0.06711762f, -0.03888990f, -0.06051658f, -0.07324078f, -0.07855154f, 0.15204714f, -0.00559625f, 
    0.18407305f, -0.11053143f, -0.15045890f, -0.16745777f, -0.06667917f, -0.01142568f, -0.10550015f, 0.04153766f, 
    -0.11251572f, -0.10018234f, -0.10157643f, -0.02055283f, 0.06333309f, 0.17543310f, 0.09570553f, -0.04398946f, 
    -0.04477930f, 0.04849201f, -0.03926595f, 0.15291606f, 0.08664105f, -0.10273021f, -0.01978859f, -0.02689781f, 
    0.17389503f, 0.00259314f, 0.09354145f, 0.05273868f, -0.06467780f, -0.03177622f, -0.08529403f, 0.03009501f, 
    0.07728398f, 0.05030596f, 0.11033147f, -0.07866052f, 0.19943941f, -0.02596650f, -0.03102329f, 0.23263916f, 
    -0.05671095f, 0.05839141f, 0.04594599f, -0.02831247f, -0.02151101f, 0.00364033f, 0.04801966f, -0.07391329f, 
    -0.12671758f, -0.31484377f, 0.15074250f, -0.06555791f, 0.00412023f, -0.07580672f, 0.06902887f, 0.14252794f, 
    0.02355899f, 0.06779309f, 0.08906455f, -0.13341832f, 0.05011427f, 0.00272504f, -0.10023898f, 0.14593422f, 
    0.04049713f, 0.01381519f, -0.01697900f, -0.07708450f, -0.06671394f, -0.00573849f, -0.09700882f, 0.12584144f, 
    0.02835086f, 0.30447403f, -0.16082314f, -0.16751693f, -0.06799602f, -0.06765453f, -0.10364849f, 0.02132995f, 
    -0.02727171f, -0.04405016f, -0.05272542f, -0.05587533f, 0.09972213f, -0.02735189f, -0.11410706f, -0.01892898f, 
    -0.03160248f, 0.00589516f, 0.04975000f, 0.02493322f, -0.01092150f, -0.04587806f, -0.11324617f, 0.13051580f, 
    -0.56204581f, -0.23145823f, 0.27675921f, 0.25698823f, 0.05317399f, -0.00716502f, 0.17546751f, -0.04681467f, 
    0.04313673f, -0.02939313f, -0.11232185f, 0.14257436f, 0.10218156f, 0.10968351f, 0.11733986f, 0.00726356f, 
    -0.00269444f, 0.14595087f, 0.05050893f, -0.01927151f, 0.05044316f, -0.01775551f, 0.03482892f, 0.00235987f, 
    0.05190773f, -0.13309337f, 0.20534754f, -0.05629733f, 0.06302911f, 0.10536447f, 0.02344517f, 0.06402619f, 
    0.09533361f, 0.07313794f, 0.01060286f, 0.17388432f, 0.12001043f, 0.12783276f, 0.19589354f, -0.10222720f, 
    0.02555366f, 0.02814662f, 0.15863168f, 0.07509771f, -0.00709772f, 0.02427483f, -0.00312214f, -0.01546733f, 
    0.11734623f, 0.09120540f, -0.01751640f, 0.13712743f, -0.05487365f, 0.01154415f, 0.01920972f, 0.02637269f, 
    -0.10065553f, -0.04083784f, -0.06808920f, -0.09226857f, 0.17772658f, 0.11891530f, 0.08910219f, -0.11330052f, 
    -0.03172350f, 0.00541073f, -0.01737791f, 0.04555587f, -0.01052598f, -0.02301324f, -0.01178654f, 0.03401997f, 
    -0.59521013f, -0.16332735f, 0.12377124f, -0.20605606f, 0.11091857f, -0.20352840f, 0.03612185f, 0.05478757f, 
    0.00183082f, -0.04137470f, -0.09613332f, 0.09975398f, 0.17033328f, 0.14839418f, 0.06434283f, 0.11928866f, 
    -0.02163237f, -0.04489780f, -0.02268207f, 0.01719584f, 0.05397260f, -0.00290220f, -0.05221190f, 0.01579780f, 
    0.43666580f, 0.07804689f, 0.05292241f, 0.01808098f, 0.01384005f, -0.00959746f, 0.00270331f, -0.10330258f, 
    0.01988747f, 0.07661230f, 0.04023420f, 0.04784491f, 0.11054336f, 0.04714141f, 0.00492445f, 0.17935961f, 
    0.07614483f, 0.00483654f, -0.00179853f, -0.02705188f, 0.14428347f, 0.06387405f, -0.12259216f, 0.01653385f, 
    -0.01502474f, 0.15275718f, -0.00102960f, 0.13323991f, -0.07800730f, -0.02009622f, -0.04041338f, 0.02660787f, 
    -0.02714581f, 0.00521946f, -0.18846007f, -0.03450921f, 0.09745157f, 0.08427493f, -0.01781289f, -0.07624930f, 
    -0.05894211f, -0.00729664f, 0.08798949f, 0.12040909f, -0.02282025f, 0.02043845f, -0.08356274f, -0.09617859f, 
    0.17121142f, 0.31385103f, -0.12821880f, -0.03113462f, 0.01703543f, 0.09008811f, -0.01176469f, 0.12133319f, 
    -0.07310379f, 0.08082777f, -0.08432276f, 0.00621590f, -0.11354487f, 0.21534599f, -0.08967343f, 0.13683702f, 
    -0.03809893f, -0.01783495f, -0.00021265f, 0.00845835f, 0.04261413f, -0.02317348f, 0.08663525f, -0.10741412f, 
    0.26379114f, 0.12007351f, -0.14520253f, -0.00063431f, 0.03272598f, 0.03369557f, 0.06249161f, -0.03676821f, 
    -0.04136699f, 0.03183907f, -0.00874180f, -0.04322617f, 0.31464800f, 0.06308294f, -0.06705094f, 0.18131241f, 
    -0.01564205f, -0.00030241f, 0.06230128f, 0.02088710f, 0.06519667f, 0.01789686f, -0.00540330f, -0.02813143f, 
    0.24140804f, 0.15337430f, 0.09506062f, -0.00604782f, 0.04406435f, -0.12327345f, 0.01723382f, 0.09138391f, 
    0.05362931f, 0.06890257f, 0.08271309f, -0.03514374f, -0.07069789f, 0.04409515f, 0.10624216f, 0.11955713f, 
    0.06760859f, -0.00993352f, 0.06221840f, 0.02880294f, -0.00811401f, -0.10999729f, 0.02709530f, 0.01203706f, 
    0.10613319f, 0.14056015f, 0.15997003f, -0.02957271f, -0.05615753f, -0.14041744f, -0.15004836f, -0.08025039f, 
    -0.03218130f, 0.02939829f, 0.04495063f, -0.05159834f, 0.16800438f, 0.04696695f, 0.07980172f, 0.06721964f, 
    0.02977083f, -0.02247381f, 0.02466819f, 0.05919946f, -0.02840668f, -0.09676920f, -0.00531026f, 0.01846231f, 
    -0.17591946f, -0.14505632f, 0.23838672f, 0.07910366f, 0.07665916f, 0.04782695f, 0.06698213f, 0.07775538f, 
    0.07229657f, 0.04492220f, 0.05629346f, 0.05189677f, 0.01101396f, 0.18228760f, 0.19349878f, 0.12779328f, 
    0.07758370f, -0.04291093f, 0.11692471f, -0.01056779f, 0.02186295f, -0.06582835f, -0.05532169f, -0.04714493f, 
    0.16029012f, -0.05404424f, -0.12840964f, 0.24903476f, -0.03601956f, 0.01268298f, 0.19212379f, 0.02024688f, 
    0.03777264f, -0.00879802f, -0.08031218f, -0.08214504f, -0.01571099f, 0.08196176f, 0.03556119f, 0.14850400f, 
    0.00064436f, 0.01405858f, -0.05994383f, -0.03426450f, 0.05439912f, 0.09870002f, 0.01672946f, -0.03735880f, 
    -0.23813842f, -0.37230968f, -0.12588175f, 0.23705845f, 0.02127039f, 0.09827515f, -0.04052018f, 0.09837279f, 
    -0.00303111f, 0.07846133f, 0.04952330f, -0.00979703f, 0.03845784f, -0.10778920f, -0.07476432f, -0.05467123f, 
    -0.03008769f, 0.14468001f, 0.02486461f, 0.06153264f, 0.06499013f, 0.18456583f, -0.05649387f, 0.00195573f, 
    0.11842492f, 0.21774466f, -0.13243525f, -0.02665976f, 0.02571070f, 0.00194241f, -0.01345744f, -0.09604773f, 
    -0.02997012f, -0.08067989f, -0.00215936f, -0.01169698f, -0.27612588f, 0.00660895f, -0.06436165f, 0.04622458f, 
    -0.16106094f, -0.01761434f, -0.03794445f, 0.00143727f, 0.00805391f, -0.04959080f, 0.14009543f, 0.17411740f, 
    0.11854371f, -0.09754642f, -0.09239543f, 0.07607030f, -0.06584393f, -0.06905106f, 0.05211245f, 0.09660539f, 
    -0.20550522f, -0.05301428f, 0.01090164f, -0.04534695f, 0.00637889f, 0.12021177f, -0.13767485f, 0.04440537f, 
    0.10687274f, -0.07876563f, 0.01816642f, -0.02529945f, -0.01267713f, 0.11443733f, 0.12347388f, 0.02920823f, 
    -0.45388681f, -0.19226186f, -0.22117546f, -0.03528578f, 0.02759894f, 0.03601138f, 0.00523064f, -0.01011647f, 
    0.05961202f, 0.15893500f, 0.06771427f, 0.01157166f, -0.12942277f, -0.01196309f, -0.03333922f, 0.11356614f, 
    -0.08224326f, 0.02386478f, 0.06525603f, -0.01954402f, -0.03046846f, -0.04131858f, 0.05953229f, -0.10924028f, 
    0.44454306f, 0.15135093f, 0.29786587f, -0.14172240f, 0.13624851f, 0.03605297f, -0.00548114f, 0.04320878f, 
    0.02349813f, 0.07229783f, 0.10402342f, 0.04610397f, 0.23327707f, 0.15260559f, 0.06131255f, -0.18751884f, 
    0.21143709f, 0.00206248f, 0.07926157f, -0.02735917f, -0.01466584f, -0.02952519f, 0.06847274f, -0.02723569f, 
    -0.21406090f, -0.06079905f, -0.11096507f, 0.01224913f, -0.04664081f, 0.05023128f, 0.02489059f, 0.04891335f, 
    -0.08224051f, 0.03328959f, -0.08780496f, -0.09728586f, 0.18752760f, -0.10264676f, -0.01167887f, -0.05615637f, 
    0.09795156f, 0.08688949f, -0.07449280f, 0.05142798f, 0.05034351f, 0.04308858f, 0.03938384f, -0.00369620f, 
    -0.08271527f, -0.08343088f, -0.07588591f, 0.00860767f, -0.09657481f, -0.04076473f, -0.02942350f, -0.07749854f, 
    0.01746820f, 0.01215814f, 0.01372039f, 0.04959762f, 0.27467367f, -0.12255083f, -0.08456831f, -0.08822051f, 
    0.11362953f, 0.11468482f, 0.02199154f, 0.05468670f, -0.07351121f, 0.09636549f, 0.14219454f, -0.00170287f, 
    0.02823533f, -0.13545258f, 0.22871852f, -0.07354847f, 0.10848653f, 0.04864028f, 0.07815550f, 0.17672667f, 
    0.12973537f, 0.01574237f, 0.10131565f, 0.02547396f, -0.08138868f, -0.00068665f, 0.21604313f, 0.09147985f, 
    -0.09343780f, 0.05549288f, -0.02452451f, -0.00330102f, -0.04758203f, -0.06236752f, -0.07146752f, 0.09962960f, 
    0.17109120f, 0.09452409f, 0.18570386f, 0.18346049f, 0.05008967f, 0.01330734f, 0.00375928f, -0.00943174f, 
    -0.06887268f, -0.03860538f, -0.02917514f, 0.01227575f, -0.15399678f, 0.04246584f, 0.05493439f, 0.01178183f, 
    -0.00083436f, -0.09063747f, 0.00689597f, -0.12729451f, 0.02389784f, -0.02934319f, -0.03237960f, 0.02572069f, 
    -0.04706668f, -0.02264254f, 0.05220263f, 0.00048146f, -0.18314634f, 0.00555505f, -0.08041915f, 0.02036422f, 
    0.01904140f, 0.04409830f, 0.09666147f, -0.02410569f, 0.23860197f, 0.29389241f, -0.14068067f, -0.02025242f, 
    -0.23127721f, 0.14661461f, 0.04255432f, 0.06668375f, 0.00581591f, 0.01696830f, 0.05236186f, 0.01225161f, 
    0.16853911f, -0.13520604f, 0.27737734f, -0.07941294f, 0.12518638f, 0.05917939f, 0.11829776f, 0.09017570f, 
    -0.00611138f, 0.03207255f, 0.04765385f, 0.04574586f, -0.02201688f, -0.10183480f, 0.05464250f, 0.02020915f, 
    0.10447907f, -0.07433210f, 0.01872693f, 0.06403375f, 0.09751683f, 0.11685644f, 0.10930347f, 0.08020262f, 
    -0.15074167f, -0.08813479f, -0.06514078f, -0.05820589f, 0.02047122f, 0.08183492f, -0.10901512f, 0.04728746f, 
    0.02548128f, 0.10520332f, 0.08186354f, -0.03597628f, -0.11277929f, -0.02643308f, 0.03071096f, -0.02794126f, 
    -0.10452604f, -0.04486781f, -0.11289144f, -0.05607904f, -0.11960992f, -0.06108021f, -0.08918386f, -0.04438006f, 
    0.15172739f, -0.05538214f, -0.08390246f, -0.08267086f, 0.05478046f, -0.08792046f, 0.09705184f, 0.10747657f, 
    -0.06293765f, 0.04438430f, -0.03175030f, -0.03400621f, -0.02172255f, 0.02538227f, -0.07075386f, -0.02406736f, 
    -0.02313890f, 0.06166038f, -0.02448314f, 0.08143041f, 0.04622248f, -0.03689338f, 0.00942467f, -0.00742093f, 
    0.07527173f, -0.02580882f, 0.03677741f, -0.17246532f, 0.03864817f, 0.02808363f, -0.11044469f, 0.14925839f, 
    -0.13440935f, -0.09084836f, -0.09038578f, -0.02524915f, -0.01215172f, 0.16782075f, 0.05666843f, 0.15897073f, 
    -0.04869568f, -0.09788749f, -0.10950824f, -0.05762227f, -0.08736742f, -0.05645190f, 0.03952460f, -0.00501331f, 
    0.34991580f, -0.00755865f, 0.07142583f, 0.00461020f, 0.00126663f, -0.03788778f, 0.02451876f, 0.01312652f, 
    0.08668744f, 0.11173865f, 0.08650482f, -0.02476537f, 0.23422199f, 0.00606966f, 0.02620967f, -0.14478604f, 
    -0.00628070f, 0.08796057f, -0.07787116f, 0.03410426f, 0.09103581f, -0.01637991f, -0.00339129f, 0.00825330f, 
    0.16018075f, 0.54451495f, -0.10348446f, 0.10517262f, 0.02627382f, -0.12981436f, 0.00689951f, 0.01757361f, 
    0.06062974f, -0.04791337f, -0.02954346f, 0.10086942f, -0.06750111f, 0.16916433f, -0.16352627f, -0.03184563f, 
    -0.06635466f, -0.02796228f, -0.02130589f, -0.05858124f, 0.07705126f, 0.06573847f, -0.09733593f, 0.20031126f, 
    0.03897088f, -0.01829196f, -0.01379129f, 0.00096419f, -0.05200105f, -0.03630370f, -0.05322713f, 0.00206264f, 
    -0.02218072f, -0.05630563f, 0.00074109f, 0.02335192f, 0.02851554f, 0.00347511f, -0.04453779f, 0.03428786f, 
    -0.05460528f, -0.05833298f, 0.00982019f, 0.02517486f, 0.02616294f, -0.01074660f, 0.04770000f, -0.03971742f, 
    0.02602244f, -0.05862778f, -0.02702020f, 0.01068509f, -0.00917734f, -0.04234331f, -0.05757367f, 0.02539562f, 
    0.00034014f, 0.02631044f, 0.00078309f, 0.03289196f, -0.04183378f, 0.01066994f, 0.01783956f, -0.02029646f, 
    0.01534663f, 0.04171349f, -0.05547868f, -0.04164257f, -0.04334788f, 0.02888293f, -0.03211771f, 0.01358529f, 
    -0.00827685f, -0.04131671f, -0.00593463f, 0.00754164f, 0.02388735f, -0.05660250f, 0.03075078f, 0.04014456f, 
    0.02554720f, 0.03548923f, 0.02719580f, 0.00891784f, -0.03103476f, -0.01698291f, -0.03313917f, 0.04321611f, 
    0.02923486f, 0.01285341f, 0.03153738f, -0.04392979f, 0.01815694f, -0.00605356f, 0.00796177f, 0.02414060f, 
    0.02571402f, -0.00088215f, -0.03206275f, -0.01016089f, -0.04135317f, -0.02389256f, -0.01325944f, 0.02653574f, 
    0.00546229f, -0.00154644f, 0.02222284f, 0.03558788f, -0.05536746f, -0.04284332f, 0.03630847f, -0.05414023f, 
    -0.05379004f, 0.02924148f, -0.03603797f, 0.00552621f, -0.04600476f, 0.01627581f, -0.02987221f, 0.04032708f, 
    -0.00333744f, 0.02406144f, -0.00438346f, -0.02912308f, -0.02297537f, 0.02906420f, 0.00904304f, -0.02788001f, 
    -0.02667104f, -0.00070290f, -0.00064147f, -0.01495138f, -0.04317695f, 0.01436978f, -0.04987000f, 0.01768878f, 
    -0.02756343f, 0.02556567f, -0.01501895f, 0.02839524f, -0.03784282f, 0.02510919f, 0.00676355f, -0.03797081f, 
    -0.02837136f, 0.02401077f, -0.04860104f, 0.02769517f, -0.03763682f, -0.00726518f, -0.00329941f, -0.03875636f, 
    -0.04689214f, -0.05653954f, -0.01698312f, -0.00905837f, 0.03028244f, -0.00017213f, -0.03971716f, 0.03292854f, 
    -0.03639814f, -0.04451253f, 0.04266725f, 0.00305203f, -0.04850014f, 0.02628125f, -0.04640233f, 0.00807705f, 
    -0.05254119f, -0.05474097f, -0.04002429f, -0.05097689f, -0.00279256f, -0.00497883f, -0.04002283f, -0.04087895f, 
    0.03219856f, 0.04203145f, -0.05508773f, -0.02743185f, -0.03630920f, -0.05441825f, 0.02961799f, -0.01050008f, 
    -0.00662554f, -0.04796988f, -0.04554626f, -0.04902774f, -0.00467379f, 0.00129241f, 0.03862931f, 0.03284693f, 
    0.01568045f, 0.04360566f, -0.04343452f, 0.00062044f, 0.01199379f, -0.02023638f, 0.03496002f, 0.00283792f, 
    -0.05209331f, 0.02036107f, -0.00913102f, -0.03712141f, -0.04413056f, 0.02235596f, 0.01820149f, -0.02495227f, 
    0.01207040f, 0.01882072f, -0.01713195f, 0.00674815f, 0.00126743f, 0.02042098f, 0.01668763f, -0.03882196f, 
    -0.00277674f, 0.04141947f, -0.05809555f, -0.00557439f, 0.03736748f, -0.02213684f, -0.04577896f, -0.00998584f, 
    -0.04273567f, 0.02274868f, -0.04826702f, 0.00524758f, 0.00279763f, 0.00397392f, 0.00449334f, 0.01634271f, 
    0.04829690f, 0.00465049f, 0.03716274f, -0.03083438f, 0.02780284f, 0.00095674f, 0.03671622f, 0.01025517f, 
    -0.01580931f, -0.00577588f, 0.01213297f, -0.04522099f, -0.01988686f, -0.03428655f, -0.04532087f, 0.04587688f, 
    -0.03429096f, -0.01951146f, 0.01985775f, -0.05397133f, -0.04779207f, -0.01396447f, -0.04387794f, -0.03768215f, 
    0.02562680f, 0.02279092f, 0.02548937f, -0.04897647f, 0.02842029f, -0.01579510f, -0.03316428f, 0.03229912f, 
    0.01788725f, -0.03667808f, 0.01740009f, 0.03226371f, 0.03812442f, 0.00684217f, -0.04820203f, 0.03598301f, 
    0.01624754f, 0.00816537f, -0.01149110f, 0.03980237f, 0.02570022f, 0.03785782f, -0.02966316f, 0.03580800f, 
    -0.01950378f, 0.01238403f, -0.02625671f, 0.03303338f, 0.01425857f, -0.04981863f, 0.02888604f, -0.03699221f, 
    0.01963392f, 0.02331667f, -0.01935226f, -0.01018191f, 0.02093290f, -0.01598634f, 0.03042825f, -0.01978583f, 
    -0.02238974f, -0.02019330f, 0.01878847f, 0.01775933f, 0.03660215f, -0.03205282f, -0.00592348f, 0.02752247f, 
    -0.05246179f, 0.04186469f, -0.02571355f, -0.04777393f, 0.02634831f, 0.01944586f, -0.03231117f, 0.01803861f, 
    -0.00041427f, -0.00628503f, -0.02362856f, -0.03861978f, -0.03046573f, -0.02386984f, -0.01618611f, 0.03761939f, 
    0.03763139f, 0.00369843f, 0.00449682f, -0.04425010f, -0.00787040f, -0.00251348f, -0.00510208f, 0.03996134f, 
    0.02762200f, -0.04225357f, -0.02801752f, 0.02246671f, -0.05754310f, -0.04093992f, -0.01984986f, -0.02301072f, 
    0.00032371f, 0.01807292f, -0.05345215f, 0.02241064f, -0.00977900f, 0.01350241f, -0.01281003f, -0.04482445f, 
    0.01134557f, -0.04224201f, -0.01243575f, -0.04145471f, -0.03151212f, 0.01244922f, -0.04130261f, -0.04263619f, 
    -0.01814136f, 0.02600824f, 0.00869002f, 0.01713327f, -0.00110021f, -0.04290275f, 0.03296239f, 0.01879837f, 
    -0.00136084f, -0.05725795f, -0.01481263f, -0.05417317f, -0.05063483f, -0.05135895f, 0.03185426f, 0.01452046f, 
    -0.01822046f, 0.02980356f, 0.02594688f, -0.01075215f, -0.02578422f, -0.03868542f, 0.02206184f, -0.00281573f, 
    0.00070390f, -0.04732065f, -0.05841633f, -0.05027864f, -0.03775628f, -0.05443702f, 0.00616993f, 0.02393597f, 
    -0.02144441f, 0.00335809f, 0.04091258f, 0.01934656f, 0.00475106f, -0.02712467f, 0.00422178f, -0.04422772f, 
    -0.03670381f, -0.01776154f, 0.01913312f, -0.00887299f, -0.02975189f, 0.02393474f, -0.03094087f, 0.00915573f, 
    0.00031017f, 0.04837506f, -0.00059428f, -0.02779966f, 0.01764034f, -0.01347657f, -0.05388626f, 0.01548133f, 
    -0.16068746f, -0.10890944f, -0.18276314f, 0.18334234f, -0.07480643f, 0.15721641f, 0.03118722f, 0.08164971f, 
    0.15639637f, 0.01147393f, -0.02519337f, 0.13605578f, -0.05577463f, -0.20805958f, -0.07420415f, -0.06982961f, 
    0.00998376f, 0.06772232f, 0.10003594f, 0.04874101f, -0.03743377f, 0.12020349f, -0.06965051f, -0.00248380f, 
    0.00094486f, 0.21355070f, 0.03738445f, -0.12368131f, -0.03437727f, -0.02559361f, 0.03393560f, -0.03987049f, 
    0.02323156f, 0.00910935f, 0.00829090f, -0.04027712f, -0.13748308f, 0.05532978f, 0.04162814f, 0.16437358f, 
    -0.13832578f, -0.03270916f, 0.01376794f, -0.08754738f, 0.09957858f, -0.09033435f, 0.11393380f, 0.19000190f, 
    0.24799138f, -0.01784917f, -0.19005345f, 0.07725927f, 0.02719805f, -0.10040195f, 0.02874761f, 0.08356418f, 
    -0.10361354f, -0.08041582f, -0.00435001f, -0.03615252f, -0.20004287f, 0.07570136f, -0.15222718f, -0.04313471f, 
    0.04134350f, 0.03248942f, 0.10377444f, 0.16341063f, 0.09695573f, 0.08383022f, 0.08497100f, 0.02994423f, 
    -0.73905307f, -0.19609110f, -0.34424701f, -0.14830567f, -0.06691705f, 0.01378145f, 0.01434478f, 0.13584800f, 
    0.13374572f, 0.02856478f, -0.03264343f, -0.08278842f, 0.12573373f, 0.09919754f, -0.04570732f, 0.16151176f, 
    0.04992615f, 0.09746403f, 0.12437001f, 0.01455962f, 0.01671722f, -0.12216347f, -0.12830216f, -0.15131631f, 
    0.18900266f, -0.24812400f, 0.32826632f, 0.20753717f, 0.16536699f, -0.10135408f, 0.06434149f, 0.07772110f, 
    0.02714693f, 0.14551461f, 0.06924667f, 0.14467634f, -0.05055108f, -0.08194765f, 0.12118842f, -0.09934688f, 
    0.10965517f, -0.04840254f, 0.00739407f, 0.10112575f, 0.09017289f, -0.01177761f, 0.14131217f, 0.14189845f, 
    -0.15899888f, -0.10263356f, -0.03032624f, -0.10740050f, -0.05932432f, -0.00955083f, 0.02170889f, 0.07033897f, 
    -0.12219708f, -0.08164974f, -0.09384593f, -0.25962406f, -0.03976100f, -0.12407161f, 0.11676085f, 0.05100857f, 
    0.16196446f, 0.16656056f, 0.00498516f, 0.04313127f, 0.08768480f, 0.05703991f, 0.01031065f, 0.12810898f, 
    -0.01519339f, 0.01306472f, -0.01036687f, 0.06153284f, -0.11740149f, 0.01955722f, -0.01045045f, 0.07788834f, 
    0.04181342f, 0.13256432f, 0.08425840f, 0.12354887f, 0.10777175f, -0.10613552f, -0.10531323f, -0.05546821f, 
    0.05337423f, 0.05373273f, -0.00931341f, 0.01036233f, -0.05036888f, 0.13158917f, 0.15777373f, 0.01797492f, 
    -0.11574470f, -0.33827618f, 0.05913537f, 0.03755156f, 0.12007429f, 0.07598516f, 0.02291925f, 0.17538105f, 
    0.06582805f, 0.07741975f, -0.02620182f, 0.02299896f, -0.15099281f, -0.03449202f, 0.11851323f, 0.10593598f, 
    0.07636045f, -0.00862422f, 0.03875824f, -0.00332460f, -0.06823099f, -0.01314086f, -0.15363212f, 0.07542215f, 
    0.28421512f, 0.13429743f, 0.19349608f, 0.16779907f, 0.06573376f, 0.06483704f, 0.06035958f, -0.04891978f, 
    0.01658311f, -0.02645559f, -0.05872983f, -0.06220261f, -0.12603728f, 0.02130179f, 0.10802563f, -0.08005632f, 
    -0.00555894f, -0.06577510f, -0.03967952f, -0.07114993f, -0.06456616f, -0.03036534f, -0.02484259f, 0.04174676f, 
    -0.10931388f, 0.02345296f, 0.07731893f, -0.04311034f, -0.08208656f, 0.02422566f, -0.01200737f, -0.04042934f, 
    0.07567995f, 0.14676949f, 0.09187780f, 0.00964634f, 0.10962085f, 0.23298746f, 0.05076151f, -0.09321578f, 
    -0.13628489f, 0.10541045f, 0.08540148f, -0.05439092f, 0.06233796f, 0.02823834f, -0.01007282f, 0.00854170f, 
    -0.06749839f, -0.17339611f, 0.17462403f, -0.04092839f, 0.08352501f, 0.00824580f, 0.05913182f, 0.06128921f, 
    -0.03368047f, 0.03968002f, -0.02051249f, 0.05160963f, -0.18983032f, 0.01671895f, -0.05295587f, 0.00079929f, 
    0.10058866f, -0.08895742f, 0.12793694f, 0.03713094f, 0.17102696f, -0.06638504f, 0.07643771f, 0.07804301f, 
    -0.13178949f, -0.02356081f, -0.06599285f, 0.01958753f, -0.00937697f, 0.04656661f, 0.02559804f, 0.02779696f, 
    0.04301734f, 0.03126337f, -0.01451748f, 0.03535323f, 0.06758156f, 0.07755688f, 0.18679847f, 0.07255851f, 
    -0.08174137f, -0.04423151f, -0.14320599f, -0.03822871f, -0.11146960f, -0.03742515f, -0.09862333f, -0.03053831f, 
    -0.05050986f, 0.00186488f, 0.05450783f, -0.06088440f, -0.00172284f, -0.00946009f, -0.05523126f, -0.12096465f, 
    0.09291555f, 0.02895147f, 0.03103631f, 0.00596563f, -0.00496765f, -0.01762172f, -0.09595697f, 0.09464011f, 
    0.01017952f, 0.12016614f, -0.00020413f, -0.05738655f, 0.07967045f, -0.00027931f, -0.00074077f, 0.05053524f, 
    -0.00854065f, -0.12675293f, 0.06371433f, -0.19089378f, 0.05099535f, 0.02806073f, -0.03714227f, 0.08715079f, 
    0.05810234f, -0.06668342f, -0.15278088f, -0.08453956f, 0.19965817f, 0.13183993f, 0.10371695f, 0.05610930f, 
    0.09461588f, -0.05895245f, -0.06910834f, 0.00493684f, 0.08123177f, 0.05406284f, 0.03982005f, -0.00473344f, 
    0.15336627f, -0.08119917f, 0.02551800f, -0.12957326f, -0.03742405f, -0.01642311f, 0.00129553f, 0.04108386f, 
    0.10385505f, -0.01425625f, -0.03980067f, -0.08669971f, 0.06221294f, 0.05866855f, 0.10755258f, -0.02345490f, 
    0.07585339f, 0.00552487f, 0.02659894f, -0.06925877f, 0.09790283f, 0.01737412f, 0.00592461f, 0.11983939f, 
    -0.10247015f, 0.31396151f, -0.00583610f, 0.25895151f, 0.01138754f, -0.13417292f, 0.04187929f, 0.18931869f, 
    0.01601885f, 0.12735312f, -0.13443367f, 0.15250528f, -0.13579519f, 0.23240927f, -0.11362503f, 0.04154761f, 
    -0.10750750f, -0.00954619f, -0.02639195f, 0.00731218f, 0.24023663f, 0.08662945f, -0.20506346f, 0.17226334f, 
    0.00711858f, -0.02251440f, -0.01378596f, -0.02503440f, -0.00169066f, -0.04004426f, 0.03731928f, 0.01767678f, 
    0.02730716f, -0.02774684f, 0.04659150f, -0.00099526f, 0.01563942f, 0.02004632f, -0.00195984f, -0.03371267f, 
    0.02047889f, -0.02043452f, -0.03295708f, -0.01386726f, 0.03443439f, -0.05199712f, -0.04411625f, -0.00498520f, 
    -0.00562725f, -0.04283429f, -0.05200954f, 0.02937091f, 0.03078589f, -0.00469594f, -0.02277162f, -0.03886757f, 
    0.04132988f, 0.01170689f, -0.03700603f, 0.00023816f, -0.04851405f, 0.01744628f, 0.00763559f, 0.02495298f, 
    0.01325457f, -0.00147111f, -0.00780409f, -0.03535339f, 0.03232867f, -0.05021117f, -0.00760185f, 0.03764901f, 
    -0.04003679f, -0.05418163f, 0.04080102f, -0.04843245f, -0.01356134f, 0.03255323f, -0.00795627f, 0.04330121f, 
    0.01310409f, 0.05893118f, 0.02439574f, -0.00604241f, -0.05525204f, 0.00892873f, -0.03674948f, 0.04080232f, 
    0.00555670f, 0.01873906f, -0.01456426f, -0.01948631f, 0.03355065f, -0.05760790f, 0.02680206f, 0.03014360f, 
    -0.01852558f, -0.03775243f, 0.00062666f, -0.02510979f, -0.00628317f, -0.04462421f, -0.04434282f, -0.05675501f, 
    -0.00595224f, -0.01352359f, -0.00229662f, 0.02141918f, -0.05273322f, 0.04936674f, 0.04810714f, 0.00689377f, 
    0.03391875f, 0.00452350f, -0.01363810f, 0.00522402f, -0.02983849f, -0.02401659f, -0.05422173f, 0.01061841f, 
    0.05473760f, -0.05012412f, -0.01161218f, -0.00792450f, 0.00558826f, 0.03119023f, -0.05658730f, -0.00587596f, 
    -0.02472551f, 0.03903596f, 0.01000421f, -0.01835052f, 0.00763374f, -0.00343501f, -0.02997935f, -0.00511812f, 
    -0.04634919f, 0.00502158f, 0.00252037f, -0.00505181f, 0.00204156f, -0.04195401f, 0.03958534f, -0.04747398f, 
    0.02082062f, -0.02898380f, -0.01051475f, -0.02946767f, -0.02721996f, -0.01270579f, 0.02370247f, 0.00278776f, 
    0.02782662f, 0.01003812f, -0.04158079f, -0.02771183f, 0.01842602f, -0.01123667f, -0.03271898f, -0.03236525f, 
    -0.03940037f, -0.02676749f, 0.03160918f, 0.02637001f, -0.00686143f, 0.01765166f, -0.00990911f, 0.02995539f, 
    -0.02482238f, -0.03216845f, 0.01940990f, -0.02627574f, 0.04407739f, 0.02147895f, -0.02488921f, 0.02929075f, 
    0.03249745f, -0.01569252f, 0.00385394f, -0.02097326f, -0.01976594f, -0.02755087f, 0.01864969f, -0.02946614f, 
    0.03096585f, -0.04031631f, -0.03268736f, 0.00256813f, -0.05498357f, 0.02922948f, 0.01687401f, -0.02835401f, 
    -0.05374451f, 0.01234169f, -0.03963280f, -0.03849079f, 0.02998540f, -0.04103673f, -0.03808705f, -0.03265634f, 
    -0.01367136f, -0.02194973f, 0.03858489f, -0.04285371f, -0.02904532f, -0.00714362f, -0.05088499f, 0.01418855f, 
    0.02380222f, -0.02947906f, 0.02065276f, -0.00759429f, -0.03987226f, -0.04890356f, -0.05422487f, 0.04401108f, 
    -0.00568657f, -0.04492230f, -0.05401959f, 0.00538602f, -0.05378365f, 0.00567232f, -0.05109128f, -0.03073524f, 
    -0.03130968f, 0.03752523f, -0.01385568f, -0.01669570f, 0.02594084f, 0.01674771f, -0.00476854f, -0.00249138f, 
    0.01449880f, -0.01909602f, 0.02842025f, -0.04176102f, -0.02843628f, 0.00313867f, 0.01893656f, -0.00795635f, 
    0.00877824f, -0.03915942f, 0.04215436f, -0.05502231f, 0.00655221f, -0.04376481f, 0.02083710f, -0.04287653f, 
    0.03359330f, 0.00558654f, -0.02075167f, 0.01820857f, -0.03513324f, 0.01179687f, -0.01193094f, -0.04236822f, 
    -0.01650015f, -0.03289471f, -0.02141172f, 0.01899749f, 0.01649159f, -0.01570928f, -0.01159634f, -0.02092536f, 
    -0.05690402f, 0.04049373f, 0.02802679f, -0.00183177f, -0.03128018f, -0.03126708f, -0.04784741f, -0.01547712f, 
    0.02442862f, -0.02556296f, 0.03061231f, -0.04703371f, -0.03041643f, 0.02663131f, -0.05087831f, -0.04980940f, 
    0.02788773f, -0.02476268f, 0.03429903f, -0.00783103f, 0.04162843f, 0.01204929f, -0.00828122f, 0.02548675f, 
    -0.02298430f, -0.04621268f, 0.03528685f, -0.04550508f, -0.02290424f, -0.01199753f, -0.04251892f, -0.04697050f, 
    0.01338108f, 0.02514703f, -0.03991703f, 0.03728116f, 0.01517660f, 0.02138202f, 0.02598457f, 0.03905853f, 
    -0.02222918f, 0.01456650f, 0.04132539f, -0.03917830f, 0.04737879f, 0.03116876f, -0.03139495f, -0.02509365f, 
    0.02017416f, 0.00632833f, -0.02894822f, 0.02203283f, -0.02407867f, 0.00224199f, -0.03625642f, -0.00056852f, 
    0.00756615f, -0.02350775f, 0.00918900f, 0.01939106f, -0.03792640f, 0.02695627f, -0.01176978f, 0.00101015f, 
    0.00721359f, 0.01279607f, 0.02927649f, -0.00683973f, 0.03514010f, -0.02837331f, 0.03007373f, -0.01965737f, 
    0.01679121f, -0.05599345f, 0.03111975f, -0.04557667f, 0.00657521f, -0.04426967f, -0.03491543f, 0.00152620f, 
    0.02486635f, 0.03204553f, -0.03202544f, -0.01785955f, -0.02574433f, -0.01531005f, -0.00881752f, -0.01686644f, 
    -0.04511359f, 0.00436678f, 0.02656893f, -0.01125128f, -0.00483879f, 0.03336165f, 0.00493005f, -0.03178599f, 
    -0.02996689f, -0.00547459f, 0.02947371f, -0.03359288f, 0.02314017f, 0.01273871f, 0.02544379f, -0.00123329f, 
    0.05372578f, 0.03019907f, 0.00597368f, -0.01005224f, -0.03174796f, -0.00185247f, 0.01794801f, 0.00961729f, 
    0.00010749f, 0.02284040f, -0.00809633f, -0.03050601f, -0.03864119f, 0.03328503f, -0.00734058f, 0.01719035f, 
    -0.04340097f, -0.03497121f, -0.00962461f, -0.02970482f, -0.00234070f, -0.00767806f, 0.01567336f, -0.04900081f, 
    0.00638125f, 0.02871937f, 0.03077166f, -0.05486327f, 0.01802978f, -0.04568497f, 0.00909534f, 0.00719800f, 
    -0.04939393f, -0.00634246f, 0.03005375f, 0.03067814f, 0.02325906f, -0.03071841f, 0.00659301f, -0.03174077f, 
    -0.23576519f, 0.41599616f, 0.17543796f, 0.04911106f, -0.00182758f, 0.02795970f, -0.00903402f, -0.00262966f, 
    -0.01650657f, 0.04236607f, 0.13985914f, 0.10209852f, -0.00832604f, -0.09333108f, 0.05969143f, -0.05070167f, 
    0.03921490f, -0.09427164f, -0.05711933f, 0.11380078f, -0.02937007f, -0.05153386f, -0.27926463f, -0.12967280f, 
    -0.13499738f, -0.11108910f, 0.16141920f, 0.16448301f, -0.02296811f, -0.16940556f, -0.07852054f, 0.02919634f, 
    -0.01236520f, 0.06838357f, 0.05899315f, -0.04975034f, 0.02432202f, -0.00854176f, -0.12246235f, -0.05280295f, 
    0.05896673f, 0.04441887f, -0.03259138f, -0.04686546f, -0.06898102f, -0.03851933f, -0.09536603f, -0.30614412f, 
    0.15517974f, 0.12430084f, -0.00478770f, 0.01083824f, 0.03601735f, 0.07846415f, 0.03684829f, -0.06051287f, 
    0.22329518f, 0.12187153f, 0.07100269f, 0.11459390f, -0.18145804f, -0.02747403f, 0.02854293f, 0.03465647f, 
    -0.08419415f, 0.08828462f, 0.00149022f, 0.21622860f, 0.08667944f, 0.05057380f, 0.10837590f, 0.01615413f, 
    -0.12500317f, 0.28451732f, 0.20164919f, 0.16013461f, -0.11107574f, -0.07869664f, 0.04322382f, 0.03575179f, 
    0.00099545f, -0.10720821f, 0.02267490f, 0.10069513f, -0.03449151f, 0.09572394f, 0.05440467f, -0.01952502f, 
    0.07616889f, 0.01840760f, -0.01377504f, 0.04534494f, 0.15028940f, 0.11442916f, 0.17008121f, 0.27006730f, 
    0.03410195f, -0.33492213f, -0.23275648f, 0.30205631f, 0.02637640f, 0.01920536f, 0.00686700f, -0.07131475f, 
    0.02283338f, 0.08429807f, 0.24138631f, 0.17113878f, -0.17510431f, -0.15987547f, -0.02560009f, 0.17455508f, 
    -0.17323399f, 0.02432851f, 0.01825797f, -0.00894111f, -0.02682585f, -0.03373462f, 0.00438584f, 0.09011565f, 
    -0.03063568f, -0.01830129f, 0.05480175f, -0.10818536f, -0.06090021f, -0.02604411f, 0.02917374f, 0.05953561f, 
    0.20357144f, 0.17629938f, 0.23971850f, 0.13422576f, -0.11086511f, 0.00532588f, 0.05858690f, -0.06315744f, 
    -0.07967653f, -0.05743556f, 0.06464620f, 0.01759857f, -0.12357564f, -0.06897828f, -0.09747241f, -0.13930628f, 
    -0.02529909f, 0.02312999f, -0.06273717f, 0.12969354f, -0.04743969f, -0.04806663f, 0.04641499f, 0.01509629f, 
    0.01654175f, -0.04189698f, -0.01278176f, -0.00705972f, -0.14718290f, 0.06294941f, 0.15657274f, 0.18860579f, 
    0.02258768f, -0.05411725f, 0.09510059f, 0.05420841f, 0.08988295f, -0.05510040f, -0.06256714f, 0.07658226f, 
    0.13620561f, -0.02763381f, -0.15935613f, 0.09971257f, 0.02667802f, -0.05175393f, 0.08412434f, -0.11389135f, 
    0.03931808f, 0.03753863f, -0.05220000f, 0.08320764f, 0.31153399f, 0.19141725f, 0.05718879f, -0.01620561f, 
    0.07562727f, 0.03504269f, 0.02839804f, 0.03325075f, -0.09352161f, -0.08078710f, -0.08527077f, -0.00794173f, 
    0.28078243f, 0.18984368f, 0.04479689f, 0.01389497f, -0.01828862f, 0.06186080f, -0.01394329f, 0.11361165f, 
    -0.02766546f, -0.03804640f, 0.02589309f, 0.04933011f, -0.00798582f, -0.11871821f, -0.07678656f, -0.08817124f, 
    0.03291175f, -0.03854084f, -0.06148014f, -0.01476137f, 0.03278818f, -0.12210423f, 0.08733375f, 0.16818458f, 
    0.01400175f, -0.01372326f, -0.07997969f, 0.07774127f, 0.10434201f, 0.00412633f, 0.05298384f, 0.02649374f, 
    0.01255934f, -0.14561102f, -0.26229200f, 0.06044541f, -0.20162080f, -0.08588608f, 0.08992376f, 0.05243627f, 
    0.08535793f, -0.06517546f, 0.00645972f, -0.10390452f, -0.06496727f, 0.04469958f, -0.05809672f, -0.05224200f, 
    0.06806625f, 0.00501320f, 0.10664254f, -0.00120276f, 0.04064899f, 0.15539512f, -0.07126877f, -0.01227950f, 
    0.06190416f, -0.09914596f, -0.02181446f, -0.05667319f, -0.10663380f, 0.00465052f, 0.08990767f, 0.30055764f, 
    0.10268713f, -0.08625942f, -0.01412482f, 0.18179703f, 0.10611180f, 0.10025239f, -0.08324799f, 0.04809549f, 
    0.17298988f, 0.08796508f, 0.05557082f, -0.06882136f, 0.10333722f, 0.00334242f, 0.17475097f, -0.03396951f, 
    0.00667112f, -0.12587222f, 0.01936725f, -0.03747842f, 0.09219618f, -0.05562631f, -0.04517842f, -0.08233353f, 
    -0.04870071f, -0.00469755f, 0.03501362f, 0.00422145f, -0.02953328f, -0.02907231f, -0.01425162f, -0.10952426f, 
    -0.13936146f, -0.13418636f, 0.11596240f, 0.06286959f, -0.14194357f, 0.12289579f, -0.03079162f, -0.21075884f, 
    0.04475686f, -0.01432642f, -0.00351083f, -0.07760800f, 0.11451422f, -0.07927202f, -0.03798757f, -0.02938759f, 
    0.04544782f, 0.02535957f, 0.10050590f, -0.03872847f, 0.00590005f, -0.07560550f, -0.09975469f, -0.13144261f, 
    -0.11355274f, 0.03907377f, 0.02640427f, 0.00223029f, -0.07123577f, 0.00745674f, 0.07942836f, -0.08569592f, 
    0.08708857f, 0.07033504f, 0.17984630f, 0.15294933f, 0.19321308f, -0.20911396f, 0.23746890f, -0.11182775f, 
    0.04914124f, -0.05813373f, -0.08279936f, 0.11598343f, -0.02123597f, -0.18168700f, -0.00267697f, -0.17993186f, 
    -0.02989689f, -0.20683834f, -0.01357985f, -0.10589713f, 0.00539929f, -0.00105667f, -0.02610239f, 0.08103128f, 
    0.01047907f, 0.15075195f, 0.23612361f, 0.16917652f, -0.10422661f, -0.10299409f, 0.20773923f, 0.07482599f, 
    0.01919873f, -0.00453961f, 0.03538530f, -0.25988609f, 0.00033042f, -0.08211322f, -0.00064892f, 0.12147212f, 
    -0.27461624f, -0.07223342f, -0.34051445f, 0.44056410f, 0.11532427f, 0.08867367f, 0.14508475f, 0.00443245f, 
    -0.07409918f, 0.14667700f, 0.06703187f, 0.01351382f, -0.08946127f, -0.04000512f, -0.11515211f, 0.02879519f, 
    0.07023187f, -0.08016365f, -0.05013800f, -0.00333441f, 0.06800067f, 0.04236252f, -0.00291395f, 0.00527365f, 
    -0.03756871f, -0.04857700f, 0.02439734f, -0.02706598f, -0.02341309f, 0.02297364f, 0.01636195f, 0.01040910f, 
    -0.00005941f, -0.01353289f, -0.05414089f, -0.00887766f, -0.00651992f, 0.02742297f, -0.03883549f, 0.01621851f, 
    0.03894553f, 0.00674454f, -0.01340609f, -0.05100723f, 0.00336654f, -0.03839832f, -0.02183411f, -0.00469272f, 
    0.04310893f, -0.04357360f, 0.00756480f, 0.01120831f, -0.00308649f, -0.00770973f, 0.04023185f, -0.05153599f, 
    -0.05475639f, 0.01641671f, -0.03360704f, 0.04487278f, -0.02891756f, 0.04359394f, -0.00060750f, -0.05583059f, 
    0.01848803f, -0.02579546f, 0.00455332f, -0.04004314f, 0.00169321f, -0.02756377f, -0.00115282f, -0.03967916f, 
    -0.03163963f, -0.03018713f, -0.03289869f, -0.04778914f, -0.02016054f, -0.03599352f, -0.03996665f, -0.01327945f, 
    -0.04722355f, -0.01575186f, -0.02725068f, 0.03040564f, 0.01992785f, -0.00998645f, 0.03660603f, -0.03178207f, 
    -0.01649580f, 0.00125323f, 0.03733408f, 0.01943553f, -0.02121681f, 0.03930945f, -0.03944668f, 0.01777135f, 
    -0.00064565f, -0.02916841f, 0.03566733f, 0.01141068f, 0.01873798f, 0.03074386f, 0.00479986f, -0.02327296f, 
    0.04591088f, -0.00645549f, -0.01308826f, 0.03241323f, -0.04678805f, 0.01295081f, 0.03678755f, -0.00377565f, 
    -0.03780585f, -0.02962504f, 0.02023570f, -0.04404994f, -0.04122196f, 0.03939083f, -0.05380380f, -0.00267403f, 
    -0.01237820f, 0.01641375f, 0.00922114f, -0.05359848f, 0.02068526f, -0.04659980f, 0.01942711f, 0.01562662f, 
    -0.03786479f, 0.02596643f, -0.04427339f, -0.00591620f, 0.00593000f, 0.04091475f, 0.02697751f, 0.00377179f, 
    -0.03350512f, -0.03653501f, 0.03223490f, -0.02308474f, 0.04813863f, -0.04963470f, 0.02969545f, 0.01514620f, 
    0.03444545f, 0.02414847f, 0.00331521f, -0.00760026f, 0.01825605f, -0.04661537f, 0.01815543f, -0.03126967f, 
    0.03337637f, -0.04303315f, 0.03379710f, 0.02232329f, 0.00118973f, 0.00833156f, 0.00541290f, -0.02644595f, 
    -0.03121320f, 0.01848403f, -0.05332453f, 0.03647511f, 0.04003436f, 0.02032452f, -0.03220423f, -0.00109670f, 
    -0.04537576f, -0.00139737f, -0.02815423f, -0.03751675f, 0.00278683f, -0.04752294f, 0.02839033f, -0.01287016f, 
    -0.04097408f, -0.01998108f, -0.03600217f, 0.01376429f, 0.01590123f, 0.00860802f, -0.03898051f, -0.01866325f, 
    0.04100769f, 0.03725699f, -0.00373003f, -0.05473919f, -0.02047564f, -0.01810991f, 0.03086567f, 0.00009646f, 
    0.02352268f, -0.00435238f, -0.04460571f, -0.00866475f, 0.03604846f, -0.05192259f, -0.05410740f, 0.02827009f, 
    0.03392697f, -0.03640526f, -0.01927227f, -0.03015433f, -0.03846123f, 0.04075773f, -0.02164836f, -0.03830789f, 
    -0.03252486f, -0.00572289f, 0.01490706f, 0.03813239f, -0.01023598f, 0.04897613f, -0.02220646f, 0.02078729f, 
    -0.03271138f, -0.00778932f, 0.00055609f, -0.03307327f, 0.03536372f, -0.01848939f, -0.00480401f, 0.01703350f, 
    0.02684351f, 0.02636814f, -0.03709438f, -0.00801527f, -0.00421722f, -0.03750928f, -0.00794544f, -0.00843210f, 
    -0.03359630f, 0.04555803f, -0.03236631f, -0.00811355f, -0.03182028f, -0.01817764f, -0.03403623f, -0.01539326f, 
    -0.03783280f, 0.01738135f, -0.00918638f, -0.00267734f, 0.04226634f, -0.02142709f, -0.04390899f, -0.01267828f, 
    -0.05125587f, -0.00984566f, 0.04624889f, -0.02571598f, 0.02833805f, 0.01123935f, 0.03486664f, 0.00785877f, 
    0.03354779f, -0.01038707f, 0.00925216f, -0.04622413f, 0.01777459f, -0.02989823f, -0.04841334f, 0.01738317f, 
    0.01349108f, 0.04278451f, -0.01977203f, 0.03511249f, 0.02899521f, -0.02810786f, 0.02151052f, 0.05000181f, 
    -0.03199140f, -0.04393138f, 0.00029867f, -0.00790230f, -0.00536936f, -0.04790767f, 0.03877001f, -0.04419160f, 
    0.00076680f, -0.00821084f, -0.01382130f, 0.03486360f, 0.00050363f, 0.00837100f, 0.03866044f, -0.00304178f, 
    0.04455981f, 0.00868370f, -0.03683974f, 0.04202970f, -0.00466815f, -0.02736448f, 0.02857100f, 0.04578141f, 
    -0.03311841f, -0.02919868f, 0.01801779f, 0.01927652f, -0.02269747f, 0.00050167f, 0.00088677f, -0.04755078f, 
    -0.02021708f, -0.03922524f, -0.03488431f, -0.03394874f, -0.01085038f, 0.01893845f, -0.04147555f, -0.04303594f, 
    0.00466508f, -0.01101728f, 0.00907627f, 0.03960055f, -0.03064168f, 0.01116927f, -0.03238519f, -0.05178672f, 
    0.01409511f, 0.02619664f, -0.02574067f, -0.03460616f, -0.05009487f, 0.00990370f, -0.00672784f, -0.00467909f, 
    -0.00597382f, -0.03987658f, -0.01537710f, -0.05116881f, -0.01252443f, 0.03820494f, -0.03733031f, -0.02737520f, 
    -0.04814519f, -0.02993924f, -0.04356438f, 0.02273273f, 0.02284250f, -0.03591330f, 0.03038024f, 0.00467894f, 
    0.02815344f, -0.01155386f, -0.02273414f, -0.04358318f, 0.02449508f, -0.01322522f, -0.03750027f, -0.02134538f, 
    -0.03509697f, -0.03311453f, -0.00369407f, 0.04596831f, -0.00385073f, -0.03625565f, 0.03387965f, -0.04225903f, 
    -0.02638841f, 0.00532971f, -0.02572051f, -0.03475603f, -0.04537702f, 0.01746777f, 0.02409713f, 0.00684337f, 
    -0.02870353f, -0.01782584f, -0.04953723f, -0.04134932f, -0.03142233f, -0.02625398f, -0.01926649f, 0.02830037f, 
    0.02942892f, -0.03307181f, -0.03918372f, 0.04240306f, 0.00236293f, -0.05071948f, -0.02218515f, -0.02205737f, 
    0.01304170f, 0.03664394f, -0.00208588f, -0.04145962f, 0.03554270f, 0.03429126f, 0.03934072f, -0.02442082f, 
    -0.03213102f, -0.04403479f, -0.03514766f, -0.03974650f, 0.02553005f, -0.02644039f, -0.03369385f, 0.00089396f, 
    -0.01151307f, 0.02366740f, -0.00974578f, -0.04886102f, -0.04868022f, -0.01463458f, -0.01213875f, -0.02935420f, 
    -0.16009204f, -0.21446383f, 0.21030280f, -0.14435717f, 0.03182207f, 0.09566188f, 0.10376284f, 0.08202965f, 
    0.10099570f, -0.03635151f, 0.21305114f, 0.10384337f, -0.00880834f, -0.11844862f, 0.06708380f, -0.07370993f, 
    0.04856814f, -0.08263162f, 0.00760844f, 0.06301184f, 0.00085445f, 0.19564663f, -0.13750271f, -0.04164184f, 
    -0.13614120f, 0.02697458f, 0.19219176f, -0.08834519f, -0.07176339f, -0.06597608f, 0.09507750f, -0.13148148f, 
    0.04031029f, 0.04701905f, 0.00165047f, -0.07410358f, -0.13009962f, -0.01932830f, 0.02334544f, -0.07673495f, 
    -0.04951949f, 0.05212219f, -0.01454298f, -0.07177240f, -0.03307225f, -0.03288860f, 0.07934850f, -0.00345041f, 
    0.24972589f, 0.35039139f, -0.06336091f, 0.12583475f, 0.08127392f, -0.14816026f, 0.02604507f, -0.04513779f, 
    -0.08473073f, 0.01643872f, 0.13236523f, -0.07796780f, -0.07824460f, -0.23587354f, 0.09055319f, -0.01919516f, 
    0.09171591f, -0.01425723f, 0.02947002f, 0.15904364f, 0.09814178f, 0.16714180f, 0.11250490f, 0.01329316f, 
    -0.50753391f, -0.09646878f, -0.06219903f, -0.00673506f, 0.01693693f, 0.06902196f, 0.00895897f, -0.06020353f, 
    0.17332645f, 0.04540747f, 0.07484123f, 0.09644087f, -0.06047632f, 0.06102536f, 0.09954765f, 0.25997639f, 
    0.01917347f, 0.08125588f, 0.17241338f, 0.00074353f, 0.16048123f, 0.09607086f, 0.03501373f, 0.00195796f, 
    0.42286715f, -0.40421376f, 0.11583807f, 0.33674139f, 0.10406274f, -0.03242877f, -0.00591622f, -0.06108654f, 
    0.08346210f, 0.19619355f, 0.26355931f, 0.18789238f, -0.10337009f, -0.17460895f, 0.09557261f, -0.00539507f, 
    0.03746459f, -0.04107259f, -0.04910256f, 0.00215651f, 0.07002002f, 0.01656706f, 0.18664235f, 0.14188150f, 
    -0.11800724f, -0.04969306f, -0.01258303f, -0.00395059f, -0.06909923f, 0.00837844f, 0.08243640f, -0.00647682f, 
    -0.10762075f, 0.07591195f, -0.01301688f, -0.11371407f, -0.00375913f, -0.24627018f, -0.14827387f, -0.08509982f, 
    0.11696506f, -0.05760222f, -0.05557306f, 0.04106000f, 0.07526624f, -0.01711231f, -0.01460489f, 0.00782108f, 
    0.01470297f, -0.12790604f, 0.08215558f, -0.06857935f, -0.02900714f, 0.02737065f, -0.02155870f, -0.01865537f, 
    0.13612995f, 0.16737761f, 0.00708088f, 0.12516275f, -0.05563997f, -0.29033369f, 0.02243167f, -0.07748755f, 
    -0.02686540f, 0.03076872f, 0.00028045f, 0.12228756f, 0.03129205f, 0.10185693f, 0.21072908f, 0.14177948f, 
    -0.24003726f, 0.01264444f, -0.18448204f, 0.10904770f, 0.20398802f, 0.13834065f, -0.01098674f, 0.08630661f, 
    0.11250719f, 0.06173082f, 0.03799973f, 0.14047514f, -0.08369423f, -0.09030063f, -0.04696116f, -0.04923258f, 
    0.15862165f, 0.09625854f, 0.07918322f, 0.07191832f, -0.05724420f, -0.05005648f, -0.09386379f, 0.05643948f, 
    0.37241364f, 0.10031395f, -0.11456574f, 0.03864644f, 0.13345428f, 0.16165741f, 0.12754610f, 0.16564789f, 
    0.07148074f, -0.03640343f, -0.06717849f, -0.00250735f, -0.18994595f, 0.08123028f, 0.06996840f, 0.07178338f, 
    -0.03396860f, 0.00095861f, -0.03727632f, -0.11942703f, -0.06337141f, -0.08724798f, 0.15748249f, 0.01199739f, 
    0.02988928f, -0.05637555f, -0.03028079f, 0.04176878f, 0.01674966f, -0.01140473f, 0.00551617f, -0.06803780f, 
    0.06271791f, -0.00399546f, 0.07508324f, 0.05066875f, -0.09527831f, 0.08928446f, 0.29269570f, -0.04940080f, 
    -0.17364095f, 0.21784489f, -0.02898868f, 0.00408853f, 0.03369794f, 0.04918371f, 0.00239768f, -0.02422968f, 
    0.09879361f, -0.01381272f, 0.18349861f, -0.01938103f, 0.12135083f, 0.01257238f, 0.03586628f, -0.01976722f, 
    0.08275283f, -0.06984571f, -0.02974727f, 0.04036529f, 0.10965914f, -0.20646177f, 0.15757251f, 0.03752232f, 
    0.04464289f, -0.10885649f, -0.02460354f, -0.05237245f, 0.12680408f, 0.10012158f, -0.03418064f, 0.08785158f, 
    0.01504930f, 0.11817685f, 0.05251668f, 0.01240721f, 0.06576275f, 0.11040182f, 0.10974989f, 0.14821163f, 
    0.10201816f, -0.01817259f, -0.03765242f, -0.07449061f, -0.09901930f, -0.00358494f, -0.01168372f, -0.08919881f, 
    0.06456071f, 0.01554915f, 0.05311492f, 0.03695283f, -0.07440488f, -0.05934153f, -0.00706230f, -0.13439846f, 
    -0.09772284f, -0.03838336f, 0.01145846f, 0.03008531f, 0.00861025f, -0.06467469f, 0.09562092f, -0.05113079f, 
    0.02479049f, 0.01798267f, -0.00027531f, 0.03608558f, -0.07131100f, 0.04920304f, -0.14280234f, 0.02338466f, 
    0.08406758f, 0.01469483f, -0.03033834f, -0.02037187f, 0.11189250f, -0.02103086f, -0.01131840f, -0.05595114f, 
    -0.13039698f, -0.07880733f, -0.10065266f, -0.14946666f, 0.03284676f, -0.02180718f, 0.01736811f, 0.08521000f, 
    0.03373684f, 0.02875502f, 0.05435728f, -0.00003296f, 0.13362798f, 0.03357241f, -0.05084644f, 0.03717174f, 
    0.12020002f, 0.02611961f, -0.06502014f, 0.05746279f, 0.03320093f, 0.00207841f, 0.09323603f, -0.10779616f, 
    0.42294711f, -0.15300964f, -0.14801764f, -0.00393254f, 0.07856835f, -0.06628304f, -0.06080204f, 0.00475005f, 
    0.00641702f, 0.07643975f, 0.03392424f, 0.03846555f, -0.03604762f, -0.06286345f, -0.05022810f, 0.07989600f, 
    -0.05625657f, -0.09103327f, -0.04352896f, -0.06031353f, 0.21482998f, 0.05861527f, 0.14630391f, 0.07976767f, 
    -0.58893782f, -0.02557375f, -0.30839422f, 0.12913664f, 0.12192190f, -0.02225707f, -0.06040929f, 0.16671874f, 
    0.00699672f, 0.08219744f, -0.08824886f, 0.16679357f, -0.18827844f, 0.27034733f, -0.16393274f, 0.02056196f, 
    0.00567167f, 0.05289210f, 0.00068796f, -0.10500335f, 0.13911670f, -0.21021286f, -0.09370685f, 0.19108754f, 
    0.27941945f, 0.06534158f, -0.17041786f, -0.11515818f, 0.10643453f, 0.08793168f, 0.03292912f, 0.13784330f, 
    0.18071681f, 0.02728249f, 0.04923788f, 0.00554299f, -0.12754115f, -0.03049901f, 0.04584884f, -0.04888567f, 
    -0.06856328f, -0.06636343f, 0.03733554f, -0.08040854f, -0.20772831f, -0.09167106f, -0.01043067f, 0.03641426f, 
    0.10048655f, 0.13678917f, 0.17243977f, -0.05935660f, -0.12085302f, 0.09617735f, 0.00001428f, -0.02031169f, 
    0.08271126f, 0.04509202f, 0.02443297f, 0.04313169f, 0.08138531f, -0.01609608f, 0.02128692f, -0.03213383f, 
    -0.00225683f, -0.00297794f, -0.01476942f, 0.02650863f, 0.11854414f, 0.01988702f, 0.04241313f, -0.02466399f, 
    0.23184636f, -0.15216321f, -0.01901190f, 0.07549160f, 0.03038737f, 0.01519611f, 0.01193364f, 0.13831080f, 
    0.20199303f, 0.04130905f, 0.02821855f, -0.12563869f, 0.24037963f, -0.11284466f, -0.10437189f, -0.21823506f, 
    0.00085869f, 0.06033636f, 0.12633121f, 0.05549132f, 0.07035854f, -0.00322717f, -0.03929288f, 0.01772761f, 
    -0.18875398f, -0.15450831f, -0.33397228f, -0.17161819f, -0.07245593f, 0.02517220f, -0.10326392f, 0.09552269f, 
    0.11171863f, -0.06894040f, 0.06767728f, -0.05215687f, 0.19537936f, 0.00377641f, -0.02921271f, -0.15268223f, 
    0.02056020f, 0.02531184f, 0.13793941f, 0.04362175f, 0.04597438f, -0.01920697f, -0.04248433f, -0.01674150f, 
    0.18460332f, -0.36740521f, 0.30911267f, 0.12737830f, 0.02328220f, 0.05043356f, -0.00578828f, 0.07073713f, 
    -0.04907293f, 0.06699230f, 0.10801437f, 0.01810144f, 0.23129745f, 0.06861436f, 0.18076330f, -0.03320207f, 
    -0.04610435f, 0.02616662f, 0.02107981f, 0.00994224f, 0.10389724f, 0.02811735f, 0.06821711f, 0.08871844f, 
    0.12683000f, -0.28512982f, 0.03044415f, 0.05470010f, -0.07310412f, -0.01853680f, 0.04784215f, -0.10791370f, 
    -0.00346191f, -0.11151893f, -0.01882572f, -0.05532965f, -0.07885617f, -0.01764696f, -0.00469895f, 0.01377031f, 
    0.15649419f, 0.02172655f, 0.03807405f, 0.03126791f, -0.06401292f, -0.03679321f, -0.06536622f, -0.05093750f, 
    0.09200923f, -0.11087035f, 0.08129598f, -0.08429506f, -0.07373393f, -0.04281297f, 0.00869519f, 0.02243021f, 
    -0.08516917f, -0.04744772f, 0.01704792f, 0.01109098f, 0.04625016f, -0.06604895f, -0.03845002f, -0.05606346f, 
    0.03852276f, 0.07851508f, 0.03420402f, -0.06044954f, -0.06075091f, -0.05798960f, 0.01077926f, -0.04296179f, 
    -0.57550192f, -0.06839247f, -0.21712440f, 0.15332675f, -0.05974320f, -0.00102643f, 0.09610822f, -0.04792267f, 
    0.02207829f, 0.06496453f, -0.09413477f, 0.16003719f, -0.10858850f, 0.13700379f, -0.28500068f, 0.14196834f, 
    0.17359738f, -0.15705852f, -0.05096009f, -0.04819262f, 0.00366768f, 0.03439182f, -0.01992409f, 0.00009425f, 
    0.12814131f, 0.12661633f, -0.12236923f, -0.08320206f, 0.07895252f, -0.04026061f, 0.01712633f, -0.06198236f, 
    -0.06679565f, 0.01877814f, 0.07171378f, -0.07001951f, 0.19877490f, 0.11824127f, 0.18470258f, -0.00010386f, 
    -0.09328327f, -0.06136427f, -0.07474287f, 0.02497922f, -0.01783797f, 0.06649910f, -0.05175887f, 0.08005461f, 
    0.05661514f, -0.02802216f, 0.02167205f, -0.03603365f, -0.01714393f, 0.03898159f, -0.01675656f, -0.05573437f, 
    0.02089682f, -0.12618180f, 0.10896947f, -0.05725909f, 0.18086030f, 0.19341981f, 0.03394839f, 0.09109277f, 
    -0.01937564f, -0.08526336f, 0.04512065f, -0.21926101f, -0.07951123f, 0.00066268f, 0.00542297f, 0.04721228f, 
    0.03661886f, 0.19647233f, -0.00876228f, 0.05221055f, 0.02084258f, 0.07389376f, 0.00508134f, 0.06778611f, 
    -0.02759967f, -0.00391248f, 0.07988589f, 0.02232159f, -0.12714550f, -0.06526534f, 0.22473249f, -0.19819169f, 
    -0.09851990f, -0.06604153f, 0.05987091f, 0.13850002f, 0.15728126f, 0.00097680f, 0.12834440f, -0.01279933f, 
    0.15714228f, 0.12801543f, -0.10698538f, -0.07141302f, 0.04346105f, -0.04862053f, 0.17161016f, 0.10318415f, 
    -0.06542228f, -0.03401460f, -0.09120906f, 0.01687257f, 0.09105461f, 0.10559090f, 0.05713277f, 0.06601568f, 
    0.02578644f, -0.06975616f, -0.09118554f, -0.02349690f, 0.00127244f, -0.01880734f, -0.03489897f, 0.02890622f, 
    0.17753129f, 0.16735780f, 0.02938297f, 0.05421063f, -0.01705346f, -0.01292025f, -0.08482917f, -0.11906177f, 
    0.04386795f, -0.08748031f, -0.01784264f, 0.15080576f, -0.05697470f, -0.07215436f, -0.05723771f, 0.13763088f, 
    -0.05219571f, 0.12095391f, 0.06703582f, -0.01808881f, -0.01261974f, 0.03218271f, -0.01308570f, 0.01712867f, 
    0.02317248f, 0.01393404f, -0.04613690f, -0.13646695f, 0.06524575f, 0.22423694f, -0.06068089f, -0.04818546f, 
    0.02802520f, -0.09120315f, -0.04967400f, -0.06136580f, 0.15169574f, 0.01681916f, 0.07513400f, -0.14480335f, 
    0.06435100f, -0.07728368f, -0.01994578f, 0.07917725f, 0.00945965f, 0.01636002f, 0.02276869f, 0.05952794f, 
    -0.05891887f, 0.03703932f, 0.19630393f, -0.06116696f, -0.02064708f, -0.05490571f, -0.03105503f, 0.05637696f, 
    0.13645387f, -0.01090088f, -0.00459489f, 0.05868168f, -0.04836002f, -0.05381365f, 0.12145246f, -0.07787553f, 
    0.09339026f, -0.04091221f, 0.05513231f, -0.05882847f, -0.02536482f, 0.03745217f, 0.02766989f, -0.02028123f, 
    0.68241340f, -0.17714560f, -0.07769796f, 0.00355500f, 0.02741833f, -0.06341759f, 0.10448049f, 0.02665856f, 
    0.05794979f, 0.07997213f, 0.11244129f, 0.03047495f, -0.01123512f, 0.00703067f, 0.21990401f, 0.15632986f, 
    0.04155489f, 0.04249347f, -0.03181404f, 0.03052517f, 0.29877692f, 0.06520146f, 0.05113988f, 0.08010312f, 
    0.40150473f, 0.08218128f, 0.02811919f, 0.11995765f, 0.06274836f, 0.04185149f, 0.00092545f, 0.07235269f, 
    0.12169711f, 0.09984831f, -0.09162897f, 0.08264782f, -0.13598488f, -0.06214369f, -0.03700279f, -0.12445380f, 
    0.02990500f, 0.06010145f, 0.12412483f, -0.02704423f, -0.10580295f, -0.14127472f, 0.05974230f, 0.04772731f, 
    -0.13543193f, -0.05394274f, -0.07419775f, 0.18245520f, -0.03557756f, 0.14410117f, 0.15014495f, 0.07446754f, 
    -0.04840792f, 0.01875439f, -0.08842814f, -0.04121599f, -0.01997495f, 0.05626993f, 0.08479560f, 0.21140768f, 
    -0.00669748f, -0.02461782f, -0.00425922f, -0.00381423f, 0.17976390f, 0.02449729f, -0.05369727f, 0.25007737f, 
    -0.17452829f, -0.05079778f, 0.02434137f, -0.09472255f, 0.07316911f, -0.03540812f, -0.00601815f, 0.04211644f, 
    0.15016653f, -0.08958592f, -0.01822902f, 0.14295118f, 0.10016590f, -0.03136016f, -0.03118885f, 0.11004022f, 
    0.01110105f, 0.04308235f, 0.01186077f, 0.08279645f, 0.14201796f, -0.00968093f, -0.01026232f, 0.05136004f, 
    -0.20930962f, 0.09029852f, -0.02422057f, -0.07279309f, -0.02962506f, 0.06789044f, -0.03504997f, 0.04549363f, 
    0.04497843f, -0.00598414f, 0.07149647f, -0.05360873f, 0.17872103f, 0.12077428f, -0.04515610f, -0.09464750f, 
    0.02144275f, -0.01500025f, -0.07583252f, -0.02689601f, -0.17027573f, -0.17363487f, -0.16250025f, -0.28738588f, 
    -0.12252251f, 0.31435147f, -0.29330942f, -0.16594435f, 0.17208184f, -0.01558546f, 0.11404923f, 0.09042141f, 
    0.03304179f, 0.00214500f, 0.01863123f, 0.07305006f, 0.08002277f, 0.14710884f, -0.09747042f, 0.05183251f, 
    0.05041556f, 0.12183668f, 0.10870078f, -0.07090156f, 0.11753507f, 0.01147091f, 0.01719536f, -0.02723510f, 
    0.19376792f, -0.08913274f, 0.09069182f, 0.05103516f, -0.05353931f, -0.01756359f, -0.17456043f, -0.13946512f, 
    -0.05405167f, -0.28077129f, -0.00490545f, -0.10933370f, -0.09753412f, 0.05668670f, 0.02281532f, 0.05079256f, 
    0.06428023f, 0.02458089f, -0.05523299f, 0.06673379f, -0.03803167f, -0.05695577f, 0.08941643f, 0.08808699f, 
    0.01157767f, 0.14189202f, -0.10716886f, 0.09546617f, -0.05329219f, -0.01782875f, -0.01822257f, 0.00381783f, 
    -0.05090772f, 0.04292313f, 0.04452437f, 0.00468821f, 0.08925700f, 0.17461471f, -0.06797986f, 0.09288731f, 
    0.04756592f, -0.04012680f, -0.00714196f, -0.10821417f, 0.00871083f, -0.08610525f, -0.01189106f, -0.12969196f, 
    -0.19650964f, -0.03403363f, 0.09826905f, -0.09209695f, -0.12117086f, 0.02837321f, 0.04567596f, -0.04333718f, 
    0.07619559f, -0.01015850f, 0.00087353f, -0.05118119f, 0.30488759f, 0.03549300f, 0.06361582f, 0.00233267f, 
    0.00790323f, -0.07214472f, 0.00321845f, 0.00047707f, -0.05594622f, -0.07493473f, 0.00271152f, -0.00374373f, 
    0.06381827f, -0.05081407f, 0.15600988f, -0.08535459f, 0.00306959f, -0.04305175f, 0.05212816f, -0.11279893f, 
    -0.11096133f, -0.11571661f, -0.01296292f, -0.10514700f, 0.00828499f, 0.17720665f, 0.05574207f, -0.01199496f, 
    -0.02680761f, -0.11589516f, -0.10291050f, -0.04943788f, -0.07210004f, 0.11205494f, -0.08801968f, 0.03057245f, 
    -0.06617271f, 0.10581063f, 0.06621201f, 0.01925723f, 0.07935136f, 0.02882500f, 0.01514510f, 0.03146150f, 
    0.07161676f, -0.07641263f, 0.24501726f, 0.03669456f, 0.09400167f, -0.19928004f, -0.33615416f, 0.21735191f, 
    -0.07417752f, -0.13403919f, 0.03234176f, -0.24472398f, 0.00486994f, 0.00380948f, -0.02797683f, 0.04003105f, 
    0.05715522f, 0.02204576f, -0.09985619f, -0.01585803f, 0.01259579f, -0.05562921f, -0.03702259f, 0.04894635f, 
    -0.07550222f, -0.03483460f, 0.07669694f, 0.03450942f, -0.04003760f, 0.24790360f, -0.12252194f, 0.03505623f, 
    0.07298319f, -0.04940444f, 0.17099014f, -0.03547439f, 0.09738450f, 0.03355513f, 0.12976328f, 0.07243585f, 
    0.10847407f, -0.09342569f, 0.03908362f, 0.04703409f, 0.02866389f, -0.06688211f, 0.01177698f, 0.04186872f, 
    -0.05159374f, 0.00174521f, -0.05682285f, 0.11360520f, 0.04189043f, 0.17272283f, 0.18447492f, 0.06879681f, 
    -0.12424432f, -0.06909069f, 0.01420902f, -0.16029349f, -0.02362159f, -0.01866313f, -0.08655638f, 0.00224457f, 
    -0.09588207f, 0.07816561f, -0.01210365f, -0.04545773f, -0.07699338f, -0.02246428f, -0.15499654f, -0.14475346f, 
    0.01867268f, -0.15042689f, -0.08999179f, 0.05956357f, -0.09094704f, -0.08031641f, 0.03655693f, 0.00116724f, 
    -0.06887722f, 0.07199314f, -0.05070386f, -0.00394383f, 0.04506972f, 0.10013954f, 0.01890076f, 0.16097334f, 
    -0.01061699f, -0.00985799f, 0.00332866f, -0.01510819f, 0.13138272f, 0.04811636f, 0.01882938f, 0.03403575f, 
    0.09278030f, -0.08311329f, -0.07142401f, -0.14614950f, -0.05054198f, 0.08626264f, 0.01141592f, 0.04197419f, 
    -0.02368299f, 0.03244536f, 0.17400414f, -0.05001754f, 0.06742125f, 0.14296111f, -0.03568216f, 0.09827033f, 
    -0.23877960f, 0.13714465f, 0.08280241f, -0.03306282f, -0.09829760f, -0.09398108f, -0.10314892f, -0.09304146f, 
    0.08570515f, -0.05712724f, -0.01556360f, -0.05506509f, -0.22762369f, -0.04577265f, 0.02051269f, -0.13882069f, 
    0.15315913f, 0.06307807f, 0.09665258f, 0.10629844f, 0.06254848f, 0.12731566f, 0.04781380f, 0.07329702f, 
    0.37699679f, -0.28301230f, 0.27666122f, -0.03878438f, -0.10291546f, 0.10258397f, -0.03793368f, 0.04327878f, 
    0.05770995f, 0.01148830f, 0.22202928f, 0.00781931f, -0.06003715f, -0.09026328f, 0.20091000f, -0.03742714f, 
    0.06885994f, 0.00033611f, -0.00616388f, 0.00104598f, -0.00425436f, 0.11196809f, 0.05768111f, 0.01837783f, 
    -0.09086779f, 0.08482037f, -0.06077449f, 0.30001029f, 0.06936534f, -0.06441052f, -0.18954404f, -0.12552400f, 
    -0.06226301f, 0.03766863f, 0.01587026f, 0.04474066f, 0.04814617f, -0.00985523f, -0.07496816f, 0.01544888f, 
    0.05413113f, 0.22866753f, 0.10338088f, 0.07103675f, 0.14367251f, 0.05796653f, -0.00649724f, -0.09349543f, 
    0.05525149f, 0.13774750f, -0.14738294f, 0.11964236f, 0.02681894f, -0.14274037f, -0.08973835f, 0.02694706f, 
    -0.14246781f, 0.02190216f, 0.07527243f, -0.01036293f, -0.03080259f, -0.14447910f, 0.06139852f, 0.19741066f, 
    0.05800354f, 0.03874668f, 0.04507931f, -0.02006183f, -0.03149785f, 0.02623285f, 0.10690527f, -0.07884151f, 
    0.17955859f, 0.03326398f, 0.14021337f, 0.06766330f, -0.06714262f, 0.01241906f, 0.11867326f, -0.10370626f, 
    -0.03379595f, 0.06385733f, -0.00812699f, 0.00900989f, -0.21789631f, 0.21216547f, -0.03831476f, 0.24658884f, 
    0.02532308f, 0.13570152f, -0.06585687f, -0.09386206f, 0.09127470f, 0.05848674f, -0.20031175f, 0.05592738f, 
    -0.17966619f, 0.46148604f, 0.16794898f, 0.16052157f, 0.07447990f, 0.04182940f, 0.03143509f, -0.00390892f, 
    0.06355226f, 0.09475553f, 0.01861735f, 0.14906786f, 0.00315852f, 0.02682529f, -0.07233740f, 0.13604736f, 
    0.04318598f, 0.06315823f, 0.07453633f, 0.08496473f, -0.04748251f, 0.04129626f, -0.13775441f, 0.02561839f, 
    -0.41108769f, 0.37454528f, -0.09168053f, -0.13665885f, -0.22790216f, -0.03245033f, 0.13637847f, 0.02177174f, 
    0.05250170f, -0.18894471f, -0.22862260f, 0.12828054f, -0.01394948f, -0.02437506f, -0.19810894f, -0.06616502f, 
    0.05469609f, 0.13403501f, 0.09860668f, -0.06893684f, -0.07881405f, 0.01281484f, 0.08272932f, 0.02703233f, 
    -0.11734207f, 0.07958423f, -0.00603408f, -0.06086546f, -0.01743640f, 0.04132360f, 0.00972585f, 0.13650531f, 
    0.17122549f, 0.13401704f, 0.09062432f, 0.30952907f, 0.13604265f, 0.11325034f, 0.09440698f, -0.05783013f, 
    -0.04592826f, -0.02086072f, 0.02397026f, 0.11425134f, 0.01561075f, -0.00000783f, 0.02072452f, 0.03392872f, 
    -0.01661374f, 0.07528672f, -0.18082424f, 0.19428033f, -0.01641914f, 0.00054097f, -0.01757379f, 0.01340603f, 
    -0.01797372f, 0.03274113f, -0.16527644f, 0.13684890f, 0.07982635f, 0.12145522f, 0.12046019f, 0.17381376f, 
    0.12264128f, 0.06726123f, 0.05611299f, 0.03124446f, 0.03539444f, 0.08587823f, -0.01808065f, -0.05671182f, 
    -0.18188733f, -0.19456856f, 0.25365183f, -0.19942078f, -0.04946218f, -0.16342963f, -0.05995971f, 0.17430618f, 
    0.07849804f, 0.01478389f, -0.09848434f, -0.09323268f, -0.05341440f, -0.07626446f, 0.25166222f, 0.00662056f, 
    -0.01149530f, 0.04878234f, 0.07281776f, 0.04191343f, 0.08424258f, 0.02770660f, -0.05934208f, 0.02267920f, 
    -0.17762756f, -0.02448606f, 0.26124418f, -0.06091713f, 0.01855334f, 0.08018778f, 0.14259082f, -0.08352390f, 
    0.03117909f, 0.04186770f, 0.02813157f, 0.02452807f, -0.19225818f, 0.01127498f, 0.02311699f, -0.04074497f, 
    -0.04081293f, -0.01518879f, 0.10697716f, -0.03147558f, 0.03417620f, -0.01704581f, 0.01426015f, 0.07885803f, 
    -0.01200154f, 0.05254382f, -0.04276196f, 0.01537028f, -0.02120909f, 0.04399716f, 0.04645694f, 0.00124773f, 
    0.02506919f, 0.03410792f, -0.05809204f, 0.03300994f, 0.11281498f, -0.19438092f, -0.05955609f, 0.17732957f, 
    0.14273292f, -0.01960657f, 0.03378143f, -0.03557782f, 0.00963001f, -0.00923789f, 0.04401006f, -0.12315337f, 
    0.05619160f, 0.05146912f, -0.03860760f, -0.05607750f, 0.00531532f, 0.17068017f, 0.16908255f, 0.07059941f, 
    0.06287089f, 0.01435455f, -0.04355895f, -0.00914645f, -0.10926684f, 0.31252792f, -0.49938530f, 0.42254084f, 
    0.10344064f, 0.00487442f, 0.09619808f, -0.00237991f, -0.03916917f, -0.09805340f, 0.11452121f, 0.12897612f, 
    0.06776396f, -0.15251514f, -0.03301159f, 0.17975368f, 0.16313782f, 0.02311964f, -0.02656191f, -0.24664654f, 
    -0.02164663f, 0.10758778f, -0.04070577f, 0.03538667f, -0.06000883f, -0.01933935f, -0.01410803f, -0.00090732f, 
    -0.00793110f, 0.08973455f, 0.02682946f, 0.00675387f, 0.03290852f, 0.03213888f, 0.03240414f, -0.01007410f, 
    0.05002924f, -0.02410288f, 0.09786924f, -0.06496485f, 0.02404532f, 0.14314738f, 0.10480964f, 0.10806549f, 
    0.12340085f, 0.09948506f, -0.00185158f, 0.00443382f, -0.07893892f, -0.07239369f, 0.10550752f, -0.12537016f, 
    0.02275191f, 0.04925079f, -0.11167436f, 0.02781421f, 0.02911234f, -0.05683768f, -0.04916361f, -0.00251305f, 
    0.20017573f, 0.09997263f, 0.15352637f, 0.08735242f, -0.05045971f, -0.26410395f, 0.10841604f, 0.10035755f, 
    -0.04897338f, -0.02060968f, -0.02774576f, 0.21866037f, 0.13469103f, -0.04557780f, -0.14332762f, 0.06738138f, 
    -0.05670052f, 0.00953879f, 0.09682452f, 0.06732221f, -0.01857090f, 0.04102280f, -0.01934977f, -0.00030234f, 
    -0.22294137f, 0.00290918f, 0.07903279f, -0.07458425f, 0.01442274f, 0.02922780f, -0.05093396f, 0.10930815f, 
    0.04981523f, 0.03987336f, 0.00097157f, 0.23136719f, 0.21032630f, 0.11368362f, -0.05218811f, -0.13575779f, 
    -0.00446829f, 0.07195257f, 0.04640448f, 0.06379166f, -0.02673597f, -0.00466791f, 0.03264217f, 0.00133590f, 
    -0.04270159f, 0.20162351f, 0.14564437f, 0.18043770f, -0.12017572f, 0.14978965f, 0.13461308f, -0.19856410f, 
    -0.18452272f, 0.02753861f, -0.05501513f, 0.11036813f, -0.20427614f, -0.03071707f, -0.07352012f, -0.02881420f, 
    -0.06552446f, 0.00410329f, 0.05890614f, 0.02927342f, -0.20233376f, -0.13935265f, 0.03123755f, 0.12969437f, 
    -0.25783578f, 0.17384225f, 0.13465890f, 0.25400797f, -0.03386470f, 0.08322538f, 0.09223136f, 0.04453591f, 
    -0.00420657f, 0.02519264f, 0.29936311f, 0.10269275f, -0.08547112f, -0.33947039f, -0.14696445f, -0.03754905f, 
    0.04320408f, -0.00441458f, 0.03155131f, 0.10101288f, 0.03089933f, 0.20000975f, -0.08560407f, -0.05399448f, 
    -0.23636499f, -0.05420339f, -0.13075671f, 0.01957433f, 0.06300308f, 0.06496487f, 0.04462914f, -0.03392730f, 
    -0.00035670f, -0.05776548f, -0.07661716f, 0.03668807f, 0.00510576f, 0.15864681f, 0.02730847f, -0.01879449f, 
    -0.11245895f, -0.06866333f, -0.00559909f, -0.00844480f, -0.13855734f, 0.02651468f, 0.04235106f, 0.18996410f, 
    0.28421098f, 0.17189284f, -0.19963448f, 0.27406973f, -0.07828962f, 0.09123740f, 0.06654019f, -0.00228637f, 
    0.00237247f, 0.12255932f, -0.06889527f, 0.01879666f, -0.20968896f, 0.23913836f, 0.03430049f, -0.06304652f, 
    -0.00038541f, 0.05475695f, 0.10125716f, 0.03865806f, 0.05917615f, -0.00045021f, 0.26713848f, -0.09966303f, 
    -0.15436867f, -0.18924002f, 0.12569511f, 0.08075823f, 0.05600814f, 0.07762361f, 0.18863896f, 0.06050155f, 
    0.01429202f, 0.07676722f, 0.05774276f, 0.00965712f, -0.19268726f, 0.09493282f, 0.10907609f, 0.05592487f, 
    -0.01505557f, 0.05446361f, 0.01604985f, -0.16295040f, 0.16848600f, 0.00926781f, 0.17650306f, 0.09887867f, 
    0.46789393f, 0.05520652f, -0.04271556f, -0.11772601f, -0.09386573f, 0.03309963f, 0.04231690f, 0.09968116f, 
    0.04461689f, 0.01171311f, 0.15873732f, 0.00525786f, -0.06516963f, -0.06193195f, -0.04814911f, 0.05731200f, 
    0.02501292f, -0.11324885f, 0.05612022f, 0.04795089f, -0.06962305f, 0.01205602f, -0.00653826f, -0.05480360f, 
    -0.12702490f, 0.36467952f, -0.21646813f, 0.11461282f, 0.00695393f, 0.04904612f, 0.14835349f, 0.07716973f, 
    0.00346078f, 0.18580036f, 0.06257760f, -0.14145695f, -0.07556622f, -0.18710528f, -0.12552318f, 0.09877245f, 
    -0.05705247f, 0.12286922f, -0.09458179f, -0.10460520f, -0.07174782f, -0.01196977f, -0.10155641f, -0.04588610f, 
    -0.09885930f, -0.03996243f, -0.12261795f, -0.07887711f, -0.11717000f, 0.10744070f, -0.14731337f, -0.08079789f, 
    0.01392086f, 0.04588352f, -0.04435031f, 0.09304926f, -0.09450692f, -0.05115158f, 0.03174736f, 0.05990683f, 
    0.02488708f, 0.03922845f, 0.09990514f, -0.00192135f, -0.07243074f, -0.01010357f, 0.04799157f, 0.03726063f, 
    0.60900724f, 0.06126131f, -0.00347612f, 0.16096315f, 0.13484018f, 0.06555869f, 0.03758826f, -0.06434453f, 
    -0.01220768f, 0.06643829f, 0.20016946f, 0.01126033f, 0.07100119f, 0.06158485f, 0.17510639f, -0.12856646f, 
    -0.10087413f, -0.03748900f, -0.09252767f, -0.06798586f, -0.10661295f, -0.00885736f, 0.01425732f, 0.05716740f, 
    0.04300435f, 0.02616814f, 0.17916018f, 0.03245191f, 0.13626310f, -0.12345275f, 0.01852344f, 0.03377546f, 
    -0.01416065f, 0.05501515f, 0.05981651f, 0.12172444f, -0.07504638f, 0.09132981f, -0.01443918f, -0.31732973f, 
    0.01023040f, 0.01203290f, -0.01285274f, 0.05805241f, -0.00776861f, -0.04541532f, 0.14204702f, -0.05643872f, 
    -0.08754180f, -0.08099593f, -0.01453575f, -0.08168358f, -0.11472122f, -0.11592200f, -0.04879777f, 0.05229610f, 
    0.06389018f, -0.00422313f, 0.11061305f, 0.13128296f, -0.16758086f, 0.01657960f, 0.02489278f, 0.09655129f, 
    0.03055581f, 0.12355690f, -0.02750312f, 0.03762303f, -0.04555848f, -0.06204486f, 0.06408943f, 0.00788970f, 
    -0.13177283f, -0.34176192f, 0.28522763f, -0.10722383f, 0.05173594f, 0.05574957f, 0.05740136f, 0.00537012f, 
    0.03191418f, -0.04307037f, -0.02716230f, 0.03874052f, 0.02808427f, -0.16093929f, 0.24126042f, 0.01257631f, 
    0.15866379f, -0.02811047f, 0.00976046f, 0.11596275f, 0.03649424f, 0.12296233f, -0.04884199f, 0.11449755f, 
    -0.22411330f, -0.17929736f, 0.28019878f, -0.15738168f, 0.05831771f, -0.02980457f, -0.07803538f, -0.11536516f, 
    0.02957860f, -0.11069696f, -0.03800293f, 0.02772142f, -0.17921752f, -0.01957402f, -0.01255091f, -0.18217206f, 
    -0.06494674f, -0.16983469f, -0.22193503f, -0.07542445f, -0.14551809f, -0.04501638f, -0.10508554f, -0.01893163f, 
    -0.24968684f, -0.27416283f, -0.19041082f, 0.05588454f, 0.03168408f, 0.15296313f, 0.02495211f, -0.13564588f, 
    0.00770520f, -0.09849937f, 0.03343890f, 0.04176686f, 0.10826050f, 0.11409651f, -0.25287473f, -0.00339385f, 
    0.02869179f, 0.03005595f, 0.02247654f, -0.00153044f, 0.02591064f, 0.13517801f, -0.07793823f, -0.07372350f, 
    -0.13005149f, -0.13999850f, -0.14957967f, -0.01396462f, -0.03908614f, 0.09775785f, 0.06382362f, 0.00123071f, 
    0.08441114f, 0.01440563f, 0.02838625f, 0.04237711f, 0.15210673f, 0.08950520f, 0.25349364f, -0.07955024f, 
    -0.05891997f, -0.04519906f, -0.11173095f, -0.01178059f, -0.10161670f, -0.08914573f, 0.07441811f, -0.00000362f, 
    0.38194996f, -0.00573974f, -0.24633056f, -0.16871482f, -0.04566581f, -0.03110706f, 0.04404806f, 0.09466104f, 
    -0.01090169f, 0.01905600f, 0.10450801f, -0.03051232f, -0.11918434f, -0.20113951f, -0.08696735f, -0.01807461f, 
    0.03514289f, 0.06069408f, -0.02059279f, -0.05295778f, 0.01396563f, 0.09119012f, -0.02136241f, -0.05125887f, 
    -0.24675955f, 0.29718223f, -0.10168365f, 0.16806798f, 0.05314085f, -0.09024499f, 0.06615957f, 0.00383600f, 
    0.00952018f, -0.06409375f, 0.08711857f, 0.02951821f, 0.05664279f, 0.24794731f, -0.10666541f, -0.09979560f, 
    0.10718338f, -0.04918074f, 0.05312712f, 0.09180190f, 0.04171279f, -0.04788166f, 0.01770579f, 0.07548234f, 
    0.04171206f, 0.00538771f, -0.04350634f, -0.03003433f, 0.02766176f, -0.01184391f, -0.02203448f, -0.01942779f, 
    -0.00871390f, 0.00508123f, -0.03876402f, 0.01672903f, 0.00807528f, 0.02305435f, 0.01312872f, -0.02156472f, 
    -0.04249199f, -0.01374398f, -0.02904685f, -0.05171365f, -0.02236295f, 0.02275923f, -0.05065556f, -0.02930176f, 
    -0.04478875f, 0.03273847f, 0.02902453f, 0.03612489f, 0.03381731f, 0.01576236f, -0.00382644f, -0.02440106f, 
    -0.01466578f, -0.04215110f, 0.03875646f, -0.05451588f, 0.02527837f, -0.02144483f, 0.02138731f, -0.03612743f, 
    0.03038082f, -0.05063855f, -0.02968484f, -0.05292881f, -0.04406703f, 0.02243908f, -0.05153896f, -0.04762208f, 
    -0.00909000f, 0.02421497f, 0.00959753f, -0.00134115f, -0.05982140f, 0.01996999f, -0.00927034f, -0.02323237f, 
    -0.01413958f, -0.05180468f, 0.01069425f, -0.02074622f, -0.00565366f, -0.04040935f, 0.00997716f, 0.00353793f, 
    -0.01351331f, 0.02731829f, 0.03332771f, -0.04130967f, 0.03109728f, -0.02944745f, -0.01584438f, 0.03669542f, 
    0.02714688f, -0.00103614f, -0.02658971f, 0.03545789f, -0.05594012f, -0.02748404f, -0.05106546f, 0.01595201f, 
    0.02842470f, 0.02392034f, 0.03857822f, -0.01956275f, -0.00788529f, -0.01205470f, -0.02227767f, -0.00184807f, 
    0.02789978f, -0.04448921f, -0.04075199f, -0.05457747f, -0.02073244f, -0.02604614f, 0.00522748f, -0.01860034f, 
    -0.00815868f, 0.02705103f, 0.04954531f, 0.03665843f, -0.05599511f, -0.00648862f, 0.03492089f, 0.02176513f, 
    0.01293853f, 0.01847231f, -0.01609044f, -0.02945621f, 0.01757815f, 0.04455652f, -0.00766224f, -0.03684956f, 
    -0.00142695f, -0.05562542f, 0.04269070f, -0.00224326f, -0.00806037f, -0.05103747f, 0.00988080f, -0.04089396f, 
    -0.02771958f, -0.03630184f, -0.03210708f, 0.02478825f, -0.00958296f, -0.03122590f, 0.03634085f, 0.03049634f, 
    0.03098325f, -0.01496510f, 0.03288142f, -0.00281701f, 0.00928286f, 0.02208622f, -0.02791472f, -0.01550819f, 
    -0.03321972f, -0.02183064f, -0.01186768f, 0.03855438f, -0.01893985f, 0.03556988f, 0.03254958f, -0.00068311f, 
    -0.03299049f, 0.03468394f, 0.00872271f, -0.01383133f, -0.03486636f, -0.01477999f, 0.03794217f, -0.05433759f, 
    0.03226620f, -0.00606357f, 0.02877089f, 0.02135084f, -0.01613853f, -0.03032907f, -0.03752512f, -0.05652931f, 
    -0.00140652f, -0.00229633f, -0.02210804f, -0.03178924f, -0.02823847f, 0.01809303f, -0.04222497f, 0.02158384f, 
    0.01150222f, -0.03802493f, -0.00058494f, -0.03483377f, -0.05499740f, -0.03918675f, -0.04111644f, -0.03448085f, 
    -0.03269377f, -0.06068800f, -0.01475224f, 0.00132411f, 0.00966786f, -0.01778545f, -0.03183621f, 0.03148488f, 
    -0.05071773f, -0.02571449f, 0.00201907f, 0.01927448f, -0.05363576f, 0.03441318f, 0.01561304f, -0.05059118f, 
    -0.05153403f, -0.05123900f, 0.01974904f, 0.00025835f, -0.02693368f, -0.03941363f, 0.01115290f, 0.01814641f, 
    0.02931168f, -0.05072278f, 0.03523151f, -0.05374722f, -0.01735214f, 0.04010091f, -0.03894411f, 0.05098953f, 
    0.03301324f, -0.03515349f, -0.00543250f, -0.02933615f, -0.06057003f, -0.03459907f, -0.03573767f, 0.03474642f, 
    -0.03135338f, 0.03069966f, 0.02892047f, 0.01731247f, 0.02544712f, 0.02220182f, -0.03712256f, -0.05581843f, 
    -0.00318778f, -0.03838947f, -0.05458453f, 0.03321103f, 0.03171671f, -0.05138554f, -0.04074052f, -0.03033944f, 
    0.04077950f, -0.05307375f, -0.05084792f, -0.01355006f, -0.01716244f, -0.03618027f, 0.03569920f, 0.02234478f, 
    0.02459692f, 0.00546778f, 0.02041082f, 0.02586040f, -0.04652955f, 0.04257623f, -0.04331532f, 0.03440076f, 
    -0.05148115f, -0.00759072f, -0.03192216f, 0.02887610f, 0.03652406f, 0.03471648f, -0.02708712f, 0.02895822f, 
    0.01970473f, -0.01681128f, 0.00554663f, 0.02323924f, -0.04873971f, -0.02804940f, 0.01446694f, -0.00821027f, 
    0.03990442f, -0.05695959f, 0.02748943f, -0.02046160f, -0.00614430f, -0.01952598f, -0.03061390f, 0.01285367f, 
    0.01248842f, -0.00448114f, 0.01100483f, -0.03924163f, -0.03718802f, -0.02655677f, -0.00519409f, -0.00112845f, 
    0.01871131f, -0.01459820f, -0.02104564f, -0.03689617f, 0.01904581f, 0.02648076f, -0.01632712f, 0.03035836f, 
    -0.03387594f, 0.02942970f, -0.00530646f, -0.01484330f, -0.05345065f, 0.00912656f, -0.02487297f, -0.04430415f, 
    -0.05009169f, -0.02964657f, 0.00985726f, 0.01440249f, -0.03914202f, -0.03379795f, 0.03121027f, -0.01809929f, 
    -0.03021134f, 0.00850744f, 0.03619307f, 0.02112831f, -0.00916804f, 0.03763795f, -0.01032019f, -0.01925868f, 
    0.04738252f, -0.01717628f, -0.02813800f, 0.02971012f, -0.00139924f, -0.05249069f, -0.04272313f, 0.02139450f, 
    -0.00454902f, -0.01804294f, -0.03401481f, 0.03317012f, 0.00130241f, -0.01861290f, -0.00770158f, 0.02380497f, 
    -0.02417644f, -0.05654652f, 0.04136693f, -0.05779521f, -0.05699578f, -0.04231584f, -0.03937832f, -0.00361079f, 
    0.04499127f, 0.03625816f, -0.00182027f, 0.01081614f, 0.03225455f, -0.02180130f, 0.02636543f, -0.05111084f, 
    -0.05235660f, -0.05168984f, 0.04034203f, 0.02711283f, -0.05083764f, 0.00003903f, -0.02189253f, 0.03371247f, 
    0.02438408f, 0.03894855f, 0.03580194f, 0.01379409f, 0.03913520f, 0.03376687f, -0.05768218f, -0.05159550f, 
    -0.04544361f, 0.03979848f, 0.03152421f, 0.01585903f, -0.04374307f, 0.02442238f, 0.04132027f, 0.01724874f, 
    -0.04307260f, 0.01654102f, -0.02650806f, -0.03326836f, -0.01740713f, 0.02265169f, -0.01421796f, -0.02127718f, 
    0.01447703f, -0.04956289f, 0.02494657f, 0.00892496f, -0.02093709f, -0.03588680f, -0.04675779f, -0.05170174f, 
    0.13029040f, 0.06526837f, -0.06180987f, -0.07761261f, 0.04289757f, 0.09261890f, -0.06571390f, 0.05686412f, 
    0.14827557f, 0.03757385f, -0.12916423f, 0.01749507f, 0.10946240f, -0.11551713f, -0.09117139f, 0.00628378f, 
    0.15823965f, 0.27844539f, 0.09931590f, 0.14458354f, 0.04718300f, 0.06643663f, 0.09071147f, -0.00009496f, 
    0.17223929f, 0.14314346f, -0.20752122f, 0.02029871f, 0.12861025f, 0.14429887f, 0.02154910f, 0.02437318f, 
    -0.06167942f, -0.05556494f, -0.06730722f, 0.07753053f, -0.01897252f, 0.04407224f, -0.07734870f, 0.21286193f, 
    -0.06692245f, -0.09538719f, -0.02591581f, 0.03393933f, 0.03427828f, -0.00237543f, -0.01829496f, 0.15615533f, 
    -0.19639975f, -0.24242041f, -0.00235566f, -0.03458603f, 0.03597050f, 0.08417902f, -0.09256008f, -0.04240439f, 
    -0.01769773f, 0.01167261f, -0.06240097f, -0.00230446f, 0.08441423f, 0.16422650f, -0.19249448f, -0.04875331f, 
    0.01820927f, -0.02224678f, 0.06327295f, -0.03386369f, -0.00409616f, 0.06876049f, 0.09613709f, 0.04467272f, 
    -0.18192509f, -0.12123317f, -0.16563827f, -0.07225642f, 0.09002721f, 0.11889031f, 0.03343849f, -0.06096368f, 
    0.01028201f, 0.00546687f, -0.01509525f, -0.07148529f, 0.02417416f, 0.21729848f, -0.00675860f, 0.01958505f, 
    -0.11831459f, -0.00907312f, -0.09522283f, -0.11848960f, -0.12127106f, -0.19875975f, -0.01744013f, -0.04885871f, 
    -0.07013673f, 0.21859123f, 0.33879402f, -0.07337946f, 0.03502746f, -0.09115533f, -0.01419714f, 0.08179121f, 
    0.02967218f, -0.01558715f, 0.00404933f, 0.01482308f, 0.28702384f, 0.26306838f, 0.16823940f, -0.06103667f, 
    0.14165118f, 0.11362186f, 0.14868072f, 0.06719272f, 0.01837939f, -0.07664167f, -0.12219832f, 0.03140312f, 
    0.02479549f, 0.02608222f, -0.06648558f, -0.02202126f, -0.01256417f, 0.01962985f, -0.03097391f, -0.13688594f, 
    -0.09078610f, 0.00818678f, -0.10083034f, -0.22604221f, 0.12723120f, 0.07756161f, 0.11885442f, 0.14278026f, 
    0.05459516f, 0.26210231f, 0.05212645f, 0.03159069f, 0.00301826f, 0.05109145f, 0.06658981f, 0.04273453f, 
    -0.05309180f, 0.03274046f, -0.03329230f, 0.04877780f, -0.04969957f, -0.01036035f, -0.03118427f, -0.03442016f, 
    -0.01520633f, 0.04497296f, 0.09892420f, -0.02901385f, 0.21963628f, 0.12343100f, -0.06152507f, -0.04418098f, 
    0.09956667f, 0.07912808f, 0.00561201f, -0.04769410f, -0.01788598f, -0.02752002f, 0.09321817f, 0.03032421f, 
    0.06803871f, -0.09901222f, -0.00114081f, -0.08958207f, 0.10799090f, 0.12022535f, -0.03163977f, -0.02855290f, 
    0.00501820f, 0.13123733f, 0.07302094f, 0.02726133f, 0.22275279f, 0.06707895f, 0.26501647f, -0.01519646f, 
    -0.12737633f, -0.09516774f, -0.06426149f, 0.01275870f, 0.00882799f, -0.00652858f, -0.02188320f, 0.00534119f, 
    0.14436327f, 0.02702547f, 0.35941079f, 0.21371756f, 0.00436922f, -0.08774992f, -0.02873902f, -0.01460107f, 
    -0.08809811f, -0.07147788f, -0.05442438f, -0.01750208f, -0.07206692f, -0.01803406f, -0.05216716f, 0.11637414f, 
    -0.04410452f, 0.00313727f, -0.00481632f, -0.01377371f, -0.04373815f, -0.01406256f, 0.10874180f, 0.02194318f, 
    -0.08972127f, -0.06313209f, -0.02540174f, 0.04392076f, -0.03806271f, 0.00407663f, -0.04658532f, 0.00831439f, 
    0.05463929f, 0.16577581f, 0.01297889f, 0.15003395f, 0.25306645f, 0.38123843f, -0.19734347f, 0.02859079f, 
    -0.03693122f, -0.00939945f, 0.08250888f, 0.08459482f, 0.04098219f, 0.01061252f, -0.01216958f, 0.05495932f, 
    0.09555140f, -0.02728411f, 0.30160660f, -0.08874706f, 0.01764911f, 0.00171072f, -0.00249848f, 0.16580589f, 
    -0.10863119f, 0.05236007f, 0.05122430f, 0.07809716f, -0.17651342f, 0.02064769f, 0.10235028f, -0.08101329f, 
    0.08916152f, 0.05648180f, -0.03494109f, 0.04938266f, 0.03127199f, -0.04113597f, 0.17628606f, 0.13255608f, 
    -0.12092996f, -0.06247958f, -0.08928588f, -0.03926730f, -0.00440583f, 0.00708301f, -0.08782195f, 0.04487315f, 
    -0.09714124f, 0.11389021f, 0.07259499f, 0.00808678f, 0.09426119f, 0.06804934f, 0.11090098f, 0.15980098f, 
    -0.09146640f, -0.04816158f, -0.11805397f, -0.03306810f, 0.00641826f, -0.08989393f, 0.01800036f, -0.03332766f, 
    0.16648684f, 0.08763016f, -0.12146436f, -0.00340085f, 0.03916787f, -0.03283213f, 0.03488892f, -0.03697396f, 
    -0.11582270f, -0.05530722f, 0.03597081f, 0.06917846f, -0.01904050f, -0.03415313f, 0.00036361f, -0.02040198f, 
    0.12414021f, -0.01783196f, 0.04699904f, 0.00859042f, 0.03417069f, 0.04634994f, 0.04531773f, 0.04327403f, 
    0.11408107f, -0.05955648f, 0.07666228f, 0.07069457f, 0.03599406f, 0.03877925f, -0.02704284f, -0.00145141f, 
    -0.06107431f, -0.00196180f, -0.01245029f, -0.11585347f, -0.03462642f, 0.13631390f, 0.20040700f, 0.05029169f, 
    -0.01638690f, -0.01968858f, -0.04739641f, -0.05839093f, -0.00897419f, -0.02055268f, 0.04453794f, 0.13680583f, 
    0.05067912f, -0.09168058f, -0.01221824f, 0.00347737f, -0.03988992f, -0.00243562f, -0.01248740f, -0.00850605f, 
    0.04151008f, -0.10362183f, 0.07203159f, -0.11927877f, 0.19952287f, -0.03873409f, 0.19867897f, -0.01144581f, 
    0.17493962f, 0.12406510f, 0.11582479f, 0.12923017f, -0.10108179f, -0.01393123f, -0.07367609f, 0.02709641f, 
    0.27471888f, 0.53084064f, -0.06287241f, -0.04879880f, -0.09805605f, -0.02332138f, 0.11884749f, 0.07109758f, 
    0.09381565f, -0.00614349f, -0.02928602f, -0.03614311f, -0.03103113f, 0.07947879f, -0.03394498f, -0.09490560f, 
    -0.06613560f, -0.04441202f, 0.03019997f, 0.02293398f, 0.11289424f, 0.08678489f, -0.10013455f, 0.00857623f, 
    0.17769955f, -0.02654861f, -0.14425084f, -0.03841006f, 0.06059286f, 0.17553891f, 0.01249761f, 0.03265197f, 
    0.16187105f, 0.03993688f, -0.03167062f, 0.02053161f, -0.08034003f, -0.07254835f, -0.03927868f, 0.08417652f, 
    0.09033687f, 0.21217740f, 0.05681726f, 0.05226274f, -0.15411638f, 0.04396342f, 0.01917844f, 0.03977339f, 
    0.16979964f, 0.16739626f, -0.12253261f, -0.04404131f, 0.08818321f, 0.26459789f, 0.16923103f, 0.02564934f, 
    0.09887730f, -0.02311556f, -0.10963058f, 0.04583564f, 0.03399231f, 0.08210739f, -0.00253839f, 0.04612802f, 
    -0.07848950f, -0.06427876f, -0.03384564f, 0.04757420f, 0.05520226f, 0.04860762f, 0.00123218f, 0.18001050f, 
    -0.09460512f, -0.35101125f, -0.02909065f, 0.02233530f, 0.10312075f, 0.16085583f, -0.04701575f, 0.15813251f, 
    0.02826572f, -0.01680066f, -0.15823226f, -0.02682482f, 0.07371542f, 0.09838895f, -0.20318867f, -0.11565264f, 
    0.06441898f, 0.03444575f, 0.16886851f, 0.00576371f, -0.00473559f, -0.14898455f, 0.21271715f, -0.09163251f, 
    -0.12291644f, -0.32170111f, -0.34046900f, -0.16634177f, 0.02760047f, 0.11957827f, 0.12359443f, 0.14334789f, 
    -0.03398416f, 0.03883366f, -0.09431089f, -0.18778999f, 0.10694770f, 0.12734188f, -0.02646716f, -0.05009439f, 
    0.01599289f, 0.01639097f, -0.02749377f, 0.05480057f, -0.11218920f, -0.14225264f, -0.00081235f, -0.11419910f, 
    0.11632767f, 0.01414537f, 0.27723625f, -0.14168169f, 0.01683004f, -0.09541904f, -0.02212353f, 0.09835004f, 
    0.02258115f, 0.06226408f, -0.00596103f, -0.08267260f, 0.26049805f, 0.27909282f, 0.10198330f, -0.06769989f, 
    0.10302910f, -0.02775195f, 0.01191312f, 0.12312151f, 0.07406197f, 0.05213958f, -0.09221739f, 0.03324205f, 
    0.07567177f, -0.05891673f, -0.12750876f, 0.05383462f, 0.00599066f, 0.03382036f, 0.04534623f, -0.04765583f, 
    -0.08486569f, -0.09422347f, -0.10605147f, -0.23398729f, 0.09568757f, 0.13757749f, 0.09786232f, 0.29647943f, 
    0.10930188f, 0.22738096f, 0.00649330f, -0.10689490f, 0.01808022f, 0.03178138f, 0.01045377f, 0.06514303f, 
    -0.06842414f, 0.02707075f, 0.01309413f, -0.02245723f, -0.07925835f, 0.00870516f, -0.04018105f, -0.02076678f, 
    -0.08275942f, 0.03560598f, 0.03077621f, 0.07180309f, 0.16987866f, 0.02287599f, -0.13741098f, 0.01377482f, 
    0.00551691f, 0.02684326f, 0.05114083f, -0.03110680f, -0.13165435f, -0.05454955f, -0.00557567f, -0.09128744f, 
    0.08468961f, -0.01602570f, -0.01687356f, 0.03060259f, 0.02087539f, 0.10373615f, 0.05234744f, 0.03370059f, 
    -0.05836128f, 0.09780463f, -0.01063882f, -0.06125179f, 0.06708765f, 0.06004919f, 0.07222068f, 0.18296142f, 
    -0.03049865f, -0.16429482f, -0.17138799f, -0.07759290f, -0.00623135f, -0.03147063f, 0.04611036f, -0.03097131f, 
    -0.14665893f, 0.17225777f, 0.32517302f, 0.17681551f, 0.00147521f, -0.04126925f, -0.10961638f, -0.10092182f, 
    -0.06659889f, 0.01932949f, 0.00511463f, 0.03302220f, 0.02247728f, -0.03536201f, 0.00129711f, 0.01003001f, 
    -0.04475633f, -0.01833720f, -0.00291905f, 0.07790925f, -0.03096444f, 0.16184416f, 0.12425519f, 0.07136016f, 
    -0.08079762f, 0.02131143f, 0.04941504f, -0.05119901f, 0.00462178f, 0.00941015f, -0.00661404f, 0.02861295f, 
    0.03471792f, -0.01058246f, 0.14914931f, 0.10146915f, 0.29019672f, 0.30142698f, -0.20480874f, 0.06376696f, 
    -0.05785365f, -0.01395182f, 0.06693464f, 0.00305264f, 0.05580178f, 0.04512630f, -0.01209902f, 0.14237806f, 
    -0.03310592f, 0.05084013f, 0.24021436f, 0.07316528f, 0.00736947f, -0.01711177f, -0.07101188f, 0.13003431f, 
    -0.05178756f, 0.03201080f, 0.00027345f, 0.02296117f, -0.09893755f, -0.10125812f, 0.26480216f, -0.27881607f, 
    0.06724865f, 0.00582187f, -0.00291669f, 0.09678047f, 0.09258137f, -0.16266552f, 0.01631639f, 0.03369131f, 
    -0.06120769f, -0.03216992f, -0.04803332f, 0.00319985f, -0.01411300f, -0.02885211f, -0.10392097f, -0.00582570f, 
    -0.09441882f, -0.00676181f, 0.02374394f, 0.08843059f, 0.00846748f, 0.11534499f, 0.11467248f, 0.00865761f, 
    -0.09873162f, -0.10390604f, -0.10148037f, -0.05312036f, -0.00461206f, 0.03647830f, 0.03012590f, 0.03682650f, 
    0.21372962f, 0.16498572f, -0.10369697f, -0.01027611f, 0.09225411f, 0.02972077f, 0.03246496f, -0.05996100f, 
    0.06744981f, -0.11329995f, 0.00219701f, 0.13758954f, -0.05051163f, 0.03204366f, -0.00084635f, 0.05333914f, 
    0.09399719f, 0.01798864f, 0.06918945f, -0.02740056f, 0.02307325f, 0.11400965f, -0.04551201f, 0.13328542f, 
    -0.04079184f, -0.12334000f, -0.08580066f, 0.02599957f, 0.13136508f, 0.22139460f, -0.06076613f, -0.02108729f, 
    0.13293223f, -0.01725202f, -0.11303273f, -0.12203785f, -0.02908021f, 0.17658317f, 0.12592039f, 0.00309996f, 
    0.04698799f, -0.04273619f, -0.01993703f, -0.00373199f, 0.02723641f, 0.03597252f, 0.06996159f, 0.05217415f, 
    -0.03581542f, -0.06557641f, 0.02872414f, -0.07122403f, -0.03985593f, -0.01107137f, 0.05343505f, 0.02965841f, 
    0.03740774f, -0.10676906f, 0.05734512f, -0.11506500f, 0.08496209f, -0.11722126f, 0.11967351f, -0.00582465f, 
    0.06893415f, 0.10574151f, 0.04809988f, 0.09097487f, -0.02416113f, 0.07140198f, -0.04966293f, 0.02969308f, 
    0.55027288f, 0.33379012f, 0.01695216f, -0.16663928f, -0.01655363f, -0.06797485f, 0.04941077f, 0.06765455f, 
    0.10938060f, 0.05069018f, 0.08241908f, -0.02220260f, 0.17665011f, 0.09247423f, 0.04108423f, -0.05362841f, 
    -0.03154151f, -0.01380216f, -0.04085885f, 0.01614254f, 0.14924391f, 0.27450520f, -0.01814816f, -0.00806854f, 
    -0.01570355f, -0.20511776f, -0.08973412f, 0.48062345f, -0.03369413f, -0.02448390f, 0.18936090f, -0.01644467f, 
    0.06205249f, 0.10403439f, 0.15879191f, 0.08116483f, -0.02602778f, -0.13333957f, -0.06262336f, -0.08831853f, 
    0.07118346f, -0.03327538f, 0.12651607f, -0.07355858f, -0.03155474f, -0.05458905f, -0.01172848f, 0.02342942f, 
    -0.29132834f, -0.10029535f, 0.00241745f, 0.07420997f, -0.04863009f, 0.02124523f, -0.07477316f, -0.01929921f, 
    0.03986103f, -0.05044289f, 0.01054616f, -0.04062774f, 0.22153068f, 0.07186990f, 0.19390455f, -0.08696327f, 
    0.01623450f, 0.07758228f, 0.03328394f, -0.00991291f, -0.02760843f, 0.05051116f, 0.04473047f, -0.00641836f, 
    0.05116623f, -0.19299503f, -0.07506097f, 0.02980085f, 0.04631087f, 0.09842430f, 0.18861461f, 0.25734442f, 
    -0.06663632f, -0.03405798f, 0.06438192f, -0.14526783f, 0.10337874f, -0.13006413f, -0.33211729f, -0.14279795f, 
    -0.03564493f, -0.02521000f, 0.05780853f, 0.03501254f, 0.02352709f, -0.00978982f, -0.02327945f, 0.12497379f, 
    -0.06183334f, -0.33083361f, -0.45433536f, -0.26457885f, -0.06163961f, -0.05156454f, -0.03288140f, 0.15609001f, 
    0.17673525f, 0.07623262f, 0.03284667f, 0.04281369f, -0.12782148f, -0.14885794f, -0.00331110f, -0.01874734f, 
    -0.04526672f, -0.06733253f, 0.06624114f, 0.01985528f, 0.17924199f, 0.26730430f, 0.12164712f, 0.01786944f, 
    0.50106072f, 0.03504325f, 0.00516204f, -0.21151946f, 0.03056927f, -0.00955657f, -0.07624615f, -0.07176639f, 
    0.04624215f, -0.07420806f, -0.02905734f, 0.05646415f, -0.09337167f, -0.36590597f, -0.26303115f, -0.13248125f, 
    -0.03717307f, -0.17601040f, -0.11530548f, 0.06552123f, -0.08113863f, -0.03117260f, -0.10409103f, 0.02940658f, 
    -0.02308191f, 0.07570743f, -0.04719869f, 0.03358227f, -0.03670518f, 0.01217643f, -0.07330573f, -0.07418275f, 
    -0.07984480f, -0.04916594f, 0.13216379f, 0.20684566f, -0.12806271f, -0.38679558f, -0.28442997f, -0.17402947f, 
    0.03524110f, -0.15813720f, -0.20601837f, 0.07754883f, -0.04341295f, -0.07336818f, -0.00319671f, 0.03076932f, 
    0.16410194f, 0.08858994f, -0.00940921f, 0.03122894f, 0.02669651f, 0.03313190f, 0.01537402f, 0.02921014f, 
    0.18482029f, -0.01740327f, -0.14755605f, 0.03221612f, -0.01136828f, -0.54189575f, -0.13500272f, -0.06572984f, 
    0.01673522f, 0.00773004f, 0.08263928f, -0.00800760f, -0.09418099f, -0.10612287f, -0.05819350f, -0.00906040f, 
    0.23756632f, -0.20928122f, -0.08730976f, -0.21251914f, -0.06944484f, 0.05561522f, 0.15547012f, -0.04414813f, 
    0.25878388f, 0.13360628f, 0.13366339f, 0.10133962f, 0.17300333f, 0.25766778f, 0.05374353f, 0.16559151f, 
    -0.09835085f, -0.06115204f, -0.10111978f, -0.05873635f, 0.06549845f, 0.05110786f, 0.04490552f, -0.01715513f, 
    0.05788914f, 0.03117083f, 0.09131639f, -0.13136443f, -0.05762604f, -0.12699550f, 0.03288881f, 0.07856171f, 
    0.07014102f, 0.08539946f, 0.04070452f, -0.05277636f, 0.17799377f, 0.40005985f, 0.17693093f, -0.10681547f, 
    -0.02244621f, 0.02550972f, -0.01711822f, -0.02888231f, 0.15643388f, 0.17418306f, -0.13389698f, 0.03107134f, 
    0.09915568f, 0.11346679f, 0.07965037f, -0.05132955f, 0.06575649f, 0.00652047f, 0.00242612f, -0.02111134f, 
    0.15108880f, 0.04085294f, 0.02731607f, 0.01866282f, -0.10613623f, -0.03116518f, 0.10972182f, 0.20608217f, 
    -0.10015682f, 0.11737266f, 0.01847037f, -0.12351391f, -0.10924461f, -0.04838723f, 0.01024450f, 0.14355904f, 
    0.14198458f, -0.07421207f, 0.04070386f, 0.10981298f, -0.02317367f, -0.02256449f, 0.04968487f, 0.14633287f, 
    0.05779872f, -0.02464456f, 0.06972032f, -0.06003859f, 0.07391302f, -0.10186122f, -0.04594683f, -0.07781073f, 
    0.07091863f, -0.03289832f, 0.01433390f, 0.05572093f, 0.09971526f, 0.20341446f, 0.06934161f, -0.03169624f, 
    0.15735786f, 0.14990851f, 0.13594753f, 0.03609131f, -0.04552662f, 0.10092958f, 0.06617930f, -0.02506940f, 
    0.04079993f, 0.14764620f, 0.03684419f, -0.00180566f, 0.12880847f, 0.23057133f, 0.21933825f, 0.20785731f, 
    -0.02009065f, 0.01283059f, 0.03149992f, -0.08427018f, 0.05087331f, 0.02298981f, 0.01446219f, 0.01297124f, 
    -0.19756021f, -0.20139587f, 0.25146273f, 0.13969551f, -0.04852533f, 0.12164220f, -0.02817368f, 0.02367976f, 
    -0.08119202f, -0.11182489f, -0.08257998f, 0.08293562f, 0.18702228f, 0.08876397f, -0.07746492f, -0.09923952f, 
    0.03605587f, 0.16230243f, -0.06315836f, 0.01385461f, -0.00721606f, 0.07538557f, 0.05382833f, -0.01301702f, 
    -0.19080871f, -0.30692697f, -0.26421317f, -0.12751076f, 0.01601836f, 0.05761905f, -0.13651752f, 0.12670693f, 
    0.01038943f, -0.03655321f, 0.00928633f, -0.03525574f, 0.13503148f, 0.14481491f, 0.01541581f, 0.08555502f, 
    -0.10295007f, 0.00509751f, -0.02455120f, -0.03703558f, 0.01804397f, 0.07834288f, -0.05031618f, 0.02577860f, 
    0.03320917f, 0.14314391f, -0.04569664f, -0.16221893f, 0.04312721f, -0.03118934f, -0.07505682f, -0.02581606f, 
    -0.01450138f, 0.18926150f, 0.11052451f, 0.26319432f, -0.25598180f, -0.42521697f, -0.22683369f, -0.04136951f, 
    0.06959553f, 0.05686094f, 0.02604120f, 0.01307986f, -0.01920336f, -0.02553368f, 0.02763985f, -0.08361913f, 
    0.40630117f, 0.14651643f, -0.03849099f, 0.28933346f, 0.03077402f, -0.01189420f, 0.11556445f, -0.08326723f, 
    -0.10563460f, -0.06881797f, -0.00432507f, 0.05912162f, 0.21668977f, 0.06373189f, 0.04060791f, 0.04490505f, 
    0.02727412f, -0.02489249f, 0.00873648f, 0.03583533f, 0.18691064f, -0.00790230f, 0.09027138f, 0.18744476f, 
    0.02815487f, 0.03660152f, -0.04091560f, 0.04162877f, -0.05059887f, -0.04161988f, -0.03837922f, -0.03527103f, 
    0.03561011f, 0.00594452f, 0.03686218f, -0.03303161f, 0.04164971f, -0.02991313f, 0.03971757f, -0.00884494f, 
    -0.02300640f, -0.02997294f, -0.04925045f, 0.01685669f, 0.03382931f, 0.01256465f, 0.00554439f, 0.01654279f, 
    -0.03736921f, -0.03911066f, 0.03116455f, -0.01574973f, -0.00431619f, -0.00901564f, -0.02046131f, -0.03548896f, 
    0.00594215f, -0.03004150f, -0.05068914f, -0.00622563f, -0.02584365f, -0.00564346f, 0.02064027f, -0.01481785f, 
    0.01410582f, 0.00566761f, -0.02389949f, -0.00646548f, -0.02298961f, -0.05447222f, 0.00991765f, 0.01130441f, 
    0.03435893f, 0.00138580f, 0.00215027f, -0.03823236f, -0.02983490f, 0.00014051f, -0.05550226f, -0.03206159f, 
    0.03483315f, 0.03922755f, 0.02113690f, 0.02050341f, 0.01417613f, 0.02281996f, 0.01235497f, -0.02657411f, 
    -0.02840891f, 0.00135631f, 0.03512798f, -0.05684613f, 0.00403211f, 0.00210982f, -0.01670147f, -0.03490769f, 
    0.02312333f, -0.02443258f, -0.01886290f, -0.01603891f, 0.02727939f, 0.00149903f, -0.04785951f, 0.00574423f, 
    -0.01364260f, 0.02999095f, 0.03076090f, -0.05260334f, 0.02666201f, -0.02133118f, -0.00060638f, -0.02959961f, 
    -0.05001874f, -0.01896464f, 0.02031651f, -0.01320667f, 0.04066119f, -0.03923703f, -0.02404159f, -0.02752621f, 
    0.04388406f, 0.02337546f, 0.02287448f, -0.03068735f, -0.01927660f, 0.02071386f, 0.02270869f, 0.01932235f, 
    -0.05629760f, -0.05518342f, 0.00946388f, 0.02055940f, 0.00199646f, 0.03040250f, -0.00295759f, -0.01558302f, 
    -0.04784130f, -0.04089828f, -0.04629131f, 0.01584911f, -0.04437532f, -0.02110683f, -0.04559922f, -0.05867082f, 
    0.03006236f, 0.01634259f, 0.03362750f, 0.00753062f, -0.05602538f, 0.04117253f, -0.03741585f, -0.02346625f, 
    -0.05335197f, 0.01774832f, -0.00251026f, -0.02263229f, 0.00224710f, -0.03877771f, -0.04456098f, -0.02436296f, 
    -0.01287034f, -0.00122677f, 0.01327990f, -0.01720790f, -0.01574221f, 0.01201661f, 0.01850343f, -0.05641059f, 
    -0.01763529f, -0.04544231f, -0.01557980f, 0.01926573f, 0.00526421f, -0.00222122f, 0.01128410f, -0.03475648f, 
    0.01450055f, -0.04339923f, -0.01767975f, 0.02004908f, 0.01743715f, -0.03601408f, -0.04515825f, -0.05434863f, 
    -0.00932769f, 0.00267874f, 0.02702485f, -0.01193301f, -0.03153575f, -0.04399713f, 0.00984185f, 0.04502639f, 
    -0.01642693f, 0.02941020f, -0.05668925f, 0.02958109f, -0.05542824f, -0.00007915f, -0.01422830f, 0.00080119f, 
    -0.02726367f, 0.02456765f, 0.01943648f, 0.01304081f, -0.04543743f, -0.05375384f, -0.01886101f, 0.01234513f, 
    -0.03011008f, -0.02605147f, -0.00586465f, -0.05333241f, 0.02769125f, -0.01697870f, 0.02026678f, 0.00932784f, 
    -0.05414236f, -0.05431700f, 0.00337876f, -0.05644175f, 0.00846733f, 0.01098919f, -0.03154497f, -0.03342584f, 
    -0.00718552f, -0.05534867f, -0.00657594f, -0.03040018f, -0.01281900f, -0.01478348f, -0.01969093f, -0.04678568f, 
    0.02088114f, -0.05686117f, -0.01497833f, -0.05179259f, -0.05463381f, 0.01906640f, -0.02574644f, 0.01563196f, 
    -0.02120434f, 0.03167418f, 0.02173914f, 0.02177668f, 0.02793231f, -0.02587752f, 0.02470964f, -0.04585700f, 
    0.03521975f, 0.04075250f, 0.01587553f, -0.05357631f, 0.03805005f, 0.00220124f, -0.01947644f, -0.01554746f, 
    0.03391445f, -0.04904775f, -0.01720480f, -0.05844638f, 0.00823615f, -0.04854079f, 0.02777715f, -0.03498732f, 
    -0.01063921f, 0.04000530f, -0.03505329f, 0.02491169f, -0.05503480f, -0.00552150f, -0.04192406f, -0.05109344f, 
    -0.03335597f, -0.00743485f, 0.00086779f, 0.01839284f, -0.02241132f, -0.00844232f, -0.00595913f, -0.04491071f, 
    0.01677247f, -0.03251856f, -0.01803655f, 0.03968730f, 0.00050766f, -0.04887422f, 0.03185081f, 0.03157671f, 
    0.01779653f, -0.04282356f, 0.02744229f, -0.00486331f, 0.01885992f, -0.04517637f, 0.01025739f, -0.03961250f, 
    -0.00526173f, -0.01897968f, -0.04460196f, -0.03388096f, -0.05784465f, 0.01819973f, 0.02111716f, 0.00336184f, 
    0.02239134f, 0.02881090f, -0.03020347f, -0.01797692f, -0.02225768f, 0.04457071f, 0.03404057f, 0.03617049f, 
    -0.03115725f, -0.00958414f, -0.02177050f, 0.03031976f, -0.00484831f, 0.02621828f, 0.01967175f, -0.00170080f, 
    -0.00415258f, 0.02563653f, -0.01400254f, 0.04050698f, -0.01485185f, 0.02698356f, -0.01831688f, 0.01344521f, 
    0.02146623f, -0.05099446f, 0.00296081f, -0.00487862f, -0.05624463f, -0.00056634f, -0.03310901f, 0.03120332f, 
    0.02253720f, -0.04410753f, -0.01818718f, 0.03973768f, -0.00524479f, -0.05001046f, 0.03517114f, 0.03088577f, 
    -0.05008585f, -0.03660782f, -0.04003805f, -0.02989673f, -0.01254085f, -0.00933089f, 0.03330581f, -0.03035079f, 
    -0.02603705f, 0.00883734f, -0.01174100f, -0.00328187f, 0.02736694f, -0.03310189f, -0.00784200f, -0.02685645f, 
    -0.02715050f, 0.02967732f, 0.04329156f, 0.04576644f, -0.01082206f, -0.05350840f, -0.02372735f, -0.00013601f, 
    -0.05710109f, 0.04485199f, 0.04182751f, 0.01656256f, 0.01718002f, -0.03749995f, -0.01037698f, -0.04211747f, 
    -0.05231820f, 0.02993780f, -0.03256263f, 0.03074094f, -0.00853890f, -0.00178196f, 0.00670728f, 0.02934671f, 
    0.03773271f, -0.00028743f, -0.02261094f, 0.03901266f, -0.00763647f, 0.03927021f, -0.00102486f, 0.02659660f, 
    -0.01791586f, -0.01060234f, 0.03448748f, -0.02825251f, 0.01726665f, 0.00053561f, -0.01555256f, -0.02961845f, 
    0.01070671f, -0.01848496f, -0.00542472f, 0.00422875f, 0.01279564f, -0.01860938f, -0.05725139f, 0.03420679f, 
    -0.03004215f, -0.01963660f, -0.06019254f, -0.03231829f, 0.00775232f, 0.03309478f, 0.02768260f, -0.03403383f, 
    -0.01902787f, -0.04062054f, -0.04666402f, -0.00676574f, 0.01864490f, -0.00705693f, 0.01894323f, 0.02561451f, 
    0.01368809f, -0.02998436f, 0.00841664f, -0.00135493f, -0.04533441f, 0.01261057f, -0.00660619f, 0.00401910f, 
    0.01051933f, 0.02346224f, -0.00183784f, -0.04601291f, -0.00965792f, 0.02614649f, -0.01082610f, -0.04748492f, 
    -0.05370644f, 0.01017780f, -0.04325624f, 0.01356711f, 0.03182470f, 0.00283466f, 0.01739652f, 0.03508198f, 
    0.01544598f, -0.04516107f, -0.04458850f, -0.03010903f, -0.00742733f, -0.02454884f, 0.01234844f, 0.00143194f, 
    -0.00550495f, 0.00240130f, 0.04117471f, 0.01249876f, 0.02542751f, 0.02296168f, 0.02174813f, 0.00667475f, 
    0.03402904f, -0.04749437f, -0.04311249f, 0.03781226f, -0.03391919f, -0.00343437f, -0.05219621f, 0.00959064f, 
    0.02515938f, -0.04211284f, -0.00503483f, -0.00345481f, -0.02066887f, -0.01143532f, 0.00403747f, -0.04002115f, 
    -0.01657159f, -0.05141783f, -0.03573658f, 0.04766229f, -0.03306670f, 0.00604833f, -0.01532930f, 0.01982776f, 
    -0.00575725f, 0.04191725f, -0.05181880f, 0.02941364f, -0.02837442f, -0.01920107f, 0.00640989f, 0.02056678f, 
    -0.02464276f, 0.02350977f, 0.00608188f, 0.00118597f, -0.01930399f, 0.00112317f, 0.02181765f, 0.02680058f, 
    -0.02578576f, -0.03594004f, 0.00927283f, 0.02463508f, -0.02010467f, -0.00963393f, -0.02914961f, -0.02630906f, 
    -0.00219344f, -0.01694800f, -0.01722022f, -0.03385712f, 0.05381730f, 0.01195777f, 0.03374781f, -0.03449199f, 
    0.02172364f, 0.02469688f, 0.00752147f, 0.01616520f, -0.03612101f, 0.01445081f, 0.01933900f, 0.00559118f, 
    -0.05393994f, -0.04158501f, 0.03272572f, 0.00505632f, -0.04643284f, 0.04173837f, -0.04645119f, -0.02529702f, 
    0.03399430f, -0.00991238f, -0.02145445f, -0.01051881f, -0.03013900f, 0.00007646f, 0.00144080f, -0.01966259f, 
    0.02892923f, 0.02521324f, -0.05970686f, -0.01178120f, 0.03121801f, 0.03988295f, 0.00079821f, -0.05326474f, 
    0.02158247f, -0.00932634f, 0.00918948f, -0.03486286f, 0.02476997f, 0.00249282f, -0.00634396f, 0.00858414f, 
    -0.02808058f, -0.05315133f, 0.00815240f, -0.04314223f, 0.05021578f, 0.05608967f, 0.01375781f, 0.02223699f, 
    0.05014992f, -0.04085176f, -0.02000290f, -0.01036914f, 0.03281321f, 0.00345831f, -0.01528406f, -0.01597863f, 
    -0.04391126f, -0.05688174f, -0.04650505f, -0.05013373f, 0.01386747f, 0.01947311f, -0.03729267f, -0.05051093f, 
    -0.04114562f, 0.04078569f, 0.01638694f, 0.02742661f, -0.05755808f, 0.03038685f, 0.01802298f, -0.03565184f, 
    0.01355245f, -0.05240418f, 0.00800172f, 0.00374177f, 0.03343733f, -0.03670778f, -0.01229798f, 0.03072304f, 
    -0.01596074f, 0.03724134f, 0.03911428f, -0.05801912f, -0.02193560f, -0.04397766f, -0.02637650f, -0.03337204f, 
    0.01740386f, 0.03410272f, -0.01649855f, -0.05592123f, -0.00793479f, 0.01980337f, 0.03525896f, -0.03699148f, 
    0.02776263f, -0.02912241f, -0.02697468f, -0.02810965f, -0.05557773f, 0.00299850f, -0.05816973f, -0.03437218f, 
    -0.02709246f, -0.01912459f, -0.03183114f, 0.02488055f, 0.00008180f, 0.00882588f, -0.03694870f, -0.02499731f, 
    -0.02191581f, -0.05479783f, -0.01326617f, 0.02422361f, -0.01985910f, -0.05144193f, -0.05726298f, -0.03391463f, 
    -0.05210892f, -0.05572831f, -0.04008008f, 0.03115774f, 0.00096073f, -0.02602548f, 0.01641217f, -0.01474737f, 
    0.03465563f, -0.01755825f, 0.00141197f, -0.00253049f, 0.01080762f, -0.01189323f, -0.04652346f, -0.03794920f, 
    0.03869938f, -0.01364987f, -0.01182059f, -0.03601749f, 0.01570647f, -0.05752585f, 0.03792520f, 0.03078212f, 
    -0.00167800f, 0.04278994f, -0.05000638f, 0.00614092f, 0.01682383f, 0.00602664f, 0.01946718f, -0.01121826f, 
    -0.02706197f, -0.01270840f, -0.01816758f, -0.01849593f, 0.01952912f, 0.00353226f, -0.03232811f, 0.00283909f, 
    -0.00872228f, -0.00824173f, 0.03526012f, -0.04903190f, -0.01550395f, -0.00166638f, 0.00319177f, 0.04024988f, 
    -0.05457975f, 0.00083814f, 0.02964301f, -0.05420332f, -0.04186216f, 0.02179679f, 0.01656769f, 0.01594981f, 
    0.02201104f, 0.00905039f, 0.02773283f, 0.04283450f, 0.02373173f, -0.05526166f, 0.04199243f, -0.03309691f, 
    -0.01628474f, -0.02934758f, 0.02908538f, -0.00024686f, -0.03107378f, 0.01324554f, 0.00125370f, 0.03831923f, 
    0.00466561f, -0.05442135f, -0.05054707f, -0.04257192f, 0.04133656f, 0.01262779f, -0.05425386f, -0.02117245f, 
    0.05503937f, 0.01186945f, -0.00080204f, -0.05012136f, -0.05227542f, -0.03426917f, -0.03498034f, -0.04290992f, 
    0.02512556f, -0.02295072f, -0.04550235f, 0.01994735f, 0.03868917f, -0.02101692f, -0.01241692f, 0.03920853f, 
    0.02238603f, 0.02603594f, 0.03476721f, 0.02016588f, -0.04956451f, -0.03092130f, 0.02317684f, 0.01658368f, 
    0.01024150f, -0.02081831f, -0.04460513f, -0.04746993f, -0.00132892f, -0.04382575f, 0.03639916f, 0.00527179f, 
    0.02792290f, 0.02243998f, -0.04967128f, -0.02804441f, -0.00769382f, -0.04627870f, -0.03014223f, 0.03853009f, 
    -0.02342487f, -0.05863232f, 0.00337766f, 0.02736249f, 0.00048863f, 0.02314090f, -0.01318312f, 0.00068586f, 
    -0.02072957f, 0.01352607f, 0.01246058f, -0.04104075f, 0.02040458f, 0.01790288f, -0.04062838f, -0.05156842f, 
    -0.04919818f, -0.00972230f, 0.02704687f, 0.03995408f, 0.01839493f, -0.03285199f, -0.03972227f, 0.02997731f, 
    -0.01439205f, 0.00524966f, -0.02918847f, -0.02996662f, 0.03271729f, 0.01029447f, 0.04112955f, -0.02862147f, 
    -0.28649539f, 0.11705055f, 0.33830902f, -0.05881096f, -0.02243124f, 0.12688977f, -0.00186971f, -0.04010293f, 
    -0.01043154f, 0.01165133f, 0.00564765f, 0.10840442f, -0.07076952f, -0.23246101f, -0.06534213f, 0.10796054f, 
    0.14987859f, 0.00090321f, 0.04341587f, 0.16007338f, -0.05933009f, 0.08349266f, 0.02491204f, 0.06309511f, 
    -0.07598343f, -0.10653793f, 0.08115651f, 0.03650847f, 0.08264977f, 0.12331621f, 0.05874386f, 0.05198626f, 
    -0.00116430f, -0.05814278f, 0.01600135f, -0.00632189f, -0.05704932f, 0.14798471f, 0.01050338f, -0.02050666f, 
    -0.12301323f, 0.00988569f, 0.04676100f, -0.04471016f, 0.03986145f, -0.03540645f, 0.07443648f, 0.07511918f, 
    -0.17430490f, 0.10383271f, -0.07261446f, 0.04111262f, 0.04065084f, 0.03556585f, -0.00088473f, -0.01726859f, 
    -0.05060503f, -0.05800201f, -0.06249210f, 0.05271375f, -0.03415571f, -0.17226246f, 0.03635402f, -0.13690470f, 
    -0.01601365f, 0.04993844f, 0.02881762f, 0.05383329f, -0.09817803f, 0.01231160f, 0.19743784f, -0.08633967f, 
    -0.18630102f, -0.38358152f, -0.02987845f, -0.01607946f, 0.03678558f, -0.02843935f, 0.11565310f, -0.00796497f, 
    0.16032839f, 0.03617115f, -0.04600137f, -0.03219031f, -0.05824918f, 0.25364873f, 0.14629661f, 0.08695565f, 
    -0.06476127f, 0.00076491f, -0.00203231f, -0.04693035f, 0.07793637f, -0.05527384f, 0.03110809f, -0.01963581f, 
    0.50542867f, -0.12161805f, -0.01717720f, 0.03446568f, 0.06437246f, -0.01159560f, 0.03129172f, -0.08074863f, 
    0.01978871f, 0.11002488f, 0.21361744f, 0.01124751f, -0.00387434f, 0.01173869f, 0.15109922f, 0.09666379f, 
    0.07088274f, -0.04618986f, -0.02187365f, 0.09659074f, 0.06392352f, 0.02722126f, 0.03510110f, 0.08959942f, 
    -0.03998401f, 0.11186238f, -0.07586650f, -0.02403394f, 0.01694258f, -0.04917347f, 0.01995437f, -0.02392295f, 
    -0.12514475f, 0.07716364f, -0.06700146f, -0.28429082f, -0.10507820f, -0.14746483f, -0.04151082f, 0.21190411f, 
    0.05599921f, 0.23249906f, 0.00638512f, -0.07099701f, 0.04090674f, 0.05680228f, -0.01679273f, -0.04457666f, 
    -0.02743270f, -0.10299728f, 0.08475602f, -0.14871518f, -0.07325124f, 0.03549621f, -0.09146082f, -0.00670195f, 
    0.12297281f, 0.05813950f, 0.09772110f, 0.03556192f, -0.06999754f, 0.01038455f, -0.01462204f, 0.05456052f, 
    0.03419210f, 0.02593423f, 0.04770628f, 0.04510340f, -0.04814257f, -0.02183658f, 0.03495298f, 0.07683074f, 
    0.54056257f, 0.14979084f, -0.26868284f, 0.03830180f, 0.06087809f, 0.13181312f, -0.04377330f, -0.04091869f, 
    0.03399448f, 0.09368023f, 0.10681904f, -0.00993522f, 0.18593083f, 0.10449069f, 0.13349797f, -0.19967800f, 
    -0.10279870f, -0.06470023f, -0.08251378f, 0.02218079f, -0.02158016f, -0.02193790f, -0.06568903f, -0.04185416f, 
    0.24065553f, 0.02709043f, 0.13773428f, 0.08859157f, 0.00220301f, -0.09584946f, -0.05779929f, 0.00800520f, 
    0.00693199f, -0.05466778f, -0.08775620f, 0.01418612f, -0.04866289f, 0.09267823f, 0.04954893f, -0.04440147f, 
    -0.00794865f, -0.02728391f, -0.06755125f, -0.04083107f, -0.01329845f, -0.13704748f, 0.15569878f, -0.04935838f, 
    -0.07361090f, -0.02119689f, -0.02375186f, -0.09765063f, 0.03574104f, 0.01045427f, 0.01675160f, -0.00995533f, 
    0.06844577f, 0.07421140f, 0.10525924f, 0.18403301f, -0.03564544f, 0.14943090f, 0.17951992f, -0.02675665f, 
    -0.09625040f, 0.11653302f, 0.02704342f, 0.13155915f, 0.00476032f, -0.01523325f, 0.04404538f, 0.03624019f, 
    -0.16989133f, -0.18632711f, 0.22393315f, 0.03179269f, 0.00746326f, -0.08192167f, -0.04743595f, 0.07021765f, 
    -0.00975178f, 0.03765144f, -0.03255280f, 0.04661135f, 0.14640459f, -0.22727805f, 0.21440676f, -0.04075073f, 
    0.11132791f, 0.01519954f, 0.02411839f, -0.03543966f, -0.02945404f, -0.04366934f, -0.04314329f, 0.08402557f, 
    -0.26287943f, 0.01982330f, 0.14755188f, -0.05551156f, 0.02058421f, -0.08828802f, -0.16178623f, 0.09083171f, 
    0.03447118f, -0.07864194f, 0.07087990f, 0.04141838f, -0.04209714f, 0.06861743f, 0.08218805f, -0.06026769f, 
    -0.06028257f, -0.06148775f, -0.10691524f, -0.02213886f, -0.02481855f, -0.03375201f, -0.07449418f, -0.05495403f, 
    -0.18437539f, -0.19074510f, -0.03215744f, 0.22981997f, 0.05090696f, 0.00660451f, 0.11206350f, -0.15998390f, 
    -0.01679906f, -0.02598550f, 0.02731543f, 0.04920270f, 0.19215572f, 0.02385646f, -0.11913658f, 0.04503391f, 
    0.09152956f, 0.04833778f, 0.09281774f, 0.04775838f, 0.06219964f, 0.07105114f, -0.01387476f, 0.02029906f, 
    -0.15118687f, -0.13305312f, -0.02881787f, 0.17523153f, 0.01169957f, 0.08341414f, 0.09810531f, -0.03513286f, 
    0.02493360f, 0.07366842f, 0.00400440f, -0.12068373f, 0.03516164f, 0.09010578f, 0.25747660f, 0.02048516f, 
    0.00096544f, -0.04476561f, -0.07180179f, -0.07514937f, 0.02763416f, -0.00188055f, 0.02062903f, 0.02344180f, 
    0.27530572f, -0.06117928f, -0.20585532f, -0.06850985f, 0.04882897f, -0.10479195f, 0.04648716f, -0.04847601f, 
    0.01777531f, -0.03788159f, 0.07331278f, -0.17769645f, -0.03176627f, -0.02871015f, 0.11552487f, 0.24292116f, 
    0.10971987f, 0.00166053f, -0.00479658f, -0.02424655f, 0.04457945f, 0.05706923f, 0.06786194f, 0.10184278f, 
    -0.29422629f, 0.15928912f, -0.05116896f, 0.13171867f, -0.00607277f, 0.03780436f, -0.14872782f, 0.11529281f, 
    0.04508495f, 0.00804740f, -0.04148040f, -0.09871319f, 0.08652648f, 0.38583174f, -0.13235073f, -0.17103346f, 
    -0.03850238f, -0.03255305f, -0.04740186f, -0.06030295f, 0.15370244f, 0.02332611f, -0.08534709f, 0.02918765f, 
    0.48745617f, 0.13028201f, 0.04396526f, 0.05301709f, -0.02031325f, -0.09996692f, 0.16614243f, 0.20631127f, 
    -0.02640020f, 0.11257454f, -0.00825358f, -0.04006304f, -0.13751614f, 0.13794433f, 0.11672723f, -0.11237779f, 
    -0.10645109f, -0.13663299f, 0.14584395f, 0.03627304f, -0.02733589f, -0.05492863f, 0.06378582f, 0.10040943f, 
    -0.16545542f, -0.11266893f, 0.13785370f, 0.12264945f, -0.07496268f, 0.11448506f, 0.07264578f, 0.15061694f, 
    0.09175566f, 0.15699695f, 0.00463864f, 0.05691198f, 0.01876204f, -0.04164435f, 0.01756080f, 0.15130532f, 
    -0.04881941f, -0.01076841f, -0.02607835f, -0.04612192f, 0.07058013f, 0.07301511f, -0.00190585f, 0.07363719f, 
    0.03744480f, 0.07775988f, 0.06219298f, -0.13311319f, -0.01690407f, 0.03422678f, -0.04018224f, 0.06017375f, 
    0.22195113f, 0.09221912f, 0.02852536f, 0.04785461f, 0.01164002f, 0.09700271f, 0.11069813f, 0.21628673f, 
    0.04721932f, 0.04835727f, -0.06006966f, 0.01824553f, 0.17288715f, 0.08171935f, 0.07527805f, 0.01546361f, 
    0.17600462f, 0.30220509f, 0.14400484f, -0.07421730f, -0.11193893f, -0.09681429f, -0.17452078f, 0.07265695f, 
    -0.04655106f, 0.09501556f, 0.09810709f, -0.07034155f, 0.20558953f, 0.00403566f, 0.12614785f, -0.02276209f, 
    0.02924342f, 0.03781277f, 0.14231506f, 0.13875513f, -0.02073778f, -0.03178547f, -0.09117913f, -0.08293395f, 
    -0.38879839f, 0.26108706f, -0.29588264f, 0.05805116f, -0.02402606f, 0.09500729f, 0.13807325f, 0.03258590f, 
    0.03515145f, 0.03193001f, -0.00390293f, 0.02747487f, -0.07791194f, -0.03203355f, -0.16583285f, 0.11554957f, 
    -0.04817875f, 0.10016722f, -0.05534292f, -0.03195840f, 0.10572047f, 0.12148801f, 0.06063408f, -0.13808535f, 
    0.14967693f, 0.04743764f, 0.15550411f, 0.09778965f, 0.00891673f, 0.02915001f, -0.06941781f, 0.03108764f, 
    0.10157242f, -0.20420156f, 0.08690920f, 0.17882858f, -0.12985826f, 0.05244484f, 0.07361241f, -0.03250306f, 
    -0.07478256f, -0.16068046f, -0.02618386f, 0.08426633f, -0.05491136f, -0.01052010f, 0.03876308f, 0.05804250f, 
    0.06831311f, 0.15925117f, -0.12488829f, 0.04898567f, -0.01121158f, -0.09084860f, -0.07177278f, -0.04322106f, 
    -0.10887498f, 0.07765245f, 0.04399568f, -0.01759822f, -0.14252992f, 0.09728838f, 0.11287447f, 0.05701752f, 
    -0.06208772f, -0.09874512f, 0.00439229f, 0.02755838f, 0.02561655f, -0.00670113f, -0.08507804f, -0.07288929f, 
    -0.12745014f, 0.10906006f, 0.22317626f, -0.05533249f, -0.06794412f, 0.07450306f, 0.04738124f, -0.09201942f, 
    0.11478715f, 0.07903905f, -0.04224254f, 0.07727399f, 0.11005670f, -0.08132491f, -0.22885068f, -0.21621738f, 
    -0.07781009f, -0.00174022f, 0.04946859f, -0.05032666f, 0.01127659f, 0.04032283f, 0.05700749f, -0.07755927f, 
    0.08717137f, -0.05566953f, 0.01792448f, -0.29647237f, 0.02562816f, 0.08982480f, 0.06058380f, 0.13592316f, 
    -0.03113159f, -0.01731153f, -0.04127890f, -0.10499629f, 0.17096719f, 0.17813179f, 0.03777898f, 0.07524899f, 
    -0.12298231f, -0.07011417f, -0.04807937f, -0.11596911f, -0.03256468f, -0.01968444f, 0.00096291f, 0.11973453f, 
    -0.03587973f, 0.11698660f, 0.00012316f, 0.00626249f, 0.03762504f, 0.02392749f, -0.01002972f, -0.03572632f, 
    0.08909433f, 0.04064849f, 0.16308028f, -0.07112113f, -0.19398925f, -0.34495047f, -0.03122050f, 0.19810642f, 
    -0.00490552f, -0.02565980f, 0.07324347f, -0.07665329f, 0.05554748f, 0.05088357f, 0.00667910f, 0.11182509f, 
    0.14113633f, 0.07354420f, -0.31866109f, -0.04645103f, 0.07378033f, -0.08554759f, 0.13107061f, -0.07622270f, 
    -0.11342853f, -0.00565420f, -0.02071393f, 0.01976385f, 0.09986920f, 0.27930602f, -0.04724374f, 0.10110344f, 
    0.06082596f, -0.01927153f, 0.10590364f, -0.04935573f, 0.06798420f, 0.08801921f, 0.09244483f, -0.08523811f, 
    0.24226196f, 0.01321903f, 0.05934215f, -0.00290298f, 0.07672905f, 0.01818613f, 0.10923832f, 0.08968635f, 
    -0.05439029f, -0.02334663f, -0.02706083f, 0.03903102f, 0.12013027f, -0.07034940f, -0.14171302f, -0.08010745f, 
    -0.09383160f, 0.00513769f, -0.01426017f, -0.14385851f, -0.02218986f, -0.05094166f, -0.10513040f, -0.00587769f, 
    -0.20656443f, -0.01417974f, 0.04972723f, -0.01989588f, -0.01718570f, -0.03664861f, -0.10075621f, -0.00405680f, 
    -0.00118119f, 0.00635408f, -0.03587525f, 0.05808423f, -0.14096309f, -0.08367456f, 0.14137088f, 0.02862052f, 
    0.00468237f, 0.08263601f, -0.04382991f, 0.10348297f, 0.07794008f, 0.08808564f, 0.15558641f, 0.14013113f, 
    -0.09155296f, 0.04088363f, 0.01432217f, 0.02875204f, 0.09263504f, -0.04911608f, 0.00380351f, 0.11301345f, 
    0.14249106f, 0.06631359f, 0.02253498f, 0.01379557f, -0.07983939f, -0.06682773f, -0.10310329f, -0.01480558f, 
    -0.04749053f, 0.02855223f, 0.11419991f, -0.06588110f, -0.06354389f, 0.09298911f, -0.02190127f, 0.04282432f, 
    -0.21972711f, 0.20858106f, 0.08939839f, 0.08662587f, -0.00097652f, 0.06367804f, -0.08392713f, -0.08575886f, 
    0.06625852f, 0.06967354f, -0.00488225f, 0.14775223f, -0.29247624f, 0.10809826f, -0.11668560f, -0.06128687f, 
    0.09374005f, -0.07227584f, 0.08829274f, 0.12174357f, 0.04983065f, 0.02269831f, 0.07697587f, 0.03893812f, 
    -0.05942320f, -0.45040828f, 0.21040426f, 0.12507674f, 0.05110612f, 0.17305784f, 0.01368816f, -0.09297055f, 
    0.19544964f, 0.11343657f, 0.22491899f, 0.04640377f, 0.01302979f, -0.03836429f, 0.24803874f, 0.17296529f, 
    0.03140202f, 0.06688184f, 0.00629694f, -0.00075100f, -0.10235584f, 0.15597692f, 0.19143809f, 0.06256342f, 
    -0.01025538f, -0.00217997f, -0.01200472f, 0.00259118f, 0.03885910f, 0.01633337f, 0.00791468f, -0.04088580f, 
    -0.05247970f, 0.02059219f, -0.00062594f, 0.02979233f, 0.02606119f, -0.00246565f, -0.01686148f, -0.02310281f, 
    -0.04438818f, 0.02677995f, -0.04415533f, 0.01374639f, 0.00724670f, 0.00752641f, -0.04547650f, -0.02714476f, 
    0.02743547f, 0.02764433f, -0.01203016f, -0.01054130f, 0.00544907f, -0.03203945f, -0.02406946f, -0.03004486f, 
    0.01933527f, -0.05230759f, -0.00452429f, 0.01246154f, -0.04981053f, 0.04871134f, 0.00809417f, 0.02982547f, 
    0.01746692f, 0.03115031f, -0.03751110f, 0.02393554f, 0.01884040f, -0.04626999f, -0.00239133f, 0.04521981f, 
    0.01186618f, -0.04355199f, -0.00489319f, 0.01788620f, 0.03674802f, -0.04966780f, 0.01335259f, -0.03033589f, 
    -0.04430584f, -0.00160517f, 0.02606786f, -0.02888751f, 0.01398501f, 0.03889723f, -0.05551307f, 0.02325801f, 
    -0.02007720f, -0.00412491f, -0.02012819f, 0.01606738f, -0.00779448f, 0.00178639f, -0.03819917f, 0.01208474f, 
    -0.03551828f, -0.05635988f, 0.02687496f, -0.02635718f, -0.05189471f, -0.00705834f, -0.03891835f, -0.01284322f, 
    0.01449440f, 0.01881309f, -0.01592009f, -0.04742809f, -0.02975294f, -0.01486832f, -0.02714730f, -0.00227492f, 
    -0.01198326f, -0.01833735f, 0.03369093f, -0.00315151f, -0.03547438f, 0.00961730f, 0.01905341f, -0.04671567f, 
    -0.03537020f, 0.02562389f, -0.03413984f, -0.01071954f, -0.02764833f, -0.02979714f, 0.00929879f, -0.04571130f, 
    -0.00474804f, -0.03677181f, -0.03047703f, -0.00652705f, -0.03548583f, 0.02776083f, 0.00057482f, -0.04284290f, 
    0.02150038f, -0.03285885f, -0.04397347f, -0.05257783f, -0.00803776f, 0.04366891f, -0.00556896f, -0.05622191f, 
    -0.04213855f, 0.00999025f, 0.02166827f, -0.05603576f, -0.02735048f, -0.03783546f, -0.03066799f, -0.00673056f, 
    -0.00183923f, 0.00515986f, -0.01606365f, 0.00287794f, 0.04053611f, -0.03455772f, 0.00184206f, -0.02801388f, 
    0.00232634f, 0.00337501f, -0.01257084f, -0.04075333f, -0.04866726f, -0.00516729f, 0.01681329f, -0.04673828f, 
    -0.02082866f, -0.04590239f, 0.01679997f, -0.04053529f, 0.00689373f, 0.00346902f, 0.00263634f, -0.04269064f, 
    -0.02224710f, 0.01385729f, -0.04953178f, -0.04521694f, 0.00226330f, 0.01981674f, -0.03896108f, -0.04801532f, 
    -0.00559760f, 0.02906444f, -0.01410686f, 0.04021023f, 0.02834494f, -0.03350719f, 0.02017168f, -0.00565098f, 
    0.01215361f, 0.02107438f, 0.03501673f, 0.00967191f, -0.02701162f, 0.02166824f, -0.04273515f, -0.02895261f, 
    -0.05375257f, -0.03810841f, 0.00250004f, 0.02361456f, 0.01669317f, -0.02408046f, 0.02966074f, 0.02637090f, 
    -0.04872582f, -0.02001186f, -0.02283057f, -0.00158697f, -0.00698496f, 0.03807462f, -0.03018619f, 0.03870599f, 
    0.02137237f, -0.03950873f, 0.01854861f, -0.04800755f, 0.04120548f, 0.01698114f, 0.00874961f, -0.01308038f, 
    -0.05172135f, -0.01091894f, 0.03314842f, -0.02300373f, -0.05109596f, 0.04449168f, -0.00801331f, -0.04311058f, 
    0.01930867f, -0.05376834f, 0.03441681f, 0.01693056f, -0.00971185f, -0.04239942f, 0.02484669f, -0.01544249f, 
    -0.00673806f, -0.00787220f, -0.05259020f, 0.03035207f, -0.01461670f, -0.04827109f, -0.01672927f, -0.01711203f, 
    -0.03056840f, 0.04377570f, 0.02916665f, 0.03966781f, 0.00609153f, 0.00826990f, -0.01941352f, -0.01961639f, 
    0.03433241f, 0.01586822f, 0.02647366f, -0.03184933f, 0.01212889f, 0.02793356f, -0.03631908f, -0.00845876f, 
    0.02481835f, 0.01532687f, -0.03410445f, -0.00395840f, -0.02643305f, -0.03403161f, -0.02977452f, 0.02448926f, 
    0.03862395f, -0.04879102f, 0.02515512f, -0.00589613f, 0.04495446f, -0.03578213f, -0.04098839f, 0.00406175f, 
    -0.01933174f, -0.04732092f, 0.01757496f, 0.03614067f, -0.04906212f, -0.00723769f, -0.02251635f, 0.03504026f, 
    0.02693209f, -0.03064721f, 0.02226088f, -0.04286041f, -0.02596873f, -0.02153507f, 0.02031793f, -0.05186071f, 
    0.02638196f, -0.03253460f, 0.01209454f, -0.03775803f, -0.03696507f, -0.00302936f, -0.04522271f, -0.01453256f, 
    -0.04879270f, -0.00096713f, -0.05070267f, -0.02292907f, 0.02988054f, 0.02639840f, 0.00754959f, -0.03410573f, 
    0.02817417f, 0.03675300f, 0.03851986f, 0.01291731f, 0.02255047f, 0.00857459f, 0.03118239f, -0.02985638f, 
    -0.02225697f, -0.04407118f, -0.04394906f, -0.04468809f, 0.00563064f, -0.04545213f, 0.02476890f, -0.01597535f, 
    0.01473727f, -0.03334657f, -0.02148818f, -0.05230140f, -0.01634612f, 0.01023238f, 0.02077398f, 0.00189759f, 
    -0.04370064f, 0.01117922f, 0.00400146f, -0.03426182f, -0.02986773f, -0.05154947f, 0.00869016f, 0.02971259f, 
    0.02959260f, -0.04753844f, -0.02666648f, -0.01649755f, -0.05007887f, -0.02319287f, -0.03533458f, 0.01793300f, 
    -0.02034313f, -0.04176776f, 0.00283865f, -0.01114567f, -0.02210402f, 0.00852141f, 0.04147266f, 0.03398474f, 
    0.03729033f, 0.04505907f, -0.05603289f, 0.03305318f, -0.02705129f, -0.01159993f, -0.00159902f, 0.01079894f, 
    -0.02498133f, -0.02301267f, 0.02468258f, -0.03321521f, 0.04302717f, -0.00083021f, -0.00556763f, -0.04728224f, 
    0.00736356f, 0.02924612f, -0.04399251f, -0.03754661f, 0.00690056f, -0.05179214f, 0.02326613f, -0.04874910f, 
    -0.01278346f, -0.04879990f, -0.01632443f, 0.03499331f, -0.01991547f, 0.00588297f, -0.01289216f, -0.01775014f, 
    0.03300613f, -0.01142976f, -0.01636641f, 0.02528245f, -0.00136980f, -0.02654983f, -0.03959100f, 0.02051647f, 
    -0.01795440f, -0.05198947f, -0.01376538f, 0.00208744f, -0.00826138f, -0.03292555f, 0.04363085f, -0.04614338f, 
    0.20101491f, 0.21720807f, 0.21035728f, -0.35511565f, 0.01546513f, 0.08461728f, -0.07829939f, -0.19052935f, 
    -0.06920606f, 0.04031218f, -0.04825692f, -0.10744514f, 0.14278562f, 0.21369803f, 0.09467616f, 0.11621495f, 
    0.13235575f, 0.03279316f, -0.08081985f, 0.17145687f, 0.01352169f, -0.06177479f, -0.06209075f, 0.04790825f, 
    0.26720253f, -0.02193703f, -0.07788688f, 0.12014668f, -0.05118243f, 0.09997606f, 0.02184964f, 0.07134612f, 
    0.00628470f, -0.01695968f, 0.02395994f, 0.05774315f, -0.11554600f, -0.17788336f, -0.21812813f, -0.09348835f, 
    0.04666230f, 0.00532346f, 0.04045726f, 0.12018763f, -0.10876189f, 0.03033596f, -0.06986549f, -0.12877081f, 
    -0.18267573f, -0.04804477f, 0.28512174f, -0.11479015f, 0.02396776f, 0.22213061f, 0.06351765f, -0.03917736f, 
    0.16335468f, 0.19626556f, -0.12075268f, 0.27669472f, 0.19104597f, -0.02552373f, 0.15901749f, 0.07440252f, 
    -0.01451310f, -0.01912061f, 0.05435514f, -0.09202052f, -0.00620052f, -0.14211582f, 0.13843945f, -0.03366474f, 
    0.49864984f, 0.17044030f, 0.26412573f, 0.19477431f, 0.00288927f, 0.13696799f, 0.10497855f, 0.02763510f, 
    -0.02099996f, -0.07963937f, 0.02388246f, 0.02504993f, -0.01531171f, 0.05872996f, -0.07493996f, -0.29656255f, 
    -0.13849580f, -0.07106372f, -0.21779573f, -0.04365709f, -0.16402067f, -0.01920087f, 0.18648578f, 0.26543477f, 
    -0.39798772f, 0.00623262f, 0.09490657f, 0.06817441f, 0.07580787f, -0.01904982f, -0.04248283f, 0.03388733f, 
    0.09296086f, -0.13792965f, 0.03596732f, -0.06095089f, 0.27668431f, 0.26261672f, 0.12218830f, 0.13378741f, 
    -0.07874933f, 0.12169115f, 0.15051264f, -0.05412852f, -0.06418969f, -0.01430489f, -0.12438501f, -0.02049895f, 
    0.14745119f, -0.27607536f, -0.02553160f, 0.05630192f, -0.00546514f, 0.02660888f, 0.03565810f, -0.16194713f, 
    0.09706252f, 0.14423999f, 0.07336988f, 0.22101656f, 0.20105226f, 0.23110546f, 0.05875101f, 0.04011023f, 
    -0.06357089f, 0.01853064f, 0.14437130f, -0.11871964f, -0.10212345f, -0.09472446f, -0.12047072f, -0.15278471f, 
    -0.01338154f, -0.19273984f, 0.08310849f, -0.05829777f, 0.14751126f, 0.06839263f, 0.02642970f, 0.00375297f, 
    -0.03919743f, -0.01269982f, 0.05858922f, -0.01838430f, 0.22510442f, 0.37552312f, 0.13557199f, 0.06568702f, 
    0.04390644f, 0.08467061f, 0.15885034f, 0.08207903f, 0.00429166f, -0.03162447f, 0.02675817f, 0.00221687f, 
    -0.09943191f, 0.23956266f, -0.17553109f, 0.13099785f, -0.06165689f, -0.04762140f, 0.02619760f, 0.04247663f, 
    -0.03001771f, 0.01013192f, 0.05855259f, -0.08346179f, 0.12599988f, -0.07235305f, -0.28242686f, -0.14353535f, 
    -0.03043152f, -0.14864478f, -0.10700526f, 0.09775197f, -0.00633262f, 0.05868314f, 0.04323611f, -0.06953049f, 
    -0.47638354f, -0.31561384f, -0.18189430f, -0.06728106f, -0.02227130f, -0.12162825f, -0.18912174f, -0.00264212f, 
    -0.06698321f, -0.03372526f, 0.07014983f, 0.09324583f, -0.28298569f, -0.28513759f, -0.26611954f, 0.21164678f, 
    0.13416868f, 0.08666409f, 0.00185254f, 0.10449255f, 0.04185780f, 0.08374608f, 0.21336180f, 0.11999667f, 
    -0.06565487f, -0.06342400f, -0.06741828f, 0.03362390f, 0.10947058f, 0.02783561f, 0.08191407f, 0.04537769f, 
    -0.04906750f, -0.09931978f, -0.15533291f, 0.09900153f, 0.21682051f, 0.13418752f, -0.16829245f, 0.06648859f, 
    0.03550911f, -0.27162221f, 0.05556290f, 0.11829519f, -0.04630341f, -0.04638817f, -0.06048987f, -0.06150016f, 
    -0.00373746f, 0.31066564f, -0.00093217f, -0.10338218f, -0.02155956f, 0.01740616f, -0.06725141f, 0.00705441f, 
    -0.00540174f, 0.06983086f, -0.05786184f, 0.02148841f, 0.09754200f, -0.17690179f, 0.32608765f, -0.03581699f, 
    -0.01936416f, 0.06343820f, -0.04854522f, 0.00487026f, -0.10984782f, -0.04909341f, 0.01744773f, 0.01147752f, 
    -0.08348321f, -0.07339083f, -0.13657814f, -0.23499247f, -0.04671533f, -0.09927191f, -0.08389786f, 0.04572335f, 
    -0.04607053f, 0.00311788f, -0.01496274f, 0.06510878f, -0.36718428f, -0.30204418f, -0.23308808f, -0.06798550f, 
    0.11255088f, -0.04686370f, 0.07142318f, 0.10746280f, 0.00225386f, 0.12753488f, 0.07809173f, 0.02244454f, 
    0.26573151f, 0.08677571f, -0.06202258f, 0.01962595f, 0.00656305f, 0.03340088f, 0.01200961f, 0.07101515f, 
    0.00036655f, 0.05247560f, 0.04029530f, 0.07291998f, -0.04261565f, 0.10665973f, 0.08293891f, 0.05590009f, 
    0.14168340f, -0.04988939f, 0.07097030f, 0.02111109f, -0.09676887f, -0.06039571f, 0.00459075f, -0.03218329f, 
    0.07477835f, 0.13894935f, 0.08790858f, 0.05909383f, 0.00409703f, 0.05045394f, 0.01369530f, -0.05893282f, 
    0.00861725f, 0.14109538f, 0.17606859f, 0.00987833f, -0.54360461f, -0.28043777f, 0.20335798f, -0.12355904f, 
    0.00629531f, -0.00038972f, 0.00937747f, 0.11231224f, -0.07903177f, -0.14884511f, 0.02726624f, -0.03012151f, 
    -0.23577820f, -0.14329012f, -0.02288807f, 0.30985054f, 0.10074715f, -0.07926732f, -0.00423091f, -0.00228253f, 
    0.07668853f, -0.06871002f, 0.14901933f, 0.06447684f, -0.02678505f, -0.01047325f, 0.13034125f, -0.00045947f, 
    0.03685729f, -0.05064131f, 0.18912970f, 0.06277069f, -0.03793489f, -0.02327202f, -0.05767963f, 0.03310927f, 
    0.47396210f, -0.04918559f, -0.14994802f, -0.06220691f, -0.06765614f, 0.10972097f, -0.03617658f, 0.03295393f, 
    0.08191516f, -0.02697850f, 0.23820911f, -0.14795300f, -0.06148166f, -0.29161209f, 0.02256993f, -0.21163104f, 
    0.07375430f, -0.04362711f, -0.00085366f, 0.07055141f, -0.15973794f, 0.00777951f, 0.12954764f, -0.18090066f, 
    0.00363859f, -0.01952216f, 0.01757393f, 0.03622534f, 0.02302404f, -0.03403392f, -0.00618383f, -0.01977001f, 
    0.01027383f, 0.01529214f, 0.02682653f, -0.00234359f, -0.05355924f, -0.05085875f, 0.01935512f, -0.03885778f, 
    0.02792904f, -0.00336801f, 0.03537346f, -0.02415919f, -0.05043878f, 0.00505304f, 0.03388701f, -0.02655083f, 
    -0.01161409f, 0.01178626f, 0.01174617f, 0.00130798f, -0.04593157f, -0.01478803f, -0.04997605f, -0.02654050f, 
    -0.04770572f, -0.03205413f, 0.01045633f, -0.04143951f, -0.05756866f, -0.05323772f, 0.01414872f, 0.01479988f, 
    -0.02783580f, -0.00048205f, -0.03050008f, 0.02356178f, 0.01631162f, -0.00456189f, 0.00669453f, -0.02658608f, 
    0.04038222f, -0.05882610f, 0.04103819f, -0.01153436f, -0.02443489f, -0.01651726f, 0.01019830f, -0.02033959f, 
    -0.05311093f, -0.04836327f, -0.01490292f, -0.03705570f, 0.02819175f, -0.00654883f, -0.02245538f, 0.00372181f, 
    0.01412509f, 0.00054553f, -0.03534104f, -0.04465891f, -0.02029709f, 0.02141575f, -0.00579243f, 0.00937840f, 
    0.02455459f, 0.01832802f, -0.00278749f, -0.02414522f, -0.03817801f, 0.03624201f, -0.00482030f, 0.02508784f, 
    0.01745559f, -0.02205385f, -0.01236178f, -0.03880509f, 0.02701969f, 0.04031264f, 0.01377160f, -0.03337263f, 
    -0.03159376f, 0.02645082f, 0.03056280f, -0.03094584f, 0.03008531f, -0.04761679f, -0.00802973f, 0.01259752f, 
    0.00404065f, -0.01175539f, -0.02794866f, 0.03656414f, 0.04093495f, -0.04891196f, -0.05800750f, 0.00782635f, 
    -0.02600675f, -0.05433049f, -0.02917321f, -0.01276591f, -0.05380795f, 0.02118732f, -0.02848312f, 0.00402120f, 
    0.00616459f, 0.02359793f, -0.00170841f, 0.02378978f, -0.03847715f, 0.00976392f, 0.01483170f, -0.04719560f, 
    -0.03145520f, 0.04067321f, -0.04739352f, -0.05471158f, 0.01065190f, 0.03039967f, -0.04180726f, -0.00347947f, 
    -0.00456005f, -0.03759560f, -0.01940097f, 0.03008948f, -0.04173427f, -0.00969586f, -0.01373450f, 0.04288877f, 
    -0.02385856f, 0.02361304f, 0.03963498f, -0.02029346f, -0.01433278f, -0.05573903f, -0.01369299f, 0.00396339f, 
    -0.04703857f, -0.03502541f, -0.01845811f, 0.03854135f, 0.01190889f, 0.02469775f, -0.04205483f, -0.02482561f, 
    0.02439475f, 0.01256454f, -0.03985462f, -0.01068172f, -0.05059297f, -0.02724705f, 0.01961001f, -0.04569769f, 
    0.00569291f, 0.03653734f, -0.01063733f, -0.01645672f, 0.03894417f, 0.03948486f, 0.00997879f, 0.03560085f, 
    -0.05585676f, 0.02564985f, -0.02785247f, -0.02312720f, -0.02541153f, 0.04246217f, 0.02989889f, -0.01183422f, 
    -0.04017209f, -0.03960233f, 0.03946028f, 0.02023356f, -0.05630958f, -0.03326931f, 0.03114051f, -0.05845993f, 
    -0.03331932f, 0.03451735f, -0.00903575f, 0.02602188f, -0.03548989f, -0.00230681f, -0.03471868f, 0.03870588f, 
    0.03579092f, 0.03072581f, -0.02269240f, 0.03631109f, 0.04312193f, -0.05695025f, -0.00207595f, -0.03146903f, 
    -0.02063794f, 0.02808892f, -0.04840460f, -0.03723676f, 0.02844298f, 0.00351567f, -0.02905589f, 0.03894368f, 
    -0.02124529f, -0.01977858f, -0.02456419f, -0.01502575f, -0.03231372f, 0.03787173f, -0.01368381f, 0.02670695f, 
    -0.04929049f, 0.00723305f, 0.01351217f, -0.03864858f, 0.05155196f, -0.02895992f, 0.00907417f, -0.05168584f, 
    -0.00699345f, -0.03280208f, 0.00825268f, -0.03206044f, 0.03011555f, -0.04191293f, -0.03664413f, -0.01041561f, 
    -0.00084104f, -0.05075618f, 0.01246473f, 0.01635095f, 0.04387934f, -0.02376796f, -0.00288546f, 0.01908323f, 
    -0.03239114f, -0.00897098f, 0.00168777f, -0.02097456f, 0.03402581f, 0.00328027f, 0.03372457f, 0.04145423f, 
    -0.05211599f, -0.02653359f, -0.03717461f, -0.04071617f, -0.04547315f, -0.00047019f, -0.04534590f, 0.02466672f, 
    0.02485771f, -0.00143731f, -0.01380541f, -0.02153239f, 0.02054171f, 0.04140965f, 0.00913610f, -0.05304536f, 
    0.00948815f, -0.01444964f, 0.02313016f, 0.04056478f, 0.04210442f, -0.02098193f, -0.05764816f, -0.04966545f, 
    -0.05500419f, -0.00530574f, 0.01545156f, 0.00356159f, 0.03970238f, 0.00326625f, -0.02080318f, -0.03918297f, 
    -0.05022397f, -0.04107762f, -0.00611420f, 0.03061612f, -0.04707157f, -0.01065343f, 0.01301313f, 0.03819244f, 
    0.03227652f, 0.00780651f, -0.03603424f, -0.02362517f, 0.00297422f, -0.03801917f, -0.00748886f, -0.04395292f, 
    -0.03138410f, -0.00543406f, 0.00774766f, -0.03001875f, -0.00244436f, 0.01027697f, -0.02914551f, -0.03060535f, 
    0.03292957f, 0.02735896f, -0.00560365f, 0.00439058f, 0.02391362f, -0.02008879f, -0.04531853f, 0.01141972f, 
    0.04758461f, -0.04298460f, -0.01667465f, -0.04412236f, -0.04668968f, -0.00242888f, -0.05775294f, 0.00455042f, 
    -0.02992337f, -0.03157903f, 0.00366982f, -0.01185666f, 0.00939725f, 0.02408162f, 0.00757632f, -0.04305835f, 
    -0.03810730f, -0.02539782f, -0.05865926f, -0.03293872f, -0.05753756f, 0.00121616f, -0.04170528f, -0.03591163f, 
    -0.00830342f, 0.04087825f, 0.03213847f, 0.01672142f, -0.01804423f, 0.01592117f, 0.01312162f, -0.02725914f, 
    -0.03154936f, 0.00792385f, -0.01965308f, 0.00839761f, -0.03552467f, -0.00331718f, -0.02451043f, -0.02542336f, 
    -0.04988012f, 0.04205268f, 0.01290184f, -0.04469792f, -0.00632794f, -0.04386121f, 0.02216196f, -0.05789418f, 
    -0.04934917f, -0.02444498f, -0.04347133f, 0.02373703f, -0.00394541f, -0.03465625f, -0.04045197f, 0.01788123f, 
    0.01738188f, 0.02715140f, -0.04347343f, 0.00656521f, -0.04312870f, 0.04011581f, 0.03135273f, -0.00713495f, 
    0.02884942f, 0.01762965f, 0.01629813f, -0.02239103f, 0.01532304f, -0.01254590f, -0.01765322f, -0.01249450f, 
    -0.05487341f, -0.04412255f, 0.00663182f, -0.02976950f, -0.00851337f, -0.04373045f, -0.00485807f, -0.00181472f, 
    -0.04753625f, 0.00919079f, -0.01892384f, -0.05531167f, -0.05433834f, 0.02346458f, 0.04405447f, -0.02233141f, 
    0.01469497f, -0.03276169f, -0.02675491f, 0.00868162f, -0.03049469f, -0.00494205f, -0.02072988f, -0.01864526f, 
    0.01999267f, 0.03305225f, -0.04136536f, -0.04508955f, -0.02323274f, -0.04186551f, 0.02087554f, -0.03209459f, 
    -0.04950912f, 0.02502763f, -0.03015374f, -0.05184159f, -0.02744357f, 0.01164175f, -0.02998403f, 0.03808961f, 
    0.00635979f, -0.03965326f, -0.01238666f, -0.04756338f, 0.02691802f, 0.00798043f, 0.02716126f, -0.04443432f, 
    0.02779543f, 0.01173401f, -0.05574827f, -0.03136308f, -0.02582432f, -0.01167010f, -0.01390396f, -0.02964710f, 
    0.03142616f, -0.03077089f, 0.00947139f, -0.05743490f, -0.01162735f, -0.01050190f, -0.03169321f, 0.04483353f, 
    -0.00568971f, -0.01357247f, 0.03494541f, -0.04616281f, -0.00370920f, -0.00075372f, -0.00733018f, -0.04544884f, 
    -0.00387382f, -0.00350801f, 0.02210078f, -0.04184573f, 0.01390752f, -0.02221182f, -0.05232833f, 0.00404967f, 
    0.00078899f, -0.02299164f, 0.03086799f, -0.01737469f, -0.05051973f, -0.03147932f, -0.05099442f, -0.00020615f, 
    -0.05491770f, 0.01689369f, 0.01954314f, 0.00394626f, -0.05041414f, 0.03583332f, 0.02166977f, -0.01722055f, 
    0.00744537f, 0.03112078f, -0.04769477f, 0.04359704f, -0.05322645f, -0.00285918f, -0.01041119f, -0.05485177f, 
    -0.01055272f, 0.03059695f, -0.01761826f, 0.00110857f, -0.05458195f, -0.04994274f, 0.02575662f, -0.01150231f, 
    -0.04550767f, -0.03228096f, 0.00845430f, -0.04808904f, -0.02993173f, 0.03108075f, -0.05590238f, -0.00500400f, 
    0.02849335f, 0.02492230f, 0.00575860f, -0.01819989f, -0.00600902f, 0.00840151f, 0.03963595f, -0.02925939f, 
    0.00822826f, 0.02908200f, 0.04173798f, 0.01374336f, -0.05797462f, -0.00379134f, 0.02708762f, -0.05373175f, 
    -0.04480672f, -0.06035793f, -0.01414340f, 0.01302810f, -0.01463412f, 0.03539705f, 0.00757917f, -0.00857939f, 
    -0.00829211f, -0.05440280f, 0.03540376f, 0.00088577f, 0.00066074f, 0.04516846f, -0.00984638f, 0.02527200f, 
    -0.01914897f, -0.00151582f, 0.00097216f, -0.00513253f, -0.03534549f, 0.04201657f, -0.05352375f, -0.04553084f, 
    0.03344942f, -0.02328702f, -0.03903828f, 0.01789548f, 0.00841668f, 0.01174363f, 0.02053798f, 0.03883446f, 
    -0.03123746f, 0.02651031f, 0.03089484f, 0.03465625f, -0.04878801f, 0.04211735f, 0.01209854f, 0.03626432f, 
    0.04000872f, -0.04428781f, -0.05109867f, 0.02293007f, 0.03438402f, -0.02822221f, 0.01757226f, -0.01857065f, 
    -0.05562963f, 0.00286306f, 0.03608076f, 0.00451359f, 0.00041432f, 0.02017980f, 0.01907406f, -0.01240537f, 
    0.01263163f, 0.01247345f, 0.04105598f, -0.05261692f, -0.04892435f, 0.03273921f, -0.00026653f, -0.05026923f, 
    -0.02007856f, 0.03328649f, -0.04854408f, 0.02572327f, 0.01495256f, 0.04411109f, -0.00869405f, -0.01744765f, 
    -0.04150748f, 0.01103709f, -0.04271391f, -0.04940993f, 0.04326804f, 0.02595692f, -0.03100673f, -0.04350793f, 
    0.04413383f, -0.00364515f, -0.03253401f, 0.04016419f, 0.03807729f, 0.03166527f, 0.00316658f, -0.01400138f, 
    0.02686344f, 0.00113436f, -0.02374450f, 0.03350506f, -0.01877954f, -0.04098850f, -0.01039699f, -0.04111597f, 
    -0.04177525f, -0.02037549f, 0.01272793f, -0.03462319f, -0.02560572f, -0.01837918f, -0.05418228f, -0.01347690f, 
    -0.03316777f, 0.01334672f, 0.01118766f, -0.03325696f, -0.01018390f, 0.02103101f, 0.01999032f, 0.02170031f, 
    0.01651887f, -0.03007118f, 0.01529877f, -0.04506038f, 0.01002011f, 0.02297780f, 0.00300710f, -0.04519968f, 
    -0.05771387f, 0.04128117f, 0.00926598f, -0.01583377f, 0.02671213f, -0.03417245f, -0.01958294f, 0.03271532f, 
    -0.04363696f, -0.00402861f, 0.01412839f, -0.05131693f, 0.00968626f, 0.00507282f, -0.05550119f, 0.01430206f, 
    0.02064334f, -0.00874713f, 0.03066765f, 0.03826117f, -0.02022318f, -0.01650136f, -0.01835124f, -0.05071854f, 
    0.03668368f, 0.02203810f, -0.03571691f, 0.00102934f, 0.01502298f, -0.02653003f, -0.04636393f, 0.02321806f, 
    -0.02504707f, 0.02535685f, 0.03592826f, -0.04165303f, -0.04572356f, 0.02500920f, -0.00688263f, 0.00617969f, 
    0.02372203f, -0.05267103f, -0.02413020f, -0.03219500f, -0.01632480f, -0.00858526f, -0.04510457f, -0.01721191f, 
    0.00342372f, 0.00042970f, 0.02965911f, 0.02474037f, -0.03954102f, -0.05178953f, -0.04487264f, 0.03697963f, 
    0.01845098f, -0.04368376f, -0.04461718f, 0.01420614f, -0.02073173f, -0.04248475f, 0.01861382f, -0.05595001f, 
    -0.05538249f, 0.00649285f, -0.05075585f, -0.01808416f, -0.05351590f, 0.00401690f, 0.00705102f, 0.04159550f, 
    -0.03088612f, 0.03596040f, 0.02655998f, 0.02979489f, -0.00078977f, -0.03289742f, 0.00996714f, 0.00773576f, 
    -0.00208239f, 0.00169185f, 0.00275888f, -0.03098919f, 0.02634887f, 0.00998094f, 0.02997351f, -0.04563392f, 
    -0.01683413f, 0.01765746f, 0.03525764f, 0.00615689f, -0.05452823f, -0.01611988f, 0.04126324f, -0.05664879f, 
    -0.03176289f, -0.03382076f, 0.00764848f, 0.03563726f, 0.04182491f, -0.05122518f, -0.03211344f, -0.04748502f, 
    -0.02528766f, -0.00981071f, 0.00679273f, 0.00638708f, -0.03856717f, 0.04045440f, 0.02972002f, 0.01995092f, 
    0.00305275f, -0.04789317f, 0.02183503f, 0.02340153f, 0.00968135f, 0.03352730f, -0.01620115f, -0.03645590f, 
    -0.00850334f, -0.02943740f, -0.05699940f, 0.00927567f, 0.02507605f, 0.04126485f, -0.01682237f, 0.02257065f, 
    0.11452390f, -0.05340745f, 0.12452320f, 0.06956986f, 0.10533878f, -0.00170283f, 0.05955487f, -0.01863125f, 
    -0.05096615f, 0.15274803f, 0.02824716f, 0.07351968f, -0.22558881f, -0.17066851f, -0.08730446f, 0.06120786f, 
    0.14018476f, 0.03819482f, 0.08938264f, 0.14424969f, 0.00802523f, 0.06351920f, 0.10700028f, 0.11962832f, 
    0.07003105f, -0.13344158f, -0.10445431f, 0.16574270f, -0.04945819f, 0.19853261f, 0.19277225f, 0.09960780f, 
    0.03277116f, 0.04119806f, -0.01691768f, 0.00383970f, 0.09417199f, 0.13279307f, 0.05597583f, 0.10389853f, 
    0.04825721f, -0.07183839f, -0.04440759f, 0.03491888f, 0.08036850f, 0.04770126f, -0.04284846f, 0.03536902f, 
    -0.50981629f, -0.30527523f, 0.24434207f, -0.13814636f, 0.04886265f, 0.06899150f, -0.11343720f, -0.03829449f, 
    0.06184335f, 0.02311959f, -0.07097180f, 0.11484776f, 0.13375047f, -0.16046865f, -0.23923407f, 0.11225548f, 
    0.02474558f, -0.03289612f, -0.01968130f, -0.14168096f, 0.01401612f, -0.08213870f, 0.08894143f, 0.09695842f, 
    0.26583472f, -0.22951563f, -0.25892144f, -0.16850737f, -0.00346225f, 0.09062476f, 0.00953923f, -0.05942770f, 
    0.04116063f, -0.00851201f, 0.01275986f, -0.08492487f, 0.10384010f, 0.18774103f, 0.12648895f, 0.01552317f, 
    -0.05043638f, 0.00719394f, 0.00280847f, -0.00221670f, -0.10212051f, -0.07240526f, -0.01009692f, -0.08675729f, 
    0.16708793f, 0.44629356f, -0.20450366f, -0.28403997f, 0.08187231f, -0.07909209f, 0.06891039f, -0.05811028f, 
    0.04548657f, 0.03354841f, 0.05907917f, -0.03411740f, 0.10271577f, 0.13529564f, -0.01110769f, -0.00629001f, 
    0.06300090f, 0.04005826f, -0.03537480f, 0.00039236f, 0.04600884f, -0.00533876f, -0.01698140f, 0.00291819f, 
    0.21456133f, -0.00609889f, -0.04956710f, 0.09191553f, -0.01061858f, 0.04842537f, -0.10205436f, -0.09702295f, 
    -0.10731892f, -0.20648590f, 0.03612864f, -0.00301030f, -0.05236508f, 0.02234324f, -0.02455858f, 0.14745079f, 
    0.02526628f, 0.01674590f, 0.08806174f, 0.10611892f, -0.01575754f, -0.00804384f, 0.05808569f, -0.04548511f, 
    0.07534574f, 0.04463026f, 0.02305732f, -0.07912666f, 0.00213733f, 0.00588133f, -0.01204260f, -0.03108384f, 
    0.00504235f, -0.01791600f, 0.00656351f, -0.07526765f, 0.08964802f, 0.03686738f, -0.14219536f, 0.02551223f, 
    0.02333753f, -0.05340921f, 0.05180580f, -0.00366872f, 0.04499269f, -0.10970719f, -0.05633584f, 0.02345406f, 
    0.18650736f, 0.11902945f, -0.07221861f, -0.25924560f, -0.11547899f, 0.08540912f, 0.03760445f, -0.10390959f, 
    0.11253649f, 0.06550323f, 0.06471000f, -0.00407258f, 0.53191489f, 0.19441542f, 0.09712575f, -0.19768362f, 
    -0.05006976f, -0.16898379f, -0.12132379f, -0.04269633f, 0.00356711f, 0.01212917f, 0.09264054f, -0.09231614f, 
    -0.01263193f, -0.00696168f, 0.25165999f, -0.14938162f, -0.07292543f, -0.11355232f, -0.10728085f, 0.02061489f, 
    -0.06745092f, -0.07462781f, 0.01995820f, 0.03284497f, 0.06816313f, 0.20273645f, 0.13820121f, 0.15056689f, 
    -0.06852594f, -0.04316078f, -0.07212988f, -0.04281134f, -0.07842109f, 0.04543612f, 0.00340668f, 0.09664544f, 
    -0.03105843f, 0.00830934f, -0.01932758f, -0.08936445f, 0.04874049f, 0.00064803f, -0.01624684f, -0.05934357f, 
    0.05350438f, -0.02200072f, 0.03123821f, 0.09544092f, 0.10286710f, 0.03691256f, -0.05637054f, 0.27772158f, 
    -0.10333913f, -0.11367624f, 0.12140301f, -0.02728730f, -0.00872339f, 0.02478431f, 0.02316326f, 0.08726915f, 
    0.19853975f, 0.14636195f, 0.04437242f, 0.00401287f, -0.00047419f, -0.09834328f, -0.08223564f, 0.09474992f, 
    -0.08833662f, 0.01560191f, 0.03418896f, 0.10715999f, 0.05744961f, -0.04143900f, 0.08709209f, -0.05108017f, 
    -0.01699782f, 0.02043363f, -0.02899581f, -0.05910484f, -0.00200932f, -0.04575396f, 0.06046987f, 0.04479949f, 
    -0.02764739f, 0.07330126f, 0.14316511f, 0.02537699f, -0.01678917f, -0.03758931f, -0.15499234f, 0.03274334f, 
    -0.08449282f, 0.00792191f, -0.04087579f, 0.12237311f, 0.13628410f, 0.18393321f, 0.16716595f, 0.08464437f, 
    -0.02034129f, -0.10802113f, -0.02317062f, -0.09180846f, -0.01690509f, -0.04457201f, -0.10514873f, -0.04006865f, 
    0.14235376f, 0.05747457f, 0.01824632f, 0.18647398f, -0.00916390f, 0.04573774f, -0.01448976f, 0.12292490f, 
    -0.03451995f, -0.04121766f, -0.00122882f, 0.11301071f, -0.02695996f, 0.06612695f, 0.01719532f, -0.09443539f, 
    0.12386752f, 0.05177295f, 0.02292439f, -0.00252377f, 0.01810559f, 0.13367240f, 0.05944743f, 0.10993581f, 
    -0.06373378f, -0.06404853f, -0.00375476f, 0.09244357f, 0.13364898f, 0.07074301f, -0.00292611f, 0.09252136f, 
    -0.03952691f, 0.02088116f, 0.03897471f, -0.15411843f, -0.05434193f, 0.12418143f, 0.15788420f, -0.04541521f, 
    -0.05192164f, -0.03969881f, 0.00662982f, -0.07548889f, 0.00284293f, -0.03191654f, -0.06805317f, 0.03590048f, 
    -0.08362950f, 0.06728176f, -0.05251605f, 0.07855235f, -0.01179212f, -0.00102560f, 0.05972772f, -0.11209220f, 
    0.02158950f, 0.05490095f, -0.00267859f, 0.07697049f, -0.21954976f, -0.02785679f, 0.07808854f, 0.14462559f, 
    0.04569613f, -0.00851932f, 0.03533899f, 0.21652444f, -0.05619559f, 0.03953567f, 0.04863374f, -0.01048169f, 
    0.24465957f, -0.00772670f, 0.09292077f, 0.04464733f, -0.03620224f, 0.12028471f, 0.02749601f, 0.05972297f, 
    0.14251406f, -0.08423960f, 0.17534687f, -0.00919091f, 0.08556096f, -0.02571639f, 0.13256367f, -0.26713017f, 
    0.02687619f, -0.01795141f, -0.06451353f, -0.05882610f, -0.00012571f, -0.01121570f, 0.15119641f, 0.00971661f, 
    -0.15359645f, 0.24376188f, 0.33644399f, 0.19471136f, -0.00816633f, -0.05245571f, 0.06355347f, -0.16453323f, 
    0.01599916f, 0.08264812f, -0.01308027f, 0.16747764f, -0.00759149f, -0.02160108f, 0.02483908f, 0.15190111f, 
    -0.00366029f, 0.01569834f, -0.08387041f, -0.03012181f, -0.03134418f, 0.01175586f, 0.04380643f, -0.00124549f, 
    0.05304662f, -0.21829948f, 0.10864583f, 0.08759248f, 0.13152902f, -0.07617932f, 0.01905996f, 0.19209665f, 
    0.00236952f, 0.05705051f, 0.03443896f, -0.04306562f, 0.27625725f, 0.14978382f, 0.16265503f, -0.09694931f, 
    0.01551772f, -0.06792887f, -0.01782185f, 0.03429049f, 0.03838862f, -0.00368680f, -0.00680073f, -0.06535851f, 
    -0.29390183f, 0.19708967f, -0.10262485f, 0.00476227f, -0.05481018f, 0.09263587f, 0.04423501f, -0.16298223f, 
    0.12898029f, -0.03262024f, 0.04493511f, 0.22879437f, 0.03302433f, -0.14086460f, 0.19919808f, -0.02710157f, 
    -0.13846786f, 0.05741381f, -0.03022848f, 0.03621794f, 0.01681711f, -0.01852628f, 0.01332056f, -0.10899001f, 
    0.48069730f, 0.01975835f, 0.30013394f, 0.19096899f, -0.05537211f, -0.10554752f, 0.04468424f, 0.06463322f, 
    0.08854316f, 0.04521856f, 0.01272970f, 0.12872103f, 0.05868795f, 0.13296582f, 0.13638140f, 0.04313925f, 
    0.03751739f, -0.01558174f, -0.08461672f, 0.07407954f, 0.10914186f, 0.06600990f, 0.00112874f, -0.02440927f, 
    0.25222686f, 0.06683755f, -0.31975925f, -0.01634234f, -0.18734854f, 0.09743602f, -0.01772780f, -0.02340658f, 
    -0.03315766f, -0.01277932f, -0.02757442f, 0.10136156f, -0.27049330f, -0.16851993f, -0.04525749f, 0.22100501f, 
    -0.16711630f, -0.03034108f, -0.08307980f, 0.02189463f, -0.00040257f, 0.00677345f, -0.03276226f, -0.00744131f, 
    0.04166395f, 0.08349355f, -0.00642273f, -0.06153946f, 0.06507083f, -0.02293070f, -0.04636824f, 0.06522490f, 
    0.18149252f, 0.09988223f, 0.16695796f, -0.01037513f, -0.22594579f, -0.00433283f, 0.01053589f, 0.16702294f, 
    -0.01874999f, 0.06212310f, 0.09059761f, 0.01384568f, 0.04524959f, 0.05495287f, 0.03955000f, 0.12751111f, 
    -0.18261522f, -0.00856379f, 0.01996276f, -0.28141984f, -0.03557223f, 0.00534995f, -0.02771911f, -0.03562231f, 
    -0.11051293f, -0.09252308f, 0.03200918f, 0.03848569f, -0.32205153f, 0.13416630f, 0.03095879f, 0.24457029f, 
    -0.05014083f, -0.16786094f, -0.00063617f, 0.11040442f, 0.01268594f, -0.07038105f, -0.13843246f, -0.02019441f, 
    0.67776579f, 0.30523407f, -0.08577304f, 0.04380601f, -0.21756424f, 0.06490473f, -0.05444182f, 0.07245596f, 
    -0.07109293f, -0.02360650f, 0.02206186f, 0.01738173f, 0.06435969f, 0.17530343f, 0.11624259f, 0.00934928f, 
    -0.06064995f, -0.17484292f, -0.09851006f, 0.02152378f, 0.10981511f, 0.03285514f, 0.07489486f, -0.02375328f, 
    -0.20588015f, 0.14508435f, -0.01805240f, 0.03425091f, -0.02693822f, -0.01018240f, 0.08370152f, -0.01792302f, 
    0.10613922f, -0.00369128f, 0.06160412f, -0.00376735f, 0.07733598f, -0.01769610f, -0.00686424f, -0.17320481f, 
    -0.08962751f, -0.04641406f, 0.00944263f, 0.01019948f, 0.11295277f, -0.04566529f, -0.07318469f, 0.00229823f, 
    -0.01046180f, -0.09643418f, -0.00107729f, -0.17906840f, -0.02170754f, -0.05012067f, -0.02519255f, -0.04814159f, 
    -0.09128559f, -0.04056304f, -0.06018175f, 0.10849656f, -0.16888489f, -0.13845992f, 0.27987042f, -0.01581388f, 
    0.15951785f, -0.07520173f, 0.08911211f, 0.16534024f, 0.06536398f, 0.02735254f, 0.07110736f, 0.02674857f, 
    -0.39301944f, 0.09148807f, -0.10678853f, 0.23280126f, 0.04231461f, 0.04534232f, 0.04025187f, -0.00197939f, 
    0.02493425f, -0.06277171f, -0.04733729f, -0.03185868f, 0.20652729f, 0.07561504f, -0.06952428f, 0.07475613f, 
    -0.03557694f, 0.11959799f, -0.03348156f, -0.03012721f, -0.01667553f, -0.07679132f, -0.07231638f, 0.03467702f, 
    -0.40660831f, 0.10784604f, 0.17894000f, 0.03570998f, 0.10457190f, -0.16577582f, -0.07447842f, -0.02702197f, 
    0.07302711f, -0.14559391f, 0.01886453f, -0.03065527f, -0.04410855f, -0.01302799f, 0.05722230f, -0.10163870f, 
    -0.10278801f, -0.20921721f, 0.00002424f, 0.02397842f, 0.03667383f, 0.02406554f, 0.02661422f, 0.07081990f, 
    -0.26037571f, -0.07696183f, 0.16510236f, 0.16289510f, 0.00843505f, 0.15870224f, 0.02252125f, -0.01843486f, 
    0.07797436f, 0.05270464f, 0.08659456f, -0.12822098f, 0.21314679f, 0.04376953f, -0.04557931f, 0.01976593f, 
    -0.07996870f, 0.00912711f, 0.05136215f, -0.06553717f, 0.04074964f, 0.11031008f, -0.04669923f, 0.07551818f, 
    -0.15193486f, 0.05398736f, 0.00797786f, 0.22339621f, -0.08487795f, -0.00636415f, 0.14881615f, -0.00034032f, 
    0.08836636f, -0.01950094f, 0.04132796f, -0.05656546f, -0.08877831f, -0.06419723f, 0.03910746f, -0.04408577f, 
    0.07955182f, 0.03019944f, -0.01047334f, -0.04574944f, 0.10891361f, 0.09576886f, 0.00249789f, -0.04406772f, 
    -0.22173144f, -0.03338841f, -0.07631497f, -0.08535809f, -0.02317409f, 0.02097704f, -0.02075278f, -0.09905834f, 
    0.08734137f, -0.05438120f, -0.00656955f, -0.09204013f, -0.13053702f, 0.12717588f, -0.01867212f, 0.26110652f, 
    -0.04772716f, 0.03712197f, 0.08643546f, -0.00371808f, 0.07894193f, -0.00610186f, 0.02847142f, 0.00531200f, 
    -0.22357079f, -0.25090316f, 0.42884037f, 0.01623717f, -0.03297343f, 0.06411008f, -0.10883941f, 0.11526231f, 
    -0.08075892f, 0.10975838f, -0.05820530f, -0.12521714f, 0.24279760f, 0.00398984f, 0.09733160f, -0.11680262f, 
    -0.05316947f, -0.10747316f, 0.01114572f, 0.05859232f, 0.01502316f, 0.10408446f, 0.00349447f, -0.09354463f, 
    0.23862931f, -0.08904636f, 0.15925121f, -0.35887024f, 0.03640519f, -0.09704310f, -0.04201854f, -0.00945381f, 
    -0.10773522f, 0.06102612f, 0.11824123f, -0.05963551f, -0.03814086f, 0.14252959f, 0.04681380f, 0.15768699f, 
    0.04863857f, 0.00022344f, -0.10184463f, 0.11535288f, 0.01320706f, -0.07692683f, -0.03855770f, 0.00151820f, 
    0.12976333f, -0.13658081f, 0.16768198f, 0.19526663f, -0.09376223f, 0.04053270f, 0.08427976f, 0.05326813f, 
    0.02174650f, 0.10244903f, -0.02550360f, -0.02526526f, 0.11638323f, -0.10959098f, 0.01680957f, 0.05956390f, 
    0.07758006f, 0.08013728f, -0.03077596f, 0.04637721f, -0.01830369f, 0.03154617f, -0.17533447f, -0.28740209f, 
    -0.42168999f, -0.01406534f, 0.40783718f, -0.27015460f, 0.22986089f, 0.01070713f, -0.05374246f, -0.01651889f, 
    0.13723581f, 0.09542183f, 0.04614433f, 0.04958815f, 0.27657074f, -0.46495011f, 0.13349418f, 0.15176685f, 
    0.02607099f, -0.08144422f, -0.05905088f, -0.03800436f, 0.01549488f, -0.03337242f, -0.01370532f, 0.08004048f, 
    0.25740424f, 0.10021956f, 0.03016189f, -0.05304166f, -0.01186740f, -0.04490396f, -0.01939690f, -0.14332458f, 
    -0.00727524f, -0.09500811f, -0.00438114f, 0.02886344f, -0.04183906f, -0.14608440f, 0.07222813f, 0.09662345f, 
    -0.06000506f, -0.09566218f, 0.01088173f, 0.05070149f, -0.00947328f, 0.15091139f, 0.02207088f, 0.10809577f, 
    -0.18952285f, -0.18654996f, -0.27803537f, 0.12602171f, 0.19976398f, -0.10704600f, 0.08056980f, -0.20809646f, 
    0.06825368f, 0.06548857f, 0.04614295f, -0.02992975f, 0.02168294f, 0.00395380f, 0.10044465f, 0.09050188f, 
    -0.02454275f, 0.07033981f, 0.01083053f, -0.02130581f, 0.01121419f, 0.01703735f, 0.09413508f, 0.10836227f, 
    0.11405100f, -0.26145861f, 0.07169493f, -0.03776135f, 0.02510538f, 0.01616209f, -0.04667573f, -0.05173939f, 
    0.04846548f, 0.04509151f, -0.08233220f, 0.31067190f, 0.21317422f, 0.12187853f, 0.00764628f, -0.07451545f, 
    -0.04635130f, -0.18796559f, 0.16417058f, 0.10328301f, 0.00513785f, -0.04524931f, -0.06000655f, -0.11765230f, 
    0.21556641f, -0.16010505f, 0.01945738f, -0.01272421f, 0.02830613f, -0.08906588f, -0.01467256f, -0.04516609f, 
    0.10225745f, -0.05895152f, -0.06331321f, -0.05077141f, 0.05717491f, 0.05042228f, 0.13457707f, -0.03863512f, 
    -0.02086374f, -0.04904730f, -0.03107747f, 0.07717861f, 0.02473742f, -0.08888848f, -0.05940209f, 0.03367960f, 
    -0.43440670f, 0.08534610f, -0.23777422f, -0.14748603f, 0.08992781f, -0.05827203f, 0.05626497f, -0.08282502f, 
    0.05171738f, 0.02365992f, -0.04133703f, 0.05684090f, 0.40131742f, 0.06193299f, -0.08864138f, -0.05165896f, 
    0.09651108f, 0.03722862f, -0.05684492f, -0.04106450f, 0.00255051f, -0.04095395f, -0.06659507f, -0.06718858f, 
    0.17475472f, 0.03473017f, -0.15263721f, 0.04016624f, 0.03047792f, 0.02179011f, -0.10188431f, 0.06551056f, 
    0.03784723f, -0.05054579f, 0.05286695f, 0.04154701f, 0.01974447f, 0.00463536f, 0.05743510f, 0.29872763f, 
    0.01871173f, 0.03182973f, 0.00057254f, -0.02612815f, 0.11853615f, 0.04263140f, 0.02391372f, 0.05950318f, 
    0.06794161f, 0.07940318f, -0.03330784f, 0.04957698f, 0.12800775f, -0.00417168f, -0.01695239f, -0.04585996f, 
    0.04999345f, -0.14300554f, -0.14341684f, -0.01153176f, 0.12077907f, -0.04099497f, 0.18526107f, 0.03094142f, 
    -0.07567529f, -0.12205859f, 0.04024528f, -0.01312621f, 0.03882249f, -0.01302013f, -0.08759096f, -0.03679693f, 
    0.40135404f, 0.41808042f, -0.24677609f, 0.12214321f, -0.00898947f, 0.03092618f, -0.04140133f, 0.02425976f, 
    0.02983954f, -0.08489455f, 0.02440184f, -0.05940063f, 0.10553657f, 0.03521838f, -0.03816867f, 0.15272553f, 
    -0.15088221f, -0.07312123f, -0.13869978f, -0.14205568f, -0.03457173f, 0.06947306f, -0.01948454f, -0.10548249f, 
    0.32245058f, 0.17410757f, -0.12081227f, 0.13850546f, -0.06332132f, 0.12371322f, 0.08232253f, 0.12743731f, 
    -0.06650728f, -0.05735107f, -0.08630465f, -0.06163933f, 0.12504856f, -0.01057535f, -0.09763316f, 0.13321833f, 
    0.05813600f, 0.00957099f, 0.11212634f, -0.01746241f, 0.05978869f, 0.04224953f, -0.00806411f, 0.01410968f, 
    0.26512209f, 0.26387984f, 0.19785708f, 0.24799134f, -0.01822511f, -0.01218714f, 0.08730771f, 0.14913957f, 
    0.08654512f, 0.08203908f, 0.04156737f, 0.07090621f, -0.08546545f, 0.12881745f, 0.12991007f, 0.00177072f, 
    0.13759752f, -0.00071110f, -0.10878421f, -0.05370421f, -0.03706488f, -0.11942200f, 0.04627252f, 0.00808340f, 
    0.15751684f, 0.12513195f, 0.11545391f, 0.05850099f, 0.02782946f, -0.04118852f, 0.03806832f, 0.09515263f, 
    0.04476262f, 0.10717067f, 0.06554709f, 0.04667879f, -0.02207252f, -0.15125416f, -0.10680183f, 0.04303413f, 
    0.04126291f, -0.00976999f, 0.01698947f, -0.08338561f, 0.01850278f, -0.10688291f, -0.15965658f, -0.13147730f, 
    -0.09696700f, -0.11106401f, 0.06481906f, 0.19147818f, 0.15025903f, 0.03075976f, 0.04592986f, -0.06672944f, 
    0.00414118f, 0.10061069f, 0.03178972f, 0.21228623f, -0.01314998f, 0.14306943f, 0.06554875f, 0.16023982f, 
    -0.02640581f, -0.06215738f, 0.04954463f, 0.12767380f, 0.00581747f, -0.01983622f, 0.09618754f, 0.03320608f, 
    -0.20618497f, -0.48564869f, -0.25581750f, 0.01862323f, -0.00695940f, 0.15561853f, -0.03584068f, -0.04324843f, 
    0.10914171f, 0.00294659f, -0.01584452f, -0.02760624f, -0.13336150f, -0.18656908f, 0.14747354f, -0.04312477f, 
    0.05533595f, 0.03072578f, -0.05318059f, -0.09683347f, -0.00848651f, -0.19444658f, 0.10986894f, -0.05940330f, 
    -0.01998134f, -0.08863591f, 0.15333585f, 0.04123456f, 0.04308616f, -0.17528749f, 0.10257803f, -0.08983973f, 
    0.00877532f, -0.00884181f, 0.27488878f, -0.00560090f, -0.02828543f, 0.16257361f, 0.02965208f, 0.02893112f, 
    -0.11256263f, -0.17002301f, -0.03400942f, 0.09042431f, -0.08253060f, -0.02046487f, -0.11387632f, -0.31867394f, 
    0.17281416f, -0.07701147f, 0.09559204f, -0.13266550f, -0.07111275f, 0.05810665f, 0.09928246f, 0.17182010f, 
    0.12469713f, 0.12386592f, 0.06009715f, 0.00639552f, 0.09276854f, 0.05465304f, 0.15149191f, -0.16455682f, 
    0.14432324f, -0.05612964f, -0.23229243f, -0.05828315f, -0.18859543f, 0.05280386f, -0.11334404f, -0.35230339f, 
    0.12818564f, 0.17695539f, 0.13511682f, 0.09661908f, 0.03935087f, 0.07159998f, 0.06608164f, -0.13745634f, 
    0.07249679f, 0.12721136f, 0.09304225f, 0.05996034f, 0.16301653f, -0.20228407f, 0.19865732f, 0.01305617f, 
    -0.08210843f, -0.02724285f, 0.06992462f, -0.06481597f, 0.00930549f, -0.11712329f, -0.00519724f, 0.04015036f, 
    0.53252745f, 0.01487589f, 0.16586660f, 0.13326310f, -0.06146852f, 0.09978055f, 0.01155159f, -0.10829339f, 
    0.00453923f, 0.10178888f, 0.00241330f, 0.19107386f, -0.02162180f, -0.17627345f, 0.15790378f, 0.07368177f, 
    -0.06814648f, -0.00109492f, -0.03120379f, 0.11527403f, 0.24031307f, 0.27268329f, 0.14666761f, 0.24757032f, 
    0.19438298f, 0.07349417f, 0.07043461f, 0.00459277f, -0.15152180f, 0.07823227f, -0.07006884f, -0.18314424f, 
    0.00915539f, -0.04031942f, 0.10585790f, -0.03598993f, 0.04097779f, 0.02039958f, -0.01338785f, 0.07428716f, 
    0.03999228f, -0.06958812f, -0.03556503f, 0.05202121f, -0.05082299f, 0.07340796f, 0.18581091f, 0.07901127f, 
    -0.01880085f, 0.02179310f, -0.07048336f, 0.07546293f, -0.04250970f, -0.02755146f, 0.14599636f, 0.04483720f, 
    0.24852373f, 0.17890914f, 0.21593882f, 0.39502519f, 0.08965391f, -0.05617530f, -0.14836106f, -0.13504608f, 
    -0.05879441f, -0.18376254f, 0.11549275f, 0.06151842f, -0.11905064f, -0.28235114f, -0.29594305f, -0.10828920f, 
    0.02429521f, -0.27448303f, 0.06661221f, -0.20311807f, -0.04562926f, -0.00514764f, -0.00251063f, -0.18548360f, 
    -0.07509226f, -0.13844010f, -0.15152913f, 0.01488308f, -0.08398391f, -0.09240896f, 0.08234940f, -0.12164680f, 
    -0.08299474f, 0.14715847f, 0.10552470f, 0.12341954f, 0.05809006f, 0.07132143f, 0.09047351f, 0.20086448f, 
    0.02383755f, 0.26291713f, -0.09690718f, 0.06780916f, 0.02507428f, 0.02179344f, -0.07082951f, -0.04045327f, 
    0.01728687f, -0.02122228f, 0.10465456f, 0.16562326f, -0.19435231f, 0.08112533f, -0.07640962f, -0.01639721f, 
    0.04991492f, 0.05832913f, 0.07188654f, -0.12410971f, -0.03134719f, -0.14427052f, -0.01641418f, -0.11293594f, 
    -0.35057378f, 0.14640802f, -0.22087787f, 0.13105024f, 0.10842538f, 0.04069469f, -0.01233384f, -0.00839186f, 
    0.02381111f, 0.01351186f, 0.00876375f, -0.08220552f, 0.10914844f, 0.02867165f, 0.00063898f, -0.00718633f, 
    -0.15956186f, 0.05345833f, 0.00639081f, -0.08462963f, 0.05445866f, 0.03786307f, 0.06099207f, 0.09363116f, 
    -0.02818180f, -0.09858126f, -0.00788414f, -0.15064304f, 0.01239998f, -0.08111214f, 0.02677745f, -0.35568818f, 
    -0.09587888f, -0.21806227f, -0.16010751f, -0.12115888f, 0.02164448f, 0.06853717f, 0.26331502f, -0.07078232f, 
    0.12777838f, 0.08240006f, 0.02713951f, 0.15090285f, 0.00022252f, -0.05149543f, 0.04348757f, -0.10289824f, 
    0.01460659f, 0.41873986f, -0.25160664f, 0.11597967f, 0.03325278f, 0.10916034f, 0.11823527f, -0.04087944f, 
    0.04813277f, -0.13749307f, -0.09575578f, -0.12739506f, 0.38637197f, -0.10560757f, 0.20584670f, -0.11522518f, 
    -0.20000345f, 0.08681417f, -0.28711241f, -0.05108208f, 0.00741465f, 0.08132123f, -0.06241501f, 0.02148511f, 
    0.00175110f, 0.09115043f, -0.00932613f, 0.00010458f, -0.03458324f, 0.06571636f, 0.05898134f, -0.01910498f, 
    -0.04054521f, -0.25943947f, -0.17123316f, -0.19455151f, -0.07644099f, -0.04983157f, -0.07554486f, 0.01719048f, 
    0.15277140f, 0.01767600f, 0.02627437f, -0.07817620f, -0.04231472f, -0.04843332f, 0.04279056f, 0.02886896f, 
    0.16538514f, 0.05042812f, -0.00240154f, 0.02103634f, 0.06994503f, 0.00857411f, 0.07558419f, 0.37558964f, 
    0.21448739f, 0.15784481f, 0.04323452f, -0.03130145f, -0.03066480f, 0.06930473f, -0.01187375f, -0.04507682f, 
    0.03066324f, -0.04176448f, -0.15051407f, -0.17710622f, -0.22164637f, 0.00883948f, -0.17778596f, -0.13779153f, 
    0.10726507f, 0.16505709f, -0.06729285f, 0.00355417f, -0.01098235f, 0.11966605f, 0.10346622f, 0.07386956f, 
    0.09530392f, 0.14044680f, 0.04548641f, 0.16696163f, -0.16223282f, -0.10470883f, -0.07761747f, -0.05163498f, 
    0.03156368f, -0.00653923f, -0.06654977f, -0.02938054f, -0.20265475f, -0.16967751f, -0.09095956f, -0.30460632f, 
    0.07493054f, 0.05067056f, 0.01780327f, 0.11402142f, 0.09148193f, 0.08834045f, 0.10202971f, -0.08087754f, 
    0.06085225f, 0.21644731f, 0.14638358f, 0.25851405f, 0.07947171f, 0.09510060f, -0.12149692f, 0.11966711f, 
    -0.08014742f, -0.03213654f, -0.00343695f, 0.10787379f, 0.02005096f, 0.04924750f, 0.12965822f, -0.07656125f, 
    0.15771744f, -0.21357487f, 0.00216941f, -0.06760804f, 0.04842083f, 0.16627713f, -0.04445952f, 0.14188966f, 
    0.00234274f, -0.03326263f, 0.08746433f, 0.06297797f, 0.13968441f, -0.09374213f, 0.06150733f, 0.03187345f, 
    -0.09532660f, 0.05102693f, -0.10715043f, -0.11132802f, 0.08214035f, -0.08650573f, 0.14677365f, 0.00795748f, 
    0.21799408f, 0.10517082f, 0.16790356f, -0.34883764f, -0.09807361f, 0.01061572f, -0.05550144f, 0.02320303f, 
    0.00472263f, 0.04022538f, -0.18300223f, -0.04396534f, 0.07844332f, 0.02251552f, -0.12401422f, -0.03239525f, 
    0.14452390f, 0.26752764f, 0.03025493f, 0.06668613f, 0.11637501f, -0.12028512f, 0.02590194f, 0.07223475f, 
    0.02610188f, -0.00016385f, -0.06470543f, 0.05240681f, 0.15674929f, 0.13945462f, 0.02112076f, -0.04191110f, 
    -0.03309999f, -0.06735464f, 0.02588594f, 0.13482977f, -0.02308268f, -0.06593515f, -0.07469159f, 0.23264816f, 
    -0.19101250f, -0.03061320f, 0.09550495f, -0.08300814f, 0.09207834f, -0.10205147f, 0.01231880f, 0.30769783f, 
    -0.21951455f, 0.22109194f, 0.07988388f, -0.19389990f, 0.00041751f, -0.07196651f, -0.09693412f, -0.18968089f, 
    -0.00935427f, 0.04211680f, 0.04874072f, 0.13414970f, 0.12890977f, 0.16078694f, 0.31692588f, 0.14506128f, 
    0.10099455f, -0.08317012f, -0.14438739f, 0.09074900f, -0.03382606f, 0.02366297f, 0.07965077f, 0.05221368f, 
    0.06018645f, 0.01540958f, 0.23396651f, -0.00615025f, 0.16777185f, -0.11011250f, -0.10032938f, -0.09983798f, 
    -0.00079900f, 0.06737748f, 0.04513333f, 0.04093547f, -0.13108294f, 0.03371121f, -0.02363495f, 0.02935608f, 
    -0.08462457f, 0.08149626f, -0.00248601f, 0.01125126f, -0.07574976f, -0.12782793f, -0.06514680f, -0.08863366f, 
    -0.27791473f, 0.14713377f, 0.17496458f, 0.14049441f, 0.01561195f, -0.03860240f, -0.06093426f, 0.08929973f, 
    0.05972800f, -0.01478964f, -0.14613949f, -0.16202310f, 0.09028732f, 0.25704721f, 0.12344659f, 0.06354638f, 
    0.18477528f, 0.09665199f, 0.05682332f, 0.05201671f, 0.06142989f, -0.03177691f, -0.08521757f, -0.03519021f, 
    -0.02399088f, 0.06267831f, -0.05183051f, -0.12510413f, -0.03014992f, -0.00430094f, -0.10064096f, -0.05678507f, 
    -0.03215478f, 0.05020276f, 0.01506483f, -0.07174570f, 0.21009144f, 0.14284910f, -0.03255017f, 0.01996212f, 
    -0.07527237f, 0.18580574f, 0.02579583f, 0.03050210f, -0.02623239f, 0.10302681f, 0.06557786f, -0.03246785f, 
    -0.13450427f, 0.02200386f, 0.11306457f, -0.15023984f, -0.13116130f, 0.01761041f, -0.18488328f, -0.18430589f, 
    0.11360966f, 0.18697631f, 0.22182132f, 0.02413939f, 0.12409881f, 0.24652433f, -0.03199906f, -0.13578682f, 
    0.03715871f, -0.04552329f, 0.09767136f, 0.08766612f, 0.03776989f, 0.09667835f, 0.15642920f, -0.00848417f, 
    0.06056433f, 0.16485786f, 0.11605933f, 0.06370843f, 0.10287575f, 0.05643027f, -0.09474438f, 0.00211230f, 
    0.00821994f, -0.00550736f, 0.00228820f, 0.01267800f, -0.08944258f, -0.19318125f, 0.17318654f, -0.08794019f, 
    -0.11216521f, 0.01447470f, 0.01206596f, 0.17675637f, 0.03983065f, 0.02611756f, -0.19104779f, -0.23996460f, 
    -0.02367707f, -0.22831267f, 0.01875921f, 0.21613014f, -0.01881482f, 0.01648002f, 0.05528528f, 0.07398292f, 
    -0.01747733f, -0.07203417f, -0.18601319f, -0.01263964f, -0.09270816f, -0.11148948f, -0.03339369f, 0.34323761f, 
    -0.04669600f, 0.04552324f, -0.13720585f, -0.13659443f, -0.07511535f, -0.07800999f, 0.08212668f, -0.12909865f, 
    -0.13687177f, -0.11932211f, -0.15916286f, -0.01355183f, -0.09428691f, -0.06562565f, -0.20441246f, -0.06836794f, 
    0.09177832f, 0.33979848f, 0.01590909f, 0.07833914f, 0.07180572f, 0.14722976f, -0.13818733f, -0.08406576f, 
    0.04654681f, 0.11080301f, 0.12835138f, 0.30421129f, 0.06962563f, 0.05278547f, -0.00858370f, -0.00529442f, 
    -0.03561978f, -0.01784995f, 0.07486602f, -0.12695242f, 0.02633554f, -0.16214386f, 0.03323173f, 0.06935421f, 
    -0.04791024f, 0.14730021f, -0.08522353f, -0.01935047f, 0.09146574f, 0.08149982f, 0.10744286f, 0.02641213f, 
    -0.04340968f, 0.16249262f, -0.07350578f, -0.17032067f, -0.01731627f, -0.07163398f, 0.15391935f, 0.07393346f, 
    -0.20493387f, -0.18764976f, -0.16898730f, -0.06945061f, -0.07200027f, 0.04121826f, -0.11254788f, 0.13419707f, 
    0.06728397f, 0.17697406f, 0.09749298f, -0.08174047f, -0.21982168f, -0.20634438f, -0.04519086f, 0.13844289f, 
    -0.15776810f, -0.05279294f, -0.02873180f, 0.02285687f, 0.03578413f, -0.23351099f, -0.11637018f, -0.15751816f, 
    -0.00872318f, 0.07127210f, -0.16579616f, -0.00039240f, 0.13170755f, -0.08972289f, 0.12729104f, -0.02910866f, 
    -0.08534741f, 0.03288035f, 0.08546803f, -0.03704370f, -0.01255542f, 0.04598440f, 0.12129253f, 0.11384185f, 
    0.12882422f, -0.10400775f, 0.08572279f, 0.13479362f, 0.00360454f, -0.06932601f, 0.02195006f, 0.00947280f, 
    0.05758191f, 0.01857952f, 0.11025197f, 0.06231506f, 0.03245267f, -0.03981666f, -0.05956634f, 0.02578972f, 
    -0.01886035f, -0.01288066f, -0.04219249f, 0.00100553f, -0.22195096f, 0.03879082f, -0.05388337f, 0.16204976f, 
    -0.06728380f, 0.04078841f, 0.09219895f, -0.08577414f, 0.14222342f, -0.08659108f, -0.01714175f, 0.19531709f, 
    0.00557710f, 0.02259179f, 0.00039629f, 0.16134956f, -0.07592024f, -0.13377373f, -0.03033078f, -0.26540825f, 
    0.07375090f, -0.07477406f, 0.01565238f, -0.15949978f, 0.15423216f, 0.11489762f, 0.08440666f, 0.05949649f, 
    0.12972079f, 0.14067939f, 0.03630967f, 0.16432415f, -0.06147372f, 0.04033604f, -0.07354252f, 0.04751812f, 
    -0.18677285f, 0.16826211f, 0.18426953f, -0.23361222f, 0.00928184f, -0.08361913f, -0.14150198f, -0.02149164f, 
    0.12618113f, 0.06986535f, -0.11155920f, -0.06211639f, -0.01076049f, 0.22163157f, 0.06025911f, 0.10374560f, 
    -0.10041591f, 0.09985025f, 0.08743054f, -0.08628053f, 0.05855208f, 0.02087425f, -0.11813739f, -0.04584209f, 
    -0.33730841f, -0.01004190f, 0.05177285f, 0.08619508f, 0.06249727f, -0.00386781f, -0.13031860f, 0.04912372f, 
    0.08669867f, -0.14352305f, 0.06978218f, 0.13480793f, 0.19904524f, -0.04632039f, -0.02623214f, 0.03049535f, 
    -0.00087396f, 0.07290394f, -0.07833434f, -0.02184596f, 0.11027415f, -0.02098479f, -0.30235258f, -0.24229482f, 
    0.19985089f, 0.21205027f, 0.09997038f, -0.05487672f, 0.10176373f, -0.05021155f, -0.02286401f, -0.06647398f, 
    0.03040851f, 0.02173968f, -0.02825789f, 0.03100187f, 0.05279881f, 0.00577373f, 0.04979184f, -0.06816833f, 
    0.02781261f, -0.03384202f, -0.05652689f, -0.00342415f, 0.06611190f, -0.02310936f, -0.00185685f, -0.07958494f, 
    0.26206067f, 0.22553618f, -0.19619471f, 0.09604874f, 0.04360709f, 0.03247412f, 0.03575523f, 0.16185988f, 
    -0.03998256f, -0.02249787f, 0.09160640f, -0.19201271f, -0.11258577f, -0.10286479f, 0.07718756f, -0.16011715f, 
    -0.02927589f, 0.06468430f, 0.07618957f, 0.08105280f, -0.07282435f, 0.04354872f, -0.08415240f, 0.02417784f, 
    -0.28363895f, 0.07424729f, 0.05707468f, 0.19385698f, 0.02166538f, -0.00509016f, 0.04717302f, 0.08890490f, 
    0.09923792f, -0.02021370f, -0.02891091f, 0.12641793f, -0.00066382f, -0.02014514f, -0.11125181f, 0.26405388f, 
    0.09058877f, 0.07517999f, 0.06701282f, -0.03529020f, 0.12592493f, 0.26099908f, 0.03550689f, 0.08204509f, 
    0.43025440f, -0.49091434f, 0.19441061f, 0.16666918f, -0.28462583f, 0.00939624f, -0.15353999f, 0.00725564f, 
    -0.10033854f, 0.09182204f, 0.04496997f, 0.15409635f, -0.13615912f, -0.13421725f, 0.05766628f, -0.01515752f, 
    -0.04161307f, -0.03650417f, 0.06276822f, 0.04694624f, 0.01074079f, 0.02431494f, 0.05884014f, 0.16392674f, 
    -0.40210691f, -0.21499525f, -0.05492660f, -0.32746273f, -0.01454153f, 0.02800376f, 0.11362578f, 0.05017681f, 
    0.07180306f, 0.21876998f, -0.03932417f, 0.04212889f, 0.07284097f, -0.00767591f, 0.12905595f, 0.10370428f, 
    0.00673731f, 0.03641872f, -0.02663536f, -0.00084168f, 0.03756593f, -0.00351863f, -0.05756772f, 0.02522070f, 
    -0.17683996f, -0.36055085f, 0.00774270f, -0.08120335f, -0.02705339f, -0.10903319f, 0.08514187f, 0.04540344f, 
    0.12849295f, 0.00653735f, 0.05383785f, 0.17681426f, -0.02130977f, -0.08884880f, 0.08667802f, 0.05381542f, 
    0.01099730f, 0.01277328f, -0.04650702f, 0.02591240f, 0.00655608f, 0.00294219f, 0.06600965f, 0.13126560f, 
    0.11385516f, -0.09176057f, -0.15275984f, 0.14299712f, 0.01663722f, -0.12654451f, 0.01717138f, 0.15140074f, 
    -0.10534332f, 0.02890282f, -0.02118832f, 0.08567339f, -0.31447569f, 0.14910959f, 0.18159492f, 0.36585584f, 
    0.07327520f, 0.04457996f, -0.11133246f, 0.17337801f, 0.01473420f, -0.13122538f, -0.12613074f, 0.11292278f, 
    0.29417410f, 0.38737005f, 0.06380268f, 0.31827849f, -0.06189824f, 0.06921504f, -0.01405544f, 0.09761594f, 
    0.21432257f, -0.00926645f, -0.00112549f, -0.02442813f, -0.15026721f, -0.20496529f, -0.06000150f, -0.26482290f, 
    0.06645769f, -0.02938349f, 0.05506810f, 0.04464797f, 0.22172843f, 0.01986519f, 0.05281715f, 0.03013238f, 
    0.04702744f, -0.29140165f, -0.06196652f, 0.10121094f, -0.10939471f, -0.14837565f, -0.02171725f, 0.08631780f, 
    0.04888154f, 0.00485538f, -0.13742208f, 0.05190733f, 0.04623492f, 0.22526670f, 0.22992949f, -0.16964766f, 
    -0.03494840f, 0.06751040f, 0.03589749f, 0.13556127f, -0.00422839f, 0.02713600f, 0.01851376f, -0.03323467f, 
    -0.01550307f, 0.11200986f, 0.32732171f, 0.28268421f, -0.02694622f, 0.11984991f, -0.10245004f, 0.08802490f, 
    0.04384843f, -0.15712111f, 0.01325397f, -0.09978270f, -0.06847659f, -0.06180598f, -0.04846569f, 0.06968859f, 
    -0.00194912f, -0.05609534f, 0.00710637f, 0.09829392f, 0.11081002f, -0.06191325f, -0.07438593f, 0.07626081f, 
    -0.19340448f, 0.08492065f, -0.13726068f, 0.04760807f, 0.08498354f, 0.07885639f, 0.01663685f, -0.03832255f, 
    0.14749944f, -0.08556794f, 0.08662451f, -0.11772683f, -0.10469600f, -0.19960503f, -0.09369131f, 0.03645484f, 
    0.03667346f, -0.14141716f, -0.02370104f, 0.13355371f, 0.16950232f, -0.00759002f, 0.02204670f, -0.08331608f, 
    0.16673359f, 0.10590050f, 0.24179427f, 0.09921809f, 0.03269120f, 0.09820295f, 0.16529542f, 0.02530075f, 
    -0.00926040f, 0.09966501f, -0.01361000f, -0.05159435f, 0.26841745f, -0.03572238f, -0.06920393f, 0.08918280f, 
    -0.02646886f, -0.05835804f, 0.00506657f, -0.07156253f, 0.01378156f, -0.08469507f, -0.20873255f, -0.05783218f, 
    0.07281041f, 0.09914408f, 0.07666379f, 0.00370216f, 0.03884572f, 0.09596651f, 0.14379767f, -0.02250133f, 
    0.01928236f, -0.01531064f, -0.05872306f, 0.09655053f, 0.32846949f, -0.11912070f, -0.04556543f, 0.08199906f, 
    -0.01181591f, -0.10756623f, -0.11216401f, 0.17152596f, 0.15138015f, -0.06724776f, 0.01670349f, -0.11936514f, 
    -0.02060371f, -0.32725483f, -0.06883232f, -0.21275112f, -0.05684887f, 0.05434484f, -0.00091694f, 0.23115021f, 
    -0.00928087f, 0.01394602f, 0.08586664f, 0.02076250f, 0.23062693f, 0.04200827f, 0.11904266f, 0.17829503f, 
    -0.03704632f, 0.01174898f, -0.02303405f, -0.04971968f, 0.11438169f, -0.14381424f, 0.00486994f, -0.00982343f, 
    -0.34010431f, 0.10596054f, -0.17454371f, 0.05146905f, -0.02592082f, -0.17230482f, -0.01680410f, 0.03506916f, 
    -0.07173733f, 0.03451961f, -0.15561031f, 0.09210352f, 0.02447044f, 0.13881642f, -0.31666082f, 0.02517366f, 
    -0.07785708f, -0.01887155f, -0.06995662f, 0.04512921f, 0.13944113f, 0.01582765f, -0.14410792f, 0.05415162f, 
    -0.07352281f, 0.05715348f, 0.37327763f, -0.07721844f, -0.02944582f, -0.04940070f, -0.04825129f, 0.06926507f, 
    0.11491536f, 0.02744243f, -0.06595247f, 0.14798334f, -0.01994445f, 0.01696575f, -0.06335404f, -0.06040562f, 
    -0.01606079f, 0.09903152f, -0.02067347f, -0.10752649f, 0.03548894f, 0.03354795f, -0.02166232f, -0.02546416f, 
    0.07208706f, 0.03039678f, 0.15819952f, -0.07991055f, 0.03354457f, -0.12743689f, 0.08783367f, 0.04864457f, 
    0.03235502f, 0.09457172f, 0.06382190f, 0.07920742f, 0.10692132f, -0.09993759f, 0.14926973f, -0.00757328f, 
    -0.07709643f, -0.04133303f, -0.05687709f, 0.01383641f, 0.10345619f, -0.02361058f, 0.12611724f, -0.00835244f, 
    -0.03153338f, 0.34251258f, -0.14349575f, -0.03308710f, -0.00974680f, 0.00187034f, 0.03069190f, 0.05765033f, 
    0.12878586f, 0.03045257f, 0.07334707f, -0.03446095f, 0.23137957f, -0.27646625f, 0.19671489f, -0.02334789f, 
    0.01277052f, 0.09134025f, -0.05346924f, 0.11476739f, 0.07852723f, -0.06678982f, -0.10567243f, 0.04715674f, 
    -0.00458389f, 0.12320095f, 0.29652578f, 0.15355095f, -0.09217096f, -0.04612952f, -0.05700294f, 0.07214300f, 
    0.14177556f, 0.03596174f, 0.08884601f, 0.10063735f, 0.15654145f, 0.00582267f, -0.03877920f, 0.12933955f, 
    0.06536635f, 0.02874161f, 0.10533325f, 0.07851257f, 0.00646378f, 0.09254503f, -0.12099928f, -0.08683094f, 
    0.19141075f, -0.24520691f, -0.21729562f, 0.23230714f, -0.05815557f, -0.00499810f, -0.05063709f, -0.00370639f, 
    0.06415530f, 0.01708395f, 0.07423144f, 0.23263593f, -0.17924312f, -0.16515216f, -0.00211675f, 0.06090059f, 
    -0.04717179f, -0.03957586f, 0.00550232f, -0.00384813f, 0.06375753f, 0.05333130f, 0.09599454f, 0.17100859f, 
    0.00351194f, -0.21310642f, 0.06698511f, -0.15945725f, -0.02801032f, -0.03092580f, 0.02343268f, 0.02791264f, 
    -0.00111847f, -0.01866596f, 0.02874172f, 0.01021280f, -0.03227523f, -0.02536674f, -0.01691425f, 0.02921712f, 
    0.08490214f, -0.01534756f, 0.04178311f, 0.10452080f, 0.03483274f, 0.01504370f, 0.07051832f, 0.15526807f, 
    -0.11250947f, -0.14700906f, -0.01211682f, -0.11098237f, 0.01424716f, -0.11675855f, -0.00246993f, -0.02001835f, 
    0.11269797f, -0.06157111f, 0.08608816f, 0.11101123f, -0.12655383f, -0.02442979f, 0.08477974f, 0.07972865f, 
    0.04431008f, -0.09943395f, -0.01864751f, -0.04895457f, 0.02909362f, -0.04625058f, 0.05849987f, 0.01102271f, 
    -0.09752350f, 0.16392928f, -0.17126814f, 0.10618570f, -0.09307880f, -0.05642994f, -0.09846675f, 0.13354057f, 
    -0.02819365f, -0.05336778f, 0.01416857f, 0.05834999f, -0.16357590f, 0.01116551f, -0.08545104f, 0.19097690f, 
    0.09788539f, -0.00992197f, -0.00785633f, 0.04324444f, -0.03192399f, -0.08220337f, -0.05056137f, 0.03054598f, 
    0.05987187f, 0.10085999f, -0.14048906f, 0.05817448f, 0.00794170f, 0.11944067f, 0.11917204f, -0.04269127f, 
    0.08268866f, -0.04504541f, 0.04092032f, -0.00516887f, -0.15918304f, 0.05947710f, -0.06400946f, -0.05713492f, 
    0.00353528f, -0.08746693f, -0.02085588f, 0.00646321f, 0.05711054f, -0.02958035f, 0.06110935f, 0.08786016f, 
    -0.02011152f, -0.14580904f, -0.07223026f, -0.07776977f, -0.09892534f, -0.03341768f, -0.09892397f, 0.01879889f, 
    -0.03213283f, 0.03404471f, 0.06549363f, 0.06033597f, -0.01810555f, -0.08763205f, 0.12765014f, -0.18176308f, 
    -0.04770769f, -0.10025594f, -0.03416804f, -0.04713938f, 0.10434965f, 0.09526154f, 0.05064646f, -0.00445420f, 
    -0.18272588f, 0.17523924f, -0.11973930f, 0.13223042f, 0.08454173f, -0.01648131f, -0.02345230f, -0.01463724f, 
    -0.00412011f, -0.07737020f, 0.02868500f, 0.03399846f, 0.12510712f, 0.14064634f, -0.17765799f, 0.22458275f, 
    -0.04226795f, 0.00451401f, 0.01642534f, -0.00724269f, 0.12228600f, -0.07819486f, -0.04027654f, 0.10969052f, 
    -0.16224810f, -0.00933824f, -0.08666871f, -0.06670330f, 0.13681939f, 0.02368432f, -0.00224840f, -0.15018298f, 
    0.04316274f, -0.08806799f, 0.02864090f, -0.06947616f, -0.20054156f, -0.05806240f, -0.05199648f, -0.08406510f, 
    -0.02723754f, -0.01253630f, -0.03055708f, -0.01631114f, 0.01536561f, -0.08574793f, -0.01100249f, -0.00389823f, 
    -0.07509902f, 0.11002548f, 0.16544984f, -0.01510201f, -0.02236678f, -0.00227255f, 0.05510284f, -0.07153878f, 
    0.13235901f, 0.01527563f, 0.04184999f, -0.00455465f, 0.06436861f, -0.05902089f, 0.03105411f, 0.03980520f, 
    -0.09748424f, 0.05643999f, 0.03360521f, -0.00136641f, 0.10046182f, 0.03741496f, 0.05301936f, 0.01820804f, 
    -0.03627760f, 0.04583187f, -0.02292168f, -0.00511865f, 0.05336231f, -0.01130133f, 0.16505703f, 0.02411141f, 
    -0.05668828f, -0.01075562f, 0.03224716f, 0.00230065f, 0.00460993f, -0.10708274f, -0.14682475f, 0.08835322f, 
    0.07423623f, -0.02406653f, 0.08379771f, 0.05743925f, 0.08564300f, 0.05951554f, -0.01180655f, -0.01857175f, 
    -0.11648125f, -0.09652252f, -0.00495681f, -0.00074095f, -0.02603281f, -0.10243451f, -0.05293968f, 0.03653214f, 
    -0.00103257f, -0.07701720f, -0.04209749f, 0.00544933f, -0.05415643f, 0.11290473f, -0.10721858f, 0.01528030f, 
    0.02185392f, -0.02897711f, -0.01486549f, -0.05879040f, 0.17620488f, 0.03902175f, 0.12523364f, 0.09927733f, 
    -0.30845347f, -0.48493791f, 0.16207433f, -0.14579307f, 0.00050989f, 0.10868003f, -0.16067861f, 0.08326507f, 
    0.00346807f, 0.09749927f, -0.03152154f, -0.00546662f, -0.12869123f, 0.00147769f, 0.00374863f, 0.08134800f, 
    -0.02913684f, -0.11191091f, -0.04638156f, -0.08018573f, 0.03185632f, 0.03385630f, -0.05122087f, 0.01650821f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01743002f, -0.01413319f, 0.12611724f, -0.03517193f, 0.14060605f, 0.22689112f, -0.03152993f, -0.10067362f, 
    -0.01615341f, 0.17243777f, -0.00790119f, 0.15505672f, -0.01768641f, -0.05564590f, -0.01150760f, 0.04797811f, 
    0.07718592f, -0.13863528f, 0.07418747f, -0.01692733f, -0.05323533f, -0.02260206f, -0.05707294f, -0.00714997f, 
    0.09786134f, -0.00714782f, 0.01491667f, 0.05318983f, 0.17201769f, -0.04496702f, 0.16148393f, 0.00189651f, 
    0.03348411f, 0.01067758f, 0.04428953f, -0.04017215f, 0.11312336f, -0.04549835f, 0.02050753f, 0.01154122f, 
    0.09067880f, 0.09528007f, 0.13906260f, 0.01791923f, 0.09373780f, -0.01275189f, 0.07384641f, 0.02306222f, 
    -0.01083081f, -0.00890456f, -0.01408931f, 0.07363819f, 0.11910107f, 0.00114452f, -0.05716264f, -0.05871398f, 
    0.00563723f, -0.00972793f, 0.01366175f, 0.01093644f, -0.02962365f, 0.14779226f, 0.07184512f, 0.15437575f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.14242175f, -0.04410189f, -0.36911464f, 0.12477589f, 0.03437546f, -0.17050217f, -0.55977184f, 0.17399004f, 
    -0.05722047f, -0.26159975f, 0.22557636f, 0.17742574f, 0.08508939f, 0.02710306f, 0.18865168f, 0.06677803f, 
    -0.24219570f, 0.14027181f, -0.44586906f, -0.09022712f, -0.09965974f, -0.29685923f, 0.03882569f, 0.29617891f, 
    -0.13866127f, -0.07041993f, 0.03205111f, 0.10318109f, -0.25686139f, -0.04067343f, -0.02204402f, -0.14398691f, 
    -0.43818182f, 0.18226366f, 0.26904947f, 0.11757717f, -0.08230981f, 0.06406325f, -0.36186460f, 0.00947470f, 
    -0.36023614f, 0.07832191f, -0.13662471f, 0.13826370f, -0.37189722f, 0.10916547f, 0.20167615f, 0.11247348f, 
    -0.32190558f, -0.06517419f, 0.06733190f, -0.46481761f, -0.25379178f, -0.04732078f, 0.27322611f, 0.11274545f, 
    -0.11640332f, -0.06594149f, -0.61601758f, -0.05823071f, 0.11747697f, 0.11891563f, -0.04662471f, -0.35320896f, 
    -0.31928369f, 0.03144845f, 0.18128639f, -0.31342617f, 0.19335896f, 0.06904903f, 0.11874083f, -0.10693291f, 
    -0.06448060f, 0.09795751f, 0.11681754f, 0.22275995f, 0.10196659f, 0.03767056f, -0.38608354f, 0.20425108f, 
    -0.32599947f, -0.24562187f, -0.27935579f, -0.00614734f, -0.03863310f, -0.22420964f, 0.05371547f, 0.18456095f, 
    -0.04679736f, 0.03187291f, -0.37774763f, 0.23437688f, 0.44783777f, 0.07434095f, 0.12765034f, -0.39731053f, 
    -0.04081671f, 0.10110053f, -0.26140606f, -0.10253390f, -0.11997304f, -0.10886363f, -0.14364703f, -0.00231905f, 
    -0.24460617f, 0.17534395f, 0.30478740f, -0.10729996f, -0.30901641f, -0.03058523f, 0.17849693f, 0.16898924f, 
    0.02169826f, 0.10765214f, 0.00264133f, -0.05690489f, 0.06808718f, 0.09137458f, 0.34039494f, 0.00242103f, 
    0.03029966f, 0.36332899f, -0.14557301f, 0.21322426f, -0.31694350f, 0.10163319f, -0.59556025f, -0.12391932f, 
    0.29251400f, -0.00242132f, -0.01467566f, -0.33770776f, 0.16985965f, 0.20145796f, -0.04634358f, 0.02072015f, 
    -0.02952681f, -0.14029685f, -0.20335835f, -0.23448502f, -0.05552303f, -0.08326509f, 0.12425824f, 0.35450238f, 
    0.04019250f, -0.18031998f, -0.00753113f, -0.01084038f, 0.02647452f, -0.43533891f, -0.00287800f, -0.40665740f, 
    0.17165147f, -0.02981927f, -0.07758558f, -0.24877802f, -0.18894534f, 0.06963797f, 0.18290487f, 0.05464712f, 
    -0.00936603f, -0.10321556f, -0.32679433f, -0.11350553f, -0.16708757f, -0.11768322f, 0.22624740f, -0.04289217f, 
    -0.09339500f, -0.19086109f, -0.12800506f, 0.00585792f, 0.33379540f, -0.09730262f, 0.02189327f, -0.11997773f, 
    -0.67705065f, 0.01088525f, -0.01637777f, 0.22898221f, -0.11373489f, -0.05089689f, 0.25208578f, -0.03322116f, 
    -0.12083886f, -0.24650411f, 0.43243101f, -0.34303430f, -0.07565521f, 0.28683227f, 0.07155668f, 0.15449764f, 
    0.25526959f, -0.02435019f, -0.17376158f, -0.06006014f, -0.17703971f, -0.41904652f, 0.34742209f, 0.16903752f, 
    0.07775953f, -0.41665733f, -0.17349379f, -0.07818774f, -0.01008838f, 0.06888981f, 0.25329858f, 0.15321189f, 
    -0.43079290f, 0.19126719f, 0.09677730f, -0.06649070f, 0.01688490f, 0.17165600f, 0.07012730f, -0.01247369f, 
    -0.17127882f, 0.08859971f, 0.21440178f, 0.11398351f, -0.02886831f, 0.04823268f, -0.57129389f, 0.15982544f, 
    0.30592459f, -0.28263724f, 0.07873789f, -0.10268655f, -0.08966684f, 0.00156494f, -0.14689898f, -0.00342411f, 
    -0.04965787f, -0.36983094f, -0.38428730f, 0.02824974f, 0.40261859f, 0.11576186f, 0.13957822f, 0.08041564f, 
    -0.11055908f, 0.05081169f, 0.07141235f, 0.23646030f, -0.30934221f, -0.12873460f, -0.05829830f, 0.08160325f, 
    0.11156883f, 0.07578390f, 0.00965420f, -0.12966256f, -0.00713729f, 0.11745886f, 0.06145776f, -0.21922468f, 
    -0.38799894f, 0.07398982f, -0.35999912f, 0.19371945f, 0.02917421f, 0.03032912f, -0.14551041f, -0.00150896f, 
    0.01643196f, -0.09534919f, 0.09058535f, -0.25056475f, -0.06915899f, -0.02930262f, -0.03447130f, -0.02423644f, 
    0.04811997f, 0.28161353f, -0.01520130f, 0.00659561f, 0.07314554f, 0.18304846f, -0.01632514f, -0.04487899f, 
    -0.05330402f, 0.09346550f, -0.33908087f, 0.13936996f, -0.26898852f, -0.05113057f, -0.30425787f, 0.19153671f, 
    -0.24526235f, 0.21165408f, -0.22635837f, 0.10350604f, -0.08301008f, 0.11017126f, 0.22070739f, 0.03510060f, 
    -0.12294901f, 0.06100255f, -0.23442493f, 0.11491228f, -0.45604444f, -0.03349112f, -0.05966828f, -0.11152340f, 
    0.19817126f, 0.02783448f, 0.04030257f, -0.21471331f, -0.14712572f, -0.07066488f, -0.01279986f, 0.08080106f, 
    0.11469140f, -0.11873889f, 0.22763348f, 0.25726926f, 0.03536392f, -0.17037340f, 0.31834298f, 0.22543892f, 
    -0.38577867f, 0.09833819f, -0.02159839f, 0.13700832f, 0.06103659f, 0.17868870f, -0.35350499f, -0.26128051f, 
    0.08248270f, -0.03253113f, 0.08748449f, 0.26111418f, 0.12256601f, -0.09621986f, -0.11964896f, -0.10148579f, 
    0.43055415f, -0.27770564f, 0.22534753f, -0.12141849f, -0.05670654f, 0.08048539f, -0.11913585f, 0.10438178f, 
    -0.00779966f, -0.02493455f, 0.46456251f, 0.13142860f, -0.15579887f, 0.06079247f, 0.00514842f, -0.09580421f, 
    -0.12181482f, 0.08398731f, 0.11815653f, -0.06520952f, 0.35204980f, -0.08379553f, -0.22015297f, 0.11266190f, 
    0.09573171f, 0.22107868f, -0.06403457f, -0.11488307f, -0.12481341f, -0.05066039f, 0.14894800f, 0.10096539f, 
    -0.30627277f, -0.11047850f, 0.05310273f, 0.07651963f, -0.17720419f, -0.02615317f, -0.18798235f, 0.09004092f, 
    0.01397679f, -0.20856005f, -0.31770191f, -0.13661915f, -0.36745018f, 0.19543260f, 0.21530010f, 0.08619877f, 
    0.05837767f, -0.02825957f, 0.24377382f, -0.26745060f, -0.46206740f, 0.10073303f, 0.08551217f, -0.28669327f, 
    -0.10725342f, 0.31107059f, -0.18008690f, 0.04901117f, -0.08537659f, -0.10720625f, 0.26754194f, 0.26360908f, 
    -0.02097401f, -0.41682199f, 0.42504644f, 0.00169558f, 0.04973350f, -0.20233333f, -0.05230108f, -0.40135410f, 
    0.12931609f, -0.12680715f, -0.39727718f, -0.43650156f, -0.07693687f, -0.06886577f, -0.34650466f, 0.12421991f, 
    -0.17187107f, -0.17097102f, -0.27596107f, 0.11694217f, -0.06141541f, 0.02115896f, 0.20114955f, 0.08437633f, 
    0.05834095f, 0.18987092f, 0.04413977f, 0.03703970f, 0.27682346f, -0.02899364f, -0.49134627f, -0.26740593f, 
    -0.07398012f, -0.03501175f, 0.03076298f, -0.31980875f, 0.15176557f, -0.04697708f, -0.47663361f, -0.08011994f, 
    0.01675323f, -0.37340373f, -0.11468470f, -0.21107611f, 0.10630654f, -0.79905224f, -0.11485328f, 0.03243839f, 
    -0.21426848f, 0.11221576f, 0.05831686f, 0.07024796f, -0.27455825f, -0.05467715f, 0.11798187f, -0.01177081f, 
    0.01598890f, -0.19523486f, -0.04960822f, -0.24992166f, -0.01108674f, 0.10143435f, -0.33858046f, -0.43614763f, 
    0.32641211f, 0.42806223f, -0.00711382f, -0.07407875f, -0.10581620f, 0.03053663f, -0.11591440f, 0.24946889f, 
    0.20633239f, -0.08750625f, 0.39604589f, -0.31531981f, -0.22051829f, 0.06259333f, 0.24245121f, -0.19574374f, 
    -0.04798765f, -0.09044797f, -0.27827576f, -0.09284574f, -0.19977582f, 0.06473490f, -0.11652759f, -0.09763695f, 
    -0.05170947f, 0.11690658f, -0.31666890f, -0.39502344f, 0.09180770f, 0.07699337f, -0.21890113f, -0.01725494f, 
    0.19947019f, 0.05123220f, -0.04222991f, 0.21989933f, -0.12438889f, 0.10826687f, -0.42518243f, -0.08685961f, 
    -0.08862798f, 0.15460354f, 0.35798410f, -0.07977390f, 0.34527513f, -0.48397949f, -0.01908963f, -0.16956818f, 
    0.40743980f, 0.05376011f, -0.11128291f, -0.56260985f, -0.25784588f, 0.04495025f, -0.23060635f, 0.27643973f, 
    0.08275968f, -0.14633302f, -0.24855481f, 0.30832413f, -0.07098427f, 0.08608323f, 0.12930968f, -0.28707460f, 
    0.01727981f, -0.37825644f, -0.30051237f, -0.02465833f, 0.10981829f, 0.08216627f, 0.02467835f, -0.14302187f, 
    -0.12632999f, -0.06406631f, 0.25182647f, -0.42335036f, -0.34051916f, -0.11617532f, 0.10292786f, -0.29556090f, 
    0.05188952f, -0.44747019f, 0.27998444f, 0.03789973f, 0.21337457f, 0.09698482f, -0.22000410f, -0.05823047f, 
    0.06575000f, 0.14597286f, 0.21095550f, -0.09056599f, 0.19643937f, -0.05737773f, 0.06394108f, 0.15918735f, 
    0.15267287f, -0.11008176f, 0.02689013f, 0.25408161f, -0.12561059f, 0.08813773f, -0.36062327f, -0.12901144f, 
    0.00462344f, 0.23732410f, 0.05000075f, -0.30204690f, -0.20551351f, -0.40630925f, 0.08191308f, 0.24183093f, 
    -0.12539051f, 0.11310442f, 0.03954398f, 0.27283871f, -0.27818871f, 0.05446789f, -0.31365475f, -0.55736434f, 
    -0.06842642f, 0.15556964f, -0.25598297f, 0.09863667f, -0.05669398f, -0.01104595f, 0.19861624f, -0.32548934f, 
    0.21780090f, -0.09545951f, -0.20859098f, -0.01486573f, -0.01066194f, -0.30689201f, 0.06312338f, -0.04899356f, 
    0.07834277f, -0.09270613f, 0.25971648f, 0.03630690f, 0.07290784f, 0.07058237f, 0.25635371f, 0.26096842f, 
    0.17672141f, 0.12265026f, -0.29025984f, 0.06493285f, -0.52177817f, 0.05701073f, -0.13882147f, 0.02258502f, 
    0.07084426f, -0.15819381f, -0.17405219f, -0.02478414f, -0.27457100f, 0.08384534f, -0.32655755f, -0.55151445f, 
    -0.34142277f, -0.04195126f, 0.09274329f, -0.16485141f, 0.13875262f, 0.11466601f, 0.07426751f, 0.09434316f, 
    -0.11406356f, -0.09452648f, 0.00361351f, 0.55540448f, 0.34733114f, 0.17195557f, -0.15242626f, 0.21136010f, 
    -0.08350798f, -0.08802592f, 0.07489561f, -0.51663482f, 0.17893137f, -0.09823537f, 0.19816180f, 0.28763437f, 
    0.01566696f, 0.24412636f, 0.26656574f, -0.00459776f, -0.12240752f, -0.05570361f, -0.31160936f, -0.10252066f, 
    -0.09465815f, -0.01556307f, 0.23054455f, 0.10534800f, -0.09877492f, 0.29606387f, -0.12490924f, -0.24622521f, 
    -0.37404051f, -0.09287940f, -0.03722675f, 0.16049382f, -0.25843522f, 0.09479643f, 0.12303271f, 0.09068583f, 
    0.14913429f, -0.04446119f, -0.04791899f, -0.04274366f, 0.09150976f, 0.02783623f, -0.37959981f, -0.04205806f, 
    -0.30375504f, -0.39590076f, 0.23367825f, 0.23613389f, -0.08218971f, -0.11888169f, 0.01447648f, -0.11144698f, 
    -0.26377174f, 0.05841876f, 0.06562132f, -0.19010654f, 0.27440262f, -0.01749673f, -0.52852648f, 0.02822305f, 
    0.08071101f, -0.01084427f, 0.26719639f, -0.58038324f, -0.38327020f, 0.18460582f, -0.39601201f, 0.02177064f, 
    0.31736067f, -0.12337102f, 0.09081428f, 0.31259131f, -0.27939120f, 0.18865561f, 0.31714031f, 0.18624827f, 
    -0.09328591f, -0.04820178f, -0.36450467f, -0.45778832f, -0.02746353f, 0.03728136f, -0.38094208f, -0.33208725f, 
    -0.43404976f, -0.02732243f, 0.21956550f, -0.03280902f, -0.09846032f, 0.15241931f, -0.00982461f, -0.17746735f, 
    -0.17399684f, 0.07786183f, -0.40568238f, -0.39691886f, 0.18480517f, -0.03457153f, -0.51351619f, -0.05373075f, 
    0.19855177f, 0.21475120f, 0.21859983f, -0.06099365f, 0.18794282f, -0.05025070f, 0.30357316f, 0.00876960f, 
    0.13356313f, -0.06395411f, -0.14901409f, -0.02605608f, 0.15590386f, -0.08141518f, 0.07711010f, -0.20582253f, 
    -0.01024728f, -0.08521987f, 0.03633224f, 0.10355157f, -0.03560661f, 0.10421094f, -0.03827379f, -0.10168254f, 
    -0.08690082f, 0.04634750f, -0.53431928f, 0.08053259f, -0.29872644f, -0.21707140f, 0.03129495f, -0.28387761f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09553766f, 0.02589243f, -0.04439341f, 0.03162696f, -0.05086221f, -0.01756012f, 0.11092769f, -0.07916863f, 
    0.09230588f, 0.04743403f, 0.14271717f, 0.01181050f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
