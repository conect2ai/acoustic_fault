#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.44926763f, 1.39870811f, 1.37778485f, -1.63599551f, 0.42251894f, 0.01753690f, 0.29012176f, -0.46158415f, 
    -0.45544851f, -0.32255936f, 0.02856583f, 0.30164325f, -0.16775033f, 0.31692073f, 0.05932295f, -0.12447074f, 
    0.03075156f, 0.13060114f, 0.30351529f, 0.00952019f, -0.12936652f, 0.00842443f, 0.03432707f, 0.03401270f, 
    0.37145013f, 0.49983996f, -1.04081011f, -0.91813761f, -1.03832698f, 0.39284629f, 0.65949249f, -0.27916583f, 
    -1.22912180f, -0.97709692f, -0.44854113f, 0.12296195f, 0.40363008f, 0.31824717f, -0.31988037f, 0.06235711f, 
    -0.11117744f, 0.00028451f, -0.53916276f, -0.12734662f, -0.18662447f, 0.05902136f, -0.03533576f, 0.29046583f, 
    0.15289563f, -0.19108701f, -1.01897168f, 1.21697855f, 1.20368981f, -0.64582002f, 1.08540475f, 1.10111320f, 
    -0.64254296f, 0.65219426f, -0.89006329f, -0.61946023f, -0.00980958f, 0.03797068f, 0.08729449f, -0.32355240f, 
    -0.58498710f, 0.10726948f, -0.10231250f, -0.24255428f, -0.44038764f, -0.29506251f, 0.22379780f, -0.04729458f, 
    0.05839027f, -0.02044785f, -0.19192153f, -0.36617568f, -1.63805985f, 0.60212833f, 1.28817225f, -0.16408911f, 
    -0.83829618f, -0.09008302f, 0.58650535f, -0.69791073f, -1.12761259f, 0.39288500f, -0.15515886f, 0.02038367f, 
    0.21204759f, 0.41906312f, 0.23390892f, 0.54921651f, -0.12203314f, -0.04367470f, -0.33050486f, -0.01474052f, 
    -0.21293138f, 0.05200175f, 0.34149650f, 0.35190189f, -0.18460554f, -0.87768638f, 0.63750482f, 0.02104134f, 
    -1.32842076f, -0.12950121f, 0.44210136f, 0.74706060f, -0.11478554f, 0.15698022f, 0.46779919f, 0.43484133f, 
    -0.07018921f, 0.21838683f, 0.16780195f, -0.43708894f, -0.30934873f, -0.07637473f, -0.65315300f, -0.21053919f, 
    0.50398827f, 0.68566036f, 0.48558724f, 0.40137050f, -0.00107618f, -1.14006150f, -1.60407138f, -0.97693813f, 
    -0.19093466f, 0.07798715f, 0.21545996f, 0.70052165f, 0.39086846f, -0.04616108f, 0.25494641f, -0.47619063f, 
    0.10371718f, 0.05446628f, -0.17139515f, 0.42477193f, 0.16062501f, -0.18584496f, 0.08404355f, -0.22131833f, 
    -0.22915444f, 0.32138270f, -0.14568327f, -0.38227016f, 0.27593642f, 0.21037102f, 0.68948698f, 1.06635380f, 
    1.57278097f, 1.19224489f, 0.11271857f, -1.12730634f, 0.03185442f, -0.83493263f, -0.96727538f, 0.16708390f, 
    0.56903452f, 0.26145670f, -0.56316364f, 0.28664419f, 0.12887000f, -0.20437892f, -0.08624777f, -0.14116499f, 
    0.07543372f, -0.36569244f, 0.36712134f, 0.50426507f, 0.38378555f, 0.11316826f, 0.13183896f, 0.61420560f, 
    -1.48115659f, 1.11186004f, 0.27588406f, -0.04697029f, 0.63446498f, -1.09327161f, 1.03500640f, 0.09601433f, 
    0.09760170f, -0.25530282f, -0.29438758f, -0.53595775f, 0.59425694f, -0.49220130f, 0.08595730f, 0.16794981f, 
    -0.02436666f, -0.13154788f, -0.01491442f, -0.39391294f, 0.05837321f, 0.56958848f, -0.31502151f, -0.04503062f, 
    1.90478885f, 1.36339712f, -0.33150032f, -0.24654409f, -1.09664547f, 0.39321461f, 0.06600084f, -0.25349164f, 
    0.25330848f, 0.60791308f, 0.56761885f, 0.72483349f, 0.00534053f, 0.24262133f, -0.10721533f, 0.11340766f, 
    -0.05814440f, 0.19171388f, 0.11877396f, 0.42443761f, -0.23820990f, 0.50105506f, 0.15302588f, 0.22646756f, 
    0.05886753f, 0.79243273f, -0.03333882f, -1.07570791f, -1.11245656f, 1.01574051f, 0.62209034f, -0.43609801f, 
    0.88403076f, 0.81661105f, 0.59170902f, -0.74867654f, -0.30779409f, -0.63843632f, -0.47236294f, -0.24254061f, 
    -0.12246101f, -0.46220544f, -0.15786366f, -0.24637794f, -0.16950747f, -0.31106558f, -0.06229607f, -0.24623020f, 
    0.27148744f, -0.13157004f, 1.53634417f, 0.16724783f, 0.35237363f, 0.29577589f, 0.08990935f, 1.09671640f, 
    0.73682982f, 0.64048749f, 0.87017614f, 0.37875244f, -0.61691654f, 0.26512229f, 0.21945299f, -0.12325965f, 
    -0.29813936f, -0.21211405f, -0.33856580f, 0.02305543f, -0.25339276f, 0.06203343f, 0.00375160f, -0.15357164f, 
    -0.32138923f, -0.31773156f, -0.20145899f, 1.19989121f, 1.13089669f, 0.89742607f, 1.47131383f, 0.52804297f, 
    0.40175930f, 0.21544467f, 0.38520467f, -0.48248091f, 0.33140150f, -0.40746999f, -0.13316724f, -0.28604239f, 
    0.23531494f, -0.01624638f, -0.61614466f, 0.06496438f, 0.44741437f, -0.16198927f, -0.10836271f, 0.08114772f, 
    -0.04968111f, -0.59271318f, 0.01253103f, 0.17862764f, 0.98774272f, 0.36321253f, 0.56800663f, 1.41861033f, 
    1.35378802f, 0.15807714f, -0.64348835f, -0.66662645f, -0.19566761f, 0.02916208f, 0.48695639f, 0.32318759f, 
    -0.01784085f, 0.40442178f, -0.28765216f, 0.64285600f, 0.28405949f, 0.73115999f, 0.25281861f, 0.52870780f, 
    0.08314780f, -0.16909869f, 0.27205089f, -0.06681027f, -0.10704764f, -0.85059714f, -1.23465824f, -1.16762626f, 
    -0.55722028f, -0.24556904f, -0.93679947f, 0.11954297f, 0.56692475f, -0.11556721f, 0.54628187f, 0.44414532f, 
    0.25776529f, 0.11824271f, -0.17257243f, -0.41546369f, -0.02359921f, 0.06846266f, -0.27012646f, 0.18045864f, 
    -0.51168311f, -0.36626521f, -0.64050651f, 0.41110289f, -0.12201484f, 0.25218144f, 0.15068683f, -0.64545190f, 
    -1.07086861f, -1.21990860f, -0.58854365f, 0.54392922f, 1.09023929f, 0.33273125f, 0.53863299f, 0.66549748f, 
    -0.20694529f, 0.27596381f, -0.43273246f, -0.08293820f, -0.34938303f, -0.14552392f, 0.21904753f, 0.24859935f, 
    0.22840294f, -0.02064466f, 0.12030878f, 0.24201442f, -0.50430173f, -0.32203254f, 0.13989338f, -0.63914305f, 
    -1.57653821f, -0.70982462f, 0.38106212f, 0.39956051f, 0.66484034f, -0.05194945f, 0.02836047f, 0.48595002f, 
    0.34597707f, 0.14189905f, -0.21402390f, 0.11250757f, 1.13738060f, 0.25752026f, 0.01081914f, 0.23342855f, 
    -0.00042762f, 0.26907462f, 0.29272830f, 0.19320543f, 0.07509468f, -0.09930467f, -0.12561050f, -0.30506274f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14977817f, 0.61043459f, 0.13352607f, 0.32414451f, 0.20499811f, 0.08151210f, 0.47978541f, 0.33794141f, 
    0.38341227f, 0.09491375f, 0.15239465f, 0.45858425f, 0.21824192f, 0.17705160f, 0.30802214f, 0.56893152f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.60194302f, 0.05788125f, 0.37430307f, -0.49626696f, 0.01027634f, 0.06286334f, -0.06320893f, 0.06502391f, 
    0.07455750f, -0.06734236f, 0.04949444f, 0.00854888f, -0.53711063f, -0.58758515f, 0.46205026f, -0.38028887f, 
    -0.26544982f, 0.03893692f, 0.00830931f, 0.02371265f, -0.30778760f, -0.02747048f, 0.15461762f, -0.14890288f, 
    -0.77701557f, -0.08501152f, 0.56952339f, -0.19819100f, 0.03936502f, 0.02726719f, 0.13441704f, -0.25958014f, 
    0.12466867f, -0.14547886f, 0.00512258f, -0.04266996f, -0.24699521f, -0.14385360f, -0.23556820f, 0.61768925f, 
    0.16403830f, 0.09558126f, -0.02355078f, -0.07568614f, -0.05636764f, 0.04428947f, 0.01106805f, -0.04600827f, 
    -0.28407618f, -0.00958084f, 0.01193593f, 0.20670380f, -0.19225590f, 0.15585718f, -0.20750198f, -0.01961331f, 
    0.10528363f, 0.13333297f, 0.20398454f, 0.19962870f, 0.01356429f, 0.08013501f, -0.09280571f, -0.31196177f, 
    0.25997517f, -0.11321428f, 0.13094008f, 0.23934130f, 0.05754256f, -0.13344975f, 0.01380377f, -0.03611528f, 
    0.19079292f, 0.16080260f, -0.19203097f, 0.27165732f, -0.18987614f, -0.27084786f, -0.04927591f, -0.09518376f, 
    -0.16986330f, 0.04895622f, -0.05134504f, -0.04586653f, 0.31443757f, 0.06652973f, 0.11600812f, 0.34616634f, 
    -0.14093186f, -0.09631028f, -0.10126118f, -0.08945224f, -0.23941161f, 0.20843048f, 0.01260285f, -0.37436646f, 
    0.00343491f, -0.21619603f, 0.01105986f, -0.38463640f, -0.11111426f, 0.04769054f, -0.16847198f, 0.15309197f, 
    -0.24059431f, 0.04928017f, -0.04418798f, 0.03946036f, 0.65048796f, 0.31920999f, 0.29336143f, -0.34258807f, 
    0.10803958f, 0.34265867f, 0.10647155f, -0.05054477f, -0.18850744f, -0.09362723f, 0.13066638f, -0.08464836f, 
    0.45881304f, 0.05153949f, -0.28182811f, 0.21854401f, 0.17930718f, -0.06660147f, 0.14194749f, 0.10384961f, 
    -0.03918334f, 0.11657416f, -0.01439898f, 0.08716347f, 0.25300121f, 0.05278750f, -0.38589379f, 0.31404147f, 
    -0.37114334f, -0.22624388f, 0.08161516f, -0.00973899f, -0.09776191f, 0.04359683f, -0.07286407f, -0.04541763f, 
    0.25727719f, -0.19894797f, -0.00131372f, 0.28304619f, -0.34711224f, -0.03524811f, -0.10473931f, 0.23513752f, 
    0.22094141f, -0.04363303f, -0.14524065f, -0.30719587f, -0.47573337f, 0.19386201f, -0.24907294f, -0.34779745f, 
    -0.16136444f, 0.04375998f, 0.12043428f, 0.16750866f, -0.03023541f, 0.15906088f, -0.30866051f, -0.01324026f, 
    0.16724418f, 0.04864792f, 0.02429469f, -0.73424029f, 0.18494077f, -0.04229926f, 0.03493506f, -0.07582240f, 
    -0.08411216f, 0.05457059f, -0.00740479f, 0.15693815f, -0.12967525f, 0.03268785f, 0.28497142f, 0.02020944f, 
    0.09129794f, 0.10089132f, -0.10989845f, 0.02925676f, 0.04800796f, -0.12486172f, -0.02149851f, -0.04663049f, 
    -0.53011107f, 0.11405399f, -0.46530735f, -0.37578541f, -0.10008602f, 0.13467190f, -0.03738253f, -0.06465346f, 
    0.19315815f, 0.19081219f, -0.08056732f, -0.12062878f, 0.27995461f, 0.00639468f, -0.00948254f, -0.30604172f, 
    -0.00238789f, -0.14294928f, -0.02616262f, 0.01271492f, -0.05872134f, -0.07643172f, -0.12298856f, -0.01124197f, 
    0.65745014f, 0.03203774f, -0.48205447f, -0.20804003f, -0.13084608f, 0.02392840f, 0.01437588f, -0.19243109f, 
    -0.05431597f, 0.07521293f, -0.07432851f, -0.11771858f, -0.83901954f, -0.03690564f, -0.15528795f, 0.17369837f, 
    -0.17301227f, 0.04226067f, -0.02134062f, -0.10909568f, 0.06098731f, -0.04474224f, -0.02345623f, 0.13659410f, 
    -0.39172217f, -0.10465010f, -0.33350065f, 0.18574624f, 0.11687670f, -0.00581135f, -0.09615865f, 0.08152229f, 
    0.08538159f, -0.13122787f, -0.24801773f, 0.00897898f, 0.27704990f, -0.08715838f, -0.13725570f, -0.08055253f, 
    -0.05175742f, 0.11006912f, -0.14690775f, -0.07975529f, -0.10406712f, 0.08611823f, 0.00535153f, 0.15987600f, 
    -0.22426146f, -0.00820278f, 0.04677561f, 0.29862773f, -0.17786898f, 0.08904111f, 0.12792766f, 0.09787995f, 
    0.19620217f, -0.10827783f, 0.01439867f, -0.02856385f, -0.05874864f, -0.05926375f, -0.13830051f, 0.03124879f, 
    -0.20257698f, 0.05952401f, 0.02495178f, -0.11001495f, 0.09416974f, -0.15385085f, 0.16947798f, -0.00689172f, 
    0.53962678f, -0.06738502f, 0.16055885f, -0.17899038f, -0.08354308f, -0.25055796f, 0.07380499f, -0.11739530f, 
    0.03019682f, 0.04735187f, -0.02302198f, 0.21595259f, -0.14052244f, -0.45558834f, 0.23969167f, -0.29440600f, 
    0.09370580f, -0.06277485f, -0.32782531f, 0.08216722f, 0.08249758f, -0.11461870f, -0.14795713f, -0.02061137f, 
    0.61266023f, -0.00516194f, 0.29545924f, 0.14987089f, -0.11083516f, 0.06558006f, -0.11124529f, -0.02963145f, 
    0.12592927f, -0.07174411f, 0.15707888f, -0.13690975f, 0.25543043f, 0.20855679f, 0.24378777f, 0.52794337f, 
    -0.11780999f, 0.09818865f, 0.08282872f, 0.01495896f, 0.01208068f, -0.07114924f, 0.09526166f, 0.02313469f, 
    0.12697227f, -0.14215249f, 0.07017857f, 0.22808821f, -0.05899363f, 0.03380002f, -0.10377372f, -0.06897781f, 
    -0.08459760f, 0.02099496f, 0.01437884f, 0.15022585f, 0.44619203f, -0.29426360f, 0.02305443f, 0.17667826f, 
    -0.15867637f, -0.14002314f, -0.07532006f, 0.06038452f, -0.06657858f, -0.48633954f, 0.07034132f, 0.04151446f, 
    -0.09316514f, -0.35079435f, -0.08655510f, -0.33531052f, 0.37471679f, 0.05420188f, -0.14491442f, 0.06697620f, 
    0.02871407f, 0.05570948f, -0.02944393f, -0.20347007f, 0.42111996f, 0.07173301f, -0.29283231f, 0.01398522f, 
    0.03828022f, -0.07435762f, -0.02205845f, 0.04124641f, -0.06427535f, 0.17999560f, 0.09980837f, 0.07486737f, 
    0.55949402f, -0.18910629f, -0.90361774f, -0.09018888f, 0.10919026f, 0.00353425f, -0.00212095f, 0.11161845f, 
    -0.06723937f, -0.00368491f, 0.11139768f, -0.04968464f, -0.28225911f, -0.79774386f, 0.02210182f, -0.75408584f, 
    0.05576704f, -0.19400731f, -0.34243906f, -0.13444225f, -0.08515707f, -0.02949026f, 0.05055198f, -0.20182377f, 
    0.50165015f, 0.04084080f, -0.23247151f, 0.26830116f, 0.00774522f, -0.07557035f, 0.04852841f, -0.14598975f, 
    -0.17941242f, 0.17879325f, -0.07738074f, -0.03014079f, 0.89875829f, -0.33323577f, -0.76248795f, -0.11550458f, 
    -0.06885255f, -0.03302246f, -0.15878372f, -0.00975388f, 0.06351090f, -0.15462004f, 0.03111196f, -0.41060153f, 
    0.31184489f, 0.05524670f, 0.36575347f, -0.26792070f, -0.30034435f, 0.07824793f, -0.14014855f, -0.09543397f, 
    0.11389429f, -0.21439318f, -0.23032598f, -0.03841840f, 0.41591558f, -0.18142296f, 0.07064386f, 0.08718999f, 
    -0.10176340f, -0.33155173f, -0.09736878f, 0.11084579f, 0.12029017f, 0.00404356f, -0.00422053f, -0.05132584f, 
    0.10141388f, 0.22299668f, -0.15233696f, -0.08295225f, 0.08049110f, 0.17498836f, -0.02913752f, -0.19533613f, 
    -0.05976851f, 0.11843135f, 0.02629595f, 0.01711707f, -0.90443361f, 0.11199916f, -0.26781499f, -0.05906136f, 
    0.08477064f, -0.12641624f, -0.23845917f, 0.13662033f, -0.01738388f, 0.03055265f, -0.09385968f, -0.23836689f, 
    0.10544524f, 0.04910367f, 0.24480958f, -0.39413774f, -0.02826289f, -0.15401682f, 0.11626245f, 0.03179438f, 
    -0.15208547f, -0.05164326f, 0.13994409f, 0.04805966f, -0.14600062f, 0.16534235f, -0.00208405f, 0.37251714f, 
    -0.03395320f, -0.13141112f, 0.18141425f, 0.09020388f, -0.00095851f, -0.03260513f, -0.09844887f, 0.20723192f, 
    0.16448171f, 0.13596994f, 0.08144397f, -0.23122893f, -0.06069775f, -0.07841192f, 0.19585419f, 0.16077574f, 
    -0.26374042f, 0.08635361f, 0.12558469f, 0.13648686f, -0.17957890f, -0.00083863f, 0.00005410f, -0.14959447f, 
    0.19843666f, 0.17156646f, 0.03544450f, -0.05355934f, -0.01538883f, 0.14254056f, -0.18240295f, 0.01381840f, 
    0.21909136f, -0.27367547f, -0.04367512f, 0.32094318f, 0.20101154f, 0.06116885f, -0.02119034f, -0.14123102f, 
    -0.31804207f, -0.17063282f, 0.04617091f, -0.03570678f, 0.41494852f, -0.25876939f, 0.04086072f, 0.18880162f, 
    -0.19658828f, -0.14666384f, -0.20591784f, 0.16049358f, -0.22121722f, -0.09664062f, 0.07098281f, -0.16080099f, 
    0.18047899f, 0.26694214f, 0.16716266f, 0.40164050f, -0.12554973f, -0.24498515f, 0.10652899f, 0.19743757f, 
    -0.02675858f, 0.03795442f, -0.18467963f, 0.11311208f, 0.15406229f, 0.02665559f, 0.21147065f, -0.03414922f, 
    -0.13859040f, 0.12619637f, -0.14736785f, -0.07034086f, -0.03352523f, -0.14502802f, -0.01193089f, -0.00766964f, 
    0.44576862f, 0.39263391f, 0.19150127f, -0.08742843f, 0.21578343f, -0.01347152f, 0.11682911f, 0.26516169f, 
    -0.01243490f, -0.12024059f, -0.07209650f, 0.09110025f, 0.38737926f, 0.13530059f, 0.12668476f, 0.32502717f, 
    -0.00255339f, 0.21271241f, -0.02368857f, 0.22498123f, 0.08200469f, 0.10822728f, 0.24373285f, 0.03736512f, 
    0.55522937f, -0.05878031f, -0.18358758f, 0.05004197f, 0.06876788f, -0.09688985f, -0.00889406f, -0.01584599f, 
    0.17605016f, 0.10313272f, -0.05188293f, 0.05016497f, 0.23669644f, 0.09067877f, 0.37029722f, 0.04828970f, 
    0.09533235f, 0.14398699f, 0.06911226f, -0.01202818f, -0.18855210f, 0.04271873f, -0.14546441f, -0.24351156f, 
    0.31953800f, -0.09922281f, 0.14545062f, -0.41365799f, 0.03026045f, -0.12946843f, -0.03295096f, -0.03706232f, 
    0.05777596f, 0.07297593f, -0.04105062f, 0.07244997f, 0.26516789f, 0.05576659f, -0.14818940f, 0.24610174f, 
    -0.05079624f, -0.35439795f, -0.03180594f, -0.06446064f, -0.18188120f, 0.17046697f, -0.03064036f, -0.15182851f, 
    -1.06238365f, -0.14661154f, -0.33044538f, 0.33243513f, -0.03835369f, 0.20647204f, -0.08227035f, -0.09356365f, 
    -0.06700245f, -0.08358986f, 0.05895089f, -0.35012394f, 0.38801220f, -0.01666974f, -0.03481113f, -0.01323612f, 
    0.08872770f, 0.19996686f, -0.12108786f, 0.11706569f, -0.06497032f, 0.28170151f, -0.17409897f, 0.06984302f, 
    -0.20767711f, -0.53788060f, -0.46745625f, -0.06959331f, -0.29881027f, -0.01161604f, -0.08752158f, 0.42310408f, 
    -0.17457610f, 0.01648012f, -0.15093851f, 0.09305903f, -0.44872209f, 0.25617704f, -0.08684407f, -0.04864904f, 
    -0.01477312f, -0.00669846f, 0.16052693f, -0.05982911f, -0.10234729f, 0.17024739f, 0.12365322f, -0.00067921f, 
    -0.50559020f, -0.36406770f, -0.49111295f, -0.39247367f, -0.01970113f, 0.00979132f, -0.09104246f, 0.04173521f, 
    -0.13952079f, 0.13825110f, 0.10840718f, -0.20225020f, -0.31751621f, -1.37313592f, -0.36601812f, 0.16713504f, 
    -0.42307353f, -0.09082152f, 0.06941067f, -0.03387441f, 0.14507081f, -0.26497054f, 0.21457998f, 0.05950151f, 
    0.11835586f, -0.35412621f, 0.05519323f, 0.38265955f, 0.17189305f, 0.10639560f, 0.06406721f, -0.16397838f, 
    0.11723941f, -0.20207761f, -0.01274460f, -0.05890398f, 0.22517270f, -0.05671884f, 0.09216602f, -0.30190691f, 
    -0.03591324f, -0.12927355f, 0.00183192f, -0.01021430f, -0.16311409f, 0.10611041f, 0.01250992f, -0.03835523f, 
    -0.12222090f, -0.11986491f, 0.01239303f, -0.10302369f, -0.22929098f, -0.03690945f, 0.02321893f, 0.02141139f, 
    -0.23736091f, -0.07106255f, 0.03621302f, 0.19425613f, 0.26784226f, 0.04622953f, -0.54189789f, -0.02063457f, 
    -0.01262633f, 0.07269208f, 0.07698521f, -0.24719116f, 0.05502881f, -0.10932283f, 0.08000933f, 0.02333358f, 
    0.47105548f, 0.40486586f, 0.08695179f, -0.30970573f, -0.12568758f, -0.13045147f, 0.10107521f, -0.04544882f, 
    0.02615651f, -0.05649723f, 0.08904546f, 0.07626781f, -0.42760661f, 0.10295697f, -0.08499083f, 0.09616967f, 
    0.20863555f, 0.03818412f, -0.00950309f, 0.10351420f, -0.19714658f, -0.09174977f, -0.15895498f, 0.18086237f, 
    0.30424911f, 0.58676302f, -0.27736449f, -0.01644029f, 0.03250745f, 0.00921764f, -0.11868414f, 0.09569751f, 
    -0.25027514f, 0.02562100f, -0.01749797f, -0.10742692f, -0.42720634f, -0.05222333f, 0.16506119f, -0.07821291f, 
    0.06948075f, -0.01327332f, -0.10474177f, 0.06695470f, -0.16751251f, 0.03308813f, -0.13776645f, 0.01789790f, 
    -0.16801576f, -0.20885994f, 0.03181157f, -0.69549650f, 0.06729602f, -0.06071147f, -0.14617749f, 0.09032312f, 
    -0.23989275f, -0.14960158f, -0.05131907f, 0.13005413f, -0.89729536f, 0.26198894f, -0.18134689f, 0.06761490f, 
    0.04535889f, -0.07779864f, 0.12945670f, 0.24951127f, -0.10216368f, -0.22413361f, 0.06604994f, -0.00643422f, 
    -0.65415853f, -0.11493203f, 0.39387113f, -0.10190476f, -0.02975794f, 0.10533807f, -0.21820356f, -0.04899653f, 
    0.16735213f, 0.03420881f, -0.05825436f, -0.04045461f, -0.34355181f, -0.16693373f, -0.07922425f, -0.11154150f, 
    0.11547481f, 0.14871824f, -0.20343713f, -0.11567575f, 0.07958093f, -0.00278078f, -0.25638616f, -0.20218615f, 
    -0.42870599f, -0.46069795f, -0.12401403f, -0.06661309f, -0.06775273f, 0.13478859f, -0.05945866f, -0.19823453f, 
    0.07136941f, -0.24286555f, -0.26298308f, -0.05133892f, -0.09756277f, -0.76358151f, -0.40515581f, 0.27125219f, 
    0.05607094f, -0.06483312f, 0.10774960f, -0.22689313f, -0.10791275f, 0.04299511f, 0.15371345f, 0.18216564f, 
    -0.16954902f, 0.20014872f, 0.06325863f, 0.08137520f, 0.10080823f, -0.15685929f, 0.01789472f, 0.21270706f, 
    0.08597337f, -0.03440449f, 0.12998442f, 0.11111976f, 0.04723413f, 0.15412569f, 0.06451085f, -0.01403096f, 
    0.02409804f, 0.09887671f, 0.19271092f, 0.18135749f, 0.16498728f, 0.17651464f, 0.06544456f, 0.13633206f, 
    -0.07663468f, 0.01703677f, -0.05612316f, 0.13147162f, -0.18786280f, 0.10586813f, 0.03998805f, 0.00404306f, 
    0.11122625f, 0.00788358f, -0.02162167f, -0.05630417f, -0.17509726f, 0.15415104f, -0.17550102f, 0.45474592f, 
    0.22433724f, 0.04746916f, 0.16160245f, 0.29917821f, -0.14483625f, 0.23771504f, 0.12175749f, 0.11212159f, 
    -0.43186337f, 0.28382233f, 0.46631482f, 0.45554253f, 0.17628975f, -0.13740382f, -0.02532713f, -0.01580567f, 
    0.09555851f, 0.13055383f, 0.22010238f, 0.06403290f, -0.57711613f, 0.40519419f, -0.27240166f, 0.00277025f, 
    -0.01617330f, 0.02664330f, 0.17154621f, 0.20867972f, 0.25181165f, -0.17759547f, -0.11231931f, -0.12548213f, 
    -0.33288890f, -0.11490934f, 0.16915648f, 0.25515017f, 0.06591374f, -0.07386682f, -0.11723956f, -0.08252010f, 
    -0.12064017f, -0.12079356f, 0.03922554f, 0.17557245f, -0.09196942f, -0.19032878f, 0.23791018f, 0.49737564f, 
    -0.01716155f, -0.07623206f, 0.05539205f, 0.14269470f, 0.10581174f, 0.28324199f, 0.19842383f, 0.04974554f, 
    -0.63789690f, -0.47132230f, 0.49572477f, 0.44696727f, -0.01246246f, 0.05973421f, 0.12442827f, 0.18676066f, 
    0.17173992f, -0.10135107f, -0.18299526f, -0.10878390f, -0.05560611f, 0.17102608f, 0.01343949f, -0.09185822f, 
    0.13917544f, 0.01641189f, -0.06474383f, 0.24227048f, 0.04632360f, 0.01814161f, 0.17399992f, 0.08448444f, 
    -0.17521705f, -0.25809288f, -0.19002151f, 0.05021103f, -0.06101741f, -0.22224891f, 0.14262410f, 0.20912504f, 
    0.19738752f, 0.16634636f, -0.03987635f, -0.16360290f, -0.65635401f, 0.15870222f, -0.47366527f, -0.24112925f, 
    0.24051951f, 0.37901437f, 0.08295639f, 0.00706470f, -0.04664536f, 0.07448427f, 0.00252872f, -0.15210609f, 
    0.16908154f, 0.10368101f, 0.19328088f, 0.16908093f, -0.22676784f, -0.26844990f, 0.05008731f, 0.14346114f, 
    -0.12981203f, 0.00174916f, -0.14920537f, 0.15580322f, -0.72862518f, 0.03371213f, -0.02104724f, 0.12816240f, 
    0.03118794f, -0.34435475f, 0.15887176f, -0.12179046f, 0.08797073f, -0.21872781f, 0.06019094f, 0.18592942f, 
    0.03135962f, 0.36980936f, -0.34328404f, -0.01669565f, 0.06655120f, -0.05251328f, 0.28987345f, -0.06562160f, 
    0.03323029f, -0.18434042f, 0.08056666f, -0.17424923f, 0.17667188f, 0.01413940f, -0.03963161f, -0.55078721f, 
    -0.08167688f, -0.04586735f, -0.29730171f, -0.24723130f, -0.12181818f, -0.04916951f, -0.13338254f, -0.25530064f, 
    0.05357622f, 0.10093720f, 0.36023387f, -0.09686290f, 0.23800202f, -0.07962772f, -0.20164458f, -0.16457997f, 
    -0.06777494f, -0.10908572f, -0.11690816f, -0.09061834f, 0.05114653f, 0.10515609f, 0.22734490f, -0.09891333f, 
    -0.04016661f, 0.20391023f, -0.14058924f, -0.00256943f, -0.11854976f, 0.00737600f, 0.06883257f, -0.09620614f, 
    0.07668099f, 0.06857199f, 0.01930814f, -0.25668362f, 0.20522800f, -0.00655888f, 0.21620034f, -0.00897044f, 
    0.01092243f, 0.18534662f, 0.25242585f, 0.60826105f, -0.54970753f, -0.41899005f, -0.32583791f, -0.18168457f, 
    0.14414714f, 0.10573617f, 0.08500429f, -0.22783375f, 0.18998571f, -0.06128350f, -0.12034647f, 0.29865101f, 
    0.26817456f, -0.19094838f, -0.35933802f, 0.11572228f, 0.01510235f, 0.12680413f, -0.19690250f, -0.20536785f, 
    0.06765414f, -0.00004943f, -0.04470674f, -0.05412788f, -0.95777315f, -0.34874859f, -0.31395286f, -0.03413481f, 
    0.19446823f, -0.03990837f, 0.03362012f, -0.09868198f, -0.06890521f, 0.07663605f, 0.10226369f, 0.09474507f, 
    0.14781085f, -0.26439226f, 0.10903627f, 0.27391240f, -0.16710696f, -0.14352764f, 0.00746148f, -0.01985613f, 
    0.02892346f, 0.07472899f, -0.22901036f, -0.08972903f, 0.28749931f, -0.17816943f, -0.42610571f, -0.38196701f, 
    -0.05355469f, -0.02726512f, -0.06437057f, -0.10213980f, -0.02334281f, -0.17198861f, -0.18201640f, 0.02296982f, 
    0.12765321f, 0.00739667f, -0.06760681f, 0.14985165f, -0.15980722f, -0.06496727f, 0.21055701f, 0.00305476f, 
    -0.05221098f, 0.10396534f, 0.08657788f, 0.17872922f, 0.37827444f, -0.32826382f, 0.18887267f, -0.47247910f, 
    0.13334957f, 0.11155727f, 0.32813156f, 0.06496540f, 0.19559751f, 0.03675673f, 0.00248836f, -0.29846445f, 
    0.24391669f, -0.05349848f, 0.24319793f, 0.11564990f, 0.12768838f, -0.04543049f, -0.00748010f, -0.18285704f, 
    -0.27277404f, -0.18439896f, 0.23182832f, -0.06334200f, 0.10749078f, -0.39310041f, -0.03512618f, -0.41434461f, 
    -0.25414655f, -0.02192826f, -0.09487941f, -0.34181479f, 0.06133727f, 0.06182285f, 0.03523247f, 0.26551917f, 
    0.12297507f, 0.30784065f, -0.09545366f, -0.39886013f, 0.31124166f, 0.06316710f, -0.03842432f, 0.00138027f, 
    -0.07295770f, 0.04882467f, 0.04533271f, -0.02009932f, -0.05056276f, -0.06056075f, 0.10495244f, 0.10876556f, 
    0.14400436f, 0.30402517f, 0.23028304f, 0.00911521f, -0.18613917f, 0.01068186f, -0.09092553f, 0.35771233f, 
    -0.23136677f, 0.26110926f, -0.12424237f, 0.60872436f, -0.06043094f, 0.18910488f, -0.27999794f, 0.12972502f, 
    0.11621854f, 0.16324227f, -0.05872823f, -0.21981871f, -0.56032085f, -0.08246555f, 0.20250487f, 0.13045587f, 
    -0.04635761f, -0.11140672f, 0.20940484f, 0.19758375f, 0.05667863f, 0.00464003f, 0.23811501f, 0.29155529f, 
    -0.70259970f, -0.19605552f, 0.13849823f, 0.15682717f, -0.43270579f, 0.00210549f, 0.20086780f, 0.14446290f, 
    -0.11409455f, -0.02057735f, 0.02616628f, 0.18261087f, 0.16346261f, 0.32565334f, 0.18753478f, -0.52519542f, 
    -0.16496344f, -0.12877014f, -0.00162578f, 0.13018367f, 0.11644305f, 0.06442623f, -0.09153518f, 0.17628631f, 
    0.37691849f, 0.38308358f, 0.34405518f, -0.81590676f, -0.29242080f, 0.18520428f, 0.00262254f, 0.07765710f, 
    0.00691578f, -0.14305738f, -0.38559681f, -0.30441615f, -0.48762101f, 0.06148908f, -0.22958210f, -0.34726655f, 
    -0.00012975f, -0.02241877f, -0.15120833f, -0.06317126f, 0.11447564f, -0.00685775f, 0.05544065f, -0.16162108f, 
    -0.24166799f, -0.27684703f, -0.35918006f, 0.09500632f, -0.05004245f, -0.13282466f, 0.22889473f, -0.09210991f, 
    -0.11730501f, 0.17569186f, 0.17774555f, 0.07322805f, -0.38655484f, -0.41192135f, -0.01810195f, -0.33381227f, 
    -0.30535388f, 0.03696602f, 0.23045620f, -0.00292938f, -0.16456369f, 0.02734199f, -0.10302690f, -0.23196857f, 
    0.77727652f, -0.15574816f, 0.49069366f, 0.50885314f, 0.09705014f, -0.11083638f, 0.02317389f, -0.09989096f, 
    -0.06457618f, -0.02304472f, -0.20101599f, -0.23257364f, -0.04306065f, 0.04967532f, -0.01279031f, 0.33232793f, 
    -0.37025231f, 0.03133832f, -0.08920787f, -0.10606555f, -0.09006727f, -0.00197160f, -0.21810743f, -0.14975850f, 
    -0.30827671f, 0.00377938f, 0.01019500f, -0.06136882f, 0.04916074f, -0.09737141f, -0.04800894f, -0.08068673f, 
    0.01639651f, -0.09532484f, -0.19971006f, -0.24115549f, 0.67086047f, -0.03050416f, 0.12142572f, 0.00354154f, 
    -0.29298857f, -0.11975171f, 0.01800628f, -0.28400946f, -0.07237477f, 0.02573973f, -0.03624275f, -0.05688277f, 
    0.31747419f, 0.18840016f, 0.21705613f, 0.19091140f, 0.14939794f, 0.02560100f, -0.01931222f, 0.04883401f, 
    0.20871130f, -0.13025679f, -0.00795315f, -0.07560290f, 0.05564030f, 0.04138325f, 0.36614820f, 0.25200260f, 
    0.03190605f, 0.12276730f, 0.05991880f, -0.05242535f, -0.20050301f, 0.06616217f, 0.03130367f, 0.03033323f, 
    0.06143465f, -0.59204513f, -0.20699561f, -0.06122419f, 0.04351662f, -0.15863720f, -0.04144011f, -0.14435464f, 
    -0.12833051f, -0.07280228f, 0.04263480f, 0.04085409f, -0.01375600f, -0.15661305f, -0.16599680f, -0.17299488f, 
    -0.05207373f, -0.05796367f, -0.15916780f, -0.02212435f, -0.31737027f, 0.06278753f, -0.04982569f, -0.24829911f, 
    -0.85600656f, 0.23744947f, -0.04273902f, -0.15489578f, -0.07299031f, 0.01794318f, -0.12855430f, -0.15163183f, 
    -0.11477356f, 0.03357043f, -0.06025119f, -0.03264766f, 0.33852205f, -0.04830458f, -0.13597813f, 0.23333469f, 
    -0.09315863f, 0.03696239f, -0.10433985f, -0.15937833f, -0.03933734f, 0.05322815f, -0.12748551f, 0.00712790f, 
    0.01018371f, 0.18512145f, -0.19671312f, -0.18853235f, -0.23999579f, 0.15695022f, 0.10252520f, -0.12685657f, 
    0.03968954f, -0.02780379f, 0.01695797f, -0.13863730f, -0.52165234f, 0.22274451f, 0.14993250f, -0.28455377f, 
    -0.14553446f, -0.05788466f, -0.01778633f, -0.10376660f, -0.04584006f, 0.00962237f, -0.15819761f, -0.01366876f, 
    -0.91071576f, 0.30202138f, -0.30446002f, -0.41295323f, -0.00710230f, -0.04038781f, -0.11086376f, -0.06973048f, 
    -0.01901632f, 0.05014603f, -0.01605911f, -0.22518511f, 0.42689869f, 0.26733962f, 0.53827429f, 0.19896831f, 
    0.20962219f, 0.15689473f, 0.09537663f, 0.11537535f, 0.03457418f, 0.15852860f, -0.24320313f, -0.19346146f, 
    -0.09804220f, 0.41727009f, 0.18109675f, 0.31935248f, 0.13393477f, 0.11480313f, 0.35402393f, -0.04470064f, 
    0.10576327f, 0.12168441f, -0.00996485f, -0.10436402f, -0.38660148f, 0.13960350f, 0.15431277f, -0.15963165f, 
    -0.10913657f, 0.05324792f, -0.17187880f, -0.27292350f, -0.10245841f, 0.00286746f, -0.14172691f, -0.24574775f, 
    0.19533314f, 0.10361343f, -0.18504788f, -0.13305551f, 0.00903766f, -0.04246221f, -0.05176202f, -0.12821075f, 
    -0.16475500f, 0.00663386f, 0.00540752f, -0.04249875f, -0.30629408f, 0.32795987f, -0.27803531f, -0.27175698f, 
    -0.17437607f, 0.08300370f, 0.07426754f, -0.11597763f, 0.14269857f, 0.18573736f, -0.04114355f, 0.14250450f, 
    0.24515343f, 0.28605694f, 0.32295054f, -0.11336685f, 0.02680589f, -0.20029762f, -0.27330837f, -0.03544124f, 
    0.20757331f, -0.06894252f, 0.00004117f, -0.09615795f, -0.50865608f, -0.66045809f, -0.05995308f, -0.34843212f, 
    -0.10283743f, -0.36631361f, 0.07257795f, -0.08577124f, -0.02706265f, -0.06731459f, -0.20913565f, 0.36432943f, 
    0.13272843f, -0.14816102f, 0.07445535f, -0.09976757f, 0.14796014f, 0.15456101f, 0.17278293f, 0.25241733f, 
    -0.05383245f, 0.09322999f, 0.07268663f, 0.01098224f, -0.38894951f, -0.05648409f, 0.34105572f, -0.02107909f, 
    -0.07394638f, 0.11599357f, -0.14330493f, -0.06452411f, 0.13041063f, 0.09458756f, -0.26027030f, -0.37656760f, 
    -0.09668622f, -0.33512616f, -0.49808589f, 0.03142179f, 0.15995483f, -0.16430344f, 0.02507146f, 0.03353433f, 
    0.26506820f, 0.14033945f, 0.07089804f, 0.15511869f, -0.21700999f, 0.23791626f, 0.09907059f, -0.17209752f, 
    0.00825156f, -0.14709054f, -0.06065933f, -0.32377031f, 0.12486433f, -0.11778826f, -0.01799779f, 0.07962014f, 
    0.36896056f, 0.27035207f, -0.44874194f, -0.01912214f, 0.01072221f, -0.04329350f, -0.09275870f, -0.11947400f, 
    0.09105455f, 0.04145242f, 0.06079448f, 0.16039133f, -0.18346240f, 0.32212991f, -0.07060742f, -0.01226673f, 
    -0.14518923f, -0.11139335f, -0.22763196f, 0.02347332f, 0.01886271f, 0.00616373f, -0.48016578f, -0.24594344f, 
    0.45920518f, 0.22545530f, 0.20640826f, 0.02155143f, -0.07173668f, -0.04343875f, -0.03595159f, -0.18526220f, 
    0.02250675f, 0.04500530f, -0.00559232f, -0.18310852f, 0.28460994f, -0.14999451f, 0.09847677f, 0.63136137f, 
    0.26051939f, -0.03581263f, -0.12841591f, -0.12221615f, 0.05407711f, -0.05900724f, 0.25297803f, -0.16297197f, 
    -0.32446638f, -0.30812737f, 0.01270416f, 0.17630351f, 0.05073836f, -0.07070106f, -0.12198385f, -0.11307088f, 
    -0.07163631f, 0.18087354f, 0.21631068f, 0.15391706f, -0.28368095f, -0.12807873f, 0.17909732f, -0.18571451f, 
    -0.12082843f, -0.04725453f, -0.43304521f, -0.48484239f, 0.03501420f, -0.18013766f, 0.05298414f, 0.32851356f, 
    0.08014355f, 0.34774423f, 0.03096665f, 0.18117045f, -0.37783676f, 0.20843974f, -0.58690363f, 0.01061112f, 
    0.03474779f, -0.21400093f, 0.07054242f, -0.12872109f, -0.29108810f, -0.13699064f, 0.52682936f, 0.10537773f, 
    -0.03052059f, -0.14529665f, -0.19459701f, -0.04160305f, -0.13389933f, 0.07404969f, 0.21558940f, -0.04716730f, 
    -0.32926419f, -0.70441753f, 0.16139522f, -0.35609266f, 0.11481087f, -0.09455130f, 0.03672240f, -0.00829933f, 
    -0.14239527f, -0.02053073f, 0.04672970f, 0.02809536f, -0.57523727f, 0.22906852f, -0.15388927f, 0.26870906f, 
    0.18944539f, 0.13968524f, 0.15777014f, -0.12330458f, 0.09668323f, -0.06141067f, 0.09663209f, -0.05082706f, 
    -0.20379800f, -0.18006879f, -0.67613006f, -0.23271468f, -0.12505125f, 0.04643811f, -0.15009513f, -0.02661478f, 
    -0.07827894f, -0.08427044f, 0.22075963f, 0.20796981f, 0.44670117f, 0.28087547f, -0.44169870f, 0.18638361f, 
    -0.02991681f, -0.15320355f, -0.01267982f, 0.12451548f, -0.07810045f, 0.06549752f, 0.11069915f, -0.21536978f, 
    0.18071653f, 0.26272357f, -0.04742832f, 0.19047852f, 0.02303994f, 0.06335341f, -0.00273135f, -0.28804818f, 
    -0.15877753f, 0.22273591f, -0.17632313f, 0.27762040f, -0.04366542f, -0.29184946f, 0.15659638f, 0.41377398f, 
    0.05696252f, -0.18238041f, 0.11222731f, -0.08752687f, 0.08848413f, -0.26103166f, -0.16467085f, -0.02723358f, 
    0.00155046f, -0.16158669f, 0.35420310f, -0.36954811f, -0.01536211f, -0.01218841f, -0.13606448f, -0.18808709f, 
    -0.01183188f, -0.20745437f, 0.05759942f, -0.06618367f, 1.21845901f, -0.01886543f, 0.12223644f, -0.49757653f, 
    -0.14218636f, -0.01071415f, 0.10106138f, 0.07276729f, 0.01329370f, -0.11037657f, 0.23190880f, 0.14989512f, 
    0.15492563f, 0.26657954f, 0.58438045f, 0.00700552f, -0.00880532f, 0.16430049f, -0.01483922f, -0.25714251f, 
    -0.04436139f, -0.18534870f, 0.10816054f, 0.01030034f, -0.21304119f, 0.50662738f, -0.05721786f, 0.28212041f, 
    -0.17714760f, 0.15444726f, -0.02326471f, 0.34114566f, 0.21833126f, 0.10847871f, 0.24560244f, 0.10608962f, 
    -0.10964377f, 0.30657810f, -0.33620697f, 0.13735248f, 0.05157565f, 0.04472681f, 0.09174073f, 0.02702626f, 
    0.10640214f, 0.11548109f, -0.00006479f, 0.03779031f, -0.53996468f, 0.05193258f, -0.31882596f, 0.02115633f, 
    0.21008103f, -0.10107961f, 0.09536719f, -0.16419534f, -0.15142870f, -0.08904283f, -0.20316885f, -0.07762869f, 
    -0.58173108f, 0.55674058f, 0.04210276f, -0.62466174f, 0.20154479f, -0.05950951f, -0.10619280f, -0.05177852f, 
    0.04297215f, 0.16417944f, -0.18723941f, -0.31861633f, -0.27864751f, -0.66478586f, -0.20335515f, 0.04162330f, 
    -0.10870370f, -0.10257591f, -0.11569928f, 0.14967279f, -0.08097170f, 0.20342734f, 0.09535677f, -0.37743840f, 
    -0.23980030f, -0.32078028f, 0.06712505f, -0.13185138f, 0.22000678f, 0.07200970f, -0.14698303f, 0.24112284f, 
    0.00287499f, 0.01381178f, -0.10731705f, 0.20158654f, 0.22918363f, -0.13818380f, -0.01847443f, -0.21652536f, 
    0.04232752f, -0.02708132f, -0.02350486f, -0.09884511f, -0.05780761f, 0.04714926f, -0.10003035f, 0.02857130f, 
    -0.62233925f, 0.16004691f, -0.34591502f, -0.18049648f, 0.15361844f, -0.03725059f, -0.10263185f, -0.04193932f, 
    0.18996531f, 0.24365684f, 0.15972133f, 0.01140967f, 0.40660661f, 0.10799317f, -0.14527613f, 0.06169099f, 
    0.28541312f, 0.01249060f, 0.00209012f, -0.08632950f, 0.06688029f, -0.08928607f, -0.03543113f, 0.00433976f, 
    -0.53038967f, 0.20911826f, 0.06005281f, -0.50067580f, 0.29244286f, 0.12848637f, -0.01587720f, 0.10811649f, 
    0.12577651f, -0.24297766f, 0.04136867f, 0.02968250f, -0.09120385f, 0.00937950f, -0.16348611f, 0.14805356f, 
    -0.11541202f, 0.10978012f, 0.06532988f, -0.08534551f, -0.07052591f, -0.04517434f, 0.11190621f, 0.22381589f, 
    0.00137911f, 0.23044768f, -0.12545162f, 0.17932652f, -0.14155482f, 0.08697058f, 0.19061024f, -0.02420775f, 
    0.01664869f, 0.20713554f, 0.27787724f, -0.05975683f, 0.53462422f, 0.08323935f, -0.00394470f, 0.05167485f, 
    -0.20707148f, -0.07683216f, -0.07048088f, -0.03461050f, -0.04432753f, 0.01410712f, 0.06418462f, 0.07865346f, 
    -0.42772096f, 0.29696167f, 0.05681372f, -0.12778297f, 0.03471378f, -0.12054951f, 0.15178388f, 0.08965528f, 
    -0.06021990f, 0.08185331f, 0.06423156f, 0.16950920f, -0.36930242f, 0.05295376f, 0.15869468f, 0.16237594f, 
    0.25433281f, -0.07150552f, 0.07283577f, -0.12211102f, 0.13895693f, 0.25920340f, 0.32671455f, -0.14832994f, 
    -1.22978973f, -0.66362876f, 0.02511214f, 0.26394132f, 0.37247077f, -0.06350067f, 0.16554493f, -0.02603688f, 
    0.25110075f, 0.20251468f, 0.14149708f, 0.18961985f, -0.02104166f, -0.23029296f, 0.06124939f, 0.07930876f, 
    -0.18978776f, -0.01275435f, 0.12127794f, 0.05824306f, 0.21505952f, -0.14699541f, -0.32916078f, -0.21651778f, 
    -0.64894414f, -0.42063084f, -0.26888198f, -0.44529665f, 0.02266812f, 0.20828976f, 0.14587343f, -0.18423489f, 
    0.12378567f, -0.35618553f, -0.14214361f, -0.13582337f, -1.67427897f, -0.37870678f, -0.41717929f, -0.63005465f, 
    0.29717463f, -0.02234339f, -0.28211972f, -0.18765107f, -0.11640919f, -0.10698480f, 0.09505482f, -0.01248043f, 
    -0.26946041f, -0.10388951f, -0.25449610f, -0.26197499f, 0.02728271f, -0.23189564f, -0.09223581f, 0.11083031f, 
    -0.00137487f, 0.19464929f, 0.27993467f, 0.18559416f, 0.07466537f, 0.18441944f, -0.00196662f, -0.29116857f, 
    0.02438863f, 0.12790175f, -0.04189569f, -0.14749891f, 0.03578361f, -0.22003241f, 0.06863971f, -0.05790742f, 
    0.35886446f, 0.10782544f, -0.13731559f, -0.07808855f, -0.43838114f, -0.01757705f, -0.07681493f, 0.10634855f, 
    0.14533041f, -0.15679656f, 0.07798601f, -0.28482980f, 0.23075941f, -0.03816859f, 0.02214690f, 0.16395263f, 
    -0.11553179f, -0.19908562f, 0.05731639f, 0.31970450f, 0.17035457f, 0.00376745f, 0.04339919f, 0.20786785f, 
    -0.14417173f, -0.14065848f, 0.00888566f, 0.76616234f, -0.16752632f, 0.15742986f, -0.04397333f, 0.19485536f, 
    0.03495200f, -0.15210529f, 0.14625122f, 0.02379890f, 0.12629665f, -0.35005903f, -0.19312085f, 0.29721630f, 
    0.16284129f, -0.06846330f, 0.23995557f, -0.09587537f, -0.03965735f, -0.04870886f, -0.25859800f, 0.06925626f, 
    -0.29695964f, -0.44541532f, 0.11806686f, 0.09074043f, -0.03562755f, 0.04129783f, -0.10471037f, 0.04224590f, 
    -0.06935530f, 0.28180453f, 0.11517586f, 0.03364365f, -0.51923299f, 0.14462444f, 0.26150414f, -0.22970635f, 
    -0.04417833f, -0.04937616f, 0.03856818f, -0.21557453f, 0.18454756f, -0.05731001f, 0.07107255f, 0.04181733f, 
    -0.40143877f, 0.18805085f, 0.00281265f, -0.00388776f, 0.16737223f, 0.12203339f, -0.17086500f, 0.00413079f, 
    -0.01424861f, -0.09080990f, 0.21383046f, -0.26496696f, -0.13414472f, 0.03773696f, 0.02926252f, -0.15296575f, 
    -0.00130480f, 0.13826428f, -0.02116788f, -0.32868215f, 0.04668966f, 0.10920922f, 0.17385410f, 0.04777582f, 
    1.11814332f, -0.03219730f, -0.27956969f, -0.31944230f, 0.07846634f, -0.09006307f, -0.06106014f, 0.07881249f, 
    -0.02433972f, -0.12365144f, 0.09447391f, 0.05078941f, 0.18193613f, -0.10875382f, -0.07425794f, -0.35959288f, 
    0.11256204f, -0.08935621f, -0.34679815f, 0.31335890f, 0.04987697f, -0.07615682f, 0.09360035f, -0.23461843f, 
    0.52643317f, -0.26412109f, 0.01732714f, 0.06088321f, 0.08733748f, 0.03669667f, -0.22137141f, 0.00839222f, 
    0.07969366f, 0.10616540f, -0.00119191f, 0.01435083f, -0.26563439f, 0.21703520f, -0.24327904f, 0.19350548f, 
    0.20713399f, -0.23144160f, 0.18693085f, 0.13887100f, 0.13847969f, 0.13060296f, -0.02105718f, 0.04552416f, 
    -1.20161903f, -0.59708315f, -0.02107508f, -0.31019181f, 0.14143050f, 0.05081407f, -0.04903015f, 0.11896486f, 
    -0.01797418f, -0.15022120f, 0.08071862f, -0.00566487f, 0.50208175f, -0.17835742f, -0.10578887f, -0.54847407f, 
    0.10617907f, -0.20770700f, -0.05505101f, -0.04361465f, 0.05350237f, 0.00090604f, -0.14204137f, 0.00869692f, 
    0.17778428f, -0.17878954f, -0.20681696f, 0.20359287f, 0.03617001f, -0.14045532f, 0.06597968f, 0.10208133f, 
    -0.13097474f, -0.06332406f, -0.08258728f, -0.03976611f, -0.26393694f, 0.45470729f, -0.09134948f, -0.12498995f, 
    -0.01729153f, -0.17811625f, -0.08448695f, -0.26434493f, 0.07299694f, 0.26539057f, 0.00230906f, -0.30670547f, 
    -0.16052176f, -0.14353079f, -0.20742472f, 0.06044951f, -0.08837712f, -0.11536747f, 0.23241103f, -0.23191844f, 
    -0.20864856f, 0.09223077f, 0.10690664f, -0.22546361f, 0.43231541f, -0.00368694f, 0.10268610f, 0.01219133f, 
    -0.05257902f, 0.13205872f, 0.10642234f, 0.03396481f, -0.02865702f, -0.22882003f, -0.06232441f, 0.04288107f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18942045f, 0.08583739f, -0.11947671f, -0.01763399f, 0.07218580f, -0.03971792f, 0.05515294f, -0.25688642f, 
    -0.04765955f, 0.08339883f, 0.28531173f, -0.02172397f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
