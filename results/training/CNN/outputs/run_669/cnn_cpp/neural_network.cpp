#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.74451923f, 0.97242612f, 0.81088638f, -0.42710379f, -0.34743795f, -0.10849689f, 0.46555573f, -0.19714671f, 
    0.45610550f, 0.45046860f, 0.53359395f, 0.68460089f, -0.16313232f, -0.40628129f, -0.25997525f, 0.32394409f, 
    0.07011425f, -0.00864071f, 0.13513905f, -0.31466156f, -0.51161861f, 0.11988009f, -0.11103193f, 0.10662403f, 
    0.13505737f, 0.60267502f, 0.86664927f, 1.21132147f, 1.08658278f, 0.49689054f, -0.83133680f, -0.15426461f, 
    -0.55597401f, -1.13190997f, 0.05812088f, 0.12290253f, -0.00659758f, -0.60444391f, 0.55691743f, 0.05938278f, 
    -0.35254532f, -0.50361270f, -0.44048664f, 0.24242252f, -0.47370291f, 0.15305145f, 0.17410859f, -0.11464547f, 
    0.10541203f, 0.43858275f, 0.25847009f, -1.80055535f, -1.23424530f, -0.05270891f, -0.07368609f, -1.24551296f, 
    0.45022199f, -0.14266448f, -0.73321217f, 0.31153232f, 0.47637591f, 0.86373764f, 0.18342683f, -0.26271439f, 
    0.12782902f, -0.23573320f, 0.36803883f, 0.07910073f, -0.07259642f, -0.24632642f, -0.01990549f, -0.49722737f, 
    0.13344471f, 0.12018002f, 0.15646277f, -0.88418740f, -1.73287678f, -0.64691490f, -0.27026603f, -0.11880644f, 
    0.17102571f, -0.56730098f, 0.42859098f, 0.28113151f, -0.28032896f, -0.30139399f, -0.14727157f, 0.15559062f, 
    0.82282430f, -0.12768985f, 0.08312557f, 0.33681959f, 0.03079326f, 0.35128388f, 0.25632110f, 0.32090205f, 
    -0.17037472f, 0.16785699f, -0.08269522f, 0.06338985f, -0.70832515f, -1.69982803f, 0.29248410f, 0.53790069f, 
    -1.03975856f, 0.58986044f, 1.40410793f, 0.72953755f, -0.21411881f, -0.07788591f, -0.16981333f, -0.51937556f, 
    -0.49632633f, 0.04190083f, -0.19497195f, -0.03493653f, 0.26062182f, -0.18941733f, -0.16857593f, -0.26484153f, 
    -0.16654047f, 0.10226744f, 0.18777101f, -0.22541869f, -0.01238581f, 1.66035414f, 0.48700279f, -0.01652069f, 
    1.25010991f, 1.23985982f, -0.64492536f, 0.19708437f, -0.23461466f, 0.40237361f, 0.33205229f, 0.44410759f, 
    0.29599798f, 0.03937393f, -0.08568434f, -0.26896340f, 0.05264372f, -0.30079848f, 0.30273145f, 0.10151517f, 
    0.43947300f, -0.21462442f, -0.01266992f, 0.53353447f, 0.06923138f, 0.23324126f, 1.44498968f, -0.38466147f, 
    -0.23257694f, 1.70487678f, 1.10626650f, 0.60481542f, 0.67871350f, -0.14561564f, 0.58916241f, 0.56671965f, 
    -0.79765147f, -0.45623517f, -0.15039012f, 0.16271473f, 0.20375445f, 0.11302839f, 0.24711052f, 0.12151889f, 
    -0.01628835f, 0.26211938f, 0.01498355f, 0.09382690f, -0.05382534f, -0.00139245f, 0.00683096f, -0.85568208f, 
    1.26808143f, -0.23671427f, -1.17939973f, 1.06157339f, 0.72550577f, -0.94730109f, -0.82518452f, -0.55187052f, 
    -0.70156753f, 0.30782971f, 0.13779971f, -0.41148934f, 0.03227077f, -0.11263256f, 0.22220059f, 0.17498058f, 
    -0.33185959f, -0.10950919f, 0.52397835f, 0.08052717f, 0.24504812f, 0.51225185f, -0.02155781f, -0.29928747f, 
    0.69370061f, 0.56604850f, 1.16835451f, 1.11733460f, 0.81554651f, 0.97027910f, 0.10776426f, 0.26727316f, 
    0.15915601f, 0.33528137f, -0.33962017f, -0.22838701f, -0.49152580f, 0.11087931f, -0.41184756f, -0.30018863f, 
    0.28362817f, 0.22350565f, -0.09000444f, -0.66178548f, -0.06781486f, 0.06701805f, -0.53468364f, -0.44249827f, 
    -0.04692382f, 1.42394602f, 0.57608438f, -1.26994824f, 0.21023571f, -0.29636779f, -0.79574245f, -0.12128089f, 
    0.53053647f, 0.56238317f, 0.18583111f, -0.20391914f, -0.51497126f, 0.53765649f, -0.33418477f, 0.58300942f, 
    0.19296014f, -0.30198282f, -0.35497311f, 0.17999934f, 0.53721225f, 0.53472281f, 0.04557564f, -0.01583314f, 
    -0.16685528f, -0.51967615f, -1.10815310f, -0.81385082f, 0.03445179f, 0.37946987f, 0.86191714f, -1.25805616f, 
    1.08244157f, 0.86673790f, -0.54515833f, 0.59175575f, -0.07731294f, 0.37091625f, -0.06655607f, -0.34980184f, 
    0.41854870f, -0.22313789f, -0.30179441f, -0.08018093f, -0.19063039f, 0.02966142f, 0.06480701f, -0.13230203f, 
    0.11773126f, -0.05703436f, -0.01366970f, 1.06796515f, -0.21224999f, 1.30974591f, -0.06521711f, -0.55743229f, 
    0.87774163f, -0.70119125f, 0.26461688f, -0.16005296f, -0.37495187f, 0.69496942f, 0.27650949f, 0.14345884f, 
    0.20314325f, 0.34272277f, 0.25955293f, 0.28203323f, -0.01962341f, 0.40258974f, 0.27624685f, 0.55567169f, 
    0.64152688f, 0.38809088f, 0.29210311f, 0.38691375f, 0.21019956f, -0.24829437f, 0.71945989f, -0.62599450f, 
    1.32571709f, -0.06659377f, 0.28423044f, 0.90135026f, 0.34817919f, -0.93762070f, 0.25764462f, 0.12020307f, 
    -0.31187445f, 0.08695401f, 0.23421802f, 0.10290704f, -0.01234555f, 0.03742871f, 0.15073192f, 0.85583639f, 
    -0.09668140f, -0.18495475f, -0.23221944f, -0.04892099f, 0.31399208f, -0.40972090f, -0.43265274f, 1.43536544f, 
    0.48686555f, -1.53649449f, -0.82090813f, -0.60709053f, 0.79777014f, -0.33482957f, 0.07792865f, -0.00826433f, 
    0.05782866f, -0.04330967f, -0.24572244f, -0.11956865f, -0.07697453f, 0.07498115f, -0.09850813f, -0.13312645f, 
    -0.29283971f, -0.13040669f, -0.28278819f, -0.45643890f, -0.43393674f, -0.08750769f, -0.93947637f, -0.54979926f, 
    0.06240364f, 1.05665362f, -0.33297643f, 0.44670489f, 0.32879287f, 0.37397411f, -0.70399719f, -0.99898767f, 
    -0.18529840f, 0.57472003f, 0.54330850f, 0.33091572f, 0.44736513f, -0.04076928f, 0.02104840f, -0.22715138f, 
    -0.70433575f, 0.28854537f, 0.45762664f, -0.08491004f, -0.38722676f, 0.21674137f, 0.14275707f, -0.31638786f, 
    -0.76496273f, -1.30379546f, -0.55370051f, -0.24091050f, -1.00977004f, 0.99478608f, 1.32562780f, 0.73859018f, 
    0.42205679f, -0.09858806f, -0.38050699f, 0.24599542f, -0.50495189f, -0.67866254f, 0.05455587f, 0.15873092f, 
    0.10221102f, -0.08633499f, -0.31645003f, 0.02953256f, -0.06057057f, -0.42730284f, -0.04107864f, -0.17024906f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.26030535f, 0.41048414f, 0.48814851f, 0.48731601f, 0.22939298f, 0.03509995f, 0.34378779f, 0.08272698f, 
    0.46698257f, 0.15093090f, 0.26991263f, 0.33815488f, 0.14824171f, 0.30841312f, 0.27918154f, 0.04351001f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04755962f, 0.15702756f, -0.01157152f, -0.13644536f, -0.31584394f, -0.19031568f, -0.28975150f, 0.15882248f, 
    0.06176487f, 0.05041328f, -0.05712852f, -0.22653408f, 0.41239411f, 0.07834166f, -0.23556770f, 0.15993743f, 
    -0.26665205f, -0.06591287f, -0.18214837f, -0.08894988f, -0.25772271f, -0.06391798f, -0.10006002f, -0.04722760f, 
    -0.61679083f, -0.69432288f, 0.22648546f, 0.03019696f, -0.20571263f, -0.15895699f, -0.06151825f, -0.16098885f, 
    -0.06458762f, -0.12550147f, -0.26684985f, 0.01074440f, -0.15698910f, 0.08771703f, -0.34195280f, -0.24087593f, 
    -0.00744448f, 0.07900957f, -0.02353578f, 0.10867438f, 0.24111098f, 0.03194524f, -0.13905278f, -0.12405424f, 
    -0.10597466f, 0.60920888f, 0.17198318f, 0.00276731f, 0.05762636f, 0.09051153f, -0.02262501f, 0.14769046f, 
    -0.05762348f, -0.02409390f, -0.01632879f, 0.17097338f, 0.64934856f, -0.22096212f, -0.06178812f, 0.55271053f, 
    -0.35015893f, 0.06506632f, -0.27848148f, 0.22751684f, -0.07585023f, 0.01585886f, 0.02046392f, -0.19857688f, 
    0.35518464f, -0.24325147f, -0.05038084f, 0.86357921f, -0.22112432f, -0.03662311f, -0.00845776f, 0.06078297f, 
    -0.08403886f, 0.04628538f, 0.08666299f, 0.08756560f, -0.46425003f, 0.08224109f, 0.52693307f, -0.41230139f, 
    0.01364330f, 0.06634773f, 0.10697947f, -0.21788606f, 0.10143227f, -0.09556261f, 0.00640345f, 0.02764723f, 
    0.16766456f, -0.10996017f, -0.08590987f, 0.20585959f, -0.19372968f, -0.03497019f, 0.26652178f, -0.08537804f, 
    -0.04297045f, 0.07093814f, 0.01984386f, -0.17433701f, -0.24142474f, -0.16052416f, -0.08603109f, -0.20703936f, 
    -0.34921989f, 0.05442802f, -0.06620070f, 0.06154388f, -0.10271310f, -0.07890498f, 0.21213968f, 0.19774051f, 
    -0.56803101f, 0.16879852f, -0.14007749f, 0.12035850f, -0.13779207f, 0.00089012f, -0.18743637f, 0.04896972f, 
    0.00265736f, 0.08804285f, 0.04970521f, 0.20290709f, 0.27228737f, -0.14729962f, -0.09938546f, -0.14858440f, 
    -0.17296946f, 0.16621462f, -0.11369708f, -0.22743963f, -0.02000684f, 0.02319940f, -0.02452325f, 0.09722194f, 
    -0.06847332f, 0.21340552f, -0.11458798f, -0.40738946f, -0.17687073f, 0.19316696f, 0.11924002f, 0.05308470f, 
    0.30338016f, -0.17660902f, 0.21247987f, -0.00536191f, -0.42882925f, -0.06139461f, -0.31662109f, 0.74166709f, 
    -0.03750706f, 0.01920408f, 0.13672642f, -0.23645613f, -0.04351655f, 0.02449123f, -0.05432989f, 0.04485441f, 
    -0.10106550f, 0.24351013f, 0.24077627f, 0.21324331f, 0.08547466f, 0.06387293f, 0.05276200f, 0.00652071f, 
    0.28587958f, -0.00974561f, -0.01666356f, -0.12583160f, -0.42633936f, 0.64404464f, -0.40764114f, -0.50270450f, 
    0.03877722f, 0.08692180f, -0.05208100f, -0.10802455f, -0.05511897f, 0.08179457f, -0.07359724f, 0.16717467f, 
    0.60447180f, 0.11533747f, -0.01545079f, 0.11634380f, 0.07766403f, -0.18636067f, -0.04407966f, -0.20705363f, 
    -0.13950936f, -0.16680110f, -0.05667963f, 0.08169809f, -0.02865265f, 0.02683351f, 0.02094059f, 0.28441387f, 
    -0.11609475f, 0.21386114f, 0.14903560f, 0.11054534f, 0.13770683f, 0.06352423f, -0.15745781f, -0.23616979f, 
    0.35876894f, -0.20438142f, -0.05588716f, 0.13389248f, 0.01969076f, 0.06577361f, 0.00324318f, 0.04142997f, 
    -0.00491064f, -0.09184810f, 0.16083112f, 0.05980641f, 0.26331630f, 0.02807664f, -0.01750926f, -0.19873479f, 
    -0.21452527f, 0.05008287f, 0.14692982f, 0.18879570f, 0.08880175f, 0.06663957f, -0.04130907f, 0.19341581f, 
    -0.18165168f, -0.11392330f, -0.45344865f, 0.19070999f, -0.18046775f, -0.22791146f, 0.03512240f, 0.03375546f, 
    0.08259059f, 0.15805334f, -0.13757364f, 0.07844801f, 0.38670972f, -0.24517347f, 0.22307599f, 0.46282712f, 
    -0.03798111f, -0.09264254f, -0.02702191f, -0.16266696f, 0.01159948f, -0.06216964f, -0.01605076f, 0.03090634f, 
    0.62120289f, -0.20669797f, -0.05689367f, 0.18041959f, -0.12504043f, 0.11821358f, -0.16101500f, 0.11940003f, 
    0.12803662f, 0.31419933f, 0.03881830f, -0.11118101f, -0.18517014f, -0.02024081f, -0.09131341f, -0.70020431f, 
    -0.00931297f, 0.00414397f, 0.13784404f, -0.18971898f, 0.00436250f, 0.18073194f, 0.03613244f, 0.07008378f, 
    0.47340137f, 0.09170190f, 0.09969525f, 0.22657970f, -0.32739562f, 0.11155884f, -0.04620863f, 0.14583114f, 
    -0.07317075f, -0.18580635f, 0.01023473f, -0.06925409f, 0.46028873f, -0.32675073f, -0.06139159f, -0.05575767f, 
    -0.07974030f, -0.31303406f, 0.02682281f, 0.15870924f, -0.19774000f, 0.17477521f, -0.39274594f, 0.06686644f, 
    0.03543264f, -0.00228301f, -0.03815084f, -0.20199057f, -0.01647567f, 0.12418319f, -0.10788010f, -0.05456541f, 
    0.03998994f, 0.07684987f, 0.08331205f, -0.07665239f, -0.35758647f, 0.19488434f, 0.24935783f, -0.03916242f, 
    -0.06490473f, 0.00246812f, 0.04157457f, -0.00967585f, -0.07018139f, 0.14787422f, 0.11933921f, 0.07202540f, 
    -0.32543063f, 0.03695736f, 0.08354076f, 0.21683675f, 0.01025773f, -0.03241855f, -0.17695983f, 0.03881129f, 
    -0.35484543f, 0.04102676f, -0.10415626f, 0.05078020f, -1.17560244f, -0.01441399f, -0.36300078f, -0.28315955f, 
    -0.21922770f, -0.13625380f, -0.12637404f, -0.15673785f, -0.18977429f, -0.21954167f, -0.06663039f, -0.07498273f, 
    -0.51075780f, 0.06469931f, -0.37230548f, 0.35178649f, -0.41180453f, 0.00656123f, -0.06182329f, -0.07128203f, 
    -0.01227630f, -0.02026718f, 0.07105834f, 0.00175081f, 0.46150699f, -0.47426143f, -0.05482094f, -0.35564041f, 
    0.15942545f, -0.18791564f, -0.33096805f, 0.08797800f, 0.21987553f, -0.24442065f, -0.06859937f, 0.02244805f, 
    0.11285152f, 0.33218032f, 0.02217466f, -0.21551208f, -0.02303637f, -0.07989798f, 0.14653693f, 0.20258328f, 
    -0.23283660f, -0.07562000f, 0.06651514f, -0.20030795f, 0.08552645f, 0.21091290f, -0.46411633f, -0.06178309f, 
    0.21012387f, 0.15816765f, -0.13361709f, -0.17069569f, -0.08205597f, 0.04764601f, -0.02566134f, -0.21807231f, 
    1.10639882f, -0.28325292f, -0.00241293f, -0.34113738f, -0.03275032f, 0.00524058f, -0.09551653f, -0.18181075f, 
    -0.11643641f, 0.04688652f, -0.00749944f, -0.23956136f, -0.41068751f, -0.10892158f, -0.15620896f, 0.13876066f, 
    -0.25162870f, -0.06895717f, -0.36332762f, -0.04681980f, -0.09372516f, -0.03569099f, -0.06434205f, 0.01955183f, 
    0.32889670f, -0.25009999f, 0.14772731f, 0.03365288f, -0.32249764f, -0.19973111f, -0.08002192f, 0.16136988f, 
    0.26149422f, -0.06647459f, -0.15243523f, -0.21685635f, 0.36327294f, -0.03405760f, -0.02321874f, 0.00870450f, 
    0.18286921f, -0.01231176f, -0.02203353f, 0.14695777f, 0.03044031f, 0.13027661f, 0.13165288f, 0.02871038f, 
    -0.11223407f, -0.06994579f, 0.22417066f, -0.09741250f, 0.31534648f, 0.00993761f, 0.01775029f, 0.13537714f, 
    0.03281862f, -0.03060645f, 0.04603609f, 0.11802828f, -0.24869719f, -0.23299594f, -0.21251656f, -0.08239154f, 
    0.07130695f, 0.12133261f, -0.00363590f, -0.09193777f, -0.27270797f, -0.08776478f, -0.01350401f, -0.13470989f, 
    -0.00453846f, -0.02737621f, 0.05067860f, 0.09986940f, 0.20974706f, 0.10101313f, 0.03604534f, -0.04532818f, 
    -0.01245087f, 0.07643045f, -0.17677230f, -0.10487760f, -0.02790639f, 0.20515348f, -0.18338180f, 0.04372006f, 
    -0.20187287f, -0.03961147f, 0.12589468f, 0.16053864f, 0.03615151f, -0.03727133f, -0.10082255f, -0.11863834f, 
    0.96277976f, -0.17722321f, -0.28623351f, 0.30196878f, 0.00390977f, 0.04578766f, -0.05557821f, -0.07942035f, 
    -0.10805151f, -0.08734261f, 0.13049567f, 0.02806332f, -0.60876846f, 0.05851283f, 0.02404580f, -0.34411374f, 
    -0.11495329f, 0.11088400f, 0.10289872f, -0.09124879f, 0.06918549f, -0.02404954f, 0.02154303f, -0.10120314f, 
    -0.14811958f, 0.06581835f, -0.24406864f, 0.01774465f, 0.13175215f, 0.00407521f, 0.05399578f, -0.01874934f, 
    -0.25717244f, -0.20553912f, -0.08874498f, 0.02775330f, -0.22873889f, -0.27560380f, -0.44817740f, -0.29559949f, 
    -0.32295516f, 0.12127177f, 0.00641999f, 0.04968413f, 0.08337885f, 0.09965798f, -0.03574351f, -0.15761153f, 
    0.14985237f, -0.24604836f, -0.16929832f, -0.00955566f, -0.23216830f, 0.01765886f, -0.17525023f, 0.06851724f, 
    0.12587544f, -0.15043363f, -0.34703213f, -0.43677345f, 0.37103558f, 0.35477930f, -0.07637122f, 0.74778342f, 
    -0.22698219f, -0.16566826f, 0.20424873f, 0.17884508f, -0.11160830f, 0.05071677f, 0.06238667f, 0.08250078f, 
    -0.62496519f, -0.16107109f, -0.61635125f, -0.04971854f, -0.24121372f, 0.23051549f, 0.04820605f, 0.11636382f, 
    -0.05621851f, 0.19633308f, -0.03016745f, -0.16978511f, -0.80868560f, -0.30894318f, -0.00533396f, 0.28604978f, 
    0.00639581f, -0.02375400f, 0.00992801f, -0.18621828f, 0.05903303f, -0.15027452f, 0.27062204f, -0.13209818f, 
    -0.24724112f, 0.04745129f, 0.06563508f, 0.07898799f, 0.01088327f, -0.10629622f, -0.05159361f, 0.04312764f, 
    0.08032402f, 0.20586161f, 0.11457484f, -0.04106962f, 0.14651160f, -0.16686504f, -0.09787776f, 0.16443647f, 
    -0.22599322f, 0.10093725f, -0.15858117f, -0.23080522f, -0.14077993f, -0.11589444f, 0.18109272f, -0.08918440f, 
    0.21686609f, -0.07377636f, 0.13422111f, -0.26431552f, -0.09339993f, -0.06702228f, 0.08625944f, 0.10314847f, 
    0.01139791f, 0.02284673f, 0.09344088f, -0.12611069f, -0.18385768f, -0.30348644f, 0.02691796f, -0.22145928f, 
    0.01439035f, 0.06666986f, 0.02372936f, -0.02538272f, -0.13899192f, -0.13862883f, 0.11863282f, -0.08560595f, 
    -0.66085792f, -0.17004992f, -0.44966465f, -0.05361670f, -0.08388233f, 0.00841370f, 0.01464886f, -0.24584430f, 
    0.02423460f, -0.16922194f, 0.00493268f, 0.02374562f, 1.11760819f, 0.34781998f, 0.18381138f, 0.11829516f, 
    0.10833694f, 0.01344860f, -0.12319274f, 0.07738604f, 0.05037799f, -0.17571381f, -0.21633728f, -0.19415891f, 
    -0.50591195f, -0.73831183f, -0.51282752f, 0.21452528f, -0.27565873f, -0.18783915f, 0.07355215f, 0.03405941f, 
    0.13050239f, 0.14549369f, 0.00382886f, 0.06226782f, 0.51329464f, -0.30699340f, -0.10069736f, -0.09888335f, 
    -0.00868066f, 0.21542028f, 0.09616863f, 0.13477629f, 0.01043934f, -0.06935178f, 0.11778005f, 0.04798923f, 
    -0.07395751f, 0.38109642f, 0.15891786f, 0.14792967f, 0.05332727f, 0.01851892f, -0.08504781f, 0.00718769f, 
    -0.05937793f, -0.01239328f, -0.07076632f, 0.13401635f, 0.01929800f, -0.38463390f, -0.32795820f, 0.14158136f, 
    0.01234252f, 0.16504188f, -0.06253229f, 0.16067426f, -0.25281465f, -0.05495518f, -0.05478556f, -0.06191865f, 
    -0.48876259f, 0.19457042f, 0.27514789f, 0.09058786f, -0.04976404f, 0.06574786f, 0.10704856f, -0.01207431f, 
    -0.09471063f, 0.01489731f, -0.00449423f, 0.04988854f, 0.20206262f, 0.13135108f, 0.29905570f, 0.13732255f, 
    0.20421511f, 0.26693404f, 0.19441800f, 0.14941449f, -0.02123249f, 0.08834264f, 0.18816034f, 0.11758110f, 
    0.19089831f, 0.03113856f, 0.07627892f, 0.03581661f, 0.28124207f, -0.23207553f, 0.10418092f, -0.20464973f, 
    -0.08656817f, -0.05691672f, -0.08100320f, 0.09261879f, -0.20483235f, -0.17734779f, 0.00860905f, -0.03718074f, 
    -0.11394137f, -0.04490546f, 0.00416474f, -0.13730747f, -0.22257110f, 0.18826188f, -0.14881077f, -0.02354051f, 
    -0.38311759f, -0.35390371f, 0.14710535f, -0.27069890f, -0.19885303f, 0.12976465f, 0.09575684f, 0.21539123f, 
    0.10637995f, 0.16904807f, 0.09313526f, -0.08150496f, -0.62890726f, 0.10341366f, 0.39184153f, 0.31316987f, 
    0.11060384f, -0.09242645f, -0.04226504f, 0.02963407f, 0.16526355f, 0.00602743f, -0.02038723f, -0.15565640f, 
    -0.35713324f, 0.12329023f, -0.07083716f, 0.18535684f, 0.26236448f, 0.07130763f, 0.01684715f, 0.26694536f, 
    0.14291409f, 0.16591159f, -0.08372671f, -0.11768003f, -0.43613511f, 0.28142241f, -0.11261681f, 0.20552179f, 
    -0.13851257f, -0.22344147f, -0.05113448f, 0.13116866f, 0.16641814f, -0.12815030f, -0.12825447f, -0.03471394f, 
    -1.10342431f, -0.17987552f, -0.07312262f, -0.14502108f, 0.03156132f, 0.05298001f, 0.07184455f, 0.09861215f, 
    -0.02289332f, -0.07303189f, 0.07296953f, 0.07043851f, 0.18561693f, -0.12389739f, 0.06198944f, 0.01751594f, 
    -0.13691922f, -0.01616009f, 0.13080785f, 0.16821007f, 0.07897818f, -0.04936197f, -0.21819983f, 0.02566384f, 
    0.30608591f, 0.54760969f, -0.22388239f, -0.18097039f, -0.10199848f, -0.03883466f, 0.05246332f, 0.11899767f, 
    -0.20553042f, -0.08199502f, -0.10328469f, 0.06145136f, 0.26817328f, 0.26210284f, -0.06692074f, 0.11678803f, 
    0.16266921f, -0.06559191f, 0.03934322f, 0.05424285f, -0.03118316f, -0.14786726f, 0.05694652f, 0.02277439f, 
    -0.12384854f, 0.15748923f, -0.16992904f, -0.01514898f, -0.02983890f, -0.08024021f, 0.12478554f, 0.18842429f, 
    0.05715146f, 0.24321283f, -0.11662241f, 0.21355876f, 0.59617358f, -0.19246708f, 0.09721885f, 0.06176241f, 
    0.00332111f, 0.09117402f, -0.11666660f, -0.41046068f, 0.12907392f, 0.13167952f, -0.02455689f, -0.26936877f, 
    -0.62299401f, 0.14576468f, 0.09864738f, 0.00268450f, -0.22235225f, -0.02897016f, 0.07397136f, 0.15653086f, 
    -0.11232701f, -0.08235551f, -0.01221717f, 0.08846948f, -0.19274405f, 0.21207453f, 0.27089521f, -0.44409221f, 
    -0.00992932f, 0.06789330f, -0.29953361f, -0.08386346f, -0.03463290f, -0.14670226f, 0.00695857f, -0.21182004f, 
    0.29235354f, -0.00987823f, -0.44001949f, -0.39057577f, 0.08879336f, -0.28433353f, 0.18254498f, -0.19882020f, 
    0.05582475f, -0.03641371f, 0.22241370f, -0.12893265f, 0.52951539f, -0.52577353f, 0.16588703f, -0.65198332f, 
    -0.01731140f, 0.15786447f, -0.00446394f, 0.05924629f, -0.07269098f, 0.25106135f, 0.00616323f, 0.08780118f, 
    -0.46247250f, 0.07012263f, -0.17473564f, -0.45577064f, 0.19015504f, -0.07749409f, -0.08796719f, 0.08558205f, 
    -0.30945316f, -0.07814050f, 0.09771916f, 0.08171230f, -0.36528480f, -0.18019202f, 0.20134680f, 0.40472299f, 
    -0.24513832f, 0.02940696f, 0.09524597f, -0.01551473f, -0.05218547f, 0.02547162f, 0.27276284f, 0.12497046f, 
    0.10986082f, -0.11559840f, -0.05241216f, 0.06717690f, 0.16094683f, 0.00119180f, -0.05105976f, 0.00016824f, 
    -0.06047801f, -0.26431060f, -0.04359135f, 0.03091680f, 0.36755142f, 0.00878519f, 0.21044602f, 0.16207217f, 
    -0.26582044f, -0.02108973f, 0.02159281f, 0.09063509f, -0.26503786f, -0.02998350f, 0.03658690f, 0.10134952f, 
    -0.56705040f, -0.13982053f, 0.13448597f, -0.04762523f, 0.11354697f, -0.02124278f, 0.00275260f, 0.04216794f, 
    0.13964154f, -0.09500132f, 0.07953837f, 0.25699741f, -0.68300241f, -0.34333780f, -0.22848809f, 0.07737212f, 
    0.39539143f, 0.18012176f, 0.05581851f, -0.05651395f, 0.10016733f, 0.23837370f, 0.12997931f, -0.00482628f, 
    -0.66993988f, 0.38852784f, -0.43338153f, 0.07599099f, 0.31616557f, -0.04002105f, 0.04779925f, -0.41396993f, 
    -0.12728198f, -0.17197356f, -0.22341931f, -0.19093068f, -0.35649702f, -0.00565768f, -0.20771365f, -0.50886470f, 
    -0.09969328f, -0.06180008f, 0.21364623f, -0.04365852f, 0.20866884f, -0.17729259f, 0.10175283f, 0.11833145f, 
    -0.15652885f, 0.13196056f, 0.35570493f, -0.39301506f, -0.12812379f, -0.16612963f, -0.15543199f, -0.03734811f, 
    0.05945622f, 0.18475907f, -0.06033091f, 0.00837503f, -0.38161179f, -0.21075083f, 0.27355790f, 0.26870474f, 
    -0.31424743f, -0.13114198f, 0.10901979f, -0.00118438f, 0.15888701f, 0.14271387f, -0.05295329f, 0.18758763f, 
    -0.03583651f, 0.03437266f, 0.33230859f, 0.26848537f, 0.20191033f, 0.10794365f, -0.02474321f, -0.15565255f, 
    0.02301803f, -0.17284751f, -0.12561199f, -0.00918926f, 0.22848226f, -0.07159995f, 0.20943694f, 0.03783888f, 
    -0.00902408f, -0.33288205f, -0.30750927f, -0.15641719f, -0.09407159f, 0.00021500f, -0.08447726f, -0.23124030f, 
    -0.36795899f, 0.05422076f, -0.18807706f, -0.71331453f, 0.12372262f, -0.24170542f, 0.20556271f, -0.11270881f, 
    -0.01491421f, -0.08258884f, -0.19709598f, -0.12012127f, 0.19062200f, 0.12199956f, 0.13272063f, 0.46029362f, 
    -0.04097433f, -0.02277476f, 0.19268776f, 0.19522178f, 0.26210609f, 0.12137558f, -0.06012341f, 0.20705886f, 
    0.14590479f, 0.05252032f, 0.18789774f, -0.05802177f, 0.01832759f, 0.22317097f, 0.04157475f, -0.15936202f, 
    -0.05975271f, 0.24859513f, -0.12450629f, 0.19541416f, 0.28444114f, 0.21625981f, -0.13816920f, 0.19959484f, 
    -0.06646109f, -0.16405205f, -0.01980056f, 0.10634523f, 0.12242332f, -0.24613528f, -0.00249934f, -0.12490042f, 
    -0.27750602f, -0.17554189f, 0.32601005f, -0.08296921f, -0.05064931f, 0.14927927f, 0.06594453f, 0.17873152f, 
    -0.18186948f, 0.31510383f, 0.08794614f, 0.17093681f, -0.12265875f, -0.08396371f, -0.21733634f, -0.29999480f, 
    0.06668133f, 0.22090980f, -0.12812820f, -0.03003098f, 0.11771856f, -0.01963145f, -0.00088329f, -0.06956982f, 
    -0.86975718f, 0.34431905f, 0.15209103f, 0.36278802f, 0.07952888f, 0.07384293f, 0.01823291f, 0.07492363f, 
    0.07111973f, 0.17790736f, 0.11038168f, 0.01115091f, 0.08469997f, 0.34269160f, -0.03243454f, -0.72935754f, 
    0.03665799f, -0.09898625f, -0.03907831f, 0.13655454f, -0.01727026f, 0.11150713f, -0.25384313f, 0.00433159f, 
    0.20339604f, 0.30385193f, -0.06032386f, -0.17579383f, -0.16775887f, -0.06795868f, -0.06316308f, 0.00227742f, 
    -0.04617197f, 0.05383641f, -0.10683512f, -0.22198190f, -0.69647890f, -0.07229859f, 0.04755275f, -0.52861112f, 
    -0.13756734f, -0.25629047f, 0.23202355f, -0.27484387f, -0.26307952f, 0.01865799f, -0.21133383f, 0.04873976f, 
    0.56286693f, -0.86292028f, 0.02519054f, -0.36608988f, 0.00127002f, 0.19532099f, 0.04197086f, 0.06561599f, 
    -0.06306332f, -0.06086433f, 0.21018277f, 0.21962641f, -0.02137732f, 0.71145201f, 0.28598768f, -0.63460338f, 
    -0.14694582f, 0.13879311f, -0.22491825f, -0.00627599f, -0.05537362f, 0.19052322f, -0.02374653f, -0.03553706f, 
    -0.09459098f, -0.23457623f, 0.18083498f, -0.41754994f, -0.03400791f, 0.17509927f, 0.01084492f, 0.11631522f, 
    -0.06552978f, -0.28961456f, -0.06430154f, -0.12167309f, 0.14851399f, -0.23036376f, -0.08598305f, -0.19520159f, 
    -0.03891450f, 0.10828396f, -0.07295360f, 0.01274966f, -0.10142499f, -0.04234256f, -0.04069980f, 0.05645044f, 
    0.14189489f, 0.19708224f, 0.15013716f, -0.34672961f, -0.22337322f, -0.12963417f, 0.12521432f, 0.11427794f, 
    0.12359703f, 0.08496188f, 0.16907993f, 0.21786126f, -0.73677862f, 0.05756588f, 0.06353637f, 0.27299196f, 
    0.09207539f, 0.21731983f, 0.26310536f, 0.08308392f, 0.11238240f, -0.26834339f, 0.26254520f, -0.07002774f, 
    0.17207350f, -0.15592688f, 0.14167617f, 0.34956774f, -0.01095650f, 0.02683205f, -0.14197043f, 0.02524740f, 
    0.01318666f, -0.18349129f, 0.12542455f, 0.16540690f, -0.35487956f, -0.23408203f, -0.21442838f, 0.29029694f, 
    0.20411484f, 0.09947828f, -0.13706666f, -0.05161802f, -0.18929034f, -0.04530344f, -0.06897565f, -0.41628066f, 
    0.11116543f, -0.05231718f, 0.22835569f, 0.53680390f, 0.03801876f, 0.00996592f, 0.14017330f, 0.07307802f, 
    0.17815822f, -0.02765221f, -0.04273023f, -0.14945109f, -0.14686784f, -0.28067139f, 0.19805890f, 0.14461945f, 
    0.15767018f, -0.08571072f, -0.08130056f, 0.13162211f, 0.10450775f, -0.02194628f, -0.03494203f, 0.01222945f, 
    0.24457619f, -0.13738279f, 0.22097220f, -0.20058814f, 0.03357296f, 0.09382449f, 0.15483946f, -0.15958425f, 
    0.09309652f, -0.23706648f, -0.07833062f, -0.22317667f, -0.50875401f, -0.29068199f, 0.08679318f, -0.13858688f, 
    0.04872318f, -0.07524645f, 0.12006032f, -0.10270851f, 0.06251363f, -0.09998581f, 0.05953262f, 0.18518704f, 
    -0.57446635f, -0.46683556f, -0.09279615f, -0.17085224f, -0.14911799f, 0.03338420f, -0.07853874f, 0.03464936f, 
    -0.14841045f, 0.07122237f, -0.01128721f, 0.04525780f, -0.02359718f, -0.74664801f, -0.00135536f, -0.05692885f, 
    -0.09664337f, -0.13423780f, -0.06023957f, -0.11592430f, -0.20198642f, -0.00799376f, -0.01923422f, -0.05373446f, 
    0.52678460f, 0.22918354f, 0.26160112f, 0.04383847f, -0.26312017f, 0.02116102f, -0.06595090f, -0.11825837f, 
    -0.18463795f, 0.09010367f, -0.32159659f, -0.11704634f, 0.07009757f, 0.24188097f, 0.34513631f, 0.40187517f, 
    0.37058422f, 0.14940555f, -0.03790179f, 0.06176109f, -0.08178820f, -0.13069932f, -0.03916558f, -0.15259437f, 
    0.11932249f, 0.17790659f, 0.38086355f, 0.29491505f, 0.18341945f, 0.19211327f, -0.05486310f, 0.05382078f, 
    0.02881156f, 0.02665174f, 0.05257702f, 0.06648935f, -0.29234457f, 0.42074415f, -0.31784412f, -0.10080536f, 
    0.04623302f, -0.01905630f, -0.08839815f, -0.09815834f, -0.09409700f, 0.00275276f, 0.04161581f, -0.06504560f, 
    -0.39085314f, 0.28784537f, -0.01738782f, -0.17596044f, -0.08419828f, -0.12565248f, 0.02818240f, -0.08464620f, 
    -0.03189438f, 0.02370782f, -0.28404602f, -0.10538102f, -0.16151285f, 0.30055261f, 0.10752294f, 0.63180691f, 
    0.10785870f, -0.00551974f, -0.12502566f, -0.17621310f, -0.03018241f, -0.13361436f, -0.09749294f, -0.17563573f, 
    -0.12916034f, 0.27817184f, -0.18295896f, -0.49210599f, -0.12875645f, 0.01862778f, -0.04504958f, -0.24301377f, 
    -0.07440925f, -0.08200615f, -0.15152802f, 0.10702906f, -0.28838468f, 0.48474622f, -0.01306503f, -0.20707870f, 
    -0.17916857f, 0.05861257f, 0.03912663f, -0.11470085f, -0.19432990f, -0.12832630f, 0.03376068f, -0.10310957f, 
    0.41508567f, -0.69771618f, 0.20762496f, -0.18331552f, 0.02272749f, 0.05654687f, -0.04408983f, -0.03739138f, 
    -0.14652012f, 0.08358075f, 0.01859143f, 0.07890315f, -0.02465249f, -0.17019229f, -0.48819083f, -0.12499285f, 
    0.05124855f, -0.05962873f, 0.09126315f, -0.03646524f, 0.01005057f, -0.08606973f, -0.05783256f, -0.05414397f, 
    -0.18712035f, -0.38001761f, -0.01196301f, 0.06876110f, -0.10373260f, 0.07700605f, 0.02666079f, -0.15989408f, 
    0.20132974f, -0.05183164f, 0.07509297f, -0.08769052f, 0.33638486f, -0.04768950f, 0.00922490f, 0.03645286f, 
    -0.00772027f, -0.26270545f, -0.17159219f, -0.05309588f, -0.02704023f, -0.06460893f, -0.05995714f, -0.17620622f, 
    0.10503548f, -0.26014104f, 0.17180610f, -0.10086969f, -0.19368714f, 0.01675075f, 0.16000222f, -0.02336149f, 
    0.06560073f, 0.04836333f, -0.02056664f, -0.10678035f, 0.51891023f, 0.06225641f, 0.25455520f, 0.07521092f, 
    0.06696670f, 0.07932203f, -0.00266880f, 0.04692920f, 0.01670430f, 0.10474065f, -0.01292268f, -0.20649683f, 
    0.46865889f, 0.15458098f, -0.28629526f, 0.14063376f, 0.16294867f, -0.02852171f, -0.09010896f, -0.23198614f, 
    -0.17639901f, -0.10287189f, -0.18936984f, 0.27929440f, -0.22508718f, -0.34285739f, -0.25939390f, 0.26818448f, 
    0.16139217f, 0.07106475f, 0.03840841f, -0.00593336f, 0.13729276f, 0.09948609f, 0.16107152f, -0.07171644f, 
    -0.46520051f, 0.40872079f, -0.12649186f, -0.35035971f, -0.03018672f, -0.12440219f, -0.02185219f, -0.08754227f, 
    -0.00438377f, -0.00743037f, 0.19723228f, 0.12219807f, -0.71458805f, -0.11758097f, 0.65982074f, -0.13602951f, 
    -0.01908044f, 0.09854300f, -0.12135105f, -0.14945126f, -0.22677675f, -0.06840859f, 0.26667157f, -0.15023264f, 
    0.03805736f, -0.35624987f, 0.41334265f, -0.26383480f, -0.32406408f, -0.32794124f, 0.07646909f, -0.07710131f, 
    0.03444171f, -0.23845851f, -0.38081706f, -0.09685192f, 0.05612611f, -0.19084479f, 0.12158626f, 0.20936720f, 
    0.22451858f, 0.12624830f, 0.13793017f, -0.19977634f, -0.16594863f, 0.17623045f, 0.09099876f, 0.12034242f, 
    0.44933727f, -0.10413628f, 0.30531254f, 0.29103684f, -0.04262506f, -0.21249305f, -0.00375684f, 0.02791119f, 
    0.00445122f, 0.06474684f, 0.09373006f, 0.04646752f, -0.55702591f, 0.06831681f, -0.18110652f, -0.59438854f, 
    0.11499435f, -0.16779670f, -0.28927514f, 0.02317151f, 0.17579503f, 0.12782353f, -0.03804391f, 0.19000635f, 
    0.19483720f, -0.01727732f, 0.15084128f, 0.29191566f, 0.14344889f, -0.18537866f, -0.22550578f, 0.06206526f, 
    0.11174330f, -0.05505553f, 0.23593564f, -0.38603798f, -0.12605578f, 0.00111784f, -0.35815173f, -0.28666934f, 
    0.00036509f, -0.05259999f, -0.16085047f, 0.08453000f, 0.18029340f, 0.19530341f, -0.02615526f, -0.25673497f, 
    0.11896174f, -0.04666463f, 0.28415063f, 0.21927620f, -0.11473410f, -0.16297668f, 0.10212873f, -0.25625786f, 
    0.07032257f, 0.13912366f, -0.13879775f, 0.01440990f, 0.42836210f, 0.42362440f, -0.18465382f, -0.08193975f, 
    -0.03313701f, -0.16540553f, 0.01921774f, 0.02638495f, 0.25223395f, 0.03374311f, 0.02811959f, 0.29004493f, 
    0.18034735f, 0.05364765f, 0.07351620f, 0.13318250f, -0.12269215f, -0.24659728f, -0.37173960f, -0.28949285f, 
    -0.14842990f, 0.18036658f, -0.04991029f, 0.14708680f, 0.16888148f, -0.06583700f, -0.07675396f, -0.42731360f, 
    0.19865547f, -0.32249123f, -0.06412858f, -0.12246366f, -0.15739694f, -0.10611159f, -0.11620804f, 0.03566389f, 
    0.02851868f, -0.29586995f, 0.02015839f, -0.22384413f, -0.01664381f, -0.12722878f, -0.13849935f, 0.01164168f, 
    0.02055955f, 0.11617748f, -0.10193747f, 0.03145444f, -0.05770064f, 0.22199221f, 0.26944068f, -0.01956334f, 
    -0.19748829f, -0.01129188f, -0.12177924f, -0.00679489f, -0.06772341f, -0.19322819f, -0.27179843f, -0.08244974f, 
    0.29257315f, 0.07752280f, 0.41772032f, -0.00205242f, -0.05050698f, -0.03238268f, -0.16809621f, 0.08636572f, 
    -0.04723419f, 0.04535463f, -0.03134172f, -0.21116540f, -0.33710685f, 0.07074317f, -0.00613393f, -0.52456951f, 
    -0.04917639f, -0.01942262f, -0.19012666f, -0.21415883f, -0.04052665f, -0.09140051f, 0.07429267f, 0.20431554f, 
    -0.49735221f, -0.44118166f, -0.26574430f, 0.37466803f, -0.01243885f, 0.08534247f, -0.03593560f, -0.02869446f, 
    -0.15622012f, 0.08927993f, 0.20041324f, -0.06792784f, 0.66637570f, -0.39979616f, -0.23274396f, 0.30808434f, 
    0.17694730f, 0.17038836f, -0.15247612f, -0.00479869f, -0.30936548f, -0.21398230f, -0.01757867f, -0.01664708f, 
    0.56393319f, -0.12232935f, 0.10622693f, -0.03968437f, 0.21943045f, 0.06653515f, -0.05856396f, -0.05792278f, 
    -0.08692336f, 0.19660211f, 0.17346914f, 0.11144187f, -0.99810594f, 0.24303275f, 0.07330775f, -0.32355794f, 
    0.14049409f, -0.05561906f, -0.04452556f, 0.03543600f, 0.00958610f, -0.01953444f, 0.02385393f, 0.08944179f, 
    -0.59852540f, 0.34756723f, -0.49894479f, -0.07364346f, 0.32817340f, 0.00266926f, 0.11341257f, 0.09327094f, 
    -0.19990651f, -0.21221751f, -0.04768430f, 0.05643824f, -0.39677656f, -0.46334681f, -0.25728232f, -0.25473291f, 
    -0.06483149f, 0.12364269f, 0.02377455f, 0.21527475f, -0.03961162f, -0.23500778f, 0.09852829f, -0.16744240f, 
    -0.10994875f, 0.28327397f, 0.00399326f, -0.25187925f, 0.19995309f, -0.07115605f, -0.06203084f, -0.10761445f, 
    -0.19004232f, -0.05098180f, 0.12434966f, -0.01619261f, -0.33987319f, 0.25080457f, 0.12540191f, 0.10607275f, 
    -0.00850928f, 0.12525630f, 0.07377057f, 0.14546603f, -0.01269388f, -0.30969051f, 0.16699360f, 0.14236914f, 
    0.24310564f, -0.77327365f, 0.13764253f, -0.08516014f, 0.10239962f, 0.04787159f, 0.03040230f, -0.19308843f, 
    0.16622402f, -0.10201020f, -0.04785115f, -0.31542537f, 0.70065522f, 0.17738916f, -0.08347504f, -0.40182722f, 
    0.10734784f, 0.04240127f, 0.19581975f, -0.07705351f, -0.31992784f, -0.04542853f, 0.05604617f, -0.09664298f, 
    0.06456868f, -0.02993781f, -0.59980690f, -0.31146082f, -0.00179680f, -0.11087447f, 0.29959223f, 0.07206341f, 
    0.00619990f, -0.01817553f, -0.02943923f, -0.13614735f, 0.49438736f, 0.46236965f, -0.01106372f, -0.06053625f, 
    -0.00339627f, 0.01872122f, 0.34523898f, 0.10352587f, 0.07901170f, 0.21136382f, 0.24533167f, 0.02848599f, 
    0.39252707f, 0.25496536f, -0.58564806f, 0.34177911f, 0.16364762f, 0.05046477f, -0.18415095f, 0.12689933f, 
    0.02868918f, 0.02998894f, -0.24357466f, 0.01424203f, -0.05010136f, -0.24687631f, -0.14507477f, 0.21369869f, 
    0.01662813f, 0.07573051f, 0.07353056f, 0.33003116f, -0.39863226f, 0.07901118f, -0.17799732f, -0.00216094f, 
    -1.23130083f, -0.80715674f, 0.12807304f, 0.15675107f, 0.15049551f, 0.05919135f, -0.02609600f, -0.33071983f, 
    0.11544274f, -0.15677132f, -0.00881697f, 0.19686300f, -0.23245016f, 0.26497173f, -0.11133930f, -0.41374645f, 
    0.06234673f, 0.24641366f, -0.09964499f, 0.15442421f, 0.18145357f, 0.12571737f, -0.17730947f, 0.04809960f, 
    0.11310907f, -0.06126848f, -0.22003600f, -0.15074937f, 0.13976358f, 0.24296713f, 0.04659525f, 0.01714800f, 
    -0.21448031f, -0.16332138f, 0.10392533f, 0.02255338f, 0.41402546f, 0.06614272f, 0.09440950f, -0.24583460f, 
    -0.26244083f, -0.11920936f, 0.23659231f, 0.08216269f, 0.18994881f, 0.37774619f, -0.01188898f, -0.02782488f, 
    0.63622111f, 0.05532354f, -0.04746865f, -0.07031655f, -0.39517939f, -0.03658275f, 0.02191786f, -0.15413119f, 
    0.11273981f, 0.00440192f, -0.06140358f, -0.15009853f, -0.62926543f, -0.97362709f, -0.51049817f, 0.07171569f, 
    0.08574513f, -0.09158096f, 0.18400642f, -0.08571702f, 0.07102399f, 0.02477580f, -0.00755195f, 0.07324573f, 
    -0.48866054f, -0.65648282f, -0.24148491f, 0.02805634f, -0.01980404f, -0.00322058f, 0.02923897f, 0.27468556f, 
    0.07327670f, -0.00535727f, 0.20387392f, -0.00300688f, -0.04921872f, -0.05871172f, -0.34366229f, -0.20136325f, 
    0.22443722f, 0.02248009f, 0.13357152f, 0.01204796f, 0.11129426f, 0.36113498f, 0.06768661f, 0.14127789f, 
    -0.88488120f, -0.20992996f, -0.09475868f, -0.62063074f, 0.17030908f, -0.01929505f, -0.28776667f, -0.00552933f, 
    -0.33103287f, -0.29494900f, -0.04218512f, -0.24196105f, -0.57838500f, -0.55562931f, 0.32743073f, 0.10089939f, 
    0.12081369f, 0.13466357f, 0.10444313f, 0.05892693f, 0.04584337f, 0.15272908f, -0.25090373f, 0.25774148f, 
    -0.01398353f, 0.09184001f, -0.27712613f, 0.15859683f, 0.04062641f, -0.08778448f, -0.09426750f, 0.08975759f, 
    -0.07850961f, 0.18998227f, -0.07428092f, 0.02296991f, -0.59314585f, -0.24964888f, 0.11457990f, 0.33341473f, 
    0.06900242f, 0.00250658f, 0.14249617f, 0.16475193f, 0.07961498f, 0.46917707f, 0.14703226f, 0.41247076f, 
    0.21516351f, 0.21209638f, 0.07959730f, -0.43414900f, 0.12125363f, -0.03463099f, -0.20641631f, 0.19355901f, 
    -0.00213512f, 0.17152829f, -0.07166047f, 0.12654209f, -0.69466066f, 0.31805632f, 0.07119410f, 0.16588478f, 
    0.19961710f, 0.02239967f, -0.19840431f, -0.11179649f, -0.20856264f, -0.01668440f, 0.00801652f, 0.18405655f, 
    0.50328666f, 0.06413253f, -0.15071927f, 0.10211491f, -0.19352548f, 0.07793492f, 0.09217299f, 0.18964052f, 
    0.11095143f, 0.07862985f, 0.10647073f, -0.08865335f, 0.18531023f, -0.05284881f, 0.14726672f, -0.23765336f, 
    -0.15521547f, -0.02142131f, 0.04199056f, -0.10410322f, 0.13523817f, -0.19883946f, 0.20934390f, -0.21417496f, 
    0.61352313f, 0.07113927f, -0.12970401f, -0.07793763f, 0.16095887f, -0.04677067f, 0.06932233f, -0.08782359f, 
    -0.00147062f, 0.11680719f, 0.09802362f, 0.08792726f, 0.68530828f, -0.11827444f, -0.26960176f, -0.18748417f, 
    0.02544213f, -0.26360428f, 0.05756276f, 0.03677512f, 0.11956296f, -0.06405146f, 0.07305172f, 0.09091679f, 
    -0.26979017f, 0.37523615f, -0.06965609f, -0.08304234f, 0.20121282f, -0.24982411f, 0.16589086f, -0.06337129f, 
    -0.08181351f, 0.00733797f, -0.00538126f, -0.08711105f, 0.51579756f, 0.21982658f, -0.03391939f, -0.07437620f, 
    -0.16881499f, 0.04333067f, -0.02615443f, 0.02482867f, 0.15518230f, -0.18989529f, 0.13536200f, -0.08427489f, 
    -0.61820352f, -0.22560127f, 0.10758803f, -0.04787706f, 0.19763911f, 0.11376323f, -0.22199373f, -0.01847121f, 
    0.02940245f, 0.03410891f, 0.08107775f, -0.19264755f, -0.04165414f, -0.10992170f, -0.03579189f, -0.22927369f, 
    0.11266644f, 0.10335775f, -0.13698423f, -0.01782331f, 0.04485681f, 0.15485780f, -0.16278332f, -0.07106578f, 
    -0.31970543f, -0.27391291f, 0.26330620f, -0.06728571f, 0.24972427f, -0.03406543f, 0.14552042f, -0.09102271f, 
    0.05822171f, -0.08165503f, 0.01522126f, 0.02138428f, 0.02479396f, -0.06138461f, 0.08616930f, 0.81058675f, 
    -0.15700747f, -0.13227107f, -0.16192956f, 0.08963425f, -0.11686302f, -0.16763955f, -0.00139329f, -0.15220940f, 
    0.15457411f, -0.43783259f, -0.19009864f, -0.63006020f, 0.02194573f, 0.05090453f, 0.04129997f, 0.13182841f, 
    0.07871751f, 0.10284256f, -0.04340520f, -0.01450550f, -0.56210470f, 0.63661790f, -0.16235313f, 0.18721323f, 
    0.11565530f, 0.18808153f, -0.11403549f, 0.08493911f, 0.14522010f, 0.00653815f, -0.03711954f, 0.08175589f, 
    -0.57006198f, 0.41962561f, -0.32193363f, -0.16660073f, -0.04207130f, -0.07306975f, -0.05432131f, 0.16144192f, 
    -0.26472223f, -0.07450651f, 0.19355282f, -0.04340057f, 0.18356049f, -0.25216755f, -0.09090672f, -0.06815991f, 
    -0.01906992f, -0.23870288f, -0.23723282f, 0.24315970f, -0.00349405f, -0.15621540f, 0.04730682f, 0.00437274f, 
    -0.43030053f, -0.47971591f, 0.26663670f, 0.23102261f, -0.05126882f, 0.13127097f, -0.02258757f, 0.31879109f, 
    -0.08054954f, -0.08902986f, -0.14020011f, -0.06349286f, -0.29480526f, 0.22291918f, 0.32656866f, -0.02272422f, 
    -0.18933088f, 0.11178319f, -0.28469938f, -0.12949739f, 0.10617935f, 0.34793752f, 0.05584341f, 0.13359299f, 
    -0.19780858f, -0.09413978f, 0.20859927f, -0.04309470f, -0.05884917f, -0.06112679f, 0.07005721f, -0.11136939f, 
    -0.01788328f, -0.23356919f, 0.19101182f, 0.22534427f, -0.49174878f, 0.35488757f, -0.14481206f, 0.05430903f, 
    0.11677679f, -0.11412634f, 0.16953856f, -0.29881442f, -0.03052127f, -0.03001760f, 0.03327647f, -0.38686824f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15032448f, 0.12795249f, -0.15505001f, 0.08718199f, -0.09027237f, -0.10341436f, -0.03683490f, -0.26354045f, 
    -0.04231039f, -0.02411042f, 0.18388154f, 0.07100897f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
