#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.58812916f, -0.20822012f, -0.58416134f, 1.03923333f, 0.26040444f, -0.99903530f, -0.55248564f, -0.50374907f, 
    0.62422067f, -0.38325855f, -1.25822318f, -0.87941355f, -0.00929270f, 0.61307162f, 0.39759865f, -0.36697066f, 
    0.12136932f, -0.23995157f, -0.43187630f, 1.12466943f, -0.50445455f, -0.69438541f, -0.55758530f, -0.49986467f, 
    -0.44902170f, 0.20818606f, -0.22449909f, 0.92800152f, -0.00331305f, 1.15986657f, 0.34447193f, 0.39981079f, 
    -0.12745132f, -0.00311180f, 0.35859260f, 0.42022866f, -0.02266947f, -1.14179969f, 0.21745549f, 0.35894886f, 
    0.46485081f, 0.92977542f, -0.52043343f, -0.20221029f, -0.53682768f, 0.00209388f, -0.53205222f, -0.40345675f, 
    -0.76851994f, -1.05575395f, -0.68075132f, 0.61437017f, 0.46611443f, -0.04550639f, 1.05466866f, -0.51429415f, 
    -0.13633466f, 0.65114254f, 0.71546739f, -0.08441627f, -0.53870982f, 0.66546756f, -0.14108253f, 0.77905732f, 
    -0.18274145f, -1.29326797f, -0.78311467f, 0.60754162f, 0.41831633f, 0.56978977f, 0.12082426f, 0.04272556f, 
    -0.84630513f, -0.11124987f, -1.24519753f, 0.57151622f, -0.56850636f, -0.60462940f, 0.18836777f, -0.25205258f, 
    0.03843239f, 0.81328470f, 1.07442403f, 0.61139631f, -1.04549670f, -0.64171988f, 0.23762429f, 0.46278998f, 
    0.35483304f, -0.69996238f, -0.41914809f, -1.41302800f, -0.09066245f, 0.82640058f, -0.45469517f, 0.44501364f, 
    -0.23992065f, -0.23061939f, -0.24497005f, 0.53860909f, -1.39102995f, 1.06664181f, 0.93625170f, 0.22334160f, 
    -0.09115248f, 0.01224108f, 0.32015878f, -0.39820322f, 1.22435093f, 0.67219222f, -0.87865317f, -0.64314914f, 
    0.02651427f, -0.37770846f, -0.25944939f, -0.17431355f, 0.76127297f, 1.02426231f, 1.04337156f, -0.90351164f, 
    0.65685451f, 0.31136826f, -0.95672208f, 0.24001577f, -0.36961925f, 0.23408374f, 0.81454843f, 0.89228773f, 
    0.27230299f, 0.76237607f, 0.32927388f, 0.00080762f, -0.11275100f, -0.05565065f, -0.32221052f, -0.87291384f, 
    -0.95397413f, -0.82402557f, -0.62807906f, 0.90688038f, 0.08042422f, 0.20047620f, 0.09367044f, 0.14591911f, 
    -1.52462459f, 0.88199610f, 1.10812831f, -0.38921875f, 1.13647485f, -0.03887977f, -0.42519176f, 0.35043755f, 
    0.18628785f, -0.73558116f, -1.10656452f, -0.23022418f, -0.89537132f, 0.59369713f, 0.99231726f, 0.26053992f, 
    -0.46621576f, -0.01101039f, 0.45790800f, 0.85878700f, 1.06330371f, 0.69531703f, -0.88848823f, 0.05767116f, 
    -0.61468589f, -0.41143650f, -0.22523767f, 0.12559335f, 1.29952633f, 0.85026824f, 0.00256492f, 0.79219699f, 
    -0.90467626f, 0.14581108f, 0.13481836f, 0.04394656f, 1.09653819f, -1.40372109f, 0.53960747f, -1.05768514f, 
    0.49475282f, -0.28755546f, 0.39106524f, -0.10467942f, -0.01483186f, -1.26141238f, 0.14868928f, -0.08520962f, 
    0.62717015f, 0.37761194f, -0.61161160f, -0.62062758f, -0.27935836f, 0.19084994f, -1.23007476f, -0.82109153f, 
    0.55447364f, 0.74057561f, 0.47486496f, 0.02495113f, -0.18870391f, -0.33370450f, -0.47097614f, 1.19422495f, 
    0.80740350f, 0.56945628f, -0.40680224f, -0.44611603f, -0.50649208f, 0.22132610f, 0.62084562f, 0.27094704f, 
    -0.51924646f, 1.13654065f, -0.23597193f, 0.95328462f, 0.37509999f, 0.88879526f, -0.47800124f, -0.66147316f, 
    -0.42751110f, -0.55969781f, -0.69397765f, -0.47711697f, 0.75709641f, 1.31917536f, -0.09821501f, 0.03304277f, 
    -0.10691155f, 0.30092719f, -0.01639609f, -0.22575815f, 1.20768964f, -1.35032785f, -0.68752718f, -0.36105624f, 
    0.18650989f, -0.24422561f, -0.43772840f, -0.19721502f, -0.96404213f, -0.31654277f, -0.13450381f, -0.53037161f, 
    -1.04658675f, -0.43610212f, 0.56897408f, 0.31083381f, 0.20660692f, -1.00751770f, -1.02237093f, -0.62372851f, 
    -0.79152244f, -0.66502583f, -0.03642478f, -0.06487610f, 0.16806895f, -1.14260280f, 1.07411480f, -0.54796737f, 
    0.59082681f, 0.07571981f, -0.89759809f, 0.43831560f, -0.19733189f, -0.40893209f, 0.25326562f, -0.31388885f, 
    -0.48113021f, -0.26457703f, -0.04024031f, 0.98617148f, -0.23818070f, 0.56061643f, 0.47252163f, 0.98545843f, 
    0.81487727f, 0.70528281f, -0.29000080f, 0.71570325f, 0.19366723f, -0.42427731f, 0.44677848f, -0.68415850f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.19244784f, 0.25046083f, 0.26702264f, 0.15669446f, -0.06542751f, 0.37514737f, 0.05392784f, 0.13413331f, 
    0.04841713f, -0.08423633f, 0.17261778f, 0.10086057f, -0.12023105f, 0.07433349f, 0.44753820f, 0.11507205f, 
    0.12403908f, 0.19507144f, 0.33132455f, 0.14974679f, -0.00952471f, -0.02400318f, 0.09395596f, -0.08887833f, 
    -0.07414068f, 0.18826911f, 0.33403647f, 0.20412545f, 0.44697168f, -0.23237421f, -0.05858642f, 0.02036002f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.14412421f, -0.12403189f, 0.08008789f, 0.06708096f, 0.26128414f, -0.02807343f, -0.18257685f, -0.02419884f, 
    -0.05197940f, -0.08556246f, -0.05705654f, 0.08177911f, 0.00654621f, 0.04386846f, -0.04262592f, 0.02647818f, 
    -0.03952970f, -0.18948083f, -0.26807117f, -0.00500444f, -0.05306956f, 0.08845181f, -0.22840990f, -0.15142502f, 
    -0.40969294f, 0.02580710f, 0.00860063f, 0.00512558f, 0.01144617f, 0.01375894f, -0.02287428f, -0.03070042f, 
    -0.00755289f, -0.06341416f, -0.03654404f, -0.02734625f, -0.01565061f, 0.03369761f, -0.03033356f, 0.04177722f, 
    -0.04513897f, -0.02583803f, 0.16986157f, -0.09798721f, 0.26042563f, 0.04215660f, -0.03118764f, -0.03538282f, 
    -0.19843063f, 0.04522358f, -0.12166252f, 0.06755656f, -0.05583602f, -0.02676928f, -0.05825785f, -0.11519644f, 
    0.00479738f, 0.06979077f, 0.02310117f, -0.05034804f, 0.27436393f, -0.08290637f, -0.05797126f, -0.10378025f, 
    -0.20349653f, -0.06593293f, -0.17921007f, 0.00706895f, 0.04726844f, -0.05801631f, 0.00240616f, 0.08571696f, 
    -0.07872455f, 0.14134343f, -0.01291687f, -0.18053609f, -0.16406640f, 0.02574467f, -0.07512777f, 0.06550868f, 
    0.17242675f, 0.12854886f, 0.04519919f, -0.07526568f, -0.26458701f, 0.08764273f, 0.08010183f, 0.03986330f, 
    -0.04097207f, -0.12629762f, 0.11211730f, -0.07050062f, 0.05983265f, -0.00111742f, -0.05302447f, 0.13437484f, 
    0.07961407f, -0.00548812f, -0.00156184f, 0.03008105f, -0.18474136f, -0.59436870f, 0.08815110f, 0.15823980f, 
    -0.07573226f, -0.06970586f, -0.05803423f, 0.04209776f, -0.08292370f, -0.04998049f, -0.00146294f, -0.07481899f, 
    -0.08748244f, -0.04052351f, 0.05770620f, 0.05740146f, -0.04487586f, -0.02508157f, 0.07034735f, 0.03481785f, 
    0.23073375f, 0.02704294f, 0.02666448f, -0.07867987f, 0.12515166f, -0.01200425f, -0.13123330f, -0.10924134f, 
    -0.01770848f, 0.02662091f, -0.09756161f, 0.07154150f, 0.10511040f, -0.04026816f, 0.00552633f, -0.03955938f, 
    0.05421138f, 0.00211967f, -0.02320566f, 0.04345897f, -0.55332857f, 0.12295844f, 0.03168692f, 0.02637126f, 
    0.15906021f, -0.09709772f, -0.12464393f, -0.00143107f, -0.11834999f, 0.07111060f, -0.04785926f, -0.10487700f, 
    0.06407028f, 0.02006050f, 0.07256413f, 0.00694002f, -0.03779489f, 0.04889214f, -0.07588000f, -0.06698478f, 
    0.45077151f, -0.57498050f, -0.11058905f, 0.06192973f, -0.06122282f, -0.01648226f, -0.06166741f, -0.03850726f, 
    0.08212363f, 0.03572113f, 0.10211861f, -0.03581051f, -0.09352739f, 0.03637078f, 0.09787720f, 0.08062477f, 
    0.02604764f, 0.08585166f, -0.03970167f, -0.15481651f, 0.13367702f, 0.20723030f, 0.16724445f, -0.18883772f, 
    0.38568988f, -0.15056251f, -0.12985937f, -0.09414333f, 0.02455982f, -0.04081932f, -0.15511790f, -0.12336443f, 
    0.08938675f, -0.06528668f, 0.07951309f, 0.03092832f, -0.01969498f, -0.08783516f, 0.03452753f, 0.02144372f, 
    0.19084699f, -0.10752551f, 0.00187707f, -0.00593180f, -0.53183383f, 0.15612821f, 0.09948492f, 0.03753560f, 
    0.08189955f, -0.00541932f, -0.05184299f, -0.05127816f, -0.01761007f, 0.02348377f, -0.00062780f, 0.07257047f, 
    0.01336076f, 0.06390642f, 0.04015952f, 0.03515040f, -0.10516515f, 0.02522875f, 0.04008980f, -0.00392994f, 
    -0.52934557f, -0.04199360f, -0.10290053f, 0.03816592f, -0.16043752f, -0.05288183f, -0.06423920f, 0.12421969f, 
    -0.05068503f, 0.08688048f, -0.07789562f, -0.03179699f, -0.06511380f, 0.05314956f, -0.09968105f, -0.00851949f, 
    -0.11754742f, -0.01730424f, 0.12234941f, -0.18288101f, 0.20297730f, -0.20121002f, -0.08354752f, -0.08588241f, 
    0.16186695f, 0.10731552f, 0.09637944f, 0.02818528f, 0.11543301f, 0.08871502f, -0.04443465f, 0.05781012f, 
    -0.10267336f, -0.00572890f, 0.05470685f, -0.11983198f, 0.07927321f, -0.04701202f, 0.06010776f, -0.05629216f, 
    0.40566096f, -0.22175853f, 0.02944569f, 0.06534048f, 0.13304199f, -0.03838062f, 0.03103049f, 0.00437773f, 
    -0.01546131f, -0.02165655f, -0.22003825f, 0.13960202f, -0.09024917f, 0.07427672f, -0.11672179f, -0.03727011f, 
    0.10648555f, 0.02125274f, 0.04761184f, -0.08050068f, 0.18756798f, -0.17039190f, -0.12262212f, 0.01262290f, 
    0.09126293f, -0.02021666f, 0.06126882f, 0.08511761f, -0.16517939f, 0.02221411f, -0.06818520f, 0.02459027f, 
    0.04771293f, -0.00882342f, -0.01461362f, 0.04605101f, -0.24017867f, 0.28019249f, -0.06043288f, -0.10617405f, 
    -0.26850286f, 0.10819983f, -0.04855860f, 0.03950903f, 0.07320613f, -0.02204001f, -0.00698555f, 0.13732758f, 
    -0.10009690f, 0.01477932f, 0.10110146f, -0.02275453f, 0.02752829f, 0.11309725f, 0.01418497f, -0.00098672f, 
    -0.09229602f, 0.03201342f, 0.33082923f, 0.04187402f, 0.09690150f, -0.08413969f, -0.05119011f, 0.01278654f, 
    -0.01032324f, -0.06123243f, 0.04798438f, -0.05466784f, 0.04409622f, 0.01342953f, -0.01431756f, 0.09594075f, 
    -0.00667982f, 0.05172415f, 0.07637007f, -0.02661002f, -0.49516115f, 0.33161080f, -0.13780417f, -0.03310807f, 
    -0.29938951f, -0.03323240f, 0.00508151f, -0.06426942f, 0.12160791f, -0.02322222f, 0.09780829f, -0.05425094f, 
    -0.05225880f, 0.10684729f, 0.02233158f, -0.02262940f, -0.07475549f, -0.05917042f, 0.10287121f, -0.00728637f, 
    -0.00882736f, -0.01898964f, 0.13072523f, 0.09358528f, 0.01584839f, -0.08138944f, -0.26129353f, -0.00095383f, 
    -0.05436933f, 0.00040012f, -0.08913966f, -0.00106958f, -0.11609367f, 0.03432122f, -0.01631342f, 0.16761513f, 
    0.04319274f, -0.08796147f, -0.04087676f, 0.08480835f, -0.12014475f, 0.00837263f, 0.08734090f, -0.16522872f, 
    0.15341541f, -0.00950385f, -0.11061604f, 0.03350500f, 0.04307846f, 0.02640649f, -0.01616186f, 0.11387966f, 
    -0.13100834f, -0.02327178f, -0.03742779f, -0.06007523f, -0.07234083f, 0.00476425f, -0.07401305f, -0.10125111f, 
    0.31475097f, -0.30629268f, 0.04394695f, 0.27567875f, -0.41046759f, -0.12293290f, -0.14785089f, -0.01106676f, 
    -0.01222564f, 0.01646322f, -0.01339429f, 0.05317068f, -0.12446597f, -0.09122249f, -0.02008228f, -0.11599935f, 
    -0.15725030f, 0.01643412f, 0.00733387f, 0.01219162f, 0.38535118f, 0.04124134f, 0.09526710f, 0.02412888f, 
    -0.09683561f, 0.06864569f, -0.07249480f, -0.03501519f, 0.00887084f, -0.02357555f, 0.06549259f, -0.10798743f, 
    -0.02692012f, 0.02667911f, -0.11488950f, -0.03129410f, -0.16877137f, 0.01530935f, -0.05098305f, 0.03287236f, 
    -0.17654316f, 0.06435545f, 0.37228340f, 0.03743357f, -0.36378554f, 0.07292054f, 0.05665251f, 0.08658633f, 
    0.13223840f, -0.05842090f, -0.04242858f, -0.01985011f, -0.01218431f, -0.07749482f, -0.06541037f, -0.01837066f, 
    0.08183355f, -0.07801490f, 0.08036590f, 0.02245835f, 0.13123995f, 0.06956429f, 0.05964969f, -0.32347298f, 
    0.14057823f, -0.14000195f, -0.09830402f, -0.09077162f, 0.09321071f, -0.02650745f, 0.01200353f, -0.02261908f, 
    0.01805195f, 0.03853449f, -0.01385666f, -0.04950967f, 0.00544657f, 0.05142982f, 0.14402598f, -0.01969804f, 
    0.23325942f, 0.01425863f, 0.19924879f, -0.01392811f, 0.15983859f, -0.00402652f, 0.02394807f, 0.13040666f, 
    -0.10651064f, -0.05502605f, -0.01416032f, -0.05297755f, -0.06200050f, -0.01410134f, 0.22307329f, 0.03279911f, 
    0.14259739f, -0.07213498f, -0.01093115f, 0.05811966f, 0.17418075f, 0.29940036f, 0.14195523f, -0.17808813f, 
    -0.30490810f, -0.07822151f, 0.08972729f, -0.04707307f, 0.06298347f, -0.11708531f, 0.02461082f, -0.01089118f, 
    -0.05488119f, 0.03712292f, 0.01892406f, 0.02828997f, 0.11234622f, 0.03690051f, 0.04844313f, -0.06630209f, 
    0.22324833f, -0.01923935f, -0.31510845f, 0.13475338f, -0.10777833f, -0.16198231f, -0.04931026f, -0.08280578f, 
    0.05125291f, 0.03195881f, 0.01450263f, -0.00919461f, 0.02193028f, -0.04027759f, -0.00086277f, 0.01900555f, 
    -0.00594520f, 0.11579341f, 0.03968751f, 0.18244615f, -0.30825078f, -0.53117079f, 0.10749180f, 0.08940525f, 
    -0.14370069f, 0.01865577f, -0.07622312f, 0.05940943f, 0.08672929f, 0.06388369f, -0.13797702f, -0.05642052f, 
    -0.06277674f, -0.03671806f, -0.00854393f, -0.00590914f, 0.02222355f, 0.03754425f, 0.01557826f, -0.12684295f, 
    -0.22866869f, -0.65107447f, 0.17770211f, 0.08015964f, -0.13178925f, 0.05201956f, -0.02680584f, 0.10669129f, 
    0.10190828f, 0.04270563f, -0.00428939f, -0.03925197f, -0.11440518f, 0.03493206f, -0.04043696f, -0.02669568f, 
    -0.07762451f, 0.02918959f, 0.04883080f, -0.02695860f, 0.52116936f, -0.12265272f, 0.20392282f, -0.13396761f, 
    0.03349346f, -0.04656223f, -0.09343687f, 0.07104666f, -0.01907091f, 0.03971586f, 0.05441924f, 0.22710662f, 
    0.09818070f, 0.03868866f, 0.03305510f, 0.02733184f, -0.04435930f, 0.15717554f, -0.06714401f, -0.19553189f, 
    -0.09129290f, -0.22460824f, -0.14151825f, -0.16455509f, -0.08046250f, 0.06484587f, -0.03603744f, -0.05801298f, 
    -0.07480415f, -0.18942583f, 0.04230805f, 0.05585540f, 0.10643346f, 0.02241761f, 0.11062783f, 0.13045348f, 
    -0.11593070f, 0.04896053f, -0.12602752f, 0.00514211f, 0.20873633f, 0.07057749f, -0.06137199f, -0.18689740f, 
    0.30862358f, -0.14199694f, -0.08609123f, -0.13450140f, 0.05223800f, 0.02964634f, -0.06129925f, -0.00787825f, 
    0.04056045f, -0.00923700f, 0.04683713f, 0.01288160f, 0.05063946f, -0.08822244f, 0.04470622f, -0.00136482f, 
    -0.04024686f, -0.41711649f, 0.10877334f, -0.05786896f, -0.06972469f, 0.03384434f, 0.01532460f, -0.08326298f, 
    0.05586747f, -0.00382761f, -0.10386051f, -0.02683626f, -0.00068851f, -0.09312902f, 0.09932458f, -0.11943087f, 
    0.00259038f, -0.05082378f, 0.07230812f, -0.06603738f, 0.22315182f, -0.21619731f, -0.09176939f, -0.02149993f, 
    -0.26464579f, -0.10904130f, -0.00731140f, 0.02781377f, 0.02832385f, 0.15075727f, 0.07852954f, 0.03234772f, 
    0.03355651f, 0.08911804f, -0.06365716f, 0.05978460f, 0.08766226f, 0.01326483f, -0.07575761f, 0.01789236f, 
    -0.13615201f, -0.15958443f, -0.33628392f, -0.48744649f, -0.02647812f, -0.02226989f, -0.07382973f, -0.00726621f, 
    0.09833094f, 0.03487602f, 0.10436296f, -0.14452048f, 0.02022455f, 0.05141902f, 0.07146983f, -0.10229154f, 
    -0.06232617f, -0.10730665f, -0.09763692f, -0.12949614f, 0.10772511f, 0.17744036f, 0.15155843f, 0.05042928f, 
    0.15219255f, -0.14383131f, -0.14801352f, 0.00351954f, -0.03461656f, 0.11564202f, 0.22404689f, -0.04225327f, 
    0.06126459f, -0.18238929f, 0.06536842f, -0.08839600f, 0.05144073f, -0.03791177f, 0.00953202f, 0.05963676f, 
    -0.03768563f, -0.07063557f, 0.02274972f, 0.04603772f, -0.16045117f, 0.06245638f, 0.06833224f, -0.07693960f, 
    -0.06918246f, 0.02566073f, 0.21658780f, 0.14510266f, -0.00938269f, -0.07639165f, -0.12863085f, 0.03227573f, 
    0.06183601f, -0.05872874f, 0.05182290f, 0.00846569f, -0.05345902f, -0.07777274f, -0.00356426f, -0.04850206f, 
    -0.11460819f, 0.08588836f, -0.01628691f, 0.05863715f, 0.10208497f, -0.03386525f, -0.08156753f, 0.04937899f, 
    0.11254389f, 0.06197355f, -0.04554905f, 0.01586755f, -0.03204830f, -0.19790135f, -0.07433686f, -0.01557307f, 
    0.35687566f, 0.04223830f, 0.09126768f, -0.03572038f, -0.04890560f, -0.05992657f, 0.03366815f, -0.03342342f, 
    -0.00586274f, 0.01791575f, 0.06165554f, -0.01087353f, -0.07328096f, 0.01589807f, -0.07167614f, 0.11337505f, 
    0.08463754f, -0.01091348f, 0.06294601f, 0.13024852f, 0.49682683f, -0.52902114f, 0.01553849f, 0.03611581f, 
    0.05794345f, -0.15324518f, -0.00598778f, 0.04307809f, 0.09505843f, -0.00279157f, 0.00892245f, 0.06366827f, 
    -0.12398572f, 0.02432789f, 0.06639265f, 0.16886337f, -0.04475712f, -0.01130333f, -0.00047850f, -0.01121034f, 
    -0.15631057f, 0.21657929f, -0.19105908f, -0.11679056f, 0.11059760f, 0.30626532f, -0.13219894f, 0.10776457f, 
    -0.10372503f, 0.07322711f, 0.04823723f, -0.08552729f, 0.08278159f, -0.02576242f, -0.07418936f, -0.05011867f, 
    0.07329337f, -0.24386254f, -0.10515948f, -0.13429976f, -0.05129664f, 0.14126176f, -0.11834399f, 0.13706960f, 
    -0.02116254f, -0.06344121f, -0.00882927f, -0.01319875f, -0.01972044f, -0.01623967f, 0.03905764f, 0.02328350f, 
    -0.07360607f, 0.19727284f, -0.12331686f, 0.02122445f, 0.03672662f, 0.00350617f, -0.10676733f, -0.00224748f, 
    0.11757933f, 0.08929852f, -0.14566787f, -0.02799654f, -0.39997441f, 0.05070488f, 0.05995673f, 0.01780928f, 
    -0.09577346f, 0.07791595f, 0.22085528f, 0.02731119f, 0.05540327f, 0.17531681f, -0.00843666f, -0.06897139f, 
    0.12223868f, -0.07156850f, 0.00174036f, -0.02147106f, 0.32726917f, -0.16250391f, 0.09078894f, -0.04841208f, 
    -0.31025082f, -0.03378491f, 0.06654939f, 0.05042651f, 0.07411276f, 0.13334399f, -0.00457607f, -0.17397095f, 
    0.03295189f, -0.07198878f, 0.08197465f, -0.05779228f, 0.14391516f, -0.02903661f, 0.05899246f, 0.14891031f, 
    0.38507283f, -0.21066691f, 0.08187522f, -0.36772439f, -0.09408474f, 0.00729003f, -0.17391166f, -0.01837193f, 
    0.02582251f, -0.04685132f, -0.09119483f, -0.04132381f, -0.11919610f, -0.01402477f, 0.14446530f, -0.10952228f, 
    -0.05133044f, -0.08277917f, -0.09638532f, -0.05115857f, 0.08981961f, -0.23024394f, 0.12916067f, -0.19717054f, 
    0.05252505f, -0.05377902f, -0.17674114f, -0.00541156f, 0.00464790f, -0.03960534f, -0.13570651f, 0.02167766f, 
    -0.00805034f, -0.01436884f, 0.10621798f, -0.16249937f, 0.00722996f, -0.14472798f, 0.07756351f, -0.01052649f, 
    0.13103507f, 0.04589069f, 0.12771396f, 0.02682866f, 0.20807396f, -0.05104185f, 0.01329477f, -0.04655278f, 
    -0.01028212f, -0.00848528f, -0.07595079f, -0.02730347f, -0.02445836f, 0.02942009f, -0.04404680f, 0.06159621f, 
    0.04860288f, 0.03634031f, 0.05075536f, 0.02740036f, 0.30668437f, -0.14401881f, -0.14045623f, 0.08104362f, 
    -0.10226127f, -0.05310244f, -0.01797211f, 0.00402183f, 0.08042131f, 0.12401763f, 0.01900394f, -0.10345523f, 
    0.01323153f, -0.00119183f, 0.10805999f, 0.12687199f, 0.04956470f, -0.05120302f, -0.20801358f, 0.02110315f, 
    -0.63062692f, 0.25766602f, -0.18387558f, -0.17416534f, 0.19195172f, -0.10255960f, 0.20345119f, 0.02327068f, 
    -0.12582083f, 0.10746054f, 0.00251561f, -0.00538235f, 0.10012146f, -0.06485769f, -0.10304584f, -0.06469647f, 
    -0.01892680f, 0.14639911f, -0.06855492f, 0.09453599f, 0.18774638f, 0.02568412f, -0.04987653f, 0.09040773f, 
    -0.23436250f, -0.08591546f, 0.03776773f, -0.06023957f, 0.14151005f, -0.02536276f, -0.01922074f, -0.07230051f, 
    -0.07168674f, 0.00203112f, 0.01876178f, 0.00329094f, -0.04987427f, 0.04032829f, -0.07834522f, 0.02582145f, 
    0.24648595f, 0.10009758f, 0.08571718f, -0.00715769f, 0.25913939f, -0.16284470f, 0.02297358f, 0.09302451f, 
    -0.04111971f, 0.04951876f, -0.02072195f, -0.04484213f, 0.09223431f, 0.03394846f, 0.07316181f, 0.12906884f, 
    -0.11091267f, -0.04218246f, 0.00010265f, 0.09929342f, 0.09272692f, 0.18399188f, 0.10898986f, 0.03553206f, 
    0.39678624f, -0.25594822f, 0.03426890f, 0.04828432f, -0.06414533f, 0.04273720f, 0.02612596f, -0.11395857f, 
    0.12062223f, 0.06604318f, -0.00077419f, -0.03744007f, 0.06329143f, 0.02157951f, -0.03385713f, 0.09077266f, 
    0.09688503f, -0.43131691f, -0.06892480f, 0.02586074f, 0.03846029f, 0.05983870f, 0.01546752f, 0.04358537f, 
    -0.04723044f, -0.06721501f, 0.10373263f, 0.03672942f, 0.05325563f, -0.00066979f, -0.10073773f, -0.00763301f, 
    -0.12646151f, -0.00670253f, -0.01935909f, -0.02019802f, -0.51101065f, -0.05094634f, -0.06209615f, -0.03770326f, 
    -0.07034591f, 0.00620044f, -0.11724536f, -0.04087871f, 0.02393057f, -0.03954728f, 0.05069309f, 0.02241139f, 
    0.04216916f, -0.05880561f, -0.02331418f, 0.04236043f, -0.09371087f, 0.02484384f, 0.04055341f, -0.12505889f, 
    -0.06287202f, 0.12205121f, -0.25604579f, 0.01434861f, -0.31386709f, 0.08078861f, -0.03414690f, -0.03770525f, 
    -0.07898874f, 0.00351339f, -0.02293328f, 0.09457323f, -0.13272266f, 0.01855845f, 0.11542489f, -0.06004912f, 
    -0.01137975f, 0.00070397f, -0.01067824f, -0.01239179f, 0.27489123f, -0.02938603f, 0.14313738f, 0.09922380f, 
    0.05441601f, -0.02207810f, -0.11209471f, -0.00053501f, -0.01875158f, -0.02364920f, -0.03719857f, -0.02796370f, 
    0.04755315f, 0.08663128f, 0.00676047f, 0.12178909f, 0.03079463f, -0.16049618f, -0.10980846f, -0.02195563f, 
    -0.15581296f, 0.03167437f, -0.02271559f, 0.00052512f, 0.21573789f, -0.11615825f, -0.07221323f, -0.02337623f, 
    -0.01158838f, -0.02920912f, 0.11800425f, 0.12575941f, 0.06985465f, 0.02349119f, 0.08728212f, 0.04469595f, 
    -0.11132210f, 0.06474832f, 0.07045171f, 0.01279872f, 0.07208565f, -0.03831161f, -0.15662792f, 0.05069957f, 
    -0.12314333f, 0.07025237f, 0.05968694f, -0.02492115f, 0.04147068f, 0.01388604f, -0.10998172f, 0.03860030f, 
    -0.02700334f, -0.01311061f, -0.01596010f, 0.13731185f, 0.06403401f, -0.06622085f, -0.01652876f, 0.03446473f, 
    -0.46727192f, 0.03025027f, -0.13471872f, -0.07308063f, -0.30005816f, 0.03087764f, 0.00704204f, -0.01790615f, 
    -0.01404282f, -0.03717966f, -0.04069320f, 0.04849271f, -0.04587727f, 0.00032889f, -0.01290196f, -0.01542078f, 
    -0.09593648f, -0.07019793f, -0.07476491f, -0.05341559f, -0.03768576f, -0.06210403f, 0.05703641f, -0.10883360f, 
    -0.08088587f, -0.09602824f, 0.07316760f, 0.12694900f, -0.01423863f, 0.06170527f, -0.01039172f, -0.09531599f, 
    0.09869224f, 0.05769240f, 0.02807586f, -0.02467986f, 0.01765387f, -0.12202819f, -0.04300558f, 0.16860922f, 
    0.02629953f, -0.02684269f, -0.00121931f, -0.11755250f, 0.05936994f, 0.03466185f, 0.04537847f, 0.08303508f, 
    0.06928723f, 0.03236055f, -0.11930033f, -0.03598474f, 0.09656887f, 0.06297947f, -0.03955405f, 0.07766216f, 
    -0.03299208f, -0.17468256f, -0.09167127f, -0.14105925f, -0.66329277f, -0.32540667f, -0.34113538f, -0.28077447f, 
    0.01257194f, -0.01943070f, -0.06997375f, -0.07927685f, 0.01207820f, 0.04762415f, 0.01983175f, -0.00554224f, 
    0.01535309f, -0.07275392f, 0.00088737f, 0.09924906f, -0.09608273f, -0.15720600f, 0.02741445f, -0.00710673f, 
    -0.08184223f, -0.08050688f, 0.12996334f, -0.14950235f, 0.00515634f, 0.09554675f, -0.10565928f, 0.01674052f, 
    0.05633023f, 0.04488155f, -0.07125726f, -0.04630288f, -0.02216097f, -0.16933621f, -0.10497881f, 0.06090119f, 
    0.08739504f, 0.04562877f, 0.09012428f, -0.13626012f, 0.20919773f, 0.33182457f, 0.08434779f, 0.14723273f, 
    0.19181739f, 0.02379316f, -0.09810918f, 0.05362710f, 0.03986987f, 0.05882138f, 0.01430457f, -0.01380036f, 
    -0.11319354f, 0.08169136f, -0.09992602f, 0.03082914f, 0.10358826f, 0.11163763f, -0.05471849f, 0.02836186f, 
    -0.03775099f, -0.18017471f, 0.17832041f, -0.08161013f, -0.05085727f, 0.04951149f, -0.05866040f, -0.04324707f, 
    -0.01043306f, 0.11278634f, -0.06446867f, 0.05016889f, 0.02941268f, 0.00974814f, -0.06479679f, -0.03178576f, 
    -0.13493828f, -0.02032997f, -0.05484924f, 0.03527804f, 0.22963929f, -0.10073695f, 0.00689370f, 0.13650686f, 
    0.13540918f, -0.22853000f, -0.12601018f, -0.08394884f, -0.00960184f, -0.01743742f, 0.03221844f, -0.06714655f, 
    -0.04204668f, 0.06491902f, 0.00329736f, 0.00991831f, -0.02894746f, 0.00938987f, -0.03778511f, -0.00712974f, 
    -0.21733861f, -0.06757173f, -0.14526755f, -0.23667175f, -0.17159198f, 0.07618128f, 0.04804379f, 0.07375839f, 
    -0.04720246f, 0.01337215f, -0.05367353f, 0.01448331f, -0.05087077f, -0.01138250f, -0.05510729f, 0.02863874f, 
    0.06239237f, 0.13918459f, -0.08922780f, 0.00622009f, -0.21700226f, 0.09416103f, 0.05072961f, -0.02808735f, 
    0.02629254f, 0.05104846f, 0.10961667f, 0.08772621f, 0.02863068f, -0.10323331f, -0.04639069f, 0.02296729f, 
    -0.02829663f, -0.02039253f, 0.05631319f, -0.03492403f, -0.11923995f, 0.03503262f, -0.01112565f, -0.01527371f, 
    0.00362815f, 0.11092487f, 0.05154778f, 0.11799429f, 0.14539012f, -0.05482300f, -0.08361828f, -0.10061242f, 
    0.20579360f, 0.08148185f, -0.02997163f, -0.00787738f, -0.06026714f, -0.00633183f, 0.03749806f, -0.11231060f, 
    -0.02127640f, -0.07569392f, -0.11522014f, 0.04915707f, 0.03635126f, -0.10267383f, 0.09717081f, -0.10923674f, 
    -0.26571983f, 0.02080599f, 0.05973149f, -0.00534837f, -0.04686628f, -0.00760464f, 0.04239143f, 0.04679471f, 
    0.04766727f, -0.11676449f, -0.06555002f, 0.03679895f, 0.03654110f, 0.08282389f, 0.07385404f, -0.05065126f, 
    -0.20669530f, -0.00930857f, 0.14148489f, -0.14116062f, 0.02431248f, -0.07021419f, -0.04686685f, 0.01515349f, 
    0.08281514f, 0.04241329f, -0.05043403f, 0.00288663f, 0.08634064f, 0.05339557f, 0.04645117f, 0.02783388f, 
    -0.07460869f, -0.03184549f, 0.00773049f, -0.02036894f, 0.22586533f, 0.05298165f, 0.10991939f, -0.04211843f, 
    -0.24286073f, -0.03873853f, -0.06024696f, 0.11775923f, -0.02222831f, 0.03639200f, -0.05080812f, -0.03283050f, 
    0.12891868f, -0.06460483f, -0.01236777f, -0.02855302f, -0.16159046f, -0.04637953f, 0.08622311f, 0.00709837f, 
    -0.29592088f, -0.16819479f, -0.01508295f, -0.11705160f, -0.06228621f, 0.05002562f, -0.16009609f, -0.15975635f, 
    0.05072021f, -0.03390926f, -0.06234633f, 0.00970086f, -0.03940622f, 0.02102517f, 0.05890239f, 0.06336709f, 
    -0.08722211f, 0.12086047f, 0.02622535f, 0.01915198f, -0.09212427f, 0.12689850f, 0.03472189f, -0.18689559f, 
    0.10588863f, 0.02415149f, 0.14493756f, 0.15929201f, -0.01579132f, -0.08605040f, -0.03122807f, 0.08702978f, 
    0.03758182f, -0.03994579f, -0.05404499f, 0.05794203f, -0.02335524f, -0.00879947f, -0.08702885f, -0.06088680f, 
    -0.36520621f, 0.03781920f, 0.10913367f, 0.06728404f, 0.16833416f, -0.16212869f, -0.03749889f, -0.30576599f, 
    0.00087630f, -0.00367147f, -0.04721138f, -0.08267397f, 0.00152661f, -0.04176273f, 0.14336525f, -0.03457614f, 
    0.06925374f, -0.11149938f, 0.02493667f, 0.04854978f, -0.10750250f, -0.16842373f, 0.06568350f, -0.08244935f, 
    0.01416201f, -0.07151174f, 0.09560716f, -0.01724866f, 0.06737883f, -0.07752816f, 0.04066113f, -0.05700355f, 
    0.04431956f, -0.16155374f, 0.06585974f, 0.06687587f, -0.04629976f, -0.00460723f, 0.03906510f, 0.05176095f, 
    -0.09323626f, 0.03679171f, -0.13252902f, -0.25947005f, -0.08406786f, 0.03119013f, 0.02316497f, 0.14976263f, 
    0.00720416f, 0.08901522f, -0.12134671f, 0.07091507f, 0.04663465f, -0.11549994f, -0.03387116f, 0.01206398f, 
    0.01383593f, 0.13319939f, 0.03972289f, 0.01567460f, 0.25410628f, -0.28697401f, 0.02475564f, -0.24544875f, 
    -0.08244150f, 0.09138773f, -0.16997056f, 0.11395055f, 0.00201986f, 0.02692795f, -0.10869399f, 0.02501332f, 
    0.03720485f, 0.01175796f, -0.05725326f, 0.01399894f, -0.10556319f, 0.10316810f, 0.00297810f, -0.05704366f, 
    0.15124297f, -0.19574329f, 0.08610455f, -0.12070405f, -0.00275885f, 0.11415248f, 0.00594795f, 0.09402102f, 
    -0.04951994f, 0.00604250f, -0.01602128f, 0.04919484f, 0.05589259f, -0.05477308f, -0.08451066f, -0.01172546f, 
    -0.05921386f, 0.00254443f, -0.19388950f, -0.06158574f, 0.43212062f, -0.17226829f, 0.06566812f, -0.02271015f, 
    0.16392718f, -0.22364354f, 0.06522004f, -0.23423749f, 0.00603433f, 0.02511309f, -0.02869319f, -0.05988498f, 
    0.03500059f, -0.00235759f, -0.06202045f, -0.01736344f, 0.06131547f, 0.02820901f, 0.03768170f, 0.03845415f, 
    0.37597188f, 0.03678031f, -0.38441429f, -0.07913619f, -0.21373887f, -0.02501800f, -0.03233797f, 0.02474879f, 
    0.03652410f, -0.07982715f, 0.00746420f, 0.02486368f, -0.05006598f, -0.02043891f, 0.01214574f, -0.03730725f, 
    -0.04739180f, -0.17484714f, 0.07384736f, 0.02377131f, 0.46975401f, 0.00356863f, -0.15362555f, 0.22507498f, 
    0.03760111f, -0.17636544f, 0.06253894f, -0.05634347f, -0.06550873f, 0.16328798f, -0.01361621f, 0.11115863f, 
    0.05328457f, 0.01967129f, -0.02888466f, 0.10362917f, -0.11231072f, -0.08337786f, 0.07318292f, 0.01484521f, 
    -0.12700421f, -0.03760247f, 0.01522587f, -0.03895573f, 0.02753839f, 0.11070686f, 0.09052143f, -0.01207521f, 
    -0.05933012f, -0.05316610f, -0.01613289f, -0.04533469f, -0.08267839f, -0.02294997f, -0.03882102f, 0.00222136f, 
    0.02201607f, -0.01791042f, -0.19949068f, 0.02059938f, 0.18548435f, -0.03454280f, -0.07464615f, -0.11334354f, 
    -0.04284037f, 0.04290313f, 0.09650002f, 0.01291932f, -0.04129094f, -0.04622538f, -0.02779974f, -0.07509980f, 
    -0.02343267f, -0.12402911f, -0.02075594f, -0.05168800f, -0.11836401f, -0.08050476f, -0.09821354f, -0.03135077f, 
    0.29994321f, 0.14723182f, -0.10734929f, -0.22349466f, -0.04681643f, -0.02822498f, 0.04602008f, 0.02938617f, 
    0.05100138f, 0.00243834f, -0.07473931f, -0.02365785f, -0.04074145f, -0.08018876f, -0.10447125f, 0.06031232f, 
    0.12779684f, 0.01300602f, 0.09785179f, -0.00358173f, 0.32394344f, -0.09186275f, -0.02975869f, -0.09387095f, 
    0.10394088f, 0.06929126f, -0.05418595f, -0.16932127f, 0.05942267f, 0.09821460f, 0.00994020f, 0.10567776f, 
    -0.03051898f, 0.05300719f, 0.01736468f, -0.04377405f, 0.00465414f, -0.05258941f, -0.01932417f, -0.10522244f, 
    0.32073855f, -0.26815787f, 0.08370708f, -0.03947244f, 0.14846538f, -0.09733030f, -0.12625244f, -0.00724421f, 
    -0.01096816f, 0.05032137f, 0.05374385f, 0.02360199f, 0.00184703f, -0.13474546f, 0.01561968f, 0.03171499f, 
    -0.02368120f, -0.02716203f, -0.04402213f, 0.00631741f, -0.09235590f, 0.21730028f, 0.06108883f, -0.21882054f, 
    0.01627171f, 0.07601456f, 0.14178510f, 0.14513154f, -0.06185508f, -0.08864683f, -0.09440576f, 0.09726868f, 
    -0.00140812f, -0.20254187f, 0.01690608f, -0.00567435f, 0.01965176f, 0.06393304f, -0.04063285f, -0.03512812f, 
    0.11785656f, 0.12194676f, -0.03551370f, 0.00272848f, 0.06353550f, 0.12881288f, 0.02867317f, 0.05602990f, 
    0.09546588f, 0.11718625f, -0.04573827f, 0.00011071f, -0.03544572f, 0.09220652f, -0.08013604f, -0.12049650f, 
    0.02561639f, 0.07733262f, -0.08624767f, -0.03795252f, 0.36959073f, -0.06338428f, 0.30412355f, -0.01611331f, 
    0.26480749f, -0.07528030f, -0.20741993f, -0.12572627f, 0.08266025f, 0.15459490f, 0.11452097f, -0.08734470f, 
    0.03963078f, -0.00395104f, -0.01515452f, 0.04009881f, -0.14784975f, 0.02409931f, -0.00431276f, -0.00713933f, 
    0.09876361f, -0.02620110f, -0.19426878f, -0.02344656f, -0.08267786f, -0.04434000f, 0.09840592f, -0.00968166f, 
    -0.00571565f, -0.19401269f, -0.01781394f, -0.03326072f, -0.06771884f, 0.02115037f, -0.07239047f, 0.02879206f, 
    0.10687038f, -0.04172436f, 0.05140445f, -0.15062009f, -0.04934480f, -0.36296991f, 0.04704131f, -0.22033946f, 
    -0.26781452f, -0.08290920f, 0.03735485f, -0.12822062f, 0.00612393f, 0.02130734f, -0.01836547f, -0.02599678f, 
    -0.03136575f, -0.04461046f, 0.08339537f, -0.07770446f, 0.06321193f, 0.17012173f, 0.00119392f, -0.17721638f, 
    0.15890829f, -0.44662094f, -0.16446677f, -0.24725172f, -0.64999872f, -0.03748851f, 0.02465883f, -0.03312407f, 
    -0.07983205f, 0.02228798f, 0.00793829f, 0.03238817f, -0.05502605f, -0.09455902f, -0.04725006f, 0.03290552f, 
    0.04727279f, 0.14897564f, -0.02563798f, -0.00269685f, 0.10299339f, -0.05330440f, -0.08336085f, -0.10400197f, 
    -0.02924183f, -0.03938433f, -0.00290244f, 0.13366129f, -0.07285267f, -0.11422642f, -0.13723081f, -0.01138235f, 
    -0.06874086f, 0.01581052f, -0.05919143f, -0.00102610f, 0.04853439f, 0.08581267f, 0.08231472f, -0.03479314f, 
    0.29397747f, 0.14841081f, 0.03605879f, 0.18658611f, -0.15303273f, -0.00066262f, -0.10097281f, 0.15767969f, 
    0.01969161f, 0.04713603f, -0.01264899f, -0.01488441f, 0.08631902f, -0.00572708f, -0.06011542f, 0.04452068f, 
    0.01406811f, 0.03547164f, 0.04076400f, -0.07099812f, 0.00112735f, 0.02158841f, -0.12585109f, -0.27853841f, 
    0.13933806f, 0.09447606f, 0.04292934f, 0.07585116f, 0.01681808f, -0.05073258f, -0.07585017f, 0.01288493f, 
    0.06740276f, -0.01518409f, -0.05259184f, -0.00997267f, -0.09585830f, -0.08097712f, -0.04034095f, 0.03932312f, 
    0.07593192f, 0.03408286f, 0.03361236f, 0.14053982f, 0.00054486f, 0.07054208f, -0.03151041f, 0.01981401f, 
    0.04227395f, -0.07474996f, -0.05442016f, -0.08919518f, -0.05677212f, -0.03084631f, 0.00985171f, -0.02086448f, 
    0.00054944f, -0.02485581f, -0.08694113f, -0.11820318f, 0.05905540f, -0.03200516f, -0.06670529f, -0.05740179f, 
    -0.20259997f, -0.02435450f, -0.10474726f, 0.02281184f, -0.03493678f, 0.05746665f, -0.06145278f, 0.04303755f, 
    0.05438761f, -0.02195970f, 0.03987857f, -0.05205590f, -0.00731712f, 0.01024652f, 0.02941440f, 0.02181884f, 
    0.31674343f, 0.20389903f, 0.02327360f, 0.11250228f, 0.19815403f, -0.04961893f, 0.17209831f, 0.03979845f, 
    0.11939748f, 0.12565774f, -0.00805824f, 0.03644729f, 0.02703869f, -0.02413143f, 0.03863177f, 0.06067566f, 
    -0.07480731f, 0.21812175f, 0.11385620f, 0.09641301f, -0.53785497f, -0.29290006f, -0.17465635f, 0.07598042f, 
    -0.23158284f, -0.05521951f, -0.04786280f, 0.14828092f, 0.06458002f, -0.14976433f, -0.04449391f, -0.10355571f, 
    -0.04093860f, -0.11763683f, -0.00980482f, 0.05877393f, -0.06950388f, 0.00013126f, -0.09220573f, -0.07530110f, 
    0.15896246f, -0.31176612f, 0.01120551f, -0.22485125f, -0.21764135f, 0.03737912f, 0.00238065f, 0.09871065f, 
    -0.12017039f, -0.02570049f, -0.08496440f, -0.01250680f, 0.00281309f, -0.13709469f, 0.01466853f, 0.00976040f, 
    0.02889588f, 0.02983158f, -0.01991684f, 0.07428699f, 0.15200755f, 0.19766831f, 0.05782570f, 0.17329822f, 
    0.07523174f, -0.05893166f, 0.03521844f, 0.01540110f, -0.02918099f, 0.10928953f, -0.07162388f, -0.02245141f, 
    0.00649091f, -0.13113782f, -0.02295196f, -0.06622358f, 0.00629624f, 0.07414912f, -0.00099961f, -0.04318447f, 
    -0.12346338f, 0.03143473f, -0.24886218f, 0.08929595f, -0.23225124f, 0.00353604f, 0.00853208f, -0.02524919f, 
    0.06660563f, -0.08686541f, -0.12390892f, 0.03555904f, 0.06034024f, 0.11016926f, 0.02484873f, 0.03195824f, 
    -0.19280076f, 0.02746630f, -0.05524761f, -0.00251899f, 0.07416842f, -0.26868719f, 0.03393612f, -0.03930468f, 
    -0.08986492f, -0.10180029f, -0.12005878f, 0.02155106f, 0.01081417f, 0.11898362f, -0.00122353f, 0.05771347f, 
    -0.00045102f, -0.01978312f, -0.06224825f, -0.05661412f, 0.07085568f, -0.14554717f, -0.04132306f, -0.07206316f, 
    0.31217664f, 0.25128648f, -0.26870337f, -0.06733464f, 0.07683662f, -0.06375643f, 0.00142878f, 0.01968684f, 
    0.06387448f, -0.07897998f, -0.05896224f, -0.03740102f, -0.09696849f, -0.04345285f, 0.16598909f, -0.05566989f, 
    -0.04932350f, 0.19903514f, -0.06967105f, 0.01831325f, -0.40025645f, -0.43419814f, -0.23964559f, 0.18585090f, 
    0.29814520f, 0.04444050f, 0.20834680f, -0.02981680f, -0.00686236f, -0.02455466f, 0.04478012f, 0.02533632f, 
    -0.05451816f, -0.14350189f, 0.02719712f, -0.10039394f, -0.00623845f, -0.13080892f, 0.12182415f, -0.08673544f, 
    0.14366716f, -0.02393821f, -0.14290231f, -0.08401285f, -0.10044762f, -0.03653598f, 0.01801876f, -0.05516006f, 
    0.07412767f, -0.01943169f, -0.13511527f, -0.02189236f, 0.08870207f, -0.00875714f, 0.01497220f, -0.03003868f, 
    0.00802794f, 0.05301422f, 0.03913393f, 0.01476923f, -0.00638642f, -0.10018075f, -0.26812297f, -0.04444483f, 
    -0.06824791f, -0.02655676f, 0.05761830f, -0.10772631f, -0.04206843f, -0.02462610f, 0.00519828f, 0.05389583f, 
    0.02128057f, -0.02291314f, -0.00431382f, 0.02608941f, -0.05341304f, -0.03406138f, 0.06847214f, -0.08402594f, 
    0.16933280f, -0.30494246f, 0.13385940f, -0.10626243f, 0.12288760f, -0.02391180f, 0.02010129f, 0.01800616f, 
    -0.00655884f, 0.13215947f, 0.07928254f, -0.00046445f, -0.04262368f, -0.03155991f, 0.01651766f, 0.03826582f, 
    -0.10356753f, 0.08102842f, -0.05843146f, 0.05871573f, 0.16892874f, 0.05747446f, -0.11894523f, 0.02484884f, 
    0.03191957f, -0.04200931f, 0.04264604f, -0.00964784f, -0.03673643f, 0.03502095f, -0.03329618f, -0.03221284f, 
    -0.04566354f, 0.05521195f, -0.00564590f, -0.09151281f, 0.03847155f, 0.02821879f, -0.00853065f, -0.00360039f, 
    -0.12961981f, -0.45303342f, -0.41461936f, -0.00088844f, -0.07954588f, -0.18301235f, -0.11187471f, -0.09396120f, 
    0.05801643f, -0.01377619f, -0.08339898f, -0.12012790f, 0.00921592f, 0.00582482f, -0.04276711f, 0.01735564f, 
    0.02229112f, -0.03865039f, 0.00402421f, 0.05735550f, -0.15563667f, 0.05333211f, 0.03605296f, 0.00835889f, 
    -0.04231282f, -0.12959823f, -0.21828456f, 0.02973367f, -0.02594419f, -0.00677465f, -0.01524787f, 0.06323255f, 
    -0.10281515f, 0.02097744f, 0.11384527f, 0.07040181f, 0.02568829f, 0.01740087f, 0.18239427f, 0.02356065f, 
    -0.36856145f, 0.46060523f, 0.12235463f, -0.00796321f, -0.05239637f, -0.01990671f, 0.04211040f, -0.06682713f, 
    0.10875268f, -0.07586748f, -0.01311944f, -0.01169746f, -0.15146998f, 0.11978468f, -0.16673352f, -0.08529731f, 
    0.01370062f, -0.11100346f, 0.08380813f, 0.02004070f, 0.10121535f, -0.18252988f, 0.15349589f, 0.06005422f, 
    -0.08541258f, -0.03969680f, -0.16529255f, 0.01866915f, -0.06222963f, -0.11876982f, -0.11885426f, 0.02307003f, 
    -0.10878972f, -0.00302619f, 0.11044526f, 0.06787059f, 0.08235160f, 0.04307252f, 0.13229439f, 0.00256900f, 
    -0.07159822f, -0.58747244f, -0.47824255f, 0.17865124f, 0.06200972f, 0.09289659f, 0.04779652f, 0.03726676f, 
    -0.05013630f, -0.09054399f, 0.01337700f, 0.03253662f, -0.08340178f, 0.02459489f, -0.06962773f, 0.02873568f, 
    0.09672459f, 0.02879206f, -0.00287083f, -0.05383446f, 0.25500444f, -0.10377089f, -0.08280351f, 0.05657929f, 
    0.11693393f, -0.06229703f, -0.01115486f, 0.01603972f, 0.07982419f, -0.05786118f, -0.07161743f, 0.07236399f, 
    0.07288189f, -0.09224700f, -0.03513854f, -0.06258546f, 0.13314256f, -0.05351259f, -0.01486342f, 0.04551329f, 
    -0.32767656f, 0.27616027f, 0.04692753f, 0.20796946f, 0.12457812f, -0.00346735f, 0.19060855f, -0.01635942f, 
    0.10736009f, -0.02834742f, -0.02471601f, 0.01910214f, -0.06277072f, -0.13773169f, -0.02651663f, 0.00304412f, 
    -0.03632097f, 0.05521074f, 0.06650849f, 0.02293035f, 0.23735590f, 0.10504871f, -0.03532539f, 0.09341707f, 
    -0.01349262f, -0.01950839f, -0.09971409f, -0.01808918f, 0.11693397f, -0.07726023f, -0.02141013f, -0.05223736f, 
    -0.03388959f, -0.03084384f, -0.02858103f, -0.07956880f, -0.04525914f, 0.00412434f, 0.01003325f, 0.00381003f, 
    -0.07788934f, -0.08891384f, 0.12015330f, -0.09955866f, -0.04414552f, -0.07172954f, -0.16778709f, -0.10507762f, 
    0.10059524f, -0.04378047f, 0.11891902f, -0.05455870f, 0.07292154f, -0.05627428f, 0.00681813f, -0.05155776f, 
    0.01303375f, 0.07151286f, 0.02298592f, 0.03652443f, -0.28994021f, -0.52990985f, -0.33319774f, 0.15032010f, 
    0.18865952f, -0.02477859f, 0.02032516f, 0.11112415f, 0.03996593f, -0.14027703f, 0.05565683f, -0.00295380f, 
    -0.10312141f, -0.18317215f, 0.00676359f, 0.00417869f, -0.04583025f, 0.03016910f, -0.00591499f, -0.12200344f, 
    -0.39410356f, 0.22548813f, -0.09267424f, -0.05847831f, -0.07811039f, -0.12679580f, -0.10193007f, 0.06382062f, 
    0.13026631f, 0.06196381f, -0.05821548f, -0.09423941f, 0.03802478f, -0.00400503f, -0.13062957f, 0.02130117f, 
    0.07113434f, -0.02844862f, 0.03775033f, 0.11197528f, -0.28574970f, -0.06558864f, -0.14131050f, -0.02285545f, 
    -0.09320657f, -0.00791557f, -0.16441005f, 0.13800277f, -0.06619454f, 0.00074541f, -0.08570227f, 0.01118612f, 
    -0.03467307f, 0.04454306f, -0.00987964f, 0.01939659f, 0.00752044f, -0.10792365f, 0.06750961f, -0.00410906f, 
    -0.26288643f, 0.36215889f, 0.03161873f, 0.28123012f, 0.19067767f, 0.06983267f, 0.09484198f, 0.07254959f, 
    0.03710187f, 0.08053669f, -0.17367244f, -0.01180468f, 0.07091318f, -0.10322810f, -0.04857223f, -0.05454701f, 
    0.08105076f, 0.00553558f, 0.06500825f, -0.06075276f, 0.09118514f, 0.25125259f, 0.05761372f, 0.13002650f, 
    -0.08613921f, -0.03477960f, 0.08196653f, -0.06460886f, -0.00379259f, -0.05148114f, -0.02462397f, 0.00206429f, 
    -0.04769760f, 0.02823376f, -0.04640094f, 0.13431560f, -0.14925055f, 0.17429426f, -0.00385342f, -0.04611144f, 
    0.22141160f, 0.18050747f, 0.13416386f, 0.08962546f, -0.06674302f, -0.08809280f, -0.02428935f, -0.03282524f, 
    -0.11021172f, 0.01076838f, -0.05605256f, 0.05435953f, -0.01951480f, -0.13113557f, -0.00334103f, -0.00155906f, 
    0.01752699f, 0.07827196f, 0.04647456f, 0.12206882f, 0.66330808f, 0.53217262f, -0.04457915f, 0.07420602f, 
    0.09339917f, 0.12843314f, 0.07037849f, -0.02817138f, 0.14918810f, 0.01945494f, 0.01895762f, -0.08530170f, 
    -0.10927445f, -0.04279108f, 0.03886164f, -0.13076182f, 0.02292165f, 0.05076435f, 0.11719035f, 0.03052874f, 
    0.24539866f, -0.14418188f, 0.01450005f, 0.12216948f, -0.10679562f, -0.01156357f, -0.10611245f, 0.02595091f, 
    -0.07460450f, -0.07463626f, -0.02117759f, 0.04596631f, 0.00403180f, 0.05972183f, 0.14741628f, 0.04812570f, 
    -0.07061901f, -0.11489351f, 0.00236140f, -0.00819600f, -0.56195337f, -0.02518660f, -0.34234676f, -0.28866398f, 
    0.00734203f, -0.10413402f, -0.04311829f, -0.01164845f, -0.05261748f, -0.06300998f, -0.03610176f, -0.04110248f, 
    0.14585634f, 0.09139439f, 0.12252972f, -0.02571402f, -0.16931906f, -0.11222532f, 0.00834738f, 0.09860949f, 
    -0.15112689f, 0.14987639f, -0.20916934f, 0.15115944f, -0.21475765f, -0.08225864f, -0.03066461f, 0.01338950f, 
    0.08726281f, -0.06949798f, -0.05313180f, -0.02237905f, 0.04745749f, 0.07735754f, 0.08113597f, -0.06972502f, 
    -0.05276205f, 0.19237861f, 0.00039169f, 0.12070367f, -0.52684194f, 0.21809995f, 0.06028428f, 0.20706581f, 
    0.11187278f, 0.08132451f, -0.10271771f, -0.01404959f, 0.09649470f, 0.13602713f, -0.02663302f, 0.03358867f, 
    0.06273947f, 0.00587500f, 0.05831207f, 0.01926372f, 0.03134206f, 0.01431417f, 0.06288002f, -0.05781031f, 
    0.13748184f, -0.01437670f, 0.16264307f, 0.16907988f, -0.25186887f, -0.02987294f, 0.05220705f, 0.13308690f, 
    -0.04456810f, -0.07254274f, 0.05319723f, -0.05757386f, -0.00819517f, 0.00262850f, 0.05869158f, -0.08092607f, 
    -0.05071769f, 0.07397363f, 0.01661095f, 0.03207415f, -0.28411984f, 0.15972261f, -0.06707489f, -0.15112346f, 
    0.01703465f, 0.01867693f, -0.02365478f, -0.15711443f, 0.10755245f, 0.04634538f, 0.00913083f, -0.04925998f, 
    0.04735758f, 0.00464630f, -0.09516809f, 0.01626765f, 0.11498756f, -0.08928278f, 0.04324554f, 0.02204216f, 
    -0.72870821f, -0.16212222f, 0.06988870f, 0.12985265f, 0.15452340f, 0.09835105f, -0.02695372f, 0.03555592f, 
    0.04162812f, 0.14608870f, -0.08487526f, 0.01706080f, 0.11328643f, 0.12465306f, 0.02218970f, 0.00459165f, 
    0.02807107f, -0.05641064f, 0.06529216f, -0.07698641f, -0.09288672f, -0.10499503f, 0.04169247f, 0.20078805f, 
    -0.04341781f, 0.05820590f, 0.02756721f, -0.05820329f, 0.01559099f, -0.02055386f, 0.18787825f, 0.00019347f, 
    0.06617247f, -0.00583467f, 0.05033046f, -0.14563999f, -0.08078403f, 0.10883921f, -0.06584544f, -0.00509427f, 
    -0.11855203f, 0.26218963f, 0.10146628f, 0.04134328f, -0.16649152f, 0.02960240f, -0.04318236f, -0.06301735f, 
    -0.02531518f, -0.16272844f, -0.02241785f, 0.02483504f, -0.03428061f, 0.02503684f, 0.04280428f, 0.03425285f, 
    -0.06553818f, -0.07917264f, -0.12123912f, -0.04006231f, 0.13838273f, 0.11693053f, -0.13625374f, -0.22545239f, 
    -0.09215521f, 0.02321848f, 0.09616781f, 0.05595596f, -0.02240889f, -0.02147198f, -0.06577855f, 0.00500478f, 
    0.02009355f, -0.03781260f, -0.08774194f, 0.00353629f, -0.21964201f, 0.07322984f, -0.13228147f, -0.06880172f, 
    0.10602719f, -0.18044145f, 0.14653395f, 0.05097149f, -0.01424892f, -0.02590933f, 0.04823726f, 0.01767925f, 
    0.00953100f, -0.01492586f, 0.02781047f, -0.03434734f, 0.11085461f, -0.05589237f, 0.06299493f, 0.01635373f, 
    0.00687892f, 0.04306547f, 0.05532776f, 0.13279505f, -0.21021517f, -0.49288324f, 0.13044614f, 0.18395944f, 
    -0.00539350f, -0.20034814f, -0.05917935f, 0.11294042f, -0.12963469f, -0.00395924f, 0.07182362f, -0.03200807f, 
    -0.08176054f, -0.14442854f, 0.06405039f, 0.07205766f, -0.09926078f, 0.03751091f, -0.04551545f, 0.00721514f, 
    -0.47676030f, -0.17371202f, -0.03653142f, 0.17787455f, 0.27564880f, 0.03046079f, -0.01449663f, 0.02385546f, 
    0.03371429f, -0.00741656f, -0.00102106f, -0.03882542f, -0.13849249f, -0.09033901f, -0.01547285f, -0.05370836f, 
    -0.04523195f, -0.00895543f, 0.03920155f, 0.10493265f, -0.28470328f, 0.32914633f, 0.02325714f, -0.38226497f, 
    -0.10753988f, 0.13560379f, -0.11110810f, -0.06665890f, -0.03578812f, -0.19817443f, 0.06843203f, -0.09742390f, 
    -0.12946734f, 0.01590840f, -0.08698831f, 0.06829634f, -0.10606806f, -0.08823501f, -0.03670902f, -0.08391422f, 
    0.30419302f, -0.20992666f, -0.01536083f, 0.10103738f, -0.22544071f, -0.12895523f, -0.08556428f, 0.00388026f, 
    -0.10443880f, -0.13937908f, 0.03548703f, 0.07407264f, 0.00796083f, -0.08907134f, 0.01421832f, -0.13909090f, 
    0.13811101f, -0.03846300f, 0.03700731f, -0.05276386f, -0.04713108f, 0.00475979f, -0.03908721f, 0.03485091f, 
    -0.24238336f, -0.01534720f, -0.04355422f, -0.02263398f, 0.04930311f, 0.01970072f, -0.07147990f, -0.06288658f, 
    0.05027957f, 0.04669816f, -0.05483829f, -0.10308440f, 0.09201012f, 0.01551802f, -0.08382778f, 0.00645462f, 
    -0.05075177f, 0.14596844f, 0.04854259f, -0.03763252f, -0.04078281f, 0.07000441f, -0.04706828f, -0.00164713f, 
    0.08041353f, 0.17605028f, 0.01730334f, -0.04986441f, 0.09086046f, -0.00865559f, 0.00582901f, 0.02927962f, 
    0.12924609f, -0.02911698f, -0.01415010f, -0.03242045f, -0.43551135f, 0.05688049f, 0.01982676f, 0.08295184f, 
    0.11347225f, 0.10268987f, 0.02974061f, 0.03122792f, 0.05095105f, 0.04501617f, -0.04654965f, 0.01196522f, 
    -0.07003090f, -0.05784927f, -0.06813847f, -0.06176102f, 0.02464311f, 0.04200398f, 0.07661447f, -0.12071101f, 
    -0.04973238f, 0.39174807f, -0.00217041f, -0.05436055f, -0.12729824f, -0.03420417f, -0.16250210f, 0.13067196f, 
    0.03433685f, 0.01416811f, -0.02916617f, -0.02899882f, -0.12301321f, 0.00022953f, 0.06072126f, 0.05200496f, 
    0.06062946f, -0.13155928f, -0.09125112f, -0.10564728f, -0.41996041f, -0.13651609f, -0.05600491f, -0.00785579f, 
    0.23290068f, -0.02160511f, 0.05250545f, 0.05661079f, 0.08072794f, 0.13076112f, -0.05366955f, -0.11711288f, 
    0.12559918f, 0.05547652f, -0.09680935f, -0.07311815f, 0.13603985f, 0.03346824f, 0.10518520f, -0.10829999f, 
    0.14072250f, 0.17169532f, 0.10318103f, -0.06725845f, 0.03561086f, -0.02705173f, 0.09651608f, -0.12001943f, 
    0.07142794f, 0.08597331f, 0.00447204f, 0.07545915f, 0.07869568f, 0.05640855f, -0.20846219f, -0.09921089f, 
    0.05839076f, 0.07116908f, 0.01517394f, 0.05666829f, -0.65067583f, 0.13678828f, -0.01572217f, 0.03824280f, 
    0.00325507f, -0.07153863f, -0.10300698f, 0.01465532f, 0.01003846f, -0.01185598f, 0.03599464f, 0.00154291f, 
    -0.10826093f, -0.03867351f, 0.05124798f, 0.05286927f, 0.06523184f, -0.04136091f, 0.04780700f, 0.06831262f, 
    -0.47010940f, 0.01604487f, -0.00107747f, -0.10456830f, -0.08435698f, -0.03200798f, 0.00764619f, 0.01574059f, 
    -0.07358704f, -0.04935621f, -0.01964980f, -0.06909572f, 0.00660216f, -0.05730391f, -0.00837760f, 0.00632426f, 
    -0.01887813f, 0.01145987f, 0.05967362f, 0.00251882f, -0.00111798f, 0.18408468f, -0.09397327f, -0.30677477f, 
    -0.13224094f, -0.03139383f, 0.04260882f, -0.01397793f, -0.00376887f, -0.02451481f, 0.02288536f, 0.04504592f, 
    -0.08156779f, 0.05626468f, 0.15943931f, -0.01124781f, 0.05013027f, 0.04295494f, 0.01381751f, 0.07678489f, 
    0.16309121f, 0.16662544f, -0.29891860f, -0.22008827f, 0.19078803f, -0.14587255f, 0.05743406f, -0.02361938f, 
    0.07492608f, -0.04418359f, 0.07407633f, -0.07745767f, 0.02067701f, 0.11814431f, -0.03813381f, 0.05638975f, 
    0.10490479f, -0.01799519f, -0.00981685f, 0.02716372f, -0.32127404f, -0.50880986f, 0.13775907f, 0.19395490f, 
    -0.01109952f, -0.19076177f, -0.00914320f, -0.04584554f, -0.02035844f, 0.02603790f, 0.09967877f, -0.03206267f, 
    0.05888708f, -0.07245244f, 0.00861041f, -0.21511388f, -0.06851276f, -0.00302241f, 0.03770568f, 0.02805856f, 
    0.39145648f, -0.19596778f, -0.25697792f, 0.25350198f, 0.08143802f, 0.19876999f, -0.06201710f, 0.12383623f, 
    0.07019802f, 0.06433216f, -0.12151160f, -0.08456685f, 0.07529594f, 0.08727726f, -0.04650967f, -0.08029257f, 
    0.04074451f, -0.05925308f, 0.03814477f, -0.05299300f, -0.82151699f, 0.06420270f, -0.11033961f, 0.06022374f, 
    0.18259153f, 0.01488681f, 0.02312758f, 0.11456673f, -0.02926257f, 0.07780933f, 0.04985489f, 0.00287887f, 
    -0.03585565f, 0.04412175f, 0.03193307f, -0.03316428f, -0.04473212f, 0.15110427f, 0.09905209f, -0.07122465f, 
    -0.20376202f, -0.26001087f, 0.14375544f, 0.11000033f, -0.01196169f, 0.04528788f, -0.04988174f, 0.07796421f, 
    -0.14302884f, 0.04546425f, 0.03220622f, 0.03900855f, -0.07304548f, -0.07135115f, 0.00766760f, 0.03177843f, 
    -0.03141136f, 0.07642089f, 0.14607844f, 0.03257976f, -0.08651795f, 0.08446036f, 0.11670189f, 0.21897744f, 
    0.01792206f, 0.01362090f, 0.01764147f, -0.10638477f, 0.07235051f, -0.06543121f, 0.12292217f, -0.00528789f, 
    -0.05846588f, 0.10480072f, -0.01802396f, 0.00897596f, 0.04026276f, -0.07258579f, -0.02549202f, 0.09470046f, 
    -0.01981988f, 0.16646793f, -0.22905272f, 0.25374895f, -0.10176633f, 0.00970491f, -0.00271005f, 0.06488941f, 
    0.08437016f, -0.06333638f, 0.05501895f, 0.08896500f, 0.01839087f, -0.05948922f, 0.07425588f, 0.06885631f, 
    0.01068761f, 0.08184289f, 0.10739005f, 0.05117856f, 0.30863011f, 0.04673753f, 0.03015111f, -0.36784375f, 
    -0.24880370f, -0.01390354f, 0.16091256f, 0.06909789f, -0.09480583f, 0.03182756f, -0.01943202f, 0.02622645f, 
    0.09653746f, 0.04791591f, -0.01903706f, -0.09661283f, 0.16821145f, 0.02362338f, -0.08203571f, 0.06356011f, 
    0.13261260f, 0.12125460f, -0.04565783f, -0.01054461f, -0.11542196f, -0.05465642f, 0.21305920f, -0.03143090f, 
    -0.04153219f, 0.17640135f, -0.04791573f, 0.01087121f, 0.04669548f, -0.01804395f, -0.01246339f, 0.00212963f, 
    -0.14081830f, -0.11982866f, -0.13481677f, -0.10846607f, 0.02069629f, 0.06123936f, 0.30922133f, -0.15306912f, 
    -0.04629844f, 0.00166241f, 0.00679242f, 0.00782518f, 0.02729934f, 0.07933614f, 0.13639189f, -0.01274491f, 
    0.04534502f, -0.16068533f, -0.01444819f, 0.16759001f, -0.00488797f, -0.17759129f, -0.02539595f, -0.01977897f, 
    0.07325745f, 0.15431359f, -0.10884993f, -0.18798614f, 0.11649519f, -0.06543352f, 0.06596600f, 0.03628122f, 
    0.06532901f, -0.00548131f, 0.19435823f, 0.03779474f, 0.04682941f, -0.11389104f, -0.02930945f, 0.03754684f, 
    0.14594929f, -0.11628064f, 0.18917640f, 0.01311509f, -0.37472859f, 0.12158364f, -0.33562163f, -0.18761812f, 
    0.01552298f, 0.16838662f, 0.10220051f, 0.01248764f, -0.12805641f, -0.20053753f, -0.03536247f, 0.01915699f, 
    -0.04809132f, -0.05410486f, -0.03153573f, -0.02904452f, 0.04864497f, 0.04178376f, 0.10203242f, -0.00869857f, 
    0.08788260f, 0.01668564f, 0.12576525f, 0.29422909f, -0.04961213f, -0.03095005f, -0.02050917f, 0.02727419f, 
    0.04136767f, 0.04151456f, -0.09173718f, -0.07669663f, -0.10390164f, 0.17109925f, 0.03520489f, -0.02220548f, 
    -0.12269978f, -0.17009725f, -0.01781721f, -0.08309203f, 0.19501233f, 0.01955583f, 0.22339314f, 0.26831663f, 
    0.07939303f, 0.08739458f, 0.10709424f, 0.16058353f, 0.06339993f, -0.00346880f, -0.13325152f, -0.01535547f, 
    -0.10485249f, 0.07472163f, -0.00650519f, 0.16475143f, 0.00160195f, 0.03055871f, 0.05002243f, 0.07659017f, 
    -0.04881959f, 0.35751936f, -0.12560076f, -0.10299154f, -0.04069677f, -0.06120638f, -0.09906127f, 0.09845039f, 
    -0.07936413f, -0.08565585f, -0.10396554f, -0.09070213f, -0.15523413f, -0.06623100f, -0.03786732f, -0.08676662f, 
    -0.10662735f, 0.10718831f, 0.12169911f, 0.01361175f, -0.08809348f, -0.06117252f, -0.01773170f, 0.12580706f, 
    0.23339018f, -0.04473625f, -0.06421558f, -0.06806715f, 0.05000759f, 0.10762472f, 0.04346910f, -0.02575761f, 
    0.06027702f, 0.17351598f, 0.05989503f, 0.12470311f, 0.19064724f, -0.10435116f, -0.24469653f, -0.07334492f, 
    -0.11523078f, -0.09460580f, 0.06481046f, 0.02737736f, 0.08024911f, 0.04413771f, 0.00187574f, 0.04975500f, 
    0.00916648f, 0.03591025f, 0.02596459f, -0.10144471f, -0.02503368f, 0.00607293f, -0.00153810f, -0.02855506f, 
    0.06527583f, -0.01113223f, 0.07971867f, -0.04756526f, -0.24521627f, -0.01662141f, 0.07340331f, -0.02770210f, 
    0.02827224f, -0.08249038f, -0.10094147f, -0.14698392f, -0.04215429f, -0.05927348f, 0.05372720f, -0.03169976f, 
    -0.07165267f, -0.00510294f, 0.07544205f, 0.00254286f, 0.18075393f, -0.01832224f, 0.00217719f, -0.03269565f, 
    -0.24181066f, -0.00007958f, 0.03998398f, -0.03251414f, -0.03992851f, -0.01956989f, 0.15054569f, 0.03462829f, 
    0.07140238f, 0.12696013f, 0.01080950f, 0.09076019f, 0.06371076f, 0.00693657f, -0.08246271f, 0.02291075f, 
    0.05620911f, -0.20788302f, -0.03274194f, 0.02255025f, 0.17830867f, 0.11507088f, -0.02809801f, 0.14176901f, 
    -0.08099106f, -0.28913242f, -0.09458052f, -0.14658912f, 0.11258365f, 0.02552826f, -0.09670337f, -0.09938546f, 
    0.08436487f, 0.20230055f, 0.12214143f, -0.06297004f, 0.03557727f, 0.13933626f, -0.00712983f, 0.02597411f, 
    -0.36202678f, 0.03302833f, -0.40533641f, 0.00584987f, -0.03056158f, 0.10269526f, 0.00832776f, 0.13341793f, 
    0.04479757f, 0.00116611f, 0.02658842f, 0.22266710f, 0.01824783f, -0.12865484f, 0.00848216f, 0.10676114f, 
    -0.03278966f, -0.04745375f, -0.02403734f, -0.07183869f, -0.64388728f, 0.25686660f, 0.03005963f, 0.31940359f, 
    -0.00545954f, -0.10178068f, 0.00552259f, 0.03230985f, 0.01986357f, 0.05899429f, 0.13739000f, 0.11410712f, 
    0.06177240f, -0.04568584f, -0.02332932f, 0.01941728f, 0.09796308f, -0.07428893f, 0.01046158f, -0.12477063f, 
    -0.02807729f, -0.02531767f, 0.02600304f, 0.16065542f, 0.24171764f, -0.11844082f, -0.12850034f, -0.01155462f, 
    -0.10907150f, 0.10042565f, 0.00925527f, -0.14676651f, -0.00226552f, 0.01226352f, -0.18380328f, 0.06345034f, 
    -0.06517844f, -0.26370567f, 0.06276983f, 0.15483099f, 0.04361418f, 0.01131783f, -0.00820899f, 0.00368144f, 
    0.20009147f, -0.01060315f, -0.13831481f, 0.01506840f, -0.06037492f, 0.08959581f, 0.11750895f, -0.03754063f, 
    0.07348955f, 0.00444235f, -0.03345104f, -0.01546603f, 0.02344160f, -0.19844121f, 0.12860008f, 0.06877975f, 
    0.14324324f, 0.02670927f, 0.09678882f, 0.11772772f, 0.01856488f, 0.01841405f, 0.09555506f, 0.00314185f, 
    -0.04490670f, -0.12408978f, -0.01868073f, 0.05747630f, 0.08853813f, 0.01013791f, 0.11665538f, 0.06310269f, 
    -0.03086544f, 0.01052083f, 0.11841139f, -0.03257400f, -0.73576373f, -0.20166101f, -0.30862972f, -0.31157640f, 
    0.06359963f, 0.14010909f, 0.01278780f, -0.00554040f, 0.05192628f, -0.12784782f, 0.08485703f, 0.04045932f, 
    0.02010103f, 0.04970621f, -0.09969737f, -0.00551256f, -0.06941940f, -0.15629999f, -0.07007324f, 0.04307852f, 
    -0.36255538f, -0.27796212f, -0.06020645f, 0.10383632f, -0.43993989f, 0.09421957f, 0.01315507f, -0.03072605f, 
    -0.01398890f, -0.09553314f, 0.04273605f, 0.02421833f, 0.04378183f, 0.01680315f, 0.00708136f, -0.05592466f, 
    -0.02129791f, 0.04220064f, 0.01488741f, -0.08572142f, -0.40762791f, -0.12114056f, -0.34595841f, -0.22387283f, 
    -0.20737843f, 0.22094545f, -0.01048944f, 0.06235998f, -0.06073217f, -0.12136953f, 0.04011072f, 0.12599266f, 
    -0.13445063f, -0.04761131f, -0.11246936f, 0.14684398f, -0.08629051f, 0.06937745f, -0.17431250f, -0.02152015f, 
    -0.05484678f, -0.05966679f, 0.14476402f, 0.11669767f, -0.16070826f, 0.05447355f, -0.15849297f, 0.03196365f, 
    -0.01942282f, -0.13859190f, 0.09533361f, 0.05153769f, 0.04357991f, -0.12257402f, 0.09946756f, -0.08845847f, 
    -0.09493460f, 0.11794798f, 0.08094217f, -0.09198333f, -0.10844364f, -0.14617741f, 0.03942363f, 0.15027505f, 
    -0.35656455f, -0.06158329f, 0.05195143f, -0.10679923f, 0.09554213f, -0.01096745f, -0.03391722f, 0.01289600f, 
    0.04278956f, 0.02280743f, 0.10604570f, -0.02554069f, -0.01034382f, 0.02702507f, 0.04269148f, -0.02460920f, 
    -0.21824993f, -0.00022677f, 0.08518490f, -0.01988461f, 0.05199211f, -0.00462888f, -0.05966298f, -0.02872737f, 
    0.06225891f, 0.07914555f, -0.04059216f, -0.15353274f, 0.01094368f, 0.06508955f, 0.13673653f, -0.10404088f, 
    0.01293689f, -0.06335124f, -0.13787057f, -0.12570117f, -0.34264708f, -0.01399552f, 0.19769584f, -0.03337412f, 
    -0.16513713f, -0.02855834f, 0.12931268f, 0.10882525f, -0.08439709f, -0.04290044f, -0.06445449f, 0.04197619f, 
    0.05591481f, -0.18098003f, 0.07739556f, 0.02267912f, -0.00335791f, -0.09023961f, 0.05916212f, 0.03970388f, 
    -0.25977170f, 0.17522703f, -0.06643432f, 0.05331057f, -0.14794835f, 0.04848154f, 0.07310043f, 0.08814558f, 
    -0.15195040f, -0.01803989f, 0.04905598f, -0.08677212f, -0.07645551f, -0.08393729f, -0.06471701f, 0.00882290f, 
    -0.01828951f, 0.01977226f, 0.12395054f, -0.04448643f, 0.14763284f, 0.09582540f, 0.01138631f, 0.11649536f, 
    0.19759549f, -0.04089841f, -0.08419231f, 0.15397157f, 0.00724596f, 0.02339017f, -0.09604454f, -0.21295688f, 
    0.01781756f, 0.12128319f, 0.08109494f, 0.06530780f, 0.03927915f, 0.02284054f, 0.08211844f, 0.00838131f, 
    0.07705614f, 0.35718036f, 0.30809900f, -0.08610937f, -0.30936700f, 0.03477793f, -0.02526249f, -0.08264991f, 
    -0.05702097f, 0.09802993f, 0.11154339f, -0.04358817f, -0.13347442f, 0.01908853f, -0.20717545f, 0.12890987f, 
    -0.00599561f, 0.09020017f, 0.00487554f, -0.03789041f, -0.52643424f, 0.04071651f, -0.21317884f, -0.15121183f, 
    0.06376243f, 0.11041780f, 0.00426337f, 0.03141811f, 0.03822204f, -0.17455457f, 0.13254341f, -0.03450475f, 
    0.16435997f, -0.07270639f, 0.09308928f, 0.04341332f, 0.07828538f, -0.12726304f, -0.06004560f, 0.11348361f, 
    0.18179135f, 0.08905376f, 0.00910266f, 0.02885398f, 0.13764164f, -0.13891652f, 0.01259380f, -0.00823569f, 
    0.16448358f, 0.00383483f, 0.02319462f, -0.12551641f, 0.05171096f, 0.11415309f, 0.21905844f, -0.15638137f, 
    -0.05320083f, -0.00871644f, -0.25459146f, -0.11645353f, -0.10743355f, -0.06741789f, -0.24542655f, 0.08250398f, 
    0.09446348f, 0.18408373f, 0.00881804f, -0.01483933f, 0.07812688f, 0.17733905f, -0.06622305f, 0.27736986f, 
    0.17616729f, -0.01826403f, 0.06497286f, -0.09694715f, 0.06920715f, -0.14976321f, 0.14141993f, -0.19060679f, 
    -0.12130915f, -0.21675299f, 0.00701301f, 0.12308891f, 0.09909256f, 0.05010385f, -0.02302402f, -0.10730527f, 
    0.01190950f, 0.07976580f, 0.04150209f, 0.01623647f, 0.10140801f, 0.12176602f, 0.03863795f, -0.12874250f, 
    0.03694638f, -0.13914680f, -0.13549340f, -0.03039756f, -0.19565342f, 0.02931294f, 0.34202808f, 0.15949222f, 
    -0.27103278f, -0.05169076f, -0.12841356f, 0.08974802f, 0.00802304f, 0.03162662f, -0.09921970f, 0.03062467f, 
    -0.03983825f, -0.08353753f, -0.18719660f, -0.17029722f, -0.10811401f, -0.07301342f, 0.02578277f, 0.12406279f, 
    -0.23746181f, 0.00979202f, -0.05876611f, -0.08360478f, -0.07810238f, -0.10969757f, 0.02099116f, 0.06048168f, 
    -0.08431864f, 0.01328366f, -0.02844269f, -0.01578426f, -0.00220849f, 0.06988142f, -0.08799509f, -0.08944320f, 
    0.05307961f, 0.01629598f, 0.10570865f, 0.25935301f, -0.05705196f, -0.06640268f, 0.00591974f, 0.13579702f, 
    -0.01998187f, -0.20485355f, 0.15214433f, -0.05842694f, 0.05003556f, -0.02182568f, -0.00383160f, 0.12179809f, 
    0.08316956f, -0.00806876f, 0.04846337f, -0.08865944f, -0.13751473f, 0.10594261f, 0.03368523f, 0.08550166f, 
    0.20282820f, -0.19522026f, -0.04385846f, -0.00250349f, 0.16831487f, -0.19365185f, 0.07038415f, -0.05374863f, 
    -0.13050851f, -0.08006614f, -0.04981800f, 0.02144960f, 0.07325764f, 0.06274915f, -0.04229139f, 0.01309012f, 
    0.02867481f, 0.11164895f, -0.07028499f, 0.01593425f, 0.13600929f, -0.22126992f, 0.02442232f, -0.44412434f, 
    0.18878515f, -0.06087080f, 0.01206843f, -0.04853260f, 0.02742420f, 0.00307033f, -0.01282820f, -0.03826672f, 
    0.03257821f, -0.02048280f, -0.03466813f, -0.02074980f, -0.10153083f, -0.09451851f, -0.07870778f, 0.11741854f, 
    -0.24657483f, 0.13569140f, 0.07898246f, -0.04492401f, -0.01459882f, 0.00478069f, 0.02831597f, 0.03971690f, 
    -0.03210983f, 0.04938038f, -0.05989503f, 0.11661644f, 0.10297567f, -0.00861337f, -0.09938598f, 0.07705396f, 
    -0.01124015f, 0.14274235f, 0.13527414f, 0.16935790f, -0.21141015f, 0.05283253f, -0.00602293f, 0.11121663f, 
    0.05810275f, -0.10311601f, -0.08263266f, -0.05780916f, -0.14694974f, 0.12568402f, -0.13309091f, 0.02544579f, 
    0.15914111f, -0.08172846f, 0.13976564f, 0.13130309f, -0.09742076f, -0.13375208f, -0.08988415f, -0.16922981f, 
    -0.06043587f, -0.45698166f, 0.01814748f, -0.04891218f, 0.16648565f, 0.07957628f, 0.02447067f, -0.01397804f, 
    0.03525640f, -0.14281155f, -0.05281764f, 0.02454021f, -0.00233544f, 0.09483435f, 0.18425114f, 0.05342336f, 
    -0.07646876f, -0.05560637f, -0.12111266f, -0.17512907f, -0.00774469f, 0.02919030f, -0.21975285f, -0.18157731f, 
    0.01555659f, 0.01572294f, 0.09174182f, 0.00881985f, -0.08485010f, 0.12535411f, -0.03506331f, -0.14615162f, 
    -0.04596762f, -0.00779774f, -0.07808051f, -0.06898451f, -0.08249368f, 0.17878090f, 0.07389571f, 0.06045632f, 
    -0.00488537f, -0.49047151f, 0.00353293f, -0.00869571f, 0.19256738f, -0.06669020f, 0.02323058f, -0.02738732f, 
    -0.01626395f, 0.02588601f, -0.13180055f, -0.06412089f, -0.14215668f, 0.06524292f, -0.09058311f, -0.10190203f, 
    -0.00141663f, 0.05398041f, -0.12762827f, 0.00760038f, -0.28926390f, -0.12962191f, -0.04886516f, 0.16958465f, 
    0.24909523f, 0.10497050f, 0.03621987f, -0.02623926f, 0.09322906f, 0.01761252f, 0.02746501f, -0.06072933f, 
    0.09381670f, -0.10272846f, -0.07644038f, -0.03770543f, 0.10467403f, -0.08956504f, 0.06302427f, 0.10238818f, 
    -0.04425828f, 0.17117105f, 0.00539500f, -0.13513654f, 0.14208108f, -0.14308318f, -0.07854389f, -0.19169457f, 
    -0.04727232f, -0.17142732f, 0.01655820f, -0.00804239f, -0.11156529f, 0.06144815f, 0.12896711f, -0.11510380f, 
    -0.00978575f, -0.02260045f, -0.02765104f, 0.13078812f, -0.24379018f, 0.32105422f, 0.04626434f, 0.08239877f, 
    -0.24621813f, 0.22737762f, -0.05169351f, 0.03739097f, 0.04651785f, -0.04193623f, 0.00596539f, -0.01735574f, 
    -0.05912083f, -0.02281401f, -0.14401832f, 0.12466951f, 0.00126720f, -0.09356520f, 0.06064261f, 0.11451249f, 
    -0.35266289f, -0.27159560f, 0.06761859f, -0.46351257f, 0.04723098f, -0.08897284f, 0.10629098f, 0.06367783f, 
    -0.05715619f, 0.02937466f, -0.11909251f, 0.04165672f, 0.01754978f, 0.07930376f, -0.01868296f, -0.08946426f, 
    0.03269023f, 0.08535079f, -0.01057609f, 0.05101614f, 0.23815219f, -0.32589889f, -0.26386163f, 0.11928623f, 
    0.48092538f, -0.03869208f, 0.05424559f, 0.03982391f, 0.02126655f, -0.01629077f, -0.20495605f, -0.03329297f, 
    0.04353548f, -0.03208274f, 0.07006301f, -0.02431254f, -0.14851999f, 0.09135498f, -0.09229926f, 0.16125576f, 
    -0.18915553f, 0.18825148f, -0.07648662f, 0.16904046f, -0.26081020f, 0.16389307f, 0.10142981f, 0.03456075f, 
    0.04996835f, 0.08277912f, -0.05190722f, 0.03076968f, 0.04366807f, 0.02038400f, -0.20377965f, 0.08176002f, 
    0.00310902f, 0.08884203f, 0.01661065f, -0.00916531f, -0.00709001f, 0.13417411f, -0.20753777f, 0.27480274f, 
    -0.18289536f, -0.02697961f, 0.18235198f, -0.09707074f, 0.09003548f, -0.01772353f, -0.01705944f, 0.09140142f, 
    0.02985270f, -0.01373764f, -0.05281183f, 0.04473534f, -0.07030897f, 0.13861483f, -0.09331291f, 0.01652449f, 
    -0.26199919f, 0.08806998f, -0.10481290f, 0.12700830f, -0.25322685f, -0.15735205f, -0.03334682f, 0.09315824f, 
    0.04049559f, 0.02395795f, 0.00173565f, -0.06496964f, -0.04730478f, 0.01840668f, 0.03794881f, -0.09541316f, 
    -0.06194767f, -0.02748497f, -0.07981963f, -0.00186259f, -0.10063512f, -0.08457617f, -0.06071559f, -0.26790753f, 
    0.03774102f, -0.01518184f, 0.16301933f, 0.07509534f, -0.14763075f, -0.10597607f, 0.00774120f, -0.15062672f, 
    0.12441114f, -0.00986800f, 0.06488818f, 0.00151311f, -0.04623817f, -0.00967095f, 0.03943815f, 0.09102832f, 
    0.37133604f, -0.48729888f, -0.03004122f, 0.15271193f, 0.05963131f, 0.04842017f, 0.01394704f, 0.08459749f, 
    -0.04074800f, -0.01759248f, -0.07229066f, 0.07247410f, -0.14718667f, -0.00436880f, -0.04693743f, -0.08045270f, 
    0.06899605f, 0.11534884f, 0.08682153f, -0.02900146f, 0.07696864f, -0.34348109f, 0.02556558f, -0.24702892f, 
    -0.04194550f, -0.02421190f, -0.06983323f, 0.09854057f, -0.16894840f, 0.05344323f, 0.03296853f, -0.13143761f, 
    0.11932006f, 0.03846481f, 0.04319501f, -0.01441010f, 0.00185479f, -0.01400925f, 0.02475441f, 0.03608027f, 
    -0.25927824f, 0.41074753f, -0.01955448f, 0.03767806f, -0.17425942f, -0.00083668f, 0.00830345f, 0.11376110f, 
    0.06784967f, 0.08409464f, 0.04812074f, 0.02313071f, -0.05970792f, 0.02497232f, 0.02835835f, -0.02913754f, 
    -0.01069308f, -0.05031117f, 0.09486692f, 0.03660120f, 0.08710782f, 0.18603918f, 0.16211803f, 0.05630769f, 
    -0.12851091f, 0.22078478f, -0.01534987f, 0.07406086f, 0.02997577f, -0.04494789f, -0.07588467f, 0.01186273f, 
    -0.04909375f, -0.06166657f, -0.11873913f, -0.04585726f, -0.10768847f, -0.01748830f, -0.06460638f, -0.06295887f, 
    0.50452626f, 0.07206962f, 0.16935991f, 0.03076323f, 0.22413187f, -0.14693995f, 0.01013901f, 0.01954661f, 
    -0.00406533f, -0.05717393f, -0.01871320f, 0.01274574f, 0.12436316f, 0.11643358f, 0.02532507f, 0.17614126f, 
    0.03090940f, 0.02328032f, 0.04584128f, 0.02465473f, 0.20688362f, -0.13295560f, -0.04088331f, 0.01246166f, 
    0.21272227f, -0.06446766f, 0.14484900f, -0.11794827f, -0.00709061f, -0.05498873f, -0.04234682f, 0.10452900f, 
    0.01689507f, 0.01897175f, -0.05795360f, 0.05720176f, 0.09466179f, -0.02712051f, -0.06268182f, 0.16853049f, 
    0.12650095f, -0.37441343f, -0.24391168f, -0.08861890f, -0.07601628f, -0.04639819f, 0.09843454f, -0.05672982f, 
    0.06030570f, 0.01851220f, -0.06306268f, 0.07995094f, -0.00614018f, -0.03905147f, 0.07562398f, 0.13462724f, 
    0.02719481f, -0.01160569f, -0.17508109f, 0.07976764f, -0.32067364f, 0.29745263f, 0.01283983f, -0.01898514f, 
    -0.42489615f, -0.03094283f, 0.08986869f, 0.00500825f, 0.03768937f, 0.06524273f, -0.03016378f, 0.05218971f, 
    0.00426504f, 0.00405867f, -0.18665281f, 0.04070135f, -0.03661833f, 0.04685127f, -0.06634226f, -0.13778606f, 
    0.02770802f, 0.02079374f, -0.19002745f, 0.15980607f, -0.16327202f, -0.16237378f, 0.01961737f, -0.01356162f, 
    0.03556329f, 0.00940249f, -0.05566828f, -0.05263365f, 0.12036706f, 0.13397644f, 0.06004884f, 0.15055834f, 
    -0.11690824f, -0.05879714f, -0.07473846f, -0.11040013f, 0.21331359f, -0.34680358f, -0.09269311f, -0.11219531f, 
    -0.03512091f, -0.10583187f, 0.04422170f, -0.00003807f, -0.10195872f, -0.01146762f, 0.05338068f, 0.04067755f, 
    0.02974822f, 0.15549429f, 0.10528356f, -0.07440175f, -0.05070889f, 0.07204281f, -0.16954321f, 0.04961380f, 
    0.09282205f, 0.06018073f, -0.00838181f, -0.17523812f, -0.20776454f, 0.02891062f, 0.03563879f, 0.02700092f, 
    -0.02438315f, -0.01505404f, -0.05678565f, -0.03124901f, -0.19598728f, 0.00621427f, 0.02051135f, 0.03765576f, 
    -0.06364924f, -0.04339832f, 0.18897511f, 0.10550318f, -0.04318735f, -0.03259366f, -0.06979319f, -0.29994038f, 
    0.04015553f, 0.10516630f, -0.01424939f, 0.05601130f, -0.19080997f, -0.13769957f, -0.00912103f, -0.08887386f, 
    -0.04574486f, -0.08871267f, -0.03951550f, 0.02656737f, -0.12732750f, 0.06541300f, -0.07190564f, 0.08516811f, 
    -0.13568777f, 0.02776642f, -0.16748507f, -0.30326924f, 0.16060276f, -0.03479170f, -0.03669715f, 0.00754812f, 
    -0.13888159f, 0.02008834f, 0.02032693f, -0.09375426f, -0.10400021f, 0.01299539f, -0.06789112f, -0.00392725f, 
    0.01406859f, 0.10264941f, 0.11925454f, 0.04428571f, 0.06401909f, 0.02042085f, 0.05582147f, 0.28955743f, 
    0.29906416f, 0.06775974f, 0.11802609f, -0.08583592f, 0.07702273f, -0.01245433f, 0.05692553f, 0.00156886f, 
    0.05956206f, 0.00378914f, 0.12956850f, -0.05554541f, 0.01169149f, 0.14125203f, -0.00437689f, 0.04316646f, 
    -0.17649914f, -0.39661658f, 0.21238293f, -0.06878689f, 0.24645054f, 0.08495279f, -0.02804945f, 0.03033227f, 
    0.04664204f, -0.08577248f, -0.05150705f, -0.04694388f, 0.06119667f, 0.06797462f, -0.09758951f, -0.08407547f, 
    0.01314346f, 0.00488996f, 0.01641258f, -0.19430517f, -0.30049559f, 0.09800009f, 0.06680720f, 0.19205111f, 
    -0.31360900f, -0.01803139f, -0.21852621f, 0.00290780f, 0.06248346f, 0.01884773f, -0.06712569f, -0.05007233f, 
    0.09363879f, 0.13765624f, -0.00697468f, -0.04253072f, 0.11192081f, -0.08967831f, 0.02059093f, -0.10239676f, 
    -0.04651735f, 0.18782461f, -0.12428318f, -0.07676431f, 0.06886099f, -0.04759853f, 0.03912896f, 0.00966163f, 
    -0.04029819f, 0.00286837f, -0.02199728f, -0.01641000f, -0.03790616f, 0.00051816f, -0.11962762f, -0.00265806f, 
    0.03168897f, 0.03995934f, -0.06971937f, -0.00902158f, 0.18099299f, 0.04830555f, 0.30325016f, 0.03672523f, 
    0.19347079f, 0.01046337f, 0.12488763f, 0.00017002f, 0.00448732f, -0.03099591f, -0.05270965f, -0.00002079f, 
    -0.04739474f, 0.00919727f, -0.07053490f, -0.03584925f, -0.04392514f, 0.05814957f, 0.00049728f, -0.09647398f, 
    -0.05332646f, 0.03500937f, -0.03453636f, -0.03655782f, 0.18151248f, 0.05483082f, -0.18825614f, -0.10743157f, 
    0.01609509f, -0.06122072f, -0.03903686f, -0.03527227f, -0.04857046f, -0.03655770f, -0.10595915f, -0.08328348f, 
    -0.06291167f, -0.08171365f, -0.07861311f, -0.05369195f, 0.03081506f, -0.13351025f, -0.19316508f, -0.08258288f, 
    0.00329425f, -0.02576532f, -0.05171947f, -0.01521720f, -0.04298393f, -0.13739064f, -0.06523205f, -0.04890414f, 
    -0.03144367f, -0.01275763f, 0.00030211f, -0.09699159f, 0.06770610f, -0.08360019f, 0.02272034f, -0.02117867f, 
    0.14910080f, -0.20765336f, 0.14299157f, 0.07749267f, 0.03429719f, -0.03635371f, 0.05694742f, 0.01054191f, 
    0.10383725f, -0.02059327f, 0.06739540f, 0.06519952f, 0.01025840f, 0.00696681f, 0.03011765f, -0.02276814f, 
    0.01224498f, 0.03010182f, -0.01541226f, -0.04080642f, 0.10774203f, 0.08665308f, -0.07272780f, -0.02212304f, 
    0.10630158f, -0.05362345f, -0.11565071f, -0.11260559f, -0.05367108f, -0.04493264f, -0.10005835f, 0.01824798f, 
    -0.02236280f, -0.08650655f, -0.05789471f, -0.03326173f, -0.08485772f, 0.06950299f, 0.03137867f, -0.01415549f, 
    -0.11234062f, -0.02083667f, -0.02922772f, -0.08865321f, -0.05907239f, -0.09501263f, 0.00284283f, -0.02584090f, 
    -0.00841465f, -0.00736317f, 0.07713447f, 0.07274880f, -0.12873530f, -0.04333614f, 0.05042491f, -0.03203266f, 
    0.06081514f, 0.02698781f, -0.10862175f, -0.09598617f, -0.06660344f, 0.16385211f, 0.04780059f, -0.15743496f, 
    0.10902596f, 0.00800114f, 0.06910738f, -0.09222233f, -0.10506231f, -0.03082340f, 0.07257959f, 0.10493085f, 
    0.00347065f, -0.04000067f, -0.01922081f, 0.00355334f, -0.03976271f, 0.03916318f, -0.03213599f, -0.00926426f, 
    -0.22605489f, 0.16715895f, 0.09109427f, 0.12431274f, 0.10324463f, 0.06156184f, -0.02962874f, 0.00021825f, 
    0.02379749f, 0.02640288f, -0.01981018f, 0.00661538f, -0.04234530f, -0.01527327f, -0.03282220f, 0.13381952f, 
    -0.03654153f, 0.07626403f, 0.01607242f, -0.03111155f, -0.23565684f, -0.20644559f, -0.37174392f, -0.26239169f, 
    -0.12277132f, 0.09371085f, -0.12240349f, -0.01957809f, -0.04120734f, -0.06585968f, -0.10753331f, -0.00078932f, 
    -0.00464974f, -0.06358138f, -0.08356745f, -0.05398820f, 0.08227602f, -0.03309365f, 0.04438971f, 0.07585096f, 
    0.07212445f, 0.12084669f, 0.19075075f, 0.25641844f, 0.28140321f, -0.00741853f, 0.07141691f, -0.03240687f, 
    0.08290166f, -0.10860863f, -0.10997570f, 0.07104786f, -0.03540995f, -0.07921174f, -0.09343397f, 0.04770763f, 
    -0.05570854f, 0.00079222f, -0.04627677f, -0.01354801f, -0.14297429f, -0.09135626f, -0.13002488f, -0.05019037f, 
    0.20201825f, -0.06036022f, 0.06114678f, -0.08942582f, 0.06777015f, -0.13572276f, 0.05008379f, 0.01920210f, 
    -0.19171345f, -0.01329485f, 0.08623942f, -0.06069525f, -0.10047667f, 0.02723482f, -0.07084160f, 0.03761297f, 
    -0.11541205f, 0.18385780f, 0.09492500f, -0.01914163f, 0.04424421f, 0.07627964f, 0.08407015f, -0.12798499f, 
    0.07540180f, -0.04024631f, -0.05168915f, 0.03116604f, 0.03034462f, -0.01415249f, -0.06346832f, 0.03853702f, 
    -0.07355236f, 0.06677480f, -0.03191319f, -0.03123047f, -0.40836793f, 0.21669836f, 0.02067143f, -0.04879316f, 
    -0.06685711f, -0.07035998f, -0.00719272f, -0.12321127f, 0.01531633f, -0.12428743f, 0.02801376f, -0.04079213f, 
    -0.09442292f, -0.00074975f, -0.12029036f, 0.01558164f, 0.03044192f, 0.05922208f, 0.01741719f, -0.06265613f, 
    -0.08088335f, 0.13314712f, -0.05116788f, -0.16985080f, -0.23922539f, -0.10042340f, -0.00831774f, 0.00389141f, 
    -0.07620363f, -0.14849035f, 0.01643571f, -0.01813755f, -0.08577533f, -0.01888453f, -0.07590392f, -0.02070228f, 
    -0.01375508f, -0.02529535f, -0.06816100f, -0.08913296f, 0.12330988f, 0.05357749f, 0.31806582f, 0.00110760f, 
    0.08358665f, 0.03527354f, 0.13470092f, 0.03089215f, -0.05591770f, 0.01066601f, -0.10073842f, 0.09508782f, 
    -0.02983671f, 0.04246216f, -0.13226593f, -0.07065026f, -0.07189859f, 0.00282786f, 0.08969183f, -0.12073717f, 
    0.34723434f, -0.37771377f, 0.14916921f, 0.05846035f, -0.28155565f, 0.19697043f, -0.05568523f, -0.05623691f, 
    -0.07111395f, 0.01933632f, -0.01907822f, 0.00682013f, -0.04010544f, -0.07171925f, -0.06190232f, 0.02319266f, 
    0.12365332f, -0.04024273f, -0.03032753f, -0.01134808f, 0.19557151f, -0.06696133f, 0.21636738f, 0.00921920f, 
    0.15301785f, 0.01292563f, 0.04986952f, -0.13245174f, -0.00165448f, 0.04769378f, 0.00283819f, 0.09660263f, 
    0.01269647f, -0.03727004f, -0.05220608f, -0.02738536f, 0.03185722f, -0.06721677f, 0.05620208f, -0.14458516f, 
    0.08833139f, 0.11136366f, -0.22237341f, -0.13959472f, -0.06272279f, 0.01091322f, -0.12107605f, -0.04697624f, 
    0.01665085f, -0.09130143f, -0.15222447f, 0.02987003f, -0.03807221f, 0.02240436f, -0.04488016f, -0.00715272f, 
    -0.11055949f, -0.02952389f, 0.02194740f, -0.07727823f, -0.11408525f, -0.19583705f, -0.11379739f, 0.01215609f, 
    -0.21816666f, -0.00575202f, -0.07977986f, -0.03932220f, 0.02737609f, -0.17406000f, -0.07824234f, -0.10736755f, 
    -0.05886905f, 0.02177783f, -0.13282196f, -0.03501088f, -0.01291522f, -0.00400547f, 0.00610042f, -0.02583511f, 
    0.19799031f, 0.01759412f, -0.16386686f, -0.02742868f, 0.23912303f, -0.16445881f, -0.08405808f, 0.00245262f, 
    -0.02881451f, 0.03895091f, -0.08056398f, -0.02164720f, -0.16814859f, 0.11100744f, -0.01572858f, 0.02380062f, 
    0.03799545f, 0.04538094f, -0.06913929f, -0.01902972f, -0.08692443f, 0.10699135f, 0.06712680f, 0.11941373f, 
    0.07316799f, 0.15687929f, 0.02770429f, 0.08113986f, -0.00200904f, 0.07576358f, -0.05101722f, 0.03738029f, 
    0.07733626f, -0.01204535f, -0.04251704f, 0.03283748f, 0.04701993f, 0.02085936f, -0.03253195f, 0.06465373f, 
    -0.06751448f, 0.16371736f, 0.22012439f, 0.14001846f, 0.25674978f, 0.16220683f, 0.15926452f, -0.05131288f, 
    0.02696425f, -0.03930131f, -0.00583144f, 0.01208287f, 0.05959826f, -0.01426613f, -0.05888398f, 0.00920525f, 
    -0.00818961f, -0.02569148f, 0.00175765f, -0.00071888f, -0.47351727f, -0.13934116f, -0.19944102f, -0.03256959f, 
    -0.19177184f, -0.06842516f, -0.11517569f, -0.08703541f, 0.02763416f, -0.08184541f, -0.03398457f, 0.00463488f, 
    0.07307793f, 0.00131822f, -0.10402486f, -0.02117385f, 0.01396194f, 0.03515566f, 0.04218107f, 0.06810270f, 
    0.12644540f, 0.07318650f, -0.01366869f, -0.05560680f, -0.16314536f, -0.06110442f, -0.09973012f, 0.00953119f, 
    -0.03527093f, 0.04602442f, 0.05845712f, 0.01817713f, -0.06121283f, 0.05389231f, -0.07116754f, -0.03631150f, 
    0.00678706f, -0.03393772f, -0.07142525f, 0.01202501f, -0.11427527f, 0.13893163f, 0.26794079f, -0.01288825f, 
    0.05908945f, 0.00421955f, 0.11278508f, -0.00254197f, 0.06525030f, -0.12183108f, -0.00081815f, 0.01841888f, 
    -0.03096620f, -0.00062369f, -0.08662452f, -0.05913791f, 0.08553549f, 0.09145422f, 0.01970569f, -0.06261387f, 
    0.18571606f, -0.28968036f, -0.03771486f, 0.01471983f, 0.25558507f, -0.10852156f, -0.12705457f, -0.04744618f, 
    -0.07155801f, -0.00546151f, -0.04510019f, 0.04047740f, -0.05888061f, -0.03493107f, -0.03382465f, -0.11528160f, 
    0.01082262f, -0.03219576f, 0.00363084f, 0.01933677f, 0.10818791f, 0.05358968f, 0.10442734f, 0.07272086f, 
    0.16324790f, -0.00987266f, 0.07279637f, 0.00281595f, -0.05165326f, -0.04432771f, -0.02844970f, 0.01727680f, 
    -0.05277716f, -0.05310278f, -0.00182307f, -0.09004191f, 0.00128876f, 0.06348955f, 0.02169064f, -0.12475595f, 
    0.12431431f, 0.19208229f, 0.12568592f, 0.04058656f, 0.16251403f, -0.00485540f, 0.05539314f, -0.05957315f, 
    -0.06339527f, -0.02011560f, -0.06102049f, -0.02329722f, -0.08992910f, -0.10311359f, -0.01345753f, -0.01657513f, 
    -0.05446657f, 0.07298157f, 0.04283010f, -0.07159650f, -0.26279745f, 0.11725909f, -0.02008786f, 0.16596484f, 
    -0.02221959f, 0.16851373f, -0.05512462f, 0.01545768f, 0.07690236f, -0.02616785f, 0.04762296f, 0.01791872f, 
    0.09306616f, -0.01817781f, -0.02229191f, 0.11532079f, 0.00612461f, 0.11789591f, 0.03255159f, -0.05084401f, 
    0.14160955f, 0.06253549f, 0.10534004f, -0.05470272f, -0.00579855f, -0.09464961f, 0.15589385f, -0.09755596f, 
    0.06195585f, 0.02872601f, 0.05550794f, 0.05987787f, -0.01081893f, 0.03842162f, 0.07732886f, -0.02562581f, 
    -0.03303395f, 0.11650077f, -0.01450417f, -0.01129654f, -0.08555053f, -0.35105848f, -0.08091589f, -0.07759910f, 
    -0.22854362f, -0.00085927f, -0.05347794f, 0.01683751f, -0.04831094f, -0.14371094f, 0.02659565f, -0.11661404f, 
    -0.11072069f, -0.04801241f, -0.02557605f, 0.06817140f, -0.01300790f, -0.10074810f, -0.02754089f, -0.05533521f, 
    0.09935743f, -0.02620157f, -0.06008321f, 0.00587581f, -0.14120804f, -0.05231673f, -0.00207571f, -0.01225498f, 
    -0.10261332f, 0.02522663f, 0.11231937f, -0.07269869f, 0.01274516f, -0.14958221f, 0.04195408f, -0.11038038f, 
    -0.10463780f, -0.16451579f, 0.13308690f, -0.06113813f, -0.28439486f, 0.08930497f, 0.18376814f, 0.05707075f, 
    0.10711768f, -0.02116333f, 0.01900460f, 0.03652503f, -0.04113225f, -0.01064342f, 0.01676423f, 0.00492618f, 
    -0.13224331f, -0.03850153f, -0.00872833f, 0.00602579f, 0.08051591f, 0.04091829f, 0.03190715f, 0.02011271f, 
    -0.19125900f, 0.01889499f, -0.33987346f, -0.18462573f, -0.05797025f, 0.10972591f, -0.09879471f, -0.21858121f, 
    -0.00160226f, -0.05109263f, 0.07061164f, 0.01009295f, 0.08570226f, -0.10339420f, 0.09736118f, -0.07157575f, 
    0.02032862f, -0.05003519f, 0.01364474f, -0.03170573f, 0.18381651f, 0.06883352f, -0.10342631f, 0.11038026f, 
    0.10019286f, 0.07006010f, 0.09769646f, -0.06590254f, -0.13400781f, -0.00083286f, -0.05973355f, 0.05817082f, 
    0.05239926f, -0.04268144f, -0.02825807f, 0.03991951f, 0.07026286f, 0.04720172f, 0.08980910f, 0.03812014f, 
    -0.00183753f, 0.16836897f, 0.08364360f, -0.03164275f, 0.15580508f, -0.10147794f, -0.06431042f, -0.01048088f, 
    0.01197747f, -0.02395325f, 0.02166927f, -0.09032357f, -0.06826199f, -0.09192009f, 0.06835503f, -0.02727881f, 
    0.04812225f, 0.11724591f, 0.03766885f, -0.02553061f, -0.14159243f, 0.03851951f, 0.03743743f, -0.22703578f, 
    -0.14973672f, -0.05089637f, -0.05844415f, -0.07171142f, 0.08927841f, -0.10104056f, -0.01688030f, 0.02301016f, 
    -0.00047298f, 0.02961702f, -0.03594885f, 0.06085770f, -0.03246769f, -0.05300552f, -0.20620368f, 0.07009509f, 
    0.19960806f, 0.19220074f, 0.02062278f, 0.02941711f, 0.09141210f, -0.03804253f, -0.00323040f, 0.02052251f, 
    -0.05593009f, -0.06924105f, 0.05482104f, 0.02205617f, 0.04036272f, -0.05406757f, -0.00176836f, -0.07331242f, 
    -0.00529911f, -0.05727074f, 0.10981309f, -0.02550055f, -0.10531206f, 0.31319755f, -0.16457078f, -0.00588348f, 
    -0.08364465f, 0.06962324f, 0.01789708f, -0.06240603f, -0.05974919f, -0.02080416f, 0.04030034f, 0.02198472f, 
    0.01016784f, 0.03680624f, 0.06397594f, 0.00759873f, -0.08862517f, -0.00953314f, 0.03695924f, 0.13992220f, 
    -0.25984755f, -0.06179903f, 0.14523356f, -0.07670124f, -0.26007721f, -0.09160168f, 0.02463852f, -0.06066667f, 
    0.10628156f, 0.00735575f, -0.00372364f, 0.08368970f, -0.04509169f, 0.01892306f, 0.01648759f, -0.06784864f, 
    0.00482960f, -0.15834191f, 0.08107564f, -0.03955324f, -0.09499737f, 0.00650773f, -0.09548590f, -0.04150517f, 
    0.18523076f, 0.21927565f, 0.01451045f, -0.06302709f, -0.02291540f, 0.01491475f, 0.06987821f, 0.06274066f, 
    -0.09421690f, 0.06070606f, -0.04071958f, 0.02108391f, -0.00335448f, 0.07233558f, 0.08480598f, -0.09719368f, 
    -0.27736369f, -0.07705685f, 0.24496712f, -0.14061245f, 0.11420070f, -0.04103477f, -0.08530237f, -0.06522184f, 
    -0.01078170f, -0.12925704f, 0.01588205f, 0.02097907f, -0.05310618f, -0.05565168f, 0.04351544f, -0.10812514f, 
    0.02850324f, 0.01423516f, -0.06401332f, -0.08929933f, 0.14571764f, 0.16762532f, 0.17517191f, -0.03758365f, 
    0.01359722f, -0.16345522f, -0.05221108f, -0.05749831f, -0.19819725f, -0.11983088f, 0.01955280f, -0.02200742f, 
    0.04329859f, 0.10878640f, -0.05008186f, -0.02722697f, -0.06749171f, -0.09399001f, 0.09042155f, -0.05378779f, 
    -0.11914904f, -0.03698112f, -0.37815398f, 0.06085194f, -0.12192004f, -0.07793900f, -0.01583186f, -0.12693845f, 
    -0.08971754f, 0.00208240f, 0.11455471f, 0.00941562f, 0.02483414f, -0.03824103f, 0.09286997f, -0.07094605f, 
    -0.06693556f, -0.07390969f, 0.13141893f, -0.02451683f, 0.11699193f, 0.10976131f, -0.15163907f, 0.14656323f, 
    -0.07085813f, 0.04389406f, 0.07291428f, -0.11279710f, -0.09017745f, -0.02741221f, 0.11051950f, 0.06460191f, 
    0.06273153f, -0.01923942f, 0.09022443f, -0.05578563f, -0.01162979f, -0.10171424f, 0.14339812f, -0.01366108f, 
    0.15160383f, 0.11425056f, -0.02403385f, 0.12580343f, 0.08919709f, 0.04468662f, 0.00731251f, -0.08770724f, 
    -0.01106570f, -0.09556296f, -0.00421952f, 0.01155265f, -0.01943716f, -0.08533285f, 0.01718911f, -0.05021566f, 
    0.03332173f, -0.03801095f, 0.11473185f, -0.05641683f, -0.22278263f, -0.11350262f, 0.19481546f, 0.06163514f, 
    0.03035591f, -0.03113952f, 0.06475017f, -0.05327049f, -0.13299327f, -0.05402992f, 0.07195897f, 0.02763245f, 
    0.01794304f, 0.04745638f, -0.02512612f, 0.05961281f, -0.02594095f, -0.08036469f, -0.00691584f, 0.01793719f, 
    0.04636123f, 0.00467944f, -0.03219885f, 0.08128794f, 0.09361839f, -0.09022315f, -0.04668778f, -0.09000321f, 
    -0.09991547f, 0.06193634f, -0.04721828f, -0.05045176f, -0.03133567f, -0.07934798f, 0.08774565f, 0.00326721f, 
    0.01813781f, -0.01527906f, 0.08917745f, 0.02664558f, -0.05906196f, -0.27960432f, 0.23185806f, -0.11626233f, 
    0.19666073f, 0.03466110f, -0.03670029f, 0.07937630f, -0.11579680f, 0.04568494f, 0.00979576f, -0.05603046f, 
    0.01318193f, -0.07884289f, 0.05619090f, -0.02459489f, -0.05756670f, 0.09059096f, -0.13518138f, 0.04564568f, 
    -0.06020311f, 0.03968214f, 0.10179870f, 0.01465254f, 0.18703414f, 0.08497912f, 0.04581941f, -0.08937961f, 
    0.05325776f, -0.02091702f, 0.11959503f, 0.09852240f, 0.00207736f, -0.00914330f, 0.07598748f, -0.07507987f, 
    0.06712078f, 0.03994953f, 0.00957857f, -0.09248178f, 0.07863181f, -0.00818434f, -0.32318619f, 0.11880995f, 
    0.17087594f, 0.07359819f, 0.04838181f, -0.07274043f, -0.04658312f, -0.01972868f, -0.04502407f, -0.02939389f, 
    0.05970816f, -0.00308076f, 0.05982789f, 0.08027524f, 0.04825751f, 0.05696445f, 0.13439851f, -0.00888221f, 
    -0.12095031f, -0.00657351f, -0.17366856f, -0.21565315f, -0.11486395f, 0.10061019f, 0.00766686f, -0.06461827f, 
    -0.07187143f, -0.11332939f, 0.07316766f, -0.00572356f, 0.05113548f, -0.03968660f, -0.09040136f, -0.07161503f, 
    0.12211777f, 0.00075008f, -0.01423778f, -0.00687121f, -0.13196434f, -0.17132796f, 0.02073545f, -0.15874021f, 
    -0.16491272f, 0.08082150f, -0.10601476f, -0.04469965f, -0.07449269f, 0.09696632f, 0.05383188f, -0.04938963f, 
    -0.00996040f, -0.08444136f, 0.06515953f, -0.00300903f, -0.07517816f, -0.03913406f, -0.01467752f, -0.02673901f, 
    -0.07567254f, -0.23973395f, 0.19972865f, -0.01961672f, 0.10636330f, -0.10629565f, -0.09106112f, 0.00170164f, 
    -0.10652623f, 0.04081764f, -0.03897335f, 0.00948558f, -0.02933736f, -0.04839768f, -0.01743582f, -0.09653878f, 
    0.02375223f, -0.03266756f, 0.06096652f, -0.03652021f, 0.14936559f, -0.03855656f, -0.27163550f, 0.04363823f, 
    0.11579338f, 0.02348678f, 0.07504240f, -0.01865634f, -0.06430706f, -0.01915123f, -0.03125340f, -0.01530344f, 
    0.02168061f, 0.05458300f, -0.01248372f, 0.01421376f, 0.11880864f, 0.07124177f, 0.09523463f, -0.02008903f, 
    0.15671340f, 0.17930074f, -0.06007668f, 0.00347971f, 0.12217011f, -0.05414534f, -0.00422869f, -0.18066514f, 
    -0.04464947f, -0.09441765f, -0.04766357f, -0.03141183f, 0.01896400f, -0.20582803f, 0.04848138f, -0.06651316f, 
    0.10652979f, -0.01990932f, 0.09676746f, -0.03379927f, 0.07325622f, -0.15220043f, 0.12123230f, 0.13649109f, 
    0.08059581f, -0.07297504f, -0.07027689f, 0.03904071f, -0.03449765f, 0.03967922f, -0.04181807f, -0.10993176f, 
    -0.02760293f, 0.00153678f, -0.00943278f, 0.10584379f, -0.00468249f, -0.05908812f, 0.04675597f, 0.01819698f, 
    -0.22268331f, -0.22595409f, -0.06365823f, -0.26903802f, 0.04227300f, 0.05615772f, -0.00835835f, -0.03656698f, 
    -0.06182509f, -0.06270394f, 0.10818823f, 0.02395681f, 0.05382448f, 0.01940868f, -0.06018799f, -0.04663422f, 
    0.07913612f, 0.11755972f, -0.15377478f, -0.16967086f, -0.14711128f, 0.00528728f, 0.01070668f, -0.22155939f, 
    -0.28503689f, -0.07014561f, 0.00820314f, 0.01565876f, -0.01058201f, -0.07361234f, 0.01466814f, 0.05718145f, 
    0.05199251f, 0.00034404f, 0.04524436f, -0.00883946f, -0.01690462f, -0.14549114f, -0.18328844f, 0.02179003f, 
    -0.21348462f, 0.14915799f, 0.05385431f, -0.22910260f, -0.23057882f, -0.06309420f, -0.00200066f, -0.05759361f, 
    0.00499307f, -0.10721416f, 0.03400555f, -0.03399394f, 0.04833054f, 0.03130378f, -0.00270297f, -0.02866425f, 
    0.05324463f, -0.17293231f, -0.15760396f, 0.04549606f, -0.31398988f, -0.04236374f, -0.23816486f, -0.01191081f, 
    -0.30278587f, 0.07410076f, -0.08958361f, -0.19622262f, 0.00171193f, -0.05152869f, 0.12459805f, -0.00701801f, 
    -0.00152663f, 0.10108173f, 0.06627944f, 0.05678603f, 0.09878954f, -0.16607958f, -0.05747289f, -0.05080133f, 
    0.00322943f, 0.07945481f, -0.03296239f, 0.11142275f, 0.00825918f, -0.07140328f, -0.01381285f, 0.05029672f, 
    0.00136083f, -0.02503990f, 0.07123572f, -0.04906010f, -0.05105269f, 0.12460006f, 0.11215343f, 0.08672591f, 
    0.05697291f, 0.03294621f, 0.10090869f, 0.08071505f, 0.16935885f, -0.04078959f, -0.08748740f, 0.15331475f, 
    0.11954846f, 0.07850718f, -0.00065307f, -0.02475985f, -0.10758992f, -0.04815322f, -0.06137859f, -0.03537828f, 
    -0.14168800f, 0.09334626f, 0.04582785f, -0.10745542f, -0.04161290f, 0.04040575f, 0.09428439f, -0.09262069f, 
    -0.50413704f, 0.17894801f, 0.07188228f, 0.00199809f, 0.06131283f, 0.12290739f, 0.10647148f, -0.09930559f, 
    0.10051624f, 0.11379980f, 0.04084947f, -0.05568148f, -0.11961426f, 0.05302122f, 0.00754794f, 0.16360623f, 
    0.02279242f, 0.06541768f, -0.14898199f, 0.03154965f, -0.15674710f, -0.13948113f, -0.08059922f, 0.18650950f, 
    -0.10735317f, -0.00451648f, 0.09026752f, -0.04055903f, -0.01613264f, 0.04346130f, -0.00877176f, -0.02941296f, 
    -0.00027879f, 0.06730521f, 0.13868402f, -0.00576716f, -0.10269500f, 0.01286348f, -0.02485410f, -0.04173649f, 
    0.09885844f, -0.45337945f, 0.04521529f, -0.05283824f, -0.02107462f, -0.06208350f, 0.01698531f, -0.02151105f, 
    -0.00744238f, -0.00912212f, -0.06718083f, -0.07801828f, 0.05781115f, -0.03837679f, -0.14476675f, 0.09092542f, 
    0.10195316f, 0.08419973f, -0.04106786f, 0.07467090f, 0.15333553f, -0.13978679f, -0.00804971f, -0.32089800f, 
    -0.27214316f, 0.09957839f, 0.11223163f, -0.01616008f, 0.06861565f, -0.14445965f, -0.16214275f, 0.05092694f, 
    -0.03345003f, 0.03007338f, -0.05224250f, -0.04495535f, 0.01046210f, -0.07423237f, 0.05571772f, -0.03734262f, 
    0.50574791f, 0.08575228f, -0.19087771f, -0.01927577f, -0.02166485f, 0.01897467f, 0.05745823f, 0.02695641f, 
    -0.02810306f, -0.05238931f, -0.13655789f, -0.06908452f, 0.01317813f, 0.12209534f, -0.05237515f, 0.04121335f, 
    0.04392530f, 0.02020008f, 0.00607636f, 0.09809473f, -0.08966233f, 0.06420392f, 0.01175861f, -0.08896802f, 
    -0.02935902f, -0.13015424f, 0.09736950f, 0.03489223f, -0.07188901f, -0.06313482f, 0.01768282f, -0.04304816f, 
    -0.06921407f, -0.18761989f, -0.00153189f, -0.05690914f, 0.06814133f, -0.06691780f, 0.18259627f, 0.06272943f, 
    -0.32826468f, 0.29681942f, -0.30323654f, 0.23615603f, -0.16275258f, 0.05950958f, 0.06191730f, 0.10248871f, 
    0.10150465f, -0.07140685f, -0.05219284f, 0.06498480f, 0.12953484f, -0.08969780f, 0.13529198f, 0.02565023f, 
    -0.01631812f, 0.08350488f, 0.05705156f, -0.03302186f, -0.37529051f, 0.02254603f, 0.16249062f, 0.12387397f, 
    -0.21514079f, 0.05019056f, 0.02314628f, -0.10763103f, -0.00244807f, -0.01595850f, 0.10054517f, -0.01037249f, 
    0.09945405f, 0.06615379f, -0.06561704f, 0.04580611f, -0.03803601f, -0.01425858f, -0.11666726f, -0.15963010f, 
    -0.40306005f, -0.33300316f, 0.03390246f, 0.17427313f, -0.08987262f, 0.01686503f, 0.10819594f, 0.08733179f, 
    0.04202275f, 0.02495942f, -0.14460936f, 0.10486504f, -0.06246474f, -0.02826565f, -0.04947674f, 0.02446860f, 
    -0.01992257f, 0.14031331f, 0.12524751f, -0.00671069f, 0.15382501f, -0.36458805f, 0.37835446f, -0.25800136f, 
    -0.56208491f, 0.03023707f, 0.00021881f, 0.02571641f, -0.13360806f, 0.14880246f, -0.03228977f, 0.03726891f, 
    0.15183015f, -0.25890717f, -0.03891881f, -0.13301352f, 0.01657692f, 0.05716093f, -0.04015822f, -0.16172884f, 
    0.66111910f, 0.06687542f, -0.08566447f, -0.11770333f, 0.10393282f, 0.07119308f, -0.13101158f, -0.03589753f, 
    0.00175954f, 0.06128116f, -0.09421505f, -0.14369607f, 0.15525076f, 0.10918664f, 0.08747222f, 0.10649486f, 
    0.02350146f, 0.01433029f, -0.00785822f, -0.08102024f, 0.48568821f, -0.03019849f, -0.24022657f, -0.23892224f, 
    -0.05375389f, 0.08927417f, 0.03806945f, 0.17978421f, -0.01634297f, -0.01476629f, -0.13667183f, 0.08253589f, 
    0.00609727f, 0.16857871f, -0.05146518f, -0.04685017f, 0.10267083f, 0.08074933f, 0.06115199f, -0.02839929f, 
    -0.48672137f, 0.04807583f, 0.10542239f, 0.02432233f, -0.05843001f, -0.01201348f, 0.02850341f, -0.02868297f, 
    0.01483274f, -0.07370929f, -0.03974554f, -0.06271402f, -0.04799980f, 0.12456848f, -0.05136766f, 0.00123234f, 
    0.11543955f, 0.19766465f, -0.03962653f, 0.04647177f, -0.44091251f, 0.18570906f, 0.30570182f, -0.15937851f, 
    0.12087396f, 0.06022997f, 0.10148691f, 0.02586186f, -0.02596588f, 0.00671569f, 0.06351060f, 0.01432758f, 
    -0.05714750f, -0.00971966f, 0.07249504f, 0.11027192f, 0.00362518f, 0.15123540f, -0.18595292f, 0.06207968f, 
    -0.27669185f, 0.14688239f, 0.05505625f, -0.00968541f, 0.06595424f, 0.09600746f, 0.07883283f, -0.04321992f, 
    -0.04133075f, -0.12732324f, 0.06511918f, 0.05411913f, -0.03534089f, 0.01822862f, -0.02708919f, 0.10663887f, 
    -0.00594598f, -0.01440798f, -0.06076539f, 0.03908626f, 0.01109488f, -0.33507693f, -0.01067710f, 0.18169205f, 
    0.10726798f, -0.10878327f, -0.06392048f, -0.11551421f, 0.03285656f, 0.05635915f, -0.07123110f, 0.13458669f, 
    -0.09044995f, -0.06153272f, 0.00499970f, -0.18459280f, 0.03326393f, 0.06573967f, 0.02569931f, -0.02473192f, 
    0.53643006f, -0.65936279f, 0.27851692f, -0.10163818f, 0.24057171f, 0.03497108f, -0.06214689f, -0.01710012f, 
    0.05449870f, -0.18850067f, -0.08163325f, -0.07424166f, -0.01907635f, 0.13011257f, 0.13320363f, -0.00372701f, 
    0.01592090f, -0.14840959f, -0.05967683f, 0.10415444f, 0.24983773f, -0.00769362f, -0.09964818f, 0.17049667f, 
    0.02484627f, -0.02196893f, -0.04405182f, -0.00104876f, 0.09907506f, -0.00122172f, -0.06951652f, 0.10650607f, 
    0.04475571f, -0.13767888f, 0.02787507f, 0.06593451f, 0.00762243f, -0.00180761f, 0.09601233f, 0.05631620f, 
    0.06198512f, -0.10297919f, -0.05638237f, -0.29408702f, -0.11520572f, 0.00067358f, 0.04431243f, -0.15339360f, 
    -0.03740519f, 0.03610081f, 0.03008658f, -0.10085140f, 0.00265316f, -0.01767029f, -0.04064379f, 0.05126135f, 
    0.13474479f, -0.22758450f, -0.08132464f, -0.05959260f, 0.03181614f, -0.18347351f, 0.18015504f, -0.40391931f, 
    0.06212977f, 0.05270036f, 0.01662236f, -0.14006542f, 0.03686752f, 0.00695005f, 0.01299970f, 0.03132701f, 
    -0.02345920f, -0.01341740f, -0.01810785f, -0.02765649f, -0.03065891f, 0.02541403f, 0.04867915f, -0.03418406f, 
    -0.11084843f, -0.09393109f, -0.16146219f, 0.01066067f, -0.47849748f, 0.05723708f, 0.06887600f, -0.05148242f, 
    -0.01677413f, 0.05010550f, -0.15669268f, 0.03728456f, -0.04177846f, 0.25454921f, 0.04940401f, -0.03568485f, 
    -0.02465360f, 0.00446754f, 0.07465278f, 0.05356022f, 0.10243838f, -0.21718992f, 0.03510717f, 0.17999728f, 
    0.22839572f, 0.01231043f, -0.08338721f, 0.05341349f, 0.05396090f, 0.17183462f, 0.01263450f, -0.04605044f, 
    0.04401954f, 0.15535101f, -0.02601305f, 0.10737821f, -0.02456230f, 0.00984858f, -0.01730352f, -0.19693999f, 
    0.03713004f, -0.11706583f, -0.10265850f, 0.07613513f, 0.15985733f, 0.16985252f, -0.06556712f, 0.06460968f, 
    -0.09494297f, 0.22115554f, -0.05995547f, -0.04790087f, 0.11053032f, 0.14027829f, -0.03769663f, -0.04061082f, 
    0.03213221f, 0.01943384f, 0.06643522f, -0.04719431f, -0.09814308f, 0.04183730f, 0.10535797f, -0.33501580f, 
    -0.30817980f, 0.04028572f, 0.07993270f, -0.07103112f, -0.08293616f, 0.05870891f, -0.15294628f, -0.00424547f, 
    -0.10456637f, -0.07033516f, -0.00856783f, -0.07484912f, -0.11018442f, 0.06130650f, 0.07275187f, 0.02755592f, 
    -0.28391492f, -0.39183873f, -0.02080351f, -0.07058275f, 0.09606703f, 0.00926165f, 0.09577164f, 0.03184335f, 
    -0.03275826f, -0.12869777f, 0.05887022f, 0.08829549f, -0.09638727f, -0.06032800f, 0.04099416f, -0.04044686f, 
    0.03852911f, -0.03183228f, -0.06557325f, 0.06023372f, -0.07946986f, -0.19149192f, -0.14132763f, 0.19402371f, 
    0.09799130f, 0.12496427f, -0.02343428f, -0.17371298f, -0.04252263f, 0.19255733f, -0.15358289f, 0.09226967f, 
    -0.02311684f, 0.00950688f, -0.08051839f, -0.15284967f, -0.19599345f, -0.00938482f, -0.09882933f, -0.00623422f, 
    0.08802107f, -0.12503824f, 0.17585716f, -0.17993881f, -0.25889406f, -0.04259983f, -0.00876519f, 0.01608409f, 
    0.02518012f, 0.05307044f, 0.00047794f, 0.09023856f, 0.17004989f, -0.03036704f, -0.16398947f, -0.03911699f, 
    0.02430271f, 0.08122024f, 0.03085263f, 0.05897636f, -0.15602463f, 0.03694995f, -0.05089378f, 0.07414327f, 
    0.13241841f, -0.05156911f, 0.04040485f, 0.09179103f, -0.04320267f, -0.01580112f, 0.01033860f, -0.00691739f, 
    -0.16540308f, 0.00033953f, 0.04505293f, 0.02833097f, -0.08239172f, 0.06479988f, 0.08091555f, 0.13177229f, 
    -0.21015516f, -0.08623800f, 0.06417581f, 0.05795914f, 0.00617252f, 0.03433672f, 0.10093290f, -0.02530105f, 
    -0.04265565f, -0.00153080f, -0.08388447f, -0.01355763f, -0.03910632f, -0.03432626f, 0.16943321f, -0.02778251f, 
    0.00862622f, 0.08802096f, 0.02403643f, 0.06030230f, -0.52060276f, -0.25616956f, 0.00945192f, -0.17732604f, 
    0.19468340f, -0.20577565f, 0.10506218f, 0.02038470f, -0.01768046f, 0.11320079f, -0.06511918f, -0.16844335f, 
    -0.05185791f, -0.02587209f, 0.05792458f, 0.13380356f, 0.02899220f, -0.00168229f, 0.03014252f, 0.08333392f, 
    0.01832341f, -0.02781331f, -0.21836129f, 0.15061672f, -0.04228515f, 0.01469114f, -0.05136039f, -0.15425441f, 
    0.02072826f, -0.03547494f, 0.06247818f, 0.01877065f, -0.16822074f, -0.10405196f, 0.10311907f, -0.11181589f, 
    -0.03694779f, -0.11242362f, -0.03712315f, 0.20310593f, -0.08278936f, -0.09684201f, 0.10186868f, 0.12249416f, 
    -0.24551800f, 0.08963305f, 0.06265613f, -0.02860425f, -0.02653878f, -0.15624274f, -0.13253218f, 0.05951529f, 
    -0.13984239f, -0.04036397f, 0.05458733f, 0.02349744f, 0.03437120f, 0.00086688f, -0.01875757f, -0.05073648f, 
    -0.02975249f, 0.05687298f, -0.05995645f, 0.04569094f, 0.01735705f, 0.07165772f, 0.00076940f, 0.19219758f, 
    -0.02464619f, 0.02334625f, 0.12825729f, 0.01814977f, 0.09072071f, -0.03843384f, 0.05294368f, 0.05460919f, 
    -0.03271876f, 0.02444766f, 0.17360185f, 0.01425145f, 0.20684083f, -0.00289526f, 0.05246849f, -0.02500677f, 
    -0.03606115f, -0.12880012f, -0.10864586f, 0.03953673f, 0.05476873f, -0.05208329f, -0.03477490f, 0.04073262f, 
    -0.12127355f, -0.02842087f, -0.08540874f, -0.10465753f, -0.01884412f, -0.04132601f, -0.09282350f, -0.02498932f, 
    0.10411274f, 0.07868671f, 0.11838844f, 0.15253121f, 0.09982436f, 0.04576549f, -0.02510237f, 0.01676937f, 
    -0.01333459f, 0.00464634f, 0.05056218f, 0.08254243f, -0.01811520f, 0.02513002f, 0.12570931f, 0.00560634f, 
    0.01868179f, -0.27346298f, -0.12037376f, -0.08672699f, -0.64660716f, -0.42538452f, -0.07237224f, -0.17847861f, 
    -0.29321444f, 0.06259429f, 0.07810398f, -0.07490329f, -0.08978587f, 0.05564252f, 0.04821245f, 0.07510557f, 
    0.08273238f, 0.01143031f, 0.07544402f, 0.10688592f, -0.01359941f, 0.08916812f, 0.08192257f, 0.11798427f, 
    0.22370526f, 0.10476675f, 0.01578729f, -0.03535409f, 0.08239069f, -0.23664872f, 0.04522023f, -0.02950970f, 
    0.18209255f, 0.06508426f, -0.01516514f, 0.01396215f, -0.00694144f, -0.14908127f, -0.04852663f, -0.16255362f, 
    0.02175186f, 0.00559012f, -0.00785767f, 0.03131715f, 0.27640346f, 0.15045173f, 0.15431309f, -0.10677281f, 
    -0.01263178f, 0.11612836f, 0.01310115f, -0.00427108f, 0.06452692f, -0.00017769f, 0.04046036f, -0.05999102f, 
    0.02463738f, 0.02873423f, -0.08831437f, 0.09999841f, 0.09788407f, -0.10967967f, 0.01095257f, 0.07295550f, 
    -0.16677056f, -0.10494689f, -0.06373049f, -0.03655268f, 0.01020031f, -0.04857164f, 0.07253691f, 0.02208468f, 
    0.04301985f, 0.04614265f, 0.08836725f, -0.11573654f, 0.03758743f, -0.09501157f, -0.06636355f, -0.07803007f, 
    0.09032506f, 0.10685256f, 0.20738582f, 0.11634633f, -0.15393643f, -0.19422661f, -0.02120025f, -0.00574492f, 
    0.21509154f, -0.00251117f, 0.13581665f, 0.05075437f, 0.04679377f, -0.08674352f, 0.01643503f, -0.03340106f, 
    -0.01806851f, -0.07756352f, 0.07668003f, -0.05112584f, 0.15396692f, 0.13173115f, 0.13008463f, 0.05294443f, 
    0.15750597f, 0.04063337f, -0.01726808f, 0.02852183f, 0.01842960f, -0.01161765f, -0.10453483f, 0.06177960f, 
    -0.01576529f, 0.05750605f, 0.05557787f, -0.00982474f, 0.03815685f, 0.07828544f, -0.07236814f, 0.00650047f, 
    -0.03420502f, -0.19082080f, 0.01115009f, 0.06314732f, -0.31689328f, 0.19480558f, -0.13212498f, -0.12847520f, 
    -0.25259385f, 0.16647987f, -0.07274462f, -0.02173170f, -0.09831405f, -0.03805913f, -0.12066047f, 0.03987619f, 
    -0.03038056f, 0.24400549f, -0.00995626f, 0.01138922f, 0.07859629f, 0.05639709f, -0.15564634f, -0.02205375f, 
    0.09915722f, 0.17362545f, 0.10863124f, 0.02540683f, -0.05829723f, -0.09259388f, -0.18626864f, 0.08153652f, 
    -0.07646489f, 0.14708534f, 0.05878707f, 0.06625788f, -0.05240470f, -0.13654970f, -0.15520212f, -0.04381924f, 
    -0.05436169f, 0.04564317f, -0.05928914f, -0.07076606f, -0.15291895f, 0.13495865f, 0.22388165f, 0.17348500f, 
    -0.10763680f, 0.02674465f, 0.05385007f, -0.02769224f, 0.02719832f, 0.02266309f, 0.04640901f, -0.01038590f, 
    0.02415683f, -0.16826063f, -0.00283844f, 0.04484529f, -0.03500166f, 0.17855085f, 0.09436930f, 0.15692629f, 
    -0.66904980f, -0.35110730f, 0.11551718f, 0.07043359f, 0.17495197f, 0.11564645f, 0.18069862f, 0.14698069f, 
    0.00901872f, -0.13949223f, 0.02888819f, 0.12209736f, -0.03666226f, 0.09652375f, 0.05241529f, -0.02353461f, 
    0.01933243f, -0.08063158f, -0.05300934f, -0.06019219f, -0.47131377f, -0.24370354f, -0.11112209f, -0.03869230f, 
    -0.10424417f, 0.12473225f, 0.07665708f, 0.07518255f, -0.00391643f, -0.03168215f, 0.19475244f, -0.00402358f, 
    -0.00304596f, -0.00913726f, 0.06576643f, 0.06911034f, -0.03859738f, -0.01177101f, 0.11378611f, 0.02832356f, 
    -0.52805436f, -0.35365856f, -0.26129308f, -0.20479999f, -0.20399535f, 0.12901880f, 0.06826632f, 0.01588749f, 
    -0.00279929f, 0.02098617f, 0.03305342f, -0.05016855f, -0.01970657f, 0.04068692f, 0.03125196f, -0.07655556f, 
    -0.05587045f, 0.04419884f, 0.11430979f, 0.03031764f, 0.26306683f, -0.04000883f, -0.13194598f, 0.06596630f, 
    -0.20296808f, -0.07627316f, -0.07231666f, -0.05815645f, -0.00233780f, 0.06049644f, -0.02404400f, 0.08095369f, 
    -0.11069825f, -0.05030515f, -0.03660710f, -0.01312659f, 0.04292861f, -0.03740673f, -0.18513815f, 0.00432336f, 
    -0.56526154f, 0.10394403f, -0.41656268f, -0.01946758f, 0.21323083f, 0.04711446f, -0.00252725f, -0.06884879f, 
    0.06277306f, 0.12409689f, 0.07455214f, 0.06698453f, 0.08687576f, -0.12141268f, 0.11349936f, 0.06864780f, 
    0.01912981f, 0.13421243f, -0.02037717f, 0.17401662f, 0.13933842f, -0.00766185f, -0.07855920f, -0.03550747f, 
    0.13202870f, 0.00870426f, 0.03281659f, -0.04146126f, -0.02172540f, -0.06838991f, -0.03685405f, 0.02987147f, 
    -0.01532809f, 0.01139143f, -0.07290721f, -0.05837105f, 0.15342219f, 0.07095434f, -0.23632713f, 0.11357453f, 
    -0.60262728f, -0.17117198f, 0.02008580f, -0.16238353f, -0.10915153f, 0.14923480f, 0.05956745f, -0.05760504f, 
    -0.09891097f, 0.08843446f, 0.02801233f, -0.11359292f, -0.07839768f, 0.02250025f, 0.08667818f, -0.12610297f, 
    -0.12639882f, 0.01928551f, 0.02744399f, 0.02512159f, -0.60147649f, -0.17790821f, -0.22924758f, -0.13935912f, 
    -0.11505842f, 0.13348155f, 0.01257751f, -0.06265636f, -0.01951765f, 0.05379052f, 0.06716724f, 0.05174076f, 
    0.05338927f, 0.02254654f, 0.02560436f, -0.04488245f, -0.04509865f, 0.07204913f, 0.01851159f, -0.02095597f, 
    -0.27572736f, -0.15303569f, 0.07039882f, -0.02739588f, -0.11244069f, 0.04807581f, 0.10540699f, 0.02057169f, 
    0.00087471f, 0.11028542f, -0.00160191f, 0.05940798f, 0.11852355f, -0.11908013f, 0.07871191f, 0.06923263f, 
    0.05398686f, 0.03106738f, 0.02227089f, 0.10732340f, 0.04450070f, 0.10615775f, -0.22876298f, 0.12578017f, 
    0.07374401f, -0.06457988f, -0.10479167f, -0.00428956f, -0.11486535f, -0.02964004f, -0.06626011f, -0.04632316f, 
    0.05035637f, -0.05207830f, 0.01978718f, -0.04375970f, -0.07029399f, 0.04162077f, -0.12761673f, -0.07935695f, 
    0.15859057f, 0.09602565f, -0.10833427f, 0.10823909f, -0.08102832f, 0.03315622f, -0.02608566f, -0.04589356f, 
    -0.00170774f, -0.02754332f, 0.01787372f, 0.05125272f, -0.07531609f, -0.02594224f, -0.05205379f, -0.05882575f, 
    -0.12455326f, 0.11427315f, -0.02998991f, -0.08761685f, -0.46063912f, -0.40543863f, 0.01931152f, -0.13056043f, 
    -0.13240217f, 0.11591356f, -0.01449165f, -0.14034669f, -0.02729067f, 0.02614762f, 0.07955705f, 0.11303043f, 
    0.02327324f, 0.22238956f, -0.07202216f, 0.12195103f, 0.09303038f, 0.07014365f, -0.06906603f, 0.01054230f, 
    -0.22553816f, -0.25098559f, -0.20124412f, -0.18230449f, -0.06806297f, 0.01642664f, 0.09835908f, -0.17307262f, 
    -0.05626298f, -0.08998998f, -0.01376667f, 0.01470042f, -0.13794430f, -0.30450064f, 0.19393650f, -0.03751380f, 
    0.01109979f, 0.13819593f, 0.00567571f, 0.11225975f, 0.41255277f, 0.18530382f, -0.17649454f, 0.04578029f, 
    -0.19601196f, -0.18919688f, -0.16340187f, 0.09313696f, 0.04874602f, -0.02801383f, -0.06044909f, -0.02673453f, 
    -0.03365096f, -0.12737522f, -0.02410403f, 0.07334615f, 0.13531822f, 0.07585903f, 0.04629749f, -0.01314117f, 
    0.09544228f, 0.27739230f, 0.17209142f, -0.01328126f, -0.13191988f, 0.10648850f, -0.06727549f, 0.05606254f, 
    0.09610102f, 0.05962406f, -0.05259458f, 0.06501162f, -0.02014522f, 0.02036589f, -0.00619793f, 0.07631168f, 
    -0.06792510f, -0.14511073f, -0.12493423f, -0.02124026f, 0.27372625f, 0.16781317f, -0.11799207f, -0.05956463f, 
    -0.10012996f, 0.09600117f, -0.00848215f, 0.08370674f, 0.01074600f, 0.05334916f, -0.13945320f, -0.00248152f, 
    0.04394067f, -0.09423515f, -0.04444123f, 0.08852709f, 0.19024588f, -0.23176476f, -0.05144668f, 0.06390675f, 
    0.16907293f, -0.01214296f, 0.02096295f, 0.05174351f, -0.00797482f, 0.09548668f, 0.08742833f, -0.02341760f, 
    0.06042425f, 0.05553726f, 0.07849734f, 0.02223226f, 0.01287564f, 0.03759104f, -0.05587287f, -0.01790782f, 
    -0.00830028f, -0.33829060f, -0.15905878f, -0.09300020f, -0.37460023f, -0.08562934f, -0.25958347f, 0.10845423f, 
    0.06671495f, -0.00260322f, -0.08226725f, -0.10416886f, 0.04402190f, -0.02943002f, 0.00990785f, 0.05636875f, 
    0.02835786f, -0.04286161f, 0.13045307f, 0.00575331f, -0.06133598f, -0.15055552f, 0.02208950f, -0.09647232f, 
    0.02009254f, -0.12331354f, -0.03266812f, -0.06939480f, 0.17502251f, -0.06243426f, -0.01726504f, 0.00051498f, 
    0.05407543f, -0.09402178f, -0.04484394f, -0.14314154f, -0.03381361f, 0.00594363f, 0.11094271f, 0.02423719f, 
    0.11420227f, 0.02238830f, 0.10794858f, 0.09480385f, -0.66229916f, -0.47176033f, -0.27351394f, -0.07144002f, 
    -0.38745895f, 0.07355920f, 0.09800468f, -0.05486530f, -0.12377515f, 0.05701953f, -0.00730849f, 0.00373093f, 
    -0.10736948f, 0.01503909f, 0.02057966f, 0.05148143f, 0.11747102f, 0.12270047f, 0.00538009f, 0.04470987f, 
    0.18384090f, -0.23598842f, -0.01479102f, 0.08779402f, -0.15315008f, 0.10175184f, 0.07573270f, -0.00864223f, 
    0.03922148f, 0.09934834f, -0.00729808f, -0.05574289f, -0.05869883f, 0.08358593f, -0.02982582f, -0.08045691f, 
    0.06126796f, 0.02335306f, -0.14323907f, -0.10206206f, 0.01119453f, 0.10725473f, -0.01129531f, 0.04411308f, 
    -0.08271883f, 0.00846680f, -0.12299097f, 0.02491429f, -0.06672743f, -0.11485330f, -0.02150815f, -0.04506815f, 
    0.09039880f, -0.04492513f, 0.00499784f, 0.00652612f, 0.04940316f, -0.03724660f, -0.02469697f, -0.02841578f, 
    -0.06981038f, 0.23330310f, -0.14694171f, -0.02715717f, -0.10483246f, 0.02013201f, 0.04846749f, -0.05818910f, 
    -0.00168759f, -0.17231205f, 0.08855006f, 0.00773345f, 0.02000359f, 0.02968360f, -0.01167231f, 0.11348770f, 
    0.09180450f, 0.02289871f, -0.03975666f, 0.05023254f, 0.36068979f, 0.00494242f, -0.20829569f, -0.02089277f, 
    0.12679595f, 0.00783740f, -0.07346630f, -0.06953875f, 0.01112522f, 0.05976040f, 0.05092119f, 0.05206652f, 
    -0.02344966f, 0.04487915f, -0.03078867f, 0.07411800f, 0.00558358f, 0.04839661f, 0.04423651f, -0.04984343f, 
    -0.38458985f, -0.03760267f, -0.02304133f, -0.06744940f, -0.07682788f, -0.05391869f, -0.03446793f, -0.07160958f, 
    0.05111419f, 0.10474136f, -0.04373556f, -0.03821001f, 0.02876360f, -0.04607225f, -0.06202045f, -0.02148918f, 
    -0.15488704f, -0.05569272f, -0.09991558f, -0.02276392f, -0.02706030f, 0.00891275f, -0.15270130f, -0.12411305f, 
    0.12729576f, 0.03562130f, -0.10313531f, 0.05134731f, 0.02897999f, 0.00741707f, -0.00757936f, -0.02135955f, 
    -0.06829485f, -0.06194680f, 0.06744888f, 0.08324274f, -0.09910851f, 0.01671517f, 0.11782722f, 0.03736825f, 
    -0.23465352f, -0.39484647f, -0.08853913f, -0.01980685f, -0.07453701f, 0.04428114f, 0.01424560f, 0.02453233f, 
    -0.06390578f, 0.09650924f, -0.01586833f, 0.01881590f, -0.04446452f, 0.00093704f, -0.02803192f, 0.04025054f, 
    0.01769868f, -0.03834214f, -0.12883095f, -0.07317200f, -0.22695924f, 0.14850840f, 0.00837340f, 0.03022523f, 
    -0.14349037f, 0.18652618f, 0.11221574f, 0.02529594f, -0.08368626f, -0.00716300f, -0.00847678f, 0.07243439f, 
    0.05560787f, 0.02573927f, 0.01683108f, -0.09940905f, 0.09574183f, -0.06241433f, 0.01524006f, 0.05241657f, 
    0.35382995f, -0.12857191f, -0.08964905f, 0.00913061f, 0.02410291f, -0.14954984f, -0.02174851f, -0.00338473f, 
    -0.10152414f, -0.10151470f, -0.04296568f, -0.04786413f, -0.01173633f, 0.01698149f, -0.23178355f, 0.11867127f, 
    0.02546163f, 0.05265542f, 0.00547244f, -0.09499919f, 0.53807664f, 0.09365223f, -0.24221279f, -0.16207252f, 
    0.00218428f, -0.03978641f, 0.16090575f, -0.00822261f, 0.06998197f, 0.02140671f, 0.17307346f, 0.05137787f, 
    -0.04069580f, 0.02002473f, 0.12161769f, 0.04394417f, -0.15077031f, 0.04411668f, 0.07548377f, 0.12424093f, 
    0.18766122f, -0.02686019f, 0.05587104f, -0.12227317f, 0.06694837f, -0.16038905f, -0.02792621f, -0.02511091f, 
    -0.02288353f, -0.26155671f, 0.01304435f, -0.15277714f, 0.03104804f, 0.03804725f, -0.00355689f, -0.05611863f, 
    -0.11917309f, -0.01247758f, -0.04611417f, 0.02840654f, -0.14015645f, -0.22733837f, -0.09473623f, 0.08997482f, 
    0.15159240f, 0.00798970f, -0.07402430f, 0.08511496f, 0.02807419f, 0.07841519f, -0.01525370f, -0.00953562f, 
    -0.11266782f, 0.07327263f, 0.00524741f, 0.03722988f, 0.08812632f, -0.04396968f, -0.10442047f, -0.17980179f, 
    -0.06525073f, 0.38684621f, -0.19588505f, 0.09698251f, 0.04453161f, 0.14814824f, 0.07294084f, -0.07378926f, 
    0.01026830f, -0.07462155f, -0.03771147f, 0.05542984f, -0.09820619f, 0.04845715f, 0.26837322f, -0.04772283f, 
    0.21490334f, 0.13567433f, -0.12213139f, 0.10049371f, 0.24348108f, -0.19529790f, -0.17984092f, 0.13669622f, 
    -0.12984280f, 0.10464468f, 0.06065090f, 0.02613443f, 0.02997828f, 0.05526948f, 0.02160764f, -0.01765420f, 
    0.03250918f, 0.06651244f, -0.03524887f, 0.02407483f, 0.07741546f, -0.02851610f, -0.08570580f, 0.03649480f, 
    0.10768286f, -0.25063354f, -0.14126168f, -0.09653857f, -0.36735743f, 0.03486772f, 0.01543871f, 0.12953332f, 
    -0.00878843f, 0.06226717f, 0.06989622f, 0.04660343f, -0.02375753f, -0.00832470f, 0.00498110f, -0.03739571f, 
    -0.02159879f, -0.04893554f, -0.02180892f, -0.07911239f, -0.05111155f, 0.25197992f, -0.03433244f, -0.11022288f, 
    -0.13638875f, -0.02581934f, -0.05642878f, 0.04618448f, -0.12005947f, -0.14148335f, -0.04518669f, -0.07950553f, 
    0.16418508f, -0.18319407f, -0.02890335f, 0.03922587f, 0.03222165f, 0.05530319f, -0.02066055f, -0.08003141f, 
    -0.40289274f, 0.26378059f, -0.00629638f, 0.05616251f, -0.10922639f, -0.12781864f, -0.04500310f, -0.06025841f, 
    0.02409559f, 0.03868197f, -0.02738409f, 0.04536429f, 0.11828035f, 0.13772239f, -0.03507679f, 0.02613832f, 
    -0.00507107f, -0.18183857f, -0.00530449f, 0.08015916f, -0.51007974f, 0.39326364f, 0.06719366f, -0.07741683f, 
    0.08435396f, -0.03932459f, -0.02665025f, -0.02455639f, -0.11725137f, 0.02354563f, -0.03831304f, 0.04216988f, 
    0.04389212f, -0.11620392f, -0.02134123f, -0.08577521f, -0.04564641f, -0.03920842f, 0.02278939f, -0.01131598f, 
    0.15371929f, -0.19392738f, -0.08508553f, -0.11836335f, -0.13433893f, -0.10973561f, 0.02053867f, 0.00794807f, 
    -0.00674423f, -0.02033559f, 0.06505015f, -0.00581323f, -0.01528955f, -0.02535204f, 0.02201599f, 0.02610701f, 
    0.02639708f, -0.07259374f, 0.04460619f, 0.08318699f, 0.43189201f, -0.02106091f, -0.33670181f, 0.11019351f, 
    -0.33967468f, -0.12484480f, -0.00162313f, 0.09203915f, -0.04062590f, 0.04461555f, 0.05241532f, -0.05108041f, 
    0.09299897f, 0.02996276f, -0.01794314f, 0.05578338f, 0.10801721f, -0.10364349f, 0.02373351f, -0.05810905f, 
    -0.23213698f, 0.24594210f, -0.01438854f, -0.08148996f, 0.49418792f, 0.27833477f, -0.11685181f, 0.07947999f, 
    0.05920275f, 0.16838250f, 0.06144660f, 0.07662737f, 0.03909615f, -0.02434042f, 0.02301158f, -0.07484443f, 
    0.10216127f, -0.00766509f, -0.02371995f, 0.00187572f, -0.10157064f, -0.13886353f, 0.04098960f, 0.04149629f, 
    -0.09215814f, -0.12026761f, 0.11369099f, 0.04403782f, 0.04562052f, -0.06646527f, 0.04019824f, -0.09253795f, 
    -0.06994867f, 0.12544471f, -0.00549980f, 0.00031543f, -0.05161476f, 0.07855848f, -0.12595083f, 0.11940618f, 
    -0.28916588f, -0.05155155f, 0.11449339f, -0.05066601f, 0.17487504f, -0.12748307f, 0.01094289f, -0.01191275f, 
    0.07524724f, -0.24880573f, -0.06069022f, 0.05133954f, 0.01321235f, 0.09248214f, 0.01567785f, -0.00321239f, 
    -0.14284445f, -0.00586328f, -0.13078626f, 0.03337917f, 0.52851784f, 0.16386893f, -0.36020768f, -0.01219272f, 
    0.08193760f, 0.05546333f, -0.09925286f, -0.11698711f, -0.01761703f, 0.00734499f, 0.12315110f, 0.12259424f, 
    0.00053280f, -0.00365323f, -0.01910117f, 0.04074537f, -0.05228977f, 0.06041706f, -0.05307388f, 0.07962100f, 
    -0.53072560f, -0.51661742f, -0.00037840f, -0.13970190f, -0.25760868f, 0.03620505f, 0.14278360f, 0.01119767f, 
    0.05282208f, 0.00884561f, -0.07156289f, 0.01735703f, 0.03078953f, -0.02421365f, -0.03356521f, -0.12642109f, 
    0.05391266f, 0.01319527f, -0.11251350f, -0.03861806f, 0.16502312f, -0.16276561f, 0.09203468f, 0.01579666f, 
    -0.04552808f, 0.08342547f, 0.15383382f, 0.06728575f, -0.05237096f, 0.06704949f, -0.17939821f, -0.10601854f, 
    0.08448157f, 0.02068679f, -0.17697026f, -0.09517168f, 0.01133502f, -0.00926811f, -0.14495566f, -0.07400773f, 
    0.25414702f, 0.05290788f, -0.08722528f, -0.12419266f, 0.50120336f, -0.02003177f, -0.03629793f, 0.08085100f, 
    0.09378558f, -0.04213111f, 0.08511069f, -0.03891904f, -0.00269311f, 0.15670343f, 0.00283767f, 0.01121950f, 
    0.04138795f, -0.02548125f, 0.10996237f, 0.07146424f, 0.06242706f, 0.04365840f, -0.09316397f, -0.01184438f, 
    0.05289490f, -0.02695802f, -0.05944079f, -0.01665554f, 0.01853104f, -0.00816219f, 0.15287413f, -0.12627415f, 
    -0.08118286f, 0.01339611f, -0.00845279f, 0.12432637f, -0.04321988f, 0.05320773f, 0.03486438f, -0.03399169f, 
    0.02026525f, 0.13884188f, -0.11630061f, -0.14559525f, 0.15942676f, -0.05312714f, -0.14440845f, 0.01592920f, 
    0.00426784f, -0.06463040f, 0.12479431f, 0.04639405f, 0.01325446f, -0.00747627f, 0.01364837f, 0.05745187f, 
    -0.01729911f, 0.00739533f, 0.07811520f, 0.05442790f, -0.10574417f, -0.27420932f, -0.14851753f, 0.17889537f, 
    -0.06225896f, -0.11983585f, 0.01409383f, -0.03110143f, -0.00390644f, -0.14646538f, 0.05029980f, -0.00114306f, 
    -0.09108911f, 0.07335845f, -0.05513031f, 0.09624868f, 0.03897862f, -0.03401720f, -0.04458913f, -0.16028415f, 
    -0.34765345f, 0.24530962f, -0.04897457f, 0.11717574f, 0.10040378f, 0.08691052f, -0.08697313f, 0.05508134f, 
    -0.09809292f, 0.02396878f, 0.01509659f, -0.03373478f, 0.13249616f, 0.00396860f, -0.00491535f, -0.05607442f, 
    0.09899794f, -0.12049615f, -0.18778449f, -0.15816584f, 0.32888877f, -0.14892335f, -0.27597824f, -0.23049040f, 
    -0.36720529f, -0.01417594f, -0.08045735f, 0.07774996f, 0.06803294f, 0.06204373f, 0.09587859f, -0.07678527f, 
    -0.00126646f, -0.14078557f, -0.09920878f, -0.10458510f, -0.09584296f, -0.03308959f, -0.08235800f, -0.00778460f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08942987f, 0.08792089f, -0.03490248f, -0.03137963f, 0.01920864f, 0.05008315f, -0.04304456f, -0.08284821f, 
    -0.04705203f, -0.00862916f, 0.10816015f, 0.03996403f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
