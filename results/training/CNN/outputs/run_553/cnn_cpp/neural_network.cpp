#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.27230620f, -0.33550999f, 0.00024620f, -0.32761392f, 0.84070456f, -0.61817509f, -0.08817920f, -0.01024829f, 
    -0.35823137f, -0.65906906f, 0.16225745f, 0.33503193f, 0.31932557f, 0.41254479f, -0.21204673f, 0.56851494f, 
    0.27760613f, -0.16634218f, 0.65356916f, 0.62680745f, 0.61164588f, 0.12644124f, 0.09630762f, -0.06478067f, 
    0.22930363f, 0.01454671f, 0.17674623f, -0.71304941f, -0.43515164f, -0.51265824f, 0.02186464f, 0.70713389f, 
    0.61371505f, 0.13074115f, -0.31318182f, -0.20390943f, -0.04937438f, -0.70361990f, 0.67701048f, 0.37043682f, 
    0.00301574f, 0.61182809f, -0.05164036f, -0.29069084f, 0.38601127f, 0.54136771f, 0.43779022f, 0.33635521f, 
    -0.46027192f, 0.51673424f, -0.30404094f, -0.35913560f, 0.13244458f, 0.22217789f, -0.85426784f, -0.69550204f, 
    -0.47667664f, 0.11944769f, -0.39745581f, 0.13133441f, 0.13301331f, -0.01720605f, 0.08029741f, 0.62077326f, 
    0.27298412f, 0.54613703f, 0.47826439f, 0.33110043f, 0.48929566f, -0.38554385f, -0.07162138f, -0.30578032f, 
    -0.53620303f, -0.07433868f, -0.66229606f, 0.38271677f, 0.34461868f, -0.52308583f, -0.20803361f, 0.34340429f, 
    0.28202260f, 0.70806581f, -0.55948502f, -0.52472651f, -0.63496369f, 0.18152218f, 0.52303374f, 0.17044050f, 
    0.07066859f, 0.33231395f, -0.13108027f, -0.89850581f, -0.10702834f, -0.83038867f, 0.00123226f, -0.07171879f, 
    -0.18588500f, -0.04537851f, -0.02953649f, -0.33764148f, 0.74027419f, -0.34632844f, 0.72764450f, -0.23614511f, 
    -0.55405599f, 0.00230428f, 0.24751101f, -0.09449247f, 0.08973574f, 0.08608784f, 0.40479460f, -0.25456396f, 
    0.22998835f, -0.44958326f, 0.35532114f, 0.66988713f, -0.21394350f, -0.25315976f, 0.36686346f, 0.81398535f, 
    0.45813367f, -0.02026034f, -0.60403824f, -0.31940556f, -0.10931800f, -0.03618941f, 0.60559267f, -0.82234383f, 
    -0.26857612f, -0.32653478f, -0.56466621f, -0.31661862f, -0.15783778f, -0.02665221f, 0.39698204f, -0.04003056f, 
    0.34918910f, -0.05633946f, -0.55986238f, -0.49054340f, -0.87877160f, -0.17336851f, -0.30605686f, 0.10887150f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.09997442f, -0.12302953f, 0.40317440f, -0.08013661f, 0.05559628f, 0.28626528f, 0.38522634f, -0.14398277f, 
    0.20148778f, -0.38165721f, 0.05021077f, -0.48407400f, -0.27752790f, -0.08453235f, -0.01278247f, 0.51245767f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.29577804f, -0.05603814f, 0.08934610f, 0.00636918f, -0.09073731f, -0.04598833f, -0.03946568f, -0.00520240f, 
    -0.08909862f, -0.03664301f, 0.26564029f, -0.28985170f, 0.12180798f, 0.00959934f, 0.04498012f, 0.10790443f, 
    0.00252551f, -0.04846428f, -0.41327783f, -0.37464854f, 0.07652999f, 0.00167453f, 0.06159368f, 0.04814846f, 
    0.02543387f, 0.17030388f, 0.09983345f, -0.08105332f, -0.08005993f, 0.17776884f, -0.04379768f, -0.03860820f, 
    0.04513087f, -0.01936003f, -0.09009014f, 0.29511231f, 0.64236301f, -0.10532966f, -0.11096800f, 0.00095935f, 
    0.00800119f, 0.12182296f, -0.04222862f, 0.12505877f, -0.01431521f, -0.28111404f, 0.10509649f, -0.10510220f, 
    -0.01212853f, 0.33145571f, -0.07060907f, 0.24280600f, 0.15224832f, -0.15038091f, 0.10796965f, 0.03584732f, 
    0.00566586f, -0.11610592f, -0.02707805f, -0.01134154f, -0.09668797f, 0.05222633f, 0.04451123f, -0.13360719f, 
    0.09902547f, -0.00093980f, 0.01267679f, 0.05458480f, 0.12933767f, 0.22094080f, 0.16065405f, -0.02721163f, 
    -0.25633377f, 0.01174090f, 0.26966020f, 0.02152549f, 0.10071310f, 0.09963224f, -0.13000984f, 0.18761897f, 
    -0.11078358f, -0.08879802f, -0.07811742f, -0.39055049f, -0.13967091f, -0.12316591f, -0.04823942f, 0.02352201f, 
    0.20216197f, -0.15713932f, -0.43872350f, 0.02076487f, 0.05424779f, -0.09629203f, -0.07823998f, 0.15977156f, 
    0.16003191f, 0.03711970f, 0.04523025f, 0.60608625f, -0.07847307f, -0.20754336f, 0.02211595f, -0.23891391f, 
    0.03529308f, -0.09836597f, -0.07512987f, -0.05819079f, -0.35961121f, 0.39303103f, -0.06661546f, -0.09650119f, 
    -0.26786804f, -0.17266719f, -0.18078183f, 0.02572408f, -0.02043058f, 0.08039153f, -0.00093014f, -0.22884052f, 
    -0.02017219f, 0.05198652f, -0.13123704f, 0.27413651f, -0.20227951f, 0.17011936f, 0.21078224f, 0.23160625f, 
    -0.05660253f, -0.12025226f, -0.11677665f, -0.03654187f, 0.08778758f, 0.02932149f, 0.06416618f, 0.17407283f, 
    0.30753446f, -0.01222500f, 0.20650585f, 0.04322372f, -0.04974377f, 0.01731649f, -0.04339679f, 0.12521258f, 
    -0.10021777f, 0.06237428f, -0.06164078f, -0.01677992f, -0.04444480f, 0.00519226f, -0.03531624f, 0.00722115f, 
    0.05727030f, -0.05418946f, -0.06507516f, -0.01268672f, -0.02594724f, 0.00576994f, -0.05132959f, 0.05233365f, 
    0.06588520f, -0.00686776f, 0.06683803f, -0.06465069f, -0.01193792f, -0.08662784f, 0.04093274f, -0.06887628f, 
    0.06971008f, 0.04500477f, 0.01810863f, 0.00831333f, 0.05572156f, -0.06758589f, 0.06088242f, -0.08021793f, 
    -0.00167357f, -0.03228555f, -0.01330416f, -0.03163179f, -0.03285018f, -0.05437357f, 0.07080117f, -0.00314434f, 
    -0.03429382f, 0.02333378f, -0.02520543f, 0.02444490f, -0.08028349f, 0.03596570f, 0.03766532f, -0.01942204f, 
    -0.02893494f, 0.01881205f, -0.08224767f, 0.05028562f, 0.02297410f, 0.02232642f, -0.06306496f, -0.06915597f, 
    0.00061761f, 0.03618705f, -0.03428086f, -0.02570036f, 0.05679828f, 0.00114276f, -0.07202473f, 0.02925882f, 
    -0.00998192f, 0.01614500f, 0.07321208f, -0.08484236f, 0.02018942f, -0.02517799f, 0.01726531f, -0.00718677f, 
    -0.05422662f, -0.07051791f, 0.02337718f, -0.02123578f, -0.05893784f, -0.05987179f, -0.05422742f, -0.05724122f, 
    0.05493997f, -0.06001103f, -0.08955567f, -0.04477413f, -0.08487695f, -0.08287361f, 0.01050424f, 0.03691567f, 
    -0.05926874f, -0.04589106f, 0.01790473f, 0.06822052f, -0.01888799f, -0.06292060f, 0.04231708f, -0.08350091f, 
    0.02463560f, -0.01840292f, 0.04329677f, -0.01270012f, -0.02689253f, 0.05393325f, -0.07864770f, -0.01819934f, 
    -0.05537567f, -0.02580419f, 0.05247110f, 0.02077026f, -0.01737414f, 0.02182369f, -0.01018495f, -0.04750474f, 
    -0.04968901f, -0.06888380f, 0.03001533f, -0.02116731f, -0.08058312f, -0.05174173f, 0.01267971f, 0.04045221f, 
    -0.04045835f, -0.02453270f, -0.07243055f, -0.08577044f, 0.01490215f, -0.07551811f, 0.06315635f, -0.02467209f, 
    0.05994535f, 0.01142927f, 0.03223645f, 0.03952877f, 0.04690474f, 0.05686788f, -0.08911493f, -0.05127315f, 
    0.01360342f, 0.05709359f, -0.03448571f, -0.02735248f, 0.06876783f, -0.05012129f, -0.07498374f, -0.04437216f, 
    0.03049953f, -0.03450377f, 0.00345979f, -0.06189200f, -0.03226949f, -0.02514999f, 0.04330639f, -0.01536547f, 
    -0.14075279f, 0.03568816f, 0.07879591f, 0.04916768f, -0.09551004f, -0.07402240f, 0.02005590f, -0.05503063f, 
    0.14123534f, -0.02030774f, -0.11709250f, 0.04346589f, 0.04331037f, -0.06061795f, 0.01857638f, 0.01031401f, 
    0.02534762f, -0.01102026f, 0.02370410f, -0.00627208f, 0.00973284f, 0.03463296f, -0.04853598f, -0.01119377f, 
    0.04857889f, 0.10220753f, -0.06751743f, -0.03891090f, -0.01027650f, -0.06665745f, 0.09826617f, -0.03576627f, 
    -0.11795583f, 0.06540994f, -0.00617465f, -0.03755914f, 0.08926355f, -0.09799354f, -0.14102788f, 0.09142103f, 
    -0.02698351f, 0.05382286f, -0.03658142f, 0.01809621f, 0.05788252f, -0.06872054f, 0.05824911f, -0.08694790f, 
    -0.14609414f, 0.05941156f, 0.05699037f, 0.11819162f, 0.04384645f, -0.09457634f, -0.03379889f, -0.05923251f, 
    -0.06923176f, -0.01008695f, -0.01977282f, -0.05121559f, -0.10334983f, 0.08112281f, -0.00823053f, -0.00063943f, 
    -0.00763852f, -0.07324027f, -0.05178971f, -0.11036810f, 0.12593590f, 0.11549598f, 0.07656306f, -0.06453837f, 
    0.01781291f, 0.04487446f, -0.13758582f, -0.03906523f, 0.04910213f, 0.10060781f, -0.13100320f, 0.05412783f, 
    0.02832177f, 0.05912148f, -0.05902636f, -0.11174501f, -0.07152500f, -0.04342345f, 0.03960631f, -0.07478745f, 
    -0.02472732f, -0.12307556f, -0.02942569f, -0.01892822f, -0.12449072f, -0.09423862f, 0.08548963f, -0.07258707f, 
    0.00919371f, -0.08779740f, -0.00508320f, 0.14791495f, 0.03929442f, -0.03970138f, 0.00772575f, -0.01460939f, 
    0.10023566f, -0.02641621f, 0.11153293f, -0.07792444f, -0.01896705f, -0.07567182f, 0.06354774f, 0.14685191f, 
    0.05081267f, 0.04938092f, -0.01749739f, -0.09506151f, -0.13593753f, -0.08528952f, -0.10785348f, -0.07087073f, 
    -0.05457454f, 0.07867335f, 0.01530543f, 0.00656664f, -0.02485063f, -0.14500539f, -0.04433387f, -0.04492645f, 
    0.00062074f, -0.02940452f, 0.03823560f, 0.11372375f, 0.03853869f, -0.14957999f, -0.19316849f, -0.15826549f, 
    0.10222487f, 0.35113582f, 0.19302385f, -0.02235140f, -0.03584518f, -0.06364404f, 0.03848899f, 0.05498766f, 
    0.04567342f, 0.28073981f, -0.10356142f, 0.02935464f, -0.10735732f, -0.08253744f, -0.09283190f, -0.06882597f, 
    0.18321352f, -0.07101401f, -0.01574414f, 0.11859965f, 0.20177802f, -0.12645425f, 0.04358814f, 0.06521340f, 
    -0.03019003f, -0.02806336f, -0.27637869f, 0.10202102f, -0.00760412f, 0.28542346f, 0.07467506f, 0.13579004f, 
    0.02363294f, -0.01022513f, 0.00974771f, -0.00688903f, -0.23760468f, -0.30295369f, -0.25168157f, 0.00682040f, 
    -0.05110943f, 0.01296975f, -0.01402657f, -0.10564055f, 0.00911678f, 0.10026022f, 0.10133046f, -0.18661088f, 
    -0.00507759f, 0.00586125f, -0.09599631f, -0.06866945f, -0.05268091f, -0.07215450f, 0.08563662f, -0.02582826f, 
    0.12742081f, 0.00679310f, 0.08763330f, -0.12365017f, 0.02552715f, -0.11816924f, -0.05377270f, -0.43513641f, 
    -0.17161401f, -0.05787794f, 0.07528021f, -0.01595597f, 0.09976108f, -0.20424679f, -0.05386350f, -0.09312231f, 
    -0.15545370f, 0.09193869f, 0.09416426f, 0.12489872f, 0.06239756f, -0.04954748f, 0.04145065f, 0.18298399f, 
    0.04927955f, 0.11183234f, -0.09599906f, -0.11808532f, -0.24490915f, 0.14532407f, -0.12845069f, -0.08984264f, 
    0.14892690f, 0.05509428f, 0.22011483f, -0.08685911f, 0.22771487f, 0.02080015f, -0.11696542f, 0.00004367f, 
    -0.01123761f, -0.10371894f, 0.15109904f, 0.40696844f, 0.19653898f, 0.08225820f, 0.02794940f, -0.10117128f, 
    -0.12209713f, -0.21239118f, 0.01209874f, 0.07239467f, 0.06370369f, -0.00328958f, 0.15623902f, 0.14528330f, 
    0.07722154f, 0.05674349f, -0.02173478f, -0.18894680f, 0.17020464f, 0.25217110f, -0.33998692f, 0.18158972f, 
    0.09480714f, 0.06957737f, 0.03883319f, -0.15306795f, 0.09708886f, -0.10302754f, 0.24795130f, 0.13496983f, 
    -0.01353959f, -0.28705904f, -0.19103372f, -0.24602164f, 0.05877123f, 0.26956946f, -0.13990942f, -0.03368152f, 
    0.02160355f, -0.13364144f, 0.20204437f, 0.04033158f, -0.20618467f, 0.00554487f, 0.07827127f, 0.13085890f, 
    -0.22488165f, -0.08991811f, 0.07922766f, 0.06735493f, -0.00414197f, 0.10232079f, 0.16859092f, -0.20738460f, 
    -0.15710287f, -0.14478591f, -0.03059219f, 0.15186223f, -0.00868567f, 0.11702846f, 0.03041572f, 0.06090328f, 
    0.01579267f, 0.16431060f, -0.02221727f, 0.12021864f, 0.09245888f, 0.21670818f, -0.00469885f, -0.09184102f, 
    -0.12051217f, 0.03092392f, 0.26489010f, -0.29902914f, -0.12046608f, -0.14844126f, -0.03013903f, -0.23381652f, 
    -0.15159589f, 0.16412391f, -0.04477597f, -0.11268575f, 0.49425691f, 0.04824741f, 0.01976791f, -0.01275051f, 
    -0.09686943f, -0.13629122f, 0.12557483f, 0.08839002f, 0.04528615f, -0.17275706f, -0.10565312f, -0.04240298f, 
    0.12422761f, 0.10775172f, -0.02971654f, 0.07036111f, 0.14062975f, 0.09571213f, -0.33690086f, -0.02098126f, 
    0.28614378f, 0.10253516f, 0.07072473f, -0.03800657f, 0.02738775f, 0.13432570f, -0.05869124f, 0.00481396f, 
    -0.07528987f, 0.13070096f, 0.02741035f, -0.22216126f, -0.26405615f, 0.06719311f, 0.03216718f, 0.16297929f, 
    -0.01530047f, -0.07461604f, -0.04173544f, 0.08898120f, -0.02701845f, 0.21431494f, -0.07147098f, -0.03425238f, 
    0.06462763f, -0.14968267f, -0.19074824f, 0.01188478f, -0.01739396f, 0.02667859f, 0.05811446f, -0.00761316f, 
    0.08732345f, 0.12663212f, -0.35032868f, 0.27908474f, -0.23035243f, 0.03351499f, 0.04931949f, -0.10037383f, 
    -0.15979700f, -0.12004447f, -0.13528161f, -0.11074372f, -0.24538973f, -0.27730635f, 0.28404349f, 0.05669850f, 
    0.04185307f, -0.05718708f, -0.08026238f, -0.08491640f, -0.08101408f, 0.02671421f, 0.03801056f, -0.00889743f, 
    0.03451251f, -0.04768063f, -0.09900434f, 0.18605143f, 0.11254439f, -0.23448426f, -0.16672504f, 0.18061996f, 
    0.20852765f, 0.12919542f, -0.01845786f, 0.01271896f, 0.26004124f, 0.02370758f, -0.29501176f, 0.08100853f, 
    0.07415099f, 0.11774974f, 0.01233632f, -0.01341364f, 0.11211773f, -0.00669594f, -0.29554868f, 0.09102332f, 
    -0.10082709f, 0.06734413f, 0.03980166f, 0.06175312f, 0.18398114f, 0.06386945f, 0.03099385f, -0.05014295f, 
    -0.06744211f, -0.39523998f, -0.30156645f, 0.04578737f, 0.08896078f, 0.01034007f, -0.21987548f, -0.04285531f, 
    0.01105250f, -0.16877906f, -0.42315435f, 0.20615113f, -0.16298905f, 0.06564715f, -0.15268102f, -0.04635869f, 
    -0.06730380f, -0.09308172f, 0.46148804f, 0.22403720f, 0.14375870f, -0.03140320f, -0.18352900f, -0.08296717f, 
    0.07644840f, 0.04186441f, -0.18161231f, -0.09983640f, -0.21420933f, -0.15364574f, -0.02033381f, 0.03705380f, 
    0.16963761f, -0.10761226f, -0.07256737f, -0.20606484f, 0.06565670f, -0.00129019f, 0.18638091f, 0.13642132f, 
    0.10398059f, 0.04963382f, 0.01293064f, 0.05202862f, -0.07288412f, 0.20937298f, 0.22260047f, 0.14263660f, 
    -0.17517035f, -0.08185415f, -0.04300070f, -0.15252222f, 0.26291189f, 0.02381143f, 0.13411784f, 0.28784746f, 
    -0.05047167f, -0.13141558f, -0.10295688f, -0.01076909f, -0.03577857f, -0.06839482f, 0.13711965f, 0.26571646f, 
    0.01209463f, 0.03058475f, -0.02877692f, -0.08498550f, -0.06631618f, -0.00209036f, 0.11238381f, 0.02583664f, 
    -0.13335134f, -0.04067781f, -0.11571290f, 0.16348366f, 0.16606599f, 0.08165880f, 0.07030910f, -0.04263311f, 
    0.00192088f, 0.09314281f, -0.16890050f, -0.15262659f, 0.00957959f, 0.02132437f, -0.01419205f, -0.23866834f, 
    0.01197208f, 0.10499681f, -0.02734813f, 0.39410615f, -0.03245283f, -0.20913021f, 0.10938075f, 0.14691944f, 
    -0.10220824f, 0.01034701f, -0.25796473f, -0.15585576f, -0.08607219f, -0.10971171f, 0.02966503f, -0.10714652f, 
    -0.01798964f, -0.16279523f, 0.22846650f, 0.04023764f, 0.04384470f, 0.16491407f, -0.22134978f, 0.12317123f, 
    -0.14502113f, 0.22508766f, -0.14863335f, 0.09565166f, 0.01218214f, 0.16659752f, 0.27283326f, 0.23931588f, 
    -0.15992723f, -0.10308281f, 0.01951867f, 0.09804838f, 0.09863391f, 0.00426670f, -0.04401711f, -0.03650678f, 
    -0.14860955f, 0.33823112f, 0.04989253f, 0.04858984f, 0.00621667f, -0.16383718f, -0.15335876f, -0.09807814f, 
    0.08914837f, -0.12625866f, 0.10718218f, 0.10207041f, 0.00620362f, 0.10880799f, 0.10835545f, -0.05107629f, 
    0.06950735f, 0.01405690f, 0.01026918f, -0.09345907f, -0.03727126f, -0.00237644f, 0.01669923f, -0.08013841f, 
    -0.07752042f, 0.02531985f, 0.03093416f, 0.00615729f, 0.01743157f, -0.00105583f, 0.04911380f, -0.07220672f, 
    0.00320323f, 0.03324431f, 0.03395918f, -0.00108576f, 0.01022966f, -0.03143022f, -0.02594671f, 0.04364640f, 
    -0.00518780f, -0.02263816f, 0.04489712f, -0.04654102f, 0.06370722f, -0.03724631f, -0.07427195f, -0.02652011f, 
    -0.00417552f, -0.04247859f, 0.01948700f, -0.09354848f, -0.10089435f, -0.04081094f, -0.08666673f, 0.05603092f, 
    0.03843143f, -0.05361817f, -0.01336112f, -0.02178266f, 0.04468848f, -0.05712416f, -0.07984389f, 0.06059506f, 
    -0.08488704f, -0.08319282f, -0.05895314f, 0.05533335f, 0.02615475f, -0.08396590f, -0.02863816f, -0.06329304f, 
    -0.05228815f, 0.02464442f, -0.07146243f, -0.02532799f, 0.06389088f, -0.09516116f, -0.03580862f, 0.04304137f, 
    0.06007700f, 0.02235490f, -0.03364736f, -0.08816495f, 0.06524304f, -0.06069467f, 0.03813779f, 0.06622719f, 
    0.01122249f, -0.08125205f, 0.04606223f, -0.01103082f, 0.01911592f, -0.08759186f, 0.05354096f, 0.02797068f, 
    -0.00989982f, -0.04082343f, -0.03009272f, -0.03556459f, -0.00373007f, -0.02412822f, 0.04825184f, -0.07291109f, 
    0.00218737f, -0.06833592f, -0.04490295f, -0.00854530f, -0.03947641f, 0.01430415f, -0.00464031f, -0.02961242f, 
    -0.06472450f, -0.04677105f, 0.04969773f, -0.04024092f, 0.04509307f, 0.02532668f, 0.05385786f, -0.06238491f, 
    -0.02711590f, -0.00699568f, -0.05163750f, 0.04589268f, -0.07896847f, -0.07341687f, 0.06661155f, 0.01814581f, 
    -0.08409860f, -0.05086769f, -0.06780101f, -0.08532303f, 0.03177635f, -0.02522963f, 0.02340793f, 0.05188800f, 
    -0.04172267f, 0.01653474f, -0.06471008f, 0.03493625f, 0.01236802f, -0.01854060f, -0.04525775f, -0.07789960f, 
    -0.01296731f, -0.01734185f, -0.03568957f, 0.04336285f, 0.00517558f, -0.09088363f, 0.05516051f, -0.02797691f, 
    -0.04159039f, -0.04957357f, -0.00667158f, -0.09226376f, 0.04789017f, -0.00194504f, -0.03574577f, 0.04168840f, 
    0.17043938f, 0.13114639f, 0.21540932f, 0.18551494f, -0.20384185f, 0.04513428f, -0.10638072f, 0.08932056f, 
    0.12734428f, 0.19916095f, 0.13123003f, -0.14036253f, 0.05806189f, -0.00699479f, -0.01249549f, 0.01338095f, 
    -0.14249405f, -0.10531361f, -0.33146816f, 0.00245586f, -0.04444212f, -0.00777667f, 0.11585617f, 0.14591792f, 
    -0.03396212f, 0.04840717f, -0.15349551f, 0.11046060f, -0.02724574f, -0.05590180f, -0.23424987f, 0.11115959f, 
    0.00568361f, 0.13927530f, -0.02428643f, 0.16803342f, 0.05689313f, -0.03777248f, -0.06489249f, -0.02668076f, 
    0.04597537f, -0.03306288f, -0.03540813f, 0.05381364f, -0.28861511f, -0.20314220f, 0.10335092f, -0.17430042f, 
    0.02058754f, -0.09257412f, 0.05327482f, 0.16206415f, -0.12312019f, -0.01775146f, 0.18142043f, -0.17796195f, 
    0.02815505f, 0.03172057f, 0.06529459f, -0.03828433f, 0.03287641f, -0.25340161f, 0.07903081f, -0.21780480f, 
    0.13870358f, -0.03070736f, 0.02258057f, 0.04761431f, 0.46308631f, 0.10517197f, -0.09588359f, -0.39247251f, 
    0.15498486f, -0.16051000f, 0.14926665f, 0.05454951f, -0.26217997f, -0.00989207f, 0.07284002f, -0.22901732f, 
    0.00232507f, -0.07843908f, 0.04508609f, -0.03210686f, -0.06511040f, 0.14983018f, -0.03767802f, -0.05366207f, 
    -0.07710460f, -0.23416504f, 0.02350257f, -0.16278018f, -0.02889774f, -0.02057941f, 0.15635538f, 0.06160574f, 
    0.00711062f, 0.07827374f, 0.01172152f, 0.24896726f, -0.13801385f, 0.13720770f, -0.19635312f, -0.12777273f, 
    0.07266868f, -0.03284274f, 0.06841362f, 0.02765381f, 0.22870901f, 0.02990646f, 0.00980770f, 0.01333822f, 
    0.08396622f, -0.04966913f, -0.09955797f, 0.07099303f, 0.22930785f, -0.06282289f, -0.05793399f, 0.16057442f, 
    0.05055314f, -0.06468568f, 0.20020708f, 0.11238451f, -0.05405810f, -0.15663378f, 0.23479019f, -0.15609980f, 
    0.11960932f, 0.04334676f, 0.17071904f, 0.04708309f, 0.05469842f, -0.00162991f, -0.00162968f, 0.15392222f, 
    -0.03177174f, 0.08369708f, 0.18786496f, 0.03509107f, -0.17934440f, 0.02095645f, 0.03647295f, 0.09806690f, 
    -0.43978447f, 0.03297500f, -0.00536364f, -0.12563135f, -0.08289183f, 0.18672362f, -0.30169261f, -0.22179638f, 
    -0.07680934f, 0.15779364f, -0.17340404f, -0.12378374f, -0.06061621f, -0.05942461f, 0.10218273f, -0.28925380f, 
    0.09976541f, 0.17348915f, 0.53839457f, 0.32133272f, -0.13559407f, -0.13086687f, 0.12385756f, 0.16151884f, 
    0.08811102f, 0.34996775f, 0.00455640f, -0.32197914f, 0.09829498f, 0.16519755f, -0.10292816f, 0.00232218f, 
    -0.00361947f, -0.09407426f, 0.11984260f, -0.08206070f, -0.34539208f, -0.19250496f, 0.08040188f, 0.04934578f, 
    -0.04857898f, 0.01861436f, 0.00276260f, -0.01544911f, -0.00764646f, 0.17785123f, 0.00698549f, 0.18426171f, 
    0.05033434f, 0.06070927f, 0.16823532f, 0.16355903f, -0.03995607f, -0.13673005f, 0.05900269f, -0.01921011f, 
    -0.19445479f, -0.02622060f, -0.00437668f, 0.07411800f, -0.07456057f, 0.11754220f, 0.13633759f, -0.58387119f, 
    -0.02045024f, -0.13056852f, 0.23888545f, 0.05216797f, 0.21038668f, -0.07179230f, 0.02165500f, 0.05256053f, 
    0.15525998f, 0.03693935f, -0.34550023f, -0.19259799f, 0.13537067f, 0.00291436f, 0.20868531f, -0.04490066f, 
    -0.21569623f, -0.36281297f, -0.02424289f, -0.00768020f, 0.03443382f, 0.09140580f, -0.13096184f, 0.16046211f, 
    0.10724221f, 0.05525464f, -0.06705891f, 0.14193617f, 0.02531711f, 0.15302874f, 0.02257668f, -0.06631097f, 
    -0.03122135f, -0.13439322f, 0.00383569f, 0.18160677f, -0.51830918f, 0.07893791f, -0.04396437f, -0.07658206f, 
    0.05708211f, 0.11902115f, 0.01768074f, -0.14843617f, 0.61472797f, -0.07831091f, -0.14903456f, -0.07278697f, 
    -0.04392158f, -0.06507186f, 0.06271575f, -0.13883184f, 0.00855108f, 0.31149945f, -0.17369232f, 0.03052245f, 
    0.02315838f, 0.04738197f, -0.15829659f, -0.02968582f, 0.17170158f, 0.12798309f, 0.31559485f, 0.17248838f, 
    -0.02718967f, 0.07955564f, -0.34896725f, -0.05754573f, -0.09744353f, 0.21571989f, -0.05227321f, 0.27284637f, 
    -0.02918272f, -0.38813421f, -0.02675022f, 0.02476039f, -0.05313335f, 0.08389162f, -0.01484784f, 0.02871436f, 
    -0.23497827f, -0.21110097f, -0.36304197f, -0.01726467f, 0.23197223f, 0.21166876f, -0.00704388f, -0.15855895f, 
    -0.10213102f, -0.51643527f, -0.42760101f, 0.03326216f, 0.20544066f, 0.15184470f, -0.39682770f, 0.09934548f, 
    -0.03472105f, -0.07950050f, 0.19422172f, 0.15446034f, 0.33626303f, 0.05859630f, 0.09349483f, -0.20196907f, 
    0.07413322f, -0.00728884f, -0.09149283f, -0.03245049f, -0.40386641f, -0.20704220f, 0.12649666f, 0.14726211f, 
    0.09167238f, -0.10244592f, -0.17602208f, 0.00508017f, -0.08705144f, -0.15560260f, -0.06086204f, 0.03581843f, 
    0.01556251f, 0.10840237f, 0.02513009f, 0.07131378f, 0.04241114f, 0.19263217f, 0.30903083f, 0.12923670f, 
    -0.04163328f, -0.13429675f, 0.10880181f, 0.13385426f, 0.05277077f, -0.03615445f, -0.52036506f, -0.25889984f, 
    -0.38825530f, -0.01991613f, 0.14107409f, -0.15954138f, 0.15353641f, 0.02441492f, -0.14705123f, -0.01294330f, 
    0.06793227f, 0.20806453f, 0.12922245f, 0.02546648f, 0.27258050f, 0.03429244f, 0.04571018f, -0.15408590f, 
    -0.37631348f, 0.08506666f, 0.27332968f, 0.00519341f, 0.08299126f, -0.00787226f, 0.10165947f, -0.03306542f, 
    -0.10935917f, -0.06555309f, -0.36727133f, -0.13862361f, -0.06619262f, -0.20365956f, -0.05013037f, 0.04764863f, 
    -0.21322468f, -0.02014681f, 0.23343343f, 0.25841129f, -0.06851736f, -0.01710373f, 0.02853299f, -0.14087926f, 
    0.03942482f, 0.11180506f, -0.08828413f, -0.36552730f, -0.08139177f, 0.14466089f, -0.02179772f, 0.11692379f, 
    -0.20103543f, 0.03030821f, -0.00157124f, 0.05517642f, -0.08618838f, 0.09895167f, -0.18858364f, -0.00122879f, 
    -0.16782215f, -0.05913284f, -0.09903491f, -0.10136917f, 0.00136416f, 0.06280667f, 0.10564885f, -0.10998312f, 
    -0.04478422f, -0.10784373f, -0.07400854f, 0.17777306f, 0.03965491f, 0.05908019f, -0.04383057f, 0.02437483f, 
    -0.20996507f, -0.20183629f, -0.07605164f, -0.05577108f, -0.06389886f, 0.02439787f, 0.23015548f, 0.30779788f, 
    0.23990105f, 0.10355836f, 0.15127924f, 0.17947295f, -0.06138808f, 0.07614028f, 0.19880879f, 0.26936963f, 
    -0.22142562f, -0.07884256f, -0.14816964f, -0.03101654f, 0.04988546f, 0.17272224f, 0.16791619f, -0.08655427f, 
    0.20597759f, -0.21137960f, -0.16454425f, 0.08860258f, -0.09774827f, 0.00244379f, 0.05825366f, -0.11840270f, 
    -0.09782211f, 0.02218633f, 0.05355956f, 0.13234511f, -0.06718309f, 0.30591044f, 0.16054653f, -0.26232418f, 
    0.06724741f, -0.04200638f, 0.01710787f, -0.25676867f, -0.33789340f, 0.41341430f, -0.13461629f, -0.00857458f, 
    0.09974494f, -0.13638455f, 0.18417737f, -0.07742300f, 0.31441525f, 0.15758027f, -0.01575200f, -0.08359791f, 
    -0.06511909f, -0.01578926f, 0.02902330f, 0.03210795f, 0.03564368f, 0.09291935f, 0.00172365f, -0.12585884f, 
    0.12838715f, -0.08288028f, 0.13843842f, -0.02371270f, -0.07196287f, -0.01303496f, -0.04663459f, -0.13389374f, 
    0.56474078f, 0.00760225f, 0.08691987f, -0.07838769f, -0.14016198f, 0.07558380f, 0.03726007f, 0.18873443f, 
    0.01942751f, 0.00114627f, 0.17483531f, 0.32032081f, -0.13094020f, -0.05104057f, 0.01891517f, -0.02633559f, 
    -0.24054947f, -0.18644989f, 0.08877824f, 0.08952394f, 0.06958063f, 0.14930807f, 0.05451198f, -0.17315115f, 
    -0.00459713f, 0.22621907f, 0.05721851f, 0.19372803f, -0.11086783f, -0.01569288f, 0.01763796f, 0.04319383f, 
    0.05746817f, -0.10375085f, -0.17207104f, 0.11574768f, -0.01835161f, 0.12284578f, -0.01562804f, 0.06348563f, 
    0.07868915f, -0.09783188f, 0.13971485f, 0.09973480f, -0.15159014f, -0.59599030f, -0.04968398f, -0.02118394f, 
    -0.16751246f, 0.05040700f, -0.05019733f, -0.18885864f, 0.30003947f, 0.01293080f, -0.43562311f, -0.05689694f, 
    -0.03476872f, -0.15160477f, -0.15334046f, 0.09257825f, -0.19451112f, 0.13393986f, -0.23473583f, -0.30384174f, 
    -0.04228402f, -0.15611090f, -0.15522705f, -0.04439324f, -0.06492353f, 0.12421338f, 0.17509198f, 0.05697652f, 
    0.03628663f, 0.12153859f, -0.06585048f, -0.07488669f, -0.08721189f, -0.12376656f, 0.00830615f, -0.06700451f, 
    0.06386890f, -0.65107894f, 0.15166703f, -0.00362766f, -0.04734106f, 0.00378244f, 0.14497685f, 0.07822435f, 
    0.12291349f, 0.15107532f, -0.19804862f, -0.17634556f, -0.10210840f, -0.19419841f, 0.12607980f, -0.13309461f, 
    -0.08820810f, 0.00629753f, 0.06294613f, -0.13542037f, 0.07136029f, -0.20862344f, -0.08792847f, 0.11161572f, 
    -0.00144238f, 0.03894701f, -0.45623580f, -0.18668997f, 0.02504872f, 0.15989435f, 0.04998456f, 0.07147336f, 
    -0.05072400f, 0.02738163f, -0.02108859f, 0.47758216f, 0.17732258f, 0.29184526f, -0.06761304f, -0.02465490f, 
    -0.24776702f, 0.19362865f, 0.01065251f, -0.01620000f, 0.11106922f, 0.00799280f, -0.00539214f, 0.04251326f, 
    -0.01147869f, 0.00468802f, 0.08514231f, 0.16499729f, 0.17980388f, -0.46377319f, -0.45937461f, -0.00579523f, 
    0.16828476f, 0.11463056f, 0.20443736f, -0.10386431f, 0.00060501f, 0.09981549f, 0.05216793f, 0.23860222f, 
    0.10802437f, -0.03147829f, -0.03763120f, 0.11117116f, -0.09639664f, 0.08557972f, 0.07615981f, -0.32488781f, 
    -0.21157433f, -0.10866521f, 0.14541848f, 0.21430920f, 0.02703595f, -0.12051899f, -0.10314095f, 0.10706002f, 
    -0.06046275f, 0.13425021f, 0.13170697f, -0.08794673f, -0.12794229f, 0.05586509f, -0.11545733f, 0.20430970f, 
    0.08456421f, -0.12020202f, -0.16687627f, -0.05957707f, -0.02620298f, -0.12795317f, -0.03902969f, -0.06154466f, 
    0.15353480f, -0.01265481f, -0.13849388f, 0.10535530f, 0.04533044f, 0.06884935f, 0.07678401f, -0.05383804f, 
    -0.21666133f, -0.07977267f, -0.20266147f, 0.28877270f, -0.12172994f, -0.22276877f, -0.23117752f, -0.21618319f, 
    -0.05326279f, 0.01302749f, 0.14699762f, -0.07127436f, 0.00164578f, -0.02946804f, 0.07915362f, 0.00057697f, 
    -0.11608689f, -0.06133650f, -0.02129183f, 0.01931744f, -0.05735603f, -0.34579435f, 0.06098220f, -0.18640487f, 
    0.08216400f, -0.05021457f, 0.16419651f, -0.31820303f, 0.00744540f, -0.16962618f, 0.25467443f, -0.06302933f, 
    -0.15799186f, -0.00104563f, -0.09987760f, 0.20640133f, 0.16833758f, -0.01065576f, -0.10800277f, 0.08510020f, 
    -0.05415417f, 0.23439153f, 0.05360475f, 0.03877447f, 0.06137499f, -0.10087109f, 0.12045652f, -0.03564119f, 
    0.20483926f, -0.14899632f, -0.49204677f, -0.00908519f, 0.04043461f, 0.04926452f, -0.07899526f, -0.07584580f, 
    -0.13164401f, 0.19830543f, -0.18819498f, -0.03788081f, -0.46704006f, 0.05745272f, 0.04978268f, 0.04514116f, 
    -0.12258670f, 0.02772255f, -0.01196209f, 0.09199957f, 0.01512572f, 0.04342790f, 0.08733459f, 0.05107017f, 
    0.10679330f, 0.08558115f, 0.08956093f, 0.40253130f, 0.01867910f, -0.17634043f, -0.10235658f, -0.01848019f, 
    -0.13113573f, 0.02432256f, 0.03473786f, 0.02418840f, -0.41153148f, 0.35460475f, -0.01222080f, -0.18250941f, 
    0.01155138f, -0.07051442f, 0.01983706f, -0.07879087f, 0.00787938f, 0.16057937f, 0.33720380f, -0.09287748f, 
    0.12119117f, 0.05586250f, 0.14664635f, 0.14705569f, -0.15990591f, 0.03651880f, -0.16725667f, 0.40749589f, 
    0.23517479f, -0.06070098f, -0.31710720f, -0.15487273f, 0.04357402f, -0.03319437f, 0.09748297f, -0.10536894f, 
    0.00604502f, -0.17112941f, 0.07416494f, -0.11104278f, -0.15319559f, -0.09393757f, 0.15232359f, 0.15088077f, 
    0.05489482f, -0.40697753f, 0.08215451f, 0.08418176f, 0.02360366f, 0.10442956f, -0.04285604f, 0.01977632f, 
    0.01574785f, 0.88473392f, -0.20164889f, -0.02507621f, 0.14122216f, -0.16349286f, -0.15363534f, 0.18191901f, 
    -0.12088457f, 0.01751448f, 0.38876206f, -0.45325527f, 0.03511911f, -0.10436572f, 0.31025523f, -0.06392845f, 
    -0.06723170f, -0.18001541f, 0.20967604f, -0.39883053f, -0.47715813f, -0.14164896f, 0.01699312f, 0.16897972f, 
    0.07012124f, -0.03411695f, -0.12315833f, 0.06212126f, 0.15799510f, 0.16659951f, 0.11662968f, -0.02680832f, 
    -0.14074577f, 0.06078061f, -0.03361274f, -0.05875431f, -0.00079864f, 0.36482668f, -0.10256860f, -0.06842899f, 
    -0.21722078f, 0.19428778f, -0.04286946f, 0.06350043f, 0.07382268f, -0.01582984f, -0.19511378f, -0.18763791f, 
    -0.12811732f, 0.14514971f, 0.09072901f, 0.23134798f, 0.04771206f, 0.09205062f, -0.17585315f, -0.20004061f, 
    -0.28622544f, -0.47172746f, 0.23657081f, 0.20167764f, 0.01008330f, -0.02986142f, 0.00775593f, 0.21397232f, 
    -0.08774605f, -0.07669981f, -0.15432736f, 0.14364997f, 0.17946024f, 0.00816443f, 0.12480935f, 0.01496176f, 
    0.04206826f, -0.37819290f, 0.07931104f, -0.04277033f, -0.10325510f, -0.08220434f, -0.20290144f, 0.37205541f, 
    0.07651404f, 0.06694125f, -0.41869032f, -0.29605961f, -0.00148055f, 0.11135235f, -0.04482550f, -0.18644324f, 
    -0.09198073f, 0.17582862f, -0.14114511f, 0.40933013f, 0.08229271f, 0.06901864f, -0.14551729f, 0.14110200f, 
    0.01298286f, -0.19640364f, 0.02992859f, -0.04533785f, 0.21327512f, 0.35130382f, 0.14087202f, -0.04759413f, 
    0.09427824f, 0.13734902f, -0.00410808f, -0.03978772f, -0.21763325f, -0.50836635f, 0.01434017f, 0.09636403f, 
    0.03005740f, 0.09866748f, -0.13328220f, 0.14642225f, -0.00726561f, 0.01949915f, 0.20811667f, 0.37322989f, 
    0.06551341f, -0.00542738f, -0.17315052f, 0.14781158f, -0.13927811f, -0.07039320f, 0.04540376f, 0.12375963f, 
    -0.15920353f, 0.12935995f, -0.11444664f, 0.24330440f, -0.22200450f, -0.14155707f, -0.09849625f, 0.18498431f, 
    0.13947780f, -0.08813081f, 0.04889039f, 0.09995056f, -0.00337522f, 0.24468069f, -0.08989058f, -0.05411690f, 
    0.06323884f, 0.24660808f, -0.16673081f, -0.02690857f, 0.17553768f, -0.10380729f, 0.08173564f, -0.03721561f, 
    -0.13510369f, 0.06726003f, -0.18871163f, -0.31217957f, 0.05106551f, 0.05460422f, 0.05250987f, 0.01166601f, 
    0.09692761f, 0.12948968f, 0.07662104f, -0.13423280f, -0.55416995f, -0.22707419f, 0.13580781f, 0.15354823f, 
    0.01672282f, 0.03232115f, -0.12745373f, 0.01828637f, -0.09780576f, -0.20687197f, -0.19451796f, 0.12569806f, 
    -0.03608324f, -0.11356107f, 0.08783074f, 0.10112600f, 0.07474029f, -0.34184045f, -0.00014813f, -0.14106072f, 
    0.01972791f, -0.04787472f, -0.27138397f, 0.03985680f, -0.04662774f, 0.20832820f, 0.07220471f, -0.06328657f, 
    0.11333405f, -0.08642191f, 0.03336938f, 0.24572074f, -0.00053860f, 0.13217483f, -0.05928197f, 0.23482005f, 
    -0.04679425f, 0.02805079f, 0.38054785f, 0.14344178f, 0.08388072f, 0.02595543f, -0.09759041f, -0.01407383f, 
    -0.02662428f, -0.15188162f, -0.19658175f, 0.08265526f, 0.10092606f, 0.14339878f, 0.00976133f, -0.12613003f, 
    -0.23848651f, -0.00862730f, -0.14788873f, 0.39827424f, -0.04854552f, 0.05361957f, -0.03536630f, 0.01678300f, 
    0.03240857f, 0.08790160f, 0.01152857f, 0.21964325f, 0.09565525f, -0.00132017f, -0.06477883f, 0.14057437f, 
    -0.11679681f, 0.00169075f, -0.05572494f, 0.35804757f, 0.48258269f, -0.37047359f, -0.04251495f, 0.10111081f, 
    0.09382107f, 0.04768634f, 0.05958122f, -0.03019600f, -0.42751077f, 0.13196020f, -0.08320581f, 0.09489637f, 
    -0.02658367f, -0.07589279f, 0.08405744f, 0.07885563f, -0.10482322f, 0.01796048f, 0.12092310f, -0.16275127f, 
    0.01830681f, -0.01479877f, 0.10343867f, -0.00714065f, -0.03927696f, 0.15951885f, -0.43167078f, 0.12001568f, 
    -0.05849551f, 0.10263049f, -0.01920178f, -0.04220336f, 0.04127134f, 0.09425447f, 0.08972745f, 0.18909632f, 
    0.10045218f, -0.07651894f, -0.07543352f, 0.04709991f, 0.02900920f, 0.19330536f, 0.21181493f, 0.04895175f, 
    0.20148054f, -0.19811204f, -0.34723884f, 0.01522709f, 0.09433866f, -0.06375071f, 0.02283666f, -0.13805716f, 
    0.08909803f, -0.30275032f, -0.35983691f, -0.30673093f, -0.03977201f, -0.15828493f, -0.00916151f, -0.11519682f, 
    -0.19241241f, 0.02597564f, -0.27092999f, -0.25130925f, 0.12438489f, 0.05409842f, 0.07015368f, -0.01151301f, 
    -0.02738455f, 0.14787571f, -0.03655030f, 0.37326485f, -0.21813372f, -0.19644292f, 0.10463092f, -0.08630016f, 
    -0.08788648f, -0.14843129f, -0.09046974f, -0.05676534f, -0.35847068f, -0.00930504f, -0.16485015f, -0.04533852f, 
    -0.05191123f, -0.08765607f, 0.15272576f, 0.04786054f, -0.03188349f, -0.12463820f, -0.05149461f, 0.33246148f, 
    -0.08179910f, -0.05883494f, -0.11097468f, 0.11107092f, 0.09934297f, 0.11557692f, -0.09930990f, -0.46415886f, 
    0.23507170f, -0.16875707f, 0.09280007f, 0.05409888f, -0.04899709f, 0.01540732f, -0.02457395f, 0.26089323f, 
    -0.10546786f, -0.07044325f, -0.01836762f, -0.09180263f, 0.03585737f, 0.02545751f, 0.12881568f, 0.12832458f, 
    -0.07929540f, 0.53276706f, 0.38437176f, 0.03936276f, -0.04839493f, 0.12041726f, -0.10187757f, -0.35595840f, 
    0.23035017f, 0.48237589f, 0.22229357f, 0.00688780f, 0.12806231f, 0.01033628f, 0.02316813f, -0.15413186f, 
    -0.18953210f, 0.04991885f, -0.15228502f, 0.24333565f, 0.01430976f, -0.18788104f, -0.25697049f, 0.08692944f, 
    0.03807408f, 0.14856109f, 0.19525930f, 0.32989287f, 0.09332506f, 0.20009093f, 0.23771338f, 0.20197994f, 
    0.07013439f, 0.10082371f, 0.05843826f, 0.01984236f, 0.03698049f, -0.20316999f, -0.12269558f, 0.06027111f, 
    -0.03705530f, -0.11973859f, 0.00098446f, -0.08550423f, 0.07818368f, -0.19249088f, 0.01426087f, 0.07195202f, 
    -0.18814710f, 0.00562955f, -0.09437004f, -0.06370044f, -0.06975083f, 0.06798768f, 0.17608792f, 0.16016094f, 
    0.44021863f, 0.25570950f, 0.00738451f, 0.19134924f, 0.15622866f, 0.07802832f, -0.08210286f, 0.31150255f, 
    -0.13748117f, 0.24050029f, -0.13445614f, 0.08235275f, 0.08552925f, 0.16141805f, -0.03631755f, 0.32467550f, 
    0.24345013f, 0.13066241f, 0.15381522f, 0.11094754f, 0.13066317f, 0.03149970f, 0.10708889f, 0.02091425f, 
    0.06145255f, 0.32574731f, -0.08120130f, -0.10057811f, -0.04962685f, 0.01053814f, -0.17756954f, 0.03724039f, 
    0.10023434f, -0.01011315f, 0.14556459f, 0.09491314f, 0.30970424f, 0.46001184f, -0.12329771f, 0.15528099f, 
    -0.01372688f, -0.02878758f, -0.14964391f, -0.11598950f, -0.19260418f, -0.35475194f, -0.05992576f, -0.03766891f, 
    -0.16395973f, 0.05920126f, 0.13292658f, -0.23439531f, -0.35550451f, -0.19969627f, 0.06136765f, -0.01748360f, 
    -0.23283198f, -0.35967344f, -0.06734283f, -0.07983124f, -0.09838679f, -0.23686028f, 0.30953026f, -0.31308690f, 
    -0.10174102f, -0.00129054f, 0.01801233f, 0.02525939f, 0.17661507f, 0.03169889f, 0.25600892f, 0.21259402f, 
    0.10274924f, -0.12791274f, -0.03680126f, 0.09616437f, -0.25718287f, 0.05786309f, -0.03155738f, -0.28205231f, 
    -0.40567431f, -0.24369906f, -0.16648370f, -0.04930514f, 0.05965444f, 0.00270801f, 0.04490672f, -0.20349199f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.25928819f, 0.03646465f, -0.03471211f, -0.09637919f, 0.13051109f, 0.13051382f, -0.08207578f, 0.07925718f, 
    -0.07445653f, 0.29632947f, -0.00923430f, 0.11018229f, 0.09689119f, 0.14776611f, 0.05108029f, -0.09784772f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.13171449f, -0.06195608f, -0.18267098f, -0.19316047f, 0.03933945f, 0.00703573f, 0.17188737f, 0.03291169f, 
    -0.00737953f, 0.11299378f, -0.19793665f, -0.05090427f, -0.05830723f, -0.02401054f, 0.00670561f, -0.20541972f, 
    -0.26898342f, -0.04732621f, 0.06062087f, 0.12927631f, 0.56858701f, 0.04366912f, -0.12114021f, -0.30408984f, 
    0.05137769f, 0.21700284f, 0.37826911f, 0.05925936f, -0.16193122f, -0.14972694f, 0.11162564f, -0.02151758f, 
    -0.14094089f, -0.12607566f, 0.13119939f, 0.48281878f, -0.09675116f, 0.01199384f, 0.04581914f, 0.19122419f, 
    -0.16135836f, -0.07369573f, -0.04977518f, 0.10200121f, 0.67999321f, 0.05223614f, -0.19603856f, -0.04286529f, 
    0.03051541f, 0.21067211f, 0.13817033f, 0.05019177f, -0.06439382f, -0.21583335f, -0.17002910f, -0.07714738f, 
    0.14748387f, -0.16253132f, 0.03164373f, -0.17503871f, -0.18557218f, -0.10939889f, -0.10359266f, -0.14763168f, 
    -0.22731537f, 0.10466945f, 0.03960085f, -0.26960188f, -0.18715240f, 0.04702920f, -0.15404397f, 0.18047668f, 
    -0.00684499f, -0.08129820f, -0.25719002f, -0.14994000f, -0.24449533f, -0.06835909f, 0.20530924f, 0.04168496f, 
    0.33713612f, 0.06287421f, 0.08698558f, 0.36262938f, -0.24470007f, -0.30279383f, 0.22693530f, 0.45032454f, 
    0.42743075f, -0.01012118f, 0.33833691f, 0.08011235f, -0.11022991f, 0.16471039f, -0.28508645f, -0.02799477f, 
    0.00785897f, 0.23507312f, 0.10726656f, -0.53893542f, 0.14950469f, 0.30708641f, -0.17217010f, 0.28347778f, 
    -0.01741197f, -0.14501652f, -0.09156814f, 0.38356692f, 0.24625441f, 0.17522368f, -0.23533560f, -0.45060390f, 
    0.33370501f, -0.12992306f, 0.16728057f, 0.51650256f, -0.14882442f, -0.33558628f, -0.07246504f, 0.26767334f, 
    0.37082338f, -0.37822008f, 0.28337890f, 0.10817330f, 0.17350750f, -0.18963264f, -0.02752977f, 0.22881863f, 
    -0.15827164f, 0.16194543f, 0.13632263f, 0.25654507f, 0.42451197f, 0.03227265f, -0.18972623f, -0.00753120f, 
    0.39825362f, 0.12130991f, 0.96491587f, 0.33816606f, 0.35659000f, -0.14604855f, -0.61288983f, -0.19614100f, 
    -0.38956141f, -0.18473791f, 0.22645257f, -0.11726008f, -0.25390929f, 0.43565589f, -0.11663889f, -0.09486662f, 
    0.36718270f, -0.18168950f, -0.22485691f, -0.04707496f, 0.54810607f, 0.16893266f, 0.10559666f, 0.24761033f, 
    0.05316817f, -0.00043730f, 0.09967753f, -0.29514000f, 0.51267660f, -0.24279965f, 0.02884023f, -0.28769037f, 
    -0.12989104f, -0.34991321f, -0.03096938f, 0.60523427f, 0.13699135f, 0.50587445f, 0.54660320f, 0.11621963f, 
    -0.15376151f, -0.06613052f, 0.02438509f, -0.05057031f, -0.16168219f, -0.24550340f, 0.24299422f, -0.05701235f, 
    -0.06844917f, 0.07120106f, 0.02211794f, -0.22444585f, -0.22130975f, 0.16320810f, -0.09958473f, -0.21867865f, 
    -0.21637064f, 0.21307510f, 0.28589210f, -0.42762420f, 0.27210468f, 0.12864597f, 0.04964161f, -0.30938759f, 
    0.24982683f, -0.07971473f, 0.01597445f, -0.04606609f, 0.11694121f, 0.25810295f, 0.57226712f, 0.24867186f, 
    -0.19234332f, -0.04887981f, 0.31158167f, -0.40025622f, 0.33119732f, 0.38465226f, 0.03062958f, -0.18486825f, 
    -0.03714703f, -0.12452719f, 0.07119117f, -0.19174515f, 0.38378572f, 0.44764730f, -0.17318076f, 0.11702581f, 
    -0.19343837f, 0.15984894f, 0.14420362f, 0.12786880f, 0.14708592f, 0.07112931f, 0.00529975f, -0.43306670f, 
    -0.20586555f, 0.33645022f, 0.14296156f, -0.01683756f, 0.34613377f, -0.14600402f, 0.00483015f, 0.43648350f, 
    -0.36920881f, -0.14354575f, -0.01751002f, 0.12849927f, -0.23016639f, 0.37218374f, 0.24508201f, 0.02956746f, 
    0.20189184f, 0.31973228f, -0.65983713f, -0.24752524f, 0.35677201f, 0.03277986f, 0.52816170f, -0.07169487f, 
    0.19338897f, -0.23152761f, -0.29775313f, 0.00152727f, -0.06959119f, -0.47064015f, -0.06453248f, -0.18423028f, 
    -0.39423782f, 0.31994322f, -0.51561397f, 0.34876701f, -0.09570688f, 0.16740818f, 0.10052010f, 0.45605153f, 
    0.43050906f, -0.10310166f, 0.06319129f, 0.21733092f, -0.38744581f, -0.39190221f, -0.07619494f, 0.30360800f, 
    0.38072044f, -0.29260296f, -0.15825309f, 0.33361444f, -0.08746742f, 0.30533412f, -0.17422067f, 0.04484237f, 
    -0.05339518f, -0.16925657f, 0.15352723f, 0.16624691f, -0.08806238f, 0.39168963f, 0.01119581f, 0.22932564f, 
    0.02583642f, 0.51636183f, 0.57898813f, -0.59027427f, 0.44537854f, -0.10739362f, -0.28510508f, 0.03336585f, 
    -0.03481262f, -0.17327334f, -0.23003682f, 0.07446402f, 0.08177941f, 0.11960325f, 0.18030536f, -0.22435203f, 
    -0.20248887f, -0.18004376f, -0.11560173f, -0.22404148f, -0.20166151f, -0.11907677f, 0.20056944f, -0.12046897f, 
    -0.01132435f, 0.22943729f, -0.13544476f, 0.33667231f, -0.21611263f, -0.00322923f, -0.16301112f, -0.18157023f, 
    0.64425915f, 0.46087188f, -0.53720593f, -0.03340167f, -0.36287439f, -0.10738643f, -0.20646819f, 0.23248774f, 
    0.01906501f, 0.21363054f, 0.08730093f, 0.14501503f, -0.08956984f, 0.30769193f, 0.13208839f, -0.04374559f, 
    0.23181963f, 0.49871251f, -0.66584337f, -0.39480600f, -0.02345453f, 0.06327900f, 0.20113359f, -0.07486632f, 
    0.09759314f, -0.10742301f, -0.20166585f, -0.01188121f, 0.35229126f, 0.10617521f, 0.01874304f, 0.15480806f, 
    -0.45882037f, 0.20271842f, 0.61076105f, -0.19909309f, 0.01428307f, 0.01912100f, 0.41930524f, 0.14281550f, 
    0.16877641f, -0.15584210f, 0.09700321f, 0.26395646f, -0.18970457f, -0.17171952f, -0.15955071f, 0.06810370f, 
    0.10464570f, 0.28622013f, -0.80316001f, 0.01125530f, 0.48134986f, -0.18192229f, 0.34486392f, 0.17496978f, 
    0.50840199f, 0.19422273f, -0.10527366f, 0.05979615f, 0.00724856f, 0.28870079f, -0.22946571f, 0.33863574f, 
    -0.40544853f, 0.40587136f, -0.37683785f, -0.42188743f, -0.28052974f, -0.23039006f, -0.08713494f, 0.23173602f, 
    0.21172374f, -0.04417749f, 0.08226920f, -0.34835050f, 0.05475442f, 0.47626764f, -0.13202579f, -0.08577102f, 
    -0.29002815f, -0.20521124f, 0.64862102f, -0.29062441f, -0.09766465f, 0.50802720f, 0.54111695f, 0.27216426f, 
    -0.20456181f, -0.17102349f, -0.00114261f, 0.19864209f, -0.32163268f, -0.16664182f, -0.18659544f, -0.09713151f, 
    -0.35401937f, -0.05098898f, -0.05865898f, 0.12366021f, -0.11187271f, -0.02773095f, -0.42158949f, 0.49590191f, 
    0.31932536f, -0.18551011f, 0.02020065f, 0.08677361f, 0.41898721f, -0.32494938f, -0.16155103f, -0.34433869f, 
    0.06560000f, 0.74590921f, -0.20315589f, 0.13393968f, 0.32813028f, 0.27093863f, -0.75390333f, -0.03511544f, 
    -0.04494692f, 0.17976114f, -0.24251613f, 0.09987648f, -0.11266000f, -0.19760704f, -0.04125807f, -0.14543672f, 
    0.16765596f, -0.21115912f, -0.23817620f, -0.18444669f, -0.09079146f, -0.04703771f, 0.10851859f, -0.14736171f, 
    0.13778719f, -0.01740145f, -0.10602168f, 0.20482852f, -0.00037060f, -0.11513968f, 0.23240885f, 0.13438040f, 
    0.07833516f, 0.02214777f, -0.54760778f, -0.28768405f, -0.06415772f, -0.17284504f, 0.94986105f, 0.35197124f, 
    -0.11108652f, -0.04016592f, -0.21105057f, -0.28133526f, 0.58882874f, -0.20286883f, 0.02889807f, -0.24341059f, 
    -0.03406172f, 0.42930853f, 0.15831418f, -0.11928056f, -0.12394667f, 0.16149047f, 0.24071883f, 0.34235585f, 
    0.43864000f, -0.04061509f, -0.09372465f, 0.15761372f, -0.01694606f, 0.36076361f, -0.13435823f, 0.52095562f, 
    0.24607271f, 0.29926285f, -0.43167350f, -0.23139754f, 0.28923753f, 0.25501367f, -0.45281512f, -0.30865991f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.10288975f, -0.02806097f, -0.27804694f, 0.01006787f, -0.24256244f, 0.36967975f, -0.40997848f, -0.28985298f, 
    0.19066647f, -0.26221335f, 0.12276990f, -0.21018100f, -0.01098889f, -0.06354847f, -0.23018697f, -0.27498126f, 
    0.33642608f, 0.17939802f, 0.16391565f, -0.02203236f, -0.18488775f, 0.26912826f, -0.08407886f, 0.30058607f, 
    0.20611343f, 0.42276210f, -0.46857160f, 0.45756581f, -0.07539073f, -0.14744674f, -0.14951524f, 0.66395956f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05276977f, -0.01492097f, -0.41977245f, -0.08953108f, -0.19943611f, 0.32654577f, 0.17037046f, -0.14354974f, 
    -0.20624027f, -0.11596359f, 0.13385318f, -0.07985966f, 0.14202006f, -0.06906430f, -0.18437085f, -0.02394423f, 
    0.31122229f, 0.43684104f, -0.25068811f, -0.06020104f, 0.62805235f, 0.15490292f, -0.36593530f, 0.12430399f, 
    0.06440824f, -0.37457404f, 0.09951159f, 0.56787139f, 0.20565702f, -0.05541600f, 0.30535656f, 0.19606999f, 
    -0.04229403f, -0.05978859f, -0.03111337f, -0.09400313f, -0.08519960f, 0.05920433f, 0.11945605f, 0.02181625f, 
    -0.03547447f, 0.04229264f, -0.03763558f, 0.13182460f, 0.16551632f, -0.14706555f, 0.02745365f, -0.02122056f, 
    0.16334082f, -0.22626026f, -0.02662912f, 0.03842875f, -0.21001679f, 0.07998609f, -0.14516944f, -0.04357627f, 
    -0.05646056f, -0.00523853f, -0.16490628f, -0.09209295f, -0.06864710f, 0.00262717f, -0.09896597f, -0.05626963f, 
    -0.10851355f, 0.21841341f, -0.07765425f, -0.01657376f, 0.11018626f, -0.46352085f, -0.49877718f, -0.16095784f, 
    -0.41502386f, 0.14397013f, 0.33382827f, -0.06126175f, 0.28239319f, 0.08444557f, 0.46298945f, 0.27848056f, 
    0.26986063f, -0.12566499f, -0.07597238f, -0.01767764f, 0.45130697f, 0.46691346f, 0.11624499f, 0.27719733f, 
    0.00727954f, 0.08501343f, 1.05762959f, 0.09206580f, -0.05820497f, 0.62104738f, 0.48416761f, -0.28419894f, 
    -0.01837282f, 0.39157680f, -0.12570471f, -0.18856254f, 0.02290109f, 0.23113209f, -0.02871201f, 0.32111740f, 
    0.45217246f, 0.25890747f, 0.42868805f, 0.16420387f, 0.36837173f, 0.05339612f, -0.30746984f, 0.01687805f, 
    -0.22057728f, 0.36301368f, -0.19692965f, 0.13554592f, 0.22521147f, -0.17862463f, -0.04883620f, -0.16707389f, 
    -0.78530741f, 0.04047586f, -0.07506968f, 0.12327088f, -0.12033381f, -0.04890726f, 0.24142703f, -0.03138126f, 
    -0.00980549f, -0.25368926f, 0.40925652f, 0.15652925f, 0.11526098f, -0.19270757f, -0.43384373f, -0.17573720f, 
    0.43923330f, 0.16921233f, 0.25247058f, 0.01591199f, 0.03196094f, 0.39780670f, 0.32425219f, 0.12695147f, 
    -0.21746784f, -0.10507095f, 0.20988452f, -0.00729251f, -0.48227152f, -0.18422076f, 0.21951677f, -0.23352017f, 
    -0.31170487f, 0.22587048f, 0.41401154f, 0.28231543f, -0.01095022f, -0.32420340f, -0.05866769f, 0.08433063f, 
    -0.16842780f, -0.10833655f, 0.02504709f, -0.00464418f, 0.13389738f, -0.15371202f, 0.13408920f, -0.16893537f, 
    0.14012022f, -0.20692897f, -0.03852067f, 0.00742109f, 0.03382541f, -0.03047424f, -0.01481924f, -0.10628556f, 
    0.11640774f, -0.03399501f, -0.21298720f, -0.11052132f, 0.02573634f, -0.20738848f, -0.07367002f, -0.20003447f, 
    -0.12088516f, 0.06841776f, 0.01584337f, -0.10173821f, 0.06859937f, 0.11509940f, -0.00907230f, -0.11796394f, 
    0.10543076f, 0.38547149f, -0.71546435f, -0.12177833f, 0.14500441f, 0.25606573f, -0.20597026f, -0.29508972f, 
    0.16128092f, -0.34554496f, 0.07303558f, -0.14619574f, 0.13596818f, -0.04091504f, -0.16545247f, -0.45189077f, 
    0.45666143f, -0.01721831f, 0.04613593f, -0.04541151f, 0.36469516f, 0.11956207f, 0.16986692f, 0.01549964f, 
    0.57836974f, 0.29988563f, -0.50601947f, 0.34391335f, 0.13026683f, 0.07170469f, 0.49788705f, 0.16929817f, 
    0.12832496f, -0.17099482f, -0.09235293f, 0.12608266f, 0.06011588f, -0.08442571f, -0.07415011f, -0.10184621f, 
    0.05820499f, -0.01457577f, 0.00306763f, -0.00183967f, -0.11356216f, 0.15237515f, 0.01918440f, -0.04931810f, 
    0.02110529f, 0.05451022f, -0.12357885f, -0.16035575f, -0.08768054f, 0.06959780f, 0.09295160f, -0.15978327f, 
    -0.17910093f, -0.14447856f, 0.05447108f, 0.09719735f, 0.15226766f, -0.06830727f, -0.01158138f, -0.03715257f, 
    -0.02696014f, -0.19003044f, 0.06584378f, 0.14563508f, 0.00588941f, 0.35999975f, 0.87865323f, 0.25762799f, 
    -0.51675493f, -0.07168201f, 0.47394437f, -0.08859449f, -0.13245156f, -0.22423807f, -0.38867557f, -0.29591489f, 
    0.31817427f, 0.52821046f, -0.25302520f, -0.02376902f, 0.10889222f, -0.44125929f, 0.15357168f, 0.32024279f, 
    0.36718068f, 0.15416698f, -0.46032354f, -0.06602735f, 0.02303029f, 0.30284312f, 0.04656190f, 0.18674821f, 
    0.10122261f, -0.47741449f, 0.05220503f, 0.00595843f, 0.11647759f, -0.37656859f, 0.59474355f, -0.17733648f, 
    -0.76442438f, 0.38327426f, 0.33443075f, 0.10159544f, 0.43814284f, 0.26259148f, 0.18955307f, 0.33071962f, 
    0.35126382f, -0.14842083f, 0.05070822f, 0.02779811f, -0.26071262f, 0.17635918f, 0.23743008f, 0.25958595f, 
    0.28163710f, 0.38705549f, 0.02895376f, -0.25826535f, 0.12154467f, 0.49545521f, 0.13515435f, 0.07969432f, 
    0.11982589f, -0.03561554f, 0.03152495f, 0.07437839f, 0.17125587f, 0.11160453f, -0.12297561f, 0.04579204f, 
    -0.07846715f, -0.09236202f, 0.01658657f, 0.08678940f, -0.02934902f, -0.14930071f, -0.09992753f, -0.14806145f, 
    -0.10618404f, -0.09507260f, -0.18830037f, -0.04140462f, -0.11857293f, -0.08644279f, -0.02317633f, -0.04062080f, 
    -0.08729455f, 0.06890735f, 0.07444566f, 0.05854628f, 0.09944648f, 0.10277351f, -0.08608320f, -0.07781558f, 
    -0.04891161f, -0.38559383f, 0.49684945f, -0.19092371f, 0.10357933f, 0.48688379f, 0.88683963f, 0.46289772f, 
    0.28522322f, 0.22297770f, 0.04517324f, -0.17232572f, -0.25418505f, 0.02818330f, -0.39382556f, 0.21100010f, 
    -0.18047282f, 0.50703382f, 0.09426951f, -0.03421055f, 0.13067515f, -0.22255112f, -0.16423923f, 0.15654759f, 
    0.09261680f, -0.08699440f, -0.31090537f, -0.02539969f, 0.15173623f, -0.20376627f, -0.54098356f, 0.26379719f, 
    0.06917339f, 0.27683681f, -0.14222682f, 0.03402673f, 0.04541288f, -0.40882182f, -0.51953673f, -0.03307967f, 
    0.14037265f, 0.01708539f, 0.46531343f, 0.10456696f, 0.35120431f, 0.39883763f, 0.59270084f, -0.03396062f, 
    0.24952631f, -0.43608755f, 0.23523287f, 0.02824572f, -0.30181283f, -0.09055893f, 0.41229871f, -0.03230897f, 
    0.17009273f, 0.35659364f, 0.59627807f, 0.02028552f, 0.10096096f, -0.02890829f, 0.75957656f, 0.02979198f, 
    0.13251808f, -0.38555303f, 0.17230572f, -0.04012403f, -0.12441362f, -0.25726318f, -0.11294021f, -0.29879314f, 
    0.19844943f, 0.48622704f, 0.01707483f, 0.12470300f, 0.39569074f, 0.46821490f, 0.17087325f, 0.40982154f, 
    0.03266633f, -0.22330433f, 0.44182420f, -0.08618258f, 0.15064420f, 0.44197005f, -0.14750548f, 0.18391375f, 
    -0.14594570f, 0.26556495f, 0.03844381f, 0.08279679f, 0.08450476f, -0.21392992f, 0.33474314f, 0.31521779f, 
    0.13946156f, 0.25233707f, -0.20910852f, -0.19151366f, 0.22033329f, 0.35095245f, -0.27537918f, 0.27677584f, 
    0.17497674f, 0.29917097f, -0.10218261f, -0.04941516f, 0.19882351f, 0.08960292f, -0.36475658f, 0.33540222f, 
    -0.22691008f, 0.21166870f, 0.14886218f, -0.14299913f, 0.55745071f, 0.00655452f, -0.12989275f, 0.10716649f, 
    -0.14958456f, 0.22778177f, -0.59635711f, -0.36319616f, 0.19360727f, 0.29489860f, -0.50863588f, 0.01546392f, 
    -0.05902335f, -0.28936675f, 0.52727377f, -0.13087781f, -0.08123942f, 0.13114154f, 0.26384407f, 0.39055890f, 
    -0.10004736f, 0.16009985f, -0.55724210f, -0.00507033f, -0.23034161f, -0.03385556f, -0.03211292f, 0.37502557f, 
    -0.19686972f, 0.07838463f, 0.35824457f, 0.15413304f, 0.08163906f, 0.02389280f, -0.03168234f, 0.51625818f, 
    0.42226821f, -0.09481866f, 0.55751348f, -0.05811752f, -0.19659016f, 0.32263717f, -0.23691195f, 0.27981642f, 
    -0.05880004f, 0.38519806f, 0.51047230f, -0.03643371f, 0.09706000f, 0.24068090f, 0.47450197f, 0.34729239f, 
    -0.09347613f, -0.37793344f, 0.33858520f, 0.10178579f, -0.40933001f, -0.33173761f, 0.23411830f, -0.16202822f, 
    0.49030602f, 0.37187237f, -0.36848179f, -0.08588851f, -0.05330193f, -0.31816074f, -0.02808967f, 0.13475959f, 
    -0.03345679f, -0.43106866f, 1.00150406f, 0.30907583f, -0.01154969f, 0.23288259f, -0.01985691f, -0.18761094f, 
    -0.05519579f, -0.30358753f, -0.06077515f, 0.13321494f, 0.13662167f, -0.10984899f, -0.09925749f, 0.03859883f, 
    0.09341605f, 0.10310333f, -0.06397274f, -0.10484336f, 0.01201586f, -0.13006568f, -0.09502315f, -0.06572051f, 
    -0.12134931f, -0.04457653f, 0.10543781f, -0.14854605f, -0.07522553f, 0.02892154f, -0.04970022f, -0.03803984f, 
    -0.06634450f, -0.02889368f, 0.01319016f, -0.06464253f, 0.02947748f, -0.00134389f, -0.17696218f, -0.17436741f, 
    -0.17586669f, -0.34207830f, 0.31274715f, -0.00083005f, 0.06018772f, 0.27413565f, -0.43946186f, 0.31010658f, 
    0.58541805f, -0.04648259f, -0.53346568f, -0.13654658f, -0.20674212f, -0.08783130f, 0.12708986f, 0.21308023f, 
    0.02871958f, 0.17808075f, 0.47663674f, 0.16653857f, 0.67635989f, 0.55431247f, -0.24861851f, 0.28999627f, 
    -0.09462857f, -0.27973339f, -0.31417266f, 0.30225471f, -0.05628628f, -0.14054167f, 0.02574020f, 0.39928994f, 
    0.01984419f, 0.17243278f, -0.38951835f, 0.08341780f, 0.05862814f, 0.32009563f, -0.13940534f, 0.10107893f, 
    -0.26864445f, 0.09619344f, -0.45743433f, -0.06648642f, -0.20228536f, -0.22219560f, 0.07420059f, 0.07860765f, 
    -0.03116164f, 0.17483313f, 0.05585503f, -0.06892004f, 0.55054712f, 0.17484587f, 0.14995652f, 0.21044652f, 
    0.81623405f, 0.17635921f, 0.29179204f, -0.13035694f, 0.14846179f, 0.59619600f, -0.10531009f, 0.24927193f, 
    -0.09473602f, -0.04810190f, -0.11224580f, 0.01719732f, -0.02337915f, 0.13370512f, -0.88080794f, 0.36705697f, 
    0.02084989f, -0.08899771f, -0.52198249f, -0.07497574f, 0.05120248f, 0.04002134f, 0.60065168f, -0.44282791f, 
    0.14758876f, -0.08534566f, 0.45470193f, -0.11413596f, 0.17011544f, 0.29684183f, 0.55375212f, -0.12060026f, 
    0.55033290f, 0.16512020f, 1.25234151f, -0.11782510f, -0.10912168f, 0.29752070f, 0.46678346f, -0.19112903f, 
    -0.12964976f, -0.17253084f, 0.04231558f, 0.01191624f, -0.06497299f, 0.09311394f, -0.13142718f, -0.08968516f, 
    0.10480058f, -0.07991814f, -0.10444476f, 0.01615014f, -0.09271278f, -0.02119320f, -0.15205973f, -0.11118939f, 
    -0.03105011f, -0.02590099f, -0.14896400f, 0.14301199f, -0.05991748f, -0.16809724f, -0.01164692f, 0.03615550f, 
    -0.11132093f, -0.14052507f, 0.05395873f, -0.08988298f, -0.14443538f, -0.04829890f, -0.05396198f, -0.02443855f, 
    0.17317270f, -0.34106532f, 0.32983944f, 0.01149037f, -0.06420930f, 0.07987312f, -0.05670878f, -0.33945692f, 
    0.06070660f, 0.44153070f, -0.23396318f, 0.15938339f, 0.17053255f, 0.33018148f, 0.18014961f, 0.23943767f, 
    -0.07022481f, -0.15254669f, 0.13963172f, -0.13790049f, -0.11846842f, 0.24970126f, -0.21949959f, 0.09365591f, 
    0.17323007f, 0.28824410f, -0.43700573f, 0.32798475f, -0.10058050f, -0.15554792f, 0.08689740f, 0.24123326f, 
    -0.02512957f, 0.17242135f, 0.12313740f, -0.04089338f, 0.06780717f, 0.12241957f, 0.38485143f, 0.26461771f, 
    0.08909920f, 0.09734174f, 0.73470086f, -0.13726406f, 0.31639633f, 0.00513349f, 0.13436058f, 0.02596156f, 
    0.15468779f, 0.33057681f, -0.27099648f, 0.11100551f, -0.25913617f, -0.41600138f, -0.02856148f, 0.18337455f, 
    -0.30133569f, 0.17883535f, 0.77402860f, -0.15476374f, 0.06451852f, 0.45351669f, 0.21192205f, 0.06194663f, 
    -0.13356014f, -0.53789085f, -0.16092202f, -0.00682626f, -0.00436578f, 0.37607947f, 0.89971238f, 0.14210436f, 
    -0.37982458f, -0.14548005f, 0.07524232f, 0.10007655f, -0.00077165f, 0.13356824f, -0.54350621f, -0.21643229f, 
    0.14057221f, 0.42276439f, 0.01300253f, 0.02787428f, -0.13205026f, -0.09578606f, -0.00862448f, 0.03760610f, 
    0.24864504f, 0.28008926f, -0.95245403f, 0.19082235f, 0.05609107f, 0.19126037f, -0.33142298f, 0.32227135f, 
    -0.10856958f, -0.23606533f, 0.41121882f, 0.08416970f, -0.23581131f, 0.13463524f, 0.04118464f, -0.22752024f, 
    0.21660015f, 0.35391989f, 0.01086337f, 0.12503274f, 0.14959113f, 0.33506465f, -0.00935523f, 0.15053798f, 
    -0.02735430f, 0.15729304f, 0.35878184f, -0.14353122f, -0.25325105f, -0.07920563f, 0.00657094f, -0.12888077f, 
    -0.14636873f, 0.24148317f, -0.29044059f, 0.25600472f, 0.12586701f, -0.43694398f, -0.20084648f, 0.33897126f, 
    -0.03323875f, -0.22001646f, 0.64749700f, -0.06105376f, 0.02228568f, -0.35545447f, -0.56733942f, -0.07515562f, 
    0.18889834f, 0.12107431f, 0.00962425f, 0.10383255f, -0.07924329f, -0.03958352f, 0.37994274f, 0.41006938f, 
    -0.03436442f, -0.44973010f, 0.17429215f, 0.10286158f, -0.13473797f, 0.21702729f, 0.21011868f, 0.45951694f, 
    -0.01949746f, -0.28588194f, 0.36164609f, 0.30768496f, 0.14022784f, 0.03491594f, -0.02004867f, 0.02623465f, 
    -0.06533522f, -0.06448030f, -0.17586917f, -0.04230113f, -0.17310569f, -0.02242847f, 0.02597584f, -0.17094423f, 
    -0.15825364f, -0.08679933f, 0.04353257f, 0.01009352f, 0.06608570f, -0.13685325f, -0.02518544f, -0.10456046f, 
    -0.03098102f, -0.11745970f, -0.04494056f, 0.16416168f, -0.06613470f, 0.10049555f, -0.02865925f, 0.14393754f, 
    0.11549328f, 0.03610619f, 0.04736985f, -0.08860429f, 0.12096318f, 0.00408267f, -0.12777825f, -0.09111288f, 
    0.14812623f, 0.01906928f, -0.14678082f, 0.10981751f, -0.08256231f, -0.07883529f, 0.01758998f, -0.26520160f, 
    -0.73776066f, 0.18784726f, -0.16558583f, 0.12672178f, 0.20563844f, -0.09539134f, -0.12091458f, 0.69115525f, 
    0.13540122f, 0.00601078f, 0.04439062f, 0.12274742f, 0.03853839f, 0.48031753f, 0.09398853f, 0.20641151f, 
    0.16858031f, 0.09081993f, -0.52543885f, -0.20878093f, -0.07009784f, 0.36763924f, 0.12718280f, 0.08118859f, 
    0.16801074f, 0.10358690f, -0.14327443f, -0.14308894f, -0.04183257f, 0.36731428f, 0.48360723f, 0.05159475f, 
    0.11798587f, -0.05195952f, 0.43021023f, 0.13420032f, 0.13663389f, 0.00359718f, -0.36470988f, -0.53743601f, 
    0.24465176f, 0.41082802f, 0.06063624f, -0.11114720f, -0.09661514f, -0.44091323f, 0.30797213f, -0.37219331f, 
    -0.07096154f, 0.39196682f, -0.79717076f, 0.06352673f, -0.04730110f, -0.42483774f, 0.03298501f, 0.13105506f, 
    -0.16024676f, -0.10778776f, 0.00972711f, -0.01230233f, -0.11709893f, -0.14525974f, -0.11607215f, -0.01402704f, 
    -0.16887422f, -0.03381745f, 0.10507905f, -0.02816436f, 0.02737948f, -0.10270443f, -0.17288527f, -0.14653033f, 
    -0.17468891f, 0.11244530f, 0.02905848f, -0.15916446f, -0.16458574f, -0.12337333f, -0.03519953f, -0.05076291f, 
    -0.05569242f, -0.01567119f, -0.15269095f, -0.13262525f, -0.04957304f, -0.05299189f, -0.15689680f, 0.16878456f, 
    0.00249651f, -0.25070190f, -0.13929284f, -0.06879857f, -0.10561395f, -0.04454287f, -0.12165829f, -0.06788971f, 
    -0.00742385f, -0.33316529f, -0.38040707f, 0.16759378f, -0.23872562f, -0.15507406f, -0.00833605f, -0.48586965f, 
    0.28695154f, 0.17386976f, 0.28356802f, 0.08255258f, -0.16323537f, -0.13478689f, 0.26428559f, 0.15470934f, 
    0.69711119f, 0.15568776f, -0.77553195f, 0.18621744f, 0.00700533f, 0.14527582f, -0.17433742f, 0.31722957f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.00801279f, 0.01192222f, -0.30448622f, 0.04813051f, 0.21668297f, -0.06927004f, 0.30434519f, -0.04154206f, 
    0.22932549f, 0.12478694f, -0.19574422f, 0.21194214f, 0.31948447f, 0.24075688f, -0.20635667f, 0.29145086f, 
    -0.03382348f, -0.19885206f, -0.15993571f, 0.29984495f, -0.04213364f, -0.09049544f, 0.34901768f, 0.00426321f, 
    0.05138394f, -0.01691829f, -0.17615229f, -0.09251314f, 0.25288942f, 0.24226263f, -0.10809895f, 0.42762485f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.52878106f, 0.09001680f, 0.13484117f, -0.23588167f, -0.35196292f, -0.06361037f, -0.18154092f, 0.11354902f, 
    0.25608152f, 0.43340310f, 0.10599625f, 0.08326675f, 0.03726037f, -0.13247462f, 0.30941230f, 0.15680017f, 
    -0.59458143f, 0.01702259f, -0.69516617f, 0.30743706f, 0.09079372f, 0.13641997f, -0.06885929f, 0.11563014f, 
    0.14643039f, -0.10232806f, -0.27050823f, 0.11476389f, 0.40043673f, -0.05648128f, 0.13951245f, 0.00443823f, 
    -0.47142881f, 0.14685874f, 0.38553581f, -0.19436181f, 0.18904431f, -0.09766218f, -0.29213473f, -0.13160697f, 
    -0.23590201f, 0.35698608f, -0.09454674f, -0.45498663f, 0.32598501f, 0.15104307f, -0.16755511f, -0.14657095f, 
    0.22964308f, 0.01545828f, -0.36541307f, -0.19095369f, -0.03107786f, -0.04726748f, 0.07333580f, 0.03496434f, 
    -0.20595352f, 0.23975660f, 0.31022623f, 0.08379038f, 0.32345617f, -0.25282213f, -0.08638791f, -0.16209830f, 
    -0.77556103f, 0.14618674f, -0.74204296f, -0.17415610f, 0.39343777f, -0.08749364f, -1.05923080f, 0.00552706f, 
    -0.66243666f, -0.23926286f, 0.15589470f, 0.35601389f, -0.17590046f, 0.16665010f, 0.00742742f, 0.37454340f, 
    -0.46546680f, -0.07124619f, 0.48136827f, -0.34393770f, -0.38972592f, -0.01058967f, 0.24600755f, -0.39311928f, 
    -0.36605102f, 0.37468916f, 0.77068990f, -0.07560306f, -0.18181488f, -0.39520636f, 0.11062308f, 0.00461793f, 
    0.15521291f, -0.03158280f, -0.41695592f, 0.09736190f, -0.81342411f, 0.14540178f, 0.09207866f, -0.14151427f, 
    0.37067357f, -0.81195039f, -0.10382223f, 0.22790843f, -0.57703733f, -0.83109105f, 0.09459861f, 0.04324316f, 
    0.42511493f, -0.13376136f, 0.20105614f, 0.10620268f, -0.46678153f, 0.17168067f, -0.47153100f, 0.09989936f, 
    0.21028066f, -0.16606660f, -0.07541591f, 0.01452334f, -0.43734860f, 0.24388430f, -0.08012788f, 0.13733935f, 
    0.11094231f, -0.15176418f, -0.11380703f, -0.33096060f, -0.01690120f, -0.02220872f, 0.25239050f, -0.10069304f, 
    0.10303889f, -0.11046588f, -0.06179746f, -0.05136368f, -0.06342962f, -0.14566143f, -0.14313672f, 0.04329967f, 
    -0.21291862f, -0.05486583f, 0.20127998f, 0.14436370f, 0.33426741f, 0.01505100f, 0.00746130f, -0.26517054f, 
    0.21659730f, 0.10348030f, -0.21559232f, -0.00640360f, -0.24746837f, 0.03837057f, 0.02863206f, 0.29907355f, 
    0.40497360f, 0.04442759f, 0.44299942f, -0.06473505f, -0.14168650f, -0.11782009f, 0.21793155f, 0.19020085f, 
    -0.12693796f, 0.07519021f, 0.02793664f, -0.43518889f, 0.23453259f, 0.12489195f, -0.18929118f, -0.04005460f, 
    0.16164167f, 0.01804694f, -0.08620662f, -0.05696719f, -0.02726687f, 0.05455136f, 0.03287898f, -0.13678376f, 
    -0.42685872f, -0.22044364f, 0.27619356f, 0.02079548f, 0.22807720f, -0.51199734f, 0.06920980f, -0.07048722f, 
    0.16192980f, -0.08353096f, -0.12046064f, -0.47719017f, -0.26532570f, -0.07939305f, 0.20957416f, 0.08630887f, 
    -0.17571901f, -0.03671497f, 0.10581963f, -0.00146401f, -0.21667069f, 0.13993728f, 0.04911884f, 0.13010788f, 
    -1.19693661f, -0.01735509f, 0.38724348f, 0.40187812f, -0.05972905f, -0.14273831f, 0.21408451f, -0.98588717f, 
    0.05491887f, 0.18591388f, 0.03698669f, 0.02447757f, 0.21311790f, -0.10856340f, 0.14248922f, 0.20016937f, 
    0.03431076f, -0.04239104f, 0.33844057f, 0.04331006f, -0.05690873f, -0.01006342f, -0.27972034f, -0.12904440f, 
    -0.01874305f, -0.53845775f, -0.04004933f, 0.04186353f, -0.10373616f, -0.54264307f, -0.39510074f, 0.17525496f, 
    0.37208185f, -0.08461507f, 0.18578903f, 0.17038839f, 0.66555494f, 0.01886581f, -0.62126642f, 0.23929316f, 
    -0.46147773f, -0.65997660f, 0.20055512f, 0.11184812f, -1.03702557f, -0.63636255f, -0.00974471f, -0.67548680f, 
    -0.34796166f, -0.17483819f, 0.05273412f, 0.56650245f, 0.25968900f, -0.00922662f, 0.07865825f, 0.05412614f, 
    -0.72993010f, -0.17892289f, 0.03527914f, -0.24432242f, 0.42541423f, 0.13538513f, 0.02035982f, -1.00648403f, 
    0.05643222f, 0.15270275f, -0.35728428f, -0.98111486f, -0.12026194f, -0.03141670f, 0.11644246f, 0.16599616f, 
    -0.90582442f, 0.31074634f, -0.32316637f, -0.15365818f, -0.60110259f, 0.33118096f, 0.17099336f, -0.62529165f, 
    -0.10190330f, -0.00369375f, -0.44229740f, -0.34208807f, 0.04769103f, 0.04545378f, 0.47423449f, -0.17799079f, 
    -0.17847764f, -0.25959146f, -0.20020194f, -0.14532529f, 0.26477635f, -0.09714401f, -0.28542587f, 0.03164647f, 
    0.21797507f, 0.08054827f, -0.13850762f, 0.24328387f, 0.26726058f, -0.08788482f, 0.07842433f, -0.48307312f, 
    -0.14760368f, 0.16132170f, -0.28866366f, -0.14955144f, -0.28543043f, 0.22812231f, 0.03017459f, 0.50420743f, 
    0.18208848f, 0.18066102f, -0.31787243f, 0.17888613f, 0.08324726f, -0.09007169f, 0.08176273f, 0.14263782f, 
    0.26781291f, 0.00302304f, -0.11111602f, 0.31426945f, 0.00834890f, -0.08755963f, -0.39058742f, -0.24495888f, 
    0.37190586f, -0.06620072f, -0.44311032f, -0.42432329f, -1.16425288f, -0.08604462f, 0.02403882f, 0.32270083f, 
    0.41584206f, 0.19199006f, -0.46225876f, -0.06950225f, -0.37990022f, 0.31737939f, 0.03421161f, -0.28227726f, 
    0.20810665f, -0.02415854f, -0.29026499f, 0.43455338f, -0.19155921f, -0.16259056f, -0.16295891f, -0.06869044f, 
    -0.14587247f, -0.32434294f, -0.00023145f, 0.39956805f, -0.55507272f, -0.07284645f, 0.63695258f, 0.12579706f, 
    -0.64870006f, -0.17871006f, 0.36224183f, 0.16108912f, -0.21348482f, -0.02571463f, -0.06623604f, -0.08460949f, 
    0.11357594f, 0.10429057f, -0.64876103f, 0.01289226f, 0.36763585f, 0.06063453f, 0.16145898f, -0.45399979f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.31849712f, -0.49304840f, -0.03639931f, -0.13202353f, -0.02187681f, 0.36896726f, -0.27745071f, -0.44823247f, 
    0.03793853f, 0.43219256f, -0.00636821f, 0.17547193f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
