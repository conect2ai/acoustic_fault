#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.81356055f, -0.16804437f, 0.01259059f, 0.25179115f, -0.55055118f, 1.03046620f, -0.13645740f, 0.88522422f, 
    -0.85111320f, 0.03601085f, 0.18909192f, 0.01453706f, 0.11453097f, -0.07175210f, -0.25526983f, 0.11596540f, 
    0.05080723f, 0.12227228f, 0.01507795f, -0.04159229f, 0.12801895f, -0.04826038f, -0.27546009f, 0.18099160f, 
    0.06961699f, -0.68249381f, 0.73471498f, 1.03242862f, 0.06071788f, -0.01968042f, 0.04534503f, -0.06247119f, 
    0.08715418f, -0.16918275f, 0.05965390f, -0.20178400f, -0.47400007f, -0.10256813f, 0.19877057f, -0.34918469f, 
    0.11603769f, -0.03654509f, -0.11597940f, 0.12906066f, -0.15208824f, -0.04301485f, -0.27302122f, -0.70920074f, 
    -0.49918351f, -0.87973374f, 0.09759904f, -0.42186707f, -0.40265092f, -0.82849908f, 0.11538541f, 0.10689555f, 
    0.16509634f, 0.07875649f, 0.39451116f, -0.18377538f, -0.01650801f, 0.63640302f, 0.07970661f, -0.05520736f, 
    -0.41008285f, -0.58292466f, 0.00292408f, -0.56040114f, -0.21243896f, 0.40620556f, 0.27009135f, 0.17529160f, 
    0.21529293f, 0.40045768f, 0.28755462f, -0.45509452f, -0.65113562f, -0.70299047f, -0.52113241f, 0.09455976f, 
    -0.60775042f, -0.50044471f, 0.16776010f, -0.74303323f, -0.59434646f, -0.11685596f, -0.30074725f, 0.05417089f, 
    -0.28277224f, -0.07112180f, 0.18826219f, 0.29933542f, -0.20413899f, 0.16473332f, 0.03077739f, 0.31622145f, 
    0.12790872f, 0.53930515f, 0.24836594f, 0.32643634f, 0.57691324f, -1.14429843f, 0.86308694f, 0.35458845f, 
    0.91215956f, -0.47924912f, -0.17932941f, 0.01797905f, -0.39106435f, -0.03047800f, -0.23801813f, -0.39761057f, 
    0.63456792f, -0.45132998f, 0.18840560f, -0.10379862f, -0.17117853f, -0.09894446f, 0.05101703f, 0.34721360f, 
    -0.19683357f, 0.14104620f, -0.19710878f, -0.01215711f, 0.26827085f, 1.09697545f, 0.34003994f, 0.30348763f, 
    0.41576841f, 0.01260946f, 0.46632811f, 0.44773588f, -0.22622392f, -0.61762935f, -0.39407268f, -0.21552338f, 
    -0.13976330f, 0.09396696f, -0.44367313f, -0.07433037f, -0.12735468f, -0.18839580f, -0.18047014f, -0.31355262f, 
    -0.06565782f, 0.21441710f, -0.26090491f, 0.16197683f, 0.27370605f, 0.12137488f, -0.73105210f, 0.09580900f, 
    0.10601161f, 0.05248512f, 0.66099614f, 0.73708665f, -0.50927472f, -0.92035484f, -0.81683081f, -0.74759358f, 
    0.15456899f, 0.00640336f, 0.53062057f, -0.62583160f, -0.21358606f, 0.07647400f, -0.18529415f, 0.49183464f, 
    0.00391747f, 0.45811459f, 0.20934471f, -0.14344682f, -0.31200388f, -0.05060503f, -0.38211706f, 0.44585925f, 
    -0.14035359f, -0.21299092f, -0.20473167f, -0.48691407f, -0.44455525f, -0.49113896f, 0.39712390f, -0.20517787f, 
    -0.53185976f, -0.61123490f, -0.16240294f, 0.05658625f, 0.48875454f, -0.42725652f, 0.44572878f, -0.38155478f, 
    -0.31289548f, -0.33253309f, -0.57148856f, -0.30186328f, -0.15359706f, -0.32518291f, -0.61588591f, -0.45445123f, 
    0.55030495f, 0.91695642f, 0.51654899f, -0.34554204f, -0.10455888f, -0.79401141f, -0.06703699f, 0.39115247f, 
    0.13816474f, 0.18104589f, -0.06520408f, -0.04933487f, 0.46915132f, 0.06377739f, -0.31370541f, 0.19376473f, 
    0.08863557f, -0.39707321f, 0.00436822f, -0.35095292f, -0.08316802f, 0.20286313f, -0.08460879f, 0.18749455f, 
    -0.18369369f, 0.32019195f, 0.36636430f, -0.96203375f, -0.78985351f, 0.36949867f, -0.58313036f, -0.69210595f, 
    -0.56805414f, -1.08563864f, -1.25666058f, 0.10693099f, 0.30790341f, 0.58348048f, -0.28507259f, -0.45242381f, 
    -0.42051971f, 0.02557759f, -0.18877594f, -0.17132947f, -0.19713551f, -0.08875692f, 0.12023320f, 0.04892824f, 
    -0.08217584f, 0.14966865f, -1.57283723f, -0.39600116f, -0.66023588f, -1.13094950f, -0.98319083f, 0.53730446f, 
    0.11306809f, 0.07357402f, 0.42540535f, 0.56045401f, -0.22820483f, -0.07006098f, 0.03626679f, 0.61948967f, 
    -0.10483380f, -0.08251906f, -0.02317550f, -0.15223219f, 0.13806944f, -0.10514311f, -0.12945202f, 0.06873072f, 
    0.33904842f, -0.30091923f, -0.44797826f, -1.16841078f, -0.94493669f, -0.72727257f, -0.08780332f, 0.22421293f, 
    0.19055776f, 0.50479001f, -0.86708099f, -0.35369247f, 0.02265147f, -0.46384352f, -0.37543857f, -0.29694131f, 
    -0.28651071f, -0.62792695f, 0.23162816f, 0.24292885f, -0.34105629f, 0.37872544f, 0.10842137f, -0.11578569f, 
    -0.38672251f, -0.32330269f, 0.11491144f, -0.48501989f, 0.61454505f, -0.49663478f, 0.10212626f, 0.62546986f, 
    -0.03846294f, 0.02150550f, -0.46086445f, -0.42853522f, -0.16183370f, 0.32178986f, 0.03261754f, 0.17258886f, 
    0.40466794f, -0.06673045f, -0.38863704f, -0.62262547f, 0.31214988f, 0.24894248f, 0.16660503f, 0.30572701f, 
    0.15643913f, 0.20504679f, -0.34601018f, 0.42944607f, -0.28286374f, 0.93358296f, -0.82924181f, -1.15348399f, 
    -1.04817438f, -0.83286476f, 0.76130611f, -0.13422462f, 0.01391765f, -0.02356067f, -0.11990330f, 0.51855952f, 
    0.27931195f, 0.31886926f, -0.16232161f, 0.17412508f, 0.20956117f, -0.02097451f, 0.01332234f, -0.03096345f, 
    -0.28593895f, -0.23363209f, -0.52906990f, 0.05269028f, 0.03418969f, -0.18296631f, -1.16678643f, 0.03627520f, 
    -0.25862378f, 0.47396550f, 0.56175756f, 0.07307117f, -0.18991572f, 0.43379846f, 0.17368235f, 0.10097522f, 
    0.20456637f, 0.21428342f, 0.03976195f, 0.00201551f, 0.15776913f, -0.05473390f, -0.19035277f, -0.53993368f, 
    -0.27960318f, -0.16396776f, 0.62595671f, -0.03428283f, 0.67028695f, 0.48332101f, 0.14565361f, -1.07959902f, 
    0.08161928f, -0.32924709f, -0.59750277f, -0.48939866f, 0.87679899f, 0.50770879f, 0.08420888f, -0.21415971f, 
    0.88020945f, 0.01167542f, 0.62826532f, -0.34061056f, -0.39665350f, -0.18745700f, 0.11735810f, 0.18142028f, 
    0.12430448f, 0.04266901f, -0.30554825f, 0.09066186f, 0.36880764f, -0.25579888f, 0.03805311f, -0.03140450f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.37819904f, -0.03001584f, 0.25825170f, 0.24481848f, 0.46579343f, 0.37274432f, 0.47295168f, 0.28547770f, 
    0.56830162f, 0.39640319f, -0.03373367f, -0.00357944f, 0.62527466f, 0.64473736f, -0.03498446f, 0.35283434f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.33339283f, -0.39709458f, -0.46046650f, -0.30530763f, 0.08181186f, 0.20678258f, 0.09946688f, 0.06156589f, 
    -0.06579915f, 0.00995170f, 0.06846119f, 0.06650584f, -0.35130635f, -0.19329311f, -0.12036893f, 0.23679270f, 
    -0.01225795f, 0.08661674f, 0.01365473f, -0.13228787f, 0.12589151f, -0.06733140f, 0.06848271f, -0.08547512f, 
    0.25959769f, 0.04028283f, 0.07819632f, 0.11078859f, 0.16595434f, -0.11894411f, 0.25267875f, 0.24142574f, 
    0.39093623f, 0.13289973f, 0.00832652f, 0.10299222f, 0.11313922f, 0.43509507f, 0.27669165f, 0.19171745f, 
    -0.00072935f, 0.11488982f, 0.04778704f, 0.08392736f, 0.05488085f, -0.01978491f, -0.08565813f, -0.02423453f, 
    -0.62995982f, -0.59428197f, -0.31103277f, -0.33186641f, 0.12338353f, -0.07861499f, 0.12275112f, -0.19192013f, 
    -0.02144327f, -0.15333638f, -0.08230261f, 0.01046288f, -0.07627852f, -0.55459201f, -0.32196024f, 0.15585129f, 
    0.07854337f, -0.00143966f, -0.04942400f, 0.00662959f, 0.01794638f, -0.03947499f, -0.09123972f, -0.11645930f, 
    0.29105088f, -0.12798376f, 0.32489860f, 0.19036141f, -0.12775157f, -0.05360042f, 0.08208138f, 0.09029433f, 
    -0.04218092f, -0.06207201f, -0.06870695f, 0.02671035f, 0.29456607f, 0.23317036f, 0.24238281f, 0.21146034f, 
    0.06959606f, 0.02042733f, 0.15629879f, 0.15423925f, 0.18744624f, 0.21397734f, 0.05699946f, -0.05531072f, 
    -0.56077915f, -0.31166926f, -0.43155849f, 0.06696099f, -0.10408083f, -0.13942805f, -0.14626589f, -0.06676940f, 
    0.26059976f, -0.01006760f, 0.08298565f, -0.00056336f, 0.39715850f, 0.60716861f, 0.25474674f, 0.27104679f, 
    0.10624807f, -0.02939141f, 0.18653992f, 0.27425355f, -0.03729942f, -0.07662630f, -0.01553509f, -0.01588612f, 
    0.19330148f, 0.08027264f, -0.09578107f, 0.02170441f, -0.07327971f, -0.08323227f, -0.01564834f, 0.00026932f, 
    0.04258075f, -0.07044032f, -0.02455460f, 0.06675693f, -0.19678281f, 0.38062528f, 0.06239556f, 0.09676841f, 
    -0.06644212f, -0.02216577f, -0.20338839f, 0.05134312f, -0.08523206f, 0.02402325f, 0.00857365f, 0.15866517f, 
    0.02575689f, -0.22653402f, 0.01985222f, -0.22629839f, 0.09930867f, 0.10168742f, -0.00797716f, 0.04533503f, 
    0.03718276f, -0.05340127f, -0.10369094f, 0.10285030f, 0.19826473f, 0.00231673f, 0.52338988f, -0.00093970f, 
    0.08392576f, -0.04524858f, -0.05109677f, -0.14098123f, -0.01097438f, -0.02570361f, 0.00800673f, 0.00805302f, 
    -0.02770976f, 0.23752190f, 0.35996711f, 0.18103315f, 0.15971738f, 0.08207577f, 0.14350021f, 0.08909549f, 
    0.12934567f, 0.09098687f, 0.06468677f, 0.21137254f, 0.21637918f, 0.18140112f, -0.14828244f, -0.39296561f, 
    0.13102046f, 0.05658305f, 0.21330582f, -0.24456649f, -0.11367556f, 0.07991478f, 0.18056893f, 0.03927080f, 
    0.03035413f, 0.02704924f, -0.03531618f, -0.04585079f, 0.02743576f, -0.04501579f, -0.04002092f, -0.00979334f, 
    0.04468442f, 0.03885840f, -0.03472562f, -0.08312518f, 0.00700850f, -0.00078506f, -0.06818685f, 0.05542763f, 
    -0.02129015f, 0.00711646f, -0.08117042f, -0.02805035f, 0.04632314f, 0.06023034f, 0.03274406f, -0.06353516f, 
    -0.03115379f, -0.05869742f, 0.01679982f, 0.00487107f, -0.01694494f, -0.00815888f, 0.03936249f, 0.04680717f, 
    0.03826851f, -0.00111723f, -0.06267399f, -0.04564969f, 0.00601746f, 0.05228567f, 0.00490469f, 0.05302035f, 
    -0.04077127f, -0.07036380f, -0.00583395f, 0.04916829f, -0.02287186f, 0.02514635f, -0.02649524f, -0.00340461f, 
    -0.02568814f, -0.03164242f, 0.02800964f, -0.07554542f, -0.02190491f, -0.00948403f, 0.03331180f, 0.05115325f, 
    -0.00491978f, 0.00989172f, 0.05836772f, 0.00890296f, -0.04577108f, -0.07414051f, -0.06016554f, -0.03031980f, 
    0.02269609f, 0.02473090f, -0.01677582f, -0.00300880f, 0.00894620f, 0.03277503f, -0.05769109f, -0.02923941f, 
    0.00088898f, 0.00327483f, 0.04683777f, 0.03254443f, 0.00149249f, -0.02821085f, -0.01429033f, 0.05299075f, 
    0.00582516f, -0.08680913f, -0.07708924f, -0.02155079f, -0.05503927f, 0.05966911f, -0.03400499f, 0.03361046f, 
    -0.07689442f, 0.03326455f, -0.05133167f, -0.03131887f, 0.00619895f, -0.03224364f, -0.00195576f, -0.07518948f, 
    -0.04816129f, -0.01130202f, -0.06748788f, -0.06202262f, 0.02769148f, -0.02839882f, -0.05456133f, -0.06801081f, 
    -0.01809895f, 0.05524134f, 0.03602073f, -0.03850485f, 0.03944124f, -0.04008119f, -0.04905831f, 0.04816958f, 
    -0.00637130f, 0.02107443f, -0.03664196f, -0.07452754f, -0.04387492f, -0.07089137f, 0.02198867f, -0.06804378f, 
    -0.06555084f, -0.05130877f, 0.03018136f, 0.04032699f, -0.03669053f, 0.00864779f, 0.04265321f, -0.01728282f, 
    0.05170762f, -0.05342758f, -0.07672057f, -0.06710918f, -0.01988906f, -0.03912230f, -0.03748468f, -0.03309417f, 
    0.01292616f, -0.04599254f, -0.06081793f, 0.01751649f, -0.05451391f, 0.04473611f, -0.01306623f, -0.07945962f, 
    -0.08236466f, 0.05569649f, -0.00137475f, -0.06569660f, -0.02818776f, 0.02494292f, 0.00193937f, -0.00693551f, 
    0.04250349f, -0.01721710f, -0.01961309f, -0.03162110f, 0.03652382f, -0.04254463f, 0.05200720f, 0.04697541f, 
    0.02742861f, 0.02475085f, 0.01369166f, 0.00984303f, 0.03079408f, -0.06369153f, -0.04184014f, -0.07864705f, 
    -0.05206336f, -0.07025664f, 0.00467711f, 0.02232510f, 0.05065919f, -0.07589968f, -0.05801320f, -0.01369607f, 
    -0.01140326f, -0.00673429f, -0.00053456f, 0.02807612f, -0.07615422f, 0.05472565f, 0.01899159f, 0.02806830f, 
    0.01058279f, -0.07175439f, -0.02591280f, -0.06707817f, -0.04154488f, -0.02560766f, -0.00415167f, -0.05276652f, 
    0.08240905f, -0.53280324f, -0.27861825f, -0.22591805f, -0.01877636f, -0.39339155f, -0.17219909f, -0.08539587f, 
    -0.04884025f, -0.04630182f, -0.08667398f, 0.09035079f, 0.15658888f, -0.14048295f, -0.26315728f, 0.31779265f, 
    0.11590750f, -0.15465881f, 0.13693102f, 0.03037444f, 0.07735711f, 0.26684988f, 0.14473806f, 0.32950592f, 
    0.24931017f, -0.13510130f, 0.04503797f, 0.12309088f, 0.13634790f, 0.07969576f, 0.00825887f, -0.09303939f, 
    -0.14944759f, -0.34536156f, -0.22465076f, -0.37086591f, 0.32011458f, 0.15559490f, 0.24165514f, 0.03025688f, 
    0.18434972f, 0.09756163f, 0.06191140f, 0.08586694f, -0.09759764f, -0.01129331f, 0.09276992f, -0.01355377f, 
    0.52777827f, -0.78187287f, 0.35440233f, -0.76394403f, -0.03100693f, 0.19128780f, -0.07717563f, -0.02354169f, 
    -0.14085777f, -0.09664030f, -0.44078079f, -0.09175123f, 0.21264763f, -0.44277754f, -0.09616564f, 0.05066675f, 
    0.07096551f, 0.01130819f, 0.17463836f, -0.10755635f, -0.14859575f, -0.07714374f, -0.07863031f, -0.06334858f, 
    0.51262349f, -0.03029907f, -0.00707070f, 0.21972060f, 0.00835789f, -0.12698138f, 0.03394933f, -0.10005666f, 
    0.05724236f, -0.12275229f, -0.22249728f, 0.01263120f, 0.12086537f, 0.19071127f, 0.23948263f, 0.05781490f, 
    0.08430037f, 0.04623421f, 0.01859303f, 0.08423145f, -0.18661219f, -0.04152714f, 0.10967434f, 0.34366795f, 
    -0.28486171f, -0.82369977f, -0.58569568f, -0.09682260f, 0.19168061f, 0.06507934f, -0.07491176f, -0.26646200f, 
    -0.13442674f, -0.35876691f, -0.05503162f, 0.03438408f, 0.38836497f, 0.28026226f, 0.06982665f, -0.00070856f, 
    0.08564542f, -0.18496670f, 0.05187043f, 0.10216947f, 0.07521625f, -0.00379723f, 0.10764569f, 0.02400924f, 
    -0.01178147f, 0.26921609f, 0.13921879f, -0.01713622f, -0.01879969f, 0.21186681f, -0.05261602f, 0.05955213f, 
    0.13448498f, -0.10684679f, 0.04125004f, 0.10591344f, 0.33656070f, -0.02381036f, 0.03944208f, 0.15294784f, 
    0.01743790f, 0.22221884f, 0.12806170f, 0.06586234f, 0.07032853f, 0.06808462f, 0.03020522f, 0.15043625f, 
    0.10307634f, -0.03877826f, 0.19438207f, -0.43161780f, 0.04307712f, 0.05585616f, -0.00436884f, -0.04985084f, 
    -0.07826086f, -0.22887911f, -0.22865468f, -0.27674761f, 0.40202582f, -0.14473404f, 0.09037658f, 0.24904449f, 
    0.01114352f, -0.02218682f, -0.14132589f, 0.13776003f, 0.06203663f, -0.05696743f, 0.16745606f, 0.13020556f, 
    0.01293113f, 0.24489763f, 0.21533103f, 0.32161236f, 0.18837172f, 0.35939953f, -0.14668120f, -0.02814015f, 
    -0.34120297f, -0.01212810f, -0.28711370f, -0.08491587f, -0.09356795f, 0.04966404f, -0.22274135f, 0.08081900f, 
    -0.05016809f, 0.05318276f, 0.02121613f, -0.07689939f, 0.14970098f, 0.13066581f, -0.01345967f, -0.18742967f, 
    0.43869656f, 0.20218627f, 0.29159260f, 0.50441206f, -0.21674283f, 0.10569378f, -0.26734760f, -0.12850535f, 
    0.02555719f, -0.00826896f, -0.19015077f, -0.12491896f, 0.25680974f, 0.21085921f, 0.25025299f, 0.19535002f, 
    -0.15276603f, -0.04419011f, 0.02809851f, -0.13486117f, 0.07412571f, -0.11057017f, -0.23617138f, 0.09535847f, 
    -0.05565969f, 0.30794978f, -0.39332402f, 0.11274141f, -0.08041155f, 0.23392168f, 0.16893867f, 0.06255115f, 
    -0.00039969f, 0.07914758f, 0.15318066f, -0.15896975f, 0.24568923f, 0.25820753f, 0.02584574f, 0.16605622f, 
    0.04500046f, 0.11162853f, 0.00670469f, 0.05501120f, -0.04205065f, 0.03964787f, -0.06687044f, -0.00476183f, 
    -0.49928752f, 0.19061512f, 0.41026375f, 0.07693824f, -0.14674428f, -0.05658238f, 0.04621435f, 0.13114096f, 
    -0.00460865f, 0.01124709f, 0.12252329f, -0.11703138f, 0.44630256f, 0.17163564f, -0.04164943f, 0.42617878f, 
    -0.15283503f, -0.00030899f, -0.05737689f, 0.08892672f, 0.02283255f, -0.03303294f, -0.01781763f, 0.10178618f, 
    0.20527579f, 0.25037172f, -0.08758832f, 0.16636904f, 0.30439472f, -0.01958354f, -0.03096492f, 0.06608047f, 
    -0.02086211f, -0.16880997f, 0.08081365f, 0.01455190f, 0.32289031f, 0.02151059f, 0.00172415f, 0.23290710f, 
    -0.03382111f, 0.01833772f, 0.10142109f, 0.22197145f, -0.12785627f, -0.21136174f, -0.27644411f, 0.17319065f, 
    0.13048013f, -0.38840452f, 0.26331213f, 0.15304284f, -0.34246102f, -0.03551596f, 0.00190144f, -0.10832923f, 
    -0.10914270f, -0.06999080f, -0.18381767f, 0.08257483f, 0.22217228f, -0.03779929f, -0.00507619f, 0.18584749f, 
    0.25733322f, 0.11818811f, 0.08039880f, -0.02328267f, 0.01913312f, -0.12668237f, 0.11402693f, 0.06752567f, 
    0.47260216f, 0.20293692f, 0.05284080f, -0.27611080f, 0.29766300f, 0.07025680f, 0.14262740f, 0.11616449f, 
    -0.00897894f, 0.23818395f, -0.09950986f, -0.07860494f, 0.40801394f, 0.12568463f, 0.11337347f, 0.01122411f, 
    0.25846803f, 0.15295504f, 0.03334819f, 0.02540006f, -0.18558995f, 0.06490558f, 0.01171308f, -0.21050116f, 
    -0.57121509f, -0.03687965f, 0.03001142f, -0.21383460f, -0.02568914f, 0.08504869f, -0.01583025f, 0.12364107f, 
    0.05976579f, 0.11752217f, 0.14886159f, -0.16236308f, 0.20562765f, -0.15954781f, -0.78283149f, 0.37340128f, 
    0.11198698f, 0.08397134f, -0.07418725f, 0.10494115f, 0.12382288f, -0.04505088f, -0.18429524f, 0.01319608f, 
    -0.24093980f, 0.11218967f, 0.29461432f, -0.33214068f, -0.06085678f, 0.18589430f, 0.11690684f, -0.06109670f, 
    0.04937363f, -0.03485252f, 0.04856808f, 0.01092463f, 0.23985295f, -0.11550090f, -0.09468736f, -0.21537244f, 
    -0.09369188f, -0.02885173f, 0.11461903f, 0.16248113f, -0.00031197f, -0.01874383f, 0.12278531f, -0.04711777f, 
    0.03786493f, 0.19239493f, 0.31123671f, -0.08500275f, 0.13972619f, 0.00919383f, 0.17418003f, -0.18411295f, 
    0.01050129f, 0.15110697f, 0.16102746f, 0.02505471f, 0.27797672f, 0.02056351f, 0.04721355f, -0.19741747f, 
    0.04221221f, -0.06562272f, -0.10948518f, -0.17983992f, 0.24223448f, 0.14919090f, 0.18029910f, 0.29639158f, 
    0.23436804f, 0.08024003f, 0.11931641f, 0.15896212f, -0.11271410f, 0.10153313f, -0.08442488f, 0.09067395f, 
    0.01388605f, -0.06256156f, -0.18296857f, -0.25569004f, -0.10607983f, -0.09951492f, 0.21717873f, 0.18416587f, 
    -0.13610330f, -0.05256169f, -0.24592525f, -0.14513923f, 0.02952407f, -0.02097979f, -0.10016150f, -0.11949690f, 
    -0.23982687f, 0.41564944f, 0.07020615f, 0.19207005f, -0.22241297f, 0.00712409f, -0.14981943f, 0.32634237f, 
    -0.07869331f, -0.08953448f, -0.00096015f, 0.06303390f, -0.03764281f, 0.16754310f, -0.18474674f, -0.23203735f, 
    0.14218441f, -0.00646550f, -0.00067620f, -0.06360530f, -0.17253502f, 0.07779799f, -0.08074113f, -0.00094979f, 
    0.04050317f, -0.24724171f, 0.28847879f, 0.40483618f, 0.25960299f, -0.12707569f, 0.06915054f, -0.20903584f, 
    -0.01832528f, 0.01189936f, 0.04988765f, 0.06636993f, 0.02376864f, -0.13326760f, 0.19274531f, -0.22282031f, 
    -0.16511747f, 0.01247781f, -0.02256510f, -0.11306880f, -0.03971328f, -0.01216762f, 0.19238335f, 0.21860810f, 
    0.60682088f, -0.35497054f, 0.17151196f, -0.36101118f, -0.23309974f, 0.06515348f, -0.16493195f, -0.01221216f, 
    -0.13889408f, 0.02316745f, 0.06046810f, -0.00558283f, -0.19911355f, -0.43539724f, 0.35180897f, -0.18903741f, 
    -0.01790646f, 0.12924069f, -0.17830688f, -0.04950486f, -0.01737175f, -0.05326802f, 0.04537541f, 0.02932574f, 
    -0.06806879f, 0.40797123f, 0.67775375f, 0.32521701f, 0.03334789f, -0.08937795f, 0.16165645f, 0.11518785f, 
    0.03081515f, 0.03410627f, -0.08559552f, -0.04148575f, -0.41619551f, -0.21963948f, 0.08055434f, 0.21831995f, 
    -0.10219750f, 0.05262077f, 0.18300049f, 0.01264428f, -0.18561713f, 0.03238058f, 0.09056991f, -0.08929412f, 
    -0.00325461f, 0.07415779f, -0.01483761f, -0.07739261f, 0.06651369f, 0.06090734f, 0.30211401f, 0.19803800f, 
    -0.04143514f, 0.04534793f, -0.16817722f, -0.09561720f, -0.18861471f, 0.48782387f, -0.32339063f, 0.57383209f, 
    0.04863991f, 0.01860908f, 0.17326358f, 0.04125250f, 0.02603676f, 0.01332327f, 0.02060334f, 0.07265414f, 
    -0.17083238f, 0.00747305f, -0.20897019f, -0.01781079f, 0.01979093f, -0.03498982f, -0.19762802f, 0.25097573f, 
    -0.05686542f, -0.03482077f, -0.08546090f, -0.06527390f, 0.05271603f, 0.14265606f, 0.12662405f, 0.45917869f, 
    0.32770109f, -0.13211527f, 0.24511571f, 0.19531241f, -0.12466346f, -0.04064545f, 0.16928926f, 0.05512265f, 
    0.27755398f, 0.07945105f, -0.38404354f, -0.37552491f, -0.34982458f, 0.09528653f, -0.12019596f, -0.03986593f, 
    -0.00645739f, 0.01543895f, 0.15554795f, -0.05428214f, 0.17216860f, 0.32389280f, 0.21386880f, 0.02429326f, 
    -0.05866621f, -0.04994101f, -0.09997493f, 0.20136428f, -0.02493680f, -0.02086096f, 0.15843719f, 0.01041788f, 
    -0.20584323f, -0.12140450f, -0.73261529f, 0.17347790f, 0.17936657f, 0.10400295f, 0.22423254f, 0.18628345f, 
    -0.04336399f, 0.21682762f, -0.31166738f, 0.01952960f, 0.27491820f, 0.11945347f, -0.11364398f, 0.14401895f, 
    0.03615244f, 0.12709776f, 0.22789876f, -0.16222057f, 0.02571124f, -0.00379815f, -0.26804650f, -0.12310354f, 
    0.08869794f, 0.53630573f, -0.54116738f, 0.06584695f, -0.03476136f, -0.20634474f, -0.05561160f, -0.50219971f, 
    0.13672204f, -0.00478784f, 0.06465399f, -0.40778482f, 0.14155059f, 0.50915593f, -0.00585561f, -0.08786209f, 
    -0.07190888f, -0.26991549f, -0.15954253f, -0.06164294f, -0.20554897f, 0.06867366f, 0.16418825f, -0.15783377f, 
    -0.04908097f, 0.62555522f, -0.25301808f, -0.12434804f, 0.12196068f, -0.01507012f, -0.04540781f, 0.24474706f, 
    0.00602705f, 0.06313923f, 0.07398595f, -0.05435295f, 0.03316104f, -0.15327804f, 0.03860478f, 0.21242927f, 
    -0.10972168f, 0.14940152f, 0.05406187f, -0.01220429f, -0.04051875f, -0.03016244f, -0.08843423f, -0.11159726f, 
    -0.17268689f, -0.07156584f, 0.54045367f, 0.02083608f, 0.01638925f, -0.26472655f, -0.21428229f, -0.11957544f, 
    0.04918662f, -0.11608705f, 0.04953418f, 0.16892168f, 0.02081941f, 0.10257958f, -0.09654178f, 0.32020074f, 
    0.02864102f, 0.18771540f, 0.09955376f, 0.09171811f, 0.02232810f, 0.06872410f, -0.06762924f, 0.03927029f, 
    0.68037105f, -0.09090643f, 0.17262930f, 0.24073769f, 0.11632758f, 0.27398407f, 0.06513524f, 0.08121339f, 
    0.08393632f, 0.00965798f, 0.14890091f, 0.04020580f, 0.52857894f, 0.25368068f, -0.03184931f, -0.01754345f, 
    0.28339648f, 0.05180486f, 0.25327575f, 0.20139582f, 0.07368351f, -0.19074264f, 0.04167113f, 0.04858297f, 
    -0.44213325f, 0.33215183f, 0.05906086f, -0.17772689f, 0.01272367f, -0.19546860f, -0.32357645f, 0.07462161f, 
    0.14083341f, -0.06064942f, 0.23671255f, 0.10929052f, -0.12144734f, -0.17669882f, -0.16964139f, 0.00023567f, 
    -0.04681419f, 0.20001052f, 0.24875160f, -0.01988203f, 0.02497722f, 0.13940713f, 0.11548103f, 0.11318368f, 
    0.32323018f, -0.06779169f, -0.42240208f, 0.01906744f, 0.22689347f, -0.03799595f, 0.45053688f, 0.03123287f, 
    -0.06701154f, 0.19694573f, 0.02569458f, 0.08480380f, 0.22366638f, -0.21816114f, 0.00605849f, -0.13504121f, 
    0.05836323f, 0.09782676f, -0.06364369f, 0.20017974f, 0.10948159f, -0.02072612f, -0.00752580f, 0.16469325f, 
    0.01828116f, -0.03820802f, -0.02055073f, -0.01921592f, 0.03064383f, -0.05139280f, 0.02470207f, -0.03088683f, 
    -0.05616020f, -0.05046267f, -0.06963354f, 0.00468344f, 0.02474515f, -0.02361712f, -0.01020038f, -0.01292536f, 
    0.01301579f, 0.03753265f, 0.00631953f, -0.02512382f, -0.07513015f, -0.07012223f, 0.01066834f, -0.06618374f, 
    -0.01013207f, 0.02355619f, -0.06953849f, -0.07423244f, -0.01961482f, 0.05910400f, 0.06683769f, 0.03940534f, 
    0.01326976f, -0.02563873f, 0.01252723f, 0.06292449f, 0.05465193f, 0.04397334f, -0.00246428f, 0.04117829f, 
    -0.06026013f, -0.04807043f, -0.00571061f, -0.05225082f, -0.06941900f, 0.03892607f, 0.04291495f, 0.00293646f, 
    -0.05557732f, 0.01966945f, -0.01742900f, 0.04932414f, -0.06717112f, 0.00396072f, -0.03640987f, 0.00038059f, 
    0.02744538f, -0.05731975f, 0.00885666f, 0.03003730f, -0.02175588f, -0.04874365f, 0.02216521f, 0.02855420f, 
    0.04404022f, -0.04164268f, -0.00996729f, -0.01805619f, -0.03742658f, -0.05947239f, 0.03860401f, -0.04150851f, 
    -0.05639542f, -0.03937835f, -0.02917998f, -0.01939838f, -0.07900284f, 0.05996640f, 0.02697255f, -0.06339720f, 
    0.03720887f, 0.03232686f, 0.00254955f, 0.01796266f, -0.05628452f, -0.01068489f, 0.01706002f, -0.00670047f, 
    0.03375447f, -0.03588916f, -0.02546741f, -0.00151012f, -0.03856704f, -0.01602049f, -0.01173197f, 0.06213386f, 
    -0.06332237f, 0.00761782f, 0.00787306f, 0.05036415f, -0.02898266f, -0.04927032f, -0.07173814f, -0.06127707f, 
    -0.07402147f, 0.01103997f, -0.00633818f, -0.01471253f, -0.03253726f, 0.04095347f, -0.02280436f, -0.06390866f, 
    0.05479695f, -0.06598192f, -0.06980664f, -0.04838401f, 0.03513598f, 0.05193081f, -0.05304493f, -0.05847001f, 
    0.02336557f, -0.01535811f, -0.07539275f, -0.03664455f, -0.04136197f, -0.01314713f, -0.02361999f, -0.03236277f, 
    -0.04462051f, -0.06781909f, -0.01675652f, -0.00816414f, -0.04810603f, 0.00576289f, -0.06756337f, -0.07064214f, 
    0.06367908f, -0.04443932f, -0.00838159f, 0.04218780f, -0.02215027f, 0.04826349f, 0.03065022f, 0.01449451f, 
    -0.04497115f, -0.03219447f, -0.07759656f, -0.07329726f, -0.00642727f, 0.06086769f, -0.07769931f, -0.07252100f, 
    0.01912612f, -0.06116528f, 0.00072242f, -0.02563196f, 0.05636630f, -0.02611640f, -0.01210675f, -0.03096236f, 
    -0.04101516f, -0.00146652f, -0.02277930f, -0.03911676f, 0.03527324f, 0.06371725f, -0.07605922f, -0.05284456f, 
    0.05453569f, -0.00994676f, -0.05522706f, -0.01097922f, 0.03530836f, -0.04522668f, -0.05270720f, -0.06926626f, 
    0.04007848f, -0.01002425f, 0.03220671f, -0.04259518f, 0.03810884f, -0.01908665f, -0.03398840f, 0.03438084f, 
    0.01302671f, 0.06178227f, 0.00767493f, 0.04608735f, 0.05872912f, -0.04016999f, -0.05285681f, -0.03853756f, 
    0.02284042f, -0.02213933f, -0.00354306f, 0.04084843f, -0.03373954f, 0.02074381f, -0.05493858f, 0.02107714f, 
    -0.03474278f, 0.01164095f, 0.00368258f, -0.00668693f, -0.01729787f, 0.01998425f, -0.06405784f, -0.03088790f, 
    -0.07111649f, -0.06067131f, -0.03164826f, 0.01387113f, -0.00028711f, -0.07408725f, -0.05562524f, 0.00499711f, 
    -0.02870956f, -0.04386829f, 0.00438302f, 0.05842474f, 0.01292802f, 0.04590711f, -0.08383672f, -0.01315382f, 
    -0.05138823f, -0.06311768f, -0.04019290f, 0.05527769f, 0.04381795f, -0.04079385f, 0.00369467f, 0.02524255f, 
    -0.01082111f, 0.00044539f, 0.02415547f, -0.02845931f, -0.01220114f, -0.06279611f, 0.02902706f, 0.03388170f, 
    -0.01754202f, 0.05224345f, -0.06576087f, -0.01532902f, 0.04074301f, 0.05986435f, -0.01684855f, -0.04408015f, 
    -0.04590853f, 0.03292752f, -0.04507893f, -0.08393343f, -0.02769162f, -0.06658025f, -0.04759470f, -0.00548716f, 
    -0.03931978f, 0.04387093f, 0.04452278f, 0.05908796f, -0.06743915f, 0.04006682f, -0.01894321f, -0.05363358f, 
    -0.09078150f, -0.04810053f, -0.08207267f, 0.00256482f, -0.01867687f, -0.01375253f, -0.01172637f, -0.03546088f, 
    -0.05967090f, -0.06221472f, -0.01825984f, 0.01324367f, -0.00282114f, -0.04433113f, -0.06436609f, 0.01506170f, 
    -0.02226596f, 0.03173825f, -0.03130399f, 0.00350978f, -0.07451921f, -0.04229616f, -0.00850206f, 0.02395846f, 
    0.05306159f, -0.02494070f, 0.01579881f, -0.04753517f, -0.03806247f, -0.02834536f, -0.05861493f, 0.04771993f, 
    -0.06561960f, 0.04484794f, 0.01400849f, -0.04824857f, -0.04932107f, -0.09275372f, -0.04260511f, -0.06258485f, 
    -0.04058885f, 0.00754284f, 0.00775847f, 0.02424480f, -0.01946321f, -0.04326470f, -0.01465086f, 0.01139052f, 
    -0.08152377f, -0.00199121f, 0.02036227f, 0.00533571f, -0.00795733f, -0.08162481f, -0.04717048f, -0.02317241f, 
    -0.08434025f, 0.00673839f, -0.06009015f, -0.09169358f, -0.07624898f, -0.10436828f, -0.08552309f, 0.03104562f, 
    -0.08841489f, 0.03081167f, -0.08101440f, 0.06495508f, 0.03539741f, -0.02029717f, -0.06814086f, -0.04127808f, 
    -0.03195394f, -0.06813368f, -0.03188648f, 0.04774363f, -0.05783304f, -0.01866137f, -0.03857023f, -0.01809093f, 
    -0.07654883f, -0.05536174f, 0.00992379f, -0.04841734f, -0.05868358f, -0.02292877f, -0.02802210f, -0.04294659f, 
    -0.01352092f, -0.00612732f, -0.03848923f, 0.03056260f, -0.03012718f, -0.01458290f, 0.03446284f, 0.03009419f, 
    0.04552896f, 0.02657743f, 0.00344751f, 0.04647450f, -0.00902962f, 0.03265957f, 0.02458685f, -0.07492749f, 
    -0.01519525f, -0.02798553f, 0.04358583f, 0.00558597f, -0.06757239f, -0.04285526f, -0.04088114f, 0.04513688f, 
    -0.08979550f, -0.08029255f, -0.06967103f, 0.00119174f, -0.08220337f, -0.00365635f, -0.06438995f, -0.00996646f, 
    0.14696056f, 0.26892135f, 0.03535119f, 0.08533648f, 0.04138747f, -0.06891935f, 0.00044918f, -0.08887425f, 
    -0.11580610f, -0.10425287f, -0.12318677f, 0.06765378f, 0.35321686f, 0.05914490f, 0.05895786f, 0.15344201f, 
    -0.02478340f, 0.05205884f, 0.06158250f, 0.06056754f, 0.03825914f, 0.24122943f, 0.24763204f, 0.36041528f, 
    -0.00629639f, 0.14256296f, 0.05453261f, 0.25981146f, -0.05907418f, 0.12510467f, 0.16408770f, 0.00026310f, 
    -0.13134006f, 0.12720510f, 0.08769275f, -0.08008981f, -0.64136374f, -0.35663122f, -0.52610952f, -0.49080402f, 
    0.04407123f, -0.16100289f, -0.26827815f, -0.10609350f, 0.06676898f, -0.05204080f, -0.01142813f, -0.10596547f, 
    -0.09902144f, -0.02933229f, 0.12042176f, 0.18542451f, 0.08198131f, -0.06915712f, -0.00989226f, -0.06898727f, 
    0.00605793f, 0.00298200f, -0.02701452f, 0.12323097f, 0.39754477f, 0.22326733f, 0.06939527f, 0.22966756f, 
    0.12352889f, 0.04230935f, 0.06706424f, -0.08612745f, 0.04601159f, 0.02275227f, -0.01436730f, -0.02810411f, 
    -0.46820122f, -0.15289208f, 0.34352911f, 0.35898519f, 0.19137408f, 0.32008159f, -0.00630732f, -0.07894013f, 
    0.08510458f, 0.07710690f, 0.05548328f, 0.08482621f, 0.29236051f, -0.16695429f, -0.02793577f, -0.20218292f, 
    -0.15203084f, 0.00384231f, 0.22603746f, -0.03542320f, 0.06677458f, 0.15186183f, 0.04645979f, 0.05997349f, 
    0.57420206f, 0.09804223f, -0.00455535f, -0.01939639f, -0.05425083f, 0.01711641f, 0.03548561f, 0.06732986f, 
    -0.09828955f, -0.00872789f, 0.11508787f, -0.14099026f, -0.23526417f, -0.13090903f, -0.02588685f, -0.14078602f, 
    0.03040859f, 0.17925316f, -0.07519197f, -0.09234105f, 0.02317177f, -0.03793952f, -0.08253474f, 0.04221444f, 
    -0.31186861f, -0.63520879f, -0.05772851f, -0.60110891f, -0.02799871f, -0.07985871f, -0.16624486f, 0.00046380f, 
    0.07769197f, 0.13498932f, 0.13915497f, 0.10055988f, -0.23932749f, -0.62512988f, -0.49807596f, -0.29609215f, 
    -0.06568197f, -0.00721505f, 0.07501758f, 0.20254050f, 0.01694815f, 0.06650438f, 0.01068295f, 0.05621171f, 
    0.01427024f, -0.03391936f, 0.05165141f, -0.00435102f, -0.02962543f, 0.09991293f, 0.26870245f, 0.03366080f, 
    -0.02738681f, 0.13673326f, -0.17644104f, 0.04051023f, -0.11580264f, 0.04815908f, -0.40609789f, -0.25791889f, 
    -0.10340745f, 0.00016305f, 0.14046283f, 0.14508520f, 0.27845296f, 0.13577808f, 0.02931433f, -0.00154388f, 
    0.06109430f, 0.12397038f, 0.12175523f, -0.04655549f, 0.02965811f, -0.04142720f, -0.06996691f, 0.12225217f, 
    -0.11182915f, -0.10944116f, 0.05646504f, -0.17770743f, -0.03605659f, 0.08424336f, 0.00407403f, 0.04943315f, 
    0.10260115f, -0.19360828f, 0.12866396f, 0.23816130f, -0.19691050f, 0.09929677f, 0.15041086f, 0.12111382f, 
    0.12882297f, -0.01751880f, 0.10467698f, 0.09665618f, 0.05961076f, -0.11213721f, 0.17835848f, 0.04584446f, 
    0.20778556f, 0.12313779f, 0.18825631f, -0.06666639f, 0.04669661f, -0.00583567f, 0.07906840f, -0.01373977f, 
    0.04266157f, 0.05125782f, 0.02987534f, -0.04501050f, 0.11254943f, 0.15436779f, 0.37609285f, 0.28216022f, 
    0.11445421f, -0.09068383f, -0.14491786f, -0.08482050f, 0.21739250f, 0.07111510f, -0.07873696f, 0.12294457f, 
    0.03267462f, -0.07730723f, -0.26740828f, -0.10737573f, 0.07735628f, -0.03063558f, 0.17734970f, -0.19102752f, 
    -0.26041234f, -0.00559258f, -0.27538010f, -0.16229968f, -0.13838980f, -0.02316939f, -0.11181687f, -0.20136270f, 
    0.28761747f, 0.51845700f, 0.14274734f, -0.02553747f, -0.18668795f, 0.01662453f, -0.05433270f, 0.30022344f, 
    -0.11853606f, 0.00423133f, -0.05797324f, 0.00427456f, 0.49743760f, 0.13286120f, 0.16873567f, 0.05624524f, 
    0.04869208f, -0.09967013f, 0.04253524f, -0.06276148f, -0.02517906f, 0.09812016f, -0.04083024f, -0.06081050f, 
    -0.01361015f, -0.04624704f, 0.21258171f, 0.12231173f, -0.30614340f, -0.05427253f, 0.01989069f, -0.15861002f, 
    -0.00420691f, -0.03530051f, -0.12013066f, 0.04548462f, 0.17419678f, -0.25618526f, 0.23372607f, -0.30370897f, 
    0.11634959f, 0.10736658f, 0.03130050f, -0.10775546f, 0.01989062f, -0.05304059f, 0.27480388f, 0.11856402f, 
    0.33278269f, 0.14389023f, 0.54899156f, 0.03235770f, 0.04546281f, -0.00718778f, 0.05412411f, -0.02557152f, 
    0.05785922f, 0.11903903f, -0.02497455f, 0.09558555f, 0.04623090f, -0.16093151f, 0.18159822f, -0.29472136f, 
    -0.32189554f, 0.03007465f, -0.08225500f, -0.08002344f, -0.07258422f, 0.12643194f, 0.01171810f, -0.01410328f, 
    -0.51238674f, -0.02705053f, 0.01342708f, 0.14554027f, -0.13240321f, -0.06153961f, 0.11066797f, -0.16956642f, 
    -0.07992247f, 0.02313547f, -0.02434297f, 0.05810533f, -0.07229654f, -0.05724983f, 0.03882982f, 0.38992634f, 
    -0.00871127f, 0.11336044f, 0.15037893f, -0.17760803f, -0.01734655f, 0.06268852f, 0.06747613f, -0.09556755f, 
    0.12424275f, 0.26848492f, 0.00747159f, 0.11950332f, 0.08649567f, -0.07309981f, -0.03922296f, 0.12556340f, 
    -0.10280535f, -0.03454128f, -0.08703979f, -0.05746785f, -0.09577031f, -0.26395702f, 0.13196704f, 0.18242891f, 
    -0.02807547f, -0.05733047f, 0.03495146f, -0.03572380f, 0.06375176f, 0.08381826f, 0.11202338f, 0.00860308f, 
    -0.10128119f, 0.04912317f, 0.02038114f, 0.02060474f, -0.04121222f, -0.10656478f, -0.13964364f, 0.00646052f, 
    -0.01256437f, -0.16261727f, -0.13952169f, 0.00629515f, -0.31344333f, 0.24134067f, -0.50274312f, 0.03628566f, 
    -0.00422737f, -0.04966014f, 0.02943870f, 0.10945851f, -0.10524797f, 0.00079983f, -0.11287308f, -0.03985197f, 
    0.16091572f, 0.01599929f, 0.11457138f, -0.07725951f, 0.13091803f, -0.02895287f, 0.06658097f, -0.05167312f, 
    -0.02059103f, 0.07014338f, 0.06270477f, 0.04199260f, 0.35538301f, 0.11905684f, -0.23598465f, 0.04746496f, 
    -0.01553196f, 0.06567281f, 0.11086541f, -0.26040307f, 0.04188730f, 0.17860223f, 0.04228510f, 0.25436658f, 
    0.22856183f, 0.23778155f, 0.52657253f, -0.04048252f, 0.11370911f, -0.34382689f, 0.06771649f, 0.11810720f, 
    0.06201626f, 0.12388907f, -0.01778733f, 0.04463943f, -0.34282035f, -0.12194598f, 0.06155302f, 0.24529758f, 
    -0.09697907f, -0.08352701f, -0.04307056f, 0.13237180f, 0.04696355f, 0.00441681f, 0.03704148f, 0.01490902f, 
    -0.57129228f, 0.08236697f, -0.02786882f, -0.01724987f, -0.08097643f, -0.04378460f, -0.04574493f, 0.29972997f, 
    -0.02592367f, -0.10666712f, -0.01580539f, -0.01738303f, 0.26883769f, -0.29141805f, 0.16415651f, -0.15383950f, 
    -0.01338836f, -0.08378209f, -0.10646300f, 0.04072559f, 0.10795339f, 0.03314743f, -0.02514629f, -0.08903977f, 
    -0.14965102f, -0.73481667f, 0.34253621f, 0.23948404f, 0.20670059f, 0.28590664f, 0.05240481f, -0.06582836f, 
    0.01310171f, -0.01974793f, 0.01822477f, 0.13389304f, -0.16721822f, 0.13674735f, -0.03871081f, 0.11309275f, 
    0.01858276f, 0.10172802f, 0.14709432f, -0.08488651f, 0.13226853f, 0.09909730f, 0.00720817f, 0.08616489f, 
    0.24307485f, -0.03022939f, -0.30284849f, -0.15454592f, -0.21595693f, -0.13906530f, -0.07082596f, -0.13233311f, 
    0.05772978f, -0.03528793f, -0.22169609f, -0.19198677f, -0.32905206f, -0.23665629f, 0.42722267f, 0.09949599f, 
    0.07315478f, -0.05764091f, 0.07132195f, 0.16817932f, 0.08528848f, -0.07995167f, 0.02124697f, -0.02480883f, 
    -0.08951849f, 0.25564209f, 0.23987962f, 0.25048003f, -0.05929877f, -0.24121185f, 0.09324785f, 0.11532762f, 
    0.09383690f, -0.04175736f, 0.04669954f, 0.10579474f, -0.56359363f, -0.16179268f, 0.00186108f, 0.13834454f, 
    -0.09605921f, 0.06983250f, -0.21016736f, 0.12084778f, -0.04367796f, 0.15101770f, 0.07178306f, 0.06507484f, 
    0.05075155f, -0.09393971f, -0.17436865f, -0.00504253f, 0.20802100f, 0.12005908f, 0.17658211f, -0.00727859f, 
    0.01488292f, -0.04201077f, -0.17335679f, 0.04523773f, -0.08505747f, 0.26133466f, 0.39244613f, 0.12160201f, 
    0.02912873f, -0.20075122f, 0.02158532f, -0.00962602f, 0.04522012f, 0.04510690f, -0.01292542f, -0.05907235f, 
    0.04726165f, 0.04604871f, -0.08157828f, -0.05500675f, -0.02022067f, -0.01671838f, -0.11764719f, 0.08543804f, 
    0.04508765f, 0.08702239f, 0.11302759f, 0.15282108f, 0.70397305f, -0.02586235f, 0.44824734f, 0.14911702f, 
    0.24801750f, -0.05866386f, 0.05677095f, -0.08878729f, -0.00395894f, -0.02835316f, -0.03749369f, 0.19388747f, 
    -0.37529695f, -0.09851887f, -0.24599183f, 0.12866428f, 0.04901288f, -0.04250379f, -0.08667850f, 0.01051376f, 
    0.24563147f, 0.03581923f, 0.00928494f, 0.17451440f, -0.60400862f, -0.37846670f, -0.12242479f, 0.12109649f, 
    0.04867908f, 0.01022776f, -0.06836475f, 0.06035082f, 0.13874801f, -0.07649338f, -0.35958141f, -0.41071942f, 
    0.09705383f, -0.14093263f, -0.03713102f, -0.16309117f, -0.08158497f, 0.23193869f, -0.12818100f, -0.05250934f, 
    0.26314232f, 0.02630701f, 0.07634048f, 0.11710431f, 0.26360881f, 0.20542566f, 0.27878970f, -0.06654130f, 
    0.15140413f, 0.20909631f, 0.16557051f, 0.21450047f, -0.02853439f, -0.07678141f, -0.03267768f, 0.08189162f, 
    0.47779498f, -0.81422246f, 0.31518516f, 0.11797916f, 0.03814192f, 0.01822402f, 0.04502566f, -0.00132963f, 
    -0.09386597f, 0.13655810f, 0.01138894f, 0.07139035f, -0.15548910f, -0.28129411f, -0.07593095f, 0.02027588f, 
    -0.14096342f, -0.07374153f, -0.04286223f, 0.03456451f, 0.04625716f, -0.04985031f, 0.02059327f, 0.00979780f, 
    0.30967668f, 0.41191733f, 0.13510965f, -0.21363944f, -0.06197386f, -0.09161937f, 0.22829537f, 0.16467331f, 
    0.00792760f, -0.01733262f, 0.02147576f, -0.16718215f, 0.22272897f, 0.32038593f, 0.01876199f, 0.00975044f, 
    0.25051442f, 0.10161763f, 0.10245794f, 0.03771601f, 0.11550076f, -0.05331922f, -0.11581702f, -0.15022001f, 
    -0.45582709f, 0.08255862f, -0.30117807f, 0.27822497f, 0.11729903f, 0.09345637f, 0.09682795f, 0.03963315f, 
    0.09996033f, -0.02687352f, 0.10224482f, 0.06916537f, 0.36419132f, 0.45891920f, -0.16871059f, -0.11296567f, 
    0.18036376f, 0.25168344f, 0.19372211f, -0.08854748f, 0.05590117f, 0.08535095f, -0.03877229f, 0.14598738f, 
    -0.18180002f, 0.12260349f, -0.09839493f, -0.20519535f, 0.05241104f, 0.04609322f, 0.11827155f, 0.10563662f, 
    -0.12861454f, 0.03068730f, -0.16078080f, -0.19988176f, 0.11698779f, 0.18618076f, 0.37488356f, -0.13655727f, 
    0.18164000f, 0.01639833f, 0.04002916f, 0.14364952f, -0.04777350f, -0.00342433f, -0.10758050f, -0.00615393f, 
    0.10945449f, -0.18203790f, 0.16063266f, -0.03425737f, 0.09367832f, 0.08155833f, -0.10860878f, 0.22324863f, 
    0.11929861f, 0.04481416f, 0.22327681f, -0.05833862f, 0.50542051f, -0.04810514f, 0.14035560f, -0.19667055f, 
    0.06776039f, 0.08480892f, -0.03295423f, 0.18482549f, -0.04087047f, -0.12567145f, -0.07363867f, -0.11773595f, 
    0.02408132f, -0.06853799f, 0.09721462f, 0.04039707f, -0.28108063f, 0.00595021f, 0.07455350f, -0.08767387f, 
    0.01141977f, -0.02970091f, -0.13655840f, -0.21589655f, -0.52398473f, 0.13851820f, -0.02364217f, -0.10950175f, 
    -0.26513764f, 0.02874825f, -0.11986932f, 0.03030791f, 0.16616662f, -0.01392611f, 0.16625944f, -0.08718602f, 
    0.43470460f, -0.00524329f, -0.13929099f, -0.17373212f, -0.13219097f, -0.02719002f, 0.07954752f, -0.03694927f, 
    -0.02701759f, -0.01559748f, 0.10244014f, 0.02992173f, 0.25081885f, 0.19537112f, 0.00322284f, 0.04588215f, 
    0.21053326f, -0.11833009f, -0.14004092f, -0.03869291f, 0.04242145f, 0.01831858f, 0.11475695f, 0.07447396f, 
    0.23008545f, -0.12666565f, -0.16912894f, 0.20264316f, 0.10750227f, 0.07970338f, 0.00980514f, 0.02844268f, 
    0.16054335f, 0.04623305f, -0.26482835f, -0.02829142f, -0.17575546f, 0.03986539f, 0.25279316f, 0.18405040f, 
    -0.12617239f, -0.00310153f, 0.25863352f, -0.16218258f, 0.04606678f, -0.03920969f, -0.13996752f, -0.09915661f, 
    0.13868417f, 0.33543649f, -0.49833187f, 0.04516550f, -0.43422678f, 0.00752355f, -0.12261616f, -0.19750163f, 
    0.01325502f, -0.05860209f, 0.03647636f, -0.19970290f, 0.83953500f, 0.37954181f, -0.15048036f, -0.14262018f, 
    -0.03591677f, -0.18959150f, -0.07474376f, -0.03523779f, -0.00861310f, 0.00794405f, 0.01289557f, -0.14837325f, 
    -0.14911425f, 0.14886644f, 0.05224710f, -0.20834456f, 0.10494173f, -0.15548861f, 0.03444558f, 0.04643393f, 
    -0.01922729f, 0.05101141f, 0.12650509f, 0.09332725f, 0.00729738f, -0.05707717f, 0.14302476f, 0.12381741f, 
    -0.05276161f, 0.02388442f, 0.06920207f, -0.11455036f, 0.05183912f, -0.07777367f, 0.12253498f, 0.04716970f, 
    0.39892688f, -0.23276700f, 0.52389431f, -0.02881638f, 0.05911862f, 0.01233267f, -0.10829183f, -0.03760471f, 
    0.08308776f, -0.02491263f, -0.01984211f, 0.00214730f, -0.14983746f, -0.10523698f, 0.46588126f, 0.07141826f, 
    -0.07012039f, 0.09540126f, 0.00828712f, -0.08714226f, -0.01641729f, -0.10513742f, 0.05967699f, 0.14104189f, 
    -0.09091896f, 0.22600189f, 0.48970702f, 0.36115605f, -0.14192121f, -0.14677677f, 0.10795234f, -0.10337960f, 
    0.10586011f, -0.15914573f, 0.07666427f, -0.00914159f, -0.23692736f, -0.11921843f, 0.29734331f, 0.15381631f, 
    -0.00914258f, -0.11226544f, 0.06226039f, 0.10947461f, 0.14092219f, -0.14055443f, -0.15455630f, -0.00542226f, 
    0.08594833f, 0.37164998f, 0.03893920f, -0.12034671f, -0.00188589f, -0.09001382f, -0.04850186f, 0.20236780f, 
    0.01274582f, -0.14221199f, -0.03319561f, -0.00112871f, -0.11051801f, 0.02405295f, 0.18779191f, -0.25402489f, 
    -0.17982210f, 0.00986825f, 0.22350407f, -0.01453967f, 0.20390487f, 0.17735110f, 0.01222516f, 0.03297489f, 
    0.05175243f, 0.09021924f, -0.13724118f, 0.18031335f, 0.06518809f, -0.14703271f, 0.07585146f, 0.11319199f, 
    -0.09293380f, 0.09220587f, -0.05721803f, 0.07248320f, 0.06888267f, 0.07709752f, -0.07821038f, -0.12253697f, 
    0.13521527f, -0.03623324f, -0.22785692f, 0.03654205f, 0.05616776f, -0.33503756f, -0.00682707f, 0.24747294f, 
    0.09492201f, -0.09468509f, -0.05035333f, -0.04307967f, 0.02789393f, 0.04602884f, 0.01944263f, 0.07852101f, 
    0.17859595f, -0.00068551f, -0.06926624f, 0.08202159f, 0.06181065f, -0.05885709f, 0.14303909f, 0.29738408f, 
    -0.10706942f, -0.07945886f, 0.14047816f, 0.11531695f, 0.05545861f, -0.09821581f, 0.18584654f, -0.02476876f, 
    0.06669330f, -0.18888184f, -0.11012464f, 0.02517812f, 0.06779496f, 0.13455723f, 0.08468829f, -0.12805638f, 
    0.16758198f, -0.00218845f, 0.12115721f, 0.14707369f, 0.11706603f, -0.07879836f, -0.29399788f, 0.04767162f, 
    0.20769008f, 0.16397470f, 0.02314786f, -0.02484447f, -0.09519745f, -0.05292355f, -0.04163503f, 0.03310378f, 
    0.72349769f, -0.04789627f, 0.19853282f, -0.08022969f, 0.05410340f, -0.07841297f, 0.04954621f, -0.13510051f, 
    -0.03515126f, -0.05034711f, -0.15068732f, -0.07928612f, 0.40418595f, 0.23840944f, 0.45693696f, 0.49854642f, 
    -0.03126908f, -0.02436102f, 0.04648719f, -0.08572071f, 0.01557230f, -0.00314480f, 0.06855030f, 0.03298896f, 
    0.21133322f, 0.23806480f, 0.10452640f, -0.07675205f, -0.26758605f, 0.17373988f, 0.10691685f, -0.02325444f, 
    -0.01910666f, -0.02075026f, -0.10231918f, -0.00719290f, 0.11431561f, 0.03138677f, -0.07608671f, 0.01881153f, 
    -0.01596469f, -0.12049915f, 0.00974730f, 0.21864466f, -0.06218081f, 0.07488296f, 0.07989635f, -0.18133400f, 
    0.14143066f, 0.38489214f, 0.15393128f, 0.19311298f, 0.18228677f, -0.02603311f, -0.03347590f, 0.02235266f, 
    0.13142985f, 0.08117431f, 0.14897351f, -0.06822973f, 0.16901600f, 0.16681835f, 0.01634240f, 0.34695199f, 
    -0.25030220f, -0.11522552f, 0.14009517f, -0.07130394f, -0.02701999f, 0.03826243f, 0.07984636f, 0.01976553f, 
    0.03713971f, -0.66840017f, -0.80973697f, -0.36583266f, -0.14376646f, 0.10582110f, 0.12179663f, 0.00383245f, 
    -0.02069787f, -0.06735341f, -0.04677399f, 0.00260796f, 0.19976047f, 0.11289383f, -0.45741469f, -0.13603409f, 
    -0.10936800f, -0.01754963f, -0.03133764f, 0.15936626f, 0.02180580f, -0.07190944f, -0.09210777f, 0.20264380f, 
    0.16889355f, 0.18713883f, 0.00085720f, 0.05489000f, -0.01374053f, 0.00297952f, -0.03157131f, -0.03600831f, 
    -0.11028545f, 0.10125137f, -0.05980862f, -0.00539708f, -0.15942626f, -0.67400497f, 0.10967964f, -0.09318199f, 
    0.05911651f, 0.14035140f, -0.02497007f, 0.08725867f, 0.06664336f, 0.07949235f, 0.09039546f, -0.10756543f, 
    0.43226004f, 0.03557949f, -0.08551133f, -0.12800898f, 0.05429948f, 0.12812452f, 0.02253349f, -0.06120593f, 
    -0.02983800f, 0.00023008f, 0.17172615f, 0.07231067f, -0.03103019f, 0.08909787f, -0.24191836f, -0.24890648f, 
    -0.18163198f, 0.00555444f, 0.09523582f, 0.07630637f, 0.08837151f, 0.14468993f, 0.00070458f, -0.11331785f, 
    -0.72179973f, 0.28463417f, -0.32243112f, -0.24159521f, 0.03893321f, 0.11830452f, -0.00376204f, 0.16620246f, 
    0.05911297f, -0.06232356f, -0.03688093f, 0.01166821f, -0.34942102f, -0.05056262f, 0.00295363f, 0.23319598f, 
    -0.01111151f, 0.07445262f, 0.14264637f, -0.10310999f, 0.14262295f, 0.04931095f, -0.16559394f, -0.04404752f, 
    -0.00688015f, 0.01353433f, 0.22123790f, -0.07172488f, -0.02410506f, 0.01036760f, -0.39706847f, -0.20452110f, 
    -0.01844848f, 0.12817149f, 0.07838285f, 0.03260176f, -0.05662303f, -0.02228301f, -0.04404288f, 0.09920748f, 
    0.11638375f, -0.10938242f, -0.03848100f, 0.25127769f, 0.01911649f, -0.04493878f, -0.06650274f, 0.03618370f, 
    -0.16587330f, -0.47626039f, 0.32505843f, 0.04339499f, 0.53335881f, 0.02716047f, 0.08368827f, 0.03195124f, 
    -0.13444372f, -0.10919013f, -0.19943160f, 0.11380834f, 0.04190623f, 0.16399610f, -0.01204880f, -0.02383016f, 
    0.24435788f, -0.04542359f, -0.09189332f, 0.11453743f, -0.03409087f, -0.11919900f, -0.00350859f, -0.20571975f, 
    -0.02282689f, 0.00152922f, 0.59790814f, -0.15899812f, -0.01649207f, 0.24929310f, 0.07108075f, 0.21867950f, 
    0.06330138f, 0.10907194f, 0.08823034f, -0.07937348f, -0.04678737f, 0.19487922f, 0.06120681f, 0.09806798f, 
    0.15024078f, 0.01537521f, 0.10187588f, 0.05586735f, 0.22491693f, 0.08563086f, 0.07137041f, -0.12478135f, 
    -0.28730103f, 0.02467191f, -0.52948552f, 0.22046863f, 0.09704646f, -0.03746102f, -0.16783036f, -0.06832063f, 
    0.21606009f, 0.03035075f, 0.11676686f, -0.11739878f, 0.09224050f, 0.35221654f, 0.37363011f, 0.09865363f, 
    0.08708895f, 0.08206473f, 0.05740753f, 0.02910364f, -0.06901761f, 0.00015044f, -0.03269780f, -0.14559962f, 
    -0.10745316f, -0.31304377f, -0.07392690f, 0.00268906f, 0.04730797f, -0.11107913f, 0.01749869f, 0.13883667f, 
    0.14073862f, -0.19239542f, 0.02935016f, 0.03257579f, -0.56617677f, 0.03507102f, 0.03391449f, -0.25085273f, 
    0.01127327f, -0.02572675f, -0.12973596f, 0.16408543f, -0.10806591f, 0.13705668f, -0.01877440f, 0.28136155f, 
    0.19539702f, -0.61938709f, 0.14633080f, -0.07068030f, 0.08696976f, 0.14690754f, 0.16553020f, 0.23498413f, 
    0.20694461f, 0.02716223f, -0.04746074f, -0.09356526f, -0.05471671f, 0.04914106f, 0.35588160f, -0.17552125f, 
    0.07825197f, -0.00394516f, 0.02420000f, 0.08343206f, 0.11747965f, -0.13457286f, 0.05617112f, 0.05581024f, 
    0.45232555f, 0.20276335f, 0.03687153f, 0.11298861f, 0.02847569f, -0.11657974f, 0.10210934f, -0.11725513f, 
    0.08266445f, 0.00339067f, -0.12612425f, -0.16026293f, -0.16614398f, 0.04465171f, 0.00602017f, -0.23004428f, 
    0.12432634f, -0.00461192f, -0.02851233f, 0.04592381f, 0.10613481f, 0.02066861f, 0.30230889f, 0.02114282f, 
    -0.14781368f, -0.08900395f, 0.00807587f, 0.07782917f, -0.04249487f, 0.01326093f, 0.01740616f, -0.08378462f, 
    0.11286274f, 0.15719736f, 0.15692830f, 0.10477268f, 0.10074276f, 0.16409837f, 0.28155413f, -0.10922229f, 
    -0.05142194f, -0.01463026f, -0.09739324f, 0.06733003f, -0.07376807f, -0.01062779f, -0.04102433f, -0.45213777f, 
    -0.08884329f, -0.00055179f, -0.08509570f, 0.21455841f, -0.32711414f, 0.09369120f, 0.28789863f, -0.01610782f, 
    0.10395728f, 0.28644332f, 0.05102202f, 0.15144874f, -0.08244649f, -0.11708414f, -0.17177396f, 0.29881966f, 
    0.04224217f, 0.16109177f, 0.20379105f, 0.20063387f, 0.03212101f, 0.10072524f, 0.09410618f, 0.05487118f, 
    0.40502363f, 0.49544436f, -0.09099957f, 0.13025235f, -0.14003183f, -0.15784159f, -0.17533472f, -0.14037384f, 
    -0.05548884f, 0.13781762f, 0.04449288f, 0.08365600f, -0.26479647f, 0.28449345f, 0.07817889f, 0.09200485f, 
    -0.20258102f, -0.16568704f, -0.12833457f, -0.04009227f, -0.04597857f, -0.07184689f, 0.04201079f, 0.00665102f, 
    -0.06187233f, 0.27693239f, 0.28051040f, -0.04098091f, 0.07982948f, 0.10888381f, 0.17719722f, 0.00791073f, 
    0.02834522f, 0.08812007f, 0.02690676f, 0.03582242f, 0.07149605f, -0.21193194f, 0.01214669f, 0.24346557f, 
    0.21022312f, 0.22803578f, 0.08516049f, 0.30741248f, 0.23781098f, -0.00123735f, -0.09365939f, -0.32715005f, 
    -0.01098184f, 0.20720831f, 0.28170276f, -0.00480334f, 0.01271447f, -0.05989583f, -0.11268227f, -0.01685518f, 
    -0.03749683f, 0.13739762f, 0.19160998f, 0.31322339f, -0.10804503f, -0.22827327f, 0.06367697f, 0.41193411f, 
    -0.07692204f, 0.30142242f, -0.01176155f, 0.03420494f, -0.04051565f, 0.02662888f, 0.00912627f, 0.15855213f, 
    0.15378678f, -0.19212292f, -0.19631706f, 0.12738167f, 0.10227278f, 0.13651061f, 0.16709574f, 0.14608578f, 
    -0.13341002f, 0.00407427f, -0.15231898f, -0.22682534f, -0.12779550f, 0.11248112f, 0.07699557f, 0.06201692f, 
    0.03388764f, -0.08535178f, 0.07484909f, -0.08079463f, 0.07270131f, -0.08033034f, 0.04036860f, -0.16203070f, 
    0.01613698f, 0.03572718f, -0.00684254f, 0.05925106f, 0.13398825f, -0.01437320f, 0.11161686f, 0.14986295f, 
    0.03415258f, 0.08656287f, 0.12540442f, 0.02996892f, -0.38899097f, -0.08828620f, -0.26123285f, 0.24727997f, 
    -0.00137095f, 0.21892314f, 0.40989622f, 0.13929145f, 0.24880658f, -0.20945314f, -0.22942811f, -0.13709524f, 
    -0.06657066f, -0.12695974f, -0.18600209f, -0.20419657f, -0.13403718f, -0.23676057f, -0.04828478f, -0.05577421f, 
    0.11147570f, 0.20641248f, 0.18533419f, 0.10518080f, -0.13136059f, 0.06866588f, -0.03766661f, 0.09828808f, 
    0.09320791f, -0.02496483f, 0.09342048f, 0.04943094f, -0.21012199f, -0.12545067f, 0.04171027f, 0.15111794f, 
    -0.18002552f, -0.29410246f, -0.06389191f, -0.00458936f, -0.04327218f, -0.12399518f, 0.06185281f, 0.11437323f, 
    0.03362025f, 0.04228992f, 0.01411840f, -0.04060481f, 0.00588030f, 0.05237398f, 0.07277498f, 0.15340519f, 
    0.15028585f, 0.03955534f, 0.05707084f, 0.03322428f, 0.10879651f, -0.06760529f, 0.17985572f, 0.09238002f, 
    0.00073626f, -0.06696278f, -0.08446182f, -0.23446718f, 0.01683617f, -0.11596476f, -0.07078999f, 0.07060980f, 
    -0.02820436f, -0.00455747f, -0.05067684f, -0.12091612f, 0.00581575f, 0.00210647f, 0.01810129f, -0.13156740f, 
    0.14293312f, 0.24311467f, 0.05244768f, 0.12638268f, 0.05326618f, -0.01710214f, 0.00702478f, -0.02825122f, 
    0.07005184f, 0.19345206f, 0.06908561f, -0.19652236f, -0.01651963f, 0.22778313f, 0.02558187f, 0.07207168f, 
    -0.01757603f, -0.04732437f, 0.08634298f, -0.01824399f, 0.36415076f, 0.03696773f, 0.09377009f, 0.20488995f, 
    0.04921352f, 0.00657325f, 0.06349676f, 0.02451734f, -0.00699838f, -0.04479473f, -0.01272216f, -0.02484193f, 
    -0.08155518f, -0.18433012f, -0.07075002f, -0.24109758f, -0.28428799f, 0.11885330f, 0.19369408f, 0.08208726f, 
    0.07704266f, 0.09869123f, -0.14992286f, -0.04824209f, -0.11811799f, -0.23980634f, 0.05394001f, -0.09307878f, 
    0.25056443f, 0.00969033f, -0.15806144f, 0.10983222f, 0.18531881f, 0.04208077f, 0.08227096f, 0.13123110f, 
    -0.03418194f, 0.19060251f, 0.37875694f, 0.05003751f, 0.14368398f, -0.00896301f, -0.01783551f, -0.04808378f, 
    0.13981977f, 0.00337078f, 0.03320475f, 0.15019947f, 0.19837345f, -0.06970471f, -0.11205888f, 0.15025726f, 
    -0.04485607f, -0.03492256f, 0.13487250f, 0.23689222f, 0.00197506f, 0.04307188f, -0.02586605f, -0.09069303f, 
    0.29292086f, 0.00299609f, -0.37314218f, -0.18988718f, -0.12438054f, -0.20628178f, -0.09439611f, -0.21383178f, 
    0.09603042f, -0.03200719f, 0.10745906f, -0.06933784f, -0.15552929f, 0.26766002f, -0.39237094f, 0.03506724f, 
    0.08873237f, -0.02960253f, -0.11762720f, -0.03886113f, 0.18152383f, 0.07567756f, -0.03302798f, 0.10001750f, 
    0.02392800f, 0.19738980f, -0.06611576f, -0.00864789f, 0.07174401f, -0.13598335f, -0.01581336f, 0.20613380f, 
    -0.15390761f, -0.06456266f, -0.03389615f, -0.01858177f, 0.11672779f, -0.16044386f, 0.29739788f, -0.19165696f, 
    0.04876443f, 0.04167096f, 0.06994485f, -0.00389933f, 0.00329372f, 0.15003078f, -0.06534899f, 0.06663574f, 
    -0.26171386f, -0.04829656f, 0.06950586f, 0.08372983f, -0.17866316f, -0.14337350f, -0.01888272f, -0.16739452f, 
    -0.03591159f, -0.06495616f, -0.14066306f, -0.09677687f, 0.16125901f, 0.30783260f, -0.25205654f, -0.21525925f, 
    -0.18294758f, 0.12488203f, -0.19245595f, -0.19179925f, -0.06518268f, 0.01366029f, 0.01391440f, 0.06233490f, 
    -0.50025356f, 0.25955257f, -0.23843926f, -0.56782895f, 0.08429018f, -0.02182977f, -0.03662144f, -0.01433690f, 
    0.06851743f, -0.20102383f, 0.16663510f, 0.10328428f, 0.32967907f, 0.21762358f, 0.00971029f, 0.23370174f, 
    -0.01103318f, -0.02274974f, 0.20536229f, -0.17096190f, 0.11891270f, 0.16312261f, 0.23169966f, 0.43296376f, 
    0.06614014f, 0.17623751f, 0.06623530f, 0.02042617f, 0.07898355f, -0.30947724f, -0.21292202f, 0.04983080f, 
    -0.21116319f, -0.19077210f, -0.42299956f, -0.33978185f, 0.03196491f, -0.11821830f, -0.13863713f, -0.01764922f, 
    0.16645904f, -0.02808269f, -0.00825336f, 0.08340833f, -0.11171420f, -0.05216561f, -0.05126071f, -0.23404890f, 
    -0.35739055f, 0.25119278f, 0.07077040f, 0.21307340f, 0.31339297f, 0.04915595f, -0.18177038f, -0.18782103f, 
    -0.21672814f, -0.18818071f, -0.23634534f, -0.17197579f, -0.22500248f, 0.16548263f, 0.18310246f, 0.13732897f, 
    0.37982029f, 0.10705995f, -0.01260779f, 0.01337941f, -0.15128100f, -0.08837324f, -0.11177575f, -0.33648196f, 
    0.04893371f, 0.07280055f, 0.10890699f, -0.01900600f, 0.16163971f, 0.09545564f, 0.04085533f, 0.31989959f, 
    -0.02001673f, -0.01363468f, 0.07479442f, 0.00045751f, -0.10468824f, 0.04986325f, -0.00034581f, 0.09270272f, 
    0.02855815f, 0.02333089f, -0.05799861f, -0.03170292f, 0.11285834f, 0.23056093f, 0.25127050f, 0.12463707f, 
    -0.41011778f, -0.14065796f, -0.23335733f, 0.31577179f, -0.19380915f, -0.08010446f, -0.17831567f, -0.24647926f, 
    -0.00841937f, -0.34869945f, 0.07058495f, -0.16105019f, -0.08725462f, 0.15266226f, 0.27273566f, 0.12833399f, 
    0.09629981f, -0.01539749f, 0.11514874f, 0.08223084f, 0.16660151f, -0.15981196f, -0.01369219f, -0.25946823f, 
    0.43852204f, -0.04124174f, 0.29831532f, 0.55881554f, -0.12793884f, -0.00649791f, -0.03862493f, -0.07370894f, 
    0.14971039f, -0.15688996f, 0.03957889f, 0.36899236f, -0.23438835f, -0.03616159f, -0.22776732f, -0.15970232f, 
    0.08991218f, 0.10474262f, -0.10477956f, 0.06157155f, 0.11852623f, 0.22392613f, 0.12553245f, 0.16774310f, 
    -0.31416637f, -0.25721434f, 0.03428534f, -0.10601263f, 0.10252119f, 0.11270248f, 0.06460822f, -0.12716103f, 
    0.03097271f, -0.17068788f, -0.23514242f, -0.14287043f, -0.20447516f, 0.23731463f, 0.36107987f, 0.10979438f, 
    -0.04098871f, 0.00345052f, 0.13389461f, -0.06823502f, 0.16124317f, 0.05402191f, 0.05996118f, 0.20100266f, 
    0.38280377f, 0.27286613f, 0.01119772f, 0.23338272f, 0.21220927f, -0.15564084f, 0.17676559f, -0.12229043f, 
    -0.33674762f, -0.24734911f, -0.32883877f, -0.37966821f, 0.66767603f, -0.24754506f, 0.29372260f, 0.17014086f, 
    0.18013741f, -0.12330419f, -0.00783423f, 0.05714681f, 0.20394590f, -0.05046979f, 0.11144953f, 0.26955310f, 
    -0.48763981f, -0.04144610f, -0.05841831f, -0.42915195f, 0.12191985f, -0.12437589f, 0.28630257f, 0.24719934f, 
    -0.04013295f, 0.06287543f, 0.18768968f, -0.03237485f, 0.22895472f, -0.11132050f, -0.07565644f, -0.01571507f, 
    0.03399690f, -0.05491065f, 0.14099854f, 0.04003373f, 0.26874968f, 0.34729838f, 0.52948439f, 0.62577170f, 
    -0.09469687f, -0.06644063f, 0.09459617f, 0.00506218f, 0.14985086f, -0.04342442f, -0.17124157f, 0.10753036f, 
    -0.31638211f, -0.21630688f, -0.18478239f, -0.40957102f, -0.01168500f, 0.01648571f, -0.04139055f, -0.22057281f, 
    0.00685919f, -0.08997954f, -0.15150270f, -0.05592377f, -0.34813124f, -0.23919754f, 0.00103206f, -0.40290824f, 
    0.00954691f, 0.37917030f, 0.19760083f, -0.25736770f, 0.26518303f, 0.09595208f, -0.05645877f, 0.00560167f, 
    -0.21286638f, -0.42366675f, -0.25058368f, -0.18984702f, 0.05797213f, -0.00202495f, 0.00510892f, 0.01703286f, 
    0.38209218f, 0.11283875f, 0.08094251f, -0.02855498f, -0.31071666f, -0.06632673f, -0.04428426f, 0.00826546f, 
    0.20226908f, 0.05608343f, -0.06865337f, 0.15742497f, -0.00794342f, 0.17392720f, -0.05627126f, 0.10136544f, 
    -0.04222997f, 0.03484659f, -0.16462187f, -0.06183159f, -0.14601482f, -0.00912594f, 0.17952652f, -0.20659235f, 
    -0.07856775f, -0.12765497f, -0.15414883f, 0.00232395f, -0.00343897f, 0.26620877f, 0.36043766f, 0.35494384f, 
    0.18044494f, -0.04283747f, 0.10013910f, 0.00675569f, 0.21260805f, 0.12539183f, -0.19012614f, 0.01463957f, 
    -0.23228985f, -0.22149946f, 0.08953820f, 0.01216054f, 0.24089323f, 0.14765556f, 0.10092489f, -0.09017864f, 
    0.00335006f, -0.06767144f, -0.03577804f, 0.19416308f, 0.10840540f, 0.02722090f, -0.03523380f, -0.27323619f, 
    0.50571817f, -0.02084655f, 0.14153290f, 0.26328573f, -0.17894161f, 0.07666271f, -0.18857910f, -0.03419438f, 
    0.09742707f, -0.28122094f, 0.06814607f, 0.18374811f, -0.01557433f, -0.03172252f, -0.30916297f, 0.21735077f, 
    0.15768698f, 0.19693434f, 0.07216758f, 0.29429981f, 0.02461197f, 0.15595129f, 0.17695346f, 0.35181350f, 
    -0.01172418f, 0.07961111f, 0.04624777f, 0.12304892f, 0.06128749f, 0.06444169f, 0.07405532f, -0.05467353f, 
    -0.11426987f, -0.16109572f, -0.45682898f, -0.07553496f, -0.25906590f, 0.16841592f, 0.45958769f, 0.18611541f, 
    -0.08601537f, 0.02346756f, 0.02876568f, -0.01970499f, -0.06708013f, 0.21973974f, 0.12710461f, 0.06550577f, 
    -0.07473472f, 0.23610911f, 0.10486862f, 0.35851133f, 0.23843694f, 0.10101034f, 0.08408875f, -0.06386573f, 
    -0.27272600f, -0.30305892f, -0.24560149f, -0.38414559f, 0.23901629f, 0.28084272f, -0.23348263f, 0.19689673f, 
    0.06170024f, 0.22180508f, 0.04727366f, 0.05829857f, -0.02489341f, 0.03933791f, 0.06026328f, 0.02241630f, 
    0.30729917f, -0.14908350f, -0.10150348f, -0.09226774f, -0.12118594f, 0.03110933f, 0.05175175f, 0.05084180f, 
    0.05795436f, 0.20950852f, 0.18039498f, -0.05657446f, -0.09502556f, 0.04444397f, -0.21796237f, -0.20836735f, 
    0.01371361f, -0.04114402f, -0.21796633f, -0.12699781f, -0.14219218f, 0.06328822f, -0.27036738f, -0.23760164f, 
    0.07075134f, 0.02254576f, -0.04882771f, 0.02714189f, 0.28126439f, 0.01097048f, 0.06304039f, 0.12391055f, 
    0.15126710f, -0.04709975f, 0.01369191f, -0.00031706f, -0.04303521f, 0.08180174f, 0.02757314f, -0.09337445f, 
    -0.10332563f, -0.07437462f, -0.04198548f, -0.06359140f, -0.00545279f, -0.15886667f, -0.10826502f, -0.06871698f, 
    0.09339799f, -0.01685570f, -0.29912874f, 0.11803765f, 0.01470382f, -0.03886899f, 0.37173301f, -0.04785351f, 
    0.04874202f, 0.13927281f, 0.01415643f, 0.05643248f, -0.07505570f, -0.22168563f, -0.37282774f, -0.23007807f, 
    0.05318065f, 0.01525669f, 0.07556518f, 0.09458437f, 0.02886219f, -0.09332054f, -0.09479621f, -0.26310927f, 
    0.10715484f, -0.01912689f, 0.01379123f, 0.41297558f, -0.05253258f, -0.03574012f, 0.06012037f, -0.11679316f, 
    -0.22028615f, -0.13553025f, -0.12899506f, 0.10172629f, -0.00654120f, 0.03846733f, -0.02540485f, -0.11927310f, 
    0.06470610f, -0.29553303f, -0.36581564f, 0.01958390f, 0.24728023f, -0.15461636f, -0.36278096f, 0.03329487f, 
    -0.35312426f, -0.25634664f, 0.05552994f, -0.05746347f, -0.23127545f, 0.02465638f, -0.02143888f, -0.11418533f, 
    -0.18316260f, -0.00034721f, 0.09613916f, -0.06125414f, -0.11123330f, 0.07007981f, -0.07753327f, 0.15651910f, 
    -0.13164175f, -0.08437296f, 0.00065547f, -0.08739375f, -0.01120540f, -0.26282477f, -0.03599959f, 0.04811007f, 
    0.12979648f, 0.14485353f, 0.16718455f, 0.03688049f, 0.05170570f, 0.14550714f, 0.09872504f, 0.21097150f, 
    -0.14766137f, -0.17682861f, -0.04494402f, 0.02770160f, 0.31652793f, -0.07371535f, 0.19549087f, -0.02240285f, 
    0.02399755f, 0.02077031f, 0.06852685f, -0.21484639f, 0.00150590f, -0.08740944f, -0.15973864f, -0.24619430f, 
    -0.03492443f, 0.11784626f, -0.13665134f, 0.08098190f, -0.00703259f, -0.09527274f, 0.17286488f, 0.14940751f, 
    0.01648287f, -0.10182010f, -0.12014272f, 0.09682173f, 0.08727915f, -0.00702508f, -0.01447799f, -0.02811721f, 
    -0.12409198f, 0.05837876f, 0.20629954f, -0.32788005f, -0.05010055f, -0.08177212f, -0.05026227f, -0.22470583f, 
    -0.13651666f, -0.00947387f, -0.02366161f, 0.02219394f, 0.23892684f, 0.00314870f, -0.02816442f, 0.18489605f, 
    0.05959116f, -0.08974549f, -0.06051791f, 0.26259884f, 0.20127620f, 0.14314143f, 0.07616223f, -0.08822241f, 
    -0.05217605f, 0.09316691f, 0.05944071f, 0.00914949f, 0.05354294f, -0.23913279f, -0.02859540f, 0.16475049f, 
    -0.69791025f, -0.09238241f, 0.13783731f, 0.27237639f, 0.14389837f, -0.00827273f, 0.13558653f, 0.11570618f, 
    0.06742848f, 0.09114365f, 0.22142994f, -0.12761134f, -0.30432171f, 0.01987426f, 0.44218916f, -0.19869541f, 
    0.03582228f, -0.04629291f, 0.18345624f, -0.04203841f, 0.00188674f, -0.24973010f, -0.14137073f, -0.22392178f, 
    -0.05437121f, -0.05094916f, 0.23463684f, -0.11364415f, -0.13071550f, 0.28123203f, -0.26539859f, -0.02273982f, 
    0.08679719f, 0.12944648f, 0.22041021f, -0.11464160f, 0.06939973f, 0.19562040f, 0.40116343f, 0.00849947f, 
    0.00585838f, 0.13675877f, -0.17989852f, 0.14783069f, 0.00831954f, -0.02389747f, -0.05265295f, -0.02380943f, 
    -0.09897922f, 0.37941477f, 0.50338596f, 0.10836490f, -0.11140762f, -0.08950610f, 0.05487416f, 0.22142282f, 
    -0.20898539f, 0.00145646f, -0.02521022f, 0.12339644f, 0.03203586f, 0.18538393f, -0.31707323f, 0.01533021f, 
    -0.15359665f, -0.01285197f, -0.11629130f, 0.05021987f, -0.01985278f, -0.07684667f, -0.08147489f, -0.05223253f, 
    -0.15691906f, 0.01111493f, 0.41912153f, 0.10802425f, -0.30445981f, 0.09464576f, 0.08050909f, 0.23417076f, 
    0.03567906f, 0.09615345f, 0.02718918f, 0.06744824f, 0.11773182f, -0.00553330f, 0.29717264f, -0.01230388f, 
    0.09043219f, -0.11900160f, -0.13852087f, 0.24899183f, 0.07768547f, -0.16790123f, -0.11228710f, -0.09291731f, 
    0.42126718f, 0.03762773f, 0.54500830f, -0.24216917f, 0.06065633f, 0.02198731f, -0.10437018f, 0.07826094f, 
    -0.00459423f, 0.13850665f, 0.07343174f, 0.04995506f, 0.13749245f, -0.02976376f, 0.33131436f, 0.19276065f, 
    -0.12719266f, 0.25756034f, -0.24629481f, 0.10201684f, -0.10773981f, 0.12324888f, -0.08959842f, -0.10114193f, 
    -0.08540057f, -0.08532777f, -0.21661504f, -0.25647256f, 0.13018030f, -0.21190070f, -0.00070353f, -0.13887894f, 
    -0.05721599f, 0.12913981f, -0.14630488f, -0.14751634f, -0.23464741f, 0.45341691f, 0.09846073f, 0.07903741f, 
    0.09587643f, 0.03301014f, 0.08038659f, -0.00668405f, -0.23315293f, 0.14198299f, 0.02159971f, 0.01513482f, 
    0.13009508f, -0.05094845f, -0.07152022f, 0.11418645f, -0.07147831f, 0.00854698f, 0.34302667f, 0.32562175f, 
    0.15108868f, 0.12994504f, 0.04343246f, -0.06631100f, -0.29266271f, 0.19483931f, -0.13293526f, 0.37660807f, 
    0.06590222f, -0.02228280f, -0.03449798f, 0.17100757f, -0.05818464f, -0.16079888f, -0.11286439f, -0.00380588f, 
    -0.40634426f, -0.06972013f, 0.05076691f, -0.26517564f, 0.00804204f, -0.20545872f, -0.08337051f, 0.14985228f, 
    0.17196122f, 0.04452727f, 0.03394508f, -0.22812857f, -0.75094908f, 0.51968008f, -0.60339534f, -0.04922745f, 
    0.26514301f, 0.13243864f, 0.14872248f, -0.12536627f, -0.06077693f, -0.01057798f, 0.33357772f, 0.11940382f, 
    0.00133600f, -0.06326398f, 0.01183012f, 0.00429980f, -0.01276585f, -0.02195154f, 0.02624909f, -0.06810572f, 
    -0.02704129f, 0.01563485f, -0.02054778f, 0.00676650f, -0.03742252f, -0.06063646f, 0.03567488f, -0.00744486f, 
    -0.07410426f, -0.00998764f, -0.03250611f, -0.01840666f, -0.01713091f, -0.02769076f, -0.04490445f, -0.04132118f, 
    0.04990612f, -0.03296606f, 0.00778876f, 0.00989269f, -0.03728274f, 0.03525311f, 0.04750233f, -0.02242886f, 
    -0.00315738f, 0.01841956f, 0.00645627f, 0.04530312f, 0.02996662f, 0.00080462f, -0.02083602f, 0.03858628f, 
    -0.07536703f, -0.03142463f, 0.05879215f, -0.04670993f, -0.07686210f, 0.03307506f, 0.02605001f, -0.03628752f, 
    -0.03673810f, 0.00891227f, -0.01615565f, -0.02805223f, 0.00333003f, 0.00962151f, 0.01298185f, 0.04245643f, 
    0.02888359f, -0.03838122f, -0.00967261f, -0.07511104f, -0.06275474f, -0.06827480f, -0.04819733f, -0.01389827f, 
    -0.07129863f, -0.04883423f, 0.04271965f, 0.03358674f, -0.06217961f, -0.02335016f, -0.04305924f, 0.04959505f, 
    0.04647723f, 0.02434729f, -0.04631963f, -0.05307851f, -0.06855460f, -0.00079257f, 0.00827318f, 0.03650688f, 
    -0.07371620f, -0.05860391f, 0.01468697f, -0.00173639f, -0.06148726f, 0.06002841f, 0.01664469f, -0.02099172f, 
    0.02879015f, -0.05004370f, 0.04893699f, 0.02687673f, -0.04652848f, 0.01955293f, -0.03250077f, -0.02800558f, 
    0.04201279f, 0.04845750f, -0.02501595f, 0.03861083f, -0.06358982f, -0.02674012f, 0.01585131f, 0.06231441f, 
    0.00601233f, -0.02760760f, -0.03220910f, 0.03946636f, -0.06471207f, -0.02036348f, -0.03704648f, -0.05521976f, 
    -0.00087043f, -0.06699374f, -0.07545517f, 0.04106234f, 0.02482946f, -0.03821813f, 0.02217097f, 0.01115627f, 
    -0.04639930f, 0.05991600f, -0.05205050f, -0.03103409f, 0.05118022f, 0.00009882f, 0.02764889f, 0.01830823f, 
    -0.05288201f, 0.04313010f, -0.06122369f, -0.07341219f, -0.06369035f, -0.02223010f, -0.07614171f, 0.01127403f, 
    0.03543959f, 0.04414034f, -0.05680089f, -0.04421395f, -0.03109383f, -0.06562445f, -0.06069772f, -0.05633075f, 
    -0.05099556f, 0.04603038f, -0.02035803f, -0.01655176f, 0.04668720f, -0.02147196f, -0.06302153f, 0.00563572f, 
    -0.02280603f, -0.03992832f, -0.00436640f, 0.02143377f, -0.00450172f, -0.04143561f, 0.06266775f, -0.08058055f, 
    -0.07484117f, 0.03011171f, -0.05610524f, -0.04876855f, 0.04685742f, 0.05155518f, 0.04639279f, -0.03341727f, 
    -0.03813131f, 0.05534416f, -0.01978778f, 0.00284232f, 0.04513980f, -0.03464663f, -0.02374444f, -0.06511362f, 
    -0.02619636f, 0.00411233f, -0.00950026f, -0.07201536f, 0.04894861f, 0.00524122f, -0.04238013f, -0.04520837f, 
    -0.01945652f, -0.07518338f, 0.01168816f, 0.03877871f, -0.04194682f, 0.03610359f, 0.02098164f, 0.00938330f, 
    0.09290611f, -0.09369015f, 0.23096184f, 0.23251455f, -0.02809916f, 0.07054261f, -0.03382085f, 0.05477072f, 
    -0.00318257f, -0.03103341f, 0.02697439f, 0.10331313f, 0.25580642f, 0.26255596f, -0.05425813f, 0.06471304f, 
    -0.16632742f, -0.06790465f, -0.09670684f, -0.02475468f, -0.13827781f, 0.01961941f, -0.06674646f, 0.09053255f, 
    0.12895739f, 0.24740240f, -0.09954280f, 0.11696601f, -0.14710748f, -0.03821183f, 0.32861662f, 0.08936798f, 
    -0.12344046f, 0.10415553f, 0.16580276f, 0.01713004f, 0.11877485f, -0.08994654f, -0.20566177f, 0.26777169f, 
    0.05147409f, 0.02094435f, 0.01500077f, 0.13297188f, -0.03053449f, -0.05495529f, -0.02079498f, -0.00710337f, 
    0.00736968f, 0.22639470f, -0.14872953f, -0.20761441f, 0.05764807f, -0.05102286f, 0.04132200f, -0.13450615f, 
    0.14879991f, 0.03768056f, 0.06244408f, -0.11107377f, -0.27542400f, 0.04605179f, 0.36854795f, 0.37102449f, 
    -0.20996837f, 0.08415031f, -0.12839875f, -0.07281678f, -0.01518930f, 0.00054395f, 0.05757689f, 0.05150287f, 
    0.08861978f, 0.07006686f, -0.25705832f, -0.00074259f, 0.09245807f, 0.05834470f, -0.10769558f, -0.08213501f, 
    0.06620443f, -0.11171533f, -0.15183140f, 0.02395481f, -0.15186955f, -0.03632804f, -0.20681283f, 0.30612233f, 
    0.07667337f, 0.02251892f, 0.15443288f, 0.23778078f, -0.09080951f, -0.04018865f, -0.14864706f, -0.07704296f, 
    -0.44427893f, 0.23041308f, -0.00932211f, 0.01590623f, 0.01104762f, -0.01991868f, -0.01727211f, -0.02214747f, 
    0.07307737f, -0.08264317f, 0.02071291f, 0.24326265f, -0.27580166f, -0.25374672f, -0.03117638f, 0.58986837f, 
    -0.11880799f, -0.04505390f, 0.25245321f, 0.32571724f, -0.05181209f, -0.05366837f, 0.11681803f, -0.01776834f, 
    0.79754627f, 0.07280086f, -0.27220234f, 0.21452655f, 0.15323387f, -0.02494819f, 0.14930271f, 0.23151858f, 
    -0.08272167f, 0.00281198f, -0.00328296f, 0.04525172f, 0.38452077f, 0.03171826f, -0.21772832f, 0.01806392f, 
    0.10875756f, 0.06556934f, -0.12292433f, -0.02723706f, 0.06841165f, -0.10487778f, -0.19752336f, -0.13076973f, 
    -0.26304615f, 0.17706504f, -0.06618984f, 0.10485626f, 0.18259396f, -0.07114890f, -0.13216646f, -0.25958145f, 
    -0.14600550f, 0.02528255f, 0.09002551f, 0.13369997f, -0.26046395f, -0.33023968f, -0.10274354f, 0.46452522f, 
    0.04312284f, 0.08669660f, 0.05804844f, 0.03482898f, -0.06614913f, 0.14071923f, -0.01012255f, 0.02279589f, 
    0.34290731f, 0.00979480f, -0.00682716f, -0.19756569f, 0.04900908f, 0.27416432f, 0.09266628f, 0.00399403f, 
    0.08164612f, 0.10404042f, 0.19768289f, 0.22792135f, 0.94074684f, -0.20935403f, 0.38121551f, 0.17524619f, 
    0.08723944f, 0.12177379f, 0.00145757f, -0.01652301f, -0.03649715f, 0.12058320f, -0.18192078f, 0.09610500f, 
    0.26598167f, 0.04416823f, 0.01786441f, 0.17241110f, -0.04764296f, -0.00102000f, -0.03854060f, 0.12201723f, 
    0.16783732f, 0.19105826f, 0.08196704f, 0.14155789f, -0.26682976f, -0.27344236f, -0.39664227f, 0.04088476f, 
    0.10477760f, 0.05423293f, -0.14882323f, 0.15761709f, -0.13720542f, -0.12658866f, -0.22428240f, -0.15895298f, 
    0.14066559f, 0.00837360f, 0.15739717f, -0.11672015f, 0.01091398f, 0.09381447f, -0.00932380f, 0.06428608f, 
    0.16156317f, 0.06636567f, 0.04405542f, -0.07385482f, -0.09594254f, 0.14012371f, 0.26381674f, -0.09378849f, 
    0.03976892f, 0.09613241f, 0.32452008f, 0.07236774f, -0.10324883f, -0.01961331f, 0.08769292f, 0.10764381f, 
    0.12191752f, -0.61805671f, 0.10909742f, 0.00814839f, -0.08594187f, 0.18422395f, 0.08196249f, 0.19249533f, 
    -0.06659035f, 0.17358714f, 0.00593613f, -0.01722843f, 0.72462809f, -0.21583161f, -0.01811255f, -0.05813472f, 
    -0.08125851f, -0.06622533f, -0.05023468f, 0.07748081f, 0.03035686f, -0.10944748f, -0.05903324f, 0.02003542f, 
    0.14122877f, 0.00828209f, -0.12891260f, -0.18281904f, -0.08652009f, -0.25110865f, 0.12616169f, 0.13218167f, 
    0.10862773f, 0.04787496f, 0.06760962f, -0.12029649f, 0.18623941f, 0.24038707f, -0.01513086f, -0.00743400f, 
    0.22750449f, -0.00319072f, -0.01152575f, 0.06059130f, 0.07582065f, -0.14354153f, -0.05791166f, 0.13040704f, 
    -0.00767747f, -0.30944592f, 0.04551313f, 0.17364196f, 0.14213403f, -0.03908413f, 0.15931626f, 0.00293551f, 
    0.02969191f, 0.06462954f, 0.00636264f, 0.05567428f, 0.14705601f, 0.14482239f, -0.18544970f, -0.21066800f, 
    0.12296809f, 0.00116952f, 0.07318668f, 0.01688104f, -0.13074823f, -0.03955537f, -0.02321880f, 0.04195311f, 
    -0.51256680f, 0.51397425f, 0.01912232f, -0.18848859f, -0.15927134f, -0.06860396f, 0.02603061f, 0.06753045f, 
    0.02051342f, -0.11209948f, -0.02115183f, -0.16072197f, 0.03956752f, -0.01864582f, 0.45093206f, 0.03045919f, 
    0.00440876f, 0.01939162f, -0.06816873f, 0.10517194f, 0.12699233f, -0.07169245f, -0.05282307f, -0.04672355f, 
    0.13125215f, 0.08228025f, 0.26360115f, -0.02663982f, 0.05711484f, 0.18064745f, -0.09694739f, 0.34922636f, 
    0.16049437f, -0.12491649f, 0.18623132f, -0.13471751f, 0.47613013f, 0.22065495f, 0.28910103f, -0.32684734f, 
    0.02398572f, -0.00241080f, -0.06226644f, 0.11099287f, 0.14937596f, 0.09421827f, -0.14035010f, -0.11586873f, 
    -0.29354522f, -0.06303923f, 0.24185051f, 0.27107579f, -0.12688570f, -0.06091232f, 0.01991521f, 0.02334777f, 
    -0.10248647f, -0.08646473f, -0.02430282f, -0.18775964f, -0.36554486f, 0.39456594f, 0.18068054f, -0.22557789f, 
    -0.17605406f, 0.07812554f, -0.26132488f, 0.14125161f, 0.10483425f, -0.08627535f, 0.02173477f, 0.03238501f, 
    -0.30685946f, 0.02242571f, -0.07161147f, -0.12293842f, 0.03931800f, -0.00546452f, 0.00604071f, -0.00537803f, 
    0.27715683f, 0.19577266f, 0.16898364f, 0.04610095f, -0.26222819f, -0.01085789f, 0.23456773f, -0.01181024f, 
    -0.08025431f, 0.00560093f, 0.02116442f, 0.09066444f, -0.00232179f, 0.04358082f, 0.16505161f, -0.33498743f, 
    -0.27134657f, 0.01178792f, 0.10976881f, -0.02778579f, 0.04131462f, 0.15438892f, -0.00324799f, -0.05745598f, 
    0.04788046f, 0.12727095f, 0.00213081f, 0.12073907f, -0.09508738f, -0.14680201f, -0.27404678f, -0.25911990f, 
    0.21112812f, 0.15250379f, 0.05745146f, -0.03410869f, 0.02932911f, -0.11702049f, -0.03646098f, 0.02131062f, 
    0.12322593f, -0.01237356f, -0.06305196f, 0.37736642f, 0.29160547f, 0.02942577f, -0.01433152f, 0.03074174f, 
    -0.00394366f, -0.05770220f, -0.05069979f, 0.08624133f, -0.75064194f, -0.05995343f, -0.00034950f, -0.03220277f, 
    -0.00696586f, -0.03833171f, -0.10899757f, -0.04024494f, -0.09137437f, -0.10163908f, 0.02325502f, 0.11805167f, 
    -0.07631785f, 0.15544775f, 0.06373474f, 0.02233470f, 0.27658612f, 0.32380372f, 0.16048925f, 0.01792566f, 
    0.10554760f, 0.14000694f, -0.04396186f, 0.12274461f, 0.00039644f, -0.17104112f, -0.06170430f, -0.07889130f, 
    -0.01014494f, 0.13463007f, 0.19966796f, 0.05924081f, 0.22532091f, 0.19862369f, 0.08346701f, -0.16528569f, 
    0.01680708f, 0.32677156f, -0.20057325f, 0.07598966f, 0.03118464f, 0.06431878f, 0.02224889f, 0.05384905f, 
    -0.07514005f, 0.11067712f, 0.20820172f, 0.20747511f, 0.02062633f, 0.09496529f, -0.27821779f, -0.16924801f, 
    0.15266158f, 0.27494669f, 0.02639803f, -0.06820358f, 0.07274866f, 0.09691846f, -0.00197496f, -0.06230243f, 
    -0.24305694f, -0.38745686f, 0.02077645f, 0.03415479f, 0.12927820f, 0.38500702f, 0.13846719f, 0.13615513f, 
    -0.01050546f, 0.09310196f, 0.00811524f, 0.04019799f, -0.02405502f, 0.18097273f, -0.08295647f, -0.09564811f, 
    0.04657175f, 0.14380653f, 0.17364703f, -0.08710128f, -0.02971140f, 0.13796286f, 0.09321914f, -0.08956652f, 
    0.04877440f, -0.29686493f, -0.12525763f, 0.12177634f, 0.10736435f, 0.30961332f, 0.20826364f, 0.08407915f, 
    0.15214090f, 0.13354520f, 0.05476048f, -0.02079673f, -0.02916673f, 0.25508365f, -0.11046347f, -0.05349804f, 
    0.18750183f, 0.14378305f, 0.12355630f, 0.20474409f, -0.00307259f, -0.01931066f, 0.20660356f, -0.09545594f, 
    -0.14394401f, -0.29934514f, -0.02158597f, -0.08540371f, 0.04170362f, -0.07996135f, 0.00433298f, -0.15229535f, 
    0.10327236f, 0.14033432f, 0.09729639f, -0.10477433f, -0.62869948f, -0.12139802f, 0.21830657f, 0.22379957f, 
    0.05233679f, 0.00460924f, 0.19921672f, 0.03742787f, 0.21926036f, 0.27253705f, 0.23599507f, 0.16457036f, 
    0.55809659f, -0.23916081f, 0.05021929f, 0.13887446f, -0.14787529f, -0.07629472f, -0.11491214f, -0.04405461f, 
    0.05133483f, 0.17214420f, 0.05362421f, 0.10681240f, -0.00386870f, -0.08251084f, -0.08825439f, 0.20531274f, 
    -0.00759591f, -0.04642352f, -0.08713794f, -0.10629242f, -0.12790661f, -0.15902822f, -0.05526606f, -0.05620871f, 
    0.14758129f, 0.20437871f, 0.10589648f, -0.04436349f, 0.11987156f, -0.06900617f, 0.11461625f, 0.15418534f, 
    -0.10419261f, -0.29878262f, 0.03637777f, 0.01535864f, 0.00122606f, 0.35168701f, 0.17943424f, 0.09239179f, 
    0.12213448f, 0.25825009f, 0.37664041f, 0.05000634f, -0.07572756f, -0.03241482f, -0.00929344f, -0.08220284f, 
    -0.38350892f, -0.38710237f, -0.09613369f, 0.22692281f, -0.07023214f, 0.15357387f, 0.12880707f, 0.04332935f, 
    0.01423479f, -0.02577183f, -0.05798134f, -0.07294354f, 0.20619023f, -0.46783182f, 0.08757793f, 0.22393604f, 
    -0.12669536f, 0.09131058f, -0.00200798f, 0.02521186f, 0.04911275f, -0.02699147f, -0.05384219f, -0.03057983f, 
    0.16549709f, -0.44175419f, -0.54460746f, 0.23401503f, 0.17025451f, -0.08185335f, 0.20788373f, -0.02843953f, 
    0.07745003f, -0.08828226f, -0.07023285f, 0.05359835f, 0.16499974f, 0.08896941f, 0.04499902f, -0.08952830f, 
    0.08841590f, 0.04979889f, -0.04783779f, 0.03340260f, -0.06321079f, 0.10148024f, 0.04868203f, 0.16444150f, 
    -0.11542344f, -0.14976095f, -0.07621650f, 0.07473628f, 0.00901468f, -0.01410935f, 0.11166351f, -0.12240459f, 
    0.00912107f, 0.07010455f, -0.15959963f, -0.09509651f, 0.20676908f, -0.03395045f, -0.39176697f, -0.20181122f, 
    0.07657514f, -0.01995181f, 0.21120514f, 0.05061684f, -0.02044090f, -0.07690728f, 0.07911117f, 0.19785795f, 
    -0.33383104f, 0.63299453f, 0.06066919f, -0.00576524f, 0.05928966f, 0.13748629f, 0.01425267f, -0.17187493f, 
    -0.06182046f, 0.06783859f, 0.15973471f, 0.01748800f, 0.17196909f, 0.06891844f, 0.17348254f, 0.15144747f, 
    0.13597085f, 0.05386452f, -0.04686004f, -0.12291520f, 0.22868447f, -0.06892367f, 0.00198562f, 0.02167081f, 
    -0.08500797f, -0.01060219f, -0.18722714f, 0.03141268f, 0.20322642f, 0.24977489f, -0.15331475f, -0.04744780f, 
    0.08467694f, -0.14702675f, 0.06402524f, 0.00953380f, 0.64239144f, 0.27861965f, 0.16125722f, -0.18965653f, 
    0.01949023f, -0.03302484f, -0.10614374f, 0.02760799f, 0.08314225f, 0.26917166f, 0.09872514f, 0.11137348f, 
    -0.49274775f, -0.02286423f, 0.24883464f, 0.15714398f, -0.02612280f, 0.12902398f, -0.06876259f, 0.04636868f, 
    -0.04461778f, -0.10617519f, -0.01179056f, 0.01066403f, 0.42001596f, 0.04128646f, 0.03023972f, -0.03430461f, 
    -0.15389821f, -0.11697221f, -0.22551128f, -0.24729978f, 0.05063877f, 0.06032596f, -0.08260134f, 0.09475633f, 
    0.22021535f, 0.19871621f, -0.04442814f, -0.01165596f, 0.08123919f, 0.21274590f, -0.09260047f, -0.02921608f, 
    0.09674525f, -0.30168110f, -0.01764721f, -0.10674018f, -0.38900217f, -0.05202585f, -0.05851897f, -0.12642765f, 
    -0.03450283f, 0.03712815f, 0.08202041f, -0.08997566f, 0.24837664f, -0.00515860f, -0.03861832f, 0.00308911f, 
    0.09442826f, 0.08083448f, 0.00487225f, 0.00092044f, 0.19497551f, -0.09297972f, -0.22759624f, -0.11039514f, 
    0.21197318f, -0.05035060f, 0.08999148f, 0.11901204f, 0.12946042f, 0.30574346f, 0.10580014f, 0.06233584f, 
    -0.10383426f, 0.00522169f, 0.02454587f, -0.37230760f, 0.13553748f, 0.07932513f, 0.02939989f, 0.06117271f, 
    -0.39362505f, -0.08325376f, 0.20536448f, 0.44871527f, -0.01832720f, 0.03270181f, 0.11528216f, 0.15438449f, 
    0.02611910f, 0.02128499f, 0.01836101f, 0.02081019f, 0.58052886f, 0.25725701f, 0.11220069f, 0.44509089f, 
    0.16658075f, 0.15693335f, 0.14304735f, 0.03763063f, 0.16837704f, 0.02368831f, 0.13139217f, -0.00310342f, 
    -0.06654296f, 0.02132340f, -0.07463713f, 0.26843211f, -0.02456264f, -0.42369589f, -0.37583745f, 0.07537034f, 
    0.10311871f, 0.02637133f, 0.00844983f, 0.06637730f, -0.24125658f, 0.06532647f, -0.38001886f, -0.37245530f, 
    -0.27666888f, -0.12433888f, -0.03872031f, -0.36417183f, -0.19502904f, 0.12619072f, -0.05254716f, 0.12707698f, 
    0.12454104f, -0.04031862f, 0.02740616f, 0.09564683f, 0.10144793f, 0.12322374f, -0.02155377f, -0.00974377f, 
    0.12168413f, 0.01777598f, -0.04491619f, -0.02944268f, 0.02958549f, 0.30118307f, 0.02702077f, -0.26333514f, 
    0.03112514f, -0.20911090f, 0.04464862f, -0.23308825f, -0.01184921f, -0.10054132f, 0.12591976f, -0.10943192f, 
    -0.10503759f, -0.00968641f, 0.29342118f, 0.24804348f, 0.15429647f, 0.11242486f, 0.15977001f, 0.03646630f, 
    0.00795926f, -0.04518270f, 0.06798508f, -0.13798530f, -0.21637437f, 0.01936379f, 0.19553822f, -0.09597582f, 
    -0.00474059f, 0.04901602f, -0.13631761f, -0.16827053f, -0.13102312f, -0.05557766f, 0.01756641f, 0.05395113f, 
    0.01203497f, 0.01396263f, 0.09720661f, 0.03518478f, -0.24157657f, -0.02096444f, -0.21285707f, -0.10945432f, 
    0.04071941f, -0.03500510f, 0.08157203f, 0.02998606f, 0.11317872f, -0.03220319f, -0.09014768f, -0.10595651f, 
    0.02628298f, 0.02332336f, 0.07733176f, -0.29491377f, -0.05840362f, -0.17665094f, -0.03588983f, -0.06853914f, 
    0.18678194f, 0.13131543f, 0.18229814f, 0.15106884f, 0.13417204f, 0.09437966f, 0.12666728f, -0.04877252f, 
    -0.07310820f, -0.10392112f, -0.09045637f, 0.09696186f, 0.19184312f, -0.11586613f, -0.13636462f, -0.18897624f, 
    -0.00705399f, 0.07282864f, 0.12603167f, 0.08621609f, 0.03442042f, -0.02038039f, 0.05569937f, -0.16986471f, 
    0.25930431f, 0.06960542f, -0.05424512f, -0.07402293f, 0.13384281f, 0.02678947f, 0.10111173f, 0.01792148f, 
    0.47733274f, 0.23409984f, -0.13265300f, 0.06043265f, -0.03739290f, -0.02401032f, -0.10777999f, 0.15745944f, 
    -0.10772119f, 0.10954567f, 0.17788948f, 0.00874341f, -0.04538762f, -0.00383972f, 0.28430441f, 0.12593837f, 
    -0.08051442f, 0.00640766f, 0.22251429f, -0.17771265f, 0.27969182f, -0.26938498f, 0.19253303f, -0.22280440f, 
    0.12629738f, 0.24041423f, 0.10959453f, 0.07174718f, -0.20907702f, -0.27043572f, -0.65081155f, -0.60976124f, 
    0.04238749f, -0.11400792f, -0.10030631f, 0.10327390f, -0.20111144f, -0.11674674f, -0.03466173f, -0.05597713f, 
    -0.01606873f, -0.03268090f, 0.02567451f, 0.28334498f, 0.13702404f, -0.05876817f, 0.00014958f, 0.07964808f, 
    -0.11528007f, -0.09771702f, -0.00989535f, -0.01549683f, 0.20875460f, -0.26452768f, 0.52001435f, 0.33398610f, 
    -0.06849128f, -0.05763092f, -0.07525140f, -0.11737119f, 0.00587638f, -0.04061599f, -0.13915618f, 0.05331650f, 
    -0.10547456f, -0.50817019f, 0.09018196f, 0.21657024f, 0.10550654f, 0.38633370f, 0.07409573f, -0.08159354f, 
    -0.05973537f, 0.13759309f, -0.02795428f, -0.00504526f, 0.06569745f, -0.08503912f, -0.23951733f, 0.10394021f, 
    0.05592977f, 0.07095648f, 0.32898751f, -0.06225772f, 0.01692171f, 0.20218337f, 0.06370088f, 0.15529178f, 
    0.24351442f, 0.53033090f, -0.31627241f, 0.10697471f, -0.10973895f, -0.10548275f, 0.11485285f, -0.01519197f, 
    0.09621848f, 0.03552082f, -0.01237086f, 0.13015938f, -0.14195275f, -0.07951269f, -0.38237697f, -0.21306419f, 
    0.06517299f, -0.17366683f, 0.29962346f, 0.01414696f, -0.12397883f, -0.01097402f, -0.03842553f, 0.10292295f, 
    -0.43937743f, -0.11621484f, 0.07651447f, -0.00986887f, -0.13965398f, 0.14701900f, -0.10786474f, -0.06387867f, 
    -0.18596448f, -0.13082562f, 0.10379187f, 0.12226061f, 0.09776765f, -0.36352098f, -0.23392050f, 0.27836320f, 
    -0.01520334f, 0.09110873f, -0.11609110f, 0.01487005f, 0.08241608f, -0.11657289f, 0.01025110f, -0.11432008f, 
    0.03611388f, -0.08097073f, 0.00482214f, 0.10738690f, 0.17370053f, 0.32575217f, 0.00863904f, -0.08507687f, 
    0.02314003f, -0.06082665f, -0.12230951f, 0.13045491f, 0.27732030f, 0.16898492f, 0.32825920f, -0.38506871f, 
    0.14790097f, -0.14378977f, -0.04103046f, 0.20374954f, 0.10295039f, 0.34303433f, 0.15584418f, -0.12524365f, 
    0.01164871f, -0.09767247f, 0.05600765f, 0.01533457f, -0.16449662f, -0.01054059f, -0.25076458f, -0.17879079f, 
    -0.05191631f, -0.16260956f, 0.15340649f, -0.18121271f, 0.02145172f, -0.31951240f, 0.47471830f, 0.11804135f, 
    -0.06015030f, -0.02896923f, -0.03302461f, 0.12596269f, -0.14422858f, 0.18305273f, -0.03268484f, 0.08602404f, 
    0.24606736f, -0.08559730f, 0.15446261f, 0.08395833f, -0.08360481f, -0.12959845f, 0.10465565f, 0.02212217f, 
    -0.01647965f, 0.33590525f, 0.00872551f, -0.04979413f, 0.11405054f, -0.10963672f, -0.12720484f, -0.32245594f, 
    0.05151297f, -0.02616991f, 0.06810432f, 0.06013434f, -0.34280375f, 0.09116176f, 0.23327312f, 0.14057145f, 
    0.02549637f, 0.08560308f, -0.18646584f, 0.08147320f, -0.13669118f, 0.14807230f, 0.28357151f, 0.14242990f, 
    -0.11665013f, 0.14268333f, -0.00410164f, -0.00484389f, -0.12560339f, -0.03793015f, 0.09974765f, 0.00591977f, 
    -0.17387955f, 0.07448313f, 0.13111401f, -0.05595977f, -0.05467812f, -0.02306514f, -0.05981786f, -0.05584673f, 
    0.32638502f, 0.19171502f, -0.31558657f, -0.07298641f, -0.04483668f, 0.03114882f, -0.01072496f, -0.04024690f, 
    0.03754050f, 0.08162346f, 0.10651977f, -0.00243690f, 0.27155757f, -0.16472419f, -0.01766092f, -0.24411196f, 
    -0.13086684f, -0.01720655f, 0.04496967f, -0.12173568f, -0.01619136f, 0.04469500f, 0.01458391f, 0.06927168f, 
    -0.10738996f, -0.14677960f, -0.18042096f, 0.11030581f, -0.00138293f, 0.07785159f, 0.13570273f, -0.24974872f, 
    -0.07736759f, -0.01101174f, 0.01202476f, 0.00288887f, 0.14307112f, -0.08095267f, 0.13572457f, -0.07649167f, 
    0.05742949f, 0.05682574f, 0.04627201f, 0.03639029f, -0.04282521f, 0.02478589f, -0.00812600f, 0.10271169f, 
    0.33951530f, -0.07286398f, 0.25479835f, -0.29076770f, 0.03710966f, -0.04586950f, 0.07339579f, 0.13806911f, 
    -0.07007682f, 0.13709150f, 0.00458773f, 0.11563355f, -0.18469910f, -0.40033710f, -0.08903981f, 0.06817356f, 
    -0.27401417f, 0.02306937f, -0.12952609f, 0.09799870f, -0.02541493f, 0.15114935f, -0.02824803f, 0.12399215f, 
    -0.07870651f, 0.28653938f, 0.00195446f, -0.02569366f, -0.04280157f, 0.09758455f, -0.02511514f, -0.02097695f, 
    -0.07472247f, 0.06043300f, 0.06005428f, -0.03435773f, 0.34542811f, -0.19444709f, 0.10993531f, 0.28814283f, 
    -0.00336098f, 0.02402726f, 0.22016236f, -0.05639945f, 0.17903908f, -0.02345678f, -0.00951619f, -0.13758349f, 
    -0.03782080f, 0.29849824f, 0.04651550f, 0.00769632f, 0.12424719f, 0.02864058f, 0.11689477f, 0.12665375f, 
    -0.02872042f, 0.04349034f, 0.04294536f, 0.15422224f, 0.15930751f, 0.03989727f, -0.06935165f, -0.00233012f, 
    -0.06731475f, 0.01347286f, 0.06743047f, 0.18846653f, 0.29586288f, 0.27611178f, 0.02053995f, -0.06633832f, 
    -0.25554344f, -0.14956811f, -0.09037957f, -0.01751129f, -0.00675796f, 0.04425974f, -0.03008523f, 0.24465714f, 
    0.00299364f, 0.08822321f, 0.25429362f, -0.01296603f, 0.00429150f, 0.14186080f, 0.13115269f, 0.24913944f, 
    -0.06002022f, -0.03924489f, -0.09130075f, -0.05820262f, -0.17296496f, 0.07033253f, -0.17933381f, 0.16378246f, 
    0.00830400f, 0.01917129f, -0.01914595f, -0.06390292f, -0.08324391f, 0.03946209f, 0.04448922f, -0.04502239f, 
    -0.03700528f, 0.02497272f, -0.00641169f, 0.00085626f, -0.03038991f, -0.07123857f, -0.02663743f, -0.05833188f, 
    0.02822814f, -0.02188990f, 0.04382923f, -0.07995296f, -0.07672243f, 0.03116172f, 0.04007214f, -0.01090537f, 
    -0.02842286f, -0.01991434f, 0.02901883f, 0.01390476f, -0.02193033f, -0.06275985f, -0.07308330f, -0.06303392f, 
    0.02108680f, -0.00852210f, -0.05561296f, -0.02390808f, -0.03439223f, -0.02728110f, -0.05801180f, 0.05603651f, 
    0.02006434f, -0.07672300f, -0.06159019f, -0.06357877f, 0.01638963f, -0.02346368f, -0.00129893f, -0.00815445f, 
    0.01674099f, 0.01879890f, 0.04081063f, -0.05421552f, 0.05125583f, -0.03816979f, -0.06655275f, -0.01118615f, 
    -0.04326963f, -0.02248926f, 0.05725418f, 0.06271423f, 0.05890330f, 0.04839686f, -0.01113400f, -0.07518108f, 
    -0.01895384f, -0.02987719f, -0.06065764f, 0.00264720f, 0.01706571f, -0.06152986f, -0.06180806f, 0.01752958f, 
    -0.02886208f, -0.00634680f, 0.04737521f, -0.04300123f, -0.05897817f, -0.05964945f, -0.03227678f, -0.07502596f, 
    0.01093192f, 0.01975663f, 0.03403150f, 0.05708366f, -0.06561047f, 0.01129928f, 0.01324311f, -0.01446913f, 
    0.05969815f, -0.04267891f, 0.05268227f, 0.06165519f, -0.01127963f, -0.05696761f, -0.04067483f, 0.02523304f, 
    -0.03368609f, -0.05868538f, -0.01240914f, -0.06951977f, 0.03816043f, 0.02450454f, 0.02946886f, -0.06885175f, 
    -0.06196956f, -0.01867634f, -0.02146785f, -0.04913156f, -0.02135804f, -0.02680515f, 0.04540832f, 0.02249954f, 
    -0.01673054f, 0.03352547f, -0.05717615f, 0.05082884f, 0.04397829f, -0.02813971f, -0.01918149f, -0.02215532f, 
    0.06772437f, 0.05906644f, -0.02383610f, 0.05215243f, -0.02485058f, -0.02998378f, 0.04448713f, -0.00067628f, 
    -0.07743226f, -0.07972799f, -0.03217355f, 0.03520218f, 0.05775772f, -0.05035270f, -0.07250990f, 0.01153454f, 
    0.02475081f, -0.00660260f, 0.05995755f, -0.01710281f, 0.03899814f, 0.00816695f, -0.05454141f, 0.00821790f, 
    -0.07551338f, 0.04879311f, -0.08467775f, -0.03281699f, -0.00962261f, 0.01612604f, 0.03959532f, -0.05540208f, 
    -0.01518147f, 0.03507352f, 0.01383798f, -0.08303400f, -0.07311416f, 0.03046674f, 0.05815153f, -0.00840239f, 
    -0.03487480f, 0.00045899f, 0.02837352f, 0.02309980f, -0.02693725f, -0.04378336f, -0.06482840f, -0.05088124f, 
    -0.07329435f, 0.04508425f, -0.05394888f, 0.01453194f, 0.00374692f, -0.05538376f, 0.04300906f, -0.04186029f, 
    -0.01764178f, 0.03449149f, 0.03030599f, 0.04126648f, -0.06965629f, -0.03861354f, 0.04797041f, 0.01334851f, 
    -0.06608057f, 0.04708277f, 0.05018875f, -0.06990692f, 0.05497839f, -0.06860919f, -0.02723153f, 0.03874008f, 
    0.02865219f, -0.05621050f, -0.00007693f, -0.03323805f, 0.01295895f, -0.06083916f, -0.06709965f, -0.06389992f, 
    -0.07806745f, -0.05240178f, 0.00546548f, -0.02509667f, -0.08198716f, 0.01159271f, -0.04576256f, 0.03074581f, 
    0.04778168f, 0.04331243f, 0.02086975f, -0.01172862f, -0.04030591f, -0.05283636f, -0.00423352f, 0.05320431f, 
    0.05074769f, -0.04466759f, 0.00137896f, -0.01685042f, -0.03739183f, -0.06306539f, -0.02744335f, 0.03622087f, 
    0.02302380f, -0.00388093f, -0.01091002f, -0.03672918f, 0.03013472f, 0.06413788f, -0.05154838f, -0.05420170f, 
    0.01963857f, 0.04262867f, 0.00794367f, 0.00225595f, -0.05415670f, -0.07105322f, 0.04369365f, 0.02540256f, 
    -0.01944508f, -0.00612283f, 0.01886717f, -0.02013532f, 0.01131114f, 0.02341513f, 0.05637556f, -0.06868554f, 
    0.04487899f, -0.07864349f, 0.05107782f, -0.02885676f, -0.01142353f, -0.00359122f, 0.05778519f, -0.05613790f, 
    0.00438045f, 0.01770335f, 0.00278941f, 0.02894125f, -0.02310835f, 0.03779142f, -0.05589777f, 0.03254956f, 
    -0.00579200f, 0.01326133f, 0.04016430f, 0.01058831f, -0.02474807f, -0.04245069f, -0.00772895f, 0.02448894f, 
    -0.01199848f, -0.03128975f, -0.07503148f, -0.03819844f, -0.02717707f, 0.03079022f, 0.01324465f, 0.06106559f, 
    -0.05596320f, -0.07827901f, 0.00653163f, 0.01705397f, -0.05977493f, 0.01411617f, -0.03222335f, 0.03694596f, 
    0.01970588f, 0.01709687f, 0.05324119f, -0.05032710f, -0.05726519f, -0.07928181f, -0.04253750f, 0.03101166f, 
    0.06052057f, 0.00597794f, -0.00535806f, 0.05094889f, -0.06376440f, 0.03828193f, 0.06041126f, -0.06540085f, 
    -0.07628306f, 0.01399840f, 0.03978721f, 0.01537521f, -0.02797748f, 0.02624756f, -0.01007861f, -0.02786800f, 
    0.03845962f, -0.04711211f, -0.07529497f, -0.05589898f, -0.00666180f, -0.01577311f, 0.00596107f, 0.05345470f, 
    -0.05384206f, -0.03180176f, -0.02498148f, -0.00854067f, -0.07604986f, 0.04187162f, -0.05699695f, -0.05041013f, 
    0.00613054f, -0.05103630f, 0.01396610f, -0.00242731f, -0.00197026f, -0.03211797f, -0.05386469f, 0.05684277f, 
    0.02517848f, -0.08091368f, -0.04348455f, 0.04004753f, -0.03117169f, -0.04132216f, -0.06168733f, 0.02027468f, 
    0.03423427f, -0.06399602f, -0.04395670f, 0.02407232f, -0.05626359f, -0.06670780f, 0.04093388f, 0.05374394f, 
    -0.02547745f, 0.04115113f, -0.08280930f, -0.02783374f, -0.05653614f, 0.04917896f, -0.04056284f, 0.03008933f, 
    0.03653576f, -0.05812315f, -0.05582871f, -0.05928504f, 0.00626678f, -0.00643863f, 0.00899821f, -0.04978447f, 
    0.00989799f, -0.00060120f, 0.03255055f, -0.06956757f, -0.04886515f, 0.00730238f, -0.03740578f, -0.05202865f, 
    0.03359424f, 0.02020121f, -0.02555126f, -0.04840184f, -0.02164978f, -0.03943083f, 0.05576195f, -0.07980589f, 
    -0.28181905f, 0.05076726f, 0.21944477f, 0.08662549f, 0.04061496f, 0.00383022f, 0.09022503f, 0.05393830f, 
    0.16693003f, 0.16451009f, 0.12522565f, 0.14495498f, 0.02612920f, -0.05069689f, -0.06311763f, 0.19536979f, 
    0.09531234f, 0.01863353f, 0.05217394f, -0.03366672f, 0.08110829f, 0.25893265f, -0.11048715f, 0.17973210f, 
    -0.06579598f, -0.05210287f, 0.45282844f, -0.15178719f, 0.09194659f, 0.07158769f, -0.11451150f, 0.05982303f, 
    -0.00257755f, -0.11371373f, 0.07338008f, -0.03395756f, -0.24999981f, -0.25406316f, 0.03317440f, -0.14288901f, 
    0.12023388f, -0.09858250f, -0.05805915f, 0.31230065f, 0.09580997f, -0.05371938f, -0.01005029f, -0.02648336f, 
    0.44119477f, -0.25653541f, 0.37734845f, -0.36574438f, 0.04327462f, 0.12851883f, 0.20994255f, 0.13731752f, 
    -0.06653386f, -0.08146212f, -0.09871330f, -0.01798625f, -0.25608122f, -0.01322285f, 0.23553234f, -0.25232714f, 
    0.03126662f, 0.13412897f, 0.01250499f, 0.01860333f, 0.05441825f, -0.09223259f, -0.07757322f, -0.08852224f, 
    -0.00488737f, -0.30339673f, 0.51152414f, -0.06884632f, 0.03790021f, 0.05466718f, 0.16345625f, 0.20075738f, 
    0.03756268f, -0.02045545f, -0.02242673f, -0.03564033f, -0.08050007f, 0.24024421f, -0.01267066f, -0.23052676f, 
    0.03943682f, -0.07966849f, 0.04600682f, 0.07131495f, 0.01129261f, 0.00276103f, -0.01045652f, 0.06212329f, 
    0.19270480f, 0.24496189f, -0.11601144f, -0.02188957f, 0.07462217f, 0.10628036f, -0.01112607f, 0.00759802f, 
    0.02141925f, -0.01376909f, -0.08543254f, 0.02095437f, -0.08335847f, 0.09613763f, 0.17792264f, -0.20897265f, 
    0.13030408f, 0.03917485f, 0.03034786f, 0.04641129f, 0.12585686f, 0.04488992f, 0.04193368f, -0.17686039f, 
    -0.14280906f, 0.18931802f, -0.12112845f, -0.31911936f, -0.22745833f, -0.43337247f, 0.19878341f, 0.32548663f, 
    0.16227098f, 0.13753468f, 0.09590156f, 0.13478026f, -0.29856980f, -0.30656070f, 0.13066547f, -0.11004176f, 
    -0.17102800f, 0.09813958f, -0.09836359f, 0.20033705f, -0.06289334f, 0.06242593f, 0.19072539f, 0.05558861f, 
    0.20130481f, -0.04146837f, 0.12034641f, 0.06741719f, 0.18329680f, 0.12689951f, 0.31094912f, 0.31110302f, 
    0.12243956f, 0.12181412f, -0.05780365f, -0.03051028f, -0.09704860f, 0.15966342f, 0.44701084f, -0.03655839f, 
    -0.19705755f, -0.21814956f, -0.08132658f, 0.25158817f, -0.09118481f, 0.15392286f, 0.22162864f, -0.03359409f, 
    0.19043933f, -0.01029376f, -0.07590707f, -0.18431929f, -0.04832654f, 0.02335315f, -0.09216730f, -0.03931188f, 
    0.09516175f, -0.02526699f, -0.01396058f, 0.01783300f, -0.11307096f, 0.35411426f, 0.36671299f, 0.05392675f, 
    -0.06283806f, -0.00240762f, 0.14800932f, 0.11078732f, 0.50537133f, 0.21813309f, 0.29112366f, -0.05347355f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08412860f, -0.08495888f, -0.23941797f, -0.17825681f, 0.04086538f, -0.02690098f, 0.04493117f, 0.02074004f, 
    0.03314415f, 0.12662524f, 0.14286111f, 0.17871350f, 0.05339187f, -0.08429115f, 0.03174837f, 0.28797260f, 
    0.02013626f, -0.10669518f, -0.10902543f, -0.06514614f, 0.09038852f, 0.04274867f, -0.07249469f, 0.29631621f, 
    0.31509143f, 0.05980982f, -0.16934241f, 0.32757208f, 0.10306692f, -0.05264663f, -0.04632003f, 0.25687227f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.00645059f, 0.00600037f, 0.34381428f, 0.40550300f, -0.22880304f, 0.23177479f, 0.14642915f, 0.06023620f, 
    -0.23441404f, -0.14210083f, -0.92068666f, 0.18913466f, -0.71271074f, -0.34759277f, -0.45293924f, -0.37428880f, 
    -0.35220596f, 0.08796171f, 0.28246397f, -0.46756768f, -0.27681667f, -0.08960278f, 0.04786481f, 0.10167457f, 
    -0.01632141f, 0.20582621f, 0.18990380f, 0.13358486f, -0.22067839f, -0.00234298f, -0.01923101f, -0.36179218f, 
    0.13929929f, -0.13570388f, 0.08297753f, 0.11033542f, -0.22167851f, 0.15780567f, -0.00385691f, -0.10183593f, 
    0.15239333f, 0.46297038f, -0.11619079f, -0.10409749f, 0.48496804f, 0.16737553f, -0.68259835f, 0.08127101f, 
    0.07361265f, -0.73006904f, -0.64168316f, 0.22947335f, -0.31734881f, -0.15509865f, -0.03856098f, 0.36289608f, 
    -0.18392047f, 0.43154985f, -0.02653995f, 0.36118922f, 0.24603735f, -0.05548484f, 0.15823643f, -0.37025633f, 
    -0.57860887f, 0.07290215f, -1.06530273f, -0.30181319f, 0.28112182f, 0.43294337f, 0.02206130f, -0.04187317f, 
    -0.66701609f, -0.03457063f, 0.11025771f, -0.22484626f, 0.55476618f, -0.64484555f, -0.15493369f, 0.03631453f, 
    0.04476381f, 0.41468039f, 0.05053823f, -0.00870633f, -0.57139963f, 0.11576909f, 0.00873404f, 0.23624229f, 
    0.09840912f, 0.03557562f, 0.01103668f, -0.13613442f, -0.04275320f, 0.01426161f, -0.17071970f, 0.20643786f, 
    0.17353997f, -0.15740889f, -0.30424112f, 0.09597408f, 0.12931319f, 0.26712090f, -0.10274053f, -0.05115823f, 
    -0.38422066f, -0.38084558f, 0.10190404f, -0.40405872f, -0.03393409f, -0.00662578f, 0.08274120f, 0.20972203f, 
    0.47242984f, 0.34934506f, 0.14039999f, -0.06172142f, 0.13642438f, 0.12561581f, 0.36634448f, -1.18210030f, 
    0.11091284f, -0.21999107f, -0.01137450f, -0.71039945f, -0.32858583f, 0.06145434f, -0.00959159f, -0.54639649f, 
    0.17506203f, 0.01271715f, 0.38419336f, -0.05783970f, 0.25286064f, -0.33648163f, 0.00657835f, 0.11078741f, 
    -0.09976692f, 0.17743303f, 0.22133137f, -0.07259956f, 0.05523888f, 0.28043741f, 0.23263457f, -0.21601953f, 
    -0.06154389f, 0.20020790f, 0.16715933f, 0.21113236f, -0.16099241f, 0.08553713f, -0.25359333f, -0.04038663f, 
    -0.26233572f, 0.01537132f, 0.22552831f, -0.84365273f, -0.35354906f, 0.14306711f, 0.00781569f, 0.00296220f, 
    0.15019485f, -0.16818748f, -0.17105246f, -0.03334592f, -0.31406358f, -0.13026945f, -0.10983194f, 0.03254702f, 
    0.22813673f, -0.53367996f, -0.32495761f, 0.39827946f, -0.04450784f, 0.00498675f, 0.59605992f, 0.12114096f, 
    0.03062044f, -0.29596040f, -0.61377382f, -0.64788377f, 0.36292884f, 0.02261129f, -0.54941958f, 0.39050975f, 
    0.26112485f, -0.04047763f, 0.00156596f, -0.27715087f, -0.28998026f, 0.07851204f, 0.10308993f, 0.01602827f, 
    -1.23100519f, 0.07403290f, 0.00832172f, -0.30186829f, 0.64854926f, -0.58778703f, 0.06734090f, 0.16030844f, 
    0.33043298f, -0.04116066f, 0.33604971f, -0.74165350f, -0.23035525f, -0.43743178f, -0.11014041f, -0.21732828f, 
    -0.34107500f, -0.12500878f, 0.05788076f, -0.12232581f, -0.19799477f, 0.15067683f, -0.45686474f, -0.04633971f, 
    0.36495009f, 0.03948245f, -0.13004571f, 0.45146608f, 0.17012215f, -0.00785416f, 0.10640448f, 0.16696700f, 
    -0.63872278f, -0.06224528f, -0.53277856f, 0.01942814f, -0.50648320f, 0.42715845f, -0.06134906f, 0.01645462f, 
    0.21410550f, -0.56119275f, 0.16671503f, -0.24706791f, 0.14319614f, 0.25022081f, 0.41646957f, -0.07908548f, 
    -0.28649309f, 0.25049475f, -0.01840867f, -0.13193922f, -0.68612856f, -0.09040519f, 0.21148731f, -0.11996655f, 
    -0.31148121f, -0.94071305f, 0.00368127f, -0.07942522f, -0.19599791f, -0.06102704f, -0.12178811f, 0.20871808f, 
    -0.59137601f, 0.07784127f, -0.38684094f, -0.29065144f, -0.38556713f, 0.06608116f, 0.14060634f, -0.13957776f, 
    -0.36956507f, -0.00630047f, -0.44287613f, 0.12962763f, -0.50496572f, 0.42185315f, -0.34351641f, 0.45993409f, 
    -0.02713104f, -0.58800513f, -0.68702894f, 0.02909110f, -0.19732131f, -0.13916932f, 0.38130173f, -0.32040173f, 
    0.54131055f, -0.35902026f, -0.37984887f, 0.13994463f, 0.14228381f, -0.02393791f, 0.10951900f, 0.12262388f, 
    0.33311379f, -0.03617077f, -0.12180906f, -0.93609113f, -0.66522896f, -0.51439750f, -0.08477830f, 0.03660472f, 
    -0.21455142f, -0.12688719f, 0.35294798f, -0.03631683f, -0.24119462f, 0.13816027f, 0.30708674f, -0.36205027f, 
    0.40691629f, 0.27697423f, 0.44296381f, 0.04170223f, -0.49415299f, -0.02805863f, -0.04664011f, 0.26560044f, 
    -0.02746490f, 0.28047708f, -0.17201409f, 0.32901332f, -0.17722021f, 0.05981814f, -0.08052053f, 0.31263435f, 
    -0.26359317f, -0.05064292f, -0.47069535f, 0.61895627f, 0.16202195f, -0.65212566f, -0.18049619f, -0.15134932f, 
    -0.27777246f, -0.59401172f, 0.43660554f, -0.15236075f, -0.59847891f, -0.50959563f, -0.34378752f, 0.24338184f, 
    -0.14864188f, -0.32528326f, -0.57305604f, -0.30711615f, 0.39327586f, -0.07470249f, 0.41502619f, 0.12137617f, 
    -0.22549309f, 0.17070301f, -0.36136690f, -0.25455973f, -0.00893003f, -0.12205174f, 0.10433517f, 0.19821528f, 
    -0.24371351f, -0.10694444f, -0.36828366f, -0.18665080f, 0.50295132f, 0.02420368f, -0.00431643f, 0.01269502f, 
    0.09619489f, 0.62239009f, -0.22188231f, -0.35682285f, 0.25464851f, -0.03840120f, -0.29245779f, 0.03975240f, 
    0.27534512f, -0.47364435f, 0.47218999f, 0.07910379f, 0.81606573f, -0.11734025f, -0.51256210f, -0.09374475f, 
    -0.09040722f, -0.55908906f, -0.28658229f, -0.40330470f, 0.28871122f, 0.12841316f, -0.03563584f, 0.24378683f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12080737f, -0.00867427f, 0.32675540f, -0.06203067f, -0.04499593f, 0.29402003f, 0.05599547f, -0.09923604f, 
    0.28368387f, -0.06169371f, -0.16764887f, 0.02816904f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
