#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.35893700f, -1.69509625f, 0.65424120f, 0.17286444f, -1.11742043f, -1.24614501f, -0.49990684f, -0.60892594f, 
    0.18862998f, 0.52319354f, -0.48794818f, 0.24209052f, -1.16933215f, -0.66463244f, -0.56902599f, -0.28319308f, 
    -0.53724849f, -0.65855861f, -1.13731503f, -1.02105808f, -0.38508287f, -0.48405689f, -0.25102752f, -0.88262767f, 
    -0.42878988f, 0.71278077f, 0.14280377f, -0.03742952f, -0.02186660f, -0.00692868f, 1.18595898f, 0.31398603f, 
    -0.72673780f, -0.55154133f, -0.24271131f, 1.10834014f, 1.16826320f, -0.28539088f, 1.06252420f, -0.50752562f, 
    0.68357933f, -0.70401698f, 0.16306630f, 0.28305504f, 0.28124735f, -0.55524457f, -0.10680947f, 0.37839746f, 
    0.89033145f, 0.13867074f, -0.13818835f, -0.94134384f, -0.42252398f, -0.73324859f, 0.28144881f, 0.66407651f, 
    1.18055809f, -0.09519795f, 0.60713369f, -0.03574335f, 0.03790581f, -0.35931250f, -0.37144017f, 0.94145417f, 
    0.19786932f, -0.28710553f, -0.50272632f, -0.00607578f, 0.84076840f, 0.60073835f, -0.53855032f, -0.64539820f, 
    -0.36414865f, -0.41107243f, 0.06941257f, -0.86315757f, -0.94095325f, -1.35454309f, 0.86990380f, 0.20710789f, 
    0.20801507f, 0.76570737f, -0.26074675f, 0.17346919f, 0.79192001f, 0.99588919f, 0.89896661f, 0.13208136f, 
    0.54330635f, 0.39572969f, -1.44157386f, -1.18855870f, -1.37405944f, 0.14468324f, 0.80392116f, 0.38560185f, 
    -0.09756996f, 0.06106827f, -1.06786180f, 1.16613030f, -0.87603527f, 0.55576861f, 0.34372556f, 0.09072088f, 
    -0.36456114f, 0.78273189f, -0.37060317f, -0.20875946f, -0.38033676f, 1.86547220f, -1.09702098f, -0.48535433f, 
    -0.08969431f, 0.09520105f, 0.07267182f, 0.03165552f, 0.31974843f, 0.90879130f, 0.74303418f, 1.00990212f, 
    0.03428506f, -0.23900488f, 0.73935127f, -0.19183557f, -0.13083693f, 0.40613490f, 0.30742541f, 1.04727077f, 
    0.64413828f, -1.42044127f, -0.90238851f, -0.29239014f, 0.60630703f, -0.07454066f, -0.23903677f, 0.77866888f, 
    0.80101466f, -0.77272213f, -0.09569338f, 0.03664360f, -0.50046903f, 0.54582626f, 0.66607076f, 0.85555440f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    1.24576402f, 0.35618365f, -0.49883384f, 0.16689950f, -0.00323756f, 0.32735103f, 0.51559794f, 0.64738059f, 
    -0.03380096f, 0.44241917f, 1.02537978f, 0.93014306f, -0.03916036f, -0.52697110f, 0.24995856f, 0.87594074f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.37102777f, -0.01279990f, 0.07585631f, -0.12652726f, -0.11417709f, -0.02189642f, -0.15806550f, -0.15031727f, 
    0.16040061f, 0.18456693f, -0.24251205f, -0.19888598f, 0.12042242f, 0.15631539f, -0.04193993f, -0.17999534f, 
    -0.18456237f, 0.20277306f, -0.04649443f, -0.29882795f, 0.05492917f, 0.36847493f, 0.18296807f, 0.15276100f, 
    0.11511225f, 0.13585290f, 0.14170051f, 0.12288350f, -0.00577750f, -0.00562577f, 0.15391129f, 0.17375933f, 
    0.03356989f, 0.13322212f, -0.21629560f, 0.01408885f, -0.07903098f, 0.34063908f, 0.01191854f, -0.02925415f, 
    0.05997749f, 0.03590064f, 0.06802153f, 0.06403841f, 0.12801935f, -0.05855744f, 0.13541371f, -0.22099981f, 
    0.06762542f, 0.23535827f, 0.08282227f, 0.19451311f, 0.00913273f, 0.17255154f, -0.02598481f, 0.16144863f, 
    0.20943098f, 0.16134833f, 0.07539947f, 0.25752136f, 0.18082429f, 0.05649741f, 0.01697361f, 0.19554099f, 
    0.05419488f, 0.36976099f, 0.24418485f, -0.19463144f, 0.30543250f, -0.08683552f, -0.01582525f, -0.23078205f, 
    0.16836727f, -0.02996448f, 0.05000657f, 0.13193962f, 0.03208677f, 0.15010324f, -0.05280245f, 0.05452661f, 
    -0.09021063f, 0.19752301f, -0.03590690f, 0.16253246f, -0.09325672f, -0.06398427f, 0.06991125f, -0.21411613f, 
    0.00288376f, 0.04107639f, -0.13806124f, -0.26763260f, 0.11452392f, -0.02861075f, -0.12297748f, -0.25550070f, 
    0.00055395f, -0.12204236f, -0.18246281f, -0.16807260f, 0.12607293f, 0.53106874f, 0.11510777f, -0.29588556f, 
    0.17160901f, 0.01913516f, 0.04118380f, 0.25189424f, 0.38924214f, 0.79417396f, 0.23864920f, -0.18927063f, 
    -0.06778428f, -0.20483840f, -0.09052227f, 0.36832377f, -0.01442308f, 0.14625265f, -0.15820223f, 0.36269030f, 
    0.10048807f, 0.15632729f, -0.03278819f, 0.10272066f, 0.11019098f, 0.25177354f, -0.08524396f, 0.21999568f, 
    0.09984748f, -0.05825875f, -0.11106026f, 0.01616699f, -0.08107834f, 0.02702474f, -0.10036169f, 0.19870153f, 
    0.09947038f, 0.04036469f, 0.11407518f, 0.25176549f, 0.16788249f, -0.10496637f, -0.08622480f, -0.04177957f, 
    0.20180428f, 0.00839860f, -0.03714285f, 0.08397719f, 0.33942306f, 0.25982556f, 0.06903934f, -0.21517274f, 
    -0.25925526f, 0.43644845f, 0.14776820f, -0.03096506f, -0.02480679f, 0.15813716f, -0.03624456f, -0.14486091f, 
    0.00459169f, -0.21223365f, 0.12101749f, 0.47120938f, 0.16786863f, -0.14796007f, 0.06876474f, -0.08671709f, 
    0.22889639f, 0.06902798f, 0.21542855f, -0.25966525f, -0.08633275f, 0.13898119f, -0.10383611f, -0.13813542f, 
    -0.00923348f, 0.25360760f, 0.21902555f, 0.12977967f, -0.02674159f, 0.58826166f, -0.01570914f, 0.01393595f, 
    -0.24916752f, -0.14188260f, -0.06960674f, 0.14410935f, 0.20420499f, -0.33091056f, -0.15944639f, -0.06098781f, 
    0.08315869f, 0.12066044f, 0.08948751f, -0.27231625f, -0.54809219f, -0.48315346f, -0.56303155f, -0.03747031f, 
    -0.14719829f, -0.08261599f, 0.05319627f, -0.05718950f, 0.07027063f, 0.02303507f, -0.21764208f, -0.37492552f, 
    -0.31660888f, -0.13001843f, 0.01370998f, 0.01150525f, 0.02386439f, -0.51736116f, 0.10318678f, 0.11110729f, 
    0.34328061f, 0.86806583f, 0.45369205f, -0.23205699f, 0.19634864f, -0.03320151f, 0.10288513f, 0.20017095f, 
    0.19444229f, -0.13402097f, -0.20938495f, 0.00457195f, -0.06434941f, -0.12564731f, -0.08341335f, -0.09399330f, 
    0.02133481f, -0.07960491f, 0.10162731f, -0.12285747f, -0.29473820f, -0.10572769f, -0.09518081f, -0.07629021f, 
    0.10845243f, -0.29124323f, -0.12492581f, 0.20269454f, -0.30644113f, 0.06569955f, 0.16342540f, 0.09271142f, 
    0.41497248f, -0.13187091f, 0.14647806f, -0.25998619f, -0.14902079f, -0.08588060f, -0.16110983f, -0.21677904f, 
    0.69660085f, 0.13936125f, 0.07718875f, 0.38396797f, 0.02818373f, -0.38564628f, -0.00570381f, 0.06557304f, 
    0.16067494f, -0.17033678f, -0.12538972f, 0.05445993f, -0.13347380f, -0.07873373f, -0.11387747f, -0.61448175f, 
    -0.13032120f, 0.18034443f, 0.06837112f, -0.12324825f, -0.05645915f, 0.31025431f, 0.13389865f, 0.03173911f, 
    -0.06483766f, -0.02453323f, -0.04860096f, 0.08821045f, 0.11388728f, 0.11890563f, 0.39794332f, 0.25416955f, 
    0.07705638f, 0.19163281f, -0.45887229f, 0.23422655f, 0.18394576f, 0.04549979f, 0.02535188f, 0.07838657f, 
    -0.06018882f, 0.40566269f, 0.21105623f, -0.10839143f, 0.08894272f, 0.09012193f, 0.05673170f, 0.16457562f, 
    0.04683627f, -0.18693909f, 0.29817575f, 0.53516829f, 0.21529004f, -0.27365801f, -0.21884444f, -0.11437813f, 
    0.03276219f, 0.03062187f, 0.06666199f, -0.07741601f, 0.04041711f, 0.36113861f, -0.02586528f, 0.03375240f, 
    -0.03278749f, 0.19909263f, 0.06541215f, -0.05459489f, 0.22380257f, -0.04199017f, -0.02113143f, 0.05035983f, 
    -0.13222598f, -0.00768519f, 0.09901281f, 0.18319897f, 0.23531409f, -0.46786225f, -0.41905549f, -0.05937607f, 
    -0.05654614f, -0.00023652f, 0.02293432f, 0.00988520f, -0.15239438f, -0.24696784f, 0.33235916f, -0.27738371f, 
    -0.00334126f, 0.04578637f, -0.10055000f, -0.21671550f, 0.24598888f, -0.00321635f, -0.04937489f, 0.18034114f, 
    0.33354518f, 0.15276746f, 0.05009698f, 0.04645776f, 0.06554053f, -0.11967006f, -0.16837361f, -0.09470648f, 
    -0.02630066f, 0.53755224f, 0.22971098f, 0.08144485f, 0.08351309f, 0.20735364f, 0.05227186f, -0.00111574f, 
    0.03254510f, 0.52486908f, 0.10811309f, 0.22120112f, 0.07777525f, -0.18901438f, -0.16296594f, 0.07605487f, 
    -0.13300332f, 0.05034192f, 0.03041009f, -0.08922293f, -0.24714696f, -0.27401796f, -0.24439926f, -0.18274972f, 
    0.02604256f, -0.07477029f, -0.23347774f, 0.16820543f, -0.44347224f, -0.26116163f, 0.05268585f, 0.09142242f, 
    0.10526661f, -0.00912543f, 0.15367906f, -0.09002564f, -0.33170182f, -0.48927802f, -0.22568315f, -0.13208072f, 
    0.10181680f, 0.07318856f, -0.15232912f, 0.06021918f, -0.08127864f, 0.12542470f, 0.03319789f, 0.24200478f, 
    -0.03244589f, -0.25283667f, -0.09104901f, 0.13683005f, -0.22170053f, -0.22584060f, -0.16921079f, -0.39552864f, 
    0.30271852f, 0.18058459f, -0.03191690f, 0.07643063f, -0.06729898f, 0.10105583f, 0.31386015f, -0.25952485f, 
    -0.32154000f, -0.15013903f, 0.05253164f, 0.15915613f, 0.35624292f, 0.16096665f, 0.22578333f, 0.14942631f, 
    0.28397545f, -0.49706554f, -0.64519465f, 0.25691190f, 0.23871763f, 0.26047781f, 0.21805429f, -0.08040977f, 
    0.05849021f, -0.17949650f, -0.10379770f, -0.65641344f, -0.02950602f, 0.24405599f, 0.11852714f, -0.02308257f, 
    -0.02943793f, -0.11291163f, -0.22257622f, -0.06665433f, -0.23715989f, -0.03900116f, -0.17533691f, -0.09058648f, 
    0.00070568f, 0.13662483f, -0.29443955f, -0.22601184f, -0.24624318f, 0.29268104f, 0.01457825f, 0.00151150f, 
    0.07032882f, 0.12622410f, 0.36008415f, -0.13441497f, 0.84644955f, -0.32085341f, 0.07933560f, -0.00251734f, 
    0.16548486f, 0.03836626f, -0.14710236f, 0.09931078f, 0.07062875f, -0.09646538f, -0.05489315f, 0.06466062f, 
    0.15736865f, -0.11930726f, -0.00926463f, -0.02636418f, -0.22836833f, 0.15139997f, -0.20418644f, -0.20987730f, 
    0.03928306f, 0.08018011f, 0.06826055f, -0.06728968f, 0.05105335f, 0.02876444f, 0.34333867f, 0.08341644f, 
    0.10557272f, 0.02358264f, 0.07348847f, -0.05286965f, 0.28069022f, -0.07518516f, 0.40772650f, 0.26284993f, 
    -0.15646717f, 0.29529402f, -0.97620898f, -0.14501761f, 0.02167838f, -0.03204012f, 0.08482948f, 0.28558719f, 
    -0.06805008f, 0.00342661f, 0.14819439f, -0.10765913f, 0.11766521f, 0.20383397f, 0.23344521f, -0.02246138f, 
    0.22701754f, -0.08483493f, -0.47334382f, -0.25071943f, 0.19135264f, 0.05517013f, -0.13415202f, -0.03620732f, 
    -0.13922136f, -0.25773332f, 0.27026924f, 0.34094080f, 0.15606028f, 0.10532915f, -0.00405510f, 0.28909209f, 
    0.23907672f, -0.01970809f, 0.09811410f, 0.34094775f, -0.38675103f, -0.12736510f, -0.59228963f, 0.10978675f, 
    -0.02563455f, -0.02534385f, 0.44358197f, -0.21232897f, 0.10716192f, 0.34406039f, -0.05014024f, 0.14852206f, 
    -0.28744537f, 0.08116928f, -0.11609900f, 0.00939333f, -0.02892156f, -0.01883970f, 0.58934981f, -0.85450548f, 
    -0.17989445f, 0.18363157f, 0.22439961f, 0.12967047f, 0.04522926f, 0.02351866f, 0.25362796f, 0.27045083f, 
    0.19007567f, -0.18491632f, 0.12968965f, 0.19405742f, 0.28910699f, 0.22464360f, 0.18607606f, 0.05139659f, 
    0.07799830f, 0.60733914f, 0.01957826f, 0.31591830f, 0.05756327f, -0.31989142f, -0.08606072f, 0.00579227f, 
    0.09919436f, 0.01403186f, -0.04033126f, 0.50996238f, -0.06927457f, -0.08076326f, 0.04548177f, 0.20478147f, 
    -0.06051500f, -0.02130809f, -0.11292545f, -0.63427532f, -0.32219511f, 0.30123815f, -0.17269301f, 0.08000185f, 
    -0.16123509f, -0.17877239f, 0.02940066f, 0.31920490f, 0.16503815f, 0.18861355f, 0.09659992f, -0.09290440f, 
    0.19336314f, 0.12784143f, -0.16458841f, 0.00051911f, 0.09186043f, 0.03823334f, -0.50617576f, 0.22895971f, 
    -0.07925354f, 0.11495988f, 0.24556518f, -0.14801151f, -0.16629626f, -0.03518607f, 0.03997298f, 0.19272467f, 
    -0.02693458f, -0.03485946f, 0.03205059f, -0.03227679f, 0.28268036f, -0.00433973f, 0.17520915f, 0.12589370f, 
    -0.33368829f, 0.17371385f, -0.11710234f, 0.02836121f, 0.09412704f, 0.08875509f, 0.08878130f, -0.29636690f, 
    0.49566346f, -0.30472559f, 0.24103647f, 0.18697231f, -0.27425882f, 0.15661326f, 0.07868088f, 0.03299287f, 
    0.04631853f, -0.13328326f, 0.19387910f, 0.36065304f, 0.21587199f, -0.05717643f, -0.09365842f, 0.02520928f, 
    -0.06742834f, 0.02927463f, 0.31979966f, 0.05169920f, 0.24578603f, 0.06823396f, 0.08629180f, -0.12127491f, 
    -0.17595777f, 0.03884694f, -0.40921730f, -0.53438491f, -0.19061339f, -0.01617037f, 0.15789093f, 0.16610152f, 
    -0.00788124f, 0.05457554f, 0.25508115f, -0.23456581f, 0.10087238f, -0.84273827f, 0.25035000f, -0.03196773f, 
    -0.24537085f, 0.05067596f, 0.34900045f, -0.05103389f, 0.16294514f, -0.44805080f, -0.36757907f, -0.06361195f, 
    0.18779935f, -0.17486973f, -0.03730312f, 0.08294114f, -0.12297434f, -0.07374682f, 0.07855333f, 0.09573083f, 
    0.06396329f, -0.00962413f, 0.10542049f, 0.09106293f, -0.05810372f, 0.14018293f, 0.05299340f, 0.25219056f, 
    0.57900876f, -0.01641618f, -0.31607333f, -0.01070139f, 0.15324692f, 0.00331402f, -0.01990295f, -0.04413995f, 
    0.12335364f, -0.17184396f, -0.16582364f, 0.02653745f, 0.02748699f, -0.10637530f, -0.25705421f, 0.04597475f, 
    0.00029548f, 0.05050439f, -0.02769776f, -0.04517073f, -0.01125656f, 0.02221692f, -0.05416901f, -0.02453327f, 
    -0.06223441f, 0.02753406f, -0.01175234f, 0.02051059f, -0.04383211f, 0.00658839f, 0.06934320f, -0.00240889f, 
    -0.05574542f, 0.06564425f, -0.02507963f, 0.03308149f, -0.04003313f, -0.03029440f, -0.05006624f, 0.03354928f, 
    0.05982098f, 0.01270416f, 0.05926757f, -0.01289552f, -0.05175228f, -0.02918546f, -0.07398760f, -0.02817215f, 
    -0.05533072f, -0.07267191f, -0.07327362f, -0.06485061f, -0.07333012f, 0.05225680f, -0.01225822f, -0.08597325f, 
    -0.05832506f, 0.00248651f, -0.02277691f, 0.03205046f, -0.01952673f, 0.06795252f, -0.01324625f, 0.07014779f, 
    0.04208636f, -0.03738096f, -0.03079528f, 0.00252350f, 0.04664760f, 0.01087677f, 0.02687056f, -0.07833423f, 
    -0.08137145f, -0.08122398f, 0.04839353f, 0.02928461f, 0.00799672f, -0.00237884f, -0.01616883f, -0.08647131f, 
    -0.08290856f, -0.06366898f, 0.06710763f, -0.04924565f, -0.03951388f, -0.05690236f, 0.01449422f, 0.05296385f, 
    0.03960413f, -0.07746799f, 0.02539616f, 0.03300079f, 0.02779664f, -0.02689508f, -0.05438968f, -0.02147244f, 
    -0.07126198f, 0.05512039f, 0.02727611f, -0.00617100f, 0.06910105f, -0.00931936f, 0.01089947f, 0.05804629f, 
    -0.08108580f, 0.02189294f, 0.00902127f, 0.02367253f, -0.07307517f, -0.04074784f, -0.01172834f, 0.00075688f, 
    -0.08035129f, -0.06847971f, -0.04345096f, -0.03458073f, 0.01126781f, -0.06482768f, 0.05829655f, -0.01209357f, 
    -0.03615101f, -0.06472652f, -0.01851242f, -0.03155782f, 0.05321131f, -0.05448201f, -0.04921938f, 0.01101588f, 
    -0.06641281f, 0.05050316f, -0.01831954f, -0.05463614f, -0.02679588f, 0.06940256f, -0.01470008f, 0.07159397f, 
    -0.03641232f, 0.00890251f, 0.02117598f, -0.03449787f, -0.08558125f, -0.03978411f, 0.02868315f, -0.00051217f, 
    -0.00981455f, 0.01257312f, -0.07453682f, -0.04560572f, -0.02455083f, -0.06011434f, 0.06128366f, 0.07061426f, 
    -0.05816302f, 0.03138816f, 0.05989957f, -0.08921386f, -0.04025397f, -0.02808372f, -0.08551806f, -0.03667545f, 
    0.03151661f, -0.37040019f, -0.63431436f, 0.05637447f, 0.04955299f, 0.01467118f, 0.11870211f, 0.01135120f, 
    -0.00226750f, 0.25926062f, 0.18619442f, -0.72931081f, 0.12541164f, -0.11298180f, 0.20010939f, -0.08966096f, 
    -0.06435145f, 0.01797022f, 0.68604475f, 0.08499365f, -0.33049139f, -0.15888558f, -0.08577304f, -0.15411492f, 
    0.11517305f, -0.10607712f, 0.05709033f, 0.06513792f, -0.42098254f, 0.14207433f, -0.32261151f, 0.18729940f, 
    -0.29096359f, 0.37729841f, -0.03634797f, 0.08037603f, 0.14585413f, -0.05601576f, 0.06245420f, 0.16296895f, 
    0.08732845f, -0.00495291f, 0.16588186f, -0.13674790f, -0.05018278f, 0.41683361f, -0.35007367f, -0.02082705f, 
    -0.23736177f, -0.11915328f, -0.26644862f, 0.06890716f, -0.24915479f, 0.14694265f, -0.19288880f, 0.08923104f, 
    0.03069924f, -0.15729451f, 0.17219645f, -0.10398958f, -0.03176171f, 0.06461570f, 0.05195856f, -0.14607260f, 
    -0.19239083f, 0.23715055f, -0.18455353f, -0.12372018f, -0.04942312f, 0.01817784f, 0.32557106f, 0.17747095f, 
    0.73555422f, 0.08918324f, 0.02145521f, -0.05724365f, -0.15732156f, -0.10086820f, 0.07825168f, -0.03199798f, 
    0.18088491f, 0.20129468f, 0.17176716f, 0.20283808f, -0.23894942f, -0.15350257f, -0.66884679f, 0.11987564f, 
    0.03136472f, 0.08939313f, 0.59717453f, -0.42371014f, 0.19361529f, 0.03046777f, -0.13353430f, -0.15518311f, 
    0.19368099f, -0.01190023f, 0.00254570f, 0.11524308f, -0.53045750f, 0.04495418f, -0.05214095f, 0.12390744f, 
    -0.12030860f, 0.22985670f, 0.11372806f, -0.14769395f, -0.88574433f, 0.40305245f, -0.70560068f, -0.09288673f, 
    0.21176754f, 0.17018121f, 0.13842580f, -0.02822756f, -0.24545258f, -0.16749868f, -0.12036345f, 0.07529935f, 
    0.21321696f, 0.04033461f, 0.10505423f, 0.10176508f, 0.02671977f, 0.12967078f, -0.05692740f, 0.63922852f, 
    -0.32493162f, 0.09227847f, 0.17257661f, 0.06523304f, 0.07140165f, 0.12707645f, 0.00460161f, -0.16518417f, 
    -0.10004069f, 0.30999130f, 0.10457078f, -0.01826136f, 0.20100956f, 0.11800861f, 0.09089833f, 0.00151674f, 
    0.04459368f, 0.01480024f, 0.00403224f, 0.05442983f, -0.08394457f, -0.04491606f, 0.04172446f, -0.08554274f, 
    -0.01589654f, 0.06378875f, -0.07853010f, -0.04571515f, -0.08114526f, -0.06332116f, 0.04009356f, -0.07548231f, 
    0.03744838f, 0.07657428f, 0.05015796f, -0.02795712f, -0.05520734f, 0.04616823f, 0.06634040f, -0.02671004f, 
    0.06625589f, 0.07453944f, 0.05579715f, -0.02943096f, -0.06332657f, 0.02072956f, -0.05045012f, -0.00332199f, 
    -0.01284550f, 0.05493285f, -0.07520127f, 0.06251979f, 0.06625495f, -0.04468003f, -0.08154046f, 0.06069489f, 
    -0.01468104f, -0.05281338f, 0.06620874f, -0.08371594f, -0.02667869f, -0.07171641f, 0.03979312f, 0.06160527f, 
    -0.07353871f, 0.01535002f, -0.04315488f, -0.01400300f, -0.04458583f, 0.03216919f, -0.05718851f, -0.08826590f, 
    -0.06820259f, -0.03865545f, 0.05697317f, 0.01106789f, 0.06376524f, -0.04655545f, 0.01816810f, 0.05259314f, 
    -0.04744774f, -0.03438522f, 0.03843758f, -0.04975763f, -0.00266322f, 0.00852399f, -0.05619884f, -0.05862280f, 
    0.01227574f, -0.04463442f, -0.07567099f, 0.03848904f, -0.00960125f, 0.03558859f, -0.05505226f, 0.02249493f, 
    -0.07025323f, -0.04789773f, -0.01408730f, 0.01755464f, 0.01362185f, -0.00106421f, -0.05400939f, 0.02262859f, 
    -0.05399783f, 0.01668964f, -0.08994315f, -0.07791892f, -0.05588442f, 0.01844829f, -0.04208095f, -0.08755346f, 
    -0.06531070f, 0.05952383f, -0.05712835f, -0.07458069f, 0.05999917f, -0.02688917f, 0.04324618f, -0.00028779f, 
    0.00370398f, -0.05097968f, 0.01674208f, 0.03695055f, 0.07701289f, 0.01308595f, -0.04985085f, -0.05071311f, 
    -0.07876267f, -0.01922584f, -0.02101122f, 0.03325214f, 0.05160692f, 0.00801170f, -0.01887736f, -0.03958812f, 
    -0.03152369f, -0.06069929f, -0.06601303f, 0.04325461f, -0.08229278f, 0.07073241f, -0.06351611f, -0.06074845f, 
    -0.05041825f, 0.07570451f, -0.06506599f, 0.06583259f, 0.01401730f, -0.04941459f, -0.01943397f, -0.02138177f, 
    0.06340750f, -0.02047032f, -0.05051552f, -0.04141717f, 0.04471740f, -0.08696630f, -0.03341030f, -0.00763209f, 
    0.40133610f, 0.06059841f, -0.12663200f, -0.33541238f, 0.12354321f, -0.03000130f, -0.09813045f, -0.08968847f, 
    -0.08006351f, 0.14757600f, 0.31235799f, 0.40062132f, -0.03503392f, 0.07666223f, 0.22781225f, -0.04429058f, 
    -0.09555020f, 0.01165396f, 0.56854028f, 0.42612562f, 0.26610747f, 0.20081641f, -0.17586993f, 0.16250497f, 
    -0.02118315f, -0.16071315f, 0.17020912f, 0.03679657f, -0.29112008f, -0.31803104f, 0.41622248f, 0.37410197f, 
    0.07927140f, -0.09593791f, -0.06331177f, -0.17834894f, 0.02888079f, -0.08134684f, 0.23496304f, -0.15035973f, 
    -0.44620958f, 0.24696147f, 0.01896991f, -0.19409318f, 0.10093211f, 0.35599294f, 0.20110618f, -0.12284417f, 
    0.25973359f, -0.16144063f, -0.05274378f, 0.18099652f, 0.06171185f, 0.00453793f, 0.39461023f, -0.30674934f, 
    -0.17871000f, 0.19756119f, -0.19150560f, -0.00998602f, 0.23219182f, -0.29575855f, -0.17703085f, -0.07783318f, 
    -0.49378499f, -0.97561532f, 0.17699078f, -0.26738733f, 0.10844913f, 0.14638725f, 0.31440124f, 0.27050292f, 
    0.30066538f, 0.50147116f, 0.47019276f, 0.03399447f, -0.18652324f, -0.30942529f, 0.10070126f, -0.04135823f, 
    -0.31011927f, 0.08342699f, -0.15187618f, -0.52208281f, -0.13090913f, -0.23589213f, 0.34946182f, -0.00658196f, 
    0.35517550f, 0.26461667f, 0.39446759f, -0.19521265f, -0.27833179f, 0.17460346f, 0.22190157f, 0.32263047f, 
    0.27129427f, 0.11858486f, 0.22710840f, -0.17847975f, -0.41889045f, -0.54868597f, -0.15899844f, 0.16521019f, 
    0.21641225f, 0.04222679f, -0.02873221f, 0.21221323f, 0.25827536f, 0.41131893f, -1.18281329f, -0.02389798f, 
    -0.04992954f, 0.07798339f, 0.19012067f, 0.12516245f, 0.26342055f, 0.42493010f, -0.64718223f, -0.67451501f, 
    0.36748409f, 0.02375356f, 0.03405199f, 0.06623950f, -0.15648949f, -0.07248105f, -0.52579421f, -0.83674860f, 
    0.30057684f, -0.24986415f, -0.35908705f, 0.11133293f, -0.24984947f, -0.02017510f, -0.02010730f, 0.20536740f, 
    -0.00287480f, -0.66599864f, 0.15049793f, -0.13732131f, -0.00634106f, -0.26084030f, -0.16314842f, -0.20478798f, 
    0.31083030f, 0.03925087f, 0.05854016f, -0.17250159f, 0.21930681f, -0.09072997f, 0.16641550f, 0.01113078f, 
    -0.33051372f, 0.01743771f, -0.12989850f, 0.02151334f, -0.06577227f, 0.00705825f, -0.25069588f, 0.05010562f, 
    -0.02682226f, -0.28037325f, 0.59365135f, -0.23226298f, 0.21881802f, 0.02535352f, 0.00151603f, 0.21629003f, 
    0.28038082f, -0.09794887f, 0.14497703f, -0.53125983f, 0.02740988f, -0.28703043f, 0.24493602f, 0.28746715f, 
    -0.02909052f, 0.13027014f, 0.30567122f, 0.04847486f, -0.91968805f, -0.42639035f, -0.24582747f, -0.28144136f, 
    -0.05360149f, 0.17163856f, 0.01926908f, 0.16044867f, 0.11579351f, 0.39112973f, 0.13999061f, -0.00932928f, 
    0.21602891f, 0.12939392f, -0.11848738f, -0.08639240f, -0.30139226f, -0.29011387f, -0.55694979f, -0.10432727f, 
    0.16405042f, 0.14361227f, 0.07666417f, -0.01448178f, -0.07552040f, 0.12890035f, -0.07858162f, 0.08093484f, 
    0.25217053f, 0.39086777f, 0.02832952f, -0.17258970f, -0.23558198f, -0.16829313f, 0.05003844f, 0.00256437f, 
    0.24506977f, -0.17363122f, 0.16740151f, 0.02014133f, -0.04730187f, 0.10528952f, -0.08854496f, 0.06462689f, 
    0.27143705f, 0.17476147f, -0.19658351f, -0.17760006f, 0.14029929f, 0.02004006f, 0.05595864f, 0.00256275f, 
    0.11062060f, -0.02657494f, 0.38212624f, 0.36145851f, 0.05343437f, 0.23645402f, -0.04464709f, -0.14301535f, 
    0.10314904f, 0.04793335f, -0.10537855f, 0.07435592f, 0.09844834f, 0.13936146f, -0.04900844f, 0.26506740f, 
    0.10263123f, -0.06285948f, 0.48217398f, 0.28032625f, -0.25168040f, 0.08409437f, -0.01384818f, 0.04860359f, 
    -0.20457338f, -0.29840770f, 0.23754257f, -0.10201913f, 0.02784346f, -0.81516635f, -0.63764870f, -0.46789780f, 
    -0.28703713f, -0.44867697f, 0.17310773f, 0.04264507f, 0.04089138f, -0.18206336f, -1.04799354f, -0.12231425f, 
    0.12625909f, -0.15181093f, -0.17082749f, 0.15477309f, -0.03822165f, -0.03801028f, 0.51819915f, -0.60027993f, 
    -0.19219981f, 0.22737747f, -0.10185279f, -0.19565693f, 0.10315083f, 0.16104396f, -0.16088507f, 0.34282508f, 
    0.04878050f, 0.19521049f, 0.25453451f, 0.11979372f, 0.20482910f, -0.11269799f, 0.21739301f, -0.02758031f, 
    0.00081672f, 0.18333873f, -0.05715054f, 0.28788877f, -0.00145350f, 0.09981868f, -0.01245887f, 0.14388527f, 
    -0.14784479f, 0.05408641f, -0.05370387f, -0.36762762f, 0.06634578f, -0.00267762f, -0.00466044f, -0.14161786f, 
    0.26889130f, -0.04147246f, 0.01945467f, -0.32067353f, 0.12367404f, -0.18099490f, 0.10494308f, -0.00038265f, 
    -0.23364136f, 0.05189212f, 0.02396217f, 0.21341191f, -0.12735842f, 0.10559025f, -0.01452232f, 0.11038323f, 
    0.18535484f, 0.10352985f, 0.27175796f, 0.25030953f, -0.02563316f, -0.10428450f, -0.09951662f, -0.30066255f, 
    0.12390062f, -0.09564417f, 0.09214937f, 0.03224092f, -0.33165014f, -0.35442042f, -0.34627298f, 0.01025103f, 
    0.23614405f, 0.11561195f, 0.00926939f, 0.28048629f, -0.01048427f, -0.14194660f, -0.17445740f, -0.19455050f, 
    -0.13306983f, -0.14578325f, 0.13042781f, -0.00666161f, 0.20813377f, 0.16428064f, -0.19477543f, -0.09354785f, 
    0.26239255f, -0.38840675f, 0.04148811f, -0.18612334f, 0.04265086f, 0.09080597f, 0.23409303f, -0.00707609f, 
    0.18211950f, 0.07780863f, -0.15346831f, -0.17940077f, 0.21674857f, 0.18427213f, 0.09353305f, 0.11038215f, 
    0.20311552f, 0.31966212f, 0.16130431f, 0.23052223f, 0.04451257f, -0.10995819f, -0.01197148f, 0.21689768f, 
    -0.11485614f, -0.18372262f, -0.11553616f, 0.21285845f, 0.18856744f, 0.33115563f, 0.38780975f, -0.03254324f, 
    0.29550496f, 0.14089110f, 0.11070295f, 0.23139359f, -0.01845270f, 0.01955388f, 0.26418924f, 0.04872353f, 
    0.23652813f, 0.00297679f, 0.11546385f, 0.33869973f, 0.36690107f, -0.47663301f, -0.00761083f, 0.14468351f, 
    -0.02825364f, 0.09758715f, -0.08186876f, -0.07655670f, -0.15341821f, -0.34580460f, -0.38930875f, -0.00403829f, 
    0.04044468f, 0.30794719f, 0.15059535f, 0.10684483f, 0.02243789f, 0.05026392f, 0.22086205f, -0.03041611f, 
    0.31654060f, -0.10295661f, 0.19576037f, 0.14590226f, -0.07655527f, 0.51926732f, 0.42078286f, 0.14974457f, 
    0.01151670f, 0.05829383f, -0.04885251f, -0.06949978f, 0.01537636f, 0.01252041f, 0.00620610f, -0.05631545f, 
    0.02221200f, 0.07235511f, -0.01241931f, -0.04445033f, 0.04375113f, -0.03280155f, -0.03963276f, 0.06145471f, 
    -0.08160334f, -0.04784327f, 0.03835114f, 0.03617738f, 0.02797937f, -0.04541373f, -0.07882341f, -0.00511123f, 
    -0.04567916f, 0.07249037f, -0.05540726f, -0.01026683f, -0.01157079f, -0.06821631f, -0.02636119f, -0.03251710f, 
    -0.01559258f, 0.01353057f, -0.01134368f, 0.01372685f, -0.07401998f, -0.07079716f, -0.05064968f, -0.05329608f, 
    -0.04032624f, -0.07227641f, -0.06760641f, 0.00135033f, -0.08173960f, 0.02229553f, 0.04603784f, -0.01935960f, 
    -0.08720192f, -0.06000404f, -0.07215380f, 0.04153918f, -0.00173068f, -0.06334236f, -0.06434229f, -0.03945263f, 
    -0.07197414f, 0.05303606f, 0.02075318f, 0.01667824f, -0.05951018f, -0.03962333f, -0.04350819f, -0.02514387f, 
    0.06934410f, -0.07364056f, -0.07044084f, 0.01951489f, 0.04225224f, 0.02583287f, 0.04099658f, -0.07522148f, 
    -0.04372951f, -0.00854073f, -0.00161351f, 0.00976191f, -0.08073190f, 0.04842471f, -0.01245096f, -0.00295244f, 
    -0.08210877f, 0.08333238f, -0.01998651f, -0.02187096f, -0.00738180f, 0.06057240f, -0.06684676f, -0.01906319f, 
    -0.00017679f, 0.05163453f, -0.05395598f, -0.01840768f, -0.06423060f, -0.08047211f, -0.03884925f, -0.03486031f, 
    0.01079098f, -0.00713584f, -0.03071953f, -0.05538239f, -0.07106780f, -0.07559307f, -0.06667922f, -0.03272329f, 
    -0.01875592f, -0.01682943f, 0.06464235f, 0.01569172f, -0.06963053f, 0.06674877f, -0.04714511f, 0.07514282f, 
    -0.03796750f, 0.03537242f, -0.01591746f, -0.00000100f, 0.01159752f, 0.02187016f, -0.01305276f, 0.06387778f, 
    0.02443148f, 0.01097316f, 0.05196233f, -0.06920905f, -0.01883744f, 0.06832360f, -0.06890538f, 0.08135882f, 
    0.02642911f, 0.00026426f, 0.01622497f, 0.06751939f, -0.01679757f, 0.00409884f, -0.08684984f, 0.05102125f, 
    -0.08068230f, -0.09010541f, -0.09024177f, -0.07024308f, -0.06202543f, 0.01955411f, 0.03993159f, 0.05771345f, 
    0.04593638f, -0.02406794f, 0.00519919f, 0.02465917f, -0.07509279f, 0.07438584f, 0.02241945f, -0.08298226f, 
    -0.07191279f, -0.07364667f, -0.06275523f, -0.01885127f, 0.02720887f, 0.05162640f, -0.01142926f, 0.01458493f, 
    -0.04907449f, -0.08145117f, 0.04977612f, 0.01339343f, 0.00969262f, 0.04795803f, 0.00635738f, -0.07281721f, 
    -0.06562957f, 0.05534283f, -0.01960980f, -0.07353467f, 0.02551216f, 0.05585891f, 0.05229616f, -0.00404567f, 
    0.06336111f, 0.03143008f, -0.05827427f, 0.00353027f, -0.03902647f, -0.05813355f, 0.03733058f, -0.07506372f, 
    0.03258518f, -0.05425138f, -0.04108256f, 0.01830097f, 0.03329529f, 0.02035745f, -0.01214584f, 0.07353950f, 
    0.02144687f, -0.07849602f, 0.05439992f, 0.04652589f, 0.05198890f, -0.07305159f, 0.00587515f, 0.05508948f, 
    -0.07014539f, -0.07036991f, -0.05953908f, -0.02550829f, -0.02955838f, -0.02259114f, -0.09235263f, -0.02857798f, 
    -0.07823618f, -0.03611400f, 0.05569661f, 0.03854002f, 0.06781290f, -0.01614229f, 0.01478869f, 0.05254551f, 
    0.03392373f, -0.02558769f, 0.00445661f, -0.05500405f, 0.01066179f, -0.04956476f, 0.03528551f, -0.00641011f, 
    0.00489238f, -0.00976314f, 0.05296152f, 0.01359263f, 0.06946738f, 0.06057104f, -0.07001532f, -0.09472543f, 
    -0.08831785f, 0.03420943f, -0.08877011f, 0.01190477f, 0.02463940f, -0.06934524f, 0.01863250f, -0.07837456f, 
    -0.05122565f, -0.08625288f, 0.01937071f, 0.05730373f, 0.05621044f, -0.04296417f, -0.07115772f, 0.02732650f, 
    -0.01706328f, -0.07429219f, 0.01822284f, 0.06496654f, -0.06180100f, 0.04882899f, -0.08651748f, 0.05073062f, 
    -0.06119555f, 0.04986124f, -0.05932385f, -0.00200786f, -0.06873000f, 0.06452459f, -0.04422949f, -0.03958837f, 
    -0.04998464f, 0.06274756f, -0.04630091f, 0.01135975f, 0.06458186f, 0.01199170f, 0.03912120f, -0.00700637f, 
    0.07196732f, -0.03884925f, 0.07105864f, -0.01833035f, 0.02698460f, 0.02165667f, -0.03281879f, -0.07050413f, 
    0.03521638f, 0.00905918f, -0.05669163f, -0.06550829f, -0.00485728f, -0.02687361f, -0.02266430f, -0.05497609f, 
    -0.41454500f, -0.10655730f, 0.71635157f, 0.12539886f, 0.30333045f, -0.14536375f, 0.06792232f, 0.02907373f, 
    -0.22343986f, -0.25048724f, -0.23063546f, -0.22930299f, -0.12062063f, 0.10318885f, 0.25757572f, 0.15688285f, 
    -0.04806526f, -0.07042608f, 0.59469754f, 0.45123747f, -0.04092645f, 0.08358300f, 0.03904801f, -0.12432326f, 
    0.10173488f, -0.16643943f, 0.02602899f, 0.08219794f, 0.40567672f, 0.40864637f, -0.16135639f, 0.11983830f, 
    -0.22908522f, 0.39274037f, -0.04610008f, -0.12450064f, 0.30381945f, 0.16362830f, -0.11203860f, -0.23265816f, 
    0.21189493f, 0.03585035f, 0.18581674f, -0.00513631f, -0.01906627f, -0.20880437f, -0.32342237f, 0.06184845f, 
    0.12566797f, 0.15161534f, -0.34692463f, -0.13854356f, 0.10914138f, 0.32464051f, -0.15796107f, 0.29680187f, 
    0.07465781f, -0.28254962f, 0.04618739f, -0.19012828f, 0.27867699f, 0.22246656f, 0.04284214f, -0.13471681f, 
    0.19500312f, 0.51597273f, -0.15520032f, -0.16532026f, 0.07460868f, -0.01296790f, 0.31761330f, -0.01047673f, 
    -0.77515584f, -0.37928081f, 0.38899136f, -0.10346879f, -0.04358738f, -0.32300207f, -0.06413298f, 0.02982348f, 
    -0.02526074f, -0.11911908f, -0.06492571f, -0.13736846f, -0.02901076f, 0.03995734f, -0.06872915f, 0.00098647f, 
    -0.44896045f, -0.19907692f, 0.21334605f, -0.23763599f, -0.33499786f, 0.34816128f, 0.17690356f, 0.09660622f, 
    -0.09579489f, 0.05966513f, 0.21887957f, 0.16704975f, -0.12352680f, 0.43149301f, -0.17962958f, 0.22549905f, 
    0.03435828f, 0.22206512f, 0.47144899f, 0.08862378f, -0.50197232f, -0.22717793f, -0.59089875f, 0.00707680f, 
    -0.26805788f, 0.74817032f, 0.39568231f, 0.04987595f, 0.03493898f, 0.05143084f, 0.23827763f, -0.19625081f, 
    -0.14743540f, -0.13341859f, -0.22098693f, 0.09451957f, 0.07217123f, -0.06513882f, -0.05766684f, 0.14878646f, 
    -0.13161018f, -0.20622613f, -0.19155797f, -0.03190300f, 0.09475262f, -0.10858791f, -0.03562740f, 0.01315499f, 
    0.06727386f, 0.15274836f, 0.15602475f, 0.17122719f, 0.14632173f, 0.17437759f, 0.09759251f, 0.31226847f, 
    0.33660448f, 0.27514550f, -0.06017025f, 0.12347139f, -0.07097166f, 0.04263357f, 0.09910435f, -0.16380346f, 
    0.18088686f, -0.21624695f, -0.21629398f, 0.00103427f, -0.01552171f, 0.10613541f, -0.20160612f, -0.02447034f, 
    -0.00521286f, 0.19564871f, -0.81688350f, -0.09400851f, 0.11485704f, 0.05390868f, -0.18878283f, -0.31823552f, 
    -0.16515116f, -0.10468127f, -0.05063731f, -0.36151248f, -0.41650668f, -0.06448600f, -0.15818734f, 0.05565812f, 
    0.04403222f, 0.12612844f, 0.23531465f, 0.27588931f, -0.15765044f, -0.13448974f, 0.12452968f, 0.05249753f, 
    -0.18407267f, 0.06181895f, -0.30866182f, -0.14288348f, 0.04614117f, -0.08283414f, 0.11534257f, 0.08795832f, 
    0.09558178f, -0.03133144f, -0.18660086f, 0.25201648f, 0.02407190f, -0.24664421f, 0.11386956f, 0.04446281f, 
    0.09525253f, 0.09540305f, -0.13338703f, -0.08860920f, 0.23466663f, 0.17068073f, 0.09671548f, 0.28176013f, 
    -0.03755178f, 0.11907870f, -0.07083224f, 0.07934961f, -0.06942789f, 0.13530111f, 0.02371429f, 0.07542835f, 
    -0.95121366f, -0.31526148f, -0.48715395f, -0.25910217f, -0.16523632f, -0.67256993f, 0.06481178f, 0.13250524f, 
    -0.00459197f, -0.06861459f, 0.01752978f, -0.06105438f, -0.31401446f, -0.24001618f, -0.24728420f, 0.20909983f, 
    0.08660850f, 0.29747114f, -0.36370519f, 0.85541123f, 0.89482546f, 0.07162905f, 0.05913829f, 0.09214499f, 
    0.16980912f, 0.06120636f, 0.00055531f, 0.07391859f, 0.31742042f, -0.18247300f, -0.04533894f, 0.12519382f, 
    0.06949036f, 0.14245921f, 0.13385011f, 0.15691981f, 0.42795125f, -1.55360866f, -0.84789199f, -0.21207853f, 
    -0.01098471f, 0.33599249f, -0.12936653f, -0.07681279f, 0.24051353f, -0.10074371f, 0.06446739f, -0.00652766f, 
    -0.19142146f, -0.02824152f, -0.17714483f, -0.25572449f, -0.15387648f, -0.10961471f, -0.52751470f, -0.72576588f, 
    -0.83204079f, -0.10508245f, 0.04149617f, -0.13094661f, 0.13810560f, 0.11202344f, 0.04489425f, 0.10644285f, 
    -0.38220105f, -0.02148566f, 0.14095594f, 0.21132477f, 0.10831530f, -0.12372226f, 0.11126003f, 0.08341895f, 
    -0.42979944f, 0.15792385f, -0.09000471f, 0.25648132f, 0.10506561f, 0.09896130f, 0.08719099f, 0.19806476f, 
    -0.03165229f, 0.02805493f, -0.30702794f, 0.16018154f, -0.07679351f, 0.05239596f, 0.18563281f, 0.12977326f, 
    -0.01057767f, 0.32987630f, -0.12465654f, 0.38084406f, 0.25811127f, -0.18378076f, -0.13622977f, -0.25252640f, 
    0.06059809f, -0.12299684f, -0.23014167f, -0.47673503f, -0.01406478f, 0.01218338f, -0.05789607f, -0.47671485f, 
    -0.12563808f, -0.13443850f, -0.01290552f, -0.11923748f, -0.62553102f, -0.30923277f, -0.36085904f, 0.09481943f, 
    0.06583699f, 0.24919841f, 0.11883586f, -0.05451623f, -0.00317395f, -0.19028544f, -0.08224895f, -0.07549030f, 
    0.03237657f, 0.01395701f, 0.10423768f, 0.07456049f, 0.01652912f, 0.08475443f, -0.03614280f, 0.00354923f, 
    0.20183979f, 0.23595385f, 0.13485287f, 0.09022779f, 0.11551143f, -0.03762250f, 0.04571385f, -0.60595101f, 
    -0.23755503f, -0.10741060f, 0.18228321f, 0.05644142f, -0.05630088f, 0.17194413f, -0.03793769f, 0.16435967f, 
    0.09596063f, -0.11895521f, -0.05018843f, -0.31011924f, -0.17675275f, -0.17266926f, 0.01930973f, -0.02014468f, 
    -0.16014403f, 0.03215124f, 0.16151939f, 0.04981164f, -0.22948624f, -0.33728433f, -0.15072598f, 0.16937003f, 
    0.13549502f, 0.16351411f, -0.12843110f, 0.68852180f, 0.67376423f, 0.01817646f, -0.13217215f, 0.07628852f, 
    0.22907874f, 0.07752913f, 0.06348549f, -0.95773035f, -0.04964182f, -0.09825122f, 0.01902287f, 0.01174906f, 
    0.15915814f, 0.15510131f, 0.16645022f, 0.25011435f, 0.60335803f, -1.21113706f, -0.86403501f, -0.27643281f, 
    -0.10487004f, -0.32685816f, 0.07203431f, -0.01148558f, 0.07300737f, -0.25707138f, -0.27056947f, 0.47457814f, 
    -0.25320575f, 0.09370121f, -0.05953009f, 0.30887821f, 0.36910993f, 0.10935979f, 0.16036777f, -0.75478017f, 
    0.50751477f, -0.05497086f, -0.02894690f, -0.24529418f, -0.19868995f, -0.02264332f, -0.10659508f, 0.45169875f, 
    0.09411235f, -0.46071854f, 0.04449005f, 0.01457824f, -0.07919586f, 0.10001073f, -0.11892641f, 0.12309836f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.20804048f, 0.04809413f, 0.25108868f, 0.54314232f, -0.05253441f, 0.03032324f, -0.00010552f, 0.07010642f, 
    -0.15039816f, 0.33387882f, 0.27323735f, -0.00454168f, 0.07579728f, 0.20831269f, 0.48281312f, 0.40286332f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02667044f, 0.24143794f, 0.37171486f, -0.10711276f, 0.01559191f, -0.22176060f, 0.90940052f, -0.07885897f, 
    0.61837709f, 0.09907773f, -0.53351563f, -0.20293754f, 0.22554307f, -0.51448464f, -0.40934032f, -0.45406440f, 
    0.11267342f, -0.05313084f, 0.49508387f, 0.29422557f, -0.32309565f, -0.22620887f, -0.37458128f, -0.23722966f, 
    -0.17027684f, 0.62717664f, -0.38549116f, 0.09370092f, 0.04034580f, 0.03179664f, 0.04636282f, -0.17484154f, 
    0.20072728f, -1.72731102f, -0.10111138f, -0.21456653f, 0.32988161f, 0.14791526f, -0.19398086f, -0.13469550f, 
    -0.41690138f, 0.35011566f, 0.01327498f, 0.12846862f, 0.15490799f, -0.43775198f, 1.18157148f, 0.16967027f, 
    0.15796873f, -0.28979155f, -0.98026407f, -0.50479442f, 0.34048340f, -0.07922636f, 0.36697608f, -0.04180149f, 
    -0.06459414f, 0.60014206f, 0.16280521f, 0.11651018f, 0.09575566f, -0.11564963f, -1.11450768f, 0.12548618f, 
    0.38687286f, 0.42634127f, 0.34413004f, -0.31919137f, 0.12244071f, -0.04314333f, -0.15154444f, -0.08632293f, 
    0.28000662f, -0.40331897f, -0.26495188f, 0.21129186f, -0.10219505f, -0.20106387f, -0.65257561f, 0.54077166f, 
    -0.02634594f, 0.30331787f, -0.25805002f, 0.08055879f, 0.05956894f, -0.06143187f, -0.50636429f, 0.13199292f, 
    0.09917877f, 0.01852932f, 0.28648338f, -0.06012009f, 0.10123748f, -0.46488491f, 0.07662240f, -0.25914890f, 
    -0.49428985f, -1.39219153f, -0.49933547f, 0.87870878f, 0.15979283f, -0.12884794f, -0.22561492f, 0.13489208f, 
    -0.60701060f, -1.14109075f, -0.40196928f, -0.20148143f, -0.17027299f, -0.03740091f, 1.20036280f, 0.05371872f, 
    -0.09894228f, 0.14109351f, -0.06143059f, -0.15388508f, 0.68482780f, -0.03144400f, 0.24943861f, -0.16261165f, 
    -0.08524675f, -0.24363028f, -0.40438426f, 0.16510502f, 0.04519986f, 0.48550960f, -0.80394852f, -0.96920621f, 
    -0.57734442f, 0.57139552f, 0.21664856f, 0.06932565f, 0.21604213f, -0.07113785f, -0.11232306f, -0.13915099f, 
    -1.55747831f, 0.21138704f, 0.35727394f, -0.13723913f, -0.10097612f, -0.06838783f, -0.14551461f, -0.97908294f, 
    -0.24750562f, -0.78482193f, -0.50740337f, 0.12025795f, 0.28797761f, -0.07083809f, 0.51173538f, -0.21623918f, 
    -0.42875385f, -0.63011485f, -0.18653417f, 0.05941489f, 0.23231609f, 0.01163393f, -0.16293129f, 1.44279969f, 
    0.82583100f, 0.58871984f, -0.27942106f, -0.54865998f, -1.10761857f, 0.06342293f, -0.27194107f, -0.23432754f, 
    -0.99337357f, 0.11778504f, 0.24110945f, -0.09425940f, 0.04938643f, -0.14930624f, 0.56617957f, -0.56835788f, 
    0.24770388f, -0.36096781f, -0.84576797f, 0.03354939f, -0.53795183f, 0.21466167f, -0.82833993f, 0.00994744f, 
    -0.55516362f, -0.17908028f, 0.06967834f, 0.10095364f, 0.06984391f, 0.75861561f, -0.33220819f, 0.00795660f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.80848634f, -0.06675745f, 0.05808171f, 0.03753797f, 0.02373417f, -0.19897969f, -0.31027001f, -0.46660188f, 
    0.48083389f, 0.57284999f, -0.07224993f, 0.18261722f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
