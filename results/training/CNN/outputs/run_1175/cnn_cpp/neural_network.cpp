#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.43754983f, -0.25659406f, -0.00449362f, 0.59537143f, 0.28055912f, 0.07855269f, -0.09418800f, -0.09154557f, 
    -0.02026893f, -0.21502449f, -0.45268455f, -0.32137945f, -0.05243872f, 0.03171666f, 0.05314139f, 0.07127615f, 
    -0.08033452f, 0.16885655f, 0.20092474f, 0.06829227f, 0.07225426f, -0.15682986f, -0.19512686f, -0.09410225f, 
    -0.10584518f, -0.94394952f, -0.21498017f, -0.08389390f, -0.84225398f, -0.26027140f, 0.03248991f, -0.43353125f, 
    -0.52265954f, -0.19925384f, 0.18003964f, -0.36889926f, -0.34008697f, -0.22135818f, -0.17441040f, -0.17768510f, 
    0.09998937f, -0.25411972f, -0.12299861f, -0.34486797f, -0.42683384f, -0.12038970f, 0.06378681f, -0.16400646f, 
    -0.17269553f, -0.11159396f, -0.13739498f, 0.76212621f, -0.32133761f, -0.47100240f, -0.71489441f, -0.40965232f, 
    -0.01152690f, 0.37023073f, 0.45340329f, 0.48800814f, -0.35777935f, 0.00409542f, 0.44144315f, -0.41761678f, 
    -0.19205987f, 0.00689296f, 0.20702846f, -0.07200590f, -0.14317681f, -0.17087278f, 0.08989731f, 0.16262020f, 
    -0.15117146f, -0.23346089f, -0.00876014f, 0.08533695f, 0.08592395f, 0.30205801f, 0.07570061f, -0.28562188f, 
    -0.25764999f, -0.27305031f, 0.08692686f, -0.01392121f, 0.09972598f, 0.20829691f, 0.10957374f, -0.18898672f, 
    0.11008693f, -0.40854827f, -0.13952526f, 0.20069563f, 0.11695942f, -0.12743343f, 0.05408438f, -0.10731934f, 
    -0.25555012f, -0.29404244f, 0.06341502f, 0.13047178f, 0.86404073f, -0.23433973f, -0.27100977f, -0.30802771f, 
    -0.23736407f, 0.08326954f, 0.20592572f, -0.02026052f, -0.39502820f, -0.10824554f, -0.18280752f, -0.02786351f, 
    0.17416981f, -0.10747048f, -0.02422341f, 0.05292390f, 0.25983694f, -0.07420217f, -0.30148765f, -0.17556243f, 
    0.20265377f, 0.17269318f, -0.12472609f, 0.12852038f, -0.16645345f, -1.12330925f, 0.71742332f, 0.27832329f, 
    -0.58653224f, 0.20250204f, -0.21766008f, -0.15999237f, 0.26093808f, 0.28726998f, 0.02098539f, -0.46168017f, 
    -0.26397070f, 0.00497850f, 0.10637193f, 0.21679151f, 0.12529179f, 0.23211233f, 0.02742113f, 0.07481587f, 
    0.02676290f, -0.37836939f, -0.08997382f, -0.07133018f, -0.33022544f, -0.15486835f, -0.44285467f, -0.35512933f, 
    -0.09784301f, -0.45396838f, -0.62160903f, 0.24736805f, -0.15041330f, 0.14143462f, 0.44919077f, 0.53020972f, 
    -0.25894251f, -0.01740207f, -0.00531053f, 0.18106249f, -0.00080215f, 0.16421629f, -0.25384691f, -0.21972416f, 
    0.11483337f, 0.11770217f, -0.05467020f, -0.26155230f, 0.15870851f, -0.18542954f, -0.27335459f, -0.48560467f, 
    -0.51593214f, -0.69944686f, 0.00836088f, 0.52783483f, 0.02040477f, -0.31443706f, -0.84567690f, -0.46830237f, 
    -0.42312896f, -0.03463107f, 0.09015017f, 0.22413421f, 0.66231763f, -0.26512161f, 0.09238771f, -0.10417377f, 
    -0.10316838f, -0.09691970f, 0.05651214f, 0.09365274f, 0.01335092f, -0.05370825f, 0.04661378f, -0.20103408f, 
    0.21673791f, -0.63720864f, -0.62648195f, -0.25749806f, -0.27597308f, 0.00127672f, 0.28264773f, 0.37609133f, 
    0.27847677f, 0.32803217f, 0.05300396f, 0.12320924f, 0.02959598f, -0.00029434f, 0.19757280f, -0.06566148f, 
    -0.10035366f, 0.03565972f, -0.06358947f, -0.10143784f, -0.03540503f, -0.01204689f, -0.15498744f, 0.33318964f, 
    0.01764374f, 1.20682049f, -0.90066493f, -0.85906726f, -0.24835119f, -0.58826923f, 0.77276373f, 0.68188292f, 
    0.51986271f, -0.19676520f, -0.32830516f, 0.18183950f, 0.15036184f, -0.03155035f, -0.08093670f, -0.08532633f, 
    0.04625130f, -0.16727373f, 0.11694692f, 0.04039640f, -0.03031643f, 0.15650320f, -0.13608772f, -0.05228273f, 
    0.01020388f, 0.05846503f, -0.01213374f, 0.22141464f, -0.20364439f, -0.13154510f, 0.11919713f, -0.41018665f, 
    -0.50033510f, -0.39827853f, 0.11175735f, -0.20410886f, 0.08306717f, 0.25298923f, -0.26499760f, 0.25746483f, 
    -0.02079799f, 0.00038309f, 0.30193955f, 0.15391025f, -0.11438974f, 0.17683513f, -0.23043405f, 0.23320077f, 
    -0.05587649f, -0.02660061f, -0.17695442f, -0.45308870f, 0.06520030f, -0.17900328f, -0.74069983f, -0.78947663f, 
    0.86065429f, -0.31794977f, 0.12210547f, 0.42995030f, 0.25451213f, -0.15110834f, -0.40719661f, 0.08188818f, 
    -0.29271942f, -0.20440461f, -0.24915138f, -0.10673317f, 0.12337878f, -0.23858163f, 0.21045138f, -0.16619463f, 
    -0.08244034f, 0.09528288f, -0.02472075f, 0.22427757f, -0.80968219f, -0.60117263f, -0.15467778f, -0.07680853f, 
    -0.30274129f, 0.18942361f, 0.21723732f, -0.00689331f, 0.16170974f, 0.45483461f, 0.27450401f, 0.22453392f, 
    0.12971064f, -0.01782071f, 0.10754719f, -0.08450615f, 0.01539847f, -0.15015382f, 0.19209954f, -0.12919374f, 
    -0.04101663f, 0.05288725f, 0.15145807f, -0.15770172f, -0.02169200f, 0.33088014f, 0.31039131f, 0.21966922f, 
    0.08892132f, -0.62609488f, -0.39198020f, -0.23457320f, 0.29883566f, 0.10516432f, -0.00804493f, 0.08342234f, 
    -0.00701703f, -0.19004746f, 0.25764585f, -0.05255685f, 0.20425786f, -0.00845770f, -0.24201478f, -0.28784764f, 
    0.26531103f, 0.06525289f, -0.17394674f, -0.24949622f, 0.05323791f, 0.26237655f, 0.53424567f, 0.34905085f, 
    -0.01332817f, 0.10804788f, -0.32141757f, 0.09017095f, -0.17844227f, 0.14829710f, -0.35594133f, -0.20866105f, 
    0.14095582f, 0.30486998f, -0.05213304f, -0.11201391f, -0.18822476f, -0.40184659f, -0.00769779f, -0.05633290f, 
    0.05127792f, 0.24061656f, 0.00242779f, 0.09343341f, 0.19267364f, 0.04478139f, -0.19298400f, 0.20546211f, 
    0.33751422f, 0.15157378f, -0.26837668f, -0.01771966f, -0.03002136f, -0.21166080f, 0.26107118f, 0.06276060f, 
    -0.17832744f, 0.01692604f, 0.00199617f, 0.15689223f, -0.19551465f, -0.03540485f, 0.08568300f, -0.02038247f, 
    -0.16010673f, -0.37216741f, 0.25012162f, -0.19234310f, 0.38612431f, 0.21169399f, -0.37088180f, -0.35827667f, 
    0.71268523f, 0.20323931f, -0.08458179f, 0.15898588f, -0.92011875f, -0.39363140f, -0.49532565f, 0.02065141f, 
    0.46324500f, -0.09983260f, 0.35884795f, -0.39194843f, -0.03934201f, 0.54634356f, -0.07973248f, -0.23841354f, 
    -0.07443934f, 0.04353324f, -0.30478540f, 0.00952405f, -0.15996876f, 0.05938881f, -0.17695136f, -0.25752231f, 
    -0.05704792f, -0.78982615f, -0.47270712f, -0.29052156f, 0.65659243f, 0.35603940f, 0.04806891f, 0.00427890f, 
    0.07945617f, 0.00080698f, -0.23865154f, 0.43123430f, -0.21317632f, -0.28400272f, 0.23826025f, 0.30447519f, 
    -0.00055587f, -0.36353239f, 0.18861541f, 0.26212853f, -0.41441190f, -0.27105385f, 0.38786545f, -0.23099057f, 
    0.32692915f, 0.22373182f, -0.36790279f, -0.45553818f, 0.15422805f, 0.24559571f, 0.32936782f, 0.19430929f, 
    0.09754127f, -0.37110886f, -0.12859748f, 0.42082664f, 0.20093997f, 0.18611085f, -0.13260610f, -0.10742342f, 
    -0.25863466f, 0.20312855f, -0.17474791f, -0.10889379f, -0.19815540f, 0.04256765f, -0.16499673f, 0.14740935f, 
    0.13628063f, 0.28514922f, 0.03416979f, -0.64936972f, -0.33773273f, 0.31924745f, -0.08240938f, 0.04664015f, 
    -0.31276330f, 0.06131344f, 0.14332743f, -0.16985174f, 0.07840862f, 0.22227472f, -0.11647472f, 0.04011462f, 
    0.13104393f, -0.02487634f, -0.01588182f, 0.17707461f, 0.17794552f, 0.19257343f, 0.09666833f, 0.25137141f, 
    0.12501168f, 0.20360725f, -0.22375721f, -0.40835595f, 0.28588587f, -0.32216164f, -0.13129370f, 0.02416726f, 
    0.30147660f, 0.18339711f, 0.42526072f, 0.38696900f, -0.38650727f, -0.50361854f, -0.18994713f, -0.00352652f, 
    0.37727162f, -0.31777844f, 0.16609280f, -0.20520623f, -0.02174517f, 0.06147745f, -0.03823529f, -0.20839880f, 
    0.30047044f, -0.41428915f, -0.20616162f, 0.20500678f, -0.02735138f, 0.48680791f, -0.43024528f, 0.06338884f, 
    0.27542540f, -0.13547312f, 0.25317359f, 0.01903928f, -0.30732274f, -0.26662999f, -0.20808926f, 0.17933686f, 
    0.09819291f, -0.14935866f, -0.30516261f, 0.02558746f, -0.35157573f, -0.03944227f, 0.24000928f, 0.18305542f, 
    -0.11695773f, 0.11631850f, 0.05585076f, -0.20790945f, 0.15429372f, 0.22244139f, 0.39856020f, 0.17706700f, 
    0.07166035f, 0.20181075f, -0.12426002f, 0.18681076f, 0.02076200f, 0.20574351f, 0.11863244f, -0.11846791f, 
    -0.16887584f, -0.15528043f, -0.02456112f, -0.04087739f, -0.22544228f, -0.18351191f, 0.01820200f, -0.09214383f, 
    0.13201013f, 0.12606566f, -0.01154984f, 0.08325619f, -0.06638416f, -0.02763817f, -0.06190139f, -0.05199735f, 
    0.50420713f, 0.43225464f, 0.06546260f, -0.03942958f, -0.00549420f, -0.20985176f, -0.21955484f, -0.43098181f, 
    -0.19917412f, 0.37030110f, -0.47922492f, -0.21653475f, -0.11714702f, 0.03796804f, 0.34565219f, 0.33519596f, 
    -0.07930538f, -0.03603819f, -0.27398267f, 0.03626597f, -0.06022495f, -0.20451331f, -0.15960491f, -0.23789239f, 
    -0.64494312f, -0.06370295f, -0.38706371f, -0.06154473f, 0.77886653f, -0.59428513f, -0.74576074f, 0.66439396f, 
    -0.14465843f, -0.53286809f, 0.34565604f, 0.01365393f, -0.10514877f, -0.04017144f, -0.44719008f, 0.41457626f, 
    -0.04214075f, -0.34597778f, -0.08915624f, -0.25301832f, -0.23011726f, -0.13692252f, 0.10629188f, 0.06446018f, 
    -0.04751951f, -0.21843904f, -0.47507840f, -0.83372492f, -0.69043100f, -0.54364258f, 0.64275169f, 0.31387028f, 
    0.27434009f, 0.06188089f, 0.03498700f, -0.23366626f, -0.32029638f, -0.11396953f, 0.35137841f, -0.02208171f, 
    0.16389897f, 0.04918838f, 0.14660431f, 0.04705316f, -0.03974373f, -0.14331868f, -0.10134778f, 0.36029309f, 
    0.24723817f, 0.14196052f, 0.23224349f, -0.54785192f, -0.59579241f, -0.59075123f, -0.33948356f, -0.23317768f, 
    -0.44409114f, -0.34332296f, -0.17699581f, 0.17973945f, -0.15354145f, -0.07399449f, -0.20824377f, -0.24459022f, 
    -0.38615093f, -0.27429023f, -0.34748831f, -0.33742285f, -0.17221241f, -0.40148622f, -0.20544551f, -0.00266162f, 
    -0.07346196f, -0.09491719f, -0.01881806f, -0.22167788f, -0.51846111f, -0.51832110f, -0.39073935f, 0.14431974f, 
    -0.05023193f, 0.12873618f, -0.15162380f, -0.05227316f, -0.48622695f, 0.04596652f, 0.44940740f, -0.23785651f, 
    -0.31659073f, -0.38975030f, -0.31609935f, 0.06967655f, -0.25732553f, -0.26834029f, -0.08071689f, -0.11392110f, 
    0.00513416f, 0.31909248f, 0.06064247f, 0.27024630f, -0.91832310f, -0.78841114f, 0.36406124f, 0.74825406f, 
    0.35599306f, 0.47058976f, -0.95343643f, -0.94052511f, -0.53876925f, -0.23426019f, -0.43893099f, -0.20164195f, 
    0.28226653f, -0.52619427f, -0.10439096f, -0.00470477f, -0.27803522f, 0.01901105f, -0.05432452f, -0.03328190f, 
    0.09718657f, -0.02834629f, -0.23658988f, -0.04370842f, 0.03780277f, 0.13287233f, -0.19478896f, -0.26713139f, 
    0.19356561f, 0.25177839f, -0.28448385f, -0.44929487f, -0.17528681f, 0.20628284f, 0.16903466f, 0.52815783f, 
    -0.42552468f, -0.18167423f, 0.13577873f, 0.20079862f, 0.13849349f, 0.18172814f, -0.09987748f, -0.02996626f, 
    -0.41339558f, -0.31469053f, 0.04308707f, 0.36342064f, 0.20954864f, 0.07614814f, -1.27666676f, 0.16280824f, 
    -0.11792207f, -0.71490109f, 0.27637094f, -0.29879335f, 0.05434120f, 0.22793980f, 0.41613483f, 0.17271896f, 
    -0.58546782f, -0.45284265f, -0.44877559f, -0.09622865f, 0.61414289f, 0.09879958f, -0.16875249f, -0.17640467f, 
    0.19559196f, -0.22572877f, -0.18572077f, -0.21202093f, -0.01076396f, -0.17432435f, -0.34354356f, 0.42656928f, 
    0.22808367f, -0.16344684f, -0.83471990f, -0.91833389f, 0.31802899f, -0.41945109f, -0.26951829f, 0.40187275f, 
    -0.04719630f, 0.16314980f, 0.06338747f, 0.19022416f, 0.02480384f, 0.36823216f, -0.10675129f, 0.13214637f, 
    -0.15691686f, -0.09831379f, -0.07687333f, 0.16576125f, -0.01417666f, 0.19350758f, 0.09778641f, -0.17072059f, 
    0.64195526f, -0.56598741f, -0.37450930f, 0.22265531f, -0.05473502f, 0.05636493f, -0.04637524f, 0.04088851f, 
    0.24087022f, 0.16236909f, 0.22523330f, -0.07050840f, -0.28480139f, 0.05752578f, 0.31040251f, -0.21488833f, 
    0.17266662f, -0.04608562f, 0.01006123f, -0.22313865f, 0.11910857f, -0.24601142f, 0.22017786f, 0.13421577f, 
    -0.18930408f, -0.06643034f, -0.40534073f, -0.34757167f, -0.25213054f, -0.04631667f, -0.31049442f, -0.37424514f, 
    -0.00687176f, -0.04583022f, -0.24492663f, 0.09611584f, 0.41215321f, 0.32574081f, 0.32468504f, -0.10247009f, 
    0.04731351f, -0.29298788f, -0.22634095f, -0.19214232f, 0.11429621f, -0.23277341f, -0.25515264f, -0.21563125f, 
    -0.30178508f, -0.08909869f, -0.69159466f, 0.17973679f, 0.06733182f, 0.08828389f, 0.15785091f, -0.23971067f, 
    0.06590452f, 0.24287671f, 0.39524138f, 0.43002400f, 0.06866590f, 0.29221016f, -0.14258973f, -0.48333466f, 
    -0.02268525f, -0.00072539f, -0.09486740f, -0.19788064f, -0.19494765f, 0.03439667f, 0.11879864f, 0.12857980f, 
    0.30327362f, -0.18709964f, 0.05131767f, 0.35315582f, -0.02827940f, -0.08330171f, 0.00060316f, -0.05746122f, 
    0.11304638f, -0.12754716f, 0.32503098f, 0.18664899f, -0.18081926f, -0.26892957f, 0.47199309f, -0.41386411f, 
    -0.34409824f, -0.11598276f, 0.13635923f, -0.21787225f, 0.22140737f, -0.10661083f, 0.04189933f, 0.14579415f, 
    -0.16973187f, -0.32729077f, 0.04910736f, 0.23694409f, -0.05070148f, -0.00165525f, 0.12861744f, -0.06116046f, 
    0.01429963f, 0.42601627f, 0.46761137f, -0.42105290f, -0.35795730f, 0.15532590f, 0.11299688f, 0.09195583f, 
    0.00034644f, -0.36299324f, -0.11930139f, 0.21279228f, -0.25360778f, -0.04155804f, 0.19183618f, -0.08912058f, 
    0.08823844f, 0.17978261f, 0.10886751f, -0.08959774f, -0.13353024f, -0.42135286f, -0.58953273f, -0.04561334f, 
    0.01353275f, 0.50059152f, -0.12648226f, -0.51553738f, -0.24019450f, 0.22838928f, 0.58907896f, -0.08151444f, 
    -0.00219354f, -0.19646347f, -0.22662935f, 0.52067292f, -0.24365945f, 0.24648900f, -0.04596900f, 0.01205408f, 
    -0.00684823f, 0.00489920f, -0.32556522f, -0.26548073f, 0.17372237f, -0.11213768f, -0.44329089f, -0.16296600f, 
    0.05184415f, -0.18894580f, 0.13489120f, 0.10211512f, -0.26993126f, -0.12669210f, 0.21716021f, 0.46622658f, 
    0.02406765f, -0.40306294f, 0.12602219f, -0.55058020f, 0.26319435f, -0.09295880f, -0.19516186f, 0.38317010f, 
    0.34488913f, -0.38927421f, 0.01961940f, 0.22727698f, -0.07945013f, -0.15379818f, 0.33343750f, -0.67315173f, 
    0.36652991f, 0.01098695f, -0.19635417f, -0.26973885f, -0.31731525f, -0.00390940f, -0.04154818f, 0.41107708f, 
    -0.11402766f, 0.21228535f, 0.15654568f, -0.09161139f, 0.38382041f, -0.22784624f, -0.28516248f, -0.24842483f, 
    -0.06484503f, -0.40426838f, -0.04539284f, 0.03310837f, -0.06201158f, 0.08564114f, 0.16606164f, 0.37990147f, 
    -0.03121969f, -0.80821222f, 0.30782944f, 0.08651244f, 0.40509367f, -0.68771577f, -0.64882022f, 0.21611805f, 
    0.40204743f, 0.15343194f, -0.22555783f, 0.00648385f, -0.16748852f, -0.01942892f, -0.08976828f, -0.02221468f, 
    0.05446752f, -0.19688328f, -0.07605599f, -0.42003945f, -0.15647514f, 0.13441251f, -0.13702816f, -0.12568985f, 
    0.12334476f, -0.66261226f, -1.17230773f, -0.42046848f, 0.27440065f, 0.32356164f, 0.23705262f, 0.30220449f, 
    0.01969039f, -0.22157611f, 0.18796374f, 0.01317298f, 0.09002320f, 0.27972010f, -0.30733740f, 0.05978196f, 
    0.09920608f, 0.03437280f, 0.08198941f, 0.04415756f, 0.30544466f, -0.24854144f, -0.01520272f, -0.09267243f, 
    0.00531624f, -0.28478485f, -0.77771968f, -0.01884441f, 0.17564669f, 0.36698964f, 0.21647878f, 0.31568077f, 
    -0.50054383f, -0.33707476f, 0.29242772f, 0.32143548f, 0.03718886f, 0.13066466f, -0.35360801f, 0.10571101f, 
    0.17903161f, -0.18345213f, 0.05798706f, -0.17109589f, 0.27660072f, -0.04419661f, 0.11163215f, 0.08600500f, 
    0.11000374f, -0.06049038f, -0.26184821f, 0.55561680f, 0.22142890f, -0.29301476f, -0.15256992f, -0.02183065f, 
    0.11979549f, -0.01307598f, -0.07730779f, 0.20425096f, 0.03058860f, -0.02685611f, -0.12739541f, -0.18043056f, 
    -0.23338935f, -0.15107693f, 0.16769129f, -0.06692413f, -0.20272896f, 0.09388932f, -0.08093262f, -0.31452575f, 
    -0.23851109f, -0.21608368f, -0.42230251f, -0.35233426f, 0.00957188f, -0.47661838f, -0.48644793f, -0.37146199f, 
    -0.31910691f, -0.38387665f, -0.67667878f, -0.66728497f, -0.68870407f, -0.57761598f, 0.19299957f, 0.00484646f, 
    0.19126515f, 0.61268306f, 0.04463154f, -0.16668263f, -0.13153017f, 0.02335243f, 0.05887870f, -0.29566264f, 
    -0.42082155f, -0.12317762f, 0.21806422f, 0.12204789f, -0.14210340f, -0.86842716f, -0.33240932f, -0.43620431f, 
    -0.01125350f, -0.21102847f, 0.16834520f, 0.13490856f, 0.41403887f, 0.22214423f, 0.19749983f, 0.15076989f, 
    0.22234225f, 0.06670959f, 0.20334817f, -0.27516639f, -0.07935395f, -0.01513944f, -0.15028945f, -0.18606922f, 
    0.18106543f, -0.03766055f, -0.15706512f, 0.11576085f, 0.00627019f, -0.17540324f, -0.86340684f, -0.72759485f, 
    -0.18018192f, 0.57263094f, 0.68211448f, 0.60472280f, -0.32515901f, -0.32368261f, 0.18697591f, 0.22630826f, 
    -0.34828874f, -0.26046428f, 0.02421620f, 0.10137314f, 0.17558248f, -0.09668617f, 0.16449408f, -0.05271791f, 
    0.07203343f, -0.12269190f, 0.05577104f, -0.32323915f, -0.19273049f, 0.34931487f, 0.32088020f, 0.47019783f, 
    0.90808254f, 0.53081322f, -0.32967705f, 0.03130883f, 0.26286158f, -0.14554115f, -0.39850003f, -0.12787645f, 
    -0.09786428f, -0.13384777f, 0.12348162f, 0.28547767f, -0.24844165f, -0.28962952f, -0.07132377f, -0.00300151f, 
    -0.10224584f, 0.08781353f, -0.13339381f, -0.08695368f, -0.04503224f, -0.06501067f, -0.25785559f, 0.00612662f, 
    -0.35558176f, -0.35540468f, 0.29431900f, 0.41988501f, 0.28894144f, 0.56902075f, -0.11124212f, -0.37622219f, 
    -0.06535083f, 0.01977637f, -0.39759275f, 0.02365265f, 0.10573279f, 0.39972690f, -0.10024485f, -0.25431344f, 
    -0.15460803f, -0.12275576f, 0.01300285f, 0.32749167f, -0.02112414f, -0.09901611f, 0.01177578f, -0.02742194f, 
    0.11162666f, -0.42089221f, -0.08632907f, -0.16672578f, 0.30269805f, -0.08092994f, 0.29127640f, 0.03909566f, 
    -0.12662341f, -0.33121219f, 0.27159187f, 0.08221293f, 0.28064927f, -0.14380608f, -0.17761818f, 0.01768503f, 
    -0.32701671f, 0.15011413f, 0.07248822f, -0.12185249f, -0.13328132f, 0.03693930f, 0.27251691f, 0.00800338f, 
    -0.03251337f, 0.17219500f, 0.16744837f, -0.92623991f, 0.33829415f, 0.94623971f, 0.12160280f, 0.51270431f, 
    -0.30870560f, -0.77561414f, -0.86214149f, -0.51639533f, 0.02246522f, -0.08814187f, -0.16721641f, -0.22084029f, 
    0.44679621f, -0.28012446f, -0.11354867f, 0.31402951f, -0.09967478f, 0.44624433f, 0.03246827f, -0.02654205f, 
    0.13229908f, -0.09137542f, -0.26773807f, 0.00766736f, -0.29635179f, 0.06130663f, 0.17100315f, 0.36783221f, 
    0.20307299f, -0.00392825f, -0.01705161f, -0.36171171f, -0.50693554f, 0.07805168f, -0.01839921f, 0.09085103f, 
    0.05028918f, 0.27807525f, -0.40922144f, 0.16763213f, 0.02625668f, -0.17536226f, 0.18489841f, 0.00607818f, 
    0.01078802f, -0.02576101f, 0.13297375f, 0.07198445f, -0.08264761f, -0.41991928f, -0.66514277f, -0.35548443f, 
    -0.52376729f, -0.27963325f, 0.05685731f, 0.29392990f, -0.08542917f, -0.01809527f, 0.09309431f, 0.05331380f, 
    -0.21825944f, -0.16899414f, -0.20593259f, 0.05717700f, 0.28793719f, 0.35077709f, 0.01636096f, -0.11052286f, 
    -0.26842237f, -0.24643797f, -0.27746639f, -0.39494434f, 0.13922173f, 0.40974423f, 0.36359191f, 0.31662676f, 
    0.13149171f, -0.28857920f, -0.53633624f, -0.22597592f, 0.37345454f, -0.14518157f, -0.32764193f, 0.03389987f, 
    -0.12413748f, 0.12288685f, -0.26002520f, 0.16025846f, -0.09881651f, 0.29903373f, -0.02930942f, 0.08680706f, 
    0.02009214f, -0.03297215f, -0.19972098f, -0.34827751f, -0.38149896f, -0.18462500f, -0.00410989f, -0.79132956f, 
    -0.17414501f, 0.18332295f, 0.19349381f, 0.23767111f, 0.40211654f, -0.03014367f, -0.20948945f, -0.17279090f, 
    -0.10403295f, -0.26274839f, -0.15337297f, 0.09013193f, 0.08292548f, 0.06650151f, 0.10132289f, -0.16669995f, 
    -0.26202956f, -0.34274390f, -0.06755871f, -0.33206514f, -0.41569883f, -0.54272968f, -0.54514354f, 0.61789167f, 
    -0.66147125f, -0.30297843f, -0.32905635f, -0.50601393f, 0.25038323f, -0.04566545f, -0.19439927f, 0.08687646f, 
    0.17756930f, 0.06639323f, 0.29459757f, 0.31218919f, 0.03091026f, -0.21496148f, -0.11439795f, -0.21931656f, 
    0.22326897f, -0.12259317f, -0.04881449f, -0.26533464f, 0.01094455f, -0.21876489f, 0.15229607f, -0.02885872f, 
    0.23687664f, 0.27367052f, -0.23622738f, -0.59745282f, 0.22977866f, 0.34506297f, -0.25020117f, 0.57788831f, 
    -0.71025032f, -0.32905382f, -0.13207790f, 0.05042084f, 0.14146745f, 0.09173235f, -0.30635366f, 0.17422032f, 
    0.15543717f, 0.28614819f, -0.08600165f, -0.24838164f, -0.06989547f, -0.15246871f, -0.17546366f, 0.25035426f, 
    -0.09942634f, -0.81122267f, -0.74054104f, -0.35721096f, 0.09477344f, -0.44392258f, 0.45290193f, 0.06537978f, 
    -0.27129364f, 0.32446176f, 0.42248207f, -0.38076577f, -0.14613084f, 0.14374125f, 0.13104264f, 0.22963373f, 
    -0.09442271f, -0.20548122f, -0.37340030f, -0.44753978f, -0.54584718f, 0.00663507f, -0.11230693f, 0.44324821f, 
    0.33897188f, -0.04984276f, -0.00546966f, -0.51271349f, -0.86317903f, -0.63957059f, -0.73546797f, 0.53924930f, 
    0.43787050f, 0.25329939f, 0.24584521f, 0.03599770f, -0.25565365f, 0.25157449f, -0.33772230f, -0.17162652f, 
    -0.25039917f, -0.04202032f, -0.23867150f, -0.13566150f, 0.24883381f, 0.17942181f, 0.17192918f, 0.06986786f, 
    0.10487283f, 0.24559852f, -0.26065597f, -0.44560128f, -0.32509711f, -0.16772005f, -0.26391324f, -0.31802669f, 
    -0.40559655f, -0.48608837f, 0.00447833f, -0.44395858f, -0.79911578f, 0.44444531f, 0.03544851f, 0.19615015f, 
    -0.01618425f, 0.20083360f, -0.05986075f, -0.17404924f, 0.26087505f, -0.29403588f, -0.09468777f, 0.11010104f, 
    0.41098332f, 0.26938859f, -0.05653915f, -0.03017472f, 0.57183629f, -0.35275054f, -0.42628551f, -0.16657789f, 
    -0.15739886f, -0.12875828f, -0.06135662f, -0.06163350f, 0.09448273f, 0.07435575f, 0.35896453f, 0.03385748f, 
    0.25675556f, 0.05538966f, -0.33916497f, -0.02826618f, -0.35263553f, -0.01241154f, -0.04692409f, -0.32445621f, 
    0.13859840f, 0.10701913f, 0.21052505f, 0.28713465f, 0.32453194f, 0.01445135f, 0.36567706f, 0.01041671f, 
    -0.40328309f, -0.70410985f, 0.18184756f, 0.39694741f, -0.06857765f, 0.01117438f, -0.05228743f, -0.12500720f, 
    0.13787985f, 0.37578371f, -0.02842720f, -0.03262245f, -0.20818922f, -0.17377099f, -0.23159547f, 0.01254777f, 
    0.27364051f, 0.08685437f, 0.02136065f, 0.26770163f, 0.22094385f, -0.24459094f, 0.26317272f, 0.52206534f, 
    -0.28514358f, -0.35679197f, 0.02778610f, -0.34495887f, -0.01916118f, -0.38674876f, -0.60316855f, -0.36857912f, 
    0.05783813f, 0.51009011f, -0.24794562f, 0.29474384f, -0.11311366f, -0.08212838f, -0.44638276f, -0.25877053f, 
    -0.20772371f, -0.27786398f, -0.12003813f, -0.28842762f, -0.18501341f, -0.11184973f, -0.38181698f, -0.11055759f, 
    0.12547889f, -0.31285405f, -0.05531127f, -0.27787751f, -0.25412899f, 0.19103277f, 0.28672996f, 0.21402173f, 
    0.10547928f, -0.08890657f, 0.11798305f, 0.02293724f, -0.06430311f, -0.00311830f, -0.47265500f, 0.15007362f, 
    0.15262467f, 0.21278481f, -0.04329880f, 0.14749905f, -0.04701836f, -0.33988032f, 0.38913205f, 0.02047273f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.26012105f, -0.53000432f, 0.04651211f, 0.04062627f, 0.04016872f, 0.02374272f, -0.05474102f, -0.12624145f, 
    0.04273396f, 0.25718963f, 0.01539333f, -0.24432611f, 0.32650161f, 0.26673004f, 0.15010609f, 0.04856697f, 
    0.18047847f, 0.10664976f, 0.12674019f, 0.02244612f, 0.35725129f, 0.07171697f, -0.22711095f, -0.04855948f, 
    0.19466428f, -0.40710494f, -0.13933782f, -0.05706255f, 0.11425380f, 0.24547854f, -0.05668002f, 0.41143280f, 
    0.25433177f, -0.26368859f, 0.36616716f, 0.08991554f, 0.08808937f, 0.18056767f, 0.01193515f, 0.29020530f, 
    0.20370260f, -0.09212268f, -0.05617376f, -0.08991638f, -0.41992146f, 0.04412574f, 0.34225893f, 0.24392028f, 
    0.19318202f, 0.13638486f, 0.19267486f, -0.12618688f, -0.24671732f, -0.00114750f, -0.01792831f, 0.29333362f, 
    0.04888077f, 0.14716081f, -0.24551180f, 0.04098644f, -0.04237297f, 0.08911943f, -0.18295762f, 0.02025774f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.26927227f, 0.02288154f, 0.20917173f, -0.17909974f, -0.03713102f, -0.04838859f, -0.02713727f, 0.10129164f, 
    0.02214508f, 0.01766348f, 0.02161669f, 0.02006088f, 0.21072932f, 0.25595227f, 0.09408125f, -0.10942397f, 
    0.04022942f, 0.33213571f, 0.12388344f, -0.05880448f, -0.04847061f, -0.03693027f, -0.03991053f, -0.05606465f, 
    -0.43394276f, -0.34353667f, 0.09630081f, 0.03627779f, -0.00355655f, -0.00359928f, 0.00180557f, -0.12401585f, 
    0.01214680f, -0.10421113f, -0.04693006f, 0.00915477f, -0.24137902f, 0.13835080f, -0.00327104f, -0.25572297f, 
    0.03689663f, 0.01641557f, -0.03101904f, -0.02994126f, -0.11316895f, -0.02358651f, 0.02385917f, 0.07745686f, 
    -0.04785021f, 0.03032866f, -0.22512589f, 0.06707108f, -0.11261173f, -0.18446408f, -0.07536602f, -0.10179133f, 
    -0.02154655f, -0.04764762f, -0.02412322f, -0.02921009f, -0.34831479f, -0.00354564f, 0.17482597f, 0.09451383f, 
    -0.07108364f, 0.19284225f, 0.03238329f, 0.07048783f, 0.07956804f, 0.09669573f, 0.06920093f, -0.01163772f, 
    -0.22342680f, -0.12271847f, 0.09539666f, 0.03832674f, 0.07807350f, 0.11779740f, 0.01500187f, 0.04735815f, 
    0.15423323f, 0.10543423f, -0.07801066f, 0.09070027f, 0.36615381f, 0.16759020f, -0.18111840f, -0.22974713f, 
    0.01235898f, 0.04773335f, 0.21667713f, 0.07837654f, -0.02724471f, -0.05677381f, 0.03057588f, -0.02382621f, 
    -0.03284611f, -0.05581823f, -0.00373225f, 0.09643959f, 0.03397729f, 0.04392911f, 0.04303124f, 0.02875705f, 
    0.04950745f, -0.07125160f, -0.07074223f, 0.02401854f, 0.09192867f, -0.28583878f, -0.68623060f, 0.02359733f, 
    0.08456542f, -0.03946947f, -0.08691816f, -0.04434985f, -0.01728547f, -0.11607441f, -0.32792130f, -0.11129940f, 
    0.18599154f, 0.19700447f, -0.02076973f, -0.11348695f, 0.01875963f, 0.03028368f, -0.15645492f, -0.02890386f, 
    0.06726929f, 0.02582148f, -0.00516765f, 0.04871616f, 0.06656926f, 0.12018746f, 0.00923525f, -0.15577713f, 
    -0.09212865f, 0.19202077f, -0.14733543f, 0.07659715f, 0.06856079f, 0.04320046f, 0.07012945f, -0.06193884f, 
    0.18933403f, 0.10081642f, 0.03315817f, -0.01491908f, 0.07928639f, 0.04139747f, 0.04269173f, -0.01481872f, 
    -0.00747142f, -0.04561689f, -0.11108867f, -0.01396861f, -0.24040301f, -0.27287632f, 0.03953434f, -0.02549884f, 
    -0.00042604f, 0.04641105f, -0.03843180f, -0.01666208f, -0.11718836f, 0.01346755f, -0.09363248f, 0.00759436f, 
    -0.38042963f, -0.46305829f, -0.16042694f, -0.03177591f, -0.02133071f, -0.10298762f, -0.02152704f, 0.05944957f, 
    -0.04109176f, 0.07249141f, 0.04439992f, -0.03789855f, -0.30426511f, -0.42344940f, -0.22657210f, 0.03048293f, 
    0.06758155f, 0.01830794f, 0.05699565f, 0.04155967f, 0.03341085f, -0.02194650f, -0.04735522f, 0.01773082f, 
    -0.14950959f, -0.19018403f, 0.01974000f, -0.25182068f, -0.23178349f, -0.04635878f, -0.06476756f, 0.00275531f, 
    -0.14029787f, -0.01122122f, -0.08295529f, -0.07727102f, 0.05558365f, 0.11475146f, 0.15940265f, -0.20169221f, 
    -0.03701828f, 0.06297921f, 0.09551792f, -0.22512640f, -0.04534366f, -0.16972002f, -0.12407091f, 0.06664599f, 
    -0.03789513f, 0.07862636f, 0.12671442f, -0.04539540f, -0.13163701f, -0.06907279f, 0.07065489f, -0.02905989f, 
    -0.07115458f, -0.07333539f, -0.06189806f, -0.18653494f, 0.08795989f, 0.08111025f, 0.08743513f, -0.05609556f, 
    -0.16503479f, -0.03624601f, -0.04715034f, -0.13962168f, -0.04956816f, 0.02757718f, 0.02067475f, 0.08819883f, 
    -0.16566281f, -0.49705374f, -0.39485136f, 0.00471093f, -0.04867901f, 0.02761788f, -0.06065032f, -0.05654166f, 
    0.01332398f, -0.03781967f, 0.00360899f, -0.08132443f, -0.04700806f, -0.11115541f, -0.05441330f, 0.00644215f, 
    -0.04729992f, 0.05305713f, -0.05353573f, -0.09419337f, -0.05786966f, 0.01240373f, 0.01231177f, 0.02183539f, 
    -0.07594150f, -0.05767807f, -0.08628929f, -0.04640598f, 0.09405167f, 0.03489994f, 0.02710307f, 0.04349680f, 
    0.06831257f, 0.02132489f, 0.04410717f, 0.00850821f, -0.22032483f, -0.04591651f, -0.07967307f, -0.01460950f, 
    0.04326723f, -0.08073873f, -0.17482299f, -0.14010981f, -0.03730485f, 0.03678148f, 0.11117913f, 0.00697202f, 
    0.26449478f, 0.17110434f, 0.10533189f, -0.15582711f, -0.02704973f, 0.09742384f, 0.07191648f, 0.06175625f, 
    -0.01950346f, -0.04790634f, -0.13727912f, 0.00056406f, 0.22255886f, -0.09182674f, -0.14336711f, 0.03174898f, 
    0.06653940f, 0.27347389f, 0.07117962f, 0.06505069f, 0.03674829f, 0.00836740f, 0.04269144f, 0.04140050f, 
    0.13583194f, 0.16748556f, 0.02515255f, -0.08528136f, 0.17393635f, 0.05335359f, -0.02919323f, -0.10116664f, 
    -0.14281209f, -0.17369652f, -0.04906623f, -0.03226637f, 0.20192465f, 0.03144290f, -0.12995535f, -0.10776957f, 
    0.18373311f, 0.06902176f, 0.07540050f, -0.00685193f, -0.00823424f, -0.11183763f, -0.02291035f, -0.14952855f, 
    0.47204149f, 0.37258357f, -0.11601457f, -0.26150212f, 0.11024316f, 0.01860163f, 0.04953901f, -0.04373758f, 
    -0.00490133f, -0.04911303f, -0.02764381f, 0.01231281f, -0.03956966f, 0.17656150f, -0.00550252f, -0.24404314f, 
    -0.11605774f, 0.05838422f, -0.08944844f, -0.24104470f, -0.01076662f, -0.03941655f, -0.29402372f, -0.06647535f, 
    -0.08122463f, 0.18704605f, 0.17882219f, -0.06966741f, -0.20459653f, 0.19482356f, 0.04093014f, -0.04535249f, 
    -0.10287891f, -0.02662266f, 0.07934610f, 0.05563600f, 0.24624716f, -0.23381004f, -0.15032387f, 0.05067364f, 
    -0.09816319f, 0.02837401f, -0.14094438f, -0.06004601f, -0.03181845f, -0.08879475f, -0.03818731f, -0.00931050f, 
    -0.29861930f, -0.05950493f, -0.15497591f, 0.06935135f, -0.01121493f, 0.00333108f, 0.02173305f, -0.03359150f, 
    0.00052355f, 0.01581455f, -0.24565955f, -0.13307281f, 0.25007689f, 0.17872167f, -0.00952893f, -0.14133364f, 
    0.01960381f, -0.02061096f, -0.00174278f, -0.01394598f, 0.06990424f, 0.04554905f, 0.03779190f, -0.00282444f, 
    -0.26746681f, -0.17402016f, 0.16654168f, -0.29989052f, 0.00178527f, 0.00572929f, 0.04307117f, 0.04608665f, 
    -0.07643717f, -0.00549891f, 0.04278716f, -0.13820501f, -0.37656537f, -0.38616121f, -0.13353464f, 0.08333056f, 
    -0.01573296f, 0.00367803f, -0.00835238f, -0.00222962f, -0.02572120f, 0.04984055f, 0.11283511f, -0.13358317f, 
    0.03748377f, -0.04055374f, -0.03336149f, -0.10310055f, 0.04659000f, -0.05896785f, 0.13370621f, 0.00801063f, 
    -0.02846132f, -0.04689019f, 0.07047668f, 0.06858736f, -0.06137319f, 0.30747569f, 0.11098913f, -0.09283496f, 
    -0.07186412f, 0.14351563f, 0.03889165f, 0.02196665f, -0.05683513f, -0.01698479f, -0.08972637f, -0.09724104f, 
    0.00175345f, 0.16750944f, 0.07621779f, -0.06900871f, 0.00074235f, 0.02531558f, 0.09833523f, -0.17175071f, 
    0.13924594f, -0.00441331f, -0.01095032f, -0.14818391f, -0.06467735f, -0.00020873f, 0.11094681f, -0.13647588f, 
    -0.02000725f, -0.06504552f, -0.15061900f, -0.09074973f, -0.08856236f, -0.09794538f, -0.11764461f, -0.23077877f, 
    0.01784139f, 0.20418826f, 0.29789335f, -0.25691834f, -0.10026132f, -0.04921089f, 0.03325334f, -0.06010348f, 
    -0.01727216f, -0.09145434f, -0.16001818f, -0.05083417f, 0.32059190f, 0.14307220f, -0.06894659f, 0.02210049f, 
    0.15856649f, 0.07235005f, 0.13353598f, -0.11300904f, -0.01702747f, -0.02610600f, 0.01473502f, 0.02565542f, 
    0.00930802f, 0.09408491f, 0.14117800f, -0.09375165f, -0.06631269f, 0.03041664f, 0.06755647f, 0.03382333f, 
    -0.04588179f, 0.00809050f, -0.17029481f, -0.19633906f, -0.48998073f, -0.18538593f, -0.04856796f, 0.05820002f, 
    0.05228937f, 0.05203423f, 0.08786593f, 0.04355589f, -0.00388466f, -0.06267392f, 0.07487893f, 0.13369921f, 
    0.38722858f, 0.14575459f, -0.12769879f, -0.17788701f, 0.14488088f, 0.04981301f, -0.00329513f, 0.08179894f, 
    -0.01218556f, 0.03998156f, 0.01265779f, 0.04854043f, 0.15860201f, 0.01230854f, 0.08500397f, -0.02029615f, 
    0.07626488f, 0.05789121f, 0.02354849f, 0.07365855f, -0.03192995f, -0.02556351f, -0.00772544f, 0.04095992f, 
    0.27637240f, 0.15629387f, 0.10811602f, -0.14813825f, -0.27046216f, -0.06374938f, 0.01261027f, -0.04258462f, 
    -0.16499716f, -0.14003685f, -0.04402919f, -0.18775888f, -0.51699036f, -0.22468673f, -0.77265239f, 0.42450738f, 
    0.08932139f, 0.03354416f, 0.01555573f, 0.03702713f, -0.05142801f, 0.02369292f, 0.02308564f, 0.07757545f, 
    0.19921781f, -0.19203790f, -0.29131097f, -0.05309030f, -0.00283366f, -0.06642035f, -0.02701871f, 0.06960305f, 
    0.07398257f, -0.06849937f, 0.01877523f, -0.15239042f, 0.01064199f, 0.02259496f, 0.02302902f, -0.01558797f, 
    -0.11884399f, 0.05909485f, -0.02779935f, -0.13970274f, -0.11668520f, -0.09948824f, -0.08727762f, -0.09383892f, 
    0.29915276f, -0.00993884f, -0.19909324f, -0.23052800f, -0.12559332f, -0.01954328f, 0.10524330f, 0.15083289f, 
    -0.05221897f, -0.02814144f, 0.03723663f, 0.01984294f, -0.01808479f, -0.04519223f, 0.07667500f, 0.06718495f, 
    -0.16092426f, -0.03736953f, -0.04553590f, -0.05753445f, 0.00796717f, -0.02713076f, 0.00120843f, -0.07197762f, 
    0.24528511f, 0.08844656f, -0.00128351f, -0.03086012f, 0.20161875f, 0.14786756f, 0.18733488f, 0.18533602f, 
    0.03479878f, 0.10582508f, 0.04629190f, 0.05267921f, -0.20841403f, -0.22818106f, 0.13977149f, -0.04923084f, 
    0.03517302f, 0.02060403f, -0.25715318f, 0.06960080f, 0.03062686f, 0.07448968f, 0.00308619f, 0.05116632f, 
    0.04701851f, -0.30245152f, -0.33974063f, -0.05624945f, -0.05022356f, 0.00189913f, 0.07538889f, -0.00320385f, 
    0.04450285f, 0.00420675f, 0.13039416f, 0.21681640f, 0.14159591f, -0.03571614f, -0.17717674f, 0.02003432f, 
    0.03439282f, 0.04370677f, -0.03101281f, -0.15117624f, -0.05673656f, 0.10184611f, -0.07994848f, 0.07302141f, 
    0.10996399f, -0.09426560f, -0.38825485f, -0.03093059f, -0.03267501f, 0.01969814f, -0.06219699f, 0.02165468f, 
    -0.00706807f, 0.00529913f, 0.04663707f, 0.08537711f, 0.10855391f, 0.02225751f, -0.02367847f, -0.07449280f, 
    -0.00127056f, 0.08001942f, -0.01553036f, -0.21299513f, -0.10107826f, -0.01960258f, -0.04113478f, 0.02517158f, 
    0.24369168f, -0.18700644f, -0.25186622f, -0.00119222f, 0.08875497f, 0.14387999f, 0.16357100f, -0.03845028f, 
    0.02258851f, -0.00274577f, 0.01892626f, 0.12108422f, 0.20155118f, 0.11958228f, -0.21486253f, -0.27483124f, 
    -0.00261479f, 0.11398081f, 0.03213446f, 0.02924779f, -0.01553711f, -0.01487247f, 0.02505156f, -0.01685413f, 
    0.07186716f, 0.12337730f, -0.16193952f, 0.05188675f, 0.21435113f, 0.02899942f, -0.03116423f, -0.24967937f, 
    -0.11632214f, -0.21055532f, -0.13330208f, -0.00800030f, -0.02951850f, -0.39687604f, -0.02548101f, 0.05685763f, 
    0.03509478f, -0.08609087f, -0.01763240f, -0.11593770f, -0.10618039f, -0.08302800f, -0.08358181f, -0.08282267f, 
    0.14356574f, 0.10995761f, -0.27481341f, 0.02427386f, -0.23939441f, -0.24565563f, -0.20564823f, -0.03286872f, 
    -0.00900777f, 0.07533551f, -0.02318633f, -0.06868552f, -0.14028868f, -0.07904453f, -0.03472615f, 0.04908135f, 
    0.08822076f, 0.01891499f, -0.26447606f, -0.04723318f, -0.01259532f, -0.15834948f, 0.03517289f, -0.05903911f, 
    -0.26651236f, 0.04166869f, -0.06751531f, -0.11421668f, -0.09156828f, -0.07236430f, -0.02257834f, 0.18252425f, 
    0.23801519f, -0.00403692f, 0.02764948f, -0.07267503f, 0.18114237f, 0.26222056f, 0.10946152f, 0.45326826f, 
    0.15536445f, 0.10525560f, -0.28017458f, 0.20444532f, -0.03815575f, 0.03904261f, 0.01382565f, -0.03720169f, 
    -0.79176986f, -0.21076402f, 0.19683023f, -0.30300373f, 0.01130083f, 0.12121706f, -0.11174861f, -0.03780319f, 
    -0.10248297f, -0.01437043f, -0.11778455f, 0.07864509f, 0.06190900f, 0.01177265f, 0.14149909f, -0.12714352f, 
    -0.00001561f, -0.01584168f, -0.00745615f, -0.01616212f, 0.13959055f, -0.14392149f, 0.03049601f, 0.05330734f, 
    0.54190338f, -0.16147187f, 0.01002646f, 0.00067710f, -0.15927474f, -0.08550971f, 0.09888297f, -0.01017956f, 
    -0.16724178f, -0.07466182f, 0.08389388f, 0.04117495f, -0.34098974f, 0.01673862f, 0.01496116f, -0.05073507f, 
    0.27044588f, 0.03851021f, -0.23634766f, 0.06823746f, -0.06897300f, 0.18899883f, -0.11861452f, -0.07714476f, 
    -0.24409126f, 0.06169924f, -0.06143998f, -0.07309351f, -0.01799575f, 0.04608041f, -0.01985544f, -0.21099953f, 
    -0.05824407f, -0.02173547f, 0.08382222f, -0.08274393f, -0.09819567f, -0.18479939f, 0.09076462f, 0.26094124f, 
    -0.04358556f, -0.15038696f, 0.18500832f, -0.14225021f, 0.00542309f, -0.03957845f, 0.01877945f, 0.00108114f, 
    0.13859278f, -0.15690818f, -0.06543488f, -0.09983052f, 0.01474545f, 0.01776995f, -0.03156655f, -0.04871527f, 
    0.09203958f, 0.04511711f, -0.06426308f, -0.03129824f, 0.92196226f, -0.31119478f, -0.39149526f, -0.09222113f, 
    -0.05680837f, -0.01394990f, -0.02735189f, -0.10225236f, 0.15474816f, 0.01602593f, -0.01577163f, -0.06547739f, 
    -0.06775472f, 0.00052264f, -0.00871369f, -0.01286499f, -0.02402736f, -0.17854574f, -0.04728667f, -0.08866619f, 
    -0.14865656f, 0.06479137f, -0.08171136f, 0.06591124f, 0.08618356f, 0.56812793f, -0.03981567f, -0.37939391f, 
    -0.19595887f, 0.06400911f, -0.01733238f, 0.00336237f, 0.01357077f, 0.09401953f, -0.03586497f, -0.30599946f, 
    -0.08313892f, -0.00067784f, -0.18268250f, -0.12379918f, -0.04787001f, 0.08090592f, 0.05401351f, 0.07938492f, 
    -0.14638628f, 0.14852221f, 0.03132416f, -0.05450667f, 0.13423921f, 0.07185530f, 0.16207156f, -0.06567597f, 
    0.01607107f, 0.09302355f, 0.04824618f, -0.02694041f, 0.04409097f, -0.09275505f, -0.05351301f, 0.02372446f, 
    0.27070737f, 0.07896970f, 0.17320374f, -0.11967161f, 0.05094448f, -0.14456026f, -0.05019822f, -0.01464799f, 
    -0.01989580f, 0.03025666f, -0.01606320f, 0.13537598f, 0.30557421f, 0.06782816f, 0.12817775f, 0.04334976f, 
    0.02413598f, -0.09070308f, -0.06229485f, 0.07747452f, -0.02414830f, 0.06347276f, -0.09369171f, -0.06235743f, 
    -0.05958289f, -0.05199225f, 0.06605797f, -0.33026409f, -0.04868741f, 0.04263632f, -0.06477803f, 0.07073983f, 
    0.03303690f, -0.06155482f, -0.20599385f, -0.03118948f, -0.43731108f, -0.02129734f, 0.01780322f, 0.15081088f, 
    -0.15459633f, 0.01422617f, 0.10793780f, 0.05179577f, -0.06236957f, 0.08129035f, 0.05066491f, -0.09909099f, 
    0.03349781f, 0.00271385f, -0.03875710f, 0.10397896f, 0.01630796f, -0.04054911f, 0.07086656f, 0.04488259f, 
    -0.09993625f, 0.07357318f, -0.05243989f, 0.10197240f, -0.13602538f, 0.07227474f, -0.06266010f, -0.01370608f, 
    -0.07028169f, 0.02239042f, 0.01159726f, -0.00239044f, -0.18027048f, -0.13080311f, -0.01291617f, -0.04433522f, 
    0.31672478f, -0.11971804f, 0.44812101f, 0.40845898f, -0.03423692f, -0.01066835f, 0.08441790f, -0.09100166f, 
    0.18269046f, 0.02146176f, 0.07186135f, 0.14252415f, 0.17742006f, 0.05853803f, -0.13236436f, -0.03936860f, 
    0.00270891f, -0.01306429f, -0.13663624f, 0.00205722f, 0.00147360f, 0.00961566f, 0.01825066f, 0.08030944f, 
    0.23110402f, 0.11171815f, 0.13977407f, 0.15837914f, -0.02801759f, -0.00990590f, -0.00520167f, 0.01374200f, 
    -0.08533460f, -0.01316208f, 0.04785926f, 0.03235685f, -0.00517466f, -0.02284587f, 0.02210509f, -0.07750444f, 
    0.06037378f, -0.06139229f, 0.11660837f, 0.09963862f, 0.07334479f, 0.08356808f, -0.09348881f, 0.03479574f, 
    -0.22674051f, -0.08044117f, -0.25424674f, 0.14920290f, -0.11422850f, 0.06368010f, 0.19863118f, -0.12452833f, 
    -0.01647304f, 0.08195408f, -0.04646765f, 0.06283426f, 0.29730800f, 0.28324658f, 0.39557514f, 0.00007643f, 
    0.10850771f, -0.12146412f, -0.00068786f, -0.25355303f, -0.00533548f, -0.00800249f, -0.00537477f, -0.16682513f, 
    0.11713219f, 0.13069125f, -0.14142136f, 0.24192746f, -0.05624643f, 0.08553188f, -0.03941993f, 0.11562348f, 
    0.00991838f, 0.00886745f, 0.12483283f, 0.02929639f, 0.13134068f, 0.06659766f, -0.09619386f, 0.09758887f, 
    0.00453066f, 0.13730991f, 0.13290608f, 0.12948754f, 0.00523400f, 0.05761001f, -0.17579260f, 0.01392101f, 
    -0.24628332f, -0.07770215f, -0.37827411f, 0.05317509f, -0.00053954f, -0.12221698f, 0.21796447f, 0.05324702f, 
    0.02205019f, 0.01007001f, 0.02268834f, 0.00713907f, -0.17371324f, 0.21354887f, -0.06262741f, -0.00870588f, 
    0.13355061f, 0.04287434f, 0.05437397f, 0.05419083f, 0.00795479f, 0.15587731f, 0.09399740f, -0.04221225f, 
    -0.21783854f, 0.08827226f, -0.05910989f, -0.08560898f, 0.18662816f, -0.08252136f, -0.25859201f, -0.13287596f, 
    0.01894331f, 0.04805176f, -0.04552560f, -0.45430586f, -0.09770906f, -0.20099260f, 0.01026967f, -0.15498495f, 
    0.10680854f, 0.08535169f, 0.01397843f, 0.03981839f, -0.04202236f, 0.10186651f, 0.03580530f, -0.00786903f, 
    0.12533115f, 0.14128016f, 0.02441651f, 0.07368551f, -0.11223652f, 0.01226576f, 0.06658176f, -0.01017326f, 
    0.12253305f, -0.13480560f, 0.10353725f, -0.06294626f, -0.07663716f, -0.03746098f, -0.17874199f, 0.08792975f, 
    0.06689391f, 0.05779204f, 0.04554477f, -0.00332353f, -0.18190068f, -0.04863329f, -0.06043645f, 0.06088444f, 
    -0.10940016f, 0.21460183f, 0.08552085f, 0.03655742f, 0.02564958f, 0.05541949f, -0.02127629f, 0.03242356f, 
    -0.00679036f, 0.05703152f, -0.14664459f, 0.11316736f, 0.44950181f, 0.23466618f, 0.11554331f, 0.05390706f, 
    -0.03646661f, 0.05597971f, 0.01417278f, 0.01072902f, 0.08140952f, -0.00556412f, -0.01023794f, 0.02617441f, 
    0.27411619f, -0.14159305f, 0.05596435f, 0.10665579f, -0.07233118f, 0.07434078f, 0.10797469f, 0.02525704f, 
    -0.02573392f, -0.09958862f, 0.01020327f, 0.07438479f, -0.09966507f, 0.11927697f, -0.09302034f, -0.01766988f, 
    -0.03495656f, 0.03329518f, -0.06276817f, -0.12167103f, -0.07481547f, -0.11712834f, 0.02059748f, -0.05027269f, 
    -0.19283511f, 0.18285672f, 0.04492889f, -0.22199334f, -0.07158135f, 0.26860595f, -0.09960558f, -0.06650908f, 
    -0.08294499f, 0.06185622f, -0.10539299f, -0.17977303f, -0.50135416f, -0.38411298f, -0.15383536f, -0.10162762f, 
    -0.02968769f, 0.02940402f, 0.10416202f, 0.09540226f, 0.24536867f, -0.13947651f, 0.04812700f, 0.02336217f, 
    -0.69640523f, 0.30394301f, -0.33980185f, -0.18645260f, 0.02205051f, 0.04440528f, -0.08249281f, 0.07614139f, 
    0.00948478f, 0.10162732f, -0.11043215f, -0.02256630f, -0.01110988f, -0.03173378f, -0.11518697f, 0.03983064f, 
    -0.10469574f, 0.03387785f, 0.12651926f, -0.04416450f, 0.06522540f, -0.17679238f, 0.08255182f, -0.09152127f, 
    -0.04597869f, 0.16925214f, -0.06913398f, 0.03442952f, 0.00333751f, -0.03044756f, 0.03606903f, 0.12982644f, 
    -0.19330293f, -0.04168133f, 0.10023762f, 0.08736107f, 0.11257398f, 0.10607015f, 0.11593949f, 0.05089128f, 
    -0.02434216f, 0.00307024f, -0.03551068f, -0.02317143f, -0.19790813f, -0.07115781f, -0.09958953f, -0.02884114f, 
    0.09581336f, 0.01556457f, 0.16794051f, 0.16679132f, -0.10989359f, -0.06286949f, 0.10510997f, -0.04048171f, 
    0.03048024f, -0.03372925f, 0.01229739f, 0.03002163f, -0.05419344f, -0.17630549f, -0.13805701f, -0.12924065f, 
    -0.03030944f, 0.03761055f, 0.09539291f, -0.00083119f, 0.01539530f, -0.05316520f, -0.00456346f, -0.09988026f, 
    -0.30748153f, 0.08829837f, -0.13887523f, 0.16037934f, 0.08478011f, 0.04566835f, 0.07816388f, -0.05280335f, 
    0.29256678f, -0.11869297f, 0.04210284f, -0.03613809f, 0.36155251f, 0.18751925f, 0.14677897f, 0.18656994f, 
    0.03808871f, -0.00562457f, -0.03791942f, -0.01527158f, -0.01025860f, 0.05863196f, 0.01911825f, 0.05345332f, 
    0.07771056f, 0.06761706f, 0.08204576f, 0.24313408f, 0.02888167f, 0.00723162f, -0.00340467f, -0.04461747f, 
    -0.00098649f, 0.03637888f, 0.01383769f, 0.12594453f, 0.00548116f, -0.00254268f, -0.01438085f, 0.05811909f, 
    0.12333083f, 0.02871203f, -0.02520522f, 0.07202418f, 0.00135557f, 0.00573318f, -0.12725694f, 0.02852426f, 
    -0.17035931f, -0.02489367f, -0.09968900f, -0.37795317f, -0.05446868f, -0.07650109f, -0.22877315f, 0.08447263f, 
    0.03294307f, 0.03529480f, 0.06061991f, 0.03406910f, -0.00198863f, -0.00452309f, 0.00724114f, 0.04244021f, 
    0.11088248f, -0.10825690f, 0.09233095f, -0.12102554f, 0.01246240f, 0.05717047f, -0.00047881f, 0.02412159f, 
    0.04821295f, 0.19465092f, 0.15546553f, 0.04660011f, 0.06336986f, -0.07845668f, -0.25539753f, -0.52034116f, 
    0.05604442f, -0.05739894f, -0.16090848f, 0.00195336f, 0.04674181f, 0.05866303f, 0.18821801f, -0.00549961f, 
    -0.02643535f, -0.01722277f, -0.01282347f, -0.08370961f, 0.15885021f, -0.01800932f, 0.00656846f, 0.09496436f, 
    0.02648325f, -0.12958017f, 0.07446846f, 0.01186219f, 0.03276836f, -0.02651196f, -0.03389744f, -0.03887724f, 
    -0.23013519f, -0.47985128f, -0.29588500f, -0.32927325f, 0.14271873f, -0.15990804f, -0.06470764f, -0.09148646f, 
    0.06332056f, 0.01711597f, 0.10654207f, -0.25683990f, 0.30109999f, 0.15418896f, 0.07738458f, 0.03032646f, 
    0.16473405f, -0.20446238f, -0.13844745f, -0.01359039f, -0.09741223f, -0.11977644f, 0.34391385f, -0.13999677f, 
    0.08857510f, 0.10076085f, -0.13579179f, 0.02794275f, -0.08987740f, 0.11971737f, 0.09586306f, -0.29159603f, 
    -0.01471734f, -0.03881308f, 0.13096227f, 0.09791634f, -0.13679476f, 0.03834451f, 0.11804535f, -0.22329974f, 
    0.18693466f, 0.23842914f, -0.09829266f, -0.12817097f, -0.14741533f, -0.20894635f, -0.11277254f, 0.02734266f, 
    -0.08598814f, -0.07411333f, -0.06318914f, -0.06470703f, -0.22182764f, 0.05049105f, 0.14873393f, 0.01637098f, 
    -0.13691616f, 0.05560756f, -0.04293223f, 0.05230090f, -0.11982446f, -0.03296854f, 0.04032758f, 0.01565523f, 
    0.10755452f, 0.09891303f, -0.04602469f, -0.08501999f, -0.02909486f, 0.16805084f, 0.02665868f, 0.03594871f, 
    -0.04241865f, -0.00995112f, -0.06232725f, -0.00987547f, 0.09107835f, -0.09593113f, -0.01628140f, -0.13262829f, 
    -0.03417442f, -0.07278391f, 0.12375293f, 0.04241417f, -0.01616034f, -0.02565864f, -0.02571475f, 0.07093369f, 
    0.02186989f, -0.49961448f, -0.12063731f, -0.31575733f, -0.04971207f, 0.07245504f, -0.11509219f, 0.12048746f, 
    0.02501028f, -0.08591336f, -0.10337708f, -0.08374447f, -0.19468118f, 0.06493940f, 0.04832317f, -0.05802387f, 
    0.02539792f, -0.05563260f, -0.00789502f, -0.00249806f, -0.06669255f, -0.01451941f, 0.02765661f, 0.05182705f, 
    -0.14127967f, 0.17356539f, -0.25228575f, 0.12579571f, -0.00550620f, -0.02511529f, 0.02160207f, 0.00139744f, 
    0.00707406f, -0.06643141f, 0.04677146f, -0.08507459f, -0.22747365f, -0.21042748f, -0.09475614f, 0.32730997f, 
    -0.07940657f, -0.03493464f, -0.14475176f, 0.08058405f, -0.01094535f, -0.06209147f, -0.01472191f, -0.01480201f, 
    0.32740429f, 0.15840314f, -0.09968113f, 0.19678447f, -0.07065251f, 0.10501670f, -0.12942024f, 0.09351885f, 
    -0.02082318f, 0.13019960f, -0.12588921f, 0.16838551f, -0.05811371f, 0.07073810f, -0.06242642f, -0.04330245f, 
    0.01819252f, 0.02102950f, 0.03198388f, 0.05365836f, 0.03239169f, -0.08701208f, 0.09157509f, 0.01478199f, 
    -0.17085086f, -0.03805914f, 0.01302744f, -0.13882978f, -0.00491184f, 0.00327088f, -0.09744120f, 0.00294135f, 
    0.00663754f, -0.02836303f, -0.03052631f, 0.06587152f, 0.11145037f, -0.00414683f, -0.11313679f, 0.03599832f, 
    -0.00301908f, -0.04463540f, 0.07914578f, -0.13904460f, -0.09511703f, 0.07601361f, -0.01398458f, 0.00866603f, 
    0.10757635f, 0.26676229f, 0.04965606f, 0.23151547f, -0.00282314f, -0.01690629f, 0.09250001f, -0.05700798f, 
    -0.12556675f, -0.08429619f, 0.03333936f, 0.02743367f, -0.33959115f, -0.75983351f, -0.12029462f, -0.28978106f, 
    0.20623612f, -0.24277233f, 0.14540000f, 0.04045140f, 0.03290495f, -0.07300125f, 0.02850088f, -0.09583372f, 
    -0.07800619f, 0.19199812f, 0.19861436f, 0.02318938f, -0.07303216f, 0.04405600f, 0.05544298f, -0.04504705f, 
    -0.12924390f, 0.05181753f, -0.05874828f, 0.03882788f, -0.24497475f, 0.31164393f, 0.36675984f, -0.26074108f, 
    -0.07908347f, -0.05533203f, 0.02081981f, -0.02256101f, 0.11432809f, -0.05106245f, 0.01236566f, -0.01087308f, 
    -0.15544441f, -0.18166369f, -0.08298577f, 0.07632791f, 0.05093541f, 0.07530368f, -0.00246017f, 0.11165758f, 
    0.01846761f, 0.03060518f, 0.02817156f, 0.08814038f, -0.26295528f, 0.55739146f, 0.21242213f, 0.46921802f, 
    -0.08236806f, -0.04955146f, 0.00932845f, -0.00229254f, -0.05602765f, 0.06527393f, -0.04962207f, 0.00221483f, 
    0.14446700f, 0.09933358f, 0.25621787f, 0.19158258f, -0.01984486f, -0.01453444f, 0.05302390f, -0.04976409f, 
    0.03058050f, -0.02016108f, 0.08411914f, 0.07171499f, -0.20073459f, 0.12955433f, -0.02603306f, -0.04128554f, 
    -0.04006423f, -0.00169784f, -0.03992677f, 0.01426979f, 0.02076408f, -0.00363230f, -0.17979345f, 0.12964551f, 
    -0.33775267f, -0.01870280f, -0.04110498f, -0.24952739f, -0.02920908f, -0.07307234f, 0.01391596f, 0.06203905f, 
    0.04140825f, -0.02892603f, -0.02961124f, 0.08837585f, -0.07322669f, -0.01359982f, -0.07459354f, -0.10517922f, 
    0.03175667f, 0.05493816f, 0.04953815f, -0.02304959f, 0.02940490f, -0.01861377f, -0.09526414f, 0.18518469f, 
    -0.53625721f, 0.23055886f, -0.08935614f, 0.06300256f, 0.00179896f, 0.03126654f, -0.01746439f, -0.22087944f, 
    0.10378298f, 0.01644750f, 0.11832724f, 0.18870272f, -0.37030736f, 0.06209181f, 0.01416758f, 0.21032397f, 
    0.00288384f, -0.05609000f, -0.05747051f, 0.10936751f, -0.06964417f, 0.02410317f, 0.03513049f, -0.04652703f, 
    0.01051451f, -0.12826867f, -0.07303341f, -0.02109944f, 0.10852353f, -0.11418098f, -0.03944398f, 0.06231293f, 
    -0.00839052f, -0.03588485f, 0.07946653f, -0.06318359f, 0.09410223f, -0.03376665f, -0.03551100f, 0.00417819f, 
    -0.02005387f, -0.07441806f, -0.02825220f, -0.00199729f, 0.05534410f, -0.01343672f, 0.08699017f, 0.04882794f, 
    0.11573421f, -0.00142705f, -0.04155120f, 0.04825753f, 0.00768747f, -0.00846789f, 0.06041981f, 0.02999992f, 
    -0.01241610f, -0.00979997f, 0.04877385f, -0.20344162f, -0.22107291f, 0.12002990f, -0.04798465f, -0.10416270f, 
    0.02209482f, 0.08586176f, -0.03706866f, 0.17044364f, 0.01064460f, -0.08096501f, 0.00484557f, -0.05025117f, 
    -0.17848466f, -0.01875962f, -0.18506569f, -0.25905368f, 0.02862251f, 0.01820914f, 0.00686857f, 0.03754773f, 
    -0.02094011f, 0.02349704f, -0.04564651f, -0.04050486f, -0.03314596f, -0.03734878f, 0.12208563f, -0.23665692f, 
    0.02255618f, -0.02679962f, -0.08501205f, 0.00992102f, 0.04824543f, -0.04250878f, -0.07511657f, 0.07900486f, 
    -0.10461231f, 0.21332411f, -0.16433325f, 0.18262501f, 0.16063064f, 0.03639551f, 0.16309035f, -0.09198544f, 
    -0.02221432f, -0.03164881f, 0.06473565f, 0.00140833f, -0.48931631f, 0.19737731f, 0.54928184f, 0.13217779f, 
    -0.26401910f, 0.10030417f, 0.13728192f, -0.10421915f, 0.00224496f, -0.01519951f, 0.03409501f, -0.02058175f, 
    -0.35453826f, 0.11295825f, 0.00296973f, -0.07064108f, -0.06048897f, -0.01586607f, -0.06398071f, -0.09066256f, 
    -0.01076165f, -0.05679626f, -0.07706948f, -0.16363318f, -0.03258853f, 0.12578230f, 0.03877851f, -0.11119626f, 
    -0.03749917f, 0.04467016f, -0.00152442f, -0.05110117f, -0.00662672f, -0.06005613f, -0.06032324f, -0.00702524f, 
    -0.27565882f, 0.49007916f, -0.48234776f, -0.05231856f, 0.02553071f, -0.12929095f, -0.08741130f, 0.03708587f, 
    -0.04742512f, 0.03717178f, 0.06000978f, -0.12282172f, -0.15507212f, -0.04385413f, -0.07839172f, 0.07517281f, 
    -0.14957474f, -0.06182462f, 0.08881918f, -0.08131065f, 0.07206709f, -0.02282087f, -0.00035840f, 0.13968095f, 
    0.11499587f, -0.04690390f, 0.10728621f, 0.20997331f, -0.00925751f, -0.06361292f, 0.02452382f, 0.07595142f, 
    -0.20357506f, 0.06314602f, -0.07201238f, -0.08400988f, -0.09856314f, 0.13671701f, 0.05887867f, 0.09279425f, 
    -0.04844677f, -0.03571209f, 0.09762768f, -0.09877066f, 0.02266933f, 0.10026544f, -0.05636402f, 0.03330937f, 
    -0.10011004f, 0.00509733f, 0.07636118f, 0.08046304f, -0.03452097f, 0.00343887f, 0.03509334f, -0.09018052f, 
    -0.13922109f, -0.03620477f, -0.11315129f, 0.12667552f, -0.06746269f, -0.00679768f, -0.12691279f, 0.14357793f, 
    -0.08006030f, -0.00651154f, 0.04452782f, -0.09330627f, 0.10937402f, 0.04816437f, 0.00386270f, -0.01734119f, 
    0.05536155f, -0.17864829f, -0.14090343f, 0.08407868f, 0.01275564f, 0.00817662f, -0.01933146f, 0.01205940f, 
    -0.00434677f, -0.08109042f, -0.20466322f, -0.01916277f, -0.03410063f, 0.10532781f, -0.09285518f, -0.04015553f, 
    -0.06216745f, 0.00813541f, 0.01253777f, 0.03377717f, -0.00775054f, -0.01258384f, -0.04172765f, 0.05779665f, 
    0.02750287f, -0.17528291f, -0.05842737f, -0.17710452f, 0.04021658f, -0.01669184f, -0.01439431f, 0.10076766f, 
    0.01178696f, -0.00425425f, 0.11224361f, -0.11229338f, 0.03416149f, -0.13368672f, -0.05022716f, 0.18571335f, 
    -0.03301175f, 0.04840621f, -0.01696817f, 0.07526061f, 0.05472903f, 0.07250168f, -0.21717544f, 0.09002505f, 
    -0.08351894f, -0.02794035f, -0.00013058f, 0.22650488f, 0.03957799f, 0.23027931f, -0.30657834f, 0.01842242f, 
    -0.02771471f, 0.01512364f, 0.05194689f, 0.02165682f, 0.23479900f, -0.03624932f, -0.29794297f, -0.13209234f, 
    0.15488091f, 0.05588577f, -0.10127304f, -0.04374836f, -0.05040063f, -0.03338988f, -0.09608686f, 0.12009882f, 
    -0.05507654f, 0.14046593f, -0.15158561f, 0.27567467f, -0.04343367f, -0.02186849f, 0.02471878f, -0.01897635f, 
    -0.00835160f, -0.01587389f, 0.00130579f, 0.00217789f, 0.11146572f, -0.09216189f, 0.16075835f, 0.13417871f, 
    -0.00887336f, -0.02309386f, -0.01344780f, 0.10011737f, 0.01914265f, 0.13379796f, 0.11174327f, -0.02454215f, 
    0.10366821f, 0.00286692f, -0.09860671f, 0.09180076f, 0.01264102f, -0.11974617f, -0.00477955f, 0.09846754f, 
    -0.05453956f, -0.03994475f, 0.01264055f, 0.08012479f, -0.10209303f, -0.07738442f, -0.01280887f, -0.01879581f, 
    -0.00490340f, 0.00345532f, -0.03923199f, -0.07123280f, 0.01403451f, 0.19210626f, 0.11943211f, 0.18313463f, 
    -0.84014285f, -0.56706524f, -0.11707439f, -0.54485059f, -0.07091846f, -0.08361442f, 0.07105475f, -0.42125878f, 
    -0.00586549f, -0.06548736f, 0.05404322f, -0.05466682f, 0.10696547f, 0.19755839f, 0.09151798f, 0.19282447f, 
    -0.05656881f, -0.06168162f, 0.08937255f, 0.00537314f, -0.06542298f, -0.02462297f, -0.05844786f, -0.04038269f, 
    -0.12927829f, 0.07040135f, -0.04727733f, 0.20980653f, 0.07171016f, 0.02588490f, 0.00474936f, 0.13073547f, 
    0.00502045f, 0.04579905f, 0.02078842f, 0.00403807f, -0.12366501f, -0.09622081f, 0.29657072f, -0.52429813f, 
    0.01086112f, -0.01534576f, 0.00320927f, 0.07082473f, 0.00073332f, -0.04338714f, 0.05967645f, -0.04779268f, 
    -0.02945895f, 0.36239469f, -0.24435422f, -0.07853130f, 0.02285990f, -0.03452596f, -0.00045421f, 0.09461366f, 
    -0.01038542f, 0.09164336f, 0.06240433f, -0.38600537f, -0.00926776f, -0.05201231f, -0.00775911f, 0.00223965f, 
    0.12146880f, -0.01523307f, -0.06026256f, 0.04738668f, 0.00582891f, 0.03401793f, -0.00253487f, 0.00951672f, 
    -0.30795720f, 0.35699767f, -0.23574902f, -0.12823533f, -0.08712348f, -0.14822014f, 0.00177747f, -0.03207996f, 
    0.00484547f, 0.07246663f, -0.05318980f, 0.01129288f, -0.06725456f, 0.08053140f, -0.06605430f, 0.05576601f, 
    -0.26039836f, -0.10555285f, -0.02842000f, 0.08973131f, -0.01294796f, 0.05679492f, -0.07697821f, -0.00892726f, 
    -0.08823903f, 0.18492259f, 0.08295096f, -0.08910070f, -0.00568393f, 0.03641018f, 0.03964455f, -0.11113052f, 
    -0.00450699f, 0.02776828f, 0.09609689f, 0.03942142f, -0.07869120f, 0.03207934f, -0.05420661f, -0.09663568f, 
    0.02665393f, -0.01185781f, -0.14642790f, -0.04793172f, 0.11525377f, -0.17312640f, -0.12752514f, 0.05122121f, 
    0.10502639f, 0.01134335f, 0.21737988f, -0.06040167f, 0.01297487f, 0.03044871f, 0.02774737f, 0.04619856f, 
    0.20767845f, 0.30475241f, 0.11753934f, 0.07191199f, -0.06673729f, 0.21038933f, 0.02601476f, 0.07636721f, 
    -0.02154553f, -0.06872525f, -0.03493799f, -0.05172451f, -0.01328239f, -0.02564994f, 0.09365895f, 0.01293592f, 
    0.00403911f, -0.25087449f, 0.04473731f, -0.14079435f, -0.14862886f, -0.25304747f, 0.02575629f, -0.08817779f, 
    0.04112514f, -0.06454752f, 0.08203757f, -0.01408895f, 0.16307467f, -0.04659209f, 0.45735872f, 0.30039471f, 
    0.02711046f, -0.01981955f, 0.08767214f, -0.05172241f, -0.06432586f, -0.17035377f, -0.08190768f, 0.02540024f, 
    -0.32861722f, 0.31356651f, 0.50590712f, 0.20210509f, -0.15589947f, -0.32328060f, 0.18920712f, -0.01397324f, 
    0.08801741f, -0.02135782f, -0.12494256f, -0.04094660f, -0.50128150f, -0.13923736f, -0.21218461f, -0.27432323f, 
    0.01159099f, -0.03399438f, 0.03667077f, -0.01336087f, 0.03699165f, -0.01850547f, 0.03251984f, -0.00453671f, 
    -0.24311589f, -0.02227722f, -0.15823273f, -0.08501824f, 0.00844187f, -0.01174184f, -0.14155883f, -0.04564000f, 
    0.01491584f, -0.09967195f, 0.05430199f, 0.00909289f, 0.10812916f, -0.06823894f, 0.03290615f, -0.08171351f, 
    0.12535991f, -0.19484672f, -0.07564546f, 0.11595708f, -0.09571403f, 0.07040787f, 0.05286509f, -0.11814291f, 
    -0.17533149f, -0.30155438f, 0.05437794f, -0.30121255f, 0.06472633f, -0.00412567f, -0.05717185f, -0.09881297f, 
    -0.07320998f, 0.01928254f, -0.03477866f, 0.19527218f, -0.04806539f, 0.16832866f, 0.07842039f, -0.01944427f, 
    0.01641004f, 0.09687630f, 0.05286466f, -0.00188684f, 0.02152333f, 0.04183837f, 0.01661547f, -0.00687756f, 
    0.17896450f, 0.48103189f, -0.13766202f, 0.29543284f, -0.00389043f, 0.04941235f, -0.01849191f, 0.11817370f, 
    0.02308065f, 0.07348796f, 0.07725754f, 0.06785405f, 0.24702582f, -0.16755924f, -0.01873117f, 0.14926602f, 
    0.03410726f, -0.03551027f, 0.03137865f, -0.00707572f, -0.05131064f, 0.05247047f, -0.03931324f, 0.11010490f, 
    0.45482481f, -0.05896971f, -0.09501058f, 0.16561025f, 0.08575343f, 0.03016456f, -0.06367180f, 0.02429131f, 
    -0.08058260f, -0.01968375f, -0.03844353f, 0.17208469f, -0.08321530f, 0.01699702f, 0.12274183f, -0.09795519f, 
    -0.22749521f, -0.18135646f, -0.09999160f, -0.11803837f, 0.04954631f, 0.18941335f, -0.13671780f, 0.03260203f, 
    -0.31809354f, 0.21025699f, -0.14231002f, 0.26609322f, -0.04694488f, 0.00528289f, 0.02586275f, -0.11640740f, 
    -0.07251068f, 0.03447486f, -0.17115487f, 0.09589951f, 0.88417673f, 0.14503102f, 0.02579446f, -0.22439350f, 
    -0.11038551f, 0.00096127f, -0.05450567f, -0.12469606f, -0.17409280f, -0.06469501f, 0.13387838f, 0.08874582f, 
    0.32597667f, -0.13318563f, -0.01854950f, 0.07390392f, 0.08289053f, 0.12338556f, 0.09147231f, -0.13556138f, 
    -0.06610950f, -0.04633077f, 0.00338164f, 0.03988257f, 0.02717212f, -0.09548204f, -0.37082508f, 0.15468484f, 
    0.00074045f, 0.02217098f, -0.03341557f, 0.05869127f, -0.02708897f, -0.00328400f, -0.03186456f, -0.00007930f, 
    -0.21802203f, 0.00088442f, -0.00218740f, 0.17057493f, 0.10921044f, 0.02004933f, 0.07414699f, -0.07838829f, 
    0.01988981f, 0.04044151f, 0.02722247f, -0.02661114f, -0.51550639f, 0.38595733f, 0.03227876f, 0.26719886f, 
    0.20789964f, 0.03209029f, 0.04381840f, -0.05535841f, -0.11578698f, -0.04637088f, 0.17540215f, -0.02269524f, 
    0.11398646f, -0.12832358f, -0.02153194f, -0.01856354f, -0.09748083f, 0.02614046f, 0.04257321f, 0.05901639f, 
    0.02061280f, -0.08223274f, 0.03287376f, -0.00375261f, 0.42127934f, -0.26588666f, 0.03204320f, 0.05429674f, 
    0.11764980f, -0.03230055f, -0.02139289f, -0.02564887f, 0.08397470f, 0.09864715f, -0.05556462f, 0.03823235f, 
    0.04641601f, -0.08438036f, 0.03325110f, 0.06100674f, 0.10738346f, -0.00081478f, -0.06922436f, -0.07165085f, 
    -0.07814024f, -0.02932615f, -0.04031270f, -0.06485000f, -0.23303138f, -0.17217709f, 0.11087576f, -0.25987774f, 
    -0.05609165f, -0.25517079f, -0.09906472f, -0.01419186f, 0.04334327f, -0.05253021f, 0.04146072f, -0.15136471f, 
    -0.61988217f, -0.02270486f, -0.00090738f, 0.22878560f, -0.26051152f, -0.10251345f, -0.09175364f, -0.08850478f, 
    0.02605206f, -0.10876255f, -0.17736156f, 0.09610987f, -0.12835239f, 0.00490324f, 0.26868138f, -0.16576767f, 
    -0.03147820f, 0.05181621f, -0.14484857f, 0.07086708f, -0.08012139f, 0.03633764f, -0.09566601f, -0.10679826f, 
    -0.23610511f, -0.17522603f, 0.10583305f, -0.03270446f, -0.08772281f, 0.10391747f, -0.19350405f, -0.01367733f, 
    -0.05739508f, 0.02388512f, -0.00276259f, -0.05680283f, 0.10688542f, 0.33407304f, -0.23006402f, -0.25745183f, 
    0.07438697f, -0.09972803f, -0.04642191f, 0.04003809f, -0.04502961f, -0.04339524f, 0.22585580f, -0.03532201f, 
    -0.14124462f, 0.11621705f, -0.21073596f, -0.34156373f, 0.05918469f, 0.08910257f, -0.20165524f, 0.01616599f, 
    -0.08400214f, 0.03555134f, -0.00573336f, 0.02515419f, 0.19636062f, 0.09121535f, 0.06074059f, -0.12608984f, 
    0.05703683f, 0.02172009f, -0.13976534f, -0.09365044f, -0.17565040f, -0.07091908f, 0.05346729f, -0.08689395f, 
    -0.18054228f, 0.62623119f, -0.29632145f, 0.16707586f, 0.18711577f, -0.11528088f, 0.17073222f, -0.18231174f, 
    -0.14775701f, -0.08075809f, 0.02708669f, -0.10048596f, -0.37383407f, 0.28968835f, 0.02857242f, 0.41811296f, 
    -0.20630690f, -0.17901297f, 0.13888255f, -0.15449753f, -0.04176755f, -0.00397988f, -0.03494330f, 0.08369763f, 
    -0.32712066f, -0.38326469f, -0.15467699f, -0.03404275f, 0.15830509f, 0.11584603f, -0.07515705f, 0.12252586f, 
    0.02540953f, 0.06107392f, -0.00965314f, -0.04904521f, 0.08417678f, -0.07202997f, 0.40029171f, 0.01735289f, 
    -0.09800652f, 0.06836545f, 0.05820920f, 0.05024533f, 0.02308229f, 0.18520296f, 0.01645547f, 0.15713368f, 
    0.08669688f, -0.16874380f, -0.17753400f, -0.08965930f, 0.02125662f, -0.03290311f, -0.00328376f, -0.04845209f, 
    -0.04082738f, 0.07611515f, -0.03733236f, 0.00720406f, 0.01425835f, -0.27154687f, -0.10795360f, 0.22249219f, 
    0.13226578f, 0.03546624f, 0.05126806f, -0.04220611f, 0.07647263f, 0.01877191f, 0.03085118f, 0.06952208f, 
    -0.08437856f, -0.04142894f, 0.01710318f, 0.19233297f, 0.00772927f, -0.02595447f, 0.01763485f, 0.00923735f, 
    0.00492029f, 0.12283009f, 0.00424711f, 0.04261751f, -0.04408253f, 0.08396964f, -0.06873880f, 0.10425431f, 
    0.04513119f, -0.02625196f, 0.05909760f, -0.04621986f, 0.00549396f, 0.09781139f, -0.04523214f, -0.01308876f, 
    -0.32752612f, 0.18461172f, -0.11150183f, 0.14180103f, 0.08532505f, 0.01437161f, -0.04006370f, 0.01956840f, 
    -0.15350048f, -0.02092940f, -0.14226587f, 0.00240677f, 0.08175345f, -0.15888819f, 0.02970627f, -0.15041250f, 
    -0.10498828f, -0.08504558f, -0.16049433f, -0.13408120f, -0.10405773f, 0.07721844f, 0.13271661f, -0.15859950f, 
    0.65972352f, -0.05872445f, -0.09462867f, -0.09784592f, 0.03049104f, -0.11657628f, 0.07996867f, -0.10787433f, 
    -0.12953568f, -0.02343117f, 0.10747502f, 0.15215206f, -0.16392852f, -0.13727170f, -0.07286698f, 0.22006266f, 
    -0.01662661f, -0.02017544f, 0.04431259f, -0.07081125f, -0.00053960f, -0.01018249f, -0.11022332f, 0.01372855f, 
    -0.36055174f, -0.08782526f, 0.04518918f, -0.23603083f, -0.02477099f, -0.10752443f, -0.11864284f, -0.23589110f, 
    -0.17166771f, 0.13584335f, -0.06180909f, 0.07199033f, -0.07805187f, -0.05461722f, -0.05859657f, 0.14346191f, 
    0.08621633f, 0.11154544f, 0.00030210f, 0.10411555f, 0.07921143f, 0.08899004f, 0.05442785f, 0.01487017f, 
    0.54487336f, 0.09043480f, -0.03119981f, -0.29425770f, 0.06525591f, 0.02275084f, 0.01995603f, -0.04606575f, 
    -0.05172080f, 0.11193012f, -0.11144121f, -0.06541026f, 0.14343043f, -0.31899416f, 0.02230658f, -0.20360123f, 
    0.04373070f, -0.14964126f, -0.08123206f, 0.04678194f, 0.02816467f, 0.01370990f, -0.10392412f, -0.02552835f, 
    -0.21452744f, 0.20927823f, -0.21149097f, -0.08681898f, 0.09215072f, 0.16770478f, -0.13325490f, 0.00754498f, 
    -0.06361496f, -0.07577400f, 0.09544217f, -0.00091967f, -0.07544348f, -0.05684218f, -0.06927876f, -0.31618118f, 
    0.03773141f, -0.13190104f, -0.06048202f, -0.09817407f, -0.02750993f, 0.11444297f, -0.21109612f, 0.15246333f, 
    0.38693860f, -0.14523864f, -0.01682920f, -0.18322378f, 0.02537802f, -0.10825663f, -0.03236401f, 0.02607283f, 
    -0.05221869f, -0.12940159f, -0.05104657f, -0.08753292f, 0.13932787f, -0.00864193f, 0.00452371f, 0.02854695f, 
    0.01973355f, 0.00694070f, -0.04538284f, -0.01296536f, -0.03916616f, 0.09890030f, -0.00388271f, -0.11460315f, 
    -0.18236974f, 0.02678857f, -0.08259034f, -0.13416320f, -0.13091901f, -0.14987841f, -0.06503176f, -0.04323889f, 
    -0.09121548f, -0.03704245f, 0.03702588f, -0.05760518f, -0.37120733f, 0.38973063f, -0.19889751f, -0.23550925f, 
    0.13282999f, 0.02008305f, 0.03754151f, -0.01516788f, -0.12223529f, 0.06622639f, -0.14647965f, -0.01223604f, 
    0.08305487f, 0.46905699f, -0.18820179f, -0.48712429f, -0.22537296f, 0.01441870f, -0.09213274f, 0.01160115f, 
    0.12678874f, -0.08603099f, 0.15672320f, 0.10049591f, -0.11790249f, 0.09521513f, -0.03656748f, 0.03369455f, 
    -0.06330251f, 0.03044368f, -0.06566220f, 0.17862937f, -0.00778375f, 0.17928889f, 0.04404505f, -0.01423871f, 
    -0.07633223f, -0.24897513f, -0.12136189f, 0.21735016f, 0.01945273f, 0.10232234f, 0.06985492f, 0.06516349f, 
    0.06424406f, -0.02929754f, 0.01620740f, -0.00249906f, 0.00002361f, -0.13772944f, -0.06725255f, -0.08268726f, 
    0.21169640f, 0.07415928f, 0.02468401f, -0.10166185f, -0.14105177f, -0.00379345f, -0.13966741f, 0.01832082f, 
    -0.23337792f, 0.43705177f, -0.17710672f, -0.51452523f, 0.15100990f, 0.01978531f, -0.04509164f, -0.13452391f, 
    -0.37792745f, -0.09392555f, -0.12675297f, 0.00299757f, -0.22364138f, 0.06322964f, 0.42764574f, -0.09542578f, 
    -0.20787358f, -0.12837003f, -0.18684600f, -0.02446337f, 0.00374644f, 0.05801241f, -0.13864717f, 0.03537986f, 
    -0.54634124f, 0.56915540f, -0.16704395f, -0.51410896f, -0.03602150f, 0.04738041f, -0.06695190f, 0.03553415f, 
    -0.26044741f, -0.13248517f, -0.03455482f, -0.00910290f, 0.08544723f, -0.04638255f, -0.17389221f, -0.09393268f, 
    0.05218300f, -0.10338130f, -0.08260038f, -0.10926064f, -0.11654985f, 0.03723937f, -0.00561954f, 0.03779567f, 
    -0.30412287f, 0.18170559f, -0.07452087f, 0.45135036f, 0.00186445f, 0.05866388f, -0.01262475f, -0.06103077f, 
    -0.00457861f, -0.00923313f, -0.06216098f, 0.02199179f, -0.14563797f, 0.14532575f, 0.00280525f, 0.12099504f, 
    0.03616396f, -0.11832511f, -0.07577929f, -0.00058063f, -0.00760391f, -0.23472378f, -0.04990398f, 0.04189320f, 
    0.04552716f, -0.20549628f, -0.03080286f, 0.17093752f, -0.06378232f, 0.03640130f, -0.07293802f, -0.10596455f, 
    -0.02813014f, 0.01830460f, -0.01218008f, 0.04043549f, -0.01392984f, -0.09834725f, 0.19923662f, 0.07832562f, 
    -0.18187650f, 0.08861086f, -0.05784839f, 0.08300897f, 0.10970435f, 0.12543850f, -0.08543637f, 0.09157327f, 
    -0.08445515f, 0.31896871f, -0.22688809f, 0.13412890f, 0.04800462f, 0.07465269f, 0.02214474f, 0.07152124f, 
    -0.26379123f, -0.05411496f, -0.02933336f, -0.02318250f, -0.54401040f, -0.13326761f, -0.01840624f, 0.16111518f, 
    0.01284829f, -0.08859950f, 0.03037238f, 0.06699684f, 0.08813643f, 0.00685069f, 0.04938139f, -0.09344750f, 
    0.26925525f, -0.09984862f, 0.08353496f, 0.09871207f, -0.09034390f, -0.05582572f, 0.10369059f, -0.14268644f, 
    -0.00160562f, -0.06417530f, 0.10545129f, -0.02636752f, -0.03808129f, 0.04610413f, 0.03895538f, 0.04770542f, 
    0.10133037f, 0.07903643f, -0.01415873f, -0.04054878f, -0.06907032f, 0.00909314f, -0.07770262f, 0.16668725f, 
    0.00924933f, -0.00500263f, 0.02539448f, 0.26105368f, 0.10436643f, 0.08901416f, -0.00241894f, 0.10992698f, 
    -0.05554496f, -0.06409513f, 0.20578848f, 0.14212367f, 0.09296384f, -0.17537503f, 0.01880944f, 0.08063444f, 
    0.06620556f, 0.02526087f, 0.03877922f, 0.10842247f, 0.09763702f, -0.06363403f, -0.00336104f, -0.13920361f, 
    -0.12661368f, 0.08505172f, 0.05542922f, 0.32052344f, -0.00505590f, -0.01487830f, -0.00400260f, -0.11104769f, 
    0.01369315f, 0.25549799f, 0.21217309f, -0.08712046f, 0.13170658f, 0.01820778f, 0.01771277f, 0.26573208f, 
    0.06339531f, 0.00111479f, -0.14306185f, -0.01211341f, -0.11197067f, 0.02974473f, -0.00039498f, 0.01323279f, 
    -0.01180862f, 0.01062130f, 0.18444443f, 0.12885396f, -0.00960672f, 0.05199256f, 0.07689296f, 0.09736184f, 
    0.06075189f, -0.03942508f, 0.05929974f, 0.14498839f, 0.24838288f, -0.09494959f, -0.04963183f, 0.12409399f, 
    -0.04820700f, 0.02079279f, 0.13108291f, -0.13191456f, -0.15901759f, 0.01005888f, -0.06112555f, 0.19705299f, 
    -0.06786910f, -0.40250009f, 0.31901252f, 0.14498401f, 0.02070801f, 0.13321522f, -0.02950516f, -0.02078592f, 
    -0.08327632f, -0.07831852f, -0.01434213f, 0.14782993f, -0.09512301f, -0.02011261f, 0.00775230f, 0.01515466f, 
    -0.00592270f, -0.07442653f, -0.02046909f, -0.00395768f, 0.02410430f, -0.03477537f, 0.10922900f, 0.10788491f, 
    0.01200644f, -0.08830626f, -0.20820975f, -0.05900728f, -0.07374440f, -0.15823968f, 0.00175405f, 0.12204734f, 
    0.01349975f, -0.01445979f, 0.04507536f, -0.16053009f, 0.13670026f, -0.30149704f, -0.06450462f, 0.10021148f, 
    -0.11898609f, 0.07520504f, -0.05702262f, 0.13428861f, 0.02833571f, 0.00769172f, 0.06250011f, 0.00683867f, 
    0.10514957f, 0.00846529f, -0.10368711f, -0.13943295f, 0.09101069f, -0.12610763f, 0.03249095f, -0.02914868f, 
    0.08941621f, 0.01234121f, 0.04971382f, -0.11957767f, 0.03079425f, -0.23750557f, -0.04517447f, 0.02320558f, 
    0.00361229f, -0.09061053f, 0.02634048f, -0.06450164f, 0.02454905f, -0.21245809f, 0.06677672f, 0.10528401f, 
    -0.21198611f, 0.16554904f, -0.03999030f, 0.01316816f, -0.04363165f, -0.13642022f, 0.01659833f, 0.05717141f, 
    0.00305942f, 0.01518228f, -0.16119640f, 0.06331225f, 0.13639471f, 0.13045511f, 0.38931176f, -0.00820887f, 
    -0.11450299f, 0.02132944f, -0.28647840f, 0.04866217f, 0.01718146f, 0.11087305f, -0.06015045f, 0.06102714f, 
    -0.04556330f, 0.07741211f, 0.00058667f, 0.04521821f, 0.04074718f, -0.00920606f, 0.02246636f, 0.05082243f, 
    -0.11829404f, 0.02086722f, -0.06288778f, 0.03265155f, -0.14361124f, -0.22756067f, 0.09970997f, -0.04145448f, 
    -0.00710861f, -0.01029971f, -0.00534567f, -0.05121849f, 0.06273806f, -0.08855098f, -0.08414817f, 0.09702257f, 
    0.00250989f, 0.10391081f, 0.16916005f, 0.10601812f, -0.09352551f, 0.01329336f, -0.04581929f, 0.01612507f, 
    0.09354337f, -0.05619657f, -0.00464500f, -0.03704483f, -0.08828318f, -0.06855102f, 0.02185115f, 0.18997730f, 
    -0.01726432f, -0.06877395f, 0.06694632f, 0.03449076f, -0.03441831f, -0.14646438f, 0.00302885f, 0.01631489f, 
    0.11145895f, 0.12673657f, 0.00484873f, 0.03922988f, -0.02520680f, -0.04854903f, 0.03201001f, -0.10204127f, 
    0.19261417f, -0.07982170f, -0.07256414f, 0.05596665f, -0.12723918f, -0.08947460f, -0.06637147f, 0.04308707f, 
    0.04989160f, 0.03538836f, -0.11007014f, 0.09989768f, -0.00846261f, 0.06678222f, 0.01448746f, -0.02307728f, 
    -0.03189727f, 0.03756058f, -0.24506477f, 0.00977041f, 0.15176186f, 0.08124444f, 0.15352596f, -0.08887081f, 
    0.05838111f, 0.05222525f, 0.04830806f, -0.01888497f, 0.03431503f, -0.46182945f, -0.12512593f, -0.17595255f, 
    0.00557475f, 0.07667062f, 0.02015238f, -0.09089980f, 0.16600944f, -0.15074691f, 0.09479672f, -0.06818423f, 
    -0.27390894f, -0.00286716f, 0.09289590f, 0.10909335f, -0.12633938f, 0.02659640f, -0.06600073f, -0.09876408f, 
    0.03554866f, 0.03587446f, 0.00392955f, -0.01938736f, 0.09826466f, -0.36538827f, 0.02261524f, 0.02104144f, 
    -0.09475317f, -0.09576504f, -0.18000232f, -0.03484379f, -0.13985296f, 0.04755062f, -0.27536160f, -0.11241903f, 
    0.17503992f, 0.09418782f, -0.08684018f, 0.04368563f, -0.03184861f, 0.15854664f, 0.08079705f, -0.11404408f, 
    -0.12219857f, -0.07634278f, -0.00186343f, -0.06671251f, -0.12005840f, -0.00399906f, 0.05942240f, 0.16911529f, 
    -0.12361265f, -0.14080346f, -0.14696197f, -0.20531741f, 0.16927759f, 0.02519176f, -0.03013404f, 0.07159154f, 
    -0.13967535f, -0.55064213f, -0.20520201f, -0.39754209f, 0.10231770f, -0.03529124f, 0.02592489f, -0.01373473f, 
    0.01535230f, -0.00960953f, -0.12046784f, -0.19129032f, 0.09089427f, 0.01269265f, 0.22656319f, -0.02194821f, 
    0.27754283f, -0.03852814f, 0.03755153f, 0.12004168f, -0.02876027f, -0.01586134f, -0.06142394f, -0.15850620f, 
    0.13322902f, 0.13864009f, 0.11860213f, 0.13051482f, 0.08064702f, 0.09658690f, 0.06680368f, 0.06108062f, 
    0.11765648f, -0.01350509f, 0.07811568f, 0.03145657f, 0.28291127f, 0.23566188f, -0.25574732f, 0.32347620f, 
    0.05661479f, -0.06217477f, 0.01111272f, -0.05091484f, 0.09499173f, -0.05570104f, 0.02791747f, 0.00498880f, 
    0.03239129f, 0.01285373f, 0.07849890f, 0.02079064f, -0.07131381f, -0.04610718f, -0.23823254f, 0.02111910f, 
    0.03771239f, -0.04528055f, 0.09312964f, -0.05991858f, -0.12400887f, 0.20365678f, 0.13306868f, 0.12686877f, 
    -0.06386484f, -0.04267244f, -0.04034926f, -0.00931863f, -0.03574024f, 0.05853204f, 0.01171789f, 0.07460357f, 
    -0.06848665f, 0.03023587f, 0.10116127f, 0.09365489f, -0.05483280f, 0.09291583f, -0.06515081f, 0.02023054f, 
    0.08106149f, -0.04829901f, -0.00452706f, -0.04032883f, -0.04858283f, -0.04818027f, 0.12670036f, 0.10496663f, 
    -0.07919521f, -0.13485083f, -0.17021197f, -0.13978338f, 0.02205452f, -0.06583034f, 0.07898463f, -0.11737127f, 
    0.13934381f, -0.22288539f, 0.16522232f, -0.01886249f, 0.01438118f, 0.05920619f, 0.12688474f, 0.02580753f, 
    -0.09922074f, -0.10314818f, -0.06550188f, 0.06631862f, -0.00394975f, -0.01595427f, 0.13511355f, 0.07352189f, 
    -0.01338728f, -0.08318335f, -0.05955990f, 0.13225706f, -0.01748233f, -0.13164096f, -0.18507174f, -0.11149777f, 
    -0.31030670f, -0.08560333f, -0.24430394f, 0.06187347f, -0.08966734f, -0.00056454f, -0.06291130f, 0.04188101f, 
    -0.05347108f, 0.00977977f, -0.09188654f, 0.11583272f, -0.10562307f, 0.09081359f, 0.06729227f, 0.00784971f, 
    0.08614129f, 0.00949102f, -0.22969390f, -0.07835487f, 0.09768584f, -0.09102035f, -0.01570154f, 0.09018709f, 
    0.06460416f, -0.06790869f, 0.00171429f, -0.14598440f, 0.05282006f, -0.04775106f, 0.06350698f, 0.06777217f, 
    -0.14792354f, -0.15253298f, -0.26483873f, 0.13123922f, 0.01882641f, 0.00287333f, 0.21513702f, 0.10695507f, 
    -0.02421649f, 0.05155002f, -0.02469462f, -0.03128827f, 0.22042954f, 0.17829214f, 0.10664775f, 0.10312361f, 
    0.10549640f, 0.03062744f, -0.23601146f, -0.28761017f, 0.07145314f, 0.02636093f, 0.13490358f, 0.08497504f, 
    0.01559206f, -0.02306243f, -0.09220602f, -0.04855324f, -0.11087297f, 0.28788882f, -0.10076886f, -0.10714949f, 
    -0.00552402f, 0.00707016f, 0.06114007f, 0.09779468f, -0.05330478f, 0.03566021f, -0.02542287f, -0.18725403f, 
    0.19607219f, 0.05712172f, -0.28151232f, 0.13400401f, 0.12628280f, 0.01819241f, 0.02761428f, 0.02898996f, 
    -0.10608359f, -0.03182328f, 0.04546525f, -0.03948424f, -0.00449540f, -0.02912313f, -0.18279155f, 0.11288747f, 
    -0.10202924f, -0.04790289f, -0.06695066f, -0.18979967f, -0.24498127f, -0.16086961f, -0.03739433f, -0.04985669f, 
    -0.10436978f, 0.06967386f, -0.12762147f, -0.03874808f, -0.07050466f, 0.00961077f, -0.05018008f, -0.13467650f, 
    -0.08120987f, 0.01817402f, -0.00195233f, -0.16376473f, -0.11775906f, 0.13858616f, 0.03287329f, 0.05172574f, 
    0.00859091f, -0.01889716f, -0.07191226f, -0.08176336f, -0.17161281f, -0.31241080f, -0.18681307f, -0.03821745f, 
    -0.09972020f, -0.17946264f, -0.04894779f, -0.09889761f, 0.02067049f, 0.06003434f, -0.02733085f, -0.07402799f, 
    -0.00279098f, -0.11498692f, 0.16889936f, 0.06375548f, 0.13707560f, -0.14131407f, 0.09677726f, 0.08424937f, 
    -0.12559676f, -0.01429949f, -0.06732041f, -0.02531328f, -0.17662635f, -0.07585417f, -0.00735350f, 0.13717540f, 
    0.02111003f, -0.18517576f, -0.09160916f, 0.07122438f, 0.07557715f, -0.02999004f, 0.00146711f, -0.12286839f, 
    -0.09729603f, -0.09363072f, -0.17372172f, 0.16748109f, 0.14576797f, -0.00938684f, -0.11953019f, 0.00910941f, 
    0.06740575f, -0.00120016f, 0.00728584f, 0.01925280f, 0.12150106f, 0.05066596f, 0.15262426f, 0.34403634f, 
    0.16000190f, 0.34751689f, 0.27138951f, 0.15310450f, -0.15625821f, 0.03256427f, 0.00721452f, 0.24635646f, 
    0.03399573f, 0.05842933f, -0.02724464f, -0.01493735f, 0.12351488f, 0.10749779f, 0.09803297f, 0.04593650f, 
    -0.00074799f, -0.04925752f, 0.05832335f, 0.05971752f, 0.06243566f, 0.05349958f, -0.10029678f, 0.08554670f, 
    0.07860611f, -0.35938156f, 0.08743799f, -0.04214687f, -0.18458110f, 0.13730334f, -0.03053828f, -0.06916810f, 
    -0.23678662f, 0.09519852f, 0.00261881f, -0.23763676f, 0.36149991f, -0.12077373f, -0.33770469f, 0.08173346f, 
    0.08923762f, 0.05162506f, 0.12061117f, -0.01718969f, 0.04377661f, -0.00522382f, 0.04722907f, -0.03822799f, 
    0.17216864f, -0.51625514f, 0.15159892f, -0.14334793f, 0.00035839f, 0.05117592f, -0.01007293f, 0.05154061f, 
    0.00359743f, 0.06294944f, -0.03443234f, 0.16757904f, 0.17251496f, 0.07118682f, 0.00763107f, -0.02332018f, 
    0.02828287f, 0.02250006f, 0.06142242f, -0.14739604f, -0.01173348f, -0.05113069f, -0.02838453f, -0.07404978f, 
    0.03843014f, -0.04381369f, 0.24432614f, 0.05078311f, 0.15596268f, -0.07897088f, 0.03433431f, 0.00952610f, 
    -0.03809927f, -0.05033931f, -0.02491006f, -0.00441361f, 0.17168422f, -0.01705485f, 0.04340914f, 0.06223837f, 
    0.19552523f, -0.07132729f, 0.07629205f, 0.11669967f, 0.06601797f, 0.01800569f, 0.03776344f, -0.09159876f, 
    -0.08800495f, 0.02227179f, 0.13482116f, 0.02158748f, -0.07127503f, -0.00432023f, -0.01695280f, 0.00881518f, 
    0.06073814f, 0.01078323f, 0.03232861f, -0.01252754f, 0.18720900f, 0.23030762f, -0.01699773f, 0.11481501f, 
    -0.00562598f, -0.03136114f, 0.04444909f, -0.14652327f, 0.13981763f, -0.06086118f, 0.19259925f, 0.06099400f, 
    -0.10042866f, -0.08263907f, 0.07897877f, -0.11996596f, -0.08098984f, -0.07942150f, 0.00015023f, -0.04660970f, 
    0.30816123f, 0.16092579f, 0.05370945f, 0.38691187f, -0.00519283f, -0.01935662f, 0.01512020f, 0.02673254f, 
    0.05346364f, -0.03052040f, 0.01492808f, -0.06763757f, -0.08644588f, 0.00625836f, -0.09053582f, -0.00030258f, 
    0.04058238f, 0.14402026f, 0.02078610f, -0.05206631f, -0.11815327f, 0.03334782f, -0.23804115f, -0.14034286f, 
    -0.00862647f, -0.02359733f, -0.06050028f, -0.12500225f, 0.10797817f, 0.13869727f, -0.11156921f, 0.12957895f, 
    -0.08742596f, -0.12795909f, 0.02361592f, -0.11952207f, 0.09498720f, -0.28566509f, 0.01664547f, -0.04022240f, 
    -0.15714261f, 0.16005151f, 0.12694471f, 0.09361329f, -0.02943828f, -0.05008081f, -0.18886495f, -0.05276228f, 
    0.00245221f, -0.00571966f, -0.11192153f, 0.07083346f, 0.08566486f, 0.10894679f, 0.21335235f, 0.14381006f, 
    -0.15127423f, -0.13730882f, -0.06854033f, -0.00748932f, 0.06979201f, -0.07553657f, 0.04527435f, 0.00061654f, 
    0.03457924f, -0.02153311f, 0.13220917f, 0.05414205f, -0.02305860f, 0.12173371f, -0.11645503f, 0.09544055f, 
    -0.08612232f, -0.18920328f, -0.05511861f, -0.13202414f, -0.02710771f, 0.22923440f, -0.14064339f, -0.07747471f, 
    0.05371444f, 0.09110601f, -0.21927170f, -0.07548125f, 0.02063366f, -0.25764146f, -0.04612264f, -0.08870003f, 
    0.04308812f, 0.28067863f, 0.04955060f, 0.18450306f, 0.12907684f, -0.05493356f, 0.04945260f, -0.13959076f, 
    -0.06847978f, 0.09309965f, 0.08003615f, 0.04919073f, -0.05438079f, -0.09603006f, 0.02314913f, -0.01193408f, 
    0.02957979f, 0.00386482f, 0.02630584f, 0.11803236f, 0.04283723f, 0.10502806f, -0.08791001f, -0.16763803f, 
    -0.11590300f, -0.04967250f, 0.17664176f, 0.04993742f, 0.00381972f, -0.12900119f, -0.10445335f, -0.19477446f, 
    -0.13692218f, 0.07096222f, 0.04087576f, -0.00993531f, -0.26392782f, 0.06249483f, 0.22185244f, -0.22153239f, 
    -0.00020161f, -0.12871870f, 0.14413583f, -0.00964367f, 0.05618551f, -0.00009591f, -0.00081169f, -0.03195209f, 
    0.27502587f, -0.10890774f, -0.20052516f, 0.11981249f, 0.05419536f, -0.08272795f, 0.07688540f, 0.10384838f, 
    0.03171365f, -0.18593739f, 0.16455039f, 0.01114489f, 0.11263427f, -0.06590939f, -0.18319257f, 0.31145585f, 
    0.09619199f, -0.05322573f, -0.01467361f, -0.09968629f, -0.05825280f, 0.10490109f, 0.05093989f, -0.05588967f, 
    0.02179297f, 0.03145623f, -0.18287171f, -0.12538965f, 0.10940368f, 0.11848726f, -0.11151078f, 0.08200993f, 
    0.14041148f, -0.03702629f, 0.08630913f, -0.08728214f, -0.34766823f, 0.11747081f, 0.15075789f, 0.09548660f, 
    -0.13421859f, -0.11892711f, 0.02407079f, 0.01675907f, 0.01935419f, -0.06904408f, -0.18091197f, -0.37336859f, 
    -0.10683163f, -0.60155725f, -0.06810334f, -0.11149989f, 0.03433420f, -0.01204075f, -0.02963212f, 0.23478641f, 
    -0.00489560f, -0.07260280f, 0.07049018f, -0.10843672f, -0.03471262f, 0.29655638f, 0.14285189f, -0.24786384f, 
    0.23867218f, -0.00010175f, 0.02739041f, -0.04910075f, 0.02028397f, 0.05590293f, 0.05791751f, 0.05750773f, 
    -0.06474180f, -0.30949703f, -0.10281272f, -0.11780138f, 0.02194276f, -0.00125887f, -0.06254835f, 0.09611412f, 
    -0.02393101f, -0.05258608f, 0.03986976f, -0.14054812f, -0.10078036f, 0.00325320f, -0.34597197f, -0.28800532f, 
    0.04399296f, 0.10961978f, -0.05883421f, 0.01719455f, -0.03488083f, 0.05594550f, 0.02023572f, -0.11593381f, 
    -0.07484280f, -0.05920068f, 0.15088916f, -0.08973027f, 0.11269917f, -0.11326461f, 0.20743152f, 0.01833957f, 
    0.01658047f, 0.03109618f, 0.19427799f, -0.01043904f, -0.13936220f, -0.15026246f, -0.13712345f, -0.11983228f, 
    0.13374223f, -0.01666193f, -0.12314294f, -0.11139513f, 0.01460397f, -0.08614334f, 0.02482187f, 0.22797759f, 
    -0.40490291f, -0.22643955f, -0.09434237f, -0.15271451f, 0.04891534f, 0.00074390f, -0.03378328f, 0.12984826f, 
    0.02481743f, -0.05785578f, -0.02828461f, -0.05599780f, 0.03209316f, -0.14033982f, -0.18944207f, 0.22298485f, 
    0.10585333f, -0.08882056f, -0.02310822f, -0.06537148f, -0.06873928f, 0.01762901f, 0.10627661f, 0.14157031f, 
    0.12368744f, -0.29055470f, -0.26860812f, 0.16938791f, 0.15110210f, 0.08064134f, -0.13128901f, 0.03694667f, 
    0.06779549f, -0.06883337f, 0.07688390f, -0.07390390f, -0.15019947f, 0.04832771f, -0.25361609f, 0.21904559f, 
    -0.03265454f, 0.05949634f, 0.02980373f, -0.04685124f, 0.04159397f, -0.02359408f, 0.15206592f, 0.02197813f, 
    0.47328880f, -0.07207932f, -0.31844151f, 0.24193774f, 0.13258943f, 0.07481284f, 0.03674376f, -0.01166793f, 
    0.01187819f, -0.03586973f, 0.05847557f, -0.13425794f, 0.13256070f, -0.01162231f, 0.23898472f, -0.33934662f, 
    0.02752287f, 0.06998517f, 0.15214799f, -0.05729104f, 0.12910137f, -0.16730949f, -0.02711187f, 0.02057878f, 
    -0.20649394f, -0.06306253f, 0.27002722f, -0.01428305f, -0.06674558f, -0.09794233f, -0.03111154f, -0.02056695f, 
    0.17809957f, -0.10814460f, -0.01672978f, 0.06847452f, 0.05735817f, -0.08308503f, 0.03390154f, 0.01104132f, 
    0.19842461f, -0.00535492f, 0.22524385f, 0.11552938f, 0.03554869f, 0.16541797f, 0.06036081f, -0.01415677f, 
    0.04317381f, 0.02643383f, -0.18504523f, -0.20471033f, -0.04487278f, -0.00394666f, -0.11585823f, 0.15069887f, 
    -0.12815396f, 0.04665759f, 0.01269227f, 0.03499591f, 0.12303211f, -0.11618479f, -0.01916029f, 0.02582502f, 
    -0.08049075f, -0.01223411f, 0.05659294f, -0.03973717f, 0.08797007f, 0.07971174f, 0.02220319f, 0.04774807f, 
    0.08896182f, -0.17775154f, -0.00146473f, 0.07260266f, -0.00046758f, 0.00168461f, -0.02421860f, -0.03880515f, 
    -0.00436823f, 0.00485572f, -0.05073681f, 0.03841040f, -0.13457800f, 0.01577202f, 0.07485723f, -0.01305527f, 
    0.13724519f, -0.00585023f, -0.09574447f, 0.05454382f, -0.03552116f, -0.10689813f, 0.13998318f, -0.09141878f, 
    -0.01417695f, 0.22537667f, 0.32442880f, 0.02701801f, 0.21680774f, 0.05327864f, 0.14417915f, -0.18898267f, 
    0.05609785f, -0.08727842f, -0.03779120f, 0.02820385f, -0.24081059f, -0.11748991f, -0.46332994f, -0.26022363f, 
    0.10136195f, -0.01447247f, -0.09341444f, 0.07948940f, 0.03688769f, -0.02094858f, -0.08087221f, 0.04422627f, 
    0.15875490f, -0.00153222f, 0.19431464f, -0.11979975f, -0.10654713f, -0.07468742f, 0.01776293f, 0.03679304f, 
    0.13030289f, -0.02110327f, -0.10235599f, 0.01903127f, 0.04120730f, 0.15329108f, 0.12932706f, -0.02817196f, 
    -0.06266080f, 0.10742966f, 0.10640377f, -0.18961644f, 0.15883169f, 0.03476864f, 0.11925325f, 0.08878974f, 
    0.06013761f, 0.02427022f, 0.38392991f, -0.08236822f, -0.07970067f, 0.10222249f, -0.16640337f, -0.00169843f, 
    0.08100317f, 0.03968073f, 0.02193367f, -0.00034787f, -0.05964253f, -0.12949064f, 0.11463737f, -0.15989220f, 
    -0.05280710f, 0.18201156f, -0.06671157f, -0.10926381f, 0.02507173f, -0.15241697f, 0.08842136f, 0.15774092f, 
    -0.29901981f, 0.18695220f, 0.27187204f, 0.00764382f, -0.10895261f, -0.12864973f, -0.01123536f, 0.02573510f, 
    0.08105930f, -0.12442149f, -0.24495207f, -0.27582681f, 0.01760214f, 0.06571796f, -0.04295612f, -0.10016230f, 
    -0.00701450f, -0.00910632f, 0.02632409f, 0.26719466f, 0.04693520f, -0.07764526f, 0.14209209f, -0.07759696f, 
    -0.00682164f, -0.17113119f, -0.00548160f, -0.08281726f, 0.06826425f, -0.01794878f, -0.02418665f, 0.06264663f, 
    0.08438869f, 0.25297576f, 0.18198404f, -0.16455826f, 0.12406927f, 0.06178508f, -0.01935619f, -0.01771445f, 
    0.03969768f, 0.01831986f, -0.00224994f, 0.00618933f, -0.14491670f, -0.18006445f, -0.20891085f, 0.00895384f, 
    -0.46913442f, -0.20219231f, 0.00427935f, 0.43772113f, -0.04441620f, -0.12817788f, -0.04364111f, -0.02165271f, 
    0.04923830f, -0.03734814f, 0.22005528f, 0.08608110f, -0.29156706f, -0.30263039f, -0.19650686f, -0.04305377f, 
    0.08731415f, 0.00331801f, -0.05166337f, -0.08023670f, 0.00060728f, -0.07143418f, 0.03797128f, 0.22023571f, 
    -0.23962422f, 0.11545730f, -0.33468288f, -0.20809737f, 0.00988634f, -0.12221751f, -0.04735601f, 0.01588357f, 
    0.15302086f, 0.11631719f, -0.11424298f, 0.00932289f, -0.11570423f, -0.24110337f, 0.24828076f, 0.04726918f, 
    -0.03025981f, -0.11963191f, 0.04330264f, 0.20808336f, 0.05270409f, -0.05067760f, 0.16813785f, 0.04252626f, 
    -0.14681785f, -0.18699978f, 0.08603693f, 0.03328770f, 0.02224931f, -0.20008600f, 0.12021010f, 0.08074839f, 
    -0.04248918f, 0.04952366f, 0.17658065f, 0.38383836f, -0.00519071f, 0.14787731f, 0.03509212f, 0.14960340f, 
    -0.13071200f, 0.10312779f, -0.04669182f, 0.03478362f, -0.08410484f, 0.18450502f, 0.08608023f, 0.02244143f, 
    0.48737061f, -0.40597227f, 0.43092611f, 0.09998056f, 0.06672880f, 0.03858818f, 0.06904884f, 0.02399343f, 
    0.08731885f, -0.03341430f, 0.01690986f, -0.07441242f, -0.15202840f, 0.02790982f, 0.09351052f, -0.07335328f, 
    0.04925648f, -0.02896523f, -0.05889972f, 0.15784471f, 0.03695021f, 0.13509333f, -0.06754091f, -0.06860634f, 
    -0.25816306f, -0.33326122f, 0.22388647f, -0.07389483f, -0.02974101f, -0.03991479f, -0.06062070f, 0.02489332f, 
    0.22874443f, 0.11169267f, -0.00622100f, -0.13899465f, 0.14304647f, -0.09403414f, -0.12888733f, -0.01159769f, 
    -0.00386676f, 0.03911332f, 0.12805475f, 0.05976981f, 0.04766234f, -0.39003840f, -0.44010672f, -0.49981105f, 
    -0.05947424f, 0.16048464f, 0.04128781f, -0.23316208f, 0.23696579f, -0.06128566f, -0.14376327f, -0.44462571f, 
    -0.02348556f, 0.02971349f, -0.02989844f, 0.01723803f, -0.28515726f, -0.08458018f, -0.19552715f, 0.03470713f, 
    0.07234602f, 0.02509598f, -0.07938554f, 0.04873436f, 0.03191143f, -0.00601409f, 0.14736454f, -0.06796594f, 
    -0.10840800f, -0.20486292f, 0.27266911f, 0.01735635f, -0.18636887f, -0.11823350f, -0.10148028f, 0.09321428f, 
    0.11543440f, -0.00713381f, -0.07320398f, 0.25951904f, -0.09286224f, -0.15879193f, -0.31041515f, 0.06856287f, 
    0.02008136f, 0.02761479f, 0.03372048f, 0.01712168f, 0.08624683f, -0.02681866f, -0.00085293f, 0.02314006f, 
    -0.13993262f, -0.13352758f, 0.01705780f, 0.18040648f, -0.11594199f, -0.09348359f, -0.00967008f, -0.01236341f, 
    0.13335331f, -0.01029098f, -0.09024918f, -0.12988515f, -0.02969267f, -0.07361455f, 0.01909333f, -0.02621625f, 
    -0.14765325f, -0.02712806f, -0.00313027f, 0.02650757f, 0.15541418f, -0.01405161f, 0.20642029f, -0.11399889f, 
    0.34463805f, -0.05817129f, 0.07186189f, 0.02436241f, 0.09747425f, 0.02176354f, 0.17850535f, 0.01475092f, 
    0.04939610f, 0.08476155f, -0.05923472f, -0.07291555f, 0.02376924f, -0.09559584f, -0.05615142f, 0.00957614f, 
    -0.12642756f, 0.21982203f, -0.05118125f, 0.02761814f, -0.01167203f, 0.05809257f, -0.03328308f, 0.01297973f, 
    -0.00627970f, -0.03269342f, -0.12924288f, -0.01082540f, -0.02449963f, -0.05278657f, -0.08427246f, 0.25095299f, 
    -0.13655901f, -0.08896264f, 0.11272613f, 0.07657466f, 0.01657995f, -0.16866876f, -0.23573139f, 0.11665020f, 
    0.11800315f, 0.00714065f, -0.01369621f, 0.14232770f, -0.15226567f, 0.02682547f, 0.08673736f, -0.23088327f, 
    -0.02289720f, -0.05555743f, -0.00541972f, -0.09935506f, 0.04362423f, 0.03532204f, 0.03940964f, 0.01005726f, 
    -0.10842838f, -0.07365837f, -0.21045133f, -0.43254101f, 0.16739787f, -0.05005032f, 0.00967800f, -0.17226538f, 
    -0.12640528f, 0.13536151f, -0.03764716f, 0.08132572f, -0.07441801f, -0.20969205f, -0.03368945f, -0.03651272f, 
    -0.29585961f, 0.28844959f, -0.12218514f, -0.27717364f, 0.22253361f, 0.19281812f, -0.27875304f, 0.07429400f, 
    -0.16125575f, -0.08598856f, 0.15704207f, -0.01400255f, -0.21033725f, -0.33972448f, -0.00958837f, -0.06475344f, 
    0.06786339f, 0.01064499f, -0.14324182f, 0.01718507f, 0.21115071f, 0.11884541f, -0.10924160f, -0.00606386f, 
    -0.05319069f, -0.12596233f, -0.19272922f, -0.27697372f, 0.07422094f, 0.07355101f, -0.12233597f, -0.12500468f, 
    0.10092016f, 0.09934926f, 0.08372673f, -0.13603735f, 0.18879966f, 0.14804739f, 0.01856669f, 0.08781368f, 
    0.23410195f, 0.09363501f, 0.25429967f, -0.10366478f, 0.05102570f, 0.10010386f, 0.04867560f, -0.02505101f, 
    0.02663685f, -0.14076386f, 0.09352417f, -0.11628764f, -0.15632333f, 0.01513624f, -0.17830820f, -0.13789353f, 
    0.17279403f, -0.03347455f, -0.01506113f, 0.04523417f, -0.11043391f, -0.11980640f, -0.12615675f, 0.11912517f, 
    0.09597228f, 0.03925491f, 0.01322845f, -0.15307313f, 0.19910669f, 0.11093641f, 0.04695607f, -0.14928332f, 
    0.04209720f, 0.21616162f, -0.00978824f, -0.01891823f, 0.04134882f, 0.02113316f, 0.05309872f, -0.13341673f, 
    -0.02648247f, -0.08526193f, -0.19512638f, -0.10778960f, -0.02187354f, -0.17262588f, -0.21755709f, -0.00487315f, 
    -0.14116770f, 0.10998044f, 0.00189710f, 0.00055298f, -0.01760149f, -0.07766584f, 0.00756737f, 0.03988209f, 
    -0.24589732f, -0.08508269f, -0.13998213f, 0.17886119f, 0.05205913f, 0.01426478f, 0.00000863f, -0.13769557f, 
    -0.05488933f, 0.01234757f, 0.05810598f, 0.07710725f, -0.53623670f, -0.50290442f, -0.43025127f, -0.43106055f, 
    -0.19165365f, -0.16511321f, -0.06371664f, -0.20799834f, -0.07063116f, 0.01080940f, -0.00377479f, 0.02498040f, 
    0.33670262f, -0.01796682f, -0.14640947f, 0.06356234f, -0.04067636f, -0.04324844f, 0.21458238f, 0.11753304f, 
    0.14136826f, 0.11242264f, -0.10567328f, -0.04973789f, 0.07256266f, -0.00959894f, -0.04790369f, -0.02380766f, 
    0.08154827f, 0.05209880f, 0.06659303f, 0.08136415f, -0.02020759f, 0.06073558f, -0.07639851f, 0.07324535f, 
    -0.01571273f, 0.10574947f, -0.00693315f, -0.16658215f, -0.04366969f, -0.07836800f, 0.13787770f, 0.01605825f, 
    0.00212840f, 0.08536040f, 0.07808658f, -0.10644048f, -0.05994123f, -0.02088849f, 0.02692312f, -0.01110683f, 
    -0.10153247f, 0.08652265f, 0.10850380f, 0.09265871f, -0.03676223f, 0.03164853f, 0.17439848f, 0.10890231f, 
    0.00857175f, 0.10008822f, 0.06726136f, 0.19207621f, -0.04683091f, 0.02373010f, -0.16643706f, 0.04009688f, 
    0.01556901f, -0.05647745f, 0.08673252f, 0.14934751f, -0.75651729f, -0.50633675f, 0.03363833f, 0.42942888f, 
    -0.04798536f, -0.15459184f, -0.32052645f, -0.24115860f, -0.01078117f, 0.01352969f, -0.03349227f, 0.01756472f, 
    -0.04854599f, 0.45672983f, -0.00191844f, 0.07394464f, -0.07348619f, -0.01748773f, -0.07353806f, -0.00768264f, 
    0.07613195f, -0.03443589f, 0.07576274f, 0.09265084f, -0.12722874f, 0.40398371f, 0.01756650f, -0.08073676f, 
    0.02864249f, 0.04256079f, 0.05104832f, -0.17872658f, 0.12026706f, -0.02477249f, 0.10923155f, -0.01111267f, 
    -0.12642039f, -0.15152359f, -0.34388503f, -0.13765210f, -0.10958996f, 0.14155391f, -0.20194849f, 0.01137332f, 
    0.08142869f, -0.05522916f, 0.02755008f, -0.09436196f, -0.33522588f, -0.24801366f, 0.38618618f, 0.26585484f, 
    0.02680908f, -0.18276753f, 0.00303244f, -0.03859008f, -0.03749830f, 0.00442709f, 0.09917399f, 0.09752344f, 
    -0.47280735f, 0.20055212f, 0.34426638f, 0.08229955f, -0.08333451f, 0.00537562f, -0.08794412f, -0.02151714f, 
    -0.07472516f, 0.06834334f, 0.05748223f, 0.05497533f, 0.27664623f, 0.05012757f, -0.17422846f, -0.06695508f, 
    -0.09863335f, 0.00270956f, 0.11448555f, -0.04624090f, 0.01870465f, 0.00962611f, 0.00534077f, -0.14179501f, 
    0.17490517f, -0.17039570f, -0.02461672f, -0.06691612f, 0.09599991f, 0.00792990f, -0.01343720f, -0.11052795f, 
    -0.03717094f, -0.01211942f, -0.00040241f, 0.01324119f, 0.14635007f, 0.08549410f, 0.01677196f, -0.14308813f, 
    -0.03748079f, -0.00052949f, -0.01434864f, 0.00437258f, 0.00979721f, -0.02858905f, 0.16953343f, -0.17706165f, 
    0.42827109f, 0.29824314f, -0.17872787f, -0.06392787f, 0.00746570f, -0.02018804f, 0.17442429f, -0.01889510f, 
    0.14586706f, 0.08308273f, 0.11017981f, -0.00716326f, -0.48024914f, -0.12337266f, 0.21382384f, -0.14409795f, 
    -0.08342113f, -0.12144493f, 0.01947964f, -0.02871906f, -0.05380462f, 0.02732938f, 0.08222075f, -0.02571600f, 
    0.02716637f, -0.20322467f, 0.02223394f, 0.08810031f, 0.01796621f, -0.03921901f, -0.10143480f, 0.06859919f, 
    -0.03532698f, -0.05409725f, 0.01742658f, -0.27986068f, -0.09681217f, -0.13538787f, 0.00794884f, -0.07199585f, 
    0.01120945f, 0.04745605f, 0.02725735f, -0.17263234f, 0.01285934f, 0.05040071f, -0.09780362f, -0.00984257f, 
    -0.08255025f, 0.15631613f, -0.01822527f, -0.13038908f, 0.06180359f, -0.00382143f, 0.02023613f, 0.02501238f, 
    0.03897841f, 0.06012838f, -0.02232402f, 0.11944401f, -0.12031255f, -0.15280186f, -0.06311595f, 0.01173649f, 
    0.15866335f, 0.06019846f, 0.18542448f, -0.00736767f, -0.04639559f, -0.01037018f, -0.05870624f, 0.05383626f, 
    -0.11254112f, 0.06527944f, -0.05037972f, -0.22715285f, -0.02302447f, -0.00272947f, -0.02510635f, -0.05164228f, 
    -0.02294873f, -0.10378483f, 0.01440309f, -0.01740309f, 0.04537359f, -0.12881291f, -0.13411191f, -0.10439252f, 
    0.04466824f, 0.17257203f, 0.03260469f, -0.06891075f, -0.08732422f, 0.00487962f, 0.04799858f, 0.00062192f, 
    -0.51777726f, -0.30977264f, -0.21391197f, -0.47470823f, -0.27006966f, -0.19937545f, 0.00960268f, 0.12607954f, 
    -0.00788287f, 0.03205219f, 0.05014318f, -0.10658152f, -0.33720380f, -0.10765041f, 0.01067698f, -0.16189222f, 
    0.03341457f, -0.06499053f, -0.18009926f, -0.00913580f, 0.00103369f, 0.03299372f, -0.01429545f, -0.00763930f, 
    -0.44708237f, -0.43120328f, -0.42826143f, -0.08223651f, -0.00091762f, 0.01443979f, 0.02713238f, -0.12409907f, 
    -0.05157050f, 0.01969352f, -0.00135206f, -0.03781764f, -0.44101924f, -0.52180755f, 0.15004611f, 0.06943262f, 
    -0.24808948f, -0.15659864f, -0.14883630f, -0.00908352f, -0.04264003f, 0.00562851f, -0.03632351f, -0.10423139f, 
    -0.27044627f, -0.92254752f, -0.48369002f, 0.45053414f, 0.13749421f, 0.08157819f, -0.21501714f, -0.17159373f, 
    0.01800125f, 0.01986806f, 0.00297292f, 0.08767591f, -0.02748045f, -0.04213104f, -0.15808336f, 0.10305032f, 
    -0.03826473f, -0.18596019f, -0.01218210f, 0.16845517f, -0.01598801f, -0.04784729f, 0.04287826f, -0.17930536f, 
    -0.05782796f, -0.56858182f, -0.37348211f, -0.03360486f, -0.25685579f, 0.07631642f, 0.06926065f, 0.21658562f, 
    0.08168999f, -0.06165064f, 0.20711979f, 0.08820532f, 0.40093923f, 0.15420617f, -0.14753158f, 0.07339716f, 
    0.04964999f, -0.19763879f, -0.08804955f, 0.14080475f, 0.17767370f, -0.11912867f, 0.02225387f, -0.02493394f, 
    0.02510807f, 0.19833541f, -0.15431598f, -0.00644422f, 0.07000949f, 0.02332631f, -0.03613732f, 0.00953485f, 
    0.18800586f, -0.14184533f, 0.09507412f, -0.09808033f, -0.14633787f, 0.09808766f, 0.02078771f, -0.07363142f, 
    -0.11183076f, 0.00306874f, -0.09993721f, -0.07141920f, 0.05195274f, -0.02823572f, 0.04202459f, 0.10406795f, 
    0.07918399f, -0.09032097f, -0.09806985f, 0.12124316f, -0.00663395f, -0.07328405f, -0.06047465f, -0.01254634f, 
    -0.08157421f, -0.08812834f, 0.14220761f, 0.02042723f, -0.11182597f, 0.06336833f, -0.24472198f, -0.08391553f, 
    0.10814589f, -0.03191743f, 0.11766924f, -0.10803735f, 0.03718425f, 0.06150346f, -0.06968784f, -0.00825483f, 
    0.05720188f, -0.12247106f, -0.07608934f, 0.11060619f, 0.06345575f, 0.05072982f, -0.03001601f, -0.04088451f, 
    -0.00257009f, -0.05309395f, 0.03370889f, -0.09845687f, 0.01438010f, 0.01255225f, -0.14701316f, 0.14443840f, 
    0.04670857f, -0.04884227f, 0.08156723f, 0.29276597f, 0.04782838f, -0.00779925f, 0.29306284f, 0.11226215f, 
    -0.00014838f, -0.01300792f, 0.27475467f, 0.20088142f, -0.01233827f, -0.11289131f, 0.09685383f, 0.14257245f, 
    -0.01457893f, -0.04944165f, -0.00793109f, 0.02773301f, -0.08976917f, 0.19111925f, 0.32939881f, 0.18946178f, 
    0.00613713f, -0.10718001f, 0.03924199f, 0.07481793f, 0.05423018f, 0.10195335f, 0.06212191f, -0.00413609f, 
    0.18630122f, 0.01351279f, -0.46481171f, -0.17608537f, -0.02675923f, 0.01336350f, -0.02006554f, 0.08939932f, 
    -0.14414388f, 0.04838977f, 0.12616967f, 0.09040551f, -0.22944823f, 0.24564521f, 0.17773263f, -0.08493888f, 
    -0.07700739f, 0.07984447f, 0.01128881f, -0.03825520f, -0.00199741f, 0.11731523f, 0.03227760f, 0.08209399f, 
    -0.07704643f, -0.07259082f, -0.10969379f, 0.13111092f, 0.04589770f, 0.14028665f, -0.01978335f, 0.04251261f, 
    0.22842841f, -0.07776680f, 0.17574438f, -0.17171516f, 0.04184564f, 0.00312865f, -0.08808117f, -0.00542986f, 
    -0.00464856f, -0.00120579f, 0.03537142f, 0.07170598f, 0.08516350f, 0.16482849f, 0.17918329f, -0.03592342f, 
    -0.54462814f, -0.59642935f, -0.62449384f, -0.23769616f, -0.26008299f, -0.04491436f, -0.31803828f, -0.24715938f, 
    -0.01615547f, -0.00894502f, -0.02891020f, 0.05781432f, -0.30983225f, 0.19766623f, 0.34876263f, 0.02435827f, 
    -0.11821475f, 0.03148060f, -0.01972007f, -0.06641385f, -0.06937046f, 0.05845734f, -0.05555173f, 0.07260516f, 
    -0.15175112f, -0.21386604f, 0.06359394f, 0.09644375f, 0.01164723f, -0.16432337f, 0.02269980f, 0.16368254f, 
    -0.09992850f, 0.10882443f, 0.00701786f, 0.08513062f, -0.00093757f, -0.27800015f, -0.10117745f, -0.27841061f, 
    0.00411219f, 0.06700491f, 0.06990309f, 0.00109069f, -0.04072170f, 0.02299579f, -0.05144731f, 0.00147797f, 
    -0.19559890f, -0.18249524f, -0.02254057f, 0.21013230f, 0.01044219f, 0.06119719f, -0.02254246f, 0.09490581f, 
    0.06004381f, -0.04292055f, -0.03084741f, 0.11370849f, -0.10452894f, -0.13731490f, 0.10147809f, 0.15237968f, 
    -0.04351260f, -0.13513869f, -0.00310259f, 0.01319832f, -0.06612810f, -0.10054512f, -0.11120532f, 0.00962818f, 
    -0.68241847f, -0.90160531f, -0.12436987f, 0.64340812f, 0.27680948f, 0.26819640f, 0.02906736f, -0.28814465f, 
    0.02476807f, -0.03582757f, 0.02889922f, 0.08426427f, -0.22458555f, -0.11098666f, 0.05463307f, 0.07941041f, 
    0.15406336f, 0.00435623f, -0.04341806f, -0.00200679f, -0.07482365f, -0.12565942f, -0.05156456f, 0.02681194f, 
    -0.45832235f, -0.10257261f, -0.09553121f, -0.09547698f, -0.31102183f, 0.04443734f, 0.24174373f, -0.06191931f, 
    0.03216933f, 0.05295861f, -0.03483084f, -0.02274976f, 0.11898561f, -0.03877071f, -0.07326898f, -0.08662749f, 
    0.02310155f, 0.07708787f, 0.21016574f, 0.04320525f, 0.00399486f, 0.07265972f, 0.07200244f, 0.09251431f, 
    -0.03934398f, 0.13485667f, 0.07108469f, -0.00240122f, -0.03791137f, 0.03450263f, 0.02103883f, -0.00519923f, 
    0.08686116f, 0.10786714f, 0.10220794f, 0.03490589f, 0.10752737f, 0.36818129f, -0.00928437f, 0.03329006f, 
    0.02597937f, -0.11451922f, -0.01210994f, 0.05576675f, 0.02686865f, -0.00875311f, -0.12309183f, 0.04885880f, 
    -0.09484946f, -0.07308288f, 0.27134225f, -0.15021601f, 0.11194906f, 0.04768245f, -0.01012840f, 0.08995284f, 
    0.02168400f, 0.11918707f, -0.06519738f, -0.00070554f, -0.02677415f, -0.00221512f, 0.15280299f, 0.08657143f, 
    0.01324079f, 0.01124059f, -0.08526049f, 0.14854158f, -0.02184178f, 0.17246595f, 0.08951959f, 0.04706351f, 
    -0.33665401f, 0.02780229f, 0.05487441f, 0.52023995f, -0.12343326f, 0.06077431f, -0.15773553f, -0.20079643f, 
    0.00574835f, -0.03038810f, 0.01575745f, 0.03983264f, -0.78886521f, -0.43920600f, -0.06290760f, -0.39852169f, 
    -0.27316910f, -0.23851654f, -0.18761860f, -0.47495914f, -0.05680223f, -0.05764855f, -0.02261925f, 0.02005097f, 
    -0.02297130f, 0.17552651f, -0.31189826f, -0.09498753f, -0.04502292f, -0.38914889f, 0.06625634f, 0.04364143f, 
    -0.01237295f, 0.11789815f, -0.14137036f, -0.11556986f, 0.11738169f, -0.06074663f, 0.09781735f, 0.10081811f, 
    0.03332217f, -0.02171852f, -0.01319535f, -0.06513130f, 0.03912279f, -0.13074596f, -0.03811044f, 0.09861990f, 
    -0.05739650f, -0.35324460f, -0.15770106f, -0.11489177f, -0.01073824f, 0.04072893f, 0.06407722f, 0.12406620f, 
    0.02950549f, -0.00317902f, 0.09044694f, 0.02158478f, -0.04932037f, 0.06475705f, -0.09929518f, 0.13277350f, 
    -0.12319282f, -0.02459089f, 0.17632098f, -0.06277462f, 0.01951807f, 0.07339641f, -0.10026515f, -0.00484926f, 
    0.25074506f, -0.24530853f, -0.17277806f, -0.19954367f, 0.15272836f, -0.07840729f, -0.08977851f, -0.08590429f, 
    -0.06850612f, 0.02884204f, 0.01662131f, 0.04430474f, -0.12157905f, -0.14273228f, -0.07305633f, -0.03565636f, 
    0.13326888f, 0.11011869f, -0.02104868f, 0.16879411f, 0.05789642f, -0.04595189f, -0.10849035f, -0.00221423f, 
    -0.15464489f, -0.27615076f, -0.11099030f, 0.04967887f, -0.13694212f, 0.12456296f, 0.03331168f, -0.04018804f, 
    0.04213323f, -0.06944369f, -0.01367334f, 0.02717170f, -0.00489007f, 0.08571263f, 0.02784958f, -0.03841692f, 
    -0.05089871f, 0.03071046f, -0.05351158f, -0.03404239f, -0.02067147f, -0.01195672f, 0.01059870f, 0.04619938f, 
    -0.21246396f, 0.17775217f, 0.32754886f, 0.09802611f, 0.09613363f, -0.13384984f, 0.09473552f, -0.04621908f, 
    0.05217545f, -0.01424910f, -0.06201772f, -0.03283404f, 0.25537115f, 0.01066669f, -0.18820894f, 0.09785707f, 
    -0.05744797f, 0.00744098f, 0.02719921f, -0.21221900f, 0.00137268f, -0.30972350f, -0.07699382f, 0.07766601f, 
    0.29044425f, -0.26697466f, -0.02900109f, -0.22000365f, -0.08692383f, 0.03799567f, -0.17698361f, 0.02326646f, 
    0.03632491f, -0.00950525f, -0.08532435f, 0.09598232f, -0.16053110f, -0.62266737f, 0.57065195f, -0.06340201f, 
    0.01238004f, 0.26521474f, -0.03595472f, 0.21512575f, 0.02576153f, 0.12578063f, 0.01175189f, 0.00875952f, 
    0.03306599f, -0.18270399f, -0.11322141f, -0.06918290f, 0.00024372f, -0.03480484f, -0.01094513f, -0.06515458f, 
    -0.17012110f, 0.03186715f, -0.00046335f, -0.01371796f, -0.18597467f, 0.13572367f, -0.05114850f, 0.10589985f, 
    0.01591580f, -0.11717466f, 0.14664891f, -0.00826664f, -0.15354212f, -0.00546746f, -0.03984705f, 0.07375038f, 
    -0.12935463f, -0.14044596f, -0.07790066f, 0.19400640f, -0.02210031f, 0.05519175f, -0.09484283f, -0.09644442f, 
    0.06500226f, 0.04325572f, 0.01993258f, -0.01912911f, -0.14890824f, -0.19083288f, -0.21092509f, -0.51001298f, 
    -0.11984292f, 0.23117183f, 0.04376717f, 0.17861719f, 0.05378809f, -0.09168869f, 0.03090333f, 0.00445460f, 
    0.51753819f, -0.40203482f, -0.30093193f, -0.29991040f, 0.00995093f, -0.06962474f, -0.06653925f, -0.03769791f, 
    0.05242613f, -0.08602601f, 0.02795961f, 0.00366344f, 0.06858674f, 0.05066945f, -0.04210095f, 0.00439728f, 
    -0.03065260f, 0.04435695f, -0.07614595f, 0.01893608f, -0.07199875f, -0.00610754f, -0.01205476f, 0.01477054f, 
    -0.10125308f, 0.12719546f, -0.02550009f, -0.04667199f, -0.06644331f, -0.06120004f, 0.00390953f, 0.03137330f, 
    0.04674319f, 0.01577421f, 0.00659319f, -0.01963606f, -0.05076379f, 0.08696061f, -0.03095293f, 0.05665714f, 
    0.02882724f, 0.04743841f, -0.00622834f, 0.01207400f, 0.11511414f, -0.00519747f, -0.06419913f, -0.14888887f, 
    -0.01054724f, -0.20826830f, 0.14879751f, -0.01421741f, 0.05149030f, -0.05751545f, -0.01652550f, 0.04762556f, 
    0.06514336f, -0.05849992f, -0.00741389f, -0.01254799f, 0.42008498f, -0.10025091f, -0.20158356f, -0.28067291f, 
    -0.01941059f, 0.17139624f, 0.03512975f, -0.12280940f, -0.11018059f, 0.11173141f, -0.00519695f, 0.04043701f, 
    0.09568713f, -0.01189214f, 0.03503681f, -0.10198367f, -0.02813600f, 0.08123157f, 0.01949621f, 0.03799359f, 
    0.02004733f, 0.02567918f, -0.10162834f, -0.00472665f, 0.10735293f, -0.08561534f, -0.01567869f, 0.01318535f, 
    0.07798530f, -0.02546972f, -0.12189322f, -0.09156358f, 0.06718031f, -0.02463671f, 0.01028753f, -0.02174450f, 
    -0.04643778f, 0.15408383f, -0.11457199f, 0.07561112f, -0.00421925f, -0.00638988f, 0.00276539f, -0.00569738f, 
    -0.05356875f, -0.02437297f, -0.10382042f, -0.13923877f, 0.05291644f, -0.00667861f, 0.10236176f, -0.21511111f, 
    -0.04517563f, 0.02297874f, 0.01304958f, 0.01648625f, 0.01997778f, 0.04326522f, 0.01230090f, 0.03155015f, 
    0.00758292f, 0.02458510f, -0.00641684f, -0.04677330f, 0.07104038f, 0.03927486f, 0.05185015f, -0.00295314f, 
    -0.01902333f, 0.01942829f, 0.05924035f, 0.01822704f, 0.03473773f, 0.00010927f, -0.00554416f, -0.12587216f, 
    -0.12896113f, -0.07070266f, -0.01345086f, 0.03549008f, 0.01848154f, -0.00413115f, 0.02311737f, 0.05615984f, 
    0.08890126f, -0.10788836f, -0.32926381f, 0.44297630f, -0.04421663f, -0.00156228f, -0.07540064f, 0.02618340f, 
    -0.02387339f, -0.01976817f, -0.16389190f, -0.03135752f, -0.24324356f, -0.34418580f, -0.38920560f, -0.39675793f, 
    -0.09277871f, -0.14755890f, 0.12649311f, 0.09955764f, 0.08075277f, 0.10994636f, -0.02594500f, 0.01964994f, 
    -0.23359926f, -0.30391163f, 0.03305151f, 0.00229953f, -0.06588127f, -0.05673706f, 0.07300891f, -0.05939046f, 
    -0.00734107f, -0.04942413f, -0.02493181f, 0.01838565f, -0.14643143f, -0.29326496f, -0.13854724f, -0.02441720f, 
    -0.16261412f, -0.19084206f, 0.04281781f, 0.10711946f, -0.02672285f, -0.04943678f, 0.04527454f, 0.02145177f, 
    -0.18675008f, -0.44006458f, 0.64602911f, -0.06245587f, 0.02831078f, -0.04261624f, -0.14947471f, 0.15873295f, 
    -0.01430717f, 0.03285328f, -0.04750783f, 0.00769148f, 0.07224339f, -0.13934849f, 0.10556989f, 0.06182491f, 
    -0.03832207f, 0.06692163f, -0.05240391f, -0.03885221f, -0.02111342f, -0.01215756f, -0.02954090f, -0.06396673f, 
    0.19044401f, -0.16936368f, -0.31106934f, 0.01763169f, 0.02972040f, -0.03390905f, -0.01837072f, -0.01073571f, 
    0.00526919f, -0.07668979f, -0.06285740f, 0.19558494f, -0.14108789f, 0.03799810f, -0.06794151f, 0.00388459f, 
    -0.13701487f, -0.00641386f, 0.09001854f, -0.04592278f, 0.02287373f, -0.02443320f, 0.01411535f, 0.02538536f, 
    0.11739428f, -0.14542530f, 0.08345758f, -0.16233595f, 0.04040826f, 0.01766246f, 0.00208664f, -0.06008846f, 
    -0.06101064f, -0.06222379f, -0.08836306f, 0.11147559f, -0.32927978f, -0.29738751f, -0.09116032f, -0.01275704f, 
    0.01682441f, -0.06569725f, 0.10634506f, 0.14633268f, 0.03837221f, 0.04760142f, 0.06228376f, -0.05609350f, 
    0.27704799f, -0.02796360f, 0.01179411f, -0.14239433f, 0.04262547f, 0.00567421f, 0.00575815f, 0.01025061f, 
    -0.03730580f, -0.00965309f, -0.10552947f, -0.28767568f, 0.01262111f, -0.07115964f, 0.07123408f, -0.09751844f, 
    0.08430508f, 0.02524387f, 0.02152205f, -0.08497951f, -0.02391987f, -0.01548243f, 0.02630302f, 0.01066423f, 
    0.01974234f, 0.08680245f, 0.07138662f, -0.03107495f, 0.05098198f, -0.05539556f, 0.03248530f, 0.04966575f, 
    0.02575962f, -0.00563814f, -0.00967732f, -0.05087789f, 0.24008107f, -0.42300731f, 0.09661388f, -0.19522187f, 
    0.04657477f, 0.02211693f, -0.05939357f, -0.09247728f, 0.04697366f, 0.15830691f, -0.21683104f, -0.06306399f, 
    0.22165793f, -0.18593697f, -0.02159438f, -0.19648720f, 0.02562023f, 0.09632324f, -0.08132385f, 0.12971753f, 
    0.08994992f, -0.04396254f, 0.08540889f, -0.08394948f, 0.18796009f, 0.09027357f, -0.54076344f, 0.13228826f, 
    -0.00109150f, 0.04742735f, -0.02179597f, -0.02514917f, -0.22902203f, 0.03152451f, 0.07064496f, 0.00255445f, 
    0.05002373f, -0.23081544f, 0.08010629f, 0.17511322f, 0.02892682f, 0.00806239f, -0.12762627f, -0.09141979f, 
    0.04039675f, -0.03238071f, -0.03851543f, 0.01485701f, 0.32478672f, -0.10889158f, -0.11573882f, -0.11412448f, 
    -0.03422086f, -0.03125812f, 0.00383943f, 0.08444864f, 0.04803017f, 0.05734152f, -0.00687086f, -0.03250926f, 
    0.29276356f, -0.16698900f, 0.08500265f, -0.19311273f, -0.01574622f, 0.03834877f, -0.04496853f, -0.00406757f, 
    -0.04564014f, 0.08751292f, -0.09591725f, -0.12133703f, 0.02305732f, 0.09017148f, 0.11372758f, 0.02095847f, 
    0.05385006f, -0.02610553f, 0.00381676f, -0.07530726f, 0.05723972f, 0.06028099f, 0.01318013f, 0.00989123f, 
    -0.31322145f, -0.22038020f, 0.12257612f, 0.14688593f, 0.08297537f, 0.17070268f, 0.03454677f, 0.17179058f, 
    -0.10027536f, -0.02386210f, -0.05288773f, -0.08286586f, 0.38144153f, 0.09612147f, -0.11502219f, -0.14544581f, 
    -0.00557881f, -0.00668738f, -0.05032077f, 0.01549708f, 0.00294836f, -0.05519228f, -0.01352786f, 0.05958095f, 
    0.48693368f, -0.38637516f, 0.23848315f, -0.57180148f, 0.00582678f, 0.07453909f, -0.03354784f, -0.00563059f, 
    -0.12368812f, 0.13664329f, 0.03617385f, -0.06030090f, -0.03699481f, 0.15059163f, -0.03821144f, -0.07242866f, 
    0.02672126f, -0.06453455f, -0.02375087f, 0.01728627f, 0.04530005f, -0.03726128f, 0.06457459f, -0.04545311f, 
    0.10381186f, -0.04186377f, 0.06058548f, -0.23385726f, 0.03742990f, 0.07254551f, -0.07263034f, 0.03001922f, 
    -0.00142490f, 0.09745666f, 0.04164979f, -0.15670052f, 0.10893828f, -0.03596956f, 0.03383745f, -0.07135013f, 
    -0.12965743f, 0.00936049f, 0.03532686f, 0.02023855f, -0.01381983f, -0.02185619f, 0.03435738f, -0.04304903f, 
    -0.10367110f, -0.23034112f, 0.26451892f, -0.47827971f, -0.12855953f, -0.00132143f, 0.12134922f, 0.04509946f, 
    0.04159205f, 0.01399014f, 0.08720144f, -0.02981224f, -0.03364306f, 0.08455738f, 0.01805423f, -0.11144663f, 
    -0.12692428f, 0.03952133f, -0.04130479f, 0.09229979f, 0.02137337f, 0.03722714f, 0.02630120f, -0.02799952f, 
    -0.34128097f, -0.29299229f, -0.03926404f, -0.01750224f, -0.02089753f, -0.04717413f, 0.13216056f, 0.20988616f, 
    0.03124686f, -0.00286448f, -0.04249516f, -0.01936268f, 0.10919137f, 0.13956846f, -0.05591309f, 0.01302135f, 
    -0.06178366f, -0.00955045f, 0.02629492f, -0.04248933f, -0.07725555f, 0.08805849f, 0.02827580f, 0.06404363f, 
    0.07232624f, -0.11798207f, -0.10850480f, -0.03780010f, -0.01920361f, -0.02319163f, -0.02295731f, -0.04260104f, 
    0.11419124f, 0.11077148f, 0.10647353f, 0.02384170f, -0.28438425f, -0.32358828f, 0.07038359f, -0.19411016f, 
    -0.05802925f, 0.03900384f, -0.03886030f, 0.07290843f, -0.11260603f, -0.02948203f, -0.02248202f, 0.05461894f, 
    -0.25305209f, 0.13621607f, -0.03350241f, 0.10438383f, -0.08237270f, -0.03858461f, -0.05318821f, 0.07045381f, 
    0.04578773f, 0.03050934f, -0.09023080f, 0.04341121f, 0.52953404f, -0.44754183f, -0.08984722f, -0.55148762f, 
    -0.14915268f, -0.00351885f, -0.06949706f, 0.15702517f, 0.09096515f, 0.08989891f, 0.08511509f, -0.03025413f, 
    -0.50357777f, -0.43513429f, -0.48800001f, -0.40887129f, 0.00450185f, -0.13148874f, 0.21911728f, 0.11037751f, 
    0.07441790f, -0.01742872f, -0.01266425f, 0.00317850f, -0.40964755f, -0.07177602f, -0.32584497f, 0.31411624f, 
    0.28155881f, -0.00222091f, 0.00131244f, 0.02384495f, 0.03087524f, -0.00964550f, -0.01122389f, -0.00837819f, 
    -0.04515518f, -0.18342583f, 0.12726526f, 0.07419826f, -0.03571517f, -0.26718509f, 0.17077109f, 0.05033703f, 
    -0.00410652f, -0.04298114f, 0.01502611f, 0.06199180f, -0.09959597f, 0.05947117f, 0.01095458f, 0.00613415f, 
    -0.12947157f, 0.04537141f, 0.14924765f, 0.08192471f, -0.19954269f, -0.08206615f, 0.06963474f, 0.04315995f, 
    -0.17809977f, 0.25122768f, 0.06971051f, 0.20386052f, -0.05441424f, -0.13101181f, -0.03977907f, 0.02814750f, 
    0.02705199f, -0.01284869f, 0.04591702f, -0.07462342f, 0.11316812f, -0.02901283f, -0.10840014f, -0.06234748f, 
    -0.13921700f, 0.03619775f, -0.11383089f, -0.11047219f, -0.09103592f, -0.07324546f, -0.05794784f, -0.06317441f, 
    0.25107163f, 0.16558455f, 0.04686983f, -0.12315600f, -0.01203130f, 0.04629491f, 0.14010994f, -0.22771071f, 
    -0.00674111f, -0.02102562f, -0.02915772f, -0.05215729f, -0.27904806f, -0.46423441f, -0.48684341f, -0.39383677f, 
    -0.06087101f, -0.25235918f, -0.11712530f, -0.08836126f, 0.02339058f, 0.01717449f, -0.04654130f, -0.04180365f, 
    -0.14879161f, 0.18661070f, -0.08241139f, 0.30212599f, 0.08762475f, 0.05178842f, -0.07140410f, 0.06315970f, 
    -0.01505152f, 0.00395369f, -0.10072763f, 0.03066151f, -0.12471567f, 0.07731427f, -0.08269563f, -0.01242086f, 
    0.07711413f, 0.01815588f, 0.03940040f, 0.01500474f, -0.07414041f, -0.14261822f, -0.01933200f, -0.08934808f, 
    -0.41331568f, -0.09408014f, 0.13441938f, 0.13393150f, 0.12307499f, 0.11323024f, -0.07453746f, -0.10044166f, 
    0.09126332f, 0.15423343f, 0.04983902f, 0.18351996f, 0.07665729f, 0.04197536f, -0.03558734f, -0.09824947f, 
    0.02817233f, 0.10641122f, 0.09089071f, 0.16057205f, -0.14401674f, 0.07320444f, 0.11734151f, -0.13110778f, 
    -0.13050477f, -0.23326021f, -0.03146266f, 0.03232756f, 0.06127827f, 0.04436985f, 0.08140732f, 0.09363500f, 
    -0.20229511f, -0.04849598f, 0.01697857f, -0.25546801f, 0.28307810f, -0.41608602f, -0.26258299f, -0.01332432f, 
    -0.15556994f, 0.06536628f, 0.11458353f, -0.10243928f, 0.07556213f, -0.02964002f, 0.01031925f, 0.03071316f, 
    -0.20910037f, -0.31303152f, -0.13060237f, -0.08011066f, 0.03160705f, 0.10187394f, 0.07623363f, 0.05262419f, 
    0.17010272f, 0.01459174f, 0.01226957f, 0.00067138f, -0.48163369f, -0.25741848f, 0.16678956f, 0.05456286f, 
    -0.05367912f, 0.05176951f, 0.05660528f, 0.05344591f, 0.01455644f, 0.02853517f, -0.08420857f, 0.05362316f, 
    -0.09287728f, -0.14017408f, 0.04057351f, -0.02006088f, 0.06379332f, 0.03373720f, 0.06557187f, -0.01328139f, 
    -0.05238127f, -0.04631246f, -0.05837295f, 0.04346319f, -0.13037591f, -0.43141186f, -0.05564526f, 0.39812970f, 
    0.09953219f, -0.13524835f, 0.12604722f, 0.04278631f, -0.02058350f, 0.03037945f, 0.04340743f, 0.13593774f, 
    -0.23481227f, -0.40714735f, -0.29038432f, 0.09981346f, 0.03939130f, 0.12354937f, 0.05395235f, 0.12830554f, 
    0.06521818f, 0.01230270f, -0.02005341f, -0.00990271f, -0.18456964f, 0.09816055f, 0.09325170f, 0.05782102f, 
    0.06157271f, -0.02424435f, -0.01496025f, 0.02619648f, -0.00937308f, -0.09904020f, 0.06781819f, -0.00241016f, 
    -0.21830140f, 0.14176537f, 0.05525632f, 0.00248116f, -0.08337249f, -0.01205658f, 0.01317637f, 0.07361135f, 
    -0.10357197f, 0.04449379f, 0.00529830f, -0.00608569f, -0.20144817f, 0.15680401f, 0.07238450f, -0.00139620f, 
    -0.02906733f, -0.05654572f, -0.08111789f, -0.01828052f, -0.10715122f, 0.05826047f, -0.06409261f, 0.16959475f, 
    -0.20368063f, 0.23682137f, 0.08408739f, -0.02925339f, 0.24013633f, -0.01259391f, -0.08489621f, 0.08555402f, 
    -0.10183702f, 0.00867773f, 0.03020082f, -0.10737317f, 0.19727689f, -0.05151255f, -0.42839208f, -0.46995151f, 
    -0.16648021f, -0.04741577f, 0.05054490f, 0.15952489f, 0.10233989f, 0.07938574f, 0.02950231f, 0.25465947f, 
    0.05082605f, -0.04408748f, -0.07208530f, -0.02030510f, -0.06057331f, -0.05011482f, 0.02078762f, -0.04541522f, 
    0.10534605f, 0.11613370f, 0.12172133f, 0.07892797f, 0.01361503f, -0.05007414f, -0.09935772f, -0.07918020f, 
    -0.03518359f, -0.02192410f, 0.00141034f, 0.25231573f, -0.01083817f, -0.01208454f, 0.01616001f, 0.00606923f, 
    -0.15810756f, -0.15320766f, 0.06310080f, -0.07944360f, -0.16542797f, 0.00674478f, 0.07693013f, -0.00817415f, 
    -0.01314786f, -0.02642792f, -0.03545969f, 0.05877589f, 0.06573260f, -0.03005314f, 0.01920408f, 0.04429380f, 
    -0.05321077f, 0.02839402f, -0.03023026f, -0.07254280f, 0.04292456f, 0.05266658f, 0.10939392f, 0.03192923f, 
    -0.21572530f, 0.18664475f, 0.12051520f, -0.00270978f, -0.07382798f, -0.07027561f, -0.02379215f, -0.04677539f, 
    -0.06513409f, -0.04011455f, 0.01499379f, 0.02983842f, -0.22551742f, 0.07682354f, 0.04042951f, -0.04432329f, 
    0.03366609f, -0.16171457f, -0.26474166f, -0.26390582f, -0.18709981f, -0.00731269f, -0.17682365f, -0.08779921f, 
    0.23116390f, -0.15984766f, -0.53173715f, 0.06932461f, -0.06961069f, -0.08212698f, -0.10306920f, -0.10575352f, 
    0.12320695f, 0.03986473f, 0.03780231f, 0.03469291f, -0.22361508f, -0.58304036f, -0.11849531f, 0.19051750f, 
    -0.17671902f, 0.08500119f, -0.10115499f, -0.02698930f, -0.10465730f, -0.07260957f, -0.04932784f, 0.03850107f, 
    -0.07512264f, -0.48528275f, -0.34615490f, -0.21237546f, 0.11128187f, 0.03856543f, 0.08743937f, -0.06982613f, 
    0.01958587f, 0.03220106f, 0.17217283f, 0.01377881f, -0.21325128f, -0.42824271f, -0.31599417f, -0.05978307f, 
    -0.07134918f, -0.04351566f, 0.02687656f, 0.02283166f, 0.01977253f, -0.01607079f, 0.02663277f, 0.18568785f, 
    0.67239612f, 0.45133907f, -0.08771430f, -0.42771590f, -0.13008699f, -0.23318698f, -0.23197368f, -0.26155990f, 
    0.02158877f, 0.12388454f, 0.00585868f, 0.07999597f, 0.14389172f, -0.03420961f, -0.10979424f, -0.11516546f, 
    0.13740335f, -0.14438263f, 0.06918903f, 0.07163265f, 0.09944980f, 0.13801649f, 0.12017780f, 0.05162516f, 
    0.07087671f, -0.09463895f, -0.15847731f, -0.10060958f, 0.16370156f, 0.09641668f, 0.12539117f, 0.17498724f, 
    -0.01341199f, -0.01787679f, 0.05504073f, -0.24510415f, -0.23150901f, -0.15837647f, 0.00290485f, 0.17672618f, 
    0.10095488f, 0.12410671f, 0.03275935f, 0.02043389f, -0.05593693f, -0.05818389f, -0.03205374f, -0.00722198f, 
    0.00992427f, 0.02455832f, -0.02630756f, -0.17813735f, 0.02785274f, 0.04140091f, 0.03622008f, -0.00637848f, 
    0.02433833f, -0.02583720f, 0.01999541f, 0.10725688f, 0.16791242f, -0.09767403f, 0.03869225f, 0.09060036f, 
    -0.09184821f, 0.07353482f, 0.02961019f, -0.00252634f, -0.26881453f, -0.31558928f, -0.13992663f, -0.15831107f, 
    0.15613005f, 0.08967181f, 0.01434223f, -0.08636202f, -0.07367887f, -0.06418613f, 0.02668364f, -0.05109772f, 
    0.11580566f, 0.05692299f, 0.09889503f, 0.19931608f, 0.00086470f, 0.09952137f, 0.13189195f, -0.06389225f, 
    -0.06811863f, -0.07509542f, 0.02799140f, -0.08656449f, -0.06443093f, 0.02085499f, -0.08808994f, -0.01108449f, 
    -0.10251532f, 0.12700881f, 0.23413977f, 0.02730425f, -0.16950513f, -0.05291705f, -0.06587932f, -0.02223225f, 
    0.00572722f, 0.14042544f, 0.08857019f, -0.01809697f, 0.35208118f, 0.05959622f, -0.19058804f, -0.23453721f, 
    0.24253875f, 0.05323517f, 0.06605285f, -0.06659638f, 0.10807162f, -0.07695581f, 0.08986709f, -0.11800262f, 
    0.11166403f, -0.00284480f, -0.19981340f, 0.14685909f, 0.16257833f, -0.23126495f, -0.04314955f, 0.05086209f, 
    0.05831428f, 0.10387435f, -0.02163940f, 0.18273038f, 0.24646418f, -0.04193551f, -0.12806810f, -0.06528689f, 
    0.18091662f, -0.02652038f, 0.16008367f, 0.02260265f, 0.17700380f, 0.12115263f, 0.09240758f, 0.20130895f, 
    0.61360234f, 0.18421933f, -0.26180273f, -0.26254019f, 0.10379772f, -0.04030234f, 0.02455922f, 0.05113971f, 
    0.12174649f, 0.06184535f, 0.08177797f, 0.21390593f, 0.00470131f, -0.12675583f, -0.37678877f, -0.08138727f, 
    -0.03337191f, 0.00067057f, 0.06658395f, 0.01359631f, 0.18231916f, -0.20410863f, -0.08621105f, -0.07175949f, 
    0.16301596f, -0.02556249f, 0.03891497f, -0.34139782f, 0.10168339f, -0.03186993f, 0.02475103f, -0.02757394f, 
    -0.08348912f, 0.00919217f, 0.06456368f, 0.12138839f, -0.35107410f, -0.15310164f, -0.04195562f, -0.11580100f, 
    -0.02983114f, -0.06846924f, -0.09244908f, -0.12771682f, -0.13152288f, -0.09973262f, -0.20480153f, -0.32156056f, 
    -0.35699379f, -0.44446158f, 0.01713926f, -0.09812923f, 0.13457379f, -0.10253541f, 0.02168399f, 0.04104717f, 
    0.00113520f, -0.07662328f, 0.00464517f, 0.04988867f, -0.09473646f, -0.18966319f, -0.15291385f, -0.13593468f, 
    -0.09134028f, 0.05354058f, 0.03919102f, 0.07004072f, 0.15354933f, -0.10547908f, -0.12513021f, -0.06254473f, 
    0.37015456f, -0.01139670f, -0.33423251f, -0.31507912f, 0.15489100f, -0.21001187f, 0.05492432f, -0.06428006f, 
    0.19838366f, 0.10224704f, 0.10816254f, 0.12629528f, -0.30604693f, 0.08123577f, 0.14344603f, 0.09269850f, 
    -0.00539873f, -0.07021900f, -0.01589537f, 0.00861479f, -0.02750475f, 0.04296340f, -0.07445981f, 0.02372997f, 
    0.33561075f, -0.10670995f, -0.05118524f, -0.25991836f, 0.03356054f, 0.01179821f, 0.03916559f, 0.01654705f, 
    0.07109891f, -0.06822874f, 0.00877418f, 0.07198001f, -0.07271096f, -0.02599621f, -0.06815849f, -0.00422341f, 
    0.01635764f, -0.06330679f, 0.06670135f, 0.02549206f, 0.04623131f, 0.09536096f, 0.04492138f, 0.19652493f, 
    0.30978525f, 0.06842083f, -0.03963245f, -0.19800127f, -0.11244921f, -0.00091636f, -0.08398397f, -0.24920833f, 
    -0.04548213f, -0.10492522f, -0.01835467f, 0.01611156f, -0.02310998f, -0.00546430f, -0.01940773f, -0.15768383f, 
    -0.05605872f, -0.06625763f, -0.01946689f, -0.04600331f, 0.08871230f, 0.09381218f, 0.06712870f, 0.14270420f, 
    -0.07490717f, -0.23189157f, -0.24070865f, 0.12217363f, -0.06872220f, 0.08197369f, 0.04264311f, -0.00689398f, 
    -0.05943713f, -0.15920331f, -0.15036632f, -0.06652650f, -0.30340049f, 0.01323832f, 0.00501841f, 0.08762611f, 
    -0.02431857f, 0.07658479f, -0.08460055f, -0.09899908f, -0.26489592f, -0.15527651f, -0.17960334f, -0.17383446f, 
    0.03429459f, -0.07188773f, 0.03786797f, 0.01718118f, -0.02323214f, 0.06044763f, 0.04741132f, 0.01326342f, 
    -0.07496446f, -0.22256006f, -0.06470218f, -0.42948624f, 0.12774017f, -0.18690178f, -0.06062614f, 0.22960663f, 
    0.06310827f, -0.00613671f, 0.02198971f, 0.02348235f, 0.00088127f, -0.03399724f, 0.05045541f, 0.00797745f, 
    -0.31991166f, -0.00793603f, -0.13537732f, 0.16275246f, 0.14214294f, -0.02839083f, -0.04315786f, 0.07831772f, 
    0.15500583f, -0.16766579f, -0.06245283f, 0.05998617f, -0.25530681f, -0.43335289f, -0.34252861f, -0.02654949f, 
    0.07515078f, 0.17980355f, 0.13070607f, 0.05437148f, 0.19494574f, 0.04037278f, 0.12755150f, 0.08103628f, 
    0.11290610f, -0.58052236f, -0.09873434f, 0.20556882f, -0.23894350f, 0.09055910f, 0.01961504f, -0.03664514f, 
    -0.09769464f, 0.02042804f, 0.06972634f, -0.03718751f, -0.18028940f, -0.43828279f, -0.45463112f, -0.14453888f, 
    -0.05068692f, 0.04427266f, -0.04446471f, 0.16531086f, -0.07424450f, 0.06346225f, -0.01227935f, 0.07683765f, 
    -0.00086847f, -0.17053795f, -0.24279854f, -0.04100258f, 0.21752809f, 0.02017174f, 0.13032818f, -0.06230657f, 
    0.09743728f, 0.18096083f, 0.13987304f, 0.13224299f, -0.28273252f, -0.03746059f, -0.10284256f, 0.16636586f, 
    -0.15751202f, 0.16223268f, 0.15060338f, 0.03156120f, 0.03548434f, 0.08778153f, 0.10570227f, 0.07790727f, 
    -0.38472182f, -0.00072011f, -0.35619599f, -0.31363419f, 0.03822168f, 0.03647332f, 0.09378897f, -0.05049795f, 
    -0.02911344f, 0.14154361f, -0.06097500f, -0.25867251f, -0.00255117f, -0.05558411f, 0.01443532f, 0.00937971f, 
    0.08259749f, -0.01675960f, 0.11033292f, 0.10935595f, 0.14912127f, -0.12954292f, 0.02003884f, 0.05938113f, 
    -0.19146293f, -0.29826406f, -0.11867304f, -0.10123639f, 0.10882373f, 0.06311629f, -0.01805163f, 0.18550214f, 
    0.09834298f, 0.01965067f, 0.00978597f, 0.07270799f, -0.26851842f, -0.03665628f, 0.00651812f, -0.07819753f, 
    -0.17499804f, 0.05036282f, 0.10634177f, 0.11042084f, 0.16604176f, 0.11364020f, 0.05260446f, 0.02850010f, 
    -0.20611601f, 0.53760481f, 0.05358593f, -0.24787025f, -0.00690536f, -0.26189196f, -0.11105867f, -0.33698255f, 
    0.08305056f, 0.06282938f, -0.06906084f, -0.06705523f, -0.16190504f, -0.05826767f, -0.25148511f, 0.13692054f, 
    0.01903035f, 0.13969310f, 0.01864036f, 0.05487008f, -0.06465100f, 0.08429360f, -0.04193148f, 0.00446805f, 
    -0.07517529f, -0.23654333f, -0.08681978f, -0.24274403f, 0.15181577f, 0.03339226f, 0.02987528f, -0.05229170f, 
    0.06230445f, 0.05898302f, -0.25760695f, -0.03967812f, -0.29170647f, 0.05098617f, -0.20674445f, 0.19034420f, 
    0.07780813f, -0.16766733f, -0.23408805f, -0.10911752f, 0.23401627f, -0.08770578f, 0.08927315f, 0.18107729f, 
    0.06840905f, 0.26766506f, -0.02012770f, -0.22138940f, -0.22727560f, -0.12388804f, -0.04765440f, -0.21197282f, 
    0.03612493f, 0.03289602f, 0.05957028f, 0.00013838f, -0.44822118f, -0.40201455f, -0.15002547f, -0.17453200f, 
    -0.32019243f, 0.10209371f, -0.10163435f, 0.13677658f, -0.03765536f, -0.05888223f, -0.03064229f, 0.02183719f, 
    0.26594251f, 0.07035489f, 0.38815004f, 0.11497222f, 0.04021095f, -0.23212047f, -0.08469570f, -0.12529728f, 
    -0.14597587f, 0.02536374f, 0.11182152f, 0.12556762f, 0.05670527f, -0.21619266f, 0.42640477f, -0.32548904f, 
    0.14857827f, -0.19076020f, -0.15337677f, 0.10954852f, -0.03813013f, 0.11730839f, 0.01924108f, 0.07130919f, 
    0.18010695f, 0.24391305f, -0.02635535f, -0.02287043f, 0.03182298f, -0.11423667f, -0.01968424f, -0.06436463f, 
    -0.07052393f, -0.00606528f, -0.01477758f, -0.07000737f, -0.00610957f, -0.11480150f, -0.30007330f, -0.80776125f, 
    -0.04632905f, -0.18194154f, 0.16503912f, -0.01037089f, 0.02267335f, -0.02014362f, -0.08478282f, -0.05844737f, 
    0.15469386f, 0.09888415f, 0.24584319f, 0.15759002f, -0.00345623f, -0.09287064f, -0.21436048f, -0.18047306f, 
    0.08150961f, -0.07570255f, 0.00095234f, 0.05614686f, -0.24667539f, 0.07493224f, -0.40975875f, 0.05643903f, 
    0.06809223f, 0.04164146f, 0.07528815f, 0.05603901f, 0.16850001f, 0.03222470f, 0.04700239f, 0.02866016f, 
    0.08091205f, -0.06546409f, -0.23238783f, 0.02502313f, 0.00932508f, 0.32293266f, 0.15981077f, 0.06279866f, 
    0.08994962f, -0.06149172f, -0.05697823f, -0.12995435f, -0.24062689f, 0.03040155f, -0.17845368f, 0.06808392f, 
    0.09954585f, 0.05672118f, 0.06452630f, 0.03456781f, -0.00758673f, 0.00775396f, 0.04510344f, 0.08099444f, 
    0.10220958f, 0.19977826f, -0.37860003f, -0.29154968f, -0.05993662f, -0.05885460f, 0.14215204f, 0.07701503f, 
    0.08992765f, -0.00599122f, 0.01263273f, -0.00710373f, 0.09888040f, -0.06403977f, 0.18536584f, 0.49031809f, 
    0.24668464f, 0.09570487f, -0.23962483f, -0.04610845f, -0.13832793f, -0.20890944f, -0.04456720f, 0.03633837f, 
    -0.05220869f, -0.28904778f, 0.23005584f, 0.24446583f, 0.03941990f, 0.23364453f, -0.05946216f, -0.04791001f, 
    -0.03893233f, -0.00389258f, -0.01589293f, 0.05032524f, -0.12063749f, 0.08297901f, -0.03427020f, 0.20513073f, 
    -0.08872046f, 0.02096844f, -0.13744175f, 0.04825822f, 0.17149277f, -0.04983898f, 0.02655483f, -0.00365829f, 
    -0.11299925f, -0.18431337f, 0.14091210f, -0.05415755f, 0.06383053f, -0.02196064f, -0.06997240f, -0.13366032f, 
    -0.05649746f, 0.02336155f, -0.12096453f, -0.01405279f, 0.12273275f, -0.39582419f, 0.04469842f, -0.08805616f, 
    -0.03553097f, 0.11923384f, -0.08974198f, -0.05888028f, -0.03718990f, 0.00030575f, -0.03961521f, -0.00329286f, 
    -0.12922540f, -0.21160433f, -0.19116892f, -0.05806006f, 0.11699455f, 0.09291124f, 0.09181123f, 0.11542870f, 
    -0.04910935f, 0.02026867f, 0.05215719f, 0.04314816f, -0.09822912f, -0.20280655f, -0.29430804f, 0.12919722f, 
    0.11027344f, 0.13994795f, 0.07637614f, 0.06233297f, 0.05566249f, -0.00215225f, -0.04331149f, -0.05069701f, 
    -0.57471597f, -0.06441311f, -0.01209051f, 0.11951502f, 0.11244201f, -0.22969347f, -0.13572638f, 0.01738263f, 
    -0.03975688f, 0.02221371f, -0.06226833f, -0.13169913f, 0.18131013f, -0.14174061f, -0.33428466f, -0.05556661f, 
    -0.16485065f, -0.10886610f, -0.04706551f, 0.17296638f, -0.00488657f, -0.05276790f, 0.11069497f, -0.05300875f, 
    0.11743017f, 0.17613752f, 0.38146639f, -0.31561479f, -0.07396086f, -0.02895097f, 0.08884518f, 0.05637483f, 
    0.01422343f, 0.16827214f, 0.01049002f, 0.05243566f, -0.26855689f, 0.03718710f, 0.17503574f, -0.35658738f, 
    0.17903507f, -0.23111370f, -0.18676612f, 0.11136940f, -0.02097108f, 0.01453653f, 0.00726175f, 0.10870443f, 
    -0.46838582f, -1.04240978f, 0.03379207f, -0.06074439f, -0.15855353f, 0.07619718f, -0.00139065f, 0.12521733f, 
    0.02413392f, 0.01433718f, 0.02500715f, -0.03231452f, 0.15047322f, -0.23529571f, 0.09376274f, -0.11932600f, 
    0.16055162f, -0.09828184f, -0.01274555f, -0.00475409f, -0.02066812f, 0.02793018f, -0.13264653f, -0.10849793f, 
    -0.28710479f, -0.02377201f, 0.16985914f, 0.42751902f, 0.17510441f, -0.01776473f, -0.07746179f, -0.14096923f, 
    0.13974769f, -0.06731577f, 0.09096119f, 0.11508067f, 0.12057442f, 0.26055267f, 0.14088582f, -0.52356887f, 
    -0.14471498f, -0.03684980f, 0.00567212f, -0.07336203f, -0.12814733f, 0.05466456f, 0.02787559f, 0.00761691f, 
    0.19483994f, -0.27359286f, 0.39153665f, 0.03255486f, 0.02271758f, -0.00770625f, -0.07969208f, -0.11643156f, 
    -0.04503093f, 0.16813083f, -0.01274505f, -0.09856579f, -0.06472841f, 0.15510733f, 0.14289193f, -0.12039839f, 
    -0.01870540f, -0.16834649f, 0.01479515f, 0.01348367f, 0.00714701f, 0.03914882f, 0.15779123f, 0.00820774f, 
    -0.14486013f, 0.13543998f, 0.19297233f, 0.20364724f, -0.04417530f, 0.13590916f, -0.07476752f, -0.05787634f, 
    0.09710696f, 0.07815669f, -0.06077328f, -0.12760164f, -0.00307544f, -0.09250268f, 0.01378962f, -0.06976517f, 
    0.08198112f, 0.05327060f, 0.08774032f, 0.00614585f, -0.10612249f, 0.04053010f, -0.02759412f, -0.22540613f, 
    -0.04299933f, -0.33882305f, 0.27307659f, -0.08146070f, -0.07819355f, 0.07665113f, -0.08101008f, -0.08940773f, 
    0.02540449f, 0.07029353f, -0.15633892f, 0.01093652f, 0.19936536f, -0.26428834f, 0.37357241f, 0.08323674f, 
    0.04221118f, -0.03130328f, -0.07273918f, -0.32725963f, 0.01579746f, 0.03232396f, -0.08172211f, 0.00607427f, 
    0.17607921f, -0.31772095f, -0.12082275f, 0.07373150f, -0.20265476f, -0.01097743f, -0.03499169f, -0.00480801f, 
    0.16291729f, -0.04990121f, -0.26476350f, -0.00958288f, -0.10404788f, 0.17245452f, -0.13929829f, -0.07401665f, 
    -0.01566023f, -0.13777834f, -0.06872845f, -0.03848940f, 0.04638893f, -0.07008737f, 0.04769527f, 0.07570601f, 
    -0.22208518f, -0.10741272f, -0.11385056f, 0.25872722f, 0.11923620f, -0.02924390f, -0.00014031f, -0.05889742f, 
    0.08216298f, 0.01496663f, -0.02176770f, -0.07911906f, -0.02313552f, -0.16870800f, 0.18649338f, 0.29452792f, 
    -0.03113992f, -0.07821109f, -0.20795570f, -0.15230636f, 0.24032141f, -0.10641786f, 0.05427850f, 0.17176330f, 
    0.02557321f, -0.30650425f, 0.16322504f, 0.15541692f, -0.17259000f, 0.14360303f, -0.05220962f, -0.19512086f, 
    -0.00167887f, -0.09171159f, -0.00611807f, 0.08355817f, 0.00920570f, -0.10307316f, 0.00160637f, -0.01136034f, 
    0.04139655f, 0.02811928f, 0.10103569f, 0.00502309f, 0.00431843f, 0.12476593f, 0.17860624f, 0.11716686f, 
    -0.06848622f, -0.06099841f, 0.08874463f, 0.03118789f, -0.02422298f, -0.05437481f, 0.14208335f, 0.23951358f, 
    -0.04270699f, 0.11684265f, 0.02420122f, 0.00425361f, 0.11175609f, 0.19746540f, 0.11125425f, 0.21010460f, 
    -0.04710982f, -0.08799867f, -0.20662351f, -0.09867524f, -0.00762779f, -0.06683304f, 0.20611519f, 0.12789233f, 
    0.08739460f, -0.11204992f, 0.04804209f, 0.19353159f, 0.01106309f, 0.09493031f, -0.03174289f, -0.05980103f, 
    -0.06062186f, -0.02867488f, -0.07500251f, -0.03553014f, -0.24935597f, -0.18848714f, -0.13897604f, 0.21882382f, 
    0.16481318f, 0.06582475f, 0.15468954f, -0.02862635f, -0.00106152f, -0.00996031f, -0.16408432f, -0.07830644f, 
    -0.05597138f, -0.43965313f, 0.29097244f, -0.00713686f, 0.06107851f, 0.01636973f, -0.04906563f, -0.10269936f, 
    -0.14215948f, -0.07176644f, 0.02394318f, 0.06858426f, 0.09156378f, -0.06428570f, 0.14644486f, -0.08527549f, 
    0.12641998f, 0.10980798f, -0.18109560f, -0.03551733f, -0.00829145f, -0.02753610f, -0.00487196f, 0.05336617f, 
    0.39711195f, -0.99277312f, 0.23528604f, -0.38563904f, -0.10597719f, -0.00716673f, -0.27271774f, 0.03364195f, 
    -0.07465231f, -0.05215245f, 0.02457319f, 0.00451825f, 0.18911585f, -0.18749876f, 0.11041681f, -0.06323946f, 
    0.14169730f, 0.06185030f, -0.15641594f, -0.07426748f, -0.09091443f, -0.13019980f, -0.03109830f, -0.06680916f, 
    0.06318367f, 0.02599928f, 0.17157467f, -0.06047846f, 0.03992023f, -0.18989775f, -0.04972985f, 0.05000183f, 
    0.08728462f, 0.07366958f, 0.06912605f, 0.01619979f, -0.26271793f, 0.03640878f, -0.29801714f, 0.03391031f, 
    0.16856927f, 0.07037569f, 0.22693765f, 0.11725356f, -0.01300276f, -0.01567668f, -0.00712748f, 0.06461320f, 
    0.05985398f, 0.01705333f, 0.09142493f, 0.17523833f, 0.01476600f, 0.00067675f, -0.07851225f, -0.01473155f, 
    0.03593510f, 0.09624239f, 0.08590548f, 0.12440674f, 0.11198794f, 0.11363463f, 0.44800282f, -0.44069859f, 
    -0.06836593f, -0.10983663f, -0.08118260f, -0.05077111f, -0.15594783f, -0.00782202f, 0.03602891f, 0.06088418f, 
    -0.14584528f, -0.07520602f, -0.30286741f, -0.15403578f, 0.09849185f, -0.14220189f, 0.00854725f, -0.03825346f, 
    0.00172357f, 0.00165348f, 0.00626610f, -0.06646619f, 0.15630066f, 0.30722970f, -0.13584648f, 0.13287173f, 
    -0.26006898f, -0.13528520f, -0.15467930f, -0.08949136f, -0.13373241f, -0.09562837f, 0.01536741f, 0.00228192f, 
    0.14857940f, -0.03096536f, 0.06667684f, -0.66905534f, 0.02411201f, 0.03079499f, -0.01754087f, 0.17667416f, 
    -0.02089678f, -0.01082282f, -0.00196018f, -0.04282298f, -0.03815198f, 0.13821410f, -0.14972839f, -0.06309768f, 
    -0.02172443f, -0.10182588f, 0.04418405f, 0.14636138f, 0.00158510f, -0.04588135f, -0.00618729f, -0.03681421f, 
    0.16973372f, 0.15835173f, 0.42584598f, -0.13931395f, 0.04583361f, -0.19169292f, 0.12175629f, -0.00142589f, 
    -0.06946406f, 0.04873794f, -0.07549363f, -0.01160390f, -0.01130580f, 0.43698373f, -0.21981156f, -0.32038161f, 
    -0.09000862f, -0.11213122f, -0.01900579f, -0.04540794f, 0.08979686f, -0.01376822f, -0.08570667f, -0.04781799f, 
    0.19371475f, 0.10212843f, 0.01937606f, -0.23911549f, 0.01459927f, 0.06482299f, 0.12472059f, 0.01231697f, 
    0.20834756f, 0.06074250f, -0.10005063f, -0.03531059f, 0.20089233f, 0.20346062f, 0.13646750f, -0.13128005f, 
    0.12057114f, -0.23738714f, 0.05370339f, -0.04905458f, 0.08295646f, -0.04090918f, 0.00740875f, 0.08740450f, 
    -0.42556876f, 0.01589978f, -0.19712541f, -0.08576187f, -0.22016117f, 0.18476722f, -0.05628753f, -0.11811216f, 
    0.01939583f, -0.13694903f, -0.05935356f, -0.03221082f, 0.06658776f, -0.29310623f, -0.43049920f, -0.24533157f, 
    -0.09183631f, 0.12496474f, 0.09042571f, -0.01762344f, -0.02739916f, 0.08593538f, 0.05227263f, 0.02215743f, 
    0.04374881f, 0.10426060f, 0.37523484f, -0.04974882f, -0.18293153f, -0.02499692f, 0.05986002f, 0.07178232f, 
    -0.05820357f, -0.03509310f, -0.01855197f, -0.01010634f, -0.05641766f, 0.09900901f, 0.14215152f, -0.21605004f, 
    -0.02492005f, -0.03828303f, -0.12010625f, -0.14533783f, -0.02453590f, 0.08024557f, -0.09098069f, -0.21329974f, 
    -0.17739542f, 0.00716132f, 0.05640220f, 0.20643042f, 0.07209518f, 0.18011272f, 0.07103930f, 0.20100328f, 
    -0.09805553f, -0.00992943f, -0.02891819f, 0.15093999f, 0.40437138f, -0.21974388f, -0.04080068f, -0.09515259f, 
    -0.24406147f, -0.08510694f, 0.12177755f, 0.18238877f, -0.10332569f, 0.05556571f, -0.21476707f, -0.28739533f, 
    0.04643550f, 0.07552055f, -0.00080487f, -0.03805768f, 0.07563185f, -0.24344878f, -0.05708452f, 0.08374792f, 
    -0.03781021f, 0.01945953f, -0.21477376f, -0.20655170f, -0.35729271f, 0.44909635f, -0.23641032f, 0.12050953f, 
    -0.01882891f, 0.13928825f, -0.00280942f, 0.06638743f, -0.00081349f, 0.20240955f, 0.02644536f, -0.02698861f, 
    -0.22485466f, 0.22344002f, -0.08609580f, -0.09482429f, -0.08086320f, 0.05703063f, -0.11727795f, 0.06043925f, 
    0.10818601f, -0.08369023f, 0.09354346f, -0.08726569f, -0.09880824f, -0.08079270f, 0.01524363f, 0.29746929f, 
    -0.03934565f, -0.15401429f, -0.01237356f, 0.12081869f, -0.04104678f, -0.15373018f, -0.10841163f, -0.09266885f, 
    -0.16547474f, 0.10639671f, 0.09793650f, 0.00916589f, 0.08083413f, -0.13382779f, 0.12254508f, 0.01508922f, 
    -0.16141492f, 0.04787635f, 0.03585193f, 0.02769483f, 0.22052878f, -0.51937807f, 0.14078017f, 0.45496881f, 
    0.04609388f, 0.01080035f, 0.01092228f, -0.04052738f, 0.05616970f, 0.13379061f, -0.04557868f, -0.16043766f, 
    0.07832807f, -0.00298201f, -0.02701034f, -0.17399642f, 0.06659001f, -0.01775786f, -0.00994455f, 0.04057310f, 
    -0.18707511f, 0.12372416f, 0.08734643f, -0.02420986f, -0.03269820f, -0.27486917f, 0.09237804f, -0.42498964f, 
    -0.10211509f, -0.06053371f, -0.00400308f, -0.07718426f, 0.00405407f, 0.04973146f, 0.17364170f, -0.11849823f, 
    -0.01101484f, -0.25847265f, 0.13937077f, 0.13246150f, -0.08699600f, 0.10434997f, -0.01242970f, -0.06088859f, 
    -0.03880817f, 0.04920791f, 0.04109900f, -0.11806028f, 0.00949148f, -0.22705960f, 0.06663312f, 0.29203817f, 
    -0.14556317f, -0.30000591f, -0.00640440f, -0.00333150f, -0.16466273f, 0.06063738f, -0.09222487f, 0.04966234f, 
    -0.04009829f, 0.14800166f, -0.22111866f, 0.07160629f, -0.05707172f, -0.08952139f, 0.29427442f, -0.14344200f, 
    -0.17913136f, -0.01256262f, -0.28685844f, -0.06285290f, -0.17235357f, 0.10331783f, -0.31198421f, 0.16258557f, 
    -0.02295429f, 0.08633033f, 0.08779634f, -0.05349755f, 0.31428820f, 0.11949904f, -0.12263819f, 0.09995069f, 
    -0.24664108f, 0.07097150f, 0.01713193f, -0.14423171f, -0.04267685f, 0.02156849f, 0.03931870f, -0.15021971f, 
    -0.10078264f, 0.06280135f, 0.15914035f, 0.14688742f, -0.09606098f, -0.22399132f, 0.06594104f, -0.14651676f, 
    0.03588425f, -0.14542273f, 0.05764039f, 0.17181557f, -0.32754287f, -0.02056596f, -0.16620916f, 0.04018608f, 
    -0.07118706f, 0.21387279f, 0.11158431f, 0.11795191f, -0.11657429f, 0.08131336f, -0.32831630f, 0.24950723f, 
    0.15811874f, -0.12748800f, 0.13158618f, 0.20697260f, -0.19422312f, 0.09239488f, -0.01568156f, 0.07334874f, 
    0.00643161f, -0.08231729f, -0.01078094f, 0.07505713f, 0.07443769f, 0.05861152f, -0.00116127f, 0.02889572f, 
    -0.17349771f, -0.19870038f, -0.34031889f, -0.17892006f, -0.18014647f, -0.17152205f, -0.10606076f, -0.13084702f, 
    0.00599704f, 0.03504020f, -0.04454063f, 0.00015681f, 0.03546584f, -0.48357567f, -0.19311249f, 0.16527408f, 
    -0.21340847f, 0.03968254f, 0.10146356f, -0.16494171f, -0.13658120f, -0.02164911f, -0.14419635f, -0.14092892f, 
    -0.05387343f, -0.09224971f, 0.04489034f, 0.02901512f, -0.12350733f, 0.16785063f, -0.14401895f, 0.15057519f, 
    -0.03003645f, 0.21473829f, -0.10728005f, 0.07610543f, 0.00163597f, -0.00912026f, -0.07729811f, 0.10791203f, 
    0.01402326f, -0.17756841f, 0.10840998f, 0.05793523f, 0.07970078f, 0.22111595f, -0.11182662f, 0.02821385f, 
    -0.16354062f, -0.08596340f, -0.30016863f, -0.13595311f, 0.06232866f, 0.07888538f, 0.08761665f, -0.00313226f, 
    0.10376851f, 0.05108158f, -0.05837785f, -0.07871244f, -0.02128734f, -0.05568549f, 0.15567067f, 0.18164857f, 
    -0.09152344f, -0.10426086f, 0.00145091f, 0.12765332f, 0.00352811f, 0.05840481f, 0.18076444f, 0.05138653f, 
    -0.37300596f, -0.41933483f, 0.01444070f, 0.08564769f, -0.11144616f, 0.13358544f, -0.07710303f, 0.01316438f, 
    0.10428685f, -0.03379801f, 0.06556127f, 0.11087161f, -0.05122631f, 0.04151608f, -0.43306586f, 0.27367744f, 
    0.13580367f, 0.05913820f, 0.15692151f, 0.03876166f, -0.13962878f, 0.07199454f, -0.14339687f, 0.18942061f, 
    0.19112022f, -0.02479791f, 0.09703059f, -0.19560446f, -0.09944788f, 0.19229013f, 0.05099822f, 0.16346954f, 
    0.03050867f, 0.06663004f, -0.05479908f, -0.26636043f, -0.02087107f, 0.02604482f, 0.13660017f, 0.29626277f, 
    0.07776137f, -0.01780992f, 0.05787998f, -0.00107972f, -0.16149722f, -0.01887891f, -0.00188661f, 0.01328346f, 
    -0.32315040f, 0.34892973f, -0.26240644f, 0.11292478f, 0.00216314f, 0.03395711f, -0.02058460f, 0.10312419f, 
    -0.21382412f, -0.06028202f, 0.07721079f, -0.01817517f, -0.20784052f, 0.10871591f, 0.05558255f, -0.15291895f, 
    0.12733728f, -0.02335102f, 0.03060611f, 0.05811164f, -0.09123948f, -0.05210502f, -0.31156990f, -0.22122549f, 
    0.07601787f, -0.06446072f, 0.07536907f, -0.30338985f, -0.17295270f, -0.10573013f, 0.04005887f, 0.05538511f, 
    0.05537880f, -0.24637824f, 0.08592579f, 0.04605339f, -0.25437570f, 0.14119294f, 0.35029444f, 0.10702887f, 
    -0.03981349f, -0.07863648f, -0.18368353f, 0.02106075f, -0.00022791f, -0.17965518f, 0.23200954f, -0.02191419f, 
    0.02932756f, 0.04449163f, 0.21351402f, 0.12155467f, 0.06143785f, -0.18112570f, -0.09160584f, -0.06927061f, 
    -0.07731342f, -0.03865466f, -0.23382743f, 0.04950126f, -0.67730862f, 0.34647202f, -0.10961141f, -0.06205722f, 
    -0.09287423f, 0.09988493f, 0.02208942f, 0.08299087f, -0.10851762f, -0.03222531f, -0.03786914f, -0.17010830f, 
    -0.19294566f, 0.04204896f, 0.19107516f, 0.16355228f, 0.12765484f, -0.11869535f, 0.11921243f, -0.13053054f, 
    -0.01315164f, -0.08874333f, 0.09644152f, 0.10563467f, 0.30120930f, 0.21314460f, 0.32125971f, -0.22947992f, 
    -0.13046549f, 0.05865209f, 0.21537150f, 0.08113358f, 0.07523943f, 0.06766121f, 0.27591696f, 0.10468522f, 
    -0.48545098f, 0.15535136f, -0.07118691f, 0.07934377f, 0.00198477f, 0.02588550f, 0.18109107f, 0.06723284f, 
    -0.09628045f, 0.02758122f, -0.12234971f, -0.06710925f, -0.53400326f, 0.12660882f, 0.01186407f, -0.32410508f, 
    0.03362804f, 0.05687299f, -0.19640285f, 0.08556624f, -0.29955822f, 0.02475620f, -0.12253559f, -0.02667792f, 
    -0.24251431f, -0.03990454f, -0.36252084f, -0.02303435f, -0.06256834f, 0.00519750f, -0.04922412f, -0.09678875f, 
    -0.18713157f, 0.06090509f, -0.04451396f, 0.00929125f, -0.03680642f, 0.18604173f, -0.04765817f, -0.05423702f, 
    -0.01333897f, -0.05961967f, -0.14229284f, -0.10330169f, -0.10276847f, -0.11993971f, -0.29378057f, -0.20200428f, 
    -0.27430311f, -0.01092813f, -0.45653543f, 0.03585536f, 0.06280281f, -0.18046795f, -0.09011038f, 0.07049254f, 
    0.08797324f, 0.13038737f, -0.05413908f, -0.07035237f, 0.14353378f, 0.19151700f, 0.15358844f, -0.30683351f, 
    0.07850707f, 0.09076953f, -0.12553714f, 0.17583796f, -0.05990972f, -0.00562879f, -0.03820855f, -0.16216084f, 
    -0.41090387f, 0.17347951f, -0.15732262f, 0.10816875f, -0.03264743f, 0.04195726f, 0.00264197f, -0.04974101f, 
    0.00526835f, -0.05002726f, 0.07319085f, 0.03880536f, -0.15015016f, -0.08119821f, -0.16345634f, 0.06429739f, 
    -0.12995535f, -0.18318844f, 0.01231117f, 0.00233254f, -0.06320029f, 0.08398356f, -0.06001430f, 0.08004053f, 
    -0.35761371f, 0.39872226f, -0.39164531f, 0.04710011f, -0.04480411f, -0.00962284f, -0.03106135f, -0.08232548f, 
    0.09602429f, 0.02830509f, -0.13521124f, 0.04725091f, -0.02933763f, 0.07927584f, 0.10621521f, 0.05078447f, 
    -0.07397269f, 0.05807365f, 0.00913628f, 0.11542528f, -0.03061081f, 0.09517638f, 0.17435266f, 0.12949596f, 
    -0.36603448f, 0.37161854f, -0.36307457f, 0.07049484f, 0.01683400f, 0.12127334f, -0.24485192f, 0.17110024f, 
    0.08920975f, 0.01046605f, 0.09881976f, 0.05376452f, -0.30298871f, 0.01028037f, -0.19587405f, -0.04727282f, 
    -0.17611876f, -0.02159920f, -0.09395016f, 0.19127817f, 0.04238224f, 0.11904594f, 0.17594367f, 0.06860072f, 
    -0.13780078f, -0.10159994f, -0.07331849f, 0.02674564f, 0.11394058f, 0.10279620f, -0.22018191f, -0.04357133f, 
    0.05604625f, 0.04138791f, -0.07167093f, -0.22022469f, -0.15070723f, -0.21583886f, 0.16862383f, -0.05080802f, 
    -0.16614243f, -0.06640450f, -0.10060345f, -0.11051922f, -0.22873659f, -0.01620317f, -0.04924398f, -0.19991255f, 
    -0.05897973f, 0.15173851f, 0.00820481f, -0.16894300f, -0.02452030f, 0.01440164f, -0.08440778f, -0.03848705f, 
    -0.11109148f, -0.25563705f, -0.16795376f, -0.30401123f, -0.25402835f, 0.08536305f, -0.09735751f, 0.16819425f, 
    0.01488842f, -0.00094943f, 0.08608426f, 0.24196762f, -0.06178967f, -0.03126182f, -0.10343783f, -0.02054567f, 
    0.08468200f, -0.27964476f, 0.31815609f, 0.57443714f, 0.04130474f, 0.17437537f, -0.07261087f, 0.08384396f, 
    -0.12673917f, -0.10342938f, 0.00175931f, 0.08272227f, -0.10187452f, 0.36489004f, 0.06983041f, -0.03514699f, 
    0.08918063f, 0.14768404f, -0.05577941f, 0.06253994f, -0.07516328f, 0.04047708f, -0.05604547f, -0.03296497f, 
    0.05897706f, -0.15018190f, 0.16322555f, 0.07499054f, -0.01286125f, -0.04296388f, 0.00984827f, -0.05481856f, 
    -0.07072778f, 0.01663877f, -0.06573486f, -0.17666325f, -0.05432585f, -0.17220086f, 0.08454313f, 0.23006649f, 
    -0.12548415f, -0.08642802f, -0.13311426f, 0.11358362f, -0.03754809f, 0.05807162f, 0.00920623f, 0.15429762f, 
    -0.05348810f, 0.02939870f, -0.15018746f, 0.04281559f, -0.13040437f, 0.12256687f, 0.01091015f, 0.08249704f, 
    0.06640022f, 0.02653100f, 0.12976786f, 0.19281650f, 0.27091721f, -0.09840321f, 0.35019511f, 0.00546590f, 
    -0.03235771f, 0.27986860f, -0.01384630f, 0.01671816f, -0.02508851f, 0.14618644f, 0.01755037f, 0.06150884f, 
    0.02004326f, -0.12807247f, 0.48327029f, -0.02891386f, 0.09738202f, 0.15401189f, 0.13145560f, 0.00448848f, 
    -0.09601653f, -0.10946856f, -0.10085702f, -0.32806295f, -0.02967292f, 0.04117996f, 0.10978086f, 0.09132972f, 
    -0.06606660f, 0.00003143f, 0.08872131f, 0.01548576f, 0.17652960f, 0.08437931f, 0.12148955f, 0.01383650f, 
    -0.01616125f, 0.03356844f, -0.02920914f, -0.03191197f, -0.01325418f, -0.00877119f, 0.12565629f, 0.05406861f, 
    -0.05975634f, 0.11192597f, 0.08768141f, 0.05764936f, -0.18664430f, -0.17841694f, -0.14036323f, -0.44008353f, 
    -0.23208418f, -0.14075252f, 0.04083623f, -0.24559551f, 0.06215176f, 0.03051049f, 0.12345938f, -0.06929965f, 
    0.13974226f, 0.01097313f, 0.29893383f, -0.40208063f, 0.18199156f, -0.02716420f, 0.03179104f, 0.09242626f, 
    0.01363880f, 0.14558685f, 0.23424728f, -0.27744186f, 0.18920457f, 0.00593987f, 0.27430353f, 0.05500808f, 
    -0.00613649f, -0.09322199f, 0.03118133f, -0.06245685f, -0.05105448f, 0.02183609f, 0.03340805f, -0.13660580f, 
    -0.10416239f, -0.01017922f, 0.03052210f, -0.05773829f, -0.14662279f, 0.05120047f, -0.08942369f, 0.12355099f, 
    -0.03159717f, -0.02997114f, 0.04844223f, -0.03831969f, 0.13650523f, -0.21586347f, 0.14951852f, -0.34041101f, 
    -0.00822877f, 0.09605931f, 0.12512946f, 0.13313019f, 0.06147456f, 0.16895643f, 0.07113265f, 0.05660182f, 
    0.06438251f, -0.01722645f, 0.04989189f, -0.24397556f, 0.05274179f, -0.12816791f, 0.09114958f, -0.16423658f, 
    0.02922781f, 0.02403778f, 0.03896492f, 0.03163406f, -0.32514542f, -0.36701271f, -0.13018538f, 0.10598619f, 
    0.03165524f, -0.00052898f, -0.12980142f, -0.32941142f, -0.01828299f, -0.04721382f, -0.03282478f, -0.07040161f, 
    -0.21661118f, -0.12026912f, -0.09472073f, -0.03324126f, 0.10380347f, -0.01691056f, 0.04748182f, 0.16553196f, 
    -0.00341703f, 0.08108998f, -0.14951862f, -0.06032232f, -0.60452896f, -0.04691461f, 0.04194101f, 0.13136518f, 
    -0.11242286f, 0.19446628f, 0.07515137f, 0.26438320f, -0.22302492f, 0.08896144f, 0.16596213f, 0.03796115f, 
    0.34072196f, -0.11310103f, 0.21110186f, 0.05098901f, -0.02028168f, 0.00998387f, -0.05754996f, -0.10350762f, 
    -0.06821532f, -0.06492170f, -0.09832945f, -0.11368083f, -0.14056918f, 0.08359034f, 0.14759658f, -0.10397881f, 
    0.00638181f, -0.00990114f, 0.08958600f, 0.02225436f, -0.04254376f, -0.04830595f, -0.04040267f, -0.11175077f, 
    -0.19192837f, 0.17571349f, -0.39977717f, 0.13631102f, 0.01587455f, -0.10002698f, 0.05621785f, -0.15455538f, 
    -0.02843447f, 0.05324730f, -0.06834590f, -0.03743490f, 0.25784600f, -0.09875116f, 0.27085871f, 0.00240003f, 
    0.11018129f, -0.04909451f, 0.10261047f, 0.09841607f, -0.03362070f, 0.03885714f, 0.08708131f, 0.00396877f, 
    0.33431241f, 0.26194063f, 0.19581462f, 0.03087030f, -0.22970189f, -0.00049623f, 0.04499103f, 0.08035737f, 
    -0.12690631f, 0.00821356f, 0.08059688f, 0.12962346f, 0.19050086f, -0.05686291f, 0.18884358f, -0.12173802f, 
    -0.08326557f, 0.11213372f, -0.06318878f, 0.05974675f, -0.05944622f, 0.04535996f, 0.01962860f, -0.06559847f, 
    0.24675487f, -0.60413265f, 0.57387376f, 0.48153836f, 0.16539349f, 0.02243100f, 0.01207607f, 0.14296772f, 
    0.02194326f, 0.11674834f, 0.05519270f, 0.25230333f, -0.15642853f, -0.06424798f, -0.23253213f, 0.45104885f, 
    0.28279209f, -0.19573410f, -0.17239340f, 0.07962056f, -0.04396207f, 0.12184630f, 0.25624800f, -0.09546460f, 
    -0.40837964f, 0.25569087f, -0.28080329f, 0.07406934f, 0.21539365f, -0.04995571f, -0.01458519f, -0.01432370f, 
    0.00408121f, -0.08736023f, 0.02241780f, -0.11286179f, 0.05469127f, 0.12761806f, 0.08594190f, 0.14729795f, 
    0.00148641f, 0.19864634f, 0.12910925f, -0.04901766f, 0.03984062f, -0.09244341f, -0.09546408f, -0.12013356f, 
    -0.08554672f, 0.05417228f, 0.00844030f, -0.06973895f, 0.05659473f, 0.04460923f, -0.06624480f, 0.01462111f, 
    -0.12073090f, -0.06385056f, 0.01989092f, 0.07049265f, -0.20827760f, 0.32864597f, -0.14673959f, 0.07128330f, 
    -0.04597155f, -0.11590852f, 0.07672902f, -0.03715663f, -0.09849174f, -0.04902885f, -0.12020929f, -0.11846707f, 
    0.11254004f, -0.08650273f, 0.05299859f, 0.00959030f, -0.05159829f, 0.00743172f, -0.08753753f, 0.01409422f, 
    -0.06602968f, -0.00365726f, -0.03432573f, -0.12006291f, 0.29537374f, 0.31577307f, 0.10008630f, -0.06462856f, 
    -0.13197806f, -0.00136418f, 0.00280090f, 0.05976929f, 0.03100429f, 0.05444982f, 0.09790648f, -0.13327600f, 
    0.21149990f, -0.37375304f, 0.46693596f, -0.14215949f, -0.04738370f, 0.14780159f, -0.20390156f, 0.17266020f, 
    0.03657678f, -0.04032296f, 0.03031941f, 0.10753105f, 0.13656193f, 0.18425478f, 0.09491573f, -0.28709841f, 
    -0.13730927f, 0.00150932f, -0.03806939f, 0.05047482f, -0.14935178f, -0.13426360f, -0.11584963f, 0.00368273f, 
    -0.19895338f, -0.35551599f, -0.25469401f, -0.14236203f, 0.00179875f, -0.12663773f, -0.11976722f, -0.01455670f, 
    0.00123564f, 0.16352978f, 0.04999480f, 0.04910156f, -0.24956718f, -0.03482445f, -0.12387779f, 0.01170325f, 
    -0.02418349f, 0.07430444f, -0.20118165f, -0.01382974f, -0.00800911f, 0.06013469f, 0.01405911f, -0.10295044f, 
    -0.42566389f, -0.32325128f, -0.02287426f, 0.19523953f, -0.09238320f, -0.39487222f, 0.05272342f, -0.23650345f, 
    -0.01907254f, 0.02689544f, -0.00732504f, 0.00368413f, 0.21055397f, -0.02608269f, -0.06267248f, 0.33713019f, 
    -0.10707111f, -0.00054095f, -0.04233083f, 0.01379380f, -0.09597348f, -0.07192036f, 0.00655403f, -0.07935587f, 
    0.15604687f, -0.17737004f, 0.11372015f, -0.35721987f, -0.04530098f, 0.02542368f, 0.17645331f, -0.06364535f, 
    -0.03629244f, 0.15392751f, 0.14441417f, 0.20111737f, -0.11319654f, -0.13929752f, 0.33931735f, 0.21016099f, 
    -0.09631269f, 0.06635005f, 0.03095770f, -0.18877244f, 0.02499848f, 0.01167992f, -0.20154133f, -0.00358379f, 
    -0.16820286f, 0.00028134f, -0.18544358f, 0.44136050f, 0.09559620f, 0.03324290f, 0.13124171f, 0.26993343f, 
    0.00976158f, 0.09500625f, -0.00804400f, 0.07276341f, -0.11610624f, -0.37627280f, 0.14424583f, -0.27168828f, 
    0.06566419f, -0.11010074f, -0.19193819f, -0.16541065f, 0.01785323f, -0.01090374f, 0.10536353f, 0.04076013f, 
    -0.21397924f, -0.06882465f, -0.14567108f, -0.01411812f, 0.08442809f, 0.04494853f, -0.12858632f, 0.03040963f, 
    -0.09332594f, 0.03678412f, 0.09898534f, -0.11338880f, -0.02922313f, -0.17199391f, -0.08263983f, 0.36604854f, 
    -0.08320156f, -0.00054637f, -0.11820497f, 0.12846781f, -0.10889899f, 0.04167967f, -0.04507116f, 0.14485000f, 
    -0.41487184f, 0.26090574f, -0.25966543f, 0.04703904f, 0.04014402f, 0.11316698f, -0.07268133f, -0.15683950f, 
    0.00384034f, -0.09102681f, 0.11782618f, 0.00698161f, -0.12660019f, 0.09286904f, -0.03796232f, -0.00378468f, 
    0.03602214f, 0.11913881f, 0.20194909f, -0.10526385f, 0.15360069f, 0.08528816f, -0.03437468f, 0.05307477f, 
    0.08921374f, 0.05095914f, -0.21888663f, 0.00244330f, -0.02491503f, -0.11117928f, 0.19122352f, -0.02465583f, 
    -0.12214984f, -0.06482458f, 0.15287904f, -0.23178294f, 0.08380727f, -0.50532019f, 0.13723060f, -0.07366700f, 
    -0.01700511f, -0.11912172f, 0.10303479f, 0.09719457f, 0.02605600f, 0.23919158f, -0.19702452f, -0.11823565f, 
    0.10474007f, -0.21628654f, 0.20263515f, 0.07817403f, 0.05141068f, -0.02292704f, 0.04620987f, 0.02645341f, 
    -0.07358026f, 0.04197050f, 0.07018445f, -0.00904920f, -0.37370872f, -0.03161423f, -0.39370483f, 0.12656227f, 
    0.06744526f, -0.02276812f, 0.16521740f, -0.04858761f, -0.03953586f, 0.07538975f, 0.00828892f, -0.07837279f, 
    -0.27956903f, 0.17650163f, -0.22826865f, 0.35421231f, 0.11381155f, -0.10808767f, 0.11231698f, -0.11626395f, 
    0.02160089f, 0.19698147f, -0.10037162f, -0.01381025f, 0.03230552f, -0.01733992f, 0.04706919f, 0.08973925f, 
    -0.06519393f, 0.04250334f, -0.08551385f, 0.03452465f, 0.04426485f, 0.08036567f, 0.11870673f, 0.16078083f, 
    -0.04884005f, -0.38646784f, -0.13004890f, -0.04921330f, -0.15364608f, -0.15050556f, -0.28208759f, -0.08635385f, 
    -0.00168781f, -0.00810543f, 0.02329008f, 0.01692217f, -0.22606567f, -0.29246223f, -0.15958203f, -0.13155797f, 
    0.02822997f, -0.05451265f, 0.03680090f, -0.14122245f, -0.01010517f, 0.04630250f, -0.00963524f, -0.04485978f, 
    -0.46539721f, -0.06870715f, -0.12119786f, 0.29357678f, 0.21178479f, -0.01250411f, 0.08036311f, -0.05333345f, 
    -0.14892161f, 0.03887768f, 0.02030049f, -0.02175102f, 0.29121852f, 0.13805777f, 0.39427274f, -0.03887433f, 
    -0.08310197f, 0.06236869f, -0.16773573f, -0.00039783f, -0.14948031f, 0.08192436f, 0.04284618f, 0.02215574f, 
    -0.11048403f, 0.04466429f, -0.11232784f, 0.05311219f, 0.11699428f, 0.01198005f, 0.19551614f, -0.06648420f, 
    -0.02706574f, -0.05202107f, -0.11797123f, 0.12017860f, -0.32700604f, 0.17188261f, -0.33735788f, 0.04585106f, 
    0.08052344f, -0.01040531f, 0.19483230f, -0.01568023f, -0.09591246f, -0.13671160f, -0.07869128f, -0.28023180f, 
    -0.45291135f, 0.46586269f, -0.18220381f, -0.07351379f, -0.11932964f, -0.17297570f, 0.18123920f, -0.01814876f, 
    0.06180471f, -0.02439922f, 0.05198023f, 0.08681723f, 0.09406020f, 0.24362257f, -0.05329108f, -0.12130820f, 
    0.00786349f, 0.14966308f, 0.04693796f, -0.08867245f, -0.01462913f, -0.09035462f, -0.08274774f, -0.03281483f, 
    0.01841955f, -0.01261786f, -0.07352865f, -0.26294920f, -0.05790382f, -0.16846545f, 0.05179816f, 0.05275161f, 
    -0.01112086f, 0.13311443f, 0.05185163f, -0.00371894f, 0.25040662f, 0.07705016f, 0.13656786f, -0.25481775f, 
    -0.03186830f, -0.08285267f, -0.00685872f, 0.04400803f, -0.07368057f, -0.00137091f, -0.03787394f, -0.01810488f, 
    -0.29201412f, 0.10254981f, -0.13134737f, 0.19473992f, 0.11821596f, 0.04285002f, 0.07628241f, 0.03713026f, 
    0.02964565f, 0.06528609f, 0.05832857f, 0.22191496f, -0.33136421f, -0.05958928f, -0.00296757f, 0.17455283f, 
    -0.04849141f, -0.00088362f, -0.02914670f, 0.12624545f, -0.02153126f, 0.06693893f, -0.11022776f, -0.04455217f, 
    0.04851351f, 0.04681114f, 0.35731599f, -0.30865794f, -0.19916245f, 0.07330450f, 0.04682084f, 0.17207123f, 
    -0.08775984f, 0.07038444f, 0.04055412f, -0.04190895f, -0.39454955f, -0.10227235f, -0.11878203f, 0.07843895f, 
    0.07411136f, -0.25700176f, 0.03301615f, -0.07067452f, -0.10837246f, -0.02009372f, -0.03353490f, 0.02911698f, 
    -0.15420492f, -0.01727830f, -0.19504587f, -0.34253538f, 0.11031451f, 0.07491110f, 0.08172772f, 0.04765965f, 
    -0.01103284f, 0.02336730f, 0.04082599f, -0.03128275f, 0.02804706f, 0.01349309f, 0.21277702f, -0.07628704f, 
    -0.17454553f, 0.00012704f, -0.18248540f, -0.14595564f, -0.04893362f, -0.03772888f, -0.06537671f, -0.11190904f, 
    -0.02788718f, -0.10162914f, 0.02404456f, 0.00780985f, -0.08474091f, -0.00918966f, 0.10150787f, 0.40878335f, 
    -0.09486156f, -0.08737026f, -0.16886757f, -0.20372672f, 0.00833976f, -0.07405883f, 0.16092117f, -0.15216883f, 
    -0.09432425f, 0.06395884f, 0.08757114f, -0.03183148f, 0.06796741f, 0.16622584f, -0.15672530f, -0.03052239f, 
    -0.04108815f, -0.10441961f, 0.13743962f, 0.12658492f, -0.05861934f, 0.15881398f, -0.12374643f, 0.03322193f, 
    0.00123451f, 0.09256992f, 0.21974289f, 0.20878191f, 0.16781405f, 0.04027903f, 0.08856706f, -0.13086411f, 
    0.06520228f, 0.06872476f, -0.13180847f, 0.05054898f, -0.14116371f, 0.07910594f, -0.00288615f, -0.14519617f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19129953f, 0.09096032f, 0.09447973f, -0.08587436f, -0.05204389f, 0.07410981f, 0.01677043f, -0.14210950f, 
    0.07996147f, 0.02040305f, 0.04350726f, -0.00630697f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
