#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.37792802f, 0.94644135f, 0.54266411f, 1.08842707f, -0.05754751f, -0.16458449f, 0.44977105f, -0.14936304f, 
    -0.15340520f, 0.51788437f, -0.36180320f, -0.11769883f, -0.13428029f, 0.28473628f, 0.35192549f, -0.19034898f, 
    0.24373202f, 0.42416051f, 0.28956154f, 0.09873194f, 0.03098082f, -0.10741013f, -0.28948736f, 0.05114831f, 
    -0.01106186f, -0.44392601f, -0.04954904f, 0.08392789f, -0.67238820f, -0.83239299f, 0.86521006f, -0.63376814f, 
    0.31170493f, 0.48159656f, 0.21907027f, 0.32783476f, -0.52285451f, 0.21546489f, 0.27718028f, 0.13003732f, 
    -0.19456081f, -0.11534074f, -0.11748061f, -0.28613067f, 0.07537595f, -0.34526685f, 0.23725964f, 0.04882161f, 
    0.29353032f, -0.01980788f, -0.69454885f, 0.04592105f, -1.23997879f, 0.33108768f, -0.40100101f, 0.45874012f, 
    -0.55804920f, -0.25750750f, 0.38166744f, -0.62053591f, 0.41187379f, 0.26189119f, -0.22051775f, 0.33893642f, 
    0.26859367f, 0.18247494f, 0.12854758f, -0.15084544f, -0.21654974f, 0.07312376f, -0.28339252f, -0.07864336f, 
    0.11420128f, -0.40060702f, -0.02943091f, -0.03567126f, 0.60443127f, 0.41482511f, -0.39418814f, -0.27598643f, 
    0.49162775f, -0.51668054f, 0.08086500f, 0.26617038f, 0.20038339f, 0.49385878f, 0.12953258f, 0.38532394f, 
    0.55224055f, -0.29385749f, -0.00504950f, 0.31397805f, -0.10630171f, -0.15395772f, 0.60381782f, -0.18772116f, 
    0.09893961f, 0.10409476f, 0.30130213f, -0.06703119f, 0.42950770f, -1.15536070f, 0.66096646f, -0.37969092f, 
    0.47704664f, 0.67366099f, -0.98718965f, 0.37342575f, -0.00286893f, 0.04464236f, 0.28047469f, 0.00923588f, 
    -0.13725251f, 0.03171970f, 0.12690119f, 0.36949942f, 0.05201074f, -0.12288383f, 0.04692787f, -0.03408197f, 
    -0.08701269f, 0.00689010f, 0.28871635f, -0.03700252f, 0.17672400f, 0.16789548f, 0.27385747f, 0.04818332f, 
    -0.33985451f, -0.01095555f, 1.00273049f, 0.43697506f, 0.03419638f, 0.63307559f, -0.34275988f, -0.60261309f, 
    -0.33430141f, -0.53332818f, -0.51563030f, -0.61223912f, 0.05691824f, -0.17815393f, -0.10891204f, -0.22316857f, 
    -0.02325799f, -0.17130852f, -0.11659312f, -0.20599677f, 0.12012918f, -0.14662240f, -0.64658046f, 0.39532769f, 
    0.46111825f, 0.06027232f, 0.19965680f, -0.87247616f, 0.14767018f, -0.59302914f, -0.71707994f, -0.34438103f, 
    0.41607451f, 0.54666841f, -0.25583819f, -0.16501051f, -0.42126453f, 0.31924117f, -0.16603102f, 0.16715983f, 
    -0.54170126f, 0.22833845f, -0.26626825f, -0.11731708f, 0.23111570f, 0.37951341f, -0.13279340f, -0.23713307f, 
    -0.55011332f, -0.74588913f, -0.53457141f, -0.49346980f, 0.39598590f, -0.11272040f, 0.35564473f, 0.50456607f, 
    -0.40543726f, -0.45632094f, -0.40253863f, -0.38019791f, -0.31027883f, 0.13047954f, -0.00150999f, 0.14831564f, 
    -0.24250408f, 0.06275202f, 0.03512786f, 0.16137885f, 0.18239148f, 0.29497668f, -0.22391848f, 0.09811045f, 
    -0.67231947f, 1.05917668f, 0.51181966f, -0.32250759f, 0.27689999f, -0.28925940f, 1.01070952f, 0.29751590f, 
    0.15232922f, 0.31180811f, -0.21402879f, 0.04699731f, 0.09102979f, -0.11523075f, 0.29093361f, 0.21556337f, 
    -0.15271617f, 0.04998725f, 0.19998644f, 0.08900873f, 0.29292342f, 0.31360295f, 0.26925883f, 0.32310361f, 
    0.09819816f, -0.66674238f, 1.02435100f, 0.69404483f, 0.14519449f, 0.65486503f, 0.02068257f, 0.23010248f, 
    0.33742982f, 0.04638123f, -0.07787118f, -0.24861608f, 0.05998798f, 0.32428992f, 0.03421872f, 0.10617489f, 
    -0.18607394f, 0.12467722f, 0.01966039f, 0.15610623f, 0.46801308f, 0.23713347f, -0.11752396f, -0.34304142f, 
    -0.26788270f, -0.25860587f, -0.10862999f, -0.07235941f, 0.12176833f, 1.00197411f, -0.71277654f, -0.52133858f, 
    -0.11905415f, 0.04747399f, 0.30011520f, -0.63565189f, -0.13200931f, -0.36525077f, -0.34868491f, -0.18961698f, 
    -0.12613724f, -0.04358538f, 0.31536189f, 0.11516945f, -0.08086538f, -0.01852921f, -0.04063760f, -0.28970310f, 
    -0.19971952f, -0.29260418f, -0.41860947f, -0.92203373f, -0.26310742f, -0.16830978f, -0.73156148f, -0.77892667f, 
    -0.30015782f, -0.30255899f, 0.25882357f, 0.10287094f, 0.15968326f, 0.21640472f, 0.33110833f, 0.09519508f, 
    0.33134255f, -0.35461685f, 0.08394583f, 0.06338629f, 0.22004049f, -0.03899069f, 0.41843328f, 0.59886581f, 
    -0.29245836f, -0.33602449f, -0.28028724f, 0.33341226f, 0.77543187f, 0.56492352f, 0.74297392f, 0.80587071f, 
    1.11219525f, 0.58763105f, 0.04795516f, 0.09636296f, -0.19363821f, 0.20618044f, 0.00547906f, 0.43023682f, 
    0.04765253f, 0.35923415f, -0.24049455f, 0.16346949f, -0.27432081f, 0.03839744f, -0.00296917f, -0.34228498f, 
    0.01433018f, -0.19833039f, -0.10642448f, -0.05075407f, 0.24932025f, -0.64388984f, 0.79446727f, 0.00766782f, 
    -0.86567169f, 0.51429641f, 0.46251160f, -0.09869344f, 0.38331720f, -0.87357914f, 0.20633003f, 0.12362614f, 
    0.36038634f, 0.04509678f, -0.00099875f, 0.26486483f, -0.07015602f, -0.17366737f, -0.30579931f, -0.03373947f, 
    -0.12929147f, 0.09833682f, 0.23223208f, 0.30763999f, 0.04253549f, -0.17224866f, 0.05096790f, 0.25455061f, 
    0.11624795f, -0.10918051f, 0.51376700f, 0.42473131f, -0.81985819f, -0.34293297f, -0.38964936f, -0.76601660f, 
    0.46063131f, 0.06143420f, -0.17525531f, -0.07248656f, 0.35121056f, 0.37725464f, 0.08517076f, -0.04294486f, 
    0.11866124f, 0.22428814f, 0.26201966f, -0.11945441f, 0.30720463f, -0.09401851f, 0.24803132f, -0.11008265f, 
    -0.72776544f, -0.36558667f, -0.02777119f, 0.69597018f, -0.17091282f, -0.72057670f, -0.40080157f, -0.72083038f, 
    0.13276175f, 0.19517793f, 0.44503400f, 0.29049018f, 0.24272873f, 0.32850575f, -0.10692552f, -0.13544837f, 
    0.16115844f, 0.23145825f, 0.28896716f, 0.06463384f, -0.13301075f, -0.06942755f, -0.00133874f, -0.09209594f, 
    1.09604955f, 0.58526367f, 0.89330113f, -0.08610660f, 0.48429224f, -0.18472244f, -0.63858938f, 0.23784834f, 
    0.05923875f, 0.32122210f, -0.43671620f, -0.36208791f, -0.06619466f, 0.19473815f, -0.00279489f, -0.07542583f, 
    0.32501730f, 0.29624093f, -0.17022896f, -0.28756925f, 0.29973659f, 0.30228803f, 0.34492573f, 0.17791015f, 
    -0.01109211f, -0.98645240f, -0.76529384f, -0.97359681f, -0.21782833f, -0.08303925f, 0.51383519f, 0.79412472f, 
    0.41424915f, 0.34175244f, 0.60037082f, 0.48131153f, -0.18942633f, 0.26582488f, -0.23654339f, 0.21771125f, 
    -0.04923712f, -0.11529537f, 0.20599750f, 0.03425440f, -0.19017164f, -0.20208110f, -0.10396704f, -0.02685620f, 
    -0.12839195f, -0.05321300f, 1.08082664f, 0.16907850f, -0.26807165f, -0.93210924f, -0.17601128f, 0.35761306f, 
    -0.30056566f, 0.50570691f, -0.11607230f, 0.00412898f, -0.24712135f, 0.34564033f, -0.37066954f, -0.18690868f, 
    -0.09259827f, 0.19835076f, -0.37634638f, -0.52011877f, -0.00348280f, 0.04752892f, -0.13039289f, -0.12968341f, 
    -0.11039408f, -0.27110413f, -0.29740086f, 1.14449966f, 0.84447080f, -0.46798071f, -0.57712823f, -0.66552335f, 
    -0.45861191f, 0.18463415f, -0.18810000f, 0.00828073f, 0.34657264f, 0.19961429f, 0.27519831f, 0.35147324f, 
    -0.16607647f, -0.03461534f, -0.10225021f, -0.10154139f, 0.09927908f, -0.07615218f, -0.06071117f, 0.43242097f, 
    -0.08613346f, 0.10041810f, 0.16317119f, -0.02668177f, 0.77724683f, 0.81771404f, 0.25913501f, 0.47964740f, 
    0.42243198f, -0.71494949f, -0.83169633f, -0.59697044f, -0.45513996f, -0.46757114f, -0.30302319f, 0.00747038f, 
    0.25547838f, -0.24212782f, -0.11414412f, -0.32050043f, 0.00612535f, -0.08221249f, -0.39823580f, 0.08216851f, 
    0.22448744f, 0.19040579f, 0.07665813f, -0.36204427f, 0.08122027f, -0.09768397f, -0.23036046f, -0.28410676f, 
    -1.08542824f, -0.22883506f, -0.59465784f, 0.12704264f, 0.20232122f, 0.39984617f, -0.80856895f, -0.47567081f, 
    0.01901026f, -0.11292943f, 0.26567787f, -0.26024282f, 0.18344456f, -0.07338389f, 0.12501392f, -0.14628395f, 
    0.08394139f, -0.23881085f, -0.22540931f, 0.11171269f, 0.18912745f, -0.08775878f, -0.51346529f, -0.94336766f, 
    -0.27081904f, 0.79397255f, 0.00310005f, -0.75305659f, 0.42715776f, 0.78639913f, -0.58613026f, -0.55225796f, 
    0.18319647f, -0.19057433f, -0.01962735f, 0.49853191f, 0.23610786f, 0.32439396f, -0.08052421f, -0.20719230f, 
    -0.41232395f, -0.14248870f, 0.06373732f, -0.34809288f, 0.15559742f, 0.07629942f, 0.36612681f, -0.28357503f, 
    -0.57608145f, -0.07531549f, 0.05479081f, 0.46586844f, 0.64343679f, 0.80276018f, 0.33439624f, 0.42380324f, 
    0.61406094f, -0.05154273f, 0.23118131f, 0.06396723f, -0.06892689f, -0.17483579f, -0.25256827f, 0.18364687f, 
    -0.16132182f, -0.02818921f, -0.08988237f, -0.06855330f, -0.20586737f, -0.38353580f, 0.05245741f, 0.16672727f, 
    0.11699249f, -0.60829443f, 0.72470737f, 0.85168231f, 0.73044473f, -0.33496404f, 0.71515775f, 0.52922517f, 
    0.10518479f, 0.17488813f, -0.49680588f, -0.39960572f, -0.18310063f, -0.05605283f, -0.12727180f, -0.54264098f, 
    -0.28392279f, -0.15935594f, 0.34822685f, -0.06545248f, -0.05583366f, 0.05168188f, 0.04706502f, -0.03410881f, 
    0.10551284f, 0.08864265f, -0.41899914f, -0.51739252f, -0.25894317f, -0.15691671f, 0.41992280f, -0.11209819f, 
    -0.62111962f, -0.72242701f, 0.12265783f, -0.27929127f, -0.47555891f, 0.34780434f, -0.02835729f, -0.55696213f, 
    -0.63175339f, -0.44444469f, -0.42829442f, -0.11508141f, -0.19211122f, 0.07411566f, -0.06905949f, -0.01841912f, 
    -0.24040824f, -0.05223630f, -0.09937667f, 0.61153096f, -0.77080667f, -0.29638225f, 0.58992916f, 0.08811017f, 
    -0.75833422f, -0.61917132f, -0.03244832f, 0.29590794f, 0.30617911f, -0.38942644f, -0.35576323f, -0.25535581f, 
    -0.17430034f, 0.19586518f, 0.21302795f, -0.29590741f, -0.16167402f, 0.18220842f, -0.41750288f, 0.28696460f, 
    -0.01259084f, 0.14682764f, -0.43914717f, 0.47410607f, 0.73930055f, 0.11052523f, -0.43466121f, 0.49215457f, 
    -0.37761065f, -0.71270597f, -0.29968211f, -0.08221765f, 0.09493762f, 0.48940587f, 0.34155518f, 0.05556027f, 
    0.17924313f, -0.13606769f, 0.16606842f, -0.26838273f, -0.00481751f, 0.20368776f, 0.06953466f, 0.42570102f, 
    0.08187751f, -0.41232425f, 0.21472985f, 0.31638938f, -0.35687876f, 0.01974434f, 0.48803812f, 0.11843772f, 
    -0.25777486f, -1.07779157f, 0.47927496f, -0.18661822f, -0.52178973f, -0.44129819f, 0.16095485f, 0.66643661f, 
    0.07908234f, 0.26275116f, -0.09057340f, -0.02795198f, -0.33754772f, -0.13110249f, 0.33941248f, -0.04458574f, 
    0.00886349f, 0.18870468f, -0.08714911f, -0.03247048f, -0.20874687f, 0.32252321f, 0.40623125f, -0.56167513f, 
    -1.19994712f, -0.60848004f, 0.53989488f, 0.17126545f, -0.59494328f, 0.10007381f, 0.16732028f, 0.08481254f, 
    -0.03251070f, -0.36550060f, 0.06582624f, -0.23277006f, -0.04408374f, 0.05201717f, 0.30446926f, 0.44452387f, 
    0.40705991f, 0.11671136f, -0.03033486f, -0.18366995f, -0.17691457f, -0.04716727f, -1.20487249f, 0.93440241f, 
    0.06071080f, -0.25738758f, -0.61852485f, 0.59898168f, 0.83331001f, -0.56044507f, 0.12257878f, 0.34356973f, 
    -0.36213195f, -0.15878941f, 0.01993498f, -0.35285673f, 0.12084001f, 0.04039000f, 0.05554339f, -0.21545027f, 
    -0.17646021f, -0.15158622f, 0.15788186f, -0.06630143f, 0.08978572f, -0.00923796f, 0.16565768f, 0.31930491f, 
    -0.39444277f, -1.16660011f, -0.82870257f, -0.29833442f, -0.06878286f, 0.45227680f, 0.77431858f, 0.50309253f, 
    0.53446460f, -0.36489701f, -0.37322280f, 0.03768985f, 0.03667609f, -0.29056865f, -0.12540601f, -0.09970896f, 
    0.07084589f, 0.27844566f, -0.40086612f, -0.18783098f, 0.07768064f, 0.05333919f, -0.13887465f, 0.28888884f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24441256f, 0.14791393f, 0.19149776f, -0.00367373f, 0.21827053f, 0.12211073f, 0.29792342f, -0.12699756f, 
    0.05213935f, 0.08611819f, 0.09184428f, 0.23844653f, 0.25738344f, -0.02114160f, 0.10680141f, 0.24417441f, 
    0.20794581f, 0.10052676f, 0.09307508f, 0.10358893f, 0.11753087f, 0.04719358f, 0.19039443f, 0.16640091f, 
    0.08705463f, 0.02485347f, 0.13150534f, 0.19756132f, -0.04111797f, 0.23731886f, -0.02564186f, 0.05940890f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.14036968f, 0.13278545f, -0.02284434f, 0.22728223f, -0.03931437f, 0.16096604f, 0.00167259f, -0.08029363f, 
    0.01606229f, 0.07108271f, -0.11699920f, 0.10360601f, 0.23143446f, 0.07868841f, 0.09265668f, 0.00872193f, 
    0.16408890f, 0.01335495f, 0.01225715f, 0.00091885f, 0.00101542f, 0.07283498f, 0.02090137f, 0.04896941f, 
    0.07646894f, -0.17589149f, -0.19196886f, -0.07721496f, 0.01728261f, -0.06912399f, 0.14677055f, 0.11704095f, 
    0.04395987f, -0.06988726f, 0.02351710f, 0.07208615f, -0.04216599f, 0.23568317f, 0.14904520f, -0.02565718f, 
    -0.01150989f, 0.14224432f, 0.05203014f, -0.10411856f, -0.11998069f, 0.16100892f, 0.14967036f, 0.07945582f, 
    -0.34842339f, -0.21160914f, 0.17879270f, -0.08861929f, 0.08457302f, 0.00232075f, -0.14769238f, 0.04061618f, 
    -0.04644181f, -0.16770047f, -0.04908920f, -0.00447677f, 0.11951127f, 0.32976964f, 0.11968347f, 0.04316464f, 
    0.09854910f, -0.03616683f, 0.05583244f, -0.01891246f, -0.08879352f, 0.00201989f, -0.02607572f, 0.05280789f, 
    0.11711035f, -0.09306064f, -0.19560391f, -0.12584756f, -0.08710721f, -0.03460288f, -0.08707149f, -0.11893531f, 
    0.06259280f, 0.01619643f, 0.15242210f, -0.04123570f, -0.04395971f, 0.21351311f, 0.04248562f, 0.18508977f, 
    0.08981406f, 0.00055278f, 0.12771736f, -0.00400854f, 0.12198032f, -0.07592329f, 0.16902891f, 0.07944454f, 
    0.36002827f, 0.18610808f, -0.13758698f, -0.03492816f, -0.04239275f, 0.18096782f, 0.07810080f, -0.14097245f, 
    -0.01156194f, -0.02777258f, 0.05976499f, -0.00687904f, -0.13935475f, 0.18083625f, -0.18656343f, 0.02239883f, 
    0.02069428f, 0.00305520f, 0.07374626f, -0.13126050f, -0.12587768f, -0.02684107f, 0.03222771f, 0.04277931f, 
    -0.11804984f, -0.08959473f, -0.35038498f, 0.05464897f, -0.14610600f, 0.06855682f, -0.12901966f, -0.07721699f, 
    0.08491796f, -0.03030771f, -0.04109809f, -0.00804088f, 0.27813727f, 0.14872569f, 0.14650401f, 0.08011642f, 
    -0.09652873f, 0.02253556f, -0.00123219f, 0.25293359f, 0.04909806f, -0.01670475f, -0.02429260f, -0.09608159f, 
    0.27847448f, 0.17803787f, -0.09685519f, 0.13750784f, 0.03212859f, -0.10063820f, -0.14702027f, 0.04680646f, 
    0.03269465f, 0.16404545f, 0.02892326f, -0.10405122f, 0.17563614f, 0.02043920f, 0.15382822f, -0.17005059f, 
    0.03001573f, 0.07601781f, -0.00397254f, -0.03848392f, 0.00150627f, 0.07088076f, 0.01993590f, -0.10099566f, 
    -0.33796236f, 0.10812960f, 0.21582778f, -0.27687141f, 0.03167650f, -0.10146517f, -0.15235895f, 0.04473737f, 
    0.02909414f, -0.01763259f, 0.03290811f, -0.07945698f, -0.01864938f, -0.47999132f, 0.16379237f, 0.02300206f, 
    0.04167550f, -0.11741721f, 0.05904730f, 0.15865894f, 0.04901508f, 0.01201328f, -0.04791256f, 0.08646711f, 
    0.13183950f, 0.02842061f, 0.12676476f, -0.16016144f, -0.01943216f, -0.16718881f, 0.01410821f, 0.08807836f, 
    0.02350004f, 0.05885549f, -0.03123474f, -0.02463054f, 0.45301580f, 0.45035389f, 0.22234561f, 0.17177019f, 
    0.01275747f, -0.01255879f, 0.03430936f, 0.16468093f, 0.05035581f, -0.03758613f, 0.07510956f, -0.05411600f, 
    0.04854586f, -0.06779800f, 0.17730887f, -0.48258460f, 0.03388268f, -0.09133772f, 0.01040455f, 0.03038317f, 
    -0.04816895f, -0.22576812f, 0.05487986f, -0.06655917f, -0.01754395f, 0.12247825f, 0.23827599f, -0.55315512f, 
    -0.15330480f, 0.01037030f, 0.07834008f, -0.03978689f, -0.03188053f, 0.05147998f, 0.02704360f, -0.08851834f, 
    -0.04214535f, 0.04528923f, 0.20132683f, 0.10838115f, -0.07306504f, -0.05302491f, 0.02678467f, -0.07380399f, 
    0.01313092f, -0.07294250f, -0.04075158f, 0.00227505f, -0.44461262f, 0.27530351f, 0.09863795f, -0.35381183f, 
    -0.08231063f, 0.05141571f, 0.17746302f, 0.12786905f, -0.03949897f, -0.05560990f, 0.02788563f, -0.07293913f, 
    0.11029553f, 0.07913346f, -0.47801179f, 0.25256363f, -0.03931446f, 0.23718311f, -0.26541114f, 0.09358946f, 
    -0.01962264f, 0.08464702f, -0.03712815f, 0.06938887f, 0.21225193f, 0.24759439f, 0.19170065f, 0.12976468f, 
    0.06551480f, 0.08502788f, -0.00686376f, 0.15375105f, 0.02215840f, 0.06301177f, -0.12143966f, -0.13091430f, 
    -0.03381910f, 0.24085961f, -0.19827308f, 0.21692736f, 0.01027266f, 0.01997878f, 0.07576089f, 0.06562636f, 
    -0.02371457f, -0.06759755f, 0.05104817f, 0.02331662f, -0.45279437f, -0.16986518f, 0.12906636f, -0.11729974f, 
    -0.01877169f, -0.05022463f, 0.14409150f, 0.13125633f, -0.00190646f, 0.12346009f, -0.14044872f, -0.25042826f, 
    0.03219686f, -0.36271176f, 0.11169688f, -0.03174191f, -0.07575386f, 0.06347178f, 0.06464881f, -0.00887990f, 
    -0.02302809f, -0.02561363f, 0.04487521f, -0.00045650f, -0.14717497f, -0.06568799f, 0.11529100f, -0.26557720f, 
    -0.07896972f, -0.07048324f, 0.06712954f, 0.12302563f, 0.29610047f, 0.06262422f, 0.06791015f, 0.11949196f, 
    0.19120798f, -0.13141271f, -0.25676396f, -0.01316092f, -0.03186239f, -0.07803606f, -0.02207646f, 0.00167681f, 
    0.01584020f, 0.05453436f, -0.11873334f, -0.30525595f, -0.02474138f, -0.07702284f, 0.34515318f, -0.19369660f, 
    0.16454548f, -0.02890215f, 0.06642266f, -0.12822491f, -0.03695423f, 0.12497749f, 0.11448716f, -0.00407893f, 
    0.41084868f, 0.03561351f, 0.11379872f, -0.17246121f, 0.21768177f, -0.02328612f, 0.04978137f, -0.09248815f, 
    0.15320252f, 0.10738444f, 0.04663346f, -0.00318634f, 0.15527844f, 0.30986014f, 0.09218035f, 0.22017586f, 
    0.02703920f, -0.19521475f, 0.05914418f, 0.09031081f, -0.04371182f, -0.09538850f, -0.03269058f, -0.10624082f, 
    0.01140478f, 0.02775439f, 0.03424666f, 0.00600657f, -0.03543583f, -0.01741884f, -0.04327055f, -0.02163700f, 
    -0.05502018f, -0.00751567f, -0.05383431f, -0.04727586f, -0.01863405f, -0.00367748f, -0.04891051f, -0.01393493f, 
    -0.02510969f, 0.01786660f, 0.03255609f, 0.03847801f, -0.00643224f, -0.02098288f, -0.01299907f, -0.04551607f, 
    0.04239247f, -0.05135977f, 0.02892368f, 0.02214539f, 0.01124952f, 0.04101267f, -0.02408179f, -0.03197033f, 
    -0.01491032f, -0.03246593f, 0.02227904f, 0.03300343f, -0.01275499f, 0.04208151f, -0.03488519f, -0.00045535f, 
    0.02243599f, 0.03477888f, -0.05456302f, -0.01629938f, -0.04289385f, 0.02378171f, -0.04733174f, -0.01823160f, 
    -0.01177302f, 0.00872552f, -0.04488163f, 0.02307446f, -0.01723163f, -0.04980321f, 0.01826500f, -0.03492950f, 
    -0.04959896f, -0.02844291f, 0.01538811f, -0.01248714f, -0.03380622f, 0.02576254f, -0.02137428f, -0.05303692f, 
    0.02882117f, 0.02127293f, 0.03409909f, -0.00886414f, -0.04908616f, -0.03118739f, 0.02853551f, -0.05133528f, 
    0.04050431f, -0.05256599f, -0.03519753f, -0.00821679f, -0.02769378f, 0.04126339f, -0.01056726f, -0.00362010f, 
    -0.03894585f, 0.04294871f, 0.00740153f, -0.04456116f, -0.00835965f, -0.02669632f, -0.02595809f, 0.02396742f, 
    0.01990554f, -0.02718330f, 0.02299848f, -0.03330943f, 0.03027908f, 0.02919188f, 0.02047075f, 0.02027091f, 
    -0.03963060f, 0.02151588f, 0.03834824f, -0.03428548f, -0.05069385f, 0.01450869f, -0.00572216f, -0.02452259f, 
    -0.00608592f, -0.01178472f, 0.02804132f, 0.03437470f, -0.00961958f, -0.04579709f, -0.00719848f, 0.02420945f, 
    -0.00955927f, -0.05215813f, 0.02190490f, 0.05197779f, -0.02989086f, -0.04259642f, 0.00763536f, 0.02520977f, 
    0.04441024f, -0.02381253f, 0.01670505f, -0.03726414f, 0.02233951f, -0.05315226f, -0.00422835f, 0.04193014f, 
    -0.03462884f, 0.03900019f, 0.00147917f, 0.03455157f, 0.01860196f, -0.03590903f, 0.04260616f, -0.02148336f, 
    0.00797567f, -0.02254171f, -0.02174151f, 0.03393999f, -0.04448149f, -0.02581449f, -0.01104443f, 0.02998999f, 
    -0.01281061f, 0.01016458f, 0.03275079f, -0.02852011f, -0.00797234f, -0.01221582f, -0.04948407f, 0.01608150f, 
    0.05472302f, 0.03786882f, -0.01859433f, -0.00029031f, 0.03248727f, -0.02386112f, -0.02560800f, 0.02023950f, 
    -0.02336763f, -0.05429319f, -0.02332254f, -0.05243587f, 0.00931967f, -0.03121624f, 0.00224268f, 0.00621017f, 
    0.03255420f, -0.02039419f, 0.00672075f, 0.04477842f, 0.00776385f, -0.00051767f, 0.00333168f, -0.03890634f, 
    -0.04781008f, 0.04095408f, -0.02333845f, -0.00973515f, 0.03050548f, -0.04147039f, -0.05022960f, -0.00654563f, 
    0.03663032f, 0.02300386f, -0.01869947f, -0.02794437f, 0.01594613f, -0.01360808f, 0.04976688f, -0.01440112f, 
    -0.01305300f, -0.03170237f, 0.00038446f, -0.03564042f, -0.03020505f, -0.02817371f, 0.02394686f, -0.00792744f, 
    -0.04846630f, -0.00219373f, 0.03078077f, -0.04450152f, -0.01248345f, 0.01041485f, -0.03523162f, -0.05029902f, 
    0.01123500f, -0.05473020f, -0.02072268f, -0.00997105f, 0.02142408f, 0.00728481f, 0.02092093f, 0.03181329f, 
    0.04319301f, -0.03869041f, -0.03381661f, -0.01302808f, -0.02862854f, -0.04051786f, -0.01686604f, 0.01638928f, 
    0.00899028f, 0.03079249f, 0.04448452f, 0.02502568f, 0.00725607f, 0.02291071f, -0.00520476f, -0.04204680f, 
    -0.01819643f, 0.03982313f, 0.00547264f, -0.04992379f, -0.02729088f, 0.00180926f, -0.00869492f, 0.04076717f, 
    -0.01967048f, -0.00118605f, -0.03822893f, -0.01632483f, 0.03478587f, -0.00627030f, -0.03578160f, -0.01896236f, 
    -0.00860087f, 0.02230363f, 0.01378122f, -0.04156386f, -0.04377411f, -0.04656020f, -0.02231032f, -0.04175266f, 
    -0.02785398f, 0.02793442f, -0.01188572f, -0.01722853f, -0.03051108f, -0.01588969f, -0.03791943f, -0.02800375f, 
    -0.00252063f, 0.04344553f, 0.03705775f, 0.02940360f, -0.02026151f, -0.00352294f, 0.02716043f, -0.02446043f, 
    -0.04830089f, 0.04443314f, -0.05069578f, -0.05081241f, -0.03327786f, 0.04404231f, -0.03388599f, 0.01404609f, 
    0.01120260f, 0.00527652f, -0.04368728f, 0.00906204f, -0.05181883f, -0.00990748f, -0.00275022f, -0.00815343f, 
    0.05576628f, 0.01512002f, 0.03617214f, 0.03867470f, 0.03743761f, -0.01511225f, -0.00843812f, 0.02434389f, 
    -0.02508863f, 0.03229850f, 0.04918956f, 0.01438464f, 0.04176225f, -0.04450087f, -0.05531515f, 0.00636257f, 
    0.01051516f, 0.02945038f, -0.01178283f, 0.01478941f, 0.01124916f, 0.02035701f, 0.02420526f, -0.02311575f, 
    -0.04522899f, 0.03397777f, -0.01996415f, -0.01041850f, 0.01954995f, -0.04595734f, -0.03329651f, 0.03164498f, 
    -0.03386185f, -0.03856182f, -0.04819336f, -0.00458180f, -0.02209294f, -0.05127854f, 0.05245386f, -0.04404449f, 
    -0.01409864f, -0.03228116f, -0.01827169f, -0.01982009f, -0.00255639f, -0.05575240f, -0.00726585f, 0.03168810f, 
    -0.02730788f, -0.00509542f, -0.05641704f, -0.03367314f, -0.01177123f, 0.00213840f, 0.00895043f, -0.00405892f, 
    -0.03038958f, 0.00387441f, -0.00720121f, -0.02097792f, 0.02640801f, 0.01438759f, 0.01611350f, -0.01642629f, 
    -0.00342631f, 0.00097663f, 0.03222520f, 0.01672002f, -0.00292360f, 0.04119778f, 0.03705246f, 0.03841579f, 
    -0.03368058f, -0.00286524f, -0.01395893f, -0.02448170f, -0.04817715f, 0.00440113f, 0.02184338f, -0.01161989f, 
    -0.02723804f, -0.02461362f, -0.00623653f, 0.04442525f, -0.00231853f, 0.02549786f, -0.01777558f, 0.02267822f, 
    0.01693546f, -0.02232778f, 0.03429884f, 0.02003745f, -0.00834609f, 0.00001887f, 0.03652206f, -0.05420376f, 
    -0.00000298f, -0.02453780f, -0.00266383f, -0.03098021f, -0.04307159f, -0.01379752f, -0.01201102f, -0.01776472f, 
    0.01837527f, 0.01823577f, -0.03088143f, 0.03694230f, 0.03725744f, 0.00275258f, -0.03927909f, -0.01454921f, 
    0.00680578f, -0.04426502f, -0.03552368f, -0.01277067f, -0.01685483f, 0.03854893f, 0.01076836f, -0.01433486f, 
    0.03505750f, -0.03688698f, 0.01174781f, -0.01028929f, -0.04657203f, 0.00364980f, 0.00922625f, 0.03916945f, 
    0.02621207f, -0.03458368f, 0.04746494f, 0.04736314f, -0.00098498f, -0.00725957f, 0.00300733f, 0.03718605f, 
    0.00556812f, 0.00298783f, -0.04160729f, -0.03093327f, -0.03627925f, 0.01023244f, -0.02075997f, -0.03703940f, 
    -0.00967240f, -0.04014458f, -0.01385569f, -0.04843844f, 0.01853205f, 0.03130979f, -0.03767773f, -0.02949430f, 
    -0.05180589f, 0.02674662f, -0.00180801f, 0.01554055f, 0.01842098f, -0.00885830f, 0.00566955f, -0.00671483f, 
    0.04305436f, -0.04184684f, 0.02699559f, 0.01914888f, -0.02165957f, 0.01690408f, 0.04808695f, 0.04297740f, 
    -0.04097156f, 0.01001825f, -0.00608034f, -0.00704384f, -0.03474832f, -0.02577300f, 0.02694179f, 0.00499122f, 
    -0.01427863f, 0.03509923f, -0.04021134f, 0.02030142f, -0.01646290f, -0.02004928f, 0.02176937f, 0.03033785f, 
    -0.02549776f, -0.05302528f, 0.04873629f, 0.02761474f, 0.02935281f, -0.00938627f, 0.00310024f, -0.01679299f, 
    0.02872234f, 0.00337794f, 0.04363132f, -0.01337251f, 0.03484039f, 0.00868845f, -0.03451043f, 0.03720285f, 
    0.01613821f, -0.02875986f, 0.00317775f, 0.00691635f, 0.02608384f, 0.04111630f, -0.04630625f, 0.03992408f, 
    -0.01224312f, -0.02017171f, -0.03797057f, 0.00148860f, -0.04396865f, -0.05005421f, 0.04477178f, -0.00083273f, 
    0.01961841f, 0.03448659f, -0.02210613f, -0.02727903f, -0.04463308f, 0.00978447f, 0.01398241f, 0.04467877f, 
    0.05323752f, -0.03767632f, -0.02595489f, 0.04554994f, 0.03070853f, 0.00384820f, -0.02353981f, -0.02205566f, 
    -0.00606000f, 0.00874279f, 0.03809433f, -0.02270722f, 0.03511390f, -0.05082678f, -0.02665902f, -0.01620602f, 
    0.00656294f, -0.04022979f, -0.03343581f, 0.00607772f, -0.00348446f, -0.02862735f, -0.03306950f, -0.00383893f, 
    0.04645333f, -0.00068931f, -0.04612457f, 0.01666947f, 0.01452928f, 0.03516149f, 0.00649152f, -0.05842633f, 
    -0.04220338f, 0.03891580f, -0.00250020f, 0.00801026f, 0.03888967f, 0.00109196f, -0.04034403f, 0.01879569f, 
    0.04211310f, 0.00243651f, -0.05786733f, 0.00926261f, 0.02786529f, 0.01347137f, -0.05136476f, 0.04309044f, 
    0.03147337f, -0.02512200f, -0.02684900f, -0.00634933f, -0.05248537f, 0.01527287f, 0.01913089f, -0.05643618f, 
    -0.02437418f, -0.03021432f, -0.03014202f, 0.02153038f, 0.01346816f, -0.02295868f, -0.00268306f, -0.04222831f, 
    -0.04221255f, -0.04848118f, 0.03151519f, 0.02608114f, -0.01291099f, -0.03866901f, -0.01414696f, 0.01961244f, 
    0.00670720f, -0.02868625f, -0.03334659f, 0.01607906f, -0.02539845f, -0.02874913f, -0.02009725f, -0.05020247f, 
    0.03020356f, 0.01427776f, -0.00421080f, -0.04307133f, 0.00964597f, 0.05177674f, 0.00872485f, 0.00185082f, 
    0.00574504f, 0.03274612f, -0.03427810f, 0.01782055f, 0.00137615f, 0.01370836f, -0.03819812f, 0.01625253f, 
    0.00731578f, -0.03670649f, -0.00267296f, -0.01283970f, -0.02075403f, -0.00389558f, 0.00042254f, -0.03504489f, 
    -0.02996993f, 0.03192175f, -0.01822615f, -0.03177642f, -0.03045732f, 0.01699043f, -0.03534760f, 0.00493520f, 
    -0.03129195f, -0.01065494f, 0.00045562f, -0.02279609f, 0.02578647f, -0.04863975f, -0.05165735f, -0.00680396f, 
    0.04021519f, 0.01502212f, 0.01504148f, 0.04308484f, -0.05783563f, -0.04867364f, -0.01799715f, -0.00089899f, 
    -0.01671542f, -0.05419521f, -0.03959052f, 0.01917387f, 0.03692933f, 0.02089170f, 0.03652979f, -0.01582259f, 
    -0.01190500f, -0.00894701f, -0.05814714f, 0.00998195f, 0.00147531f, 0.01093193f, 0.02758666f, -0.00799628f, 
    -0.03799453f, 0.01034645f, 0.03655936f, 0.01488753f, 0.03617657f, 0.04711701f, -0.04530130f, -0.00904628f, 
    -0.04361648f, -0.01915242f, -0.02508749f, -0.01919675f, 0.02395043f, -0.03619880f, -0.01140264f, -0.02593888f, 
    -0.01318809f, -0.02335434f, 0.00663253f, 0.01304914f, -0.01847144f, -0.03617964f, 0.00013570f, -0.05536926f, 
    0.02230486f, -0.02229282f, -0.05163257f, 0.00411144f, -0.05751461f, -0.00208284f, -0.02851819f, 0.01890081f, 
    -0.02451944f, 0.03648926f, -0.02776254f, 0.00728878f, -0.03266699f, -0.04513386f, -0.01748899f, -0.05255330f, 
    -0.01814784f, -0.04433304f, -0.01922646f, 0.02336489f, 0.00822068f, 0.02003643f, -0.01004467f, -0.03443395f, 
    -0.04735433f, -0.00082284f, -0.00113752f, 0.02025876f, 0.02997581f, 0.02674238f, 0.03973852f, 0.01137944f, 
    0.00297723f, -0.03976396f, -0.03548675f, -0.00981753f, -0.00550391f, -0.02826379f, 0.00083008f, 0.04462606f, 
    0.03374396f, -0.00024259f, 0.03154726f, 0.03501116f, -0.03505938f, -0.03098752f, 0.03442087f, 0.01898134f, 
    -0.01656760f, -0.04184493f, -0.00838670f, 0.02015567f, -0.01635263f, -0.00257905f, -0.04792659f, 0.03516254f, 
    -0.04751807f, 0.02728062f, 0.04574529f, 0.02721347f, -0.00811887f, -0.02631647f, 0.03868145f, -0.02972098f, 
    0.00721719f, 0.02630258f, 0.04363806f, -0.01492832f, -0.04374280f, -0.01412505f, 0.03644366f, 0.01829174f, 
    0.01437133f, 0.03707319f, -0.04230212f, 0.04630565f, 0.01073018f, -0.00769574f, 0.04022022f, -0.05052434f, 
    -0.00984040f, -0.03725430f, 0.03576545f, -0.03243358f, 0.02384411f, -0.00446825f, -0.04633766f, 0.04720197f, 
    0.24182248f, 0.30753142f, 0.12420948f, 0.17378880f, -0.07523223f, 0.06547809f, 0.10430995f, 0.08325668f, 
    0.06113844f, -0.01883399f, 0.07625492f, 0.07755500f, -0.10947609f, -0.07708471f, -0.02467586f, 0.00624272f, 
    0.13190815f, 0.01349680f, -0.09532406f, -0.03369997f, 0.01745626f, 0.01159977f, -0.06508885f, -0.02585568f, 
    -0.18133909f, 0.15914561f, -0.12026069f, 0.10272270f, 0.12089448f, 0.10078295f, 0.11903588f, 0.01376374f, 
    0.13184871f, -0.05074525f, 0.02960259f, 0.17286727f, -0.18745232f, -0.02602562f, 0.08075406f, 0.00550261f, 
    -0.12492254f, -0.09384720f, -0.06182277f, -0.11712315f, -0.02983124f, 0.14315867f, 0.14622392f, -0.05383696f, 
    -0.04934618f, -0.01886049f, 0.21803749f, -0.10199298f, 0.15493803f, 0.00389631f, -0.06359279f, 0.10798749f, 
    0.07641678f, -0.11304152f, -0.07421531f, -0.07247595f, 0.13292614f, -0.04154269f, 0.02657189f, 0.12244844f, 
    0.10180458f, -0.09565052f, 0.01229617f, 0.03569606f, 0.02335018f, 0.03755399f, 0.05328339f, -0.06125635f, 
    -0.24969417f, -0.19949852f, 0.19448118f, -0.10610049f, -0.21647991f, 0.01265570f, 0.11623798f, -0.06439219f, 
    -0.06025465f, -0.00743467f, 0.02367769f, 0.07542746f, -0.12836979f, 0.00957636f, -0.13324514f, 0.07924294f, 
    0.09048848f, -0.01104535f, 0.18935081f, 0.01280399f, 0.13823669f, 0.09153215f, 0.00260521f, 0.02593770f, 
    -0.16917992f, 0.41748390f, -0.06513657f, 0.09190489f, -0.00890397f, -0.03986003f, 0.08903925f, -0.14004591f, 
    0.03996711f, 0.04227198f, 0.05984762f, -0.00665841f, -0.00024028f, 0.20437758f, 0.00947910f, -0.01618119f, 
    0.06300677f, -0.08205178f, 0.09314336f, -0.10333611f, -0.10402276f, -0.05249399f, 0.05921076f, -0.03115617f, 
    -0.07364892f, 0.06952634f, -0.38258046f, -0.08762209f, 0.08826403f, 0.10677519f, -0.06068726f, 0.07868894f, 
    -0.02848531f, 0.04514630f, -0.07899284f, 0.23525511f, 0.19019581f, 0.07010608f, 0.02438595f, 0.18433434f, 
    0.22426547f, 0.02522786f, 0.01292902f, 0.22465415f, 0.08454281f, 0.13199718f, 0.05984724f, 0.02084118f, 
    0.41273606f, 0.25889400f, 0.25567150f, 0.24502714f, -0.09116029f, -0.00432181f, 0.05657370f, 0.09476346f, 
    -0.01890592f, -0.10574686f, -0.16975467f, 0.12146037f, 0.13228765f, -0.01972413f, -0.06251615f, -0.05450244f, 
    0.07638209f, 0.03787819f, 0.01797553f, -0.10428686f, 0.03161165f, -0.04077034f, -0.09419461f, -0.05414383f, 
    -0.17372951f, 0.01612139f, 0.26548421f, -0.09319898f, 0.00916120f, -0.02346586f, 0.00984611f, -0.07696299f, 
    -0.01909984f, 0.00689260f, 0.02652913f, -0.03589838f, -0.27459270f, -0.30265021f, 0.14024283f, 0.09123690f, 
    0.12532373f, -0.13261665f, -0.05438345f, 0.09317895f, 0.14064729f, 0.07002911f, -0.02808904f, 0.09351676f, 
    0.42170775f, -0.05083727f, 0.25659418f, 0.18613851f, -0.10675395f, -0.10563946f, 0.03215765f, 0.07729017f, 
    0.18759511f, 0.06282553f, -0.01891188f, 0.05042453f, -0.21897329f, 0.20055006f, -0.21078421f, 0.00430873f, 
    0.28175506f, 0.09670553f, -0.08502922f, -0.04698846f, 0.05249973f, -0.02182369f, 0.08625297f, 0.10037725f, 
    0.20216891f, -0.31145066f, 0.14297749f, -0.19467600f, -0.00993480f, 0.13946982f, 0.02895603f, -0.13805158f, 
    -0.00302695f, 0.03494730f, 0.08442675f, -0.05444595f, 0.36122486f, -0.38675627f, 0.07178789f, -0.24143240f, 
    -0.19903812f, 0.06941625f, 0.06545955f, 0.00858312f, -0.10122274f, -0.03583563f, -0.11842068f, -0.08699106f, 
    0.05199156f, -0.15911597f, 0.36053529f, 0.36178955f, -0.18575197f, -0.05858269f, 0.01951576f, 0.03165575f, 
    -0.14480345f, -0.03796845f, 0.08582965f, 0.12331942f, 0.14300041f, -0.08722526f, 0.28042069f, 0.04301701f, 
    0.08224569f, -0.02903108f, 0.17363417f, -0.03051468f, -0.03548183f, -0.01144092f, -0.03785705f, 0.16908555f, 
    -0.45503515f, 0.01591551f, -0.17998829f, 0.17120028f, 0.04521798f, -0.07494854f, 0.01368621f, 0.12105116f, 
    -0.14168827f, -0.13138907f, 0.06149739f, 0.07520224f, -0.20033932f, 0.03645382f, 0.03817448f, 0.06883279f, 
    0.12074897f, -0.03853804f, -0.02058816f, 0.05666545f, 0.03593410f, 0.03750329f, 0.19996151f, -0.07813687f, 
    0.12138055f, 0.53417641f, -0.07904617f, 0.17230830f, -0.16130227f, 0.13397107f, 0.10476196f, 0.07199223f, 
    -0.06549126f, 0.02534916f, 0.16153271f, -0.11890216f, -0.07677797f, 0.02501738f, 0.11073816f, 0.18002214f, 
    -0.04027021f, -0.10670830f, 0.15226468f, 0.14402334f, -0.14663906f, -0.01713410f, 0.09873516f, -0.03675852f, 
    0.22556134f, -0.30655587f, -0.04473600f, -0.13920797f, -0.02874286f, -0.06534156f, -0.12025953f, -0.10179565f, 
    -0.09839075f, -0.00501979f, -0.03623049f, -0.07706067f, -0.19496672f, -0.11784962f, -0.09062843f, 0.00437075f, 
    -0.20188980f, -0.09992608f, -0.07029259f, 0.09103775f, 0.07469151f, 0.06247601f, -0.09549408f, 0.03178557f, 
    -0.40289018f, -0.36244950f, -0.02638435f, 0.08962112f, 0.03218877f, -0.12976807f, -0.07820162f, -0.03480585f, 
    0.01085459f, -0.00793161f, -0.06862194f, -0.06310342f, -0.10923611f, -0.10007519f, 0.13562417f, -0.05473314f, 
    0.16247033f, -0.04638400f, 0.09944608f, 0.07846978f, 0.11465874f, 0.08692555f, 0.01798649f, 0.08345251f, 
    -0.63784593f, -0.16367358f, -0.05638354f, 0.03173450f, 0.09692651f, -0.14706013f, 0.11731689f, -0.06643889f, 
    -0.01878362f, 0.15361962f, -0.02489964f, -0.05879780f, 0.02206874f, -0.38615882f, 0.07843580f, -0.07067265f, 
    0.06166468f, 0.02409303f, -0.10004372f, -0.10096166f, -0.01006762f, -0.04445229f, 0.09816270f, 0.03272722f, 
    -0.00588841f, 0.00480779f, 0.03858385f, 0.01735362f, 0.02630614f, -0.02214158f, -0.01170593f, -0.02860595f, 
    -0.03521688f, 0.03839907f, -0.02790504f, 0.01090130f, -0.02553446f, -0.01908018f, 0.00913909f, 0.03805546f, 
    0.03569026f, -0.02157477f, 0.02433010f, 0.02976553f, -0.01880840f, 0.03287709f, -0.03172780f, -0.02403391f, 
    0.00259077f, -0.04046084f, 0.00748469f, 0.01710299f, 0.01766888f, 0.00828912f, 0.00772382f, 0.02100152f, 
    -0.01220540f, 0.00339144f, -0.04376281f, 0.02877573f, 0.02103636f, -0.03054397f, 0.04232851f, 0.02453608f, 
    -0.02912630f, 0.01247375f, -0.00084885f, -0.04351199f, -0.01940947f, -0.03852767f, -0.02472864f, 0.03756419f, 
    -0.01394336f, -0.03910429f, -0.01432924f, -0.01677874f, -0.00513899f, 0.00701617f, 0.02058249f, -0.05299922f, 
    -0.05111739f, -0.01721506f, -0.05059370f, -0.01778101f, 0.01035517f, 0.02756584f, 0.01760118f, -0.02297116f, 
    -0.02390197f, -0.04384471f, -0.00079375f, -0.03530785f, -0.01307098f, -0.05402645f, -0.02648065f, 0.02743586f, 
    0.00826435f, 0.00517816f, -0.04804907f, 0.00012190f, 0.04304454f, -0.05236926f, 0.00515247f, 0.04092846f, 
    0.00263114f, -0.05236857f, 0.00222235f, -0.02649414f, 0.01705287f, 0.03577272f, 0.03351549f, 0.02221001f, 
    -0.00292415f, -0.05847716f, -0.02753478f, -0.04879926f, -0.04030358f, 0.01460874f, 0.01191641f, -0.05419487f, 
    -0.05407598f, -0.02327556f, 0.00561100f, 0.00659125f, -0.02766449f, 0.01808818f, 0.00991632f, -0.04665878f, 
    -0.04313841f, -0.05214339f, -0.04963582f, -0.00836864f, -0.01116217f, -0.00084266f, -0.02182927f, 0.00703153f, 
    -0.03713944f, -0.01198977f, -0.01134737f, -0.04092469f, 0.01186252f, -0.04647318f, 0.01907796f, -0.00295199f, 
    0.00095744f, -0.02995970f, 0.02464984f, -0.02375762f, -0.02480921f, 0.03652941f, -0.00015304f, 0.02252367f, 
    -0.03112407f, -0.05930522f, -0.00774402f, 0.01464720f, -0.03118334f, -0.05196980f, 0.02559934f, -0.01626494f, 
    0.01964362f, -0.01827794f, 0.01625538f, -0.05552483f, -0.05942654f, -0.02110559f, 0.04286509f, -0.02962965f, 
    -0.04679132f, 0.01451006f, 0.03488571f, 0.04580354f, 0.02538845f, 0.04169102f, -0.01925615f, -0.04782777f, 
    -0.00388919f, -0.01326999f, 0.04261560f, -0.04502318f, 0.01824391f, -0.00649049f, 0.01728743f, -0.04145947f, 
    -0.00770953f, -0.05817693f, -0.01066991f, -0.04692602f, 0.01246765f, -0.03195547f, -0.03701150f, 0.00259338f, 
    0.01282609f, 0.03177650f, 0.03925496f, -0.01236671f, -0.04846472f, -0.01028754f, 0.02475707f, -0.00902797f, 
    -0.01576142f, 0.02860410f, -0.00362648f, 0.00743223f, -0.00312396f, -0.02591054f, -0.00963066f, 0.00235258f, 
    0.02342174f, 0.02970301f, -0.03404058f, 0.03898316f, -0.02391657f, -0.02589639f, -0.04373504f, -0.01675178f, 
    0.03804980f, -0.06019749f, 0.04345376f, -0.00363988f, 0.03299297f, -0.01713888f, 0.00368127f, -0.00607310f, 
    0.03879677f, 0.03688815f, 0.03811049f, -0.05300127f, 0.03423620f, -0.00934978f, 0.02390422f, -0.04216399f, 
    0.01630452f, 0.01402364f, 0.00993723f, 0.01068597f, 0.03703197f, 0.02880671f, 0.00281524f, 0.03842340f, 
    -0.01734051f, -0.03886291f, 0.01920801f, -0.04569005f, -0.00478344f, 0.01064638f, -0.01533555f, -0.01146622f, 
    -0.00106089f, -0.02928648f, -0.00072430f, -0.03664226f, 0.03680186f, -0.02550033f, -0.05414304f, -0.02306435f, 
    -0.02370144f, -0.04959633f, 0.01509292f, -0.05290867f, -0.04537988f, -0.03025480f, -0.01340038f, -0.03842491f, 
    -0.02188816f, 0.01779337f, 0.04408809f, 0.01068825f, -0.01431726f, 0.01301060f, -0.04585369f, -0.03640447f, 
    0.00020184f, -0.02794018f, -0.05264771f, -0.04912161f, 0.04368591f, -0.02381293f, -0.00597575f, -0.01149690f, 
    -0.06013113f, 0.00069759f, 0.00877479f, -0.01905577f, -0.02176868f, -0.00216329f, -0.05290718f, -0.05487505f, 
    0.00152859f, 0.00134720f, 0.03784232f, -0.03017992f, 0.02385578f, 0.00580368f, 0.00906281f, 0.01639505f, 
    -0.00919413f, 0.00378660f, 0.02862337f, -0.01827965f, -0.00043430f, -0.03901536f, -0.03346494f, 0.03984780f, 
    -0.04394419f, 0.03199067f, -0.04801859f, 0.03321898f, -0.02970768f, -0.04832964f, 0.03212934f, -0.04695290f, 
    0.00751520f, 0.01658542f, 0.01872263f, -0.01004637f, 0.02095275f, -0.02413279f, -0.01259703f, 0.02194255f, 
    -0.01399344f, -0.04242565f, 0.04280866f, -0.05537817f, -0.02779526f, 0.04046234f, -0.04327255f, 0.00887624f, 
    -0.02404729f, -0.02857835f, -0.01296987f, 0.01441054f, -0.04390368f, 0.03095412f, 0.01965738f, -0.02850593f, 
    0.01655145f, -0.00562716f, 0.01330560f, 0.02749548f, -0.00557064f, 0.03780575f, -0.02089789f, -0.01098427f, 
    0.03896141f, -0.01083635f, -0.01282876f, 0.00208780f, 0.00415678f, -0.03732136f, 0.01133630f, -0.00200022f, 
    0.00359125f, -0.05467870f, 0.00975439f, -0.02201412f, -0.00733078f, -0.00090613f, 0.01538045f, 0.02424653f, 
    -0.03582273f, -0.02229195f, 0.03579399f, -0.02556479f, -0.03538676f, -0.02335256f, -0.01552267f, -0.02264443f, 
    -0.01560091f, 0.01449274f, 0.04218094f, -0.05655403f, -0.04623078f, -0.05206849f, 0.03720473f, 0.04418094f, 
    0.01324650f, -0.04551831f, -0.05454592f, -0.04875910f, 0.02430698f, -0.01320751f, 0.03166949f, 0.02202875f, 
    0.01244142f, -0.04538297f, 0.00360371f, 0.03429420f, -0.05160294f, 0.00969995f, 0.02455175f, -0.05169398f, 
    -0.01437010f, 0.00008156f, -0.04579072f, 0.03881048f, 0.03671236f, -0.04365435f, 0.01952521f, -0.03553434f, 
    -0.04851567f, -0.04048261f, -0.03164479f, -0.04693001f, 0.00215108f, -0.01378104f, 0.00505622f, -0.05663859f, 
    0.49079606f, 0.21718535f, 0.10753141f, 0.10457554f, 0.00795870f, 0.01436927f, -0.04344608f, 0.03453566f, 
    -0.05964377f, -0.02151210f, 0.09584811f, 0.06098712f, -0.15698078f, -0.39655149f, -0.06056169f, -0.12175190f, 
    -0.13460293f, 0.06530407f, 0.07966504f, -0.08090968f, -0.00289529f, -0.00408510f, 0.07794432f, 0.13983074f, 
    0.03633251f, -0.17489780f, 0.01588512f, -0.05508024f, 0.04467648f, 0.05268741f, 0.03532322f, -0.11267155f, 
    -0.01931136f, 0.14312710f, 0.05808537f, 0.10063065f, 0.05160378f, -0.00146431f, -0.00000028f, 0.18385404f, 
    -0.08204622f, -0.06949168f, 0.17842813f, -0.00310612f, 0.00772206f, -0.07826988f, 0.04731490f, 0.15564741f, 
    -0.01863225f, 0.01829831f, 0.25347963f, 0.06314830f, -0.06899122f, 0.01343399f, 0.08499827f, -0.02635795f, 
    0.03547452f, 0.10827968f, 0.09437531f, 0.14808828f, 0.06358668f, -0.15974396f, 0.22630520f, 0.21899466f, 
    0.07885284f, 0.09705453f, -0.02130053f, 0.05732961f, -0.03631283f, 0.07311369f, -0.09519818f, -0.06325629f, 
    -0.04313833f, 0.13266054f, -0.21049029f, 0.13803814f, 0.17289348f, 0.03032965f, 0.10203642f, 0.01161701f, 
    -0.04067008f, 0.03817178f, 0.03829676f, 0.18041885f, -0.13488457f, -0.22546154f, -0.20088722f, -0.42549428f, 
    0.02610973f, 0.01931157f, -0.05959115f, 0.04378033f, 0.05196499f, 0.12189891f, -0.09370571f, -0.00149548f, 
    -0.19732080f, 0.13523026f, 0.07823149f, 0.06193390f, 0.03191252f, -0.01800499f, 0.07321266f, 0.07896997f, 
    0.09463608f, 0.13163778f, 0.04051798f, 0.04420144f, -0.02438372f, 0.16722120f, 0.22333384f, 0.21491626f, 
    0.03379678f, -0.07168702f, -0.10760826f, 0.04140551f, 0.11187029f, 0.06279830f, 0.02232694f, -0.01928721f, 
    -0.21435845f, -0.16709022f, 0.04901877f, 0.14219053f, 0.08155975f, -0.06863309f, -0.00797292f, 0.10821800f, 
    0.04081339f, 0.05862634f, 0.09197588f, 0.05452423f, -0.36662841f, -0.29761785f, -0.16104501f, -0.03747560f, 
    -0.02353519f, 0.04774704f, 0.03482089f, -0.08323118f, 0.13938244f, -0.02878934f, 0.09000499f, 0.09124734f, 
    0.37837690f, -0.03197548f, 0.55624092f, 0.28415918f, -0.11451835f, 0.05314797f, 0.13701254f, 0.05305545f, 
    0.07648396f, 0.02420995f, 0.02924546f, 0.13145591f, -0.45281759f, 0.05609370f, 0.14298321f, -0.16417320f, 
    0.05317087f, 0.00380507f, 0.22034629f, 0.15981570f, 0.04804867f, 0.03112362f, 0.07464881f, 0.05099489f, 
    0.11300655f, -0.04477163f, 0.26683018f, 0.10786224f, -0.03553926f, 0.20927630f, 0.07520702f, -0.08313236f, 
    0.09576856f, 0.08342577f, -0.05105332f, 0.31141463f, -0.02243111f, 0.06387638f, 0.03352594f, -0.13209882f, 
    0.04958735f, 0.13076083f, 0.00312498f, 0.04995075f, -0.02879759f, -0.00304171f, 0.11990605f, 0.07655803f, 
    0.16647227f, 0.35093617f, 0.19675927f, 0.07380837f, 0.05014644f, -0.10324932f, 0.06191441f, 0.08135823f, 
    0.11152563f, -0.15714116f, 0.08503266f, -0.08799113f, -0.01871247f, -0.12923589f, -0.19303232f, -0.24244443f, 
    -0.00848934f, 0.07407009f, -0.03693703f, -0.03898546f, 0.09024711f, 0.05547122f, -0.14181328f, 0.06259749f, 
    0.16031167f, 0.11753404f, 0.13308574f, -0.09591030f, 0.17915148f, -0.07421555f, -0.16695528f, -0.07693525f, 
    -0.04734305f, 0.09932274f, -0.15801270f, 0.17568021f, 0.12509908f, 0.29627624f, -0.04924039f, 0.15461256f, 
    0.14213678f, -0.02151558f, -0.01955104f, 0.30572498f, 0.02905197f, -0.01197207f, 0.08609302f, 0.13067132f, 
    0.25333878f, 0.23054534f, 0.01056591f, 0.00462473f, 0.04615685f, -0.05729891f, 0.12382936f, 0.14270461f, 
    -0.09489398f, 0.02093886f, -0.03168369f, 0.03033603f, -0.16140381f, -0.10004226f, -0.10210022f, -0.16899309f, 
    0.12697710f, 0.02053540f, 0.04358096f, 0.01187081f, 0.00576177f, 0.22620821f, -0.02408016f, 0.00401352f, 
    -0.41305816f, 0.15863837f, 0.06896152f, 0.12634975f, 0.05416527f, 0.05464797f, 0.05845171f, -0.10300267f, 
    0.16086827f, 0.03927206f, 0.07755212f, 0.00891870f, 0.27646577f, -0.02015753f, 0.04339878f, 0.04539151f, 
    -0.08428083f, 0.17095411f, -0.03219070f, 0.08203297f, 0.02177389f, 0.02587141f, -0.02424627f, 0.16014917f, 
    0.04890488f, 0.03311029f, 0.26071283f, 0.20003343f, -0.07342760f, 0.00119048f, 0.02007892f, -0.00665240f, 
    0.10572072f, 0.01740058f, -0.04791643f, -0.03723019f, 0.04995469f, -0.10526481f, 0.02244463f, -0.04484299f, 
    0.04769297f, -0.07205337f, -0.24851736f, 0.09586480f, 0.10525533f, 0.00590054f, 0.15477858f, -0.04911211f, 
    0.03087616f, -0.00449694f, 0.13136512f, -0.12420405f, 0.04515266f, 0.06629444f, 0.20726211f, -0.03808836f, 
    0.04289271f, 0.10095169f, -0.09006453f, 0.02044922f, 0.30572358f, 0.22630659f, 0.29641789f, -0.03708722f, 
    0.03922257f, 0.24528767f, 0.03022057f, 0.10641470f, 0.03205481f, -0.05963623f, 0.03509078f, 0.13359331f, 
    -0.18072891f, 0.13815984f, -0.13077751f, 0.03387825f, 0.02076380f, 0.13063700f, -0.05783674f, 0.10979245f, 
    -0.01177982f, 0.10903081f, 0.12118050f, 0.08783902f, 0.24879752f, -0.25351623f, -0.18923642f, -0.30034167f, 
    0.12578347f, 0.08550821f, -0.05921208f, 0.07828978f, -0.06789563f, -0.02705390f, 0.09507229f, 0.02431609f, 
    0.17846042f, 0.11301063f, 0.01924100f, -0.06708644f, -0.17371225f, 0.17822532f, 0.02130855f, -0.02330214f, 
    -0.00364019f, -0.10646535f, 0.15825921f, 0.04151043f, 0.08897427f, -0.00465351f, -0.20062512f, -0.46665537f, 
    0.18762299f, 0.09624678f, 0.05006466f, -0.04591746f, 0.16290031f, -0.18793508f, 0.12417810f, 0.11529122f, 
    -0.07779884f, 0.26556322f, 0.13404936f, 0.06167435f, -0.10151462f, 0.04958862f, 0.12337477f, 0.06963281f, 
    0.07420509f, 0.03503437f, -0.04484973f, 0.05770197f, 0.35048312f, -0.08123670f, -0.17025386f, 0.12494534f, 
    -0.05423561f, 0.22576432f, 0.03832411f, -0.04031716f, -0.04804382f, -0.06762335f, -0.03282707f, 0.10794439f, 
    0.19386400f, 0.14440176f, -0.13651882f, 0.42887327f, -0.06908913f, 0.04264555f, -0.09298216f, 0.12968443f, 
    0.19037391f, -0.17239758f, 0.08381440f, 0.00221448f, -0.12623392f, -0.22316420f, -0.11857235f, 0.02217614f, 
    0.04441439f, 0.13055374f, 0.05640504f, 0.14235507f, 0.03509963f, 0.08184494f, -0.12578399f, -0.14429866f, 
    0.42187116f, -0.18735233f, 0.01517852f, -0.08402662f, 0.04086585f, 0.11196647f, -0.05161745f, 0.05281435f, 
    -0.17352504f, 0.13720782f, 0.08187366f, -0.20902199f, -0.00572610f, 0.15635771f, -0.14931871f, 0.08839174f, 
    -0.01472406f, -0.04904578f, 0.12207329f, -0.02436140f, -0.05224723f, 0.13465907f, 0.18702976f, 0.21120653f, 
    -0.15878707f, 0.04904217f, 0.28982237f, 0.00794150f, 0.12481389f, 0.01066600f, -0.00543733f, 0.15348911f, 
    0.06541021f, 0.06955912f, 0.02387223f, -0.23963825f, 0.15329397f, 0.03182779f, 0.04118113f, 0.02703464f, 
    -0.09079918f, -0.09983009f, 0.09265956f, -0.00357697f, -0.04106745f, -0.14628893f, 0.28132504f, 0.21197933f, 
    -0.03395012f, -0.14784834f, 0.20320679f, 0.02733624f, 0.10109363f, -0.08082992f, 0.01628632f, -0.01238304f, 
    -0.14968082f, -0.08083151f, -0.08757107f, -0.04339051f, 0.05876482f, 0.02168569f, 0.04195178f, -0.14847353f, 
    -0.15254106f, 0.05478164f, 0.23513502f, 0.02631825f, 0.11413985f, -0.12362439f, -0.06016963f, 0.04953119f, 
    0.39524189f, 0.21144573f, 0.16095649f, 0.21647033f, 0.17987041f, 0.19200465f, 0.35008278f, -0.19476302f, 
    0.08855575f, 0.03288153f, -0.04204522f, 0.07535068f, 0.13726613f, 0.05631107f, -0.21847084f, 0.02820371f, 
    0.12711051f, 0.01460095f, 0.14785470f, 0.15996981f, -0.05386656f, -0.08034184f, -0.01456802f, -0.25881821f, 
    -0.06096485f, -0.01001740f, -0.11202762f, -0.08724003f, -0.24670193f, -0.07641805f, 0.01098927f, 0.17507817f, 
    0.05163626f, 0.13670307f, 0.07298077f, -0.06416664f, 0.01722295f, 0.15846363f, -0.07062229f, 0.01233120f, 
    0.07327982f, 0.06018296f, 0.08244707f, 0.00463313f, 0.00204282f, -0.19107629f, 0.14012332f, 0.10149465f, 
    0.02014051f, 0.19744107f, -0.06190539f, 0.02054085f, -0.08517412f, 0.06992605f, 0.13424626f, 0.06691430f, 
    -0.09079077f, -0.26509255f, 0.16737661f, -0.18687977f, 0.03495476f, -0.09873018f, 0.01149810f, 0.07822205f, 
    -0.02599793f, 0.07902041f, 0.11655006f, -0.00746866f, 0.21142481f, -0.22199878f, -0.13020790f, -0.00154710f, 
    0.14027405f, 0.13753864f, 0.18070278f, 0.09536294f, -0.09762440f, 0.15266027f, -0.12218381f, 0.02276894f, 
    -0.06045109f, 0.21724086f, -0.08574174f, -0.02713405f, -0.02101136f, -0.03170416f, 0.02962578f, -0.06538513f, 
    -0.01041011f, 0.07112746f, 0.13293399f, 0.07568870f, -0.00712339f, 0.17219663f, 0.08649051f, 0.23268671f, 
    0.06139544f, -0.27500728f, -0.03083965f, 0.16743223f, -0.17678878f, 0.12393951f, 0.10215230f, 0.22968107f, 
    -0.13163881f, -0.04127464f, 0.17848860f, 0.09007066f, -0.41100135f, -0.23302068f, 0.10680658f, 0.19329350f, 
    0.12697342f, 0.06787530f, -0.19698495f, -0.00786280f, -0.06402957f, 0.08301430f, 0.06931145f, -0.00014794f, 
    0.18650164f, 0.25495806f, 0.23782168f, -0.09321674f, -0.04754435f, 0.12699226f, -0.08947139f, 0.09691046f, 
    -0.04709247f, -0.12630981f, -0.05914287f, 0.07802109f, 0.13450857f, 0.10682626f, 0.16584428f, 0.07042127f, 
    -0.01449034f, -0.02836906f, 0.06570123f, 0.01303379f, 0.18295795f, 0.01226073f, 0.10015280f, 0.01341752f, 
    -0.01365131f, 0.14642119f, 0.08789279f, 0.10919975f, -0.05178087f, -0.08104030f, 0.13131082f, -0.08218770f, 
    0.06124489f, 0.10258191f, 0.06663912f, -0.07801255f, -0.18705489f, -0.08012995f, -0.07077651f, -0.03454835f, 
    0.08561239f, 0.04948714f, 0.09943556f, 0.05286856f, 0.02411187f, 0.13427614f, 0.08619709f, 0.03545359f, 
    0.28612214f, -0.11450522f, 0.03194503f, 0.03233999f, -0.07389084f, 0.04160458f, 0.12203959f, -0.00494854f, 
    0.01905263f, -0.02990608f, 0.01903065f, 0.30175602f, 0.05604400f, -0.02976945f, -0.02276840f, 0.04715256f, 
    -0.05303330f, 0.12624964f, -0.13011470f, -0.11391831f, -0.04874882f, 0.15942815f, -0.09168325f, 0.46081439f, 
    0.10496896f, 0.18592949f, 0.14034335f, -0.02710560f, -0.20482130f, 0.21292093f, -0.04893233f, 0.18620303f, 
    -0.02615896f, 0.06037635f, 0.20875619f, -0.03415534f, -0.10106985f, -0.01130600f, 0.17023151f, -0.02043460f, 
    0.09073412f, 0.08291784f, 0.03323159f, -0.06666576f, 0.14640683f, 0.01746554f, 0.00240827f, -0.23434915f, 
    -0.22921297f, -0.17384684f, 0.30585337f, 0.18317063f, 0.10666844f, 0.20342554f, 0.01611992f, 0.02850768f, 
    0.06395104f, -0.01504899f, 0.08122018f, -0.05025469f, 0.00839749f, 0.17842551f, -0.04337456f, 0.10333367f, 
    -0.01731461f, 0.14561081f, 0.11305471f, 0.01911768f, 0.00497787f, 0.04265823f, 0.05941090f, 0.03715824f, 
    0.72786301f, 0.18569209f, 0.19782753f, 0.29526934f, -0.04593926f, 0.07063930f, 0.14697272f, 0.07114816f, 
    -0.07058946f, 0.10501528f, 0.00550477f, 0.10141268f, -0.03621860f, -0.00604253f, 0.04791628f, -0.19243169f, 
    0.09936784f, -0.07051995f, 0.10025498f, -0.13125484f, 0.09983438f, 0.16054398f, 0.07095498f, 0.14175045f, 
    -0.01603235f, -0.04776818f, -0.02347288f, -0.05120584f, -0.02127917f, -0.02382125f, 0.02744710f, -0.01702259f, 
    -0.05432571f, 0.03313388f, -0.00426164f, 0.00213330f, 0.03964787f, -0.02165293f, -0.01599115f, 0.03677962f, 
    0.03812775f, -0.04084216f, -0.01529844f, -0.04288995f, 0.01300248f, -0.04656744f, -0.01353973f, 0.01295490f, 
    0.02338336f, -0.03060355f, -0.01697816f, -0.01210067f, -0.05470042f, -0.00763251f, 0.03674376f, -0.01783261f, 
    -0.03402087f, -0.04558722f, 0.00800468f, 0.00416319f, -0.03183338f, 0.00496956f, -0.04399696f, -0.02956194f, 
    0.01233991f, 0.03480126f, -0.01308067f, 0.03632659f, 0.02675449f, -0.05288651f, 0.03742370f, -0.02913300f, 
    0.03422590f, -0.04581441f, -0.06124097f, 0.03430726f, -0.02375542f, -0.05364966f, 0.00362682f, 0.03534378f, 
    -0.03839060f, 0.02575104f, 0.04127076f, 0.02614390f, -0.03873313f, -0.03193430f, -0.03546378f, -0.01708404f, 
    -0.02573049f, 0.03912502f, 0.01763203f, -0.03726890f, -0.00493862f, -0.01696349f, 0.02278175f, -0.03742859f, 
    -0.03326672f, -0.01528603f, -0.03808859f, -0.01161045f, 0.04205200f, -0.03733317f, 0.01069142f, -0.04085382f, 
    0.00645894f, -0.00784810f, -0.01988776f, -0.01199057f, -0.01943378f, -0.01969743f, -0.04256091f, -0.05149662f, 
    -0.00817597f, -0.02538914f, -0.03583292f, 0.01135406f, -0.00468028f, 0.00436085f, 0.01308115f, 0.01410056f, 
    0.00192196f, -0.00488803f, -0.02121000f, -0.01756759f, 0.01136483f, 0.01141380f, -0.00643995f, 0.03419292f, 
    0.01823633f, 0.02422229f, 0.01374805f, -0.03996749f, -0.01725404f, 0.04274403f, -0.04036434f, -0.05135606f, 
    0.02069444f, -0.02568656f, -0.02062281f, -0.05469659f, 0.04467914f, 0.00944867f, -0.00410409f, 0.00379145f, 
    0.01469806f, 0.02830018f, -0.01587316f, -0.00874015f, 0.02268756f, 0.01313100f, -0.01444162f, -0.04736712f, 
    -0.01602319f, 0.03265469f, -0.00830597f, -0.04582792f, -0.03481572f, -0.03732020f, 0.02274337f, 0.02225148f, 
    0.01794034f, 0.00226265f, 0.00808354f, -0.00746042f, 0.01992174f, 0.00064469f, 0.02967628f, -0.02749567f, 
    -0.03863416f, 0.00218446f, 0.00439750f, 0.02718944f, 0.04120008f, 0.01976322f, -0.04544957f, -0.04184326f, 
    -0.03232409f, -0.05753745f, -0.02718974f, 0.02758982f, -0.01955861f, 0.02168907f, 0.00168420f, 0.01494432f, 
    0.01543329f, 0.04111554f, 0.03666941f, 0.01276088f, -0.03338763f, 0.03127171f, -0.01679666f, -0.04548237f, 
    0.01608506f, 0.00240827f, 0.00347995f, 0.03691249f, 0.04244921f, -0.02976792f, -0.04582824f, -0.04029723f, 
    0.00955104f, -0.04192000f, -0.00288662f, -0.00209532f, -0.00510897f, -0.05109876f, -0.02295227f, -0.04594697f, 
    0.03204390f, -0.01967712f, 0.02330836f, 0.04777629f, -0.00672751f, 0.00867081f, -0.00378474f, -0.03876636f, 
    0.03835588f, -0.03836276f, 0.03348889f, 0.03433535f, 0.00911459f, 0.00758451f, 0.00404451f, -0.01522627f, 
    -0.02320897f, 0.04062758f, -0.04165595f, -0.00888592f, -0.03284583f, -0.01396604f, -0.01283339f, 0.02204104f, 
    0.02029014f, 0.00826582f, 0.03783976f, -0.05435461f, 0.00510638f, 0.00491146f, -0.01346671f, -0.04426289f, 
    0.01917225f, -0.01495663f, -0.05023332f, 0.00206274f, -0.00612599f, -0.03486719f, -0.00907876f, -0.02704699f, 
    -0.02334095f, 0.00764060f, -0.03840044f, 0.03768730f, -0.03815116f, -0.02584964f, -0.01547253f, 0.01943968f, 
    0.04494924f, -0.03729732f, 0.03129551f, 0.04183767f, 0.02849106f, -0.03284289f, -0.04803220f, -0.05476717f, 
    0.03771619f, 0.04334877f, -0.04507031f, -0.03656439f, -0.00731716f, -0.03162085f, 0.00629688f, 0.00584982f, 
    -0.01235933f, -0.01240172f, 0.03928370f, -0.01512087f, 0.05272052f, 0.03403474f, -0.03348813f, 0.02236546f, 
    0.01889133f, -0.04542347f, 0.02949480f, 0.03491191f, -0.02285625f, -0.03856625f, -0.04654283f, 0.03975034f, 
    0.00117787f, 0.02116834f, 0.02845569f, -0.02526671f, -0.04715821f, -0.00087704f, -0.05631428f, -0.04857737f, 
    -0.02076631f, 0.01662464f, -0.01388649f, 0.01502424f, 0.00781324f, -0.01439309f, -0.01167935f, 0.04313774f, 
    0.03475002f, -0.00895387f, -0.03784135f, -0.00865929f, -0.01793437f, 0.01982161f, -0.02435661f, -0.01370906f, 
    -0.00785307f, -0.00007843f, -0.03038948f, 0.03567931f, 0.01714134f, -0.02433674f, -0.03446275f, -0.01281858f, 
    0.01614316f, -0.03640604f, -0.01607323f, 0.02143919f, -0.02887263f, -0.04608167f, -0.01486323f, -0.04678247f, 
    -0.04968935f, 0.02726240f, 0.02412124f, -0.04505930f, 0.03997387f, 0.00820218f, -0.02121087f, 0.01951501f, 
    0.03005235f, 0.03377511f, -0.01127867f, -0.01596331f, 0.02945825f, 0.02616168f, 0.00309869f, -0.02710877f, 
    0.03675851f, 0.04203610f, -0.00554094f, -0.02224352f, -0.00300106f, 0.01024562f, -0.03964412f, -0.05105544f, 
    0.01810214f, -0.00168697f, 0.03995293f, 0.00888118f, 0.00622710f, 0.04124198f, -0.02344976f, 0.02364218f, 
    -0.05295438f, -0.02814158f, -0.02229930f, -0.05271952f, 0.03575877f, 0.01293492f, 0.03705710f, -0.02746004f, 
    0.04779306f, 0.02102941f, 0.00140065f, 0.02970286f, -0.03850578f, 0.01858388f, 0.02869432f, -0.01475486f, 
    -0.00367273f, 0.00753454f, -0.00979880f, 0.00965076f, -0.00164123f, -0.03505825f, 0.01260935f, -0.00154084f, 
    0.02069502f, -0.00008240f, -0.03138680f, -0.01662449f, 0.01635663f, 0.04264995f, -0.04529219f, -0.05289427f, 
    0.02386839f, -0.05836869f, -0.03644839f, -0.05426106f, -0.02243569f, 0.02859082f, 0.00512056f, -0.04386997f, 
    -0.02921133f, -0.04139325f, 0.04206109f, 0.02730797f, -0.00511548f, -0.01323667f, 0.01995607f, -0.02572545f, 
    -0.00850961f, 0.02213041f, -0.02900450f, 0.02113582f, 0.01152815f, 0.03844482f, 0.01116008f, 0.01086371f, 
    -0.01109112f, -0.00770784f, -0.00294789f, -0.05080663f, -0.03791793f, 0.04701818f, -0.00532978f, -0.01455961f, 
    -0.01240077f, 0.00918186f, 0.01295078f, -0.01250303f, -0.04063306f, 0.03043289f, 0.03255945f, -0.01292335f, 
    -0.01287059f, 0.04618986f, -0.02626430f, 0.04415723f, -0.00281559f, 0.01100842f, -0.02473064f, -0.03914553f, 
    0.00388989f, 0.03444855f, -0.00924585f, -0.03554912f, -0.04734989f, 0.02027820f, -0.01275247f, 0.02371426f, 
    -0.03475678f, -0.02667746f, 0.03898815f, -0.03427000f, 0.03564166f, 0.00026496f, 0.02731841f, -0.02804659f, 
    -0.00827443f, -0.04526574f, 0.03850069f, -0.02335015f, 0.01310471f, -0.00128188f, 0.01378983f, 0.02654274f, 
    -0.04672957f, -0.00738757f, -0.02802712f, 0.03834082f, -0.00325892f, -0.00623736f, -0.02388358f, -0.00376004f, 
    0.05084092f, -0.04702235f, 0.00708796f, 0.02031085f, 0.00296535f, -0.01594327f, 0.01437016f, 0.01731796f, 
    -0.03004270f, -0.03613650f, -0.03435531f, -0.01827883f, 0.04769178f, -0.03806495f, 0.00750090f, -0.03658925f, 
    0.01870815f, 0.03917075f, 0.01387579f, 0.01152693f, -0.00254323f, -0.03077170f, -0.02172317f, 0.03082262f, 
    -0.02648934f, 0.00341375f, 0.02102169f, -0.04733752f, -0.04405115f, 0.00421836f, -0.04423703f, 0.01844016f, 
    0.02928968f, 0.03789445f, -0.02844499f, 0.04404807f, 0.04502641f, 0.00075895f, 0.00845987f, 0.03952162f, 
    0.03484946f, -0.00192696f, -0.04628803f, 0.00345898f, -0.03652133f, 0.01502268f, -0.04946369f, -0.04404809f, 
    0.03285166f, -0.03930138f, -0.03063916f, 0.03815429f, -0.04927859f, -0.03793385f, 0.01023901f, -0.02859983f, 
    0.04865177f, -0.04913462f, 0.04199805f, 0.01695945f, 0.01064985f, -0.03229961f, -0.01920016f, -0.04343237f, 
    -0.04743899f, 0.04408262f, -0.01085676f, -0.01198183f, 0.04875354f, -0.03180401f, 0.00649758f, -0.04996994f, 
    -0.01434044f, 0.02553760f, -0.02535658f, -0.04925191f, -0.03737992f, -0.03101749f, -0.04892217f, 0.04013795f, 
    -0.02839861f, 0.04458580f, -0.00122091f, -0.04485547f, -0.04757342f, 0.00864865f, 0.02583681f, -0.04970516f, 
    0.02063525f, 0.04607324f, -0.00337701f, -0.01241624f, 0.03154019f, 0.01930761f, 0.01423419f, 0.00552517f, 
    0.03202528f, -0.01680382f, -0.00327844f, -0.00130608f, -0.04981197f, 0.03311637f, -0.03516999f, -0.05048644f, 
    0.03351845f, -0.04468343f, -0.01257000f, -0.01722092f, -0.03938174f, -0.01722741f, -0.00153283f, 0.03433378f, 
    -0.00657195f, -0.04468039f, -0.01690985f, 0.01605554f, 0.01798576f, 0.00775229f, -0.04857989f, 0.00058899f, 
    0.03879919f, 0.02996745f, 0.03180489f, 0.01167693f, -0.03307915f, -0.01354348f, -0.03026736f, -0.05008080f, 
    -0.04158649f, -0.04532578f, 0.02719014f, 0.03044519f, -0.03824604f, 0.01339850f, -0.01473912f, 0.02043192f, 
    -0.00988067f, -0.04784324f, -0.00028498f, -0.02115107f, -0.05067676f, 0.00825803f, 0.02848938f, -0.02754174f, 
    -0.04895467f, -0.01806699f, -0.04974963f, -0.04226699f, -0.04920696f, -0.02241580f, 0.04882007f, 0.03540200f, 
    0.04689113f, 0.01682624f, -0.00513841f, -0.02044846f, 0.02447393f, 0.00522787f, 0.00221394f, -0.05043107f, 
    -0.04464046f, 0.01449421f, -0.00834195f, 0.04572117f, -0.00374738f, 0.00673096f, 0.00762778f, 0.03867153f, 
    -0.02092844f, -0.00320858f, -0.01793014f, 0.04499259f, 0.02026009f, -0.03913685f, 0.02922456f, 0.00981762f, 
    -0.03267311f, -0.04769763f, 0.02770907f, -0.03838305f, 0.04843345f, 0.02862207f, -0.03919844f, 0.03351932f, 
    -0.04554327f, 0.02103191f, -0.00671993f, -0.03418278f, -0.02828478f, -0.02653298f, 0.01974498f, 0.01155811f, 
    -0.03510317f, -0.04678285f, 0.00411894f, -0.03664539f, -0.02293496f, -0.00897591f, -0.00054499f, -0.02641241f, 
    0.00280142f, 0.04752054f, 0.04327267f, -0.03748525f, -0.01847596f, -0.03945728f, -0.00792558f, 0.00674409f, 
    0.02255685f, -0.02668594f, 0.03353424f, -0.02051798f, -0.04896524f, -0.02005572f, -0.03871701f, -0.04285426f, 
    -0.02225520f, -0.00712103f, -0.04115740f, -0.01521862f, -0.01683317f, 0.01990496f, -0.04936649f, 0.03472267f, 
    -0.00026543f, -0.04860468f, -0.03802342f, -0.03311859f, 0.04153870f, 0.00545266f, -0.03772227f, 0.03306505f, 
    -0.01637760f, 0.04809185f, -0.02772277f, 0.02481991f, 0.03855870f, -0.01859868f, 0.01951193f, 0.03339688f, 
    0.03627597f, -0.04552558f, -0.03968802f, 0.00544029f, -0.01120590f, 0.02091877f, -0.00026126f, 0.01724778f, 
    0.01497955f, -0.04779514f, -0.02105540f, 0.00740780f, 0.03534336f, 0.02640196f, 0.04037160f, 0.00249570f, 
    0.01591377f, 0.02436203f, -0.01285113f, 0.01544118f, 0.00635332f, 0.00830623f, 0.00083993f, -0.03218346f, 
    0.03015650f, 0.00102482f, 0.00205002f, 0.00967605f, 0.01631377f, -0.01219456f, 0.00388786f, -0.02483899f, 
    -0.03761708f, 0.04770927f, 0.01865330f, -0.03437712f, 0.03678736f, 0.00984836f, 0.02231015f, -0.02666325f, 
    -0.00428922f, -0.03601419f, 0.05099424f, 0.04791118f, 0.04732251f, 0.04017023f, -0.03873211f, 0.02442235f, 
    -0.04418845f, 0.02172764f, 0.04515024f, -0.00819552f, -0.03604701f, -0.03548777f, -0.02856351f, 0.04083590f, 
    0.00667504f, -0.00629014f, 0.01691527f, 0.03744423f, -0.03308438f, -0.01329962f, -0.03529772f, -0.00371955f, 
    0.03272241f, 0.04879589f, -0.03420274f, -0.01925755f, -0.00439595f, -0.00705027f, -0.03073956f, 0.04278674f, 
    -0.02021807f, 0.03999705f, -0.00793711f, -0.02626113f, -0.00006523f, -0.00155905f, -0.02477956f, -0.04067195f, 
    -0.05350274f, 0.00484020f, -0.02375291f, 0.01164228f, -0.04962567f, 0.02927836f, -0.03404633f, -0.00232413f, 
    -0.02912158f, 0.01015205f, 0.02595595f, -0.03857850f, -0.01142359f, -0.02143717f, 0.00043329f, -0.01483879f, 
    -0.03074775f, 0.00170660f, 0.00407527f, -0.00648930f, -0.05376695f, 0.00726426f, 0.04315688f, -0.00771420f, 
    0.03327020f, 0.00716760f, -0.01374400f, -0.02825000f, -0.05813179f, -0.01592650f, -0.01277753f, -0.00102894f, 
    0.03031823f, -0.05585919f, -0.03587437f, -0.01421248f, -0.05612767f, 0.01488720f, 0.02039951f, -0.03998285f, 
    0.01055519f, -0.04964738f, 0.00616570f, -0.03701295f, 0.02872676f, -0.02077367f, -0.02092318f, 0.01678210f, 
    0.03396125f, 0.00722031f, 0.00456576f, -0.02074836f, -0.02665723f, 0.02764732f, -0.00837707f, -0.05422054f, 
    0.04247105f, -0.01363900f, -0.05266725f, 0.03517814f, -0.03036023f, -0.00483625f, 0.00543605f, -0.00797981f, 
    -0.02476919f, -0.02591112f, -0.05328338f, 0.02876285f, -0.02835355f, -0.03497363f, 0.00277666f, -0.01666730f, 
    -0.05253008f, -0.01670316f, 0.00837332f, -0.03858522f, 0.00019638f, -0.04789450f, 0.02204507f, -0.00302702f, 
    0.04219617f, -0.01505922f, -0.05509242f, 0.01802211f, -0.05510249f, -0.01830300f, 0.00127678f, -0.04411760f, 
    -0.05379918f, -0.03066147f, -0.03455774f, -0.00527072f, -0.01728271f, 0.04018839f, 0.01414342f, -0.02554702f, 
    -0.04749362f, -0.00721659f, 0.00758642f, -0.04971605f, -0.03276264f, -0.05111948f, 0.00638267f, -0.03442693f, 
    -0.02033097f, -0.04657188f, 0.01547845f, -0.02951078f, -0.04134333f, 0.00889425f, 0.01143264f, -0.05412212f, 
    -0.05411397f, 0.02435291f, 0.01313398f, 0.02508408f, 0.00493990f, 0.00438083f, -0.03497751f, 0.02180902f, 
    0.04255056f, 0.04098132f, -0.01735144f, -0.01207203f, 0.02572864f, -0.02436172f, -0.05551235f, -0.00722463f, 
    0.02707033f, 0.00015725f, -0.00343653f, 0.00745001f, -0.01369281f, -0.03541353f, 0.01301710f, 0.02917397f, 
    -0.00138995f, 0.00244135f, 0.00034858f, 0.02136626f, -0.02981053f, -0.03391739f, -0.01147723f, 0.02077475f, 
    -0.01794671f, 0.03265797f, -0.05417800f, 0.00396987f, 0.00404948f, -0.01921252f, -0.01287009f, -0.02801560f, 
    -0.00628117f, 0.02167107f, -0.00508768f, -0.01322515f, -0.04479898f, 0.00770637f, -0.05456892f, 0.00134825f, 
    0.03136631f, -0.00649672f, -0.01525388f, 0.00005426f, 0.01174917f, -0.00748736f, 0.03172074f, 0.04085983f, 
    -0.01915029f, -0.03309848f, -0.05638088f, -0.04559613f, 0.02904975f, -0.03365158f, -0.00334057f, 0.01200522f, 
    0.03559732f, 0.00335103f, 0.02835570f, -0.02689358f, -0.02883012f, 0.00843535f, -0.02388325f, -0.00271609f, 
    -0.01801743f, 0.02995702f, 0.04356514f, -0.03546386f, -0.00482651f, -0.05150554f, 0.04132789f, -0.01282307f, 
    0.00882547f, 0.02597601f, -0.05657947f, 0.01379945f, 0.02279852f, -0.00659325f, 0.00254992f, 0.00948257f, 
    -0.04123302f, -0.02900966f, -0.03107020f, 0.01363208f, 0.00594808f, -0.00445531f, 0.02941170f, -0.04744327f, 
    0.04268858f, -0.04434887f, -0.05256652f, -0.04303086f, 0.01979348f, -0.02997447f, -0.04601987f, -0.05479446f, 
    0.03389615f, -0.04699918f, 0.00692612f, -0.02590623f, -0.05130582f, 0.02693741f, 0.01364457f, 0.02424275f, 
    0.04016785f, 0.02822114f, -0.03203461f, -0.03699500f, 0.01399620f, 0.04360958f, -0.04552121f, -0.02467718f, 
    -0.02317531f, -0.04627652f, -0.05271835f, -0.03418916f, -0.02215723f, 0.01304942f, 0.00592679f, 0.03889138f, 
    0.03274707f, 0.00423625f, -0.01155594f, 0.01771918f, -0.00716249f, -0.05219083f, -0.04128980f, -0.00787516f, 
    0.00355878f, -0.03022919f, -0.04316168f, -0.01517399f, 0.03304683f, -0.00397568f, 0.03082530f, 0.02531205f, 
    0.01944735f, -0.05852947f, -0.04172375f, -0.00736083f, 0.00023186f, -0.04121591f, 0.00922162f, 0.03902292f, 
    0.01788453f, 0.01050394f, 0.03005818f, 0.01302344f, 0.00170315f, -0.05116897f, -0.02539299f, -0.02464866f, 
    -0.02021657f, 0.01575797f, -0.04316368f, -0.04331174f, 0.03658084f, -0.02783353f, -0.02371864f, 0.04137433f, 
    -0.02382027f, -0.04288945f, 0.02893211f, 0.00999135f, 0.01876634f, -0.03958457f, 0.01586304f, -0.00494058f, 
    -0.03841933f, -0.05184616f, -0.03052491f, -0.05082004f, -0.02974864f, -0.03908124f, 0.01864904f, -0.02192989f, 
    0.02551453f, -0.00906014f, -0.01139378f, 0.02550710f, -0.00837201f, -0.03054882f, -0.04338885f, -0.04962487f, 
    -0.04178314f, -0.00520947f, 0.01908621f, 0.02246265f, -0.00946621f, 0.01474832f, -0.02218066f, 0.03843383f, 
    0.04315291f, -0.04570185f, -0.00192059f, 0.03029195f, -0.04083650f, 0.03540203f, -0.04068541f, -0.03678198f, 
    0.00547000f, -0.03050064f, -0.04167066f, 0.03112534f, 0.00509049f, -0.00313505f, 0.03017102f, 0.03212463f, 
    0.00785751f, -0.04674793f, 0.01402386f, 0.01288275f, -0.03950852f, -0.00128911f, -0.04539110f, 0.03853587f, 
    0.02973726f, 0.00292544f, 0.03907910f, 0.03304819f, -0.02178974f, -0.03355217f, 0.04140539f, -0.02087648f, 
    -0.04391740f, -0.00043801f, -0.02049387f, -0.00067748f, -0.04717938f, 0.02816951f, -0.00742039f, 0.00244537f, 
    0.02986304f, -0.01586499f, -0.00451049f, -0.00304398f, -0.05372472f, 0.00510049f, -0.05584815f, -0.03418009f, 
    -0.00981484f, -0.03263232f, -0.01834373f, -0.04690937f, -0.03263485f, -0.03500914f, -0.03256175f, 0.00795686f, 
    -0.01106517f, -0.03810331f, 0.00843956f, 0.03022373f, 0.00659008f, 0.04087272f, 0.01901926f, -0.04336694f, 
    -0.00499057f, -0.04690580f, 0.03291323f, -0.04694428f, 0.02413346f, -0.04556165f, 0.01097992f, 0.00931680f, 
    0.50223434f, 0.03243617f, -0.02253978f, -0.44854793f, 0.03693694f, 0.10770816f, 0.05515312f, 0.05771475f, 
    0.00648522f, -0.07669191f, 0.00980211f, -0.01502556f, 0.01384979f, 0.02762696f, 0.00956646f, 0.22765990f, 
    0.04871164f, -0.00756164f, -0.20315906f, 0.13494188f, -0.11840290f, -0.06925330f, 0.00163742f, -0.09482842f, 
    -0.08808269f, 0.11514845f, 0.09705298f, -0.18280371f, -0.02321768f, 0.06119050f, -0.04300493f, -0.19824366f, 
    -0.00383518f, 0.19290578f, 0.12617655f, -0.08368202f, 0.41289255f, 0.21759196f, -0.02464344f, 0.19612823f, 
    -0.01978185f, 0.11670210f, 0.00314138f, 0.00449399f, 0.03239926f, -0.18609974f, -0.23318034f, -0.05497868f, 
    -0.15900616f, 0.04864937f, -0.34936219f, 0.06071764f, -0.05270298f, -0.02956651f, -0.02054805f, 0.05364370f, 
    0.00656286f, -0.11249155f, -0.03734670f, 0.03171778f, 0.16657001f, -0.02691961f, -0.06744567f, 0.12568600f, 
    -0.05676635f, -0.07353897f, 0.11454733f, 0.05906692f, 0.03523567f, 0.04552117f, 0.01042718f, -0.01717585f, 
    0.31717384f, -0.25390419f, -0.26972887f, 0.32922074f, 0.03482765f, -0.01017933f, -0.06786305f, 0.06957723f, 
    -0.18887669f, 0.05282005f, -0.05391805f, -0.02980523f, 0.02071981f, 0.35737339f, -0.06814957f, 0.22324677f, 
    0.18478079f, 0.16964480f, -0.03193190f, 0.07738662f, -0.18141317f, -0.07205330f, 0.08882610f, 0.06532787f, 
    -0.05986900f, 0.25073603f, -0.01534817f, 0.07379353f, -0.02863276f, -0.00961152f, 0.06506883f, 0.07531363f, 
    0.04741612f, -0.15766013f, 0.06818414f, -0.15345964f, 0.17451940f, 0.01251026f, 0.16808699f, 0.28183529f, 
    -0.03201145f, 0.07952627f, 0.05253551f, 0.01452324f, -0.08519503f, -0.13288613f, -0.01431961f, -0.02154598f, 
    0.13359281f, -0.06422783f, -0.07626008f, -0.31150764f, -0.01124640f, 0.09763268f, -0.02838262f, 0.12476373f, 
    -0.19174816f, 0.14196193f, 0.09890257f, -0.14993192f, -0.09715812f, 0.12957960f, -0.00373349f, 0.23631144f, 
    0.02879300f, 0.19531052f, -0.05588336f, -0.25561497f, 0.10244197f, -0.05524598f, -0.14789692f, -0.03508595f, 
    0.36978492f, -0.05716684f, 0.19939323f, 0.19532433f, 0.12789284f, 0.00106390f, 0.14967796f, -0.03722091f, 
    -0.07738984f, 0.02303384f, -0.05195688f, 0.09623065f, -0.00777563f, -0.23141624f, 0.21291319f, 0.27930704f, 
    -0.02161295f, 0.00122285f, 0.01401970f, 0.05349336f, -0.07970431f, 0.08934662f, 0.17045301f, -0.05767645f, 
    0.00149472f, -0.36124977f, -0.00263700f, 0.49472594f, 0.05169926f, 0.03072963f, 0.03065009f, -0.11029038f, 
    0.04805553f, -0.03030032f, -0.19223863f, -0.08260351f, -0.32061943f, 0.02223822f, -0.11297051f, 0.04825671f, 
    0.06558035f, -0.05301686f, -0.03589981f, -0.11405329f, -0.12261432f, -0.11778534f, -0.07151145f, -0.06647404f, 
    0.43330190f, 0.27061257f, -0.43062094f, -0.10866677f, 0.07653514f, -0.06562408f, 0.06605040f, -0.09036113f, 
    -0.07725860f, -0.10122427f, 0.05078245f, 0.05507442f, -0.28157747f, -0.16091464f, 0.11465957f, 0.02522825f, 
    -0.00849653f, 0.07773482f, 0.03526918f, 0.00317489f, 0.06802946f, 0.09322826f, 0.09167285f, -0.11323665f, 
    0.06699692f, 0.20086257f, -0.23005417f, 0.10477237f, 0.10922835f, -0.11646920f, -0.05723735f, 0.10117184f, 
    0.05537638f, 0.13415389f, 0.16357991f, -0.04129661f, 0.44000861f, 0.49129933f, -0.21249552f, 0.06761588f, 
    0.09138194f, -0.11390106f, 0.09622680f, -0.04178107f, -0.01195560f, -0.11823477f, 0.03133298f, -0.01081933f, 
    0.05165382f, 0.26072147f, -0.32199970f, 0.30216575f, 0.14223354f, -0.14068769f, 0.06160348f, -0.07469234f, 
    0.04262900f, 0.07481254f, 0.08831298f, -0.02091441f, 0.04719571f, 0.31282088f, -0.24194622f, 0.45289969f, 
    -0.01818663f, -0.08700208f, -0.08047438f, -0.03172653f, -0.03522320f, 0.12892950f, -0.11071699f, 0.10222794f, 
    -0.00139742f, 0.20059194f, 0.26055700f, -0.30385432f, -0.01065059f, 0.02194782f, 0.15036739f, -0.04413607f, 
    0.02612536f, -0.15192914f, 0.11874017f, 0.00266881f, -0.08185611f, -0.20138213f, 0.14422771f, -0.12941606f, 
    -0.10534644f, -0.03940523f, 0.12619559f, -0.07320842f, 0.03839791f, -0.07884309f, 0.02183143f, -0.05365585f, 
    -0.26939380f, -0.02889303f, 0.17021896f, -0.10503940f, 0.24216221f, -0.06553052f, 0.00565377f, -0.07592329f, 
    0.12931722f, 0.02173892f, 0.00116135f, 0.09589874f, 0.14173463f, -0.18714176f, -0.01591378f, 0.02245812f, 
    0.11120290f, -0.05058162f, 0.02451230f, 0.17262688f, 0.09849995f, 0.04579945f, 0.16016510f, 0.17694926f, 
    0.03001497f, 0.14228182f, 0.00707951f, 0.13489509f, 0.01216417f, 0.05636638f, -0.13848835f, 0.00341007f, 
    0.02804678f, 0.06325334f, -0.03474317f, 0.03128885f, 0.23190245f, 0.12936810f, -0.28659564f, 0.22236425f, 
    0.06776804f, -0.06641155f, 0.00617585f, -0.04930618f, -0.09627201f, -0.12190361f, -0.16414195f, -0.05574369f, 
    0.41942677f, 0.05513468f, 0.01083523f, 0.04831870f, 0.06027889f, -0.01975661f, 0.05855151f, 0.05458854f, 
    0.01656980f, 0.00225023f, 0.00990974f, -0.06348248f, 0.27828324f, 0.06052095f, -0.20778193f, 0.27664921f, 
    -0.15566675f, 0.02009900f, 0.08519273f, -0.09374207f, 0.02645846f, -0.06197696f, -0.08009577f, -0.02196387f, 
    -0.18709488f, -0.00388509f, 0.05213521f, 0.03485424f, -0.04260446f, 0.14805551f, -0.03811809f, 0.21048306f, 
    -0.03461103f, 0.05380784f, 0.01790638f, 0.07299262f, -0.08227167f, 0.26565912f, -0.18338037f, 0.17998634f, 
    0.07091949f, -0.02565956f, 0.02094597f, 0.03150158f, -0.01553725f, 0.11412511f, 0.03179812f, 0.07529054f, 
    -0.01376934f, -0.16119742f, -0.13012160f, 0.28482538f, -0.09414047f, -0.06403843f, 0.06690488f, -0.03641965f, 
    0.04361922f, -0.11128627f, -0.05592924f, 0.12834597f, -0.02516842f, 0.03020466f, 0.09639273f, -0.14506325f, 
    0.09936203f, 0.07927216f, -0.06930125f, 0.09986535f, -0.03651161f, -0.05482368f, 0.02112787f, 0.03951265f, 
    0.41270572f, 0.01763717f, -0.25334945f, -0.09308569f, 0.12838663f, -0.01344829f, 0.22986144f, 0.21311244f, 
    0.09686467f, -0.03223517f, 0.11429656f, -0.08261807f, -0.05482123f, -0.05174418f, 0.04111414f, -0.08046383f, 
    0.02026255f, 0.08441796f, -0.07106594f, 0.13687779f, 0.02234051f, 0.08704042f, 0.15040316f, -0.03527632f, 
    0.07842868f, -0.08323169f, 0.00881690f, 0.00444879f, 0.04999353f, 0.10194763f, -0.07456109f, 0.15368576f, 
    -0.07548948f, -0.07240184f, -0.01098354f, -0.02704243f, -0.36437505f, -0.18744273f, 0.02938494f, 0.04076302f, 
    0.02990071f, 0.12437506f, 0.01384271f, 0.11616088f, -0.13440184f, 0.03873255f, 0.05518772f, -0.04763489f, 
    -0.04033654f, 0.25600973f, -0.14220598f, 0.04884237f, 0.11378382f, 0.03083999f, -0.12061550f, -0.00353930f, 
    0.00113340f, 0.00203835f, 0.17549823f, -0.13970126f, 0.06874838f, -0.08601487f, 0.11248372f, 0.05672123f, 
    -0.15377231f, -0.12719573f, 0.05804803f, -0.04446466f, 0.11500664f, -0.02887380f, 0.09242254f, 0.04018158f, 
    -0.35786945f, 0.10428514f, -0.09191324f, -0.20980020f, -0.03589893f, 0.01906536f, -0.02633412f, 0.07931662f, 
    -0.04374382f, -0.11780265f, 0.06520767f, -0.04024183f, -0.13602196f, -0.04132635f, -0.20518890f, 0.03449804f, 
    -0.00400644f, 0.05921378f, 0.03166576f, -0.03027339f, -0.05360331f, -0.01917287f, 0.07409195f, 0.06417928f, 
    -0.06162624f, -0.01883049f, -0.22872539f, 0.04199103f, 0.03651349f, -0.00072671f, 0.02238827f, -0.02301275f, 
    0.01727792f, 0.06276421f, 0.10801035f, 0.06998235f, -0.16881192f, 0.09743959f, 0.14128028f, -0.10880872f, 
    -0.19836828f, 0.12687877f, -0.00632169f, 0.14511269f, 0.07832874f, -0.15757395f, -0.05459606f, 0.03375737f, 
    -0.01742140f, -0.30246884f, -0.23624146f, 0.09542403f, -0.02135830f, 0.04032935f, 0.03588451f, 0.06615500f, 
    0.10666127f, 0.05375667f, -0.04255132f, 0.01822320f, 0.30688742f, 0.18344896f, 0.07058745f, -0.19554865f, 
    0.13875344f, 0.13017288f, -0.05142717f, 0.11902006f, -0.06805481f, 0.13291934f, -0.06949216f, -0.11891035f, 
    0.17523070f, -0.06430224f, 0.05880331f, 0.15682049f, -0.00020535f, 0.05922838f, -0.01693884f, 0.08751839f, 
    -0.10477760f, -0.01470482f, -0.11134395f, -0.13648702f, 0.33882520f, 0.02185225f, 0.11893595f, 0.19135652f, 
    0.18164834f, 0.09520154f, 0.04470794f, 0.04081039f, -0.03564845f, -0.03004650f, -0.05685247f, -0.13616288f, 
    0.02095174f, -0.03455522f, -0.27817434f, -0.14424266f, -0.07454749f, -0.02614248f, 0.07861959f, 0.09913683f, 
    -0.04870888f, -0.03265859f, -0.14351596f, 0.00283694f, 0.58660853f, 0.20752753f, 0.00436525f, -0.08304551f, 
    -0.04855634f, -0.04054649f, -0.01442862f, 0.05214733f, 0.01460447f, -0.05589373f, -0.06225044f, 0.02924438f, 
    -0.01528129f, -0.10900575f, 0.20334598f, -0.19866671f, 0.11090834f, -0.03994139f, 0.19597407f, 0.04691087f, 
    -0.10483275f, -0.11685546f, 0.17781135f, -0.09147431f, 0.36018252f, 0.01151095f, 0.02657262f, -0.28274325f, 
    0.05752531f, 0.09038910f, 0.07103518f, 0.04260707f, -0.05627494f, 0.08622915f, 0.02393982f, 0.13780555f, 
    0.39834070f, 0.05682083f, -0.08634268f, 0.02351615f, 0.17974229f, 0.06734353f, 0.01614756f, -0.03376513f, 
    0.13705359f, 0.07603081f, -0.04808296f, -0.04396874f, -0.12102028f, 0.32556427f, 0.19775571f, -0.06587350f, 
    -0.03585128f, -0.04829326f, 0.01908593f, 0.13883504f, -0.11142185f, 0.01973102f, 0.13994111f, -0.07076325f, 
    -0.11484367f, 0.19192232f, 0.11986978f, 0.31959921f, 0.01009103f, 0.03934323f, -0.21062537f, 0.01165689f, 
    -0.04763925f, -0.04970788f, -0.08245904f, -0.03660834f, 0.06672839f, 0.07070677f, -0.03752507f, -0.13256130f, 
    0.04095135f, 0.03994461f, 0.07580382f, 0.17030469f, -0.05415179f, 0.06954540f, 0.00958698f, 0.00702665f, 
    -0.37886000f, -0.08350257f, -0.17181855f, 0.08071119f, -0.00485876f, -0.00358942f, 0.09461079f, 0.04904474f, 
    0.01562015f, 0.01085804f, -0.08865186f, 0.08526041f, 0.29049057f, -0.03133185f, -0.03085377f, 0.02740072f, 
    0.04004801f, -0.04365766f, -0.00053311f, 0.06880906f, 0.05969842f, 0.01983056f, -0.19824335f, 0.00979220f, 
    0.50479579f, -0.01946924f, -0.05102746f, -0.08400913f, 0.05306442f, 0.00449972f, 0.06536679f, 0.00515722f, 
    0.09099647f, 0.03018798f, 0.15128486f, 0.02681578f, 0.29206640f, -0.02123900f, 0.03807044f, 0.11957452f, 
    0.04231119f, -0.03079796f, 0.25386447f, 0.04978143f, 0.11797603f, 0.17247161f, -0.04868556f, -0.05024306f, 
    -0.19815862f, 0.52694035f, -0.04691790f, 0.13990629f, -0.02551289f, 0.10360932f, -0.10140686f, 0.10822257f, 
    0.04533308f, 0.09239805f, -0.16283286f, -0.13323124f, 0.05152343f, -0.06232305f, 0.17759639f, -0.20248608f, 
    -0.04648937f, 0.08452737f, -0.02998172f, -0.15136214f, -0.01216231f, 0.13401760f, -0.03822548f, 0.03978925f, 
    -0.08045456f, 0.09010807f, -0.02374344f, -0.11002094f, -0.00232608f, 0.05964682f, -0.06520439f, 0.06546184f, 
    0.10688198f, -0.00946482f, 0.05557872f, 0.01097882f, 0.26599824f, -0.06724028f, 0.01410594f, 0.09803375f, 
    0.05994947f, -0.17248580f, 0.03012148f, -0.13458884f, -0.08583082f, -0.00026283f, 0.00912157f, -0.06643346f, 
    -0.32704177f, 0.00048360f, 0.04998909f, -0.22098853f, -0.01919501f, 0.24316792f, 0.03765823f, 0.10636951f, 
    -0.16377543f, 0.12914844f, 0.16239940f, 0.07661217f, 0.17970799f, 0.07796777f, -0.16125154f, 0.02696575f, 
    -0.06232060f, 0.12458607f, 0.02134188f, -0.03968041f, -0.03180035f, 0.05511168f, -0.01563624f, -0.01155079f, 
    0.09082261f, 0.14393811f, 0.06169589f, -0.06752251f, -0.04978032f, 0.01252148f, -0.19002017f, -0.24192290f, 
    0.04135013f, -0.08337979f, -0.02827277f, 0.09807368f, -0.05259848f, 0.25530988f, -0.14412275f, 0.10437781f, 
    -0.08284687f, 0.12822372f, 0.18184192f, 0.04627230f, -0.01303233f, 0.03337873f, -0.04180497f, 0.04066924f, 
    -0.35793447f, 0.08150267f, -0.00539721f, 0.24194477f, 0.10005240f, 0.08065069f, -0.08573160f, -0.26774862f, 
    0.18163212f, 0.07430989f, 0.01594365f, 0.00150429f, 0.40565518f, 0.20172027f, -0.03766788f, 0.05348545f, 
    -0.00311812f, -0.07611238f, 0.20116940f, -0.03543257f, -0.00297613f, 0.02152022f, -0.07823355f, 0.06882799f, 
    0.11308079f, 0.10880422f, 0.27579787f, 0.12674633f, -0.04965688f, -0.02469733f, 0.15325205f, 0.02277219f, 
    0.01797476f, 0.04300643f, -0.19465744f, 0.12231886f, -0.04969859f, -0.04126772f, -0.22119750f, 0.16098972f, 
    0.08384533f, 0.20181987f, 0.04218265f, 0.12908246f, -0.07050054f, 0.01195612f, -0.11191698f, -0.03730593f, 
    -0.00963373f, 0.07734907f, -0.09086127f, 0.02916079f, -0.11539412f, -0.01757349f, 0.15196934f, -0.03576535f, 
    0.07482607f, -0.05193147f, -0.09337805f, 0.07434811f, -0.03782954f, 0.06016088f, 0.07250058f, -0.01741688f, 
    0.03186004f, 0.00867552f, 0.07066112f, 0.06060413f, 0.03291036f, 0.09389759f, -0.14965278f, 0.04220697f, 
    0.10713962f, 0.01472895f, 0.07802083f, 0.00667530f, 0.07500789f, 0.18751486f, -0.07506555f, 0.13020626f, 
    0.06436659f, 0.02997135f, -0.04762724f, 0.00610888f, 0.34659800f, 0.20089166f, -0.08173461f, 0.03813157f, 
    0.10622045f, -0.07186916f, -0.02741468f, -0.03546348f, -0.07388394f, 0.17425022f, 0.11793842f, 0.06615590f, 
    -0.16986206f, -0.08996402f, 0.12618156f, 0.02729661f, 0.00995872f, -0.05631711f, 0.12270623f, -0.04915987f, 
    -0.16222443f, -0.00079929f, -0.01215935f, 0.09455568f, -0.05624795f, 0.05335784f, 0.11438411f, 0.16762494f, 
    -0.06312837f, -0.09546685f, 0.00202094f, -0.06599084f, 0.07000402f, -0.15555465f, 0.02454726f, 0.13785452f, 
    -0.21325646f, 0.08273998f, 0.13489281f, -0.05065625f, 0.11347744f, 0.00755265f, -0.00795333f, -0.11704576f, 
    0.09647792f, -0.10216221f, 0.13885185f, 0.08311246f, 0.10907570f, 0.01002042f, 0.03080970f, -0.04150152f, 
    -0.05116925f, 0.01062102f, -0.07907789f, -0.19572213f, -0.04561444f, -0.01665322f, 0.16577114f, 0.10463104f, 
    -0.30005229f, -0.13980898f, 0.16496867f, 0.16155712f, 0.11636354f, 0.01259293f, -0.12390782f, -0.05875054f, 
    0.09537367f, 0.07273746f, 0.03180964f, 0.08412086f, -0.34078088f, 0.18105097f, -0.00258930f, 0.00912427f, 
    -0.03880122f, -0.06848787f, 0.01362409f, 0.02255307f, 0.05622043f, -0.07051105f, 0.02515995f, 0.01078714f, 
    -0.32605228f, -0.25575340f, -0.06466848f, 0.05980494f, -0.02851149f, 0.07414532f, -0.11647592f, -0.01392945f, 
    -0.03221592f, 0.12603982f, -0.10129766f, 0.04204179f, -0.51693100f, -0.31428447f, -0.00753407f, 0.17245637f, 
    -0.07853884f, -0.07123383f, 0.10878899f, -0.12213060f, 0.03486634f, -0.09920320f, -0.10138628f, -0.14149038f, 
    -0.06686212f, -0.11973510f, 0.31309512f, 0.17628185f, -0.00939122f, 0.08492261f, -0.06283846f, 0.00473244f, 
    -0.04552256f, -0.03531248f, 0.01357409f, 0.10229325f, 0.11031225f, -0.00556919f, -0.07220110f, 0.09559324f, 
    0.02571094f, 0.01027899f, 0.11766820f, -0.09958403f, 0.09128515f, 0.00721761f, -0.00744271f, 0.03041330f, 
    0.26384676f, -0.08788738f, -0.18026437f, -0.26065099f, 0.15238306f, -0.04728853f, 0.16691464f, -0.03016360f, 
    0.02516654f, -0.06587447f, -0.02186844f, 0.01913204f, -0.02526776f, 0.15986080f, 0.08678313f, 0.00796287f, 
    -0.09883451f, -0.04196015f, 0.01595407f, -0.17690220f, -0.05040560f, -0.02996890f, -0.06227513f, 0.00412657f, 
    0.11205118f, 0.25720078f, -0.05676519f, -0.10097300f, 0.00493763f, 0.03202490f, 0.02888134f, -0.00307375f, 
    -0.04613734f, -0.02939354f, 0.13448228f, -0.07508866f, -0.10718589f, 0.10627110f, 0.18456215f, 0.09363704f, 
    0.05628171f, 0.12527886f, 0.11306254f, 0.03146709f, 0.05724704f, 0.07307637f, 0.26713696f, 0.06343077f, 
    -0.02255027f, 0.06426144f, 0.15672313f, 0.26501447f, -0.02492226f, 0.05022224f, 0.13080662f, -0.04504515f, 
    0.05240806f, -0.03609115f, -0.09681282f, -0.12580089f, -0.30557081f, -0.07345963f, -0.02702280f, 0.00654891f, 
    0.04086293f, 0.06793331f, 0.02770315f, -0.14832045f, 0.01328279f, -0.08288503f, 0.09422484f, 0.05169543f, 
    0.13226299f, 0.08042435f, 0.15677452f, -0.05396320f, 0.14190589f, 0.05575098f, 0.15639423f, -0.02600729f, 
    -0.12612647f, -0.03862916f, 0.14481576f, 0.01831650f, -0.06728115f, -0.03012511f, 0.03172876f, 0.09416943f, 
    0.00960183f, -0.03232206f, 0.17113407f, 0.01305812f, 0.04541089f, -0.00022989f, 0.05243548f, 0.06900863f, 
    0.38004962f, 0.13654572f, 0.11723457f, 0.02978514f, 0.11116972f, -0.05061330f, 0.05185210f, 0.15285216f, 
    -0.07834158f, 0.08713282f, -0.06358168f, -0.05999817f, -0.23011369f, 0.08416105f, -0.15755562f, 0.06494337f, 
    -0.14418910f, 0.18138090f, 0.09572700f, -0.09794082f, -0.08001926f, -0.04624042f, 0.01543310f, 0.18909311f, 
    -0.16962667f, 0.02165534f, 0.14409325f, -0.22249860f, 0.07702047f, -0.05968038f, 0.06224813f, 0.02441652f, 
    0.00297989f, 0.12126588f, -0.26534280f, -0.10770172f, 0.03525741f, 0.42375651f, 0.22717914f, 0.13453782f, 
    0.02128574f, 0.02894961f, -0.00546051f, 0.14990021f, -0.04756396f, 0.06621291f, 0.01200939f, -0.01596676f, 
    -0.03442034f, -0.04701740f, 0.17981809f, 0.22645234f, 0.02557348f, 0.03985176f, -0.07080121f, 0.01246847f, 
    0.05439910f, -0.05160740f, -0.15311207f, -0.11888658f, 0.10894350f, 0.17739208f, -0.00759143f, 0.00681233f, 
    0.04494432f, 0.16146871f, -0.04052093f, 0.04617564f, 0.00426121f, -0.02266282f, -0.06643797f, -0.11318824f, 
    0.09627977f, 0.05014656f, -0.18523566f, -0.04546466f, 0.04795905f, 0.05059658f, 0.08188559f, 0.03178672f, 
    -0.02549492f, 0.04044249f, 0.05144219f, -0.01563064f, -0.10642485f, 0.07122377f, -0.22416463f, -0.05350087f, 
    0.01973066f, 0.06237968f, -0.02720304f, 0.07401079f, 0.18794774f, 0.00407657f, 0.10423870f, 0.25425297f, 
    0.31233671f, 0.04865947f, -0.04965234f, -0.23942477f, 0.02341688f, 0.13204868f, -0.03778164f, 0.07695393f, 
    0.01007265f, -0.08745068f, 0.05906767f, -0.21371131f, -0.13542968f, 0.20440875f, 0.13353652f, 0.25852278f, 
    0.05592910f, -0.21243657f, -0.06979922f, 0.00629283f, -0.10191864f, -0.10494958f, 0.15157227f, 0.13070276f, 
    0.40447515f, -0.22086348f, 0.10506631f, 0.14767380f, 0.08438172f, 0.01144264f, -0.02267678f, -0.01590092f, 
    -0.25376734f, -0.04611555f, -0.02547548f, -0.03286560f, 0.37779203f, -0.15038791f, -0.09892861f, -0.09111614f, 
    -0.15739770f, 0.03123246f, 0.12325764f, -0.00651489f, 0.04346478f, -0.00935929f, 0.03581630f, 0.02872174f, 
    0.15169451f, 0.18597083f, 0.23924249f, -0.06152802f, -0.01850367f, 0.03248928f, 0.13245423f, -0.06502296f, 
    0.08369847f, -0.02499432f, -0.02674068f, -0.02748985f, 0.11302301f, 0.05273728f, 0.05902586f, -0.00883277f, 
    0.07053458f, -0.08234283f, 0.08682315f, 0.00500786f, -0.09381674f, 0.06744823f, -0.07832264f, -0.15855663f, 
    -0.25028032f, 0.26465517f, -0.24868166f, -0.31697065f, 0.10496952f, -0.04818784f, -0.02490514f, -0.00048541f, 
    -0.01674834f, 0.14781362f, 0.06127242f, -0.10702689f, 0.27438065f, -0.18604094f, -0.32040545f, 0.05951526f, 
    -0.08822010f, -0.02013094f, -0.10809373f, 0.06940068f, -0.06739885f, -0.00895886f, 0.09156186f, 0.03316229f, 
    -0.00785121f, 0.04078290f, -0.31026480f, -0.23917401f, 0.10505933f, -0.06051268f, 0.07138620f, 0.03805900f, 
    -0.07523964f, -0.02940043f, 0.03696661f, -0.19830140f, 0.18258688f, 0.12966922f, -0.10637590f, -0.08854859f, 
    -0.03160844f, -0.00933291f, 0.08198155f, -0.02902902f, 0.09694669f, -0.07065392f, -0.05816908f, -0.11568868f, 
    -0.25355539f, 0.12549540f, 0.04865869f, 0.00815960f, 0.10556786f, 0.21250392f, -0.01782852f, -0.09100536f, 
    -0.11511403f, 0.21407530f, 0.06285717f, 0.09675042f, 0.06896474f, -0.22487442f, 0.16002941f, 0.23688225f, 
    -0.08678870f, 0.01047354f, 0.02354065f, 0.18908229f, -0.05256898f, -0.00620808f, 0.00812560f, 0.08443065f, 
    -0.28062913f, 0.16761850f, -0.13052313f, 0.42608202f, -0.07236137f, 0.10689921f, 0.10660067f, 0.10569999f, 
    0.10610183f, 0.01801836f, 0.10239987f, 0.09079676f, -0.27190369f, 0.12563756f, 0.06548390f, 0.18217409f, 
    0.05164612f, -0.01046556f, 0.01696647f, -0.13797797f, 0.01116613f, 0.02892387f, -0.04355914f, -0.06013995f, 
    -0.39274174f, 0.14093801f, -0.08571190f, -0.36805865f, 0.05761061f, 0.16082285f, 0.03852073f, -0.17145224f, 
    0.14563361f, 0.00964038f, -0.01550701f, -0.03009382f, -0.03767209f, 0.06686962f, -0.27473634f, 0.19084114f, 
    -0.00168632f, -0.01844342f, -0.01900038f, 0.00977294f, 0.10279462f, -0.14768441f, 0.09387202f, 0.03970992f, 
    0.61299962f, -0.00932921f, -0.15868631f, -0.15209723f, -0.08966296f, -0.06702992f, 0.08796679f, -0.00093064f, 
    0.02458151f, 0.20604961f, 0.04260498f, -0.11307363f, 0.18165907f, -0.24837494f, 0.00650686f, 0.10827126f, 
    -0.01895483f, -0.08425194f, 0.14479756f, 0.06768876f, 0.06987941f, 0.02949347f, 0.01974161f, 0.01297149f, 
    0.27604645f, -0.18608201f, -0.00200816f, -0.24188168f, 0.14919966f, -0.04783508f, -0.00277724f, 0.02345324f, 
    -0.02508067f, 0.02733066f, -0.04685802f, 0.27148837f, -0.17491068f, 0.04579660f, -0.07460038f, -0.15413454f, 
    0.04683580f, 0.09417903f, 0.03329175f, -0.19854157f, 0.07540114f, 0.11117744f, -0.02722461f, 0.28942958f, 
    -0.38170767f, -0.02990115f, -0.07322964f, -0.01303676f, 0.10758640f, 0.14360033f, 0.05919038f, 0.13953149f, 
    -0.03275934f, 0.04010274f, 0.19445415f, 0.08766269f, -0.08766100f, -0.04639159f, 0.11407135f, -0.05934248f, 
    0.11732110f, -0.06816886f, 0.00641532f, -0.09090761f, -0.06855748f, -0.09334600f, 0.06762148f, -0.09974657f, 
    0.39018396f, -0.23033661f, 0.05451566f, -0.13170345f, -0.07790282f, 0.05119089f, 0.13706106f, -0.03545024f, 
    0.06996135f, -0.08131995f, 0.02029655f, 0.01331882f, -0.26003283f, 0.06673642f, 0.11279580f, 0.37162128f, 
    0.02725495f, 0.05736519f, 0.06232622f, -0.01367471f, 0.03087304f, 0.01863827f, -0.04884955f, -0.11740695f, 
    0.31998342f, -0.19244702f, 0.02940028f, 0.13619745f, 0.12289178f, 0.03917258f, 0.07546902f, 0.05580384f, 
    -0.03143646f, 0.01295909f, 0.01769027f, 0.08029021f, -0.22102313f, 0.16344526f, 0.16191560f, 0.38289255f, 
    -0.13609584f, -0.10039054f, 0.09168283f, 0.17630212f, -0.05995977f, 0.12930015f, -0.01653345f, 0.08980447f, 
    0.25041413f, -0.00411454f, -0.11832278f, -0.00333636f, 0.09644946f, -0.10109031f, -0.18294381f, 0.04114807f, 
    -0.01311328f, 0.00476187f, -0.01595045f, -0.02347272f, 0.12113579f, -0.13391238f, 0.01801296f, 0.15335833f, 
    -0.07949491f, 0.14104654f, 0.13182762f, -0.05430532f, 0.00562237f, 0.18793762f, 0.01914978f, 0.01625159f, 
    0.23044360f, -0.04573053f, 0.22875997f, -0.12745208f, 0.12372678f, 0.06570004f, 0.02292915f, -0.09426639f, 
    -0.10023911f, 0.04617616f, -0.00668049f, 0.14385372f, -0.05460935f, -0.03818729f, -0.05904836f, 0.17533384f, 
    0.10009304f, -0.02821814f, 0.12508789f, -0.06349020f, 0.07943121f, 0.09497661f, 0.05651988f, 0.17637233f, 
    -0.55844355f, -0.01163822f, 0.43195617f, 0.17990766f, -0.11234517f, -0.13487579f, 0.12599099f, -0.05318924f, 
    -0.12105557f, 0.09508111f, 0.04927740f, 0.15612319f, 0.17849538f, -0.03942017f, 0.05752356f, -0.21332362f, 
    -0.06213622f, 0.19740340f, 0.04398689f, -0.14053050f, 0.02933212f, -0.19582345f, -0.20186470f, -0.00960163f, 
    0.30930722f, 0.11198030f, -0.23695253f, 0.07730386f, 0.00441258f, -0.08378760f, 0.00535840f, -0.12427309f, 
    -0.03169065f, 0.16660370f, 0.07200122f, 0.15051515f, 0.05200810f, -0.04412530f, 0.15767360f, -0.29167905f, 
    -0.08687466f, -0.08679372f, -0.06971974f, -0.13021390f, 0.00936471f, 0.11689155f, -0.09317610f, -0.13269289f, 
    -0.25470206f, 0.25340268f, -0.32366177f, 0.10576443f, 0.11919915f, -0.07096813f, 0.05946663f, 0.05749603f, 
    0.11042883f, 0.16859058f, -0.05851568f, -0.02815047f, -0.36351532f, 0.15797049f, -0.21208513f, -0.09463374f, 
    0.18788470f, -0.16108277f, -0.22531034f, 0.04813525f, 0.10094743f, -0.04187629f, 0.11355428f, 0.00583425f, 
    -0.32858780f, -0.17955889f, 0.28461814f, -0.04009307f, -0.03656996f, -0.23931427f, -0.23060361f, 0.07759724f, 
    -0.04509505f, 0.00614095f, 0.03279033f, 0.08370725f, -0.00757723f, 0.21858339f, 0.02239680f, 0.03052319f, 
    -0.14919369f, 0.03296180f, 0.10942377f, 0.03634183f, 0.05459505f, 0.01904531f, 0.15204041f, 0.03374569f, 
    0.07463734f, -0.29175323f, 0.24087527f, -0.14621395f, -0.01079607f, -0.04660859f, -0.13504176f, 0.06189041f, 
    0.04910525f, -0.00630924f, 0.00011228f, 0.03792584f, -0.31945932f, 0.04521847f, -0.02154691f, 0.13354033f, 
    -0.06455689f, 0.09930074f, 0.17737579f, 0.09634657f, 0.13496444f, 0.05656008f, -0.08356131f, 0.03303541f, 
    0.01196438f, -0.19807211f, 0.18008611f, -0.12052269f, 0.09274761f, 0.10208011f, 0.02303072f, -0.00619658f, 
    0.19208537f, 0.06852752f, 0.06144186f, 0.37161368f, 0.29139721f, 0.07239341f, -0.07455035f, -0.10003290f, 
    -0.07882233f, -0.16046703f, 0.16008507f, 0.13590325f, -0.04338753f, 0.03147345f, 0.08621123f, 0.07640957f, 
    -0.14791718f, 0.37029856f, 0.17036983f, -0.00102268f, -0.03553455f, -0.06300734f, 0.04482392f, 0.07672605f, 
    0.17540003f, 0.02457994f, 0.23546325f, -0.00289847f, 0.24123430f, 0.04663962f, 0.00913925f, 0.02290271f, 
    -0.10554826f, -0.01299897f, 0.06212259f, -0.09187274f, -0.09175606f, 0.06526507f, -0.05514506f, -0.06339826f, 
    -0.19469745f, 0.06519707f, -0.07822287f, -0.13716963f, 0.26846787f, 0.11575885f, 0.04012414f, -0.18634924f, 
    0.15762949f, -0.15104626f, -0.25418824f, 0.13463140f, -0.06352673f, 0.27465841f, -0.15029638f, 0.04428811f, 
    0.12493675f, -0.06391476f, -0.04702010f, 0.18819562f, 0.15459645f, 0.22214323f, 0.07106550f, 0.04306621f, 
    -0.16796678f, 0.40275076f, -0.06337883f, 0.03108951f, 0.00566838f, -0.11434135f, 0.11132636f, 0.06516791f, 
    0.12881047f, -0.01487890f, 0.24876879f, 0.03431849f, 0.01124612f, 0.02572463f, -0.05638494f, -0.33185050f, 
    0.00142416f, 0.10498599f, 0.08192205f, -0.13041723f, -0.02013082f, 0.13773736f, -0.03199683f, -0.23059982f, 
    -0.07461894f, -0.07607228f, -0.05843046f, -0.07400939f, 0.00964473f, 0.14039034f, 0.05209874f, -0.07557599f, 
    0.10173945f, 0.15388206f, 0.12045903f, 0.15463865f, 0.23052771f, -0.19719760f, 0.01142349f, 0.11136059f, 
    -0.22229496f, 0.03493140f, -0.13876610f, 0.15780836f, 0.03032753f, -0.04561420f, -0.10638825f, 0.04836477f, 
    0.18111305f, -0.15142997f, -0.08178984f, -0.24309050f, 0.12801780f, -0.07506461f, -0.23736571f, 0.14483988f, 
    0.13411218f, 0.02191820f, -0.18850406f, -0.10030258f, 0.24769342f, -0.09332631f, -0.17701495f, -0.05901268f, 
    -0.00137257f, -0.10830694f, 0.00846575f, -0.07285883f, 0.10706856f, -0.12361632f, -0.04624831f, -0.05609833f, 
    -0.13244009f, -0.21256369f, -0.07501202f, 0.09485249f, 0.05457865f, -0.03686523f, 0.18551992f, -0.15740627f, 
    -0.00176410f, 0.05449036f, -0.10504550f, 0.11542001f, 0.23961687f, 0.09779859f, -0.16961910f, 0.10182332f, 
    0.11632795f, 0.16053113f, -0.06476294f, 0.18128332f, 0.21038754f, 0.15994810f, 0.05986483f, 0.24910070f, 
    0.27122721f, -0.03308894f, -0.22062378f, -0.28505152f, 0.12061912f, -0.07013544f, -0.00591349f, 0.05779148f, 
    0.00130874f, 0.04358127f, 0.01718616f, 0.05179644f, 0.18008576f, -0.19774053f, -0.30444300f, 0.15234697f, 
    0.09790457f, 0.02796766f, 0.07311523f, -0.07248899f, 0.07605359f, 0.06542824f, -0.04068900f, -0.05897779f, 
    -0.14027369f, 0.12568550f, -0.33782145f, 0.20764223f, -0.07068293f, 0.00115250f, -0.02303238f, -0.06576319f, 
    -0.06088688f, 0.01274382f, 0.14628822f, -0.20253664f, 0.01020270f, 0.12754767f, -0.02595245f, -0.05514320f, 
    0.05393913f, 0.03689690f, 0.13424088f, -0.11778782f, 0.22453973f, -0.26659051f, 0.05482742f, -0.16743717f, 
    -0.01162936f, 0.00195126f, 0.01116119f, 0.00487898f, -0.03304376f, -0.04744625f, -0.02412309f, 0.03809673f, 
    -0.04566377f, 0.03827617f, -0.01544187f, -0.05068408f, -0.04965520f, -0.04133827f, -0.04145255f, -0.02016014f, 
    -0.03752773f, 0.04232199f, 0.00605481f, 0.02104260f, -0.00934030f, -0.00287742f, -0.02061059f, -0.05422439f, 
    0.03717736f, 0.03756662f, 0.03018971f, 0.00121094f, -0.02802001f, -0.03237826f, -0.04658322f, -0.01242985f, 
    -0.00123964f, -0.02972319f, -0.04214734f, 0.02133111f, 0.02625933f, -0.03503748f, -0.01787106f, 0.03425437f, 
    -0.04536091f, -0.01384566f, -0.03051590f, 0.02993246f, -0.00401737f, 0.02449026f, 0.00509997f, 0.01997311f, 
    0.00763792f, 0.01247387f, 0.02685258f, 0.00097397f, -0.05588600f, 0.00301799f, -0.00108503f, 0.02964868f, 
    -0.04868738f, 0.03283136f, 0.03997238f, -0.02242073f, -0.05094650f, 0.01581889f, -0.00214895f, -0.04684351f, 
    0.00876395f, -0.03888987f, -0.04549798f, 0.01982453f, -0.01841939f, 0.01607759f, -0.02495601f, -0.03562445f, 
    -0.01822415f, 0.01030499f, 0.00769956f, -0.01880085f, 0.02492992f, -0.04649673f, 0.03000786f, 0.03846826f, 
    -0.04401846f, 0.01799355f, 0.04037551f, -0.02201384f, 0.01221569f, -0.00036051f, -0.04297050f, 0.02273514f, 
    0.00588462f, 0.02211417f, -0.03056088f, -0.03763058f, -0.01604892f, -0.00116746f, -0.03543606f, -0.03535059f, 
    -0.00196139f, 0.01996252f, -0.01219921f, -0.00661900f, 0.00139169f, -0.01970842f, 0.03322422f, -0.02798053f, 
    0.01633070f, -0.01907147f, -0.00378595f, -0.01410808f, 0.02712269f, -0.01851618f, -0.00387195f, -0.02846495f, 
    0.02909213f, -0.02570518f, 0.00315425f, -0.01201685f, -0.02752226f, 0.03486241f, 0.00237579f, -0.04842204f, 
    0.01125572f, 0.02374546f, 0.03193285f, -0.04840755f, -0.01931303f, -0.05587833f, 0.03357606f, 0.02382486f, 
    -0.00772328f, -0.03703907f, 0.04626625f, 0.00943956f, 0.00583045f, -0.05554681f, -0.05358353f, -0.05254495f, 
    0.04348285f, -0.03805692f, 0.00344703f, -0.05451999f, 0.03865869f, 0.01750331f, -0.02736826f, -0.04251532f, 
    0.00287994f, -0.05012418f, 0.00483765f, -0.04125221f, 0.04291400f, -0.03813840f, 0.03086047f, -0.05336719f, 
    0.00353767f, -0.02036781f, 0.03512111f, -0.04709415f, -0.05670318f, -0.05180535f, -0.05091178f, -0.01453453f, 
    0.02187664f, 0.02103678f, 0.03726671f, 0.01652119f, 0.00732554f, 0.03059372f, 0.01994018f, 0.01043166f, 
    -0.04636731f, 0.03660814f, -0.05354678f, -0.01484641f, -0.01582713f, -0.05285808f, -0.02716470f, -0.04473735f, 
    0.03904973f, -0.01219920f, 0.01726250f, 0.02811370f, 0.01163425f, -0.02504061f, 0.00908098f, -0.00028986f, 
    -0.02391793f, 0.02183013f, -0.04753952f, -0.00617335f, 0.02919432f, 0.03849934f, 0.03895551f, -0.04734341f, 
    0.01934413f, -0.03544421f, -0.01340084f, 0.02398148f, -0.04319336f, -0.04034347f, -0.03405371f, -0.01126968f, 
    -0.02989863f, 0.00756012f, -0.00383848f, -0.05658771f, -0.03293593f, 0.02183560f, -0.05153902f, 0.03390943f, 
    -0.00899435f, -0.04947340f, 0.03525656f, 0.03533377f, -0.04677225f, -0.04952421f, 0.02864265f, 0.00457749f, 
    0.01342318f, -0.03434878f, -0.03323065f, 0.03342514f, -0.00551799f, -0.01288149f, 0.02900269f, 0.04413727f, 
    -0.02137196f, 0.02881568f, 0.01723082f, -0.02756422f, -0.01873885f, -0.02801461f, -0.01010323f, 0.02487515f, 
    -0.00069304f, -0.04804285f, -0.03577403f, 0.04710043f, 0.01109122f, 0.01690898f, -0.04199461f, -0.00103897f, 
    -0.05320648f, 0.03105318f, 0.01941615f, 0.02146665f, 0.00604141f, -0.01969797f, -0.04174916f, 0.03767618f, 
    -0.03704227f, -0.02201452f, -0.00558991f, -0.00758783f, 0.01261261f, 0.03046937f, 0.01983678f, 0.02706138f, 
    0.01250782f, -0.01507888f, -0.01123190f, -0.03896935f, 0.04125946f, 0.00493271f, 0.01547145f, -0.01848311f, 
    0.01981428f, -0.00999768f, -0.01876924f, 0.00717905f, 0.03241430f, 0.00387197f, 0.04801870f, 0.04043572f, 
    -0.02474972f, 0.03074126f, 0.00067449f, -0.04009262f, -0.01252829f, -0.04051857f, -0.04789690f, 0.04111344f, 
    -0.01911190f, -0.03953016f, -0.04361746f, -0.00894332f, -0.05594737f, -0.02062923f, 0.02289722f, -0.05217068f, 
    -0.01366533f, -0.01291842f, -0.00781209f, -0.05535992f, -0.00981447f, -0.04363289f, -0.04132118f, -0.03417737f, 
    -0.00143399f, -0.02255224f, -0.02391413f, 0.02173879f, 0.00268285f, -0.05507410f, 0.01227705f, 0.04255046f, 
    0.01130283f, 0.00320340f, 0.00281230f, -0.03311421f, -0.05330062f, 0.03871807f, 0.00270279f, 0.01267658f, 
    -0.03828244f, -0.00400565f, -0.03662334f, 0.01559726f, -0.04152598f, -0.02136292f, 0.02112115f, 0.03564818f, 
    0.03657329f, -0.00771922f, -0.03734810f, -0.04581510f, -0.00264143f, 0.01559600f, -0.00886649f, 0.02112765f, 
    -0.01438755f, 0.00978022f, -0.01008637f, -0.01513029f, 0.00606791f, 0.04248582f, -0.01543980f, -0.00729342f, 
    -0.02064171f, 0.01060069f, -0.03528987f, -0.03542098f, -0.00066995f, 0.00528154f, -0.00819854f, -0.03546953f, 
    -0.02966429f, -0.03758845f, -0.00711128f, 0.01270685f, 0.00885153f, -0.03987841f, 0.02820740f, -0.00101132f, 
    -0.04351202f, -0.01759067f, 0.01202149f, 0.01908744f, -0.01585176f, -0.01009281f, -0.02852249f, -0.02514245f, 
    -0.01245491f, 0.01510801f, 0.02934197f, 0.03097505f, -0.01114399f, 0.02744831f, -0.03211455f, -0.00974167f, 
    0.01385700f, 0.00334757f, 0.00407050f, -0.01734383f, -0.04987220f, 0.02067515f, 0.00138104f, -0.05670638f, 
    -0.03240995f, -0.01603420f, -0.03697396f, -0.01560844f, -0.00812799f, 0.01760240f, -0.01226107f, 0.00657885f, 
    -0.06080986f, -0.07663694f, 0.10423195f, -0.06699300f, 0.14058223f, 0.00323672f, -0.06379069f, -0.00655345f, 
    0.03382900f, 0.05802232f, -0.02085921f, 0.00320331f, 0.27944517f, -0.11831690f, 0.02875818f, -0.03470020f, 
    -0.03580712f, -0.08519470f, 0.08592104f, -0.01359371f, 0.05166668f, -0.12025126f, 0.05667186f, 0.01549823f, 
    -0.38663870f, -0.18500297f, 0.20387730f, 0.16604736f, -0.10797711f, 0.07396387f, -0.10526434f, 0.01125996f, 
    -0.12839273f, 0.01666918f, 0.00124557f, 0.02932326f, 0.14920802f, -0.06005926f, 0.05911607f, -0.07011528f, 
    0.06882906f, -0.06585864f, 0.01983908f, -0.03319811f, 0.12645860f, -0.13843483f, -0.09003944f, 0.16492778f, 
    0.52453101f, -0.06720024f, -0.15284146f, -0.10325787f, -0.01818678f, -0.00057612f, 0.10892764f, -0.02640343f, 
    0.06624605f, 0.08739757f, 0.07150424f, 0.05395371f, 0.15197890f, 0.35085487f, 0.08700123f, -0.02170548f, 
    0.07231044f, -0.08635902f, -0.02202130f, -0.10566633f, 0.05977153f, 0.01936323f, -0.16022955f, -0.07618900f, 
    -0.07247517f, -0.30383340f, 0.18698302f, 0.05373992f, -0.11533690f, -0.16340272f, -0.06461245f, -0.05513380f, 
    0.21781726f, 0.00597275f, -0.08671169f, 0.12134375f, 0.25782716f, 0.21173702f, 0.07463551f, -0.00526409f, 
    0.25425223f, 0.22429658f, -0.01943543f, 0.17632727f, -0.04392058f, -0.04108626f, -0.03420399f, -0.06827807f, 
    0.54151994f, -0.49863410f, 0.33932051f, 0.04075159f, 0.06072900f, 0.17392108f, 0.01929871f, -0.15354684f, 
    0.11739709f, 0.01046877f, 0.00946085f, 0.00819958f, 0.11089543f, -0.15429011f, 0.27277207f, 0.02744271f, 
    0.12060031f, 0.12572987f, -0.09179664f, 0.05301059f, 0.08594660f, 0.03821033f, -0.06532039f, -0.03929280f, 
    0.21418343f, 0.22710356f, 0.19738884f, 0.19739011f, -0.10553245f, -0.06312753f, -0.00385281f, -0.14255697f, 
    0.14022140f, -0.02932508f, 0.01363959f, -0.19607210f, 0.00165037f, -0.24886249f, 0.03416544f, 0.12429474f, 
    0.01844941f, 0.02305678f, 0.01318087f, -0.15183958f, -0.05035671f, 0.04652183f, 0.00378878f, 0.06551959f, 
    -0.11963396f, 0.27110806f, -0.04410347f, -0.14342156f, 0.10001311f, -0.00478367f, 0.00849841f, -0.15478683f, 
    -0.18784913f, 0.00397578f, 0.15347683f, 0.00284877f, -0.42790931f, -0.24433883f, 0.15381750f, 0.13801187f, 
    0.02405068f, 0.00070363f, 0.05133588f, -0.14685547f, 0.09911821f, -0.01100861f, 0.12283659f, -0.00500309f, 
    -0.01255754f, 0.04800506f, -0.07105979f, -0.01062507f, -0.08043059f, -0.10878407f, -0.05682326f, 0.06234722f, 
    0.02683577f, 0.16613206f, 0.08765688f, 0.14585847f, -0.33219302f, -0.04999407f, -0.16443892f, -0.15305617f, 
    -0.05287334f, -0.01556858f, 0.11737897f, -0.05187660f, 0.02817735f, 0.12068837f, -0.00581452f, 0.21449605f, 
    0.33390063f, -0.14488186f, 0.02695078f, -0.10050341f, 0.09371135f, 0.09283441f, -0.09656832f, 0.01260919f, 
    0.01203736f, 0.03254509f, 0.05988317f, -0.11237586f, -0.44449240f, -0.09282529f, 0.05890344f, 0.03315103f, 
    0.15166578f, -0.00621593f, 0.04156804f, -0.01362143f, 0.01362082f, -0.00389505f, 0.04527653f, -0.06085790f, 
    0.37483388f, 0.36362794f, -0.02160033f, 0.07573105f, -0.08599364f, 0.04042453f, -0.18345167f, 0.03621015f, 
    0.04569154f, 0.02704691f, -0.01523868f, 0.00125382f, -0.29943073f, 0.32757765f, 0.11276090f, 0.10148307f, 
    -0.00012820f, 0.00175597f, -0.03240226f, 0.01451137f, 0.02029592f, -0.08744569f, 0.07462477f, -0.04984280f, 
    -0.16846937f, -0.12582083f, -0.02125615f, -0.07688854f, -0.13591236f, -0.03091940f, 0.05184515f, 0.06757428f, 
    -0.08527056f, -0.01949776f, -0.09062884f, -0.08895265f, 0.14290206f, -0.15276095f, -0.12328921f, 0.08920092f, 
    0.01989101f, 0.09184820f, -0.19741122f, 0.06491482f, 0.11993482f, 0.00860214f, -0.04087229f, -0.01867033f, 
    0.03432313f, -0.10012253f, -0.02543291f, -0.09977639f, 0.06835996f, 0.00822127f, -0.05274148f, 0.05447757f, 
    0.11696756f, 0.18770699f, 0.00122654f, 0.01185966f, -0.11134560f, 0.09812882f, -0.04104837f, -0.03425808f, 
    0.14657368f, 0.13491224f, -0.02706272f, -0.10775145f, 0.03425426f, 0.02789644f, 0.02619381f, 0.08455200f, 
    0.11760027f, -0.15904795f, 0.19068184f, -0.04612381f, 0.07114061f, -0.00241528f, 0.03397216f, -0.20839421f, 
    -0.09394470f, -0.01762841f, 0.02474164f, -0.03889323f, -0.42232162f, 0.10801165f, 0.15479358f, -0.02260550f, 
    0.01255805f, 0.15774170f, 0.01086432f, 0.03308987f, 0.02751494f, 0.03435311f, 0.05368787f, -0.16943857f, 
    -0.43752429f, 0.14900781f, 0.34281039f, 0.10566960f, -0.04536997f, 0.01063961f, -0.09355227f, 0.07014701f, 
    0.11664110f, 0.11260911f, 0.07567280f, 0.09109546f, 0.02321842f, 0.09234848f, 0.12268446f, -0.22130781f, 
    -0.12156254f, -0.02102245f, -0.10866568f, -0.02768875f, -0.09059131f, -0.09008507f, 0.04496853f, 0.03030869f, 
    0.24461076f, -0.36772135f, 0.06442669f, 0.07168535f, 0.02957251f, 0.01195403f, 0.04777421f, -0.02753010f, 
    -0.00290608f, -0.05177247f, 0.09199290f, 0.13478932f, -0.06968617f, 0.25693488f, -0.06247111f, -0.04031087f, 
    0.09937759f, 0.04777281f, -0.09599682f, 0.05898092f, 0.05758100f, -0.02213444f, 0.05600442f, 0.09092262f, 
    0.46706980f, 0.00415313f, 0.30303514f, 0.05213832f, -0.01103788f, 0.13215613f, 0.02911583f, -0.13622756f, 
    0.10906678f, -0.02756098f, 0.01225796f, 0.11751541f, -0.04524553f, 0.28465623f, 0.05429875f, -0.09967842f, 
    0.05330281f, 0.15780993f, -0.08562425f, 0.18994251f, 0.05866013f, 0.08051927f, -0.02268525f, 0.00422257f, 
    0.01871237f, 0.00693059f, 0.01598912f, -0.04434081f, 0.02325452f, -0.03909202f, -0.01940280f, 0.01311891f, 
    -0.05794520f, -0.01525353f, 0.02871685f, 0.04072834f, 0.03617366f, -0.01978959f, -0.03027874f, -0.02462026f, 
    -0.03383122f, 0.03223797f, -0.04646970f, -0.01754551f, -0.01260963f, 0.03617266f, -0.05588272f, 0.03028610f, 
    -0.00063478f, 0.02587713f, -0.03358356f, 0.01462723f, -0.04441642f, 0.02417955f, -0.03982310f, -0.04277198f, 
    0.00139265f, 0.03191236f, -0.00349129f, 0.02814435f, 0.03396462f, -0.04264060f, 0.03870874f, 0.00860589f, 
    -0.02494690f, 0.03155005f, -0.04970765f, -0.05220927f, -0.04935925f, -0.01615497f, -0.03851281f, -0.05280910f, 
    -0.01549712f, -0.00888832f, -0.05301626f, 0.00428251f, 0.00910335f, 0.04329107f, -0.01403509f, -0.03533871f, 
    0.03153543f, -0.03105627f, -0.03635647f, 0.03723240f, 0.03617372f, 0.03157641f, 0.04234765f, 0.02788978f, 
    0.01114866f, -0.01841284f, -0.02124123f, -0.01869861f, 0.00677974f, -0.03021018f, -0.02867774f, -0.00575354f, 
    -0.02541344f, -0.02648761f, -0.02112987f, 0.02807212f, -0.01543744f, 0.02945628f, 0.01544176f, -0.05051266f, 
    -0.03228532f, 0.03453188f, 0.02793671f, -0.03969677f, 0.03891959f, -0.01398479f, 0.02082917f, 0.04424354f, 
    -0.01951738f, 0.00031803f, -0.01544496f, 0.04292367f, 0.01432533f, -0.03114381f, 0.03090667f, -0.05217236f, 
    0.02728354f, 0.03498829f, -0.02389834f, 0.00621632f, -0.02398597f, -0.04087620f, 0.04282653f, -0.01141736f, 
    0.01544587f, -0.01962953f, -0.03802785f, 0.00155255f, -0.05108726f, -0.02513357f, 0.02647792f, 0.02065317f, 
    0.03123001f, 0.00091570f, 0.00666556f, -0.01463331f, 0.00573133f, -0.00651241f, -0.04528774f, 0.02542967f, 
    -0.02048359f, 0.02429646f, -0.05167447f, 0.02755566f, -0.00392295f, 0.02453602f, -0.01258818f, -0.02577143f, 
    0.02809599f, -0.02784677f, -0.05415087f, 0.00043511f, 0.01509121f, -0.01809274f, -0.04275919f, -0.04231007f, 
    -0.05320031f, -0.03606370f, -0.02276772f, -0.02063218f, 0.04235217f, -0.04992293f, 0.04145827f, 0.00708476f, 
    0.01630186f, 0.04399516f, 0.01565963f, -0.01028399f, -0.04975692f, -0.04593083f, -0.02746570f, -0.02285437f, 
    0.03432044f, 0.01521266f, 0.02028825f, -0.04303689f, -0.02573241f, -0.05605927f, -0.02466578f, 0.04304187f, 
    0.03164382f, -0.04835886f, -0.05161104f, -0.05227105f, -0.01494434f, 0.03145589f, -0.01488214f, -0.00147219f, 
    0.03896586f, -0.04031968f, -0.05303251f, 0.01349290f, -0.02804872f, -0.04101117f, 0.04176275f, -0.00675798f, 
    -0.02658199f, -0.05708488f, 0.02679025f, -0.04135895f, -0.03695832f, 0.02281698f, -0.03600673f, 0.02581864f, 
    -0.01309900f, 0.03565659f, 0.01110713f, -0.02908514f, 0.02366739f, -0.04556594f, 0.01849083f, -0.00205789f, 
    -0.00469713f, -0.04510222f, 0.01138790f, 0.03798841f, 0.03534786f, -0.02908365f, 0.01464375f, 0.00705643f, 
    0.00846121f, 0.01594897f, -0.05316081f, 0.00547415f, -0.05201806f, -0.03036605f, -0.00572943f, 0.01558409f, 
    -0.05227794f, -0.03928818f, -0.00659725f, -0.00935448f, -0.05184582f, 0.00303142f, 0.03566100f, 0.04414468f, 
    -0.00542898f, -0.01657226f, 0.02724359f, 0.00584132f, -0.02260317f, -0.00213956f, 0.00615632f, -0.00585263f, 
    -0.01976752f, 0.03127077f, 0.00772525f, -0.04931699f, 0.00513106f, -0.03975785f, -0.02077362f, -0.04651537f, 
    -0.00944624f, 0.00756356f, -0.04646390f, 0.03122850f, -0.03456646f, 0.02613439f, 0.03659832f, -0.01610499f, 
    -0.02006429f, -0.03009721f, -0.02324108f, 0.01584732f, 0.02014915f, 0.03774254f, -0.01980183f, -0.01909396f, 
    0.00166535f, 0.05478948f, -0.03335025f, -0.05257896f, -0.05823874f, 0.01939921f, -0.04010260f, -0.00604343f, 
    -0.00699197f, 0.00990530f, 0.02143424f, -0.03056077f, 0.01769101f, 0.03176700f, 0.03848514f, -0.03148811f, 
    -0.03611012f, 0.03189640f, 0.02933346f, 0.03972962f, -0.03380062f, -0.04520163f, 0.01523099f, -0.02413555f, 
    -0.03378144f, -0.01479083f, -0.02672079f, -0.00522584f, 0.02330145f, -0.03614056f, -0.01507318f, 0.02092361f, 
    -0.02374017f, -0.05318592f, -0.01584660f, 0.01919780f, 0.03396779f, -0.00506599f, 0.04243268f, -0.01274118f, 
    0.03783200f, -0.02405591f, -0.04876790f, -0.00987635f, -0.01477182f, -0.04410661f, 0.03626508f, -0.04242216f, 
    0.00335421f, 0.02734038f, -0.03978977f, -0.04765037f, -0.04322072f, -0.01823379f, -0.05473427f, 0.00093130f, 
    0.00243256f, 0.00889524f, -0.00221139f, -0.05184264f, -0.05013012f, -0.01587773f, -0.00563737f, 0.02283962f, 
    -0.01395309f, 0.02980015f, 0.03108046f, -0.05148547f, 0.01463661f, -0.04349294f, -0.05098281f, 0.01046609f, 
    0.02052698f, -0.03617839f, -0.03840191f, -0.02033250f, 0.00982261f, 0.01134484f, -0.02260675f, -0.01779331f, 
    0.00315874f, 0.02938745f, -0.02139716f, 0.00896347f, 0.00301426f, -0.04934015f, -0.00505431f, 0.00065441f, 
    0.01295378f, -0.04714836f, -0.05665477f, -0.04484268f, 0.01380031f, 0.04322255f, 0.03434265f, -0.04525693f, 
    0.02344174f, -0.00993443f, -0.04895785f, -0.05062090f, 0.01199216f, -0.05334862f, -0.01863890f, -0.02061778f, 
    -0.00660533f, -0.00960575f, 0.03018357f, 0.02049239f, 0.02231155f, -0.03757933f, -0.03607414f, -0.00897421f, 
    0.00795480f, -0.03882935f, 0.03290502f, 0.02811742f, -0.04122138f, 0.03629442f, 0.00903665f, -0.03483578f, 
    0.04251013f, -0.03649063f, -0.04013074f, -0.03611673f, -0.03690748f, -0.03762499f, 0.01658785f, 0.04220302f, 
    0.01498324f, -0.01244812f, 0.00724218f, -0.05662332f, -0.03597160f, -0.02831596f, -0.01691761f, 0.01884079f, 
    -0.04725587f, -0.04858612f, -0.04985338f, -0.02463989f, 0.01110118f, -0.01786724f, -0.00507970f, -0.04386710f, 
    0.03660889f, 0.03864308f, 0.02511969f, 0.01019859f, 0.02194633f, -0.05290200f, 0.02906328f, -0.01029748f, 
    0.02136096f, -0.03080409f, -0.01749014f, 0.00675362f, 0.01102934f, -0.05316379f, -0.01188054f, -0.03433521f, 
    0.01202905f, -0.02715937f, 0.00657366f, 0.00462426f, 0.02495360f, 0.00383456f, 0.01441721f, 0.04237875f, 
    -0.02510069f, 0.00804515f, -0.04588643f, -0.01474933f, -0.05277761f, 0.00002976f, 0.02056640f, -0.00180579f, 
    -0.00338659f, 0.00225087f, 0.04957293f, -0.05643992f, 0.05724587f, -0.01237515f, 0.04041550f, -0.00528861f, 
    -0.02793884f, 0.03866886f, -0.00373657f, -0.05869361f, -0.05159558f, -0.05746068f, 0.00545927f, -0.01748616f, 
    -0.05418311f, -0.05141014f, -0.00279334f, -0.04554163f, 0.01280047f, -0.04221462f, -0.04326810f, -0.03427007f, 
    -0.03432721f, -0.01205796f, 0.00991331f, -0.00805772f, -0.03339239f, 0.01655604f, -0.04737651f, -0.04582708f, 
    -0.03809589f, 0.01097262f, 0.03870715f, -0.01098897f, 0.00926436f, 0.03364868f, -0.03915931f, -0.04756259f, 
    0.00347260f, 0.04285882f, -0.03237271f, 0.03068104f, 0.04108106f, -0.01947680f, -0.03781848f, -0.01952582f, 
    -0.03757353f, 0.04242136f, -0.03906990f, -0.02402717f, -0.03345542f, 0.00248965f, -0.00483895f, 0.02958288f, 
    -0.00734548f, 0.01077760f, 0.00462697f, -0.02585174f, -0.02488819f, -0.02261834f, -0.05613900f, -0.03504257f, 
    -0.01597015f, -0.03314778f, -0.03940698f, 0.03666649f, 0.03019289f, -0.01041745f, -0.04459676f, 0.01368296f, 
    -0.02393091f, -0.01512204f, 0.01950621f, 0.01331898f, 0.03875749f, 0.02880590f, -0.04151464f, 0.04934759f, 
    -0.04365806f, 0.01947201f, 0.00578245f, -0.01655238f, -0.00510624f, -0.00906288f, -0.01204320f, -0.01601903f, 
    -0.05378349f, 0.01611916f, 0.03515843f, 0.01683239f, -0.03221570f, -0.05629247f, -0.04001634f, -0.04561142f, 
    0.02786853f, 0.02186499f, 0.00171276f, 0.03554068f, -0.03451496f, 0.00143259f, -0.05611667f, 0.03499015f, 
    0.03280839f, 0.00116010f, -0.05773844f, -0.05760638f, -0.01048663f, 0.01404945f, -0.03425544f, 0.01034231f, 
    -0.03495404f, -0.04843603f, -0.00311752f, -0.02727248f, 0.01854725f, -0.02428686f, 0.02620400f, -0.00242732f, 
    0.02866101f, 0.04654644f, -0.05510309f, -0.02347815f, -0.03481638f, 0.00020192f, 0.01044388f, -0.02531945f, 
    -0.02838227f, 0.01246697f, -0.03973258f, 0.02845900f, 0.01676819f, 0.00421882f, -0.03259560f, -0.03524791f, 
    0.03610940f, -0.02181077f, -0.01253282f, -0.02521303f, 0.04682102f, -0.01102136f, -0.03891615f, -0.00691329f, 
    -0.04252667f, 0.01202261f, 0.04139142f, 0.00388228f, -0.01352791f, -0.02995772f, -0.01716531f, 0.01633162f, 
    -0.01710923f, -0.03867696f, 0.03654847f, 0.03323379f, -0.03081992f, -0.02373918f, -0.02683797f, -0.04930332f, 
    0.00751286f, -0.05899371f, 0.03927178f, 0.03646900f, -0.05435401f, 0.02581007f, 0.03399993f, 0.00718180f, 
    -0.03071248f, -0.00106767f, 0.00523243f, -0.01286810f, 0.02515034f, 0.01197089f, -0.04382251f, -0.00939977f, 
    -0.05388444f, -0.05657496f, -0.01487733f, 0.03430852f, 0.01344770f, -0.03053975f, -0.03177422f, -0.01812577f, 
    0.03206439f, 0.01312902f, 0.01939676f, -0.03445537f, -0.04277726f, -0.03300215f, -0.05650549f, -0.03172514f, 
    0.04408554f, -0.01438924f, -0.01738871f, -0.00717011f, 0.03351343f, 0.02898005f, 0.01844026f, 0.00326203f, 
    0.03385588f, 0.02109783f, -0.03370427f, 0.02805408f, 0.01533494f, -0.01218404f, -0.01677923f, -0.03363810f, 
    0.01489368f, 0.00877199f, 0.02858648f, -0.01262766f, -0.04986406f, -0.03153674f, -0.04268732f, 0.01010944f, 
    -0.02321503f, -0.03254531f, 0.03134925f, -0.05121144f, -0.02221746f, 0.02955388f, 0.03484652f, -0.01314209f, 
    0.04548684f, -0.02677083f, 0.04532660f, 0.00245708f, -0.05695262f, 0.04629247f, -0.00178234f, 0.02515437f, 
    0.02106890f, -0.02163791f, 0.00839451f, 0.01123865f, 0.02998162f, -0.05553311f, 0.01756886f, -0.03948622f, 
    0.01211395f, -0.01915469f, -0.04613592f, -0.00973441f, 0.02051865f, 0.00077175f, -0.02343425f, 0.04379066f, 
    0.02359428f, -0.00977544f, 0.02621241f, -0.01752270f, -0.03070000f, 0.04337130f, -0.03901429f, -0.03758801f, 
    0.02484837f, -0.01446102f, 0.02202066f, -0.04341457f, -0.03250261f, 0.00963217f, -0.04435314f, 0.03862234f, 
    -0.04559203f, 0.02312566f, -0.01436070f, 0.04152372f, -0.04888296f, -0.04034549f, -0.03673740f, 0.03114183f, 
    -0.03681745f, 0.02690371f, 0.03143495f, 0.01494593f, -0.00525110f, -0.00992294f, -0.03785231f, -0.04179294f, 
    0.03997543f, 0.03850200f, 0.02261417f, -0.03740602f, -0.05544553f, 0.02640731f, 0.02131749f, -0.05577065f, 
    -0.06115391f, -0.01515177f, 0.03569474f, 0.03776743f, -0.02529155f, 0.01592036f, -0.03103411f, 0.04464142f, 
    0.01446257f, 0.01471119f, -0.03130059f, -0.05075185f, 0.03486173f, 0.00100921f, -0.01952878f, -0.04196529f, 
    -0.01078848f, 0.03783303f, -0.04247576f, 0.03590138f, 0.00058860f, -0.01566860f, -0.04086479f, 0.04057967f, 
    -0.04190438f, -0.04080445f, -0.05142691f, 0.01528521f, 0.01959003f, 0.02186584f, 0.03212364f, -0.04090679f, 
    0.01934990f, 0.04224803f, -0.03681668f, -0.01798133f, 0.01429313f, 0.00972491f, -0.03966596f, -0.03298711f, 
    0.02121728f, -0.04777074f, -0.05459544f, -0.01387294f, 0.02387653f, 0.02857793f, -0.03771150f, 0.00818465f, 
    0.01954501f, -0.05186929f, 0.00313425f, 0.01880337f, -0.02181516f, -0.04135688f, 0.01854821f, 0.02924558f, 
    -0.16510881f, -0.13488492f, 0.04178162f, -0.27067089f, 0.06761004f, 0.07220539f, -0.09921461f, 0.13053979f, 
    -0.06706552f, 0.00914600f, 0.00635676f, 0.00569924f, 0.25055715f, -0.16595796f, -0.09444495f, 0.18727289f, 
    0.05215030f, 0.08504661f, -0.09684592f, 0.04302439f, 0.07232267f, 0.03671728f, -0.00050598f, -0.08430853f, 
    0.27884540f, -0.04027356f, 0.17733656f, -0.11695901f, 0.08572576f, 0.07511952f, -0.04753963f, -0.15299854f, 
    0.03525536f, 0.02890408f, 0.03723696f, 0.09169821f, 0.13007514f, -0.10989509f, -0.09062827f, 0.17132361f, 
    0.07768396f, -0.03037525f, -0.15685311f, 0.08527715f, 0.08778832f, -0.01264369f, -0.00477691f, 0.10957720f, 
    -0.13406019f, 0.04851693f, 0.01384646f, 0.26958281f, 0.08045386f, -0.08494557f, 0.09766767f, 0.01341704f, 
    0.05274925f, 0.06584996f, 0.03424836f, 0.05565710f, -0.14951047f, -0.11915249f, -0.08301544f, -0.15248924f, 
    -0.05193812f, 0.03168855f, 0.00019492f, 0.11336220f, 0.09520790f, -0.18724070f, -0.05440586f, 0.05787855f, 
    0.24166933f, 0.17552128f, 0.15971291f, 0.18567663f, -0.04057001f, 0.04690632f, 0.06303760f, 0.10656804f, 
    -0.03019330f, 0.05808529f, -0.03752248f, 0.13824189f, 0.26132458f, -0.13183287f, 0.10282540f, -0.05623333f, 
    -0.02230835f, 0.03434585f, -0.05836622f, -0.15746562f, -0.11209311f, 0.06127434f, -0.10390081f, -0.11478116f, 
    -0.38977185f, -0.05173598f, -0.15089452f, 0.03174669f, 0.00690263f, -0.03332738f, -0.01240414f, 0.20651752f, 
    0.00648030f, 0.14348644f, 0.00807561f, 0.04887361f, -0.28883466f, 0.02305869f, -0.06547350f, -0.09788503f, 
    -0.02010355f, -0.04113237f, -0.12153228f, 0.28396091f, 0.05439122f, 0.03562504f, 0.05947788f, 0.08999711f, 
    -0.19228934f, 0.02640421f, 0.41096243f, -0.29449692f, 0.05728734f, 0.02909000f, -0.01439058f, 0.02937385f, 
    -0.10057830f, 0.01396039f, 0.03472047f, 0.10665002f, 0.12104908f, 0.18711878f, -0.13728654f, 0.10411444f, 
    -0.13593802f, 0.13118429f, 0.01098191f, -0.14026189f, -0.01812030f, 0.09852823f, -0.04750970f, -0.01212232f, 
    -0.19207719f, -0.17946039f, -0.13200688f, -0.38754928f, 0.01512984f, 0.08974718f, 0.06355829f, -0.02079892f, 
    -0.01413601f, -0.08457594f, 0.11587331f, 0.17230274f, -0.29843244f, -0.18294397f, -0.05827883f, 0.28550807f, 
    -0.01436048f, -0.01897012f, 0.10748672f, 0.01422199f, 0.05727503f, 0.04301820f, 0.02450488f, 0.08092562f, 
    0.14354612f, -0.25723061f, 0.14810809f, 0.19798805f, 0.27471793f, -0.02388200f, 0.05591410f, 0.08968956f, 
    -0.04965379f, -0.04497119f, -0.00457450f, 0.06085662f, 0.22768071f, 0.14906259f, -0.15949903f, 0.12288708f, 
    0.14345734f, -0.03556592f, 0.11010759f, 0.06799070f, 0.05112671f, 0.10924307f, 0.01627646f, 0.13685118f, 
    -0.13102673f, 0.18105002f, -0.05939186f, -0.07733825f, 0.14896278f, 0.04013528f, 0.03802135f, 0.01683651f, 
    0.14083920f, 0.14155996f, 0.05800078f, 0.08406131f, -0.20364492f, -0.06913517f, -0.06478340f, -0.03623903f, 
    -0.08105081f, -0.04195416f, 0.14126906f, -0.12915702f, 0.01123964f, 0.00092028f, 0.01748012f, -0.13696794f, 
    -0.31801754f, 0.03520715f, 0.10669873f, 0.26350528f, 0.03702630f, 0.01632569f, -0.01620402f, -0.03860139f, 
    0.11790235f, -0.04808176f, 0.04800095f, 0.03160016f, -0.11461309f, 0.08295571f, 0.06456436f, 0.43430325f, 
    0.16909300f, 0.08383159f, -0.03126314f, -0.02191056f, 0.14987537f, 0.09831815f, -0.04509804f, -0.02736332f, 
    -0.01028129f, 0.26849332f, -0.00583161f, 0.01526273f, 0.05072052f, -0.00196457f, 0.07992806f, 0.10567778f, 
    0.07820486f, -0.00132586f, 0.11698072f, 0.10340222f, 0.27200586f, -0.03039131f, 0.09035829f, 0.33194345f, 
    -0.05927382f, 0.00669446f, 0.03473419f, -0.07099245f, -0.01779249f, 0.04414773f, -0.01455317f, -0.13665937f, 
    -0.32190657f, 0.04990013f, 0.17624226f, -0.08981166f, 0.07756455f, -0.03780149f, 0.09890685f, 0.16255353f, 
    0.04369012f, -0.08928579f, -0.01893107f, 0.02126744f, -0.24676087f, -0.02392885f, -0.03924796f, -0.07117741f, 
    0.00838375f, -0.00486460f, 0.12480084f, -0.01204516f, 0.05670945f, -0.06888583f, -0.01917962f, -0.03004156f, 
    -0.20206302f, 0.00133265f, -0.10420576f, -0.39606768f, 0.08766444f, -0.12200030f, -0.11028010f, 0.04816386f, 
    0.09877195f, 0.07995933f, 0.00681627f, -0.03452485f, 0.34992492f, 0.08398335f, -0.13967183f, 0.18852961f, 
    0.11290153f, -0.03860441f, 0.21733922f, -0.06023767f, 0.30075148f, -0.09670988f, 0.00942931f, 0.22376874f, 
    0.13637088f, 0.02175570f, 0.02725066f, 0.31474388f, 0.16934595f, -0.00633715f, -0.07906414f, -0.10856213f, 
    0.06524450f, 0.07122646f, -0.07092202f, 0.09203882f, 0.34626734f, 0.01264896f, -0.22139925f, 0.43424082f, 
    0.17984065f, 0.11594610f, -0.07159074f, -0.02070962f, 0.00151151f, -0.04181290f, -0.04062323f, 0.04200530f, 
    0.17199451f, 0.19584502f, 0.04986834f, 0.01878423f, 0.05116725f, -0.01176034f, 0.00842050f, 0.11372983f, 
    -0.05021518f, -0.06218489f, 0.07248236f, -0.03095701f, 0.04266054f, -0.16632855f, -0.09838052f, 0.40050697f, 
    0.00784292f, 0.08005635f, -0.01643966f, -0.06269271f, 0.12583938f, 0.01507500f, -0.06206688f, 0.06208368f, 
    -0.54180712f, -0.07649608f, -0.05767755f, 0.17222454f, -0.05987817f, 0.04063115f, -0.05806746f, -0.00208767f, 
    -0.11549123f, 0.02134861f, -0.00079913f, -0.10380275f, -0.09640914f, 0.12381543f, -0.04166088f, 0.19034740f, 
    -0.02548964f, -0.01658801f, -0.00505299f, 0.00355746f, 0.10593369f, -0.01569072f, 0.07283808f, -0.00138258f, 
    0.02123069f, 0.01872552f, -0.04330556f, 0.04483299f, -0.05509472f, -0.02291997f, -0.00878803f, 0.00548444f, 
    -0.05718181f, -0.04642993f, 0.00023340f, -0.00190512f, -0.05364848f, 0.02551508f, 0.00079003f, 0.04693794f, 
    0.03124856f, 0.02018356f, -0.05017530f, 0.03675481f, -0.01187619f, -0.04839640f, 0.02280282f, -0.01207834f, 
    0.03419061f, -0.00043040f, 0.03189319f, 0.04566312f, 0.01092832f, -0.04242654f, -0.00758918f, 0.02645265f, 
    -0.04319676f, -0.03571661f, -0.05120078f, 0.03042677f, -0.03628080f, -0.05302026f, -0.01459970f, 0.01464872f, 
    -0.03292756f, 0.02281320f, 0.00827092f, -0.01904345f, -0.05395266f, -0.04209008f, -0.04515273f, 0.03292700f, 
    -0.05283618f, -0.01078185f, -0.02355338f, -0.01591018f, -0.05359716f, -0.01691966f, -0.05188874f, -0.03770830f, 
    0.04134615f, -0.00611879f, -0.03280174f, -0.02908428f, 0.01314655f, 0.03800060f, -0.04601461f, -0.04974324f, 
    -0.04574762f, -0.00572550f, -0.02404727f, -0.04484899f, 0.03614222f, -0.04348658f, -0.04182207f, -0.01808411f, 
    0.00412734f, -0.02360901f, 0.04117440f, -0.04759433f, -0.02585783f, -0.04741268f, -0.01694671f, -0.01201196f, 
    0.01019923f, 0.01016487f, -0.01423117f, 0.01350190f, 0.04732790f, 0.01463525f, -0.04231493f, -0.04316499f, 
    0.01841337f, 0.01659109f, 0.03025794f, 0.02360005f, 0.04401082f, -0.02587800f, 0.01470078f, 0.04087147f, 
    -0.03295133f, -0.04667255f, 0.00569874f, 0.00376875f, 0.01409869f, 0.00464351f, 0.04166887f, -0.01157254f, 
    -0.03836386f, -0.01347835f, 0.01658078f, 0.03764672f, -0.00961216f, -0.01343578f, -0.00060992f, -0.03093284f, 
    0.01211610f, 0.03784892f, -0.05218245f, -0.03881457f, -0.03576750f, 0.00685302f, -0.02701716f, 0.04452107f, 
    -0.02842139f, 0.03348324f, -0.00328773f, 0.01033206f, 0.04337940f, 0.03285142f, -0.03390504f, 0.00697559f, 
    0.04117919f, 0.03111455f, -0.05025050f, -0.04055165f, 0.00873072f, 0.00849242f, 0.04685804f, 0.01002948f, 
    -0.04644078f, 0.01445270f, 0.03471160f, 0.00293321f, -0.03683899f, 0.00036452f, 0.03249289f, 0.02533073f, 
    -0.03425677f, -0.00107140f, -0.03370991f, -0.01883900f, -0.02850440f, -0.04108085f, -0.03092753f, 0.01347746f, 
    0.03506858f, -0.04708270f, -0.02147471f, -0.04224657f, 0.02887517f, 0.00952389f, -0.05061829f, 0.02791819f, 
    0.01156574f, -0.02569903f, -0.04211903f, 0.03707247f, 0.03788080f, 0.01753065f, 0.03006264f, -0.03005621f, 
    -0.03506956f, -0.01352129f, -0.00645786f, -0.04454678f, -0.02909823f, -0.02090435f, -0.04732560f, 0.01716004f, 
    0.02082787f, 0.04635363f, 0.00525101f, 0.02541219f, 0.03300779f, 0.04417328f, -0.02287021f, 0.03626055f, 
    -0.03527664f, -0.03548551f, -0.01808874f, 0.03225937f, 0.00307319f, -0.05230356f, 0.02499497f, 0.03119028f, 
    -0.01877384f, -0.02479218f, -0.05056526f, -0.01813260f, 0.00416891f, -0.03540782f, 0.02249331f, 0.02607430f, 
    -0.05177660f, -0.01505124f, 0.02474724f, -0.04193481f, 0.02345567f, 0.00087605f, -0.03228403f, 0.02416550f, 
    -0.00530513f, -0.04284113f, -0.02860882f, -0.03448472f, 0.04143877f, 0.00576466f, 0.02340792f, 0.03746090f, 
    -0.00728582f, -0.02198084f, -0.04428054f, 0.04724687f, 0.03276153f, -0.01535688f, -0.03888128f, -0.03126829f, 
    0.03552843f, 0.00883344f, 0.03501084f, -0.02674044f, 0.01092426f, -0.00170700f, -0.03720291f, 0.04736700f, 
    0.03193853f, -0.02383218f, -0.01468901f, 0.02607400f, -0.00248862f, 0.03640532f, 0.01393934f, -0.01872943f, 
    0.00827883f, -0.02560615f, -0.02040092f, -0.04113658f, 0.04182870f, 0.01775394f, 0.03495428f, 0.04562980f, 
    -0.02698506f, 0.02565715f, -0.02142468f, -0.04828229f, -0.02286768f, 0.04406425f, 0.02360295f, 0.00833912f, 
    -0.04506721f, -0.03070953f, -0.00801062f, 0.04194279f, -0.04027016f, 0.00591499f, -0.02036355f, -0.00230964f, 
    -0.04752193f, -0.03660204f, -0.03706396f, 0.02472068f, 0.04070753f, -0.02034013f, -0.00755598f, -0.04361891f, 
    0.00926584f, 0.04673473f, -0.03681234f, 0.01907047f, 0.02127205f, 0.01064126f, -0.04236215f, 0.04859393f, 
    -0.03479390f, -0.02609527f, -0.04612359f, -0.00000742f, -0.04501271f, 0.01193564f, -0.03834438f, 0.02688539f, 
    -0.05604614f, -0.03226269f, 0.04245584f, -0.01698354f, -0.03492105f, 0.02155302f, -0.04719664f, -0.04546006f, 
    -0.01368375f, 0.00697294f, -0.00971819f, -0.01919770f, -0.01685952f, -0.00579446f, -0.01494533f, -0.02496277f, 
    0.02658190f, 0.00915292f, 0.01144729f, 0.03044317f, 0.02928429f, -0.05004309f, 0.01054390f, 0.04300968f, 
    -0.00259892f, 0.04526456f, -0.00847535f, 0.01323982f, -0.02009836f, -0.03807355f, 0.02605299f, -0.05032977f, 
    -0.02539264f, -0.01995210f, 0.01837720f, -0.03640540f, -0.02071808f, -0.04294770f, -0.04559748f, -0.04550462f, 
    -0.04051078f, 0.02320528f, -0.00706364f, -0.02722443f, -0.00993403f, 0.00035683f, -0.02721025f, 0.02446651f, 
    -0.00310035f, 0.01255520f, 0.03526146f, 0.02129463f, 0.00403644f, -0.00385634f, 0.02505342f, -0.05070028f, 
    0.00795877f, -0.02749129f, 0.01761093f, -0.04522996f, -0.01256428f, 0.01926501f, -0.01070786f, 0.01824127f, 
    -0.03184267f, 0.00694455f, 0.04062157f, -0.05250890f, -0.04451320f, -0.05015758f, -0.00222636f, -0.02864031f, 
    0.00007032f, -0.01836853f, 0.00990120f, -0.04506807f, -0.04551430f, 0.04164762f, -0.00036671f, -0.01749637f, 
    0.02405708f, 0.00392323f, -0.01107397f, -0.02530951f, -0.02015604f, -0.00196690f, -0.03364588f, 0.01700608f, 
    0.01446808f, 0.03610429f, -0.03679420f, -0.01065165f, 0.03533284f, 0.01984375f, -0.04388103f, 0.03532642f, 
    0.00781150f, 0.04614173f, 0.01660939f, -0.03904864f, -0.03467460f, -0.04268066f, 0.04741286f, -0.00238321f, 
    0.03711854f, 0.01378197f, -0.05005801f, 0.04175798f, -0.02080486f, 0.01271776f, 0.03143508f, 0.02035682f, 
    -0.01789314f, -0.02949307f, -0.04743989f, -0.01495639f, 0.04534245f, -0.05306134f, 0.02442283f, 0.01309474f, 
    0.00560076f, 0.03566807f, 0.00668863f, -0.01758130f, 0.00392822f, -0.03844112f, -0.02398873f, -0.02788380f, 
    -0.02712324f, -0.02596961f, 0.01553283f, 0.03096886f, -0.03938613f, 0.01468316f, 0.02777094f, -0.02650805f, 
    -0.00015560f, -0.02750032f, -0.04342478f, 0.00046415f, -0.01400703f, 0.02056783f, 0.00730087f, 0.03752832f, 
    -0.02376290f, -0.02318046f, -0.02918315f, 0.00007974f, -0.04662751f, 0.04093734f, -0.00022094f, -0.01556596f, 
    0.00957668f, 0.00634398f, 0.03742856f, -0.01182275f, 0.00090746f, 0.03922920f, -0.01868816f, 0.01888078f, 
    -0.04511093f, -0.01788044f, -0.03054398f, 0.02064290f, -0.00718399f, 0.02923294f, -0.00893380f, 0.01988808f, 
    0.00095084f, 0.00603673f, -0.03828303f, -0.00425785f, -0.00059940f, -0.05109284f, -0.02837341f, -0.01371349f, 
    0.03780659f, 0.00580138f, 0.02545939f, -0.02095856f, 0.03513984f, 0.00110596f, 0.00747574f, 0.02417200f, 
    0.01319573f, -0.01382615f, -0.04148380f, -0.05184471f, -0.01972634f, -0.03440608f, -0.03586557f, 0.01403043f, 
    -0.00243419f, -0.03971219f, 0.02369716f, 0.03461340f, -0.00621011f, 0.02507966f, -0.03300412f, -0.04115474f, 
    0.02132731f, -0.00827425f, 0.02266840f, -0.03195253f, -0.01418168f, -0.04657002f, -0.04191046f, -0.04694445f, 
    0.02210239f, -0.01103873f, 0.02774046f, 0.04170552f, -0.05271894f, -0.04455986f, -0.00616878f, 0.03471904f, 
    -0.00064556f, -0.01450561f, -0.00668748f, -0.04086924f, 0.04009341f, 0.04758768f, -0.01543760f, -0.03967483f, 
    -0.00616021f, 0.04211455f, 0.03369094f, -0.03802115f, -0.03651909f, 0.01034292f, 0.02347591f, 0.00244050f, 
    -0.01929403f, 0.03667149f, 0.01378839f, -0.01433077f, -0.01019662f, 0.00554746f, -0.01130558f, -0.01377780f, 
    0.04059468f, 0.02625611f, -0.00954954f, -0.03066098f, -0.03751063f, 0.01876571f, 0.04462118f, 0.02354824f, 
    -0.00561263f, 0.02581283f, 0.00550422f, 0.00613981f, 0.00078603f, 0.03773553f, 0.04556063f, -0.05570637f, 
    0.02145835f, 0.03552968f, -0.00378200f, -0.01507426f, 0.03704125f, 0.05011849f, -0.00596133f, -0.03059761f, 
    0.02921268f, 0.05391376f, 0.01151980f, 0.01754295f, -0.02730300f, -0.03410673f, -0.04947133f, -0.02563482f, 
    0.00751887f, 0.03083391f, -0.03330556f, -0.01747074f, 0.04807430f, -0.04705406f, -0.04218226f, -0.03634215f, 
    0.03494675f, -0.02902294f, 0.00934974f, -0.04768238f, -0.04999401f, -0.00395559f, 0.01779192f, -0.04061823f, 
    -0.05204720f, -0.06034502f, -0.01132849f, 0.02649445f, 0.05195510f, -0.02327722f, 0.01353112f, 0.04359575f, 
    0.02270098f, -0.00601829f, 0.01368497f, -0.02990879f, 0.02577328f, 0.03870792f, -0.01398131f, -0.03772026f, 
    0.02061881f, -0.05211535f, -0.04228874f, 0.00943648f, 0.03396805f, -0.04646463f, 0.02603822f, -0.04411421f, 
    0.01120425f, 0.00445984f, -0.03404967f, 0.00917054f, -0.04131540f, 0.00416700f, -0.04502774f, 0.00453451f, 
    -0.02734849f, 0.02544952f, 0.02342578f, 0.00235704f, 0.03506119f, -0.00831378f, -0.01158693f, -0.01512264f, 
    -0.04285211f, 0.00074417f, -0.03718448f, -0.05279740f, -0.00116343f, 0.01704050f, -0.05526903f, -0.01318097f, 
    -0.00665509f, 0.03300896f, 0.01193526f, 0.04063813f, -0.02942786f, -0.00180356f, 0.02434991f, -0.04006530f, 
    -0.04187537f, -0.04262998f, -0.04543370f, -0.00957797f, -0.05056414f, -0.01523218f, 0.04749385f, 0.00524009f, 
    -0.00240570f, -0.04525539f, -0.01022485f, 0.03236715f, 0.00656326f, 0.03423931f, -0.03451481f, 0.02488748f, 
    0.04750598f, -0.00274967f, -0.00029732f, 0.01827210f, -0.05298673f, 0.01584712f, -0.03941826f, -0.04340817f, 
    0.00865049f, -0.04275352f, 0.02028458f, -0.03737775f, 0.01566442f, -0.05370800f, -0.05033629f, 0.04037426f, 
    0.02380108f, -0.00447300f, 0.01124518f, 0.02840517f, 0.01516327f, -0.01450276f, -0.04419499f, 0.01309569f, 
    0.01486873f, -0.00480163f, -0.04988829f, -0.01213654f, -0.03705381f, -0.05833580f, 0.01059199f, 0.03042159f, 
    0.01440715f, -0.04645981f, -0.02078084f, 0.00743212f, -0.02751695f, -0.03996425f, -0.02250746f, 0.04149500f, 
    0.04938499f, 0.00869124f, 0.01566419f, 0.02944589f, -0.00489572f, 0.01458002f, -0.02342422f, -0.02076603f, 
    -0.00921624f, -0.01677844f, 0.04295219f, 0.02057805f, 0.03965969f, 0.00680539f, 0.02620181f, 0.01136575f, 
    -0.01623633f, 0.04681144f, -0.03323376f, -0.04294742f, 0.00629129f, 0.02302329f, -0.02139247f, 0.00631280f, 
    -0.03383461f, 0.04568659f, 0.00793215f, 0.03210182f, -0.03038302f, -0.02271350f, -0.05507797f, -0.05736885f, 
    -0.04516434f, 0.02053944f, -0.01048394f, -0.04677080f, 0.02269454f, 0.03461466f, 0.01915959f, -0.00651767f, 
    -0.01793329f, 0.03949986f, -0.03746524f, -0.03540629f, 0.00384152f, -0.03041887f, -0.01717188f, -0.05530190f, 
    0.05199772f, -0.04587670f, -0.05092727f, 0.01941021f, -0.04152721f, -0.02585739f, -0.03713271f, 0.01939784f, 
    0.04140327f, 0.00906701f, 0.04262804f, 0.04954115f, 0.01748297f, -0.04021421f, -0.01501656f, 0.04907255f, 
    -0.03250765f, -0.03946230f, -0.03659707f, 0.01574225f, -0.03519134f, -0.01267565f, 0.02988837f, -0.01475217f, 
    -0.04556074f, -0.05070037f, 0.01571511f, -0.02645612f, -0.02376503f, -0.01697079f, -0.04485667f, -0.03204968f, 
    -0.21250226f, -0.16825277f, -0.09801468f, 0.20694163f, -0.01944715f, 0.04990149f, 0.00232232f, 0.07523271f, 
    0.08394907f, 0.01423660f, 0.29292014f, 0.06558081f, 0.10684086f, 0.26869950f, 0.03297026f, -0.02837678f, 
    0.20435230f, -0.00117971f, 0.02620954f, 0.24967362f, 0.08750403f, 0.09155447f, -0.00995919f, 0.03493287f, 
    0.13848920f, 0.25106078f, -0.13617687f, -0.30271322f, 0.08559471f, -0.04079059f, 0.10739404f, -0.06368176f, 
    0.07465539f, 0.04982139f, 0.06350640f, 0.07472327f, 0.10456724f, 0.04053077f, -0.10049555f, -0.09846344f, 
    0.11169051f, -0.14323735f, -0.03293530f, 0.11383332f, 0.09812385f, 0.13632715f, 0.09838011f, 0.11763497f, 
    -0.23617065f, 0.20965378f, -0.11908478f, 0.14534764f, 0.09036996f, -0.01343221f, -0.04972589f, -0.14449479f, 
    0.17563885f, -0.05354037f, -0.08859004f, -0.04563865f, 0.37027317f, 0.05114269f, -0.07783686f, -0.11940388f, 
    -0.15323359f, -0.17612222f, 0.03077758f, 0.01926784f, -0.05394514f, 0.07054465f, 0.05851876f, 0.00571595f, 
    -0.19569935f, 0.10998749f, 0.26147041f, -0.00500867f, -0.12333883f, -0.08257470f, 0.12220249f, -0.00691056f, 
    -0.07459556f, 0.11079018f, -0.13819687f, 0.20584817f, 0.05382992f, 0.09029610f, 0.11012506f, 0.18307999f, 
    0.01275112f, 0.15599686f, 0.17000821f, 0.10050075f, -0.00170676f, 0.15203239f, -0.18699570f, -0.11781505f, 
    -0.27067649f, 0.44128904f, -0.16153920f, -0.01377692f, -0.11922529f, -0.00829072f, -0.06312638f, -0.00861328f, 
    0.21918547f, -0.09696435f, 0.01183545f, 0.03878484f, -0.09097244f, 0.09356270f, -0.03941660f, 0.09965551f, 
    0.21374539f, 0.00464931f, -0.12012186f, 0.08924564f, -0.03589749f, 0.11327971f, -0.03321659f, -0.09952345f, 
    0.15779302f, -0.19060488f, 0.07617009f, -0.14613615f, 0.06021095f, -0.02922899f, -0.07831289f, 0.22749560f, 
    -0.03649819f, 0.03739952f, -0.03811902f, -0.00006059f, 0.46007460f, 0.37126946f, 0.33110759f, 0.06841616f, 
    0.04416453f, 0.13884355f, -0.01331864f, 0.02160724f, -0.04813287f, -0.07192555f, 0.10751036f, 0.16077301f, 
    -0.07895115f, -0.32755890f, -0.12838525f, 0.28351474f, 0.05914615f, 0.05351323f, -0.00864696f, -0.12992796f, 
    -0.04084516f, -0.07051007f, 0.02657822f, 0.02310630f, 0.19129296f, 0.33696160f, -0.06467248f, 0.40582544f, 
    0.03766177f, 0.00195452f, -0.10248066f, -0.11860755f, 0.05020596f, -0.00569436f, -0.13482895f, 0.04995812f, 
    -0.06500891f, 0.07721107f, -0.04495721f, 0.26957503f, 0.02378493f, -0.02291039f, -0.09310240f, -0.05569312f, 
    0.04755079f, -0.08271670f, -0.01097316f, -0.04726224f, -0.12209270f, 0.21528341f, 0.09112199f, 0.11878092f, 
    -0.00602477f, 0.00347446f, -0.11434358f, -0.00375415f, 0.07763789f, 0.14653893f, 0.10790511f, 0.06363839f, 
    -0.14518428f, -0.44758308f, -0.25068057f, 0.14154086f, -0.04648870f, 0.04621394f, -0.12588327f, -0.04442451f, 
    0.12937687f, 0.00240557f, 0.00994991f, 0.16508234f, -0.25211385f, 0.21783271f, 0.13107830f, 0.22764082f, 
    0.03491659f, 0.00035308f, 0.04681866f, -0.04987434f, -0.02869392f, -0.07264163f, 0.14794724f, -0.10018901f, 
    0.00795806f, -0.01982216f, -0.25106919f, 0.00931097f, -0.00384136f, 0.17658862f, -0.06320424f, -0.00175244f, 
    0.13678646f, 0.12189947f, -0.02670429f, -0.07535236f, 0.14532666f, -0.28375039f, -0.24803080f, -0.10816284f, 
    -0.10145891f, 0.01267546f, -0.00653857f, -0.13106295f, 0.13089250f, -0.01149486f, -0.08487577f, -0.01295431f, 
    -0.03391997f, -0.35067946f, 0.15501034f, 0.47971657f, -0.01925788f, -0.03830319f, -0.13653985f, 0.00877436f, 
    0.14492010f, 0.07972502f, 0.08423513f, -0.07410468f, 0.32315743f, 0.16939884f, 0.25183529f, 0.05516300f, 
    -0.03452455f, -0.05503899f, 0.05802634f, -0.10908972f, 0.01571598f, -0.09991992f, 0.00626064f, 0.05200906f, 
    -0.10898277f, -0.22565125f, 0.27886319f, -0.20636617f, 0.25184968f, -0.05988504f, 0.09498457f, 0.13435744f, 
    -0.15899502f, -0.15180101f, -0.14556697f, 0.17205463f, -0.20048764f, 0.17611790f, -0.03673580f, 0.09788141f, 
    -0.10857992f, -0.09718552f, 0.05149728f, -0.04199083f, -0.10610078f, -0.11957017f, 0.04738662f, -0.13484873f, 
    -0.12756367f, 0.30762681f, -0.05649630f, 0.09523397f, -0.00024993f, -0.00296196f, 0.04600713f, 0.00937718f, 
    -0.02484137f, 0.06472465f, 0.20977306f, -0.18924178f, 0.25633368f, 0.12521856f, -0.02133927f, 0.23222180f, 
    0.02961091f, -0.05035697f, 0.15332621f, 0.23445371f, 0.01695722f, -0.14445230f, 0.07631899f, -0.13897336f, 
    0.25496879f, 0.27801466f, -0.23494554f, 0.24432456f, 0.00698417f, -0.11815509f, -0.19301376f, 0.03264526f, 
    0.01610784f, 0.02596503f, -0.23772919f, 0.07729015f, -0.27490655f, -0.06395334f, -0.38490906f, 0.17577665f, 
    -0.05995708f, -0.07104882f, -0.05669719f, 0.03736149f, 0.05068329f, 0.09433000f, -0.00845888f, 0.10095859f, 
    -0.09519974f, 0.09463087f, 0.11540032f, -0.11623287f, 0.08706505f, -0.07884036f, 0.04244034f, -0.06797724f, 
    0.08526887f, 0.06558628f, 0.05872189f, 0.18028013f, 0.15172094f, 0.36689767f, -0.03850473f, 0.13082567f, 
    -0.14762795f, -0.06361357f, 0.05748229f, 0.06199103f, 0.16498008f, 0.02912495f, 0.02040214f, 0.21951021f, 
    -0.41467687f, 0.28994185f, -0.14780357f, 0.07913202f, 0.15454319f, -0.12951778f, -0.05241952f, 0.11149669f, 
    -0.05053182f, 0.10219920f, -0.08949489f, -0.03846504f, -0.05956743f, 0.15387052f, 0.13133928f, 0.26834041f, 
    -0.18841143f, 0.20574775f, -0.07468218f, -0.03282241f, -0.10359527f, 0.00291070f, -0.02634363f, -0.06646408f, 
    -0.02971469f, 0.01709608f, -0.01525669f, -0.05212338f, 0.02268409f, 0.03658159f, -0.04190547f, -0.01041157f, 
    -0.03060652f, 0.00681312f, 0.01170160f, 0.00290931f, 0.04140310f, 0.00489525f, -0.03893203f, 0.03298403f, 
    0.01538320f, -0.04748134f, -0.02914612f, -0.01219004f, 0.02978654f, 0.03376695f, -0.03969373f, 0.00253696f, 
    -0.03348852f, 0.02106184f, -0.03027368f, 0.03876885f, 0.02551840f, 0.00925986f, -0.03830982f, -0.03501793f, 
    -0.00483694f, -0.00971638f, 0.00464488f, 0.03674135f, -0.05311520f, 0.04393548f, 0.03527518f, -0.01272986f, 
    -0.03029237f, 0.00259017f, 0.02974067f, -0.01915926f, -0.05090091f, -0.04691260f, 0.00953193f, -0.01479302f, 
    0.01299090f, -0.01824451f, -0.02669682f, 0.00764242f, -0.03601781f, -0.04634030f, -0.00572863f, -0.01340543f, 
    -0.02085341f, -0.03993873f, -0.04694851f, -0.03742130f, 0.00289264f, -0.01603869f, 0.02722517f, 0.01503829f, 
    -0.03179195f, -0.03156290f, -0.01746156f, -0.00655992f, -0.03493633f, 0.01900821f, -0.01386137f, 0.00874424f, 
    0.00967782f, 0.01047791f, -0.01706076f, 0.01407311f, -0.03647550f, -0.04825552f, -0.05267157f, -0.02449402f, 
    0.00049297f, 0.00822657f, -0.00820561f, -0.05052607f, 0.00529145f, -0.04807025f, -0.01002281f, -0.02934495f, 
    0.04443135f, -0.05163762f, -0.03181173f, 0.03025462f, -0.02700315f, 0.01140954f, 0.02752612f, -0.05269512f, 
    -0.01969795f, 0.04368189f, 0.00249121f, 0.03261023f, 0.01211860f, -0.02504293f, -0.00811982f, -0.00220222f, 
    0.00242796f, 0.02409619f, -0.00718068f, -0.05484994f, -0.03844095f, 0.03767271f, 0.03827642f, 0.02969790f, 
    0.03571376f, 0.03116971f, -0.00241311f, 0.03926191f, 0.00253009f, -0.04389488f, -0.01770898f, -0.02716274f, 
    0.01738134f, 0.00442498f, 0.01235488f, 0.01383120f, -0.01771461f, 0.04068966f, -0.04619712f, -0.03063820f, 
    -0.03917375f, -0.01403482f, -0.01189087f, -0.01385627f, -0.04634130f, -0.03372661f, -0.05000030f, -0.00266777f, 
    0.02806856f, -0.05061847f, -0.03136284f, 0.03216646f, 0.02855070f, 0.02109290f, -0.03847972f, -0.00584642f, 
    -0.02633100f, -0.04477013f, -0.01588973f, -0.02469234f, 0.02268066f, -0.04740559f, -0.04699422f, -0.02673787f, 
    0.01640873f, -0.05373486f, 0.03800009f, 0.02158836f, -0.01668728f, 0.03053239f, -0.01355577f, -0.02149336f, 
    -0.05095810f, -0.00116925f, -0.02054587f, -0.00420224f, 0.04464305f, -0.03844335f, 0.02048902f, -0.04004169f, 
    -0.04690716f, -0.02216005f, -0.02681905f, -0.01767489f, -0.01843712f, -0.03729209f, 0.01998691f, 0.02727899f, 
    0.01360784f, -0.02608439f, 0.02748266f, -0.00146071f, -0.05318237f, 0.02511459f, -0.04302344f, -0.00330794f, 
    -0.04913100f, -0.04219268f, -0.04178038f, -0.04925481f, -0.01961113f, -0.01390596f, 0.02285190f, 0.01292166f, 
    -0.00803426f, 0.02751546f, 0.00677220f, -0.05225781f, 0.04015721f, 0.03810928f, -0.04788063f, -0.02601801f, 
    -0.04464396f, 0.00972126f, 0.03118431f, 0.02390065f, -0.03015856f, 0.02642745f, 0.00731980f, 0.00025050f, 
    -0.01450002f, 0.01147436f, 0.00958396f, 0.04438999f, -0.01138413f, 0.02994599f, 0.02951939f, -0.03127563f, 
    0.00754472f, -0.04087556f, 0.01301996f, -0.03965920f, 0.02416309f, -0.00508636f, -0.00202381f, 0.00100093f, 
    -0.01797504f, 0.00504428f, -0.03988745f, -0.00122422f, 0.03538686f, -0.02927084f, -0.00962568f, -0.03814565f, 
    -0.00043485f, -0.03952234f, -0.02873218f, 0.03537179f, -0.04612878f, 0.00615330f, 0.03782813f, -0.02718347f, 
    -0.03439682f, 0.04027215f, -0.03740883f, -0.04100727f, 0.04285489f, -0.05390283f, 0.04140011f, -0.01997793f, 
    0.03378603f, -0.05001036f, -0.01662243f, -0.01237149f, -0.02998312f, 0.04633711f, -0.00612637f, -0.00476634f, 
    -0.01353437f, 0.03379606f, -0.04143606f, -0.04293453f, -0.00133838f, -0.01219359f, 0.01048479f, -0.02142635f, 
    -0.02429663f, 0.04188415f, 0.04526780f, 0.02517455f, -0.03620414f, -0.00884609f, 0.01678919f, -0.00248006f, 
    -0.03627164f, -0.00604043f, 0.02949005f, -0.05137588f, 0.02721108f, -0.03488222f, -0.02119958f, -0.03237490f, 
    -0.04954950f, -0.00235667f, 0.00385526f, -0.01883585f, -0.05171914f, -0.01226181f, -0.04428036f, 0.00983162f, 
    -0.02051869f, 0.02684598f, 0.03606420f, 0.04262252f, 0.00425027f, -0.02911456f, 0.00133570f, 0.01079215f, 
    0.02294726f, 0.02005012f, -0.03478243f, -0.00904259f, 0.03778720f, -0.01273577f, 0.02356529f, -0.00772180f, 
    -0.02393954f, -0.05324708f, -0.04889276f, -0.02303928f, 0.01912743f, -0.02811771f, 0.01885872f, -0.02255417f, 
    0.04260852f, 0.03289174f, 0.01169441f, 0.02276339f, -0.01623789f, 0.03858746f, -0.04179659f, -0.01142322f, 
    -0.05333862f, 0.01212778f, 0.01663682f, 0.00475691f, -0.03565123f, 0.00129515f, 0.03675262f, -0.05073134f, 
    0.03159755f, -0.01995561f, -0.04159419f, -0.01294867f, -0.04698034f, 0.01828919f, 0.02247610f, 0.00743496f, 
    -0.04191385f, 0.04195113f, 0.00652754f, 0.01554944f, -0.04639709f, -0.00958108f, 0.00045809f, -0.00572967f, 
    -0.00189624f, -0.00232128f, 0.04391593f, -0.00532194f, 0.00975324f, -0.01560518f, -0.02577237f, 0.02175305f, 
    0.01563715f, 0.02387438f, 0.03181272f, 0.02133947f, 0.00137708f, -0.04401301f, 0.01667683f, -0.05536485f, 
    -0.02427042f, -0.02325543f, -0.02049128f, 0.04539048f, 0.00074254f, 0.02418762f, -0.05323852f, -0.01879891f, 
    -0.04438432f, 0.00514496f, 0.00231609f, -0.03552017f, 0.00627335f, -0.02077776f, 0.03761494f, 0.03473242f, 
    -0.03207706f, 0.04029762f, 0.00034420f, 0.01640636f, -0.03576640f, -0.03261945f, -0.00177414f, 0.04304077f, 
    -0.03786951f, -0.02105751f, -0.01775998f, 0.01855364f, -0.03188524f, 0.02718492f, -0.00128604f, -0.02106886f, 
    -0.04409365f, 0.03366018f, 0.01304356f, -0.04123536f, 0.02125191f, -0.00053358f, -0.05841862f, -0.02727233f, 
    -0.01976096f, -0.04705477f, -0.02205371f, 0.02872633f, 0.03306566f, 0.01055169f, -0.00294419f, 0.00794928f, 
    -0.00714556f, -0.03785397f, -0.05570246f, -0.01180255f, -0.04261401f, 0.00365552f, -0.01388872f, -0.03414641f, 
    -0.04219493f, 0.00875578f, 0.02492929f, 0.01404714f, -0.03797580f, -0.04975933f, 0.03143882f, -0.00739874f, 
    -0.00223375f, -0.00044986f, -0.01514903f, -0.05590883f, -0.03875148f, -0.02516325f, 0.01564486f, -0.02226852f, 
    -0.01978985f, -0.04063720f, 0.03720355f, -0.01841419f, -0.05081732f, -0.01017488f, 0.01537770f, -0.00101278f, 
    -0.05063939f, 0.00334371f, -0.04227787f, 0.00715237f, 0.03319480f, 0.03199667f, -0.01337180f, -0.02420734f, 
    0.03512695f, -0.04288711f, -0.03295557f, -0.03336577f, 0.03348604f, -0.03992959f, -0.05555670f, -0.00512618f, 
    -0.03875110f, 0.01829426f, 0.03202686f, 0.02988495f, -0.04255030f, -0.05114053f, 0.01894153f, 0.01548470f, 
    0.00748498f, 0.03563857f, -0.00846863f, -0.05177090f, -0.01917458f, 0.03094337f, -0.03259022f, -0.01571148f, 
    0.01812495f, 0.03305185f, -0.02259789f, -0.02370186f, -0.03891177f, 0.00827048f, -0.06567307f, -0.05281375f, 
    0.04699459f, -0.01070838f, 0.03973925f, 0.01726796f, -0.04239283f, -0.03624289f, -0.02593710f, 0.04470863f, 
    0.01729140f, 0.03054829f, -0.03924554f, 0.01228092f, -0.00308765f, -0.06007499f, 0.04176299f, 0.00275294f, 
    0.00048519f, 0.00300959f, 0.01886233f, 0.00299732f, 0.04219699f, -0.01803561f, -0.02148492f, -0.05138268f, 
    -0.02063188f, 0.04141480f, 0.01933629f, 0.02473597f, -0.06143505f, -0.04810080f, 0.00213629f, 0.01559753f, 
    -0.06038145f, 0.02701656f, 0.02742621f, -0.02144052f, -0.00314064f, -0.02406834f, -0.01020000f, -0.06266059f, 
    -0.04655179f, 0.00851290f, -0.01922049f, 0.00490674f, 0.02460411f, -0.01996465f, 0.03233743f, -0.01583421f, 
    0.01800267f, -0.01795417f, -0.04015191f, 0.04484318f, 0.02861183f, -0.05396662f, 0.02827678f, 0.02090875f, 
    0.02360796f, -0.00390110f, 0.01652403f, 0.03341031f, -0.01064149f, 0.01724818f, -0.00004403f, -0.02531338f, 
    0.02216900f, -0.05828714f, 0.00740793f, 0.03017985f, -0.04821234f, -0.01308173f, 0.05146226f, -0.03979220f, 
    -0.02332260f, -0.04352985f, 0.04280351f, -0.03623605f, 0.03076462f, -0.01886745f, 0.03540991f, -0.03211983f, 
    -0.03608831f, 0.01042801f, -0.02256097f, 0.03577079f, 0.00464007f, 0.00397210f, 0.00588017f, 0.00028711f, 
    0.02164590f, -0.05892344f, 0.02325804f, 0.01821385f, -0.01886029f, -0.00048546f, -0.02180312f, -0.01393117f, 
    -0.03326784f, -0.01081194f, -0.00455082f, -0.00742486f, -0.04658677f, -0.03544638f, -0.02324974f, -0.05715127f, 
    -0.03612174f, -0.01587318f, 0.03554709f, 0.00250563f, 0.03813039f, -0.05272948f, 0.01113263f, -0.05113428f, 
    0.01542007f, 0.00674052f, 0.00359313f, 0.00387752f, -0.05210453f, 0.01931514f, -0.04692693f, -0.00849296f, 
    -0.05387940f, -0.02982705f, 0.02327029f, -0.00404665f, -0.04319307f, 0.00634254f, -0.01300240f, -0.04352457f, 
    0.03427571f, 0.01201385f, 0.02661889f, -0.02308563f, -0.05034474f, 0.00285257f, -0.04404446f, 0.03707201f, 
    -0.00459212f, 0.03065622f, 0.03581131f, -0.04651871f, 0.03483038f, -0.04059709f, -0.00648668f, -0.00199818f, 
    0.01289073f, -0.01143371f, -0.02889841f, 0.00098702f, 0.01821030f, -0.04510847f, -0.01614801f, -0.03321813f, 
    0.02935800f, 0.01421892f, -0.00145974f, 0.04547747f, -0.01237450f, 0.03008933f, 0.03538191f, 0.02253752f, 
    0.02420104f, 0.00714049f, -0.00376653f, -0.06236378f, -0.04091594f, 0.01877740f, -0.04424151f, -0.05581982f, 
    -0.06767899f, -0.00013963f, -0.00707539f, -0.02689865f, -0.02171285f, 0.03144455f, 0.04230677f, -0.01786259f, 
    -0.04444286f, 0.02052357f, 0.04339765f, -0.00404684f, -0.03968545f, -0.04811285f, 0.01692632f, -0.00939946f, 
    0.04652522f, 0.04824534f, 0.02500222f, -0.00166209f, -0.00897010f, 0.01274033f, -0.02592588f, 0.04321189f, 
    0.02179076f, -0.00396362f, -0.02190913f, -0.04481182f, 0.01449689f, 0.00191767f, -0.02609889f, -0.05584769f, 
    0.03954631f, 0.02956064f, 0.03429474f, 0.02571071f, -0.01818659f, -0.03832746f, -0.05351199f, 0.02714304f, 
    0.04120814f, -0.04783192f, -0.00058926f, -0.02983829f, 0.02327115f, 0.01278629f, 0.02534301f, 0.01205598f, 
    0.03504170f, 0.01253709f, 0.02803279f, -0.02660961f, -0.00016677f, 0.02074751f, -0.05383614f, -0.04964345f, 
    0.01865667f, -0.00475269f, -0.03553572f, -0.00974476f, 0.02580690f, 0.01690441f, -0.05098253f, 0.02494713f, 
    -0.00232518f, -0.00893657f, 0.02885772f, 0.00922245f, -0.01235470f, -0.03585551f, -0.02183083f, -0.03869819f, 
    0.01809689f, 0.03295128f, 0.03067533f, -0.00226000f, 0.01433484f, 0.03207903f, 0.01150839f, 0.02342059f, 
    -0.04708049f, -0.03702564f, -0.00995978f, -0.03142184f, -0.03310923f, -0.03542804f, 0.00150044f, 0.03761370f, 
    -0.03264805f, 0.03615446f, -0.05999019f, 0.04803304f, 0.03858864f, -0.06359176f, -0.03985071f, 0.00193781f, 
    -0.03724203f, -0.01171626f, 0.02474111f, -0.03561351f, 0.00639909f, 0.01204745f, 0.01591117f, -0.02572941f, 
    -0.03937281f, 0.02778485f, -0.00854425f, 0.00967475f, -0.00165514f, 0.01466127f, -0.00023954f, -0.01291358f, 
    0.02805761f, 0.00297245f, 0.00712879f, 0.03396721f, 0.03732810f, -0.01171697f, -0.03206298f, 0.02631263f, 
    -0.00295512f, 0.04244277f, 0.00883425f, 0.01744130f, -0.00362537f, 0.03847171f, -0.03019622f, 0.02880157f, 
    -0.04028117f, 0.02931851f, 0.04503480f, -0.04850814f, -0.02977439f, -0.01828884f, 0.02492154f, -0.02672202f, 
    0.01122479f, -0.01191319f, -0.02983228f, 0.04128569f, 0.04470714f, -0.04457283f, -0.02294119f, 0.00716719f, 
    0.00278360f, -0.03352791f, -0.03248497f, -0.02763496f, -0.01001155f, -0.02178564f, 0.00097597f, -0.00741548f, 
    -0.03480088f, -0.00193618f, -0.05321940f, 0.03588394f, 0.04005327f, 0.03454437f, -0.02148514f, -0.04009884f, 
    -0.03353148f, 0.00488438f, -0.02671745f, -0.05412060f, 0.03657880f, 0.00766567f, 0.04341665f, 0.03929950f, 
    -0.02778183f, 0.03770302f, -0.01671974f, 0.01774356f, 0.02852704f, -0.01550998f, 0.02753331f, -0.04454633f, 
    -0.00851885f, -0.02276235f, -0.01802262f, 0.00858072f, -0.01397700f, -0.05091447f, 0.04046807f, 0.01483939f, 
    -0.03230677f, 0.04363729f, 0.00871634f, -0.04560748f, -0.05181921f, 0.02907035f, 0.00290524f, -0.02891332f, 
    -0.02344766f, -0.00331687f, 0.02299917f, 0.02441769f, 0.02864288f, -0.00018198f, -0.02835001f, -0.05056310f, 
    0.00145538f, 0.00265536f, 0.01568739f, 0.03777405f, -0.02025377f, 0.04714300f, 0.03218171f, -0.02392775f, 
    0.00666282f, -0.01079914f, 0.01597972f, -0.04558765f, 0.01848542f, 0.01727068f, -0.04212053f, 0.01767121f, 
    -0.01679554f, 0.02096117f, 0.04425099f, 0.02037290f, -0.02090253f, -0.02024938f, 0.03412450f, 0.01025214f, 
    0.03254553f, -0.02771505f, 0.00079215f, 0.03920091f, -0.00476558f, -0.02118319f, -0.04178750f, -0.04401618f, 
    0.02918997f, -0.04421062f, 0.01697512f, -0.05239373f, 0.04161088f, 0.02446867f, 0.04400955f, -0.02400652f, 
    -0.02296400f, -0.00317360f, 0.03608120f, 0.03185389f, -0.04787518f, -0.04442322f, -0.03022332f, -0.04227537f, 
    -0.03636439f, -0.03161770f, 0.02981361f, -0.04294604f, 0.02701779f, 0.01921687f, -0.00358695f, 0.04915936f, 
    0.03747299f, 0.01491546f, -0.01099610f, -0.00018243f, 0.04304070f, -0.03856622f, 0.04967571f, -0.02736288f, 
    -0.03810601f, 0.02648681f, 0.04038870f, -0.00179385f, -0.03669786f, 0.03084121f, -0.04085408f, -0.01365072f, 
    -0.04844063f, 0.02516933f, -0.00694620f, 0.01961527f, 0.00815989f, -0.01180872f, 0.00245808f, -0.00720416f, 
    -0.02592322f, -0.03448851f, 0.04228832f, -0.02695299f, -0.03982778f, -0.02001331f, -0.05168948f, -0.03666623f, 
    -0.03970349f, 0.03076397f, 0.03853866f, 0.00869838f, 0.03254207f, 0.02275126f, 0.04414130f, -0.03091035f, 
    -0.05330307f, -0.01047459f, 0.00968280f, 0.04476397f, -0.04999407f, 0.02553253f, -0.02669787f, -0.03968848f, 
    -0.03827030f, -0.00599868f, 0.03300918f, -0.00127770f, 0.03421850f, -0.01915364f, -0.03138731f, -0.02739209f, 
    -0.04275674f, 0.01720088f, 0.00954589f, 0.01070227f, 0.04812691f, -0.00152292f, -0.00859695f, 0.02787622f, 
    -0.04431157f, 0.00508357f, -0.03683188f, -0.02210842f, -0.03514797f, 0.03680342f, 0.03379102f, -0.04876580f, 
    0.03190937f, 0.01393351f, -0.02667008f, 0.03139931f, -0.03488848f, -0.04662539f, -0.04944644f, 0.02124959f, 
    0.03718009f, 0.02865784f, 0.01210063f, -0.00393826f, 0.00769781f, 0.03952312f, -0.00333222f, -0.01517340f, 
    0.02789554f, 0.03681178f, -0.05024752f, -0.03149066f, 0.01464053f, 0.00330166f, 0.01932221f, 0.01348151f, 
    0.04993802f, -0.05288447f, -0.03176605f, -0.04680300f, -0.01535665f, -0.04916564f, 0.00211791f, -0.00553045f, 
    0.03615381f, 0.04144798f, 0.04658378f, 0.03106455f, -0.02031052f, -0.01449200f, -0.00415439f, -0.01849049f, 
    0.00861612f, 0.01583911f, 0.02209487f, -0.00985744f, -0.04617707f, 0.02111800f, 0.04265715f, 0.03660138f, 
    0.04174989f, -0.00148841f, -0.01906113f, -0.02879253f, -0.00460763f, 0.02322622f, 0.00581765f, 0.02990632f, 
    0.04437730f, 0.03793379f, -0.04363320f, 0.04872826f, 0.00793971f, -0.04255753f, -0.03405979f, 0.02033278f, 
    -0.04765135f, -0.05019626f, -0.00933220f, -0.04583454f, -0.03707879f, -0.00790446f, 0.02958353f, -0.03245955f, 
    -0.01779522f, 0.03878470f, -0.04224735f, 0.03189669f, -0.01796242f, -0.04527288f, -0.05046064f, -0.04790212f, 
    -0.01849572f, -0.05366135f, 0.02308225f, -0.05784104f, 0.00354504f, -0.04686134f, -0.04046087f, -0.01851466f, 
    -0.04541221f, 0.03528295f, 0.00269018f, 0.03813112f, -0.02266415f, 0.04572692f, -0.05045487f, -0.04109010f, 
    -0.00442805f, -0.00309000f, -0.04694515f, -0.04639792f, 0.03149437f, 0.01065130f, 0.04250194f, 0.04188680f, 
    -0.04273370f, -0.04141321f, 0.02147014f, -0.04725776f, -0.03657490f, 0.01510432f, -0.03756552f, -0.02631702f, 
    0.02895799f, -0.00302694f, 0.00240329f, -0.02405522f, -0.02554329f, -0.00126173f, -0.03418894f, 0.03558712f, 
    -0.02836230f, 0.04982613f, -0.00632631f, -0.04337146f, -0.02467325f, -0.03105098f, 0.03750500f, 0.01773943f, 
    -0.04881633f, 0.04730369f, -0.02544241f, -0.02441104f, 0.03204788f, -0.03193390f, -0.04446209f, 0.02006886f, 
    -0.00646099f, -0.03638419f, -0.04234292f, 0.01238266f, 0.00266623f, -0.04690077f, 0.02424595f, -0.03868341f, 
    0.02912060f, 0.01021917f, -0.05248458f, -0.01299436f, 0.00451732f, -0.02717196f, -0.05010261f, -0.02602871f, 
    -0.02088338f, -0.03944177f, -0.04267190f, -0.05122096f, -0.02562379f, -0.03642032f, -0.01910827f, -0.01620256f, 
    0.03687857f, 0.00033830f, 0.01487252f, 0.00337858f, -0.03852072f, 0.02977994f, -0.04975680f, 0.02204614f, 
    -0.01078175f, -0.05387509f, 0.00559112f, 0.03464589f, -0.02864462f, 0.00000227f, 0.00269344f, -0.05412458f, 
    0.49625751f, 0.15584932f, 0.17311884f, -0.14842638f, 0.15113261f, -0.07429192f, -0.00184025f, 0.07851391f, 
    0.00382655f, 0.03121635f, -0.07347828f, -0.01565963f, -0.37216297f, 0.11172544f, 0.24395958f, 0.05514294f, 
    -0.05534027f, -0.15427105f, -0.04786528f, 0.04618598f, 0.09626953f, -0.01076746f, 0.05103776f, -0.06339776f, 
    -0.40092051f, -0.03244756f, 0.32402793f, 0.07221803f, 0.16568993f, 0.12593828f, -0.00035799f, -0.03089770f, 
    -0.10283503f, 0.07283077f, -0.00738888f, 0.02971943f, 0.05450372f, 0.22996354f, 0.16766514f, 0.05149174f, 
    -0.15409777f, -0.09265341f, -0.05579024f, -0.21685381f, -0.01274427f, -0.01077690f, -0.03396720f, -0.04284644f, 
    -0.15665792f, 0.29485187f, 0.02144554f, -0.12237517f, 0.00647861f, -0.02387196f, 0.11815687f, 0.11076931f, 
    0.08272359f, -0.03876915f, 0.12154048f, 0.18422885f, 0.07943612f, -0.20468467f, 0.10706426f, 0.12212670f, 
    0.12084963f, 0.03574840f, -0.07950871f, 0.07673737f, 0.19189136f, -0.04713217f, -0.07920159f, 0.09464043f, 
    0.23644829f, -0.13975690f, -0.23254693f, -0.23454235f, -0.09862382f, 0.07678001f, 0.12663490f, -0.11692140f, 
    -0.06090388f, -0.01029086f, 0.08863441f, 0.11056659f, -0.28738227f, 0.04776985f, -0.14354131f, -0.14195901f, 
    0.05227030f, -0.09792724f, -0.01977761f, 0.12095784f, 0.08907487f, 0.14847407f, -0.09497579f, -0.03057034f, 
    0.10257778f, 0.23066303f, -0.02254000f, 0.19773114f, 0.07490577f, 0.01620630f, 0.05479952f, -0.00261578f, 
    0.05679142f, 0.05328956f, 0.02208944f, -0.01598042f, 0.46799815f, 0.05452826f, 0.12500772f, 0.21518467f, 
    0.08742060f, -0.10013910f, -0.04101086f, -0.04722353f, 0.00920190f, 0.07868706f, 0.21044730f, -0.15442325f, 
    -0.27783346f, 0.01023110f, -0.05715954f, -0.25167459f, 0.06881873f, -0.07577801f, -0.09123218f, 0.19473778f, 
    -0.04791112f, 0.03857765f, 0.02965694f, 0.15893680f, -0.03748574f, -0.23501724f, 0.03426514f, 0.16187969f, 
    0.18735762f, -0.05984498f, 0.01757439f, -0.04954708f, 0.06394727f, 0.18409644f, 0.06273755f, 0.06272246f, 
    0.30770814f, 0.53479040f, 0.40763348f, 0.12186625f, 0.15377088f, 0.02128383f, 0.09663235f, 0.03166232f, 
    -0.00744527f, -0.04962956f, -0.02495383f, 0.02857598f, 0.04512738f, -0.19923365f, -0.20900956f, -0.03209203f, 
    -0.07359338f, -0.03677221f, 0.00872098f, 0.09613072f, 0.01574064f, 0.11930237f, -0.09483968f, 0.04808833f, 
    -0.04435917f, -0.01301790f, 0.04802084f, -0.10365031f, 0.11215344f, 0.12334988f, 0.03372639f, -0.09337229f, 
    0.12219640f, 0.20862685f, -0.05294257f, 0.22818486f, -0.24012215f, 0.15804933f, -0.04225239f, -0.18678463f, 
    -0.00040604f, -0.06926826f, -0.12267865f, 0.10805710f, 0.01333326f, 0.20038897f, 0.01510977f, 0.00259969f, 
    0.16810529f, 0.24719083f, 0.26215199f, 0.22673894f, 0.09222610f, -0.08989885f, 0.09578954f, 0.03130705f, 
    0.14045416f, -0.05867988f, 0.17571367f, 0.04444523f, -0.17530935f, -0.27175218f, -0.13877115f, 0.12357622f, 
    0.12768805f, 0.08527735f, -0.06338086f, -0.04188641f, 0.02179733f, 0.08630493f, 0.00827650f, 0.00822428f, 
    0.07358990f, 0.32537916f, -0.03151516f, 0.19930585f, 0.12653714f, -0.04106098f, 0.01399304f, -0.12094245f, 
    0.16813657f, 0.16402210f, -0.05368712f, 0.21240716f, 0.51090842f, 0.15923464f, -0.05045241f, 0.05613961f, 
    0.07024075f, -0.01046650f, 0.13000298f, 0.03814404f, -0.07746312f, -0.04036871f, -0.04003879f, -0.00676356f, 
    -0.33040860f, -0.02696721f, -0.08198984f, 0.08890191f, -0.00207623f, -0.04319340f, 0.09092753f, 0.07628518f, 
    0.00429811f, 0.10428815f, 0.03936338f, 0.09711577f, 0.05248480f, -0.22693068f, -0.18696018f, 0.14218320f, 
    0.15467082f, 0.07533486f, 0.05727407f, -0.04324181f, -0.06225414f, 0.00847330f, -0.04577770f, 0.14039098f, 
    -0.03751741f, -0.10406085f, -0.06725280f, -0.12068820f, 0.07347644f, 0.01918284f, 0.18276784f, 0.00007751f, 
    -0.05728608f, -0.03000500f, 0.14552167f, 0.01338019f, 0.19432524f, -0.21709654f, 0.11275193f, 0.11875206f, 
    -0.03681948f, -0.02648250f, -0.00362286f, 0.09161241f, 0.05909350f, -0.08281527f, 0.17412245f, 0.03334159f, 
    0.34160310f, 0.28227174f, 0.14253607f, -0.07493796f, 0.08614218f, 0.04796246f, -0.00753263f, 0.06973779f, 
    -0.04609459f, 0.12573977f, 0.01366872f, -0.06303385f, -0.12206867f, 0.04753703f, 0.00507424f, -0.10580773f, 
    0.16730301f, -0.09609761f, 0.13657586f, 0.06722643f, -0.08249163f, -0.00451834f, 0.10309567f, -0.14806108f, 
    -0.30748102f, -0.20063381f, -0.17940331f, -0.15358856f, 0.17927568f, -0.01763125f, 0.03643496f, 0.02477601f, 
    0.00004114f, 0.03275141f, -0.08474609f, 0.13724677f, -0.10338522f, 0.06882101f, -0.04853546f, -0.07239250f, 
    -0.07421054f, -0.06753733f, -0.07314751f, 0.14027776f, -0.14391683f, -0.03947624f, -0.10296894f, 0.04758070f, 
    0.15247363f, -0.23913388f, -0.17429465f, -0.13078196f, -0.05843220f, -0.15344594f, -0.02268429f, -0.00918782f, 
    0.02159408f, 0.06206127f, 0.10241423f, 0.07635210f, -0.06234045f, -0.15867370f, 0.04611210f, 0.13088521f, 
    0.17603643f, -0.06689104f, 0.01572803f, 0.10595737f, 0.03173567f, -0.02566509f, 0.05421569f, -0.04276403f, 
    -0.71375072f, -0.33356053f, -0.13360341f, -0.01567070f, 0.02613760f, -0.03480875f, 0.01501219f, -0.03817742f, 
    -0.03264328f, -0.03077687f, -0.04023269f, -0.01177256f, -0.13675304f, -0.18863106f, 0.03275509f, 0.00822219f, 
    0.10196029f, 0.05544310f, -0.11726601f, 0.20044026f, 0.03199246f, -0.18488157f, 0.13978902f, 0.03740346f, 
    -0.26082259f, -0.27869135f, -0.05014247f, 0.01211158f, 0.03587904f, 0.08799943f, -0.05682338f, 0.08850418f, 
    -0.05742772f, -0.08547848f, 0.12638652f, 0.24521826f, 0.09633038f, -0.23118509f, 0.00674960f, -0.11933695f, 
    0.13522288f, -0.11694315f, -0.08447291f, 0.01707514f, 0.10737105f, -0.17118910f, -0.06216305f, -0.02610695f, 
    -0.08607332f, -0.14146160f, -0.10273366f, -0.13491897f, 0.05460037f, 0.15167929f, 0.23042706f, 0.02302247f, 
    -0.08248101f, 0.04853340f, -0.00335502f, -0.02331991f, 0.01544813f, -0.08550878f, 0.07212041f, -0.20140457f, 
    0.02425513f, 0.06332909f, -0.14310186f, -0.02942053f, 0.13423645f, -0.07861593f, 0.02123897f, 0.13791104f, 
    0.47291771f, -0.10274286f, -0.12881199f, 0.03438454f, 0.09856160f, -0.05551124f, 0.03587653f, 0.06970716f, 
    0.19656649f, -0.01899889f, 0.04956920f, 0.04768327f, -0.26945293f, 0.14887685f, 0.13905364f, 0.04917096f, 
    0.11614401f, -0.11972924f, -0.08116501f, -0.03741642f, 0.01969725f, -0.02164274f, -0.00836848f, -0.20129967f, 
    -0.08532056f, 0.08910295f, 0.40333170f, 0.22178009f, -0.10687072f, -0.01322485f, -0.04984001f, 0.02777898f, 
    0.16451325f, 0.02203709f, -0.07442879f, 0.17699261f, 0.21945818f, -0.17071214f, -0.03444198f, 0.15401655f, 
    0.13425933f, 0.32547900f, 0.10751556f, 0.12868378f, -0.02922685f, 0.06145039f, -0.00777358f, -0.06179220f, 
    -0.06758977f, -0.25515851f, 0.03615428f, -0.14604288f, -0.04185810f, 0.11285460f, -0.03746966f, 0.01995843f, 
    0.23211281f, 0.00625038f, 0.14512418f, 0.10664269f, -0.13545647f, -0.08303367f, 0.04030561f, -0.00841958f, 
    0.06629831f, 0.07596139f, -0.10705107f, 0.22271302f, -0.03123797f, 0.05896406f, 0.01311359f, 0.14453970f, 
    -0.09768868f, 0.22440827f, -0.14096211f, 0.00955208f, -0.09875599f, 0.05954885f, -0.03042958f, -0.01566988f, 
    0.08064229f, 0.00447667f, 0.14802372f, -0.01014296f, -0.04125108f, -0.16053326f, -0.07225193f, 0.01623010f, 
    -0.03362029f, 0.11819237f, -0.04566402f, -0.02432678f, 0.07585011f, 0.02502966f, -0.11855920f, 0.13934675f, 
    -0.17203005f, 0.02368909f, -0.16150714f, -0.13341720f, 0.17193112f, 0.05383950f, 0.07676571f, -0.01397377f, 
    -0.10701787f, -0.04978255f, 0.01100982f, 0.19625588f, -0.17451972f, -0.26196280f, 0.18330044f, -0.10154460f, 
    0.13686042f, 0.04969066f, -0.05748196f, -0.02837975f, 0.12316430f, 0.11063343f, -0.02902880f, 0.00037028f, 
    0.01561512f, -0.04156666f, 0.21079804f, 0.05224307f, 0.05006868f, -0.20804861f, -0.08368482f, 0.16040242f, 
    -0.09604236f, 0.12611878f, 0.03302314f, 0.02863017f, -0.14650109f, -0.05970543f, -0.00864404f, 0.12681143f, 
    0.23261350f, 0.00872447f, 0.06854343f, -0.01458733f, -0.07543864f, 0.19671613f, 0.00112370f, 0.24419345f, 
    0.32808837f, -0.22813711f, -0.08999380f, 0.00518344f, 0.01922660f, -0.03084547f, 0.05036530f, 0.05628590f, 
    0.08150285f, 0.01479554f, -0.03292364f, 0.05148710f, -0.37723330f, 0.06659947f, -0.10003196f, -0.07835569f, 
    0.19164152f, 0.03772239f, 0.05533455f, 0.01677608f, 0.09682920f, -0.06399248f, 0.07649094f, -0.12616226f, 
    0.14998001f, 0.08194651f, 0.37989733f, -0.01988280f, -0.05110414f, -0.01455750f, 0.01505600f, -0.04903189f, 
    -0.05725248f, -0.03286858f, 0.10975448f, -0.12154406f, 0.11644450f, -0.00124818f, 0.24884829f, 0.03209316f, 
    -0.17930561f, 0.15037610f, 0.10612096f, -0.08404000f, 0.04489307f, -0.08085031f, 0.02217252f, 0.04875531f, 
    0.21775188f, -0.11313064f, 0.06813975f, 0.24446532f, -0.09744873f, 0.03451253f, 0.03580793f, 0.02033165f, 
    -0.11677051f, 0.05427025f, -0.05029637f, 0.04604386f, 0.10038646f, -0.05379888f, 0.36284944f, 0.35193583f, 
    -0.07042088f, 0.09736282f, -0.06714211f, 0.15026787f, -0.00873740f, -0.00909068f, 0.05520748f, 0.07188806f, 
    -0.24844967f, 0.08443671f, -0.03295017f, 0.15763701f, 0.09700123f, 0.03190428f, -0.13387512f, 0.24751052f, 
    0.07653379f, -0.12656847f, -0.06269868f, 0.07475277f, -0.28842628f, 0.36457568f, -0.12060621f, -0.27501878f, 
    0.36994365f, 0.08251465f, 0.09313241f, -0.10400232f, 0.00121151f, -0.00856139f, 0.00902356f, -0.09674965f, 
    -0.40587172f, 0.21537067f, -0.13464572f, -0.07352941f, -0.06056836f, -0.05057433f, 0.03544521f, -0.01088783f, 
    -0.00048869f, 0.04091648f, 0.17193961f, -0.13982254f, -0.13437423f, 0.10004389f, 0.10303856f, 0.28591603f, 
    0.03670079f, 0.07043420f, 0.30669615f, 0.15015501f, 0.05552679f, -0.06787268f, 0.10304989f, -0.16703665f, 
    0.33524969f, -0.05787154f, 0.29879329f, 0.16859034f, 0.12478701f, -0.07138140f, -0.02673032f, -0.13066733f, 
    0.16414589f, 0.02178327f, 0.01706824f, 0.04995950f, 0.26976198f, 0.07666001f, 0.02800956f, 0.17892195f, 
    -0.10918491f, 0.00655679f, 0.03755580f, 0.01726750f, 0.01016842f, -0.03322444f, -0.02016316f, 0.07953337f, 
    -0.12452915f, 0.25988933f, 0.16195752f, 0.16988076f, -0.07148204f, -0.11548510f, -0.02078853f, 0.04638344f, 
    0.02116797f, 0.00856316f, -0.10539144f, 0.01850986f, -0.08617447f, -0.10849587f, 0.41458938f, -0.12715414f, 
    0.03136687f, 0.06374799f, -0.04548540f, 0.01017123f, 0.08444372f, -0.00129625f, 0.08550497f, 0.18969172f, 
    -0.41028559f, -0.22043002f, 0.25460255f, -0.13306567f, -0.01825251f, 0.09479292f, -0.07932213f, -0.09821258f, 
    0.15232329f, 0.02596558f, 0.00896294f, 0.02754947f, 0.11058332f, -0.04414197f, -0.06223791f, -0.00837057f, 
    -0.01001413f, 0.04791542f, -0.10976368f, 0.19727288f, -0.03703677f, 0.09136659f, -0.04041056f, 0.00217910f, 
    0.00693774f, -0.01835157f, -0.02214031f, 0.01559847f, -0.01955945f, -0.04217771f, -0.03459093f, -0.03526597f, 
    -0.01932279f, -0.01652338f, 0.03012100f, -0.02146155f, -0.01002486f, 0.02966898f, 0.02365878f, 0.00154622f, 
    -0.02412371f, 0.03863335f, -0.01277186f, 0.03060257f, 0.00267852f, 0.03004302f, 0.00430329f, -0.03376939f, 
    0.00559378f, 0.02719410f, 0.01337082f, 0.01893278f, -0.02902636f, 0.02570686f, 0.01180313f, -0.04418698f, 
    -0.03084697f, 0.01260609f, -0.02996547f, -0.00663619f, -0.01297223f, -0.02615843f, 0.04197726f, -0.03365337f, 
    0.04044439f, -0.00823814f, -0.05274254f, -0.04617597f, 0.04401579f, -0.02643536f, 0.00329227f, 0.00563568f, 
    -0.04863012f, -0.04656484f, -0.03366942f, 0.03420106f, -0.04629119f, 0.01190423f, -0.00426351f, 0.01937088f, 
    -0.03917754f, -0.03400166f, -0.03477014f, -0.03599377f, -0.00464250f, 0.01702261f, -0.00056964f, -0.01280748f, 
    -0.00404517f, 0.02269982f, 0.04190614f, -0.02884162f, -0.00516378f, -0.03545902f, -0.02593723f, -0.04597045f, 
    0.00286938f, 0.00741363f, -0.01834708f, -0.00963356f, 0.04388461f, -0.05566021f, -0.05593099f, -0.01096161f, 
    -0.02231965f, 0.01277072f, 0.04090424f, 0.03504219f, -0.01662485f, -0.05443607f, 0.02538713f, -0.00139178f, 
    0.01239112f, -0.04730129f, 0.02676096f, -0.03402755f, -0.01471212f, -0.03712276f, 0.02634301f, -0.00402871f, 
    -0.00429845f, 0.01440232f, -0.04415440f, -0.03106188f, -0.05217686f, -0.05699290f, -0.00478846f, 0.00725282f, 
    -0.04043594f, -0.00143496f, 0.04347806f, -0.00580814f, 0.02287014f, -0.03351748f, -0.05384780f, -0.02506834f, 
    -0.01500894f, 0.00731842f, 0.04082180f, -0.01438451f, -0.00832823f, -0.02622842f, -0.05416595f, 0.02529690f, 
    -0.02237017f, -0.04022722f, -0.00116156f, -0.05430684f, 0.03910755f, 0.03334994f, -0.02348336f, -0.01764002f, 
    0.03764765f, -0.04475036f, -0.03846835f, 0.02474551f, -0.03869756f, -0.03090173f, -0.01075941f, 0.01401111f, 
    0.03529808f, 0.00283468f, 0.00015715f, -0.02110999f, 0.02686045f, 0.00182245f, -0.01691208f, -0.02670549f, 
    -0.03158082f, 0.01971077f, -0.02544637f, -0.04035806f, 0.00860284f, -0.00958655f, -0.03596613f, -0.03295497f, 
    -0.03851375f, 0.00123775f, 0.03782585f, -0.01245905f, 0.02657718f, -0.01111253f, 0.03028829f, 0.00933181f, 
    -0.04041255f, -0.02409918f, 0.00981463f, -0.02735077f, -0.01682318f, -0.02917196f, -0.05334901f, -0.03534615f, 
    0.01698954f, -0.00835187f, 0.03406887f, 0.00863109f, 0.02025656f, -0.04413078f, 0.01588346f, -0.00209032f, 
    -0.04854405f, 0.00940665f, 0.01990436f, 0.01740178f, 0.03907164f, 0.00487087f, -0.01072872f, -0.00910076f, 
    0.02214670f, -0.03759706f, 0.00225297f, 0.03010590f, -0.01018113f, -0.00550684f, 0.03505971f, -0.03227158f, 
    -0.04425673f, 0.00261635f, -0.02393554f, 0.04252512f, -0.01513178f, -0.02116011f, 0.02698774f, -0.02789414f, 
    -0.00360059f, 0.01723260f, 0.02464383f, 0.02723557f, 0.00254493f, -0.05157723f, 0.00720360f, -0.02420051f, 
    -0.01865058f, 0.00615640f, 0.03400009f, -0.02639308f, 0.02689080f, 0.01934471f, 0.00539773f, 0.01812519f, 
    0.00234315f, -0.02937740f, 0.00657023f, -0.00283090f, -0.01774480f, 0.02812052f, -0.04335409f, 0.03613609f, 
    -0.04328709f, -0.05348142f, 0.02209193f, 0.03185833f, -0.02199049f, -0.00717445f, -0.04417910f, 0.02570813f, 
    0.03390032f, -0.03238248f, -0.00571490f, 0.03801041f, -0.05264041f, -0.01488569f, -0.00712650f, 0.02869110f, 
    -0.02836229f, -0.04126640f, 0.02354374f, 0.03098735f, 0.02393915f, -0.00132245f, 0.03001542f, 0.03136278f, 
    0.01161812f, 0.02379578f, -0.01428463f, -0.05045298f, 0.03395731f, -0.04990385f, 0.04342320f, -0.02133391f, 
    -0.00211097f, -0.01585751f, -0.03600893f, 0.00080479f, 0.03082694f, 0.01500149f, -0.02582645f, -0.01711998f, 
    0.03449601f, 0.04271340f, 0.02719201f, 0.00206710f, 0.02283041f, 0.03162953f, -0.01462432f, 0.04252305f, 
    0.02586111f, 0.04195925f, 0.01287522f, -0.01528239f, 0.01073931f, 0.01634627f, 0.02919671f, -0.00079555f, 
    -0.04175013f, 0.03458788f, -0.01764075f, -0.04467027f, 0.02037536f, -0.00527337f, -0.01996654f, -0.05554131f, 
    -0.02997026f, 0.03196679f, 0.03016578f, 0.00163578f, -0.00315232f, 0.03370170f, -0.01663313f, -0.04985070f, 
    -0.02484897f, -0.02922965f, 0.04252722f, -0.01099987f, -0.02309582f, -0.04276480f, -0.05441074f, -0.00274207f, 
    -0.03382798f, 0.03169963f, -0.04360173f, -0.03324369f, -0.00481182f, 0.04190375f, -0.05626635f, 0.03251243f, 
    -0.02622792f, 0.02862041f, -0.03669596f, -0.04081712f, -0.02759028f, -0.05486514f, -0.03292436f, 0.00731308f, 
    -0.02981317f, -0.05393673f, 0.04299974f, -0.05470821f, -0.04224584f, 0.00205877f, -0.05696505f, -0.01823372f, 
    -0.00222106f, 0.02614286f, -0.03582466f, 0.03671322f, 0.02995820f, -0.03301094f, 0.00675737f, -0.03456337f, 
    -0.04250938f, -0.03005178f, -0.03044094f, 0.01526417f, -0.04322383f, 0.04494675f, -0.02417626f, -0.00500781f, 
    -0.04748770f, -0.02171408f, 0.02095758f, -0.00812550f, 0.04200919f, -0.02727441f, -0.01470298f, 0.02460555f, 
    0.02550531f, 0.01627601f, -0.05458483f, 0.03374508f, -0.01524887f, 0.00210486f, -0.05432577f, 0.01509983f, 
    0.00941624f, 0.02885406f, 0.02489529f, -0.01903229f, -0.00796213f, -0.02744022f, -0.01335115f, -0.04601356f, 
    -0.05678766f, -0.03060090f, 0.00748229f, -0.05242296f, -0.04164335f, 0.02477865f, -0.03824955f, -0.02363972f, 
    -0.03322378f, 0.03191913f, -0.03726474f, -0.04338209f, 0.01893973f, -0.03008067f, -0.02566963f, -0.04771837f, 
    -0.03504263f, 0.09867138f, -0.00975977f, 0.10894962f, -0.02180179f, 0.02623551f, 0.06698927f, 0.03878068f, 
    0.10804041f, 0.11346558f, -0.01849901f, -0.03600054f, 0.37425402f, 0.09830158f, 0.15063167f, -0.12768516f, 
    -0.02296984f, 0.12368881f, -0.02529440f, 0.07321189f, -0.00117979f, 0.10001122f, 0.02213524f, 0.08664645f, 
    0.42332923f, -0.02140923f, 0.01252737f, -0.01717535f, -0.02590971f, 0.01051931f, -0.02498295f, 0.00303143f, 
    0.14676754f, -0.18188907f, 0.07024655f, -0.08681601f, 0.45972916f, 0.03177483f, -0.27801609f, -0.01656534f, 
    -0.10453268f, 0.19702968f, 0.02151880f, 0.05531498f, 0.04030443f, 0.04312675f, -0.03020891f, -0.01022811f, 
    0.11883610f, -0.11477754f, -0.01359531f, 0.06968939f, 0.08433472f, -0.01947229f, -0.05861250f, -0.03969410f, 
    -0.09611533f, -0.00688703f, -0.02907784f, -0.07542268f, -0.05382722f, -0.06225787f, -0.21207888f, 0.02469183f, 
    -0.08708376f, 0.01595811f, 0.05927105f, 0.08476295f, -0.08682748f, 0.12102717f, 0.21026802f, 0.22657169f, 
    -0.15311587f, 0.13543372f, -0.03766204f, -0.18952063f, 0.17145635f, 0.04771454f, 0.05744093f, 0.15194102f, 
    -0.00765300f, 0.03723031f, -0.04513574f, -0.09729902f, -0.43640608f, -0.22067232f, -0.02516548f, -0.00236111f, 
    -0.09380045f, -0.23854268f, 0.00959289f, 0.00903431f, -0.16997257f, -0.21202627f, 0.17478405f, 0.13500224f, 
    0.17996864f, 0.07913939f, 0.04617261f, 0.14271940f, -0.03560971f, -0.14961603f, -0.03207727f, 0.00272815f, 
    -0.18563573f, -0.11011973f, -0.09206476f, -0.13091023f, 0.19517499f, -0.00811983f, -0.07684456f, 0.06501799f, 
    -0.18307295f, 0.05751957f, 0.17232677f, 0.09494950f, 0.00307539f, -0.07100243f, -0.09918238f, 0.02073637f, 
    0.00088281f, -0.16901885f, 0.06726021f, -0.18694608f, 0.06921916f, 0.05542427f, 0.18151383f, -0.13462375f, 
    -0.01383040f, 0.06220091f, -0.12234001f, 0.02622968f, 0.16006319f, 0.09325972f, 0.15433019f, -0.28779393f, 
    -0.14958183f, 0.16018789f, 0.00094199f, 0.12859049f, -0.13191344f, -0.10962731f, -0.01403932f, -0.13369173f, 
    0.02789966f, -0.05555166f, -0.33747962f, 0.16119432f, -0.05574283f, -0.11694675f, -0.04577063f, -0.00609006f, 
    0.12547736f, 0.06745589f, 0.04082721f, -0.09255572f, 0.19340332f, 0.18563932f, -0.26039875f, 0.06901555f, 
    0.11531338f, 0.02463561f, -0.07282156f, -0.03758122f, -0.08137204f, -0.15966357f, 0.14675660f, 0.13128880f, 
    -0.00908496f, 0.13382044f, -0.11704610f, -0.09417473f, 0.03973494f, 0.04564398f, 0.01260378f, -0.00282269f, 
    0.09016298f, -0.29808387f, -0.00866743f, -0.24328466f, -0.06267163f, 0.10107814f, -0.06899239f, 0.08747063f, 
    0.01111818f, 0.09262522f, 0.05803506f, 0.03651401f, 0.20744668f, -0.16078372f, -0.01583596f, -0.09893444f, 
    -0.05984654f, 0.08365243f, -0.00527210f, 0.03402580f, -0.08794355f, 0.16022177f, -0.11214769f, -0.01192658f, 
    -0.02757871f, 0.19933678f, -0.10858415f, -0.03683068f, -0.11729303f, -0.07126335f, 0.14932907f, 0.17572135f, 
    -0.07541819f, 0.05955572f, 0.04091261f, 0.15677270f, -0.04947075f, 0.02360536f, 0.04563876f, 0.06862981f, 
    -0.19807836f, 0.10388093f, -0.10944999f, 0.05263504f, 0.01014684f, 0.15246169f, 0.16894644f, 0.13680902f, 
    0.10025759f, 0.08329879f, 0.13338271f, 0.10414588f, -0.06329360f, -0.05327694f, -0.12401105f, 0.01271589f, 
    0.02737898f, 0.04285492f, -0.06725477f, -0.11390337f, 0.02252982f, 0.02020327f, -0.07483341f, 0.01599553f, 
    0.04731844f, 0.13479070f, 0.14373897f, -0.07497667f, 0.05554537f, 0.15673418f, -0.12218251f, -0.04766599f, 
    0.29774702f, -0.02995426f, -0.10395053f, -0.11885216f, -0.30737782f, 0.24797264f, 0.03260063f, -0.15410782f, 
    -0.08424833f, -0.16240025f, 0.04230559f, -0.02442706f, 0.17177932f, 0.02276792f, 0.15457639f, -0.03946642f, 
    -0.16920434f, 0.07722678f, -0.01950973f, 0.04214912f, 0.10991476f, -0.15776108f, 0.09173772f, -0.04992126f, 
    -0.08365870f, 0.04914315f, 0.02683627f, -0.02721395f, -0.07911257f, -0.12047574f, -0.01114368f, 0.23744076f, 
    -0.00199256f, -0.07197891f, 0.14775714f, 0.08402084f, 0.04263395f, -0.03247010f, -0.06121320f, -0.02796032f, 
    -0.07955644f, -0.00668561f, -0.07186992f, 0.11595235f, 0.09565651f, -0.04582915f, 0.01030338f, 0.04818810f, 
    -0.02543076f, -0.16948430f, 0.02027626f, 0.31433201f, -0.18067610f, -0.08417742f, -0.08842289f, -0.16373570f, 
    0.02307230f, 0.05652144f, -0.00261150f, -0.10074342f, 0.05111978f, 0.04077937f, 0.00327273f, 0.27144265f, 
    0.07330907f, 0.13603146f, -0.19711778f, 0.05630944f, -0.15891437f, 0.12255337f, -0.04402004f, 0.06826136f, 
    -0.15181644f, 0.02517363f, 0.07764062f, 0.07104169f, -0.02998007f, -0.05090408f, 0.01795966f, 0.07375980f, 
    -0.04412413f, 0.02779225f, 0.03978739f, -0.06172538f, 0.17614195f, 0.06151785f, 0.05142951f, -0.14075536f, 
    -0.14842489f, -0.01457228f, 0.10901517f, -0.10599103f, 0.08197058f, 0.12199231f, 0.07554559f, -0.00606309f, 
    0.18850434f, 0.08479311f, 0.06446110f, -0.02959017f, 0.13851041f, 0.10452008f, 0.19619045f, 0.17460282f, 
    -0.16846681f, 0.08729669f, 0.09544689f, -0.03696831f, 0.09239632f, 0.00220438f, 0.04505574f, 0.10216313f, 
    0.75170612f, -0.00091721f, 0.05554803f, -0.00437130f, 0.02629939f, 0.06049613f, 0.11101547f, 0.15954335f, 
    -0.05199413f, 0.09603892f, -0.10265728f, 0.02941495f, -0.43689144f, 0.15139316f, 0.00557272f, 0.38584083f, 
    -0.03820095f, -0.13585891f, 0.06298514f, -0.02108885f, -0.03331875f, 0.18060763f, 0.04379273f, 0.04368751f, 
    -0.16552219f, -0.21775348f, -0.01380635f, 0.25190562f, 0.04980442f, -0.18242554f, -0.02255747f, -0.04339160f, 
    0.05398495f, -0.11790377f, -0.05371999f, 0.05070215f, -0.40172118f, 0.45475015f, 0.37664613f, -0.25724909f, 
    0.09100506f, -0.15945496f, 0.07855960f, 0.20995361f, 0.06721547f, -0.08408622f, 0.08160334f, -0.05441794f, 
    -0.09573310f, -0.01911847f, 0.02686428f, -0.04621080f, 0.01017652f, -0.00190297f, 0.15191112f, 0.20843312f, 
    0.04174238f, 0.05537847f, -0.05998269f, -0.11915905f, 0.01514780f, 0.16548242f, 0.20462024f, -0.18427084f, 
    0.08831530f, -0.04229361f, -0.06960967f, 0.06884607f, 0.05698414f, 0.04560193f, 0.22101593f, -0.04985111f, 
    0.33976352f, 0.26825714f, -0.14205131f, -0.11171501f, 0.05527789f, 0.13119131f, 0.02790824f, 0.07989912f, 
    0.11153540f, 0.00601833f, 0.08243773f, 0.07881752f, -0.29856530f, -0.08903796f, 0.06301649f, 0.00912784f, 
    -0.00724836f, 0.05424794f, -0.10660220f, 0.11161027f, 0.07327101f, 0.07469514f, 0.12628344f, 0.01193444f, 
    -0.05162493f, 0.25659811f, -0.10297089f, -0.30231321f, 0.15161617f, 0.15984406f, -0.02229549f, 0.04873041f, 
    0.06745305f, -0.03721020f, 0.06833685f, -0.08003023f, -0.23376392f, -0.06066614f, 0.17683674f, 0.10563092f, 
    -0.05640923f, -0.15315720f, 0.03511255f, 0.09920570f, 0.10458577f, -0.01996064f, 0.05684138f, 0.08712161f, 
    0.22100964f, -0.06875376f, 0.02823248f, -0.18576324f, 0.12694862f, 0.04181590f, -0.07836431f, 0.05236738f, 
    -0.10329171f, 0.00744711f, 0.05287444f, 0.03135581f, 0.37343386f, -0.17323971f, -0.04627977f, 0.07341869f, 
    0.03658501f, -0.00510572f, -0.02579441f, -0.13235384f, -0.01634673f, 0.05156625f, 0.13232066f, -0.00219775f, 
    -0.01536144f, 0.09499155f, -0.17911907f, -0.00702042f, -0.09858325f, -0.13958627f, 0.10512016f, 0.07580880f, 
    0.09677467f, -0.06325202f, 0.12711418f, -0.06004815f, -0.28569713f, -0.15431061f, 0.28088596f, -0.26428989f, 
    -0.01204000f, -0.06732911f, 0.00181782f, 0.04626291f, -0.02373984f, 0.02501888f, 0.02178586f, 0.11845028f, 
    -0.16470227f, 0.23194996f, -0.12009506f, 0.11117087f, 0.13249344f, 0.12175275f, -0.09203132f, -0.06174488f, 
    0.04539887f, 0.08722866f, 0.02617188f, -0.05857673f, 0.42346099f, 0.16000603f, -0.16587643f, -0.26021504f, 
    0.05937596f, -0.03753506f, -0.22043347f, 0.19740748f, -0.08020898f, 0.16693342f, -0.05037926f, -0.03984237f, 
    0.15824142f, 0.21635172f, -0.26423994f, -0.18922140f, 0.01239576f, 0.06148518f, 0.08917757f, 0.08816437f, 
    -0.05296369f, 0.12847899f, -0.12817504f, -0.10443980f, 0.12904918f, 0.29368219f, -0.00312345f, -0.01656968f, 
    0.03263963f, 0.10850687f, -0.01767932f, 0.03865089f, -0.00318089f, 0.09017746f, 0.06766117f, -0.20564075f, 
    -0.26547652f, -0.18353643f, -0.07982167f, 0.04257970f, 0.04484511f, 0.12524140f, 0.08047476f, -0.06472672f, 
    -0.13927290f, -0.12817629f, -0.03464070f, 0.08855048f, 0.48429152f, -0.05697678f, 0.10606788f, 0.09650993f, 
    -0.05555922f, -0.01201995f, -0.16545351f, 0.16785288f, 0.02775441f, -0.00825519f, -0.09206203f, 0.10107240f, 
    0.10753395f, 0.21477717f, 0.04033575f, 0.11079593f, -0.01777607f, -0.07036381f, 0.18452212f, 0.17270048f, 
    0.12139907f, 0.01087646f, 0.05768108f, 0.08301738f, 0.50336856f, 0.09440802f, 0.11845171f, -0.15255879f, 
    -0.04751565f, 0.07814511f, 0.14036386f, 0.01683879f, -0.04993380f, 0.00097411f, -0.00156487f, 0.21799599f, 
    -0.04282486f, -0.29347602f, -0.26278359f, -0.19163728f, 0.25957334f, 0.22315672f, 0.02594857f, -0.13393974f, 
    0.20061839f, 0.13098122f, -0.05966191f, -0.16996209f, -0.21384193f, -0.08664846f, -0.04708120f, -0.06610156f, 
    0.09461142f, 0.06785590f, -0.03358749f, 0.14861839f, -0.09102402f, -0.08870301f, 0.14128520f, 0.16071324f, 
    0.53783727f, -0.02081134f, 0.04143146f, 0.17535698f, -0.09879917f, -0.01593012f, -0.02172885f, 0.04330964f, 
    -0.02068910f, 0.10426369f, -0.02365249f, -0.02895978f, 0.28560057f, 0.03793542f, 0.01116361f, 0.13244136f, 
    0.05609206f, -0.10758536f, 0.01851621f, 0.10740054f, 0.00046212f, 0.01073839f, 0.10186011f, 0.04112704f, 
    -0.08213742f, -0.07800278f, 0.08484228f, 0.20428729f, -0.00882725f, 0.04952838f, 0.08075575f, -0.06085997f, 
    -0.01182522f, 0.11439729f, 0.00348589f, 0.11553483f, -0.08840416f, 0.14146261f, 0.04531252f, -0.18566175f, 
    0.09502043f, 0.02581780f, -0.04093204f, 0.06063690f, -0.04680470f, 0.03507483f, -0.10908668f, -0.18970747f, 
    -0.02267226f, 0.05122149f, -0.21894974f, -0.15278026f, 0.14336270f, 0.04155125f, 0.07002673f, 0.13354419f, 
    0.00392265f, -0.06080646f, 0.13736154f, 0.10000125f, -0.00242026f, -0.03379662f, 0.17973478f, -0.20214157f, 
    -0.03610205f, -0.01649890f, 0.22061576f, 0.09757739f, -0.08169374f, 0.10091441f, 0.05912052f, -0.06152910f, 
    0.02638438f, 0.33182082f, -0.09728658f, -0.13724929f, -0.20466200f, 0.01872515f, 0.04733923f, -0.10712735f, 
    0.12766136f, 0.12182315f, -0.04914854f, 0.07592039f, -0.18795723f, 0.06445909f, 0.31775784f, -0.11856242f, 
    -0.02417702f, 0.03697298f, -0.06198060f, 0.10157469f, -0.05452822f, 0.01634939f, -0.04629891f, 0.00486173f, 
    -0.26852310f, -0.14657797f, -0.01874570f, -0.20856681f, 0.01811960f, 0.00148174f, -0.03827150f, -0.01196377f, 
    0.14683640f, -0.07556943f, -0.04251702f, 0.17039512f, 0.21013348f, -0.12241862f, 0.22062846f, 0.19992881f, 
    -0.07538169f, -0.10904297f, 0.02149145f, 0.21874341f, -0.12006231f, 0.13167782f, -0.04654453f, -0.05018091f, 
    0.00637247f, -0.11861746f, -0.07628266f, 0.25365865f, 0.03202430f, -0.16460828f, -0.14271890f, -0.13499720f, 
    -0.03653191f, -0.09493846f, 0.10168093f, -0.00271154f, -0.24490879f, 0.10439484f, -0.02844040f, 0.04561187f, 
    -0.01024601f, -0.08613804f, 0.18974099f, -0.04525444f, 0.02157515f, 0.04376420f, 0.03305421f, 0.03653804f, 
    -0.09294649f, 0.08351034f, -0.06212240f, 0.10649115f, 0.11794928f, -0.11318822f, 0.10932602f, 0.24502377f, 
    0.00129962f, 0.19634336f, -0.09209721f, 0.05025940f, -0.48517734f, 0.04850928f, 0.26012760f, 0.04838485f, 
    0.07799833f, -0.21849452f, 0.12087681f, -0.03649827f, -0.07277142f, 0.03445708f, 0.16726461f, 0.10202409f, 
    -0.13313973f, 0.21469519f, 0.27385119f, -0.09264675f, -0.00442130f, 0.05199295f, 0.05948806f, 0.07805238f, 
    -0.03657742f, 0.07099671f, 0.07514419f, 0.12193107f, 0.21483479f, 0.04159820f, 0.17803693f, 0.02223272f, 
    0.01583138f, 0.11000319f, -0.00872514f, -0.08696237f, 0.15159242f, -0.02045805f, -0.13494478f, -0.13058823f, 
    -0.01707544f, 0.07433581f, -0.09610179f, -0.00502555f, -0.00755831f, 0.02184101f, 0.01941084f, -0.05812742f, 
    0.10685296f, 0.03413856f, 0.04515302f, 0.11340795f, 0.38330919f, 0.19809483f, 0.19087110f, -0.06420467f, 
    0.02650525f, 0.14778477f, 0.06298817f, 0.03834527f, 0.24002352f, 0.19161095f, -0.19043502f, -0.10858633f, 
    -0.08689108f, 0.09861811f, -0.06589671f, -0.14004202f, 0.12093358f, 0.06340031f, -0.02752553f, -0.00086101f, 
    0.16613118f, 0.23070736f, 0.06512745f, 0.13850057f, -0.21630843f, 0.09370682f, -0.01862136f, -0.01846382f, 
    0.26633406f, -0.03396606f, -0.17708774f, -0.09893347f, -0.02402641f, 0.06280547f, 0.02225260f, -0.08695386f, 
    0.05289162f, 0.04523988f, 0.01381533f, 0.36960515f, -0.00439277f, -0.17954458f, -0.08988189f, 0.14178069f, 
    0.08747722f, -0.02507047f, 0.04259130f, 0.04947869f, -0.06942894f, -0.01881399f, 0.06210479f, 0.12814885f, 
    0.10955034f, -0.12920703f, 0.01671476f, -0.03422587f, 0.10653002f, -0.03875195f, 0.13607541f, 0.12006836f, 
    -0.10018890f, 0.00177086f, 0.26192260f, 0.04463075f, 0.00748447f, 0.04443437f, -0.11985661f, -0.05004358f, 
    -0.03516460f, -0.07545112f, -0.06983665f, -0.07869703f, 0.03195968f, 0.21086287f, 0.24151026f, -0.09524817f, 
    -0.02794460f, -0.00020054f, 0.02647436f, 0.13272436f, 0.06979743f, 0.19812287f, -0.17116092f, -0.09658644f, 
    0.00521529f, 0.09147642f, 0.05806011f, -0.09522316f, -0.08602402f, 0.01913108f, -0.04265351f, 0.04034855f, 
    0.13335869f, 0.27886412f, -0.00674555f, 0.26853403f, 0.29586118f, 0.01744676f, 0.12781705f, -0.14881986f, 
    -0.13088430f, -0.02147441f, -0.06585345f, 0.03813593f, -0.07619643f, 0.12342671f, 0.10298853f, 0.00189747f, 
    -0.18772939f, -0.17991036f, 0.07324622f, -0.07258231f, 0.02119386f, -0.16250707f, 0.14697550f, 0.05252640f, 
    0.02236293f, -0.17535654f, 0.10650975f, 0.05759034f, 0.51931924f, 0.24335390f, -0.04558475f, -0.06003737f, 
    0.04369771f, -0.02211652f, -0.02625609f, -0.03703970f, -0.01333631f, -0.04669063f, -0.12318646f, 0.04414399f, 
    0.20061280f, -0.04671518f, 0.12326174f, -0.21869935f, 0.12595741f, -0.11643465f, -0.02029415f, -0.08382606f, 
    -0.02680867f, -0.07041192f, -0.23936109f, -0.00752570f, 0.04821624f, -0.00883455f, 0.04502583f, -0.16073279f, 
    -0.02765124f, 0.01587483f, -0.07390036f, 0.29236329f, -0.01046771f, 0.00620306f, 0.10714594f, 0.09605569f, 
    0.03404994f, -0.19269507f, -0.07524151f, 0.02038126f, 0.04763115f, -0.09345819f, 0.08468246f, 0.13300948f, 
    -0.13908561f, 0.07819542f, 0.03100332f, 0.04335100f, 0.14895846f, -0.19586746f, 0.04420526f, -0.23325935f, 
    0.08073830f, 0.20989659f, -0.00597952f, 0.12805943f, -0.11877021f, -0.03208889f, -0.07331148f, 0.04257616f, 
    0.42268389f, -0.21583170f, 0.07761351f, 0.17828630f, -0.18209207f, 0.24414054f, -0.12148451f, -0.07398244f, 
    0.08816241f, 0.10959548f, -0.00607996f, 0.03698750f, 0.42073759f, 0.14241028f, 0.07935725f, -0.02239233f, 
    -0.13009004f, 0.10112969f, -0.24675791f, 0.08427722f, -0.01864992f, 0.06157768f, -0.03396099f, 0.11498734f, 
    0.23917450f, -0.07711250f, 0.15310088f, 0.18861353f, -0.19912401f, 0.06474291f, -0.07945295f, -0.03464175f, 
    0.02750901f, 0.08361322f, -0.06287027f, -0.14253494f, 0.11504378f, 0.10134764f, 0.04992268f, 0.09268639f, 
    -0.03530422f, 0.00764848f, -0.12113639f, 0.15984009f, -0.05770304f, -0.04546622f, -0.12642044f, -0.38786232f, 
    -0.14743619f, 0.02183824f, -0.01129373f, -0.18015918f, 0.04682842f, -0.08591162f, 0.13498899f, 0.04515229f, 
    0.14477897f, -0.04107704f, -0.00698319f, 0.02387968f, -0.11215569f, 0.03406083f, 0.12911077f, -0.26817477f, 
    0.08123943f, 0.02328779f, 0.06385231f, 0.18438932f, 0.04162694f, 0.12857431f, 0.18887593f, 0.23227252f, 
    0.16238226f, 0.07189004f, -0.16281424f, 0.03699098f, -0.07403573f, -0.03372451f, -0.07999495f, -0.06132091f, 
    -0.04761267f, 0.05048017f, -0.07213543f, 0.07518763f, -0.05709589f, 0.13812338f, -0.19265133f, -0.29841062f, 
    0.22317415f, -0.04369257f, -0.05586368f, 0.11375781f, -0.07871673f, 0.02290654f, 0.02461261f, -0.08144611f, 
    -0.23244128f, 0.25456530f, -0.22368844f, 0.04196141f, 0.07205013f, -0.10918846f, -0.14851324f, -0.08636403f, 
    0.15061945f, -0.04203083f, 0.12320155f, -0.05725273f, 0.50786090f, -0.05189884f, 0.17784409f, -0.32406601f, 
    0.03558693f, 0.15022615f, 0.00728258f, -0.05677347f, -0.01057693f, -0.22796187f, -0.03414360f, -0.11421806f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01601933f, 0.03938132f, 0.00642337f, 0.04911067f, -0.02276138f, 0.10147958f, 0.02579203f, 0.01743507f, 
    -0.00594007f, -0.02084713f, -0.08287595f, 0.06763755f, -0.02463603f, -0.05706690f, 0.07094671f, -0.02548528f, 
    -0.04527228f, 0.04050817f, 0.03047156f, 0.08328424f, -0.04430293f, -0.02303046f, 0.01834363f, -0.04983861f, 
    -0.00599501f, -0.01613854f, 0.07941632f, 0.01749645f, -0.00904069f, -0.02149065f, 0.02334258f, 0.04038258f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.38156113f, 0.13612057f, 0.09115396f, 0.04159768f, -0.16631873f, 0.26231989f, 0.32809576f, -0.15647109f, 
    -0.02203176f, -0.03202406f, -0.28836989f, 0.16618648f, -0.12224266f, -0.61630476f, -0.11485153f, -0.13302913f, 
    0.25309315f, -0.10614293f, -0.01841034f, -0.53003919f, -0.09468453f, 0.05821738f, -0.48983315f, -0.09315618f, 
    0.02099187f, -0.16741762f, -0.47339156f, 0.10005002f, 0.15891697f, 0.13620159f, -0.29461032f, 0.14356577f, 
    0.04670481f, 0.03637647f, 0.14603993f, 0.49301451f, 0.15486884f, 0.18192822f, -0.14685985f, 0.11385267f, 
    0.14701714f, -0.13023844f, -0.10123980f, 0.22830693f, -0.60900164f, -0.49565390f, -0.02650308f, -0.14189358f, 
    -0.43591079f, 0.00457850f, -0.16130280f, -0.42391798f, 0.08696252f, -0.09346853f, -0.11661848f, 0.01331269f, 
    -0.12102877f, 0.06651189f, 0.29268551f, 0.02580504f, 0.04370489f, -0.37928775f, 0.23141985f, 0.37138692f, 
    0.47679871f, -0.16882133f, 0.13686927f, -0.30760136f, 0.08816292f, -0.08185261f, -0.30351090f, 0.04502855f, 
    -0.04283460f, -0.08097752f, 0.23807636f, 0.15409300f, 0.33319503f, 0.52790612f, -0.07580999f, 0.06845338f, 
    -0.59011048f, 0.11539199f, -0.08033706f, -0.45882383f, 0.03034216f, 0.05597174f, -0.40417573f, 0.02859206f, 
    -0.16727409f, -0.07010755f, 0.05860587f, -0.33475387f, -0.13235874f, 0.15077569f, 0.29062468f, -0.03748874f, 
    -0.72362489f, -0.12927240f, -0.09579935f, -0.36699823f, 0.09494600f, 0.02040119f, 0.11504992f, -0.04352220f, 
    0.01288058f, 0.04044127f, 0.01485468f, 0.38758931f, 0.16446589f, -0.44601920f, -0.53906977f, -0.16032210f, 
    -0.44711983f, -0.17015675f, 0.04338203f, -0.01606421f, 0.00864457f, 0.10368756f, 0.38143966f, -0.07880863f, 
    0.01434814f, -0.10993556f, -0.71473420f, 0.26219195f, -0.12012765f, 0.19528091f, 0.23905960f, -0.06272113f, 
    0.06907050f, -0.09564977f, 0.02853021f, 0.49329934f, -0.14300083f, -0.16881603f, 0.14527118f, -0.05423634f, 
    -0.04968487f, 0.15035768f, -0.05100848f, -0.19067174f, 0.32124314f, -0.03890168f, -0.27098876f, 0.05673922f, 
    -0.18925704f, 0.09004860f, 0.13609248f, 0.02685704f, -0.12582308f, 0.15231405f, 0.28484139f, 0.05496107f, 
    -0.15605836f, -0.11648070f, -0.03051154f, 0.15413052f, -0.13772431f, 0.41083869f, -0.32525703f, -0.66426611f, 
    -0.30218050f, 0.09096438f, 0.13718979f, 0.13409363f, -0.03638169f, 0.31192836f, -0.24294570f, -0.06444417f, 
    -0.01104393f, 0.10642613f, 0.32449144f, -0.46922556f, 0.27297667f, -0.53415823f, 0.01590411f, -0.02316990f, 
    0.29678032f, 0.12905610f, 0.15425456f, 0.14538445f, 0.05148759f, -0.02743008f, -0.16557664f, -0.10463904f, 
    0.17632942f, -0.00739461f, 0.23415405f, 0.37603688f, -0.16553426f, -0.64833987f, -0.45136866f, -0.01545465f, 
    -0.61644697f, -0.04727176f, 0.16948724f, -0.22564985f, 0.13875823f, 0.22465158f, 0.36469766f, -0.08441433f, 
    -0.10248446f, -0.08050531f, 0.08394834f, -0.36892667f, 0.07169625f, 0.40257290f, 0.19549127f, 0.12102924f, 
    -0.10487495f, -0.11256059f, 0.01809881f, 0.02951957f, -0.09964557f, 0.07364081f, -0.60836786f, -0.06040921f, 
    -0.03216356f, -0.11256267f, 0.11945391f, -0.51190215f, -0.17139122f, 0.26637030f, -0.23321818f, -0.29304445f, 
    0.03032432f, 0.09325714f, -0.11146691f, -0.10508728f, -0.12630364f, -0.60760146f, 0.16223754f, 0.12424801f, 
    -0.14692311f, -0.14903641f, 0.40876591f, -0.29077899f, 0.06950392f, 0.30010340f, -0.17028564f, -0.12152097f, 
    0.41338265f, 0.07592032f, -0.05172437f, -0.10971276f, -0.14293629f, 0.03657376f, 0.29062286f, -0.16086280f, 
    -0.10957687f, 0.05885548f, -0.30227262f, -0.11641338f, 0.09560461f, -0.52075875f, -0.28346360f, 0.28002498f, 
    -0.07927954f, -0.04444082f, -0.13093820f, -0.41679338f, -0.12062879f, 0.14055423f, -0.54915744f, -0.14772026f, 
    0.00734377f, 0.16522965f, 0.12382912f, -0.40792042f, -0.05905668f, -0.09919444f, 0.30598506f, -0.08761568f, 
    0.25558817f, 0.16187339f, -0.06972086f, -0.36524495f, 0.11865585f, -0.10654056f, 0.46410692f, -0.02271989f, 
    0.02925165f, -0.12660103f, 0.26201096f, -0.55916947f, -0.07338056f, 0.30450803f, 0.10826182f, 0.12773089f, 
    -0.19856153f, -0.06394278f, 0.12443678f, -0.29295608f, 0.13199744f, -0.09918851f, 0.09882165f, 0.03686645f, 
    0.01172549f, -0.08962672f, -0.14972420f, -0.12827899f, -0.37331110f, 0.52090001f, -0.74070078f, -0.16843034f, 
    0.58458877f, -0.07837883f, 0.00599856f, -0.17478585f, 0.01375467f, -0.03270012f, -0.58663303f, -0.02462146f, 
    0.03377777f, 0.05144750f, 0.04806374f, 0.34457535f, 0.15502663f, 0.10358278f, 0.42692566f, -0.26009750f, 
    -0.02786531f, -0.12784272f, 0.04230785f, -0.28899446f, -0.13040550f, -0.01977107f, -0.16271536f, 0.10446125f, 
    0.14684643f, -0.09137136f, -0.80361634f, 0.14396298f, 0.09358805f, -0.03220347f, 0.58768177f, -0.09925198f, 
    -0.40276524f, -0.05494248f, 0.13301593f, 0.43017495f, 0.14420439f, 0.13431251f, 0.00747442f, 0.11604347f, 
    -0.04127996f, -0.05491464f, -0.28785178f, 0.14541207f, -0.16867699f, -0.34243950f, -0.06690025f, 0.43737039f, 
    -0.13321227f, 0.01781782f, -0.06584236f, -0.31455478f, -0.13536754f, 0.12236334f, -0.09764518f, 0.11804539f, 
    -0.16362372f, -0.11865634f, 0.66702276f, 0.42458102f, -0.75046432f, -0.22747496f, 0.25460258f, -0.03895292f, 
    -0.38221923f, 0.14890336f, -0.01935278f, 0.42539364f, -0.11595593f, -0.11736757f, -0.17504354f, 0.05897257f, 
    0.14107499f, -0.11730632f, -0.15416440f, 0.21513854f, -0.16773769f, 0.20207617f, -0.23004565f, -0.55946851f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.21430817f, 0.18466802f, 0.05368159f, 0.14306116f, 0.00098519f, -0.14759421f, 0.16468312f, -0.20721284f, 
    -0.05106558f, 0.10253008f, 0.10393661f, -0.06909003f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
