#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.55926114f, -1.49693799f, -0.83360904f, -0.82671458f, 0.29765841f, 0.40141112f, 0.25843275f, 0.48103136f, 
    -0.15724990f, -0.38430533f, -0.01931212f, 0.73911965f, -0.29796717f, -0.68277174f, -0.14851356f, 0.84098804f, 
    0.58874714f, -0.16996922f, 1.29849660f, -1.12299216f, 0.11637995f, -0.71653908f, -0.23440126f, -0.38808453f, 
    0.08598930f, -0.25816286f, 0.33301303f, 0.95075428f, 0.91535985f, 0.88370073f, 0.82534009f, 0.20397906f, 
    -0.52191740f, 0.01000233f, 0.54945087f, -0.57390285f, -0.87713283f, -0.63449538f, -1.09667015f, -0.34192738f, 
    1.12175024f, 0.70382583f, -0.00527335f, -0.35108572f, -0.09129797f, -0.77475995f, -0.56231260f, 0.70298678f, 
    -1.08342552f, -0.57826674f, -0.05260822f, 0.23453389f, -0.01114114f, 0.15431754f, 1.12284529f, 0.67265826f, 
    1.19713044f, -0.94111997f, -1.03582549f, -0.29600793f, 0.09690713f, -0.19555612f, -0.80060798f, 0.58122414f, 
    -0.44039860f, -0.87123191f, -0.66867781f, 0.00682557f, 0.03484368f, -0.64908493f, -0.09111163f, -0.29812980f, 
    1.17301393f, 0.53798723f, 0.49718374f, -0.02174166f, 0.70473492f, 0.58318567f, -0.00715285f, 0.50357777f, 
    -0.18511496f, -0.90825170f, -0.67833364f, 0.75932044f, 0.06488366f, 0.92954147f, -0.57631016f, 0.23672034f, 
    0.22141255f, 0.37925041f, -1.04765904f, 1.33477330f, 0.44781968f, -0.97411823f, 0.93927282f, -0.03848772f, 
    -0.29531372f, 0.71290845f, -0.67049652f, -1.29586244f, 0.11719736f, 0.68332005f, -0.27939469f, -0.09842616f, 
    0.70783436f, -0.19547401f, 0.43085703f, -0.38966700f, -1.30950224f, 0.83423656f, 0.91447377f, 0.03363215f, 
    0.95290458f, -0.11764488f, -0.29328713f, 0.05448363f, 0.54542822f, -0.31384465f, 0.80092067f, -0.03337410f, 
    -0.76777899f, -1.06092799f, -0.82343590f, 0.43671310f, 0.11878709f, 0.44024453f, -0.39549235f, -0.91732168f, 
    -0.62461323f, 0.47622234f, 0.48673889f, -0.97577578f, 0.49088299f, 0.51270205f, -0.19745632f, -0.38426223f, 
    -1.49798357f, -0.35711050f, 0.55920839f, 0.56120443f, 0.84830612f, -0.68747675f, 0.06471490f, -0.48458371f, 
    -0.21436383f, -1.31023991f, 1.13959217f, 0.39213395f, -0.81481117f, 0.97418797f, 0.13625108f, -0.24549136f, 
    -0.26822862f, -1.44135439f, 0.43699372f, -0.76856804f, 0.51661932f, 1.06926644f, -0.76215291f, -0.19414224f, 
    -0.32706901f, 0.42372110f, 1.19438398f, 1.31781340f, -0.96380258f, 0.04818871f, 0.78614932f, 0.45351642f, 
    -0.23682050f, -0.07436089f, 0.29915652f, -0.54038167f, -1.13058352f, -0.57260287f, 0.74580723f, 0.91470152f, 
    -0.33373913f, -0.31431726f, -0.09109071f, -0.36024010f, -0.27936172f, -0.57463205f, 0.90169674f, 0.85652733f, 
    0.34202889f, 0.46355975f, -0.29651555f, -0.20948313f, 0.50259614f, -0.30981705f, 0.71026552f, 0.79010803f, 
    0.93121946f, 0.43955955f, 0.70857680f, -0.49627498f, -0.64840126f, -0.25234696f, 0.12546051f, 1.33749676f, 
    0.77602673f, 0.07741204f, -0.57130641f, 0.73792201f, -0.16406800f, -0.06566372f, 0.15591747f, -0.93409210f, 
    -0.23424962f, 0.95942795f, 0.05028823f, -0.41696134f, -0.67481244f, -0.22256598f, -0.18785058f, -0.52994043f, 
    -1.01645887f, -1.17987204f, -0.55771989f, -0.11888588f, -0.20163919f, 0.32684782f, 0.47869426f, -0.25308490f, 
    0.54621089f, -0.85027963f, 0.68304843f, -0.96240997f, -0.01647564f, 0.56121707f, 0.57603663f, 0.43437445f, 
    -0.34763432f, -0.34926724f, 0.48941666f, -1.06022167f, -0.57394314f, 0.98638886f, -0.98855239f, 0.01510222f, 
    -0.36213875f, -0.35682440f, -0.07179473f, -0.70890814f, -0.41118845f, -0.47271109f, -0.67894822f, -0.15455918f, 
    -0.56642085f, 0.89019692f, 0.34027746f, -0.71637774f, -0.51064128f, 0.53598797f, -0.50035870f, 0.92223644f, 
    -0.67967790f, -0.64080775f, 0.38222852f, 0.42777449f, 0.47422266f, 1.18305564f, 0.89695460f, 0.66268450f, 
    0.27396393f, -1.11960769f, -0.33503485f, 0.40645218f, 0.04281298f, 0.44769448f, -0.71840620f, -0.22153400f, 
    -0.63041580f, -0.18022563f, -0.32465678f, -1.00626910f, -0.51569277f, 0.29529390f, 0.05987918f, 0.20660284f, 
    -1.12071991f, -0.65099174f, -0.23871757f, -0.98905873f, -0.74079382f, -0.50289094f, 0.25842077f, -0.54865712f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.19251002f, 0.02978913f, -0.08479685f, 0.21849854f, 0.08000804f, 0.31913576f, 0.31223449f, 0.23792754f, 
    0.22398716f, 0.04442160f, -0.02031905f, 0.26508421f, 0.17591502f, -0.10613860f, 0.27038997f, 0.05962829f, 
    -0.08113334f, -0.18916462f, 0.39692038f, 0.14222781f, 0.25709450f, -0.12655850f, 0.36675695f, 0.07431990f, 
    0.37240207f, 0.00377768f, 0.18983212f, -0.07473058f, 0.17756318f, 0.07946387f, -0.05398966f, 0.40883878f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.07637652f, -0.14517593f, -0.07371760f, 0.11767873f, -0.25601488f, -0.17354701f, -0.03634835f, -0.02702705f, 
    -0.12243334f, 0.10128340f, -0.07042477f, -0.03742007f, 0.05931946f, -0.05297287f, 0.08779959f, -0.10311851f, 
    -0.16478795f, -0.08721431f, 0.01127563f, 0.07536115f, -0.29775742f, -0.05943093f, -0.17857638f, 0.20340936f, 
    -0.17980002f, -0.07469394f, 0.01547290f, 0.00763584f, -0.04283616f, -0.07236534f, 0.04011153f, -0.01749255f, 
    0.06270152f, -0.06193026f, -0.12147675f, -0.03689415f, 0.06623759f, -0.06405572f, -0.02920645f, -0.06273597f, 
    0.31116119f, -0.44695798f, 0.31354770f, 0.30414101f, -0.31790477f, -0.01584357f, -0.07248988f, -0.00521814f, 
    0.06098274f, 0.10760410f, -0.20258182f, 0.00439935f, -0.06635325f, -0.03252137f, 0.03432708f, -0.06178866f, 
    -0.21177478f, 0.00164646f, 0.19969477f, -0.06403942f, 0.07723285f, 0.10689268f, 0.06469525f, -0.10490651f, 
    0.17840709f, -0.08482867f, -0.09937352f, 0.03225542f, 0.03232115f, 0.00046238f, -0.00340618f, 0.11446746f, 
    0.02501314f, -0.00534565f, -0.07330411f, 0.00035088f, -0.00591175f, -0.00535076f, -0.04488406f, 0.03762511f, 
    0.00240003f, 0.42049456f, 0.05221973f, -0.31130603f, -0.29560897f, 0.13493715f, 0.06069749f, -0.04232104f, 
    0.14552407f, -0.01010897f, 0.00295200f, -0.03387418f, -0.02792620f, 0.01553779f, -0.00136655f, -0.09403531f, 
    -0.05140361f, -0.03749045f, 0.07372648f, -0.02038980f, -0.12923245f, -0.13992031f, -0.24111508f, 0.10496825f, 
    -0.15869184f, -0.08371728f, 0.03108547f, -0.00716315f, 0.08165163f, -0.05129192f, -0.02891535f, 0.01128030f, 
    -0.02604667f, 0.00260418f, -0.04865806f, 0.00426090f, 0.16170143f, -0.06183396f, 0.07655048f, 0.03784094f, 
    0.27335367f, 0.10399534f, -0.00970649f, 0.02539981f, 0.08883013f, -0.25176916f, -0.21226326f, -0.11862657f, 
    0.07607370f, 0.05466850f, -0.03599125f, -0.04541422f, -0.00189861f, -0.03597194f, 0.06147297f, 0.08674727f, 
    0.01565726f, 0.02308457f, 0.07304592f, 0.09632535f, 0.05383526f, -0.17023878f, -0.04003439f, 0.09702330f, 
    0.03899025f, -0.05917363f, -0.02224407f, 0.02450752f, -0.07301261f, -0.04725765f, 0.03323903f, -0.00760336f, 
    0.11757556f, -0.04343628f, -0.09871567f, -0.07572894f, 0.04292502f, -0.13269319f, 0.00061879f, -0.11160757f, 
    0.12427014f, 0.05812510f, -0.14125666f, -0.26819143f, 0.14697982f, -0.15703461f, -0.02540499f, -0.14190152f, 
    0.04102478f, 0.01107545f, -0.06426020f, 0.05772715f, 0.06709579f, -0.02291267f, 0.02265222f, -0.05681467f, 
    -0.03335959f, -0.07532234f, -0.01409904f, -0.02670015f, -0.11634244f, -0.05326979f, 0.29157260f, 0.03766776f, 
    -0.29978240f, -0.08504704f, -0.05230480f, 0.05948141f, 0.07276780f, -0.09313112f, 0.00155774f, 0.06054110f, 
    0.06064044f, -0.00675100f, -0.04548482f, 0.02100813f, -0.03041201f, -0.04401772f, -0.10183033f, 0.07320297f, 
    -0.09481750f, -0.00855663f, 0.22278906f, -0.13484780f, 0.30963653f, -0.03414675f, -0.01719349f, 0.03763556f, 
    -0.08785252f, 0.03932564f, -0.13260387f, -0.08049104f, 0.03760557f, -0.06394401f, 0.03857552f, -0.02337035f, 
    -0.00218122f, 0.02593550f, 0.06796822f, -0.07905153f, -0.45052415f, 0.12457544f, 0.05786238f, 0.14985248f, 
    -0.03396844f, 0.00593424f, -0.02717991f, 0.06045303f, 0.08323637f, -0.03774719f, 0.06180548f, -0.02154407f, 
    0.07362559f, -0.04237913f, -0.05912618f, -0.06181269f, -0.04449555f, -0.04015456f, 0.00196656f, 0.10131122f, 
    0.17522182f, -0.03201943f, 0.25815722f, 0.00114577f, 0.04777107f, -0.05855684f, -0.01617708f, 0.04749143f, 
    -0.01623240f, -0.07845677f, 0.02782862f, -0.07287142f, 0.07577036f, 0.06042065f, -0.06865898f, 0.03934928f, 
    0.03885631f, 0.03201693f, -0.09574413f, 0.02224750f, -0.18052575f, -0.03248416f, 0.19044074f, 0.01421256f, 
    0.01881615f, -0.01278314f, -0.01310354f, -0.02798791f, -0.03020349f, 0.00004847f, 0.05793402f, 0.12578957f, 
    0.00510928f, -0.02280450f, 0.02364428f, -0.00571811f, 0.02770266f, 0.06456266f, 0.02211856f, -0.14917280f, 
    -0.27238217f, -0.08452577f, -0.07216201f, -0.03106062f, -0.11875611f, -0.10476467f, 0.00346974f, 0.04834099f, 
    0.03666262f, 0.02881822f, -0.10222338f, 0.05554893f, -0.00746624f, -0.03747349f, 0.02057867f, 0.06526925f, 
    0.04675142f, 0.04068065f, 0.04095627f, 0.01997848f, 0.06921896f, 0.17337127f, -0.14910488f, -0.18595208f, 
    -0.52533561f, 0.17575771f, 0.08927621f, -0.01111176f, 0.07533320f, -0.04003369f, 0.13399841f, -0.05788115f, 
    0.08459893f, 0.04061861f, -0.14119345f, -0.01293527f, 0.03852957f, 0.02524223f, -0.04801444f, 0.10434227f, 
    -0.00873789f, -0.06058824f, 0.00358663f, 0.08936512f, -0.66519833f, -0.08093121f, 0.17750433f, 0.06205465f, 
    0.03033159f, 0.01802564f, -0.04617750f, 0.03733237f, -0.04822283f, 0.01073194f, 0.02300622f, 0.01891310f, 
    -0.01074808f, -0.03406592f, 0.06151765f, 0.04795261f, 0.82526588f, 0.16310637f, 0.15563950f, -0.20838749f, 
    -0.06605791f, -0.01752959f, 0.02121598f, -0.09766790f, -0.09912550f, -0.04120447f, 0.13278934f, 0.00633140f, 
    -0.14402352f, 0.06491919f, 0.15748419f, -0.07183234f, -0.06532159f, 0.07848875f, -0.03754573f, -0.05649463f, 
    -0.12777789f, 0.08908405f, -0.00089129f, -0.25936267f, 0.42811224f, -0.20380747f, -0.06222969f, 0.03747458f, 
    0.10053310f, -0.07076161f, -0.03310773f, 0.04798108f, -0.01054651f, -0.02403085f, -0.02734673f, -0.05553621f, 
    0.01966228f, 0.01030136f, -0.00212203f, 0.01189952f, -0.17213762f, 0.08773607f, 0.13487171f, -0.07759023f, 
    -0.36673793f, 0.08541046f, -0.01876622f, 0.01292160f, 0.00503013f, -0.05324576f, -0.01891761f, -0.01361435f, 
    0.02607385f, 0.01383484f, -0.02916850f, -0.00174431f, 0.12404700f, 0.03290612f, 0.03104210f, 0.01918349f, 
    -0.07024822f, 0.05052169f, 0.20409763f, 0.07336752f, -0.26138738f, 0.07811908f, -0.03373285f, 0.01176722f, 
    0.02858293f, -0.10115640f, -0.10245979f, 0.00270021f, -0.05295880f, -0.04072456f, 0.01880586f, -0.12516931f, 
    0.10070782f, 0.00063290f, 0.00289879f, 0.03533735f, 0.09692985f, 0.06804737f, 0.24774246f, 0.20449741f, 
    0.12644319f, -0.15425134f, -0.10495230f, 0.10328677f, -0.01146679f, -0.05793798f, 0.04251495f, -0.06985910f, 
    -0.02421676f, 0.00964099f, 0.07392785f, 0.15888573f, 0.10524582f, -0.06120751f, 0.04891183f, 0.16418394f, 
    -0.24174069f, 0.21675344f, 0.08003180f, 0.06827287f, 0.34188834f, -0.13805464f, -0.23555163f, 0.00728182f, 
    -0.06177287f, -0.04057369f, -0.05700161f, -0.10273752f, -0.04513396f, -0.00199177f, 0.03390313f, 0.06564176f, 
    0.08862189f, -0.05880425f, -0.07809266f, 0.12155779f, -0.23039638f, -0.11678276f, -0.01948025f, 0.11351278f, 
    -0.11548856f, -0.01145497f, -0.13459967f, 0.05541795f, 0.09609094f, 0.04353491f, 0.02695737f, 0.10326830f, 
    -0.02756678f, 0.03022319f, -0.14048760f, -0.03915679f, -0.16236678f, 0.11697207f, -0.02162649f, 0.04078384f, 
    -0.37965775f, -0.30290923f, -0.06362165f, 0.04309209f, -0.20605327f, 0.11955954f, 0.07440947f, -0.05384991f, 
    0.08136198f, 0.04959446f, -0.06325218f, 0.06718588f, -0.05893587f, -0.03054095f, 0.06634671f, -0.00277156f, 
    0.04908201f, -0.02963672f, 0.04656910f, -0.12089182f, 0.32344553f, 0.21391436f, 0.21323061f, -0.27290249f, 
    -0.07089179f, 0.08840661f, -0.03742087f, 0.02223115f, 0.05762025f, -0.05432854f, -0.14150369f, 0.03307298f, 
    -0.09357096f, -0.06422672f, 0.16595370f, -0.07545220f, -0.01418755f, -0.13024981f, 0.00622181f, -0.16866195f, 
    0.30929288f, -0.32637948f, 0.10474398f, 0.15138692f, -0.16194247f, 0.13138270f, 0.02958117f, 0.03047043f, 
    0.00265630f, -0.06784815f, -0.20944817f, 0.03413220f, -0.03839745f, 0.12164012f, 0.00839278f, 0.05709146f, 
    0.10762104f, 0.13248526f, -0.20134112f, 0.00588829f, -0.43571976f, -0.47637588f, -0.30643496f, 0.20096724f, 
    0.01704840f, -0.10805631f, -0.09751330f, 0.00588808f, 0.05648516f, -0.09532267f, 0.08966777f, 0.01005453f, 
    -0.14144756f, -0.01321977f, -0.00197487f, 0.14533730f, -0.04112241f, -0.09098254f, -0.01384910f, -0.07901994f, 
    -0.02877972f, -0.27910307f, -0.00738078f, -0.02987834f, 0.05636828f, -0.04040118f, -0.10873482f, 0.00093713f, 
    -0.21854635f, 0.06608095f, -0.03553715f, 0.15580837f, -0.00020196f, 0.00578620f, 0.13724309f, 0.03026200f, 
    0.02566332f, 0.04789159f, -0.06109873f, -0.06172226f, 0.21065521f, -0.05834666f, 0.11663903f, -0.32530022f, 
    0.01277021f, -0.26315364f, -0.14359139f, 0.00437488f, 0.01985617f, 0.02470314f, -0.01105596f, -0.06971961f, 
    -0.03488103f, -0.01139862f, -0.04248731f, 0.13515729f, -0.01499394f, 0.01397257f, 0.00973971f, 0.00327657f, 
    -0.11985010f, -0.44413832f, -0.01459572f, 0.06235538f, -0.04292523f, 0.13805802f, -0.01754398f, 0.06347277f, 
    0.04795067f, 0.13697223f, 0.01767249f, -0.04270308f, -0.18556616f, 0.07794461f, -0.06800795f, -0.04240117f, 
    0.00821319f, 0.05830143f, -0.00738211f, -0.04802116f, 0.02185551f, -0.61586666f, 0.26997128f, 0.15552713f, 
    -0.12927590f, 0.02573313f, -0.10443595f, 0.10372952f, 0.03728358f, 0.12605684f, -0.13903455f, -0.14372520f, 
    -0.06346037f, 0.08028927f, -0.02415992f, 0.01739239f, -0.01565980f, 0.01767946f, -0.07254159f, -0.00760710f, 
    0.29553324f, -0.50308532f, 0.09448934f, 0.04339301f, 0.09412088f, -0.15346532f, 0.12974684f, 0.02187855f, 
    0.08989417f, 0.01762497f, 0.03847678f, -0.01474275f, 0.02223630f, 0.08380246f, -0.14910431f, 0.14034881f, 
    -0.02375339f, 0.02324615f, -0.07538738f, -0.03454042f, -0.41507903f, -0.09680619f, -0.02480862f, -0.01317760f, 
    -0.13506106f, -0.05465111f, -0.00471531f, -0.10723221f, 0.09601189f, -0.02694425f, -0.00383029f, 0.07782573f, 
    -0.04132279f, -0.10334124f, -0.09024979f, -0.04932890f, -0.05879221f, -0.00570984f, -0.04201655f, 0.09276368f, 
    0.20372613f, -0.60950637f, -0.27159798f, -0.24250780f, -0.09138218f, 0.09012287f, 0.01163904f, 0.06694967f, 
    -0.06545479f, -0.04231324f, 0.02905295f, 0.11072376f, 0.09887938f, -0.05663482f, -0.13328330f, -0.05751385f, 
    -0.11457503f, -0.15099880f, -0.10938507f, -0.12927304f, 0.08772940f, 0.10092217f, 0.24405105f, -0.01385235f, 
    0.20295708f, -0.04352524f, -0.00899369f, -0.03094839f, -0.04509776f, -0.00684196f, -0.08962933f, -0.06795260f, 
    -0.02764580f, 0.04452897f, 0.00367098f, -0.13430272f, 0.02903344f, -0.10903740f, 0.04725081f, 0.14206098f, 
    0.39550918f, -0.02555886f, -0.21440670f, 0.01488388f, -0.21188310f, -0.03391789f, 0.07498100f, -0.06759645f, 
    -0.06527445f, 0.09564833f, 0.10042924f, -0.00394348f, -0.08232716f, -0.08000064f, 0.16403535f, 0.07527432f, 
    0.01757356f, 0.03696171f, -0.15412900f, 0.08463620f, -0.36006033f, 0.07273138f, 0.00179436f, 0.03430578f, 
    -0.36842009f, 0.05084269f, -0.06722786f, -0.11813861f, 0.08363223f, 0.01451534f, -0.08177914f, 0.01752145f, 
    -0.04731515f, 0.06658347f, 0.04591055f, -0.03389348f, -0.16062020f, -0.11178410f, -0.10296223f, -0.18828006f, 
    0.03671921f, 0.18340558f, -0.09353121f, 0.10403065f, -0.09542115f, 0.02022488f, -0.04121768f, 0.09109894f, 
    0.08732681f, 0.06033904f, -0.01074671f, -0.03062367f, -0.09451509f, 0.04358782f, -0.11605226f, -0.02558529f, 
    -0.05331739f, -0.07719304f, -0.13050196f, -0.00734016f, 0.18794595f, -0.37499613f, 0.06303576f, -0.32164201f, 
    -0.07063921f, -0.03010756f, -0.03720127f, 0.02796152f, -0.02173322f, -0.00314073f, -0.13955139f, -0.00436506f, 
    -0.10791354f, 0.06525833f, -0.02844618f, -0.00323649f, -0.07343251f, 0.00056933f, 0.10753981f, 0.01323897f, 
    0.41693079f, 0.23787707f, 0.18369372f, 0.15535000f, 0.14130376f, -0.00610628f, -0.17054321f, -0.02410125f, 
    -0.00069340f, 0.02318987f, -0.01185514f, 0.01789071f, -0.12012699f, 0.11166403f, -0.24319604f, 0.07932696f, 
    0.02993131f, 0.06777725f, -0.06773454f, -0.01676385f, -0.31774583f, -0.12775443f, -0.11869340f, 0.03790385f, 
    0.07933795f, -0.14916499f, -0.04471326f, 0.02032186f, -0.03041425f, 0.01182762f, 0.00710351f, -0.06913111f, 
    -0.00482620f, -0.01860851f, 0.01069734f, -0.02039657f, -0.00677811f, -0.07973842f, 0.00553745f, -0.02357794f, 
    -0.47264010f, 0.16351309f, -0.30244082f, -0.35242805f, 0.10106595f, 0.04993562f, 0.09422709f, 0.05121564f, 
    -0.00521907f, 0.07834989f, 0.08165406f, -0.05548699f, 0.02410582f, 0.02678822f, -0.14136444f, -0.04343607f, 
    0.00434639f, 0.17455973f, -0.19535871f, 0.13697051f, -0.16893877f, 0.01660775f, -0.17992631f, -0.17365919f, 
    -0.16962215f, 0.09409653f, -0.05312204f, -0.04979368f, 0.00312631f, -0.09080610f, -0.02883873f, 0.06993091f, 
    -0.15645185f, -0.08715817f, -0.03078861f, 0.04138999f, 0.03765336f, 0.04564804f, -0.04700932f, 0.04177666f, 
    -0.38451475f, 0.10431370f, -0.14993390f, -0.15201509f, 0.17286827f, -0.20735493f, 0.11775826f, -0.02730215f, 
    -0.09088004f, 0.01457497f, -0.01715567f, -0.02350639f, 0.07767713f, -0.07045814f, -0.06952889f, 0.02697638f, 
    -0.05553564f, 0.07007417f, 0.09329436f, -0.02461014f, -0.16041335f, -0.42390344f, -0.05474157f, -0.21796887f, 
    0.04311226f, 0.08200795f, -0.06498534f, 0.16696385f, 0.00566445f, -0.02143328f, -0.08469924f, -0.00192097f, 
    0.16235308f, 0.08451611f, -0.03593960f, -0.13684438f, -0.05516598f, -0.18827678f, -0.03057658f, 0.04868947f, 
    0.22064872f, -0.06256635f, -0.21217147f, 0.04565210f, -0.06434108f, 0.03353089f, -0.06963957f, -0.14845519f, 
    0.02944341f, 0.17919527f, -0.03479806f, -0.09249387f, -0.00921315f, 0.00819558f, -0.03465949f, 0.08100919f, 
    0.13789883f, -0.09383240f, 0.02795510f, -0.02448504f, 0.30381510f, -0.13610001f, 0.01500949f, 0.10901429f, 
    -0.30023667f, 0.02529289f, 0.09073804f, -0.02145537f, -0.11446578f, 0.04344765f, 0.20282701f, 0.09239403f, 
    0.07084335f, 0.04367185f, -0.09456241f, -0.02944352f, 0.14681551f, -0.01537268f, -0.02521812f, 0.04265174f, 
    -0.42368656f, 0.27861193f, 0.04347425f, 0.08672494f, -0.40700147f, 0.02596217f, -0.11026294f, -0.00355102f, 
    0.05526332f, 0.20859137f, 0.07151884f, 0.02763943f, -0.00140023f, -0.04924977f, 0.02071742f, -0.01131912f, 
    -0.02534656f, 0.05076424f, 0.08511044f, 0.07887821f, -0.57938653f, -0.12982747f, -0.07351313f, 0.01977295f, 
    0.05412460f, 0.09988166f, -0.00301818f, -0.05662507f, 0.11278397f, -0.06337286f, 0.00022119f, 0.03225411f, 
    0.04350391f, -0.09835152f, 0.03875282f, 0.06486600f, -0.07122863f, -0.15864423f, 0.04878525f, -0.15891021f, 
    0.34378302f, 0.05569704f, 0.19158264f, -0.10412223f, 0.09307036f, 0.03941284f, -0.07968044f, 0.02843075f, 
    0.06247396f, -0.01579229f, -0.00403669f, 0.03928371f, -0.05245008f, 0.04957497f, 0.04086072f, -0.07403437f, 
    0.13015302f, 0.01704177f, -0.01546967f, -0.01086025f, 0.33030111f, -0.13270108f, -0.26529822f, 0.06211597f, 
    -0.25649461f, 0.03583914f, -0.06285730f, -0.00189816f, 0.01052328f, 0.07214822f, -0.05706606f, 0.08140923f, 
    -0.05780553f, 0.07373932f, 0.01288780f, 0.03480630f, 0.00842214f, -0.01405589f, -0.06168806f, -0.00993096f, 
    -0.06006257f, 0.13954075f, -0.03006523f, 0.07150318f, -0.10556431f, -0.16713096f, 0.09074633f, -0.03396684f, 
    -0.15666828f, 0.18930650f, 0.04265485f, 0.08296687f, 0.06199914f, -0.04088261f, 0.05404792f, 0.04017412f, 
    -0.02191883f, -0.00671698f, 0.07368509f, 0.10233100f, 0.00993656f, 0.23797154f, -0.03204919f, 0.06937259f, 
    0.24518394f, 0.01206708f, 0.05873491f, 0.05933340f, -0.02894414f, 0.07620926f, -0.00409819f, 0.18434542f, 
    0.01566047f, -0.04974495f, -0.13088174f, 0.06534699f, -0.13505715f, 0.11055934f, 0.02898840f, -0.03367012f, 
    0.29003543f, 0.13332944f, -0.03820453f, 0.10878216f, 0.24965072f, -0.01655539f, -0.01022077f, 0.10384642f, 
    -0.03154644f, 0.06255203f, -0.01630467f, -0.03915235f, -0.02948119f, 0.03324533f, 0.14265189f, 0.12317686f, 
    -0.02888855f, 0.05820814f, 0.01465028f, -0.12557669f, -0.16627166f, 0.02153485f, -0.16406173f, -0.14983888f, 
    -0.36029229f, -0.05056390f, 0.01696839f, -0.02953524f, -0.04766195f, -0.00584458f, -0.15296185f, 0.02314517f, 
    -0.06296957f, -0.05959660f, 0.01052371f, 0.03379649f, -0.07281891f, 0.00521962f, -0.11777708f, 0.05854311f, 
    0.27234632f, 0.21252562f, -0.00902892f, 0.10870958f, -0.22060703f, 0.04707095f, 0.02291282f, 0.10230316f, 
    0.03324623f, 0.09001867f, -0.00091912f, -0.16068488f, -0.03598263f, 0.11367647f, -0.02700477f, 0.09880920f, 
    0.04886432f, -0.08915387f, 0.07208668f, 0.03743594f, 0.22175050f, 0.04837104f, -0.24899939f, -0.10880583f, 
    0.05567144f, 0.00734648f, 0.05447841f, -0.14426331f, -0.01836511f, -0.01956754f, 0.19679441f, -0.18391907f, 
    -0.00100081f, -0.04831399f, 0.12791651f, -0.00341901f, -0.00376487f, 0.00731544f, 0.01133830f, 0.18130724f, 
    -0.02672269f, 0.01810637f, 0.18957035f, -0.16215119f, -0.01620756f, -0.07831512f, 0.07580365f, -0.02546508f, 
    -0.00239356f, 0.07622062f, 0.10955603f, -0.05433317f, 0.12038466f, -0.01260212f, -0.06569697f, -0.04230855f, 
    0.00949902f, -0.22809529f, 0.07177405f, -0.05882038f, 0.19934273f, -0.02544226f, -0.61009824f, 0.06085172f, 
    -0.23875004f, 0.06260787f, 0.04795828f, -0.02846632f, 0.04597484f, 0.16660333f, -0.06319429f, -0.22479600f, 
    0.00877179f, 0.04938693f, -0.12526742f, 0.01752701f, 0.03910048f, -0.03696631f, -0.16660120f, -0.07243803f, 
    -0.23217766f, -0.22972621f, 0.06143020f, -0.03034897f, 0.21153437f, 0.12267465f, -0.06177161f, -0.03403846f, 
    -0.00378749f, 0.06952988f, 0.07539482f, 0.09270340f, -0.03158908f, -0.01191490f, -0.06321121f, 0.01214232f, 
    0.01968084f, -0.14175665f, 0.03228126f, 0.13482055f, 0.11717171f, 0.07727785f, 0.20426515f, 0.14433354f, 
    0.26266110f, -0.06960958f, -0.16601415f, 0.08763074f, 0.00197519f, -0.04539199f, -0.07649704f, 0.03587173f, 
    0.15710765f, 0.16420527f, -0.07466786f, 0.09001213f, 0.02739909f, -0.10693596f, -0.01205033f, -0.01915189f, 
    0.03590696f, 0.05552189f, -0.04636877f, -0.20498373f, -0.11417647f, 0.00069786f, -0.10600220f, 0.14823504f, 
    0.02617675f, 0.12077689f, -0.04685330f, -0.19874005f, 0.12017729f, 0.07102083f, -0.02031353f, -0.13459125f, 
    0.10863223f, -0.13334198f, -0.19154678f, -0.00118202f, 0.03334243f, 0.01076767f, 0.10370679f, -0.17078871f, 
    0.01011750f, 0.02710737f, 0.08080224f, 0.00651388f, 0.08603028f, -0.00622457f, -0.10690286f, -0.14763692f, 
    0.11640521f, 0.05196141f, -0.00532139f, -0.07288966f, 0.01306930f, -0.28356510f, -0.14071745f, 0.00831540f, 
    0.49307674f, -0.22171879f, 0.00228481f, 0.04773079f, -0.16898288f, -0.05909748f, 0.00376728f, 0.09888583f, 
    -0.05974713f, -0.04387612f, 0.05451685f, -0.00519035f, 0.08322088f, -0.01045955f, -0.00681592f, 0.09212469f, 
    -0.01704067f, 0.09774914f, 0.04300079f, -0.02444976f, 0.16776021f, -0.01783636f, 0.00412161f, 0.11506820f, 
    -0.09408817f, -0.11122940f, 0.08476127f, 0.00873030f, 0.01433261f, -0.06662413f, -0.06553908f, -0.00415947f, 
    0.01584183f, -0.01702811f, -0.03544336f, 0.05943542f, 0.01238011f, -0.05033136f, 0.00747214f, -0.06444035f, 
    0.01879282f, 0.00047338f, -0.26106152f, -0.30770537f, -0.31019181f, 0.00720026f, 0.06702104f, 0.09470766f, 
    0.10259749f, 0.06567180f, -0.01412347f, -0.03371828f, -0.04035509f, -0.16159900f, -0.07979976f, 0.01689893f, 
    -0.02373567f, 0.04088392f, 0.23446004f, 0.04439034f, 0.11121428f, -0.11177664f, 0.09592327f, -0.15534624f, 
    0.08575650f, 0.10168365f, 0.08884010f, 0.09187482f, -0.03356248f, 0.02684029f, 0.02318868f, 0.05621327f, 
    0.06491158f, -0.14799489f, -0.02314745f, 0.04571512f, -0.10983963f, 0.01069728f, -0.10698834f, -0.02692841f, 
    0.17304727f, 0.07010683f, 0.01839091f, 0.15117316f, 0.12194224f, -0.13713162f, 0.04062115f, -0.12289936f, 
    -0.00337736f, 0.07661521f, 0.07067294f, -0.01618088f, 0.05780609f, 0.06557684f, 0.00829296f, 0.03109065f, 
    -0.12039961f, -0.03629085f, -0.05004983f, -0.01561405f, 0.33653241f, -0.19190511f, -0.33156064f, 0.11879499f, 
    -0.34137362f, -0.06646480f, 0.08644845f, -0.00419038f, 0.01610262f, -0.03383371f, 0.03180451f, -0.02767161f, 
    -0.07823585f, -0.04780140f, -0.07560591f, 0.01406971f, 0.07020258f, -0.02659655f, 0.10601894f, -0.07529209f, 
    -0.35456917f, 0.12950088f, -0.13566971f, -0.13413265f, 0.12556742f, 0.03135961f, 0.10484056f, -0.03018093f, 
    0.04698234f, -0.13787740f, -0.14716630f, 0.02311689f, -0.08379692f, -0.06781533f, -0.02347893f, -0.06444269f, 
    0.05044483f, -0.01815969f, -0.13395368f, -0.11647313f, 0.24984576f, -0.23983611f, -0.25684702f, 0.11881393f, 
    -0.19122493f, -0.06638550f, -0.04008248f, 0.02212151f, 0.09457339f, -0.00420838f, 0.02056170f, 0.05006823f, 
    -0.00907394f, 0.03267904f, -0.02010795f, -0.03455194f, -0.04819002f, 0.04021741f, -0.04914291f, 0.02226822f, 
    -0.03412491f, 0.16236952f, 0.07430630f, -0.23836453f, 0.13804612f, 0.06645785f, -0.00819345f, 0.13948734f, 
    0.06650385f, -0.03162271f, -0.14499557f, -0.06051202f, 0.12577806f, -0.01007327f, 0.01952955f, -0.09952662f, 
    -0.15198053f, -0.07693541f, -0.01169842f, -0.06129585f, 0.38412052f, -0.21065694f, 0.01904965f, -0.03388356f, 
    0.00577408f, -0.13807330f, 0.04650064f, 0.02244197f, 0.05404554f, 0.00376563f, 0.06638715f, -0.05368989f, 
    -0.03444866f, -0.00814738f, 0.02295239f, 0.06087023f, -0.02402508f, 0.10687498f, 0.04667708f, -0.07278832f, 
    0.33077732f, 0.02788530f, -0.37730375f, -0.26699981f, -0.11779959f, -0.00194617f, 0.09033030f, 0.00618874f, 
    -0.03100194f, -0.08118235f, -0.10933672f, -0.03040094f, 0.11155264f, -0.06577422f, -0.04073729f, -0.04903787f, 
    0.01899308f, -0.06285252f, -0.07190603f, 0.01146389f, 0.21817632f, -0.03312676f, -0.17562027f, -0.01139934f, 
    -0.07131053f, -0.10320339f, -0.08447302f, 0.01660882f, 0.06760756f, -0.03692995f, -0.03452266f, 0.01459143f, 
    -0.00081527f, -0.07928632f, -0.06841946f, -0.01643083f, -0.04705849f, -0.12564446f, 0.08393390f, -0.07832160f, 
    0.24607931f, -0.01480499f, -0.19932908f, -0.05705661f, -0.17076135f, 0.04050815f, 0.03378769f, 0.02338637f, 
    -0.02603841f, 0.02340498f, 0.04477502f, 0.05426311f, 0.00075969f, 0.06708048f, 0.05619821f, 0.02718831f, 
    -0.08681192f, -0.05813000f, -0.02982760f, -0.00607010f, -0.11803698f, 0.22805391f, -0.15956287f, -0.17785823f, 
    -0.18081835f, 0.20191047f, 0.10323908f, 0.04715094f, -0.04165266f, 0.02618976f, -0.16576944f, 0.07586387f, 
    -0.07249898f, -0.12847726f, -0.12426879f, 0.00321685f, 0.01068957f, 0.15894057f, -0.03555290f, -0.05011258f, 
    0.23907135f, -0.51863515f, 0.18116692f, -0.04469716f, 0.00585441f, -0.01517646f, -0.13076979f, -0.09077287f, 
    0.04079766f, 0.08959541f, 0.04854295f, -0.07402641f, 0.03208933f, 0.01281395f, -0.00294575f, 0.04624015f, 
    -0.08715385f, 0.04094511f, 0.01265041f, 0.02800856f, 0.09982567f, 0.09093031f, 0.22348483f, 0.16858184f, 
    0.21846187f, -0.21051171f, -0.10551439f, -0.21266712f, 0.02591565f, 0.04471723f, 0.04535861f, -0.08062909f, 
    -0.03176396f, -0.02842861f, 0.03059576f, -0.05385830f, 0.00589941f, -0.02518389f, 0.01667368f, 0.01077712f, 
    -0.32629946f, 0.21366450f, -0.01305211f, -0.07195748f, 0.03836086f, -0.10911310f, -0.07873066f, -0.08236351f, 
    0.03141843f, -0.19223252f, 0.01591849f, -0.09559906f, 0.11125181f, -0.06052637f, 0.14615555f, 0.06901945f, 
    -0.03417481f, -0.08555495f, -0.00704295f, 0.02572217f, 0.37723017f, 0.08322827f, 0.11070385f, -0.18925825f, 
    0.14021315f, 0.15091789f, -0.06488332f, -0.14703590f, 0.06793400f, 0.11532687f, 0.07252631f, 0.05922912f, 
    -0.01943696f, 0.06222142f, -0.00553138f, 0.05188041f, -0.08430714f, 0.01555995f, -0.02220886f, -0.06542542f, 
    0.17725940f, -0.07804287f, 0.00539082f, -0.10305955f, -0.12286828f, 0.02097739f, -0.04026087f, 0.16715562f, 
    -0.02791321f, 0.07761149f, -0.08001261f, 0.02301951f, 0.14416671f, -0.01252279f, -0.00696350f, -0.05552166f, 
    -0.03061437f, -0.00468143f, -0.06501369f, -0.08606891f, 0.25926629f, -0.32335690f, 0.20287986f, 0.03721629f, 
    0.21755728f, -0.11251939f, -0.07667872f, -0.08821966f, -0.02564214f, 0.06038390f, 0.08402371f, -0.04669172f, 
    -0.04840586f, 0.01732429f, 0.01518878f, 0.01837792f, -0.05401124f, -0.01917583f, 0.02395064f, -0.00124437f, 
    0.06038250f, 0.04112865f, 0.12510578f, 0.01179974f, 0.06455681f, -0.18198495f, 0.00580521f, -0.00933425f, 
    0.07720620f, -0.02976132f, 0.04924483f, -0.01072424f, 0.03718590f, -0.01678247f, -0.02189948f, -0.07444075f, 
    -0.05662973f, 0.01628071f, 0.01976837f, 0.01822345f, 0.02430386f, 0.07730459f, 0.07975391f, -0.11964726f, 
    0.11533400f, 0.08780951f, -0.03456502f, 0.01349502f, 0.05311811f, 0.11109415f, 0.02925799f, 0.09784447f, 
    0.00563702f, 0.00383395f, -0.02044742f, -0.11075655f, 0.00123657f, -0.10271053f, -0.16483606f, -0.01314330f, 
    -0.01578463f, 0.11261785f, -0.05737561f, -0.01158808f, 0.01182040f, 0.04416412f, 0.11401607f, 0.05372485f, 
    -0.00692428f, -0.03636882f, -0.03534499f, 0.04595575f, -0.04687541f, 0.02864728f, -0.08704247f, -0.04373409f, 
    -0.01897913f, -0.02028545f, -0.13960224f, 0.00607348f, 0.34617659f, -0.33397272f, -0.39956731f, 0.00835472f, 
    -0.19578928f, -0.01968878f, 0.00353633f, 0.06962472f, 0.04389740f, -0.11065228f, 0.04412235f, 0.02719381f, 
    -0.06290510f, 0.03558343f, -0.05337200f, 0.00962770f, -0.01093093f, 0.03076559f, 0.03067461f, -0.03230451f, 
    0.20188332f, -0.07406930f, 0.08809039f, 0.07861567f, 0.10314004f, -0.24444827f, 0.01122907f, -0.13888162f, 
    -0.07610787f, 0.04501001f, 0.08497281f, -0.03062022f, 0.02218330f, -0.11049207f, 0.05778168f, -0.01160721f, 
    -0.07492862f, 0.02189360f, -0.03325282f, 0.08063113f, -0.04955425f, 0.10739451f, -0.04344389f, 0.03666572f, 
    0.03094869f, -0.00594266f, 0.03548035f, -0.02138427f, -0.10466277f, 0.07137851f, 0.04084827f, -0.05380296f, 
    0.03789079f, -0.00717900f, -0.02919192f, -0.00545961f, -0.09382468f, -0.03006477f, -0.02940997f, -0.02921863f, 
    -0.59449995f, -0.03777695f, 0.09348968f, 0.09731833f, 0.01011289f, 0.01636020f, 0.01055761f, -0.10182949f, 
    -0.04243141f, 0.09919257f, -0.11163590f, -0.14768344f, -0.00860618f, 0.02556459f, 0.01058763f, -0.07000846f, 
    0.07854585f, -0.00061278f, -0.06147202f, -0.04912271f, 0.13598786f, -0.42753243f, 0.07270462f, 0.01486541f, 
    -0.22552785f, -0.01031837f, 0.06403516f, -0.09349235f, -0.08561202f, -0.00363616f, -0.03048848f, 0.01088444f, 
    0.12456191f, 0.05747367f, -0.04446277f, 0.10968941f, -0.02344205f, -0.10350522f, 0.06493326f, -0.04996599f, 
    -0.01494839f, 0.12235319f, 0.02083127f, -0.12951334f, -0.06046457f, 0.05563741f, -0.04693360f, -0.05690257f, 
    0.00537230f, 0.05157135f, -0.04666670f, 0.04045820f, -0.01980401f, -0.08066631f, -0.01178162f, 0.03104300f, 
    -0.04690232f, 0.13252980f, 0.11187004f, 0.09364556f, -0.14679272f, 0.16228686f, 0.02980204f, -0.18718323f, 
    0.07694934f, 0.07526422f, 0.08535216f, 0.13249424f, -0.03914692f, -0.09345806f, -0.19355702f, 0.07585624f, 
    -0.02595234f, -0.12820733f, -0.01651290f, 0.09133019f, -0.01125005f, -0.00867211f, -0.21434364f, 0.06480869f, 
    -0.13763124f, -0.24314635f, -0.11470082f, -0.29579717f, -0.29717389f, 0.11202317f, -0.09770937f, -0.11014926f, 
    0.03609333f, -0.05647571f, 0.03927805f, 0.06528084f, -0.06692555f, 0.00850775f, 0.06982185f, -0.14602217f, 
    -0.05363381f, 0.04822481f, -0.06111529f, -0.03184098f, -0.49095032f, -0.41976041f, -0.10011452f, -0.10270084f, 
    -0.37501758f, 0.00899705f, 0.02529010f, -0.07168822f, 0.02204077f, -0.09918506f, 0.12366596f, 0.03053022f, 
    0.08931860f, 0.02378467f, 0.03511192f, 0.02282778f, -0.00350190f, 0.07761711f, 0.03721394f, -0.12757528f, 
    0.06120288f, 0.05994868f, 0.11890493f, 0.06992978f, -0.08424269f, -0.00848835f, -0.08816799f, -0.01578057f, 
    -0.05917551f, -0.06483521f, 0.04700465f, 0.05033980f, -0.05697453f, -0.00933038f, 0.06781057f, -0.01135490f, 
    0.02759315f, -0.08654997f, -0.10127228f, 0.05785501f, -0.28172910f, 0.08057471f, 0.01051041f, 0.17569003f, 
    0.12193332f, 0.16286659f, 0.00988613f, 0.03977407f, -0.07628024f, -0.03881623f, -0.15839951f, 0.02377310f, 
    -0.05849979f, -0.07405891f, -0.10616139f, -0.00214870f, -0.01910986f, -0.02119966f, 0.05679828f, -0.23643215f, 
    0.05329184f, 0.22899991f, 0.21716988f, 0.20863350f, 0.18451682f, -0.11714576f, 0.18805800f, 0.00826828f, 
    0.15119621f, 0.16528010f, 0.08628861f, 0.07883227f, -0.05655837f, -0.04778412f, -0.05095588f, 0.06638657f, 
    0.00506655f, 0.02942948f, 0.11582468f, -0.02525767f, -0.10629155f, -0.43949035f, -0.38699019f, 0.13788983f, 
    0.03633631f, -0.10193704f, -0.16543078f, -0.06343640f, 0.04771207f, -0.02657497f, -0.04897427f, 0.01633125f, 
    -0.12486117f, -0.02903074f, -0.00433798f, -0.03038163f, -0.00548215f, 0.10941420f, -0.04726352f, -0.05985608f, 
    -0.20183803f, -0.07389861f, -0.08874273f, -0.04907862f, -0.13904804f, -0.10901301f, -0.23707090f, 0.16434599f, 
    -0.03900826f, 0.03618765f, -0.06503446f, 0.08461671f, -0.06480755f, -0.01036582f, -0.00970872f, 0.03601122f, 
    0.00012597f, 0.09263884f, 0.21858062f, -0.03699340f, -0.04247179f, 0.26210752f, 0.16883798f, 0.22492364f, 
    -0.01740804f, -0.02475822f, -0.08947265f, 0.04705227f, -0.09816834f, -0.01755151f, -0.05808479f, -0.03772343f, 
    0.06103913f, -0.04345953f, -0.09135047f, 0.01714734f, 0.03504705f, -0.05407475f, -0.03083252f, -0.00471646f, 
    -0.17849028f, -0.23911266f, -0.21680245f, 0.17808194f, 0.21233925f, 0.04208985f, 0.08553166f, 0.06006227f, 
    -0.00078463f, 0.02399996f, -0.06485850f, 0.07122473f, 0.02960803f, -0.03242747f, 0.03289857f, -0.05410655f, 
    0.02255536f, 0.02340183f, 0.00497900f, -0.04811430f, 0.08510008f, -0.00477242f, 0.14102571f, 0.08785967f, 
    0.03454502f, -0.04910120f, -0.01358223f, 0.03712253f, -0.05875194f, 0.05123884f, 0.00761095f, 0.05092436f, 
    -0.08548946f, -0.01181436f, 0.00541264f, -0.03460761f, -0.00461564f, 0.02963714f, -0.01413784f, 0.08872078f, 
    -0.46121669f, -0.45767924f, -0.07999216f, -0.25179860f, -0.12304697f, -0.18644500f, -0.09547923f, -0.01863044f, 
    0.00244984f, -0.10970026f, -0.12227650f, 0.01131739f, 0.08656961f, -0.03605151f, 0.09907179f, 0.00779743f, 
    -0.18361622f, -0.11373483f, 0.00978110f, -0.01289157f, -0.22099502f, 0.19341688f, 0.12245997f, 0.07773431f, 
    -0.01518150f, 0.01726005f, -0.15937087f, -0.03403623f, 0.08205306f, -0.04093115f, -0.00959553f, -0.00951817f, 
    -0.02502351f, 0.00957215f, -0.06950679f, -0.02761974f, -0.07626075f, -0.06289641f, 0.07921346f, 0.02901731f, 
    -0.32432508f, 0.49188071f, 0.14465377f, -0.04643124f, 0.13619490f, 0.00586569f, 0.09628999f, -0.10059500f, 
    0.17938316f, -0.01653526f, -0.03306697f, 0.00475888f, -0.05328540f, 0.07301701f, -0.05688388f, -0.06822716f, 
    0.01855618f, -0.18102346f, 0.20811683f, 0.06771872f, -0.13694152f, 0.11451513f, 0.18647732f, -0.10288523f, 
    0.02904895f, -0.02054799f, -0.07218075f, -0.00621667f, 0.02065473f, 0.02235424f, -0.06153393f, 0.00865133f, 
    -0.01302035f, 0.05183158f, -0.00158444f, -0.05015332f, 0.04471820f, -0.10218179f, 0.09190530f, -0.00984198f, 
    -0.11119696f, 0.26274508f, 0.04895702f, -0.08531833f, -0.07212883f, 0.08467819f, -0.02235018f, -0.05027315f, 
    0.08104058f, -0.00963245f, 0.06504776f, -0.01203977f, -0.00889481f, -0.01867687f, -0.08528994f, -0.06018218f, 
    0.02413882f, -0.05992740f, 0.05988749f, -0.01906592f, 0.09620803f, 0.28541386f, -0.04508647f, 0.27958199f, 
    0.14398329f, 0.15760896f, 0.11523896f, 0.07250096f, 0.07219750f, 0.03004297f, -0.01225473f, -0.07593326f, 
    -0.02680960f, -0.11141051f, -0.16965035f, 0.01322853f, 0.02593382f, 0.09475639f, 0.04213705f, 0.05438430f, 
    0.03509968f, 0.07746852f, -0.03246056f, -0.10197514f, 0.06590612f, -0.00646347f, -0.03399855f, -0.04700163f, 
    0.02652015f, 0.01780974f, -0.08318529f, 0.02014655f, 0.03168155f, 0.07307773f, 0.00722774f, -0.03706345f, 
    -0.01038865f, 0.00669063f, -0.02094410f, -0.10763033f, 0.05548287f, -0.16050133f, -0.11664052f, -0.09361152f, 
    -0.23856050f, -0.00710196f, -0.11169674f, -0.00154702f, -0.08097017f, 0.12532005f, -0.09615706f, -0.04030472f, 
    0.11034407f, -0.10125071f, 0.08485788f, 0.04106767f, -0.11386758f, 0.09863313f, -0.02153173f, 0.09393928f, 
    0.47054279f, -0.17571817f, 0.15452670f, -0.00101207f, 0.00769427f, -0.05678067f, 0.03794704f, -0.02290430f, 
    -0.08731463f, -0.07789813f, -0.05282585f, 0.06363796f, 0.10991246f, 0.02036715f, -0.02447690f, -0.06891289f, 
    0.04891937f, -0.15738116f, 0.09249299f, -0.05295648f, 0.19501945f, 0.28297827f, -0.16826630f, -0.04205218f, 
    0.00404384f, 0.04719574f, -0.07812042f, 0.00836063f, 0.01061191f, -0.01548915f, -0.01254439f, 0.00999061f, 
    -0.12123115f, 0.07298622f, -0.06889287f, -0.06816514f, 0.00181561f, -0.01023721f, 0.07146650f, 0.05128852f, 
    0.02063875f, -0.35958672f, -0.22237824f, -0.07790701f, -0.14269266f, -0.22733402f, -0.12740706f, -0.07086360f, 
    0.00571309f, 0.05309480f, -0.05630963f, 0.01404083f, 0.00389294f, -0.00998304f, -0.04482447f, -0.03205963f, 
    -0.00912150f, -0.10282643f, -0.00614379f, 0.11319295f, -0.06787176f, -0.03965851f, -0.07458934f, -0.01141546f, 
    -0.02401138f, -0.05662151f, -0.18745865f, -0.06116646f, 0.07342499f, 0.01125728f, 0.02880462f, -0.04438523f, 
    0.07030455f, -0.00667007f, 0.03120453f, -0.05442122f, -0.02782598f, -0.02002878f, 0.02093288f, 0.02265830f, 
    -0.09681615f, -0.24719591f, -0.08326670f, -0.09525152f, -0.19492547f, 0.07076715f, -0.01741370f, 0.06426188f, 
    -0.00852496f, -0.10709968f, -0.00565515f, -0.02744333f, 0.05342075f, -0.05957592f, 0.01430111f, 0.01972758f, 
    -0.01311132f, -0.01100364f, -0.02232273f, -0.00693728f, -0.62327832f, -0.47171170f, -0.05165992f, -0.06321557f, 
    -0.23690850f, -0.11531127f, -0.10694111f, 0.00373981f, 0.03654882f, -0.09256102f, 0.00363102f, -0.14644493f, 
    0.12697050f, -0.01884057f, 0.00827021f, 0.08310608f, 0.19643676f, -0.03727693f, 0.05840784f, 0.15854767f, 
    -0.17714630f, -0.61805612f, -0.26489064f, 0.05263731f, 0.14924920f, -0.01787750f, -0.02615101f, 0.08261577f, 
    0.03895949f, -0.08874867f, 0.01926236f, 0.02313916f, -0.08058434f, 0.04425948f, 0.02976397f, 0.10897110f, 
    0.05017182f, -0.03636775f, 0.06427617f, 0.01649852f, 0.01867547f, 0.10165767f, 0.11140714f, 0.05965300f, 
    -0.04739577f, 0.06616245f, -0.04108038f, -0.01424219f, 0.06662691f, 0.04973903f, 0.06564955f, 0.03005353f, 
    -0.02137131f, -0.00517351f, -0.07908271f, -0.09673900f, -0.04616207f, 0.04386291f, 0.05179927f, 0.00186867f, 
    0.20815238f, -0.03484644f, -0.05398103f, -0.00505680f, -0.13747901f, -0.12815091f, -0.08200374f, -0.07275420f, 
    -0.02437436f, 0.03710305f, -0.09043798f, -0.02264548f, 0.04283616f, 0.01439073f, 0.03229154f, -0.06379484f, 
    -0.04527259f, 0.05629976f, -0.07138272f, 0.10753028f, -0.23108388f, 0.21491443f, -0.09044036f, -0.18832222f, 
    -0.20250711f, -0.15061334f, -0.08899740f, 0.14532758f, -0.01012114f, -0.06534481f, -0.01874358f, 0.03523747f, 
    -0.08471686f, 0.00931722f, -0.01448463f, 0.02362364f, -0.02798514f, 0.04879187f, 0.10934458f, -0.01161483f, 
    -0.01822539f, 0.14691828f, -0.22109188f, 0.11072789f, -0.06241257f, -0.09895806f, 0.09510507f, -0.00296917f, 
    0.02396886f, 0.03459088f, -0.01354015f, 0.06780685f, -0.14802843f, -0.04769054f, 0.04652411f, 0.05930034f, 
    0.05790177f, -0.02961412f, 0.00023306f, -0.04737695f, -0.29454887f, 0.23743534f, 0.10194637f, 0.07962079f, 
    0.11391570f, 0.03354334f, 0.02109332f, -0.02399304f, 0.06228397f, 0.06657366f, 0.02170510f, 0.02440535f, 
    -0.02940424f, -0.00852419f, 0.02853723f, -0.06818025f, 0.10143501f, -0.00733149f, 0.11671325f, -0.09274018f, 
    0.38391113f, 0.30707818f, -0.13999352f, 0.03105288f, -0.00768745f, 0.03066075f, 0.02023797f, -0.02091821f, 
    0.07763872f, 0.00895149f, -0.07020733f, 0.05492356f, -0.07902440f, 0.00959213f, 0.05322524f, -0.02111073f, 
    -0.02270755f, 0.01050041f, -0.08212396f, -0.04010645f, 0.09598371f, -0.50337237f, -0.41327578f, 0.20879854f, 
    0.12396374f, -0.04006021f, 0.06767816f, 0.02592196f, 0.03422274f, -0.13862747f, 0.05291132f, 0.00774052f, 
    -0.05664783f, -0.15707707f, -0.00696114f, 0.04193207f, 0.01230547f, 0.12324817f, 0.01538105f, -0.06405755f, 
    0.22099562f, 0.15925233f, 0.04436188f, 0.08179346f, -0.02712346f, -0.04583230f, -0.05448242f, -0.02602018f, 
    -0.03144260f, 0.01455025f, -0.07848527f, -0.06412515f, -0.02240268f, 0.03258305f, 0.00656590f, 0.04370207f, 
    0.00037843f, 0.19483916f, 0.05464782f, -0.01645628f, 0.11018172f, 0.17278451f, 0.10238731f, 0.16017799f, 
    -0.05188502f, -0.10883372f, 0.01467076f, -0.02862645f, -0.02589038f, 0.04092964f, 0.05121037f, -0.02057340f, 
    -0.10652637f, -0.05806858f, -0.07753143f, 0.01249615f, -0.00441104f, 0.07277997f, 0.08178548f, 0.04764140f, 
    -0.36390156f, 0.41822150f, -0.13066402f, 0.04554978f, -0.13701321f, 0.08169296f, -0.00671487f, 0.03467784f, 
    0.06639369f, 0.03274388f, -0.16473603f, 0.05714469f, 0.00001313f, -0.00036058f, -0.09582949f, 0.04039141f, 
    -0.03683868f, 0.03329941f, 0.04498414f, -0.09518438f, -0.09897486f, -0.10810520f, 0.16638450f, -0.00130366f, 
    0.15387468f, 0.05094584f, -0.00313970f, -0.08308316f, -0.20439148f, 0.00999788f, -0.09852252f, 0.02440580f, 
    -0.09137170f, 0.00986581f, 0.05065473f, -0.04676127f, -0.09796792f, -0.05160218f, 0.02339231f, -0.09583374f, 
    -0.18465635f, 0.02860788f, -0.08253369f, 0.07580342f, -0.31581935f, -0.08581664f, -0.02517716f, -0.02460268f, 
    -0.06501466f, -0.17867181f, 0.06404528f, -0.01657370f, 0.04223866f, -0.10441103f, -0.04124031f, -0.06940304f, 
    0.06203036f, 0.18628947f, 0.10180677f, 0.05492904f, -0.26041174f, 0.05753953f, 0.04345517f, -0.04085240f, 
    0.02172762f, 0.07299233f, -0.08319016f, -0.03694106f, 0.11983197f, 0.11370014f, 0.05385636f, -0.14048027f, 
    0.03281777f, 0.03434105f, 0.02954383f, 0.08613741f, -0.02723739f, -0.02981214f, -0.01916710f, -0.02964445f, 
    -0.36978641f, -0.22138315f, 0.03609446f, 0.10513296f, 0.27330902f, 0.01956301f, 0.05663488f, 0.02336123f, 
    -0.06727340f, 0.00318750f, 0.01966871f, -0.05989416f, 0.08657414f, 0.05438956f, -0.03129882f, -0.03209408f, 
    0.07997815f, 0.14598082f, 0.10143334f, -0.15957597f, -0.02062235f, -0.09976624f, 0.12123266f, 0.03407946f, 
    0.20735788f, 0.03345184f, -0.09185816f, -0.02758997f, -0.08061725f, 0.04782044f, 0.06509843f, 0.02291389f, 
    -0.04888300f, -0.03899693f, 0.05277618f, -0.12539914f, 0.02438739f, -0.00915116f, 0.08709125f, -0.06967825f, 
    -0.10131259f, -0.35062775f, 0.21019229f, 0.18321460f, 0.01278094f, 0.02726184f, 0.01932653f, 0.03317018f, 
    -0.07561994f, 0.03069889f, 0.16588539f, 0.02566019f, -0.01098215f, -0.09662300f, 0.00902460f, 0.14398271f, 
    0.01447130f, 0.05920569f, 0.05941680f, 0.07933642f, 0.07851599f, 0.16666974f, -0.01794420f, 0.14675064f, 
    -0.03815071f, 0.04871723f, -0.12476452f, 0.01512659f, 0.13889636f, 0.00117809f, -0.01242970f, -0.01611732f, 
    0.03382617f, 0.00289789f, -0.00853495f, 0.05319741f, 0.07028688f, -0.01773406f, 0.00694007f, -0.08788548f, 
    -0.03250955f, -0.15231866f, 0.20258473f, -0.20502095f, 0.06994636f, -0.01359456f, -0.00394155f, -0.06054028f, 
    0.10791019f, 0.08300132f, 0.18495640f, -0.01629557f, 0.06243885f, -0.11006699f, 0.06917593f, 0.04891874f, 
    -0.03983606f, -0.12991130f, -0.00164215f, 0.04727806f, -0.32459393f, 0.22147791f, -0.20756321f, -0.37096187f, 
    -0.09825023f, 0.12348615f, -0.05466033f, 0.00989432f, 0.01126633f, -0.01534965f, 0.00256750f, -0.00558663f, 
    -0.05558091f, 0.03343727f, 0.00514060f, -0.00161276f, -0.05290931f, -0.05332490f, -0.04466185f, -0.05119511f, 
    0.10077370f, 0.32133538f, 0.21484074f, 0.06566740f, -0.01965422f, -0.14873928f, -0.13522194f, 0.15412933f, 
    -0.03326460f, -0.02890502f, -0.01587931f, 0.05581710f, -0.13958113f, 0.01211660f, 0.03493192f, 0.03521345f, 
    -0.07962703f, 0.06122385f, -0.13410951f, -0.08998341f, 0.48150909f, 0.03539729f, -0.00293162f, -0.13310264f, 
    0.20127481f, -0.16838247f, 0.04902495f, 0.06770508f, 0.05278483f, -0.07914497f, 0.00787340f, -0.00733826f, 
    -0.00096827f, -0.00538892f, 0.01114353f, -0.08183228f, -0.04445012f, -0.14191553f, 0.09727371f, -0.04452297f, 
    -0.25797030f, 0.48788756f, -0.21994770f, -0.12546194f, -0.10444736f, 0.02693553f, -0.02185748f, 0.14400706f, 
    0.05968603f, -0.01665468f, -0.00451523f, 0.04072416f, -0.10652919f, -0.02180722f, -0.00270482f, 0.02334340f, 
    0.05988575f, -0.13489695f, -0.04836795f, -0.04724605f, -0.31855810f, -0.44283691f, 0.25539395f, 0.22647162f, 
    -0.11832000f, -0.10535909f, 0.07368665f, -0.16992024f, -0.13828400f, -0.19810291f, 0.02971074f, 0.02505053f, 
    -0.20985657f, 0.03729051f, 0.14062268f, -0.07820763f, -0.08407875f, 0.10774755f, -0.03116665f, 0.00327510f, 
    -0.32259500f, 0.13743666f, 0.06686649f, 0.00914529f, -0.07989003f, 0.03234933f, 0.03347607f, 0.05035168f, 
    0.06846018f, -0.16480862f, -0.12978926f, 0.05886134f, -0.05964175f, 0.05750034f, -0.00135983f, -0.03657933f, 
    -0.07739826f, 0.03203964f, -0.09468298f, -0.03336301f, -0.83332872f, 0.03544530f, -0.03093082f, 0.22922520f, 
    0.23681340f, 0.08868454f, -0.00763159f, -0.03260589f, 0.06062147f, 0.16214857f, 0.00229704f, -0.03044516f, 
    0.01700592f, -0.01316350f, 0.06842814f, 0.10256681f, 0.01219354f, -0.04622780f, 0.14990373f, -0.02830987f, 
    0.05039874f, -0.15668985f, 0.05319777f, -0.37366673f, 0.10409093f, 0.08783517f, -0.00549869f, -0.03709389f, 
    0.02080663f, -0.02630094f, -0.07304408f, 0.09310665f, -0.01032184f, -0.03545348f, -0.10502721f, -0.02627852f, 
    -0.06813722f, -0.33481863f, -0.05502854f, 0.03552395f, -0.39161181f, -0.09212551f, 0.00120432f, -0.12810813f, 
    -0.16947143f, 0.07590757f, -0.01115874f, 0.09258955f, -0.09870852f, 0.02550347f, -0.02867857f, -0.04564209f, 
    0.05718870f, -0.03840456f, 0.04472098f, 0.03275237f, 0.08282869f, 0.07523644f, 0.14882840f, 0.08181411f, 
    0.34757888f, -0.43806943f, -0.04359248f, 0.02529372f, -0.19641531f, -0.00484300f, -0.09686077f, 0.02867156f, 
    0.01535542f, 0.03547765f, -0.06609116f, 0.02990663f, -0.00922574f, -0.06435733f, -0.04782177f, 0.00972561f, 
    0.06002133f, -0.09488701f, 0.01728991f, -0.09635015f, -0.46787426f, 0.03161243f, 0.00978439f, 0.03638456f, 
    0.09638227f, -0.07610279f, -0.03883823f, 0.01145548f, 0.07233304f, -0.05070879f, -0.08216848f, -0.00513187f, 
    -0.02693508f, 0.08611500f, 0.04128456f, -0.05939097f, 0.05160807f, 0.09281395f, 0.05431008f, -0.05285436f, 
    -0.12818097f, 0.17246512f, -0.41009718f, -0.25643021f, 0.12819238f, 0.06297012f, -0.11892612f, -0.04610319f, 
    0.13059372f, -0.12403290f, 0.01388272f, -0.05383987f, -0.03036959f, 0.10972546f, 0.12189747f, 0.07376758f, 
    0.01623843f, 0.04449290f, -0.06114168f, -0.05205260f, 0.38092896f, 0.17009549f, -0.27964130f, 0.07239331f, 
    0.12317988f, 0.15402117f, -0.01224258f, 0.01750978f, 0.16680357f, 0.05159191f, -0.06007957f, 0.02361928f, 
    0.04310863f, 0.13417426f, 0.09068681f, -0.10217650f, 0.14605647f, -0.00639445f, 0.02067431f, 0.01015157f, 
    0.23032144f, -0.05850377f, 0.08625695f, 0.01193080f, 0.06838732f, -0.10484309f, -0.07469420f, 0.02712096f, 
    0.02737442f, 0.02444597f, -0.08066761f, 0.01859267f, -0.01843671f, -0.08316836f, -0.13926579f, 0.04027515f, 
    -0.06992114f, -0.01621865f, 0.05412876f, 0.02994299f, 0.21373974f, 0.25144681f, -0.07555167f, -0.23631202f, 
    -0.19343966f, -0.09681118f, -0.01328879f, -0.05013812f, -0.11383007f, -0.08579522f, 0.03653633f, -0.08177768f, 
    -0.03816302f, 0.12981580f, 0.05919977f, -0.00025458f, 0.09829043f, 0.04016265f, 0.00487296f, 0.00879568f, 
    0.01414546f, 0.24712074f, -0.06741884f, 0.01211904f, 0.17154944f, 0.14757384f, -0.01218227f, 0.00369158f, 
    0.07238641f, -0.07681812f, 0.08051886f, 0.00812740f, -0.03882259f, -0.04630475f, -0.00795204f, 0.00957987f, 
    -0.12248509f, -0.02044119f, -0.00442299f, -0.04187082f, 0.03605665f, -0.26923618f, -0.06770414f, 0.05179558f, 
    0.09826162f, 0.06801409f, 0.09509105f, 0.13493292f, -0.06059204f, -0.13731439f, 0.01886404f, 0.00984928f, 
    0.09808548f, 0.00325708f, -0.08300086f, 0.03033942f, -0.03269111f, -0.15629169f, 0.12232926f, 0.02343890f, 
    -0.21108635f, 0.02573854f, -0.17097823f, 0.19722515f, -0.07857305f, -0.00307964f, -0.05645866f, -0.02637416f, 
    -0.06892453f, -0.06541779f, -0.04630429f, -0.00212608f, -0.03692880f, -0.01291683f, 0.03699141f, -0.07161702f, 
    -0.08879964f, 0.04411103f, -0.06313762f, 0.18537383f, -0.01987421f, 0.09819908f, 0.07780486f, -0.12202365f, 
    0.07773699f, 0.01241256f, 0.10972686f, 0.08458965f, 0.09635101f, 0.04124065f, 0.03584070f, 0.11807394f, 
    0.14273676f, -0.10636101f, 0.10720034f, -0.10622125f, -0.08336668f, 0.14502469f, -0.01866508f, 0.09639131f, 
    -0.02700118f, -0.05271152f, 0.03498362f, -0.15835902f, -0.05677670f, -0.06545879f, 0.03207533f, -0.07493468f, 
    0.05161210f, -0.03622605f, -0.04153492f, -0.17911480f, 0.04663789f, 0.03503408f, 0.07406283f, -0.07410968f, 
    0.03114390f, -0.08542200f, -0.08656552f, 0.10321645f, -0.33325616f, -0.22096653f, 0.21381758f, 0.21585372f, 
    0.04195851f, -0.23036394f, 0.02479382f, -0.13019834f, -0.01807260f, 0.07616141f, 0.01440194f, 0.01368879f, 
    0.03944100f, 0.00516981f, 0.00131410f, -0.27217427f, -0.03200482f, -0.10839185f, 0.03976911f, 0.04427468f, 
    0.01087408f, -0.09647839f, 0.20628488f, -0.04546176f, -0.16016011f, -0.00977335f, 0.05277390f, -0.18140759f, 
    0.26931539f, -0.00953847f, 0.16310449f, -0.01363637f, -0.03953442f, 0.05191953f, 0.11641884f, 0.08213373f, 
    -0.11845444f, -0.01480232f, 0.04524832f, 0.12524243f, 0.03501086f, 0.08021416f, -0.13211897f, 0.33372504f, 
    -0.03683672f, 0.03543008f, 0.04266293f, 0.02349200f, 0.13784173f, -0.01683247f, 0.02842726f, 0.02253228f, 
    -0.00465410f, 0.02809134f, 0.01135200f, 0.00938349f, -0.02314374f, -0.04587837f, 0.11786776f, 0.08498854f, 
    -0.53983325f, -0.24303660f, -0.14369047f, 0.00597573f, 0.03463252f, 0.08851609f, -0.15553716f, 0.00230700f, 
    -0.01833728f, -0.07170257f, 0.06288874f, -0.06120545f, -0.10285901f, 0.04254402f, 0.00142444f, -0.05837547f, 
    0.10080963f, 0.04904519f, -0.05697852f, 0.03698935f, 0.14233193f, -0.10566281f, -0.03781582f, -0.06083679f, 
    0.13862059f, -0.15926751f, -0.13750702f, 0.00735405f, 0.13607344f, 0.10005409f, 0.12634790f, 0.00104368f, 
    -0.03121492f, 0.22607914f, 0.19275688f, 0.07108913f, 0.16760223f, 0.00849045f, -0.22978583f, 0.00975350f, 
    -0.10894316f, -0.11159821f, 0.15329729f, 0.15665133f, 0.27031428f, -0.10969495f, -0.02266416f, -0.02719463f, 
    0.07753205f, 0.09644718f, 0.00040937f, -0.19276112f, -0.01462917f, 0.12829207f, 0.04267748f, 0.05877299f, 
    -0.11239138f, -0.21027927f, -0.27481252f, -0.07430018f, 0.01858249f, -0.12559138f, 0.05033930f, 0.18814915f, 
    0.06994989f, 0.03236800f, 0.05336699f, 0.00589827f, 0.00839653f, -0.04684084f, -0.06062586f, 0.04930502f, 
    0.01235229f, 0.03245346f, 0.10542045f, -0.03698384f, 0.01448237f, 0.06234207f, 0.08351901f, -0.06129325f, 
    -0.41435191f, 0.21237814f, -0.24238619f, -0.20522663f, 0.00811670f, 0.13191216f, 0.04594037f, 0.13490535f, 
    -0.07194839f, -0.19953947f, 0.14539096f, 0.00953347f, -0.06968348f, -0.00789811f, -0.08395978f, 0.03242496f, 
    -0.04415123f, -0.03168427f, -0.11817248f, -0.04504795f, 0.25765300f, -0.01444350f, 0.04773607f, -0.01260500f, 
    0.17724724f, 0.09366197f, 0.06391610f, -0.01158251f, 0.07233263f, 0.08378883f, 0.01250723f, 0.02894409f, 
    0.07385445f, 0.10757261f, 0.12175883f, 0.09183553f, 0.02215597f, 0.01620224f, -0.34454253f, 0.14836545f, 
    0.10130495f, 0.06345461f, -0.02911762f, 0.12728590f, 0.12920932f, -0.16637824f, 0.09352411f, -0.12115268f, 
    0.06916357f, 0.03267722f, -0.08773129f, -0.06302188f, 0.13992171f, 0.17152697f, 0.13935162f, -0.02807050f, 
    0.02099903f, 0.01970321f, -0.02027614f, -0.01465075f, -0.10611615f, -0.05858979f, 0.00263552f, -0.05885440f, 
    0.15488419f, 0.14099813f, 0.16699994f, -0.06919377f, -0.00266432f, 0.06080401f, -0.03501888f, 0.03132081f, 
    -0.01961518f, -0.09615768f, 0.03773516f, -0.13265555f, -0.04167341f, 0.09984430f, -0.13966924f, 0.13096291f, 
    0.05720774f, 0.01091961f, 0.15868799f, 0.14277485f, 0.01812961f, -0.15880491f, 0.10704756f, 0.07900421f, 
    0.02565488f, 0.03254543f, 0.09919734f, -0.01437624f, 0.00050999f, -0.02466464f, 0.05085117f, 0.10820217f, 
    0.01618583f, 0.15776943f, 0.07274332f, 0.06974374f, -0.35679722f, 0.01455105f, -0.20038958f, -0.07449516f, 
    -0.07382792f, 0.12528221f, -0.00407637f, -0.07089134f, -0.05276635f, -0.04871697f, -0.03854496f, 0.09547251f, 
    -0.02628922f, -0.05636907f, 0.04623196f, 0.06964689f, 0.00359777f, 0.10598432f, 0.06529655f, 0.00449083f, 
    0.05472400f, -0.25177234f, 0.01185008f, 0.23362803f, -0.12200723f, -0.00734820f, 0.03971318f, -0.10395521f, 
    0.04334809f, -0.06568813f, 0.04261928f, 0.10967711f, 0.00216743f, 0.06961063f, 0.14491197f, -0.08107617f, 
    -0.07934558f, -0.03568165f, -0.02966824f, -0.04364677f, -0.06791906f, 0.07793912f, -0.06330400f, 0.11643095f, 
    -0.00876552f, 0.04939206f, -0.01019196f, -0.06291956f, -0.09497461f, 0.13701759f, -0.01105053f, -0.03477520f, 
    -0.05420126f, 0.00385434f, -0.02028119f, -0.03492443f, 0.01762407f, 0.12631531f, -0.11459761f, 0.02368670f, 
    -0.41360268f, -0.16724777f, 0.13064809f, 0.14599568f, -0.28995436f, 0.09635547f, -0.07988255f, -0.04551094f, 
    -0.02627409f, -0.00055088f, -0.05030832f, 0.03201910f, 0.09506758f, 0.07200056f, 0.02420275f, 0.03240392f, 
    -0.06007560f, 0.01657445f, 0.07761767f, -0.00709833f, 0.20137192f, 0.14687462f, 0.05780794f, 0.40826944f, 
    -0.04022716f, -0.16996831f, -0.12953533f, 0.04262962f, -0.04359604f, 0.09288231f, -0.07361934f, -0.13853568f, 
    -0.04562761f, 0.17250809f, 0.17339560f, 0.04942245f, 0.06968537f, -0.13720202f, -0.15324600f, -0.05103804f, 
    -0.34868997f, -0.11986186f, -0.14544347f, -0.08522677f, 0.05195624f, 0.01369040f, 0.05614046f, 0.00720522f, 
    -0.05826497f, -0.04938256f, 0.04063390f, 0.00769778f, 0.06791953f, -0.01920747f, 0.02340667f, -0.00664746f, 
    0.12160517f, -0.05414417f, 0.03530123f, -0.05096899f, -0.28008857f, 0.29626560f, -0.30686694f, -0.15923746f, 
    0.01140403f, -0.01590630f, 0.06897303f, 0.11295383f, -0.09507499f, -0.11230459f, -0.06217572f, 0.08596809f, 
    -0.05687499f, -0.19195318f, -0.04083805f, -0.03962094f, -0.00095480f, 0.07607307f, 0.12054864f, -0.02683587f, 
    -0.49112540f, -0.00086045f, -0.09445554f, 0.31698647f, -0.04386198f, 0.02761302f, -0.04803941f, 0.01965634f, 
    -0.03314289f, 0.06264278f, 0.02201736f, -0.04878625f, -0.07872120f, 0.09656540f, -0.11333840f, 0.01033424f, 
    -0.04501137f, 0.04322584f, -0.17970456f, -0.08526517f, -0.65282917f, 0.02811052f, 0.01876248f, -0.20974606f, 
    -0.04263189f, -0.16232663f, 0.06144818f, 0.21680735f, -0.01173569f, -0.03011321f, 0.04672984f, -0.05575486f, 
    0.13754098f, -0.18349731f, -0.09069802f, -0.09905109f, -0.05219622f, -0.17742822f, -0.03033172f, 0.20021139f, 
    0.11969263f, 0.10205068f, 0.09278951f, 0.03009750f, 0.04342485f, -0.03419935f, 0.03422844f, -0.09533649f, 
    -0.13988927f, 0.08439285f, 0.02387259f, -0.05247309f, -0.02163894f, 0.01040103f, -0.08511014f, 0.06854551f, 
    0.02898255f, 0.00864910f, 0.12425694f, 0.04963869f, -0.21261360f, 0.19074640f, -0.32385093f, -0.15954860f, 
    0.00683261f, 0.10478976f, 0.14003950f, 0.01708615f, -0.02718791f, -0.11128783f, 0.07512984f, -0.05373561f, 
    0.00825146f, -0.12773067f, 0.03385947f, -0.00056657f, 0.03226444f, -0.05950291f, 0.03436255f, -0.04453580f, 
    -0.23744072f, 0.04810963f, 0.19058926f, 0.11400929f, -0.13612832f, 0.01264268f, 0.04621296f, -0.04611531f, 
    -0.09559841f, -0.04981986f, 0.04468510f, -0.01304669f, -0.04558066f, -0.09235813f, -0.01574943f, 0.09197015f, 
    -0.02581915f, 0.07561884f, 0.02262347f, 0.01973944f, 0.04805862f, 0.10116889f, 0.26785874f, 0.05253307f, 
    -0.25270057f, -0.03424920f, -0.02128000f, 0.00163368f, -0.17917238f, -0.06956191f, 0.08012073f, -0.10612031f, 
    -0.01705937f, -0.11869877f, -0.12540446f, 0.09633473f, -0.09173591f, 0.10540991f, -0.00368799f, 0.01127582f, 
    -0.06397264f, 0.01897926f, 0.09771511f, 0.11822718f, -0.42381689f, 0.00804649f, 0.00871749f, -0.01235586f, 
    0.01802905f, 0.04263812f, -0.00800119f, 0.02601382f, 0.05022551f, -0.08179583f, -0.02516661f, -0.00231653f, 
    -0.08055992f, 0.07422433f, 0.07869636f, 0.06023150f, 0.01140935f, 0.15878110f, 0.06566971f, 0.12444825f, 
    0.06451467f, 0.02491608f, 0.02569536f, -0.08440273f, -0.01370081f, -0.12275131f, 0.02560775f, -0.01623654f, 
    0.02813613f, -0.04013975f, 0.23350720f, -0.28620839f, 0.10283632f, -0.10854659f, -0.05114593f, -0.15520871f, 
    -0.58544600f, -0.42912254f, -0.22249763f, -0.06143532f, -0.00577719f, 0.08176609f, 0.08050039f, -0.03821650f, 
    -0.03912366f, -0.14343254f, 0.00758379f, 0.08167947f, 0.01737552f, 0.03810449f, -0.06723171f, 0.07067376f, 
    0.08456222f, 0.09950767f, -0.16500239f, -0.00404633f, -0.12082273f, 0.21309312f, 0.05117205f, 0.04794295f, 
    -0.04169906f, 0.07102848f, -0.00067677f, 0.06902735f, -0.09398662f, 0.05478784f, 0.15238822f, 0.05581376f, 
    -0.15025373f, 0.06346296f, -0.09699166f, 0.05986718f, -0.02614123f, 0.06276733f, -0.15220235f, -0.07465311f, 
    -0.03872386f, -0.07093041f, -0.13470633f, -0.13781001f, -0.04543079f, 0.06112011f, -0.06005803f, -0.01500278f, 
    0.07713185f, 0.14895867f, 0.15083469f, 0.18384996f, 0.09035713f, -0.12372158f, -0.06450869f, 0.05907510f, 
    -0.12661187f, -0.09235851f, 0.09822096f, -0.04277482f, 0.00377758f, -0.12161062f, 0.06573442f, -0.11992896f, 
    0.27388355f, -0.06313100f, -0.06698791f, -0.10605699f, -0.00966216f, -0.01897644f, -0.14031641f, 0.07774032f, 
    -0.15405405f, 0.12000545f, 0.05093031f, 0.03793273f, -0.06934861f, 0.05375021f, -0.32870045f, 0.13919616f, 
    -0.21267217f, -0.06497399f, -0.00509154f, 0.03591154f, -0.06137943f, -0.13089788f, 0.18740955f, 0.08538806f, 
    -0.05170600f, 0.12132159f, -0.11613806f, 0.04322667f, -0.06151842f, 0.03392224f, -0.11687132f, -0.04569178f, 
    -0.06101953f, -0.05633353f, 0.10645710f, -0.08007247f, 0.12526622f, 0.03504482f, -0.09423463f, 0.17343380f, 
    -0.03384433f, 0.00597823f, 0.02013965f, 0.09071252f, -0.03066231f, 0.03969609f, -0.02218100f, -0.18527567f, 
    -0.03331263f, 0.02679091f, 0.13459073f, 0.03040797f, 0.00627068f, 0.09116244f, 0.08488337f, 0.01018243f, 
    -0.05937194f, 0.01147999f, -0.19242568f, -0.01812908f, -0.03698423f, 0.10148544f, 0.09343062f, -0.01826529f, 
    -0.06247235f, 0.13313572f, -0.07814319f, 0.32374519f, 0.13345571f, -0.08250809f, 0.00225404f, -0.18529512f, 
    0.00280729f, -0.18345545f, -0.07821255f, -0.14854345f, -0.14228347f, 0.01996341f, -0.17599639f, 0.10497291f, 
    0.11259287f, 0.10406178f, -0.09456689f, -0.09377787f, 0.01030853f, 0.17260997f, -0.04103857f, 0.19494434f, 
    0.13072839f, 0.02817025f, 0.12598632f, -0.10812218f, 0.02150115f, 0.05293990f, -0.00264633f, -0.18014438f, 
    0.33316666f, 0.00999688f, 0.08616451f, -0.36174372f, 0.28735059f, -0.02863419f, -0.01269928f, -0.01118007f, 
    -0.00413342f, 0.09867917f, -0.01462711f, -0.03358500f, 0.15217203f, -0.10086002f, -0.05408771f, -0.09694238f, 
    0.04243118f, -0.01135237f, 0.10338034f, 0.08121704f, -0.03408467f, 0.06632534f, -0.07939222f, -0.04155099f, 
    -0.03541033f, 0.12229798f, 0.00417109f, 0.05213314f, 0.02509258f, -0.09753527f, 0.04074736f, -0.05612136f, 
    -0.06255229f, 0.01452431f, -0.14455979f, -0.02491499f, -0.06406369f, 0.12189107f, 0.01000527f, 0.00019857f, 
    0.21199949f, 0.11552752f, -0.01047913f, -0.04606494f, 0.21331576f, -0.03886996f, 0.04987058f, -0.04200381f, 
    -0.09083610f, 0.08447037f, -0.09754860f, -0.02018468f, 0.11073675f, 0.07159112f, 0.04508574f, 0.15526906f, 
    -0.01624612f, 0.12388375f, 0.13436943f, 0.02976038f, -0.24360307f, 0.32720634f, -0.00363940f, 0.20145941f, 
    -0.32204592f, -0.15717490f, -0.05605294f, 0.06360627f, 0.08665255f, -0.02175939f, 0.07564486f, -0.04230630f, 
    0.04316777f, -0.04069881f, -0.00892557f, 0.02085023f, -0.03993786f, 0.01385361f, -0.19670594f, 0.12074067f, 
    -0.20557722f, -0.33600116f, -0.05828631f, -0.22755419f, 0.06255108f, 0.02665132f, 0.02481743f, 0.05782504f, 
    -0.05917330f, -0.07054701f, -0.12181852f, -0.02414573f, 0.14152977f, 0.05972761f, 0.08958090f, -0.00808601f, 
    -0.12092286f, -0.07177760f, -0.01036275f, 0.12167954f, 0.04094404f, -0.11563249f, -0.11258015f, -0.23997533f, 
    -0.13244662f, -0.07618699f, 0.07039380f, 0.04695378f, -0.09561575f, -0.02788645f, 0.07265185f, -0.08361642f, 
    -0.05880613f, -0.10014108f, -0.03257608f, -0.11120269f, -0.13476144f, 0.00265519f, 0.19024526f, -0.02979670f, 
    -0.20010637f, 0.36272520f, 0.09355033f, -0.07966322f, -0.34775925f, 0.10767532f, -0.04486768f, 0.10154256f, 
    -0.00994909f, 0.01398338f, 0.03814957f, 0.03101334f, -0.21624038f, -0.03320069f, -0.08031094f, 0.04999532f, 
    -0.03277848f, -0.12737350f, 0.16228205f, 0.07697990f, 0.00487435f, -0.17331876f, -0.11070868f, -0.11537421f, 
    0.11670787f, 0.05691552f, -0.02918809f, -0.03471819f, -0.05795741f, -0.01206428f, 0.03322639f, -0.10040966f, 
    -0.00646089f, 0.01182439f, -0.08413666f, 0.06968021f, 0.04910761f, -0.03944397f, 0.07684521f, 0.08156313f, 
    -0.40869737f, 0.09130447f, 0.04266562f, 0.26084539f, 0.00776930f, -0.07815563f, -0.09338102f, -0.09555668f, 
    0.01053220f, -0.01592348f, -0.20506430f, 0.01497353f, 0.13644645f, 0.09271032f, -0.08722032f, -0.05743331f, 
    0.17527427f, -0.12383509f, -0.04609708f, -0.32396418f, 0.35610670f, -0.26976568f, -0.08970049f, 0.16481450f, 
    -0.12500025f, -0.00346753f, 0.13519958f, 0.04398616f, -0.08093562f, -0.04177739f, 0.11926011f, -0.00400380f, 
    0.14536273f, -0.00803773f, 0.00528194f, -0.13852383f, 0.02409396f, 0.09230728f, -0.06507868f, 0.04838760f, 
    -0.01896949f, -0.20953541f, 0.13127400f, 0.05394030f, -0.03663930f, 0.21152201f, -0.05459579f, 0.18075465f, 
    -0.07319405f, -0.07456313f, -0.09285507f, 0.08434448f, 0.04340981f, 0.09740958f, -0.10502493f, 0.06157620f, 
    0.05509387f, 0.16045053f, 0.21711165f, -0.12517948f, -0.00311559f, -0.12386020f, -0.05441371f, 0.01098085f, 
    -0.10113017f, -0.01597312f, -0.07278173f, 0.09148418f, -0.06300304f, 0.01597309f, 0.09734888f, -0.02435231f, 
    0.11185563f, -0.04874455f, 0.02797197f, 0.10585071f, -0.00883433f, 0.01280137f, 0.10382973f, -0.06369790f, 
    0.38703090f, -0.32898059f, 0.01207772f, 0.13909021f, 0.20969914f, 0.05106899f, -0.04531293f, 0.14475922f, 
    0.00397422f, 0.07672606f, -0.06622519f, -0.01550530f, -0.15951519f, -0.02727446f, 0.03654132f, -0.03684031f, 
    0.09644176f, 0.10274877f, -0.02886334f, -0.01462661f, -0.02975040f, 0.01206209f, -0.05580505f, -0.19608431f, 
    0.00246947f, 0.09515742f, -0.02753584f, -0.03247079f, -0.06283063f, 0.05810416f, -0.11641957f, -0.04703023f, 
    -0.10793188f, -0.11589906f, -0.26479596f, 0.07971507f, -0.05824790f, -0.01244606f, -0.01516133f, 0.03887884f, 
    0.20048882f, 0.07579578f, -0.14978668f, -0.13553488f, 0.01221196f, -0.02195054f, 0.07589357f, -0.07669357f, 
    -0.02082044f, -0.10110636f, 0.00912273f, -0.00804796f, -0.11337076f, -0.04021343f, 0.11386469f, -0.11978474f, 
    -0.09770927f, 0.04880128f, -0.03741014f, 0.18246581f, -0.08970007f, -0.46422324f, -0.00277079f, -0.44197991f, 
    0.06606504f, -0.09407236f, 0.01182383f, -0.00967659f, 0.03447977f, -0.04767289f, -0.04523852f, 0.01824038f, 
    -0.05610365f, 0.12470601f, 0.15087129f, 0.01736848f, -0.05884732f, -0.03781579f, -0.13865176f, -0.04884169f, 
    -0.17583981f, -0.48558506f, 0.16412355f, 0.17787485f, 0.00968925f, 0.12188420f, 0.08582431f, 0.09570265f, 
    -0.01991478f, -0.03246435f, -0.06603200f, 0.00025236f, -0.07484750f, -0.00938135f, 0.09301763f, -0.05648115f, 
    0.05751733f, 0.08695160f, 0.19623683f, 0.03457013f, 0.03624064f, -0.03478555f, -0.03144766f, 0.16249479f, 
    0.24370007f, -0.07331222f, 0.09485660f, -0.09590302f, 0.04738381f, -0.05979393f, -0.07733791f, 0.03484484f, 
    -0.15057345f, 0.11871649f, 0.09627600f, -0.01329946f, 0.06228290f, 0.12978321f, -0.08657744f, 0.06541851f, 
    -0.56209058f, 0.18065187f, -0.15371534f, 0.37258857f, -0.11445778f, -0.01036697f, -0.01209401f, 0.09776546f, 
    0.13600859f, -0.03056000f, -0.00591675f, -0.04153904f, 0.02828150f, -0.04988106f, -0.07155861f, 0.00968532f, 
    -0.06891502f, -0.03768434f, -0.14356959f, -0.09285522f, 0.27245334f, -0.23394421f, -0.17959520f, -0.22930661f, 
    0.01889356f, -0.07301932f, 0.07702880f, -0.09871878f, -0.00917971f, -0.08253525f, 0.11107990f, 0.09255573f, 
    0.02195664f, 0.11693333f, -0.01160893f, 0.06477457f, -0.06484347f, -0.05407833f, -0.13597244f, 0.12112068f, 
    0.15900193f, -0.53222436f, -0.08508061f, 0.15335725f, 0.20217775f, -0.05041314f, 0.09391710f, 0.03121540f, 
    0.00830165f, 0.10096961f, -0.07413071f, 0.01058862f, 0.10844111f, 0.08631720f, 0.06590797f, -0.10070206f, 
    0.08687835f, -0.13718960f, -0.09458752f, -0.10278260f, 0.22598834f, -0.08499670f, -0.09215029f, 0.23519182f, 
    -0.37095347f, -0.11528608f, 0.05189927f, 0.04550798f, -0.01079249f, 0.02887361f, -0.05413916f, -0.05398763f, 
    -0.01892569f, 0.09735493f, 0.15767406f, 0.14873707f, 0.01754132f, -0.09329829f, -0.16536514f, -0.08794301f, 
    -0.19375743f, 0.43062216f, 0.03646166f, 0.02889396f, -0.20192985f, -0.03576497f, -0.14627081f, 0.08388918f, 
    -0.02430360f, 0.05862221f, 0.06638786f, 0.01143995f, 0.01581946f, -0.04534882f, 0.01515146f, -0.00704914f, 
    -0.04462301f, -0.15148097f, -0.03079105f, -0.04954553f, 0.11978199f, -0.03679315f, -0.05500552f, -0.32617348f, 
    0.07686979f, 0.07983386f, 0.05208382f, 0.06206821f, -0.01804334f, 0.08686227f, -0.09929460f, 0.05149503f, 
    0.11212537f, -0.02458314f, -0.02721294f, 0.11185362f, -0.05728681f, -0.02815088f, 0.06169233f, 0.09180351f, 
    -0.29389748f, -0.08901916f, 0.03809322f, -0.37541622f, 0.05624786f, -0.13486615f, 0.03124017f, 0.07341670f, 
    -0.07300452f, 0.06590641f, -0.02506981f, 0.00347634f, 0.01930000f, 0.08372160f, -0.01857394f, -0.12377835f, 
    -0.10168216f, -0.02468156f, 0.07301217f, -0.00403089f, -0.16811289f, -0.15308572f, 0.03160444f, 0.18607539f, 
    0.05803349f, -0.00642620f, -0.07109202f, -0.09985481f, 0.01784661f, -0.04727820f, 0.01307541f, 0.07885395f, 
    0.09815386f, 0.00549852f, 0.13576294f, -0.08940119f, -0.03143934f, 0.01408723f, 0.11313525f, -0.00856480f, 
    -0.13761398f, -0.10016997f, -0.16570914f, -0.33395591f, 0.20933321f, -0.07626823f, 0.02855414f, 0.09684096f, 
    0.02385722f, -0.08344618f, -0.05930040f, -0.11730802f, 0.02087897f, 0.08542909f, 0.03241488f, -0.06936094f, 
    0.10201590f, 0.14225483f, 0.04617029f, 0.01020251f, -0.14354266f, 0.21306258f, -0.09978073f, 0.05721886f, 
    0.02302323f, 0.14961387f, 0.03707043f, -0.06391723f, -0.12660128f, -0.11390628f, -0.01696679f, -0.02796130f, 
    0.06290194f, -0.00630988f, 0.08719318f, -0.12386470f, 0.14043483f, 0.09704714f, 0.03665815f, 0.00848225f, 
    0.33663547f, -0.06420661f, -0.07738639f, 0.21781985f, 0.05598724f, -0.04815613f, 0.00252046f, -0.02809733f, 
    -0.03252042f, -0.17043911f, 0.01274100f, -0.10180505f, -0.06750771f, 0.07592053f, -0.00395453f, -0.04579438f, 
    -0.04662343f, 0.07163861f, -0.10502044f, 0.05954161f, -0.24336696f, 0.37813249f, -0.00626518f, 0.17044102f, 
    -0.33028147f, 0.00568159f, 0.05965606f, -0.04814437f, 0.07676044f, 0.06426038f, -0.02694396f, 0.13329296f, 
    0.03037732f, -0.04795803f, -0.09233817f, -0.04583473f, 0.00295775f, 0.10136359f, 0.01470886f, -0.06823955f, 
    -0.09509993f, -0.06815713f, -0.06420293f, -0.18643253f, 0.36041954f, -0.08960044f, 0.06580678f, -0.03399069f, 
    -0.22553958f, -0.24604894f, -0.05212802f, -0.09127899f, 0.00746203f, -0.01052490f, 0.12903561f, 0.10827595f, 
    0.06686419f, 0.09757369f, 0.14962259f, 0.07689400f, -0.03860695f, 0.11576612f, -0.25765419f, -0.39494672f, 
    0.10368804f, -0.03184698f, -0.03606375f, 0.06308986f, -0.07848408f, -0.02750945f, -0.02095001f, -0.15040278f, 
    -0.21112956f, -0.05214583f, -0.04602985f, 0.06721240f, -0.16548309f, 0.14855111f, 0.04452668f, 0.09779558f, 
    0.18240301f, 0.16501249f, 0.25263354f, -0.02539295f, 0.19196036f, -0.08022834f, 0.13980585f, -0.12840861f, 
    -0.05618761f, -0.03785048f, -0.10930134f, 0.11922719f, -0.06218629f, -0.00973669f, -0.04466794f, -0.02685133f, 
    -0.05683701f, 0.07641839f, 0.05508042f, -0.06541922f, 0.05092257f, -0.11708341f, -0.04668147f, -0.03007028f, 
    0.03802755f, -0.03438338f, -0.00461091f, -0.04649329f, -0.12949540f, -0.00961963f, -0.08347332f, 0.04530777f, 
    -0.04121885f, -0.09074088f, -0.02297219f, -0.13128665f, -0.04465584f, -0.01668582f, 0.02471655f, 0.07858688f, 
    0.14879845f, 0.35787699f, -0.21464969f, 0.04332100f, 0.27582589f, -0.31523094f, -0.01475994f, -0.10745888f, 
    -0.06985822f, -0.07782523f, -0.15115266f, -0.00206876f, -0.01064928f, -0.01105321f, -0.05159715f, 0.08794226f, 
    0.05488646f, 0.02959779f, -0.12847999f, 0.01805199f, -0.19833134f, -0.03164433f, -0.16444476f, -0.10987156f, 
    -0.17691003f, 0.01784646f, -0.03480348f, 0.03106610f, -0.02698928f, -0.15997109f, -0.03584691f, 0.00746489f, 
    -0.09646200f, 0.02909107f, -0.09908698f, -0.00995472f, -0.10161432f, -0.03222072f, 0.04183672f, -0.01688164f, 
    0.15926361f, 0.00250416f, 0.23166464f, 0.03202767f, 0.09242186f, 0.08092759f, 0.07845869f, -0.04605128f, 
    -0.02219119f, -0.03842594f, -0.05478179f, 0.04516076f, 0.02918104f, -0.00252653f, -0.13194714f, 0.03313326f, 
    -0.05326708f, 0.03722940f, 0.02163444f, 0.01247601f, 0.11748064f, -0.20433666f, 0.02530303f, 0.02619020f, 
    0.10885103f, 0.06216434f, -0.03391044f, -0.01295221f, -0.15344213f, -0.04708248f, -0.02384740f, 0.00366206f, 
    -0.07223917f, -0.04110685f, -0.06115068f, -0.08800142f, -0.01132825f, -0.01986342f, 0.07165420f, -0.04209497f, 
    -0.11635276f, -0.05399416f, -0.29131329f, -0.07011125f, 0.10601058f, -0.03654122f, -0.18638617f, -0.03482891f, 
    -0.08860200f, -0.13367642f, -0.10699618f, 0.09078399f, -0.02263639f, -0.04040389f, -0.05118026f, -0.08665526f, 
    -0.02445641f, -0.11135429f, -0.02114688f, 0.06795222f, 0.11708902f, 0.12848216f, 0.13262673f, -0.04832506f, 
    0.22188638f, 0.01413401f, 0.12561630f, 0.00349706f, 0.07636061f, -0.01075071f, -0.06877158f, -0.04158967f, 
    -0.05180271f, -0.09453879f, -0.00570038f, 0.03208204f, -0.04978152f, -0.02051596f, 0.00077150f, -0.05568977f, 
    -0.28587791f, -0.17293213f, -0.07382516f, -0.10281693f, -0.15350477f, -0.09650692f, 0.02034780f, 0.04905074f, 
    -0.02491630f, -0.13646434f, -0.04342135f, -0.03691015f, 0.00839836f, 0.03288209f, -0.10733622f, 0.00951952f, 
    0.06992773f, -0.01736706f, 0.03225445f, 0.00581353f, 0.25656351f, 0.14057389f, 0.21413691f, -0.06665713f, 
    0.10424624f, 0.08005388f, 0.09125303f, 0.00640630f, 0.01904454f, -0.04798657f, -0.01853085f, 0.06900706f, 
    0.00025087f, 0.00699541f, 0.01172455f, -0.02312313f, 0.00686962f, 0.04950748f, 0.00503357f, -0.00516081f, 
    0.17542613f, -0.46192205f, 0.15312143f, -0.02418533f, -0.25058430f, 0.17171052f, -0.08239604f, -0.04189820f, 
    -0.08721252f, -0.00069763f, -0.01515169f, -0.08046311f, -0.03701532f, -0.02697773f, -0.14415100f, 0.04714365f, 
    0.08789452f, 0.01743037f, -0.08158281f, -0.09736133f, 0.16048998f, -0.25251833f, 0.07531361f, 0.01531361f, 
    -0.05064897f, 0.15063770f, -0.06281037f, -0.01267569f, -0.06991758f, 0.02460099f, 0.02860774f, -0.02072938f, 
    -0.01410457f, -0.09449472f, -0.11582953f, -0.02077819f, 0.09268228f, -0.02680069f, -0.03910470f, -0.08394603f, 
    0.22404818f, -0.21617277f, 0.08768320f, 0.06258380f, -0.23004135f, 0.12184109f, -0.09157127f, -0.03010236f, 
    -0.08769842f, 0.03129356f, -0.04703123f, 0.10250539f, 0.01929496f, -0.05227252f, -0.08182532f, 0.04057779f, 
    0.08139437f, -0.01673392f, -0.06082825f, 0.00902047f, -0.11234888f, -0.12640698f, -0.07875019f, -0.01369565f, 
    0.07882190f, 0.06492327f, -0.19451398f, -0.18588416f, -0.02783618f, -0.01729857f, 0.01035371f, 0.03312317f, 
    0.07267444f, 0.00930191f, -0.10290687f, 0.01173126f, 0.00618164f, 0.04442750f, -0.07390136f, 0.09974601f, 
    -0.11958677f, 0.22858839f, 0.22212011f, -0.05218754f, 0.13530940f, -0.09062302f, 0.06758202f, -0.03108060f, 
    -0.01416566f, -0.00835227f, -0.03168427f, 0.05624594f, -0.03439825f, 0.01555664f, -0.05941829f, -0.10087756f, 
    -0.06010220f, 0.01686333f, 0.02090262f, -0.05675482f, 0.14203724f, -0.06471705f, 0.27281764f, 0.13607326f, 
    0.18511717f, -0.02647340f, 0.18638964f, -0.03735373f, 0.09703014f, -0.08421613f, 0.03155562f, 0.07630394f, 
    -0.05995731f, 0.01914748f, -0.04973976f, -0.03957873f, 0.05281147f, 0.07090155f, -0.03906677f, -0.08123807f, 
    0.10637914f, -0.11845843f, -0.03727238f, 0.07876357f, 0.34230193f, -0.01782564f, -0.06037519f, -0.09615137f, 
    0.13149215f, 0.03136754f, -0.05266873f, -0.00368243f, -0.10910355f, -0.07026130f, -0.07134224f, 0.01050286f, 
    -0.14699444f, 0.03329120f, -0.04684016f, 0.01471093f, -0.27854550f, 0.08205473f, 0.09711187f, 0.09388570f, 
    -0.01881206f, 0.10746602f, -0.04895810f, 0.01509505f, 0.15349601f, -0.01984263f, -0.05332641f, 0.08102121f, 
    0.08359320f, 0.00093645f, -0.13333264f, 0.10413281f, 0.10957552f, 0.02425716f, 0.03576972f, 0.03422807f, 
    -0.20909585f, 0.11182963f, 0.06606564f, -0.08650895f, -0.13569507f, -0.04748992f, -0.01317648f, -0.07232120f, 
    0.04989639f, -0.04478592f, -0.00768389f, 0.05592114f, -0.02983178f, -0.09949444f, -0.03350881f, 0.00643695f, 
    0.00047480f, -0.02743269f, -0.03990067f, -0.03545342f, -0.10867387f, 0.24657373f, 0.24493761f, 0.05886731f, 
    0.17488271f, 0.07242519f, 0.18025887f, 0.06127691f, 0.03316765f, -0.08581920f, -0.04234744f, -0.00006806f, 
    0.01401274f, -0.01671931f, -0.10567529f, -0.02703198f, 0.01757798f, -0.01301700f, 0.07113898f, -0.01976849f, 
    0.05716157f, -0.13770933f, -0.10458770f, -0.10239704f, 0.05266856f, -0.04372782f, -0.10182109f, -0.12276131f, 
    -0.05681503f, -0.13842055f, -0.04582398f, -0.06082195f, -0.04143698f, -0.05354744f, -0.08522386f, -0.01793999f, 
    -0.00861862f, -0.02627982f, 0.00254837f, -0.06008646f, 0.22360668f, -0.02514141f, -0.10286345f, -0.17174236f, 
    -0.17606784f, -0.12032249f, -0.05824178f, -0.01975457f, -0.07064551f, -0.06276133f, 0.04507411f, 0.04599253f, 
    -0.05745992f, 0.12451377f, -0.06420255f, 0.04548508f, -0.13303493f, -0.02830205f, -0.06409956f, 0.01545835f, 
    -0.13196954f, -0.22224890f, -0.16185273f, -0.22771232f, -0.31451133f, 0.04119164f, -0.10664003f, -0.03279634f, 
    -0.08127377f, -0.11453351f, -0.05342416f, 0.01369009f, -0.08801426f, 0.00337297f, -0.14925855f, -0.08385445f, 
    0.00484784f, -0.01813954f, 0.02229208f, 0.05374502f, 0.10230213f, 0.04095541f, 0.07480539f, 0.16682200f, 
    0.23372880f, 0.11663230f, 0.04929595f, -0.00646483f, -0.01683511f, -0.00469719f, -0.03480770f, -0.02960518f, 
    0.02513114f, -0.05308397f, 0.02368852f, 0.02292802f, -0.07051066f, -0.00041454f, -0.01317684f, 0.03199019f, 
    -0.03035021f, 0.00937232f, 0.13407481f, 0.05108755f, 0.16505449f, 0.04491078f, 0.06616833f, -0.06689978f, 
    -0.05859701f, -0.08673375f, -0.00474452f, 0.07719731f, -0.00440512f, -0.04218717f, -0.00850982f, 0.00199248f, 
    0.01503180f, 0.00766412f, 0.08391342f, -0.14749393f, 0.02395822f, -0.12049141f, 0.08149623f, 0.04018973f, 
    0.02014701f, 0.05327170f, -0.04571488f, -0.05430744f, 0.01738145f, -0.01066468f, -0.03324689f, 0.06136866f, 
    0.01424121f, 0.03118784f, -0.11122818f, 0.06826442f, -0.13776724f, -0.03803971f, -0.01402588f, -0.06656279f, 
    0.20782842f, 0.21402834f, 0.04035598f, 0.12635799f, 0.07609553f, -0.04106611f, 0.06404350f, -0.04220472f, 
    0.03020630f, -0.11695150f, -0.23997745f, 0.03582640f, -0.03950707f, -0.10263743f, -0.06596719f, 0.02677003f, 
    -0.02246222f, 0.00979656f, -0.08399776f, -0.00880610f, 0.09193206f, 0.13728157f, 0.19820806f, -0.02995395f, 
    0.13127315f, -0.04775445f, 0.01887283f, -0.02806958f, -0.09471117f, 0.02214309f, 0.07729483f, -0.01743774f, 
    0.03165124f, -0.01246850f, -0.04331281f, -0.01339660f, -0.06169752f, -0.02485268f, 0.13300487f, 0.00882012f, 
    -0.21955800f, 0.08675503f, 0.02054085f, 0.06477912f, -0.04879136f, 0.00932703f, -0.21821475f, 0.00240218f, 
    0.03246297f, -0.00376410f, -0.06238387f, 0.08277306f, 0.00851152f, -0.06014945f, 0.04028615f, -0.09126769f, 
    -0.03724695f, 0.10295563f, -0.00298256f, -0.11860982f, -0.54716021f, -0.00639929f, -0.35006556f, -0.22291732f, 
    -0.09226012f, 0.02475730f, -0.09078602f, -0.09606825f, 0.05838574f, -0.06757691f, -0.16324684f, 0.09936297f, 
    0.08474358f, -0.02351213f, 0.07929394f, -0.03374938f, -0.08243617f, 0.03733962f, 0.04403033f, 0.07550836f, 
    -0.06565921f, 0.09593502f, 0.12250721f, 0.00890117f, 0.21663745f, 0.15473020f, -0.00825035f, 0.03972374f, 
    0.02325889f, -0.06782823f, 0.03545095f, 0.06812586f, -0.03988685f, 0.00959025f, -0.07264342f, 0.02853161f, 
    0.03427907f, 0.03787635f, 0.10837165f, -0.06358756f, 0.12503079f, 0.07251563f, 0.10588928f, 0.06487441f, 
    0.15637253f, -0.03915884f, 0.08309492f, -0.08661673f, -0.03367224f, -0.12448072f, -0.06556973f, -0.01793692f, 
    -0.14266889f, -0.09727044f, -0.05128874f, -0.05399286f, 0.03591800f, -0.02044665f, -0.08660441f, -0.10478004f, 
    -0.26360694f, 0.31868908f, 0.07261299f, -0.12657352f, -0.03493127f, -0.01219505f, 0.02622180f, -0.04331833f, 
    0.03904070f, 0.05157745f, 0.10218061f, -0.02453163f, 0.00247223f, 0.03010057f, 0.06245556f, -0.06280991f, 
    0.02790512f, -0.04995276f, 0.05338010f, 0.13331072f, 0.12968788f, -0.08036590f, 0.01927599f, -0.17182967f, 
    -0.07003605f, 0.12511460f, -0.08862099f, 0.05898828f, -0.00612152f, -0.13867128f, -0.06586310f, -0.02876861f, 
    0.01725847f, 0.11065667f, -0.10141321f, 0.16333060f, -0.01996445f, -0.02543309f, -0.16648191f, -0.02775538f, 
    -0.23864828f, 0.18241908f, -0.15060180f, -0.32548168f, -0.25981927f, -0.02631799f, -0.01113444f, -0.14784403f, 
    -0.10557111f, -0.19046021f, 0.13961747f, 0.03746220f, -0.06464260f, 0.02776078f, -0.02081167f, -0.04243169f, 
    0.18825458f, -0.08808615f, 0.04929314f, 0.03343800f, 0.21468468f, 0.02740618f, -0.14625426f, 0.11534548f, 
    0.20111616f, 0.01277435f, 0.05018834f, -0.01172204f, -0.05485054f, 0.02067896f, 0.03467495f, -0.12183027f, 
    -0.01497837f, -0.02050927f, 0.05042411f, -0.01945899f, -0.01819315f, 0.04477582f, 0.12667893f, -0.02541013f, 
    -0.01639300f, -0.05354878f, 0.13807747f, 0.07822283f, 0.16984455f, -0.13928227f, -0.07155026f, 0.05584654f, 
    -0.09716076f, 0.11785715f, -0.02595797f, -0.00751395f, -0.11209819f, -0.00955752f, 0.02274490f, -0.01227937f, 
    -0.04306497f, -0.00291596f, 0.04246804f, 0.02439359f, -0.11749624f, -0.28555205f, 0.21764724f, -0.23782435f, 
    -0.03877435f, -0.04433853f, -0.08218518f, 0.05026811f, -0.08266142f, -0.15983523f, -0.01348240f, 0.07319276f, 
    0.05705176f, 0.01298881f, 0.00869271f, -0.03339453f, -0.03683887f, 0.07062506f, -0.32697073f, 0.12945986f, 
    -0.19873551f, -0.23930721f, -0.03491210f, -0.02017800f, 0.16185658f, 0.13517733f, 0.08532619f, -0.08260769f, 
    -0.03065002f, -0.04857039f, 0.07266697f, 0.07091891f, 0.04143199f, 0.00780076f, 0.02941384f, -0.13167730f, 
    0.06389129f, 0.14940384f, -0.02730604f, -0.16443202f, -0.23277181f, 0.27082831f, -0.06029603f, -0.26344603f, 
    -0.30465618f, 0.01445765f, -0.00463399f, -0.02332917f, 0.04494569f, -0.07263654f, 0.10393171f, -0.01024530f, 
    -0.06659348f, -0.06580252f, 0.03444406f, -0.11172204f, 0.06989062f, -0.08302731f, -0.09942093f, -0.04068744f, 
    0.29002136f, 0.06166626f, -0.19200732f, 0.14683288f, 0.13785456f, 0.11825371f, -0.00205962f, -0.01997372f, 
    -0.04743469f, 0.03829789f, 0.11456703f, 0.08641396f, -0.09529971f, -0.04930601f, -0.13784958f, -0.04198352f, 
    -0.11291454f, 0.04058033f, 0.05716966f, -0.04898755f, -0.00750926f, -0.38408917f, 0.03739600f, -0.06626908f, 
    -0.05395018f, -0.07383713f, 0.06102529f, 0.04181154f, -0.21576338f, 0.06293310f, -0.04772065f, 0.02222806f, 
    0.00261498f, 0.08113767f, 0.03594178f, 0.00417891f, -0.04365240f, -0.07895608f, 0.07696743f, 0.08596705f, 
    -0.01497730f, 0.08262156f, -0.22207971f, 0.04741818f, 0.03308735f, -0.01768102f, -0.11781666f, -0.08397961f, 
    -0.13393757f, -0.06195293f, -0.00964480f, -0.01074717f, -0.11059991f, 0.05171873f, 0.00556782f, 0.01206162f, 
    -0.01607274f, -0.07956372f, 0.12757990f, 0.01970679f, 0.01242562f, -0.23367164f, 0.09294999f, 0.05400951f, 
    0.15258232f, -0.02161302f, -0.00427287f, 0.00110810f, -0.07799386f, 0.00440481f, -0.02421931f, 0.04889420f, 
    -0.06764393f, 0.01790243f, 0.05341885f, 0.03137253f, -0.02495518f, 0.03306797f, -0.05787158f, 0.06205402f, 
    0.04828511f, -0.05266109f, -0.03301128f, 0.04538007f, 0.07145473f, 0.00114933f, 0.00818288f, -0.02770071f, 
    -0.07388318f, 0.09574538f, -0.07474198f, -0.06516414f, -0.00567417f, -0.11303610f, 0.03754566f, 0.02996993f, 
    -0.01262247f, -0.06464709f, 0.08817355f, 0.01830175f, -0.11077371f, 0.04401791f, -0.14128777f, -0.32686880f, 
    -0.14641960f, 0.11659029f, -0.23522833f, -0.01973349f, 0.15526265f, -0.18602912f, 0.14200659f, 0.07894816f, 
    0.09121147f, -0.04804459f, 0.00626485f, 0.04367894f, 0.03453621f, -0.05059447f, -0.08674496f, 0.06085480f, 
    -0.04253688f, -0.02851488f, 0.15219854f, 0.05003203f, -0.13660529f, -0.17266716f, 0.05346042f, 0.03500036f, 
    -0.00982869f, -0.00999719f, 0.05728773f, -0.01368853f, 0.01686275f, 0.09054773f, 0.06704255f, 0.03408703f, 
    -0.01958348f, -0.12721679f, 0.00711989f, 0.04059561f, -0.13230908f, -0.00979623f, 0.18843336f, -0.01052379f, 
    0.17390470f, -0.07503449f, -0.10096290f, 0.13117017f, -0.03136782f, -0.05988662f, -0.03879898f, -0.01072257f, 
    -0.21019889f, -0.03607215f, 0.05818529f, 0.01658094f, 0.06483579f, 0.01987025f, -0.02271755f, -0.03073104f, 
    -0.18204314f, 0.04231231f, 0.06720817f, -0.09599623f, 0.15898396f, -0.00049234f, -0.08514909f, -0.06558465f, 
    -0.17735393f, -0.14230260f, 0.00327775f, 0.00737636f, 0.04919436f, 0.09894234f, -0.02787019f, 0.05236128f, 
    0.00061353f, 0.11461290f, -0.27213308f, 0.07539070f, -0.05975056f, -0.02551702f, -0.07779814f, 0.05162504f, 
    -0.09369847f, -0.08437423f, -0.09927084f, -0.07823611f, -0.10693067f, 0.17680746f, 0.02935719f, -0.02287268f, 
    0.00927623f, -0.00023237f, -0.03241581f, 0.05202738f, 0.02805799f, -0.10897483f, 0.13735513f, -0.02866968f, 
    0.12387516f, 0.12527291f, -0.23167850f, 0.16577087f, 0.01866222f, 0.02354073f, 0.07170611f, -0.23050013f, 
    -0.01569956f, -0.00205881f, 0.04078887f, 0.08709379f, 0.01895762f, -0.16143364f, -0.05004440f, -0.07574999f, 
    -0.04224561f, -0.02663730f, 0.12406606f, -0.00355042f, -0.05324424f, -0.07674830f, 0.19313629f, 0.00122422f, 
    0.03477085f, -0.12082358f, -0.04400101f, 0.06378624f, -0.04466364f, 0.00548655f, 0.00979326f, -0.01760270f, 
    -0.10590325f, -0.00213008f, 0.05294041f, 0.01177798f, -0.02898955f, -0.09372100f, 0.06008139f, -0.00201736f, 
    0.11289823f, 0.11147029f, 0.09352852f, -0.03827521f, 0.16379766f, -0.06745340f, -0.04176298f, -0.08897983f, 
    -0.04743755f, -0.09741606f, 0.01626720f, -0.06248405f, 0.02814930f, -0.15306437f, -0.04714555f, 0.03285483f, 
    -0.11543430f, 0.07043060f, 0.09860559f, 0.09305412f, 0.24285907f, 0.27498901f, 0.08445160f, -0.00151035f, 
    0.21960081f, -0.00390928f, -0.02150003f, -0.15009591f, 0.00766418f, -0.08298224f, 0.10053400f, -0.04384018f, 
    0.02406825f, -0.18522048f, 0.01231858f, -0.05663150f, -0.02101822f, 0.07964773f, 0.07902685f, -0.08159333f, 
    0.13722120f, 0.00929304f, 0.12718636f, -0.08755935f, 0.15954044f, 0.05834083f, 0.09546228f, -0.15594931f, 
    0.01717584f, 0.03908486f, 0.02467516f, 0.02503178f, 0.06779731f, -0.07142996f, 0.03058795f, -0.08451004f, 
    0.01479068f, 0.06894040f, 0.00716708f, 0.00997358f, -0.23710294f, -0.29655445f, -0.00532583f, -0.20229314f, 
    -0.16648504f, 0.04219329f, -0.05956133f, 0.04275900f, -0.01450239f, -0.04698984f, 0.10156909f, 0.02788409f, 
    -0.00080187f, 0.05593449f, 0.09347104f, -0.01490827f, -0.01976340f, -0.00098067f, 0.00915644f, -0.03701503f, 
    -0.28744316f, -0.09436194f, 0.30775639f, -0.09412417f, 0.01292730f, -0.00786361f, 0.05080570f, 0.04412208f, 
    -0.06663391f, -0.04242259f, -0.03997759f, 0.05357166f, 0.12888400f, -0.00357712f, 0.00533001f, -0.00134887f, 
    0.03186293f, 0.05162135f, -0.14405400f, 0.04211296f, -0.01908817f, -0.00522375f, -0.03722499f, 0.15718727f, 
    0.10747475f, -0.04342156f, -0.06252034f, -0.09478304f, -0.10543105f, 0.07066733f, -0.05944699f, -0.00434904f, 
    -0.09906145f, 0.01472651f, 0.02616157f, 0.06597272f, -0.04052364f, 0.04984174f, 0.01125868f, 0.05520886f, 
    -0.22922578f, 0.10483665f, 0.22783384f, -0.18552312f, -0.18266717f, -0.03940753f, 0.03314547f, 0.04352521f, 
    0.03635861f, -0.15176836f, 0.11555440f, 0.05723717f, 0.00854769f, 0.02499964f, 0.06993393f, -0.19209059f, 
    0.04060293f, -0.09780423f, 0.10497104f, -0.13420269f, -0.19452645f, -0.25813034f, 0.00491605f, -0.22733445f, 
    -0.18942823f, 0.11244837f, -0.05212101f, -0.05937409f, 0.00860585f, -0.00834262f, 0.08691121f, 0.09999429f, 
    -0.17774297f, 0.13287498f, -0.00072206f, 0.16159391f, 0.06769726f, 0.05700437f, -0.32265377f, 0.01160588f, 
    -0.05491041f, 0.01176894f, -0.03059249f, -0.05238589f, -0.19348806f, -0.01814447f, -0.06103334f, -0.10561023f, 
    0.05830179f, -0.07988698f, 0.12498346f, 0.04995587f, 0.10936838f, 0.02176316f, 0.01398118f, 0.03547671f, 
    -0.00493448f, -0.06800400f, 0.06384482f, -0.01525906f, 0.01925218f, 0.06275494f, -0.22490782f, -0.01306892f, 
    0.03712618f, 0.17411338f, 0.08875252f, -0.05792482f, -0.00418075f, -0.08479986f, 0.10663796f, 0.01803708f, 
    0.02875288f, 0.05284102f, 0.08975308f, -0.16437036f, 0.04792161f, 0.08479702f, 0.06453151f, -0.04992047f, 
    -0.16894946f, -0.04253796f, -0.08150090f, -0.20710197f, -0.30599660f, 0.03676987f, -0.00486274f, -0.02836770f, 
    -0.06323741f, -0.07438011f, 0.06245597f, -0.03097663f, -0.01297653f, -0.05219955f, -0.01058565f, -0.14527854f, 
    -0.12689707f, -0.07618159f, -0.12899937f, -0.14150997f, -0.16046879f, 0.07402781f, 0.16263086f, -0.36710048f, 
    -0.20227209f, -0.05678832f, 0.01781215f, -0.11699165f, -0.02628555f, -0.06169561f, 0.04379827f, -0.00308489f, 
    0.04647879f, -0.00921414f, -0.00845305f, -0.00704261f, 0.03504752f, -0.12190590f, -0.11945798f, 0.04883458f, 
    -0.10295841f, -0.13488980f, -0.22837465f, 0.19867341f, -0.03491417f, 0.07133096f, 0.08690914f, -0.06843250f, 
    -0.09351206f, -0.06435163f, -0.04158604f, 0.00431720f, 0.00498612f, 0.08293692f, 0.21334837f, -0.03752923f, 
    -0.10875132f, -0.01435278f, -0.06916824f, -0.05407525f, 0.04673249f, 0.08970593f, 0.02996911f, -0.13060285f, 
    -0.07365154f, 0.05743742f, -0.03682248f, 0.00499358f, -0.16904631f, 0.04558350f, 0.02486047f, 0.00013041f, 
    0.10180730f, -0.09257918f, -0.02963749f, -0.02146715f, -0.07512357f, -0.08334428f, 0.16392146f, 0.10696946f, 
    -0.08706743f, -0.16554391f, -0.22632065f, 0.08428787f, -0.45692798f, 0.01770830f, 0.11446118f, -0.02843860f, 
    -0.02535037f, -0.01976394f, -0.27858382f, -0.08020401f, -0.10788845f, 0.03912059f, 0.14360233f, -0.05538360f, 
    -0.02584647f, 0.04794655f, 0.00465019f, 0.04444782f, -0.08747221f, 0.19055617f, 0.07950706f, -0.30479446f, 
    -0.05276604f, 0.11498604f, -0.00909340f, -0.05401632f, 0.00360769f, 0.02758507f, -0.17800817f, 0.18321535f, 
    0.03410671f, -0.07624116f, -0.02417950f, 0.11540292f, 0.02157237f, 0.02483268f, 0.11282509f, -0.01549979f, 
    0.05365131f, -0.20326576f, -0.00944665f, 0.17802013f, -0.10805812f, -0.01804229f, -0.01102688f, -0.06193226f, 
    0.14416283f, 0.11037110f, -0.06601466f, 0.14540289f, -0.06158561f, -0.02616773f, 0.04753463f, -0.08585028f, 
    0.06961833f, -0.02659483f, 0.04955140f, 0.02059180f, 0.05530083f, -0.12441141f, -0.03844970f, 0.05623158f, 
    0.01482498f, 0.02207006f, 0.02598349f, 0.02604295f, -0.10170454f, 0.06841910f, -0.01834922f, -0.00089303f, 
    0.01822656f, -0.14230053f, -0.02914826f, 0.14022088f, 0.02912771f, 0.08049078f, 0.07068960f, 0.03047199f, 
    0.13439654f, -0.21250327f, 0.18868034f, -0.21417974f, -0.39589113f, 0.00962567f, 0.00912025f, -0.03458907f, 
    -0.01402524f, 0.04250721f, -0.06005201f, 0.04706368f, 0.05949419f, -0.13576929f, -0.09538786f, -0.16318890f, 
    0.10832022f, 0.05398647f, 0.06660336f, -0.05204536f, -0.32060465f, 0.17424388f, -0.14117415f, 0.04350387f, 
    -0.21526252f, -0.13061486f, -0.03377767f, -0.04721405f, -0.07847893f, 0.13318457f, 0.00050176f, 0.05251449f, 
    0.00059815f, 0.08217889f, 0.08135750f, -0.03685656f, -0.04261649f, 0.09612828f, -0.01581807f, 0.03903228f, 
    -0.10175742f, 0.00244917f, -0.03814942f, 0.14535759f, -0.37492216f, 0.13404673f, 0.06204318f, 0.06781248f, 
    -0.11234584f, -0.12954861f, -0.05443377f, -0.04986760f, -0.01497059f, -0.03346188f, 0.13541381f, -0.02612713f, 
    -0.06723559f, -0.07908683f, 0.10166369f, -0.00000692f, 0.05571983f, -0.15526384f, 0.10951981f, 0.03846768f, 
    0.25154337f, -0.00294651f, 0.04200665f, -0.02973731f, -0.06219190f, 0.08125276f, -0.01371723f, -0.01551280f, 
    -0.11910855f, 0.05986030f, 0.01114604f, -0.11020774f, 0.00914775f, -0.04511168f, -0.07071908f, 0.03756449f, 
    0.33916441f, -0.68803006f, 0.24800389f, 0.08706640f, 0.04860248f, -0.07877675f, -0.03722393f, -0.07318576f, 
    0.05485161f, -0.02791984f, 0.11589418f, -0.11155856f, 0.01296623f, -0.17072231f, 0.12401158f, 0.02711041f, 
    0.00137384f, -0.09911938f, 0.01352282f, 0.14021054f, 0.06017258f, -0.27770418f, 0.10357522f, 0.13716474f, 
    -0.11911378f, 0.09076907f, 0.04199568f, -0.03674412f, -0.06061432f, 0.08020215f, -0.02565440f, -0.04902764f, 
    0.05566173f, 0.06590664f, 0.13879202f, 0.04779199f, 0.05046525f, -0.11585037f, -0.08669281f, -0.00832808f, 
    0.44201759f, -0.26933184f, 0.21144158f, -0.19637142f, 0.13987269f, 0.03492928f, 0.03656898f, 0.02234586f, 
    0.04042291f, -0.11596458f, 0.04145996f, -0.09675397f, -0.03598905f, 0.08710374f, 0.08981735f, 0.01480306f, 
    -0.09925016f, -0.01532309f, -0.09223273f, -0.01392634f, -0.10860149f, -0.01499815f, 0.09463554f, -0.26762956f, 
    -0.16980906f, -0.18383785f, 0.08257579f, 0.05617790f, 0.09688067f, 0.07564980f, 0.06975590f, -0.01729850f, 
    0.01129582f, -0.16167246f, -0.13352932f, -0.02888859f, 0.03688218f, 0.13819358f, 0.14425941f, -0.06117402f, 
    -0.35038745f, -0.14213212f, -0.20569812f, 0.17211840f, 0.20542704f, 0.04108912f, 0.00887873f, 0.01585672f, 
    -0.12773462f, 0.15700603f, 0.07624448f, 0.07333149f, 0.01203717f, -0.00349197f, -0.11571175f, -0.00919009f, 
    -0.08828192f, 0.05191973f, -0.02318097f, 0.04616715f, 0.28387651f, -0.00575122f, -0.03521428f, 0.04860039f, 
    -0.00362385f, 0.13167709f, -0.06015227f, -0.03225414f, -0.01266533f, 0.03475463f, -0.03336323f, -0.07396667f, 
    0.01435880f, 0.19620432f, 0.10945743f, 0.07789354f, -0.10381238f, -0.04233709f, 0.04219398f, 0.03426342f, 
    0.79935348f, 0.01294668f, -0.42181379f, -0.20092045f, 0.04832818f, -0.02202492f, -0.01763548f, 0.07606514f, 
    -0.05287445f, -0.19321856f, 0.00222483f, -0.06248597f, 0.04464826f, 0.00990140f, -0.03193485f, 0.05452623f, 
    0.09196392f, 0.00361234f, 0.04385614f, 0.00773384f, 0.11629806f, -0.45209247f, 0.02632746f, 0.18297353f, 
    0.17631821f, 0.00059713f, -0.01445708f, 0.09719732f, -0.02784285f, 0.02862894f, -0.00775893f, 0.05353327f, 
    -0.02536547f, 0.13701953f, -0.08376309f, -0.06127088f, -0.06326302f, 0.13995683f, -0.11818377f, -0.00022442f, 
    -0.21352445f, 0.06661925f, 0.23888923f, -0.05517467f, 0.00785455f, 0.10749762f, 0.01874562f, 0.06841585f, 
    -0.03302345f, -0.13605943f, 0.09550881f, 0.06104755f, -0.00120574f, -0.00992170f, 0.03699487f, 0.10026555f, 
    0.00273299f, 0.05767349f, -0.18367679f, 0.14153132f, -0.44126594f, -0.15470238f, -0.11875652f, 0.19688162f, 
    0.15813941f, 0.14292631f, -0.05423064f, 0.01138509f, -0.10348565f, 0.15678433f, -0.06151234f, -0.04821448f, 
    -0.02193600f, 0.03015609f, -0.03007150f, 0.05455581f, -0.20233758f, -0.00872123f, 0.05824525f, -0.12372211f, 
    0.24967772f, 0.12512988f, 0.07980345f, -0.12225454f, 0.00335662f, 0.16520657f, -0.01644048f, 0.00566574f, 
    -0.12154718f, 0.07250355f, 0.04337059f, 0.08559400f, 0.04150109f, 0.06562287f, -0.17148201f, -0.04934920f, 
    0.03460995f, -0.19524840f, -0.07460467f, -0.12178262f, -0.24677226f, -0.16156182f, 0.02346537f, -0.21214367f, 
    0.09896502f, 0.07022281f, 0.08810246f, -0.06156735f, -0.08992441f, -0.13524461f, 0.05161887f, -0.04103517f, 
    -0.03155362f, 0.10719691f, -0.12372442f, -0.01452095f, 0.05447471f, -0.15929839f, 0.02973731f, -0.08786711f, 
    0.18105352f, -0.32226524f, 0.09934954f, -0.11721189f, -0.32064447f, -0.02142739f, 0.12080075f, -0.08349364f, 
    0.05201662f, -0.08601538f, 0.00606515f, 0.01766620f, 0.01229783f, 0.00231449f, -0.09739887f, 0.02563480f, 
    0.04941385f, -0.10430925f, -0.17184974f, -0.10695203f, -0.16197933f, -0.18860170f, 0.06198999f, 0.00064245f, 
    0.20678264f, 0.04623451f, 0.01638095f, 0.05850622f, 0.10451511f, 0.09091522f, 0.00041230f, -0.04857245f, 
    -0.01613760f, -0.02687925f, -0.08490416f, 0.09334525f, 0.08200522f, 0.06362123f, 0.03074656f, -0.03917966f, 
    0.33708775f, -0.04907707f, -0.00425774f, 0.17469640f, 0.09546930f, -0.06219375f, -0.12310856f, -0.06209941f, 
    0.06116946f, 0.03927130f, -0.10539327f, 0.11821528f, 0.00725987f, -0.15251531f, 0.07538927f, -0.02168710f, 
    -0.04642909f, -0.09352889f, 0.05635268f, 0.01920660f, -0.02282287f, -0.38610876f, 0.00050333f, -0.00354435f, 
    -0.16400672f, -0.14199209f, 0.05164664f, 0.02653824f, 0.16603635f, -0.01546863f, -0.19228201f, 0.08602625f, 
    0.07202365f, -0.09851691f, -0.07301146f, 0.08811724f, 0.07390315f, -0.00003752f, -0.05622964f, 0.05452537f, 
    0.17316774f, 0.17119792f, 0.08700214f, -0.00509486f, 0.06407578f, 0.09299067f, -0.06418031f, -0.06486668f, 
    -0.00589252f, 0.03058127f, -0.08188745f, -0.03816154f, 0.02500779f, 0.03399691f, 0.13263044f, 0.10964563f, 
    -0.01009552f, 0.11544418f, -0.07181992f, 0.00054812f, 0.02163830f, -0.28794259f, 0.01867606f, 0.11377257f, 
    -0.03771683f, -0.11126839f, 0.01883429f, 0.03133903f, -0.11843643f, -0.00349171f, 0.23089109f, 0.11438828f, 
    0.08766847f, -0.22660841f, -0.16511963f, -0.11588799f, 0.08662409f, -0.15073162f, 0.18861297f, 0.00309830f, 
    -0.23885401f, 0.06459437f, 0.03631224f, -0.04873586f, -0.06478442f, -0.02645815f, 0.04709165f, 0.03847056f, 
    0.03535165f, -0.00209466f, 0.04842230f, -0.05010564f, 0.08432952f, -0.07950410f, -0.18358152f, -0.04155530f, 
    0.01083691f, 0.03100283f, -0.09914908f, 0.00632030f, -0.06690471f, 0.06210797f, 0.11995926f, -0.29156888f, 
    -0.41841751f, 0.01166563f, -0.01418846f, -0.03416905f, -0.05190069f, 0.03023889f, 0.06143081f, -0.08204836f, 
    -0.08561530f, -0.14884670f, 0.07784462f, -0.00100204f, 0.06169555f, -0.04588270f, -0.13334957f, -0.01705678f, 
    -0.18759124f, -0.21232428f, 0.02373097f, 0.23429365f, 0.15455227f, -0.11140703f, 0.00198206f, 0.14465681f, 
    -0.01497623f, -0.02943917f, 0.00776386f, -0.08795303f, -0.07395435f, 0.03608622f, -0.23423721f, 0.07733374f, 
    -0.00721499f, 0.06825936f, 0.01673617f, 0.05004871f, -0.06881239f, -0.08726281f, 0.09346020f, -0.12624831f, 
    -0.16768689f, -0.04801213f, 0.10033536f, 0.00938362f, -0.05820841f, 0.00719992f, 0.00793479f, 0.08374627f, 
    -0.00772782f, 0.03224759f, 0.09670568f, 0.07987152f, 0.03645608f, -0.06983000f, 0.03683375f, 0.00824104f, 
    -0.07340587f, -0.13510975f, -0.10284518f, -0.08166026f, 0.09708634f, -0.03244893f, -0.00377621f, -0.04102734f, 
    0.01995162f, -0.01530293f, 0.04178119f, -0.05296251f, 0.01460073f, -0.01508881f, -0.03310721f, 0.02836400f, 
    0.03226577f, -0.02779719f, -0.00024934f, 0.10753999f, 0.12642501f, 0.23551667f, 0.11127264f, -0.09923387f, 
    -0.08956079f, 0.09015117f, -0.01629220f, -0.04264144f, 0.07311609f, 0.07709587f, 0.00182905f, -0.04170006f, 
    0.11237247f, 0.00330307f, -0.05829000f, 0.01706293f, 0.20597306f, 0.12365782f, 0.08654598f, 0.17180552f, 
    -0.48507181f, -0.40142485f, 0.12400573f, -0.01651645f, -0.28555906f, 0.04367315f, 0.00573498f, 0.03272040f, 
    -0.11615008f, 0.05398314f, 0.02378545f, 0.09082611f, 0.05355627f, -0.03866512f, 0.04029578f, -0.03520771f, 
    -0.03653710f, -0.24852389f, -0.13527721f, -0.05109687f, -0.71241242f, -0.42806217f, -0.17148951f, -0.29601043f, 
    -0.36864021f, 0.04095242f, 0.10539637f, -0.03892714f, -0.12926985f, 0.10309128f, 0.11685503f, 0.01575268f, 
    0.05411620f, 0.11723271f, -0.04952508f, -0.00644282f, 0.01063865f, 0.02666490f, 0.14145556f, 0.10020933f, 
    0.32247654f, -0.06377312f, -0.00920904f, 0.10468412f, -0.00098445f, -0.14210467f, 0.01380773f, -0.14851753f, 
    -0.00932086f, -0.08162262f, -0.01424162f, 0.12511043f, -0.02947634f, -0.00889462f, -0.03099852f, -0.10974833f, 
    0.09692703f, -0.01818287f, -0.19983925f, -0.00369621f, 0.18538488f, 0.27019849f, -0.01668340f, -0.13522512f, 
    -0.06174367f, 0.08386434f, 0.05932530f, 0.05611905f, 0.10543537f, -0.03317476f, -0.01514582f, 0.08341956f, 
    0.06520328f, -0.03871112f, 0.03521466f, 0.10546069f, 0.13175292f, 0.04399176f, -0.09582464f, 0.05749893f, 
    -0.42093223f, -0.01327225f, 0.09621209f, -0.05856967f, -0.26245531f, 0.11359487f, -0.07459797f, 0.04129344f, 
    -0.06152727f, 0.07177756f, -0.07435228f, 0.02330986f, -0.00240562f, 0.11489549f, 0.02468770f, -0.00535767f, 
    -0.06257288f, -0.06360134f, -0.02908534f, -0.04671685f, -0.11916231f, -0.21830115f, -0.04509959f, 0.04099499f, 
    0.03911417f, 0.01015084f, 0.03492313f, -0.00035055f, 0.04468363f, -0.07002553f, 0.03727978f, -0.01679049f, 
    0.08910161f, -0.04407350f, -0.05070583f, 0.01998212f, -0.00231297f, -0.15158130f, -0.08226287f, -0.01828422f, 
    -0.59371829f, -0.42308766f, -0.23792271f, -0.08562265f, -0.15762183f, 0.07710313f, 0.07874452f, -0.09686163f, 
    -0.06560303f, 0.03882404f, 0.13004553f, -0.03028536f, -0.10949252f, 0.06263346f, 0.00697486f, -0.02280636f, 
    0.06220360f, 0.18986911f, 0.10363570f, 0.12509497f, 0.06472363f, 0.11351932f, -0.19013835f, 0.08347797f, 
    -0.08162626f, -0.06270103f, 0.00325476f, 0.00837894f, 0.04002398f, 0.06499080f, 0.00274498f, 0.06629041f, 
    0.03093299f, -0.05058802f, -0.03673611f, -0.00423958f, 0.05708947f, 0.00247263f, 0.02669427f, 0.07252207f, 
    -0.46178952f, -0.07478213f, -0.35115719f, 0.07956488f, 0.08493991f, 0.04875224f, 0.02953498f, -0.09368204f, 
    -0.04254514f, 0.12931035f, 0.05828921f, 0.09009428f, -0.07720475f, 0.00852812f, 0.09736534f, 0.02587720f, 
    -0.01598369f, -0.00851859f, -0.15774919f, 0.06096560f, -0.12980683f, 0.12641005f, -0.11244769f, -0.10230505f, 
    0.05955474f, 0.02234842f, 0.11511722f, 0.00553678f, 0.06923854f, -0.00888539f, 0.01663144f, 0.09220938f, 
    -0.02246371f, 0.00253129f, 0.03342662f, 0.04630426f, 0.04300133f, 0.10572658f, -0.08349622f, 0.11665256f, 
    -0.41906330f, 0.03134404f, -0.31332546f, -0.05607033f, 0.14987415f, -0.02912635f, 0.01523391f, -0.06998180f, 
    0.05067005f, 0.07447920f, 0.05243297f, 0.05891431f, 0.10616194f, -0.04479416f, 0.03798134f, -0.01164532f, 
    0.07050573f, 0.13902107f, 0.00534828f, 0.03490599f, 0.37171730f, 0.27452385f, 0.01914506f, -0.04293213f, 
    0.10522743f, 0.11722907f, 0.00167938f, 0.07829463f, -0.01387606f, -0.00741557f, -0.15356328f, 0.00436204f, 
    0.03423011f, 0.00625785f, -0.01091031f, 0.05794404f, 0.13893570f, -0.15723123f, -0.11055421f, -0.06635096f, 
    0.19434279f, 0.13211253f, -0.08353628f, 0.05705687f, -0.10047397f, -0.04060404f, -0.13898084f, 0.03389924f, 
    0.02539736f, 0.05911075f, 0.07200672f, -0.06835370f, 0.04764122f, 0.01086982f, -0.02448058f, 0.01486959f, 
    0.00813117f, 0.01367958f, 0.05790881f, 0.03281490f, 0.28363395f, 0.08543751f, 0.05536832f, -0.10258275f, 
    -0.00608933f, -0.22365591f, -0.06301060f, 0.06441506f, 0.15334737f, 0.00599110f, -0.06000335f, 0.04337318f, 
    -0.05989936f, -0.14461675f, -0.10028452f, -0.12263621f, -0.00214363f, 0.05371624f, -0.06106626f, 0.08254966f, 
    -0.31355909f, 0.04939295f, 0.10826147f, 0.02653640f, 0.08539781f, 0.01238891f, 0.06466257f, -0.03914619f, 
    -0.00623337f, 0.10231785f, -0.06254805f, 0.04844771f, -0.02105534f, 0.05192348f, -0.01122600f, -0.09303259f, 
    0.06950779f, 0.09622210f, -0.07307506f, 0.06554995f, 0.01322596f, 0.04666970f, -0.19502878f, 0.23987776f, 
    -0.02250344f, -0.15047443f, -0.11273967f, -0.05692811f, -0.03081938f, -0.07136622f, 0.01074418f, -0.03747334f, 
    0.07689353f, -0.16686401f, 0.05789655f, -0.05940009f, 0.05024955f, 0.02857976f, -0.00231895f, -0.09735533f, 
    -0.41862071f, -0.23863235f, -0.10918253f, -0.08173851f, 0.15901951f, -0.00227202f, 0.00032951f, 0.02493616f, 
    -0.05499559f, -0.11948820f, 0.00414830f, -0.02281488f, 0.01837382f, 0.00251319f, 0.10182155f, 0.00026251f, 
    0.04668618f, 0.05990203f, 0.14395733f, 0.03137695f, 0.30965590f, 0.14734606f, -0.09641433f, 0.08231121f, 
    -0.06733646f, -0.15578799f, -0.12107712f, 0.02409958f, -0.00575237f, 0.02906876f, 0.00103964f, 0.00481350f, 
    -0.05826692f, -0.08009181f, -0.07986610f, -0.03527896f, -0.05221279f, 0.00783438f, -0.09193647f, -0.05175606f, 
    0.03562063f, 0.16691945f, 0.01265977f, 0.15409623f, -0.03964837f, -0.03089505f, 0.00227931f, 0.02125074f, 
    0.03298748f, 0.03000611f, 0.01231353f, -0.03451962f, 0.07181773f, -0.05524194f, -0.01534518f, 0.00593475f, 
    -0.01702014f, 0.10302693f, 0.04132951f, 0.04697429f, -0.47210231f, -0.06127770f, -0.27451286f, -0.23695932f, 
    -0.17197636f, 0.07458600f, 0.05959581f, -0.16711546f, -0.02918105f, -0.03909126f, -0.05718174f, -0.04256398f, 
    -0.10653488f, -0.18855497f, 0.00714815f, -0.20821193f, -0.16395879f, 0.12341428f, 0.09147363f, 0.01618029f, 
    -0.59973729f, -0.03054266f, -0.15970197f, -0.13745596f, -0.10081273f, 0.16508719f, 0.04287425f, -0.11354939f, 
    -0.05285062f, 0.03079498f, 0.08948801f, -0.01560523f, -0.07537780f, 0.05013808f, 0.08162034f, -0.04222307f, 
    -0.03195969f, 0.12074000f, -0.04551084f, 0.06816050f, -0.15791781f, 0.17937183f, 0.01020778f, 0.07172216f, 
    0.12109488f, 0.05680059f, 0.01778835f, 0.02282476f, 0.01553821f, -0.02963620f, -0.03458301f, 0.02621699f, 
    0.04137527f, -0.02034832f, -0.03879562f, 0.01318070f, -0.05523133f, -0.16114622f, -0.06011970f, -0.06203962f, 
    0.14522400f, 0.11827283f, -0.01889180f, -0.04043663f, -0.05597349f, 0.02978428f, -0.02270865f, 0.10541866f, 
    0.00596199f, 0.07607768f, -0.01662761f, 0.00077299f, 0.00362716f, 0.03197762f, -0.03963340f, 0.04269917f, 
    0.06902221f, 0.06669202f, -0.02145350f, 0.04169765f, 0.09786829f, -0.06414086f, 0.17693186f, 0.12204348f, 
    0.01496288f, -0.00781163f, 0.04410408f, -0.07477972f, 0.04697730f, 0.01717803f, 0.02537875f, 0.06610098f, 
    -0.09044201f, -0.01805191f, 0.12047300f, -0.02200435f, 0.02452252f, 0.07703730f, -0.11503393f, -0.02404342f, 
    -0.12686108f, -0.05075808f, 0.05907558f, 0.07593604f, 0.04005780f, 0.08219007f, -0.10643241f, 0.16420799f, 
    -0.11273729f, -0.03124874f, 0.04680072f, 0.05732007f, -0.02889189f, -0.05777606f, 0.05202362f, 0.04594860f, 
    -0.15173082f, -0.07242238f, 0.06122372f, -0.01113943f, 0.32980749f, 0.11284097f, 0.12194980f, -0.10587795f, 
    -0.08005058f, 0.00401768f, -0.04548499f, 0.02708557f, -0.05538148f, -0.02430689f, -0.05158977f, -0.07117119f, 
    -0.05241800f, 0.02831941f, -0.00262390f, 0.10926019f, -0.08268954f, -0.06220421f, -0.07682156f, -0.00212615f, 
    0.11605346f, 0.07904561f, -0.03330803f, 0.03005129f, 0.06315880f, -0.02481636f, -0.07795852f, 0.04172522f, 
    0.00791661f, -0.01418628f, 0.01910511f, -0.02131515f, 0.07553060f, -0.03922459f, -0.00265586f, 0.07317736f, 
    0.14932369f, 0.03121527f, 0.11730777f, 0.14769465f, -0.71546477f, -0.39826202f, -0.00042444f, -0.18031868f, 
    -0.09372306f, 0.07658733f, -0.04283915f, 0.00679067f, -0.04680393f, 0.06091671f, 0.05136281f, 0.02014003f, 
    -0.00407628f, 0.22227930f, 0.02609566f, 0.15350538f, -0.03343380f, -0.05825933f, -0.01989330f, -0.08374575f, 
    0.28977534f, 0.12668982f, -0.13637635f, 0.04702701f, 0.02369728f, 0.04663177f, -0.02491765f, 0.11460740f, 
    -0.12894268f, 0.02830062f, -0.08672200f, -0.03280484f, 0.08198144f, -0.12260021f, -0.03319494f, 0.05518121f, 
    -0.02817929f, -0.26092196f, -0.20005624f, 0.02217757f, 0.14006773f, -0.00822067f, 0.02889641f, -0.01632386f, 
    0.04235594f, 0.08120948f, 0.02333868f, 0.05247113f, -0.08328442f, -0.00752851f, 0.03104248f, -0.00378433f, 
    0.01176815f, -0.06055706f, -0.03610839f, 0.04723679f, 0.05652925f, -0.31694046f, -0.14481130f, 0.00491602f, 
    -0.29707912f, 0.17576367f, -0.05310008f, -0.03724122f, 0.04130914f, 0.10364402f, -0.10889821f, 0.03148225f, 
    -0.06068269f, 0.00542004f, 0.00985157f, 0.11307326f, 0.04851136f, -0.06436582f, 0.03073484f, -0.03023577f, 
    0.07720033f, -0.11444183f, 0.07484711f, -0.11224400f, 0.22205144f, -0.00501367f, 0.00280424f, 0.11035918f, 
    0.14161289f, 0.02400894f, 0.17069830f, 0.02612712f, 0.11066192f, 0.08618982f, -0.02115364f, -0.01896428f, 
    -0.02753591f, -0.03969747f, 0.17077966f, 0.00811775f, -0.05971152f, -0.02140450f, 0.08261790f, 0.00151781f, 
    -0.24836607f, 0.36006969f, 0.01641962f, -0.28298363f, 0.58514339f, 0.36242393f, -0.22991836f, 0.01579623f, 
    0.07666757f, 0.00622657f, 0.07882707f, 0.10584757f, 0.01125020f, 0.01716470f, 0.04432339f, -0.02918697f, 
    0.21080078f, 0.10368573f, -0.07409918f, 0.06969029f, 0.59936482f, -0.22603641f, -0.31300366f, 0.04282040f, 
    -0.24907693f, 0.02695908f, 0.00773497f, 0.11369078f, -0.06911537f, 0.01878670f, 0.15267056f, -0.03126281f, 
    0.08114123f, -0.01498942f, -0.04332308f, 0.05650009f, -0.01007898f, -0.05523871f, 0.03151735f, 0.01958175f, 
    -0.18984269f, 0.08693633f, 0.13994357f, 0.01616843f, -0.13060066f, 0.00960176f, -0.02880441f, -0.09069123f, 
    -0.05498889f, -0.07936806f, -0.08918595f, -0.04140978f, 0.06723551f, -0.12873472f, -0.10895062f, -0.00675101f, 
    0.00831218f, -0.04209841f, -0.02129291f, 0.01332462f, -0.47277576f, 0.13860495f, -0.02258884f, -0.05618412f, 
    0.28910547f, -0.12205802f, 0.04706877f, 0.08436032f, -0.00324058f, -0.01557415f, 0.07110869f, -0.01089422f, 
    0.04202596f, 0.03160377f, 0.06150202f, -0.04447972f, 0.03514883f, 0.07041294f, 0.05186030f, 0.04779844f, 
    0.49860269f, 0.11233456f, -0.22600800f, -0.31344658f, 0.20476694f, -0.02418959f, 0.00008929f, 0.02115864f, 
    0.06017023f, -0.06027129f, 0.10708703f, -0.09658008f, 0.03032824f, 0.06314722f, 0.00785901f, -0.02620506f, 
    -0.06724068f, 0.00377610f, 0.04635477f, 0.05485463f, -0.13519329f, 0.20853245f, -0.15747419f, 0.05669490f, 
    -0.05598358f, 0.04743264f, -0.08269064f, 0.03574717f, 0.00321986f, -0.12708811f, 0.06229543f, 0.09424289f, 
    -0.01554807f, 0.05109926f, -0.01341380f, 0.05336084f, 0.06070917f, -0.00397397f, -0.00815372f, -0.00238086f, 
    0.07022724f, -0.10521931f, -0.32959655f, -0.14006555f, -0.21260659f, 0.08970809f, 0.02624788f, -0.01433525f, 
    -0.02257103f, 0.11624871f, 0.14525302f, 0.04747315f, -0.03625653f, -0.05676527f, 0.05067371f, -0.07718092f, 
    -0.09296586f, -0.04894790f, -0.12600590f, 0.02307532f, -0.06805097f, 0.21902680f, 0.03846205f, 0.15438826f, 
    0.13995017f, 0.11335712f, 0.08582043f, 0.00500011f, 0.05867545f, 0.05537552f, -0.01177759f, 0.01465146f, 
    0.13523215f, 0.02710585f, 0.07172015f, 0.03390010f, 0.00297231f, 0.06477676f, -0.06241596f, -0.04689283f, 
    0.15577051f, 0.14692852f, -0.18705116f, 0.08131538f, -0.40865433f, -0.17662404f, -0.03571376f, 0.08742153f, 
    0.05736555f, -0.06895611f, -0.02023305f, -0.04713135f, 0.13216324f, -0.03346599f, 0.01730306f, 0.10904393f, 
    -0.02107149f, -0.09279112f, 0.00160471f, -0.09845833f, -0.47725528f, 0.20063320f, 0.10717949f, -0.08469463f, 
    0.06327018f, -0.05778822f, 0.04775768f, -0.04151724f, 0.04137488f, 0.00308956f, 0.03418960f, 0.03107947f, 
    0.07205293f, -0.00612452f, 0.02132959f, 0.04014330f, -0.04816814f, -0.00107842f, -0.11918095f, -0.01198591f, 
    -0.29138392f, 0.05233416f, 0.03501361f, 0.14262578f, 0.06620469f, -0.06515694f, 0.04127605f, -0.01025796f, 
    0.00531360f, 0.04299491f, -0.03692732f, 0.01862489f, 0.05870166f, 0.09548247f, 0.03833123f, -0.05015198f, 
    -0.01646061f, -0.17125966f, -0.01316471f, 0.06770260f, 0.19752435f, -0.09306223f, -0.23998897f, 0.02937371f, 
    0.11186483f, -0.06938482f, 0.16978516f, -0.04940579f, 0.10380983f, -0.02253083f, 0.15104796f, 0.10055760f, 
    -0.10767119f, 0.02635115f, 0.05440241f, 0.09806586f, -0.08332717f, 0.03279466f, 0.09036171f, 0.02403365f, 
    0.17287150f, -0.03466398f, 0.08173294f, 0.02523005f, -0.04301734f, 0.03458472f, 0.02864798f, 0.04711087f, 
    -0.03116173f, -0.11840048f, 0.01394604f, -0.11529194f, -0.02319693f, 0.01516419f, -0.15412872f, -0.06234399f, 
    -0.06560304f, 0.05044478f, -0.00550418f, -0.02175093f, -0.17034772f, -0.00180234f, -0.05017208f, 0.00101143f, 
    0.02404793f, -0.02914802f, -0.05810371f, -0.04854256f, -0.02755539f, -0.11770216f, -0.03939189f, -0.00331698f, 
    0.07146895f, -0.02387313f, -0.06521261f, -0.02270017f, -0.12486788f, 0.00324101f, -0.13999192f, -0.01751616f, 
    -0.52588242f, 0.11923175f, 0.06006675f, -0.22237737f, 0.16272858f, -0.02288918f, -0.03787818f, -0.11757438f, 
    0.15621375f, 0.02019271f, 0.00494070f, 0.01782358f, 0.02589548f, -0.06353958f, 0.01091964f, 0.09915425f, 
    -0.09084581f, 0.07907815f, -0.10767179f, -0.10156985f, 0.14601666f, -0.19404346f, 0.04889835f, 0.03968404f, 
    -0.17884898f, 0.01211337f, 0.07607286f, -0.05111423f, -0.00334208f, -0.00231275f, -0.18256682f, -0.01962598f, 
    0.03031991f, 0.05463175f, -0.04941509f, -0.04274589f, -0.09232998f, -0.02418687f, -0.19009596f, -0.12704478f, 
    -0.27703807f, 0.08840781f, -0.14125915f, 0.15775183f, -0.35023111f, 0.21777958f, 0.14028879f, 0.04328753f, 
    0.05929999f, 0.10184124f, 0.03276253f, -0.06735901f, 0.02101289f, 0.00491691f, 0.08992021f, -0.02712208f, 
    0.04100849f, -0.04010992f, -0.05704583f, 0.00782163f, 0.00066198f, -0.02813846f, 0.08643629f, 0.03257498f, 
    0.03251110f, -0.10307048f, 0.01443567f, 0.03627937f, -0.12106133f, -0.18164459f, -0.12230818f, -0.02126585f, 
    0.04118996f, 0.00596130f, -0.01963861f, -0.11446057f, -0.03354217f, 0.04465372f, -0.05744150f, -0.03025996f, 
    -0.29390752f, -0.21936874f, 0.09132175f, -0.05679841f, 0.03329262f, 0.00222022f, 0.08485473f, 0.06904196f, 
    0.11995450f, 0.00817839f, -0.03248449f, 0.02514111f, -0.03793108f, -0.00281686f, -0.00679759f, -0.06190502f, 
    -0.08629952f, 0.00534595f, -0.06248856f, -0.03275173f, -0.48229668f, -0.66569400f, -0.11533384f, -0.26822075f, 
    -0.15608011f, -0.08242840f, 0.07151213f, 0.10188307f, 0.02342432f, 0.10684386f, -0.10364469f, 0.04725359f, 
    0.05371334f, -0.06008795f, 0.00673060f, -0.16961689f, -0.03103775f, -0.01182997f, -0.09565317f, -0.10004953f, 
    0.18538298f, -0.13741575f, -0.00543661f, -0.00896884f, -0.07106050f, -0.07230593f, 0.15934888f, -0.07384340f, 
    0.04730803f, -0.00822166f, 0.13332295f, -0.13924243f, -0.06742834f, 0.03908456f, 0.03715581f, -0.10005511f, 
    0.00199929f, -0.04321893f, -0.06743899f, 0.03202287f, -0.00974333f, -0.17351617f, 0.10160557f, 0.12833811f, 
    0.30365694f, -0.08648497f, 0.04137745f, 0.06020360f, -0.01282879f, -0.06755285f, 0.09002715f, -0.05535099f, 
    -0.04166916f, 0.04847494f, 0.10889006f, 0.05908379f, 0.09428903f, -0.07707497f, 0.05717403f, 0.16240536f, 
    0.00459488f, 0.14016441f, 0.03377084f, -0.10779391f, -0.00398573f, -0.06028067f, -0.03783266f, 0.11566126f, 
    -0.08979063f, -0.13991074f, 0.15017220f, -0.11695223f, -0.03589802f, -0.07472182f, -0.04600265f, -0.12576728f, 
    -0.05994009f, -0.08120234f, 0.01034617f, -0.08708303f, -0.16887802f, -0.05987452f, 0.07208508f, -0.07004299f, 
    0.01475351f, 0.03709962f, 0.03488202f, -0.03199197f, -0.04996880f, 0.05604250f, -0.12950085f, 0.05873701f, 
    0.01925046f, -0.05938305f, -0.11862281f, -0.04779891f, -0.01589174f, -0.07448149f, -0.01902815f, -0.05442569f, 
    0.29708394f, -0.21132600f, 0.00655826f, 0.11996621f, 0.01004262f, -0.04917665f, -0.18614866f, -0.02836399f, 
    0.06485097f, -0.09557695f, 0.03622851f, -0.05454895f, 0.11057606f, -0.01558363f, -0.08650563f, -0.00684564f, 
    -0.01392407f, 0.04450060f, -0.00461886f, 0.00665309f, 0.09366835f, 0.17955257f, -0.06543817f, -0.31723648f, 
    -0.04846416f, -0.11110309f, -0.06292666f, 0.08011409f, -0.09389839f, -0.10906594f, -0.08994054f, -0.04800459f, 
    -0.06969757f, -0.06324724f, 0.08338418f, 0.01588660f, -0.12122499f, -0.09078436f, 0.13946387f, -0.13159740f, 
    -0.02600898f, -0.10716063f, 0.09182819f, 0.16482013f, -0.01671191f, 0.04547920f, 0.08713931f, -0.05518797f, 
    0.05248738f, -0.02942181f, 0.11696707f, -0.02765218f, -0.04346196f, 0.03456509f, 0.06708895f, 0.06226478f, 
    -0.06015605f, 0.14087379f, 0.01869099f, -0.10016575f, 0.58248287f, 0.05023701f, -0.41626284f, -0.13037087f, 
    0.02297684f, 0.01448683f, -0.08150868f, -0.18689457f, -0.01535802f, -0.05060879f, 0.20053615f, 0.07791844f, 
    -0.02760096f, 0.10040141f, -0.03696015f, 0.11894052f, -0.03030102f, -0.04711980f, -0.08657611f, 0.03350743f, 
    0.07305251f, 0.06699079f, -0.17836404f, -0.08473044f, -0.22762017f, -0.19214292f, -0.09176975f, -0.09702317f, 
    -0.06823519f, -0.09356838f, 0.05080899f, -0.09516232f, -0.06658594f, 0.01073248f, 0.03828931f, 0.06909346f, 
    -0.00282386f, 0.03700757f, 0.10614865f, -0.06217601f, 0.07935070f, 0.02924038f, -0.18010637f, -0.12600537f, 
    0.13483104f, 0.00069126f, -0.19051392f, -0.07256126f, -0.11846691f, -0.06972670f, -0.01799881f, 0.12855218f, 
    -0.05917925f, 0.00028178f, -0.00285725f, 0.09796236f, 0.03662953f, 0.12921362f, 0.11097880f, 0.02606220f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07475334f, 0.00192755f, -0.06162907f, -0.01888583f, 0.00667299f, 0.00754503f, -0.01037691f, -0.09518544f, 
    -0.00227239f, -0.01890992f, 0.08383932f, 0.01766931f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
