#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.66783071f, 0.09133269f, -0.27338591f, 0.60771596f, -0.39570361f, -0.68168640f, 0.01810722f, -0.07559069f, 
    -0.44240251f, 0.62862933f, 0.54165399f, 0.20400271f, -0.80701435f, -0.72738928f, -0.15193154f, -0.14206508f, 
    0.00888641f, -0.18378389f, 0.72552526f, -0.45806402f, -0.35939881f, -0.43734041f, -0.63697040f, 0.02731593f, 
    0.05438492f, -0.25634784f, 0.46547812f, 0.01996302f, -0.69977593f, 0.32490015f, -0.46489200f, -0.61096573f, 
    -0.65453511f, -0.46885312f, -0.26751223f, -0.16017035f, -0.64860725f, -0.64347523f, -0.65659219f, -0.58730352f, 
    -0.25567877f, -0.07532077f, 0.37671381f, 0.35349497f, 0.24290679f, 0.04892300f, 0.59871584f, -0.02059879f, 
    0.49034932f, -0.80684721f, 0.25326556f, 0.12053610f, -0.65585643f, -0.25270396f, 0.01005170f, 0.23289602f, 
    0.43947068f, 0.56591493f, 0.34260190f, 0.50810045f, -0.08452156f, -0.43486539f, -0.42218572f, 0.69064611f, 
    0.22261438f, 0.73242986f, 0.05559941f, 0.24146187f, 0.22959699f, -0.37992781f, -0.28569520f, 0.37917736f, 
    0.00164040f, -0.23525445f, 0.26386890f, -0.32874432f, 0.08294803f, 0.81516260f, -0.36459869f, -0.47922608f, 
    0.35299343f, 0.53562099f, -0.58292586f, -0.52752584f, -0.37032089f, -0.01978478f, -0.25133726f, -0.38756788f, 
    0.39796907f, 0.41331044f, 0.47023571f, -0.15398619f, -0.40613461f, 0.73695898f, 0.65016937f, -0.07389774f, 
    0.02320833f, 0.36756712f, -0.20002227f, 0.57348698f, 0.41678879f, 0.54337716f, 0.38580859f, -0.28703818f, 
    0.53223735f, -0.08725421f, 0.29459688f, 0.29341543f, -0.58190840f, -0.28541467f, -0.12570016f, 0.77682143f, 
    0.67806542f, 0.41543210f, 0.29237574f, -0.52520156f, 0.23366649f, -0.96328908f, -0.06299749f, 0.61108017f, 
    0.38591757f, 0.26514012f, 0.27757165f, 0.24036907f, 0.17211881f, 0.36236587f, 0.66192156f, 0.08076791f, 
    0.19748771f, -0.14593703f, -0.34788713f, 0.57164812f, -0.03041679f, 0.38226473f, -0.05526384f, 0.64872080f, 
    -0.68044597f, 0.34437448f, 0.46421093f, 0.04013374f, 0.22794344f, -0.00173924f, -0.27922332f, -0.43635073f, 
    0.36914748f, 0.74898964f, 0.58849835f, -0.00351681f, 0.34629908f, 0.12754393f, 0.03796187f, 0.00129149f, 
    -0.27489731f, 0.55441272f, 0.78385937f, 0.62272388f, 0.00194196f, 0.33291885f, -0.61449760f, 0.17483103f, 
    0.38315395f, 0.22502495f, -0.40065148f, -0.53396845f, 0.42473590f, 0.60867500f, -0.02910023f, 0.05207754f, 
    -0.43238139f, 0.08004881f, -0.32311305f, -0.76704174f, 0.04845443f, 0.28459027f, 0.29831353f, 0.44384283f, 
    -0.58567685f, -0.00669912f, -0.27480093f, -0.36290136f, -0.52347207f, -0.21031989f, -0.06967605f, -0.57141823f, 
    -0.39639026f, 0.04436700f, 0.06498353f, 0.18974510f, -0.54338050f, -0.62547827f, 0.47382149f, -0.22415060f, 
    0.50446659f, 0.79647642f, 0.39161092f, 0.10792778f, 0.37078035f, 0.18156423f, 0.45756733f, 0.24694484f, 
    0.47495741f, 0.46573684f, 0.04630502f, 0.22267994f, 0.35852313f, 0.40227729f, -0.27673623f, 0.44958660f, 
    0.26459891f, -0.32885021f, -0.78698862f, 0.40687189f, 0.24278018f, 0.25684124f, 0.31716335f, 0.27126411f, 
    0.52189577f, 0.47584459f, 0.59007013f, -0.00527879f, -0.45189539f, 0.12535886f, 0.27298701f, -0.19391382f, 
    0.44450176f, 0.35893458f, 0.23024935f, 0.34492943f, 0.75863236f, 0.52277112f, -0.62750953f, -0.15853544f, 
    0.01178503f, 0.13659456f, 0.20050304f, 0.11880071f, 0.49993467f, -0.88774717f, 0.31161040f, -0.66640687f, 
    0.22088620f, 0.07909810f, 0.06105481f, -0.41354874f, 0.20554268f, 0.01232633f, -0.15102245f, 0.52915406f, 
    -0.55973381f, 0.46664241f, 0.34283370f, -0.28414732f, 0.77254254f, 0.66954744f, -0.63668925f, -0.25340962f, 
    0.00600419f, -0.38731074f, 0.23304100f, 0.51178908f, -0.16616151f, -0.41624227f, -0.64437139f, -0.68711698f, 
    0.09804562f, 0.47581488f, -0.30211964f, -0.35213932f, -0.48274559f, -0.09249637f, -0.17321320f, -0.26652071f, 
    -0.41764620f, -0.35340089f, 0.28030655f, 0.85718197f, -0.48930299f, 0.29287753f, -0.19949821f, -0.65245324f, 
    -0.27339342f, -0.32526484f, 0.03585490f, 0.71674055f, 0.05901206f, -0.04040610f, -0.07028390f, -0.21718886f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.16198279f, 0.09289208f, -0.11398314f, 0.03298932f, 0.12388194f, -0.31274182f, 0.01768872f, -0.22143328f, 
    -0.28276327f, -0.14058998f, 0.04987741f, -0.27563018f, -0.37316594f, 0.10076650f, -0.12691613f, 0.03451857f, 
    0.30631024f, 0.04382982f, -0.00904690f, 0.01989072f, 0.20966922f, -0.22063445f, 0.09286756f, -0.20530599f, 
    -0.02381729f, 0.23402861f, 0.20479459f, 0.20622759f, -0.14597318f, -0.00627150f, -0.22225529f, -0.04999994f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.23115824f, 0.07868988f, 0.03239034f, 0.09035251f, -0.09969185f, 0.14731745f, -0.07774395f, -0.04194616f, 
    0.02586651f, -0.20452756f, 0.14552508f, -0.13737631f, 0.07410287f, 0.05296286f, -0.10104762f, -0.07468037f, 
    -0.14046396f, -0.04356236f, 0.16535939f, 0.01006390f, -0.10766571f, -0.04693850f, 0.01737772f, -0.12745240f, 
    -0.09958652f, 0.18085103f, 0.03730492f, 0.28834760f, -0.01790510f, 0.21954954f, 0.16112113f, -0.12099411f, 
    -0.02558017f, 0.03771431f, -0.26639041f, -0.08506512f, -0.03308485f, -0.04944479f, 0.07616944f, 0.10531604f, 
    0.01945572f, -0.17350586f, -0.18807399f, -0.14678907f, 0.10430612f, -0.08787085f, 0.26133785f, -0.19966625f, 
    0.05770274f, 0.10977054f, 0.00439080f, 0.10281472f, -0.05737165f, -0.13611309f, 0.01135734f, 0.06831823f, 
    0.00052196f, -0.10845188f, 0.01665759f, 0.11034381f, -0.09770410f, 0.00718258f, -0.18243976f, -0.16044120f, 
    -0.00801797f, -0.18962027f, -0.02157167f, 0.13146162f, -0.04049687f, -0.02591836f, 0.03445995f, 0.02520921f, 
    0.12415043f, 0.02207298f, -0.08437885f, -0.12306228f, 0.01427300f, 0.06480952f, 0.09881805f, -0.10429231f, 
    -0.25022861f, 0.09175098f, -0.11938709f, 0.14303960f, -0.00847841f, -0.07129223f, 0.06070734f, -0.02091139f, 
    0.16554528f, 0.01261311f, -0.15291664f, 0.26178363f, -0.06646629f, -0.00179131f, 0.13630679f, 0.00402437f, 
    0.14608769f, 0.17014123f, -0.14476278f, -0.18412165f, -0.06841158f, -0.12957677f, 0.05088429f, -0.03980648f, 
    -0.09240198f, -0.05915384f, -0.12097798f, -0.03874702f, 0.04664321f, -0.00254633f, -0.07486726f, -0.00837020f, 
    -0.03388198f, -0.03436452f, 0.15345864f, 0.05675313f, 0.11458506f, 0.15776759f, 0.00305073f, -0.12102488f, 
    0.09092964f, -0.05132188f, 0.15393800f, 0.14095494f, 0.09367406f, -0.09808696f, -0.03068379f, 0.03866016f, 
    -0.25322655f, 0.01230570f, 0.03494317f, -0.00574318f, -0.04932638f, 0.13228926f, 0.02732878f, 0.05264997f, 
    0.13507293f, -0.05026721f, 0.06220417f, 0.19736169f, -0.05654392f, -0.04253375f, -0.04610792f, -0.10004318f, 
    -0.32783723f, 0.17314182f, 0.06928933f, -0.02207960f, 0.13878550f, 0.06582786f, 0.09297904f, 0.01272634f, 
    -0.29604459f, -0.27397379f, 0.04740331f, -0.15993448f, -0.01635717f, 0.01213857f, -0.07673018f, 0.09600836f, 
    0.04189717f, -0.20088764f, 0.25877127f, -0.12735924f, 0.19425805f, -0.04117901f, 0.13206598f, 0.16114797f, 
    -0.14969458f, 0.04954726f, -0.13517182f, 0.03755415f, 0.12253107f, -0.10694579f, 0.08030800f, 0.01708606f, 
    0.12971997f, -0.13349433f, 0.14369160f, 0.03036532f, -0.00567946f, 0.03797896f, 0.16925015f, -0.03783449f, 
    0.07962044f, -0.05704394f, -0.01101302f, 0.03183629f, 0.12640603f, 0.09256324f, 0.16122772f, -0.09618207f, 
    0.01925317f, 0.05521547f, 0.08183157f, 0.15208042f, -0.03820583f, 0.07036474f, -0.10505916f, 0.01004817f, 
    -0.17065461f, -0.03670111f, 0.10917012f, -0.10801280f, -0.09412024f, 0.06561726f, 0.09012369f, -0.11012153f, 
    0.00774319f, -0.06296431f, 0.13869402f, 0.04617932f, -0.12020028f, -0.20124918f, 0.05720372f, -0.08135182f, 
    -0.23745273f, -0.00899373f, -0.36117229f, 0.03118873f, -0.00543668f, -0.06660309f, 0.05803827f, 0.09519196f, 
    -0.00448288f, -0.16918676f, 0.01680478f, -0.02306635f, 0.06209381f, -0.05204612f, 0.08329941f, 0.10268496f, 
    0.07399542f, -0.09160713f, -0.09222388f, 0.31572044f, -0.00734157f, 0.17601982f, 0.07212187f, -0.16581041f, 
    -0.18409511f, 0.04821862f, 0.28774571f, 0.01451162f, 0.12097872f, 0.10463385f, 0.07106210f, 0.14659496f, 
    0.01296114f, 0.09867121f, 0.05215516f, 0.03345915f, -0.16831058f, -0.05406568f, 0.10186063f, 0.00145450f, 
    -0.09754473f, 0.06088846f, -0.04241318f, 0.21763429f, 0.15240867f, -0.05470197f, -0.24381824f, 0.14344554f, 
    0.03543133f, -0.00466757f, 0.00542884f, -0.01583257f, -0.00881943f, 0.19553950f, -0.06482895f, 0.01486519f, 
    0.14560437f, -0.10316877f, 0.01952479f, 0.25955886f, -0.04588688f, 0.11714356f, -0.09368045f, 0.03794062f, 
    -0.00712445f, 0.01427145f, 0.03640260f, 0.01652975f, -0.12370500f, 0.03578039f, 0.00310398f, 0.25245786f, 
    -0.01514029f, 0.03155801f, 0.04866618f, -0.03234845f, -0.03334372f, -0.05054940f, -0.05936092f, -0.00121275f, 
    -0.04343203f, -0.04092396f, -0.01029095f, 0.00673993f, 0.02600894f, -0.01125151f, -0.04546908f, 0.01276957f, 
    -0.06163248f, -0.06407713f, -0.02922110f, -0.02370065f, -0.00749564f, 0.05420855f, 0.01539539f, 0.04225509f, 
    0.02169729f, 0.05207642f, 0.04325972f, 0.01305815f, 0.01932568f, 0.03405622f, -0.00266359f, -0.03064152f, 
    -0.04518240f, 0.03774972f, 0.04840120f, 0.01756502f, -0.00098001f, -0.03311824f, -0.01571856f, 0.02321271f, 
    -0.02585521f, -0.06366333f, -0.01238902f, 0.00689467f, -0.04173490f, 0.03385108f, 0.03873104f, 0.03955265f, 
    0.04132773f, -0.06078482f, 0.02121668f, 0.05120429f, 0.04382602f, -0.00551257f, -0.00050488f, 0.04777551f, 
    0.00286320f, -0.02178537f, 0.03126043f, -0.05117625f, 0.04686407f, -0.03160680f, -0.05730847f, -0.06580781f, 
    0.02730716f, 0.04469224f, -0.01185721f, -0.01204672f, 0.01096056f, 0.02092410f, -0.00431978f, 0.04887828f, 
    -0.04304060f, -0.06648876f, 0.04176266f, -0.05148384f, 0.01393161f, -0.00794368f, -0.01642894f, -0.00809753f, 
    0.00992349f, 0.01614764f, 0.00202058f, -0.02724078f, 0.00414012f, -0.01545017f, -0.02204542f, -0.01542891f, 
    -0.02205843f, -0.01232065f, -0.03590069f, 0.01040782f, -0.01124280f, -0.03110967f, -0.02053617f, 0.03735933f, 
    0.01777155f, -0.03966602f, -0.03042676f, -0.02783800f, 0.01738722f, -0.05377343f, -0.01562179f, -0.00905537f, 
    -0.02678525f, -0.00639695f, -0.03141211f, -0.03330286f, -0.04538622f, 0.02197667f, -0.03406842f, 0.03731100f, 
    -0.00517622f, 0.00828218f, 0.03410964f, -0.02874584f, 0.01637102f, -0.04026624f, -0.03830705f, -0.03302106f, 
    0.03061384f, 0.00375869f, -0.05058975f, 0.00470428f, 0.00819597f, -0.03436039f, -0.06036704f, -0.04079429f, 
    -0.05440436f, 0.04206896f, -0.06252456f, 0.01197818f, 0.01571584f, 0.01379620f, -0.03651405f, -0.04313112f, 
    -0.06059414f, -0.00515022f, -0.04233151f, 0.00054742f, -0.02825578f, 0.01689367f, -0.04478368f, -0.04679538f, 
    -0.01149739f, 0.02424058f, 0.00495798f, 0.01275522f, 0.03199936f, -0.00899953f, -0.02946468f, 0.04147745f, 
    0.00853396f, 0.03601265f, -0.00135242f, 0.03376278f, -0.06193358f, -0.00603273f, -0.06277940f, 0.04770108f, 
    -0.05148465f, -0.00269919f, 0.04276901f, -0.01012856f, 0.02348931f, 0.00493974f, -0.04762507f, 0.01667163f, 
    -0.01393060f, 0.04957945f, -0.05400746f, -0.03135383f, -0.05872057f, 0.03681307f, -0.04029336f, -0.02374687f, 
    -0.03223912f, -0.03908965f, 0.01570530f, -0.02270384f, 0.00265763f, -0.06350043f, -0.03470554f, 0.03067078f, 
    0.03557220f, -0.00525066f, -0.02089966f, -0.00343369f, -0.04556999f, 0.03014695f, -0.03934900f, -0.00233256f, 
    0.03936265f, 0.00603069f, -0.00995719f, -0.05694135f, -0.03375015f, -0.03689388f, 0.03360784f, 0.00120174f, 
    0.03884301f, 0.04829670f, -0.01359126f, -0.01349474f, -0.05644748f, -0.03388158f, 0.00039458f, -0.03659352f, 
    0.00769649f, -0.04042507f, -0.00898173f, -0.02360110f, -0.02070945f, -0.04511443f, -0.05728652f, 0.03419276f, 
    -0.03973612f, -0.03790255f, -0.02426042f, -0.05845033f, 0.02559537f, -0.00880764f, -0.05947171f, 0.00324771f, 
    -0.00386605f, 0.02896534f, 0.02722435f, -0.00684547f, -0.05808429f, -0.03539768f, 0.00765527f, -0.02015496f, 
    0.01505743f, -0.00733783f, 0.03850367f, -0.00739715f, -0.04701579f, 0.02522437f, -0.05231745f, 0.02011002f, 
    -0.00169634f, -0.05095452f, 0.02755319f, -0.06187890f, 0.01565901f, 0.02049190f, -0.02807023f, 0.02757882f, 
    -0.03869581f, 0.01892065f, -0.04374719f, -0.06496876f, -0.02806244f, -0.06134488f, -0.06114928f, 0.04540771f, 
    -0.02866326f, 0.03012707f, -0.03713215f, 0.03690355f, 0.04161822f, 0.04125269f, 0.01888820f, 0.03427052f, 
    -0.02629392f, 0.03102617f, 0.00757054f, -0.00822944f, 0.02247308f, -0.00869618f, -0.04228874f, 0.03666607f, 
    -0.00012890f, -0.04937549f, -0.01681112f, -0.01238789f, 0.01941803f, 0.02148154f, 0.00814879f, 0.01222294f, 
    -0.05058780f, -0.04639449f, -0.06099934f, -0.06009986f, -0.05023510f, 0.01523122f, -0.00939842f, 0.04458085f, 
    -0.05621222f, -0.02466005f, 0.03483585f, 0.01204329f, 0.00314868f, -0.06006875f, 0.04580386f, -0.06153863f, 
    -0.00531581f, 0.05087821f, 0.00205375f, 0.03454171f, 0.01336503f, 0.02386255f, -0.03528490f, -0.02123275f, 
    -0.02020112f, 0.03268860f, 0.02482985f, 0.03601235f, 0.03525752f, -0.02651687f, 0.02481976f, 0.00416508f, 
    0.03938312f, 0.00973047f, 0.00229331f, 0.01839799f, 0.03760270f, -0.05534022f, -0.05882415f, -0.02014277f, 
    -0.05871065f, 0.01543140f, -0.02679255f, 0.03078533f, 0.02919165f, 0.01113414f, 0.03421545f, 0.01468393f, 
    0.00648941f, -0.02973340f, -0.04620416f, 0.04415990f, -0.03505702f, 0.03944046f, -0.05623879f, -0.04882878f, 
    0.04881166f, 0.03413276f, 0.01985935f, -0.06386475f, -0.04115730f, -0.05240645f, 0.04406745f, -0.00013895f, 
    0.03913000f, -0.02367082f, -0.05389368f, -0.02117220f, -0.02241873f, -0.04147982f, 0.00193684f, -0.01095209f, 
    -0.00824586f, -0.04801191f, 0.02950602f, -0.02843535f, -0.05345435f, -0.06214055f, -0.04938932f, 0.02444497f, 
    -0.03003035f, -0.04475687f, 0.03441930f, 0.01376779f, -0.05195682f, 0.00544374f, -0.05088293f, 0.01833170f, 
    -0.01240127f, 0.04833578f, -0.04918823f, 0.02430752f, 0.02552383f, -0.00747172f, -0.06409602f, -0.04765463f, 
    0.02985510f, 0.04792946f, -0.02079545f, -0.00552874f, 0.01432752f, -0.02065389f, -0.05581053f, 0.04707833f, 
    -0.03184374f, -0.02179054f, -0.04903695f, 0.03968368f, 0.02493354f, -0.04615270f, -0.04027054f, -0.02488346f, 
    0.02177730f, -0.02378283f, 0.04784183f, -0.04613397f, 0.04589685f, 0.02394474f, 0.01519726f, -0.05857759f, 
    0.00194677f, -0.00113047f, 0.02054083f, 0.00097293f, -0.04060932f, -0.04551771f, -0.01626177f, 0.02600204f, 
    -0.03624553f, -0.04682644f, -0.01854512f, -0.01399748f, -0.02156724f, 0.04032902f, -0.06081438f, 0.03792962f, 
    -0.01114730f, -0.04336255f, 0.01734250f, 0.03511177f, -0.06791129f, -0.00339257f, 0.01010726f, -0.02251992f, 
    -0.03360627f, -0.00461282f, 0.04474694f, 0.03660462f, -0.06683797f, -0.04216239f, 0.01145784f, 0.02141442f, 
    -0.03048320f, -0.03934557f, 0.02094606f, 0.04383450f, -0.03850082f, -0.00368907f, -0.01837798f, -0.01885332f, 
    -0.02691866f, -0.03503062f, 0.01699066f, 0.00377340f, -0.04693805f, -0.01133591f, 0.02498123f, -0.05033790f, 
    -0.00214069f, 0.04045729f, 0.03127717f, -0.00858226f, 0.04656326f, 0.01848047f, -0.05615984f, 0.00270216f, 
    0.03317059f, -0.01150234f, 0.02050253f, 0.02677251f, -0.03696820f, -0.06016165f, -0.02735187f, 0.02732900f, 
    0.00506409f, -0.04780185f, 0.03412586f, -0.00097777f, -0.00560175f, 0.00270614f, 0.01232726f, -0.02567921f, 
    0.02111804f, -0.03253917f, -0.00368169f, 0.00881375f, -0.05782268f, 0.00269474f, 0.02086583f, -0.00684107f, 
    -0.00328879f, -0.00194679f, -0.02359013f, -0.03867744f, 0.02998522f, -0.05418092f, -0.05739062f, -0.00282435f, 
    0.00854830f, -0.02305555f, 0.03225559f, 0.03415111f, -0.04059749f, -0.04339628f, -0.02934271f, -0.01073867f, 
    -0.02562103f, -0.02996195f, 0.00364382f, -0.01220038f, 0.04210469f, 0.01888573f, 0.03724853f, 0.02335024f, 
    -0.00542145f, -0.04496924f, -0.05372649f, 0.02237860f, 0.01858438f, -0.01504607f, -0.01549112f, 0.02340615f, 
    -0.06287037f, -0.06043733f, 0.03516881f, 0.04125423f, 0.03107964f, -0.01303098f, -0.06755076f, -0.01513109f, 
    -0.02713885f, -0.01654846f, -0.05240644f, -0.05780638f, 0.02338869f, 0.01421264f, -0.05625086f, -0.01593685f, 
    -0.04736684f, -0.00649009f, 0.02543704f, 0.00050783f, -0.05551127f, 0.04235612f, -0.01194128f, 0.03596158f, 
    0.03318619f, 0.01377812f, 0.00535724f, -0.03489530f, -0.04034287f, -0.05954469f, -0.05287697f, -0.03230825f, 
    0.03424250f, -0.00262733f, -0.05883070f, 0.04736807f, -0.06519762f, -0.05591927f, 0.04696428f, -0.04733096f, 
    -0.01175061f, 0.01221720f, 0.00673610f, -0.04208259f, -0.01509622f, 0.04373541f, -0.03335341f, 0.00779227f, 
    -0.01329914f, -0.03682997f, -0.02139632f, -0.00729455f, -0.05648945f, -0.04494439f, -0.03784395f, -0.01574401f, 
    -0.03618573f, -0.02924318f, -0.03092669f, -0.05030432f, -0.01004637f, -0.04482056f, 0.00056354f, -0.02275269f, 
    -0.04395353f, -0.07596410f, 0.02737495f, -0.01013882f, -0.05719066f, -0.00363059f, 0.01788280f, -0.06704587f, 
    -0.00772340f, -0.05351738f, 0.00416732f, -0.04698208f, 0.02238553f, 0.00233883f, -0.07973921f, -0.04972114f, 
    -0.03340436f, -0.06929661f, -0.07996581f, 0.00028542f, -0.01834597f, 0.00925907f, 0.02299257f, 0.00304446f, 
    -0.04360325f, 0.00934330f, 0.00019631f, -0.01602492f, -0.03792926f, 0.02255056f, -0.03395629f, 0.03127411f, 
    0.01823931f, 0.00849994f, -0.05006015f, -0.07556836f, 0.00714624f, 0.01882126f, -0.06535376f, 0.00733995f, 
    -0.02446933f, 0.02311306f, -0.06188644f, -0.06464169f, -0.03456754f, 0.00807983f, -0.04987663f, -0.02762216f, 
    -0.06584877f, 0.01557039f, -0.04943640f, -0.04688100f, -0.07287642f, -0.03550405f, -0.04714758f, -0.03627876f, 
    -0.07221825f, 0.00289585f, -0.06574623f, -0.04911869f, -0.00676412f, 0.02599641f, -0.06470847f, -0.03742816f, 
    -0.00783114f, -0.03562907f, -0.02989438f, -0.06495740f, -0.01428909f, 0.03142134f, -0.03430515f, 0.01469756f, 
    0.02365964f, 0.01045879f, -0.00943536f, 0.00053772f, -0.01935489f, -0.00460847f, 0.02364440f, -0.07125624f, 
    -0.02816804f, -0.05420126f, -0.03662181f, -0.05463179f, -0.03669189f, -0.00326864f, -0.01976083f, -0.02657176f, 
    -0.03199528f, -0.06601684f, -0.06596959f, -0.04206996f, 0.01990755f, 0.02749031f, -0.05019690f, -0.03985935f, 
    -0.02760801f, -0.02745118f, -0.01770349f, 0.02164100f, 0.00445112f, -0.05277954f, -0.03863003f, -0.02839438f, 
    0.03353160f, -0.04751242f, -0.05490580f, -0.01925172f, -0.06173922f, 0.02300449f, 0.02549914f, -0.04037774f, 
    -0.01008880f, -0.07472247f, 0.00566899f, -0.04877885f, -0.00996991f, -0.03890354f, -0.00392110f, 0.01546569f, 
    0.01754930f, -0.03268348f, -0.01262416f, -0.05651764f, -0.06520045f, 0.04741539f, -0.03483054f, -0.02049073f, 
    0.02092586f, -0.03864867f, -0.04273106f, 0.03354435f, -0.03726325f, 0.01888600f, -0.02881137f, -0.00028827f, 
    -0.01975685f, 0.00552212f, -0.06376150f, -0.06345108f, -0.03942476f, -0.07426564f, 0.01371628f, -0.04976438f, 
    -0.01808252f, 0.00561838f, 0.01611134f, -0.06917820f, 0.02255622f, -0.04698349f, -0.03133197f, -0.02928207f, 
    0.00733906f, 0.01233457f, -0.05562887f, 0.02399590f, -0.05065363f, -0.06566481f, -0.02747311f, -0.04415848f, 
    -0.05244592f, -0.05764762f, -0.03739393f, 0.00020880f, -0.07001375f, -0.04268128f, -0.05423949f, -0.05189512f, 
    0.03151826f, 0.02261562f, 0.02187621f, -0.07613254f, -0.01105252f, -0.01508784f, -0.07360483f, 0.02919477f, 
    0.02909390f, -0.04081562f, 0.01967213f, -0.02241529f, -0.03000316f, -0.01279421f, -0.03981435f, 0.03257290f, 
    0.03047059f, -0.08158357f, -0.06237114f, -0.01934469f, 0.02455661f, -0.06467466f, 0.02689539f, 0.01278122f, 
    0.03410939f, -0.05587361f, -0.07624406f, -0.03091675f, -0.05113228f, 0.03821017f, -0.03696572f, 0.01127595f, 
    -0.06334659f, -0.01046670f, -0.01433244f, 0.01534059f, -0.01918491f, 0.03935773f, -0.06035706f, -0.04815917f, 
    -0.04975374f, -0.04728808f, -0.07879601f, 0.02838355f, -0.06600442f, 0.00623897f, 0.02922048f, 0.00198600f, 
    -0.01483623f, -0.03905308f, -0.00998540f, -0.01526071f, -0.00027713f, -0.03764460f, -0.01368072f, -0.03195565f, 
    -0.02267007f, -0.06345457f, -0.06026012f, -0.05686677f, 0.01787974f, 0.00987492f, -0.01143899f, -0.03359115f, 
    0.03043671f, -0.06068198f, 0.01011212f, 0.02994215f, -0.06886809f, 0.01148383f, -0.02359186f, 0.01204902f, 
    -0.03656982f, -0.00773937f, 0.03534748f, -0.04806840f, -0.01946943f, 0.01436133f, -0.08163882f, -0.06836945f, 
    0.02516523f, -0.05836999f, -0.03312392f, -0.05435898f, -0.00438854f, 0.02072641f, -0.07737393f, 0.01989955f, 
    -0.06891821f, -0.06789690f, -0.06272753f, 0.00955949f, -0.04666108f, -0.07132487f, -0.07871869f, -0.06078145f, 
    -0.07962991f, -0.03074661f, -0.04449518f, -0.02184090f, -0.05363705f, 0.01555952f, 0.02339527f, -0.07884301f, 
    -0.00457002f, -0.00810122f, 0.00947659f, -0.08107611f, -0.06704222f, -0.01670120f, 0.01189642f, -0.02676033f, 
    0.03048296f, -0.01498492f, -0.00999081f, -0.03014888f, 0.00607525f, -0.02614425f, 0.00784935f, -0.03764939f, 
    0.29912171f, -0.07929055f, 0.05947542f, 0.01048155f, 0.08476540f, 0.01563902f, 0.13562906f, 0.03329961f, 
    0.03552866f, -0.06061649f, -0.04566696f, -0.06500433f, 0.02639379f, -0.00923895f, -0.10379680f, -0.03821030f, 
    -0.04337643f, -0.03008779f, 0.10949042f, 0.11058549f, -0.20288499f, -0.02219264f, 0.12243375f, 0.01312919f, 
    -0.30338958f, 0.01851536f, -0.01725493f, 0.11999234f, 0.35383976f, 0.17860778f, -0.01457378f, -0.00592145f, 
    0.13659720f, -0.02479820f, -0.04269912f, -0.02949927f, 0.04521292f, 0.06118170f, 0.17382126f, -0.04194261f, 
    0.02446307f, 0.09796239f, -0.07965332f, 0.08739450f, 0.07166260f, 0.24089938f, -0.32131201f, -0.03948496f, 
    0.10235599f, 0.11198985f, 0.18911792f, -0.19633333f, -0.10773115f, 0.00269992f, -0.00275302f, 0.07688887f, 
    0.06689950f, 0.16964990f, 0.17413913f, -0.12255610f, -0.07145681f, -0.07112035f, 0.10692342f, -0.21766829f, 
    -0.15792790f, -0.00164876f, 0.02721089f, 0.17274401f, -0.00852262f, 0.18840727f, 0.01327262f, 0.04106286f, 
    0.00252028f, -0.23528638f, -0.19020422f, -0.12880760f, 0.06284212f, 0.11616309f, -0.04435578f, 0.14204723f, 
    0.05552813f, -0.00258339f, 0.06074296f, -0.11009245f, 0.06775342f, -0.19404502f, -0.01891340f, 0.04571722f, 
    -0.00019475f, 0.06740002f, 0.12708084f, -0.07603714f, -0.20540100f, -0.01472355f, -0.03927547f, 0.10006832f, 
    0.08553778f, -0.08471157f, 0.08346698f, -0.34297770f, -0.34401384f, -0.06190744f, -0.08214846f, -0.01665318f, 
    0.08046118f, -0.12051111f, -0.02866726f, 0.10632268f, 0.30061632f, 0.00774216f, -0.04809802f, -0.10155658f, 
    0.15118323f, -0.04344523f, 0.07617170f, -0.02498665f, -0.05073221f, -0.06054147f, 0.14663938f, -0.10701123f, 
    -0.22889465f, -0.07907321f, -0.13501251f, -0.00106950f, -0.14082099f, 0.09203304f, -0.37617594f, -0.15224677f, 
    0.02628263f, -0.01287210f, 0.12788057f, -0.12888150f, -0.02395778f, -0.03267293f, -0.06256869f, 0.05367965f, 
    0.08681881f, 0.07547817f, -0.00552447f, 0.07949149f, -0.10814878f, -0.02324644f, 0.08069470f, 0.06914501f, 
    -0.18512870f, 0.16330847f, 0.05795804f, 0.07322214f, 0.06923681f, -0.00056352f, -0.05915963f, 0.07037423f, 
    -0.01027188f, -0.30279467f, -0.23018080f, -0.14352280f, 0.08275782f, -0.04431535f, 0.19007932f, -0.02498845f, 
    0.05924052f, 0.02475107f, 0.04320895f, 0.07186688f, -0.14218107f, 0.16900805f, 0.09084462f, -0.05820901f, 
    -0.10449535f, -0.06932135f, -0.08571456f, -0.02566346f, 0.13121872f, -0.07554987f, 0.10987245f, 0.10148374f, 
    -0.05190793f, 0.06427459f, -0.04936479f, -0.02029980f, -0.04547705f, 0.11191774f, 0.13422436f, 0.02619441f, 
    -0.08627877f, 0.03673483f, 0.08955151f, 0.06910784f, 0.16722392f, 0.07901274f, 0.11948720f, -0.02244987f, 
    0.01933292f, -0.09198561f, 0.06487070f, 0.09556751f, 0.03813319f, 0.18063793f, -0.31034148f, -0.05962481f, 
    0.04513916f, -0.08686547f, 0.01405178f, -0.01111939f, 0.02755846f, 0.01882938f, 0.03665264f, -0.46921927f, 
    -0.17620958f, -0.24488129f, 0.10469561f, -0.19540036f, -0.08031853f, 0.02680757f, -0.13239533f, 0.10936020f, 
    -0.41144067f, -0.03189224f, -0.05535252f, 0.20193696f, 0.06557493f, 0.04713564f, -0.10183739f, -0.10879377f, 
    0.00437860f, -0.02822446f, -0.10588501f, -0.09885324f, -0.06198587f, -0.02691437f, 0.15211865f, 0.04146720f, 
    0.12011760f, 0.04238019f, -0.09225546f, -0.09268866f, 0.12375097f, 0.05412448f, 0.05606741f, 0.14935972f, 
    -0.13912460f, -0.01394147f, -0.02002152f, -0.07979060f, 0.01971263f, -0.06425104f, -0.05207701f, -0.03229513f, 
    -0.08324315f, 0.08885275f, 0.05374193f, 0.01107369f, -0.18114364f, -0.20856349f, -0.18688469f, -0.06771932f, 
    0.15696232f, 0.14896019f, -0.07647300f, 0.10111210f, -0.11065244f, 0.17642204f, 0.13042061f, -0.00581739f, 
    -0.08282205f, 0.11160141f, 0.15916812f, 0.05130741f, 0.15676509f, -0.10615352f, -0.14337647f, 0.01601223f, 
    0.11116670f, -0.05815993f, 0.00305708f, 0.04207090f, 0.07238773f, 0.01553020f, 0.04341162f, 0.35142779f, 
    0.09248099f, 0.08681796f, -0.02821613f, 0.07708551f, -0.01751991f, -0.04177031f, 0.11215798f, -0.16280828f, 
    -0.13769871f, -0.12247864f, 0.17008848f, -0.06345129f, 0.10781323f, -0.06674886f, -0.10613078f, 0.03792970f, 
    -0.12179546f, 0.21225922f, 0.22212605f, -0.19629043f, -0.06760757f, -0.11648409f, 0.08567596f, -0.09548616f, 
    0.06247265f, 0.06230642f, -0.01359263f, -0.14719942f, 0.01077024f, -0.17733656f, -0.08261851f, 0.00670989f, 
    0.00587637f, -0.00716489f, -0.13957554f, -0.06767349f, 0.01276342f, 0.14788562f, 0.00804760f, -0.03664425f, 
    0.00693615f, -0.13674253f, 0.00823964f, -0.04539010f, 0.12626970f, 0.08522788f, -0.08801387f, 0.09413096f, 
    0.04110507f, -0.07305899f, -0.02417643f, 0.06180149f, 0.06620660f, -0.20427468f, -0.13241354f, -0.03293681f, 
    0.11282044f, -0.06446049f, 0.10398340f, -0.21407780f, 0.10333769f, -0.15837020f, -0.02005755f, -0.10072850f, 
    -0.11505979f, 0.10078637f, 0.13945195f, -0.09002259f, -0.11812993f, 0.00916130f, 0.05256366f, -0.20910805f, 
    -0.03511137f, -0.15707141f, 0.00859400f, 0.10361787f, -0.05045709f, 0.10908671f, -0.07960621f, 0.02525558f, 
    0.15151998f, -0.15406558f, 0.00339815f, -0.14973360f, -0.07225789f, 0.10868641f, -0.20200963f, 0.04482317f, 
    0.07217006f, -0.24622710f, -0.21098295f, 0.07936020f, -0.07288136f, -0.06090975f, 0.01813952f, 0.06613968f, 
    -0.04751516f, -0.05222281f, -0.06687102f, 0.04566596f, -0.13737412f, 0.07356250f, 0.17399238f, -0.01594026f, 
    0.15260278f, 0.06334576f, 0.19525386f, -0.43318036f, -0.18334001f, -0.22933051f, 0.12001341f, -0.01604602f, 
    0.04729299f, -0.12277441f, -0.07942125f, 0.10622507f, 0.29470488f, 0.30385670f, -0.03080839f, 0.02639633f, 
    -0.09196703f, -0.03009023f, 0.08814550f, 0.03494413f, -0.05498732f, -0.09213645f, 0.04599917f, -0.10691476f, 
    -0.03026710f, -0.07883389f, 0.07247057f, 0.14584669f, 0.03327231f, 0.09426732f, -0.12003218f, -0.10757893f, 
    -0.08377656f, 0.04549647f, -0.09866461f, -0.04304432f, 0.23152667f, 0.03579587f, 0.15122814f, -0.45572355f, 
    -0.08413447f, 0.15492682f, -0.00315680f, 0.14662427f, -0.02415801f, -0.07028672f, -0.02934192f, 0.04246050f, 
    -0.21833037f, 0.11637187f, -0.28556171f, 0.17987680f, -0.14229582f, 0.08532246f, -0.13340026f, -0.07997195f, 
    -0.10466755f, -0.32839119f, -0.15390594f, 0.01410902f, 0.08099517f, 0.02920874f, -0.01938906f, -0.03728950f, 
    -0.06687544f, 0.20550264f, -0.02674654f, 0.21863280f, 0.03272342f, 0.01662749f, -0.01817125f, -0.05569077f, 
    0.07062176f, -0.05783575f, -0.06912259f, -0.02050230f, 0.00668420f, -0.12678623f, 0.02039665f, -0.03882835f, 
    0.09818773f, 0.15515637f, 0.11040907f, 0.02137836f, 0.10402795f, -0.02295666f, -0.09183832f, 0.05792687f, 
    -0.00609036f, -0.09426997f, -0.04142429f, 0.08351054f, -0.08201287f, -0.03486551f, -0.00672810f, -0.00434877f, 
    -0.04504103f, 0.05428632f, -0.04761083f, -0.00035231f, 0.03931789f, 0.01156609f, -0.30397183f, -0.03586262f, 
    0.00047392f, 0.02680331f, 0.01563209f, 0.11035478f, 0.23668516f, -0.04757275f, 0.09807430f, -0.24799348f, 
    0.00795389f, 0.01034405f, -0.05364227f, -0.00217561f, -0.07449583f, 0.02599003f, -0.08870248f, 0.06768055f, 
    -0.18417533f, 0.16704106f, -0.03548458f, 0.09366841f, -0.11845037f, 0.07447170f, 0.04585839f, -0.07726298f, 
    -0.15481286f, -0.09293097f, -0.07818451f, -0.28437808f, 0.16762564f, 0.05296152f, 0.07959677f, 0.09240150f, 
    0.01305047f, 0.10392343f, -0.01470341f, 0.14477263f, 0.16839048f, -0.04841086f, 0.00556634f, -0.03140742f, 
    -0.06773923f, 0.11409353f, 0.10346629f, 0.02588855f, 0.02791965f, -0.00784723f, -0.03063279f, 0.02238414f, 
    0.09053180f, 0.16611993f, 0.35553020f, -0.00667075f, -0.13427588f, -0.27973706f, 0.26544064f, -0.04860126f, 
    -0.08098492f, 0.03578874f, 0.05720547f, 0.09041109f, -0.04991679f, 0.08046131f, 0.22965612f, 0.10906465f, 
    0.00978938f, -0.19095971f, 0.10331108f, 0.03055953f, 0.04709069f, -0.14862640f, 0.12196887f, -0.15100831f, 
    0.14553235f, 0.07727066f, 0.15031359f, -0.03603875f, 0.03214059f, 0.08970999f, -0.11381997f, 0.19507633f, 
    0.15402870f, 0.15275258f, -0.02603345f, -0.05487034f, -0.02858339f, 0.18483323f, -0.01326209f, -0.05654062f, 
    -0.35202008f, 0.11048780f, 0.02718809f, 0.08979426f, 0.11483088f, -0.03169655f, 0.08414276f, 0.12435976f, 
    -0.09818143f, 0.02328303f, 0.02371703f, 0.26422715f, -0.15858535f, -0.05264302f, 0.10172150f, -0.13358352f, 
    0.17368405f, 0.24047771f, -0.23581986f, -0.21751481f, -0.19346701f, 0.09583940f, 0.01291543f, -0.06326301f, 
    -0.12403028f, 0.11418676f, -0.00576087f, -0.06410610f, 0.00836069f, 0.11422267f, -0.03286241f, 0.07286816f, 
    -0.02523410f, -0.01811898f, 0.23651366f, -0.01323800f, -0.27190322f, -0.21726617f, -0.01134940f, 0.22630247f, 
    0.16474482f, 0.08954404f, 0.01410153f, -0.01962501f, -0.21757723f, -0.27286682f, -0.16478322f, 0.24188806f, 
    -0.22383614f, -0.12022175f, 0.08588038f, -0.01822788f, -0.00733937f, 0.04911170f, 0.18678701f, 0.08288665f, 
    0.09718286f, -0.03112187f, 0.11901538f, 0.10435014f, 0.17417145f, 0.00420839f, 0.10214156f, -0.17753999f, 
    0.05266169f, 0.06102166f, 0.09056260f, 0.01913111f, 0.01292996f, 0.13073763f, -0.01951209f, 0.00803297f, 
    -0.08254623f, -0.00754107f, -0.23482156f, -0.02396714f, -0.03882327f, -0.00041499f, 0.15383628f, -0.07023477f, 
    0.10357226f, -0.42220449f, -0.25151446f, -0.15328826f, -0.00903197f, -0.02509572f, -0.17232160f, -0.04449691f, 
    -0.05166947f, 0.05783399f, -0.24620728f, 0.00581649f, -0.05408712f, 0.09937224f, 0.08277044f, 0.04778065f, 
    -0.01996931f, 0.06103808f, -0.03319300f, -0.31508785f, 0.15672652f, 0.13836385f, -0.09718432f, -0.01823668f, 
    0.10096466f, -0.02697270f, -0.03346816f, -0.16178507f, 0.08992200f, 0.01161250f, -0.22207606f, 0.15997747f, 
    0.11952155f, 0.01863289f, 0.07082296f, -0.17222972f, -0.07910599f, -0.10574715f, -0.21560259f, -0.00230539f, 
    0.04187157f, -0.02579425f, 0.04835460f, 0.00364031f, -0.06010093f, -0.05534206f, -0.03511557f, 0.02551856f, 
    -0.01001081f, -0.17360273f, -0.00740876f, -0.02568201f, 0.00723447f, -0.11782708f, -0.11359077f, 0.38771772f, 
    -0.01107314f, -0.17535210f, -0.05095952f, 0.03285059f, 0.02460564f, -0.02123795f, 0.04440652f, 0.16911952f, 
    0.14628774f, 0.26064172f, 0.35530624f, 0.03993569f, -0.03743184f, 0.01837394f, 0.05830722f, -0.00689385f, 
    0.10300665f, -0.02306863f, 0.21382268f, 0.23555408f, -0.03046079f, -0.01157509f, -0.00167247f, -0.12209923f, 
    0.11274633f, 0.14411542f, 0.12348574f, 0.09770280f, -0.17878610f, 0.07252870f, -0.10993040f, -0.10475644f, 
    0.05081907f, -0.04925320f, 0.06583320f, -0.14368039f, 0.02405610f, 0.04170806f, 0.10282129f, 0.13399915f, 
    -0.18797149f, 0.13386017f, 0.00487191f, -0.01051474f, -0.19546238f, -0.14311334f, 0.18075067f, 0.13540694f, 
    0.09933380f, -0.04173196f, 0.12122899f, 0.11331327f, -0.07743590f, 0.10350328f, 0.03274455f, -0.06189429f, 
    0.08409598f, 0.16886638f, 0.02600792f, 0.08127750f, -0.09264243f, -0.04188449f, 0.03185802f, 0.06352893f, 
    -0.03759229f, 0.02129469f, 0.01510422f, 0.13035704f, 0.12180466f, 0.09107561f, 0.00325586f, -0.36435059f, 
    -0.08792382f, -0.05585108f, -0.10751595f, -0.10131096f, -0.02969813f, -0.17424601f, -0.02672839f, 0.13958466f, 
    -0.06449507f, 0.13769607f, 0.24674237f, -0.27451715f, 0.03813575f, -0.06247130f, -0.06319318f, 0.04669295f, 
    0.01283606f, -0.06892218f, 0.15604793f, 0.05507253f, -0.01435449f, 0.04444486f, -0.05034976f, 0.10472302f, 
    0.13529569f, 0.09685535f, 0.01389147f, 0.01581760f, 0.06519334f, -0.02776259f, 0.14469428f, 0.08185118f, 
    -0.07676168f, 0.04980060f, 0.15024087f, -0.10467368f, -0.06847832f, -0.05799231f, 0.00301734f, 0.05975263f, 
    -0.07516801f, 0.06309988f, 0.07425372f, 0.03463915f, 0.10834726f, 0.00567909f, 0.09698401f, -0.14454682f, 
    -0.18001278f, -0.24878584f, -0.21395247f, -0.02475080f, -0.01403822f, -0.13599728f, -0.01369184f, -0.08577280f, 
    0.07062846f, -0.01147721f, 0.09309702f, 0.02537988f, 0.16830626f, -0.02730470f, -0.21720235f, -0.19408876f, 
    -0.27441421f, 0.05932428f, 0.03323872f, 0.04571781f, -0.07386634f, -0.14319135f, 0.06703772f, 0.11645354f, 
    -0.21416546f, -0.24470650f, 0.21453135f, 0.16452983f, 0.12532194f, -0.11828575f, -0.08942273f, -0.16337536f, 
    0.45163763f, 0.11503491f, -0.14311978f, -0.10109174f, -0.10701441f, 0.02740342f, 0.06320255f, 0.09068307f, 
    0.14111501f, -0.23573104f, 0.07042293f, 0.33054844f, 0.16780688f, 0.00141926f, -0.22257668f, 0.00044793f, 
    0.09544930f, -0.26485386f, 0.02552049f, 0.00735322f, 0.15060356f, -0.09334804f, -0.06981622f, -0.10946188f, 
    -0.05663922f, 0.05693263f, 0.09727665f, 0.22893608f, 0.04554995f, 0.31379488f, -0.14465728f, 0.04474403f, 
    -0.32194176f, 0.06883861f, -0.03920348f, -0.08367490f, 0.13393492f, -0.00630420f, 0.13142751f, -0.00283046f, 
    -0.05232376f, -0.00802021f, 0.14636731f, 0.03034252f, -0.13389768f, -0.22561832f, -0.03388394f, 0.19638292f, 
    0.18717262f, 0.01964823f, 0.11512219f, 0.01050322f, 0.05563141f, 0.16333674f, 0.06156605f, -0.12039623f, 
    -0.03521268f, -0.00063129f, 0.14961255f, 0.04001750f, -0.05101623f, -0.03228599f, 0.07914643f, -0.32360712f, 
    0.14445408f, 0.17963947f, 0.11243328f, 0.19030496f, -0.15912153f, 0.16096200f, 0.13918546f, -0.09584939f, 
    -0.20065457f, -0.36661008f, -0.06408543f, 0.15709174f, -0.14597651f, -0.17087749f, 0.11178077f, -0.05431583f, 
    0.08131291f, 0.03903100f, -0.07829496f, 0.17794858f, 0.13644876f, -0.26168802f, -0.27314404f, 0.02886279f, 
    -0.09893869f, -0.11867687f, -0.15377675f, -0.19035013f, 0.08705229f, 0.00399506f, -0.15478624f, -0.07478464f, 
    -0.10639396f, -0.15501074f, 0.05039502f, -0.26430753f, 0.13895084f, 0.22249828f, 0.00571434f, 0.16853862f, 
    0.04671430f, 0.05276645f, 0.09593311f, -0.20778720f, 0.03113631f, -0.31548241f, -0.08082040f, 0.06507940f, 
    -0.01916183f, -0.11011937f, -0.01219187f, -0.03806459f, 0.03208864f, 0.34138653f, -0.05169544f, -0.01955923f, 
    -0.05392543f, -0.13905400f, -0.09295563f, 0.05449037f, -0.06734604f, -0.16483454f, -0.02358985f, 0.16447563f, 
    0.30141461f, -0.06796457f, 0.03742936f, 0.10242184f, 0.06181446f, 0.04994714f, 0.09521445f, 0.21010394f, 
    0.02698512f, -0.06851037f, 0.09624239f, 0.06696640f, -0.08675339f, 0.01617195f, 0.03890520f, 0.06134989f, 
    -0.17970715f, 0.37606314f, 0.28134239f, -0.04436547f, 0.01587268f, 0.13786204f, 0.08807515f, -0.05401270f, 
    0.04362516f, -0.26041633f, 0.19241565f, 0.19173981f, -0.03283055f, 0.06159688f, -0.00412926f, 0.10312744f, 
    -0.06720232f, -0.12137716f, -0.03702248f, -0.18990552f, -0.16653338f, 0.08160739f, 0.03280390f, 0.07884718f, 
    -0.02573414f, -0.00017058f, -0.05643336f, 0.43645814f, -0.16367035f, -0.13927376f, -0.10560640f, -0.05269613f, 
    -0.02936516f, 0.11574763f, 0.00277857f, -0.05025296f, 0.03052954f, 0.05982329f, -0.03652661f, -0.09741896f, 
    0.01733826f, 0.03334694f, 0.06859296f, 0.07236330f, 0.04450651f, 0.22412378f, -0.18953481f, -0.03015639f, 
    -0.08982307f, -0.10348932f, 0.05261724f, 0.05351814f, -0.17210530f, -0.01076186f, -0.04514340f, -0.01265349f, 
    -0.02604797f, 0.03007258f, -0.01322343f, -0.03877971f, -0.19774596f, -0.07303274f, 0.02843610f, -0.45126539f, 
    0.11165158f, -0.05315942f, 0.08318936f, 0.03497680f, -0.08098245f, -0.01502394f, 0.01782101f, 0.12151915f, 
    -0.07267647f, 0.06701224f, 0.27272624f, 0.08390396f, 0.26508334f, -0.12545381f, -0.10320509f, 0.05404450f, 
    0.02568807f, -0.18537067f, -0.07240609f, 0.09554686f, 0.13210939f, -0.16843958f, 0.08397407f, 0.21654546f, 
    0.06060701f, 0.10130767f, 0.12493424f, 0.23319545f, 0.13122052f, 0.15142860f, 0.15361957f, -0.00679983f, 
    -0.06237892f, -0.03418864f, 0.01129095f, -0.03118148f, -0.03055087f, -0.12782529f, 0.05351395f, 0.06793619f, 
    0.01807429f, -0.12505861f, 0.03485636f, 0.09252968f, -0.30409327f, 0.07370022f, -0.04949122f, 0.19541603f, 
    -0.00202634f, -0.00859753f, 0.04696746f, 0.04777599f, -0.18581653f, 0.07071859f, -0.34798375f, -0.02213651f, 
    -0.04664604f, -0.02192844f, -0.15631582f, -0.01947717f, -0.02630102f, 0.04958657f, -0.12000269f, -0.17178632f, 
    -0.01279537f, -0.02671704f, 0.00539421f, -0.05865717f, 0.07990710f, -0.08420341f, 0.23719205f, 0.17495288f, 
    -0.37625635f, -0.17898990f, -0.22199915f, -0.19288675f, -0.03775850f, -0.02029754f, -0.03575727f, 0.13972661f, 
    -0.21614686f, -0.07983226f, -0.49041113f, 0.09733397f, 0.19405749f, 0.09375547f, -0.06313255f, 0.04931837f, 
    -0.04548289f, -0.10413637f, -0.12962954f, -0.17072688f, 0.05858416f, -0.14649326f, 0.23333248f, -0.10994569f, 
    -0.32523021f, 0.03743066f, -0.14352275f, 0.15285859f, -0.24594058f, 0.25623897f, 0.03338815f, 0.11570963f, 
    0.06547431f, -0.20773068f, -0.04975611f, -0.09216504f, -0.13243249f, -0.22959036f, 0.17374866f, 0.24251181f, 
    0.20425433f, -0.12968408f, -0.13427094f, 0.01102206f, 0.30744702f, 0.22812125f, -0.19215038f, 0.02751391f, 
    -0.00099580f, 0.22002286f, 0.08445206f, 0.06679094f, -0.06228365f, 0.13977972f, -0.17522612f, 0.00822310f, 
    0.35907802f, -0.05463104f, -0.17608452f, -0.03697097f, -0.25788122f, -0.19385377f, -0.16251238f, 0.16749884f, 
    -0.01110868f, 0.07194119f, 0.10983108f, -0.18302974f, 0.07238638f, 0.11795516f, -0.17422226f, 0.03249838f, 
    0.06818257f, 0.15184075f, 0.12774758f, -0.16282950f, -0.07864738f, 0.01639913f, 0.22110736f, 0.10096884f, 
    0.26659387f, 0.24591106f, -0.09907401f, 0.10474730f, -0.19411930f, 0.08212399f, -0.02710456f, 0.04107251f, 
    0.06593902f, 0.28644210f, -0.08615766f, -0.17501341f, 0.08417960f, -0.01164944f, 0.20010458f, 0.00655540f, 
    -0.11871555f, -0.10915995f, 0.35051274f, -0.18344738f, 0.10312541f, -0.31385592f, 0.01625563f, -0.19533224f, 
    0.16626491f, 0.08973859f, 0.13352181f, -0.04732473f, -0.09469663f, 0.20302007f, 0.07449649f, 0.09850132f, 
    -0.11856868f, 0.18542676f, -0.03651468f, 0.19837570f, 0.13552152f, 0.22312975f, -0.05736384f, -0.41510862f, 
    0.00047080f, -0.17344157f, -0.08858622f, 0.14801201f, -0.07701241f, -0.16752182f, 0.30495799f, -0.07776284f, 
    0.03547272f, -0.13580215f, -0.02971055f, 0.06578130f, 0.00947229f, 0.09514082f, -0.43782616f, -0.02156397f, 
    0.02535734f, 0.30906218f, -0.03909897f, 0.01344841f, 0.12912042f, -0.12942708f, 0.11767492f, -0.41483447f, 
    0.24370097f, 0.18897292f, 0.14860582f, 0.16315717f, -0.09444988f, 0.00730977f, 0.27838278f, -0.28327337f, 
    -0.00902400f, -0.09478084f, 0.14474528f, 0.11969389f, 0.11519189f, 0.14154032f, -0.03616437f, 0.09251640f, 
    0.02483600f, 0.06476372f, -0.18304148f, 0.22371623f, -0.05197442f, 0.02447569f, -0.07119842f, -0.19381386f, 
    0.06430334f, 0.29738685f, -0.06320557f, 0.05442584f, -0.09322386f, -0.07815758f, 0.00687322f, -0.11986370f, 
    -0.10240722f, 0.05322728f, 0.05412085f, -0.43970373f, -0.11735450f, -0.29271793f, -0.01579953f, 0.11250591f, 
    -0.04054623f, -0.19056301f, -0.08426834f, -0.02764024f, -0.00168911f, 0.14461929f, -0.20477761f, 0.00396011f, 
    0.14707033f, 0.27628276f, -0.10942794f, 0.09864544f, -0.09929617f, -0.02652992f, 0.08872860f, 0.07884941f, 
    -0.25873855f, -0.15642786f, -0.18346418f, 0.11499107f, 0.11213308f, 0.05847672f, -0.21927322f, 0.04557599f, 
    0.23886642f, 0.04091709f, 0.19435681f, -0.10098495f, 0.17971104f, 0.10916805f, 0.15454148f, 0.21639900f, 
    0.01410895f, -0.20548834f, -0.03521554f, -0.09371316f, -0.06699441f, 0.14449996f, 0.16168028f, 0.16407149f, 
    0.00450754f, -0.01114128f, 0.25422847f, 0.15273228f, 0.00309284f, -0.08291040f, 0.04737447f, -0.08514716f, 
    0.19585153f, -0.16718997f, -0.11890519f, 0.26778898f, 0.09201981f, 0.04682913f, -0.05817130f, -0.09532515f, 
    0.15904818f, 0.07508470f, 0.17300342f, -0.14307672f, -0.09391654f, 0.15406451f, 0.09191847f, -0.02921299f, 
    0.05039144f, 0.06269822f, 0.16346003f, 0.14753041f, -0.09429158f, -0.10233793f, -0.05623726f, 0.00066410f, 
    0.13976860f, 0.10462134f, 0.07971847f, 0.08265003f, 0.32328174f, -0.45435005f, -0.19974415f, 0.14367576f, 
    -0.07422394f, 0.16437478f, 0.07887314f, -0.21963567f, 0.13175204f, -0.11530649f, -0.12480229f, -0.19751459f, 
    -0.08810292f, 0.04331265f, -0.03710039f, -0.01843548f, 0.00709336f, -0.07424842f, 0.23303485f, 0.07481088f, 
    0.35167170f, 0.13951150f, -0.00028710f, -0.13265771f, -0.03949494f, -0.02482040f, 0.10764202f, -0.02227943f, 
    -0.15633088f, -0.10793316f, -0.24050203f, 0.08487564f, -0.24240080f, 0.00528454f, -0.08219151f, -0.21302663f, 
    0.33470944f, 0.01781710f, -0.04259797f, 0.01158320f, -0.17632970f, -0.03753607f, 0.05339373f, -0.05730048f, 
    0.12501675f, 0.18090251f, -0.07547005f, 0.05859944f, 0.10101502f, 0.03144133f, 0.01433802f, 0.01640606f, 
    -0.21554790f, 0.00280045f, 0.29511517f, 0.18862763f, -0.18475872f, -0.19098188f, 0.03381155f, -0.11649511f, 
    -0.01023792f, 0.16182749f, -0.11341626f, 0.00460884f, 0.29410207f, 0.09819030f, 0.11876110f, 0.16126332f, 
    -0.04159238f, 0.17264102f, -0.05080289f, -0.08784486f, 0.00478373f, 0.07167859f, -0.16538353f, -0.01491591f, 
    -0.05588465f, -0.17058416f, -0.00658954f, 0.04527694f, -0.06681859f, 0.20542939f, -0.12540062f, 0.00656505f, 
    0.13359872f, 0.04000529f, 0.02726978f, -0.07083676f, -0.09507994f, -0.15654694f, -0.22888595f, -0.08429901f, 
    0.18777607f, 0.01400336f, 0.08577520f, 0.13108912f, -0.11194968f, 0.02309641f, -0.05311928f, -0.34052187f, 
    -0.07681902f, -0.04241161f, 0.03244351f, 0.15324469f, 0.08778971f, 0.02010952f, 0.09562822f, -0.07530221f, 
    0.15131314f, -0.20228058f, -0.00244863f, -0.05031301f, -0.05345811f, 0.08851985f, -0.09517013f, 0.00401016f, 
    -0.21609975f, 0.16549700f, -0.07235371f, 0.03332793f, -0.08028676f, -0.14144942f, -0.14485255f, 0.28894198f, 
    0.10067765f, 0.06173759f, -0.03898301f, 0.04540121f, -0.08913033f, 0.08826208f, 0.10428195f, -0.01066227f, 
    -0.09150716f, 0.08429006f, -0.08152813f, -0.49899521f, -0.43084085f, 0.02485366f, 0.08735934f, 0.02963620f, 
    0.14313577f, 0.20705321f, -0.02230006f, -0.04788883f, 0.13373059f, 0.05862005f, -0.06095620f, -0.05528335f, 
    0.05516047f, 0.06087582f, -0.19068693f, 0.16770706f, 0.08176573f, 0.02511144f, 0.01445983f, 0.01164647f, 
    -0.00143101f, 0.02955935f, 0.16344859f, 0.05250247f, 0.03605816f, 0.00480914f, -0.21042469f, -0.33539686f, 
    0.07194250f, 0.04203571f, 0.10938625f, 0.00214585f, -0.05698832f, 0.06055508f, -0.06411552f, -0.35607082f, 
    -0.09039676f, -0.10332743f, 0.08730799f, 0.01244978f, -0.00864885f, 0.08363765f, 0.04259146f, -0.29578683f, 
    -0.01720421f, -0.12440078f, 0.07811040f, 0.17713246f, -0.01163452f, 0.04936359f, 0.02460952f, -0.07790492f, 
    0.02485148f, -0.03767273f, -0.29660290f, 0.08392553f, 0.01412769f, -0.02240115f, -0.03710606f, -0.00603788f, 
    0.02076223f, 0.06281298f, -0.12673056f, 0.09608025f, 0.04209777f, 0.01242486f, -0.10185308f, 0.01804238f, 
    -0.00149866f, 0.01416583f, 0.03181908f, 0.11386192f, 0.08590467f, 0.10372103f, 0.00134208f, 0.01196820f, 
    0.01285464f, -0.16565502f, -0.03371174f, 0.04702890f, -0.04480786f, 0.07343011f, -0.11794673f, -0.00774515f, 
    0.06606233f, -0.04865622f, 0.02773740f, 0.06359830f, 0.03348511f, -0.04160954f, 0.20533365f, -0.09874606f, 
    0.11795811f, -0.02303631f, 0.02132001f, 0.00807009f, 0.13779239f, 0.01608162f, -0.35214698f, -0.17016383f, 
    -0.15774597f, 0.05377831f, -0.01982168f, 0.01633058f, 0.13135475f, -0.00550968f, -0.16990505f, -0.25336009f, 
    -0.05317706f, -0.09085391f, 0.06112340f, -0.07871608f, -0.08194658f, 0.06193040f, 0.17850868f, -0.06622389f, 
    -0.08027301f, -0.34849671f, 0.11833213f, 0.09753327f, 0.06507372f, 0.10160469f, 0.08478904f, -0.00983460f, 
    -0.10229439f, -0.11170675f, -0.16480140f, 0.00091739f, -0.10594966f, 0.07272987f, 0.09710652f, 0.12322392f, 
    0.15489946f, 0.00796167f, 0.06808285f, 0.15208384f, 0.21001767f, 0.03357900f, -0.02154047f, -0.02219907f, 
    0.07304175f, -0.10733993f, 0.02983727f, 0.25859380f, 0.15248242f, 0.05203890f, -0.16529407f, 0.00666262f, 
    0.06301033f, -0.06537060f, 0.12168245f, 0.03378424f, 0.00649223f, 0.05685217f, -0.08570460f, -0.02661461f, 
    0.12731311f, -0.04662458f, -0.17656918f, 0.06008644f, 0.04346570f, 0.06446066f, 0.12938498f, -0.02790443f, 
    -0.14090054f, -0.03260835f, 0.04442183f, -0.00006038f, -0.04969810f, 0.07993727f, 0.01452156f, -0.14434791f, 
    0.10918992f, -0.07667176f, -0.20173709f, -0.19988172f, 0.08505484f, -0.08620009f, -0.11310410f, 0.05821395f, 
    0.15256482f, 0.06423043f, -0.04800318f, 0.04897433f, -0.14811422f, 0.00256734f, 0.22258167f, 0.06090584f, 
    0.04113834f, -0.05542802f, 0.03577625f, 0.04419060f, 0.00854932f, -0.01772363f, -0.00653492f, 0.02840004f, 
    -0.03631592f, -0.02774813f, -0.01185177f, 0.00168994f, -0.01208058f, -0.00354821f, -0.00610327f, 0.03188254f, 
    -0.00297966f, -0.06650136f, -0.01510186f, -0.01822270f, -0.05289266f, -0.02503487f, -0.03108723f, 0.04557235f, 
    -0.04308351f, 0.00280094f, -0.03083303f, 0.02822703f, -0.00957808f, -0.04925326f, -0.05257658f, -0.01577163f, 
    0.02889497f, 0.02729144f, 0.01999808f, 0.02604741f, 0.02099325f, -0.05185914f, -0.04501262f, -0.01947662f, 
    -0.02209578f, 0.00114065f, -0.00107945f, -0.01367749f, -0.04379981f, 0.01489949f, -0.05594647f, 0.03968082f, 
    -0.02949204f, -0.01972221f, 0.02618729f, 0.04489783f, 0.04301882f, 0.03057231f, 0.03085076f, 0.00999007f, 
    -0.03062053f, -0.05764317f, -0.03101719f, -0.00778609f, -0.03224680f, 0.00812377f, 0.02812997f, 0.01773454f, 
    -0.04632740f, 0.03831058f, 0.03725334f, -0.03218029f, -0.03964114f, -0.05899714f, -0.04996821f, -0.03084859f, 
    -0.05538648f, -0.02449720f, 0.00500723f, 0.01706399f, -0.04746442f, -0.02455759f, 0.00309592f, -0.04648902f, 
    0.02061472f, -0.05626938f, 0.02591748f, 0.00469956f, -0.00585942f, -0.00825731f, 0.00967858f, 0.03893743f, 
    0.04992982f, -0.00564795f, -0.06797367f, -0.00644541f, -0.05925137f, 0.02815307f, -0.05744408f, 0.02739401f, 
    0.00856978f, -0.07141497f, -0.03929671f, -0.00819792f, 0.04719080f, -0.02291639f, 0.01941964f, 0.01613453f, 
    0.03361427f, 0.05016541f, -0.06452905f, -0.02858637f, 0.03943552f, -0.05393708f, -0.01700425f, -0.05108804f, 
    0.02781545f, -0.03917733f, -0.01976717f, -0.01227033f, -0.01871895f, -0.00535857f, -0.02881140f, -0.02930588f, 
    -0.00252524f, -0.03711928f, -0.02762922f, 0.00014997f, 0.05031247f, 0.03232328f, -0.04582061f, 0.04877656f, 
    -0.01319031f, -0.04882754f, 0.02407467f, 0.03375931f, 0.05100191f, 0.00450311f, 0.04789839f, -0.06035067f, 
    0.01550154f, -0.05486508f, -0.05458818f, 0.01570695f, 0.04760802f, 0.01532378f, 0.00109935f, 0.01542526f, 
    -0.02100552f, -0.00085376f, 0.02437269f, -0.00430072f, -0.00839698f, -0.02137166f, -0.02895776f, 0.00209799f, 
    0.04734267f, -0.04012256f, -0.05344196f, 0.02203435f, -0.02606808f, -0.00617202f, 0.04852992f, 0.03879102f, 
    0.01600313f, 0.02294272f, 0.02994636f, 0.03171770f, -0.05461558f, -0.04083464f, -0.05841325f, 0.01959320f, 
    -0.02874682f, 0.01787312f, -0.03643482f, -0.04820061f, 0.00579809f, 0.01507489f, -0.02544167f, -0.06575178f, 
    0.00540468f, 0.04398820f, -0.06459476f, -0.03812731f, -0.00392371f, -0.02180117f, -0.04775883f, -0.02231956f, 
    0.04370191f, 0.00294524f, -0.02620624f, -0.06572822f, -0.07250763f, -0.06310443f, -0.00685580f, 0.03608013f, 
    -0.05824506f, 0.01931280f, 0.04338704f, 0.01182669f, 0.01602698f, -0.03363855f, -0.03033541f, -0.04709169f, 
    0.00888608f, -0.03582223f, -0.00515010f, 0.02536716f, 0.00664961f, -0.03201108f, -0.04551079f, -0.05910844f, 
    -0.05903053f, 0.03831802f, -0.06891458f, -0.07154308f, -0.00002878f, 0.02152314f, -0.00705929f, -0.06652596f, 
    -0.00529363f, -0.00107986f, 0.01738024f, -0.01691832f, 0.01666620f, 0.01030974f, 0.03970297f, 0.03413818f, 
    -0.05375737f, -0.00816417f, 0.00068665f, -0.06460226f, -0.03244893f, -0.06268842f, 0.02619628f, -0.07074928f, 
    -0.00682972f, -0.02382250f, -0.03376286f, -0.02885493f, 0.04673846f, -0.06442235f, -0.01988204f, -0.06895667f, 
    0.04525644f, 0.03935573f, 0.04412300f, 0.00064968f, 0.02586866f, 0.04730718f, 0.01854102f, 0.00220701f, 
    -0.03595867f, 0.01420500f, -0.05500924f, 0.03100910f, -0.00740216f, -0.07457010f, -0.05998238f, -0.05577929f, 
    -0.02939731f, 0.03722539f, -0.03573529f, 0.04543092f, -0.01262787f, -0.00818111f, 0.00007506f, -0.02440331f, 
    -0.00355576f, -0.06695486f, -0.03025647f, -0.00687490f, -0.00180526f, 0.02050652f, 0.03694038f, 0.02947892f, 
    -0.02583713f, -0.06240124f, -0.05180194f, 0.03107822f, 0.00484354f, -0.02442369f, -0.03381987f, -0.00520542f, 
    0.01115005f, -0.03674163f, 0.00096146f, -0.06575137f, -0.05507477f, -0.04781299f, 0.05317444f, -0.04446512f, 
    0.03340428f, 0.05871145f, 0.08225688f, -0.07668080f, 0.07579611f, 0.32613313f, 0.15005603f, -0.02489063f, 
    0.14576295f, -0.07635665f, 0.02734249f, -0.17607942f, 0.07135793f, 0.01257734f, -0.28437927f, 0.15700720f, 
    0.03881448f, -0.16410917f, -0.11521847f, 0.04947656f, 0.22981441f, -0.05618697f, 0.08074732f, -0.02252357f, 
    0.10202267f, 0.09016861f, -0.11671440f, 0.08940950f, -0.02433031f, 0.12050297f, -0.06664705f, -0.09474131f, 
    -0.04459798f, 0.09157091f, 0.11032456f, 0.09285580f, 0.04978199f, 0.04301694f, 0.16909772f, -0.09317619f, 
    0.13799052f, -0.21367136f, -0.01935090f, -0.05013001f, -0.10196371f, -0.02126772f, 0.01653788f, -0.03792133f, 
    -0.24174626f, -0.01183252f, 0.10670385f, -0.03289888f, 0.26279119f, -0.31948629f, -0.08277829f, -0.03768936f, 
    -0.11062182f, -0.05172629f, 0.05693399f, 0.18465286f, 0.11057509f, 0.05528943f, -0.25508979f, 0.17203766f, 
    0.13149275f, -0.12846956f, 0.12837408f, 0.08331513f, 0.00978726f, -0.07241140f, -0.09113910f, 0.05471507f, 
    0.21009165f, 0.21132213f, -0.20389751f, 0.10627547f, -0.05480009f, 0.03797586f, 0.10673066f, -0.13420254f, 
    -0.17913219f, -0.08566563f, -0.01565098f, 0.10571609f, 0.12462070f, -0.02603528f, -0.01439099f, 0.11171391f, 
    0.07678944f, -0.10133603f, 0.20571393f, 0.08271124f, 0.07313110f, 0.23442993f, 0.04287784f, 0.05641094f, 
    -0.19487643f, 0.15067689f, -0.10673065f, -0.02282925f, -0.25885120f, -0.15418646f, -0.03852257f, 0.02920120f, 
    0.03659690f, -0.01639911f, -0.16169772f, -0.24903198f, -0.18369159f, -0.22244133f, 0.15930274f, 0.08908171f, 
    0.09879997f, -0.03677446f, -0.28771263f, 0.03141887f, -0.10956676f, -0.07078377f, 0.42691362f, -0.18433112f, 
    0.07228223f, 0.04361727f, 0.11849372f, 0.09847227f, -0.04268179f, -0.28220063f, -0.01874232f, -0.19396466f, 
    -0.21917810f, 0.03034521f, 0.09289571f, 0.08002015f, -0.00407559f, -0.11865705f, -0.31939283f, -0.02656457f, 
    0.15898763f, -0.01206992f, 0.02438818f, -0.03619974f, 0.12608066f, 0.05368156f, -0.02926643f, -0.17784572f, 
    0.08977573f, 0.04488803f, -0.12974571f, -0.06916807f, 0.04402609f, 0.13131554f, 0.13354750f, -0.01114289f, 
    0.10264526f, 0.03807022f, 0.01182663f, 0.03678158f, 0.00317174f, -0.09794352f, 0.03173778f, 0.06707420f, 
    -0.11386835f, 0.04132688f, -0.07241134f, -0.11560433f, -0.07202664f, -0.02980170f, 0.00674864f, 0.19756746f, 
    -0.13330516f, -0.08540647f, 0.16445448f, 0.01285690f, -0.04908568f, -0.01815181f, 0.09071568f, -0.20649612f, 
    0.11860733f, -0.03083146f, 0.01708590f, -0.06776967f, 0.00939624f, 0.16146216f, 0.24205206f, 0.07696213f, 
    -0.07993243f, 0.01781583f, -0.06103214f, 0.03104918f, 0.03492782f, 0.09783188f, -0.03206028f, 0.05563213f, 
    0.16501223f, 0.08684097f, 0.12737985f, -0.09730115f, 0.01122714f, -0.01726478f, 0.07841358f, -0.23660749f, 
    -0.14526010f, -0.04613092f, 0.15134071f, -0.10509882f, -0.02191076f, -0.11762386f, -0.13380462f, -0.32370853f, 
    0.01807803f, -0.05105651f, -0.21616906f, -0.07472879f, 0.09410357f, 0.02625560f, -0.08729998f, -0.23334748f, 
    0.05594602f, -0.20886585f, -0.11685892f, 0.08519971f, -0.15453620f, -0.11170111f, -0.01452684f, -0.08542100f, 
    -0.15425582f, 0.24754182f, -0.10701037f, -0.13771068f, 0.06179231f, -0.07641507f, 0.29309797f, 0.05462545f, 
    0.02176252f, -0.14156725f, -0.09187667f, 0.27480245f, -0.03970674f, -0.07292043f, -0.15034661f, -0.03059113f, 
    -0.07023606f, 0.18805888f, 0.11689018f, 0.09281456f, 0.24674848f, -0.00046912f, 0.06159066f, 0.02318494f, 
    0.07756783f, -0.00485703f, 0.08364057f, 0.08109587f, 0.07323197f, 0.15230593f, -0.05364409f, 0.09282111f, 
    -0.07419747f, -0.30240721f, 0.14853109f, 0.18977709f, 0.02543371f, -0.05405698f, -0.15746647f, 0.20223868f, 
    0.06704629f, -0.04498791f, 0.06705460f, -0.21678048f, 0.00948009f, 0.32515725f, -0.44417268f, 0.05085686f, 
    0.06200280f, -0.13116300f, -0.06985044f, -0.02224914f, 0.00688844f, -0.09667511f, -0.08582691f, -0.30778399f, 
    0.02908295f, 0.21045354f, 0.09341103f, 0.00008907f, 0.10765611f, -0.13944304f, 0.04041185f, 0.18828370f, 
    -0.12745081f, -0.49369669f, 0.02252091f, -0.16907744f, -0.00710429f, -0.03447442f, -0.08035795f, -0.05502030f, 
    0.06712054f, -0.11273403f, 0.13666812f, -0.05776389f, -0.01173205f, 0.06924111f, 0.12920190f, -0.06120622f, 
    0.02487581f, -0.04380847f, 0.02198208f, -0.06173595f, -0.18044154f, -0.02126051f, 0.12695004f, 0.05298088f, 
    -0.02219331f, 0.04720680f, -0.00175570f, -0.46602133f, -0.22118464f, -0.06613836f, 0.01677102f, 0.10460939f, 
    -0.07332229f, -0.02621087f, 0.04144285f, 0.05425089f, 0.18188415f, -0.16335300f, -0.00020719f, -0.15959400f, 
    -0.23536031f, -0.01095112f, -0.02554495f, 0.08789189f, -0.02808754f, 0.05279687f, -0.06572855f, -0.14196712f, 
    0.03085502f, 0.14689532f, -0.09194257f, -0.06548436f, 0.05369001f, -0.14686543f, -0.05805871f, 0.14688607f, 
    -0.03644958f, -0.00730385f, -0.03160083f, 0.11665472f, 0.14590563f, -0.04203765f, 0.17017645f, -0.20294169f, 
    0.06579899f, 0.00833911f, 0.06542145f, -0.02678772f, 0.15513210f, 0.06862776f, 0.11104857f, 0.27588066f, 
    0.08504532f, 0.06044824f, -0.06245404f, 0.02850266f, -0.01182061f, 0.03584287f, 0.04965304f, -0.00417699f, 
    -0.05048924f, 0.12111427f, 0.02773076f, 0.00716230f, -0.00605023f, 0.04700350f, -0.08602903f, 0.07832921f, 
    0.03554185f, -0.16967344f, 0.09239849f, 0.03061549f, 0.15821263f, -0.00850711f, -0.05685128f, 0.00476433f, 
    -0.08567613f, -0.00589365f, 0.05515165f, -0.31259167f, -0.06461560f, -0.06809062f, -0.01857328f, 0.06171554f, 
    0.16858481f, -0.24797270f, 0.01219962f, -0.09025627f, 0.45966789f, 0.26910803f, 0.24649090f, -0.08990205f, 
    -0.14471804f, 0.08431401f, 0.11428985f, 0.06400365f, -0.00089586f, 0.19191433f, 0.15155450f, 0.05337653f, 
    -0.26229265f, -0.00669291f, 0.13884288f, -0.00186660f, 0.11624701f, -0.18047634f, -0.41186884f, 0.15764982f, 
    -0.05934002f, 0.04077270f, -0.07351983f, 0.27401569f, -0.07673775f, 0.02500380f, 0.07897127f, -0.41328791f, 
    0.18478480f, -0.06236463f, -0.01816512f, 0.03131710f, 0.05414408f, 0.07862575f, -0.21966855f, 0.01895265f, 
    -0.06586768f, -0.03785620f, -0.10437965f, -0.05293480f, -0.06009831f, 0.22638540f, -0.09396196f, -0.18125838f, 
    -0.05537533f, 0.04346596f, -0.01338877f, 0.01988583f, 0.06421874f, 0.14891616f, -0.02023211f, 0.05170410f, 
    -0.05758334f, -0.06791338f, 0.15090688f, 0.06985844f, 0.05245472f, -0.04825439f, -0.04595778f, 0.13755342f, 
    0.08533378f, 0.09860601f, 0.03892792f, 0.18192232f, -0.20061538f, -0.20587619f, -0.17531949f, -0.11386288f, 
    -0.01508870f, -0.05632664f, 0.03407046f, 0.15114672f, -0.09051647f, -0.31390074f, -0.41581345f, -0.07235792f, 
    0.03844898f, -0.08715217f, -0.01377162f, 0.14656521f, 0.05299722f, 0.53466469f, 0.12377755f, 0.10396621f, 
    -0.12868084f, -0.18213528f, 0.11407951f, -0.01804208f, 0.07960787f, 0.01251806f, -0.26886156f, -0.02387680f, 
    -0.09438486f, -0.15797362f, 0.11866262f, 0.10233114f, 0.02548273f, -0.06471251f, 0.01375149f, 0.28166920f, 
    0.22646469f, -0.12339994f, -0.04057275f, -0.02505479f, 0.15994403f, 0.01717099f, -0.08986562f, -0.05466761f, 
    0.10651387f, -0.00950891f, 0.08227740f, 0.13588314f, 0.14898811f, 0.01746262f, -0.02966877f, -0.04262545f, 
    -0.03241843f, -0.07896621f, -0.34385365f, 0.00367947f, -0.04227384f, 0.06175986f, -0.06561904f, -0.12907577f, 
    0.13726921f, 0.03063532f, 0.12340398f, 0.28662536f, -0.19753234f, -0.01380425f, 0.13415577f, 0.00053775f, 
    -0.11305702f, -0.00227144f, -0.08246727f, 0.11536237f, -0.13155109f, -0.01150026f, 0.03361663f, -0.10944358f, 
    -0.01212569f, -0.20808688f, 0.02048395f, -0.04444680f, 0.28361815f, -0.03472342f, 0.09158728f, -0.03449879f, 
    0.02433121f, 0.03440729f, -0.01044001f, -0.00074515f, -0.17004772f, -0.15199704f, -0.04224312f, 0.01719537f, 
    -0.12108509f, 0.03065703f, -0.01525179f, 0.11774682f, -0.04378241f, 0.14506194f, 0.35476619f, 0.08797268f, 
    0.02237519f, -0.16206877f, -0.03938270f, 0.08986455f, -0.11047665f, 0.04561149f, 0.16491044f, 0.27733842f, 
    0.15521196f, 0.11323989f, -0.11071628f, 0.00392193f, 0.01716340f, 0.03871125f, -0.03203518f, 0.07074723f, 
    -0.38162816f, -0.39727238f, -0.01731169f, 0.10887597f, 0.03731976f, -0.07555557f, 0.09179470f, 0.07599400f, 
    -0.08833697f, 0.17775622f, -0.18716630f, 0.05613300f, -0.01136100f, 0.04382953f, 0.19356169f, -0.02330821f, 
    0.04557706f, 0.17080460f, -0.32656908f, -0.10543050f, 0.22505154f, 0.20942809f, 0.02196499f, 0.05461378f, 
    -0.10473753f, 0.13008049f, -0.20012750f, -0.09856293f, 0.00676793f, 0.05347458f, 0.07976643f, 0.17839840f, 
    0.11554661f, 0.07352551f, 0.04562033f, -0.02047389f, -0.07245051f, -0.04277948f, -0.05818759f, -0.01817787f, 
    -0.02806506f, 0.04839360f, 0.00472954f, 0.03945176f, -0.11648605f, 0.00824094f, 0.03501462f, -0.03754405f, 
    0.06705096f, -0.01036220f, 0.01462523f, 0.04783608f, 0.00241035f, -0.04002807f, -0.02501082f, -0.03970224f, 
    0.04004885f, 0.00343439f, -0.11693280f, -0.16927572f, 0.20269077f, 0.02921435f, 0.01765110f, -0.03382173f, 
    -0.04061929f, -0.05064610f, -0.31613666f, 0.01995466f, -0.18360408f, 0.03575834f, 0.20579894f, 0.13383223f, 
    -0.01270260f, 0.10781290f, 0.07048949f, 0.20353165f, -0.02205148f, -0.28050277f, 0.05709220f, -0.04679915f, 
    0.06442068f, -0.18043028f, 0.05470822f, -0.11312849f, 0.03823759f, 0.04546111f, 0.06271026f, -0.14567523f, 
    -0.11460119f, -0.12268156f, 0.04280082f, -0.13677441f, -0.23114491f, -0.01208961f, -0.06444693f, -0.05365158f, 
    0.10371505f, -0.01630461f, 0.00429655f, -0.02907937f, 0.00511809f, -0.10832743f, -0.12812532f, -0.00377666f, 
    -0.07424923f, -0.08399232f, 0.12458275f, 0.08326841f, 0.18182543f, 0.31026009f, -0.07951594f, -0.12176827f, 
    0.08476525f, 0.10676771f, 0.00147091f, -0.20753504f, -0.06483193f, -0.25682071f, 0.11054175f, 0.08297091f, 
    0.06741310f, 0.10396048f, -0.00580382f, -0.04950021f, 0.06252667f, 0.00860622f, 0.14446238f, -0.11574289f, 
    0.02954070f, -0.08661895f, 0.09684271f, -0.02094145f, -0.04011049f, 0.10609712f, 0.02781253f, 0.11776970f, 
    -0.09432518f, 0.01111685f, 0.05498364f, 0.03158787f, -0.14653929f, 0.08654936f, -0.02422625f, 0.10591537f, 
    0.26075375f, 0.05998070f, -0.08717652f, -0.02223664f, -0.10250344f, -0.03458881f, 0.06915225f, 0.03116751f, 
    -0.05276166f, 0.29784796f, 0.16436133f, -0.02475551f, -0.08969356f, 0.07476506f, -0.00737202f, -0.06684843f, 
    0.19133869f, 0.15436539f, 0.04060692f, 0.21691856f, 0.23263113f, 0.08336286f, 0.02416270f, -0.05312459f, 
    0.00166086f, 0.17562360f, -0.23605236f, -0.23607717f, -0.14279252f, 0.30188844f, 0.02498444f, 0.18682665f, 
    -0.06738728f, 0.01981362f, -0.06067030f, 0.01632840f, -0.27271852f, -0.01419003f, -0.00298209f, -0.03626175f, 
    0.02508466f, 0.09490816f, -0.02402458f, -0.01649719f, -0.18910633f, 0.16638975f, 0.10099408f, -0.28348479f, 
    -0.03552599f, -0.00066885f, -0.09333809f, 0.09448611f, -0.01250478f, 0.03361445f, 0.20206916f, 0.11765561f, 
    -0.09887666f, -0.00761119f, 0.07052758f, -0.02861319f, 0.11929766f, 0.08100817f, 0.15994959f, 0.21211906f, 
    0.03081777f, -0.14046820f, -0.01774217f, -0.14086956f, -0.07495095f, 0.12411987f, 0.14599025f, 0.15717545f, 
    -0.01571113f, 0.25566271f, 0.01674337f, -0.03194791f, -0.12588954f, 0.15865716f, -0.08088982f, -0.01969053f, 
    0.08435936f, -0.17678653f, 0.15061527f, 0.16704446f, 0.03129265f, 0.07418981f, -0.09202868f, 0.05800191f, 
    0.10986161f, 0.14448397f, 0.04687200f, -0.11915980f, -0.11988979f, 0.21947961f, 0.01808909f, 0.06089694f, 
    -0.10343663f, 0.00785326f, 0.09177628f, -0.09769808f, -0.00273289f, 0.11084283f, -0.06161601f, 0.02522356f, 
    0.03163541f, -0.08035693f, 0.00995759f, -0.01624690f, -0.01422536f, 0.12026875f, 0.02375518f, -0.01626948f, 
    -0.04099309f, 0.10003070f, -0.07803432f, -0.12931044f, 0.05587064f, 0.19561060f, -0.06634738f, -0.38562635f, 
    0.03636586f, -0.00235426f, 0.03043527f, 0.05932476f, -0.15412255f, -0.20005658f, 0.00064558f, -0.10476794f, 
    -0.17087150f, 0.14550748f, -0.01417733f, -0.12617926f, 0.01344504f, -0.09364889f, -0.02662925f, 0.18735448f, 
    -0.07666758f, -0.14683345f, -0.05368339f, 0.06697151f, 0.10340620f, -0.07837727f, -0.16980769f, -0.20372181f, 
    -0.02996298f, 0.01702009f, 0.03147736f, -0.03218504f, -0.01553125f, 0.02200653f, 0.01234320f, -0.00129305f, 
    -0.00245328f, 0.03297364f, -0.05895433f, 0.00876678f, -0.04714990f, -0.01779457f, -0.06012190f, -0.04795893f, 
    -0.01771102f, -0.01914825f, 0.05148705f, -0.05161103f, -0.04937179f, -0.01605849f, 0.01184991f, 0.01948117f, 
    -0.01670376f, -0.03662816f, 0.00241042f, 0.02147099f, 0.03722173f, 0.04248623f, 0.01727284f, -0.00703313f, 
    -0.03313860f, -0.01093484f, -0.04047282f, -0.01819084f, -0.04742609f, -0.06443989f, 0.04204628f, -0.03212543f, 
    0.02720245f, 0.04677093f, -0.05552013f, 0.00919723f, 0.02728586f, -0.02654210f, -0.04370391f, -0.04587767f, 
    -0.04869086f, 0.02453530f, -0.02117174f, -0.00478985f, -0.04185455f, 0.04083360f, 0.04181963f, 0.04116226f, 
    0.01659072f, -0.03780945f, 0.04479951f, 0.03698919f, -0.00190768f, 0.01907771f, -0.05597064f, 0.04104852f, 
    0.02308343f, -0.03556386f, 0.03655816f, 0.00350130f, 0.02031361f, 0.02154708f, -0.00011169f, -0.02454205f, 
    -0.05164206f, -0.01162953f, -0.01192866f, 0.03713550f, -0.03454830f, 0.00826285f, 0.00792839f, -0.03004479f, 
    0.04180513f, -0.02576949f, -0.01992938f, 0.01257971f, 0.00922673f, -0.02855569f, -0.03092978f, 0.04512981f, 
    -0.05453961f, 0.03818894f, -0.00468515f, -0.02884857f, 0.04526981f, -0.01634816f, -0.05185074f, -0.04659811f, 
    -0.03883174f, -0.02740490f, -0.03611886f, 0.00914096f, -0.00776137f, 0.03412263f, -0.03012825f, -0.00271504f, 
    -0.01611309f, 0.00022182f, -0.02785065f, 0.03844927f, 0.02089236f, -0.01982878f, -0.04947953f, -0.05098509f, 
    -0.04988075f, 0.04432670f, -0.03485413f, 0.01319905f, 0.06439184f, -0.04954004f, -0.06545433f, 0.00954045f, 
    -0.02491880f, 0.02092850f, -0.03283200f, 0.00412511f, -0.00449717f, -0.04097670f, -0.06613036f, 0.03462356f, 
    -0.00688304f, -0.06547769f, 0.03346356f, -0.04451177f, 0.02206000f, -0.01807686f, -0.02421445f, -0.04695944f, 
    -0.05149987f, -0.00762519f, 0.02352963f, 0.05376253f, 0.00018997f, -0.04240948f, 0.02636406f, -0.03413863f, 
    -0.03450075f, 0.01194592f, -0.05229366f, 0.01638218f, 0.02532124f, -0.02670495f, -0.02587507f, -0.00109345f, 
    0.04474435f, 0.01704616f, 0.04862880f, -0.06643166f, -0.03382090f, 0.01729347f, -0.04115409f, -0.02338779f, 
    0.02281010f, -0.02774073f, 0.01001708f, -0.05629900f, -0.04942282f, -0.02541282f, 0.03201798f, -0.05424087f, 
    -0.02850312f, -0.04490769f, 0.00491950f, 0.05007032f, 0.00180153f, 0.01123682f, 0.02433656f, -0.05183405f, 
    0.03733201f, -0.01144719f, -0.00249765f, 0.00950440f, 0.02057562f, -0.01515194f, 0.00400412f, 0.03853445f, 
    0.03969248f, -0.01571805f, 0.02184675f, -0.05981010f, 0.00041482f, -0.04401862f, 0.02173411f, -0.05896232f, 
    0.05226692f, -0.02152420f, -0.02973067f, 0.00083900f, -0.02823335f, -0.04382124f, -0.02899860f, -0.03709560f, 
    -0.05912935f, 0.03946346f, -0.02447973f, -0.04781424f, 0.02209892f, 0.00531996f, -0.01258075f, -0.05856351f, 
    0.03670665f, 0.00102283f, -0.00510814f, 0.02551879f, -0.01231904f, 0.01088143f, 0.00328051f, 0.03964834f, 
    0.02598894f, 0.05194138f, 0.00743190f, -0.05231771f, 0.03073195f, -0.01829963f, 0.05404788f, 0.02530461f, 
    -0.01236816f, -0.01913377f, 0.00265795f, -0.03736478f, 0.04638648f, 0.04477134f, 0.02256160f, -0.04506835f, 
    -0.03583308f, 0.02030537f, 0.02910924f, 0.04801904f, 0.00557512f, 0.01404959f, 0.00408965f, -0.04806840f, 
    -0.00164619f, -0.02046095f, -0.03235517f, 0.00732381f, -0.02029094f, 0.01779702f, -0.03522798f, 0.01759736f, 
    -0.05159408f, 0.03385862f, 0.00333629f, -0.03927720f, 0.04847589f, 0.04283217f, -0.03058265f, 0.01199031f, 
    0.02071242f, -0.00948263f, -0.01137365f, 0.01224734f, -0.00851491f, -0.00238119f, -0.06188572f, -0.01190546f, 
    0.05923122f, -0.06182430f, -0.01295617f, -0.03766522f, -0.01299313f, 0.03714643f, 0.01849176f, -0.04536100f, 
    -0.01676705f, -0.02033179f, -0.03172853f, -0.05306116f, 0.01506232f, 0.00766325f, -0.04190513f, 0.04101489f, 
    -0.00657673f, 0.02537531f, 0.04659057f, -0.00897466f, -0.03340770f, -0.01863368f, -0.05097716f, 0.00686261f, 
    -0.10205404f, -0.09997049f, -0.08179140f, -0.19759277f, 0.08470888f, 0.15115120f, 0.02280065f, 0.12666012f, 
    -0.06269710f, 0.47728416f, 0.28589436f, -0.22673045f, 0.18253392f, 0.06847148f, -0.09227838f, 0.04357985f, 
    0.12815590f, 0.16917662f, 0.13221355f, 0.15428585f, -0.20109619f, 0.11050937f, -0.01788821f, 0.14740756f, 
    0.19879693f, 0.08008581f, -0.02583145f, -0.04999099f, -0.03162866f, -0.20734957f, 0.21512364f, 0.08023353f, 
    -0.00029809f, 0.01038052f, 0.09889799f, 0.03939921f, -0.08638259f, 0.08622161f, -0.07371084f, 0.00207101f, 
    0.12584342f, 0.01254029f, 0.04054094f, 0.06146685f, -0.07658692f, 0.16426706f, -0.48477593f, -0.16132912f, 
    0.13197906f, 0.10192815f, -0.00986551f, -0.08815891f, 0.06664570f, -0.11023326f, -0.46453568f, -0.07360692f, 
    -0.18352517f, -0.00404785f, 0.17845035f, -0.02628618f, -0.13009572f, 0.06902587f, 0.00597915f, -0.30942470f, 
    0.34473529f, -0.16857408f, -0.07545045f, 0.03655415f, 0.15297620f, 0.07386339f, 0.08989386f, -0.10063413f, 
    -0.05982296f, 0.22071929f, -0.09370460f, -0.09963612f, -0.03838162f, -0.07017435f, 0.02340436f, -0.05035173f, 
    -0.03359056f, 0.05292710f, -0.03440792f, -0.12083533f, -0.12713283f, -0.04472291f, 0.06947339f, 0.26468298f, 
    0.02776786f, -0.24805525f, -0.08561848f, -0.07717267f, 0.04331925f, -0.03831267f, -0.11714923f, -0.08234844f, 
    -0.05708355f, 0.14751287f, 0.11189813f, 0.00871007f, -0.08378417f, -0.24363188f, 0.06371629f, -0.00189903f, 
    -0.03880572f, 0.19606219f, 0.00026804f, 0.13699967f, -0.14532924f, -0.16279040f, 0.19106755f, -0.03860823f, 
    -0.01941944f, 0.13877864f, -0.09820294f, -0.00446476f, 0.16917498f, -0.14436439f, 0.13048579f, -0.06680951f, 
    0.06139368f, 0.00495681f, 0.11515189f, 0.18260515f, 0.05572287f, 0.04704496f, -0.27372849f, 0.14167577f, 
    -0.24945340f, 0.06900343f, -0.05853105f, -0.12964436f, -0.01626465f, 0.07663402f, -0.02539980f, -0.48334903f, 
    -0.16966093f, -0.27068576f, 0.04136089f, -0.02936602f, 0.18688177f, -0.11835898f, -0.11043787f, -0.05465045f, 
    0.32536224f, -0.16374582f, -0.07880479f, -0.00339338f, 0.08817872f, -0.05025990f, 0.08805121f, -0.01391014f, 
    0.11655716f, 0.55758971f, -0.05407463f, 0.03331777f, 0.03608951f, -0.11367775f, 0.12840033f, 0.18419707f, 
    -0.05017504f, 0.11476927f, -0.34117717f, 0.02165698f, -0.10359243f, -0.07592265f, 0.10618459f, 0.04294770f, 
    -0.13693374f, -0.23884667f, 0.20732903f, -0.05807802f, 0.06854821f, -0.06900881f, 0.00328122f, -0.00385063f, 
    0.04908330f, -0.16567554f, -0.03587096f, -0.01913066f, -0.07867251f, 0.31222874f, -0.15457252f, -0.02614234f, 
    0.02943936f, 0.06204851f, 0.02248309f, 0.11160619f, -0.10403065f, -0.08739233f, -0.15464292f, 0.13175213f, 
    0.06653977f, -0.03904909f, 0.06838767f, -0.12030619f, -0.04627866f, 0.11249377f, 0.08544312f, -0.21829852f, 
    -0.15842988f, 0.07132122f, -0.08729032f, -0.03251299f, 0.04461465f, 0.18962345f, -0.03351015f, -0.03896561f, 
    0.08093002f, -0.05455181f, -0.07913080f, 0.12496015f, 0.03607298f, -0.08176897f, -0.03909476f, 0.09023863f, 
    0.38376024f, 0.11266255f, -0.21953031f, 0.10846920f, -0.08626835f, -0.00063423f, 0.04275202f, 0.05140259f, 
    -0.10178661f, 0.16243127f, -0.18662123f, -0.03515630f, -0.04973949f, 0.01188256f, 0.09190119f, 0.04282005f, 
    0.02416230f, 0.05851894f, 0.16419655f, 0.13173410f, -0.12378870f, 0.00717682f, 0.06183181f, 0.07181098f, 
    0.08326001f, 0.12927531f, 0.04914616f, 0.27888432f, 0.12758794f, -0.27466014f, -0.05440983f, -0.04238274f, 
    0.06231272f, -0.06737500f, 0.06334167f, 0.13783965f, 0.15810239f, 0.21727960f, -0.13518919f, 0.01698560f, 
    0.10526741f, -0.09350004f, 0.03487220f, -0.02523075f, -0.03539535f, 0.08209019f, 0.02383367f, 0.23349197f, 
    0.06388765f, 0.10080776f, 0.14431059f, -0.09303195f, -0.10652090f, 0.06502732f, -0.06949299f, 0.11011548f, 
    0.18425603f, -0.10158689f, -0.14721251f, -0.19278748f, 0.09566968f, -0.08324568f, 0.13665526f, -0.37827751f, 
    0.18231800f, 0.21433784f, 0.12326951f, -0.15709148f, 0.17810734f, -0.14845818f, 0.01369440f, 0.14249459f, 
    0.00067865f, 0.02953856f, 0.12217192f, 0.00577563f, -0.08841223f, 0.03830295f, -0.08247685f, 0.11432519f, 
    0.04398853f, -0.15382589f, 0.03782883f, -0.06572886f, -0.08806904f, -0.06730719f, -0.00987811f, -0.00740439f, 
    -0.01145556f, 0.08311018f, 0.26643944f, 0.16585818f, -0.05496510f, 0.14806467f, 0.00155237f, -0.18519790f, 
    -0.08377099f, -0.01349500f, 0.14349081f, 0.17428306f, -0.07681101f, 0.00511798f, -0.26938128f, -0.03766049f, 
    0.01375240f, 0.00132688f, -0.12106169f, -0.03971541f, -0.07375604f, -0.01517799f, 0.20667939f, -0.04399867f, 
    -0.01361329f, 0.16633861f, -0.01839247f, -0.02319521f, -0.01678108f, 0.13367552f, -0.04137590f, -0.05488897f, 
    0.05706126f, 0.11241272f, -0.01486865f, 0.01728113f, -0.00114899f, 0.34438753f, -0.01013594f, 0.01741887f, 
    0.08220345f, -0.05171367f, 0.06016887f, -0.04874595f, -0.09679520f, -0.03727126f, 0.18483281f, -0.02853221f, 
    0.01353936f, 0.04730855f, -0.07406479f, 0.00406625f, -0.03883839f, 0.14327289f, -0.06767266f, -0.14021493f, 
    0.14467426f, -0.03729048f, -0.04627967f, -0.07092967f, 0.06527847f, -0.03819496f, 0.10437661f, 0.05576407f, 
    0.04855808f, 0.01693144f, 0.10810699f, 0.01742909f, 0.21165183f, 0.01579976f, -0.19469985f, 0.01095546f, 
    0.03311784f, 0.14892401f, -0.05311848f, 0.10656207f, 0.00578169f, -0.00088757f, -0.21304496f, -0.07599923f, 
    0.04488416f, -0.05089367f, 0.01902434f, -0.23774286f, -0.13840061f, -0.01791269f, -0.10710230f, -0.11212382f, 
    0.00273150f, 0.06511439f, 0.19118960f, -0.08780751f, -0.07253148f, 0.11839348f, 0.05316129f, -0.06193947f, 
    -0.01514736f, 0.14438230f, 0.06823080f, -0.00886579f, 0.06693652f, 0.05221862f, -0.10430559f, 0.09071244f, 
    -0.02601025f, -0.02583559f, -0.08639152f, -0.05859115f, 0.01377851f, 0.04841895f, -0.10689547f, -0.07938904f, 
    -0.02186664f, -0.03806032f, 0.10551073f, -0.01971131f, -0.02343944f, 0.00236969f, -0.11025190f, -0.12381416f, 
    0.01747439f, -0.13712199f, -0.01490950f, 0.00609592f, 0.06655522f, 0.02074924f, -0.04483359f, 0.09227417f, 
    -0.11225504f, -0.00193760f, 0.09955912f, -0.01951799f, -0.04000632f, 0.13563219f, 0.04594266f, 0.00143965f, 
    0.17027842f, -0.16418630f, 0.06202246f, -0.00416282f, 0.03588146f, -0.08603857f, 0.11278743f, 0.03698856f, 
    -0.05239263f, 0.04412678f, -0.03912146f, -0.08347881f, 0.00559050f, -0.06946673f, -0.00793621f, 0.01933856f, 
    -0.11905343f, 0.02504079f, -0.06586686f, 0.12750073f, 0.16730134f, 0.20386147f, 0.13369499f, 0.00777288f, 
    0.08233201f, -0.04304356f, 0.12654334f, 0.04066063f, -0.10894576f, -0.11621685f, 0.19888723f, -0.02970403f, 
    0.00713603f, -0.13952571f, 0.05755529f, 0.01750785f, -0.00206528f, -0.04851057f, 0.08508541f, 0.08590575f, 
    0.15344118f, -0.22896117f, 0.16192578f, -0.01675017f, 0.01994062f, 0.13463624f, -0.12736519f, 0.04640911f, 
    -0.14770566f, -0.04000095f, -0.00967156f, -0.03157655f, -0.11022051f, 0.06177250f, -0.02819147f, -0.35880736f, 
    -0.07215784f, 0.01550216f, 0.04630565f, -0.06449453f, -0.09208784f, -0.17026258f, 0.06568376f, 0.05012403f, 
    -0.26020473f, -0.02647153f, -0.11825379f, -0.03260075f, 0.06320000f, 0.05924104f, 0.07407936f, -0.00982591f, 
    0.03114092f, -0.00362490f, 0.12676570f, -0.00499193f, 0.00693361f, -0.06682099f, 0.07777270f, 0.03630453f, 
    0.04037039f, 0.03499608f, -0.04817921f, -0.21365665f, 0.06537748f, -0.03688258f, -0.07660335f, 0.08465530f, 
    -0.14127997f, 0.00068471f, 0.02341164f, 0.07569881f, 0.15442255f, 0.16406085f, 0.03878414f, -0.12112522f, 
    0.01988555f, -0.00376525f, 0.01369825f, 0.06473746f, -0.25757810f, 0.04505969f, -0.06126097f, -0.12404539f, 
    0.09008773f, 0.00763381f, -0.09372050f, -0.00985701f, 0.11112464f, -0.04234864f, 0.10757419f, 0.21689937f, 
    0.05248937f, 0.17451318f, 0.05078899f, 0.02337858f, 0.13462600f, -0.08565121f, 0.08243465f, -0.04257301f, 
    0.03636858f, 0.02046293f, 0.05702809f, 0.07405315f, 0.13269076f, -0.04750492f, 0.23472889f, -0.00858827f, 
    0.30125728f, 0.35463172f, 0.01722920f, -0.05718762f, 0.16745028f, -0.02194593f, 0.05295968f, 0.02028968f, 
    0.03042455f, -0.02529818f, -0.03531669f, 0.04149171f, 0.01493105f, 0.00234333f, 0.03720924f, -0.00712315f, 
    0.05234109f, -0.05307130f, -0.01072786f, -0.03845271f, -0.02877727f, 0.03578624f, 0.04650261f, -0.01312313f, 
    0.04656838f, 0.05639075f, 0.02170773f, -0.06166931f, 0.01577923f, -0.03593018f, 0.02861850f, 0.01887531f, 
    0.04715694f, -0.06272404f, 0.00216301f, 0.04061426f, 0.00828281f, -0.04084661f, 0.03837886f, -0.03369194f, 
    -0.00082767f, 0.03405188f, 0.00614484f, -0.03644523f, -0.00633107f, -0.01760783f, -0.02441996f, -0.03229452f, 
    -0.03948797f, 0.04680518f, -0.04060289f, -0.04519930f, 0.00578162f, -0.04171766f, -0.00067492f, -0.05931580f, 
    0.02902694f, -0.06288900f, 0.02247462f, -0.01179376f, 0.00200151f, 0.01595912f, -0.04127360f, -0.04287248f, 
    0.00703764f, -0.04303664f, 0.00486287f, -0.01943201f, -0.03776249f, -0.04282394f, -0.02252494f, -0.02728545f, 
    -0.04694846f, -0.02752251f, 0.03001039f, -0.03358405f, 0.03512708f, 0.03092125f, 0.02151375f, 0.04514503f, 
    -0.01822093f, -0.01888404f, -0.00313307f, -0.06099650f, -0.06251468f, -0.00155190f, 0.03260651f, -0.00025785f, 
    0.00711416f, -0.05596985f, -0.02475217f, -0.01840807f, -0.06280901f, 0.02624418f, -0.06104686f, 0.02263976f, 
    -0.02789935f, -0.04392684f, -0.05006773f, -0.05301639f, -0.03702673f, 0.01227099f, -0.03815499f, -0.01580799f, 
    -0.02926037f, 0.02996195f, 0.00118194f, 0.02963141f, 0.02480879f, -0.01448964f, 0.03455350f, 0.04204592f, 
    0.00477615f, -0.01998352f, -0.01173577f, -0.00665622f, -0.05669149f, 0.00486778f, 0.03486978f, -0.02520309f, 
    -0.03377998f, 0.00509755f, 0.01294099f, -0.01817184f, -0.05944599f, 0.00197451f, 0.02198906f, 0.04245556f, 
    -0.05474348f, 0.03678089f, 0.02481598f, -0.04754873f, -0.04328992f, -0.00911256f, -0.04788863f, 0.04800199f, 
    -0.00680787f, -0.03771428f, 0.01974575f, 0.04655533f, -0.00764234f, -0.01792900f, -0.01019479f, -0.00247837f, 
    0.02918051f, -0.06297170f, -0.00911586f, 0.02482217f, -0.04871034f, -0.01401637f, 0.00952081f, -0.05151077f, 
    -0.03056298f, -0.02872152f, -0.02868386f, -0.02695397f, -0.05451240f, -0.03021620f, -0.04584409f, -0.02014808f, 
    -0.01075491f, -0.02015699f, -0.01229692f, -0.05413709f, 0.02731827f, 0.04104772f, -0.03947468f, -0.03998274f, 
    0.02463980f, -0.02265710f, 0.03183987f, 0.04861097f, -0.00118048f, -0.01342155f, -0.03888027f, -0.05829751f, 
    -0.03363094f, -0.00448185f, -0.00737247f, 0.01131226f, 0.01637423f, -0.02058786f, -0.02045720f, -0.01722253f, 
    -0.00972058f, 0.02028103f, -0.06419203f, 0.00254535f, 0.01558806f, 0.03794874f, -0.03724187f, -0.06369397f, 
    -0.01056375f, -0.04067268f, 0.02435008f, 0.00317555f, 0.00593699f, -0.04872007f, -0.02763770f, -0.03109359f, 
    -0.04951128f, 0.04346830f, 0.01229716f, -0.00174978f, -0.03194506f, 0.00079984f, 0.03869786f, 0.01080345f, 
    0.00782058f, -0.00312785f, -0.03975734f, 0.02413126f, -0.01273242f, 0.04208722f, 0.04920683f, 0.00781138f, 
    -0.04842042f, 0.04952165f, -0.02545483f, 0.01931586f, 0.03504884f, -0.03890007f, -0.04291178f, -0.00048723f, 
    0.02231046f, -0.02181363f, 0.00389630f, -0.04020208f, -0.03279772f, 0.01469400f, 0.01837490f, 0.04878894f, 
    -0.01890074f, -0.02417942f, 0.00135429f, 0.01736645f, 0.01533536f, -0.06381522f, -0.04159024f, -0.05527966f, 
    -0.05260550f, -0.01977344f, 0.04970262f, 0.00151241f, -0.02891885f, -0.01335995f, -0.04296886f, -0.00358848f, 
    -0.01257015f, -0.04556261f, -0.02555398f, -0.02697550f, 0.01198402f, -0.05306145f, 0.00856277f, 0.04157894f, 
    -0.06171744f, 0.04441634f, -0.05367224f, -0.03649753f, -0.02159790f, 0.01885608f, 0.01509788f, -0.05782638f, 
    -0.04398155f, 0.03342802f, 0.00933787f, 0.02081671f, -0.06163000f, 0.01058722f, 0.03507478f, 0.02871402f, 
    -0.02146911f, -0.01543608f, -0.01012131f, -0.03022254f, 0.01935982f, 0.04025612f, -0.01064947f, 0.04975106f, 
    0.04518302f, -0.04687039f, -0.05798506f, -0.05594668f, 0.01102498f, -0.01872476f, -0.03882212f, 0.00446799f, 
    -0.03807935f, 0.03201376f, -0.00917210f, -0.05125290f, 0.05332991f, 0.00518472f, 0.04760439f, -0.02985025f, 
    0.01593432f, -0.04055361f, -0.06158588f, 0.01354877f, 0.03180474f, -0.02876222f, -0.01961656f, 0.00309087f, 
    -0.01272314f, 0.03742706f, 0.00780867f, 0.04709128f, -0.01792833f, -0.05176125f, -0.02940955f, -0.06504248f, 
    0.04530819f, -0.05500735f, -0.05098437f, -0.02919213f, 0.03438380f, -0.05619399f, 0.01225368f, 0.01066456f, 
    0.02870253f, -0.00254385f, 0.01127793f, 0.03317804f, -0.03620931f, -0.01697203f, 0.03598884f, -0.05379753f, 
    0.02065259f, 0.02786666f, 0.00611094f, -0.03930981f, 0.03261814f, 0.03779940f, -0.01415450f, -0.00391091f, 
    -0.05273841f, -0.06096838f, -0.02141202f, -0.00981335f, 0.02607380f, -0.00517971f, -0.00214626f, 0.03882400f, 
    -0.01014655f, -0.02141300f, -0.05393445f, -0.03304898f, 0.02667826f, -0.00896305f, -0.02359252f, -0.06189170f, 
    -0.05006785f, 0.04656217f, -0.00618671f, 0.04539350f, -0.00924596f, 0.02875938f, -0.06727732f, -0.02880496f, 
    -0.02282171f, -0.05271348f, 0.03738246f, 0.04315033f, 0.03934655f, 0.01371036f, -0.04680988f, -0.03774957f, 
    0.03836223f, 0.02898460f, 0.04015285f, 0.03946588f, -0.03261084f, -0.01332692f, 0.03653556f, -0.03380797f, 
    0.00698817f, -0.01881853f, -0.05686724f, -0.02535809f, -0.01762581f, 0.01218033f, -0.00258435f, -0.01596749f, 
    -0.01290083f, -0.05511930f, 0.02719315f, -0.02519803f, -0.00584675f, 0.03696935f, 0.04582640f, -0.01972836f, 
    -0.04515757f, -0.04115404f, -0.05292894f, -0.04224342f, 0.04968064f, -0.02048694f, -0.03675029f, -0.04314905f, 
    -0.02436754f, 0.01631236f, -0.06138375f, -0.05113857f, -0.04897629f, 0.00551490f, -0.02452866f, -0.06294902f, 
    0.05037443f, 0.03722532f, -0.04552232f, 0.01715829f, -0.03454252f, -0.04146702f, -0.04956715f, -0.01437263f, 
    0.00382475f, -0.00868573f, -0.05110151f, -0.00611625f, -0.03339721f, 0.04596983f, 0.02609657f, 0.01564960f, 
    -0.00894917f, 0.05055973f, -0.06153605f, -0.01631516f, -0.02229434f, 0.00416572f, 0.02705023f, -0.02413256f, 
    0.00212211f, 0.00064281f, -0.03004900f, 0.04089769f, -0.02155204f, 0.04550244f, 0.02724252f, -0.06745068f, 
    -0.05750819f, -0.06370527f, 0.03391331f, 0.03049417f, 0.01540947f, -0.06928945f, -0.01849686f, 0.02863258f, 
    0.03547071f, 0.03065835f, -0.03273037f, -0.05204561f, 0.00429705f, 0.02128434f, -0.04644835f, 0.03794540f, 
    -0.06881778f, 0.01985400f, 0.00170531f, 0.01020324f, -0.06348902f, -0.01109482f, -0.01344703f, -0.03279385f, 
    -0.06144337f, -0.04021866f, -0.00584830f, 0.02727029f, 0.00052545f, 0.01907298f, -0.04022097f, 0.00639867f, 
    0.03426845f, -0.00940930f, -0.03302137f, -0.05374302f, 0.01845964f, -0.05206519f, 0.03933648f, 0.04187301f, 
    -0.06566726f, 0.02511130f, -0.06018984f, -0.05810469f, 0.00037198f, -0.04562625f, -0.00679530f, -0.06455464f, 
    0.02195206f, 0.03181327f, 0.00854362f, 0.00163287f, -0.04120168f, 0.00711694f, 0.00014461f, -0.00686157f, 
    0.02487868f, 0.03726798f, -0.03953421f, -0.03814328f, 0.02227770f, -0.01103526f, 0.03642928f, 0.02650956f, 
    0.04290003f, -0.01552731f, 0.04011178f, -0.04263228f, -0.02957709f, 0.03752757f, -0.02354259f, -0.05845255f, 
    -0.05725636f, 0.02287422f, -0.03527961f, -0.02160943f, -0.01376345f, -0.00151116f, 0.04143739f, -0.05403780f, 
    0.01957051f, -0.05594696f, -0.02147615f, -0.06478771f, -0.00266640f, -0.02827513f, 0.01687971f, 0.02330110f, 
    -0.03921958f, -0.05576847f, -0.02565175f, 0.00970255f, 0.03548772f, -0.01891433f, -0.05004959f, -0.02540247f, 
    -0.00241430f, -0.06849820f, 0.02077594f, 0.01090469f, -0.05168847f, -0.01927666f, -0.04763890f, 0.01617228f, 
    -0.04151356f, -0.02939118f, -0.06145513f, -0.03932215f, 0.04705020f, 0.04226902f, 0.04167721f, 0.00722305f, 
    0.03799831f, -0.03748444f, 0.01459343f, 0.03052698f, -0.03039583f, 0.02015935f, 0.00603141f, -0.06302220f, 
    -0.00759161f, 0.01965719f, 0.02389497f, 0.03105232f, 0.02568024f, 0.02563171f, -0.04313026f, 0.01963057f, 
    0.01127612f, -0.00906695f, -0.00985280f, -0.00028381f, 0.03331515f, 0.02260061f, -0.00630548f, -0.00065756f, 
    -0.01295510f, -0.05655907f, -0.05567413f, 0.05023450f, 0.02435722f, 0.01213467f, -0.01896793f, -0.05749632f, 
    -0.10538987f, -0.31105494f, -0.12004223f, -0.05319727f, -0.11320790f, 0.09029291f, 0.06641587f, 0.13812132f, 
    0.06229993f, 0.03017952f, -0.07482163f, -0.20910268f, 0.21890444f, -0.01899875f, -0.02587248f, 0.20539564f, 
    0.16320525f, 0.00698892f, 0.15148982f, -0.03585051f, 0.26967421f, 0.10410561f, -0.08225887f, 0.02915816f, 
    0.10404932f, 0.00217363f, 0.01206638f, -0.05869031f, 0.08424408f, -0.20701849f, 0.05706720f, 0.02240754f, 
    -0.04145212f, 0.03259169f, -0.03023398f, 0.28577295f, -0.53692400f, 0.04164462f, 0.40873033f, -0.00071214f, 
    -0.07997073f, -0.07553558f, -0.09877925f, -0.00931418f, -0.04111964f, -0.24394482f, 0.15704577f, -0.23844191f, 
    -0.26177016f, 0.02920066f, -0.01433512f, 0.06841478f, -0.00853345f, -0.04258887f, -0.07391850f, 0.19578026f, 
    -0.08500730f, 0.02091402f, 0.05643945f, -0.17601903f, 0.05378970f, 0.09763567f, -0.00681294f, -0.25003916f, 
    0.04447772f, -0.01147790f, -0.03974598f, 0.05415978f, -0.08077011f, 0.11122951f, -0.14034459f, -0.05395395f, 
    0.16024204f, 0.00589122f, 0.15279280f, -0.05636844f, -0.02239364f, 0.10665385f, 0.18852389f, 0.03375514f, 
    0.15007450f, 0.07195903f, 0.33478257f, 0.01064758f, 0.14424318f, -0.13618012f, -0.21109413f, 0.19512799f, 
    -0.16651689f, 0.03823590f, 0.33615986f, 0.12957382f, -0.04291266f, -0.07804929f, -0.13544765f, 0.03520588f, 
    -0.03414850f, 0.03316435f, 0.03047583f, 0.00919739f, 0.05557146f, 0.05941109f, 0.07738946f, 0.14101106f, 
    -0.00709471f, -0.04236677f, -0.11055287f, 0.04654998f, -0.12824111f, 0.01950956f, 0.12753542f, -0.12104975f, 
    -0.15527184f, 0.00099952f, -0.10425034f, 0.06199884f, 0.06304656f, 0.10590966f, -0.22934422f, 0.23921654f, 
    -0.03779243f, 0.06074442f, -0.11342789f, -0.03703868f, -0.09191141f, 0.28609994f, 0.17749329f, -0.05777009f, 
    0.00387630f, 0.03385038f, 0.07395159f, 0.16289918f, -0.02144625f, 0.05541582f, -0.09082935f, 0.08877673f, 
    -0.01792299f, 0.09709901f, -0.07020804f, 0.14044569f, -0.03203780f, 0.07266760f, 0.04898534f, 0.09500000f, 
    -0.21493290f, 0.00507917f, 0.02688415f, 0.12243114f, 0.01182211f, -0.09565854f, 0.07353943f, -0.00487909f, 
    -0.04054257f, 0.17329539f, 0.00945775f, -0.22581446f, 0.03690583f, -0.06588718f, -0.09855510f, -0.09076381f, 
    0.11493238f, 0.13767377f, -0.02453871f, -0.02324967f, -0.10350804f, -0.13850167f, -0.11455320f, -0.17046025f, 
    -0.10507998f, 0.22550042f, 0.07039487f, -0.34441820f, -0.29867795f, -0.05770671f, 0.05207218f, 0.04010313f, 
    0.01013851f, -0.04855790f, -0.06937162f, 0.08274738f, -0.29749420f, 0.14695948f, 0.15560102f, 0.08363891f, 
    0.02198208f, -0.02273695f, 0.03652979f, 0.15783842f, -0.16623297f, -0.10544805f, -0.04447868f, -0.19497453f, 
    -0.20140491f, -0.28153160f, 0.11934454f, -0.02950111f, -0.08709449f, 0.15160877f, 0.12397993f, 0.14596619f, 
    -0.01363188f, -0.05664293f, 0.11661496f, 0.00300019f, 0.13824621f, 0.14588483f, -0.07089293f, 0.04031978f, 
    0.12972140f, -0.25756338f, 0.11172637f, -0.19986641f, 0.02185469f, -0.00327626f, 0.00157528f, 0.07198676f, 
    0.09384213f, 0.29980487f, 0.01550427f, 0.18915473f, 0.13812700f, -0.22396824f, 0.03054204f, -0.05698562f, 
    0.04961452f, 0.08422634f, -0.00861306f, -0.17409934f, -0.09476474f, -0.07314223f, 0.07170325f, 0.07629274f, 
    -0.00898659f, 0.12516665f, -0.15565935f, -0.00790847f, -0.56615102f, 0.18902804f, -0.00218426f, 0.11964827f, 
    0.10406344f, -0.03946943f, 0.07484875f, -0.01473812f, -0.14232691f, -0.22772776f, 0.02875453f, 0.09245648f, 
    0.06736369f, 0.06445835f, 0.01267428f, -0.04073234f, 0.36445621f, 0.21452670f, -0.40466353f, -0.03420305f, 
    0.03774652f, -0.17079724f, -0.04254091f, 0.01074282f, 0.01003187f, -0.17237006f, 0.01711708f, 0.36289692f, 
    0.18338795f, -0.14146961f, -0.07347515f, -0.12425761f, -0.00246690f, -0.01888874f, -0.20439668f, -0.08343807f, 
    0.23125118f, -0.12248369f, -0.07334550f, 0.00440912f, 0.00915237f, -0.05519896f, -0.14512549f, -0.30129033f, 
    -0.22878990f, 0.21042719f, -0.16511688f, -0.02602987f, 0.00203418f, 0.05560034f, -0.01719834f, -0.13817464f, 
    0.01245372f, -0.30142772f, -0.22891378f, 0.23400292f, 0.27330160f, 0.05219724f, 0.18062101f, -0.03990670f, 
    0.17323267f, -0.02170699f, -0.01222165f, 0.03952691f, -0.00114619f, -0.04561383f, 0.22997782f, 0.21102750f, 
    0.14140984f, -0.11096328f, -0.23099653f, -0.40302581f, -0.12582459f, 0.05271529f, 0.24293400f, -0.02446682f, 
    -0.04012813f, 0.13808818f, 0.10749697f, 0.01307156f, -0.01931892f, 0.17162259f, 0.28611612f, 0.33347088f, 
    0.12541655f, 0.15659839f, 0.22134036f, -0.00943530f, 0.31780216f, 0.02657163f, 0.14196654f, 0.23776133f, 
    0.02987655f, 0.20238510f, 0.21841486f, -0.00823224f, 0.10699762f, -0.02421723f, -0.11962517f, -0.02529827f, 
    -0.10027245f, 0.08070996f, 0.05703590f, -0.03710853f, 0.04404603f, -0.42616567f, 0.11704249f, 0.14292279f, 
    0.14597389f, -0.12079211f, 0.05911012f, -0.10002884f, 0.22868595f, 0.08853713f, -0.01080638f, 0.42374718f, 
    0.15302557f, 0.09330910f, -0.19345272f, -0.10729968f, 0.10566226f, 0.10321477f, 0.06810696f, -0.11307543f, 
    -0.26180533f, 0.02758023f, -0.32653996f, 0.00332760f, 0.03066151f, 0.16329461f, 0.00836707f, -0.12851563f, 
    -0.14646541f, -0.16742694f, -0.20318720f, 0.03602366f, -0.05517202f, 0.13880786f, -0.02268196f, -0.16697778f, 
    0.08214702f, 0.11819588f, 0.14278407f, -0.29589692f, -0.04153876f, -0.15402187f, -0.01841534f, 0.03808683f, 
    0.08321549f, 0.04236058f, -0.05653351f, 0.06542341f, 0.01294666f, -0.06954984f, 0.09771387f, -0.16246367f, 
    0.08779121f, 0.03197300f, -0.09164923f, -0.02737502f, 0.39079288f, 0.26691389f, 0.06493980f, -0.20190996f, 
    -0.28291237f, -0.07318089f, 0.16582501f, -0.04849189f, -0.27433568f, -0.25837156f, 0.26842269f, 0.29399484f, 
    -0.05111106f, 0.01992204f, -0.01222629f, -0.01164025f, -0.00205881f, 0.05917127f, -0.12768541f, 0.00688891f, 
    -0.15982936f, 0.07895098f, -0.21257949f, -0.11154316f, 0.05197980f, -0.05368277f, 0.18562546f, -0.05338050f, 
    -0.22368707f, 0.10058221f, 0.02849314f, 0.20691897f, -0.05004912f, 0.21727359f, 0.00180950f, 0.19803099f, 
    0.36618188f, 0.37827376f, 0.06610143f, 0.12712905f, 0.02073694f, 0.06168040f, 0.24080828f, -0.02083796f, 
    -0.02214980f, -0.00364185f, 0.18276410f, 0.01181645f, -0.14548403f, 0.08285536f, -0.10060500f, 0.10678815f, 
    0.04872987f, 0.08706606f, 0.12075551f, -0.05246008f, 0.07893214f, -0.06331183f, 0.05098160f, -0.15340306f, 
    0.13767447f, 0.08198133f, 0.27267304f, 0.03686539f, -0.23988684f, 0.00966832f, 0.03390743f, 0.23325039f, 
    -0.11726179f, 0.07751568f, 0.13948934f, 0.10126934f, -0.03693438f, -0.01526115f, -0.11994159f, 0.25635049f, 
    0.04160377f, 0.32958663f, 0.20860931f, 0.06986570f, 0.02876685f, 0.35433450f, 0.06915902f, -0.01209816f, 
    -0.11596061f, -0.01605663f, -0.17776065f, -0.04235053f, 0.07216702f, -0.11429300f, 0.01683399f, 0.07346983f, 
    0.06295038f, 0.02759631f, 0.10078254f, -0.06321771f, -0.05201074f, 0.14071015f, 0.08899225f, 0.00786512f, 
    -0.26176628f, -0.37510678f, -0.02175074f, 0.06923353f, -0.04035749f, -0.12631167f, -0.09640521f, 0.05888087f, 
    -0.05074754f, 0.20563339f, 0.16865577f, -0.01913163f, -0.12704210f, 0.07975178f, -0.04406283f, -0.06509686f, 
    -0.01287076f, 0.18337256f, 0.15969561f, 0.16228087f, -0.13067159f, 0.11484373f, 0.09669264f, -0.01784969f, 
    0.13589941f, 0.15262726f, -0.14522102f, -0.03361375f, -0.30897859f, 0.05300733f, 0.02118232f, 0.15874383f, 
    0.11876962f, 0.08973768f, -0.08799270f, 0.00478813f, -0.03148903f, -0.03394233f, -0.10998911f, 0.25924280f, 
    0.00487930f, 0.08461215f, 0.03243938f, 0.06767018f, -0.06159809f, -0.15889859f, -0.27080616f, 0.08332897f, 
    0.12767984f, -0.08374704f, 0.00677516f, -0.12536788f, 0.07348064f, 0.26293364f, 0.09104464f, -0.00683716f, 
    0.11615106f, -0.04303940f, 0.15430638f, 0.21464291f, 0.11299955f, -0.01417924f, -0.26716325f, -0.02392771f, 
    -0.33788005f, 0.09857816f, -0.16072904f, 0.15020168f, -0.09939308f, 0.08923402f, 0.08891854f, 0.32653126f, 
    0.11565543f, -0.04575039f, -0.06056317f, 0.07019772f, 0.07564651f, 0.07423855f, 0.02645118f, -0.17860632f, 
    -0.06060266f, -0.07202098f, -0.01959384f, -0.00924815f, 0.11522029f, 0.01440904f, -0.09566383f, 0.20699137f, 
    0.07900081f, -0.06606094f, 0.23225224f, -0.04417283f, 0.09055477f, 0.12351049f, 0.02592043f, 0.19566493f, 
    0.01473792f, 0.06953485f, -0.14463323f, -0.31507888f, 0.00964196f, 0.18387124f, 0.05378393f, 0.15652968f, 
    0.25228792f, -0.03963073f, 0.14500740f, 0.03877760f, 0.02714921f, -0.28104815f, 0.05540414f, 0.05327020f, 
    0.07933880f, 0.03184155f, -0.07963350f, 0.14289895f, -0.08205315f, 0.07219410f, 0.13299201f, 0.31456110f, 
    0.11262119f, -0.01840639f, -0.12561411f, -0.02636873f, -0.22403145f, -0.05441524f, -0.02427763f, -0.14210878f, 
    -0.06050964f, -0.09104630f, -0.01358909f, 0.07253654f, 0.03192944f, 0.13993007f, 0.18018626f, -0.04414729f, 
    -0.10072090f, -0.03661293f, 0.02050244f, 0.05455521f, 0.12750663f, 0.02943856f, -0.02858762f, -0.19580007f, 
    0.38399765f, 0.09588878f, -0.10066140f, -0.12741512f, -0.00602070f, 0.01395770f, -0.05753479f, 0.14728051f, 
    0.20612101f, -0.03544016f, -0.00063484f, 0.03710309f, -0.11385318f, 0.26190868f, 0.24666359f, -0.27282131f, 
    0.14666690f, 0.26391679f, -0.06768865f, -0.09874586f, 0.03901522f, -0.01281298f, -0.22456324f, -0.13340384f, 
    0.10362672f, -0.18989350f, -0.07168463f, -0.01949431f, 0.19390577f, -0.00984645f, 0.22683631f, 0.13834050f, 
    -0.18297179f, -0.16346326f, 0.11124349f, -0.22449382f, 0.27676660f, 0.10828028f, -0.26587579f, 0.25018507f, 
    -0.01445943f, -0.10657837f, 0.08038566f, -0.04269470f, 0.03061322f, -0.14959972f, -0.05753695f, -0.00847264f, 
    0.09238014f, 0.13818392f, -0.23181063f, -0.00445621f, -0.06054440f, 0.12503491f, -0.34403548f, 0.03849214f, 
    0.15996906f, 0.03279709f, 0.20687084f, -0.08433636f, 0.08825097f, -0.00088725f, -0.12918009f, 0.22322747f, 
    -0.03978484f, -0.22262184f, 0.17581829f, 0.20693627f, 0.04538089f, 0.08192436f, 0.21314767f, 0.29541519f, 
    -0.16731635f, -0.13836466f, -0.06548526f, -0.12553854f, 0.18565400f, 0.03221025f, 0.09696362f, -0.06315747f, 
    0.11685964f, 0.29143068f, 0.04529810f, 0.04044989f, -0.00432933f, 0.00346885f, 0.10675509f, -0.02816338f, 
    0.07739232f, 0.11361055f, 0.16324878f, -0.20978785f, 0.09864803f, 0.05803401f, -0.04548218f, -0.12066084f, 
    -0.15506220f, 0.07332562f, 0.14295317f, -0.52412874f, -0.24151449f, 0.01381643f, -0.07625566f, 0.11015469f, 
    0.17411101f, -0.05252155f, -0.03145742f, 0.04795088f, -0.21060723f, -0.18796439f, 0.06612542f, 0.00858704f, 
    -0.00687334f, 0.05417992f, 0.12926751f, 0.13523544f, -0.03558552f, 0.20239092f, -0.06799133f, 0.27519795f, 
    0.05978090f, 0.17152718f, 0.00734852f, 0.17633328f, 0.22282960f, 0.14607868f, -0.20526862f, 0.10178299f, 
    -0.08660830f, 0.06173139f, 0.29281875f, -0.25150749f, -0.01495847f, -0.18064240f, 0.12343273f, -0.08188287f, 
    -0.01532159f, -0.18468072f, 0.09456266f, 0.15374519f, -0.05419783f, 0.00718059f, 0.02394027f, 0.02839341f, 
    0.13668822f, 0.08229966f, -0.09167922f, 0.00706124f, 0.06781041f, 0.04282671f, -0.10012763f, -0.09525892f, 
    0.01310531f, 0.08061627f, 0.02070315f, 0.00499681f, 0.11200170f, -0.09240125f, 0.10483409f, -0.14773007f, 
    0.03688922f, -0.04087453f, 0.04179246f, -0.17458214f, -0.02310817f, 0.13610289f, 0.12153608f, -0.00923057f, 
    0.08062493f, 0.25849700f, 0.31259003f, 0.28446725f, -0.11472843f, 0.03761587f, -0.02836262f, 0.04910926f, 
    0.20334306f, -0.05505313f, 0.08179895f, -0.00014533f, 0.00404556f, 0.00094760f, 0.11287131f, 0.08271499f, 
    0.06454584f, -0.08127309f, 0.16033340f, 0.24315453f, 0.20012112f, -0.07069100f, -0.23151541f, 0.10148524f, 
    0.03070490f, -0.04593215f, 0.03553854f, -0.18219174f, 0.04288152f, -0.13394797f, -0.25290757f, 0.20446712f, 
    0.12764443f, 0.05235121f, -0.17475122f, 0.05183783f, -0.15279719f, 0.11646330f, 0.11411222f, -0.00250409f, 
    0.22030778f, 0.12239575f, 0.02951609f, 0.05482638f, 0.04080626f, -0.13802382f, 0.23832124f, -0.02739951f, 
    -0.19393516f, 0.11818845f, 0.11263645f, 0.09652589f, 0.16387485f, -0.09023318f, -0.24962568f, -0.01544161f, 
    -0.02687101f, -0.04107688f, -0.04982277f, 0.01794374f, 0.01514369f, -0.05427145f, -0.03854316f, 0.00200644f, 
    0.03706435f, -0.02969091f, 0.04333866f, 0.00566359f, -0.02894601f, 0.00600723f, 0.04168481f, 0.02917108f, 
    -0.06858601f, -0.00860956f, -0.00522482f, 0.00807188f, 0.01742482f, -0.00470113f, -0.02831818f, 0.01286210f, 
    -0.04808102f, -0.05565112f, 0.04427785f, -0.01252985f, -0.03978915f, -0.04002208f, -0.01938134f, -0.01387927f, 
    0.04926280f, 0.00130931f, -0.07216685f, -0.05095607f, 0.01211267f, 0.03239233f, -0.03936783f, 0.00304127f, 
    -0.01113312f, 0.00573131f, 0.02443152f, -0.04063761f, -0.02105776f, 0.03252235f, 0.00912339f, 0.04039555f, 
    -0.07681791f, 0.00081341f, -0.00572075f, -0.00686044f, -0.06283426f, -0.03015481f, -0.07052746f, 0.05064505f, 
    0.03529396f, -0.04784721f, 0.01464788f, 0.01108703f, 0.02787342f, 0.00804200f, 0.03473769f, 0.03704660f, 
    -0.04130402f, -0.03676506f, 0.05009418f, 0.01949276f, 0.01537484f, 0.00419074f, -0.04403935f, 0.00495403f, 
    -0.01442763f, 0.01400886f, 0.02461876f, -0.02043875f, -0.01751314f, 0.03516000f, 0.05180413f, -0.02403768f, 
    0.00735521f, 0.06940572f, 0.02015215f, -0.04751687f, -0.00378752f, 0.00643406f, -0.05033313f, 0.03143416f, 
    -0.00182023f, -0.03685049f, 0.04985320f, -0.01934505f, -0.06420375f, 0.03669078f, 0.01653948f, -0.03897797f, 
    -0.05774301f, -0.00419593f, -0.03773208f, -0.03658637f, -0.00465243f, -0.07095916f, -0.03960566f, -0.02703193f, 
    -0.01098043f, 0.03815309f, 0.01254664f, 0.03357047f, -0.02300402f, -0.02159485f, -0.02408371f, -0.03986024f, 
    -0.04235109f, -0.03742471f, -0.04308785f, -0.03223840f, -0.05879565f, -0.03252000f, -0.01009690f, -0.02687541f, 
    -0.03033035f, 0.03981746f, -0.07388327f, 0.02957964f, -0.00211026f, -0.02670002f, 0.00752974f, -0.06798892f, 
    -0.00077243f, 0.02964861f, 0.01893402f, -0.01057704f, -0.01802175f, -0.05086315f, -0.01502785f, -0.03468630f, 
    -0.05078875f, 0.00260911f, -0.06297850f, 0.03701936f, -0.02797547f, -0.03777628f, 0.03111602f, 0.05234095f, 
    -0.01071355f, -0.01353949f, 0.00352998f, 0.04915006f, -0.00936601f, -0.02979196f, -0.06527738f, 0.00570682f, 
    -0.00972690f, -0.05222004f, 0.03813910f, -0.01611050f, -0.05659691f, -0.06058259f, -0.05858526f, 0.00317568f, 
    -0.05550809f, -0.02742062f, 0.01548878f, -0.06562582f, 0.02986121f, 0.03160473f, -0.03164040f, -0.05451116f, 
    0.02389137f, -0.01844291f, -0.05676882f, -0.00621180f, -0.05744458f, 0.01945764f, -0.05651398f, 0.01141689f, 
    -0.03944606f, 0.01999837f, -0.02883814f, -0.01919824f, -0.02972910f, 0.00664339f, -0.01780930f, -0.00811824f, 
    0.03965851f, -0.06527484f, -0.02448044f, -0.07031280f, -0.03637883f, 0.01320215f, 0.04767154f, 0.00517451f, 
    0.03725376f, 0.01620289f, 0.02641713f, 0.04862804f, -0.02240483f, -0.01038453f, 0.04267396f, -0.00993987f, 
    -0.04489180f, 0.01363186f, 0.04502151f, 0.01924103f, 0.01475673f, 0.00748389f, -0.00573776f, -0.00130127f, 
    -0.04032815f, 0.03922681f, 0.04074795f, 0.00052054f, 0.02383781f, 0.02076111f, 0.03201391f, -0.03603153f, 
    0.03286291f, 0.02709562f, -0.01009288f, 0.02211900f, -0.00006054f, -0.02358837f, 0.00155094f, -0.03103094f, 
    -0.04295050f, 0.04689341f, -0.03697340f, 0.01822978f, -0.02623783f, -0.04711105f, 0.01769529f, 0.01049182f, 
    -0.01369014f, 0.02267469f, -0.05806849f, 0.00246582f, -0.00888804f, -0.06579539f, 0.01078787f, -0.06915363f, 
    -0.01566269f, -0.06332615f, -0.04591660f, -0.04886715f, -0.00026182f, -0.01001595f, 0.02409732f, -0.00141993f, 
    0.03855544f, -0.06927832f, -0.03690003f, 0.00365480f, 0.02568384f, -0.01178543f, -0.06427149f, -0.06180570f, 
    -0.04467779f, -0.05453404f, 0.04330578f, -0.05764283f, -0.04869789f, 0.00124208f, -0.03818280f, -0.03874648f, 
    -0.06433120f, 0.04037752f, -0.05587988f, 0.04824062f, -0.05009751f, -0.01441283f, -0.00695597f, 0.03369861f, 
    0.02518211f, 0.00637297f, -0.03030503f, 0.01244749f, -0.00003498f, -0.06560040f, -0.05416732f, 0.04422436f, 
    0.03337979f, -0.02924681f, 0.01786003f, -0.01361495f, 0.01883827f, 0.04587756f, 0.02691812f, 0.01381167f, 
    -0.17138715f, 0.15287431f, -0.01116080f, 0.06916322f, 0.07731473f, 0.00905099f, -0.01059990f, 0.08645736f, 
    -0.10497473f, 0.18696481f, 0.19164044f, 0.24720141f, -0.32842198f, 0.08256527f, 0.03569027f, -0.18858285f, 
    0.03700908f, 0.09031362f, 0.12793145f, 0.01785591f, 0.00296581f, 0.04268145f, -0.34570828f, -0.12719084f, 
    -0.09241135f, 0.01998674f, -0.01256997f, 0.25132743f, 0.10456232f, -0.23517118f, -0.18294193f, 0.06540614f, 
    -0.10253773f, 0.07715864f, 0.05965552f, 0.09225816f, -0.10702990f, -0.14419229f, 0.11477609f, 0.03714198f, 
    -0.01203101f, 0.00330266f, 0.00306570f, -0.00655098f, 0.08463274f, -0.01916297f, 0.01007556f, 0.02829059f, 
    -0.05035298f, -0.03258204f, 0.20494825f, 0.02607400f, -0.15676484f, 0.11940271f, 0.22243242f, 0.01111264f, 
    -0.01266426f, -0.04206363f, -0.16268417f, -0.03142058f, -0.07943211f, -0.07595227f, 0.05243937f, -0.00194438f, 
    -0.05178942f, 0.16580234f, -0.01915339f, -0.03762266f, -0.10301811f, 0.02690223f, -0.10508915f, -0.08212095f, 
    0.35072845f, 0.03263939f, 0.05718416f, -0.20090272f, 0.30367577f, 0.01868717f, -0.07771593f, -0.00484442f, 
    0.11075354f, 0.13391647f, -0.00669261f, 0.04381228f, -0.13916391f, -0.06777436f, 0.00843270f, -0.02144900f, 
    0.02609292f, -0.08769060f, 0.10740378f, 0.13459718f, 0.04737095f, 0.18252473f, 0.03506529f, -0.23937213f, 
    0.10449653f, 0.01540260f, 0.02646841f, -0.50117379f, -0.07766390f, 0.01879756f, 0.23321471f, 0.15784536f, 
    -0.08440381f, -0.09305190f, 0.13630171f, -0.05372635f, -0.08118480f, -0.03582664f, -0.15781626f, 0.12194352f, 
    0.13830046f, -0.06752219f, 0.13437989f, 0.01532846f, 0.12679559f, -0.48936665f, 0.02142129f, 0.02748998f, 
    0.07786676f, -0.00089859f, -0.05049681f, -0.07618319f, 0.08876169f, 0.01901037f, 0.03630197f, 0.04956915f, 
    -0.05999459f, -0.14856400f, -0.05794407f, -0.10146513f, -0.04039134f, 0.00419853f, -0.21779196f, 0.28390443f, 
    -0.04225842f, -0.11432542f, -0.14356579f, -0.03465588f, -0.12143742f, -0.07842734f, 0.05085419f, -0.00361043f, 
    -0.29724306f, -0.20880084f, 0.00396272f, 0.14542040f, 0.03208699f, -0.13625392f, -0.09846853f, 0.03337045f, 
    -0.09387913f, -0.27271390f, 0.02368341f, 0.14696197f, 0.08964621f, 0.08451150f, -0.05470682f, -0.03564505f, 
    -0.01276879f, -0.04378698f, 0.38433105f, 0.10795763f, 0.12588918f, 0.14075133f, -0.01235123f, 0.03973351f, 
    -0.05216862f, -0.00589631f, -0.10525788f, -0.27602625f, 0.16284627f, 0.17288285f, 0.19042547f, -0.03202941f, 
    0.06743518f, -0.08381970f, -0.14415576f, 0.02696992f, -0.01469717f, -0.05677644f, -0.02412236f, 0.24229427f, 
    0.10087288f, 0.19011134f, 0.08223397f, -0.04659285f, -0.10396434f, -0.52526277f, -0.08244281f, 0.15805909f, 
    0.10403004f, 0.08138578f, 0.08223470f, 0.13941450f, 0.04450769f, -0.18475223f, -0.20053180f, -0.20519878f, 
    0.11998466f, 0.07120004f, -0.18439737f, -0.04887126f, 0.11573838f, -0.01188562f, -0.05778489f, -0.07159075f, 
    -0.28925112f, 0.23203982f, -0.23993301f, -0.01778302f, -0.12121929f, 0.06650820f, -0.04539794f, 0.03182656f, 
    -0.13971990f, 0.04761779f, 0.06302318f, 0.11605148f, -0.08115964f, -0.01339751f, -0.11680297f, -0.05915195f, 
    0.17543212f, -0.19962423f, -0.00563691f, 0.11833390f, 0.07042149f, -0.10864403f, -0.00303130f, 0.02407539f, 
    -0.10171190f, -0.01148734f, 0.12548631f, 0.11393900f, 0.08308751f, -0.12426816f, 0.20844159f, 0.00279654f, 
    0.16475466f, -0.01441255f, 0.10428489f, -0.39588058f, -0.16026334f, -0.06841952f, -0.07955755f, 0.00351402f, 
    -0.06843349f, -0.10894346f, -0.10072539f, -0.17925349f, 0.06574719f, 0.24762866f, -0.04199416f, -0.24447788f, 
    -0.12943073f, -0.15549833f, -0.02679107f, -0.00457934f, 0.04854317f, -0.04515206f, -0.10910730f, -0.30477661f, 
    0.16997464f, 0.14296588f, -0.23233758f, -0.18389836f, 0.02280406f, 0.02741921f, 0.09439606f, 0.26812500f, 
    -0.07636433f, 0.05789767f, 0.08207023f, -0.32378745f, -0.12458220f, 0.16781567f, 0.03543646f, -0.10188831f, 
    0.00374379f, -0.21476792f, 0.06850002f, 0.15126978f, 0.01566442f, 0.04245239f, -0.00857218f, -0.11837833f, 
    -0.16967227f, -0.11725210f, 0.17128865f, -0.02158867f, -0.08864112f, 0.15543358f, 0.08723594f, -0.04041920f, 
    0.16832104f, -0.09468025f, -0.17524801f, -0.03847876f, 0.01467462f, 0.05906614f, -0.03698461f, 0.10753855f, 
    0.03703195f, 0.13926223f, 0.35676774f, -0.03673731f, 0.08405805f, -0.34136346f, 0.10673415f, -0.00389225f, 
    0.04374489f, 0.17567672f, 0.06205067f, 0.02792050f, 0.15022798f, 0.00130400f, 0.01043476f, 0.05376182f, 
    -0.02729688f, 0.03382996f, -0.06523716f, 0.05894126f, -0.08783174f, -0.12363289f, 0.01905439f, 0.07359985f, 
    0.00952217f, 0.07096381f, -0.05365108f, 0.07249362f, 0.04286640f, -0.03533933f, -0.08462961f, -0.15695633f, 
    -0.00668062f, 0.03268719f, 0.18033241f, -0.07970968f, -0.11840496f, 0.07360977f, 0.12364437f, -0.03928482f, 
    -0.03977692f, -0.04679266f, 0.04639669f, 0.15464602f, -0.00993508f, -0.18279384f, 0.06669736f, -0.05635114f, 
    0.19632740f, -0.17800112f, 0.12774304f, 0.06830598f, 0.23670778f, -0.09208016f, 0.00530376f, 0.16335668f, 
    -0.10547925f, -0.18453339f, -0.05085485f, -0.17795892f, 0.03820944f, 0.28703520f, 0.07527169f, -0.09184267f, 
    0.03502872f, 0.17611837f, -0.29234719f, 0.24869895f, -0.07401551f, -0.04365107f, 0.12667586f, 0.12848943f, 
    0.01830851f, 0.09083935f, -0.17940666f, 0.17068462f, 0.16500208f, -0.03764942f, -0.06273863f, -0.06821796f, 
    -0.01381228f, -0.18569970f, -0.08031934f, -0.08958479f, 0.06993627f, -0.03696907f, 0.13445601f, 0.03345236f, 
    0.16153742f, 0.03581508f, -0.04032043f, 0.13628887f, -0.24298058f, -0.02998584f, 0.22971509f, 0.07446631f, 
    -0.03472411f, -0.16728571f, 0.00443968f, -0.14694367f, 0.03517342f, 0.15754490f, 0.05459752f, -0.13689081f, 
    -0.07508388f, 0.14323591f, -0.02383593f, 0.00474716f, -0.00556497f, -0.05697840f, -0.15573689f, 0.01796785f, 
    -0.15415731f, 0.02094610f, 0.02991110f, 0.12507100f, -0.00418551f, -0.15609673f, 0.10638051f, -0.12842071f, 
    0.02522712f, -0.17352101f, 0.07701506f, -0.01376433f, -0.10734878f, -0.06722324f, -0.05369335f, -0.01574619f, 
    -0.07448296f, -0.00274011f, 0.04597184f, -0.02095524f, -0.00592732f, 0.11596791f, -0.03422419f, -0.02019578f, 
    -0.02864559f, 0.04279296f, -0.01014144f, 0.23784225f, -0.01890612f, -0.02907371f, 0.14766948f, 0.04275743f, 
    -0.00077393f, 0.03336447f, -0.09837621f, -0.05031658f, -0.12223011f, 0.13419293f, 0.01226135f, 0.02635183f, 
    -0.04372636f, -0.03462916f, -0.05935662f, 0.29343948f, 0.07282590f, -0.04764947f, -0.16421323f, -0.07265426f, 
    0.01139981f, 0.02841592f, 0.07974352f, -0.07864670f, 0.04250034f, -0.26748472f, 0.02234861f, 0.05591271f, 
    0.16055395f, -0.12318460f, 0.16530339f, 0.01144819f, -0.10788494f, -0.05058184f, 0.01647684f, 0.10080170f, 
    0.04096569f, -0.06887417f, 0.09106738f, 0.00430761f, -0.05671410f, 0.16385037f, -0.12072472f, 0.09775147f, 
    -0.13793378f, -0.04211923f, 0.07524669f, 0.06098080f, 0.06828524f, -0.17331879f, -0.24422352f, -0.09341370f, 
    0.05055182f, 0.10325618f, -0.08081941f, 0.03955696f, -0.11543825f, 0.12880643f, -0.12599759f, 0.01832428f, 
    -0.10002583f, -0.03244982f, 0.02179187f, 0.08395742f, -0.15348047f, 0.17017351f, -0.07531590f, 0.00576735f, 
    0.02264278f, 0.04789421f, 0.05673807f, -0.23735286f, -0.02841550f, -0.04598611f, 0.06268660f, 0.12638436f, 
    -0.02194659f, -0.08260892f, 0.25757593f, 0.13299137f, 0.25395969f, -0.10676177f, -0.00957471f, -0.00743867f, 
    -0.08307499f, 0.00656579f, 0.06129450f, 0.14438611f, 0.06429900f, -0.02670991f, -0.12719831f, -0.04552497f, 
    0.09624550f, -0.07407845f, -0.00501519f, -0.22246653f, -0.03645041f, -0.11698598f, 0.17477636f, -0.00734606f, 
    -0.04170505f, -0.09042557f, -0.10432307f, 0.05697536f, 0.01594547f, -0.25071788f, -0.19984695f, 0.29307443f, 
    0.05002255f, 0.10865405f, -0.03261054f, 0.06259672f, 0.06463418f, 0.01398540f, 0.05013262f, -0.08500825f, 
    0.11735032f, -0.15451388f, 0.02932014f, 0.04806260f, -0.06706507f, 0.06206684f, -0.08137756f, -0.00192621f, 
    0.01878590f, 0.20856364f, -0.09449443f, -0.16289040f, -0.09362973f, -0.08251353f, 0.15644734f, 0.08744448f, 
    0.10558072f, 0.01196124f, 0.21260697f, -0.13608195f, 0.08057706f, -0.11982191f, -0.00756430f, 0.12457060f, 
    0.03982978f, -0.01638168f, -0.21525274f, -0.20674050f, -0.16132709f, -0.17713864f, -0.04271256f, 0.04440525f, 
    0.14442028f, 0.02333417f, 0.17862293f, -0.17764573f, -0.32402524f, -0.14627211f, -0.23012923f, -0.08545050f, 
    0.03253442f, 0.12211989f, -0.12070741f, 0.12344328f, -0.02896229f, -0.00528010f, 0.04211600f, -0.01846447f, 
    -0.09895887f, 0.05769987f, 0.05470488f, -0.06819748f, -0.27462432f, 0.16810273f, -0.13801232f, 0.23377950f, 
    0.09164741f, -0.18795502f, 0.07584005f, -0.22054935f, 0.08032393f, -0.10664830f, -0.13305105f, -0.08714439f, 
    -0.10595776f, 0.01752619f, 0.16397263f, 0.19629414f, 0.00411630f, -0.15912819f, 0.12098504f, 0.08430015f, 
    -0.13644096f, 0.04446055f, -0.01930391f, 0.09768280f, -0.05013601f, 0.01405236f, 0.12138212f, -0.01127782f, 
    0.05530087f, 0.08507868f, 0.08897389f, 0.06183224f, 0.00095951f, 0.11355021f, 0.14469022f, 0.00201598f, 
    0.00748438f, -0.21754804f, -0.08495590f, -0.16920359f, 0.12966208f, 0.00581004f, 0.02442668f, 0.13095202f, 
    -0.22690383f, -0.20945238f, -0.03957643f, -0.13516261f, 0.04437716f, -0.17383605f, 0.06169336f, 0.04040449f, 
    0.02781782f, -0.04904231f, -0.25518987f, 0.08305911f, -0.00283321f, 0.05801484f, 0.09888358f, -0.03465904f, 
    -0.02207947f, 0.24688357f, -0.03449670f, -0.09074759f, 0.04469401f, -0.10831155f, 0.15549429f, 0.05546266f, 
    0.04414428f, 0.02135920f, -0.02520193f, 0.13044643f, -0.07720644f, 0.11921140f, -0.13828433f, 0.20629929f, 
    -0.12753922f, 0.11751639f, 0.07001826f, 0.19273514f, -0.09330492f, 0.15666987f, 0.04737089f, -0.01027982f, 
    -0.01637794f, -0.14935456f, 0.22384378f, -0.01413885f, -0.10810494f, 0.13368693f, 0.11067984f, -0.11880788f, 
    -0.18499930f, -0.13540924f, -0.03179988f, -0.06385279f, -0.03668978f, 0.07702948f, -0.07338963f, -0.36508355f, 
    -0.31264484f, -0.04280642f, 0.21320340f, 0.16765878f, 0.04511254f, 0.13712896f, -0.13772318f, 0.04369131f, 
    -0.15952106f, 0.12684788f, -0.05237713f, -0.02159819f, 0.07302035f, 0.11949847f, 0.08866575f, 0.01881930f, 
    0.03430572f, -0.15339819f, -0.23160532f, 0.18350735f, 0.05810335f, 0.07027049f, 0.14041726f, 0.01513515f, 
    -0.06522073f, 0.11778713f, 0.05090162f, 0.06466047f, -0.12485348f, 0.06332666f, -0.10062861f, -0.02312550f, 
    -0.10555840f, -0.16528849f, -0.09844750f, 0.18909732f, 0.16203073f, 0.06319670f, -0.08624378f, 0.10676087f, 
    0.05399807f, 0.05108694f, 0.06136562f, 0.06421869f, -0.03680671f, -0.06856038f, -0.01286881f, -0.06889117f, 
    0.13034493f, -0.17289194f, 0.13763110f, 0.06827462f, -0.06059150f, -0.20104012f, 0.20753308f, 0.11133551f, 
    0.25119156f, 0.09406765f, -0.00495214f, 0.05708062f, 0.08587147f, 0.06928352f, -0.08204263f, 0.18746017f, 
    0.00928776f, 0.13688645f, 0.04587246f, -0.00666303f, 0.11575630f, -0.04601813f, -0.04211715f, -0.25185484f, 
    -0.00223792f, 0.05596492f, -0.03258060f, 0.01296364f, -0.07475669f, 0.04954196f, 0.04912278f, 0.02683822f, 
    -0.01233756f, -0.16983099f, -0.17188288f, 0.11106319f, 0.01358073f, -0.01657809f, -0.07258285f, 0.00045284f, 
    0.01254740f, 0.00695240f, 0.07219443f, -0.02888005f, 0.13354877f, 0.04092051f, 0.00566054f, 0.06445184f, 
    0.11324178f, 0.17243671f, -0.27543914f, -0.00505922f, 0.14873305f, -0.08965303f, 0.02220133f, 0.05804449f, 
    -0.01627980f, -0.03787516f, 0.09158259f, 0.06289721f, 0.06238508f, 0.02158487f, -0.01563714f, 0.10719150f, 
    -0.03976650f, 0.01672490f, 0.04455480f, 0.00801174f, -0.09395912f, -0.15577511f, 0.00080000f, -0.05629424f, 
    -0.03751277f, -0.07401578f, 0.00024455f, -0.02562594f, -0.09360904f, -0.12659186f, 0.18574823f, 0.03535896f, 
    0.10610945f, -0.04673730f, 0.00938874f, 0.02475821f, 0.05846138f, -0.00443400f, -0.28429323f, 0.02079037f, 
    -0.04963069f, -0.13822557f, 0.10854987f, 0.15721741f, -0.02126122f, -0.03332128f, -0.06795507f, 0.01698213f, 
    0.14112028f, 0.12391338f, -0.02278116f, -0.03429918f, 0.08980428f, -0.01752199f, 0.09325893f, 0.07761358f, 
    0.00239359f, -0.05043323f, -0.03510777f, -0.02325108f, 0.04609319f, -0.02975530f, -0.03887572f, 0.03498216f, 
    0.00447219f, 0.04690678f, 0.00148210f, 0.01970414f, 0.04449328f, -0.05379776f, -0.01554039f, -0.04466409f, 
    0.00164139f, 0.01389799f, 0.04780914f, -0.05482390f, 0.01059893f, -0.00222473f, 0.00648317f, 0.01633231f, 
    0.01288351f, -0.05357708f, -0.05376647f, -0.03170414f, 0.03911105f, -0.02665627f, 0.03336779f, -0.02999097f, 
    -0.05565076f, -0.03794045f, 0.05058981f, 0.01445886f, -0.06073641f, 0.04682762f, 0.00447817f, -0.04046190f, 
    0.02789627f, 0.02300375f, -0.02380007f, 0.04529653f, 0.01513195f, 0.04560960f, 0.00267375f, 0.00955690f, 
    -0.00585787f, 0.01081075f, -0.04882107f, -0.02526851f, -0.01641604f, -0.04576099f, 0.03213148f, -0.02428609f, 
    0.05583658f, -0.01922051f, -0.04459723f, -0.02852795f, -0.04452204f, -0.03624711f, -0.05788730f, -0.03334003f, 
    0.03147230f, -0.01813766f, 0.03289168f, -0.02474969f, -0.02603297f, 0.03350227f, -0.05393204f, -0.03592350f, 
    0.00987816f, 0.01187245f, 0.02476830f, -0.02901123f, 0.05795118f, -0.03444744f, 0.03441701f, -0.02635740f, 
    0.00469558f, 0.01233847f, -0.02891563f, -0.04678423f, -0.05914427f, -0.01436979f, 0.00968971f, 0.05789571f, 
    -0.02710640f, -0.04063841f, 0.02882376f, 0.01315418f, -0.02994585f, 0.04684381f, -0.02507907f, 0.01447844f, 
    -0.00415076f, 0.03403346f, -0.00167427f, 0.05381503f, 0.00272471f, 0.04702654f, -0.04291915f, -0.01902424f, 
    -0.02636774f, -0.06359608f, 0.02056976f, 0.01918875f, 0.02971745f, 0.02879299f, -0.00075719f, -0.05769228f, 
    0.00104757f, 0.01759138f, -0.04125093f, -0.03737970f, -0.02226268f, -0.02015628f, 0.02382790f, -0.03410766f, 
    0.03496615f, 0.01241608f, 0.01267111f, -0.01722015f, -0.01541052f, -0.03348605f, -0.03927535f, -0.02333197f, 
    -0.04965879f, -0.02765407f, -0.02869978f, 0.05228277f, -0.00053832f, 0.04110569f, -0.01418850f, -0.01525679f, 
    -0.01300370f, -0.01902581f, -0.06349712f, 0.00213297f, -0.00275588f, 0.03563609f, 0.01066930f, -0.04828177f, 
    0.05051948f, -0.04280827f, 0.00600695f, -0.03722572f, 0.03070462f, -0.06222266f, 0.03673826f, -0.06351475f, 
    0.03013950f, 0.03895402f, 0.00523092f, 0.03270909f, -0.00273752f, -0.04908765f, 0.04149751f, 0.04821278f, 
    -0.00187615f, -0.04754133f, 0.01486526f, -0.01348932f, -0.05513398f, -0.00625617f, -0.01333104f, -0.01164941f, 
    0.01822888f, -0.01707510f, -0.04352538f, -0.05972565f, 0.04080537f, -0.04632426f, -0.00785486f, -0.00697539f, 
    -0.03068248f, 0.04182927f, -0.05504049f, -0.06365831f, -0.00830557f, 0.04226179f, -0.01435063f, 0.01671213f, 
    -0.00075529f, -0.02502911f, -0.01143730f, -0.00622935f, -0.05671619f, -0.01885825f, -0.04823997f, 0.02360367f, 
    0.01966213f, 0.03897035f, -0.04282143f, -0.00164741f, 0.02132736f, 0.00370449f, -0.03518463f, -0.04858305f, 
    0.04346400f, -0.04946871f, -0.02295427f, -0.04473414f, -0.00222658f, -0.06196927f, -0.02732053f, 0.00355164f, 
    -0.00425069f, -0.03398231f, -0.00940094f, 0.02122558f, -0.00642224f, -0.05599177f, 0.02200933f, 0.01073719f, 
    -0.00616069f, 0.01527672f, 0.01325409f, 0.04803527f, -0.04443152f, 0.04903482f, -0.05811287f, 0.00445988f, 
    0.02815022f, -0.02361960f, -0.01871654f, 0.03694933f, 0.04846691f, -0.02972944f, -0.03433925f, 0.00612029f, 
    0.00133534f, -0.00347676f, 0.04256429f, -0.05023740f, -0.00819912f, 0.00385827f, 0.01943713f, 0.04814967f, 
    0.01972603f, 0.03006330f, 0.00949331f, -0.06611780f, -0.06145436f, -0.05659145f, -0.00807924f, -0.01888540f, 
    0.00535193f, -0.01177007f, -0.06099704f, -0.01685849f, -0.00282800f, -0.00505416f, -0.02767726f, 0.02018316f, 
    -0.01690581f, -0.01935077f, -0.05353540f, 0.02473513f, -0.02271281f, 0.01424586f, 0.02735603f, -0.06337695f, 
    0.02715100f, -0.04892762f, -0.05759090f, 0.01880092f, -0.01855967f, 0.04173383f, -0.01169936f, -0.04032160f, 
    0.04524970f, -0.01097692f, -0.05506244f, -0.00740620f, -0.02504089f, -0.03526814f, -0.05367455f, -0.05218123f, 
    0.02432276f, 0.01801229f, -0.02370569f, -0.05854814f, 0.01158764f, -0.06256381f, 0.03279155f, 0.01170028f, 
    0.04814103f, 0.03409364f, -0.04232476f, -0.00727598f, 0.02505503f, -0.06476384f, 0.01756840f, 0.02037813f, 
    0.00379392f, -0.03061221f, 0.05046992f, 0.01874895f, 0.03188736f, -0.00547354f, -0.05739674f, -0.02856082f, 
    0.01806965f, 0.02466386f, 0.00055692f, -0.02780894f, -0.04114492f, 0.01582025f, 0.02273034f, -0.04638632f, 
    0.00276879f, 0.03645080f, 0.02353400f, -0.04343138f, -0.03891049f, -0.02776790f, 0.04476013f, 0.02220627f, 
    -0.01299660f, -0.06549624f, -0.04546624f, -0.03665362f, 0.02121440f, -0.03559868f, -0.05070842f, -0.02998609f, 
    -0.01645995f, -0.03850174f, -0.01961564f, 0.02039268f, 0.00183454f, -0.06118830f, -0.04008264f, -0.02162435f, 
    -0.05492288f, 0.03103601f, -0.00524599f, 0.02976658f, 0.05171265f, 0.03918235f, -0.00792854f, -0.04625760f, 
    -0.01539016f, 0.04317060f, -0.01284880f, -0.06083313f, 0.02402007f, 0.00380332f, 0.04331434f, -0.04363827f, 
    0.02179297f, 0.00723255f, -0.00846511f, -0.02852205f, -0.03097138f, -0.03802686f, 0.01170363f, 0.01426514f, 
    -0.01598824f, 0.02703518f, -0.05028876f, -0.00404418f, -0.03518805f, 0.04613424f, 0.01801385f, -0.03449568f, 
    0.03372319f, -0.03183112f, 0.03911097f, -0.04829803f, 0.01336329f, -0.06484833f, -0.03561777f, 0.03958623f, 
    0.00601985f, 0.04533263f, 0.04592825f, -0.05883109f, -0.06706683f, -0.00630016f, -0.06225756f, 0.04151409f, 
    -0.01204876f, -0.00671128f, -0.01208131f, 0.00739817f, -0.00451324f, 0.04589096f, -0.02191112f, -0.05790632f, 
    -0.01046486f, -0.02143816f, -0.06461768f, -0.04211311f, 0.02213263f, -0.06231022f, 0.02791210f, -0.05998712f, 
    -0.04026030f, 0.02021150f, -0.00350252f, 0.03368317f, 0.01190670f, 0.00839991f, -0.05404568f, -0.04619028f, 
    -0.06629877f, 0.02673661f, -0.03412089f, -0.02661234f, 0.01091459f, -0.06643267f, -0.02965282f, -0.02588135f, 
    -0.04855809f, 0.00684818f, -0.00153361f, -0.03918723f, -0.02966746f, 0.01596827f, 0.00655482f, -0.04796981f, 
    -0.05538254f, -0.01794236f, 0.02378502f, -0.01323862f, 0.02946563f, 0.01468647f, -0.01813409f, -0.06031655f, 
    0.03384320f, 0.03907178f, -0.03788423f, 0.04360268f, 0.03366625f, -0.01975284f, 0.04278335f, -0.03115424f, 
    -0.01829021f, -0.01980820f, 0.03966830f, -0.05155383f, -0.03678371f, 0.02589828f, 0.04369458f, 0.01087573f, 
    -0.02980493f, 0.02448781f, 0.04011221f, -0.00184986f, -0.05963989f, 0.01820798f, 0.01231205f, 0.02910146f, 
    -0.03080139f, 0.03650917f, -0.00586977f, 0.00194424f, -0.00908864f, -0.06740357f, 0.04323025f, 0.02560815f, 
    0.03265057f, -0.07498989f, -0.01479295f, -0.04505406f, 0.03673025f, 0.01844271f, 0.04328081f, 0.00624962f, 
    -0.00003530f, -0.05669171f, 0.01101516f, -0.06518037f, 0.04761025f, -0.06131195f, -0.03223592f, -0.02503196f, 
    -0.06473298f, -0.01897209f, -0.00772428f, 0.01499684f, -0.04981577f, 0.04273300f, -0.05364791f, 0.00151521f, 
    0.00564373f, -0.04780169f, 0.01368636f, 0.02010482f, 0.04306422f, 0.02285153f, -0.04229149f, 0.00726693f, 
    0.02730832f, 0.05254958f, -0.05168748f, -0.02142693f, 0.04616504f, 0.04816187f, -0.01903033f, -0.06771651f, 
    -0.02813552f, 0.02553847f, -0.01742591f, -0.04182992f, -0.01485019f, 0.00445348f, 0.05080080f, -0.01594654f, 
    0.00372734f, 0.03258319f, -0.04058501f, 0.03903659f, -0.02499728f, 0.00715172f, -0.00344797f, -0.05008236f, 
    -0.03060942f, 0.01567243f, 0.01674934f, 0.03193258f, -0.02662146f, 0.01980011f, 0.04743267f, 0.02500872f, 
    0.04248073f, 0.01754411f, -0.03496830f, 0.04118453f, -0.01650480f, 0.00923291f, -0.03950042f, -0.00469471f, 
    0.02360030f, -0.04354354f, -0.01236368f, -0.00214903f, -0.04499577f, 0.02709811f, -0.00422325f, 0.02325200f, 
    -0.03514511f, -0.03731687f, -0.02469938f, 0.01955425f, 0.03452180f, -0.01549941f, -0.03951512f, -0.04148081f, 
    0.03222618f, 0.01013053f, 0.00191441f, -0.05213385f, 0.01188843f, -0.05013788f, -0.04511512f, 0.01832581f, 
    -0.04984340f, 0.00541718f, -0.00473340f, -0.05651895f, -0.05069591f, 0.01477528f, -0.06408753f, -0.03795641f, 
    -0.06059541f, -0.06250379f, -0.01501250f, -0.03061660f, -0.02838436f, 0.02619616f, 0.04981981f, 0.03917563f, 
    -0.13528691f, 0.27281067f, 0.00832409f, 0.11683654f, 0.09119976f, -0.06435533f, 0.07279907f, 0.02594754f, 
    0.07462448f, 0.22536506f, -0.05067232f, -0.16892843f, 0.01913595f, 0.09212524f, 0.20796712f, 0.08349254f, 
    -0.08928464f, 0.06486734f, -0.33676085f, -0.14576794f, -0.28531879f, 0.10498428f, -0.02382525f, -0.00657034f, 
    0.10337993f, 0.10995372f, -0.03337339f, -0.07024148f, -0.06645105f, 0.03572104f, -0.03001178f, 0.11846436f, 
    0.17391926f, -0.14279976f, 0.14399002f, 0.05214343f, -0.16033632f, 0.16779914f, -0.44027728f, 0.02113718f, 
    0.17468618f, 0.10758192f, 0.13247874f, 0.01031714f, -0.03279577f, 0.00728492f, -0.24608216f, 0.12262870f, 
    0.13475764f, 0.04958311f, 0.01355683f, -0.06225326f, -0.07533041f, 0.15351370f, 0.23589149f, -0.16859268f, 
    0.00182630f, 0.04165417f, 0.13004282f, -0.12360071f, 0.05648306f, 0.09452686f, -0.03301046f, 0.23297402f, 
    0.03290751f, 0.07376024f, -0.07667789f, -0.19909857f, -0.20205595f, 0.06949602f, 0.15173291f, 0.01645811f, 
    -0.24465123f, 0.04143393f, -0.07039721f, 0.10710140f, 0.03999406f, 0.14793576f, -0.08642646f, -0.10830581f, 
    0.04018320f, 0.02731078f, -0.02256643f, -0.32164681f, 0.08748536f, -0.17748046f, 0.00512133f, -0.04415883f, 
    -0.36352727f, 0.12318410f, -0.20326276f, -0.08202507f, 0.17332947f, 0.10292678f, -0.05665924f, 0.06946301f, 
    0.00062033f, 0.00536210f, -0.02829682f, 0.43572706f, 0.19971041f, 0.25960180f, 0.16332516f, -0.12363324f, 
    0.01736725f, 0.14378947f, 0.09356564f, -0.03584867f, -0.35883904f, -0.08199053f, -0.23853762f, -0.14681476f, 
    0.08642480f, 0.09100044f, -0.05344745f, 0.02361364f, -0.05118422f, -0.80864465f, -0.11285124f, -0.19806518f, 
    -0.07375323f, -0.01813378f, 0.05204463f, 0.03878491f, -0.09553422f, 0.10453766f, 0.23562130f, 0.24528112f, 
    0.10917293f, -0.17942299f, -0.09099132f, -0.03907578f, 0.06125635f, 0.05675070f, 0.02849781f, 0.19870171f, 
    0.08532464f, 0.01807590f, -0.03265179f, -0.11198188f, 0.06003220f, 0.01356794f, 0.06969173f, 0.18733352f, 
    0.20869705f, 0.11996192f, 0.10862704f, 0.13165210f, 0.08761593f, -0.15180612f, -0.05595629f, 0.18012431f, 
    0.01825040f, 0.34951887f, 0.11666530f, -0.00235182f, 0.04412143f, -0.06071418f, 0.08134133f, 0.01978782f, 
    0.04959229f, 0.00158264f, -0.23885342f, -0.19098790f, -0.11592064f, -0.02679279f, -0.01227132f, 0.04624434f, 
    -0.01434597f, 0.00691218f, -0.12749958f, -0.47060734f, -0.31721678f, -0.01982013f, 0.00251576f, 0.04406459f, 
    0.00821498f, -0.06447925f, -0.06913856f, 0.02629207f, -0.14900425f, 0.02522987f, -0.14638878f, -0.03574548f, 
    0.10816870f, -0.00105875f, -0.03696203f, 0.09711969f, -0.13034125f, -0.48253995f, -0.29601216f, 0.12478478f, 
    -0.15733036f, 0.16119142f, -0.02880357f, 0.10220343f, -0.17137733f, 0.04927515f, 0.20033689f, -0.11017106f, 
    0.18864684f, 0.05569119f, -0.00359926f, -0.05946410f, 0.05421051f, 0.00160727f, 0.04091946f, 0.28200984f, 
    0.17967531f, 0.12982614f, -0.08267716f, -0.03959755f, -0.16624406f, 0.02165502f, 0.06205497f, 0.17269555f, 
    0.23138240f, 0.05999829f, 0.07180590f, 0.02991378f, -0.13766962f, 0.17004710f, 0.07097878f, 0.09016646f, 
    0.01847160f, 0.03982968f, 0.04759772f, -0.06136807f, -0.05978445f, 0.11409563f, 0.01355117f, 0.04451789f, 
    0.02414546f, 0.16505432f, 0.02035561f, 0.17494029f, 0.00314526f, 0.05100047f, 0.12077089f, 0.10510418f, 
    0.02595950f, -0.07820702f, -0.00114286f, -0.06567355f, -0.15588847f, -0.10783205f, -0.08048280f, -0.00650391f, 
    0.05381991f, 0.06633125f, -0.09044115f, 0.08713059f, 0.44253370f, -0.10005014f, 0.06585973f, 0.05937284f, 
    -0.03872409f, -0.10408499f, -0.08605459f, -0.04691093f, 0.11399534f, -0.09947819f, -0.01930975f, -0.29717207f, 
    0.12509228f, 0.01983926f, 0.11292794f, -0.15026225f, 0.11455332f, -0.18318008f, 0.03812268f, -0.03218815f, 
    0.06438642f, 0.04690326f, 0.20267324f, 0.00828629f, -0.18021770f, 0.04412306f, -0.01616552f, -0.33858997f, 
    -0.43550646f, -0.18756033f, 0.08372577f, 0.11519961f, 0.00346128f, -0.05627440f, -0.05568995f, -0.22021100f, 
    -0.02186057f, 0.04036533f, 0.03710184f, 0.00280422f, 0.03958002f, 0.04499242f, -0.00150153f, 0.02876934f, 
    -0.02747178f, 0.03075317f, -0.05863459f, 0.02427182f, -0.02730696f, -0.02727348f, -0.05842302f, -0.01646891f, 
    -0.00396162f, -0.05265988f, -0.04770650f, -0.03287901f, 0.02748216f, 0.03362580f, -0.00627670f, -0.00692186f, 
    0.02121875f, -0.06071695f, 0.01509729f, 0.02128565f, -0.03396757f, -0.01293040f, -0.04408586f, 0.01119508f, 
    -0.02340693f, 0.04556657f, 0.03134312f, -0.03874053f, -0.06390724f, 0.02795138f, 0.01595644f, -0.06046971f, 
    -0.03073335f, -0.06130119f, 0.04422831f, 0.03261375f, 0.04813702f, -0.04954893f, 0.02865455f, -0.01694917f, 
    -0.05127367f, -0.01666831f, 0.01737952f, -0.02809241f, 0.02683432f, 0.04859001f, -0.06699938f, -0.00382570f, 
    -0.03280624f, -0.00646292f, -0.06142789f, 0.01136105f, 0.04182496f, -0.05096451f, -0.05626427f, -0.01325703f, 
    -0.04443900f, 0.02033725f, 0.00937991f, 0.01133026f, 0.01646570f, 0.04871386f, 0.04922654f, -0.04796968f, 
    -0.05616691f, 0.03579591f, -0.05434067f, 0.02018016f, 0.02740335f, -0.00007135f, -0.03403701f, -0.04463173f, 
    0.01270222f, 0.04328395f, 0.02872470f, -0.02697362f, -0.04845180f, 0.00349137f, 0.02849684f, 0.01039026f, 
    0.03842294f, -0.02353623f, 0.04472883f, 0.00583749f, 0.03396995f, -0.01941231f, 0.01638592f, -0.01224521f, 
    -0.05224631f, -0.03228466f, 0.00144730f, 0.02282058f, -0.05087629f, 0.04621488f, -0.03182717f, -0.01958730f, 
    -0.01964731f, -0.01314655f, 0.02624924f, -0.02153980f, -0.00395316f, -0.06300694f, 0.01682095f, -0.03475258f, 
    -0.01739029f, 0.02130390f, -0.05549192f, 0.03389987f, -0.01805235f, -0.03395622f, -0.01134296f, -0.06739179f, 
    -0.06415080f, -0.01215634f, 0.03913757f, 0.03039514f, -0.04737886f, -0.00226972f, -0.06356466f, 0.02380944f, 
    -0.00509490f, 0.02925374f, -0.04126298f, -0.01372918f, -0.01660833f, 0.01661582f, -0.05523633f, 0.04470111f, 
    -0.02622297f, 0.01708586f, -0.00024029f, 0.03001730f, 0.02658659f, -0.03668056f, -0.01853050f, 0.03906568f, 
    -0.04694204f, -0.03454449f, -0.01973535f, -0.03852530f, 0.02754864f, 0.01939808f, -0.00261194f, 0.04050639f, 
    -0.00649586f, -0.00559709f, -0.01142216f, -0.03142347f, -0.01356757f, -0.02726411f, -0.05532988f, 0.01836599f, 
    0.04928843f, -0.04773606f, 0.01177729f, -0.03975123f, -0.02465213f, -0.02242826f, -0.02435302f, -0.06194115f, 
    -0.04767699f, -0.01894277f, -0.03183854f, -0.03028578f, -0.06278285f, -0.05047660f, 0.02514640f, 0.01397236f, 
    0.04843575f, 0.00706992f, -0.00520958f, 0.00141503f, 0.00630985f, 0.04397040f, 0.04925077f, -0.03154707f, 
    -0.01044806f, -0.03941802f, -0.06055880f, 0.01238062f, -0.04305402f, -0.01408648f, -0.04048274f, 0.05091030f, 
    -0.03743444f, 0.00000307f, -0.03432913f, 0.06415194f, -0.04076305f, 0.03096497f, -0.06680041f, -0.00308539f, 
    -0.02469075f, -0.01391627f, -0.01570434f, 0.05447857f, -0.02649154f, 0.00836488f, 0.04363617f, -0.00597240f, 
    0.02789560f, 0.00948383f, -0.03190473f, 0.03969240f, -0.00563484f, -0.03094245f, 0.00689367f, 0.00974075f, 
    -0.03916023f, 0.03212592f, -0.04175401f, -0.01056268f, -0.02332665f, -0.04916721f, -0.03730704f, -0.01372727f, 
    -0.04854945f, -0.01494571f, 0.01448810f, 0.02938415f, 0.04613055f, 0.03493626f, 0.00954537f, 0.02779541f, 
    -0.06110191f, -0.04438510f, -0.06646322f, -0.02325532f, -0.05316124f, 0.01779848f, -0.06312730f, -0.06556230f, 
    -0.00315529f, 0.04330818f, 0.02094644f, 0.04249913f, 0.03958527f, -0.01945912f, 0.00521866f, 0.03261972f, 
    0.01287515f, -0.03061093f, 0.03360732f, -0.03084384f, -0.05019684f, -0.01657389f, -0.00837077f, 0.04146153f, 
    -0.06417646f, 0.00192800f, -0.04524330f, -0.03619714f, -0.03298453f, -0.00411539f, -0.03827277f, -0.01426455f, 
    -0.02076819f, -0.04858804f, 0.00738092f, -0.04913837f, -0.03507649f, 0.03753550f, -0.03962011f, -0.02712829f, 
    0.02076710f, -0.04858394f, 0.04580961f, -0.00071884f, -0.00563194f, 0.03642105f, 0.02393216f, 0.02361743f, 
    -0.01210980f, -0.06215833f, 0.00235419f, -0.04200792f, 0.04263444f, -0.02130336f, -0.03078066f, -0.06151801f, 
    0.01803962f, -0.03828533f, -0.01127926f, -0.03268909f, -0.05648571f, -0.02081962f, 0.03455061f, 0.02252144f, 
    0.01546867f, -0.03744845f, -0.04036661f, 0.01024527f, -0.04792703f, -0.05481354f, -0.01281072f, -0.04214000f, 
    -0.04118209f, -0.05607102f, 0.01772348f, -0.01162759f, -0.05546424f, -0.01097394f, -0.00144908f, 0.05213754f, 
    0.04559736f, -0.00099648f, -0.04868737f, -0.02119481f, -0.03742649f, 0.05585050f, -0.02965067f, 0.04840376f, 
    -0.04416278f, -0.03819922f, 0.02119592f, -0.04579896f, 0.02704639f, -0.00322145f, -0.05161710f, -0.04904901f, 
    -0.04749162f, 0.01674497f, 0.00263452f, -0.02385746f, 0.04383859f, -0.02059312f, -0.05553320f, 0.01159636f, 
    0.01984511f, 0.01377982f, 0.03316677f, -0.05148355f, -0.05287293f, -0.05198091f, -0.05567580f, 0.00340093f, 
    0.01971876f, -0.03537788f, -0.01070235f, -0.01899307f, -0.05138965f, -0.02159612f, -0.00146575f, -0.01911298f, 
    0.03566520f, -0.05004486f, -0.01100687f, 0.01516803f, -0.01782970f, 0.05624474f, -0.01861965f, 0.03260340f, 
    0.04389112f, -0.03259924f, 0.01090928f, -0.02810534f, -0.04291368f, 0.02495657f, 0.04829453f, -0.02448806f, 
    0.01943369f, 0.02684443f, 0.02951055f, -0.05292718f, 0.00347932f, 0.04783416f, 0.02162950f, -0.01667319f, 
    -0.01882731f, 0.05721848f, 0.01863191f, -0.00240594f, -0.02652794f, -0.03127929f, 0.03549326f, 0.02064230f, 
    -0.01597285f, -0.01324609f, 0.05438289f, -0.04739418f, 0.01855290f, -0.02739438f, -0.05342447f, -0.05887956f, 
    -0.02938856f, -0.02067095f, -0.00241012f, -0.00000539f, 0.04974749f, -0.04111418f, -0.01357299f, 0.02404224f, 
    0.03224800f, -0.04725454f, 0.03915606f, 0.05709732f, -0.02426193f, -0.02363715f, -0.04983427f, -0.04192237f, 
    -0.04112028f, 0.05439762f, -0.01910348f, -0.01722160f, -0.02024629f, -0.03759135f, -0.01984941f, -0.03711259f, 
    0.03119122f, -0.00962041f, -0.04192410f, -0.02641847f, -0.01498259f, -0.03907346f, 0.02448511f, -0.04556641f, 
    0.03310372f, -0.00247352f, 0.04790264f, -0.05686256f, -0.05772814f, -0.03655326f, -0.03437703f, -0.03807412f, 
    -0.05467856f, 0.00969528f, -0.05245173f, 0.05058627f, 0.04272053f, -0.03369929f, 0.01604761f, 0.04349947f, 
    0.00170211f, 0.00506954f, -0.04801522f, -0.01849060f, 0.04367200f, -0.00488508f, -0.03016241f, -0.04270057f, 
    -0.02107501f, -0.02228285f, -0.00670800f, 0.05014094f, -0.05873305f, -0.02059738f, -0.04705828f, -0.03694979f, 
    0.01004934f, 0.02741803f, -0.04869704f, -0.05081350f, -0.05509738f, -0.01125135f, 0.02377064f, -0.00422867f, 
    -0.04382202f, -0.03968642f, 0.02013544f, -0.01075170f, 0.04007953f, -0.04666062f, -0.05079357f, 0.02583878f, 
    0.02945135f, -0.01222916f, -0.01070135f, -0.03875154f, -0.05000577f, -0.04160857f, -0.04167295f, -0.03012181f, 
    0.01917550f, -0.04751793f, 0.00328650f, 0.04440851f, 0.01188573f, 0.04088264f, 0.03142735f, 0.05233509f, 
    0.01242578f, 0.02648551f, -0.02983227f, -0.05192535f, -0.01314168f, 0.01405677f, 0.04318681f, -0.01320141f, 
    -0.02298262f, -0.02387753f, 0.03028065f, 0.05362584f, 0.02891676f, 0.00801040f, -0.02131648f, 0.03103808f, 
    0.00618253f, -0.05312237f, 0.01756889f, 0.00023314f, -0.01068547f, 0.04375023f, 0.00203064f, -0.04739078f, 
    -0.01172387f, -0.00229628f, 0.00228439f, -0.02804082f, 0.03282902f, -0.05073057f, 0.03807047f, -0.02855186f, 
    -0.02376260f, -0.02329281f, -0.05230685f, -0.04533249f, 0.01500152f, -0.05118733f, -0.05459204f, -0.03947127f, 
    -0.01713853f, 0.04154601f, -0.00071307f, -0.04843815f, 0.00010287f, 0.01976745f, 0.03759145f, 0.00207112f, 
    -0.04671127f, 0.03424129f, -0.00541360f, -0.00464225f, 0.01688979f, -0.04939580f, -0.05774119f, 0.05649724f, 
    0.00526647f, -0.00560826f, 0.01539336f, 0.00622571f, 0.04360665f, 0.03189971f, -0.02709255f, -0.02429337f, 
    -0.03312343f, -0.01102307f, 0.03071377f, -0.05199624f, -0.00132607f, -0.02364986f, 0.01560793f, 0.02125334f, 
    -0.02787580f, 0.01040926f, 0.03738930f, -0.03694751f, 0.01084336f, -0.03840977f, 0.05623403f, 0.00919120f, 
    0.02574274f, 0.04867667f, -0.01814126f, 0.02910084f, -0.01552492f, 0.04521874f, 0.00464378f, -0.00047872f, 
    -0.07875725f, 0.15071800f, 0.15235616f, -0.02054592f, 0.00241301f, 0.02831260f, -0.05996081f, 0.04506949f, 
    -0.01815048f, -0.11069982f, -0.26169086f, -0.26903275f, -0.03985472f, -0.04869619f, -0.09173615f, -0.08819985f, 
    -0.13568306f, 0.05251257f, 0.14510663f, 0.09170701f, -0.12166647f, -0.12934868f, -0.10904862f, -0.08016434f, 
    -0.02679706f, -0.14699781f, -0.16313882f, 0.19172683f, -0.14415382f, 0.07800267f, 0.01836799f, -0.05374484f, 
    0.00529421f, -0.02098552f, -0.03098157f, -0.02075284f, 0.04854415f, -0.04847502f, 0.22846831f, 0.04080478f, 
    0.09289086f, 0.06434821f, 0.06594563f, -0.12349829f, 0.05648420f, 0.14823522f, 0.02032042f, 0.03468451f, 
    -0.04848740f, -0.05433461f, 0.03260256f, 0.05588985f, -0.04740024f, -0.00264951f, 0.31133696f, -0.20980559f, 
    -0.03267559f, -0.02291007f, 0.01485554f, 0.00849537f, 0.21256813f, -0.10725322f, -0.03701421f, 0.14220372f, 
    0.02351587f, -0.11835230f, 0.01164405f, 0.08175638f, 0.09377022f, -0.11361713f, 0.08506548f, 0.00524689f, 
    0.02426761f, -0.06695422f, -0.10156231f, 0.16443600f, -0.03332290f, -0.05056418f, -0.02415342f, -0.04531643f, 
    0.11060425f, 0.10705005f, -0.05748446f, 0.11921306f, -0.16479899f, 0.07322969f, -0.03230209f, -0.13263980f, 
    0.13669398f, -0.06758104f, 0.07968716f, 0.12407368f, -0.14787769f, -0.06132412f, 0.02265143f, -0.20947920f, 
    0.01645936f, 0.19822539f, 0.08954827f, 0.07293983f, 0.17656383f, 0.12787457f, 0.10547756f, -0.13310717f, 
    -0.04416162f, -0.14252299f, 0.10722542f, 0.06921187f, 0.08175171f, 0.26538557f, 0.07458930f, 0.08513246f, 
    0.05871076f, 0.08283670f, 0.15318407f, -0.10717014f, 0.08769341f, 0.21455200f, 0.03866823f, 0.05924136f, 
    0.05342234f, -0.01358139f, 0.02331746f, -0.01792382f, -0.04854156f, 0.00882263f, -0.21080709f, 0.10549559f, 
    -0.27573431f, 0.05656381f, 0.00952222f, -0.03970120f, -0.09010047f, 0.00489806f, -0.07060133f, -0.12742816f, 
    -0.02543043f, -0.24845769f, -0.08822007f, -0.04683136f, -0.07410878f, 0.13745710f, -0.26142240f, -0.03248339f, 
    -0.15416299f, -0.08997372f, 0.05036068f, -0.03625111f, -0.03070328f, -0.06700344f, -0.02322964f, -0.09043311f, 
    -0.01677123f, 0.01155576f, -0.08337812f, 0.16947237f, -0.21800572f, -0.09949242f, -0.05583679f, -0.04974109f, 
    -0.09688947f, -0.06767438f, 0.22461756f, 0.03062016f, -0.06635711f, -0.15052642f, 0.17600870f, 0.08504822f, 
    0.11637477f, -0.18058451f, -0.12552553f, 0.19128752f, 0.36325535f, 0.14936022f, -0.00641271f, 0.03111526f, 
    0.13496001f, -0.05545291f, 0.06618492f, -0.10682736f, 0.00562108f, -0.13891374f, 0.13835633f, 0.06497781f, 
    -0.07195245f, -0.22562930f, 0.05441529f, 0.01025811f, -0.11909474f, 0.08884721f, 0.11652640f, 0.01143025f, 
    0.17749044f, 0.10903873f, 0.00212881f, -0.01894563f, 0.05138836f, 0.24464521f, -0.03351307f, 0.02298768f, 
    -0.06479700f, 0.08195648f, -0.01816094f, 0.07911097f, 0.03480155f, -0.04909309f, -0.15300648f, -0.23363718f, 
    -0.08124545f, -0.06105700f, -0.01466228f, -0.01651782f, -0.20574406f, 0.03592626f, 0.04879226f, 0.00603936f, 
    -0.12565589f, -0.05786680f, -0.17144367f, -0.06697546f, -0.12023085f, -0.02787922f, -0.16012631f, -0.07979640f, 
    0.07388939f, 0.07468317f, 0.09269297f, -0.09458736f, -0.09748960f, -0.04000504f, -0.08012059f, 0.04940436f, 
    0.04920634f, -0.17679940f, 0.09851083f, -0.19285193f, 0.02039799f, -0.19922835f, -0.00532843f, -0.09997455f, 
    -0.02798234f, -0.17133687f, -0.07189918f, 0.22636291f, 0.18434465f, 0.11844977f, -0.04097258f, -0.13517416f, 
    0.00638619f, -0.01306984f, -0.03051924f, -0.21917050f, -0.42586133f, 0.14930141f, -0.22007115f, -0.03978470f, 
    -0.09122157f, -0.25975975f, -0.09511210f, -0.00484625f, -0.10243502f, -0.00164307f, 0.22438525f, 0.25057408f, 
    0.01498746f, 0.01109799f, 0.13974151f, 0.11387707f, 0.11087248f, -0.05723678f, 0.21325530f, -0.07060806f, 
    0.32557246f, 0.17869824f, -0.02413679f, -0.11481166f, -0.02036209f, 0.16772726f, 0.12372112f, 0.12560536f, 
    0.25879586f, 0.23919846f, 0.18353328f, 0.18887934f, 0.06891622f, -0.10941426f, -0.13912115f, 0.05849827f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.17373976f, 0.01525753f, -0.02615412f, -0.05009132f, 0.08191446f, 0.13189313f, 0.10615606f, 0.05876471f, 
    0.07950820f, 0.13557225f, -0.04594049f, 0.16994968f, -0.05465468f, 0.12579206f, -0.04092928f, 0.01655155f, 
    -0.06327987f, -0.00798234f, 0.01354704f, 0.03388909f, 0.23635454f, 0.19543882f, 0.02211396f, -0.00885912f, 
    -0.01120283f, 0.04317336f, 0.04015538f, 0.00397458f, 0.01874300f, -0.00859374f, -0.00311432f, -0.10149986f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.14026348f, 0.05125881f, -0.15394126f, 0.15433282f, 0.03900136f, 0.11247951f, -0.16737346f, 0.11977939f, 
    0.00378995f, -0.13766138f, -0.07891724f, -0.02102550f, -0.10498347f, -0.15318079f, -0.08655962f, -0.10639086f, 
    -0.19332184f, 0.01819633f, -0.06501815f, -0.04604899f, -0.13252343f, -0.03275694f, 0.12623978f, 0.08385213f, 
    -0.17470875f, -0.17633508f, 0.08079321f, -0.04845425f, 0.04775086f, -0.10491876f, -0.14364462f, -0.05882687f, 
    0.16220710f, 0.07282268f, 0.00037083f, -0.16596948f, 0.04386328f, -0.45433736f, 0.25065586f, -0.06028102f, 
    0.15315442f, -0.47369757f, -0.13698274f, 0.01215842f, 0.03956065f, -0.18403155f, -0.10793595f, -0.16949990f, 
    -0.02825311f, 0.04532099f, 0.07453391f, 0.68407190f, 0.30242172f, -0.14551401f, 0.16230890f, 0.11795861f, 
    0.06164769f, 0.39777258f, -0.08370354f, 0.13531482f, -0.25866979f, -0.04933518f, -0.11790132f, 0.09118877f, 
    -0.18006711f, -0.10457702f, -0.06374986f, -0.06995413f, 0.01689466f, -0.19464009f, 0.15382090f, 0.26731709f, 
    0.33722550f, -0.11018115f, 0.11406513f, -0.03898277f, -0.15367366f, 0.18889548f, -0.16665034f, 0.03596495f, 
    -0.00316933f, 0.04839996f, 0.07938933f, 0.53232241f, 0.25956136f, 0.35106638f, -0.02086644f, 0.08623190f, 
    -0.49888772f, -0.40728596f, -0.00701546f, 0.09395478f, 0.45355240f, 0.05492124f, -0.07495659f, -0.39087433f, 
    0.01613310f, -0.08974319f, -0.02960974f, -0.15125661f, -0.08780396f, -0.03230550f, -0.16225596f, 0.00075883f, 
    -0.06696788f, -0.14080204f, 0.01712210f, 0.10687280f, -0.11000872f, -0.10055464f, -0.13386692f, -0.10626531f, 
    -0.20634194f, 0.02101476f, 0.08157381f, -0.18278465f, 0.07542737f, -0.00440903f, 0.06501619f, 0.06710371f, 
    -0.07135592f, -0.08659380f, -0.03410798f, 0.07527834f, 0.01464000f, 0.12978660f, -0.09955998f, -0.14871177f, 
    0.15417315f, 0.03355617f, -0.17285134f, 0.08982842f, 0.28234112f, -0.19118339f, -0.31686145f, 0.16898085f, 
    -0.11346228f, 0.31812409f, 0.09248900f, 0.06638005f, -0.03356095f, -0.50773948f, -0.09987122f, 0.20663677f, 
    0.24275690f, -0.04831196f, 0.00583815f, 0.29953569f, -0.17144375f, -0.01982458f, 0.05750537f, -0.12369537f, 
    0.30464551f, -0.00455030f, 0.05581866f, 0.16564280f, -0.26524898f, 0.08800449f, -0.04520766f, 0.45015687f, 
    -0.04496568f, 0.18114720f, -0.08456013f, 0.07168418f, 0.33973187f, 0.30160558f, 0.11836428f, -0.07666951f, 
    0.15730532f, -0.21930937f, -0.04264327f, -0.24040730f, 0.10832162f, 0.39774868f, -0.16810806f, -0.30693293f, 
    0.03457880f, -0.00570655f, 0.15199545f, -0.45532018f, 0.31713766f, -0.09193132f, 0.08290906f, -0.14131702f, 
    -0.13524655f, -0.12866448f, -0.17269236f, 0.04557865f, -0.20837007f, -0.04114184f, 0.13612947f, -0.02884316f, 
    -0.28116840f, -0.07110743f, -0.14813773f, 0.19358994f, -0.07068250f, 0.04033374f, -0.11639521f, -0.12327617f, 
    0.30614242f, 0.03580257f, 0.11518273f, -0.04665446f, -0.01425234f, 0.16002411f, -0.01297337f, 0.43007427f, 
    -0.20150854f, -0.00391820f, 0.06996158f, 0.21885981f, 0.21376868f, 0.15565287f, -0.06410079f, 0.15728323f, 
    -0.16580293f, -0.17527798f, 0.15764113f, -0.10007843f, 0.38702604f, -0.01802353f, 0.16712056f, -0.34264654f, 
    0.05845322f, 0.10011999f, -0.05120175f, 0.12192428f, -0.29660502f, -0.39680383f, 0.51825464f, -0.06453147f, 
    0.06850588f, 0.08483057f, 0.15175609f, 0.26422131f, -0.49623218f, -0.14646611f, -0.01851823f, 0.08855162f, 
    0.03919804f, -0.14067671f, 0.01209659f, -0.28120658f, 0.17019773f, 0.13417479f, -0.17571066f, 0.25791624f, 
    0.16493113f, 0.39615461f, 0.15161209f, -0.15998599f, -0.04654284f, -0.11045180f, 0.15942024f, 0.59596205f, 
    0.26164564f, -0.04174884f, 0.05745289f, 0.05695910f, 0.73169488f, 0.42995414f, 0.08985247f, -0.06970776f, 
    0.18973459f, 0.31867886f, 0.02012335f, 0.05646844f, -0.28624916f, 0.48971388f, 0.04394595f, -0.10016504f, 
    0.18078600f, -0.06329968f, 0.10581748f, 0.44758898f, 0.18956850f, -0.34650972f, -0.10005822f, -0.32672238f, 
    -0.29556519f, 0.25392202f, 0.14065029f, 0.03978086f, -0.31324452f, 0.04073850f, 0.10121030f, 0.04611982f, 
    -0.13844275f, -0.11100198f, -0.12899250f, -0.16142377f, -0.06267154f, 0.11416319f, -0.22247511f, -0.11750583f, 
    -0.08407841f, -0.18030845f, 0.06295961f, 0.14498089f, 0.30690601f, -0.08509155f, -0.11875669f, 0.12548222f, 
    -0.13758153f, -0.02717357f, 0.05239430f, 0.04263693f, 0.07713237f, 0.17209187f, 0.01560571f, -0.00052379f, 
    -0.00219646f, -0.25310975f, -0.17619614f, 0.08862154f, 0.15621674f, -0.03967310f, -0.02574429f, -0.23617640f, 
    -0.16400647f, 0.15071978f, 0.01046828f, 0.08450434f, -0.17507744f, 0.15135759f, -0.07815383f, -0.10542233f, 
    0.09962590f, -0.11261817f, -0.07920488f, -0.03402097f, -0.09446885f, -0.00984337f, 0.00532516f, -0.13518018f, 
    -0.03338782f, -0.07888280f, -0.05265846f, 0.13089506f, 0.01813969f, -0.17545058f, 0.06922344f, 0.01491467f, 
    0.06918087f, -0.11237816f, -0.15988714f, -0.06076464f, -0.11549477f, -0.00675996f, -0.12232541f, -0.08256910f, 
    0.38576993f, -0.00055504f, 0.09341754f, -0.04462266f, 0.26645520f, 0.18680571f, -0.44700390f, 0.14863543f, 
    -0.06969383f, 0.23777282f, 0.04120660f, 0.43559924f, 0.02936894f, -0.15541352f, -0.14102395f, 0.28350034f, 
    -0.28903189f, 0.14592017f, 0.06030481f, 0.30702603f, 0.00315226f, 0.19292791f, 0.16595221f, -0.23505418f, 
    0.15790612f, -0.07038024f, -0.08080443f, -0.03639762f, -0.48335153f, 0.01111929f, -0.00676185f, -0.15139103f, 
    -0.18813862f, -0.15841763f, 0.07547155f, -0.08994428f, -0.42406428f, -0.08037210f, -0.19041914f, -0.06843372f, 
    -0.03301568f, 0.26249972f, 0.03004246f, 0.37989920f, 0.12621820f, -0.11377861f, -0.10643474f, 0.57739586f, 
    -0.21417439f, -0.01769150f, 0.03370563f, 0.36320910f, 0.09766797f, 0.01609520f, 0.05372839f, -0.04209979f, 
    0.25582725f, -0.01030380f, -0.14347547f, 0.10188699f, -0.06592363f, -0.11919916f, -0.13747288f, -0.25646242f, 
    -0.09376284f, -0.06205558f, -0.12850949f, 0.00533290f, -0.13246495f, 0.15499826f, -0.15285273f, -0.18033573f, 
    0.13054185f, 0.13444191f, 0.12085427f, 0.08176479f, 0.07790690f, -0.14433305f, -0.16383883f, -0.09882523f, 
    -0.10014602f, 0.07780138f, -0.15885597f, -0.16194907f, -0.12102668f, -0.12706655f, -0.01691970f, -0.15051682f, 
    0.11514869f, -0.12077583f, -0.15809442f, -0.01476195f, -0.15857530f, 0.16679187f, -0.09552830f, 0.14922380f, 
    0.27137607f, -0.16641974f, -0.15578543f, 0.01722222f, 0.51949477f, -0.08228769f, -0.23525862f, 0.31896424f, 
    0.36287454f, 0.19211772f, 0.11654794f, -0.19144455f, 0.42622143f, -0.16705705f, 0.14475258f, -0.16231033f, 
    0.21701628f, -0.12740773f, -0.10235026f, -0.33960134f, 0.01836043f, -0.09708998f, 0.00693051f, -0.22461085f, 
    0.22086421f, 0.00490356f, -0.16302401f, 0.07702579f, 0.11651040f, 0.05078858f, 0.02206931f, 0.27709898f, 
    0.06317753f, 0.15392998f, 0.05806135f, -0.05608662f, -0.06141921f, -0.37989289f, 0.15619145f, 0.32124165f, 
    -0.11013350f, 0.16396058f, 0.19986881f, 0.25945187f, -0.27811024f, -0.33686304f, 0.11435696f, 0.19206563f, 
    -0.01536122f, -0.05805003f, -0.17195655f, -0.16914946f, -0.04447603f, 0.11226677f, -0.00429341f, -0.15994665f, 
    0.28719348f, 0.49630919f, -0.07151403f, -0.12343296f, 0.09962569f, -0.15819672f, -0.06409014f, 0.28638831f, 
    0.14292277f, -0.03871601f, -0.05273462f, 0.03631058f, -0.08092972f, 0.00479000f, 0.04575520f, -0.00266875f, 
    0.02922548f, 0.27815756f, 0.16489212f, 0.45045462f, 0.39255261f, -0.24599062f, -0.04729399f, 0.14488158f, 
    -0.07814231f, -0.14136547f, 0.11764661f, 0.49309745f, -0.14815415f, -0.01290280f, -0.09349171f, 0.29979300f, 
    0.30323023f, 0.03782199f, 0.04963804f, -0.00052869f, -0.22667268f, -0.11265196f, 0.08484767f, -0.08552621f, 
    0.19370610f, -0.13307661f, -0.15472658f, -0.12577204f, -0.54486805f, 0.00033796f, 0.18499652f, 0.09205601f, 
    -0.00084830f, -0.25189561f, 0.13582645f, 0.48086563f, 0.26540372f, -0.19500397f, -0.11997019f, 0.02758471f, 
    -0.20705676f, 0.09800389f, 0.06557020f, 0.36051503f, -0.00302435f, 0.26893309f, -0.12736821f, 0.51097721f, 
    0.12677042f, 0.01465010f, 0.14361322f, -0.02939501f, 0.16405317f, 0.16248775f, -0.10932924f, -0.07639047f, 
    0.36954519f, 0.16819645f, 0.11111549f, -0.04122823f, -0.01012433f, 0.30643737f, -0.27550405f, -0.03567027f, 
    -0.01687606f, 0.25175819f, -0.07342444f, 0.09891814f, 0.40314710f, -0.02264645f, -0.15204731f, 0.28863269f, 
    -0.09878658f, 0.07800174f, -0.16498490f, -0.38700387f, -0.01450794f, -0.14294258f, 0.11957241f, -0.41790411f, 
    0.47346243f, 0.16179472f, -0.09357031f, -0.01510315f, -0.31176525f, -0.15822718f, 0.04744171f, 0.15047906f, 
    -0.12123138f, 0.16850284f, 0.16029420f, 0.16837035f, -0.17898998f, -0.05675817f, -0.00696964f, -0.08705704f, 
    -0.04747831f, 0.08934670f, -0.04252006f, -0.11466645f, -0.14543279f, -0.12262985f, 0.06644465f, -0.11914747f, 
    -0.11804378f, -0.14675283f, 0.17403138f, 0.09864306f, -0.11613623f, 0.08610713f, 0.07521873f, 0.10336012f, 
    -0.03236097f, -0.01648855f, 0.08849151f, 0.14341575f, -0.14441727f, 0.15792228f, 0.16823523f, -0.04737477f, 
    0.02924531f, -0.14456253f, -0.06549382f, -0.17060304f, -0.04409774f, 0.05423985f, -0.07648899f, -0.18099725f, 
    -0.04858300f, -0.03957555f, -0.13993853f, -0.12998649f, 0.08522639f, -0.09477381f, 0.07630457f, -0.14525634f, 
    -0.19441058f, -0.07800990f, 0.08132801f, 0.07778909f, 0.03794406f, -0.06462765f, -0.04658234f, -0.15006121f, 
    0.06892250f, 0.03480900f, 0.16020872f, -0.11720442f, -0.08397769f, -0.12266522f, -0.14977336f, 0.02534557f, 
    0.29813671f, -0.16547433f, 0.07529773f, 0.09990656f, 0.06285180f, 0.40969679f, -0.58176982f, -0.20452757f, 
    -0.06032215f, 0.07361788f, -0.02891745f, 0.01336691f, 0.01605395f, 0.10290958f, -0.08399517f, -0.24573578f, 
    0.09271315f, 0.14948639f, -0.09106444f, 0.06193679f, 0.00439091f, 0.01925640f, -0.14551856f, 0.24720183f, 
    0.07808091f, -0.11866206f, 0.00532117f, -0.14072196f, 0.00288740f, 0.07895342f, -0.08039851f, 0.45226815f, 
    0.21131402f, -0.05654555f, -0.10622025f, 0.18974678f, -0.01640547f, 0.43184757f, 0.28430995f, -0.11184552f, 
    -0.01544984f, -0.24369267f, 0.08526827f, 0.04158144f, -0.07167985f, 0.42182389f, 0.14777923f, -0.01208413f, 
    0.02842784f, -0.15122190f, -0.09086239f, 0.46189320f, 0.04934362f, 0.13740681f, -0.07083301f, 0.47447976f, 
    -0.48892942f, -0.04705184f, 0.01998024f, -0.00411455f, 0.12246329f, -0.06180930f, 0.11763076f, -0.25929546f, 
    0.45726433f, 0.05431421f, 0.04939731f, -0.02972359f, -0.25985813f, 0.18420130f, 0.04550963f, 0.05316573f, 
    -0.27897504f, -0.28138000f, 0.13324066f, 0.18815841f, 0.42310250f, 0.26652500f, 0.00571483f, -0.27918014f, 
    0.02781573f, 0.00685728f, -0.06075206f, -0.15969202f, 0.28146741f, 0.22026482f, -0.05777294f, -0.21612614f, 
    -0.17657675f, -0.07201363f, -0.16726661f, -0.04372156f, -0.41419694f, 0.05264483f, 0.10529071f, -0.39021915f, 
    0.04143766f, -0.02244349f, -0.06472468f, -0.00532101f, -0.17352243f, 0.16988972f, 0.12502402f, -0.31181964f, 
    -0.13631234f, -0.36958286f, -0.03642851f, -0.09400532f, -0.04856589f, 0.26044053f, -0.09511562f, -0.00861658f, 
    0.31437901f, 0.17581226f, 0.14528960f, -0.13448110f, 0.22478355f, -0.02514492f, 0.04397532f, 0.46643126f, 
    0.17061183f, 0.47573039f, 0.16428541f, 0.07331602f, -0.29666376f, -0.15647139f, 0.10967855f, 0.73210013f, 
    0.22047465f, 0.00556108f, -0.13677382f, 0.10364024f, -0.12095136f, -0.26412657f, 0.19931053f, 0.23345058f, 
    -0.29518110f, 0.17455776f, 0.02932821f, 0.28556749f, -0.15798718f, -0.03125416f, -0.03332600f, 0.16833882f, 
    0.22874571f, -0.15043251f, -0.06017537f, -0.50275213f, 0.17443427f, 0.06605175f, -0.08622783f, -0.06205553f, 
    0.21527782f, 0.42511827f, 0.00425874f, 0.16036949f, -0.23136887f, 0.02895613f, -0.14317979f, 0.17527440f, 
    -0.06115040f, 0.01771843f, 0.08416559f, -0.04372013f, 0.06194819f, 0.36384925f, 0.27574804f, -0.13973539f, 
    -0.02100764f, -0.06464657f, 0.13131592f, 0.20132448f, -0.30093691f, -0.30584320f, -0.15256009f, 0.02739872f, 
    0.09373304f, 0.02068532f, -0.05296438f, 0.24512990f, -0.22351907f, 0.29102233f, 0.00407909f, 0.84341872f, 
    0.18782295f, 0.01734706f, 0.02991020f, 0.13124780f, 0.18034978f, 0.06232864f, -0.14192249f, 0.31981888f, 
    -0.05971653f, -0.05328571f, 0.06433263f, -0.02463969f, 0.11760259f, 0.50618428f, -0.04554310f, 0.06495081f, 
    0.33901057f, 0.16065216f, 0.11090770f, -0.10585117f, -0.50410932f, -0.21318109f, 0.02590278f, 0.57917976f, 
    0.08128953f, -0.06674535f, -0.06094364f, -0.49966386f, 0.18684709f, 0.08745272f, 0.12075194f, 0.36087298f, 
    0.14437445f, 0.65061527f, 0.07696842f, 0.07608569f, 0.33080682f, -0.16393749f, -0.10487311f, 0.41259488f, 
    0.10285730f, -0.17405479f, -0.17213520f, -0.16295639f, 0.14107157f, 0.03218618f, -0.03316485f, -0.11686874f, 
    0.06199401f, -0.06417140f, -0.12093039f, -0.01070823f, -0.10378575f, 0.08327924f, -0.14664772f, -0.02388626f, 
    -0.05328419f, 0.01835500f, -0.02437276f, -0.13158853f, -0.17299524f, -0.13552114f, -0.00184536f, 0.08986231f, 
    -0.11639775f, -0.07065390f, 0.12949204f, -0.14994472f, 0.05518449f, -0.09954300f, -0.01697755f, -0.17278367f, 
    0.39373061f, 0.13865757f, -0.01388541f, 0.13787618f, 0.15461731f, -0.50355715f, 0.19907285f, 0.30995780f, 
    -0.21806893f, 0.37852317f, 0.11329670f, 0.21107928f, -0.00227347f, -0.21454847f, 0.01883458f, -0.13416111f, 
    0.15563056f, -0.03229799f, 0.05279639f, -0.27406719f, 0.12947904f, 0.32375181f, -0.06710351f, -0.42149451f, 
    -0.23828721f, -0.14717652f, 0.06628174f, -0.09969498f, 0.05700490f, -0.02924098f, -0.16719782f, -0.41331872f, 
    0.11762438f, -0.13047539f, 0.11481498f, 0.14103393f, 0.05772744f, 0.59592599f, -0.60174453f, -0.22045977f, 
    0.24845013f, 0.22534944f, 0.09226871f, 0.09179124f, 0.33555213f, -0.22898154f, 0.09516861f, 0.25345498f, 
    -0.32103038f, 0.06365486f, 0.16193525f, -0.09872811f, 0.10012797f, 0.12923898f, -0.03327855f, -0.27595663f, 
    0.05780254f, 0.18781485f, -0.01966263f, -0.14713931f, -0.07775014f, 0.04807539f, -0.04714199f, -0.46746325f, 
    -0.10688646f, 0.15840988f, -0.14547679f, -0.13971846f, -0.14142448f, -0.08645080f, -0.08734617f, 0.07456179f, 
    -0.16405647f, -0.06199420f, 0.14020321f, 0.13253736f, 0.16538046f, 0.07439223f, 0.08204590f, -0.00194246f, 
    -0.17808397f, 0.05376296f, -0.09201230f, -0.09424113f, -0.16516967f, -0.08494300f, -0.00052343f, 0.06280125f, 
    -0.08764558f, -0.10389831f, -0.10384964f, -0.01395119f, -0.16484509f, -0.09937557f, 0.16966599f, 0.02581956f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09699345f, 0.15205263f, 0.28789139f, -0.05744745f, 0.09054316f, -0.04997563f, -0.07673410f, 0.15086845f, 
    0.22975701f, 0.03718036f, 0.08252051f, 0.19215475f, -0.06202306f, -0.01163409f, 0.02487568f, 0.00202222f, 
    -0.09672582f, 0.05977723f, 0.05663147f, 0.12533198f, 0.03265021f, 0.13514644f, 0.15826054f, 0.28941301f, 
    0.06179755f, 0.02145651f, 0.05858266f, 0.30268887f, 0.11658397f, -0.03240997f, 0.06817017f, 0.11723772f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.14675803f, 0.00140889f, 0.29841149f, -0.01279374f, -0.22898191f, -0.39787054f, -0.09253906f, -0.01846023f, 
    0.14171056f, 0.01610477f, 0.13964215f, 0.31441462f, -0.09170730f, -0.04816407f, -0.17062502f, -0.00156026f, 
    0.39594090f, 0.26207387f, -0.19164614f, -0.16221428f, 0.09080963f, -0.23339947f, 0.50587249f, 0.49964470f, 
    -0.19749308f, -0.01730319f, 0.10013375f, -0.26361284f, 0.05930883f, 0.58712894f, -0.07622765f, 0.18051645f, 
    0.08311830f, 0.46697456f, -0.22073580f, -0.16465290f, -0.09933984f, -0.09622630f, -0.40962818f, 0.09763738f, 
    -0.05921486f, -0.33713704f, 0.11332626f, 0.01255911f, -0.35867733f, -0.10793237f, 0.14340611f, 0.13680805f, 
    -0.00196383f, 0.10773431f, 0.06657151f, -0.14535278f, 0.05051295f, 0.13909614f, -0.08925983f, -0.18045938f, 
    0.41656262f, 0.07603892f, 0.56282514f, 0.25110164f, -0.13562413f, -0.17263971f, 0.08881478f, 0.03338426f, 
    -0.01811259f, -0.12650943f, 0.12705167f, 0.02941967f, -0.41490531f, 0.07173777f, 0.24084544f, 0.34046829f, 
    -0.21477255f, 0.00266866f, 0.13887091f, -0.20577447f, 0.36880338f, -0.01932100f, -0.26116157f, 0.09180214f, 
    -0.33990565f, 0.19708213f, -0.14793980f, -0.17455442f, 0.09192983f, 0.12225582f, 0.09471144f, 0.35583422f, 
    0.48227209f, 0.21972588f, 0.01749356f, 0.04088502f, -0.14446452f, 0.03775221f, -0.06749552f, -0.13452041f, 
    0.12722889f, 0.00949022f, -0.05898556f, -0.03986752f, -0.18828325f, -0.19366978f, -0.08576470f, -0.09231953f, 
    -0.13035354f, 0.03551818f, 0.10774311f, -0.09640358f, -0.06686445f, 0.15952350f, -0.00198288f, 0.01608596f, 
    -0.14116596f, -0.04099575f, -0.11842463f, 0.07780144f, 0.08048335f, 0.07129196f, -0.03048617f, -0.07205626f, 
    0.11708199f, -0.08170551f, -0.11516938f, -0.06413702f, -0.16762878f, 0.11061995f, -0.09673776f, 0.16673478f, 
    0.03187545f, 0.19713016f, 0.06020969f, -0.09483752f, -0.45152745f, -0.02772935f, 0.02802343f, 0.46036184f, 
    0.02029095f, -0.09166788f, -0.11462069f, -0.36316189f, -0.04198486f, 0.11452898f, -0.25174549f, 0.47001815f, 
    -0.25850782f, 0.02954947f, -0.23976654f, -0.02625308f, 0.11641269f, -0.14835428f, -0.12590070f, -0.05568910f, 
    0.50291270f, 0.34108388f, 0.08560203f, 0.34511778f, -0.06607669f, 0.14626235f, -0.31154022f, 0.12401335f, 
    -0.06552987f, 0.18296653f, 0.01353630f, 0.07308054f, -0.20796427f, 0.45260137f, -0.14281599f, -0.13502054f, 
    -0.37633494f, 0.28256837f, -0.05047342f, -0.03979177f, -0.25848249f, -0.08614185f, 0.36441153f, 0.02322268f, 
    -0.12124265f, 0.26099786f, 0.18100461f, 0.00100925f, 0.12803088f, -0.62598157f, -0.01804353f, 0.70701796f, 
    -0.05566176f, -0.00730467f, -0.21543120f, -0.21604402f, -0.07673325f, 0.45703045f, 0.39670327f, -0.04934340f, 
    0.14742494f, 0.02823643f, -0.03551502f, 0.10316613f, -0.14976558f, -0.09253406f, -0.05629944f, -0.00451759f, 
    -0.05472950f, 0.00416695f, 0.02547712f, 0.12377545f, -0.01046873f, 0.14999321f, -0.13085532f, 0.09815691f, 
    0.04246936f, 0.06392857f, -0.16073073f, 0.11752174f, -0.00876842f, 0.11711671f, -0.17043482f, 0.00555904f, 
    0.07628659f, -0.14505474f, 0.03902132f, -0.15065342f, 0.05029457f, -0.08405211f, -0.13510568f, -0.16150722f, 
    0.01505491f, 0.56852955f, 0.35772151f, -0.03704156f, -0.42931068f, -0.20854218f, -0.02614573f, 0.40539536f, 
    -0.09229111f, 0.04870913f, 0.05072915f, -0.32216614f, 0.17535350f, 0.12611631f, -0.23115346f, 0.47717556f, 
    -0.09308303f, 0.34009767f, -0.52153665f, -0.07492930f, -0.07816837f, -0.25105760f, 0.33090502f, -0.02087468f, 
    0.27697399f, 0.15816566f, 0.28242421f, 0.23754588f, -0.04303387f, 0.12636034f, -0.43656883f, -0.00321738f, 
    -0.08846690f, 0.14225224f, 0.32091621f, -0.07105990f, -0.36554563f, 0.35943672f, 0.20540950f, -0.19162121f, 
    0.17164446f, 0.27281013f, -0.13595025f, 0.31525815f, 0.00403507f, -0.10247506f, -0.13089687f, -0.40672904f, 
    0.01273614f, 0.22055279f, 0.01388950f, 0.11750392f, 0.00746937f, 0.11020091f, 0.47098157f, 0.42346621f, 
    -0.30733931f, -0.02870900f, 0.16345645f, -0.12489478f, 0.10023843f, 0.14162339f, 0.33658552f, 0.11881261f, 
    -0.13245170f, -0.19169943f, 0.43580917f, -0.11785344f, 0.01401823f, 0.11077558f, 0.30267647f, -0.22510636f, 
    0.28126237f, -0.17345005f, 0.14155358f, 0.07692530f, -0.38584456f, -0.16574116f, 0.45669243f, -0.02599590f, 
    -0.32554466f, -0.21191715f, -0.23471974f, -0.12949336f, 0.03685094f, -0.01178746f, 0.17168686f, -0.20541722f, 
    -0.55437446f, -0.15531729f, -0.39775383f, 0.26103461f, 0.14669625f, 0.25886288f, 0.27480000f, -0.02966996f, 
    -0.12458327f, -0.41660294f, -0.14379320f, -0.05846892f, -0.34751296f, -0.01669424f, 0.05927937f, -0.16488872f, 
    0.02553792f, 0.02277461f, 0.10786570f, 0.08908732f, 0.39328995f, -0.10260066f, -0.24543233f, -0.03559214f, 
    0.06032225f, 0.08923841f, 0.52518713f, -0.12512206f, 0.03422909f, 0.17953876f, 0.23564130f, 0.02274883f, 
    -0.21413027f, 0.07487676f, 0.28673944f, 0.26107746f, 0.02671773f, 0.18041243f, 0.58490139f, 0.14193740f, 
    -0.11617669f, -0.21444449f, -0.15141918f, 0.17327654f, 0.31285974f, -0.16340256f, -0.14095536f, 0.30377838f, 
    -0.04026697f, -0.34961542f, -0.07087484f, 0.00699679f, -0.36346757f, -0.04717828f, 0.33430454f, 0.50393867f, 
    -0.15376431f, 0.19597487f, 0.16064054f, 0.06456306f, 0.03765564f, -0.04324274f, -0.15142645f, 0.44140169f, 
    -0.00529046f, 0.52399123f, 0.21747409f, 0.22522937f, 0.15803774f, 0.53693742f, 0.01247694f, 0.05323992f, 
    -0.09920280f, -0.07880638f, 0.01969831f, -0.09991909f, 0.47782615f, 0.49967977f, -0.26209903f, 0.10282984f, 
    0.52732551f, -0.26761571f, -0.01987489f, 0.17481332f, -0.33482769f, -0.04844144f, 0.08588782f, 0.07572955f, 
    -0.18707420f, -0.11312380f, 0.13234559f, 0.11035520f, 0.00502153f, 0.17176425f, 0.18081836f, 0.23521520f, 
    0.35401782f, 0.44983441f, -0.54691839f, 0.00211713f, 0.16327569f, 0.39698428f, -0.41597849f, -0.13720493f, 
    -0.14184834f, -0.24425477f, -0.21151862f, -0.11552495f, 0.39396566f, 0.05205018f, -0.12646221f, 0.04546027f, 
    0.11120470f, -0.14952274f, -0.07775841f, -0.16629598f, -0.39770263f, -0.03389205f, 0.38862830f, 0.07620264f, 
    0.34315768f, 0.07199003f, -0.04399015f, 0.16179591f, -0.03955846f, 0.54760092f, 0.01957427f, -0.42785436f, 
    0.35477066f, -0.04258218f, 0.52158630f, 0.23992783f, 0.07449232f, -0.26211235f, 0.21652499f, 0.06009858f, 
    0.07245117f, -0.00522329f, -0.13612603f, -0.10754832f, 0.36721677f, -0.00503138f, 0.33699688f, -0.06175521f, 
    -0.08060813f, -0.16798988f, 0.09194382f, 0.21259241f, 0.49635080f, -0.04192619f, 0.41104251f, 0.32502675f, 
    0.01088003f, 0.06376424f, 0.27927732f, -0.12916514f, -0.07611411f, -0.41018230f, -0.32908446f, -0.52287996f, 
    -0.36987448f, -0.02202855f, -0.09196892f, 0.40942821f, 0.06041264f, -0.01925755f, 0.66169894f, -0.07885721f, 
    -0.11140485f, -0.00556049f, 0.01528189f, 0.09514251f, 0.91077679f, -0.03693271f, 0.11022030f, -0.11278769f, 
    0.12973565f, 0.11689569f, 0.13072954f, 0.48460507f, 0.42629105f, 0.14531733f, 0.48424068f, -0.00247490f, 
    0.23965430f, -0.13826941f, 0.55397683f, 0.02118270f, -0.11481474f, 0.04622244f, -0.41846615f, -0.17004155f, 
    -0.48912993f, 0.06018896f, -0.29293180f, 0.09937721f, -0.02670106f, -0.09262832f, 0.56940329f, -0.13480788f, 
    0.17614338f, 0.48134953f, -0.28134653f, 0.11866400f, 0.09454612f, 0.29601124f, -0.17460681f, -0.05268948f, 
    0.47236267f, 0.01565738f, -0.03550015f, 0.37196642f, 0.11341376f, 0.02076427f, -0.07561321f, 0.01042660f, 
    0.40362895f, -0.02783907f, 0.36259744f, -0.18224171f, -0.15668674f, 0.39595014f, 0.19426560f, 0.33646131f, 
    0.54406321f, 0.12963815f, -0.05519734f, 0.14836872f, -0.08550609f, -0.39843175f, 0.48958024f, 0.01544684f, 
    -0.15295073f, 0.06512954f, -0.30167598f, 0.05668996f, -0.37565655f, -0.33614010f, -0.17293474f, 0.41441265f, 
    0.04547425f, -0.12274607f, -0.13761266f, 0.14313048f, 0.35987386f, 0.05293529f, -0.32521266f, 0.43041795f, 
    0.22778215f, 0.13138354f, 0.37824011f, -0.13826393f, -0.05072880f, -0.36742356f, 0.05026987f, 0.11034241f, 
    0.16488101f, 0.32925996f, 0.18681861f, 0.24012539f, 0.04689187f, 0.04867152f, -0.22931296f, 0.14122720f, 
    -0.13515286f, 0.00011426f, -0.29656944f, -0.03621726f, -0.06680820f, 0.12010031f, -0.24259146f, 0.12311510f, 
    -0.00949669f, 0.03374791f, -0.14870332f, 0.30796629f, 0.27163252f, -0.13839419f, 0.01078301f, 0.25755405f, 
    0.38072130f, -0.06538890f, 0.69033891f, 0.01419986f, -0.14100428f, -0.45589748f, -0.19302553f, 0.39599234f, 
    0.11906880f, 0.34902319f, -0.38444260f, -0.02216467f, 0.03787512f, 0.40616152f, 0.40290532f, 0.02647308f, 
    -0.06632053f, -0.13120669f, -0.05751885f, -0.09383856f, -0.15413724f, -0.03105952f, -0.06229483f, -0.05882751f, 
    -0.17610167f, 0.02694117f, 0.13934274f, 0.08408181f, 0.02376226f, -0.16472270f, 0.01162985f, -0.19346227f, 
    0.11572535f, -0.13899051f, 0.02813526f, -0.08266350f, 0.02571004f, 0.00624056f, -0.18729423f, 0.01580155f, 
    0.04198517f, -0.03340319f, 0.00277029f, -0.13670632f, -0.04990349f, -0.11260932f, 0.06404652f, 0.10652647f, 
    -0.00259507f, 0.61067426f, 0.28638253f, 0.09445210f, 0.10231747f, 0.37119478f, 0.11436145f, -0.31984183f, 
    0.27637225f, 0.31326100f, -0.15994720f, 0.27085951f, 0.14903003f, -0.14510515f, 0.03914959f, -0.60798466f, 
    0.45129311f, 0.32598820f, 0.07940359f, -0.12276705f, -0.04414544f, 0.42795128f, 0.11183746f, 0.28228667f, 
    -0.02856816f, -0.44713768f, 0.06346141f, -0.07773300f, -0.06599943f, -0.40513310f, 0.48983997f, -0.06619600f, 
    0.02036526f, -0.29630983f, 0.00407535f, 0.05471414f, 0.39949721f, -0.39767203f, -0.25678459f, -0.06373451f, 
    -0.18266690f, -0.01866748f, 0.11173256f, 0.22659625f, 0.27725768f, -0.10051447f, 0.23490614f, 0.52700073f, 
    0.31814402f, 0.14734796f, 0.26772657f, 0.03511617f, -0.04950218f, -0.42193669f, -0.38860512f, -0.01065856f, 
    -0.45280677f, 0.33989561f, -0.01452750f, 0.13583101f, -0.09611717f, 0.58254552f, 0.01804832f, 0.09384436f, 
    -0.13286412f, -0.27946490f, 0.33926076f, 0.01433640f, -0.26089779f, 0.42926905f, 0.25893071f, 0.02383119f, 
    0.07500247f, 0.32956800f, 0.13540462f, -0.36371866f, -0.37034580f, 0.12104473f, -0.18467218f, -0.25570571f, 
    -0.37672377f, 0.04780919f, -0.29744577f, -0.02051874f, -0.13846911f, 0.32453397f, 0.52886313f, 0.31208068f, 
    0.23439336f, 0.08916659f, -0.02987277f, 0.26706198f, 0.12954864f, 0.20307243f, -0.05422331f, 0.14413705f, 
    0.09432429f, 0.01638632f, 0.08326357f, -0.11481157f, 0.31160402f, 0.05893670f, 0.37517264f, 0.02452960f, 
    -0.07523689f, 0.12465575f, -0.11027898f, -0.16719261f, 0.26815420f, 0.10307970f, 0.05812845f, -0.19847761f, 
    0.00534263f, -0.04501532f, 0.12623137f, -0.02036000f, 0.10226490f, 0.41027048f, 0.10512818f, -0.21004628f, 
    0.55955559f, -0.11459080f, -0.17651652f, 0.32219785f, 0.14490649f, -0.59509265f, 0.40097845f, 0.13067244f, 
    0.01485999f, 0.18288127f, 0.14079809f, 0.05860806f, -0.63720447f, -0.02255782f, 0.32286230f, 0.09334103f, 
    0.23936960f, 0.16010059f, -0.14457691f, 0.21435142f, 0.50187516f, -0.06635646f, -0.53765786f, -0.35488081f, 
    -0.00683827f, 0.03898119f, -0.07933652f, 0.05307507f, 0.18174954f, -0.06912264f, 0.21680988f, 0.34530616f, 
    0.45133093f, -0.03636119f, -0.11389757f, 0.10584921f, 0.01978023f, -0.28809652f, 0.10919909f, -0.17501289f, 
    -0.00038672f, 0.55701864f, -0.27682877f, -0.12698388f, 0.75768149f, 0.57885951f, -0.05692802f, 0.17063279f, 
    0.40183380f, -0.34778190f, -0.08237267f, 0.39733094f, -0.38804877f, -0.13301633f, 0.32590240f, 0.01327676f, 
    -0.02063648f, -0.11901709f, 0.31540665f, -0.13222453f, 0.02530080f, -0.43536106f, -0.26968428f, 0.33218908f, 
    0.46724409f, 0.27398670f, -0.37603402f, -0.02734883f, 0.17272246f, 0.09178230f, 0.09416679f, -0.12243904f, 
    -0.12140591f, 0.15623601f, -0.11844837f, 0.14453298f, -0.09920888f, -0.09870572f, 0.07210795f, 0.00158561f, 
    -0.00152684f, -0.07721180f, -0.13174927f, -0.17575420f, 0.02344745f, -0.14079091f, -0.17769571f, -0.08832359f, 
    0.02474307f, -0.12870267f, -0.10845917f, 0.13042583f, -0.13096307f, -0.05614512f, -0.15185337f, -0.11825676f, 
    -0.03804388f, 0.11162750f, -0.13906726f, 0.03352964f, -0.13398142f, -0.13992633f, -0.14064804f, 0.14724983f, 
    0.12397633f, 0.25914946f, 0.28537163f, 0.00401485f, -0.04119767f, 0.65774655f, 0.07997882f, 0.00006310f, 
    0.49960843f, -0.32999948f, -0.18597093f, -0.13545766f, -0.37766033f, 0.04724186f, 0.31424686f, -0.13832192f, 
    -0.51445800f, -0.25785071f, -0.14041054f, -0.06222747f, 0.09042914f, -0.13530758f, 0.21838509f, 0.12128414f, 
    -0.06175255f, -0.03392516f, -0.48184922f, 0.26881495f, 0.02783707f, 0.04454167f, 0.12495275f, -0.00393739f, 
    0.13482860f, -0.24664804f, 0.41036409f, 0.05312847f, -0.43335372f, -0.62411898f, 0.41130126f, 0.13955611f, 
    -0.27231926f, 0.26701942f, -0.11602619f, -0.00915816f, 0.60433429f, -0.16346236f, -0.34297761f, 0.42008832f, 
    0.23401317f, 0.25653586f, -0.30053365f, 0.15408735f, -0.06959589f, -0.18645166f, 0.06349599f, -0.27721417f, 
    -0.51232678f, 0.08469298f, 0.63907182f, 0.34306633f, -0.02762382f, 0.10677116f, 0.42683598f, 0.06004497f, 
    0.01461815f, 0.19692972f, 0.39945918f, -0.10817735f, 0.17304909f, -0.30767921f, 0.36174804f, 0.25190940f, 
    0.10770127f, -0.20406519f, 0.08868317f, 0.06515948f, 0.37467250f, 0.01756641f, 0.03529147f, 0.06797720f, 
    0.36762357f, 0.25785488f, -0.41599306f, 0.08157438f, -0.13280036f, -0.23269211f, 0.11438537f, -0.12511410f, 
    -0.41965339f, -0.07124308f, 0.10762703f, -0.00913361f, -0.15231462f, 0.41874695f, -0.36888823f, -0.10904140f, 
    -0.04377797f, -0.07174885f, -0.08473323f, -0.01518602f, 0.12663279f, 0.31026673f, -0.01662492f, -0.10948998f, 
    -0.50602460f, 0.29277834f, -0.07990056f, -0.12488601f, 0.04640900f, 0.15105020f, 0.31483257f, -0.36037686f, 
    0.08712571f, 0.17990196f, 0.33432573f, 0.04316242f, 0.11090870f, -0.08312216f, 0.07725213f, 0.65712589f, 
    0.06026201f, 0.18083964f, -0.19862053f, -0.17323837f, 0.04481588f, 0.11716847f, 0.07702077f, 0.00521896f, 
    -0.02029102f, 0.03857695f, -0.22179142f, -0.11806416f, 0.09849536f, -0.73182404f, -0.07894912f, -0.04172610f, 
    -0.29047993f, -0.04761010f, 0.00355679f, 0.57573014f, 0.49537516f, -0.16243482f, -0.07224005f, 0.42305177f, 
    0.54016840f, 0.23462448f, 0.20563543f, 0.16295807f, 0.05328495f, -0.02028335f, 0.01516287f, 0.22567952f, 
    -0.22058208f, 0.10916954f, 0.42163882f, -0.07563451f, -0.08352789f, 0.07577974f, 0.16939621f, 0.00982153f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.33066699f, -0.13070321f, 0.10515790f, -0.09406084f, 0.21183182f, 0.00473999f, -0.09663096f, 0.02835770f, 
    0.17914943f, 0.14490066f, 0.29180905f, 0.26778182f, 0.03103901f, -0.17318065f, -0.20134522f, -0.02775376f, 
    0.16953279f, 0.16969800f, 0.14030159f, 0.13696411f, -0.02438355f, -0.17400800f, 0.27647680f, -0.09393614f, 
    0.03985678f, -0.08857696f, 0.03297040f, 0.03534823f, 0.29972771f, -0.03008342f, 0.01469322f, 0.11454278f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.11031880f, -0.25739446f, 0.01508177f, -0.09425895f, 0.13857909f, -0.02878365f, -0.04580380f, -0.21598235f, 
    -0.01751000f, -0.27107432f, 0.04462900f, 0.03776697f, 0.42749703f, -0.54250848f, -0.67940605f, -0.37739804f, 
    0.35775399f, 0.23791151f, 0.29703557f, 0.17790636f, -0.15577127f, -0.17312597f, 0.03857413f, -0.22172631f, 
    0.24187988f, 0.29492104f, -0.11685216f, 0.16128708f, -0.63439882f, -0.43197981f, -0.04387853f, -0.45991981f, 
    0.01604664f, -0.13864523f, 0.10249893f, 0.14907444f, 0.00612664f, 0.07951747f, 0.16397123f, 0.00922643f, 
    0.16039447f, 0.42861426f, -0.61800110f, -0.14379208f, 0.27906191f, -0.23081368f, -0.37735716f, -0.08245324f, 
    -0.23733470f, -0.59439403f, -0.27358264f, 0.10818676f, -0.02140844f, -0.28312728f, 0.30301490f, -0.12385287f, 
    -0.02100734f, 0.11392915f, 0.02337868f, 0.48325059f, -0.24549490f, 0.17728475f, -0.06834058f, -0.54246914f, 
    0.23373622f, -0.28747302f, -0.08107064f, 0.11960571f, -0.75724179f, 0.79975408f, -0.01713486f, -0.32028106f, 
    0.18105295f, -0.18515512f, -0.01117367f, -0.20758145f, -0.42856035f, -0.48915049f, -0.16868225f, -0.05040223f, 
    -0.16283295f, -0.34109664f, 0.10965601f, -0.02378534f, 0.38918719f, 0.03407647f, 0.02906168f, -0.02839448f, 
    0.01371167f, -0.36109644f, -0.15165584f, -0.39748523f, 0.07821485f, -0.07107473f, 0.62811106f, 0.32952994f, 
    -0.00836506f, -0.55827838f, -0.91522467f, -0.09981524f, -0.43331137f, -0.44853646f, 0.10158267f, -0.54012793f, 
    -0.23897037f, 0.20867808f, -0.16986692f, 0.12065233f, 0.24186490f, 0.00444001f, 0.25105098f, 0.41631955f, 
    -0.01449930f, 0.07225423f, 0.17567135f, -0.11809511f, -0.13301356f, 0.39037645f, -0.63390660f, -0.24154988f, 
    -0.82147694f, 0.15786588f, -0.04880088f, 0.03689320f, -0.14199442f, 0.19751284f, -0.32894358f, 0.26133403f, 
    0.02196825f, 0.30223086f, -0.17455821f, -0.06705248f, 0.18492901f, 0.22270209f, -0.05644953f, 0.11968358f, 
    -0.10433293f, -0.49088123f, -0.17628746f, 0.14345816f, -0.07643664f, -0.12029630f, 0.10347919f, -0.16840577f, 
    0.05309616f, 0.23100875f, 0.24121988f, -0.06181335f, -0.12983754f, 0.19949126f, -0.46728295f, -0.34665927f, 
    -0.24203770f, 0.20591013f, 0.09941225f, -0.15697472f, 0.07518863f, -0.16864401f, -0.21451019f, 0.28062478f, 
    -0.16923274f, 0.27632380f, 0.18271628f, -0.07487229f, 0.37936911f, -0.34718227f, 0.10940677f, 0.33542833f, 
    -0.12271483f, -0.20200346f, -0.30986458f, 0.01317382f, -0.09649836f, 0.47936440f, -0.16628379f, -0.58525258f, 
    -0.10075212f, 0.11985623f, -0.36567509f, -0.15709750f, -0.21993287f, -0.54471648f, 0.34164584f, 0.34500614f, 
    0.03012782f, -0.27041033f, -0.16248719f, 0.03759259f, 0.21891354f, -0.10253482f, -0.33850202f, -0.61805212f, 
    0.18161571f, -0.64586794f, 0.11942706f, -0.04792443f, 0.31615326f, 0.24950947f, -0.02163636f, 0.18265548f, 
    -0.15124215f, 0.34339434f, 0.03011714f, 0.25797465f, 0.01923426f, -0.46989602f, 0.01010095f, -0.38518348f, 
    -0.85879058f, -0.01974377f, -0.10972164f, -0.02422499f, -0.99358988f, 0.34411117f, 0.13594326f, -0.65489370f, 
    -0.33324677f, -0.45208612f, -0.11759433f, -0.04509472f, 0.29577366f, 0.13568348f, 0.02506611f, -0.12924367f, 
    -0.73532760f, 0.41658434f, -0.07178241f, 0.08092216f, -0.00972985f, 0.06583942f, 0.04196009f, -0.16539264f, 
    -0.71546012f, -0.43263051f, -0.42708182f, 0.20729540f, 0.21843387f, 0.46186924f, 0.07742473f, 0.17166184f, 
    0.20261107f, 0.01561748f, 0.06983015f, 0.07288138f, -0.13586901f, 0.04628986f, -0.37359241f, 0.33952916f, 
    -0.24225673f, 0.26732516f, 0.13945760f, -0.32770917f, -0.73276925f, -0.57298255f, 0.23984787f, 0.04047294f, 
    0.13769521f, -0.02942569f, -0.10630693f, 0.02991876f, -0.20799412f, -0.66850120f, -0.12477884f, 0.15511243f, 
    0.06261446f, 0.16327247f, -0.17934009f, -0.92262495f, -0.58915108f, -0.01316805f, 0.11375952f, 0.04939348f, 
    -0.10602881f, -0.46245191f, -0.60616100f, -0.14241204f, 0.41715527f, -0.53327185f, -0.06164219f, 0.24286576f, 
    0.28761023f, -0.47985458f, 0.09117893f, 0.03924460f, 0.26601940f, 0.35194042f, -0.60397619f, -0.24630459f, 
    0.32224953f, 0.19757600f, 0.06511315f, 0.05111741f, -0.03097667f, -0.43837169f, 0.09112471f, 0.18399823f, 
    0.16199557f, -0.58090252f, -0.07476798f, 0.00378303f, 0.03915121f, 0.40584159f, -0.68449593f, -0.85576302f, 
    -0.07984801f, 0.17301314f, -0.15404262f, 0.12969685f, 0.07188101f, -0.02402746f, -0.08068084f, -0.38790286f, 
    0.11612166f, -0.30072746f, -0.16243120f, -0.52533656f, 0.24208069f, 0.32648864f, -0.41297993f, 0.48516706f, 
    -0.14016266f, -0.01324137f, -0.81255352f, 0.10002058f, -0.76111382f, -0.03547227f, 0.09946764f, -0.91738868f, 
    0.24726422f, 0.43326649f, 0.41026768f, -0.03572059f, -0.06890157f, 0.12922370f, 0.21574771f, 0.12143277f, 
    0.29565644f, -0.27393997f, -0.07594314f, 0.06033242f, 0.34252891f, -0.19085512f, -0.07073952f, 0.05312293f, 
    -0.13319783f, 0.02807028f, 0.11641765f, 0.32011864f, -0.03878034f, -0.51193202f, -0.36736214f, -0.09790140f, 
    -0.28405496f, -0.75883609f, 0.09471621f, -0.06419631f, -0.10792152f, -0.53131145f, 0.08264455f, -0.41877902f, 
    -0.07812819f, -0.24900512f, 0.45918387f, -0.17642309f, -0.30291343f, -0.45943746f, 0.48781061f, 0.26910710f, 
    -0.00123370f, 0.16671194f, 0.19878706f, -0.11895721f, -0.22070037f, 0.17398119f, -0.44823211f, 0.36220786f, 
    0.19581772f, -0.21505113f, 0.02493091f, -0.39592883f, 0.29192546f, -0.18055232f, -0.15694936f, 0.31238067f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.03108415f, -0.11075102f, 0.03778334f, -0.13203329f, -0.05495618f, 0.12658130f, 0.10348518f, -0.10180930f, 
    -0.17162457f, 0.22210853f, 0.22425720f, -0.22224796f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
