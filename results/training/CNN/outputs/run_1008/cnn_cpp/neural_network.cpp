#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.28340539f, 0.47693077f, -0.50220340f, -0.16080774f, 1.02407241f, -0.32024065f, -0.26986367f, 0.40325728f, 
    -0.07417280f, -0.26977095f, 1.03493464f, 0.59768373f, -0.93024480f, -0.57645422f, 0.31243509f, -0.32507274f, 
    -0.10538641f, 0.60454118f, 0.58539236f, -0.07726745f, -0.42197764f, -0.18086641f, -0.50842357f, -0.60129952f, 
    0.33226481f, 0.45843372f, 0.33604509f, 1.18731546f, -0.26533338f, -0.27181879f, -0.23778415f, -0.20315976f, 
    -0.07771625f, 0.18540624f, 0.35895535f, -0.10703693f, -0.75193018f, -0.33988559f, -0.81766570f, -0.47546223f, 
    0.85346711f, 0.23599227f, -0.35765517f, 0.26841301f, -0.38227153f, -0.03757365f, -0.01551976f, 0.37343317f, 
    0.38013929f, -0.40693498f, -0.20804878f, -0.49023861f, 0.70968831f, 0.04957097f, -0.37432671f, -0.54710907f, 
    -0.67517990f, -0.17016083f, 0.30021095f, 0.42216668f, 0.50175720f, 0.17018349f, 0.41963777f, -1.01487577f, 
    0.62739050f, -0.25624746f, -0.67980742f, -0.00699989f, 0.72562647f, -0.41447237f, 0.30931145f, 0.38788575f, 
    -0.62873989f, -1.03552568f, 1.70010912f, -0.89210433f, -0.12353010f, -0.33547434f, -0.31877032f, 0.59277380f, 
    -0.13897726f, 0.00811685f, -0.14725845f, 0.38006741f, -0.81539047f, 0.21159427f, 0.29120395f, 0.28593501f, 
    -0.36049369f, 0.31727380f, 0.89339280f, -0.83301264f, -0.95492327f, 0.26960188f, 0.73324633f, 0.63741231f, 
    -0.37618867f, -0.21715969f, -0.11921922f, 0.06486180f, 0.10529336f, 0.78127140f, -0.73522156f, -0.87472528f, 
    -0.13363490f, -0.45759273f, -0.81328177f, -0.62755626f, -0.25163117f, -0.33981353f, 0.68687475f, -0.36405718f, 
    -1.15922379f, -0.71515012f, -0.07259884f, 0.35669628f, 0.17326292f, -0.78463614f, -0.77434003f, -0.67055404f, 
    0.70975596f, -0.98602295f, -0.81937850f, -0.28732944f, 0.36699060f, 0.32251838f, -0.64641452f, -0.43686232f, 
    -0.67739904f, 0.06295170f, -0.48329386f, -0.31277376f, -0.39983970f, -0.63203120f, -0.45559037f, 0.58798778f, 
    -0.29495078f, -0.42102182f, 0.83959663f, -0.84706324f, 0.41902855f, 0.40923214f, 0.20228197f, -0.56368196f, 
    0.63481832f, -0.84127223f, 0.40590957f, -0.20299567f, -0.18541956f, 0.18118748f, -0.05593719f, 0.34472811f, 
    -0.26561743f, 1.42586458f, -0.86715573f, 0.05373375f, 0.07970704f, -0.30686650f, 0.30250925f, 0.12703942f, 
    -0.33849266f, 0.06459070f, 0.40515834f, -0.70246148f, -0.56763440f, -0.18209773f, 0.28243327f, -0.44199833f, 
    0.62241417f, 0.27596834f, -0.39098811f, 0.32336807f, 0.09609157f, 0.05206925f, -0.52205145f, 0.04875271f, 
    0.57820237f, -0.41555458f, 0.50912577f, 0.14945796f, 0.28623700f, 0.48674512f, 0.38819322f, -0.82287520f, 
    -0.10295888f, 0.29272625f, -0.19762591f, -0.05468501f, 0.37515679f, -0.04139161f, 0.84028822f, -0.90802735f, 
    -0.56693989f, -0.62304980f, -0.74659061f, -0.18229906f, 0.07016014f, -0.60078925f, -0.87180567f, -1.39558733f, 
    0.57264608f, 0.59539479f, 0.35448804f, -0.18189630f, 0.07728916f, -0.20146091f, 0.02193376f, -0.87879807f, 
    -0.85938376f, -0.82786691f, 0.75726658f, 0.68121922f, -0.05125641f, 0.22076987f, -0.11835940f, 0.47490066f, 
    1.03472233f, -0.88624817f, -0.65485340f, 0.50555372f, 0.50382429f, 0.10118391f, 0.28044674f, -0.25110018f, 
    -0.45217294f, 0.28101540f, 0.08636487f, 0.00943057f, 0.48345730f, 0.12772375f, 0.05497953f, -0.06051948f, 
    0.42518425f, -0.06833968f, -1.40844584f, 0.20024642f, -0.43867752f, 0.71643269f, 0.54525208f, 0.54579240f, 
    0.09972157f, -0.31989872f, -0.43789679f, -0.09955511f, -0.71833056f, -0.18647045f, -1.00302017f, -0.61381841f, 
    -0.81289214f, 0.20187008f, -0.70845634f, -0.36080697f, 0.43692029f, 0.50392365f, 0.08922249f, -0.01707996f, 
    0.31454933f, 0.63913411f, -0.47205260f, -0.27886140f, 0.15090643f, -0.73529953f, 0.83275318f, -0.58466023f, 
    0.59526145f, -0.71563447f, 0.44412127f, -0.13880357f, -0.03468119f, 0.07283542f, -1.11499536f, -0.50309432f, 
    -0.74152064f, 0.10048010f, 0.51638758f, -0.23164313f, -0.08105922f, -0.74233437f, -0.62568933f, -0.78433615f, 
    -0.53726149f, -0.54347968f, -0.71299106f, -0.63063180f, -0.64839774f, 0.40538040f, 0.59043366f, 0.20690332f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05910772f, 0.40761769f, 0.10019232f, -0.00019888f, -0.22026920f, -0.06730423f, 0.22891407f, 0.30948997f, 
    0.02850504f, 0.20791830f, 0.07202559f, 0.00846850f, 0.44879010f, -0.18497771f, -0.03543784f, 0.22695433f, 
    0.25099549f, 0.21779138f, 0.37865275f, 0.34463134f, 0.53027803f, -0.13558316f, 0.16914086f, -0.04369473f, 
    0.24544387f, -0.12425231f, -0.05407486f, -0.06741522f, -0.29047439f, 0.12829562f, -0.24292180f, -0.24536763f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.09277876f, -0.07906969f, -0.17982984f, 0.09202778f, -0.00369740f, 0.03245513f, -0.00103940f, 0.00199336f, 
    0.04197443f, 0.11302815f, -0.15114519f, -0.03746943f, -0.30771500f, -0.21697325f, -0.30675161f, -0.07609039f, 
    0.01420451f, -0.10301191f, -0.07465376f, 0.01993011f, -0.60431898f, -0.16863360f, 0.26440594f, -0.07801822f, 
    -0.06868650f, -0.10198624f, -0.38076511f, -0.26959610f, -0.03026196f, -0.18790559f, 0.04479735f, -0.02536646f, 
    -0.01770920f, 0.05975695f, 0.04658166f, -0.12686504f, -0.06113777f, -0.03350275f, -0.11448395f, -0.10057785f, 
    0.25798303f, 0.14797348f, -0.16963600f, -0.05493229f, -0.11068832f, -0.08396670f, -0.12942894f, -0.04241597f, 
    0.11970413f, -0.09122744f, -0.02449907f, -0.00692327f, 0.03203072f, 0.05497925f, 0.01957521f, -0.05893053f, 
    -0.05438944f, -0.07965457f, -0.15273392f, 0.01696397f, -0.07012851f, -0.00926015f, -0.07234765f, -0.07081406f, 
    -0.04405790f, -0.17256124f, -0.09447309f, -0.15068595f, 0.13253427f, -0.00433083f, -0.15366760f, 0.12384704f, 
    0.06041855f, 0.02988303f, -0.02829666f, -0.04295403f, -0.09893964f, -0.04198271f, -0.12789355f, 0.05057966f, 
    0.41288722f, 0.06785066f, -0.05858990f, -0.05135468f, -0.20788456f, 0.06265635f, 0.06596356f, 0.28393215f, 
    0.04013490f, -0.01909303f, 0.02984910f, 0.06233830f, -0.00090732f, 0.09646408f, -0.05316902f, 0.00532719f, 
    0.06380057f, -0.02162149f, 0.02939955f, 0.05593725f, -0.02799786f, -0.10389284f, 0.01898861f, 0.06559868f, 
    0.05127098f, -0.03980664f, 0.06516952f, -0.01502793f, 0.06089719f, 0.01407685f, 0.03739880f, 0.07549870f, 
    -0.00668854f, -0.09113044f, -0.08757167f, -0.18729065f, -0.08048054f, -0.18839073f, 0.02784734f, -0.06860218f, 
    0.10785624f, 0.13330692f, -0.05224122f, 0.05283910f, 0.08442638f, 0.10287943f, 0.01888113f, 0.06395471f, 
    -0.03419459f, -0.11082415f, -0.08779780f, -0.04561833f, -0.09931321f, -0.03111586f, 0.07271622f, 0.02906995f, 
    -0.01564540f, -0.03666788f, -0.01941092f, 0.00999681f, -0.25990629f, -0.08327696f, 0.25967374f, 0.06656168f, 
    -0.05418866f, -0.07076824f, -0.00894566f, 0.06492916f, -0.00686533f, -0.22059073f, -0.20642218f, -0.16707928f, 
    0.02315260f, -0.06023729f, 0.05912874f, -0.16252159f, -0.09220155f, -0.01778269f, -0.11692476f, -0.04225680f, 
    0.41948408f, 0.22177888f, 0.29506519f, -0.47451383f, 0.12230649f, -0.09285124f, 0.03575189f, 0.24837737f, 
    0.01069966f, -0.00494049f, 0.09417506f, -0.08559294f, -0.10688004f, -0.14912473f, -0.18481369f, -0.02473856f, 
    0.01416831f, -0.09100868f, 0.16391939f, -0.15478046f, -0.05645321f, -0.03949784f, 0.12466432f, 0.04370952f, 
    -0.01379641f, -0.08014635f, -0.03108961f, 0.04622995f, 0.00306741f, 0.03799683f, -0.16417684f, -0.02273840f, 
    -0.09700563f, -0.09371562f, -0.10685223f, 0.01878547f, -0.12770180f, -0.06326836f, -0.13042526f, -0.12870954f, 
    0.18606177f, -0.19756742f, -0.49780399f, 0.17410164f, -0.07234785f, 0.10462836f, -0.03901491f, 0.11272773f, 
    -0.10681325f, 0.07480187f, -0.08525396f, 0.00927639f, -0.20834847f, 0.03037861f, -0.02293310f, 0.06314743f, 
    0.17563215f, 0.04614340f, 0.09224937f, 0.03174726f, -0.08948861f, 0.32511786f, 0.32501429f, -0.43662730f, 
    0.11783876f, -0.22701541f, -0.28276896f, -0.20178042f, -0.13304503f, -0.05491441f, 0.03530101f, -0.08044122f, 
    -0.04646531f, 0.00628848f, 0.04050864f, 0.07126635f, -0.08193807f, 0.07080253f, 0.01789936f, -0.11296573f, 
    0.20616484f, 0.34727299f, -0.06433450f, -0.46799463f, -0.14974651f, 0.00077572f, 0.01643537f, -0.09078924f, 
    -0.03204308f, 0.05739129f, 0.04898174f, -0.08057459f, 0.02054437f, -0.02823726f, -0.09446507f, -0.06747657f, 
    -0.02606533f, -0.05302921f, 0.06799044f, -0.16984878f, 0.35515279f, 0.29406282f, -0.04862390f, -0.24560402f, 
    -0.05558074f, 0.07109649f, 0.02678283f, 0.20378889f, -0.19264032f, 0.03815738f, 0.00703697f, -0.04935997f, 
    0.04941415f, -0.03976760f, 0.04056433f, -0.00528961f, -0.05217314f, -0.07655763f, 0.00432678f, 0.06241044f, 
    0.29594198f, 0.23322134f, 0.12549366f, -0.17596391f, -0.10980435f, 0.05916364f, 0.19672891f, 0.17746684f, 
    -0.12096708f, 0.00675476f, -0.00401356f, 0.00131415f, 0.04098540f, -0.14709923f, -0.06614907f, 0.01136959f, 
    -0.18969522f, 0.05043571f, -0.01368082f, 0.08656678f, -0.23469740f, -0.22041835f, -0.22145399f, 0.04562004f, 
    0.01378572f, -0.06851798f, -0.02256860f, -0.00953019f, 0.02189228f, 0.05310817f, -0.16939887f, 0.08932154f, 
    0.01698128f, -0.21682359f, -0.09453709f, -0.07705689f, -0.00636281f, -0.09126458f, -0.12200622f, -0.01629353f, 
    -0.31012008f, -0.10563326f, 0.02224446f, -0.31796339f, 0.14781578f, -0.24001527f, -0.12315246f, 0.03415583f, 
    -0.09019482f, 0.01817158f, -0.19280785f, 0.00996057f, -0.04130935f, -0.04986397f, -0.05300274f, -0.02766481f, 
    -0.11957894f, -0.12506858f, -0.30349910f, -0.01521119f, -0.76485133f, -0.41738036f, -0.30518037f, -0.17472339f, 
    -0.03028793f, -0.07219562f, 0.01739995f, 0.00383435f, 0.05726340f, 0.01876074f, 0.09673606f, 0.01648622f, 
    0.00007275f, 0.00656483f, 0.02450821f, 0.01101345f, 0.22790375f, -0.02227177f, -0.04102769f, -0.01317107f, 
    0.23053446f, 0.29172879f, -0.29855198f, -0.18073671f, -0.15622102f, 0.07652473f, -0.11171180f, -0.04094580f, 
    -0.10542596f, -0.00590803f, 0.02659106f, 0.03027066f, -0.21443075f, 0.02810294f, 0.00618242f, -0.03273582f, 
    -0.05336812f, -0.09135770f, -0.01879426f, 0.07673492f, -0.18548208f, -0.12345968f, 0.02649881f, 0.06557543f, 
    -0.00479441f, -0.06595511f, -0.01533015f, -0.03125194f, -0.01443090f, 0.04536371f, -0.06145558f, 0.07021985f, 
    -0.09159227f, -0.02608238f, 0.06930909f, -0.03610855f, -0.16868174f, 0.01210796f, -0.05068319f, -0.03501808f, 
    -0.43712616f, -0.28754601f, 0.06077025f, 0.03091525f, -0.13576604f, -0.02538151f, -0.05872472f, -0.06893363f, 
    -0.02709280f, 0.02695062f, 0.02130704f, 0.00614667f, 0.01889311f, 0.01338607f, 0.07941845f, 0.00352959f, 
    0.01929283f, -0.15352385f, -0.05977514f, -0.07029513f, 0.10528102f, 0.36050269f, -0.06077173f, -0.20399688f, 
    -0.29901016f, -0.04350532f, 0.12239512f, -0.03394417f, -0.08084130f, 0.15718725f, 0.00685221f, -0.05219162f, 
    -0.06835418f, 0.05119797f, 0.01578491f, -0.07024632f, 0.00276026f, -0.00807036f, -0.04160518f, 0.07705456f, 
    0.58073413f, 0.01679675f, -0.19445489f, -0.26120728f, 0.03465031f, 0.02059971f, 0.12268534f, 0.25524658f, 
    -0.17066111f, 0.06965761f, 0.05834608f, -0.08634662f, -0.17164581f, 0.00627401f, -0.04213869f, -0.02196692f, 
    0.03411235f, 0.07011902f, -0.01581690f, -0.02033775f, 0.33797306f, 0.21569596f, -0.41588697f, 0.06669310f, 
    0.12231128f, 0.14234005f, 0.17167154f, 0.16079316f, -0.14562210f, -0.08661927f, 0.01316853f, -0.05390912f, 
    -0.08251375f, 0.07019865f, 0.06807277f, -0.00159430f, 0.08404152f, 0.05567387f, 0.06568822f, 0.05807447f, 
    0.17131378f, -0.65350485f, -0.81537157f, 0.19735919f, -0.09500542f, -0.01557380f, -0.15110911f, 0.03116961f, 
    -0.10187909f, 0.02633372f, -0.04955830f, 0.06508297f, -0.23724028f, 0.05080235f, 0.02746313f, -0.00660132f, 
    0.09348602f, 0.13908885f, -0.03776442f, 0.04395084f, -0.00515155f, -0.02598865f, -0.03766793f, 0.08304615f, 
    0.06612056f, 0.03950426f, 0.07769112f, 0.01946597f, 0.05017884f, 0.06301706f, -0.35659152f, -0.25706679f, 
    -0.20706812f, -0.29666021f, -0.24528684f, -0.04979818f, -0.00272827f, -0.01104431f, 0.02500749f, 0.02866238f, 
    0.30227453f, -0.27336279f, -0.19812505f, -0.04227513f, 0.10023009f, -0.02863321f, 0.15118706f, 0.05141828f, 
    0.09683269f, -0.11755899f, 0.00825310f, -0.01115032f, 0.10012924f, 0.06191517f, 0.01332253f, 0.03724807f, 
    0.07204401f, 0.04274548f, -0.00126360f, 0.00029674f, 0.32240522f, 0.27150252f, 0.21510307f, -0.47732902f, 
    -0.10109886f, 0.13541451f, 0.21926434f, 0.05500140f, -0.07481597f, -0.00633815f, -0.04130214f, -0.03105327f, 
    -0.01316574f, -0.05676797f, -0.03803721f, -0.05529782f, -0.07736053f, -0.10532057f, 0.16367136f, 0.12352073f, 
    -0.19152893f, -0.08692933f, -0.05092363f, -0.00518118f, 0.04544879f, 0.05909832f, 0.01391346f, 0.00428178f, 
    0.07412556f, 0.05564488f, 0.19378486f, 0.08110973f, 0.08888201f, -0.00847350f, 0.06031764f, -0.07215509f, 
    -0.09087250f, 0.00340312f, 0.09857450f, -0.05284155f, -0.36218905f, -0.14060818f, 0.06182201f, -0.16560805f, 
    0.04469329f, -0.16940956f, 0.13154922f, 0.04943474f, -0.21557266f, -0.12201454f, -0.19481371f, -0.01860271f, 
    0.00432444f, -0.13329238f, -0.02410893f, -0.00350165f, 0.00258552f, -0.07112955f, -0.14720894f, -0.09533838f, 
    0.45202550f, 0.16444111f, 0.00973217f, -0.16910748f, -0.10256468f, 0.12509862f, 0.18454488f, 0.12969238f, 
    0.02590594f, 0.04394716f, 0.02459430f, -0.03286511f, -0.00632910f, 0.06450167f, 0.11438686f, -0.09170823f, 
    0.02549264f, -0.09135502f, -0.05822863f, -0.04208039f, 0.51477498f, 0.46880987f, 0.13332328f, -0.29234958f, 
    -0.09597311f, 0.09968674f, -0.01461199f, 0.10669116f, 0.14276752f, -0.03313231f, 0.07923476f, -0.01532788f, 
    0.02026443f, 0.09145270f, 0.06482302f, 0.01000011f, -0.03566911f, -0.04099488f, -0.05584525f, -0.03660939f, 
    0.06014420f, -0.00466661f, -0.00343365f, 0.10365072f, 0.00946341f, -0.03912995f, -0.00431635f, -0.06565581f, 
    0.09933208f, -0.03193262f, 0.11567712f, 0.21452998f, -0.09649149f, -0.04637600f, 0.09161086f, -0.11114077f, 
    0.03487983f, -0.32776260f, 0.07878851f, 0.04120167f, 0.06778781f, -0.14874272f, -0.00694912f, -0.11026626f, 
    -0.02980195f, 0.11886817f, -0.08156160f, -0.09711253f, -0.05858891f, 0.11435849f, -0.04482569f, 0.03086437f, 
    0.04908190f, 0.05041239f, -0.01313891f, 0.00673895f, 0.11339136f, -0.08251944f, 0.10818919f, 0.16533501f, 
    -0.20434727f, -0.08035292f, -0.24237768f, -0.00491519f, -0.19993696f, 0.15181580f, 0.01359780f, -0.00166950f, 
    -0.00753447f, -0.01128143f, 0.03763505f, 0.02181395f, 0.02108388f, 0.10186482f, 0.06573327f, -0.00768978f, 
    -0.02917035f, -0.02753417f, 0.17221375f, 0.10741282f, 0.11122971f, 0.04826180f, -0.00734851f, -0.13771893f, 
    -0.02487226f, 0.00887584f, -0.03362260f, -0.12952900f, -0.03711105f, -0.00668403f, -0.02952212f, -0.05961027f, 
    -0.00675334f, 0.22210930f, 0.03184690f, 0.04891381f, -0.01885237f, -0.05689930f, 0.19377540f, 0.00879146f, 
    -0.27170771f, -0.03703129f, 0.15905924f, -0.09223435f, -0.18811296f, -0.08454353f, -0.05250574f, -0.17139076f, 
    -0.08772415f, -0.02349736f, 0.04102784f, 0.01101521f, -0.08152089f, -0.12457142f, -0.08183631f, 0.05773357f, 
    0.04059792f, -0.13325921f, 0.06255548f, 0.00630735f, -0.06236177f, 0.06049962f, 0.01294278f, -0.00117748f, 
    0.06368861f, 0.18274364f, -0.16792543f, 0.08215456f, 0.00276792f, -0.01998339f, -0.05882768f, -0.00256714f, 
    0.06577679f, -0.09371247f, 0.05292675f, -0.16349758f, 0.15631074f, 0.07822711f, -0.01671943f, -0.08580282f, 
    -0.15229984f, -0.24081539f, -0.25918967f, -0.03577904f, -0.16901152f, -0.05541202f, 0.05073103f, 0.11149592f, 
    0.04484453f, 0.06667607f, -0.00578042f, 0.09269951f, 0.01248800f, 0.03406148f, -0.04386189f, -0.01437887f, 
    0.00999963f, 0.00243312f, -0.04216529f, 0.02649469f, -0.70213622f, -0.50521392f, 0.03315934f, 0.00767427f, 
    -0.07211855f, 0.05988338f, 0.16053474f, 0.15734105f, -0.00374879f, -0.04912492f, 0.12984824f, 0.14346671f, 
    0.04573623f, 0.12205026f, -0.03773689f, -0.09032488f, 0.09680501f, 0.00086521f, 0.04411631f, 0.04687951f, 
    -0.71077305f, 0.55160969f, -0.31644997f, -0.41256252f, 0.26712814f, -0.20347312f, -0.00313328f, -0.32644644f, 
    0.20300336f, 0.16308168f, 0.02817047f, 0.09503465f, 0.06357969f, -0.00692485f, -0.07116532f, -0.04769218f, 
    -0.06278639f, -0.13233657f, -0.23288488f, -0.00965243f, 0.04949361f, -0.01452138f, 0.01974291f, 0.03030043f, 
    0.03172615f, -0.08360043f, 0.08735415f, -0.01927491f, 0.01081691f, 0.00963286f, 0.13626473f, -0.03564634f, 
    -0.00872078f, -0.01612669f, 0.04757884f, 0.03448551f, -0.04964107f, 0.12640643f, 0.02101745f, -0.11605160f, 
    1.12284791f, -0.05716266f, 0.18875057f, 0.23121393f, -0.40671566f, 0.04973092f, -0.02502706f, 0.08730236f, 
    -0.08136304f, 0.01967138f, 0.10851938f, -0.24900901f, -0.16951722f, -0.13435681f, -0.18068883f, 0.07110532f, 
    -0.02317209f, -0.16476274f, -0.04013721f, -0.03943947f, -0.09146524f, -0.04143352f, -0.34953034f, -0.51706767f, 
    -0.28216156f, 0.06536784f, -0.06271891f, -0.08162653f, -0.01802708f, -0.00847961f, -0.01308270f, 0.00574405f, 
    -0.03676420f, 0.01905744f, 0.04001720f, -0.09542530f, -0.31020141f, -0.16772023f, -0.12465122f, -0.31936991f, 
    -0.50077987f, 0.17219734f, -0.19001560f, 0.07625343f, -0.04265795f, 0.08757006f, -0.19188525f, -0.05051215f, 
    0.28476331f, -0.04142947f, -0.09349919f, 0.04259223f, 0.04174427f, 0.11196064f, 0.12173114f, -0.03711187f, 
    0.00596549f, 0.09812745f, -0.05685594f, 0.17061205f, 0.05065467f, 0.23599653f, -0.02704493f, 0.32756644f, 
    -0.07748408f, -0.05646679f, 0.18363425f, 0.06054046f, 0.13211112f, -0.08503209f, -0.07150511f, -0.03900905f, 
    0.01209279f, -0.03668373f, -0.03249894f, -0.08347064f, 0.10446785f, -0.01342179f, -0.13762891f, 0.13441585f, 
    0.16447262f, 0.38442472f, 0.25263911f, 0.17405510f, -0.00090691f, 0.09221541f, -0.05524280f, 0.09158325f, 
    0.02207367f, 0.08128954f, 0.00764309f, 0.04121672f, 0.04870687f, -0.06176433f, 0.07107200f, -0.07619148f, 
    -0.02173899f, -0.02431219f, -0.07327174f, 0.06447080f, 0.47106338f, 0.16101789f, -0.06611169f, -0.02491605f, 
    -0.10036695f, -0.05814327f, -0.05660734f, -0.01892922f, 0.17422995f, -0.13297994f, 0.07768721f, 0.13366403f, 
    0.02920104f, 0.07701015f, -0.15823814f, -0.05940393f, -0.03307442f, 0.12765566f, 0.00435775f, 0.03134610f, 
    -0.00812705f, 0.17505832f, -0.15919545f, -0.12401909f, 0.19869418f, -0.13944829f, 0.15867075f, -0.06847981f, 
    -0.01286844f, 0.12366847f, -0.17997849f, -0.00684292f, 0.00181098f, 0.24695460f, -0.02681013f, 0.00675548f, 
    0.12182809f, 0.12567644f, 0.00434076f, 0.02696797f, 0.76128083f, 0.45592386f, -0.02274400f, 0.17752415f, 
    0.00274584f, -0.15162621f, 0.03208801f, -0.10974448f, -0.12139063f, 0.01152373f, -0.07645163f, -0.08191249f, 
    -0.04640192f, 0.07061701f, -0.04969530f, -0.09649190f, 0.06416605f, -0.00505351f, 0.07282626f, 0.05646289f, 
    -0.12263308f, 0.03479734f, -0.30164328f, -0.14077191f, -0.13989559f, -0.06217971f, 0.05119341f, 0.14157283f, 
    0.05144733f, 0.03289216f, 0.07170243f, 0.00338441f, -0.04622212f, 0.11038852f, 0.07060066f, 0.03239244f, 
    0.03300565f, -0.02650459f, -0.05920609f, 0.03440909f, 0.13491395f, 0.05807948f, 0.12829505f, -0.00453836f, 
    0.10400134f, -0.02873393f, 0.01105047f, -0.00113608f, -0.06051290f, -0.00160342f, 0.03381774f, 0.02371920f, 
    0.03925923f, 0.22334848f, -0.12065241f, -0.14959559f, 0.17914143f, 0.03559245f, 0.04089392f, 0.06417621f, 
    0.28466311f, 0.04624654f, 0.07883713f, -0.04036462f, 0.02368181f, -0.01101051f, -0.07319538f, 0.02270756f, 
    -0.04327331f, 0.03232403f, 0.02985954f, 0.04420778f, 0.04921738f, 0.03421897f, 0.00951042f, 0.11498780f, 
    0.12177648f, -0.06215953f, 0.02846276f, 0.06652009f, -0.25876984f, -0.00451062f, -0.11386780f, 0.16479668f, 
    -0.48205543f, 0.09754015f, -0.14678915f, -0.31165990f, -0.35423821f, 0.04794508f, -0.04282820f, 0.00792345f, 
    -0.01986541f, 0.07097838f, 0.10136369f, -0.09600300f, 0.02360261f, -0.02722782f, -0.12324617f, -0.18183586f, 
    0.11746351f, -0.25815398f, 0.00382882f, -0.14293812f, 0.01601778f, -0.02023198f, -0.00287287f, 0.22481161f, 
    0.13300936f, -0.04291869f, 0.10340286f, -0.03828732f, 0.15170521f, -0.11267880f, -0.18645331f, 0.04927052f, 
    -0.03088292f, 0.04199336f, -0.03866089f, -0.08826628f, 0.05854266f, -0.24857852f, -0.03066511f, -0.05097664f, 
    -0.06681249f, 0.03579187f, -0.02363003f, 0.16745974f, -0.01615651f, -0.39585790f, 0.03190786f, -0.13098238f, 
    0.01227766f, -0.08408282f, -0.09092962f, 0.00060297f, -0.02107398f, -0.03564437f, -0.01285841f, 0.01438254f, 
    0.84935200f, 0.06570236f, -0.08632860f, 0.09676926f, -0.14614768f, 0.00199935f, -0.02018098f, 0.01971781f, 
    -0.06524237f, -0.00545928f, 0.22333899f, -0.14545622f, 0.08470225f, -0.07392815f, -0.00623271f, -0.03085626f, 
    -0.15226418f, -0.19123378f, 0.02022632f, 0.07651854f, 0.12808900f, 0.01439023f, 0.08769654f, 0.10530577f, 
    0.04203967f, 0.00935939f, -0.08651049f, -0.01070717f, -0.05395138f, -0.06732963f, 0.06735073f, 0.16450557f, 
    -0.06063476f, 0.01171933f, 0.12791982f, -0.17436911f, -0.06972548f, -0.07191866f, 0.01057420f, -0.03471453f, 
    -0.32216975f, -0.33216569f, 0.00717351f, 0.01596015f, -0.12010182f, 0.05811518f, -0.08116565f, -0.05044124f, 
    -0.02262835f, -0.11698361f, 0.03884292f, -0.05328385f, -0.07676639f, -0.07049080f, 0.24526890f, 0.06804614f, 
    -0.03910416f, -0.12511007f, 0.06891699f, -0.03607220f, -0.07733544f, 0.27045295f, -0.04383548f, -0.06633227f, 
    0.08848906f, -0.01642978f, -0.19421855f, 0.00529223f, -0.22867030f, -0.01883871f, 0.03148451f, -0.01787034f, 
    0.08723608f, -0.01858757f, 0.13473640f, -0.02896444f, 0.00857756f, 0.18866363f, -0.46171248f, -0.20138434f, 
    0.29456031f, 0.09913629f, 0.14270926f, 0.07278436f, 0.22767144f, -0.08445678f, -0.02853945f, -0.01096318f, 
    -0.02196121f, -0.05122320f, -0.08356386f, 0.04597130f, -0.00175182f, -0.00814650f, -0.04781999f, 0.16815050f, 
    -0.11208912f, -0.17466803f, 0.04365540f, 0.00132764f, -0.73686922f, 0.30527666f, 0.08706367f, -0.14660347f, 
    0.07909708f, 0.01987650f, 0.10531104f, 0.04703643f, -0.10862873f, -0.11462705f, -0.10823193f, 0.04108181f, 
    0.07699639f, -0.06308941f, -0.05853428f, 0.04752306f, 0.02979818f, 0.08134933f, -0.06856947f, -0.05007075f, 
    0.25008446f, 0.17063613f, 0.33793056f, -0.12490880f, 0.04000317f, 0.09380271f, -0.19631572f, 0.11872432f, 
    0.14013159f, 0.06799519f, 0.02877510f, -0.02757056f, -0.04838874f, -0.18399855f, -0.07503621f, 0.23747300f, 
    -0.08825670f, -0.13239761f, -0.03975976f, 0.02510859f, -0.30645698f, 0.04269718f, -0.06055919f, 0.38843614f, 
    0.18008499f, -0.11326192f, 0.11186832f, -0.19081935f, 0.07715479f, -0.06840532f, -0.03797539f, -0.02948667f, 
    0.00921019f, 0.06954548f, 0.03228368f, -0.02911540f, 0.04577215f, -0.01707675f, 0.00232852f, 0.06227031f, 
    0.17028579f, -0.24623559f, -0.09026910f, -0.11189903f, 0.05078396f, 0.06739169f, -0.10656250f, -0.02747833f, 
    0.06723198f, 0.01920488f, 0.00098445f, -0.30491647f, 0.02912115f, 0.00488163f, 0.18685049f, 0.08736759f, 
    -0.13514805f, -0.23356891f, 0.23547210f, -0.06877042f, -0.27042666f, -0.03183725f, 0.03134013f, -0.06188820f, 
    0.05101488f, -0.13358721f, 0.09412022f, 0.01240179f, -0.09418204f, 0.00078906f, -0.03578020f, -0.01380254f, 
    -0.00758908f, -0.01652500f, -0.01101709f, 0.08519225f, -0.10342947f, -0.00144634f, -0.03057678f, -0.07587783f, 
    -0.27587295f, -0.02451610f, 0.01171619f, 0.04545710f, -0.08700705f, 0.04720917f, 0.08675981f, -0.19314338f, 
    -0.10129879f, -0.36606029f, 0.05450135f, -0.04026729f, 0.02802775f, 0.03443982f, -0.03565041f, 0.00050203f, 
    0.04215397f, -0.06978803f, -0.05369779f, -0.15814975f, -0.33580664f, 0.06881476f, -0.01808984f, 0.08913930f, 
    -0.02287429f, -0.05525113f, -0.01561145f, -0.22307588f, -0.13143533f, 0.08626031f, 0.14162314f, -0.01928683f, 
    -0.12706344f, 0.06374694f, -0.04297952f, 0.07168049f, -0.04412243f, -0.06742101f, -0.07672364f, -0.03815383f, 
    -0.01666040f, 0.13090172f, 0.71869802f, -0.21642585f, 0.35046178f, -0.03958900f, -0.13539465f, -0.12495836f, 
    0.09688263f, 0.14261675f, 0.00790205f, 0.02763411f, -0.04295335f, -0.03843246f, 0.16166806f, 0.03587968f, 
    -0.01856505f, -0.07967066f, 0.06508798f, 0.01488556f, -0.01696665f, 0.12298786f, -0.14215037f, -0.18014948f, 
    0.07293021f, 0.02610757f, -0.10115260f, -0.00444122f, 0.02283244f, 0.13441169f, 0.11847094f, -0.07276856f, 
    -0.08521613f, 0.07257041f, 0.12335864f, 0.03993552f, -0.13856433f, 0.00236541f, 0.09373550f, 0.01946913f, 
    0.08049145f, 0.12789460f, 0.21081227f, 0.06706849f, 0.14696796f, 0.02491316f, 0.00886529f, 0.06172597f, 
    0.07584789f, -0.27633402f, -0.10322946f, -0.10067259f, 0.06730343f, 0.05456162f, 0.11014830f, 0.03412784f, 
    -0.05089757f, 0.02453352f, 0.01774854f, -0.06674102f, 0.18851823f, 0.19535393f, -0.10284165f, 0.11557626f, 
    0.08530217f, -0.08791895f, 0.05205922f, 0.06053998f, -0.15196046f, -0.07632411f, -0.11364286f, -0.01803404f, 
    0.01012080f, 0.02855080f, 0.10166159f, -0.01974826f, 0.01603779f, -0.00491893f, 0.04243774f, 0.04768295f, 
    0.94279987f, 0.06146983f, -0.70223504f, -0.09154534f, -0.16176210f, -0.24533069f, 0.12287048f, -0.28849432f, 
    -0.01217580f, 0.20579380f, -0.05134943f, -0.11274917f, -0.00226693f, -0.00314656f, -0.11305583f, 0.05352587f, 
    0.02303028f, 0.00099515f, -0.08163485f, 0.00158891f, 0.00780901f, -0.05658836f, -0.13949907f, 0.03042004f, 
    0.05931586f, 0.01400341f, 0.04755436f, -0.03778877f, -0.01970959f, 0.04116257f, -0.00727605f, 0.07797604f, 
    0.00944214f, 0.07386351f, -0.02162450f, 0.09515651f, -0.04518534f, 0.06592869f, -0.03851097f, -0.00195334f, 
    -0.18955222f, 0.30515045f, 0.73666584f, 0.00094877f, 0.18652134f, -0.04773153f, -0.03056506f, -0.05904345f, 
    -0.13227308f, 0.16919729f, 0.12868445f, -0.03052874f, 0.10846779f, -0.05426427f, 0.04580887f, 0.00344780f, 
    0.04214426f, -0.02054306f, 0.03115164f, -0.09122133f, -0.09374885f, 0.28580198f, 0.08160557f, -0.00919318f, 
    -0.10456326f, -0.08522421f, 0.08145988f, -0.02196468f, -0.00995517f, 0.05551133f, 0.00191296f, 0.01188475f, 
    0.00649643f, -0.02580841f, 0.00094372f, -0.03250881f, 0.11961561f, 0.32018903f, -0.04467391f, 0.16242361f, 
    -0.11792080f, -0.28498542f, -0.27219436f, -0.11526272f, -0.22601283f, 0.14298946f, 0.11932095f, -0.12715465f, 
    0.04602551f, 0.06457482f, 0.00178831f, -0.00647080f, -0.02699468f, -0.02020412f, -0.07650514f, 0.04356431f, 
    -0.01227502f, 0.05835022f, -0.02391555f, -0.04969185f, -0.01952463f, -0.57317114f, 0.01646344f, 0.58834773f, 
    -0.51123881f, 0.02813974f, -0.13692720f, -0.04722854f, 0.17652316f, -0.20078653f, 0.01901385f, 0.05522773f, 
    0.00176832f, 0.03673436f, -0.10371304f, 0.00071570f, 0.05650290f, 0.09288301f, 0.21191345f, -0.08896171f, 
    -0.31324190f, -0.16034521f, 0.28219464f, 0.45034620f, -0.00564832f, -0.08546807f, -0.01917900f, 0.05892486f, 
    0.01090167f, -0.10562237f, -0.01536855f, 0.00849857f, 0.02760043f, -0.00934863f, -0.04326966f, -0.02878772f, 
    -0.01761188f, -0.09250138f, -0.15081745f, 0.10822126f, -0.12507203f, 0.10208299f, -0.09169391f, -0.05329169f, 
    0.06792933f, 0.00836503f, -0.02469168f, 0.04353387f, 0.06141412f, 0.01705858f, -0.05257493f, 0.04844720f, 
    -0.19123469f, 0.08631451f, 0.10949371f, 0.03905363f, -0.05324996f, 0.08813318f, -0.04524627f, -0.05597315f, 
    -0.07129829f, 0.16426750f, -0.19801021f, 0.09312757f, -0.00337738f, -0.18610504f, -0.03553350f, -0.20432818f, 
    -0.03133959f, 0.01714442f, 0.11862750f, 0.01754884f, -0.10118437f, 0.01222414f, -0.04396713f, -0.01235033f, 
    0.01355007f, 0.01246137f, -0.13760734f, -0.07496169f, -0.86972320f, 0.40701258f, -0.28766096f, 0.34504351f, 
    -0.39094409f, -0.05842120f, -0.00813123f, -0.00312199f, -0.11813029f, 0.15414359f, -0.00840786f, 0.02292495f, 
    -0.01016828f, 0.07686335f, -0.10129941f, 0.08406343f, -0.10330015f, 0.01232000f, 0.13233364f, -0.08304441f, 
    -0.05727468f, -0.11113919f, -0.05460121f, -0.07290746f, 0.09006790f, -0.02455810f, -0.01036637f, -0.16651103f, 
    0.15691251f, -0.07627276f, 0.00191603f, 0.06424470f, 0.09072473f, 0.07436704f, 0.02759970f, 0.07952902f, 
    0.06946243f, -0.05504786f, 0.06914152f, 0.00597742f, -0.01749513f, 0.04537947f, -0.02314736f, -0.01731515f, 
    0.15234110f, -0.11191422f, 0.08357408f, 0.00515526f, 0.01226145f, 0.08434965f, -0.00599263f, -0.00608368f, 
    -0.13495605f, 0.17483078f, -0.01863165f, -0.01418527f, -0.15821920f, 0.08360752f, 0.01141726f, -0.07215764f, 
    -0.18889758f, -0.09497279f, 0.05092068f, -0.07081913f, 0.04611819f, -0.01377472f, 0.01066123f, -0.01371954f, 
    -0.02079377f, 0.09852056f, 0.01709767f, -0.02460561f, 0.02427565f, 0.02011112f, 0.00915976f, 0.02504251f, 
    -0.06141246f, 0.07961007f, -0.02867830f, -0.05474131f, -0.24322186f, -1.09859633f, -0.01179910f, -0.13902406f, 
    -0.38790834f, 0.19169179f, -0.02304888f, -0.15979372f, 0.05769085f, -0.12751286f, -0.03815648f, 0.02064615f, 
    -0.02942426f, 0.00392915f, -0.07177968f, -0.00371532f, -0.06449677f, -0.16738166f, 0.28545037f, 0.12560838f, 
    0.36038896f, -0.10744000f, 0.68882006f, 0.21662115f, 0.34264237f, 0.02025955f, 0.06137249f, -0.06306156f, 
    0.15100107f, 0.04139922f, 0.07991340f, 0.04430178f, 0.03589247f, -0.05135016f, 0.03174232f, -0.00688277f, 
    -0.06382985f, 0.02998475f, -0.05197142f, 0.00685487f, -0.06021458f, -0.21642037f, 0.47282109f, 0.23609139f, 
    0.24330647f, -0.04402572f, -0.10785363f, 0.07622117f, 0.20586690f, -0.24921067f, 0.09402233f, -0.02222195f, 
    0.11767576f, -0.09859557f, 0.08209144f, 0.01277247f, -0.04836888f, -0.03333623f, 0.04193030f, -0.06058758f, 
    -0.21210465f, 0.21743703f, 0.39894721f, -0.21491742f, 0.19536375f, 0.00060894f, -0.09921051f, -0.08946992f, 
    -0.01172000f, 0.16061258f, 0.06445556f, -0.04701395f, -0.02594533f, -0.09366880f, 0.07259118f, 0.08181439f, 
    0.01811734f, 0.11005297f, 0.12764084f, -0.09372410f, -0.10955589f, -0.05014868f, -0.10536289f, -0.06231325f, 
    0.05485841f, 0.04637022f, -0.01171009f, 0.07893630f, 0.04434660f, 0.05940888f, -0.08356380f, -0.22795989f, 
    -0.04378945f, 0.14331840f, -0.02805636f, 0.04087903f, -0.02544480f, -0.02591412f, 0.03833903f, 0.00195651f, 
    -0.31753531f, -0.47690865f, 0.43358463f, 0.05102947f, 0.24986345f, -0.02113318f, -0.01644213f, 0.11261459f, 
    -0.02337647f, -0.23101872f, 0.03081581f, 0.01114002f, -0.15844880f, -0.06267077f, 0.05304343f, 0.08579252f, 
    0.00021647f, 0.05890677f, -0.02779584f, 0.00585890f, -0.84760916f, -0.63664752f, -0.59336537f, 0.05553389f, 
    -0.57335013f, 0.00592711f, 0.06341300f, 0.04958687f, 0.08597036f, 0.03992471f, -0.00250924f, -0.02610715f, 
    -0.02489389f, -0.02447916f, -0.08720469f, -0.08921374f, -0.01876296f, -0.04035052f, -0.10518828f, 0.21319367f, 
    -0.28656152f, -0.36539826f, -0.23436433f, -0.08491603f, -0.07148595f, -0.04133025f, -0.01506902f, 0.03489894f, 
    0.02413042f, 0.07507210f, -0.07047591f, -0.06422188f, -0.07446854f, -0.01172435f, 0.02562160f, -0.14178258f, 
    -0.02479289f, 0.01370244f, 0.03465004f, -0.05228588f, 0.18366298f, 0.06974124f, -0.23992066f, 0.11009561f, 
    -0.12447932f, 0.17944932f, -0.02331383f, 0.06963030f, 0.03149103f, -0.13639806f, -0.14443244f, 0.06600235f, 
    -0.05543436f, 0.11673790f, 0.20654424f, -0.03752423f, 0.06395607f, -0.01244260f, 0.05142004f, -0.01688554f, 
    -0.26147771f, -0.12994705f, 0.60465413f, 0.26546270f, 0.43213356f, -0.07175510f, -0.09553979f, -0.08049982f, 
    0.02457520f, -0.07816196f, -0.01830647f, -0.01576327f, 0.01763707f, -0.13474855f, -0.02042642f, -0.03480027f, 
    0.03473432f, -0.12428553f, -0.05719047f, 0.07162147f, -0.21028376f, -0.32438010f, -0.50122523f, -0.09158374f, 
    -0.21068022f, 0.07546231f, 0.03228280f, -0.02628334f, 0.07144865f, -0.24732421f, 0.02016774f, 0.10471819f, 
    -0.00673191f, 0.02867773f, -0.06578054f, 0.01046562f, -0.02481771f, 0.00361207f, -0.16075815f, -0.00264958f, 
    -0.39528608f, 0.40077385f, -0.48311850f, -0.06049479f, -0.47096631f, 0.12359480f, -0.19319843f, -0.21205442f, 
    0.01168386f, -0.10515282f, -0.15728644f, -0.17520651f, -0.08577099f, -0.07083076f, 0.00410834f, 0.02330673f, 
    -0.03088892f, 0.00699384f, 0.18197002f, -0.16218112f, 0.30344930f, 0.20002389f, 0.44578454f, -0.35937095f, 
    0.18630061f, -0.22379616f, 0.02591844f, 0.00132618f, -0.11783335f, -0.13590389f, 0.16015485f, 0.05899972f, 
    0.03955550f, 0.03039830f, 0.11382697f, -0.00803591f, -0.00643631f, -0.05586289f, -0.05275205f, -0.11735320f, 
    -0.25131810f, -0.07618609f, -0.12334178f, 0.15908630f, 0.24676970f, 0.11835115f, 0.13162671f, 0.19829816f, 
    -0.02302806f, 0.02731976f, 0.05431589f, -0.01552568f, -0.09695983f, -0.03561518f, -0.08482189f, 0.05711615f, 
    -0.18363002f, -0.01932422f, -0.00234063f, 0.01558894f, -0.87496930f, -0.02393056f, 0.17488918f, 0.65226573f, 
    0.06128757f, 0.09401736f, -0.06592115f, 0.18953112f, -0.12020638f, 0.02472776f, 0.02850544f, 0.21462581f, 
    -0.08768303f, 0.05719520f, -0.09002727f, 0.08705135f, 0.07687344f, 0.12856950f, -0.02841207f, -0.08261315f, 
    0.29806155f, 0.03259252f, -0.13382055f, -0.01588164f, 0.26109099f, 0.14828545f, -0.00912884f, 0.13684927f, 
    -0.04859390f, -0.14850949f, -0.22000925f, 0.03345195f, 0.04208553f, 0.04633189f, 0.08015812f, -0.06086403f, 
    0.14198826f, -0.04624516f, 0.00434146f, 0.11190578f, -0.04067124f, 0.12076816f, -0.02021059f, -0.31533283f, 
    -0.22018744f, -0.30389175f, 0.09687024f, -0.16313562f, -0.08636069f, -0.18405998f, 0.10059793f, -0.10604914f, 
    -0.30787545f, -0.02492592f, 0.07607571f, -0.15172680f, -0.15684137f, 0.15941939f, -0.18947601f, -0.07295465f, 
    -0.18462546f, -0.02531477f, -0.12141827f, 0.00140323f, 0.24954687f, 0.07327981f, -0.11328243f, 0.05122388f, 
    -0.16481917f, -0.01447667f, -0.13973893f, 0.00629809f, -0.00924013f, -0.07013901f, -0.05655232f, 0.00112839f, 
    -0.08356141f, -0.00707380f, 0.06594238f, -0.01321028f, 0.53569663f, 0.14731915f, -0.32389417f, -0.04237605f, 
    0.02059420f, -0.08926670f, -0.13638441f, 0.18365277f, -0.18363817f, -0.08647291f, -0.16342856f, -0.10603271f, 
    -0.05046749f, 0.16804360f, 0.05621444f, 0.12532406f, 0.07506905f, 0.03484456f, -0.10003456f, -0.01866754f, 
    0.01044907f, 0.56671387f, -0.33085114f, -0.05334411f, 0.23721087f, -0.15582508f, 0.06556868f, -0.23529889f, 
    -0.15912783f, -0.11507225f, 0.01744782f, -0.01034289f, -0.24355993f, 0.09811015f, 0.01027265f, 0.10741438f, 
    -0.13614789f, 0.23917516f, -0.23074138f, 0.01071170f, 0.08439600f, -0.11537463f, -0.17174184f, -0.31078303f, 
    -0.68836582f, 0.04146440f, -0.12450536f, -0.09544908f, 0.13265790f, -0.10953503f, 0.03271104f, -0.00780979f, 
    0.07543878f, -0.18964423f, -0.12057642f, -0.01524033f, 0.00157720f, -0.09359824f, 0.16373092f, -0.00650942f, 
    0.27986792f, 0.80119735f, 0.01113250f, 0.13355809f, 0.11501637f, 0.14739558f, -0.01329939f, 0.07424309f, 
    0.07705853f, 0.11039563f, -0.06014512f, -0.04277651f, -0.04247027f, 0.02160883f, 0.12971684f, -0.01192639f, 
    -0.14537463f, 0.02506643f, -0.02784894f, 0.00439622f, 0.04386858f, -0.17513831f, 0.36065835f, -0.01861664f, 
    0.21320882f, -0.31038582f, 0.05141819f, 0.11454614f, 0.07770375f, 0.03625797f, 0.06783254f, 0.00248326f, 
    0.03716160f, 0.00960094f, 0.01716418f, -0.02109170f, 0.04388788f, 0.15481199f, -0.07191458f, -0.10914382f, 
    0.08270141f, 0.00091457f, -0.13795550f, 0.05357632f, 0.26277044f, 0.00130380f, 0.02954985f, -0.05418988f, 
    0.03112555f, -0.10861730f, 0.08929531f, -0.07268951f, -0.17431226f, -0.05856015f, 0.00166954f, -0.04607093f, 
    -0.21846713f, 0.13230740f, -0.31083566f, -0.07219150f, -0.14461333f, -0.13242209f, -0.40082061f, -0.11060347f, 
    0.40354708f, 0.09279101f, -0.07786147f, -0.01656713f, 0.12608120f, -0.00544674f, -0.06197720f, 0.12006460f, 
    -0.14776549f, 0.08987125f, -0.07492059f, -0.09226528f, -0.05257732f, 0.22227706f, -0.01024117f, 0.02734459f, 
    0.04855393f, -0.11504472f, -0.30267972f, -0.02232474f, 0.26841977f, 0.00211382f, -0.00315517f, -0.06508843f, 
    0.03181201f, 0.02445023f, -0.03211335f, 0.01069634f, 0.00216606f, 0.04071634f, 0.04814907f, -0.00969490f, 
    0.00390076f, 0.05427759f, 0.00556900f, -0.05023936f, -0.48016110f, -0.36606976f, 0.48571712f, -0.34313130f, 
    0.14872028f, 0.06739756f, -0.00937302f, 0.01002744f, -0.07196023f, -0.11657923f, -0.20723756f, -0.04605631f, 
    0.11572969f, 0.11856835f, -0.07506461f, 0.00727156f, 0.09381054f, 0.23600115f, -0.03521578f, -0.11281202f, 
    -0.57165265f, -0.00413403f, -0.14628419f, 0.16753472f, -0.36560363f, -0.02167107f, -0.08133248f, -0.04401778f, 
    -0.21483812f, 0.07520182f, -0.12097806f, 0.12637317f, -0.16857432f, -0.02520726f, -0.14751568f, 0.04829704f, 
    -0.17983203f, 0.25351027f, -0.07922672f, -0.11616004f, -2.17277455f, 0.05086447f, 0.17001209f, 0.52334893f, 
    0.04687468f, 0.26596585f, -0.22462949f, -0.00335994f, -0.20398642f, -0.30489287f, -0.09530102f, 0.20883942f, 
    -0.10200778f, 0.12868801f, -0.11145749f, -0.01577145f, 0.07810000f, 0.05550531f, -0.22549118f, -0.15114842f, 
    -0.15495747f, 0.01329625f, -0.20537643f, 0.09858960f, 0.24662642f, -0.01476288f, -0.00203100f, 0.00851521f, 
    -0.01934054f, 0.09841499f, -0.04093854f, 0.12122563f, 0.20402159f, -0.02463238f, 0.00152256f, 0.13153933f, 
    0.07246058f, 0.01421886f, 0.00302021f, -0.11299624f, -0.17452887f, 0.05420812f, 0.10340841f, -0.25221503f, 
    -0.29971084f, -0.11645115f, -0.23618245f, -0.02285744f, -0.13679029f, -0.22010665f, 0.01493397f, -0.00446904f, 
    -0.11368342f, -0.05205727f, 0.12086174f, 0.02973222f, 0.00729712f, 0.07843439f, -0.07198394f, -0.02728518f, 
    -0.23984119f, -0.03597604f, 0.45237187f, 0.04161644f, -0.14118905f, -0.21502936f, -0.22306077f, -0.14184077f, 
    -0.07423393f, -0.19959554f, 0.07542252f, 0.04288948f, 0.02805177f, -0.00474835f, 0.05674820f, -0.10780077f, 
    -0.06928289f, -0.12378138f, -0.04931068f, -0.10834435f, 0.13512014f, -0.24411972f, 0.01398240f, 0.02989928f, 
    0.48411956f, 0.15401129f, 0.18691964f, 0.04011828f, 0.06990416f, -0.08042459f, 0.04643323f, -0.04055697f, 
    -0.04901312f, -0.13591008f, 0.02349142f, 0.01988148f, -0.11400480f, 0.00276518f, 0.05598787f, -0.05251209f, 
    -0.83763981f, 0.67288113f, 0.02239250f, -0.19596727f, 0.39419550f, 0.26461211f, 0.13618264f, -0.11411590f, 
    0.05248016f, -0.18513551f, -0.37105015f, 0.04548172f, -0.09433523f, -0.01127189f, 0.13154267f, -0.08786444f, 
    0.07055281f, -0.10137518f, 0.03610157f, -0.06932359f, -0.34875515f, 0.12243263f, -0.03006665f, -0.04166419f, 
    0.38876498f, 0.37762424f, 0.09235875f, -0.03237357f, -0.09178787f, -0.03141158f, -0.05196718f, 0.05131202f, 
    -0.00682155f, 0.02738308f, 0.01841148f, -0.06940284f, -0.09062393f, -0.01716827f, 0.12437042f, -0.03027663f, 
    -0.49433717f, 0.81414765f, 0.04038502f, -0.00547608f, 0.12863065f, 0.16602825f, 0.00530915f, -0.00678129f, 
    -0.11125710f, 0.07657106f, -0.10215858f, -0.02125648f, 0.06298209f, 0.14579028f, -0.04003750f, 0.01603466f, 
    -0.03466628f, 0.01965727f, -0.12510534f, -0.00338875f, -0.16131464f, -0.64564490f, -0.17925473f, 0.06506621f, 
    -0.20470861f, 0.07411940f, 0.06588565f, 0.04168352f, -0.05501482f, 0.04474631f, -0.05912994f, -0.10477995f, 
    -0.13371210f, -0.06433501f, -0.24196428f, -0.01440980f, -0.01418651f, -0.06190871f, -0.17240690f, -0.15463825f, 
    0.84936416f, 0.13386407f, -0.17412852f, -0.18819536f, 0.12162250f, 0.47587299f, 0.15069662f, 0.22308496f, 
    0.18695684f, 0.05588705f, -0.15683971f, -0.13859046f, 0.18659124f, -0.03296939f, 0.02370832f, -0.22252585f, 
    -0.00073847f, -0.04086038f, 0.04116024f, 0.06205884f, -0.02518017f, -0.11069587f, -0.23760399f, 0.13683143f, 
    0.25118506f, -0.12580179f, 0.11033298f, 0.06454177f, 0.08697573f, 0.03159911f, -0.08138990f, -0.02218251f, 
    0.01358613f, -0.20087086f, -0.07531738f, -0.04541139f, 0.06268243f, 0.03339045f, -0.08570959f, -0.07304417f, 
    -0.84475720f, -0.38147494f, -0.23574997f, 0.06685869f, -0.49611282f, 0.15740179f, 0.14198866f, -0.02766065f, 
    0.21308579f, 0.10782360f, 0.06881236f, 0.04299111f, 0.27337864f, 0.09626097f, -0.16007499f, 0.12292936f, 
    -0.00762472f, -0.11619705f, -0.19923678f, -0.05005627f, 0.39548206f, -0.25146148f, -0.23381953f, -0.04677118f, 
    0.05888418f, 0.13549413f, 0.02881213f, 0.02441034f, 0.01649361f, -0.16923149f, -0.06738038f, -0.10089484f, 
    0.08091426f, -0.02485385f, -0.22864762f, -0.14656243f, -0.08442841f, 0.24463753f, 0.10482986f, -0.10023177f, 
    0.13829097f, -0.00700558f, -0.16492766f, 0.02903551f, 0.30562839f, 0.19739711f, 0.09256572f, -0.03222782f, 
    -0.03154921f, 0.05912108f, 0.06176542f, 0.06526974f, 0.13790113f, 0.13655125f, 0.22338544f, -0.07297646f, 
    0.02744213f, 0.07752896f, -0.03821406f, 0.04892724f, 0.13064444f, -0.26491606f, -0.38048232f, -0.06457653f, 
    0.22464395f, 0.24287462f, 0.06959903f, 0.15490565f, 0.19855815f, 0.08026376f, 0.06382186f, -0.00895861f, 
    0.10617457f, -0.08358215f, -0.05348377f, 0.04433561f, -0.04157889f, 0.08634132f, -0.01515835f, 0.14995348f, 
    0.02738375f, 0.01740649f, 0.04616597f, 0.01335807f, -0.14145602f, 0.13151027f, -0.02551015f, 0.12626199f, 
    -0.03545009f, 0.05388034f, -0.20158021f, -0.01952101f, 0.18563192f, -0.16455358f, 0.06889860f, 0.01202238f, 
    0.01777189f, 0.02844066f, -0.24097554f, 0.00781245f, 0.05269709f, 0.02758690f, -0.16905464f, 0.11370128f, 
    0.21525121f, -0.18165298f, 0.01329705f, -0.15664676f, 0.03068561f, -0.07316488f, 0.12944078f, -0.13538730f, 
    -0.07922737f, -0.06594487f, 0.05228655f, -0.16755328f, -0.03796456f, -0.03229482f, -0.01591504f, -0.22354035f, 
    0.07148395f, 0.08118780f, 0.24551843f, -0.15234081f, 0.08283038f, 0.01627599f, -0.01297044f, 0.05075423f, 
    -0.07766693f, 0.25639528f, 0.13286316f, 0.06895079f, 0.10256816f, -0.00235632f, 0.02667532f, 0.01679111f, 
    -0.10064200f, -0.15691419f, -0.16312304f, -0.46903574f, 0.17880286f, -0.09127112f, 0.08554161f, -0.14888462f, 
    0.16960080f, 0.11479018f, 0.13003561f, 0.34306672f, -0.19537450f, -0.03368750f, 0.08816055f, 0.06790425f, 
    0.16352215f, -0.19488315f, 0.00680685f, -0.02187884f, -0.06131207f, -0.07025807f, -0.17066243f, -0.04628093f, 
    -0.16654882f, -0.11137452f, 0.15330505f, 0.16479291f, 0.26656070f, -0.08322040f, 0.13558006f, -0.00261824f, 
    -0.14483559f, 0.16936123f, -0.00129618f, 0.03169348f, 0.02608139f, -0.08013018f, 0.05495084f, -0.12613147f, 
    -0.06628441f, 0.07880549f, -0.08547989f, 0.00393528f, 0.08530202f, 0.04754149f, -0.08855986f, -0.01162050f, 
    0.07286698f, 0.16595612f, 0.03475117f, -0.00533486f, 0.09632486f, 0.06350243f, -0.03208989f, 0.21799609f, 
    0.00690566f, 0.03996973f, -0.04074738f, 0.14562690f, -0.39752379f, -0.00123539f, -0.04288355f, -0.14835867f, 
    0.20606537f, -0.02180381f, 0.12465695f, -0.01323237f, 0.06645191f, -0.05009856f, -0.01240145f, -0.03202310f, 
    0.05582760f, -0.03306280f, 0.16893114f, 0.03330557f, -0.05292414f, 0.03330871f, 0.01697062f, 0.09494690f, 
    0.07108322f, 0.03523050f, -0.04932360f, -0.06296746f, 0.00581715f, -0.13514818f, 0.01343024f, -0.18433645f, 
    0.05872145f, -0.05387581f, -0.08415196f, -0.20978437f, 0.14770576f, -0.17809464f, 0.07734853f, -0.03125578f, 
    0.09807021f, -0.09657676f, 0.08993351f, -0.06844357f, -0.26713625f, -0.05571563f, -0.13387316f, -0.10250648f, 
    -0.13078241f, -0.21563236f, 0.32198730f, 0.36957678f, 0.07570186f, 0.00367456f, 0.00812684f, 0.05865688f, 
    -0.29266456f, -0.05750683f, -0.14368631f, -0.01506765f, 0.17081186f, 0.03286621f, 0.07646894f, -0.10992853f, 
    -0.08531659f, -0.01120427f, -0.11482757f, -0.04901449f, -0.06105581f, -0.02342411f, 0.04288600f, -0.02458744f, 
    -0.00849249f, -0.02058731f, 0.09282979f, 0.01854605f, -0.03920552f, 0.02404457f, 0.12620255f, -0.13713667f, 
    -0.05183300f, 0.02526926f, 0.05689445f, -0.05023488f, -0.11712138f, -0.07783552f, -0.05050477f, -0.09097021f, 
    -0.68730891f, -0.31622055f, 0.07017893f, -0.37268150f, -0.00520625f, -0.00855381f, 0.17112395f, -0.31669089f, 
    0.12756924f, 0.03953901f, -0.06484931f, -0.06593009f, -0.09685616f, 0.16633114f, -0.08750025f, -0.05422841f, 
    0.09574367f, -0.02473738f, -0.01198883f, -0.04653001f, 0.12870163f, 0.03800241f, -0.22932960f, 0.10700836f, 
    0.02747302f, -0.07910383f, 0.05054219f, -0.04248133f, 0.06112545f, 0.03659235f, 0.02838355f, -0.05618510f, 
    -0.01344379f, 0.04591752f, 0.00901216f, 0.09717779f, 0.40064573f, 0.02720880f, 0.30908975f, 0.38090959f, 
    -0.03944012f, 0.06295069f, 0.21209593f, 0.17015120f, 0.18724997f, -0.02963441f, 0.04274726f, 0.12528840f, 
    0.13955972f, 0.12862760f, -0.10697994f, -0.02576765f, -0.03562070f, -0.03287836f, 0.01934695f, -0.02803207f, 
    -0.08284499f, -0.12981598f, -0.06779770f, -0.21781136f, 0.18817925f, 0.11257428f, 0.36167058f, 0.09297408f, 
    0.01813172f, -0.23892178f, 0.02751166f, -0.06887577f, 0.00835176f, -0.03754233f, 0.03225512f, -0.01318001f, 
    0.04788697f, 0.07030771f, 0.01658942f, 0.01940522f, -0.01714289f, -0.11950807f, 0.01230965f, -0.17140082f, 
    -0.21001208f, -0.08287750f, 0.11424138f, -0.01291275f, 0.03469420f, -0.05945191f, 0.06559128f, -0.06181542f, 
    -0.08227321f, -0.11462946f, -0.00734015f, 0.02928246f, 0.01770529f, 0.08729249f, 0.04168563f, 0.07539881f, 
    0.18410634f, -0.02393225f, 0.10108629f, 0.04801986f, 0.12689693f, -0.00918000f, -0.07440001f, 0.06147825f, 
    -0.15712164f, 0.03104988f, -0.02891511f, -0.00251825f, -0.08291920f, -0.03227897f, 0.10685329f, -0.16300580f, 
    -0.25262651f, -0.21704702f, -0.01959279f, 0.18632580f, 0.04851161f, -0.11824203f, -0.05339390f, -0.02300835f, 
    0.03894068f, -0.17481609f, 0.20146570f, -0.23402625f, 0.06980769f, 0.01663982f, -0.00861456f, -0.01286771f, 
    0.03563512f, -0.24996535f, 0.13267581f, 0.05995878f, 0.01619602f, -0.11462656f, -0.01474086f, -0.01499932f, 
    -0.08552318f, -0.23660418f, -0.09850301f, 0.03563808f, 0.13720787f, -0.24204928f, -0.11729034f, -0.52410036f, 
    0.18938680f, 0.07382386f, 0.06375194f, 0.12637281f, 0.09589058f, -0.07237289f, 0.01750117f, 0.04071889f, 
    0.05693729f, -0.05228596f, 0.10139070f, -0.28137618f, -0.07524933f, -0.15240383f, -0.03756693f, 0.01024514f, 
    0.11118688f, -0.11809375f, 0.13050807f, -0.01117305f, 0.09235368f, -0.00056208f, 0.04394626f, 0.02339882f, 
    -0.21081516f, -0.30683735f, -0.01238101f, -0.03601738f, -0.02556040f, -0.02366486f, -0.04932245f, -0.03827206f, 
    -0.05844166f, -0.08072444f, -0.01552382f, -0.17178443f, 0.00182443f, -0.05733493f, -0.13427661f, -0.14471130f, 
    0.01199641f, 0.16514657f, 0.03738494f, 0.05612977f, -0.04235955f, 0.02718686f, 0.06542049f, 0.02703320f, 
    0.03375182f, -0.23918101f, 0.01380629f, 0.00206281f, -0.28106448f, -0.07922326f, -0.11565717f, -0.02412507f, 
    -0.05366462f, -0.06034162f, -0.21181250f, -0.03763987f, 0.15156931f, 0.01393768f, 0.08760970f, -0.01133216f, 
    0.01315047f, 0.00446304f, 0.09540888f, -0.07519787f, -0.02376480f, -0.00627649f, 0.06422758f, -0.12008033f, 
    -0.10099424f, 0.05246153f, -0.05381199f, -0.03985468f, -0.03056382f, 0.14128554f, 0.15521446f, 0.19720425f, 
    0.08043113f, 0.02193561f, 0.15696830f, 0.05633214f, 0.14931190f, 0.29065832f, -0.03846311f, -0.02306230f, 
    0.01891053f, -0.02245099f, -0.10000404f, -0.01222011f, 0.03120116f, -0.06819983f, 0.02708474f, 0.18786334f, 
    0.04987489f, -0.31887847f, 0.01546087f, 0.09254793f, -0.01742168f, -0.25844353f, -0.19785690f, 0.01059422f, 
    -0.31865555f, -0.00905412f, -0.21083625f, 0.08768022f, 0.05388501f, 0.00581983f, -0.00048966f, -0.00358448f, 
    -0.05962306f, 0.05956599f, -0.06508493f, 0.05833117f, 0.32961148f, -0.11805113f, 0.19362721f, 0.05528920f, 
    0.03851297f, -0.17712855f, -0.06144148f, -0.12281097f, -0.02146633f, 0.04418817f, 0.08607685f, -0.02608106f, 
    0.03036594f, 0.02766618f, 0.09235694f, 0.06891974f, 0.03427570f, 0.04383553f, -0.02930847f, -0.07214629f, 
    -0.30711582f, -0.29558474f, -0.01238427f, -0.30952257f, -0.14753020f, 0.06010681f, 0.13673118f, -0.13294600f, 
    0.11955278f, -0.04629445f, -0.08125150f, -0.06288740f, -0.08537546f, 0.05515503f, -0.13093801f, -0.03422783f, 
    0.03913515f, -0.09338804f, 0.02727002f, -0.05189614f, 0.13335687f, 0.09192371f, 0.04113220f, -0.07834122f, 
    0.00532437f, 0.10905238f, 0.07576070f, 0.06617381f, 0.08197085f, 0.09734614f, 0.10850591f, -0.05940328f, 
    0.02580149f, -0.04210061f, 0.10579433f, 0.25522032f, 0.05891145f, 0.01211412f, -0.08616509f, 0.06065909f, 
    0.07078513f, -0.54504621f, 0.18568939f, -0.03103231f, -0.09569319f, -0.14160433f, -0.15728155f, -0.00998908f, 
    0.05668707f, 0.30196694f, 0.08859579f, 0.03234340f, -0.16684355f, -0.07122471f, -0.15266477f, 0.02665784f, 
    0.08521268f, 0.06941216f, -0.03009841f, 0.07024485f, -0.05415255f, 0.12075460f, 0.27976549f, 0.09292120f, 
    0.07592187f, -0.15899527f, 0.11085370f, -0.04243447f, 0.05867665f, 0.08855239f, -0.01447841f, -0.02563272f, 
    -0.02206323f, 0.11869110f, -0.00062366f, -0.01620282f, 0.05351563f, -0.18314604f, -0.07842254f, 0.11203972f, 
    0.10985572f, 0.20243822f, -0.00545414f, -0.06844047f, -0.05364248f, 0.07620121f, 0.06604276f, 0.06516581f, 
    0.07665507f, 0.11597019f, 0.11142210f, 0.10111631f, 0.01130767f, -0.08084714f, 0.11733373f, -0.10747551f, 
    0.05950245f, 0.05729320f, -0.16193679f, 0.11258786f, 0.39971226f, -0.35711676f, 0.10708557f, 0.17489064f, 
    -0.22757699f, -0.22351494f, -0.18986988f, -0.24122624f, 0.20888516f, -0.07157699f, 0.12127056f, -0.06657533f, 
    -0.17522825f, -0.03417482f, 0.06914935f, 0.08432507f, -0.00663486f, 0.00808839f, -0.04343442f, -0.05223585f, 
    -0.24015301f, -0.17839232f, -0.00405065f, 0.10541892f, 0.12404954f, -0.15858755f, 0.00600551f, -0.11978777f, 
    -0.28562751f, -0.14868504f, -0.03120354f, 0.09019442f, -0.00906722f, 0.06434448f, -0.04810232f, -0.01754986f, 
    0.04175204f, 0.10204113f, 0.00538648f, 0.18788774f, 0.18683116f, 0.25901085f, 0.31736347f, 0.27940392f, 
    0.18424149f, -0.13339715f, -0.03405525f, 0.02651411f, -0.09787623f, 0.24830814f, 0.10555103f, 0.02306422f, 
    0.05757268f, 0.01899428f, 0.03676192f, 0.02588735f, -0.02062876f, -0.10345894f, -0.00529272f, -0.15471405f, 
    0.09927470f, -0.02299753f, -0.35713285f, -0.11623061f, 0.09280816f, -0.01243032f, 0.02134624f, 0.03517650f, 
    -0.15709770f, -0.03986071f, 0.18057987f, -0.21053913f, 0.03356283f, 0.14633521f, -0.20166503f, 0.09797903f, 
    -0.06268996f, 0.37422493f, -0.00760256f, -0.08069444f, -0.41548470f, -0.12886684f, -0.15984379f, 0.36418563f, 
    -0.19998957f, 0.02017576f, 0.09038004f, 0.09613032f, 0.10144167f, 0.24323547f, -0.09265328f, 0.02162378f, 
    0.01105888f, -0.02491789f, 0.00378575f, 0.09118477f, -0.10641261f, 0.20201175f, -0.18189095f, 0.03739398f, 
    0.26006070f, 0.15170647f, 0.14250229f, -0.23755258f, 0.07692470f, -0.08521660f, 0.05388577f, -0.05418982f, 
    0.02753181f, -0.10005922f, -0.16648969f, -0.05942132f, -0.03602535f, -0.06880307f, -0.01227060f, 0.05524217f, 
    0.09726523f, -0.00917609f, 0.08062364f, 0.18591283f, 0.06479535f, -0.02906189f, -0.19048680f, -0.05756855f, 
    0.08306934f, 0.10164135f, 0.05816374f, 0.01852535f, -0.04270633f, 0.04981558f, 0.02677511f, -0.10536906f, 
    -0.13646893f, -0.14836892f, -0.04360851f, -0.05743263f, -0.00876796f, 0.03969761f, -0.14836702f, 0.01202103f, 
    -0.17026713f, 0.19900650f, -0.16917066f, 0.20265940f, -0.29560629f, 0.02862665f, -0.07747093f, 0.16714828f, 
    -0.06928480f, -0.02057188f, 0.01642919f, -0.09850875f, -0.03979297f, 0.09979583f, -0.02862375f, -0.06629007f, 
    -0.09256912f, 0.06114111f, -0.05192961f, -0.03373871f, 0.10758879f, -0.11442980f, -0.06183548f, 0.14651367f, 
    0.09255140f, -0.27095234f, 0.06829299f, -0.19639829f, -0.05179891f, -0.00283098f, 0.09027414f, -0.06606191f, 
    0.20027961f, 0.05116804f, -0.00643710f, 0.19022743f, 0.00189849f, -0.06831346f, 0.08219182f, 0.15375260f, 
    0.03308228f, 0.00127961f, -0.08571112f, -0.00154747f, -0.06477034f, 0.05110036f, -0.01755872f, -0.00879320f, 
    0.04101750f, 0.12855414f, -0.06876147f, -0.07271633f, -0.04747920f, -0.00812499f, -0.11110865f, -0.00551714f, 
    0.01489323f, 0.07030438f, -0.05079746f, 0.09072596f, -0.16310658f, 0.16910654f, -0.14559285f, 0.26017162f, 
    -0.13140461f, 0.15284155f, -0.11902870f, -0.13837448f, 0.03462939f, 0.26530123f, -0.08318286f, 0.00470083f, 
    -0.09569044f, 0.02117126f, -0.13716307f, 0.18873717f, 0.06644798f, 0.05283245f, 0.01042959f, 0.20375049f, 
    -0.02149721f, -0.74376851f, 0.37617785f, 0.33529529f, -0.75655645f, 0.33578521f, 0.00339284f, 0.12127122f, 
    0.10133576f, -0.00653687f, 0.02427721f, -0.04138488f, -0.05046178f, 0.06476367f, 0.17027228f, -0.02296616f, 
    0.06618982f, 0.06917893f, 0.14687197f, 0.15102270f, -0.02336105f, -0.16084833f, -0.10413442f, 0.06233322f, 
    0.07882210f, 0.17510650f, -0.20970061f, -0.07416842f, 0.05835592f, 0.02237280f, -0.25982508f, 0.12299026f, 
    0.02950791f, 0.06682322f, -0.02267326f, -0.02091524f, 0.14152172f, -0.03422621f, -0.06850377f, 0.20450470f, 
    -0.30742782f, -0.14494795f, -0.34841311f, -0.21388426f, 0.10683486f, -0.11482067f, -0.08805332f, 0.01521850f, 
    -0.04668770f, -0.02034860f, -0.06789317f, 0.17520685f, 0.10445643f, -0.11439353f, 0.13387132f, -0.09637953f, 
    -0.07638559f, 0.10150635f, -0.06989319f, 0.10376685f, 0.02224072f, -0.06029456f, 0.18901412f, 0.28288558f, 
    -0.26350921f, 0.15692104f, 0.01967683f, -0.04715827f, -0.06337935f, 0.08268093f, 0.05801747f, 0.08394980f, 
    0.03470845f, 0.00553402f, -0.03551766f, -0.21970569f, -0.14631015f, 0.02746051f, -0.25375330f, -0.27046910f, 
    0.23049638f, -0.11247416f, 0.31174004f, -0.06459337f, -0.17993423f, -0.08331990f, 0.09575005f, -0.05170876f, 
    -0.10081931f, 0.01546579f, 0.11333435f, 0.01125544f, 0.03841866f, -0.00886484f, 0.00948340f, 0.03508309f, 
    0.07167083f, -0.09371722f, 0.01120475f, 0.23381081f, -0.15276195f, 0.01048301f, 0.30374327f, -0.18123102f, 
    -0.07879292f, 0.30432793f, 0.00684824f, -0.15555017f, -0.20612046f, 0.07697511f, 0.10550375f, 0.04601927f, 
    -0.01810384f, 0.01153512f, 0.01014102f, 0.08431047f, -0.04357543f, -0.11858592f, 0.05757846f, 0.17053284f, 
    -0.10903537f, 0.09486199f, 0.14873934f, -0.00180677f, -0.13250165f, 0.04008112f, -0.07875620f, -0.01265799f, 
    0.05094941f, -0.00042937f, 0.10295417f, 0.04754660f, -0.01022393f, 0.04580491f, -0.03907857f, 0.04363257f, 
    -0.08098972f, -0.19263181f, -0.20998921f, -0.19143212f, -0.34371057f, -0.01187023f, -0.17808738f, -0.15941927f, 
    0.22698882f, 0.05250660f, 0.21070850f, -0.08036352f, -0.15296951f, 0.08136977f, 0.07978207f, -0.08677936f, 
    0.13629375f, 0.04530298f, 0.08924117f, -0.06796984f, 0.02004148f, -0.10935798f, 0.22735798f, -0.01390166f, 
    0.38778907f, -0.18698217f, 0.08834924f, 0.18082276f, -0.14153451f, 0.23780699f, -0.03540340f, 0.09190729f, 
    -0.07647195f, 0.01344694f, 0.17775133f, -0.06230237f, 0.10923176f, -0.12198888f, 0.14583686f, -0.02988863f, 
    -0.03774675f, 0.02953173f, 0.20594940f, -0.10707373f, -0.02381469f, -0.45200658f, 0.18755755f, -0.41969150f, 
    0.09056216f, 0.12608393f, 0.06493841f, -0.07800400f, 0.04655436f, 0.04080702f, 0.10456584f, 0.00641070f, 
    -0.07354444f, -0.05315664f, 0.11558327f, 0.11930346f, -0.18866493f, 0.01700949f, 0.12894404f, 0.11750918f, 
    0.17184918f, 0.06698073f, 0.31739333f, -0.10889704f, -0.04845021f, 0.04048749f, 0.03273156f, -0.08982623f, 
    -0.00964462f, 0.02511052f, 0.03256220f, 0.03323477f, -0.07963610f, -0.03544785f, -0.02852137f, -0.06106537f, 
    0.02282373f, 0.00338552f, 0.08553512f, 0.04530823f, -0.06182411f, -0.23387372f, -0.17762052f, 0.21263282f, 
    -0.02958796f, 0.07137311f, -0.01126335f, -0.14134188f, 0.03138954f, 0.07921667f, 0.02090796f, -0.04373797f, 
    0.15422483f, -0.14781603f, 0.09404839f, 0.21523614f, 0.06774571f, -0.04075164f, -0.04968215f, 0.04688806f, 
    -0.07960574f, -0.18714112f, -0.27436030f, 0.15415202f, 0.02112153f, 0.07766189f, 0.01863513f, -0.02156036f, 
    0.01000498f, 0.09570713f, -0.01851252f, -0.00438656f, 0.03346743f, -0.06751735f, 0.06159980f, 0.02286890f, 
    -0.11525379f, 0.12898692f, -0.12766707f, 0.08324389f, 0.28989616f, 0.23224004f, 0.26165017f, -0.13168040f, 
    0.15340354f, -0.15570515f, -0.14881438f, 0.09972420f, 0.00910898f, -0.14322215f, 0.10115745f, 0.02635864f, 
    0.00909118f, -0.00622232f, -0.04608057f, 0.09135370f, -0.03040517f, 0.13260564f, -0.11082642f, -0.09421180f, 
    -0.24761444f, -0.15988044f, -0.09643701f, -0.06839713f, -0.46501133f, -0.01016328f, 0.07365676f, 0.03215063f, 
    -0.06841785f, 0.00363031f, 0.07070871f, 0.06363881f, -0.18405943f, -0.05471195f, 0.08792943f, 0.03022621f, 
    -0.00855381f, -0.05455573f, 0.07340984f, 0.05230139f, -0.63623691f, 0.09849261f, -0.33616024f, -0.33417276f, 
    -0.17080253f, 0.05638594f, 0.00649823f, -0.06343498f, -0.03605802f, 0.25796348f, -0.03235079f, 0.16274561f, 
    -0.11386754f, 0.00814998f, -0.16331665f, -0.03912179f, -0.04814012f, -0.01193585f, -0.04223435f, 0.10372695f, 
    0.00077545f, -0.14741656f, -0.10658944f, -0.25488299f, 0.18621050f, -0.09772530f, 0.03231822f, -0.01976733f, 
    -0.02841899f, -0.11406269f, -0.04494812f, 0.05692302f, -0.10873986f, -0.08323918f, 0.10710160f, -0.04319098f, 
    0.00892077f, 0.09906518f, -0.01974503f, -0.07434997f, 0.02905348f, -0.06092367f, -0.16979414f, -0.08328519f, 
    0.07960886f, -0.05453591f, 0.09700239f, -0.07243697f, -0.08308277f, -0.04286279f, 0.24430265f, 0.07602043f, 
    0.17935500f, -0.02544592f, -0.06960408f, -0.03862923f, 0.02401870f, 0.14179467f, 0.06530897f, 0.07344826f, 
    -0.77278590f, 0.83160388f, -0.92314696f, -0.26057053f, -0.05108447f, -0.08853935f, 0.04057878f, -0.02885045f, 
    -0.12741810f, -0.19078548f, 0.03527472f, 0.00004764f, -0.12485944f, 0.12320265f, 0.00557107f, -0.18769588f, 
    -0.01816043f, 0.23105097f, -0.12539706f, -0.09081276f, 0.14623629f, 0.01068383f, 0.30275989f, 0.19405888f, 
    -0.16298291f, 0.16661300f, 0.03513809f, 0.04453577f, 0.11700174f, -0.07151324f, 0.02416436f, -0.00910183f, 
    0.02088347f, 0.13073131f, 0.02239802f, -0.03223662f, 0.01940570f, -0.11038362f, -0.05206989f, -0.06614873f, 
    -0.05739816f, -0.22413303f, 0.01307242f, 0.10669217f, 0.11466456f, 0.03384053f, 0.06849869f, -0.09011444f, 
    -0.00668834f, 0.03778345f, -0.02728600f, -0.11375388f, -0.03928868f, -0.00270860f, 0.02894515f, -0.22798681f, 
    0.02745468f, 0.10467812f, 0.06684811f, 0.00879742f, -0.29108274f, 0.23501034f, -0.02306615f, -0.11322398f, 
    0.11224657f, 0.05949256f, -0.00629367f, 0.04414098f, -0.05485547f, 0.26195192f, 0.04344570f, -0.03973572f, 
    0.05899059f, -0.02190530f, 0.02960374f, -0.04359638f, -0.01451518f, -0.06791596f, 0.16415778f, 0.20225577f, 
    -0.48675397f, 0.25282875f, -0.11678128f, 0.11731051f, -0.20655067f, -0.03419876f, -0.05939312f, 0.07126039f, 
    -0.05720880f, -0.01336341f, 0.00389487f, -0.08411051f, -0.08645094f, -0.01077101f, -0.04530891f, -0.26872632f, 
    -0.09726267f, 0.06393085f, -0.06151641f, -0.26662874f, 0.12056135f, -0.14973822f, 0.28115684f, -0.09009120f, 
    -0.33982795f, 0.16353293f, 0.11124142f, 0.09026191f, -0.17001057f, -0.20151490f, -0.01252081f, -0.02974567f, 
    -0.05176335f, -0.00128356f, 0.03538303f, -0.00643189f, 0.10247338f, 0.02648706f, 0.04309975f, 0.13968381f, 
    0.06330553f, -0.04336803f, 0.28781867f, 0.06231700f, -0.05539230f, 0.04395514f, -0.00391035f, 0.05745570f, 
    0.04354738f, -0.08078543f, -0.09493192f, 0.13322017f, 0.29372889f, 0.03163697f, 0.10388500f, -0.01274121f, 
    -0.05028613f, 0.12541442f, -0.23396680f, -0.04767793f, 0.14386450f, -0.35504928f, -0.65339363f, -0.17573689f, 
    0.24106281f, -0.07271657f, 0.22849469f, 0.28231865f, 0.15552984f, 0.00024979f, -0.05069908f, -0.02715675f, 
    -0.08252446f, 0.02611704f, 0.05950669f, -0.01073845f, 0.12579282f, -0.11720732f, 0.22927983f, -0.00158844f, 
    0.17631088f, 0.13833004f, -0.25413856f, -0.08885728f, -0.01730325f, 0.00928906f, -0.03016031f, -0.11924405f, 
    -0.02082071f, -0.46936223f, 0.09759649f, 0.02414780f, -0.14812675f, -0.04996810f, 0.06322236f, -0.02648478f, 
    -0.04631788f, 0.14339082f, -0.20740983f, -0.16088587f, 0.31856516f, 0.12580806f, -0.18411049f, -0.19422635f, 
    -0.06711274f, 0.15488344f, 0.03114962f, 0.13009684f, -0.07253583f, 0.00521487f, 0.08649854f, -0.05004444f, 
    -0.06438646f, -0.02975977f, 0.06281175f, -0.08332755f, -0.07311676f, 0.13640085f, -0.20934287f, -0.05076407f, 
    -0.46584651f, -0.31891996f, 0.36592805f, -0.13614750f, 0.55154401f, -0.17208688f, 0.09259629f, 0.08260388f, 
    0.06264208f, 0.01423549f, 0.11542434f, 0.08039264f, 0.07379732f, -0.01872325f, 0.04075161f, 0.00023383f, 
    -0.02017039f, -0.05500309f, 0.10035254f, -0.05483715f, 0.03378164f, -0.10743583f, -0.08278954f, -0.01921855f, 
    -0.05536236f, 0.05984929f, 0.07122418f, 0.03183831f, 0.00009203f, 0.01457884f, 0.07094663f, -0.20568341f, 
    0.05734945f, 0.05228216f, -0.09728764f, -0.07483481f, 0.00608194f, -0.04806905f, -0.04247293f, -0.03254262f, 
    -0.29792246f, 0.37919670f, 0.24947305f, -0.00035061f, 0.06371434f, -0.15853909f, -0.04131179f, -0.15846249f, 
    -0.09049880f, 0.02967667f, -0.09158019f, 0.00613473f, 0.05955212f, 0.02784756f, 0.09662757f, 0.02201551f, 
    -0.07545269f, -0.09026729f, 0.00919823f, -0.02476083f, -0.26359299f, 0.29145801f, -0.04538712f, -0.23830435f, 
    0.27660692f, -0.11269435f, 0.08529425f, 0.06828990f, -0.03636954f, 0.29069063f, 0.06249678f, 0.10803416f, 
    0.00351750f, 0.03397625f, 0.02375348f, -0.02115968f, 0.00987095f, -0.02518225f, 0.09546760f, -0.09769060f, 
    -0.75036418f, -0.94632477f, -0.80057186f, -0.17054890f, 0.69115186f, 0.01535592f, 0.08622941f, -0.13583392f, 
    -0.37262273f, -0.07009447f, 0.01771168f, -0.00199429f, -0.02135890f, 0.01249152f, 0.06011824f, -0.02659464f, 
    0.13796589f, -0.03552561f, 0.25846162f, -0.00995805f, 0.15090999f, 0.06157899f, -0.07522022f, -0.04270250f, 
    0.07188073f, -0.05019405f, 0.00231148f, -0.01968345f, -0.05359021f, 0.17961645f, 0.08156114f, 0.08050340f, 
    -0.04628933f, -0.09946480f, 0.14250401f, -0.10543668f, 0.00480081f, -0.14714625f, 0.00811341f, -0.05459335f, 
    -0.46402067f, 0.47310796f, -0.01080340f, -0.10874631f, 0.48081055f, -0.12876482f, -0.02820239f, -0.05800627f, 
    0.06482303f, -0.06516830f, 0.14761907f, 0.13193543f, 0.23116080f, -0.03586252f, -0.07947362f, 0.04408848f, 
    0.02215934f, 0.05200297f, 0.07780157f, -0.01666187f, -0.33642453f, 0.04752102f, -0.60864002f, -0.19705002f, 
    0.06373420f, -0.11243998f, 0.16702801f, 0.15832959f, 0.01328796f, 0.06727603f, -0.03798540f, -0.06826442f, 
    -0.01460606f, 0.09168698f, 0.05660719f, 0.06855375f, 0.02809127f, -0.05880556f, 0.12580888f, 0.04532361f, 
    -0.53281695f, -1.12922454f, -0.72121620f, -0.06154934f, 0.23726882f, -0.00756138f, 0.13472772f, -0.06189626f, 
    -0.08207308f, -0.37518376f, 0.09382094f, -0.04037558f, -0.07129431f, 0.04945993f, 0.06884705f, -0.01903835f, 
    0.00924199f, 0.11613974f, 0.19076279f, 0.11229014f, -0.74434549f, -0.58535379f, -0.25084081f, -0.05491566f, 
    -0.38192648f, 0.10854035f, -0.08607578f, -0.11774251f, -0.16334225f, -0.23090430f, -0.00892270f, -0.01802450f, 
    -0.02064249f, 0.06979416f, 0.00750402f, -0.01828166f, -0.03343716f, 0.13495687f, 0.03351253f, 0.01460680f, 
    -0.24435411f, -0.59622478f, -1.00104833f, -0.22576375f, 0.08413219f, 0.00416181f, -0.14206226f, -0.12726690f, 
    -0.11768252f, -0.08508446f, -0.01655963f, -0.02088288f, -0.02137844f, 0.00041582f, -0.11491469f, -0.09556844f, 
    -0.03582499f, 0.12027398f, 0.15104365f, 0.02428878f, 0.04053893f, 0.17215222f, 0.16891125f, 0.02369936f, 
    -0.13333610f, 0.05875281f, 0.03551767f, -0.03087791f, -0.09639005f, 0.12732624f, 0.06917096f, -0.07404300f, 
    0.15065821f, -0.06407259f, 0.18260336f, 0.02254623f, 0.11873104f, -0.09697882f, -0.02040832f, -0.01061580f, 
    0.03574358f, 0.06208350f, -0.06486522f, -0.08391231f, -0.06673243f, 0.04171628f, 0.04000850f, 0.18327953f, 
    0.00793909f, 0.12418029f, -0.03490616f, -0.00779815f, 0.08332326f, 0.06951989f, 0.01879794f, 0.00763852f, 
    -0.05359419f, -0.02458915f, 0.06334438f, -0.01706292f, 0.10175287f, 0.22240728f, 0.07456882f, -0.23515533f, 
    0.11661919f, 0.02277081f, -0.02709682f, 0.17031537f, 0.08269723f, 0.07588290f, 0.10062434f, -0.03639315f, 
    -0.00960396f, -0.01762201f, 0.09862337f, 0.09073536f, 0.05100000f, -0.06072165f, -0.14166893f, 0.20217219f, 
    -0.44274727f, 0.19770917f, 0.32304439f, 0.23780467f, -0.17516528f, -0.07727436f, 0.11864772f, -0.10146549f, 
    -0.12404132f, -0.22002289f, 0.04608432f, -0.07546346f, 0.01315322f, -0.08234008f, 0.02053464f, 0.01203316f, 
    0.02645068f, 0.07194319f, 0.01143063f, -0.14614356f, 0.10276553f, 0.10909330f, -0.12518334f, -0.22314559f, 
    0.04889435f, 0.01998457f, -0.07187387f, 0.16872200f, 0.10528247f, 0.10156760f, -0.02296530f, -0.04305299f, 
    -0.01169658f, -0.07764755f, -0.08462284f, -0.08204416f, 0.01502638f, -0.12318195f, -0.03180452f, -0.03375917f, 
    0.14676842f, -0.06584215f, -0.25981662f, -0.14658874f, 0.11759384f, -0.06673782f, 0.05201585f, 0.19773807f, 
    0.10870805f, 0.04608500f, -0.04220416f, -0.04457010f, -0.06757580f, -0.09999329f, 0.00918630f, -0.09005090f, 
    -0.03215402f, -0.11619487f, 0.02859540f, 0.00927964f, -0.32941684f, -0.50988507f, -0.97013164f, 0.01090589f, 
    -0.19636384f, -0.15674129f, 0.12016623f, -0.17723988f, 0.15579925f, -0.47724512f, 0.06778403f, -0.09038200f, 
    -0.05110717f, -0.14091344f, 0.08327196f, 0.00852139f, 0.00856721f, 0.18239672f, 0.11205035f, 0.11835683f, 
    -0.42722404f, 0.33916539f, 0.53663856f, -0.16675067f, 0.13642646f, -0.13158470f, -0.09666543f, -0.18061613f, 
    -0.08663592f, 0.19601455f, -0.15422806f, 0.12613527f, 0.04233715f, 0.03383600f, 0.01286728f, 0.02535231f, 
    0.05052334f, -0.05263036f, 0.10984052f, 0.07049219f, -0.79820812f, 0.61883372f, 0.75167686f, -0.17343335f, 
    0.25475246f, -0.12402181f, -0.13296498f, -0.01582088f, -0.19507112f, 0.20826454f, -0.08676922f, 0.12202340f, 
    -0.00361829f, 0.11528411f, 0.01905050f, 0.00922438f, -0.02799708f, -0.07540244f, -0.00292890f, -0.01742423f, 
    -0.18222953f, 0.25224525f, 0.08405013f, -0.05587895f, 0.16078153f, 0.09802520f, 0.01791445f, 0.03273899f, 
    0.06922650f, -0.03407190f, 0.11455229f, -0.00942220f, 0.15585110f, 0.06275231f, 0.08871588f, 0.11165201f, 
    0.12948042f, 0.01027747f, -0.02040663f, 0.00434059f, -0.08680058f, -0.07066826f, -0.02522028f, -0.13575973f, 
    -0.06865820f, 0.02305052f, -0.04099059f, -0.02387235f, -0.10970042f, -0.04045820f, -0.22578473f, -0.04712100f, 
    0.01306633f, 0.02396902f, 0.06410922f, -0.02359446f, -0.07968119f, -0.02098772f, -0.12037590f, -0.03866337f, 
    -0.24212785f, 0.05690800f, 0.40424272f, 0.03809774f, 0.24431276f, -0.03929532f, -0.12932013f, -0.01560743f, 
    0.06696006f, 0.24762094f, -0.06225321f, 0.12117471f, 0.07154319f, 0.06287872f, 0.01291304f, -0.02560111f, 
    0.03112569f, 0.03112397f, -0.01281423f, 0.01918307f, -0.74168009f, -0.57380068f, -1.01032448f, -0.22742796f, 
    0.40349722f, -0.08795871f, 0.11104999f, -0.07365489f, -0.22574498f, -0.42259464f, 0.02955603f, -0.05117938f, 
    -0.04622018f, -0.06857346f, 0.00246531f, -0.02704135f, 0.01748374f, 0.05489237f, 0.28079614f, 0.14149664f, 
    -0.15926796f, 0.06433520f, -0.03761028f, -0.28691429f, -0.00004462f, -0.06297187f, -0.01082605f, -0.01051660f, 
    -0.10374636f, -0.01761409f, -0.04863456f, -0.09646884f, -0.13352996f, -0.01692221f, -0.17898180f, 0.02047712f, 
    -0.03431368f, -0.12114867f, -0.03780175f, 0.08029868f, -0.09191449f, 0.23146698f, 0.15718432f, -0.02675072f, 
    0.16813880f, -0.03011077f, -0.16229898f, -0.03301383f, 0.07181176f, 0.15923806f, 0.17797349f, 0.02638191f, 
    -0.00871308f, 0.08248547f, -0.00516767f, -0.03823245f, 0.08852715f, -0.02079513f, 0.00708725f, 0.04651385f, 
    -0.19223818f, -0.55239731f, -0.55367905f, -0.21792109f, 0.26428613f, -0.13023365f, -0.03640468f, -0.05317770f, 
    0.00712503f, 0.02598402f, 0.02622365f, 0.00282056f, -0.00292021f, -0.00886573f, -0.18034030f, -0.02538230f, 
    0.02549366f, -0.04845559f, 0.15566355f, -0.02947059f, -0.89909208f, -0.62256318f, -0.13702261f, -0.49592978f, 
    -0.40564898f, -0.52617979f, -0.33872724f, -0.15368618f, -0.16822852f, -0.30702519f, -0.03021007f, 0.05498005f, 
    -0.03027646f, -0.04993831f, 0.06932714f, -0.00849532f, -0.05474719f, 0.04242218f, 0.13857289f, -0.31150934f, 
    -0.06202034f, 0.19274025f, 0.08395962f, 0.06897424f, 0.00717196f, 0.01156101f, -0.02551449f, -0.00777199f, 
    -0.00653198f, -0.02990622f, 0.12731783f, -0.19213672f, 0.12686409f, -0.10230236f, -0.12196033f, -0.02739591f, 
    0.00405615f, 0.07316366f, -0.09393039f, 0.02500152f, -0.06339447f, 0.17849496f, -0.38372666f, 0.16200346f, 
    -0.41863826f, 0.04954516f, 0.08666031f, -0.06528907f, -0.09008066f, 0.02403719f, 0.00600836f, 0.04343696f, 
    0.01306899f, 0.01455458f, -0.01746640f, -0.02584160f, -0.11149246f, 0.07052144f, -0.09023814f, -0.02672438f, 
    -0.48599118f, -0.30383199f, 0.26732683f, 0.21099320f, 0.16811746f, 0.00504120f, 0.06061380f, -0.02302619f, 
    -0.02264121f, 0.20656952f, 0.04760040f, -0.08192690f, -0.02152144f, 0.05755237f, 0.03737872f, 0.06718074f, 
    -0.02217163f, -0.16471553f, -0.03280258f, 0.01430160f, -0.05094144f, -0.04246354f, 0.07624869f, -0.01044965f, 
    0.00505857f, -0.00049811f, -0.08731879f, 0.03628375f, 0.04918278f, 0.01201531f, 0.04867382f, -0.02574736f, 
    0.02058391f, 0.04761669f, -0.04532690f, 0.13549544f, -0.00643668f, -0.11471370f, 0.06244660f, 0.00180352f, 
    0.68087727f, -0.50842053f, -0.44152096f, -0.48899230f, -0.32856375f, 0.19931147f, -0.11828785f, 0.01159318f, 
    0.07692935f, -0.09842911f, 0.03129686f, 0.02372289f, 0.07879405f, 0.01341652f, -0.05371496f, -0.07399794f, 
    -0.04639883f, 0.05910856f, -0.01875965f, -0.00633042f, -0.03707385f, 0.10763747f, 0.13108289f, -0.05046410f, 
    -0.04210970f, -0.05773661f, 0.01215715f, 0.00158739f, -0.04943321f, -0.04368680f, 0.00447739f, 0.02055130f, 
    0.04023939f, -0.07995459f, -0.08040106f, -0.13192463f, -0.04121627f, 0.09179788f, -0.07036154f, 0.06665856f, 
    0.16263242f, -0.01127535f, -0.22851990f, -0.14106011f, -0.13253614f, 0.05947434f, -0.08349267f, 0.05819245f, 
    -0.07461101f, -0.02267308f, -0.07785678f, 0.04986485f, 0.10736745f, 0.01292914f, 0.08134255f, -0.00468853f, 
    -0.03359937f, -0.01472683f, 0.01410713f, 0.01008728f, 0.85600621f, 0.19836973f, -0.26183379f, 0.01015012f, 
    -0.43229851f, 0.04821322f, -0.04568464f, 0.08301736f, -0.37629846f, -0.08809871f, -0.11758973f, -0.11434940f, 
    0.12264336f, 0.04375293f, -0.12206596f, 0.04600583f, -0.16839440f, 0.08886318f, -0.05615436f, -0.14587149f, 
    -0.11087410f, -0.73360616f, -0.47732678f, 0.54596245f, 0.44246009f, 0.05888091f, -0.31400317f, 0.12545162f, 
    0.03589620f, -0.07943285f, 0.10649249f, 0.07884701f, 0.02831391f, -0.11318874f, -0.06259079f, 0.02154563f, 
    -0.01719113f, 0.06051419f, 0.05595820f, 0.10569654f, 0.03949269f, 0.00656231f, -0.10989826f, 0.03746798f, 
    -0.12888770f, -0.00243744f, 0.02472833f, 0.03362593f, -0.02072727f, -0.05735144f, -0.17400311f, 0.04946453f, 
    -0.06145321f, 0.03039957f, -0.14774241f, -0.06164250f, -0.01168479f, 0.00025224f, -0.03088300f, -0.00213571f, 
    -0.48364824f, -0.29286078f, -0.30624908f, 0.09644376f, -0.13982908f, 0.09882635f, 0.02621045f, 0.33620676f, 
    -0.04966203f, 0.09860256f, -0.15950568f, 0.17607419f, -0.04352504f, 0.01900691f, -0.01746445f, -0.03284943f, 
    0.01874268f, 0.03390130f, 0.07727376f, 0.08891052f, -0.03085948f, 0.09660684f, 0.06470887f, 0.21387875f, 
    -0.03428146f, 0.09305087f, -0.00758988f, -0.23817946f, -0.12257527f, 0.02977145f, 0.02911766f, 0.00470909f, 
    -0.00810138f, 0.02176155f, 0.02979612f, 0.09041675f, 0.14702635f, -0.15411726f, -0.03871961f, 0.09317333f, 
    -0.56139982f, -0.60964519f, 0.40315235f, 0.34341416f, 0.08141374f, -0.01279946f, 0.01397294f, -0.07489064f, 
    0.00343762f, -0.02393223f, -0.00268274f, -0.01055526f, 0.01952137f, -0.00860183f, -0.02514229f, 0.01701539f, 
    0.01927149f, -0.16210876f, -0.03036628f, -0.10296274f, 0.15174933f, -0.41125467f, 0.83730787f, -0.22657754f, 
    0.07419064f, -0.20271137f, 0.34711033f, -0.06570844f, 0.31580737f, 0.01920844f, 0.01338298f, -0.00719484f, 
    -0.03339458f, -0.04605957f, -0.01371689f, -0.00045704f, -0.02387032f, -0.07274751f, -0.00466274f, 0.04571846f, 
    0.00957954f, -0.43630570f, -0.08420313f, -0.39985293f, -0.14904475f, -0.01868405f, 0.09032466f, -0.11001413f, 
    0.14263977f, 0.06796158f, -0.00131631f, 0.01604064f, -0.03922611f, -0.04788479f, 0.00312113f, 0.08303569f, 
    0.16505101f, -0.01244798f, 0.13137032f, -0.09474961f, -0.07039542f, 0.01606957f, 0.09464689f, -0.24855652f, 
    0.06045733f, 0.04823694f, 0.04872835f, 0.09125141f, -0.07058725f, 0.07919945f, -0.01832379f, -0.09065304f, 
    -0.03172903f, -0.02994765f, -0.02909413f, 0.00673134f, -0.08343124f, -0.01214238f, 0.05501460f, -0.03630838f, 
    -0.01278833f, -0.10038095f, 0.05418193f, -0.07068330f, 0.05428293f, -0.00640888f, -0.11476509f, 0.00938158f, 
    0.01175529f, 0.00456545f, 0.08370917f, -0.00192593f, -0.04342826f, -0.00601293f, 0.00288709f, -0.01178722f, 
    0.02183656f, -0.09466226f, 0.03045999f, -0.03039507f, 0.04046087f, -0.05315327f, 0.10156286f, 0.05779137f, 
    0.10076727f, 0.01834282f, 0.07291597f, 0.07745656f, -0.09524816f, -0.02736503f, 0.06017402f, -0.02377328f, 
    0.05948101f, 0.06146482f, -0.05832947f, -0.02357488f, -0.13070613f, -0.23074886f, 0.00495661f, -0.01365821f, 
    -0.35222161f, -0.64297867f, -0.08782128f, -0.03162275f, 0.25862834f, 0.02023810f, 0.01684428f, 0.07525872f, 
    0.02145690f, -0.01951517f, -0.10986049f, 0.02709852f, 0.13164873f, 0.00122689f, 0.04898150f, -0.04558700f, 
    0.01649045f, 0.02401877f, -0.00122612f, -0.11272689f, -0.02103540f, 0.11487075f, -0.10490441f, 0.03794047f, 
    -0.18729265f, 0.00220629f, -0.06725091f, 0.02195817f, -0.04190107f, -0.04895315f, 0.03895808f, 0.07244220f, 
    -0.01664327f, -0.03949789f, -0.09701899f, -0.08281123f, -0.18601675f, 0.08066101f, -0.01885889f, 0.04473512f, 
    -0.03747793f, 0.11893571f, -0.12216970f, 0.08164901f, -0.17266296f, 0.00096077f, 0.02474032f, -0.09810727f, 
    -0.06638389f, -0.08504381f, 0.03221913f, 0.06422383f, -0.00196563f, 0.03638429f, -0.01199375f, -0.14396679f, 
    -0.14821775f, 0.09464017f, 0.01628569f, 0.01955535f, -0.33581248f, -0.36496794f, -0.05642082f, 0.34027508f, 
    0.00798425f, -0.05206351f, 0.21598849f, -0.01285195f, 0.01186406f, 0.20837274f, 0.00646615f, -0.05801848f, 
    -0.07149723f, -0.11024091f, -0.07393812f, -0.08214345f, -0.00800458f, -0.20504014f, 0.02368028f, -0.22193442f, 
    0.50779170f, -0.34236157f, -0.35564470f, -0.45025077f, -0.02149497f, -0.07759435f, 0.02581798f, -0.42031243f, 
    0.19606113f, -0.16573311f, 0.12425308f, 0.05618000f, -0.00634645f, -0.02880700f, 0.14454819f, -0.01582071f, 
    0.08464560f, -0.04804106f, 0.04830778f, -0.06004097f, 0.58524162f, -0.60095555f, -0.25997505f, -0.10495036f, 
    -0.22898677f, -0.03335606f, -0.14524314f, -0.03552871f, 0.09045871f, -0.27173367f, 0.04055957f, -0.00995255f, 
    0.02216198f, 0.11338466f, 0.07622495f, 0.00002217f, 0.01439918f, -0.02380422f, 0.04526215f, 0.07029352f, 
    -0.21250923f, -0.17585877f, 0.06508487f, -0.08848493f, 0.09468308f, 0.04268315f, -0.00754203f, 0.20742179f, 
    -0.04973526f, -0.03648870f, -0.12271096f, 0.10652945f, -0.05885800f, -0.00662133f, -0.11360847f, -0.01233349f, 
    -0.00452805f, -0.05465201f, 0.13097088f, 0.07056870f, -0.03928230f, 0.09817871f, 0.13097830f, -0.08758652f, 
    -0.02047867f, 0.00331882f, 0.01050968f, 0.05079865f, -0.02907955f, 0.01447916f, -0.05932086f, -0.28307018f, 
    -0.12094294f, -0.18595137f, -0.29582950f, 0.02482054f, 0.04884262f, 0.03718430f, 0.06846530f, -0.02184750f, 
    0.64048582f, 0.10330378f, -0.24015349f, -0.22244175f, -0.16262758f, 0.08814289f, 0.05715658f, 0.00052831f, 
    0.08139686f, 0.01726149f, 0.14033292f, 0.01939152f, 0.02690409f, -0.13747491f, -0.19656143f, 0.05764870f, 
    0.02610617f, -0.13547908f, 0.13516118f, 0.11229939f, -0.44813728f, -0.59954470f, -0.35942659f, 0.40297344f, 
    0.08274845f, 0.01869692f, 0.12759508f, -0.04380416f, 0.11493932f, 0.19597419f, -0.01992661f, -0.04013144f, 
    -0.10206083f, -0.09462466f, -0.06468108f, -0.05698014f, 0.06838352f, -0.09058903f, 0.21493474f, -0.06267976f, 
    -0.00608665f, 0.16802908f, -0.10542138f, 0.10068541f, -0.25721598f, 0.04315726f, 0.05132040f, 0.09247737f, 
    -0.05108851f, -0.03802237f, 0.08186661f, 0.00925056f, 0.08043408f, 0.03238728f, -0.02139858f, -0.26269078f, 
    -0.13453786f, 0.11381885f, -0.00512299f, 0.08128068f, 0.63274169f, -0.05984922f, -0.00359960f, -0.14025396f, 
    -0.04443561f, -0.13643698f, 0.00796646f, 0.09921335f, -0.04215405f, -0.18929695f, 0.12907425f, -0.07694511f, 
    -0.05528500f, 0.02923224f, -0.02010701f, -0.04892237f, -0.04805082f, 0.03492026f, -0.00401967f, -0.00830652f, 
    0.46314171f, -0.71773034f, -0.59050882f, -0.50068641f, -0.29745108f, -0.02760833f, -0.01431611f, -0.20085475f, 
    0.18118432f, -0.01384202f, 0.02673938f, 0.06414733f, -0.04437189f, 0.02492213f, 0.05350823f, -0.08591378f, 
    -0.02008717f, 0.00150906f, 0.06936953f, 0.03967408f, 0.39802077f, -0.68043000f, -0.47245491f, -0.01789393f, 
    0.06656726f, 0.08126633f, -0.03244449f, 0.03221373f, 0.08776883f, 0.26213872f, 0.00221060f, 0.06540425f, 
    0.07844621f, 0.03430313f, -0.00186564f, 0.05833031f, 0.04060638f, -0.01309168f, -0.10421594f, -0.08629638f, 
    -0.32607719f, -0.03934750f, 0.08058614f, 0.04975611f, -0.17198768f, -0.09579505f, 0.06166787f, -0.00055770f, 
    0.00875410f, -0.06902582f, -0.09938842f, 0.18345965f, 0.08304108f, 0.09879306f, 0.13842687f, -0.00978453f, 
    0.05496932f, -0.03106363f, 0.14172685f, 0.07795303f, 0.33551869f, 0.23169689f, 0.12524329f, 0.07425894f, 
    -0.18738024f, 0.16297619f, -0.05811083f, 0.16756001f, 0.04754876f, -0.25927526f, -0.04852951f, -0.01570789f, 
    0.05163209f, 0.02743263f, -0.01902195f, 0.01447743f, -0.03020556f, -0.05164737f, 0.10849725f, 0.10994279f, 
    0.15320908f, -0.37437603f, -0.15414999f, 0.18154117f, -0.05731810f, -0.00531650f, -0.17131416f, -0.12943219f, 
    -0.01015898f, -0.05958336f, -0.05905172f, 0.12991914f, 0.02794318f, -0.06945637f, 0.01076132f, -0.08665211f, 
    0.13033697f, 0.27015659f, 0.10758253f, 0.25776872f, -0.08266843f, -0.13687459f, -0.04279123f, 0.05603968f, 
    -0.08611988f, 0.01475082f, -0.11090863f, -0.15221402f, -0.03894564f, -0.00389351f, -0.00476954f, -0.01870497f, 
    0.01693648f, 0.08722878f, 0.06250990f, -0.06033317f, 0.13351214f, 0.09396487f, 0.15363878f, 0.19409759f, 
    -0.24252078f, -0.52159816f, -0.53008062f, -0.54506606f, 0.03342118f, -0.19942582f, 0.37855881f, 0.07100323f, 
    0.22804505f, -0.11646734f, 0.02360254f, -0.06547113f, -0.02255645f, -0.03257080f, -0.00358115f, 0.10667165f, 
    0.06501111f, -0.08725322f, -0.04796261f, -0.07575108f, -0.03578834f, -0.01206250f, 0.02185964f, -0.05458165f, 
    -0.24489836f, -0.02547493f, -0.03130795f, -0.09147250f, 0.03318753f, 0.00059875f, -0.06189283f, 0.04330533f, 
    -0.07099550f, 0.00955847f, 0.09475651f, 0.09844248f, 0.32445791f, -0.03579703f, 0.11890666f, 0.06291106f, 
    -0.04733306f, -0.30143714f, -0.25696167f, -0.22448750f, 0.03049377f, -0.05813620f, 0.05905712f, 0.08354174f, 
    0.09383451f, 0.11893576f, 0.06988177f, -0.03059224f, -0.03952992f, -0.15777364f, -0.03010589f, 0.07634933f, 
    0.06542608f, 0.05824404f, 0.17989190f, -0.01920832f, 0.57521743f, -0.27038139f, -0.33304802f, -0.11908012f, 
    -0.10213287f, -0.11787651f, 0.13104013f, 0.11178530f, 0.19769777f, 0.03063640f, 0.10951823f, -0.08841265f, 
    -0.07890996f, -0.05693536f, -0.00989823f, 0.07614316f, 0.15677327f, -0.05430248f, 0.19225582f, -0.09186456f, 
    1.19951272f, 0.38183191f, -0.19886501f, -0.13159509f, -0.26151913f, 0.11087310f, -0.02460223f, -0.22409894f, 
    0.06457908f, -0.19160576f, 0.18084651f, 0.08464718f, 0.00730825f, -0.06802425f, 0.11247130f, -0.05254095f, 
    0.08338072f, -0.11595542f, -0.02451724f, -0.09385702f, 0.07602104f, 0.12069272f, -0.06247149f, -0.08683940f, 
    -0.01393096f, -0.07947400f, 0.04586679f, -0.02295437f, -0.05372308f, -0.05354684f, 0.09920800f, -0.05501454f, 
    0.08222417f, 0.04929410f, 0.02139668f, -0.00061453f, 0.09609818f, 0.11843175f, 0.13183461f, 0.05272966f, 
    -0.24446936f, -0.90446419f, 0.11270511f, -0.13378856f, 0.39950985f, -0.17132401f, 0.04618936f, -0.00246126f, 
    -0.08316323f, -0.10195011f, 0.04294687f, 0.06675928f, 0.06025641f, 0.13164704f, -0.03261957f, -0.00952565f, 
    -0.06610525f, -0.10726041f, -0.05378626f, -0.16732198f, 0.08625637f, 0.23685552f, 0.30868685f, 0.17849989f, 
    0.03188735f, 0.16772333f, -0.20981178f, -0.02699569f, 0.02403465f, -0.04210960f, 0.02143651f, 0.00049509f, 
    0.04682815f, -0.02899701f, -0.04248777f, -0.13170633f, -0.08883721f, -0.25292948f, -0.19838449f, -0.45027015f, 
    0.64552295f, -0.04795779f, -0.07098861f, -0.11330114f, -0.12757669f, 0.06979928f, -0.00682444f, -0.02690423f, 
    0.05603298f, -0.08751673f, 0.01373093f, 0.16461609f, 0.10670038f, -0.00200292f, 0.06056623f, 0.03899111f, 
    0.10574359f, 0.06072854f, 0.09771680f, 0.03303181f, 0.05175561f, -0.52990168f, -0.80834407f, -0.21874085f, 
    0.11638764f, 0.06242688f, -0.03909235f, 0.16548610f, 0.01895826f, -0.02311177f, -0.01159962f, -0.03874015f, 
    0.01589003f, 0.01581866f, 0.03756432f, 0.02633727f, 0.05974118f, 0.08993188f, 0.09552381f, -0.03963503f, 
    0.10889054f, -0.19323263f, -0.64011621f, -0.33673242f, 0.03038928f, -0.13088174f, -0.21335605f, 0.16869421f, 
    -0.09974748f, -0.21577162f, 0.00879556f, -0.03825618f, -0.03381474f, 0.03111675f, 0.04175839f, 0.02551664f, 
    0.04307443f, 0.04829093f, -0.18239765f, -0.30267474f, -0.20663191f, -0.11469319f, -0.08788917f, -0.01050261f, 
    0.04675124f, -0.02362950f, -0.03098263f, 0.11479106f, 0.05866319f, 0.12952481f, 0.09756228f, -0.00308264f, 
    0.02428940f, 0.03998934f, 0.05108712f, -0.13619214f, 0.15255342f, 0.02231272f, -0.08011276f, 0.17837813f, 
    0.48514983f, 0.04686246f, -0.06600169f, 0.13531424f, -0.08647754f, 0.02739104f, -0.08247316f, -0.14573906f, 
    -0.03840259f, 0.13701780f, 0.13419387f, 0.01586518f, 0.02914637f, 0.02487813f, 0.07678384f, -0.17860617f, 
    0.16103776f, -0.02987033f, 0.04491610f, 0.04995292f, 0.07275797f, -0.07542122f, 0.16035505f, 0.11194628f, 
    0.06651153f, 0.15310116f, -0.04146175f, -0.12079986f, -0.13593359f, -0.00795438f, 0.09681574f, -0.05104735f, 
    -0.07320791f, 0.02114619f, -0.11485893f, -0.11288667f, -0.03252062f, 0.09305895f, -0.24203332f, 0.00127700f, 
    0.30215046f, -0.51018113f, -0.44567028f, 0.10191194f, 0.22151317f, 0.00061534f, -0.05454713f, 0.10740271f, 
    0.01263635f, 0.18990567f, -0.06289118f, -0.27910867f, -0.02012561f, -0.04091277f, 0.01007168f, 0.00581350f, 
    -0.00746719f, 0.08409166f, 0.01710187f, 0.10230163f, -0.12642129f, 0.13174437f, 0.03880917f, 0.00071319f, 
    -0.17602387f, -0.02729141f, 0.01489156f, -0.00267909f, 0.01173105f, 0.02125752f, 0.05788857f, -0.03469272f, 
    0.03410445f, 0.06696554f, 0.03767109f, -0.03080844f, 0.16897260f, 0.06548567f, 0.15836239f, 0.06215956f, 
    -0.12679347f, 0.17536642f, 0.15237074f, 0.13502343f, -0.10504953f, 0.06297798f, 0.03679843f, 0.01861266f, 
    0.00946617f, -0.03537613f, -0.06092678f, -0.04089602f, 0.02160287f, 0.05789692f, 0.05887787f, 0.02090284f, 
    0.06260240f, 0.04168667f, 0.05302333f, -0.01354516f, -0.07434482f, -0.36970893f, -0.08097967f, -0.09428849f, 
    -0.07061964f, 0.10368701f, -0.19178964f, 0.19678420f, -0.04281906f, -0.56121743f, 0.00245908f, 0.06405459f, 
    0.05969124f, -0.00276803f, 0.12400219f, 0.06222389f, 0.07914801f, 0.16133593f, -0.09837336f, -0.30171373f, 
    0.14756067f, -0.25538734f, -1.07295310f, -0.30545014f, 0.03536400f, 0.01628958f, -0.04324928f, 0.10056868f, 
    0.15742953f, 0.07544468f, 0.17957440f, -0.15520179f, 0.02380283f, 0.11761772f, 0.02482967f, 0.00029447f, 
    0.00907465f, -0.03061441f, -0.04558392f, -0.01342639f, -0.17811245f, -0.63653851f, -0.71640319f, -0.20670466f, 
    -0.07033391f, -0.14136504f, 0.08892277f, 0.17043039f, 0.14031735f, 0.27972019f, 0.03750620f, -0.15674205f, 
    -0.22366875f, -0.10058270f, -0.07914621f, -0.02304669f, -0.01575476f, 0.07810175f, 0.01791726f, -0.03270273f, 
    -0.23216967f, -0.37546763f, 0.23317401f, -0.01507892f, 0.06500211f, -0.03845577f, 0.01803699f, -0.01886263f, 
    -0.06840052f, -0.01370207f, 0.03279479f, -0.08047085f, -0.00603101f, 0.02080818f, 0.06207331f, -0.12288900f, 
    0.04229880f, 0.07256753f, -0.14199622f, -0.03830362f, -0.18156068f, -0.08156890f, -0.03099464f, -0.04975998f, 
    -0.21326722f, -0.08052718f, -0.05713638f, 0.00982824f, 0.01841336f, 0.00902006f, 0.08966210f, 0.00962079f, 
    -0.00940163f, 0.04989965f, 0.17115141f, -0.00623169f, 0.06217317f, -0.02393227f, 0.06834084f, 0.15668856f, 
    0.05652583f, -0.56921297f, -0.22808768f, -0.11474456f, -0.05623550f, -0.16522294f, -0.02754692f, 0.06601376f, 
    0.06271564f, -0.04948813f, 0.11548825f, 0.07978443f, 0.04856690f, -0.10680065f, -0.10436336f, -0.07212085f, 
    -0.07792663f, -0.11840978f, -0.06808550f, -0.07294817f, 0.35235015f, -0.36755994f, -0.38520142f, -0.13234517f, 
    0.03166281f, -0.06797098f, -0.26294383f, -0.02213273f, -0.05758747f, -0.40851778f, 0.01608526f, 0.06455279f, 
    0.00958376f, 0.08080894f, 0.05486796f, 0.10023534f, 0.11209252f, 0.13897958f, -0.23175670f, -0.17890768f, 
    -0.43903747f, -0.00136466f, 0.17990945f, 0.02668925f, -0.19080362f, -0.05537769f, -0.05370907f, -0.03758354f, 
    -0.06955964f, -0.12984927f, -0.20706278f, -0.09231173f, -0.01386346f, -0.05097446f, -0.01599002f, 0.00044513f, 
    0.01787519f, 0.03716346f, 0.01809443f, -0.03830141f, 0.24068150f, -0.33065140f, -0.30999929f, -0.01638900f, 
    0.18120934f, 0.09845766f, 0.01475138f, 0.02742633f, 0.04308232f, 0.04428755f, 0.10290914f, 0.13188225f, 
    -0.02001188f, 0.05971454f, 0.01094029f, -0.05463642f, 0.13771929f, -0.15118201f, -0.15266772f, 0.12732527f, 
    -0.05805944f, -0.24268645f, -0.70504951f, -0.38822109f, -0.01701270f, -0.12983409f, 0.16592780f, 0.20032308f, 
    0.15793309f, -0.03393940f, -0.01813761f, -0.10871740f, -0.09532395f, 0.04116355f, 0.09487436f, 0.12270341f, 
    -0.03879242f, -0.00473706f, -0.13446410f, -0.03830368f, -0.22340630f, -0.48899797f, -0.53230745f, -0.26118651f, 
    -0.11372385f, -0.24208589f, -0.07105170f, 0.00044614f, 0.04263549f, 0.01708815f, -0.07714517f, 0.01716369f, 
    -0.06047874f, -0.04859325f, -0.02757812f, -0.01022047f, 0.04419189f, 0.08176343f, 0.15898065f, 0.11470288f, 
    -0.18155868f, 0.16283673f, 0.09283741f, -0.52954441f, 0.21257479f, -0.10053302f, 0.03720190f, -0.04033935f, 
    0.00714425f, 0.14245860f, 0.07595503f, 0.10422466f, -0.26382241f, 0.17059632f, 0.02708718f, 0.05342828f, 
    0.15848486f, -0.09094277f, -0.21526271f, 0.05732649f, -0.34790713f, 0.45603454f, -0.99174547f, 0.14163758f, 
    -0.23427014f, 0.12710573f, -0.11534742f, 0.24934068f, -0.07776027f, 0.06591986f, 0.03880568f, -0.06747147f, 
    -0.01066019f, -0.03285243f, -0.07055404f, 0.04921257f, 0.02352066f, -0.06070057f, 0.07517431f, -0.06047049f, 
    0.32701945f, 0.30754414f, 0.32306629f, -0.10451363f, -0.09760056f, -0.08608466f, 0.02600755f, 0.06412558f, 
    0.04449107f, 0.17154738f, -0.08036086f, 0.10961618f, 0.00460867f, -0.03814001f, -0.03205045f, -0.02779837f, 
    -0.03805889f, -0.00570310f, -0.14244245f, -0.15416475f, 0.11739834f, 0.14367864f, 0.39494541f, -0.19129331f, 
    -0.00820058f, -0.01984555f, 0.01740170f, 0.00623795f, 0.19993763f, 0.06235310f, -0.01236072f, -0.11118054f, 
    0.04873100f, -0.20154990f, -0.02818380f, 0.12127595f, -0.02394627f, -0.17404132f, 0.03614684f, -0.18748537f, 
    -0.29923859f, -0.06431862f, -0.35471603f, 0.24638562f, -0.68947893f, 0.27719811f, -0.34232298f, -0.16411965f, 
    -0.00034708f, 0.02383018f, 0.00652802f, -0.11608526f, 0.07800915f, 0.08055408f, 0.03576292f, 0.06173647f, 
    0.06999870f, 0.12008584f, 0.01020753f, 0.06917688f, -0.02987135f, -0.38486901f, -0.23292969f, -0.12081983f, 
    0.17462857f, 0.08544212f, 0.27799696f, 0.07981867f, -0.06871598f, -0.06323140f, 0.07688988f, -0.04844651f, 
    -0.17681547f, -0.08035461f, -0.15113683f, 0.17873661f, -0.17423253f, -0.01376048f, -0.19506100f, 0.02584220f, 
    0.08902431f, 0.14683807f, 0.46352157f, 0.31840101f, -0.24673453f, 0.14391823f, -0.16829646f, -0.22549441f, 
    -0.20761542f, -0.13407086f, 0.03745680f, 0.08257434f, 0.09704138f, 0.08593674f, 0.05743036f, 0.01132605f, 
    -0.09213472f, -0.07495957f, -0.04085626f, 0.00640940f, -0.62017810f, 0.24701618f, -0.05145829f, 0.23888898f, 
    -0.22932076f, 0.01314078f, -0.28079462f, -0.13415185f, -0.32707331f, 0.03468350f, 0.05113393f, -0.06197033f, 
    -0.05604151f, -0.00204538f, 0.06663933f, -0.06598517f, -0.24942909f, -0.06851353f, 0.06635711f, -0.05874063f, 
    -0.72406304f, -0.44944280f, -1.00865304f, -0.28833744f, -0.39859593f, 0.03405957f, 0.07602435f, -0.26591873f, 
    -0.05169360f, -0.12199926f, -0.02785442f, -0.11500072f, -0.06057525f, -0.01960022f, -0.14110641f, 0.11463389f, 
    0.00392630f, -0.02973756f, -0.01533096f, 0.06074414f, -0.08011879f, 0.09044185f, -0.08250484f, 0.01370238f, 
    0.15502790f, 0.18942134f, 0.00631170f, 0.14132924f, 0.07553405f, -0.25998560f, 0.11605452f, -0.00998633f, 
    -0.02233445f, -0.04659644f, -0.01419335f, -0.05401298f, -0.04735656f, -0.16707414f, 0.02891321f, -0.06075440f, 
    0.01897011f, -0.28862220f, 0.16102256f, 0.09849360f, -0.46089810f, 0.09190933f, -0.22784646f, -0.04684188f, 
    0.19102670f, -0.14790845f, -0.11586406f, 0.10595686f, -0.04377879f, 0.02700629f, 0.03987482f, 0.11875075f, 
    0.01539112f, 0.09205940f, 0.00782949f, 0.18070240f, -0.17027013f, -0.24860093f, -0.93022978f, 0.26314601f, 
    -0.02123929f, 0.11233880f, 0.02580364f, 0.19009863f, 0.12656911f, 0.00925346f, 0.03982242f, 0.00870817f, 
    -0.02963874f, 0.02773311f, -0.03207377f, -0.02032140f, 0.08443788f, 0.02933312f, 0.12052708f, 0.35129762f, 
    0.35870150f, 0.11773601f, -0.29716471f, 0.00593165f, -0.22768109f, -0.08804832f, 0.11703561f, 0.18022186f, 
    -0.12869784f, 0.10350832f, -0.05625956f, -0.03250879f, -0.05418342f, -0.06471813f, -0.04446589f, -0.00019438f, 
    -0.01643028f, 0.05409789f, 0.09617425f, -0.11607968f, -0.23212804f, -0.61283940f, -0.05983196f, -0.36558565f, 
    -0.09655706f, -0.52797449f, 0.04917256f, 0.11130733f, 0.07376990f, 0.15052325f, 0.05495976f, 0.00266170f, 
    0.01302745f, 0.03122038f, 0.02346365f, -0.02782479f, 0.00837404f, 0.02345940f, -0.04834573f, -0.18415965f, 
    0.22589986f, -0.05287528f, 0.16843329f, 0.25050977f, -0.56364471f, -0.11256109f, -0.07409883f, -0.09822291f, 
    0.11369186f, 0.15937085f, 0.05835513f, -0.01574510f, 0.09620343f, 0.01992048f, 0.02627158f, -0.09921376f, 
    0.04026156f, 0.16285785f, 0.16514717f, 0.11261325f, 0.15712316f, -0.12992579f, 0.13815320f, -0.13998570f, 
    0.09629176f, 0.01902365f, -0.04167999f, -0.08444430f, 0.07279874f, -0.04316285f, -0.02718903f, 0.04245905f, 
    0.12019904f, -0.06191649f, 0.00487181f, 0.07368466f, -0.06348616f, -0.09030969f, -0.09052918f, 0.08894939f, 
    -0.14637239f, -0.08223611f, 0.09092309f, 0.07653117f, -0.00770340f, 0.12951608f, 0.09757406f, -0.18394107f, 
    -0.01799329f, -0.14648610f, 0.08560795f, -0.08665850f, 0.06718325f, -0.04052675f, 0.06502771f, 0.17474264f, 
    0.01308405f, -0.23472936f, -0.04361993f, 0.03455509f, -0.08030601f, -0.50397819f, -0.42104867f, -0.60887504f, 
    -0.04170302f, 0.06614208f, -0.07312589f, 0.02677409f, -0.00695539f, -0.07331431f, -0.01533836f, -0.01605984f, 
    0.09857876f, 0.00565334f, 0.02934168f, 0.17154786f, 0.14718266f, 0.08392721f, -0.18476088f, -0.07860593f, 
    -0.06577985f, -0.03833726f, 0.47027332f, -0.12733871f, -0.53583837f, 0.04058086f, -0.21567382f, -0.07498427f, 
    0.08990890f, 0.22744003f, -0.05076174f, 0.02113667f, 0.04673286f, 0.06756184f, -0.14264002f, 0.00032958f, 
    -0.00269455f, -0.05160786f, -0.06096024f, 0.05213058f, -0.24690863f, 0.15696084f, -0.02808174f, -0.03986547f, 
    0.08465926f, 0.18160307f, 0.05057728f, 0.14053015f, -0.03893544f, -0.06392810f, 0.18016888f, -0.12888896f, 
    -0.08356059f, -0.15949011f, -0.00753834f, 0.06507675f, 0.02092985f, -0.11293363f, 0.00047118f, -0.03796915f, 
    -0.21108870f, 0.26950920f, -0.55784833f, 0.02129162f, 0.10527641f, 0.20827127f, 0.02303534f, 0.28576562f, 
    0.07219227f, 0.01574471f, 0.07405248f, 0.00558265f, 0.02179245f, 0.03211600f, 0.01712229f, 0.01675216f, 
    0.09303597f, -0.10603221f, 0.02204913f, -0.02353763f, -0.00934650f, 0.16547833f, -0.26773372f, -0.10586584f, 
    -0.04403922f, -0.16840859f, -0.06518826f, -0.09031895f, -0.07934893f, 0.38693008f, -0.01496831f, 0.11104267f, 
    -0.01486442f, 0.01889463f, -0.07725380f, 0.03088058f, 0.14851989f, 0.11019776f, -0.04393139f, 0.16245210f, 
    -0.37071881f, 0.18413402f, -0.00843993f, 0.67515779f, -0.35717180f, -0.07004601f, 0.20050888f, -0.31546423f, 
    0.13253663f, -0.28975016f, 0.07904455f, -0.11763126f, 0.14279470f, 0.16528745f, 0.11463109f, 0.06349525f, 
    0.07509210f, -0.10747124f, 0.01660776f, 0.00841916f, 0.15888350f, 0.17017221f, 0.17658705f, 0.36839786f, 
    -0.45435283f, -0.09953701f, -0.09039688f, -0.53628892f, -0.11752973f, -0.17112829f, 0.10090430f, -0.03892105f, 
    0.07177939f, 0.10460497f, 0.06885237f, 0.02309610f, -0.02040399f, -0.00506825f, 0.00132869f, -0.00833053f, 
    0.08432534f, -0.24238314f, 0.21191436f, 0.06444252f, 0.03293342f, -0.08159865f, 0.01525891f, -0.09816071f, 
    0.15388690f, -0.07273930f, -0.04159332f, 0.03056220f, 0.11211205f, -0.06661258f, -0.03346454f, 0.09791886f, 
    -0.00312223f, 0.00392028f, 0.00898103f, 0.12529199f, 0.00574871f, -0.02948300f, 0.09170493f, -0.09417748f, 
    0.21869233f, -0.00629838f, 0.04520432f, -0.04183879f, 0.09759343f, -0.08413950f, 0.14676614f, 0.12519926f, 
    0.10058491f, -0.11053196f, -0.11717311f, 0.11748107f, 0.08176115f, 0.02038806f, -0.04606054f, 0.11009751f, 
    -0.05169541f, 0.31965613f, 0.39615884f, 0.72144520f, -0.01361586f, 0.03068709f, -0.06116830f, -0.24911149f, 
    -0.11202321f, -0.15032269f, 0.13881901f, -0.07804621f, 0.15657653f, -0.05666221f, -0.03520292f, 0.11034340f, 
    0.08332489f, -0.08076387f, 0.03090344f, 0.13207717f, 0.10834993f, -0.36074582f, -0.01157754f, 0.07872554f, 
    -0.17848094f, 0.00620399f, -0.32502249f, -0.00869921f, 0.12831898f, 0.22605368f, -0.03479486f, 0.00606971f, 
    0.06836905f, 0.03413519f, -0.05158480f, -0.00711578f, 0.04876858f, 0.08935835f, 0.22471948f, 0.09660953f, 
    -0.42743239f, 0.00220983f, -0.24181801f, 0.01235786f, 0.22889595f, 0.07935359f, -0.16808814f, 0.19103508f, 
    0.02540728f, -0.04643914f, 0.00035748f, -0.02183399f, -0.02891121f, 0.04027337f, -0.13888048f, 0.02634413f, 
    0.06431458f, 0.15345560f, -0.02925285f, 0.10124484f, -0.09907477f, 0.03210150f, -0.08604092f, -0.15129739f, 
    -0.15034288f, -0.06795055f, -0.04100223f, -0.10550953f, -0.22773021f, 0.05431294f, 0.22869582f, 0.06811986f, 
    0.01363036f, 0.00901878f, -0.13206854f, 0.02535324f, -0.07968316f, -0.07974707f, -0.12913741f, -0.01384644f, 
    -0.09987397f, 0.03208459f, 0.13951614f, 0.47689763f, -0.86021394f, 0.01602190f, -0.08142648f, -0.19800872f, 
    0.04159669f, 0.06368292f, 0.08836341f, -0.04773870f, 0.08678123f, 0.09651911f, 0.05844739f, 0.06852721f, 
    0.13305645f, 0.04565901f, 0.10947995f, 0.07952037f, -0.46132907f, -0.16049451f, 0.36830950f, 0.11714390f, 
    -0.21792336f, -0.01679578f, -0.21590053f, 0.02022889f, 0.06463783f, 0.15915163f, -0.05012129f, -0.08513872f, 
    0.05384459f, -0.02372859f, -0.10935038f, -0.02754474f, -0.05177138f, 0.00057580f, -0.07215984f, -0.22550882f, 
    0.05787734f, -0.25340107f, 0.52564359f, -0.10227960f, -0.35580409f, 0.04648498f, 0.01226228f, 0.13677937f, 
    -0.09228487f, -0.04652687f, -0.07115450f, -0.10381833f, -0.01739252f, 0.04507707f, -0.09593809f, -0.03870668f, 
    0.22295785f, 0.36368415f, -0.04730778f, 0.11053644f, -0.11701067f, -0.45386299f, 0.28058308f, -0.00456575f, 
    0.10819153f, -0.20616567f, 0.03639640f, 0.08290926f, -0.12618035f, -0.01587699f, -0.13306421f, 0.01378197f, 
    -0.04294853f, 0.06892297f, 0.03317146f, 0.09825378f, -0.01016711f, 0.07702692f, 0.07024355f, -0.03568397f, 
    -0.35650888f, 0.00333432f, -0.22077385f, -0.02637388f, -0.02821657f, -0.03632233f, 0.02559694f, 0.08738440f, 
    0.14965916f, 0.00606173f, -0.10994435f, -0.10845356f, 0.07192519f, 0.04411387f, 0.00287425f, 0.09996103f, 
    0.06950147f, -0.00471091f, 0.23447402f, 0.35048741f, -0.36159143f, -0.23673582f, 0.03924319f, -0.03339736f, 
    -0.24005637f, -0.01108939f, -0.09572188f, -0.17286544f, 0.24342297f, 0.08181364f, -0.27058792f, -0.12077899f, 
    0.06040790f, -0.07047476f, 0.10193590f, 0.04194099f, 0.01829507f, -0.10357433f, 0.23852128f, 0.18868794f, 
    -0.24398004f, 0.00626171f, 0.16861580f, 0.02143827f, 0.00265672f, -0.12916264f, -0.01753920f, -0.31719407f, 
    0.09579147f, -0.13875429f, -0.00794434f, 0.06348490f, -0.11087507f, -0.15112107f, -0.29233399f, -0.10440511f, 
    -0.10177675f, 0.08571056f, -0.07908487f, -0.23635440f, -0.38525119f, -0.44590089f, 0.12714148f, 0.18040198f, 
    -0.00291989f, 0.00877175f, 0.12155234f, 0.21543382f, -0.10504805f, 0.04390115f, -0.04513167f, -0.06049220f, 
    0.04713098f, -0.08543854f, 0.01009788f, -0.16891165f, 0.18531984f, 0.04615788f, 0.08190838f, 0.16409408f, 
    -0.06565508f, -0.03862817f, 0.08574007f, 0.07598258f, 0.06425409f, -0.07128281f, 0.05981772f, -0.22616288f, 
    0.04794183f, 0.00980812f, 0.07732896f, -0.01083669f, -0.00961359f, 0.02585201f, -0.02687828f, -0.04534708f, 
    0.04524129f, 0.03850000f, 0.08095324f, 0.18361320f, 0.26624241f, -0.07178428f, 0.33315498f, -0.23068635f, 
    0.06711275f, -0.11149946f, 0.12919068f, 0.08038805f, 0.19992065f, 0.07984097f, -0.11213024f, -0.03898567f, 
    -0.20896815f, -0.18595590f, -0.00712181f, 0.03491590f, 0.16778098f, 0.17738570f, 0.29649627f, -0.05607885f, 
    -0.59686548f, -0.12303521f, 0.08156333f, 0.33205146f, 0.21589868f, -0.13151957f, -0.18377461f, 0.27485225f, 
    0.19055714f, 0.15049033f, -0.12695760f, 0.01993630f, -0.07358854f, 0.22764274f, 0.07096594f, 0.00301655f, 
    0.16972688f, 0.04249542f, -0.05121229f, -0.17593576f, -0.33730376f, -0.35869029f, 0.26257920f, 0.08957516f, 
    -0.11792623f, -0.16493596f, 0.05477421f, -0.01807962f, 0.06266627f, -0.02003958f, -0.02638132f, -0.04736897f, 
    0.09705731f, 0.10551313f, 0.13877706f, 0.04080703f, 0.14631562f, 0.11900887f, 0.13581890f, 0.06212498f, 
    -0.41828218f, 0.22874555f, -0.18995781f, -0.07681908f, -0.06245336f, 0.12625274f, -0.00725042f, 0.02119035f, 
    0.01565969f, -0.09784839f, 0.08993960f, 0.03972536f, 0.03395457f, 0.09331825f, 0.02469792f, -0.05588350f, 
    -0.15224814f, -0.16106492f, -0.11381748f, -0.24125674f, -0.16985130f, -0.18737629f, -0.12224359f, 0.02440170f, 
    0.11702450f, -0.07688445f, 0.14235353f, -0.02211920f, -0.11391474f, -0.12763134f, 0.01693010f, 0.10249837f, 
    -0.08171030f, -0.00277718f, 0.02712555f, 0.21158223f, -0.46243593f, -0.19110590f, -0.25204614f, -0.16878192f, 
    -0.38672599f, 0.01672501f, -0.09464173f, -0.00676221f, 0.06583805f, -0.02809460f, -0.01881728f, 0.13862573f, 
    -0.19726551f, 0.11067974f, 0.05683966f, 0.08703557f, 0.03248469f, 0.15358779f, 0.01402166f, 0.08773050f, 
    0.03141243f, -0.03228174f, 0.06582573f, 0.12561068f, -0.35224992f, 0.14641038f, -0.52895129f, 0.07589231f, 
    0.25144747f, 0.05892586f, -0.10565603f, 0.06124344f, -0.11111298f, 0.02680380f, -0.11182997f, 0.06265607f, 
    0.11441054f, -0.00568833f, -0.01974292f, 0.01812925f, 0.02347610f, -0.36179084f, 0.05201025f, 0.01872700f, 
    -0.29790500f, 0.04422259f, -0.68257320f, 0.03114850f, 0.08048806f, -0.11058160f, -0.04695702f, 0.07870387f, 
    -0.09274119f, 0.08225798f, -0.00566941f, 0.11440010f, -0.01399797f, 0.03307883f, -0.08722705f, 0.02724235f, 
    -0.06922595f, -0.12182925f, -0.05845654f, -0.15196867f, 0.00259624f, -0.01077944f, 0.02721826f, 0.43183219f, 
    0.13487220f, -0.10494504f, 0.02159684f, -0.12716362f, -0.06258587f, 0.09680553f, -0.29409251f, 0.06081580f, 
    -0.10423835f, -0.03218157f, 0.08054021f, -0.11773721f, 0.02767092f, 0.00822937f, 0.06340991f, 0.24745502f, 
    -0.62096667f, 0.09532334f, 0.20961130f, -0.00088796f, -0.01492456f, 0.13120340f, 0.00089399f, 0.11756387f, 
    0.25395167f, -0.01141590f, -0.20313050f, -0.05548071f, 0.11640427f, -0.11942840f, 0.07863278f, 0.01796692f, 
    0.07823699f, 0.03237988f, 0.14570266f, 0.25729072f, -0.64801455f, 0.09198198f, -0.16466172f, 0.42141163f, 
    -0.00593789f, -0.05987892f, -0.17203912f, -0.16383146f, 0.47569153f, 0.08205247f, -0.28578269f, -0.01811051f, 
    -0.01975345f, -0.20784587f, 0.21698603f, 0.08672262f, -0.15776850f, -0.16161291f, 0.24008672f, 0.12708655f, 
    -0.11114824f, 0.26249346f, 0.11975466f, 0.29236767f, 0.06529588f, 0.04742097f, -0.01550605f, -0.07173123f, 
    -0.02704206f, 0.03773694f, -0.10828734f, -0.17802808f, -0.04058365f, -0.06311404f, -0.01000894f, 0.04983201f, 
    -0.03345215f, 0.11466260f, 0.01461204f, 0.11750181f, -0.35714510f, -0.23362501f, 0.11483885f, -0.11584612f, 
    -0.10322290f, 0.02375705f, 0.04425236f, -0.16015668f, 0.13827382f, 0.03682077f, -0.13300881f, -0.12465966f, 
    0.06956158f, -0.11762383f, 0.11488458f, 0.13652124f, 0.29969606f, 0.04796336f, 0.21660058f, -0.02400112f, 
    -0.15409321f, -0.36679602f, 0.12199655f, -0.02348356f, -0.02675845f, -0.19997883f, -0.07381806f, 0.05981141f, 
    -0.02165756f, -0.13298158f, -0.14822538f, 0.02695731f, 0.09178124f, 0.00538742f, -0.01767783f, 0.07953291f, 
    0.02439866f, 0.10451747f, 0.11662632f, -0.07823221f, 0.01172827f, -0.10408782f, 0.12960677f, -0.14684846f, 
    -0.02800213f, 0.07045233f, -0.20116606f, 0.37512380f, -0.03366638f, -0.26662898f, -0.02002069f, 0.09397934f, 
    0.14370620f, 0.05220289f, -0.03490473f, 0.00401372f, -0.10885064f, 0.04119436f, -0.41135100f, -0.24956547f, 
    0.13096911f, 0.33887795f, -0.17144194f, -0.07020309f, 0.09961946f, 0.06455708f, -0.12085856f, 0.02450276f, 
    0.03229282f, -0.00890635f, -0.21887490f, 0.11056589f, -0.02099460f, -0.05063813f, -0.03584934f, 0.03089933f, 
    -0.04236974f, -0.06111381f, -0.06969324f, 0.03237883f, 0.01311213f, 0.13724107f, -0.06928545f, 0.01326448f, 
    0.08440328f, 0.09139945f, -0.05488077f, -0.13354380f, 0.00296713f, 0.04679750f, -0.18553190f, 0.16050725f, 
    0.03725563f, -0.06183036f, -0.09812804f, 0.10146293f, 0.01238168f, 0.00386070f, 0.03992973f, -0.00471882f, 
    -0.18523258f, 0.31577966f, -0.13807863f, 0.28523442f, 0.00957792f, 0.06292885f, -0.12658444f, -0.06672443f, 
    0.00729041f, 0.08668538f, -0.07241132f, 0.06886363f, -0.12366652f, -0.04472014f, -0.04626562f, -0.06651565f, 
    -0.10067279f, -0.16027981f, -0.02945438f, -0.08015796f, -0.08002362f, -0.34851325f, -0.10459935f, 0.14660299f, 
    -0.43292433f, -0.06228308f, -0.14498781f, -0.28133783f, -0.13626261f, 0.04355621f, -0.21496893f, 0.05349897f, 
    0.07556342f, -0.01337568f, -0.00691396f, -0.07054119f, 0.19317363f, 0.01636314f, 0.11420412f, 0.06324390f, 
    0.43837154f, -0.26289377f, 0.20355372f, -0.00604448f, -0.10769320f, 0.03157240f, -0.03765173f, -0.02914313f, 
    0.07933106f, 0.00454472f, -0.10330128f, 0.17894748f, -0.20300406f, -0.17731188f, -0.23222250f, -0.03801673f, 
    -0.16108572f, 0.04949318f, -0.04252875f, -0.10004088f, -0.41476715f, 0.02531150f, -0.46264526f, 0.04689959f, 
    0.05864104f, 0.00410421f, -0.08822247f, -0.21292028f, -0.04451058f, 0.05192767f, -0.01941863f, 0.13228458f, 
    0.00047344f, 0.12207557f, -0.01998790f, 0.10846180f, -0.09991869f, -0.14890802f, -0.10913874f, -0.28924695f, 
    -0.12956841f, -0.42435631f, -0.04001569f, -0.41150302f, -0.45101997f, -0.11963690f, -0.11551158f, 0.03136567f, 
    -0.13263395f, -0.14517497f, -0.21214575f, 0.01682799f, -0.04025273f, 0.11922202f, -0.00110627f, 0.20422266f, 
    -0.05596805f, -0.05298392f, -0.15154667f, -0.34721759f, 0.38054064f, -0.05468142f, 0.13243870f, 0.40529630f, 
    0.14259449f, -0.01429411f, 0.15666543f, 0.31445581f, 0.04113978f, 0.08558700f, -0.11833423f, 0.05181412f, 
    0.00024835f, -0.08394285f, -0.06830684f, 0.00893776f, 0.01927806f, 0.12115488f, 0.11207218f, -0.04685335f, 
    -0.30079293f, 0.00063858f, -0.08552238f, 0.03928292f, 0.01003628f, -0.01655261f, -0.11213660f, 0.05988897f, 
    0.12914789f, 0.05923104f, 0.01528514f, 0.08146146f, 0.03271001f, -0.09915707f, -0.16079174f, 0.05867959f, 
    0.00283341f, 0.14794539f, -0.23992194f, -0.17427078f, -0.55110294f, -0.00453906f, -0.06541584f, -0.11147012f, 
    0.08426806f, -0.18810597f, -0.01168814f, -0.04775926f, 0.06171888f, -0.13195750f, -0.15469648f, -0.04516176f, 
    0.00804140f, 0.04815707f, 0.01361428f, 0.05555711f, 0.06174865f, -0.06062780f, 0.22957776f, 0.26312640f, 
    0.02872198f, 0.00860270f, -0.34496146f, 0.21325697f, 0.36937708f, -0.01057558f, 0.23989768f, -0.11343727f, 
    0.14914644f, 0.06865994f, -0.07079270f, 0.14582804f, -0.02099010f, 0.12785667f, 0.10604507f, 0.12524135f, 
    0.02838595f, -0.03071439f, -0.11019903f, -0.02316223f, 0.67197448f, 0.08185106f, 0.62122327f, -0.43356854f, 
    0.08843607f, 0.16129039f, 0.07737603f, -0.12101172f, 0.18989566f, -0.01083062f, -0.02212752f, 0.03850548f, 
    -0.02208438f, 0.06614537f, -0.10588130f, -0.12674472f, 0.24365643f, -0.01398697f, 0.01600754f, 0.14864430f, 
    -0.03574072f, -0.08392654f, 0.00638581f, 0.41386023f, 0.11110496f, -0.19565426f, -0.11612728f, -0.02070482f, 
    -0.07511100f, -0.12932143f, 0.03965599f, 0.07019091f, -0.04395143f, -0.01809120f, 0.09277646f, -0.04193024f, 
    -0.06560439f, 0.09056442f, -0.10132825f, -0.32565883f, 0.13167876f, 0.03227169f, 0.08243648f, 0.47064999f, 
    -0.02026871f, -0.03185267f, 0.15078197f, 0.03827221f, 0.20803779f, -0.19645174f, -0.15434095f, 0.03325633f, 
    -0.03104769f, -0.00782204f, 0.12556808f, -0.14333057f, 0.01520705f, 0.17413114f, -0.15445350f, -0.17909989f, 
    0.01367012f, 0.01922651f, -0.11424146f, 0.12271947f, -0.41077536f, -0.15019141f, 0.11890246f, -0.18430082f, 
    -0.04604564f, -0.10928255f, 0.03838221f, -0.01385550f, 0.06426559f, 0.07414187f, 0.02008232f, 0.05842740f, 
    0.08178438f, 0.09422229f, -0.04584290f, 0.15333769f, 0.08166422f, 0.23022032f, 0.01377577f, -0.03616527f, 
    -0.13087879f, 0.00460837f, 0.10925013f, 0.06294687f, -0.03540087f, -0.08125826f, -0.24485646f, 0.16098493f, 
    -0.15943259f, 0.07145862f, 0.04573298f, -0.04161803f, -0.04579395f, 0.09588499f, -0.06577257f, 0.00186110f, 
    -0.14527631f, -0.21352156f, -0.01955947f, 0.12976633f, -0.02732206f, -0.00426334f, -0.04649179f, 0.01410125f, 
    0.02444222f, -0.04146453f, 0.08283774f, 0.04874727f, 0.01446508f, -0.14042522f, -0.00208830f, -0.10478427f, 
    -0.16191657f, -0.09132104f, -0.08403299f, -0.09522463f, 0.09798852f, -0.15134798f, 0.34074262f, -0.19927830f, 
    0.42647281f, 0.08242928f, 0.20835422f, -0.20500070f, 0.17360392f, 0.01989128f, 0.13909325f, 0.12647124f, 
    0.09461196f, -0.03761145f, 0.11196738f, -0.15068570f, 0.04387163f, -0.09176930f, -0.17944123f, 0.02449133f, 
    -0.45131007f, -0.32672358f, -0.31661981f, -0.05089249f, -0.04988967f, 0.01444238f, -0.02857791f, 0.28868711f, 
    0.07545567f, 0.04509096f, -0.11218467f, 0.01484685f, -0.02735531f, 0.13749361f, 0.07786543f, 0.04271607f, 
    -0.11520450f, 0.06938732f, -0.02892143f, 0.05282939f, 0.08792263f, 0.07563165f, 0.20965281f, -0.01383510f, 
    0.15067925f, -0.04064658f, 0.12356624f, 0.01399385f, -0.03704736f, -0.12449731f, -0.04781040f, -0.07475430f, 
    0.04382119f, -0.10032565f, -0.02148531f, 0.07183086f, -0.06484988f, -0.08923877f, -0.12568754f, -0.03518869f, 
    -0.69502658f, -0.00375788f, -0.28116295f, 0.35274625f, -0.20900230f, 0.06385138f, 0.26087624f, -0.10033654f, 
    0.15869145f, -0.11136149f, -0.26073700f, -0.09689003f, 0.03322748f, 0.09796326f, 0.09062715f, 0.02760707f, 
    0.00544292f, 0.06948999f, -0.06247938f, 0.19884619f, 0.51914746f, -0.36382452f, 0.45359361f, 0.00173880f, 
    0.09770525f, -0.02292323f, -0.16323192f, 0.07835876f, -0.04878964f, -0.09828406f, -0.02789689f, -0.01243294f, 
    0.00966978f, -0.08469083f, -0.05254783f, 0.12251418f, 0.06039427f, 0.03982107f, 0.06497425f, 0.07166070f, 
    0.08923387f, -0.14256135f, 0.08721154f, 0.23010424f, -0.06909178f, 0.07442944f, -0.34226424f, 0.04704200f, 
    -0.20637158f, -0.08589579f, 0.03942012f, 0.06520137f, -0.01841464f, 0.13359641f, 0.00020806f, -0.00806629f, 
    -0.09649713f, 0.01497191f, -0.02108754f, -0.01605516f, -0.08874117f, -0.05507175f, -0.15357898f, 0.26537669f, 
    -0.27031806f, -0.10669820f, -0.30480644f, -0.10910482f, -0.02844020f, 0.12341391f, -0.01998989f, 0.02768204f, 
    -0.04907183f, -0.03053820f, 0.01233703f, 0.14862293f, 0.02514890f, 0.15498187f, 0.07925199f, -0.03698697f, 
    0.11688064f, -0.27718109f, -0.09788840f, -0.30169454f, -0.08202926f, -0.02692138f, -0.07724474f, 0.04320869f, 
    0.02269481f, -0.06629673f, 0.01418086f, 0.11694526f, 0.12755023f, -0.01843831f, -0.10371227f, 0.17100830f, 
    0.00665545f, 0.00242366f, 0.13553300f, 0.18440330f, -0.17017581f, -0.07299410f, -0.03006703f, 0.32071528f, 
    -0.21472540f, -0.04865288f, -0.03991405f, 0.15258506f, 0.07174410f, 0.03476825f, -0.05150545f, 0.06436749f, 
    -0.00464843f, 0.14805855f, -0.07202715f, -0.14622501f, -0.09457759f, 0.34705222f, 0.03170694f, -0.14324188f, 
    -0.15461949f, 0.14591469f, -0.03670599f, 0.37731639f, -0.18923114f, 0.09664018f, -0.01140299f, 0.04121603f, 
    0.25028712f, -0.16393952f, -0.08459733f, 0.02788724f, -0.15890449f, 0.03239556f, -0.00246584f, 0.13754185f, 
    -0.06557362f, 0.13428684f, -0.01318961f, -0.07041761f, -0.12451282f, -0.27657807f, 0.07605853f, 0.42980343f, 
    -0.46669501f, -0.06456264f, -0.04451371f, 0.05016508f, 0.13105646f, -0.23162030f, -0.18898490f, -0.05073049f, 
    0.00597687f, 0.05733169f, -0.04218319f, 0.16703036f, 0.08978072f, 0.09558425f, 0.00384405f, -0.12898621f, 
    -0.16243069f, 0.02933472f, -0.44428825f, 0.34363198f, -0.11782262f, -0.10103262f, 0.05827722f, -0.02114402f, 
    0.09573139f, 0.10972040f, -0.04610815f, 0.14973801f, -0.07488272f, -0.07440586f, -0.00719011f, 0.04371313f, 
    -0.07075956f, -0.02251553f, 0.00483644f, -0.01604543f, 0.29065579f, 0.12263496f, 0.16192088f, 0.14427425f, 
    0.05978349f, -0.11037090f, 0.23048617f, -0.04860254f, 0.14737509f, -0.16044784f, -0.11294990f, 0.07420797f, 
    0.06346755f, 0.01147337f, 0.02056962f, -0.02701365f, -0.15300308f, 0.14968459f, -0.14916509f, -0.00886909f, 
    0.43736354f, 0.11010695f, 0.41944814f, -0.12650052f, 0.01419034f, 0.01116493f, 0.07951548f, -0.10628030f, 
    0.07685886f, -0.04035125f, -0.10812192f, 0.03516028f, -0.07179331f, -0.03756236f, -0.11550970f, 0.01382696f, 
    0.08688862f, -0.08089586f, -0.00026539f, 0.08212569f, -0.07732973f, -0.33064216f, -0.27758589f, 0.00645053f, 
    0.41446972f, -0.28440255f, -0.42825326f, -0.18658909f, 0.05875487f, -0.07567924f, 0.11026993f, 0.05330239f, 
    -0.02295861f, -0.06398251f, 0.02150261f, 0.09025872f, -0.04250902f, -0.04809719f, 0.31320807f, 0.18817236f, 
    -0.64476144f, -0.12234016f, -0.33705556f, 0.33183217f, -0.51146418f, 0.24995360f, 0.06739911f, 0.03267064f, 
    -0.19840033f, 0.04134133f, -0.01580134f, -0.11103968f, 0.03753386f, 0.10715736f, -0.00959591f, 0.01376712f, 
    -0.05184641f, 0.09219439f, 0.00234411f, -0.06320933f, -0.61410666f, 0.05013414f, -0.38757041f, 0.34230939f, 
    -0.31863463f, -0.07209376f, -0.08643171f, -0.07469915f, 0.03316493f, 0.11185881f, -0.06065001f, -0.15429822f, 
    -0.06176696f, -0.19130713f, -0.08346058f, 0.00785925f, -0.09444874f, -0.13876145f, -0.10126814f, -0.06943091f, 
    -0.70417994f, 0.06232540f, -0.33081862f, 0.36037591f, -0.29944634f, 0.05900444f, 0.18852983f, -0.04014942f, 
    0.04142632f, 0.08632688f, -0.09692930f, 0.02558963f, 0.06888574f, 0.27345282f, -0.07571106f, 0.08962751f, 
    0.05180622f, 0.14591524f, -0.01837730f, 0.17818627f, -0.18584099f, 0.00568445f, -0.17836763f, 0.09505318f, 
    0.00273970f, -0.08505084f, 0.12803863f, 0.05497770f, 0.04304183f, 0.01589378f, -0.17216912f, 0.01020509f, 
    0.01687683f, 0.14692202f, 0.05630014f, 0.01991975f, 0.02326421f, 0.04887771f, -0.26820081f, -0.22904930f, 
    -0.69786626f, 0.08828923f, -0.25424740f, -0.08443674f, -0.30324081f, 0.14412400f, 0.15882283f, 0.03593333f, 
    -0.14268729f, 0.13532351f, -0.19346577f, -0.06047000f, 0.11814497f, 0.08448225f, -0.00392681f, -0.07781219f, 
    -0.01086016f, -0.03631731f, 0.09273465f, 0.14256729f, 0.18573382f, -0.33228472f, -0.35994935f, -0.07443732f, 
    0.13375340f, -0.22135897f, -0.38284358f, 0.08483723f, -0.13947110f, -0.19415277f, -0.02224799f, -0.00954228f, 
    0.07788546f, -0.10654510f, -0.02714585f, 0.12362998f, -0.07951146f, 0.05990999f, 0.25434679f, 0.00539864f, 
    0.39058632f, -0.33754230f, 0.06916794f, -0.27691281f, 0.06161167f, -0.05816690f, 0.03714190f, -0.14571777f, 
    0.09141847f, -0.10204501f, -0.15637173f, -0.02164842f, -0.03369523f, -0.01815027f, -0.06874748f, 0.12988901f, 
    0.08094016f, -0.02387047f, -0.05543832f, -0.03581653f, -0.29967353f, -0.33142352f, 0.17287286f, -0.01697193f, 
    -0.03952626f, -0.05081700f, -0.00974212f, -0.09400101f, 0.25971469f, 0.14058709f, -0.03847415f, -0.00438102f, 
    -0.27642646f, -0.09742404f, -0.06441087f, 0.03846455f, -0.14529106f, 0.00328807f, 0.14562373f, -0.11562649f, 
    -0.10690267f, -0.20104508f, -0.26879919f, 0.15064892f, -0.38187757f, -0.12964934f, 0.27314460f, 0.01378449f, 
    -0.25459227f, -0.07021792f, 0.01187678f, 0.00206241f, 0.21417917f, 0.16233890f, 0.04850567f, 0.04036474f, 
    0.16240208f, 0.08512533f, 0.13584006f, 0.12346648f, -0.04344756f, -0.32929358f, -0.39058334f, -0.06020534f, 
    0.00005581f, -0.00760193f, -0.22869258f, -0.09711082f, -0.25451100f, -0.09732511f, 0.01536145f, 0.05637669f, 
    -0.08361626f, -0.08698165f, -0.10810847f, 0.06282298f, -0.05707045f, -0.03516993f, -0.13082406f, -0.32453543f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.21714553f, 0.14563635f, 0.00917009f, -0.09764177f, -0.06346326f, 0.06254568f, 0.03330439f, -0.05093919f, 
    0.01721467f, 0.03609094f, -0.02400897f, -0.02312984f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
