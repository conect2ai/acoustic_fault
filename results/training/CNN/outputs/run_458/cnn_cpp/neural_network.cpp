#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.00049169f, -0.25884369f, -0.65223652f, -0.29797557f, 0.00497365f, 0.53480142f, -0.41645145f, -0.92673200f, 
    0.05505733f, -0.20303963f, -0.46084699f, -0.29894489f, -0.34350830f, 0.34830743f, -0.11074753f, -0.21160087f, 
    0.24913040f, -0.11040501f, -0.04222673f, 0.12095442f, 0.10889014f, -0.02970232f, -0.07486059f, 0.15303306f, 
    -0.18658432f, 0.89953876f, 0.48489299f, -0.13636671f, -0.13570918f, -0.23403718f, -0.26155657f, 0.36067426f, 
    -0.13522577f, 0.46419778f, 0.71155906f, 0.21766847f, -0.21326074f, -0.22980589f, -0.39263943f, 0.37004596f, 
    0.50007331f, 0.22868918f, -0.27605152f, -0.09002543f, 0.26344958f, 0.12406111f, -0.07236875f, -0.28464589f, 
    0.23544933f, 0.16967352f, 1.24601626f, 0.74553210f, 0.81077641f, 0.72616708f, 0.76103073f, -0.25117084f, 
    -0.03207120f, -0.52931070f, -0.07361417f, -0.06309556f, 0.06166711f, 0.41384587f, -0.05183181f, 0.06950995f, 
    0.15571104f, 0.05617532f, -0.04370223f, 0.15260501f, -0.07922816f, 0.02636648f, 0.03144445f, 0.01654806f, 
    0.05778803f, -0.01122154f, 0.14578059f, -0.47961515f, 0.23444951f, -0.25883937f, -0.95348823f, -0.69665420f, 
    0.47341657f, -0.47822937f, 0.30727625f, 0.42067754f, -0.08009851f, -0.00865259f, 0.26265031f, -0.16377848f, 
    -0.08806732f, -0.16214889f, 0.18790840f, 0.16300701f, -0.16554613f, -0.10894576f, 0.03622195f, -0.06229676f, 
    0.10761505f, 0.35392219f, 0.10476606f, 0.43741545f, 1.34714329f, -0.06397990f, -0.98257488f, -0.16756688f, 
    0.30262715f, -0.19276130f, -0.29206735f, 0.18200512f, -0.20909692f, -0.05412138f, -0.54366648f, -0.18624279f, 
    0.32991064f, -0.04652895f, -0.04899075f, -0.24234532f, -0.36070612f, -0.34421518f, -0.04221133f, -0.00121455f, 
    0.25552857f, 0.09323520f, -0.09267846f, -0.18889847f, -0.14754942f, 0.58555394f, -0.69018418f, 0.57194591f, 
    0.60943502f, -0.64095730f, 0.46398181f, 0.30381104f, 0.49980578f, 0.17787930f, 0.12073611f, -0.24596919f, 
    -0.43520203f, -0.38550454f, -0.13751014f, -0.05668241f, -0.33544084f, -0.00525292f, -0.17691147f, 0.03818737f, 
    -0.13541314f, 0.14008270f, -0.09902547f, -0.23935647f, -0.24496888f, -0.05244183f, -0.29616675f, -1.43416512f, 
    -0.64133751f, 0.40696737f, 0.50148952f, -0.67173547f, 0.85340214f, 0.17460696f, -0.32077789f, 0.39944831f, 
    0.31525451f, 0.13657749f, 0.01099487f, -0.01400454f, 0.20821932f, -0.18404795f, -0.04837453f, 0.01232892f, 
    -0.14372043f, -0.04068461f, 0.11306842f, -0.07894700f, 0.01318692f, 0.04109668f, 0.02486121f, -0.10303878f, 
    -0.80974609f, -0.76817018f, -0.64543402f, -0.56834733f, -0.18866289f, 0.56966472f, 0.48618892f, 0.18040095f, 
    0.53740662f, -0.00684973f, -0.25741330f, -0.20061211f, -0.28487343f, -0.30884331f, -0.03656038f, 0.34138852f, 
    -0.00397769f, -0.03864997f, -0.09832451f, -0.06873447f, 0.15924527f, -0.03632511f, -0.24403940f, -0.03395947f, 
    0.02305419f, 0.44017667f, 0.80690718f, 0.49189055f, 0.55489057f, 0.69311643f, 0.35624677f, 0.34646690f, 
    -0.52771062f, 0.11320450f, 0.27665365f, -0.14971049f, -0.18896514f, -0.33199397f, -0.22819260f, -0.16015847f, 
    -0.27245346f, -0.08142589f, -0.12653838f, -0.60096508f, 0.08520778f, -0.04748008f, 0.23660898f, 0.18776843f, 
    0.13403143f, -0.30507419f, -0.00298105f, -0.21789071f, -0.66490549f, 0.45754507f, -0.02571980f, -0.31694371f, 
    -0.17616051f, -0.54722100f, 0.14873238f, -0.19287620f, -0.20548630f, -0.20742588f, 0.00140830f, -0.53369367f, 
    0.00528525f, -0.48256370f, -0.07384890f, -0.55768466f, -0.64065903f, -0.17462000f, -0.08579420f, 0.13326778f, 
    0.27501377f, 0.32189152f, 0.65495694f, 0.26687059f, -0.50196612f, -0.36441851f, 0.23561750f, 0.63010204f, 
    0.24401677f, 0.48377824f, 0.72340918f, 0.48202115f, 0.03002344f, 0.13956770f, -0.18363069f, -0.22182855f, 
    -0.48249394f, -0.23335877f, -0.31008065f, 0.04120485f, 0.20203091f, 0.21014030f, -0.05677280f, 0.09507026f, 
    -0.29132351f, 0.12220012f, 0.07865839f, -0.13075803f, 0.14633755f, 0.06692660f, -0.52190429f, 0.41270950f, 
    -0.14336039f, -0.76656139f, -0.65262544f, -0.63990456f, -0.67528337f, 0.08378123f, 0.52900916f, 0.31377789f, 
    0.00999722f, 0.17047314f, 0.32830852f, 0.03077452f, -0.06237719f, -0.11326142f, 0.25714082f, 0.02982194f, 
    0.28226423f, 0.40074939f, 0.08455247f, 0.15095070f, 0.25792921f, -0.23607416f, 0.03876121f, 0.46524683f, 
    0.05783405f, -0.69982207f, -0.61802977f, -0.30592588f, 0.10425772f, -0.13355532f, 0.17239045f, 0.29146776f, 
    0.44773328f, 0.25783977f, -0.43928862f, 0.02168639f, 0.07325500f, 0.04746960f, 0.09512743f, -0.30878446f, 
    -0.02863026f, -0.02378075f, 0.01945059f, 0.19402675f, 0.47245941f, 0.97381723f, -0.33310357f, 0.65077931f, 
    -0.59934384f, -0.50388217f, -0.17859973f, -0.86601907f, 0.44481853f, 0.50768530f, -0.15102772f, 0.07861213f, 
    0.16473410f, -0.23271917f, -0.15072459f, 0.02077760f, -0.09779302f, -0.21227011f, 0.12861896f, -0.23979534f, 
    -0.12790774f, 0.04789955f, 0.18671082f, -0.23659965f, 0.23713094f, 0.11452837f, 0.67641312f, 0.05326489f, 
    0.27525663f, 0.99909240f, 0.56859237f, 0.46802843f, -0.06222458f, -0.02802748f, 0.09827362f, -0.27198488f, 
    0.22670829f, -0.11178010f, -0.03886292f, -0.07753175f, -0.09402859f, 0.26165426f, 0.27633315f, 0.09483429f, 
    0.19138806f, 0.52792203f, 0.21552372f, 0.21334893f, 0.22028810f, -0.40732926f, -0.13987650f, 0.64195067f, 
    0.96833783f, -0.80458415f, -0.63295645f, -0.77693224f, 0.55322999f, 0.25010985f, -0.13368188f, -0.17051041f, 
    -0.23522048f, 0.40882128f, -0.10625124f, 0.07567565f, 0.14993206f, 0.16982850f, 0.10302059f, -0.10727403f, 
    0.11663581f, 0.17650215f, 0.07422168f, 0.13416477f, -0.06009975f, -0.03676732f, -0.07601582f, 0.04459276f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09166244f, 0.35794872f, 0.21690026f, 0.17552957f, 0.33026555f, -0.10091536f, 0.13163826f, 0.05234529f, 
    0.24517690f, 0.14815199f, -0.10445728f, 0.24711879f, 0.12133092f, 0.16215417f, 0.01513051f, 0.09399664f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.34101918f, -0.33622527f, 0.06271137f, -0.33832395f, 0.18407133f, 0.01449119f, -0.00480113f, 0.01210230f, 
    0.11907087f, 0.04344983f, -0.05965658f, -0.07422858f, 0.13998617f, 0.17747702f, 0.14732835f, 0.11235955f, 
    0.04690249f, 0.03264159f, 0.05847783f, 0.03548503f, 0.09006710f, 0.08798266f, 0.09904794f, -0.01533832f, 
    -0.02319422f, 0.24477763f, -0.02602423f, -0.21001543f, 0.09078887f, 0.04143589f, -0.06513908f, -0.02631343f, 
    0.02091614f, 0.08913797f, 0.05209349f, 0.18181053f, -0.27184796f, 0.11667094f, 0.19782718f, -0.04688149f, 
    -0.07956252f, -0.04671985f, 0.09660302f, -0.07043327f, -0.00273776f, -0.07078733f, 0.14877908f, 0.20729876f, 
    -0.63867915f, 0.13463417f, 0.03420302f, -0.11804510f, 0.11079165f, 0.01347097f, -0.01824918f, 0.08410136f, 
    0.27238572f, 0.05431709f, 0.14643249f, 0.11081716f, 0.19246013f, -0.03260229f, -0.07896541f, 0.16010207f, 
    -0.03267953f, -0.05625598f, -0.11467899f, -0.06122464f, -0.02493742f, -0.08438294f, 0.00654294f, -0.05297012f, 
    0.34249601f, -0.05586253f, -0.13110475f, 0.04733548f, 0.06697806f, 0.02325043f, 0.03242511f, 0.03905621f, 
    0.09837961f, 0.03305412f, 0.06285699f, 0.05470093f, 0.06186080f, -0.03717629f, -0.28515020f, -0.30611655f, 
    0.08512586f, -0.04256351f, 0.05767121f, 0.02191492f, 0.11293960f, -0.17511015f, -0.03879251f, -0.01795833f, 
    0.14527641f, 0.09276079f, 0.04842038f, -0.05918101f, 0.06471109f, -0.03507610f, -0.05577785f, -0.09044258f, 
    0.07891113f, 0.09203690f, 0.00452047f, 0.08336712f, -0.05121808f, -0.13109720f, 0.00965278f, -0.13304518f, 
    -0.04870722f, 0.06636702f, -0.08271517f, -0.10771595f, 0.04640300f, 0.05496941f, 0.12999241f, 0.06246801f, 
    0.25047663f, 0.16358757f, 0.02828867f, -0.03519832f, 0.10677872f, 0.01892727f, 0.04637206f, 0.04570042f, 
    0.05717656f, -0.06198763f, -0.07221226f, 0.03262486f, 0.03885564f, 0.18121219f, -0.06414117f, -0.26090750f, 
    0.11469050f, 0.12741090f, 0.00824455f, 0.00437977f, -0.05834400f, 0.03249774f, -0.04381394f, 0.20755118f, 
    0.01337625f, 0.17729641f, 0.10077256f, -0.12835293f, 0.04239390f, -0.02823092f, 0.02297573f, -0.00249740f, 
    -0.09962848f, 0.01242136f, 0.09622272f, 0.14668068f, -0.23400714f, 0.30826277f, 0.22966987f, 0.17574428f, 
    0.08264498f, -0.06763979f, -0.00025205f, 0.12891702f, -0.03094989f, -0.04706910f, -0.13551171f, 0.09540466f, 
    -0.17207512f, -0.00275795f, 0.07636653f, 0.02046964f, 0.03573433f, -0.09914919f, -0.10165282f, 0.07826232f, 
    0.05108938f, 0.13713907f, -0.04496449f, 0.14817667f, 0.05789703f, 0.01883401f, -0.07704420f, -0.03573281f, 
    0.07850353f, 0.05073801f, 0.06586849f, -0.10360834f, -0.00727329f, -0.07040006f, 0.19315657f, 0.04179111f, 
    -0.06992444f, -0.05014731f, 0.06288824f, -0.06201244f, -0.01794179f, -0.01686442f, -0.00727684f, -0.02959718f, 
    0.00210191f, -0.06864742f, -0.01971895f, 0.05096615f, -0.04622839f, 0.01571413f, 0.03465811f, -0.04889958f, 
    -0.03862335f, -0.07012286f, 0.00844048f, -0.01395366f, -0.00350639f, -0.03993774f, -0.05873650f, -0.02227951f, 
    0.05450394f, -0.03869408f, -0.00414895f, -0.06754658f, -0.01489601f, -0.04715554f, -0.07081728f, -0.04891552f, 
    0.05751278f, -0.04299214f, -0.03754667f, 0.06552551f, -0.05440476f, 0.03373064f, -0.05019010f, -0.02062296f, 
    0.05543783f, -0.00448443f, -0.05940535f, 0.05485768f, -0.03830032f, -0.05700298f, 0.00989206f, 0.04311164f, 
    -0.01877381f, 0.05621022f, 0.03475622f, -0.02545572f, 0.03845673f, -0.07917272f, 0.00039510f, -0.07175977f, 
    -0.00173686f, -0.07029738f, -0.07287849f, -0.00898510f, 0.03797222f, -0.01363446f, 0.05444640f, 0.01425705f, 
    -0.07662904f, 0.02748211f, 0.00510074f, -0.06723359f, -0.02919212f, -0.01215159f, 0.05111457f, -0.02608162f, 
    0.04938385f, -0.05703764f, 0.05432157f, -0.02337626f, 0.05901969f, -0.01815216f, -0.00900372f, 0.04843682f, 
    -0.03217167f, -0.06373922f, 0.04385864f, -0.07845083f, -0.00161126f, -0.03069815f, -0.05031370f, -0.01937805f, 
    0.05762905f, -0.02961417f, -0.02232577f, 0.00627950f, 0.04010794f, -0.00653558f, -0.00655249f, -0.00714505f, 
    0.04885132f, -0.04102564f, -0.04707433f, 0.01099062f, -0.04690155f, -0.03639783f, -0.07724110f, -0.04930267f, 
    -0.07474571f, 0.00399443f, 0.04282348f, 0.01109835f, -0.02403364f, 0.04239809f, -0.06446168f, -0.04402935f, 
    -0.03234937f, -0.00101396f, 0.00517197f, -0.07142632f, 0.05383663f, 0.03730947f, -0.01654820f, -0.07233579f, 
    0.03495678f, 0.00825958f, -0.02545616f, -0.01212115f, 0.03980747f, -0.06139465f, -0.00642221f, 0.07120410f, 
    0.04873622f, -0.07203105f, -0.05404916f, -0.05018275f, -0.04854145f, -0.03571489f, -0.04979417f, -0.00920244f, 
    0.06358553f, -0.06876531f, 0.06417806f, 0.01374184f, -0.05217252f, -0.06816477f, -0.06170367f, -0.00170885f, 
    0.04242678f, 0.05400517f, 0.04124600f, -0.06753795f, 0.04861910f, -0.07748540f, -0.01849267f, -0.00859518f, 
    -0.06842498f, 0.05595755f, -0.06415591f, -0.02193285f, 0.00437398f, -0.04399354f, 0.04029801f, -0.03368410f, 
    0.06235410f, 0.06147040f, -0.04381449f, -0.01103689f, -0.07274193f, -0.09286471f, -0.01194987f, -0.03118635f, 
    0.03012078f, -0.05725010f, 0.01590138f, -0.06434248f, 0.05337635f, -0.02910467f, 0.05821108f, 0.00540694f, 
    0.02433042f, -0.04613866f, 0.02432236f, 0.02378181f, 0.05073524f, 0.02579676f, -0.05082387f, 0.01342393f, 
    0.02108592f, 0.00585383f, -0.02907595f, 0.02055587f, -0.06969809f, -0.00039395f, -0.02669227f, -0.05422111f, 
    0.06049343f, -0.31520304f, 0.15505083f, -0.13059364f, 0.02483896f, -0.10622875f, 0.14430709f, 0.03993108f, 
    -0.12576635f, 0.01342292f, -0.05493997f, 0.05971237f, 0.36488524f, 0.04945877f, -0.01847764f, -0.09175967f, 
    0.06793032f, -0.03339720f, 0.04672176f, -0.13254973f, -0.10985757f, 0.23257942f, -0.16333176f, 0.22758321f, 
    0.49432564f, -0.19997238f, -0.15860115f, 0.27254078f, -0.04397834f, -0.16471758f, 0.02877652f, -0.01644170f, 
    -0.10509969f, 0.07151584f, -0.00217198f, 0.11524021f, -0.09704200f, 0.06881569f, 0.08303734f, -0.24525863f, 
    0.14481062f, 0.02771532f, 0.02461345f, -0.14677358f, 0.10502920f, 0.05254169f, -0.00433585f, -0.02628989f, 
    -0.03289330f, 0.07507209f, 0.11802425f, 0.08133346f, 0.13564488f, -0.17512025f, 0.09659882f, 0.14612395f, 
    0.04630184f, -0.00113635f, -0.00390099f, -0.05475508f, 0.00505470f, 0.01124202f, -0.05756056f, 0.03267280f, 
    0.14555070f, -0.14593202f, -0.07856312f, 0.05451184f, 0.13330269f, -0.02581418f, 0.01750296f, -0.18155329f, 
    -0.58501202f, 0.27386722f, -0.04534286f, -0.08786633f, 0.19794717f, -0.10890359f, -0.01854196f, 0.00478723f, 
    0.01950691f, 0.00428719f, 0.01451675f, 0.09590866f, 0.13042925f, 0.29569805f, -0.14360321f, -0.24729991f, 
    -0.03307449f, -0.01631229f, -0.06270627f, -0.03596104f, 0.08545271f, -0.05895499f, -0.25798491f, -0.13783546f, 
    0.06802345f, 0.09420635f, 0.15229006f, 0.11210183f, -0.10636359f, 0.18132004f, -0.02790084f, -0.15166485f, 
    0.13856936f, 0.01662219f, -0.10286300f, -0.04042641f, -0.11492369f, -0.13918380f, 0.05529499f, 0.01560223f, 
    0.10160146f, 0.11426936f, 0.03480383f, 0.21211195f, 0.12944606f, -0.15291531f, -0.03700625f, -0.14208817f, 
    0.43650231f, 0.00974862f, 0.04841568f, -0.19980118f, 0.13010043f, 0.05961305f, -0.21250576f, -0.12492369f, 
    0.08147307f, -0.11297666f, -0.02077390f, -0.01567042f, -0.09903454f, -0.00158846f, 0.16768312f, 0.01226693f, 
    0.01769370f, -0.06479205f, 0.07158146f, -0.06756818f, 0.06348571f, 0.05592780f, 0.09871918f, 0.20126039f, 
    -0.04942988f, -0.08003743f, 0.01307717f, 0.20092969f, -0.07490139f, -0.00810364f, 0.09173946f, 0.17824906f, 
    0.03982392f, 0.03716165f, 0.17975789f, 0.24676947f, 0.25467288f, 0.15828981f, 0.06970859f, -0.17880100f, 
    -0.01149728f, -0.03347998f, -0.23169027f, 0.01120536f, 0.04717313f, -0.12964614f, -0.03590607f, 0.08820056f, 
    0.08445251f, -0.12898207f, 0.19333874f, 0.34844944f, -0.02888628f, -0.06335950f, -0.10406439f, 0.03575755f, 
    0.13809735f, 0.24314345f, 0.01839299f, 0.35075331f, 0.10701647f, 0.04471233f, 0.00155214f, -0.26617670f, 
    -0.13419428f, -0.06827255f, 0.01481857f, -0.04459106f, 0.08574928f, 0.00539455f, 0.19405244f, 0.10606682f, 
    0.07907036f, -0.24121340f, 0.00795547f, -0.11129395f, 0.08366837f, -0.24604462f, 0.08277266f, -0.01189386f, 
    -0.02052405f, -0.14585514f, -0.11322483f, -0.20620227f, 0.03478386f, -0.07725780f, 0.16732579f, 0.09928141f, 
    -0.05052881f, 0.13355972f, 0.20157897f, 0.08874056f, 0.18461803f, 0.06614724f, -0.10006766f, 0.24418454f, 
    -0.18938336f, -0.11118937f, -0.22518015f, 0.00793881f, 0.11445276f, 0.13456385f, -0.07392936f, -0.10431299f, 
    0.02710422f, 0.06778731f, 0.13550247f, 0.14104813f, -0.02686789f, 0.27987278f, 0.00086548f, -0.02946103f, 
    -0.16584665f, 0.01830363f, 0.07528012f, -0.16910507f, -0.01881105f, 0.12887488f, -0.01193464f, 0.05544510f, 
    -0.43371212f, -0.11093137f, 0.06592970f, -0.13037971f, 0.08716991f, 0.04823630f, 0.04464553f, 0.09040800f, 
    0.24461684f, 0.01017469f, -0.09938324f, 0.03939409f, -0.15511374f, -0.22293468f, -0.05860586f, 0.05239661f, 
    0.00089096f, -0.01757566f, 0.00996330f, -0.00075918f, 0.02986444f, -0.02387978f, 0.03017862f, -0.19414781f, 
    0.53644037f, 0.13299955f, 0.00772751f, 0.08796877f, -0.03738815f, -0.03367144f, 0.01396994f, 0.09271228f, 
    0.05591217f, 0.02835371f, 0.10414946f, 0.19612062f, 0.27219158f, 0.30695939f, 0.10695092f, -0.21470486f, 
    -0.21000345f, -0.10219809f, 0.06100218f, -0.03683159f, 0.06806433f, -0.24058853f, -0.27122319f, -0.06526626f, 
    -0.15137170f, -0.11488552f, -0.04924376f, -0.05118679f, 0.03509885f, 0.14520293f, -0.08879976f, 0.06309361f, 
    0.06956364f, -0.01164945f, 0.08672705f, 0.11212655f, 0.05603649f, 0.12237396f, 0.01092246f, -0.04564648f, 
    -0.04752000f, 0.12348258f, -0.06881735f, -0.12128277f, 0.18147956f, -0.01502818f, 0.03966319f, 0.02945088f, 
    0.07245706f, -0.09642950f, -0.07025217f, -0.02318705f, 0.03865028f, 0.08791848f, 0.20418090f, -0.09209981f, 
    0.09106306f, -0.04206621f, -0.12826736f, 0.02798841f, 0.36072445f, 0.10148560f, -0.03189806f, -0.09669795f, 
    0.30759287f, 0.12240265f, 0.04024894f, -0.13177057f, 0.02457400f, 0.07354239f, 0.03399453f, 0.11340945f, 
    0.17955306f, -0.04175801f, 0.05288851f, 0.07110232f, 0.14403626f, -0.01728699f, 0.03440651f, 0.15899739f, 
    0.07039158f, -0.01545602f, 0.03727653f, 0.14805976f, -0.44386888f, 0.18213369f, 0.10586784f, -0.00254721f, 
    0.13480718f, 0.06957743f, -0.19307551f, -0.04409717f, 0.09640384f, 0.14778392f, -0.07065614f, 0.12163159f, 
    -0.27479088f, -0.24965437f, 0.01497902f, -0.03484474f, 0.07436667f, -0.04787752f, -0.09001770f, 0.10764990f, 
    0.14429560f, 0.22333844f, 0.06340816f, 0.28812456f, 0.02480436f, -0.06974508f, -0.31617826f, -0.27670211f, 
    -0.12177987f, 0.00512434f, -0.08660925f, -0.05139735f, 0.01921143f, -0.02552956f, 0.06311692f, 0.17827064f, 
    0.12438130f, 0.05495190f, 0.11541998f, 0.20086531f, 0.12422139f, -0.05242492f, 0.07962397f, 0.08486751f, 
    0.08356117f, 0.04972096f, 0.02797020f, 0.05722977f, -0.39411139f, -0.06711122f, -0.00912795f, 0.03793336f, 
    -0.04838397f, 0.01014920f, 0.09492851f, 0.11797293f, 0.09201279f, -0.08240007f, 0.21811892f, -0.05146761f, 
    0.02260056f, 0.07116219f, 0.14232191f, -0.13499199f, -0.12337827f, -0.05668132f, -0.09169788f, 0.10352472f, 
    0.11661788f, 0.04094499f, -0.05795687f, -0.08836512f, 0.46270794f, -0.06630845f, -0.19888893f, -0.00304207f, 
    -0.10345560f, -0.02370789f, -0.04680499f, 0.00908133f, -0.13482361f, 0.07984027f, 0.08109502f, -0.10354681f, 
    0.33062786f, -0.24404240f, 0.04053776f, -0.00145097f, -0.00945031f, 0.17697741f, 0.07395082f, -0.05219025f, 
    -0.03916848f, -0.04775370f, 0.03819136f, 0.11708341f, 0.00673355f, -0.01039844f, 0.19215089f, 0.14597797f, 
    -0.05404370f, 0.00687777f, 0.14190538f, -0.08324119f, -0.07144377f, -0.04444613f, -0.09739713f, 0.15608679f, 
    -0.01287634f, 0.14633837f, 0.02084504f, 0.16291714f, -0.07964025f, -0.00893285f, 0.01359513f, 0.05060070f, 
    0.03162945f, 0.06424637f, -0.02379801f, 0.04563085f, -0.20659818f, 0.16463760f, 0.23517776f, -0.12474062f, 
    0.02675000f, -0.02361008f, 0.19584164f, -0.11824860f, -0.07111105f, 0.04086190f, 0.21467736f, -0.01484737f, 
    0.10724203f, 0.20886795f, -0.01385932f, -0.12113497f, -0.05231731f, -0.14145513f, 0.05253544f, 0.07554995f, 
    -0.11424515f, -0.02165422f, 0.12201679f, 0.20401770f, 0.14356378f, 0.01202154f, 0.15381096f, -0.07227794f, 
    -0.01108958f, -0.05700520f, 0.02276893f, 0.12213697f, 0.01817388f, 0.07261981f, -0.08527862f, 0.04668695f, 
    -0.27274767f, -0.06257355f, -0.10515517f, -0.02480902f, 0.03903040f, -0.05667042f, 0.29237968f, 0.07789346f, 
    0.05378145f, 0.09802125f, 0.00099066f, -0.05403502f, -0.00051039f, -0.11147352f, 0.10262213f, -0.01526879f, 
    0.11219075f, -0.06281336f, -0.07711983f, 0.00912286f, -0.05299384f, -0.20936812f, 0.06624158f, -0.05034243f, 
    0.12075557f, -0.05684779f, 0.07856030f, 0.25698650f, 0.11851009f, 0.11298174f, -0.15761277f, -0.09190909f, 
    0.15367387f, 0.22360753f, 0.01145477f, -0.09974609f, -0.05435157f, -0.15064210f, -0.13893044f, 0.03689498f, 
    0.06148482f, 0.10139751f, 0.05205281f, -0.08690849f, -0.03460223f, 0.16583799f, -0.00394091f, 0.08591327f, 
    0.04831655f, 0.05133064f, -0.08797956f, -0.16963828f, -0.06450411f, 0.21238759f, 0.05937484f, 0.02568978f, 
    0.08834922f, -0.14679816f, 0.03567689f, -0.07422752f, -0.18417110f, -0.19587837f, -0.22071412f, 0.21870518f, 
    -0.02330502f, -0.01202815f, 0.05156443f, 0.03279909f, -0.04383199f, -0.01468055f, -0.20820938f, 0.00476557f, 
    -0.42335820f, -0.04323784f, 0.09126955f, -0.10170248f, -0.05759906f, -0.00685158f, -0.00667127f, 0.00805703f, 
    0.07341588f, 0.00634038f, 0.05996977f, 0.06724301f, 0.12353160f, -0.04150940f, 0.09256404f, 0.08587427f, 
    0.09881923f, -0.12496852f, 0.07663645f, -0.08418142f, 0.02281871f, 0.01074071f, 0.03964337f, 0.09374017f, 
    0.12984951f, 0.14637767f, 0.29475868f, 0.04064347f, 0.06149489f, -0.03817390f, -0.10455254f, -0.00651117f, 
    -0.08662889f, 0.04568473f, -0.04870025f, 0.12234842f, 0.44172722f, 0.20102981f, -0.12163554f, 0.00481585f, 
    -0.02315097f, -0.03338809f, 0.04534550f, -0.04846198f, -0.01613345f, -0.10484279f, 0.09416118f, 0.07374886f, 
    0.19189335f, -0.30919242f, -0.14275862f, 0.00770148f, -0.11402737f, -0.08744057f, 0.10791990f, 0.11021960f, 
    0.07014223f, 0.12555459f, 0.05303653f, -0.07611549f, -0.20422681f, 0.40308741f, 0.18794356f, 0.09319211f, 
    0.04195746f, -0.10343426f, -0.00787772f, 0.03446359f, -0.02462665f, -0.15683250f, -0.06740943f, -0.08282181f, 
    -0.50339788f, 0.11124240f, -0.10015319f, -0.04727834f, 0.09202692f, -0.06169348f, -0.05557055f, 0.07997086f, 
    0.06491491f, -0.01610483f, 0.02358154f, 0.10868052f, -0.40081871f, 0.04445108f, 0.12636466f, 0.10334200f, 
    0.05967541f, -0.00575765f, 0.13993660f, 0.03713647f, 0.03559900f, 0.02472319f, 0.11838643f, -0.02116893f, 
    0.38266641f, 0.51092124f, 0.18616438f, 0.13589530f, 0.00680746f, -0.02782165f, 0.04852620f, 0.12364909f, 
    -0.01900833f, -0.14575103f, 0.01718865f, -0.00048303f, 0.04010580f, -0.16884916f, -0.05529676f, -0.10058343f, 
    0.06682242f, 0.10959088f, 0.11561087f, 0.02279753f, 0.05510864f, -0.22390583f, 0.05981370f, -0.15731321f, 
    0.34563732f, -0.00706244f, 0.02745991f, 0.14241093f, 0.02416427f, 0.01281468f, 0.05169803f, 0.05511459f, 
    -0.12932825f, -0.04555587f, 0.04652542f, 0.07662435f, -0.24842162f, -0.02222870f, -0.07971285f, -0.28369823f, 
    -0.05844498f, -0.04825249f, 0.09888122f, 0.03469487f, -0.08702615f, -0.13377884f, 0.13243128f, 0.14420253f, 
    -0.02061215f, -0.16330284f, 0.05479277f, -0.00212327f, 0.02493380f, 0.13338508f, 0.07378235f, -0.11660609f, 
    0.00276232f, 0.09058088f, 0.13934138f, 0.03909101f, -0.15650617f, -0.10018964f, -0.07806685f, -0.19970685f, 
    -0.07206506f, 0.05565428f, -0.04577120f, -0.21274436f, 0.16705158f, 0.04877589f, 0.14490485f, 0.04985179f, 
    0.08205087f, 0.17862369f, -0.04883430f, 0.04674806f, 0.21770822f, 0.00412391f, -0.09710072f, 0.16335280f, 
    0.09962766f, 0.21422593f, 0.03700770f, 0.15770482f, -0.02922805f, 0.23454164f, -0.17570612f, -0.17938599f, 
    0.04904504f, -0.03542596f, 0.00096746f, -0.16985175f, -0.03532350f, -0.00262258f, 0.07066789f, 0.01376813f, 
    -0.15070130f, 0.35884342f, -0.07295096f, 0.02046522f, -0.08723681f, 0.03190213f, -0.19480391f, 0.04146828f, 
    0.00193891f, -0.00632384f, 0.04651510f, -0.06111211f, -0.14490892f, 0.01342756f, -0.02729502f, 0.20269847f, 
    0.03853983f, 0.17642550f, -0.07753401f, 0.12678981f, 0.17424899f, -0.22294725f, 0.03265873f, 0.01979958f, 
    -0.66766220f, 0.06105159f, 0.02300180f, -0.05119089f, 0.28130639f, 0.20151097f, 0.02439980f, -0.10499145f, 
    0.09964763f, 0.07140072f, 0.09142814f, -0.10488896f, 0.15574223f, 0.24661143f, 0.12335884f, 0.10857643f, 
    -0.06296662f, -0.09518245f, -0.06125531f, 0.17602313f, 0.00079572f, 0.01193250f, 0.07354363f, 0.21257341f, 
    -0.20582902f, 0.04929643f, -0.11711165f, 0.12366487f, -0.14307205f, 0.21881251f, 0.02540568f, -0.08624690f, 
    0.18339430f, -0.00028548f, 0.07147542f, 0.07942908f, 0.17882721f, 0.04073011f, 0.01029243f, -0.11587912f, 
    0.01210284f, 0.09296398f, 0.00536018f, -0.10255481f, 0.09710303f, 0.03738909f, 0.02996746f, 0.06933282f, 
    0.42752632f, -0.10471747f, 0.28045741f, 0.04569106f, -0.20334975f, 0.08011163f, -0.05966359f, -0.02027936f, 
    0.12973349f, 0.12633158f, -0.02399355f, -0.04782508f, 0.04346579f, -0.04937835f, 0.30723611f, 0.29850659f, 
    -0.23345917f, -0.01452490f, 0.12400878f, 0.02657588f, -0.08463896f, 0.03502728f, -0.05075878f, 0.01345140f, 
    -0.04831659f, 0.01477006f, -0.29314706f, -0.03603762f, 0.24182194f, 0.01619887f, -0.18082571f, 0.10238498f, 
    0.00651091f, -0.00973611f, 0.05479693f, 0.07451683f, -0.07830878f, 0.16030294f, 0.03038859f, 0.01041250f, 
    0.02807019f, 0.05834245f, -0.07254577f, -0.19203568f, 0.06397223f, -0.00343600f, 0.17163576f, 0.18946178f, 
    -0.29815280f, 0.02891530f, -0.05085472f, 0.29088932f, -0.21535490f, 0.08698036f, 0.02110816f, 0.02950808f, 
    -0.03151465f, 0.03066637f, 0.10609654f, 0.00544424f, 0.19679435f, 0.23834428f, -0.21098843f, -0.30376855f, 
    0.06034901f, 0.20364915f, 0.00813094f, 0.02575012f, 0.11535925f, 0.12316886f, -0.05167971f, -0.05250679f, 
    -0.07831601f, 0.07694186f, 0.13124056f, -0.19866431f, 0.13079096f, 0.01839137f, -0.00518810f, -0.03532212f, 
    0.03518535f, -0.02294534f, -0.00899051f, -0.04266933f, 0.12351301f, 0.00089504f, -0.06233934f, -0.11947026f, 
    0.02778080f, 0.17498712f, 0.11972757f, 0.07983457f, 0.17713076f, 0.21407707f, 0.04134057f, 0.00423460f, 
    -0.22173800f, 0.18371332f, -0.13067898f, -0.15849221f, 0.12387918f, -0.15827914f, 0.08397239f, -0.02619855f, 
    -0.13798055f, -0.02046165f, 0.14105143f, -0.01509534f, -0.02552512f, 0.23911238f, 0.08985802f, 0.14209121f, 
    0.13871947f, -0.04111876f, -0.06618362f, 0.06059727f, -0.01688210f, 0.02551954f, -0.04987249f, -0.05195113f, 
    -0.10381353f, 0.00641850f, -0.15649542f, -0.08508620f, 0.03056989f, -0.01123038f, 0.09335370f, 0.05906700f, 
    0.06427003f, 0.16930762f, -0.02251273f, -0.15178794f, 0.10014681f, 0.03719617f, -0.18669116f, 0.01470520f, 
    0.01087164f, 0.20523936f, -0.19271193f, 0.04037501f, -0.02809380f, 0.02313634f, -0.08622503f, 0.15764278f, 
    -0.22589557f, 0.06023756f, 0.07675397f, -0.07010425f, -0.00646508f, -0.01411106f, 0.17189291f, -0.05086335f, 
    -0.11145291f, -0.07171787f, 0.05275907f, 0.05193547f, -0.09519652f, 0.06431896f, 0.09562223f, 0.22868225f, 
    0.05488636f, 0.02936002f, 0.11804073f, -0.07605080f, 0.21008886f, 0.01586720f, -0.02852325f, 0.20744595f, 
    -0.04778718f, -0.15715925f, 0.11347834f, 0.06750886f, -0.07702705f, 0.01809294f, 0.11339276f, 0.06477065f, 
    -0.06943378f, -0.03007888f, -0.02885271f, -0.15934831f, 0.27972379f, 0.23961261f, -0.09481317f, 0.02204628f, 
    -0.02960486f, -0.14853899f, -0.31660381f, -0.10646193f, -0.08515427f, 0.00875313f, -0.02064283f, -0.23389503f, 
    -0.11562896f, -0.11508086f, 0.06710444f, -0.35835201f, 0.04955736f, 0.08977956f, 0.00333203f, 0.10194191f, 
    0.07978025f, 0.01876052f, -0.04577146f, 0.10706740f, 0.02481178f, 0.03726775f, -0.17103328f, 0.18307367f, 
    0.12621877f, 0.05515423f, -0.10178572f, 0.08353054f, 0.13946228f, -0.24490522f, -0.15608022f, -0.03186991f, 
    -0.02436884f, -0.13121058f, 0.16210535f, 0.11150870f, -0.07783775f, -0.02289286f, 0.08700436f, 0.06788196f, 
    0.14415941f, -0.13271345f, -0.15065013f, -0.10517868f, 0.11753947f, -0.00596108f, 0.19053979f, 0.21304747f, 
    0.13374227f, 0.16625047f, 0.03998696f, 0.01762416f, 0.06380332f, -0.24140851f, 0.06251828f, -0.06987683f, 
    0.34469217f, 0.04273073f, -0.03685777f, -0.29956880f, -0.05208470f, -0.02572949f, -0.27735940f, -0.14776823f, 
    0.02780128f, -0.11771508f, 0.00976736f, -0.01356803f, 0.08512735f, 0.08052656f, 0.09082516f, 0.04724352f, 
    -0.12064295f, 0.01905471f, -0.01064726f, -0.07496162f, 0.01671631f, 0.10924368f, 0.09708637f, 0.22623025f, 
    0.18284941f, 0.18347538f, 0.08055367f, -0.16379932f, 0.02019854f, 0.09198100f, 0.07775450f, -0.02912427f, 
    -0.06878959f, -0.21657835f, 0.12159536f, 0.09815690f, -0.11112696f, -0.01032105f, -0.02294544f, 0.23851496f, 
    -0.08813330f, -0.02938942f, -0.02563195f, 0.15231191f, -0.00949315f, -0.14201808f, 0.15952003f, -0.08911452f, 
    -0.22425917f, 0.06680080f, 0.13634577f, -0.03167555f, 0.06541368f, -0.06694529f, -0.00801655f, -0.06219427f, 
    0.03297240f, 0.25242344f, 0.08489816f, 0.17963056f, -0.06210798f, 0.33338845f, -0.27945259f, 0.13307242f, 
    0.05717689f, -0.06749489f, -0.04054801f, 0.02210568f, 0.01170393f, -0.02326539f, 0.09734301f, 0.05390015f, 
    0.16112806f, 0.26565427f, -0.08961201f, 0.29228953f, -0.01923415f, 0.01470230f, -0.05354296f, -0.01587700f, 
    -0.00335407f, 0.09806615f, 0.05522924f, 0.15805236f, -0.40120620f, 0.00496887f, -0.00423502f, -0.07099949f, 
    0.13809246f, 0.04356737f, -0.02625308f, 0.08445172f, 0.02117891f, 0.04837136f, 0.21995325f, -0.02275724f, 
    -0.38991114f, -0.02897407f, -0.00799283f, -0.13660182f, 0.06251921f, 0.01866078f, 0.06414302f, -0.04806526f, 
    -0.01002842f, -0.05212981f, -0.06118253f, -0.10768661f, 0.14462048f, -0.09481600f, 0.00462263f, 0.14714600f, 
    0.11908803f, 0.00376170f, -0.03232508f, 0.13800037f, -0.04593860f, 0.02415349f, -0.15949138f, 0.13501883f, 
    0.22827134f, 0.14593805f, -0.06758033f, 0.28449649f, 0.04715705f, 0.06499730f, 0.04262694f, -0.06518472f, 
    -0.11393429f, 0.01605496f, -0.02726765f, 0.08661806f, 0.01905645f, 0.05782321f, 0.04205957f, 0.02072794f, 
    0.07486069f, 0.19469589f, 0.09606526f, 0.02766554f, -0.00908173f, -0.12864305f, 0.00868766f, 0.22177210f, 
    -0.46024397f, 0.12781052f, 0.08184888f, -0.05426595f, 0.08696020f, -0.04903535f, -0.06880951f, -0.06048425f, 
    0.01071657f, 0.14010170f, -0.08927444f, -0.13402754f, 0.09677999f, 0.02204056f, -0.00886827f, 0.12946188f, 
    0.06859677f, 0.08362873f, 0.12581871f, -0.00081512f, -0.12643886f, 0.07133729f, 0.09062473f, 0.08152262f, 
    -0.33399236f, -0.07658014f, -0.03303863f, -0.07262076f, -0.01080812f, -0.14718509f, -0.02202907f, 0.03311047f, 
    0.05769142f, -0.03949299f, 0.05583798f, -0.05622926f, 0.04046401f, 0.09691756f, 0.17464657f, 0.25908381f, 
    0.09859074f, -0.07352110f, -0.03541455f, 0.05243742f, -0.12708046f, 0.11222285f, 0.10745668f, 0.11746494f, 
    -0.16985331f, 0.12049003f, 0.01198800f, -0.14232691f, 0.06677019f, 0.12191413f, 0.11818106f, 0.09322847f, 
    -0.05740936f, 0.15838642f, -0.12008464f, -0.05191243f, 0.03671267f, -0.06812236f, 0.15668692f, 0.37216923f, 
    -0.01031082f, -0.10454340f, -0.05666400f, 0.05703803f, -0.04847908f, -0.04814501f, 0.01919663f, -0.11350718f, 
    -0.03401346f, 0.11693366f, 0.00795257f, 0.11768166f, 0.02244255f, -0.03947961f, 0.06351514f, -0.11872540f, 
    -0.14524207f, 0.16949368f, -0.05343803f, -0.09547609f, 0.34102759f, -0.09559682f, -0.05964844f, 0.11747089f, 
    -0.04724012f, 0.07911078f, 0.22038856f, 0.16166919f, -0.01054567f, 0.00281471f, 0.01531866f, 0.01016418f, 
    -0.13180752f, 0.17929882f, -0.08240393f, -0.12000603f, -0.03347959f, 0.07588737f, 0.18413274f, 0.02170935f, 
    -0.05066235f, -0.03562764f, -0.10620189f, -0.06805565f, -0.27386925f, 0.10048565f, 0.34632611f, 0.17482692f, 
    0.04825925f, -0.04431721f, 0.10103706f, -0.03946748f, 0.07067835f, -0.00155195f, -0.10898852f, -0.00445306f, 
    0.29396057f, 0.05578259f, -0.17004152f, 0.02587961f, -0.00145327f, 0.07953277f, 0.05367569f, -0.04011175f, 
    0.13618803f, 0.04575757f, 0.01617589f, 0.13442713f, 0.15092374f, -0.09833889f, -0.10785004f, 0.03775563f, 
    -0.12771384f, -0.05177458f, 0.01223731f, 0.03114137f, -0.07527924f, -0.10420408f, 0.04311680f, -0.11135598f, 
    0.04224150f, -0.01138603f, 0.00223137f, 0.21509850f, -0.05493707f, 0.07692095f, 0.06851637f, 0.04114683f, 
    0.16024603f, 0.01083079f, -0.01808497f, 0.08549190f, -0.39023748f, -0.29960218f, -0.07341595f, -0.17788477f, 
    -0.16712339f, 0.01875479f, -0.05636591f, 0.03335379f, 0.12211972f, 0.14187028f, 0.08610892f, -0.03693404f, 
    0.12670749f, -0.02800274f, 0.20984821f, -0.10790803f, -0.06252775f, 0.01744108f, -0.04235155f, -0.04856021f, 
    0.05500408f, 0.11296748f, -0.10092413f, 0.13624381f, 0.12244094f, -0.25736752f, -0.03613776f, 0.02617176f, 
    0.01509275f, 0.20701167f, -0.04128586f, 0.00690626f, 0.03752963f, 0.20410722f, 0.12380912f, 0.08611954f, 
    0.62205935f, -0.11612878f, -0.04196395f, 0.16205232f, -0.11974537f, 0.08755161f, 0.03316741f, 0.09448397f, 
    0.01168130f, -0.02312861f, 0.04688961f, -0.04678622f, 0.19004597f, -0.38540351f, -0.13652202f, -0.11949659f, 
    -0.16977851f, -0.03193325f, -0.12166066f, 0.08276159f, 0.07663129f, 0.00114109f, 0.11856993f, 0.13575771f, 
    -0.01248893f, -0.16523117f, 0.00389675f, 0.12061509f, 0.10097133f, 0.12278027f, 0.00292976f, 0.15613638f, 
    0.06848933f, 0.06650402f, 0.11091708f, 0.00291951f, 0.10199714f, 0.25188267f, 0.01881264f, -0.14053127f, 
    -0.06192544f, -0.19037704f, -0.06771651f, -0.05533069f, -0.04126739f, 0.28200400f, 0.04421354f, 0.31285778f, 
    -0.38575548f, -0.11900356f, -0.07224291f, 0.07571075f, -0.07575064f, -0.12572017f, 0.04424518f, 0.05987708f, 
    0.00428687f, -0.04514517f, -0.00810068f, 0.24979451f, 0.05852801f, -0.02610663f, 0.03690551f, -0.07753222f, 
    0.03650391f, 0.00316751f, 0.06333508f, -0.03986562f, 0.16923992f, 0.10082218f, -0.18264376f, -0.17780775f, 
    -0.13146469f, -0.02680372f, -0.00409788f, -0.05145397f, 0.12220829f, -0.01331474f, -0.04126650f, 0.10618410f, 
    0.02156809f, -0.04679427f, -0.24256280f, -0.17190720f, -0.19516708f, -0.10142247f, 0.09227034f, 0.07486872f, 
    0.02654042f, 0.01175527f, 0.22491635f, -0.04784721f, 0.08365431f, 0.10181415f, 0.00347923f, 0.06699017f, 
    0.08385996f, -0.19835025f, 0.05024897f, 0.07785524f, -0.09021144f, 0.07525894f, -0.09425654f, -0.03401627f, 
    -0.19688122f, -0.30998424f, 0.09955733f, -0.15376785f, 0.27990019f, -0.29081464f, 0.01262499f, 0.12107342f, 
    0.03220169f, 0.03647117f, -0.06983715f, 0.11564918f, -0.02370944f, 0.09890244f, -0.09606830f, 0.00947066f, 
    -0.21543738f, -0.01501765f, 0.00255782f, -0.20502619f, -0.00701618f, 0.10475636f, -0.14566499f, -0.01267824f, 
    -0.08545402f, 0.09946727f, -0.05958762f, 0.00715042f, 0.27336264f, 0.16275463f, 0.08845235f, 0.21786159f, 
    -0.00797288f, -0.05802299f, 0.09319410f, -0.01118574f, -0.02439015f, 0.06120629f, 0.02700599f, -0.01887968f, 
    0.12915470f, 0.31648791f, 0.05518579f, -0.25501758f, -0.03752672f, -0.09059083f, 0.00186269f, 0.05354919f, 
    0.04122748f, 0.08648650f, 0.07208197f, 0.17728855f, -0.14804611f, 0.19532809f, 0.11982698f, -0.11938736f, 
    -0.09488446f, -0.00757919f, 0.05959435f, 0.05551826f, 0.11622142f, -0.02597300f, 0.22616123f, 0.01525516f, 
    -0.40911198f, 0.04527172f, -0.10441653f, -0.04777771f, 0.05869845f, 0.07303720f, 0.04209102f, -0.01787914f, 
    0.07343916f, 0.04559884f, 0.05068792f, 0.09231384f, 0.34136191f, -0.06168911f, -0.00934764f, 0.04852076f, 
    0.01721515f, -0.11574687f, 0.19038071f, -0.06511065f, 0.05212187f, -0.02469636f, 0.00547461f, 0.17857458f, 
    0.44281331f, -0.19483614f, -0.02754863f, 0.01367317f, -0.04946589f, 0.05853850f, -0.07224277f, -0.06917985f, 
    -0.02184887f, -0.13776730f, 0.14299396f, -0.00594151f, 0.01887452f, -0.10031815f, -0.01765930f, 0.07624448f, 
    0.09970525f, -0.12261930f, 0.15299034f, 0.09407021f, 0.10551262f, -0.14582770f, 0.06734239f, 0.01612450f, 
    0.35475841f, 0.20485230f, -0.06470851f, -0.12140046f, 0.08847439f, 0.16232495f, 0.01819028f, 0.01601988f, 
    -0.15804355f, 0.04879795f, 0.11146327f, 0.17805336f, -0.08738373f, -0.18718578f, -0.17661405f, -0.23284754f, 
    -0.06589130f, 0.06310756f, 0.06534955f, 0.04220352f, 0.03778787f, 0.00003239f, -0.06263860f, -0.04406758f, 
    0.08253696f, -0.03783371f, 0.20623402f, 0.22797666f, 0.05846802f, 0.04859511f, 0.03350829f, 0.17217086f, 
    0.12376818f, -0.02860183f, 0.05661508f, 0.01207325f, -0.19414292f, 0.00241507f, -0.15273134f, -0.33873668f, 
    0.06036318f, -0.00392289f, 0.11509728f, -0.06311563f, -0.02591681f, 0.13811290f, -0.01819589f, 0.04608023f, 
    -0.13732013f, 0.04884611f, -0.10590147f, -0.22053902f, 0.07865675f, 0.02713531f, -0.18507038f, 0.20352651f, 
    0.06607617f, -0.02477880f, 0.00568960f, -0.12161304f, 0.04061443f, 0.23993473f, 0.07471969f, 0.03176003f, 
    -0.04578410f, -0.09384864f, -0.02675675f, -0.08058814f, 0.00386868f, -0.01829883f, 0.01469348f, 0.00719468f, 
    -0.00831422f, 0.16044511f, -0.03362589f, -0.18440279f, 0.08575480f, -0.06884341f, -0.12512563f, -0.03829967f, 
    -0.04839590f, -0.09477296f, -0.12413542f, -0.10648234f, 0.22319660f, -0.14983189f, 0.24408112f, -0.02124960f, 
    0.15820661f, 0.11371186f, -0.04400163f, 0.02337215f, 0.02135019f, 0.10556386f, 0.09551559f, -0.08114950f, 
    -0.23035106f, 0.25440589f, 0.17830299f, 0.01332544f, -0.01261090f, 0.10094369f, -0.23775652f, 0.02372619f, 
    0.02899503f, -0.07588345f, 0.04134414f, 0.10365698f, -0.11821415f, 0.11934114f, 0.06427589f, 0.15590851f, 
    0.07401820f, -0.04104013f, 0.05652562f, 0.03220116f, 0.14731298f, -0.22190215f, 0.08232664f, -0.03511072f, 
    -0.27527842f, -0.04886432f, 0.07022692f, 0.08134012f, 0.17308506f, 0.02292597f, -0.04260389f, -0.09957600f, 
    0.02636527f, 0.07969264f, 0.04615876f, -0.19196351f, 0.27376527f, 0.19711293f, -0.04455505f, 0.06726316f, 
    0.04292870f, -0.01192245f, 0.00491487f, 0.12041529f, -0.20423757f, -0.14559323f, 0.11042703f, 0.07313700f, 
    -0.03839481f, 0.22320442f, -0.24695407f, 0.11324155f, -0.07850104f, 0.07807367f, -0.00625588f, 0.01696646f, 
    0.06337441f, 0.01293001f, 0.01232177f, -0.06896401f, -0.08092203f, 0.13516989f, 0.09381919f, -0.12525007f, 
    0.07032114f, 0.14162827f, -0.01513376f, -0.03940218f, 0.02470902f, 0.02229425f, 0.00277586f, 0.17772955f, 
    -0.20257339f, 0.00926660f, 0.11077119f, 0.11903077f, -0.04355546f, -0.08755477f, 0.06872577f, -0.04648836f, 
    0.08140038f, 0.13538489f, -0.06222273f, 0.06716865f, -0.40471002f, 0.01697180f, 0.32098532f, 0.21876112f, 
    -0.05589785f, -0.00594568f, 0.18864839f, 0.18638653f, -0.22966093f, 0.23098971f, 0.10258663f, 0.00833428f, 
    0.09573897f, 0.19680366f, -0.08379868f, -0.04202019f, 0.12824970f, -0.13930495f, -0.03080493f, -0.11721246f, 
    -0.05099716f, -0.02904826f, 0.04923563f, 0.08701757f, -0.12512791f, -0.05487614f, -0.12757441f, -0.02161305f, 
    -0.05793140f, -0.10763164f, -0.02675822f, -0.01997061f, -0.10098896f, 0.08439274f, 0.11340749f, 0.06571548f, 
    -0.21449102f, 0.10240355f, -0.02200507f, 0.28272161f, -0.05409964f, 0.03915630f, 0.07290686f, 0.10982742f, 
    -0.06076319f, 0.12176579f, 0.14076091f, -0.03148397f, -0.16448255f, 0.07872566f, -0.15495026f, -0.30463517f, 
    0.00564532f, 0.10951359f, 0.00807508f, 0.11764885f, 0.08857482f, -0.09975323f, 0.01196371f, -0.12892464f, 
    -0.14149056f, 0.00881615f, 0.08375359f, -0.05091711f, -0.05903424f, 0.06699572f, 0.05436252f, -0.16449119f, 
    -0.00399996f, 0.13915899f, -0.07979146f, 0.01667145f, 0.33498484f, -0.06878743f, -0.11862262f, -0.32109484f, 
    -0.03582033f, 0.08807524f, 0.00655612f, 0.01333265f, 0.06143922f, 0.18439405f, 0.03320677f, -0.00089685f, 
    0.04597171f, 0.16968802f, -0.19935067f, 0.17207848f, 0.12542675f, -0.01778231f, 0.05114069f, 0.03863065f, 
    -0.08625095f, 0.04744239f, -0.06694953f, -0.09856924f, -0.14633147f, 0.29775172f, 0.24409644f, -0.03572179f, 
    0.07664659f, -0.07700626f, 0.02467479f, -0.07715654f, 0.07435628f, -0.12313507f, -0.01798170f, -0.05739497f, 
    -0.01839210f, 0.24450164f, -0.18609034f, 0.16393934f, 0.07806803f, 0.13679452f, 0.00611724f, -0.01584195f, 
    0.01246624f, 0.09780193f, -0.03318035f, -0.02822854f, -0.06482241f, -0.00796908f, 0.03915538f, -0.01153252f, 
    0.07865568f, 0.04634316f, -0.09940165f, 0.02514881f, -0.00780041f, 0.00506089f, -0.00878664f, 0.07276049f, 
    -0.27399504f, -0.00651624f, -0.07323112f, -0.14151235f, 0.10847139f, 0.02467071f, 0.07780741f, -0.02285870f, 
    -0.08571333f, -0.02918299f, -0.01136053f, 0.08923130f, 0.03834565f, 0.24900872f, 0.13294823f, 0.30009398f, 
    0.09576871f, 0.07714555f, 0.00751849f, -0.04126282f, -0.03647680f, 0.11837184f, 0.07907797f, 0.07295161f, 
    -0.08165654f, 0.12740542f, -0.01643429f, 0.20776083f, -0.04655031f, -0.10933928f, 0.10023695f, -0.06794932f, 
    0.04197141f, 0.05121441f, 0.03293480f, -0.03395912f, -0.01029063f, 0.21939723f, 0.02819357f, -0.09307539f, 
    -0.02899239f, -0.07760761f, -0.10283995f, 0.01035955f, -0.02411363f, -0.05333633f, -0.03081185f, -0.07749089f, 
    0.16470744f, -0.09446197f, 0.06241290f, -0.34524843f, 0.01358232f, 0.11119120f, 0.01502396f, 0.14551330f, 
    -0.02768683f, -0.01935095f, 0.03801151f, -0.08599827f, 0.28698957f, 0.31605089f, 0.09880786f, 0.42986640f, 
    0.10725467f, 0.04264694f, 0.07782188f, -0.02390298f, -0.00963807f, 0.06481130f, -0.05151191f, -0.05093942f, 
    -0.09467199f, -0.15837282f, -0.02615504f, -0.16038823f, 0.01328175f, 0.10001309f, 0.01201052f, 0.07605521f, 
    0.01285329f, 0.04917395f, -0.01184159f, -0.02388972f, 0.09825606f, 0.00376012f, 0.10880857f, 0.29320148f, 
    0.06807347f, 0.05121786f, 0.08836912f, 0.09827621f, 0.01573658f, -0.11900227f, 0.09487363f, 0.00854357f, 
    0.14999670f, 0.04200643f, 0.09468178f, -0.09911701f, 0.01413504f, 0.03210660f, -0.07128182f, -0.06308819f, 
    0.03305259f, 0.04383321f, -0.02706157f, -0.18440525f, 0.19700371f, -0.00323382f, 0.01993651f, 0.41220692f, 
    -0.20207077f, -0.03503330f, -0.08118209f, 0.04348415f, -0.09166382f, 0.07980831f, 0.02975325f, 0.16675393f, 
    0.01042742f, 0.30149090f, -0.16291043f, -0.25138515f, 0.02556847f, 0.07521681f, 0.06415888f, -0.05121545f, 
    -0.11312015f, -0.01066362f, 0.16585958f, 0.12371996f, -0.10059139f, 0.16595867f, -0.00453029f, 0.08652291f, 
    -0.13565961f, -0.06164367f, 0.09852926f, 0.09675754f, -0.08085492f, -0.05157115f, 0.11378656f, -0.03138599f, 
    -0.40863386f, 0.00164593f, 0.13864988f, -0.37720290f, 0.25933340f, -0.16018805f, 0.10349907f, 0.01626127f, 
    0.02805008f, -0.03218430f, -0.02268832f, 0.12068915f, -0.19489467f, -0.11149622f, 0.03183185f, 0.17284313f, 
    0.10575446f, -0.20372862f, 0.00081708f, -0.04076525f, 0.09040339f, -0.07776590f, 0.10113795f, -0.12014557f, 
    0.00446473f, -0.06411675f, 0.02651542f, -0.02312471f, 0.02264558f, -0.06401040f, -0.05909345f, 0.00056973f, 
    0.04048846f, -0.01949809f, -0.07482696f, -0.06238595f, -0.06305850f, 0.00193851f, 0.03460049f, 0.01640404f, 
    -0.05225801f, -0.05894162f, -0.03307727f, 0.05036711f, -0.04757201f, -0.00984316f, 0.00682352f, -0.06377043f, 
    -0.01735216f, -0.05937572f, 0.06036596f, -0.00957127f, -0.07143567f, 0.02689592f, -0.03233122f, -0.05092089f, 
    -0.01401041f, -0.02983950f, -0.01807396f, 0.01884111f, 0.00012581f, -0.06344171f, 0.00528427f, 0.04860442f, 
    -0.04733970f, -0.03535394f, 0.05655523f, 0.05876676f, -0.01201840f, 0.00616331f, 0.00148197f, -0.01836809f, 
    0.04849194f, 0.01049130f, 0.05393188f, -0.04702140f, -0.04967763f, 0.05225383f, -0.05012477f, -0.03778626f, 
    0.04224559f, -0.04835321f, 0.02737268f, -0.07686678f, 0.05279527f, -0.01713164f, -0.01078176f, 0.00799511f, 
    -0.06199128f, 0.05457345f, -0.02915004f, -0.00208301f, -0.06705158f, -0.02202233f, -0.06874970f, 0.02335124f, 
    0.06272058f, -0.04431506f, -0.00288637f, 0.02146634f, 0.04386932f, 0.03689593f, -0.02112903f, 0.04197472f, 
    0.02854159f, -0.06627703f, -0.00746808f, -0.07535198f, 0.06094902f, 0.04483764f, 0.03521552f, -0.05678108f, 
    -0.07854094f, 0.02058277f, -0.00517819f, 0.02584272f, -0.07422779f, -0.06964084f, -0.07247408f, 0.04980844f, 
    0.02963335f, -0.00402979f, 0.01560187f, -0.00227237f, -0.06991544f, 0.01834423f, 0.00521507f, 0.02919591f, 
    -0.02920696f, -0.05742901f, -0.02774546f, 0.05402006f, -0.07158992f, 0.02339376f, -0.01599066f, -0.06356699f, 
    0.04489821f, -0.03641204f, 0.00449293f, -0.00811502f, -0.02635828f, 0.04987587f, -0.06456479f, 0.06298558f, 
    -0.00938260f, 0.04943955f, -0.04196534f, -0.05941154f, -0.06137712f, -0.02563835f, 0.04643872f, -0.02304081f, 
    -0.02185865f, 0.02222247f, -0.00669984f, -0.05357847f, 0.04438757f, -0.00226742f, 0.00782095f, -0.00061485f, 
    -0.02489768f, 0.04071681f, -0.05917544f, 0.05026800f, 0.06599851f, -0.01158220f, -0.07572103f, -0.07159621f, 
    -0.07254022f, -0.07370280f, 0.05629358f, -0.04410085f, 0.06390744f, -0.03777757f, -0.03150941f, 0.02709931f, 
    0.01722930f, -0.01155932f, 0.00587904f, -0.04238909f, 0.02639185f, -0.04049839f, -0.02861382f, -0.00719736f, 
    -0.04713721f, -0.02468141f, 0.04586793f, -0.02924804f, -0.07120187f, -0.01809267f, 0.00046544f, 0.01030056f, 
    -0.00649797f, -0.00144193f, -0.04533682f, 0.04991305f, 0.01058763f, -0.07742496f, 0.05440687f, -0.06211715f, 
    0.04270640f, -0.04409219f, -0.02184333f, -0.04507124f, 0.05841960f, -0.00058377f, 0.00706167f, 0.03002706f, 
    0.06304946f, 0.01015458f, 0.00517310f, -0.04744834f, -0.03062284f, 0.02455650f, 0.01228714f, -0.04532661f, 
    -0.31126434f, 0.17502768f, -0.00383431f, -0.10453966f, -0.04139809f, 0.08774524f, -0.12043829f, 0.04385219f, 
    0.06323785f, 0.00319339f, 0.12251580f, -0.02592417f, 0.13835812f, 0.18038367f, 0.01605993f, -0.02870523f, 
    0.04806582f, -0.03085188f, -0.12063847f, -0.02042278f, -0.01018695f, -0.04240630f, 0.04341769f, 0.06417773f, 
    -0.24958313f, 0.15025941f, -0.13778707f, -0.16016737f, 0.20250891f, 0.12372642f, 0.00953428f, -0.07919131f, 
    -0.11157231f, 0.03360727f, 0.20554088f, -0.00127376f, -0.19733022f, 0.25116542f, 0.31646305f, 0.19454680f, 
    0.08286431f, -0.07693402f, 0.03861269f, -0.03663766f, 0.10292691f, -0.01933888f, 0.03026749f, -0.00495284f, 
    -0.44906029f, 0.23028326f, 0.08253681f, -0.04425634f, 0.02940189f, 0.03248316f, 0.05875006f, 0.04324912f, 
    -0.07213661f, 0.06142546f, 0.02291226f, 0.04141054f, 0.35237551f, 0.10841008f, -0.30964667f, -0.04769718f, 
    0.02596406f, 0.04249510f, 0.00427445f, 0.08924945f, 0.14014371f, -0.02271745f, 0.03964094f, 0.05330417f, 
    0.47508633f, -0.50530714f, 0.22933680f, -0.18756709f, -0.16918200f, 0.11764564f, -0.08595581f, 0.05181100f, 
    0.03883086f, 0.01954702f, -0.00634138f, 0.05430850f, 0.26487437f, 0.05710245f, -0.03358762f, 0.13631243f, 
    -0.02495998f, -0.00339620f, -0.03651265f, 0.17723370f, 0.00975964f, -0.00720536f, -0.00691826f, 0.09887761f, 
    -0.00098900f, -0.15801431f, -0.12061582f, -0.12872702f, 0.09388667f, -0.00598933f, -0.01580861f, -0.17366639f, 
    0.14497226f, -0.02990715f, -0.11838072f, 0.04397429f, -0.15276074f, -0.10590068f, 0.01856947f, 0.08598885f, 
    0.06626372f, 0.06710030f, -0.05887556f, -0.19799688f, -0.09790764f, 0.11550717f, 0.16946770f, 0.09838546f, 
    0.22163887f, 0.30467418f, 0.07095926f, -0.01927831f, -0.11698313f, 0.02214188f, -0.16028360f, 0.03242802f, 
    0.06627094f, -0.05357055f, 0.05750513f, -0.06564792f, -0.12367250f, 0.03032422f, -0.12938993f, -0.13669792f, 
    -0.16180770f, 0.13235505f, -0.00204359f, 0.02972838f, 0.05979086f, 0.09131600f, -0.06939217f, -0.10027914f, 
    -0.05187089f, 0.16919895f, -0.09344895f, -0.18875113f, -0.08508999f, -0.04351530f, 0.05986129f, -0.01769370f, 
    -0.13695808f, -0.14777888f, 0.12184998f, 0.06800969f, 0.21633339f, 0.16987112f, -0.07999346f, 0.17686577f, 
    -0.09683106f, -0.04672448f, 0.10872088f, 0.15826263f, 0.09728220f, -0.21151404f, 0.00899771f, -0.02800686f, 
    -0.24310409f, 0.11199984f, -0.01811077f, -0.07315124f, -0.04705604f, -0.10130649f, -0.03029934f, -0.11468689f, 
    -0.00257464f, 0.10838611f, -0.07905739f, 0.00703678f, 0.02343493f, 0.38450918f, 0.26293236f, -0.19630148f, 
    0.11869828f, -0.06458257f, -0.03422675f, 0.03570190f, 0.04014699f, 0.06273259f, 0.11264507f, -0.04339626f, 
    -0.05247371f, 0.02800992f, 0.38384533f, 0.27675045f, 0.09315877f, -0.03404528f, 0.14677438f, 0.05432215f, 
    0.19540189f, 0.06840202f, -0.06194915f, 0.18575513f, -0.21011202f, -0.29573607f, 0.16139111f, -0.17713434f, 
    0.12817492f, 0.10914271f, 0.11523402f, -0.18630566f, 0.11885458f, -0.02202992f, 0.17517722f, 0.11982851f, 
    -0.27807236f, -0.26154935f, 0.03281496f, -0.13859713f, 0.03004856f, -0.10071082f, -0.11938757f, -0.21315400f, 
    -0.05586745f, 0.00885854f, -0.05859965f, -0.02657074f, 0.23186928f, -0.13485897f, 0.03433722f, -0.09624386f, 
    0.07296135f, -0.02645217f, -0.04928571f, 0.07806110f, 0.00333252f, -0.08310514f, -0.13460182f, 0.09106377f, 
    0.37163818f, -0.14356788f, 0.00433557f, 0.15001541f, 0.05813405f, 0.12535277f, 0.11755857f, -0.06764290f, 
    -0.00178230f, 0.20104067f, 0.07411849f, 0.11498874f, -0.05254306f, 0.00160988f, -0.03032863f, -0.00745064f, 
    -0.00088685f, 0.15810719f, -0.03727253f, -0.16910613f, 0.10970209f, -0.01877570f, 0.15232623f, 0.22137818f, 
    -0.39778590f, -0.04721991f, -0.04562395f, 0.23749286f, 0.10472719f, -0.07220441f, -0.07090864f, -0.02443097f, 
    -0.00666797f, 0.18274885f, 0.00873378f, -0.09543053f, -0.06811827f, -0.17241766f, 0.13730182f, 0.02512711f, 
    -0.01463781f, 0.25519028f, 0.19318748f, 0.14480504f, -0.15666793f, 0.23276362f, 0.05561960f, 0.03798990f, 
    -0.31272259f, 0.19119577f, -0.06137534f, -0.20915914f, 0.10167939f, -0.10692532f, -0.31015220f, -0.18669121f, 
    -0.09736722f, 0.08350449f, 0.16836946f, 0.14662787f, -0.11552384f, -0.07118218f, 0.21681184f, 0.07427373f, 
    0.09946234f, -0.01849414f, -0.05007023f, 0.07448650f, 0.14978381f, 0.25150272f, 0.11635558f, 0.10639048f, 
    -0.14219275f, -0.19415694f, -0.06409170f, -0.24932560f, 0.08264343f, -0.00597417f, 0.13214737f, 0.06104814f, 
    0.04194018f, -0.02534032f, 0.04026743f, 0.05191517f, 0.12346373f, 0.12252523f, 0.24360602f, -0.03342871f, 
    0.09090489f, -0.07206997f, -0.15319969f, 0.03304199f, 0.02150540f, -0.14461380f, 0.03558126f, -0.18880998f, 
    0.11519212f, -0.02487540f, 0.21982007f, 0.23277038f, -0.04280046f, -0.08987329f, 0.05771424f, -0.08914042f, 
    -0.01517690f, 0.02184488f, -0.03012235f, 0.05181890f, 0.49887985f, -0.36550593f, -0.11111772f, -0.04100020f, 
    0.01257461f, 0.10858370f, 0.06713278f, -0.05498571f, 0.01335478f, 0.14733946f, -0.05266863f, 0.09972045f, 
    -0.09074243f, -0.08353993f, -0.17787780f, 0.05856480f, 0.01992781f, 0.01582037f, -0.00612404f, 0.07614955f, 
    -0.02904353f, -0.04347715f, -0.01238326f, 0.07528857f, -0.37963900f, 0.07696131f, 0.46521851f, -0.32676291f, 
    -0.08760844f, -0.04282439f, 0.11813792f, -0.18297799f, 0.04891498f, 0.04199514f, -0.15550897f, 0.04137796f, 
    -0.10450623f, 0.03825674f, -0.09156004f, -0.20012167f, -0.09901885f, 0.07669506f, -0.01393912f, 0.03705346f, 
    -0.06000566f, 0.09712259f, 0.13529299f, 0.01038862f, 0.26129532f, 0.13637695f, -0.12051170f, 0.14996080f, 
    -0.09140579f, -0.07093276f, -0.10904448f, -0.00754081f, -0.08915129f, -0.05650493f, 0.06067268f, -0.23695028f, 
    0.23478310f, 0.17524910f, 0.07129464f, 0.17435195f, -0.04850302f, -0.00783477f, 0.12759279f, 0.04234062f, 
    0.05681986f, -0.03839670f, -0.05270724f, 0.05780011f, -0.08998974f, 0.11750083f, -0.14317270f, 0.03137222f, 
    0.04570707f, -0.01126535f, 0.03101544f, -0.06284873f, 0.04770944f, 0.04225076f, 0.11428290f, -0.04514027f, 
    -0.02090476f, -0.12492628f, 0.03541275f, -0.31348500f, -0.12503502f, 0.03483249f, -0.05164446f, -0.03001134f, 
    -0.13280399f, 0.02393587f, 0.05783666f, 0.02650153f, 0.25218225f, -0.01529855f, -0.06743359f, 0.02965031f, 
    -0.03294580f, 0.06259586f, 0.12720251f, 0.02424690f, 0.03511606f, 0.12028769f, 0.08597098f, 0.06303226f, 
    0.52178997f, -0.23917292f, 0.12628122f, 0.09939737f, -0.10255520f, 0.13865077f, -0.07574204f, 0.01637097f, 
    0.01699800f, -0.04268379f, 0.12938777f, 0.02059948f, -0.08472373f, -0.24287683f, 0.11256091f, 0.14880599f, 
    0.10636734f, -0.08153518f, 0.01372081f, 0.08173750f, 0.10063063f, 0.00274233f, 0.19319463f, 0.05386591f, 
    0.35321757f, 0.07255225f, 0.02105615f, 0.18702985f, 0.05685740f, 0.02147352f, 0.13880810f, 0.13453522f, 
    -0.01199245f, 0.01498937f, 0.10250790f, 0.05931286f, -0.02141988f, -0.10797086f, -0.16658100f, -0.14275543f, 
    0.00295147f, -0.08386127f, -0.05340336f, -0.00259538f, -0.14993350f, 0.04724807f, -0.14615150f, 0.08040754f, 
    0.06773035f, 0.04858292f, 0.09398348f, 0.20609535f, -0.03264137f, -0.10198198f, -0.02448329f, 0.08405943f, 
    0.01238347f, -0.09296756f, 0.06053185f, 0.17840952f, -0.20146540f, 0.01185520f, -0.17234606f, -0.18847443f, 
    -0.09648542f, -0.08517101f, 0.10234559f, 0.00864889f, 0.11393737f, 0.12685692f, 0.00485074f, -0.01630545f, 
    -0.14583260f, -0.01057255f, -0.19600597f, -0.16829164f, -0.00808690f, 0.03070506f, -0.15618743f, 0.12624152f, 
    -0.01147462f, -0.11173019f, 0.00193802f, -0.12262549f, -0.24894316f, 0.03521659f, -0.09693356f, 0.01999094f, 
    0.00177671f, 0.01405654f, 0.04844667f, -0.03758945f, 0.03660585f, 0.03818745f, 0.00506624f, -0.03866053f, 
    0.27004611f, 0.02790010f, 0.02992760f, 0.07048301f, -0.01925479f, 0.19747819f, -0.05901420f, 0.00108207f, 
    -0.04727999f, -0.04844313f, 0.00387511f, -0.23088658f, 0.35800004f, -0.05415934f, -0.17775244f, 0.06714179f, 
    0.03155343f, 0.04603294f, 0.06586482f, 0.06878881f, -0.05434785f, 0.03930620f, -0.09794325f, 0.00788106f, 
    0.28229895f, -0.03629465f, -0.01267301f, 0.15514289f, -0.17633879f, -0.10814057f, 0.06086693f, 0.12267656f, 
    0.07453623f, -0.05438028f, 0.12837394f, -0.04290636f, 0.00629747f, -0.02157213f, -0.21563281f, -0.01474484f, 
    -0.08002625f, 0.08524001f, 0.02785726f, 0.06539346f, -0.00426228f, -0.10602760f, -0.14789963f, -0.04343131f, 
    0.08640137f, -0.25337943f, -0.09705352f, 0.31829262f, 0.18230307f, 0.15753967f, 0.05044391f, -0.11248391f, 
    0.06392246f, -0.01714090f, 0.02923191f, 0.00530484f, 0.33670792f, 0.23505406f, -0.14151600f, 0.13698277f, 
    -0.01679241f, 0.13118568f, -0.02580204f, -0.07309881f, -0.04749838f, 0.04760203f, 0.01412831f, 0.00680340f, 
    0.32906353f, -0.00602194f, -0.02783561f, -0.01448988f, -0.15037325f, -0.09076089f, -0.12270202f, -0.05778790f, 
    0.07663373f, 0.10509706f, -0.03721454f, -0.19521441f, -0.23084389f, 0.19129243f, 0.14658782f, -0.15609449f, 
    -0.04857446f, 0.03930705f, -0.12573428f, 0.07466929f, -0.00265576f, 0.09722915f, 0.05942893f, -0.08303403f, 
    -0.35173136f, 0.27419490f, 0.04257771f, 0.00563263f, -0.10554614f, -0.05581809f, 0.08927532f, 0.03220557f, 
    0.05700146f, -0.04382271f, 0.02765831f, 0.12297244f, -0.34131837f, 0.17131960f, 0.33879340f, 0.20104548f, 
    -0.10550542f, 0.02357074f, -0.14381082f, 0.01793661f, 0.10511124f, 0.07859458f, 0.03794371f, -0.00378449f, 
    0.20035614f, -0.15990786f, 0.06778017f, 0.24746051f, 0.13349064f, 0.02113249f, 0.07367273f, 0.05234366f, 
    0.16279991f, 0.02279278f, 0.05023133f, -0.01858451f, 0.00068063f, 0.12440027f, 0.12470046f, 0.18274899f, 
    0.13588098f, -0.04076604f, 0.13736841f, 0.06366441f, 0.05494257f, -0.07136036f, -0.01783285f, 0.00492146f, 
    -0.16325484f, -0.05584192f, -0.21506208f, 0.19396049f, -0.08940081f, -0.06185518f, -0.09670814f, -0.13711767f, 
    -0.12170715f, -0.05163481f, 0.09108435f, 0.07155798f, -0.02655000f, 0.00746040f, -0.05157551f, 0.12605055f, 
    -0.09053957f, -0.17481180f, -0.04217694f, 0.06757456f, 0.08531401f, 0.15485466f, 0.00235600f, -0.02695624f, 
    0.07816601f, -0.12689577f, -0.08164589f, 0.09241462f, -0.03695783f, 0.11360879f, 0.06204551f, -0.07062610f, 
    0.11118762f, 0.09283593f, 0.00410322f, 0.05796724f, -0.18538103f, 0.03706382f, -0.22677368f, -0.27560413f, 
    0.09058875f, 0.21759352f, -0.03531260f, -0.03955716f, 0.04175104f, 0.10949358f, 0.24792159f, -0.02856262f, 
    0.09247962f, -0.07515790f, 0.13825633f, 0.10292298f, 0.02824236f, -0.03083929f, -0.04039493f, 0.06047320f, 
    0.02794069f, 0.16532452f, 0.27165931f, 0.05712669f, 0.13060749f, 0.29114705f, -0.42654470f, 0.21446772f, 
    0.07171489f, -0.13868859f, -0.10837909f, -0.01654256f, -0.00514453f, -0.10019705f, -0.06206304f, -0.03936727f, 
    0.03928114f, 0.00746804f, -0.23790994f, 0.02625606f, 0.02833422f, -0.16927475f, 0.06460512f, 0.04532914f, 
    -0.05816448f, 0.00865389f, 0.00484237f, -0.01359234f, 0.25863385f, -0.15158103f, 0.00408156f, 0.02064872f, 
    -0.08309045f, 0.11426185f, 0.00536068f, 0.04181254f, 0.05767155f, -0.03259620f, -0.08290406f, 0.05884290f, 
    -0.33913922f, -0.23604552f, -0.05871917f, 0.11625995f, 0.05287057f, 0.07893579f, 0.01056016f, -0.01049318f, 
    -0.00050060f, -0.02712155f, 0.04638876f, 0.12086147f, -0.41317296f, -0.08394291f, 0.11397208f, -0.24514303f, 
    -0.12082195f, 0.08121110f, 0.05145766f, 0.05785841f, 0.23051138f, 0.15782636f, 0.08304331f, 0.04871120f, 
    -0.11890516f, -0.19791533f, 0.26553226f, 0.04394111f, -0.01882844f, 0.01398730f, 0.13278221f, -0.06599725f, 
    -0.01182663f, 0.03845104f, -0.09657633f, -0.02803000f, 0.13715462f, -0.22336324f, -0.06041424f, -0.04424427f, 
    -0.08177609f, 0.12244625f, -0.06240146f, -0.03141529f, 0.07367190f, 0.10888518f, -0.05720774f, -0.11710123f, 
    0.69877976f, -0.12259910f, 0.04852224f, 0.04895356f, -0.14279005f, 0.08297496f, -0.05199929f, 0.05111820f, 
    -0.00805338f, -0.05167594f, 0.06789327f, 0.03518414f, 0.35676971f, -0.08779377f, 0.10071315f, -0.01969120f, 
    -0.26681823f, -0.06301390f, -0.00288585f, 0.03386748f, 0.13850093f, -0.10608964f, -0.11649936f, -0.06648339f, 
    -0.19017693f, 0.00973693f, -0.13480335f, 0.02753466f, 0.11566531f, 0.17349847f, 0.02541728f, 0.08763869f, 
    0.03026351f, -0.08828315f, -0.05463925f, -0.05427758f, 0.18312587f, 0.15239364f, 0.10198169f, -0.07781023f, 
    0.01813896f, 0.04616777f, -0.03714497f, 0.01999368f, 0.01820502f, 0.01466035f, 0.01008094f, 0.16646588f, 
    -0.14516947f, -0.16124789f, 0.04353253f, 0.03055752f, -0.10837252f, 0.00849335f, -0.04395948f, -0.04913190f, 
    0.10963745f, -0.13341589f, -0.06298941f, 0.08250591f, 0.26036513f, 0.12059408f, 0.02665804f, -0.16414836f, 
    0.03187648f, 0.09521126f, 0.15760204f, 0.01835993f, 0.17986645f, 0.23801790f, 0.10214034f, 0.09319077f, 
    0.04908139f, -0.19663844f, 0.03554811f, -0.09883764f, 0.07553021f, 0.05459991f, -0.09508787f, 0.18072158f, 
    -0.02299086f, -0.12616129f, 0.03727234f, 0.04294423f, -0.05948642f, 0.06031904f, 0.17004433f, 0.05245978f, 
    0.10932279f, 0.09960643f, 0.18332936f, 0.12050720f, -0.00597699f, 0.13219483f, -0.00146943f, 0.07815086f, 
    -0.15867384f, -0.15684560f, 0.12113184f, -0.06541780f, -0.03320985f, -0.03827766f, -0.04631387f, -0.07907080f, 
    -0.05840981f, -0.06356054f, 0.12249534f, 0.03177710f, 0.21073395f, -0.20875524f, 0.20205012f, -0.11344893f, 
    0.03127627f, -0.05119027f, 0.01096429f, 0.10138176f, -0.00464316f, 0.02275372f, 0.06168557f, 0.00761961f, 
    -0.29422724f, -0.32025719f, 0.23086333f, -0.21531944f, 0.13356104f, -0.08178123f, 0.22580688f, -0.02496822f, 
    0.05350803f, 0.09849862f, -0.03636206f, -0.06980023f, 0.13517562f, -0.09422576f, 0.00389038f, 0.03904232f, 
    0.10120316f, 0.08332742f, 0.04216622f, -0.01183346f, 0.08506405f, 0.10437202f, -0.11112426f, 0.24818668f, 
    -0.02576563f, -0.02927439f, 0.08229949f, -0.05720510f, -0.12315702f, -0.12225031f, 0.03243562f, -0.06597830f, 
    -0.07076918f, 0.02869661f, 0.04142246f, 0.05549794f, -0.02325703f, -0.01745163f, 0.05996619f, -0.21056831f, 
    -0.07046807f, -0.03263061f, 0.12783417f, -0.03654739f, 0.13971411f, -0.02475607f, 0.05896861f, 0.16463685f, 
    -0.19477203f, -0.30428058f, 0.13036700f, -0.08537465f, 0.05870698f, -0.05957067f, 0.07193428f, 0.15849687f, 
    0.08454294f, -0.01026064f, 0.08940211f, -0.12470569f, 0.30277523f, -0.02925671f, -0.08430412f, 0.30969402f, 
    0.07489376f, -0.17517062f, -0.14603294f, 0.01321383f, 0.02231770f, 0.00977359f, 0.03041853f, -0.11756189f, 
    -0.57896721f, 0.04079630f, -0.15442687f, -0.02977359f, 0.10752747f, -0.04906428f, -0.01762017f, 0.00993656f, 
    0.13784115f, 0.06354363f, -0.00220080f, 0.14086650f, -0.13656461f, 0.01179316f, -0.33892265f, -0.34106827f, 
    0.01423211f, 0.00488171f, -0.13889050f, 0.06381587f, 0.03914985f, -0.20494615f, -0.19185539f, 0.02306376f, 
    -0.12556162f, 0.17667316f, 0.13623804f, 0.12670746f, 0.00247783f, 0.00533326f, 0.02532451f, -0.05977753f, 
    0.12345001f, -0.05379497f, -0.14612998f, 0.08985848f, 0.08749124f, -0.03632220f, 0.14279929f, -0.02729433f, 
    -0.01286594f, 0.25596726f, -0.02897199f, 0.11715324f, 0.10041872f, -0.13545512f, 0.01029030f, -0.11556167f, 
    0.33829480f, -0.00981195f, -0.01596220f, -0.31524011f, 0.00805191f, 0.06372558f, -0.15901436f, -0.03770754f, 
    0.05775940f, -0.04328422f, 0.00284905f, -0.01617378f, 0.12643868f, 0.17356451f, 0.27058831f, -0.19055061f, 
    0.12667294f, 0.02077588f, 0.04266044f, -0.05591356f, -0.02354484f, -0.00761564f, 0.18043190f, 0.28975248f, 
    0.11390517f, -0.10144149f, 0.31494179f, 0.15271695f, -0.06651137f, -0.00181420f, 0.06424718f, 0.08134314f, 
    -0.03783513f, -0.05382318f, 0.19071352f, 0.26173484f, 0.08486698f, -0.10250776f, 0.23052417f, 0.12061208f, 
    0.12989913f, 0.09453897f, -0.11154828f, -0.03351872f, 0.01868612f, -0.04775874f, -0.00469116f, 0.01488459f, 
    0.04826300f, 0.04897270f, 0.05350230f, 0.12310538f, 0.12935367f, -0.08308573f, -0.09828669f, 0.05788557f, 
    0.11034760f, 0.35513288f, 0.02864584f, 0.28649640f, -0.03286706f, 0.17114717f, 0.03988638f, -0.23853405f, 
    -0.00791622f, 0.04798491f, -0.02168778f, 0.00931000f, 0.04589877f, 0.06860006f, 0.09473836f, 0.17919251f, 
    0.04406793f, 0.04953633f, -0.01986633f, 0.03633971f, -0.03603246f, -0.07428955f, 0.03382852f, -0.07693749f, 
    0.01790179f, -0.02407978f, -0.03734958f, 0.01605482f, 0.04499040f, -0.04907624f, -0.02048249f, 0.01929774f, 
    0.00899990f, -0.05202904f, 0.03356158f, 0.03098853f, -0.00168272f, 0.02071138f, -0.01142120f, 0.01957100f, 
    -0.08218651f, -0.00667671f, -0.04112106f, 0.05622189f, 0.05232609f, -0.07416573f, -0.06294721f, -0.04880154f, 
    -0.07301977f, -0.01253004f, -0.05513274f, 0.00896720f, 0.03528854f, 0.06047852f, -0.00077300f, 0.04304063f, 
    0.03092905f, 0.05155005f, -0.07465711f, -0.04769018f, -0.04183644f, -0.05069856f, -0.03524164f, 0.01450125f, 
    -0.07155038f, 0.06327456f, -0.00972609f, -0.02220914f, 0.00632260f, 0.02030973f, 0.05718342f, 0.05701988f, 
    -0.05991161f, 0.03936272f, -0.05485196f, -0.04727704f, -0.00748876f, 0.05186947f, -0.02595184f, 0.03497384f, 
    -0.03326994f, -0.05458472f, 0.01344403f, 0.02122787f, 0.04669701f, -0.02762374f, 0.05251409f, -0.07738623f, 
    -0.00736649f, 0.05095921f, 0.03903998f, 0.05942710f, -0.00978781f, 0.04369503f, 0.02296680f, -0.01409250f, 
    -0.00721408f, 0.06144853f, -0.04307769f, -0.02149216f, -0.06392749f, -0.01410857f, -0.03210998f, -0.00872153f, 
    -0.01975032f, -0.02564985f, -0.07303190f, 0.03848847f, -0.01345016f, -0.04896981f, -0.05337870f, -0.03239096f, 
    0.01375058f, 0.00526152f, -0.04381470f, 0.06148652f, -0.06275949f, 0.05603103f, -0.03467097f, -0.07104471f, 
    0.01086252f, -0.07098829f, -0.07570267f, 0.03002878f, -0.06227574f, -0.00964162f, 0.05105133f, -0.06576183f, 
    -0.06440498f, -0.05664267f, -0.03151595f, -0.07443906f, 0.01864557f, -0.04099238f, -0.07976100f, 0.04053327f, 
    -0.00711309f, -0.01706272f, -0.00291347f, -0.01961750f, -0.05153171f, -0.08301869f, -0.06897077f, 0.05484765f, 
    -0.01561562f, -0.07231293f, 0.02943324f, -0.00930599f, -0.03681178f, -0.02898784f, 0.05356948f, -0.05505235f, 
    0.02889463f, 0.05339035f, 0.05485619f, -0.07078201f, -0.03519777f, -0.05452682f, -0.06322756f, 0.03480066f, 
    0.03351360f, 0.03247292f, 0.03486501f, -0.04323492f, -0.05629454f, -0.01424471f, -0.03603182f, -0.03656749f, 
    -0.03231745f, -0.03826569f, 0.02128866f, -0.06156227f, -0.03803426f, 0.01390974f, 0.04192097f, -0.01577270f, 
    0.02056936f, -0.08011151f, -0.06288122f, 0.05207639f, -0.01198727f, 0.04559309f, 0.02848573f, -0.04010211f, 
    -0.07852058f, 0.04832214f, -0.05443639f, 0.00900219f, 0.05281618f, -0.05109044f, -0.04852736f, -0.06843974f, 
    0.03663388f, 0.06007276f, 0.05807713f, -0.02945106f, -0.00357450f, 0.04636785f, 0.00143080f, -0.06901383f, 
    0.02597268f, -0.00758670f, 0.01285144f, 0.03469559f, 0.00379932f, -0.06363049f, 0.05396732f, 0.05947268f, 
    0.00366876f, -0.06764987f, -0.07527476f, 0.01771609f, 0.00403821f, -0.04910653f, -0.04659996f, -0.07513402f, 
    0.01495417f, -0.03184650f, 0.04619069f, 0.05267831f, -0.05049365f, -0.01810547f, 0.04990205f, -0.02643383f, 
    0.04427456f, 0.06036904f, 0.04770155f, 0.00215551f, 0.01977251f, -0.00124243f, -0.02924445f, 0.01075852f, 
    -0.02105596f, 0.00192271f, 0.04764590f, -0.07809031f, -0.02920710f, -0.07007526f, -0.04489059f, 0.04714408f, 
    0.06263586f, -0.02641031f, 0.01549077f, -0.01467407f, 0.06288999f, 0.00422813f, 0.02030342f, 0.04358138f, 
    -0.04692943f, -0.02461771f, 0.01959749f, 0.00222070f, 0.05992148f, -0.05508224f, 0.02487316f, -0.01596695f, 
    0.02641446f, -0.05338418f, -0.01392782f, -0.03492765f, -0.03139319f, 0.01398642f, -0.06701646f, -0.08151795f, 
    -0.06562889f, 0.05036793f, -0.02088240f, 0.04912125f, -0.05495834f, -0.05049207f, 0.01962623f, 0.04880351f, 
    -0.07155220f, 0.00504501f, 0.02318359f, -0.06595330f, -0.03691022f, -0.02362969f, 0.06167215f, 0.00955426f, 
    0.01401872f, 0.03846825f, -0.04148145f, -0.01605263f, 0.04948689f, 0.04401518f, -0.02992398f, -0.03447298f, 
    -0.03676376f, -0.03118753f, -0.07421540f, -0.06063293f, 0.00147752f, -0.00397176f, 0.05187784f, -0.02329530f, 
    -0.05012711f, -0.05045304f, -0.00956350f, -0.00840965f, -0.04301404f, -0.08210474f, 0.06075276f, -0.07355468f, 
    -0.01695457f, -0.01929016f, -0.07396626f, -0.08045321f, 0.01107383f, -0.04813173f, 0.01411110f, -0.04535658f, 
    0.01276749f, -0.03650299f, 0.05093378f, 0.02002325f, 0.00318916f, -0.06995867f, -0.00698815f, 0.00323161f, 
    -0.01979377f, 0.04477316f, -0.01862623f, 0.01918823f, 0.01999241f, 0.02972015f, -0.05361350f, -0.02680293f, 
    -0.06887656f, 0.00058570f, -0.01376898f, -0.01736380f, -0.00899958f, 0.03978993f, -0.02648075f, -0.05967071f, 
    0.00266221f, 0.04482750f, 0.02122172f, -0.07786430f, -0.06196037f, 0.04442460f, 0.02060652f, -0.01081394f, 
    -0.02888854f, 0.01886225f, -0.04056589f, -0.01570810f, 0.02565565f, -0.07014874f, -0.00608029f, -0.04691626f, 
    -0.03788884f, 0.01381417f, 0.00713815f, -0.06686135f, -0.02858412f, -0.01046078f, -0.07877845f, -0.05441518f, 
    0.00381081f, -0.04697800f, -0.06538077f, -0.07475545f, -0.05736959f, 0.04785876f, 0.02932409f, 0.03868277f, 
    -0.03496205f, -0.01206806f, -0.02164464f, -0.05105750f, -0.07268266f, 0.05577642f, -0.05720555f, -0.07938243f, 
    0.05896991f, 0.04340082f, 0.05186507f, -0.02325553f, -0.06860986f, -0.02141402f, -0.02886325f, 0.02000347f, 
    0.00110858f, 0.05616448f, 0.02956442f, 0.03934675f, 0.03706018f, 0.00846054f, 0.03799506f, -0.07696051f, 
    -0.07047199f, 0.03054512f, -0.02307098f, 0.00909335f, 0.01754523f, -0.04468651f, -0.03866361f, -0.07941159f, 
    -0.40480602f, 0.13099714f, -0.03706829f, 0.14572451f, 0.17056534f, -0.05353304f, -0.02754703f, 0.01160047f, 
    0.00745544f, 0.07155702f, 0.05560057f, 0.08165806f, 0.07452504f, -0.18306592f, 0.00459469f, 0.10383353f, 
    0.01827174f, -0.00481098f, 0.00718692f, -0.00293560f, 0.15125899f, 0.03143519f, 0.03703108f, 0.18115981f, 
    -0.64858484f, -0.02043350f, 0.36907402f, -0.15366183f, -0.00155098f, -0.00688735f, 0.09429833f, 0.06918101f, 
    -0.06325069f, -0.00840866f, 0.10728988f, 0.01007640f, 0.01447255f, -0.14675377f, 0.11001061f, -0.10584466f, 
    -0.04050295f, -0.04025802f, 0.03289034f, 0.10268832f, 0.06051002f, 0.03051959f, 0.05921342f, 0.18312956f, 
    -0.03902214f, -0.36346522f, 0.04077307f, 0.06710921f, -0.06700482f, 0.09221257f, 0.15309301f, -0.00237896f, 
    -0.05073535f, 0.08435909f, 0.00131228f, -0.09890573f, 0.18087262f, 0.04371543f, -0.03414981f, 0.11022011f, 
    0.00021547f, 0.00624493f, -0.03306881f, -0.07952713f, 0.15208441f, 0.00410537f, -0.05119860f, -0.00005321f, 
    0.01010720f, -0.27945697f, -0.11649254f, 0.02959218f, 0.01417427f, 0.00647928f, -0.12992987f, 0.11899757f, 
    -0.02106745f, -0.01856606f, 0.02633149f, -0.04392994f, 0.07833241f, -0.15421073f, -0.01476920f, 0.17559339f, 
    -0.12353004f, -0.02178729f, 0.01559118f, 0.19781268f, -0.05773683f, -0.06640734f, -0.06274848f, 0.02001819f, 
    -0.20768595f, 0.44967446f, -0.13034718f, -0.06494209f, 0.09086876f, 0.17803174f, 0.00456712f, 0.11875805f, 
    0.01951925f, -0.11996486f, -0.01808179f, 0.01820779f, 0.26959977f, 0.08149297f, -0.06032976f, -0.03660613f, 
    -0.03397116f, 0.12119938f, 0.06350512f, 0.06076964f, 0.11482343f, -0.13702548f, 0.08493275f, 0.11914778f, 
    -0.02154673f, -0.17031367f, 0.07381923f, 0.04063866f, -0.01231444f, 0.05277423f, -0.05994457f, -0.02805968f, 
    0.01840744f, -0.21315788f, -0.00374109f, 0.04596739f, 0.24961644f, 0.17801595f, 0.26913691f, -0.18560898f, 
    0.04104583f, 0.12007030f, 0.07580888f, -0.05763543f, 0.04133451f, 0.09455197f, 0.19338986f, 0.14717233f, 
    -0.03669364f, 0.01532442f, 0.28074184f, 0.04096866f, -0.05150588f, 0.01862788f, -0.06367441f, 0.05033698f, 
    -0.08965761f, -0.03870215f, 0.05444103f, 0.06560459f, 0.16517317f, -0.19047251f, 0.13628256f, 0.08869207f, 
    -0.03049787f, 0.15234894f, 0.12817453f, 0.01899505f, 0.08735623f, 0.05323916f, -0.03091244f, 0.03517883f, 
    -0.24576209f, 0.22884446f, -0.25485897f, -0.16116838f, 0.20892915f, -0.09564679f, 0.06437629f, 0.08477037f, 
    -0.03353582f, -0.07120894f, -0.07965340f, 0.20863153f, -0.18203628f, -0.01435782f, 0.43893188f, -0.18946145f, 
    0.09799301f, -0.02358099f, 0.09953818f, 0.04895542f, -0.02759946f, 0.09397971f, 0.07772114f, -0.10592806f, 
    -0.16259611f, 0.21675305f, 0.13002434f, 0.07498627f, 0.07096007f, 0.03204568f, -0.10534909f, -0.02404638f, 
    -0.15039258f, 0.00716430f, -0.02431201f, 0.12037240f, 0.34858808f, -0.12036580f, -0.03983590f, -0.14032626f, 
    -0.10511228f, -0.20814040f, -0.05107749f, -0.07340052f, -0.18192680f, 0.09273155f, -0.08149248f, -0.02660626f, 
    0.33204171f, 0.12391596f, 0.09601071f, 0.24887203f, -0.04848782f, 0.09423395f, 0.13417576f, 0.04634548f, 
    -0.09788066f, 0.11465721f, -0.08199392f, 0.01624320f, 0.00505801f, 0.02165433f, 0.13485079f, -0.15280780f, 
    0.10827034f, -0.08068682f, 0.14819874f, 0.13827264f, 0.18877122f, -0.06899164f, -0.04174782f, -0.11183013f, 
    0.21847886f, -0.31638154f, 0.23285185f, -0.19372886f, -0.10372571f, -0.10907990f, 0.12360428f, 0.13398284f, 
    -0.34792444f, 0.11442308f, -0.07194540f, -0.02104071f, 0.06914458f, 0.30605346f, -0.13961592f, 0.14522904f, 
    -0.02836562f, 0.08573523f, 0.17051432f, -0.04630710f, 0.03206200f, 0.08612154f, -0.04007274f, -0.13894613f, 
    0.38107276f, -0.34510046f, 0.05298386f, 0.04253658f, -0.21446261f, 0.04003864f, -0.19484638f, -0.10250700f, 
    0.02062055f, 0.11901571f, -0.02246831f, 0.01600591f, 0.11882740f, 0.07745960f, 0.17240165f, 0.27836365f, 
    0.03146830f, -0.00905773f, 0.10637245f, 0.14357038f, 0.05710672f, -0.00499064f, -0.03791158f, -0.14114346f, 
    0.03783612f, 0.24000718f, 0.27084008f, 0.22566791f, -0.00881513f, 0.09005328f, -0.02274683f, -0.05972835f, 
    -0.13765882f, -0.02584174f, 0.10214207f, 0.00311574f, -0.00916564f, -0.15650077f, -0.03286824f, -0.08960007f, 
    0.01426023f, -0.04419196f, -0.14771771f, -0.00876454f, -0.11937178f, -0.01428725f, -0.12315442f, -0.00923397f, 
    0.40542313f, 0.15060721f, 0.19773710f, 0.03559527f, -0.03738366f, -0.05553561f, -0.05135517f, 0.06585760f, 
    -0.10978373f, -0.11191536f, 0.08331546f, 0.21819004f, -0.36304981f, -0.07078925f, 0.19947100f, -0.24230176f, 
    -0.01719163f, 0.06615981f, -0.02545190f, -0.13867477f, 0.13649723f, -0.06387135f, 0.10333285f, -0.17247358f, 
    0.00048178f, -0.10604199f, -0.26970524f, 0.14165550f, -0.05198064f, 0.03809017f, -0.00483267f, 0.01729426f, 
    -0.03170893f, 0.04150203f, 0.00291194f, -0.07179721f, 0.04123035f, 0.02971310f, -0.20905875f, 0.00156892f, 
    -0.17232916f, -0.07389596f, -0.00714436f, -0.00919849f, 0.05158996f, -0.01950448f, 0.02023065f, -0.02598991f, 
    0.29477766f, 0.06739365f, -0.02374702f, 0.46195680f, -0.11532009f, 0.22968538f, -0.03019424f, -0.04572764f, 
    0.00783485f, 0.01580681f, 0.03967272f, 0.07963030f, 0.05354129f, -0.00801029f, 0.32041791f, -0.32599950f, 
    -0.13461076f, -0.07846957f, 0.21149978f, 0.03542379f, -0.04873313f, 0.02924318f, 0.20295465f, -0.05551802f, 
    0.06003879f, 0.02137760f, -0.01417895f, -0.02039511f, -0.04127651f, -0.01463136f, 0.00577140f, -0.07284034f, 
    0.03820232f, 0.00073935f, -0.04188634f, 0.03108634f, -0.00364299f, -0.06485616f, 0.03125854f, -0.07727684f, 
    -0.05133834f, -0.02604229f, -0.06862600f, 0.05648034f, 0.02337458f, 0.05960103f, -0.05807947f, -0.02358086f, 
    -0.06039372f, 0.02593809f, 0.06325707f, -0.04712758f, 0.01686242f, 0.03651340f, -0.06397967f, -0.03605236f, 
    -0.00502074f, 0.03342995f, 0.00177499f, 0.06220838f, 0.05701248f, 0.00520243f, 0.00630693f, -0.07821533f, 
    0.05773153f, -0.01338082f, -0.06173837f, -0.02721816f, -0.03288187f, -0.07616367f, -0.07901869f, -0.05660140f, 
    -0.01591731f, -0.00716613f, -0.07526839f, 0.03609079f, 0.01327892f, 0.06109402f, 0.04862285f, -0.04426996f, 
    -0.06160520f, -0.04875652f, -0.07041853f, -0.04516885f, 0.00578957f, 0.02219267f, -0.03493052f, 0.01310263f, 
    -0.04637206f, -0.04201130f, -0.01018628f, 0.03506861f, -0.04025970f, -0.07879708f, 0.01622385f, -0.07269388f, 
    -0.06615747f, -0.01226057f, 0.00312513f, -0.01073364f, 0.06413179f, -0.08009756f, -0.00489711f, 0.04727039f, 
    0.04545979f, -0.07680340f, -0.04170353f, 0.03941899f, 0.02783674f, -0.04408227f, 0.03839638f, 0.02816681f, 
    -0.02489651f, 0.04710645f, -0.00011398f, -0.06985898f, -0.07913727f, 0.02360197f, -0.05309139f, 0.02761420f, 
    0.00638215f, 0.02173345f, -0.03422439f, 0.06117634f, 0.04595204f, -0.07465479f, 0.00200441f, 0.02953944f, 
    -0.06065346f, -0.07563405f, -0.02177142f, 0.04580411f, 0.00755099f, -0.06100481f, -0.00195324f, -0.02206314f, 
    0.02343781f, 0.00439845f, -0.04428820f, -0.08005131f, 0.00766672f, -0.05662085f, 0.03196002f, 0.02089166f, 
    0.00018384f, 0.00579880f, 0.05962776f, -0.06367025f, -0.01395879f, -0.02115804f, -0.02834394f, 0.06002742f, 
    0.05132172f, 0.04638565f, -0.07036415f, 0.05238272f, 0.03106534f, -0.01021995f, -0.01009761f, -0.02555457f, 
    0.06177012f, 0.06291930f, -0.06367020f, -0.05990981f, -0.01994780f, 0.01631085f, -0.07909156f, -0.00905022f, 
    0.02685282f, -0.03559075f, 0.00638106f, -0.02896172f, -0.02503823f, 0.02085924f, 0.04961874f, -0.03575210f, 
    -0.01032519f, 0.01524986f, -0.05210599f, -0.07897364f, 0.02159882f, -0.01010467f, 0.02541723f, -0.04955148f, 
    -0.06675259f, 0.02645366f, -0.03370721f, 0.04837704f, -0.01389004f, -0.01296617f, -0.04363778f, -0.01355002f, 
    -0.04341876f, 0.02804970f, 0.03599926f, 0.03782996f, 0.00770965f, -0.04110211f, -0.01192151f, -0.06602316f, 
    0.05844607f, -0.04273338f, -0.00790172f, -0.03841129f, 0.03105991f, -0.06562382f, -0.07275131f, -0.05180741f, 
    0.01749798f, -0.04803370f, -0.06796617f, -0.06954251f, -0.05948250f, 0.05010936f, 0.01108858f, -0.05963068f, 
    0.01486224f, 0.03230567f, 0.02927464f, 0.03913176f, -0.01196609f, -0.02134021f, 0.03147681f, -0.02608747f, 
    -0.03129390f, -0.02888711f, 0.00912436f, -0.07523978f, -0.08208472f, 0.05047004f, 0.02978097f, -0.04999020f, 
    0.01785777f, -0.06470080f, 0.00804676f, 0.03992550f, 0.04031954f, 0.02620285f, -0.02243029f, -0.04554331f, 
    -0.04894366f, 0.01740453f, -0.05213306f, 0.00809159f, -0.05215755f, -0.00250525f, -0.02610166f, -0.05164920f, 
    0.01247717f, -0.01359757f, -0.03630542f, 0.02183628f, 0.01129595f, 0.02691012f, 0.02893719f, -0.01246845f, 
    0.03606597f, -0.05732179f, -0.02554914f, 0.01578734f, 0.05068232f, -0.09001588f, -0.03795086f, -0.06812871f, 
    -0.08168535f, 0.01334391f, 0.00732226f, 0.05027742f, -0.01527505f, 0.06350838f, -0.03998747f, -0.03537039f, 
    -0.00893554f, 0.00988932f, 0.00547139f, -0.04313241f, 0.05203123f, -0.02942505f, 0.03149081f, -0.06019937f, 
    0.01285486f, 0.00753197f, -0.02851528f, -0.03997399f, -0.06158862f, 0.02583280f, -0.00529075f, -0.00638279f, 
    -0.01797799f, -0.00406707f, 0.00728739f, -0.06772894f, 0.04468457f, 0.01829288f, -0.07263492f, -0.03964006f, 
    -0.05682592f, -0.04668909f, 0.02331329f, 0.00026531f, -0.06723619f, -0.00924428f, -0.04845032f, 0.04052840f, 
    -0.02435663f, -0.04209685f, -0.06877667f, 0.02649524f, -0.05289921f, 0.00321193f, 0.05015083f, -0.07938129f, 
    0.04989045f, 0.02863089f, -0.03642434f, -0.00500931f, 0.03529183f, 0.02220912f, -0.08681940f, 0.03250589f, 
    0.05068431f, -0.04392542f, -0.08009581f, -0.07635448f, 0.03670865f, -0.07670575f, 0.06169871f, 0.03279725f, 
    0.02160980f, 0.03873606f, -0.04683568f, -0.00853206f, -0.07659990f, -0.02327480f, -0.00963645f, -0.09508058f, 
    -0.03907779f, 0.05018032f, -0.03348561f, 0.01378800f, -0.05634536f, 0.05006438f, -0.04659490f, -0.08917300f, 
    -0.06872870f, -0.09426419f, -0.02264773f, -0.06272080f, 0.03778457f, -0.01462043f, -0.04981719f, -0.06897008f, 
    -0.08527095f, 0.02856872f, 0.05059774f, 0.01007586f, -0.00127015f, -0.03420170f, 0.00065207f, -0.00839531f, 
    -0.01112147f, -0.02541638f, -0.01247487f, -0.01033970f, -0.04483393f, -0.09558709f, -0.01535356f, -0.07943285f, 
    -0.04228680f, 0.02100442f, 0.03173179f, 0.05462068f, 0.08016302f, -0.01391506f, 0.02401054f, -0.01481524f, 
    -0.02217075f, -0.01746378f, -0.08602986f, -0.09068439f, -0.07623179f, -0.01323151f, -0.00866867f, -0.08307226f, 
    -0.05465696f, -0.07629512f, -0.08521321f, 0.04021718f, 0.01500301f, -0.05678248f, 0.02114253f, 0.02567143f, 
    -0.00017337f, 0.04452807f, -0.02040300f, 0.03004469f, -0.07766239f, 0.01637859f, -0.04964635f, 0.01924990f, 
    0.02472364f, 0.00259357f, 0.03671760f, 0.02185573f, 0.03993740f, -0.03047366f, -0.02894895f, 0.04629768f, 
    0.20680106f, -0.03158145f, -0.10153735f, 0.00176602f, 0.04421967f, -0.03754622f, 0.16000065f, 0.05507415f, 
    0.08043008f, 0.00225903f, 0.10253019f, -0.07957478f, -0.24035352f, 0.00552449f, -0.06205350f, 0.04287076f, 
    0.05706501f, 0.16223004f, 0.03149008f, 0.09766703f, 0.10538771f, 0.06482499f, -0.07142004f, 0.07249027f, 
    -0.19392343f, 0.00607164f, -0.15449336f, -0.02933387f, 0.03293869f, -0.01154277f, 0.13777809f, -0.00798610f, 
    -0.14832634f, -0.06621459f, 0.12353580f, 0.07382766f, 0.07916004f, 0.17584781f, 0.03064150f, 0.33382374f, 
    0.03277763f, -0.00059736f, 0.04760643f, -0.10073709f, 0.10273848f, 0.01433182f, -0.04319738f, 0.10053077f, 
    0.03526575f, 0.06478018f, 0.08721407f, 0.12423943f, 0.05392734f, 0.10581546f, -0.08335695f, 0.06385140f, 
    0.18091807f, 0.01131134f, 0.08861297f, -0.12296370f, 0.04181235f, 0.04204034f, -0.00217384f, -0.05265179f, 
    -0.05203669f, -0.11418767f, -0.24156451f, -0.02636831f, -0.11027351f, -0.08441027f, -0.07747856f, -0.10696912f, 
    -0.31286299f, 0.28609318f, 0.04650923f, -0.22897106f, 0.02268890f, -0.07135119f, 0.08814689f, 0.13770057f, 
    0.10850041f, 0.07593196f, 0.01938123f, 0.00363626f, -0.03475393f, 0.20237616f, -0.18646742f, -0.04405614f, 
    -0.08254810f, 0.13538948f, -0.15547454f, -0.04919257f, 0.07483374f, -0.09824722f, -0.17655444f, 0.06013948f, 
    -0.09137926f, -0.33669069f, 0.05073676f, -0.01122917f, -0.04115684f, -0.00486791f, 0.03434845f, 0.04184268f, 
    0.11000533f, -0.04569149f, -0.15098865f, -0.08088235f, 0.12623464f, 0.05861343f, 0.23329198f, 0.31831601f, 
    0.11086068f, 0.09925517f, 0.03632099f, 0.04007805f, 0.17630675f, -0.05769698f, 0.08648829f, -0.08308557f, 
    0.12003663f, -0.01194742f, -0.11828620f, -0.32667157f, 0.07975824f, -0.02590455f, -0.15751024f, -0.16745010f, 
    0.15255257f, 0.10540766f, 0.00740897f, -0.07979198f, 0.25387305f, -0.00408926f, 0.05665971f, 0.29337984f, 
    -0.02455996f, -0.04123860f, -0.06741878f, -0.06940050f, -0.10222564f, 0.04134507f, 0.04297475f, 0.16929270f, 
    0.20806478f, 0.09074755f, 0.00962180f, -0.02618210f, 0.03073409f, 0.09920151f, 0.20747741f, -0.03280765f, 
    0.00584571f, -0.11488968f, 0.08113933f, 0.09021983f, -0.13728081f, 0.11479106f, -0.02005043f, 0.25043529f, 
    0.07924678f, 0.00489107f, 0.05470214f, 0.08975130f, -0.05549324f, -0.03365691f, 0.10945126f, 0.01807290f, 
    -0.23029998f, 0.04521253f, 0.14091252f, -0.17777047f, -0.02560291f, -0.10155991f, -0.01294609f, 0.04338974f, 
    0.11373283f, 0.15983303f, 0.18983223f, 0.10326105f, -0.14485179f, 0.29334354f, -0.41419661f, 0.36498007f, 
    0.06405108f, -0.02758633f, -0.09539843f, 0.03328298f, 0.01687874f, 0.05437497f, -0.01039945f, 0.07005682f, 
    0.03401342f, -0.03034595f, -0.01537668f, 0.15337613f, -0.04416405f, 0.08100191f, -0.01304624f, -0.02350692f, 
    0.20947734f, -0.06452788f, 0.15848993f, 0.11078985f, 0.06667335f, 0.07275189f, 0.07544360f, 0.11707757f, 
    0.05446737f, 0.06768577f, -0.01806540f, -0.01563519f, -0.01375558f, -0.07644645f, 0.04791006f, 0.01869716f, 
    0.12517126f, -0.02176808f, 0.03676942f, 0.03364502f, 0.16320880f, 0.03577921f, 0.03193967f, 0.03343998f, 
    0.04532832f, 0.02165212f, -0.04834655f, 0.10286028f, 0.24435541f, 0.05107852f, -0.06538495f, 0.17980163f, 
    -0.01276831f, 0.11446861f, -0.19418918f, 0.00193521f, -0.19424212f, 0.01418287f, -0.08294141f, 0.01951884f, 
    0.19086950f, 0.28474048f, -0.20925513f, 0.17888100f, 0.10972384f, -0.01396727f, -0.07258132f, -0.07925506f, 
    0.14031166f, -0.05710447f, 0.06474590f, -0.02641434f, -0.44546539f, 0.08354042f, 0.24655548f, -0.30695149f, 
    0.02570314f, 0.06490526f, -0.17225114f, 0.07755953f, -0.12626278f, -0.05048132f, -0.02940861f, 0.13506073f, 
    -0.62068009f, 0.20581330f, -0.06122829f, -0.11976555f, 0.24334785f, -0.09123979f, 0.22722076f, 0.19658615f, 
    -0.03796083f, -0.02642278f, 0.03097496f, -0.04310240f, -0.38234496f, -0.06434066f, 0.00969930f, 0.33367947f, 
    -0.02468197f, 0.00018473f, -0.00754891f, 0.08327165f, -0.04465119f, 0.11849219f, 0.16513340f, 0.04445411f, 
    0.08988456f, -0.08737186f, -0.16142961f, -0.03596761f, 0.03987522f, -0.08445211f, 0.02418521f, 0.10847598f, 
    0.14372356f, 0.01905006f, -0.02421921f, 0.00230020f, 0.06769731f, 0.10728659f, -0.09458618f, 0.22084270f, 
    0.03490049f, -0.03283927f, 0.20510149f, -0.02361548f, 0.06471232f, 0.02411601f, 0.12432215f, 0.16455129f, 
    -0.41038871f, -0.07621121f, -0.10963564f, 0.09191071f, 0.05905699f, 0.07087245f, -0.02558629f, 0.07931332f, 
    -0.04945086f, 0.00995259f, -0.03657352f, -0.05006758f, 0.02986441f, -0.05171214f, -0.06442618f, 0.40465316f, 
    -0.17519441f, -0.03086611f, -0.02955365f, 0.10372924f, -0.13743998f, 0.01859237f, -0.10826968f, 0.05666981f, 
    -0.26600558f, 0.07842124f, -0.00195580f, -0.11450215f, 0.03643879f, 0.03131586f, 0.06785174f, 0.02670759f, 
    -0.04532223f, -0.01573219f, -0.03237911f, 0.11132952f, -0.08073445f, 0.03045199f, 0.07823957f, -0.15024655f, 
    0.03457123f, 0.01634741f, 0.24340269f, 0.02299672f, 0.00910571f, 0.02398001f, 0.16442859f, -0.09446824f, 
    -0.00534857f, -0.00464157f, 0.04117057f, -0.30521545f, 0.29968971f, -0.14554532f, 0.11773429f, 0.06807795f, 
    -0.00569737f, -0.03623667f, 0.03884539f, -0.01986362f, -0.03326604f, -0.06600353f, -0.14115964f, 0.29782814f, 
    0.29670951f, -0.11031208f, -0.11267899f, 0.01622917f, 0.17757167f, 0.01302660f, -0.11774004f, -0.11728256f, 
    0.01833159f, 0.25354302f, 0.06972645f, 0.12399321f, 0.01730226f, 0.12084183f, -0.17524080f, -0.00458051f, 
    0.08344626f, 0.04814895f, -0.00503005f, 0.09374546f, -0.47653455f, 0.17789897f, 0.21706331f, 0.06526611f, 
    0.16755597f, 0.05221288f, 0.13389865f, 0.13771592f, 0.08708219f, -0.11439911f, 0.19697264f, -0.08504990f, 
    -0.02250500f, 0.42797518f, 0.07229688f, -0.36888462f, -0.07270505f, -0.05897999f, -0.08319771f, 0.06445125f, 
    -0.03760880f, 0.11327675f, -0.04969762f, -0.07798666f, 0.48501399f, 0.25591710f, -0.05291322f, 0.29870683f, 
    0.06383845f, 0.00516033f, -0.06294031f, 0.08310155f, -0.18467802f, -0.01715127f, 0.05197542f, -0.09568347f, 
    -0.13982312f, 0.24801257f, -0.30995324f, 0.21209665f, 0.07043591f, 0.15204147f, 0.08624748f, -0.08572941f, 
    -0.00299617f, -0.07445706f, 0.09723181f, 0.19694966f, 0.02637111f, 0.05928816f, 0.05385059f, -0.07423090f, 
    -0.05230268f, -0.01895355f, 0.21033376f, 0.07564627f, -0.16736847f, -0.07400747f, -0.08976575f, 0.32208103f, 
    -0.12276504f, 0.05838591f, 0.06699216f, -0.13886273f, 0.15817532f, -0.03114551f, -0.01401432f, 0.05358980f, 
    0.04572962f, 0.04371769f, -0.05590434f, -0.03185178f, -0.05025031f, 0.11490723f, 0.13844803f, 0.13217418f, 
    0.22121479f, 0.01398071f, 0.15988684f, 0.02177894f, -0.08484572f, 0.09350900f, 0.12122336f, 0.03976030f, 
    0.33782870f, 0.12001685f, -0.09741233f, -0.23612496f, 0.09293765f, -0.14350636f, -0.01099166f, -0.09586535f, 
    -0.05042920f, 0.03999535f, 0.14770207f, 0.05590912f, -0.01993893f, -0.05660472f, -0.05168423f, 0.09846444f, 
    -0.01532614f, -0.07241350f, -0.03756634f, 0.04813932f, 0.05235479f, 0.03377937f, 0.09418720f, 0.06537620f, 
    -0.20817678f, 0.20315020f, 0.09368983f, 0.03592342f, 0.02598891f, 0.01322870f, 0.21942429f, 0.15848741f, 
    0.09191942f, 0.22817834f, -0.09313750f, -0.17808315f, -0.14947444f, -0.07020960f, -0.13570684f, 0.18854831f, 
    -0.00940686f, -0.04799731f, -0.01162043f, 0.07072597f, -0.18001141f, -0.16962688f, 0.03020031f, 0.03703871f, 
    0.00380840f, 0.16748138f, -0.01589927f, -0.17701921f, 0.09450432f, -0.04806880f, -0.12355101f, -0.12498964f, 
    -0.00301999f, 0.27435198f, 0.01677722f, -0.08721533f, 0.13961679f, 0.13054533f, -0.12428571f, 0.10425268f, 
    0.02481851f, -0.09781878f, -0.00911792f, -0.00012251f, -0.10520278f, -0.00344444f, 0.08693738f, -0.06623067f, 
    -0.05311135f, 0.25273010f, -0.12722571f, -0.39112321f, 0.02762459f, 0.13097084f, 0.10889123f, 0.06499183f, 
    0.07846236f, -0.14272159f, -0.14135556f, -0.13819726f, -0.35446551f, 0.01252312f, 0.10014585f, 0.36340591f, 
    0.11530429f, -0.06415987f, 0.04037322f, -0.07818019f, 0.05361170f, -0.07465843f, -0.08450973f, -0.03111817f, 
    -0.13111950f, -0.01180321f, 0.06647336f, -0.09948713f, 0.03772993f, -0.14302267f, 0.06077671f, 0.14693290f, 
    -0.07766958f, 0.05923700f, -0.10368577f, -0.05775901f, 0.31440154f, 0.02843269f, 0.11486212f, -0.03409702f, 
    -0.04959228f, -0.04535097f, -0.00551319f, -0.09010843f, -0.00755233f, 0.07597055f, -0.10844853f, 0.04218199f, 
    0.25430134f, 0.13000309f, -0.00690835f, 0.00027879f, -0.19393083f, -0.13589381f, 0.04062399f, 0.05607872f, 
    0.05409308f, 0.03277410f, -0.00844759f, 0.12819389f, -0.17360801f, -0.09331969f, 0.01271314f, -0.33260477f, 
    -0.00376687f, -0.11575688f, 0.15965632f, -0.06065224f, 0.22772132f, 0.05697996f, 0.06919234f, -0.07433234f, 
    -0.07715184f, -0.34315464f, 0.16161838f, -0.13257691f, -0.07753316f, 0.01848636f, 0.11837987f, 0.15847053f, 
    -0.09453582f, -0.01740910f, -0.07679044f, 0.02830373f, 0.39860365f, -0.06873304f, -0.10576770f, 0.27535045f, 
    0.06696024f, -0.08701941f, 0.09738589f, -0.14256491f, 0.02936712f, -0.00326182f, -0.07907124f, -0.08409457f, 
    0.33968550f, -0.06179265f, -0.11629084f, 0.01734823f, 0.04769954f, 0.04555132f, -0.27178016f, -0.04215522f, 
    0.04029703f, -0.04218020f, 0.08849929f, 0.06725724f, 0.16651715f, 0.02306778f, -0.15226980f, -0.31287196f, 
    0.11957988f, -0.08793254f, -0.02441456f, 0.12047710f, 0.08435642f, -0.15525317f, 0.07901458f, -0.01067896f, 
    0.05512465f, 0.30618280f, 0.15940505f, 0.08650248f, 0.01292274f, 0.25460383f, 0.06916634f, -0.01507715f, 
    -0.03537186f, -0.01360698f, -0.01078473f, 0.16021572f, 0.04225068f, -0.03948240f, -0.02815872f, -0.24664693f, 
    0.00728697f, 0.01216371f, 0.01000722f, 0.04750495f, 0.06473045f, -0.14652279f, -0.22205706f, -0.06519021f, 
    0.37194461f, -0.16289915f, 0.18705936f, 0.05810222f, 0.02612829f, -0.05522991f, -0.11006938f, 0.06017719f, 
    0.15537289f, -0.02422215f, -0.03400602f, 0.13456549f, -0.09953845f, 0.08796310f, 0.10667043f, -0.39445361f, 
    0.07411315f, 0.00236531f, 0.12293383f, 0.03953171f, 0.04072473f, 0.10624983f, 0.04953151f, 0.05476443f, 
    -0.01100983f, -0.14296925f, -0.00563968f, 0.05100295f, -0.03037998f, 0.00478794f, -0.07103091f, 0.17087942f, 
    0.06658356f, 0.03440726f, 0.06773764f, -0.06766237f, 0.07022503f, -0.00624409f, 0.10453776f, 0.08833764f, 
    0.02663475f, -0.00793140f, -0.10250468f, -0.13991643f, -0.00494948f, -0.05927993f, 0.00006380f, 0.12116407f, 
    0.16259055f, -0.08285006f, -0.07828923f, 0.20395692f, -0.03065870f, 0.14488061f, -0.13730730f, -0.00005657f, 
    -0.00801345f, 0.00861145f, -0.06552958f, 0.10582145f, 0.18395019f, -0.24228953f, 0.14388104f, -0.18032296f, 
    -0.16930498f, 0.12435740f, 0.15428570f, 0.08349524f, -0.06018271f, 0.09710576f, 0.09493659f, 0.04412724f, 
    -0.17594640f, -0.24537383f, -0.35019818f, -0.00778223f, 0.01371514f, 0.09246188f, 0.06634139f, -0.00879375f, 
    0.25432038f, 0.01798682f, 0.18584597f, -0.04324478f, 0.07638248f, 0.18646678f, -0.13871588f, 0.17790943f, 
    0.10125002f, 0.04979623f, -0.00611857f, 0.15845680f, 0.09627261f, 0.08549021f, -0.01717987f, -0.03977869f, 
    -0.18460929f, 0.26922479f, 0.28553742f, 0.00689777f, -0.01923695f, -0.04699201f, 0.06338725f, 0.02435531f, 
    -0.01060095f, 0.08187175f, 0.02656538f, 0.01404714f, -0.43872595f, -0.36346620f, -0.13738546f, 0.04619348f, 
    -0.03059078f, 0.03651316f, -0.05618919f, -0.14447942f, 0.14019793f, 0.01351006f, 0.11893762f, 0.23647763f, 
    -0.26805654f, 0.06839716f, -0.07517275f, 0.18401831f, 0.01137496f, 0.10322951f, 0.09683972f, -0.01537565f, 
    0.18334693f, -0.12141149f, 0.01097011f, -0.06083932f, 0.00828194f, -0.07530400f, 0.09531865f, -0.16430840f, 
    0.19203314f, -0.02414274f, -0.22499445f, 0.01168828f, -0.14633884f, 0.00641016f, -0.05766056f, 0.03105035f, 
    -0.35654074f, -0.25650567f, -0.18468836f, -0.61898720f, 0.10065898f, 0.07933982f, 0.06714807f, 0.11576696f, 
    0.06453333f, -0.01551162f, -0.05119494f, 0.08911224f, -0.44220695f, -0.50205475f, -0.55976206f, -0.11640854f, 
    0.03127046f, -0.01813542f, -0.15906924f, -0.08338138f, 0.18346924f, -0.16257010f, 0.04376109f, 0.05107460f, 
    0.03244376f, 0.05484288f, 0.24779834f, 0.13361274f, 0.04658763f, 0.02118916f, 0.04508220f, 0.14925422f, 
    0.13013139f, 0.01882352f, -0.04153012f, 0.00347808f, 0.03795613f, 0.06151545f, -0.11026774f, 0.06470791f, 
    0.10668065f, 0.15714443f, 0.05058734f, -0.04463367f, -0.03980768f, -0.19214262f, -0.13785304f, 0.05383946f, 
    -0.10848840f, -0.02374927f, 0.03767160f, -0.13914476f, 0.02684509f, 0.04874996f, -0.27586755f, -0.10855003f, 
    0.16722766f, -0.09937596f, -0.07435133f, -0.02976614f, 0.19646929f, -0.03516997f, -0.01020737f, 0.30253589f, 
    -0.25269371f, 0.04260337f, 0.08248336f, -0.08868535f, 0.01086293f, 0.15193692f, -0.09590984f, 0.13882987f, 
    0.05431666f, 0.28341779f, -0.02605898f, -0.22816300f, 0.06948606f, 0.11420380f, 0.12687106f, -0.00071213f, 
    -0.02287449f, -0.16800612f, -0.04844929f, 0.12304635f, -0.29106456f, -0.06726461f, -0.04766617f, 0.33840844f, 
    0.17618060f, -0.08688082f, 0.21344687f, 0.07698797f, 0.03583679f, 0.05406697f, 0.09305914f, -0.07691428f, 
    -0.07932769f, 0.31126374f, 0.26592153f, -0.19035417f, 0.04921589f, -0.13161132f, 0.06517144f, -0.02494979f, 
    -0.00299034f, 0.06291945f, 0.02170001f, 0.04179213f, -0.18897600f, -0.33155474f, 0.15049674f, 0.48844525f, 
    0.25159684f, 0.01183054f, -0.03426453f, -0.00779354f, 0.07751187f, 0.14538135f, 0.17970799f, 0.01849916f, 
    0.10607983f, 0.23631793f, 0.02870124f, 0.16829352f, 0.00825495f, 0.06515785f, -0.11691412f, -0.09512629f, 
    -0.04736391f, -0.11398856f, -0.06661522f, 0.02947022f, -0.16354254f, 0.07581018f, -0.02774835f, 0.00343833f, 
    0.15631720f, 0.08348732f, 0.06787577f, 0.07421292f, 0.05953930f, -0.08472670f, -0.10963479f, 0.25129163f, 
    -0.37837228f, -0.25638980f, -0.31135181f, -0.03128268f, 0.13427912f, 0.12921958f, -0.12764680f, -0.19984855f, 
    0.03567162f, 0.08551350f, 0.04694811f, -0.02925781f, -0.04150295f, 0.32326084f, 0.21553130f, 0.07582181f, 
    0.15522936f, 0.00065280f, 0.03820053f, 0.12109412f, 0.05948195f, 0.10337906f, -0.01252604f, 0.01227293f, 
    -0.28514484f, 0.36639270f, -0.05329902f, 0.23503862f, -0.00882873f, 0.16483420f, 0.01031492f, -0.03221107f, 
    0.11322435f, -0.10749664f, -0.03412474f, 0.06429739f, 0.00998486f, -0.14726964f, 0.03014986f, -0.20622770f, 
    -0.01539231f, -0.01146852f, 0.08171539f, -0.02388812f, 0.21609427f, -0.02136970f, 0.09683304f, 0.08405918f, 
    -0.02020838f, 0.07117219f, 0.18502809f, -0.00196830f, -0.01938405f, -0.01727406f, 0.05355742f, -0.11318857f, 
    0.03918458f, 0.13470607f, -0.08957179f, 0.02657239f, 0.29414740f, 0.21200112f, 0.20710276f, 0.17757264f, 
    -0.15047982f, 0.04574488f, 0.01579810f, -0.00441397f, -0.12719198f, 0.07587122f, -0.19472016f, -0.03921640f, 
    -0.18438824f, -0.06823391f, -0.22643697f, -0.17852317f, 0.16604303f, 0.09620583f, -0.12047537f, -0.15909262f, 
    0.01048946f, 0.02658151f, -0.09589862f, -0.05426858f, -0.18237804f, 0.12831874f, 0.03217275f, 0.16719434f, 
    0.08778875f, -0.04933726f, -0.00695728f, 0.00605349f, 0.01885596f, -0.08358433f, 0.05278644f, 0.06458049f, 
    -0.10891702f, 0.08130110f, -0.03076951f, 0.12652488f, -0.00320906f, 0.09223963f, -0.00253985f, -0.05249648f, 
    0.13330680f, 0.15075171f, -0.08828592f, -0.11383200f, 0.18223587f, 0.13704531f, -0.18945158f, 0.07068703f, 
    -0.00160277f, 0.07968328f, 0.00868764f, 0.02728150f, 0.12655377f, 0.14705807f, 0.01619110f, -0.02762132f, 
    0.01529688f, 0.04092759f, 0.03039951f, -0.20420839f, 0.03822447f, -0.08429637f, 0.01143762f, 0.01502215f, 
    0.03721036f, 0.04151922f, 0.08826488f, 0.11468267f, 0.44310212f, 0.17666240f, -0.01143787f, -0.15799898f, 
    0.11681496f, 0.04041635f, -0.14293957f, 0.16917041f, -0.04139381f, 0.11035456f, 0.03893030f, -0.02367761f, 
    -0.19717181f, 0.00174959f, 0.03163827f, -0.07807030f, 0.04359136f, -0.21347554f, 0.12673336f, -0.07782932f, 
    -0.14271808f, -0.02337690f, -0.01170061f, 0.09086554f, -0.11760340f, 0.21926554f, 0.18610588f, -0.08923742f, 
    -0.01687824f, -0.00800114f, -0.12440355f, 0.07882153f, 0.05031782f, -0.01264677f, -0.01296202f, -0.03658061f, 
    0.33081305f, -0.26688561f, -0.02918554f, 0.08438797f, 0.00739798f, -0.16485399f, 0.25513601f, 0.00068208f, 
    0.07754939f, 0.04010416f, 0.11762111f, 0.10184858f, 0.25571957f, -0.05909272f, -0.08672367f, -0.10445431f, 
    -0.01473529f, 0.07765170f, -0.05141241f, -0.05525678f, -0.07499974f, 0.08046880f, -0.10263970f, 0.06274824f, 
    0.40842733f, -0.28396067f, -0.00591673f, 0.21295920f, -0.02995475f, 0.00099444f, 0.04378087f, 0.08865058f, 
    0.14861338f, -0.02726917f, -0.06754228f, 0.24030264f, -0.12219258f, -0.29687029f, -0.17579399f, -0.27151212f, 
    -0.01646152f, 0.14867623f, -0.10653671f, -0.11461788f, 0.02147820f, 0.01839671f, -0.12207881f, 0.06086897f, 
    0.32058921f, -0.13323829f, 0.19394541f, 0.05213976f, 0.07459664f, -0.13397358f, -0.03747064f, 0.05129630f, 
    0.13090688f, -0.01079699f, 0.04774637f, -0.05311448f, -0.17159790f, 0.01251649f, 0.16770509f, 0.08722356f, 
    0.07059152f, -0.00891249f, -0.22088286f, 0.03006856f, -0.05917107f, -0.00706628f, -0.00179216f, -0.07403509f, 
    -0.55542153f, 0.25097328f, -0.25351790f, 0.03114054f, 0.14846249f, -0.06122613f, 0.10152408f, 0.07327652f, 
    0.00232403f, -0.04557285f, 0.08701286f, 0.03297265f, -0.08682115f, -0.01459625f, -0.13531224f, -0.21734385f, 
    -0.03658149f, -0.03286115f, -0.19367775f, -0.17940301f, 0.11279090f, -0.05194092f, -0.06631920f, -0.10961460f, 
    -0.01665401f, -0.20043947f, 0.06637759f, 0.16367628f, -0.11555349f, 0.08312450f, 0.06419127f, 0.15344386f, 
    0.10599855f, -0.02262146f, 0.01539020f, -0.01834171f, 0.23770219f, 0.12351277f, 0.15644659f, 0.13508908f, 
    0.01839455f, 0.05263307f, 0.18728939f, 0.16547063f, 0.19832565f, -0.06235086f, -0.09076148f, 0.08910943f, 
    -0.18397214f, -0.21464992f, -0.05619080f, -0.20333432f, 0.13307311f, 0.05105146f, -0.07060986f, -0.03020261f, 
    0.00479080f, -0.07693353f, -0.06051756f, 0.11725129f, 0.07099287f, -0.01251123f, 0.25130960f, 0.28902581f, 
    0.06928989f, 0.00336455f, 0.14944105f, -0.06766446f, 0.06821577f, 0.10995168f, 0.03291837f, 0.10612558f, 
    0.00225537f, -0.18923952f, 0.08503568f, 0.15292038f, 0.01144273f, 0.07465503f, 0.16990109f, 0.21843848f, 
    0.21522814f, -0.09595449f, -0.00116910f, 0.19772847f, -0.24123156f, -0.07957537f, 0.13336344f, -0.05752763f, 
    0.05673963f, 0.05033532f, 0.06450741f, -0.02436914f, 0.00178992f, 0.07688153f, 0.03641739f, 0.01448913f, 
    0.22652540f, -0.16144323f, 0.17585452f, 0.02376792f, 0.16476966f, 0.00650516f, 0.00190669f, 0.15080029f, 
    0.15673862f, 0.04411709f, 0.17190591f, 0.24460481f, 0.25763822f, -0.23402180f, -0.21612963f, 0.04012832f, 
    0.11676961f, -0.01518701f, -0.05864381f, 0.09654873f, 0.01254108f, 0.14274928f, 0.01893399f, -0.02969646f, 
    -0.24137093f, 0.05440950f, -0.10241244f, -0.11607318f, -0.09656165f, -0.11495622f, 0.09071776f, -0.00995763f, 
    0.01606037f, 0.07093228f, 0.16600327f, -0.06118314f, 0.27599889f, -0.01464085f, -0.18318637f, 0.04627544f, 
    -0.03845773f, 0.06593843f, -0.11576623f, -0.12875727f, 0.02638696f, -0.01358070f, -0.12506069f, 0.18415023f, 
    -0.18387307f, -0.15815441f, 0.31242087f, 0.15314429f, -0.06621633f, -0.09587663f, 0.10580039f, -0.03767505f, 
    0.01513039f, -0.08240287f, 0.07726209f, 0.12681963f, -0.09189681f, -0.09262566f, 0.01093736f, -0.28997898f, 
    0.10292228f, -0.04160281f, 0.08271189f, 0.01301153f, 0.14526568f, -0.11456028f, -0.00323905f, 0.34044826f, 
    0.29038864f, -0.30747613f, 0.07167489f, -0.01789103f, -0.14786875f, 0.12052154f, 0.00128764f, 0.08837686f, 
    -0.07564159f, 0.02188795f, 0.06840464f, -0.16527252f, 0.33725375f, 0.10581911f, 0.02295621f, 0.19206527f, 
    0.06553488f, -0.06258093f, -0.09017599f, -0.02663602f, 0.00644554f, 0.03155348f, 0.06692968f, -0.07745399f, 
    -0.59183753f, 0.04210256f, -0.03330690f, -0.08274131f, 0.01200846f, 0.08082273f, -0.02674349f, 0.00380808f, 
    0.09159179f, 0.00236947f, 0.01499130f, 0.06624062f, -0.29033139f, -0.29702160f, 0.03171616f, -0.16001572f, 
    -0.01737860f, 0.15205817f, -0.19960929f, 0.09461395f, 0.18222579f, -0.09729256f, -0.16643243f, -0.02288756f, 
    0.10182086f, 0.20847528f, 0.14774755f, 0.23226109f, -0.04337495f, 0.15710482f, 0.02427837f, 0.14597169f, 
    0.10681117f, -0.08135312f, -0.03386563f, 0.05189922f, 0.16677566f, -0.00561298f, 0.17452407f, -0.02770389f, 
    0.02390852f, 0.20447299f, 0.04962491f, 0.09517937f, 0.03164251f, -0.30134997f, -0.04324109f, -0.02681498f, 
    0.22013594f, -0.14590020f, -0.05693245f, -0.01852539f, -0.05825592f, -0.02129468f, -0.38786322f, -0.12918034f, 
    -0.06001467f, -0.20239407f, 0.13290773f, 0.05024612f, 0.02681037f, 0.17017061f, 0.29465160f, -0.24276580f, 
    -0.05474558f, 0.08876566f, 0.12562028f, -0.04667092f, 0.21078257f, 0.12336760f, 0.16507018f, 0.05279102f, 
    -0.00717778f, -0.25601330f, 0.20423591f, 0.11359956f, -0.13291653f, 0.05345860f, 0.10400702f, 0.13000332f, 
    0.04927711f, -0.17934822f, 0.06778403f, 0.05682368f, 0.13256356f, -0.35431525f, -0.05050820f, 0.07814898f, 
    0.01717881f, 0.12335844f, 0.07120416f, -0.04085903f, 0.17734875f, 0.01892041f, 0.10327193f, 0.02550953f, 
    0.09370798f, 0.09138243f, 0.06297000f, 0.15147203f, -0.00348779f, -0.09720910f, -0.01230020f, -0.02939509f, 
    -0.03472555f, 0.19510099f, 0.10539372f, 0.27227271f, 0.18579032f, 0.40334901f, 0.01787336f, -0.04587260f, 
    0.04593544f, 0.07336441f, -0.04777335f, 0.00055960f, -0.03742188f, 0.18115786f, -0.08465827f, 0.07875311f, 
    -0.03816556f, -0.03372769f, 0.02319106f, -0.06903105f, 0.00708802f, 0.01745370f, 0.03342895f, -0.02852247f, 
    -0.02734723f, 0.04512643f, 0.03847937f, 0.04889772f, -0.06985547f, -0.05231933f, -0.04740337f, 0.01221934f, 
    0.05874585f, -0.01254681f, -0.05619286f, -0.02899962f, -0.05533893f, -0.04427324f, -0.06170245f, -0.05680841f, 
    0.06165797f, -0.03661218f, -0.04293482f, -0.06741450f, -0.06395971f, 0.03920048f, 0.02402607f, -0.04068686f, 
    -0.04438801f, 0.00839971f, -0.06463787f, -0.02869714f, 0.02388814f, -0.00818994f, 0.00328827f, -0.05451568f, 
    -0.05112266f, 0.00489660f, 0.04954686f, -0.05711374f, 0.06470308f, 0.04139806f, -0.06071725f, 0.02959836f, 
    0.00447968f, -0.01111091f, 0.03430334f, -0.00464218f, 0.00538720f, 0.00435195f, 0.02526779f, -0.07276860f, 
    -0.04632537f, -0.00323706f, -0.02300299f, -0.03666888f, -0.04612888f, 0.02835155f, -0.03695475f, -0.00843339f, 
    0.02143206f, -0.02434722f, -0.05521861f, 0.05021596f, -0.02746870f, -0.00990095f, -0.03930537f, -0.03431537f, 
    0.05059754f, -0.05580209f, 0.01209104f, 0.00052097f, -0.02860776f, -0.02186385f, -0.01906105f, -0.04055153f, 
    -0.06214312f, -0.04965664f, -0.06639480f, 0.01727468f, -0.01225806f, -0.06808092f, -0.05891677f, 0.05248983f, 
    -0.05921813f, 0.03894110f, 0.01062917f, -0.06855448f, 0.05502968f, 0.03056187f, 0.03654647f, 0.06453328f, 
    0.04233221f, -0.06982981f, -0.00000855f, 0.04515412f, -0.03769456f, -0.07231101f, -0.03415149f, -0.01618646f, 
    -0.04247585f, -0.01582803f, 0.01558424f, 0.05552523f, 0.06076460f, -0.03734664f, -0.05618352f, 0.00446773f, 
    -0.03361532f, -0.05231851f, 0.05922580f, -0.06357671f, 0.02498043f, 0.02748491f, -0.04915801f, -0.03596761f, 
    -0.01737309f, -0.06576228f, 0.03180400f, 0.02623613f, -0.07473285f, -0.01852357f, -0.03045731f, 0.00726045f, 
    0.00301501f, 0.01990851f, 0.02831071f, 0.04764703f, -0.03357852f, -0.06629373f, -0.03379265f, -0.01209623f, 
    0.06235636f, -0.03793174f, 0.03947729f, -0.01796410f, -0.06176722f, 0.03436884f, -0.04910067f, 0.02437266f, 
    -0.04703468f, -0.02389183f, -0.03622669f, -0.00444036f, 0.05140194f, 0.01884769f, -0.05784793f, 0.00515768f, 
    -0.02150219f, -0.05835775f, 0.02642035f, 0.00271764f, -0.05018431f, 0.00460612f, -0.01495656f, 0.06232410f, 
    -0.03929624f, -0.06847154f, 0.05535187f, -0.02641182f, 0.00300268f, -0.00590635f, -0.04930188f, 0.04404337f, 
    -0.04235949f, 0.04042752f, -0.05477996f, -0.06944680f, 0.01137288f, -0.04004690f, -0.02372815f, -0.06484693f, 
    -0.00809713f, -0.06589486f, -0.03031470f, 0.01021127f, -0.00548022f, 0.00457161f, 0.02824534f, -0.01786709f, 
    0.01740782f, -0.00647038f, -0.00097690f, 0.01678463f, -0.07584567f, 0.02087327f, 0.04077179f, -0.05181414f, 
    0.00423512f, -0.07625215f, 0.01195058f, 0.01907494f, -0.03551933f, 0.04096619f, 0.02465681f, 0.00907345f, 
    0.00461474f, 0.02256046f, 0.04316708f, 0.05407215f, -0.08918323f, 0.02052134f, 0.03375417f, -0.07167915f, 
    -0.04986649f, 0.02749704f, -0.02976420f, 0.00037067f, 0.01082952f, -0.00631824f, 0.03219928f, -0.04328692f, 
    -0.04451070f, -0.02759494f, -0.04853014f, -0.01342305f, -0.03835189f, -0.06906492f, 0.01252918f, 0.05433477f, 
    0.04610664f, 0.05675873f, -0.03696178f, -0.03338429f, 0.05038108f, 0.01799047f, -0.08819091f, 0.01879293f, 
    -0.06803574f, -0.00347270f, 0.00824923f, 0.05052434f, -0.05930168f, 0.04798257f, 0.03250002f, -0.05261420f, 
    -0.07783670f, -0.07114640f, -0.02912880f, -0.05054975f, -0.06126729f, -0.08463529f, -0.04250012f, -0.06101565f, 
    -0.05176622f, -0.04608379f, -0.00701135f, 0.02321658f, 0.04028183f, 0.06059499f, -0.00564308f, 0.00590619f, 
    0.02501211f, -0.00333714f, -0.05754434f, 0.01410926f, -0.07529777f, 0.02850236f, -0.02202931f, -0.04163474f, 
    -0.03381136f, 0.03449076f, -0.05925428f, 0.00109491f, 0.05764092f, 0.00909509f, -0.03247753f, -0.04380577f, 
    -0.05474008f, -0.02300230f, -0.07522998f, -0.07550513f, 0.01787744f, 0.00930125f, 0.00606753f, -0.01665164f, 
    -0.01718035f, 0.01141131f, 0.05917761f, -0.07489742f, 0.01030022f, -0.02200697f, -0.03840404f, -0.08468817f, 
    0.02092073f, -0.05989583f, -0.00975611f, -0.07452205f, 0.05690242f, -0.03114016f, -0.07526302f, -0.01791878f, 
    0.04831864f, -0.05263920f, -0.05903707f, 0.03935784f, 0.00130424f, -0.04447905f, -0.05017106f, -0.02466617f, 
    0.05386567f, -0.05593898f, -0.00106378f, 0.00637509f, -0.01643499f, -0.05725929f, -0.04782647f, 0.02518415f, 
    0.00942095f, -0.08554505f, 0.02752189f, 0.06222906f, 0.03647837f, -0.02243036f, -0.07222255f, 0.00212363f, 
    0.00479450f, -0.03813039f, -0.05701555f, -0.04202190f, -0.03112270f, 0.01261105f, -0.00784695f, 0.03714934f, 
    0.03829776f, 0.04330736f, 0.02086607f, -0.08698265f, 0.01466081f, -0.00852491f, -0.03268613f, -0.05878760f, 
    0.02235168f, 0.00650144f, -0.05939907f, 0.01647231f, -0.03947626f, -0.08000423f, 0.03127523f, 0.03792997f, 
    0.05815737f, 0.01438359f, 0.02787929f, 0.00626431f, -0.00738845f, 0.06333649f, 0.03725573f, -0.06937465f, 
    -0.00100663f, -0.01309316f, -0.08347949f, 0.03573973f, -0.06432848f, 0.04300630f, -0.01980919f, 0.01662752f, 
    0.03230413f, -0.08964553f, 0.02998281f, 0.00255195f, 0.00893313f, 0.05082921f, -0.02404636f, 0.04572022f, 
    -0.06674652f, -0.05496988f, -0.03631699f, 0.03890262f, -0.06151671f, -0.00915680f, -0.03027895f, -0.00698314f, 
    -0.04185003f, -0.06877032f, -0.00600239f, 0.01219043f, -0.00939950f, -0.06907050f, -0.04271396f, 0.03806477f, 
    -0.28617266f, -0.04237661f, 0.02212881f, -0.11863607f, -0.04074317f, 0.15403986f, -0.10822347f, -0.03979788f, 
    0.08695706f, 0.09301767f, 0.17389558f, 0.02997208f, 0.22560033f, 0.06398506f, -0.01823544f, 0.21138522f, 
    -0.00656129f, -0.08090629f, 0.18100719f, -0.05619549f, 0.07787271f, -0.11586680f, 0.13637055f, -0.18453060f, 
    0.47847900f, 0.46105310f, 0.40496871f, 0.09338947f, 0.08351988f, -0.07845230f, 0.03366304f, -0.04576830f, 
    0.00074143f, -0.02685875f, -0.02862807f, 0.09664738f, 0.18710294f, 0.02372815f, -0.15306294f, 0.16355421f, 
    0.11815088f, -0.01469166f, -0.08305724f, 0.04968723f, -0.07847508f, -0.15739797f, -0.01722139f, 0.02799797f, 
    -0.21190771f, 0.15742689f, -0.14478962f, -0.00051071f, -0.01632067f, -0.11428188f, 0.11856503f, -0.05519858f, 
    0.02123147f, 0.04576699f, 0.10346836f, 0.09562158f, -0.01882282f, 0.43746316f, -0.12205088f, -0.16877876f, 
    0.12812597f, -0.04518453f, 0.13442224f, 0.13766347f, -0.10520228f, 0.04090606f, -0.07107943f, 0.23595072f, 
    -0.34273836f, -0.17644781f, -0.03784381f, -0.27100530f, 0.29076406f, 0.11259855f, 0.10170557f, 0.12495629f, 
    0.05592606f, -0.10910855f, 0.01254798f, -0.09846772f, -0.43014717f, -0.27863365f, -0.06400087f, 0.25839931f, 
    0.21030563f, 0.06268382f, 0.25442597f, 0.28042915f, -0.15499292f, -0.10680437f, 0.13189486f, -0.01992098f, 
    0.53756690f, 0.32452723f, 0.02863133f, 0.06042619f, 0.09734067f, -0.05832258f, -0.11416036f, -0.14947550f, 
    0.01236416f, -0.06369125f, 0.15571693f, 0.11727999f, -0.12708271f, -0.28249070f, -0.21669759f, -0.01341999f, 
    -0.03707039f, -0.01824937f, 0.12481032f, -0.00304808f, -0.08671147f, 0.06165632f, 0.14488755f, -0.04534801f, 
    0.05364583f, 0.10328807f, -0.05020731f, 0.07900477f, 0.02915226f, 0.09356628f, 0.02060308f, 0.21825135f, 
    -0.07838245f, 0.03530127f, 0.10014339f, 0.06996656f, -0.26266661f, 0.04213619f, -0.06606343f, 0.00117123f, 
    -0.20095679f, -0.14211255f, -0.05045510f, 0.03061640f, 0.05412756f, -0.03780415f, -0.09853348f, -0.04209665f, 
    -0.10821842f, 0.13750786f, -0.10231143f, -0.15073550f, -0.08113947f, -0.08732825f, -0.06076856f, -0.05860395f, 
    0.00743564f, 0.14467400f, 0.09835587f, 0.02060533f, -0.17466156f, 0.08081824f, -0.10678916f, 0.00936934f, 
    -0.13741431f, -0.15867671f, 0.07199445f, -0.00812962f, 0.08138163f, -0.00392360f, 0.08614533f, 0.04147007f, 
    0.09985729f, 0.39320335f, 0.07780945f, -0.06396530f, 0.25096416f, -0.03065595f, -0.04914610f, -0.06520477f, 
    -0.00980982f, 0.05665107f, 0.04096757f, -0.03047645f, -0.09855750f, 0.30654323f, -0.00372023f, 0.16195633f, 
    0.15508223f, 0.05198430f, 0.17020166f, 0.02704453f, 0.06827004f, -0.01072624f, 0.03786278f, -0.11162879f, 
    0.15762854f, 0.03213158f, -0.07403501f, -0.01655540f, -0.03611033f, 0.06659409f, 0.12885498f, 0.08913307f, 
    0.06392093f, 0.05875072f, 0.15916085f, 0.00640473f, -0.04479475f, 0.06802936f, -0.13442753f, -0.14463885f, 
    -0.07424474f, 0.13745876f, -0.11715279f, 0.06587672f, -0.08741243f, 0.01868004f, -0.00262104f, -0.06753939f, 
    0.22029600f, 0.03867348f, -0.00896387f, 0.19329186f, 0.02102697f, 0.09276529f, 0.21340625f, 0.06901848f, 
    -0.16309813f, -0.12229856f, -0.02402331f, -0.02714246f, 0.07656273f, -0.04046227f, -0.04374796f, 0.34341303f, 
    0.01245056f, 0.08288383f, -0.02020841f, -0.13377021f, 0.07150508f, -0.10186683f, -0.11059672f, 0.08553400f, 
    0.30599019f, 0.01910454f, 0.11002885f, -0.11979373f, -0.04720544f, 0.02800565f, 0.00595084f, 0.09276212f, 
    -0.06954687f, -0.01049405f, -0.00399656f, -0.03619937f, 0.12034011f, 0.19965157f, -0.08868591f, -0.09609034f, 
    -0.02480358f, 0.03945727f, -0.23027544f, 0.05779502f, -0.00168818f, 0.06223652f, 0.08875656f, -0.17005479f, 
    -0.12670675f, -0.03480745f, 0.07816373f, -0.28020898f, -0.03586302f, -0.04709807f, 0.01156509f, 0.07354627f, 
    0.02078503f, 0.06446638f, 0.07374548f, -0.00904122f, -0.05875432f, -0.02112715f, 0.00979692f, 0.10597168f, 
    0.12975240f, 0.11483021f, -0.05776059f, 0.06835954f, 0.12697473f, -0.03843597f, -0.01197812f, 0.03612132f, 
    0.08614770f, -0.36123300f, 0.14242917f, 0.26816240f, 0.01884956f, -0.13646078f, 0.14431019f, 0.00921468f, 
    0.11321194f, -0.07745554f, -0.05750590f, -0.16706954f, 0.03623432f, -0.05266839f, 0.12036234f, 0.23017244f, 
    0.09790170f, -0.01333909f, 0.06057004f, -0.04334299f, -0.03601228f, 0.04264211f, -0.00139497f, 0.02179041f, 
    0.27093124f, 0.19362567f, -0.10063960f, -0.14888589f, -0.10276811f, -0.04864359f, -0.06591865f, -0.05522911f, 
    -0.02703790f, 0.07079346f, 0.13379183f, 0.01652138f, -0.04603463f, -0.09660742f, 0.01652209f, 0.23683888f, 
    -0.06656257f, -0.07801013f, -0.11869720f, -0.07825111f, 0.07179759f, -0.00387100f, 0.00643979f, 0.00129036f, 
    0.09534947f, 0.15939991f, -0.07165537f, 0.03000321f, -0.05073883f, 0.07406534f, 0.12868392f, -0.16681845f, 
    -0.02776640f, -0.07613749f, 0.09074213f, 0.06297733f, -0.17905253f, 0.05598698f, -0.11836951f, 0.25669256f, 
    -0.03036991f, -0.01987991f, 0.12824634f, 0.14868899f, 0.03044458f, -0.18635947f, 0.07553161f, -0.07313223f, 
    0.05098950f, 0.04367825f, 0.18324658f, 0.13297462f, -0.11633067f, 0.12405429f, 0.07377216f, -0.04035848f, 
    0.04780138f, 0.05087702f, 0.19228223f, -0.02232439f, 0.04470747f, 0.41851047f, -0.37347224f, 0.30060339f, 
    0.07748068f, -0.04344386f, 0.01802968f, 0.09111788f, 0.02984003f, 0.02091886f, 0.09248184f, 0.09701520f, 
    0.05474584f, 0.03832898f, -0.06944982f, -0.04021844f, 0.02384572f, 0.04157443f, 0.02249814f, -0.00369613f, 
    0.03863293f, -0.04303183f, -0.04440779f, -0.01560581f, -0.05062553f, -0.03117737f, -0.01125076f, 0.03953331f, 
    -0.02107399f, 0.03658063f, -0.05055297f, -0.07518076f, -0.00137522f, 0.04287364f, 0.00004242f, -0.01089888f, 
    0.02132621f, 0.05687675f, 0.01233549f, -0.00717939f, -0.03224780f, 0.04712479f, -0.06527740f, -0.01531259f, 
    0.04801511f, 0.02345178f, -0.05956632f, -0.06338570f, 0.06271094f, -0.01523216f, 0.00858480f, 0.04445589f, 
    0.00897006f, -0.05951185f, -0.02817964f, 0.05401503f, 0.01889933f, 0.01440225f, -0.05496465f, -0.06232357f, 
    -0.04077097f, 0.04206498f, 0.01764031f, 0.04818356f, -0.03492284f, 0.01486577f, -0.07419704f, -0.06399064f, 
    -0.07682618f, -0.07658180f, 0.02375679f, 0.02678995f, -0.03859023f, 0.02164770f, 0.01274441f, -0.01983768f, 
    -0.06633034f, -0.06359676f, 0.00908130f, -0.07670602f, -0.02635094f, 0.00431058f, -0.06846385f, -0.04443720f, 
    -0.02357425f, -0.04658256f, 0.01602388f, -0.06457946f, -0.00487053f, 0.04223901f, -0.05740523f, -0.07602010f, 
    -0.07461682f, -0.04687845f, -0.01806967f, 0.02318767f, 0.01704077f, 0.02067542f, 0.02880804f, 0.04655460f, 
    0.02361386f, -0.02866363f, -0.01422270f, -0.01011072f, -0.00524274f, -0.03978501f, 0.01253037f, 0.02370997f, 
    -0.05115863f, -0.06262693f, -0.02285970f, -0.05824136f, 0.00952644f, -0.03895574f, 0.00406003f, -0.01126664f, 
    -0.05996431f, 0.06141108f, -0.03860307f, -0.05031731f, 0.01753105f, -0.02269603f, 0.03100258f, 0.04111188f, 
    -0.03483885f, -0.01824052f, 0.00764565f, -0.01628727f, -0.06639620f, 0.00718381f, 0.03380178f, 0.05093129f, 
    0.06487106f, 0.00919948f, -0.01547149f, 0.01877417f, -0.04953081f, -0.03267435f, -0.00316729f, 0.04637174f, 
    -0.05744603f, -0.02830646f, -0.05257403f, -0.07345036f, 0.01410766f, 0.01985510f, 0.04885873f, -0.05735343f, 
    -0.07214770f, 0.01578104f, 0.02472769f, 0.01812988f, 0.04163811f, -0.02599596f, -0.07528863f, 0.01239007f, 
    -0.04326705f, -0.02217743f, 0.06159071f, 0.05036130f, -0.00304837f, -0.06194045f, -0.05245087f, 0.00642305f, 
    -0.04930789f, -0.02282461f, 0.02193351f, -0.01998163f, -0.06624206f, -0.02505544f, -0.01853183f, -0.06526110f, 
    0.02604729f, -0.06793212f, -0.00198899f, 0.01898364f, 0.06585301f, -0.06580397f, -0.01269653f, 0.06115964f, 
    -0.00396235f, 0.05202370f, -0.00512577f, -0.02560216f, 0.02474266f, -0.01298584f, 0.01077869f, 0.05384815f, 
    0.01348571f, 0.00323157f, 0.04380939f, 0.02162488f, -0.06720644f, -0.04984772f, -0.06621165f, 0.05869218f, 
    0.04881408f, -0.06884465f, -0.06745639f, 0.02227544f, -0.07749569f, -0.04604475f, -0.00089332f, 0.02575012f, 
    0.08961310f, -0.23622388f, -0.00963602f, 0.05157347f, -0.24029878f, -0.00956128f, -0.14758322f, 0.02627456f, 
    0.13825110f, 0.00674428f, 0.00538115f, -0.06250053f, 0.25813466f, 0.06621832f, 0.03965297f, -0.03555664f, 
    0.00096591f, 0.12676360f, 0.15659447f, -0.05894213f, -0.07032986f, -0.02186245f, -0.07295845f, 0.09005336f, 
    0.28503361f, -0.21397792f, -0.18144204f, 0.23496148f, 0.37895223f, 0.19638415f, 0.10732360f, -0.04443991f, 
    0.01680983f, -0.01732401f, 0.04601391f, 0.05275422f, 0.04023132f, 0.13273601f, 0.08234871f, 0.13643780f, 
    0.09292087f, 0.07798062f, -0.15890074f, -0.01874366f, -0.13051334f, -0.05751365f, -0.03885675f, 0.05179157f, 
    -0.05744705f, 0.28178203f, -0.09864865f, 0.13657068f, 0.12163941f, -0.13860652f, 0.05920646f, -0.01170660f, 
    0.22222021f, 0.08225640f, -0.06113380f, -0.08547715f, -0.50625229f, 0.26095334f, -0.02307680f, -0.33200797f, 
    0.08172593f, -0.02546044f, -0.14004533f, 0.22626078f, -0.08443367f, 0.05728609f, -0.00321549f, -0.04483587f, 
    -0.16952117f, 0.14893353f, 0.06266488f, -0.15929559f, 0.15294693f, -0.02445002f, 0.10906977f, 0.10867063f, 
    0.02188450f, 0.00962171f, -0.02169859f, -0.00040235f, -0.13840987f, 0.08151774f, 0.04525207f, 0.49685875f, 
    -0.25075272f, -0.15684736f, -0.24899979f, 0.12307555f, 0.00882886f, 0.24606301f, -0.06860442f, -0.17636806f, 
    0.15007468f, -0.17672089f, -0.07970503f, -0.02414808f, 0.08786678f, 0.10007814f, -0.06969891f, -0.04270463f, 
    0.15092464f, -0.01813373f, -0.03781475f, -0.05425435f, -0.17971873f, -0.20189732f, 0.00626272f, 0.00244730f, 
    0.00879183f, -0.08558561f, 0.20762450f, 0.06014308f, 0.10828052f, -0.06603307f, 0.05731945f, 0.10163731f, 
    -0.11323034f, -0.03346840f, -0.11942446f, 0.16052698f, -0.02754617f, 0.16745168f, -0.05000295f, 0.01630738f, 
    -0.17093214f, -0.15224899f, 0.08108059f, 0.11863986f, -0.19631439f, -0.14298397f, -0.21630809f, 0.19992787f, 
    -0.21219265f, -0.20018245f, -0.10570936f, 0.24695064f, 0.06855380f, 0.13162477f, -0.06241594f, 0.07752955f, 
    -0.33723637f, -0.00836616f, -0.09161317f, -0.19964448f, 0.09967168f, -0.04239450f, 0.04176443f, 0.02199345f, 
    0.07671753f, 0.01445651f, -0.04801000f, 0.23389457f, -0.17667623f, 0.22190906f, -0.10918285f, -0.38278568f, 
    -0.08507911f, 0.11548350f, -0.06789882f, 0.02273036f, 0.06107293f, -0.00143451f, -0.00118551f, 0.12528452f, 
    0.06842902f, 0.06374815f, 0.08205996f, 0.16788502f, 0.20393971f, -0.09768332f, 0.06324688f, -0.02353317f, 
    0.06553518f, 0.00622023f, 0.23963970f, 0.11952465f, 0.10797200f, 0.23845795f, -0.06924339f, -0.12416931f, 
    0.05745926f, -0.08201377f, -0.00218218f, -0.02774848f, 0.13844487f, -0.16383038f, 0.09184445f, -0.04835525f, 
    -0.04130895f, 0.11937491f, 0.10058232f, -0.08259689f, -0.14764491f, 0.03053874f, -0.17210224f, -0.05751770f, 
    0.00440866f, 0.11481798f, 0.01328827f, 0.12400714f, 0.28817677f, 0.17388463f, 0.00725859f, 0.15042892f, 
    0.13845064f, -0.17172693f, -0.04297749f, -0.00098192f, -0.04957447f, 0.02732388f, -0.06612805f, -0.01393803f, 
    0.29126680f, 0.07714193f, 0.01325249f, -0.15157779f, 0.00312223f, -0.07010403f, 0.02891996f, 0.02984695f, 
    0.09663530f, 0.00597691f, -0.06026304f, 0.14701243f, -0.07780111f, -0.17791462f, -0.00036101f, -0.22758831f, 
    -0.00420612f, -0.00469325f, 0.10771105f, 0.15225989f, 0.06490275f, 0.00889670f, -0.00291809f, 0.07628784f, 
    -0.11400497f, 0.32245293f, -0.21072170f, 0.10519015f, -0.06102385f, -0.01535171f, -0.01319122f, -0.05085558f, 
    0.02105109f, 0.01228447f, 0.07376186f, 0.04704290f, 0.15355250f, -0.02844392f, 0.09433673f, 0.05097501f, 
    0.16571024f, -0.04082698f, 0.15389447f, 0.08616199f, 0.04196323f, -0.06524198f, 0.05232815f, 0.15263899f, 
    -0.59209025f, 0.06314436f, -0.14775212f, -0.00755553f, 0.21011288f, 0.06400269f, 0.07189864f, -0.00825561f, 
    0.05268686f, -0.02210847f, 0.08747514f, -0.09978019f, -0.14180128f, -0.11163551f, -0.22298090f, 0.00429983f, 
    0.29316553f, -0.01638441f, 0.01214261f, 0.11317580f, -0.05499915f, 0.01945256f, 0.12458450f, -0.07729566f, 
    0.20039022f, 0.20393871f, -0.08434586f, 0.03270240f, 0.01557637f, 0.11347452f, 0.03869414f, -0.05963700f, 
    -0.04202893f, 0.01377090f, 0.02434638f, 0.17019965f, -0.19602963f, -0.13101858f, -0.09480730f, -0.21238343f, 
    -0.02415629f, -0.11332028f, 0.16473149f, 0.08500750f, -0.06661256f, -0.12814163f, 0.04779967f, 0.02621886f, 
    0.12021512f, -0.01194587f, 0.24141315f, 0.03317158f, 0.20585109f, 0.12715217f, -0.08822375f, 0.09315506f, 
    -0.05844520f, 0.04442387f, -0.00853104f, -0.00767419f, -0.18099730f, -0.05484157f, -0.02767413f, 0.00986966f, 
    -0.21995766f, -0.10416030f, 0.16254592f, 0.12033478f, -0.04452240f, 0.03430223f, -0.07411710f, 0.03583844f, 
    -0.26455361f, 0.06371902f, -0.01253437f, -0.19227323f, 0.09341162f, -0.09564433f, -0.06942449f, 0.11664105f, 
    0.13124940f, 0.03495063f, 0.09411087f, 0.04083786f, 0.42574334f, 0.03163360f, 0.02954935f, -0.16710261f, 
    0.00028248f, -0.12814155f, 0.05101790f, -0.02107202f, 0.01893903f, -0.11596818f, 0.07951769f, -0.05584892f, 
    0.19610217f, 0.01520255f, 0.01254937f, -0.05068251f, 0.02404219f, -0.04000327f, 0.01550525f, 0.03547277f, 
    -0.04756791f, 0.09665943f, -0.17269297f, -0.00552363f, 0.14723329f, -0.06520933f, 0.35244790f, 0.00931460f, 
    0.06789319f, 0.13438690f, 0.04301561f, -0.01457327f, -0.00382308f, 0.12199210f, -0.05576016f, 0.06341591f, 
    0.40581670f, 0.27243638f, -0.07686217f, 0.39424041f, 0.01602643f, 0.03351214f, 0.01214389f, 0.00067982f, 
    -0.07300162f, -0.03070842f, 0.13581613f, -0.09407020f, -0.39272887f, 0.02161566f, -0.04193459f, -0.11172673f, 
    0.04922032f, 0.13959184f, 0.01971019f, 0.09446783f, -0.00451069f, 0.00538073f, -0.00124957f, 0.12535226f, 
    -0.04867418f, -0.27100804f, -0.44102561f, -0.13197309f, 0.12403499f, 0.08600536f, -0.06896154f, -0.05426059f, 
    0.04611508f, -0.11105670f, -0.06030771f, -0.07571545f, 0.09432128f, 0.24100401f, -0.08378143f, 0.19080611f, 
    -0.02371855f, 0.23278879f, -0.07055667f, -0.04839104f, -0.12613083f, 0.25412598f, 0.03723789f, -0.17557310f, 
    -0.00559909f, 0.28223357f, -0.02452920f, 0.22572763f, 0.12567163f, 0.05674548f, -0.04628891f, -0.04969716f, 
    0.17587435f, -0.04089774f, -0.08474711f, -0.01914591f, -0.36321926f, -0.14093226f, 0.05904535f, -0.27079880f, 
    0.05787226f, 0.00050833f, 0.03867054f, 0.00840681f, 0.17759500f, 0.09936969f, -0.06365027f, 0.03697051f, 
    0.23334846f, 0.13732633f, 0.04103890f, 0.05893998f, -0.07240917f, 0.02442011f, 0.12984994f, 0.00522377f, 
    0.06960170f, 0.06066649f, 0.17418981f, 0.07144848f, 0.05790114f, 0.29201275f, 0.25894541f, 0.25136387f, 
    -0.14058325f, -0.06381235f, 0.04037580f, -0.11348525f, -0.06671333f, 0.28296459f, 0.06592928f, 0.02405079f, 
    -0.18773869f, -0.28383017f, -0.25864211f, -0.20538887f, 0.01381087f, 0.02648928f, -0.03523066f, 0.00909521f, 
    -0.08887089f, 0.03783946f, 0.12207450f, 0.03604187f, 0.01171877f, 0.26347911f, 0.19674014f, 0.30499738f, 
    0.12727267f, -0.05236249f, 0.04056925f, 0.15739910f, 0.11984000f, 0.05190307f, 0.10249760f, 0.14317881f, 
    -0.34023497f, -0.13117157f, -0.07520666f, 0.03643300f, -0.01092918f, -0.01085476f, 0.23765980f, -0.03972049f, 
    -0.09272864f, 0.19666198f, -0.05670422f, -0.19367619f, 0.20399000f, 0.04126509f, -0.12962851f, 0.45501882f, 
    0.02171345f, -0.05496466f, -0.15614623f, 0.07347441f, -0.06972133f, 0.01276970f, 0.02047195f, 0.04014872f, 
    0.22432421f, 0.00397999f, -0.04087634f, -0.09780085f, 0.07658152f, -0.01689074f, 0.06738034f, -0.02761649f, 
    0.10935894f, -0.03908486f, 0.01531908f, -0.02080525f, -0.06711885f, 0.08608758f, -0.04575007f, -0.14276987f, 
    0.23864582f, 0.03249741f, 0.05963337f, 0.11666645f, -0.10393783f, 0.11305888f, 0.01573086f, 0.12767990f, 
    -0.19609593f, -0.32165715f, -0.05954850f, -0.18037172f, 0.04332200f, -0.01175237f, 0.08790201f, -0.01184798f, 
    -0.10180482f, -0.19369136f, 0.16594961f, -0.12887512f, -0.17973720f, -0.15185872f, -0.06434578f, 0.18983456f, 
    -0.06673957f, -0.00349082f, -0.13031040f, 0.00060426f, 0.09785197f, 0.10486910f, -0.00834360f, -0.02849110f, 
    -0.05567237f, -0.20003681f, 0.28506669f, -0.16548078f, 0.00525630f, 0.16375105f, 0.03105062f, -0.04669894f, 
    0.04656879f, 0.04591715f, 0.18869941f, 0.19959177f, 0.05358654f, -0.02642309f, 0.21957381f, 0.02291274f, 
    0.02733124f, 0.00743107f, 0.05506109f, -0.03568352f, 0.03709023f, 0.06736431f, 0.23815078f, -0.13414358f, 
    0.48539981f, 0.22097179f, 0.10590886f, -0.11952700f, -0.02164806f, -0.01331077f, 0.06532118f, 0.00403145f, 
    0.02884606f, 0.05163444f, -0.09800924f, -0.09749995f, 0.06063263f, -0.22554499f, -0.04681121f, -0.07319239f, 
    0.02589881f, 0.02601520f, -0.09532260f, -0.05859613f, -0.22714086f, -0.09669404f, -0.06255667f, -0.07573432f, 
    0.19212018f, 0.24935034f, 0.05958014f, -0.04018818f, 0.26858309f, -0.04943415f, 0.10172223f, 0.08709400f, 
    -0.08218196f, 0.05997860f, 0.14458026f, 0.06232450f, -0.12917945f, 0.04925473f, -0.03269065f, 0.09227014f, 
    0.05571849f, 0.02584227f, -0.00884894f, 0.13787501f, -0.03706151f, -0.07719287f, 0.10964114f, 0.03886952f, 
    -0.34060580f, 0.05516480f, -0.05929120f, 0.01178991f, 0.11232021f, -0.05878075f, 0.07261513f, 0.01135010f, 
    -0.00327864f, 0.03890818f, 0.10181443f, -0.01178125f, -0.17978960f, -0.18089849f, -0.26575732f, -0.07330476f, 
    0.21231146f, 0.06492174f, 0.03017872f, 0.03286244f, -0.05213137f, 0.04124537f, 0.10206515f, 0.12757486f, 
    0.02755180f, -0.02475772f, 0.18358728f, 0.02064251f, -0.12560268f, -0.22123353f, 0.08643074f, -0.01734389f, 
    0.01408755f, 0.08461828f, -0.04460473f, 0.03876813f, -0.03929886f, -0.06314511f, -0.02351076f, -0.04394029f, 
    -0.08687278f, -0.03547248f, -0.00679253f, -0.03874050f, -0.10487352f, 0.17939603f, 0.08172988f, 0.08943871f, 
    0.05444567f, 0.28051439f, 0.16343546f, -0.08060981f, 0.14110951f, 0.01128168f, 0.07177286f, 0.10874570f, 
    0.01103021f, 0.11738918f, 0.05581614f, 0.16462353f, -0.21525116f, -0.08320500f, 0.08046062f, 0.22134557f, 
    0.00713005f, 0.08043259f, -0.05634689f, 0.05949750f, -0.08420909f, -0.26234555f, -0.03453809f, -0.07132065f, 
    -0.07313906f, 0.16678500f, 0.00456716f, 0.15294427f, -0.14576885f, 0.03621826f, 0.02197209f, -0.19764572f, 
    -0.08777364f, 0.04233643f, -0.12716433f, -0.05903970f, 0.05107071f, -0.06097829f, 0.12877366f, 0.13184738f, 
    -0.08897228f, -0.13870043f, 0.19021049f, -0.00015467f, 0.00377843f, -0.11086839f, -0.03907409f, 0.00364202f, 
    0.17053062f, 0.16860130f, -0.06375018f, 0.06717429f, 0.06696808f, 0.11053682f, -0.02311588f, 0.05698101f, 
    0.00381978f, -0.09838010f, -0.13541906f, -0.13099337f, -0.00821057f, -0.08134679f, 0.14904967f, 0.01348932f, 
    0.13086280f, 0.09038883f, 0.17781721f, -0.03475446f, 0.06974075f, 0.10264231f, 0.13524501f, 0.09097943f, 
    -0.06354360f, -0.04839074f, 0.02267123f, 0.06910046f, -0.07429773f, -0.01142297f, -0.03159832f, 0.03934935f, 
    -0.00336999f, -0.05962255f, 0.04023537f, 0.04832631f, -0.08008055f, -0.00903020f, -0.03972772f, -0.04293097f, 
    0.01890084f, -0.08032616f, -0.06403090f, -0.00585643f, 0.05372876f, -0.04222996f, 0.06127203f, -0.02404064f, 
    0.02108158f, -0.03118795f, -0.00346631f, -0.01870603f, 0.02489259f, 0.05044483f, 0.03559769f, 0.02213940f, 
    -0.06079873f, 0.02302619f, -0.00848094f, -0.07647832f, -0.03136234f, 0.05607393f, 0.06040706f, 0.05162371f, 
    0.03684711f, 0.00839771f, 0.01454206f, -0.04030661f, 0.02159591f, -0.01176733f, 0.00938983f, -0.04044829f, 
    0.04828661f, -0.02458649f, 0.01792083f, 0.06100476f, -0.04156879f, 0.00135341f, 0.03625793f, -0.00084666f, 
    -0.03568740f, 0.05598250f, 0.06074468f, -0.03497713f, 0.03524488f, -0.06388322f, 0.00671969f, 0.02981349f, 
    -0.07162704f, 0.00581612f, -0.04570963f, -0.06996137f, -0.08312471f, -0.00340638f, -0.01084117f, 0.01339375f, 
    -0.05109539f, 0.00490742f, -0.04430942f, 0.03863163f, 0.05300645f, 0.02186608f, -0.07670515f, 0.04946953f, 
    0.00810324f, 0.02010377f, -0.06851690f, -0.00076593f, -0.03233176f, -0.00704359f, -0.04993248f, -0.05689545f, 
    -0.01462393f, -0.05194756f, 0.03962813f, 0.05134393f, 0.01478167f, 0.02782080f, -0.03379261f, -0.02660708f, 
    -0.07887564f, -0.06114028f, -0.00897309f, 0.01541078f, 0.04911195f, -0.02360698f, -0.04950469f, -0.05538734f, 
    0.04738887f, -0.08256333f, 0.01104302f, -0.01649999f, 0.02396500f, 0.06681771f, -0.07567865f, -0.06934419f, 
    -0.03576048f, 0.04119260f, 0.00666260f, -0.01851054f, 0.01738464f, -0.01255735f, 0.02214796f, -0.01356346f, 
    0.03144583f, -0.01287839f, -0.05013787f, -0.00051810f, 0.00256756f, -0.00089264f, 0.00504586f, 0.00952875f, 
    -0.06443979f, -0.07531833f, 0.04102493f, 0.02997534f, -0.05997144f, -0.07053050f, 0.05227588f, -0.02363171f, 
    -0.07522648f, 0.04843011f, 0.01308982f, 0.03589827f, -0.06314716f, 0.04942059f, -0.00265169f, 0.02838989f, 
    -0.03738955f, -0.07260286f, -0.01491071f, -0.04455126f, -0.04234876f, -0.03011975f, -0.07973808f, 0.03860573f, 
    -0.06974908f, 0.05787867f, -0.07930421f, -0.03772070f, -0.07685912f, -0.02081660f, -0.02201968f, 0.02738537f, 
    0.04386661f, -0.04882707f, -0.04606386f, -0.01301141f, -0.04767317f, -0.01674985f, 0.01979518f, -0.00915545f, 
    -0.03561914f, 0.04711443f, 0.00898596f, -0.01151976f, 0.04729580f, 0.00937857f, -0.06095380f, -0.00869304f, 
    -0.03519927f, 0.04700010f, -0.03237807f, 0.02304119f, -0.00087519f, -0.07817873f, -0.07490316f, 0.04768243f, 
    -0.02234016f, 0.04383576f, -0.05247929f, -0.00521654f, 0.03319017f, -0.00523649f, 0.02480784f, 0.02810176f, 
    0.21658722f, -0.19068344f, -0.26753083f, 0.09559492f, -0.13689364f, -0.01354927f, 0.00547306f, 0.00220011f, 
    0.07345457f, -0.04481457f, 0.07614979f, -0.02372419f, 0.04468970f, -0.04377115f, -0.05461517f, 0.10187571f, 
    -0.08162302f, 0.02215802f, -0.03647440f, 0.10377741f, -0.03527472f, 0.03850801f, 0.01318637f, -0.14877737f, 
    0.23599012f, 0.01820439f, 0.23773478f, 0.31251070f, -0.11236412f, 0.03379839f, 0.06079452f, 0.00239249f, 
    0.18169570f, -0.03810599f, 0.13742666f, 0.19688264f, -0.14306708f, -0.16001737f, -0.09090747f, 0.09631341f, 
    -0.11662181f, 0.09156566f, -0.02854699f, -0.00239851f, 0.08828268f, 0.09926746f, 0.05199433f, -0.08408073f, 
    0.20050681f, -0.33476463f, 0.09825433f, 0.01673635f, 0.01221332f, -0.01101766f, 0.03909380f, -0.14414512f, 
    0.08001117f, 0.03422889f, 0.00805666f, -0.04936419f, -0.40859237f, 0.04857788f, 0.08655838f, -0.18801625f, 
    -0.08892706f, 0.07489683f, -0.11610537f, 0.05992744f, -0.09633119f, -0.02738744f, -0.04529580f, -0.03167695f, 
    0.44458184f, -0.09764703f, -0.13552974f, -0.21027088f, 0.07497836f, 0.20442411f, 0.10059508f, 0.23157455f, 
    -0.00470916f, -0.08640670f, 0.05474317f, 0.03090490f, -0.14908880f, -0.19949703f, 0.11887520f, 0.23592153f, 
    -0.05430638f, -0.08695734f, -0.00129917f, 0.06814871f, 0.17817326f, 0.01370439f, 0.08500845f, -0.02791468f, 
    0.23228064f, -0.09195678f, -0.07197436f, 0.08405934f, -0.00916089f, 0.04051821f, -0.00909466f, 0.20036826f, 
    0.09277482f, 0.03015535f, 0.10989512f, 0.05716161f, 0.16249782f, 0.13020384f, -0.04183446f, 0.13503186f, 
    0.07810586f, -0.07332838f, 0.08998516f, 0.02119620f, -0.05205405f, 0.00914251f, -0.07384787f, 0.04315963f, 
    -0.31811094f, -0.26937199f, 0.01288410f, 0.05704279f, -0.06760847f, -0.13643937f, -0.02722717f, 0.00730472f, 
    0.07542076f, -0.18617691f, -0.06001552f, 0.05131904f, 0.07403073f, -0.06167436f, -0.03400156f, 0.23327510f, 
    -0.12819768f, -0.11180750f, 0.04537548f, -0.07304018f, 0.02769353f, 0.07267993f, -0.01266424f, 0.06726491f, 
    -0.03689926f, -0.05092204f, -0.09701985f, -0.05311200f, 0.07976599f, 0.01479420f, -0.02139733f, 0.03110309f, 
    0.17955197f, 0.01392230f, 0.00974565f, 0.03958992f, -0.83373433f, -0.08288021f, 0.00113075f, 0.01252907f, 
    0.17212877f, 0.06798609f, 0.18861917f, -0.13804182f, -0.01586517f, 0.05619809f, 0.15878722f, 0.00691144f, 
    0.13422486f, -0.10113765f, 0.21511754f, -0.12283752f, 0.12653242f, -0.06446349f, -0.01405447f, -0.03374975f, 
    -0.00067025f, -0.01717210f, 0.30991572f, -0.01689507f, 0.08863477f, -0.35230994f, -0.30272311f, 0.26338151f, 
    0.15997785f, -0.03321777f, -0.00249307f, 0.08681102f, -0.04720900f, -0.00584763f, -0.03708024f, -0.10463538f, 
    -0.29175332f, -0.22056291f, 0.13666387f, -0.02186585f, 0.09255967f, 0.03376373f, 0.12619998f, 0.03062062f, 
    0.13941297f, 0.18386538f, 0.10042978f, -0.00062439f, -0.02894902f, -0.18416719f, 0.07214671f, -0.05384694f, 
    -0.12476424f, -0.00965966f, 0.00295154f, 0.03825751f, 0.02697830f, 0.02894692f, 0.00477832f, -0.01260571f, 
    0.14816681f, 0.07305399f, 0.27696317f, 0.24591331f, -0.11763986f, 0.08624645f, 0.05421271f, 0.04882287f, 
    -0.06487045f, 0.04199014f, 0.03678620f, -0.08796641f, 0.28281802f, -0.17030962f, 0.01829267f, 0.05620256f, 
    -0.00081946f, -0.01475822f, 0.01818095f, -0.03811257f, -0.09032092f, -0.08283186f, -0.09483857f, 0.10549520f, 
    0.32482615f, -0.30531901f, 0.03685252f, -0.20939963f, 0.03074630f, -0.08812372f, 0.06770084f, 0.10994767f, 
    -0.04623205f, 0.08104710f, 0.07968794f, -0.02322669f, -0.13617313f, 0.26422021f, -0.05187273f, 0.15298666f, 
    0.00208436f, 0.06509370f, -0.08538938f, -0.03823100f, -0.05003763f, -0.13020085f, -0.02159055f, -0.12878178f, 
    -0.18821548f, -0.09195027f, -0.07530038f, -0.02640289f, -0.01011537f, 0.00704102f, -0.10636185f, 0.04288965f, 
    0.02379556f, -0.04892403f, -0.03039824f, 0.07345275f, -0.14456342f, -0.17341407f, -0.09813870f, 0.07252834f, 
    -0.00515621f, 0.07586339f, 0.01098078f, 0.06835146f, 0.08284524f, -0.02267391f, 0.04470302f, 0.15882421f, 
    -0.09289942f, 0.01903972f, 0.25990617f, 0.23633432f, -0.05239271f, -0.18022007f, 0.06952427f, -0.00935120f, 
    0.11343641f, -0.10291176f, -0.08700823f, -0.13152450f, 0.10427401f, -0.14130460f, 0.05500842f, 0.17107071f, 
    0.11231147f, 0.03070569f, -0.05652028f, -0.06919764f, 0.07892927f, 0.06816511f, -0.01307608f, -0.03860840f, 
    0.25445214f, 0.07139822f, -0.00541190f, -0.12930858f, -0.05983808f, -0.03750446f, -0.00013993f, 0.00771742f, 
    -0.10613647f, -0.06584182f, 0.05333971f, 0.08529371f, -0.05181343f, -0.10965587f, 0.27557281f, 0.09596694f, 
    0.05143252f, 0.00061038f, -0.07284842f, 0.01151904f, -0.08804026f, -0.08876483f, 0.13255133f, 0.10157220f, 
    0.08624619f, 0.01481641f, 0.02967286f, 0.33729807f, -0.17448689f, 0.10505138f, 0.06032741f, -0.14478017f, 
    0.01024042f, 0.00626553f, 0.06838411f, 0.02149795f, -0.31190312f, -0.10952897f, 0.03434595f, 0.10657468f, 
    -0.11353955f, -0.00636236f, 0.06168629f, -0.00445638f, 0.01313613f, -0.03952405f, -0.02142736f, 0.02823127f, 
    -0.00347896f, 0.04069651f, 0.07371121f, 0.08955853f, 0.04122565f, 0.15445265f, -0.02688853f, 0.08369221f, 
    0.09626435f, 0.08379644f, 0.05274080f, 0.09574328f, -0.19379738f, 0.10771269f, -0.15169409f, -0.08821175f, 
    -0.07703041f, -0.08715937f, 0.05506593f, -0.06363595f, 0.01663902f, 0.03739216f, 0.07089771f, 0.06905782f, 
    0.26210216f, 0.01167434f, 0.14131118f, 0.20563217f, 0.02725796f, -0.00521426f, 0.13238834f, -0.00942586f, 
    -0.09749287f, -0.04674901f, 0.04078211f, 0.13638793f, -0.11130597f, -0.12720264f, -0.06612808f, -0.24250776f, 
    -0.00490656f, -0.03141217f, 0.08702940f, -0.09430054f, -0.07375226f, 0.11677314f, 0.10658990f, 0.08674210f, 
    0.33019882f, -0.22836402f, -0.07027238f, 0.00138623f, -0.10474987f, -0.16787809f, -0.10419667f, 0.04362813f, 
    0.02733938f, 0.02286099f, -0.06506582f, -0.00544378f, 0.15175420f, -0.17307954f, -0.01324931f, -0.21537289f, 
    0.08163918f, 0.06823771f, -0.02085090f, -0.03983805f, -0.03384906f, 0.06608286f, -0.06524234f, -0.22174369f, 
    0.49122673f, 0.16358225f, 0.03474756f, 0.08628183f, 0.06897675f, 0.00981082f, 0.03210020f, -0.00825982f, 
    -0.15484928f, -0.03378512f, 0.06096880f, 0.05976255f, -0.08780695f, 0.06695639f, 0.03218579f, 0.08676211f, 
    -0.00262690f, 0.02064362f, 0.05727539f, -0.00946386f, 0.06720794f, 0.07025176f, 0.06284302f, 0.17843066f, 
    -0.64823133f, 0.21896498f, -0.06705339f, 0.12317020f, 0.21586645f, -0.11833333f, -0.03751588f, 0.03540646f, 
    -0.08722085f, 0.09859607f, -0.08006959f, 0.02570604f, -0.00361413f, 0.21598001f, -0.03448120f, -0.25487587f, 
    0.04451926f, 0.08657698f, 0.03899338f, -0.06748034f, -0.10989983f, 0.09276596f, 0.01340358f, 0.05472715f, 
    -0.28194901f, -0.00506951f, 0.08360771f, -0.09414347f, -0.18137540f, -0.05062446f, 0.06533998f, -0.09508910f, 
    0.07309396f, 0.14189029f, 0.07350872f, 0.09331761f, -0.05343945f, 0.14396474f, 0.15252689f, 0.16673222f, 
    0.08868754f, -0.08969341f, 0.00921490f, 0.20376480f, 0.10533899f, 0.09253035f, 0.07179865f, -0.02242045f, 
    -0.04249367f, 0.06009567f, -0.06230714f, -0.09525249f, 0.13334422f, -0.00904531f, 0.20027238f, -0.05557862f, 
    -0.02984896f, 0.14163084f, 0.00863123f, 0.10007384f, 0.04228795f, -0.05079676f, 0.29723296f, 0.29903895f, 
    0.05790203f, -0.00839003f, -0.11992091f, 0.08345963f, -0.05225570f, -0.17583792f, 0.03497168f, -0.11590401f, 
    0.12058917f, -0.06562811f, 0.11220632f, 0.33128762f, -0.01490303f, 0.01247403f, 0.04100326f, -0.06943637f, 
    0.07933129f, 0.22553134f, -0.16657111f, 0.12305772f, 0.47260487f, -0.10401229f, -0.01602345f, -0.14670630f, 
    -0.05300185f, 0.06350158f, 0.05558217f, -0.08986543f, -0.01896623f, -0.03524810f, 0.00520419f, 0.02011468f, 
    0.18631855f, -0.00586446f, -0.00476752f, 0.17910627f, -0.08134825f, 0.03569820f, 0.04862891f, 0.06946579f, 
    0.11639796f, 0.00366405f, -0.08075125f, 0.02744503f, -0.07504708f, -0.07877165f, 0.20851813f, -0.24148893f, 
    -0.05520857f, -0.08052261f, 0.12333019f, -0.01252255f, -0.02205940f, 0.08015805f, 0.01270929f, 0.08267637f, 
    -0.21584758f, 0.07084162f, -0.08270209f, -0.09262761f, 0.10009383f, 0.07187270f, 0.09694396f, -0.06806029f, 
    0.06982186f, 0.20131496f, 0.01438136f, -0.12322667f, 0.29318380f, 0.05647480f, 0.02418423f, 0.07190057f, 
    0.04378774f, -0.01441739f, 0.03254000f, -0.05071110f, -0.03260856f, 0.11572218f, 0.00947519f, 0.16378336f, 
    -0.14173621f, 0.31606764f, 0.08784892f, -0.26975679f, -0.16845785f, -0.04112817f, 0.04693241f, -0.03271556f, 
    -0.12570824f, 0.08200704f, 0.11148957f, 0.16901599f, -0.32855541f, -0.06054378f, 0.15855236f, 0.02928489f, 
    -0.03844545f, 0.05595489f, 0.05545421f, 0.01361888f, 0.24389912f, 0.12985684f, 0.04047855f, 0.02801290f, 
    -0.23291172f, -0.08710011f, 0.08466765f, -0.06874111f, -0.02747633f, -0.07772425f, 0.10463431f, -0.01356082f, 
    0.00106041f, 0.03539753f, 0.06300601f, -0.02102986f, 0.31010580f, 0.02308140f, -0.20812540f, 0.05640615f, 
    -0.06649550f, -0.05791380f, 0.04325796f, -0.16344677f, -0.06140110f, -0.08512119f, -0.01303143f, -0.00456781f, 
    0.33866251f, -0.34608975f, -0.06914252f, -0.12223213f, 0.13080813f, 0.12659304f, -0.01822034f, 0.03406585f, 
    -0.01748954f, -0.04533116f, 0.15713760f, -0.05291479f, 0.11801707f, -0.13969083f, -0.18656871f, 0.06520025f, 
    0.19271217f, -0.06539451f, -0.00092757f, 0.16567653f, 0.06936315f, -0.17578399f, -0.02051319f, -0.03835763f, 
    0.16008787f, 0.07093393f, -0.08945153f, -0.11511436f, -0.12649709f, 0.13194475f, -0.08720446f, 0.02833997f, 
    0.01599439f, -0.03710105f, 0.03048648f, 0.12856133f, 0.17869760f, 0.04957805f, 0.02994544f, -0.03056627f, 
    0.04893237f, 0.09096368f, 0.06578552f, -0.00334950f, 0.07042537f, -0.12465241f, -0.08941733f, 0.01096325f, 
    0.22123645f, -0.19895779f, 0.10583314f, -0.19465326f, -0.02504124f, -0.05884527f, -0.09532186f, 0.02251057f, 
    0.12353162f, -0.13912854f, 0.00423235f, 0.01257596f, 0.08754139f, 0.03442576f, 0.01751144f, -0.02343991f, 
    -0.05054951f, -0.01148910f, 0.15698777f, -0.02774683f, -0.09223439f, 0.15777487f, 0.07684389f, 0.17335203f, 
    -0.02923139f, 0.13826457f, -0.01552611f, -0.14155345f, -0.00064044f, -0.06604327f, -0.12702522f, 0.13058117f, 
    0.00259242f, -0.10262648f, 0.17954615f, 0.04734100f, -0.21009381f, 0.10539718f, 0.11526311f, 0.37104550f, 
    -0.03658814f, -0.03994783f, 0.09936260f, -0.04073036f, -0.02967655f, -0.09887772f, 0.08550116f, -0.00915318f, 
    -0.13303046f, 0.15612088f, 0.05331234f, -0.43345422f, 0.01673543f, -0.03762010f, -0.08094954f, -0.02118028f, 
    0.03209088f, -0.03526841f, 0.03862332f, 0.13771817f, 0.08131232f, -0.18346313f, 0.12279829f, 0.07362091f, 
    0.08792149f, 0.07546042f, -0.01334952f, 0.04267142f, 0.06243017f, 0.06342425f, 0.03081373f, -0.06896393f, 
    0.13072301f, -0.03230806f, -0.06945331f, -0.00854244f, 0.10566343f, 0.11197183f, -0.07936668f, -0.01828113f, 
    0.06040476f, 0.10753746f, -0.08014221f, -0.06985428f, -0.19788367f, 0.19505611f, 0.22491564f, 0.16311505f, 
    0.19326240f, 0.21598962f, 0.11225599f, 0.14194319f, 0.06682941f, 0.00583823f, 0.17737275f, 0.01778741f, 
    -0.31357932f, 0.14918540f, -0.13846420f, -0.28492701f, 0.20871297f, 0.17659548f, 0.07954947f, -0.11156375f, 
    0.00919931f, -0.01267059f, 0.10003264f, 0.00556015f, -0.05285003f, 0.03818982f, 0.21125682f, 0.34777173f, 
    -0.07923686f, 0.03964117f, -0.08766260f, -0.02898217f, -0.06060214f, 0.08318479f, -0.05628471f, 0.05375429f, 
    -0.28647059f, 0.43693274f, -0.05129024f, 0.24121070f, 0.18789680f, 0.15147853f, 0.01218336f, -0.08432747f, 
    0.14112872f, -0.01414995f, 0.17349172f, 0.07250794f, -0.10148226f, -0.18739909f, -0.13284996f, -0.14668024f, 
    0.05449396f, 0.03444070f, -0.09163202f, 0.12007391f, -0.06578914f, 0.00422473f, 0.12525851f, 0.19215716f, 
    0.39233041f, 0.03760646f, 0.03302924f, -0.12933969f, 0.00454910f, 0.00030426f, 0.08495615f, -0.00983358f, 
    0.06493360f, 0.04537991f, -0.00688732f, -0.13712335f, 0.31620666f, 0.04589488f, -0.18501952f, 0.04595893f, 
    -0.08549874f, -0.07755808f, 0.08435853f, -0.02825521f, -0.02959012f, -0.00382395f, 0.05094595f, 0.04981016f, 
    -0.17724077f, -0.41751978f, -0.21348184f, -0.27824095f, 0.02399370f, -0.04028779f, -0.01066410f, 0.03227671f, 
    0.11733691f, 0.16038066f, 0.04509894f, 0.02695930f, 0.00782482f, 0.09080228f, -0.03567512f, 0.20237358f, 
    -0.06015041f, -0.04143659f, 0.03084532f, -0.12337674f, 0.05785000f, 0.14500220f, 0.10553190f, 0.14058518f, 
    -0.17111884f, 0.06971110f, -0.05628654f, -0.16961026f, 0.05251534f, 0.16315351f, 0.19511057f, -0.04036104f, 
    0.05661035f, 0.14743468f, -0.09784517f, -0.17353737f, 0.29698637f, 0.02429963f, -0.14383706f, 0.24512875f, 
    0.06018627f, -0.02463993f, 0.00863131f, 0.08234587f, -0.19032061f, -0.00066788f, -0.16940376f, 0.01485768f, 
    0.02562848f, 0.36088783f, -0.06865223f, -0.18688704f, 0.12488080f, -0.00967699f, 0.10902740f, -0.07993755f, 
    -0.02676066f, -0.02955040f, -0.02617199f, 0.01096425f, -0.10952543f, 0.16357926f, 0.16076913f, 0.14107364f, 
    0.03949870f, 0.01190635f, 0.15094747f, 0.23033261f, -0.00144645f, -0.03059622f, -0.07991911f, 0.04940285f, 
    -0.34720698f, 0.00255743f, 0.08431655f, -0.35704336f, 0.06918591f, -0.06257374f, 0.02587111f, 0.01998386f, 
    -0.03047704f, -0.10745125f, 0.00826884f, -0.05686738f, -0.16323575f, -0.08407146f, -0.00813794f, 0.24231297f, 
    0.05683252f, 0.05980916f, -0.06589564f, 0.06048572f, 0.06985058f, 0.06351940f, 0.06228866f, -0.04696863f, 
    0.13598570f, -0.06479313f, 0.09442866f, -0.00231232f, -0.04194305f, -0.00199507f, 0.05856697f, 0.00922882f, 
    0.06744977f, -0.04028863f, 0.17239119f, 0.11025785f, 0.22015369f, -0.13014601f, -0.23562366f, -0.20192862f, 
    -0.15175539f, -0.01209007f, -0.01004979f, -0.11936556f, -0.07633726f, -0.06284142f, -0.05251466f, -0.05981711f, 
    0.39970753f, -0.29657456f, 0.18449062f, 0.44522253f, -0.02009443f, -0.00741510f, -0.00051254f, 0.07816318f, 
    0.09665242f, -0.08339693f, -0.00749238f, -0.04629488f, -0.00869230f, -0.23159744f, -0.06779069f, -0.33150259f, 
    0.02370463f, 0.02672989f, 0.05875569f, -0.01719963f, -0.02705267f, -0.02822493f, -0.00983222f, -0.04438816f, 
    0.44517654f, -0.22363138f, 0.19266866f, -0.15860038f, 0.03220235f, -0.07141845f, -0.00805852f, 0.14548965f, 
    -0.15130468f, 0.13395248f, -0.13609907f, -0.14317881f, -0.03137448f, 0.10533931f, 0.09174077f, 0.09674056f, 
    0.03533974f, 0.18201579f, 0.01845881f, 0.06052225f, 0.16705365f, 0.22601543f, 0.12283242f, -0.12351965f, 
    -0.15074614f, 0.01721711f, 0.09835760f, 0.23646091f, -0.15238987f, -0.00419181f, 0.07770012f, -0.05768856f, 
    -0.01411912f, 0.09976292f, -0.00228740f, 0.09656239f, -0.22776914f, -0.16608204f, 0.07914738f, -0.11902522f, 
    -0.06426050f, 0.03688368f, -0.15126356f, 0.10814788f, 0.05827010f, 0.08714680f, -0.03374449f, 0.11358910f, 
    0.01439981f, -0.01778591f, 0.26520324f, 0.31587920f, -0.00291531f, -0.01796730f, 0.03869409f, 0.07365997f, 
    0.03113336f, 0.04990770f, -0.00188581f, -0.10850598f, 0.05868730f, 0.03403121f, -0.03164773f, -0.10979558f, 
    0.07172327f, -0.04383872f, 0.02406124f, 0.03743824f, -0.13378480f, 0.09788708f, 0.04882972f, 0.01620462f, 
    0.12103466f, 0.08699545f, 0.01883490f, 0.05852339f, -0.11770976f, -0.09723631f, -0.14318086f, 0.04945234f, 
    -0.04302097f, -0.00544228f, 0.19901921f, 0.22706871f, -0.18085852f, -0.02402821f, 0.13100447f, -0.08371082f, 
    0.08465025f, 0.03332301f, -0.03406668f, -0.01973048f, 0.18031867f, 0.08959665f, -0.02418293f, -0.09819181f, 
    -0.03687440f, -0.23225161f, 0.01527628f, 0.24328026f, -0.17674334f, 0.02328777f, 0.02863843f, 0.05899383f, 
    0.03974575f, -0.03584681f, -0.04596197f, 0.04117623f, 0.11081640f, -0.18786374f, -0.04868223f, -0.12107380f, 
    0.06610514f, 0.07900945f, -0.00808366f, 0.01178021f, 0.10794104f, 0.06162143f, 0.09731791f, 0.05720145f, 
    0.46285978f, -0.05017255f, 0.10741085f, 0.56187862f, -0.15333837f, 0.17889698f, -0.00413005f, 0.04519472f, 
    0.04202727f, 0.07353197f, 0.10183226f, 0.00567996f, 0.36729899f, 0.20452686f, -0.07933908f, -0.26766458f, 
    -0.10687530f, 0.01170018f, 0.06425291f, 0.08434539f, -0.06072182f, 0.00838988f, 0.03198514f, 0.02342898f, 
    0.15390760f, -0.06270890f, 0.08435071f, -0.16445035f, 0.08418351f, -0.02554774f, -0.14696684f, 0.06122463f, 
    -0.09669430f, -0.08228439f, 0.00627211f, 0.04245763f, 0.39553210f, 0.04331974f, 0.09476496f, 0.02538078f, 
    0.00035221f, -0.19785970f, 0.04389801f, 0.08594534f, -0.21990027f, 0.04404600f, -0.00510819f, -0.09686194f, 
    0.44516090f, 0.08591662f, -0.02411269f, 0.08832701f, -0.02578165f, -0.00376588f, 0.04792912f, 0.06648367f, 
    0.04018030f, 0.05571381f, -0.09963541f, 0.02772414f, -0.07350279f, 0.02162471f, 0.01767514f, -0.12421601f, 
    0.02748251f, 0.00460143f, -0.03052280f, -0.01589300f, -0.05238609f, 0.06443761f, 0.13367276f, -0.21902846f, 
    -0.04465107f, 0.12523344f, -0.03338086f, -0.13004118f, 0.03061840f, -0.06189791f, -0.05656502f, -0.00037301f, 
    0.03662869f, 0.01771102f, -0.01143780f, 0.12146358f, -0.13021046f, -0.09614877f, 0.03412478f, 0.00184496f, 
    0.03303012f, 0.05473997f, 0.10958249f, 0.03808695f, 0.01845236f, 0.04644553f, 0.05819558f, 0.01057151f, 
    0.59539115f, -0.14452443f, -0.09902210f, 0.22502987f, 0.04095121f, 0.10610456f, 0.08508433f, -0.03625303f, 
    -0.12893903f, -0.03188554f, 0.15907086f, 0.01062770f, 0.18742049f, 0.02343185f, 0.09270961f, 0.08975945f, 
    -0.00220820f, -0.10880967f, 0.07369716f, -0.00398780f, 0.07230642f, 0.08368459f, 0.14531930f, -0.11121605f, 
    0.26776654f, 0.07653026f, -0.10231611f, 0.06546942f, -0.06837027f, 0.08238707f, 0.01693669f, 0.02997260f, 
    -0.06073518f, 0.10415465f, 0.20224629f, 0.14086968f, -0.01753313f, -0.02215707f, -0.21467468f, -0.23963735f, 
    0.02364417f, -0.02759257f, 0.06055176f, 0.09412729f, 0.00570392f, 0.14227685f, -0.02372547f, 0.12810631f, 
    -0.07621270f, -0.14069164f, 0.13539636f, 0.23882018f, -0.03904629f, -0.07698213f, 0.20826553f, 0.17421688f, 
    -0.01656861f, -0.04047486f, -0.02601222f, 0.10844011f, -0.23804948f, -0.01876406f, -0.01012595f, -0.16378717f, 
    0.11045828f, -0.01132810f, 0.03381961f, 0.08602580f, 0.06201377f, -0.04660685f, 0.02208142f, -0.12918988f, 
    -0.07729310f, -0.12843616f, -0.21550421f, 0.04611209f, 0.08378244f, 0.00196454f, -0.05332599f, 0.18617667f, 
    -0.00913114f, 0.02622940f, -0.15332900f, -0.17528525f, -0.17651184f, 0.14516608f, 0.07930765f, -0.21315204f, 
    -0.03361193f, 0.02181020f, -0.10257848f, -0.16951007f, -0.02548235f, 0.11834848f, -0.06168610f, -0.00820942f, 
    0.25714406f, -0.12653664f, -0.06461584f, 0.07277911f, 0.01686239f, 0.04234030f, -0.10851277f, -0.00753190f, 
    0.02240461f, -0.15752073f, -0.07509137f, -0.14086750f, 0.33279240f, -0.51414788f, 0.02016348f, -0.26633701f, 
    0.02577797f, -0.04324831f, 0.13928369f, -0.01501265f, -0.08376942f, -0.02894296f, 0.05555428f, -0.08986001f, 
    -0.04440311f, 0.06428833f, 0.04774035f, -0.05556339f, -0.11892164f, -0.02570734f, -0.07661544f, -0.10143243f, 
    -0.00680309f, -0.01612266f, 0.14238511f, 0.06832876f, 0.36601609f, 0.18599267f, -0.08569185f, -0.03553411f, 
    -0.00904626f, 0.00873564f, -0.09481600f, -0.10392669f, -0.07679003f, -0.01965876f, -0.03667532f, 0.12050801f, 
    0.01066442f, -0.18964276f, -0.04174821f, -0.01417942f, 0.08666085f, -0.00602340f, -0.01179882f, 0.00214246f, 
    0.05589709f, -0.04633215f, 0.08582197f, 0.00627468f, -0.42166159f, -0.19054450f, 0.17747141f, -0.38655606f, 
    0.07438337f, -0.05174041f, 0.09167152f, 0.12477958f, 0.16244249f, -0.05751017f, 0.05979753f, 0.09130618f, 
    -0.13698374f, 0.33065823f, -0.00496233f, 0.09008731f, 0.01234187f, 0.09784058f, -0.07265605f, 0.02739300f, 
    0.11812727f, 0.00499813f, 0.03091168f, 0.00579460f, 0.21668865f, -0.21336733f, 0.02615376f, -0.04820598f, 
    0.20128669f, 0.06749356f, 0.05591241f, 0.03640327f, 0.09759664f, 0.12053663f, 0.09560898f, 0.14835587f, 
    -0.47295526f, -0.13209811f, -0.02035172f, -0.01143245f, 0.09713114f, -0.07018819f, -0.00124036f, 0.00167847f, 
    -0.01790514f, -0.00866923f, 0.10195512f, -0.17977369f, 0.03371482f, -0.30613744f, -0.30483407f, -0.05660114f, 
    0.03663215f, -0.00463840f, -0.13565040f, 0.07229476f, 0.05262602f, -0.05233387f, -0.01860570f, -0.04165373f, 
    -0.01298219f, 0.13569060f, -0.01263447f, 0.04875840f, 0.00753113f, 0.13563481f, -0.01882062f, -0.02348252f, 
    0.02967035f, 0.12557797f, -0.00977451f, 0.07602379f, -0.13568524f, 0.03684848f, -0.10869206f, -0.06412626f, 
    -0.06457786f, -0.00557963f, 0.02933677f, 0.02600461f, -0.01946975f, -0.03391856f, 0.03120417f, 0.15571524f, 
    -0.06525379f, -0.04396281f, 0.15212369f, 0.07152525f, 0.02499501f, 0.15548874f, -0.24482755f, -0.03744020f, 
    -0.01934936f, -0.03293011f, -0.02978945f, 0.12245000f, 0.03821127f, 0.07238150f, 0.08818294f, -0.09365827f, 
    -0.09012160f, 0.09690219f, 0.17321149f, 0.00827349f, 0.17682244f, 0.13395059f, -0.11097869f, -0.08491208f, 
    -0.30652303f, -0.06149841f, 0.16674398f, -0.06057538f, -0.06944819f, -0.13301536f, 0.11685818f, 0.17912644f, 
    -0.00832782f, -0.09362114f, -0.02259500f, 0.10408895f, 0.51241744f, -0.12381150f, 0.16053019f, -0.06575970f, 
    0.03050138f, -0.08362645f, 0.13924658f, 0.08628654f, -0.03163954f, 0.03019196f, -0.04843893f, 0.04234887f, 
    0.15468583f, 0.09558482f, 0.00174275f, 0.21472675f, 0.02903133f, -0.13829553f, 0.01315760f, -0.06862082f, 
    -0.13691171f, 0.07724552f, -0.11611694f, 0.08331975f, 0.32937592f, 0.09123641f, 0.48046640f, 0.00831896f, 
    0.04382629f, 0.11657247f, -0.05883553f, 0.18388963f, 0.06355468f, 0.13386428f, 0.02149286f, -0.02605520f, 
    0.02741554f, -0.01008904f, -0.08806320f, 0.16956258f, 0.02602017f, -0.10065687f, -0.09885309f, 0.06024857f, 
    -0.08046623f, -0.04666287f, -0.03017166f, -0.03962471f, 0.44619566f, -0.23369826f, -0.01802024f, -0.02764577f, 
    -0.04019833f, 0.05449533f, -0.01952614f, -0.03939314f, -0.03171336f, 0.15905464f, -0.23156214f, 0.21803528f, 
    -0.02553182f, -0.34231526f, -0.12375870f, 0.27134615f, 0.25792733f, 0.17953604f, 0.01991408f, -0.10226794f, 
    0.01455902f, 0.07786065f, 0.01875655f, -0.01988510f, -0.04597229f, 0.17288119f, 0.15193135f, -0.14987272f, 
    0.06761782f, 0.10317574f, 0.05561562f, 0.06517725f, 0.13651012f, 0.09260941f, 0.06546335f, -0.05075004f, 
    0.03195211f, -0.12359846f, 0.18409251f, 0.20667847f, 0.03274346f, -0.19024613f, 0.09513535f, 0.04722540f, 
    0.11366107f, 0.08374290f, -0.17048368f, -0.05170722f, -0.40464258f, 0.18193577f, -0.00452808f, -0.09839605f, 
    0.01051706f, 0.09650244f, -0.06435645f, 0.08411861f, 0.09699883f, -0.02446003f, -0.01015902f, -0.20881143f, 
    0.32297462f, -0.14273486f, -0.01929585f, 0.04899187f, -0.01465272f, 0.04844601f, 0.06587371f, 0.11865874f, 
    -0.01401402f, -0.02473792f, -0.08211038f, 0.12219293f, 0.26785630f, 0.23254967f, 0.20152493f, 0.37212381f, 
    -0.28659248f, -0.11842001f, -0.04736692f, 0.02547208f, -0.01155438f, 0.12774555f, -0.12342470f, -0.19158190f, 
    -0.13862796f, 0.01406316f, -0.02961093f, -0.00609893f, 0.04550000f, 0.22157453f, -0.10275424f, 0.01586914f, 
    0.04425425f, 0.00783899f, 0.04998486f, -0.10256233f, 0.05706595f, 0.02344775f, -0.05138740f, -0.04071540f, 
    0.07395669f, 0.13345158f, 0.15584856f, 0.09295274f, 0.10042085f, -0.11034361f, -0.07586062f, 0.02174929f, 
    0.10200007f, -0.24327756f, -0.02644739f, 0.04060622f, 0.01089906f, 0.11100271f, -0.03311211f, 0.00720090f, 
    -0.09236401f, -0.23836571f, 0.07200054f, 0.08929696f, 0.21135141f, 0.10788707f, 0.13937795f, 0.08546466f, 
    -0.07627891f, 0.08427661f, 0.10146515f, 0.01293971f, 0.09136471f, 0.11220806f, 0.00721819f, -0.06834470f, 
    -0.05568282f, -0.15571281f, -0.06722698f, 0.03503343f, 0.02876245f, 0.05290809f, 0.08722501f, 0.24186529f, 
    -0.00610667f, -0.09861276f, 0.00537666f, 0.13802835f, -0.24415174f, 0.14594454f, 0.02412319f, -0.20616734f, 
    -0.11419513f, 0.08358475f, -0.01256072f, 0.01500510f, 0.14909843f, 0.10547622f, 0.01719101f, 0.01184785f, 
    -0.06702027f, -0.11245967f, 0.01534469f, 0.17793557f, 0.19006665f, -0.05330779f, -0.08759551f, 0.02454552f, 
    0.08404288f, -0.07501050f, 0.10734630f, 0.19861515f, -0.01172155f, -0.23362134f, 0.13818422f, -0.35501662f, 
    0.01900665f, -0.09154769f, 0.08494695f, 0.09507089f, -0.00094620f, 0.00720434f, 0.09256881f, -0.12207710f, 
    0.26729557f, 0.29285601f, 0.08456019f, 0.10220845f, 0.03085144f, 0.10645181f, -0.03084541f, -0.01323014f, 
    -0.10820738f, -0.01515126f, 0.07252636f, 0.18601839f, -0.04792902f, -0.02967893f, -0.07281763f, -0.19582237f, 
    -0.01122192f, -0.04057601f, -0.11711393f, -0.08380221f, -0.03173732f, 0.02435394f, 0.09478278f, -0.09068170f, 
    0.28388491f, 0.00755837f, -0.15638997f, -0.01316832f, -0.04106449f, -0.09980085f, 0.06857924f, 0.05517457f, 
    -0.01880993f, -0.00736115f, -0.02192494f, -0.09410603f, 0.03420938f, -0.16653113f, 0.11899234f, 0.01504100f, 
    0.13808466f, -0.07832997f, -0.10348513f, 0.12086508f, 0.02432101f, -0.00106287f, -0.05708957f, -0.16534336f, 
    0.28004339f, 0.49712169f, -0.04307787f, 0.12282948f, 0.06485652f, -0.03433094f, 0.05953627f, 0.01204344f, 
    -0.22046481f, 0.07282840f, -0.02472277f, 0.05284794f, -0.04486106f, 0.11451188f, -0.07311420f, -0.07920910f, 
    0.13136964f, 0.10346591f, 0.02072012f, 0.13795860f, 0.07588305f, 0.04440047f, 0.16094144f, 0.00240866f, 
    -0.27777430f, -0.05387920f, 0.12294736f, -0.06498072f, 0.06296116f, -0.00484299f, 0.12967829f, -0.02711027f, 
    -0.02837412f, 0.11873582f, 0.02180850f, -0.06989987f, 0.22764118f, 0.11815575f, -0.12405137f, 0.12564670f, 
    0.13242392f, 0.11375814f, 0.08083839f, 0.09783205f, -0.10433847f, 0.19744875f, 0.01036918f, -0.01502920f, 
    -0.21345414f, -0.16761775f, 0.14184618f, -0.05012452f, -0.02713887f, -0.04448006f, -0.03085901f, -0.17690644f, 
    -0.05983475f, 0.06963874f, -0.04562182f, -0.04883322f, -0.17943734f, -0.05957413f, 0.09590525f, 0.06158268f, 
    0.09433684f, -0.16077742f, -0.00743639f, -0.01336291f, -0.08210921f, 0.17882204f, 0.13087383f, -0.05262370f, 
    0.18083493f, 0.26834679f, 0.12191278f, -0.11613327f, 0.11435635f, 0.08277109f, -0.00261612f, 0.01851187f, 
    -0.08138647f, 0.13589469f, -0.04445079f, -0.00168962f, -0.06287109f, -0.07924678f, 0.19354814f, 0.32567933f, 
    -0.21225552f, -0.03347358f, -0.17855236f, -0.03020723f, -0.05766773f, -0.05096989f, -0.09256431f, -0.10996404f, 
    -0.05351423f, 0.09830973f, -0.06080090f, 0.08681260f, -0.13455831f, -0.16839729f, 0.03671110f, -0.09098775f, 
    -0.12031776f, 0.03046904f, -0.12095457f, -0.02700863f, 0.57918179f, -0.04340252f, 0.01408957f, 0.06914185f, 
    -0.20224354f, -0.10851067f, 0.16740039f, 0.03206692f, -0.10254572f, -0.16959608f, 0.00794836f, 0.02921676f, 
    0.17333686f, 0.11633142f, 0.00103496f, 0.16035502f, -0.09898913f, 0.13624887f, 0.03947767f, -0.09731475f, 
    -0.06545343f, -0.08544739f, -0.11655064f, -0.10324919f, -0.05982241f, -0.06214062f, 0.33318868f, 0.00556641f, 
    -0.01223969f, 0.07122586f, 0.11976065f, 0.00983872f, 0.05532349f, 0.03660289f, 0.06534543f, 0.02537824f, 
    -0.03728525f, 0.04456215f, -0.05921634f, -0.04767200f, -0.02998627f, -0.00260622f, -0.01037307f, -0.04383970f, 
    0.05859379f, 0.04013671f, 0.02784922f, -0.04451951f, -0.00563040f, 0.00194605f, -0.01151810f, -0.04888260f, 
    -0.05860861f, -0.06508254f, -0.08002555f, -0.02798460f, 0.01020019f, -0.07212924f, -0.03113760f, -0.07189798f, 
    -0.01802975f, -0.07755338f, 0.04801598f, -0.07746665f, -0.04433809f, 0.01883524f, -0.01343509f, 0.03762547f, 
    -0.02416075f, -0.03815781f, 0.02892887f, -0.05172561f, 0.06064676f, 0.02276366f, -0.02043531f, -0.00744576f, 
    0.06141365f, 0.01505461f, -0.04300751f, 0.01615825f, -0.07505030f, 0.00100004f, 0.04709134f, -0.01586322f, 
    0.02041832f, 0.03432998f, -0.05818886f, -0.06334833f, -0.05012479f, -0.00975917f, -0.01863593f, -0.00359269f, 
    -0.07873084f, 0.05362459f, -0.00510104f, -0.01670873f, -0.03943725f, 0.03552495f, -0.03147086f, 0.05832561f, 
    -0.03784813f, -0.01950309f, 0.00480110f, 0.05431595f, 0.01983207f, 0.03228321f, -0.07166938f, -0.05748199f, 
    -0.01948149f, -0.04961028f, -0.07042358f, 0.04951846f, 0.02267131f, -0.03468311f, -0.01775295f, -0.01283078f, 
    -0.02882383f, -0.01429510f, -0.00626946f, 0.00501596f, -0.01290354f, 0.01702266f, 0.03696185f, -0.04537647f, 
    -0.05779665f, 0.00219401f, 0.03126412f, 0.00218157f, -0.01650929f, -0.00723073f, -0.07711183f, 0.03411791f, 
    0.03217265f, -0.01595091f, -0.07667492f, -0.02939341f, -0.01783519f, 0.04171124f, 0.05107017f, -0.06838376f, 
    0.06035483f, -0.04435873f, -0.06986234f, 0.02568708f, -0.05476020f, 0.06092701f, -0.05181074f, 0.05414115f, 
    -0.02230799f, -0.04407337f, -0.03028895f, -0.06202484f, 0.01479741f, 0.03268890f, 0.01488027f, -0.00761928f, 
    0.05243368f, 0.02332574f, -0.05182761f, -0.01324264f, 0.04059305f, 0.02022188f, -0.06865452f, 0.05478103f, 
    0.01513922f, -0.01032822f, 0.04299469f, -0.03004094f, -0.02506716f, 0.00727199f, -0.02804420f, 0.05850107f, 
    -0.03508444f, 0.02069470f, -0.05333621f, -0.02942662f, 0.05209623f, 0.01724321f, 0.03030688f, 0.04089988f, 
    -0.02423388f, -0.00829504f, -0.01806756f, -0.05526812f, -0.04433668f, 0.01467029f, 0.00302380f, -0.02735408f, 
    -0.00640090f, -0.01452520f, -0.06518723f, -0.03858212f, -0.07771694f, 0.00659532f, -0.07022613f, 0.00153102f, 
    0.02366158f, 0.06109949f, -0.06637695f, 0.06099982f, 0.04384447f, 0.00543698f, 0.01645566f, 0.00302012f, 
    0.02132901f, -0.06469731f, -0.05782380f, 0.02372697f, 0.03378499f, 0.05752088f, -0.05101646f, -0.02523027f, 
    -0.04635133f, 0.02575785f, -0.03320579f, -0.03015132f, -0.00163332f, 0.02910123f, 0.04708190f, -0.06732092f, 
    -0.01197294f, 0.05110599f, 0.02904668f, 0.05073112f, -0.01143354f, 0.02163717f, -0.02670421f, -0.05767150f, 
    -0.23708439f, -0.04977416f, 0.27639759f, -0.26600891f, 0.17404540f, 0.00721731f, 0.02974650f, 0.10627568f, 
    0.00154530f, 0.04978123f, -0.03725633f, 0.05117034f, 0.04940296f, -0.10216174f, 0.20801280f, -0.01909175f, 
    -0.05137692f, -0.05632689f, 0.10514259f, 0.06707154f, 0.02222447f, -0.02219685f, 0.15453316f, -0.06115817f, 
    0.12332997f, 0.30507702f, 0.09275436f, -0.04484784f, -0.05719844f, -0.02049422f, -0.02221086f, 0.01518675f, 
    0.12449509f, 0.06972907f, -0.01393325f, 0.01791789f, -0.09339116f, -0.05310171f, -0.02604934f, -0.22608513f, 
    -0.06653710f, -0.05094280f, 0.08665133f, -0.03059177f, -0.07535867f, -0.04101838f, 0.06396824f, -0.01992686f, 
    -0.09106052f, -0.23375288f, 0.12685347f, -0.20438890f, 0.03815576f, 0.11583613f, 0.09371448f, 0.01278754f, 
    0.02374281f, 0.08879036f, -0.05233683f, 0.21263728f, 0.18751995f, -0.06916188f, -0.08930789f, 0.26215810f, 
    -0.09463778f, 0.06626544f, 0.10164551f, -0.10875229f, 0.07670768f, 0.02715679f, -0.02254634f, 0.09568818f, 
    0.62503541f, -0.27801937f, -0.09714467f, 0.37308514f, -0.17832640f, 0.04572642f, -0.10584658f, -0.06848355f, 
    0.02867397f, 0.08147103f, 0.06557395f, 0.06543902f, 0.03210396f, -0.27458739f, -0.01975727f, -0.24132501f, 
    0.13225342f, 0.02138313f, 0.15711565f, -0.00725289f, -0.04382631f, -0.08836970f, 0.07426675f, 0.16961354f, 
    0.02064763f, 0.17087854f, 0.05293263f, -0.09718993f, 0.06405882f, -0.05779323f, 0.05962207f, -0.04453437f, 
    -0.10259213f, 0.11550578f, 0.08827887f, 0.11944723f, 0.01292738f, -0.03474014f, -0.03683620f, -0.19763803f, 
    0.00040885f, 0.03558955f, -0.21641596f, -0.12798621f, -0.04897122f, 0.21581620f, 0.02938960f, 0.06040999f, 
    0.05156241f, 0.11623573f, 0.11901624f, 0.00922347f, 0.01403679f, -0.20088652f, 0.16635321f, 0.26663715f, 
    -0.00007129f, 0.02468786f, 0.03196035f, 0.18279944f, 0.01217583f, 0.22727917f, 0.08752775f, -0.47125217f, 
    0.26080573f, 0.16501848f, 0.07320961f, 0.01403780f, 0.04305444f, -0.16065714f, 0.02676127f, -0.05940744f, 
    0.13591272f, -0.04158902f, 0.13449298f, 0.21258466f, 0.01267294f, -0.05408105f, -0.17114288f, 0.06714403f, 
    0.03821830f, 0.15522008f, -0.09563442f, -0.13104144f, -0.09574233f, 0.08104344f, 0.05422602f, 0.08104473f, 
    -0.03526620f, 0.01232110f, -0.00530701f, -0.01159568f, 0.02350609f, 0.09369583f, -0.11544329f, 0.08449279f, 
    0.16208802f, -0.06336205f, -0.21576823f, 0.17569318f, -0.05910208f, 0.16942731f, -0.05234042f, 0.02433553f, 
    0.02896826f, -0.03741158f, -0.18465684f, -0.17538796f, 0.07860849f, -0.14804168f, 0.26560128f, -0.26055804f, 
    -0.12161434f, 0.06974457f, 0.09863809f, 0.02665402f, -0.06070151f, 0.02422520f, -0.00751576f, 0.07278946f, 
    0.13714238f, 0.01961335f, -0.12364241f, 0.07866651f, 0.00632305f, -0.13073742f, 0.04846212f, -0.01665763f, 
    0.12514184f, -0.03013788f, -0.16313946f, -0.08219325f, 0.00605486f, 0.09335081f, 0.11708467f, 0.19971631f, 
    0.07304290f, -0.02845136f, 0.05691416f, 0.14411713f, 0.11521534f, 0.04639065f, 0.08951481f, 0.04723836f, 
    0.22234422f, 0.07184329f, -0.02503987f, -0.09434073f, -0.12116706f, -0.02455090f, 0.01325458f, 0.01523663f, 
    0.17951986f, 0.09793901f, -0.04723881f, 0.15028375f, -0.02745583f, -0.02654026f, -0.13299476f, -0.15245032f, 
    -0.14524934f, 0.15287393f, 0.01495697f, 0.01162987f, 0.02703690f, 0.10691989f, 0.08227865f, -0.04746256f, 
    -0.19572560f, 0.18801208f, -0.08863080f, 0.04464967f, -0.04640573f, 0.08013571f, -0.06618133f, -0.05292650f, 
    0.16452153f, 0.02535361f, 0.04281837f, 0.14818735f, -0.14811347f, -0.24063113f, 0.02275295f, -0.03924920f, 
    -0.01154968f, -0.03231311f, 0.14135963f, 0.07776485f, -0.03899033f, -0.07794700f, -0.00771983f, 0.19697885f, 
    0.20341136f, -0.03754859f, -0.06928303f, 0.09561603f, 0.07639006f, 0.05492768f, 0.18876079f, 0.14710616f, 
    -0.03869972f, -0.11080657f, 0.08798171f, -0.04498186f, -0.02222372f, -0.07907610f, 0.00384504f, -0.15249306f, 
    -0.13404109f, -0.08283199f, -0.00138272f, -0.12100704f, -0.02874475f, -0.07322069f, 0.09807094f, -0.05612072f, 
    0.26620585f, 0.03500438f, -0.29426926f, -0.08110516f, 0.03142402f, 0.05188893f, 0.03648020f, 0.07223894f, 
    -0.07030275f, 0.05043903f, 0.10589970f, 0.15552631f, 0.17667826f, 0.18712839f, -0.11598450f, -0.18589103f, 
    -0.04808655f, -0.15738533f, 0.13622956f, 0.05490050f, 0.19812387f, -0.05055673f, 0.01505260f, 0.26765066f, 
    -0.50748318f, -0.35025892f, -0.09800607f, 0.02994441f, 0.10344919f, -0.03789858f, 0.14174515f, 0.14977114f, 
    0.01538675f, -0.13339247f, -0.08385462f, -0.04953402f, 0.15832749f, 0.22715729f, -0.06531820f, -0.03961624f, 
    0.12406079f, -0.08604488f, -0.00317885f, 0.07397933f, -0.01572558f, 0.01946917f, -0.00595313f, 0.10182527f, 
    -0.14073722f, -0.08024292f, 0.02296854f, -0.09826889f, 0.12034895f, -0.09265013f, -0.06885584f, 0.19740844f, 
    0.21450259f, 0.03239280f, -0.00461820f, -0.07791979f, -0.38230133f, 0.10300520f, 0.20712598f, -0.00804951f, 
    0.09659209f, 0.09174197f, 0.01008387f, 0.02504308f, 0.02552839f, 0.13861437f, -0.00016053f, 0.04745200f, 
    0.15794529f, -0.14789526f, 0.03183445f, -0.23159020f, -0.00497854f, -0.12483671f, -0.11161365f, 0.05656850f, 
    -0.04195013f, -0.12648340f, -0.04145156f, 0.00249692f, 0.07989104f, -0.34723321f, -0.14620298f, 0.03222550f, 
    0.10561266f, 0.10045489f, -0.06137404f, 0.06312694f, -0.04497525f, -0.06176057f, -0.09020797f, -0.09652717f, 
    0.42107770f, -0.08835685f, -0.04900586f, 0.07354670f, 0.00189435f, -0.03833919f, 0.17623538f, 0.03784493f, 
    -0.00632842f, 0.00073549f, -0.05696215f, -0.13623255f, 0.04796159f, 0.01768743f, -0.00016538f, -0.02113385f, 
    0.01681569f, -0.07305721f, 0.05830299f, 0.02956974f, -0.10767893f, 0.03251994f, -0.06912126f, -0.00061988f, 
    0.36541721f, 0.05156928f, -0.19358474f, 0.07121827f, 0.04337814f, -0.00122251f, 0.09241348f, 0.01431671f, 
    0.05550628f, 0.11004575f, 0.08630217f, 0.10688526f, -0.14651775f, 0.26019982f, 0.02813688f, 0.05813485f, 
    -0.06967504f, 0.06819765f, 0.06764310f, -0.10836524f, 0.08754379f, 0.12750399f, 0.05171660f, -0.20625176f, 
    -0.10125742f, -0.00462438f, 0.08013518f, -0.07083446f, 0.00058012f, -0.03095491f, -0.03012351f, -0.00294652f, 
    0.01119616f, 0.02885879f, -0.10459667f, 0.10519896f, -0.04912123f, -0.03575587f, -0.04097229f, -0.02258237f, 
    -0.15422149f, -0.03384684f, 0.15730233f, -0.07965424f, 0.00033374f, 0.01485894f, -0.03242883f, 0.01399591f, 
    0.91130930f, -0.05303741f, 0.09798223f, 0.07829973f, -0.08679461f, 0.14198916f, 0.02845315f, 0.00467439f, 
    0.00861687f, 0.03223614f, 0.06468564f, 0.02734315f, 0.36548671f, 0.34004611f, 0.27911332f, 0.01033778f, 
    -0.00671204f, -0.14530763f, 0.09622531f, -0.11083433f, 0.07481911f, -0.11434777f, 0.00717218f, -0.03115110f, 
    0.20341088f, -0.11848252f, -0.06131382f, 0.08464912f, 0.00025309f, 0.14769660f, 0.03907661f, -0.05558570f, 
    -0.10793438f, 0.12431363f, 0.00701100f, 0.01057477f, -0.08693960f, 0.00431563f, -0.10313903f, -0.13027126f, 
    0.09702064f, -0.06861939f, -0.02526560f, 0.01586376f, 0.10076855f, 0.04079130f, -0.08871136f, -0.02284856f, 
    0.07903030f, -0.09082244f, 0.01301259f, 0.07665108f, -0.03432797f, -0.04460161f, 0.19538859f, 0.05468372f, 
    0.06775444f, 0.03395266f, -0.04830439f, 0.11118919f, 0.00616032f, 0.00881047f, -0.11148945f, -0.15534745f, 
    0.09647845f, -0.03247434f, -0.05562057f, -0.00639657f, 0.07363603f, 0.13532227f, 0.06134007f, -0.02118378f, 
    0.18976453f, 0.04180964f, -0.30974686f, -0.12190385f, 0.16161680f, 0.09507251f, -0.05536671f, 0.14043626f, 
    0.10348835f, 0.03271722f, 0.04542665f, -0.03613081f, -0.53668875f, 0.31885350f, -0.12186082f, 0.03725571f, 
    0.09011225f, -0.05718905f, -0.20696844f, -0.13900004f, -0.10553098f, -0.03902891f, 0.06669468f, 0.07078405f, 
    0.15754612f, -0.22539531f, 0.23388322f, 0.01300733f, -0.15999186f, 0.05017726f, -0.08178919f, -0.06385351f, 
    -0.05799185f, 0.02641810f, 0.00663742f, -0.01318086f, 0.24561587f, -0.19044852f, -0.33846563f, -0.00159062f, 
    -0.04902967f, -0.06365718f, 0.03738104f, -0.04965302f, -0.03810638f, -0.02191281f, 0.00599497f, 0.05775299f, 
    0.07622056f, 0.16177367f, 0.16712999f, 0.18894818f, 0.11490275f, 0.05595176f, 0.14544089f, 0.01238848f, 
    0.02220485f, 0.15341215f, -0.01153788f, 0.04744409f, -0.40748405f, 0.00013179f, -0.07215825f, -0.09734131f, 
    0.10336605f, 0.05886715f, 0.00831313f, -0.00666405f, 0.07059389f, -0.00063191f, 0.16552030f, -0.01610165f, 
    -0.05012621f, 0.10186134f, 0.26845640f, -0.18157575f, -0.24191844f, -0.11722159f, -0.08430269f, 0.10034596f, 
    -0.01488003f, 0.06345269f, -0.05127664f, -0.08813106f, 0.36277243f, -0.10741967f, -0.17900400f, 0.08732323f, 
    0.09396569f, 0.03190067f, -0.00890497f, 0.01962996f, -0.08573733f, -0.04300751f, -0.02354057f, 0.04059362f, 
    0.34459180f, -0.20340538f, -0.03936745f, 0.00708333f, -0.04376033f, 0.23876020f, -0.01600453f, 0.04621548f, 
    -0.20762280f, -0.01620279f, 0.15416323f, -0.04954842f, 0.22671467f, 0.09695315f, 0.11292201f, 0.19774529f, 
    -0.05665563f, 0.01893113f, 0.14735174f, -0.05035262f, -0.05282015f, -0.00482949f, -0.09468919f, 0.21657737f, 
    -0.46425515f, 0.18375759f, 0.01088301f, 0.07272694f, -0.00238919f, -0.03586418f, -0.00419350f, 0.07148284f, 
    0.06066801f, 0.06003147f, -0.01617078f, 0.01084279f, -0.25656036f, 0.08983628f, 0.08784490f, -0.23628823f, 
    0.17594880f, 0.15527299f, 0.10163620f, -0.08319002f, -0.10590159f, 0.04015006f, 0.03233739f, 0.07949620f, 
    0.01120293f, 0.18062031f, 0.08327850f, 0.03394369f, -0.01267840f, -0.20991820f, 0.07430237f, 0.07470217f, 
    -0.00427808f, -0.05327770f, 0.08629622f, 0.17052595f, 0.07457151f, 0.02286758f, 0.25080478f, 0.10170110f, 
    0.09238532f, -0.00216950f, 0.01842050f, 0.10995197f, 0.00744765f, -0.03816584f, 0.01633107f, -0.10499740f, 
    0.03426514f, 0.15153752f, 0.01795786f, -0.09690904f, 0.06710883f, -0.06145658f, 0.15291198f, -0.07295271f, 
    0.05419043f, 0.12107750f, 0.05695301f, -0.10020661f, -0.05043891f, -0.14062008f, 0.25097665f, 0.11105397f, 
    0.06921575f, -0.07790001f, -0.08932725f, -0.05068108f, -0.07322200f, -0.09724862f, 0.07885291f, 0.00163395f, 
    0.28705111f, -0.05603489f, 0.23659933f, 0.15170129f, -0.07165905f, -0.00118083f, -0.06619029f, -0.09449127f, 
    0.10725085f, 0.17640841f, 0.01332640f, -0.00270214f, 0.34891760f, -0.17203066f, -0.06494350f, 0.30350399f, 
    0.09312405f, -0.00405943f, -0.01694151f, -0.07213365f, -0.14110719f, -0.02350962f, -0.05095204f, -0.04920978f, 
    0.10755867f, 0.27691877f, -0.11593163f, -0.10810194f, -0.14210829f, 0.11835875f, 0.15539159f, 0.05019468f, 
    -0.00558382f, 0.04345283f, 0.03096053f, -0.05757005f, -0.29156691f, 0.21812685f, 0.01183642f, 0.18389961f, 
    -0.04437706f, 0.03738758f, 0.06336138f, -0.00734187f, -0.02064903f, 0.04988203f, -0.09585343f, 0.06018041f, 
    0.28041127f, -0.27962735f, 0.09048615f, -0.16569033f, 0.01591311f, 0.05379096f, 0.09823049f, 0.01206172f, 
    -0.00035760f, -0.08759523f, 0.11054239f, 0.08197986f, 0.06033016f, 0.28060284f, -0.04363017f, -0.09128780f, 
    0.07003453f, 0.09088419f, 0.08710513f, 0.09129532f, -0.07257021f, 0.02577216f, 0.03599665f, -0.16223228f, 
    0.58580959f, 0.01727010f, -0.35364845f, 0.08944451f, -0.01230435f, -0.05677741f, -0.03496337f, 0.00125966f, 
    0.00539332f, 0.01421487f, 0.00693844f, 0.03042105f, -0.24631645f, 0.07801559f, 0.05824417f, -0.09895997f, 
    -0.02136562f, 0.05149885f, -0.00054020f, -0.10205378f, -0.02275795f, 0.01269072f, -0.00772627f, -0.11026358f, 
    -0.22227997f, 0.43076852f, 0.13209838f, -0.09242897f, 0.22883908f, 0.00848040f, -0.05430967f, 0.04468455f, 
    0.03996057f, 0.02237974f, 0.07215074f, 0.04240093f, 0.19034088f, -0.27031663f, -0.05693967f, 0.09717321f, 
    0.03355147f, -0.05531212f, -0.06087651f, 0.08791182f, 0.08100560f, 0.13576785f, 0.14262354f, 0.01888541f, 
    0.22454244f, 0.13370411f, 0.05667155f, 0.13723218f, -0.02027745f, -0.10168223f, 0.08971922f, -0.07352830f, 
    -0.03626847f, 0.03094496f, 0.12618853f, -0.00987369f, 0.05384194f, 0.06761937f, -0.14165416f, -0.42832381f, 
    -0.00224504f, 0.04297074f, -0.11798500f, -0.05229753f, -0.04276463f, 0.01024718f, -0.01057282f, 0.17017484f, 
    0.01838127f, -0.37581122f, 0.11172318f, 0.12830083f, 0.02417624f, -0.05132059f, 0.11504299f, -0.18555267f, 
    0.10798549f, 0.11028245f, 0.01907877f, -0.01885969f, -0.07864560f, -0.03301301f, 0.03528886f, 0.04810745f, 
    0.09227445f, -0.01367364f, -0.07393115f, 0.00425013f, -0.03022609f, 0.27112970f, 0.12960546f, 0.10216379f, 
    0.12596253f, 0.13803682f, -0.04600722f, -0.13135652f, 0.11090004f, 0.08537954f, 0.08204277f, 0.05717085f, 
    0.01542692f, 0.10654999f, -0.00394103f, 0.05276564f, -0.11674784f, -0.01954278f, -0.13359405f, -0.04152856f, 
    0.20082387f, 0.09934808f, -0.02004582f, -0.09860347f, 0.12407207f, -0.00503954f, -0.18183462f, -0.07450658f, 
    0.05108553f, 0.01200114f, -0.05098099f, -0.07353409f, 0.04096194f, -0.02807246f, 0.00329673f, 0.09807574f, 
    0.01028516f, 0.01791092f, -0.03422703f, -0.04306763f, 0.01409276f, 0.33440423f, 0.02401745f, 0.03296765f, 
    0.05131417f, -0.07960673f, -0.13928707f, 0.02766691f, 0.04381522f, 0.01907769f, -0.12164601f, 0.00132564f, 
    0.24326786f, -0.21035254f, 0.22721970f, 0.33531058f, -0.22898096f, 0.00479546f, -0.12378574f, 0.01227675f, 
    -0.09886516f, 0.00755465f, 0.05231869f, -0.08210254f, 0.35785532f, 0.08672190f, -0.23149726f, 0.02671391f, 
    -0.02328724f, 0.10179559f, -0.02525075f, 0.02876378f, -0.00691572f, 0.01246556f, 0.10875878f, 0.07540917f, 
    0.17818402f, 0.28792483f, 0.00829511f, 0.38597873f, 0.04754574f, -0.03908594f, 0.12235422f, 0.00352055f, 
    -0.06343684f, -0.12392613f, -0.00126886f, 0.00537064f, -0.01122088f, -0.19263323f, -0.11842895f, -0.18986203f, 
    0.04362235f, -0.01798730f, -0.01087123f, -0.05846386f, -0.06153935f, 0.10403080f, -0.05780778f, 0.14281528f, 
    0.12781155f, -0.27220380f, -0.04557670f, 0.02246039f, -0.12222782f, -0.13913476f, -0.06683516f, 0.02801826f, 
    0.06934652f, 0.13495652f, -0.04036053f, 0.05273310f, 0.21634997f, 0.01891339f, 0.01040690f, -0.03139555f, 
    0.11466876f, 0.14218113f, -0.06347672f, 0.01675111f, 0.07096322f, 0.15681736f, -0.03969755f, -0.09997401f, 
    0.58336061f, -0.09186680f, 0.14363648f, 0.23936413f, -0.05882538f, -0.12573680f, -0.00961833f, 0.11868665f, 
    -0.09341975f, 0.06936055f, 0.00376721f, -0.01011214f, -0.21749832f, 0.16461375f, 0.06180381f, 0.02852749f, 
    -0.04795555f, -0.03385424f, 0.05652908f, -0.03588441f, -0.03372154f, -0.00410589f, -0.07120374f, -0.02848376f, 
    -0.52576458f, 0.07435646f, -0.15987003f, -0.12759158f, 0.20308343f, -0.00850102f, -0.01873256f, -0.00185225f, 
    0.04409058f, 0.00032818f, -0.07752871f, 0.02453618f, 0.01217120f, 0.34175238f, 0.22530575f, 0.07403613f, 
    0.00069764f, 0.09316806f, 0.06711086f, 0.05209457f, -0.02062910f, 0.17497954f, -0.00921829f, -0.08998967f, 
    -0.11580312f, 0.11665788f, 0.10534277f, -0.06442838f, -0.14391731f, -0.02294574f, -0.02078006f, 0.00790906f, 
    -0.05156328f, 0.02753535f, 0.19342782f, 0.02078721f, 0.14032242f, 0.15541430f, 0.14246914f, 0.06871957f, 
    0.12437104f, 0.01268974f, 0.14996231f, 0.27788690f, 0.04312350f, -0.23513648f, -0.01341377f, -0.08274131f, 
    -0.04180462f, -0.16200550f, -0.09084940f, -0.19476183f, 0.02483716f, 0.13903683f, 0.02752774f, -0.08173171f, 
    -0.00879463f, 0.03934973f, 0.02501081f, -0.02971677f, 0.07217241f, -0.12125425f, 0.31649637f, 0.29863623f, 
    -0.06187749f, -0.20863838f, 0.05798200f, -0.04412147f, 0.01779131f, -0.05700523f, 0.17399837f, 0.04981439f, 
    0.08592339f, -0.24729694f, 0.12901062f, 0.26001614f, -0.03943295f, -0.07136215f, 0.04652246f, 0.03677416f, 
    0.13072880f, 0.23870458f, 0.02890130f, 0.08386043f, 0.24104849f, -0.13985340f, -0.06366152f, -0.18802541f, 
    -0.04736111f, 0.06363991f, -0.02660617f, -0.16065596f, -0.05243051f, 0.11183517f, 0.19613428f, -0.04185900f, 
    0.01462470f, -0.11686773f, -0.02780166f, 0.04377801f, 0.03738790f, -0.01943807f, -0.04572006f, 0.00091264f, 
    0.08733871f, 0.04821511f, 0.05863462f, 0.23037535f, -0.25707424f, -0.08828081f, 0.11831658f, -0.17172867f, 
    -0.11562788f, -0.11284588f, 0.04788347f, 0.00592493f, -0.07879554f, 0.07180256f, -0.02527983f, 0.05121824f, 
    0.05470844f, -0.22625221f, 0.10046891f, 0.04233987f, 0.10180248f, 0.04784775f, 0.13637547f, 0.09285140f, 
    0.15947564f, 0.03590764f, 0.05429479f, 0.07727972f, -0.36171162f, -0.06246027f, 0.12589169f, 0.07735557f, 
    0.07678224f, 0.08886742f, 0.15816255f, 0.06118049f, 0.12438665f, -0.01119175f, 0.19975407f, -0.12979153f, 
    -0.14324851f, 0.10167298f, 0.10626744f, -0.11845476f, -0.03081444f, 0.07860045f, -0.00443194f, 0.05972418f, 
    0.03673618f, 0.04025665f, -0.04976375f, -0.05200186f, 0.14327943f, -0.18058565f, -0.16241679f, 0.04901889f, 
    -0.19713911f, 0.11987151f, -0.00462008f, -0.00416467f, -0.17848927f, 0.03420292f, -0.10749459f, -0.04017397f, 
    0.12849393f, -0.20482516f, 0.01652724f, -0.10767228f, 0.14895092f, 0.18899059f, 0.04132681f, 0.03664254f, 
    0.07509591f, 0.02781831f, 0.12176831f, 0.06278259f, -0.08813163f, -0.14966220f, 0.08093924f, 0.07958786f, 
    -0.07530843f, 0.07833231f, 0.04341307f, 0.06649368f, -0.11133856f, -0.07875234f, -0.01859763f, 0.10746080f, 
    0.19299351f, 0.19894250f, -0.05956825f, 0.24586299f, -0.15810366f, -0.08230375f, 0.04947530f, 0.11751413f, 
    0.04270634f, -0.02510758f, 0.01382035f, 0.06249591f, -0.10570902f, -0.08572312f, -0.08998431f, -0.29207513f, 
    -0.08309515f, 0.07810834f, 0.02836239f, -0.18781374f, -0.02516944f, -0.01224830f, 0.04586409f, 0.13230857f, 
    -0.11268523f, -0.10221291f, 0.04965731f, -0.07347192f, 0.06636235f, -0.10406445f, 0.08255824f, 0.06552282f, 
    -0.00897120f, 0.09611942f, 0.09273087f, 0.06407807f, 0.23187095f, 0.21657775f, 0.17732452f, 0.10916408f, 
    -0.00267954f, -0.01884387f, -0.00276611f, 0.02151545f, 0.13235448f, 0.17618276f, 0.00206475f, 0.02350342f, 
    -0.30849096f, 0.06329564f, -0.09481129f, -0.18659018f, 0.05613105f, -0.12211335f, 0.33893156f, 0.12332319f, 
    0.11190476f, 0.14996958f, -0.04921392f, 0.05463766f, 0.17976476f, 0.01674412f, 0.03999389f, 0.12548418f, 
    0.19107279f, 0.11230378f, -0.04178840f, 0.05727609f, -0.09809650f, -0.14258052f, 0.09321169f, 0.00424356f, 
    0.13715823f, 0.09275481f, 0.16835584f, 0.24860901f, 0.09461756f, 0.07050913f, 0.06196273f, -0.09770343f, 
    0.13356435f, 0.13394791f, -0.03067275f, -0.07192294f, -0.23348300f, -0.07794598f, 0.04887001f, 0.25803295f, 
    0.15799102f, 0.15352383f, 0.07582606f, -0.07944275f, -0.03511014f, 0.09664725f, -0.07913918f, -0.01068271f, 
    -0.01794987f, -0.05621563f, 0.01330448f, -0.20636041f, -0.05480590f, 0.17120686f, 0.06070445f, 0.11178554f, 
    0.13814490f, -0.12019237f, 0.10265058f, -0.04292183f, -0.09987568f, -0.10527083f, -0.33385807f, 0.15232801f, 
    -0.07077258f, 0.00477747f, -0.02654377f, 0.09242596f, -0.05491704f, -0.00121226f, -0.11668625f, 0.06104356f, 
    -0.10835570f, 0.01059526f, 0.08380910f, -0.00499633f, -0.04713811f, 0.08920945f, -0.22241122f, 0.08605328f, 
    0.00934228f, 0.00123565f, 0.14568444f, 0.08836943f, -0.27932116f, 0.18178472f, 0.10405042f, 0.22212915f, 
    0.13219815f, -0.04210588f, 0.13615806f, -0.00246297f, 0.03760065f, -0.12694624f, 0.23588611f, -0.14218996f, 
    0.00882886f, 0.21422885f, 0.18767720f, -0.06964853f, 0.19159611f, -0.00084642f, -0.11490454f, 0.03243529f, 
    0.06611983f, 0.10429915f, 0.00806127f, -0.09564962f, 0.36976838f, 0.03625753f, -0.11566393f, 0.12246761f, 
    -0.02283265f, 0.00528466f, -0.06776084f, 0.15350257f, -0.22072102f, -0.10890882f, -0.07719907f, 0.08503199f, 
    0.02328674f, 0.34254071f, -0.25045571f, 0.04135744f, 0.09170502f, 0.11582837f, -0.01419919f, -0.05883992f, 
    0.08209074f, 0.00581033f, 0.08976375f, 0.18229440f, -0.22083102f, -0.04462588f, 0.09682046f, -0.15596728f, 
    -0.02345780f, 0.13165547f, 0.12155581f, 0.04655571f, -0.08022874f, 0.00502277f, 0.02527483f, 0.29220366f, 
    -0.14185278f, 0.16528141f, 0.01269353f, 0.21605523f, 0.02654901f, -0.03557773f, 0.06679676f, -0.01031918f, 
    -0.00484010f, 0.04074641f, 0.01940484f, 0.00027517f, -0.38597140f, -0.23367165f, 0.16622809f, 0.14022581f, 
    0.04145331f, -0.03418608f, 0.16754331f, 0.00047054f, -0.20450845f, 0.08690538f, 0.18393290f, 0.11493903f, 
    0.29657647f, 0.15512624f, -0.17824420f, -0.11665770f, 0.05868097f, -0.13355462f, 0.02023471f, 0.04286347f, 
    -0.02833212f, 0.00609907f, 0.13304059f, 0.07352523f, -0.14116092f, -0.05898581f, -0.13701290f, -0.03024708f, 
    -0.08499144f, -0.12361059f, 0.07478205f, -0.12560792f, -0.07975967f, 0.21315475f, 0.17686139f, 0.20546268f, 
    -0.39938974f, 0.13070284f, -0.05012693f, 0.27804613f, 0.00827912f, -0.00219909f, 0.18074287f, 0.24500389f, 
    -0.11630902f, 0.10789870f, -0.02944615f, 0.05519862f, -0.17059343f, 0.03800771f, -0.17628239f, -0.10388025f, 
    0.10539651f, 0.06300379f, -0.04582042f, 0.06067512f, -0.04126029f, -0.10973847f, -0.10145403f, -0.21026157f, 
    -0.11250224f, 0.09253747f, 0.01526208f, -0.11388368f, -0.02684024f, -0.01425066f, -0.02900840f, -0.08227016f, 
    0.00131024f, 0.18843544f, -0.10034668f, -0.12043644f, 0.12113599f, 0.03678471f, -0.02603714f, -0.19426048f, 
    0.10803351f, 0.04388535f, 0.13207291f, 0.04255073f, -0.03180602f, 0.15175791f, 0.02585169f, 0.05328385f, 
    0.07188300f, 0.15796703f, -0.20861842f, -0.12246177f, 0.15179171f, 0.10599877f, 0.06483871f, -0.02095716f, 
    0.03122163f, -0.05561289f, -0.07738085f, -0.23625553f, -0.02884428f, 0.04146566f, 0.03525888f, 0.21606456f, 
    0.11920146f, 0.03563504f, -0.09827470f, -0.06452891f, 0.03658505f, 0.00016476f, -0.13107020f, 0.00108487f, 
    -0.00869525f, -0.12442438f, 0.14212950f, -0.15955305f, 0.00069449f, -0.13654590f, -0.08439439f, 0.01288320f, 
    0.00393127f, -0.07666511f, 0.00779891f, -0.03300402f, 0.37216723f, -0.13226132f, 0.03224223f, -0.15027565f, 
    0.12509754f, -0.06588942f, 0.03432673f, -0.01004135f, 0.08921111f, 0.02444268f, -0.04900757f, 0.06138014f, 
    0.23075250f, -0.06358909f, -0.26125124f, 0.07739277f, 0.07188211f, 0.01478804f, -0.05957600f, 0.03784704f, 
    0.02551099f, 0.04585843f, 0.07419001f, 0.01062619f, -0.36591551f, 0.00194720f, 0.18383573f, -0.49473608f, 
    0.00019396f, -0.03727783f, 0.12486079f, -0.00407490f, 0.12683603f, 0.00876144f, 0.08998249f, 0.02978649f, 
    -0.18760589f, 0.03161168f, 0.18654385f, 0.02297380f, 0.21424650f, 0.04335498f, -0.00577175f, 0.07675256f, 
    -0.01450490f, 0.04311954f, -0.13939260f, 0.05836569f, 0.12402691f, -0.26571074f, -0.22156769f, 0.10303582f, 
    0.13106295f, 0.04024879f, 0.05086466f, 0.06147663f, 0.15393382f, 0.04226802f, 0.02148213f, -0.05452959f, 
    0.41575897f, -0.10803777f, -0.05758442f, 0.21347965f, -0.12910764f, -0.03598754f, -0.07017040f, -0.03915235f, 
    0.05025975f, 0.01331414f, 0.15551232f, 0.00321864f, 0.42162991f, -0.06853963f, -0.18591306f, -0.19693501f, 
    -0.12012361f, -0.02384029f, -0.03889442f, 0.14174616f, 0.02017665f, -0.11386687f, -0.05036587f, -0.05251569f, 
    -0.06491099f, 0.03523702f, -0.01682539f, -0.16449057f, 0.11431868f, 0.21835612f, 0.03710796f, -0.10215729f, 
    -0.05503375f, 0.01082514f, 0.01915881f, -0.02688574f, -0.06134250f, -0.12439376f, -0.03353314f, -0.22020604f, 
    -0.09092908f, 0.08271646f, -0.17798811f, 0.08429796f, 0.05721448f, 0.18670309f, -0.06500100f, 0.03258060f, 
    0.30352986f, -0.08675612f, 0.05234037f, -0.03649112f, 0.10813215f, 0.17302319f, -0.03363642f, 0.10895558f, 
    -0.00908562f, 0.04268994f, -0.08907185f, 0.04097376f, 0.03659563f, 0.07461914f, 0.17066601f, -0.20117214f, 
    0.07468147f, 0.04248174f, 0.09740445f, -0.01109899f, 0.06587046f, 0.05797307f, -0.04528705f, 0.03443875f, 
    -0.01202254f, -0.05386321f, -0.06228053f, 0.16734439f, -0.07824786f, -0.11546397f, -0.08020549f, 0.19027208f, 
    0.03595851f, 0.05823639f, 0.07213233f, -0.06223100f, 0.12323005f, 0.22417170f, 0.16132787f, -0.10424647f, 
    -0.03459907f, -0.01232458f, -0.02306312f, -0.03266944f, 0.00717575f, 0.00000920f, -0.10108340f, 0.08301550f, 
    0.10371763f, -0.05210074f, -0.17221111f, 0.28972590f, 0.00581252f, 0.02665460f, -0.02997876f, -0.07285330f, 
    -0.01391829f, -0.06568084f, -0.14998971f, 0.05766231f, 0.32921371f, -0.18603082f, 0.37338716f, -0.42061931f, 
    0.02333357f, 0.06856802f, 0.05661828f, 0.07030905f, -0.00154630f, 0.01333813f, 0.03568926f, 0.11308545f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.10000388f, -0.01193575f, -0.04725944f, 0.13510369f, 0.04026619f, 0.03191501f, 0.13704436f, 0.03146981f, 
    -0.05324272f, 0.11103203f, 0.05847698f, -0.01068574f, 0.05514050f, 0.02865222f, -0.01723216f, 0.12826692f, 
    -0.07474220f, 0.00814700f, 0.13166976f, 0.09492407f, 0.02323739f, 0.03984029f, 0.19527930f, -0.04250032f, 
    -0.01937792f, -0.05545226f, -0.03224779f, 0.06757895f, 0.02808905f, 0.00786867f, 0.16651191f, -0.00068186f, 
    0.07151610f, -0.00283199f, 0.05865246f, 0.04581275f, -0.02352455f, -0.09526649f, -0.03873533f, 0.00172573f, 
    -0.04146286f, 0.12457939f, -0.07005654f, 0.05505002f, 0.01120729f, -0.08206672f, -0.01974086f, 0.00234255f, 
    0.04436405f, -0.04181619f, 0.09349689f, 0.03075977f, 0.10465013f, -0.05756940f, -0.05418132f, 0.04870581f, 
    0.12407090f, -0.03161906f, 0.04956425f, -0.09099627f, 0.03149853f, 0.15176147f, 0.06133722f, 0.01390408f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.06400113f, -0.06602666f, 0.32452744f, -0.00669297f, 0.21603985f, 0.12644984f, -0.52263045f, -0.23000218f, 
    -0.02625086f, -0.27153632f, -0.06757708f, -0.14583161f, -0.44810706f, 0.11201360f, -0.40943402f, 0.38353989f, 
    -0.10859551f, -0.26902002f, -0.38055566f, 0.32396254f, -0.08324564f, 0.07449961f, -0.08507425f, 0.23590103f, 
    0.10234332f, -0.08264469f, -0.15722677f, -0.50703377f, -0.01328127f, 0.19735754f, -0.72592658f, -0.41171804f, 
    0.05531430f, 0.01572533f, -0.04436802f, -0.04600478f, -0.06915102f, -0.07418135f, -0.09827316f, -0.55195051f, 
    0.04830631f, -0.45066136f, 0.23902984f, -0.09953419f, -0.48601836f, 0.22654477f, 0.34459135f, -0.14951412f, 
    -0.40695840f, 0.20117825f, 0.03220463f, -0.11842206f, -0.20642103f, 0.08373832f, -0.09143098f, 0.29189801f, 
    -0.20350187f, -0.01654566f, 0.27369973f, 0.19394189f, 0.15204169f, 0.13904640f, -0.11305103f, 0.22137909f, 
    -0.08179896f, -0.09590590f, 0.14474259f, -0.10838060f, -0.17048557f, -0.05429285f, -0.18120830f, -0.00855822f, 
    -0.36280072f, 0.36851946f, 0.14891534f, -0.29681838f, -0.19567856f, 0.07641193f, -0.08479211f, -0.64479190f, 
    0.25788215f, -0.10247005f, 0.27847490f, 0.00216677f, 0.00210289f, -0.06007895f, 0.09608074f, 0.35359737f, 
    0.09645308f, -0.01060213f, -0.34523293f, -0.34943217f, -0.52114159f, 0.27813873f, 0.16736075f, -0.18809195f, 
    0.15787646f, 0.20537521f, -0.04012924f, -0.04665422f, 0.00749963f, -0.06581813f, 0.04479992f, -0.13010907f, 
    0.10626633f, -0.19391538f, -0.11190218f, -0.02538557f, 0.30943716f, -0.05470650f, -0.10204215f, 0.27059728f, 
    -0.50037891f, 0.25521001f, 0.28899533f, 0.16827980f, 0.23225199f, -0.06668919f, -0.04268787f, 0.11475645f, 
    0.07237798f, 0.19276725f, -0.19646387f, -0.01801251f, 0.05334143f, -0.27171525f, -0.37087533f, 0.29929784f, 
    0.19252203f, 0.00085707f, -0.26312226f, 0.15588629f, -0.21740046f, -0.01030841f, 0.12458815f, -0.11849824f, 
    -0.27874011f, 0.15485378f, 0.10181667f, 0.03580619f, 0.12243883f, -0.08776321f, 0.39624220f, -0.20554154f, 
    0.21046467f, -0.18796429f, 0.03336323f, -0.46132016f, -0.11392518f, 0.02892649f, -0.05212774f, 0.36068791f, 
    -0.10115439f, -0.10248294f, -0.35877135f, -0.19473651f, -0.02272539f, -0.09255508f, -0.75885838f, -0.21712375f, 
    -0.42989117f, -0.53951818f, 0.08805951f, 0.00700302f, 0.10298161f, 0.05769549f, 0.09131568f, 0.24121962f, 
    -0.42173302f, -0.07748176f, 0.13130434f, 0.01833167f, 0.18813014f, 0.22823147f, -0.64825493f, 0.09193669f, 
    0.23048460f, -0.06308416f, 0.36359131f, -0.51574290f, 0.28198537f, -0.08426723f, 0.03647305f, 0.31599852f, 
    -0.14924894f, 0.34825057f, -0.60119778f, 0.07435176f, -0.57580149f, -0.02475169f, 0.07273316f, 0.17297514f, 
    -0.37536758f, -0.06565571f, -0.15200874f, -0.00370658f, -0.01647412f, -0.75208670f, 0.13824505f, -0.10451869f, 
    0.22702529f, 0.39316344f, -0.78970873f, -0.04781359f, -0.10704818f, 0.09767896f, 0.00309177f, 0.27021751f, 
    -0.38153607f, 0.06861075f, 0.18170439f, -0.20724319f, -0.10509341f, 0.07152438f, -0.02450586f, -0.11130296f, 
    -0.06278387f, -0.06605755f, 0.12129651f, 0.00236770f, -0.37888625f, -0.53460318f, 0.00578536f, 0.14090785f, 
    0.21399377f, -0.00120633f, -0.09099419f, 0.04082855f, -0.87879717f, 0.18529831f, -0.01715261f, -0.02132102f, 
    -0.43411753f, 0.20475365f, -0.03260486f, -0.03471994f, 0.20464289f, 0.05346892f, 0.26078483f, -0.58578157f, 
    0.17710057f, 0.32387713f, -0.28988141f, 0.13238251f, 0.12224410f, 0.15504688f, 0.03399150f, -0.11020681f, 
    -0.20446549f, -0.15239294f, -0.00841038f, 0.22819969f, 0.08208104f, 0.22653003f, -0.08970929f, 0.06142832f, 
    -0.40052682f, 0.09119556f, -0.19120100f, -0.48775372f, 0.27882773f, 0.33511212f, 0.02615535f, -0.18570207f, 
    0.12213444f, -0.17064245f, -0.17218761f, 0.31076929f, -0.04275916f, -0.01122982f, -0.60354125f, 0.38229817f, 
    -0.04138035f, 0.15792115f, -0.36528429f, -0.21026210f, 0.09466976f, 0.06934606f, 0.12146045f, 0.07962444f, 
    -0.05794896f, 0.06929051f, -0.16471508f, 0.32906944f, 0.19161610f, -0.31440064f, -0.20527941f, -0.16775218f, 
    0.08344799f, 0.09514076f, -0.12888119f, 0.07242920f, 0.20216535f, -0.05438514f, 0.11870698f, 0.28304088f, 
    0.05975301f, 0.05841161f, 0.07409820f, 0.10250247f, 0.18550013f, 0.19467461f, 0.18354814f, -0.28051361f, 
    -0.28109068f, 0.10806832f, -0.00649036f, -0.19378662f, 0.04844681f, -0.03793718f, 0.04060425f, -0.13994476f, 
    -0.00518168f, -0.34038892f, 0.16444474f, -0.61361414f, 0.28673354f, 0.02547528f, 0.32399040f, -0.60378343f, 
    0.05590104f, 0.08851738f, 0.24770482f, -0.15902801f, -0.27701426f, 0.10924798f, -0.25935435f, 0.45327151f, 
    0.02228877f, -0.26674077f, -0.14797479f, -0.40670919f, 0.20033261f, 0.11614542f, 0.13068174f, -0.29040891f, 
    -0.14312313f, -0.07403682f, -0.21617225f, 0.32586429f, 0.02228973f, -0.11719857f, 0.10264967f, -0.11448021f, 
    -0.02635458f, -0.00638308f, 0.36290953f, 0.15382648f, -0.15055703f, -0.14240626f, 0.48849875f, -0.28893882f, 
    0.23174404f, 0.20179810f, -0.04220842f, 0.07829075f, 0.10296156f, 0.32343310f, 0.02558965f, 0.22459851f, 
    0.05320524f, -0.45886379f, 0.14898647f, -0.06917120f, 0.08028675f, 0.25970951f, -0.03764969f, 0.23839074f, 
    0.05108662f, -0.06503667f, -0.40023193f, 0.01969104f, -0.04162071f, 0.02218850f, -0.04318731f, -0.28684235f, 
    -0.30482066f, -0.34258679f, -0.01447366f, -0.12159882f, 0.04280952f, -0.08358513f, -0.32756457f, -0.22044078f, 
    0.11075372f, -0.12765299f, -0.63950717f, -0.09945527f, 0.26367667f, -0.10466160f, 0.09787317f, -0.03067242f, 
    -0.05656476f, 0.24969633f, 0.15595992f, -0.08627528f, -0.11293150f, -0.05935373f, -0.01454778f, -0.52873141f, 
    0.28398469f, -0.07842810f, -0.12027843f, -0.24690032f, 0.06609283f, -0.11965588f, -0.18065333f, -0.39444318f, 
    -0.02884791f, 0.04251190f, 0.09174503f, 0.03780000f, 0.29200861f, -0.13543327f, 0.19602232f, -0.32185987f, 
    -0.06059984f, -0.13365172f, 0.04822964f, -0.12110844f, 0.14641541f, 0.15470625f, 0.05694628f, -0.50140399f, 
    -0.02544461f, -0.04147490f, 0.09225223f, 0.02039436f, 0.27773485f, -0.05528548f, -0.34642467f, 0.18785217f, 
    0.22817406f, -0.16393763f, 0.03588928f, -0.22831072f, -0.60680586f, -0.29137015f, 0.04249191f, 0.17284440f, 
    0.22584996f, 0.19327067f, 0.11307593f, 0.16468556f, -0.46524712f, 0.35440770f, 0.30396378f, -0.36758164f, 
    -0.40954497f, -0.02307598f, -0.11716553f, -0.15911613f, 0.08800643f, -0.10495802f, 0.13582970f, 0.30098042f, 
    0.25816193f, -0.44552618f, -0.08125877f, -0.03723556f, 0.44174320f, -0.03292831f, 0.34744355f, -0.00778757f, 
    0.00388735f, 0.00419940f, -0.15262221f, -0.62083972f, -0.04784124f, 0.07676993f, -0.17631128f, 0.24229692f, 
    -0.10429616f, 0.03046435f, 0.27643642f, -0.32765931f, 0.40566361f, -0.12581728f, -0.27000546f, 0.27991316f, 
    -0.46503097f, -0.23979448f, -0.09056985f, 0.08699474f, -0.02376299f, 0.31656829f, -0.02711333f, -0.24829973f, 
    -0.25849053f, 0.30428249f, -0.42452082f, -0.11138126f, -0.29492468f, -0.15650499f, 0.05838259f, 0.00237910f, 
    0.18486482f, -0.29145032f, -0.30165410f, -0.56253451f, -0.02266304f, 0.26317140f, 0.04272731f, -0.47982863f, 
    -0.51795554f, 0.26448587f, 0.21232186f, -0.20594227f, 0.23686378f, -0.19794932f, -0.36049849f, -0.27253190f, 
    0.14499876f, 0.04283614f, 0.32013515f, 0.13958301f, -0.40113264f, 0.28064740f, 0.25658336f, 0.15188818f, 
    -0.44319066f, -0.39359489f, -0.05495697f, 0.41671103f, -0.32461038f, 0.09078628f, 0.17443922f, -0.49906793f, 
    0.04650006f, 0.30279034f, -0.12361679f, 0.22711505f, -0.01576522f, 0.06637896f, -0.22680603f, -0.05614712f, 
    -0.04477908f, 0.09906362f, 0.11184925f, -0.11926986f, -0.35598293f, -0.15051615f, -0.21567707f, 0.27216637f, 
    -0.09177629f, 0.27850428f, -0.02526559f, 0.04506451f, 0.11304215f, 0.14077945f, 0.08719146f, 0.37624386f, 
    -0.01546577f, -0.21429725f, -0.42929161f, 0.03206769f, -0.18433514f, -0.12386864f, -0.44581622f, -0.34697258f, 
    -0.40363601f, 0.24321936f, -0.17958830f, 0.08200603f, 0.07273284f, -0.46965808f, 0.08545963f, -0.23693715f, 
    -0.26778838f, 0.06926620f, -0.21897833f, 0.24223892f, -0.26098272f, -0.40150380f, 0.06488106f, -0.03899410f, 
    0.07731257f, -0.00878131f, -0.20739490f, -0.37545380f, -0.21326493f, -0.13854280f, 0.27739316f, -0.15330720f, 
    0.19923042f, -0.10745466f, 0.22842009f, 0.34336802f, 0.02067924f, -0.05846516f, 0.39573616f, 0.30975902f, 
    -0.07900700f, -0.62029654f, -0.06106135f, -0.05731540f, 0.04425871f, 0.09150837f, 0.31302688f, -0.06429799f, 
    -0.01298722f, 0.11006249f, -0.34727085f, -0.03967836f, 0.25596061f, -0.09990202f, 0.25953579f, 0.25217104f, 
    -0.42866486f, -0.02987812f, -0.07042503f, 0.01826980f, 0.14593586f, -0.40530473f, 0.01053050f, -0.19377415f, 
    0.32674289f, -0.24160591f, 0.11123530f, 0.02492036f, -0.69001800f, -0.30133274f, -0.06338150f, 0.14160591f, 
    0.19483933f, -0.30260468f, -0.07645826f, 0.41817230f, -0.16634379f, 0.18055372f, 0.01741464f, 0.09064450f, 
    -0.12885350f, -0.56363082f, -0.02912426f, -0.21787380f, -0.18365403f, -0.26070315f, 0.27703580f, 0.28705147f, 
    0.16867866f, -0.09476008f, -0.09383502f, 0.44462723f, 0.12438109f, -0.09911429f, 0.28717601f, 0.07336468f, 
    -0.08981566f, -0.06909864f, 0.06077703f, -0.14728631f, 0.16989039f, 0.03534261f, -0.12587549f, 0.12747349f, 
    -0.38514486f, -0.19084758f, 0.38008061f, 0.24082354f, 0.02616348f, -0.04679377f, 0.45171404f, -0.50470430f, 
    0.10015079f, -0.05552838f, 0.14596966f, -0.18294309f, -0.04179384f, 0.06522779f, -0.11788577f, 0.22967763f, 
    0.02414769f, -0.01851626f, 0.02643174f, 0.01681976f, -0.67524242f, -0.55384290f, 0.03780894f, -0.23459089f, 
    -0.43376926f, 0.12726542f, -0.65203798f, 0.10182843f, 0.06195657f, -0.23597659f, -0.16388267f, 0.29537785f, 
    0.26511836f, -0.50326210f, -0.14443669f, -0.32132301f, 0.27033457f, -0.57104737f, -0.02859127f, 0.00921178f, 
    0.35006785f, 0.11013594f, -0.08694975f, -0.45372847f, 0.09973016f, 0.21613032f, -0.26830253f, 0.05147870f, 
    -0.04876500f, -0.09442426f, 0.32683271f, -0.01165954f, -0.10231470f, -0.25435883f, -0.31131729f, -0.44312063f, 
    -0.03939391f, -0.02605484f, 0.00156890f, -0.16804618f, 0.09166614f, -0.05572475f, -0.42080569f, -0.26631910f, 
    -0.11785534f, 0.01699220f, -0.27158967f, -0.39655435f, -0.05334793f, -0.11611045f, -0.62725848f, -0.59785479f, 
    -0.04425264f, -0.03529451f, 0.00491556f, 0.37768653f, 0.17664890f, -0.31150812f, -0.10111167f, 0.12311165f, 
    0.28054947f, -0.55126220f, -0.02993322f, -0.10234250f, -0.05335674f, -0.14657122f, -0.01718304f, 0.50642520f, 
    0.26815918f, 0.29357943f, 0.13314472f, 0.05558559f, 0.12440760f, -0.46940392f, 0.21001031f, -0.18895531f, 
    0.26113909f, -0.19651715f, 0.34411523f, 0.05397992f, 0.14423688f, 0.16427746f, -0.03125967f, -0.40141103f, 
    0.32472393f, 0.25550246f, -0.26097223f, 0.42672080f, 0.12835903f, -0.08450495f, 0.12609844f, 0.07917132f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.03657120f, 0.11763863f, -0.14641260f, -0.01715672f, 0.08341573f, -0.07559974f, 0.16496700f, -0.22403345f, 
    0.04330799f, 0.10422949f, -0.00634121f, 0.05053653f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
