#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.03625072f, -0.40781170f, -0.30514365f, -0.18879505f, -0.12081411f, -0.57124382f, -0.54054922f, -0.35177752f, 
    -0.55813652f, -0.40613994f, 0.70726204f, -0.03532247f, 0.70543891f, 0.21903650f, 0.19233595f, -0.00196242f, 
    -0.45380366f, -0.34993300f, -0.10224077f, -0.38170269f, -0.13573486f, 0.22209504f, 0.01241570f, -0.26408306f, 
    0.13666962f, 0.29074758f, -0.38236466f, 0.02774973f, 0.49270749f, -0.07743689f, -0.32886219f, 0.20947489f, 
    -0.42421222f, -0.35446742f, -0.25021428f, 0.30027181f, 0.07615216f, -0.05265538f, 0.10111641f, -0.08954555f, 
    -0.34230959f, -0.09021359f, 0.23417872f, 0.13070300f, -0.23105523f, 0.08647662f, -0.01446905f, 0.23766111f, 
    0.29168335f, 0.23872057f, 0.47726309f, 0.16153227f, -0.53575277f, -0.44815239f, -0.27875257f, 0.29303756f, 
    0.03001851f, 0.15035380f, 0.10137316f, -0.23466478f, 0.50127751f, -0.20282978f, 0.17417835f, 0.10609552f, 
    -0.28885260f, -0.26511613f, -0.15145448f, -0.00712730f, 0.05564638f, -0.24934807f, 0.06029106f, 0.15744016f, 
    0.12677276f, 0.39563155f, 0.23275888f, -0.20971198f, 0.34358358f, 0.46980336f, 0.09318502f, 0.03386536f, 
    -0.22801168f, 0.25742346f, -0.03933756f, -0.03374713f, 0.32528007f, 0.33667436f, -0.24737890f, 0.25204867f, 
    -0.18142867f, -0.26139799f, -0.01436255f, -0.11764333f, -0.19304544f, 0.12704894f, 0.16300926f, -0.08272506f, 
    -0.09085653f, -0.30120635f, -0.00553727f, 0.51654536f, -0.32999024f, -0.27562159f, 0.48306364f, 0.41706023f, 
    -0.42219177f, -0.60750198f, -0.51174021f, -0.26377270f, 0.22291996f, 0.30108675f, -0.09907444f, -0.03843249f, 
    -0.57220513f, 0.13467786f, 0.48102212f, 0.22089864f, 0.00209303f, -0.26326972f, 0.06330786f, -0.46946427f, 
    0.09880070f, -0.23747922f, 0.03955892f, -0.17963289f, 0.17052473f, 0.43650872f, -0.50845182f, -0.32114032f, 
    0.10538427f, 0.55519813f, -0.14506267f, -0.33490685f, -0.37600884f, -0.17654388f, -0.38348442f, -0.06733746f, 
    -0.09079611f, 0.45744324f, -0.33879632f, 0.05581235f, -0.01997031f, 0.16641477f, 0.10301404f, 0.03983231f, 
    -0.07993315f, 0.31814733f, -0.33551466f, -0.17867634f, 0.14867565f, 0.34477538f, 0.28065142f, 0.00508623f, 
    0.08891415f, 0.15851532f, -0.09506881f, 0.49546808f, 0.04364637f, 0.11972109f, 0.49481153f, 0.05112755f, 
    0.01513805f, 0.35451815f, -0.27742669f, -0.34763196f, 0.13129692f, -0.22563604f, 0.29239821f, -0.09587348f, 
    -0.01905332f, -0.21999779f, 0.23871680f, 0.02897741f, 0.09539206f, -0.11574505f, 0.26999754f, -0.44139925f, 
    -0.45676231f, 0.09189322f, 0.64072591f, 0.39067551f, -0.55461287f, -0.69789225f, -0.15058811f, 0.34079820f, 
    0.30089334f, 0.23467232f, 0.13688542f, 0.26785475f, -0.00137974f, -0.20989868f, -0.26350793f, -0.09231420f, 
    0.26059696f, -0.11351194f, -0.26625794f, 0.02800655f, 0.02489631f, 0.18941650f, 0.22754897f, 0.26401487f, 
    0.96467763f, 0.01713422f, -0.46941081f, -0.82181305f, -0.90181309f, 0.17171630f, 0.22596560f, 0.26767153f, 
    0.05745598f, 0.23307109f, 0.16709326f, -0.01544620f, -0.04873167f, -0.20977610f, 0.25264704f, -0.00713985f, 
    0.04358688f, -0.18542962f, -0.07214392f, 0.25197580f, -0.18693680f, -0.13155185f, -0.07346509f, 0.23314339f, 
    0.14327767f, -0.72753441f, 0.80096334f, 0.59155637f, -0.55820173f, -0.10181664f, -0.63466382f, 0.36422175f, 
    0.27482435f, 0.06287824f, 0.06702431f, -0.32384476f, -0.03976435f, 0.09812064f, -0.19400617f, -0.00858361f, 
    0.23479968f, 0.02531870f, -0.09483255f, -0.13504602f, -0.17003490f, -0.19194221f, -0.12738559f, -0.37497389f, 
    -0.15888353f, -0.40127182f, -0.04960728f, 0.20596406f, -0.09729761f, 0.44465709f, 0.08691777f, 0.49387518f, 
    -0.01910220f, -0.06327851f, -0.05661624f, 0.26683378f, 0.42143819f, -0.07920940f, -0.22027187f, -0.28833589f, 
    0.40658095f, -0.20864475f, -0.24607320f, 0.07602037f, 0.06011336f, -0.25035274f, 0.28324014f, 0.12366066f, 
    0.07490563f, -0.09806813f, -0.17783901f, -0.17906313f, -0.13662218f, -0.21111923f, -0.40863225f, -0.55823267f, 
    0.13355611f, -0.10809720f, 0.20361663f, 0.32364416f, 0.33193496f, -0.55025798f, -0.34141898f, -0.23080678f, 
    -0.07752351f, 0.08680224f, 0.21986093f, 0.03461114f, 0.00149782f, -0.07630394f, 0.12274400f, -0.05924841f, 
    -0.36000785f, -0.20129700f, -0.35760224f, -0.60159063f, -0.77233124f, -0.07698824f, -0.37693784f, -0.01085583f, 
    0.14033957f, -0.11789915f, -0.18324918f, -0.53382874f, -0.37016892f, -0.07357855f, -0.26319641f, -0.46991980f, 
    -0.15222792f, -0.33127779f, -0.24479546f, -0.27133775f, -0.50232548f, -0.10872631f, -0.12064759f, -0.22267257f, 
    0.10260147f, -0.07820481f, -0.10581395f, 0.13973406f, 0.08792745f, -0.76792097f, -0.66567481f, -0.61788493f, 
    0.24351726f, 0.09702166f, 0.89038676f, 0.01051446f, -0.21382199f, -0.02880451f, -0.24489310f, -0.22417124f, 
    -0.28722849f, -0.25398612f, 0.32478783f, -0.10063232f, 0.06065443f, 0.09477503f, 0.11143041f, -0.38613930f, 
    -0.41664752f, 0.04708743f, -0.06566793f, -0.03394929f, 0.28010798f, -0.03381644f, -0.03289165f, -0.31550694f, 
    -0.82140630f, -0.27191892f, -0.60832155f, 0.49257705f, 0.39305413f, 0.33887446f, -0.37167439f, -0.42088819f, 
    -0.24227381f, -0.25913239f, 0.08991208f, 0.06779571f, 0.13573319f, -0.28560284f, 0.38584480f, 0.23217922f, 
    -0.58729267f, 0.09501578f, -0.02231168f, -0.24254629f, 0.22316866f, -0.00973028f, -0.12740931f, 0.49471074f, 
    -1.04482222f, -0.21486224f, 0.26787341f, 0.26436284f, 0.10844787f, -0.06460636f, 0.01372448f, 0.15037377f, 
    0.45019233f, -0.01233223f, -0.13429807f, -0.34328881f, -0.14513414f, 0.39289963f, -0.14471692f, -0.29487219f, 
    -0.19157980f, 0.18831792f, -0.14948970f, -0.36337176f, -0.09126531f, -0.25904372f, 0.14573434f, 0.09185164f, 
    0.20406668f, 0.17653228f, 0.32839498f, -0.17964911f, 0.14587966f, 0.30945140f, -0.37027735f, -0.01225874f, 
    0.57214081f, 0.26208371f, 0.27075431f, -0.29591051f, -0.19787547f, 0.18897824f, 0.20169236f, -0.17967585f, 
    0.06977404f, -0.16441049f, 0.10443439f, -0.17218839f, -0.04390513f, 0.12803753f, -0.32057878f, -0.24919602f, 
    0.05646401f, 0.41685531f, 0.60579765f, 0.29470423f, -0.08244928f, -0.55272412f, -0.33190697f, -0.60078955f, 
    -0.04065575f, 0.44011351f, -0.15559949f, 0.00263544f, -0.48045489f, -0.13755088f, 0.39126733f, -0.27826864f, 
    -0.08102465f, -0.00478832f, 0.31408790f, 0.35905519f, -0.13858052f, 0.03614946f, -0.22119616f, -0.10544670f, 
    -0.11759032f, 0.12178243f, -0.52893323f, -0.09678885f, 0.13913532f, -0.67399687f, -0.66438729f, 0.29582682f, 
    0.26593652f, 0.06216954f, 0.35593760f, 0.34964964f, -0.30155587f, -0.18082492f, 0.20496975f, -0.09912101f, 
    0.19637452f, 0.02526782f, -0.04610858f, -0.14495105f, 0.03357735f, 0.21760839f, -0.05106138f, 0.02856781f, 
    0.23419563f, 0.15022558f, 0.21107699f, -0.61433071f, -0.84258735f, 0.22131059f, -0.01190178f, 0.49263224f, 
    0.20702140f, -0.21430451f, -0.32299721f, -0.50321686f, -0.19645223f, -0.29517239f, 0.07808249f, 0.08326513f, 
    -0.41156971f, -0.19081552f, -0.00952122f, 0.12870237f, 0.16362645f, 0.30516592f, 0.39889854f, 0.09573541f, 
    -0.02713148f, -0.16685358f, 0.08702734f, -0.24933475f, -0.68239975f, -0.26395884f, 0.18335195f, 0.35827050f, 
    0.18355994f, -0.70146847f, -0.75716186f, -0.27214041f, 0.31360072f, 0.22016375f, 0.13077065f, 0.08693951f, 
    -0.02523648f, 0.31335878f, -0.06303507f, -0.19796285f, 0.25456765f, 0.11427955f, -0.32983223f, -0.55859810f, 
    0.18357535f, 0.36189461f, -0.20205700f, -0.32930797f, -0.45603117f, 0.37464684f, 0.53485739f, 0.52974248f, 
    0.43917939f, 0.30866265f, -0.43885776f, -0.42176369f, -0.12335541f, -0.40723988f, -0.49857092f, -0.09657688f, 
    -0.21454367f, 0.24356373f, -0.12732607f, 0.19225614f, -0.14847454f, 0.28890046f, -0.18902136f, -0.10791908f, 
    0.26060259f, -0.13306423f, 0.07887830f, -0.08523442f, 0.13201371f, -0.34486315f, 0.45199096f, 0.39401028f, 
    0.37400258f, -0.19471192f, -0.14561141f, -0.05779346f, -0.02806537f, 0.28408188f, -0.23009843f, 0.09648560f, 
    0.01516950f, 0.19882241f, -0.11027223f, -0.25600919f, -0.10048414f, -0.12206464f, 0.19313818f, 0.08099316f, 
    -0.10764039f, 0.08673934f, -0.06608221f, 0.18123285f, -0.31203574f, -0.31313935f, 0.25579906f, 0.52005792f, 
    0.08065119f, -0.32339922f, 0.05643455f, 0.23470196f, 0.07224689f, 0.25727877f, -0.28182933f, -0.57421225f, 
    -0.67167914f, -0.17728585f, -0.03280419f, -0.23626536f, -0.05872236f, -0.25570801f, -0.32795033f, -0.16016415f, 
    -0.07518966f, -0.07049014f, -0.21326257f, -0.07688845f, 0.00769384f, 0.04977578f, -0.21691570f, -0.33716702f, 
    0.79059899f, -0.92150217f, -0.11603208f, 0.51023728f, 0.20522662f, 0.09133013f, 0.02710644f, 0.38089901f, 
    -0.21373305f, -0.04030124f, -0.17118956f, 0.13503620f, 0.00152557f, -0.37769189f, 0.31586027f, 0.06375711f, 
    -0.04467752f, -0.07843040f, 0.00501346f, -0.08366928f, 0.14787546f, -0.09164188f, 0.03688078f, -0.12108465f, 
    0.06610256f, -1.24862731f, -0.20279284f, -0.46192989f, -0.61927336f, 0.09690551f, 0.01476303f, 0.05590302f, 
    0.57186812f, 0.71435666f, 0.67736000f, 0.15323696f, 0.00773031f, 0.08049896f, -0.12621215f, 0.12299200f, 
    0.06277383f, 0.01700743f, -0.09090392f, -0.04943877f, 0.11068650f, 0.03708231f, -0.02547245f, 0.07349789f, 
    0.04791936f, -0.16023129f, 0.36590677f, 0.01241888f, 0.04947137f, 0.06566402f, -0.29127693f, -0.23081562f, 
    0.51485467f, -0.11345862f, 0.10337722f, 0.00045447f, -0.08725683f, -0.21517028f, 0.32790595f, -0.04606998f, 
    -0.13157971f, 0.07761264f, 0.19071221f, -0.18677329f, -0.15464313f, 0.14982530f, 0.38055581f, -0.00352243f, 
    -0.07392261f, 0.16224521f, -0.55376780f, -0.00517680f, 0.64301026f, -0.06212741f, -0.20441218f, 0.09920524f, 
    -0.39891058f, 0.09425244f, 0.37568623f, -0.17002532f, -0.04814111f, -0.27924609f, -0.08620106f, 0.08733739f, 
    0.28577977f, -0.30456063f, 0.27840433f, 0.24570999f, -0.35838106f, 0.03144073f, -0.50732797f, -0.22633275f, 
    0.32213637f, 0.36510023f, 0.18562596f, -0.04249560f, -0.72310537f, -0.14227335f, -0.37944421f, -0.48343265f, 
    -0.27870125f, 0.04484070f, 0.36872277f, -0.36277202f, -0.34096286f, 0.05102905f, -0.20928985f, -0.02964166f, 
    -0.28475279f, -0.26698995f, 0.20080349f, -0.01398088f, -0.02594046f, -0.18780845f, -0.12380429f, -0.22137681f, 
    0.09163257f, 0.21959957f, -0.10100802f, -0.12590429f, -0.24754050f, 0.04603507f, 0.32423332f, 0.46563005f, 
    0.09219056f, -0.29662296f, 0.21506755f, -0.04791915f, 0.16842866f, -0.38884926f, 0.11614828f, -0.24553415f, 
    -0.00741993f, 0.49495658f, -0.25049475f, -0.08532637f, 0.02331695f, 0.20279166f, -0.29499358f, 0.20714007f, 
    -0.15547350f, -0.31992567f, 0.05572210f, -0.16352914f, 0.07435578f, 0.25521907f, -0.46567932f, -0.19487210f, 
    0.41846961f, -0.61013675f, -0.69397211f, 0.57599133f, 0.03561646f, -0.20551072f, 0.12336005f, 0.24491034f, 
    0.21854092f, 0.11792352f, 0.27901441f, 0.27303487f, 0.24037540f, -0.16948459f, -0.09625307f, -0.19664478f, 
    -0.00905342f, -0.17380527f, -0.06377262f, 0.28994486f, 0.24345452f, -0.02014899f, -0.02247380f, -0.50812328f, 
    -0.51424503f, -0.38699421f, -0.41132322f, -0.33046609f, 0.34582961f, 0.20312834f, -0.48201406f, -0.27252457f, 
    0.32820559f, 0.03365695f, -0.03162511f, 0.17008027f, -0.07042067f, 0.03190776f, -0.18442269f, 0.16336133f, 
    -0.26509568f, -0.25178349f, 0.00815863f, -0.42734161f, -0.22605792f, -0.35188851f, -0.28101891f, -0.27638254f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22012801f, 0.11347041f, 0.06124309f, 0.08048940f, 0.24481837f, 0.24275452f, -0.17321105f, 0.22251596f, 
    0.42813349f, 0.00258431f, 0.10297915f, 0.02142851f, -0.14241263f, -0.03695801f, 0.19090454f, 0.41444680f, 
    -0.03657571f, 0.26476189f, 0.18557355f, 0.13764463f, 0.24317607f, 0.05673173f, 0.15865608f, -0.11202890f, 
    0.34418657f, 0.21044844f, 0.21936931f, 0.17134923f, 0.02598121f, 0.10595664f, 0.11428860f, -0.09980894f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04416083f, 0.06180861f, -0.07518026f, 0.00715899f, 0.19950099f, 0.17038712f, 0.01017815f, -0.04113007f, 
    0.01015442f, 0.08945017f, 0.07079407f, -0.00220847f, -0.28848478f, -0.01268636f, -0.14870831f, 0.10304797f, 
    -0.00630815f, -0.05243848f, 0.08990365f, -0.08504584f, 0.08552881f, 0.05425376f, 0.09135180f, 0.13900697f, 
    -0.20115647f, 0.02178840f, -0.19500561f, 0.30370289f, -0.10677138f, -0.01254554f, -0.12167420f, -0.18644567f, 
    0.15197012f, 0.02881081f, 0.02768652f, 0.02179685f, 0.13358608f, -0.02332203f, 0.11032151f, -0.02773101f, 
    -0.20964521f, -0.14461419f, 0.02174783f, -0.13057025f, 0.05512320f, -0.15229401f, 0.15805630f, -0.01391821f, 
    0.03175214f, -0.02109720f, 0.13107665f, -0.07572159f, -0.01581666f, 0.06387553f, -0.04009622f, -0.01461916f, 
    0.02393895f, -0.07075865f, -0.05464746f, -0.04692975f, -0.07937543f, 0.22079089f, -0.15631767f, 0.14589038f, 
    0.05758367f, 0.20199622f, -0.00743747f, 0.17527218f, 0.04171086f, -0.02875558f, 0.11463018f, -0.02278395f, 
    -0.22958644f, 0.02919919f, -0.17098261f, -0.15057138f, -0.13919309f, -0.14451972f, -0.18631633f, -0.13518505f, 
    -0.24590974f, -0.02955550f, 0.10326429f, 0.07572735f, -0.01557824f, 0.25475651f, -0.01171863f, -0.40834391f, 
    -0.09616937f, 0.06896055f, -0.09737355f, 0.02108090f, 0.03414459f, -0.04898157f, 0.04613091f, -0.00796663f, 
    -0.04780544f, 0.23139991f, -0.09621832f, 0.53142333f, 0.02760062f, -0.02251361f, -0.14427142f, -0.05524953f, 
    0.08334136f, 0.05533079f, -0.05558222f, 0.09027709f, 0.52635515f, -0.04715793f, 0.35184959f, -0.08127296f, 
    -0.17391397f, -0.02584569f, -0.06354731f, 0.04331531f, -0.01949310f, 0.13725278f, -0.01644148f, 0.13093834f, 
    -0.07811651f, 0.00346939f, 0.00630233f, -0.00556683f, -0.07299302f, -0.00822861f, 0.02053344f, -0.21490847f, 
    -0.06232470f, -0.00292251f, 0.03045521f, 0.12933163f, 0.21085814f, 0.07848786f, 0.10241125f, 0.20112945f, 
    0.13269319f, 0.16763856f, 0.01773511f, -0.02347881f, 0.03047295f, 0.08411432f, -0.00995908f, 0.07145096f, 
    0.21230970f, 0.09793682f, -0.26365313f, -0.18737800f, 0.03031335f, 0.10386626f, 0.05086546f, 0.00543196f, 
    -0.13253900f, -0.07894444f, -0.01132795f, -0.14803346f, 0.03568846f, 0.20682721f, -0.13640635f, -0.07993900f, 
    0.10879448f, 0.06167847f, 0.08990927f, -0.12513690f, -0.15060481f, 0.10897909f, -0.05167459f, 0.13495323f, 
    0.15775563f, -0.03623040f, 0.05171811f, 0.24072514f, 0.10421621f, 0.17942390f, 0.02677898f, -0.01363324f, 
    -0.07229540f, 0.03957587f, -0.00456514f, 0.09151394f, -0.33549583f, 0.52106595f, -0.15180004f, -0.02973768f, 
    0.06734623f, -0.01866300f, 0.01941107f, 0.03706276f, 0.09327055f, 0.20353417f, 0.06135464f, 0.00631015f, 
    -0.07816921f, -0.04204746f, -0.23867974f, -0.13979200f, -0.04927831f, -0.06103873f, 0.05895733f, -0.02427978f, 
    0.05579030f, 0.05444380f, 0.04308944f, 0.00443568f, -0.35439089f, 0.08220989f, 0.18680866f, -0.12389228f, 
    -0.07535741f, 0.09278293f, -0.15565406f, 0.02435239f, 0.05696660f, 0.01052091f, 0.04683660f, -0.05481274f, 
    0.33977979f, -0.09980255f, 0.28285807f, 0.41646656f, 0.04294368f, 0.09266475f, 0.05321514f, 0.06285661f, 
    -0.04875926f, 0.03499477f, 0.07999948f, 0.12892872f, 0.01691970f, 0.25695935f, -0.19664538f, 0.07372656f, 
    0.11374982f, 0.08791748f, 0.07198458f, -0.00468069f, -0.10146102f, -0.03722408f, -0.00867885f, 0.00069786f, 
    0.13964413f, 0.14269620f, -0.03135569f, -0.20076245f, 0.04373253f, 0.01892772f, -0.02364146f, 0.13694718f, 
    -0.03412304f, -0.05654988f, -0.07665700f, 0.04988632f, -0.71125156f, -0.20743491f, 0.26405886f, 0.23326321f, 
    -0.05878956f, 0.01081944f, -0.03750393f, -0.14072099f, 0.12436762f, 0.03413405f, 0.00092715f, -0.04267049f, 
    -0.27565777f, 0.01337261f, 0.10247885f, -0.00077785f, -0.14719540f, -0.10976617f, -0.08578150f, -0.09796636f, 
    -0.06300300f, -0.04396524f, 0.02051989f, -0.02129204f, -0.04598432f, 0.03929435f, 0.08638345f, 0.26121798f, 
    0.01311811f, -0.05635408f, -0.04944228f, -0.05741213f, -0.01333451f, -0.05256530f, -0.15366180f, 0.00004278f, 
    -0.53006530f, 0.64379889f, 0.00599931f, 0.14296570f, -0.11513514f, 0.05757334f, -0.11767699f, 0.02745694f, 
    0.13061796f, 0.02655898f, -0.00448467f, -0.10025074f, 0.34269568f, 0.08311225f, -0.05024621f, -0.02381691f, 
    0.09835621f, 0.03110879f, 0.09231435f, 0.10101759f, -0.09222485f, 0.03185720f, -0.00338616f, 0.01866210f, 
    -0.02134304f, -0.08099954f, 0.20094633f, 0.12816004f, -0.17090878f, 0.05678448f, 0.08307721f, -0.03825370f, 
    0.13073666f, 0.00454621f, 0.00592147f, 0.08710352f, 0.00437494f, -0.11227117f, 0.03110535f, 0.05729834f, 
    -0.19449371f, 0.08907489f, -0.06895176f, 0.03319936f, -0.15847361f, -0.04980428f, -0.07319085f, 0.13462184f, 
    0.15636878f, -0.08523126f, 0.08152030f, 0.06988646f, 0.09598242f, 0.05810770f, 0.06284588f, 0.03428101f, 
    -0.12333877f, 0.00639579f, -0.02434465f, 0.05829547f, -0.07788535f, 0.03844097f, 0.19748560f, 0.06488423f, 
    -0.11079927f, -0.05640586f, -0.20579679f, -0.10500178f, -0.11218703f, -0.03877599f, 0.04295424f, 0.01929986f, 
    0.33829522f, -0.05056226f, 0.17980778f, 0.25935042f, 0.03237799f, -0.00000612f, 0.11801129f, 0.03039218f, 
    -0.05964552f, 0.07764899f, 0.01551188f, 0.06606933f, 0.00370148f, 0.09633864f, 0.00520571f, 0.15060179f, 
    0.18948750f, 0.03343235f, -0.00819849f, 0.00824795f, -0.01979605f, 0.08708264f, -0.06328991f, 0.07602654f, 
    0.11453541f, 0.10165305f, 0.19616553f, 0.01580854f, 0.03098462f, -0.03762425f, -0.02184856f, 0.05462372f, 
    0.08185963f, -0.04008278f, -0.03607078f, 0.04426486f, -0.01963711f, -0.12430509f, -0.07515670f, -0.01371506f, 
    0.17350906f, 0.10107762f, 0.13427560f, 0.17338032f, -0.00357095f, 0.04830228f, -0.17556857f, -0.11725152f, 
    0.11674390f, 0.04558945f, -0.00376808f, -0.09032441f, 0.01885869f, 0.07934900f, -0.08432284f, 0.07168800f, 
    0.14675741f, 0.06848446f, -0.03112653f, -0.03866592f, -0.12824544f, -0.27216956f, 0.04504190f, 0.12875703f, 
    0.10089567f, 0.07404135f, 0.00899442f, 0.01729770f, 0.03404630f, 0.03261184f, -0.10519028f, 0.05038608f, 
    -0.03138315f, -0.06231454f, -0.19274010f, 0.03567585f, -0.09066588f, -0.01594850f, 0.04557789f, 0.05373655f, 
    -0.03518527f, -0.07433442f, -0.06209989f, 0.09046786f, 0.06783948f, -0.12621351f, 0.17335586f, -0.10488417f, 
    0.01937205f, 0.11640908f, 0.01994977f, 0.12406994f, -0.12261321f, -0.05021473f, -0.01508144f, 0.02823434f, 
    -0.10240010f, -0.08013989f, -0.13523935f, 0.08988178f, 0.02402978f, -0.01884752f, -0.04825826f, -0.00622555f, 
    0.07529012f, -0.00896624f, 0.05102725f, 0.06879104f, -0.20665456f, -0.08016431f, -0.02942128f, 0.08212177f, 
    -0.06261053f, 0.07107618f, -0.02650286f, 0.09069714f, -0.11092127f, 0.03560462f, -0.00757082f, -0.08155131f, 
    0.16921453f, 0.34126642f, 0.13467766f, -0.17882064f, 0.02123784f, -0.04910198f, -0.01190891f, 0.04264983f, 
    0.05125063f, 0.06534987f, -0.00091201f, 0.03164744f, -0.07853785f, 0.12112586f, -0.19856395f, -0.14825182f, 
    -0.03755127f, -0.08847376f, 0.03771447f, -0.11333600f, 0.10369880f, 0.07768676f, 0.11910165f, 0.13146159f, 
    -0.13307449f, -0.00069350f, -0.16011874f, 0.12243507f, 0.09196872f, -0.05457893f, 0.06429459f, 0.00106748f, 
    -0.00963168f, -0.00173641f, -0.06521909f, 0.12948410f, -0.00498211f, 0.07945190f, -0.05468696f, -0.05807481f, 
    -0.10315534f, -0.08790524f, 0.06629854f, 0.11324789f, 0.07142344f, 0.06069759f, -0.00559084f, 0.11515199f, 
    -0.21503352f, -0.15317892f, 0.04385019f, 0.10524492f, -0.11759964f, 0.07305752f, 0.06730222f, 0.04749275f, 
    -0.07057601f, 0.01717980f, 0.06671483f, 0.16364072f, -0.19954735f, -0.05075598f, -0.12534712f, 0.29643711f, 
    -0.02751711f, 0.00272840f, -0.07231979f, -0.07612549f, -0.07290777f, -0.02981314f, 0.01073121f, -0.03294883f, 
    -0.13777703f, 0.16079882f, -0.02056251f, 0.03371962f, -0.08279049f, -0.01665707f, -0.00331369f, 0.05006062f, 
    -0.02227230f, 0.02306493f, 0.02507928f, -0.01834153f, -0.04501675f, 0.03070302f, 0.21712990f, 0.12406714f, 
    -0.04648121f, -0.02771771f, -0.05876853f, 0.18974376f, 0.00696030f, 0.08284040f, -0.10509115f, 0.07018839f, 
    0.01198957f, -0.02993590f, -0.21698895f, 0.13464755f, -0.07739686f, -0.06244568f, 0.10003225f, -0.02111496f, 
    0.02085642f, 0.03888012f, 0.20722570f, 0.06646325f, 0.34642175f, -0.01733384f, -0.37167719f, 0.31194547f, 
    0.03361110f, -0.00614326f, 0.21913940f, 0.07105553f, -0.01267655f, -0.00571239f, -0.06386728f, 0.00679465f, 
    -0.04198325f, 0.10577843f, -0.00078899f, 0.03114672f, 0.12530103f, -0.12466717f, 0.00146814f, -0.01552648f, 
    -0.00573995f, 0.02167357f, -0.03203662f, -0.04391574f, -0.19578139f, -0.20061094f, 0.28095132f, 0.18705541f, 
    -0.12273968f, 0.05523347f, 0.09397383f, 0.00175790f, -0.02975500f, 0.09519323f, 0.00922220f, 0.04291154f, 
    -0.06026936f, -0.00880083f, 0.00208455f, 0.11444801f, 0.10478221f, 0.07843183f, -0.02903935f, -0.10928458f, 
    0.04438394f, 0.08545410f, 0.22620167f, 0.16958785f, 0.17207438f, -0.03012003f, 0.06490488f, -0.02435891f, 
    0.11240681f, 0.31692752f, 0.19380315f, 0.10976974f, 0.01952730f, -0.09616662f, -0.04228973f, -0.06387565f, 
    0.09863273f, -0.09772351f, -0.13728777f, -0.03785240f, 0.02570242f, -0.01533825f, 0.07720235f, 0.05742319f, 
    0.06822962f, 0.00686943f, -0.01947824f, 0.00326568f, -0.13961497f, -0.09423869f, -0.04240735f, -0.02342752f, 
    0.14123257f, 0.16207196f, 0.14273427f, 0.08360794f, 0.01793180f, 0.00675562f, -0.07118087f, -0.02760031f, 
    -0.20354584f, -0.12814453f, 0.04754447f, 0.07020919f, 0.14809944f, 0.03376231f, 0.08012011f, 0.13664989f, 
    0.01540652f, -0.09802123f, 0.07971935f, 0.11713166f, -0.43148583f, 0.20295000f, 0.21997875f, 0.17623059f, 
    -0.02826229f, -0.01865054f, -0.00111507f, 0.05586715f, 0.02041218f, -0.00234123f, 0.16150281f, 0.02711728f, 
    0.03841380f, -0.04185027f, -0.09463162f, -0.04067226f, 0.07718929f, 0.14242412f, 0.10913929f, 0.07825745f, 
    0.18248868f, -0.01808708f, -0.08009119f, 0.08588142f, 0.26740378f, -0.04512165f, -0.08367955f, -0.09849672f, 
    0.12801422f, 0.09859630f, -0.09539261f, 0.05033689f, 0.01934641f, -0.03757727f, 0.05872862f, -0.16745850f, 
    -0.22875151f, 0.05206940f, -0.01548167f, 0.07202757f, -0.05237791f, -0.05934939f, 0.07998786f, 0.04893343f, 
    0.06137881f, -0.00237154f, 0.04126363f, -0.04172247f, -0.11854377f, -0.21387611f, -0.00847452f, -0.08547091f, 
    0.01532252f, 0.09973089f, 0.01151255f, -0.00479377f, 0.08080219f, 0.08838800f, -0.02409297f, -0.04394740f, 
    0.02665183f, 0.45301229f, 0.09163268f, 0.13097432f, 0.03461275f, -0.09558555f, 0.09715451f, -0.09199314f, 
    0.04945309f, 0.12740082f, -0.02333616f, 0.01630841f, -0.09245631f, 0.13551939f, 0.23074926f, 0.05594051f, 
    -0.02011779f, -0.04829545f, -0.04995514f, 0.05260915f, 0.02869343f, 0.07058597f, 0.07951313f, 0.15118979f, 
    0.01047375f, -0.04999755f, -0.11555303f, -0.23539345f, -0.12338158f, 0.09995679f, 0.00054349f, -0.11911801f, 
    0.03368040f, 0.07319598f, -0.02430237f, 0.00045540f, 0.07781618f, 0.08720504f, -0.09015986f, -0.05994684f, 
    -0.06806497f, 0.02507582f, 0.02121937f, -0.04273892f, -0.02245283f, -0.01806335f, -0.02025345f, 0.06732596f, 
    0.00490985f, 0.06815375f, 0.04579478f, -0.17668746f, -0.13335755f, 0.01107957f, -0.11436129f, 0.09608801f, 
    0.06019370f, -0.01089116f, -0.08540493f, -0.18130888f, 0.11989319f, 0.10802527f, 0.03593391f, -0.00916738f, 
    0.04637805f, -0.04523680f, 0.00685783f, 0.05537745f, 0.00442214f, -0.02378378f, 0.07052188f, 0.01203790f, 
    0.02289986f, 0.05479965f, 0.16290991f, -0.13535865f, 0.14903364f, 0.01882043f, 0.02668342f, 0.14543578f, 
    0.08005496f, -0.13960977f, 0.10349078f, 0.04701955f, 0.23010775f, 0.05931063f, -0.12523682f, 0.07049894f, 
    0.06208761f, 0.10341680f, -0.05880850f, 0.03353457f, 0.08489061f, 0.04354386f, -0.04474948f, 0.10903935f, 
    -0.07327504f, 0.05342701f, 0.00861448f, 0.09349149f, 0.01762390f, -0.06561343f, -0.04170598f, -0.03897684f, 
    0.01357828f, 0.03357322f, -0.03010277f, 0.13190702f, -0.03668508f, 0.09766082f, -0.08912862f, -0.04299938f, 
    0.06813528f, -0.06164340f, -0.05178496f, 0.15295187f, -0.06764084f, 0.10819484f, 0.01676046f, 0.05788019f, 
    0.39025271f, -0.07842263f, -0.27762118f, 0.10575648f, 0.17282392f, 0.08842593f, -0.07021119f, -0.00524390f, 
    0.29272157f, -0.10776448f, -0.11536532f, 0.00292665f, -0.05989657f, -0.22661507f, -0.04271146f, 0.02005023f, 
    0.09332988f, 0.00374669f, -0.11817512f, 0.16370025f, 0.05794629f, -0.00681798f, -0.00445426f, -0.04866481f, 
    -0.10996660f, 0.20081247f, -0.15926445f, 0.08279905f, -0.00696086f, -0.01665393f, 0.00832427f, 0.07507975f, 
    -0.01514181f, -0.04814972f, 0.08897983f, 0.07985428f, -0.13550913f, -0.13959850f, 0.08522289f, 0.16193794f, 
    0.01117039f, 0.24563479f, 0.00865296f, 0.09684423f, 0.00562801f, -0.09001792f, 0.08780145f, -0.16649339f, 
    0.02245110f, 0.15698193f, 0.07778422f, -0.21375608f, -0.04398254f, -0.24440746f, -0.17412806f, -0.10317679f, 
    0.16535242f, 0.06939371f, 0.00965119f, -0.01128765f, -0.26094347f, -0.17138295f, 0.23808166f, -0.23985995f, 
    -0.08058950f, -0.18341941f, 0.08786621f, -0.15569073f, 0.16197853f, 0.07142012f, -0.00051262f, 0.08386419f, 
    0.01797757f, 0.17688471f, 0.09809121f, -0.15504345f, 0.09222777f, 0.17138417f, 0.03978516f, -0.08361430f, 
    -0.02460509f, 0.02947232f, 0.00398692f, 0.06565287f, 0.21004102f, -0.01559569f, -0.10772485f, 0.06150428f, 
    0.03857628f, 0.01214814f, 0.16406482f, 0.08180948f, 0.14189713f, 0.01662483f, 0.04316887f, 0.09048811f, 
    -0.04482758f, -0.08307479f, 0.02560409f, 0.03412508f, 0.06177600f, 0.03388006f, -0.06779242f, 0.07114366f, 
    0.05072603f, -0.01340686f, 0.11922818f, 0.19502866f, 0.11726556f, -0.20298381f, 0.48070917f, 0.04709223f, 
    0.11422255f, -0.00294673f, -0.04965097f, 0.09892043f, -0.06693629f, -0.07684654f, 0.13520761f, -0.01597586f, 
    -0.26670566f, 0.00740895f, 0.03625457f, 0.20234267f, 0.05350764f, -0.01273780f, 0.05625543f, -0.09759849f, 
    -0.11248247f, -0.05829696f, -0.15420830f, 0.03574052f, 0.15348683f, 0.20151597f, -0.02012677f, -0.08797545f, 
    0.07141255f, -0.01513972f, 0.18095468f, 0.05434215f, -0.06498341f, 0.05638765f, 0.07326529f, -0.02362147f, 
    -0.01947794f, 0.05198079f, 0.21817677f, -0.14526425f, -0.00162736f, -0.11923148f, 0.09463742f, 0.31435457f, 
    0.07178275f, 0.18576419f, 0.20678686f, -0.07794140f, 0.03887957f, 0.18454173f, 0.17448927f, 0.05203008f, 
    0.03349426f, -0.01223730f, -0.14025415f, -0.04396578f, -0.04685163f, -0.05817069f, -0.00699869f, 0.06381662f, 
    0.11956232f, -0.01268944f, 0.06554005f, 0.00703026f, 0.07272100f, -0.09048210f, -0.05762872f, 0.05874117f, 
    -0.06885828f, -0.06655449f, -0.05995958f, 0.02873530f, 0.06843414f, 0.17577973f, -0.18521269f, -0.26440933f, 
    0.04543182f, 0.08845164f, 0.00673311f, -0.04315874f, -0.03230279f, 0.11323991f, 0.00218280f, 0.11473527f, 
    0.38002700f, -0.05694249f, -0.02702368f, 0.25183910f, 0.03383549f, -0.04762971f, 0.12744614f, 0.09193207f, 
    -0.06662578f, 0.11955060f, -0.10531452f, 0.12195445f, -0.62418771f, -0.24311151f, -0.17150165f, 0.07638540f, 
    -0.03636537f, 0.11781979f, 0.08772173f, 0.24405809f, 0.05681813f, -0.13720794f, 0.03176056f, -0.13093053f, 
    0.17360029f, -0.08475254f, -0.14402632f, 0.22654606f, -0.11079798f, 0.03456241f, -0.00182302f, -0.05690298f, 
    -0.15896828f, -0.11673006f, 0.07083925f, 0.00940523f, 0.17796601f, -0.07706769f, 0.17589134f, -0.12992556f, 
    0.16536459f, 0.08395845f, -0.11294561f, 0.08948509f, -0.07980916f, 0.09823103f, 0.07491421f, 0.06557563f, 
    -0.10310775f, 0.11344219f, 0.00765396f, -0.15533254f, 0.02738212f, 0.12705381f, 0.06034422f, 0.01456279f, 
    -0.01992001f, 0.00479127f, 0.00702417f, -0.01898304f, 0.18594372f, 0.08540771f, -0.13328134f, 0.07610562f, 
    0.06502572f, -0.12849917f, -0.03604752f, 0.07447924f, -0.02824074f, 0.11491656f, 0.01052793f, 0.03022426f, 
    -0.36939555f, -0.38199940f, -0.10166097f, 0.06246012f, 0.01088999f, 0.11093492f, 0.00468362f, 0.04564737f, 
    0.24879172f, -0.03747756f, -0.10479133f, -0.06080479f, -0.05348182f, 0.04697187f, -0.01684733f, -0.10725133f, 
    0.11234555f, 0.19007407f, 0.19054300f, 0.01229985f, -0.04555244f, 0.05006775f, 0.13659823f, -0.08799202f, 
    -0.04386729f, -0.01390604f, -0.07083637f, -0.14562786f, -0.08249302f, 0.00117717f, 0.01848003f, -0.13108997f, 
    0.06222037f, 0.03668533f, -0.07209059f, 0.00941394f, -0.04301432f, 0.05936826f, -0.00531096f, -0.06302007f, 
    0.02856259f, 0.00197537f, -0.14642641f, -0.00545104f, -0.03214311f, -0.03935079f, 0.05757463f, -0.03221731f, 
    0.07955150f, 0.04006185f, 0.02693396f, -0.07290202f, -0.06016472f, -0.09076014f, 0.01193037f, -0.00664392f, 
    -0.10440251f, -0.06229920f, -0.20230879f, -0.08392902f, 0.00316853f, 0.06765807f, 0.09135944f, 0.01441018f, 
    -0.02085483f, 0.09824409f, 0.01701628f, 0.01063085f, 0.03028367f, -0.01638610f, 0.00632603f, 0.04439291f, 
    -0.08888896f, 0.03779903f, 0.08145688f, -0.21518241f, 0.10534526f, 0.06746465f, 0.03628315f, 0.04881981f, 
    0.01045120f, 0.02487950f, -0.01815472f, -0.10418477f, -0.03899596f, 0.02146152f, -0.08033342f, -0.04001488f, 
    0.07397642f, -0.02446657f, 0.12314361f, 0.10803614f, 0.06876234f, 0.01307243f, -0.01377842f, 0.02149564f, 
    -0.03107626f, -0.02331078f, -0.03523577f, 0.09160022f, -0.06581371f, 0.00060133f, 0.02689456f, 0.06639384f, 
    0.05157341f, 0.13439141f, -0.06792546f, -0.08730930f, -0.39352277f, 0.16507760f, 0.04490235f, 0.05380132f, 
    -0.00576575f, 0.08149547f, 0.02510031f, 0.09835356f, -0.02641331f, -0.06779987f, 0.02860644f, 0.05301753f, 
    0.24919200f, 0.06803746f, 0.17640017f, -0.10196117f, 0.02828813f, 0.08810783f, 0.03547785f, -0.04972026f, 
    0.03436397f, 0.19610383f, -0.05381745f, -0.06599806f, -0.35536763f, -0.28340989f, 0.16566131f, 0.01640116f, 
    -0.05490469f, 0.04059258f, 0.08021071f, 0.09007721f, 0.03307477f, 0.10829093f, -0.07910965f, 0.01673507f, 
    0.00014676f, -0.06563432f, 0.03109920f, 0.14325093f, -0.03668575f, 0.02418369f, -0.01226845f, 0.07917017f, 
    -0.03714339f, 0.07205087f, 0.08218400f, -0.09220942f, -0.04510951f, 0.19306660f, 0.06994671f, 0.04401547f, 
    0.09895212f, 0.16826573f, -0.05265767f, -0.11981719f, 0.05970116f, 0.12654658f, 0.06777118f, 0.03676606f, 
    0.05307459f, 0.06021670f, 0.05514720f, -0.04648890f, 0.06239173f, 0.00504481f, 0.01178690f, -0.00660309f, 
    -0.04593208f, -0.11094028f, -0.06840707f, -0.12000861f, 0.19264865f, -0.00553209f, 0.20962070f, -0.03939878f, 
    0.00782771f, -0.02056898f, 0.05581924f, 0.13125083f, 0.05942335f, -0.14540082f, -0.00247184f, -0.21209826f, 
    0.19623934f, 0.04332160f, 0.22107880f, -0.11900632f, 0.00068832f, 0.09675615f, 0.15396459f, -0.05696280f, 
    -0.03608953f, 0.04031515f, 0.05897865f, -0.12648997f, 0.21866095f, 0.12521710f, 0.04613004f, 0.11627826f, 
    -0.07166819f, 0.10533740f, 0.04748772f, -0.03792630f, 0.11229737f, 0.04725631f, 0.06212078f, 0.06449925f, 
    0.01723227f, 0.02875703f, 0.08169673f, 0.12714632f, 0.03937724f, 0.01807265f, -0.04184624f, 0.02770151f, 
    0.03631794f, 0.06847133f, -0.05982490f, 0.06638300f, -0.11820704f, 0.20211469f, 0.03090136f, -0.31300688f, 
    0.04750480f, -0.01791520f, -0.04123244f, 0.01299410f, -0.03115134f, -0.04160232f, 0.08101235f, -0.02222726f, 
    -0.04921040f, 0.17864370f, 0.14388588f, -0.00383209f, -0.09011179f, -0.05964325f, -0.01411591f, -0.06896652f, 
    -0.12846363f, -0.04122518f, -0.02158984f, -0.12582971f, 0.18576857f, -0.04865353f, -0.18915142f, 0.01198653f, 
    0.01934672f, -0.01979030f, 0.02646264f, 0.06527600f, 0.05616518f, 0.00204169f, 0.05880369f, -0.02415870f, 
    -0.22108912f, 0.19818148f, 0.01700553f, -0.01566114f, 0.01136288f, 0.03391017f, 0.04686657f, 0.16925120f, 
    -0.05335957f, -0.07460165f, -0.07646748f, 0.02906351f, -0.15937313f, 0.08550297f, -0.14237832f, -0.21897906f, 
    -0.00517343f, -0.22021019f, 0.04697911f, 0.01173198f, -0.08030050f, 0.05675310f, 0.04263286f, 0.02865665f, 
    0.08832145f, -0.03960084f, 0.04088673f, -0.10119757f, 0.00786482f, -0.03397569f, -0.03517295f, -0.00976696f, 
    -0.04124375f, -0.02968907f, 0.01620702f, 0.09639505f, 0.10788085f, -0.11264094f, -0.13049845f, -0.18598017f, 
    -0.07327308f, -0.15736942f, -0.06563555f, -0.09378934f, -0.10688991f, 0.01253951f, -0.07259898f, 0.02219411f, 
    0.41217467f, -0.28588206f, 0.00342597f, 0.12723379f, -0.03495310f, 0.05037680f, -0.04026916f, 0.10656738f, 
    0.09122072f, 0.01462538f, -0.02548512f, 0.07741220f, -0.18464071f, 0.27988642f, 0.09590539f, 0.11364187f, 
    -0.09419321f, 0.05093265f, 0.05787261f, 0.09865089f, 0.02378191f, -0.00684202f, 0.05494247f, -0.02418540f, 
    -0.05347870f, -0.03290911f, -0.02510655f, 0.08821880f, -0.03972429f, -0.11140451f, 0.05194386f, 0.08825107f, 
    -0.07829289f, -0.08867816f, 0.04973665f, 0.13989137f, -0.12238293f, -0.19185916f, 0.06797417f, -0.00284283f, 
    0.07777474f, -0.12762478f, 0.20682847f, 0.00943246f, -0.10355499f, 0.01371282f, -0.06120515f, 0.19032262f, 
    0.11260230f, 0.07834948f, 0.13802837f, 0.00617005f, 0.11280824f, 0.14073391f, -0.02976057f, 0.06102107f, 
    -0.04923059f, -0.06844416f, -0.05034318f, -0.06728709f, 0.03999262f, -0.06956028f, -0.07138049f, 0.01152692f, 
    -0.00062557f, 0.01815193f, 0.06883238f, -0.01365126f, 0.04455923f, -0.00439979f, -0.03489896f, 0.02019043f, 
    0.15932380f, 0.02339143f, -0.08536636f, -0.01663887f, -0.00882456f, 0.01129868f, -0.01125883f, 0.02159713f, 
    -0.07821520f, -0.16127160f, -0.03284848f, 0.03589818f, 0.28460702f, 0.01871450f, -0.00042861f, 0.02453803f, 
    -0.00599995f, 0.01338627f, 0.04072333f, -0.06906696f, -0.00946434f, 0.03000616f, 0.09468814f, 0.01531740f, 
    0.01388679f, 0.02326313f, -0.19792448f, -0.09877738f, 0.09147940f, -0.06134513f, 0.13201492f, 0.06275808f, 
    -0.07412364f, 0.05382525f, 0.03747990f, 0.08937143f, 0.19614281f, -0.03150033f, 0.16615975f, -0.19544926f, 
    -0.00425976f, 0.12933907f, -0.05366236f, 0.03541398f, 0.01862533f, 0.11016219f, 0.03075830f, 0.04767529f, 
    0.00273846f, -0.00372996f, -0.07752492f, -0.22450560f, 0.01161917f, 0.02507159f, 0.11536369f, 0.06724042f, 
    0.04876952f, 0.19354774f, 0.06758404f, 0.07936457f, -0.01825067f, 0.03777570f, -0.08432463f, 0.00813651f, 
    0.11733864f, -0.00630970f, -0.08138088f, -0.13103132f, -0.01060770f, 0.05995664f, 0.02955812f, -0.01103943f, 
    0.12888415f, 0.06429137f, 0.22056550f, 0.02539825f, 0.14785001f, 0.09406928f, 0.04624622f, 0.16236722f, 
    0.10779866f, -0.03479942f, 0.13554513f, 0.10012978f, -0.03525887f, 0.02441858f, -0.18211161f, -0.01612339f, 
    0.08417144f, -0.10676182f, 0.04452701f, -0.08664649f, 0.05466157f, 0.06078460f, -0.02792275f, 0.01404696f, 
    0.02119170f, -0.06315535f, 0.08525256f, -0.02917827f, -0.13692717f, -0.06956664f, -0.07030331f, -0.12117730f, 
    0.11674379f, 0.14255795f, 0.19155192f, 0.11024369f, 0.33887750f, -0.26610544f, 0.17236175f, 0.07120721f, 
    0.24085535f, 0.02559122f, 0.10230096f, 0.04893738f, 0.16653924f, 0.04074073f, 0.03389810f, 0.06071933f, 
    0.05187067f, -0.24404930f, 0.14743116f, -0.40535679f, -0.07950050f, 0.03923303f, 0.24981214f, 0.08379453f, 
    0.11880740f, -0.07782334f, -0.00539280f, 0.07104115f, -0.65667874f, 0.40494168f, -0.06089949f, 0.29104558f, 
    -0.01391180f, 0.05027454f, -0.03068327f, 0.01688829f, -0.08482748f, -0.05386602f, -0.18312316f, -0.09139627f, 
    0.09333105f, -0.05666313f, 0.19154668f, 0.09762702f, -0.24599753f, 0.09570965f, -0.11864008f, -0.08557016f, 
    0.06889453f, 0.10420246f, 0.14828648f, 0.00672244f, 0.02682290f, -0.06862685f, -0.02410891f, -0.11552797f, 
    0.05090063f, -0.08612040f, 0.05170972f, 0.01707645f, 0.02054812f, -0.04459924f, 0.06046099f, -0.18037611f, 
    0.03566808f, 0.10893849f, 0.15717795f, -0.12591669f, 0.08084641f, -0.08041512f, -0.02899923f, 0.07598799f, 
    0.15635708f, -0.06153018f, 0.02253712f, 0.02111000f, -0.07283838f, 0.09889890f, -0.07904716f, -0.13425265f, 
    0.05024102f, -0.03904890f, -0.13947380f, 0.21101166f, 0.00875879f, -0.15594567f, -0.03252601f, 0.10066733f, 
    0.09327227f, -0.02801593f, -0.23382261f, -0.16520785f, 0.12365365f, 0.06206689f, 0.05670828f, 0.21879686f, 
    -0.07106477f, -0.09372927f, -0.09598892f, 0.12215254f, 0.42409340f, -0.24946995f, 0.46471405f, 0.12824403f, 
    0.05594812f, -0.05607072f, 0.01504119f, -0.14048228f, 0.02377366f, -0.04929226f, 0.11708007f, -0.04278716f, 
    0.01392877f, 0.07808273f, 0.12187184f, -0.03525388f, -0.11734429f, -0.02946790f, -0.04221585f, -0.21405572f, 
    0.06453456f, -0.04121147f, 0.12015031f, 0.01982798f, 0.04951148f, 0.13355392f, -0.05527507f, 0.16997223f, 
    0.06927141f, 0.06470148f, 0.27206239f, 0.01400022f, 0.02612944f, 0.00537992f, -0.00183161f, 0.03439973f, 
    -0.10558029f, -0.21793099f, -0.27174258f, -0.28699428f, 0.02978282f, 0.20838803f, 0.08998756f, 0.13816625f, 
    0.14027302f, 0.01223704f, 0.02328100f, 0.00444378f, 0.18183140f, 0.24381991f, 0.02502023f, -0.22368683f, 
    0.10056596f, 0.06001183f, 0.04445546f, 0.12386898f, -0.00075758f, 0.00682027f, 0.00844781f, -0.03216237f, 
    0.09581628f, -0.03288523f, 0.13847135f, 0.19829856f, 0.09275065f, 0.08103159f, 0.00429652f, 0.06821167f, 
    0.11381750f, 0.08928207f, -0.04358288f, -0.13228859f, 0.05756481f, -0.25755525f, -0.33638611f, -0.08091713f, 
    0.16780828f, 0.06428468f, 0.17383075f, 0.16628379f, -0.06689527f, -0.11680451f, -0.05651962f, -0.11288651f, 
    -0.17345934f, 0.06147359f, -0.03574550f, 0.05252224f, 0.01750454f, -0.02824824f, -0.00055656f, 0.02517059f, 
    -0.04135532f, -0.00773062f, -0.07457346f, 0.05281458f, 0.07593691f, -0.01886935f, 0.00778471f, -0.16273756f, 
    -0.12431724f, -0.01498744f, 0.13456213f, 0.21083276f, -0.06042032f, -0.02275597f, 0.00742639f, -0.07716363f, 
    0.15769903f, -0.09234855f, 0.21634059f, -0.01596455f, 0.11508502f, -0.00065594f, -0.00667707f, -0.04127545f, 
    -0.16686577f, 0.01705343f, 0.05975781f, 0.00473787f, 0.05866162f, -0.23300545f, -0.00012147f, -0.04734784f, 
    -0.04971680f, 0.01673867f, -0.11617406f, -0.13890894f, 0.04253018f, -0.01037266f, 0.09893570f, -0.08886990f, 
    0.01116927f, 0.22303756f, -0.01314607f, 0.09165379f, 0.05947000f, -0.02028670f, -0.05689744f, -0.15032661f, 
    -0.06142782f, 0.10468766f, 0.18462390f, 0.17482884f, -0.20829973f, 0.20131883f, -0.07528818f, 0.03295764f, 
    0.10138903f, -0.11881560f, 0.08793281f, -0.06253602f, 0.08594822f, 0.13066164f, 0.05727918f, 0.06925633f, 
    -0.03302003f, 0.08094146f, -0.13286982f, -0.14381382f, 0.00914205f, 0.00516464f, -0.02789749f, 0.04597438f, 
    0.02603054f, -0.08600731f, -0.01115805f, 0.00378437f, 0.03402413f, -0.06443356f, -0.02404731f, 0.10430448f, 
    0.02298717f, 0.06290891f, 0.01010674f, -0.02075372f, 0.10755064f, -0.02965427f, -0.12833713f, 0.12210629f, 
    -0.03764715f, -0.19296667f, -0.09059437f, -0.37134275f, -0.10104927f, 0.11453690f, -0.18844882f, 0.07733453f, 
    0.11272632f, 0.18899839f, -0.01778497f, -0.06508341f, -0.05221776f, -0.03364569f, -0.03223068f, -0.23494153f, 
    0.03270843f, 0.01560069f, -0.07932548f, 0.11657734f, 0.02677213f, -0.13957153f, 0.04203372f, -0.11353456f, 
    0.28867027f, 0.21376051f, 0.05470216f, -0.06443030f, 0.03543589f, -0.02541325f, 0.14194247f, 0.09138191f, 
    -0.01177110f, -0.04613603f, -0.06118152f, -0.07572424f, 0.13729008f, 0.04277199f, 0.16407865f, -0.05970617f, 
    0.09595910f, 0.11347720f, 0.15722194f, 0.11371803f, -0.11820393f, -0.01158301f, -0.04013859f, -0.19742383f, 
    0.01660750f, -0.05846982f, -0.03762830f, -0.28156376f, 0.08785605f, 0.15586294f, -0.11510452f, -0.09362602f, 
    0.07795981f, -0.25628367f, 0.01712324f, -0.14507174f, -0.42702729f, -0.32169282f, -0.28287813f, 0.11464997f, 
    0.18818243f, -0.07063541f, -0.06383096f, 0.05744391f, -0.01268275f, 0.08401742f, -0.06041476f, 0.20376900f, 
    0.12060413f, 0.04377169f, 0.26135075f, 0.11552566f, 0.05316530f, 0.08854357f, -0.18087046f, 0.05351105f, 
    -0.03186521f, -0.04702153f, -0.03902604f, 0.11475335f, 0.21909885f, -0.04149366f, 0.13229999f, -0.17002019f, 
    0.01332557f, 0.04395796f, 0.15859535f, 0.07849452f, -0.00158403f, 0.02444390f, -0.04690067f, -0.02703642f, 
    0.03313945f, -0.30705422f, -0.13572675f, -0.11194991f, 0.05023179f, -0.00545360f, -0.04027331f, 0.03797452f, 
    0.09030490f, -0.01183181f, -0.01461297f, 0.03461587f, 0.04345536f, 0.00228792f, 0.32277009f, 0.03226323f, 
    -0.03116634f, 0.13975239f, 0.15953529f, -0.00011094f, -0.02256540f, -0.12423772f, -0.01131628f, -0.06018996f, 
    -0.07493936f, 0.07721116f, 0.10536372f, -0.36295867f, 0.10798803f, 0.12018924f, -0.07025427f, -0.08778614f, 
    -0.00407140f, 0.00385537f, 0.02718908f, 0.15033525f, -0.56136066f, -0.02042173f, -0.24457559f, 0.24879038f, 
    0.07028125f, -0.06739862f, -0.09679655f, -0.06223692f, 0.04540546f, 0.05219043f, -0.02057922f, -0.03221783f, 
    -0.04489715f, -0.23521389f, -0.03277215f, -0.18874155f, 0.08282612f, -0.14837945f, -0.02672340f, 0.10529545f, 
    0.01039487f, 0.05139316f, -0.16583882f, 0.06549481f, -0.07101557f, 0.08061425f, 0.09647986f, 0.04708692f, 
    0.04867789f, 0.05863664f, 0.08058023f, 0.01427654f, -0.08618034f, 0.07951919f, 0.05399403f, 0.19331247f, 
    0.03574317f, 0.15353729f, 0.23035863f, 0.07409620f, 0.02516720f, 0.05474712f, -0.01661369f, 0.11390177f, 
    0.04217057f, -0.01117772f, -0.09106359f, 0.02802845f, 0.11242388f, -0.01824258f, 0.33410454f, 0.09754932f, 
    -0.08051642f, 0.01824004f, -0.05225279f, 0.03061145f, 0.11715183f, -0.15301080f, -0.06278396f, -0.03863656f, 
    0.13680251f, 0.08053223f, 0.06997918f, -0.11373977f, -0.05652719f, 0.06882773f, 0.06588320f, 0.07691070f, 
    -0.02304598f, 0.02945987f, -0.01014665f, -0.02855438f, 0.29149038f, -0.34779164f, 0.26871449f, 0.05741806f, 
    -0.06246421f, -0.02342822f, 0.00285649f, -0.01073249f, -0.02740928f, 0.01279884f, -0.13293231f, 0.03147341f, 
    -0.38736391f, -0.28799421f, -0.06141018f, -0.14875689f, 0.07953084f, -0.00877539f, -0.12332151f, 0.06159852f, 
    0.16393848f, -0.00640068f, -0.03907635f, 0.04579998f, -0.23237965f, 0.08768148f, -0.24155103f, 0.09948460f, 
    0.10705277f, 0.03464320f, -0.08520994f, 0.02839302f, 0.02368052f, 0.08062672f, 0.04785365f, 0.03791550f, 
    -0.08306401f, 0.08965193f, -0.08848099f, -0.07757214f, -0.08563621f, 0.04943419f, -0.04489664f, -0.03187393f, 
    0.05549372f, 0.06446649f, -0.05087240f, -0.01807540f, 0.20378639f, 0.00684175f, 0.23341726f, 0.01208764f, 
    0.00864888f, 0.05588500f, 0.10826956f, 0.07521141f, 0.07211869f, 0.15602009f, -0.00307468f, 0.01369173f, 
    0.08224857f, 0.06644617f, 0.29797438f, 0.24665335f, 0.03231220f, 0.06694587f, -0.05204900f, -0.11687319f, 
    0.12158608f, -0.09733102f, 0.15040363f, 0.15746547f, -0.11879495f, 0.11179234f, -0.05827566f, -0.01772235f, 
    0.07548666f, -0.04194631f, -0.10683695f, 0.10419981f, 0.01269489f, 0.00275537f, 0.01554948f, -0.01597591f, 
    -0.27993619f, -0.24131583f, -0.29155785f, 0.08739085f, 0.20582740f, 0.01672507f, -0.10978308f, 0.05728039f, 
    0.15823761f, 0.06432864f, -0.01829526f, 0.07554140f, 0.09269761f, 0.16321887f, 0.00002459f, -0.28399333f, 
    -0.04817361f, -0.08070270f, 0.06671300f, 0.19381596f, -0.05557604f, -0.02068367f, 0.02900966f, -0.11311352f, 
    0.16603187f, -0.57678217f, 0.03520189f, -0.21576658f, 0.04142205f, -0.00086846f, 0.04968602f, 0.03171269f, 
    0.02775720f, 0.00411518f, -0.01271873f, 0.12254475f, -0.19544223f, 0.05010122f, 0.13656300f, 0.22328241f, 
    -0.07919797f, 0.01048648f, 0.05635501f, 0.15850222f, 0.11899693f, 0.02740241f, -0.01208877f, 0.10059331f, 
    -0.21008563f, -0.00647944f, -0.09697399f, -0.06385653f, 0.20574048f, -0.15090922f, -0.00830624f, 0.00930516f, 
    0.10088660f, -0.07993007f, 0.07177539f, 0.00836918f, -0.17025085f, -0.03045553f, -0.10754144f, 0.27383405f, 
    0.14738527f, 0.02707202f, -0.00648531f, -0.04823926f, 0.11377050f, -0.12052668f, 0.00584729f, -0.11041046f, 
    -0.02249388f, 0.12257595f, 0.05169732f, 0.01052480f, 0.07658184f, 0.01868877f, 0.08337220f, 0.12757121f, 
    0.04872563f, -0.07165340f, 0.02716807f, -0.03388989f, -0.36868003f, -0.35587075f, -0.43302923f, 0.07620088f, 
    0.17278448f, -0.04712570f, -0.01070240f, 0.05980415f, 0.04650604f, 0.00267852f, 0.09115446f, -0.00464587f, 
    0.23361921f, 0.00266738f, -0.16596970f, -0.11388103f, -0.02957946f, -0.00086906f, -0.04583755f, 0.03271599f, 
    0.16871618f, 0.01647018f, 0.04324790f, 0.00196899f, 0.17493044f, 0.03588987f, 0.08687638f, 0.04874813f, 
    -0.01638244f, 0.06291661f, -0.05523385f, 0.03306795f, 0.10281832f, -0.01550357f, 0.05320788f, 0.10691041f, 
    -0.00819898f, 0.02752090f, -0.00342709f, 0.01515015f, 0.04149869f, 0.01997421f, 0.01614027f, 0.01412243f, 
    -0.03574432f, -0.04790694f, -0.04419294f, -0.03269570f, -0.05205350f, 0.03528434f, -0.00484480f, -0.03803075f, 
    0.02001842f, 0.01389541f, -0.04150101f, -0.01058108f, -0.03167738f, -0.03867703f, 0.03126752f, -0.06102098f, 
    -0.00610526f, 0.03810377f, 0.00798922f, -0.03190416f, 0.00649212f, -0.04614127f, 0.03019780f, 0.00412376f, 
    0.00670829f, 0.01558140f, -0.01012314f, 0.01244817f, 0.03500978f, -0.04580036f, 0.02264523f, -0.01166264f, 
    0.01261774f, 0.02518076f, 0.02172384f, -0.05236870f, 0.01872190f, 0.04136096f, -0.04642843f, 0.00915418f, 
    -0.01874099f, 0.01384745f, -0.04556828f, -0.04288908f, -0.03939327f, 0.00401183f, -0.03470809f, 0.03087123f, 
    -0.02413159f, -0.00843045f, -0.00858936f, 0.03015590f, -0.03693578f, 0.02469060f, 0.00401287f, -0.05378184f, 
    0.02099268f, -0.02395592f, -0.01851770f, -0.00981661f, -0.00318920f, -0.02152437f, -0.03194842f, -0.01981207f, 
    0.02811441f, -0.03372707f, 0.01169081f, 0.02962700f, 0.03597127f, -0.05141715f, -0.03571162f, 0.01554848f, 
    -0.01092172f, -0.00005106f, -0.03868199f, 0.01191018f, 0.02643890f, 0.00787883f, 0.04138050f, -0.04860409f, 
    0.00889322f, 0.04521527f, 0.03394531f, -0.03643762f, 0.00435168f, -0.04435116f, -0.01475204f, -0.01099509f, 
    -0.00785988f, -0.02306684f, -0.01534275f, -0.05651509f, -0.04651200f, 0.03339424f, -0.05168243f, 0.01717890f, 
    0.04573037f, -0.01449644f, -0.01826858f, -0.00397167f, -0.02651014f, -0.02306188f, 0.00093114f, -0.05824935f, 
    0.01398325f, 0.00398828f, 0.02177256f, -0.04899220f, -0.03474106f, 0.00508046f, -0.03864473f, 0.03562981f, 
    -0.02329301f, 0.01990322f, -0.02466710f, 0.00135189f, -0.05392667f, 0.04206238f, -0.02975486f, -0.02285592f, 
    0.00788941f, -0.04055173f, -0.03019609f, 0.03915993f, 0.02292030f, -0.04166222f, -0.00397983f, 0.03844400f, 
    -0.01489525f, 0.04039092f, 0.01410223f, -0.00981693f, -0.02762418f, -0.02823222f, 0.02522127f, -0.05541173f, 
    -0.04569826f, 0.03535026f, -0.03437675f, -0.05268104f, -0.05167136f, -0.03586086f, -0.01407252f, -0.05826530f, 
    0.02397086f, 0.04104319f, -0.05033562f, -0.00821239f, -0.01260419f, -0.03059498f, -0.03020608f, 0.03209949f, 
    -0.03401385f, 0.00138799f, 0.02460579f, -0.03874519f, -0.02731852f, -0.05393467f, -0.03135606f, -0.04016453f, 
    0.00331228f, 0.00769283f, -0.01090620f, -0.02933135f, 0.00333877f, -0.03336591f, 0.02559332f, 0.01262617f, 
    -0.03063148f, -0.04013548f, -0.00521193f, 0.03877876f, 0.03224824f, -0.01957504f, 0.01827854f, 0.04078914f, 
    0.03747752f, -0.00121446f, -0.01332416f, -0.05353825f, 0.00798635f, 0.03097588f, -0.01420700f, 0.02153484f, 
    -0.02036378f, -0.00800550f, 0.02273908f, 0.00965513f, -0.02818571f, -0.02964398f, -0.00391833f, -0.04972551f, 
    0.01427586f, -0.03990380f, -0.03995113f, 0.04827399f, -0.04985588f, -0.00535299f, -0.04350940f, 0.00981045f, 
    -0.04356842f, -0.05474129f, 0.00054722f, -0.04686999f, 0.03599132f, 0.01342293f, 0.02659778f, -0.04059950f, 
    -0.00771964f, 0.01755398f, 0.00462721f, -0.01455983f, 0.04624575f, -0.04423650f, -0.00126247f, -0.03207208f, 
    -0.04891409f, 0.03052810f, 0.02562511f, 0.00613719f, -0.02601996f, 0.02425177f, -0.01776125f, 0.01349639f, 
    -0.01644736f, 0.00778963f, 0.01831391f, -0.04473460f, -0.01335448f, -0.05441969f, -0.02873676f, -0.00427502f, 
    -0.04626914f, -0.01146835f, -0.04436915f, 0.00325223f, 0.03850890f, 0.02053251f, -0.00989880f, 0.00064281f, 
    -0.02731691f, 0.03150925f, -0.06024960f, -0.04584930f, -0.01098061f, 0.03017170f, -0.04915405f, 0.01374409f, 
    0.02986359f, -0.02141636f, -0.03528580f, 0.04076375f, -0.04913829f, 0.02921364f, -0.02986690f, -0.02699044f, 
    -0.02156020f, -0.02121005f, -0.00594315f, -0.04636403f, 0.05194932f, -0.02074585f, 0.04424975f, -0.01893470f, 
    0.02480880f, -0.02678776f, 0.00788729f, -0.00965029f, -0.01667796f, 0.02800794f, 0.00532216f, 0.03597742f, 
    0.04003873f, -0.05642305f, -0.03027064f, -0.03529692f, 0.01690706f, 0.00917231f, 0.02376916f, -0.01620276f, 
    -0.05813355f, -0.01934763f, 0.02157676f, 0.00313651f, -0.04093749f, 0.03335141f, 0.03899483f, 0.01081553f, 
    0.05615665f, -0.02771222f, -0.03510746f, -0.02653936f, 0.00642800f, 0.03238686f, -0.04745717f, -0.00254617f, 
    0.02503997f, 0.00453000f, -0.00589822f, -0.04077815f, -0.02078238f, 0.00367445f, -0.00471749f, 0.00702568f, 
    -0.02791720f, -0.01318626f, -0.03126600f, -0.02842633f, -0.00012790f, 0.04031584f, -0.03643244f, 0.03957110f, 
    0.02390343f, 0.02338272f, 0.02006529f, 0.01663656f, 0.01774036f, -0.04272541f, -0.03580649f, 0.00495109f, 
    0.00974384f, 0.03812652f, -0.04285644f, 0.04057584f, 0.00774554f, -0.05083488f, 0.02990505f, 0.01039905f, 
    -0.04325988f, -0.04123808f, -0.04272861f, -0.04762087f, 0.02463164f, -0.02764750f, 0.01610287f, -0.02796452f, 
    -0.05457412f, 0.03844466f, 0.03172346f, -0.05878527f, 0.03562985f, -0.04043001f, 0.02717705f, 0.02920223f, 
    0.02395970f, -0.04104560f, -0.01246119f, -0.01114414f, 0.01641234f, 0.03204445f, -0.00583669f, -0.01149795f, 
    -0.05314532f, -0.02654244f, -0.04133099f, 0.02247676f, 0.00437886f, 0.01094051f, -0.00422778f, 0.01943882f, 
    -0.01437238f, -0.04030124f, -0.04751716f, -0.04078918f, -0.05287828f, 0.00578335f, 0.04895826f, 0.00910661f, 
    -0.03197854f, 0.01294202f, -0.00667508f, -0.03843528f, 0.00327966f, -0.01715135f, -0.00148165f, 0.03297975f, 
    -0.28826091f, -0.08885608f, 0.04198543f, 0.07111278f, 0.00715418f, -0.03452979f, 0.02728455f, 0.15843356f, 
    0.08957993f, -0.08817277f, 0.15455076f, 0.02513059f, -0.10650762f, -0.08414845f, -0.12489081f, -0.02120380f, 
    0.05172199f, 0.10692791f, 0.00266709f, 0.16319872f, -0.10294197f, -0.00552248f, -0.04669225f, 0.02012972f, 
    0.11433399f, 0.02842687f, 0.08586746f, -0.01369832f, 0.07239741f, -0.09585749f, 0.25958693f, 0.15959179f, 
    -0.01310553f, 0.19309181f, 0.01866098f, 0.05748323f, -0.01924413f, 0.00248990f, 0.10194467f, -0.05835759f, 
    -0.03790338f, 0.05117527f, -0.00462305f, -0.12813728f, 0.09756666f, -0.02889757f, 0.03399653f, -0.05941683f, 
    -0.13113900f, -0.02795773f, -0.37700284f, 0.01473781f, -0.05723415f, -0.04684638f, 0.13274023f, -0.07441927f, 
    0.02725549f, 0.04259252f, 0.13120449f, -0.22484392f, -0.26678607f, 0.06880692f, -0.07570451f, 0.15980777f, 
    -0.03703230f, 0.01911782f, 0.16380595f, -0.03899736f, 0.03877538f, -0.00065085f, -0.02067302f, -0.03743370f, 
    0.00324298f, 0.00487630f, -0.06484539f, 0.02241407f, -0.08672214f, -0.00617724f, 0.00941635f, -0.03847115f, 
    -0.03032463f, 0.03037684f, -0.04078522f, -0.04358224f, -0.33481872f, -0.09428625f, -0.24782123f, 0.14561245f, 
    0.08128513f, -0.03872056f, -0.01165877f, 0.28897154f, -0.06588403f, -0.03503778f, -0.04400138f, -0.01275883f, 
    0.32515359f, 0.24543776f, 0.25389314f, -0.14474541f, 0.01677800f, -0.05006410f, 0.24682376f, 0.03859247f, 
    0.04317370f, 0.21416143f, 0.13871476f, -0.10812206f, 0.32293677f, 0.11222416f, -0.00836349f, -0.13813719f, 
    -0.05408854f, 0.00664017f, -0.00171830f, -0.11629742f, -0.00430662f, 0.10053015f, 0.01928470f, -0.03520562f, 
    0.17205021f, 0.01781849f, 0.07170015f, 0.25978988f, -0.07992017f, 0.01308734f, -0.00195630f, -0.01438456f, 
    0.07594468f, 0.01293113f, 0.03654930f, -0.04427687f, 0.11912527f, 0.17985544f, -0.07438492f, -0.01058641f, 
    -0.02684334f, 0.05308022f, -0.08450059f, 0.02445238f, 0.27190500f, 0.11972097f, 0.04196422f, 0.03482337f, 
    -0.24907868f, -0.24925594f, -0.07599933f, 0.18331732f, -0.04260112f, -0.08547143f, 0.09401087f, -0.05155072f, 
    -0.01241954f, 0.13597617f, 0.10681607f, -0.09868825f, 0.03612575f, 0.12390193f, 0.01921909f, 0.23371942f, 
    0.02091992f, 0.04485538f, 0.00329468f, 0.09204143f, 0.02560866f, 0.01240649f, 0.04293693f, -0.00395017f, 
    -0.01988372f, 0.00996797f, 0.24480414f, 0.05869272f, 0.06529640f, -0.04439367f, 0.13226180f, 0.03597903f, 
    0.08931270f, 0.03069436f, 0.00765328f, -0.06012148f, -0.10262537f, 0.22435233f, 0.08731285f, 0.29148901f, 
    0.05470276f, 0.00239849f, -0.03245171f, -0.04730804f, -0.01080847f, 0.07908689f, 0.27831566f, 0.07071909f, 
    0.19969405f, 0.03684530f, -0.08826506f, 0.02832817f, -0.06975664f, -0.03043860f, -0.06337170f, -0.11114762f, 
    0.04186003f, 0.16089784f, 0.10889532f, 0.07088307f, 0.18663143f, -0.05938381f, -0.19139531f, -0.16513838f, 
    -0.04667604f, 0.05714005f, 0.37986559f, 0.00414433f, 0.08559737f, -0.08342468f, 0.03338281f, -0.01977230f, 
    0.09581825f, 0.15392908f, 0.06613011f, -0.04625057f, 0.00577616f, -0.10086269f, -0.00579498f, 0.05469370f, 
    -0.00285272f, 0.01591787f, -0.02183526f, -0.04243673f, -0.39329305f, -0.11681519f, -0.01082326f, 0.09334109f, 
    -0.05679279f, -0.06713571f, -0.05992519f, 0.04914394f, 0.00593612f, -0.01596958f, -0.03730587f, 0.06691731f, 
    -0.26294422f, -0.09040888f, -0.25422359f, 0.13055088f, -0.03739826f, -0.07462704f, 0.03847465f, 0.15681121f, 
    0.01847496f, 0.14291644f, -0.04353841f, -0.00962045f, 0.15701234f, -0.01912178f, -0.30261028f, -0.23288392f, 
    0.13377672f, 0.10061937f, 0.07114875f, 0.23204315f, -0.10492079f, -0.00526835f, -0.07058674f, 0.06930701f, 
    0.19137013f, -0.08885171f, 0.09191512f, -0.12148901f, -0.04684067f, 0.02476648f, 0.01732192f, -0.01129184f, 
    0.01389970f, -0.04082811f, -0.01079828f, 0.03134034f, -0.01534117f, -0.30295148f, 0.01924814f, 0.01929820f, 
    0.13989179f, 0.13051742f, -0.09847648f, -0.10067973f, -0.02333937f, 0.03912959f, -0.03685774f, 0.05778980f, 
    0.21635421f, 0.29271328f, -0.04920774f, 0.14427832f, 0.02693821f, -0.01458016f, -0.00563463f, 0.01096955f, 
    -0.01422315f, 0.02912791f, -0.05199208f, 0.09896883f, 0.23503160f, 0.10906594f, 0.10729820f, 0.06333297f, 
    0.01452507f, -0.04313689f, -0.14661433f, -0.20219326f, -0.04192176f, 0.14855498f, 0.15359230f, 0.12236955f, 
    0.11773043f, 0.16505970f, -0.10705560f, -0.06889506f, 0.00911872f, 0.06814834f, 0.02104794f, 0.14092988f, 
    0.07729840f, -0.04740782f, 0.03565279f, 0.19231972f, 0.01684346f, -0.21595477f, 0.02483220f, -0.00675271f, 
    -0.04522261f, -0.06151386f, 0.10117785f, 0.01436053f, -0.01114261f, -0.02663033f, -0.12894668f, 0.00642208f, 
    -0.06609645f, -0.10784366f, 0.11726899f, 0.13172226f, -0.01288033f, -0.07690129f, -0.09234762f, -0.03258142f, 
    0.07052413f, 0.05705572f, 0.02671936f, 0.04371520f, 0.01424652f, -0.03905922f, 0.19067743f, -0.03343667f, 
    -0.02269837f, 0.07718676f, -0.01445638f, -0.05926830f, 0.01604703f, -0.00046450f, -0.04290116f, -0.06163844f, 
    0.05753228f, 0.27437171f, 0.13795274f, 0.03651743f, -0.00783866f, -0.05288161f, -0.10883240f, -0.02937619f, 
    -0.17683804f, -0.07842002f, 0.13562480f, 0.13162164f, 0.07589684f, 0.15575437f, 0.25654361f, 0.13931397f, 
    -0.03508233f, -0.07363573f, 0.00809574f, 0.06698286f, -0.03379765f, 0.07049882f, -0.04694092f, 0.02723293f, 
    -0.23532923f, -0.12208568f, 0.08406001f, 0.02837896f, -0.09996973f, -0.02089311f, -0.07559239f, 0.04046609f, 
    0.13540265f, -0.00529107f, 0.11931102f, -0.03456979f, -0.08966713f, 0.15733996f, -0.13121702f, 0.05344889f, 
    0.06163326f, -0.00922364f, 0.01612676f, 0.02399713f, -0.15599284f, -0.30100179f, -0.01847877f, -0.11607654f, 
    -0.00298096f, 0.02003598f, 0.20612019f, -0.05647213f, -0.07346511f, -0.10983903f, 0.07285908f, 0.12086480f, 
    -0.22481032f, 0.01292568f, -0.05541569f, -0.02306516f, 0.06625704f, 0.11595254f, 0.06098228f, -0.27382225f, 
    -0.03481901f, 0.04996770f, -0.09595851f, 0.02202156f, 0.06726596f, -0.02230168f, 0.02486398f, -0.25963169f, 
    -0.05790840f, 0.01916819f, -0.17510144f, 0.04159965f, 0.06209417f, -0.13583744f, 0.14668614f, -0.01873877f, 
    0.04304959f, 0.12260837f, 0.11269162f, -0.09570815f, 0.00574136f, 0.10677089f, 0.03664427f, 0.21967061f, 
    -0.04800446f, -0.03457484f, 0.17104547f, -0.02076496f, 0.02995030f, -0.08014492f, -0.13408294f, -0.18856561f, 
    -0.01022555f, -0.04806850f, -0.03326680f, -0.03962895f, -0.09584011f, 0.02886287f, 0.09103131f, 0.05819693f, 
    -0.14213154f, 0.10449546f, -0.21202807f, -0.09403161f, -0.20010595f, 0.15133065f, -0.28332308f, 0.13093194f, 
    0.01803434f, -0.03621526f, -0.04726385f, 0.12242761f, -0.22687639f, -0.08702476f, -0.13423383f, -0.16808046f, 
    0.06185823f, 0.30140173f, 0.23567437f, -0.00668004f, 0.02450449f, 0.06602734f, 0.21581069f, -0.04046845f, 
    -0.03777353f, 0.07159812f, 0.06349719f, 0.13568188f, 0.51238346f, -0.11432648f, -0.08024329f, -0.18919559f, 
    0.11160829f, 0.00747243f, -0.04432106f, 0.00367949f, 0.05084436f, 0.23627861f, 0.22893494f, 0.18669695f, 
    0.04293558f, 0.04619273f, 0.01412837f, 0.03734892f, -0.00725098f, -0.00109193f, 0.02987035f, -0.04347752f, 
    -0.06101979f, -0.04018889f, 0.15332980f, -0.13901883f, 0.07224711f, 0.07752150f, -0.03045953f, 0.07960509f, 
    0.05510328f, 0.17837422f, 0.07732994f, 0.00704472f, 0.09135234f, 0.11690135f, 0.11982879f, 0.25888145f, 
    -0.11762159f, -0.27180097f, -0.13605712f, 0.10671961f, 0.00718891f, -0.05518701f, 0.07358516f, -0.08324382f, 
    -0.07360832f, 0.13827653f, 0.01380767f, -0.02495427f, -0.09673666f, -0.11684768f, 0.12144232f, 0.15190445f, 
    0.09483607f, -0.02521537f, 0.03434129f, 0.12986346f, -0.12347115f, 0.12646322f, -0.00668525f, 0.00786341f, 
    -0.03902453f, -0.02842026f, 0.31343803f, 0.06872677f, 0.01383128f, -0.01510242f, 0.06776349f, -0.10197006f, 
    0.06416070f, -0.00568912f, -0.09411857f, -0.05971350f, -0.24829812f, 0.10737380f, -0.06782469f, 0.16484733f, 
    0.08463132f, 0.00800599f, -0.08917911f, 0.00104848f, -0.05697177f, 0.14963733f, 0.30162057f, 0.08195993f, 
    0.22808276f, -0.04604532f, -0.01783950f, 0.05198484f, -0.16096778f, -0.04953996f, -0.06563461f, -0.05374123f, 
    0.06451968f, 0.17073283f, 0.04144901f, 0.01465744f, 0.10012596f, -0.30648807f, 0.33192059f, -0.07753112f, 
    0.08973322f, 0.05523535f, 0.06320363f, 0.04873621f, -0.07612823f, -0.05980229f, 0.02134411f, -0.03679439f, 
    0.16497701f, 0.24401242f, 0.18496080f, 0.10167104f, 0.05799156f, 0.02796914f, -0.01385736f, -0.01028453f, 
    -0.12655890f, -0.09703138f, -0.12912019f, -0.01146146f, -0.26018739f, -0.05141636f, -0.19769162f, 0.04673762f, 
    -0.07694807f, -0.03938235f, 0.04666822f, 0.06827901f, -0.05525869f, -0.14254767f, -0.02909318f, 0.05811187f, 
    -0.16328938f, -0.06569942f, -0.28107107f, 0.09610818f, 0.10498589f, -0.07211426f, 0.03753857f, 0.11498702f, 
    0.05412217f, 0.14815971f, 0.07212508f, 0.13181382f, 0.38959706f, 0.33657083f, 0.01368344f, -0.13235833f, 
    -0.03420006f, -0.05075890f, 0.04359934f, 0.09744790f, -0.05526487f, 0.05636630f, -0.07478265f, 0.03573579f, 
    0.26800972f, 0.07791977f, 0.20351300f, -0.16942476f, -0.08344591f, 0.06580167f, -0.14745705f, 0.12340236f, 
    0.01170878f, 0.11430746f, -0.00177171f, -0.09059594f, 0.07368312f, -0.21599345f, 0.07490161f, 0.01191398f, 
    -0.09286940f, 0.05261499f, -0.07927364f, -0.08320080f, 0.01672081f, -0.03617841f, 0.01936213f, 0.14004989f, 
    0.01945799f, 0.32198644f, -0.23286963f, 0.35566124f, -0.09086456f, -0.01759989f, 0.06414482f, -0.04231261f, 
    0.16135734f, 0.13188460f, 0.03193622f, 0.03478167f, 0.31881481f, 0.18004873f, 0.01857793f, 0.11184611f, 
    0.13110039f, -0.08521184f, -0.00252542f, -0.08650665f, -0.01724757f, 0.05992713f, -0.03477630f, 0.10925105f, 
    0.04126719f, 0.02350629f, -0.01991337f, 0.07668925f, -0.03792657f, 0.07531110f, 0.21741897f, 0.11692166f, 
    0.03973822f, 0.11316864f, 0.03083245f, 0.08525115f, 0.25654262f, -0.05218893f, 0.01723009f, -0.16121298f, 
    -0.09711855f, 0.02470391f, -0.06305361f, 0.02273580f, -0.12208881f, -0.17372908f, -0.05694164f, -0.09434042f, 
    -0.00582272f, -0.18024403f, 0.11060126f, 0.11772989f, -0.06709016f, -0.00990489f, -0.05750065f, -0.02780314f, 
    0.02495522f, -0.00262201f, 0.09341862f, 0.03512354f, 0.03604452f, 0.20523272f, 0.17966482f, -0.23970725f, 
    -0.02166777f, 0.05395607f, -0.15982132f, -0.02548047f, -0.08376015f, 0.01312073f, 0.07168300f, -0.08579091f, 
    0.08531418f, 0.17658536f, 0.29279834f, 0.26706275f, -0.08169633f, -0.07223350f, -0.02459055f, -0.17961095f, 
    -0.11646803f, -0.16571848f, -0.04206517f, 0.10500502f, -0.09735321f, -0.14610422f, 0.01813778f, 0.13607189f, 
    -0.04440380f, 0.03116651f, 0.11567357f, 0.05768931f, 0.05244223f, 0.10646242f, 0.00279022f, 0.17724250f, 
    -0.00247653f, -0.01048516f, 0.07815706f, 0.14065489f, 0.06457891f, -0.06191399f, 0.08918158f, 0.11293149f, 
    0.06525390f, -0.05126409f, 0.01984225f, -0.04187263f, 0.10164713f, -0.08663798f, 0.04792324f, 0.06975619f, 
    0.05322642f, 0.03657108f, 0.15197815f, 0.00530381f, -0.04262145f, -0.00066460f, -0.13970926f, -0.09518047f, 
    -0.08878796f, 0.01794681f, 0.02017984f, -0.05857033f, -0.10665987f, 0.04967642f, -0.05990417f, -0.05815612f, 
    0.03441001f, -0.02610320f, 0.10936917f, -0.06925842f, -0.10195797f, -0.03432772f, -0.05575893f, -0.10997456f, 
    0.09973154f, -0.00381944f, -0.02794681f, -0.04469008f, -0.04991703f, 0.10468873f, -0.03540544f, -0.05271993f, 
    0.08173681f, -0.03855622f, -0.10950968f, 0.36858121f, -0.06882715f, -0.01565868f, 0.00656915f, -0.06048103f, 
    0.01704536f, 0.00597154f, 0.06575987f, 0.10541483f, 0.05868060f, -0.02058985f, 0.30442026f, 0.03755954f, 
    0.03476170f, 0.02548767f, -0.00244914f, 0.07356056f, -0.03246211f, 0.00223341f, -0.12107204f, 0.04706153f, 
    -0.14010864f, -0.14092518f, -0.09124790f, -0.13226974f, -0.03684734f, 0.01755360f, 0.00012590f, -0.10365885f, 
    0.04705424f, -0.16890836f, 0.02631040f, 0.11372645f, 0.24352671f, -0.35993880f, -0.08337240f, 0.11409901f, 
    -0.04624078f, -0.03192077f, 0.02761056f, 0.00750583f, -0.07068032f, 0.07665888f, -0.08920068f, -0.08727272f, 
    -0.06742224f, 0.16530485f, -0.05174628f, 0.05501509f, 0.09635590f, 0.02734864f, 0.05261676f, 0.04057079f, 
    -0.00093129f, 0.00853686f, 0.04168161f, 0.04865874f, 0.29715437f, 0.16519658f, -0.37484723f, -0.11149833f, 
    0.02363544f, 0.01764763f, -0.00208218f, -0.12733269f, 0.10941890f, -0.02746238f, 0.19964999f, 0.04024371f, 
    -0.09733242f, -0.02802715f, -0.14929976f, -0.18922913f, -0.00418968f, 0.04110057f, -0.04938915f, 0.02437971f, 
    0.03577778f, -0.06544040f, -0.02984118f, 0.01800833f, 0.03343501f, -0.15750316f, -0.04789988f, -0.03778360f, 
    -0.11085419f, -0.08191147f, 0.10905972f, 0.17719014f, 0.03425154f, -0.00658424f, 0.07818903f, 0.03143370f, 
    -0.25724795f, -0.11299679f, 0.04654257f, 0.14052497f, -0.12313997f, -0.06557927f, -0.00594507f, 0.09582496f, 
    0.02540350f, 0.11083192f, 0.11104000f, 0.09569740f, -0.18457954f, -0.15915588f, -0.04941088f, 0.06498425f, 
    -0.02670529f, -0.04562132f, -0.06623407f, -0.04696483f, 0.00470335f, 0.01136671f, -0.08353360f, 0.14202447f, 
    -0.24890955f, 0.01343988f, -0.14680550f, 0.06307707f, -0.08487289f, -0.07212040f, -0.02100194f, 0.05090689f, 
    0.00329633f, -0.02923843f, -0.05054308f, 0.09091593f, 0.05893960f, -0.20670307f, 0.19256718f, -0.01779858f, 
    0.00420243f, 0.00915064f, -0.05706956f, 0.13041033f, 0.00874429f, 0.09643655f, 0.01760659f, 0.05953451f, 
    -0.05072139f, -0.05132390f, -0.10024980f, -0.08657945f, -0.06408422f, -0.02621064f, -0.02568651f, -0.00491470f, 
    0.03343485f, -0.04219754f, 0.17875898f, 0.02748724f, 0.26955861f, -0.12457605f, -0.04996169f, 0.31022099f, 
    0.12100047f, 0.10942540f, 0.16112109f, 0.10809036f, -0.08528805f, 0.01115487f, 0.01771604f, 0.06654671f, 
    -0.07018231f, -0.01933184f, -0.13271621f, 0.02515089f, 0.13621467f, 0.06757706f, -0.01108223f, 0.00056542f, 
    0.00306984f, -0.02484182f, -0.03733096f, 0.09212647f, -0.19117367f, -0.03343081f, 0.21088825f, 0.06604952f, 
    0.01286855f, 0.09838298f, -0.00306504f, 0.01936784f, -0.01844772f, 0.02331187f, -0.07467709f, 0.03420112f, 
    0.14233428f, -0.23223411f, 0.01075793f, 0.17222528f, 0.11640697f, 0.07202314f, -0.05193600f, -0.13743591f, 
    0.09285485f, 0.20698257f, 0.17780273f, 0.08599129f, 0.11367682f, 0.02691107f, 0.00453300f, 0.09047206f, 
    0.18768901f, 0.28042820f, 0.17100102f, 0.05119060f, -0.00465087f, -0.04873062f, 0.00252458f, 0.03197237f, 
    -0.04504915f, -0.02851923f, -0.15492433f, -0.03895547f, 0.04406878f, -0.01587084f, 0.10510946f, -0.01471856f, 
    0.00150062f, 0.00978711f, -0.04337187f, -0.04674650f, -0.16803107f, 0.20301068f, 0.22874583f, 0.14592594f, 
    0.10428003f, 0.17189039f, 0.05620284f, 0.04718303f, 0.01377947f, -0.01852059f, 0.02896083f, -0.09451648f, 
    -0.20251517f, -0.05578875f, -0.07967453f, -0.17219688f, 0.04006586f, -0.01424854f, 0.08223312f, -0.04646299f, 
    0.00307445f, 0.08085079f, -0.04881378f, 0.14119922f, -0.07309015f, -0.00108944f, 0.03889669f, 0.13721369f, 
    0.01156420f, -0.04375387f, 0.04111801f, 0.06143082f, 0.11044061f, 0.00440230f, 0.13566172f, 0.07960939f, 
    0.11815964f, 0.08150166f, -0.11883790f, -0.11466555f, 0.11524774f, 0.07097032f, 0.02732023f, -0.02899443f, 
    0.03729499f, -0.05916961f, -0.04177357f, -0.01663413f, 0.09858178f, 0.03255248f, -0.10434608f, -0.05916940f, 
    0.16713220f, 0.09757037f, -0.16822807f, 0.00651430f, 0.04464456f, -0.09645436f, 0.14281315f, -0.16122141f, 
    -0.24257003f, -0.08082473f, -0.13009563f, 0.05273383f, -0.07441810f, -0.09142869f, 0.11146145f, -0.04445466f, 
    0.08893202f, -0.01320764f, 0.03752921f, -0.02389561f, -0.13804922f, 0.09265392f, -0.11678861f, -0.11134393f, 
    -0.03232229f, -0.01406146f, -0.04366672f, 0.03987260f, -0.08483014f, 0.10833437f, 0.04017578f, -0.06684011f, 
    -0.20436329f, 0.14284851f, 0.10361940f, 0.04151325f, -0.04255638f, -0.02581370f, -0.01115631f, -0.03385935f, 
    0.11021423f, 0.06227576f, -0.04368472f, -0.01038883f, -0.13381875f, -0.09155712f, 0.14498520f, 0.07967174f, 
    0.01139329f, 0.03946874f, 0.02897746f, 0.06765802f, 0.10682946f, 0.02788974f, 0.07274915f, 0.14066173f, 
    0.04206978f, -0.03938895f, -0.00726907f, 0.00912841f, -0.04153538f, -0.02280784f, -0.00833598f, 0.03793888f, 
    -0.04379643f, -0.04456979f, -0.03336390f, 0.02466189f, -0.01406008f, 0.04091004f, 0.02120894f, -0.04115772f, 
    -0.04011258f, 0.04152010f, -0.01461915f, 0.00071098f, 0.01054198f, 0.02136121f, -0.04505177f, -0.03334296f, 
    -0.02797002f, -0.03300072f, -0.03920254f, 0.01690887f, -0.01330228f, 0.00058342f, -0.01889935f, -0.02231445f, 
    0.02509540f, -0.00139227f, 0.01158259f, -0.04455977f, -0.05722580f, -0.05208504f, -0.03904594f, 0.00741560f, 
    -0.05163703f, 0.01974640f, 0.03799899f, -0.00910712f, 0.02634751f, 0.01495289f, 0.02850633f, 0.01018329f, 
    -0.03087063f, -0.02002971f, 0.03456139f, 0.03325206f, 0.02730848f, -0.04083971f, -0.00359235f, -0.03800121f, 
    0.01769187f, -0.03305926f, -0.03684985f, 0.03465687f, -0.02716979f, -0.01564829f, -0.00810082f, 0.00905451f, 
    -0.05420470f, 0.04036789f, 0.01232596f, -0.01569663f, -0.00839416f, -0.01567927f, -0.02041277f, -0.05074686f, 
    -0.02546454f, -0.03743733f, -0.04101631f, -0.03697793f, -0.01154173f, 0.01472292f, -0.04975490f, -0.02170160f, 
    0.00511308f, 0.03377873f, -0.02051448f, 0.03258255f, 0.03414315f, 0.00313125f, -0.01010983f, -0.05434867f, 
    -0.05165974f, -0.04428042f, 0.01051683f, 0.04083717f, -0.01780724f, -0.00786144f, -0.03741065f, 0.01959161f, 
    -0.03904670f, -0.00349055f, -0.05668627f, 0.03537361f, 0.02768154f, -0.02338867f, -0.02897616f, -0.04486196f, 
    -0.00208403f, -0.03057627f, 0.02909196f, 0.00202453f, -0.01762702f, 0.00319309f, 0.00668170f, -0.01586030f, 
    -0.04040229f, -0.00438556f, -0.02071478f, 0.00400156f, 0.02107252f, -0.04386372f, -0.01761565f, -0.04407585f, 
    0.03514231f, 0.00780213f, 0.02458590f, 0.01525525f, -0.01167306f, -0.01061892f, 0.02909922f, 0.01035772f, 
    -0.03193557f, -0.03979290f, -0.03686604f, 0.00299962f, 0.02983351f, 0.03545099f, -0.01939412f, -0.01609762f, 
    0.00352038f, -0.03390987f, -0.00972766f, -0.02739182f, -0.02768291f, -0.01137573f, -0.01621971f, -0.01128978f, 
    0.00325734f, -0.00117866f, 0.02841003f, -0.04984910f, 0.00326828f, -0.02889671f, 0.04432605f, 0.01630439f, 
    0.04276395f, -0.01197300f, 0.00025658f, -0.00900001f, -0.01188926f, -0.02170059f, -0.01910647f, -0.01254466f, 
    -0.00293552f, -0.00967249f, 0.03009604f, 0.00992552f, 0.00004021f, 0.04393472f, -0.00737176f, -0.01449800f, 
    0.00666149f, 0.00772313f, -0.01549674f, 0.02293228f, 0.03912303f, -0.01195602f, 0.01461835f, -0.01216898f, 
    0.00661199f, -0.05813742f, -0.00127032f, 0.00518123f, 0.01717930f, -0.04074715f, 0.03496465f, -0.03884986f, 
    0.04290915f, 0.03978236f, -0.05230410f, -0.04684196f, 0.03565093f, -0.02063155f, 0.01427270f, -0.03798525f, 
    -0.05618772f, 0.00125640f, 0.03058978f, 0.03965798f, -0.01188561f, 0.01124521f, -0.04852185f, -0.03681291f, 
    -0.03051798f, 0.01680023f, 0.00972672f, -0.05217327f, -0.03134476f, -0.04529019f, -0.03502132f, 0.02920425f, 
    -0.05299424f, 0.02187880f, -0.01487617f, 0.01809572f, -0.01397625f, 0.03252412f, 0.02306765f, 0.03733837f, 
    -0.05327874f, 0.04413804f, -0.04273089f, 0.03628374f, -0.02763018f, -0.00790853f, 0.03985243f, 0.00247651f, 
    0.02145992f, -0.05278477f, 0.00148739f, -0.04061921f, -0.02214295f, 0.03677724f, -0.04218051f, 0.01641880f, 
    -0.00886742f, 0.02244588f, -0.01927575f, 0.01280299f, -0.04290513f, -0.02299130f, -0.00593060f, -0.02237994f, 
    -0.03573738f, 0.01517235f, -0.04386394f, 0.01645259f, -0.05217845f, -0.03738465f, 0.03086718f, -0.04056860f, 
    -0.03579002f, -0.03326098f, -0.01429274f, -0.01030913f, -0.03903545f, -0.01407186f, -0.02340332f, 0.00595478f, 
    0.00333994f, -0.05537147f, 0.00865432f, 0.03011605f, 0.00842956f, 0.02729627f, -0.02075625f, -0.02944179f, 
    -0.00852221f, -0.01903148f, 0.04393649f, -0.01583032f, 0.00473653f, 0.02049162f, -0.03873686f, 0.00831826f, 
    0.00243733f, 0.03471811f, -0.02051629f, -0.00877502f, -0.04648276f, -0.04245298f, 0.04081958f, -0.03709831f, 
    -0.01652093f, 0.02742177f, 0.02205116f, 0.02534213f, -0.00187812f, -0.00197959f, -0.01574136f, 0.02933211f, 
    -0.02066280f, -0.00310300f, -0.01503173f, -0.03954046f, -0.02403012f, -0.00350335f, -0.04142724f, -0.01018461f, 
    -0.03586025f, -0.05803011f, 0.03199091f, -0.04410938f, -0.03146909f, 0.00485793f, -0.02451218f, 0.02749841f, 
    0.03935133f, -0.00209448f, -0.02246854f, 0.01959735f, -0.02114118f, 0.01802078f, -0.04917519f, -0.05110668f, 
    -0.05262417f, -0.05198508f, 0.02869046f, 0.01738271f, 0.02670958f, -0.02877668f, -0.02658571f, -0.05703458f, 
    0.02289233f, 0.02546826f, 0.00770855f, -0.03848182f, -0.01419492f, -0.01876966f, 0.00911176f, 0.04387754f, 
    0.03344824f, 0.02555539f, 0.03586446f, -0.00834615f, 0.01412736f, -0.05634519f, 0.04396484f, 0.01917583f, 
    0.01414691f, -0.03801474f, 0.01830201f, 0.00173053f, -0.05643095f, -0.02335761f, -0.05630466f, 0.03263002f, 
    -0.03498995f, 0.03520223f, -0.00989729f, -0.05393771f, -0.00012752f, 0.03326166f, 0.01393099f, -0.03740842f, 
    -0.01430704f, -0.02780034f, 0.01867462f, 0.04246397f, -0.00428449f, -0.03357776f, -0.02351837f, -0.01523456f, 
    0.00426871f, -0.05356563f, 0.01254628f, 0.04299624f, 0.00208402f, -0.05183085f, -0.00853109f, 0.03358905f, 
    -0.01464515f, 0.02864640f, -0.05353793f, -0.04725881f, 0.00352590f, 0.00880781f, -0.00787635f, 0.00661349f, 
    0.00623397f, -0.00025127f, 0.04008133f, -0.02045425f, -0.01611629f, -0.00345091f, 0.01717612f, -0.01201470f, 
    0.08602965f, 0.04116185f, 0.25282097f, 0.33832887f, 0.08123069f, 0.13806649f, -0.04572366f, 0.18073730f, 
    -0.15017827f, 0.07540388f, 0.14641602f, 0.07647847f, 0.01490044f, 0.01974068f, 0.04812174f, 0.06040100f, 
    -0.08147936f, -0.05653345f, 0.03159161f, 0.01009095f, 0.06774361f, -0.03229664f, 0.03469072f, -0.03523182f, 
    0.06100915f, 0.02618341f, 0.03792655f, 0.18440683f, 0.04594992f, 0.11339168f, 0.02425550f, 0.04935211f, 
    -0.08771721f, -0.00406362f, 0.20113982f, 0.14030811f, 0.08922785f, 0.12519011f, 0.01522443f, -0.06150612f, 
    0.00977032f, 0.08619861f, 0.00941046f, -0.02974672f, 0.17048337f, -0.00531184f, -0.01680245f, 0.01259296f, 
    0.01856889f, -0.01307954f, -0.10924384f, 0.22046006f, -0.12108354f, -0.02216573f, -0.01431780f, -0.20935686f, 
    -0.02928802f, -0.00959430f, -0.09222111f, -0.00040787f, -0.03790800f, -0.05947550f, 0.30343324f, -0.04420288f, 
    -0.02228637f, 0.00185556f, -0.03659262f, -0.05438545f, -0.07869195f, -0.06467760f, 0.01506167f, -0.05675535f, 
    0.09051086f, 0.08290631f, 0.16388138f, -0.01692645f, 0.05573992f, 0.08800741f, 0.03940391f, 0.06058249f, 
    0.01631901f, 0.04051439f, -0.01876698f, -0.02852264f, 0.26129979f, 0.05640267f, -0.01538197f, -0.04469452f, 
    -0.07151598f, -0.00336578f, -0.11318430f, -0.20920715f, -0.06290166f, -0.09652876f, 0.01792198f, -0.02515406f, 
    -0.25144219f, -0.21397254f, -0.03545161f, 0.12377683f, -0.01537233f, -0.09266733f, -0.03091912f, 0.03432717f, 
    -0.17310491f, 0.07138816f, 0.02657410f, -0.06352790f, 0.36446667f, 0.08166896f, -0.00677511f, -0.12072326f, 
    0.00198888f, -0.09025795f, 0.01277910f, -0.06662985f, 0.05122617f, -0.13033798f, 0.13828725f, 0.12307405f, 
    0.17608523f, 0.15121058f, 0.16493051f, -0.08416827f, 0.00898016f, 0.02476067f, 0.09234717f, 0.02093815f, 
    0.06735971f, -0.01903346f, -0.01248100f, 0.10773250f, 0.10210192f, 0.05605272f, -0.14124233f, -0.16959345f, 
    -0.05457344f, -0.14300820f, 0.12624116f, 0.08480900f, -0.02563231f, -0.03221308f, -0.07034437f, 0.06776249f, 
    -0.09539550f, -0.16873562f, -0.06911669f, 0.16350472f, -0.00641314f, 0.08770856f, -0.02902343f, 0.15582645f, 
    -0.09685847f, -0.04951965f, -0.03102427f, 0.01673150f, 0.00260021f, -0.03629438f, -0.08769836f, 0.20301889f, 
    0.08242926f, 0.12478089f, 0.08704294f, 0.09004909f, -0.06206727f, 0.01342103f, 0.03732422f, 0.05258485f, 
    -0.11299922f, -0.00425578f, 0.00489168f, 0.18674976f, -0.01559714f, -0.13014150f, 0.02110248f, -0.00239498f, 
    -0.01991670f, 0.05614031f, -0.02173460f, -0.06158979f, -0.29641783f, 0.00915319f, -0.35420844f, -0.13697048f, 
    0.04201022f, 0.03680721f, -0.05554943f, -0.02473255f, -0.08051431f, -0.04804994f, -0.16074528f, -0.02245783f, 
    0.11363429f, 0.10375110f, -0.03564373f, -0.06094246f, 0.03549487f, -0.00532136f, 0.03034446f, -0.01967992f, 
    0.13040026f, 0.08847633f, -0.09628088f, -0.04744060f, 0.06999104f, -0.01921391f, 0.03757186f, 0.13545629f, 
    -0.08314088f, -0.17559280f, -0.05510376f, 0.00583646f, 0.09404935f, 0.09185238f, -0.08440088f, 0.06390698f, 
    0.18722960f, -0.04109087f, -0.13955192f, -0.06933676f, -0.16594358f, -0.16373253f, 0.06263963f, -0.00693196f, 
    0.05306108f, 0.04428058f, 0.02503907f, 0.00406670f, -0.13768761f, -0.08017755f, 0.10469204f, 0.24818684f, 
    -0.13355255f, -0.00589286f, -0.11682196f, -0.08198461f, -0.06019908f, -0.06072254f, -0.08021402f, 0.01358574f, 
    0.06512866f, -0.04471871f, -0.02371654f, 0.08487286f, 0.05776720f, 0.20343037f, -0.16845481f, -0.27170187f, 
    -0.15125760f, -0.03272928f, 0.22714178f, 0.22426276f, 0.24532916f, 0.17464612f, 0.21256605f, 0.17364706f, 
    -0.18652052f, 0.01468509f, 0.04824332f, -0.07032302f, 0.11516308f, 0.05662349f, 0.03550732f, -0.03227656f, 
    0.05670926f, 0.12717672f, 0.09936219f, 0.04799750f, -0.06507442f, -0.01249417f, 0.09129399f, -0.02737498f, 
    0.04450174f, 0.13203958f, 0.02529371f, -0.06481227f, -0.04385847f, 0.07813927f, 0.15484335f, 0.28457072f, 
    -0.03964391f, -0.05278851f, 0.09677360f, 0.09094396f, 0.03009056f, -0.03950980f, 0.08352584f, -0.02647036f, 
    -0.11638957f, 0.25530571f, 0.08783220f, -0.16331013f, 0.00724365f, 0.05010849f, 0.02689155f, -0.01375812f, 
    0.10337637f, 0.00978571f, 0.06045758f, -0.05130682f, 0.49273321f, -0.10438482f, -0.18061358f, -0.23026830f, 
    -0.04971996f, 0.00843237f, 0.00688194f, 0.01656294f, 0.11520530f, 0.07157953f, -0.11485985f, -0.02041685f, 
    -0.00879074f, 0.17915541f, 0.14192350f, -0.12711087f, -0.01916321f, 0.15828221f, 0.06794269f, 0.08601564f, 
    0.02501259f, 0.23857050f, -0.12560229f, -0.11452992f, 0.12641415f, 0.14532633f, 0.00441959f, 0.19075544f, 
    -0.04510546f, 0.14089704f, -0.00266048f, -0.04542437f, 0.02361752f, 0.00228219f, -0.06173768f, -0.12346871f, 
    -0.01541559f, -0.13702501f, -0.06743302f, 0.16787529f, -0.07437444f, -0.15143149f, 0.03072338f, -0.05355480f, 
    -0.06343563f, 0.03679175f, -0.00499665f, 0.10040998f, 0.06446873f, 0.08368389f, 0.25137085f, 0.13898498f, 
    -0.00364650f, 0.06334215f, 0.01501019f, -0.03243062f, 0.02311133f, 0.01051749f, 0.03239209f, -0.08219159f, 
    0.02530974f, 0.04435808f, -0.02472516f, 0.03083340f, 0.07020707f, 0.02624050f, 0.07449939f, 0.02485896f, 
    0.04336918f, 0.04955316f, 0.06544898f, 0.05024021f, 0.03620051f, 0.04292736f, -0.02125216f, 0.22751367f, 
    0.00741901f, -0.15292037f, 0.01271945f, 0.12146934f, -0.01205287f, 0.04510103f, -0.03247824f, 0.01872456f, 
    0.11458336f, -0.04535647f, 0.00376606f, 0.04239495f, 0.01196752f, 0.02633204f, 0.03078745f, 0.03734377f, 
    -0.00486683f, -0.01153081f, 0.07864211f, 0.05560604f, 0.00107794f, -0.02801859f, -0.06533055f, -0.07411709f, 
    0.05116708f, 0.05751042f, -0.01387300f, 0.12180525f, 0.02455834f, 0.03178407f, 0.09858574f, 0.02766538f, 
    -0.13111947f, 0.01276474f, 0.03981764f, -0.24445464f, 0.01851561f, 0.01761715f, 0.04782272f, 0.03695556f, 
    0.07391218f, -0.04664362f, 0.10527828f, 0.01206987f, -0.10662422f, -0.01126445f, -0.14242497f, -0.16266054f, 
    -0.01323470f, -0.03392473f, -0.13680987f, 0.04143186f, -0.00813260f, 0.02907574f, -0.10044060f, 0.09873040f, 
    0.07285786f, 0.00285064f, 0.09179623f, 0.24053109f, 0.20450348f, 0.06989191f, -0.05535972f, 0.02418930f, 
    -0.03769043f, 0.14381875f, -0.01669669f, 0.03822906f, 0.20583196f, 0.07442119f, 0.10799246f, -0.05419073f, 
    -0.06967839f, 0.08339942f, 0.19467589f, 0.01340965f, 0.08090428f, 0.02831727f, 0.09732678f, 0.08398442f, 
    -0.16009733f, -0.12236406f, -0.04794534f, -0.10750025f, -0.07464671f, -0.16159755f, -0.06678399f, -0.04149775f, 
    0.11026075f, 0.12170964f, -0.06803824f, 0.07700834f, 0.06095105f, 0.03465436f, -0.22663997f, -0.01278277f, 
    0.06829992f, 0.04721569f, 0.03799715f, 0.04939977f, 0.04704097f, 0.08621068f, 0.09011170f, 0.06878087f, 
    0.02531947f, 0.03444070f, 0.11920977f, -0.06335276f, 0.00152787f, 0.13789356f, -0.00277035f, -0.09692890f, 
    0.08095244f, -0.02847739f, 0.01221795f, 0.05744706f, -0.00313606f, -0.14056259f, -0.16138113f, -0.01875331f, 
    0.11392260f, -0.01062873f, -0.12942258f, -0.04558904f, 0.06507315f, 0.02360780f, -0.11203648f, -0.17420636f, 
    -0.08524888f, -0.10119247f, -0.00977711f, -0.19435391f, -0.00249539f, -0.16485178f, -0.07061598f, 0.06645361f, 
    0.03403872f, 0.04077904f, -0.02075003f, 0.06644093f, -0.09778374f, 0.07075554f, 0.06464200f, 0.15141542f, 
    0.07383906f, 0.01980550f, -0.04341330f, -0.09790336f, -0.02573564f, 0.00531949f, -0.08307959f, -0.13280374f, 
    -0.15680958f, 0.03162238f, 0.18823238f, 0.08751230f, -0.04025379f, -0.05565356f, 0.03653608f, 0.12444502f, 
    0.14362450f, 0.07538822f, 0.07190421f, 0.04838829f, 0.04358676f, -0.13433476f, 0.37650406f, 0.08376932f, 
    -0.06180759f, 0.02826796f, 0.09849557f, 0.10627455f, 0.25795016f, -0.09524204f, -0.00981473f, -0.12047794f, 
    0.03793130f, 0.05031300f, 0.31082529f, 0.03200743f, -0.06970708f, 0.05585390f, 0.10019460f, -0.13017572f, 
    0.16219801f, -0.03210285f, 0.02979138f, -0.09046779f, 0.33675712f, -0.14093198f, 0.06591339f, 0.06123422f, 
    -0.07987966f, 0.07472288f, -0.00727890f, -0.03236463f, 0.03700030f, -0.07184283f, -0.16894203f, 0.02905823f, 
    -0.28648439f, -0.04277621f, -0.03366921f, -0.16959068f, 0.00838107f, -0.10778697f, -0.16544493f, -0.01234305f, 
    0.05052651f, 0.06900465f, -0.02476837f, 0.11273105f, -0.22114073f, 0.03637230f, -0.01500136f, -0.07633574f, 
    0.16331083f, 0.08981461f, -0.06619266f, -0.03008319f, 0.02117753f, -0.05480054f, 0.06212249f, -0.01154095f, 
    -0.11112202f, 0.11828945f, 0.02297725f, 0.11767232f, -0.08991307f, -0.03244773f, 0.07010609f, 0.03886470f, 
    0.00332794f, -0.01218549f, 0.11486536f, 0.01947590f, 0.11014734f, -0.09106509f, 0.06213936f, 0.09385819f, 
    -0.06387855f, -0.04001976f, 0.05295533f, 0.01011013f, 0.14456677f, -0.03941664f, -0.03071424f, 0.00753149f, 
    -0.10752279f, 0.04770666f, 0.03133914f, 0.08217992f, 0.09069212f, 0.04922396f, 0.06959081f, 0.02429359f, 
    0.08472613f, 0.06426683f, 0.11889133f, 0.06349949f, -0.12611391f, 0.27638716f, -0.12026402f, 0.05539665f, 
    0.05407760f, -0.17428298f, -0.07297337f, -0.03381703f, -0.03363337f, -0.06143850f, -0.08233168f, -0.03788875f, 
    -0.12382001f, -0.05263127f, -0.01116236f, -0.15980172f, 0.04239986f, -0.07946125f, -0.15355967f, -0.07308578f, 
    0.04178021f, 0.01387434f, -0.03836689f, 0.05586264f, -0.04950165f, 0.06957127f, -0.10138570f, -0.44274315f, 
    0.06354846f, -0.07762395f, -0.00309992f, -0.01620029f, 0.03219782f, -0.00848418f, -0.05588236f, -0.03679103f, 
    0.61698288f, -0.37559587f, -0.01627094f, -0.03673448f, -0.09529682f, 0.00996997f, -0.13552667f, -0.07294598f, 
    0.11945053f, 0.05284454f, -0.01956367f, 0.13689935f, -0.22063629f, 0.01410149f, -0.14778684f, 0.08444127f, 
    -0.05759049f, -0.03837236f, -0.04206550f, -0.04215458f, 0.05779079f, 0.07162448f, -0.04333441f, 0.09448757f, 
    0.04833102f, 0.00284595f, -0.03143505f, -0.02337143f, 0.00486668f, -0.07820304f, -0.05948458f, -0.02814128f, 
    -0.02384459f, -0.00842901f, 0.06532949f, 0.14531280f, -0.15269788f, -0.11919382f, -0.02013188f, 0.10233207f, 
    0.19792032f, -0.08922888f, 0.02144911f, -0.05753876f, 0.06144971f, -0.01278470f, 0.11731306f, 0.07637731f, 
    -0.03392566f, 0.04592827f, 0.23821402f, 0.13261788f, 0.06817785f, 0.00333025f, 0.01328735f, 0.04704296f, 
    0.04244157f, -0.05984143f, -0.08016957f, -0.04044446f, -0.13863674f, -0.14496914f, -0.15879053f, 0.07858536f, 
    0.03387439f, -0.03494320f, -0.05389411f, -0.03112707f, -0.00359715f, -0.01108892f, -0.06866670f, -0.12221376f, 
    -0.11855338f, 0.06876979f, -0.08331827f, 0.01732271f, 0.02653218f, -0.01794103f, 0.03272857f, 0.02338946f, 
    0.05932239f, 0.00811199f, 0.11454769f, -0.00296376f, 0.18124475f, -0.10232437f, 0.16501133f, 0.16258323f, 
    -0.02087606f, 0.05616424f, 0.12588026f, 0.07551131f, -0.11521809f, -0.14924262f, -0.05704048f, -0.05413135f, 
    0.05861767f, 0.02840292f, -0.04219841f, 0.08110130f, 0.13761765f, 0.23163158f, 0.10395713f, 0.07563479f, 
    -0.02810029f, 0.05626702f, 0.10947694f, -0.00546111f, -0.01291577f, 0.14372970f, 0.03280772f, -0.00441429f, 
    -0.08122729f, 0.04377148f, 0.10700306f, 0.01023748f, 0.02065643f, -0.02323907f, 0.07385584f, -0.02239049f, 
    -0.13105695f, -0.17324640f, -0.11742191f, 0.20026606f, -0.07419442f, 0.08723449f, -0.10315980f, -0.08738500f, 
    -0.02508029f, -0.03241740f, -0.00655519f, 0.02888191f, 0.13327493f, 0.15799418f, 0.14997613f, 0.06792525f, 
    -0.05218270f, -0.17605320f, -0.03638715f, -0.03962287f, -0.03733668f, -0.01947725f, 0.02725826f, 0.04263569f, 
    0.00010276f, 0.16386579f, 0.46142581f, 0.01507779f, 0.11810499f, 0.04583238f, -0.01422422f, 0.13730350f, 
    0.01099918f, 0.00469449f, -0.03441897f, 0.11732882f, 0.02895805f, 0.21312107f, 0.02949462f, 0.05781697f, 
    0.11361855f, 0.17443600f, 0.04916446f, 0.10237344f, 0.00239257f, 0.00060852f, 0.03981584f, -0.04437150f, 
    0.08241431f, -0.01660418f, 0.11258695f, 0.05627660f, -0.08543704f, -0.09671634f, -0.09238530f, -0.02945250f, 
    -0.06477363f, -0.00898591f, 0.10133709f, -0.03116384f, 0.19526877f, 0.19548586f, 0.29893339f, -0.22057244f, 
    0.11193290f, 0.13734826f, -0.00572842f, -0.08214135f, -0.01691697f, -0.07390064f, 0.07384507f, 0.01455797f, 
    -0.32180482f, -0.42611456f, -0.25910488f, -0.02072137f, -0.04554697f, -0.01979324f, 0.06289513f, 0.17738126f, 
    -0.00107713f, 0.03633246f, -0.13986862f, 0.05581527f, 0.06925859f, 0.01595385f, 0.30498353f, 0.23429458f, 
    0.07773916f, 0.11622635f, -0.04200376f, -0.02009714f, -0.08812965f, -0.06581316f, -0.10636587f, 0.06713810f, 
    0.04898098f, 0.16011700f, 0.08395935f, 0.00407515f, -0.04784251f, -0.11482081f, -0.07290532f, -0.07594843f, 
    0.02695035f, 0.01409325f, 0.05330223f, 0.00375467f, 0.03354783f, -0.09953438f, 0.06023439f, -0.08078601f, 
    0.08854718f, -0.02584711f, -0.03177674f, 0.08765772f, -0.04188678f, -0.02769347f, 0.05311530f, 0.03060268f, 
    0.23243806f, 0.28368694f, 0.07020161f, -0.08231124f, 0.15169784f, 0.14105430f, -0.07998289f, 0.12925369f, 
    0.00825851f, -0.01457932f, -0.06048073f, -0.06880552f, 0.02591947f, 0.14275233f, 0.07877330f, -0.19235125f, 
    0.14035314f, 0.10167075f, 0.11230197f, 0.05066133f, 0.01271725f, -0.02073732f, 0.04178246f, 0.08250587f, 
    0.22140045f, -0.01271139f, -0.08513061f, 0.07128659f, 0.10543265f, 0.07395958f, 0.06540063f, 0.06632228f, 
    -0.02330091f, 0.06146863f, 0.01739279f, 0.00712125f, 0.04204632f, 0.07015146f, -0.06150971f, -0.03108468f, 
    0.04517171f, 0.04462707f, -0.01551189f, -0.13525291f, 0.04538436f, -0.00486347f, -0.13770862f, 0.04419795f, 
    -0.03860095f, -0.00169184f, 0.13690276f, 0.00601785f, -0.06425186f, -0.00152514f, -0.07463946f, -0.05532972f, 
    0.06201705f, -0.10877199f, -0.04437554f, -0.04810474f, -0.00791063f, -0.08975592f, 0.32957900f, 0.04055633f, 
    -0.02497372f, -0.00523294f, -0.11068491f, 0.21609093f, -0.04127217f, -0.04267812f, 0.06946261f, -0.14456214f, 
    -0.07701085f, -0.28790557f, -0.05616656f, -0.22175193f, 0.09199405f, 0.16936548f, 0.10084419f, 0.07991142f, 
    0.00705941f, 0.10428589f, -0.01756401f, 0.03047359f, 0.28029373f, 0.33940297f, -0.04733812f, -0.23836544f, 
    0.21197143f, 0.10530823f, 0.05120049f, 0.11550748f, 0.04697268f, 0.05333534f, 0.05586949f, 0.03300362f, 
    0.10794383f, 0.17415197f, 0.29381579f, -0.00906675f, 0.01750676f, -0.00628039f, 0.02451873f, 0.18987410f, 
    0.08573892f, -0.13596480f, -0.04426185f, -0.07135370f, 0.05488289f, 0.14544024f, 0.26363376f, 0.02070266f, 
    -0.05596123f, -0.11173604f, -0.10403933f, -0.04537591f, -0.07561791f, 0.02889797f, -0.04205494f, -0.03423454f, 
    0.02800918f, 0.11480813f, 0.07403492f, 0.10132012f, -0.02682953f, -0.05532795f, -0.18280993f, -0.04889811f, 
    -0.06246612f, -0.11392674f, -0.04254872f, -0.03492461f, 0.24743536f, 0.39043489f, -0.01708202f, 0.22108224f, 
    -0.01329527f, 0.01089067f, 0.08928489f, 0.18083598f, -0.01613332f, -0.06902693f, -0.04763175f, -0.04142476f, 
    0.10503397f, 0.18023357f, 0.11376578f, 0.07687182f, -0.08585142f, -0.02619360f, -0.07881714f, -0.05849743f, 
    -0.13043331f, 0.05407936f, -0.15596686f, -0.07462117f, 0.30882385f, -0.37074259f, -0.35889632f, -0.38092455f, 
    -0.02960235f, 0.02410392f, -0.04592209f, -0.06207521f, 0.02232031f, -0.06952405f, -0.00787878f, -0.01340692f, 
    0.06349386f, -0.01741020f, 0.09699327f, 0.09034566f, -0.09502760f, -0.04064354f, -0.04215297f, 0.01553296f, 
    -0.06355350f, 0.06982568f, 0.16821052f, 0.02619760f, 0.01475887f, -0.04335103f, 0.05714395f, 0.18897152f, 
    -0.11295187f, -0.04797264f, -0.00811383f, -0.05547667f, 0.03740114f, -0.03417661f, 0.03131852f, 0.14420919f, 
    0.17415798f, 0.16640073f, -0.04512427f, -0.00504549f, 0.11078725f, 0.03545080f, 0.05454035f, 0.11914027f, 
    -0.02908833f, 0.03994695f, -0.04194008f, 0.02025254f, 0.14895727f, 0.20327359f, 0.14559583f, 0.13630131f, 
    0.01686645f, -0.05923401f, -0.05226968f, -0.00170268f, 0.00304699f, -0.08063480f, 0.04275006f, 0.04982470f, 
    0.03200828f, -0.37373331f, -0.14833266f, -0.13185911f, -0.04559613f, 0.09483016f, 0.06111161f, 0.06373914f, 
    0.13535243f, 0.15706243f, -0.02642851f, -0.05345731f, 0.09716173f, -0.03280498f, -0.13779727f, -0.04461703f, 
    0.06092314f, -0.00088790f, -0.01893334f, 0.10035500f, 0.01977465f, 0.02983735f, 0.04714954f, -0.10601386f, 
    -0.04107539f, -0.11331196f, -0.14564857f, -0.03713126f, 0.16003425f, 0.01602621f, 0.04060093f, -0.07525178f, 
    -0.04397507f, 0.08934117f, -0.08400434f, 0.04494577f, 0.04592789f, -0.17143375f, -0.02967943f, -0.03846166f, 
    -0.07197549f, 0.02009706f, 0.04855500f, -0.11915993f, 0.08470176f, 0.10740470f, 0.00936086f, 0.12881483f, 
    -0.09410420f, 0.02130417f, -0.18339291f, -0.17689776f, -0.13744098f, -0.04354024f, 0.02467181f, -0.14486165f, 
    0.15194808f, 0.05227591f, 0.01173792f, 0.04553287f, 0.06227075f, 0.05960310f, -0.11793441f, 0.01091272f, 
    0.08426926f, -0.15817709f, -0.02861034f, -0.07400916f, -0.07779644f, -0.02574991f, -0.04945636f, 0.07701918f, 
    0.11246401f, -0.00946136f, 0.13563797f, 0.14240299f, 0.13279459f, 0.19176653f, 0.12965161f, 0.23168968f, 
    0.05792027f, 0.03737728f, 0.05526703f, 0.07427189f, 0.02613848f, -0.02625634f, -0.00033912f, 0.02465228f, 
    0.11395039f, 0.08550282f, 0.00629652f, 0.08629553f, 0.05869239f, 0.10431378f, 0.11306569f, 0.10180333f, 
    -0.21070907f, -0.10841384f, 0.03834078f, -0.04997733f, -0.09497757f, -0.13723518f, -0.21556425f, -0.20390706f, 
    0.03429716f, -0.13011739f, 0.14834496f, 0.18550964f, 0.26716974f, -0.42145360f, -0.07064364f, 0.03118813f, 
    -0.00170086f, -0.03858333f, 0.00749515f, -0.05307757f, 0.17669228f, 0.10324895f, 0.03701784f, 0.07817796f, 
    0.10646531f, 0.02379882f, -0.13352519f, 0.05733696f, -0.06987155f, 0.05185085f, 0.08435182f, 0.13878976f, 
    0.18730801f, -0.08648299f, 0.06040075f, -0.03356069f, -0.15283543f, 0.17343782f, -0.13632458f, 0.00495568f, 
    0.00177772f, 0.03138386f, -0.00264366f, 0.03453613f, -0.00021982f, 0.02238596f, -0.00273921f, -0.15302861f, 
    -0.08017834f, -0.07484735f, 0.04690122f, -0.14539021f, -0.10160600f, -0.01888288f, -0.10670934f, -0.07897785f, 
    0.03869160f, 0.02364314f, 0.04663942f, 0.04153649f, 0.06416878f, -0.17595404f, -0.01473569f, -0.02782563f, 
    0.03482136f, -0.06825652f, 0.14499129f, 0.10850579f, -0.04157254f, -0.06205747f, 0.05631069f, -0.33577928f, 
    -0.02104941f, 0.07695008f, 0.09578388f, -0.09717900f, 0.02530577f, -0.04232127f, 0.01745274f, 0.17007233f, 
    0.04159563f, 0.00282324f, 0.06598103f, 0.10711437f, -0.19356327f, 0.00977129f, -0.04873638f, -0.20791402f, 
    -0.00882353f, -0.05189101f, -0.02984853f, 0.15029085f, 0.04774465f, -0.01330087f, -0.01864581f, 0.09273165f, 
    -0.12149724f, 0.08894151f, -0.21188943f, -0.07372344f, 0.12774651f, 0.17702937f, 0.02823438f, 0.12113728f, 
    -0.07674210f, -0.03986410f, -0.04416553f, 0.17034255f, 0.28638384f, -0.01172938f, 0.33784637f, 0.07946791f, 
    0.04841926f, -0.01369174f, 0.09296544f, -0.00670195f, 0.24143426f, 0.09739976f, 0.25526741f, -0.04672091f, 
    -0.01478438f, 0.04627513f, 0.06218213f, -0.14359835f, -0.03688644f, -0.08010260f, 0.03429082f, -0.07058544f, 
    -0.03408478f, -0.01957067f, 0.15526265f, 0.04154523f, 0.00677964f, 0.23376559f, -0.03987089f, 0.06582824f, 
    0.06191974f, 0.05895303f, 0.06404065f, 0.07146825f, -0.02546594f, 0.07077981f, 0.05393982f, 0.03786563f, 
    -0.08168619f, -0.24287823f, -0.21025538f, 0.08059642f, 0.10368405f, 0.13719603f, 0.04237629f, 0.18306243f, 
    -0.00770698f, 0.03171083f, 0.02498620f, 0.05202074f, 0.06736946f, 0.05759457f, 0.03480500f, -0.03568149f, 
    0.20756944f, 0.22234884f, 0.07720568f, 0.12914644f, -0.01477481f, 0.08044478f, 0.04762241f, -0.02444704f, 
    0.23906450f, -0.04119524f, 0.11294689f, 0.05345139f, 0.04955573f, 0.09697922f, 0.11060788f, -0.00244313f, 
    0.10498808f, 0.19518477f, -0.03892726f, -0.02512606f, -0.28557435f, -0.37082446f, -0.17626201f, 0.13885833f, 
    0.14251485f, 0.11646860f, 0.16658968f, 0.05520662f, -0.07780681f, -0.09984304f, -0.05778121f, -0.03951933f, 
    -0.17729975f, 0.00185174f, 0.02302430f, 0.09297159f, -0.03305493f, -0.02877348f, 0.01606937f, -0.02953230f, 
    -0.11008329f, -0.07137592f, 0.02777726f, 0.05721088f, -0.14109910f, 0.19792509f, 0.07534818f, -0.04893254f, 
    0.03658783f, 0.09228970f, 0.05495664f, 0.02795102f, -0.06759100f, 0.00914258f, 0.02477588f, -0.09385310f, 
    0.02198204f, -0.03025822f, 0.22366515f, 0.05321738f, 0.09770040f, -0.03756283f, -0.00628199f, 0.02378985f, 
    -0.03105099f, -0.02442771f, 0.00937757f, -0.05256692f, -0.13247594f, -0.20649858f, -0.10776724f, -0.04596444f, 
    -0.07480938f, -0.05178221f, -0.06005448f, 0.01086459f, 0.06840231f, -0.00726475f, 0.18187925f, 0.06709266f, 
    0.12177911f, 0.15330000f, -0.01541487f, 0.05792600f, 0.04596950f, -0.02286672f, 0.00127262f, -0.01168081f, 
    0.08334980f, 0.04311275f, 0.23546989f, 0.01471406f, -0.06930271f, 0.07418159f, -0.09244464f, -0.06332090f, 
    0.06940846f, 0.00155038f, -0.04592534f, -0.01458081f, 0.12916301f, 0.20843031f, 0.10700514f, 0.03922577f, 
    -0.10124248f, 0.10227713f, -0.08113323f, -0.13498883f, 0.04264394f, 0.01368806f, 0.13493371f, 0.11738300f, 
    -0.06153211f, 0.02398187f, -0.04977059f, -0.07204357f, 0.02118035f, 0.02371746f, -0.11791583f, 0.13440219f, 
    -0.11487677f, 0.01783452f, -0.09969991f, 0.04074624f, 0.01576601f, -0.03208239f, -0.00711069f, 0.15709415f, 
    -0.27412391f, -0.31389737f, -0.09037645f, -0.19481458f, 0.00137935f, -0.04084492f, -0.08876608f, 0.02702043f, 
    0.07738500f, 0.16270304f, 0.10448351f, -0.01313469f, -0.10404857f, -0.05267021f, 0.04299236f, -0.13015138f, 
    -0.00762929f, -0.02757347f, -0.01340315f, 0.06642112f, 0.04820215f, -0.04121518f, 0.06067494f, -0.14562726f, 
    -0.03492754f, -0.04294828f, -0.02230820f, 0.02635316f, -0.03940881f, -0.05215848f, -0.05174401f, -0.01781723f, 
    0.01475706f, 0.03084412f, -0.00545795f, 0.02814463f, -0.01473676f, 0.02329413f, 0.02811088f, -0.02790588f, 
    0.00758846f, 0.02983727f, -0.01327919f, 0.03176888f, -0.04402553f, 0.02940202f, -0.02123945f, 0.02707950f, 
    -0.03404164f, 0.03579267f, 0.00870106f, 0.00584707f, 0.04005706f, -0.00502224f, -0.00312817f, -0.04446205f, 
    -0.03922592f, -0.05410994f, -0.04552002f, 0.02405779f, -0.03274893f, 0.01493299f, -0.01059901f, -0.04942611f, 
    0.01126882f, 0.01196150f, -0.04346946f, -0.01085253f, 0.02250229f, 0.02904618f, -0.03040664f, 0.04064619f, 
    0.04268370f, 0.03779633f, 0.00954762f, -0.04358852f, -0.03542955f, 0.02696167f, -0.05481950f, -0.03621696f, 
    0.00871542f, 0.03362841f, -0.03501790f, 0.03439704f, -0.04195937f, -0.01184127f, 0.04072724f, 0.00998196f, 
    -0.02304262f, -0.03951780f, -0.03688004f, -0.03543599f, 0.03576136f, 0.01314107f, -0.05568648f, -0.02677796f, 
    0.00149630f, 0.00052099f, -0.04558662f, 0.03932987f, -0.01137451f, 0.01731075f, -0.02128407f, -0.05171868f, 
    -0.02505496f, -0.04029648f, -0.02685643f, 0.02603837f, -0.00283165f, 0.02900414f, -0.03776291f, 0.01729705f, 
    -0.03913276f, 0.03174241f, -0.00380113f, 0.00395633f, -0.05261378f, -0.02827986f, -0.02524162f, -0.04161547f, 
    0.02809855f, -0.03064046f, -0.01788561f, -0.01733494f, -0.05295041f, -0.02793089f, -0.04202788f, 0.03547199f, 
    -0.03507840f, -0.00309839f, 0.00481438f, 0.01525074f, -0.00459856f, -0.04912859f, -0.00370014f, 0.02570557f, 
    0.00598846f, 0.00763581f, 0.01046463f, -0.05713080f, 0.04024898f, -0.02633679f, 0.01380778f, -0.04898611f, 
    -0.01136501f, -0.00681247f, 0.01395880f, -0.00767301f, -0.03255862f, 0.01694646f, 0.01021097f, -0.01374517f, 
    -0.00804838f, 0.02649475f, -0.03054862f, -0.03432894f, 0.04308719f, -0.03017728f, -0.03278121f, -0.05477854f, 
    -0.01055588f, 0.01108454f, -0.02751046f, 0.00270164f, -0.02722033f, -0.03991530f, -0.05300145f, -0.05517774f, 
    0.00298762f, 0.03334677f, 0.01374093f, 0.04300504f, -0.03052274f, 0.02350010f, -0.00143651f, 0.00654184f, 
    -0.01729649f, -0.03855034f, -0.05360607f, -0.05458204f, 0.01548113f, -0.00275953f, -0.03251810f, 0.00139417f, 
    -0.05000688f, -0.02187190f, 0.03988351f, -0.03513837f, 0.02344847f, -0.03939680f, 0.02867583f, -0.03031441f, 
    0.02243862f, 0.01449673f, 0.01797510f, 0.01845151f, -0.02290937f, 0.04531595f, -0.02031968f, 0.00811316f, 
    -0.02537114f, -0.00828007f, 0.01798340f, 0.04019094f, -0.04901240f, -0.00718225f, -0.00430029f, 0.01117418f, 
    -0.02138662f, -0.02299369f, 0.00942647f, 0.01514746f, -0.01938890f, 0.00833873f, -0.01821855f, 0.00221150f, 
    -0.00013714f, -0.03532770f, -0.00605218f, -0.03030274f, 0.00012485f, 0.00398801f, -0.04500750f, 0.03134602f, 
    -0.04502093f, 0.03933803f, 0.04336919f, 0.01788362f, -0.02966374f, -0.02921789f, 0.04169664f, -0.01723950f, 
    0.01303141f, -0.00459929f, -0.01671606f, 0.00484957f, 0.04490013f, -0.03357955f, 0.03815518f, -0.03650904f, 
    -0.02060837f, -0.03422154f, -0.03151720f, 0.03491737f, 0.00920801f, -0.03199947f, -0.04849048f, -0.00765643f, 
    0.01056917f, 0.02290386f, 0.03471185f, -0.03039558f, -0.04681852f, 0.02296070f, -0.05139897f, -0.01871390f, 
    -0.00491584f, -0.01489369f, 0.00839787f, -0.04646928f, -0.02484146f, 0.03119287f, -0.02753449f, 0.02058832f, 
    0.00893168f, 0.01802489f, 0.03969599f, 0.04640939f, 0.01151393f, 0.00139259f, -0.00007319f, -0.05203640f, 
    0.00780836f, -0.05244538f, 0.01978027f, 0.00429177f, -0.00393461f, 0.00393595f, 0.00843507f, -0.04517007f, 
    0.02030603f, -0.04037484f, 0.00857021f, 0.01517539f, -0.04375431f, 0.02647859f, -0.00617848f, 0.00255780f, 
    0.01066202f, 0.01424924f, -0.02280027f, -0.03627342f, -0.00306059f, 0.01124190f, -0.05193368f, 0.04509111f, 
    0.04426781f, -0.03963960f, -0.01743775f, -0.01472703f, 0.03641434f, -0.03149403f, -0.00426349f, 0.02829158f, 
    -0.02840310f, -0.02468275f, 0.02525999f, 0.03822848f, -0.04005541f, 0.01198032f, -0.03431943f, -0.05564433f, 
    -0.01944103f, -0.05046083f, -0.01314597f, -0.02944552f, 0.02174249f, -0.00123170f, 0.02849402f, 0.00929342f, 
    0.04212411f, -0.04282663f, 0.00660877f, 0.00977620f, 0.00856689f, 0.01374086f, -0.00895819f, -0.01894079f, 
    0.04171335f, -0.00425954f, 0.02165350f, -0.04179070f, -0.00279004f, 0.00328764f, -0.00618816f, 0.00996922f, 
    -0.01940555f, -0.01978132f, -0.01259026f, 0.04540931f, 0.00086749f, 0.00531162f, 0.02105945f, -0.03545055f, 
    0.00651387f, -0.00384168f, 0.04348311f, 0.03527803f, 0.00962965f, -0.03439711f, -0.02555540f, -0.00619974f, 
    -0.01903367f, 0.02443874f, -0.02355883f, -0.00733184f, -0.03734824f, -0.04049776f, -0.02802022f, -0.00842953f, 
    -0.04054602f, -0.05159020f, 0.00976262f, -0.02256333f, -0.03393406f, -0.04183329f, -0.05326536f, -0.01539126f, 
    0.01284063f, -0.00451485f, 0.03089835f, 0.01242252f, -0.02291077f, -0.01431644f, 0.03244275f, 0.04360847f, 
    0.04047941f, -0.01385511f, 0.00851393f, -0.04977254f, 0.03342082f, -0.01031907f, -0.00309886f, -0.05663266f, 
    -0.04009398f, 0.03399959f, -0.02146761f, 0.04372279f, 0.03453968f, -0.01452366f, -0.05623500f, -0.04555191f, 
    0.01530618f, -0.01512527f, -0.02770482f, 0.02720556f, -0.01275352f, 0.01167222f, 0.01668160f, -0.05141921f, 
    0.01795655f, -0.00689477f, 0.02261445f, 0.00990389f, -0.00310206f, -0.00865327f, -0.05637444f, 0.01633745f, 
    -0.11774102f, -0.10528827f, 0.08299492f, 0.25089192f, 0.23460926f, 0.11470683f, 0.06052659f, 0.03415528f, 
    -0.10426041f, -0.01355174f, 0.00984345f, 0.01449686f, -0.06976013f, -0.08084413f, -0.07019065f, 0.07600664f, 
    -0.05003899f, 0.01687805f, 0.04165632f, 0.00472501f, 0.09495205f, 0.12495564f, 0.09501780f, 0.16266640f, 
    -0.00682436f, 0.10376113f, -0.04076194f, 0.15753375f, -0.11463200f, 0.00841000f, 0.12757283f, -0.10112076f, 
    0.23008206f, 0.16947463f, 0.19500862f, 0.12219468f, 0.03013161f, 0.08619386f, 0.00055653f, -0.08484524f, 
    -0.12103609f, -0.12251203f, 0.01284018f, -0.12168864f, 0.09015120f, 0.01116100f, 0.10591245f, 0.03204024f, 
    0.01810041f, -0.07220490f, -0.07802946f, 0.19967720f, 0.04765200f, 0.06561168f, 0.11012341f, 0.01941695f, 
    -0.07484899f, -0.02412655f, -0.04064796f, 0.01767123f, -0.11257409f, 0.13458756f, -0.07152959f, 0.23633803f, 
    -0.00229467f, 0.12457360f, -0.14123462f, 0.04824970f, 0.03506405f, 0.06418839f, 0.08838727f, 0.08488157f, 
    -0.09779678f, 0.09256699f, 0.06025294f, -0.14431334f, -0.07150843f, -0.06711861f, -0.08771247f, -0.06905021f, 
    -0.00776224f, -0.08609101f, 0.18609002f, 0.13784975f, 0.14920793f, -0.18097335f, -0.12082676f, -0.09450395f, 
    -0.02328915f, -0.07992445f, -0.03284278f, -0.02201996f, 0.07535090f, 0.17339569f, -0.02406835f, 0.12285670f, 
    0.01217947f, -0.05433442f, -0.16763492f, 0.22773622f, -0.12451261f, 0.01495789f, 0.12935913f, 0.05402195f, 
    0.12523608f, -0.02033455f, -0.05265450f, -0.04595799f, 0.50276101f, 0.10186540f, 0.02148889f, -0.23109962f, 
    -0.11783874f, -0.07471184f, -0.07286774f, -0.06952619f, 0.01613566f, -0.06815588f, -0.14827842f, -0.13110954f, 
    0.03231018f, 0.01081382f, 0.14076084f, -0.02588713f, -0.03893054f, 0.05210057f, -0.12454770f, -0.07534635f, 
    0.09355684f, 0.03433235f, 0.07402241f, 0.04730280f, 0.21048608f, -0.09397153f, -0.09132884f, 0.00683796f, 
    0.09422329f, -0.05437652f, -0.02897322f, 0.07331441f, -0.10235292f, -0.17640129f, -0.16550735f, -0.17601664f, 
    -0.00631406f, -0.00779936f, -0.02853436f, 0.04461864f, 0.08325145f, -0.00093934f, 0.01892802f, 0.05629268f, 
    0.00806696f, -0.02084728f, -0.02198212f, 0.04745605f, -0.11479977f, 0.23802820f, -0.16997683f, -0.02463120f, 
    0.08568282f, 0.15719797f, 0.08256636f, 0.05117817f, -0.08612678f, 0.13444373f, -0.06371401f, 0.10427494f, 
    -0.06908456f, 0.03475530f, -0.07368235f, 0.17807837f, 0.13979107f, 0.02675222f, -0.02462681f, 0.07069146f, 
    -0.01115818f, -0.02041938f, -0.01541342f, 0.07046444f, -0.19743718f, 0.23409130f, -0.01888554f, -0.10965942f, 
    0.07370321f, 0.02532878f, -0.01295979f, 0.00039603f, 0.10091529f, 0.00094953f, 0.07981527f, -0.07899258f, 
    0.05643921f, 0.11425649f, -0.07112463f, -0.08369985f, -0.04669175f, 0.02069356f, 0.07419870f, -0.09754740f, 
    -0.09344421f, -0.04451549f, 0.10577476f, 0.01152998f, 0.02573640f, -0.00565449f, -0.06913222f, -0.04585317f, 
    -0.29953828f, 0.04854825f, -0.03849046f, -0.02321672f, -0.07672711f, 0.03842256f, 0.01068178f, 0.04895628f, 
    0.24325390f, -0.16869551f, 0.05052718f, 0.14893530f, 0.07557916f, 0.04548687f, 0.12637870f, 0.18620916f, 
    0.09433733f, 0.09000594f, 0.03444184f, 0.13945572f, -0.20468050f, 0.14515924f, -0.06112503f, 0.02123004f, 
    0.11708497f, 0.12161440f, -0.00027217f, 0.07017680f, -0.08552102f, -0.04264090f, 0.01191578f, 0.02252050f, 
    0.16620612f, -0.05086400f, -0.08229442f, -0.01799645f, -0.03090226f, 0.07089870f, 0.10821053f, 0.07393798f, 
    -0.07862368f, -0.00942053f, -0.17876776f, -0.11792871f, -0.31633511f, -0.28178450f, -0.00085213f, 0.19553618f, 
    -0.13389519f, 0.02050903f, 0.12181479f, -0.06782351f, -0.03678805f, 0.05108266f, 0.04202830f, -0.07708642f, 
    -0.11494036f, 0.09138013f, 0.03430435f, 0.01147442f, -0.19444427f, -0.13149138f, 0.03951240f, -0.01814488f, 
    0.03049584f, -0.02385544f, 0.06431986f, 0.04601025f, -0.07333952f, 0.10763652f, 0.06813723f, 0.26619372f, 
    -0.07259997f, 0.04091744f, -0.03438575f, -0.09148225f, 0.05302888f, -0.06792114f, -0.01204425f, -0.04658948f, 
    -0.33086729f, 0.41358617f, 0.12084490f, -0.02617120f, 0.04610038f, -0.10884344f, -0.15065365f, -0.01396977f, 
    0.04607480f, 0.07020819f, -0.00697858f, 0.01533979f, 0.47076970f, -0.17647296f, -0.16148382f, -0.14083527f, 
    -0.02119581f, -0.07012998f, -0.04883688f, -0.01290487f, -0.06359677f, -0.03528488f, -0.04019215f, -0.00427790f, 
    0.21084432f, 0.01086930f, 0.04472288f, -0.00753446f, -0.06225462f, 0.10843832f, -0.05344327f, -0.05510143f, 
    -0.00337613f, 0.00198940f, 0.14133659f, -0.10027716f, -0.03333679f, 0.01666794f, -0.14161026f, -0.04980651f, 
    -0.15994664f, 0.10634170f, -0.02581456f, -0.03157159f, 0.01812328f, 0.14412691f, 0.13890666f, 0.09838282f, 
    -0.02134668f, -0.09941243f, 0.00211897f, 0.13156119f, -0.00798096f, -0.06315923f, 0.03859842f, 0.03212220f, 
    -0.00623826f, 0.04059748f, 0.04684281f, 0.04205276f, -0.03327916f, 0.04271448f, 0.16925226f, 0.08507612f, 
    -0.16221511f, -0.02982564f, -0.09889370f, -0.03473033f, -0.02489813f, 0.00260832f, -0.00924519f, 0.07141178f, 
    0.03148305f, -0.12141687f, 0.14931402f, -0.04879729f, -0.01382717f, -0.03209294f, 0.02054514f, 0.05519505f, 
    0.00076872f, 0.22744314f, 0.03070531f, -0.03346386f, -0.15912965f, -0.01650246f, 0.01678492f, 0.06159094f, 
    0.09416822f, -0.00468870f, -0.06773428f, 0.06206306f, -0.06335938f, -0.06860483f, -0.09323133f, -0.09074262f, 
    0.18663774f, 0.22779936f, 0.38822848f, 0.29134652f, -0.07986747f, -0.00620745f, 0.04355384f, 0.18191858f, 
    -0.04689945f, -0.00968399f, -0.22344877f, -0.02472250f, 0.03394759f, 0.02127052f, 0.11484923f, -0.07851166f, 
    -0.04735844f, 0.16148727f, 0.16209166f, 0.13756672f, -0.00271754f, 0.05608401f, 0.00781670f, 0.06390165f, 
    0.11664439f, 0.00036155f, -0.09530120f, -0.02252693f, -0.04747605f, 0.09372588f, 0.01291268f, 0.10749371f, 
    0.09338677f, 0.04731812f, 0.05515141f, 0.04619451f, -0.27577743f, -0.21310845f, -0.16774552f, -0.10496325f, 
    -0.12044453f, -0.00649153f, 0.01094357f, -0.08983328f, 0.04278571f, -0.00954349f, -0.16135702f, 0.15203938f, 
    -0.02014977f, 0.10541259f, 0.16536704f, 0.12747341f, 0.09867192f, 0.12217246f, 0.05808844f, 0.10019556f, 
    -0.11890962f, -0.00768522f, -0.12836157f, 0.08412322f, 0.15967920f, 0.00248166f, 0.18934974f, -0.09904034f, 
    -0.07685193f, 0.00353559f, -0.02560708f, 0.14907341f, 0.02587074f, -0.06236478f, 0.06508061f, 0.05212607f, 
    0.10296895f, -0.08329859f, -0.16388401f, -0.04252811f, -0.03558716f, -0.06074575f, -0.05642020f, 0.00114938f, 
    0.05109873f, 0.04245119f, 0.12375087f, 0.06840265f, -0.22945620f, 0.03615021f, 0.30977800f, 0.05758823f, 
    -0.04668944f, 0.14930350f, 0.09228740f, -0.02379972f, 0.06847971f, 0.07014412f, 0.03194166f, 0.09399977f, 
    0.28856573f, -0.18409999f, -0.10638048f, -0.10629898f, 0.08363026f, -0.00437629f, 0.02316070f, 0.26790807f, 
    0.05572434f, 0.00106080f, 0.08609617f, -0.03033694f, -0.48944005f, -0.20736113f, -0.02683499f, 0.10697411f, 
    0.02076328f, -0.04782594f, -0.00732086f, -0.05703442f, 0.00550295f, -0.17220102f, -0.07489171f, -0.06871653f, 
    -0.08135339f, -0.07739269f, -0.21747939f, 0.00460271f, -0.04005385f, -0.03221061f, -0.00332468f, -0.00312243f, 
    -0.01691884f, 0.01655428f, -0.01448719f, -0.02645262f, -0.02853810f, 0.02508351f, 0.01205856f, -0.11889182f, 
    0.05569907f, -0.03967371f, -0.10371617f, 0.09180042f, -0.07210375f, -0.11273772f, -0.01138607f, -0.05887701f, 
    0.03594751f, 0.13374148f, 0.27485025f, 0.21164630f, -0.04642401f, 0.03203080f, -0.00455846f, 0.03742214f, 
    -0.03515016f, -0.05753513f, -0.07484182f, -0.03771699f, 0.11064621f, 0.12015855f, 0.26849931f, 0.17131664f, 
    -0.06389336f, 0.06588499f, 0.13209651f, 0.07902704f, 0.09964330f, -0.03328919f, 0.05200069f, -0.17975341f, 
    0.15918022f, 0.25036347f, 0.22637710f, 0.02663910f, 0.05837726f, 0.06396669f, 0.13539213f, 0.12112613f, 
    0.01211763f, -0.01003545f, -0.00406863f, -0.13968132f, 0.20016125f, -0.06184441f, -0.12491276f, -0.07843664f, 
    -0.10835205f, 0.08039059f, 0.02596548f, -0.09802167f, -0.03817139f, -0.09476299f, -0.11188083f, -0.07457693f, 
    -0.27795234f, -0.20436542f, -0.13917767f, -0.12599492f, -0.07052726f, -0.05804317f, -0.04529366f, -0.02882236f, 
    -0.00218842f, -0.07694508f, 0.04046147f, 0.03211305f, 0.20542389f, 0.18444648f, -0.23302355f, 0.05484270f, 
    -0.02910088f, -0.07736120f, 0.02490802f, 0.04346341f, 0.02595724f, 0.03275085f, -0.05665874f, 0.05157765f, 
    -0.13300978f, 0.07077882f, -0.00871960f, -0.13438058f, 0.01238589f, 0.02084064f, 0.19100894f, 0.03938407f, 
    0.07813437f, 0.11163291f, 0.07061785f, 0.01217306f, 0.18607923f, -0.03407066f, 0.25036439f, 0.15109788f, 
    -0.01969143f, 0.04556112f, 0.07976820f, 0.08050597f, -0.02392408f, 0.00852796f, -0.00254983f, -0.01863328f, 
    0.03258364f, 0.10033117f, 0.19984116f, 0.19070908f, -0.01971106f, 0.07778350f, -0.06817830f, -0.14924704f, 
    -0.05930502f, 0.01794541f, 0.11782549f, -0.07232423f, 0.09325514f, -0.08455224f, -0.15785457f, -0.28159001f, 
    -0.04804756f, 0.01045918f, -0.03265170f, 0.00136002f, -0.13653210f, -0.06220751f, 0.06190973f, 0.02331498f, 
    0.06614824f, -0.27710098f, -0.19481498f, -0.12228551f, -0.00675029f, -0.09354735f, -0.02271032f, -0.08770688f, 
    0.00707953f, -0.08461943f, 0.02851726f, 0.03643238f, 0.15165503f, 0.16237077f, -0.01207533f, -0.11740433f, 
    -0.04878236f, -0.00879608f, 0.00039298f, 0.03854437f, -0.06266504f, -0.01415797f, -0.08331893f, -0.14923015f, 
    0.29228750f, -0.60872161f, 0.10539081f, -0.42234251f, -0.01262373f, -0.04625239f, -0.11779091f, 0.13749984f, 
    -0.11312221f, -0.05148391f, 0.06244884f, 0.09231046f, -0.31834954f, -0.10616970f, -0.08022200f, -0.10715490f, 
    -0.08701984f, -0.01781078f, -0.13669249f, -0.02347908f, 0.07532986f, -0.05977603f, 0.07026810f, 0.13143238f, 
    0.06793030f, -0.15492406f, -0.08545133f, -0.11643295f, -0.02641489f, -0.02911342f, -0.17376319f, -0.02627918f, 
    -0.09124233f, -0.01047125f, -0.00164996f, -0.00105080f, -0.25786829f, 0.03685050f, -0.08377309f, 0.09257173f, 
    0.09684458f, -0.02239147f, 0.00686313f, -0.03129784f, 0.10402979f, 0.15070480f, 0.01151472f, -0.03435526f, 
    0.03911361f, 0.23541652f, 0.09965712f, 0.07622366f, 0.09742812f, 0.10831698f, 0.10760964f, 0.06342403f, 
    0.02511942f, -0.07772017f, -0.02751612f, -0.13866842f, -0.04078088f, -0.29140797f, -0.16398960f, 0.11442920f, 
    -0.03408362f, -0.03226848f, 0.13464463f, -0.16450581f, 0.01041277f, -0.01878032f, -0.02681456f, 0.05617117f, 
    -0.17460713f, 0.06629936f, -0.00617168f, -0.15483563f, -0.05316813f, -0.07230624f, 0.13408315f, -0.02380219f, 
    -0.02612457f, 0.03476728f, 0.05843127f, 0.04927073f, 0.12568718f, 0.06332954f, 0.06190851f, -0.01159505f, 
    -0.05511887f, -0.05561608f, -0.11250170f, -0.03638787f, -0.08318387f, -0.04374744f, 0.07074411f, -0.11802668f, 
    -0.00199937f, -0.01417738f, -0.00981220f, -0.01945526f, -0.04759677f, -0.05547974f, -0.04450455f, -0.05246072f, 
    -0.03644388f, 0.03002395f, 0.01329057f, -0.04975605f, -0.01237361f, -0.00447186f, 0.01562786f, -0.05331247f, 
    0.00908483f, 0.03519121f, -0.03636136f, 0.00712961f, 0.00515894f, 0.00402847f, -0.01939147f, 0.00236175f, 
    -0.04581746f, -0.02760248f, -0.00419011f, -0.04720123f, 0.02911428f, 0.03307122f, -0.04360959f, -0.04531663f, 
    0.00335909f, 0.02743744f, -0.00244732f, -0.01464059f, -0.04474304f, -0.01585493f, 0.03467160f, -0.03401794f, 
    -0.04869522f, 0.04389913f, 0.02980209f, -0.03576818f, 0.04437377f, -0.02235816f, -0.03783561f, 0.02064705f, 
    0.01242056f, 0.04476701f, -0.02993728f, 0.00829489f, 0.02074997f, 0.04243189f, -0.01950796f, 0.00229018f, 
    -0.03421552f, -0.00734953f, -0.03914331f, -0.00706076f, -0.04131545f, 0.01236331f, -0.04595337f, 0.03858008f, 
    -0.02553874f, 0.00148944f, -0.04425279f, 0.00244100f, -0.02400167f, 0.02206479f, 0.00204007f, 0.00691654f, 
    -0.04693540f, 0.01196572f, 0.04486478f, 0.01669673f, -0.04193192f, -0.04791291f, -0.03497517f, 0.03577889f, 
    -0.05186475f, -0.05027732f, -0.01366348f, 0.01275857f, 0.04236634f, 0.03829083f, 0.03411303f, 0.01409082f, 
    0.03775074f, -0.03993252f, -0.02411861f, -0.03057298f, -0.02376042f, -0.01183160f, -0.04016344f, -0.04282479f, 
    -0.00757049f, -0.01018812f, -0.02033547f, -0.03288732f, -0.03456893f, -0.01405869f, -0.01414292f, 0.01007592f, 
    0.01348479f, 0.03257650f, -0.02300555f, -0.03220753f, -0.02641968f, -0.05261845f, -0.00065394f, -0.03726632f, 
    0.01987275f, 0.02117790f, -0.04503205f, -0.02108089f, 0.00534399f, -0.00704696f, -0.01015568f, -0.05524752f, 
    0.03892211f, -0.02425245f, 0.03842295f, 0.00664938f, -0.00741754f, -0.01364150f, -0.00481341f, -0.00439875f, 
    -0.04427419f, 0.04134871f, 0.01678326f, 0.02380057f, 0.00073463f, 0.00571613f, -0.00189686f, -0.00422072f, 
    -0.03973284f, 0.02545776f, -0.00153016f, -0.04220885f, -0.00543775f, -0.02759860f, -0.04580094f, 0.01059039f, 
    -0.00980688f, -0.02845818f, 0.04350213f, -0.03995464f, -0.04089740f, 0.03616394f, 0.00711670f, -0.03033353f, 
    -0.01919798f, -0.00323259f, -0.04960212f, 0.00632852f, 0.04204347f, 0.01288813f, -0.04997968f, -0.00001429f, 
    -0.05084828f, 0.01111582f, -0.05548737f, -0.03711499f, -0.01155659f, 0.02667482f, -0.00978763f, 0.00630142f, 
    -0.02176122f, -0.05152384f, -0.04730475f, -0.01072323f, 0.02026505f, 0.00382248f, 0.01974502f, -0.02423634f, 
    0.03905664f, -0.05245191f, -0.02693776f, -0.02093383f, -0.00666014f, -0.02090317f, 0.04250260f, 0.02191197f, 
    0.04584906f, -0.00283193f, 0.04253745f, -0.02350215f, 0.04507307f, 0.00064704f, 0.01565473f, 0.03545359f, 
    0.01638458f, -0.02598850f, -0.00403186f, 0.00116571f, -0.03284805f, -0.03082383f, 0.02896172f, 0.00990663f, 
    0.03430360f, 0.03585048f, -0.05283746f, -0.01844275f, 0.00273568f, -0.04385278f, -0.03118507f, 0.02071209f, 
    0.00310824f, -0.02312107f, 0.02496308f, -0.04958837f, 0.01696552f, -0.00566511f, 0.00369788f, 0.00746449f, 
    -0.03951875f, 0.01408014f, -0.00691667f, 0.01967311f, 0.00346795f, -0.00311755f, -0.00560386f, 0.01871172f, 
    -0.04918202f, 0.03549726f, -0.04531688f, -0.05563849f, 0.02527719f, -0.04055761f, -0.04178850f, -0.01744960f, 
    -0.03342442f, 0.01337246f, -0.02339494f, 0.03768066f, -0.03522043f, -0.02258987f, 0.01029162f, 0.00281311f, 
    0.00870200f, -0.02430577f, 0.02963769f, -0.02237348f, 0.00640185f, 0.01941869f, 0.03580817f, -0.00417041f, 
    0.04471895f, 0.02137521f, -0.05498984f, 0.00542476f, 0.03104390f, -0.01881057f, -0.00965448f, 0.04259931f, 
    -0.05538020f, -0.03703016f, -0.02521118f, -0.05069015f, -0.03111527f, -0.02832749f, 0.01233870f, 0.01969156f, 
    -0.03777076f, -0.03138755f, -0.00723148f, 0.02456478f, -0.03405614f, 0.01311686f, -0.04826029f, 0.01618604f, 
    -0.03173314f, -0.05501291f, -0.02354474f, -0.02465480f, -0.04317194f, -0.04973963f, -0.04665403f, 0.00841943f, 
    0.02713394f, -0.03542975f, 0.04459087f, -0.02741337f, -0.00280741f, -0.00740766f, -0.01143114f, -0.00451859f, 
    -0.05253273f, -0.04514762f, -0.04504718f, 0.00721508f, 0.04582019f, -0.02508109f, -0.04989717f, 0.03884847f, 
    0.03665203f, 0.00417527f, 0.00686227f, 0.01832448f, -0.02136216f, -0.00944161f, -0.04620479f, 0.04317045f, 
    0.01687218f, 0.04243154f, -0.04242611f, 0.03165738f, 0.00094119f, 0.01755338f, -0.01701565f, -0.03815463f, 
    -0.03425785f, -0.04774250f, 0.02750824f, 0.02906556f, -0.03707952f, 0.02005579f, 0.03574593f, 0.03872340f, 
    -0.04980050f, 0.02384771f, 0.02300644f, 0.04199211f, 0.03340420f, -0.00376417f, -0.00712185f, 0.00819588f, 
    0.01394075f, -0.02176238f, 0.03474164f, -0.01483155f, -0.02123943f, 0.04197323f, -0.04688492f, 0.00622534f, 
    0.01291184f, 0.01083756f, -0.04679543f, 0.00247488f, 0.03655245f, -0.02653026f, 0.00670567f, -0.00276649f, 
    0.01684564f, 0.01163874f, 0.03811104f, 0.00904806f, -0.02019585f, 0.01336847f, -0.01901790f, -0.01387630f, 
    0.02745363f, -0.01922040f, 0.02778318f, -0.00566814f, 0.01083148f, -0.02783152f, -0.04240972f, -0.04410560f, 
    0.02032644f, -0.05016229f, -0.01199282f, 0.02724347f, 0.03310264f, 0.02539543f, 0.00887055f, -0.04088423f, 
    -0.04732238f, 0.03310158f, -0.04706012f, -0.04584753f, -0.02341555f, -0.03351527f, 0.02548861f, -0.03517135f, 
    0.02064264f, 0.00431677f, -0.00745598f, 0.00124498f, -0.03331612f, -0.00708607f, -0.01322929f, -0.00308084f, 
    0.20764947f, 0.17338036f, -0.09845173f, -0.13500544f, 0.09461149f, -0.11145376f, 0.19218060f, 0.00962749f, 
    0.05225694f, 0.04639412f, -0.14249858f, -0.00810656f, 0.10079338f, -0.20283099f, 0.14008942f, -0.04651925f, 
    0.03739573f, 0.10886928f, 0.02517941f, 0.06200539f, 0.02459997f, 0.05607831f, -0.02842639f, -0.03519333f, 
    0.04919517f, -0.03892232f, -0.06539335f, -0.01697374f, 0.05361043f, 0.07959133f, -0.11255337f, -0.11942097f, 
    0.11074806f, -0.12105191f, -0.15169078f, 0.04732818f, -0.24463275f, -0.23939468f, -0.16858047f, 0.11404096f, 
    0.08185291f, -0.02316632f, -0.00319549f, 0.04515386f, -0.04543306f, 0.02174679f, -0.12488822f, 0.08428208f, 
    0.02116098f, -0.08484628f, 0.03008475f, -0.04554653f, -0.05713739f, 0.15285215f, -0.01782193f, 0.17531720f, 
    0.02836030f, -0.04345519f, -0.02263696f, 0.25465080f, 0.11492268f, -0.09364817f, 0.00501494f, -0.19420914f, 
    0.15600283f, 0.05192073f, 0.11475638f, 0.18948811f, -0.04664229f, 0.00616377f, 0.10851891f, 0.02326420f, 
    0.10306146f, -0.00775757f, -0.11211017f, -0.00665624f, -0.01267761f, 0.06907995f, 0.00516188f, -0.07999378f, 
    0.02284811f, -0.01961595f, 0.17841199f, -0.05781182f, 0.00224703f, -0.17589657f, 0.17305535f, 0.04459725f, 
    -0.01350951f, 0.11167046f, 0.15929742f, -0.07503575f, 0.06935202f, -0.00642379f, 0.01827046f, 0.02953759f, 
    -0.01847777f, 0.20810594f, 0.12250297f, -0.10658894f, -0.00351893f, -0.06482019f, -0.15495782f, 0.04423777f, 
    0.02498972f, -0.13007689f, 0.12365584f, 0.06890888f, -0.49404702f, 0.21512137f, -0.03293168f, 0.28295508f, 
    -0.06321143f, -0.03945847f, 0.13427913f, -0.02566595f, 0.01417311f, 0.07458454f, -0.05958369f, 0.09560239f, 
    0.09608422f, -0.28626552f, 0.22117953f, 0.01329677f, 0.07865054f, 0.01704162f, 0.00705465f, 0.04423230f, 
    -0.08187105f, 0.07156618f, -0.09218853f, 0.00291937f, -0.13697702f, -0.04747906f, 0.02537018f, 0.03511554f, 
    0.03151029f, -0.08422053f, 0.04679640f, -0.05675796f, -0.10933977f, 0.05599479f, -0.08242448f, 0.04212652f, 
    0.03329067f, 0.18670648f, 0.10989598f, -0.06118374f, 0.00280116f, 0.24541938f, 0.14459370f, 0.09248605f, 
    -0.01359570f, -0.08794308f, -0.01890508f, 0.16858269f, 0.17881973f, 0.03675392f, -0.14646769f, -0.03523919f, 
    -0.10827725f, -0.07814024f, -0.15133516f, 0.06097614f, 0.03351324f, 0.03586684f, -0.03895654f, -0.01997389f, 
    -0.02341906f, -0.03567540f, -0.27478072f, -0.14557594f, -0.07636896f, 0.00631661f, 0.02169791f, 0.17257749f, 
    0.07032757f, -0.06047498f, 0.05857305f, 0.06574593f, 0.27705726f, -0.07370840f, 0.45025921f, -0.06709632f, 
    -0.07074180f, -0.03666721f, -0.04817885f, 0.06961687f, 0.01852540f, 0.06693736f, -0.01195386f, -0.06310941f, 
    -0.11015978f, -0.00077818f, -0.06829774f, 0.02303316f, 0.04710257f, -0.01408183f, 0.08323848f, -0.01416190f, 
    -0.04960085f, 0.03163394f, -0.11078497f, -0.04956193f, -0.16664152f, 0.41025922f, -0.39756846f, 0.22295320f, 
    0.09207761f, 0.19861211f, -0.01603171f, -0.03253371f, -0.02666389f, 0.17402364f, -0.10325808f, 0.10485281f, 
    -0.02199099f, -0.00904187f, -0.05565213f, -0.07670850f, -0.01035121f, 0.08354408f, -0.18492793f, 0.08843863f, 
    0.14445898f, 0.04060780f, 0.08541821f, 0.05206588f, 0.20443262f, -0.16804460f, -0.01296327f, -0.05756930f, 
    0.10086866f, 0.15065107f, -0.02264512f, 0.11902186f, 0.02177760f, 0.09049343f, 0.10810350f, -0.01413982f, 
    0.09924310f, 0.09236896f, 0.07430996f, 0.08777519f, -0.05040026f, 0.08335063f, 0.15552866f, -0.13827437f, 
    -0.00129838f, -0.10683048f, -0.12606844f, 0.05048729f, -0.27547213f, -0.41476667f, -0.23411416f, 0.10719398f, 
    0.10892578f, 0.11852349f, 0.22656873f, -0.06784918f, 0.07119492f, -0.03945388f, -0.01191618f, 0.04487741f, 
    -0.25201923f, -0.09723773f, -0.12372977f, 0.16354015f, 0.15383242f, 0.00688960f, 0.10303617f, -0.02551139f, 
    -0.01817111f, 0.06892334f, 0.05468238f, -0.00067248f, 0.04309019f, -0.06091221f, 0.06995185f, -0.07265676f, 
    -0.04015921f, -0.06347099f, 0.11720699f, 0.16799963f, 0.06628321f, -0.01324208f, 0.11009990f, -0.02046322f, 
    -0.16680957f, -0.28661856f, 0.28018323f, -0.18373780f, 0.13451821f, 0.06433769f, -0.07047180f, -0.00774477f, 
    -0.02488578f, -0.10900664f, 0.39395654f, -0.08893969f, -0.15122819f, 0.26681638f, 0.31899637f, 0.18856983f, 
    -0.00117337f, -0.05348820f, -0.00992322f, 0.04706533f, 0.15980698f, 0.10942516f, 0.06233017f, 0.22088496f, 
    -0.18942331f, 0.00464833f, 0.06047634f, 0.09163855f, 0.18987180f, 0.00511463f, -0.10516410f, -0.04719004f, 
    0.16452582f, 0.03736253f, -0.01757792f, -0.05020073f, -0.16572605f, 0.25731558f, -0.16524538f, 0.14319620f, 
    0.18060856f, 0.00934815f, 0.00759731f, -0.07428467f, 0.11473628f, -0.02387651f, 0.02977006f, -0.04920099f, 
    -0.05493087f, 0.06289785f, -0.07327197f, -0.14563106f, 0.02180743f, 0.04966760f, 0.06394479f, 0.08544514f, 
    -0.02228158f, 0.03852929f, 0.02174591f, 0.00390806f, -0.13080370f, -0.20453192f, -0.18160921f, 0.11413543f, 
    0.09665808f, 0.05917288f, -0.00741244f, -0.00637902f, 0.02542247f, -0.10490544f, 0.04467177f, 0.03272826f, 
    0.43750340f, 0.23291256f, 0.03774006f, -0.12390770f, 0.02608922f, 0.04160512f, -0.05087489f, -0.02964055f, 
    0.00903412f, 0.03336395f, 0.01653983f, 0.08654455f, -0.05075091f, -0.01091398f, 0.01726027f, -0.27835947f, 
    0.01001791f, 0.05018806f, -0.00635552f, -0.05997061f, 0.10882597f, -0.02775257f, -0.02993360f, 0.04765910f, 
    0.01833404f, 0.26596260f, -0.03500178f, -0.08507822f, 0.10542540f, -0.01440874f, 0.02836050f, -0.08554177f, 
    0.05222683f, -0.00388356f, -0.06855399f, -0.01072381f, -0.03494272f, -0.16032076f, 0.15146656f, -0.12065370f, 
    0.22067404f, 0.18749285f, 0.14077489f, -0.03738096f, -0.15363663f, -0.23105013f, -0.24741758f, -0.18502755f, 
    -0.04995829f, 0.09455191f, -0.12200665f, -0.35750127f, -0.03742015f, 0.02954178f, -0.05575282f, -0.17437950f, 
    0.09118030f, -0.15196913f, 0.00545971f, -0.10036059f, -0.18703197f, -0.06108179f, -0.07112657f, 0.08792572f, 
    0.23713487f, -0.07525332f, -0.04557983f, -0.05128112f, -0.00888097f, -0.00649355f, -0.05951535f, 0.18854253f, 
    -0.10265358f, -0.02682177f, 0.18488298f, 0.21614514f, 0.06279665f, 0.18181704f, -0.16107389f, 0.00992425f, 
    0.04846381f, -0.03950933f, -0.06099235f, 0.07831293f, -0.02445332f, -0.07949709f, 0.00301828f, -0.30559713f, 
    0.15579107f, 0.08745448f, 0.08049402f, 0.19804697f, -0.09938213f, 0.00748364f, 0.02676406f, -0.00949067f, 
    0.12896639f, -0.21426225f, 0.03167499f, -0.05724980f, 0.04718390f, 0.00168340f, -0.13430274f, -0.06998675f, 
    0.18416844f, -0.11682019f, 0.10511883f, 0.02427056f, -0.14268528f, -0.31306514f, 0.34313881f, 0.08903679f, 
    -0.03952946f, 0.16375761f, 0.15093027f, 0.06667056f, 0.09085095f, -0.18841276f, -0.17383647f, -0.26491502f, 
    0.21081725f, 0.17172050f, -0.28124821f, -0.30319855f, -0.02262466f, 0.01617426f, 0.03146960f, -0.01761330f, 
    0.07447401f, 0.06062738f, -0.00027013f, 0.01665163f, -0.31427035f, 0.17889157f, -0.21427771f, 0.20398052f, 
    -0.01002101f, -0.00361538f, 0.03835615f, -0.10806851f, 0.14134808f, 0.09958489f, 0.08975615f, 0.14278637f, 
    0.23780479f, -0.02980152f, 0.09902783f, -0.14691029f, 0.01498755f, -0.02371860f, -0.19362164f, 0.13981858f, 
    0.13672186f, 0.08957501f, -0.10732292f, 0.03960393f, -0.05311543f, -0.15473342f, 0.05231734f, 0.05345260f, 
    0.01876411f, 0.16058831f, 0.04521468f, 0.01073630f, 0.05753630f, 0.08043794f, 0.06520042f, 0.22728710f, 
    -0.02991227f, 0.22503735f, 0.32985911f, 0.03671931f, 0.01052475f, 0.06414825f, 0.07604013f, 0.14694926f, 
    -0.03555635f, -0.05194140f, 0.01302692f, 0.09410638f, 0.18037361f, -0.08982456f, 0.37361869f, -0.23049781f, 
    -0.03949373f, 0.02496708f, -0.02392183f, 0.09751391f, 0.07640860f, -0.06074417f, -0.09806589f, -0.03429148f, 
    0.02674997f, 0.09699576f, 0.01108770f, -0.14044984f, 0.02037679f, 0.12843014f, 0.04561233f, 0.03924284f, 
    0.07607560f, -0.04774084f, 0.03588530f, 0.01269007f, 0.18175779f, -0.26593882f, 0.33633038f, -0.03100050f, 
    -0.03154096f, -0.05702174f, -0.04104510f, -0.05128590f, 0.13064241f, 0.11507444f, 0.03792161f, -0.01702471f, 
    -0.03383410f, -0.04273160f, 0.14775747f, -0.04526582f, 0.01186544f, 0.03669763f, -0.14845787f, 0.01151000f, 
    0.11624415f, 0.08458079f, 0.03749121f, 0.05893055f, -0.09265695f, 0.22336109f, -0.16835047f, -0.10204467f, 
    0.01374116f, 0.03359816f, 0.03560770f, 0.06626374f, 0.02766949f, 0.03520969f, 0.07999272f, 0.00679997f, 
    0.01466066f, -0.08537166f, -0.20290518f, -0.03530101f, -0.02214240f, 0.15113778f, -0.12658268f, -0.00491438f, 
    0.06436269f, -0.09979220f, -0.16020940f, -0.00315434f, 0.06835634f, -0.03100140f, 0.10000671f, -0.13907623f, 
    0.17489243f, 0.13441645f, 0.06765664f, 0.21618156f, 0.01951225f, 0.21877497f, 0.13473280f, 0.01624545f, 
    0.14554293f, -0.06683687f, 0.27966723f, 0.25617653f, -0.01077094f, 0.11439504f, 0.02556591f, -0.01692384f, 
    0.14507335f, -0.01104301f, 0.04533816f, 0.11269590f, -0.48675564f, -0.21993263f, -0.21459201f, 0.14422949f, 
    0.15856810f, 0.01650598f, 0.18722138f, 0.15350965f, 0.01204573f, -0.09873482f, -0.01958792f, -0.03107828f, 
    0.00441217f, -0.05710128f, -0.14330117f, 0.06768187f, 0.19984487f, -0.09282224f, -0.02365921f, 0.10398814f, 
    0.20128317f, -0.03781711f, -0.06920284f, 0.02656278f, 0.13183582f, 0.26776350f, 0.13400742f, 0.06624652f, 
    0.04817079f, 0.03866421f, 0.19388656f, 0.11984909f, -0.08684314f, 0.02167989f, -0.00053894f, -0.08575391f, 
    0.08681943f, -0.31866315f, 0.17388554f, -0.06575342f, 0.08668610f, -0.00999474f, -0.02491328f, -0.02529657f, 
    -0.01833964f, 0.06803690f, -0.00344635f, -0.09070233f, 0.14356621f, 0.17957988f, 0.11516454f, 0.30633214f, 
    -0.21463573f, -0.14316513f, -0.10051581f, 0.09494545f, 0.14233328f, 0.00666398f, 0.06641913f, 0.12003376f, 
    -0.04033882f, -0.03166352f, -0.10286766f, -0.05842372f, 0.23988070f, -0.18266286f, 0.02663448f, 0.03155879f, 
    0.05738589f, -0.03389737f, 0.16227591f, -0.09570202f, -0.03284901f, -0.04851275f, -0.22521143f, 0.15434417f, 
    0.10518956f, 0.07578533f, 0.16734442f, -0.06263663f, 0.10764362f, -0.07902042f, -0.11867226f, -0.10837870f, 
    -0.00656359f, 0.22884203f, 0.15877879f, -0.04361156f, 0.19141887f, -0.00636292f, 0.14109074f, 0.11996646f, 
    0.04680302f, -0.05486985f, 0.01426894f, 0.09339934f, -0.04006733f, 0.03560825f, -0.30222744f, 0.08788288f, 
    0.07126821f, -0.02583274f, -0.05993757f, 0.05253813f, -0.02172932f, -0.17880568f, 0.00390564f, 0.06039258f, 
    0.35304046f, 0.06792594f, -0.03750605f, -0.32497144f, -0.13404883f, -0.05338145f, -0.17156452f, 0.07943411f, 
    0.22083955f, -0.00989500f, 0.04810692f, 0.03535332f, 0.16270478f, -0.16849640f, 0.21671095f, -0.08650172f, 
    -0.09608015f, 0.01936682f, 0.02506988f, 0.06155492f, 0.25548992f, 0.08263308f, 0.13212846f, 0.28381264f, 
    -0.05520000f, -0.02783974f, -0.11578324f, -0.02983634f, 0.05163833f, 0.13063283f, 0.05801652f, 0.15163176f, 
    0.02540755f, 0.01901992f, 0.03227111f, -0.04144539f, -0.03324075f, 0.04071077f, -0.11095709f, -0.03327845f, 
    0.06532433f, -0.06624126f, 0.00578902f, 0.08804683f, -0.08786093f, 0.00111896f, 0.07146844f, -0.06927157f, 
    -0.22886811f, -0.06198641f, 0.10036669f, -0.10476444f, 0.22015765f, -0.08346618f, 0.13708359f, 0.06723909f, 
    -0.06069861f, 0.14427406f, 0.18840231f, -0.09970479f, 0.16907144f, 0.23343022f, -0.06866962f, 0.00925350f, 
    -0.02657649f, 0.01541835f, -0.05799795f, 0.05679062f, -0.02545867f, -0.01340578f, 0.05612829f, -0.24348123f, 
    0.12797713f, 0.02642105f, -0.09727921f, 0.04503304f, -0.01477986f, -0.08804602f, 0.05356576f, -0.04718481f, 
    -0.11908124f, 0.11031063f, 0.15526702f, -0.03245389f, -0.07645508f, 0.02412708f, 0.02458902f, 0.15780663f, 
    -0.00739529f, -0.08501355f, 0.15916972f, -0.15939133f, 0.05219029f, -0.04533686f, -0.09877303f, -0.11231650f, 
    -0.01439628f, -0.05463069f, 0.07841600f, -0.05055955f, 0.02074447f, 0.01454780f, -0.01237872f, 0.06651657f, 
    -0.02818042f, 0.06634134f, -0.16803369f, 0.12134108f, 0.18525009f, -0.05795792f, -0.19054359f, 0.12017479f, 
    0.16989136f, -0.10870722f, 0.12756127f, -0.00936838f, -0.08163577f, 0.04485602f, -0.05039467f, 0.00589481f, 
    -0.02895946f, 0.23813817f, 0.17655443f, 0.05422235f, 0.08006338f, 0.04948285f, 0.12353057f, -0.05804367f, 
    0.00721202f, 0.10380600f, 0.18864056f, 0.05655005f, 0.32472241f, -0.06755065f, -0.22770667f, -0.10770051f, 
    -0.08669984f, -0.01490422f, -0.04819190f, -0.07763028f, 0.11129050f, 0.16108377f, 0.26655781f, 0.09724917f, 
    0.08066789f, -0.08172957f, 0.24844606f, -0.08877598f, 0.05776403f, -0.00964487f, 0.00491222f, -0.02899534f, 
    -0.06379767f, -0.02015236f, 0.03919138f, 0.03776704f, 0.04764745f, 0.02609150f, -0.01413057f, 0.11110126f, 
    -0.12647527f, 0.09035712f, 0.07641134f, -0.02514923f, -0.07338179f, 0.03496207f, 0.11117211f, 0.20348276f, 
    -0.10273958f, -0.08490494f, -0.12081137f, 0.02899591f, -0.02880693f, -0.06539579f, 0.01810993f, -0.00749362f, 
    -0.12185813f, -0.07497769f, 0.02529434f, -0.03810604f, 0.11419684f, -0.17537288f, 0.12676507f, -0.03588424f, 
    0.03128180f, 0.14504310f, 0.12820718f, 0.13329345f, -0.03696270f, 0.00697027f, -0.06364144f, -0.02393667f, 
    -0.01388943f, -0.10523973f, 0.17876849f, -0.00370887f, 0.04433845f, -0.04459256f, 0.08001880f, -0.10307233f, 
    0.00782478f, -0.08673286f, -0.04769943f, -0.04000081f, 0.02711460f, -0.15219875f, -0.02766247f, 0.02144788f, 
    0.01800981f, -0.01656762f, -0.04386265f, -0.17942128f, -0.06480267f, 0.10099990f, 0.21245521f, 0.13907146f, 
    0.10683537f, 0.13398686f, 0.09764648f, -0.16154857f, -0.01328385f, 0.02628921f, -0.08861160f, -0.00436523f, 
    -0.06110940f, 0.08110424f, 0.00274223f, 0.04657650f, -0.23604073f, -0.06553695f, 0.07906292f, -0.28108996f, 
    -0.02446619f, 0.14929907f, 0.05748992f, 0.02101177f, 0.03042359f, -0.07831819f, 0.12664406f, -0.01303890f, 
    0.16477019f, 0.06995204f, -0.01903504f, 0.10018601f, -0.00143569f, 0.10734187f, 0.07532202f, 0.16333044f, 
    -0.05405547f, -0.00375424f, 0.11451207f, 0.02135610f, -0.13984495f, 0.12444936f, -0.17015234f, 0.05329863f, 
    -0.05605335f, -0.07237104f, -0.03916632f, 0.01658520f, 0.01824582f, -0.09392681f, -0.06820985f, -0.03934134f, 
    -0.12144108f, -0.06191753f, -0.15753274f, -0.05673425f, -0.01695479f, 0.02508668f, 0.00385348f, 0.06951337f, 
    -0.06500098f, 0.00869413f, 0.01609142f, 0.17602344f, 0.02529641f, 0.26228711f, -0.10441691f, 0.12328234f, 
    0.04300155f, -0.01227090f, 0.17038517f, 0.22146522f, -0.02463125f, -0.01072374f, 0.02582943f, 0.01622902f, 
    -0.01028103f, 0.21176095f, 0.09745223f, -0.11327942f, -0.02870483f, 0.10896472f, 0.04869279f, 0.03435202f, 
    0.10181122f, 0.00384692f, -0.10802479f, -0.00338458f, -0.03994614f, -0.13888338f, 0.09649777f, -0.00584159f, 
    -0.02570976f, -0.07657336f, -0.09647542f, -0.17210905f, -0.06789393f, -0.08038633f, -0.09671009f, 0.08270854f, 
    0.37085402f, 0.14241406f, -0.18342958f, 0.07656312f, -0.08103573f, 0.04531146f, -0.05291840f, -0.25975281f, 
    0.13065580f, 0.12112548f, -0.09114801f, 0.07929598f, 0.42380247f, 0.15182191f, 0.03779275f, 0.15883382f, 
    0.11148019f, -0.00911055f, -0.02153013f, -0.20194939f, 0.05131163f, 0.13574313f, 0.06670141f, 0.25677237f, 
    0.00931317f, 0.21581788f, -0.12865539f, -0.04818641f, -0.00184770f, 0.07735761f, 0.09343701f, 0.04784072f, 
    0.12249248f, -0.10956613f, 0.03440690f, 0.29672584f, -0.09930053f, -0.10311007f, 0.08883055f, 0.12137406f, 
    -0.04195341f, 0.05215705f, 0.05116244f, -0.03337402f, -0.03734471f, -0.13356984f, 0.10529049f, -0.02799476f, 
    0.10009485f, -0.22563000f, 0.02605873f, 0.05283109f, 0.03987968f, 0.05623193f, -0.03233754f, -0.01453922f, 
    -0.02127864f, -0.09782983f, 0.00195937f, 0.11127912f, -0.06140539f, 0.28729510f, 0.05978167f, 0.00025621f, 
    -0.04248024f, -0.00006506f, 0.00462490f, 0.00401810f, 0.00397707f, -0.12427464f, -0.03351095f, -0.13291524f, 
    -0.02304212f, 0.10693257f, 0.18323496f, 0.11336829f, -0.01914534f, -0.03114932f, -0.15635245f, 0.00038224f, 
    0.02143068f, -0.05979978f, 0.11639485f, -0.02213313f, 0.04806816f, -0.22587456f, 0.10560685f, 0.26263452f, 
    -0.15186946f, -0.05216747f, -0.01657747f, -0.04228722f, 0.04558914f, -0.03409736f, -0.01302850f, 0.16686784f, 
    -0.28180063f, -0.32813859f, 0.05139523f, 0.04310166f, -0.06078411f, 0.21592022f, -0.04610953f, -0.01071767f, 
    0.03809392f, -0.04183458f, 0.06723458f, 0.09281681f, 0.00206077f, 0.12626994f, -0.09578394f, 0.01736348f, 
    -0.00257968f, 0.05525435f, -0.04261045f, 0.07489435f, -0.04649273f, -0.03354960f, 0.10206839f, -0.03200777f, 
    -0.01182004f, 0.03705397f, 0.06867275f, -0.12687713f, 0.00789618f, 0.02073569f, 0.08401454f, 0.02072144f, 
    -0.01744841f, 0.12046560f, 0.05390534f, 0.04963392f, 0.14029241f, 0.16749340f, 0.13207635f, 0.00676851f, 
    -0.05593377f, -0.00149569f, -0.04731903f, 0.04152134f, 0.06885516f, -0.05971761f, 0.01523035f, -0.05076461f, 
    -0.09103141f, 0.00699981f, -0.03574853f, 0.00702951f, 0.21040016f, 0.09524610f, 0.17946674f, 0.09474114f, 
    -0.00952031f, 0.10657640f, 0.14323619f, 0.04498361f, 0.06326373f, 0.18132663f, 0.00396886f, 0.16411674f, 
    -0.04873440f, 0.15063900f, 0.10166062f, -0.04586538f, 0.02654267f, -0.02288904f, 0.00440043f, 0.03418018f, 
    -0.04756636f, 0.01865209f, -0.00135943f, 0.12329388f, -0.04800653f, -0.08748452f, -0.06296179f, -0.00208801f, 
    0.02038992f, 0.11929044f, -0.09229072f, 0.07111388f, -0.17351277f, 0.14303944f, -0.32020468f, 0.05564798f, 
    0.02602624f, -0.03340790f, 0.02794192f, 0.06134186f, -0.04719013f, -0.00823874f, 0.06558347f, 0.03000509f, 
    0.24389447f, 0.05450155f, 0.10452701f, 0.10067206f, 0.10013882f, 0.08294824f, 0.08328352f, 0.02354155f, 
    0.24574178f, 0.07482413f, -0.00481447f, 0.03174355f, 0.29789996f, -0.26523629f, 0.13302141f, -0.18799645f, 
    0.02448571f, -0.00232926f, -0.10262256f, 0.03978758f, -0.04081806f, 0.02601621f, -0.19302978f, -0.10431879f, 
    0.03032632f, 0.20223600f, -0.07144672f, 0.15417357f, -0.07321779f, -0.10250259f, 0.05379895f, 0.04398907f, 
    -0.02350065f, -0.01046631f, 0.09946948f, 0.02242889f, 0.01830477f, 0.17430788f, 0.08847151f, 0.11981310f, 
    0.01590255f, -0.01425279f, -0.08658244f, 0.01749186f, -0.01744704f, -0.05266915f, 0.01607431f, -0.22210748f, 
    -0.24023859f, -0.24182113f, -0.02029728f, -0.01526438f, -0.07601561f, -0.07254779f, 0.10491404f, 0.02989409f, 
    0.01638940f, 0.01992328f, 0.03208463f, 0.02506948f, -0.16837659f, -0.01325372f, 0.16711225f, 0.15970320f, 
    0.10992242f, 0.02916154f, 0.26296610f, 0.11281934f, 0.02448381f, -0.07359500f, 0.05789359f, 0.01813077f, 
    0.07553935f, 0.16503185f, 0.39775920f, 0.21025215f, 0.07930002f, 0.11546237f, 0.18336970f, -0.09046289f, 
    0.02455359f, 0.02233090f, -0.01785746f, -0.16032225f, 0.10018870f, 0.26954162f, -0.12365294f, 0.18748666f, 
    -0.03014788f, 0.02814042f, -0.02607952f, -0.02517621f, 0.07910383f, -0.02201399f, -0.00160583f, 0.07494230f, 
    -0.02074037f, 0.12837063f, -0.02170760f, 0.08400909f, -0.04238858f, -0.04494355f, -0.06053160f, -0.02458074f, 
    0.07300182f, 0.21100327f, 0.00789139f, 0.19128458f, 0.06564742f, -0.05061284f, 0.31241384f, -0.15086535f, 
    0.22433302f, -0.02661106f, -0.00528184f, 0.17247580f, -0.04470771f, 0.04606383f, -0.02286452f, -0.04825957f, 
    -0.15932623f, 0.06839448f, 0.07078345f, 0.11355352f, 0.16534220f, 0.08964185f, 0.10221729f, 0.01276444f, 
    -0.16615261f, -0.03659458f, -0.07102726f, -0.13540940f, -0.11975928f, -0.10363521f, -0.10017025f, 0.07377879f, 
    -0.00723630f, -0.07285158f, 0.10671414f, 0.05302824f, -0.10041877f, -0.12925562f, -0.05151588f, -0.06901619f, 
    -0.34052658f, 0.11178553f, -0.14988305f, -0.05738825f, 0.14036021f, -0.01049589f, 0.15895441f, 0.18178751f, 
    0.00103930f, 0.06744741f, 0.08118489f, 0.07850555f, 0.20080619f, 0.29120418f, 0.12761621f, -0.09151272f, 
    -0.10490729f, -0.17159574f, -0.12190380f, -0.12165812f, -0.09546909f, -0.04878522f, -0.08744748f, -0.07694355f, 
    0.16035683f, 0.10346929f, 0.15251058f, -0.09758880f, -0.08719550f, -0.09641971f, -0.05561683f, 0.01232123f, 
    -0.04880764f, -0.01157179f, -0.05174115f, 0.02271116f, 0.05060275f, -0.09480428f, -0.22039334f, -0.30236691f, 
    -0.02491856f, -0.01222364f, -0.04176274f, -0.08709921f, -0.09804165f, -0.08346172f, 0.00068712f, 0.01099094f, 
    0.42358062f, 0.19608410f, -0.03836126f, 0.36017439f, -0.03401967f, 0.04769040f, -0.01616031f, 0.06960384f, 
    0.10387393f, 0.09419523f, 0.06906185f, 0.09035729f, -0.27525321f, -0.01486402f, -0.06652945f, -0.00200401f, 
    -0.05489543f, 0.04126332f, -0.02591792f, -0.05618184f, 0.00709284f, 0.10872569f, -0.00071144f, 0.00432868f, 
    0.27386841f, 0.05120354f, 0.07998241f, 0.15097243f, -0.05965312f, 0.08798768f, 0.05193028f, 0.08964776f, 
    -0.13265346f, 0.00227088f, 0.22342627f, 0.17259482f, 0.19343925f, -0.15319671f, 0.17627510f, -0.09194458f, 
    0.09538333f, -0.01232701f, -0.05441636f, 0.03873743f, -0.02394201f, 0.09932691f, 0.04306185f, 0.11005022f, 
    0.00525669f, 0.01303565f, 0.23432429f, 0.08455240f, 0.04336644f, -0.00244755f, -0.02054471f, 0.08252549f, 
    -0.00074075f, -0.01904793f, -0.07169010f, -0.03552847f, 0.15927817f, 0.07095267f, 0.22239108f, 0.07728191f, 
    -0.00302531f, -0.09396221f, -0.03743220f, -0.10355441f, 0.00614788f, 0.05024819f, -0.01570910f, -0.10064560f, 
    -0.24664000f, 0.01323734f, 0.06238843f, 0.13479760f, -0.00941098f, -0.02165072f, 0.07283200f, -0.08306571f, 
    -0.09207091f, 0.10553080f, 0.03921403f, -0.06371062f, -0.04105031f, 0.04638625f, 0.08327855f, 0.11288948f, 
    -0.06410842f, -0.01213061f, 0.00069876f, 0.05175269f, -0.18835430f, 0.02093479f, -0.09305289f, -0.17340693f, 
    0.20566829f, 0.09941456f, -0.17236799f, -0.24426074f, -0.03124254f, -0.01151086f, 0.04994273f, 0.05473150f, 
    -0.03952846f, 0.07349949f, 0.07219601f, 0.02798426f, 0.09116914f, 0.01313580f, -0.09194639f, -0.09549213f, 
    0.03310911f, 0.04689221f, 0.06044979f, -0.02448510f, -0.02983559f, -0.06255104f, -0.07428189f, 0.02190207f, 
    0.05901717f, -0.04470450f, -0.04029420f, 0.00102033f, 0.06689610f, 0.07431667f, 0.00528327f, 0.04738600f, 
    -0.03251077f, 0.13123818f, 0.08958471f, -0.08734186f, 0.12407661f, 0.08915757f, 0.13036323f, 0.09395645f, 
    0.00378384f, -0.04903594f, -0.00123416f, -0.03588883f, 0.05154220f, -0.01920881f, 0.04017790f, -0.08692459f, 
    0.11068028f, 0.20828201f, 0.19280668f, -0.31616360f, 0.09048122f, -0.01751732f, 0.15958968f, 0.14274628f, 
    0.09052670f, 0.08316731f, 0.10565021f, 0.15637957f, 0.03817003f, 0.11450990f, -0.27770668f, 0.14363390f, 
    -0.02751103f, -0.10473319f, -0.03199406f, -0.03322484f, -0.08192608f, 0.00503707f, -0.09543704f, 0.01380980f, 
    0.00663811f, 0.00231226f, 0.01361914f, 0.19931942f, -0.07952520f, -0.04584706f, -0.02871055f, -0.08189195f, 
    0.04720365f, 0.14776352f, 0.12805927f, 0.14794603f, 0.16616878f, 0.09792592f, 0.08426949f, -0.10786278f, 
    0.07226108f, 0.01870804f, 0.03484279f, 0.05531059f, -0.00096137f, -0.03921258f, -0.08471911f, -0.01645594f, 
    0.15948713f, -0.27705750f, -0.00955981f, -0.03448107f, 0.00856093f, -0.05828332f, 0.14580387f, 0.22063495f, 
    0.12460916f, 0.00360230f, 0.06098806f, 0.08092088f, -0.30527332f, 0.04104735f, 0.24225023f, -0.08690432f, 
    -0.04250262f, 0.06430803f, -0.05007173f, 0.03400067f, 0.01257910f, 0.02312014f, 0.01055816f, -0.08082400f, 
    -0.08798087f, 0.18477230f, 0.02572478f, 0.22476289f, -0.12399603f, -0.03956163f, 0.04277996f, -0.00748137f, 
    0.02718495f, 0.05841139f, 0.19005875f, 0.11829107f, 0.13612740f, -0.05450770f, 0.04997277f, -0.08009724f, 
    0.07056171f, -0.00727377f, 0.11866479f, 0.11952978f, -0.00598413f, 0.03737364f, 0.13928954f, -0.05362250f, 
    0.19280881f, 0.19072926f, 0.04785545f, -0.10044779f, 0.17229573f, 0.00916455f, 0.10296735f, -0.00861150f, 
    0.08116870f, 0.03562204f, 0.04081864f, 0.08568871f, -0.12157165f, 0.18763772f, -0.19189063f, -0.21791643f, 
    0.02378617f, -0.06349368f, -0.00464321f, -0.07537904f, -0.14752904f, -0.09044244f, 0.06758101f, 0.10248626f, 
    0.19642690f, 0.02674117f, -0.21545123f, -0.02594849f, 0.08226259f, 0.09265448f, -0.10355346f, -0.00103907f, 
    -0.12684029f, -0.10491002f, -0.04563456f, 0.04986318f, -0.01007462f, 0.15208103f, 0.01066717f, 0.22948113f, 
    0.03658945f, -0.05230128f, 0.03438085f, -0.02764506f, 0.10975192f, -0.05375311f, 0.18575639f, 0.04201634f, 
    0.06881001f, 0.11225907f, -0.00674582f, 0.11309355f, 0.04249202f, 0.04576379f, 0.02611394f, -0.05130047f, 
    0.16267504f, -0.05715418f, 0.22308740f, 0.09691790f, 0.20936333f, -0.15592399f, 0.16379628f, 0.11232729f, 
    -0.00643465f, -0.05236777f, 0.21803980f, 0.09170043f, 0.00053026f, -0.06407204f, -0.02443725f, -0.06283246f, 
    -0.19753391f, -0.17807308f, -0.06437463f, -0.11727252f, 0.14038318f, -0.02509350f, 0.13475889f, 0.00221632f, 
    -0.06760073f, -0.05934684f, -0.14194967f, -0.11793086f, 0.16955826f, 0.31422678f, -0.00917761f, -0.06791855f, 
    0.06061624f, 0.02623247f, 0.10157152f, -0.04614151f, 0.00796019f, -0.03585056f, -0.06504647f, -0.00850457f, 
    0.11555970f, 0.15495087f, 0.18638986f, -0.06965263f, 0.10257631f, -0.01479563f, 0.03598091f, 0.20590355f, 
    0.08112287f, 0.09209789f, 0.05478130f, -0.07307189f, 0.24833728f, -0.09213787f, 0.13381822f, 0.01721576f, 
    0.23496181f, 0.18432824f, 0.20192727f, 0.12476579f, -0.10044926f, -0.02136832f, -0.06962247f, 0.01005584f, 
    0.02193545f, 0.01438493f, 0.07316659f, 0.09736640f, -0.04036951f, -0.03307660f, 0.02887411f, 0.03719993f, 
    -0.03466798f, -0.04193989f, -0.02871853f, -0.06337853f, 0.05613039f, -0.10498001f, -0.18683641f, -0.02198692f, 
    0.00436836f, 0.12151659f, -0.00174276f, 0.10737681f, -0.05756542f, 0.01038169f, 0.00604024f, 0.14413834f, 
    0.07535004f, 0.27574223f, 0.00957429f, 0.21029365f, 0.04464621f, 0.07995199f, 0.11076350f, 0.04710525f, 
    -0.13399862f, -0.01685841f, 0.01322453f, 0.03710720f, -0.40457359f, -0.32276821f, -0.08244505f, -0.24667135f, 
    0.03616851f, 0.05686508f, -0.00464686f, -0.01243153f, -0.06911854f, 0.01096758f, 0.18662737f, -0.02480255f, 
    0.07825366f, 0.07840282f, 0.02239776f, -0.00446789f, -0.04845497f, 0.04368319f, 0.06490581f, 0.01159759f, 
    0.05878324f, 0.10424012f, 0.18219487f, 0.17243102f, -0.00616416f, 0.07419512f, 0.07612509f, -0.15287000f, 
    0.06421315f, -0.12857461f, -0.07420797f, 0.05757923f, 0.04220581f, 0.07901385f, 0.15162507f, 0.01812105f, 
    0.10226286f, 0.09090626f, -0.21420383f, -0.13382342f, 0.00000810f, 0.10452563f, -0.01020705f, -0.00968034f, 
    -0.05465015f, 0.02635821f, 0.04554807f, 0.02396224f, 0.09188489f, -0.04035888f, 0.13118677f, 0.11078660f, 
    0.00234707f, -0.02442473f, 0.00267852f, -0.00216371f, -0.02514423f, 0.04483671f, -0.11566609f, 0.03964401f, 
    -0.25442004f, -0.14137100f, -0.05576270f, -0.12384433f, -0.04051692f, 0.01376801f, -0.07020906f, 0.01977479f, 
    0.03691603f, 0.14990513f, -0.15389490f, -0.01218952f, -0.16630180f, 0.12728791f, -0.13773561f, -0.04231608f, 
    0.05989815f, 0.08635722f, -0.00727776f, -0.04652691f, -0.07319234f, -0.07529859f, 0.05793369f, -0.10538337f, 
    0.04197388f, -0.03267683f, -0.00659443f, 0.00663038f, 0.02255911f, 0.01132050f, -0.02238605f, -0.04914330f, 
    -0.05288780f, 0.03192473f, -0.05035720f, 0.03811742f, 0.03993296f, -0.04516298f, -0.01526680f, 0.01411331f, 
    -0.04586452f, -0.04959323f, 0.02624059f, 0.02660890f, 0.00888254f, -0.00167294f, -0.03975078f, -0.02466339f, 
    -0.02647184f, -0.01134461f, 0.01785391f, -0.00798570f, 0.01866766f, 0.03936253f, 0.02500126f, 0.02081809f, 
    0.01365209f, -0.02771862f, -0.01735507f, 0.02525445f, -0.05004871f, -0.01806546f, -0.03035559f, -0.02785615f, 
    -0.02474770f, -0.02320606f, 0.01658293f, -0.04015079f, -0.02206679f, -0.04430144f, 0.00981727f, -0.03212095f, 
    -0.04420586f, 0.00354340f, -0.03641535f, -0.05735048f, -0.03021212f, -0.00123847f, -0.04382926f, -0.00166410f, 
    -0.00581862f, -0.02519104f, -0.00285683f, 0.01379162f, 0.02440110f, 0.04101794f, 0.00914096f, -0.05379966f, 
    -0.01699160f, 0.01944391f, -0.03937940f, -0.03195954f, -0.01731262f, -0.01710312f, -0.01257446f, -0.04936730f, 
    0.03360605f, 0.00897767f, 0.01850994f, -0.05739390f, 0.00399975f, -0.00455423f, 0.00295399f, 0.03429253f, 
    0.04386285f, 0.00811474f, -0.00333802f, 0.03549279f, 0.01649867f, -0.00315650f, 0.04238709f, -0.03502809f, 
    -0.02427669f, 0.04990948f, -0.05362326f, -0.04755291f, 0.00678696f, -0.05329818f, 0.02640654f, 0.01551962f, 
    0.02584801f, -0.03219639f, -0.02065781f, -0.02526042f, 0.03126067f, -0.03310163f, -0.00007557f, -0.05421469f, 
    0.00425633f, -0.03822164f, -0.04740284f, 0.01973346f, 0.02367520f, -0.02724597f, -0.03821931f, 0.03718919f, 
    -0.00011128f, -0.02800427f, 0.02329044f, -0.00168586f, 0.02156674f, 0.04063161f, 0.02255334f, 0.03429900f, 
    0.02996983f, -0.00889840f, 0.01450014f, 0.04024430f, -0.01147609f, 0.02274676f, -0.01955492f, -0.01003275f, 
    -0.02310738f, 0.00756399f, 0.04375400f, -0.01035130f, 0.01732772f, -0.01613679f, 0.00650925f, -0.05020163f, 
    -0.02270104f, -0.04023623f, 0.00781290f, -0.02236564f, 0.02049072f, 0.03630865f, 0.02660254f, 0.00650808f, 
    -0.02947894f, 0.03961447f, -0.03967914f, 0.00190789f, 0.04071205f, -0.02530093f, -0.04583325f, -0.01706749f, 
    -0.00239601f, 0.00496535f, 0.03724306f, 0.00751560f, 0.02212038f, 0.00164932f, 0.03203440f, -0.01697686f, 
    0.02548786f, 0.03851250f, -0.01310816f, 0.03003973f, -0.01606802f, -0.00520570f, 0.03348407f, -0.05325537f, 
    0.01337487f, -0.01149437f, 0.03984504f, -0.01555471f, 0.01621061f, -0.04196321f, -0.04130158f, 0.05035546f, 
    -0.04258489f, 0.03591163f, -0.03165611f, 0.00975321f, 0.04636058f, -0.02697449f, 0.03485136f, -0.00292885f, 
    0.03364383f, -0.03155759f, -0.05401972f, 0.02680045f, -0.05151001f, 0.03805395f, 0.02229544f, -0.02532662f, 
    0.02587985f, -0.00938235f, -0.03848670f, -0.03212762f, -0.04301096f, 0.04218930f, -0.00755700f, -0.03418923f, 
    -0.02662081f, -0.03772784f, 0.02600304f, 0.03090622f, 0.00338688f, 0.04001373f, -0.05087431f, -0.02021733f, 
    0.01003814f, -0.04820634f, 0.01525589f, 0.01203468f, 0.00681238f, -0.01329172f, 0.02885696f, -0.03028346f, 
    -0.01435861f, -0.02529067f, 0.01275560f, 0.01927635f, 0.00693065f, 0.02867392f, -0.04765610f, -0.00875569f, 
    -0.04803225f, -0.00576736f, 0.02711368f, -0.02713326f, 0.02451226f, -0.01877331f, -0.04408559f, 0.01822930f, 
    0.02312267f, 0.03701655f, -0.03620005f, 0.03884834f, -0.00467197f, -0.01545245f, -0.05079228f, 0.04251768f, 
    0.02179851f, -0.00706773f, 0.02666998f, 0.00172554f, 0.01193564f, -0.01657098f, 0.03821514f, -0.02672714f, 
    -0.05388628f, 0.00201808f, 0.01351029f, 0.02100505f, 0.00482839f, -0.04019439f, -0.04485602f, 0.01474732f, 
    -0.02830501f, -0.05184290f, -0.01418969f, -0.00741214f, -0.01840401f, 0.01528209f, -0.00466253f, -0.03092863f, 
    0.01040284f, 0.00902592f, -0.03635919f, -0.04984239f, 0.03159056f, 0.03555021f, 0.00384171f, 0.02677434f, 
    -0.05561019f, -0.04555544f, 0.03628720f, -0.05076261f, -0.03408364f, -0.01441598f, 0.00519473f, -0.01014296f, 
    -0.01180678f, -0.00386609f, 0.00507430f, 0.00239369f, 0.01158298f, 0.00781087f, -0.00441169f, -0.05182882f, 
    -0.04370071f, 0.00373344f, 0.02080496f, 0.03972611f, 0.00024102f, -0.00749176f, -0.00200299f, 0.03386064f, 
    -0.05532627f, 0.02989338f, -0.03209184f, -0.00445390f, 0.02306625f, -0.03603434f, -0.00801792f, -0.00022066f, 
    -0.03953058f, -0.01369718f, 0.00826792f, -0.03450397f, 0.02539147f, 0.00485821f, 0.02774908f, 0.00506149f, 
    -0.00765499f, -0.01854572f, -0.05695546f, 0.00874512f, -0.02515267f, 0.03866734f, -0.01423985f, -0.04580032f, 
    -0.03670837f, -0.03476067f, 0.00522180f, -0.01901111f, 0.00062584f, 0.03098145f, 0.02978093f, -0.01006324f, 
    0.00187226f, -0.00177687f, -0.04096385f, 0.00188029f, 0.01103591f, -0.04652882f, 0.01031461f, 0.03448610f, 
    -0.03061974f, 0.02557442f, -0.01300104f, -0.02718357f, 0.02786764f, -0.04426108f, -0.01227333f, -0.02112736f, 
    -0.03577948f, 0.01628710f, 0.01600928f, -0.00271019f, 0.03053258f, -0.04839079f, -0.04409444f, -0.02069232f, 
    0.02130904f, -0.03768895f, -0.00411041f, 0.01575507f, 0.02674014f, 0.03256064f, -0.04140372f, -0.00670772f, 
    -0.02141033f, 0.00699694f, -0.02846337f, -0.05186979f, 0.02932426f, -0.04385488f, 0.00867607f, 0.00275261f, 
    -0.04293190f, -0.04487426f, -0.05240796f, 0.00150040f, 0.00663195f, 0.05134037f, -0.03181457f, 0.03391978f, 
    0.04088049f, 0.01673367f, 0.00971051f, -0.00812513f, -0.00236833f, -0.00874193f, 0.00794274f, 0.00037253f, 
    0.15555403f, 0.03416959f, -0.09341686f, 0.03775624f, 0.16037035f, 0.11364518f, 0.06319021f, 0.04580634f, 
    -0.05605851f, 0.07719799f, -0.00668412f, -0.01974244f, 0.01558949f, -0.01950030f, -0.02239889f, 0.03626601f, 
    -0.09108327f, -0.05876813f, 0.06366169f, -0.04777655f, 0.08630370f, 0.03737446f, 0.08430096f, 0.08139561f, 
    -0.18024510f, -0.12450539f, -0.09369863f, 0.21203658f, -0.01854305f, 0.14097153f, -0.02993292f, -0.12366714f, 
    0.08937213f, -0.00839603f, 0.10132694f, 0.08623666f, 0.00534017f, -0.04980910f, -0.00300514f, 0.05335494f, 
    -0.05723134f, -0.11444765f, -0.04086772f, -0.02810482f, 0.04280924f, -0.04418162f, 0.05848723f, -0.01797389f, 
    0.15847521f, 0.11956051f, 0.26823720f, -0.08877581f, 0.12828691f, 0.08023116f, 0.01221478f, 0.15061788f, 
    0.07169947f, -0.04557098f, -0.05868464f, 0.08185807f, 0.05374496f, 0.19817017f, -0.11545765f, 0.18248712f, 
    0.00558530f, 0.12207204f, -0.04794411f, 0.07537459f, 0.04318941f, 0.05479852f, 0.06049494f, 0.03634137f, 
    -0.14712000f, -0.00080342f, -0.03601279f, 0.01009432f, -0.03341476f, -0.05592252f, -0.01882492f, -0.06125711f, 
    -0.04378716f, 0.02567752f, 0.16205923f, 0.10766947f, 0.22896460f, 0.06393128f, 0.14803290f, -0.20196784f, 
    -0.02279582f, -0.03337498f, 0.02669373f, -0.14611766f, 0.11338685f, 0.05418506f, 0.03675051f, 0.03773125f, 
    -0.25070170f, -0.19229712f, -0.08736847f, 0.15080738f, 0.04829371f, 0.05037891f, -0.11372051f, 0.06947652f, 
    0.03707878f, 0.02123412f, -0.02718743f, 0.09405656f, 0.03091901f, -0.04619936f, 0.34422299f, 0.08286674f, 
    -0.04367370f, 0.04611933f, 0.01910339f, 0.01138872f, -0.07475507f, 0.01973535f, -0.11443090f, -0.02462167f, 
    -0.20166865f, -0.02078801f, 0.01770585f, -0.03286334f, -0.08954301f, -0.07442694f, -0.00730057f, -0.06186621f, 
    -0.02300259f, 0.08447656f, 0.04675239f, 0.17589907f, 0.07412470f, -0.04607883f, 0.05763688f, -0.00242305f, 
    0.13355242f, -0.02074734f, 0.11591081f, 0.00732087f, -0.03909294f, 0.01691295f, -0.06864709f, -0.18091196f, 
    0.25089306f, 0.16674860f, -0.11716465f, -0.07614237f, 0.18131864f, 0.10065028f, 0.04093612f, 0.03653316f, 
    0.01446758f, -0.01131522f, -0.06152179f, -0.01500514f, -0.00099514f, 0.27107605f, -0.21908596f, -0.11000834f, 
    0.15400597f, 0.09281539f, 0.11221632f, -0.04540038f, -0.03826219f, 0.03213150f, -0.06612308f, 0.09804436f, 
    0.19223568f, -0.02431244f, -0.14853325f, 0.15783827f, 0.13229820f, 0.08030996f, -0.03479938f, 0.12347113f, 
    -0.05506549f, 0.05879346f, -0.02251042f, 0.05104129f, -0.02735725f, 0.33275563f, -0.10492647f, -0.03972711f, 
    -0.01124898f, -0.00037545f, -0.02303235f, -0.01981737f, 0.11984053f, 0.10038171f, -0.03736068f, -0.02644717f, 
    -0.18828763f, -0.05415959f, -0.06372771f, -0.03365968f, 0.03772220f, -0.01067722f, 0.01668895f, -0.02466140f, 
    -0.00305077f, -0.07581029f, 0.06701113f, -0.01450736f, -0.18403649f, -0.00913531f, 0.12223104f, 0.03786403f, 
    -0.01253482f, -0.01427867f, -0.11534835f, 0.07226043f, -0.07186571f, 0.03018401f, -0.04900264f, -0.02331070f, 
    0.09615391f, -0.21445201f, 0.04150585f, -0.01588680f, 0.12830448f, 0.18117262f, 0.06554759f, 0.11366823f, 
    -0.03828334f, 0.08889143f, -0.00548609f, -0.01053319f, 0.21204773f, 0.30554718f, -0.03414145f, -0.04206991f, 
    0.16508514f, 0.16117041f, 0.08098452f, 0.02997974f, -0.04634277f, -0.03321014f, -0.01295973f, 0.01601020f, 
    0.19523053f, 0.11633739f, 0.19329156f, -0.09122156f, 0.01436127f, 0.01707488f, 0.04838254f, 0.07746791f, 
    -0.01303602f, -0.03063064f, -0.16798149f, -0.04017606f, -0.16583601f, -0.09113758f, 0.28444561f, 0.19492035f, 
    0.04788983f, 0.06229286f, -0.01891188f, -0.06421746f, -0.02540196f, 0.02880677f, -0.03186043f, -0.09996065f, 
    -0.25717071f, 0.04102225f, 0.05370412f, 0.16711792f, -0.10912986f, -0.07745006f, -0.00868358f, -0.01976964f, 
    -0.06570109f, -0.00920750f, -0.02679609f, -0.02078815f, 0.08820975f, 0.10011540f, -0.00706183f, 0.17583115f, 
    -0.13287266f, -0.00832029f, -0.01779944f, 0.10418681f, -0.04085765f, -0.00222755f, -0.09117721f, -0.00222591f, 
    -0.43493763f, 0.40688640f, 0.08645843f, -0.03093915f, -0.00513837f, -0.01161601f, -0.07580288f, 0.00044124f, 
    -0.02155722f, -0.01150990f, 0.00064071f, -0.01077586f, 0.14936246f, -0.17751552f, -0.16210194f, -0.18326150f, 
    0.03754049f, 0.06575727f, 0.03672338f, 0.05272320f, -0.05419514f, -0.00178276f, 0.02099152f, -0.07908219f, 
    -0.05724488f, -0.06179707f, 0.18751478f, 0.02318540f, -0.07180852f, -0.01786118f, -0.07162604f, -0.04886997f, 
    0.00395870f, 0.09922979f, 0.08030779f, 0.04968603f, -0.11948943f, 0.06165834f, -0.01269587f, -0.02542334f, 
    -0.08735068f, 0.03191241f, -0.08798353f, -0.06719431f, 0.05813017f, 0.10709314f, 0.10293405f, 0.10473351f, 
    0.22144556f, 0.05593592f, -0.02803424f, 0.04328313f, 0.08853197f, -0.00230717f, 0.01677645f, 0.02103678f, 
    -0.03758922f, -0.00939140f, -0.02699468f, 0.03821983f, 0.04576422f, -0.00333609f, 0.24494684f, 0.17739649f, 
    -0.04641889f, -0.03913509f, -0.04122442f, -0.05180326f, 0.01386663f, -0.00470085f, 0.03899442f, 0.08070432f, 
    -0.05035527f, -0.25284195f, 0.01260453f, 0.00448072f, 0.03566705f, 0.05193036f, 0.06863552f, 0.04368404f, 
    0.01942588f, 0.22461282f, -0.09167719f, -0.05532818f, -0.09307531f, 0.05319546f, -0.20412961f, -0.01183544f, 
    0.16503958f, 0.02870887f, -0.01136212f, -0.02027427f, -0.02448442f, -0.04658600f, -0.06434232f, -0.14500083f, 
    -0.26722467f, 0.06936161f, -0.24351303f, -0.20752758f, 0.17753214f, 0.12860157f, 0.15821345f, -0.01463185f, 
    0.02779515f, -0.05965720f, 0.03351408f, 0.02690752f, -0.00807434f, -0.04598215f, 0.09303927f, -0.02560470f, 
    0.12008514f, 0.14157897f, -0.03754918f, 0.00313683f, -0.10417302f, -0.02484483f, -0.08395359f, 0.04429693f, 
    0.15230361f, 0.08779798f, 0.02116233f, -0.07755767f, -0.01043411f, -0.07498878f, 0.07601585f, -0.04651272f, 
    0.18779659f, 0.08711184f, -0.06975131f, -0.01644689f, 0.03943954f, 0.17669204f, 0.01414739f, 0.17390426f, 
    -0.02473454f, 0.06195229f, 0.01156790f, -0.11562001f, 0.00740449f, 0.04897306f, 0.05958507f, 0.07965431f, 
    -0.23650071f, -0.14879413f, -0.16493326f, 0.03091932f, -0.10169990f, 0.12082978f, -0.04275921f, -0.06567917f, 
    -0.14419016f, -0.08757085f, 0.06174699f, -0.14173897f, -0.24121951f, -0.16264048f, -0.21182552f, -0.07117696f, 
    0.14916299f, -0.02391898f, 0.12933750f, -0.06684656f, -0.02305593f, 0.03156947f, -0.04748142f, 0.01519030f, 
    0.15355276f, 0.05371901f, 0.06949981f, 0.02526541f, 0.05923880f, -0.01855926f, -0.04494287f, 0.03501089f, 
    0.02082041f, -0.04754333f, -0.05668636f, -0.06866017f, -0.14157191f, -0.10082773f, 0.16705394f, 0.09975154f, 
    0.00285095f, -0.00082376f, 0.13269968f, 0.10359079f, -0.03958743f, -0.07882286f, -0.07007103f, -0.10055998f, 
    0.20437416f, 0.22317691f, -0.06797358f, -0.13488173f, -0.09716528f, -0.00117835f, 0.24084118f, 0.16881858f, 
    0.06511483f, 0.21251971f, 0.02976097f, -0.22481324f, -0.01037467f, 0.06891519f, -0.18452424f, 0.13805969f, 
    -0.09713797f, 0.04765117f, 0.01721657f, 0.00219953f, 0.16365941f, -0.00653513f, -0.02862959f, 0.00110827f, 
    0.37182847f, 0.01588056f, 0.27350572f, 0.07505043f, 0.04875445f, 0.04716925f, -0.06557303f, 0.04167899f, 
    0.10146914f, 0.09706892f, -0.06501061f, -0.15023810f, -0.13514133f, -0.09350120f, 0.00167785f, -0.02387121f, 
    -0.04753903f, 0.06079592f, -0.13985044f, -0.06336661f, 0.02214804f, -0.03936767f, -0.00199380f, 0.15202391f, 
    -0.02255488f, -0.03706275f, 0.03645858f, 0.03470063f, -0.07406098f, -0.13406536f, 0.00560664f, -0.05849300f, 
    -0.08157789f, -0.01182662f, -0.03995005f, -0.00538305f, 0.09450278f, -0.48590100f, 0.00272875f, -0.23870276f, 
    -0.06691896f, 0.11078489f, -0.16337430f, 0.02354321f, 0.06132783f, 0.00407489f, 0.05098074f, -0.03623790f, 
    -0.37201190f, -0.23882510f, -0.10255381f, -0.26076278f, 0.09197934f, 0.07752013f, -0.12603791f, -0.05155561f, 
    0.09183926f, 0.00982367f, 0.00164039f, 0.01222952f, 0.18568356f, -0.12300608f, 0.29446974f, 0.01398946f, 
    -0.00737508f, -0.02123575f, -0.00676517f, -0.03135173f, -0.01012543f, 0.01331930f, 0.13503650f, -0.06557703f, 
    0.11562190f, 0.10455086f, 0.03594561f, 0.09445409f, -0.03993821f, 0.02883060f, -0.13491260f, 0.00270602f, 
    -0.01775242f, 0.06989362f, -0.01107497f, -0.00404121f, 0.03574335f, 0.24094175f, -0.13916917f, -0.16709001f, 
    0.01244248f, 0.01926539f, 0.20377983f, -0.09196055f, 0.08317406f, 0.03648545f, 0.18626177f, 0.00831765f, 
    -0.01391053f, 0.03273775f, -0.09828893f, 0.01450946f, -0.11117092f, -0.07845256f, -0.07845775f, 0.05275647f, 
    0.04961842f, 0.06719593f, 0.03986081f, -0.01437279f, -0.31748542f, -0.32465649f, -0.12788486f, -0.08304578f, 
    0.03222355f, 0.04289515f, -0.04534478f, 0.10128812f, 0.00026855f, -0.00128171f, 0.09433104f, -0.01885639f, 
    -0.25530627f, -0.06923991f, -0.05621081f, 0.06397425f, -0.09414474f, 0.07647516f, 0.12400431f, 0.06047764f, 
    0.06820801f, -0.16340683f, 0.06030666f, 0.01010440f, -0.11325590f, -0.04046870f, -0.16821766f, 0.34460199f, 
    0.07214344f, -0.00912429f, -0.08174347f, 0.21517050f, -0.00324047f, 0.02902184f, 0.04233188f, 0.01812093f, 
    0.08325867f, 0.08586743f, 0.02124304f, 0.07207221f, 0.04904136f, -0.00261547f, 0.00544475f, -0.04433184f, 
    0.09352313f, -0.00454217f, 0.04740359f, 0.15070841f, 0.13216686f, -0.11137455f, 0.21759941f, 0.13299949f, 
    0.09377038f, -0.01081137f, 0.00682518f, -0.09338255f, 0.05290189f, 0.04714661f, -0.01112240f, 0.02937965f, 
    0.39360765f, -0.00776475f, 0.13661495f, 0.04885222f, 0.03504241f, -0.01023629f, -0.00986469f, 0.00464010f, 
    0.09987125f, 0.06279425f, -0.13231483f, 0.03871915f, 0.16694325f, 0.15942335f, 0.17017955f, 0.10512868f, 
    -0.11458467f, -0.18619853f, -0.16673934f, -0.08308485f, -0.17039742f, -0.02683555f, 0.19615380f, 0.05634362f, 
    0.18208463f, 0.06738017f, -0.05696669f, 0.01970505f, 0.05778071f, -0.01025224f, -0.01569664f, 0.06495541f, 
    0.19556682f, -0.20128709f, 0.16673729f, -0.01448317f, -0.03860954f, 0.11076767f, 0.03540920f, 0.13451600f, 
    -0.01725350f, 0.01117541f, 0.13872777f, 0.02784543f, -0.05574695f, -0.05710701f, 0.02643861f, -0.00293966f, 
    -0.27531636f, -0.10283241f, -0.04498512f, -0.21045916f, 0.09774774f, -0.00133177f, 0.05018944f, -0.01155728f, 
    0.03532366f, -0.01639736f, 0.02617621f, -0.01849779f, 0.10792921f, 0.20310275f, -0.14072549f, 0.16632737f, 
    0.07118875f, 0.00051620f, 0.04526897f, 0.00697436f, 0.03106650f, -0.05018568f, -0.03872430f, 0.05690027f, 
    0.16670115f, 0.08656614f, -0.04816807f, -0.26437178f, -0.08194736f, -0.05925216f, -0.14937286f, 0.10437326f, 
    0.04434799f, 0.02093904f, 0.22528562f, 0.09376010f, 0.06377286f, -0.21225686f, 0.10787756f, -0.16215011f, 
    -0.14574006f, -0.09232211f, 0.04741985f, -0.01149170f, 0.11630964f, 0.08886866f, 0.10910151f, 0.15823281f, 
    -0.27496970f, -0.19248725f, -0.13333739f, -0.02906724f, 0.07007860f, 0.03504383f, 0.01878491f, 0.17642273f, 
    -0.03063416f, 0.00472481f, 0.15564047f, 0.04531459f, -0.03136489f, 0.12187406f, -0.00576121f, -0.01453539f, 
    0.04678335f, -0.02737095f, -0.03755268f, 0.13006607f, -0.10147422f, -0.09763736f, -0.00592874f, -0.15014254f, 
    -0.04213560f, -0.06156838f, 0.11217216f, -0.07947385f, 0.13171779f, -0.08833737f, 0.05074049f, 0.17767453f, 
    -0.05598494f, 0.16731377f, -0.08469685f, -0.08920803f, 0.22353043f, 0.25451270f, 0.08449008f, -0.08362459f, 
    -0.09309445f, -0.06586631f, -0.11197211f, -0.02541153f, 0.00467049f, -0.00270037f, -0.06659249f, -0.05494788f, 
    -0.00073067f, 0.03191353f, -0.08486000f, 0.11994995f, -0.02663900f, 0.16046570f, 0.05911921f, -0.09594223f, 
    0.00954336f, 0.01884798f, 0.27306673f, -0.01999559f, -0.18943326f, 0.08897913f, 0.11906379f, 0.06137224f, 
    0.06837989f, -0.11006112f, 0.06984805f, 0.02226735f, -0.06295624f, 0.01068456f, -0.13838013f, -0.10059756f, 
    0.07556134f, -0.02689630f, 0.12301216f, 0.02690565f, -0.10560787f, -0.05544315f, -0.08038837f, -0.01436336f, 
    -0.03919301f, 0.05112705f, -0.14369427f, -0.11790342f, 0.25264752f, -0.04165079f, 0.03389329f, -0.00373104f, 
    0.13700889f, -0.03151040f, 0.00301258f, 0.11495241f, -0.09831929f, -0.14489836f, -0.06202002f, -0.14545687f, 
    -0.02729638f, -0.10029941f, -0.08841709f, -0.01347520f, -0.03122052f, -0.02981639f, 0.30125773f, 0.12862837f, 
    0.00220231f, 0.18499066f, -0.03004229f, 0.18279108f, 0.17438009f, -0.00267635f, 0.04573149f, -0.07452342f, 
    0.05032720f, 0.00207529f, 0.12656936f, -0.01380787f, 0.14026682f, 0.11776324f, 0.24462628f, 0.14373776f, 
    0.12854537f, 0.20209993f, 0.04961828f, 0.03789858f, -0.07636277f, 0.06150738f, -0.04256545f, -0.05322506f, 
    0.06607611f, -0.01308155f, 0.08018303f, -0.16860048f, 0.17493269f, -0.11304490f, -0.09687725f, -0.00647922f, 
    -0.03741326f, 0.07282415f, 0.14678301f, 0.08393991f, 0.05105298f, -0.09811692f, 0.21243757f, 0.20994376f, 
    -0.17315100f, -0.30679995f, -0.15150253f, -0.15097800f, -0.02541153f, -0.12211238f, -0.03046232f, 0.01784589f, 
    -0.06136250f, 0.02512283f, 0.05523201f, 0.12017071f, -0.03225854f, -0.28532523f, -0.07397384f, -0.22523062f, 
    0.06977049f, 0.08099817f, -0.09917022f, 0.19597742f, -0.12416748f, 0.04893660f, -0.05944626f, 0.00792332f, 
    -0.02501550f, -0.22520928f, -0.05462683f, -0.15204328f, 0.00595310f, -0.05671874f, 0.05420487f, 0.01819764f, 
    0.03839838f, -0.10796238f, -0.13626616f, 0.06097682f, 0.13194147f, -0.05002550f, -0.14876454f, 0.05418817f, 
    0.04585847f, 0.09154023f, -0.07850092f, 0.05432563f, -0.01461717f, 0.07662658f, 0.25906157f, 0.13462457f, 
    0.12383349f, 0.16888334f, 0.05686169f, -0.02300574f, -0.12029067f, 0.06766103f, -0.09775201f, -0.08781753f, 
    0.15208538f, 0.08721208f, 0.02747071f, 0.05661958f, 0.18511942f, -0.00290087f, 0.35245094f, 0.07698382f, 
    -0.08622996f, -0.00655485f, 0.23064807f, 0.04050685f, 0.04029970f, -0.04817589f, 0.05313623f, 0.02943605f, 
    -0.07801974f, -0.11028393f, -0.11207711f, -0.16517206f, -0.08907367f, 0.06484558f, 0.10067727f, 0.09391042f, 
    -0.05763418f, -0.07553384f, -0.08590163f, -0.07837541f, -0.02506529f, 0.11520198f, -0.11294031f, -0.13606988f, 
    0.03932371f, -0.07339399f, 0.02552363f, 0.10210893f, -0.04961820f, -0.11398017f, -0.01850721f, 0.04569415f, 
    -0.02937145f, -0.16623056f, -0.20952046f, 0.03529419f, 0.05652985f, 0.13351075f, 0.05745303f, 0.11493757f, 
    0.01491178f, 0.06267743f, 0.14698955f, -0.00193021f, 0.33694232f, 0.25898397f, 0.12613694f, -0.04833683f, 
    -0.10864273f, -0.18950383f, 0.12301408f, 0.05553358f, -0.02637621f, 0.02473286f, -0.00570362f, 0.07412785f, 
    0.16726264f, 0.13429022f, 0.22319913f, 0.01648646f, -0.09788848f, 0.04838669f, -0.01490903f, -0.02103268f, 
    0.05664982f, 0.04191638f, -0.09816950f, 0.04011237f, 0.08802588f, -0.04725349f, 0.00692889f, 0.02771164f, 
    -0.05012472f, -0.06473613f, -0.03446484f, -0.01470133f, 0.01521955f, -0.03085710f, 0.10707923f, 0.12787770f, 
    0.35017839f, 0.22847104f, 0.07072381f, 0.22869375f, -0.00544575f, 0.01063637f, -0.02888608f, -0.04429868f, 
    0.01525594f, 0.16061109f, -0.01628177f, -0.07463111f, 0.38188314f, -0.05812490f, -0.27802241f, -0.21512339f, 
    -0.10886434f, -0.06079089f, -0.08442770f, -0.12228126f, 0.00583117f, 0.06697129f, 0.19065985f, 0.09155994f, 
    0.16535674f, 0.17915694f, 0.10157119f, 0.17889009f, -0.04595476f, 0.08628418f, 0.12977563f, 0.00786052f, 
    0.04576109f, 0.11168728f, 0.24307826f, 0.16636425f, 0.20279075f, -0.02457762f, 0.13853760f, -0.05606078f, 
    -0.19993480f, -0.07645024f, -0.01361118f, -0.05051293f, 0.02845321f, -0.06059937f, 0.02271154f, -0.03622654f, 
    -0.07364067f, -0.22073935f, -0.16083091f, -0.09844258f, -0.07982773f, 0.04407048f, 0.05254469f, 0.07123903f, 
    -0.05840116f, 0.01755974f, 0.04898069f, 0.18683590f, 0.17375034f, 0.32373717f, 0.23603530f, -0.10291368f, 
    -0.07677729f, -0.09834121f, -0.02709609f, 0.03224412f, 0.06066656f, 0.04072560f, -0.06042201f, -0.02037308f, 
    -0.21906462f, -0.29479092f, 0.00740853f, -0.01504902f, -0.12331823f, -0.07835888f, 0.01392726f, -0.00576095f, 
    0.11828937f, 0.02109463f, -0.03720368f, 0.02309240f, -0.08832972f, -0.19713394f, -0.09086103f, 0.08789048f, 
    -0.12845606f, -0.01072396f, 0.04389250f, 0.05582771f, 0.09628161f, 0.08963084f, 0.09894006f, 0.13977143f, 
    0.46961197f, 0.18705432f, 0.08409811f, 0.15276627f, 0.04957835f, 0.06966201f, 0.23372474f, 0.29447100f, 
    -0.02765544f, 0.12680762f, -0.03623569f, -0.00963023f, 0.11849134f, -0.13790120f, 0.06580145f, -0.05916580f, 
    -0.02246528f, 0.12557790f, -0.04853791f, 0.07826132f, 0.03602859f, 0.08347209f, -0.02093449f, 0.08854229f, 
    0.05206458f, 0.04895895f, -0.02383050f, 0.00961360f, 0.05120226f, 0.00707845f, 0.13303995f, -0.03202378f, 
    0.04402390f, 0.06973720f, 0.03252579f, 0.17574510f, -0.06077106f, -0.06747937f, -0.12605800f, 0.09122730f, 
    -0.06288808f, -0.00197734f, 0.05407627f, -0.10081065f, 0.08563168f, -0.03304009f, -0.00396454f, 0.02720540f, 
    0.14276345f, 0.09387311f, 0.10305741f, -0.10265051f, 0.01844758f, 0.13788447f, 0.02553543f, 0.16844836f, 
    -0.02917453f, -0.02199248f, 0.02994366f, 0.00635357f, 0.02310738f, 0.01876081f, -0.21073644f, 0.10394465f, 
    -0.02194830f, 0.06701526f, 0.10259216f, -0.01765320f, -0.02528261f, -0.00918513f, -0.00775685f, 0.02005479f, 
    0.03499712f, 0.08690833f, -0.00169709f, 0.06228181f, -0.09355284f, -0.06729852f, -0.11016951f, -0.03552618f, 
    0.03839202f, 0.11078166f, 0.10365368f, 0.12922309f, 0.04584428f, -0.14844880f, 0.09088396f, -0.01121642f, 
    0.08206923f, -0.07019366f, 0.12045771f, -0.06109981f, 0.08915734f, 0.09567768f, 0.07253779f, 0.17348517f, 
    -0.06232297f, -0.11088802f, 0.22774911f, -0.31306350f, -0.00227720f, 0.07238630f, 0.03541161f, 0.11894654f, 
    0.07852791f, -0.01502740f, 0.14570116f, 0.00148085f, -0.18784274f, 0.14441790f, -0.02635195f, 0.13233396f, 
    0.03149125f, -0.05138145f, 0.04976545f, -0.01297205f, -0.00058936f, -0.18260276f, -0.14220956f, -0.17490903f, 
    0.02922676f, -0.10270415f, 0.15438457f, 0.11486162f, -0.14745770f, -0.06801189f, -0.08511663f, -0.05150723f, 
    0.00474785f, 0.02543303f, -0.00420698f, 0.07137962f, -0.04734439f, -0.12028036f, -0.02432400f, -0.07568055f, 
    0.10011200f, -0.07043367f, -0.05852158f, -0.04609351f, -0.06455369f, -0.04152774f, -0.04904909f, -0.21976285f, 
    -0.01826290f, 0.11869087f, 0.12655440f, 0.13462190f, 0.12956412f, 0.11158176f, 0.12784179f, 0.12473993f, 
    0.22039738f, 0.08375315f, 0.06736627f, 0.12187617f, 0.04381109f, 0.45208269f, -0.45062342f, 0.06820234f, 
    0.02623891f, 0.11045898f, 0.00490555f, 0.06700851f, 0.03169880f, -0.07347543f, 0.03710457f, 0.02506314f, 
    0.15784071f, -0.09134868f, -0.28685805f, 0.04758903f, 0.11689021f, 0.01478703f, 0.00480430f, 0.15815248f, 
    0.03099196f, -0.03230929f, 0.02123915f, 0.08364172f, 0.27655721f, 0.05550750f, 0.13620694f, -0.06567103f, 
    -0.01495556f, -0.03486093f, -0.04453406f, -0.14719369f, -0.03455471f, -0.04015088f, -0.08381778f, -0.14404216f, 
    -0.04875686f, 0.06664202f, -0.04779560f, 0.05300434f, -0.03505395f, -0.00882850f, -0.04932469f, -0.10400282f, 
    -0.00980134f, 0.05010242f, -0.00759956f, -0.01245170f, -0.10135003f, 0.17064899f, -0.27463838f, 0.11086512f, 
    0.07018247f, -0.03065627f, 0.10861302f, -0.05230189f, 0.01279713f, -0.08208510f, -0.12561099f, -0.04182482f, 
    -0.07579040f, -0.02776080f, -0.12514456f, -0.19032300f, -0.12302976f, -0.05683767f, 0.08626976f, 0.09605271f, 
    0.03185694f, 0.01181204f, 0.05359754f, -0.02266627f, -0.10456043f, 0.10963070f, 0.22982806f, -0.03816046f, 
    0.03023270f, 0.08429606f, -0.12406613f, 0.02946825f, -0.01043715f, -0.03584873f, -0.02273987f, 0.02302805f, 
    -0.02164295f, 0.03719984f, 0.15974584f, 0.06465663f, 0.07912353f, -0.00756109f, 0.10535859f, 0.04718738f, 
    -0.07044758f, 0.03834467f, -0.04310780f, -0.02558010f, 0.02845072f, -0.19513384f, -0.15733223f, 0.19508803f, 
    0.15331136f, 0.09831294f, 0.09121137f, 0.07192914f, -0.10259789f, -0.08632236f, -0.09847537f, -0.13111903f, 
    -0.14015800f, 0.00970161f, -0.03429267f, 0.12567219f, 0.04106416f, -0.03948307f, 0.06863566f, -0.04489275f, 
    -0.03623647f, -0.05434348f, -0.10505696f, 0.07401066f, -0.01480247f, -0.13422450f, -0.10586550f, -0.03763952f, 
    0.02330524f, 0.06643355f, 0.09649389f, 0.13070028f, -0.03808556f, 0.03136223f, -0.03495376f, -0.02278260f, 
    0.15599450f, 0.02146950f, 0.15386999f, -0.23378873f, 0.00385029f, 0.06991107f, -0.11246156f, -0.03579646f, 
    -0.06220820f, -0.02682508f, 0.02451304f, 0.12024052f, -0.04726860f, -0.13533296f, 0.00424232f, -0.09248397f, 
    -0.10237931f, -0.02175760f, -0.03776393f, -0.11408284f, 0.03832748f, -0.02303148f, 0.03939471f, 0.03735115f, 
    -0.04645843f, 0.17410430f, 0.06395742f, -0.02871916f, -0.00375445f, 0.08238652f, -0.13548313f, 0.00371963f, 
    0.15676926f, -0.02082115f, -0.05376846f, 0.10089580f, -0.19592409f, 0.09386544f, 0.02352218f, 0.18082708f, 
    0.11919758f, -0.10449608f, 0.03270725f, -0.04621365f, 0.02752588f, 0.13469853f, 0.10256786f, 0.02812007f, 
    0.00475092f, 0.02922196f, -0.12503654f, -0.05458697f, 0.03265826f, -0.00555696f, -0.05676383f, 0.09419892f, 
    0.02985044f, 0.01555882f, -0.00687849f, 0.06297004f, 0.02571548f, -0.11211227f, 0.00942796f, 0.25920260f, 
    -0.00238658f, -0.03885353f, 0.07932885f, -0.00170212f, 0.08815289f, -0.05304730f, -0.13472694f, 0.09816077f, 
    0.02108903f, 0.08335210f, -0.11333928f, -0.28447273f, -0.03061821f, 0.01400510f, -0.12031520f, 0.04209257f, 
    0.00151113f, 0.03512413f, 0.05039826f, -0.00735194f, 0.00469182f, 0.02552428f, -0.00791436f, -0.05899964f, 
    0.06651118f, 0.05326025f, -0.00429162f, 0.02951248f, -0.09641239f, -0.14112750f, -0.05301422f, -0.15907311f, 
    -0.04849323f, -0.04321788f, -0.05147885f, -0.00936967f, -0.05022653f, 0.01049723f, -0.00172415f, -0.04138640f, 
    -0.01906072f, -0.03909104f, -0.00132288f, 0.01657934f, 0.03142773f, 0.00269026f, -0.04130727f, -0.00981919f, 
    0.05391322f, 0.00327870f, -0.00030294f, -0.02460612f, -0.02729026f, -0.00986533f, -0.03992761f, -0.05777075f, 
    -0.01035005f, -0.01365719f, 0.00487688f, 0.03415427f, -0.01459493f, -0.00049107f, -0.05538822f, -0.03820692f, 
    -0.01934955f, -0.05294489f, 0.03964284f, -0.05171531f, 0.00808310f, 0.03343762f, 0.02783444f, 0.02455117f, 
    -0.01584287f, -0.00398226f, 0.03107100f, -0.02729048f, -0.01303033f, -0.02351212f, -0.01736023f, -0.03419481f, 
    -0.04228614f, -0.03234138f, 0.01725399f, -0.01889016f, 0.01325232f, 0.03080288f, -0.00524020f, 0.03599434f, 
    -0.03692309f, -0.02963145f, -0.03846176f, 0.01674382f, 0.03332325f, 0.02313455f, 0.00900493f, 0.03194956f, 
    -0.05396654f, -0.00623505f, -0.00645623f, -0.02532899f, 0.01241821f, -0.01432663f, -0.04095364f, -0.00100559f, 
    0.02904133f, -0.00000969f, -0.05404528f, 0.00595125f, 0.02586870f, -0.05638190f, -0.05249068f, 0.00377128f, 
    0.04212480f, -0.03547186f, 0.04141743f, -0.04967123f, -0.02673952f, -0.00228292f, 0.02132707f, -0.03178058f, 
    0.01663552f, 0.04318049f, -0.00183725f, 0.02722802f, -0.01934292f, 0.02467153f, 0.02822211f, -0.01526295f, 
    0.03881109f, 0.02131398f, 0.01954225f, -0.00145481f, 0.02230420f, -0.04000630f, -0.00205520f, 0.00594595f, 
    -0.03594686f, -0.05358059f, 0.04341578f, -0.03095659f, 0.01811597f, 0.00733946f, 0.02731864f, -0.02520340f, 
    0.01986960f, -0.03729108f, -0.01315837f, -0.04832200f, -0.04173104f, -0.02353516f, -0.00174933f, -0.05174770f, 
    0.02248557f, 0.01197247f, -0.03718114f, 0.01049087f, 0.00234680f, 0.01986177f, 0.00559083f, -0.01192311f, 
    0.01425790f, -0.04793786f, 0.03588556f, 0.00827812f, 0.02594144f, 0.03508008f, 0.04255755f, -0.00528184f, 
    -0.03705396f, 0.00319065f, 0.03220009f, 0.02118129f, 0.03858691f, 0.03249045f, -0.00055432f, 0.02994284f, 
    0.03354976f, 0.00035211f, 0.00380467f, -0.05542881f, 0.00345232f, -0.04116337f, -0.04453572f, -0.03688069f, 
    -0.03072765f, 0.03740559f, -0.03780432f, -0.01637425f, 0.02666004f, -0.01735995f, -0.05042811f, -0.01833540f, 
    -0.01165540f, -0.03746798f, -0.04137530f, -0.01634791f, -0.00119049f, -0.02180474f, 0.00258180f, -0.00202765f, 
    0.02056256f, 0.04201907f, -0.05149705f, 0.01226179f, -0.02977495f, 0.00877637f, 0.02132388f, -0.00642922f, 
    0.00909684f, 0.03037618f, -0.02882136f, -0.03125610f, -0.03812291f, 0.01078749f, -0.05409668f, 0.01542100f, 
    -0.04376025f, 0.04012938f, 0.00103338f, 0.03768731f, -0.01435000f, 0.03592834f, 0.03176132f, -0.00558558f, 
    -0.05244853f, 0.03708987f, -0.03809316f, 0.04375098f, 0.00617921f, 0.02687993f, -0.00658846f, 0.01819296f, 
    0.00762102f, -0.03922217f, -0.02522694f, -0.04208583f, 0.02072997f, -0.03652592f, 0.03181812f, -0.00369095f, 
    -0.00953841f, 0.02915082f, -0.01113403f, 0.01489416f, -0.05298164f, -0.05428804f, 0.00006409f, 0.03355540f, 
    0.00062429f, -0.04201353f, 0.00998689f, -0.02185059f, -0.04032899f, 0.03540492f, -0.01784051f, 0.03236062f, 
    0.01930811f, -0.02143415f, 0.00312536f, -0.04985146f, -0.03520251f, 0.01057002f, -0.05079399f, -0.01078700f, 
    0.00680228f, -0.04930118f, -0.00307333f, 0.00718729f, -0.05537936f, 0.04486174f, -0.03274744f, 0.03728261f, 
    -0.02273230f, -0.01292646f, 0.03154104f, -0.01872081f, -0.03789028f, -0.01911570f, -0.04406244f, -0.01332866f, 
    -0.01958016f, 0.02809663f, -0.02544003f, -0.02388893f, 0.04138954f, -0.01137826f, -0.01627016f, 0.00359377f, 
    -0.05490860f, -0.05338395f, 0.04022070f, -0.00279687f, 0.03163969f, -0.00581013f, 0.04032442f, 0.00400392f, 
    -0.02497225f, -0.02822857f, 0.02247675f, -0.03179803f, 0.01548105f, -0.05115461f, -0.00686009f, 0.02230688f, 
    0.04144203f, 0.01494344f, -0.00144790f, 0.02363667f, -0.02394551f, 0.01309576f, 0.05301945f, -0.03879017f, 
    0.01914877f, 0.00117849f, -0.01071737f, 0.02679532f, 0.01580270f, 0.03767532f, 0.02216445f, -0.05300811f, 
    0.00436503f, -0.01018793f, 0.03610651f, 0.02053505f, 0.00692796f, 0.01699609f, -0.02227048f, 0.03068844f, 
    -0.00816546f, -0.01563654f, 0.01895580f, -0.00303290f, 0.03455774f, 0.00930105f, 0.02167378f, 0.02144967f, 
    -0.01402655f, 0.03026504f, -0.01250485f, -0.00714096f, 0.04147783f, 0.03531903f, 0.01742685f, -0.05022135f, 
    -0.00107938f, -0.04660380f, -0.04989054f, -0.03769055f, -0.01194320f, -0.01594772f, 0.01217871f, 0.02516551f, 
    0.04108479f, -0.04622466f, -0.00612978f, -0.02102526f, -0.03249770f, 0.02014247f, -0.05222673f, 0.01061914f, 
    0.04030989f, 0.00585574f, -0.01914324f, -0.01640971f, -0.05041124f, 0.03339949f, -0.02418716f, 0.02409406f, 
    -0.02351776f, -0.00316014f, -0.05460375f, -0.02299920f, -0.02056063f, 0.04890806f, -0.03494851f, -0.00661602f, 
    -0.05439737f, 0.02640246f, -0.05268799f, 0.03422263f, -0.01331324f, -0.04390086f, 0.00697800f, -0.03145498f, 
    -0.01405671f, 0.00063179f, 0.02466776f, -0.04511379f, -0.02021743f, 0.02685819f, 0.02883141f, 0.03179071f, 
    -0.03526313f, -0.05131306f, 0.03983780f, -0.01947729f, -0.04948997f, -0.03553015f, -0.05298785f, -0.00150379f, 
    0.01329225f, 0.04451430f, 0.01712605f, 0.02006511f, 0.04663449f, 0.02129795f, -0.05470351f, 0.01706824f, 
    0.03058641f, -0.02979236f, -0.05553227f, -0.05765991f, 0.00781090f, 0.02696801f, -0.01088094f, -0.05654368f, 
    -0.00055495f, -0.11028130f, 0.29090524f, 0.26113239f, -0.10976931f, -0.06562956f, -0.09351266f, 0.03564477f, 
    0.05604756f, -0.03568099f, 0.15142466f, 0.02961113f, 0.07060403f, 0.12171217f, -0.04850178f, 0.05051897f, 
    0.08862894f, 0.01574471f, 0.14264011f, 0.03947878f, -0.02427494f, -0.12655418f, -0.12947704f, -0.13645104f, 
    0.16820306f, -0.05283077f, 0.09025413f, 0.10374988f, -0.00153540f, 0.11551419f, -0.07265315f, 0.13975142f, 
    -0.14783120f, -0.05485512f, 0.07168298f, 0.00487943f, 0.04285534f, -0.02118900f, 0.09116378f, -0.00404237f, 
    0.00792546f, -0.02702780f, -0.04435575f, -0.07547808f, 0.00378595f, -0.00681989f, -0.07194902f, -0.02500319f, 
    -0.10850581f, 0.16115440f, -0.03980487f, 0.00763489f, 0.02500501f, -0.04832737f, 0.02008515f, -0.01412039f, 
    0.00393846f, 0.07363553f, -0.01120920f, 0.05563927f, 0.14396685f, 0.08761821f, 0.21982314f, 0.05381723f, 
    -0.02263014f, 0.07097883f, -0.03967564f, 0.02000365f, -0.04660908f, -0.05599955f, -0.06278682f, -0.02841873f, 
    0.06331550f, -0.02170073f, -0.01200254f, 0.15341040f, 0.00987180f, 0.07460660f, 0.02231630f, -0.02995224f, 
    -0.01447837f, -0.01083455f, -0.05274612f, -0.07055569f, -0.11869156f, 0.12221979f, 0.05167586f, 0.02546899f, 
    0.02798670f, 0.14098109f, 0.07697632f, 0.06862874f, -0.08366929f, -0.03454737f, -0.14896321f, -0.13739195f, 
    -0.07442877f, -0.23267123f, -0.00907878f, -0.17677453f, 0.09444807f, -0.02791202f, -0.10200979f, 0.05471124f, 
    0.01850414f, 0.11001331f, -0.01924220f, 0.06834193f, 0.03468468f, 0.04616403f, 0.18978041f, -0.04252458f, 
    0.11258066f, -0.03457268f, 0.02976323f, -0.11045385f, 0.06411707f, 0.02101084f, 0.06034659f, 0.04759585f, 
    -0.10805798f, 0.23897740f, -0.17372571f, 0.16285992f, 0.03001192f, -0.04045090f, 0.06752393f, 0.01849622f, 
    0.08131318f, -0.05106653f, 0.09503791f, 0.02099762f, 0.08806112f, 0.04953738f, 0.03553215f, -0.20979117f, 
    -0.08407389f, -0.16828273f, -0.05775633f, 0.08409452f, 0.04250529f, 0.00822655f, 0.01353035f, 0.18928862f, 
    -0.12775445f, -0.14527200f, 0.07704078f, 0.23923995f, 0.01583437f, 0.08292191f, 0.01613450f, -0.02400881f, 
    0.02702743f, 0.08217999f, 0.09543857f, 0.04116888f, -0.20691286f, 0.21234867f, -0.01333946f, 0.35938671f, 
    0.14111704f, 0.04565916f, -0.07433810f, -0.04648159f, -0.01227073f, -0.07198623f, 0.05813456f, 0.09591225f, 
    0.01739453f, 0.18346342f, -0.05260748f, 0.15557984f, -0.01636208f, -0.08047537f, -0.01200306f, 0.01183231f, 
    -0.03807497f, -0.00364833f, -0.03329234f, -0.03651450f, -0.25775224f, 0.16516544f, -0.12775272f, 0.10226789f, 
    0.11660721f, -0.06891108f, -0.01310352f, 0.05167820f, -0.09107510f, 0.03700364f, -0.14543186f, 0.00402198f, 
    0.01462967f, -0.10745806f, -0.05278378f, 0.13364519f, -0.05420091f, -0.02381796f, 0.03149819f, -0.00988530f, 
    0.10567582f, 0.03620500f, 0.06831825f, 0.09705190f, 0.43462768f, -0.40122655f, 0.08928438f, 0.22064622f, 
    -0.01869890f, -0.10034052f, 0.12051159f, 0.13054383f, 0.02883188f, 0.01516095f, -0.01373774f, -0.05975210f, 
    -0.08070473f, 0.05831796f, 0.03054947f, -0.25024828f, 0.16625525f, -0.13468410f, -0.01059127f, -0.12303422f, 
    -0.02561761f, -0.01013108f, -0.15902512f, -0.06398444f, -0.20064120f, -0.01140725f, 0.19147351f, 0.07698330f, 
    -0.16256325f, -0.01200084f, 0.12212515f, -0.11422631f, -0.10403198f, 0.05918765f, -0.04410337f, -0.04672312f, 
    -0.09270813f, -0.05045969f, 0.00593385f, 0.18616834f, 0.13354744f, -0.03744302f, -0.06262081f, 0.00386826f, 
    0.03411954f, 0.11684159f, 0.22255433f, 0.05087648f, 0.37452394f, 0.19411646f, 0.18004487f, -0.17798667f, 
    0.02509333f, 0.11811672f, -0.09527605f, 0.03638317f, 0.01830858f, -0.02157548f, -0.01728529f, 0.04918769f, 
    0.20850930f, -0.08027416f, 0.04631295f, 0.02957499f, -0.04827183f, 0.05096025f, -0.03272380f, 0.02654534f, 
    -0.01010927f, 0.02819857f, 0.04639097f, -0.05186891f, 0.18852042f, 0.16887951f, 0.00605467f, 0.08427472f, 
    0.10508093f, 0.17164151f, 0.09839416f, 0.08669095f, 0.01731125f, -0.05144478f, -0.00115542f, 0.04358885f, 
    -0.11966313f, 0.22152099f, -0.10008281f, 0.14656261f, 0.08387975f, -0.01479014f, 0.09921351f, 0.11976254f, 
    -0.06938622f, -0.02752131f, 0.01782756f, 0.06717602f, -0.20095456f, -0.17696969f, -0.06653947f, -0.16349959f, 
    0.02358181f, -0.11131041f, -0.09077194f, -0.05025870f, -0.06471948f, 0.05025872f, 0.02108627f, -0.02447282f, 
    0.06442890f, -0.16776198f, 0.09902516f, 0.01729647f, 0.05802654f, 0.02639323f, 0.07953579f, 0.20436598f, 
    -0.02433348f, 0.02767347f, 0.02962042f, -0.00914193f, 0.31514564f, -0.06596734f, 0.08722804f, -0.11157934f, 
    -0.02333192f, 0.01137300f, -0.14079167f, -0.00500268f, -0.01493980f, -0.02382118f, 0.02138659f, -0.12200169f, 
    0.00048098f, 0.06557121f, 0.02732576f, 0.18919048f, -0.01458450f, -0.10701224f, -0.02216716f, -0.03590997f, 
    0.08617606f, 0.05735448f, 0.01283899f, 0.06132764f, 0.05456815f, 0.01099097f, 0.18409678f, -0.14206076f, 
    0.00679293f, -0.00176010f, 0.00734852f, -0.01187913f, -0.06452435f, 0.11699083f, 0.10562529f, -0.05747925f, 
    -0.14157993f, 0.14586280f, 0.01796486f, 0.10099902f, 0.01979672f, -0.02233406f, 0.15613189f, -0.10779908f, 
    0.03109233f, 0.07903685f, -0.12770078f, 0.01359158f, -0.19294544f, 0.11561035f, -0.11906637f, 0.00279571f, 
    0.05991792f, -0.10264611f, -0.04861394f, -0.01408260f, 0.02182077f, 0.10028605f, 0.04780694f, 0.05705965f, 
    0.05612737f, -0.04808120f, -0.01704809f, 0.10430720f, 0.14390615f, 0.07240976f, -0.01328415f, 0.08969782f, 
    0.01895011f, -0.03447207f, 0.03454007f, -0.02422042f, -0.02121414f, -0.06242685f, -0.05984346f, 0.07127192f, 
    0.00752627f, -0.02280797f, 0.08390061f, -0.00688783f, 0.08582836f, 0.05623854f, 0.08413491f, 0.11557361f, 
    -0.26213127f, 0.01318108f, -0.07158735f, 0.15273264f, 0.00883025f, -0.06238518f, 0.02092849f, -0.08403248f, 
    0.18828240f, 0.10684212f, 0.19732678f, 0.12755580f, 0.04573118f, 0.02881148f, -0.05044701f, -0.17339711f, 
    -0.01087726f, -0.10264523f, 0.03880196f, 0.03096709f, 0.07413496f, -0.08209566f, 0.08222661f, -0.06084828f, 
    0.22304812f, -0.02966485f, -0.01962177f, 0.20488176f, 0.04885793f, 0.05172488f, 0.05017683f, -0.04915234f, 
    0.10947388f, 0.05075669f, 0.09649380f, 0.02654238f, 0.01459425f, 0.09985180f, 0.03671947f, 0.20781304f, 
    -0.01447547f, 0.11184631f, -0.06458590f, -0.01234441f, 0.03292004f, 0.04907512f, -0.02674550f, 0.06516816f, 
    -0.20418701f, -0.03038981f, -0.04565369f, -0.19668630f, -0.04274344f, -0.03942788f, -0.07963787f, -0.05649713f, 
    0.01392651f, 0.00136641f, 0.03282443f, 0.21162026f, 0.39949265f, -0.22760378f, -0.25261033f, -0.09603481f, 
    0.05382324f, -0.13750893f, 0.00929521f, -0.07768027f, 0.04469884f, 0.20593843f, 0.09096611f, 0.07874449f, 
    -0.31061280f, 0.13984571f, -0.04615734f, 0.31873184f, -0.03040036f, 0.07757209f, 0.03185790f, -0.00303059f, 
    0.05178119f, -0.15493616f, 0.02675417f, 0.10124077f, 0.62630153f, 0.06996899f, -0.11851946f, -0.22953543f, 
    0.03515475f, -0.05114346f, 0.04954179f, -0.07897072f, 0.08499844f, -0.03402018f, 0.10906781f, 0.05872630f, 
    -0.08838598f, -0.13670078f, 0.07005467f, -0.33462736f, -0.04090833f, -0.03930768f, -0.05206078f, -0.09699429f, 
    0.04926594f, -0.02800030f, -0.00754332f, 0.16607247f, 0.15376560f, -0.15691893f, -0.07518072f, 0.19259152f, 
    0.08084044f, 0.05794907f, 0.29283136f, 0.15583080f, -0.10600580f, -0.05230031f, -0.11519121f, -0.12518629f, 
    -0.05586408f, -0.10086877f, -0.13971241f, -0.06397548f, -0.01502150f, 0.09054713f, 0.03901721f, 0.05327994f, 
    0.06066693f, -0.01338606f, 0.00704961f, 0.13818312f, -0.07267144f, 0.10256343f, -0.27415419f, -0.03746503f, 
    0.03284671f, 0.05873930f, -0.01048062f, -0.04155175f, -0.08753528f, 0.04859209f, -0.08710963f, 0.13627397f, 
    -0.13673188f, -0.06110081f, -0.16096303f, 0.26078069f, 0.03852061f, -0.03950359f, -0.07184865f, 0.00173774f, 
    -0.11480642f, -0.06367519f, -0.05493032f, 0.17466323f, -0.05234607f, 0.13639817f, 0.01297202f, -0.17119981f, 
    0.03003889f, 0.01913800f, -0.07862747f, 0.06083983f, 0.10233492f, 0.06894683f, 0.12998931f, 0.00060477f, 
    -0.02586656f, -0.04562873f, -0.13937891f, -0.27409232f, -0.04849423f, -0.02883763f, -0.00584774f, -0.06529620f, 
    -0.00514677f, 0.06552830f, 0.16368507f, 0.10703303f, -0.23682024f, -0.01398322f, -0.00605676f, 0.08539344f, 
    -0.08236507f, 0.12487409f, 0.02013000f, 0.01013558f, -0.02493097f, -0.04565120f, 0.04657815f, -0.02408287f, 
    0.15478216f, -0.12948827f, 0.01884104f, 0.35024965f, 0.01507118f, 0.14405565f, 0.04576546f, 0.15588844f, 
    0.03867092f, 0.00614643f, 0.06677441f, 0.08935328f, -0.07469185f, 0.16156523f, -0.00791767f, 0.07306725f, 
    0.04685571f, 0.08732804f, -0.03330628f, -0.04754654f, -0.02523137f, -0.01847465f, -0.07924761f, 0.02712398f, 
    0.28641704f, -0.13001242f, -0.07012841f, -0.09639393f, 0.12473724f, 0.09692194f, 0.03161039f, -0.01733277f, 
    0.00401572f, 0.06648262f, -0.13229066f, 0.09996096f, -0.34659904f, -0.06207841f, 0.17642014f, 0.34631732f, 
    0.12415779f, 0.13337871f, 0.14319706f, -0.01811405f, 0.02226143f, -0.10362364f, -0.05236948f, -0.05014051f, 
    -0.22377551f, 0.09642482f, 0.02415782f, 0.00425035f, -0.10391363f, -0.04435809f, 0.04868843f, -0.02193641f, 
    -0.05184462f, -0.07423324f, 0.00371964f, -0.03846201f, -0.22046766f, 0.09023660f, 0.08112615f, 0.29180777f, 
    0.03468569f, 0.08560707f, -0.00552501f, -0.02693010f, -0.01509733f, -0.03520675f, 0.00036139f, -0.06216718f, 
    -0.41948837f, 0.29785234f, 0.00319164f, -0.09465175f, 0.04167755f, -0.01266709f, -0.07575416f, -0.18452068f, 
    0.10119174f, 0.09345216f, -0.02064488f, 0.00111661f, 0.43903929f, -0.10858322f, -0.19661249f, -0.06413332f, 
    0.12777235f, 0.06479067f, 0.07526746f, 0.05657667f, -0.01897869f, 0.05805400f, -0.09661389f, -0.00436269f, 
    -0.04407900f, 0.16645814f, 0.05157546f, -0.00719599f, -0.00418574f, 0.03412383f, 0.03200315f, -0.10735466f, 
    0.06289961f, 0.09668792f, 0.02147944f, 0.01001474f, -0.07886399f, 0.05525395f, -0.16208491f, -0.03974945f, 
    -0.07634878f, 0.01411995f, -0.06844363f, 0.09295427f, 0.02173044f, 0.06338955f, 0.20474790f, 0.05137013f, 
    -0.00269171f, -0.15022515f, -0.12689051f, 0.14873298f, -0.00961342f, -0.13785614f, 0.03729817f, -0.07097159f, 
    0.00212375f, 0.02928216f, -0.00101619f, -0.00291561f, -0.14638741f, 0.09751727f, 0.10834876f, 0.04319753f, 
    -0.14461084f, -0.05994997f, -0.06213580f, 0.04439655f, 0.02619380f, -0.05107438f, -0.02778703f, -0.03984538f, 
    0.00072834f, -0.09749160f, 0.21671258f, 0.17034049f, -0.03940460f, -0.02188556f, 0.01116843f, 0.08583046f, 
    0.11550289f, 0.03944520f, -0.05852069f, -0.05224988f, -0.18872716f, -0.04547910f, -0.00044954f, 0.15550086f, 
    0.13858561f, 0.08770529f, 0.02817311f, 0.18004487f, -0.15786736f, -0.08875241f, -0.19335908f, -0.06610748f, 
    0.00911465f, 0.01951970f, 0.03743039f, -0.03266753f, 0.02132385f, 0.02697106f, 0.00337521f, -0.03606783f, 
    0.00607656f, -0.03223170f, 0.02405782f, 0.00310759f, -0.01488532f, 0.03683869f, -0.02535861f, 0.02419311f, 
    -0.00963123f, 0.01911796f, 0.03593675f, -0.03045627f, -0.02508261f, -0.04672271f, -0.02666208f, 0.00069998f, 
    -0.01315545f, 0.00005387f, 0.01113199f, 0.00446357f, 0.00841768f, 0.01588525f, -0.05066091f, 0.04119947f, 
    -0.02433373f, -0.04722495f, -0.00885127f, 0.01809498f, -0.03379282f, 0.02016683f, 0.04441186f, -0.04974644f, 
    0.03918026f, -0.03502437f, -0.01557326f, -0.00449162f, -0.02053915f, 0.01307695f, -0.04346377f, 0.00341023f, 
    -0.00625535f, -0.05551763f, 0.01888628f, -0.00816353f, 0.00050568f, 0.02905034f, 0.03927187f, -0.02976798f, 
    -0.04578362f, 0.00958961f, 0.02916412f, 0.00391884f, -0.03212255f, 0.03290576f, -0.00513763f, -0.05184630f, 
    0.03159474f, 0.04084371f, 0.02562754f, -0.03283796f, 0.03702585f, 0.02770387f, -0.03217871f, 0.01484515f, 
    -0.00054195f, -0.02695035f, 0.04176863f, -0.04368351f, -0.04073508f, 0.00084333f, -0.05020048f, 0.00017114f, 
    -0.03662528f, -0.04947827f, 0.01997987f, -0.00520094f, -0.01966459f, 0.03615810f, 0.01947404f, -0.05529002f, 
    -0.05685962f, 0.00636367f, 0.03133496f, 0.00994754f, 0.01868456f, -0.03177480f, -0.02154397f, 0.03522219f, 
    -0.00472337f, 0.04112487f, 0.02532888f, -0.04111199f, -0.05638757f, -0.01542958f, 0.01855253f, -0.01712411f, 
    0.04388618f, 0.01505248f, -0.03263589f, -0.00587394f, 0.01165448f, 0.01803466f, -0.00743875f, 0.03518916f, 
    -0.03368831f, 0.03114555f, -0.04137485f, -0.01551019f, 0.03014411f, -0.05664929f, -0.01353767f, 0.01717687f, 
    -0.04405269f, 0.02579373f, -0.05186297f, 0.01767658f, -0.03194096f, 0.02856230f, 0.02272798f, -0.01587867f, 
    -0.04592840f, 0.02741511f, -0.03343474f, 0.04563268f, -0.03009991f, -0.00837600f, -0.05382588f, -0.00663187f, 
    -0.00110215f, -0.00033002f, -0.04632964f, -0.00451014f, -0.01240920f, -0.03068751f, -0.01853727f, -0.05539652f, 
    -0.00107480f, -0.04442949f, 0.04389460f, 0.03299459f, -0.01992922f, -0.03983708f, 0.01761231f, 0.02207827f, 
    -0.04426615f, 0.03554101f, 0.01232710f, -0.01635949f, 0.03811261f, 0.01867723f, -0.05698111f, -0.04937218f, 
    -0.05496773f, -0.04683445f, 0.04628692f, -0.02455338f, 0.02864762f, 0.00065554f, 0.01853363f, -0.03870472f, 
    -0.05702601f, 0.02680366f, -0.04362310f, 0.00946862f, 0.02461014f, 0.02368818f, -0.05066870f, 0.02371015f, 
    -0.04184248f, -0.03010786f, 0.02076361f, -0.01987912f, -0.01162385f, -0.05495286f, -0.01713631f, -0.04646036f, 
    -0.02035289f, -0.04251288f, 0.02452759f, -0.02272983f, 0.00973815f, 0.00096541f, -0.01725159f, -0.04339065f, 
    0.00407295f, -0.04119745f, 0.00317381f, -0.03213421f, -0.02081712f, -0.00514777f, 0.03271723f, 0.01243896f, 
    -0.00528112f, -0.03825258f, -0.01475359f, -0.04111968f, -0.02062300f, -0.02333357f, -0.02872593f, 0.01398662f, 
    0.01923113f, -0.04983811f, 0.03425637f, 0.02558578f, -0.02623429f, -0.02183361f, 0.03285316f, 0.01282235f, 
    -0.05139891f, 0.02436375f, -0.01461123f, 0.01491742f, -0.01954466f, -0.04224031f, 0.01949759f, 0.03251028f, 
    -0.03036846f, -0.05114773f, 0.03713771f, 0.00909154f, 0.00410547f, 0.00687598f, 0.00910719f, -0.01102329f, 
    -0.02877210f, -0.01134605f, -0.03692937f, -0.04799060f, -0.05021511f, 0.00495666f, -0.02774317f, -0.05388604f, 
    0.02298497f, 0.00368154f, -0.03374448f, -0.03785669f, -0.02349533f, -0.02972703f, -0.03657455f, 0.04373182f, 
    0.01383935f, -0.03218897f, -0.02069065f, 0.00454928f, 0.02166090f, -0.03916880f, -0.01035682f, 0.03843564f, 
    0.03773402f, 0.03110755f, 0.01818191f, 0.01215306f, 0.03958942f, 0.01758637f, -0.03853204f, 0.03433842f, 
    0.01274881f, 0.03501557f, -0.00800349f, -0.01768454f, 0.02080930f, 0.03161442f, 0.03325748f, 0.02388026f, 
    -0.05371698f, -0.04781228f, 0.04001084f, -0.04318157f, 0.02219473f, -0.02214777f, 0.04487354f, -0.00476782f, 
    -0.04266176f, -0.05143234f, -0.01290693f, 0.00656854f, -0.00527652f, 0.02091938f, -0.01458341f, 0.00662181f, 
    0.02605857f, -0.02732364f, -0.03419863f, -0.02822905f, -0.04061663f, 0.01154062f, 0.02534197f, -0.05642461f, 
    -0.01913041f, -0.01891140f, 0.04029466f, 0.01843548f, -0.05591258f, -0.02409474f, -0.05110135f, -0.00006808f, 
    -0.02407030f, -0.03479774f, 0.02284173f, 0.02350079f, 0.00484322f, 0.03242953f, -0.05594242f, -0.00385716f, 
    -0.02884614f, 0.02583752f, 0.02404405f, -0.02974385f, 0.02211200f, -0.00792291f, -0.03133998f, 0.00536224f, 
    -0.03668139f, 0.01068005f, -0.01560323f, -0.04334390f, -0.02599010f, -0.04334436f, -0.01660249f, -0.03493030f, 
    -0.00084212f, 0.02782120f, 0.01525603f, -0.04049481f, -0.01691695f, -0.03655401f, 0.00152528f, 0.04250226f, 
    -0.03576594f, -0.05466234f, -0.05072996f, -0.01525848f, 0.01822341f, -0.02048034f, -0.04128588f, 0.02904298f, 
    -0.03651959f, -0.04470268f, -0.01910866f, -0.01410821f, 0.03334879f, 0.00605876f, 0.00293584f, -0.05624730f, 
    -0.04929747f, 0.00371300f, 0.03836406f, -0.02165992f, -0.00086670f, -0.05169932f, 0.02362570f, -0.03547347f, 
    -0.02348635f, -0.02479795f, -0.03637492f, -0.03927394f, -0.00780591f, 0.03232029f, 0.01145009f, 0.02985770f, 
    -0.03108977f, -0.03969928f, 0.02342950f, 0.03055801f, -0.02579137f, -0.05608992f, -0.00590739f, 0.02355483f, 
    -0.03466024f, -0.03714122f, 0.04008726f, -0.04409900f, -0.00957974f, -0.04044991f, 0.00130774f, -0.00458032f, 
    -0.06411062f, -0.12043741f, -0.03980036f, -0.11656479f, -0.08434700f, -0.03405158f, 0.07094552f, 0.07524773f, 
    0.13903886f, 0.11209346f, 0.07955047f, 0.02290379f, -0.17869420f, -0.14295626f, -0.14699541f, -0.10699798f, 
    0.04465721f, -0.00434734f, -0.13142568f, 0.14557032f, -0.02107647f, 0.05169329f, 0.08666648f, -0.01680437f, 
    -0.03469075f, 0.05055011f, 0.01030174f, -0.04314784f, 0.11810281f, -0.08926526f, 0.08351203f, 0.13715056f, 
    -0.05713939f, 0.20453346f, -0.01881724f, 0.06601533f, 0.00383237f, -0.03524307f, 0.02511717f, -0.07756981f, 
    -0.17532225f, 0.04832189f, 0.05902353f, -0.01025201f, 0.01053985f, -0.00926481f, 0.02957989f, -0.22536112f, 
    0.03053408f, -0.05690242f, -0.35533407f, -0.16647385f, 0.01757366f, -0.05813833f, 0.25845051f, -0.03035043f, 
    0.03961731f, 0.04425510f, 0.14177851f, -0.07166021f, -0.11800681f, -0.06223054f, -0.22004621f, 0.13982710f, 
    0.01616921f, -0.06718576f, 0.13520490f, -0.05797035f, 0.03570897f, -0.01436891f, -0.03046181f, -0.06027883f, 
    -0.15424798f, 0.00177374f, -0.13175054f, -0.08646730f, -0.07553452f, -0.06413948f, -0.02116371f, -0.01492396f, 
    -0.03318021f, 0.22013359f, -0.06828880f, -0.09347200f, -0.23688857f, 0.14273025f, -0.39107421f, 0.06736465f, 
    0.07366509f, -0.08005537f, -0.14597523f, 0.10498691f, -0.09974264f, 0.01903213f, -0.02887167f, 0.03494840f, 
    0.20213607f, 0.26795909f, 0.31112614f, -0.03214751f, -0.03953535f, -0.01564805f, 0.12457172f, -0.01966524f, 
    0.13295060f, 0.16015573f, 0.25592473f, -0.01409579f, 0.23717666f, -0.09426279f, 0.07642304f, -0.29640543f, 
    -0.12255241f, -0.02026654f, 0.06125179f, -0.01092276f, 0.04881236f, 0.24294512f, 0.08188030f, 0.09097150f, 
    -0.07822447f, -0.19561684f, -0.01201528f, 0.18074861f, -0.02591132f, -0.00975346f, 0.04837228f, -0.09850926f, 
    -0.05242026f, -0.04159340f, 0.02751225f, 0.09829930f, 0.02539481f, 0.19942653f, 0.00160378f, 0.12800728f, 
    -0.00841257f, 0.08703940f, 0.10932812f, -0.03692739f, 0.18840840f, 0.20433922f, 0.12804441f, 0.03785737f, 
    -0.10512463f, -0.23191640f, -0.22945991f, -0.00205170f, -0.04378161f, 0.04886135f, 0.11796879f, -0.00512860f, 
    -0.05940085f, 0.02921659f, 0.06455018f, 0.05457182f, 0.09361164f, 0.00823368f, -0.12832172f, 0.23179334f, 
    0.07140473f, -0.04781064f, 0.04714427f, 0.11803638f, -0.04840075f, -0.00298550f, 0.13873005f, 0.00099608f, 
    0.04464380f, -0.15235926f, 0.27060810f, 0.02256576f, -0.05264540f, 0.02425183f, 0.07712145f, -0.05238709f, 
    0.03675351f, 0.00418210f, 0.00636140f, 0.00548158f, -0.00497647f, 0.36771229f, -0.00503207f, 0.16525680f, 
    0.01316430f, -0.01036411f, -0.01371730f, 0.08924972f, 0.05872680f, 0.01636878f, 0.37637189f, 0.12130518f, 
    0.13640738f, 0.12115800f, -0.13922206f, 0.05558954f, -0.05941736f, -0.10560953f, 0.01973926f, -0.07106910f, 
    0.03629694f, 0.14625007f, 0.02105130f, 0.09726717f, -0.16176143f, 0.10203309f, -0.16193154f, -0.14485094f, 
    0.02632437f, 0.05379738f, 0.24532366f, -0.01875109f, 0.09194585f, -0.06554051f, -0.10830121f, 0.05473158f, 
    0.07756028f, 0.18638432f, 0.19062491f, 0.13935463f, -0.01333848f, -0.10663047f, 0.00438949f, 0.10265426f, 
    -0.04993660f, 0.00233999f, 0.09143203f, 0.01006377f, -0.19197722f, -0.16865882f, -0.12739438f, 0.16760278f, 
    -0.08357405f, -0.10914952f, -0.06332915f, -0.06632460f, 0.08837444f, -0.08592309f, -0.02341288f, 0.04093258f, 
    -0.27670705f, 0.11055512f, -0.35792446f, -0.08879463f, 0.11224834f, -0.01563078f, 0.10385884f, 0.13103023f, 
    -0.12918147f, 0.08197644f, -0.01743633f, 0.15577993f, 0.05200250f, -0.00148414f, -0.20437749f, -0.10816252f, 
    0.02816270f, 0.13776395f, 0.28243095f, 0.03488198f, -0.04514123f, -0.07875511f, -0.08874846f, -0.02167876f, 
    0.00856892f, 0.00741464f, 0.11260851f, -0.12243811f, -0.03384499f, 0.04170929f, 0.11228383f, -0.03744787f, 
    -0.03398651f, 0.01535898f, -0.01226061f, -0.09098638f, -0.09593062f, -0.51855922f, -0.15180315f, -0.14549579f, 
    0.02258409f, 0.10516558f, -0.04701382f, -0.09610116f, -0.08334289f, 0.01081717f, -0.00378107f, 0.19811195f, 
    0.06806833f, 0.16900191f, -0.09948106f, 0.10320937f, -0.09062587f, 0.10804930f, -0.02604728f, -0.03685542f, 
    0.13472742f, -0.03822460f, 0.17659225f, 0.08829699f, -0.15650317f, 0.33114573f, 0.21587768f, 0.16440055f, 
    -0.00368542f, 0.02887795f, 0.03926915f, -0.11663561f, 0.00802550f, 0.15785566f, 0.07643596f, 0.19937693f, 
    0.04821168f, 0.13749664f, 0.03200955f, 0.01647914f, -0.06624830f, 0.08733170f, 0.16335636f, 0.01651583f, 
    0.10204228f, 0.04424686f, 0.00674468f, 0.30408734f, -0.04810447f, -0.14780584f, 0.05907093f, -0.15658458f, 
    -0.03117394f, -0.06626669f, 0.04439327f, 0.01329263f, -0.04197111f, 0.04927915f, -0.03258228f, 0.04960700f, 
    0.09899242f, -0.08877652f, 0.03323547f, 0.01141204f, -0.04634190f, 0.13731593f, -0.11437175f, -0.02873906f, 
    -0.02097962f, 0.00222101f, 0.08712806f, 0.06592536f, -0.10948815f, -0.13965760f, 0.22195092f, -0.07711096f, 
    -0.06849296f, 0.04768774f, 0.04480641f, -0.03487136f, 0.02292887f, -0.00876438f, -0.10111265f, -0.14276727f, 
    0.13159448f, 0.35193533f, 0.16020922f, 0.25893357f, -0.02741052f, -0.10071958f, -0.07059700f, -0.16337910f, 
    -0.16123584f, -0.01449610f, 0.09469746f, 0.06931128f, 0.11328966f, 0.09511653f, 0.05624361f, 0.16060735f, 
    -0.08305562f, 0.01056774f, 0.05056477f, -0.02672556f, -0.10465234f, -0.02938711f, -0.00235608f, 0.06597910f, 
    0.27027187f, 0.18248020f, 0.19710408f, 0.16312996f, -0.02599695f, 0.00225039f, 0.15954730f, 0.18722014f, 
    0.10332511f, 0.10171396f, 0.16415335f, -0.09653148f, 0.18524653f, -0.10528604f, 0.03573918f, 0.14329723f, 
    0.11002533f, -0.06618606f, -0.08991424f, -0.03718083f, -0.06920007f, -0.09792977f, -0.33306670f, -0.36495504f, 
    0.03041626f, -0.02980709f, 0.15723386f, 0.21520011f, 0.12185819f, -0.01547376f, -0.10068228f, -0.10575645f, 
    -0.17007527f, -0.07325889f, -0.16469552f, -0.14325576f, -0.25524601f, -0.22760107f, -0.10004992f, 0.05406171f, 
    0.04441580f, 0.08467034f, -0.11426733f, -0.05218454f, 0.16086723f, 0.10498644f, 0.09845497f, -0.22857076f, 
    0.14404778f, 0.15237533f, -0.01245745f, 0.06931216f, 0.01592419f, -0.17672127f, -0.00614692f, -0.00982392f, 
    0.01628982f, -0.03155942f, 0.00653244f, -0.01730205f, 0.25363168f, -0.08923531f, 0.15795638f, -0.09263173f, 
    0.06826513f, -0.02646623f, 0.07562364f, -0.02735326f, -0.09313405f, 0.03900984f, -0.27137458f, -0.17483431f, 
    0.24847294f, 0.01812531f, 0.06641491f, -0.06004038f, 0.03479943f, 0.07569823f, 0.14460079f, -0.19326881f, 
    -0.02040538f, 0.05349483f, 0.02026179f, -0.09492749f, 0.04938212f, -0.04944548f, 0.18309952f, 0.05704442f, 
    0.13647017f, -0.06216368f, 0.01543765f, -0.10159551f, -0.16205443f, -0.10269543f, -0.18500702f, -0.09896790f, 
    -0.50319797f, -0.11868350f, 0.25827119f, -0.47628054f, 0.06621654f, 0.00093483f, -0.06681193f, -0.06020623f, 
    -0.12731615f, 0.02803008f, 0.02429367f, -0.01093674f, 0.02648733f, 0.25042117f, -0.10819286f, 0.17931670f, 
    0.04459411f, -0.11180148f, 0.02631464f, -0.22903287f, 0.18941601f, -0.03848618f, 0.13242415f, 0.24552666f, 
    0.00823655f, -0.25052771f, 0.10795881f, -0.09753871f, -0.05063059f, -0.01124469f, -0.02846117f, -0.28605351f, 
    -0.01576119f, -0.04539412f, 0.01826775f, 0.02470201f, -0.10135876f, -0.02543236f, -0.03627698f, -0.04478739f, 
    -0.05753506f, -0.03211450f, -0.00431418f, -0.08605744f, 0.11869539f, 0.10205175f, 0.04687403f, 0.34216645f, 
    0.09468514f, 0.08455312f, 0.08629899f, 0.12131631f, 0.06808615f, 0.04948989f, 0.02542290f, 0.10452347f, 
    0.03720856f, 0.04140714f, -0.01841849f, 0.02270144f, 0.20649768f, 0.05992309f, -0.16678047f, 0.20071088f, 
    0.11265910f, 0.11343450f, -0.08404019f, 0.05438573f, -0.08715677f, -0.04028054f, 0.03767838f, -0.03204428f, 
    0.06133605f, -0.10763377f, -0.17275803f, 0.12877023f, -0.00608395f, -0.12543274f, -0.01628264f, 0.11656362f, 
    0.03105777f, -0.06449325f, -0.10785878f, -0.00946872f, -0.02611078f, -0.14791335f, 0.16272016f, -0.03008900f, 
    0.04549264f, -0.15724047f, -0.16803940f, -0.16618291f, -0.07123675f, 0.06884902f, -0.02159531f, 0.03829946f, 
    0.06796364f, -0.17527935f, -0.03466870f, 0.01611540f, -0.06427222f, 0.04235955f, -0.12771334f, -0.41530976f, 
    0.11697987f, -0.03439246f, -0.05106980f, -0.02380417f, 0.16552591f, -0.14478150f, -0.29071397f, 0.26001436f, 
    0.04382341f, 0.06065705f, 0.10024220f, 0.05026963f, 0.00877645f, -0.18727145f, -0.04387434f, -0.03666388f, 
    -0.01351948f, 0.04469071f, -0.07269660f, -0.26725891f, -0.04150810f, -0.12588325f, -0.09317292f, -0.14112575f, 
    0.02467292f, -0.06492975f, -0.10810443f, -0.07576735f, -0.03367635f, 0.06666455f, -0.01081859f, -0.16445418f, 
    0.01055354f, 0.10573222f, 0.03491408f, 0.06726323f, -0.00863538f, 0.01531162f, -0.05966261f, 0.06493697f, 
    0.15476769f, 0.14810632f, 0.10723045f, 0.22145571f, 0.11049957f, 0.02255596f, 0.01883508f, -0.01142187f, 
    -0.01149712f, 0.08565234f, 0.08034434f, 0.19347219f, 0.44849807f, 0.41084808f, 0.22400838f, 0.15183987f, 
    0.18468025f, 0.12332352f, -0.03050152f, 0.25281990f, 0.05583158f, 0.04396717f, 0.02161170f, 0.02424464f, 
    -0.06789507f, -0.06170255f, -0.20013948f, 0.02779896f, 0.00896556f, 0.09876359f, 0.11504962f, 0.04825414f, 
    0.06020567f, 0.09106842f, 0.02933581f, -0.14683445f, 0.16419178f, 0.10257046f, 0.20211613f, 0.28044692f, 
    0.05346055f, 0.01723196f, 0.12465600f, 0.03993198f, 0.12469598f, -0.00359298f, 0.04998649f, 0.15164523f, 
    -0.17509358f, -0.19580227f, -0.01141796f, -0.31614235f, 0.06347285f, -0.10347638f, 0.12309819f, -0.20783855f, 
    0.06440811f, -0.05943686f, -0.15166558f, 0.11123256f, 0.11760581f, -0.11134507f, 0.19611228f, -0.00820718f, 
    0.18204843f, -0.12674581f, -0.11253538f, -0.36252257f, 0.15119232f, 0.09101721f, -0.01094942f, 0.07125766f, 
    -0.18487631f, 0.00720924f, -0.04715236f, -0.12695274f, 0.04847476f, 0.04224884f, -0.16337767f, -0.00823984f, 
    0.15609089f, 0.02701678f, -0.28146127f, 0.06167309f, -0.12312828f, 0.25984392f, 0.02099017f, 0.32852533f, 
    0.16092713f, 0.00866269f, -0.11862823f, -0.10213381f, -0.12970264f, -0.29156899f, -0.08610463f, -0.28420430f, 
    0.08546122f, -0.02677514f, -0.01103232f, 0.16273341f, 0.04218837f, -0.01337718f, -0.01546227f, 0.02071094f, 
    0.08496212f, 0.06175316f, 0.08703317f, 0.04598252f, -0.22062200f, -0.09106389f, -0.05271889f, 0.00827972f, 
    0.05389429f, 0.09784763f, 0.04692597f, 0.02810562f, -0.05007014f, -0.06293854f, -0.07090799f, -0.14373697f, 
    0.26884580f, 0.25343585f, -0.07202399f, 0.04591608f, -0.09389566f, 0.10170031f, -0.22312216f, -0.12668884f, 
    0.09743272f, -0.00939871f, -0.13638720f, 0.02751089f, 0.01114703f, -0.04952359f, -0.09181862f, 0.11890417f, 
    0.05771753f, 0.06462967f, 0.02316504f, -0.04658842f, 0.16663744f, 0.06557545f, 0.03860014f, 0.21639054f, 
    0.00298303f, -0.02397098f, 0.03715759f, -0.05209928f, -0.00237266f, -0.01521311f, -0.03560269f, 0.03553708f, 
    0.01999014f, -0.02637053f, 0.01075158f, -0.01950214f, -0.02726901f, -0.00430573f, -0.00196416f, -0.02541688f, 
    -0.04487389f, 0.03672091f, -0.03789257f, -0.01911246f, 0.01525490f, -0.05541973f, -0.02880547f, -0.05099212f, 
    0.01189834f, 0.02105532f, -0.04992086f, 0.00809264f, 0.01626506f, -0.01151629f, 0.02915329f, 0.01345157f, 
    0.02826423f, -0.03064153f, -0.00091990f, 0.01009679f, 0.00030030f, -0.04686231f, -0.04640227f, -0.00776053f, 
    -0.02314552f, -0.05599746f, 0.02819927f, -0.01970696f, 0.03748913f, -0.00854566f, -0.02841198f, -0.03216207f, 
    0.02663967f, 0.03146774f, 0.00644027f, 0.02336524f, 0.03834900f, -0.02197882f, -0.00844096f, -0.04212007f, 
    -0.03561754f, -0.01668183f, -0.03721215f, -0.01101886f, -0.04620808f, -0.00273572f, -0.05023529f, -0.01736171f, 
    0.00627439f, 0.01868530f, -0.01665794f, -0.05811434f, -0.03091774f, 0.01677338f, 0.00825124f, 0.02407226f, 
    0.03792704f, -0.01460551f, -0.05721504f, -0.00492750f, 0.01894657f, 0.03600656f, -0.03609480f, -0.02825606f, 
    -0.01756317f, 0.00129106f, 0.03591536f, 0.01959050f, -0.03558897f, -0.05027603f, -0.01371250f, -0.05356493f, 
    -0.03818269f, -0.03583019f, -0.03840644f, 0.00040300f, -0.04305111f, 0.02887953f, -0.04785092f, -0.01798821f, 
    -0.00577619f, -0.01653520f, -0.03240114f, 0.02750079f, -0.01661021f, 0.01668340f, 0.03535553f, 0.04053966f, 
    0.01758574f, -0.05097768f, -0.01396970f, -0.03765179f, -0.01089781f, 0.04104992f, 0.02215370f, -0.02339143f, 
    0.04040080f, -0.03384135f, -0.01807183f, 0.00953704f, -0.00177771f, -0.03520049f, 0.03067530f, 0.01272110f, 
    0.02931638f, -0.05642907f, 0.00379198f, 0.00091290f, 0.01838898f, -0.04874786f, -0.00489052f, 0.04031442f, 
    -0.01856134f, -0.04890345f, -0.04323901f, 0.00077202f, 0.03763379f, -0.03780203f, -0.04956992f, 0.01676462f, 
    -0.00817751f, 0.01000650f, 0.01079652f, 0.01069379f, -0.03982946f, -0.02295645f, 0.02469548f, -0.04148603f, 
    0.02907050f, -0.04039385f, 0.00884402f, 0.02826302f, -0.01546612f, 0.01210136f, -0.01442147f, 0.03286281f, 
    -0.01356076f, 0.00172827f, -0.00034678f, 0.00859662f, -0.01580307f, -0.01734833f, -0.05334376f, 0.04159081f, 
    0.05141893f, 0.02203498f, 0.03812611f, -0.01337355f, -0.01005156f, -0.00938825f, 0.04160092f, -0.05573921f, 
    0.00466101f, 0.01375361f, -0.02637808f, -0.03853479f, 0.02056680f, -0.04226107f, -0.05252170f, -0.05063825f, 
    -0.02097484f, 0.03419432f, -0.03821512f, -0.01556872f, -0.04412445f, 0.03156691f, -0.03459355f, -0.02112612f, 
    -0.04733250f, -0.03548170f, -0.03956908f, 0.02417799f, 0.03363977f, -0.00269403f, 0.00159154f, 0.02567570f, 
    0.03272593f, -0.04314168f, -0.00992517f, -0.03581484f, 0.00835803f, 0.02460800f, 0.00927312f, -0.00193152f, 
    -0.04448423f, 0.00445851f, 0.01741830f, 0.03637579f, 0.02185016f, -0.03647027f, -0.04708949f, 0.02113950f, 
    0.04167432f, -0.04393129f, -0.05355801f, 0.03506299f, 0.03411409f, 0.00298475f, -0.00790284f, -0.05802646f, 
    -0.01398428f, -0.02468382f, 0.02878002f, 0.00111158f, -0.05090426f, -0.04495299f, -0.05054827f, 0.00031598f, 
    0.00931008f, -0.01203175f, -0.01454916f, 0.00057465f, -0.01630679f, 0.02328790f, 0.00248695f, -0.03115305f, 
    0.01662859f, 0.01771062f, -0.04590742f, 0.00972761f, -0.01238161f, 0.03342733f, 0.01300795f, -0.03166484f, 
    -0.03413600f, 0.02700050f, -0.05588545f, -0.01309738f, 0.02575966f, 0.03131112f, 0.00180873f, 0.02990714f, 
    -0.00331543f, -0.02665215f, 0.00929658f, 0.02132684f, 0.01804294f, 0.02380697f, -0.03005340f, -0.00012467f, 
    -0.05860446f, -0.03618585f, -0.00856508f, -0.00098844f, -0.00482713f, 0.00632505f, -0.00900310f, -0.01769021f, 
    -0.00742919f, 0.01344875f, 0.04195326f, 0.00413457f, -0.00689564f, -0.03022788f, -0.00121136f, -0.02825246f, 
    0.03415693f, -0.00679201f, 0.02565150f, -0.05417356f, 0.01847908f, -0.03212599f, -0.02260900f, 0.00034598f, 
    0.03104504f, -0.05558796f, 0.03158484f, -0.00003319f, 0.02368269f, -0.04151894f, -0.03773435f, -0.04185716f, 
    0.01484656f, -0.05170077f, 0.01576983f, 0.02932268f, 0.03452636f, 0.01474332f, 0.01028516f, 0.01268606f, 
    -0.02257008f, 0.02625356f, -0.03245199f, 0.01406698f, -0.05092947f, 0.00672760f, -0.02183046f, 0.02665306f, 
    -0.01342271f, -0.05284709f, -0.00649053f, -0.04651764f, 0.02596896f, -0.00207638f, 0.03111067f, -0.05548358f, 
    0.01983994f, 0.01004060f, -0.03860772f, 0.04157983f, -0.05399521f, -0.01695301f, -0.05753072f, 0.04094357f, 
    -0.02779043f, -0.05819987f, 0.03770673f, -0.02151380f, 0.03026086f, -0.04048016f, 0.00600250f, -0.02372153f, 
    -0.01094520f, -0.01643650f, 0.00271025f, 0.00338240f, 0.01877301f, 0.03452217f, -0.03793041f, -0.05477454f, 
    0.00228421f, -0.05048135f, -0.04804339f, 0.02475440f, 0.00104321f, -0.03940692f, 0.03474722f, -0.03781118f, 
    -0.02785636f, -0.03196002f, 0.01837955f, -0.01323845f, 0.00223097f, 0.04083245f, 0.02905642f, 0.03148151f, 
    0.04026477f, 0.02437211f, 0.02080611f, -0.03632942f, 0.02805259f, -0.00613804f, -0.05014388f, 0.01080251f, 
    -0.03984861f, -0.02891622f, 0.02313633f, -0.01730344f, 0.02504982f, -0.01740779f, 0.00402193f, 0.01036521f, 
    0.01247804f, 0.02342533f, -0.00424030f, -0.05359273f, 0.01837977f, -0.05468145f, 0.03469585f, 0.01888545f, 
    0.01754423f, 0.03405892f, -0.02498971f, -0.01226083f, -0.05328710f, -0.04019444f, 0.03242590f, -0.01363679f, 
    -0.26830110f, -0.33974457f, 0.02232192f, 0.10326813f, 0.06009262f, -0.06655171f, -0.04392026f, -0.03861452f, 
    0.10241934f, -0.01443888f, 0.01467113f, -0.00280048f, -0.08372839f, -0.03238237f, 0.00801320f, -0.03236684f, 
    0.13821185f, 0.07549845f, 0.10459717f, -0.00643026f, 0.02949216f, -0.07683723f, -0.00066899f, -0.08942836f, 
    -0.12373364f, 0.05268303f, 0.11647069f, -0.10525137f, -0.12439580f, -0.02800078f, 0.06741192f, 0.00807376f, 
    -0.02502942f, 0.07694104f, 0.12758039f, -0.00660300f, 0.04689055f, -0.04296562f, 0.01876627f, -0.15952048f, 
    0.00592211f, -0.02201440f, -0.01786346f, -0.01586364f, -0.05620713f, 0.06073065f, -0.07290208f, -0.01680523f, 
    0.04491327f, -0.11246403f, -0.22879258f, 0.34274083f, 0.09250991f, 0.00398635f, 0.17682135f, -0.04032673f, 
    0.11034191f, 0.03239672f, 0.07518958f, 0.04507696f, -0.13205566f, -0.07011993f, 0.23881024f, 0.01228796f, 
    0.02221849f, 0.11005308f, -0.01370302f, 0.13074715f, -0.02948382f, -0.05028426f, -0.03542831f, -0.05785114f, 
    -0.16173759f, -0.09977643f, -0.01163434f, -0.10631945f, -0.06036842f, -0.09129212f, -0.10025557f, -0.10051743f, 
    0.09520576f, -0.06687880f, -0.04678877f, 0.07993650f, 0.13873917f, -0.21153069f, -0.19889151f, 0.15591523f, 
    0.03571342f, 0.09446108f, -0.06888889f, 0.14243786f, -0.08295102f, -0.03116134f, 0.03253623f, -0.04856988f, 
    -0.03902905f, 0.30430248f, 0.12014713f, -0.04899729f, 0.00873470f, 0.03532016f, 0.22698435f, 0.02668809f, 
    0.00842241f, 0.12862623f, 0.07121161f, 0.00696429f, 0.34693980f, 0.07630963f, -0.24503988f, -0.13731013f, 
    -0.06189523f, 0.00965978f, -0.04767315f, -0.06959110f, -0.00561727f, 0.15925787f, 0.11098889f, 0.09216463f, 
    -0.06355261f, 0.12837768f, -0.08334195f, -0.08844583f, -0.04232712f, -0.03574003f, 0.01444641f, -0.00339900f, 
    0.03029699f, 0.04213485f, 0.02021382f, 0.08397407f, 0.03607417f, 0.02215123f, 0.02379758f, 0.03900611f, 
    -0.02850083f, -0.07664659f, 0.10870085f, 0.21984483f, 0.08854880f, 0.04689514f, 0.05056240f, 0.06108207f, 
    -0.33032566f, -0.24181499f, 0.00275271f, 0.10873259f, -0.12315453f, -0.09125113f, -0.06551553f, 0.01719991f, 
    0.05559780f, 0.08757097f, 0.05163134f, 0.07723255f, -0.26364598f, -0.13542159f, 0.02932234f, 0.17054130f, 
    -0.02867294f, -0.07218933f, -0.04724269f, 0.17524482f, -0.06392100f, -0.02739182f, 0.00933403f, 0.06466599f, 
    -0.30874780f, 0.14706454f, 0.06014500f, 0.04412944f, -0.07240301f, 0.01327568f, 0.14941968f, 0.08534750f, 
    0.03966987f, -0.01042247f, -0.01304192f, -0.01297224f, 0.00794845f, -0.08919028f, 0.23786922f, 0.10652248f, 
    0.07288164f, 0.01304660f, -0.05297979f, 0.14276117f, 0.08764058f, 0.17556077f, 0.16978011f, 0.14718080f, 
    0.00703624f, -0.01193951f, -0.08230483f, -0.05528411f, -0.13105917f, -0.01591071f, 0.00536476f, 0.01681704f, 
    0.13752851f, 0.19469929f, 0.21214077f, 0.20577355f, 0.23975842f, -0.02611619f, 0.03590676f, 0.11771025f, 
    0.16896991f, 0.07620631f, 0.19199978f, 0.16098861f, -0.05581719f, 0.01698624f, -0.05032898f, 0.06685656f, 
    0.01126553f, 0.06506957f, -0.01084035f, 0.10965797f, 0.08153646f, 0.09654613f, 0.11859458f, 0.08582944f, 
    -0.07979158f, -0.06441710f, -0.06912031f, 0.02161206f, -0.27849969f, -0.18575746f, 0.02674583f, 0.01976144f, 
    -0.02203776f, 0.07027947f, 0.06199267f, 0.10817329f, 0.00813762f, -0.00911757f, -0.00574982f, 0.04911567f, 
    0.07821333f, -0.18393481f, -0.18686111f, 0.20076768f, 0.23606975f, 0.13749409f, 0.01055867f, 0.02481672f, 
    0.15540241f, 0.20482114f, 0.23283629f, 0.05449712f, 0.16102374f, 0.10814720f, -0.06491921f, -0.13980123f, 
    0.07306164f, 0.15011145f, 0.10147133f, 0.07722919f, -0.03686834f, -0.09810466f, -0.07062183f, -0.01424266f, 
    0.03468250f, -0.02192689f, 0.06630746f, -0.19143629f, -0.08362364f, -0.01633802f, -0.01232851f, -0.00090348f, 
    -0.01790172f, 0.05323981f, 0.05370724f, -0.04407477f, -0.12246053f, 0.11123919f, 0.15315267f, -0.04279554f, 
    0.01236835f, 0.04930102f, -0.00824897f, -0.01325602f, 0.04107025f, -0.01754559f, 0.01203960f, 0.00003730f, 
    -0.17941175f, 0.06317715f, -0.02433457f, 0.24369904f, 0.02894143f, -0.07224751f, 0.07893261f, 0.12145377f, 
    0.00641223f, 0.06897814f, 0.11417133f, 0.15409350f, -0.05044508f, 0.05240874f, 0.00800914f, 0.08776738f, 
    -0.04298852f, -0.07521687f, -0.01204203f, -0.01813883f, 0.03244459f, 0.06522490f, 0.11237182f, 0.06778117f, 
    0.16599701f, 0.12825026f, 0.00427962f, -0.00135579f, 0.13065109f, 0.03353840f, 0.12354964f, 0.01669548f, 
    0.04663663f, 0.02238091f, 0.12191747f, 0.02051632f, 0.22039266f, -0.04884897f, -0.00643660f, -0.15534401f, 
    0.06883270f, 0.10527121f, -0.07225089f, 0.03101024f, -0.06006881f, -0.00911159f, -0.01596564f, -0.04003379f, 
    -0.24021421f, -0.07911583f, 0.04409358f, 0.01094526f, -0.04966482f, -0.12618753f, 0.14975733f, 0.03783113f, 
    0.11180060f, 0.03957213f, 0.04978701f, -0.04532624f, -0.01836052f, 0.08094310f, 0.12839027f, -0.27175212f, 
    -0.00478697f, -0.04731958f, -0.08823357f, -0.01667625f, -0.07455088f, 0.10595102f, 0.04595154f, -0.09739283f, 
    -0.09159414f, 0.07685308f, 0.15241767f, 0.11700895f, -0.05066619f, -0.09699538f, 0.01739973f, -0.01072803f, 
    0.04041000f, 0.13092165f, -0.00454713f, 0.05481563f, -0.18486769f, -0.10292488f, 0.18217303f, 0.02796370f, 
    -0.04166025f, -0.10824510f, -0.01999651f, 0.03655034f, 0.07769005f, 0.15141355f, 0.05085393f, 0.04682957f, 
    0.00919727f, -0.05455710f, 0.00669760f, -0.00990665f, -0.05438317f, 0.00327007f, 0.01977618f, -0.02445233f, 
    0.01511830f, -0.03025011f, 0.01385973f, 0.02461929f, -0.00160370f, 0.01260392f, -0.00115223f, 0.00514626f, 
    -0.00591707f, -0.01624484f, 0.01388490f, 0.00207372f, 0.01758317f, 0.02514122f, -0.01879992f, -0.00033062f, 
    -0.04414429f, -0.04278026f, 0.03189087f, -0.03564023f, 0.04342154f, 0.03672898f, 0.05114007f, -0.01379501f, 
    -0.03114966f, 0.01190685f, -0.02906040f, -0.04019856f, 0.01048743f, -0.02659665f, 0.03275592f, -0.00570855f, 
    -0.04231048f, -0.02833616f, 0.03927701f, 0.04057563f, 0.02116838f, 0.01121476f, 0.03705910f, 0.03074543f, 
    -0.03174422f, 0.02023976f, -0.04047356f, 0.00862301f, 0.01006530f, 0.02917892f, -0.00615395f, -0.05529104f, 
    -0.00957586f, -0.03809229f, -0.02942444f, -0.03240209f, -0.02681083f, -0.04411645f, -0.05238326f, 0.00616599f, 
    -0.06237682f, 0.02203343f, -0.04432551f, -0.02843646f, -0.03305550f, 0.01266099f, -0.02046027f, 0.03775952f, 
    0.00777055f, -0.02087408f, -0.00042447f, -0.03475032f, -0.02060449f, 0.00319666f, -0.02668617f, -0.02762105f, 
    0.03293609f, -0.04649572f, -0.00718691f, -0.03218347f, -0.05542500f, -0.01902428f, 0.01743357f, 0.01739136f, 
    0.02230963f, -0.03810553f, -0.01129835f, -0.01599254f, -0.00778743f, -0.02116955f, -0.03682478f, 0.03505890f, 
    0.02766296f, 0.03362657f, -0.03711257f, 0.02551607f, -0.00559448f, -0.01947054f, 0.03227402f, -0.02186095f, 
    0.03953250f, 0.02128412f, -0.02458804f, -0.00936394f, -0.03470279f, 0.01650492f, -0.05854515f, 0.00721389f, 
    -0.02916044f, -0.00819628f, -0.03722931f, 0.04507283f, 0.02506899f, 0.01478196f, -0.00981129f, -0.03129308f, 
    0.03034958f, -0.04464842f, 0.00257184f, -0.00775595f, -0.06346868f, 0.02200093f, 0.01494481f, -0.03217826f, 
    0.01977863f, -0.01130946f, -0.05180578f, -0.04533504f, -0.04274139f, 0.04348708f, -0.00085118f, -0.01727755f, 
    0.03744106f, -0.01590664f, 0.03101211f, 0.01800631f, -0.06306542f, 0.00748812f, -0.01260463f, -0.01593060f, 
    0.02025943f, -0.04777531f, 0.00579383f, -0.05434887f, -0.05436521f, -0.03594603f, -0.04420209f, 0.03568498f, 
    0.01649049f, 0.00355924f, -0.02273299f, -0.02837142f, -0.04082783f, 0.01006886f, -0.04223256f, -0.01500799f, 
    0.01833650f, 0.02302768f, -0.05402333f, 0.04454491f, -0.01422414f, -0.02173213f, -0.00664669f, -0.00912647f, 
    -0.00175936f, -0.05475188f, 0.00314407f, 0.03236746f, -0.05508701f, 0.01340074f, -0.01991474f, 0.00762297f, 
    -0.00715794f, -0.02642457f, -0.02565755f, 0.03328303f, 0.01538947f, -0.00950588f, -0.04887246f, -0.03950565f, 
    0.02056604f, -0.02748923f, 0.01074706f, -0.00058093f, -0.00831551f, -0.05633378f, -0.00646910f, -0.04387143f, 
    -0.03951749f, -0.01457950f, 0.04155935f, 0.01372951f, 0.00532971f, 0.02711457f, -0.05890858f, 0.00791564f, 
    0.02912673f, -0.04033468f, -0.05791397f, -0.04553464f, 0.01173780f, -0.04390904f, 0.01590418f, -0.00598275f, 
    -0.03827688f, -0.06015347f, -0.00443170f, 0.02993339f, -0.05617818f, -0.01378410f, -0.01462774f, -0.00754575f, 
    0.04269501f, 0.03262771f, -0.00712270f, 0.03673052f, 0.00872600f, -0.01406532f, 0.02130302f, -0.03545112f, 
    0.03808536f, 0.03230737f, 0.01967283f, -0.01579871f, -0.05264332f, -0.05422597f, -0.04348264f, -0.03116727f, 
    0.01762248f, -0.05708326f, -0.03904283f, 0.02192775f, -0.04098302f, 0.00701025f, -0.05194752f, 0.00724148f, 
    -0.03448255f, -0.02756388f, 0.03993519f, -0.02379560f, 0.00452268f, 0.00330860f, -0.01638017f, -0.00298555f, 
    -0.04480600f, -0.04845925f, -0.05882920f, 0.02439033f, -0.03238349f, -0.02121533f, 0.01527463f, -0.02237417f, 
    -0.02608724f, -0.03737959f, 0.00188044f, -0.05656895f, 0.02706504f, 0.03379294f, -0.03569539f, -0.00908621f, 
    -0.00076220f, 0.02321422f, 0.00229201f, -0.03730710f, 0.00771018f, -0.06035101f, -0.01194546f, -0.04225678f, 
    0.03648293f, 0.00395062f, -0.00668108f, 0.00364010f, -0.02739279f, 0.00949878f, -0.01052804f, -0.05942708f, 
    -0.02156885f, 0.01198369f, 0.00371117f, -0.01189604f, 0.03073882f, -0.00572717f, 0.02660603f, 0.03629866f, 
    -0.01897383f, -0.02495808f, 0.03361185f, 0.02217686f, 0.02820022f, -0.02807794f, 0.00184299f, 0.03038553f, 
    0.00710984f, 0.03371571f, 0.03003439f, -0.03275497f, 0.03027059f, -0.03895329f, -0.04515456f, -0.02810419f, 
    -0.04957909f, 0.03905686f, -0.02523490f, -0.00653905f, 0.00618081f, 0.03148985f, 0.00251855f, 0.00369438f, 
    -0.05198443f, 0.00201255f, -0.01185852f, 0.00126181f, -0.01370288f, -0.06022140f, 0.02674644f, -0.04062904f, 
    0.03981209f, 0.01848467f, 0.00118772f, 0.00985426f, 0.01745118f, -0.05578565f, 0.02499504f, -0.00999903f, 
    -0.05098775f, 0.03015002f, 0.04261558f, 0.01819733f, -0.00572290f, -0.00389156f, 0.03178029f, 0.00481451f, 
    -0.02572169f, -0.01732647f, -0.04031879f, -0.02634701f, 0.02335494f, -0.03759589f, -0.02249225f, -0.06178048f, 
    -0.02610997f, -0.03210858f, -0.00062522f, -0.05234105f, 0.02372464f, 0.03578877f, -0.00790541f, -0.00479381f, 
    -0.03461240f, 0.03481360f, 0.00768366f, -0.01941696f, 0.02443461f, -0.03547318f, 0.01785902f, -0.04406533f, 
    0.03126611f, 0.00003915f, -0.05301714f, -0.00993957f, -0.05145210f, 0.02046455f, 0.02776192f, -0.02035282f, 
    -0.00485405f, -0.05965272f, -0.06122139f, -0.03682499f, -0.05818157f, -0.02366338f, -0.01920542f, -0.01844749f, 
    -0.01675233f, 0.00185221f, -0.02075484f, -0.04040546f, -0.02079974f, -0.06163244f, 0.01081106f, -0.01449030f, 
    -0.00575745f, 0.00295230f, -0.00238829f, -0.04197190f, -0.00557626f, 0.00443240f, -0.04827455f, -0.01705455f, 
    -0.03542759f, 0.02939232f, 0.03258389f, 0.03453869f, -0.01929190f, 0.03005250f, -0.01048852f, 0.02285214f, 
    0.02881238f, -0.01586806f, 0.04373165f, 0.04116480f, 0.00298027f, -0.03825546f, -0.04216536f, -0.00391377f, 
    -0.03760237f, -0.03877619f, 0.00458558f, -0.03301144f, -0.04443998f, -0.05598133f, 0.03515093f, -0.02327066f, 
    -0.01901034f, -0.00326332f, 0.03993222f, -0.04720609f, -0.03185865f, 0.02664300f, 0.00329767f, -0.03121616f, 
    -0.05371711f, -0.02965776f, 0.01867729f, -0.03619625f, -0.00548204f, 0.03482610f, -0.01782962f, 0.05254982f, 
    -0.05350536f, -0.01222766f, -0.04260729f, -0.03643161f, 0.03896696f, -0.05196363f, -0.02651126f, 0.04415579f, 
    -0.04318350f, 0.03869134f, 0.02624459f, 0.02649290f, -0.03068322f, 0.03927650f, -0.03104571f, -0.02207402f, 
    0.03533551f, -0.01005775f, -0.00313069f, -0.04184422f, -0.01595246f, 0.00281740f, -0.03785547f, -0.04987618f, 
    -0.03355481f, 0.04641082f, -0.03788332f, -0.05798585f, 0.03431746f, -0.03996227f, 0.01209347f, -0.01189077f, 
    0.03236312f, 0.02368141f, -0.01293117f, -0.03251436f, -0.04540791f, -0.02577918f, -0.00010056f, -0.02768960f, 
    -0.02632070f, -0.01398975f, 0.00383246f, 0.00923152f, -0.02422139f, -0.04201947f, -0.02981862f, 0.03616307f, 
    -0.02914463f, 0.04521368f, 0.02127935f, 0.01001671f, 0.04175003f, -0.03915736f, -0.01068098f, -0.04060350f, 
    0.01009747f, 0.02396274f, -0.01851797f, 0.01656206f, -0.03773380f, -0.05141815f, -0.05132952f, 0.02907767f, 
    0.04374947f, 0.01788063f, 0.01862546f, -0.02544557f, 0.00676501f, -0.02924604f, -0.02770575f, -0.04465402f, 
    -0.00892645f, 0.01449797f, 0.02164730f, 0.01273223f, 0.01397617f, 0.02181770f, -0.01445517f, 0.02113894f, 
    -0.05348254f, 0.00015837f, -0.02135337f, -0.00763809f, 0.04551890f, -0.04379699f, 0.02261253f, -0.01093608f, 
    -0.04662801f, -0.00351657f, 0.00987943f, 0.02754288f, -0.04716002f, -0.04002726f, 0.04112874f, -0.05740335f, 
    -0.03825702f, 0.02320010f, 0.01149348f, -0.01793812f, -0.00940412f, 0.02323971f, -0.00597230f, -0.00912632f, 
    -0.04629209f, 0.03230700f, -0.05068657f, 0.03857040f, 0.02382508f, 0.00640983f, -0.00597918f, -0.05048806f, 
    0.01230867f, -0.04481665f, 0.00543710f, 0.00286813f, 0.04791002f, 0.02699093f, -0.02757346f, 0.01264021f, 
    0.01336538f, -0.01674851f, -0.05788310f, 0.02182354f, -0.01023245f, 0.04022394f, 0.04036000f, 0.03638300f, 
    -0.00929939f, 0.04681998f, -0.01896993f, -0.05423478f, 0.00839366f, -0.00006402f, 0.04761259f, -0.03147759f, 
    0.03338185f, 0.00455695f, -0.02953697f, -0.02307689f, -0.04638921f, -0.01541087f, -0.05191975f, -0.04569329f, 
    -0.00995889f, -0.05009697f, -0.03967508f, 0.00822915f, -0.05528089f, -0.01501494f, 0.02065736f, -0.05169420f, 
    -0.03862910f, -0.04597120f, -0.01500811f, -0.05511597f, 0.00850772f, -0.02944841f, 0.04154351f, 0.04421691f, 
    -0.00146600f, -0.02312619f, 0.02808833f, -0.02923929f, 0.04420446f, 0.02742568f, 0.02129301f, 0.04035583f, 
    -0.02844125f, -0.05778497f, -0.00072933f, 0.00400079f, -0.03595608f, 0.03824231f, 0.04636877f, 0.02010596f, 
    0.04411625f, -0.04678983f, 0.03240543f, 0.00528392f, -0.04222798f, -0.01012544f, -0.01438890f, -0.02966633f, 
    -0.00961521f, 0.02242202f, 0.03519460f, 0.03425139f, 0.01298878f, -0.02637916f, 0.04566957f, 0.03939631f, 
    0.01782606f, 0.02325467f, -0.02932038f, 0.02352823f, 0.02108355f, -0.02405294f, 0.02133937f, -0.00472200f, 
    -0.05053837f, 0.01169973f, 0.00366095f, 0.03382359f, 0.00307989f, -0.03334505f, 0.03481707f, 0.03935079f, 
    -0.01570979f, 0.00322223f, -0.01580049f, 0.01941756f, 0.02709106f, -0.04230190f, 0.03535738f, -0.03252261f, 
    -0.03288478f, -0.04206859f, 0.03621071f, -0.04412955f, -0.00257265f, 0.02258477f, 0.01991788f, -0.02223953f, 
    -0.01159994f, 0.01312956f, 0.02462703f, -0.05176511f, 0.03612014f, -0.04618631f, 0.00310880f, -0.02718272f, 
    -0.00123753f, -0.05516699f, 0.03633432f, 0.03823244f, 0.03869377f, -0.05016960f, -0.03164313f, 0.00535722f, 
    -0.03747090f, 0.02135690f, -0.01227953f, -0.01840616f, 0.03941247f, -0.02900674f, -0.01024536f, -0.01135791f, 
    -0.04564595f, 0.03258933f, 0.01180192f, -0.00766643f, -0.01032316f, -0.04374126f, -0.01451389f, -0.04149790f, 
    -0.02336260f, -0.00571556f, 0.04537372f, -0.02390368f, -0.05146105f, 0.00077715f, -0.00416116f, 0.00508743f, 
    -0.04569473f, -0.02523798f, 0.02786082f, 0.01107361f, -0.04511728f, -0.03058149f, -0.04374308f, 0.04110514f, 
    -0.04597272f, 0.05049223f, 0.00051525f, -0.05562003f, -0.02320086f, -0.04953740f, 0.01968687f, -0.04057929f, 
    -0.01015806f, 0.04058667f, -0.00348570f, -0.01291605f, -0.03299835f, -0.03943405f, 0.01042730f, -0.00020283f, 
    -0.04569285f, -0.02973112f, -0.01604329f, -0.01800960f, 0.03282724f, -0.03269976f, -0.05473405f, -0.04115226f, 
    0.01779245f, 0.03397820f, 0.00210368f, 0.01723828f, -0.04527798f, -0.02010308f, 0.02789360f, -0.05628750f, 
    0.00039510f, -0.05181241f, 0.01584011f, -0.03556968f, 0.00223653f, 0.00880727f, 0.00999041f, 0.01190672f, 
    -0.01604472f, -0.04310714f, 0.02731680f, 0.03349440f, -0.01711529f, 0.01356166f, -0.01126556f, 0.00218102f, 
    -0.00854563f, -0.00147573f, -0.04298370f, 0.00261662f, -0.01078285f, -0.01982665f, -0.01309564f, -0.02377331f, 
    -0.04383914f, -0.00203189f, -0.05615153f, -0.02181312f, 0.00456926f, -0.04040129f, -0.01569190f, 0.03694045f, 
    0.02723398f, -0.02810174f, 0.02877706f, 0.02224643f, -0.01857032f, 0.02588012f, -0.04859925f, 0.02550372f, 
    0.01557862f, 0.02673877f, -0.00465478f, 0.00918323f, 0.02897391f, -0.02229950f, -0.01008098f, -0.01215590f, 
    -0.05246127f, -0.00080554f, -0.03852271f, 0.02528670f, 0.02588847f, -0.01272365f, 0.01793304f, -0.01447742f, 
    -0.05246833f, 0.02455017f, -0.04943466f, 0.02188468f, -0.05623090f, -0.03188250f, -0.04738188f, 0.04144576f, 
    0.03409186f, -0.04231349f, -0.03656777f, 0.01959731f, 0.04881280f, -0.05212745f, 0.00401088f, -0.05249110f, 
    0.00353996f, 0.03082122f, -0.05061344f, 0.03937770f, -0.01731954f, 0.03754521f, -0.03345063f, 0.00720415f, 
    -0.03570093f, 0.00727222f, -0.00966596f, 0.00286989f, -0.01654766f, 0.02332591f, -0.03178519f, -0.03123079f, 
    -0.02486468f, -0.03188884f, -0.01764669f, -0.01617865f, -0.04890319f, 0.03679631f, -0.00945697f, 0.00475531f, 
    0.00526405f, 0.03536189f, -0.00371976f, -0.00295976f, -0.04868690f, -0.05383667f, -0.01262913f, -0.03948295f, 
    0.00158338f, -0.01908056f, -0.04435590f, -0.00287923f, -0.03592335f, 0.02903481f, 0.03884828f, -0.01950247f, 
    0.01970311f, -0.04206622f, -0.01842819f, -0.03411599f, -0.05362608f, 0.00703828f, 0.02803169f, -0.03821698f, 
    0.01546882f, -0.02605205f, 0.00587811f, 0.00503909f, -0.05422273f, 0.03894767f, 0.03967271f, -0.00152584f, 
    0.00291118f, -0.01323097f, -0.05344767f, 0.01971183f, -0.00917643f, 0.00704653f, 0.02742203f, -0.04828832f, 
    -0.02006313f, 0.04144865f, -0.04261230f, -0.04124413f, 0.03310823f, -0.04640314f, -0.04522570f, -0.05274929f, 
    -0.04661233f, -0.04212941f, 0.01880295f, 0.03997907f, -0.02704548f, -0.03180827f, -0.01671806f, -0.03233316f, 
    -0.04239600f, -0.02492222f, 0.02348110f, 0.01995087f, -0.00450120f, -0.02120898f, 0.02755331f, -0.04809454f, 
    0.03657108f, 0.01740970f, -0.01162949f, -0.05193098f, -0.05561234f, 0.03675886f, -0.05736003f, 0.03290380f, 
    0.02569669f, -0.01594175f, 0.02060753f, 0.03705704f, -0.02828465f, 0.02709853f, -0.01966426f, -0.00154178f, 
    -0.00929264f, -0.02526285f, -0.00829208f, -0.03628699f, 0.01567676f, -0.01342793f, -0.03970608f, -0.02835623f, 
    -0.03661043f, 0.01788510f, 0.03069282f, -0.01432348f, 0.01272497f, 0.04136338f, 0.02786715f, -0.05023553f, 
    0.01792038f, -0.00549180f, -0.02886598f, -0.05606954f, -0.03438904f, -0.02135041f, -0.05690847f, 0.02445123f, 
    0.01009006f, -0.03336824f, -0.02917598f, -0.02818453f, -0.05743917f, 0.01895714f, -0.04071465f, -0.00828683f, 
    0.00802913f, -0.05610060f, 0.00285420f, 0.03654147f, 0.03890222f, 0.00557916f, 0.00819799f, -0.04860340f, 
    0.02131953f, 0.02001029f, 0.03806429f, -0.01790765f, -0.01889544f, -0.03901774f, -0.04861158f, 0.02177014f, 
    -0.02051318f, -0.03953916f, -0.04809326f, -0.04068280f, -0.02604086f, -0.02577067f, -0.04618328f, 0.04138861f, 
    -0.01972684f, -0.03981350f, 0.03175541f, -0.00987585f, 0.02224275f, 0.04403509f, -0.01309555f, -0.00903175f, 
    -0.04504023f, -0.04407704f, -0.00037414f, -0.00384112f, -0.04354688f, -0.01612834f, -0.02156481f, -0.02445802f, 
    -0.00348254f, -0.00123996f, -0.00586797f, 0.03935669f, -0.02947948f, 0.03590465f, -0.03745177f, -0.01042495f, 
    0.03390657f, -0.00607953f, -0.01608841f, -0.01821380f, -0.04726264f, -0.00277141f, 0.03911268f, -0.02247357f, 
    -0.00861181f, 0.03929888f, -0.03161598f, -0.04634919f, 0.00015973f, -0.01430009f, 0.02065246f, -0.00714514f, 
    -0.05002454f, -0.05133673f, 0.03903897f, 0.02254939f, -0.03385152f, 0.01366419f, 0.02974263f, -0.01420945f, 
    -0.02537691f, -0.05492135f, -0.03201265f, 0.04145846f, 0.03628700f, 0.03731883f, -0.04791186f, 0.00916944f, 
    -0.02877841f, -0.01068665f, -0.03420808f, -0.01974050f, -0.05070374f, -0.05153114f, -0.02145695f, 0.02306869f, 
    0.01834264f, 0.00791119f, 0.01898788f, -0.02756859f, -0.05854955f, -0.05077080f, -0.02919817f, 0.02185928f, 
    0.02935540f, -0.00082987f, 0.01147158f, 0.00001646f, 0.02039987f, 0.04281589f, 0.02109937f, -0.01244004f, 
    0.02451780f, 0.00418195f, -0.00755530f, -0.05738616f, -0.03157140f, -0.05253350f, 0.01299895f, 0.01544432f, 
    0.03223260f, -0.04345782f, 0.03661114f, -0.04108739f, -0.00853110f, 0.03524400f, 0.03124493f, 0.01152548f, 
    -0.02116799f, 0.00940939f, 0.00184483f, -0.03156795f, -0.02734669f, -0.05672055f, 0.02082893f, -0.05299115f, 
    -0.02135150f, -0.03519802f, 0.02954798f, -0.04643799f, -0.02066592f, -0.02719891f, 0.00874585f, -0.04246236f, 
    0.01777592f, 0.00826919f, -0.05542484f, 0.01028293f, -0.02442855f, -0.04967646f, -0.00268004f, 0.03481924f, 
    0.01203635f, 0.01933157f, 0.00937264f, -0.02191678f, 0.03446329f, 0.00362871f, -0.04732266f, -0.01868489f, 
    0.01278852f, -0.04382065f, -0.00514948f, -0.04475838f, -0.05636735f, 0.03285726f, 0.02298816f, 0.01686589f, 
    -0.05083814f, 0.04382163f, 0.00491785f, 0.01842961f, 0.02245283f, -0.05657593f, 0.04333734f, -0.05425580f, 
    -0.00720950f, 0.02399935f, 0.01945475f, -0.00006830f, -0.03269622f, -0.01997611f, -0.03226225f, -0.01180881f, 
    -0.01374894f, 0.01624383f, -0.01552031f, -0.04304726f, -0.04700991f, -0.01337898f, 0.01607118f, -0.02148496f, 
    -0.01765788f, -0.02629640f, 0.02622855f, 0.03081202f, 0.00411075f, -0.04506204f, 0.01976109f, 0.03682237f, 
    -0.01742218f, -0.00943776f, -0.01687064f, -0.02920564f, 0.00243436f, 0.01108320f, 0.00467393f, -0.05659165f, 
    -0.02060364f, -0.00639651f, 0.02432324f, 0.04271830f, -0.01337777f, 0.03006211f, 0.00099036f, -0.05371270f, 
    -0.21234490f, -0.13702193f, 0.19079590f, 0.28418881f, 0.04042631f, -0.01394544f, -0.05659046f, -0.07746276f, 
    0.05118288f, -0.11862678f, -0.01643878f, 0.05675429f, -0.10782773f, 0.15892859f, 0.07816100f, 0.18427660f, 
    0.09988331f, 0.01805009f, 0.23381247f, -0.03976205f, 0.10906107f, 0.01187866f, -0.15493827f, -0.09862091f, 
    -0.02596515f, 0.02706504f, 0.05041794f, 0.02290843f, -0.15870927f, 0.05712473f, -0.08437977f, -0.02146717f, 
    -0.14037544f, 0.01621714f, 0.00783009f, -0.00484505f, 0.07779476f, 0.01097606f, 0.13556588f, -0.09319012f, 
    0.09848391f, -0.10441658f, -0.13596086f, -0.05555825f, -0.08634560f, 0.02356231f, -0.09095717f, 0.09065101f, 
    -0.04003700f, 0.00582001f, 0.02973336f, 0.31496894f, 0.10832509f, 0.11196571f, 0.08256562f, -0.05612735f, 
    0.13254850f, 0.01569454f, -0.00272107f, 0.09676448f, 0.06764410f, -0.10669469f, 0.46182162f, -0.13351972f, 
    0.09924623f, 0.10637042f, -0.10646166f, 0.22751379f, -0.11675717f, 0.05295912f, 0.00644916f, 0.01489449f, 
    -0.14265859f, -0.07071447f, -0.05071093f, -0.04513356f, -0.18526697f, -0.07788428f, -0.06984899f, -0.13032980f, 
    0.07733670f, -0.20704646f, -0.06717900f, -0.02173358f, 0.07252870f, -0.15680507f, -0.05903789f, 0.18441039f, 
    -0.01459520f, 0.10151342f, 0.04343411f, 0.11039751f, -0.03850141f, -0.01795440f, 0.02085889f, -0.17554756f, 
    -0.01061503f, 0.10215890f, -0.12792420f, 0.08117002f, -0.02943833f, -0.03952320f, 0.06371370f, 0.16767149f, 
    0.00376904f, 0.04288039f, -0.13496092f, 0.06343894f, 0.06989044f, -0.06392186f, -0.05908252f, -0.00497077f, 
    0.07997970f, 0.08189576f, 0.05085531f, -0.06241570f, 0.02271480f, 0.01584803f, 0.04926296f, 0.09775754f, 
    -0.05545641f, 0.20696943f, -0.21823174f, -0.09373006f, 0.06755064f, -0.09615940f, 0.13725838f, 0.06321941f, 
    -0.00656174f, -0.02454513f, 0.01046741f, 0.00344092f, -0.02917587f, 0.00142988f, 0.02908052f, -0.11002092f, 
    -0.08524937f, -0.10227040f, 0.05581440f, 0.23446839f, 0.08231075f, -0.03596180f, 0.01327793f, 0.03789668f, 
    -0.21208054f, -0.12287976f, 0.10511139f, 0.06679902f, -0.10421748f, -0.06578437f, -0.05336645f, 0.09491118f, 
    -0.07107703f, -0.07430148f, -0.00466776f, 0.07078167f, -0.26578903f, -0.15458982f, 0.25098673f, 0.15276788f, 
    0.01038781f, -0.05278683f, 0.02348796f, 0.04308331f, -0.00577244f, 0.01202749f, -0.05922897f, 0.00583923f, 
    -0.22181261f, 0.27135170f, 0.03031326f, 0.06639511f, -0.02386668f, 0.00419052f, 0.07160913f, 0.11061219f, 
    -0.08648327f, 0.01879440f, -0.04658565f, -0.03099100f, -0.00915856f, -0.08156530f, -0.06752721f, 0.09187453f, 
    0.06086015f, -0.02842178f, 0.02881883f, 0.21733351f, 0.11934008f, 0.08923458f, -0.04699559f, 0.01784852f, 
    0.03076267f, -0.02858492f, 0.05210384f, -0.06565951f, -0.10651078f, -0.08643688f, -0.01100278f, 0.07423197f, 
    0.02814461f, -0.00157838f, 0.12412462f, 0.07472882f, 0.24304155f, 0.02927625f, 0.18018784f, 0.16956492f, 
    0.18073955f, 0.03721135f, 0.02926275f, 0.13872311f, -0.08285591f, 0.12431926f, 0.03074699f, 0.05098048f, 
    -0.12615229f, 0.04310130f, 0.05734080f, 0.02630920f, 0.12222263f, 0.01279513f, 0.00042344f, -0.01862771f, 
    -0.04661807f, -0.01581064f, -0.19553253f, -0.00354975f, -0.01586577f, -0.17676355f, 0.12371947f, 0.09643364f, 
    0.03393387f, 0.09864938f, 0.14623034f, 0.06648848f, -0.18454061f, 0.12285303f, -0.00811290f, -0.04094530f, 
    0.18331710f, -0.16870940f, 0.05564130f, 0.09197272f, 0.07281701f, 0.15967819f, 0.00174397f, -0.01954576f, 
    0.19228958f, 0.05835585f, 0.19546819f, -0.00232510f, 0.14584157f, 0.17659019f, 0.12862901f, -0.24409983f, 
    0.01870960f, 0.10688395f, -0.14806333f, 0.11617505f, 0.01678947f, -0.10062188f, 0.02116711f, 0.02082343f, 
    0.04063643f, -0.00404574f, 0.08372395f, -0.08362319f, -0.04937651f, -0.06062970f, -0.07677197f, 0.05595598f, 
    -0.00613826f, -0.02239424f, 0.10461581f, -0.04018162f, -0.07295045f, 0.33826903f, 0.18629892f, 0.00204952f, 
    0.11033506f, 0.00022724f, 0.01901575f, 0.02492441f, -0.00722120f, -0.07637324f, 0.00285014f, -0.05689360f, 
    -0.17098896f, -0.01376745f, 0.01613582f, 0.12082259f, 0.10769681f, -0.13907622f, 0.17783408f, 0.24306381f, 
    0.00278738f, 0.03075321f, -0.00766999f, 0.11215448f, -0.07070331f, 0.06396072f, -0.00847427f, -0.10589542f, 
    -0.12242222f, -0.12031410f, -0.12475500f, 0.15677908f, 0.05964856f, -0.00159919f, 0.01638195f, -0.02756169f, 
    0.11301877f, -0.03516552f, 0.07533390f, -0.00165585f, 0.14766575f, -0.07210238f, 0.09664228f, 0.17001650f, 
    -0.05303071f, 0.00296224f, 0.10042204f, -0.09495760f, 0.32513106f, 0.08839946f, -0.01283278f, -0.23592751f, 
    0.02620441f, 0.17750420f, -0.21211392f, 0.13202229f, -0.00636363f, -0.04990053f, 0.01028855f, -0.12131418f, 
    -0.20859694f, 0.03014949f, 0.07072350f, 0.01225946f, 0.03051995f, -0.12879524f, 0.20305388f, 0.00753314f, 
    0.06058336f, -0.06702828f, 0.04221593f, -0.07530534f, 0.03151581f, 0.17479731f, 0.06505331f, -0.21237655f, 
    -0.03673511f, -0.04651884f, -0.04532484f, 0.03839212f, -0.20753248f, 0.13918696f, 0.21749267f, -0.03614679f, 
    -0.16469449f, -0.08494534f, 0.04578976f, 0.25412339f, -0.08640630f, -0.10712036f, 0.14094925f, -0.10289565f, 
    0.08173699f, 0.09064488f, -0.02125899f, 0.02538696f, -0.10347557f, -0.03980245f, 0.06278441f, -0.00390716f, 
    -0.11460812f, -0.18856972f, -0.11759542f, -0.03319602f, 0.11866305f, 0.02185073f, -0.01918570f, -0.02077619f, 
    0.32694981f, 0.22168222f, -0.00037150f, -0.15908535f, -0.02109730f, -0.12461400f, 0.05874577f, 0.15603673f, 
    0.13057408f, 0.18935716f, 0.17037429f, -0.07843394f, 0.00372476f, -0.25643012f, 0.02259103f, -0.16365430f, 
    0.16930184f, -0.07469042f, -0.03995426f, -0.10157432f, -0.16333422f, -0.15029651f, -0.28565556f, -0.30263549f, 
    -0.07358300f, -0.00728919f, 0.03431199f, 0.08145732f, 0.02495313f, 0.02464673f, -0.04725286f, -0.05530895f, 
    -0.07820102f, -0.18251295f, -0.16079707f, -0.31049469f, -0.19052200f, -0.25160027f, -0.18544452f, 0.20628567f, 
    0.06080346f, 0.15437700f, 0.05497346f, 0.02862655f, -0.01618954f, 0.02300300f, -0.01021041f, -0.23971993f, 
    0.26717463f, 0.06086961f, -0.03706457f, -0.13024521f, 0.00592748f, -0.06832966f, 0.01060863f, 0.01314126f, 
    0.02596066f, -0.01163713f, 0.05673515f, 0.01521341f, 0.12462363f, -0.17701045f, -0.12365212f, -0.12659374f, 
    0.05285717f, -0.04587118f, 0.11715189f, 0.03414860f, -0.15966381f, 0.00932908f, -0.27356675f, -0.25723392f, 
    0.07525926f, 0.09369462f, -0.06147053f, 0.01510160f, -0.01361493f, 0.12310170f, 0.06006576f, -0.13164458f, 
    -0.10207496f, 0.00616555f, 0.01295732f, -0.13332014f, 0.00423543f, 0.23520476f, 0.15563272f, -0.15437980f, 
    0.05568241f, -0.07475511f, -0.01778852f, -0.05980309f, -0.12748548f, -0.11908328f, -0.04255763f, -0.16262138f, 
    -0.34471011f, 0.30418378f, 0.36375517f, -0.25833023f, 0.01710928f, 0.07218762f, -0.08641371f, -0.09913959f, 
    -0.07994112f, 0.08949701f, 0.08157340f, -0.00698524f, -0.02158816f, 0.12658352f, -0.06314545f, 0.20475177f, 
    -0.19354740f, -0.15859911f, -0.03455517f, -0.10920372f, 0.10111730f, 0.05310056f, 0.25586629f, 0.26709810f, 
    0.06982552f, -0.26846614f, 0.30613565f, 0.06118341f, -0.11447220f, -0.10740151f, -0.13797671f, -0.21908113f, 
    -0.00549936f, 0.06884427f, -0.06750975f, 0.13068052f, 0.00338899f, 0.06727881f, 0.02682791f, 0.08944704f, 
    -0.02520960f, 0.07453900f, 0.06112379f, -0.05745064f, 0.15214662f, 0.25034615f, 0.16703239f, 0.41404054f, 
    0.16851455f, 0.08578111f, -0.09619604f, -0.04689164f, 0.08389559f, 0.02870761f, 0.02337102f, -0.00781160f, 
    -0.09041049f, -0.03336262f, -0.06311893f, -0.05767678f, 0.23249550f, -0.02365644f, -0.15631191f, 0.09786450f, 
    0.01944926f, 0.07506968f, -0.05826189f, 0.06361815f, -0.06452456f, -0.09074007f, -0.07616583f, 0.03653033f, 
    0.15631564f, -0.10854892f, -0.17781779f, 0.05374448f, -0.09620784f, 0.03201644f, 0.03436859f, 0.11026800f, 
    -0.02984032f, -0.07405571f, -0.08269830f, 0.11403722f, 0.00143517f, -0.01839553f, 0.18818016f, 0.02840577f, 
    -0.05282035f, -0.18194708f, -0.16362226f, -0.09770849f, 0.04963528f, 0.12171204f, -0.00934695f, 0.07193607f, 
    0.03843594f, -0.21044907f, -0.10285130f, 0.02943425f, -0.11505831f, -0.03794179f, -0.25947654f, -0.27665690f, 
    0.01146905f, 0.06919051f, -0.03599667f, 0.05612779f, -0.11555135f, -0.01817676f, -0.25218540f, 0.13570257f, 
    0.03442466f, 0.05235938f, 0.07010283f, 0.03046364f, 0.06946275f, -0.19063105f, 0.00121598f, -0.10984479f, 
    -0.00526130f, 0.18105149f, -0.00065537f, 0.02701315f, -0.04681446f, -0.00317063f, -0.00200922f, -0.03610343f, 
    -0.06301928f, -0.18805394f, -0.12762956f, -0.10992755f, 0.10517374f, 0.03841121f, -0.18019068f, -0.20249805f, 
    0.06817095f, 0.06391980f, 0.12213194f, 0.08830275f, 0.04902563f, -0.03889248f, -0.06231600f, -0.09179656f, 
    0.13372372f, 0.15046644f, 0.05754830f, 0.10064081f, 0.13268903f, -0.02958355f, 0.03279965f, 0.07125931f, 
    0.05335818f, 0.10364433f, 0.04504765f, 0.23674721f, -0.01957597f, 0.20548274f, 0.16485342f, 0.21179189f, 
    0.11095698f, 0.13260493f, 0.15133891f, 0.23036581f, -0.00230729f, -0.10103126f, -0.03560017f, -0.10215434f, 
    -0.14113019f, -0.02992936f, -0.09902334f, 0.02275896f, 0.06215584f, 0.11876533f, 0.11150528f, -0.00856457f, 
    0.08679849f, -0.01793324f, 0.03661604f, -0.07836431f, 0.05983986f, -0.23044504f, 0.11417700f, 0.06341136f, 
    0.01727526f, 0.04945891f, 0.03218863f, 0.00959384f, 0.02515402f, -0.06792618f, 0.00673169f, 0.24823828f, 
    -0.29273975f, -0.11881451f, 0.07847229f, -0.14149071f, -0.05416847f, 0.00815816f, 0.15459311f, -0.10226491f, 
    0.02785150f, -0.09595200f, -0.07876018f, 0.17764108f, 0.07894158f, 0.18841200f, 0.44278070f, 0.22832200f, 
    0.11657654f, -0.06468607f, 0.01107491f, -0.17779484f, 0.14890902f, 0.13321045f, 0.10358129f, 0.05069536f, 
    -0.26395327f, -0.03671436f, 0.07813945f, 0.02619994f, -0.01083291f, -0.02887699f, -0.08066656f, -0.05633143f, 
    0.26202244f, -0.00101888f, -0.27709538f, 0.06595010f, -0.19010794f, 0.16990831f, 0.05424896f, 0.22813514f, 
    0.14417174f, -0.00147991f, 0.07343483f, -0.08882473f, -0.25563911f, -0.31040797f, -0.20973100f, -0.27085719f, 
    0.12053856f, -0.04296857f, -0.05603018f, 0.03006161f, -0.01483769f, 0.07986586f, -0.03368444f, 0.01842945f, 
    0.04454372f, 0.00482604f, -0.04153010f, 0.08195163f, -0.18948616f, -0.11017859f, 0.02645368f, -0.12719734f, 
    0.06010485f, 0.08256285f, 0.02397146f, -0.01514645f, -0.17381249f, -0.07022595f, -0.06533833f, -0.18616691f, 
    0.49459538f, 0.35383117f, -0.01354581f, 0.13665587f, -0.15801027f, 0.07400923f, -0.13176802f, -0.08190776f, 
    0.10253432f, -0.09262311f, -0.08000425f, 0.05362516f, 0.08767269f, 0.04462314f, -0.01777897f, 0.09002181f, 
    -0.06280189f, 0.11341127f, -0.05838782f, -0.05248206f, 0.17262851f, 0.14111370f, 0.09370462f, 0.31052086f, 
    -0.01895954f, -0.00123007f, 0.00362565f, -0.01241119f, -0.03325088f, 0.02361348f, -0.05182109f, -0.01521335f, 
    -0.05106260f, 0.00932129f, -0.06227518f, 0.01383802f, 0.01030563f, -0.00183640f, 0.02587114f, -0.01851090f, 
    0.00467031f, 0.04450580f, -0.02259655f, 0.01923932f, -0.07975893f, -0.00423170f, -0.05821766f, -0.09108303f, 
    -0.01581565f, -0.05324429f, -0.00654294f, -0.07391465f, -0.00840559f, -0.05132195f, -0.01996146f, -0.03554101f, 
    0.01561451f, -0.07445300f, 0.02532633f, -0.06026283f, 0.02182933f, -0.06376781f, -0.00466414f, 0.02742144f, 
    0.02984089f, -0.03400391f, -0.09437303f, -0.02556176f, -0.00994771f, 0.02630300f, -0.05033987f, 0.01124315f, 
    -0.04587896f, -0.04197183f, -0.06738703f, 0.01435197f, 0.00724101f, -0.01719447f, -0.05948694f, -0.05721961f, 
    0.02007378f, -0.05388593f, -0.01161055f, 0.05610612f, 0.00085967f, -0.05456193f, -0.06306059f, -0.04305325f, 
    0.03600220f, -0.01027928f, -0.02167733f, 0.05274769f, 0.00015736f, 0.02448388f, 0.00685924f, -0.06017842f, 
    -0.00425688f, 0.01761895f, -0.02158021f, -0.02199888f, -0.01884873f, -0.06241313f, -0.01342158f, -0.10086634f, 
    -0.04870457f, -0.02179784f, 0.02189325f, -0.01023158f, -0.02424915f, -0.02296712f, -0.05202805f, -0.00787955f, 
    -0.02861819f, 0.01954983f, -0.06295525f, -0.00766808f, -0.08482610f, -0.00517580f, -0.05805537f, -0.07553040f, 
    0.02910871f, 0.05417520f, -0.07681184f, -0.02100190f, 0.01532155f, -0.05080657f, 0.05750891f, 0.00359462f, 
    -0.00830050f, -0.06610209f, 0.02165289f, 0.02529790f, 0.00343898f, -0.05976394f, -0.01915947f, -0.07505887f, 
    0.00162503f, 0.04378371f, 0.05543537f, -0.05321159f, 0.00940368f, -0.02404557f, 0.03806907f, 0.05283481f, 
    0.03232034f, 0.02833900f, -0.03009509f, 0.00638073f, -0.03234696f, 0.02891457f, -0.01627197f, -0.03310312f, 
    -0.01763564f, -0.05790886f, 0.01789069f, -0.01229940f, -0.02952474f, -0.01151638f, -0.06990807f, -0.02681953f, 
    -0.00149460f, -0.02053202f, 0.05448541f, 0.00373039f, -0.03772261f, 0.01451902f, -0.06029138f, 0.05211564f, 
    -0.01460696f, -0.07395037f, -0.09054188f, -0.00425608f, -0.08620042f, -0.05290912f, -0.00464341f, 0.03194003f, 
    -0.04914268f, -0.03082164f, -0.04453744f, -0.00476692f, -0.01663384f, -0.07415074f, 0.03175300f, -0.04348795f, 
    -0.08920384f, 0.01018993f, -0.04542441f, -0.04020961f, 0.03572695f, 0.02631058f, -0.05571062f, 0.03408232f, 
    0.00940450f, -0.04198722f, -0.00785393f, 0.00515643f, -0.00398733f, -0.06927600f, 0.00307107f, 0.00266642f, 
    -0.02824968f, 0.05537228f, 0.03437230f, -0.05133348f, 0.00030732f, 0.02191651f, -0.00940359f, 0.01417863f, 
    -0.05988957f, -0.04849464f, 0.00572979f, 0.05495750f, 0.03540986f, -0.04335972f, 0.00615186f, -0.03115075f, 
    0.04073104f, 0.05573810f, -0.00607747f, -0.00509348f, -0.00294766f, -0.02702132f, -0.03317007f, -0.05413139f, 
    0.01032167f, -0.02272905f, -0.04082190f, 0.04214461f, -0.07095177f, -0.04706157f, -0.05531172f, -0.00053371f, 
    -0.02353452f, 0.03077539f, 0.03438144f, 0.01745270f, -0.00483193f, -0.03253472f, 0.00508899f, 0.03212028f, 
    -0.03290212f, 0.01508999f, -0.08813359f, -0.03061520f, 0.00168703f, -0.02982463f, -0.05162681f, -0.02507816f, 
    0.00226263f, -0.04144730f, -0.04780451f, -0.07368445f, 0.00247002f, -0.06061907f, -0.04783101f, -0.03782602f, 
    0.03618898f, 0.00841277f, -0.01288660f, 0.01411477f, -0.04190720f, -0.07589918f, -0.05176966f, -0.02664231f, 
    -0.00551065f, 0.00513999f, 0.00730090f, 0.01290029f, -0.03473059f, -0.05013308f, -0.01610268f, 0.02081949f, 
    -0.01947631f, -0.03809129f, -0.00440203f, -0.00127525f, -0.03609454f, -0.00645179f, -0.01309783f, -0.01819357f, 
    0.04065607f, -0.03929973f, 0.03558348f, 0.02017192f, -0.01386298f, -0.03017749f, 0.00179371f, -0.02822384f, 
    -0.03294763f, -0.04041546f, 0.01270563f, 0.02156280f, -0.04168783f, 0.03881549f, -0.02175063f, -0.04438959f, 
    -0.00130956f, -0.00636869f, -0.00825804f, -0.07398701f, -0.05034484f, -0.01359518f, 0.04631729f, 0.00589686f, 
    0.01591545f, -0.03724818f, -0.00405668f, -0.05622591f, -0.05298138f, 0.01123331f, -0.01537814f, -0.03821157f, 
    0.03182689f, 0.03491031f, 0.02531267f, 0.06300701f, -0.00080421f, -0.05585699f, -0.06733926f, -0.00700288f, 
    0.02167625f, -0.01662743f, -0.02072684f, -0.00063606f, 0.01952393f, 0.03887535f, -0.03043121f, 0.02096180f, 
    -0.06058907f, -0.04593877f, -0.06831547f, -0.05686983f, 0.00724823f, -0.01153186f, -0.05300821f, -0.00924245f, 
    0.03971029f, 0.01974086f, 0.03154286f, 0.00226508f, -0.03341770f, -0.00957510f, 0.03647620f, -0.00342436f, 
    -0.05177954f, 0.00650064f, -0.05092095f, -0.06454080f, 0.00517977f, 0.03640009f, 0.01037110f, -0.04314737f, 
    -0.04573938f, -0.01027736f, -0.04040254f, -0.07196831f, -0.04898668f, -0.07751981f, -0.04163013f, 0.02923102f, 
    -0.02542299f, -0.01699920f, 0.02028124f, -0.04738801f, 0.01526602f, -0.04482708f, 0.02900634f, -0.02834442f, 
    -0.04820069f, 0.02031107f, -0.02567067f, -0.05235167f, 0.00013838f, 0.03112356f, -0.03250444f, -0.00996323f, 
    -0.01297827f, 0.01073829f, -0.06283108f, 0.00660283f, -0.03231903f, 0.00546986f, 0.02279913f, -0.01916721f, 
    0.01561434f, -0.02089583f, -0.07534828f, -0.04030740f, -0.08091965f, 0.02348137f, 0.01912543f, -0.01351682f, 
    -0.00820719f, 0.00027543f, 0.02740537f, 0.00871123f, 0.00814723f, -0.07143405f, -0.02867699f, -0.04659266f, 
    0.00591079f, 0.01279220f, -0.04111630f, -0.03907444f, -0.00034169f, 0.00639733f, 0.04897561f, -0.02748777f, 
    -0.11384415f, 0.01633960f, 0.00531857f, 0.08081739f, -0.09311873f, 0.05362333f, 0.08824340f, 0.06280898f, 
    0.10198703f, 0.04953499f, 0.07088453f, 0.00116225f, -0.28281841f, -0.02823979f, -0.00122605f, -0.01201481f, 
    0.06013425f, -0.12389569f, -0.06636553f, -0.01612181f, -0.13595946f, -0.25972050f, 0.00568880f, -0.10042611f, 
    -0.25314710f, 0.00268661f, 0.17097828f, -0.03374908f, -0.04389369f, -0.09327228f, 0.08262735f, -0.04642662f, 
    -0.07811482f, -0.00998678f, -0.03936902f, -0.15845338f, 0.02506183f, 0.16795470f, 0.04693792f, -0.10450079f, 
    -0.17001535f, -0.04202396f, -0.09946074f, 0.04564474f, -0.09466056f, -0.08742224f, -0.04515928f, -0.18839553f, 
    -0.00264776f, -0.07084105f, 0.01740713f, 0.19317035f, 0.00725539f, 0.07567860f, 0.05868728f, -0.03987266f, 
    -0.00910429f, 0.10027065f, 0.09157467f, -0.01839996f, -0.05602031f, 0.18955332f, 0.00888807f, 0.00496298f, 
    0.02514279f, 0.00874392f, 0.09019382f, 0.00722607f, 0.03053248f, -0.03362121f, -0.03186509f, -0.22755452f, 
    0.11844213f, -0.03055717f, 0.09415109f, -0.26430780f, 0.09552264f, -0.04486761f, 0.00727528f, 0.12869039f, 
    -0.12469383f, -0.01514049f, -0.17399485f, -0.09628753f, -0.18670607f, 0.03979739f, -0.10232408f, -0.03228348f, 
    -0.01743969f, -0.01473804f, -0.02415845f, 0.02749544f, -0.11123715f, -0.15319918f, -0.08724619f, -0.05442820f, 
    -0.15816693f, 0.07384916f, 0.00059399f, 0.16052061f, 0.01742876f, 0.04731451f, 0.14286253f, -0.10407646f, 
    -0.01874700f, 0.00067957f, 0.07104572f, 0.15916741f, 0.51743490f, -0.08177727f, -0.00263020f, 0.03910109f, 
    0.00702911f, -0.03088299f, 0.04433194f, -0.11769188f, 0.04025175f, 0.11487771f, 0.03579416f, 0.13295095f, 
    0.28955239f, -0.20276202f, 0.22288905f, -0.18072146f, 0.03866910f, -0.03234771f, -0.20190750f, -0.12010320f, 
    -0.07840040f, -0.08898708f, -0.05508154f, -0.08989919f, -0.00723603f, -0.09600497f, 0.00546750f, 0.20425601f, 
    0.06765579f, 0.33449298f, 0.09956841f, -0.12451984f, -0.00806944f, 0.10228147f, 0.03167647f, 0.25743386f, 
    -0.00007642f, -0.07157033f, -0.00530311f, 0.12629528f, -0.05079328f, -0.00094515f, 0.10745632f, 0.06392210f, 
    -0.02065122f, 0.00431349f, -0.07824466f, -0.05964898f, 0.17882182f, -0.09589251f, 0.24757180f, -0.10397591f, 
    0.05210276f, 0.07438862f, 0.10097720f, 0.26962146f, 0.11545413f, 0.07800172f, -0.00690410f, -0.05321046f, 
    -0.01141027f, -0.16734256f, 0.26097631f, 0.12821718f, 0.04529365f, -0.04600058f, 0.10963407f, 0.06718169f, 
    0.10547128f, -0.04109294f, -0.10034186f, 0.04339119f, -0.01073780f, -0.02143951f, -0.02734988f, -0.12945016f, 
    -0.05663200f, 0.03431651f, -0.03561817f, -0.16637212f, -0.05449159f, 0.01189158f, 0.12341274f, 0.02932271f, 
    0.06017187f, -0.02285745f, 0.12099214f, -0.19054842f, -0.04489373f, -0.00217065f, -0.11433864f, -0.07411783f, 
    -0.06875093f, 0.09072462f, -0.08322998f, -0.10181254f, -0.29410002f, 0.01984782f, 0.27758595f, -0.15872023f, 
    -0.04342198f, 0.05881237f, -0.04171991f, -0.01553540f, 0.06187406f, -0.05688679f, 0.10108504f, -0.03073040f, 
    0.16352595f, 0.08772916f, 0.01056697f, 0.07933363f, -0.15017292f, 0.14970303f, -0.09425481f, 0.00154694f, 
    -0.06605484f, -0.16895333f, 0.01851140f, 0.13142431f, -0.15112397f, 0.09595682f, -0.21832024f, -0.09155083f, 
    0.01979334f, -0.05283349f, -0.02435648f, 0.16821574f, 0.02835104f, -0.12177397f, 0.03688350f, 0.04172837f, 
    -0.06320597f, 0.03465998f, -0.05567612f, 0.05582233f, 0.02695018f, 0.04153293f, 0.11048892f, 0.14529446f, 
    0.01906863f, 0.04806314f, 0.01132362f, 0.10742883f, -0.10666906f, 0.34669831f, 0.01981077f, 0.09482444f, 
    -0.07890154f, -0.22260866f, -0.04874688f, -0.05431299f, -0.10055468f, 0.10015608f, -0.07841497f, 0.06960717f, 
    0.20450209f, 0.06608626f, 0.13098902f, -0.13499108f, -0.03752241f, -0.03053903f, -0.14560947f, -0.01020014f, 
    0.04351953f, -0.11571813f, -0.10749541f, -0.00461980f, 0.13123243f, 0.11346775f, 0.23515750f, 0.22485870f, 
    -0.00147621f, -0.14961948f, -0.01963767f, -0.03104122f, -0.02336229f, 0.02968835f, 0.07487576f, -0.00321876f, 
    0.16132334f, 0.18250626f, -0.01049773f, 0.04345124f, -0.04308961f, 0.11181675f, -0.02403455f, -0.43180087f, 
    0.13206318f, 0.06345551f, -0.03960745f, -0.02129200f, 0.63065976f, 0.09121267f, -0.14883880f, 0.03989927f, 
    0.01521390f, -0.14292067f, 0.02744599f, -0.06951050f, 0.02054857f, -0.01006757f, -0.01820658f, 0.16840631f, 
    -0.06057304f, 0.01576104f, -0.07556081f, -0.00987195f, -0.11264455f, -0.00700904f, 0.00214969f, -0.02327298f, 
    0.09567261f, -0.08658964f, -0.01836956f, -0.03169388f, -0.10093407f, -0.04010997f, -0.00613413f, 0.25442103f, 
    -0.07897113f, 0.00261411f, -0.07984108f, -0.16435541f, -0.04421068f, -0.23151937f, -0.08307869f, -0.00946373f, 
    0.15140115f, -0.14466201f, 0.16560209f, 0.21218003f, 0.04586506f, -0.04391187f, 0.04700595f, 0.12908505f, 
    -0.02168498f, -0.02988245f, 0.01863167f, 0.13859101f, 0.15552510f, 0.26870257f, 0.08618750f, 0.01412767f, 
    -0.08069780f, -0.08741018f, -0.18276009f, -0.07891226f, -0.17400454f, -0.20656531f, -0.10153630f, -0.08333649f, 
    0.47699538f, 0.06327643f, 0.16681792f, 0.07255846f, -0.12061943f, 0.12619331f, -0.26257604f, -0.02991566f, 
    0.07916552f, -0.17139606f, 0.06470272f, 0.08876152f, 0.10474168f, -0.21731524f, 0.01792680f, 0.14069912f, 
    0.00591313f, 0.14729479f, 0.19396208f, -0.01372296f, 0.07264065f, 0.00707007f, -0.00505295f, 0.16764607f, 
    0.09362767f, -0.03069471f, -0.02325322f, -0.18024835f, -0.06497411f, -0.07938700f, 0.07576149f, 0.03429765f, 
    0.07979361f, 0.12894060f, -0.05046772f, 0.08642171f, 0.08979395f, -0.02559478f, -0.00625478f, -0.12915432f, 
    -0.03537058f, 0.01841240f, -0.11789005f, 0.03715074f, -0.02945448f, 0.00392843f, -0.06179892f, 0.02337560f, 
    0.13793172f, 0.06449094f, 0.03670727f, -0.11776432f, 0.07113528f, 0.02025885f, 0.00704200f, 0.01895235f, 
    -0.06850214f, 0.04978719f, -0.15896209f, -0.07639179f, 0.07796232f, 0.09633712f, 0.05007449f, 0.11696412f, 
    -0.00789023f, 0.03986184f, 0.04373512f, 0.07167435f, -0.05437436f, -0.04529648f, -0.01000540f, 0.03160444f, 
    0.05625959f, 0.04440970f, 0.08625316f, -0.28278944f, 0.16318482f, 0.03992630f, 0.22945924f, 0.16114761f, 
    0.11525133f, 0.00635430f, 0.11752249f, 0.01890999f, 0.12133557f, -0.09059170f, -0.12733546f, -0.03051867f, 
    -0.00433890f, -0.04067766f, 0.04696316f, 0.00738497f, -0.01581950f, -0.03942728f, -0.01209999f, 0.06106956f, 
    0.05592034f, 0.14165978f, 0.07035005f, 0.18229283f, -0.07770228f, -0.06878524f, -0.01848205f, -0.05083810f, 
    0.11097503f, 0.23142004f, 0.00598134f, 0.10203549f, -0.00734508f, 0.13486949f, -0.04262889f, -0.07461692f, 
    0.11436025f, 0.04313301f, -0.00406756f, 0.08227905f, 0.00641023f, -0.05110783f, 0.03165140f, 0.09061050f, 
    0.26804850f, -0.09505632f, -0.07252211f, -0.16943572f, 0.02698650f, -0.00054659f, 0.05338793f, 0.19860950f, 
    0.09456114f, -0.04716150f, 0.02192811f, -0.10432182f, -0.51751441f, -0.03898333f, 0.01856811f, 0.07605234f, 
    -0.02439437f, 0.01775523f, 0.01799209f, 0.05488465f, 0.04993461f, 0.04189165f, -0.10646591f, -0.07342350f, 
    0.05771408f, 0.15758500f, 0.03897919f, 0.21144359f, -0.04493717f, 0.03791057f, 0.04562860f, 0.02960350f, 
    -0.07207336f, 0.02452365f, 0.12330867f, 0.14894524f, -0.07999965f, 0.08222374f, 0.01290379f, -0.06909119f, 
    0.01677681f, 0.03780589f, 0.02681464f, 0.05987486f, 0.12683196f, 0.02005108f, 0.14052778f, -0.15457304f, 
    0.05647538f, 0.06062378f, 0.02319019f, -0.03299892f, 0.13887328f, -0.02310946f, 0.06646332f, 0.05276973f, 
    0.14670467f, 0.00727950f, 0.02181232f, 0.05387915f, 0.04305956f, -0.03932489f, -0.03799567f, 0.01462730f, 
    -0.07752857f, -0.14681174f, -0.00390040f, 0.04167975f, 0.02838246f, -0.08966973f, 0.04405607f, -0.06544284f, 
    0.15727271f, 0.04598408f, -0.05976426f, -0.15693162f, -0.01897423f, 0.06676227f, -0.03515214f, 0.07030170f, 
    -0.02185685f, -0.06268739f, 0.02711373f, 0.03657527f, 0.44088960f, -0.03324502f, 0.03885419f, 0.13724345f, 
    -0.06238770f, -0.03321847f, 0.05550506f, 0.00430139f, 0.16814047f, -0.04849127f, 0.08558790f, 0.03875893f, 
    0.02183751f, 0.02467287f, 0.01307194f, 0.11542454f, -0.02217131f, 0.00371498f, 0.00845096f, -0.00101943f, 
    0.16763571f, 0.15142454f, 0.14636740f, 0.13825653f, 0.13217436f, 0.17369604f, 0.03966187f, 0.05124771f, 
    0.27275175f, -0.13528302f, 0.06158453f, 0.02348698f, 0.07906234f, -0.05036620f, -0.06015427f, -0.04353956f, 
    -0.23241583f, 0.05147924f, -0.01983785f, -0.05785038f, -0.06206949f, -0.02688985f, 0.13138391f, -0.00634444f, 
    -0.09167242f, -0.11735177f, -0.07308953f, -0.18947360f, 0.24343428f, -0.07326045f, 0.01179471f, -0.08738365f, 
    0.08196791f, 0.00243614f, 0.09071527f, 0.06616650f, -0.08292279f, -0.10253397f, 0.01811573f, -0.09511796f, 
    -0.02559733f, 0.11889681f, 0.14439559f, -0.05063860f, 0.07080693f, 0.09476632f, 0.11028195f, 0.02336627f, 
    0.10311032f, 0.08676357f, 0.15564930f, -0.00320177f, 0.11010104f, 0.06669618f, 0.06101507f, -0.08478330f, 
    0.05793495f, 0.06903940f, 0.05384279f, -0.02191618f, -0.09168125f, -0.10060149f, -0.10730720f, -0.07636497f, 
    0.08667462f, 0.00160506f, 0.02962538f, 0.02407949f, -0.02588413f, -0.01685002f, 0.08817803f, 0.07463863f, 
    -0.00937883f, 0.00167381f, -0.01288826f, 0.02271800f, 0.02898072f, -0.12212134f, -0.16610913f, -0.28293067f, 
    -0.06628483f, 0.05233553f, 0.07576179f, 0.08181959f, -0.10934985f, 0.07376602f, -0.04175939f, 0.13126545f, 
    0.51852524f, -0.20542626f, 0.09110727f, 0.04216128f, 0.03491418f, 0.04794480f, 0.12331871f, 0.13855185f, 
    -0.05261612f, -0.02770796f, 0.09980948f, 0.13538930f, -0.52710682f, -0.01022405f, 0.01422312f, -0.08753725f, 
    -0.10827756f, 0.03769618f, -0.02113315f, 0.11313586f, 0.16585943f, 0.01418851f, 0.09713499f, -0.05961420f, 
    -0.00344490f, 0.04895001f, 0.10711156f, 0.08026169f, -0.01067515f, 0.12075408f, -0.00575437f, -0.03831249f, 
    0.08021238f, 0.00770834f, 0.06329849f, 0.24084124f, -0.08542320f, 0.08152536f, 0.11794113f, -0.04133853f, 
    0.19860400f, -0.11000041f, -0.04116255f, 0.02241612f, -0.04806044f, 0.11828860f, 0.03102830f, -0.00387359f, 
    -0.04794532f, 0.11373505f, -0.02833447f, -0.18714526f, 0.05198791f, 0.12452024f, 0.00293482f, 0.07314046f, 
    -0.05692000f, -0.06789032f, 0.00429921f, 0.02275053f, 0.16413502f, 0.00016090f, 0.11155553f, 0.11223016f, 
    -0.01028986f, -0.05089363f, 0.09305049f, 0.01997900f, 0.04965812f, 0.08117833f, -0.03740380f, 0.08031752f, 
    -0.14194928f, -0.03322250f, -0.11418047f, -0.09695855f, -0.10451064f, -0.03591876f, 0.01826535f, 0.00452894f, 
    0.03639359f, -0.03517517f, -0.04274176f, -0.01847971f, 0.14547867f, 0.19435346f, -0.00560187f, -0.13881202f, 
    0.00232789f, 0.03111085f, 0.02718244f, -0.02737743f, -0.10967644f, -0.03089510f, 0.09312170f, -0.10918533f, 
    -0.15905780f, -0.03013326f, 0.10247850f, 0.24744390f, -0.06036034f, 0.15294915f, 0.05773540f, -0.00390375f, 
    0.03728990f, -0.01538053f, -0.12650749f, -0.03054026f, -0.04477199f, -0.00708373f, 0.02032156f, -0.10994250f, 
    -0.14769585f, 0.04990685f, -0.12239319f, 0.03049945f, -0.11393024f, 0.00186257f, 0.01287621f, 0.08202457f, 
    0.14207932f, 0.02665991f, -0.07937690f, -0.04004899f, -0.11893716f, -0.07858235f, 0.05981788f, -0.01714265f, 
    0.10810596f, 0.08276678f, 0.00719910f, 0.04314146f, 0.13686088f, 0.20197538f, 0.13960096f, 0.03707933f, 
    -0.18029141f, -0.00459682f, 0.02830070f, -0.11570457f, 0.06687778f, -0.06692138f, -0.01026732f, 0.02092512f, 
    -0.27807420f, -0.05825954f, -0.12061575f, -0.04243495f, 0.05889631f, 0.19457816f, 0.10281797f, 0.08142721f, 
    -0.16191745f, 0.06469146f, 0.02490353f, -0.05414770f, -0.11353265f, 0.07968383f, -0.06746730f, 0.06004192f, 
    0.02746710f, 0.08442210f, 0.00304838f, 0.02384771f, 0.01397860f, -0.12087297f, 0.08634851f, -0.01331891f, 
    0.07942265f, 0.16296118f, 0.03530338f, 0.05255782f, -0.06265018f, -0.09794337f, -0.06535260f, -0.05171144f, 
    0.04708737f, 0.19905594f, -0.01239169f, 0.02200423f, -0.42383355f, 0.11302683f, -0.15943299f, -0.03871855f, 
    -0.02992549f, 0.03465522f, 0.06976218f, 0.07958367f, -0.07945681f, 0.01539074f, -0.07662718f, 0.14124258f, 
    0.32564953f, -0.05740162f, -0.14027055f, 0.02851772f, -0.05493753f, 0.09933737f, 0.15228790f, 0.08209426f, 
    0.23661764f, 0.07219452f, 0.00730931f, -0.09029791f, 0.16635107f, -0.11533827f, 0.15978114f, -0.01337892f, 
    -0.08256447f, -0.00269697f, 0.01279757f, 0.06177472f, -0.03957842f, -0.06238272f, -0.30781636f, -0.28249243f, 
    0.18102792f, 0.14428766f, 0.13163477f, 0.21378359f, -0.07613780f, -0.03163932f, -0.05945374f, -0.02616516f, 
    -0.03630567f, 0.06728113f, -0.02985915f, -0.04170781f, -0.06414498f, 0.11056295f, -0.06498780f, -0.04206164f, 
    0.11137141f, -0.00769300f, -0.15332611f, -0.09168470f, -0.04462196f, -0.06097880f, -0.12276927f, -0.37543499f, 
    0.02209492f, -0.09012876f, -0.02948381f, 0.12525567f, 0.00469392f, 0.06512757f, 0.07983656f, 0.13184501f, 
    0.09845833f, 0.10985525f, -0.00228730f, 0.11117981f, 0.15851915f, 0.17344865f, 0.14463422f, 0.11005307f, 
    0.08140491f, 0.13950145f, 0.26973093f, 0.25082549f, 0.13821514f, -0.01423084f, 0.11833718f, -0.11093889f, 
    0.11851332f, 0.00219025f, 0.34735620f, 0.03573225f, 0.14610004f, 0.04321068f, 0.12422247f, 0.03925809f, 
    0.09004564f, 0.09040207f, 0.01645840f, -0.05098271f, 0.11969407f, 0.32259154f, -0.20150968f, -0.00879620f, 
    -0.11150550f, 0.07578374f, 0.06129437f, -0.06483801f, 0.09341078f, -0.07403091f, 0.01511906f, -0.06125152f, 
    -0.02002630f, 0.06449805f, 0.00550893f, 0.02672959f, -0.06294987f, -0.05184473f, -0.09006785f, -0.05303969f, 
    0.05727660f, 0.17827651f, 0.03728527f, 0.06511801f, 0.04694133f, 0.34211251f, -0.02243366f, -0.13392827f, 
    0.02784680f, -0.10472748f, -0.01711783f, -0.03528666f, 0.02605994f, 0.08655285f, -0.02949821f, -0.02905052f, 
    -0.12134117f, 0.06406440f, 0.08488945f, -0.06258468f, 0.01987053f, -0.00840800f, 0.09561072f, 0.02489814f, 
    -0.06859236f, 0.02540278f, 0.00000756f, -0.09614952f, -0.10665453f, -0.27934754f, -0.00058302f, 0.02063739f, 
    0.04650924f, -0.04903031f, -0.06143712f, 0.10429210f, -0.05453030f, -0.18947695f, -0.01794431f, -0.11460036f, 
    -0.37046573f, 0.15732571f, -0.04681366f, 0.03929986f, -0.08081028f, 0.09311770f, 0.16400312f, 0.11025702f, 
    -0.05931414f, 0.00029636f, -0.02892295f, 0.01430680f, -0.07888233f, 0.03998449f, 0.02046456f, 0.01717009f, 
    -0.20309819f, -0.14548957f, 0.06901584f, -0.10925780f, -0.08381810f, -0.01278396f, -0.03784215f, -0.03508257f, 
    0.20159933f, 0.09001179f, 0.17570557f, 0.03150694f, -0.03369934f, -0.10504834f, 0.03458843f, -0.01815386f, 
    -0.03082813f, -0.05667501f, -0.02110077f, 0.07934850f, -0.00227415f, -0.21079761f, -0.12207249f, -0.13122416f, 
    0.00102783f, -0.04941974f, 0.02256914f, -0.03244578f, -0.01864935f, -0.06333432f, -0.10064180f, 0.07274471f, 
    0.61131036f, 0.11407401f, 0.19988629f, 0.06032190f, -0.08226139f, 0.03321953f, -0.16304711f, 0.04072327f, 
    0.05437088f, 0.02696840f, 0.14671849f, 0.06302895f, -0.08383607f, 0.02043258f, -0.15511404f, -0.08895021f, 
    -0.16867414f, -0.00087614f, -0.10002665f, -0.03264843f, -0.01727165f, 0.01416710f, -0.00625890f, -0.06053250f, 
    0.26706329f, 0.04238721f, 0.11435162f, 0.17127132f, -0.16627640f, 0.13891089f, -0.05932068f, 0.07447243f, 
    -0.05174861f, -0.03294709f, 0.09770755f, 0.20625061f, -0.01732089f, 0.01047435f, 0.03163744f, 0.05040256f, 
    -0.05451344f, -0.04670027f, 0.08580352f, -0.04641673f, -0.07519834f, 0.14229187f, -0.03685533f, 0.14359052f, 
    0.04413566f, -0.03153000f, 0.23203790f, 0.10440613f, 0.11475019f, 0.02724227f, -0.06543280f, 0.12262966f, 
    -0.12438782f, 0.01334605f, -0.03828150f, 0.06304673f, 0.30145216f, 0.04760583f, 0.21036239f, 0.21705574f, 
    -0.08307479f, -0.01958555f, 0.02073706f, -0.14250037f, 0.09421575f, 0.04553019f, -0.05257917f, 0.05311495f, 
    0.08093657f, 0.00330009f, -0.07140840f, -0.13509963f, -0.01496906f, -0.06949389f, -0.01332134f, -0.03800749f, 
    -0.11415809f, 0.09078450f, 0.14882922f, -0.01782927f, 0.24472325f, 0.09565716f, -0.01360205f, -0.04707350f, 
    0.01655867f, -0.01664195f, 0.07140168f, 0.18031587f, -0.07663749f, 0.03176230f, 0.03681828f, -0.15741916f, 
    0.17205557f, 0.26905596f, 0.34024161f, 0.22444706f, -0.00978321f, 0.04018366f, 0.09758380f, 0.20202760f, 
    0.03795589f, 0.02314546f, -0.00077418f, 0.02910015f, 0.07974208f, 0.13942948f, 0.19143440f, 0.09175107f, 
    0.06306526f, 0.16610001f, 0.06815970f, 0.18769783f, -0.03838188f, 0.01639972f, -0.10424793f, -0.18173693f, 
    0.16137956f, 0.02338363f, 0.07491230f, 0.07171357f, 0.08854315f, 0.17030983f, -0.08193143f, 0.02741574f, 
    -0.03695010f, -0.06918519f, -0.02759852f, -0.08544976f, -0.35355681f, -0.31439337f, -0.23994780f, -0.09471552f, 
    0.01843576f, -0.05385520f, -0.02013185f, -0.02693829f, 0.06523304f, 0.08197536f, -0.03280294f, 0.10902879f, 
    0.03875423f, 0.10416723f, 0.08840803f, 0.09343807f, -0.08636656f, -0.04086305f, -0.05218548f, -0.08521613f, 
    -0.02455408f, -0.03472653f, 0.02310857f, 0.02473950f, 0.23167314f, 0.10029279f, 0.26951927f, -0.07572578f, 
    0.04935464f, 0.04772662f, 0.03019300f, 0.11530929f, -0.02848562f, -0.02180620f, -0.07844113f, -0.02648703f, 
    0.07369246f, -0.14355107f, -0.16001733f, -0.15159625f, 0.04021710f, 0.05237053f, 0.07716358f, 0.06082068f, 
    0.06134618f, 0.05105910f, 0.04836835f, -0.06370889f, -0.18735421f, 0.22704051f, 0.39157650f, -0.01156101f, 
    0.04929585f, 0.28450295f, 0.09765752f, 0.10291494f, -0.05883059f, -0.08427840f, -0.09486027f, -0.08162018f, 
    0.01965982f, -0.04671906f, 0.06081050f, -0.09790376f, 0.10271981f, 0.05493282f, -0.02955000f, 0.01264037f, 
    -0.11438261f, 0.00277030f, 0.06247158f, 0.04604423f, -0.27973896f, -0.16392660f, 0.02219737f, 0.12601703f, 
    0.03688449f, -0.04101637f, -0.00304951f, -0.08478627f, 0.10214401f, -0.09677362f, 0.06992997f, 0.09048308f, 
    -0.20349558f, -0.21827631f, -0.22373691f, -0.12781398f, 0.02625233f, -0.06902625f, 0.08993860f, -0.06328214f, 
    -0.05969497f, -0.03579344f, -0.11100614f, 0.09857143f, -0.06845278f, 0.14988925f, 0.11697705f, 0.06069114f, 
    0.06779376f, 0.03718436f, 0.01940615f, 0.03391871f, 0.02510129f, 0.02750803f, 0.08947873f, 0.15835711f, 
    0.09544202f, 0.08252008f, 0.15295455f, 0.10634335f, -0.02473312f, -0.00792169f, -0.00392173f, 0.08167262f, 
    -0.00677308f, 0.02645186f, -0.03380257f, 0.05879906f, 0.14126080f, -0.00650107f, 0.24019860f, 0.22133398f, 
    0.04052848f, 0.08046625f, 0.05002393f, -0.02642989f, 0.07910705f, -0.06284530f, -0.01396158f, -0.09482610f, 
    0.09360037f, 0.17921619f, 0.16050245f, 0.01554377f, -0.03571546f, -0.04599038f, 0.08444998f, 0.04106863f, 
    -0.00343287f, -0.00259180f, -0.02756838f, -0.01360182f, 0.05852677f, -0.07231337f, -0.16555582f, -0.10116912f, 
    -0.16040780f, 0.01072422f, -0.04980414f, -0.01543733f, -0.03883168f, -0.04749483f, -0.26402014f, -0.02135087f, 
    -0.26465034f, -0.32325369f, -0.17885788f, -0.13734147f, -0.04914752f, 0.01182101f, -0.03394394f, -0.02729905f, 
    0.09525627f, 0.00065415f, -0.01950030f, 0.11920700f, 0.12266841f, 0.10298154f, -0.11593473f, 0.04128788f, 
    0.01873497f, -0.03177925f, -0.09269436f, -0.06932332f, 0.11862672f, 0.02110925f, -0.08731306f, -0.06188504f, 
    -0.00819084f, 0.13654676f, 0.09469409f, -0.09613843f, 0.06168951f, 0.03228491f, 0.05441147f, 0.00105315f, 
    0.04726579f, -0.06515678f, 0.04938377f, -0.05179147f, 0.16933964f, -0.09277955f, 0.30353895f, 0.25011685f, 
    -0.11188646f, -0.05123513f, -0.03447317f, -0.00868175f, -0.01379454f, -0.03400200f, 0.00364013f, -0.02867304f, 
    -0.00394493f, 0.12301285f, 0.18330108f, 0.15602735f, -0.03133726f, 0.12969317f, 0.03385685f, -0.15061606f, 
    0.01673557f, -0.09147680f, 0.20028035f, 0.06291052f, 0.19532491f, 0.20585452f, -0.00498692f, -0.12553175f, 
    -0.10990381f, -0.10447452f, -0.09950355f, -0.02812401f, 0.07370405f, 0.05196039f, 0.07361904f, 0.00558116f, 
    0.05523436f, -0.22870027f, -0.30951098f, -0.12467390f, 0.02311197f, -0.06017136f, 0.00487947f, -0.09211022f, 
    0.09878956f, 0.12429528f, 0.01770843f, 0.02647752f, 0.10348355f, 0.08486965f, -0.06029891f, -0.10811942f, 
    0.05550834f, -0.03121190f, 0.00139247f, 0.07733937f, -0.01255012f, -0.01791614f, -0.00428664f, 0.05139782f, 
    0.05699508f, -0.57420576f, -0.13368313f, -0.45093271f, -0.07242749f, -0.05572465f, 0.00529755f, 0.00694902f, 
    0.01429401f, 0.04090646f, 0.07496412f, 0.09579576f, -0.11493152f, 0.18639085f, 0.07740145f, -0.05781252f, 
    -0.07147947f, 0.03828293f, 0.02862635f, 0.14047608f, 0.09962019f, 0.11300360f, 0.06501409f, 0.04697300f, 
    -0.19218977f, -0.21439810f, -0.08156096f, -0.11807751f, 0.03499766f, -0.08310267f, -0.06073473f, -0.00766419f, 
    0.08772340f, -0.02122633f, -0.06374434f, 0.04945596f, 0.02251087f, -0.01683101f, 0.03270455f, 0.07268633f, 
    0.18062286f, -0.07045250f, -0.03541369f, -0.00246276f, 0.01085552f, -0.06527541f, 0.00499732f, -0.11293418f, 
    0.07264992f, 0.07747451f, 0.03792026f, 0.10196767f, 0.05453065f, 0.05724761f, -0.00787016f, 0.08493972f, 
    0.03808263f, 0.02135425f, 0.06292763f, -0.01805806f, -0.15784752f, -0.26597336f, -0.23562771f, -0.07791618f, 
    0.01860366f, -0.01975225f, 0.09943076f, -0.09823126f, 0.03325380f, -0.00358130f, 0.01796315f, -0.02220290f, 
    0.17600632f, 0.22789834f, -0.00168458f, 0.00299299f, -0.02062737f, 0.02347985f, 0.17862123f, -0.03916094f, 
    0.11366574f, -0.06303595f, 0.00971551f, 0.00948731f, 0.26359805f, 0.10390822f, -0.00104430f, 0.13705346f, 
    0.00288082f, 0.04313763f, 0.01010496f, 0.01865372f, 0.03538096f, -0.01881644f, 0.07075212f, 0.11996326f, 
    0.00106866f, -0.01051504f, -0.04945984f, -0.05406600f, -0.03043893f, -0.02223608f, -0.04965615f, -0.04190349f, 
    -0.07668941f, -0.02093303f, -0.02539891f, -0.05570067f, -0.03437962f, -0.06606577f, -0.02179324f, -0.03897056f, 
    0.00411925f, -0.06998555f, -0.04106242f, -0.01851768f, -0.08068845f, -0.02936183f, 0.00936838f, -0.07370782f, 
    -0.01695052f, -0.00007839f, 0.03440678f, -0.05038072f, -0.03553329f, -0.06401297f, -0.01292698f, -0.00015644f, 
    -0.06578586f, -0.03508789f, 0.01203166f, 0.01074027f, 0.00285818f, -0.03284015f, 0.02406095f, -0.06172144f, 
    -0.05578096f, -0.05437139f, -0.06398806f, -0.01310565f, -0.00844110f, -0.01585431f, -0.02566348f, 0.01721274f, 
    -0.00572425f, -0.04996675f, -0.00284633f, 0.02222265f, -0.08315159f, 0.00535852f, 0.00608665f, -0.00441675f, 
    -0.00129023f, 0.00322600f, -0.05473961f, -0.05079995f, -0.07499297f, -0.07104827f, -0.04991101f, -0.08205765f, 
    -0.04604185f, -0.05459082f, -0.01304975f, -0.02180799f, -0.01042122f, -0.03794704f, -0.06488986f, -0.06687943f, 
    0.02134416f, 0.05090885f, 0.02911222f, -0.02537370f, 0.01692031f, 0.00932853f, -0.05978614f, 0.02136406f, 
    -0.04264671f, -0.01829471f, 0.00556385f, 0.00255528f, -0.05617997f, -0.00151654f, -0.05049029f, -0.03133561f, 
    0.01557203f, -0.01836765f, 0.00942669f, 0.03344469f, -0.00874735f, -0.01664162f, -0.07462342f, -0.00016318f, 
    -0.00525911f, 0.01490388f, -0.03960107f, 0.01996215f, -0.02111688f, -0.01715696f, 0.01346750f, -0.03502516f, 
    -0.02715287f, -0.08221027f, -0.03815590f, -0.01644430f, -0.05036309f, 0.00066340f, -0.00347157f, -0.00002468f, 
    0.00049865f, -0.04144945f, 0.00400330f, -0.02687977f, -0.04204891f, 0.00163427f, -0.00470476f, 0.03482802f, 
    0.07245518f, -0.00447101f, -0.02090826f, -0.03148554f, 0.00564664f, 0.00159439f, -0.00395024f, 0.00070561f, 
    -0.00050576f, 0.00597017f, 0.01324379f, -0.01565591f, -0.07261883f, 0.01048562f, -0.08047586f, -0.04237214f, 
    -0.01909458f, -0.00362764f, 0.01893278f, -0.04547904f, -0.00181885f, -0.01246681f, -0.00179014f, -0.03605644f, 
    -0.02715883f, 0.00102436f, 0.03679674f, 0.01142204f, 0.02885696f, -0.02897181f, 0.00165154f, 0.02548543f, 
    -0.06785781f, -0.06306256f, -0.06025646f, -0.00523153f, 0.00342804f, -0.02986952f, 0.04519339f, -0.03400234f, 
    -0.03436841f, -0.08199516f, -0.02567077f, 0.02120836f, -0.08268916f, -0.03865757f, -0.05778261f, -0.08403511f, 
    0.01600586f, 0.04575035f, 0.00232097f, 0.00010786f, -0.08303811f, -0.04254030f, -0.05511561f, -0.00286106f, 
    -0.06193586f, -0.03490848f, -0.04371025f, -0.03543479f, -0.05196645f, -0.04635454f, -0.05824955f, -0.06467685f, 
    0.01662842f, -0.06550157f, -0.03348777f, 0.02521306f, -0.05734350f, -0.03686180f, 0.03252538f, 0.05198844f, 
    0.02001158f, -0.01749188f, -0.00608829f, -0.05739105f, -0.03621408f, -0.00206592f, -0.01213858f, 0.01860230f, 
    -0.06771290f, -0.02158254f, 0.06050967f, 0.02970865f, -0.04523314f, 0.00749544f, -0.01558775f, -0.04052094f, 
    -0.09358111f, -0.05405151f, -0.05611515f, -0.05659067f, -0.00037812f, 0.00279390f, -0.03478465f, -0.01793399f, 
    -0.03865629f, -0.00713319f, -0.01970563f, -0.03179282f, -0.01895343f, -0.04793283f, -0.03821012f, -0.04832810f, 
    0.00458937f, -0.00050131f, -0.04111627f, -0.06038508f, -0.00970493f, -0.03349405f, -0.06178112f, -0.05652807f, 
    -0.06148248f, -0.03114711f, -0.03904209f, -0.01820772f, 0.01454080f, -0.03148451f, -0.04439226f, -0.06216428f, 
    -0.04509004f, -0.00511349f, -0.01190663f, -0.01164278f, -0.09354018f, -0.02303813f, -0.05056188f, -0.07780802f, 
    -0.03244967f, -0.07292374f, -0.08270010f, 0.00521228f, -0.06267177f, -0.02462641f, -0.05730662f, -0.04285093f, 
    -0.05108901f, -0.00619609f, -0.04791097f, -0.03376571f, -0.02431409f, -0.01642156f, -0.00784035f, 0.03700098f, 
    -0.03796545f, -0.04695960f, 0.00762282f, 0.00099179f, -0.03200319f, -0.03448109f, 0.02759718f, -0.05468723f, 
    -0.01571215f, 0.00160769f, -0.07313285f, -0.04712327f, -0.02623133f, 0.02573812f, -0.07026101f, -0.02485088f, 
    -0.03814460f, -0.01160740f, -0.02576361f, -0.03597749f, -0.04523045f, -0.04144760f, -0.07279589f, -0.05478973f, 
    -0.00430251f, 0.00517552f, -0.06874572f, 0.01298509f, 0.01715594f, -0.02768241f, 0.02991365f, -0.01735010f, 
    -0.05932213f, -0.00603078f, -0.05978425f, 0.01038477f, 0.01604241f, -0.02209585f, -0.02998788f, -0.04503753f, 
    -0.06184879f, 0.02377158f, -0.06886306f, -0.04274187f, 0.00160405f, -0.03261440f, 0.00157151f, 0.01500270f, 
    -0.00044981f, 0.03047350f, 0.02650991f, 0.01387146f, -0.01453085f, 0.01198253f, -0.00457653f, -0.06875065f, 
    -0.00507792f, -0.01369577f, -0.02724420f, -0.06118416f, -0.00008442f, -0.02423927f, 0.00196757f, 0.00486122f, 
    -0.01758565f, -0.03276496f, -0.07891830f, -0.07093545f, 0.01166404f, 0.00382243f, -0.02555871f, -0.05203969f, 
    -0.01191735f, -0.02081370f, -0.03249076f, 0.00766163f, 0.00820398f, -0.03445781f, -0.03113376f, -0.00362781f, 
    -0.01805346f, -0.01600622f, -0.02590093f, -0.03346666f, -0.00843470f, 0.04709901f, -0.01871205f, -0.03881948f, 
    -0.05005794f, -0.00118054f, -0.03877541f, -0.00920816f, -0.02413343f, 0.00310018f, -0.05495239f, -0.03767454f, 
    -0.01804264f, -0.01329000f, -0.01793426f, 0.02064163f, -0.01534648f, -0.01234768f, -0.03859910f, -0.01281717f, 
    -0.04172976f, -0.07254700f, -0.02215792f, -0.02938398f, -0.03123842f, -0.07519310f, -0.06965326f, -0.02007359f, 
    -0.06330897f, -0.01360857f, -0.00148606f, -0.04731587f, -0.01284310f, -0.01548674f, -0.03567593f, 0.03489581f, 
    0.08051544f, 0.10213740f, 0.26399535f, 0.15324077f, -0.01024795f, 0.16571648f, -0.03174872f, 0.01083607f, 
    0.06718060f, -0.10764236f, 0.05473480f, 0.01220690f, -0.10175209f, 0.07248072f, -0.13698579f, 0.15774602f, 
    0.11605366f, 0.06146668f, 0.12363087f, 0.02270383f, -0.01187032f, -0.02955734f, -0.17753103f, -0.03685100f, 
    0.11243454f, 0.08973768f, -0.04071641f, 0.17489837f, -0.15803908f, 0.19560663f, -0.04166647f, 0.00653167f, 
    0.08154856f, -0.07146167f, -0.05135584f, 0.00321392f, -0.03282335f, -0.26576075f, 0.03975879f, 0.03633025f, 
    -0.01575653f, -0.00367495f, 0.04193251f, 0.00352651f, 0.14554258f, 0.07134333f, -0.03817349f, 0.00342170f, 
    -0.10323524f, 0.02677458f, -0.05857367f, 0.07554114f, -0.06673335f, 0.01349116f, 0.08969711f, -0.00648219f, 
    -0.06602586f, -0.06526721f, -0.12565388f, 0.09697141f, 0.02883818f, 0.14608186f, 0.11827229f, 0.05736607f, 
    -0.05780865f, 0.17028445f, 0.04855908f, 0.06360903f, -0.06000590f, -0.11047299f, 0.00372632f, -0.02304524f, 
    -0.05078946f, -0.02854287f, -0.23167691f, 0.10713581f, -0.00425983f, 0.01391391f, -0.05023498f, -0.05270068f, 
    -0.09487188f, -0.06782079f, 0.08458611f, 0.03370695f, -0.38481724f, 0.15058541f, -0.03488674f, -0.08108734f, 
    -0.08118241f, 0.03558095f, 0.07292552f, 0.03598433f, -0.17122544f, 0.03363141f, -0.12533620f, -0.13885213f, 
    0.13663991f, 0.21672650f, -0.01405750f, 0.04396400f, 0.03877826f, 0.06351387f, -0.17874773f, 0.03501125f, 
    0.01385541f, 0.06025512f, 0.02222452f, 0.05340678f, 0.24153431f, -0.10496715f, 0.14033943f, -0.12000754f, 
    0.03664371f, -0.07288046f, -0.01956548f, -0.14694813f, 0.07094972f, 0.05425809f, 0.03930496f, 0.14550433f, 
    -0.18700013f, 0.11065501f, -0.24148303f, 0.17368606f, 0.14631876f, -0.05311973f, 0.05574374f, -0.06018394f, 
    -0.02906918f, 0.04013123f, 0.02982518f, 0.09998838f, 0.09175536f, 0.14162569f, -0.02113730f, 0.02160043f, 
    -0.02330935f, 0.03452455f, 0.06691976f, 0.13422482f, 0.11483932f, 0.10236695f, -0.02071341f, 0.17520972f, 
    -0.11958111f, -0.06935436f, -0.06395894f, 0.04247284f, 0.06585272f, 0.14056119f, 0.11456079f, 0.05486979f, 
    -0.01868715f, 0.10894022f, 0.11980538f, 0.10357216f, -0.14269121f, 0.22083224f, -0.07539443f, 0.35694161f, 
    0.08822390f, 0.11778988f, 0.08548453f, -0.13569450f, -0.12944990f, -0.03085140f, 0.01639857f, 0.09805501f, 
    -0.00223882f, 0.26546609f, 0.04473145f, 0.22440951f, 0.01364704f, 0.05470591f, 0.00529308f, 0.02953960f, 
    -0.11626992f, 0.12182888f, -0.04808854f, -0.04808877f, -0.38411656f, 0.43853956f, -0.03724925f, 0.14792010f, 
    -0.01499516f, -0.03065513f, -0.08228626f, 0.10550309f, 0.08619139f, 0.07890670f, -0.11718415f, 0.03111276f, 
    -0.09421550f, -0.05268635f, -0.26761907f, 0.11819567f, -0.07297072f, 0.03384756f, -0.00494025f, -0.03497462f, 
    0.05939202f, 0.07758230f, 0.17132607f, 0.12727931f, 0.35647574f, -0.07850632f, -0.18157616f, 0.08974589f, 
    -0.08957773f, -0.05664477f, 0.04724216f, 0.07796186f, -0.03045156f, 0.02899511f, -0.13155769f, -0.09398790f, 
    0.13650537f, 0.13441469f, 0.22862820f, 0.10275220f, 0.23422028f, -0.15921742f, 0.02749005f, -0.06521995f, 
    0.00910521f, 0.06739391f, -0.06418473f, -0.03541381f, -0.22519594f, -0.06139421f, 0.11646664f, 0.24024591f, 
    -0.01349003f, 0.12776054f, 0.16291440f, -0.04539134f, -0.13075866f, 0.02841000f, 0.02627073f, -0.01127518f, 
    -0.04514055f, 0.10550579f, 0.03449389f, 0.05777692f, 0.10336782f, 0.03703664f, 0.02088447f, 0.13189620f, 
    -0.05634192f, 0.03151621f, 0.09183659f, 0.12221533f, 0.11714401f, -0.02181698f, 0.19174801f, -0.02598300f, 
    -0.09807745f, 0.17332900f, -0.03988163f, 0.08005812f, 0.01163126f, -0.01019883f, 0.01376880f, -0.04591492f, 
    0.15510863f, -0.07490161f, -0.03447304f, -0.02898735f, -0.10399284f, 0.00996882f, -0.03757321f, -0.02153721f, 
    0.03211043f, 0.03190496f, -0.00436894f, -0.00324166f, 0.07436141f, 0.05090654f, 0.01429567f, 0.20488046f, 
    0.06061132f, 0.16528979f, 0.02715071f, -0.00066001f, -0.01836525f, -0.09863947f, -0.05870885f, 0.01576238f, 
    -0.41769013f, 0.28016827f, -0.04381683f, 0.17771727f, 0.06437407f, -0.05226755f, -0.08487874f, 0.22617710f, 
    0.03785422f, -0.06693090f, 0.01973538f, 0.09087196f, -0.24961315f, 0.08598160f, 0.13735189f, 0.05968626f, 
    0.05946944f, -0.04263770f, -0.05710236f, 0.09758726f, -0.02467326f, 0.00036775f, 0.04266886f, -0.01452620f, 
    0.08379096f, -0.21811074f, 0.00348655f, -0.12666397f, 0.05988056f, 0.04036926f, 0.06132190f, 0.13298649f, 
    0.05111043f, 0.02475292f, -0.01818992f, -0.03875758f, 0.35573399f, -0.04368271f, 0.01637032f, -0.17657147f, 
    0.01366833f, 0.08151389f, -0.07374313f, 0.03992472f, -0.10498278f, 0.01586187f, -0.07393347f, -0.18412614f, 
    -0.06538751f, -0.00162420f, 0.04276732f, 0.18627615f, -0.02245708f, -0.06433942f, 0.05361487f, 0.12098759f, 
    0.03661656f, 0.05015995f, 0.02611320f, 0.06889014f, -0.01905733f, -0.19691366f, 0.09103036f, -0.09867719f, 
    -0.03661573f, -0.03180499f, 0.01882270f, -0.06059250f, 0.01773392f, 0.09314367f, 0.01728393f, -0.02730197f, 
    0.16083331f, 0.37056306f, 0.18178262f, 0.28272012f, 0.12590075f, -0.14431800f, 0.17139345f, -0.06944273f, 
    0.03463883f, 0.03641178f, -0.06741402f, 0.02570251f, -0.10562474f, 0.24218957f, 0.16412009f, 0.13563305f, 
    0.05288562f, -0.02824460f, -0.03469128f, 0.14342254f, 0.05560697f, 0.18145151f, 0.06368438f, 0.18216245f, 
    0.00915162f, -0.02784981f, -0.02824125f, -0.02556637f, -0.05510407f, -0.04228502f, -0.03070202f, 0.00557521f, 
    0.03708084f, -0.04850983f, -0.03639846f, -0.03766643f, 0.04032187f, -0.05708545f, -0.00729344f, -0.04799719f, 
    -0.02621516f, 0.03324458f, 0.00262883f, -0.00121363f, -0.02288322f, -0.00124528f, 0.01837335f, 0.03662549f, 
    -0.01085107f, -0.02562967f, -0.00886031f, 0.01111403f, -0.02773086f, 0.03216986f, -0.03779734f, 0.04501632f, 
    -0.00135246f, 0.00072084f, 0.01012772f, -0.01889487f, 0.00356401f, -0.02281768f, 0.04122045f, 0.02111482f, 
    0.01467926f, 0.01024285f, -0.03210361f, 0.02015000f, -0.04443189f, -0.03145402f, 0.03218452f, -0.02718616f, 
    -0.02203952f, -0.00594775f, -0.02888151f, -0.03847712f, 0.03445660f, 0.02606505f, 0.00759329f, 0.02194140f, 
    -0.03677293f, -0.04583795f, 0.01267848f, 0.02932316f, 0.03803198f, -0.01450603f, -0.05088183f, 0.03864423f, 
    0.01481499f, 0.03567605f, -0.04511021f, 0.00342946f, -0.03639292f, -0.00630053f, 0.02692541f, 0.01997141f, 
    -0.03104632f, -0.01223095f, -0.02572580f, -0.02060587f, -0.01008695f, -0.04178264f, -0.03090619f, -0.00397340f, 
    -0.02665830f, -0.03058806f, 0.02348984f, -0.02580943f, -0.03930116f, 0.02144255f, -0.00043677f, -0.02625409f, 
    -0.04467503f, -0.03568925f, -0.03190768f, -0.00321741f, 0.05374430f, -0.05303279f, 0.02483213f, 0.00256927f, 
    -0.02082090f, -0.01808000f, -0.02669859f, -0.00913199f, -0.02464125f, 0.03896506f, -0.00212537f, 0.04767444f, 
    -0.00940471f, 0.03993750f, 0.03569960f, 0.03418157f, -0.00217461f, -0.03336890f, 0.01531389f, -0.03140050f, 
    0.03119427f, -0.05577393f, 0.03962405f, 0.05437881f, 0.01455224f, -0.05566478f, -0.01638164f, -0.03399455f, 
    -0.03523717f, 0.02624281f, 0.05180560f, -0.04236856f, -0.02009424f, -0.00590988f, -0.05290506f, 0.00000765f, 
    0.01434106f, 0.01935481f, -0.04270366f, 0.04845481f, 0.00377664f, -0.01086953f, -0.01451798f, -0.03215884f, 
    0.01920250f, 0.04065501f, -0.03503468f, -0.02178339f, -0.01163881f, 0.02191655f, 0.00554531f, 0.00518903f, 
    -0.05539234f, 0.00969178f, -0.01361104f, 0.03858668f, 0.03684353f, 0.03992570f, -0.01190939f, -0.01826813f, 
    0.01743306f, -0.05135588f, 0.04063544f, -0.00736606f, -0.01294913f, 0.02581969f, -0.04357864f, -0.01392948f, 
    -0.00992886f, 0.02959531f, -0.03892148f, 0.02673042f, -0.04889071f, 0.01627146f, -0.03593250f, -0.01760679f, 
    -0.01082158f, -0.04861483f, -0.03411596f, -0.00926957f, -0.01626177f, -0.01224444f, 0.02977004f, 0.01551862f, 
    -0.04280910f, 0.02866161f, 0.00108497f, -0.00032261f, -0.03913330f, 0.03022640f, 0.01117890f, -0.05637531f, 
    -0.02671825f, -0.00632461f, -0.01948503f, -0.00748231f, 0.02599298f, -0.01832786f, -0.04704705f, -0.05355632f, 
    0.01685210f, 0.02080339f, -0.01747371f, -0.02769126f, 0.02453450f, 0.02510898f, -0.04128085f, 0.00671013f, 
    -0.04161815f, 0.01622934f, -0.03883332f, 0.01418823f, 0.00135180f, -0.01957807f, -0.04849176f, -0.02783537f, 
    0.03337456f, -0.02576501f, 0.00082691f, -0.00090715f, -0.00414250f, 0.01693725f, -0.02534873f, 0.01973504f, 
    0.01236663f, 0.02415726f, 0.03100394f, -0.00282724f, -0.03831010f, -0.01073760f, -0.01192771f, -0.05743605f, 
    0.00397301f, 0.02972233f, -0.00775309f, 0.01811386f, 0.01152270f, -0.04019013f, 0.01932002f, -0.01021615f, 
    -0.05692177f, -0.02428377f, -0.02520199f, -0.01079319f, -0.03916280f, -0.01135004f, -0.04162761f, -0.03448698f, 
    0.02358592f, 0.01707355f, -0.05186839f, -0.00993138f, 0.02507610f, 0.03324819f, 0.01713506f, -0.00733825f, 
    0.00962904f, 0.04047782f, -0.02659682f, 0.01897353f, -0.05470622f, 0.01311355f, 0.00009462f, 0.01180571f, 
    0.03316019f, -0.00537377f, -0.05761285f, 0.04092813f, 0.02490764f, 0.02256871f, -0.04396571f, -0.05559524f, 
    -0.04033652f, -0.02760103f, 0.02410630f, -0.03230151f, 0.00578260f, -0.02966682f, -0.01919530f, -0.00681743f, 
    -0.03113028f, 0.03737833f, 0.03666403f, 0.00720416f, -0.01339967f, 0.01993871f, -0.01094046f, -0.03061695f, 
    -0.00581780f, -0.05033517f, -0.03054173f, 0.00856507f, -0.04264248f, 0.01410384f, -0.02724165f, 0.01244093f, 
    0.00174571f, 0.03442083f, 0.02980739f, -0.03948959f, 0.03930523f, -0.00133946f, -0.04116713f, -0.04054153f, 
    -0.04658734f, 0.00054633f, 0.04018537f, -0.01513756f, -0.05124229f, -0.03433250f, -0.04641271f, 0.00585761f, 
    0.03637823f, -0.03159555f, 0.00205201f, 0.02490376f, -0.03895937f, -0.05215390f, -0.05239796f, -0.02640974f, 
    0.00450824f, -0.05917295f, -0.02199100f, 0.03206947f, -0.01196482f, 0.03754431f, -0.04914977f, 0.01669057f, 
    -0.00348288f, -0.05011836f, 0.00845959f, 0.01109602f, 0.03387583f, -0.00036471f, -0.01476399f, -0.02857751f, 
    0.02800404f, 0.03276181f, 0.01772710f, 0.00196881f, 0.02711600f, 0.00936223f, -0.01315251f, 0.03645192f, 
    0.02467965f, 0.00585679f, 0.01903927f, -0.02787433f, 0.03467948f, -0.03988638f, 0.01745314f, -0.00453110f, 
    -0.04704614f, -0.00041016f, -0.02572874f, -0.00932247f, 0.03264834f, -0.02500475f, 0.02748200f, -0.03876740f, 
    0.01363226f, -0.03495448f, -0.00045678f, -0.04164835f, -0.05882000f, 0.03802067f, 0.04554441f, -0.02042313f, 
    0.01207337f, 0.04318395f, 0.00393856f, -0.00394398f, -0.05781529f, 0.02703121f, -0.01786634f, -0.01962774f, 
    0.00302320f, 0.00423669f, -0.02245650f, 0.01573899f, -0.03932235f, 0.00338642f, -0.05552627f, -0.03456311f, 
    0.03512150f, -0.03511792f, -0.02840880f, -0.00537793f, -0.01676282f, -0.02014088f, 0.03189585f, 0.03103113f, 
    0.04584581f, -0.12893969f, -0.18899390f, -0.07883514f, 0.14473489f, 0.08236435f, 0.12678315f, 0.06257015f, 
    -0.10335122f, -0.00986441f, 0.05079881f, -0.05415570f, 0.03719327f, 0.13879803f, -0.02656939f, 0.24187467f, 
    -0.00934226f, -0.17008936f, 0.11707437f, -0.05113098f, 0.08609927f, 0.02850209f, 0.01574223f, -0.04362759f, 
    -0.34764710f, -0.07460561f, 0.04986127f, -0.01848173f, -0.08060510f, 0.12726885f, -0.10654611f, -0.20376483f, 
    0.06189876f, 0.05355355f, 0.18799946f, 0.01303949f, 0.06611109f, 0.01300446f, 0.02595658f, -0.04547464f, 
    0.14272277f, -0.33749548f, -0.26406831f, -0.11404535f, -0.08388913f, -0.04992524f, 0.19876140f, 0.03927627f, 
    0.17563118f, 0.04573787f, 0.24787647f, 0.20563921f, 0.08451252f, 0.02173966f, -0.08303430f, 0.06057347f, 
    0.15772913f, -0.13154998f, 0.04201688f, 0.09167577f, 0.05560181f, 0.16231570f, 0.05646265f, 0.13137168f, 
    0.06945504f, 0.05696101f, -0.01313212f, 0.06934138f, -0.16000451f, 0.12355965f, 0.09720747f, 0.04965119f, 
    -0.33747175f, -0.24918586f, -0.06066981f, -0.04350676f, -0.26639959f, -0.12299765f, -0.27701977f, -0.18375285f, 
    -0.06027057f, -0.22855701f, -0.07071842f, 0.10380017f, 0.58483052f, -0.20894046f, 0.01435320f, 0.09506718f, 
    0.05301036f, -0.12197196f, -0.01159381f, 0.01167610f, 0.07914840f, 0.00780663f, 0.14924932f, -0.16286191f, 
    -0.46724567f, 0.01540575f, 0.18890570f, 0.00837771f, -0.03334631f, 0.00943942f, 0.02699339f, -0.00478880f, 
    0.02018660f, 0.11808269f, -0.02905077f, 0.19230136f, 0.10697830f, 0.15360145f, 0.00315038f, 0.06139069f, 
    -0.00613576f, 0.08090803f, -0.12356769f, -0.08005462f, -0.05435972f, 0.06035889f, 0.10972700f, -0.00751506f, 
    -0.18642615f, 0.05024108f, -0.07939841f, -0.31589153f, -0.17914711f, -0.06615730f, -0.13059920f, 0.02238747f, 
    0.05615156f, 0.07919417f, 0.04551964f, 0.11232142f, 0.16548280f, -0.14723562f, 0.08762683f, 0.13050808f, 
    0.00576860f, -0.09019069f, 0.22267203f, 0.15179729f, -0.06873012f, -0.07812918f, -0.01609524f, 0.02335345f, 
    -0.04865197f, 0.06605867f, 0.00075701f, -0.07818187f, 0.07404479f, 0.02879209f, 0.02753922f, 0.03414289f, 
    -0.00833398f, -0.03994456f, 0.05464775f, -0.01196905f, -0.22057073f, 0.06681212f, -0.02087913f, -0.10346802f, 
    0.05093130f, 0.03462875f, -0.00345417f, 0.02450917f, -0.12568069f, -0.10568326f, -0.00284418f, 0.18642135f, 
    -0.11019447f, 0.07091254f, -0.11037442f, 0.18152326f, -0.03657841f, 0.09049213f, 0.06164767f, 0.06131521f, 
    -0.21019465f, -0.06565510f, -0.04977461f, 0.05146368f, 0.05481059f, -0.14534378f, 0.35228968f, 0.04698300f, 
    0.17498940f, -0.11442783f, 0.10802796f, 0.09163339f, 0.04739460f, 0.15721984f, 0.08155691f, 0.01858038f, 
    -0.12645544f, -0.18599384f, 0.09456434f, -0.10597225f, -0.12073116f, 0.02614323f, -0.04587923f, -0.11068942f, 
    0.15831999f, -0.02541050f, 0.11819752f, 0.04805741f, -0.11726074f, -0.26213634f, 0.30327553f, 0.27272630f, 
    -0.03745716f, 0.11238625f, -0.02666598f, -0.00473458f, -0.03199331f, -0.05004453f, 0.16046034f, -0.05683830f, 
    0.06466577f, -0.15767969f, 0.03494535f, 0.01667871f, 0.11537151f, 0.15858752f, -0.03008735f, -0.05272454f, 
    0.00213022f, 0.01153404f, -0.11237282f, 0.14042003f, 0.02874360f, 0.28998721f, -0.05303640f, -0.08636805f, 
    0.08109308f, 0.06861962f, 0.12286613f, 0.10393484f, -0.17201051f, 0.00895427f, -0.07625172f, 0.00326505f, 
    0.35467774f, -0.00885181f, 0.06407332f, 0.10794608f, 0.17098995f, -0.04381750f, -0.03424175f, 0.08118038f, 
    0.10195550f, 0.01574358f, 0.04958788f, -0.03753683f, -0.10433205f, -0.00402215f, 0.14200251f, 0.14781110f, 
    0.02521069f, -0.08868827f, -0.24616852f, 0.00414591f, 0.00743797f, -0.04281551f, 0.05073864f, -0.04338158f, 
    -0.39308304f, 0.16516905f, 0.01906213f, 0.02026593f, -0.24008690f, 0.06825088f, -0.25240132f, -0.01845386f, 
    0.05138075f, 0.02194637f, 0.05442465f, -0.06990483f, 0.01474969f, 0.34278828f, 0.05659235f, 0.06298085f, 
    -0.13693008f, 0.00554365f, -0.00902395f, 0.01669949f, -0.09631541f, -0.03998433f, 0.00708559f, -0.06924824f, 
    -0.39496735f, 0.41639954f, -0.00149254f, 0.25911132f, 0.11313724f, 0.03496107f, 0.06455713f, 0.05798240f, 
    0.02305600f, 0.20384990f, -0.12787747f, 0.02239562f, 0.23163819f, -0.18450440f, -0.03591219f, -0.03843899f, 
    0.13094786f, -0.02792022f, -0.00319729f, -0.01843806f, -0.05400717f, 0.03227895f, 0.01220532f, 0.07348256f, 
    0.05859163f, 0.17794698f, 0.01158955f, -0.02092478f, 0.28567660f, 0.00701809f, 0.02291516f, 0.03988662f, 
    0.13191412f, 0.11520246f, 0.11800674f, -0.04458876f, 0.18045399f, 0.14076453f, 0.05721891f, 0.06353301f, 
    0.03088731f, -0.01237575f, -0.13801810f, -0.01766064f, 0.18325119f, -0.10041053f, 0.10073400f, 0.10799559f, 
    0.02211405f, -0.02027750f, -0.03590772f, 0.04984472f, -0.01189556f, -0.04270422f, 0.04861942f, 0.07191952f, 
    0.01358314f, 0.00375983f, -0.03033209f, -0.05762045f, -0.20235784f, 0.17612092f, 0.06642639f, -0.08853836f, 
    -0.01390241f, -0.06505959f, -0.23626256f, 0.13969104f, -0.07936323f, 0.04654198f, 0.23357192f, 0.07912309f, 
    -0.07692946f, -0.30158320f, -0.03660708f, 0.14706784f, -0.04839119f, 0.03620215f, 0.02185921f, 0.13771653f, 
    0.04598191f, 0.24244906f, -0.12012314f, -0.01442654f, -0.21568067f, -0.08286058f, 0.06989194f, 0.05923018f, 
    0.07761331f, -0.07020269f, -0.12545952f, 0.05956904f, 0.03198749f, -0.06521481f, -0.05466743f, -0.06798591f, 
    -0.05945024f, -0.01188522f, -0.00631242f, 0.02511863f, 0.00602941f, -0.04038260f, 0.01460767f, -0.00904658f, 
    0.00861608f, 0.03213795f, -0.03312051f, -0.00257731f, 0.01849082f, 0.01437574f, 0.03326220f, -0.02931851f, 
    -0.03878272f, 0.03749673f, -0.05233307f, -0.05426132f, -0.00680361f, 0.02982665f, 0.01061379f, 0.00445843f, 
    0.02629368f, 0.00745722f, -0.05472182f, 0.01736681f, 0.01483430f, -0.05491701f, -0.04148168f, 0.02574138f, 
    0.01200463f, 0.01898307f, 0.02829362f, 0.00691618f, 0.02675854f, -0.00366768f, 0.02304611f, 0.00513517f, 
    -0.03959240f, -0.01662196f, -0.05488231f, -0.02440725f, -0.05298823f, 0.01662703f, 0.04026608f, -0.02084968f, 
    -0.04690646f, 0.00868126f, -0.04289708f, -0.02356960f, 0.00677833f, -0.01278449f, 0.00835811f, -0.02875159f, 
    0.00513228f, -0.02984416f, 0.04217699f, -0.00715719f, 0.00213256f, 0.02977462f, -0.00980901f, -0.01334344f, 
    0.02511428f, -0.04175268f, -0.01465976f, 0.03618659f, -0.03296810f, -0.02824732f, -0.03212348f, 0.03885461f, 
    0.01490605f, 0.03993979f, -0.05631996f, 0.04123447f, -0.04143253f, 0.00709930f, 0.02342315f, 0.03585819f, 
    -0.02555268f, 0.02249195f, 0.02432158f, -0.04999806f, -0.05720150f, -0.00138621f, -0.00843990f, 0.03166459f, 
    0.01622702f, -0.05388600f, -0.00503574f, -0.01468741f, -0.02375929f, 0.02324869f, 0.01095724f, 0.00392492f, 
    -0.03688810f, -0.02030339f, -0.05006087f, -0.01770240f, -0.01738726f, -0.03144703f, -0.00947100f, 0.02562818f, 
    0.03736717f, 0.00849373f, 0.01459435f, 0.04050394f, 0.03541775f, -0.04639982f, 0.02728987f, -0.02793515f, 
    0.03869203f, -0.01314338f, -0.02655127f, -0.01579280f, -0.02788710f, 0.01368359f, 0.03065923f, 0.01367201f, 
    -0.04583496f, 0.01800292f, 0.03073885f, 0.02287932f, 0.02983801f, 0.04015303f, -0.05181985f, 0.03413424f, 
    0.01379613f, -0.05785014f, 0.00994518f, -0.04336460f, 0.01906963f, -0.00682242f, -0.01461999f, 0.01993887f, 
    0.01133976f, -0.02994779f, 0.01371164f, -0.02057621f, 0.03325058f, 0.05083137f, -0.04266889f, -0.03103410f, 
    0.00742359f, -0.00753650f, -0.00357753f, 0.01126010f, -0.04534756f, -0.04044211f, -0.02722083f, -0.05201786f, 
    0.03509467f, 0.03322753f, -0.04431113f, -0.01151023f, -0.02739531f, -0.03999427f, -0.04707241f, 0.02447371f, 
    0.03436552f, 0.00585629f, -0.05059620f, 0.03116284f, 0.00000428f, 0.01456450f, -0.01826846f, -0.03948778f, 
    0.01837013f, 0.00727797f, -0.04212204f, -0.03886619f, -0.00221597f, -0.02892842f, -0.02690074f, -0.02184683f, 
    -0.00121246f, -0.00597966f, -0.00526881f, 0.02653213f, 0.02524101f, -0.01816179f, -0.02582841f, -0.01824287f, 
    -0.03983336f, -0.05112752f, 0.00370142f, 0.01321998f, -0.04969043f, -0.00659359f, -0.01749008f, 0.00255233f, 
    -0.01927068f, -0.05697093f, 0.02615103f, 0.00981887f, -0.01770868f, -0.03082554f, 0.00743696f, 0.00923629f, 
    -0.01074781f, -0.01497365f, -0.00160423f, 0.01087903f, -0.02191345f, -0.04127224f, -0.04799011f, -0.03471287f, 
    0.02109616f, 0.00917385f, -0.00170760f, 0.01464671f, -0.04415986f, -0.01263368f, -0.03334454f, 0.02429809f, 
    -0.03336050f, -0.01888053f, -0.03267945f, 0.03778983f, -0.02098336f, -0.00922964f, -0.02346632f, -0.00473846f, 
    -0.02685970f, -0.00532933f, 0.02348678f, 0.03912174f, 0.00544884f, -0.02961998f, 0.01351256f, 0.03869936f, 
    0.01977306f, 0.01023807f, -0.01677558f, -0.04640674f, 0.04033592f, -0.00387286f, -0.04945634f, -0.01555266f, 
    0.01272513f, 0.01331342f, 0.02326716f, -0.01266299f, -0.04488473f, 0.03210264f, -0.04723419f, 0.02234121f, 
    0.00179806f, 0.04104644f, -0.00351793f, 0.02720317f, -0.03739317f, -0.00434011f, -0.03787887f, 0.03039240f, 
    0.04475135f, 0.02343893f, -0.04254426f, -0.04934753f, -0.01659859f, -0.02825764f, -0.02222098f, 0.02365490f, 
    -0.00174011f, -0.02072276f, -0.01063662f, -0.04383091f, 0.00967147f, -0.03191690f, 0.00507743f, 0.01401803f, 
    -0.04448966f, -0.05619140f, -0.05311054f, -0.05607650f, 0.00593256f, -0.00529504f, 0.00251690f, -0.04011439f, 
    0.01828164f, 0.00111457f, 0.01227182f, -0.03088067f, 0.00907708f, 0.02570642f, -0.00869386f, 0.02628473f, 
    -0.02410963f, -0.01458291f, -0.00797484f, 0.00101731f, 0.03457572f, 0.01926057f, -0.04736443f, -0.02139292f, 
    -0.00846296f, -0.02340785f, 0.03382586f, 0.02964683f, 0.02253669f, 0.02546201f, -0.01632357f, -0.00118522f, 
    0.02221687f, -0.05706794f, -0.01204185f, -0.05231725f, 0.01646577f, 0.02025162f, -0.04097172f, -0.03992753f, 
    0.02355926f, 0.02165967f, -0.04393227f, 0.01193943f, -0.03598386f, -0.04851977f, -0.01715958f, 0.03309888f, 
    -0.04081080f, 0.03043659f, 0.03556865f, 0.00834718f, -0.01817608f, -0.05372895f, -0.01827660f, 0.00622642f, 
    -0.03237214f, 0.00358214f, -0.05443527f, 0.00349130f, 0.00887303f, -0.01300703f, 0.02802925f, -0.05009440f, 
    0.02700286f, -0.02955581f, 0.01454189f, 0.01732558f, -0.02077383f, -0.03447273f, -0.03944770f, -0.01799971f, 
    -0.04202385f, -0.01773388f, 0.02664780f, -0.00707984f, -0.02211409f, 0.03825468f, 0.03598415f, 0.02906861f, 
    0.03782125f, 0.00807314f, 0.03532293f, -0.01219895f, -0.06001512f, -0.01859165f, -0.03335924f, 0.03895228f, 
    -0.04536995f, -0.00090224f, -0.03696365f, -0.00928948f, 0.03383639f, -0.04273075f, -0.01774388f, 0.01896258f, 
    -0.00040038f, -0.04297404f, 0.01039409f, -0.05985472f, 0.01678736f, 0.03059721f, -0.03061924f, -0.01048752f, 
    -0.00564489f, -0.03431559f, 0.00599856f, -0.02740293f, 0.02588707f, 0.04247778f, -0.02452166f, 0.02553158f, 
    0.00967710f, -0.01597643f, 0.02786083f, -0.04530851f, 0.00034915f, 0.03079920f, 0.00031831f, 0.03385174f, 
    -0.05177292f, -0.00699384f, -0.05306294f, -0.00265842f, -0.05694845f, 0.00068578f, 0.00560107f, 0.01675374f, 
    -0.01912051f, -0.01554093f, 0.04143213f, -0.02413745f, -0.00131498f, -0.00104053f, 0.04114071f, -0.05006790f, 
    0.00016779f, 0.03026626f, 0.04139911f, 0.04074584f, -0.00885854f, -0.01938629f, -0.00075568f, 0.04742018f, 
    0.02299076f, -0.01761857f, -0.00991948f, 0.04207076f, 0.00440836f, -0.00424524f, -0.04933675f, 0.02843741f, 
    -0.00832193f, 0.04430287f, -0.02479698f, -0.02603172f, -0.03249305f, 0.01610960f, -0.01748214f, -0.02516345f, 
    0.01762921f, -0.00304695f, 0.00999639f, 0.04570485f, 0.01484820f, -0.03955428f, 0.01116132f, -0.02466575f, 
    -0.01348086f, -0.00230422f, -0.02037422f, -0.02351669f, 0.03361187f, -0.04168978f, -0.03496913f, -0.00012937f, 
    -0.04291575f, 0.02481202f, 0.00700892f, -0.05528821f, -0.04126238f, -0.01753202f, 0.02406310f, 0.01426271f, 
    -0.00560635f, -0.01166667f, -0.02339607f, 0.00301504f, -0.01625625f, 0.01490468f, -0.03315601f, 0.01978029f, 
    -0.01431954f, -0.03217164f, -0.02308621f, -0.03642112f, -0.05645336f, -0.01973406f, 0.02044072f, -0.01044629f, 
    0.00781608f, -0.01612098f, 0.00147364f, -0.03724018f, -0.01045303f, -0.03527205f, -0.04106141f, 0.02781486f, 
    -0.00028599f, -0.02406444f, 0.03948744f, -0.02874567f, 0.01827641f, -0.03943786f, -0.01935548f, 0.04995221f, 
    0.02400084f, -0.02705610f, 0.02437791f, -0.05167014f, -0.04554680f, 0.02050099f, -0.04978411f, 0.00253595f, 
    -0.02486122f, 0.03989007f, -0.04401363f, 0.03880703f, -0.03823438f, -0.05409130f, 0.03566349f, 0.01348922f, 
    -0.04903131f, -0.05306124f, -0.00624847f, 0.00069379f, 0.01968410f, 0.04329212f, -0.01605873f, -0.04572018f, 
    0.00290368f, -0.00828658f, 0.02038789f, -0.02990812f, 0.03189885f, -0.01330227f, 0.03349133f, 0.01548767f, 
    -0.04424083f, 0.03636262f, -0.04731153f, 0.00137186f, -0.03520043f, -0.01045582f, 0.00759337f, -0.01342608f, 
    -0.00768454f, 0.01631875f, 0.00824638f, -0.00832761f, 0.02596760f, -0.02962079f, 0.01098192f, -0.02810549f, 
    -0.05059003f, -0.05624952f, 0.00429901f, -0.01492434f, 0.00411518f, -0.03780902f, -0.00781379f, -0.02223314f, 
    0.00662279f, -0.02776480f, -0.01654461f, -0.02877880f, -0.01972826f, -0.04245284f, 0.03971136f, -0.01490955f, 
    0.02456469f, 0.00010558f, 0.03939165f, 0.03884330f, -0.01897953f, -0.03324493f, -0.04561990f, -0.01704877f, 
    0.03631803f, -0.01366868f, -0.00033082f, 0.01461248f, -0.02117809f, -0.02178863f, -0.00992838f, -0.01297294f, 
    -0.04764265f, -0.03434039f, -0.03066691f, 0.02687750f, -0.03055158f, 0.00219307f, 0.02305897f, 0.00925190f, 
    -0.06289828f, -0.01316271f, -0.03426825f, -0.05104174f, -0.04833980f, -0.02439699f, 0.02994701f, 0.00080800f, 
    0.03786012f, -0.01335157f, -0.02159827f, -0.03888273f, 0.03408367f, 0.00344167f, -0.01522164f, -0.02850704f, 
    -0.05554578f, 0.01407586f, -0.02260076f, 0.04102843f, -0.01112425f, 0.02709915f, 0.00594630f, 0.04123222f, 
    0.04045021f, -0.03460662f, -0.05125214f, 0.02218662f, -0.02889924f, -0.01944096f, 0.04330538f, -0.05269564f, 
    -0.03018206f, 0.01001521f, -0.05000504f, -0.03933113f, -0.02314808f, -0.02287841f, -0.02560029f, -0.04794048f, 
    -0.03652193f, -0.00566893f, -0.00843144f, -0.00325795f, -0.01702169f, -0.00989737f, -0.02463714f, 0.00088458f, 
    0.02701465f, 0.00027025f, -0.01288164f, -0.03501299f, -0.04054281f, -0.00809887f, -0.01340034f, -0.01720717f, 
    -0.02387938f, -0.04251580f, -0.04065658f, 0.04422402f, -0.01839730f, -0.02400580f, -0.02297368f, 0.01400046f, 
    -0.01662680f, -0.00931954f, -0.00826699f, -0.01041999f, -0.05269650f, -0.05110095f, 0.00687862f, -0.02280393f, 
    0.01862659f, 0.03566325f, 0.00669392f, 0.03589640f, 0.03534530f, -0.01512597f, -0.03530985f, -0.02066352f, 
    -0.01213393f, -0.03386417f, 0.01481313f, -0.01315936f, 0.03638130f, 0.03344904f, -0.04563158f, -0.04617897f, 
    -0.02028507f, -0.01705119f, -0.01013811f, 0.03171403f, -0.01736337f, -0.01788863f, -0.01160952f, -0.00385785f, 
    -0.00936048f, -0.03931082f, -0.02788306f, -0.04807539f, 0.00045759f, 0.03645213f, -0.03788899f, -0.02275985f, 
    0.03921709f, -0.03422403f, -0.00063881f, 0.00146681f, 0.01663787f, 0.03928040f, -0.04843187f, -0.00882706f, 
    0.03507827f, -0.03973303f, 0.01884079f, 0.01864504f, 0.01986964f, -0.01300648f, -0.01874918f, 0.04657534f, 
    -0.02773477f, 0.00258480f, 0.03172597f, -0.01059727f, -0.03384370f, -0.00283966f, -0.02123765f, 0.02669908f, 
    -0.00006984f, 0.01932453f, 0.04873324f, 0.03730286f, 0.02925782f, -0.00429138f, -0.00580136f, 0.00352857f, 
    0.01540435f, 0.04258862f, -0.01017493f, -0.00994132f, -0.02421316f, 0.04455345f, -0.01332283f, -0.00395243f, 
    -0.03097031f, 0.01199644f, 0.04920239f, -0.02462860f, -0.03165000f, 0.03687046f, -0.05521409f, -0.01604712f, 
    0.00323224f, 0.03800688f, 0.02298782f, -0.01419142f, 0.03118950f, 0.01655984f, 0.00035314f, -0.03702964f, 
    -0.03693270f, -0.00767517f, -0.03548685f, -0.01617051f, 0.02904182f, 0.04145251f, 0.04727560f, -0.03882062f, 
    -0.01689981f, 0.00591290f, -0.04115659f, 0.01248633f, 0.00106496f, 0.03043512f, -0.05366884f, 0.00957005f, 
    -0.04850316f, -0.03312210f, -0.05190055f, 0.03069851f, -0.00031279f, 0.03299185f, -0.03903097f, -0.05032691f, 
    0.02032699f, -0.00951584f, -0.04610882f, 0.00293008f, 0.00447677f, -0.05857965f, -0.00812576f, 0.01075996f, 
    0.02016799f, -0.00122117f, -0.03323791f, 0.01973998f, 0.03392127f, 0.02011956f, -0.04058146f, 0.04098781f, 
    -0.02546236f, -0.05224015f, -0.00303079f, -0.02716476f, 0.01139565f, 0.01081294f, -0.05048897f, 0.03225004f, 
    -0.03611815f, -0.03996697f, 0.03762757f, 0.01713521f, -0.03734345f, -0.04480411f, -0.04935021f, 0.02005064f, 
    0.03471455f, 0.00071425f, -0.04854612f, 0.00647318f, -0.02678440f, -0.02001074f, -0.03221540f, 0.03659843f, 
    -0.04669895f, -0.03322917f, -0.02942211f, -0.00925815f, -0.04521196f, -0.03803087f, -0.03875151f, -0.00501206f, 
    -0.03505221f, 0.00319073f, -0.01051251f, -0.01832075f, 0.01904781f, 0.01755624f, 0.00925726f, 0.01245786f, 
    -0.01032976f, 0.00724590f, -0.02516185f, 0.00675696f, 0.00413775f, -0.05662025f, -0.01939688f, -0.04950679f, 
    0.02074152f, 0.03303973f, -0.02226586f, -0.01717541f, -0.01463588f, 0.02191985f, -0.03085455f, -0.04029621f, 
    -0.01966703f, -0.05138191f, -0.05419028f, -0.01990167f, -0.02385601f, -0.02286437f, -0.01707329f, -0.04715269f, 
    0.03308917f, -0.00712844f, 0.01619075f, 0.04471137f, -0.02394977f, -0.00373351f, -0.05101596f, -0.03505163f, 
    0.00150133f, -0.04630542f, -0.02843300f, 0.02998657f, 0.00897035f, -0.04596634f, -0.03254739f, -0.00627471f, 
    0.02142476f, -0.00465631f, -0.01475438f, -0.02988070f, -0.00938964f, -0.01080638f, -0.03627588f, -0.00182605f, 
    -0.02588029f, 0.01944021f, -0.04955746f, -0.01907320f, -0.03812223f, 0.00119948f, -0.02831446f, 0.02504905f, 
    0.02825755f, 0.03486504f, 0.02855529f, -0.04520953f, -0.01653349f, 0.01710541f, 0.03865134f, -0.03704550f, 
    0.01996612f, 0.03302899f, -0.03693842f, 0.01506804f, -0.04360023f, -0.04324315f, -0.04016513f, -0.04809952f, 
    -0.04913716f, 0.03298868f, 0.02934873f, -0.04622639f, 0.00297081f, -0.04366186f, 0.03460647f, 0.02813091f, 
    0.04273029f, 0.01187813f, -0.05107048f, -0.04138490f, -0.03370569f, 0.04408466f, 0.01470613f, 0.02496652f, 
    -0.04410864f, -0.03519924f, -0.01364432f, -0.03423594f, -0.05589033f, 0.01789012f, 0.03838774f, -0.02882688f, 
    0.03334627f, 0.00453443f, 0.03734557f, -0.03161644f, -0.03547852f, 0.00139957f, 0.02306409f, -0.01885735f, 
    -0.04033200f, 0.03998588f, -0.01294646f, -0.02038673f, 0.01868758f, 0.01102900f, -0.00644297f, 0.04215377f, 
    -0.00463814f, -0.05215362f, -0.03326386f, -0.00658937f, -0.02504423f, 0.01975913f, -0.02217316f, 0.04299356f, 
    0.01908698f, 0.00909788f, -0.00745211f, -0.02636942f, -0.04891013f, -0.03625961f, 0.02479124f, -0.00538595f, 
    -0.04090474f, -0.00750230f, -0.00098959f, -0.05697362f, -0.02489672f, 0.03352532f, 0.01310238f, 0.02917856f, 
    -0.02658764f, -0.04920677f, -0.05551032f, -0.02987343f, 0.00025498f, -0.00140690f, -0.04915013f, -0.00668470f, 
    -0.01886255f, 0.00689664f, 0.02202464f, -0.02240499f, -0.03782681f, -0.03132292f, -0.00136234f, 0.04829143f, 
    -0.02675163f, 0.03787144f, 0.03120547f, -0.04071931f, -0.04684582f, -0.05544300f, -0.03560620f, -0.04539664f, 
    -0.02315188f, 0.03533964f, -0.01377025f, 0.02015601f, -0.01689844f, -0.04461794f, -0.05004268f, 0.04125854f, 
    -0.02567683f, -0.03083177f, -0.03707901f, 0.02063589f, 0.03364730f, -0.03586345f, 0.00603687f, 0.00778750f, 
    0.04357475f, 0.02416467f, 0.01929578f, -0.02658097f, -0.03744562f, 0.02247872f, -0.02179365f, 0.01417265f, 
    0.02622441f, -0.02377574f, -0.05016650f, 0.01779245f, -0.02546144f, -0.01135185f, -0.01382290f, -0.05627107f, 
    0.03962215f, 0.03524784f, -0.04491115f, 0.03123503f, -0.01701131f, -0.02416939f, -0.05381774f, 0.00927231f, 
    -0.05441256f, 0.01310474f, 0.04258365f, -0.05241022f, 0.00009079f, 0.00086120f, -0.04543586f, -0.03720675f, 
    -0.04096559f, -0.04719241f, -0.02843125f, -0.02803515f, -0.05160379f, 0.04000500f, 0.02133470f, -0.02933977f, 
    0.04491705f, -0.01334117f, 0.01468080f, -0.02331182f, -0.00883534f, -0.01728287f, -0.02058861f, 0.02534056f, 
    -0.02303777f, 0.02970119f, -0.02412964f, 0.01106793f, 0.01273543f, 0.03935272f, -0.02711073f, 0.02963562f, 
    0.01499090f, 0.04051042f, -0.03940942f, -0.02929736f, 0.01117101f, 0.03335877f, -0.04067281f, -0.00612243f, 
    0.02651523f, 0.04046569f, 0.00358536f, 0.01590468f, 0.03675584f, -0.02933682f, -0.00725050f, -0.00246166f, 
    0.02469694f, 0.02541602f, -0.04884227f, -0.01755893f, 0.03326289f, -0.05404643f, 0.03654647f, -0.02203039f, 
    -0.01003468f, 0.04252058f, -0.01803782f, -0.00006406f, -0.05612861f, 0.00650706f, -0.02455425f, 0.04312097f, 
    -0.02518068f, 0.04313103f, -0.02237515f, 0.01514743f, -0.00582104f, -0.04949513f, -0.03537985f, 0.03170541f, 
    -0.02465212f, -0.00204458f, -0.04922892f, -0.00947336f, 0.00429284f, 0.03847210f, -0.00587380f, -0.00613562f, 
    -0.00666728f, 0.00212602f, -0.01438000f, -0.03023459f, 0.02617874f, 0.01512479f, 0.02195040f, 0.00892228f, 
    0.02096331f, -0.04888982f, -0.02554935f, 0.04222265f, 0.02358516f, -0.00587313f, 0.00130759f, -0.04302787f, 
    0.01453648f, 0.02686772f, 0.02078579f, 0.03128350f, 0.00125480f, -0.04408808f, 0.00223008f, -0.01302096f, 
    -0.04977986f, 0.02117376f, -0.04120440f, -0.04116512f, 0.03334874f, -0.04208537f, -0.01635855f, -0.01921465f, 
    -0.05695173f, 0.03680933f, -0.05697573f, 0.02572608f, 0.01469484f, -0.00531785f, 0.01667046f, -0.02198082f, 
    0.00934720f, -0.02604674f, -0.02705139f, -0.00552344f, 0.00586674f, 0.00439675f, -0.02444863f, -0.04697406f, 
    0.03159407f, -0.04260309f, -0.01530139f, 0.00036644f, 0.04157841f, 0.02074153f, -0.01203444f, 0.00032385f, 
    0.20811613f, 0.20272715f, 0.19039409f, 0.03752615f, -0.05860432f, -0.01369702f, 0.00502117f, 0.02902070f, 
    -0.07247706f, 0.00949509f, 0.01093308f, 0.03162832f, 0.03046634f, 0.07480194f, -0.02077624f, -0.23570302f, 
    -0.07425631f, -0.01933846f, -0.04488152f, 0.02465286f, -0.01929298f, -0.06429635f, -0.00555657f, -0.04268535f, 
    0.08299497f, 0.05275475f, -0.01959536f, -0.27412698f, 0.09029248f, 0.07775883f, 0.03987151f, 0.10934909f, 
    -0.13980545f, -0.07849554f, 0.01481704f, -0.03785211f, -0.37697729f, -0.04856686f, -0.21197593f, -0.22635391f, 
    -0.00674861f, 0.01081639f, -0.06505614f, 0.06601403f, -0.04611623f, 0.03158694f, -0.06920229f, -0.03493167f, 
    0.10660946f, 0.06593518f, 0.23440841f, -0.14036170f, 0.10501526f, -0.03623096f, -0.03393000f, 0.12009527f, 
    -0.10980601f, 0.01911443f, -0.02071239f, 0.02559346f, 0.15695837f, 0.03062761f, -0.02641024f, -0.03880405f, 
    -0.10057684f, -0.24715362f, 0.22729081f, -0.02656480f, 0.10030811f, -0.03010357f, -0.02821194f, -0.01371262f, 
    -0.08602494f, -0.20237160f, -0.22240500f, -0.16218294f, 0.03480823f, -0.02213549f, 0.09784710f, 0.04116382f, 
    -0.00923126f, 0.26090553f, -0.02017185f, -0.04671136f, -0.06946047f, 0.11883637f, 0.00333931f, 0.05507359f, 
    -0.01899003f, 0.04869381f, 0.02712691f, 0.04316974f, 0.01196724f, -0.06419297f, -0.05876452f, 0.05155659f, 
    0.36510968f, -0.23155946f, -0.02308817f, -0.01915611f, 0.07221706f, -0.03264180f, 0.16383715f, 0.00724818f, 
    0.01812083f, -0.11626015f, 0.05965964f, 0.08126178f, -0.50191432f, -0.12613955f, -0.01191852f, 0.02864977f, 
    0.02346183f, -0.03295712f, -0.13742313f, 0.04613515f, -0.04052600f, 0.05993621f, -0.02953663f, -0.12015895f, 
    -0.27239594f, -0.46378893f, -0.12150417f, -0.11733845f, 0.01128636f, -0.13467756f, 0.03332986f, 0.06633231f, 
    -0.09790803f, -0.04737097f, 0.11994993f, 0.02642447f, 0.10639481f, 0.15367082f, 0.17491780f, 0.07550754f, 
    0.01998385f, 0.09437374f, -0.01981321f, -0.08185501f, 0.13846646f, 0.02798075f, 0.08661937f, -0.05005613f, 
    0.20235352f, 0.21984251f, 0.29078230f, 0.15072751f, 0.07992957f, -0.03451845f, 0.07288180f, 0.01198872f, 
    0.04477567f, -0.02296353f, -0.05950319f, -0.04367206f, 0.34097174f, 0.09260526f, 0.50970918f, 0.05821143f, 
    0.05475319f, -0.05613713f, 0.29407191f, 0.16856638f, 0.05106004f, 0.00624522f, 0.05077557f, -0.12882134f, 
    0.32190329f, 0.22481743f, 0.41151741f, -0.00530092f, 0.11172612f, 0.16148289f, 0.06702011f, -0.05329713f, 
    0.04053778f, -0.02116636f, 0.04797833f, -0.15445152f, 0.11148284f, -0.24403307f, -0.15641883f, 0.12090123f, 
    -0.11119304f, -0.02672170f, 0.06931321f, -0.10120704f, -0.03522955f, -0.11219568f, 0.13223110f, 0.07665530f, 
    -0.21306030f, -0.29575962f, 0.02667329f, -0.16725110f, 0.02594982f, -0.04416853f, -0.07309903f, -0.02206447f, 
    0.03524478f, -0.16853319f, -0.05634196f, -0.17069846f, -0.08239340f, -0.11079840f, 0.17760882f, -0.34482718f, 
    0.12435427f, -0.07764456f, -0.11477208f, -0.02658116f, 0.01814934f, -0.06583748f, 0.02017422f, -0.03157578f, 
    0.08993841f, 0.16042343f, -0.05866596f, -0.03756811f, -0.01611163f, 0.10197160f, 0.12174300f, 0.02803977f, 
    -0.01643198f, 0.00357309f, 0.05893876f, -0.12313227f, 0.26588124f, 0.17217095f, 0.10860884f, 0.11773973f, 
    0.02472345f, -0.09129957f, 0.07662929f, 0.05998268f, 0.10753331f, -0.00859733f, 0.02967480f, 0.03065165f, 
    -0.03474319f, 0.18213518f, 0.20940538f, 0.15620989f, -0.07126040f, -0.02232917f, 0.06792930f, 0.07785751f, 
    0.01045700f, -0.01714534f, -0.02642528f, 0.04831868f, -0.00387528f, -0.06991818f, -0.37255651f, -0.31748578f, 
    -0.06443511f, -0.22276787f, -0.13822110f, -0.04714597f, -0.02711494f, 0.03270848f, -0.03492812f, 0.06373193f, 
    -0.02693512f, -0.15199770f, -0.13780668f, -0.32899675f, 0.09507021f, -0.06565747f, -0.18511301f, -0.10417339f, 
    -0.10934159f, 0.01441868f, -0.01322392f, 0.00069420f, 0.12218440f, -0.07349084f, -0.14351349f, -0.31472600f, 
    -0.06479206f, -0.16712794f, -0.02921202f, -0.01418379f, -0.02329602f, -0.01466632f, 0.04555382f, 0.00779349f, 
    0.31140640f, -0.59249204f, -0.42135429f, -0.16865709f, -0.11037974f, -0.09929360f, -0.01208796f, -0.12983093f, 
    -0.11094723f, -0.06680922f, 0.06936373f, 0.03596067f, -0.10545462f, -0.05623732f, -0.02822527f, 0.03714344f, 
    0.02047276f, 0.12566608f, -0.03858465f, -0.10864299f, 0.12456039f, 0.11407771f, 0.01713300f, 0.12071346f, 
    -0.19313262f, -0.09503724f, -0.22606757f, -0.16962136f, -0.12796618f, -0.11146436f, -0.08997561f, -0.10013255f, 
    -0.11985100f, 0.06948826f, -0.05047483f, 0.21251926f, -0.38690516f, -0.10902130f, -0.14953773f, -0.02307570f, 
    -0.02224719f, -0.04031464f, -0.06466848f, -0.00885310f, -0.03533491f, -0.08623735f, -0.05222384f, -0.02175463f, 
    0.21192206f, 0.19293958f, 0.26918685f, 0.11705791f, 0.03538681f, 0.22427361f, -0.08924162f, -0.02831354f, 
    -0.02390161f, -0.00468544f, 0.00981183f, -0.05324602f, -0.16777079f, -0.17010637f, -0.37920547f, -0.08880287f, 
    0.02288824f, -0.03409045f, 0.02043951f, -0.02313394f, -0.04146798f, -0.06025227f, -0.16096611f, 0.00510984f, 
    -0.08072022f, -0.07657397f, 0.08438439f, -0.19976443f, 0.04830711f, 0.13515985f, -0.10015578f, -0.04529851f, 
    0.01470689f, -0.07219176f, 0.14202523f, 0.07126475f, 0.25424355f, 0.09708576f, 0.06427301f, 0.09850948f, 
    -0.03034050f, 0.11824301f, 0.03560427f, 0.00298081f, -0.02723180f, 0.02901544f, 0.13077806f, 0.10055915f, 
    0.07976262f, 0.11612412f, 0.05100293f, 0.09180859f, 0.04256309f, 0.09876974f, 0.07089710f, 0.14531758f, 
    0.03581708f, 0.03981873f, 0.09112387f, -0.06554738f, -0.04331344f, 0.01495006f, 0.00875387f, 0.02106923f, 
    -0.04977427f, -0.01894910f, -0.01894770f, 0.00924551f, 0.03170545f, 0.02793176f, 0.00674617f, -0.01940862f, 
    0.06346259f, -0.07254936f, -0.07457241f, 0.27486423f, -0.10556061f, -0.00787091f, -0.02582464f, -0.15086801f, 
    0.06251706f, 0.01109480f, 0.00326555f, 0.02344678f, -0.15840706f, -0.35422981f, -0.01600290f, 0.03382382f, 
    -0.11034271f, -0.11458630f, 0.08989845f, -0.03803584f, 0.11188815f, -0.11313059f, 0.13656801f, -0.06657863f, 
    0.06603176f, 0.08231085f, 0.09041186f, -0.00373404f, -0.02391119f, 0.01062734f, 0.05403247f, 0.14646602f, 
    0.06310111f, -0.01918723f, 0.00388405f, 0.02162042f, -0.16091563f, 0.14325847f, -0.06748764f, 0.09690566f, 
    0.04437294f, 0.03292224f, -0.07335183f, 0.12106915f, -0.03352810f, 0.07012157f, 0.03953620f, -0.08678740f, 
    0.04471030f, -0.15673812f, -0.18552880f, 0.02195514f, -0.18404415f, 0.03208661f, -0.02084921f, -0.00468768f, 
    -0.27336878f, 0.01929693f, 0.17070176f, -0.02323787f, -0.11201614f, 0.09394025f, 0.26879227f, -0.07217706f, 
    0.06919736f, 0.06096271f, -0.00400021f, -0.05547871f, -0.00336285f, -0.06573597f, 0.00126931f, 0.01411167f, 
    -0.23345250f, 0.01046352f, 0.13455360f, -0.19798277f, -0.07498717f, -0.00129174f, 0.05875831f, 0.02852995f, 
    -0.01900156f, 0.04408761f, 0.03817435f, -0.01096382f, -0.12808090f, 0.08977778f, 0.15347497f, 0.05741647f, 
    -0.10144886f, -0.03293894f, 0.05828605f, -0.01003218f, -0.04804955f, -0.01076363f, -0.03744640f, 0.20270607f, 
    -0.13626084f, -0.11782003f, -0.04985610f, 0.09488191f, -0.18468809f, 0.15515603f, -0.08644285f, -0.04591879f, 
    -0.04544406f, 0.05956480f, 0.00228208f, 0.07629425f, 0.16985971f, 0.02246491f, 0.05738102f, -0.07296286f, 
    0.04174036f, -0.03496954f, 0.12030496f, 0.00835169f, 0.02822038f, 0.04449836f, -0.04201927f, 0.11889875f, 
    0.16840756f, 0.05544872f, -0.12622617f, -0.00578193f, 0.12557393f, 0.13872886f, 0.05851559f, 0.05810589f, 
    -0.01224129f, 0.00784547f, 0.03297127f, 0.00466083f, 0.09121082f, 0.38781145f, -0.20255010f, 0.12604295f, 
    0.09165455f, 0.08995949f, -0.08492091f, -0.03020867f, -0.12466780f, -0.03092213f, 0.06431881f, 0.05757952f, 
    0.18079510f, 0.05613441f, -0.20064154f, 0.12439356f, 0.06524260f, 0.06454538f, -0.00749377f, 0.14637826f, 
    -0.07028400f, 0.02095452f, -0.03040832f, -0.04150244f, -0.25053155f, 0.21828669f, 0.07763104f, 0.05191883f, 
    0.13836876f, -0.08409965f, -0.01525578f, -0.01352546f, -0.00475560f, 0.11224073f, 0.01361193f, 0.02679398f, 
    -0.05911970f, -0.25605831f, -0.22810949f, 0.02268419f, -0.18382841f, -0.00948764f, 0.13380262f, -0.07865646f, 
    -0.06611529f, -0.03709007f, 0.04776354f, -0.05987048f, 0.15088619f, -0.00513582f, -0.13612810f, 0.17510726f, 
    -0.22529669f, -0.04153937f, 0.11375103f, -0.06137577f, 0.02966206f, 0.03584149f, -0.03395566f, -0.03262066f, 
    0.14250620f, -0.05306699f, 0.05877870f, -0.17167610f, -0.02700043f, -0.01274361f, 0.02837731f, 0.01652965f, 
    0.01348705f, 0.04755953f, -0.10019246f, -0.00944860f, 0.01220301f, 0.18019417f, 0.03869700f, -0.07507119f, 
    -0.02683761f, 0.09060819f, 0.01473898f, 0.08851981f, -0.05429176f, 0.07886310f, 0.00373874f, 0.04629955f, 
    0.18215437f, 0.07900052f, 0.13742286f, 0.15222406f, 0.02756047f, 0.02731869f, -0.11664278f, 0.03610474f, 
    -0.01273058f, -0.02615102f, -0.09400717f, 0.09431601f, 0.06923718f, -0.32057601f, -0.02077409f, -0.02177938f, 
    0.00811533f, 0.04545665f, 0.04021969f, 0.05337170f, 0.04395034f, 0.06662106f, -0.01870925f, -0.07396541f, 
    -0.17911506f, -0.13488881f, -0.07673449f, 0.11114024f, -0.13606668f, -0.05135528f, 0.06043269f, 0.00956809f, 
    -0.01408634f, 0.01306217f, 0.04084254f, -0.02851088f, 0.18147659f, -0.01264506f, 0.07553742f, 0.16663331f, 
    -0.03855598f, 0.09871650f, -0.00337711f, 0.14184158f, -0.00833533f, -0.01300742f, -0.05371608f, 0.02565766f, 
    -0.69243819f, 0.36082554f, 0.03666019f, 0.00806024f, 0.01844734f, -0.01136813f, -0.01015689f, 0.15238395f, 
    -0.02339329f, 0.00575819f, 0.00970655f, -0.03507559f, 0.15771915f, -0.08835903f, 0.14135821f, -0.17759888f, 
    0.03586709f, -0.05369572f, 0.02173723f, -0.04029845f, -0.17585824f, -0.00087178f, -0.00758247f, 0.01688320f, 
    -0.13913481f, -0.08467842f, 0.12997167f, -0.09068692f, 0.07521205f, 0.09351264f, 0.01822926f, 0.01410077f, 
    0.00622335f, 0.07857516f, 0.01457770f, 0.00344111f, -0.02578092f, 0.08417439f, -0.03980277f, 0.11061422f, 
    -0.03757412f, -0.13121913f, -0.00634218f, 0.01994398f, -0.06081697f, 0.00356606f, -0.02759955f, 0.01367363f, 
    0.14434901f, 0.13036834f, -0.00626915f, 0.06655184f, 0.08235996f, -0.01284657f, 0.02550402f, 0.07908951f, 
    -0.02863455f, -0.03114214f, 0.00590313f, -0.01599219f, -0.09146217f, -0.19999425f, 0.08962146f, 0.03587821f, 
    -0.07052111f, -0.08271837f, 0.01110018f, 0.02433309f, 0.08658694f, -0.05955672f, 0.14353880f, 0.09837795f, 
    0.29587451f, 0.01894652f, -0.03450238f, 0.01385017f, -0.12909426f, 0.00212250f, 0.02291232f, -0.01528130f, 
    -0.08087175f, 0.12813401f, -0.17836998f, 0.00732448f, -0.08152360f, 0.12409619f, -0.02362707f, -0.04517838f, 
    0.02160896f, 0.01532284f, -0.09648717f, 0.09041162f, 0.04748612f, 0.03894997f, -0.02357651f, 0.05181091f, 
    -0.00444416f, 0.14180085f, 0.10953515f, 0.13310471f, 0.12313244f, -0.02702502f, 0.07721805f, 0.00279682f, 
    0.01286692f, -0.01303202f, 0.00339953f, -0.07894182f, -0.03428331f, -0.25265959f, -0.08778797f, 0.19709744f, 
    0.18199982f, 0.10161734f, 0.13508439f, -0.05888254f, -0.14246118f, -0.14300613f, -0.25785303f, -0.00616333f, 
    -0.10766689f, 0.16533001f, 0.07414348f, -0.05157743f, 0.07028180f, -0.12145671f, -0.09395546f, -0.19315566f, 
    0.09966476f, -0.07343204f, 0.08700764f, -0.10571452f, -0.19353123f, -0.05853681f, -0.09524205f, -0.03190114f, 
    0.12909804f, -0.03487209f, -0.06859302f, -0.01544526f, 0.00679622f, -0.01703871f, 0.00913029f, -0.01775164f, 
    0.07481121f, -0.06700715f, -0.12201920f, 0.32980031f, -0.15200268f, 0.13068901f, -0.05140186f, -0.16792805f, 
    -0.03707194f, -0.02146936f, 0.08222995f, -0.01985696f, 0.00222776f, -0.01812305f, 0.23903869f, 0.05523410f, 
    0.07852967f, 0.02052305f, 0.08989944f, 0.04642338f, -0.07464187f, 0.03115214f, -0.12909549f, -0.00673935f, 
    -0.13264301f, -0.13132221f, -0.12219135f, -0.31333992f, 0.12686852f, -0.00884120f, -0.03575017f, -0.12457714f, 
    0.09834035f, -0.22523524f, -0.04876760f, 0.09764549f, -0.00877828f, -0.33100381f, -0.02148635f, 0.13346560f, 
    -0.05783155f, -0.07795887f, 0.02999972f, 0.14244011f, -0.03651273f, 0.01873147f, -0.15559100f, -0.19083209f, 
    0.23918717f, 0.41093054f, -0.17754479f, 0.29139537f, 0.02639303f, -0.05096352f, 0.06601769f, 0.00181854f, 
    0.05080281f, 0.06692880f, 0.06151526f, 0.00190280f, 0.29623431f, 0.00888568f, -0.33361223f, -0.10401392f, 
    0.02477253f, -0.01720379f, 0.03723226f, -0.12410419f, 0.13169794f, 0.11828674f, 0.26617604f, 0.15087509f, 
    0.11823206f, -0.16055672f, -0.05195525f, -0.32629043f, 0.16889006f, -0.01094996f, -0.15122114f, -0.02212785f, 
    0.09136380f, 0.04607053f, -0.03535318f, -0.00222163f, 0.08726526f, -0.14009212f, -0.04644500f, 0.16738945f, 
    -0.08920049f, 0.11617912f, 0.15919997f, 0.06125451f, -0.02808605f, 0.06131069f, 0.03582879f, 0.24440093f, 
    -0.15369581f, -0.05486605f, 0.08364213f, 0.07933625f, -0.12394895f, -0.06738207f, -0.01357533f, 0.01011981f, 
    -0.11118154f, 0.06035228f, 0.02542259f, 0.12109713f, 0.00313652f, -0.13672636f, 0.06437556f, -0.04379327f, 
    0.01797094f, 0.06876157f, -0.04771872f, -0.04443858f, -0.01530540f, 0.10623452f, -0.13471402f, 0.07440656f, 
    -0.26847452f, 0.08818872f, -0.02378482f, 0.05801665f, 0.05993251f, -0.00212848f, -0.00263578f, -0.02498251f, 
    -0.04328301f, -0.04326126f, -0.05018587f, 0.11147811f, -0.06530032f, -0.06874353f, 0.10887189f, -0.06863004f, 
    0.04776131f, -0.03953744f, 0.02754517f, 0.14132236f, 0.11727329f, 0.13834037f, 0.13911019f, 0.01453141f, 
    -0.01876753f, -0.05735549f, -0.17683595f, -0.16937217f, -0.04026342f, 0.00280533f, -0.13819183f, -0.01351409f, 
    0.05667447f, -0.01520354f, 0.18139231f, 0.05509866f, 0.07862607f, -0.02087566f, -0.15125692f, 0.03919123f, 
    -0.01839170f, 0.12340999f, -0.00004684f, -0.05267398f, 0.06564604f, 0.00528510f, 0.09894732f, -0.04620249f, 
    0.11906938f, 0.06380795f, -0.08180708f, 0.38383749f, 0.05589846f, -0.01894127f, -0.05535612f, 0.02482515f, 
    -0.02822358f, -0.07304268f, -0.08537003f, 0.12343981f, -0.21675520f, -0.06783208f, 0.13158111f, 0.23146620f, 
    -0.02418891f, 0.04323476f, 0.03970510f, 0.04786597f, -0.10250952f, 0.06228618f, -0.03817873f, 0.09396398f, 
    0.17864586f, -0.15787750f, 0.01510742f, 0.06632495f, -0.02152997f, 0.15957513f, 0.06935925f, -0.07618358f, 
    0.14328367f, 0.10915116f, 0.07504760f, 0.04327447f, -0.38543326f, -0.25139683f, 0.01785156f, 0.29157779f, 
    0.09479852f, 0.06800850f, 0.10646345f, -0.04956579f, 0.04376894f, -0.12108456f, 0.04970194f, 0.04177292f, 
    -0.09789577f, -0.00923737f, -0.16204271f, -0.09991037f, 0.06378317f, 0.00583833f, 0.00638193f, 0.02931420f, 
    0.20587169f, 0.02553233f, 0.03884595f, 0.04609501f, -0.14318256f, 0.04360428f, 0.24142934f, 0.27766579f, 
    0.16976699f, 0.04027783f, 0.06824631f, -0.13259879f, -0.03090164f, 0.03974449f, -0.01934629f, 0.01993107f, 
    -0.24466626f, 0.00122555f, -0.08708210f, -0.10390500f, 0.12876819f, 0.02439906f, 0.05505444f, -0.12786989f, 
    0.16807741f, 0.12566549f, -0.03026951f, 0.06845782f, 0.20501351f, 0.22409123f, 0.11216427f, 0.25088081f, 
    -0.02552953f, -0.14638063f, 0.01858133f, 0.17359640f, -0.03315212f, 0.02030879f, 0.05996493f, 0.14281012f, 
    0.16352658f, 0.01053976f, -0.10754007f, -0.11122753f, 0.20924583f, 0.01106181f, 0.05165879f, 0.01623263f, 
    0.19157471f, -0.03602110f, 0.03910507f, -0.09066369f, 0.11600628f, 0.03446425f, -0.23216061f, -0.06969037f, 
    0.05062865f, 0.06806508f, -0.19325134f, 0.08064993f, -0.08378507f, -0.07246197f, 0.07180613f, -0.18716291f, 
    -0.16837861f, -0.15097946f, -0.00327783f, 0.08716547f, -0.00158426f, -0.06998341f, 0.05756876f, -0.01340084f, 
    0.01307683f, 0.03009058f, 0.12165125f, 0.02985739f, -0.12334631f, 0.18634158f, -0.20534079f, -0.15411764f, 
    0.01339506f, -0.09191697f, -0.14909846f, 0.05909308f, -0.05305701f, 0.00930149f, -0.01502800f, -0.07416227f, 
    0.15237050f, 0.11557641f, 0.14315790f, 0.08670301f, 0.01302907f, -0.10512397f, -0.05574382f, 0.05419256f, 
    0.17052616f, -0.00481128f, 0.05804550f, -0.07244535f, -0.14325728f, -0.11870298f, 0.18731983f, 0.16851218f, 
    0.03663163f, 0.01932609f, 0.12986885f, 0.14823839f, 0.10783002f, 0.04790674f, 0.03254646f, 0.23194943f, 
    -0.23777795f, -0.12653540f, 0.05747283f, 0.08963111f, -0.05885178f, 0.15784706f, 0.01590442f, 0.05262458f, 
    0.08397827f, -0.01850660f, 0.12758434f, 0.06423160f, -0.04038155f, 0.18363935f, 0.00367364f, -0.07148309f, 
    -0.02312797f, 0.02638102f, -0.15038134f, 0.08103646f, -0.01577008f, -0.05109357f, 0.04039531f, -0.02227916f, 
    0.14455666f, 0.03987039f, 0.01113096f, 0.05470597f, -0.04291373f, 0.02860708f, 0.17620787f, 0.07890581f, 
    0.01883201f, 0.17726535f, 0.02371481f, 0.03042091f, 0.05801090f, 0.17377049f, 0.11736253f, -0.05409630f, 
    -0.11345253f, 0.04508584f, 0.00524775f, -0.14797349f, 0.05547944f, 0.03017419f, 0.06646797f, -0.06833215f, 
    -0.24318725f, 0.06226861f, -0.00613036f, -0.08991513f, 0.05875216f, 0.05986589f, 0.02014855f, 0.10436010f, 
    -0.12337778f, 0.07565012f, 0.10588145f, -0.14475648f, -0.13107353f, 0.03963755f, -0.07442708f, 0.15661630f, 
    0.00756467f, -0.09107218f, 0.09713898f, -0.01686913f, 0.03446782f, -0.08383812f, -0.01829733f, -0.04076044f, 
    0.07464231f, -0.00759153f, -0.00915119f, 0.01171585f, -0.05553199f, 0.03476889f, -0.03457077f, -0.02773623f, 
    0.03527097f, 0.17513268f, 0.02826116f, 0.00230406f, -0.24500240f, 0.21495487f, 0.00468170f, -0.01256962f, 
    0.13042544f, 0.05737302f, 0.07129362f, 0.10404491f, -0.06802195f, -0.06882758f, 0.02932657f, 0.03298262f, 
    0.01927118f, -0.00491100f, 0.18232268f, -0.16746210f, -0.07225807f, 0.10383512f, 0.42292419f, 0.05146534f, 
    0.06338488f, 0.21966858f, -0.06359974f, -0.04087812f, 0.01475823f, -0.15582311f, 0.15400617f, 0.03813376f, 
    -0.01704202f, 0.03239757f, 0.00610026f, 0.00228443f, -0.13148342f, 0.00233776f, -0.19876604f, -0.06344780f, 
    0.07739635f, 0.03276960f, 0.14613901f, 0.16817762f, -0.07272753f, 0.03917610f, -0.02675785f, 0.01965931f, 
    0.03222759f, 0.05083808f, 0.02340816f, -0.06861299f, -0.03957841f, 0.14302419f, 0.01008941f, -0.09078512f, 
    0.07824357f, 0.00453440f, -0.15246460f, -0.08615781f, -0.04713660f, -0.01330471f, -0.09184400f, -0.10662272f, 
    0.01809982f, -0.11737115f, -0.06965476f, 0.11786550f, 0.03320793f, 0.02393617f, 0.05806647f, 0.10383197f, 
    0.04261569f, -0.01402405f, -0.06690291f, -0.02746424f, 0.23946717f, 0.08045226f, 0.12620428f, 0.08995888f, 
    0.06871811f, 0.16026187f, 0.12669674f, 0.27826944f, -0.03095338f, -0.01887570f, 0.07800320f, -0.13532786f, 
    0.19758658f, -0.07690111f, 0.21841758f, -0.02831761f, 0.08776706f, 0.02198823f, 0.14506075f, 0.02154893f, 
    0.03621205f, 0.03480301f, -0.00355591f, -0.08687995f, 0.09882607f, 0.10258223f, -0.08375116f, 0.12959391f, 
    0.06655967f, 0.08147018f, -0.02612787f, -0.15355925f, -0.01364242f, -0.06680689f, -0.01016437f, -0.00076718f, 
    0.07633471f, 0.04969902f, 0.07536373f, 0.01987722f, -0.02461826f, -0.00480879f, -0.07558043f, -0.02495010f, 
    0.10191515f, 0.12025838f, 0.05605146f, 0.04540479f, 0.04403284f, 0.19842945f, 0.09900129f, -0.14468229f, 
    0.09976366f, -0.03668638f, 0.06638925f, -0.05073024f, 0.00276907f, 0.01533217f, 0.09165745f, -0.09845030f, 
    0.10085331f, 0.18229289f, 0.07510868f, -0.15450811f, 0.00600649f, 0.16926964f, 0.17162901f, -0.00253053f, 
    -0.12826745f, 0.02266971f, 0.00879857f, -0.11244811f, -0.04869895f, -0.07325902f, -0.12357274f, 0.00769858f, 
    -0.01126517f, -0.07257158f, -0.03808555f, 0.07192798f, -0.05439245f, -0.16285501f, 0.02212326f, -0.09408646f, 
    -0.29277599f, 0.11719692f, -0.10580880f, 0.05776810f, -0.07438199f, 0.00611642f, 0.08441740f, 0.20657597f, 
    0.01623671f, 0.03277689f, -0.10606604f, -0.02586093f, 0.16360103f, 0.16530630f, -0.10898023f, -0.09335070f, 
    -0.13964851f, -0.18765071f, -0.09535882f, -0.03608268f, -0.05361846f, 0.11471757f, -0.04033385f, 0.00567612f, 
    0.14075649f, 0.14825919f, 0.16466464f, -0.03892653f, -0.05906219f, -0.00775643f, -0.04922543f, -0.03416454f, 
    0.00168148f, 0.04749450f, 0.01770564f, 0.06341619f, 0.11829425f, -0.22167188f, -0.02712104f, -0.12041274f, 
    -0.16325633f, -0.17793205f, -0.08233857f, -0.00139684f, 0.02938996f, 0.00666660f, -0.08679715f, -0.00450381f, 
    0.37913308f, 0.13449688f, 0.05945214f, 0.18192413f, -0.10472574f, 0.01851755f, -0.04398475f, 0.03554309f, 
    0.04555992f, 0.10045968f, 0.00152824f, 0.09998152f, 0.56742626f, 0.05176351f, -0.04911045f, -0.08560662f, 
    0.04736701f, -0.09736920f, -0.11179874f, -0.16377863f, -0.20179641f, -0.05279491f, 0.00880287f, -0.02765073f, 
    0.06190225f, 0.06655262f, 0.10026475f, 0.08554318f, -0.16131596f, 0.00478514f, -0.00019639f, 0.15107599f, 
    -0.06283016f, -0.11695248f, 0.07933237f, 0.25118843f, -0.07304791f, -0.03538320f, 0.13023828f, 0.01505196f, 
    -0.16788444f, -0.12726064f, 0.21187037f, -0.01278825f, -0.11217915f, -0.02419939f, -0.00250614f, 0.06715265f, 
    0.13347518f, -0.02017513f, 0.15200213f, -0.00309759f, 0.05450745f, 0.01941592f, -0.10210062f, 0.07183494f, 
    -0.08122806f, 0.02066918f, -0.12906818f, -0.05942126f, 0.11507000f, 0.16811080f, 0.18784557f, -0.07112931f, 
    -0.03491861f, 0.04282542f, 0.01333886f, -0.09742325f, 0.00938364f, 0.05022277f, 0.04364963f, -0.04841878f, 
    0.24679859f, -0.02166001f, 0.05173175f, -0.14550759f, -0.04351958f, -0.00021435f, 0.07907110f, 0.07457765f, 
    -0.25994283f, 0.04972123f, 0.04411708f, 0.04680046f, 0.27039540f, -0.03930636f, -0.02100933f, -0.04623568f, 
    -0.04445527f, -0.09267247f, -0.06255082f, 0.16276826f, -0.02327845f, 0.09786389f, 0.01064758f, -0.09803043f, 
    0.06095236f, 0.21667373f, 0.29232481f, 0.18816158f, 0.04232651f, -0.01208435f, 0.06813733f, 0.00570747f, 
    -0.01689956f, -0.05543102f, -0.18135531f, -0.07512182f, 0.09536437f, -0.16796230f, 0.19731028f, 0.02731225f, 
    0.08724520f, 0.18373029f, 0.18642187f, -0.02499808f, 0.03801520f, 0.01561659f, -0.30879167f, -0.00730734f, 
    0.23428851f, 0.14787531f, -0.04275709f, 0.05072029f, -0.11145151f, 0.04846474f, -0.07678326f, -0.05480587f, 
    0.09613828f, -0.09466231f, -0.08236991f, 0.14351682f, -0.27897131f, -0.18780179f, -0.11836805f, 0.16070244f, 
    0.05194712f, 0.02773722f, 0.05822031f, -0.07056173f, 0.00827947f, 0.00414104f, -0.12773754f, 0.27733827f, 
    -0.10526324f, -0.03125445f, -0.03521501f, 0.15608336f, -0.10163774f, 0.23234446f, 0.06392391f, 0.06636222f, 
    -0.04385763f, -0.06839757f, -0.05926545f, 0.02319199f, 0.09174027f, -0.15237138f, 0.17494552f, -0.21539666f, 
    0.10371474f, 0.06799425f, 0.02164895f, 0.14719754f, 0.01666220f, 0.02922475f, 0.03606512f, 0.06972347f, 
    0.12170494f, 0.07439402f, -0.13801913f, -0.02211327f, 0.08115919f, -0.10735109f, -0.12169220f, -0.10082939f, 
    0.17314212f, -0.12133221f, 0.14365776f, 0.00060166f, -0.21457179f, -0.17697622f, 0.21407554f, 0.08481985f, 
    -0.15617552f, 0.09595969f, 0.05487342f, 0.11403281f, 0.01369370f, 0.00325461f, -0.08856805f, -0.00879464f, 
    0.25289142f, 0.05842185f, -0.22793938f, -0.08788444f, -0.03998672f, 0.00957630f, 0.03252883f, 0.17686842f, 
    0.01664774f, -0.07690647f, 0.04817775f, -0.09215067f, -0.37504783f, 0.10051329f, -0.31541333f, 0.03011704f, 
    0.02744181f, -0.04787920f, 0.13471605f, -0.15469970f, 0.20710763f, -0.08504897f, 0.01573647f, 0.05289213f, 
    0.05104120f, -0.00435979f, -0.16156808f, 0.06774324f, 0.13386999f, -0.03084262f, -0.03242061f, 0.06927272f, 
    0.09385168f, 0.04113355f, -0.10946847f, 0.01215999f, -0.13844970f, -0.10528981f, -0.16495657f, -0.09933085f, 
    -0.03796917f, -0.03217910f, -0.02262134f, 0.08110434f, 0.12418070f, -0.00266896f, 0.00342399f, -0.03985964f, 
    -0.15372619f, -0.00271507f, 0.18283731f, 0.06843528f, -0.02845914f, 0.03508187f, -0.01675381f, 0.08534312f, 
    0.02904285f, -0.03983194f, 0.01163327f, 0.11347421f, -0.01829601f, -0.07896766f, -0.01479354f, 0.12151437f, 
    -0.15114994f, -0.04296565f, -0.04429072f, 0.04379293f, 0.07110413f, 0.00810104f, -0.01251059f, -0.06039925f, 
    -0.19052878f, 0.13276359f, -0.08961191f, -0.03935378f, 0.03309020f, -0.02588737f, -0.05623486f, 0.15132982f, 
    -0.00013324f, -0.06369419f, 0.01343967f, 0.06197328f, 0.10018685f, -0.11620381f, 0.07478368f, -0.10747202f, 
    -0.02991506f, 0.06601126f, -0.04581777f, 0.17308699f, 0.04748780f, -0.04353903f, -0.05257487f, -0.08864023f, 
    -0.02710245f, 0.04413885f, -0.09569802f, 0.11765751f, -0.05038477f, 0.02018187f, 0.03262946f, -0.06873246f, 
    -0.02166781f, -0.06681661f, 0.12633529f, 0.00680324f, 0.31281072f, 0.26616511f, -0.49076822f, 0.21177179f, 
    0.00388150f, 0.08516839f, 0.08596329f, -0.01567702f, 0.07290168f, 0.13330522f, -0.08334144f, 0.09391494f, 
    -0.21669784f, -0.02719660f, -0.09558479f, -0.02510231f, 0.03528693f, -0.13791510f, -0.02231609f, 0.00764295f, 
    0.10651065f, -0.01642873f, -0.03861365f, 0.03286133f, -0.00701621f, -0.22660019f, 0.29594484f, 0.11852840f, 
    0.03614722f, 0.06506743f, 0.08450120f, 0.02288183f, -0.07869358f, 0.13144910f, 0.02925723f, -0.03583406f, 
    0.00992012f, -0.09413563f, 0.10875165f, 0.09695505f, 0.01840185f, 0.10459267f, 0.02737330f, -0.18177240f, 
    0.13439693f, 0.07309692f, 0.11614754f, -0.03342007f, -0.06998909f, -0.31753787f, -0.10961354f, -0.00931283f, 
    0.13797194f, 0.33549011f, 0.13101022f, 0.15697615f, -0.03515039f, -0.15474173f, 0.04509847f, -0.01345333f, 
    0.01270661f, -0.17018199f, -0.23147494f, 0.08484289f, 0.11515979f, -0.08201455f, 0.16310079f, -0.00626490f, 
    0.04277988f, 0.01966716f, 0.08850350f, 0.08489911f, -0.04990371f, 0.12333418f, 0.11484528f, 0.08630612f, 
    0.10735784f, 0.06290415f, 0.06190146f, 0.10361438f, 0.00723146f, 0.04670352f, -0.08981149f, -0.04314262f, 
    0.08953556f, -0.48517075f, 0.27173224f, -0.41036454f, 0.23609501f, -0.08016857f, 0.01900651f, 0.20268017f, 
    -0.03215640f, -0.12490904f, 0.10721633f, 0.06055099f, -0.38213146f, 0.13684329f, 0.16430360f, 0.07655669f, 
    -0.17404440f, -0.09488238f, -0.10426325f, 0.12525918f, 0.10633338f, -0.02404920f, 0.11721355f, -0.03687036f, 
    0.07740290f, -0.09476827f, 0.00148955f, -0.11003464f, 0.13254210f, -0.01529968f, -0.17351797f, -0.03036073f, 
    0.07236250f, 0.01068191f, 0.00188167f, -0.00557709f, -0.09346796f, 0.18950711f, -0.23528370f, -0.00922147f, 
    0.20177843f, 0.01929828f, -0.02346349f, 0.13527471f, 0.07469369f, 0.15902437f, -0.06960259f, -0.19464046f, 
    -0.13496558f, 0.12417559f, -0.00731482f, 0.02767006f, 0.07022620f, -0.05274775f, 0.11526274f, 0.09797815f, 
    0.02721762f, -0.00674247f, 0.06116351f, -0.08170859f, 0.00290360f, -0.16938958f, -0.25760421f, 0.15336363f, 
    0.11820553f, 0.02095641f, 0.08410586f, 0.00105850f, -0.04169484f, 0.01328556f, 0.01524665f, 0.17205243f, 
    0.05595122f, 0.29875940f, -0.03144298f, -0.12838517f, -0.03308587f, -0.18016537f, 0.02273921f, -0.00524643f, 
    0.05139976f, -0.03786482f, 0.09282497f, 0.07955657f, -0.08025814f, 0.03083551f, 0.03151555f, -0.12897040f, 
    -0.09512627f, -0.07389355f, -0.04563160f, 0.04329243f, 0.10083547f, -0.03814667f, 0.01472890f, 0.03582027f, 
    -0.03431992f, -0.01986466f, -0.04659428f, -0.05119509f, -0.11672373f, -0.02351961f, 0.01590402f, 0.08731577f, 
    -0.04708114f, -0.07369743f, 0.08836030f, -0.02874972f, -0.08505102f, 0.21984856f, -0.19812806f, 0.17396083f, 
    -0.07413423f, -0.07916382f, -0.06657110f, -0.03437179f, -0.09343041f, -0.09629422f, 0.08631747f, 0.03282849f, 
    -0.08179661f, 0.01907383f, 0.09925868f, 0.07902448f, 0.10489819f, 0.05082254f, -0.03634242f, 0.01897427f, 
    -0.17091018f, 0.08508869f, 0.13812679f, -0.14791635f, -0.01769003f, 0.01583502f, -0.01414684f, -0.14020239f, 
    -0.06681452f, 0.10149465f, 0.00151224f, 0.12014597f, 0.11353535f, -0.00413689f, 0.12211222f, -0.05285869f, 
    0.09541796f, 0.09980165f, 0.12540838f, -0.11527343f, 0.06733340f, -0.13141504f, -0.00713821f, -0.02559985f, 
    0.04764032f, 0.01809659f, -0.08829643f, -0.04933400f, 0.05385391f, 0.24346541f, -0.14507015f, 0.25549436f, 
    -0.13395905f, -0.02354625f, 0.05845032f, -0.06445663f, -0.04467202f, -0.04194538f, -0.04717200f, -0.07445119f, 
    -0.14701614f, -0.10539018f, -0.07810229f, 0.02027592f, 0.03237584f, 0.11380650f, 0.09066191f, 0.07831091f, 
    -0.11753353f, 0.09240334f, -0.02490247f, -0.01248650f, 0.01876931f, 0.25943515f, 0.02252300f, 0.07880775f, 
    0.10728416f, -0.03637964f, -0.04863927f, 0.05767608f, 0.00227624f, -0.06462667f, 0.05048733f, 0.00929843f, 
    0.07670794f, -0.02701151f, 0.20275807f, 0.18213722f, 0.02826727f, -0.00565154f, -0.07463007f, -0.21277130f, 
    0.05122710f, 0.20836700f, -0.00999429f, -0.02249324f, 0.13664259f, -0.16681336f, 0.15597714f, -0.15722628f, 
    -0.04244001f, -0.03723706f, -0.04545575f, -0.01773213f, -0.05521721f, 0.17339557f, 0.12122279f, 0.06863631f, 
    -0.16876800f, -0.11119822f, -0.19065671f, -0.18690909f, 0.03173112f, -0.00042444f, 0.02277615f, 0.10306264f, 
    -0.08350210f, -0.01598084f, 0.20062757f, -0.08491178f, 0.17567684f, 0.16877966f, 0.17482828f, 0.15962327f, 
    0.02935837f, 0.09286771f, 0.07412516f, -0.05095305f, 0.08901648f, 0.14549778f, 0.15249570f, 0.26359445f, 
    0.18037497f, 0.15283480f, -0.04881317f, 0.01860617f, 0.06865261f, 0.06976535f, 0.05279572f, -0.11289627f, 
    -0.13374770f, -0.13965164f, -0.05641096f, -0.05900617f, 0.14595763f, 0.07863659f, 0.35108322f, -0.02554133f, 
    0.16039588f, 0.10805161f, 0.16194804f, -0.04143969f, -0.08879206f, -0.02330853f, -0.01690211f, 0.01851727f, 
    0.26742974f, 0.07381387f, 0.29134086f, 0.13831657f, 0.04253764f, 0.07628092f, 0.06542025f, -0.18185098f, 
    0.01922966f, -0.06604384f, 0.00099727f, -0.14089151f, -0.21915899f, 0.11297045f, -0.12166744f, 0.00417838f, 
    -0.04744647f, -0.02401310f, 0.02131923f, -0.12367726f, -0.11108480f, 0.01733904f, 0.08098830f, 0.00740888f, 
    -0.15093420f, -0.14442758f, 0.01832424f, -0.10240550f, 0.01409966f, 0.02074693f, -0.06528541f, 0.16480172f, 
    0.07510948f, 0.02929039f, 0.01191759f, 0.07497984f, -0.12672491f, -0.34689200f, 0.41013727f, -0.35224950f, 
    -0.22184205f, -0.05517506f, -0.10706057f, -0.00891422f, -0.04638429f, -0.15697333f, 0.16117336f, -0.12116868f, 
    0.32721466f, 0.27801329f, 0.24050844f, 0.17536253f, 0.13292706f, 0.09261536f, -0.07650544f, -0.05593908f, 
    -0.06559549f, -0.04614636f, -0.06017950f, -0.01725142f, 0.10953848f, 0.35203090f, -0.16608496f, 0.04045756f, 
    -0.03350385f, -0.08847955f, -0.02827109f, -0.00358288f, 0.04847170f, -0.07990298f, -0.01850410f, 0.09091268f, 
    -0.07446112f, 0.05882676f, -0.00069237f, -0.10854606f, 0.03514543f, -0.11739086f, 0.00806029f, 0.17702197f, 
    0.02567922f, -0.04951988f, -0.18111415f, 0.07519855f, -0.05751545f, 0.24122755f, 0.00919467f, -0.10598869f, 
    -0.00235292f, -0.24622108f, 0.03654042f, -0.02228123f, -0.01589005f, 0.09925110f, 0.05722049f, 0.13451432f, 
    -0.05932540f, -0.16637637f, 0.11998884f, -0.31180194f, -0.05600536f, 0.00464678f, -0.16770913f, 0.11924343f, 
    0.04543108f, 0.05658450f, 0.05969789f, -0.02236627f, 0.02629719f, -0.12953217f, -0.03173084f, 0.05749902f, 
    -0.05245062f, -0.07116263f, -0.05792639f, -0.07898838f, -0.12886378f, 0.01821393f, -0.07457935f, 0.00308462f, 
    -0.24081272f, 0.12428906f, -0.55745715f, 0.16709480f, -0.12617055f, -0.02473144f, -0.03011062f, -0.12110913f, 
    0.00106360f, 0.16192727f, -0.13786247f, 0.07040534f, 0.34104344f, 0.14274533f, 0.00487840f, 0.07314664f, 
    0.14475670f, 0.21465859f, 0.13079859f, 0.00848016f, -0.08544698f, 0.12616123f, -0.08108409f, 0.05349234f, 
    -0.20692329f, -0.00699419f, -0.17651552f, -0.16521324f, -0.01966053f, -0.08063416f, 0.26607618f, 0.10437474f, 
    -0.12760511f, -0.03521948f, 0.00478244f, 0.04702529f, 0.13003787f, -0.35036364f, 0.12655784f, -0.15313715f, 
    0.06401775f, -0.08897051f, 0.09418423f, -0.00669295f, -0.10491800f, -0.11231722f, 0.03373127f, 0.21761969f, 
    0.20681219f, 0.05012181f, 0.17245086f, 0.17581242f, 0.01774625f, 0.09300036f, -0.09915638f, -0.02740046f, 
    -0.02418610f, -0.09243845f, -0.08564769f, 0.03289696f, -0.21022944f, 0.04028323f, -0.10989081f, -0.26884860f, 
    -0.02615275f, 0.01664537f, -0.09773987f, 0.11950369f, 0.01204685f, 0.04676044f, 0.05789209f, -0.01828384f, 
    0.12423261f, -0.06167839f, 0.10399707f, 0.14360574f, 0.08190458f, 0.04417946f, -0.02985942f, 0.11958794f, 
    -0.01885254f, -0.09730815f, -0.01352724f, -0.01039235f, 0.16093807f, -0.02125277f, -0.04505222f, 0.24755092f, 
    0.03349951f, 0.04488428f, 0.02148777f, -0.10318279f, 0.09856357f, 0.12646687f, 0.03476714f, 0.10805735f, 
    0.12411425f, 0.31287885f, 0.02392183f, -0.08355442f, 0.00891269f, -0.06459650f, -0.02532183f, 0.07019701f, 
    0.14961027f, 0.06693964f, -0.00650996f, -0.10237536f, -0.11992405f, -0.04300014f, -0.01538541f, 0.04303567f, 
    0.10447093f, -0.03963158f, 0.06616189f, -0.13090360f, -0.16673569f, -0.07558327f, -0.25168210f, -0.10513799f, 
    -0.19428425f, -0.03884297f, -0.05502976f, 0.07200491f, 0.09635884f, -0.24891931f, -0.07979139f, 0.06632409f, 
    -0.05895027f, 0.10545078f, -0.05739250f, -0.37945703f, 0.09259310f, 0.12629128f, 0.02445497f, -0.08436495f, 
    -0.08421757f, -0.11405758f, 0.10511102f, -0.01089667f, -0.07382213f, -0.08359337f, 0.00436000f, -0.25761950f, 
    0.17543650f, -0.00402446f, -0.02688551f, -0.07991380f, -0.03513258f, 0.02431309f, 0.17275095f, -0.11888467f, 
    0.14083692f, 0.04479539f, 0.06456355f, 0.02299962f, 0.04881092f, -0.04634929f, 0.00047586f, -0.06510600f, 
    0.10371221f, -0.10191719f, 0.02110554f, 0.09938035f, -0.03019534f, -0.07204702f, -0.27212226f, -0.22946799f, 
    -0.10283952f, 0.03927173f, 0.06922434f, -0.21604902f, 0.15672037f, 0.08316956f, 0.23844337f, -0.01411621f, 
    -0.10542003f, 0.07354997f, 0.02749209f, -0.19946450f, 0.23512471f, 0.17483506f, 0.22278911f, -0.12079751f, 
    0.05189510f, 0.09431292f, -0.13461587f, 0.05363392f, -0.05915440f, -0.07654391f, -0.28586456f, -0.16821036f, 
    0.06965432f, -0.03583498f, -0.31729043f, 0.52931547f, 0.06983909f, -0.11151522f, 0.15812045f, 0.15570363f, 
    -0.17998998f, -0.02632681f, 0.19390070f, -0.06123927f, 0.12063913f, -0.11179775f, -0.06955268f, -0.05903644f, 
    -0.23778193f, 0.08714008f, 0.11517141f, 0.19400807f, 0.16895771f, 0.18216777f, 0.44185883f, 0.32551062f, 
    -0.01910458f, -0.05355681f, 0.01580600f, -0.21568553f, 0.02571076f, -0.03619056f, 0.13525067f, -0.27497479f, 
    -0.10093769f, -0.12247285f, 0.04884285f, -0.00647688f, 0.00390916f, -0.05440905f, -0.14861895f, 0.09169420f, 
    -0.00555350f, 0.37139842f, 0.26593086f, 0.09389865f, 0.16215640f, 0.09344929f, 0.18033247f, 0.42423588f, 
    0.30044985f, 0.06640810f, -0.09052908f, -0.16066831f, 0.01250994f, -0.17403956f, 0.00324782f, -0.08877863f, 
    -0.18732713f, -0.14135015f, -0.01048938f, 0.09819370f, 0.38721386f, -0.17470327f, 0.01153116f, -0.26597896f, 
    -0.03222609f, -0.01358022f, 0.11591263f, 0.01353637f, -0.07588768f, 0.19512834f, -0.06346788f, -0.00104260f, 
    0.04976777f, -0.10785073f, -0.00420091f, -0.14459129f, 0.00020496f, -0.02352628f, 0.03117306f, -0.05278138f, 
    -0.11379340f, -0.12334899f, -0.00691196f, 0.16686572f, -0.10908445f, -0.11177953f, -0.26062945f, -0.11468832f, 
    -0.09464317f, -0.04716349f, 0.11618159f, 0.03659888f, 0.17237033f, 0.08561032f, 0.29511556f, 0.23776001f, 
    0.13540235f, -0.05758989f, -0.03461534f, -0.14438397f, -0.06585745f, 0.04197618f, 0.03724909f, 0.04163215f, 
    -0.09424173f, -0.11361940f, 0.13735573f, -0.02989203f, -0.04267517f, 0.09047753f, 0.19126369f, -0.03961398f, 
    -0.00039884f, 0.11329363f, -0.02613183f, 0.02839254f, 0.07740673f, -0.07804820f, 0.02836065f, 0.03843935f, 
    0.03310356f, -0.10255259f, -0.04731030f, 0.19258484f, 0.07472356f, 0.04000951f, 0.09356108f, 0.08415590f, 
    -0.04346254f, -0.23985036f, -0.10809917f, 0.02932138f, 0.27312404f, 0.08420292f, -0.05880413f, 0.09649991f, 
    0.10958906f, 0.06091338f, 0.08945951f, 0.00631378f, 0.00581323f, -0.08986529f, 0.00923323f, 0.00222979f, 
    0.18898165f, 0.03938434f, 0.02651302f, -0.14935246f, -0.04176987f, 0.14945523f, 0.05243279f, 0.08045967f, 
    0.08438655f, 0.07662401f, 0.03448404f, 0.12342963f, 0.02029923f, -0.01875176f, 0.14700286f, 0.14535899f, 
    0.04014612f, 0.02957178f, 0.21150936f, 0.05364675f, 0.08455390f, -0.00422390f, -0.03056771f, 0.12243798f, 
    -0.02526130f, -0.02745730f, 0.02429017f, -0.02083602f, -0.03360782f, -0.02167375f, 0.11894227f, -0.10445663f, 
    -0.00565276f, 0.03188259f, 0.03576902f, -0.11397386f, -0.08440296f, -0.17875287f, 0.10634890f, 0.25531223f, 
    0.03191548f, -0.04865832f, -0.01713537f, -0.13315801f, -0.07259434f, 0.04876404f, 0.05483118f, 0.25662443f, 
    -0.13325717f, -0.26105779f, -0.11967841f, -0.13356091f, -0.06792654f, -0.06427606f, 0.27259734f, -0.26234683f, 
    0.05202752f, -0.08685545f, 0.01230196f, -0.02295504f, 0.32421359f, 0.09867684f, -0.04519675f, -0.13125181f, 
    0.04225004f, 0.18143627f, 0.07761233f, 0.10543121f, 0.06582034f, 0.11561297f, 0.14011866f, 0.07087288f, 
    -0.13297917f, 0.06216288f, 0.03464119f, 0.11394496f, -0.15581536f, 0.01771578f, 0.18502991f, -0.27252916f, 
    0.17458819f, 0.11522832f, -0.08166932f, 0.06413603f, -0.07355566f, 0.16129862f, -0.03177061f, 0.01204261f, 
    -0.07267030f, 0.05761298f, -0.14163357f, 0.03804224f, -0.31756866f, -0.13592137f, -0.07022864f, -0.16539685f, 
    0.07540203f, -0.10570717f, -0.19517089f, -0.07522341f, -0.00606147f, 0.13611740f, 0.02145908f, -0.10341179f, 
    -0.11493587f, -0.03288474f, 0.06670287f, 0.06525711f, 0.05139479f, 0.25411835f, -0.15080166f, -0.08855978f, 
    -0.10645936f, -0.09209111f, -0.11909705f, 0.07709829f, -0.31011966f, -0.01910409f, -0.17652842f, -0.07028802f, 
    0.01218792f, -0.11925300f, 0.23020758f, 0.04451204f, -0.02517203f, 0.04336679f, -0.13429496f, -0.09673195f, 
    0.16165343f, -0.13677378f, -0.05098632f, 0.05583543f, 0.13645782f, -0.04806709f, -0.11032633f, 0.05082485f, 
    0.02435380f, 0.09370220f, 0.22914705f, 0.06385005f, 0.16391282f, 0.07711453f, 0.08560671f, 0.22742462f, 
    0.10628758f, -0.03997931f, -0.06629810f, 0.10870952f, 0.00393209f, 0.16443256f, 0.16346882f, 0.06680782f, 
    -0.04859649f, 0.05596625f, -0.01115017f, 0.04403251f, -0.10443130f, 0.04505930f, -0.05280849f, -0.12724397f, 
    -0.10062884f, 0.02847657f, 0.00514439f, 0.18802430f, 0.05683054f, 0.00313422f, 0.19782412f, 0.07080702f, 
    -0.07729484f, -0.23056214f, -0.18424219f, -0.03734280f, 0.06334598f, 0.11381420f, 0.02338237f, 0.05377072f, 
    0.10307895f, 0.01779705f, 0.01811879f, 0.14831182f, 0.08867583f, 0.07814373f, 0.08065842f, 0.03092568f, 
    -0.14710940f, -0.07010388f, -0.06693061f, -0.04776897f, 0.10656918f, -0.06759954f, 0.02125759f, -0.03148085f, 
    -0.02113749f, 0.13460475f, 0.40522218f, -0.00091903f, 0.22724397f, 0.11965106f, 0.00244400f, 0.18532461f, 
    -0.04889257f, -0.00016503f, 0.05009815f, 0.02770638f, 0.07200526f, 0.28107727f, -0.16406122f, 0.11378025f, 
    0.03814091f, 0.23719765f, 0.17221834f, 0.01370021f, 0.09011894f, 0.02716739f, 0.17318591f, 0.02087736f, 
    0.03031049f, -0.03917209f, -0.03219885f, 0.04038851f, -0.13090642f, -0.13050151f, -0.09862880f, -0.03122501f, 
    0.05123006f, 0.14733982f, 0.00361426f, 0.07355450f, -0.21492441f, 0.17251572f, -0.11303641f, -0.15351774f, 
    0.05629112f, 0.05459448f, 0.05274631f, -0.04268238f, 0.08468993f, 0.04183731f, 0.10185207f, 0.13785100f, 
    -0.07523341f, -0.22893903f, 0.04459489f, -0.17182438f, 0.04503186f, 0.10789506f, -0.04607017f, 0.01659892f, 
    0.19863132f, 0.04797040f, -0.03680436f, 0.12925293f, -0.02576710f, -0.05369044f, 0.23031317f, 0.11997247f, 
    0.07100064f, 0.01116848f, -0.15340891f, 0.01560409f, -0.05687007f, -0.04350491f, -0.24759455f, -0.09918262f, 
    0.02586359f, -0.03946562f, 0.09897642f, 0.15446329f, -0.13670224f, -0.10819104f, -0.13709800f, 0.00173723f, 
    0.02892420f, 0.02017228f, 0.04978950f, 0.06728178f, -0.09463155f, 0.05965926f, 0.01942633f, 0.04183625f, 
    0.10206150f, -0.04397786f, -0.14423366f, -0.10377876f, -0.13450450f, -0.01668838f, -0.07108707f, -0.22096446f, 
    0.14630917f, 0.17478585f, 0.04988060f, -0.00840404f, 0.17354225f, 0.11834349f, 0.05096908f, 0.07399935f, 
    0.03685510f, 0.01669827f, -0.02925069f, -0.15811446f, 0.02797014f, 0.26086992f, 0.23467898f, 0.03926092f, 
    0.16432738f, 0.16959365f, 0.20483267f, 0.06231579f, 0.14833501f, -0.07582118f, 0.13408819f, -0.04701451f, 
    0.32790238f, 0.03379813f, 0.24329907f, 0.19401598f, 0.13886245f, 0.10239826f, 0.12845564f, 0.04532880f, 
    0.04111649f, 0.07294802f, 0.02043460f, -0.07031190f, 0.22264223f, 0.22746782f, -0.00952697f, -0.00193670f, 
    -0.04700520f, 0.01192453f, -0.03819806f, -0.15367548f, 0.04359359f, 0.00397150f, -0.13480009f, -0.00214072f, 
    -0.13050917f, 0.04280960f, 0.00050509f, 0.00930391f, 0.03203643f, -0.16829339f, -0.13401628f, -0.06456842f, 
    0.02630771f, 0.09425818f, -0.18069685f, 0.04758556f, -0.28342620f, 0.02003601f, 0.14951523f, -0.07082604f, 
    0.03024765f, 0.06081578f, 0.04229501f, 0.12168116f, 0.04831997f, -0.03450993f, -0.02683973f, -0.09064598f, 
    -0.04874275f, 0.04207731f, 0.01368322f, -0.12981045f, -0.02778993f, 0.05833025f, 0.13023864f, 0.05272478f, 
    0.05047457f, 0.10230973f, 0.10498606f, -0.03241251f, 0.15808220f, 0.14982535f, -0.07803021f, -0.11413713f, 
    0.04786070f, -0.00924408f, 0.03550774f, 0.06202313f, 0.06649929f, -0.00387986f, -0.01362921f, -0.00704896f, 
    -0.20448168f, 0.21527250f, 0.19534247f, 0.00112160f, 0.04892473f, -0.12099931f, 0.07406282f, 0.20458668f, 
    -0.13313064f, -0.04591322f, -0.08770399f, -0.02933319f, -0.07305623f, 0.25626597f, 0.12441441f, 0.09012004f, 
    -0.05805292f, -0.11399666f, -0.00505493f, 0.00545322f, -0.12007241f, 0.01419609f, -0.11713763f, -0.16517690f, 
    -0.05153767f, 0.11709692f, 0.08808611f, 0.02564897f, -0.05158086f, -0.06683456f, -0.07491041f, -0.00837651f, 
    -0.05295400f, -0.13416474f, -0.06122975f, 0.00845745f, 0.25920719f, 0.22689690f, -0.21472578f, -0.09673212f, 
    -0.11183529f, 0.00901794f, 0.02622015f, 0.07425641f, -0.13734323f, -0.07502007f, -0.09741028f, -0.18580732f, 
    0.46409073f, 0.09720938f, 0.15345617f, 0.08523329f, -0.10673539f, 0.06699250f, -0.18526588f, -0.06668590f, 
    0.07581311f, 0.08043505f, 0.01008685f, -0.11361885f, -0.03486003f, -0.12592661f, -0.22519867f, -0.11401989f, 
    -0.03175649f, 0.03162002f, -0.05680425f, -0.14021915f, 0.08540141f, 0.04463568f, -0.08571130f, 0.11305456f, 
    0.04623128f, -0.03338994f, 0.08126949f, 0.10442762f, -0.06256934f, 0.04092797f, -0.14461456f, -0.01463331f, 
    -0.07644429f, 0.00008071f, 0.20190939f, 0.10721105f, -0.14765042f, -0.18678923f, 0.12139882f, 0.24120729f, 
    0.14809364f, -0.01141781f, 0.05621250f, -0.06669821f, 0.13374908f, 0.14075500f, 0.06755578f, 0.25125784f, 
    0.24004249f, 0.13699305f, 0.21745810f, 0.09674534f, 0.09955924f, 0.17388375f, -0.08525836f, 0.16352837f, 
    -0.01602957f, -0.00741663f, -0.15550369f, -0.02058452f, 0.06746145f, -0.06892912f, 0.14336251f, 0.28568399f, 
    -0.01018972f, -0.07592325f, -0.03930830f, -0.04515935f, 0.15375677f, -0.12798627f, -0.01127098f, -0.04760756f, 
    -0.03603590f, -0.06082517f, -0.17380741f, -0.09754536f, 0.00901311f, 0.03191281f, 0.05086165f, 0.02402462f, 
    -0.05203085f, 0.08910655f, 0.13047805f, 0.00231197f, 0.18799993f, -0.06895186f, -0.13247506f, 0.06419200f, 
    0.05556647f, 0.06659862f, -0.03791981f, -0.01718459f, -0.13593037f, -0.06090505f, -0.05378379f, -0.25151074f, 
    0.03512720f, -0.00593481f, 0.00070229f, 0.02617404f, -0.01275277f, 0.03333774f, -0.00308760f, 0.03351983f, 
    0.00937064f, -0.03419117f, -0.03472369f, -0.03724793f, -0.01838785f, 0.03332082f, 0.01355145f, -0.01943970f, 
    0.03126493f, -0.05523362f, -0.01281449f, 0.02817875f, 0.00517964f, 0.02246748f, -0.04087720f, 0.01010835f, 
    -0.03787773f, 0.02289637f, -0.00536170f, 0.00997166f, -0.02740995f, 0.04009810f, 0.02711603f, -0.03133829f, 
    -0.05471957f, 0.01697046f, -0.03087875f, 0.02262117f, -0.02940025f, -0.05139440f, 0.00095548f, 0.02908914f, 
    0.00305434f, -0.03378114f, -0.03185536f, 0.01639575f, -0.02485097f, 0.02337377f, 0.01074839f, -0.05184762f, 
    -0.02955731f, 0.02213743f, 0.00288952f, 0.04218858f, 0.03619216f, 0.02236605f, -0.04969714f, 0.02218739f, 
    -0.03824626f, 0.01132373f, -0.00707276f, -0.03467978f, -0.03013598f, -0.02140414f, -0.03530554f, 0.01944593f, 
    -0.01525631f, -0.00111612f, 0.01055402f, -0.00403680f, -0.00787050f, -0.03301449f, -0.02779940f, -0.01463505f, 
    -0.02085979f, -0.00359385f, 0.02575931f, -0.04757319f, -0.02014035f, -0.04996780f, -0.05994738f, -0.04969037f, 
    -0.06238806f, 0.00016672f, -0.03713668f, -0.02621121f, -0.02297502f, -0.01807369f, 0.00709772f, 0.01479204f, 
    -0.02252392f, 0.02390738f, -0.02128083f, -0.03211260f, -0.01195952f, 0.01245917f, 0.02989566f, -0.03189819f, 
    0.01635688f, 0.03556729f, -0.02347513f, 0.03441372f, -0.03587655f, 0.03822218f, 0.04597769f, 0.02083503f, 
    -0.02858321f, -0.02834752f, 0.04575170f, 0.01948886f, -0.01254924f, -0.00473118f, 0.03503612f, -0.00760930f, 
    0.03342268f, 0.02170510f, -0.04636542f, 0.00905552f, 0.03700027f, -0.04107086f, 0.01498262f, 0.03562361f, 
    -0.00851378f, -0.00106333f, -0.02436870f, -0.01881343f, -0.04596538f, -0.02609090f, -0.02385968f, 0.04429997f, 
    -0.00467504f, 0.03950659f, 0.01443034f, -0.06022835f, -0.00792582f, -0.02373360f, 0.02780787f, -0.01445116f, 
    -0.00458250f, 0.04049536f, 0.02255242f, 0.00639965f, -0.00497337f, -0.00147888f, 0.00501006f, -0.03063903f, 
    0.03901676f, 0.00506369f, 0.02736846f, -0.03567252f, -0.04705304f, -0.05044837f, 0.01047697f, 0.04436793f, 
    -0.01608328f, -0.04144302f, -0.05219940f, -0.04337217f, 0.01642200f, 0.00899242f, 0.04562892f, -0.03571671f, 
    -0.02747071f, 0.01005370f, -0.00982051f, -0.03238020f, 0.03461685f, -0.05784929f, 0.01922295f, 0.01240601f, 
    0.01930029f, 0.03590517f, -0.02222812f, -0.01424719f, 0.04004300f, -0.03208810f, -0.02255233f, 0.00864061f, 
    -0.02102191f, 0.03132268f, 0.01933398f, -0.03082030f, -0.03379317f, 0.04697381f, -0.05567492f, -0.04602880f, 
    0.00178813f, -0.00375752f, -0.03563039f, -0.00091223f, 0.03612701f, -0.03156588f, -0.04729727f, 0.01546661f, 
    0.02863275f, -0.01269919f, -0.04055072f, -0.00114034f, -0.04073156f, 0.03822127f, -0.05898836f, -0.01450095f, 
    -0.01908740f, 0.04664914f, -0.01124760f, 0.02743778f, 0.04795733f, 0.01067218f, 0.00341115f, -0.01495561f, 
    -0.05181476f, 0.01273182f, -0.02843969f, -0.02171935f, -0.01412025f, -0.02509192f, 0.02757012f, 0.02735428f, 
    0.02226122f, -0.01740316f, -0.03795670f, 0.00647182f, -0.01972155f, 0.01159713f, 0.00462287f, -0.01533305f, 
    0.03509150f, 0.04147240f, -0.03307917f, -0.01993421f, -0.04078067f, -0.01512611f, -0.04758477f, -0.02758887f, 
    -0.05026217f, 0.02268661f, -0.00067182f, -0.02289771f, -0.01439835f, 0.00347179f, -0.04465939f, 0.02795888f, 
    0.02765061f, -0.03431338f, 0.02133249f, -0.03282521f, -0.04694558f, 0.00994208f, 0.02314731f, -0.04381345f, 
    -0.04866003f, -0.00435135f, -0.02327732f, -0.00078058f, 0.05335173f, -0.02515061f, 0.04459217f, -0.00543824f, 
    0.03112893f, -0.04961106f, 0.03606166f, -0.06282347f, 0.03206451f, -0.03490076f, -0.01118338f, 0.00207045f, 
    -0.00694358f, -0.01495388f, -0.02844670f, 0.00196785f, -0.02761371f, -0.04073103f, 0.02059225f, -0.04402583f, 
    0.03983855f, 0.02078904f, 0.01093013f, 0.02437072f, -0.00500247f, 0.03110035f, -0.00810204f, 0.02220923f, 
    -0.02164487f, -0.00461107f, -0.01925041f, 0.04080729f, 0.02813716f, -0.04603097f, -0.04867286f, -0.02108186f, 
    -0.01719806f, -0.02528099f, 0.04649931f, 0.01284704f, 0.02568815f, -0.04675350f, -0.03071070f, -0.00002704f, 
    0.04415422f, 0.02063332f, -0.01398844f, 0.04392049f, -0.01499107f, -0.04370437f, 0.03161862f, -0.04626867f, 
    -0.05065649f, -0.02612006f, 0.02488888f, 0.00274813f, 0.03183155f, 0.04589680f, 0.03046111f, -0.05697462f, 
    0.02495547f, 0.02839511f, 0.02588889f, -0.02839490f, -0.00679849f, -0.02883218f, -0.02809335f, -0.04286159f, 
    -0.00303638f, -0.01123806f, -0.02674249f, -0.03718717f, -0.03768748f, -0.02009539f, 0.00925859f, -0.00974636f, 
    -0.05476221f, 0.02879101f, 0.03910360f, 0.02045381f, -0.02997139f, -0.05677297f, -0.01414089f, -0.04518178f, 
    0.03112633f, 0.00692328f, -0.04991534f, 0.03896837f, -0.04596272f, -0.03114788f, -0.02828879f, 0.04022189f, 
    -0.00877897f, -0.00809420f, 0.02587745f, -0.02571112f, 0.02629451f, 0.02583287f, -0.04900419f, -0.05463140f, 
    0.00933010f, -0.02490854f, -0.01928180f, -0.00250136f, 0.04415502f, -0.05173029f, 0.02220947f, 0.00097481f, 
    -0.03145259f, -0.03526984f, -0.00457404f, 0.00091799f, 0.02397801f, -0.00346708f, -0.00106028f, -0.04438903f, 
    -0.01417416f, -0.02227887f, -0.02052444f, -0.01811153f, -0.00263881f, 0.00512062f, 0.04634070f, 0.02402795f, 
    -0.04444543f, -0.05552630f, -0.02387114f, 0.02957130f, -0.02750805f, -0.05569987f, -0.03896187f, -0.00189783f, 
    -0.03289078f, -0.01858072f, -0.00163091f, -0.05743267f, -0.01979147f, 0.03640893f, -0.04573252f, 0.03914845f, 
    -0.02306748f, -0.00206398f, -0.00321111f, -0.05745082f, -0.02644979f, -0.00313053f, 0.00631935f, 0.03078206f, 
    0.04300328f, 0.01378766f, -0.04409501f, -0.05382651f, 0.00016078f, -0.00825068f, -0.00913317f, 0.00591166f, 
    0.03430200f, -0.02047610f, -0.04734685f, 0.00112438f, -0.03049958f, 0.02066401f, -0.04174597f, -0.05104540f, 
    -0.02716274f, -0.03579079f, 0.03443516f, -0.00236613f, -0.01257695f, 0.03224163f, -0.02475087f, -0.03542647f, 
    -0.02928920f, -0.03594574f, -0.00699766f, 0.01587850f, -0.05589756f, -0.05686963f, -0.05591611f, -0.00658460f, 
    0.03981787f, 0.03066609f, -0.03635069f, -0.04678238f, -0.00937668f, 0.01725881f, -0.00740699f, 0.02179451f, 
    -0.01574034f, -0.02356476f, -0.00842550f, 0.00225662f, 0.03323215f, -0.02356054f, -0.01634268f, -0.04697686f, 
    -0.02943914f, -0.05374252f, 0.00434860f, -0.05167870f, 0.01480305f, -0.01923729f, 0.02208491f, -0.05206407f, 
    0.02925654f, 0.00931062f, -0.03761583f, 0.03067554f, -0.00385220f, -0.01427659f, 0.02959905f, 0.00248444f, 
    -0.01858527f, -0.03843722f, -0.01993625f, 0.02832115f, -0.00142168f, 0.01018734f, -0.02625715f, -0.03413141f, 
    0.01147111f, 0.02780687f, -0.02313769f, 0.03835294f, 0.04123897f, 0.01054300f, -0.05661264f, 0.00750765f, 
    -0.02149115f, 0.00091218f, -0.05007700f, -0.02458575f, 0.00322256f, -0.02606172f, 0.03067960f, -0.00963616f, 
    -0.04104801f, 0.00286368f, -0.01777267f, 0.00393437f, 0.01051330f, -0.00589924f, 0.02798972f, 0.03786493f, 
    -0.04928705f, 0.00864787f, -0.02906023f, -0.02582656f, 0.02646849f, -0.01541598f, -0.03361645f, -0.01759398f, 
    0.01928149f, -0.01701257f, -0.05138227f, -0.05081468f, 0.01475417f, -0.02596868f, -0.00577676f, -0.00075922f, 
    -0.02304817f, 0.04765734f, 0.00042883f, -0.01134280f, -0.04284951f, 0.03909739f, -0.03298716f, -0.03746687f, 
    -0.00109705f, -0.04027624f, -0.04799014f, -0.03334720f, 0.02791749f, 0.01209227f, -0.01927818f, -0.04616793f, 
    -0.05074987f, -0.02700442f, 0.01762104f, 0.01537993f, -0.04851513f, -0.02398785f, -0.00291281f, -0.04769967f, 
    0.02609316f, -0.02617013f, -0.02433132f, -0.01918688f, 0.00278944f, -0.02364702f, 0.03780532f, 0.03834796f, 
    -0.01315351f, -0.00304751f, 0.00339958f, 0.03576896f, -0.04204638f, 0.03417698f, -0.04502191f, -0.00520277f, 
    0.00710486f, -0.01564131f, 0.02969740f, -0.02945867f, -0.04582824f, -0.05077633f, -0.00455279f, -0.02090746f, 
    -0.04407277f, -0.01270121f, 0.03836354f, 0.03005900f, 0.04099757f, -0.05316368f, 0.01563248f, -0.00154601f, 
    0.03734899f, -0.03034095f, 0.01104370f, -0.00769326f, 0.01482989f, -0.01463617f, -0.02571011f, 0.02368565f, 
    0.02135163f, -0.04318127f, 0.00116014f, -0.04128360f, -0.01536878f, -0.03250200f, -0.01621974f, 0.01935103f, 
    -0.04175346f, -0.03528691f, 0.04646640f, -0.02835840f, -0.02909705f, -0.04760481f, -0.01879820f, -0.01706517f, 
    -0.02502384f, 0.03969254f, -0.01532529f, -0.03586132f, -0.03049868f, -0.03600429f, 0.01214289f, -0.00028535f, 
    -0.00621209f, 0.04332286f, -0.01507141f, -0.03881740f, 0.01782878f, -0.04181558f, -0.04441588f, -0.04296485f, 
    0.01357387f, -0.04974309f, -0.04941620f, 0.04755558f, -0.00876751f, -0.04152349f, -0.01764138f, 0.02869537f, 
    -0.02409233f, -0.02908896f, -0.02133349f, -0.05476122f, 0.04036589f, -0.01728038f, 0.03336832f, -0.05346069f, 
    -0.01301153f, -0.02054706f, 0.00797585f, 0.03303860f, -0.05399640f, -0.01347092f, 0.02024393f, 0.02620880f, 
    0.03553341f, 0.04016791f, 0.00682383f, 0.01656933f, -0.01628024f, -0.03688323f, 0.02726288f, 0.03485851f, 
    0.04010736f, 0.02486438f, 0.04006142f, -0.04583870f, -0.03109016f, -0.05512256f, -0.01534713f, 0.00143576f, 
    -0.02355016f, 0.03313837f, 0.02803682f, -0.05107237f, 0.02442640f, 0.01920188f, -0.03089135f, 0.01509275f, 
    0.02948596f, -0.00118195f, -0.02792030f, -0.04873115f, 0.01663611f, -0.02500122f, 0.02926522f, 0.03604184f, 
    -0.02746056f, -0.00050760f, 0.00298270f, -0.04101390f, -0.00378750f, 0.01841425f, 0.01901938f, -0.03151938f, 
    -0.02755786f, 0.02886373f, -0.02911103f, 0.00537695f, 0.03981732f, -0.02725647f, 0.02006762f, 0.01799882f, 
    -0.03305700f, -0.02714535f, -0.05142098f, -0.01490425f, -0.02413422f, 0.03271933f, -0.00963529f, -0.03526814f, 
    0.03458577f, 0.02546921f, 0.02724274f, 0.01465240f, -0.04756840f, 0.02395168f, -0.02083588f, -0.05187689f, 
    0.03983558f, 0.03198377f, -0.01862413f, -0.00115765f, -0.05522515f, -0.05876138f, 0.04509611f, -0.06061153f, 
    0.02722263f, -0.02764347f, -0.02991617f, 0.01512782f, -0.03116921f, -0.02045815f, -0.02892190f, 0.02003524f, 
    -0.02165204f, 0.00991695f, -0.04583348f, -0.03368536f, 0.02331864f, -0.00734097f, 0.03269319f, -0.01526829f, 
    -0.01749737f, -0.01070458f, -0.01844847f, 0.04113136f, -0.03724655f, 0.01796400f, -0.00970466f, -0.03232193f, 
    -0.01772851f, -0.00723420f, -0.01260683f, -0.04950274f, 0.02452566f, 0.03723168f, -0.00386982f, -0.02282873f, 
    -0.05104522f, 0.03959526f, 0.03614664f, -0.04070001f, 0.02450937f, 0.01191890f, 0.03493624f, -0.04730275f, 
    0.00201602f, -0.01478378f, 0.01841189f, -0.03514033f, 0.00464101f, -0.05169078f, -0.05341376f, -0.04877929f, 
    0.03049394f, 0.03713053f, -0.03889642f, -0.02126085f, -0.00374937f, 0.04516029f, 0.04157634f, 0.02742467f, 
    -0.02163406f, -0.03264143f, -0.00758368f, -0.05244897f, 0.02080130f, -0.01198374f, -0.00678966f, -0.02662549f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03342510f, 0.08310057f, 0.13085148f, 0.04049634f, 0.13083003f, 0.04567296f, -0.02393460f, 0.17266667f, 
    0.01967906f, 0.01133107f, 0.01967422f, -0.02457284f, 0.10004063f, -0.05010933f, 0.10940805f, 0.04011131f, 
    0.01692873f, 0.05776982f, -0.04923229f, 0.03449361f, 0.00802538f, 0.10359554f, 0.20105083f, 0.09492645f, 
    0.02917182f, 0.03736505f, 0.18713573f, 0.09192398f, 0.09989622f, -0.03440952f, -0.02399607f, 0.00407792f, 
    -0.04241848f, 0.09342232f, -0.00734172f, -0.01166888f, 0.16398081f, -0.03270181f, 0.00127826f, -0.04765477f, 
    0.05106813f, -0.06221012f, -0.05326118f, -0.01358595f, 0.09913126f, 0.20320736f, 0.00176199f, 0.00922013f, 
    0.08557662f, 0.00418303f, 0.02737429f, 0.01669085f, 0.00533462f, -0.03226972f, -0.00189388f, -0.05228188f, 
    0.05942891f, 0.09800322f, 0.09886325f, -0.06215388f, -0.07007886f, 0.15910549f, -0.03792799f, 0.03468303f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.16658708f, -0.12853940f, 0.03652112f, 0.24266790f, 0.02684780f, 0.15888312f, 0.10255612f, -0.39908743f, 
    -0.31215870f, -0.49524829f, 0.03002453f, -0.20453183f, -0.10436548f, 0.17448920f, -0.16674984f, -0.08702116f, 
    -0.34571570f, 0.06129341f, 0.06303325f, 0.16763648f, 0.10421792f, -0.14780560f, -0.29691336f, 0.18837938f, 
    0.00103780f, 0.15742414f, -0.06187658f, -0.31490216f, 0.01896953f, 0.07174861f, -0.18768273f, -0.24582805f, 
    -0.02427267f, -0.04741329f, 0.02927626f, 0.08437860f, -0.43136248f, 0.02250506f, 0.10557748f, -0.09301485f, 
    -0.34407961f, 0.22271025f, -0.11492825f, -0.02963652f, 0.15511154f, -0.17754114f, 0.10722744f, 0.06453191f, 
    -0.08024503f, -0.10395635f, -0.16263594f, 0.08985688f, -0.05661691f, -0.02714145f, 0.16551921f, 0.13998492f, 
    -0.26902440f, -0.06513504f, -0.09841276f, 0.18545693f, 0.21948196f, 0.01766337f, -0.08333411f, -0.00685729f, 
    -0.18946247f, -0.10901564f, 0.20221926f, 0.20109856f, 0.02369298f, 0.00906691f, 0.03844520f, 0.08475257f, 
    0.03304026f, -0.23538025f, -0.02574607f, -0.12273768f, 0.22739892f, 0.10922228f, -0.07340094f, -0.08059496f, 
    -0.08668934f, 0.25901595f, 0.00097629f, -0.23720936f, -0.05556149f, 0.05141050f, 0.25321639f, 0.14306934f, 
    -0.09171631f, -0.08643529f, 0.05886072f, 0.23902367f, 0.11006831f, -0.02178011f, -0.01778824f, -0.30078864f, 
    0.05283691f, 0.08094332f, -0.46123841f, -0.03433469f, -0.19831151f, 0.07384282f, -0.10237448f, 0.03251278f, 
    -0.29700115f, -0.66412091f, -0.04425241f, 0.14998433f, 0.15165725f, 0.27406847f, 0.01382660f, 0.04500234f, 
    -0.09743640f, 0.04467675f, -0.44900668f, -0.09193359f, 0.07246046f, 0.10328416f, 0.36382794f, -0.22453514f, 
    -0.35582751f, 0.22976506f, -0.12649758f, 0.17511782f, -0.26006341f, 0.22341807f, -0.04923834f, -0.09643581f, 
    0.17495763f, 0.07853615f, -0.05675548f, 0.14204991f, -0.27750126f, 0.04964415f, 0.12908809f, 0.07955966f, 
    0.32000822f, -0.06006142f, 0.05362368f, -0.10937967f, 0.28098851f, -0.24695446f, -0.12912883f, -0.09241440f, 
    -0.26505873f, -0.66189712f, 0.05527683f, 0.01901492f, 0.25472963f, 0.24306613f, 0.22277032f, -0.60800850f, 
    0.06428419f, -0.16330566f, 0.00036640f, -0.05966647f, -0.35136428f, 0.01106573f, -0.10575584f, -0.03289168f, 
    0.09419516f, 0.20674424f, -0.34711385f, 0.06390864f, 0.10015813f, -0.01738072f, 0.10763073f, 0.06330575f, 
    0.14298260f, 0.00384090f, 0.11735562f, 0.39846200f, -0.14766853f, -0.03940605f, -0.09874243f, 0.00880452f, 
    -0.08825460f, 0.02371014f, 0.22843900f, 0.02767848f, -0.02503238f, 0.08122394f, -0.30565023f, -0.19463308f, 
    0.13051245f, -0.03570842f, -0.42333320f, 0.08459102f, -0.28693700f, 0.02475707f, 0.11068906f, -0.12657039f, 
    0.30491433f, -0.09460013f, -0.22644712f, -0.34215948f, -0.20007497f, -0.13466011f, 0.02436216f, -0.00809333f, 
    0.12863442f, 0.04004190f, -0.01992982f, 0.15696721f, -0.18365930f, 0.13776216f, -0.22186306f, 0.06525054f, 
    0.32786882f, -0.23577192f, -0.03586629f, -0.27884859f, -0.05451304f, 0.15098502f, -0.16812077f, 0.06109257f, 
    0.10027488f, 0.21766406f, -0.52161485f, 0.09804849f, -0.03828241f, 0.08075677f, 0.05164206f, 0.36761791f, 
    -0.09716765f, -0.02862940f, 0.09501053f, -0.05051012f, -0.17985424f, 0.08110532f, -0.05007860f, 0.06378628f, 
    -0.23801026f, 0.01427820f, -0.07286084f, 0.20441142f, -0.47336972f, -0.32508475f, -0.10326868f, 0.01249448f, 
    0.05903209f, -0.09649908f, 0.22876324f, -0.02392393f, 0.02527883f, -0.09484710f, -0.06465600f, 0.18378818f, 
    0.14115158f, -0.10079194f, -0.43493533f, 0.27315864f, 0.03514974f, -0.04477912f, 0.12959801f, -0.00123000f, 
    -0.09106816f, 0.20802055f, -0.00933202f, -0.05938707f, -0.51325381f, 0.17752972f, -0.10219698f, -0.10654864f, 
    -0.05746771f, 0.19874322f, 0.07611418f, 0.27273282f, 0.13753328f, -0.05929695f, -0.36369523f, -0.06274600f, 
    -0.23059340f, 0.12971741f, -0.00275392f, 0.00467361f, 0.01915847f, -0.02491540f, -0.16274641f, -0.26527658f, 
    0.05856863f, -0.13715217f, 0.00761956f, -0.48962563f, -0.01629799f, -0.00025592f, 0.08085296f, 0.03703323f, 
    -0.05416587f, -0.03538908f, 0.23739083f, 0.10687142f, -0.11036559f, -0.05892346f, 0.09676969f, -0.00682467f, 
    0.05846257f, 0.11362838f, -0.00237567f, 0.06463186f, -0.05318601f, -0.16240664f, 0.23814900f, 0.00863012f, 
    0.09588228f, -0.02121349f, -0.22862002f, 0.03038717f, 0.00837310f, -0.06696029f, 0.03054894f, -0.10951118f, 
    0.15938650f, -0.12566413f, 0.29056934f, -0.18162765f, 0.01999214f, -0.12803578f, 0.09203596f, 0.01275554f, 
    -0.12633049f, 0.09816679f, 0.26405543f, -0.10948727f, 0.22628842f, 0.22377521f, 0.00628280f, -0.19819577f, 
    -0.62505764f, 0.13304642f, 0.10984379f, -0.18408169f, 0.04729076f, 0.13412251f, 0.26755172f, 0.07360625f, 
    0.04051087f, 0.26168460f, -0.03462017f, 0.13027729f, 0.28010169f, -0.30419320f, -0.12671719f, 0.15617406f, 
    -0.10991318f, 0.05338484f, 0.01795871f, -0.33213800f, 0.13651305f, 0.09577622f, -0.02093426f, -0.07246627f, 
    -0.05246083f, -0.35929152f, -0.25876009f, -0.06751138f, -0.06381915f, 0.09565330f, -0.06225688f, -0.11215246f, 
    0.13455096f, -0.39759460f, -0.00792607f, -0.58078444f, 0.08045520f, -0.15920717f, 0.00522450f, -0.06798539f, 
    -0.02477280f, -0.03520655f, 0.19342296f, -0.08443597f, 0.06243161f, -0.01556736f, 0.03180581f, 0.01318697f, 
    -0.01217478f, -0.24374378f, 0.40685526f, -0.27862051f, -0.45095855f, -0.00060085f, 0.04023246f, -0.06770584f, 
    0.12326816f, 0.16937831f, 0.04982900f, -0.01471390f, -0.13286428f, -0.68554318f, 0.02499399f, 0.23228367f, 
    0.18039785f, 0.17953582f, -0.00833607f, -0.18219548f, -0.51383960f, -0.51883751f, 0.12815908f, 0.10109521f, 
    0.04556844f, -0.52213484f, -0.00976213f, -0.02943231f, 0.08749221f, 0.11618156f, -0.01424453f, 0.04033899f, 
    -0.06504673f, -0.40719166f, 0.12759903f, 0.01871910f, -0.28833777f, 0.03554528f, -0.22490844f, 0.00828211f, 
    -0.10821048f, 0.28215128f, -0.71457869f, -0.03431499f, 0.13046435f, -0.07184457f, -0.07360008f, -0.09566741f, 
    0.06964713f, -0.16683495f, 0.12618263f, -0.15709890f, 0.01777164f, -0.03386028f, -0.51268959f, 0.11319614f, 
    0.05669041f, 0.08904807f, -0.43977964f, -0.00440319f, 0.03736238f, 0.02566876f, -0.12764731f, -0.42881295f, 
    0.47102135f, -0.18912692f, 0.28342581f, -0.47660255f, 0.43813285f, -0.83680892f, -0.07808942f, 0.02603958f, 
    -0.20111378f, -0.46360832f, -0.32684240f, -0.05548393f, 0.15794288f, -0.30127257f, -0.06739542f, 0.03833590f, 
    0.00099729f, 0.12469371f, -0.03052324f, 0.15150020f, -0.35182691f, 0.18768960f, 0.07400490f, 0.05378811f, 
    0.18574598f, -0.11405469f, 0.00612425f, 0.01424695f, 0.29703608f, 0.23259488f, -0.18857303f, -0.32657465f, 
    -0.09176018f, -0.10946681f, 0.14475137f, 0.18630311f, -0.13921852f, 0.10864644f, -0.23880331f, 0.05971396f, 
    0.00157926f, -0.29356015f, 0.03055230f, -0.07365257f, 0.04216043f, -0.06157008f, 0.09764946f, 0.05274756f, 
    0.24413073f, -0.27455330f, -0.02396580f, 0.44012323f, -0.22413421f, 0.02064493f, -0.36500058f, -0.05727618f, 
    -0.58906639f, -0.06185501f, 0.07647939f, 0.07280519f, -0.09139429f, 0.02102024f, -0.08871793f, -0.28420615f, 
    0.12184720f, 0.23789431f, 0.00304958f, -0.28224859f, 0.27668786f, -0.18804987f, -0.00721655f, -0.09887344f, 
    0.07729432f, -0.23289634f, 0.20352030f, -0.16973130f, 0.18799375f, -0.19156247f, -0.05702953f, -0.12910439f, 
    -0.24648890f, 0.09677736f, -0.03412976f, -0.03308303f, 0.28501925f, 0.06964040f, 0.30117580f, -0.11835830f, 
    0.13521840f, -0.54443979f, 0.08337224f, -0.13076423f, -0.55257076f, 0.18382521f, 0.13171513f, 0.19853030f, 
    -0.12614648f, 0.24356480f, -0.25945592f, 0.01832188f, 0.22294873f, 0.07826863f, -0.48285106f, 0.48458833f, 
    -0.05281398f, 0.20068116f, -0.11628605f, 0.07220288f, -0.03102577f, -0.09016562f, 0.12445762f, -0.08152319f, 
    -0.17424966f, -0.05710534f, -0.06493369f, -0.15581553f, 0.18725400f, -0.10927079f, -0.49445543f, -0.08441150f, 
    -0.60161042f, -0.08843488f, 0.31794107f, -0.05528545f, 0.00541789f, 0.00631623f, -0.20118119f, -0.44212201f, 
    -0.23157881f, -0.08328714f, -0.58061689f, -0.20348597f, -0.05022534f, 0.11480225f, -0.01688069f, -0.05779919f, 
    -0.65827888f, 0.18646125f, -0.50972021f, -0.07518771f, 0.29996651f, 0.23524363f, 0.04552022f, 0.26643103f, 
    0.08882151f, 0.12673631f, -0.04692574f, -0.20188816f, -0.04755376f, -0.44000420f, -0.08577119f, -0.11850451f, 
    -0.33843458f, -0.10676759f, -0.01002553f, 0.33363223f, 0.14226136f, 0.04282767f, -0.29578847f, 0.02052002f, 
    0.08054391f, -0.45442778f, 0.05734002f, -0.06851166f, 0.36084795f, -0.08524443f, -0.04657198f, -0.21540755f, 
    -0.04823258f, 0.23350479f, 0.47924241f, -0.08483022f, 0.01234065f, -0.00717936f, -0.03304042f, 0.01268471f, 
    -0.30660334f, 0.36592534f, -0.01586578f, -0.02733636f, 0.09910116f, -0.29949909f, 0.06631003f, -0.07282214f, 
    -0.16627395f, -0.11022619f, -0.11856249f, -0.04338456f, 0.08265787f, 0.05199787f, 0.03701122f, 0.25166878f, 
    0.01542078f, 0.05830012f, 0.15206356f, -0.46267930f, -0.16883746f, -0.35978717f, -0.09460659f, -0.05542998f, 
    0.35187036f, 0.08639930f, -0.32639095f, -0.03977804f, -0.16687897f, -0.44595650f, 0.05844862f, 0.16455700f, 
    -0.04704731f, -0.18450898f, 0.00752101f, 0.04154630f, -0.18212797f, -0.01530496f, -0.05075169f, 0.01841375f, 
    0.36682737f, 0.11703669f, -0.03596500f, -0.01781290f, -0.36982790f, -0.35745615f, 0.15082937f, -0.13355471f, 
    0.11535181f, 0.23277007f, -0.33159679f, -0.43490252f, 0.16653223f, -0.00476168f, 0.04331187f, 0.13709128f, 
    -0.05270922f, 0.21585733f, -0.46592394f, 0.03655313f, -0.00897394f, -0.00327331f, -0.04436839f, 0.04127204f, 
    0.00764473f, -0.30906531f, -0.13856049f, -0.14981344f, -0.05468824f, 0.35983431f, -0.06598094f, -0.06406325f, 
    0.23711658f, 0.00679258f, -0.19514696f, -0.10991842f, 0.11643293f, -0.10400990f, -0.50348359f, 0.32991499f, 
    -0.27613243f, 0.21613798f, 0.14219405f, -0.38228396f, -0.67606634f, 0.07773301f, -0.01494348f, 0.07933729f, 
    -0.28081271f, 0.19444147f, 0.14706993f, -0.24435715f, -0.03563133f, -0.23537040f, 0.00058638f, 0.06948137f, 
    0.34516749f, 0.15954493f, 0.06013215f, -0.00373144f, -0.50098163f, 0.01376846f, -0.14316626f, -0.00217726f, 
    -0.30577803f, -0.11131385f, -0.07037169f, -0.62389982f, -0.48376778f, -0.03924003f, 0.24587174f, 0.28667670f, 
    0.04229873f, -0.14744586f, -0.33662993f, 0.23152268f, -0.39822471f, -0.09953061f, 0.48956624f, -0.14991824f, 
    0.01967702f, 0.07825884f, 0.07010223f, 0.07741646f, 0.21634944f, 0.11146233f, -0.01658113f, 0.01995001f, 
    0.45517150f, -0.37426561f, 0.02706924f, -0.45125279f, 0.11699560f, -0.34473944f, 0.07713000f, 0.03513778f, 
    0.15494728f, -0.11632323f, 0.23728552f, 0.08905117f, -0.01810401f, -0.11509201f, -0.07053811f, 0.08583067f, 
    -0.32810006f, 0.00414198f, -0.34044147f, 0.11426146f, -0.03195156f, -0.22591127f, 0.07172447f, -0.03672162f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.18693660f, 0.10681155f, 0.14683430f, -0.15585133f, 0.07143540f, 0.12360357f, 0.07976881f, 0.02714129f, 
    0.04778614f, -0.11576889f, 0.02569184f, -0.03576690f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
