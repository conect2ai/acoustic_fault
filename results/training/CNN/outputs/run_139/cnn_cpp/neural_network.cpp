#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.70346880f, 0.85399836f, 0.99896127f, -0.26082048f, -0.31749421f, -0.62399256f, 0.15397026f, -0.41947466f, 
    -0.09767694f, 0.22360830f, 0.04715097f, 0.27545270f, -0.09292548f, -0.03378905f, 0.13946596f, -0.08187392f, 
    0.11483240f, -0.00838651f, -0.03932161f, -0.06723338f, -0.01146734f, 0.12575625f, -0.09305661f, 0.01860761f, 
    0.17436215f, -0.67384148f, -0.27633238f, -0.38411114f, -0.14729719f, 0.16200858f, 0.10494366f, 1.05609679f, 
    -0.48251686f, -0.04392982f, 0.03880255f, 0.00764920f, -0.03587495f, 0.14454712f, 0.08938861f, 0.08028550f, 
    0.21539731f, 0.11555051f, 0.06438719f, 0.06232556f, -0.01307593f, 0.03865586f, 0.07319211f, -0.15694408f, 
    0.05276123f, 0.13410284f, 0.65474957f, 0.32410294f, 0.72311717f, 0.48291579f, 0.18357393f, 0.51726115f, 
    0.21209073f, 0.18867743f, -0.00016811f, -0.16232763f, -0.04948741f, 0.32964224f, 0.01498271f, 0.45416889f, 
    0.24283694f, 0.34213087f, -0.06245780f, 0.04529354f, 0.00444932f, 0.06806461f, -0.23412660f, -0.16942145f, 
    0.12507607f, 0.08204473f, 0.11716181f, 0.46108234f, 0.65401149f, -0.24278766f, -0.89755881f, -0.50156766f, 
    -0.27201498f, 0.40870857f, 0.72881109f, 0.02280224f, 0.58308154f, -0.01711768f, 0.13902737f, -0.25378898f, 
    -0.32920665f, -0.27496511f, -0.19951640f, -0.13427715f, -0.08985045f, 0.01476046f, -0.04223698f, -0.17056429f, 
    0.09650696f, -0.00750601f, 0.05675966f, 0.24493673f, -0.09682397f, -0.70071876f, 0.07146918f, 0.74284464f, 
    -0.34793147f, -0.23583046f, -0.06868960f, 0.58880007f, -0.36926836f, 0.27910760f, 0.11768382f, -0.31893504f, 
    0.09222922f, -0.03586530f, 0.13614196f, 0.02661827f, -0.08323903f, -0.03575788f, -0.16200408f, 0.34153134f, 
    0.51136708f, 0.43991444f, 0.09973309f, 0.12486459f, 0.00579960f, 0.42255503f, 0.21564744f, 0.40768695f, 
    0.79440504f, 0.36605528f, 0.26831084f, 0.17518331f, -0.37264353f, 0.36992833f, -0.04537535f, 0.07874081f, 
    0.06616230f, 0.22460903f, 0.03322467f, -0.61762869f, -0.29166570f, -0.03530184f, 0.02228582f, -0.08483667f, 
    0.05842146f, -0.06005774f, -0.00453299f, 0.21259733f, -0.23628736f, 0.19736311f, 0.49098524f, -0.68282235f, 
    -0.69050407f, -0.45452181f, 0.46518096f, 0.59805351f, 0.26422578f, -0.67862749f, -0.35051829f, -0.09787264f, 
    -0.04242666f, 0.39684063f, -0.08396634f, 0.03841895f, -0.01232229f, -0.01215868f, -0.03748213f, 0.00574659f, 
    -0.00003742f, -0.19829147f, -0.02279094f, -0.08747856f, -0.06594916f, 0.06360632f, -0.21980765f, 0.78706002f, 
    0.99452418f, -0.21510497f, 0.36335170f, 0.11509845f, -0.25269377f, -0.69867194f, -0.23734507f, 0.09904677f, 
    -0.09935386f, 0.20727584f, -0.23249502f, -0.09525537f, -0.10008591f, -0.11219975f, 0.08167920f, 0.05763027f, 
    0.07978769f, -0.09753527f, 0.12903926f, 0.31540751f, 0.06676869f, -0.06530867f, 0.10701492f, -0.04271908f, 
    -0.84143078f, -0.37011921f, 0.11045405f, 0.41203594f, 0.51586002f, -0.42820725f, 0.03043193f, 0.40444604f, 
    0.15480562f, -0.76404089f, 0.46953842f, 0.22480068f, 0.04730686f, 0.04548815f, 0.23961143f, 0.37134737f, 
    0.08426891f, -0.05205873f, 0.22233245f, 0.25712919f, -0.08491025f, 0.02593598f, -0.08445776f, 0.11242539f, 
    0.01956007f, -0.30998749f, -0.87849087f, -0.72374594f, -0.66271383f, -0.58668399f, -0.32544783f, 0.16040884f, 
    0.45063001f, 0.45552859f, 0.36805898f, 0.23926859f, 0.05735779f, -0.06039815f, 0.00714733f, 0.13298318f, 
    0.20273794f, -0.02169755f, 0.32694092f, 0.18008079f, -0.06136369f, -0.02816512f, -0.12267924f, 0.05490435f, 
    0.07306176f, 0.10156856f, -1.17117548f, 0.19793835f, -0.31209269f, 0.16917138f, -0.42766583f, 0.35024089f, 
    0.53184146f, -0.58838159f, 0.17371498f, 0.13101894f, 0.00509650f, -0.11995192f, -0.07643215f, -0.00331129f, 
    0.03309558f, -0.32793480f, -0.08471480f, -0.11262814f, 0.04583532f, -0.21457945f, 0.13794027f, 0.05567739f, 
    0.33247659f, -0.01612734f, -0.06921160f, -0.47636577f, 0.76408297f, 0.37664971f, -0.26098287f, 0.66721714f, 
    -0.22256710f, -0.24384227f, -0.48146304f, -0.71563417f, -0.47645795f, 0.15827435f, -0.27305847f, 0.19992657f, 
    0.32174510f, -0.06373389f, -0.16987133f, 0.11020300f, 0.03228584f, -0.13495806f, -0.06671964f, 0.04556852f, 
    -0.02744813f, 0.07330263f, -0.01680295f, -0.08676650f, 0.37024790f, -0.19918048f, 0.57954901f, 0.75192916f, 
    0.64335084f, 0.23359008f, 0.08415000f, -0.28440937f, 0.35252693f, 0.24470678f, -0.35516480f, -0.14049645f, 
    0.04698290f, -0.04040822f, 0.04918251f, -0.02096960f, 0.24611817f, -0.16475721f, 0.05951587f, 0.08993856f, 
    -0.02561097f, 0.23072764f, -0.04583826f, -0.02309542f, -0.11502592f, -0.16980186f, -1.21418095f, 0.13055944f, 
    0.62015319f, 0.10553572f, -0.24945423f, 1.06308591f, 0.49564686f, -0.28618473f, 0.27010205f, -0.01063654f, 
    0.13150227f, 0.09584218f, 0.11193840f, 0.07546186f, -0.30552500f, -0.01993228f, -0.01915669f, -0.05311459f, 
    -0.09316502f, -0.03776462f, -0.10535100f, -0.03484806f, -0.18787712f, -0.08240537f, 0.69253552f, 0.03815053f, 
    -0.49747524f, -0.16496690f, 0.30101690f, -0.07506651f, -0.38107243f, -0.35639536f, -0.06097442f, -0.17089273f, 
    -0.09818578f, 0.53736848f, -0.05273901f, 0.40769613f, 0.12137260f, 0.27895874f, 0.01714924f, 0.12480205f, 
    0.03484942f, 0.31553417f, -0.03582688f, 0.15227848f, 0.13615125f, -0.03574828f, 0.12958352f, -0.20132671f, 
    0.02785736f, -0.16739962f, -0.33791855f, -0.54202938f, 0.20140837f, -0.16986543f, -0.36292139f, -0.51749909f, 
    0.24289078f, -0.22790119f, -0.50713485f, -0.42183888f, -0.11785553f, 0.23202741f, -0.36507705f, -0.54184765f, 
    -0.17580037f, -0.15902060f, -0.16147470f, -0.34416744f, 0.14753711f, -0.31379953f, 0.17729470f, 0.11519521f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03051705f, 0.17301090f, 0.16594584f, 0.16853179f, 0.12229706f, 0.09630912f, 0.34933016f, 0.02566781f, 
    0.39191824f, 0.22446254f, 0.01690878f, 0.03020247f, 0.24411887f, 0.34740490f, 0.21366219f, 0.16356800f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02059331f, 0.02311623f, 0.04145909f, -0.04101501f, -0.01298246f, -0.00809124f, 0.01569094f, 0.05164453f, 
    -0.03538128f, -0.05282107f, 0.04690042f, 0.01560984f, 0.03824823f, -0.04191620f, 0.02928505f, 0.05725272f, 
    0.06270806f, -0.00362892f, -0.02771057f, -0.02204388f, 0.06745286f, 0.05421175f, -0.01980925f, 0.01350327f, 
    0.03163046f, 0.04036012f, 0.01829188f, -0.04272655f, -0.06394489f, -0.01507941f, -0.05539258f, -0.05821653f, 
    -0.00751587f, -0.07199612f, -0.07740797f, 0.05439221f, -0.03346164f, 0.04249507f, -0.00692576f, -0.06578958f, 
    0.07064766f, -0.04778186f, 0.00803627f, 0.03073701f, -0.06116866f, -0.06263570f, 0.01728384f, -0.04514584f, 
    0.00151082f, 0.01880338f, -0.06147015f, -0.03164444f, 0.05325216f, 0.01835595f, 0.05226596f, -0.03842385f, 
    0.03340401f, 0.03517501f, -0.02736408f, 0.01822172f, -0.06108302f, -0.02109802f, -0.00479162f, -0.03119258f, 
    0.02970554f, -0.01847292f, 0.00753049f, 0.07489559f, -0.03464470f, -0.00678112f, 0.07391224f, 0.05400900f, 
    -0.07321932f, -0.05534218f, 0.01704864f, 0.05978017f, 0.02190795f, 0.02890432f, 0.04651304f, 0.05396646f, 
    -0.04918877f, -0.05200499f, 0.06567260f, 0.05920021f, -0.00170743f, -0.03261480f, 0.03665315f, -0.02736878f, 
    -0.01131251f, 0.05687535f, -0.06939798f, 0.06789188f, 0.00609925f, 0.01078571f, 0.04828648f, 0.05691748f, 
    -0.03162194f, 0.04069145f, -0.06095478f, -0.04864608f, -0.04126354f, 0.02936985f, 0.02702746f, -0.06571374f, 
    0.01828464f, -0.05055609f, -0.06785324f, 0.01901895f, 0.07035157f, 0.01336211f, -0.00626659f, -0.06297356f, 
    -0.05675378f, -0.00661311f, 0.06040888f, -0.01702921f, -0.04934183f, 0.05487357f, 0.06139038f, 0.04400234f, 
    -0.05853988f, -0.05777225f, 0.00108644f, -0.04449085f, 0.02022937f, 0.05211756f, 0.01796096f, -0.04066540f, 
    -0.04237227f, -0.06790920f, -0.05615312f, -0.03152118f, -0.06916938f, -0.03098300f, 0.06329876f, -0.01500687f, 
    -0.05114359f, -0.06669912f, -0.07216802f, -0.00150126f, -0.02152844f, 0.05556720f, 0.03463293f, -0.03260713f, 
    -0.03146392f, 0.02983597f, -0.04110693f, -0.02799295f, 0.04246937f, -0.02882533f, 0.00265884f, 0.02180203f, 
    -0.01672519f, 0.06642515f, -0.05404972f, 0.06502489f, -0.06497931f, -0.00149522f, 0.00679470f, -0.05817193f, 
    -0.05457746f, -0.03480931f, -0.06438442f, 0.01195972f, -0.05438316f, -0.02607029f, -0.05733252f, -0.03641018f, 
    -0.01609919f, -0.00286768f, -0.00044344f, -0.04108932f, -0.04392014f, -0.06577104f, 0.00020182f, -0.05306038f, 
    -0.01036017f, -0.06751814f, -0.04246077f, 0.00996483f, 0.04204965f, 0.03511205f, 0.03377102f, -0.05508706f, 
    -0.01844338f, -0.01355382f, -0.07158672f, -0.03249798f, -0.03565658f, 0.04341573f, 0.02541181f, -0.01515401f, 
    -0.07113763f, -0.10708590f, -0.05110339f, -0.07068580f, -0.00220243f, 0.02499761f, 0.05590995f, 0.06397429f, 
    -0.13540682f, -0.14039454f, -0.10378276f, 0.15714554f, -0.26940092f, 0.02453045f, 0.30977982f, -0.00502005f, 
    0.10111807f, -0.09822900f, 0.05375103f, 0.04844344f, 0.04103592f, -0.01561777f, 0.04059108f, 0.09138423f, 
    0.05358870f, 0.27434710f, 0.11133089f, -0.06953645f, -0.11704022f, 0.10890494f, 0.21562663f, -0.12040810f, 
    -0.25276729f, -0.10724581f, 0.12674977f, 0.07702328f, -0.03229559f, -0.20521069f, -0.11112029f, -0.02742803f, 
    0.10327127f, 0.03963415f, 0.05649554f, -0.02136964f, -0.01413029f, 0.11866710f, -0.20242526f, 0.16540930f, 
    0.38422495f, -0.05936719f, -0.03161396f, -0.26535091f, 0.03427718f, -0.07230287f, 0.08513521f, 0.05773750f, 
    -0.09648483f, 0.08650424f, -0.04446326f, -0.18906543f, -0.26685768f, 0.00098533f, 0.07515308f, -0.23340410f, 
    0.13930564f, -0.07963356f, -0.01797446f, -0.12836961f, -0.09279812f, -0.14402407f, 0.07483725f, -0.01012171f, 
    -0.29492182f, 0.38801163f, 0.09347309f, 0.02845576f, -0.00043889f, 0.09461153f, -0.07548015f, -0.01603520f, 
    0.04166055f, 0.01869106f, 0.04871462f, 0.02229799f, -0.30711657f, 0.12200288f, -0.12382557f, -0.05298796f, 
    0.10488061f, -0.04951015f, 0.05022578f, -0.08451947f, -0.03812053f, -0.04567213f, -0.19559170f, -0.09709281f, 
    0.38173196f, -0.49425444f, 0.02900799f, -0.04098399f, 0.01233523f, -0.01724016f, 0.09673029f, -0.09721154f, 
    0.08166941f, 0.04378211f, 0.16719888f, 0.00084027f, -0.25964960f, -0.12623723f, -0.04570553f, 0.08310993f, 
    0.15429202f, 0.20994860f, 0.10950404f, -0.02836179f, 0.02374236f, -0.10969739f, -0.03756150f, -0.05481355f, 
    -0.12384421f, 0.02694084f, 0.34418216f, 0.15862475f, 0.12249855f, 0.06328754f, 0.22229457f, 0.08579855f, 
    0.00892935f, -0.13382868f, 0.01855057f, 0.01684299f, 0.25856349f, -0.23503456f, 0.21110311f, 0.43989411f, 
    0.02478395f, -0.07835107f, 0.12261373f, 0.04265913f, -0.04377725f, 0.04770509f, 0.08264997f, 0.14887896f, 
    -0.04902921f, 0.27242434f, -0.14585437f, -0.19298330f, 0.14163448f, -0.00929069f, -0.11414514f, -0.12730932f, 
    -0.06569900f, -0.01052222f, 0.09590857f, 0.09671151f, 0.16289109f, -0.04749447f, 0.08246403f, -0.30964115f, 
    0.12590005f, 0.04143605f, 0.01760597f, -0.08874991f, 0.06706791f, 0.05718293f, 0.02686365f, 0.03767582f, 
    -0.03847975f, 0.31077492f, -0.04373081f, 0.00617661f, -0.16052799f, -0.14012234f, -0.09889863f, -0.07987592f, 
    -0.02286423f, -0.06996416f, -0.02020603f, -0.01433422f, 0.12620367f, 0.22130767f, 0.10515703f, 0.24098644f, 
    0.16602719f, 0.07674402f, 0.04444481f, 0.19645286f, -0.05726509f, 0.28775561f, 0.10102410f, -0.19664933f, 
    0.47895050f, 0.53243238f, 0.15886687f, 0.02437505f, -0.03072540f, -0.02238872f, -0.11094897f, -0.08604673f, 
    0.18077204f, 0.08427680f, 0.10264703f, 0.10568964f, 0.06132484f, -0.08744647f, -0.19484000f, 0.01217843f, 
    -0.17749730f, 0.22807996f, 0.02309128f, 0.12354478f, 0.08771914f, 0.05502688f, 0.11066747f, 0.16834959f, 
    0.12527628f, 0.03749475f, -0.04404668f, 0.02993398f, 0.05687196f, -0.03091497f, -0.08333399f, -0.09469730f, 
    0.04703156f, 0.05578461f, -0.07306437f, 0.11361917f, -0.02028058f, 0.26908171f, -0.05018342f, -0.20359606f, 
    -0.03391952f, 0.11432061f, 0.07049556f, 0.03579683f, -0.00429544f, -0.09766567f, 0.06687103f, 0.02252832f, 
    -0.55048323f, -0.00120816f, 0.01368081f, 0.30143788f, 0.06777603f, 0.02261596f, -0.04865678f, 0.13850182f, 
    0.21986626f, 0.09272412f, 0.03394156f, 0.12479600f, 0.33805105f, -0.10412454f, 0.13177662f, 0.07409987f, 
    0.15157034f, -0.10582227f, -0.08412325f, -0.00363229f, 0.02121127f, 0.01001282f, -0.00737955f, 0.03292055f, 
    0.12631689f, -0.11960545f, 0.08112342f, -0.03946812f, 0.13708110f, 0.05962498f, 0.18181404f, 0.08560992f, 
    0.15901266f, 0.10605188f, 0.08814679f, 0.11745406f, 0.43817961f, 0.17519814f, 0.21980388f, 0.13221428f, 
    0.00301759f, 0.01323803f, 0.02015111f, 0.17622480f, 0.12868807f, 0.04940786f, 0.04286860f, 0.11918337f, 
    -0.37933773f, 0.23080325f, -0.08268549f, -0.11929080f, 0.13745683f, 0.06428687f, -0.06172467f, 0.25771600f, 
    0.04657705f, 0.02620153f, 0.08037117f, 0.25082508f, -0.08096121f, -0.17404723f, -0.11324429f, -0.27220371f, 
    0.13225029f, -0.05577375f, 0.12072649f, -0.08442257f, 0.15413263f, 0.08412667f, 0.08125272f, 0.08453097f, 
    0.06090334f, -0.20302211f, -0.22817585f, -0.02912167f, -0.08940471f, 0.01311963f, 0.15941264f, -0.05005206f, 
    -0.00801703f, -0.00903443f, -0.12369771f, -0.04156789f, -0.28132766f, 0.09345699f, -0.01692256f, -0.08189978f, 
    -0.07797638f, 0.06623702f, 0.01729056f, -0.06431919f, 0.06838311f, -0.00994847f, 0.25674939f, 0.06673427f, 
    0.08777288f, -0.10103104f, 0.16958401f, 0.20357265f, -0.08149131f, -0.20724306f, -0.04875604f, 0.14011025f, 
    0.12493555f, 0.15291712f, -0.12915859f, -0.01118166f, -0.49150535f, 0.44704238f, -0.22721547f, 0.13427007f, 
    0.19443496f, -0.09782746f, -0.06192632f, 0.04581787f, 0.06988550f, -0.08259876f, 0.06468638f, 0.05159761f, 
    0.06767600f, -0.23651867f, 0.12950522f, -0.14966521f, 0.03575110f, -0.03705727f, 0.06134905f, 0.12406672f, 
    0.12064657f, 0.09557489f, 0.07292357f, 0.18645582f, 0.05730443f, -0.14426988f, -0.21682869f, -0.03292431f, 
    0.06823049f, 0.16246574f, 0.08393827f, 0.07692429f, 0.18273719f, -0.00361892f, -0.14412089f, -0.04965886f, 
    0.06501056f, -0.14555782f, -0.02113725f, 0.00037825f, 0.25602686f, 0.01044400f, 0.11017774f, -0.04470160f, 
    0.09118400f, -0.04383427f, -0.02294347f, 0.01454154f, -0.06671519f, -0.21168762f, -0.25754246f, -0.08643376f, 
    0.06714834f, -0.16770774f, -0.12599118f, -0.09803852f, -0.02561698f, 0.02054754f, 0.15415505f, 0.01464317f, 
    0.25836244f, 0.14503211f, 0.33829966f, 0.32123452f, 0.16982117f, 0.18398480f, -0.04067847f, -0.20982128f, 
    0.02819950f, 0.07954089f, -0.15766336f, 0.03676561f, 0.26530227f, 0.20787747f, -0.12797162f, 0.07583093f, 
    -0.04413685f, -0.02239123f, 0.00675587f, 0.16598777f, -0.00850139f, 0.01279160f, 0.02730433f, 0.07263241f, 
    0.12619591f, -0.01712471f, 0.05283708f, -0.07041784f, 0.08658508f, -0.04624395f, -0.06478235f, 0.05946502f, 
    0.05563499f, 0.15349796f, 0.05870416f, 0.07213274f, 0.30151820f, 0.00873015f, 0.33781236f, 0.19154222f, 
    0.12070337f, -0.02546502f, -0.15519114f, -0.27291033f, 0.12723498f, -0.05657659f, 0.22949837f, 0.06147886f, 
    0.04378858f, 0.11973872f, -0.03732772f, -0.25731000f, -0.00348358f, 0.01821463f, -0.00214052f, 0.14376658f, 
    0.08748481f, -0.03183747f, -0.05266657f, 0.15378769f, -0.21158344f, -0.17436673f, -0.16030915f, 0.11427467f, 
    -0.07668500f, -0.08377150f, 0.00009241f, 0.01178908f, -0.07872052f, -0.02212914f, -0.05465849f, 0.18910977f, 
    -0.25391835f, -0.28149426f, 0.01292287f, -0.19992936f, -0.00687106f, -0.00396938f, -0.05792681f, -0.13904327f, 
    -0.14851348f, 0.02113768f, 0.05210632f, 0.18892403f, -0.41369063f, -0.03021037f, 0.07417104f, 0.20213525f, 
    -0.04515056f, -0.08711486f, -0.14111982f, 0.12364262f, -0.01114302f, -0.04997294f, 0.01142765f, 0.00061826f, 
    -0.55721307f, -0.21564865f, -0.01465867f, -0.07516465f, -0.14378533f, 0.11485570f, 0.08420116f, -0.05839995f, 
    0.18701774f, -0.09928530f, 0.04905517f, -0.05743153f, -0.03891353f, 0.04476777f, -0.05228765f, 0.08721619f, 
    0.03790336f, -0.07221483f, -0.03083908f, -0.03930185f, 0.11622947f, -0.00127011f, 0.13422921f, 0.06434788f, 
    0.07192564f, 0.27267835f, 0.26570326f, 0.25029135f, 0.04798736f, -0.08879493f, -0.14761914f, -0.03350478f, 
    0.21198390f, 0.05017310f, 0.05442424f, -0.02692491f, 0.34869981f, 0.04108784f, 0.14263538f, 0.08845906f, 
    -0.01829498f, -0.02694448f, 0.01351140f, 0.05953554f, 0.03875187f, 0.14372937f, 0.02089128f, 0.01343574f, 
    -0.22411348f, -0.01201135f, -0.38458467f, -0.21184580f, 0.04246650f, 0.03447787f, -0.08338863f, 0.00555015f, 
    -0.02111215f, -0.00515261f, -0.09448504f, 0.13319780f, -0.26710773f, -0.09605884f, 0.00821543f, -0.17463906f, 
    0.04498692f, 0.05237985f, 0.05186394f, 0.20592232f, -0.10911044f, -0.04281044f, -0.07962350f, -0.08862060f, 
    0.04967320f, -0.01000142f, -0.05501462f, 0.02531181f, 0.00369785f, -0.05958023f, 0.02238824f, -0.06444412f, 
    0.04088148f, -0.04714755f, -0.04529488f, -0.03595690f, -0.00897469f, 0.05762373f, -0.05184325f, 0.04726122f, 
    -0.03392093f, 0.02514019f, -0.07345705f, -0.06991454f, 0.01036824f, 0.05402206f, -0.01698676f, 0.02302148f, 
    0.00643237f, -0.03980758f, -0.00904102f, -0.02281289f, -0.05623074f, 0.04120632f, 0.01021402f, -0.07294396f, 
    -0.03602989f, -0.04920242f, -0.01133318f, 0.02846446f, 0.02578271f, -0.04556322f, 0.06486106f, 0.03255069f, 
    0.00818551f, -0.01904878f, -0.00590346f, 0.05487214f, -0.05130341f, -0.01990112f, -0.05787377f, -0.00965525f, 
    -0.04337602f, -0.02434935f, -0.04593276f, -0.01627665f, -0.01361241f, 0.00946955f, -0.06285580f, 0.01284166f, 
    -0.04940221f, -0.00883420f, 0.00343291f, -0.02138084f, 0.05273396f, -0.01409201f, -0.03955294f, -0.02537188f, 
    -0.01568613f, -0.03936848f, -0.04315329f, -0.05694396f, -0.04030310f, -0.04063713f, -0.05635166f, -0.06353129f, 
    0.02697296f, -0.02926745f, -0.03481936f, 0.01889523f, -0.03431362f, 0.00763123f, 0.00209484f, 0.04471577f, 
    0.02781172f, 0.01728556f, -0.01201583f, 0.05085247f, 0.04528483f, 0.00861293f, 0.02338857f, -0.06123246f, 
    -0.05015092f, -0.04130366f, 0.02260929f, -0.01626179f, -0.06041410f, -0.07700974f, -0.04410480f, -0.00744453f, 
    -0.03663999f, -0.00741380f, -0.03175521f, -0.01067944f, -0.04493185f, 0.03575010f, -0.03775267f, -0.04058114f, 
    0.01026861f, 0.00339753f, -0.04216425f, -0.01596083f, -0.05535672f, -0.05110377f, 0.05039767f, -0.04679034f, 
    -0.04791821f, -0.06466754f, 0.00930387f, 0.03909961f, 0.06113813f, 0.02637885f, -0.07105785f, 0.05873200f, 
    -0.04905665f, -0.05998955f, 0.05459172f, -0.03199269f, -0.06665965f, -0.05148239f, -0.00962806f, -0.01264802f, 
    -0.03436985f, 0.00495624f, 0.02189219f, -0.04720616f, -0.00441953f, 0.00465901f, -0.02126974f, 0.00598053f, 
    0.04586774f, -0.03224056f, -0.04777392f, -0.07514139f, -0.03607965f, 0.02359499f, 0.03336332f, 0.03969148f, 
    -0.04461073f, 0.04304825f, -0.02357732f, 0.04527930f, -0.06949973f, -0.06809227f, -0.04675731f, 0.05166035f, 
    0.02153210f, 0.00266532f, -0.03053553f, -0.07197967f, 0.04263572f, 0.04890016f, 0.00317513f, -0.01595963f, 
    -0.02334605f, 0.01294509f, -0.05933125f, 0.03994335f, 0.00700857f, 0.02323410f, 0.05895187f, 0.05986103f, 
    -0.00022124f, 0.04615339f, 0.00097665f, -0.07008256f, -0.02556067f, 0.03222970f, -0.06583825f, -0.02347424f, 
    -0.01191555f, -0.03012474f, 0.02484442f, 0.06615590f, 0.05525877f, 0.02844614f, -0.00763819f, -0.05972320f, 
    0.02118316f, -0.05610529f, -0.00869331f, -0.00438788f, -0.03176129f, -0.05011036f, 0.03234142f, 0.05870801f, 
    -0.11470486f, -0.34086388f, 0.24389456f, -0.02609557f, 0.14049213f, 0.03886006f, -0.03266081f, -0.01537558f, 
    -0.04967353f, 0.00225142f, 0.01521781f, 0.08653221f, 0.14249080f, 0.19058703f, -0.03844155f, 0.33353904f, 
    0.02062613f, -0.05456933f, 0.12485814f, 0.00462426f, -0.00547560f, 0.10610461f, 0.03832398f, -0.08004609f, 
    -0.56785607f, -0.03558127f, -0.24618623f, -0.32891342f, 0.14567542f, -0.07229882f, -0.13195582f, -0.01863715f, 
    0.09807389f, 0.00219896f, 0.16959824f, 0.02657717f, -0.22991532f, -0.09585313f, 0.10581935f, 0.17700134f, 
    0.01479986f, 0.05127400f, 0.07543425f, 0.15915053f, 0.13938040f, 0.08925926f, -0.11173846f, 0.06988093f, 
    0.13323961f, -0.00761707f, -0.05551405f, -0.13684009f, 0.04585011f, 0.06584097f, 0.05485703f, -0.04197447f, 
    0.10037407f, 0.08352181f, 0.11028394f, 0.13001746f, -0.32834563f, 0.01627767f, -0.15145370f, -0.53273946f, 
    0.15986265f, -0.06600451f, -0.00721743f, 0.04221267f, -0.00630556f, 0.00034072f, 0.01443912f, 0.00309875f, 
    -0.06148151f, 0.13239366f, -0.35295939f, 0.41136238f, 0.17156148f, -0.02016066f, 0.02038631f, 0.19779249f, 
    0.04078443f, 0.11164533f, 0.09413046f, -0.00650703f, -0.34085387f, 0.08295505f, 0.24822673f, -0.16269028f, 
    0.07264288f, 0.00701915f, -0.11004549f, 0.09506494f, -0.02107770f, 0.12808147f, 0.03320180f, 0.02494711f, 
    0.24760790f, 0.18618166f, -0.09048909f, 0.07177668f, 0.10359123f, -0.06240467f, 0.08389534f, 0.21903482f, 
    0.09149756f, 0.03838081f, 0.05957960f, 0.09790537f, 0.23787808f, 0.22523294f, 0.14740717f, -0.02606596f, 
    -0.09369081f, -0.00243698f, 0.03408049f, -0.03788472f, -0.13724878f, 0.02906215f, -0.04938849f, -0.10546248f, 
    0.13233513f, -0.05973076f, -0.07105416f, 0.26687053f, -0.05010073f, 0.00667397f, -0.01119672f, 0.00515873f, 
    -0.08945698f, 0.22300819f, 0.00919403f, 0.10800739f, -0.07397525f, -0.08364732f, -0.06144017f, -0.17203656f, 
    -0.03267816f, 0.06550661f, -0.04891738f, 0.13978928f, 0.04587064f, 0.08216165f, 0.13068117f, 0.08740773f, 
    -0.14360613f, -0.06760027f, -0.20698753f, -0.30633307f, 0.12619492f, -0.13792674f, -0.10426295f, 0.12120246f, 
    0.02686103f, -0.03138451f, -0.03035735f, 0.21675219f, -0.22774188f, 0.03777982f, -0.16938561f, -0.10579463f, 
    0.07442671f, -0.07626641f, -0.11219044f, 0.10826772f, 0.03664999f, 0.04291686f, -0.03393214f, -0.03233018f, 
    -0.16115499f, 0.09823719f, -0.07657761f, 0.12325781f, 0.07844762f, 0.09692010f, 0.00795650f, -0.00880279f, 
    0.10108688f, 0.06079673f, -0.04325235f, 0.01019435f, 0.02758829f, -0.04413651f, 0.21958257f, 0.26674652f, 
    0.01080342f, 0.06040111f, -0.08543996f, -0.14221627f, 0.18254556f, -0.17453477f, -0.00453528f, 0.30687264f, 
    -0.52138507f, -0.08620696f, -0.18737569f, 0.01086172f, 0.05280742f, -0.01975578f, 0.01738531f, 0.03691391f, 
    0.07779127f, 0.12770940f, 0.04826530f, 0.00564166f, -0.29890382f, 0.38449416f, 0.22574210f, 0.10280066f, 
    0.00040770f, -0.02093913f, 0.15536541f, 0.04756752f, -0.04971201f, -0.04224011f, 0.15315163f, 0.11371680f, 
    -0.38360882f, -0.06297033f, -0.04329477f, 0.08772349f, 0.05926940f, -0.14199267f, 0.02485327f, -0.04646239f, 
    -0.02503808f, 0.07788859f, 0.17791687f, 0.01086736f, -0.09728791f, -0.13308835f, -0.12179540f, -0.13520463f, 
    0.05165123f, 0.06759463f, -0.11480150f, 0.05839040f, 0.08610721f, 0.12633753f, -0.19670905f, 0.06838571f, 
    -0.06234964f, -0.29045337f, 0.02865526f, -0.03531045f, -0.01455773f, 0.11276176f, 0.08502214f, 0.09422050f, 
    0.05666364f, -0.13416249f, 0.08483977f, -0.02541214f, 0.00411504f, -0.08222795f, -0.09665163f, 0.05454205f, 
    0.03258742f, -0.07704194f, -0.00698959f, 0.00292470f, 0.09229640f, 0.03063229f, -0.10883551f, -0.06238287f, 
    -0.11803550f, 0.28712052f, 0.07464995f, 0.26545447f, -0.01687676f, 0.02505993f, 0.07607368f, 0.05494116f, 
    0.06062300f, 0.12088635f, 0.07285830f, 0.09225886f, 0.02994528f, -0.12731844f, -0.08082501f, 0.13710445f, 
    0.04716868f, 0.11406095f, -0.15424617f, 0.08194616f, 0.06321705f, 0.09890357f, 0.03852012f, 0.00614151f, 
    -0.26750669f, -0.00917120f, 0.17055288f, -0.10026478f, 0.07856914f, -0.16146111f, -0.01579237f, 0.11292077f, 
    0.06322210f, 0.09479988f, -0.05840145f, 0.14644532f, 0.24214596f, 0.17267899f, 0.08172389f, -0.12142189f, 
    0.02778257f, 0.13799612f, 0.08011036f, -0.13056481f, 0.00561359f, 0.03141315f, -0.06023585f, 0.11022401f, 
    0.12891500f, 0.13453218f, 0.03622187f, 0.07199010f, 0.01824219f, -0.10583074f, 0.05250270f, 0.08870316f, 
    0.00324040f, 0.06451851f, 0.09103786f, 0.01899698f, -0.08653901f, 0.10352527f, 0.32755247f, 0.25963780f, 
    0.01894824f, 0.00427921f, -0.05367096f, 0.05304274f, -0.01607472f, 0.03438096f, 0.10076767f, -0.00162806f, 
    -0.13071622f, 0.05873867f, -0.13722956f, 0.15130220f, -0.01270570f, -0.14036258f, -0.14312999f, 0.00722469f, 
    0.17786877f, 0.06209153f, -0.20467903f, 0.19367437f, -0.48010007f, 0.29183453f, -0.00951098f, 0.00804551f, 
    0.05312730f, -0.04296527f, 0.05345313f, 0.10246303f, 0.00643894f, 0.03345369f, -0.05944344f, -0.12756999f, 
    0.10144492f, -0.03146346f, 0.01868888f, 0.20012605f, -0.05330039f, 0.13418882f, 0.04911641f, 0.06193069f, 
    -0.03397834f, 0.08918345f, 0.11568645f, -0.07245872f, 0.18156233f, 0.03619779f, 0.03453833f, 0.22247006f, 
    0.05156291f, 0.02075437f, -0.18634714f, 0.03697646f, 0.01638149f, 0.01613639f, -0.01939398f, 0.06218325f, 
    0.24178411f, -0.10500703f, 0.32499588f, 0.11718656f, 0.02550322f, 0.03511947f, -0.00867336f, 0.07370799f, 
    -0.15223192f, -0.10251176f, -0.02689402f, 0.11558899f, 0.17505519f, -0.22050589f, -0.29081091f, 0.17971744f, 
    0.14920808f, 0.07226326f, -0.05058673f, 0.02338783f, -0.02358039f, -0.00379026f, 0.05125948f, -0.08839505f, 
    0.01791323f, 0.09896573f, 0.00071305f, -0.06100320f, 0.03427368f, 0.15966545f, 0.00426475f, 0.02060596f, 
    -0.01823574f, -0.09048543f, -0.01321112f, -0.02471615f, 0.24068198f, 0.15880817f, -0.02931970f, 0.29445583f, 
    -0.00936940f, -0.06790416f, 0.08446841f, 0.05807881f, 0.04594864f, 0.01383909f, -0.00234467f, 0.03560184f, 
    -0.04224852f, 0.31031200f, 0.07405229f, -0.12799971f, 0.20738539f, -0.05183407f, 0.13323867f, 0.01272575f, 
    -0.09310951f, 0.13936982f, -0.00001261f, 0.01559772f, -0.11695057f, 0.03823923f, 0.08217328f, -0.26198792f, 
    -0.00256538f, -0.06739482f, 0.07177678f, -0.04932013f, 0.07555665f, -0.01967809f, 0.04543492f, 0.04215188f, 
    0.14572170f, 0.34630516f, -0.28049910f, 0.06149135f, 0.10995514f, 0.03256433f, -0.07653569f, -0.03537522f, 
    0.00961469f, 0.02750248f, 0.10564210f, 0.02589819f, -0.35210964f, 0.14472152f, 0.15335628f, -0.04037884f, 
    0.03363582f, 0.01238881f, 0.07402736f, -0.05060655f, 0.02689535f, -0.02047868f, -0.00851120f, -0.01738404f, 
    0.24528128f, 0.00884106f, -0.10605659f, 0.08062357f, 0.05092046f, 0.15767096f, 0.10982011f, -0.02550401f, 
    0.11809738f, 0.00092182f, 0.02047455f, -0.04172098f, -0.36397409f, -0.22404525f, -0.20019829f, -0.24024640f, 
    -0.02549370f, 0.04411128f, -0.08745793f, -0.09816954f, 0.03549205f, 0.01669926f, 0.04849213f, 0.01714518f, 
    -0.44369221f, -0.29031622f, 0.06977896f, 0.27337882f, -0.14307249f, -0.03777128f, 0.07362956f, -0.15293823f, 
    -0.01885087f, 0.03879987f, 0.08292152f, -0.02040472f, 0.31233731f, -0.22057892f, 0.00526488f, -0.32809478f, 
    -0.07634220f, 0.03937328f, -0.00267849f, 0.15831606f, 0.02250851f, -0.04576195f, 0.06002411f, -0.00335431f, 
    0.01504290f, 0.03880467f, 0.19129318f, -0.26386315f, 0.06230702f, 0.06393452f, -0.00685154f, 0.06433333f, 
    -0.09554359f, 0.02758408f, 0.07127739f, -0.05308055f, 0.35865083f, -0.34512556f, 0.03048265f, -0.07766072f, 
    0.04659992f, -0.04674245f, -0.01033867f, -0.03035217f, 0.04203080f, -0.01333819f, 0.17986369f, -0.00933903f, 
    -0.13367240f, 0.24653874f, -0.17042381f, -0.04486096f, 0.07802749f, 0.04598498f, -0.04330190f, -0.02069061f, 
    0.10097157f, 0.07174014f, 0.06604508f, 0.07750226f, -0.07576519f, -0.02053696f, 0.15370843f, -0.18708722f, 
    0.00734441f, 0.10967077f, 0.01883078f, -0.04147298f, 0.09027614f, 0.12792623f, 0.06434920f, 0.00066734f, 
    -0.02510115f, -0.00461820f, -0.02406103f, -0.06979493f, 0.02863720f, -0.01368403f, -0.02618671f, 0.03901144f, 
    0.02250237f, 0.01369801f, -0.03500924f, 0.06092960f, -0.02863005f, -0.04979112f, -0.03267092f, -0.02262845f, 
    0.02045395f, 0.02918781f, -0.02902727f, 0.02850082f, 0.04683178f, 0.03296698f, 0.01472066f, -0.00281005f, 
    -0.04896004f, -0.06511363f, 0.06336098f, 0.04322413f, -0.00937201f, 0.02859197f, 0.04881029f, -0.00094829f, 
    -0.00384905f, -0.03585815f, -0.00668584f, 0.05529251f, 0.02127154f, 0.04478364f, -0.01949704f, -0.01775912f, 
    -0.01128787f, 0.01852257f, -0.06088828f, 0.00353450f, 0.03602044f, 0.05879724f, -0.01622660f, -0.05581803f, 
    -0.07315563f, 0.02827784f, -0.05790402f, 0.00739240f, -0.00341121f, 0.01121259f, -0.01743164f, -0.01628148f, 
    -0.05221637f, -0.01708115f, -0.07714386f, -0.03660967f, 0.00789794f, -0.06643470f, -0.06767651f, 0.03063603f, 
    0.05047837f, 0.04058956f, -0.04046305f, 0.05480159f, 0.03404722f, -0.00957699f, 0.01539067f, -0.08130732f, 
    0.01729160f, 0.04751826f, -0.00270390f, -0.00124540f, -0.06488039f, 0.04647519f, -0.06978076f, 0.03254480f, 
    -0.06039209f, -0.04849549f, -0.03813203f, 0.04573599f, -0.04115858f, 0.01961630f, 0.04502757f, 0.03078383f, 
    0.05801440f, 0.05881445f, -0.00075027f, 0.02394610f, 0.02356125f, -0.01328811f, 0.04137501f, 0.02079225f, 
    -0.04136407f, -0.07045268f, -0.06628370f, -0.06263974f, 0.05778813f, -0.04507677f, -0.03849336f, -0.06234520f, 
    -0.03167851f, 0.00321677f, -0.04911608f, 0.05052474f, 0.06235248f, -0.05692316f, -0.02997929f, -0.05854076f, 
    -0.01501619f, -0.03986198f, 0.07086000f, 0.06339108f, -0.03261491f, -0.04025634f, -0.00456224f, 0.00269580f, 
    -0.06240946f, 0.04362789f, 0.03997111f, 0.03849288f, -0.01450117f, -0.04212308f, 0.04038355f, 0.03394889f, 
    0.04871791f, 0.02963415f, -0.07654213f, -0.00608093f, 0.02122921f, 0.04237186f, -0.00178000f, -0.05973287f, 
    -0.00751038f, 0.03753006f, -0.06957222f, -0.06386524f, 0.03522035f, 0.00038785f, -0.00741591f, -0.04733836f, 
    -0.01667435f, -0.06902880f, -0.00385799f, -0.03674786f, -0.07314084f, 0.00600285f, -0.05617503f, 0.01808725f, 
    -0.02834545f, 0.05847971f, 0.02264732f, 0.03905496f, 0.03762427f, -0.01274815f, -0.05924544f, -0.03619029f, 
    -0.01639771f, 0.03347845f, 0.01420289f, -0.06278635f, -0.02834111f, -0.01314869f, -0.01941045f, -0.07724626f, 
    -0.01649284f, 0.05598746f, -0.04804463f, 0.03260358f, 0.02123242f, -0.02736722f, 0.04502820f, -0.03829751f, 
    -0.03171375f, 0.04993740f, -0.01158701f, -0.03643188f, 0.06168271f, -0.04935328f, 0.01472037f, 0.00662173f, 
    -0.05190356f, -0.03507860f, 0.03860767f, -0.01194711f, 0.00250307f, -0.00064645f, -0.02509141f, -0.03449391f, 
    0.04797756f, -0.08118960f, 0.06917635f, -0.08374725f, -0.02353283f, -0.07260041f, 0.00832792f, -0.10783286f, 
    0.02260595f, -0.04933254f, 0.09341813f, -0.12139945f, -0.07457734f, -0.08687590f, 0.18310989f, -0.30694708f, 
    0.05713996f, -0.02082306f, 0.03228787f, 0.19581343f, 0.02733916f, 0.18594429f, -0.09190678f, -0.08649954f, 
    0.37278944f, 0.27060816f, -0.03990866f, -0.13828084f, -0.06738546f, -0.07876822f, -0.01651740f, 0.10126773f, 
    0.10943367f, 0.07485125f, 0.01540920f, -0.03320603f, 0.22591095f, -0.22881967f, 0.31013548f, -0.17675684f, 
    -0.09443660f, -0.14119595f, -0.01876703f, 0.04578506f, -0.14455825f, 0.09203014f, 0.24105147f, 0.11285984f, 
    0.12975265f, 0.04934729f, -0.07756004f, -0.04235901f, -0.14451464f, 0.24236533f, -0.06797150f, -0.16683394f, 
    -0.04431232f, 0.01561474f, -0.09838487f, -0.06536443f, 0.08212738f, 0.36327860f, -0.04057151f, 0.37285829f, 
    -0.07386878f, 0.08781323f, 0.01737761f, 0.05207019f, -0.20156910f, 0.04480385f, -0.15371947f, 0.00638048f, 
    -0.30671054f, 0.11153760f, 0.18828590f, -0.08418868f, 0.14785066f, -0.05337044f, -0.07410259f, 0.11589393f, 
    0.00707138f, 0.08459000f, 0.00096180f, 0.00678602f, 0.00278255f, -0.18729120f, 0.34261942f, 0.03809875f, 
    -0.23160140f, -0.04337539f, 0.07259899f, -0.17996189f, -0.11748691f, 0.05994992f, -0.00888367f, -0.08886642f, 
    0.09082669f, 0.07470816f, -0.29983777f, 0.12836716f, -0.05241363f, -0.03959773f, 0.04979918f, -0.01370596f, 
    -0.03804115f, -0.11701141f, -0.03467680f, -0.26378682f, 0.17430115f, 0.01808680f, 0.14466989f, 0.43020225f, 
    0.13855177f, 0.08282747f, 0.13088733f, 0.44952154f, 0.01236223f, 0.00624385f, 0.18519448f, 0.01325153f, 
    0.14118695f, 0.03512320f, 0.00490378f, -0.24635868f, 0.27611852f, 0.21650173f, -0.05074727f, -0.02418974f, 
    0.10199462f, 0.08365653f, 0.15938708f, 0.15338059f, -0.43585977f, 0.14245279f, -0.09351359f, -0.03332020f, 
    0.00564785f, 0.17357279f, -0.00616159f, -0.05589685f, -0.15777354f, 0.02668321f, -0.09764486f, -0.09145714f, 
    0.13355288f, 0.29650584f, -0.01677345f, 0.33419880f, -0.11498636f, 0.23059288f, 0.02375865f, -0.11096991f, 
    -0.10949226f, -0.12651154f, 0.03241267f, -0.01529443f, -0.18408108f, 0.10492067f, 0.02701839f, 0.18276013f, 
    -0.13632800f, 0.00831715f, -0.05179836f, 0.01111428f, -0.04909666f, 0.16518453f, 0.00011012f, 0.11681497f, 
    -0.06978451f, 0.23938628f, 0.16700473f, 0.04464794f, 0.04287861f, -0.04318162f, 0.05931068f, 0.08617542f, 
    -0.14608270f, 0.08605438f, -0.04044403f, -0.14949720f, -0.19972147f, -0.03306921f, 0.26191342f, 0.00521698f, 
    0.06055549f, -0.02431616f, -0.00472291f, 0.06450520f, 0.05382928f, -0.06166751f, 0.21521966f, 0.29431775f, 
    -0.04156243f, -0.05653442f, -0.06809151f, 0.00973175f, -0.05233363f, 0.06231483f, -0.02311357f, 0.05284644f, 
    -0.06005608f, -0.06519040f, -0.00385022f, -0.07401508f, -0.03791458f, -0.06218176f, 0.01720284f, 0.06247824f, 
    0.04653547f, 0.02031323f, -0.06375814f, -0.06628634f, -0.02888317f, -0.03700567f, -0.07256541f, 0.06290880f, 
    -0.01743980f, 0.03540869f, 0.01374562f, -0.00499011f, 0.05257673f, -0.05193524f, -0.04055941f, -0.06402797f, 
    -0.03736627f, -0.04722012f, 0.01413554f, -0.02627266f, 0.03785620f, -0.03130933f, 0.01481718f, 0.05907460f, 
    0.01652797f, -0.03751724f, 0.03075929f, -0.05457415f, 0.02421769f, -0.00317153f, 0.02564792f, 0.01364406f, 
    0.01600803f, -0.00919435f, 0.04771143f, 0.02759222f, -0.06054813f, 0.04653959f, -0.04657289f, -0.05568425f, 
    -0.03747948f, -0.05339241f, -0.02864562f, 0.06040148f, -0.00482004f, -0.02372891f, 0.00044048f, 0.01476109f, 
    0.02597845f, -0.05978289f, -0.05537178f, -0.00159190f, 0.02843058f, 0.00795078f, -0.00063528f, 0.01394161f, 
    0.02382190f, -0.04858102f, 0.05834331f, 0.00465265f, 0.01427028f, -0.03005203f, -0.06653359f, 0.05015186f, 
    0.02262604f, -0.07661209f, -0.04627527f, -0.03826399f, 0.00900409f, -0.05898345f, 0.01293835f, 0.00952405f, 
    -0.04203020f, 0.05129568f, -0.00373582f, 0.00652309f, 0.00784039f, -0.05597525f, -0.03509483f, -0.01473878f, 
    0.02452498f, -0.04088201f, 0.02655765f, 0.06352400f, 0.05543972f, 0.02494906f, -0.03767922f, 0.05957961f, 
    0.05605596f, -0.01002453f, 0.02205982f, 0.01596012f, -0.05465242f, -0.05679114f, -0.04763778f, -0.06297411f, 
    -0.07281795f, -0.05745924f, -0.03764479f, -0.06727469f, 0.06290462f, -0.06606638f, -0.07890975f, -0.02184029f, 
    -0.05884087f, 0.03160218f, 0.03655582f, -0.04227614f, 0.05764839f, 0.04094756f, -0.01420029f, 0.00592070f, 
    0.03249379f, -0.06631710f, -0.00218393f, -0.05914383f, 0.03972067f, -0.06613931f, -0.05589163f, 0.06147275f, 
    -0.04772718f, -0.01892409f, 0.03812663f, -0.00890289f, 0.00746019f, -0.04583128f, 0.00618228f, -0.00719169f, 
    -0.00055614f, -0.04372009f, 0.03966455f, -0.06594459f, -0.06817206f, 0.02687130f, 0.00602718f, -0.01136471f, 
    -0.06533749f, 0.05205037f, 0.03370637f, 0.01793449f, -0.02903624f, 0.01266968f, 0.02638484f, -0.05462022f, 
    -0.05273092f, 0.02715684f, 0.04919469f, 0.02542020f, -0.02843252f, -0.07781995f, 0.01099919f, -0.03281882f, 
    -0.00446295f, -0.00139445f, -0.06672276f, 0.06413470f, -0.03510954f, -0.03625865f, 0.02982999f, -0.01295376f, 
    -0.02875279f, 0.05573070f, -0.05629580f, -0.05933828f, -0.02901394f, -0.06074431f, 0.03148956f, -0.05784169f, 
    0.00655037f, 0.04745015f, -0.00498886f, 0.03521553f, 0.02965725f, -0.01746815f, -0.06144108f, -0.07956943f, 
    -0.04688291f, 0.03903203f, 0.03529214f, 0.03347743f, 0.02981454f, 0.03692294f, 0.02694648f, 0.03737002f, 
    -0.05454473f, 0.04019508f, 0.01852461f, 0.04860632f, -0.01475184f, -0.05817084f, 0.03073209f, -0.01288871f, 
    0.03398938f, 0.02353022f, 0.01966160f, -0.00324254f, 0.05162985f, -0.03417134f, -0.03915507f, -0.03527847f, 
    0.00155143f, -0.01335197f, -0.00227053f, -0.01157785f, -0.00557489f, -0.07895574f, -0.00818826f, 0.05522524f, 
    -0.05776082f, 0.03593901f, 0.04435219f, 0.02351117f, -0.00777810f, -0.00534209f, -0.00531222f, -0.05637908f, 
    -0.07866444f, -0.00481670f, 0.05203157f, -0.01345370f, -0.05469786f, -0.06267513f, 0.01020882f, 0.04621066f, 
    0.04253151f, -0.02192594f, -0.01595347f, -0.07226033f, -0.00572676f, 0.05930487f, -0.00855537f, 0.04984270f, 
    -0.05776494f, -0.00689358f, -0.02827702f, 0.03925858f, 0.03962996f, -0.05960665f, 0.03230408f, 0.02749294f, 
    0.06281564f, -0.06787167f, -0.04533475f, 0.04928120f, -0.06827224f, -0.02621993f, -0.05087193f, 0.03964296f, 
    -0.07636219f, 0.02259822f, -0.04039906f, -0.03662398f, 0.00064827f, 0.00852139f, 0.05509954f, -0.06041070f, 
    -0.02890620f, -0.00430975f, -0.00175667f, 0.02740216f, -0.07646368f, -0.01487124f, -0.02246210f, 0.02306092f, 
    0.04015844f, -0.00754151f, -0.06471583f, -0.00076435f, -0.07761855f, -0.02772927f, 0.05059588f, 0.01039146f, 
    -0.05681743f, 0.06045276f, -0.03061295f, -0.03416638f, 0.03633001f, -0.05904720f, -0.08238729f, -0.00528024f, 
    0.02606809f, 0.00790696f, 0.03418967f, 0.05916987f, -0.02170721f, -0.08109731f, -0.02695976f, -0.01432871f, 
    0.03784426f, 0.01770178f, 0.01638844f, -0.01721013f, -0.07399209f, -0.05452785f, -0.06404854f, -0.03357081f, 
    0.01604630f, -0.00142524f, -0.07746541f, -0.07154834f, 0.03198795f, 0.03491042f, -0.03258502f, 0.01742402f, 
    0.04301517f, -0.03893525f, -0.01951239f, -0.04778695f, -0.07366270f, -0.05081722f, -0.07523192f, -0.05337743f, 
    0.06147569f, -0.04331508f, -0.01419147f, 0.02802844f, 0.00507954f, -0.02461649f, 0.02427080f, 0.01247551f, 
    0.04514019f, -0.02265511f, 0.00786513f, 0.05118660f, -0.07007232f, -0.07379494f, 0.00587372f, 0.03208525f, 
    -0.05454454f, -0.06583644f, 0.01852448f, -0.00024043f, -0.03937053f, 0.00410621f, 0.01041094f, -0.06759403f, 
    0.01169841f, 0.01031181f, -0.04613131f, -0.02547138f, 0.01908097f, -0.06657442f, -0.02379491f, 0.04440244f, 
    0.04164600f, -0.03878102f, 0.04509584f, -0.05047321f, 0.02370784f, 0.00706050f, 0.01274297f, 0.00475997f, 
    -0.00474175f, 0.01413120f, 0.01053414f, 0.01744053f, 0.01511643f, 0.02935384f, 0.06830492f, -0.00655224f, 
    -0.01351657f, -0.03717599f, 0.01161617f, -0.07026281f, 0.00939715f, -0.01446828f, -0.03010250f, 0.06151249f, 
    -0.03516137f, -0.01802607f, 0.04949211f, -0.05200701f, -0.05775976f, 0.02481679f, -0.06887509f, 0.01166732f, 
    -0.03856927f, 0.02931911f, 0.05900898f, 0.01543770f, 0.02192603f, -0.03688437f, -0.01424054f, 0.01639832f, 
    -0.05359663f, -0.06948233f, 0.04464146f, -0.06192132f, -0.05578656f, -0.06289111f, 0.05804078f, -0.04365766f, 
    -0.00525369f, 0.00457585f, -0.07013485f, -0.03544771f, -0.00203372f, -0.05846381f, 0.02166726f, -0.08306851f, 
    -0.07181937f, -0.06020996f, 0.06066834f, 0.01359080f, -0.06067456f, 0.05770684f, -0.02319214f, -0.02529300f, 
    -0.02811669f, 0.05731186f, -0.04799109f, -0.06250931f, -0.01950112f, 0.02843159f, 0.03227463f, 0.02538567f, 
    0.01291191f, -0.02335124f, -0.05529720f, -0.01121313f, 0.02435557f, 0.00406225f, -0.05381258f, -0.05589335f, 
    -0.07777421f, 0.00408394f, -0.00162511f, 0.00708830f, -0.04761336f, 0.00511450f, 0.00712051f, 0.06026633f, 
    -0.07581946f, 0.01636480f, 0.00194498f, 0.05017607f, 0.00266092f, -0.04649965f, 0.01817993f, -0.03666441f, 
    -0.02942272f, -0.01403945f, -0.00419958f, -0.07163160f, 0.03382253f, -0.05045716f, -0.06671194f, 0.01600666f, 
    -0.07445412f, -0.01232343f, -0.07765292f, 0.03468355f, -0.02875872f, 0.03672790f, 0.05133442f, 0.02194142f, 
    0.02963655f, 0.06160726f, -0.07344728f, 0.03771079f, -0.02914607f, -0.06911496f, -0.00033122f, 0.00345295f, 
    -0.06883977f, 0.02152960f, 0.05143528f, -0.07755470f, 0.04129700f, -0.07394705f, -0.01616776f, -0.03457819f, 
    0.00642223f, 0.05280416f, 0.00244193f, -0.02371749f, 0.00856712f, -0.02031003f, -0.01925288f, -0.00162011f, 
    -0.07489024f, -0.00036289f, -0.03016520f, -0.02275758f, 0.01793930f, -0.05418004f, -0.05903118f, -0.05752473f, 
    -0.05648759f, 0.04700748f, 0.01968065f, 0.04965739f, -0.07040119f, -0.05277944f, -0.00701652f, 0.02251133f, 
    -0.02922617f, 0.03886668f, -0.07465120f, 0.01466494f, 0.06356893f, 0.02423450f, 0.02541066f, -0.01243484f, 
    -0.00481902f, 0.05993363f, -0.00636802f, 0.05885971f, -0.07720658f, 0.03282565f, -0.00488172f, 0.01584753f, 
    0.05705089f, -0.00596364f, 0.00270568f, -0.01239518f, 0.05063253f, -0.05343553f, 0.01560078f, 0.04136758f, 
    -0.06883272f, -0.01781330f, 0.02283737f, -0.04398182f, -0.05828538f, 0.00890452f, 0.03275932f, 0.02171573f, 
    -0.06017613f, -0.04933405f, 0.05320101f, 0.04222821f, 0.02875910f, 0.04178489f, 0.00491695f, 0.01335415f, 
    0.00788275f, -0.03103651f, -0.06181006f, 0.01475900f, 0.04822307f, -0.03631557f, 0.01293265f, -0.08046296f, 
    -0.02927696f, -0.02235427f, -0.00534303f, 0.03492625f, 0.04466187f, 0.01691470f, 0.02305711f, -0.06416177f, 
    -0.05426855f, -0.05333091f, -0.02489777f, -0.02146232f, -0.07392178f, 0.00042154f, -0.02959665f, 0.02358568f, 
    0.00738373f, -0.01223133f, -0.04363726f, 0.06067443f, 0.04314522f, -0.01573174f, 0.02157412f, -0.00554043f, 
    0.05173526f, 0.02931978f, 0.01177670f, -0.01515480f, -0.07625175f, -0.06644341f, -0.05817217f, 0.01542075f, 
    -0.03235851f, 0.05963480f, -0.00100537f, 0.06865332f, -0.02387245f, 0.03189958f, -0.00396908f, -0.02689330f, 
    0.03298520f, 0.01958656f, 0.05614383f, -0.01323744f, -0.03813612f, 0.04101879f, 0.01026196f, 0.00480342f, 
    0.03035734f, -0.05867108f, -0.04139194f, -0.06515857f, -0.04391710f, 0.05339559f, -0.04710492f, -0.07611598f, 
    0.01482424f, 0.06455103f, -0.02368780f, -0.06749841f, 0.00975598f, 0.00866711f, 0.05641872f, -0.04571159f, 
    -0.02409410f, -0.00138517f, -0.02615860f, 0.00141798f, -0.02499532f, -0.01795541f, 0.01467698f, -0.01849402f, 
    -0.02848906f, 0.01044674f, -0.04968259f, -0.07509562f, 0.02036943f, 0.03924857f, -0.00109351f, -0.02774492f, 
    0.01884111f, 0.06166844f, -0.05807244f, -0.07784537f, -0.02335605f, -0.02920588f, -0.03891837f, 0.04993967f, 
    -0.04442595f, -0.04483985f, -0.06574056f, -0.05482123f, 0.03372727f, -0.06408527f, -0.05143827f, -0.01983760f, 
    -0.05227601f, 0.00389434f, 0.03278198f, 0.01173078f, -0.01445874f, -0.05919905f, 0.06275015f, 0.00662258f, 
    0.03879476f, -0.01154350f, 0.04268827f, 0.00826449f, 0.02943844f, 0.05911745f, 0.00358304f, -0.05026890f, 
    -0.04927788f, 0.03320271f, -0.03964556f, -0.00533557f, -0.00807254f, 0.00054828f, -0.03581649f, -0.06499527f, 
    -0.04971153f, -0.06488855f, -0.07319640f, -0.03398370f, -0.05926156f, -0.02128153f, 0.03758800f, -0.05067378f, 
    -0.02968743f, 0.04706243f, -0.05929066f, 0.01691488f, -0.01283645f, 0.04277391f, -0.00721842f, -0.01920382f, 
    0.00727097f, 0.02000320f, 0.06538159f, 0.02396138f, 0.02984035f, 0.00544813f, -0.07806545f, -0.03095960f, 
    -0.07983871f, -0.04818510f, -0.04254647f, -0.03809186f, -0.04463530f, 0.00368654f, -0.05190183f, -0.01568978f, 
    0.02165154f, -0.06733122f, -0.01530529f, 0.04245409f, -0.05140763f, -0.06521266f, 0.05050846f, -0.03436336f, 
    0.03575768f, 0.01513493f, -0.07420447f, -0.06464049f, 0.00665241f, 0.06512430f, 0.02949138f, 0.00863016f, 
    0.05219224f, 0.02976279f, 0.06634793f, 0.01380122f, -0.00567437f, -0.03687380f, -0.05712223f, -0.02658694f, 
    0.04624848f, -0.04422345f, -0.00416626f, -0.07213280f, -0.01288902f, 0.01813407f, 0.03032335f, 0.04944146f, 
    0.05996166f, 0.05333315f, 0.01689134f, -0.04692994f, 0.05265829f, 0.03087616f, -0.07076337f, -0.06290273f, 
    0.03732044f, 0.03869172f, 0.01321676f, -0.02931971f, -0.04434365f, -0.06124273f, -0.05884703f, 0.04351701f, 
    0.04666883f, -0.03033732f, 0.03652786f, -0.01308824f, -0.06834563f, -0.06009249f, 0.00386498f, 0.01417957f, 
    -0.42607871f, 0.02447667f, -0.05835900f, 0.17286666f, -0.09681191f, -0.01402837f, 0.08558431f, -0.14635430f, 
    0.15572207f, 0.03263567f, -0.03621334f, -0.16599560f, -0.25531405f, 0.14530116f, 0.15940005f, -0.14682677f, 
    0.07059155f, -0.06261487f, 0.07124045f, 0.14878576f, 0.02262485f, 0.06411357f, -0.07710914f, -0.04514783f, 
    -0.05566530f, 0.09600407f, 0.14890827f, -0.01147709f, -0.07200764f, -0.08218602f, 0.05115695f, 0.08966942f, 
    -0.06953406f, 0.06999575f, 0.05302224f, 0.08925191f, -0.20975354f, -0.32705423f, 0.27670741f, -0.11298059f, 
    0.01831887f, 0.11125234f, 0.04963492f, 0.03781175f, -0.04042962f, 0.12091372f, 0.16179532f, 0.03074415f, 
    0.08359718f, -0.29192817f, 0.07941132f, 0.04884356f, -0.13256410f, 0.17781433f, -0.14650701f, -0.21101525f, 
    0.02151403f, -0.06197171f, 0.10998536f, -0.02005995f, 0.12679014f, 0.22989181f, -0.01638815f, 0.21896525f, 
    -0.02798379f, 0.08318841f, -0.02860215f, 0.07102256f, -0.16117951f, 0.08002370f, 0.02749407f, 0.09194003f, 
    -0.05714494f, -0.16988942f, 0.15313943f, -0.00668953f, 0.05163941f, 0.00834469f, 0.01229949f, -0.00677955f, 
    -0.04639665f, -0.07043402f, -0.14287157f, 0.00744539f, 0.29923648f, -0.13243257f, -0.14402615f, 0.16402893f, 
    -0.06173760f, 0.14923440f, 0.05409980f, -0.13066840f, -0.02561970f, 0.04943237f, 0.04724577f, -0.06174421f, 
    -0.15464239f, 0.30228898f, -0.00817754f, -0.00964138f, 0.04152860f, -0.12817504f, -0.06289680f, -0.00905874f, 
    -0.14987712f, -0.00292373f, -0.09037317f, -0.24443804f, 0.29061595f, -0.00606548f, 0.06235886f, 0.20064545f, 
    -0.08803394f, 0.00744101f, 0.00251871f, 0.16730748f, -0.03946092f, 0.20395209f, 0.13923489f, 0.04759619f, 
    0.19575995f, 0.35724273f, -0.04271623f, -0.22170644f, 0.18903111f, 0.13896002f, -0.07126410f, 0.08741757f, 
    0.14585802f, 0.05442799f, -0.01648200f, 0.12086575f, -0.08148056f, 0.19080189f, 0.14283721f, 0.10374890f, 
    0.11149360f, 0.04822169f, 0.00163361f, -0.08780620f, 0.02471008f, 0.01868095f, -0.09333527f, -0.07005909f, 
    0.16679412f, 0.11308284f, -0.14623907f, 0.18872996f, -0.06458919f, 0.21452956f, -0.00346662f, -0.02113902f, 
    0.06911679f, -0.05948354f, 0.06387052f, 0.10231188f, -0.22439246f, 0.12569040f, 0.05806548f, -0.00209483f, 
    -0.13953355f, 0.03480794f, -0.08384463f, 0.08754274f, -0.07380710f, 0.04475125f, -0.03255175f, 0.18210410f, 
    0.08816466f, 0.02552927f, 0.13637528f, 0.21716723f, 0.09290831f, -0.08721655f, 0.06422719f, 0.08782098f, 
    -0.10963549f, 0.02638753f, 0.00230011f, -0.19951636f, 0.07379863f, -0.02157035f, 0.00226793f, 0.11717710f, 
    0.02570887f, 0.02032594f, 0.01056674f, 0.11655190f, 0.10271198f, -0.01683331f, 0.19763874f, 0.17409895f, 
    0.01731816f, -0.11878660f, -0.08440474f, -0.27504992f, 0.15087612f, -0.03819316f, -0.04109399f, -0.01374430f, 
    0.09111100f, -0.17491935f, -0.03921201f, 0.06788772f, 0.28549659f, 0.02036438f, -0.25996739f, -0.03538510f, 
    -0.09946496f, -0.06554936f, -0.03180225f, 0.07924181f, 0.06679980f, 0.15398221f, 0.22624867f, 0.06731600f, 
    0.08961286f, 0.10222828f, 0.10920475f, 0.02915248f, 0.16100189f, -0.02722414f, -0.10806584f, -0.13849683f, 
    -0.03205230f, 0.06777547f, -0.07704803f, 0.18953645f, 0.49956018f, 0.07920208f, 0.10150573f, -0.21822135f, 
    -0.22842634f, 0.03935162f, -0.08144601f, 0.03728135f, 0.04580220f, -0.10449015f, -0.12376807f, 0.00325169f, 
    -0.10448980f, 0.08242889f, -0.17306291f, 0.29184347f, -0.03517447f, -0.00784916f, -0.00851284f, 0.18985716f, 
    0.15522066f, 0.33609128f, 0.04272875f, 0.26697081f, -0.02557132f, -0.20983468f, 0.28613624f, 0.09229442f, 
    0.03713109f, -0.02310163f, -0.12489600f, -0.04109240f, -0.09418053f, -0.06448493f, 0.18360938f, -0.18597665f, 
    0.17387508f, 0.13751885f, 0.18206649f, 0.05680263f, 0.19107614f, -0.03529453f, -0.06079756f, 0.12525435f, 
    0.16278154f, 0.06751771f, -0.03344207f, -0.03881813f, -0.16443360f, -0.44849092f, 0.30743724f, 0.05016813f, 
    -0.13408373f, -0.02438468f, -0.01686110f, 0.10603616f, -0.06934746f, -0.03917686f, 0.03748982f, 0.18349738f, 
    0.08644290f, 0.12496173f, -0.28344151f, -0.18888983f, 0.25155300f, -0.13483013f, -0.09707429f, 0.17436662f, 
    -0.06543200f, 0.02756133f, -0.03071840f, 0.37372968f, 0.37703013f, -0.11328081f, 0.28729787f, 0.32418364f, 
    0.26000085f, -0.01032060f, 0.13088800f, 0.11789259f, 0.08942578f, 0.02607237f, 0.00918243f, 0.18194504f, 
    -0.53012455f, 0.03687800f, -0.35844505f, 0.00964161f, 0.02353173f, -0.23568137f, 0.17609999f, -0.09505694f, 
    -0.08152084f, -0.04444053f, -0.02057098f, -0.05961450f, -0.24894157f, -0.10165538f, -0.23519583f, 0.04301261f, 
    0.00908904f, 0.06294560f, -0.09080941f, -0.09488149f, -0.05420384f, 0.12339370f, 0.12799734f, 0.05129205f, 
    -0.03635865f, 0.02908949f, 0.01349483f, 0.10766698f, 0.00151213f, -0.08238547f, -0.11404058f, -0.00760652f, 
    0.19795467f, 0.21332210f, -0.02855764f, 0.06490902f, -0.12619951f, 0.31842229f, -0.02864612f, 0.11101319f, 
    0.05861669f, 0.00241574f, -0.09382385f, 0.01439908f, 0.00391079f, -0.10161790f, 0.01637943f, -0.20435795f, 
    0.14683628f, -0.20557684f, 0.04101207f, 0.04411037f, 0.01108945f, -0.06320964f, 0.02327409f, -0.02552411f, 
    0.03002095f, 0.03311862f, 0.10355338f, 0.28266266f, -0.04663236f, 0.08833781f, 0.10069853f, 0.11249658f, 
    0.24517329f, 0.13205154f, 0.16092514f, -0.00495654f, -0.03404538f, -0.08607794f, -0.18628825f, -0.36736515f, 
    0.84980607f, -0.00554022f, 0.05701831f, -0.28190205f, -0.08953522f, 0.09419369f, 0.07731075f, 0.01968029f, 
    0.08055425f, 0.15272336f, 0.18872152f, 0.13898702f, 0.46553937f, -0.03026075f, 0.07592492f, 0.10981885f, 
    0.02151020f, -0.00880563f, -0.01533647f, 0.00054396f, -0.00216039f, -0.06784491f, 0.11710854f, 0.00915124f, 
    0.44140494f, -0.17704050f, -0.03609289f, -0.01740697f, 0.20704618f, 0.04414471f, -0.05668001f, -0.06031840f, 
    0.05366698f, -0.00496713f, -0.13983905f, 0.00471986f, 0.10932418f, 0.40549123f, 0.19287482f, 0.15611868f, 
    -0.08410391f, -0.12126123f, 0.17584936f, 0.08374776f, -0.04513971f, 0.02998101f, 0.15741698f, 0.05986543f, 
    0.06978104f, 0.40024474f, -0.01290616f, 0.15897925f, 0.02906420f, -0.00989011f, -0.03514874f, -0.03451156f, 
    0.10066680f, 0.17211886f, -0.00289401f, -0.00938683f, 0.00277503f, -0.17961989f, 0.16528405f, -0.10074485f, 
    0.21195628f, 0.00818528f, 0.03080611f, -0.01288132f, -0.09083252f, -0.01761576f, 0.07011115f, -0.00231485f, 
    -0.11947444f, -0.05515940f, -0.13817371f, 0.05735186f, -0.01577261f, -0.03987482f, -0.07111657f, -0.03570946f, 
    0.10305680f, 0.01474194f, 0.05538645f, 0.01396418f, 0.20854990f, 0.08551221f, 0.10807315f, -0.00322370f, 
    0.17670062f, -0.11697204f, -0.13437739f, -0.01118848f, 0.01891578f, 0.07203423f, 0.10353731f, 0.11469750f, 
    0.18851978f, -0.16465080f, 0.06984321f, -0.14229889f, -0.04594185f, -0.00628465f, -0.07974365f, -0.05960806f, 
    0.04175458f, 0.01719938f, 0.01240246f, 0.03845007f, 0.05767953f, 0.39325875f, 0.25037608f, 0.20839356f, 
    -0.01640415f, 0.00414439f, -0.00892356f, 0.01557511f, -0.00078140f, 0.00807211f, -0.19335787f, -0.17284340f, 
    -0.11105160f, -0.26226673f, -0.12783161f, -0.06376579f, 0.04865327f, 0.11039381f, -0.05108245f, -0.12209728f, 
    -0.04565527f, -0.06214197f, 0.00616698f, -0.02216674f, -0.01440469f, -0.23453355f, -0.24898872f, 0.34195766f, 
    0.06293160f, 0.03653722f, -0.08274042f, 0.03021726f, 0.00461208f, -0.04995763f, 0.13170862f, 0.12336431f, 
    -0.20500976f, -0.13408841f, 0.27545246f, -0.01049327f, 0.30443040f, 0.06694749f, -0.02895206f, 0.05645720f, 
    -0.04111560f, 0.04632460f, 0.01356770f, 0.16228737f, 0.11392218f, 0.17262480f, -0.00962040f, -0.00041642f, 
    0.14067964f, 0.09314104f, 0.23051712f, 0.05474129f, 0.17246005f, 0.13098945f, -0.03424435f, -0.02668716f, 
    -0.27851826f, 0.01853925f, -0.20111725f, -0.00245603f, 0.13728763f, -0.05907683f, -0.00426593f, -0.07334930f, 
    0.05128963f, 0.06020540f, 0.00419061f, 0.07554276f, -0.17115133f, -0.10090443f, -0.07035147f, -0.11897427f, 
    0.00211074f, 0.06313068f, 0.03303698f, -0.29267430f, 0.11126997f, 0.08725938f, 0.18323041f, -0.11406273f, 
    -0.07122416f, 0.36711434f, -0.06500753f, 0.08539022f, -0.00629560f, 0.09890924f, 0.09779712f, -0.00781410f, 
    -0.02419402f, -0.01695114f, -0.06574872f, -0.07166888f, 0.13649161f, -0.04149251f, -0.09317742f, 0.00417656f, 
    0.00496291f, 0.19350354f, -0.07842457f, 0.11259673f, -0.01450585f, 0.02970057f, -0.13074037f, 0.07711611f, 
    -0.01758398f, -0.03229295f, 0.11521063f, 0.16048768f, -0.13697055f, -0.03295690f, 0.04658092f, 0.05666342f, 
    0.00226666f, 0.04310275f, -0.06710351f, 0.02578649f, 0.10431217f, 0.15970258f, -0.11100408f, -0.11129753f, 
    0.06833583f, 0.06916939f, -0.04200350f, -0.03751741f, -0.04936441f, 0.05068417f, 0.04158983f, 0.09960223f, 
    0.13666472f, 0.26738676f, -0.04590947f, 0.26890743f, 0.02018139f, -0.03086935f, 0.14221995f, -0.07650483f, 
    0.00973167f, 0.02308570f, 0.04305242f, 0.18597259f, 0.16846348f, 0.00014435f, -0.05754986f, 0.36864087f, 
    -0.07202785f, 0.04749853f, 0.04352630f, -0.15211329f, 0.01885739f, 0.23137848f, 0.11248586f, 0.07472211f, 
    0.27211756f, -0.13933215f, 0.18864958f, -0.10731521f, -0.14442296f, 0.14722681f, 0.07460652f, 0.07264669f, 
    -0.02547463f, -0.08352519f, 0.13517100f, -0.01121075f, 0.14953680f, 0.12352424f, -0.08361867f, 0.02448082f, 
    0.09454942f, -0.00620563f, 0.15188916f, -0.01874904f, -0.03396055f, -0.04811436f, 0.08630968f, 0.05505138f, 
    -0.01537725f, 0.12903887f, 0.20638345f, 0.16082811f, -0.02265407f, 0.12728290f, -0.04109616f, -0.03853549f, 
    -0.09996449f, 0.00344114f, 0.17608663f, -0.15085886f, -0.03164572f, -0.25303861f, -0.22218321f, -0.34127474f, 
    -0.00639134f, -0.13245618f, 0.06959926f, 0.09057407f, 0.06988915f, -0.03445069f, 0.04230049f, 0.07926567f, 
    0.28524059f, 0.13148305f, -0.05855876f, 0.06200117f, 0.02451067f, -0.04514843f, -0.12127605f, 0.09860040f, 
    0.12948759f, 0.08067420f, 0.04227528f, 0.09376515f, 0.39486372f, 0.07987589f, 0.02346071f, -0.29691499f, 
    0.18322581f, 0.11005332f, -0.01353421f, -0.03051757f, 0.03423770f, -0.06636320f, -0.10704848f, -0.11340846f, 
    0.13193263f, -0.13669379f, 0.14130118f, 0.14199618f, -0.20138033f, -0.02069072f, 0.07950015f, -0.12561780f, 
    0.02109123f, -0.04969924f, 0.20270933f, -0.11639045f, 0.72262245f, -0.27462700f, 0.15159960f, 0.05155260f, 
    -0.02017464f, 0.05373606f, 0.02776641f, -0.11420801f, 0.13819887f, 0.09112708f, 0.10147272f, -0.04004832f, 
    0.19390854f, -0.06509230f, 0.05046076f, -0.14872143f, 0.08405890f, 0.06719875f, 0.06994841f, 0.02282900f, 
    0.01672633f, -0.03399760f, 0.04718351f, -0.05015239f, 0.17421055f, -0.01630896f, -0.15478109f, -0.21477450f, 
    -0.21077274f, 0.05825690f, 0.13824116f, 0.05680401f, -0.02315780f, 0.01070190f, -0.01627802f, -0.00103758f, 
    0.17019142f, -0.37902039f, -0.16773833f, -0.06494932f, 0.03089358f, -0.10517361f, -0.04803270f, 0.07533277f, 
    0.01601241f, 0.04757348f, 0.03908370f, -0.02934869f, -0.17902617f, 0.21753846f, 0.13096176f, 0.09824304f, 
    0.17543316f, -0.01950029f, 0.02502848f, -0.01290161f, -0.04067507f, 0.01947718f, 0.04814134f, -0.00987766f, 
    0.03531292f, 0.08242401f, -0.10243405f, -0.20448324f, 0.07837193f, -0.03590292f, 0.05939220f, 0.09731187f, 
    -0.00019828f, -0.05809660f, -0.02787818f, -0.03196856f, 0.24707353f, -0.30741149f, 0.23833592f, 0.07922949f, 
    0.00555733f, -0.00738303f, -0.11996963f, 0.17911246f, 0.00554385f, 0.25951153f, -0.00812760f, 0.07588697f, 
    0.19097751f, -0.01063053f, 0.01932425f, -0.22864676f, -0.00206001f, -0.02770409f, -0.04681022f, -0.10334989f, 
    -0.08638183f, 0.03791571f, -0.04530211f, -0.15136725f, -0.30679816f, 0.13810816f, 0.05483284f, -0.23412935f, 
    0.01034772f, -0.07344652f, 0.07088818f, 0.04736079f, -0.11281715f, 0.04436219f, -0.17364922f, -0.10013721f, 
    -0.05010178f, 0.37853295f, -0.07065827f, 0.44590884f, 0.01206562f, 0.05729060f, -0.06907441f, 0.02837074f, 
    -0.11839196f, 0.04927559f, 0.02567149f, 0.07796696f, 0.09229332f, -0.01295633f, -0.09401364f, -0.00407322f, 
    -0.02561377f, 0.04583828f, -0.13945588f, -0.13114849f, -0.09392416f, 0.04328562f, -0.13328162f, -0.03287409f, 
    0.05623198f, -0.14399680f, -0.07708388f, 0.01961492f, 0.18866096f, -0.19317755f, 0.10422658f, -0.02464188f, 
    -0.01865099f, 0.00928867f, 0.03876622f, -0.02007381f, 0.13394146f, 0.23061948f, 0.21524981f, 0.37986326f, 
    0.11451019f, 0.20228587f, 0.09016898f, 0.24750520f, -0.09935531f, 0.12933700f, -0.08000048f, -0.07042509f, 
    -0.29355454f, 0.21058169f, 0.12151485f, 0.06192704f, 0.13199696f, 0.07351290f, 0.02666669f, 0.02180083f, 
    -0.05778641f, -0.03805920f, 0.07761005f, 0.04040992f, -0.05177734f, -0.33649415f, 0.02044048f, 0.30331716f, 
    -0.13785087f, 0.02762627f, 0.17534532f, 0.20369437f, -0.00299569f, -0.02016010f, 0.08022231f, -0.01593896f, 
    -0.00963192f, 0.31101611f, -0.13564399f, -0.14899908f, 0.03025125f, 0.07267808f, 0.04196501f, -0.12302191f, 
    -0.00370374f, 0.02666797f, -0.09736998f, 0.06009001f, -0.38823566f, 0.13885993f, 0.10336742f, 0.02700608f, 
    0.11075079f, -0.02200902f, 0.05262337f, -0.01789886f, -0.04658270f, 0.13178591f, -0.05038784f, 0.08488113f, 
    0.26840815f, 0.18482828f, -0.04709366f, 0.33541051f, -0.01517849f, -0.01382641f, 0.01305497f, -0.14205362f, 
    -0.14448838f, 0.06812040f, -0.14875564f, -0.16450071f, -0.00742297f, 0.25301608f, 0.35626915f, 0.29898468f, 
    0.10581386f, -0.00864719f, -0.07228041f, 0.09105848f, -0.06956623f, -0.03770699f, 0.24535415f, 0.15086760f, 
    -0.13205031f, 0.19862400f, 0.01849059f, -0.06768498f, 0.16210285f, 0.10524252f, 0.07965274f, 0.08531266f, 
    0.00557662f, 0.01545200f, -0.04157253f, -0.02313152f, -0.10838369f, -0.03249846f, -0.01070324f, -0.11491560f, 
    0.08663698f, 0.04203660f, 0.07803534f, 0.07942073f, 0.21227083f, 0.13580035f, -0.10968815f, 0.02772454f, 
    0.35710001f, 0.31615761f, 0.08137152f, 0.14010350f, -0.02982731f, 0.30168015f, 0.08469088f, 0.10969965f, 
    0.07805114f, 0.04820208f, -0.04212105f, 0.07766548f, 0.35053223f, -0.17400035f, -0.14363791f, -0.06450279f, 
    0.06128294f, -0.02681061f, 0.02679147f, -0.04107750f, -0.03153134f, 0.10014852f, 0.13376428f, 0.06615137f, 
    0.13993064f, 0.18837860f, 0.04145596f, -0.10654273f, 0.02646963f, -0.09358940f, 0.06735601f, 0.01246595f, 
    -0.18101464f, 0.12688473f, -0.05529995f, -0.04627272f, 0.06760665f, 0.11143064f, -0.01776673f, 0.33210394f, 
    0.02647025f, 0.01393825f, 0.02643449f, -0.07708193f, 0.09268597f, 0.12513135f, -0.03521668f, 0.01164581f, 
    0.05071804f, 0.28271148f, 0.13373184f, -0.12791429f, -0.09611743f, 0.10858347f, 0.00547135f, -0.00981511f, 
    0.08315685f, -0.10301869f, 0.17971139f, 0.08487176f, 0.08135419f, -0.10131747f, 0.05060503f, 0.00456926f, 
    0.08670681f, 0.10351783f, 0.05836110f, -0.00679991f, -0.04377706f, 0.00966270f, 0.04205881f, 0.02685469f, 
    0.10708834f, -0.02328063f, -0.15309578f, 0.11058226f, 0.00556181f, 0.06777720f, 0.07677750f, 0.04109627f, 
    0.14999880f, -0.02975022f, 0.05180552f, -0.12455036f, -0.22228700f, -0.22401959f, -0.19352451f, 0.11461915f, 
    0.24400026f, 0.09105233f, -0.01691580f, 0.10743149f, 0.14353709f, -0.02157979f, -0.05332264f, 0.09087214f, 
    0.03170487f, 0.05262106f, 0.26462203f, -0.12812696f, -0.06208381f, -0.00970288f, -0.09421656f, 0.04374042f, 
    0.07585743f, -0.07079042f, 0.18425047f, -0.04518808f, 0.19070348f, -0.08840030f, 0.02754856f, -0.18495920f, 
    -0.07529278f, 0.01164283f, 0.00065055f, 0.05481755f, -0.03154995f, 0.08795311f, 0.01586179f, 0.12569931f, 
    0.22880264f, 0.20014884f, 0.01049220f, 0.08403459f, 0.01500919f, -0.02395210f, 0.01552463f, -0.13166618f, 
    -0.06569380f, 0.19912674f, 0.03432771f, -0.32639486f, 0.13992135f, 0.00906228f, 0.20557101f, 0.06848991f, 
    0.07755657f, -0.02395268f, 0.07190471f, -0.01602653f, 0.14942166f, 0.15801996f, 0.10985327f, -0.01193307f, 
    0.26734874f, 0.30665302f, 0.12598979f, -0.05756503f, -0.11272608f, 0.00344148f, 0.10889028f, -0.12163991f, 
    -0.00637787f, -0.06468499f, 0.08015084f, 0.12218184f, -0.02005719f, 0.03358815f, 0.11046024f, -0.14003609f, 
    -0.14005339f, -0.06221938f, 0.20676698f, 0.25143841f, -0.23063697f, 0.14558612f, 0.15207484f, -0.06217881f, 
    -0.35139412f, 0.19151168f, -0.23925725f, -0.07280323f, -0.01579301f, 0.12281191f, 0.09197996f, -0.11651172f, 
    -0.10127246f, 0.01894912f, -0.08093282f, 0.07007173f, 0.05475701f, 0.28525549f, 0.32738879f, 0.06871318f, 
    -0.00132008f, -0.11316827f, 0.09018273f, 0.04980483f, 0.01334809f, -0.13619494f, -0.08632605f, 0.05984516f, 
    -0.37164474f, -0.26659009f, -0.14848734f, -0.07291490f, 0.10712648f, -0.10105752f, 0.00828366f, -0.08006202f, 
    0.08047447f, -0.11079010f, 0.02962285f, 0.05480411f, -0.24789408f, -0.14263451f, 0.08352375f, 0.06505113f, 
    0.19434227f, 0.12222463f, 0.04662419f, -0.03095739f, -0.13353634f, 0.10195877f, 0.05946991f, 0.07521830f, 
    0.26356521f, -0.12895812f, -0.11539882f, 0.06568977f, -0.09137037f, 0.17941783f, 0.05097223f, -0.19125877f, 
    0.07284414f, -0.03809695f, 0.04058234f, -0.11865942f, 0.03040584f, -0.04066890f, -0.32336318f, 0.23134913f, 
    0.09215450f, 0.01712803f, -0.08420382f, 0.07131980f, -0.10592615f, 0.27861547f, -0.14957272f, -0.08025879f, 
    -0.28874007f, -0.05541513f, 0.29707623f, 0.13707493f, -0.22639123f, 0.07828321f, 0.14713892f, -0.04252809f, 
    -0.03027915f, 0.12842560f, 0.09798159f, 0.04542333f, 0.28474072f, 0.04368475f, -0.04386935f, 0.16104361f, 
    0.33063427f, 0.11496474f, -0.18324456f, -0.12635282f, 0.02909813f, 0.01545172f, 0.13874614f, 0.04977597f, 
    -0.12025833f, 0.14621979f, 0.21306233f, -0.02099983f, 0.02140737f, -0.05530445f, -0.06601040f, 0.06477544f, 
    -0.02206542f, 0.07588662f, 0.00463845f, -0.01231353f, 0.20472892f, 0.14928664f, -0.02704002f, -0.12099154f, 
    -0.12325083f, -0.07867479f, 0.12452111f, -0.00723215f, 0.05132037f, 0.02326231f, -0.03586100f, -0.08932362f, 
    0.84060675f, 0.29918459f, -0.03355199f, -0.11528870f, 0.03177893f, -0.04685825f, -0.07125951f, 0.09673474f, 
    0.13571285f, 0.03560445f, 0.07616063f, 0.19259849f, 0.10611954f, 0.10357174f, 0.34542802f, 0.21940994f, 
    0.13263963f, -0.01340300f, -0.17744713f, -0.08064152f, 0.07352718f, -0.01652760f, -0.01631928f, -0.03115067f, 
    -0.17491566f, -0.24183364f, -0.27851927f, 0.24637096f, 0.02435826f, -0.22820425f, -0.07712415f, -0.11642199f, 
    -0.02234515f, -0.10695841f, 0.00752635f, 0.17794573f, -0.12122428f, 0.30318010f, -0.17748384f, -0.06072720f, 
    0.00389822f, 0.06395651f, -0.01505857f, 0.08985687f, 0.08710980f, 0.03345988f, -0.10616693f, 0.01330876f, 
    -0.14218976f, -0.19410661f, 0.27949861f, 0.00883857f, 0.01145266f, 0.06932345f, 0.01806669f, -0.04992304f, 
    0.11758298f, -0.14354596f, -0.03261006f, -0.09997094f, 0.18436119f, -0.08723210f, -0.07758339f, 0.16160867f, 
    0.01839378f, 0.00473264f, -0.21097779f, -0.00678442f, 0.09637478f, 0.04850781f, 0.15205908f, 0.10962886f, 
    -0.63418615f, -0.15187983f, 0.36828679f, 0.12596196f, 0.11582132f, 0.12107989f, 0.03507003f, -0.04338611f, 
    -0.11640085f, 0.07109591f, 0.04994211f, -0.04607803f, 0.19834748f, -0.12833199f, -0.00663255f, 0.05038225f, 
    0.02121649f, 0.03599058f, 0.05582403f, 0.01723952f, 0.01658994f, -0.00249768f, 0.00240606f, -0.07615152f, 
    -0.34157753f, 0.02762395f, 0.00378823f, -0.07412649f, -0.03535743f, 0.06487674f, -0.01259771f, -0.00774221f, 
    0.07890398f, 0.01821851f, 0.06672527f, -0.02405663f, -0.30307975f, 0.07243989f, -0.11127016f, 0.28040436f, 
    0.07785259f, 0.01091736f, 0.25402921f, -0.00167789f, 0.16888759f, -0.11334379f, 0.01226401f, -0.00636058f, 
    0.29144073f, -0.07631458f, 0.12312588f, -0.18136470f, 0.04711122f, 0.08855888f, 0.01567326f, 0.01739738f, 
    -0.07323107f, -0.09195985f, 0.05740819f, 0.13373272f, 0.03622490f, 0.10391035f, -0.12240460f, -0.33191475f, 
    -0.01799009f, 0.01997790f, -0.01237158f, -0.02374107f, 0.09882480f, -0.08186744f, 0.14550477f, 0.10104688f, 
    -0.16106111f, 0.00278985f, -0.21730334f, -0.18541309f, -0.01939265f, 0.01165666f, 0.02889821f, 0.05201024f, 
    0.08712523f, 0.07717675f, 0.07028468f, 0.05234893f, -0.54234451f, 0.16445160f, 0.08660427f, 0.04489468f, 
    0.00354519f, 0.10242490f, 0.14718145f, -0.11242370f, 0.00467885f, 0.06710009f, 0.09598399f, 0.01160940f, 
    0.31117383f, 0.03112696f, -0.04577779f, 0.18829553f, -0.10650012f, 0.17173353f, 0.16047969f, 0.03335002f, 
    0.09772947f, 0.02300554f, 0.02503322f, -0.12744775f, -0.26046398f, 0.02165061f, 0.03585392f, -0.01324241f, 
    -0.03197540f, -0.01839250f, 0.05350212f, -0.12603112f, -0.00021943f, -0.04855720f, 0.16071467f, -0.04695419f, 
    0.43078223f, -0.04102072f, 0.18645987f, 0.17763373f, -0.00444153f, 0.02042983f, -0.08299728f, -0.02737981f, 
    -0.02072284f, 0.08727835f, 0.09428471f, 0.09801443f, 0.20884214f, 0.27221322f, 0.06013272f, -0.12762900f, 
    0.00323727f, 0.05377685f, -0.08938576f, 0.10573294f, 0.00384975f, 0.10669084f, 0.01473920f, 0.01760989f, 
    0.01232728f, 0.08408879f, 0.06877758f, -0.18207122f, 0.10723950f, -0.01992358f, -0.05247418f, 0.11788115f, 
    -0.06286584f, -0.04631473f, 0.08167096f, 0.05919201f, 0.53168786f, -0.30617821f, 0.05400285f, -0.15878037f, 
    -0.03912677f, 0.03295846f, -0.00112177f, 0.27227029f, 0.06635318f, 0.08061768f, -0.06424682f, 0.06861612f, 
    -0.23287745f, 0.08054931f, -0.23125589f, -0.10922349f, -0.04395030f, 0.05053281f, -0.02565168f, -0.02887257f, 
    0.18294723f, -0.03531462f, -0.00848917f, 0.07864746f, 0.06472030f, 0.00074816f, 0.08901752f, -0.14595389f, 
    0.08714400f, 0.01611722f, 0.06851576f, -0.05197913f, 0.09580117f, -0.00301438f, -0.11440255f, 0.14357863f, 
    -0.25593463f, 0.06540624f, -0.10785852f, -0.04243307f, 0.13481474f, 0.00847402f, -0.05250582f, 0.00640520f, 
    0.02806081f, -0.03158240f, -0.03453678f, 0.01636908f, -0.07794075f, 0.07128907f, -0.16130809f, -0.06083287f, 
    0.06604472f, 0.09961358f, 0.03294686f, -0.09911902f, 0.17291906f, 0.01835947f, 0.11020013f, 0.08522347f, 
    -0.02765940f, 0.16082148f, 0.28170535f, 0.26803246f, -0.11172468f, 0.00911397f, 0.04561550f, -0.09488385f, 
    -0.14380455f, 0.09406783f, -0.01067223f, 0.06476345f, 0.18566245f, 0.18790258f, -0.34395206f, -0.06824096f, 
    0.09611769f, 0.04828697f, -0.08169479f, -0.19952404f, 0.10950504f, -0.23799872f, -0.12667529f, -0.03353048f, 
    0.07461829f, -0.18201655f, 0.01859725f, 0.07365467f, 0.04719413f, -0.05619071f, -0.00551475f, 0.23711590f, 
    0.08461425f, -0.01228127f, 0.13826522f, 0.17208867f, 0.30507588f, -0.08220363f, 0.17875634f, 0.11082084f, 
    -0.02952375f, 0.01362303f, -0.00797625f, -0.08397174f, 0.10487036f, -0.06825589f, 0.14355057f, 0.03283866f, 
    0.17299849f, -0.06055915f, 0.18552317f, -0.17649046f, -0.19015993f, 0.01990751f, 0.13766970f, 0.08790573f, 
    0.10546079f, 0.03712356f, -0.10995966f, -0.02510162f, -0.21701190f, 0.00686701f, -0.02037197f, 0.12162600f, 
    0.05405982f, -0.11066903f, 0.06441417f, 0.17824280f, -0.00383330f, 0.06067384f, 0.11853781f, 0.13290161f, 
    -0.14426996f, -0.24134380f, 0.00051742f, -0.14826597f, 0.03033897f, 0.20130564f, -0.10575967f, -0.07825810f, 
    -0.03467236f, 0.15687306f, 0.05781053f, 0.23782113f, 0.07645649f, 0.04624183f, -0.05147192f, -0.14550368f, 
    0.23153795f, 0.08425872f, -0.11315221f, -0.13321836f, 0.08285794f, -0.02595120f, -0.01068576f, 0.14544421f, 
    -0.04766801f, 0.17793381f, -0.03559482f, 0.15637387f, 0.13822582f, -0.28564095f, 0.10294712f, 0.06895423f, 
    0.03890004f, -0.03215936f, -0.07956715f, -0.16688736f, 0.02112101f, 0.27186006f, 0.24922687f, -0.04155607f, 
    0.10805649f, -0.14821988f, -0.00949698f, -0.03863764f, 0.04621132f, 0.09616636f, -0.00251540f, -0.07636907f, 
    0.17418277f, 0.08518885f, 0.11081862f, 0.16024740f, -0.13707605f, -0.16364557f, -0.04253741f, 0.14246100f, 
    0.02227285f, 0.09336764f, 0.02812170f, -0.04140769f, 0.32036993f, 0.06554393f, 0.12183487f, 0.03093985f, 
    -0.07188936f, -0.02694786f, 0.12785330f, -0.01084819f, -0.00034504f, -0.02588262f, -0.03286721f, -0.07406661f, 
    0.14406759f, -0.21681803f, -0.02747841f, -0.13827303f, -0.08799404f, 0.04728151f, -0.01122502f, 0.09152151f, 
    -0.01714147f, -0.03442571f, 0.04291681f, 0.12899347f, 0.15605949f, 0.19340673f, -0.18192762f, 0.05629467f, 
    0.01150509f, -0.06239049f, 0.12370545f, 0.05551882f, -0.25300846f, -0.07546465f, -0.36893183f, -0.41524518f, 
    -0.06859715f, -0.01946971f, 0.04474622f, 0.00451524f, 0.00389616f, -0.04078465f, -0.00180315f, 0.04744583f, 
    -0.06791866f, -0.02847686f, 0.04003554f, 0.04166577f, 0.01124722f, -0.00485916f, -0.05238571f, -0.03550233f, 
    0.01225853f, 0.02207390f, -0.03240224f, 0.00154305f, -0.00769883f, -0.00339364f, -0.03567486f, 0.04118938f, 
    0.00633707f, -0.03822212f, -0.06585753f, 0.02432723f, 0.03815986f, -0.05645140f, 0.02656387f, 0.04593682f, 
    -0.01491469f, -0.05038619f, -0.00203098f, 0.04792899f, 0.00175405f, 0.01070376f, 0.01015646f, 0.06174230f, 
    0.03709675f, -0.05544877f, -0.01829527f, 0.04635048f, 0.03300397f, 0.03451040f, -0.07602243f, -0.05397140f, 
    -0.00905233f, -0.08012083f, -0.05513759f, 0.03724927f, -0.04639923f, 0.03566184f, 0.00005593f, -0.07297068f, 
    -0.01699024f, -0.00215801f, -0.06481306f, -0.00426968f, 0.06060360f, -0.05989366f, -0.03603126f, -0.04702394f, 
    -0.07982027f, -0.05628548f, -0.04424705f, -0.06894626f, -0.00213325f, -0.06786184f, -0.05238727f, -0.05372042f, 
    -0.02309331f, -0.01998948f, -0.06989934f, 0.01581459f, -0.07568274f, -0.02061850f, 0.00747595f, 0.01034874f, 
    0.05800629f, 0.01659805f, -0.00163349f, 0.05045947f, -0.03360054f, 0.05236328f, -0.03923753f, 0.03895078f, 
    -0.01240104f, 0.00136311f, -0.03658488f, -0.05684322f, -0.03435879f, 0.03731682f, -0.01362680f, 0.05725265f, 
    0.01337008f, -0.02761775f, 0.00107702f, -0.06682639f, -0.02050748f, 0.00963946f, -0.00081224f, 0.00241727f, 
    0.00749231f, 0.04728102f, 0.04882896f, 0.02656952f, -0.02137252f, -0.07105003f, -0.05201942f, -0.01426073f, 
    0.01975535f, -0.06341509f, 0.04351014f, 0.02326625f, -0.00879018f, -0.03875693f, 0.05115204f, -0.07306741f, 
    -0.00467202f, 0.02776815f, 0.01372777f, 0.03709613f, -0.04349783f, 0.05960229f, -0.04997228f, -0.01724530f, 
    -0.04977942f, 0.06664619f, -0.07195067f, -0.05375712f, 0.05958496f, -0.02415499f, 0.02156698f, 0.05087577f, 
    -0.04599479f, -0.05163853f, -0.04851325f, -0.07504047f, -0.02646150f, -0.06430672f, 0.06474202f, 0.05694707f, 
    -0.01094950f, -0.06755023f, -0.04761752f, -0.00634708f, 0.00551518f, -0.01473359f, -0.04911308f, 0.05673847f, 
    -0.07825822f, 0.05719930f, 0.04051549f, 0.01354199f, 0.05044348f, -0.04051699f, -0.02195179f, -0.00259416f, 
    -0.04316972f, 0.05272392f, 0.04495948f, -0.07529107f, -0.01803759f, -0.05416425f, -0.04019526f, -0.03406746f, 
    0.04144887f, 0.00747727f, -0.05045432f, -0.04151833f, -0.00371900f, -0.03405877f, 0.04830374f, -0.05336751f, 
    -0.03983921f, -0.02043753f, 0.03358975f, 0.02520874f, -0.06469195f, 0.02770293f, -0.02715643f, -0.05358282f, 
    0.02004553f, 0.04591112f, -0.02589725f, 0.02203149f, -0.04178828f, -0.06048356f, -0.06867215f, 0.04775216f, 
    -0.76010025f, 0.07346403f, -0.02830307f, 0.44367713f, 0.07126454f, -0.18493348f, 0.11029810f, -0.06989150f, 
    0.08288888f, 0.06836150f, -0.08671509f, 0.00086513f, -0.45514399f, 0.08739327f, -0.07339471f, 0.04955587f, 
    -0.02093609f, -0.04585407f, 0.15585822f, -0.09412088f, 0.03967487f, -0.10102969f, 0.00501930f, -0.10849350f, 
    -0.31228870f, 0.07582584f, 0.28724295f, 0.21485797f, -0.08102515f, -0.04690750f, 0.15387058f, 0.07344740f, 
    -0.10731840f, 0.02214562f, 0.04770407f, 0.04776905f, -0.39275342f, -0.33023927f, -0.20523165f, 0.16964644f, 
    0.06183020f, 0.12133047f, 0.00948937f, 0.11750333f, 0.14694220f, 0.08377359f, 0.02350989f, -0.01811375f, 
    -0.20349592f, -0.29811433f, 0.25720447f, -0.10184783f, 0.13589633f, -0.10692315f, -0.04522777f, -0.02830540f, 
    0.04275900f, -0.12870337f, 0.13660663f, -0.07023357f, 0.13991983f, 0.05224625f, 0.03839583f, -0.17734692f, 
    -0.01750841f, -0.03551522f, -0.03140359f, 0.02664039f, 0.17933938f, 0.01668341f, 0.03593481f, 0.05733283f, 
    0.09854198f, 0.00579427f, -0.02795472f, -0.04666209f, 0.03773967f, 0.16129503f, -0.05799004f, -0.03316971f, 
    0.07741474f, -0.09591457f, -0.03348815f, 0.16600229f, 0.19144797f, -0.07037402f, -0.28274059f, 0.19908515f, 
    0.04438851f, 0.16162446f, -0.06425513f, -0.08581560f, 0.16963783f, 0.09036750f, -0.00265282f, -0.08292508f, 
    -0.24231841f, 0.16545004f, 0.20635454f, -0.09664000f, -0.00123318f, -0.12226731f, 0.04780157f, -0.00146814f, 
    0.13407104f, 0.02111894f, -0.01238462f, 0.03955736f, -0.18401764f, -0.24482509f, -0.19168353f, -0.05713297f, 
    -0.06770610f, -0.01977255f, -0.00293835f, -0.19968931f, 0.01916260f, 0.10997486f, 0.01004758f, 0.13527563f, 
    -0.19316603f, 0.17307974f, 0.13206716f, -0.04715383f, -0.02071922f, 0.07446775f, 0.07364713f, 0.17299016f, 
    -0.03503755f, 0.03035073f, -0.01310393f, -0.11124410f, 0.16665609f, 0.15844472f, 0.19347166f, 0.24966408f, 
    -0.06560042f, -0.02197684f, 0.12189266f, 0.04645386f, -0.08511519f, -0.00273894f, 0.06978630f, 0.00427489f, 
    0.11993800f, 0.21742760f, -0.04517219f, -0.13601066f, 0.02920508f, -0.07388829f, -0.01692053f, 0.14520849f, 
    0.14625619f, 0.09198220f, 0.10475867f, 0.14238812f, -0.42367586f, 0.20559840f, -0.00348677f, 0.00988252f, 
    0.10704056f, -0.15067939f, -0.00444188f, 0.16447352f, 0.00542075f, 0.01001876f, -0.03716676f, 0.11021140f, 
    0.23997428f, -0.02393035f, 0.18244848f, 0.32598907f, -0.11884630f, 0.05279714f, 0.01284118f, -0.08781801f, 
    0.01502437f, -0.11538568f, 0.10138734f, 0.00637386f, 0.09722638f, -0.04689266f, 0.04554135f, 0.14705372f, 
    -0.03252285f, -0.00656609f, -0.07954400f, 0.14880642f, 0.05303774f, 0.04062581f, 0.10921413f, 0.06305585f, 
    -0.16126889f, 0.08765156f, 0.37115920f, 0.22538349f, -0.01370174f, -0.12562515f, -0.01951034f, -0.08276106f, 
    -0.03135537f, -0.17396761f, 0.02315629f, 0.10509504f, -0.66322690f, -0.11511082f, -0.08650540f, -0.21520650f, 
    0.15638117f, 0.00421543f, -0.10694848f, 0.14354120f, 0.15554890f, 0.02317273f, 0.04421363f, -0.14112446f, 
    0.03426458f, 0.32136795f, 0.21332265f, 0.18878545f, 0.06297731f, 0.03505174f, 0.07963512f, 0.08500408f, 
    0.08863746f, 0.10311662f, 0.09395199f, 0.04268514f, 0.03313054f, -0.13907905f, -0.05438708f, -0.10193094f, 
    0.06399155f, -0.01011263f, -0.01460179f, -0.05430823f, 0.11908363f, -0.13731670f, -0.04753693f, -0.08170684f, 
    -0.27549231f, -0.06499355f, -0.23795892f, 0.02341351f, 0.21202996f, 0.02088503f, -0.04792959f, 0.12866372f, 
    0.07461736f, 0.10256641f, 0.04964688f, 0.07347365f, 0.13062060f, 0.13110563f, 0.22387666f, 0.12422545f, 
    -0.11408315f, -0.19394672f, 0.07401099f, 0.05301731f, 0.00019987f, -0.13706324f, -0.01919845f, -0.07963590f, 
    -0.01832138f, -0.15293942f, 0.27481672f, -0.34986258f, 0.19615965f, 0.15108494f, -0.10832318f, 0.00467228f, 
    0.26518196f, 0.09142236f, -0.07192931f, 0.05590390f, -0.02207976f, -0.06445675f, 0.44405076f, 0.10953838f, 
    -0.20648055f, -0.11009299f, 0.03875318f, -0.10258120f, 0.05446198f, -0.00066804f, 0.09182505f, 0.19352821f, 
    0.04798978f, 0.08483161f, -0.25045878f, -0.11049873f, 0.19479732f, 0.05354033f, -0.08925872f, 0.13218175f, 
    0.07810870f, -0.00350930f, 0.15531905f, 0.27562058f, -0.33920562f, -0.63639325f, -0.46602190f, -0.16307619f, 
    0.21916531f, -0.07518212f, -0.02801718f, -0.07785272f, 0.04524017f, -0.09184762f, -0.13554941f, 0.14675163f, 
    -0.49429968f, -0.01684506f, -0.21826605f, -0.10820220f, -0.02571396f, 0.00481896f, 0.22497921f, 0.13075802f, 
    -0.09354814f, -0.04220255f, -0.10127255f, -0.09147047f, -0.11314791f, 0.15514606f, 0.29271975f, 0.14132577f, 
    -0.24272113f, -0.17026243f, 0.15221402f, 0.00607693f, -0.09777941f, 0.17761296f, 0.20880391f, 0.08491101f, 
    0.33569527f, 0.20537911f, 0.10726815f, 0.04799452f, 0.01855683f, -0.04112278f, 0.02620069f, -0.10507329f, 
    0.04868210f, 0.12746759f, 0.05545943f, 0.04644850f, -0.40353972f, 0.30236563f, -0.13192737f, -0.08563808f, 
    0.09637254f, -0.02404700f, -0.06069862f, 0.20130938f, 0.00842954f, -0.08343437f, 0.11488853f, -0.11997951f, 
    0.00330319f, -0.03548297f, 0.27321360f, -0.01633210f, -0.12113625f, -0.05655747f, 0.00589112f, 0.00288860f, 
    0.06433763f, 0.10027844f, 0.19745551f, 0.10426129f, -0.11247772f, 0.08311965f, -0.06858293f, -0.00318745f, 
    0.06864548f, 0.08420517f, 0.11601356f, 0.12052384f, -0.11853520f, -0.03355487f, -0.09897848f, -0.11777616f, 
    0.36363265f, -0.06071670f, 0.05168453f, 0.03952597f, 0.06577602f, -0.16587041f, -0.06998238f, -0.01492904f, 
    -0.08388890f, 0.09287563f, 0.05246255f, 0.08185278f, -0.20072058f, 0.13682927f, 0.27362943f, 0.17473112f, 
    0.12648030f, -0.04801617f, 0.03840683f, -0.04143161f, -0.02158060f, -0.05532983f, 0.07224754f, 0.00915551f, 
    0.11677803f, 0.00504815f, -0.07411091f, -0.02664236f, -0.00758786f, 0.09254822f, 0.13828847f, -0.04016281f, 
    0.06342664f, 0.02652621f, 0.10257920f, -0.10004703f, -0.12808819f, 0.04432027f, -0.12120529f, 0.30195862f, 
    0.07093368f, -0.05255434f, -0.04120703f, -0.07253092f, 0.02250688f, 0.10648215f, -0.09400585f, 0.01143370f, 
    -0.10670063f, -0.10174601f, 0.29312405f, -0.28870091f, 0.10096592f, 0.03775421f, 0.12024126f, 0.13804202f, 
    -0.08936682f, -0.07214270f, -0.01583437f, -0.24539180f, 0.01135043f, 0.09587494f, 0.03923539f, -0.38705280f, 
    0.12217441f, 0.01317968f, 0.02765727f, -0.02967863f, 0.15674649f, -0.03924172f, -0.00621929f, 0.07092325f, 
    -0.22430034f, 0.32548237f, -0.19469248f, 0.19335644f, 0.01647757f, 0.04859350f, 0.08028542f, -0.04304316f, 
    0.07526609f, 0.12199786f, 0.05457259f, 0.06435996f, 0.08086087f, 0.43849233f, -0.08845086f, -0.10028147f, 
    0.28378662f, 0.15604058f, -0.09467801f, 0.01321402f, 0.00405004f, -0.00556728f, -0.14346357f, -0.10963824f, 
    -0.11754181f, -0.25917181f, 0.17723854f, 0.00455389f, 0.02064366f, -0.02752919f, 0.14402492f, -0.07199033f, 
    0.20311974f, 0.06221262f, 0.07846630f, 0.04396720f, -0.25568929f, 0.21998052f, -0.11972649f, -0.10480743f, 
    -0.01334971f, 0.18782352f, 0.00860180f, -0.19519676f, -0.05855628f, 0.05444266f, -0.13221884f, -0.17738374f, 
    0.00787339f, -0.17232500f, 0.26582655f, 0.04388710f, -0.09850211f, 0.14489692f, 0.05939901f, 0.05538196f, 
    -0.13961209f, 0.01828890f, -0.09830552f, -0.04844682f, -0.10610258f, -0.25940877f, 0.10631096f, 0.43386579f, 
    -0.09066489f, -0.03978570f, 0.07250099f, 0.11555482f, -0.06575309f, 0.00231858f, 0.05829624f, 0.13886739f, 
    -0.03826126f, 0.20682128f, 0.10111742f, -0.22237100f, 0.13367298f, 0.01131038f, -0.04100209f, 0.03464265f, 
    -0.02010264f, -0.01028269f, -0.11414983f, 0.06301150f, -0.42213625f, 0.00363883f, 0.00023301f, -0.08108544f, 
    0.20774247f, -0.05357368f, 0.06397735f, 0.01871548f, 0.06805031f, 0.07173096f, 0.07192910f, 0.12750389f, 
    -0.14343368f, 0.23993723f, -0.09613065f, 0.22108874f, -0.11373770f, 0.09115590f, 0.00242420f, -0.19015537f, 
    0.02208172f, -0.14541154f, -0.07413825f, 0.04525181f, 0.01046950f, 0.07930577f, 0.07949381f, 0.23089859f, 
    0.01399048f, -0.00364199f, -0.22849573f, -0.00770358f, 0.13462071f, 0.08710437f, 0.24500830f, 0.11531696f, 
    0.18586709f, 0.50123483f, -0.01763539f, 0.32474038f, 0.03096786f, -0.13336523f, 0.05729285f, -0.02570943f, 
    0.11726905f, 0.16789040f, 0.00802321f, -0.05180982f, -0.25569174f, 0.04847771f, -0.07392629f, 0.09839828f, 
    0.01111608f, 0.00841587f, 0.01087343f, 0.06549506f, 0.00954297f, -0.13081181f, -0.05310166f, 0.09982786f, 
    0.05274726f, -0.13027290f, 0.18507205f, 0.07171262f, -0.11803955f, 0.03203947f, 0.05815170f, 0.00207933f, 
    -0.09749988f, 0.03964787f, -0.08013073f, -0.00060447f, -0.37613052f, 0.09050132f, -0.13711324f, 0.06053375f, 
    0.13335538f, 0.06197191f, -0.02646669f, 0.06299057f, 0.06294576f, 0.00853266f, 0.03044591f, 0.00014899f, 
    -0.40152192f, -0.05606935f, 0.23933451f, -0.00856905f, 0.02320784f, -0.09276852f, 0.06249593f, -0.01008286f, 
    -0.00947150f, -0.18721190f, -0.04094080f, -0.08399129f, 0.28589889f, -0.02406665f, 0.08316590f, -0.01727229f, 
    -0.01732698f, -0.04100866f, 0.02871073f, 0.02547915f, 0.09458189f, 0.02319946f, 0.03887890f, 0.08374431f, 
    0.19516316f, -0.17218424f, -0.01155144f, 0.06501243f, -0.03159117f, 0.01100603f, 0.12014727f, -0.09746686f, 
    0.05642143f, -0.09317474f, -0.12912405f, 0.06323738f, 0.61663985f, 0.28441116f, -0.47377935f, 0.15667149f, 
    0.13164631f, 0.11874317f, 0.02053075f, -0.02739991f, 0.11220673f, -0.07136659f, -0.03786459f, 0.02525940f, 
    -0.40408802f, 0.07176617f, 0.31691852f, -0.07664393f, -0.08458396f, -0.00753960f, 0.05062177f, 0.00323536f, 
    -0.02654960f, 0.02270779f, -0.04533491f, -0.06363489f, -0.16215733f, 0.00331896f, -0.28741044f, -0.29341969f, 
    -0.16001920f, -0.01106719f, -0.00196756f, -0.13719970f, 0.02770555f, 0.11970142f, 0.12059732f, -0.02842697f, 
    0.05022400f, -0.02710305f, -0.01628706f, -0.10107187f, 0.00864679f, 0.23748335f, 0.00898723f, 0.17040618f, 
    -0.05091844f, 0.15590474f, -0.12997451f, 0.02791772f, 0.06271077f, 0.03656954f, 0.11312411f, 0.08054499f, 
    -0.04408835f, 0.00615218f, 0.07189117f, -0.09795049f, 0.04144379f, -0.08170273f, 0.03947970f, 0.02404052f, 
    0.16620477f, -0.06988958f, 0.00185947f, -0.16943099f, -0.16572739f, 0.08399903f, 0.05978106f, 0.00401859f, 
    0.00035719f, 0.11098300f, 0.03665272f, -0.03655861f, -0.19922367f, 0.02101979f, 0.01176504f, -0.06401147f, 
    0.18565308f, 0.06725429f, 0.05659683f, 0.08352049f, 0.03919479f, -0.02717415f, 0.17037962f, 0.25091514f, 
    0.06245689f, -0.18123087f, 0.02031071f, 0.19260062f, -0.03223097f, -0.01342164f, 0.10584290f, -0.04261178f, 
    0.08395749f, -0.05750410f, -0.10788292f, -0.00633145f, 0.16286738f, -0.13748063f, -0.11355200f, 0.02526544f, 
    -0.19269356f, 0.01314304f, 0.07274828f, 0.04913362f, 0.13199209f, 0.13308996f, 0.13276057f, 0.11413179f, 
    -0.32550818f, -0.19238555f, 0.06145392f, -0.14508779f, 0.20605022f, 0.07648434f, -0.00408224f, -0.01434435f, 
    0.06352104f, 0.00879813f, -0.07590887f, -0.06746798f, 0.35266325f, 0.06472471f, -0.12405593f, 0.03850861f, 
    0.05437745f, -0.01258013f, -0.06367534f, -0.05499562f, 0.02591597f, -0.01460290f, 0.08337104f, -0.05409228f, 
    -0.14176609f, -0.20940527f, 0.04399332f, 0.00182717f, 0.06940968f, -0.02650311f, -0.12226783f, -0.06160767f, 
    0.01659915f, 0.08332365f, -0.03801762f, -0.08326790f, -0.11906559f, 0.26044944f, 0.05672453f, 0.32424110f, 
    0.00494154f, -0.00935907f, 0.13847597f, 0.03174520f, 0.11457144f, -0.01512169f, 0.08437055f, 0.03603630f, 
    0.30788389f, -0.06592152f, 0.05112738f, -0.00829553f, 0.03088202f, -0.10854721f, 0.08806738f, -0.03044237f, 
    0.04020583f, -0.02082436f, 0.12361041f, 0.13124302f, 0.08674583f, -0.11365646f, 0.03652865f, -0.01955601f, 
    -0.07351949f, 0.15755156f, -0.14020368f, -0.02578189f, 0.04938472f, 0.06019173f, 0.23303425f, -0.11602556f, 
    0.13394322f, -0.15171985f, -0.15472625f, -0.08389834f, -0.03889892f, -0.09144784f, 0.12193507f, 0.05965929f, 
    -0.03621758f, -0.07078476f, -0.10601791f, 0.02295173f, -0.52026975f, -0.09029298f, -0.09909523f, 0.07468591f, 
    0.05815472f, -0.01024658f, 0.01095587f, -0.05039910f, 0.04971400f, 0.11448963f, 0.05122355f, 0.05072701f, 
    0.26570508f, -0.06461006f, 0.16998196f, 0.03838414f, 0.00234369f, 0.21109878f, -0.01336261f, -0.06004776f, 
    -0.12531960f, 0.02081679f, -0.09336716f, -0.01842096f, 0.20209521f, 0.28663573f, 0.31762469f, 0.26878616f, 
    -0.14082479f, 0.03164331f, 0.09414031f, -0.04108859f, -0.13200642f, -0.01491990f, 0.14259797f, -0.03328308f, 
    0.21458288f, 0.10415264f, 0.12920082f, 0.15448223f, 0.07283381f, -0.00380524f, -0.07829486f, 0.01788290f, 
    0.03733120f, 0.02074717f, 0.09515794f, 0.09178313f, 0.05354798f, 0.27947068f, -0.16748953f, -0.07929105f, 
    0.09598356f, 0.06442915f, -0.14754422f, 0.14009230f, 0.06558602f, 0.12123650f, -0.08903307f, -0.01311497f, 
    -0.00212700f, -0.12374267f, 0.03093953f, 0.12171238f, 0.00941502f, 0.02257737f, -0.07131014f, 0.13619328f, 
    -0.01257532f, -0.10346880f, 0.20827307f, 0.04378407f, 0.68811673f, -0.41338989f, 0.09795654f, 0.01643273f, 
    -0.17897661f, 0.06378274f, 0.10501719f, 0.20289515f, 0.00380183f, 0.07854345f, 0.00869306f, 0.10008475f, 
    -0.11237150f, -0.07880697f, -0.29247385f, -0.03339003f, 0.06596768f, 0.07498211f, -0.12593186f, 0.01573035f, 
    0.03942574f, 0.09855118f, -0.02509146f, -0.06644610f, 0.01256327f, -0.03594394f, 0.20609769f, -0.01229895f, 
    -0.00306481f, 0.00920944f, 0.13736323f, -0.04437233f, 0.04817749f, -0.16660313f, -0.04970597f, 0.15071477f, 
    0.05971509f, -0.00361427f, -0.26374251f, -0.02655468f, -0.05314822f, 0.00802832f, 0.10013118f, 0.08384610f, 
    0.10870761f, -0.00651506f, -0.06653072f, 0.10467088f, 0.12829652f, 0.07097431f, -0.07860815f, 0.11636614f, 
    0.02852613f, -0.01450045f, -0.08067911f, -0.05627476f, 0.06345304f, 0.03878268f, 0.09209558f, -0.02213197f, 
    -0.05675441f, 0.01147657f, 0.20233287f, 0.04114174f, 0.09059474f, 0.01280238f, 0.10718359f, -0.01936898f, 
    -0.07298553f, 0.04360016f, -0.08063685f, 0.10472846f, 0.08557510f, -0.03321604f, -0.14251764f, -0.05782946f, 
    -0.02651878f, 0.00552138f, -0.01097264f, 0.14852671f, -0.00499842f, 0.01810845f, -0.11631772f, -0.05512996f, 
    0.08473999f, -0.06370571f, -0.09382065f, 0.15069930f, -0.00096510f, -0.14899749f, -0.01466403f, 0.12771882f, 
    0.15412712f, 0.10650645f, 0.17404881f, 0.09703433f, -0.06958217f, -0.23461917f, 0.09324589f, -0.27728638f, 
    0.08994935f, 0.00529577f, -0.08603105f, -0.03674944f, 0.11636922f, -0.09651579f, 0.14922959f, -0.07261731f, 
    0.41985899f, -0.32543775f, 0.16047555f, 0.11306904f, 0.03479551f, -0.05506545f, -0.06302622f, -0.01325214f, 
    0.03417911f, -0.07276294f, -0.08696057f, -0.00211052f, 0.18143119f, 0.08405561f, -0.29118359f, -0.00102567f, 
    0.07938972f, -0.07779192f, -0.01993579f, 0.06943162f, -0.05116108f, -0.00036001f, -0.10287516f, 0.22369689f, 
    -0.01889011f, -0.11044934f, 0.06467450f, -0.26024786f, 0.08892574f, -0.12947185f, 0.00236922f, 0.00284736f, 
    -0.03774518f, 0.13274096f, -0.02872391f, 0.19502355f, 0.18953876f, 0.10307915f, -0.04801250f, 0.13597776f, 
    0.03179250f, 0.14378959f, 0.00074835f, -0.21704122f, -0.01116759f, 0.06847537f, -0.07831313f, -0.02695033f, 
    -0.55503321f, 0.11036456f, -0.10649393f, -0.08098940f, -0.01072735f, -0.14355594f, 0.18218380f, 0.17114656f, 
    -0.07940032f, -0.07155667f, 0.00474898f, -0.12877168f, 0.16308838f, -0.11524303f, 0.08313686f, 0.59322089f, 
    0.13533965f, -0.01459845f, 0.05630871f, -0.04566663f, 0.03695734f, -0.00751786f, 0.12809999f, 0.11883803f, 
    -0.01419294f, 0.09583683f, -0.09685701f, -0.28434932f, 0.00023578f, -0.04789787f, 0.01289720f, 0.09786426f, 
    0.17746831f, 0.23961733f, -0.06555897f, 0.10217132f, 0.04507029f, 0.25152153f, -0.00417526f, -0.11176974f, 
    0.00625293f, 0.07745863f, 0.04677173f, 0.10415004f, -0.02045014f, -0.00818321f, -0.07926239f, -0.17418125f, 
    0.15631087f, -0.20408159f, -0.08406460f, 0.18183763f, -0.01701027f, -0.11764178f, 0.04080426f, -0.12649177f, 
    0.05762457f, 0.03264990f, -0.07533080f, 0.10123229f, 0.20344573f, 0.15112711f, -0.11448903f, 0.28601950f, 
    0.04124432f, 0.05870290f, 0.02944931f, 0.07010458f, -0.01696289f, 0.01855266f, -0.04863473f, -0.17914625f, 
    -0.15257600f, 0.08647379f, 0.52803594f, 0.22206758f, -0.11944282f, 0.00674024f, 0.03006320f, -0.06772351f, 
    -0.16388974f, 0.02372139f, 0.02706006f, -0.08833131f, -0.00025219f, -0.13607582f, 0.04959895f, -0.08047622f, 
    0.13274300f, -0.00140264f, 0.18097387f, 0.09837569f, 0.11875273f, 0.00163340f, -0.15424238f, -0.14927202f, 
    -0.05189973f, 0.16698921f, -0.06746268f, -0.20305839f, -0.01990808f, 0.07269800f, -0.03771935f, 0.13985913f, 
    0.03381397f, 0.03306976f, 0.15930037f, 0.08690299f, -0.09158716f, -0.24089798f, 0.29624769f, 0.25761923f, 
    0.02899635f, 0.07216652f, 0.23371091f, 0.05354251f, 0.03510464f, -0.01338850f, 0.28622004f, -0.00542650f, 
    -0.06126357f, 0.11366111f, 0.00112579f, -0.10012307f, 0.04001683f, 0.06732224f, -0.06400099f, -0.13771644f, 
    -0.07084024f, -0.07830980f, -0.02175076f, -0.03564037f, 0.04633177f, 0.26660934f, -0.03346173f, -0.22556242f, 
    -0.06797043f, 0.00633935f, -0.00771558f, 0.03744476f, 0.05322951f, 0.02924369f, 0.00390275f, 0.14238079f, 
    -0.32901070f, 0.15441677f, 0.01035463f, -0.03233534f, 0.21852627f, 0.07461990f, -0.08854520f, 0.11837929f, 
    0.19664630f, 0.02389607f, 0.06608476f, 0.05832621f, -0.01262355f, 0.11898744f, 0.40411064f, 0.05130691f, 
    -0.01748200f, 0.10784850f, 0.10305315f, -0.12754884f, 0.03833233f, 0.01920361f, 0.09208767f, -0.14252010f, 
    0.29064071f, 0.12418580f, -0.26809159f, 0.18158451f, 0.02534411f, -0.05839177f, 0.15934823f, 0.05563425f, 
    0.20888269f, -0.10991041f, 0.02518878f, -0.22483802f, -0.30466476f, -0.32942209f, -0.18376030f, 0.08678887f, 
    0.03918338f, -0.08951581f, 0.02774499f, 0.15161419f, -0.02493019f, -0.03781716f, 0.07443321f, -0.02910551f, 
    0.29000673f, -0.12542742f, 0.08682746f, -0.09269686f, -0.00800347f, 0.17618600f, 0.02196447f, -0.08427461f, 
    -0.00487931f, 0.13011047f, 0.02978005f, 0.05172818f, 0.08673747f, 0.17107999f, -0.15513434f, -0.17996585f, 
    -0.17059422f, 0.17915785f, 0.07380746f, -0.04349165f, -0.07121626f, 0.10904807f, -0.00309025f, 0.10557411f, 
    0.20452626f, 0.30065057f, 0.02455576f, -0.18122989f, 0.20703052f, 0.20964502f, 0.01555457f, 0.10075602f, 
    -0.01434251f, -0.09419040f, 0.14035630f, 0.05956609f, -0.32772261f, 0.00341054f, -0.18181907f, -0.01618573f, 
    0.05789967f, 0.00516294f, -0.00648410f, 0.10185692f, -0.01785546f, 0.02537422f, 0.13347827f, 0.20993435f, 
    -0.25477347f, 0.32707304f, 0.23426361f, 0.12168005f, -0.00641342f, 0.01142981f, 0.07731063f, 0.09921319f, 
    0.13139430f, -0.03553057f, 0.05409947f, -0.05279273f, -0.15831028f, -0.22535844f, 0.26904911f, -0.06629653f, 
    0.21861257f, 0.12017041f, 0.06560418f, -0.01875556f, 0.26541075f, 0.10439193f, 0.22736515f, 0.25599885f, 
    0.27697694f, 0.33769646f, 0.16133112f, 0.02677768f, -0.01382971f, 0.01114497f, -0.08007148f, 0.05703944f, 
    0.04824438f, -0.07432007f, 0.03162431f, -0.10816217f, 0.50054818f, -0.02259185f, -0.26817709f, 0.16266032f, 
    -0.08164535f, 0.17745270f, -0.02320645f, 0.14456758f, -0.01182942f, 0.09149988f, -0.11483654f, 0.08542911f, 
    0.07405710f, -0.13665245f, -0.14639296f, -0.14030561f, -0.07765804f, -0.13731785f, -0.05693682f, 0.01197739f, 
    0.11138179f, -0.05733524f, -0.07676331f, -0.01303058f, 0.11697860f, 0.17444398f, 0.04371117f, -0.18826151f, 
    -0.09587462f, -0.02004111f, -0.04034095f, 0.04872995f, 0.00891840f, 0.02644117f, 0.13958894f, -0.05208745f, 
    -0.14088218f, 0.24756104f, -0.18600397f, 0.22721687f, 0.06855077f, 0.09875030f, 0.02570502f, -0.09942318f, 
    0.02982014f, 0.05412306f, -0.05747911f, 0.12665214f, 0.04997013f, -0.05310711f, -0.12333748f, -0.01704334f, 
    0.08436824f, 0.00547841f, -0.02751637f, 0.02374742f, -0.09567522f, 0.04923338f, 0.04397158f, 0.01995159f, 
    0.38101840f, -0.19552557f, -0.00354201f, 0.10195373f, 0.24798951f, 0.00978854f, 0.07888333f, 0.13658260f, 
    -0.02498142f, -0.01353382f, 0.03565302f, -0.06493344f, 0.30283764f, 0.09030946f, 0.13816099f, -0.06983289f, 
    -0.00570012f, 0.07066859f, 0.07353467f, 0.07644780f, -0.10702991f, -0.11018591f, 0.00944019f, 0.02446213f, 
    0.11223203f, 0.34436506f, -0.11384796f, 0.14010091f, -0.01547724f, 0.06556232f, -0.01348263f, 0.14621226f, 
    -0.11404055f, -0.12797284f, -0.05053508f, -0.01013017f, 0.21112691f, -0.22808658f, -0.09715363f, -0.16055827f, 
    -0.00985773f, -0.04541172f, 0.06907120f, 0.15082735f, -0.00669309f, -0.00330196f, 0.04311037f, 0.07767777f, 
    -0.05455101f, -0.02803647f, -0.29967934f, -0.00167964f, -0.05587522f, 0.02386414f, 0.06086306f, -0.01928415f, 
    0.03709427f, 0.05719009f, 0.03667561f, 0.12100909f, 0.06451251f, -0.06346999f, -0.29956993f, -0.46467486f, 
    0.02703963f, 0.18821995f, 0.00450477f, -0.02416760f, 0.05472498f, -0.01756548f, -0.06468661f, 0.04051912f, 
    0.13729814f, -0.17193244f, 0.03845316f, -0.13167982f, -0.02212801f, 0.03137992f, 0.06706963f, -0.01853327f, 
    0.02370366f, 0.01264478f, 0.13847721f, 0.00005201f, 0.28971252f, 0.00189325f, -0.18182257f, 0.02613271f, 
    0.04868922f, 0.07735658f, -0.06383554f, -0.10956832f, -0.01787059f, -0.05529452f, 0.07623127f, -0.05624076f, 
    0.14882351f, -0.16412432f, 0.08898319f, -0.15583184f, 0.18217680f, -0.11745641f, 0.00508041f, 0.07268001f, 
    0.04387028f, 0.09741875f, -0.10410260f, -0.02124903f, -0.03478163f, -0.01666856f, -0.10242630f, -0.08196693f, 
    -0.04404740f, 0.11546116f, 0.18156429f, 0.06346665f, 0.05572026f, -0.16316041f, 0.03289329f, 0.13758689f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.05386664f, -0.04449050f, 0.15047929f, -0.00861314f, -0.00884131f, 0.23565820f, 0.12158559f, 0.02496113f, 
    -0.04494959f, -0.00704481f, -0.01689850f, 0.05689129f, -0.07915167f, -0.05277674f, -0.03224981f, 0.08856431f, 
    -0.04202232f, -0.05208192f, -0.03759681f, -0.01523099f, -0.01333601f, 0.11531156f, -0.02428741f, 0.06195315f, 
    0.10384777f, 0.04230446f, 0.04070546f, -0.05945397f, 0.02082822f, 0.05358215f, 0.13972835f, 0.11535189f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.06811237f, -0.08337866f, -0.13258882f, 0.12965649f, 0.05977150f, -0.04765380f, 0.12731194f, 0.11774802f, 
    0.15865369f, -0.01863117f, -0.03903158f, -0.07172880f, -0.08524424f, 0.09972267f, 0.15707676f, -0.17480099f, 
    -0.14228329f, 0.10948563f, -0.08624414f, -0.12794438f, -0.03392157f, 0.06331504f, 0.05644713f, 0.06518863f, 
    0.05943081f, -0.04698105f, -0.06427416f, -0.13503394f, 0.00839209f, -0.14712246f, -0.12037322f, 0.07381301f, 
    0.13719471f, 0.65216815f, 0.16114925f, 0.11227606f, 0.00330103f, 0.01556938f, 0.08777536f, 0.02283547f, 
    0.00622272f, -0.41020563f, 0.08773360f, -0.13496660f, -0.02631626f, 0.04855505f, -0.10768485f, 0.20108822f, 
    0.33348304f, -0.15325089f, 0.17101830f, 0.06483265f, 0.09815867f, -0.35443395f, -0.01836250f, 0.00653635f, 
    0.13298576f, 0.00123668f, 0.53208894f, 0.21785057f, -0.32524592f, 0.41743103f, -0.13507843f, -0.14003517f, 
    0.11010558f, 0.45559531f, 0.06882758f, 0.46127170f, -0.02564813f, -0.26424068f, -0.15360348f, 0.35041910f, 
    0.00893846f, -0.43992800f, 0.05129817f, 0.00687488f, 0.09936722f, 0.11863319f, -0.35936475f, -0.22120214f, 
    -0.28381625f, 0.16484866f, -0.13374396f, 0.07014855f, -0.29569688f, 0.31217569f, 0.22882046f, 0.12636557f, 
    0.28913775f, 0.37313685f, 0.23170771f, 0.29216269f, -0.04063671f, 0.27179724f, -0.08930381f, 0.00601893f, 
    0.15933309f, 0.23983890f, -0.06167813f, -0.28718936f, 0.13528676f, 0.39427656f, -0.03319037f, 0.06016768f, 
    -0.01220986f, 0.22846568f, 0.00355214f, -0.06719384f, 0.12502536f, 0.05691504f, 0.27375045f, -0.21574099f, 
    0.18451673f, 0.05497429f, 0.05078045f, -0.01192329f, 0.57485026f, 0.52426600f, -0.27461797f, 0.08077326f, 
    -0.08867285f, -0.47589907f, 0.00791078f, -0.17639312f, 0.26507258f, 0.07064092f, 0.26788807f, -0.04191044f, 
    0.09650551f, 0.11606160f, 0.22544466f, 0.01522067f, -0.05915065f, 0.08396209f, 0.21038987f, 0.25070328f, 
    0.08476267f, -0.15381947f, -0.01515289f, -0.07397102f, 0.01915865f, -0.14596221f, -0.22521435f, -0.12178124f, 
    0.30794549f, 0.36630735f, -0.22553532f, -0.08896594f, 0.30791926f, 0.33927944f, 0.08450869f, 0.17511941f, 
    -0.36768255f, -0.70377916f, 0.19517642f, -0.06016898f, 0.15280184f, -0.20251548f, -0.01396414f, -0.05570457f, 
    -0.12421948f, 0.30094442f, 0.06848755f, -0.06227339f, -0.13138926f, -0.07543100f, 0.33819011f, -0.33810315f, 
    0.04452027f, 0.30002347f, -0.16625516f, -0.05433928f, -0.10467440f, -0.02964878f, 0.24589182f, 0.37890923f, 
    -0.27333009f, 0.08320034f, 0.13412960f, 0.11237460f, 0.37379891f, -0.21293044f, 0.48688477f, -0.10179777f, 
    -0.17793633f, 0.43895537f, -0.34619170f, -0.38939345f, -0.18896002f, 0.16818230f, -0.10213757f, 0.04025041f, 
    -0.15619884f, -0.44632053f, 0.11511382f, 0.11272971f, -0.00064974f, 0.13286234f, 0.14714508f, -0.29496640f, 
    -0.10968295f, -0.21169406f, 0.14517313f, 0.07429584f, 0.16873799f, -0.00650528f, 0.39729181f, 0.24136089f, 
    0.02660388f, 0.07562280f, -0.14070934f, -0.10823571f, 0.32677710f, 0.08125183f, -0.23261720f, 0.11060705f, 
    0.58916676f, -0.19653165f, -0.30604723f, 0.38799748f, 0.14534219f, 0.50589216f, 0.15267974f, 0.19173284f, 
    0.08565412f, 0.30782104f, -0.02619388f, -0.29004636f, 0.05008744f, -0.22518471f, -0.17428264f, 0.12178513f, 
    -0.01517101f, 0.09456856f, -0.00397006f, 0.13009904f, 0.12954871f, 0.08981515f, 0.12441096f, 0.01751387f, 
    -0.20019807f, 0.31754684f, -0.03083161f, 0.31679350f, -0.06645352f, 0.24818775f, -0.09400114f, -0.11908107f, 
    0.35124019f, 0.43502936f, -0.24119568f, -0.11545190f, -0.19026077f, -0.21765624f, 0.36247867f, -0.00646666f, 
    -0.10035553f, -0.27435574f, 0.14830470f, 0.21649623f, 0.04914546f, -0.57913637f, 0.00672915f, 0.19614586f, 
    -0.06717024f, 0.08525909f, -0.03407339f, 0.04192938f, 0.14474684f, 0.15971620f, 0.08229884f, 0.34768882f, 
    -0.00317087f, 0.10230966f, -0.19349205f, -0.10394987f, -0.64964557f, -0.18875557f, 0.25007588f, -0.07954510f, 
    0.23251180f, 0.62196296f, -0.32268253f, -0.08173848f, -0.19900966f, 0.14286028f, -0.06398576f, 0.05044441f, 
    0.14275366f, 0.34138665f, -0.12448350f, 0.48199621f, 0.08234464f, -0.13455401f, 0.09473274f, -0.19496714f, 
    0.01561648f, -0.05012272f, 0.05102938f, -0.14528193f, -0.14533164f, -0.18254276f, 0.04181477f, 0.14195356f, 
    0.20999797f, 0.14564851f, 0.10089276f, 0.10235260f, 0.39177921f, -0.06388492f, 0.23130322f, -0.06344955f, 
    -0.27122095f, -0.75715113f, -0.09326483f, -0.17144547f, 0.39781696f, 0.18940130f, -0.29588899f, -0.11520860f, 
    -0.14486733f, 0.49393216f, -0.21914192f, 0.65740669f, 0.02627717f, -0.09996767f, -0.00358215f, 0.01735179f, 
    -0.07393196f, -0.05402970f, 0.16542411f, 0.14326659f, 0.01117014f, 0.08125026f, -0.06925095f, 0.32250345f, 
    -0.02803780f, -0.03003614f, 0.27620023f, 0.18836506f, -0.21492162f, 0.11775374f, 0.18933733f, 0.09185043f, 
    0.09835331f, 0.04139691f, 0.01960075f, -0.22468273f, 0.20658450f, 0.32894373f, -0.02679552f, -0.06147536f, 
    -0.03016641f, -0.11305620f, 0.05520784f, 0.10848650f, -0.06661015f, 0.08234771f, -0.05296822f, 0.13541472f, 
    -0.05572399f, 0.05544876f, -0.08611494f, 0.12425685f, 0.13552585f, -0.05870009f, 0.13902232f, 0.05937141f, 
    -0.15218747f, -0.14590488f, -0.03228534f, -0.18384047f, 0.09669566f, 0.05410968f, -0.05222898f, -0.00111416f, 
    -0.08012811f, 0.00048491f, 0.12166903f, -0.11874133f, -0.17432885f, -0.18432730f, -0.07457184f, 0.10825838f, 
    0.03770049f, -0.66929269f, 0.09123885f, 0.53139025f, -0.11483305f, -0.42087919f, -0.36077213f, -0.02701257f, 
    -0.03055981f, 0.42108184f, -0.15957519f, -0.02118859f, -0.08734165f, -0.15079135f, 0.18280043f, 0.28163266f, 
    0.21808653f, 0.19715378f, 0.09094562f, 0.16842294f, -0.45502037f, -0.09418872f, 0.16572267f, 0.03448703f, 
    -0.49240741f, 0.03720735f, -0.37120903f, -0.01486938f, 0.41440022f, -0.02549824f, -0.11329519f, 0.28834406f, 
    -0.05534897f, 0.26120496f, -0.30531269f, -0.05338708f, -0.03068594f, 0.19141178f, -0.03843996f, -0.16039784f, 
    -0.05466960f, 0.17661387f, 0.07946739f, 0.07478505f, -0.09329613f, 0.16129951f, 0.09395033f, -0.08937764f, 
    0.18290639f, 0.09332669f, 0.43948343f, 0.06630332f, 0.24840201f, -0.18934131f, -0.25868192f, -0.11095607f, 
    -0.33259836f, -0.47322133f, -0.04596739f, -0.20357820f, 0.25808674f, 0.23863018f, -0.26892322f, -0.02807701f, 
    0.16642758f, -0.22042340f, -0.18739212f, -0.14653987f, -0.07757106f, -0.12113912f, -0.05151007f, -0.00333256f, 
    -0.09495202f, 0.00403549f, 0.01224199f, -0.07005139f, 0.09734119f, 0.00837184f, 0.09243897f, 0.02385153f, 
    0.10862625f, -0.09245283f, -0.07312169f, 0.02054089f, 0.04988153f, -0.15078527f, 0.16568455f, 0.01119191f, 
    -0.01647688f, -0.03340134f, -0.09089893f, -0.11283375f, 0.13212945f, -0.19293228f, -0.19193672f, -0.02503529f, 
    -0.12102498f, 0.03292015f, 0.02189254f, -0.16572535f, 0.17730154f, 0.35224041f, 0.31210569f, -0.33815259f, 
    0.13250235f, 0.30685711f, 0.09885971f, -0.07988500f, 0.06494821f, 0.06560804f, 0.17999363f, 0.02325163f, 
    -0.12143131f, -0.29074109f, 0.38051417f, -0.15675209f, 0.27419588f, -0.06530116f, -0.17175581f, 0.10280056f, 
    0.18926817f, -0.41743630f, 0.33505449f, 0.15420651f, 0.08478255f, -0.14584436f, 0.09791416f, -0.25224483f, 
    -0.06673829f, 0.38242325f, 0.13118312f, -0.01192607f, -0.11514340f, -0.56122649f, -0.16176432f, -0.05789365f, 
    0.09672680f, 0.56104463f, -0.13707277f, -0.07786209f, 0.02279687f, 0.13414878f, 0.20275475f, -0.10625140f, 
    0.20796657f, 0.02607294f, 0.06908578f, 0.32252544f, 0.04973378f, -0.16684948f, -0.13627899f, 0.14604577f, 
    0.24088252f, 0.52082503f, 0.38121432f, 0.31853822f, -0.16913384f, -0.30222118f, 0.37225074f, -0.32670954f, 
    -0.03588968f, 0.15519650f, -0.16550060f, 0.25339606f, -0.12851845f, 0.21663974f, -0.22252147f, 0.27756938f, 
    -0.08362718f, 0.24645436f, 0.12615988f, -0.08642455f, 0.14377312f, -0.16474389f, 0.07610244f, 0.03697894f, 
    0.27039975f, -0.15640843f, 0.15626527f, 0.10547764f, -0.15738539f, 0.49273703f, -0.45328164f, -0.17203315f, 
    -0.28039441f, -0.27733302f, 0.19224051f, -0.19923005f, 0.26325306f, -0.23238401f, 0.30402768f, 0.18975462f, 
    -0.00801300f, -0.41634357f, 0.39868852f, -0.41697988f, 0.07825586f, -0.26163164f, 0.15992808f, -0.31046245f, 
    -0.13802345f, -0.02450198f, -0.10995063f, 0.16273662f, -0.02676793f, 0.14661983f, 0.11299341f, 0.11870881f, 
    0.17543499f, 0.24763542f, 0.07523600f, 0.09745093f, 0.31146193f, -0.42974371f, -0.02912309f, -0.02425608f, 
    0.09887213f, -0.00825217f, 0.03999252f, 0.39619184f, -0.25567386f, -0.00059783f, -0.11476835f, 0.31926680f, 
    -0.16788264f, 0.59245843f, -0.11804803f, 0.65028971f, -0.17326501f, -0.33627063f, -0.01942511f, 0.03945955f, 
    -0.17216432f, 0.17981675f, -0.11185564f, -0.01878302f, -0.15043285f, -0.08878467f, -0.07548643f, 0.22709762f, 
    0.28705376f, 0.01580651f, 0.22095443f, 0.17192233f, -0.44860846f, -0.01664008f, 0.15121174f, -0.15614226f, 
    -0.12112473f, 0.15746561f, 0.08295543f, -0.07291242f, 0.06816842f, 0.31148919f, -0.07601279f, -0.28392968f, 
    0.00232915f, 0.23908862f, 0.03644603f, 0.16614810f, -0.06808440f, 0.56519145f, 0.49293846f, 0.47006190f, 
    -0.07108668f, -0.26510313f, 0.05085190f, 0.07593711f, 0.03987304f, -0.07136254f, -0.04716931f, 0.34190160f, 
    -0.18013243f, -0.04127822f, 0.24031328f, 0.08315830f, -0.18341932f, 0.16100280f, 0.00563051f, -0.04703887f, 
    0.48667774f, 0.06033808f, -0.01101593f, -0.18341103f, 0.29057634f, -0.12938832f, -0.08492662f, -0.11175403f, 
    -0.12664697f, -0.19253415f, 0.19081059f, 0.06827647f, -0.11131062f, 0.17006147f, -0.28034762f, 0.42881539f, 
    0.12248868f, -0.04395382f, -0.04818315f, 0.12381024f, -0.02704256f, -0.13990872f, -0.26154473f, 0.15963013f, 
    -0.06120558f, 0.38033980f, -0.23800732f, 0.15807760f, -0.18741046f, 0.35170448f, 0.26735058f, -0.00303605f, 
    -0.31037596f, 0.23222820f, -0.19932087f, -0.04939225f, 0.22034983f, -0.08850074f, 0.19410032f, 0.47234190f, 
    0.05372537f, -0.54251242f, 0.25989607f, 0.00216558f, -0.09583334f, 0.05270696f, 0.00469683f, -0.44915673f, 
    -0.12331463f, 0.27174100f, -0.08219469f, 0.00227384f, 0.03459913f, -0.08898659f, 0.32998481f, 0.23423623f, 
    0.18507558f, -0.16280571f, 0.22686940f, -0.09388360f, -0.18574646f, -0.29951203f, -0.18402271f, -0.06124686f, 
    0.09603440f, 0.06300679f, 0.09669354f, 0.12273145f, -0.09320634f, 0.21075580f, 0.08824820f, 0.24630278f, 
    0.15495424f, -0.15530214f, -0.03418402f, -0.00581791f, -0.14408545f, -0.04498921f, -0.07090712f, -0.14953348f, 
    0.09441054f, -0.10258484f, -0.05154423f, -0.12041306f, 0.14596246f, -0.05719100f, 0.07222113f, -0.04742161f, 
    -0.02090996f, 0.07319590f, -0.14170200f, -0.00212070f, 0.00250869f, -0.13635032f, -0.10816578f, -0.07935695f, 
    0.12226211f, -0.08461265f, -0.09343044f, 0.00488452f, -0.02434754f, 0.05798993f, -0.15163919f, -0.07890067f, 
    0.10504737f, -0.40766975f, 0.31069061f, -0.50940746f, 0.16770898f, -0.29896960f, 0.27127558f, -0.46613172f, 
    0.15290354f, 0.23547268f, 0.16253656f, 0.10693422f, -0.08092052f, -0.03700865f, 0.23393182f, 0.09237151f, 
    -0.17701510f, 0.19562592f, -0.11213953f, 0.27431577f, 0.55751348f, -0.19294177f, -0.09201671f, -0.14199957f, 
    0.09444565f, 0.16518925f, -0.15889460f, 0.25660396f, -0.11387075f, -0.17546684f, 0.08494234f, 0.09817610f, 
    0.13710910f, 0.08124541f, -0.01174828f, -0.01308474f, 0.02786748f, -0.29731652f, -0.32262024f, 0.10028978f, 
    0.13481574f, -0.11495008f, -0.02882065f, -0.07248799f, -0.02703293f, 0.06068083f, 0.27512065f, -0.48708344f, 
    -0.11425617f, 0.34385690f, -0.33629349f, 0.00280276f, -0.13450044f, 0.35948166f, 0.27764958f, 0.10058329f, 
    0.32014325f, -0.26757890f, -0.07500113f, 0.45048639f, 0.32583806f, -0.14357628f, 0.10517230f, -0.08746491f, 
    0.04880627f, 0.35500771f, -0.09994489f, 0.29277244f, 0.03671610f, 0.08124547f, 0.21947537f, -0.11334506f, 
    -0.13464539f, 0.35959807f, 0.15078959f, -0.15149857f, 0.03502054f, 0.01236969f, 0.19188498f, -0.03080229f, 
    -0.16487812f, -0.40202776f, 0.19463116f, -0.05387088f, -0.10461570f, 0.07461196f, -0.07751442f, -0.05295932f, 
    0.33208090f, 0.35854185f, 0.13931483f, -0.18640842f, -0.17647305f, -0.11011888f, 0.25881690f, -0.40587613f, 
    -0.10730179f, -0.03452441f, 0.38228619f, 0.44810992f, -0.17311004f, 0.22163036f, -0.21041144f, 0.18547526f, 
    0.09290811f, 0.18396224f, -0.11283284f, -0.01429177f, 0.16816123f, 0.02065726f, -0.30572453f, 0.51742256f, 
    0.27522939f, -0.16720381f, -0.15125638f, 0.11143803f, -0.16942216f, 0.14644431f, -0.08328114f, -0.09197274f, 
    -0.19974697f, 0.16421029f, -0.14752133f, -0.37121415f, 0.04449980f, -0.14238510f, 0.31993684f, 0.21331960f, 
    0.11512051f, 0.43239680f, 0.18752736f, -0.25782406f, -0.14330690f, 0.34042394f, -0.11285432f, 0.64481676f, 
    0.12605251f, -0.20221680f, 0.11139119f, -0.11712948f, -0.02352589f, 0.13010097f, -0.23060860f, -0.14955059f, 
    0.12606660f, -0.09267083f, 0.42934290f, 0.10548355f, -0.46875724f, -0.24530090f, -0.48085564f, 0.11833711f, 
    0.11018936f, 0.18018372f, 0.52319390f, 0.44953018f, -0.22325096f, 0.29141700f, 0.22984691f, 0.36398086f, 
    -0.18338600f, 0.10931204f, -0.19238929f, -0.54286230f, 0.12548438f, 0.04609428f, 0.25785166f, 0.06106491f, 
    -0.16979048f, 0.30309713f, 0.09493851f, 0.14626129f, 0.00862578f, -0.00152507f, 0.32448620f, -0.35341915f, 
    -0.26341835f, 0.32714784f, 0.25340015f, 0.22932000f, 0.19637923f, 0.09209697f, -0.08040572f, -0.17695835f, 
    0.37075937f, -0.06235754f, 0.25772738f, 0.13714363f, -0.16549911f, -0.37618610f, 0.26228717f, 0.14240210f, 
    0.15081859f, 0.15575415f, 0.18844081f, 0.10947586f, -0.14683643f, 0.10285509f, 0.54959625f, -0.44424766f, 
    0.04936909f, -0.39118820f, -0.02253215f, -0.13241637f, -0.00213035f, 0.11341169f, 0.01815896f, -0.14865848f, 
    0.00591835f, -0.15961471f, -0.07576969f, 0.00848908f, 0.44328755f, 0.38209775f, 0.57985306f, -0.12773488f, 
    0.61681694f, -0.12948728f, 0.36976397f, 0.24365598f, 0.26166812f, 0.31573817f, -0.14300080f, -0.31645811f, 
    0.08917965f, 0.21061093f, -0.17388035f, -0.33729073f, -0.02795792f, 0.00541569f, 0.04684613f, 0.15591402f, 
    -0.17520326f, -0.13922806f, 0.00244675f, -0.11405084f, 0.12365828f, 0.11143588f, 0.10494588f, -0.01204452f, 
    0.05962008f, 0.35226256f, -0.00846572f, -0.03476814f, 0.41612592f, 0.13624528f, -0.10926618f, 0.04943303f, 
    0.09225359f, -0.73194653f, -0.16516002f, 0.06052417f, 0.04600948f, 0.15143533f, -0.00791456f, 0.19436856f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03595224f, 0.06752320f, -0.01634331f, 0.19528829f, 0.16554894f, 0.11532050f, 0.05188788f, -0.08021776f, 
    0.04592234f, -0.16357000f, -0.09977240f, -0.05755566f, 0.18131743f, -0.13074681f, -0.19092113f, 0.18289186f, 
    -0.10538738f, 0.14008203f, 0.22979119f, -0.00578980f, 0.16970965f, 0.12495933f, 0.16406077f, 0.09079400f, 
    -0.01029790f, -0.05388754f, 0.08383754f, 0.20915766f, -0.02137326f, 0.03662645f, 0.25386736f, 0.03478713f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.10112574f, -0.24806027f, -0.20573178f, -0.07650499f, 0.11167630f, 0.35879874f, -0.15373093f, 0.11584321f, 
    -0.27692363f, -0.35364163f, -0.61123902f, -0.15050614f, -0.03052986f, -0.87627822f, 0.08793902f, -0.09072552f, 
    0.26748809f, -0.40395245f, 0.45072949f, -0.41909277f, -0.30907208f, 0.13367756f, 0.03718308f, -0.03225863f, 
    0.54271704f, -0.18723907f, -0.61156547f, 0.03464244f, -0.34525493f, 0.21478790f, -0.07408330f, -0.32508028f, 
    -0.15115254f, -0.20183633f, 0.02696154f, -0.53019679f, -0.39199704f, 0.21313021f, 0.12568519f, -0.09127834f, 
    0.77154392f, 0.02599809f, 0.06852660f, -0.00864187f, 0.46464908f, 0.52355063f, 0.10876903f, 0.05808303f, 
    -0.03668274f, -0.28531286f, 0.25337797f, 0.03400376f, -0.03836169f, 0.14301212f, 0.24508484f, -0.10806839f, 
    0.11329058f, 0.15446100f, -0.62830603f, 0.04882396f, -0.12525070f, -0.22226322f, -0.41578445f, -0.15152638f, 
    0.13279298f, -0.52424121f, -0.51092345f, 0.32329690f, 0.17014949f, -0.30263835f, 0.14640759f, 0.15810445f, 
    -0.44782749f, 0.26155901f, 0.05254316f, 0.08283135f, 0.24654287f, -0.09342596f, 0.08767250f, -0.38500708f, 
    0.04827395f, 0.28132585f, -0.15192670f, 0.07721785f, -0.55448687f, 0.08969463f, -0.18236287f, -0.04935105f, 
    0.00566108f, 0.27833876f, -0.57502896f, 0.19515237f, -0.57942033f, -0.27343088f, -0.40801844f, 0.11014315f, 
    -0.16906543f, 0.08431952f, 0.14074232f, 0.01379822f, -0.06542560f, 0.14098656f, 0.25780320f, 0.11591475f, 
    -0.24173909f, 0.03406346f, -0.03956779f, -0.09365016f, -0.86486489f, 0.08139025f, -0.08787492f, 0.10322452f, 
    -0.19778612f, -0.47925049f, 0.22034547f, -0.40582860f, 0.19082353f, -0.46522334f, -0.19277608f, -0.16399954f, 
    0.27549431f, 0.35518122f, -0.24508360f, -0.66632652f, -0.12530687f, 0.25982273f, 0.08425318f, 0.33619758f, 
    -0.03608511f, -0.14565197f, -0.46466103f, 0.03170231f, -0.62304473f, 0.00009881f, 0.05714203f, -0.03542318f, 
    -0.33365437f, -0.52031583f, -0.01738485f, -0.00285415f, -0.09111697f, -0.70820522f, -0.02959446f, 0.41633859f, 
    0.26549476f, 0.00971812f, -0.14384480f, -0.03569160f, 0.16762106f, -0.30815873f, 0.20576429f, -0.00895713f, 
    0.11714455f, -0.13191661f, 0.59426880f, 0.03276014f, -0.14772655f, 0.00682050f, 0.14349340f, -0.52358121f, 
    0.08914153f, 0.44023666f, 0.37629899f, -0.43478048f, -0.29415831f, 0.22171529f, -0.07909934f, 0.15378724f, 
    0.09464847f, -0.30276641f, 0.17656834f, -0.00531057f, -0.30798477f, 0.11488689f, 0.12271028f, -0.51645821f, 
    0.21616213f, -0.32216135f, 0.03589276f, 0.15278463f, 0.05477862f, -0.04530545f, -0.07314582f, -0.05644771f, 
    -0.02933023f, -0.60355580f, 0.07823946f, 0.12931551f, 0.19798550f, -0.14705402f, 0.01668186f, 0.01499217f, 
    0.07746774f, -0.18365905f, 0.49969071f, -0.11134674f, 0.04246918f, -0.70009434f, -0.04171679f, 0.25055775f, 
    -0.74257237f, -0.31094271f, -0.05499911f, 0.10141502f, -0.10093813f, -0.14085478f, 0.01882153f, -0.40180779f, 
    0.01579636f, 0.01472428f, -0.18310346f, -0.10838827f, 0.06380570f, 0.26301110f, -0.25414523f, -0.14589344f, 
    -0.03130399f, 0.70601803f, -0.46165264f, -0.17887296f, 0.15544130f, 0.25353318f, 0.02713025f, -0.00643958f, 
    0.07105280f, 0.07119194f, 0.07079168f, 0.17982143f, 0.03626392f, 0.20135069f, -0.46806934f, -0.50832325f, 
    -0.20537175f, 0.22951239f, 0.35373044f, -0.03920717f, -0.18331899f, 0.45312896f, -0.08062860f, 0.21569470f, 
    -0.23931576f, 0.08388995f, -0.56825048f, 0.26486054f, 0.01610288f, -0.29039949f, -0.20542753f, 0.06842183f, 
    -0.51169080f, 0.17046291f, 0.25217298f, -0.58018482f, -0.17683227f, -0.03312180f, -0.00471507f, -0.01772480f, 
    -0.00738378f, 0.26719886f, 0.26586583f, -0.52982080f, 0.45076349f, -0.05130592f, -0.37820765f, -0.51143420f, 
    -0.14605778f, 0.44897872f, 0.29512095f, 0.03151508f, 0.14002116f, -0.16199569f, -0.00998988f, -0.40471342f, 
    -0.13423857f, -0.19444710f, -0.11520566f, 0.34187633f, 0.17928363f, 0.00459880f, -0.32527333f, -0.05991996f, 
    -0.18208696f, 0.14902796f, -0.06334123f, 0.19444321f, -0.37389460f, -0.56926072f, 0.22167604f, -0.58439738f, 
    -0.15341167f, -0.16954343f, -0.38091040f, 0.09256581f, 0.11647107f, -0.35459188f, -0.47373262f, 0.11317251f, 
    -0.58201921f, -0.44576693f, -0.10223921f, 0.06458317f, -0.05443444f, -0.05309412f, -0.05851689f, -0.16029042f, 
    0.04243126f, 0.51409739f, -0.27646381f, -0.06966437f, 0.20729822f, 0.22963941f, -0.10663479f, -0.04515457f, 
    -0.26659217f, -0.86412591f, 0.04047417f, 0.35863116f, 0.31641108f, 0.08486135f, -0.76867908f, -0.02603652f, 
    0.16326885f, -0.14982548f, -0.12918715f, 0.14200830f, 0.25061509f, 0.06524227f, 0.30089226f, -0.26282394f, 
    -0.14046669f, -0.06712616f, -0.05579091f, 0.14178060f, -0.19352511f, -0.43163663f, 0.04714293f, 0.03466631f, 
    -1.30860066f, -0.06022597f, -0.15167311f, -0.53082395f, 0.37375897f, 0.32837513f, -0.04293640f, 0.15302564f, 
    -0.04582890f, -0.60906839f, -0.26748481f, 0.29016489f, -0.33419347f, -0.20005305f, 0.27592495f, 0.18112986f, 
    0.01665377f, 0.45757097f, -0.24613050f, -0.03292216f, 0.23962173f, -0.66005713f, 0.22726566f, -0.55442488f, 
    -0.46712881f, -0.22533654f, -0.55350614f, 0.05423277f, -0.31128779f, -0.39656502f, -0.00009044f, 0.28537026f, 
    -0.07161558f, -0.06770670f, 0.44814113f, -0.24362308f, -0.25649157f, -0.25342685f, 0.34242034f, -0.13429962f, 
    0.10560551f, 0.10847016f, -0.50247645f, 0.00806657f, 0.41955584f, -0.16852002f, 0.06190382f, 0.01611253f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.08636738f, -0.17761053f, -0.02888647f, 0.11688235f, -0.02425333f, -0.13115194f, -0.06240274f, -0.19144168f, 
    -0.11457549f, 0.09494263f, 0.28273168f, 0.14325555f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
