#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.87061620f, 0.62247068f, 0.98246378f, 0.82877952f, 0.57786715f, -0.23479404f, 0.41875046f, -0.49236494f, 
    0.49633345f, 0.14317247f, 0.14295644f, 0.24064417f, -0.46299481f, -0.22491442f, -0.17056221f, -0.45811644f, 
    -0.07398670f, -0.13170600f, -0.19740023f, -0.41306049f, 0.21103252f, 0.55563611f, 0.22945400f, -0.01496794f, 
    0.06364625f, 1.04250813f, 1.00534892f, 1.35607553f, 0.11082001f, 1.27802992f, -0.04003611f, -0.62808084f, 
    -0.08888891f, -0.92762685f, -0.76680344f, 0.52465928f, 0.12056497f, -0.06612922f, 0.51132637f, -0.16344006f, 
    -0.05101847f, -0.04277772f, 0.00750393f, 0.45564693f, 0.40940380f, -0.28965950f, -0.02192121f, 0.06643374f, 
    0.11784253f, 0.01704903f, 1.76042652f, 1.52671146f, -0.94852364f, -0.21097197f, -1.12505007f, 0.07135651f, 
    0.11535253f, -0.72115928f, 0.00966611f, 0.01181612f, 0.35271272f, 0.38417324f, 0.10974178f, -0.04979676f, 
    -0.15749101f, -0.02343616f, -0.42271191f, -0.19424967f, 0.18153423f, -0.05422539f, -0.36514601f, 0.20197393f, 
    0.02046249f, -0.10672048f, -0.14830786f, -0.81098562f, -0.17404923f, 0.11860529f, 0.76245272f, -0.59190494f, 
    -0.11731575f, 0.68463373f, 0.85370249f, -0.19370086f, -0.42582220f, -0.82845104f, -0.48971781f, -0.58389491f, 
    -0.48500660f, -0.15174961f, 0.16595912f, -0.52969450f, 0.23975162f, -0.32261002f, -0.18424845f, -0.62305057f, 
    -0.08001743f, 0.20833147f, 0.28336456f, -0.23103657f, 0.70857292f, -0.27383587f, 0.71409476f, 1.02257097f, 
    -0.21403049f, -1.18519926f, -1.71375251f, 0.21358094f, -0.13709009f, -0.76914340f, -0.41187438f, -0.02432533f, 
    0.12562761f, 0.14513411f, 0.33498371f, -0.05686187f, 0.16141662f, -0.02769640f, -0.08076064f, 0.13236286f, 
    0.52199787f, 0.40503529f, 0.16478661f, 0.20706224f, -0.08030517f, 0.43011782f, 0.00580266f, -0.53633541f, 
    0.99120557f, 1.23111641f, 0.50643504f, 0.78455174f, 0.87679678f, 0.89020288f, 0.94036990f, -0.26010174f, 
    -0.29210189f, 0.03445495f, -0.29670343f, 0.21033017f, -0.37616235f, -0.52447289f, -0.07989591f, -0.25692105f, 
    -0.08251565f, 0.27140251f, -0.30987689f, -0.17420018f, 0.20064330f, -0.40037504f, 0.41009635f, 0.20938869f, 
    0.95290267f, 0.99978656f, 0.60823953f, 0.65967059f, 0.10565384f, 0.69481474f, 0.28715265f, 0.50053519f, 
    0.62083316f, 0.34374604f, -0.31783095f, 0.57774091f, 0.43575507f, 0.88917077f, -0.03493142f, -0.27092871f, 
    0.10812943f, 0.32764420f, 0.34622166f, 0.49056628f, -0.02998896f, 0.11296690f, 0.25103047f, -1.18510830f, 
    -0.80733639f, 0.39409822f, -0.80573606f, -0.09318577f, 0.99097890f, -0.13544950f, -0.41871884f, -0.63295865f, 
    -1.19695842f, -0.64352936f, -0.10217115f, 0.20816793f, 0.42334470f, 0.36720964f, -0.23629203f, 0.42583588f, 
    -0.36796454f, 0.01449363f, 0.00527105f, 0.38062093f, 0.12500629f, 0.21090056f, 0.55752426f, -0.38006616f, 
    -0.49417868f, 1.80024624f, 0.17649335f, -0.48252538f, 1.38904464f, -0.54213130f, 0.96666896f, 1.13463771f, 
    -0.20372000f, 0.37453589f, -0.65195930f, 0.05240403f, -0.03298337f, -0.30813891f, 0.09911951f, 0.53479016f, 
    0.00208945f, 0.21741314f, 0.03635832f, 0.09699966f, 0.09786168f, 0.08174327f, -0.13170806f, 0.13560916f, 
    0.33125088f, 1.14648616f, 0.98811781f, 0.04879232f, 1.52635908f, 1.48022044f, 1.29418838f, -0.01028173f, 
    -1.15063727f, 0.30246383f, -0.16766900f, -0.52906936f, -0.01701964f, -0.37038532f, 0.85650510f, -0.42009979f, 
    -0.34379217f, -0.00120509f, -0.03779678f, -0.00199213f, -0.35892552f, 0.18341838f, -0.11822487f, -0.15180370f, 
    -0.33592206f, 0.32222041f, 0.78508979f, -0.14283645f, -1.44518840f, -1.82446826f, -0.58850229f, -0.01113764f, 
    -0.54412222f, 0.55778772f, 0.46233439f, 0.18100122f, -0.08636030f, -0.08039855f, 0.32904261f, 0.04210875f, 
    -0.26019934f, 0.20041531f, 0.14876163f, 0.04555352f, 0.21378212f, 0.53535789f, -0.17847361f, 0.11381105f, 
    0.10310190f, -0.35855964f, 0.21079382f, 0.40219051f, 0.23880936f, 0.18206821f, -0.29178724f, 1.07767999f, 
    0.49343890f, -1.18118691f, -1.51413572f, -0.93477154f, -0.34570381f, 0.03703554f, 1.14062190f, 0.14590527f, 
    -0.28107837f, -0.02126390f, 0.22863637f, -0.40787694f, 0.10678944f, -0.20793681f, -0.12565079f, 0.24645266f, 
    -0.08452256f, 0.15687044f, 0.23073101f, -0.04703116f, -0.90758663f, -0.06945033f, -0.85810888f, -0.39023659f, 
    -0.94019544f, 1.20850670f, 1.59083021f, -0.09591879f, 0.39765525f, 0.55833751f, -0.09162205f, -0.20018232f, 
    0.00538995f, -0.19163261f, -0.32903433f, 0.02370665f, 0.05761260f, -0.13698150f, 0.10005803f, -0.30097249f, 
    0.24143775f, -0.27503544f, -0.02141705f, -0.06612445f, 0.21357985f, -0.36498094f, -2.39428735f, -0.89985269f, 
    0.36917377f, -0.35493085f, -0.03990246f, 1.16593802f, 0.61628944f, 0.27728948f, -0.01835795f, -0.02866576f, 
    0.28887090f, -0.00576016f, 0.67208576f, 0.19394243f, -0.24044940f, -0.05661336f, -0.01238674f, -0.29272324f, 
    0.02648572f, -0.05903449f, -0.17980766f, 0.04564864f, -0.13852923f, -0.09311730f, -0.43728921f, 0.17737925f, 
    -0.65663725f, -0.81895137f, -0.88641948f, 0.33500791f, -0.00112249f, -0.90053707f, -0.47723159f, 0.40714154f, 
    0.39998627f, -0.35655648f, -0.83165061f, -0.36756766f, -0.08386548f, 0.12244428f, 0.06817318f, 0.21357317f, 
    -0.32161039f, 0.54315197f, -0.70411015f, 0.03840736f, 0.67051512f, 0.37888801f, 0.23906386f, -1.44097185f, 
    -0.71861279f, 0.82831830f, 1.30465615f, 0.48959661f, 0.52022213f, 0.54824907f, -0.71766663f, 0.79631829f, 
    -0.32428318f, -0.01585192f, -0.23404312f, -0.45347705f, 0.46277750f, -0.12201232f, 0.31294811f, 0.09800909f, 
    -0.07487914f, -0.07295712f, 0.36437973f, -0.25593677f, 0.22425106f, -0.36917430f, 0.11244174f, -0.37906185f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.45019990f, 0.18539359f, 0.13836327f, 0.00372951f, 0.49709317f, 0.37813279f, 0.50339222f, 0.62634879f, 
    -0.02947570f, 0.15427576f, 0.30635825f, 0.29287341f, 0.11613842f, 0.28511542f, 0.27557346f, 0.34453043f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.44941434f, -0.13416144f, -0.02709941f, 0.21215591f, -0.29732987f, -0.30721307f, -0.00154425f, -0.07658356f, 
    -0.19674723f, 0.09560361f, 0.00647427f, -0.07176795f, 0.14006570f, 0.22776943f, 0.11912965f, -0.49780631f, 
    -0.40320858f, 0.03223323f, -0.04663599f, 0.14085692f, 0.28874904f, -0.19154119f, -0.01779223f, -0.06497113f, 
    -0.35919946f, 0.04518346f, 0.19864519f, -0.17825776f, -0.11057638f, 0.17572156f, -0.05937304f, 0.20092806f, 
    -0.06523164f, -0.00966288f, 0.07800256f, -0.03817516f, -0.15214294f, 0.49581581f, -0.19887063f, 0.24092481f, 
    -0.14903358f, 0.24705887f, -0.17616978f, -0.18102886f, 0.00326204f, 0.05964412f, 0.32036641f, -0.18441236f, 
    0.41096458f, -0.29077843f, -0.25243506f, 0.56367093f, 0.05237060f, 0.09961627f, -0.26409009f, -0.09434765f, 
    -0.05098623f, -0.17742614f, -0.24181883f, -0.13612852f, -0.23077790f, 0.23598041f, 0.02726217f, 0.28734979f, 
    -0.12490912f, 0.13916209f, -0.08601356f, -0.01078364f, -0.16058628f, 0.07743401f, -0.10391773f, 0.07834144f, 
    -0.05276200f, -0.24913669f, -0.26303816f, 0.10021727f, 0.16500746f, 0.07862513f, 0.08067740f, -0.18776371f, 
    0.05214673f, 0.08972794f, 0.27810058f, -0.05038109f, -0.86137587f, 0.09887025f, 0.24159580f, -0.03989974f, 
    0.17641045f, -0.00362321f, -0.15266843f, -0.22648051f, -0.08374275f, 0.08893133f, 0.06537556f, -0.20980056f, 
    -0.32725427f, 0.00835499f, 0.33668920f, -0.47242048f, -0.01643109f, -0.02993853f, 0.02991564f, 0.00435295f, 
    -0.17308980f, -0.08984470f, 0.02894106f, 0.08219238f, 0.28386721f, -0.05551566f, 0.20663929f, 0.37539473f, 
    -0.05834346f, 0.00036298f, -0.00796049f, 0.07021502f, -0.17088602f, 0.17390472f, 0.03379766f, 0.02542903f, 
    0.12594071f, -0.57141954f, -0.07391610f, -0.91295373f, 0.06066220f, -0.17171218f, 0.18670996f, -0.06080360f, 
    -0.11696804f, 0.04724926f, 0.01485615f, -0.08133799f, -0.11019872f, -0.43772647f, 0.51627427f, -0.35018098f, 
    -0.23026519f, -0.15160351f, 0.18665180f, -0.22481473f, 0.01569893f, -0.05034772f, 0.10939202f, -0.09560224f, 
    0.71920955f, 0.34249443f, 0.18970947f, -0.52864808f, 0.04955429f, -0.01004238f, -0.04373449f, 0.13612558f, 
    -0.02320400f, -0.05426745f, -0.03494716f, 0.17306720f, -0.52755439f, 0.02470976f, -0.24663441f, -0.00500391f, 
    -0.00185670f, 0.14829022f, -0.02880117f, -0.16665199f, 0.08659025f, -0.08215281f, 0.02624991f, 0.00717680f, 
    0.27646729f, -0.29945984f, 0.09316771f, -0.28304881f, 0.00926599f, 0.23375663f, 0.22220899f, 0.10231851f, 
    -0.21832265f, 0.01622649f, 0.17870499f, -0.03259527f, -0.11839832f, -0.19497460f, 0.09974486f, 0.46747962f, 
    -0.11603575f, -0.15465719f, 0.18933374f, 0.00614142f, -0.07764733f, -0.21654744f, -0.11071265f, -0.01425923f, 
    0.43536031f, -0.03894113f, 0.20329362f, 0.56167537f, -0.32524937f, 0.13223171f, 0.11637355f, 0.15206476f, 
    -0.07066912f, -0.14295618f, -0.07735530f, -0.07833962f, 0.25171632f, 0.03755850f, 0.14400490f, 0.23063429f, 
    -0.14780836f, -0.18382108f, 0.11918002f, -0.00130108f, -0.02807410f, 0.15187508f, 0.01994220f, 0.05302481f, 
    0.73344594f, -0.45427203f, -0.08039910f, -0.55114549f, -0.16352415f, -0.23660009f, 0.05524267f, 0.00427305f, 
    -0.12475178f, 0.05127766f, -0.17479770f, 0.08556511f, -0.45983762f, -0.01511335f, 0.00119535f, 0.19771108f, 
    0.19300835f, -0.03766850f, -0.15754168f, -0.11474697f, -0.09309206f, -0.13522145f, -0.12015328f, -0.11679669f, 
    -0.47477332f, 0.15652946f, -0.15941368f, 0.01964105f, -0.10314187f, -0.02227702f, -0.00879618f, 0.05440789f, 
    0.04021517f, 0.06778026f, -0.04549078f, 0.23534805f, 0.47178754f, -0.09389991f, 0.17025095f, 0.17743030f, 
    0.03197879f, 0.08436161f, -0.17964642f, -0.05079207f, 0.18721204f, 0.30264881f, -0.15196809f, 0.13758090f, 
    0.32609376f, -0.02212516f, 0.32997823f, 0.31267318f, -0.19553708f, -0.13767511f, -0.16350044f, -0.18923110f, 
    0.05809270f, 0.09768444f, -0.30259600f, 0.25166243f, -0.21378471f, 0.11280968f, 0.05294486f, 0.12805858f, 
    -0.05823711f, -0.16077258f, -0.02029796f, -0.23580001f, 0.07169404f, 0.19008625f, -0.28377873f, -0.05943452f, 
    0.03508324f, 0.28093722f, -0.23997089f, -0.30254671f, 0.05946929f, 0.19559304f, -0.22538768f, 0.17432493f, 
    0.28416088f, 0.14480807f, 0.07270973f, 0.11405108f, 0.29996446f, -0.31641218f, 0.12084069f, 0.20554237f, 
    -0.25425294f, 0.05064394f, -0.15731873f, 0.03002893f, -0.04430081f, -0.02543348f, -0.14926969f, -0.14227812f, 
    0.41441223f, -0.38183919f, 0.28376156f, -0.51639682f, 0.06242662f, -0.10445153f, 0.07867897f, 0.11167946f, 
    -0.16294917f, 0.05238764f, 0.30159977f, 0.00682763f, 0.05546349f, -0.16431774f, 0.05464438f, -0.48476905f, 
    0.00251118f, 0.03256975f, 0.12193561f, 0.01004465f, 0.15858442f, -0.00258665f, -0.10774090f, -0.10127040f, 
    -0.40401205f, -0.28905782f, -0.37826228f, -0.12248056f, 0.13108587f, -0.00518205f, -0.08796676f, -0.14260833f, 
    0.14501750f, 0.13732183f, -0.13412626f, -0.06643353f, 0.48289880f, -0.38559684f, -0.16450831f, 0.27526665f, 
    -0.22541216f, 0.02256390f, 0.06109734f, 0.27255109f, -0.16828783f, -0.03409902f, 0.17522711f, 0.09274426f, 
    -0.27424484f, -0.13583489f, -0.32636184f, -0.33897611f, -0.20486599f, -0.09382256f, 0.09611103f, -0.38831052f, 
    0.04250782f, -0.07870155f, 0.06399994f, 0.04628643f, -0.03598478f, 0.19513325f, -0.56212509f, -0.11407872f, 
    -0.04071544f, 0.04713646f, -0.03059563f, -0.25832552f, -0.07066164f, 0.02061947f, 0.09141813f, 0.01322635f, 
    -0.41503292f, 0.41938797f, 0.01662512f, -0.10298780f, 0.23097055f, -0.10887291f, 0.07452454f, 0.03859206f, 
    0.00587781f, 0.14577577f, 0.17228508f, 0.16859862f, -0.19735925f, 0.42752141f, -0.14129436f, 0.18468627f, 
    0.22409268f, 0.10375217f, 0.02705790f, -0.36542773f, -0.08087284f, -0.08743452f, 0.00142650f, 0.01636569f, 
    0.15863721f, -0.18550342f, 0.17478226f, -0.69960845f, 0.14054114f, -0.15546997f, 0.27606407f, -0.10665578f, 
    -0.14738573f, 0.02481931f, 0.13987066f, -0.17434636f, 0.17918085f, -0.04775943f, -0.23382317f, -0.15704496f, 
    -0.19061445f, 0.18149464f, -0.29881543f, 0.08109447f, -0.04963444f, 0.04295788f, 0.16432858f, -0.24455434f, 
    -0.37996599f, 0.48274410f, -0.78103721f, -0.24645169f, -0.08884591f, -0.01748474f, 0.02891592f, 0.05166691f, 
    -0.01455226f, 0.01394079f, -0.01074226f, -0.04220723f, 0.03526034f, -0.06134834f, 0.10485664f, 0.07466705f, 
    0.07516994f, -0.04895817f, 0.11910167f, 0.12149128f, 0.11660960f, -0.20098616f, 0.03016243f, 0.08896613f, 
    -0.07422055f, 0.15967424f, 0.01282437f, 0.16838065f, -0.15338631f, -0.04849098f, -0.05037101f, -0.15242949f, 
    -0.00059373f, -0.20894316f, 0.04797794f, -0.04477722f, -0.00094524f, -0.19920690f, -0.01724237f, -0.65784651f, 
    -0.10916346f, -0.08300239f, -0.25836238f, 0.00561726f, 0.08478721f, -0.27872053f, -0.06891826f, 0.11469458f, 
    0.37011474f, -0.44043401f, -0.22582562f, -0.05468017f, 0.16644695f, 0.00642716f, -0.04876893f, -0.13499291f, 
    -0.09814144f, -0.03793232f, 0.03003028f, 0.07299563f, 0.15584318f, -0.69840491f, 0.24863896f, -0.01111297f, 
    0.32181615f, 0.09716856f, -0.05504736f, -0.08601332f, 0.04411925f, 0.20108613f, -0.10364140f, 0.06088665f, 
    -0.82919019f, 0.02269093f, 0.10350355f, 0.33159325f, 0.07961176f, -0.24473763f, 0.11149363f, 0.03693712f, 
    -0.14805128f, -0.18110958f, -0.04542015f, -0.05271956f, -0.30779165f, -0.06174496f, 0.20214112f, -0.42446533f, 
    0.15016586f, 0.06067917f, -0.00118468f, -0.15332799f, -0.09812021f, 0.08675402f, 0.04465306f, -0.37126711f, 
    0.90728575f, 0.13558801f, 0.40396619f, 0.46186554f, -0.14038861f, -0.27223203f, -0.03410028f, 0.03268693f, 
    0.06329251f, 0.03202303f, 0.08245528f, -0.01746307f, 0.68403882f, 0.01697415f, 0.21534494f, -0.09821802f, 
    -0.55939454f, 0.13109529f, -0.14710841f, -0.08504208f, 0.09661742f, 0.02251219f, 0.20110580f, -0.11884756f, 
    -0.08931203f, -0.16936353f, 0.33921871f, -0.50126356f, 0.01175473f, -0.13294050f, -0.37554011f, 0.10755502f, 
    -0.09936462f, -0.24045095f, -0.03955413f, -0.16175047f, 0.99922985f, -0.69312251f, -0.29489002f, 0.15139647f, 
    -0.16313198f, 0.06417563f, 0.04415650f, -0.19407555f, 0.01041739f, 0.10336408f, -0.27158105f, -0.00219565f, 
    -0.96756232f, -1.16810942f, -0.18670413f, -0.14651480f, -0.24262978f, 0.00393199f, 0.01789970f, 0.08105699f, 
    0.00946241f, 0.17123997f, 0.08389952f, 0.02260800f, -0.24731329f, -0.76540238f, 0.18954052f, 0.31933984f, 
    0.04938807f, 0.04715418f, 0.04822751f, 0.03198124f, -0.04508053f, -0.25271779f, -0.03595416f, -0.31729245f, 
    0.33937848f, -0.41571996f, -0.24069311f, 0.16710298f, 0.07490184f, 0.21392314f, 0.05331825f, 0.25587621f, 
    0.02180781f, 0.06989598f, 0.02690468f, -0.17190303f, 0.13305356f, -0.18887214f, -0.00848575f, 0.01685104f, 
    -0.08579537f, -0.02677364f, 0.17897978f, 0.19005746f, -0.05059440f, 0.02133812f, 0.13213269f, 0.19580859f, 
    0.72470194f, -0.26279834f, 0.35573071f, 0.20507462f, 0.06003283f, 0.11242802f, -0.23185246f, -0.05576869f, 
    0.00033361f, 0.07516806f, 0.13062786f, 0.06194710f, -0.25949118f, 0.01452075f, -0.27356446f, -0.40331021f, 
    -0.04931415f, 0.02112463f, 0.13288623f, -0.39926571f, 0.07141121f, 0.12625235f, 0.03518867f, -0.06102468f, 
    -1.25986326f, -0.26491129f, -0.19739017f, -0.12741299f, -0.20712470f, -0.19864878f, 0.15369119f, -0.21307819f, 
    -0.07652967f, -0.10244925f, 0.01610308f, -0.16920871f, 0.38557222f, 0.09044929f, 0.06687129f, 0.20185894f, 
    -0.00665290f, 0.12426957f, 0.02613598f, 0.23359969f, -0.19333850f, -0.14085655f, -0.02872441f, 0.03555223f, 
    -0.65371436f, 0.09321715f, 0.14601582f, -0.00025635f, -0.16385718f, -0.01091505f, -0.06972919f, 0.28562948f, 
    0.08722830f, 0.02003073f, -0.08080105f, 0.11634018f, 0.78807020f, -0.51221603f, -0.12150479f, 0.30489478f, 
    -0.02347470f, -0.01884689f, -0.07124124f, -0.01118195f, 0.02339876f, -0.34922582f, 0.12467064f, 0.13164346f, 
    -0.12692283f, -0.22486451f, -0.08891343f, -0.05683624f, -0.07210968f, 0.02420273f, -0.03009813f, 0.03443122f, 
    0.12877783f, 0.23539290f, -0.26732388f, 0.13882338f, 0.39751658f, -0.15991372f, -0.04994490f, 0.56211376f, 
    0.20982321f, 0.15946010f, -0.12367015f, -0.05456233f, 0.07587630f, -0.06086787f, -0.32838449f, -0.04417302f, 
    -0.36269897f, 0.27528107f, 0.01846025f, -0.26411808f, -0.01378312f, -0.11747243f, 0.18815644f, -0.04044159f, 
    -0.07557041f, -0.18732585f, -0.03728933f, -0.14297041f, 0.33668447f, -0.21677664f, -0.03395699f, 0.05070143f, 
    -0.24348554f, -0.02644870f, -0.07457465f, -0.20024450f, -0.05994315f, -0.08474049f, 0.08891955f, 0.01610249f, 
    0.10648181f, 0.08536717f, -0.13040227f, -0.33776414f, -0.13928702f, 0.18561719f, -0.09195411f, 0.09514676f, 
    0.11310601f, -0.16524231f, 0.09527956f, 0.01197825f, -0.17526636f, -0.17154494f, 0.21804622f, 0.39461604f, 
    0.18532197f, -0.03220220f, 0.00380948f, 0.12405036f, 0.11899210f, 0.04205136f, 0.28586251f, -0.08356123f, 
    0.14626215f, 0.10282930f, 0.16418317f, 0.12207232f, 0.04815332f, 0.02860581f, -0.02798709f, 0.05017192f, 
    0.14905412f, 0.14262788f, -0.09106460f, -0.06170769f, -0.48935157f, 0.00977966f, -0.03545357f, -0.12420914f, 
    0.12996078f, 0.09494583f, -0.23922904f, -0.14823195f, 0.00829053f, -0.20569378f, -0.03218035f, -0.25478265f, 
    -0.39053091f, -0.38326743f, -0.08255796f, -0.00113085f, -0.31457889f, 0.14075270f, 0.04387101f, -0.18190803f, 
    0.01937276f, -0.09975291f, -0.04253496f, -0.02394557f, -0.04376966f, -0.29706186f, -0.18518151f, 0.00554385f, 
    0.17407960f, 0.01305048f, 0.01861314f, 0.06214970f, -0.03710571f, 0.05451594f, -0.34364340f, 0.25423619f, 
    -0.17519793f, -0.27091709f, 0.28220102f, 0.43211836f, -0.34329703f, 0.13272130f, -0.15264116f, -0.32801527f, 
    0.04586362f, -0.01333624f, -0.09435165f, -0.05433225f, 0.13817690f, -0.28288379f, -0.25139591f, 0.23460585f, 
    0.00823132f, 0.05347241f, 0.19557276f, 0.02592274f, -0.05731525f, 0.01926623f, 0.12166047f, 0.02918268f, 
    -0.21778092f, -0.17474340f, -0.15260740f, -0.16012470f, -0.15521291f, -0.35926604f, -0.00637038f, 0.08265065f, 
    0.18113415f, -0.07566664f, -0.01801945f, -0.51533985f, 0.09518286f, 0.04734262f, -0.14879781f, -0.61003679f, 
    0.03264351f, 0.08801000f, 0.17361496f, 0.20401073f, 0.02175510f, 0.04035334f, -0.03123076f, 0.24875195f, 
    0.25232610f, 0.35157096f, -0.07982209f, 0.09423944f, -0.32087654f, -0.15069698f, 0.31261727f, -0.06641413f, 
    -0.06144005f, -0.11049259f, -0.04438103f, -0.10995165f, 0.39269397f, 0.37006280f, -0.11352587f, -0.05408621f, 
    -0.07709587f, 0.13591598f, 0.18063638f, 0.12530622f, -0.10835060f, -0.05513947f, 0.12254232f, 0.18179430f, 
    0.22843423f, -0.20324902f, 0.01890368f, 0.39709139f, -0.25636041f, 0.08451170f, 0.24843499f, -0.07731785f, 
    -0.10599810f, 0.26035088f, -0.09514940f, 0.01122402f, -0.50231618f, -0.02031391f, 0.22653960f, 0.26025280f, 
    -0.33782679f, 0.01007536f, -0.13628772f, 0.00610097f, -0.13434777f, -0.07828035f, -0.05062386f, 0.10783355f, 
    -0.61771250f, -0.29891637f, 0.12463672f, 0.15429533f, 0.10918183f, -0.11469753f, 0.25878274f, 0.17648493f, 
    -0.00238669f, 0.11034508f, 0.00282067f, 0.06939765f, -1.16802204f, 0.57949930f, 0.00969352f, 0.18044825f, 
    0.02857532f, 0.09151875f, -0.08566832f, 0.19881973f, -0.04407969f, -0.10178012f, -0.13891980f, 0.03196957f, 
    0.02710776f, 0.30275264f, 0.31854111f, 0.24430886f, 0.15312485f, 0.11903974f, 0.21359283f, 0.09055602f, 
    -0.10490751f, 0.05759571f, 0.06261747f, 0.16428590f, -0.33044270f, 0.49867010f, -0.17923270f, -0.48696560f, 
    0.01356676f, 0.23539494f, 0.01221075f, 0.16590987f, 0.16729718f, -0.09406713f, -0.11733326f, 0.02881671f, 
    0.02018363f, -0.13068829f, 0.10781978f, 0.00470323f, -0.00735280f, -0.17582837f, -0.08709572f, 0.03863323f, 
    0.17532168f, -0.12517482f, -0.06833551f, -0.28411832f, 0.15741843f, -0.03294702f, 0.30237037f, 0.31071800f, 
    -0.27245742f, 0.25237855f, 0.14684333f, -0.01143500f, -0.35001171f, 0.01707328f, 0.06176443f, 0.45283690f, 
    0.05426770f, 0.29987130f, -0.29122752f, 0.02840640f, -0.17896673f, -0.12302205f, 0.01276868f, -0.04452240f, 
    -0.10381115f, -0.19819030f, 0.02532510f, -0.08630549f, 0.03577878f, 0.42687121f, 0.05290842f, -0.05128479f, 
    -0.05631285f, -0.10642275f, 0.31963548f, -0.12936650f, 0.14990093f, -0.13097905f, -0.14364481f, -0.26082948f, 
    0.14941972f, -0.22639835f, -0.07427946f, -0.06230165f, -0.04154215f, -0.30619597f, -0.00758378f, 0.15960512f, 
    0.01560893f, -0.03683409f, 0.19607531f, 0.05680653f, 0.14014481f, 0.32489324f, 0.41353366f, -0.62781066f, 
    -0.11422253f, -0.30150136f, -0.04743972f, -0.11286238f, -0.06452629f, -0.26399943f, -0.02732065f, -0.41519612f, 
    -0.16421144f, 0.17829917f, -0.05767838f, -0.02702750f, 0.13386352f, 0.24825729f, -0.05442024f, 0.08646105f, 
    0.14219998f, 0.05989018f, -0.00920938f, 0.19748373f, -0.59350318f, 0.06134145f, 0.14798056f, 0.12496132f, 
    -0.04466066f, -0.04843559f, 0.00317954f, 0.10680264f, 0.20467599f, 0.23437749f, 0.17296799f, -0.00908932f, 
    0.16316673f, -0.24544577f, 0.56241763f, 0.07214160f, 0.00060700f, -0.02056558f, 0.10207535f, -0.18039580f, 
    0.09463870f, 0.05720190f, 0.14907522f, 0.10662622f, -0.07685222f, -0.15309964f, -0.08476769f, -0.33229816f, 
    0.08217987f, -0.02154988f, 0.17018509f, -0.08769178f, -0.01115738f, -0.09431421f, 0.06018413f, 0.08235253f, 
    -0.17493083f, -0.19076967f, -0.07827183f, -0.16606256f, 0.12463045f, -0.05722372f, -0.29541901f, -0.15995014f, 
    0.04199027f, -0.10864718f, 0.07074080f, 0.11273803f, 0.05767304f, -0.04432630f, 0.03324811f, 0.12856477f, 
    -0.10087141f, -0.00337065f, -0.01783168f, 0.04209546f, 0.02198799f, 0.04575744f, 0.15451811f, 0.17976937f, 
    -0.30989313f, 0.27126342f, -0.60264361f, -0.25914106f, 0.12581916f, 0.20964831f, -0.05467352f, -0.20631656f, 
    0.00358469f, -0.16588818f, 0.05500779f, -0.32356170f, -1.28630483f, 0.03436346f, -0.43180338f, 0.00411001f, 
    0.19887398f, -0.19564253f, -0.02458088f, -0.08794229f, -0.00183793f, 0.15289885f, 0.03849799f, 0.03541540f, 
    -0.10850421f, -0.13383099f, -0.06384675f, 0.30460539f, 0.23205297f, -0.15241496f, 0.09987314f, 0.14696527f, 
    0.05772405f, 0.04074192f, -0.16157755f, -0.15430143f, -0.36951756f, 0.06965613f, 0.32864416f, -0.10636748f, 
    0.04149934f, -0.05640437f, 0.14219984f, -0.10008306f, 0.04022416f, 0.14367650f, 0.05338725f, -0.11084381f, 
    -0.32507700f, 0.57721555f, 0.14947502f, -0.42015091f, -0.11626521f, -0.02253932f, -0.08414698f, 0.04819253f, 
    -0.22736734f, 0.19539081f, 0.37301990f, 0.32700700f, 0.13181862f, 0.28574678f, 0.21031192f, -0.42085245f, 
    -0.04060229f, -0.02314584f, -0.15798417f, 0.06666744f, 0.08264524f, -0.02828062f, -0.44616580f, -0.18402810f, 
    -0.18554376f, 0.20046563f, 0.13502328f, 0.69102556f, 0.17038818f, 0.12660065f, -0.14301361f, 0.28331399f, 
    0.12477596f, 0.00437929f, 0.00028684f, 0.02488081f, 0.27992976f, -0.45334712f, -0.03762735f, -0.16633300f, 
    -0.02865124f, -0.16083482f, -0.25145623f, -0.04084896f, 0.10752583f, 0.08339287f, 0.22729960f, 0.18856734f, 
    -0.11159457f, 0.29988217f, 0.05233850f, -0.53545916f, 0.27948320f, 0.11517323f, 0.19839053f, 0.08541735f, 
    -0.09352955f, -0.07731628f, -0.03711200f, -0.07510819f, -0.26460019f, -0.27397645f, 0.23097989f, -0.13875890f, 
    -0.18255229f, 0.07409704f, -0.05164572f, 0.25750539f, -0.02191507f, -0.07869851f, -0.02325012f, 0.36976686f, 
    0.19647759f, 0.27375621f, 0.17097469f, 0.07432055f, 0.04630001f, -0.04703154f, 0.10271277f, 0.01073914f, 
    -0.23077150f, -0.04340853f, 0.14007641f, -0.39398471f, 0.36853683f, -0.17704460f, -0.19926125f, -0.31653705f, 
    -0.10011936f, 0.14403707f, -0.08386391f, 0.00572260f, -0.04839200f, 0.07948599f, 0.09596006f, -0.06893823f, 
    -0.59437060f, 0.05242618f, 0.08667220f, 0.11344212f, 0.10559165f, -0.02658242f, 0.13156198f, -0.17858180f, 
    -0.09101187f, -0.24031036f, -0.13039903f, -0.26153925f, -0.31431100f, 0.24298078f, 0.11629784f, -0.38244742f, 
    -0.13116267f, -0.06247228f, -0.05702875f, 0.09527264f, 0.12938924f, 0.13827586f, 0.00538404f, -0.16504523f, 
    -0.54895723f, -0.23691495f, -0.44310534f, 0.21435447f, 0.07261468f, 0.24820705f, 0.15981200f, -0.18802419f, 
    0.20809194f, -0.27309439f, 0.05499629f, -0.16085802f, 0.06206619f, 0.05113286f, -0.27621198f, -0.28986624f, 
    -0.16547121f, 0.05097171f, 0.08512414f, -0.06512956f, -0.01531738f, -0.19534272f, -0.01369701f, 0.07063536f, 
    0.12843640f, -0.64828044f, -0.25694770f, 0.12704714f, -0.06662107f, 0.07884666f, -0.05142789f, -0.06433301f, 
    -0.16638653f, 0.13971254f, 0.06317030f, 0.33285651f, 0.17318872f, -0.32391223f, 0.19383711f, -0.25213027f, 
    -0.13439044f, 0.00543067f, 0.27869931f, -0.18089215f, 0.11397125f, -0.05492663f, 0.21667397f, 0.04001455f, 
    0.24456657f, 0.00660177f, -0.47474772f, -0.06715100f, -0.40642640f, -0.07017141f, -0.03752890f, 0.14138693f, 
    -0.00034702f, 0.05535412f, 0.05843073f, 0.00379337f, 0.80671823f, -0.48090911f, 0.03081430f, -0.23750322f, 
    -0.02513772f, 0.28393483f, -0.02407095f, 0.07736818f, -0.03126822f, -0.02914460f, 0.10108291f, -0.23455532f, 
    -0.33932757f, -0.18286347f, -0.60197258f, -0.40667024f, -0.06635154f, 0.12983844f, -0.03438739f, -0.18020172f, 
    -0.09154870f, -0.15680884f, 0.07533152f, -0.03015707f, -0.68019205f, -0.37123746f, -0.22497550f, 0.14205846f, 
    0.06452703f, -0.03276648f, 0.09963390f, -0.03504226f, -0.08969273f, -0.06372653f, 0.01776815f, -0.19685915f, 
    -0.78747737f, 0.30374482f, -0.18178238f, 0.34615329f, -0.27100170f, -0.07028208f, -0.03718549f, 0.14630017f, 
    -0.15593357f, -0.01117713f, 0.06459673f, 0.15978311f, 0.43613845f, 0.08529077f, 0.21823238f, -0.15032643f, 
    0.12253822f, 0.02348616f, 0.09553917f, 0.02195393f, -0.12622356f, 0.14259790f, 0.19523266f, -0.06628150f, 
    0.43676659f, 0.23559272f, -0.24003726f, 0.22023445f, -0.24001054f, -0.06004898f, -0.00854841f, -0.05000177f, 
    -0.24630429f, -0.11208433f, -0.07466758f, -0.31574664f, -0.42323431f, -0.05241045f, -0.20379876f, -0.25074530f, 
    -0.26441681f, -0.03610001f, -0.26202270f, -0.17422581f, -0.15356459f, -0.13263972f, -0.12815428f, -0.18813035f, 
    0.04259998f, 0.14364617f, -0.05973421f, -0.18984434f, -0.08036711f, 0.14240380f, -0.07181903f, -0.08051527f, 
    -0.04721067f, 0.03084463f, -0.11343857f, -0.16691761f, 0.18415886f, 0.24048385f, 0.05982081f, 0.25798517f, 
    0.15662213f, 0.09324390f, -0.01217883f, -0.02030605f, -0.05713086f, -0.23989902f, -0.17189172f, -0.05701807f, 
    0.38742524f, -0.07114874f, 0.25225264f, 0.22240245f, -0.04846001f, -0.03557432f, -0.03510438f, -0.19864120f, 
    0.05397504f, -0.15238076f, -0.17188929f, 0.07813986f, -0.71107072f, 0.65399408f, -0.11594777f, -0.38449198f, 
    -0.04802284f, 0.04244573f, 0.04256196f, -0.05598669f, -0.23745458f, 0.16812083f, 0.12530375f, -0.01407652f, 
    0.12919554f, 0.46016562f, 0.01483057f, 0.41084030f, 0.37013298f, -0.06777947f, -0.15336609f, -0.03596412f, 
    0.03408742f, 0.14965208f, -0.14603016f, -0.19200437f, -0.17275371f, 0.09213887f, -0.35563502f, 0.29199770f, 
    -0.17999782f, -0.23302288f, -0.24364384f, -0.07531547f, -0.12612708f, 0.02157257f, -0.02351176f, -0.16741832f, 
    -0.08000293f, 0.42691994f, 0.33815151f, 0.31382585f, 0.21086997f, 0.00026354f, 0.13830604f, -0.03035125f, 
    0.09322730f, 0.05226727f, 0.18733457f, -0.00474395f, 0.41188768f, 0.19881028f, 0.31888732f, 0.06093417f, 
    -0.11640543f, 0.12558778f, 0.00044342f, 0.06190296f, 0.10318262f, 0.11095627f, -0.31886214f, -0.06408409f, 
    0.00004707f, 0.50243706f, 0.13636683f, 0.65494651f, 0.32757041f, -0.00261386f, -0.04272319f, -0.05407165f, 
    -0.15294641f, 0.03381846f, 0.03488581f, -0.18873121f, -0.86549634f, -0.15871508f, 0.14488149f, -0.56639910f, 
    0.17139275f, 0.12018763f, -0.00599098f, -0.27262235f, -0.05113567f, -0.09019075f, 0.14342178f, -0.15106548f, 
    0.21895751f, -0.18584839f, -0.03494162f, 0.15191823f, 0.21660681f, 0.00239223f, 0.01715169f, 0.06108916f, 
    -0.03572770f, -0.07268776f, -0.32439071f, -0.10681401f, 0.05413201f, -0.12244190f, -0.08928918f, 0.27887747f, 
    0.18855366f, 0.13113473f, -0.01018581f, 0.02429001f, 0.08936401f, 0.29608890f, 0.07397322f, 0.00580691f, 
    0.28217754f, 0.50816363f, -0.80115747f, -0.13440980f, 0.12948781f, -0.12502953f, -0.22412020f, -0.17177062f, 
    0.13262121f, 0.05230694f, -0.08021787f, -0.07527491f, 0.08293077f, -0.31578374f, 0.18281151f, -0.27197784f, 
    -0.09976213f, -0.31178895f, 0.20969297f, -0.32480758f, 0.02253759f, 0.02850845f, -0.33945003f, -0.29896796f, 
    -0.41389206f, -0.43422973f, -0.05048872f, -0.49693593f, -0.04260501f, -0.06347264f, 0.01311432f, 0.26579997f, 
    0.28304455f, 0.19722612f, 0.00819141f, 0.04419129f, 0.57722640f, 0.11829148f, -0.08617900f, 0.24775672f, 
    -0.02570216f, -0.10600372f, 0.05780515f, -0.02148801f, -0.13349622f, -0.21381916f, 0.08517004f, -0.35109189f, 
    0.18290791f, -0.16924737f, 0.11597396f, 0.20445961f, -0.00513283f, 0.08125067f, -0.01482496f, -0.06446902f, 
    0.01226553f, 0.11549727f, -0.00443578f, 0.10158697f, -0.17154446f, -0.25407544f, -0.13138385f, -0.56785369f, 
    -0.12017268f, -0.38517621f, 0.16151074f, 0.04093752f, -0.02694049f, 0.11943356f, -0.08840336f, -0.07167299f, 
    0.27375099f, 0.42750746f, -0.12557609f, 0.15963891f, 0.13866220f, -0.03454560f, -0.11696171f, -0.21073700f, 
    0.04819685f, 0.16176577f, 0.18659104f, -0.11022901f, 0.00206237f, -0.46850130f, 0.13023838f, 0.54148889f, 
    0.08922830f, 0.03382656f, -0.15338023f, -0.10481142f, 0.05681927f, -0.16186239f, 0.15885442f, -0.32232776f, 
    -0.41565698f, 0.74957263f, 0.06000492f, 0.02933306f, 0.04662350f, 0.07591497f, -0.46470687f, 0.04575389f, 
    0.23575272f, -0.11600351f, 0.08164249f, -0.09722532f, -0.46277651f, 0.06152513f, -0.22364855f, -0.07068785f, 
    -0.01379001f, 0.05888700f, 0.03806004f, -0.09014955f, 0.23144618f, 0.18620718f, -0.13352035f, 0.10062799f, 
    0.19913295f, -0.06295126f, 0.18426023f, 0.04901508f, -0.24326947f, -0.03697325f, -0.30203885f, 0.13338743f, 
    -0.06279697f, -0.28039929f, -0.24571525f, -0.01545783f, -0.33385316f, -0.07411097f, 0.35255682f, -0.16931766f, 
    0.08422790f, -0.30329943f, 0.15349261f, 0.16752586f, 0.07086345f, 0.02215838f, -0.00551658f, -0.13325934f, 
    -0.19403997f, 0.30962580f, -0.38436627f, -0.17737794f, 0.15448970f, -0.05899209f, 0.12977563f, -0.11772494f, 
    -0.17499231f, -0.09329058f, -0.18401268f, 0.20777628f, -0.31533182f, -0.91485840f, 0.05738390f, 0.13001637f, 
    -0.06145337f, -0.17757869f, -0.20415661f, -0.13716318f, -0.04152814f, -0.01550814f, -0.04923235f, 0.26904374f, 
    -0.22386359f, 0.26050556f, -0.10314717f, -0.30033153f, 0.00532486f, -0.04939727f, 0.04264124f, -0.24656695f, 
    -0.16162208f, 0.00902753f, -0.09977836f, 0.17333885f, -0.03153357f, -0.04600173f, -0.39642292f, -0.41376644f, 
    -0.04705837f, -0.24147558f, 0.22369121f, 0.09993652f, -0.03541399f, -0.12035742f, 0.10711195f, 0.01801186f, 
    -0.17766552f, 0.36246243f, 0.64297640f, -0.16564967f, 0.05591574f, 0.15812217f, 0.05101391f, -0.13929731f, 
    -0.05087894f, 0.10236695f, 0.21565616f, 0.04383310f, 0.22351329f, 0.16492005f, -0.03945107f, 0.37779427f, 
    0.07165755f, 0.04143546f, 0.19529343f, 0.03613253f, -0.07096408f, -0.18731235f, 0.23212865f, 0.34554395f, 
    -0.01324969f, -0.22705474f, -0.03323445f, -0.22907877f, 0.03282263f, -0.16673079f, -0.09319013f, -0.19273387f, 
    -0.08248497f, -0.06878792f, -0.08657403f, -0.18023741f, -0.33488324f, 0.38168481f, -0.14656129f, -0.10233035f, 
    0.26904798f, 0.26434112f, -0.09362108f, 0.01801936f, 0.03598166f, 0.02057066f, 0.16672638f, 0.04561233f, 
    0.32910278f, 0.32628432f, -0.00825621f, -0.38105494f, 0.00940133f, 0.13721964f, 0.22551708f, -0.11956406f, 
    -0.03620873f, -0.35552189f, 0.12917210f, -0.16633888f, 0.12075791f, -0.15665999f, -0.29718134f, 0.22167723f, 
    0.27334678f, 0.01659125f, -0.09854620f, 0.07735351f, -0.09329187f, -0.45159355f, 0.05603098f, -0.04771212f, 
    0.82247967f, -0.96215576f, -0.26698130f, 0.08859626f, -0.07011849f, -0.05506697f, 0.01576982f, 0.09059447f, 
    -0.17742117f, -0.06392480f, 0.11386388f, -0.26142600f, -1.00677848f, 0.84868336f, -0.31841034f, -0.25252879f, 
    0.25861165f, 0.02387300f, -0.08596731f, 0.00374467f, -0.18553445f, 0.01952389f, -0.14697821f, 0.11735608f, 
    -0.28853855f, -0.06217774f, 0.19425261f, 0.22209558f, -0.17982787f, 0.29216754f, -0.06282403f, 0.51757956f, 
    -0.01305183f, -0.02745969f, -0.15071860f, 0.11761406f, -0.23287150f, 0.54218787f, -0.35465145f, -0.36715636f, 
    0.08323731f, -0.00946744f, 0.02267756f, 0.00625222f, -0.09968963f, 0.15920867f, 0.06469196f, -0.15507628f, 
    -0.39827365f, -0.31703103f, 0.37824222f, -0.00357730f, 0.09523401f, 0.02549838f, -0.03498414f, 0.05288846f, 
    0.27262706f, 0.07037445f, 0.10069136f, 0.26382402f, 0.34488666f, -0.03577435f, 0.00744401f, -0.03322843f, 
    0.17659603f, 0.14889885f, -0.08981974f, 0.03551889f, -0.10458679f, 0.05216355f, -0.17927392f, -0.20199338f, 
    -0.24065921f, -0.49007750f, 0.25611171f, -0.16986081f, 0.18503317f, -0.00428531f, -0.36818326f, 0.14532280f, 
    0.05516049f, -0.31765762f, 0.05550356f, 0.00732849f, 0.06805582f, 0.24758963f, -0.03575956f, 0.21291374f, 
    -0.18206657f, -0.16635497f, 0.03326223f, 0.10766210f, 0.08459131f, -0.00277712f, -0.14070658f, 0.05940568f, 
    -0.92742163f, -0.54228228f, -0.13127613f, -0.23591967f, 0.13170221f, 0.18716511f, 0.10173906f, -0.16760080f, 
    -0.06384277f, 0.00945327f, -0.12019543f, 0.18415523f, -0.54567915f, 0.03952243f, -0.00974532f, -0.54339498f, 
    -0.16730694f, -0.11507183f, -0.16850162f, 0.15459430f, 0.27744463f, 0.25178200f, 0.03781374f, 0.04334224f, 
    -1.32203496f, -0.96504724f, 0.25862524f, 0.09135735f, 0.28931487f, 0.08010077f, 0.06677703f, -0.08348551f, 
    0.23922765f, -0.06144418f, -0.24402456f, 0.10861896f, 0.09708833f, -0.20770994f, 0.09888312f, -0.06872021f, 
    -0.03693246f, -0.10161666f, -0.12547296f, -0.03747219f, 0.15011086f, -0.07939346f, -0.23448074f, -0.16719142f, 
    -0.18491386f, 0.40268236f, 0.13148440f, -0.14208458f, 0.16174993f, 0.07345134f, 0.36785781f, 0.08394829f, 
    -0.02656749f, 0.14685357f, 0.03930151f, 0.21805497f, 0.10785047f, 0.02632431f, -0.51234549f, -0.05072251f, 
    0.04142697f, -0.18197894f, 0.08881751f, 0.01448414f, 0.00885801f, -0.02448606f, -0.28701937f, -0.17827278f, 
    -0.59035414f, -0.11341345f, -0.00888796f, -0.21152100f, 0.12351648f, 0.01152628f, -0.05564877f, 0.24664895f, 
    -0.04993145f, 0.22782721f, 0.12399119f, 0.45219672f, 0.21748720f, 0.18822294f, -0.30437374f, 0.18706502f, 
    0.01176224f, -0.04317943f, 0.20958081f, -0.12909943f, 0.04919531f, 0.19390614f, 0.09321690f, 0.01960176f, 
    -1.03819823f, 0.41508552f, -0.25249058f, -0.04011927f, 0.05526087f, 0.21495642f, -0.15088175f, -0.10096175f, 
    0.14762497f, 0.43180645f, 0.01773270f, 0.13749053f, -0.99499881f, -0.54538274f, -0.18487701f, -0.22372587f, 
    -0.08301919f, -0.28607476f, 0.05913413f, -0.10603389f, 0.09681914f, -0.14527640f, 0.10928091f, -0.06352147f, 
    0.02642802f, -0.13594024f, 0.13668679f, -0.13785042f, -0.06226359f, 0.12972635f, -0.09334508f, -0.11747496f, 
    0.11352906f, -0.16712654f, 0.17596231f, -0.02533077f, 0.68777269f, -0.07469875f, 0.15716022f, -0.23901185f, 
    0.30228925f, 0.10680772f, 0.19458012f, 0.06512329f, -0.04652772f, 0.00120127f, 0.22014253f, 0.03770742f, 
    0.43163612f, 0.25351489f, -0.11510987f, 0.02839285f, -0.37862694f, -0.13849637f, 0.03141814f, 0.01957711f, 
    -0.05409211f, 0.02373273f, 0.14526184f, -0.20880970f, 0.63879108f, -0.18459131f, 0.04383891f, -0.06154230f, 
    -0.07780339f, -0.06903605f, 0.07916152f, 0.05688260f, 0.11373764f, -0.00042655f, 0.01097474f, 0.07758585f, 
    -0.10521192f, 0.04858122f, 0.04470945f, 0.03264374f, 0.34783074f, 0.05824934f, 0.03875095f, -0.37593111f, 
    0.27416804f, 0.24121045f, -0.20337619f, 0.19924350f, 0.22881043f, 0.21553005f, -0.13134970f, 0.14939617f, 
    0.01158194f, -0.18920285f, -0.15524223f, 0.07716595f, -0.05290543f, -0.00841533f, -0.11049626f, 0.08986291f, 
    0.53464234f, 0.02924178f, -0.33037770f, -0.32157338f, 0.15272491f, 0.15370801f, 0.00127714f, -0.03038912f, 
    0.13784404f, -0.00182521f, 0.09908148f, -0.03955662f, 0.54937875f, -0.52584046f, -0.53879648f, 0.42701325f, 
    0.20869313f, -0.10982995f, -0.07202791f, 0.00593822f, -0.07284977f, -0.09438981f, 0.09621278f, -0.07802962f, 
    0.38223410f, -0.08106077f, -0.16041926f, 0.10094607f, 0.21979518f, 0.05612565f, 0.00459612f, -0.23039180f, 
    0.24952467f, 0.14611094f, 0.19154884f, 0.20188829f, -0.57590985f, -0.17222065f, 0.26786602f, -0.31660119f, 
    -0.18929763f, 0.15255742f, -0.26110351f, 0.34040588f, -0.16672835f, 0.29865628f, -0.06590825f, -0.26738673f, 
    -0.18545859f, 0.52757519f, -0.10813435f, -0.23589893f, 0.00549069f, 0.13295546f, 0.15091455f, 0.34067425f, 
    0.11855944f, -0.23880008f, 0.04663729f, -0.13916792f, -0.52098036f, -0.53243852f, -0.30405927f, -0.33706549f, 
    0.21815822f, 0.11884142f, 0.17735007f, 0.19542302f, 0.12221459f, 0.02567522f, 0.08669613f, 0.27502573f, 
    0.06402233f, -0.29832223f, -0.02440421f, -0.31245112f, 0.00105895f, 0.10883275f, -0.04898900f, 0.04068141f, 
    -0.12353864f, -0.09229868f, -0.00486267f, -0.06072146f, -0.13715701f, -0.29472885f, 0.10011176f, 0.32096490f, 
    -0.22764158f, 0.26031071f, 0.16645801f, -0.01102043f, -0.03093203f, -0.17472683f, 0.03881164f, 0.05317768f, 
    -0.84706688f, 0.52612180f, -0.16170022f, 0.25181922f, 0.09650422f, -0.08808949f, -0.14300536f, 0.16346456f, 
    -0.03654980f, -0.23940377f, -0.01523239f, -0.29423395f, 0.16427317f, -0.23693335f, 0.20484947f, -0.01605101f, 
    -0.06347290f, 0.04307550f, -0.10434427f, 0.00365975f, 0.04632285f, 0.13698690f, 0.03295558f, 0.05356582f, 
    0.15482989f, 0.32958597f, -0.35532320f, 0.08404754f, 0.15406679f, -0.26580662f, -0.04649162f, -0.38592589f, 
    -0.15168887f, 0.05097105f, -0.12272687f, -0.11732498f, 0.41630128f, -0.22262172f, -0.53093565f, 0.52894878f, 
    0.16561630f, -0.13856143f, 0.00313786f, 0.19822758f, 0.09744556f, 0.02973925f, -0.03289755f, 0.11365268f, 
    0.01960194f, -0.38497478f, -0.10641090f, 0.16314259f, -0.26671240f, 0.05581889f, -0.09337579f, 0.03981339f, 
    -0.39649945f, 0.00146589f, -0.20974009f, -0.05844532f, -0.37344369f, 0.08641472f, 0.03409131f, -0.07800783f, 
    0.25382623f, -0.13090947f, 0.01876043f, -0.02133392f, -0.02442287f, -0.00283322f, 0.05449428f, -0.16478172f, 
    0.16371422f, -0.19854020f, -0.21239656f, 0.18781340f, -0.18112606f, -0.14727321f, -0.39442286f, -0.08356142f, 
    -0.08829659f, 0.26815075f, -0.07720528f, -0.14279939f, -0.15910704f, 0.11625443f, 0.22772783f, -0.11544093f, 
    -0.08836075f, 0.03467461f, -0.00928358f, 0.16800939f, -0.12032364f, -0.00811472f, 0.15419754f, 0.23307222f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.20936680f, -0.01296050f, -0.19891471f, 0.01267505f, -0.01932208f, 0.02056609f, 0.04456070f, -0.22774702f, 
    -0.03311767f, -0.03780289f, 0.29992092f, 0.01186087f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
