#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.99092841f, 0.38733318f, 0.43738812f, -0.11757682f, -0.37215760f, 0.66927046f, 0.89845628f, 0.19125073f, 
    0.10373348f, -0.47744310f, -0.20747083f, 0.34991619f, 0.19739574f, -0.00239655f, 0.00775085f, -0.10557691f, 
    -0.14223383f, -0.09591002f, -0.32865429f, -0.27889225f, 0.38380513f, 0.17053173f, 0.08063810f, 0.21866371f, 
    0.04221411f, -0.58062893f, -0.76702386f, -1.13458097f, 0.04041712f, -0.15456580f, -0.46494460f, 0.50732964f, 
    -0.12614454f, 0.38162854f, 0.89612913f, 0.44093838f, 0.09609418f, 0.18768609f, -0.20191182f, 0.20521258f, 
    0.07737858f, 0.00440390f, 0.12930442f, 0.35704958f, 0.10274331f, -0.05921985f, 0.19746201f, -0.17360350f, 
    0.12242325f, -0.02434907f, -0.22463770f, -0.84844589f, -0.55621934f, -0.18164936f, -0.26796409f, -0.24691693f, 
    -1.20277023f, 0.33738697f, -0.00146781f, 0.03127363f, 0.43540114f, 0.04683554f, 0.39272976f, -0.01556076f, 
    0.09557487f, -0.20971875f, 0.22756691f, -0.16437477f, -0.31564105f, 0.39774701f, 0.09429926f, -0.10408819f, 
    0.23244081f, 0.28178310f, -0.43717477f, 0.29229099f, -1.50896370f, 0.99208081f, -0.12642525f, -0.24411051f, 
    0.72776794f, -0.09736156f, 0.70558655f, 0.33437186f, 0.03182892f, -0.34781161f, -0.14600457f, -0.29666549f, 
    0.14942980f, -0.13752027f, 0.07521842f, -0.16283725f, 0.06435624f, -0.51002163f, -0.01220655f, -0.09027778f, 
    -0.14583017f, 0.03099557f, -0.07840918f, -0.17683171f, 0.23307626f, 0.22018252f, 0.49106616f, 0.52722025f, 
    0.91759777f, 0.19997467f, -1.30205655f, -0.57630223f, -0.80100065f, -0.37354696f, 0.39562067f, 0.07790235f, 
    0.12883969f, -0.00007201f, -0.25995755f, 0.36893156f, 0.28899509f, -0.16183804f, 0.28551501f, 0.31076115f, 
    0.39706367f, 0.05368508f, 0.02577537f, -0.11025846f, 0.18935071f, 1.26926577f, 0.69833297f, 0.62599260f, 
    0.83416545f, 1.04736280f, 0.14998008f, -0.13763209f, -0.80342257f, 0.14256728f, -0.23729211f, 0.18263616f, 
    0.38584930f, -0.01625582f, 0.02679100f, 0.01965952f, 0.31067774f, 0.17396604f, 0.39522207f, 0.19805969f, 
    0.17395711f, 0.20921613f, 0.04198052f, -0.22463554f, -0.20159964f, 0.52574587f, 0.95882964f, 0.67678738f, 
    -0.13156845f, 0.29008457f, -0.99532336f, 0.17784265f, 0.59087503f, -0.39826593f, 0.10062271f, 0.59794855f, 
    0.35869968f, 0.35633424f, -0.43138224f, -0.02315391f, 0.31274745f, 0.04425912f, -0.31472605f, 0.28135800f, 
    -0.01283325f, 0.15044831f, -0.31679505f, 0.35037801f, 0.08305936f, 0.23081076f, -0.02656177f, 0.12174981f, 
    0.79152697f, -0.59356636f, 0.06375208f, -0.01983977f, -0.70572144f, -0.88969803f, -0.80890316f, -0.66526276f, 
    -0.58852571f, 0.20329660f, 0.46665943f, 0.03450322f, -0.13626613f, -0.22800896f, -0.16014950f, -0.16988216f, 
    0.10383543f, -0.34134567f, 0.25873259f, 0.22299556f, 0.08820911f, -0.02156090f, 0.11273839f, -0.04991503f, 
    -0.23858364f, 0.79129422f, 0.99856931f, 0.35825279f, 0.51005292f, -1.12664759f, 0.80303520f, -0.49362931f, 
    -0.77060205f, 0.10717605f, 0.20401274f, 0.42482284f, -0.20717603f, 0.15267482f, -0.01329738f, 0.02625378f, 
    -0.48038441f, -0.23355983f, -0.26205820f, -0.12394398f, 0.00843554f, 0.35404179f, 0.49224836f, 0.34360236f, 
    -0.06762341f, 1.07779586f, 0.57124078f, 0.68561578f, -0.85427547f, -0.71747071f, -0.11662170f, 0.28866446f, 
    -0.53994477f, -0.26252908f, -0.08520916f, 0.10153754f, 0.51975244f, 0.31146783f, 0.08334646f, -0.34274200f, 
    -0.24627602f, -0.10098665f, 0.25736922f, 0.11103743f, -0.00700586f, 0.09865391f, 0.09841309f, -0.07108643f, 
    -0.09667189f, 0.33371291f, 1.00380051f, 0.56291455f, 0.81463295f, -0.22521257f, -0.46934411f, -0.07593124f, 
    -0.78348333f, 0.50720680f, 0.43207821f, 0.52917647f, -0.17114925f, -0.46318167f, -0.31579652f, 0.18548810f, 
    -0.12792583f, -0.11267707f, 0.18169820f, 0.26253015f, -0.25666347f, -0.08681420f, 0.37029186f, 0.11830566f, 
    0.41842565f, 0.38083881f, 0.18034604f, -0.51554936f, -0.68705899f, -0.76904750f, -0.79092497f, -0.45889100f, 
    -0.51199734f, 0.22776301f, 0.01527274f, -0.42549017f, 0.35151139f, -0.29930040f, 0.14791310f, -0.03848183f, 
    0.27634674f, 0.06224878f, 0.14494343f, 0.15499809f, 0.33129400f, -0.15921633f, 0.11299270f, 0.21187520f, 
    0.13408995f, -0.25222367f, 0.23939519f, -0.00204868f, 1.07509768f, -0.60482752f, -0.11674998f, -0.53958803f, 
    1.01607871f, 0.35343084f, -0.48747510f, -0.04792993f, -0.41673684f, 0.61095476f, -0.41258398f, 0.29199660f, 
    0.17425478f, -0.03718769f, 0.06042986f, -0.00055898f, 0.04482808f, 0.20908029f, -0.00704315f, -0.14579786f, 
    0.11310034f, -0.33011815f, -0.02230068f, 0.12244122f, -0.08932453f, 0.81956154f, -1.55590141f, 0.31177017f, 
    1.14165819f, 0.38847306f, -0.80381656f, 0.59912002f, 0.29462475f, -0.13206375f, 0.10384269f, 0.13705726f, 
    -0.00533854f, -0.25212315f, 0.03755013f, 0.19435464f, -0.00017636f, 0.19978270f, 0.11545905f, 0.16961202f, 
    0.26422009f, -0.14938915f, 0.03777763f, -0.00955056f, -0.12430014f, 0.04804792f, 0.20897560f, -0.58829767f, 
    0.39365688f, 0.07983150f, 0.46661368f, -0.96643388f, -0.26576665f, -0.04568019f, -0.75505322f, -0.59012181f, 
    -0.26502177f, 0.26539215f, 0.22841391f, 0.30398306f, -0.27244100f, -0.40261823f, -0.26837376f, 0.36047137f, 
    0.39972326f, -0.53529686f, 0.07790309f, -0.12382357f, -0.09428654f, -0.19187771f, -0.02225601f, -0.62360215f, 
    -0.21722020f, 0.58936071f, 0.69426972f, 0.26621497f, 0.06528126f, 0.00865195f, -0.12039372f, -0.42165646f, 
    0.00649004f, 0.08560828f, -0.44689319f, -0.68744630f, -0.30077597f, 0.09204455f, -0.38149059f, -0.10824141f, 
    0.30879766f, -0.15028864f, -0.25859502f, -0.50219434f, -0.26220921f, -0.28205824f, -0.36912745f, -0.58592367f, 
    -0.42710772f, -1.05009079f, -0.44608179f, -0.17894891f, 0.39575118f, -0.83475047f, 0.60622150f, -0.28366810f, 
    -0.65104222f, 0.32747126f, 0.65131092f, 0.53618771f, 0.13902147f, -0.22956194f, -0.09894519f, -0.36324656f, 
    0.03725468f, 0.26691866f, -0.08790375f, -0.47173765f, 0.03953544f, -0.07886723f, 0.05587850f, 0.03722046f, 
    0.05729095f, 0.30271280f, -0.58648479f, -1.04926825f, -0.91819268f, -0.61740643f, -0.25871938f, 0.94655830f, 
    0.63713986f, 0.29613808f, 0.30139437f, -0.13551752f, -0.41458347f, -0.44248948f, -0.15785094f, -0.08168494f, 
    0.15501393f, 0.02326967f, -0.30623707f, -0.19909988f, -0.30858672f, -0.17808253f, 0.23900962f, 0.06352370f, 
    0.21085232f, 0.28287649f, 0.26763111f, 0.80669141f, 0.53338367f, -0.18814257f, 1.05775392f, -0.01978166f, 
    -0.22061162f, 0.27604952f, -0.08085120f, -0.02622670f, 0.33204883f, 0.09805301f, 0.17547803f, 0.46258774f, 
    -0.48780331f, 0.17296053f, -0.18085974f, -0.10752846f, 0.41343489f, -0.08777981f, -0.32424968f, -0.29595435f, 
    -0.35075414f, 0.19011772f, -0.11340520f, -1.07344580f, 0.61974329f, 0.35172826f, -0.71919918f, 0.76395935f, 
    0.58217579f, -0.60950512f, -0.23885483f, -0.46556187f, -0.03949464f, -0.71162397f, -0.42891225f, -0.34323910f, 
    0.02683623f, -0.01869758f, -0.10118814f, -0.27730817f, -0.04916902f, -0.16061956f, 0.08296890f, 0.23818497f, 
    0.15101515f, -0.03288949f, -0.11374325f, 0.11018376f, 0.75931984f, 0.05074422f, 0.16723949f, 0.25414357f, 
    0.93467164f, 0.73352385f, 0.76813418f, 0.62711400f, 0.51962417f, 0.43350235f, -0.53740495f, -0.16132383f, 
    -0.63222742f, 0.23384231f, 0.23533070f, -0.30464917f, -0.14875878f, -0.22372597f, 0.26459473f, 0.17775792f, 
    -0.16486593f, -0.05344772f, -0.36051229f, -0.18181799f, -0.15701167f, 0.88265741f, -0.06443620f, 0.47612187f, 
    0.74773073f, 0.69908220f, 0.29116616f, -0.61992586f, 0.56383413f, -0.51155955f, -0.63884991f, -0.03391154f, 
    -0.48604113f, -0.62001735f, -0.09516009f, -0.05723350f, -0.21218999f, 0.01069493f, -0.19976825f, 0.30939057f, 
    -0.29498461f, -0.29471207f, -0.09862125f, 0.05996951f, -0.23526619f, -0.15291791f, 1.20953476f, 0.47093248f, 
    -0.36007354f, 1.44225621f, 0.39855722f, 0.45550945f, 0.10492024f, -0.64026463f, 0.73821414f, 0.02553271f, 
    -0.24221681f, -0.12956865f, 0.14105612f, 0.31985369f, -0.20193517f, 0.11758579f, 0.15868606f, 0.26972815f, 
    -0.04209244f, -0.01460903f, -0.01209596f, 0.12466478f, 0.06427657f, -0.31258783f, 0.08742183f, -0.59187663f, 
    -1.26340723f, -0.46685591f, 0.12289388f, -0.31694418f, -0.59383756f, 0.72215521f, 1.25609326f, -0.68287033f, 
    0.10181768f, 0.31032196f, -0.36477843f, -0.06131592f, -0.19980478f, 0.10657844f, -0.20145568f, -0.10431659f, 
    -0.20396461f, -0.21737573f, -0.18080612f, -0.19107221f, -0.11032940f, 0.00059395f, -0.02955368f, 0.23382145f, 
    -0.82557750f, -0.35175315f, -0.89675778f, 0.58022928f, -0.01002123f, 0.42908904f, 0.21354128f, 0.20638685f, 
    -0.63027096f, -0.75483918f, 0.25067580f, 0.13112335f, -0.09153852f, -0.20675398f, 0.49665686f, 0.02980409f, 
    0.50901300f, 0.58063090f, 0.31366825f, 0.28675190f, 0.04511471f, -0.16070035f, -0.30620429f, 0.35563967f, 
    -0.09873948f, 0.93401498f, 0.22191559f, -0.99990761f, -0.83216280f, -0.66375262f, 0.47382909f, 0.04610710f, 
    -0.23339063f, -0.24032246f, -0.41666722f, -0.25258595f, -0.27796596f, -0.12389553f, -0.33822852f, -0.08016134f, 
    -0.01370492f, -0.18638742f, 0.01269534f, 0.41412315f, 0.29594254f, 0.14514403f, -0.15341252f, -0.27259138f, 
    -0.26286745f, 0.15476689f, 1.21389878f, -0.06455570f, -0.03880623f, 1.35057795f, -0.01488527f, -0.57084453f, 
    0.23799236f, 0.47344351f, -0.45210937f, 0.30969766f, -0.25302762f, -0.01264832f, -0.01169516f, -0.22551399f, 
    0.14941275f, -0.45251128f, -0.29573393f, 0.05467762f, -0.10174461f, -0.07224896f, 0.62417793f, 0.14776006f, 
    0.22819543f, 0.24556318f, 0.02373012f, -0.63512707f, -0.35400560f, 0.69522744f, -0.28412354f, -0.94379747f, 
    0.16029648f, -0.54365534f, 0.11753260f, -0.31086519f, -0.34797978f, 0.19100565f, 0.36159465f, -0.47882348f, 
    -0.30608767f, -0.45718217f, 0.27020067f, 0.58291930f, -0.30242100f, 0.15308693f, -0.73032498f, 0.00189131f, 
    -0.11094127f, 0.34989825f, 0.18279253f, 0.12349644f, -0.22290133f, -0.51666874f, -0.51380777f, -0.38700339f, 
    -0.73199618f, 0.53170979f, 1.05927587f, 0.23996656f, 0.26195383f, 0.56264901f, 0.12161966f, -0.39598992f, 
    -0.25769818f, -0.44211411f, 0.11058052f, -0.36961138f, -0.08844674f, 0.00097535f, 0.10516085f, -0.11254013f, 
    -0.48558536f, 0.00274034f, 0.10587246f, -0.57934117f, -0.22648591f, 0.66200387f, 0.50855619f, 0.24704295f, 
    0.97974223f, 0.97779363f, 0.60919428f, 0.47618997f, 0.64943969f, 0.13533066f, 0.06487644f, 0.08578207f, 
    -0.19926234f, 0.03741257f, -0.12510273f, -0.06908016f, 0.23441701f, 0.20255022f, 0.20164457f, -0.15720086f, 
    0.10135816f, -0.12501381f, 0.27602002f, 0.25400621f, -0.04488958f, 0.27677613f, 1.10807621f, 0.59098870f, 
    -0.91038829f, -0.87199616f, -0.20702493f, 0.21671890f, -0.45273262f, 0.17057021f, -0.06515121f, 0.00282734f, 
    0.20542590f, 0.42403269f, -0.14160959f, 0.24698827f, -0.15530409f, -0.01074694f, 0.00231926f, -0.23026435f, 
    -0.10948277f, 0.26399896f, -0.23044682f, 0.12728423f, 0.35318008f, 0.00453000f, 0.28768104f, 0.26192603f, 
    -1.11670697f, 0.14424109f, 0.77050257f, 0.57360590f, -0.68264222f, 0.60800058f, 0.15832554f, 0.35372317f, 
    -0.05645789f, 0.32840726f, 0.43920487f, -0.06445019f, 0.01352355f, -0.01275522f, -0.51961833f, 0.07601666f, 
    -0.78921318f, -0.08606958f, -0.26916429f, 0.04243068f, 0.05202189f, -0.07122126f, 0.27906647f, 0.16036277f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.21468049f, 0.21601848f, 0.28668520f, 0.08736148f, 0.34190914f, 0.11857605f, 0.13961540f, 0.31750455f, 
    0.19009352f, 0.04587435f, 0.20067324f, 0.31083614f, 0.20292230f, -0.14332688f, 0.23226584f, 0.01460157f, 
    0.44805548f, 0.33700562f, 0.02111949f, -0.09366242f, 0.27770248f, -0.01565349f, 0.31870767f, 0.04361615f, 
    0.17502749f, 0.11659295f, 0.09821309f, 0.17006473f, 0.06895667f, 0.27319869f, 0.21651492f, 0.08583559f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.23352011f, 0.20288865f, 0.36006522f, 0.05200719f, -0.04109582f, 0.01787968f, 0.00737789f, -0.02919821f, 
    0.02540053f, -0.05462767f, 0.12855047f, -0.15247041f, 0.09497330f, 0.25592089f, -0.24232997f, -0.10629271f, 
    0.09081668f, 0.00786878f, 0.14341147f, 0.04170694f, 0.04551040f, -0.07397740f, -0.01482935f, -0.02925294f, 
    -0.04919600f, -0.50171852f, -0.22093295f, 0.14913176f, 0.01889365f, 0.12132868f, 0.07826401f, 0.06078457f, 
    -0.19681181f, -0.03345841f, 0.03294176f, -0.11831846f, 0.27712786f, -0.10369188f, 0.09882857f, 0.07071765f, 
    0.02206632f, 0.11517090f, 0.05490863f, 0.04977138f, -0.08568393f, 0.02506801f, -0.17329997f, 0.03055711f, 
    0.15996802f, -0.11617157f, 0.14382523f, -0.14380379f, -0.09687204f, 0.01567592f, -0.06515650f, -0.00787579f, 
    0.00704603f, -0.06876463f, -0.02989911f, -0.06002541f, 0.16003919f, -0.23129728f, 0.05841532f, 0.00640594f, 
    -0.21148437f, -0.05660259f, 0.08569530f, 0.09399266f, 0.02507851f, 0.03484926f, -0.05432079f, 0.00150033f, 
    -0.09969192f, 0.03722000f, -0.10769670f, 0.05107919f, -0.21229513f, 0.00553943f, -0.11640395f, -0.01032847f, 
    -0.00551363f, 0.13761242f, 0.02461364f, -0.12842919f, 0.19503619f, 0.14790969f, 0.24012245f, 0.00644987f, 
    -0.15959930f, -0.06422284f, -0.04142176f, -0.07417339f, 0.04488146f, -0.08497203f, -0.13769646f, -0.05519578f, 
    -0.12402250f, 0.05736698f, 0.07463160f, 0.18069214f, 0.00088043f, -0.03850058f, -0.12741283f, -0.11395738f, 
    -0.04772342f, 0.01974519f, -0.03291925f, 0.00542211f, -0.26264408f, 0.19690838f, 0.24267927f, -0.28264409f, 
    -0.03464533f, -0.00153778f, 0.02633174f, 0.08613346f, -0.08644583f, -0.05360719f, -0.10567033f, 0.00284394f, 
    0.26878065f, -0.19205369f, -0.12644452f, 0.11848383f, -0.19560054f, -0.03116819f, -0.11259653f, -0.13349038f, 
    -0.05488848f, 0.12214645f, -0.22021347f, -0.03827049f, -0.24539119f, -0.14893386f, -0.12786298f, -0.46383893f, 
    0.02380560f, 0.04153480f, -0.07007544f, 0.10766080f, 0.06481840f, -0.00449968f, -0.00568711f, 0.07091779f, 
    0.18752429f, -0.32302880f, 0.15003376f, -0.30358246f, -0.03646243f, 0.04344857f, 0.03021458f, 0.14519452f, 
    -0.10490543f, 0.09831081f, -0.09099499f, -0.00531300f, 0.42722812f, -0.20524012f, -0.14344376f, 0.52427882f, 
    -0.25354695f, 0.08822571f, 0.08671633f, 0.06416495f, 0.02536270f, -0.14805773f, -0.04920078f, 0.00915627f, 
    0.15981562f, -0.00777566f, -0.14420187f, -0.01279369f, -0.16013254f, 0.05045698f, 0.04065133f, 0.00343349f, 
    -0.04088720f, 0.09322548f, -0.12739404f, -0.03901127f, -0.21755075f, 0.00596116f, -0.20655078f, 0.10364598f, 
    -0.06814937f, 0.03261418f, 0.13850898f, -0.00022773f, -0.07171755f, -0.07574011f, 0.01019773f, -0.08480842f, 
    -0.49971795f, -0.22576511f, -0.11511728f, 0.03226471f, -0.06230961f, -0.15814638f, -0.07165354f, -0.05467612f, 
    0.00352946f, 0.12698847f, -0.16845737f, 0.02567141f, -0.08663033f, 0.18345490f, -0.08830693f, -0.53846574f, 
    0.05847403f, -0.06302175f, 0.01960126f, -0.17130788f, -0.04335113f, -0.03780267f, -0.01192138f, -0.03093705f, 
    0.05426195f, -0.11341157f, 0.03771051f, -0.35684010f, -0.08247104f, 0.12755758f, -0.05525798f, 0.04746343f, 
    0.30504784f, 0.09524415f, 0.01150676f, 0.01198912f, -0.34228128f, -0.13870364f, 0.40918851f, -0.14757659f, 
    0.08193907f, -0.12345264f, 0.21321318f, -0.09202107f, 0.01148543f, -0.06524570f, 0.00070128f, 0.08989657f, 
    0.10776443f, -0.06457494f, 0.09274942f, 0.06156553f, -0.13042775f, 0.03497281f, 0.02643852f, 0.05971159f, 
    0.00645643f, -0.04981185f, 0.00167776f, 0.05035682f, 0.35529596f, -0.04787166f, 0.11566512f, 0.01393230f, 
    -0.25251201f, 0.04882701f, -0.01057628f, 0.02005728f, -0.07346106f, -0.14047326f, 0.04751159f, -0.17089407f, 
    0.09933776f, -0.03427477f, -0.28335503f, 0.45232826f, -0.19672479f, 0.01091066f, -0.03492366f, 0.07015222f, 
    -0.06269560f, 0.07755343f, -0.08550716f, 0.07818282f, -0.78100395f, 0.32299191f, -0.07716346f, -0.08577016f, 
    -0.06074323f, 0.08005416f, -0.10594483f, 0.06632214f, 0.14648443f, -0.11373535f, 0.08990219f, 0.10147671f, 
    -0.36001131f, 0.06683309f, -0.05408775f, -0.11509682f, 0.07049546f, 0.02238071f, -0.06844512f, 0.10676395f, 
    0.17468616f, -0.00209041f, -0.03049562f, 0.05277595f, -0.09034380f, -0.15009971f, 0.12964153f, -0.30319786f, 
    -0.00739867f, -0.15226907f, 0.03811515f, 0.05037016f, -0.12751620f, -0.02439761f, 0.10615347f, 0.21595344f, 
    0.30422735f, 0.01233138f, -0.21978313f, 0.44289488f, -0.04923134f, -0.00684776f, -0.12801689f, -0.06947115f, 
    -0.04856423f, 0.00287339f, -0.00760995f, -0.03056006f, -0.49905762f, 0.08841264f, -0.11557353f, 0.18619524f, 
    -0.10167232f, 0.14244899f, -0.00097122f, 0.04285987f, -0.02008172f, 0.16276619f, 0.01973304f, -0.16854374f, 
    0.25872159f, 0.05184341f, 0.20026696f, -0.25512218f, 0.08869954f, 0.08087771f, 0.10139149f, -0.08281323f, 
    -0.02742940f, -0.01784131f, 0.07505706f, 0.07210701f, 0.05324557f, -0.10916178f, -0.02188044f, 0.17227279f, 
    -0.29651228f, 0.06304732f, 0.04718179f, 0.04070680f, -0.08100885f, 0.14133430f, 0.00605522f, -0.19470569f, 
    0.12028065f, -0.20987631f, 0.28727052f, -0.39827591f, -0.09418191f, -0.03517455f, 0.10955717f, 0.17405975f, 
    -0.02164345f, -0.07980915f, -0.01452350f, -0.04306547f, 0.08118618f, 0.01381671f, -0.13890886f, 0.13909520f, 
    -0.14067398f, -0.10231940f, 0.10143067f, -0.17238006f, 0.01950863f, 0.07832699f, 0.06398982f, 0.02875903f, 
    -0.79879123f, -0.03430064f, -0.34786722f, 0.01658360f, -0.03183168f, -0.01358406f, 0.05429488f, 0.00371929f, 
    0.06591684f, -0.10879242f, -0.10812228f, -0.10030086f, 0.36035016f, -0.10874312f, -0.27662867f, 0.01055136f, 
    0.04135912f, -0.00932546f, 0.19708046f, 0.05626412f, 0.03835794f, 0.02050824f, -0.01438310f, 0.18329185f, 
    -0.04924271f, 0.10014294f, 0.08508425f, -0.10506796f, 0.00964680f, -0.11040965f, 0.07685783f, 0.04236384f, 
    0.09080133f, 0.03960570f, -0.05420870f, 0.09107652f, 0.05809554f, -0.01917491f, -0.02723905f, -0.03365051f, 
    0.09525565f, 0.14304551f, -0.02242681f, -0.23678783f, 0.14431150f, -0.08290853f, 0.09958004f, -0.21921341f, 
    0.01591078f, -0.04318513f, 0.09253667f, 0.13746709f, -0.01787048f, 0.02894367f, 0.04310847f, 0.02024360f, 
    -0.08442210f, 0.21775854f, -0.04489835f, 0.10567030f, 0.24053884f, -0.21534573f, 0.21462992f, 0.32470304f, 
    -0.02895528f, 0.03856222f, -0.11460394f, 0.00299707f, -0.07336152f, -0.04815262f, -0.01041409f, -0.00043699f, 
    0.42562309f, -0.10653140f, -0.04564815f, -0.07249496f, -0.13183421f, -0.12528372f, 0.03892066f, -0.02313795f, 
    -0.20081694f, -0.10566799f, -0.12187403f, 0.23410688f, -0.19709802f, -0.34222934f, -0.22604725f, -0.27664036f, 
    0.05569614f, 0.08971667f, 0.08419213f, 0.03866815f, -0.01714149f, 0.12996170f, 0.13858177f, -0.05306401f, 
    -0.11912671f, 0.18716921f, 0.05316293f, -0.22375852f, 0.03215187f, 0.16320044f, 0.11745748f, -0.05439420f, 
    0.08984669f, -0.00138360f, 0.03169197f, -0.01714431f, 0.27146667f, -0.00268079f, 0.07756209f, -0.12823330f, 
    0.00424584f, -0.07448046f, 0.02500432f, -0.05473485f, 0.11461526f, -0.16301855f, 0.09540940f, 0.00759558f, 
    0.01126736f, 0.18181880f, 0.07706666f, -0.03921427f, -0.10786758f, -0.09881023f, 0.13598458f, 0.05486110f, 
    0.01993726f, -0.17804340f, 0.08355127f, -0.11876737f, 0.07526041f, -0.03499715f, -0.05365367f, -0.12189557f, 
    0.02884173f, 0.06361276f, 0.21269016f, 0.01148010f, 0.00984416f, 0.15511160f, 0.10242466f, -0.05027757f, 
    0.31127089f, -0.13239506f, 0.16221851f, -0.30708700f, -0.06079164f, 0.04450772f, -0.09472872f, 0.05124256f, 
    0.18378530f, -0.12483427f, -0.06643570f, 0.01955436f, -0.10406555f, -0.38870206f, -0.00716852f, 0.07760262f, 
    -0.22467098f, 0.01966438f, -0.09360784f, -0.04247903f, 0.04631036f, 0.11650187f, 0.07997075f, -0.00029068f, 
    -0.25786641f, -0.18332720f, 0.01170276f, -0.02248510f, 0.08419813f, -0.09427686f, -0.04925685f, 0.16433458f, 
    0.05324480f, -0.11035511f, 0.14293508f, 0.06725772f, -0.07528369f, -0.02564972f, -0.16114584f, 0.15311304f, 
    0.18235311f, 0.04779300f, -0.06251614f, 0.04781060f, -0.25643978f, -0.16155854f, -0.11518268f, -0.03134298f, 
    0.18462276f, -0.16907811f, -0.18460217f, -0.06452166f, -0.05446463f, 0.05036939f, -0.07674886f, 0.24119569f, 
    0.06984685f, -0.28375304f, 0.20768628f, -0.05405578f, 0.30506802f, -0.45294261f, 0.02381003f, -0.25167981f, 
    -0.02300219f, -0.07127379f, -0.09247018f, 0.04158730f, 0.15616013f, 0.00437636f, -0.02911279f, 0.05105397f, 
    0.12222354f, 0.18909439f, 0.03476766f, 0.02144053f, -0.01042255f, -0.15092060f, 0.02904899f, 0.10606061f, 
    -0.12166547f, -0.02233319f, -0.20156628f, 0.02341798f, 0.24552573f, -0.16623998f, -0.61187285f, -0.23927020f, 
    -0.14786376f, -0.06578486f, -0.05192147f, -0.14801300f, -0.10572867f, 0.33269608f, -0.20716150f, -0.19884412f, 
    0.46857175f, 0.00798281f, 0.02011801f, 0.11548066f, -0.00938242f, -0.05870056f, -0.07420801f, 0.04514113f, 
    0.02920843f, 0.16381557f, -0.19284405f, -0.09174666f, -0.02722510f, 0.06017990f, 0.06770074f, 0.20442854f, 
    -0.00785823f, 0.07585367f, -0.05186307f, 0.01281190f, -0.12671730f, -0.01990508f, -0.01311800f, 0.07339638f, 
    0.32805884f, -0.25000852f, -0.07233596f, 0.14115852f, -0.02031172f, -0.10144771f, -0.11497094f, 0.05681612f, 
    0.01199771f, 0.00419664f, 0.03779314f, -0.12669657f, 0.24405551f, -0.18246782f, -0.11620498f, 0.20654237f, 
    -0.20477033f, -0.06688187f, -0.06235380f, -0.09236535f, -0.06652469f, -0.09958729f, -0.10333125f, -0.02715502f, 
    0.16600755f, 0.13210241f, -0.32444721f, 0.23957837f, 0.11462983f, 0.05026614f, -0.00299847f, -0.12927105f, 
    -0.06883121f, -0.02825494f, 0.04040772f, 0.05921723f, 0.22503617f, -0.33893380f, 0.07022867f, -0.26082838f, 
    0.01837054f, -0.02484974f, 0.04808704f, 0.10061199f, -0.09363297f, -0.02262689f, 0.00173810f, -0.16905653f, 
    0.01327106f, -0.06385642f, 0.13320445f, 0.39239839f, -0.23669595f, -0.02064736f, 0.03238354f, 0.04397037f, 
    0.06731138f, -0.03907448f, -0.03559178f, 0.15045427f, -0.17506401f, -0.00598076f, -0.44632390f, 0.09259330f, 
    -0.01339565f, -0.10277157f, 0.03834205f, 0.01018730f, 0.06155796f, -0.01611196f, -0.18068554f, 0.02324553f, 
    0.00836072f, -0.08075947f, -0.12284112f, -0.09232859f, 0.00079133f, -0.20968255f, 0.09280199f, 0.02116873f, 
    0.02285088f, 0.01941833f, -0.22456412f, -0.03813513f, 0.31564209f, 0.12788074f, 0.15983370f, 0.17627759f, 
    -0.06023116f, -0.01212185f, -0.09272951f, 0.02636009f, -0.09218688f, -0.07548223f, 0.09217122f, 0.09554908f, 
    0.28033823f, -0.38829565f, 0.05368277f, -0.33741000f, -0.02403757f, -0.00554088f, -0.03852591f, -0.06859224f, 
    -0.21590684f, 0.10740452f, 0.11320727f, 0.04354329f, -0.08087190f, -0.27827093f, 0.12153316f, 0.17616157f, 
    0.06390123f, 0.18200652f, -0.06817577f, 0.03780299f, -0.02436315f, -0.06819894f, -0.19253261f, -0.18287143f, 
    0.47534159f, 0.03767898f, -0.19075932f, -0.16475669f, -0.11521312f, -0.02722911f, -0.07806271f, 0.13184175f, 
    -0.02249378f, 0.01368184f, -0.04780909f, 0.00720592f, 0.30838957f, -0.24159722f, 0.26944014f, 0.14403932f, 
    -0.09902698f, -0.02821091f, -0.07492589f, 0.07147377f, -0.11937822f, 0.05074517f, -0.03394830f, -0.14359899f, 
    -0.04258861f, -0.22352208f, 0.24380712f, -0.11637249f, -0.26173875f, 0.20310700f, -0.14597714f, -0.18498063f, 
    -0.01568014f, -0.05443536f, 0.04522875f, -0.09114673f, -0.28790739f, 0.22376466f, 0.03562477f, -0.09277132f, 
    -0.09984153f, -0.00498533f, 0.05479828f, 0.10035605f, 0.00640885f, 0.08991764f, 0.00224101f, -0.11178134f, 
    -0.15052870f, 0.01719386f, -0.12921458f, 0.09729691f, 0.11255765f, -0.00345680f, -0.01706768f, -0.18620734f, 
    -0.06387703f, -0.13812150f, -0.01960904f, -0.10446438f, 0.08438023f, -0.07270502f, -0.08645745f, 0.05595863f, 
    0.16296588f, -0.03129469f, 0.01523105f, -0.07529636f, -0.01927208f, -0.01357645f, 0.01085926f, -0.07361583f, 
    0.21354024f, -0.09332316f, 0.19561455f, -0.15764479f, -0.07797221f, 0.05839868f, 0.01011223f, 0.12808235f, 
    -0.01951488f, 0.01732363f, 0.13638332f, -0.11650019f, -0.31483459f, -0.01865615f, -0.08591495f, -0.39763364f, 
    0.02980107f, -0.04672927f, 0.03370354f, -0.10840945f, -0.01865200f, 0.09351916f, -0.09117596f, -0.10933942f, 
    0.40865088f, 0.05396570f, -0.32098082f, 0.09269455f, 0.05558746f, 0.07181029f, -0.15947981f, -0.13594344f, 
    -0.02330017f, -0.00469133f, 0.12856801f, -0.12408169f, -0.44674110f, 0.11446840f, -0.03431480f, -0.37182054f, 
    -0.01306197f, 0.01202799f, -0.02125733f, -0.10296426f, 0.03397181f, 0.00828762f, -0.08297516f, 0.00357001f, 
    -0.12817369f, 0.06268259f, 0.10315023f, 0.05898479f, 0.04699615f, 0.05174503f, 0.07497828f, -0.08157091f, 
    -0.10693779f, -0.02245710f, 0.09949588f, 0.01004384f, 0.29188117f, -0.00673936f, 0.05650773f, 0.14290793f, 
    -0.04373433f, -0.19141276f, -0.11554433f, 0.02537249f, 0.03287837f, -0.14584053f, 0.01099951f, 0.01456879f, 
    -0.27420858f, 0.04749012f, 0.01490923f, -0.38311902f, 0.01529020f, 0.06597585f, -0.02807388f, -0.09286638f, 
    -0.29187244f, -0.15335843f, -0.06634276f, -0.09617437f, 0.51669431f, 0.01115495f, -0.13302580f, -0.13210686f, 
    0.00650113f, 0.11922078f, -0.09327112f, 0.04843489f, -0.10635866f, -0.12142199f, -0.18438034f, -0.03890770f, 
    0.07893597f, 0.19094391f, -0.26424161f, -0.08476099f, 0.00980413f, -0.02014647f, 0.00407291f, 0.01257930f, 
    -0.04196183f, 0.01743420f, -0.14575900f, -0.09784038f, 0.14608429f, -0.16667947f, -0.12875365f, -0.01171974f, 
    0.02648821f, 0.07766884f, -0.06178011f, 0.05411796f, 0.02151202f, 0.09883679f, 0.00360062f, -0.01942461f, 
    0.58640486f, -0.18571757f, 0.05765693f, 0.00166027f, -0.11594725f, -0.00295326f, -0.05880007f, -0.11949111f, 
    -0.10274936f, -0.00033550f, -0.04824571f, -0.05338690f, 0.17526163f, 0.13762128f, 0.18787391f, 0.37761080f, 
    -0.09181575f, -0.25870728f, 0.05363834f, 0.08621516f, -0.02922948f, 0.02402880f, 0.04383632f, 0.04569392f, 
    0.16665404f, 0.03343517f, -0.08616969f, 0.13978130f, 0.05155995f, 0.12968037f, 0.12953000f, -0.22688915f, 
    -0.09990977f, 0.01080125f, 0.04437484f, -0.07472828f, 0.04223835f, -0.11016285f, -0.07042393f, -0.02884921f, 
    -0.00552989f, -0.08446863f, -0.00671789f, -0.08786584f, 0.02101107f, 0.02754200f, -0.16462535f, 0.17569776f, 
    -0.04346537f, 0.11732639f, 0.11978164f, -0.07752955f, 0.10274560f, 0.01505142f, 0.00226837f, 0.10182765f, 
    0.03454185f, -0.15800126f, 0.12110066f, 0.03828703f, -0.59519321f, 0.20762943f, -0.05014803f, -0.19516714f, 
    0.11999770f, 0.00819972f, -0.18736915f, 0.06173390f, 0.03968024f, -0.02658732f, 0.04685773f, -0.09546310f, 
    0.25034955f, -0.16052474f, 0.02032527f, -0.10888855f, 0.14419499f, -0.01411661f, -0.07749757f, -0.03147851f, 
    -0.17830662f, 0.14229025f, 0.00049308f, -0.03857372f, 0.53005362f, 0.00850907f, -0.02342829f, 0.29842749f, 
    -0.10448847f, 0.00307900f, 0.00891687f, 0.04345074f, 0.03342680f, 0.08921035f, 0.10099876f, -0.06456000f, 
    0.04100099f, -0.09125921f, -0.04626836f, -0.11287598f, -0.28840178f, -0.10225946f, -0.23227327f, 0.06062215f, 
    -0.07708085f, -0.17852581f, 0.02535464f, -0.15108852f, -0.24539329f, -0.14122571f, -0.18138205f, -0.14773053f, 
    -0.08826534f, -0.07478781f, -0.04297435f, -0.03749766f, 0.02712339f, -0.07292390f, -0.02028646f, 0.06495203f, 
    0.15789507f, 0.16655408f, -0.16174746f, -0.11340924f, 0.11680690f, -0.00467314f, -0.01982602f, 0.02088586f, 
    0.02683651f, 0.09902157f, 0.19632441f, 0.01080691f, -0.32382062f, -0.50239545f, -0.08452710f, -0.30464801f, 
    -0.12689343f, 0.00570511f, -0.08178370f, 0.01607506f, -0.01575404f, 0.03213776f, -0.03757041f, -0.13962211f, 
    0.26504761f, 0.12534851f, 0.27340350f, 0.04938808f, 0.01815524f, -0.11743306f, -0.05424565f, 0.23769401f, 
    -0.07983886f, -0.01425649f, 0.08588451f, -0.10776550f, 0.00642407f, -0.05894008f, -0.02906042f, 0.05090586f, 
    0.10231464f, -0.06450059f, -0.04708669f, -0.03718386f, 0.05851448f, 0.03643706f, -0.05842599f, 0.03532435f, 
    -0.28306872f, -0.08285363f, 0.00766427f, -0.33449057f, 0.05358630f, -0.11489362f, 0.16286108f, 0.04486455f, 
    -0.06168811f, 0.00021125f, 0.11504629f, -0.10317206f, 0.29211798f, -0.01470541f, 0.00066137f, -0.07457417f, 
    -0.04898503f, -0.03406406f, 0.01138577f, -0.07448762f, 0.06208479f, -0.09267239f, 0.04883246f, -0.00155065f, 
    -0.14990190f, 0.50362879f, 0.09532676f, -0.05697424f, -0.03225701f, -0.04723717f, -0.05455578f, 0.05085828f, 
    -0.09868793f, 0.13058698f, -0.06674914f, -0.02763433f, -0.03291143f, 0.01090087f, -0.06255388f, -0.17515582f, 
    -0.22272265f, -0.03095998f, 0.04961535f, 0.00122839f, -0.00422184f, -0.12244026f, -0.04152679f, -0.06619518f, 
    0.27785507f, 0.20062158f, -0.15284769f, 0.05025464f, -0.09486829f, 0.02524440f, -0.05963928f, -0.00232572f, 
    -0.14717816f, -0.02495760f, -0.00764275f, -0.07154091f, 0.33531365f, -0.17804398f, -0.01801752f, -0.16013756f, 
    0.01429007f, 0.04143832f, -0.05572757f, 0.11457422f, 0.04466386f, 0.18654783f, 0.06158762f, -0.08946046f, 
    0.11204094f, -0.19106074f, -0.05854375f, 0.39978081f, 0.13604201f, 0.10413809f, -0.01928491f, -0.05222043f, 
    0.04440374f, -0.02512100f, -0.04378993f, -0.18547326f, -0.20856935f, -0.53647953f, -0.21587124f, 0.16890253f, 
    -0.05794315f, -0.01395065f, 0.04673395f, -0.04807204f, -0.02051347f, -0.11471620f, -0.09517337f, -0.01806114f, 
    -0.19379313f, -0.30143613f, -0.29460010f, 0.01300927f, -0.14862978f, 0.14427659f, -0.29073650f, 0.15336071f, 
    0.10148913f, -0.03675257f, 0.04453225f, -0.01923279f, 0.34058735f, 0.07674028f, -0.00849944f, 0.14675397f, 
    0.11950830f, 0.12518437f, -0.02098769f, 0.06168626f, -0.07125086f, 0.08358736f, -0.06851663f, -0.07787202f, 
    -0.85113275f, 0.24974373f, 0.21800391f, 0.13673545f, -0.04106900f, -0.06407901f, -0.17789012f, -0.08114661f, 
    -0.06660027f, -0.00557996f, -0.03067383f, -0.09053648f, -0.16726796f, 0.04052986f, -0.28114885f, 0.06550370f, 
    -0.02845180f, -0.12504178f, 0.02970034f, 0.06135992f, -0.00205885f, 0.09849118f, -0.10671400f, 0.04634701f, 
    -0.53252667f, -0.57108754f, -0.34256598f, -0.11192210f, -0.12671180f, 0.08971353f, -0.04786196f, -0.11228129f, 
    -0.02938284f, 0.07491964f, -0.07212664f, 0.18321259f, 0.06724812f, 0.04464137f, 0.02905537f, -0.13354042f, 
    -0.19058490f, -0.16298702f, -0.05644145f, -0.01854846f, -0.05174844f, 0.04063943f, -0.12625305f, 0.15081672f, 
    -0.05154730f, 0.31205383f, -0.14352600f, 0.35399285f, 0.09150653f, 0.29306543f, 0.00297117f, -0.10405605f, 
    -0.12769048f, 0.02010516f, -0.05045426f, 0.04517948f, -0.47605082f, -0.00009755f, 0.20143192f, 0.01477017f, 
    -0.00695770f, 0.18360059f, 0.07815830f, 0.12865503f, -0.08199307f, 0.01971897f, -0.03683266f, -0.08386754f, 
    -0.13199385f, 0.22019516f, 0.34831291f, 0.24852648f, 0.05611029f, 0.15580083f, 0.08046339f, -0.07318453f, 
    -0.03396512f, 0.04105273f, -0.03643238f, 0.14263955f, -0.37681064f, -0.20756392f, 0.15883851f, 0.14149331f, 
    0.00595189f, 0.00113836f, 0.09600317f, 0.08567612f, 0.13703041f, 0.14181605f, 0.16978402f, 0.07529098f, 
    -0.12345625f, 0.28783876f, 0.13703103f, 0.20148587f, 0.03279069f, 0.06938012f, -0.06022066f, -0.04103144f, 
    -0.03574727f, 0.22256094f, -0.12203202f, 0.01287895f, 0.08352121f, -0.17022046f, 0.06406029f, 0.11602151f, 
    -0.02453765f, 0.01731353f, -0.00622833f, -0.09221359f, -0.13992396f, 0.12730087f, -0.13213225f, 0.04442366f, 
    0.15185504f, -0.27260533f, 0.03336079f, -0.12690583f, -0.16572258f, 0.08459987f, 0.14057489f, 0.18712579f, 
    0.12449877f, 0.00626302f, 0.17480095f, -0.03715454f, 0.58935571f, 0.05293591f, 0.11361155f, 0.13230436f, 
    0.01761210f, -0.03448340f, 0.04354494f, 0.07285389f, 0.07573545f, -0.14203984f, 0.01791462f, 0.01430173f, 
    -0.80079383f, -0.32757232f, -0.19373374f, -0.31727245f, -0.09415077f, 0.02023924f, -0.07342704f, -0.06567596f, 
    0.00967980f, -0.00948347f, 0.14422156f, -0.01857766f, 0.18372974f, -0.50643080f, 0.12896198f, 0.17296758f, 
    -0.13354273f, 0.12861098f, 0.08616294f, -0.04577404f, 0.10012913f, -0.21391764f, 0.23010014f, 0.08529416f, 
    0.26113576f, -0.17608899f, -0.42399576f, 0.04432227f, -0.08272409f, 0.04356601f, 0.06188917f, -0.11954195f, 
    0.13233919f, -0.23065035f, 0.06007547f, 0.12917575f, 0.39642784f, -0.26639107f, 0.18769987f, -0.05977659f, 
    0.13735643f, 0.07163094f, 0.03130781f, -0.06448265f, -0.01937671f, 0.00594930f, 0.01349517f, 0.00158455f, 
    0.17430426f, -0.01059232f, -0.05678294f, -0.19563334f, -0.17933676f, -0.25791264f, 0.12968668f, -0.14548288f, 
    -0.10996514f, -0.04128318f, -0.02024807f, -0.00705228f, 0.12344485f, -0.02320872f, 0.13455503f, -0.01492551f, 
    -0.08020145f, 0.09754836f, -0.08067195f, -0.01026801f, -0.15395120f, 0.16211700f, -0.00281989f, 0.08611389f, 
    0.08219741f, -0.65576702f, -0.10394253f, -0.08993877f, -0.00337181f, -0.00563846f, 0.00991740f, -0.05394472f, 
    0.04417177f, 0.10311475f, -0.00343808f, -0.19894205f, 0.14813915f, 0.06356255f, 0.13463239f, -0.07740360f, 
    0.02315408f, -0.05436828f, -0.10155489f, 0.15629342f, -0.01849108f, 0.05623931f, -0.14440867f, 0.02015697f, 
    -0.10173586f, -0.27355182f, -0.03285029f, -0.23811260f, -0.14650378f, -0.03486119f, -0.04840819f, 0.02043796f, 
    -0.04513617f, -0.22789522f, 0.02805623f, 0.02354355f, -0.70398092f, -0.32570428f, 0.00162573f, -0.04990995f, 
    -0.26084012f, -0.00333469f, 0.11090412f, 0.04266752f, 0.15043706f, -0.11538319f, -0.09427393f, -0.14935687f, 
    0.06142768f, -0.15194188f, 0.02893746f, 0.07054370f, -0.07122948f, 0.01115496f, -0.03875284f, 0.22268854f, 
    -0.01924575f, 0.15617110f, -0.24020077f, -0.08396240f, -0.24337152f, 0.16758066f, 0.00985674f, 0.17429022f, 
    -0.03729447f, 0.00990338f, 0.16377331f, -0.16058987f, -0.07393084f, 0.17612843f, -0.04555024f, 0.08595397f, 
    0.20678109f, 0.23454407f, -0.19280705f, -0.40182444f, -0.00744827f, 0.03481077f, 0.03510795f, 0.04547050f, 
    0.00401217f, 0.05599593f, -0.05609199f, 0.02362504f, -0.04859235f, 0.21307983f, 0.04001524f, 0.28144181f, 
    0.08406928f, 0.09272870f, -0.19856259f, 0.03658680f, -0.00845659f, 0.01541705f, 0.08384859f, -0.07983869f, 
    0.04200836f, -0.03273485f, -0.19081131f, 0.19539349f, 0.00043977f, 0.11752795f, -0.02765518f, 0.06276219f, 
    0.14825834f, -0.00909856f, -0.19792743f, -0.01215493f, -0.50640804f, -0.10723691f, -0.07414816f, -0.11485440f, 
    0.05023494f, -0.08336516f, 0.02358429f, 0.17668344f, -0.00437358f, -0.03838599f, 0.03035131f, 0.01268488f, 
    -0.34045085f, 0.09329624f, 0.24177307f, 0.11340266f, 0.04701884f, -0.01399126f, -0.16356684f, -0.00865735f, 
    0.17277382f, -0.16325514f, 0.06363982f, -0.08593651f, -0.06621027f, 0.01837390f, 0.08642944f, 0.03368142f, 
    -0.04162821f, -0.10847023f, 0.15149942f, 0.10896709f, 0.14928824f, -0.08507238f, -0.17108549f, -0.06471766f, 
    -0.48938096f, -0.01426820f, 0.12927493f, -0.15662569f, 0.03181379f, -0.02461332f, -0.13163877f, -0.06121514f, 
    0.09062369f, -0.10276979f, -0.10737770f, -0.01324733f, -0.39011887f, -0.27941293f, 0.14360215f, 0.05303215f, 
    -0.04041240f, -0.06763744f, -0.01533737f, -0.10524444f, 0.00502710f, -0.01210585f, -0.04412686f, 0.01082260f, 
    -0.66824913f, 0.02716810f, 0.31495002f, 0.14597803f, -0.22761242f, -0.13431445f, 0.09727059f, -0.02253015f, 
    -0.02506274f, 0.03524077f, -0.04615025f, 0.01880548f, -0.25345525f, -0.30758253f, 0.05903774f, -0.14365220f, 
    -0.12784560f, 0.17438227f, -0.06320208f, -0.01720678f, 0.01187301f, 0.00597299f, -0.05542510f, -0.12034658f, 
    -0.08096713f, -0.25875697f, 0.20390390f, 0.01527710f, 0.02534167f, -0.15828073f, -0.13732424f, -0.01025498f, 
    0.11198714f, 0.01017209f, -0.11832593f, 0.12555291f, -0.12357453f, 0.21633822f, 0.27662623f, 0.25431326f, 
    0.09524260f, -0.08411732f, 0.09077732f, 0.18529333f, 0.03494287f, -0.10936250f, -0.00683314f, 0.06776997f, 
    -0.09849385f, -0.28411475f, -0.14531671f, 0.07426462f, 0.02909598f, -0.02263846f, 0.14311038f, -0.15213093f, 
    0.11536674f, -0.06872368f, -0.13600728f, -0.08495814f, -0.48896578f, 0.36841390f, -0.09884938f, -0.19389284f, 
    0.07450880f, 0.07343064f, 0.03093302f, -0.09034820f, 0.06764324f, 0.02035803f, -0.06956920f, -0.12205657f, 
    -0.09265904f, -0.15728000f, 0.25850832f, 0.04956485f, 0.09350650f, -0.03850432f, -0.20007698f, -0.12510705f, 
    -0.04829055f, -0.13702928f, 0.00179818f, 0.07138301f, 0.00098521f, 0.01513146f, -0.07159392f, -0.15677452f, 
    -0.08434384f, 0.06951187f, 0.02033075f, 0.17493083f, 0.14638864f, 0.13756178f, -0.06261457f, 0.14292125f, 
    -0.34928700f, -0.02960946f, 0.14684004f, -0.10478611f, 0.16773085f, -0.00334814f, 0.11632356f, -0.01038164f, 
    0.07300085f, 0.10171353f, -0.11747883f, 0.07416246f, -0.44711345f, -0.08420928f, 0.10873546f, 0.14449485f, 
    -0.05286639f, -0.02455881f, 0.08328459f, 0.16816898f, -0.05052583f, -0.08035523f, 0.10678550f, 0.04570967f, 
    -0.15628386f, 0.00448196f, -0.39490283f, -0.07056618f, -0.00742091f, -0.14420868f, -0.06422413f, 0.06810820f, 
    -0.16075793f, -0.06022802f, -0.17243774f, -0.12570171f, 0.44969156f, 0.24895908f, -0.39814880f, 0.03435438f, 
    -0.04149659f, 0.00352459f, -0.03318989f, 0.07849283f, -0.06301356f, -0.14285991f, -0.03493547f, 0.18371117f, 
    -0.16833508f, 0.01527237f, -0.27430782f, 0.17280340f, 0.03171832f, -0.07284930f, 0.14795157f, 0.03886221f, 
    -0.03926194f, -0.02374770f, 0.10332517f, 0.18134581f, 0.11304300f, 0.18825573f, 0.02212877f, 0.02325658f, 
    0.08809281f, -0.00975626f, 0.06598005f, 0.05643142f, 0.20052339f, 0.00553294f, 0.03719380f, -0.03693981f, 
    0.21677190f, 0.13802327f, -0.07084603f, 0.13851663f, -0.09371980f, 0.07499883f, 0.18079790f, -0.07012901f, 
    -0.06488863f, -0.06292152f, 0.09602496f, 0.02145401f, -0.48806456f, 0.00252095f, -0.12954497f, -0.05662514f, 
    0.11636043f, 0.06638314f, -0.04229553f, 0.10194117f, -0.10587614f, -0.08669266f, -0.03720612f, 0.06554601f, 
    -0.35911378f, 0.10463872f, 0.00092528f, -0.21804373f, 0.04463835f, -0.09691419f, 0.18453442f, 0.05041373f, 
    -0.10682158f, 0.03453638f, 0.08880195f, -0.05156748f, 0.01739673f, 0.31949919f, 0.03424090f, 0.25012445f, 
    -0.01048260f, 0.17274411f, 0.16741493f, -0.05588089f, -0.04953298f, 0.01079151f, 0.07529218f, -0.04380963f, 
    0.12747692f, 0.16985403f, 0.26196101f, -0.02361305f, -0.11084768f, 0.01810874f, 0.06858610f, -0.11623272f, 
    -0.06536462f, 0.02480209f, -0.11242353f, -0.04140909f, 0.46120900f, -0.21741441f, 0.14395250f, -0.16742672f, 
    0.00160892f, 0.12521437f, -0.09810486f, 0.03820207f, -0.09441096f, 0.02978353f, 0.09227700f, 0.07289724f, 
    -0.60990030f, 0.11501185f, 0.21662919f, 0.22220491f, -0.11858822f, 0.09810475f, 0.03377172f, -0.00835101f, 
    -0.03487727f, 0.11758017f, 0.21842223f, 0.08137520f, 0.32884228f, -0.07389682f, -0.25804645f, -0.00178576f, 
    0.00653789f, -0.06509066f, -0.02607471f, 0.07365919f, -0.02608031f, 0.04652350f, -0.03582683f, 0.04485916f, 
    -0.01138192f, -0.14898998f, -0.36714229f, -0.07909381f, -0.14866737f, 0.12466633f, 0.03328417f, -0.06924553f, 
    -0.05576226f, 0.00415128f, -0.02786833f, -0.08331508f, -0.37937298f, 0.36475056f, 0.05116015f, 0.03289154f, 
    0.03907459f, -0.11129216f, -0.01305121f, 0.12134849f, -0.18431768f, -0.00457426f, -0.06600460f, 0.00221378f, 
    -0.89534932f, -0.24897346f, 0.19098957f, 0.12068764f, 0.00107822f, -0.02491069f, -0.01275480f, 0.03735559f, 
    0.11157630f, 0.01012791f, 0.03718693f, -0.00919316f, -0.74292117f, -0.20484969f, -0.02097599f, -0.15708621f, 
    0.04468100f, -0.01907333f, -0.04545016f, -0.06472131f, -0.04566023f, -0.00579140f, 0.04826337f, 0.08022093f, 
    -0.23556828f, -0.69423395f, -0.17130813f, 0.20097844f, 0.15444082f, -0.08875494f, -0.10254614f, -0.04530946f, 
    -0.11392369f, -0.07003676f, 0.13217571f, 0.22133493f, -0.38734218f, 0.22744374f, -0.00539003f, 0.21398646f, 
    0.00380895f, -0.18773550f, 0.01873581f, -0.25461432f, 0.01141591f, -0.02864990f, -0.21339510f, -0.04941799f, 
    0.09278377f, -0.04607961f, 0.01569300f, 0.03830267f, -0.02736380f, -0.12850317f, 0.15751171f, -0.04270486f, 
    -0.04292198f, 0.13709813f, 0.07523167f, 0.26604363f, 0.13858323f, 0.00084799f, -0.01603387f, -0.16956291f, 
    0.08610468f, 0.04656292f, 0.08852156f, 0.01936092f, -0.01979014f, 0.17958203f, 0.13413705f, 0.29258114f, 
    0.07473321f, 0.00000317f, -0.12533236f, -0.03090830f, 0.15871598f, -0.08184254f, 0.12995654f, -0.03634425f, 
    -0.13554266f, 0.03923148f, 0.09990396f, -0.14377262f, 0.09376010f, 0.09367890f, 0.21066090f, 0.29463020f, 
    -0.10958373f, -0.03795186f, 0.02040900f, 0.09198420f, -0.11318596f, -0.02641489f, 0.01347825f, 0.15024519f, 
    0.17438494f, -0.10662358f, 0.07600692f, 0.07621213f, -0.05794791f, -0.12110969f, 0.06590168f, 0.12061696f, 
    -0.04408305f, -0.04672086f, -0.16653909f, 0.04006168f, -0.06487912f, 0.05873268f, -0.08639600f, 0.25067866f, 
    -0.03311701f, 0.01652863f, 0.21683885f, -0.00553051f, -0.08374593f, -0.11720795f, 0.09446383f, 0.00349422f, 
    0.23323478f, 0.00411406f, -0.06406844f, 0.06229703f, 0.08906893f, 0.00023388f, 0.08502658f, 0.11799088f, 
    0.09865803f, -0.02178551f, 0.16941306f, 0.06732028f, -0.20892918f, -0.20871550f, -0.32925838f, 0.11218634f, 
    0.19122779f, 0.04950244f, 0.05009601f, 0.02230846f, 0.14647894f, -0.05439755f, 0.03893672f, 0.05324374f, 
    -0.11830478f, 0.07437744f, 0.14010170f, -0.16635041f, 0.10209678f, -0.06511225f, -0.04542715f, 0.03972178f, 
    0.12569685f, 0.04012713f, 0.04294869f, -0.03152914f, -0.56694281f, 0.30639073f, -0.09529366f, -0.25091264f, 
    0.06198399f, -0.09132519f, -0.02415602f, -0.01477642f, 0.09028830f, 0.02432055f, 0.07053668f, 0.07917130f, 
    0.30570483f, -0.11737439f, -0.03705230f, 0.06911162f, -0.04801906f, -0.00782341f, -0.08529311f, -0.03276827f, 
    -0.10612587f, -0.11173858f, 0.10958537f, 0.03490317f, 0.11036186f, 0.28536630f, 0.22985496f, -0.09476978f, 
    -0.03216136f, -0.05474899f, -0.03229133f, -0.11006518f, 0.05461480f, -0.03522490f, 0.07368398f, -0.30725399f, 
    -0.04079448f, -0.15567912f, -0.00808427f, -0.09675151f, 0.06384478f, -0.00009443f, 0.02134467f, -0.07868065f, 
    0.04061317f, -0.02275203f, 0.06030759f, 0.11804640f, -0.02429852f, -0.06291781f, -0.42235899f, -0.07100078f, 
    0.11981761f, 0.28542036f, 0.09441604f, -0.04298439f, 0.00246357f, -0.01325522f, -0.31155610f, -0.02051282f, 
    -0.07744682f, 0.08366517f, 0.25854400f, 0.18640153f, -0.00992673f, 0.08655544f, -0.00055900f, -0.12903376f, 
    -0.15149015f, -0.14756246f, 0.07308058f, 0.20425695f, -0.14358157f, 0.00112755f, 0.42939699f, 0.32420474f, 
    0.03138035f, 0.09765124f, 0.02319383f, 0.12147702f, -0.07669473f, -0.03331611f, 0.22878113f, -0.25965792f, 
    -0.01556063f, 0.22573116f, 0.37454712f, -0.18187453f, 0.10702796f, 0.05223472f, -0.10736293f, -0.21810076f, 
    -0.05777475f, -0.11509641f, 0.10913881f, -0.13431479f, -0.20758457f, -0.01664669f, 0.08707840f, 0.17878444f, 
    -0.20741813f, 0.09245434f, -0.06552325f, -0.13338098f, 0.00174122f, -0.11020944f, -0.02317551f, 0.14824162f, 
    -0.00733616f, 0.16891912f, 0.04710987f, -0.25614968f, -0.05243099f, -0.04521886f, -0.01660469f, -0.11127995f, 
    -0.00679562f, -0.02843092f, 0.06508453f, 0.11783600f, -0.50867403f, 0.02945878f, -0.31305149f, -0.21208106f, 
    0.18895495f, 0.13925417f, 0.09389523f, -0.06702553f, -0.06357086f, 0.00797130f, -0.16716474f, -0.08473407f, 
    -0.40724158f, 0.04330769f, 0.24488182f, -0.19400133f, 0.05419524f, 0.01105437f, -0.18249397f, 0.11326337f, 
    0.17794436f, 0.17038605f, 0.00096903f, 0.12197512f, 0.22346248f, 0.07613750f, -0.08482932f, -0.01745743f, 
    0.00918486f, 0.03119241f, -0.29230052f, 0.14492354f, 0.06245013f, 0.02840455f, 0.11042122f, -0.11358144f, 
    -0.10430037f, 0.02561926f, 0.08017277f, -0.38640743f, -0.18182290f, -0.14487198f, -0.09274476f, 0.23181467f, 
    0.09573520f, -0.06295130f, 0.02458069f, -0.31258053f, -0.23760282f, 0.11097760f, -0.02469528f, -0.01776814f, 
    0.11692030f, -0.03227130f, 0.06237420f, -0.03449305f, 0.24669376f, -0.16577205f, -0.17960319f, 0.17688118f, 
    -0.09977160f, 0.05800231f, -0.36205304f, -0.02874246f, 0.08862399f, -0.11507103f, -0.18499765f, -0.24163574f, 
    -0.02293203f, -0.18889423f, -0.01288435f, -0.15126525f, -0.10511602f, 0.18308111f, 0.17311083f, -0.17032275f, 
    0.05983376f, -0.02519491f, 0.13132201f, 0.03539936f, 0.22739132f, -0.05961818f, -0.05274644f, 0.21511194f, 
    -0.20976590f, 0.30069858f, 0.08892252f, 0.12391154f, -0.14747667f, -0.12871072f, 0.05826884f, -0.04339628f, 
    0.04849399f, -0.09937715f, -0.11472378f, 0.01789651f, -0.26508951f, 0.04632473f, 0.07036699f, -0.43780375f, 
    -0.08319449f, 0.04289237f, 0.00265688f, 0.04353410f, -0.08139346f, -0.14089774f, 0.06037231f, -0.01632776f, 
    0.45628732f, -0.54402143f, 0.05256657f, 0.02135799f, -0.03309022f, 0.05059588f, 0.05544214f, -0.07098687f, 
    -0.08739898f, 0.02355508f, -0.05721108f, -0.02073753f, -0.56940103f, -0.20435527f, 0.00825672f, -0.14195928f, 
    -0.10590774f, 0.13486797f, 0.16823854f, -0.12251531f, -0.00695539f, -0.05924608f, -0.11422882f, -0.04738328f, 
    -0.41635245f, 0.14588240f, -0.04646595f, -0.24119036f, -0.05811060f, 0.00513654f, 0.11732138f, -0.12882410f, 
    -0.03117906f, 0.02137569f, -0.03454304f, -0.19626674f, -0.08386508f, -0.35254765f, -0.08767445f, 0.21131560f, 
    -0.11322968f, 0.16159156f, 0.15897967f, 0.09508469f, 0.01900000f, 0.04618898f, 0.17649870f, 0.18445864f, 
    0.23471995f, 0.10455710f, -0.01968118f, -0.38607976f, -0.17049623f, 0.14379762f, 0.10432135f, -0.11156884f, 
    -0.09909233f, -0.28638637f, 0.00453263f, -0.16682230f, -0.02124968f, 0.40159070f, 0.20163326f, -0.38678509f, 
    -0.24206465f, 0.03877225f, -0.05216740f, -0.01890604f, 0.16710772f, -0.11604022f, -0.07899572f, -0.13030452f, 
    -0.30911198f, 0.10462593f, 0.09329454f, 0.31555933f, -0.12354188f, 0.12810969f, 0.12038963f, 0.08481827f, 
    -0.01619747f, 0.06524712f, -0.10096835f, -0.12198226f, -0.01667190f, -0.08370882f, -0.15207747f, 0.25696826f, 
    0.04625447f, -0.00371832f, -0.05924461f, -0.01797776f, -0.03157225f, -0.21616867f, -0.16565077f, 0.15879649f, 
    0.11121202f, -0.04856249f, -0.15310980f, -0.04062083f, 0.18026496f, 0.09737318f, -0.02326323f, 0.09973214f, 
    -0.06156239f, 0.07969628f, 0.16966783f, 0.02858560f, -0.11014505f, -0.21347371f, -0.17353706f, 0.32088745f, 
    0.02726458f, -0.13544458f, -0.06130208f, -0.00241296f, 0.03987522f, 0.10003529f, 0.03894706f, -0.15143503f, 
    -0.67249811f, 0.28779227f, 0.11903719f, 0.15446115f, 0.09641712f, 0.01020033f, -0.02079201f, 0.03865838f, 
    -0.02787245f, -0.05416016f, -0.05407964f, -0.21480800f, -0.18206021f, 0.10161663f, -0.30086794f, -0.19725300f, 
    -0.18748392f, -0.07269051f, -0.11135639f, -0.18541348f, -0.16201055f, 0.01490899f, 0.14610058f, -0.02585675f, 
    0.20555887f, 0.04328692f, 0.29712769f, 0.08112833f, -0.15304266f, -0.02204045f, -0.11399696f, -0.00700301f, 
    -0.06751814f, 0.05428205f, 0.03433632f, 0.04603575f, 0.73137653f, 0.09020741f, 0.20996067f, -0.08940352f, 
    0.07577381f, 0.03407719f, 0.08228313f, 0.06115300f, -0.15420082f, 0.05688937f, -0.00371894f, -0.18124945f, 
    0.12268683f, 0.02399944f, -0.09650121f, -0.19842838f, 0.03113962f, 0.03187336f, 0.03668713f, 0.11394196f, 
    0.18396065f, -0.08688228f, -0.18115635f, -0.02770857f, 0.28180775f, -0.45259041f, 0.10677113f, -0.27510563f, 
    -0.15627931f, -0.05700828f, 0.14315087f, 0.10147827f, 0.07979214f, 0.16396430f, 0.05457621f, 0.09083599f, 
    0.06530415f, 0.12681271f, -0.05938422f, -0.08117007f, 0.05468997f, -0.02077443f, 0.00382061f, -0.01436692f, 
    -0.08516133f, -0.09916972f, -0.09853189f, 0.07492253f, -0.18945135f, 0.02771625f, -0.14569788f, -0.03005951f, 
    0.07550915f, -0.01767266f, -0.04413002f, -0.07103822f, 0.03134307f, -0.04254199f, 0.20387428f, -0.02503111f, 
    -0.09916578f, 0.04447773f, 0.22083807f, -0.23276038f, -0.10471059f, -0.09397686f, 0.19352315f, 0.01476412f, 
    -0.02327627f, 0.14982481f, -0.07259338f, -0.16294830f, -0.17734283f, -0.03362758f, 0.09132771f, -0.05120935f, 
    0.00146609f, 0.14405534f, -0.02117595f, 0.14161044f, 0.06872020f, -0.00903370f, -0.05014789f, 0.05762874f, 
    -0.37548399f, -0.17865463f, 0.13104710f, -0.13306350f, -0.15775754f, -0.10353784f, -0.08627947f, 0.09811734f, 
    -0.01049153f, -0.06825604f, -0.14551145f, 0.13207482f, 0.22418758f, -0.04036888f, 0.14681821f, -0.53339392f, 
    0.11514278f, 0.03671141f, 0.14625119f, 0.04711490f, -0.04947697f, 0.22277413f, -0.09004486f, 0.07937877f, 
    -0.26982033f, 0.19948366f, 0.13146439f, -0.24284640f, -0.09581258f, 0.09871154f, -0.02304614f, 0.04073637f, 
    0.09138373f, 0.03891370f, -0.16034658f, -0.12198102f, -0.00362540f, -0.36502269f, 0.12721810f, -0.22804390f, 
    0.11657277f, -0.08110355f, 0.02690334f, -0.13910693f, 0.06523137f, -0.07609218f, 0.23986040f, 0.11056080f, 
    0.02049604f, -0.12985739f, 0.04880700f, 0.32237327f, 0.00691440f, -0.03110730f, 0.10451081f, 0.12685482f, 
    0.14382796f, -0.04961374f, -0.25335225f, -0.22682890f, 0.02307144f, -0.26769441f, -0.47149250f, 0.25896955f, 
    -0.04524625f, -0.11109912f, 0.23180611f, -0.07390946f, 0.08980680f, -0.10173122f, -0.06087628f, 0.04766751f, 
    0.23770750f, -0.10475972f, 0.11255302f, -0.26901197f, 0.09946489f, -0.16109473f, -0.10135137f, 0.00885647f, 
    -0.21504949f, 0.16500393f, 0.00131236f, 0.13778412f, -0.11680951f, -0.05125742f, -0.19820721f, -0.02261166f, 
    -0.16852041f, -0.10695443f, -0.04828679f, -0.02084645f, -0.12207242f, 0.04318241f, 0.08954191f, -0.10819335f, 
    -0.14920722f, -0.36547771f, -0.12881166f, -0.18415333f, -0.09117712f, 0.08479314f, -0.03878380f, -0.01209087f, 
    0.11370987f, 0.10195874f, 0.06780270f, 0.23442595f, -0.22607990f, 0.02736866f, 0.08065187f, -0.15584892f, 
    -0.02150917f, -0.00019850f, 0.07341858f, 0.07249741f, -0.04901189f, 0.16505192f, 0.26440471f, -0.17843837f, 
    0.08624236f, -0.07449426f, -0.39966342f, 0.28240871f, 0.07543156f, 0.08075345f, -0.11502297f, -0.07682168f, 
    0.11855559f, 0.00075530f, -0.03421927f, -0.04738191f, 0.63456690f, -0.03292233f, 0.14373882f, 0.05333496f, 
    -0.04391106f, -0.08247340f, 0.12839191f, -0.03033917f, 0.24126855f, -0.08654499f, 0.22442012f, 0.02571216f, 
    0.19539884f, -0.12475068f, 0.10190541f, 0.14913690f, 0.15692690f, -0.06074746f, 0.09265338f, -0.07669429f, 
    -0.01061638f, 0.10491025f, 0.05577509f, -0.05746606f, 0.04854700f, 0.20297764f, 0.23064873f, -0.04122368f, 
    0.08528440f, -0.01902549f, 0.11464889f, -0.06919897f, 0.01201688f, 0.02417773f, 0.06873181f, -0.10736552f, 
    0.21188292f, 0.16417547f, 0.11736209f, 0.20595545f, -0.03794254f, -0.02517124f, -0.10103502f, -0.00695361f, 
    -0.08807583f, 0.02523368f, -0.07201046f, -0.07609348f, -0.01295941f, -0.00446630f, -0.06268233f, -0.01522136f, 
    -0.07508457f, -0.05775625f, -0.08172873f, 0.03410722f, 0.02706551f, -0.15482679f, -0.19889192f, -0.01809428f, 
    -0.47003287f, 0.04486300f, -0.37072176f, 0.02746651f, -0.05551172f, -0.01884570f, -0.05432227f, -0.00683743f, 
    0.01266264f, 0.02143421f, 0.00147391f, -0.04698369f, -0.61293024f, 0.10258806f, -0.23643011f, -0.11665798f, 
    -0.04376854f, 0.01815372f, 0.05659482f, -0.05462610f, -0.02160498f, 0.08383393f, 0.06226577f, -0.00184725f, 
    -0.31729630f, 0.11514790f, 0.02279735f, -0.05420350f, -0.11201364f, 0.05067264f, 0.06683639f, -0.04766123f, 
    -0.05608650f, 0.01644431f, -0.05790890f, -0.10245906f, -0.05644724f, -0.03119222f, -0.05676991f, 0.11165107f, 
    -0.15124585f, -0.21798347f, -0.17143124f, -0.01828321f, -0.05353815f, -0.01684809f, -0.02461915f, -0.15310097f, 
    0.11064347f, -0.53810960f, 0.01478538f, -0.07979035f, 0.08952085f, -0.06481477f, -0.00642795f, -0.00224425f, 
    -0.09681765f, 0.03628987f, -0.05992001f, 0.02167702f, -0.16752647f, -0.33784488f, -0.24377957f, 0.07623669f, 
    -0.14317933f, -0.06539367f, -0.12472447f, -0.08462072f, -0.14143056f, -0.02156162f, -0.04012754f, -0.09977201f, 
    -0.18436912f, -0.11774578f, -0.14822443f, -0.38000566f, -0.02825163f, -0.12890160f, -0.05088509f, -0.08436736f, 
    -0.02532828f, 0.05193277f, 0.06931092f, 0.11554859f, 0.11475726f, 0.16269095f, 0.29128107f, 0.17878163f, 
    0.19398135f, 0.05734438f, -0.05635975f, -0.03889544f, 0.00149433f, -0.10934138f, -0.04790663f, -0.07779197f, 
    -0.25614789f, -0.11017738f, -0.17379273f, 0.04673924f, -0.09502134f, -0.01994628f, -0.03747893f, 0.02379081f, 
    -0.20922707f, -0.03572513f, -0.06163619f, -0.11532266f, 0.54339617f, 0.01101035f, -0.07594009f, -0.12621434f, 
    -0.02544363f, 0.04073774f, -0.05845115f, -0.00615358f, -0.08272944f, 0.03551905f, -0.06042914f, -0.03421804f, 
    0.20968781f, -0.22425996f, 0.09635404f, 0.08731960f, -0.09170331f, -0.00823089f, -0.04722624f, -0.02619246f, 
    -0.13794990f, 0.05899090f, -0.06799942f, -0.06227596f, 0.07547331f, 0.04340268f, 0.10316588f, 0.15595224f, 
    -0.08324389f, -0.06632892f, -0.04296201f, -0.01981252f, -0.04090863f, 0.01495306f, 0.04717762f, -0.13513668f, 
    0.10128920f, -0.03522441f, 0.25200328f, 0.04143365f, -0.18873616f, -0.08338304f, -0.05464375f, -0.06887147f, 
    -0.00654723f, 0.03746324f, -0.10382138f, 0.00663986f, 0.06789920f, 0.21106140f, 0.19701895f, 0.15278830f, 
    -0.04626266f, 0.00052740f, 0.00140220f, 0.01100831f, -0.03239028f, 0.04445694f, 0.03790389f, -0.07375423f, 
    -0.24325049f, 0.04535623f, -0.09757038f, 0.14305572f, 0.13412991f, -0.04248863f, 0.07645049f, -0.04064765f, 
    -0.07182734f, -0.01346373f, -0.03311466f, -0.07940331f, 0.10562339f, 0.16040289f, 0.04630928f, 0.29191819f, 
    -0.01680604f, 0.00761397f, -0.03240910f, -0.17851745f, -0.04582669f, -0.03093320f, -0.02229635f, -0.08310017f, 
    0.10256872f, 0.05121036f, -0.14390504f, -0.03166409f, -0.12488807f, 0.04257238f, -0.01790911f, -0.17289233f, 
    0.02962161f, 0.01194560f, -0.06924974f, -0.08627216f, 0.08945414f, 0.11995594f, -0.01499678f, 0.18743484f, 
    -0.08711787f, -0.01215429f, -0.04210009f, -0.05654189f, -0.00608894f, -0.00167188f, -0.00427948f, -0.04520391f, 
    -0.48614433f, 0.30337906f, -0.03935147f, -0.22947907f, -0.09381647f, 0.03798043f, -0.03972559f, -0.05738873f, 
    -0.10174190f, 0.08864330f, -0.02947865f, -0.06144302f, 0.31920874f, 0.03339700f, 0.25104299f, -0.03684632f, 
    0.02697999f, -0.02001390f, -0.10723243f, 0.07010137f, 0.00881447f, 0.15205497f, -0.11068607f, -0.03358323f, 
    0.09588481f, -0.04084987f, 0.17297322f, -0.05355489f, -0.01047168f, -0.01851437f, 0.06543551f, 0.02719534f, 
    0.02288788f, 0.02551891f, -0.02304547f, -0.10872830f, 0.06651028f, 0.16852035f, -0.11024208f, 0.18513386f, 
    -0.01543809f, 0.03772284f, 0.03464871f, -0.05369403f, -0.09090202f, 0.00148711f, -0.05430198f, -0.04076991f, 
    0.13164169f, 0.10303186f, -0.07192556f, -0.24785894f, -0.09131879f, 0.00243670f, 0.00099412f, -0.15209262f, 
    -0.04410557f, -0.06996229f, -0.01363043f, -0.10382920f, 0.18060106f, 0.16211468f, 0.23661706f, 0.33719113f, 
    0.17173925f, 0.08054452f, 0.02787204f, -0.00493706f, -0.09935965f, -0.06017603f, 0.00301155f, -0.22803991f, 
    0.04254627f, 0.31004012f, 0.01000541f, 0.09316293f, 0.13372920f, 0.15079652f, 0.14888814f, -0.03571732f, 
    -0.11027257f, 0.05395979f, 0.01446930f, -0.01178929f, -0.17492154f, 0.12613153f, 0.00444085f, -0.08077092f, 
    -0.14241359f, -0.02511583f, -0.04934040f, -0.09369979f, 0.02391687f, 0.00168093f, -0.03036480f, -0.04693575f, 
    -0.24993873f, 0.25354928f, -0.27133322f, 0.17746428f, 0.03439241f, -0.06228748f, -0.17357165f, -0.06438626f, 
    0.04333035f, 0.00910658f, 0.10363486f, -0.10386724f, 0.10526419f, -0.20659326f, -0.06017608f, -0.19261175f, 
    0.09592905f, 0.01373536f, -0.12874520f, -0.06171301f, -0.14111578f, -0.00873024f, 0.03899013f, 0.07225991f, 
    0.11295196f, -0.23098694f, 0.03679140f, -0.03079396f, -0.08075176f, 0.03782467f, -0.00129934f, -0.00061491f, 
    0.01124669f, -0.08586472f, -0.12848200f, -0.02453820f, -0.22203016f, 0.18832895f, 0.22246720f, 0.20184596f, 
    -0.18734112f, 0.06518958f, -0.34090051f, 0.02447006f, 0.03481504f, 0.10111966f, 0.11892294f, -0.00479247f, 
    -0.31278419f, 0.33563367f, 0.22617158f, -0.14960749f, -0.09109250f, -0.24143521f, 0.08514977f, 0.15089181f, 
    0.05447322f, 0.12397370f, 0.12149650f, 0.10176603f, 0.03298175f, 0.21945424f, 0.17538381f, -0.06248986f, 
    -0.16076624f, -0.12381897f, -0.14905553f, -0.20631163f, -0.04531144f, -0.02015510f, -0.10039572f, -0.04551406f, 
    -0.21678403f, -0.18784328f, -0.01075102f, 0.12088753f, -0.04407097f, -0.00533310f, 0.01950397f, 0.04953221f, 
    0.14242338f, 0.12815346f, -0.01065760f, 0.03286008f, -0.12617509f, -0.10357321f, 0.11046957f, 0.17739195f, 
    0.10881601f, 0.04402697f, -0.02594231f, -0.10319449f, -0.12368666f, -0.01839531f, 0.17266877f, 0.18003349f, 
    0.30464700f, 0.08820687f, -0.39183921f, 0.02258122f, 0.13786823f, -0.06574091f, -0.04053099f, -0.13690057f, 
    0.02692868f, -0.13653651f, -0.05130329f, 0.06616319f, -0.13883659f, 0.02890618f, -0.47062355f, -0.34550920f, 
    0.03880252f, -0.10864659f, -0.05115054f, 0.09166986f, 0.17973001f, 0.02954758f, 0.04727514f, -0.01152307f, 
    0.04096318f, -0.05506139f, -0.32314992f, 0.16150762f, 0.04270454f, 0.04273248f, 0.08522165f, -0.03686324f, 
    0.22943799f, 0.05764770f, 0.02589461f, 0.05920213f, 0.44715318f, 0.05905906f, -0.43713951f, -0.06746746f, 
    0.06881822f, 0.02324911f, -0.02397037f, -0.02034997f, 0.04538869f, -0.01380200f, 0.09789574f, 0.09730902f, 
    0.09514463f, 0.10013146f, -0.07465889f, -0.04063005f, 0.05686224f, 0.12487332f, 0.00549213f, 0.11676563f, 
    0.07315495f, -0.18837792f, 0.04628417f, -0.22511572f, -0.32596391f, 0.13249236f, 0.10152461f, -0.06629384f, 
    0.00002396f, 0.10805697f, -0.03441855f, -0.09370504f, 0.06513289f, 0.04883910f, -0.02392667f, -0.03017001f, 
    -0.34851739f, 0.22364236f, -0.27143288f, -0.17794944f, -0.22222055f, -0.06231730f, -0.08144422f, -0.23595275f, 
    0.09975463f, -0.08007632f, 0.03176737f, 0.10225218f, -0.23675716f, -0.12045556f, 0.04290511f, 0.04035936f, 
    0.11009965f, -0.17217699f, 0.07137613f, -0.10703344f, 0.12425052f, -0.04148447f, 0.10411489f, 0.06798358f, 
    -0.26501647f, -0.14433780f, -0.03706162f, -0.24690129f, -0.11477444f, -0.04291124f, 0.04656194f, -0.13279021f, 
    0.04101300f, -0.04497959f, 0.11213613f, -0.12321430f, -0.07864217f, -0.13474722f, -0.01309164f, 0.16014713f, 
    0.08601790f, -0.17431128f, 0.04135258f, -0.04952753f, 0.01019412f, 0.02041515f, -0.02175654f, 0.10693550f, 
    -0.22802241f, 0.11402471f, -0.03909576f, -0.13888887f, -0.05488173f, 0.01151411f, -0.10832557f, -0.19103253f, 
    0.04374795f, -0.00938287f, 0.11247486f, 0.15151739f, -0.12965703f, 0.33310246f, 0.00483971f, 0.00903502f, 
    -0.07131797f, 0.06725184f, -0.07315268f, 0.03179960f, 0.00004711f, 0.00644251f, -0.29867697f, -0.15420657f, 
    0.04004522f, -0.05832399f, -0.09929860f, 0.10284566f, 0.17021385f, -0.04645795f, -0.14916851f, -0.04305659f, 
    -0.04485621f, 0.08886543f, 0.14511904f, 0.00238308f, -0.22736026f, -0.06167454f, 0.05150462f, -0.21145706f, 
    -0.03660850f, -0.11858121f, -0.28744665f, 0.05244995f, 0.08172768f, 0.08766789f, 0.02617203f, -0.25862461f, 
    0.31395927f, 0.22442347f, 0.03059865f, 0.12876451f, -0.10088079f, -0.05982876f, -0.07523345f, -0.14706130f, 
    -0.22110781f, 0.00431125f, 0.05497535f, -0.24636211f, -0.30415177f, 0.08514975f, 0.01742375f, 0.17932461f, 
    -0.05465382f, -0.10466164f, -0.03204305f, -0.06659221f, 0.17782533f, 0.04967058f, 0.03652091f, -0.14503765f, 
    0.17738019f, -0.19595481f, 0.17455366f, 0.27116588f, 0.10645211f, -0.06650765f, 0.03938113f, -0.06515568f, 
    0.08470721f, 0.00666986f, 0.17700104f, -0.20581645f, -0.00339663f, -0.30990475f, 0.23608340f, -0.31255814f, 
    -0.03854986f, -0.10820024f, 0.08695153f, -0.08972035f, 0.01752510f, 0.02011398f, -0.10290808f, 0.05587304f, 
    -0.19539957f, -0.21639322f, -0.16445114f, -0.28212285f, -0.35636827f, -0.11941919f, 0.12731335f, -0.24705110f, 
    0.03447645f, 0.18939257f, -0.00336364f, 0.14909075f, -0.14215891f, 0.34515280f, -0.26252764f, -0.26443428f, 
    -0.07446617f, 0.09405966f, -0.29004759f, 0.07694201f, 0.14953801f, -0.04105561f, 0.00149126f, -0.19947203f, 
    0.12299041f, -0.08257616f, -0.07077879f, 0.01430299f, 0.09108678f, -0.04653145f, -0.00883230f, 0.09542516f, 
    0.09304561f, -0.08582301f, -0.07921104f, -0.12704974f, -0.03210259f, -0.15007828f, 0.00203687f, -0.34145328f, 
    0.04336963f, -0.06706437f, 0.09498574f, -0.11206686f, 0.01990120f, -0.28278255f, -0.17995578f, 0.26108137f, 
    0.04378388f, 0.11591263f, 0.02073011f, 0.13357320f, -0.07449006f, -0.19866320f, -0.09477559f, 0.00024501f, 
    -0.14305088f, -0.01885243f, -0.15090215f, -0.09358720f, 0.33988369f, -0.00754539f, 0.15657006f, 0.23538454f, 
    0.11549231f, -0.03680242f, -0.08785798f, -0.07488260f, -0.05063969f, 0.03076504f, 0.01597372f, -0.06148650f, 
    -0.04656911f, 0.42377475f, -0.27061075f, -0.12887938f, 0.08689610f, 0.04103634f, -0.16919725f, -0.10738653f, 
    0.05649498f, -0.07639182f, 0.02300369f, 0.18216558f, -0.04115203f, -0.29127312f, 0.03822111f, 0.03853271f, 
    0.14890960f, 0.00654443f, -0.04912594f, 0.05924656f, 0.02402086f, -0.09856065f, -0.02437067f, -0.00544155f, 
    0.30721766f, -0.21123950f, -0.03748374f, 0.44620085f, 0.20825309f, 0.14220627f, -0.10203008f, -0.05409681f, 
    -0.13077170f, -0.01735160f, 0.06997168f, 0.09671126f, -0.25415078f, -0.62303048f, -0.01456220f, -0.18067436f, 
    0.03385421f, -0.04285310f, 0.01276516f, -0.03063599f, 0.00572936f, 0.06702962f, 0.07206506f, -0.05612848f, 
    -0.10782400f, -0.08234423f, 0.11619952f, 0.02142417f, -0.09695533f, -0.03863794f, -0.12878472f, 0.06303928f, 
    -0.08640304f, -0.09386428f, 0.02447498f, -0.14336099f, 0.96857995f, -0.10483722f, -0.16743793f, -0.22165297f, 
    0.00827880f, -0.06489072f, -0.01604212f, 0.06313769f, 0.02905383f, -0.02851840f, 0.06535859f, 0.19537339f, 
    -0.07126206f, 0.20936917f, -0.19996051f, -0.52640164f, -0.00665545f, -0.05049042f, 0.00323706f, 0.13819145f, 
    -0.11179772f, -0.00982303f, -0.03244815f, -0.15568709f, -0.37588489f, 0.43974045f, -0.00454639f, -0.31119940f, 
    0.12767483f, -0.07538834f, -0.05947632f, -0.17840976f, -0.10344405f, -0.02698627f, -0.02275330f, -0.31703070f, 
    -0.22553115f, 0.27654791f, 0.17252067f, 0.08861391f, 0.09154399f, 0.05810257f, 0.12097525f, 0.06144343f, 
    0.24071555f, 0.00399340f, 0.05144440f, 0.06321327f, -0.13633499f, -0.01114898f, 0.20337440f, -0.32838371f, 
    0.02277538f, -0.00857844f, 0.00567019f, -0.04070880f, -0.03555568f, 0.04825085f, -0.04016655f, -0.12749298f, 
    0.15349573f, -0.26037326f, 0.09493351f, -0.46265864f, -0.04109896f, 0.08253033f, -0.03791885f, -0.02097928f, 
    -0.04561922f, -0.15833193f, 0.02831924f, -0.05620885f, 0.26763803f, 0.11234822f, 0.23855095f, -0.20638208f, 
    0.01174299f, 0.12353440f, -0.01247306f, -0.05384901f, -0.11592865f, 0.05636450f, -0.08299851f, 0.11654387f, 
    0.40008730f, -0.08684997f, 0.21180448f, 0.06000692f, -0.05817610f, 0.22530667f, -0.17152199f, -0.32176176f, 
    -0.05806864f, 0.07655341f, -0.05045275f, 0.07644849f, -0.24396329f, -0.58717304f, -0.14474212f, -0.04381799f, 
    -0.00763175f, -0.04747041f, 0.00390904f, 0.01802997f, -0.05293019f, -0.10574562f, -0.29534298f, 0.07598928f, 
    -0.15202482f, 0.37634781f, -0.37520429f, 0.26458955f, -0.04160257f, 0.10520826f, 0.09122452f, -0.16696812f, 
    -0.00395985f, 0.09988102f, 0.14860602f, -0.03209974f, -0.14779446f, -0.04019739f, -0.06851128f, -0.20168124f, 
    0.13746727f, -0.14102317f, -0.01907160f, -0.00177232f, -0.00462658f, -0.16978282f, -0.01198841f, 0.11090391f, 
    -0.15435918f, -0.04761675f, -0.17535159f, -0.02440805f, -0.18172278f, -0.03697772f, 0.15828329f, -0.12216803f, 
    0.01883374f, 0.23745129f, -0.09434346f, 0.08079949f, -0.05673596f, 0.15853745f, 0.08395058f, 0.12457439f, 
    0.04375127f, 0.00636650f, -0.07623558f, -0.06741299f, 0.09538516f, -0.06625239f, 0.09621110f, 0.07982641f, 
    -0.18994653f, -0.31053638f, -0.11373787f, 0.16741617f, -0.02192003f, 0.00224007f, 0.04134797f, -0.12818708f, 
    0.07043875f, 0.14171737f, 0.06991003f, -0.16100642f, -0.08881511f, 0.04990005f, 0.10051717f, 0.19519846f, 
    -0.03563729f, -0.10785176f, -0.07046217f, 0.12967223f, -0.06798056f, 0.14240381f, -0.02954391f, 0.10908951f, 
    -0.08326492f, -0.04808034f, -0.03179174f, -0.12137389f, 0.01490844f, 0.08334545f, 0.02372530f, -0.09763114f, 
    0.08390507f, 0.03093770f, 0.15402053f, 0.04654922f, -0.25158507f, -0.30708262f, -0.10166767f, -0.40556568f, 
    -0.06167615f, -0.01870308f, -0.03359198f, -0.03855202f, -0.03867263f, -0.24714991f, 0.08598617f, 0.15266050f, 
    -0.30225298f, 0.31702772f, -0.19283156f, 0.11138408f, 0.19532265f, 0.09837071f, -0.00230203f, -0.05403531f, 
    0.04640559f, -0.04137161f, -0.00809141f, -0.07902937f, 0.18893632f, 0.10330091f, -0.32367739f, -0.11878538f, 
    0.02255012f, -0.26414436f, 0.11190258f, 0.11293086f, -0.03360513f, 0.15964946f, -0.08848674f, 0.10478563f, 
    -0.63901424f, 0.34074870f, 0.04965526f, -0.27341017f, 0.16260420f, 0.05634709f, 0.02120291f, 0.03558966f, 
    -0.06668089f, -0.04229186f, -0.11727964f, 0.07636018f, 0.20327951f, 0.21082467f, -0.26669767f, 0.24051403f, 
    -0.07560603f, -0.00121511f, 0.04484939f, -0.02062264f, -0.01977646f, 0.15853396f, 0.07255494f, -0.08706665f, 
    0.20463082f, 0.13750230f, -0.17590959f, 0.16165049f, 0.07180274f, 0.06239452f, 0.09850477f, -0.02833884f, 
    -0.21345088f, -0.36514986f, -0.11023115f, -0.12146115f, -0.40649465f, 0.25288960f, 0.29695082f, -0.02983578f, 
    0.14318392f, -0.12423457f, -0.01728890f, 0.01850899f, -0.07014060f, 0.04377509f, -0.00164572f, 0.04318034f, 
    -0.69974571f, -0.05016395f, -0.26605719f, -0.08384090f, 0.09711926f, 0.06327675f, 0.10021542f, -0.09941409f, 
    -0.16105543f, 0.03606926f, 0.04778810f, 0.09298171f, 0.30339527f, -0.02155707f, 0.01896603f, -0.15029655f, 
    0.29449472f, -0.12872688f, 0.10764630f, 0.03356265f, -0.04300043f, 0.17694737f, 0.25965676f, -0.01393003f, 
    -0.38370252f, -0.13463333f, -0.01107686f, 0.09958924f, 0.22879824f, 0.12085813f, 0.03067022f, 0.07607441f, 
    0.03948814f, 0.07718695f, -0.02812785f, 0.01853603f, -0.14175117f, 0.17363390f, -0.34575579f, -0.21161097f, 
    0.12490284f, 0.06460571f, -0.05896499f, -0.08730834f, -0.01159398f, -0.09131826f, -0.15621376f, -0.09045050f, 
    0.06298643f, 0.15476003f, 0.44778004f, 0.25646421f, -0.10633691f, 0.02192212f, -0.12117066f, 0.12570772f, 
    -0.02859262f, 0.02943465f, 0.01189433f, -0.02658426f, -0.27169245f, -0.05912865f, -0.10192900f, 0.03172983f, 
    0.03790518f, -0.00866016f, 0.03441948f, -0.08184291f, 0.11370680f, 0.13546948f, -0.04890402f, 0.17801236f, 
    0.04498105f, 0.14356606f, -0.18615104f, 0.04206758f, -0.17715997f, -0.02987206f, 0.06881645f, -0.02739666f, 
    0.00281990f, -0.06372040f, 0.08612031f, -0.15421411f, 0.18612850f, 0.11796953f, -0.00307083f, -0.02257431f, 
    0.09098535f, -0.12272284f, 0.02084502f, 0.08612113f, -0.02342924f, 0.04772082f, -0.05932758f, 0.23235463f, 
    0.20744827f, 0.02500794f, 0.13212585f, -0.17594245f, 0.17088169f, 0.05842050f, 0.18290621f, -0.08192553f, 
    0.15865418f, 0.07695270f, -0.00550663f, 0.10440652f, -0.07244554f, 0.10238274f, 0.29581305f, 0.15589456f, 
    0.08491194f, 0.08330287f, 0.02310050f, -0.04979327f, 0.05639603f, -0.04605767f, -0.12115805f, 0.01377639f, 
    0.19820936f, 0.14389534f, -0.02646455f, -0.23910530f, 0.09801813f, -0.16242698f, 0.14796996f, 0.11654607f, 
    0.05743151f, 0.04440136f, 0.04976783f, 0.11499416f, -0.60735708f, -0.39945576f, -0.20188195f, -0.29857507f, 
    -0.02302247f, 0.03324884f, -0.01548006f, 0.05999779f, 0.07299118f, 0.15196846f, 0.16249211f, 0.27894619f, 
    -0.78985977f, -0.19175477f, -0.02390666f, 0.11812266f, 0.11717802f, -0.03644236f, 0.17094505f, -0.11885890f, 
    0.14938462f, 0.04526113f, -0.02967100f, 0.14088884f, 0.27888665f, 0.12727611f, 0.14869155f, -0.00610685f, 
    0.00392640f, 0.07743174f, -0.04716299f, 0.11578211f, 0.04351299f, 0.02744403f, 0.10082022f, 0.06361651f, 
    -0.30519193f, 0.30895108f, -0.23911534f, -0.13717093f, 0.01224201f, 0.09184723f, -0.00679250f, 0.04210190f, 
    0.15140817f, 0.10068232f, -0.11182046f, 0.10301488f, -0.58185047f, -0.45857316f, 0.25056642f, -0.07813180f, 
    0.03727993f, 0.00985584f, -0.08756021f, 0.10876110f, 0.04062999f, 0.00486474f, -0.01200812f, 0.05169982f, 
    -0.87660909f, -0.07242421f, 0.18559088f, 0.25817356f, 0.21479529f, -0.00034911f, 0.10836335f, -0.03603818f, 
    0.02378400f, 0.10966124f, 0.03895684f, 0.11467032f, 0.30982956f, 0.01638161f, -0.08908961f, -0.08233152f, 
    -0.21116142f, 0.09205586f, -0.09729242f, -0.03875204f, -0.09564198f, 0.06354669f, 0.08925901f, -0.06772035f, 
    -0.07996681f, -0.36758307f, 0.20238626f, 0.13877867f, 0.04018791f, -0.21167532f, 0.06431603f, 0.07178330f, 
    0.07514013f, 0.03497327f, 0.16085912f, 0.07494641f, -0.47459894f, -0.34296635f, -0.14287968f, 0.01287815f, 
    0.04071880f, -0.15455340f, -0.06995223f, -0.04295416f, -0.15456666f, 0.12561554f, 0.12407633f, 0.07098571f, 
    0.34282869f, 0.18803576f, 0.10117210f, -0.14646083f, -0.08945213f, 0.07900704f, 0.04397637f, 0.21788345f, 
    -0.06163789f, 0.02484228f, 0.13364407f, -0.08363331f, -0.13529389f, 0.23934709f, 0.00162013f, 0.11709015f, 
    0.09629712f, -0.14396322f, -0.09200921f, -0.12458719f, -0.23545617f, -0.20599444f, -0.27472880f, -0.22562011f, 
    0.32383364f, 0.11183611f, -0.10715169f, -0.02080550f, 0.01963716f, 0.05521272f, 0.01119164f, 0.09695250f, 
    -0.10383354f, -0.15280311f, 0.03851763f, -0.03966475f, 0.22539227f, -0.06786432f, 0.00854276f, -0.12047490f, 
    -0.30669263f, 0.05215858f, 0.07420204f, -0.11204420f, 0.11396328f, -0.17862022f, -0.10451390f, -0.14729981f, 
    -0.30244878f, -0.37534675f, -0.11195104f, -0.30769479f, 0.09537090f, -0.01982278f, -0.24019293f, -0.15154201f, 
    0.06538369f, 0.03864508f, -0.03538935f, 0.00716526f, -0.33520216f, 0.19924480f, 0.00099943f, -0.13078330f, 
    0.22908199f, -0.07678862f, -0.11673546f, 0.13768329f, 0.08006286f, 0.22602071f, -0.02707081f, -0.02969478f, 
    0.12861033f, -0.14863050f, -0.18213059f, -0.13744220f, -0.08780711f, 0.11554095f, 0.05669670f, 0.06896634f, 
    -0.02858382f, 0.02608952f, -0.08688232f, -0.06609897f, -0.34618458f, -0.04587032f, 0.04626558f, -0.20172517f, 
    0.00581817f, -0.10436244f, -0.09552121f, 0.03592078f, -0.11075768f, 0.17080069f, -0.19264887f, -0.26182055f, 
    -0.82628137f, -0.67467618f, -0.02366061f, -0.18673369f, 0.09054161f, -0.11265823f, -0.01747342f, 0.06914128f, 
    0.17164738f, 0.15750413f, 0.04033222f, -0.02545733f, 0.19908488f, 0.05968484f, -0.00124814f, -0.06167984f, 
    0.03470898f, -0.06861357f, -0.05162033f, 0.03221863f, -0.03072605f, 0.01364501f, -0.13998556f, 0.06480162f, 
    0.18583901f, -0.10776317f, 0.05655882f, 0.19667229f, -0.09298991f, 0.11763877f, -0.06382608f, 0.10689113f, 
    -0.08623672f, 0.17760538f, 0.00516552f, 0.15476041f, -0.28738338f, -0.23386484f, 0.00975511f, -0.07173016f, 
    -0.09037422f, 0.17495941f, -0.08361357f, -0.12471732f, 0.17493823f, -0.17344256f, -0.09089913f, -0.05876489f, 
    -0.49904531f, -0.30122897f, -0.05347421f, -0.05668310f, -0.06442986f, 0.12542340f, 0.06244094f, 0.03308745f, 
    0.10490593f, 0.07186126f, 0.03022702f, 0.21715499f, -0.17654689f, 0.25463995f, 0.18514232f, 0.11050128f, 
    0.07419632f, 0.12331626f, -0.02341256f, -0.15702716f, -0.05604187f, -0.14243585f, 0.06785715f, 0.06648163f, 
    0.35413611f, 0.11181714f, -0.11455438f, -0.06128524f, -0.21855845f, -0.24407843f, 0.18132165f, -0.05175264f, 
    0.02079483f, -0.10213418f, -0.22344929f, -0.07811476f, -0.23215169f, -0.18449563f, -0.36455950f, -0.28900415f, 
    0.12698068f, 0.02163640f, -0.06792552f, 0.01284540f, -0.08485567f, 0.02007117f, 0.12292734f, 0.12756637f, 
    -0.36515963f, -0.24985471f, 0.04250082f, 0.15963468f, 0.08354688f, 0.18380433f, 0.01752381f, -0.10427172f, 
    0.15660362f, -0.03338301f, -0.00077381f, 0.05346768f, 0.17017950f, -0.09428548f, -0.09551831f, 0.01994327f, 
    0.04842238f, 0.07988348f, -0.13842469f, 0.05427669f, -0.02069445f, -0.14651999f, -0.16305079f, -0.07717885f, 
    -0.42816937f, 0.02979226f, 0.07862383f, -0.08373615f, -0.10992958f, 0.03065087f, -0.13848557f, -0.06548209f, 
    -0.14821094f, 0.03455092f, 0.21123964f, 0.14106396f, 0.20232044f, 0.20903775f, -0.00960864f, -0.04012179f, 
    0.02641932f, 0.04179793f, 0.07010894f, -0.03788140f, 0.00892010f, 0.05339663f, -0.17813210f, -0.17281334f, 
    0.06341726f, 0.08494473f, -0.14642662f, -0.23462790f, -0.03116600f, -0.02232164f, -0.06637918f, 0.08164558f, 
    -0.03413467f, 0.06998800f, 0.07571895f, 0.02488245f, -0.40438491f, -0.16704881f, -0.04508604f, -0.14550038f, 
    0.02707549f, -0.18664865f, -0.03328399f, 0.19254743f, -0.06317282f, -0.03882511f, 0.11005188f, 0.01609860f, 
    0.25028497f, -0.33408302f, -0.16888480f, 0.18008436f, -0.00012833f, -0.07725535f, 0.04013645f, 0.15821046f, 
    -0.00829720f, 0.06599414f, 0.07336652f, -0.13245086f, 0.38597971f, 0.03533508f, -0.22763875f, 0.15879942f, 
    -0.02015959f, 0.06735696f, -0.06153757f, 0.02106921f, -0.11309234f, -0.02017684f, -0.04565924f, -0.09854525f, 
    0.41188082f, -0.09398512f, 0.14594869f, 0.13738827f, 0.13206662f, -0.08579234f, -0.23434076f, -0.04776255f, 
    0.05291352f, 0.08253466f, -0.04696028f, 0.10016501f, 0.26422283f, 0.25011712f, -0.28234950f, 0.20814115f, 
    0.10023211f, -0.00109144f, 0.04911590f, -0.00223987f, 0.10309306f, 0.08849394f, 0.02940312f, -0.17300205f, 
    0.70874625f, 0.18783189f, -0.40932572f, 0.17894770f, -0.03495369f, -0.06130308f, -0.17751281f, 0.09436946f, 
    -0.05732977f, -0.04170208f, 0.16298476f, -0.06651543f, 0.43036008f, 0.15145470f, -0.26893556f, 0.15152624f, 
    -0.02679968f, -0.18746853f, -0.22606857f, 0.05745707f, 0.03678582f, 0.09173771f, 0.00757922f, 0.09352382f, 
    0.52181935f, 0.25442171f, -0.04958702f, -0.34600967f, 0.11326686f, -0.14858198f, -0.05191557f, 0.18520428f, 
    -0.14198869f, -0.09678195f, -0.09895157f, -0.00375396f, 0.19634049f, 0.04601268f, -0.17033222f, -0.07424963f, 
    -0.22962555f, -0.01194978f, -0.09452298f, -0.23890926f, -0.02976607f, -0.06727607f, 0.07954425f, -0.13805179f, 
    0.10827940f, 0.04306227f, -0.45972055f, 0.28610024f, -0.00037478f, -0.17793664f, 0.06696492f, -0.01096987f, 
    -0.06018831f, 0.03566391f, -0.03410026f, 0.09923732f, -0.40743944f, 0.01974292f, 0.01033357f, -0.06339852f, 
    0.24897377f, -0.02082456f, -0.04064658f, -0.00707047f, -0.13809931f, -0.06933570f, -0.06065435f, 0.06197825f, 
    -0.46237153f, 0.18352938f, -0.08373394f, 0.04762951f, 0.11312966f, -0.07332166f, 0.03041869f, -0.04405372f, 
    0.09884318f, 0.05252373f, -0.05720091f, -0.16519517f, 0.14603798f, -0.04867052f, -0.10820439f, -0.36813045f, 
    0.05804492f, -0.11004077f, 0.04821012f, -0.08762245f, -0.07322556f, 0.05183699f, 0.09020115f, 0.19632667f, 
    -0.15400246f, 0.24224794f, -0.21940029f, 0.06345400f, 0.07587558f, 0.07128536f, 0.11288375f, -0.03734685f, 
    -0.20419700f, -0.02444937f, 0.05529421f, -0.18994193f, -0.11693167f, 0.10539678f, -0.08397588f, 0.07746778f, 
    0.17278734f, -0.13251729f, 0.05569366f, -0.08424418f, -0.11028609f, -0.02721336f, 0.12750758f, 0.02732913f, 
    0.07276987f, -0.11166099f, 0.04406551f, 0.34835735f, -0.02779756f, 0.02855046f, 0.09381165f, 0.17892480f, 
    0.07259098f, -0.02312967f, 0.08479270f, -0.16986655f, -0.22695315f, -0.15786017f, 0.01298060f, 0.26803881f, 
    -0.17063537f, 0.18937741f, 0.07113041f, -0.03230528f, -0.02373714f, -0.11551938f, 0.03025837f, 0.04010176f, 
    -0.44962046f, -0.47735658f, -0.19200154f, -0.17845328f, -0.02094764f, 0.05312403f, 0.15091550f, 0.05989015f, 
    0.04513216f, 0.03331883f, 0.09458797f, 0.03446046f, -0.05066953f, -0.16905721f, -0.24357088f, -0.24415748f, 
    0.20088439f, -0.01450953f, -0.00207565f, -0.00905112f, -0.01475760f, 0.05059932f, 0.05758491f, 0.00611763f, 
    0.08429649f, -0.18571056f, 0.21050163f, -0.34852648f, 0.06680118f, -0.04432604f, 0.08645919f, 0.07955714f, 
    -0.01411742f, -0.02191043f, -0.00279879f, -0.02765272f, -0.54946721f, 0.28264058f, 0.01530575f, 0.14772251f, 
    -0.03947236f, 0.00193802f, 0.11812429f, -0.03050377f, 0.01623889f, 0.08299278f, 0.06468702f, -0.12189346f, 
    0.13369665f, -0.23938181f, 0.38509250f, -0.06410600f, 0.00624857f, 0.00225034f, -0.19981994f, -0.22717020f, 
    -0.27490082f, -0.11811082f, -0.01122184f, -0.24391368f, -0.00548620f, -0.10289782f, -0.15108491f, 0.24989773f, 
    0.10586890f, 0.04323438f, 0.02946655f, -0.26618636f, 0.00436743f, 0.01476155f, -0.12127029f, 0.09609581f, 
    -0.29772890f, 0.36594331f, -0.09283102f, 0.05768863f, 0.26583052f, -0.04077262f, 0.09255315f, 0.02165961f, 
    0.13031614f, -0.12812993f, -0.03538233f, 0.03768856f, -0.17380929f, 0.02567936f, 0.06909290f, -0.13543968f, 
    -0.42741257f, 0.12432412f, 0.02233200f, -0.01063264f, -0.03123247f, 0.04408520f, 0.03977364f, -0.11782200f, 
    -0.20593116f, -0.38139069f, -0.06753374f, 0.12766296f, -0.03644268f, 0.05242718f, -0.08795201f, 0.05880007f, 
    0.08137783f, 0.05324885f, 0.07317061f, -0.05303748f, -0.36001438f, -0.42538482f, -0.02259254f, -0.22771655f, 
    0.01915970f, 0.01545363f, -0.05094735f, 0.01157354f, -0.08754934f, -0.00037375f, -0.09733027f, -0.04221548f, 
    0.10999767f, 0.10541192f, -0.10342790f, 0.19077538f, 0.23234750f, -0.00479693f, 0.03327236f, -0.15390225f, 
    0.13079529f, 0.17087229f, 0.08290190f, 0.02515092f, -0.29159346f, -0.02199381f, -0.09806614f, -0.28939530f, 
    0.07296967f, -0.13869043f, 0.04121993f, 0.13674690f, -0.05556349f, 0.13397904f, 0.02902466f, 0.05629088f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08106785f, 0.00044788f, -0.07720848f, 0.00853011f, 0.06233002f, 0.02715680f, 0.00247729f, -0.04093101f, 
    -0.08686633f, -0.01813499f, 0.09785926f, 0.02120943f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
