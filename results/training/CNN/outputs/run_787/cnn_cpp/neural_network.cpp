#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.54754287f, 0.75291187f, 0.87889171f, 0.88362449f, -0.07457225f, -0.63576531f, -0.11846431f, -0.85698062f, 
    -0.07143996f, -0.13883790f, 0.42546588f, 0.16048673f, -0.12454335f, 0.12758830f, -0.08257854f, -0.00148313f, 
    0.19943516f, 0.32121626f, -0.01212260f, 0.03759668f, -0.31078917f, 0.08409560f, 0.23551135f, 0.17159490f, 
    0.13026723f, -0.75038689f, -0.31079501f, -0.27546993f, -0.25380790f, -0.25031725f, 0.42352730f, -0.27973989f, 
    0.23708467f, 0.54446536f, 0.24117880f, 0.40822077f, 0.15312625f, -0.22709960f, 0.14628854f, 0.34832856f, 
    0.08434221f, 0.35627076f, -0.06404293f, -0.33517331f, 0.44427446f, -0.35024771f, 0.11344022f, 0.12546755f, 
    -0.08756207f, 0.06943027f, 0.82433999f, -0.54320365f, -0.41621411f, -0.01808920f, 0.25675926f, -0.17888603f, 
    -0.41822398f, -0.59525955f, -0.45268568f, -0.04222909f, -0.54287565f, 0.15543912f, -0.08334287f, -0.07437075f, 
    -0.12776883f, -0.15585753f, -0.12236906f, -0.10468844f, 0.03117014f, -0.36153740f, 0.18381275f, -0.05305779f, 
    0.20135556f, -0.01295363f, 0.04834780f, 1.10726380f, 0.22219400f, -0.03196304f, -0.10302164f, 0.31653762f, 
    0.26436388f, -0.30743793f, 0.65758753f, 0.68161243f, 0.26329121f, -0.52808696f, 0.08690473f, -0.25341856f, 
    -0.08322366f, 0.05924911f, 0.36247006f, 0.03204380f, -0.30851448f, -0.04147874f, 0.07861253f, 0.18985216f, 
    0.08033092f, 0.11447452f, -0.10503527f, -0.21475849f, -1.29886925f, 0.95314056f, -0.01690858f, -0.44011241f, 
    0.23752892f, 0.09925372f, 0.91621441f, 0.08535933f, 0.14461756f, 0.25542188f, 0.02265880f, -0.05396470f, 
    0.40197167f, -0.34385782f, 0.15511380f, 0.19218507f, -0.14806503f, 0.01735595f, -0.00346422f, -0.03631439f, 
    0.12061574f, -0.04378831f, 0.00562242f, 0.21764602f, -0.02733947f, -0.20079023f, 0.26252460f, 0.60244203f, 
    0.59371632f, 0.54067159f, 0.33125120f, 0.32060868f, 0.60492480f, 0.04542473f, 0.49069354f, -0.44595492f, 
    -0.03321099f, 0.11233424f, 0.11116184f, -0.19133992f, -0.14976710f, -0.10513529f, -0.10375430f, -0.09179322f, 
    -0.21281457f, -0.19467434f, -0.08262774f, 0.30986828f, 0.43252039f, 0.18995309f, 1.06398284f, 0.85822040f, 
    -1.05000246f, 0.60382468f, -0.14626163f, 0.29984722f, 0.06555342f, -0.39737391f, -0.00830253f, -0.24355882f, 
    0.16635126f, -0.08020716f, 0.04728238f, 0.04729379f, -0.13574545f, 0.11274275f, -0.21142997f, 0.06557224f, 
    -0.08762681f, -0.04865065f, -0.09877180f, 0.03225810f, 0.08688968f, -0.16711240f, 0.13266832f, 0.58501458f, 
    -0.41422817f, -0.06804265f, -0.04590126f, -0.40110663f, -0.44740841f, -0.02079692f, 0.45450643f, 0.48803884f, 
    -0.26063991f, -0.39766663f, -0.41239500f, 0.30087125f, -0.04503472f, -0.29455245f, -0.43720481f, -0.53027159f, 
    -0.48732126f, -0.05399875f, 0.01774585f, -0.19390251f, -0.00300675f, -0.14263847f, -0.03488537f, -0.28199771f, 
    -0.97954410f, -0.62911940f, -0.22967941f, -0.23836192f, -0.26038328f, -0.02761214f, 0.82646704f, 0.46621460f, 
    0.04690395f, 0.76349425f, -0.25058767f, -0.10234252f, 0.27806213f, -0.16032955f, 0.18840982f, -0.11329247f, 
    0.06948985f, -0.13380739f, 0.20941103f, -0.19655398f, -0.09258720f, 0.07758609f, -0.00132088f, 0.05577664f, 
    0.22917871f, -0.13662842f, 0.49669686f, -0.36008823f, -0.72257221f, -0.72802734f, 0.13542871f, 0.23089847f, 
    -0.46109119f, -0.56570959f, -0.48217547f, 0.03232767f, 0.36054951f, -0.11250450f, 0.30528632f, 0.29681477f, 
    -0.03617037f, 0.13984112f, 0.16271086f, 0.04268739f, 0.19094466f, 0.01349358f, 0.02935454f, -0.14512077f, 
    -0.18552889f, -0.01461288f, 0.37389922f, 0.34404424f, 0.95497555f, 0.74478561f, 0.33719656f, -0.37957063f, 
    0.38338429f, 0.23555976f, 0.00708779f, 0.32632747f, 0.09949630f, 0.29988366f, 0.01153804f, -0.39876524f, 
    -0.10481572f, -0.12437858f, -0.21237361f, -0.35836744f, 0.28402469f, 0.02423153f, 0.17464527f, 0.11888394f, 
    -0.10812724f, 0.00277812f, 0.09418194f, 0.29566443f, -0.41809043f, -0.60454118f, -0.49381104f, -0.41067323f, 
    -0.54614002f, 0.79730082f, 0.58479333f, -0.36061075f, 0.18811433f, 0.07264463f, -0.09595730f, -0.02131139f, 
    -0.32380784f, 0.04655924f, -0.12958474f, -0.04067988f, 0.09703197f, 0.15667824f, 0.21869481f, 0.10263170f, 
    0.08150499f, 0.18243124f, 0.31389013f, 0.02165370f, -0.07741958f, -0.15986423f, -0.77806866f, -0.67340410f, 
    0.05545019f, 0.26873472f, 0.16781139f, 0.47323334f, 0.54468364f, 0.36914960f, -0.25554234f, 0.04433143f, 
    -0.24239731f, -0.47753260f, -0.25055990f, 0.15882529f, -0.08387604f, 0.16155727f, -0.09013885f, -0.25477096f, 
    -0.33401412f, -0.17225853f, -0.49269596f, -0.17951711f, -0.09571525f, -0.07908753f, -0.39645314f, -0.72453439f, 
    -0.62932628f, -0.29276118f, 0.24026680f, -0.48700377f, -0.27320361f, 0.42968559f, -0.15568456f, -0.35757843f, 
    -0.32900122f, 0.05529850f, 0.04160629f, -0.40307322f, -0.12860675f, 0.47434849f, 0.03119673f, -0.04249112f, 
    0.18420397f, -0.04355188f, 0.12965579f, 0.17419448f, 0.07622931f, 0.08715155f, 0.62111384f, 0.70230556f, 
    -0.35120508f, 0.14512835f, -0.66341031f, 0.48627317f, 0.42456615f, 0.11530536f, 0.25078946f, 0.40736267f, 
    0.22930004f, 0.03577932f, -0.04424860f, -0.26950574f, 0.26843441f, -0.22783005f, 0.12171342f, -0.17648043f, 
    0.17737092f, 0.08838614f, -0.03364591f, -0.24302983f, 0.09529660f, 0.13275512f, 0.13290545f, 0.24115165f, 
    0.81788117f, 0.15655670f, -0.59512299f, 0.24052137f, -0.44831246f, -0.83664018f, -0.71655500f, 0.05138830f, 
    -0.33625984f, 0.00434900f, -0.10641631f, 0.06814533f, 0.02205856f, 0.07794325f, -0.12540129f, -0.14114654f, 
    -0.01845090f, -0.02035071f, 0.27382207f, 0.07521426f, -0.02483095f, -0.12212042f, -0.06337313f, -0.39293808f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.21594864f, -0.00036723f, 0.37232959f, 0.11993439f, 0.09559607f, 0.18119659f, 0.23326774f, 0.15107341f, 
    -0.04715851f, 0.31347492f, 0.15146878f, -0.00330013f, 0.00561961f, 0.15539338f, 0.16475126f, 0.22418448f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.07094178f, 0.05399207f, -0.04928539f, 0.24818809f, -0.19632240f, 0.00472730f, -0.04022001f, 0.09559343f, 
    -0.10038666f, 0.10636798f, 0.09943286f, 0.05304001f, 0.12598841f, -0.02764941f, -0.05136986f, -0.05747226f, 
    0.08727260f, -0.05436206f, -0.07200903f, 0.05716274f, 0.03746720f, 0.04661122f, 0.03351179f, 0.11915011f, 
    -0.32112855f, -0.00279985f, 0.28555796f, 0.11469986f, 0.02724430f, 0.06968766f, 0.04629994f, -0.14069261f, 
    0.03770659f, 0.03602364f, 0.01447543f, 0.16290174f, 0.25858259f, -0.06017941f, -0.18510579f, 0.03560638f, 
    0.10529956f, -0.08691076f, 0.00520003f, -0.08215415f, 0.06485407f, 0.02800249f, 0.01813026f, 0.06953193f, 
    0.24995348f, -0.03179709f, -0.09693949f, -0.50038302f, 0.08970076f, 0.15133923f, 0.02883925f, 0.07724170f, 
    0.07249324f, -0.04518581f, 0.02549434f, -0.09244784f, 0.01917725f, 0.06515548f, -0.24056606f, -0.21564029f, 
    0.07116541f, 0.09461232f, -0.23270383f, 0.11480125f, -0.07727415f, -0.08014040f, 0.20806456f, -0.02801700f, 
    0.18651406f, -0.17575656f, 0.15549260f, -0.41796467f, -0.13770604f, -0.03025234f, 0.17977864f, 0.09486848f, 
    -0.00862656f, 0.10333243f, -0.03180144f, -0.02522566f, 0.05813013f, 0.07720099f, -0.04209909f, 0.31248009f, 
    0.02524937f, 0.16083317f, 0.03340936f, -0.20539884f, -0.01255272f, 0.06932858f, -0.03465164f, -0.15876257f, 
    0.25720578f, -0.01915320f, -0.12166828f, -0.12629500f, -0.05799692f, -0.07682216f, 0.03638644f, 0.08572862f, 
    0.08410553f, 0.13426697f, -0.06232532f, -0.08901445f, -0.66993761f, 0.13352628f, 0.31911385f, -0.35125831f, 
    0.14101012f, 0.06292084f, 0.10666832f, 0.00281083f, 0.17164151f, 0.04921661f, 0.01820054f, 0.09636249f, 
    -0.15201390f, 0.01292502f, -0.09715952f, 0.28695625f, -0.14371558f, 0.15919949f, 0.13249648f, -0.01458645f, 
    -0.07892484f, 0.17652330f, 0.00207111f, -0.16521367f, -0.19901101f, -0.15496007f, -0.05367148f, 0.17687726f, 
    -0.04506429f, -0.08520863f, 0.03179917f, 0.01208264f, -0.04807620f, -0.00946737f, 0.28502387f, 0.02700821f, 
    0.19751312f, 0.09682909f, 0.08879857f, -0.09818661f, -0.08853652f, 0.02196426f, 0.06061277f, 0.08907109f, 
    0.07403298f, -0.03340556f, 0.00042183f, -0.06458729f, -0.52594340f, -0.35017872f, 0.25813037f, 0.01918397f, 
    0.20873359f, -0.13651781f, 0.01380342f, 0.06277145f, 0.17722619f, 0.04090676f, -0.03828573f, 0.19291133f, 
    0.15689600f, -0.16851057f, 0.19690494f, -0.31188372f, -0.02298776f, 0.05138341f, 0.02181816f, -0.03043374f, 
    -0.02693539f, 0.10252971f, 0.08227057f, 0.19855401f, -0.19053867f, -0.03597239f, 0.19322957f, -0.26046291f, 
    -0.00910174f, 0.06907229f, 0.10769925f, -0.04166536f, 0.09209502f, 0.04041152f, 0.12019690f, 0.03616183f, 
    0.05371209f, -0.03914244f, 0.00888363f, 0.04582046f, -0.01682792f, -0.04418432f, -0.01042161f, -0.03942991f, 
    -0.06929970f, 0.03557955f, 0.05906986f, 0.00501110f, 0.03940557f, 0.04035154f, 0.02597348f, 0.03794004f, 
    -0.04138481f, -0.05262367f, -0.07609180f, -0.03619961f, -0.06052781f, -0.02795169f, 0.00355528f, 0.02871278f, 
    0.04364479f, 0.06316087f, 0.03076036f, -0.04199944f, 0.04136924f, 0.03225657f, 0.01357623f, 0.04270157f, 
    -0.03212411f, -0.00739289f, 0.00580366f, -0.06008307f, -0.00664623f, -0.04337088f, -0.06240533f, -0.01504031f, 
    0.04130173f, 0.03566080f, 0.03533150f, 0.02919420f, -0.03370404f, -0.04286016f, -0.07430491f, -0.07363659f, 
    -0.07788534f, -0.02076698f, 0.03256284f, -0.03779757f, 0.06426105f, 0.01381348f, 0.03535337f, -0.07295926f, 
    0.04862931f, -0.06076137f, 0.02128720f, 0.05842647f, -0.03547899f, 0.04186950f, 0.00542241f, -0.05911549f, 
    -0.01172035f, -0.02439998f, -0.04523821f, -0.07097639f, 0.00788671f, -0.00540471f, 0.02023139f, -0.00570250f, 
    -0.07565310f, -0.01011599f, 0.02410999f, 0.01569537f, 0.00190411f, -0.04708825f, 0.00768952f, -0.07326150f, 
    0.05173226f, 0.02258668f, 0.02889320f, 0.00736794f, -0.04011647f, -0.07799264f, -0.01459725f, 0.00992549f, 
    -0.06660904f, 0.06326367f, -0.05023004f, 0.02946548f, -0.05113151f, 0.01441945f, -0.00640425f, 0.04005407f, 
    0.02274136f, 0.03418805f, -0.07267892f, 0.00716412f, 0.03616262f, -0.07807994f, -0.02156848f, -0.05336717f, 
    -0.05462849f, -0.03633624f, 0.02590717f, -0.05781278f, -0.07020121f, 0.05785876f, 0.05014832f, -0.05429748f, 
    0.00415765f, 0.01515478f, 0.01351314f, -0.03150563f, -0.07693013f, 0.06488191f, 0.01677008f, 0.02106466f, 
    -0.00216748f, -0.00010331f, -0.04139280f, 0.04235398f, 0.02020257f, -0.06142035f, -0.03356856f, 0.02340955f, 
    -0.04119978f, -0.04899900f, 0.00747512f, -0.05037327f, -0.03447966f, -0.05863210f, 0.03417265f, 0.01852052f, 
    -0.04283703f, -0.01512411f, -0.02134966f, -0.06706956f, -0.04205421f, -0.01123120f, -0.00187235f, -0.00289991f, 
    -0.02154219f, -0.01213523f, 0.03904636f, -0.04738163f, 0.06211717f, -0.01594253f, 0.00492455f, 0.05092838f, 
    0.01197247f, 0.03219917f, 0.04029843f, -0.01817959f, -0.04747804f, -0.01170574f, 0.01307926f, -0.03872921f, 
    -0.00496922f, 0.03431696f, 0.01303391f, 0.04513976f, -0.06629214f, 0.04498798f, -0.00689704f, -0.05794261f, 
    0.00667168f, -0.05675624f, 0.00990689f, 0.00430705f, 0.03550317f, -0.05649577f, -0.02885672f, -0.06398092f, 
    -0.03564008f, -0.05653816f, 0.02936105f, -0.01529661f, -0.07366209f, -0.07141071f, 0.01574070f, -0.01723459f, 
    -0.02783552f, -0.07263987f, 0.05860955f, 0.01146807f, -0.03880348f, 0.03299607f, -0.05839289f, 0.05774123f, 
    -0.01926823f, 0.19909720f, 0.34996364f, 0.35789067f, 0.00921686f, -0.02621837f, -0.03771191f, -0.06321049f, 
    0.04028164f, 0.14427103f, 0.11733079f, 0.23680571f, -0.26312506f, -0.35907516f, -0.05847242f, -0.01178881f, 
    0.19285911f, 0.04099454f, 0.11986025f, -0.04662465f, 0.09410202f, 0.18136428f, -0.11410822f, 0.15601830f, 
    0.16842720f, -0.18400480f, 0.17765453f, 0.00209103f, 0.04495801f, -0.11770600f, 0.07923862f, 0.20264758f, 
    0.01961210f, -0.11318408f, 0.04034119f, 0.13777326f, 0.40760452f, -0.03904941f, 0.28162590f, -0.13030484f, 
    -0.08521880f, -0.01489168f, -0.06026827f, -0.14290556f, -0.09642000f, 0.20831604f, 0.12730411f, 0.05338272f, 
    -0.03149524f, -0.15399964f, 0.21600518f, -0.00711174f, 0.04472287f, 0.04995247f, 0.21820903f, -0.12507255f, 
    0.01565925f, -0.01558746f, -0.06729400f, -0.01472440f, 0.15945090f, 0.22765583f, 0.19470568f, 0.27881476f, 
    0.06333806f, 0.09881217f, 0.09660367f, 0.00301387f, -0.09408347f, 0.02887361f, 0.02684145f, 0.13173066f, 
    -0.08929653f, 0.24350339f, 0.25192776f, 0.16224033f, -0.06825929f, 0.08912683f, -0.11613420f, 0.01180800f, 
    0.09015147f, -0.04822965f, -0.04506345f, -0.01949894f, -0.02430987f, -0.24839260f, -0.14482725f, 0.29602987f, 
    0.03163531f, 0.13106605f, 0.08853103f, -0.23841223f, -0.09080394f, -0.03112360f, -0.10096547f, -0.10262951f, 
    -0.39165631f, -0.09311020f, -0.29154578f, -0.08441993f, 0.08145306f, 0.22015212f, 0.15958844f, 0.05620579f, 
    0.03222292f, 0.05776849f, -0.07640432f, 0.10052687f, -0.36644435f, -0.01796116f, -0.01695438f, 0.04377227f, 
    0.06583431f, 0.14390095f, -0.11689959f, -0.03001681f, 0.11186338f, 0.20524098f, 0.15067232f, 0.05075974f, 
    0.24633251f, -0.07832635f, 0.32651606f, 0.19469011f, -0.02391370f, -0.13304698f, -0.12928639f, 0.07603255f, 
    0.24690565f, -0.00253859f, -0.15795517f, 0.08731364f, -0.60110307f, -0.09885756f, -0.20957446f, -0.38675469f, 
    0.02388939f, -0.06039768f, 0.14029326f, -0.04607747f, 0.16847685f, 0.08140749f, 0.07242470f, 0.00252920f, 
    0.17808253f, -0.14834455f, 0.00051250f, -0.39453825f, 0.37913153f, -0.03696827f, -0.04054201f, -0.03826016f, 
    -0.09561265f, -0.26732466f, -0.02812747f, -0.08465209f, -0.19609356f, -0.22068177f, 0.05325522f, -0.21865959f, 
    0.18890905f, 0.04256051f, 0.18866904f, 0.05828197f, 0.12792501f, -0.06956645f, -0.11823384f, 0.01107012f, 
    0.49369776f, 0.27522948f, -0.14170903f, 0.06867583f, 0.10272221f, 0.14050588f, 0.10583285f, -0.27939001f, 
    0.04283684f, -0.09049262f, 0.08699114f, 0.09602161f, -0.08059791f, -0.12200624f, 0.36216739f, -0.08511255f, 
    -0.17248957f, -0.27567497f, -0.03656477f, 0.02144841f, 0.03076590f, -0.00398057f, 0.04527302f, 0.23486722f, 
    0.26068619f, 0.13486443f, -0.06228554f, -0.12903278f, 0.01890599f, -0.05620442f, 0.12271833f, -0.01438708f, 
    -0.03585115f, -0.11412624f, 0.08967362f, 0.11082851f, -0.44386265f, 0.03632140f, 0.04647786f, 0.18041614f, 
    -0.11110348f, -0.05662097f, 0.16263996f, -0.17378691f, -0.03592791f, 0.23879811f, 0.05685962f, 0.13890246f, 
    0.21338418f, -0.11540233f, -0.06890444f, -0.21474122f, -0.00985318f, -0.06171171f, 0.14917372f, 0.15134291f, 
    -0.08250239f, -0.08054028f, 0.05791594f, 0.00395650f, 0.11078245f, 0.31856754f, 0.30638543f, -0.03203994f, 
    0.09998053f, -0.13375440f, -0.09876186f, 0.06022482f, -0.04788065f, 0.04105766f, -0.07803790f, -0.01906533f, 
    -0.39909106f, -0.37243962f, 0.02804208f, 0.14366719f, 0.04531594f, 0.07450610f, 0.03553527f, -0.04159607f, 
    0.12111747f, -0.07304395f, 0.08955374f, -0.02114437f, 0.03054313f, 0.07241205f, 0.24542668f, 0.18810131f, 
    0.01729058f, 0.07714716f, 0.33685121f, -0.15276840f, 0.10485259f, -0.04581260f, -0.06911866f, -0.03222487f, 
    -0.18904825f, 0.07528412f, 0.15812087f, 0.16888088f, 0.06214272f, 0.03781355f, 0.00413090f, 0.06713782f, 
    0.03321657f, -0.00345380f, -0.16841760f, 0.06780928f, 0.02327792f, -0.13977741f, 0.08702915f, 0.17930380f, 
    0.07662576f, -0.15562192f, 0.22354110f, 0.02692152f, 0.09028418f, 0.02895304f, -0.15496042f, -0.03904841f, 
    -0.14869776f, -0.19483517f, -0.26151469f, -0.09861284f, -0.13669308f, -0.01152660f, 0.03708921f, -0.05306570f, 
    -0.00330347f, 0.09177721f, 0.18328333f, 0.04303516f, -0.06389546f, -0.19550575f, -0.09383863f, 0.28264269f, 
    0.09087609f, -0.01651997f, -0.21103379f, -0.10017892f, 0.04061361f, 0.13956696f, 0.20697819f, -0.07104681f, 
    0.25535882f, -0.16812754f, 0.25546354f, 0.05195230f, -0.04036174f, -0.03202015f, -0.11649910f, 0.06314342f, 
    0.08444116f, -0.09154953f, -0.11514606f, 0.15083995f, 0.07750057f, -0.10331575f, -0.10887208f, -0.36117625f, 
    0.00031833f, -0.14617284f, 0.00166464f, 0.01362448f, -0.02811024f, 0.11879148f, -0.02782684f, -0.00086885f, 
    0.12227715f, -0.15018438f, -0.08253881f, -0.22534950f, 0.24508639f, 0.04859594f, -0.21998990f, -0.08325799f, 
    0.09858552f, 0.01637256f, -0.06284028f, 0.04286575f, 0.00968640f, 0.08272068f, -0.01365711f, -0.13374010f, 
    -0.03571156f, 0.06521180f, 0.12415540f, 0.07512662f, -0.08140379f, 0.01323107f, -0.01508269f, -0.13803816f, 
    0.43976414f, 0.28413126f, 0.01165562f, 0.12974018f, 0.00875403f, -0.07431992f, -0.03531698f, -0.09006761f, 
    -0.00310681f, -0.08507475f, -0.03033228f, -0.08034534f, 0.05003425f, -0.07193463f, -0.02975571f, 0.11739788f, 
    0.11493038f, -0.10513651f, -0.01376179f, 0.16892123f, -0.12658258f, 0.12693702f, 0.03234341f, 0.03324351f, 
    0.05254453f, 0.03041035f, -0.07975670f, 0.02736223f, 0.02765497f, -0.06243740f, -0.01102715f, 0.05082227f, 
    0.05822578f, 0.03948018f, 0.03187218f, -0.03720951f, -0.01010734f, 0.00941131f, -0.04807835f, 0.00107382f, 
    -0.06225946f, -0.02062771f, -0.03153012f, 0.06407002f, -0.03502619f, 0.03637566f, 0.05830982f, -0.00458199f, 
    -0.00776193f, 0.06757515f, -0.06345094f, 0.00833881f, 0.04583778f, 0.02849123f, -0.02121141f, 0.01466323f, 
    -0.07345089f, 0.05037361f, 0.02017822f, -0.03054539f, -0.03453847f, -0.03296209f, 0.00443155f, -0.03901568f, 
    -0.05986433f, 0.00357924f, -0.06540380f, 0.02833341f, -0.00401778f, -0.06196612f, 0.00165253f, -0.00676891f, 
    0.01935550f, 0.02647877f, 0.01885612f, -0.02428130f, -0.01541116f, -0.04537566f, -0.04254708f, 0.04376872f, 
    -0.03899067f, -0.06423398f, 0.04080704f, 0.01621845f, -0.03390338f, -0.03191116f, 0.06091858f, -0.00679314f, 
    0.06739624f, -0.00565717f, 0.05476185f, -0.04387574f, 0.04887589f, -0.01998752f, 0.05270376f, -0.06971353f, 
    -0.00092834f, -0.00430620f, -0.05519970f, -0.01488381f, -0.01076661f, 0.01564321f, -0.07648679f, -0.01494324f, 
    -0.04234773f, 0.01098300f, 0.00019075f, 0.00564422f, 0.05234401f, 0.00498748f, -0.00689364f, 0.02571126f, 
    -0.07888869f, -0.00290086f, 0.04862797f, -0.00882884f, -0.05224059f, -0.01782814f, -0.04256675f, 0.02871611f, 
    0.02710097f, -0.06101435f, -0.07453765f, 0.03702824f, -0.03338701f, -0.06809194f, -0.01398210f, -0.06533950f, 
    -0.05201330f, 0.00080235f, -0.04800640f, 0.02469885f, -0.05324952f, 0.03591344f, 0.05604585f, -0.00402323f, 
    -0.07843479f, -0.06269147f, 0.06463596f, -0.04949991f, -0.07943104f, 0.03144805f, 0.05268174f, -0.07849796f, 
    -0.05455457f, 0.04164600f, -0.05374600f, -0.03838880f, -0.04904115f, 0.01405831f, -0.03238074f, -0.04802265f, 
    -0.00681376f, -0.03864804f, -0.07995219f, 0.03772955f, 0.04814072f, -0.05477928f, -0.02052028f, 0.03272638f, 
    0.03929117f, -0.06746715f, -0.07626458f, -0.04005474f, -0.01029652f, -0.03841087f, 0.05060054f, -0.00618336f, 
    -0.07190301f, 0.03538608f, 0.00991843f, 0.05550637f, -0.00611580f, 0.06686952f, 0.04802222f, -0.02384771f, 
    -0.06381054f, 0.03389623f, 0.02732518f, -0.07334830f, -0.05409789f, 0.03708513f, -0.03299382f, -0.05394345f, 
    -0.02368694f, -0.04942292f, -0.04384345f, -0.01517137f, -0.02482405f, 0.02465834f, 0.00356013f, -0.02966142f, 
    0.03977148f, -0.06348822f, 0.00860178f, 0.03527746f, -0.03249523f, 0.03840205f, -0.05194620f, 0.02062686f, 
    0.03224203f, 0.01824308f, 0.05175871f, -0.02965480f, -0.03988817f, 0.04111553f, 0.01350417f, -0.07369286f, 
    -0.07650964f, 0.00517648f, 0.00880622f, 0.01277932f, 0.04569787f, 0.03281364f, 0.03720329f, 0.01717992f, 
    0.16694254f, 0.28626522f, -0.05454732f, -0.03091414f, 0.17943631f, 0.06240776f, 0.19000490f, -0.08195556f, 
    -0.08635318f, 0.05163486f, 0.13390359f, 0.02682536f, 0.10494111f, 0.03178976f, 0.11802954f, 0.01733462f, 
    -0.12589209f, 0.02728644f, 0.25209793f, -0.00024422f, 0.02881425f, 0.20570958f, 0.07473949f, 0.23073417f, 
    0.20565185f, -0.30228823f, 0.24765429f, -0.24446756f, 0.05336641f, 0.11860237f, 0.00597333f, 0.26733699f, 
    0.00096572f, 0.12106368f, -0.03440455f, -0.01033724f, -0.27428082f, -0.08712173f, 0.21425037f, -0.02854100f, 
    0.13069190f, -0.00489820f, 0.04422623f, 0.15285696f, 0.00258049f, -0.03064649f, -0.04027226f, 0.02515141f, 
    0.05563455f, 0.23794654f, -0.10461657f, -0.04801724f, 0.03683909f, 0.08744407f, -0.00349135f, -0.02662444f, 
    0.11718736f, 0.04396233f, 0.06851105f, 0.04852964f, 0.08749595f, 0.14368564f, 0.03797083f, 0.12390781f, 
    -0.21494000f, 0.18096872f, 0.10942966f, 0.00460758f, 0.07631290f, 0.20176984f, -0.00987991f, 0.12734629f, 
    0.10983163f, -0.47803846f, -0.07431079f, 0.14977475f, 0.08369224f, -0.10576271f, -0.00643164f, -0.00737790f, 
    0.19004874f, 0.08446925f, -0.03989525f, 0.07736377f, -0.17353317f, -0.15999991f, 0.09131917f, 0.10552754f, 
    0.18631679f, -0.09295426f, 0.15487485f, -0.01672924f, 0.11146852f, -0.04930902f, -0.21809079f, -0.06583823f, 
    0.53331101f, 0.01710464f, -0.17637382f, 0.06495197f, -0.08800948f, -0.04931737f, 0.05187713f, 0.05207800f, 
    0.18291849f, 0.05810060f, -0.06826943f, 0.09713113f, -0.11059636f, -0.04632890f, -0.17364325f, -0.18037698f, 
    -0.02932155f, -0.07737172f, -0.04676106f, -0.05763553f, -0.00897415f, -0.03254670f, 0.01332966f, 0.15642565f, 
    0.16970128f, 0.11913090f, -0.01785317f, 0.14563578f, -0.00417399f, 0.04493999f, -0.09789431f, 0.13503703f, 
    0.01710418f, -0.00589106f, 0.07769956f, 0.00677227f, 0.32099304f, 0.02431837f, -0.05136966f, -0.31307009f, 
    -0.10985436f, 0.03068120f, 0.00412169f, -0.08298258f, 0.11368579f, -0.00076077f, 0.11980004f, 0.01369870f, 
    -0.00554844f, 0.14130668f, -0.11286079f, -0.34933713f, 0.07122777f, 0.02389590f, -0.18555619f, -0.13608339f, 
    0.10739011f, -0.09538975f, -0.13652849f, -0.03371660f, -0.42003992f, -0.20196278f, 0.15030643f, -0.29354960f, 
    -0.04723849f, 0.06139305f, 0.08217242f, 0.10764305f, 0.05243469f, 0.00876369f, 0.10763317f, -0.01721523f, 
    0.26862216f, 0.06612019f, -0.12544926f, -0.04203562f, -0.12765788f, -0.14225218f, 0.04727563f, 0.03473089f, 
    0.09255519f, -0.00363466f, -0.04913017f, -0.05202686f, -0.23064706f, 0.30060598f, 0.11585811f, -0.11789919f, 
    0.21419643f, 0.02143736f, 0.13620217f, 0.01462929f, -0.12809530f, 0.03726449f, 0.02254155f, -0.01779591f, 
    -0.10780378f, -0.20329736f, -0.14995939f, 0.79241616f, -0.06723193f, -0.08298962f, 0.01920960f, -0.03482977f, 
    0.19896136f, 0.06165432f, 0.11886118f, 0.11853720f, -0.00109566f, 0.08067561f, 0.02445257f, -0.07803315f, 
    0.06570406f, 0.04234396f, -0.03720693f, -0.00655744f, 0.07452589f, 0.16870292f, -0.08265886f, 0.32382855f, 
    0.48817971f, -0.32836497f, 0.62791550f, 0.11577145f, -0.11406422f, -0.07564203f, -0.07404123f, 0.17977957f, 
    0.24591057f, -0.01927521f, 0.06148133f, 0.04060092f, 0.34567711f, -0.43816325f, 0.18401454f, -0.11376538f, 
    -0.09718106f, -0.08124380f, 0.03399003f, -0.20272915f, -0.02282456f, 0.12963724f, -0.04928990f, 0.02401069f, 
    -0.19986556f, 0.48925525f, 0.09158415f, -0.13907313f, -0.06500000f, 0.05987255f, -0.00725925f, 0.02632805f, 
    0.15519913f, -0.01320538f, 0.01498277f, -0.08367704f, -0.07495654f, 0.24404179f, 0.03033524f, 0.27385682f, 
    -0.12293208f, 0.03305595f, 0.06528192f, 0.14099023f, 0.02907780f, 0.05876251f, -0.04020955f, -0.04946322f, 
    0.34052539f, -0.17616928f, -0.04497538f, -0.02690967f, -0.24912006f, -0.02698819f, -0.12124065f, -0.00101799f, 
    0.15409362f, -0.04567907f, -0.10726524f, -0.01583395f, -0.08949307f, -0.39536044f, 0.02377479f, 0.20137945f, 
    0.10306840f, 0.17689399f, 0.03221158f, -0.03568101f, -0.08045503f, -0.02781880f, -0.06197200f, -0.21670048f, 
    -0.01679213f, 0.29936379f, -0.26335928f, -0.05718962f, 0.09625773f, 0.04635496f, 0.06802096f, 0.16942102f, 
    0.01531426f, -0.09753239f, -0.02886567f, 0.03922353f, -0.03643288f, 0.21383895f, -0.10599362f, -0.29986504f, 
    0.02796118f, 0.11314500f, 0.17259598f, 0.09431329f, 0.01256918f, 0.22739634f, 0.15032062f, 0.20464270f, 
    0.01679230f, 0.15418677f, -0.05161394f, 0.32185125f, 0.00821031f, -0.06894755f, -0.14001261f, 0.08870231f, 
    0.10701352f, 0.16504781f, 0.13338308f, -0.18859138f, 0.09938190f, -0.11502966f, -0.03811740f, -0.23726392f, 
    -0.17300729f, 0.04940753f, 0.21284573f, -0.03261849f, 0.19440748f, 0.00167577f, -0.01500968f, 0.16386519f, 
    0.01784064f, 0.09700114f, -0.03288906f, -0.38487512f, 0.12243608f, 0.03125652f, -0.16576014f, -0.01448793f, 
    0.03963680f, -0.01135645f, 0.01046624f, -0.14807741f, -0.25168610f, -0.15271062f, 0.28925201f, -0.08683857f, 
    0.12443203f, 0.18092856f, 0.12256139f, 0.14174049f, 0.22176751f, 0.00232945f, 0.00766915f, -0.01637160f, 
    0.41819799f, -0.17024909f, -0.26546389f, -0.26705933f, 0.01671154f, -0.12868476f, -0.05237383f, -0.10405787f, 
    -0.10802905f, -0.03769929f, 0.00875463f, 0.09849449f, -0.01565051f, 0.21625893f, 0.19025610f, -0.01703347f, 
    0.02160330f, -0.21644209f, -0.03863339f, 0.05807572f, -0.11850628f, 0.11331569f, 0.09951460f, 0.05808613f, 
    0.32143995f, 0.03440405f, -0.22390632f, 0.00170327f, -0.02222406f, -0.24131174f, -0.10480411f, -0.06303416f, 
    0.08338793f, 0.09924328f, -0.13916939f, -0.05818419f, 0.49551186f, -0.09235157f, -0.17427608f, -0.26276320f, 
    -0.05735942f, 0.14763936f, -0.09728526f, 0.27319300f, -0.13304201f, -0.09598150f, 0.11859456f, -0.25823388f, 
    0.13363515f, -0.08426392f, -0.02741512f, 0.23282705f, 0.14052036f, -0.13211553f, 0.02351198f, -0.07512364f, 
    -0.22066198f, 0.25172418f, 0.05492635f, 0.11977667f, -0.03235588f, -0.03850836f, -0.19779724f, 0.05369914f, 
    0.14204262f, 0.02034482f, 0.08294463f, 0.08328765f, 0.11984316f, -0.07786150f, 0.12686653f, -0.05561956f, 
    0.49811733f, 0.18901914f, 0.13546240f, -0.15076992f, 0.03351475f, 0.09980100f, 0.03311175f, 0.21513067f, 
    -0.27908471f, -0.01276395f, -0.02215450f, -0.04148868f, -0.24404107f, -0.11673376f, -0.22062552f, -0.19828990f, 
    0.03439422f, -0.02867836f, -0.24613886f, 0.04825451f, -0.07601997f, -0.00626152f, 0.03897116f, -0.02395257f, 
    0.43410271f, -0.04848895f, -0.03183393f, 0.05536567f, -0.04450868f, 0.05432328f, -0.05502083f, -0.01174956f, 
    0.13454767f, 0.12541237f, 0.17596631f, 0.07450071f, -0.09620503f, 0.29667103f, -0.03352774f, 0.08874745f, 
    0.13299504f, -0.10297038f, -0.07057406f, 0.09155529f, 0.22538248f, -0.08335239f, 0.31502113f, 0.32888395f, 
    0.19065183f, 0.25155485f, 0.10874481f, -0.06065114f, -0.02765014f, 0.14527102f, -0.08692617f, 0.21731833f, 
    -0.02686936f, 0.05026905f, 0.01363303f, 0.10859006f, 0.21361245f, -0.16586266f, 0.05228627f, -0.09190128f, 
    -0.07567132f, 0.09272959f, 0.13332330f, -0.08282256f, -0.05945540f, -0.21270233f, -0.14053090f, -0.03115856f, 
    0.24900438f, 0.26994738f, -0.33260065f, -0.08004194f, 0.08033152f, 0.00601686f, -0.10645032f, -0.06493597f, 
    0.07062942f, 0.05478093f, 0.04640752f, -0.08356836f, -0.40225187f, 0.18927461f, -0.10042458f, 0.17777921f, 
    0.16058429f, 0.10230372f, 0.06901120f, -0.04407534f, -0.02507378f, -0.14477259f, -0.01440728f, -0.04705122f, 
    0.02929755f, 0.21600762f, -0.17922100f, -0.07093158f, -0.07485591f, 0.03841883f, 0.25312597f, -0.03117657f, 
    0.12340606f, 0.11055011f, 0.09135907f, 0.06734116f, 0.41044906f, -0.04941605f, -0.28187385f, -0.22159234f, 
    -0.16838771f, -0.06600129f, -0.12110481f, -0.13928363f, -0.15958934f, 0.16051053f, 0.11454235f, 0.03917946f, 
    -0.10967126f, -0.33992627f, 0.04856420f, -0.14096296f, 0.20136859f, -0.09410598f, -0.10886251f, 0.03628301f, 
    0.26696396f, 0.09563185f, -0.11303791f, -0.04946549f, 0.49222460f, 0.34535864f, 0.05861659f, 0.13075164f, 
    -0.01788097f, 0.18805671f, -0.09596820f, 0.01704284f, 0.25056252f, -0.04605523f, -0.07408892f, 0.20276113f, 
    0.78554350f, -0.00072446f, 0.06682875f, -0.04460949f, 0.08180126f, 0.07830649f, -0.03638780f, -0.02330491f, 
    0.05422205f, -0.09599797f, 0.15736885f, 0.11700328f, -0.32359663f, 0.02582870f, 0.11194864f, 0.12873414f, 
    0.19638261f, 0.05182897f, -0.04451922f, 0.04708106f, -0.09935686f, 0.04505515f, -0.17181487f, -0.24456379f, 
    -0.10075780f, 0.12279375f, -0.35232529f, -0.03983775f, -0.06164359f, -0.13245969f, -0.01565947f, -0.10000723f, 
    0.10437237f, -0.01858730f, -0.02608508f, 0.09554534f, 0.11518956f, 0.23263116f, -0.02498661f, -0.03400117f, 
    0.01628191f, -0.06901167f, 0.16375156f, 0.09165774f, 0.18673050f, -0.11245476f, -0.09481658f, 0.02419103f, 
    -0.35610691f, -0.25518155f, -0.20170116f, -0.06155064f, -0.11495381f, 0.14652194f, -0.06958549f, 0.03641839f, 
    0.02846974f, 0.02016748f, 0.09172586f, -0.08174061f, 0.31807327f, 0.05983256f, 0.05649428f, -0.03681418f, 
    0.14787604f, 0.09302445f, 0.20746712f, -0.01025166f, -0.07646398f, 0.15911743f, -0.06561014f, -0.05697773f, 
    0.62036926f, -0.13424656f, 0.10639876f, 0.02652816f, 0.19412990f, -0.11298005f, -0.01533900f, -0.06445136f, 
    0.08454867f, 0.05128250f, -0.01768311f, 0.02238186f, -0.30591935f, 0.21646343f, -0.15426841f, -0.14925219f, 
    -0.00102232f, -0.18484624f, 0.08073396f, 0.22143656f, -0.08658890f, -0.02536497f, 0.17541879f, 0.03079630f, 
    -0.40973195f, -0.19973955f, -0.21670485f, 0.15158293f, 0.12048767f, 0.09673700f, 0.10561740f, 0.28122810f, 
    -0.12824303f, -0.04031952f, 0.08009596f, -0.02174332f, 0.05328135f, -0.02806698f, -0.10619847f, -0.01922907f, 
    0.09079654f, -0.11900321f, 0.06340200f, -0.01889759f, 0.10632146f, -0.00919701f, 0.17269813f, -0.11689761f, 
    0.53503507f, 0.07049863f, 0.11991890f, 0.12406616f, 0.16138840f, -0.07152930f, -0.01675757f, -0.01446176f, 
    0.10554227f, -0.02269426f, 0.10527680f, -0.05358283f, 0.01382787f, 0.25354460f, -0.08782075f, 0.09739430f, 
    0.13840355f, -0.11634155f, -0.04899867f, 0.02354489f, -0.01407806f, -0.02737994f, -0.10821056f, 0.01418843f, 
    -0.29009426f, -0.10060582f, -0.13474765f, 0.11559536f, 0.21010028f, -0.04209923f, -0.04895765f, 0.16640432f, 
    0.18943268f, 0.14341040f, 0.23499553f, 0.20197935f, -0.09801359f, -0.16811971f, -0.07029925f, 0.19894823f, 
    -0.03142598f, -0.08800834f, -0.00900655f, 0.02454336f, -0.12869863f, -0.03544642f, 0.04740123f, -0.07099292f, 
    0.60221785f, -0.10633206f, 0.11149902f, -0.04945333f, -0.07785635f, -0.13949199f, -0.12088462f, -0.08846337f, 
    -0.11307498f, -0.14808227f, -0.05144780f, -0.18962923f, 0.14696331f, 0.11173260f, -0.23600054f, 0.36558217f, 
    -0.06987142f, -0.06032588f, -0.04983163f, -0.02914901f, -0.02743125f, 0.20747659f, -0.08658379f, 0.04075057f, 
    0.10629162f, -0.24196996f, -0.04781356f, 0.00592390f, -0.13937747f, -0.17429489f, -0.11768657f, -0.03192517f, 
    0.02089821f, -0.00334077f, -0.04590397f, -0.17638065f, -0.06770506f, -0.15808971f, 0.16919105f, 0.20606613f, 
    0.11883193f, -0.01968028f, -0.14941059f, 0.13394909f, -0.02156124f, -0.13750030f, -0.04128254f, -0.01862117f, 
    -0.38976598f, 0.07125307f, -0.32178098f, 0.04771674f, -0.28105599f, -0.08613888f, 0.03365230f, -0.10554338f, 
    -0.15851183f, -0.01765724f, 0.05227770f, 0.00301020f, 0.62042642f, 0.11009133f, -0.27560753f, 0.02675847f, 
    -0.02682654f, -0.09142451f, -0.09821174f, 0.14020760f, -0.09951635f, 0.13420606f, 0.10529222f, -0.11616439f, 
    0.61995846f, -0.29243365f, 0.21801893f, 0.08841523f, 0.08999165f, 0.03317159f, 0.04946575f, -0.08467615f, 
    0.04423533f, -0.00925168f, 0.02793303f, -0.20118028f, 0.32700002f, 0.06505601f, -0.07525440f, 0.15027133f, 
    0.15397778f, 0.10650706f, -0.24620719f, -0.06541178f, 0.00882404f, -0.11329359f, 0.03585378f, 0.02155663f, 
    -0.13612390f, 0.35385227f, 0.12410149f, -0.02518578f, -0.22063465f, 0.12685628f, -0.03046068f, 0.02614371f, 
    -0.05131677f, -0.00324210f, 0.12149799f, -0.12139881f, 0.09179665f, 0.06824494f, -0.16660754f, 0.04521827f, 
    -0.02724236f, 0.01795046f, -0.02893565f, -0.04498214f, 0.03686612f, 0.06212134f, 0.20568629f, 0.08610576f, 
    0.15137914f, 0.05161180f, 0.43385088f, 0.10819805f, 0.22736855f, 0.16131812f, 0.03645842f, 0.07459167f, 
    0.01863294f, 0.09388565f, 0.01510197f, 0.06930491f, -0.04367717f, 0.24002737f, 0.15874827f, -0.08399185f, 
    0.02122525f, -0.00011972f, -0.04818643f, -0.16319947f, -0.01827024f, -0.14871031f, -0.11403823f, -0.14036883f, 
    0.16430284f, -0.18952857f, 0.06994218f, 0.19804168f, 0.09890644f, -0.00342163f, -0.04701326f, -0.13500404f, 
    0.07144836f, 0.06222115f, -0.11042883f, -0.06406318f, -0.40203926f, 0.36933881f, 0.15025553f, 0.03420326f, 
    0.02950116f, 0.02530469f, -0.00991837f, 0.04818817f, 0.00646478f, -0.03922081f, 0.04020806f, 0.06397832f, 
    0.25947136f, 0.28081751f, 0.12011100f, 0.15440805f, 0.00592937f, 0.08640681f, 0.08321557f, 0.20413944f, 
    -0.12907155f, 0.00779613f, 0.03305629f, 0.09492889f, 0.00951369f, 0.26506656f, 0.06336669f, 0.07389059f, 
    0.24622488f, 0.09986457f, -0.07069863f, 0.02097007f, -0.02100804f, -0.09893245f, 0.10299169f, 0.06111721f, 
    0.08047856f, 0.14455613f, 0.19925667f, -0.01244571f, 0.00795191f, 0.03331443f, -0.02262394f, -0.00314350f, 
    0.01693812f, 0.19525702f, 0.00514508f, 0.17517830f, -0.05902649f, -0.04021705f, -0.19219947f, -0.41174802f, 
    -0.30289471f, -0.07968030f, -0.06430524f, 0.00114810f, 0.11732825f, -0.15816087f, -0.02787069f, -0.07430451f, 
    0.23947622f, -0.07398260f, -0.40615803f, 0.09049252f, 0.13594720f, -0.12800807f, -0.02489262f, 0.07704359f, 
    -0.05724096f, -0.02140881f, 0.06604641f, -0.08853059f, 0.15866527f, -0.00283162f, 0.13317432f, -0.11613599f, 
    0.03847023f, 0.09492291f, 0.03408865f, 0.13322926f, -0.09461877f, -0.05712097f, 0.01951123f, -0.02921497f, 
    -0.06393098f, -0.08088217f, -0.04929395f, -0.05498299f, 0.04190587f, 0.01066274f, 0.05433710f, -0.00842247f, 
    -0.13195002f, 0.20655510f, 0.00493731f, -0.07754744f, -0.05158436f, 0.05632425f, -0.19618592f, 0.04591891f, 
    0.19243449f, -0.07056506f, -0.00555584f, 0.09795951f, -0.00229008f, -0.10944389f, -0.05307230f, 0.04609334f, 
    0.34467110f, 0.10717165f, -0.03433652f, -0.00697559f, 0.01217566f, 0.12345956f, -0.12168559f, 0.21575877f, 
    0.03711050f, -0.04278819f, 0.11182115f, -0.12955689f, -0.03297706f, -0.00576967f, -0.18668862f, -0.12979917f, 
    -0.00550810f, 0.08980180f, -0.22050348f, 0.01506539f, 0.14516807f, -0.00722095f, 0.06884228f, 0.00754318f, 
    0.11718347f, -0.32459402f, -0.00664183f, -0.09270015f, 0.02356781f, -0.15743989f, -0.08276771f, 0.00128570f, 
    -0.00588623f, 0.07820247f, 0.08691276f, -0.00739041f, -0.12660253f, 0.17991298f, -0.04452486f, -0.04937324f, 
    0.10259868f, -0.01863513f, -0.02775252f, 0.18096243f, 0.03540173f, 0.02486294f, 0.03269598f, 0.10759300f, 
    0.60621542f, 0.11391533f, 0.26077396f, 0.11766373f, 0.04714607f, -0.10247273f, -0.00886437f, 0.08111645f, 
    0.01863252f, 0.02656135f, -0.08979193f, -0.06218847f, 0.13792889f, 0.04428999f, -0.13606657f, -0.30489966f, 
    -0.18173771f, -0.07170712f, -0.01317184f, 0.00813664f, -0.08635535f, -0.15466642f, -0.08588779f, -0.01159939f, 
    0.04045963f, 0.06236748f, -0.19767419f, 0.12209807f, 0.23048541f, 0.11655465f, -0.08815056f, -0.17048243f, 
    -0.00450713f, 0.10150094f, 0.03972435f, -0.03020902f, 0.18686338f, 0.31702608f, 0.01586542f, 0.21813858f, 
    0.11973567f, 0.09265942f, -0.00617059f, 0.02374669f, -0.03048809f, -0.10086692f, -0.03864279f, 0.03272457f, 
    0.16694243f, 0.42478514f, -0.00061996f, -0.09465475f, -0.13943693f, 0.11732651f, -0.04628896f, 0.05110493f, 
    -0.02247421f, 0.12117305f, -0.06773672f, 0.01416881f, -0.10158943f, 0.06914499f, 0.15909484f, -0.18746965f, 
    -0.05233906f, 0.08993232f, -0.16011229f, 0.03274732f, -0.06317765f, 0.02910438f, 0.22709146f, 0.08961551f, 
    0.01935599f, -0.05363392f, -0.02482376f, -0.25495732f, -0.09743927f, -0.14580640f, 0.13044113f, 0.22473568f, 
    0.02428199f, 0.02355526f, -0.10571557f, 0.08470181f, 0.17241786f, 0.26290414f, -0.17334533f, -0.15392628f, 
    0.07983813f, 0.25701341f, -0.00533900f, 0.11671525f, 0.13945639f, -0.05246573f, 0.03847470f, -0.11452470f, 
    -0.00366898f, -0.03029942f, 0.04326631f, 0.02923967f, -0.06090904f, 0.02188220f, -0.03949336f, -0.04560897f, 
    -0.02233463f, 0.01855421f, 0.05803485f, 0.00138058f, 0.02057383f, 0.00810143f, -0.06588236f, 0.03337794f, 
    -0.06493668f, -0.08320603f, -0.02191618f, -0.01891098f, -0.07456025f, 0.04239332f, 0.01620258f, -0.00968325f, 
    -0.08340056f, -0.05519341f, -0.04971492f, 0.00816432f, -0.04376293f, -0.08364229f, 0.03661907f, 0.05241858f, 
    0.03383113f, 0.02813187f, 0.01681051f, 0.04356775f, 0.03861875f, -0.05160734f, -0.01203079f, 0.01712991f, 
    0.03745198f, 0.00281533f, 0.05247145f, -0.07808430f, 0.00223160f, -0.01391358f, -0.00729675f, 0.03589474f, 
    -0.01947813f, 0.04647138f, 0.03752578f, -0.07014599f, 0.03305900f, -0.04384362f, -0.05929625f, 0.00436905f, 
    -0.01120669f, 0.01146955f, 0.02206047f, -0.06437283f, 0.04319562f, 0.03327528f, -0.01959172f, 0.04161241f, 
    0.04422654f, -0.04003915f, 0.00633159f, -0.02357533f, -0.02497966f, -0.00183614f, -0.06269672f, -0.06446622f, 
    -0.01514609f, -0.07100078f, 0.01079169f, -0.01900843f, 0.01240599f, -0.05438506f, -0.06814713f, -0.07351679f, 
    -0.06293632f, -0.03418437f, -0.06005497f, -0.06858327f, 0.02850242f, -0.05363351f, -0.00108929f, 0.01587194f, 
    -0.02728447f, 0.05554512f, -0.05493348f, -0.05387585f, 0.03745284f, -0.07387831f, 0.05661238f, -0.01908058f, 
    0.04895230f, -0.03886540f, -0.01761766f, 0.01850011f, -0.04548039f, 0.05163189f, -0.06381376f, -0.03194176f, 
    0.00191964f, 0.00542632f, -0.03356963f, 0.04915646f, 0.04218756f, 0.01326489f, -0.04010243f, 0.06800574f, 
    -0.03709782f, 0.00387203f, 0.01525417f, -0.05731418f, -0.07160178f, -0.00275718f, 0.06061676f, 0.00115352f, 
    0.02065981f, -0.04627133f, -0.03475099f, 0.04084847f, 0.03745280f, 0.04029410f, -0.01023657f, 0.04303601f, 
    0.04692983f, -0.01741303f, 0.02422247f, -0.06353527f, 0.01882781f, -0.01992285f, 0.02911211f, -0.00078372f, 
    -0.06272410f, -0.06873871f, -0.01748663f, 0.00247484f, 0.01935636f, -0.07311057f, -0.00157579f, 0.02820066f, 
    -0.05809649f, -0.05202989f, 0.01704528f, 0.00749444f, 0.04815234f, 0.01950974f, -0.02821036f, -0.00807673f, 
    0.02345876f, -0.02490633f, 0.03705150f, 0.00923149f, 0.04450292f, -0.04127364f, 0.06258506f, 0.04077694f, 
    0.04470618f, 0.00216973f, 0.04937726f, 0.03032876f, 0.01816867f, 0.05940789f, -0.02930987f, -0.07681575f, 
    -0.06583279f, -0.00794301f, -0.05223156f, -0.02590571f, 0.02451131f, -0.05624999f, -0.03128731f, -0.00979215f, 
    0.06415445f, -0.08245961f, 0.02021006f, -0.05935503f, -0.01637013f, -0.07401556f, 0.03517274f, 0.06763031f, 
    -0.02029741f, -0.05465371f, -0.07724209f, 0.05260301f, 0.02875188f, -0.04304856f, -0.05968664f, 0.05094256f, 
    -0.08731040f, -0.26862669f, -0.02013948f, -0.03952419f, 0.01017487f, 0.00518225f, 0.02633833f, -0.01008272f, 
    0.13776320f, 0.10303208f, -0.04547755f, 0.04311021f, -0.16681704f, 0.03202032f, -0.15120031f, -0.04387374f, 
    0.05126096f, -0.00730319f, -0.04951332f, -0.06016625f, 0.12518862f, 0.03313669f, -0.10311955f, -0.22701639f, 
    0.16170612f, 0.19825371f, -0.00086028f, 0.20322105f, 0.08572417f, -0.03198972f, 0.03046143f, -0.11242681f, 
    0.18087205f, -0.02014441f, 0.01089689f, 0.11797929f, -0.13326216f, -0.01252569f, -0.17792889f, -0.11912675f, 
    -0.10431897f, 0.09460088f, -0.04337636f, -0.10649410f, 0.01648648f, -0.01463789f, -0.04521943f, 0.10380059f, 
    -0.34789029f, -0.00732783f, 0.03304983f, 0.16373542f, -0.00849290f, -0.08374780f, -0.12803185f, 0.14910688f, 
    -0.05756432f, 0.08036996f, -0.10656811f, 0.03322374f, -0.09684218f, -0.12940022f, -0.02812596f, -0.26344892f, 
    0.02713789f, -0.19382708f, -0.00951685f, -0.02585944f, -0.02354097f, -0.02419871f, -0.03677285f, -0.14393485f, 
    0.08182357f, 0.50386834f, -0.04042557f, 0.03704006f, 0.02071485f, 0.12533724f, -0.02588378f, 0.02374425f, 
    -0.03965264f, 0.03887260f, 0.07921290f, 0.01569127f, 0.19800375f, 0.14267926f, 0.09378377f, -0.10015281f, 
    0.09810495f, -0.02998778f, -0.12273449f, 0.15619147f, 0.14986001f, 0.00700382f, 0.26383165f, 0.17897856f, 
    -0.44963804f, -0.09641702f, 0.09378217f, -0.09600427f, 0.00303537f, 0.19714399f, 0.09970134f, -0.10346915f, 
    -0.08162563f, 0.01045597f, 0.09620868f, -0.03475047f, 0.49754304f, 0.12495174f, 0.02448214f, 0.22708739f, 
    0.06490742f, 0.10917179f, -0.07564997f, 0.16164081f, 0.01790591f, 0.12421737f, -0.00796190f, 0.04953209f, 
    -0.01159009f, -0.09384377f, -0.07469989f, -0.27908784f, -0.04948028f, -0.01717892f, 0.11870422f, -0.08421715f, 
    0.01163416f, 0.06543428f, 0.13155708f, 0.06627703f, 0.10727850f, 0.02938929f, -0.00664995f, 0.06091241f, 
    0.12673610f, 0.27747568f, 0.11103433f, 0.02414331f, -0.00596676f, 0.02020448f, -0.10483781f, -0.05638095f, 
    -0.20743321f, -0.06836471f, 0.05951101f, 0.16381624f, -0.05171493f, -0.03876942f, 0.13086000f, 0.08462705f, 
    0.07985530f, 0.17698002f, 0.14138675f, 0.19515026f, 0.42936680f, 0.16343547f, -0.09921020f, 0.18422306f, 
    -0.16032720f, 0.02219871f, -0.07674668f, 0.05640030f, -0.00454765f, 0.07467435f, -0.10625759f, -0.00335589f, 
    -0.26464814f, -0.06007214f, -0.03174628f, 0.10348796f, 0.14389190f, 0.03027203f, -0.19601519f, 0.15727958f, 
    0.06932527f, 0.01085951f, 0.09016852f, -0.08812267f, 0.37752324f, 0.07264835f, -0.12350730f, 0.36970866f, 
    0.16351050f, 0.12497910f, -0.07717839f, 0.08476092f, 0.06164157f, 0.11118290f, 0.06087624f, 0.03994842f, 
    -0.34563336f, 0.24205488f, 0.37529922f, -0.10489297f, 0.17766970f, 0.13726883f, -0.10162221f, -0.04701850f, 
    -0.00427689f, 0.06568150f, -0.07813191f, -0.13490784f, -0.01387826f, -0.16854864f, -0.07022006f, -0.04884151f, 
    -0.02642293f, -0.01320237f, 0.06522578f, 0.16389343f, 0.09127145f, 0.00363600f, 0.18698286f, 0.02892749f, 
    0.00263778f, 0.26293546f, 0.03877214f, -0.13371000f, -0.02678610f, 0.28794914f, -0.10505669f, -0.14737892f, 
    0.07759353f, 0.02502762f, 0.08805043f, 0.00470682f, -0.49756572f, -0.03203812f, -0.00247578f, 0.11301282f, 
    -0.02281721f, 0.06194739f, 0.02216793f, -0.04390334f, 0.07658301f, 0.15112655f, 0.05022907f, 0.06007386f, 
    0.35812688f, 0.10363925f, -0.30143353f, -0.09075729f, -0.04852505f, -0.05242788f, 0.01297475f, -0.00082944f, 
    0.05104233f, 0.09346566f, -0.11525871f, 0.06357313f, 0.34047496f, -0.15911280f, -0.13466629f, 0.01597826f, 
    -0.00458749f, 0.02492001f, -0.17412470f, -0.07878140f, 0.05295743f, 0.03957790f, 0.09988595f, 0.08028760f, 
    0.06842621f, -0.03144318f, -0.21904135f, 0.09670160f, 0.14616162f, 0.06985484f, 0.03903414f, 0.01066568f, 
    0.19034864f, 0.07320584f, 0.06853353f, 0.06880009f, 0.00898913f, -0.16872515f, 0.16578481f, -0.07939479f, 
    0.05329993f, 0.16278081f, 0.23127897f, 0.07315061f, -0.07511133f, 0.11103585f, -0.07176565f, 0.11660048f, 
    0.33498353f, -0.32260388f, 0.25725132f, -0.00605594f, 0.00625829f, -0.01385063f, 0.02498849f, -0.13064063f, 
    -0.03755619f, -0.08345720f, 0.10049764f, -0.00315055f, 0.11323351f, 0.18286648f, 0.14693369f, -0.23892002f, 
    0.10589010f, 0.02590175f, 0.10495823f, 0.03214808f, -0.11031224f, -0.09644781f, -0.13906658f, 0.30270070f, 
    -0.13290571f, 0.05333592f, 0.11046851f, 0.21392055f, -0.05844568f, -0.00229299f, -0.00550979f, -0.02196468f, 
    -0.11881699f, 0.08704434f, 0.01764136f, 0.07436942f, 0.08922038f, -0.07435700f, -0.15648887f, 0.17594597f, 
    0.09705042f, 0.09511717f, -0.11067042f, -0.01358008f, 0.02102227f, -0.05848955f, 0.13459381f, 0.01326709f, 
    -0.27686599f, -0.22858718f, -0.10432474f, 0.27955613f, -0.07081444f, -0.03512031f, 0.04657055f, 0.22625293f, 
    -0.08787359f, -0.07320490f, 0.00488921f, 0.18967894f, -0.40827483f, -0.03952033f, 0.33234116f, -0.02168589f, 
    0.08047538f, -0.01855659f, -0.14198776f, 0.00142158f, 0.05391213f, 0.09412429f, 0.02548157f, 0.10616015f, 
    -0.32801473f, 0.01379288f, -0.21489218f, 0.30399236f, -0.07850649f, 0.08140594f, 0.11984435f, -0.06813660f, 
    0.08524357f, 0.06985320f, -0.04810702f, 0.11489729f, -0.16960819f, -0.01707920f, 0.17951991f, -0.26215944f, 
    -0.04664522f, 0.16922617f, 0.02478818f, -0.01227639f, 0.04561939f, 0.07692324f, 0.05024312f, -0.04453830f, 
    -0.00766854f, -0.00878654f, 0.03967585f, -0.01910264f, 0.04753564f, -0.02559161f, -0.01326313f, 0.02427280f, 
    0.03226661f, -0.01070679f, -0.06565076f, 0.05836702f, -0.02109102f, 0.06210635f, 0.04506860f, -0.03313991f, 
    -0.01228048f, 0.01126307f, 0.01320830f, -0.03800848f, 0.00973613f, 0.03983356f, 0.05739919f, -0.03565434f, 
    0.00433518f, -0.02044068f, 0.04629947f, 0.02094822f, -0.01534359f, -0.05525148f, 0.01506527f, -0.01813002f, 
    -0.07095325f, 0.03412155f, -0.04604984f, -0.05874481f, -0.00634346f, 0.00759359f, -0.02711536f, -0.03684359f, 
    -0.03046351f, -0.03141950f, -0.06279882f, -0.03763254f, 0.04549942f, -0.07946038f, 0.05617666f, 0.02206726f, 
    0.00812267f, 0.05450312f, -0.00976836f, 0.00266787f, -0.05565955f, -0.01638692f, -0.00452782f, 0.04319040f, 
    0.02213817f, -0.03557236f, 0.04608075f, 0.05116721f, 0.05354464f, 0.05409413f, 0.04025456f, -0.01534441f, 
    -0.06217514f, -0.03852752f, -0.02394314f, 0.00827592f, -0.03656393f, 0.04624663f, -0.02219016f, -0.05178791f, 
    -0.02815979f, 0.02871426f, -0.04381298f, 0.01707673f, 0.04517334f, 0.04273610f, 0.02639218f, 0.04155708f, 
    -0.06513672f, -0.04545115f, -0.01877226f, 0.00378558f, -0.00088563f, -0.04019578f, 0.04786553f, -0.06143667f, 
    -0.05902237f, 0.00984769f, 0.03241808f, 0.02573003f, 0.05770539f, -0.00347720f, 0.04926387f, 0.02333339f, 
    0.03104134f, 0.02212256f, -0.06590733f, -0.06321464f, -0.04255950f, -0.05675175f, 0.04331765f, -0.06978257f, 
    -0.02226835f, -0.02592070f, -0.03436643f, 0.06412216f, -0.05697208f, -0.00084082f, -0.07559848f, 0.06109232f, 
    0.01227470f, -0.04281915f, -0.05033977f, -0.04646513f, -0.03533472f, -0.03598091f, 0.04428416f, -0.06902532f, 
    0.04363784f, 0.04693460f, -0.07795192f, -0.01744062f, -0.01113791f, -0.03073279f, -0.03203036f, 0.03947470f, 
    -0.05854781f, 0.05382742f, -0.02993924f, -0.04917591f, -0.00390510f, 0.03271771f, 0.00484201f, -0.06563712f, 
    -0.02883879f, -0.01264396f, 0.03048772f, -0.03742972f, -0.02417610f, -0.07398666f, -0.07375862f, -0.04376119f, 
    -0.00904371f, -0.06860464f, -0.04294375f, 0.03392645f, 0.02269655f, -0.04166599f, -0.01777808f, -0.06116560f, 
    -0.02556159f, 0.02098392f, 0.03847820f, -0.07841543f, 0.04260498f, -0.03300027f, 0.06161078f, 0.02451519f, 
    -0.06142540f, -0.03368882f, -0.01487457f, -0.03693316f, -0.01686992f, -0.06107180f, 0.04444998f, 0.03061560f, 
    -0.01270616f, -0.05594108f, 0.04128011f, 0.05295816f, 0.00461639f, -0.05624783f, -0.07247615f, 0.01340149f, 
    -0.01716687f, 0.02382863f, -0.02044382f, -0.07474267f, 0.00583069f, -0.01818195f, 0.02735900f, -0.03041090f, 
    -0.01509817f, 0.04573084f, -0.00486419f, -0.01465744f, -0.07686920f, -0.05953112f, -0.06610672f, -0.02849022f, 
    -0.06111996f, 0.11450191f, 0.09756579f, -0.09985314f, -0.11546560f, -0.03487464f, 0.10349334f, 0.13662045f, 
    0.02976627f, 0.00868919f, 0.06562747f, 0.05985923f, -0.15578189f, 0.13999858f, -0.04156379f, -0.07272417f, 
    0.05096059f, -0.03389295f, 0.10882904f, -0.15006523f, 0.01396013f, 0.06406153f, -0.09620349f, -0.07779802f, 
    0.49264738f, -0.14252630f, 0.19496818f, 0.06929712f, 0.01760777f, -0.18493553f, -0.14181294f, 0.16019562f, 
    0.02596598f, 0.03457708f, 0.11850961f, 0.16185209f, 0.18047024f, 0.04403427f, 0.27422419f, -0.13424279f, 
    -0.08172234f, 0.13910452f, -0.06923467f, -0.13857524f, -0.06172105f, 0.02878415f, 0.02143933f, 0.04541232f, 
    -0.38126749f, -0.05240246f, 0.03910042f, 0.00080312f, 0.20055817f, 0.00879655f, -0.02008277f, -0.12260763f, 
    -0.02686389f, -0.02842803f, -0.06714389f, -0.01001834f, -0.13129899f, 0.09440145f, 0.09682775f, -0.05508645f, 
    -0.02349259f, -0.08484989f, 0.25397021f, 0.09902875f, -0.07514534f, 0.08720141f, -0.02715883f, 0.06534184f, 
    0.04167297f, 0.24073336f, 0.15739119f, 0.14328574f, 0.03338493f, 0.08077309f, -0.09972535f, 0.07781414f, 
    0.11788317f, -0.00988590f, -0.10370413f, 0.09301071f, 0.23080577f, -0.28995332f, -0.04915567f, 0.20807384f, 
    -0.07318921f, -0.03378587f, 0.07337642f, -0.11734834f, -0.02582648f, -0.08795846f, 0.00029989f, 0.00880889f, 
    -0.21696389f, 0.11090930f, -0.41488278f, -0.19459149f, -0.00169353f, 0.10365091f, 0.06363356f, -0.04076406f, 
    0.01094755f, -0.02962871f, -0.02891416f, 0.15092295f, 0.09978360f, -0.04031915f, -0.00051781f, 0.41177666f, 
    -0.07585198f, -0.06808008f, -0.14663486f, -0.03344478f, 0.00950492f, 0.06009680f, -0.00173707f, -0.03604144f, 
    0.11196657f, 0.04732667f, 0.04588994f, -0.17344664f, -0.10818568f, -0.03702243f, 0.00234468f, 0.09162613f, 
    0.07514576f, -0.00393962f, 0.01970408f, 0.17556484f, 0.12368453f, -0.15769091f, -0.03289579f, -0.30676857f, 
    0.01653587f, -0.05969069f, 0.08439106f, 0.05689221f, -0.04063139f, 0.03686172f, -0.11995174f, -0.05480029f, 
    0.20079848f, -0.13889138f, -0.10197544f, -0.29077870f, 0.20390479f, 0.12250734f, -0.03977749f, -0.15414065f, 
    0.07804651f, 0.05953226f, 0.01099179f, 0.03467749f, 0.41224009f, 0.10748896f, -0.06306633f, 0.13859333f, 
    -0.01413492f, 0.07356473f, 0.14538428f, 0.03105425f, -0.01997563f, -0.01210727f, -0.21559112f, -0.03582064f, 
    0.26927629f, 0.17592716f, 0.01937177f, -0.02417955f, 0.16183814f, -0.03175684f, -0.01920647f, -0.09591925f, 
    0.04879337f, -0.02093678f, 0.02794233f, -0.18892860f, 0.12950204f, 0.06629089f, 0.12175523f, 0.28464404f, 
    0.12628280f, -0.26665372f, -0.04371289f, 0.15662865f, -0.09022632f, 0.00561556f, -0.06246389f, 0.19727489f, 
    -0.30978686f, 0.16387308f, 0.31547445f, -0.03974263f, -0.06580612f, -0.12304063f, -0.07267647f, 0.09454672f, 
    0.05283671f, 0.18236250f, -0.22027835f, -0.19264887f, 0.28739142f, -0.09969908f, -0.27906305f, -0.14689410f, 
    -0.09695639f, -0.01366604f, -0.04798225f, 0.15640411f, 0.06434883f, -0.17451611f, 0.21128602f, -0.18542884f, 
    0.21903747f, 0.14233427f, 0.13369064f, 0.07561956f, 0.09040427f, 0.00793038f, -0.02589704f, -0.07537089f, 
    -0.16779484f, -0.04418387f, 0.01532759f, 0.16427059f, -0.14228986f, -0.17787237f, -0.12310686f, -0.02691633f, 
    -0.24098657f, 0.17977673f, 0.06450682f, 0.05415677f, 0.03982566f, 0.13457482f, 0.11908031f, -0.04654575f, 
    0.28047633f, 0.12652349f, -0.00201207f, -0.00223658f, 0.13868155f, -0.07516691f, -0.00640524f, -0.06427030f, 
    -0.18891016f, -0.03045799f, -0.20000075f, 0.07277492f, 0.12050886f, -0.13758138f, -0.15571271f, -0.00574371f, 
    -0.06914273f, -0.10546987f, -0.16131949f, 0.11218269f, -0.04819419f, -0.00728345f, -0.02563445f, -0.00007006f, 
    0.00889327f, 0.39797664f, 0.06687744f, 0.13849273f, -0.21022590f, 0.13003187f, 0.04335897f, 0.12976560f, 
    0.03416876f, 0.05985074f, 0.11719014f, 0.03845546f, 0.21221730f, 0.12867111f, -0.04371975f, -0.14098834f, 
    0.12666696f, 0.13174409f, 0.01727679f, -0.07426105f, 0.17994377f, 0.00028248f, 0.21443179f, 0.39043427f, 
    0.08658379f, 0.12254281f, 0.21199767f, -0.18007821f, -0.00478114f, 0.13190739f, -0.06802268f, -0.10148115f, 
    0.07184151f, -0.05116435f, -0.06260096f, 0.14047647f, 0.20425689f, 0.10099227f, 0.18767500f, 0.16203375f, 
    0.10489789f, 0.13312477f, 0.19358630f, 0.18243103f, 0.01621586f, -0.13409407f, -0.20136006f, -0.00828511f, 
    -0.01538812f, 0.19325672f, -0.02154451f, -0.22014564f, -0.18015869f, 0.06151899f, 0.12532021f, 0.02763616f, 
    -0.02687054f, 0.01639949f, -0.01323576f, -0.00352834f, -0.32576150f, -0.07314125f, 0.06070509f, -0.11376935f, 
    0.08947831f, 0.08991181f, -0.09953357f, -0.06912222f, -0.04212356f, -0.09792551f, 0.02503373f, -0.20889907f, 
    -0.16700120f, -0.14027244f, 0.13834190f, 0.19194400f, -0.05782478f, -0.03929871f, 0.45798573f, 0.17075042f, 
    0.07629984f, 0.12200166f, 0.13503528f, 0.10457566f, 0.34831429f, 0.08121804f, -0.11584310f, -0.05969809f, 
    -0.09825070f, -0.01788597f, 0.01189289f, 0.00900940f, 0.00525942f, 0.21848744f, -0.11641994f, 0.04366399f, 
    -0.54534745f, -0.03034125f, -0.04499551f, 0.24024871f, 0.08544045f, 0.11144339f, -0.06123973f, 0.01783846f, 
    0.20435259f, 0.02743737f, -0.01515063f, -0.02989150f, 0.00930625f, 0.09520554f, 0.23625214f, 0.11509637f, 
    -0.13755733f, 0.01576896f, 0.07279500f, 0.01586491f, 0.12360966f, -0.10013144f, -0.08788569f, 0.15620458f, 
    -0.05635544f, 0.03854843f, -0.06239033f, 0.01339182f, 0.06149008f, 0.00819542f, 0.03197783f, 0.02063495f, 
    -0.05617688f, -0.03553441f, -0.03767061f, 0.00489184f, 0.04155418f, -0.00760262f, 0.06019422f, -0.00712710f, 
    0.02902555f, -0.01678954f, 0.06270862f, 0.04666187f, 0.03114649f, -0.01262960f, 0.02402855f, -0.06973921f, 
    -0.06533697f, -0.04894697f, 0.02373867f, -0.06071577f, -0.03588357f, 0.01600300f, -0.06986414f, -0.05702467f, 
    0.03052101f, 0.06296955f, 0.01425247f, -0.05373380f, 0.06579096f, 0.00490802f, 0.05180325f, -0.05946972f, 
    0.00513523f, 0.03251535f, -0.05151497f, -0.06868757f, -0.03369456f, 0.04700284f, -0.01296836f, 0.02735523f, 
    0.05849376f, -0.02128103f, -0.06636202f, 0.04080059f, -0.07633525f, 0.00186961f, 0.03803614f, -0.03183283f, 
    0.01553542f, -0.04859337f, -0.06152138f, -0.04238050f, 0.00739313f, -0.06003339f, 0.03279981f, -0.00859561f, 
    -0.01559261f, -0.04099609f, -0.00864904f, -0.06057326f, 0.00821726f, 0.05471346f, 0.04012507f, -0.01303473f, 
    -0.03328169f, -0.04270050f, 0.03831134f, -0.05254891f, -0.05722453f, -0.04316325f, -0.00062871f, -0.01550223f, 
    -0.06419648f, 0.06051404f, 0.06287787f, 0.03810724f, -0.05528265f, 0.05573791f, -0.03755716f, -0.07668027f, 
    0.00871245f, -0.05621906f, -0.07770642f, -0.05006967f, 0.05015717f, 0.03641653f, -0.01732020f, 0.05615631f, 
    -0.00035366f, -0.06481554f, 0.01118612f, -0.02515985f, -0.00869590f, -0.05727992f, -0.01206939f, -0.04056879f, 
    -0.03722247f, -0.04403154f, -0.02567826f, -0.02787179f, -0.02737315f, -0.02924347f, -0.04318870f, 0.03144039f, 
    -0.03996428f, -0.05855080f, -0.00409361f, 0.00997625f, -0.00851022f, -0.03629708f, -0.01251147f, -0.01147784f, 
    -0.05313357f, 0.01012024f, 0.05681129f, 0.00031921f, -0.03276766f, -0.06472160f, 0.01891976f, 0.02709563f, 
    0.00081870f, -0.06369345f, -0.03293933f, -0.06458209f, -0.04551083f, 0.04004678f, 0.06355213f, 0.01397288f, 
    -0.06265337f, -0.07887293f, -0.05639042f, 0.04138540f, 0.01841217f, -0.06384820f, -0.00227394f, 0.00058682f, 
    0.06169170f, 0.01460976f, 0.00922308f, -0.06442858f, -0.05126831f, 0.04871755f, 0.04482701f, 0.04842249f, 
    -0.03764170f, 0.00069023f, -0.03789518f, 0.03994392f, 0.03094440f, -0.05404307f, -0.02443412f, -0.06418839f, 
    -0.03878679f, 0.02763087f, -0.05272859f, 0.00199299f, -0.00763173f, -0.03476245f, -0.01012361f, 0.05613268f, 
    -0.05416061f, -0.02756538f, 0.02189379f, 0.01988729f, -0.02800623f, -0.01931267f, -0.06602134f, 0.02385435f, 
    0.00199001f, -0.04597639f, 0.01058183f, -0.07149889f, -0.01202512f, -0.02902399f, 0.04473323f, -0.04584771f, 
    0.03365280f, 0.05377006f, -0.05067118f, 0.01241806f, 0.03467521f, -0.02721361f, 0.05183507f, -0.07277563f, 
    0.01121682f, -0.25267315f, -0.12545773f, 0.03734902f, 0.17369200f, 0.05638778f, -0.16589110f, -0.04457206f, 
    -0.03956811f, -0.26465845f, 0.22319062f, 0.03904889f, -0.17545213f, 0.04856944f, 0.27869165f, 0.26375192f, 
    0.01859285f, -0.04952176f, 0.00365195f, -0.03529954f, -0.10181269f, -0.00351833f, -0.08318622f, 0.07164349f, 
    -0.16353764f, 0.14768200f, -0.11560168f, -0.10266417f, -0.31613070f, 0.11063548f, -0.00700246f, -0.01048734f, 
    0.05247747f, -0.04579386f, 0.12754348f, -0.02873084f, 0.53890705f, 0.02966789f, -0.00574361f, 0.23273453f, 
    -0.07391725f, 0.01664690f, -0.15468323f, -0.08921451f, 0.00331144f, -0.01885118f, -0.06711248f, 0.00528045f, 
    0.17743845f, -0.16157101f, -0.03156340f, -0.06269370f, 0.06884766f, 0.09109274f, -0.14475936f, 0.01320439f, 
    0.13275900f, 0.02774568f, 0.20845087f, -0.02215699f, 0.22202316f, 0.07175474f, 0.08146841f, 0.10711711f, 
    0.16631086f, -0.04170089f, -0.19955528f, -0.18115225f, 0.01099683f, 0.01755526f, 0.14372902f, -0.00976452f, 
    -0.26831323f, -0.00699899f, 0.08896973f, 0.00726882f, 0.16172948f, -0.11292205f, -0.12856057f, -0.04642210f, 
    -0.04965670f, 0.04585725f, -0.06669534f, -0.00284508f, 0.07953894f, -0.19742315f, 0.05218991f, 0.02712343f, 
    -0.10311118f, 0.04708023f, 0.13010733f, 0.09617899f, -0.12008801f, 0.10865409f, -0.10924121f, -0.16067588f, 
    0.28909823f, -0.02092252f, 0.25789821f, 0.16164304f, 0.13347264f, -0.08953978f, 0.08642124f, 0.09259389f, 
    0.06808311f, 0.03085552f, -0.00848582f, -0.11275079f, 0.07173279f, 0.31775385f, -0.08878993f, -0.12056270f, 
    0.11876570f, 0.04200586f, -0.04164666f, -0.03081420f, 0.01000548f, 0.18070854f, 0.04670847f, 0.08599554f, 
    -0.07161330f, -0.25521517f, 0.10102623f, 0.36520714f, 0.31053644f, 0.04411633f, -0.15647835f, -0.17810544f, 
    -0.12992437f, -0.13330057f, -0.00637363f, -0.06367257f, 0.42516696f, 0.07899970f, 0.00552563f, 0.13931382f, 
    -0.20669597f, 0.00591755f, -0.16804346f, 0.16388874f, 0.10904096f, -0.06222307f, -0.04210950f, 0.11772920f, 
    0.30084497f, 0.22856680f, 0.11747903f, 0.05344495f, -0.04092795f, 0.07146926f, -0.27276197f, 0.35410550f, 
    -0.02621936f, -0.06118381f, -0.02978551f, -0.09410989f, -0.34434712f, 0.13256323f, 0.38937888f, 0.28615341f, 
    0.15991384f, 0.16481818f, 0.05706792f, 0.16938590f, 0.15837762f, -0.01417843f, 0.12655768f, -0.00151322f, 
    0.04654069f, 0.01567389f, 0.09010445f, -0.04882681f, -0.14098062f, -0.06096862f, -0.03078956f, -0.14425562f, 
    -0.10136896f, -0.02988401f, -0.09602848f, 0.23299330f, -0.17794625f, -0.15980756f, -0.26345870f, -0.46543956f, 
    -0.03610507f, 0.00737646f, 0.01406488f, 0.10309444f, -0.08923142f, 0.02527776f, 0.13946453f, -0.07598113f, 
    0.42181900f, 0.22521915f, -0.19069035f, -0.17913963f, 0.31930512f, 0.03176928f, -0.05282754f, -0.11655616f, 
    -0.08245943f, 0.03258431f, -0.00891363f, -0.12585235f, 0.12049002f, -0.06220824f, 0.08586701f, -0.02132564f, 
    -0.15249850f, 0.04776747f, 0.15493052f, 0.16929731f, -0.08106966f, 0.14823586f, 0.14569409f, -0.06799952f, 
    0.07627651f, -0.11961657f, -0.04279815f, -0.27427453f, 0.03763218f, 0.15568982f, 0.04499994f, -0.03731903f, 
    0.01258799f, 0.13204207f, 0.01651880f, -0.01847115f, -0.21627608f, 0.17830026f, 0.02786779f, 0.13344407f, 
    0.00047920f, -0.07057462f, 0.16811305f, 0.17219254f, 0.01604248f, -0.01510186f, 0.02852227f, -0.00362827f, 
    0.36571342f, 0.09673876f, -0.20291840f, -0.00591345f, -0.05109119f, 0.11771476f, -0.06491047f, 0.09123752f, 
    -0.08625324f, 0.02536360f, 0.13650690f, -0.06959963f, 0.18977845f, -0.15147625f, -0.07617002f, 0.12270002f, 
    -0.18556689f, 0.15743920f, -0.06018426f, -0.07728213f, 0.00930896f, 0.12085151f, 0.16679937f, 0.07964671f, 
    0.29342100f, -0.29501596f, -0.05350964f, 0.16488723f, 0.21831308f, -0.22406422f, -0.12069199f, -0.00187578f, 
    0.18209228f, 0.16481851f, -0.08052073f, 0.05545004f, -0.18138462f, 0.01336981f, 0.04359769f, 0.02432661f, 
    0.18453847f, -0.07752974f, 0.28067786f, 0.18771841f, 0.05269127f, 0.10429290f, -0.09043080f, 0.22026163f, 
    0.63394898f, -0.23047367f, 0.03427484f, 0.14537022f, -0.05853073f, -0.08858883f, -0.04722338f, 0.10614900f, 
    0.04476947f, 0.01289626f, 0.09616614f, 0.06647199f, -0.03182569f, 0.00502953f, -0.15249357f, -0.24064735f, 
    0.02733702f, -0.06271345f, 0.05592246f, -0.06832292f, -0.06779160f, -0.24647766f, -0.04461877f, 0.09720545f, 
    0.36967263f, 0.17369528f, -0.00699682f, 0.23197311f, 0.07417747f, 0.12364192f, -0.03184684f, 0.02478214f, 
    -0.09446991f, -0.11090735f, 0.08019049f, -0.08392210f, 0.37938967f, 0.13263667f, -0.08552062f, -0.06360779f, 
    0.05016977f, -0.02366406f, -0.16241464f, 0.04470940f, -0.03816600f, -0.15487355f, 0.09919904f, 0.06152920f, 
    -0.06570659f, 0.04438552f, -0.21691237f, 0.01631439f, -0.04194125f, -0.00216322f, 0.02967458f, 0.10233746f, 
    0.13818322f, 0.04419892f, 0.01179801f, 0.15067247f, -0.36500636f, -0.25264123f, 0.17170255f, -0.27591294f, 
    -0.18624610f, 0.02765039f, -0.08629262f, -0.01118871f, -0.05834093f, 0.04376155f, 0.08209684f, 0.13022968f, 
    0.11673069f, 0.02846339f, -0.14695944f, 0.11965047f, -0.17503883f, -0.12716235f, 0.06582648f, 0.00917121f, 
    0.12615009f, 0.00127344f, -0.23632133f, -0.01054900f, -0.14270402f, 0.28279507f, -0.01217073f, -0.18870005f, 
    0.08735147f, 0.22565459f, 0.03938202f, -0.00675326f, -0.07986595f, -0.02670374f, -0.13462593f, -0.04743324f, 
    -0.01500074f, -0.08923423f, -0.26161978f, 0.49971417f, -0.10717019f, 0.11123861f, -0.00584366f, 0.19468728f, 
    0.13855088f, -0.09740167f, -0.12062845f, -0.11196660f, 0.25247610f, 0.29425356f, -0.14660735f, -0.13746685f, 
    0.12345157f, 0.08515147f, -0.19768335f, 0.09585517f, -0.00219041f, -0.05313208f, 0.06004089f, -0.12764427f, 
    0.15635170f, -0.06802995f, 0.30560109f, 0.17756140f, 0.03003483f, 0.12749858f, -0.09120737f, -0.10009793f, 
    0.01910847f, 0.14420158f, -0.00258193f, -0.01459530f, 0.15294163f, -0.18841936f, -0.11114001f, -0.03110926f, 
    -0.10372748f, 0.03205000f, 0.06310505f, 0.01319187f, 0.22555287f, -0.01941520f, -0.13540326f, -0.03261781f, 
    -0.14410092f, 0.56165814f, 0.04074404f, -0.30606380f, 0.08550303f, 0.19332400f, 0.00984605f, 0.13790515f, 
    0.03860120f, -0.04633997f, -0.03127336f, -0.00814240f, -0.24948217f, 0.10503947f, -0.07575485f, 0.04753686f, 
    -0.01822491f, -0.04914657f, -0.09606709f, 0.28954563f, 0.03057633f, 0.10737570f, 0.07476015f, 0.03213169f, 
    0.73397827f, -0.05157746f, -0.21018146f, -0.08785909f, 0.01638964f, -0.07909064f, 0.05608405f, 0.03133654f, 
    -0.07534511f, 0.00868396f, -0.01634209f, -0.05480808f, -0.02407787f, 0.01338844f, 0.05546260f, -0.06417656f, 
    -0.03039409f, -0.06503662f, -0.15773839f, -0.05854474f, 0.04033842f, -0.00998389f, 0.09878742f, -0.06860720f, 
    -0.01821540f, 0.28893158f, 0.02937484f, -0.03331383f, 0.16237055f, -0.23383601f, -0.11733090f, 0.20032054f, 
    -0.00833853f, -0.07639285f, -0.10532741f, 0.02547510f, -0.07523223f, 0.10369393f, 0.14267398f, -0.26571724f, 
    -0.01142440f, 0.14264144f, 0.10761865f, 0.18180773f, 0.02151767f, 0.09902944f, 0.03161804f, -0.03303854f, 
    -0.19352289f, 0.27352139f, -0.06914457f, 0.29531416f, -0.08639112f, 0.13175067f, 0.11779597f, 0.02759268f, 
    -0.00521628f, 0.12589402f, 0.17806691f, -0.19287342f, 0.17490354f, -0.27069697f, 0.12283785f, 0.16366909f, 
    -0.01081413f, -0.04964449f, 0.08345478f, 0.01794172f, 0.06060279f, -0.02593759f, 0.05260688f, 0.02889611f, 
    -0.27319795f, -0.13947313f, 0.14795382f, 0.02172357f, -0.06927992f, 0.01256841f, -0.00271927f, 0.05248202f, 
    0.09525308f, 0.15712540f, 0.21089463f, 0.01082158f, -0.14783357f, -0.24322496f, -0.00629600f, 0.03918814f, 
    -0.09776700f, -0.14323056f, -0.05491192f, -0.07307518f, 0.09105685f, 0.04423359f, -0.08614971f, 0.15384330f, 
    -0.01028767f, -0.28381321f, 0.05743403f, -0.11240185f, 0.08375725f, -0.05036311f, -0.09492759f, 0.08906525f, 
    -0.20364599f, 0.01533596f, -0.02291765f, -0.07134212f, 0.14884615f, 0.05475598f, -0.09707306f, 0.04911951f, 
    0.04887095f, 0.07240737f, 0.21009010f, -0.11905470f, 0.00079898f, -0.03710553f, 0.05226971f, -0.04396895f, 
    0.14900959f, -0.21958758f, 0.14101513f, -0.00438844f, 0.00657123f, -0.05720714f, 0.08107278f, -0.01535329f, 
    -0.01207282f, 0.02779614f, -0.04501260f, 0.08749773f, -0.10725224f, 0.09519162f, 0.08208603f, 0.11333738f, 
    -0.04420812f, -0.00467821f, 0.02076491f, -0.09978820f, 0.07784945f, -0.02470122f, -0.13308565f, 0.04399063f, 
    0.05578705f, 0.08409093f, -0.00190565f, 0.11009831f, 0.16450597f, -0.07843713f, 0.10306763f, 0.08607051f, 
    0.07792420f, -0.00636672f, -0.10232419f, 0.10074803f, -0.35276484f, 0.00966796f, 0.05207717f, -0.06432013f, 
    -0.07491691f, 0.09527972f, 0.05883246f, 0.12650633f, 0.05930237f, -0.01252185f, 0.04701381f, 0.05042353f, 
    -0.33349940f, 0.16079535f, -0.07554123f, 0.29830000f, -0.03214765f, -0.13161899f, -0.07289909f, 0.07937568f, 
    -0.07379124f, 0.16980441f, 0.03212029f, 0.04148100f, -0.07220629f, -0.02157650f, 0.09115518f, -0.08962513f, 
    0.08587784f, -0.07878289f, 0.18922047f, 0.06381085f, 0.00769196f, 0.02910767f, -0.11845918f, -0.13896310f, 
    -0.12172756f, 0.22465193f, 0.18089055f, 0.11538481f, 0.01805159f, 0.10538639f, -0.04160484f, -0.02586029f, 
    -0.01795976f, 0.01046868f, 0.07951850f, 0.02240755f, -0.01471573f, 0.22584116f, 0.14267920f, -0.21134771f, 
    0.09417431f, 0.08478473f, -0.03557008f, 0.02801949f, 0.04475428f, 0.04885052f, 0.21063012f, 0.12529157f, 
    -0.47709352f, 0.10136137f, 0.02216948f, 0.10345518f, -0.16903675f, 0.15114401f, 0.09384523f, -0.13065571f, 
    -0.08231214f, -0.03083646f, 0.13641472f, -0.04581955f, 0.46764788f, 0.01714513f, -0.25399840f, 0.26567674f, 
    -0.01601604f, 0.07005527f, -0.06572690f, -0.01629313f, 0.04904456f, 0.08633593f, 0.16688427f, -0.01464487f, 
    0.03390503f, -0.04151230f, -0.04713713f, -0.31887671f, 0.06839169f, 0.05280064f, 0.08415375f, 0.09026290f, 
    -0.01172135f, 0.16495775f, 0.15439756f, 0.04826672f, 0.10809448f, 0.15401420f, 0.14031045f, -0.04737058f, 
    -0.04980675f, 0.11378700f, 0.15126392f, -0.06300528f, 0.01148946f, 0.12011231f, -0.10613685f, 0.00050858f, 
    -0.09452299f, 0.01734860f, 0.00618267f, 0.19682802f, -0.08737873f, -0.10342686f, 0.13132179f, -0.07640682f, 
    0.08841906f, 0.03410548f, 0.10651667f, 0.05029091f, 0.44424820f, 0.24644829f, -0.23277088f, 0.20326497f, 
    -0.06553193f, 0.07642704f, -0.01484589f, 0.01276629f, 0.05212857f, 0.09724629f, -0.07362891f, -0.02943055f, 
    -0.23645011f, 0.02445349f, 0.03887274f, 0.23048335f, 0.02719996f, 0.01098323f, -0.03744336f, 0.04691394f, 
    -0.04340929f, 0.04632055f, 0.11858383f, -0.10807753f, 0.19595848f, -0.04363161f, -0.15960240f, 0.56145620f, 
    0.06522236f, -0.09600087f, -0.03642463f, -0.03679486f, 0.09722330f, 0.20613761f, 0.06991206f, -0.01278832f, 
    -0.08530400f, 0.23529714f, 0.31729132f, -0.01161081f, -0.06976435f, 0.15673362f, 0.06928940f, -0.06433759f, 
    0.03254896f, -0.02478863f, -0.08577422f, -0.01246311f, 0.28674093f, 0.18051490f, 0.01485621f, 0.17352639f, 
    0.10824482f, 0.01228143f, -0.00652203f, 0.08200642f, -0.12325160f, -0.13390462f, 0.06262283f, 0.05272128f, 
    0.07598011f, -0.06076846f, 0.22291344f, -0.21218525f, 0.01286129f, 0.12838753f, -0.00378047f, 0.10133564f, 
    0.03705600f, -0.13696937f, 0.01504482f, 0.09912754f, 0.24636646f, -0.09037434f, 0.16046904f, 0.01945499f, 
    -0.16720678f, 0.00795813f, 0.10850043f, 0.00785580f, 0.14696126f, -0.02417006f, -0.11123522f, 0.01040533f, 
    -0.10200047f, 0.21872734f, -0.31349885f, -0.30781761f, 0.07479285f, 0.10340530f, 0.06153366f, -0.11377048f, 
    0.03700556f, -0.01911732f, -0.05696294f, 0.02565300f, 0.33843529f, 0.29265276f, 0.04138255f, 0.14906086f, 
    -0.07585163f, 0.09290255f, -0.00598327f, 0.18504602f, -0.01319330f, 0.10992426f, 0.11029489f, 0.09321480f, 
    0.05971913f, -0.39207378f, 0.04387284f, -0.28515002f, 0.06620089f, -0.12101702f, 0.10860629f, 0.00124404f, 
    -0.01654017f, 0.00624861f, 0.00761127f, 0.05659074f, 0.04858945f, 0.03639850f, -0.03313263f, -0.15345961f, 
    -0.16090600f, 0.10462655f, 0.01355424f, -0.00861601f, -0.24322599f, -0.02249022f, -0.15992077f, -0.11776309f, 
    -0.00270522f, 0.08689314f, -0.22881186f, 0.13733007f, -0.01874018f, -0.16354685f, 0.00548820f, 0.07172593f, 
    0.16385722f, 0.06561875f, -0.04168151f, -0.06988641f, -0.28938434f, -0.00532079f, 0.18090001f, -0.15270597f, 
    0.29440993f, 0.04750812f, 0.26192057f, 0.15817650f, 0.04363260f, 0.19066264f, 0.15173092f, -0.01633861f, 
    -0.05054864f, 0.21291684f, 0.16215253f, -0.02347630f, -0.16609132f, -0.04131990f, 0.06165949f, 0.00833919f, 
    -0.06658903f, -0.12103576f, -0.02487319f, -0.23623203f, 0.40137506f, -0.22517784f, 0.15520668f, 0.05887539f, 
    -0.18139359f, 0.01481578f, -0.08121791f, -0.03212047f, 0.16239655f, -0.06693454f, 0.16035196f, 0.00713367f, 
    -0.08718432f, -0.27743766f, 0.07309600f, 0.16400830f, 0.05802312f, -0.15344951f, 0.07246394f, 0.11730310f, 
    0.05015178f, -0.18719471f, 0.28189442f, -0.03525300f, -0.22529590f, -0.25398937f, -0.05478664f, 0.26175168f, 
    0.18993995f, -0.02751373f, 0.17077425f, 0.17261197f, 0.11885042f, 0.05052800f, 0.09773546f, 0.06100462f, 
    -0.09577440f, -0.06695711f, 0.14631318f, -0.04006280f, -0.01240537f, 0.01007774f, -0.06927423f, -0.19869748f, 
    0.09447858f, -0.07412802f, -0.11802281f, 0.02982904f, -0.41352829f, -0.29128832f, 0.14032993f, -0.14751346f, 
    -0.11412343f, -0.04087177f, 0.16205566f, -0.10783487f, -0.17511493f, 0.10903986f, 0.03715428f, 0.08742178f, 
    0.17135930f, -0.15308587f, 0.02998110f, -0.39835703f, 0.25103724f, -0.07386056f, 0.03850897f, -0.08772365f, 
    0.00254396f, -0.02855276f, 0.12888536f, 0.35402668f, 0.19921698f, -0.00743137f, 0.18948153f, 0.26723921f, 
    0.07872234f, 0.07853827f, 0.29100698f, -0.01143023f, -0.00505187f, 0.11620087f, -0.26504898f, 0.27654323f, 
    -0.10854249f, -0.13220789f, 0.05190697f, 0.18715852f, 0.18369165f, -0.01362685f, 0.21299013f, 0.19874357f, 
    0.21683995f, -0.06242270f, 0.00180144f, -0.04335919f, -0.37532625f, 0.10417855f, 0.04848965f, 0.05764369f, 
    0.20948870f, -0.05726001f, 0.05531324f, 0.12078942f, 0.02018199f, -0.08546894f, -0.00175814f, 0.11740775f, 
    0.02686087f, -0.24261290f, -0.09405284f, 0.11061141f, 0.08029524f, -0.02399311f, -0.06852956f, 0.03841170f, 
    0.07921204f, 0.05825314f, 0.15789957f, 0.02396106f, -0.19951156f, -0.04026255f, -0.09989046f, -0.23474853f, 
    0.08356502f, 0.13478750f, 0.01359617f, 0.09510519f, 0.16728584f, 0.06256755f, 0.00290490f, 0.06590518f, 
    -0.82893330f, -0.57534772f, 0.07125775f, -0.20688790f, 0.29448339f, -0.01805723f, -0.03398610f, -0.16591072f, 
    0.17968082f, 0.07545142f, -0.03089838f, -0.00072810f, -0.24449253f, -0.05622681f, 0.26756898f, -0.05912092f, 
    0.19173715f, -0.06116762f, 0.03321920f, -0.00230227f, 0.05334951f, 0.11256408f, -0.13984881f, -0.11128855f, 
    0.04945508f, -0.02311857f, -0.21591333f, 0.17909263f, -0.17092668f, -0.08691960f, -0.03644841f, -0.00368771f, 
    -0.05926520f, 0.05457630f, 0.05398090f, -0.16212724f, 0.08570106f, -0.29375061f, -0.14005567f, 0.00297359f, 
    -0.12990367f, 0.04007294f, 0.07664160f, -0.19845808f, 0.08204695f, 0.15147333f, 0.25798145f, 0.03313020f, 
    0.01091950f, -0.36378238f, -0.36087769f, -0.42877930f, 0.25922546f, 0.08590756f, -0.22817907f, 0.03213445f, 
    0.19417910f, 0.08307946f, 0.01664688f, 0.13592148f, 0.06420084f, 0.11782353f, -0.11142398f, 0.20958903f, 
    -0.09160367f, 0.08397342f, -0.00446201f, 0.03178155f, 0.11548382f, -0.01862668f, 0.04093123f, -0.03522601f, 
    0.42287943f, 0.06869182f, -0.05294845f, -0.05026386f, 0.04706860f, -0.00717680f, -0.11732143f, -0.01531527f, 
    0.07916796f, -0.29033080f, -0.22841497f, -0.13796112f, 0.16707432f, -0.08350323f, 0.12163496f, -0.06979135f, 
    -0.04946171f, 0.12126957f, 0.03915944f, 0.08276304f, 0.07228996f, -0.07770526f, 0.07371233f, -0.08451636f, 
    0.04455490f, 0.14754640f, -0.27665401f, -0.15599011f, 0.01950289f, 0.14254691f, 0.02236142f, -0.12654231f, 
    -0.01275510f, 0.08556905f, 0.20161273f, 0.09049606f, 0.11216091f, -0.17236973f, 0.12431379f, -0.00447592f, 
    0.17591612f, 0.06275164f, -0.19507538f, 0.25657356f, 0.06448118f, 0.16245323f, -0.10628976f, 0.04531004f, 
    -0.01267042f, -0.00157661f, -0.02439570f, -0.06409118f, 0.06695481f, 0.00168728f, 0.00883714f, -0.02354647f, 
    0.05389403f, -0.07249501f, -0.06022244f, -0.05981004f, 0.00834089f, -0.09881293f, -0.07564805f, -0.03492125f, 
    0.05663723f, 0.00324327f, 0.00595451f, 0.06026806f, -0.04667113f, -0.02018582f, 0.05435745f, -0.06355756f, 
    -0.07681488f, 0.02431032f, -0.02044374f, -0.03578702f, 0.00327699f, 0.01913595f, -0.04933912f, 0.04289591f, 
    -0.04498003f, -0.04263015f, -0.07267154f, -0.05631393f, -0.06551454f, 0.05780210f, 0.04201616f, -0.05795053f, 
    0.01534845f, 0.03158146f, -0.07745539f, 0.05432154f, -0.04724649f, -0.05280800f, -0.02618573f, 0.00284619f, 
    -0.06062455f, -0.00680247f, 0.01256142f, 0.04926192f, 0.04301762f, -0.02734290f, -0.04682085f, -0.07236557f, 
    0.02706036f, -0.02371651f, -0.07805646f, -0.02087625f, -0.02888220f, -0.05184424f, -0.09410115f, 0.00777936f, 
    0.05847295f, -0.00753892f, 0.04251345f, 0.03878832f, 0.01005841f, -0.00037547f, 0.03053331f, 0.04196177f, 
    -0.03599073f, -0.03857278f, -0.06545590f, -0.00386154f, 0.02011126f, -0.00573960f, -0.02754080f, -0.01688448f, 
    0.03236825f, -0.01858586f, -0.08494767f, 0.05667675f, 0.05503323f, -0.01910131f, 0.02731476f, -0.02800772f, 
    -0.04467809f, 0.04915368f, 0.06795903f, 0.03810185f, 0.00845809f, -0.01121835f, -0.03032152f, -0.05808814f, 
    -0.02715254f, -0.06754976f, 0.02510564f, -0.01745032f, -0.03929309f, -0.03426576f, -0.02557723f, -0.06093362f, 
    -0.01119439f, 0.03623309f, 0.00385801f, -0.02237418f, 0.03881371f, -0.07600768f, -0.06852469f, 0.03049971f, 
    0.04590167f, 0.03502339f, 0.05877900f, -0.06856833f, -0.04951802f, 0.05036299f, -0.06247902f, -0.00367354f, 
    0.03986891f, 0.01211505f, -0.06905122f, -0.01798255f, 0.02732291f, 0.04079580f, -0.08347943f, -0.07259473f, 
    -0.06456910f, -0.07277763f, -0.04163622f, -0.07149323f, -0.07095677f, 0.00773145f, -0.00605700f, -0.08256124f, 
    0.02958056f, -0.03232957f, -0.04581867f, 0.04471515f, 0.05519406f, -0.01504366f, 0.01813562f, 0.04874181f, 
    -0.01354309f, -0.08130321f, -0.01701199f, 0.01287645f, 0.03921176f, 0.04389219f, -0.01497080f, -0.07228659f, 
    -0.06881206f, -0.05500010f, 0.00605495f, 0.01480870f, 0.04099262f, -0.03516151f, 0.02110836f, -0.07815488f, 
    0.02493717f, -0.04353642f, -0.03557690f, -0.07405846f, -0.04227144f, 0.06520344f, 0.06721589f, 0.01086648f, 
    -0.04132425f, 0.01134668f, 0.03434970f, -0.06436887f, -0.02898280f, -0.06863653f, -0.03408337f, -0.06569287f, 
    -0.03577884f, -0.01586435f, -0.04934163f, -0.01985314f, -0.02771074f, -0.02725907f, 0.08373468f, 0.02214701f, 
    0.05294700f, -0.05534158f, -0.01140747f, 0.04308160f, 0.03536644f, 0.04727014f, -0.01474909f, -0.04702994f, 
    0.00285590f, 0.38955092f, 0.09096649f, 0.02363982f, 0.01913571f, -0.03351277f, -0.16559333f, 0.15881321f, 
    -0.04458595f, 0.05426325f, 0.08176704f, -0.09469879f, -0.36507893f, -0.31174719f, -0.16250789f, -0.21647541f, 
    0.01751619f, -0.03948957f, 0.04108144f, 0.00269725f, 0.07532258f, 0.08444498f, 0.11901874f, -0.19044562f, 
    -0.07599792f, 0.09255716f, -0.04750431f, 0.11256397f, -0.05403506f, 0.13938403f, 0.17203769f, -0.07567474f, 
    -0.07777566f, 0.06059545f, 0.04204712f, 0.07849018f, 0.32185167f, 0.15967000f, 0.09343769f, -0.03166271f, 
    0.17740285f, -0.09205632f, 0.04232157f, -0.07667209f, 0.05913394f, 0.05173858f, 0.17553802f, -0.08208869f, 
    0.17762703f, -0.59789467f, 0.08521914f, -0.27308276f, 0.17391324f, 0.00242161f, -0.18864407f, 0.08459860f, 
    0.01727607f, -0.16548593f, 0.01000563f, -0.05318625f, 0.02704867f, -0.10126323f, -0.06855243f, 0.04343135f, 
    0.04727436f, 0.03959907f, -0.04797252f, -0.13192891f, 0.01479427f, 0.01299505f, 0.07738858f, 0.08882318f, 
    -0.08359603f, 0.27246955f, 0.25216755f, 0.21118464f, 0.06629024f, 0.00961160f, -0.00779646f, 0.19234292f, 
    0.02914515f, 0.11863104f, -0.09949227f, 0.01495573f, 0.01170136f, -0.05694440f, 0.16850415f, 0.30607098f, 
    0.07149031f, -0.16144197f, 0.08994105f, 0.03957428f, 0.19060138f, 0.06255249f, -0.07035659f, 0.21007912f, 
    0.12042698f, -0.32957140f, -0.22579882f, -0.37948588f, 0.14118496f, -0.03727534f, -0.07073542f, 0.08664320f, 
    0.20958921f, 0.07495480f, 0.00904068f, 0.23493440f, -0.31723014f, -0.10986998f, 0.15688205f, 0.23225808f, 
    0.13074043f, 0.14757723f, -0.16634563f, 0.06596345f, 0.03796699f, -0.15570520f, -0.04100681f, 0.17293009f, 
    0.18415128f, -0.11272649f, 0.17529660f, 0.20238093f, -0.09455594f, -0.15509893f, 0.08823878f, 0.03038301f, 
    0.10806438f, -0.01329021f, -0.05204590f, 0.23990849f, -0.47548395f, -0.19830050f, -0.31407726f, -0.00105096f, 
    0.17656298f, -0.21277541f, -0.20890464f, 0.18262921f, -0.14287968f, -0.15364535f, 0.01646778f, 0.00549213f, 
    0.12911862f, -0.26188424f, -0.11165455f, -0.29991463f, 0.09590034f, -0.02787858f, -0.02197846f, 0.09714016f, 
    0.09778529f, 0.22788723f, -0.09669574f, 0.12868986f, -0.23247060f, -0.18225321f, 0.13697353f, -0.13735510f, 
    -0.14884500f, -0.16033082f, 0.00197220f, -0.05464543f, 0.21241838f, -0.18474494f, -0.15477440f, 0.08482697f, 
    0.13764547f, 0.26218411f, 0.14294739f, -0.16056412f, 0.08077008f, 0.06705171f, 0.13775764f, 0.02565520f, 
    0.06213387f, 0.10320680f, -0.01238477f, -0.02339514f, 0.07832576f, 0.17358750f, 0.46307525f, -0.12936702f, 
    -0.08045119f, 0.06643170f, 0.08064642f, 0.12132487f, 0.05303160f, -0.15821320f, 0.07191417f, 0.11654849f, 
    0.19250396f, 0.10245109f, 0.54553318f, -0.33232197f, 0.04306326f, 0.08146885f, -0.13287896f, -0.02716660f, 
    0.04554034f, 0.11156081f, -0.06460191f, 0.03879927f, 0.17181899f, -0.14231496f, 0.01158651f, 0.11708262f, 
    0.12655525f, 0.05204981f, 0.04984610f, 0.21461080f, -0.03329215f, -0.15111026f, -0.01468867f, -0.23851016f, 
    -0.39256978f, 0.35382545f, -0.28174257f, -0.06438342f, 0.11172269f, 0.01252785f, 0.13970485f, -0.14176141f, 
    0.05452327f, 0.01765503f, 0.00505939f, 0.13035861f, -0.23144078f, 0.32847431f, -0.15886979f, 0.08052659f, 
    0.16120385f, -0.02020361f, 0.19545361f, 0.04972142f, 0.10949714f, -0.00078216f, 0.10378622f, 0.07337580f, 
    0.27910817f, -0.37366620f, -0.25613740f, 0.22401792f, -0.01605080f, 0.00270856f, 0.02120785f, 0.07168066f, 
    -0.12635359f, 0.02551595f, -0.02798961f, -0.01207253f, 0.38237548f, -0.01646717f, -0.04819140f, -0.22336717f, 
    0.26838368f, 0.06620106f, -0.12911673f, 0.07054435f, -0.03937384f, -0.07739867f, 0.05414031f, 0.07269483f, 
    -0.23987319f, 0.15071291f, 0.25042883f, -0.04554775f, 0.36363602f, 0.09177259f, 0.20606719f, -0.18632905f, 
    -0.00138928f, -0.02705114f, 0.14557269f, -0.02085194f, -0.13951746f, 0.49086958f, 0.03825580f, -0.14578953f, 
    -0.01326511f, 0.05266221f, 0.13513741f, 0.19150651f, -0.02462416f, 0.11207422f, 0.16913119f, 0.27018532f, 
    -0.39690134f, -0.26934177f, 0.02829815f, 0.24577552f, -0.01984509f, 0.10057486f, 0.03596212f, 0.01668344f, 
    -0.10192459f, 0.09367968f, 0.15301745f, -0.00671477f, 0.07960849f, -0.23800811f, 0.06509409f, 0.20293090f, 
    0.17433475f, 0.05576076f, 0.06079648f, -0.05400369f, 0.12119863f, -0.00290576f, -0.00565330f, -0.09657663f, 
    0.01953787f, 0.00647005f, 0.02713739f, -0.24369816f, -0.02657012f, -0.03229752f, 0.12235754f, -0.06000056f, 
    0.10549983f, 0.08266672f, 0.10345929f, 0.02697708f, -0.25055486f, 0.14831337f, -0.09943507f, 0.34469455f, 
    0.11875390f, -0.01262622f, -0.07596765f, -0.17522879f, -0.08170504f, -0.06068939f, 0.03546283f, -0.06743568f, 
    -0.12460568f, -0.19458954f, 0.00899912f, 0.50579613f, 0.00506454f, -0.19647919f, 0.23815218f, 0.13990630f, 
    -0.06900632f, 0.05929903f, 0.24227662f, 0.10172316f, 0.11223180f, -0.02611418f, -0.19697030f, 0.23648173f, 
    0.05444058f, -0.07795510f, -0.12559880f, 0.06806228f, -0.04995035f, 0.03455380f, 0.09017924f, 0.07689726f, 
    -0.25225982f, 0.00249591f, 0.10697166f, 0.17944488f, 0.11206143f, 0.22486039f, -0.00758328f, -0.02523580f, 
    0.15765710f, 0.02864582f, 0.02316363f, 0.03144469f, 0.06217822f, -0.13975951f, 0.00998523f, 0.21239014f, 
    -0.08155965f, 0.22218195f, -0.01612524f, -0.16759133f, 0.26129219f, 0.05373879f, 0.06412606f, 0.05110458f, 
    -0.36901399f, 0.19701254f, 0.19162385f, -0.12725462f, -0.10567391f, 0.24329896f, -0.02215737f, 0.11918206f, 
    -0.18280649f, 0.01351249f, -0.05247582f, -0.03060863f, 0.22700620f, 0.18148297f, -0.12103671f, -0.20424151f, 
    0.16560876f, 0.00438056f, -0.06024943f, -0.01890309f, 0.01554139f, -0.12371033f, -0.06279331f, -0.20697585f, 
    -0.23776090f, 0.13604137f, -0.03634905f, 0.18927248f, 0.11718778f, 0.06101965f, -0.03162751f, -0.13025853f, 
    0.06915011f, 0.04499429f, 0.15355898f, 0.01267317f, -0.11867026f, 0.17938708f, -0.14627855f, 0.00912614f, 
    0.22619133f, 0.00622579f, 0.14898805f, -0.06613653f, 0.00548232f, -0.01833530f, 0.17258842f, 0.03231899f, 
    -0.02325301f, -0.21274996f, -0.01233363f, -0.07333639f, 0.22895440f, 0.01950020f, 0.05882636f, -0.02712426f, 
    0.10420971f, -0.08119652f, -0.11237374f, 0.17525050f, -0.18725204f, -0.09747544f, -0.07491998f, -0.21346149f, 
    0.27699018f, 0.00592397f, 0.13100740f, 0.00359574f, 0.02243255f, 0.00074167f, 0.07511712f, 0.05451955f, 
    -0.27505305f, 0.26981413f, 0.13453616f, -0.33852577f, 0.20310372f, 0.16675609f, 0.33233991f, -0.01128058f, 
    -0.06021504f, -0.00096007f, 0.03422135f, -0.03508287f, 0.24720627f, 0.41882682f, 0.02809546f, 0.15453522f, 
    -0.28520027f, 0.03287475f, 0.09260092f, 0.12161525f, -0.11540534f, 0.05057329f, 0.08771798f, 0.00066886f, 
    -0.03175247f, -0.01744590f, -0.20254870f, -0.07177397f, 0.01933725f, 0.01247670f, 0.04781388f, -0.01669540f, 
    -0.06683545f, 0.04793432f, 0.08676120f, 0.05025834f, -0.39996383f, -0.08621992f, 0.37706289f, 0.17078221f, 
    0.19820172f, 0.00491650f, -0.13306896f, 0.13989997f, 0.22941153f, 0.00188198f, -0.01687192f, -0.06404035f, 
    -0.36285621f, -0.12140885f, 0.00841094f, -0.18079296f, -0.11792596f, 0.09533972f, 0.27734283f, -0.02319262f, 
    0.04196263f, 0.08045115f, -0.12096241f, 0.17908919f, 0.06375479f, -0.16035536f, 0.04558459f, 0.41699821f, 
    0.12837157f, 0.07804937f, -0.00368493f, 0.14560799f, -0.16601516f, 0.02348549f, 0.06369530f, -0.06698419f, 
    0.34803578f, -0.03950533f, -0.00083176f, 0.11440228f, -0.01962820f, 0.21630192f, 0.23967123f, 0.09189950f, 
    -0.13925256f, -0.02002928f, -0.02669157f, -0.04096349f, 0.22615640f, 0.00526466f, -0.18243502f, 0.35702914f, 
    0.15458973f, -0.07182262f, -0.18008068f, 0.01693678f, -0.00667745f, -0.01031733f, -0.08503293f, -0.06590274f, 
    -0.14911363f, 0.03110396f, 0.27526334f, -0.22316003f, 0.20902692f, 0.26529804f, 0.31030756f, 0.09684356f, 
    0.09833081f, 0.06800555f, 0.20377100f, 0.01380270f, 0.04518383f, -0.17621288f, 0.16257165f, 0.18817672f, 
    0.13033399f, 0.22245122f, 0.08227374f, -0.06908510f, -0.01274705f, -0.12189329f, 0.09699433f, 0.00163130f, 
    -0.04051374f, 0.03101658f, 0.06578076f, -0.00272972f, -0.03643096f, -0.01499019f, -0.00582114f, -0.05175795f, 
    -0.04517460f, 0.01947717f, -0.05607557f, -0.01587090f, -0.01999594f, 0.03651516f, 0.02065608f, -0.05297425f, 
    0.00591640f, -0.04179484f, -0.04229825f, -0.06077787f, 0.02640310f, 0.05090683f, 0.02451433f, 0.01312307f, 
    -0.00758263f, -0.06500851f, -0.01155453f, 0.01579674f, -0.03936817f, -0.00784400f, -0.06618722f, -0.06614251f, 
    0.02811423f, 0.00057773f, 0.03147155f, 0.04758401f, -0.06710565f, 0.01108301f, 0.03111514f, 0.02959880f, 
    -0.03435151f, -0.05980174f, -0.04940977f, -0.05102343f, 0.01375378f, 0.03983909f, -0.05534095f, 0.01906327f, 
    -0.03241115f, -0.06473021f, -0.05057572f, -0.07518294f, 0.01557416f, -0.05299877f, -0.01995480f, 0.04571086f, 
    0.01954060f, -0.06846581f, -0.03605831f, 0.06550452f, 0.05886386f, -0.05617527f, -0.04140124f, -0.03090867f, 
    0.05549014f, 0.00524057f, -0.02292165f, 0.01279711f, -0.04504599f, -0.03800495f, -0.04057526f, -0.04442903f, 
    0.02007229f, -0.05971911f, 0.01171811f, 0.02177071f, -0.07377113f, -0.02485351f, -0.03408392f, 0.01396660f, 
    -0.07340320f, -0.03692244f, 0.05070734f, -0.04786178f, 0.00518887f, -0.00223308f, -0.00665036f, 0.00496328f, 
    0.04019438f, 0.02965960f, -0.03092955f, 0.03869558f, 0.05721537f, -0.07791813f, -0.00693446f, 0.06328498f, 
    -0.03694661f, -0.02578112f, -0.03122053f, -0.04595150f, 0.00038715f, 0.01872017f, -0.07293763f, 0.06525696f, 
    -0.05342082f, 0.04784565f, -0.04041338f, -0.04991508f, 0.02345429f, -0.02049650f, -0.07689478f, 0.00047080f, 
    -0.06108675f, 0.01128665f, 0.02421250f, -0.04246088f, -0.07446990f, -0.01540439f, 0.00613922f, 0.00889609f, 
    -0.03420946f, -0.00631931f, -0.03657111f, -0.00068598f, -0.02933101f, 0.00903696f, -0.07811554f, -0.02350945f, 
    0.05545649f, 0.00442559f, 0.03913224f, -0.00074220f, 0.00009175f, -0.04461576f, 0.02217866f, -0.04959321f, 
    -0.01099062f, 0.00561934f, -0.06159569f, 0.05150069f, -0.01877928f, 0.00786745f, 0.05573746f, 0.01397955f, 
    -0.07100879f, 0.03339517f, 0.05152159f, 0.04976145f, 0.05850434f, -0.02977336f, 0.06332397f, 0.03501684f, 
    0.04069750f, -0.01939674f, -0.06643081f, -0.07431804f, -0.06109629f, 0.04396483f, 0.05079340f, -0.04124178f, 
    0.05307397f, -0.06026391f, 0.01285777f, 0.00625534f, 0.05886607f, -0.06020540f, -0.00704499f, -0.01288814f, 
    0.06219986f, -0.04733114f, -0.01812167f, 0.02148951f, -0.03916552f, 0.03101024f, -0.05741960f, -0.03974894f, 
    0.02133766f, -0.05709483f, 0.04357722f, 0.02069492f, 0.03311763f, 0.00364762f, -0.04820278f, 0.05561170f, 
    -0.00374613f, -0.01797863f, -0.06850937f, 0.02738477f, -0.05641733f, -0.05376136f, -0.05479534f, 0.05870951f, 
    -0.35517356f, -0.18543646f, -0.08951547f, 0.24180572f, -0.09936227f, -0.01520943f, -0.12359416f, 0.00666561f, 
    -0.01065361f, -0.07095671f, 0.09366421f, 0.18643743f, 0.11775839f, 0.03676331f, 0.01876998f, -0.09325092f, 
    0.14186159f, 0.08279104f, -0.01044883f, -0.16561408f, 0.03917208f, 0.01266374f, -0.02403321f, 0.03159026f, 
    0.14287668f, 0.07874372f, 0.47738257f, 0.38013402f, -0.13656662f, -0.02458910f, 0.02884446f, 0.03844998f, 
    0.01345994f, 0.11675407f, 0.01391035f, 0.03824393f, 0.34311655f, -0.25542489f, -0.08687449f, -0.11114084f, 
    -0.06178738f, -0.08150008f, -0.12504272f, -0.17665985f, -0.03302363f, -0.07436670f, -0.07208811f, -0.02152737f, 
    -0.12967259f, 0.23008133f, 0.24811253f, -0.14542760f, 0.15449286f, 0.06917828f, -0.07751319f, -0.06598821f, 
    0.06107989f, -0.07037531f, 0.04899027f, -0.05688589f, -0.41725338f, 0.16736425f, -0.02700074f, -0.19389357f, 
    0.03600758f, -0.12862100f, -0.08050718f, -0.14259219f, -0.07300603f, -0.08252189f, 0.15467863f, -0.01347094f, 
    -0.41397318f, 0.17589048f, 0.15099463f, -0.10358343f, -0.07155573f, 0.06482321f, 0.05069777f, 0.03354408f, 
    -0.05554982f, -0.03001559f, -0.10070638f, -0.00751608f, 0.35369989f, -0.21579151f, -0.03183522f, 0.14701959f, 
    -0.07009400f, 0.23020917f, -0.00818653f, 0.04210768f, -0.08100218f, -0.14491865f, -0.05749037f, -0.25778115f, 
    0.11803772f, 0.44446367f, -0.01246149f, -0.15803944f, 0.15772338f, 0.20451273f, 0.06508610f, -0.10290529f, 
    -0.07726223f, 0.06986029f, -0.02367869f, 0.01991534f, 0.10556601f, 0.17557156f, 0.01082435f, 0.16315374f, 
    0.05220484f, 0.12055999f, -0.11291169f, 0.07227006f, -0.05432599f, 0.22123185f, 0.10591935f, 0.06937271f, 
    -0.39732015f, -0.08579206f, -0.16982859f, -0.20313999f, -0.05539166f, 0.03776072f, -0.17388193f, -0.19208397f, 
    -0.01286439f, -0.07681393f, -0.08005857f, -0.02127787f, 0.13726224f, -0.22720245f, 0.04221225f, -0.06031483f, 
    -0.05689749f, 0.12240443f, 0.07313196f, 0.17393486f, 0.03871809f, 0.15841915f, -0.02861302f, 0.11964165f, 
    0.49220985f, 0.26807603f, 0.14807227f, -0.22225241f, 0.03322884f, 0.10776080f, 0.01705805f, -0.04413237f, 
    -0.12959047f, -0.06728577f, -0.11484694f, -0.02842991f, 0.18280603f, 0.19729130f, 0.00399575f, 0.38640133f, 
    0.25635079f, 0.19433586f, 0.16521689f, -0.08888794f, 0.00850671f, 0.05395380f, 0.07708731f, 0.14868604f, 
    -0.30038261f, -0.09054644f, -0.00620744f, -0.36229476f, 0.17497617f, 0.00300191f, -0.03047139f, -0.01450915f, 
    0.07603983f, -0.10766610f, 0.10495536f, 0.03846872f, 0.26843122f, 0.12880547f, 0.20922250f, 0.20133762f, 
    0.07002615f, -0.07071981f, -0.02615717f, 0.01371714f, 0.09526818f, -0.11622783f, 0.07168107f, 0.09159800f, 
    0.04474450f, -0.03939440f, 0.06513103f, 0.01198977f, -0.07419026f, 0.03423372f, 0.04919021f, -0.07073727f, 
    -0.04923988f, -0.02249328f, 0.05629402f, -0.03898425f, -0.04113873f, -0.01722364f, 0.00838065f, 0.04503769f, 
    -0.03591337f, -0.06569178f, -0.05866147f, -0.01645330f, -0.04674418f, 0.00774198f, 0.06681477f, 0.05059347f, 
    -0.02804968f, -0.06866197f, -0.00415201f, 0.00777203f, -0.02444350f, -0.01043077f, 0.02245905f, -0.01833179f, 
    -0.03577239f, -0.05332737f, -0.02692820f, 0.00681490f, -0.07528335f, 0.06592879f, -0.00522208f, -0.05825146f, 
    -0.04919931f, -0.06220582f, 0.03629555f, 0.01775473f, 0.06364071f, 0.02209822f, -0.06960774f, 0.04266178f, 
    -0.06643449f, -0.05968762f, 0.00166712f, -0.05930766f, -0.03129967f, -0.05340945f, -0.07500475f, 0.06654886f, 
    -0.05360920f, 0.03093944f, 0.01691611f, 0.02180292f, 0.05603001f, -0.04188084f, 0.00535634f, 0.02797535f, 
    -0.06953602f, -0.03928078f, -0.02270634f, 0.00829243f, -0.01358691f, -0.05754426f, -0.02101300f, 0.03250902f, 
    -0.03204731f, -0.07712255f, 0.03049995f, 0.02292499f, 0.00643104f, -0.07673139f, 0.01965378f, 0.00998031f, 
    -0.07139800f, -0.02758743f, -0.01858092f, 0.05641137f, 0.04516926f, -0.06562354f, -0.02279373f, -0.02761715f, 
    -0.06507249f, -0.04972853f, -0.01806241f, -0.02554885f, 0.05317884f, -0.06664196f, -0.05142814f, -0.02927084f, 
    -0.02628800f, -0.04639572f, 0.05801775f, 0.05506758f, 0.02895306f, 0.01943706f, -0.06062617f, -0.00161215f, 
    0.02231860f, 0.04156256f, 0.05157148f, -0.01912453f, 0.04337240f, -0.02869836f, 0.02707878f, 0.02377794f, 
    -0.01317196f, -0.00716425f, -0.04742405f, 0.02835554f, -0.07287282f, -0.03041171f, 0.00020013f, -0.01225776f, 
    -0.03576447f, 0.02237998f, -0.06679571f, 0.05279410f, 0.06005558f, -0.00575692f, -0.05678732f, -0.06503267f, 
    -0.04108521f, -0.04473814f, -0.05941182f, -0.02956062f, -0.06816641f, 0.03938447f, 0.04655263f, -0.07417279f, 
    -0.04196907f, -0.05629499f, -0.00489454f, -0.07595208f, 0.02046045f, 0.04102862f, -0.01204579f, -0.07023884f, 
    -0.02294425f, -0.02099689f, -0.01696256f, -0.05045324f, -0.01525084f, -0.04324552f, 0.02639766f, 0.02890769f, 
    -0.04912258f, 0.04304494f, -0.01758460f, -0.03626288f, -0.04471590f, -0.07554635f, 0.05552606f, 0.05430330f, 
    -0.03986885f, -0.02555005f, -0.06660064f, 0.02616557f, 0.05622429f, -0.05087008f, 0.06034574f, 0.02381773f, 
    0.04875625f, -0.02112514f, 0.00639311f, -0.03683634f, -0.05166684f, 0.05945320f, -0.06062532f, -0.01201733f, 
    -0.01486986f, 0.04396397f, 0.04661311f, 0.05747204f, 0.03267788f, -0.05324294f, -0.01005589f, 0.02856106f, 
    -0.03552973f, 0.04553371f, -0.02803543f, 0.01043908f, 0.01834282f, -0.06152990f, 0.04768214f, -0.01496358f, 
    -0.02521928f, -0.01539837f, 0.05975470f, -0.02224097f, -0.02517098f, 0.05494701f, -0.05859186f, -0.06326793f, 
    0.05355133f, 0.05071085f, -0.03834360f, -0.07065760f, 0.04788817f, 0.00734117f, 0.05004824f, 0.03164786f, 
    0.01429470f, -0.02412070f, 0.04395021f, 0.04990289f, -0.03342343f, 0.06104970f, 0.00871431f, -0.04403202f, 
    -0.02393484f, -0.04791952f, -0.01549897f, -0.03969974f, -0.00723655f, -0.00489140f, -0.07147984f, -0.00608780f, 
    0.00433617f, -0.07133038f, -0.03378507f, 0.00672305f, 0.05988949f, 0.02980422f, 0.05745902f, -0.06782115f, 
    -0.02048355f, -0.04105670f, -0.01205299f, 0.04589806f, -0.06896854f, 0.04067703f, -0.02109950f, 0.02179345f, 
    0.00443663f, -0.06035221f, -0.03600232f, -0.05547345f, -0.02119393f, -0.01874548f, 0.04831106f, -0.03223894f, 
    -0.02328063f, -0.05677338f, 0.00946296f, 0.06692657f, -0.00836067f, -0.03250206f, 0.04135904f, -0.06149783f, 
    -0.02963195f, -0.04880591f, 0.06324973f, -0.02534494f, 0.02459906f, 0.06632026f, -0.04347622f, -0.06739005f, 
    -0.06111233f, -0.02399241f, -0.03775133f, 0.06967803f, -0.05625034f, 0.02481007f, 0.03021501f, -0.01553284f, 
    -0.06809760f, -0.00878905f, -0.04020553f, -0.01354454f, -0.03125140f, 0.02861062f, 0.04742263f, 0.00129743f, 
    0.02958070f, 0.02971473f, -0.04084102f, -0.01538726f, -0.05155608f, 0.02587582f, 0.03690542f, -0.03625054f, 
    -0.05140838f, -0.01490923f, -0.01955994f, 0.02543152f, 0.04127701f, -0.06946820f, -0.04056462f, -0.06007106f, 
    0.03244442f, 0.00328504f, -0.03775370f, -0.01244883f, 0.06011049f, -0.02331955f, -0.02112048f, -0.01287850f, 
    -0.04243526f, 0.05431968f, -0.06437021f, -0.02347704f, 0.06730527f, 0.06552085f, -0.04776157f, -0.05147764f, 
    -0.07215712f, -0.04271310f, 0.06875298f, -0.00158971f, -0.06155812f, -0.00765880f, -0.03405802f, -0.01616144f, 
    -0.03164994f, 0.01261236f, 0.04224234f, -0.06243672f, 0.00131419f, -0.05219172f, -0.02777452f, -0.04437090f, 
    0.03982810f, 0.01403086f, -0.07004423f, -0.05416975f, -0.03189388f, 0.01336327f, -0.00451109f, 0.05617686f, 
    -0.03945887f, -0.04960473f, 0.03250309f, 0.04491709f, 0.01638010f, 0.00303943f, 0.04979747f, -0.02101223f, 
    -0.05635966f, -0.03246232f, 0.00009599f, 0.02052096f, -0.04432112f, -0.00115786f, -0.06888523f, 0.02626973f, 
    -0.05082257f, -0.06767709f, 0.01478010f, -0.05241010f, 0.05831568f, -0.06230120f, 0.06216322f, -0.02337624f, 
    0.01214868f, 0.05372337f, -0.00877204f, 0.01368879f, 0.06174277f, 0.07065015f, 0.02920218f, 0.03360399f, 
    -0.06363192f, -0.06741439f, 0.06519078f, -0.06847464f, -0.04588463f, 0.03055608f, -0.02463501f, 0.04192258f, 
    0.06522408f, -0.03729365f, -0.05558529f, 0.05431781f, 0.07042421f, 0.05816726f, -0.04440540f, -0.03833912f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00743844f, -0.00048901f, 0.06095413f, 0.01698755f, -0.07791081f, 0.03536522f, 0.11297365f, 0.03789588f, 
    0.05160673f, -0.18299185f, -0.07603087f, 0.01729477f, 0.05335754f, -0.00125735f, -0.05741473f, 0.05634319f, 
    0.00149218f, -0.00805872f, 0.03063409f, 0.03785314f, -0.09191703f, 0.04827623f, 0.11989189f, 0.28856337f, 
    -0.04769995f, 0.04046671f, 0.05287037f, 0.06405599f, 0.05247767f, 0.00846873f, -0.03579327f, -0.02547564f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.09977002f, 0.04364425f, 0.39336306f, 0.07431259f, -0.05535434f, -0.22876148f, 0.30323318f, -0.32036912f, 
    0.34136695f, -0.26823083f, -0.41966367f, -0.01482823f, 0.41035673f, 0.21099064f, 0.05820318f, 0.37447372f, 
    -0.01302749f, -0.05016546f, 0.07103837f, -0.02584382f, 0.10708431f, 0.16739871f, 0.13019681f, -0.37937611f, 
    -0.06732334f, 0.15697469f, 0.18263309f, 0.04796889f, -0.00687575f, -0.14206700f, -0.09390269f, 0.07759551f, 
    0.60935479f, -0.09935402f, 0.32948124f, 0.23071025f, -0.08825173f, 0.12791288f, 0.12902595f, -0.38635409f, 
    0.25375560f, -0.13698842f, -0.16986644f, -0.00007549f, -0.20468846f, 0.04068734f, 0.14554915f, 0.04372600f, 
    -0.27511212f, -0.02665576f, 0.16675664f, -0.09603868f, -0.01952315f, -0.19328170f, 0.60477871f, 0.21992262f, 
    -0.04957899f, 0.19546041f, 0.19666125f, 0.32235619f, -0.12498058f, 0.27538985f, 0.15085666f, 0.01374407f, 
    -0.01708793f, -0.02708845f, -0.20295666f, -0.02100565f, 0.02269496f, -0.03958026f, -0.05679145f, -0.15341501f, 
    0.02068553f, 0.13372999f, -0.00730487f, -0.00207922f, 0.11970390f, 0.13857935f, -0.13654207f, -0.22172695f, 
    -0.00396840f, -0.06149470f, -0.15714686f, -0.04592188f, 0.12407991f, -0.11455733f, 0.07199425f, -0.00778586f, 
    0.07023389f, -0.05550150f, -0.10854167f, 0.09689975f, -0.01910453f, -0.17589669f, 0.13608673f, 0.07472223f, 
    -0.21990630f, -0.05565201f, 0.28269926f, 0.40009809f, -0.16461770f, 0.35866618f, 0.02172057f, 0.35199937f, 
    0.32004267f, -0.47264704f, 0.12169508f, 0.06839578f, -0.00877932f, 0.06206871f, 0.00090395f, 0.20549579f, 
    0.17287195f, -0.09647790f, -0.25193182f, 0.49373192f, -0.04864400f, -0.04749240f, 0.28476158f, 0.36455110f, 
    0.13902327f, 0.31012222f, 0.17213632f, -0.20006134f, -0.15317141f, -0.29373884f, -0.03116674f, -0.17620277f, 
    0.65327328f, -0.07651306f, -0.19277026f, -0.46668792f, -0.03396327f, -0.12462543f, 0.18783441f, 0.21133313f, 
    -0.63975626f, -0.01989919f, 0.36307725f, 0.14412916f, -0.00061618f, 0.28308997f, 0.04374331f, -0.24391361f, 
    0.38188449f, 0.00932496f, -0.04942732f, -0.09164762f, 0.37037653f, -0.02945249f, 0.02920453f, 0.12038346f, 
    0.05549605f, -0.16474819f, 0.05757045f, 0.39992544f, 0.03654141f, 0.43102789f, -0.00112127f, 0.00885090f, 
    -0.51090449f, 0.16784200f, 0.01987531f, 0.06942635f, -0.15049346f, 0.03866176f, -0.23771456f, 0.25313830f, 
    -0.25074926f, -0.32498494f, -0.11106303f, -0.01793027f, 0.46449926f, 0.37899840f, 0.13844746f, 0.24568675f, 
    0.46194133f, -0.16946217f, -0.30626231f, -0.09545426f, -0.37377879f, 0.34992915f, -0.30244482f, 0.49926752f, 
    -0.00577584f, 0.01347145f, 0.27203229f, 0.26822844f, 0.13900129f, 0.04435115f, -0.02072514f, 0.04994191f, 
    0.11615863f, 0.10630824f, -0.22088316f, -0.22842650f, 0.10506654f, -0.24802808f, -0.42037651f, -0.11249442f, 
    0.26546529f, 0.38441476f, 0.23406222f, -0.07458052f, 0.31788906f, 0.42778513f, -0.03486948f, -0.34693912f, 
    -0.00611421f, 0.09898976f, 0.32941785f, 0.20777410f, -0.00541871f, 0.09788840f, 0.27858904f, 0.01750365f, 
    -0.12635566f, -0.20101745f, 0.42381406f, 0.26175803f, 0.04752740f, -0.14481269f, 0.10933252f, -0.16050118f, 
    0.19359702f, -0.13931729f, -0.06531556f, -0.07329527f, 0.03035178f, 0.03389379f, 0.21082875f, -0.02944674f, 
    0.17059454f, -0.14300504f, 0.05433040f, -0.02978967f, -0.08201949f, 0.04604689f, -0.00267822f, -0.06673045f, 
    -0.15630260f, 0.02318159f, -0.14696397f, -0.05882828f, -0.02210508f, -0.05021608f, 0.10281293f, -0.03566631f, 
    0.04240514f, 0.15150057f, -0.04128449f, 0.06183482f, -0.03693931f, 0.01964437f, 0.01012926f, -0.06202990f, 
    -0.07683611f, 0.11066970f, 0.36355346f, 0.13870072f, 0.10219967f, -0.27216840f, 0.26549566f, 0.28800952f, 
    0.37043998f, 0.31930521f, 0.06340823f, -0.05358653f, 0.27979878f, -0.65005088f, -0.15243033f, 0.05887979f, 
    0.09443376f, -0.08340754f, -0.30145177f, -0.35273457f, 0.37193984f, 0.20904948f, -0.21406507f, -0.47530970f, 
    0.06409772f, -0.05132787f, -0.03406638f, 0.08377250f, 0.01223649f, 0.26164678f, -0.15902254f, 0.03297753f, 
    -0.08682943f, 0.12407483f, -0.27169934f, -0.15979829f, 0.12359092f, -0.38486218f, -0.02184185f, 0.20548460f, 
    0.24142180f, 0.11915261f, 0.00554602f, 0.13005437f, 0.40486795f, -0.37894687f, 0.12773795f, 0.13058282f, 
    0.09387438f, 0.08751077f, 0.25565755f, -0.31511334f, 0.37849677f, 0.26028192f, 0.09602613f, 0.02547684f, 
    -0.07668070f, -0.19825293f, 0.14466304f, -0.15418319f, 0.10558062f, 0.11202081f, -0.15923180f, -0.14041612f, 
    0.12482113f, -0.14954384f, -0.00295159f, 0.01360890f, 0.13610119f, -0.10104466f, -0.16925903f, 0.05073454f, 
    0.00245318f, 0.07984044f, 0.03572932f, -0.08084421f, -0.17396994f, -0.10256783f, -0.09320541f, -0.12071350f, 
    0.02045226f, 0.14253628f, -0.08596218f, 0.14815700f, -0.07231360f, -0.08107104f, -0.01945920f, 0.10743457f, 
    0.07779945f, 0.00876406f, -0.15382090f, -0.10073432f, 0.04352924f, -0.13420540f, 0.07623476f, 0.14831154f, 
    -0.08761989f, 0.16213806f, 0.13908489f, 0.19083250f, 0.05306584f, 0.22597562f, 0.23564215f, 0.35522079f, 
    0.29628929f, 0.44959572f, 0.26653633f, 0.15407820f, -0.24963427f, -0.10871615f, -0.13668905f, -0.18274871f, 
    0.12821022f, -0.14602381f, -0.05559044f, 0.36809754f, 0.16696604f, 0.09555527f, 0.07145822f, -0.02800452f, 
    -0.13762321f, 0.10903826f, 0.19718872f, -0.43521181f, -0.13738064f, -0.57914150f, -0.05678388f, 0.03724540f, 
    -0.30937138f, 0.13816749f, -0.36554635f, -0.18012404f, 0.01240718f, 0.17696743f, 0.22803430f, 0.11508564f, 
    0.16403922f, -0.48395759f, 0.38448688f, -0.03562661f, 0.23764728f, 0.25678402f, -0.16963813f, 0.02859849f, 
    -0.02299578f, -0.06162466f, 0.16105478f, 0.30059052f, 0.43262196f, 0.23935437f, -0.04309379f, -0.09112473f, 
    -0.07666873f, -0.35466278f, 0.04866876f, 0.02808063f, 0.13089144f, -0.22967647f, 0.01929253f, -0.11379280f, 
    -0.33885092f, -0.11533456f, -0.00697642f, 0.00409498f, 0.00375307f, -0.13285099f, -0.09041822f, -0.02970027f, 
    0.20473829f, 0.42823929f, -0.16645707f, 0.13288565f, 0.02133179f, -0.04666976f, 0.03277946f, 0.05602698f, 
    0.40226513f, -0.01292816f, -0.28701895f, -0.09820077f, -0.23186100f, 0.24985996f, 0.27542156f, -0.53393471f, 
    0.18617235f, -0.09315193f, 0.32910472f, 0.18671104f, 0.17140628f, -0.12829883f, 0.13424604f, 0.15650269f, 
    -0.04353305f, -0.03821798f, -0.01473920f, 0.33873838f, -0.04181399f, -0.18882783f, -0.21210457f, 0.03665434f, 
    0.23248729f, 0.46950915f, 0.09962297f, -0.08298033f, -0.15819395f, -0.24919699f, -0.07334837f, 0.22765680f, 
    -0.16699083f, 0.06124405f, 0.34080049f, -0.01847002f, -0.35316357f, 0.09100422f, -0.29266483f, 0.08246736f, 
    -0.01131058f, 0.44776887f, 0.22267526f, 0.24155921f, -0.09861277f, 0.10781834f, 0.02414644f, 0.07291874f, 
    0.29982981f, -0.17376144f, 0.21278851f, -0.55218863f, 0.10795378f, 0.02980464f, 0.20614140f, 0.38074303f, 
    -0.07584257f, 0.07328951f, -0.08542062f, 0.09522560f, -0.13850263f, 0.23278913f, 0.01830063f, 0.13976613f, 
    0.41897833f, 0.01737085f, -0.45390263f, 0.13515204f, 0.37021920f, -0.15387772f, 0.26971561f, -0.54640865f, 
    0.15631264f, -0.09514436f, 0.00754428f, -0.00854304f, 0.04456704f, -0.34659615f, -0.06191846f, -0.14109744f, 
    -0.72353047f, 0.02546498f, -0.08859827f, 0.13812220f, 0.15141365f, 0.20862527f, 0.11673799f, -0.57101917f, 
    -0.12366073f, -0.11424530f, -0.23077282f, 0.03744553f, -0.03011809f, 0.00503581f, 0.04489524f, 0.14641017f, 
    -0.17983100f, -0.17535320f, -0.10092220f, -0.29321077f, -0.04054206f, 0.28537148f, -0.16198377f, 0.11215743f, 
    0.01677524f, -0.38950494f, 0.16760725f, 0.18795744f, 0.00819883f, -0.15096220f, -0.03433763f, 0.03879000f, 
    0.61703539f, 0.02706187f, 0.24247234f, -0.00915959f, -0.15481918f, 0.31991583f, 0.37514102f, -0.10762686f, 
    0.04318708f, 0.47813106f, 0.26815951f, -0.16290088f, -0.37689111f, -0.18238163f, -0.08900414f, 0.19028471f, 
    -0.20748159f, -0.06589942f, 0.55430907f, 0.10709514f, 0.37743565f, -0.29628929f, 0.34936425f, -0.19380863f, 
    0.07525484f, 0.12799951f, -0.24853060f, 0.11803944f, 0.02188748f, 0.35815513f, -0.11352227f, -0.16262189f, 
    0.08942176f, -0.09388206f, -0.08246671f, -0.03535702f, -0.09332827f, -0.10200869f, -0.12375202f, -0.13182396f, 
    -0.01194392f, -0.10271855f, 0.06999473f, -0.01503078f, 0.05755417f, -0.02350197f, -0.16084594f, 0.08349395f, 
    -0.07414377f, -0.12809309f, -0.03435865f, -0.10185635f, 0.06208329f, 0.04177291f, -0.10243091f, -0.03085023f, 
    0.01436040f, 0.09848192f, -0.02362541f, -0.10958924f, 0.04013712f, -0.17694375f, 0.04172144f, -0.02710843f, 
    -0.30188590f, 0.06066971f, 0.32816425f, 0.20906407f, -0.12261359f, -0.02636927f, 0.34152418f, -0.01904643f, 
    -0.06888054f, 0.44205740f, 0.23552985f, 0.13610442f, 0.21342930f, -0.00438506f, -0.08559026f, 0.21480195f, 
    -0.08716370f, -0.01759082f, 0.39940187f, 0.07710817f, -0.42359802f, 0.09535602f, -0.42634857f, 0.40159717f, 
    0.13481501f, -0.02886525f, -0.11827372f, -0.24016570f, 0.03642938f, 0.43151745f, -0.03016752f, -0.03363099f, 
    -0.00218113f, 0.07617377f, -0.20966628f, -0.28664383f, 0.12323541f, 0.05767216f, -0.08957388f, 0.29554114f, 
    0.10114201f, -0.26357684f, -0.00323050f, 0.04094505f, -0.02130804f, -0.06271851f, -0.10899936f, -0.05241670f, 
    0.19967090f, -0.06076019f, -0.17280135f, 0.05656439f, 0.02902325f, 0.11286087f, 0.22514598f, 0.23340876f, 
    0.10739189f, -0.60308415f, 0.18745917f, 0.38346136f, 0.16455756f, 0.24808255f, 0.08665337f, 0.14550062f, 
    -0.02160627f, -0.16207010f, 0.13966720f, 0.28181952f, 0.02569735f, 0.03285397f, -0.04679897f, -0.03431902f, 
    -0.14886251f, -0.11796903f, -0.15538944f, 0.08104410f, 0.33478376f, -0.29378849f, 0.05548819f, 0.53271365f, 
    0.32490861f, 0.02325523f, -0.21990232f, 0.04225649f, 0.28958997f, 0.15860680f, -0.08809036f, -0.40239877f, 
    0.08055451f, 0.54486948f, -0.01475983f, 0.35761064f, -0.09495375f, 0.33832407f, -0.15553677f, 0.05533409f, 
    0.15200214f, 0.08627363f, 0.05486540f, -0.20853904f, 0.11363246f, 0.17549090f, 0.38678753f, 0.35765624f, 
    0.03532756f, -0.13868508f, 0.31324643f, 0.04150201f, 0.04338753f, -0.36693951f, 0.07310975f, 0.11265073f, 
    -0.16323596f, -0.15281162f, -0.17450912f, -0.01771592f, 0.17219478f, 0.29421762f, -0.12185150f, 0.42185816f, 
    -0.02969251f, -0.48696929f, 0.04892061f, -0.14082991f, 0.11509054f, 0.39192402f, -0.08334183f, 0.16364372f, 
    0.14854611f, 0.04378545f, 0.16767415f, 0.18703273f, 0.11204375f, 0.05251024f, 0.07666811f, 0.17664696f, 
    0.51091558f, 0.04526192f, 0.28630316f, -0.07282149f, -0.09700520f, 0.13206804f, 0.15169893f, -0.06090940f, 
    -0.27708617f, -0.14511286f, -0.30942127f, 0.22408944f, 0.01154944f, -0.09049664f, -0.28605783f, 0.29306659f, 
    0.05164558f, 0.25621402f, 0.28735995f, 0.32955438f, -0.16048770f, -0.34076434f, -0.16123435f, 0.11812700f, 
    -0.11472195f, 0.04338719f, 0.05472657f, -0.06389835f, -0.11920188f, 0.02656735f, -0.15210113f, -0.21920125f, 
    -0.09608918f, 0.07981033f, -0.04923807f, -0.16207275f, -0.25582683f, 0.06125615f, 0.03638672f, -0.40589246f, 
    -0.07386351f, -0.13782200f, 0.16515139f, 0.17514963f, 0.29293689f, 0.22681420f, 0.24901740f, 0.11798565f, 
    -0.13789666f, -0.54798800f, 0.34437525f, -0.10699419f, -0.17167473f, -0.09758604f, 0.17660570f, 0.15804043f, 
    -0.16300416f, -0.01767310f, -0.11505642f, -0.10771945f, -0.12767087f, -0.18333606f, -0.13710307f, 0.03238289f, 
    0.13181132f, 0.08660974f, -0.03847053f, -0.03966125f, 0.03284621f, -0.04768902f, 0.00003300f, -0.14935052f, 
    -0.10576995f, 0.12572469f, 0.04401991f, 0.02835029f, -0.00985436f, -0.17110425f, 0.02493764f, 0.01152444f, 
    0.11432431f, 0.08271063f, -0.18120918f, -0.08410205f, 0.17425568f, 0.03795951f, 0.13811940f, -0.05848065f, 
    0.45322722f, 0.02974797f, 0.08174556f, -0.54352826f, -0.04744083f, -0.30451322f, 0.04683903f, 0.35538802f, 
    -0.18213201f, 0.31972325f, -0.00805843f, -0.01065175f, 0.15557048f, 0.31691438f, -0.16735309f, -0.14943781f, 
    0.36314493f, -0.11446151f, 0.01572942f, -0.01640083f, 0.39489737f, -0.34211138f, -0.17579465f, -0.55682129f, 
    -0.01069932f, 0.29175624f, 0.00815408f, 0.05535347f, 0.06493853f, 0.13467465f, 0.09737783f, -0.01514496f, 
    0.14028156f, -0.08033497f, 0.02717427f, 0.08659067f, -0.06651419f, -0.19886245f, -0.34027541f, 0.41695422f, 
    -0.07029381f, 0.13280226f, 0.24568872f, -0.02534008f, -0.04290702f, -0.55453640f, 0.10398480f, 0.11160155f, 
    -0.04205040f, 0.01346735f, -0.14923428f, 0.04584078f, -0.18754327f, 0.01375636f, -0.08037309f, 0.43192637f, 
    0.08207384f, 0.17031217f, 0.24922279f, 0.43946344f, 0.02929420f, 0.19102524f, 0.07209075f, 0.05082248f, 
    0.32245159f, 0.15962945f, 0.07168066f, 0.00133260f, 0.05699632f, -0.16258581f, 0.29258499f, 0.12064562f, 
    0.36512780f, -0.13413115f, -0.05900594f, -0.08173801f, 0.07732769f, -0.32158613f, -0.13796794f, -0.07507611f, 
    -0.37373558f, 0.07037938f, -0.00731674f, -0.19822484f, 0.35475564f, 0.12689199f, -0.27308080f, 0.15589789f, 
    0.07067857f, 0.15175906f, 0.10214276f, 0.15138066f, -0.03593375f, -0.05599852f, 0.04910361f, -0.15696390f, 
    -0.13901952f, 0.05035960f, 0.00620989f, 0.09182531f, 0.06367722f, 0.09225725f, -0.09321779f, -0.10606960f, 
    0.01000516f, -0.04658503f, -0.17771445f, -0.05285380f, -0.05567447f, 0.07190946f, -0.14106070f, 0.09380880f, 
    -0.16602457f, -0.17586638f, -0.04961940f, -0.12985674f, 0.07659048f, -0.20304962f, -0.22309873f, 0.11170398f, 
    -0.13743870f, -0.06365764f, 0.05670950f, -0.23415925f, 0.16593544f, -0.18259721f, -0.11307637f, -0.03516590f, 
    0.17434797f, -0.06698006f, 0.09099410f, -0.29655138f, 0.02425623f, 0.06087738f, -0.25859797f, 0.28234640f, 
    0.03962525f, 0.64565593f, 0.27069262f, 0.04050742f, -0.13760576f, 0.42601171f, -0.09197069f, -0.33760303f, 
    0.24819082f, -0.07737856f, 0.22162174f, 0.20976688f, -0.33602151f, -0.25744301f, -0.27165440f, -0.09522149f, 
    -0.11098485f, 0.28588605f, 0.25146183f, -0.06840490f, -0.09128816f, -0.27227002f, 0.14640500f, 0.07071735f, 
    0.12545577f, 0.16869809f, 0.48202804f, 0.10936408f, -0.07502738f, -0.12129812f, 0.24099079f, -0.23277767f, 
    -0.31421205f, 0.07406622f, -0.40031788f, -0.16057859f, -0.14558704f, 0.20846286f, -0.07595508f, 0.12447145f, 
    0.21021454f, 0.09057468f, 0.09856611f, -0.26631624f, -0.34589010f, 0.12781651f, 0.31973571f, 0.45887253f, 
    -0.10134292f, -0.14951929f, 0.18947671f, 0.14082918f, -0.02840423f, 0.29461601f, 0.14432770f, 0.13350672f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.17256136f, 0.26883960f, -0.00206848f, 0.25845775f, 0.17667022f, 0.31829587f, 0.10237607f, -0.11185385f, 
    -0.06532755f, 0.17212269f, -0.14415924f, -0.06700595f, 0.16248347f, -0.09070599f, -0.16070691f, -0.19001962f, 
    0.04761472f, -0.18644030f, -0.10645471f, -0.04095112f, 0.02852462f, 0.14537501f, -0.00021495f, -0.05734371f, 
    -0.08343273f, -0.15994921f, -0.17006442f, -0.09929084f, 0.08304879f, -0.18844956f, -0.13241464f, 0.22832523f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.31507006f, -0.19199297f, 0.01919166f, -0.02767259f, 0.16169509f, -0.48935422f, -0.75898355f, -0.14653786f, 
    0.23641415f, -0.53443801f, 0.03069007f, 0.19810916f, -0.50621527f, -0.11114866f, 0.06926152f, 0.30330411f, 
    0.37682170f, 0.37897187f, 0.12534097f, 0.21319255f, -0.43326971f, 0.01080515f, 0.07425133f, -0.06650005f, 
    0.23409122f, -0.13972099f, 0.51187485f, -0.02600693f, -0.11992231f, -0.04805669f, 0.20072669f, -0.00380747f, 
    0.17163749f, 0.28276563f, -0.22468749f, 0.17953420f, -0.26775524f, -0.78494495f, -0.15960898f, 0.21581225f, 
    -0.08035112f, 0.46465087f, 0.06243794f, 0.17195444f, 0.20548089f, -0.36635688f, -0.19408417f, 0.00965865f, 
    -0.34702089f, 0.40116107f, -0.14386529f, -0.16294253f, -0.37251815f, 0.07794473f, -0.14597623f, -0.03865988f, 
    -0.26920748f, -0.10184878f, -0.39347929f, -0.42914799f, 0.15079378f, 0.02971705f, -0.15569973f, 0.02885805f, 
    -0.52478743f, 0.09541760f, 0.06858405f, -0.20348205f, 0.12516294f, -0.52114171f, 0.41753483f, -0.11313821f, 
    -0.63722163f, -0.61846542f, -0.12289292f, 0.15301394f, 0.32265800f, -0.06692681f, -0.07203609f, 0.15192235f, 
    0.25423789f, 0.27138692f, 0.00130399f, -0.80970502f, 0.28275132f, -0.46327409f, -0.16176687f, 0.27617860f, 
    -0.03607800f, -0.11570504f, -0.05314812f, -0.07272377f, -0.20109507f, 0.05065863f, 0.33164042f, -0.48188010f, 
    0.00785774f, -0.39457801f, -0.03654718f, -0.24138679f, 0.38144237f, 0.14980191f, -0.13330905f, 0.03013141f, 
    0.13617957f, 0.05536433f, 0.06262061f, -0.38666523f, 0.42799339f, -0.42792872f, -0.60953760f, 0.16661507f, 
    0.49792126f, -0.11630795f, 0.10945554f, -0.16520593f, 0.05899667f, 0.29512072f, 0.07996921f, -0.16677043f, 
    0.08491857f, -0.01292917f, 0.37408355f, -0.21042307f, 0.02609368f, 0.05016692f, -0.38440013f, -0.31345496f, 
    0.29822397f, 0.08013500f, -0.02143390f, -0.21314511f, -0.02820755f, -0.00278812f, 0.26063612f, -0.08747669f, 
    0.20760454f, 0.34128830f, 0.11917152f, -0.05267984f, -0.18973492f, 0.37313083f, -0.33973706f, 0.40962085f, 
    -0.11333528f, -0.22008903f, -0.14181140f, -0.29646188f, 0.09373143f, -0.07463710f, -0.20970312f, -0.17550698f, 
    0.35627785f, 0.03931116f, 0.30486450f, -0.16240448f, -0.13065745f, -0.14971571f, -0.06182783f, 0.23090437f, 
    0.34998930f, 0.35269514f, 0.13600868f, -0.04190903f, -0.47392476f, -0.09188055f, -0.32105437f, 0.03808216f, 
    0.11912575f, -0.33300614f, -0.11828644f, -0.29603446f, -0.38939559f, -0.12318116f, 0.25028884f, -0.35946095f, 
    -0.23864073f, 0.05580299f, 0.07685966f, 0.07728042f, -0.25772759f, 0.28637958f, -0.17041825f, 0.18954760f, 
    -0.32672781f, -0.11251470f, -0.38312408f, 0.13117877f, 0.30500183f, 0.03106692f, -0.44578326f, 0.26942912f, 
    0.19590528f, -0.19958533f, -0.07153760f, 0.32716534f, -0.55851763f, 0.36728716f, -0.12011801f, -0.13510637f, 
    -0.23144546f, -0.66702068f, 0.05314846f, 0.16447094f, 0.20344295f, 0.34778747f, 0.02022206f, 0.23350909f, 
    0.31663930f, -0.49102229f, 0.11350171f, -0.14744364f, -0.14771831f, 0.18424630f, -0.52288604f, 0.12353987f, 
    -0.38473374f, -0.04409827f, -0.18006557f, -0.03588481f, -0.68019831f, -0.08368279f, 0.15011285f, -0.09373847f, 
    -0.15875460f, -0.45469296f, -0.12250882f, -0.52134734f, -0.08468757f, 0.05597391f, 0.21125300f, 0.08474158f, 
    0.27446827f, 0.20914476f, 0.00061741f, -0.34185293f, -0.16287655f, 0.26806763f, 0.26093379f, -0.35288247f, 
    -0.03773141f, -0.03877417f, -0.02684150f, 0.32841057f, 0.21115758f, 0.21144331f, 0.06003817f, -0.89265800f, 
    -0.08370568f, -0.08117086f, -0.03229003f, 0.21943130f, -0.60824561f, -0.15710373f, 0.07716182f, 0.00202538f, 
    0.09611700f, -0.13071966f, 0.01427392f, -0.03110793f, -0.59959328f, -0.01644468f, 0.24973471f, 0.06345429f, 
    -0.27081770f, -0.34664783f, 0.13081127f, 0.34612903f, 0.19487441f, -0.31935766f, 0.04018359f, -0.68954158f, 
    0.05465109f, 0.05050171f, -0.02708315f, 0.59554446f, -0.58477491f, -0.70716250f, 0.10577476f, 0.09736741f, 
    -0.13713628f, -0.06988173f, -0.33589643f, -0.85806316f, 0.04089979f, -0.14033955f, 0.48076099f, 0.05877618f, 
    -0.12265732f, 0.09245981f, 0.07615915f, -0.14172840f, 0.06557542f, 0.09186726f, 0.42835966f, -0.06001956f, 
    -0.40659979f, -0.11529183f, 0.12662344f, -0.10310998f, -0.46261469f, 0.02969421f, 0.40767965f, -0.21060611f, 
    -0.22254327f, -0.14340250f, 0.09745300f, -0.11342134f, -0.18975154f, 0.05071732f, -0.58335936f, 0.12219619f, 
    -0.75317323f, -0.00261193f, 0.33992770f, 0.26118049f, -0.31042361f, 0.08678617f, 0.42865947f, 0.03577915f, 
    -0.37622097f, 0.08365186f, 0.12693679f, 0.17790501f, 0.31525534f, 0.33552918f, -0.14827588f, -0.06910405f, 
    -0.45083660f, -0.16847409f, 0.06541532f, -0.23309092f, 0.11304563f, -0.52360594f, -0.77062827f, -0.21856800f, 
    -0.37957874f, -0.10055993f, -0.02695438f, 0.17734537f, 0.42474425f, -0.20571581f, 0.37102634f, -0.20305413f, 
    0.09315130f, 0.05946667f, -0.49179730f, 0.15189438f, -0.66074425f, -0.20086110f, -0.44513100f, 0.48496464f, 
    -0.19135618f, -0.32327893f, -0.02926817f, 0.11834005f, -0.36760005f, 0.12773342f, 0.13157332f, 0.07770387f, 
    0.29658854f, 0.27090454f, 0.08276671f, 0.14318700f, 0.09279868f, -0.15384462f, -0.05504793f, -0.15418659f, 
    -0.15454750f, -0.49452043f, 0.01258520f, -0.17454831f, 0.11805680f, -0.10438635f, 0.24751826f, 0.18579359f, 
    -0.24403405f, 0.11466829f, -0.27948481f, 0.38907525f, 0.33806893f, 0.13455248f, -0.19861683f, -0.40048093f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.02659904f, 0.17639153f, -0.28745860f, -0.04583006f, 0.07210372f, 0.17649038f, -0.08452547f, -0.30133736f, 
    0.09788813f, -0.00589010f, 0.16218407f, -0.16879532f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
