#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.66734624f, -0.17501645f, 0.15279216f, 0.31696129f, -0.39786801f, -0.02778515f, 0.25027126f, -0.30758354f, 
    -0.38682571f, -0.00413782f, -0.45606497f, -0.45676184f, -0.15284741f, -0.46747470f, -0.46157235f, -0.35635170f, 
    0.02238948f, 0.25449803f, 0.20265847f, 0.39507243f, 0.44884774f, 0.33445090f, 0.09901802f, -0.01002550f, 
    -0.18112484f, -0.15867648f, 0.00191104f, 0.29774705f, 0.57789254f, 0.06831256f, -0.41153347f, -0.35828191f, 
    -0.30792820f, 0.28782791f, -0.10678789f, 0.43036562f, -0.62044352f, -0.27959687f, 0.16362315f, 0.12716134f, 
    0.52859503f, -0.17254539f, 0.04226536f, 0.09335405f, -0.29356569f, -0.26644644f, -0.11903806f, -0.52779245f, 
    0.03639463f, 0.63688737f, 0.30478126f, 0.05566219f, -0.27879316f, -0.51559561f, -0.23073241f, -0.55758065f, 
    -0.09043131f, 0.50677866f, -0.22098495f, 0.32433867f, 0.00809995f, -0.23291036f, -0.42635110f, -0.49771729f, 
    -0.36136967f, -0.27201268f, -0.34293932f, -0.08000278f, 0.33286628f, -0.32580799f, 0.33891922f, -0.17112793f, 
    -0.44975770f, -0.43253803f, -0.31870806f, -0.06477015f, 0.72462636f, 0.40129888f, -0.07253025f, -0.09844854f, 
    0.32043830f, 0.00391139f, -0.74858677f, 0.15302302f, 0.40545931f, 0.00590749f, 0.66045380f, 0.01286387f, 
    -0.19212501f, 0.11547638f, -0.05070278f, 0.08349725f, 0.23194349f, 0.40938741f, -0.46720451f, 0.16942266f, 
    -0.45301983f, -0.19723566f, -0.51237541f, 0.06047204f, 0.59982663f, -0.45991835f, 0.47041911f, -0.33715102f, 
    0.35253581f, -0.19915320f, -0.14420892f, -0.10234132f, 0.47199199f, -0.25617653f, -0.62905139f, 0.52764589f, 
    0.38544992f, -0.10108344f, 0.12206414f, 0.25054193f, -0.05732141f, 0.50511366f, 0.11333576f, 0.36190104f, 
    0.36726660f, 0.43838781f, 0.38470104f, -0.06146286f, -0.37877050f, -0.30471286f, -0.69560564f, 0.54617703f, 
    -0.44107598f, 0.01799793f, -0.31141022f, -0.48305354f, 0.12495240f, 0.12850919f, -0.02811636f, -0.55004758f, 
    0.63690674f, -0.01692690f, 0.35242319f, 0.05144624f, -0.50964320f, -0.14516574f, 0.13249375f, -0.21785845f, 
    0.38920388f, -0.15391396f, -0.50834399f, 0.42824170f, -0.33805013f, 0.20512559f, -0.13303229f, -0.40809751f, 
    0.20222104f, 0.35215640f, 0.12483031f, 0.47403479f, -0.58139384f, -0.70873713f, -0.42349732f, 0.10473965f, 
    0.23412707f, 0.09231190f, 0.07417810f, 0.51529044f, 0.57458246f, 0.50506663f, 0.00056630f, 0.15858571f, 
    0.26094994f, 0.16259000f, 0.41169432f, -0.07187443f, 0.05533038f, 0.40619323f, 0.17945169f, 0.25116494f, 
    0.00720128f, -0.51041102f, 0.54763895f, -0.29032159f, -0.30895698f, -0.53166890f, -0.62322062f, -0.02903926f, 
    -0.33327433f, -0.31429744f, 0.29334867f, 0.23299481f, 0.36834291f, -0.51386982f, -0.20106719f, -0.29787576f, 
    0.42882490f, 0.57463318f, -0.23552570f, 0.08381489f, -0.33818665f, 0.11880962f, 0.60528451f, -0.38359374f, 
    -0.58625811f, -0.55670911f, -0.25547862f, -0.26763555f, 0.10787261f, -0.01752377f, 0.25816122f, -0.18165748f, 
    0.11302887f, -0.07862312f, -0.72371870f, 0.01014476f, -0.55275351f, -0.32531345f, 0.31480321f, 0.07569900f, 
    0.28031671f, -0.45326182f, -0.39738181f, -0.42015514f, 0.60228264f, -0.43640396f, 0.01978321f, 0.28094026f, 
    -0.22102530f, 0.54885912f, 0.70310003f, -0.23343925f, 0.30076706f, -0.55546808f, -0.30778822f, 0.09742565f, 
    0.04725893f, 0.05165253f, 0.03699825f, 0.24215692f, 0.28637162f, 0.10006399f, -0.70450777f, 0.09655939f, 
    -0.49474546f, -0.46577772f, 0.19913012f, 0.27605745f, 0.15564308f, 0.14715138f, -0.57381719f, -0.12617934f, 
    0.59810722f, 0.00481517f, -0.07144333f, 0.23567280f, -0.73199058f, -0.55618417f, 0.30562934f, 0.16127381f, 
    -0.11281151f, -0.04029502f, 0.19765414f, -0.12719043f, 0.16593775f, 0.47527140f, -0.46549037f, 0.45034045f, 
    0.29257756f, 0.10030162f, -0.11064410f, -0.22968113f, 0.05298262f, 0.45573273f, 0.51069653f, 0.28560618f, 
    0.45996371f, 0.04352384f, -0.53447533f, 0.31177652f, 0.06838570f, 0.09839816f, 0.17537138f, 0.71003562f, 
    0.57445079f, 0.27212808f, -0.41237116f, 0.44601306f, -0.21792270f, -0.03392906f, 0.27448210f, -0.15102568f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13825043f, -0.16294137f, -0.11208092f, 0.02900605f, -0.04723929f, -0.19283615f, -0.04310481f, -0.08174586f, 
    0.18360132f, -0.15543213f, 0.16785619f, -0.48262137f, 0.23534954f, -0.24351993f, 0.11501554f, -0.11814083f, 
    0.01152410f, 0.20682499f, -0.36210528f, -0.02101302f, -0.28946018f, 0.03572273f, 0.19717577f, 0.05397869f, 
    -0.05902129f, -0.31863081f, -0.51920414f, 0.17673816f, -0.18250714f, -0.31811544f, 0.01720146f, -0.31337890f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04426229f, 0.29792547f, 0.11382601f, 0.03235912f, 0.04245613f, -0.06830176f, -0.11960483f, 0.04477618f, 
    0.04046162f, 0.15292774f, 0.08834875f, -0.02827643f, -0.06377523f, -0.00828885f, -0.03485262f, 0.00946226f, 
    0.12071290f, -0.17354885f, -0.04658617f, 0.01541154f, -0.02773509f, -0.03463904f, 0.01736142f, 0.04560460f, 
    0.05956989f, 0.11725178f, 0.04727680f, 0.30231267f, 0.12332133f, -0.16483893f, 0.14611676f, 0.05306435f, 
    0.00090466f, 0.02383888f, 0.02509117f, -0.08892027f, -0.09357009f, -0.11382940f, 0.05657946f, -0.08879940f, 
    -0.06814761f, -0.00028368f, -0.07360063f, 0.03649696f, 0.10960894f, -0.08460563f, -0.11633810f, 0.11293435f, 
    -0.21415883f, -0.14172293f, 0.04147803f, -0.02174546f, -0.01099529f, 0.11621246f, -0.15141875f, 0.09742874f, 
    0.01283266f, -0.13764480f, -0.13365869f, 0.08577761f, -0.04973387f, 0.02904583f, 0.07335171f, 0.02496968f, 
    0.18674946f, -0.10734869f, -0.13849649f, 0.02196623f, -0.01401073f, 0.02217621f, 0.05402931f, 0.04951304f, 
    -0.05629159f, 0.03088384f, 0.14126611f, -0.14446762f, -0.05445144f, 0.10588502f, 0.04350460f, 0.05302295f, 
    -0.04835545f, 0.16576423f, 0.11972466f, 0.15067972f, -0.09729464f, -0.08004189f, -0.13871013f, -0.16164874f, 
    -0.09097420f, 0.02357359f, -0.19546059f, 0.07476673f, 0.05718958f, 0.02499273f, 0.06037629f, 0.01111376f, 
    0.02466262f, -0.02685043f, 0.04381363f, 0.12758024f, -0.01828418f, -0.19644745f, -0.07510236f, 0.10765085f, 
    0.01734212f, -0.10640845f, 0.04168651f, -0.13758470f, 0.14085753f, 0.05280407f, -0.03395522f, 0.01614814f, 
    -0.08156910f, -0.00276514f, -0.16965999f, -0.08712921f, 0.04421682f, -0.33179891f, -0.00969260f, -0.09051196f, 
    -0.01508908f, -0.07382885f, 0.11494157f, -0.00559448f, 0.16640341f, -0.09279732f, 0.13742240f, -0.01440084f, 
    -0.04030500f, 0.09002968f, 0.04663733f, 0.08842584f, 0.02921090f, -0.05505146f, -0.12123872f, 0.28015345f, 
    -0.10791058f, -0.08021644f, -0.11162755f, 0.07754828f, 0.00446455f, -0.04715803f, -0.03057018f, -0.13011448f, 
    0.12688586f, 0.11772505f, 0.11646908f, -0.07645219f, 0.02425798f, 0.13576287f, -0.08622564f, 0.09304856f, 
    -0.10754459f, 0.31942782f, 0.22438754f, 0.09400050f, 0.15058213f, 0.04437894f, -0.13855445f, 0.04510373f, 
    0.03394238f, -0.02859505f, 0.10221747f, -0.12995765f, 0.00746943f, -0.00420864f, 0.04445470f, 0.05534163f, 
    -0.26341507f, -0.03587729f, -0.20435278f, 0.02675927f, 0.03752590f, 0.03917357f, -0.18610883f, 0.07251512f, 
    0.04090318f, -0.09078287f, 0.13646232f, 0.09925749f, 0.13231285f, -0.12558249f, -0.09535290f, 0.00977648f, 
    -0.03089185f, -0.21744363f, -0.08088246f, 0.05069761f, -0.08499976f, 0.03409952f, -0.03183167f, 0.02802240f, 
    -0.14486755f, -0.05465412f, -0.02070132f, -0.02818840f, 0.04000600f, 0.15982348f, 0.14481631f, 0.20374779f, 
    -0.09283623f, 0.04985876f, 0.20719692f, -0.02710638f, 0.04971370f, 0.06680939f, -0.02620129f, -0.03089256f, 
    0.08138553f, -0.09560364f, 0.07114463f, -0.00394768f, -0.07105490f, 0.10086318f, -0.01479057f, 0.01579997f, 
    0.07785647f, 0.12186202f, -0.01939403f, -0.01357525f, 0.06325801f, -0.16559705f, -0.09526367f, -0.00407115f, 
    0.06046673f, 0.37566864f, -0.04581869f, -0.07712606f, 0.19583836f, 0.13066800f, -0.01912770f, -0.12408908f, 
    0.04349520f, -0.20125395f, 0.00437125f, -0.10806466f, -0.02846543f, -0.02724076f, 0.08466267f, -0.19146138f, 
    0.05228086f, -0.06106484f, 0.01302224f, -0.02556231f, 0.18315433f, 0.16054428f, 0.02472280f, 0.14933343f, 
    0.06406182f, 0.15936078f, -0.05938423f, -0.08169844f, 0.04515895f, -0.10715295f, 0.06233336f, -0.03922073f, 
    -0.19298272f, -0.00864950f, -0.08772064f, -0.01993820f, 0.06837291f, -0.21855523f, -0.13465565f, -0.17896752f, 
    -0.12947667f, 0.10509413f, 0.01252672f, 0.01035202f, 0.02316208f, -0.31746572f, -0.05251556f, 0.03608128f, 
    -0.06998825f, 0.07257190f, -0.04991898f, 0.13372827f, -0.08849096f, -0.10010323f, -0.01194413f, 0.29200110f, 
    0.31745243f, -0.21390975f, -0.01740004f, 0.03079191f, 0.02279613f, 0.08372838f, -0.28989050f, -0.06434734f, 
    -0.20022461f, -0.18034825f, -0.04882534f, 0.07742353f, -0.10076026f, 0.02846411f, 0.11676817f, 0.04852658f, 
    -0.14604311f, 0.21316929f, -0.00579696f, -0.19939777f, -0.05512315f, -0.01078647f, -0.15124324f, 0.05798868f, 
    -0.00861500f, -0.06685573f, -0.06578908f, -0.08774442f, -0.00715120f, 0.24236631f, 0.09629568f, 0.16210820f, 
    -0.00733453f, -0.16670100f, 0.00268473f, 0.18606295f, -0.11300427f, 0.17355601f, 0.16984658f, 0.02768019f, 
    0.09219303f, -0.05763326f, 0.00899519f, -0.03310586f, -0.06709809f, 0.02450442f, 0.08338260f, -0.14837714f, 
    -0.06696779f, 0.03544510f, 0.07533431f, 0.04472913f, -0.00630725f, 0.05249798f, -0.01013236f, -0.10226414f, 
    -0.21923506f, 0.00314093f, -0.09002963f, -0.02078252f, 0.06356286f, -0.21146575f, -0.03994979f, 0.00815452f, 
    -0.05701565f, 0.07144375f, 0.00919601f, 0.04225508f, -0.15239605f, 0.12002047f, 0.08219341f, -0.05567000f, 
    0.03386557f, -0.07264473f, -0.13742067f, -0.28284571f, -0.06253866f, -0.01316041f, 0.06251692f, -0.03609589f, 
    0.02197163f, 0.12196139f, 0.03466333f, -0.18353251f, 0.09011742f, -0.07325953f, -0.05088346f, 0.08979898f, 
    -0.04886712f, 0.14075026f, 0.13081355f, 0.04745210f, 0.01159869f, 0.01722831f, 0.01101447f, -0.08158045f, 
    0.17582643f, 0.20200796f, -0.11951934f, -0.05048737f, 0.04538501f, 0.04194198f, 0.11028715f, 0.00069554f, 
    -0.18505341f, -0.11199898f, -0.00782441f, 0.21220955f, -0.03969696f, 0.11907494f, 0.16044608f, -0.09280755f, 
    0.01724567f, -0.03273460f, -0.21927525f, 0.00649274f, -0.05759032f, 0.04395466f, 0.02218848f, 0.03066783f, 
    0.03434100f, -0.14557721f, -0.05456889f, 0.09565905f, 0.10618512f, -0.36370364f, -0.09918248f, -0.08891958f, 
    0.08111262f, 0.10508085f, -0.01135730f, -0.06536216f, 0.10585028f, -0.09383481f, 0.22642681f, -0.08415841f, 
    0.05315690f, -0.03435807f, -0.08354107f, 0.02052682f, 0.03716056f, -0.04172433f, 0.01977948f, 0.14181709f, 
    -0.17404035f, -0.07741009f, -0.04572651f, -0.20862478f, -0.06316509f, -0.17361294f, 0.01545869f, 0.03902699f, 
    0.05145611f, 0.11017407f, 0.01471407f, -0.00511142f, 0.06647884f, 0.02894472f, 0.00571361f, -0.13088205f, 
    -0.12773398f, 0.30090988f, 0.04943846f, 0.26016966f, -0.00748081f, 0.11365589f, 0.07878388f, 0.06458498f, 
    0.01234170f, 0.01119467f, -0.49003676f, -0.00852527f, -0.13093936f, 0.23676004f, 0.08152178f, 0.11948194f, 
    0.12945837f, 0.01115443f, 0.14837639f, 0.01813874f, -0.04636373f, -0.20470694f, 0.08061565f, 0.04748207f, 
    -0.01462639f, 0.14629720f, -0.05716051f, -0.04019030f, 0.07228646f, 0.04723920f, -0.08852264f, -0.00958277f, 
    -0.21889517f, -0.12378085f, -0.01268650f, -0.11222867f, 0.17939606f, -0.05231353f, 0.03278032f, 0.04924615f, 
    0.04153196f, 0.07502985f, 0.09904834f, 0.10195222f, 0.02004003f, 0.00001848f, 0.09986323f, 0.03752170f, 
    0.01606476f, -0.12607363f, -0.17391944f, -0.00387693f, 0.10810021f, 0.03316266f, 0.04101370f, 0.05340720f, 
    -0.04641409f, 0.07874733f, 0.02666063f, -0.08830399f, -0.04028902f, -0.07194324f, -0.04514093f, 0.11360140f, 
    -0.02826367f, -0.03507194f, -0.00034210f, -0.16603233f, -0.03984384f, -0.00390028f, 0.12008697f, 0.04049459f, 
    -0.04626882f, 0.35423967f, -0.13892493f, 0.09008326f, 0.03832731f, -0.10417738f, 0.01433765f, 0.02963769f, 
    0.15261750f, 0.01020047f, 0.03544159f, -0.20951402f, -0.01546566f, 0.10657856f, 0.06646598f, 0.06723577f, 
    -0.03396367f, -0.06101982f, -0.07737160f, -0.06761611f, -0.04750267f, -0.08828043f, 0.09532760f, 0.03043039f, 
    0.08425739f, 0.02202411f, 0.08751246f, -0.10128975f, -0.11401694f, 0.06394447f, -0.10434383f, 0.07133786f, 
    -0.12556465f, 0.07878241f, -0.05988681f, 0.00403806f, 0.03544162f, -0.40990213f, -0.15801097f, -0.04877389f, 
    -0.04643897f, -0.10334388f, -0.00343846f, 0.12704302f, 0.02521861f, 0.01631350f, -0.35504097f, -0.29210776f, 
    -0.06549229f, 0.11065219f, 0.05110491f, 0.15799899f, 0.11652434f, 0.13600300f, 0.05058669f, -0.03012715f, 
    -0.46333778f, -0.12424356f, 0.23962998f, 0.04170324f, -0.15005371f, 0.06658340f, -0.07487577f, 0.02588101f, 
    0.32743537f, -0.10065082f, 0.09479266f, -0.26135895f, -0.04623505f, 0.08809241f, 0.11715539f, 0.28991547f, 
    -0.06396428f, 0.15389362f, 0.08528671f, -0.09323673f, 0.17924272f, 0.04438182f, -0.16565935f, -0.03101142f, 
    -0.11461170f, 0.06636981f, 0.14808051f, 0.20007496f, -0.00188132f, -0.07346155f, 0.07431615f, -0.07126807f, 
    -0.14336379f, 0.04535811f, -0.09047279f, 0.23289739f, 0.14402312f, -0.13465233f, -0.08883198f, -0.07982472f, 
    -0.03725504f, 0.11109491f, -0.09717847f, -0.06699470f, -0.46999547f, -0.11115866f, -0.14166518f, 0.23496714f, 
    0.06926993f, 0.16508399f, -0.10868638f, -0.00186232f, 0.05872010f, -0.10296963f, -0.04055681f, -0.05004145f, 
    0.03822131f, 0.03662034f, -0.00130208f, -0.04089770f, -0.17609534f, -0.13764971f, 0.13643672f, -0.14268014f, 
    -0.02063387f, 0.05188210f, -0.13737546f, -0.09638008f, -0.04808179f, 0.19158116f, 0.06806236f, 0.02066865f, 
    0.16010968f, 0.24437985f, -0.01593302f, 0.00679121f, 0.01599179f, 0.02481629f, -0.06727304f, -0.02574617f, 
    -0.28465021f, -0.02652913f, 0.09724669f, 0.09497661f, 0.15295103f, 0.08274873f, 0.02143983f, -0.20899597f, 
    0.05323399f, 0.02640348f, -0.19523266f, -0.03407107f, 0.09314793f, -0.07648009f, 0.02444367f, -0.07895710f, 
    0.04827560f, -0.12330408f, 0.10181274f, 0.08205856f, -0.19622473f, 0.10724697f, -0.16964379f, 0.00509329f, 
    -0.07420650f, 0.15721661f, 0.08306370f, -0.04317965f, 0.07329580f, 0.01333956f, 0.14881721f, -0.03608442f, 
    0.00085632f, 0.00386278f, -0.15203910f, 0.01126239f, 0.15556662f, 0.23180906f, 0.30605021f, 0.08356259f, 
    0.04367344f, -0.16383897f, 0.04646810f, 0.00365695f, 0.01395777f, 0.19131707f, -0.10006520f, 0.00319002f, 
    -0.05918524f, 0.07539880f, -0.19413364f, 0.09705506f, 0.08660538f, 0.03744892f, -0.19625771f, -0.02775408f, 
    0.01868870f, 0.02031635f, 0.11050742f, 0.17863981f, -0.06991497f, 0.06585801f, 0.11457076f, -0.27866885f, 
    -0.08783691f, 0.09790464f, 0.13968749f, -0.01014077f, 0.10309793f, -0.05626388f, 0.08992713f, 0.02027770f, 
    0.26971981f, -0.08243948f, 0.19217268f, 0.22578309f, -0.05602664f, 0.03331236f, -0.01231397f, -0.02319581f, 
    0.08095789f, 0.10598128f, 0.29338488f, -0.20861700f, -0.00560680f, 0.04877610f, -0.08848789f, 0.21704857f, 
    0.07133866f, 0.16524142f, 0.00236480f, 0.07366934f, -0.27123499f, 0.05269940f, 0.05660154f, -0.01781474f, 
    -0.09884586f, -0.11109221f, 0.04322971f, -0.00380216f, 0.00797578f, -0.00151347f, 0.02468323f, -0.19696216f, 
    -0.01445417f, 0.07539345f, -0.07824325f, -0.13554037f, -0.13676085f, 0.07544237f, 0.24957651f, 0.23314370f, 
    0.06886548f, -0.08611698f, -0.00913091f, -0.09915248f, 0.01540887f, -0.16268587f, -0.31780976f, 0.09853628f, 
    0.19337608f, 0.12917963f, 0.01337578f, 0.04026274f, -0.01351023f, 0.00437216f, 0.15109360f, -0.02545790f, 
    -0.00905492f, 0.05602992f, -0.04051255f, -0.08974739f, 0.01216458f, -0.14822075f, 0.18050554f, -0.00439806f, 
    0.01920028f, -0.14045411f, 0.00176574f, 0.11195201f, 0.08995501f, 0.16650315f, 0.05490016f, -0.13615680f, 
    0.00495616f, 0.01529360f, -0.07493109f, 0.09339705f, -0.05154853f, 0.05603068f, 0.06874669f, -0.01721550f, 
    0.19903640f, 0.27851567f, 0.19760241f, -0.23569192f, 0.01981522f, 0.09533745f, -0.27705973f, 0.06121616f, 
    0.07056364f, -0.10445811f, -0.05407672f, 0.12339301f, -0.14544131f, 0.07632442f, -0.16842157f, 0.23037672f, 
    -0.02336659f, 0.14296579f, -0.01443966f, 0.05448493f, 0.08696786f, 0.05580921f, 0.04626038f, 0.03839840f, 
    0.10240622f, 0.11744057f, 0.05428508f, 0.09852851f, -0.04789365f, 0.08585314f, -0.08189555f, 0.21072122f, 
    0.18759620f, 0.02229849f, 0.15754405f, 0.25635040f, 0.10306828f, -0.13206889f, -0.28682929f, -0.11891270f, 
    0.01009635f, -0.12904923f, -0.16567422f, -0.03435204f, -0.18583269f, -0.00899077f, 0.04024689f, 0.15691793f, 
    0.10149476f, -0.01435819f, -0.02013391f, -0.09463549f, -0.02845173f, 0.02303049f, -0.10098751f, 0.16096550f, 
    0.14178914f, -0.05558394f, -0.24821778f, -0.14257228f, 0.02884254f, 0.02438824f, -0.15729021f, 0.01880645f, 
    -0.13585743f, -0.08182146f, 0.12346003f, -0.08019524f, 0.03594406f, -0.12133076f, 0.09935087f, 0.04857696f, 
    -0.06531514f, 0.17853124f, -0.02434499f, 0.03286880f, 0.01716074f, 0.02501497f, 0.11135121f, -0.03291600f, 
    0.01490142f, 0.02992408f, 0.15040408f, 0.10485214f, -0.01258174f, -0.05039627f, 0.01593540f, -0.00862386f, 
    -0.03465302f, -0.01171259f, 0.08103710f, -0.08726352f, -0.04297175f, -0.03612601f, -0.16560405f, -0.05909096f, 
    0.08494801f, -0.03170672f, 0.10933763f, 0.00607054f, 0.25434798f, 0.19810849f, 0.15923521f, 0.01464363f, 
    0.01898987f, -0.13037072f, -0.09099115f, -0.03468512f, 0.15596585f, 0.21341991f, 0.07130927f, 0.08815751f, 
    0.03440624f, 0.01926797f, 0.00889454f, 0.04953648f, 0.02256025f, -0.02170311f, 0.16060920f, 0.10012665f, 
    0.10448530f, 0.08356941f, 0.00237618f, 0.04464798f, 0.00450707f, -0.02153964f, -0.02700458f, 0.00502163f, 
    0.26270679f, 0.16516410f, 0.16947719f, -0.00506804f, -0.03587060f, -0.00357709f, -0.05817934f, -0.09760498f, 
    0.13203326f, 0.13327998f, 0.19080715f, 0.04969912f, 0.00657826f, -0.02057136f, 0.03805096f, -0.03114748f, 
    0.05594682f, 0.12758054f, 0.03068699f, 0.02843735f, -0.01827540f, 0.07552450f, -0.01018138f, -0.04362139f, 
    0.02862182f, 0.06094758f, -0.03387617f, -0.25049150f, -0.01242863f, 0.00855359f, -0.03150411f, 0.01666025f, 
    -0.17013632f, -0.04959929f, 0.01629804f, -0.06249898f, -0.10236404f, 0.09102020f, 0.14602678f, -0.02125802f, 
    -0.10800643f, -0.00253640f, -0.02659432f, -0.01334479f, 0.10868560f, 0.07534923f, -0.04396421f, 0.08094988f, 
    0.04596387f, 0.00300896f, 0.10811727f, 0.03762576f, 0.07305070f, -0.04037988f, -0.10981665f, -0.01005850f, 
    0.09501821f, 0.16729242f, -0.18137689f, 0.09805144f, -0.03391459f, 0.20714736f, 0.10996285f, -0.07223780f, 
    0.09507405f, -0.10996103f, 0.12287334f, 0.02170131f, -0.05012173f, 0.06409544f, -0.13183923f, -0.12730426f, 
    -0.09586795f, -0.16547291f, 0.00059262f, 0.08497944f, 0.00361658f, -0.03107676f, 0.03719609f, -0.17032841f, 
    0.10875569f, 0.05143161f, -0.13740054f, 0.15470424f, -0.03405842f, 0.11004487f, -0.05679571f, -0.09384278f, 
    -0.15719125f, -0.01191907f, -0.21280284f, 0.02509277f, -0.10780003f, -0.02494497f, 0.08030259f, -0.08712163f, 
    -0.01116221f, -0.07932069f, -0.17977449f, -0.03652853f, -0.16993910f, -0.10695577f, -0.05103275f, 0.10427941f, 
    0.02749167f, 0.12774393f, 0.08554424f, 0.00139910f, -0.07033555f, -0.04361904f, 0.03327242f, -0.08245022f, 
    0.00302139f, 0.02121223f, -0.06193367f, -0.03143849f, 0.23197962f, 0.22874486f, 0.17885171f, -0.05031382f, 
    -0.18433294f, 0.15830354f, -0.00330459f, 0.01068913f, 0.05120970f, 0.28945997f, 0.16759214f, 0.15923823f, 
    -0.04164469f, -0.03525121f, 0.10429273f, 0.06829315f, 0.03273334f, -0.17453620f, -0.08214863f, -0.03296354f, 
    0.01344738f, 0.11214951f, 0.13627870f, -0.07146488f, -0.01182749f, -0.04044395f, -0.03815738f, -0.07445598f, 
    -0.10061502f, 0.16117741f, 0.10127769f, 0.00914772f, 0.16000782f, -0.27739131f, -0.01247520f, -0.14420502f, 
    -0.07786629f, -0.10137853f, 0.06887764f, 0.13058184f, 0.03282074f, -0.01213399f, -0.06056757f, -0.06514309f, 
    0.04485751f, -0.00209563f, 0.03521975f, -0.06070808f, -0.07610089f, -0.17306060f, -0.01922295f, 0.17505112f, 
    0.00858686f, -0.20477837f, 0.04362806f, -0.08916511f, -0.06631807f, -0.03089295f, -0.08122806f, 0.05888424f, 
    -0.07894173f, 0.04578019f, -0.05418378f, -0.02557806f, -0.04826590f, -0.15832871f, 0.01964463f, -0.11315756f, 
    -0.04001945f, 0.01282830f, 0.03886207f, 0.17700128f, 0.16124624f, 0.10618314f, 0.23839815f, -0.02496348f, 
    -0.10772505f, 0.03955034f, 0.03962250f, -0.06062956f, 0.04976290f, 0.01273939f, 0.01060019f, 0.11395153f, 
    0.17112701f, -0.07398876f, -0.09547330f, -0.12218020f, -0.08901174f, 0.02673337f, 0.07365795f, -0.09817133f, 
    -0.04604135f, -0.12426842f, -0.09261791f, -0.00857399f, -0.02164237f, -0.05839460f, 0.15829548f, -0.31400058f, 
    -0.32469130f, 0.15081471f, 0.04635317f, -0.07561772f, -0.01154494f, -0.09487638f, -0.20760384f, 0.15770891f, 
    -0.04368497f, -0.12832898f, -0.16484033f, -0.04426858f, -0.03382229f, 0.03442522f, -0.10476480f, 0.02973393f, 
    -0.00856098f, 0.12870637f, 0.07271996f, -0.13211600f, 0.00604687f, -0.17732377f, -0.05666227f, 0.00757358f, 
    0.02318568f, -0.08860207f, 0.05061330f, -0.01283157f, -0.16690063f, -0.04844475f, -0.11655070f, -0.00277074f, 
    0.03992116f, 0.09964514f, -0.01150918f, -0.29694694f, -0.05460017f, -0.18788786f, 0.02877799f, 0.07280466f, 
    -0.01313896f, -0.16248731f, -0.01133775f, -0.13359348f, -0.04666058f, 0.13858002f, 0.18962547f, 0.14415519f, 
    -0.02588565f, 0.06051090f, 0.11146099f, -0.03255885f, 0.01670341f, 0.10145582f, 0.16585770f, -0.04155511f, 
    0.08485907f, 0.06013759f, -0.03727127f, 0.09633608f, 0.09462916f, 0.08556651f, 0.05583995f, 0.12581652f, 
    0.01093027f, 0.03803481f, 0.05553697f, 0.10748211f, 0.02630217f, 0.06495504f, 0.00424082f, -0.28395268f, 
    0.07159430f, 0.22250676f, 0.07364800f, -0.06321007f, 0.01791758f, 0.13061535f, 0.02058244f, -0.05801601f, 
    -0.10434048f, 0.03582712f, -0.12135667f, 0.05791242f, -0.07587323f, -0.04385531f, 0.07817397f, 0.04008474f, 
    0.12577291f, 0.12989751f, -0.00323162f, -0.23313497f, -0.09943087f, 0.04968998f, -0.03829803f, 0.00112488f, 
    -0.02389679f, 0.16393632f, 0.12240931f, -0.05123019f, 0.14632455f, 0.11395237f, 0.07367734f, 0.04690321f, 
    -0.03144337f, -0.10399504f, 0.02946781f, 0.31011561f, 0.14512600f, 0.03606123f, -0.14769715f, 0.19475979f, 
    0.07640751f, 0.00677950f, -0.00706575f, 0.12336108f, -0.09697650f, 0.03116363f, -0.14797857f, -0.04695844f, 
    0.11421958f, -0.07174013f, -0.00404150f, -0.00468638f, 0.13093050f, -0.05400394f, -0.25136822f, 0.11868355f, 
    0.03917191f, 0.07265712f, -0.06950306f, -0.07471500f, 0.00757831f, -0.00742366f, 0.28569663f, -0.03989656f, 
    0.01570289f, 0.01943698f, -0.03810470f, -0.04930093f, -0.04466835f, 0.05402710f, -0.00797233f, 0.32474974f, 
    -0.08157797f, -0.00551318f, 0.01173398f, 0.02021779f, -0.26924142f, -0.02405837f, 0.00518847f, 0.01317341f, 
    0.19820257f, 0.11880670f, 0.03311723f, -0.08112778f, 0.01659903f, -0.01275658f, -0.04972007f, -0.13398886f, 
    -0.03579064f, 0.12534927f, -0.16206780f, 0.13970098f, 0.13378192f, 0.09484537f, -0.05217710f, -0.12794203f, 
    -0.04287714f, -0.25054738f, -0.11845320f, 0.15886769f, 0.05098113f, 0.04426711f, -0.12023290f, -0.05277735f, 
    -0.17707129f, 0.07646167f, -0.08172718f, 0.04196744f, 0.00185458f, 0.00249342f, -0.18329191f, -0.12875870f, 
    0.07970982f, -0.09343296f, -0.05540614f, -0.10137649f, -0.03514164f, 0.16439112f, -0.21063600f, -0.02178713f, 
    0.06390993f, -0.10049493f, -0.13135973f, 0.10816474f, -0.03835834f, -0.02133019f, 0.13181850f, 0.01994896f, 
    -0.06680433f, -0.07983755f, 0.07731050f, 0.14049460f, 0.07444178f, 0.02277353f, 0.16522174f, 0.13845843f, 
    -0.21272451f, -0.04745693f, 0.08038605f, -0.08365765f, 0.00358268f, -0.05203167f, -0.06732766f, -0.04865446f, 
    0.07954876f, 0.00751527f, 0.08535463f, -0.02090661f, 0.02772987f, 0.02889577f, 0.02564354f, -0.19735645f, 
    0.00286723f, 0.17327121f, 0.13037884f, -0.11815085f, 0.04976732f, 0.00076619f, -0.00753507f, -0.00008929f, 
    -0.13750979f, 0.10171901f, -0.04270364f, -0.05430406f, -0.07617745f, -0.08760245f, 0.06951152f, -0.10184452f, 
    0.04201785f, 0.03232991f, 0.31296134f, 0.02589108f, -0.09391341f, -0.07875671f, 0.08739040f, -0.10557851f, 
    -0.01372890f, 0.16752753f, -0.04069025f, -0.01305408f, -0.22343841f, -0.18919460f, -0.11591405f, 0.09908201f, 
    0.03238164f, 0.00794828f, -0.04106881f, -0.00959108f, -0.01217877f, -0.11947301f, 0.10652254f, -0.00413960f, 
    -0.01385624f, 0.00978578f, 0.00066156f, 0.06464419f, 0.13363743f, 0.12305944f, -0.16371068f, -0.01944155f, 
    -0.18723670f, 0.06966706f, 0.09128839f, -0.02738063f, 0.09807692f, -0.09130225f, 0.06721605f, -0.30641013f, 
    -0.24613665f, -0.07699373f, 0.07162567f, 0.03066485f, -0.06582165f, -0.11001091f, -0.08163343f, -0.26721510f, 
    -0.23802401f, 0.08016409f, 0.09913218f, 0.09260872f, 0.00660710f, -0.09180319f, 0.04391805f, -0.16579035f, 
    0.01030230f, -0.01128810f, 0.00144767f, -0.04017165f, -0.00579526f, 0.02238873f, -0.03668541f, -0.04238206f, 
    -0.05698324f, -0.03936345f, -0.02960818f, -0.00024900f, -0.06454752f, 0.00217483f, -0.00348002f, -0.06268949f, 
    0.02732794f, 0.00573319f, 0.05070623f, -0.02160912f, 0.03929686f, -0.04653713f, -0.05367170f, 0.04157741f, 
    -0.01188772f, -0.02064448f, 0.01411674f, -0.01410554f, 0.02581424f, -0.00466412f, -0.03311678f, -0.05310841f, 
    0.01154379f, 0.03096541f, -0.03829157f, -0.04110734f, -0.05941909f, -0.02238917f, -0.03076141f, 0.03394447f, 
    -0.06327377f, 0.01705582f, 0.03965292f, -0.03114272f, 0.00589608f, 0.00704270f, 0.03683745f, -0.00053994f, 
    0.04847842f, -0.00935480f, 0.03677326f, -0.02118337f, 0.04638321f, -0.05061875f, -0.03582877f, 0.00516590f, 
    0.04957572f, -0.02500603f, -0.03779234f, 0.05238195f, -0.00432514f, 0.04080801f, -0.01061389f, -0.00374559f, 
    -0.00454990f, -0.06359984f, -0.02328613f, -0.01426097f, 0.02405602f, -0.01720358f, 0.00355511f, -0.06479614f, 
    0.03884644f, 0.04808805f, -0.00276234f, 0.01821095f, -0.05074146f, -0.01092759f, -0.04040859f, -0.01136482f, 
    -0.02490833f, -0.00324199f, -0.04868461f, -0.06298985f, -0.03728496f, 0.03449658f, -0.00517433f, -0.02435153f, 
    -0.01857803f, 0.03003184f, 0.02081264f, -0.05974079f, 0.02565421f, 0.01189732f, -0.02942731f, -0.02812709f, 
    0.01781830f, 0.03140731f, 0.03520358f, 0.04130776f, 0.01820511f, 0.03120302f, 0.04233201f, 0.00389920f, 
    0.03717699f, -0.03634083f, 0.03646709f, 0.04610088f, 0.04084892f, 0.00930942f, -0.02443007f, 0.00626498f, 
    -0.00345640f, 0.04020471f, 0.05123194f, -0.04274573f, 0.00811073f, -0.00598711f, -0.01089582f, -0.06435880f, 
    -0.02351769f, -0.04083541f, 0.00537321f, -0.03282712f, -0.01557998f, -0.03608491f, 0.05850201f, -0.03876369f, 
    -0.03922048f, -0.04894346f, -0.01696111f, -0.02378029f, 0.02592672f, -0.05708993f, -0.01365132f, -0.01026580f, 
    0.03404723f, -0.01484029f, -0.02753312f, 0.04235491f, -0.05149565f, 0.04861857f, 0.04403187f, -0.00898851f, 
    -0.03775956f, -0.02171230f, -0.06272303f, -0.03494550f, 0.02425817f, -0.00438888f, 0.02576528f, 0.02612777f, 
    -0.04243660f, -0.03047563f, -0.03279356f, -0.02941269f, -0.04832685f, -0.05429854f, -0.05704105f, -0.02094969f, 
    0.00964313f, 0.04378042f, 0.02927488f, 0.04020649f, 0.00338243f, 0.05890041f, 0.04065733f, -0.06034612f, 
    0.03034856f, -0.04910383f, -0.01625689f, -0.06295647f, -0.06000511f, 0.01798317f, -0.05040803f, 0.02276497f, 
    -0.06064951f, 0.04599160f, 0.00306471f, 0.03780556f, -0.00274343f, -0.01796974f, 0.01408528f, -0.03648034f, 
    0.01518729f, 0.00723210f, 0.02899290f, -0.04728055f, -0.05067562f, 0.01417704f, -0.04171469f, 0.05292499f, 
    -0.01155349f, 0.03641479f, -0.03013734f, -0.05190659f, 0.05320509f, -0.00697307f, 0.00498673f, -0.01363995f, 
    -0.00308186f, 0.00685658f, 0.04959386f, 0.01886862f, 0.00766148f, -0.00222167f, -0.01301573f, -0.05051949f, 
    0.03404871f, -0.02112292f, 0.02490413f, -0.00323905f, -0.05292663f, 0.03052385f, 0.02498671f, 0.01965788f, 
    0.05466148f, 0.02639597f, -0.03284753f, -0.04995816f, 0.03585564f, -0.03205566f, -0.00131883f, 0.00334378f, 
    -0.04933456f, 0.01822210f, -0.05059256f, 0.01140030f, -0.03268176f, -0.05035657f, -0.02452647f, -0.04223164f, 
    -0.04497348f, 0.03772024f, 0.00034088f, -0.06043301f, -0.01212712f, 0.03838108f, -0.05826250f, 0.05044923f, 
    -0.01572998f, 0.04951886f, -0.03683514f, 0.00266230f, 0.00213229f, -0.03650254f, 0.06163543f, -0.01886825f, 
    -0.03744618f, -0.05690953f, -0.01208549f, -0.02410434f, -0.01022850f, -0.04453163f, -0.04573120f, -0.06059964f, 
    0.02479627f, -0.02449839f, 0.00319524f, -0.01479120f, 0.02366570f, 0.01699925f, 0.01456929f, 0.01803572f, 
    -0.01742597f, 0.00135813f, 0.02518084f, -0.01824848f, -0.01469463f, 0.01585644f, -0.00534502f, 0.03621425f, 
    -0.00272445f, 0.02809457f, 0.01500868f, -0.00876780f, 0.03414632f, 0.04413809f, 0.04140946f, 0.03650938f, 
    -0.01897851f, 0.03495216f, 0.06336161f, -0.00020852f, -0.03506826f, -0.02078263f, -0.04930937f, 0.00819504f, 
    0.00820535f, -0.04329399f, 0.00767836f, -0.03428612f, -0.00320154f, 0.01390298f, 0.01778439f, -0.03604912f, 
    -0.04769173f, -0.02488252f, -0.00407735f, 0.01346687f, -0.02955010f, -0.01957871f, -0.01007215f, -0.02160595f, 
    -0.00893582f, -0.03237640f, 0.03804901f, 0.01827322f, -0.02207836f, 0.01015146f, -0.05584626f, 0.03904258f, 
    -0.04644739f, 0.00301025f, -0.05310209f, -0.01862601f, 0.02263021f, 0.04474615f, -0.02330194f, 0.03922317f, 
    -0.01658573f, -0.03888971f, -0.06535018f, -0.06008547f, -0.06149319f, -0.04694312f, 0.00055560f, -0.00404901f, 
    0.04262130f, -0.06375194f, 0.04668290f, -0.02675476f, 0.01270721f, -0.04653537f, 0.01542025f, 0.02744518f, 
    -0.00902226f, -0.00046201f, -0.01100312f, -0.05753589f, 0.04965554f, 0.00983557f, 0.00701713f, 0.01297912f, 
    0.03033033f, 0.04475291f, -0.05916335f, -0.02075151f, 0.03586991f, -0.02879388f, -0.02599047f, 0.01352734f, 
    -0.05960648f, -0.02477198f, 0.01786151f, -0.00776483f, 0.04449359f, 0.01745239f, -0.02430402f, 0.04604314f, 
    0.02389176f, 0.02736009f, -0.04356957f, 0.02093452f, -0.01238082f, -0.00391606f, 0.00411511f, 0.00689870f, 
    -0.04886158f, -0.04572610f, -0.00752854f, -0.05123280f, -0.04915436f, 0.03882175f, -0.05040473f, -0.03967790f, 
    -0.04913769f, 0.04812824f, -0.06390662f, -0.03209105f, -0.01748927f, 0.03992844f, 0.03624775f, -0.01180434f, 
    -0.03122867f, 0.01124086f, -0.06141725f, -0.00462795f, 0.05036391f, 0.00661154f, 0.03382513f, -0.04965288f, 
    0.04877884f, -0.03851925f, -0.04490413f, 0.02860353f, -0.05856467f, 0.02247004f, -0.04271714f, -0.06509347f, 
    -0.00213818f, -0.00625492f, -0.03484640f, -0.04492246f, 0.03820175f, -0.06510536f, -0.03974874f, -0.05272511f, 
    0.02308337f, -0.00270850f, 0.04216830f, -0.06489063f, -0.00483986f, 0.00491196f, -0.00357267f, 0.03979788f, 
    0.03437215f, -0.01473082f, 0.01594439f, 0.01645485f, 0.04404335f, -0.00411008f, 0.01064636f, 0.03576344f, 
    -0.04784668f, -0.04601274f, -0.00808890f, 0.04341608f, -0.05287404f, 0.00974586f, -0.03663035f, -0.05648374f, 
    -0.01540943f, 0.01257308f, -0.05735793f, 0.00960934f, -0.00924209f, -0.02451494f, -0.02403140f, 0.00210898f, 
    0.03119717f, -0.04629959f, -0.02387508f, 0.00336877f, 0.04733853f, -0.02793207f, -0.04221016f, -0.03599454f, 
    -0.04016303f, -0.03764756f, -0.06058260f, -0.04680927f, -0.05424723f, -0.03180478f, 0.01099362f, -0.03971498f, 
    -0.05220262f, -0.04112839f, 0.00512721f, 0.01013028f, -0.05986061f, -0.01274801f, 0.03222362f, 0.00995039f, 
    -0.00496705f, -0.03086741f, 0.04675663f, 0.03105722f, -0.03045968f, 0.02232884f, 0.04107925f, -0.02145036f, 
    -0.05543455f, 0.04482499f, -0.03243202f, -0.00848341f, -0.03554887f, 0.04756082f, 0.03734330f, 0.01905676f, 
    0.04396715f, -0.01680671f, 0.03453833f, 0.00928884f, 0.02203668f, 0.02968985f, -0.04202383f, -0.00612118f, 
    -0.05488426f, -0.04277937f, 0.03744495f, -0.03148445f, 0.02616754f, 0.04522882f, 0.00383658f, -0.04958832f, 
    0.02987334f, -0.03355631f, -0.05180568f, 0.00603439f, -0.01088551f, -0.06055020f, 0.00786526f, 0.01312030f, 
    0.03761137f, 0.03259047f, -0.00702156f, -0.01392202f, -0.04039024f, -0.01617131f, -0.00028911f, 0.00265850f, 
    0.03036742f, 0.03745655f, -0.04229058f, -0.03574935f, -0.00193487f, 0.03921573f, 0.01384479f, -0.05489029f, 
    0.02385997f, 0.03169171f, -0.03139332f, -0.03258153f, 0.02778812f, -0.05483496f, 0.00864575f, -0.05341965f, 
    -0.03370200f, 0.03280438f, 0.01714991f, -0.00219709f, -0.02693238f, -0.00798697f, 0.02256047f, -0.04453798f, 
    0.01961545f, -0.03505552f, 0.02032983f, -0.01298532f, 0.04107505f, -0.01868786f, -0.01169921f, 0.03448301f, 
    -0.02996225f, -0.05586018f, -0.02755024f, -0.02540582f, -0.02953754f, -0.00519757f, 0.01861065f, 0.03959806f, 
    -0.03747528f, 0.00876821f, -0.04388766f, 0.02237697f, -0.06569286f, -0.03480778f, 0.01980248f, -0.06534833f, 
    0.04100894f, -0.00984771f, 0.00099544f, -0.04618290f, -0.01916666f, 0.02055018f, 0.04595622f, -0.00921543f, 
    -0.02519292f, 0.03021466f, 0.01203070f, 0.01574774f, -0.04296699f, 0.02405587f, -0.00212287f, -0.02778124f, 
    0.04560034f, 0.04253713f, 0.02299680f, 0.02528430f, -0.01707222f, 0.01350699f, -0.00994323f, 0.02756927f, 
    0.02768634f, 0.05106120f, 0.02222650f, 0.04841374f, 0.02775455f, -0.00857511f, -0.00436459f, 0.00851672f, 
    0.03030068f, 0.04824729f, 0.02498127f, -0.05549053f, 0.02902705f, 0.03992606f, 0.02528172f, 0.02287445f, 
    -0.05189485f, -0.03389193f, 0.05425948f, -0.00124270f, -0.01958171f, -0.01072137f, -0.05145405f, 0.03561851f, 
    0.05800238f, -0.03945899f, -0.02059253f, 0.01407013f, -0.00923150f, -0.00295581f, 0.03125701f, 0.01652130f, 
    0.01381087f, -0.06135612f, 0.05745731f, 0.01871430f, 0.02173572f, 0.01957108f, -0.02014058f, 0.02896010f, 
    0.01560637f, 0.01499257f, -0.05634165f, 0.04717603f, 0.05155784f, 0.04998464f, 0.01315331f, 0.04269075f, 
    0.01818052f, -0.04149726f, 0.05356976f, -0.05808380f, 0.05303476f, 0.05464844f, 0.03045345f, 0.03233666f, 
    -0.00725232f, -0.03734925f, 0.01087981f, 0.01463714f, -0.05541877f, 0.00487146f, -0.01180562f, 0.00066375f, 
    -0.01572361f, -0.05528900f, -0.06324934f, 0.01266770f, -0.01541519f, -0.03570141f, -0.03699913f, -0.05114866f, 
    -0.05712173f, -0.03442870f, -0.01261088f, 0.04435559f, -0.05395260f, -0.02053056f, 0.01316274f, 0.02350259f, 
    0.03447752f, 0.01298063f, -0.05855598f, -0.01591052f, -0.04310067f, -0.05639606f, 0.01490427f, -0.00369932f, 
    0.00261831f, -0.05036466f, -0.05188634f, 0.03057040f, -0.04486599f, -0.05694767f, 0.05824635f, 0.03204174f, 
    -0.02181659f, 0.02856537f, 0.02997797f, 0.05388479f, 0.04953975f, -0.01568353f, -0.05993454f, -0.03716667f, 
    -0.00029017f, -0.05184365f, -0.04939272f, 0.04898180f, -0.03766262f, 0.02798376f, -0.01857169f, -0.06703080f, 
    -0.01269226f, -0.05777847f, -0.03809852f, 0.05408297f, -0.05794258f, 0.05680799f, -0.03757071f, 0.02354715f, 
    -0.01519095f, -0.03948091f, 0.04262645f, 0.03588768f, -0.05693762f, 0.02209220f, 0.01169622f, -0.05357883f, 
    -0.01070543f, -0.04898212f, -0.04756510f, 0.00290415f, -0.03974272f, 0.02572158f, -0.03260166f, -0.02678716f, 
    0.02317605f, -0.00448242f, 0.04004110f, -0.02898966f, -0.02011553f, -0.00280896f, -0.03823137f, 0.04134014f, 
    -0.06615525f, -0.03693610f, 0.03417989f, -0.02795000f, 0.00744899f, -0.05939677f, 0.02634053f, -0.04927750f, 
    -0.04752411f, -0.05063448f, -0.04561613f, -0.04185005f, -0.03368107f, 0.02603853f, -0.01282159f, -0.03951544f, 
    -0.03266896f, 0.00570021f, -0.03990220f, 0.00678457f, 0.02427837f, -0.00654630f, -0.04257195f, -0.03681776f, 
    -0.05700803f, 0.00378270f, 0.01994441f, 0.05592072f, -0.02480564f, 0.03448765f, -0.02559245f, -0.02939148f, 
    -0.05441773f, -0.03353928f, -0.03926123f, 0.03150906f, 0.04557097f, -0.02279491f, 0.02817893f, -0.04481601f, 
    -0.01461839f, -0.05187665f, -0.04709595f, -0.03265478f, 0.03746392f, 0.04635893f, -0.00118053f, 0.03868955f, 
    -0.01159945f, -0.03009285f, -0.06112815f, 0.03754100f, 0.01980870f, -0.05722108f, -0.02759402f, -0.02391146f, 
    0.03960849f, 0.00158118f, -0.03089016f, -0.01811340f, 0.01479893f, 0.00958336f, -0.03909871f, -0.06436556f, 
    -0.03032401f, 0.04076153f, -0.02816429f, 0.00147973f, -0.03568216f, 0.03760668f, -0.05022097f, -0.03535100f, 
    -0.03302550f, -0.01313782f, -0.03612977f, -0.03096952f, 0.01051439f, -0.00607500f, -0.03251370f, -0.01640999f, 
    0.02179261f, -0.01608972f, 0.01037978f, 0.04098861f, 0.01183523f, -0.04404566f, 0.04871967f, 0.02679813f, 
    0.03000286f, -0.01616582f, 0.02010914f, -0.00011018f, 0.02061093f, 0.03072906f, -0.04809819f, 0.01502201f, 
    0.05362593f, 0.04596981f, 0.03993803f, 0.02038899f, -0.04746386f, -0.03121062f, 0.03838350f, -0.05531853f, 
    -0.06066867f, -0.04374833f, 0.03350574f, 0.01313249f, -0.02291355f, -0.04755526f, -0.02712361f, 0.05160281f, 
    -0.02952277f, -0.06491288f, 0.04020452f, -0.03333220f, -0.05371925f, -0.01473679f, -0.04984556f, 0.04163155f, 
    0.04959797f, 0.02211832f, -0.01473242f, 0.02592948f, -0.00744531f, 0.04043412f, -0.05366688f, -0.00165227f, 
    -0.04927104f, -0.00157336f, 0.02590944f, -0.01639093f, 0.00903039f, 0.03798591f, 0.01157911f, -0.03152820f, 
    0.27657717f, 0.02022150f, 0.03165979f, -0.06599274f, -0.05464237f, 0.09021722f, 0.04074325f, -0.03353362f, 
    0.18070416f, -0.11891343f, 0.14622936f, -0.16508469f, 0.05546682f, -0.00777148f, 0.04790865f, -0.01266687f, 
    0.11287068f, -0.07428095f, -0.02562990f, 0.18885319f, -0.06112823f, 0.07730285f, -0.00802765f, -0.15884829f, 
    0.03781015f, 0.15477683f, -0.00373918f, 0.06059634f, -0.05016511f, -0.14331654f, 0.07792713f, 0.06548280f, 
    -0.03309871f, 0.02188934f, -0.05003877f, 0.11536150f, -0.16969749f, -0.11295675f, 0.21090882f, -0.12919644f, 
    -0.01849279f, 0.02962252f, 0.09422132f, -0.03245310f, -0.05543386f, 0.01873947f, 0.01988224f, -0.16287027f, 
    0.02443193f, -0.07925168f, -0.18677212f, 0.01691467f, -0.02249677f, 0.02707773f, 0.10859390f, -0.00362701f, 
    0.10333483f, -0.11491244f, -0.04568122f, -0.03617241f, -0.03150539f, -0.01132487f, 0.06725744f, -0.14648224f, 
    0.06373069f, 0.13918424f, 0.03796582f, -0.04885931f, -0.01290259f, 0.04147097f, -0.00888845f, -0.12069644f, 
    0.10409341f, 0.00615285f, 0.01802929f, -0.02950743f, 0.02700940f, 0.03774406f, -0.00413722f, -0.03473119f, 
    0.04525466f, 0.07871815f, 0.25270313f, 0.01515235f, -0.13614081f, -0.12243028f, 0.17862441f, 0.01648975f, 
    0.07648842f, 0.01481819f, -0.02483767f, 0.02227267f, 0.03912371f, 0.00184614f, -0.08140793f, 0.01600447f, 
    0.06022589f, -0.06279692f, 0.00398572f, -0.01849296f, -0.06293420f, -0.15394159f, -0.08089896f, 0.09489305f, 
    0.05674840f, -0.09699250f, 0.07146426f, -0.04136809f, -0.11276516f, 0.03259442f, -0.11510425f, -0.01697308f, 
    -0.08055492f, -0.07043929f, -0.03661949f, -0.08486909f, 0.18734992f, 0.15705998f, -0.02832954f, -0.04100334f, 
    -0.01774305f, 0.02640261f, -0.00737413f, 0.07663289f, 0.11861826f, -0.00783506f, -0.25645810f, -0.16321884f, 
    -0.39375776f, 0.09876171f, 0.06168584f, -0.05892521f, 0.05595070f, 0.02567834f, 0.06106320f, -0.15392284f, 
    -0.05909627f, -0.12645392f, 0.06793604f, -0.04754866f, -0.00063967f, 0.08215150f, -0.00262168f, 0.07256655f, 
    -0.11598718f, 0.00592019f, 0.09625139f, -0.02801451f, 0.04449734f, 0.06691614f, 0.01192081f, 0.03923388f, 
    -0.13064399f, 0.04077010f, -0.14520758f, 0.00453850f, 0.12402967f, 0.06752746f, -0.07506365f, 0.15482371f, 
    -0.04184656f, -0.03465486f, 0.24660043f, 0.26261845f, -0.10285798f, 0.22881937f, -0.10934956f, -0.28127888f, 
    -0.14672391f, -0.06192427f, 0.03438950f, 0.19626391f, -0.03418006f, 0.19972236f, 0.01446473f, 0.03671998f, 
    0.02632318f, -0.10045281f, 0.18379764f, -0.16093113f, -0.41376254f, 0.12740491f, -0.00295142f, -0.12763110f, 
    0.04035408f, -0.01922344f, 0.00868537f, 0.01453852f, -0.16300073f, 0.10421040f, -0.11490113f, -0.12443353f, 
    -0.04444729f, -0.08852553f, 0.03399987f, 0.03059090f, -0.10505299f, -0.02133052f, -0.18359245f, 0.12590922f, 
    0.23313083f, -0.03482985f, -0.08501784f, 0.03273029f, -0.06545743f, 0.07576146f, -0.13950844f, -0.12155939f, 
    -0.18797840f, -0.16010197f, 0.05805361f, -0.11022181f, 0.06193902f, 0.03636869f, -0.01254595f, -0.07807834f, 
    -0.20243366f, 0.25956091f, -0.04839068f, 0.06064054f, 0.07588539f, -0.03644146f, -0.00629473f, 0.11285625f, 
    0.00710513f, 0.01983020f, 0.05097972f, -0.24857432f, 0.10296121f, 0.16205473f, 0.08150924f, 0.05055249f, 
    0.05296994f, 0.01246463f, 0.11652585f, 0.12543571f, -0.00524537f, 0.09358878f, -0.02878776f, 0.00041041f, 
    0.02443575f, 0.00341629f, 0.03796080f, 0.21578231f, -0.15813588f, 0.07496323f, -0.07061289f, 0.06902175f, 
    0.02634715f, 0.06398297f, 0.13891722f, 0.16534807f, 0.01776133f, 0.06211732f, 0.26579142f, -0.06870817f, 
    -0.10917920f, -0.07230410f, -0.04083483f, -0.12471890f, 0.06857044f, -0.04964333f, 0.11966489f, -0.10910626f, 
    -0.04844531f, 0.07972313f, -0.17698193f, -0.18454435f, 0.00056698f, -0.02271802f, 0.07084858f, 0.09989835f, 
    -0.09443191f, 0.06882409f, 0.07685178f, 0.05822232f, -0.05265824f, 0.06521978f, 0.06498431f, 0.32278991f, 
    -0.06189496f, -0.24027781f, -0.02647835f, 0.21554428f, 0.06040914f, 0.07018563f, -0.00843835f, -0.09054163f, 
    0.01718510f, -0.04844901f, -0.00044411f, -0.01132770f, -0.03656697f, -0.04549218f, -0.06747787f, -0.05498874f, 
    0.02542381f, 0.03975781f, -0.03986381f, -0.09378699f, -0.01836652f, -0.03666990f, -0.06377935f, -0.03992922f, 
    -0.06007062f, -0.05612079f, -0.09066825f, -0.03275358f, -0.03128745f, 0.01698183f, -0.03914643f, -0.04508182f, 
    -0.03652406f, -0.05108447f, -0.00821482f, -0.04996318f, 0.03289929f, -0.04440108f, -0.00113669f, -0.04653653f, 
    -0.03585507f, -0.06179953f, -0.07788824f, -0.04824901f, -0.00228573f, -0.00025756f, -0.04769128f, 0.01315227f, 
    -0.05983409f, 0.01552169f, 0.01728522f, 0.02772347f, 0.02861215f, 0.04695602f, -0.03722704f, -0.05917623f, 
    -0.09008510f, -0.03840058f, -0.05817383f, -0.06572628f, 0.02382303f, 0.00595474f, -0.04261088f, -0.00463921f, 
    0.01207638f, 0.00451270f, -0.00955066f, -0.07345492f, -0.03100757f, 0.00918079f, -0.05084387f, -0.04964050f, 
    -0.07047585f, -0.02064134f, -0.02588202f, -0.09334265f, 0.01845917f, -0.00146720f, -0.03348781f, 0.00747173f, 
    0.01358886f, 0.00376761f, -0.03955727f, 0.00409647f, -0.00692043f, -0.01588834f, -0.02873507f, -0.00918311f, 
    -0.01495161f, -0.02288743f, -0.02613880f, 0.02924728f, -0.01109681f, 0.01890453f, 0.00812068f, -0.00185457f, 
    -0.05587040f, -0.03845473f, -0.05828852f, 0.01956559f, 0.01933929f, -0.04427769f, -0.07840052f, -0.01817395f, 
    -0.07372531f, 0.01016411f, -0.03648126f, -0.02496599f, 0.02888294f, -0.06347408f, -0.07575329f, -0.08338980f, 
    -0.08991489f, -0.11163859f, -0.03087893f, -0.05109525f, 0.02088526f, -0.05083188f, -0.07825553f, -0.06557231f, 
    -0.08884718f, -0.07393257f, 0.01678992f, -0.02576868f, -0.02884659f, -0.00249810f, -0.08315040f, 0.00798555f, 
    0.00418424f, -0.01650839f, -0.08837266f, -0.03099831f, 0.02642387f, -0.02447850f, 0.01885200f, 0.02666161f, 
    -0.05017086f, -0.03656979f, -0.07411331f, -0.03101157f, -0.00491088f, -0.07806973f, -0.06247774f, -0.07916441f, 
    0.01084815f, -0.03443757f, -0.07787132f, 0.02350763f, 0.01080177f, -0.07528726f, -0.02335526f, 0.03642629f, 
    0.01774178f, -0.07645810f, -0.05113393f, -0.08793218f, -0.07138099f, -0.03408276f, 0.00662946f, -0.03919955f, 
    -0.04511607f, 0.03869656f, -0.03724425f, -0.08673133f, 0.01574569f, 0.00553297f, -0.01513484f, -0.08694878f, 
    -0.04904167f, -0.05658866f, -0.05438927f, 0.03160151f, -0.02501447f, -0.00188980f, -0.04021804f, -0.04158365f, 
    0.02313549f, -0.06406511f, 0.02725797f, -0.00281933f, -0.05580783f, 0.01449239f, -0.04610579f, 0.00064924f, 
    -0.02639092f, -0.05320807f, -0.05642406f, 0.02403929f, -0.01172215f, 0.03439731f, -0.08061951f, -0.05786390f, 
    -0.02346718f, -0.00701701f, -0.09093052f, -0.07270271f, -0.05692838f, 0.01171179f, 0.03132527f, -0.04124337f, 
    -0.07421827f, -0.05517717f, 0.01699688f, -0.06699370f, -0.04452837f, -0.00944439f, -0.02214657f, -0.00269588f, 
    -0.07856559f, -0.00638086f, -0.06512641f, -0.06516920f, 0.02098857f, -0.09420360f, 0.02457031f, 0.01569861f, 
    -0.03670705f, -0.05387639f, -0.01257957f, -0.04483609f, 0.02135534f, -0.07498371f, 0.02940504f, 0.02011055f, 
    -0.00339028f, -0.02167287f, -0.03203848f, -0.07723540f, -0.05512907f, -0.06591880f, -0.03448410f, 0.02012612f, 
    -0.02147775f, 0.03681976f, -0.00115435f, -0.03581905f, -0.03166358f, -0.02903212f, -0.07920836f, 0.00289300f, 
    -0.02877334f, 0.01053974f, 0.02365064f, -0.01019574f, -0.00023162f, -0.01503812f, 0.00500833f, -0.01579836f, 
    0.03306297f, -0.04513774f, -0.02163817f, -0.04225648f, -0.04846581f, -0.01368697f, -0.03076417f, -0.08894520f, 
    -0.00664116f, -0.07985629f, 0.02507262f, -0.03713509f, -0.06915835f, 0.01782122f, -0.06281950f, 0.00416921f, 
    -0.00083778f, 0.00597923f, -0.05376782f, -0.07729291f, -0.02280350f, 0.03314369f, -0.05716763f, 0.00108354f, 
    -0.02251700f, -0.03961539f, -0.05016786f, -0.06196501f, -0.06861277f, 0.02401076f, 0.00098849f, 0.00292811f, 
    -0.01848209f, 0.02692400f, -0.02811422f, -0.08063404f, -0.02714005f, -0.08127143f, 0.02210274f, -0.00963358f, 
    -0.00661044f, -0.00911671f, 0.01507895f, 0.01958063f, 0.03314984f, -0.02036684f, -0.04033585f, -0.05485417f, 
    0.23117971f, 0.05890908f, 0.01142752f, 0.01170836f, -0.05387950f, 0.12725066f, 0.01382617f, 0.03958162f, 
    0.06755122f, -0.26788583f, -0.02215328f, -0.18697640f, 0.06263576f, 0.04967536f, 0.19478543f, -0.28570011f, 
    0.09831879f, -0.03389159f, 0.07566386f, 0.06131937f, 0.07398363f, 0.05311007f, -0.09991802f, -0.11175337f, 
    -0.05554317f, -0.02518869f, -0.10806616f, 0.05997040f, 0.08313789f, 0.04053691f, -0.02311669f, -0.10527256f, 
    0.06911004f, 0.10473685f, -0.01278273f, 0.03683162f, -0.26026949f, -0.47228247f, -0.12098309f, -0.00535078f, 
    0.05074271f, -0.14475656f, 0.03904236f, -0.09961988f, 0.03876278f, -0.27653140f, -0.47701386f, -0.07997208f, 
    -0.10627338f, -0.02828800f, -0.09831331f, -0.04237654f, 0.00363679f, -0.01370170f, 0.05640413f, -0.03550401f, 
    0.04034887f, -0.12018217f, -0.15851820f, -0.09975723f, 0.13382031f, -0.01911200f, 0.00054107f, -0.39262187f, 
    0.07895055f, -0.22822869f, -0.06543310f, 0.02472980f, -0.20009822f, 0.05814752f, -0.13378069f, 0.03080723f, 
    -0.30483761f, -0.16781524f, -0.21371388f, -0.03523732f, 0.08959904f, 0.00433992f, 0.03219399f, -0.06356251f, 
    -0.03215870f, 0.01842339f, -0.26906949f, -0.13152486f, -0.04267417f, -0.07465954f, -0.01315727f, 0.02319454f, 
    -0.03667296f, -0.02468729f, -0.06043519f, 0.05323156f, 0.08841591f, 0.05657620f, 0.03192353f, 0.09463495f, 
    0.16228670f, -0.08983887f, 0.03593770f, 0.06555068f, 0.04133518f, 0.10133664f, 0.05980729f, 0.02060008f, 
    0.15958463f, -0.03647950f, -0.06418230f, -0.06309515f, -0.34074169f, -0.04778715f, -0.00184404f, 0.09672813f, 
    -0.09486442f, 0.08728594f, -0.01149185f, 0.06342532f, -0.05029481f, 0.15092146f, -0.00382937f, 0.15368466f, 
    -0.00994854f, -0.16383682f, -0.06825361f, 0.05366521f, -0.07898261f, 0.06898062f, -0.08047655f, -0.17860766f, 
    0.08407512f, 0.16818477f, 0.06031375f, -0.03064053f, -0.05426660f, -0.00231076f, 0.06440102f, -0.39779961f, 
    -0.02467946f, -0.01555984f, 0.17826770f, -0.05429177f, 0.08026908f, 0.05146549f, -0.03933107f, 0.13755929f, 
    -0.21070467f, 0.19182818f, -0.18436196f, -0.02840530f, -0.00365728f, 0.00204137f, 0.12117215f, -0.06075114f, 
    -0.13213846f, 0.14575545f, 0.16899098f, 0.17668043f, 0.16022532f, 0.03200811f, 0.18241850f, 0.14985028f, 
    0.05934202f, -0.00949960f, 0.28967983f, 0.06775318f, -0.13606855f, 0.12154368f, -0.00228770f, 0.13026862f, 
    -0.02297572f, 0.07664275f, -0.12364705f, 0.03686591f, -0.04817301f, -0.06881025f, 0.01978054f, -0.15961641f, 
    0.07029880f, 0.15041502f, 0.02525244f, -0.05882767f, -0.21674646f, 0.02645100f, -0.09690893f, 0.01519753f, 
    0.15293668f, -0.09545080f, 0.02636684f, -0.09460931f, -0.04946233f, -0.14364462f, -0.45374241f, -0.11106794f, 
    -0.02669405f, -0.05584151f, -0.06396952f, 0.07680816f, 0.05207482f, -0.03793313f, 0.00711437f, -0.08923718f, 
    -0.12539913f, -0.08028920f, 0.05375155f, 0.04781098f, 0.04071282f, -0.02038151f, 0.04003257f, -0.06531807f, 
    -0.02688190f, -0.09172677f, 0.06877349f, 0.08365016f, 0.15646087f, 0.01267072f, 0.13934137f, 0.08497134f, 
    -0.00715898f, -0.07022284f, -0.07040514f, 0.06673019f, 0.15167400f, 0.12063868f, -0.06650832f, -0.16632411f, 
    0.10099646f, 0.15166377f, -0.13148993f, 0.00617049f, -0.00445440f, 0.20027895f, -0.11567990f, -0.02047321f, 
    -0.02162421f, -0.02067137f, 0.10089252f, -0.01452951f, -0.02260417f, 0.01217823f, 0.04881033f, 0.03926417f, 
    -0.15593864f, 0.19686098f, 0.02661757f, 0.20535485f, 0.13068187f, 0.13571815f, -0.00437146f, 0.01255682f, 
    0.07010315f, 0.05621764f, 0.06387850f, 0.06980935f, -0.14248268f, -0.14312810f, 0.10944925f, -0.09577104f, 
    -0.03129732f, -0.15345675f, -0.01356189f, 0.17975362f, -0.01687806f, -0.07479934f, -0.21714172f, -0.03533992f, 
    -0.10815816f, 0.02653540f, -0.23208874f, -0.09292786f, -0.02663091f, 0.12528832f, 0.23124911f, 0.29105240f, 
    0.22403021f, -0.09997944f, -0.01136089f, 0.04461044f, 0.07867014f, 0.12771276f, 0.07798339f, 0.18667068f, 
    0.19792977f, 0.26033399f, -0.03436480f, 0.08638646f, -0.17827658f, -0.16373795f, -0.06972742f, 0.04040705f, 
    -0.32006487f, 0.06106976f, 0.07773110f, -0.00764455f, 0.05864378f, 0.01263675f, 0.02101411f, 0.12966949f, 
    0.00457278f, -0.00236272f, -0.11910826f, -0.22823344f, -0.01620106f, 0.11265627f, 0.17817980f, -0.12915534f, 
    -0.00777253f, -0.00641266f, -0.05288015f, -0.26035872f, -0.19625047f, 0.02080060f, -0.02240367f, -0.02583017f, 
    -0.11186212f, -0.09104526f, 0.03832783f, 0.08278688f, 0.04133244f, -0.03544367f, 0.02850123f, 0.00047253f, 
    0.25052446f, -0.01707454f, -0.15055096f, 0.02529602f, 0.11787134f, 0.06768360f, -0.14196792f, -0.07273643f, 
    -0.06422853f, 0.03054254f, 0.04569725f, -0.02091886f, -0.08165358f, 0.25747961f, -0.08345310f, -0.12998444f, 
    0.05321781f, 0.14190286f, -0.12172666f, 0.05299485f, 0.07719584f, -0.18248169f, -0.12417476f, 0.04945274f, 
    0.00806784f, 0.06374025f, 0.09712163f, -0.25944838f, 0.10460070f, -0.06589373f, 0.02265341f, 0.07748167f, 
    -0.01421554f, -0.04059453f, 0.14747472f, -0.05717677f, 0.05461490f, 0.04552580f, 0.04812345f, -0.01638534f, 
    0.22205772f, 0.06060410f, 0.04773097f, -0.02520988f, -0.01574662f, 0.01763112f, 0.04730970f, 0.01631310f, 
    -0.10056368f, 0.04795963f, 0.28456014f, 0.13662066f, -0.21224518f, -0.07025538f, -0.19322045f, 0.05394760f, 
    0.17183720f, 0.06078560f, -0.11158359f, -0.11660807f, -0.09556404f, 0.04585834f, 0.03358003f, 0.02672789f, 
    0.01897102f, -0.04798356f, 0.01392690f, 0.07327466f, 0.02657047f, -0.13232549f, -0.04159855f, -0.02875167f, 
    -0.20200115f, -0.13877648f, -0.03334311f, 0.19321428f, -0.04363035f, -0.05570542f, 0.01571870f, -0.06554941f, 
    -0.10346606f, 0.07399996f, 0.07082814f, -0.02217063f, 0.16431476f, -0.11693559f, -0.12299241f, -0.06115887f, 
    0.01740624f, 0.09076423f, -0.06131290f, -0.01673656f, 0.19222872f, 0.19105686f, 0.08977033f, -0.16836654f, 
    -0.25549987f, 0.08719209f, 0.14967383f, 0.13528286f, 0.09028915f, -0.08557356f, -0.06344281f, -0.05443351f, 
    -0.13747580f, -0.15350388f, 0.19677350f, -0.03741316f, -0.00404419f, -0.01642305f, -0.04126133f, -0.12192526f, 
    -0.03705085f, 0.15281525f, -0.09364957f, -0.02990594f, 0.04234004f, -0.02141812f, -0.07563315f, 0.14849608f, 
    -0.04943897f, 0.20758505f, 0.02952894f, -0.08645935f, 0.00294806f, 0.03381182f, 0.14008039f, -0.11660069f, 
    -0.02660121f, -0.07067590f, -0.20532058f, -0.00260518f, -0.10089604f, -0.07747787f, -0.20423102f, -0.06798329f, 
    0.01893697f, 0.13883896f, 0.12316235f, 0.05419707f, 0.15980422f, 0.00959855f, 0.02528939f, -0.05367439f, 
    -0.03258618f, 0.11166542f, 0.05967810f, 0.06222449f, 0.17291833f, 0.06239553f, -0.22463520f, -0.19560586f, 
    -0.02318518f, -0.00042108f, 0.13668372f, 0.05048113f, -0.09753014f, 0.10779399f, 0.00996173f, -0.01721843f, 
    -0.12006384f, -0.10350890f, 0.03818579f, 0.01842346f, 0.08217304f, -0.17607798f, -0.08612004f, -0.13051830f, 
    0.24252237f, 0.02606175f, -0.04396179f, 0.14073244f, 0.03106434f, -0.01903551f, -0.10860668f, 0.10390732f, 
    -0.03068903f, -0.02076186f, 0.00616551f, 0.01778347f, 0.30903810f, -0.04187664f, 0.01794010f, -0.21838726f, 
    -0.02428925f, -0.09208289f, -0.05122309f, 0.01888652f, 0.05191009f, 0.11111303f, 0.11370850f, -0.05847953f, 
    -0.14016078f, -0.16286263f, -0.27371436f, 0.07387261f, 0.09977747f, -0.02628561f, 0.06314065f, 0.08351547f, 
    -0.04985965f, -0.02943429f, 0.02688008f, -0.08320158f, -0.10986172f, -0.03280513f, 0.06727213f, 0.16101508f, 
    -0.03863563f, -0.04984983f, 0.17276925f, 0.00469523f, 0.15345646f, -0.03456428f, 0.09224352f, -0.12296772f, 
    0.07896457f, 0.02779278f, 0.00027618f, 0.23192587f, -0.02491051f, 0.02125283f, 0.10054825f, -0.04492498f, 
    -0.09239872f, 0.00799635f, 0.00679678f, 0.06579622f, 0.02570646f, -0.16865246f, -0.04758821f, 0.25086021f, 
    0.03075524f, -0.14414494f, -0.05979804f, 0.18111466f, 0.04326771f, 0.01013745f, -0.06180488f, 0.03709181f, 
    -0.01511364f, 0.12380543f, -0.04083118f, -0.01812777f, -0.11312465f, -0.01637067f, 0.09170725f, -0.09458641f, 
    -0.13474570f, -0.23213221f, -0.05847974f, 0.00174874f, -0.01467661f, -0.07075898f, 0.08140289f, -0.00806363f, 
    -0.06236618f, 0.02792527f, -0.05595995f, -0.04910871f, -0.03581140f, -0.04805621f, -0.00621825f, 0.03789443f, 
    -0.02967399f, 0.02971727f, 0.02829605f, -0.06276325f, -0.04919243f, -0.02286050f, 0.02457812f, 0.02669955f, 
    -0.04170050f, 0.01805114f, 0.03059352f, 0.04211565f, 0.00075434f, 0.02865053f, -0.02650947f, -0.02844354f, 
    0.01958465f, 0.02437225f, 0.03184143f, -0.05796353f, -0.06049373f, 0.03043491f, -0.02856902f, -0.01078782f, 
    -0.00756938f, 0.03075543f, 0.01073702f, 0.00999935f, 0.02609029f, 0.04760063f, 0.04850593f, 0.03480934f, 
    -0.05875795f, 0.00345450f, -0.01427088f, 0.02349567f, -0.02913550f, -0.03339171f, 0.01128554f, -0.03685387f, 
    -0.01121239f, -0.05957090f, 0.05510194f, 0.01759757f, -0.05248688f, -0.02701639f, 0.00552323f, -0.05823217f, 
    -0.06225778f, -0.05133174f, 0.04032794f, -0.06056473f, -0.00533041f, -0.05783509f, -0.02521405f, 0.03486308f, 
    -0.05592178f, -0.04639504f, -0.03591655f, -0.02548913f, -0.01138379f, 0.05056598f, 0.00209332f, -0.04401707f, 
    -0.04530550f, -0.04999681f, -0.05824559f, 0.00809865f, -0.04508908f, -0.01687027f, 0.00788062f, 0.03696401f, 
    0.04069894f, 0.00696974f, -0.04944349f, 0.03391052f, 0.02987903f, 0.00445377f, 0.03521062f, 0.01878407f, 
    -0.05234148f, -0.01276394f, -0.00477342f, 0.00072703f, -0.04897148f, -0.00530600f, 0.00669609f, 0.00654513f, 
    0.02938758f, -0.03571982f, 0.02887129f, -0.04732487f, 0.04690505f, 0.02427722f, 0.04066188f, 0.04653293f, 
    -0.03954170f, -0.00739825f, 0.01973669f, -0.01303567f, 0.04449045f, 0.02997052f, 0.04950147f, 0.04331162f, 
    -0.04116599f, 0.01549162f, -0.03772782f, 0.03175989f, -0.02888826f, 0.02783764f, 0.00442967f, 0.00707480f, 
    -0.00828860f, 0.03552822f, -0.04373022f, -0.02686283f, -0.05636116f, -0.03695327f, 0.03201683f, -0.05221378f, 
    0.00324682f, 0.03797805f, -0.03133674f, -0.03739892f, -0.00544249f, 0.02267650f, -0.02572005f, 0.01759322f, 
    0.02218079f, 0.01793466f, 0.05126915f, 0.02023532f, 0.04693817f, 0.00689445f, -0.04648413f, -0.01993035f, 
    0.00668924f, 0.04299144f, -0.03346189f, 0.00226355f, 0.03814010f, -0.05654937f, -0.00179027f, -0.00332168f, 
    0.03535875f, -0.04314534f, -0.03899249f, -0.01242141f, -0.01142511f, -0.03040961f, -0.04649230f, -0.00008776f, 
    -0.02718871f, 0.04991309f, -0.00417846f, 0.03561673f, -0.01578466f, -0.04236433f, 0.03462394f, -0.03004067f, 
    0.04295730f, -0.03628339f, -0.06155162f, -0.05390319f, -0.05552356f, -0.04606666f, -0.05066388f, 0.03329280f, 
    0.01519966f, 0.04045931f, -0.03177102f, -0.04739513f, -0.00826679f, -0.02965619f, -0.00750831f, 0.02571327f, 
    -0.03762710f, -0.03274427f, -0.04036481f, -0.03061431f, -0.05615840f, -0.05155300f, -0.04553152f, -0.04459455f, 
    -0.05542831f, -0.01363788f, 0.00228731f, -0.03907071f, -0.01238636f, -0.04223278f, 0.05379369f, -0.04525639f, 
    -0.05818164f, 0.01656097f, -0.05620281f, -0.00279141f, 0.03434160f, 0.02615078f, -0.01645374f, 0.05266163f, 
    -0.02722930f, 0.01762169f, -0.04020467f, -0.00041385f, 0.00785956f, 0.02845067f, -0.00717659f, 0.03436708f, 
    0.00918366f, -0.02608459f, 0.03037273f, -0.00767573f, -0.05391991f, 0.00432386f, -0.00737529f, -0.05389002f, 
    -0.04366923f, -0.05307767f, 0.01800718f, 0.02219729f, -0.03200720f, 0.01899931f, 0.05127373f, -0.04285498f, 
    0.00636528f, 0.03477130f, 0.00933834f, -0.01064716f, 0.01973603f, -0.00015705f, -0.01411771f, -0.00079886f, 
    -0.05205278f, 0.04499409f, -0.00419682f, 0.04169199f, -0.01827349f, 0.03440096f, 0.03176730f, -0.03829137f, 
    0.00545024f, -0.05776878f, -0.01898119f, -0.05687537f, -0.01454825f, -0.02111229f, 0.03299112f, -0.05862123f, 
    -0.06124403f, 0.02581167f, -0.02528389f, -0.01315888f, -0.05637590f, 0.03621029f, 0.00454155f, 0.03014116f, 
    -0.05556128f, 0.00361501f, 0.02166781f, 0.03735457f, 0.00463289f, -0.02785353f, -0.00934392f, -0.00192842f, 
    -0.04542619f, -0.00165047f, -0.04218442f, -0.01335084f, -0.05997755f, -0.00843476f, 0.02931640f, -0.01560170f, 
    -0.02500681f, -0.03922991f, 0.01345875f, 0.04363863f, -0.02903373f, 0.05052738f, 0.00367575f, 0.03598743f, 
    0.03368158f, 0.01398852f, -0.04558857f, 0.02794262f, 0.02796449f, -0.06090562f, 0.00763796f, -0.01392557f, 
    0.01836807f, -0.05401167f, -0.01770029f, -0.04124884f, -0.00444159f, -0.05597751f, 0.01743066f, -0.01994958f, 
    -0.02301906f, -0.00514576f, -0.03185176f, -0.05564664f, 0.01163570f, 0.04524164f, 0.04043863f, 0.01908753f, 
    -0.02558564f, 0.01105803f, -0.05942401f, -0.01816662f, 0.03642454f, 0.01737391f, -0.01984720f, 0.01938212f, 
    -0.04943182f, -0.06996077f, -0.00774448f, 0.01161161f, 0.00732733f, 0.01943228f, -0.01065489f, 0.00700089f, 
    -0.06106178f, -0.06026459f, 0.00233096f, -0.02456766f, -0.01284769f, -0.05016579f, 0.00991514f, -0.04076374f, 
    0.04266010f, -0.05308393f, 0.00250397f, -0.01274624f, -0.06945194f, -0.05583503f, 0.00147003f, -0.00450243f, 
    0.02033247f, 0.00060501f, -0.02276934f, 0.04317146f, -0.05056797f, -0.00953183f, -0.01401736f, -0.02255961f, 
    -0.02593009f, 0.01559892f, -0.01538344f, -0.02945603f, -0.06558923f, -0.02619748f, -0.06756578f, 0.03488236f, 
    -0.05317868f, 0.05475447f, -0.00783280f, -0.02487692f, -0.02292985f, -0.05398214f, 0.00466451f, -0.00261518f, 
    0.04320489f, 0.03880061f, 0.02758548f, -0.05096880f, -0.07414345f, 0.02578739f, -0.02968876f, -0.00313394f, 
    -0.02908264f, -0.01902874f, 0.02951107f, -0.00056597f, 0.00620782f, -0.00113553f, 0.01683548f, -0.00464358f, 
    0.02040371f, -0.05810452f, -0.02013329f, -0.00357035f, -0.01449395f, -0.06271074f, -0.06634191f, -0.03973900f, 
    -0.03929994f, 0.00194125f, -0.03716734f, 0.03154643f, -0.01008137f, -0.03215853f, -0.02234383f, -0.00130373f, 
    0.03555521f, -0.06132373f, 0.04331917f, -0.00733548f, 0.01219620f, -0.05723965f, -0.02997904f, -0.05334598f, 
    -0.03515171f, 0.03890196f, -0.01728635f, -0.05464383f, 0.02934973f, -0.03783209f, 0.02307298f, -0.03365469f, 
    0.04385135f, -0.06850544f, 0.03390410f, 0.03543308f, 0.04713598f, -0.04004733f, 0.04470401f, 0.00987694f, 
    0.03039177f, 0.01290414f, -0.02760071f, 0.02332181f, -0.00477047f, 0.02440867f, -0.03037752f, -0.06590772f, 
    0.02386353f, 0.03301404f, -0.01408606f, -0.02627237f, -0.06327647f, 0.02851243f, -0.00878958f, -0.05683525f, 
    0.03288727f, -0.01134635f, -0.02905665f, -0.00501973f, 0.02485721f, 0.01932308f, -0.03836308f, 0.00733002f, 
    0.02157472f, -0.03836420f, 0.04552262f, -0.04174062f, 0.01003945f, 0.04758329f, -0.03668985f, -0.00914044f, 
    0.01004675f, -0.03552102f, -0.03818390f, -0.02442308f, -0.02719435f, 0.02041050f, 0.01833593f, -0.05304411f, 
    -0.02874401f, -0.01684083f, 0.03894190f, -0.04387248f, -0.05500601f, 0.02060350f, -0.05514500f, 0.02934348f, 
    -0.02377354f, -0.05031435f, 0.02811363f, 0.00269596f, 0.03541190f, -0.03165099f, 0.03165123f, -0.04953004f, 
    0.03576949f, 0.03392971f, 0.00453350f, -0.01693629f, -0.04324372f, 0.04820444f, -0.03464063f, 0.01392178f, 
    -0.05367648f, -0.00663069f, 0.04290810f, -0.03305418f, -0.03159456f, -0.01292488f, 0.01527647f, 0.02944267f, 
    0.01279213f, 0.03913373f, 0.04257565f, 0.04121701f, -0.01118968f, -0.06669039f, -0.00957773f, -0.00423892f, 
    0.00480967f, -0.04990838f, -0.05470063f, 0.01989965f, -0.01696344f, 0.02003260f, 0.04183422f, -0.02385962f, 
    0.03587337f, 0.00185135f, 0.05780549f, -0.00704426f, 0.05276537f, -0.03776960f, 0.05250853f, 0.00842983f, 
    -0.00830202f, 0.03952681f, -0.01136041f, -0.01502450f, -0.03038688f, -0.05021198f, 0.02705333f, -0.03465621f, 
    -0.01812764f, 0.00915561f, -0.06527263f, 0.00029383f, 0.04543840f, -0.03806010f, -0.06075703f, -0.00296484f, 
    0.03456220f, 0.02917043f, 0.00828008f, -0.03231826f, -0.05578152f, 0.01793176f, 0.02714770f, -0.03995294f, 
    0.04394783f, 0.00724036f, -0.02959729f, 0.03481442f, 0.04665232f, -0.04550193f, -0.02953549f, 0.04905626f, 
    0.00175304f, 0.04633648f, -0.01465444f, 0.02329396f, -0.00751307f, 0.03053821f, -0.00581051f, 0.05610072f, 
    -0.00291299f, 0.01739394f, -0.00775971f, 0.01316138f, 0.03876574f, 0.03979363f, 0.00368568f, 0.04684529f, 
    -0.05515732f, 0.00609362f, 0.01574251f, 0.04096396f, -0.04496527f, -0.06782684f, -0.05997726f, -0.04647796f, 
    0.00725096f, -0.02858533f, -0.04497740f, 0.05213335f, 0.04055038f, -0.03554644f, 0.04606154f, -0.00285788f, 
    -0.02296360f, -0.05319406f, -0.02614904f, -0.00564031f, -0.01347875f, -0.03696730f, -0.02698000f, 0.03795087f, 
    0.02544760f, -0.02140105f, 0.02972372f, -0.04932605f, 0.00490996f, -0.04339465f, 0.02706334f, 0.04541766f, 
    -0.01402167f, -0.04267795f, 0.00581520f, 0.00014434f, -0.06409859f, 0.00524623f, -0.00527010f, 0.00933501f, 
    -0.02897632f, 0.01987581f, -0.03716141f, 0.03113170f, 0.01831935f, -0.00770082f, 0.04622036f, 0.00719737f, 
    -0.02701242f, -0.02711569f, 0.03927439f, -0.05220920f, -0.01192165f, -0.03387030f, -0.04746181f, -0.05363189f, 
    -0.06177612f, -0.04145519f, -0.01839038f, -0.04465117f, -0.00703752f, -0.02308010f, -0.05440975f, -0.01717027f, 
    -0.05798894f, -0.02582935f, -0.04947487f, -0.04974589f, -0.00226329f, -0.05601763f, 0.04106194f, 0.02258185f, 
    -0.00644580f, -0.03139461f, 0.02819096f, -0.06018985f, -0.01270725f, -0.05532744f, 0.00137274f, 0.02914068f, 
    0.03038436f, 0.03961808f, -0.00033557f, -0.00369642f, -0.05665778f, 0.00059608f, 0.03311654f, 0.04148254f, 
    0.04905890f, -0.05311922f, -0.06188032f, -0.03492793f, -0.02254584f, 0.04870741f, -0.02422522f, -0.03503377f, 
    0.01928588f, 0.05096431f, -0.02064769f, 0.01118893f, -0.01159458f, -0.03673841f, -0.01432138f, -0.01121139f, 
    0.05037600f, 0.02615902f, 0.05065804f, 0.01796472f, -0.02986075f, -0.04789785f, 0.03775236f, 0.00295871f, 
    0.02475733f, -0.02961709f, -0.05565269f, 0.00491889f, -0.00499055f, 0.01983915f, 0.00105534f, -0.03503367f, 
    0.01824638f, -0.04593607f, 0.03991858f, 0.01276641f, -0.03883735f, 0.01836049f, -0.04602744f, -0.06073041f, 
    -0.02386625f, 0.03352100f, -0.03415450f, -0.02173766f, -0.05366684f, -0.00444653f, 0.04038042f, -0.01283469f, 
    0.04699130f, -0.06436455f, 0.02991938f, -0.00632723f, -0.02178168f, -0.04339365f, -0.03887096f, -0.05957784f, 
    -0.03127694f, 0.03544398f, 0.03535739f, -0.02622413f, -0.02531731f, -0.03919043f, -0.02097737f, -0.03608210f, 
    -0.01561085f, -0.06474621f, 0.05099306f, -0.04947088f, 0.00963419f, -0.05107852f, -0.01392107f, 0.00989948f, 
    0.02825170f, 0.00097570f, -0.01338873f, -0.04133435f, 0.02648299f, 0.01200052f, -0.03873675f, 0.03639783f, 
    0.01926815f, -0.03228625f, -0.01649181f, -0.01631758f, 0.02630641f, -0.04532629f, 0.02571190f, 0.04056681f, 
    -0.03819774f, 0.01108851f, 0.04219022f, -0.01902351f, -0.01538911f, 0.01105395f, -0.04577690f, 0.02557958f, 
    -0.00594533f, -0.06712203f, -0.01813370f, -0.02305191f, 0.04230267f, -0.03550820f, 0.03997079f, -0.05489147f, 
    0.00715959f, -0.01608394f, -0.03699280f, -0.02560685f, -0.03607422f, 0.03312738f, 0.04690833f, -0.05622603f, 
    0.00833326f, -0.02226361f, 0.00649789f, -0.00765522f, -0.00972757f, -0.04877524f, 0.01561362f, -0.02709509f, 
    -0.03954143f, 0.03464461f, -0.05790161f, -0.05818741f, 0.02721811f, -0.05866749f, -0.03920859f, -0.04525898f, 
    -0.00249702f, 0.04186011f, 0.02154192f, -0.00096986f, 0.01785993f, 0.00964519f, 0.02041997f, 0.00419686f, 
    0.00894655f, 0.04606113f, 0.04891109f, -0.06138343f, -0.02219653f, -0.03506687f, 0.04953634f, 0.01992209f, 
    -0.02329622f, -0.05346151f, 0.04282533f, -0.04104414f, -0.05338131f, 0.01180359f, 0.04732202f, 0.01270072f, 
    -0.05970689f, -0.03209088f, -0.04474602f, 0.04624819f, -0.00070248f, 0.02267870f, 0.05221962f, -0.00400588f, 
    -0.00315235f, -0.04693116f, 0.03637221f, -0.03555406f, -0.00581461f, -0.01992524f, 0.01900555f, 0.03214270f, 
    -0.00221013f, -0.00798821f, 0.01733459f, 0.01844284f, -0.00414337f, -0.03085881f, -0.05656799f, 0.03542652f, 
    -0.05062634f, 0.01890687f, -0.03081173f, -0.05200297f, 0.02368591f, 0.01654296f, 0.03380468f, 0.04719627f, 
    0.03254571f, -0.04886408f, 0.03146553f, -0.04167504f, 0.04886185f, 0.04287819f, -0.06323761f, -0.05087020f, 
    -0.04542148f, -0.02672324f, -0.03638959f, -0.01692159f, -0.05168446f, -0.04952883f, -0.03987729f, -0.02905977f, 
    0.01535010f, -0.00285446f, -0.05493192f, -0.01339590f, 0.01893001f, 0.01386961f, 0.04402067f, 0.05143097f, 
    0.01067624f, -0.05521915f, -0.06832428f, -0.03340468f, 0.01170759f, -0.01310905f, 0.00253347f, 0.00562972f, 
    0.01500686f, 0.02969674f, -0.02750348f, -0.01941194f, -0.00734514f, -0.03395275f, 0.02133748f, -0.02450558f, 
    -0.05586231f, 0.02545511f, -0.00746323f, -0.04901598f, 0.02001874f, 0.04810234f, 0.04157912f, 0.02672729f, 
    0.01132779f, -0.03546480f, 0.02978285f, 0.03439274f, 0.00845139f, -0.06431503f, -0.00761549f, 0.03855278f, 
    -0.06271046f, 0.02089273f, -0.06270256f, 0.02719238f, -0.03791029f, -0.03809125f, 0.04933646f, -0.00568471f, 
    -0.04997589f, 0.04575058f, -0.04709679f, 0.03705706f, -0.04324286f, 0.03513981f, 0.01279386f, -0.01617771f, 
    -0.03229343f, -0.00723891f, 0.00710516f, -0.05560425f, -0.03127804f, -0.01885369f, -0.02528547f, 0.02833920f, 
    0.00595244f, 0.02187528f, -0.06997253f, 0.03188027f, -0.03623667f, 0.01729688f, -0.02619488f, -0.01015719f, 
    -0.00513777f, -0.00354592f, -0.06589802f, -0.06296009f, -0.01207883f, -0.01135450f, -0.01920908f, -0.06154610f, 
    0.02286303f, -0.02683939f, -0.02180818f, -0.03196159f, -0.01222022f, 0.02007384f, 0.04288157f, 0.02344900f, 
    0.01741732f, -0.00021059f, 0.02202564f, -0.00934797f, -0.02283314f, -0.02571863f, 0.02318133f, 0.00527198f, 
    -0.02330281f, -0.02191676f, -0.03152296f, -0.01984850f, 0.02352963f, -0.06235018f, -0.02796570f, 0.03547584f, 
    -0.05691049f, -0.06194656f, -0.03654667f, -0.05642075f, 0.00704867f, 0.04195994f, -0.02909955f, 0.03277760f, 
    -0.00177483f, -0.05315888f, -0.04398311f, 0.02554460f, 0.04950527f, 0.01645763f, -0.03157208f, -0.03061981f, 
    0.01615793f, -0.04514293f, 0.04937691f, -0.03944100f, -0.04285520f, 0.01585581f, -0.03007732f, 0.02405494f, 
    -0.05473428f, -0.00420849f, 0.04455767f, 0.03841796f, -0.02843757f, -0.00583948f, 0.02859105f, -0.00134884f, 
    0.01591756f, 0.01428879f, -0.01360755f, -0.03420254f, 0.00851213f, 0.04386936f, 0.00821068f, -0.06316271f, 
    -0.06565040f, 0.02801581f, -0.00373533f, 0.03854968f, -0.01998091f, -0.04166977f, 0.04228938f, -0.03072067f, 
    -0.04180444f, -0.02449195f, -0.06331413f, -0.06670975f, -0.00234977f, -0.00336550f, 0.04383540f, 0.03166272f, 
    -0.04610839f, -0.00997335f, -0.05705969f, -0.02727388f, 0.01381333f, -0.02655119f, -0.01068073f, 0.02602705f, 
    -0.01206589f, -0.02338920f, 0.04012408f, 0.03915472f, -0.06198182f, 0.04474526f, 0.03557885f, -0.04330960f, 
    -0.04693560f, -0.00469121f, 0.02309862f, -0.06208370f, -0.01285701f, -0.01518859f, 0.01421877f, 0.03761981f, 
    0.00348314f, -0.03813270f, -0.02805139f, -0.01497756f, -0.01066427f, -0.02531336f, -0.03733129f, -0.05822702f, 
    0.03692152f, -0.03533239f, -0.04303022f, -0.04558169f, -0.06262153f, 0.00016888f, -0.06006771f, 0.03778087f, 
    -0.06002324f, -0.02145437f, -0.05479369f, 0.04195250f, -0.06816395f, 0.04022452f, -0.01808010f, -0.05562651f, 
    -0.04301048f, 0.04598844f, 0.00730539f, -0.00406411f, 0.03109586f, 0.04788899f, -0.00612220f, -0.00986757f, 
    -0.01512955f, -0.01571418f, -0.01217390f, -0.06325936f, 0.02897021f, -0.01505516f, 0.04388282f, 0.03455709f, 
    -0.03242947f, -0.00796461f, -0.05953766f, 0.04288476f, 0.01279745f, 0.00784561f, 0.02628691f, 0.00365667f, 
    0.01603394f, -0.02696989f, -0.04351189f, 0.04330343f, -0.00682648f, -0.01799014f, 0.01635361f, -0.03079668f, 
    -0.05132868f, -0.00155354f, -0.05533676f, 0.03168250f, -0.00478081f, 0.03062277f, -0.04692858f, -0.03134296f, 
    -0.03663915f, -0.05207321f, -0.06736487f, 0.03847085f, -0.02917838f, -0.03731313f, -0.04132310f, -0.01996766f, 
    0.03508539f, -0.01966641f, 0.03758218f, 0.03418615f, -0.06576706f, 0.01157865f, -0.05244284f, -0.03209455f, 
    0.00523272f, 0.01202512f, -0.02566860f, 0.02062951f, -0.02416487f, -0.04525521f, 0.01726443f, -0.02168337f, 
    -0.04682440f, -0.03400030f, 0.01194873f, -0.06863546f, -0.03116080f, 0.02556116f, 0.04802080f, -0.05411183f, 
    -0.05241271f, -0.01879759f, 0.04895634f, 0.00545073f, -0.01366589f, -0.03675009f, 0.01904713f, 0.03250767f, 
    0.02562047f, -0.04201424f, -0.04172488f, -0.00692771f, -0.01248858f, -0.03046810f, 0.04713193f, -0.01358618f, 
    -0.10105705f, 0.00004420f, -0.05384911f, 0.13871592f, -0.06247584f, 0.02951701f, -0.10254115f, 0.02883422f, 
    0.06957975f, -0.22846006f, -0.11544962f, 0.09372585f, -0.09513717f, -0.05828729f, -0.01724952f, -0.02831868f, 
    -0.10362972f, 0.02436017f, -0.08947107f, 0.26438785f, 0.14922422f, -0.00357763f, -0.09818731f, -0.14920083f, 
    0.18394347f, 0.13879603f, 0.01910078f, -0.05196794f, 0.23608345f, 0.00974367f, -0.13561770f, -0.12787203f, 
    0.04321102f, -0.16830657f, -0.07045455f, 0.05220313f, 0.05032259f, 0.17209996f, 0.24701321f, 0.05919285f, 
    0.03619720f, 0.01759833f, -0.00347469f, -0.07070845f, -0.26037541f, 0.22482595f, 0.30142277f, -0.34020644f, 
    0.10231965f, -0.06859247f, 0.03750739f, 0.17556633f, -0.12436004f, 0.06184108f, 0.07502141f, 0.14207943f, 
    -0.12919216f, 0.10824290f, 0.13111770f, 0.11801965f, 0.09179651f, -0.10425690f, -0.01254763f, -0.32746497f, 
    0.04533211f, -0.14948998f, 0.02276601f, 0.06433032f, -0.07997972f, -0.04382342f, 0.02481701f, 0.01138188f, 
    0.06772965f, 0.19996367f, -0.25524452f, 0.14114168f, 0.01365903f, 0.03116881f, -0.03875247f, 0.02304292f, 
    0.02308167f, -0.00346984f, 0.11052346f, -0.18178365f, -0.01480670f, 0.14751710f, -0.04158420f, 0.16559651f, 
    -0.09332649f, -0.12984076f, 0.13724318f, 0.10870036f, 0.16580893f, 0.11982450f, 0.02617769f, -0.05889485f, 
    0.04832710f, 0.04303980f, 0.02481788f, 0.19132282f, -0.21411337f, -0.11939976f, 0.03924100f, -0.07284233f, 
    -0.05652620f, 0.07656565f, 0.01074098f, -0.07488169f, 0.04320066f, -0.07437829f, -0.31228656f, -0.10737471f, 
    -0.03861358f, 0.05844823f, 0.06908157f, 0.08002715f, 0.01022897f, 0.12402836f, 0.05630736f, -0.03904451f, 
    -0.03880065f, -0.11002114f, -0.13835135f, 0.17206763f, 0.07178772f, -0.01997087f, -0.08426150f, -0.15554370f, 
    -0.12746979f, 0.13993619f, 0.13461293f, 0.02288023f, 0.00359783f, -0.10924952f, 0.03294985f, 0.03459770f, 
    0.09608915f, -0.01568355f, 0.14496505f, -0.09367301f, 0.06117135f, -0.06024196f, -0.00304386f, 0.15303752f, 
    0.02456525f, -0.15333998f, -0.06704613f, 0.06852762f, -0.17138769f, -0.01434666f, 0.13113889f, -0.04681468f, 
    -0.11508331f, -0.07718597f, -0.04665943f, 0.16221942f, -0.09539156f, -0.04302749f, -0.01326048f, -0.01692956f, 
    -0.05542298f, 0.21954910f, -0.17764182f, 0.12128171f, 0.13739678f, -0.01583170f, -0.00985584f, -0.15929286f, 
    0.04081790f, 0.08628543f, 0.00631470f, 0.05254140f, 0.13500494f, 0.05306834f, 0.05488963f, -0.12355865f, 
    -0.20707628f, 0.00811598f, 0.10759927f, 0.04827905f, -0.53391385f, 0.25606403f, -0.06487293f, -0.03385709f, 
    0.03653784f, -0.07043179f, 0.05851635f, 0.04548300f, -0.01848450f, 0.22678562f, 0.06863400f, -0.07585970f, 
    0.07804856f, 0.11328526f, 0.08827429f, -0.00770951f, -0.19013438f, 0.04095326f, -0.03864469f, -0.25534174f, 
    0.18027440f, -0.07533905f, 0.00573346f, -0.01914605f, -0.02331822f, 0.09173864f, -0.00883601f, -0.07817665f, 
    -0.31234294f, 0.07702615f, -0.00797997f, 0.02480015f, 0.20848969f, -0.00956590f, 0.03301146f, 0.04160918f, 
    -0.27524748f, -0.21972431f, -0.09525298f, -0.02725384f, -0.02127571f, 0.12318838f, 0.03225622f, -0.14346056f, 
    -0.14433989f, -0.13302301f, -0.02545649f, 0.01476631f, -0.07796665f, 0.04054608f, 0.15448487f, -0.15586121f, 
    -0.02298570f, 0.15994394f, -0.12404656f, 0.18631309f, 0.12161552f, -0.13064533f, 0.04990265f, -0.00459706f, 
    0.18889309f, -0.03673321f, 0.14984109f, -0.14719975f, -0.12610222f, -0.09696495f, 0.07918556f, -0.20466299f, 
    0.06318277f, 0.01696733f, 0.07161952f, -0.07653987f, -0.50282949f, 0.13493702f, 0.34555653f, -0.01717751f, 
    -0.00580618f, -0.04973547f, -0.07957252f, 0.02145028f, 0.02354092f, -0.00127298f, -0.03424438f, -0.05296757f, 
    -0.11507732f, 0.06859329f, 0.04760188f, 0.13000524f, -0.13842081f, 0.15471135f, -0.05040518f, 0.17982833f, 
    0.03553369f, 0.00778406f, -0.20014668f, 0.07921288f, 0.02331061f, 0.01116679f, 0.01359775f, 0.10258301f, 
    0.04967775f, 0.08549437f, 0.00348328f, 0.03849422f, -0.03517604f, -0.14004153f, 0.10892692f, 0.00868373f, 
    0.05915672f, 0.16852006f, -0.07184847f, 0.02298685f, -0.00845541f, 0.05882502f, -0.21355301f, -0.05128521f, 
    -0.03283517f, 0.07845881f, -0.01520713f, 0.03788669f, 0.12832749f, -0.11846897f, -0.03172114f, 0.17032288f, 
    0.06407479f, -0.08108895f, 0.05100368f, 0.00255555f, -0.20690067f, 0.02984011f, 0.00915185f, 0.11633079f, 
    0.06225710f, -0.05080665f, -0.08153003f, 0.01568746f, 0.02311345f, -0.03421479f, 0.05425049f, -0.01365385f, 
    0.00395337f, -0.08371183f, 0.04729185f, -0.01421040f, -0.16753355f, -0.05690595f, -0.04170483f, 0.00585318f, 
    -0.19785818f, 0.00277453f, -0.05517495f, 0.15234631f, 0.03129876f, -0.51651597f, 0.03979001f, 0.28870219f, 
    -0.08585052f, -0.01610542f, 0.03726589f, -0.05512096f, 0.04709144f, 0.09272566f, -0.07450292f, -0.08839590f, 
    0.08222358f, -0.15887855f, -0.03871835f, 0.10525502f, -0.12609613f, 0.07973451f, 0.05117072f, -0.30030000f, 
    0.02242569f, 0.05772052f, -0.05950401f, 0.01352889f, 0.08236064f, 0.01558138f, -0.05789320f, 0.21189329f, 
    -0.34743109f, -0.14933310f, 0.26385930f, -0.18356650f, -0.03837179f, 0.07788113f, -0.03299586f, -0.06351686f, 
    0.08187582f, 0.15098786f, -0.14413412f, 0.29520389f, 0.01740809f, -0.05881025f, -0.08792573f, -0.06343102f, 
    -0.15121327f, -0.22625569f, -0.00114478f, -0.06783324f, -0.00919521f, -0.08416328f, 0.14915195f, 0.15530345f, 
    -0.00097455f, -0.13443048f, -0.01448629f, -0.12188958f, 0.08193126f, 0.09465582f, 0.03865572f, 0.02831091f, 
    -0.02704660f, 0.00184747f, -0.08925732f, -0.01004055f, 0.08209728f, 0.09576545f, 0.14036626f, 0.07961468f, 
    0.11868881f, 0.00792136f, -0.09873554f, -0.00782165f, -0.10204094f, -0.03619794f, -0.02270536f, -0.03232246f, 
    0.00253186f, 0.04357710f, 0.27773452f, -0.04756724f, 0.05082834f, -0.06718621f, 0.14621927f, 0.10786247f, 
    -0.01844689f, -0.19522385f, 0.10333830f, 0.09423627f, 0.08588666f, 0.04226257f, 0.09209838f, 0.24336754f, 
    -0.01978661f, -0.11294881f, -0.05859408f, -0.01320088f, 0.04343700f, 0.06705011f, -0.06684788f, 0.00742598f, 
    0.12960561f, 0.00985137f, 0.17827080f, 0.05921327f, -0.03130195f, 0.11996683f, -0.15759152f, 0.07092868f, 
    -0.03578404f, -0.07666744f, 0.04037495f, -0.01905584f, 0.06081529f, -0.00745701f, 0.00516268f, -0.02406742f, 
    0.05024294f, -0.10959777f, 0.07132442f, -0.05435915f, -0.07119545f, 0.04363142f, 0.17663129f, 0.13151717f, 
    0.11270394f, 0.01766612f, -0.17556351f, -0.13751726f, -0.07834821f, -0.15742417f, 0.00620086f, 0.23179117f, 
    0.05126088f, 0.07181254f, -0.05594031f, -0.08615218f, -0.01520545f, -0.04205386f, 0.04410616f, 0.02438208f, 
    0.17240502f, 0.08209763f, 0.06289941f, 0.05148603f, -0.04721776f, -0.00639107f, -0.19889317f, -0.01593994f, 
    0.00208629f, 0.01548170f, 0.11297427f, -0.18769315f, 0.11927801f, 0.04694084f, 0.11016382f, 0.04712325f, 
    0.03149869f, 0.11126611f, 0.05568642f, -0.11654198f, 0.09794671f, 0.14853413f, 0.07737835f, -0.20260280f, 
    0.13933721f, 0.00991694f, -0.00879245f, -0.10497253f, -0.12466243f, 0.06179823f, -0.00606149f, -0.03750095f, 
    0.15850972f, 0.17616323f, 0.08151652f, -0.10640938f, -0.07639270f, -0.00998333f, -0.00766062f, 0.13143639f, 
    0.04136887f, 0.08416884f, 0.10612702f, 0.11131510f, 0.21340318f, -0.11581389f, 0.02307985f, 0.10768662f, 
    0.04630569f, -0.16507019f, 0.00318880f, -0.11116968f, -0.13779022f, -0.06929050f, 0.05627241f, 0.06605971f, 
    -0.04159081f, -0.05228173f, -0.04575620f, -0.09865372f, 0.12050983f, -0.04861397f, 0.01659089f, 0.11937886f, 
    -0.01743766f, -0.10871424f, -0.00871041f, -0.16504000f, 0.03411896f, -0.06441174f, -0.14937824f, -0.10236912f, 
    0.14993139f, 0.00096807f, -0.10620070f, -0.01708198f, 0.04150143f, -0.03449927f, 0.05220691f, -0.36251324f, 
    0.12606597f, 0.07223906f, -0.00409095f, 0.00555467f, 0.09383295f, -0.14831097f, 0.02914421f, -0.10756810f, 
    -0.11987225f, 0.06145812f, 0.13302700f, -0.07132481f, -0.06130830f, -0.09442678f, -0.16686882f, 0.19233625f, 
    0.20742203f, -0.22330897f, -0.02638581f, 0.00356596f, -0.00009180f, 0.02066364f, -0.04690473f, 0.03698964f, 
    0.09063623f, 0.01003778f, -0.06095866f, 0.03079855f, -0.01000904f, 0.04716773f, 0.10543117f, 0.04907387f, 
    0.18179953f, 0.11320531f, 0.02335401f, -0.13897328f, 0.24050149f, -0.11189088f, -0.14007528f, 0.16664390f, 
    -0.06517033f, 0.25507423f, 0.12231752f, 0.11988633f, 0.12428900f, 0.15844670f, 0.01586701f, 0.03870020f, 
    0.13031904f, 0.01350649f, 0.06499039f, 0.19758908f, 0.12187926f, 0.17114441f, 0.02157418f, -0.02459286f, 
    -0.13549078f, -0.00128015f, -0.05179669f, -0.00196553f, -0.01258584f, -0.17311758f, -0.00830483f, 0.16441742f, 
    -0.09375972f, 0.06121239f, -0.19879062f, 0.04837588f, 0.01504539f, -0.24251090f, 0.09867471f, 0.08102077f, 
    0.02574464f, 0.06871857f, -0.01253497f, -0.10689682f, -0.07661442f, 0.01783048f, -0.16364263f, -0.14259073f, 
    -0.03607989f, 0.08088150f, 0.02452954f, 0.03401650f, -0.14408374f, -0.16660532f, 0.13498326f, -0.06631691f, 
    -0.02674959f, 0.01408795f, 0.04141580f, -0.05481308f, 0.18499351f, 0.04497123f, -0.06033336f, -0.02114263f, 
    -0.22905356f, -0.11812373f, 0.13855000f, 0.09566782f, 0.09416018f, 0.02451176f, 0.00705648f, -0.06289162f, 
    0.02922047f, -0.16507426f, -0.17785701f, -0.15618259f, 0.11602265f, 0.10981358f, 0.09939457f, -0.13363056f, 
    -0.10047524f, -0.18415649f, 0.03793549f, 0.02879576f, 0.08239778f, -0.02083345f, -0.00299111f, 0.26904893f, 
    0.18427612f, -0.13982640f, -0.08247294f, -0.11007177f, -0.03145855f, 0.16143823f, 0.08557059f, -0.03367347f, 
    -0.07955564f, -0.10257964f, -0.17110819f, -0.19377552f, -0.07741302f, 0.05388610f, 0.22615521f, 0.16982229f, 
    0.08861788f, 0.06497316f, -0.08506253f, 0.01470719f, -0.09638808f, 0.03356405f, 0.27010792f, -0.01835364f, 
    0.14588195f, 0.09103240f, 0.19386335f, 0.08846321f, 0.04322216f, -0.07668949f, -0.11367496f, 0.21887802f, 
    0.15336199f, 0.06338180f, -0.07490402f, -0.08257118f, -0.01697852f, 0.06053869f, -0.00128246f, 0.01822733f, 
    0.05952699f, 0.06040699f, -0.13361271f, -0.00925937f, -0.01080096f, 0.10021788f, 0.04730445f, 0.04406782f, 
    0.00740001f, -0.12877581f, -0.14692256f, 0.07858304f, -0.02012527f, -0.01152166f, -0.09250607f, -0.01779490f, 
    0.11951099f, 0.19949821f, 0.09940828f, 0.19857484f, -0.02198705f, 0.00920920f, -0.13041177f, 0.20195989f, 
    0.07255249f, 0.23336814f, -0.02091498f, -0.17299017f, -0.04033525f, 0.06023944f, 0.14529876f, 0.31055960f, 
    0.16659881f, -0.13013567f, 0.09761538f, -0.12255350f, -0.14936255f, -0.00791568f, 0.05113078f, 0.02652386f, 
    0.08200574f, 0.12092451f, -0.10965422f, -0.01931501f, -0.02439039f, 0.02009230f, 0.00223432f, 0.22170079f, 
    0.02150179f, 0.02169355f, 0.03579495f, -0.12365201f, 0.07223790f, -0.17626505f, -0.26672640f, -0.01839004f, 
    0.17124382f, 0.04650699f, 0.03029611f, -0.00363777f, 0.01573509f, 0.03153699f, 0.20230065f, 0.00522154f, 
    -0.09622815f, 0.04691084f, -0.02591274f, -0.07288516f, 0.20926537f, 0.07778741f, 0.09596767f, 0.09903201f, 
    0.08802842f, -0.01061971f, 0.13128541f, -0.03071212f, -0.08222047f, 0.12878929f, -0.03778874f, 0.09027769f, 
    -0.07606245f, -0.01708220f, -0.09437607f, -0.04639855f, -0.04192940f, 0.02591690f, 0.02297334f, -0.01833188f, 
    0.11539710f, -0.00566087f, 0.00686605f, 0.21965566f, 0.09294120f, -0.14720644f, -0.07299192f, 0.10579582f, 
    -0.04677155f, -0.04299096f, -0.23601621f, -0.05786414f, -0.12963703f, -0.11361542f, 0.14869854f, 0.00771161f, 
    0.08028908f, 0.10577212f, -0.01151424f, -0.12713236f, 0.12098688f, -0.04298345f, 0.00952166f, 0.08092164f, 
    0.13603131f, 0.17507324f, 0.02768257f, -0.02717998f, -0.22240272f, -0.38232449f, -0.23263432f, 0.22293814f, 
    0.16581419f, -0.09470854f, -0.04243064f, -0.02513092f, -0.15640372f, -0.12872578f, -0.26908419f, -0.28352723f, 
    -0.23501046f, -0.12032970f, 0.01088702f, -0.00397457f, -0.00454365f, -0.00330559f, -0.12437128f, 0.20606543f, 
    0.22325371f, 0.04430532f, 0.05651734f, -0.03250653f, 0.08751734f, -0.02814559f, 0.07169582f, -0.00801637f, 
    0.20950983f, 0.20325206f, -0.03308800f, -0.10401181f, 0.16097561f, -0.06295352f, 0.10140445f, -0.13453923f, 
    0.02474259f, -0.04974867f, 0.04687422f, -0.00617076f, 0.01315595f, -0.02328088f, -0.04735080f, -0.06190334f, 
    -0.03638347f, -0.06364693f, 0.01583731f, 0.01030671f, -0.06035559f, 0.04131107f, -0.03615323f, 0.02408514f, 
    -0.00892819f, -0.01469590f, 0.02936220f, 0.04926868f, -0.00908936f, -0.05119494f, -0.02773021f, -0.04035769f, 
    -0.03983862f, -0.00043519f, -0.05039700f, -0.01243887f, 0.00179696f, -0.06309006f, -0.05549415f, -0.02136089f, 
    0.01913656f, -0.01767628f, 0.04360409f, -0.06568064f, -0.06211435f, 0.01948294f, 0.01913577f, 0.04057468f, 
    -0.05754969f, -0.04249588f, 0.02280612f, 0.03054157f, -0.04199237f, 0.01648928f, 0.00836599f, -0.01399904f, 
    0.04862864f, 0.00706962f, -0.04643853f, -0.00404338f, -0.01481893f, -0.01279645f, -0.04293726f, 0.05033217f, 
    0.01265737f, -0.00444685f, -0.02200197f, 0.00710381f, -0.03402187f, 0.02057023f, -0.06082331f, 0.03029755f, 
    -0.01744577f, 0.00902121f, 0.03134108f, -0.04491635f, 0.02470344f, -0.00365508f, -0.03767589f, -0.00194923f, 
    -0.01179358f, 0.01937859f, -0.04845700f, -0.01369943f, -0.04602651f, -0.04222045f, -0.06008096f, -0.02462979f, 
    -0.01285018f, -0.05082298f, -0.05079478f, -0.00997960f, 0.04771518f, 0.00733939f, -0.01154141f, -0.00349652f, 
    0.01226467f, -0.02065026f, -0.01073281f, -0.00734620f, 0.03518743f, -0.02893716f, -0.00905226f, 0.04554021f, 
    -0.04977497f, 0.01215971f, -0.00742714f, -0.00897702f, 0.00509481f, -0.02919258f, -0.02319007f, -0.06491477f, 
    0.02054903f, -0.02004895f, -0.00285346f, 0.00660919f, -0.02252847f, 0.04804693f, 0.03241514f, -0.04531312f, 
    0.01451009f, -0.05741077f, 0.00343165f, 0.03615698f, -0.02956448f, 0.00287079f, -0.03754058f, -0.05732686f, 
    0.03944228f, -0.03772390f, -0.01326510f, 0.01266653f, -0.00413148f, -0.03679188f, 0.00298257f, 0.04040938f, 
    0.00975951f, -0.02944371f, -0.04219029f, 0.04391678f, -0.04448396f, -0.02083698f, -0.05059323f, -0.05365045f, 
    0.00732746f, 0.03685720f, 0.02392763f, -0.01788442f, 0.00345925f, -0.00958463f, 0.00626860f, -0.03269569f, 
    0.04671249f, -0.04933394f, 0.00146504f, 0.00048008f, 0.01635152f, -0.04707760f, 0.00481558f, 0.02538429f, 
    -0.03562486f, -0.01356206f, 0.02548040f, 0.03559721f, -0.06078676f, -0.02269006f, 0.00868616f, -0.03338567f, 
    0.03161459f, 0.03741113f, -0.03144111f, 0.03828694f, -0.05200806f, 0.03710288f, -0.04619856f, 0.01461903f, 
    0.05447682f, -0.03154854f, 0.02493988f, 0.02509159f, -0.03798909f, 0.03089549f, -0.06336404f, -0.04686520f, 
    -0.05304927f, 0.05168600f, -0.00181115f, -0.05038616f, 0.00281607f, -0.00653281f, -0.03372698f, 0.02635956f, 
    -0.00079896f, -0.03729570f, 0.03282847f, -0.03346870f, 0.02361741f, 0.02707226f, 0.01474762f, 0.01109647f, 
    -0.03698629f, -0.01659983f, -0.03234984f, -0.01267679f, -0.04776633f, 0.02517994f, -0.05732623f, -0.01904858f, 
    -0.06132988f, 0.00050725f, 0.05116481f, -0.02326094f, 0.00198071f, -0.00215734f, 0.02251584f, -0.03439323f, 
    0.01958001f, 0.04737979f, -0.05415350f, 0.04336581f, 0.02554168f, 0.04912952f, -0.01427533f, -0.05009050f, 
    0.00251232f, -0.01628480f, 0.03557552f, 0.02283452f, -0.04404836f, -0.04809818f, 0.04071715f, -0.03077108f, 
    0.03757353f, -0.02123582f, -0.00215561f, -0.03876740f, -0.00384549f, 0.00627479f, 0.01541684f, -0.00524935f, 
    0.03202074f, 0.01221431f, 0.00840397f, 0.03582034f, -0.05497763f, -0.05037513f, 0.01255365f, 0.01021434f, 
    -0.03765012f, 0.03946192f, 0.02567420f, -0.03922428f, -0.02281020f, -0.01799631f, 0.02994723f, 0.03735717f, 
    0.03444336f, 0.04406732f, -0.00888262f, 0.00425867f, -0.03645432f, -0.00081200f, 0.01534613f, -0.03978580f, 
    0.03125863f, -0.03201620f, -0.05045664f, -0.03890209f, -0.02530194f, -0.00982184f, 0.04098748f, 0.05744258f, 
    -0.01341145f, 0.01209986f, 0.03322650f, -0.04067724f, -0.00991972f, -0.00489961f, -0.04943762f, -0.02562874f, 
    -0.02674119f, 0.02106947f, 0.00319666f, -0.03383770f, -0.03005201f, -0.03438496f, -0.04553993f, 0.04519102f, 
    0.04927465f, 0.06167587f, -0.05292169f, 0.02983717f, 0.02914374f, 0.02395023f, 0.02231354f, 0.02633531f, 
    -0.00010961f, -0.05496811f, -0.01006583f, 0.00712980f, 0.00593183f, 0.00717583f, 0.03401846f, 0.01825080f, 
    0.00441666f, 0.03870913f, -0.00063790f, -0.02293969f, 0.00756937f, -0.00615664f, -0.00875688f, 0.02455718f, 
    -0.03845426f, 0.01503591f, 0.01177984f, -0.01110986f, 0.02867579f, -0.01482229f, -0.04396626f, -0.06508162f, 
    -0.01155226f, 0.05490691f, -0.02245012f, -0.06164917f, -0.04868538f, 0.02956349f, 0.03846001f, -0.00375324f, 
    -0.05557671f, 0.01438665f, 0.04451976f, 0.00883304f, -0.02761909f, -0.03825397f, -0.00643267f, 0.03764987f, 
    -0.03906181f, -0.04269010f, -0.05394521f, -0.06168844f, -0.00484516f, 0.00887624f, -0.02855261f, 0.06989218f, 
    0.00550355f, 0.00269694f, -0.00776172f, -0.03494418f, -0.01611847f, -0.05513152f, -0.05931375f, 0.02244196f, 
    0.00686033f, 0.04165884f, 0.01014004f, 0.00758156f, 0.04574437f, 0.01516333f, -0.00400624f, -0.00734650f, 
    -0.04403925f, 0.03226236f, -0.00907045f, 0.04414204f, -0.00979388f, -0.02308531f, -0.04735586f, 0.05622130f, 
    -0.03001932f, 0.01423341f, 0.05398510f, -0.02323418f, -0.06669398f, 0.04897355f, 0.01217887f, -0.00271021f, 
    -0.06759476f, -0.05942219f, -0.00697685f, 0.03506769f, -0.01249084f, -0.05067252f, -0.03597909f, -0.06435560f, 
    0.03868186f, -0.04817244f, -0.06396753f, 0.01201524f, -0.01663620f, -0.06347958f, -0.02598180f, -0.06336696f, 
    0.04285724f, -0.05632223f, 0.01357074f, -0.02229470f, -0.05386629f, -0.00007400f, -0.04538094f, -0.05324240f, 
    -0.05547207f, -0.01861585f, -0.01942659f, -0.02795635f, -0.00041657f, 0.03512970f, -0.04575490f, 0.03956635f, 
    -0.04894052f, 0.00228383f, 0.03044404f, 0.03878985f, -0.01831867f, -0.04624226f, -0.03605974f, 0.05001002f, 
    -0.02477975f, 0.01822245f, 0.00985474f, -0.05392253f, 0.01871319f, -0.00420053f, -0.00401944f, -0.03133691f, 
    -0.03928702f, 0.04056684f, 0.03491537f, 0.04715632f, -0.05614359f, -0.02186635f, 0.02190783f, 0.01984326f, 
    0.04477348f, -0.00640412f, 0.00033997f, 0.02855421f, -0.02061083f, -0.04085090f, 0.02297637f, 0.02616292f, 
    0.00033096f, 0.01737463f, -0.05671786f, 0.04665202f, -0.04178593f, 0.01332538f, 0.02316754f, -0.03826476f, 
    0.02967762f, 0.03134100f, -0.05249651f, -0.00366422f, -0.02096440f, -0.03833806f, 0.00591203f, -0.06228839f, 
    -0.01575903f, -0.03532413f, -0.01956867f, 0.01783043f, -0.03525218f, 0.01658782f, 0.00971454f, -0.05774799f, 
    0.06599859f, -0.00217118f, 0.00344803f, -0.06224395f, -0.03428964f, -0.02310247f, -0.02751689f, -0.06201465f, 
    -0.02419672f, -0.00223941f, -0.03727366f, 0.01013489f, -0.01847093f, 0.01863174f, 0.03345779f, -0.05213710f, 
    0.03959349f, 0.01687983f, 0.02629898f, -0.02076743f, -0.02868637f, -0.03312001f, 0.03601971f, 0.05514381f, 
    0.04579929f, 0.04031748f, -0.00944790f, -0.04990764f, -0.03686271f, -0.02525370f, -0.04290026f, -0.05402887f, 
    -0.02030302f, 0.03182623f, 0.01889582f, -0.04797991f, 0.01523735f, 0.05278599f, 0.00313352f, 0.04848263f, 
    -0.05533955f, 0.00398304f, -0.03037888f, 0.04815535f, 0.02408093f, -0.02947558f, -0.06687506f, 0.01688205f, 
    -0.02791247f, 0.01652738f, 0.00688946f, 0.02958940f, 0.01870628f, -0.02577388f, 0.00991056f, -0.01608766f, 
    0.03473279f, -0.04821856f, -0.00815052f, 0.03455234f, -0.00344761f, 0.03905050f, -0.01569925f, -0.05658365f, 
    0.05512431f, 0.00019154f, 0.02646724f, 0.01899469f, -0.06140139f, 0.03497918f, -0.03417971f, -0.06098579f, 
    0.00795205f, -0.04313792f, 0.01097323f, -0.06429233f, 0.02796743f, -0.06515263f, -0.04144653f, 0.03271381f, 
    -0.03818036f, 0.04151071f, 0.00019140f, 0.02081541f, -0.05816025f, 0.04625064f, 0.02853998f, 0.04209781f, 
    -0.00668687f, -0.04462899f, -0.03031661f, -0.03182485f, -0.00062103f, 0.04435819f, 0.01662512f, -0.04860263f, 
    0.00074276f, 0.00752829f, 0.03386088f, -0.04708779f, -0.03553959f, -0.06659595f, -0.04698547f, -0.03042166f, 
    -0.01860216f, -0.03339360f, -0.04278760f, 0.01725990f, -0.04917709f, -0.00870525f, -0.02683648f, 0.01832235f, 
    -0.04753265f, -0.02752406f, -0.01820880f, -0.03242908f, 0.02216489f, -0.00403068f, -0.03565880f, -0.03031221f, 
    0.01008687f, 0.04568612f, -0.03011072f, 0.04545556f, -0.01223345f, -0.05855628f, 0.01701150f, 0.00459709f, 
    -0.03768329f, -0.05105961f, 0.00211465f, -0.00687388f, 0.04947282f, -0.02271744f, -0.02585427f, 0.01142968f, 
    -0.04668756f, 0.04605407f, 0.00722138f, -0.04158580f, 0.04498812f, -0.00289831f, -0.03377222f, 0.02363793f, 
    0.00939359f, 0.01604552f, -0.02605987f, -0.04382842f, 0.01655173f, 0.03443771f, 0.03677877f, -0.00478042f, 
    -0.03813722f, 0.04616924f, 0.03194690f, -0.02952453f, -0.03624110f, -0.03143318f, 0.00234041f, -0.04921768f, 
    0.03243975f, -0.02573234f, 0.00679611f, -0.01921822f, 0.01208174f, -0.03064625f, 0.03181603f, -0.05243647f, 
    0.03403608f, 0.02378910f, -0.05869114f, 0.02665638f, 0.02868834f, 0.04027880f, -0.05503026f, -0.02653990f, 
    0.00558543f, -0.02416312f, -0.01953324f, -0.03923830f, 0.03049454f, 0.05479427f, 0.04310941f, -0.02588998f, 
    -0.05522129f, -0.00544303f, -0.01788157f, -0.00337532f, 0.04453843f, -0.04572909f, 0.01772752f, -0.00643407f, 
    0.04507412f, 0.01397643f, -0.00314859f, -0.03128260f, -0.00136252f, -0.04926944f, 0.03450337f, -0.03440973f, 
    -0.05551291f, -0.03349198f, 0.04114478f, -0.04679644f, -0.00841009f, 0.02685627f, -0.01568182f, -0.03716719f, 
    -0.01191215f, -0.04565554f, 0.02804189f, -0.01305787f, 0.00132581f, -0.01171606f, -0.02467045f, -0.04887827f, 
    -0.00074879f, 0.00001918f, 0.00476231f, 0.02030979f, -0.00939317f, -0.01904522f, 0.03952996f, -0.03772715f, 
    -0.02211286f, 0.00232286f, 0.04708321f, 0.03905025f, -0.05378819f, -0.03020960f, -0.03524116f, -0.04045962f, 
    0.02619927f, -0.00795560f, 0.00365804f, 0.02818352f, 0.01029954f, -0.03348112f, 0.05281616f, -0.04419697f, 
    0.02616174f, -0.02522110f, -0.03111816f, -0.05614597f, -0.04793084f, -0.02155878f, -0.02853361f, -0.00052660f, 
    0.00776557f, 0.03670317f, 0.04880023f, 0.02641879f, -0.02651545f, -0.00408553f, 0.03713056f, 0.00923201f, 
    -0.05660057f, 0.01620196f, 0.03492634f, -0.00507100f, -0.04402953f, -0.00973814f, -0.01517844f, 0.00071381f, 
    -0.00971271f, -0.05280413f, -0.05584903f, -0.03468803f, -0.02356751f, -0.02934408f, 0.00822670f, 0.00104637f, 
    0.02582492f, -0.00694600f, -0.05560161f, -0.04434119f, 0.05547348f, -0.00919015f, -0.04925197f, 0.05073794f, 
    -0.04577644f, -0.03990850f, 0.02589081f, -0.03967933f, -0.00004502f, 0.02425235f, 0.02423196f, 0.03455577f, 
    0.03696083f, 0.01921897f, -0.00836903f, -0.01806176f, -0.05323295f, 0.03453484f, -0.05766440f, -0.05435474f, 
    -0.04995243f, -0.02915881f, -0.02332638f, -0.01763974f, -0.01468490f, -0.01454696f, 0.03051048f, 0.00893906f, 
    -0.03216457f, 0.00339822f, 0.05484615f, 0.04667764f, -0.00005955f, -0.03065223f, -0.01126642f, 0.05057549f, 
    -0.04871970f, 0.03503434f, -0.02594801f, -0.02419576f, -0.05820642f, 0.00741711f, 0.03025351f, -0.02523385f, 
    -0.02400190f, 0.02405669f, -0.02536901f, -0.04453405f, 0.01315480f, 0.03053163f, -0.04217977f, -0.02947239f, 
    -0.01984260f, 0.00506026f, -0.02039491f, 0.03333291f, 0.05022939f, -0.05774259f, 0.03257877f, 0.01450042f, 
    0.05798894f, -0.01171773f, 0.04386963f, 0.03626626f, -0.01031184f, -0.04915183f, 0.00208306f, -0.00968658f, 
    0.05260834f, 0.02473963f, -0.04331713f, -0.02849738f, 0.02450996f, 0.00475536f, -0.02619887f, -0.00229501f, 
    -0.02962919f, -0.04277238f, -0.05688498f, 0.02630726f, -0.04226888f, 0.02226717f, -0.05172661f, 0.04777205f, 
    -0.03034038f, -0.02339440f, -0.00300837f, -0.00451011f, -0.04019382f, 0.01525874f, -0.04856532f, 0.03831396f, 
    -0.02126837f, -0.01880914f, 0.01548056f, -0.04747790f, 0.01212832f, 0.05454753f, 0.00084461f, 0.01127259f, 
    -0.01345707f, -0.05871992f, -0.05296724f, -0.02155051f, -0.03353266f, -0.01560487f, 0.03631394f, -0.03735018f, 
    0.04980678f, -0.01626830f, 0.03330110f, -0.03708809f, 0.03201106f, -0.03536165f, 0.04665868f, -0.02252115f, 
    -0.05730695f, -0.02626202f, 0.04009842f, -0.01873622f, -0.05058143f, 0.04667261f, 0.01577843f, -0.00628469f, 
    0.00996492f, -0.00826725f, -0.01359576f, 0.01149168f, -0.01689145f, -0.04363564f, -0.01194667f, -0.04004726f, 
    0.03810291f, -0.04899936f, -0.04736741f, 0.00454399f, -0.00626612f, -0.05720308f, -0.03671563f, -0.01008792f, 
    0.05089689f, 0.04635121f, 0.03106889f, -0.02383174f, -0.01020932f, -0.01365218f, 0.00575840f, 0.01238895f, 
    0.05334747f, -0.06374161f, 0.00925730f, 0.03156821f, -0.05380983f, 0.04194847f, 0.04025671f, 0.03822442f, 
    0.03501707f, -0.00730956f, -0.04697342f, -0.02078604f, -0.05894163f, -0.02786479f, -0.05669317f, 0.05392082f, 
    -0.04459749f, 0.04792500f, -0.03666845f, 0.03798555f, -0.03452453f, 0.02541077f, 0.02703672f, 0.01851656f, 
    -0.05830497f, -0.05857877f, -0.03457003f, -0.02351521f, 0.02432325f, -0.04406349f, -0.03178477f, -0.01289580f, 
    0.03156082f, 0.01628489f, 0.04406523f, 0.02001669f, -0.04724929f, 0.00319304f, -0.06147903f, 0.02276057f, 
    0.04926320f, 0.02120158f, -0.00290124f, 0.04221551f, -0.01533288f, -0.00881136f, 0.01111784f, -0.03504494f, 
    -0.03666411f, 0.04737484f, -0.01408288f, -0.03118240f, -0.05774344f, -0.01143156f, 0.02728950f, 0.03871569f, 
    0.03530392f, -0.00219403f, -0.04981107f, -0.00064120f, -0.00352447f, 0.01530106f, -0.03333147f, -0.04164905f, 
    -0.01033155f, -0.01061808f, 0.02846796f, -0.02945250f, -0.01120513f, -0.06332721f, -0.03519220f, -0.02764525f, 
    0.01990232f, -0.01238986f, 0.04921627f, 0.03121457f, -0.02434514f, 0.00096151f, -0.05655825f, -0.03518686f, 
    -0.02420015f, -0.02489519f, 0.03601947f, -0.02466135f, 0.03589581f, -0.00413350f, 0.04244539f, -0.05692300f, 
    0.04335663f, -0.01246803f, -0.04943658f, -0.05763234f, -0.01821155f, -0.01856275f, 0.02164890f, -0.01623810f, 
    -0.05377667f, -0.05903367f, -0.02917899f, -0.05659071f, -0.05474808f, 0.04198641f, 0.05147704f, 0.01398542f, 
    -0.05498653f, 0.04410710f, -0.03057555f, -0.06289180f, -0.01767962f, 0.05328117f, 0.04264541f, 0.01086721f, 
    0.00251982f, 0.02060603f, -0.01381608f, -0.05794736f, 0.01113988f, -0.05011479f, 0.00799613f, 0.04177155f, 
    -0.01501128f, -0.03421312f, -0.01603867f, -0.04651803f, 0.04785205f, -0.05263464f, 0.00393385f, 0.02004059f, 
    -0.04878097f, -0.03286530f, -0.02087307f, 0.03488295f, 0.03989389f, 0.01705259f, -0.01123161f, -0.01385961f, 
    -0.02730581f, 0.00584994f, 0.00067410f, -0.03182731f, -0.00891167f, -0.05956031f, 0.03361740f, -0.05964883f, 
    0.01548004f, 0.00134666f, 0.03782931f, 0.03631365f, -0.04872994f, 0.02646355f, -0.00457767f, -0.02203433f, 
    -0.01603387f, -0.03964575f, -0.02322757f, -0.01568694f, -0.05218821f, -0.04487813f, -0.02917554f, -0.02692420f, 
    -0.05085476f, -0.06222191f, -0.00546832f, 0.05257627f, -0.05988782f, -0.03115432f, -0.03082454f, 0.03308814f, 
    0.00613088f, -0.02761718f, -0.00998640f, -0.02592909f, 0.02612360f, -0.05420481f, -0.03464906f, -0.02219440f, 
    -0.02198262f, 0.04083605f, 0.05147132f, -0.00005409f, -0.05423565f, -0.03960903f, 0.02113033f, 0.04574089f, 
    -0.02352488f, 0.03610458f, -0.02766661f, 0.04876990f, -0.01616001f, -0.02781025f, 0.02827692f, 0.04107642f, 
    0.03267750f, -0.05761327f, -0.03161781f, 0.03654315f, -0.02119596f, 0.02255697f, 0.04535306f, -0.02928248f, 
    0.00424449f, 0.02717606f, 0.04935365f, -0.05441033f, -0.01380140f, 0.01041753f, 0.02163098f, 0.01054080f, 
    -0.01219820f, -0.00814323f, 0.03311654f, -0.00240210f, 0.04171534f, -0.05816916f, -0.03617356f, -0.04527009f, 
    -0.06239366f, 0.03547387f, 0.04869580f, -0.00343624f, -0.00723189f, 0.04242980f, -0.02490958f, -0.01824372f, 
    -0.05312166f, -0.05454842f, -0.02981441f, 0.05226989f, -0.03408862f, -0.01924278f, 0.04855030f, -0.01559798f, 
    -0.06070391f, -0.03121617f, 0.02517304f, 0.04052313f, 0.01986520f, -0.04429395f, -0.03895644f, -0.05188162f, 
    0.03667154f, 0.01663779f, -0.00304761f, -0.00538096f, -0.05940513f, 0.02660146f, 0.04986165f, 0.00107699f, 
    0.01018331f, -0.05434776f, 0.03761234f, -0.02115344f, 0.02285457f, 0.00939830f, 0.00918806f, 0.00868579f, 
    -0.00071883f, 0.02434580f, -0.05886411f, -0.05439538f, 0.01544840f, -0.03223546f, 0.02669865f, -0.00252389f, 
    -0.03870029f, 0.02957398f, 0.03160269f, 0.03134480f, 0.01313991f, 0.01899386f, 0.03761962f, 0.04144449f, 
    -0.18181883f, 0.05228024f, 0.20741910f, -0.02071598f, 0.12106175f, 0.01685100f, 0.06932206f, 0.01586871f, 
    0.14027989f, 0.21209346f, 0.06996953f, 0.09541891f, 0.13361332f, -0.06225962f, 0.05089116f, -0.02242590f, 
    0.08181201f, 0.06384217f, -0.32988393f, 0.17816229f, 0.05839555f, -0.02723788f, 0.09986363f, 0.17986123f, 
    -0.00850341f, -0.01700721f, 0.14541751f, -0.16279076f, -0.13866889f, -0.16601361f, 0.09191696f, 0.05460065f, 
    -0.03630910f, 0.05146990f, 0.14062274f, -0.02981418f, 0.18807191f, 0.10433063f, -0.08977041f, -0.02226157f, 
    0.03361489f, 0.04102432f, 0.03866773f, 0.08137684f, 0.00398954f, -0.28166121f, -0.23279998f, -0.07246552f, 
    0.01204180f, -0.06665286f, 0.03475170f, 0.06466112f, -0.07731311f, 0.00593868f, 0.14454734f, -0.07019950f, 
    0.02648891f, 0.03636115f, 0.13404934f, -0.00244309f, 0.03552262f, -0.00352671f, 0.02535250f, -0.00297484f, 
    -0.02435279f, -0.09183873f, -0.01147191f, 0.15964030f, 0.02988830f, -0.07139511f, 0.07305273f, 0.01749790f, 
    0.16675235f, -0.04230248f, -0.11903787f, 0.17458193f, -0.05991915f, 0.13133709f, -0.00296785f, 0.15772118f, 
    0.05716560f, 0.19052203f, -0.08638091f, -0.01511475f, 0.10155696f, 0.05450704f, 0.03580389f, -0.11044451f, 
    0.04457517f, -0.00045943f, -0.18968080f, -0.10774970f, 0.36238661f, 0.07279052f, -0.08115922f, 0.10668866f, 
    -0.04808196f, -0.00583546f, 0.29979813f, -0.27274933f, -0.06579163f, 0.01767118f, 0.07700566f, 0.12357259f, 
    0.01613977f, -0.20919169f, -0.15054263f, -0.01150092f, -0.00701395f, -0.00302156f, -0.01745650f, -0.00411699f, 
    0.10010786f, 0.00525487f, 0.09157117f, 0.09295321f, 0.02103575f, -0.41484162f, 0.06998327f, 0.06292731f, 
    0.10119466f, 0.17200702f, -0.10196409f, 0.05508734f, 0.03979938f, 0.01175034f, 0.34359491f, -0.03418608f, 
    -0.04214766f, -0.00842242f, -0.02795979f, -0.04599084f, 0.03596742f, 0.02336057f, 0.09549988f, 0.25567737f, 
    -0.18712863f, -0.07227277f, -0.05998840f, -0.09881970f, 0.13716203f, 0.00207439f, 0.09435783f, -0.01995743f, 
    0.05837461f, -0.09260576f, -0.04161827f, 0.08935247f, 0.11415672f, -0.00036523f, 0.01826664f, 0.09434532f, 
    -0.04616481f, 0.04959881f, -0.13393556f, 0.11966087f, 0.08720835f, -0.01044035f, -0.01608707f, 0.03406992f, 
    0.01898555f, -0.14030950f, -0.53260547f, -0.26026919f, -0.02461096f, 0.05591182f, -0.22688025f, -0.04534506f, 
    -0.10122003f, -0.04023265f, -0.09338922f, -0.06769396f, 0.09238483f, -0.02171071f, 0.15751565f, -0.02077836f, 
    0.13012481f, -0.01861924f, 0.03429887f, 0.01678647f, -0.04104505f, 0.10457238f, 0.15009178f, 0.10792976f, 
    -0.07446810f, 0.00592499f, -0.02088529f, 0.15062703f, -0.02870112f, 0.18044786f, 0.06835648f, -0.10214958f, 
    0.12238239f, 0.08257019f, 0.12392796f, -0.06538694f, 0.10702464f, 0.04954360f, -0.06248282f, 0.01223031f, 
    0.11139157f, 0.28105056f, -0.06821144f, 0.00322024f, -0.14183784f, 0.12856811f, 0.03724285f, 0.19765243f, 
    0.11980431f, 0.16484518f, 0.21218964f, -0.05475008f, 0.06114678f, -0.17659399f, 0.06045032f, 0.15467623f, 
    0.04975742f, 0.06400162f, 0.03622917f, 0.14789844f, -0.14215036f, -0.05791281f, -0.06187682f, -0.03142448f, 
    0.08906817f, -0.35090545f, -0.11906374f, -0.30820364f, -0.07240375f, -0.01706472f, -0.09273148f, 0.12771897f, 
    -0.13107736f, 0.02151762f, -0.21435395f, -0.29853526f, 0.29936582f, -0.05069190f, 0.02609300f, -0.04737671f, 
    0.05614164f, -0.09312531f, -0.03525657f, -0.05456527f, -0.18632044f, 0.02941890f, 0.04525045f, 0.06201908f, 
    0.02689362f, 0.11428066f, -0.03268540f, -0.12118343f, 0.17690480f, 0.00855972f, -0.11605237f, -0.13879848f, 
    0.13785075f, -0.18775424f, -0.08689010f, -0.05503207f, -0.14330629f, -0.24075755f, -0.05395560f, -0.09600525f, 
    -0.08603916f, -0.21235712f, -0.01055001f, 0.02090380f, -0.05814030f, 0.12563120f, -0.23545805f, -0.33320075f, 
    -0.05675080f, -0.10927858f, -0.00612167f, -0.10976436f, 0.09487742f, 0.10486342f, -0.03861961f, -0.51020813f, 
    -0.27892572f, 0.11818409f, -0.11074147f, -0.16429895f, -0.01852307f, 0.07953789f, -0.07382735f, -0.02631579f, 
    0.00424590f, -0.01285318f, 0.02620012f, -0.01998825f, -0.02904585f, -0.05685520f, -0.03480640f, -0.04804539f, 
    -0.04165560f, -0.01828594f, -0.07063518f, 0.01704950f, -0.03606134f, 0.03295141f, 0.00985338f, -0.00069311f, 
    0.02223646f, -0.01776622f, 0.04396253f, -0.04652458f, -0.00382937f, -0.05146137f, 0.04696640f, -0.01029147f, 
    -0.03520406f, -0.04287593f, 0.03100549f, -0.06544793f, 0.01803183f, 0.03113731f, 0.02946992f, 0.00990737f, 
    -0.01235556f, 0.01309280f, -0.04785436f, 0.02857777f, 0.01064998f, -0.05406745f, -0.03830135f, 0.01163868f, 
    0.04097610f, 0.03972309f, 0.05044418f, 0.01903662f, -0.03128540f, -0.03885038f, -0.01054170f, 0.03749071f, 
    -0.03473490f, 0.00410939f, 0.01008780f, -0.01554897f, 0.00150474f, -0.04964260f, 0.03278146f, -0.00297881f, 
    -0.06218697f, 0.02168156f, -0.01189407f, -0.06589317f, -0.01813278f, 0.03257472f, -0.03252984f, 0.03671512f, 
    -0.03078536f, -0.06490891f, -0.04614223f, -0.06240794f, -0.00164056f, -0.06178827f, -0.05482551f, 0.02094350f, 
    -0.01406788f, -0.01221254f, -0.05414834f, 0.03188981f, -0.03507228f, 0.03777235f, 0.03172904f, 0.03612552f, 
    -0.05366370f, -0.05761115f, 0.00389488f, 0.04193036f, 0.00179075f, 0.02113583f, -0.05960982f, -0.02686031f, 
    -0.07017361f, -0.02770228f, -0.01148777f, 0.00385775f, -0.02726866f, -0.04106310f, -0.04452122f, 0.02779279f, 
    -0.03321571f, 0.03390836f, -0.03203368f, -0.03731437f, -0.06097760f, 0.02796280f, 0.02034504f, -0.00165938f, 
    -0.06133833f, 0.02979848f, -0.02838095f, 0.01422324f, -0.00318912f, -0.02661319f, 0.03774486f, -0.06314721f, 
    -0.00842245f, 0.01904243f, 0.01525255f, -0.00023556f, 0.04008614f, 0.03900723f, -0.03988393f, -0.05708862f, 
    0.04584726f, 0.02812506f, -0.04196065f, 0.04597211f, -0.01963462f, 0.02771411f, -0.02832886f, -0.04577361f, 
    0.01198980f, 0.01006608f, 0.04509296f, 0.02004343f, -0.01492494f, 0.01589892f, 0.00839000f, -0.02198478f, 
    -0.03826371f, -0.02652751f, -0.01829947f, 0.05044205f, -0.02806557f, 0.00479199f, 0.03173745f, 0.03279001f, 
    -0.04770835f, 0.02128633f, 0.00483892f, 0.01966123f, 0.02936749f, -0.00501365f, -0.05405309f, 0.03361849f, 
    0.02110317f, -0.03872106f, -0.01214543f, 0.00594902f, -0.00014119f, 0.04957056f, -0.04732234f, -0.00332304f, 
    -0.02304139f, 0.04668320f, 0.03873343f, -0.00323404f, 0.05113335f, -0.03624113f, 0.03588671f, -0.04182642f, 
    -0.03690493f, -0.02531542f, -0.01799974f, -0.00574688f, -0.04462836f, -0.06530085f, -0.05695580f, 0.03600219f, 
    -0.06857328f, 0.03802348f, 0.02332718f, -0.03819349f, 0.05271839f, -0.03807222f, 0.01813415f, 0.03289539f, 
    0.03129836f, 0.03657077f, 0.03793860f, 0.00977919f, 0.04414332f, -0.00466743f, 0.01940978f, 0.02684609f, 
    0.02010348f, -0.06273939f, 0.03538550f, 0.01034916f, -0.06261367f, -0.04920931f, -0.01411699f, -0.06053760f, 
    0.00209585f, -0.04651879f, -0.01496901f, -0.03196000f, 0.04073720f, -0.05018731f, -0.03396831f, -0.05039202f, 
    -0.00131295f, -0.06722749f, -0.00450848f, 0.01810202f, 0.01744131f, 0.04812624f, -0.01228756f, -0.00559316f, 
    0.00168266f, -0.02560032f, -0.05015601f, -0.04698185f, -0.04517828f, -0.00357043f, 0.01513460f, -0.05320096f, 
    -0.04886632f, 0.04265446f, 0.00486909f, 0.02714265f, 0.01504656f, -0.01836092f, 0.04320724f, -0.05841713f, 
    0.03972350f, -0.01269843f, 0.01021745f, 0.05037309f, -0.02723044f, -0.02454004f, -0.03547974f, 0.00403286f, 
    0.03039383f, -0.04841327f, -0.00669255f, 0.03247689f, -0.02872960f, -0.01384625f, 0.03943724f, 0.03498712f, 
    0.04211186f, 0.02362362f, -0.05879055f, 0.04536315f, 0.04213182f, 0.01487587f, -0.01193234f, -0.05192227f, 
    -0.00678849f, 0.02259228f, -0.00206208f, 0.02905736f, 0.04529943f, 0.00556424f, -0.02475776f, 0.03770716f, 
    -0.06938186f, -0.02835343f, -0.01781821f, -0.05930409f, -0.04099436f, -0.04745984f, -0.05032198f, -0.01398213f, 
    -0.05428639f, -0.01365409f, 0.00210412f, -0.05173336f, -0.07203151f, -0.02608289f, -0.03213793f, 0.01828790f, 
    0.01115411f, -0.00278706f, 0.01406779f, -0.00111667f, -0.05218408f, -0.00482265f, 0.02688073f, 0.03656990f, 
    0.06076470f, 0.10623465f, 0.11356539f, 0.05714718f, -0.04485411f, -0.01260952f, -0.06138018f, -0.05992531f, 
    0.01298773f, 0.03885516f, -0.11868998f, -0.24678060f, 0.02924232f, 0.15180515f, 0.04704460f, -0.04850436f, 
    0.06683710f, -0.04781090f, 0.10185174f, 0.04350540f, 0.11075027f, 0.02707506f, 0.00855287f, -0.07566183f, 
    0.05336888f, 0.07233271f, -0.10430993f, 0.23590983f, -0.43962744f, -0.03670377f, -0.09803064f, 0.05771927f, 
    -0.00954522f, 0.06864338f, -0.06095056f, -0.08234672f, -0.18410584f, 0.04390834f, -0.10242835f, 0.03164424f, 
    0.11008804f, 0.06290109f, 0.04910298f, 0.09924912f, -0.07204244f, 0.18767129f, -0.16214812f, -0.01981360f, 
    -0.04254242f, 0.06427617f, 0.04478331f, 0.05027776f, -0.03813656f, -0.05004597f, 0.00018168f, 0.27999133f, 
    0.08425017f, 0.06399320f, 0.10886488f, -0.07022218f, -0.01296728f, 0.02485879f, -0.12202267f, -0.02743056f, 
    0.05409377f, 0.11291631f, 0.04079652f, -0.11810117f, -0.00926667f, 0.09144783f, 0.03652513f, 0.09676377f, 
    -0.00276381f, 0.26136443f, -0.01095386f, 0.05881834f, 0.16837645f, -0.16331492f, -0.01233931f, 0.05751179f, 
    0.02844818f, -0.07229160f, 0.12689471f, 0.06137656f, -0.10974380f, 0.03678409f, -0.07389706f, 0.12710369f, 
    -0.00470184f, 0.06167268f, 0.01967083f, -0.00610875f, -0.15098736f, 0.06781726f, 0.09319644f, -0.00770575f, 
    0.07925654f, -0.04178225f, -0.13468271f, -0.04688491f, -0.09783687f, -0.36634919f, 0.07618662f, -0.00071302f, 
    0.00157962f, -0.10295440f, 0.08288373f, -0.16742842f, 0.18361092f, -0.14176984f, 0.27979282f, 0.04239990f, 
    -0.00479835f, -0.06183114f, -0.03295596f, 0.00690617f, 0.03299664f, 0.22973527f, -0.00852224f, 0.12362047f, 
    0.14120492f, -0.04572112f, -0.13637708f, -0.05077548f, 0.01924983f, 0.00451776f, -0.13915941f, -0.14895076f, 
    -0.41236460f, 0.01329694f, -0.05074392f, 0.10055301f, -0.09834115f, 0.00902038f, 0.06196504f, -0.45364010f, 
    -0.14247067f, -0.01611801f, -0.19819924f, -0.01702143f, 0.12623216f, -0.02139988f, -0.04247647f, 0.12204833f, 
    0.07267935f, 0.05885959f, -0.03045546f, 0.01198809f, 0.07741843f, 0.10557526f, 0.14008561f, -0.16193244f, 
    -0.05263663f, -0.29521003f, -0.20439045f, 0.09297036f, 0.05247798f, -0.11873753f, -0.09596906f, -0.05277484f, 
    -0.07031792f, 0.04525359f, 0.17324133f, 0.11250383f, 0.11021595f, -0.08833184f, 0.03365943f, -0.10222989f, 
    0.03191190f, 0.05458054f, 0.03991646f, 0.01782949f, 0.16407505f, 0.01367235f, -0.24521510f, -0.08484544f, 
    -0.07304529f, 0.07244768f, 0.21276425f, -0.00692989f, 0.18381608f, 0.35073337f, -0.09212033f, 0.01060160f, 
    -0.08620284f, -0.03659733f, 0.08704092f, 0.08934940f, 0.01705504f, -0.17378777f, 0.14849102f, -0.05146670f, 
    -0.06336449f, 0.13038926f, -0.01728220f, 0.11176883f, 0.05951598f, -0.04526043f, 0.47788838f, -0.02780166f, 
    -0.19117433f, 0.09564475f, -0.10222469f, -0.01044857f, -0.00675331f, -0.07058525f, -0.03230434f, -0.03805898f, 
    -0.10827143f, -0.32110879f, 0.02837037f, -0.02367989f, 0.11678600f, -0.06925163f, 0.01678703f, -0.06037629f, 
    0.33088100f, -0.18211718f, -0.18906794f, 0.11872191f, 0.14526089f, -0.08570676f, -0.09609275f, -0.02219993f, 
    0.12724236f, 0.04330847f, -0.20825192f, 0.16814099f, 0.04693420f, 0.07443420f, 0.00270145f, 0.00741034f, 
    -0.08647742f, 0.06537257f, -0.03792332f, -0.11918633f, -0.00131812f, 0.13884284f, 0.07235087f, 0.04102445f, 
    -0.10239171f, 0.00554245f, -0.05821631f, -0.26243418f, 0.07623573f, -0.14733981f, 0.07056326f, -0.13315521f, 
    -0.01837981f, 0.09917360f, -0.04171147f, 0.05930310f, -0.34230280f, 0.29783940f, 0.06525008f, -0.06567930f, 
    -0.20859003f, -0.11282889f, 0.01072622f, 0.00502107f, -0.13422459f, -0.05904640f, -0.13105758f, -0.05144233f, 
    0.02005547f, -0.02547690f, 0.00011325f, 0.03388658f, 0.11679714f, -0.08741336f, 0.16968092f, -0.07082982f, 
    0.17556916f, 0.19119771f, -0.03337457f, -0.03157081f, 0.00621453f, -0.04836677f, 0.10462733f, -0.01545706f, 
    -0.27353391f, 0.05202501f, 0.08914509f, -0.06447430f, 0.01440348f, -0.09796325f, -0.04793722f, 0.07058534f, 
    -0.03271872f, 0.01724338f, -0.08420185f, 0.00759328f, -0.01174240f, -0.06150387f, -0.08171283f, -0.04400345f, 
    -0.01926313f, 0.00289320f, 0.08107931f, 0.00380616f, -0.02362394f, 0.02029799f, -0.08586122f, 0.01513486f, 
    -0.03590157f, 0.02556326f, -0.02494993f, -0.08533696f, 0.00117770f, 0.00670966f, -0.02575776f, -0.03180827f, 
    -0.05327411f, -0.01370645f, -0.04056072f, -0.01720160f, -0.03109533f, 0.01885040f, 0.01425771f, -0.08583897f, 
    0.01698062f, -0.03773817f, -0.02237645f, 0.02605606f, 0.02402451f, -0.04563848f, -0.02506138f, -0.01704131f, 
    -0.04702467f, -0.02115877f, -0.01912987f, -0.07450915f, 0.02237659f, -0.05523848f, -0.06554310f, 0.00364132f, 
    0.02060134f, -0.03978622f, -0.08341084f, -0.03842057f, -0.01501957f, 0.02623251f, 0.01772339f, -0.00812867f, 
    -0.01136584f, -0.07746325f, -0.05788106f, -0.03616106f, -0.05830909f, -0.03576861f, -0.03876888f, 0.00624515f, 
    -0.02901002f, 0.04588047f, 0.01244525f, -0.01351963f, -0.02826539f, 0.03856475f, 0.00533122f, -0.00105862f, 
    -0.05071234f, -0.04183372f, 0.00015688f, 0.00030747f, -0.03241696f, -0.06097350f, -0.07867344f, -0.02849404f, 
    0.03450991f, -0.04773807f, -0.07689185f, 0.03949095f, 0.01875606f, 0.01369320f, 0.01072813f, -0.02345902f, 
    0.00963239f, 0.01181061f, 0.01766047f, 0.02225973f, -0.01797621f, -0.07496524f, 0.02621082f, -0.04326867f, 
    0.02281026f, 0.01788140f, -0.07345834f, -0.02307312f, -0.06019518f, -0.03347613f, -0.00390675f, -0.07075899f, 
    -0.03616156f, 0.01779381f, 0.00410437f, -0.02569857f, -0.00708544f, -0.08352289f, -0.03239381f, -0.03837751f, 
    -0.06307427f, -0.07990038f, -0.00932088f, -0.02754826f, -0.00341592f, -0.05449421f, 0.01592550f, -0.08069415f, 
    -0.01118792f, 0.02206863f, 0.03501015f, -0.08047350f, -0.01950986f, -0.01060535f, -0.04460955f, -0.01235157f, 
    -0.05070549f, -0.02365582f, -0.05577318f, 0.02902836f, -0.04590305f, -0.05654235f, -0.01266862f, 0.02005228f, 
    -0.06170127f, -0.07307217f, -0.04662603f, -0.06138815f, -0.04881004f, -0.02775834f, -0.07889356f, -0.07620155f, 
    -0.06552438f, -0.07848847f, -0.02983858f, -0.05785004f, -0.05516271f, -0.04448258f, -0.06725274f, -0.02494294f, 
    -0.04467568f, 0.01225941f, -0.03971532f, 0.01780904f, -0.05986769f, -0.00140603f, 0.02009557f, 0.01582879f, 
    0.01737939f, 0.01839077f, 0.02102499f, -0.07933756f, 0.00668656f, 0.01490567f, -0.01433265f, -0.01075134f, 
    -0.06045898f, -0.00275900f, 0.01407472f, -0.05624881f, -0.07553143f, -0.04490945f, -0.01152591f, -0.04520571f, 
    -0.04372748f, -0.03901500f, 0.00522713f, -0.06898230f, 0.01739914f, -0.01200437f, -0.04552234f, 0.03081876f, 
    -0.00424575f, -0.06510380f, 0.04592331f, -0.04106339f, -0.03119149f, 0.03424209f, -0.01058465f, 0.00718472f, 
    -0.01268054f, -0.05354859f, 0.01578884f, -0.09219959f, -0.03759339f, -0.05850665f, -0.05899028f, 0.03064450f, 
    -0.01152780f, -0.05761665f, 0.00308844f, -0.01816650f, 0.02440221f, -0.04781070f, -0.03392644f, -0.04479618f, 
    -0.01345874f, 0.03737892f, 0.00365393f, -0.01904175f, -0.03454364f, -0.01228117f, -0.04361479f, 0.03626933f, 
    0.03310142f, 0.01052857f, -0.01129983f, -0.00364204f, -0.07790099f, -0.08698907f, -0.05309241f, -0.00212144f, 
    -0.04847593f, 0.04015385f, 0.00017944f, -0.05513731f, -0.06393497f, -0.09575269f, -0.08016907f, -0.05704035f, 
    -0.01764212f, 0.03224591f, 0.02759122f, -0.02201384f, -0.04077511f, -0.02322118f, 0.05077731f, -0.07949039f, 
    0.02407877f, -0.02750349f, -0.00871422f, -0.09623870f, -0.00692007f, -0.05576136f, 0.01149835f, -0.02437785f, 
    -0.02993143f, -0.04050128f, -0.05301701f, -0.01706441f, 0.00325398f, 0.03816934f, 0.00562765f, -0.04101844f, 
    -0.01684340f, -0.07838591f, 0.00604997f, -0.02731019f, 0.01840754f, -0.05492548f, -0.06687635f, -0.05415747f, 
    0.00432227f, 0.05194530f, 0.02653960f, -0.08529782f, -0.06422517f, -0.00780761f, -0.01232889f, -0.02739938f, 
    -0.08898025f, -0.06773564f, -0.03903398f, -0.01887512f, -0.04358966f, -0.05232443f, -0.03050208f, 0.01381573f, 
    -0.01017139f, -0.07482782f, -0.05052051f, -0.00210678f, 0.02918169f, 0.00711905f, -0.00453337f, -0.03127706f, 
    -0.01615729f, -0.02100101f, -0.03410741f, 0.07198087f, -0.01429619f, -0.02301576f, 0.05243584f, -0.01732698f, 
    -0.04520616f, 0.04823002f, -0.06468771f, -0.05288794f, 0.03542679f, 0.00978361f, -0.01306939f, 0.04864720f, 
    0.01089520f, 0.01106054f, -0.03915548f, -0.00235384f, -0.00664912f, 0.03593737f, 0.01801641f, 0.00358063f, 
    -0.01816952f, 0.02285207f, 0.01203373f, -0.00875927f, -0.05567308f, -0.02034594f, 0.00820902f, -0.07551227f, 
    -0.04824251f, -0.01557549f, -0.04660064f, -0.03468196f, 0.01301259f, -0.04645636f, 0.00232519f, -0.05696846f, 
    -0.02600872f, 0.02412026f, -0.01788742f, -0.02906176f, 0.01571478f, 0.03672595f, -0.04890693f, -0.03241041f, 
    -0.05086364f, 0.03182248f, 0.01936020f, -0.04935274f, -0.01089003f, -0.02907055f, -0.04975134f, -0.01809463f, 
    0.03715640f, 0.02272668f, -0.04773253f, -0.00437586f, -0.01559389f, 0.00751501f, -0.05789234f, 0.04700258f, 
    0.00516358f, -0.03716484f, 0.00987604f, -0.04315373f, 0.03734211f, 0.01217563f, -0.02826758f, 0.05117979f, 
    0.00337625f, 0.03751490f, 0.01499819f, 0.00316792f, 0.01316470f, -0.00059434f, 0.03793281f, -0.07738215f, 
    0.03636228f, -0.03747002f, -0.01259232f, 0.02342211f, -0.01759537f, 0.02124854f, 0.07488941f, 0.03733114f, 
    0.02973008f, -0.00845245f, -0.01268195f, 0.03661955f, -0.06510614f, 0.00699157f, 0.04195631f, -0.01569428f, 
    0.06762297f, 0.03002938f, -0.01486783f, 0.00235533f, 0.01677634f, 0.00193522f, -0.00010971f, 0.02825821f, 
    0.01240512f, 0.00152159f, -0.03778188f, -0.04919009f, -0.06645156f, 0.04318845f, -0.05052802f, -0.06672227f, 
    0.02710750f, -0.02928168f, -0.08559082f, -0.06963296f, -0.08234100f, -0.03662152f, 0.01415787f, 0.03716490f, 
    -0.04946624f, 0.04713209f, -0.03048023f, -0.01313244f, -0.06589380f, 0.00401321f, -0.01956886f, -0.06134217f, 
    -0.01333126f, -0.00985634f, -0.05757416f, -0.03854065f, -0.03080040f, 0.02922687f, 0.03799285f, -0.03238788f, 
    -0.03752861f, 0.01514353f, -0.03860957f, 0.02562831f, -0.05187663f, 0.00653662f, -0.00159372f, -0.00929132f, 
    -0.01357594f, -0.03200938f, -0.00049895f, 0.04996514f, 0.00954346f, 0.05522385f, -0.03074822f, -0.00486285f, 
    0.02083933f, -0.05692031f, -0.04826440f, -0.00768965f, -0.01342522f, -0.01245265f, -0.02985825f, -0.04543138f, 
    0.01832997f, -0.06997638f, -0.02903550f, -0.02348554f, 0.05773332f, 0.00168284f, 0.01847868f, 0.03553749f, 
    0.01334978f, 0.03195607f, -0.03692758f, 0.04940650f, 0.06099800f, 0.00443127f, 0.01514793f, -0.02163858f, 
    -0.00734637f, 0.04244917f, -0.08980229f, -0.07891887f, -0.00230246f, -0.05255129f, 0.00025639f, 0.03211117f, 
    0.02687131f, 0.03743437f, 0.05780664f, 0.02131833f, -0.00741189f, -0.06764576f, 0.03465988f, -0.06961254f, 
    -0.03528281f, 0.01753905f, 0.04885211f, -0.03234291f, -0.03214650f, -0.05273505f, 0.04837690f, 0.00888256f, 
    -0.05854834f, 0.03850221f, -0.01657880f, -0.00939632f, -0.03925869f, 0.06258306f, -0.02549157f, -0.04806718f, 
    0.06521975f, 0.00206219f, 0.05819252f, -0.03427962f, -0.02388829f, -0.03966414f, -0.04051688f, 0.04033298f, 
    0.03690662f, -0.01476292f, -0.05361311f, -0.01760274f, 0.02148478f, 0.04793449f, -0.00479749f, 0.05691842f, 
    0.02941262f, -0.06791887f, 0.02838215f, -0.03159638f, -0.00838613f, -0.03181128f, -0.02532948f, -0.04793620f, 
    0.06125447f, -0.01201561f, -0.00863357f, -0.00879078f, -0.02295124f, 0.09493194f, 0.01382061f, -0.02996844f, 
    -0.00875612f, 0.04355139f, -0.04274555f, -0.03989152f, -0.05552422f, -0.02533963f, -0.00258895f, 0.00686852f, 
    -0.04931466f, -0.04158869f, -0.07065855f, -0.06532314f, 0.00026773f, 0.03110469f, -0.06049374f, -0.00618279f, 
    -0.00979844f, -0.05677415f, 0.00539858f, -0.02561023f, -0.02114790f, 0.00823446f, -0.03862999f, -0.04562639f, 
    -0.00612480f, -0.08661866f, -0.06268296f, 0.02111682f, 0.01022576f, -0.06178470f, -0.06982627f, -0.02731755f, 
    -0.04251520f, -0.04896181f, 0.01353928f, 0.03601920f, 0.00391653f, 0.04056684f, -0.03072223f, -0.02466884f, 
    0.06818866f, 0.01983658f, -0.05538183f, -0.02904814f, -0.02404255f, -0.01876491f, -0.03960136f, -0.06555433f, 
    -0.01798194f, -0.02385367f, 0.03796936f, -0.04426182f, 0.00177598f, -0.03484181f, -0.00604294f, -0.01600052f, 
    -0.05263877f, 0.04291571f, -0.02480777f, -0.04570546f, -0.04616855f, -0.03802896f, 0.01552391f, 0.02899146f, 
    0.01879279f, 0.04500521f, -0.02651496f, 0.02211250f, 0.00494200f, -0.03125623f, -0.04660585f, -0.02374079f, 
    0.00054884f, -0.01668393f, 0.02924718f, -0.02407650f, 0.03348471f, -0.04975089f, -0.01527506f, -0.03470792f, 
    -0.00865660f, 0.01264364f, 0.01716579f, -0.03302706f, -0.01569081f, 0.05051544f, -0.04690997f, 0.00826165f, 
    -0.04854998f, -0.02703987f, 0.02179869f, -0.04976362f, -0.02038229f, 0.02226296f, -0.02856405f, -0.03375810f, 
    0.01980889f, -0.03926307f, 0.00708229f, 0.03017536f, -0.00396765f, 0.01390800f, 0.04926522f, 0.02959267f, 
    0.04156999f, -0.03973034f, -0.02867898f, -0.05590038f, -0.01508650f, -0.01892752f, 0.04714560f, -0.02942900f, 
    -0.06276619f, 0.04829493f, -0.01539151f, 0.02400410f, -0.05406399f, 0.01583511f, -0.02514663f, -0.01467023f, 
    0.03522130f, -0.01481309f, -0.01508293f, -0.03696590f, -0.05185568f, -0.04358783f, 0.01183564f, -0.00239584f, 
    0.01317499f, 0.02702199f, -0.00688173f, 0.03213885f, -0.05398794f, -0.02052213f, -0.00407120f, 0.01038441f, 
    -0.05426120f, 0.02246160f, 0.01358191f, -0.01458805f, 0.02928343f, -0.04516861f, -0.03990524f, 0.00705319f, 
    -0.06377644f, -0.05032407f, 0.05019573f, -0.02955550f, 0.03983213f, 0.02127775f, -0.00876850f, -0.01540179f, 
    -0.06187983f, -0.01739023f, -0.03729509f, -0.04278136f, -0.03368926f, -0.00905063f, -0.05925746f, -0.00756842f, 
    -0.05460127f, -0.03521591f, -0.01089272f, -0.04943885f, -0.01492716f, -0.03080714f, -0.00271286f, -0.04729149f, 
    0.00500593f, 0.04728517f, -0.03666188f, 0.02261738f, 0.04319151f, 0.03931254f, -0.06244716f, -0.03298050f, 
    0.03477395f, 0.01958752f, -0.05838360f, 0.02419309f, -0.05665070f, 0.02697157f, 0.01178079f, 0.04404110f, 
    -0.01929113f, 0.03036243f, 0.00379771f, -0.05625221f, 0.02686146f, -0.02736886f, 0.03261193f, -0.03654034f, 
    -0.04814536f, -0.06531356f, 0.02583247f, 0.00228364f, 0.01375023f, -0.00490454f, 0.02093036f, 0.04949744f, 
    0.02044700f, 0.02023816f, 0.01904557f, 0.03980071f, -0.00819141f, -0.01517124f, -0.03593853f, -0.02700928f, 
    -0.02258721f, 0.00895834f, -0.02355207f, 0.01356733f, 0.02380114f, 0.01463761f, 0.03586128f, 0.00456713f, 
    0.02083658f, 0.03895594f, 0.01804026f, -0.03929852f, 0.00087082f, 0.00371183f, 0.02313188f, -0.00820574f, 
    -0.03996169f, 0.01235421f, -0.01800318f, -0.03650733f, -0.01014972f, 0.04425925f, -0.01292525f, -0.02735584f, 
    -0.03680735f, 0.00381093f, -0.05504085f, -0.03419445f, -0.00779711f, -0.05505737f, -0.02637724f, -0.06344234f, 
    0.03070901f, -0.02227307f, -0.00692427f, -0.05493730f, 0.01167110f, 0.00639574f, -0.03896919f, -0.02355076f, 
    0.03133232f, -0.01751061f, -0.02945217f, 0.05114185f, -0.01393976f, 0.02441746f, 0.00123156f, 0.04260135f, 
    -0.05587626f, -0.03370139f, -0.02952334f, 0.03523761f, -0.02122404f, -0.01565702f, -0.05219207f, -0.04931497f, 
    0.01700088f, -0.03282151f, -0.03357152f, 0.01105122f, 0.03256023f, -0.05746059f, 0.04559204f, -0.02633202f, 
    0.04273197f, -0.03271378f, -0.00767662f, 0.03927812f, 0.04923030f, 0.04624740f, 0.04922060f, -0.01249443f, 
    -0.01775481f, 0.03249159f, -0.03961572f, 0.00513980f, 0.00934454f, 0.00825433f, -0.03414409f, -0.01517882f, 
    -0.05903829f, -0.05366404f, 0.02943577f, -0.04377260f, -0.01643789f, 0.03923519f, 0.03982060f, 0.03501732f, 
    0.02105282f, 0.03674370f, -0.05257678f, 0.00509872f, -0.03821725f, 0.02236329f, -0.00384289f, 0.02779883f, 
    0.02849459f, -0.05753177f, 0.04648140f, -0.02392981f, 0.02920251f, 0.00152524f, 0.03823176f, 0.01663426f, 
    0.02921538f, 0.04121485f, -0.04022231f, 0.03572898f, 0.00435285f, -0.05799214f, -0.02458614f, 0.04955084f, 
    -0.05618476f, -0.02158453f, -0.02404218f, -0.05932075f, 0.01609347f, -0.00318222f, -0.00590004f, 0.04709315f, 
    -0.06240650f, -0.00773076f, 0.04792938f, 0.01359163f, -0.05188525f, 0.02654999f, 0.04473098f, -0.00108624f, 
    0.03127649f, -0.04646950f, 0.04536727f, -0.04455244f, -0.02473596f, -0.02118405f, 0.04361594f, -0.01648645f, 
    -0.05191477f, -0.04780183f, -0.01282573f, -0.05149101f, -0.03927790f, -0.06383233f, -0.05584364f, -0.03548033f, 
    0.02545761f, 0.00018436f, -0.05376190f, -0.06048756f, -0.00108332f, -0.04768226f, 0.04459919f, -0.01433262f, 
    0.00684447f, -0.02988826f, 0.02930699f, 0.04956035f, -0.00850970f, -0.02512530f, -0.05640966f, 0.04153983f, 
    0.00822150f, -0.03621296f, -0.03505157f, 0.03645850f, -0.00981348f, 0.03723625f, -0.02643726f, 0.04638532f, 
    0.04769044f, 0.01073648f, -0.03902021f, -0.06445105f, 0.00553452f, -0.01767632f, 0.00411045f, -0.02136028f, 
    -0.05934127f, 0.04862108f, -0.03355716f, -0.04718991f, 0.01484612f, -0.01260935f, 0.03657521f, -0.00674346f, 
    -0.05706682f, 0.01602422f, -0.01018351f, 0.01395209f, 0.02461056f, 0.04233911f, -0.01183400f, -0.05345235f, 
    -0.05828775f, -0.04944265f, 0.03204674f, 0.02498492f, 0.02287993f, 0.01221698f, -0.04541994f, 0.00120450f, 
    0.01533054f, 0.00115227f, -0.02611041f, -0.00782246f, -0.06066490f, -0.03182741f, 0.01742443f, -0.05609505f, 
    0.03464762f, -0.00181946f, 0.03533540f, 0.01037551f, 0.03742978f, -0.00020696f, -0.01945261f, -0.05112313f, 
    0.01488373f, -0.03624356f, 0.04239807f, -0.06364986f, -0.03730702f, -0.02366324f, 0.03396332f, 0.03570034f, 
    -0.00348759f, 0.01035729f, -0.05984434f, -0.02807927f, -0.01642708f, 0.01651121f, 0.05246451f, -0.01879044f, 
    -0.01912925f, 0.00001195f, -0.02325428f, -0.01017107f, -0.04452262f, 0.00556195f, -0.01214192f, 0.03020301f, 
    -0.03672061f, -0.04104474f, 0.03001389f, -0.02472859f, -0.01564519f, 0.02633316f, -0.03529764f, 0.00435655f, 
    -0.01087179f, -0.02300627f, -0.06417248f, -0.02585817f, -0.05006503f, -0.04335742f, -0.05121078f, -0.03013324f, 
    -0.04821361f, 0.03742877f, -0.02555411f, -0.05769629f, 0.00156254f, -0.03610349f, -0.04503524f, 0.02037248f, 
    -0.04483753f, 0.01187163f, -0.03441791f, -0.02827539f, 0.02836005f, -0.03272073f, 0.02928649f, 0.00658246f, 
    0.01429900f, 0.05264314f, -0.01341884f, 0.00651242f, -0.02560135f, -0.02665529f, 0.04683540f, 0.02123195f, 
    0.00006103f, -0.06390207f, 0.01401455f, -0.06174041f, 0.01113975f, -0.02498168f, 0.03563429f, -0.00235131f, 
    -0.03447979f, -0.05489876f, -0.03428531f, -0.04809628f, 0.03164526f, -0.01399569f, -0.01842312f, -0.03507635f, 
    -0.03608326f, -0.00198533f, 0.03359139f, 0.00652519f, 0.01034433f, -0.01169589f, -0.04184289f, 0.03633235f, 
    0.01648607f, 0.04847341f, -0.01242348f, -0.02284714f, -0.05125391f, -0.01352780f, 0.03278175f, -0.01245670f, 
    -0.00381069f, 0.03457794f, -0.01644029f, 0.00427413f, -0.04059770f, -0.03145200f, -0.03974548f, -0.03159637f, 
    -0.02964582f, -0.05799814f, -0.03332868f, -0.04935523f, 0.01269753f, -0.01041007f, -0.00960822f, -0.01515855f, 
    0.01326185f, -0.03962817f, -0.03353262f, 0.03468707f, -0.00109056f, -0.04458953f, -0.04762699f, 0.04070020f, 
    -0.03313635f, -0.00684505f, 0.03008213f, 0.04503546f, 0.01495947f, -0.04252251f, -0.02750965f, 0.01248805f, 
    -0.02697921f, 0.04845306f, 0.03873912f, -0.01312022f, 0.04849568f, -0.00526385f, -0.04429406f, -0.06330776f, 
    0.00146643f, -0.01928690f, 0.03688517f, -0.00193861f, -0.05803439f, 0.05099525f, 0.00433541f, -0.04515451f, 
    0.03895920f, -0.04860877f, -0.03524959f, 0.02302431f, -0.03297102f, 0.00928672f, 0.02743020f, -0.01373767f, 
    -0.00277757f, -0.04834704f, 0.03612972f, 0.00789343f, 0.00894840f, 0.04208135f, 0.02016596f, 0.04936654f, 
    -0.04751251f, -0.03263058f, -0.05319414f, -0.00282116f, -0.03696913f, -0.00099424f, 0.02573384f, -0.05251877f, 
    -0.00255821f, 0.01859548f, -0.01067927f, 0.03812399f, -0.01484755f, -0.01674222f, 0.02971096f, 0.03241507f, 
    -0.01139163f, -0.04280240f, -0.03091934f, 0.03919698f, -0.05999234f, -0.03590513f, 0.03311814f, -0.02333360f, 
    -0.02929887f, -0.05028946f, -0.02923707f, 0.05211633f, -0.04034388f, 0.04905443f, 0.03896580f, -0.03547811f, 
    0.02015507f, -0.06224001f, -0.05242848f, -0.04394275f, -0.00779990f, -0.00270081f, 0.04261095f, -0.02131340f, 
    -0.20340185f, 0.08344610f, 0.00067274f, -0.09725532f, 0.02905052f, -0.00999548f, 0.00132841f, -0.03393430f, 
    -0.02588081f, 0.07252262f, -0.01063549f, 0.08748548f, 0.02904478f, -0.07554787f, 0.01224886f, 0.10271598f, 
    0.04997239f, -0.02533269f, 0.22095937f, 0.15186781f, -0.25862283f, -0.00953157f, -0.04983680f, -0.02975458f, 
    -0.11908185f, 0.13191183f, 0.05398298f, -0.10136390f, -0.03694552f, -0.01948024f, -0.04379438f, -0.08453457f, 
    -0.07196566f, -0.11188872f, -0.06180546f, -0.05916353f, -0.05252653f, 0.24358511f, 0.19309294f, 0.27530846f, 
    -0.06008841f, 0.07458141f, -0.16593303f, -0.01182850f, -0.06100285f, 0.21836238f, 0.10112120f, 0.00143434f, 
    0.02414060f, 0.04060942f, -0.06396633f, 0.13906035f, -0.00690302f, 0.05736331f, 0.29118761f, 0.11536700f, 
    0.07678687f, 0.05907599f, 0.07156830f, -0.02211008f, 0.26432803f, -0.02159699f, -0.04205394f, 0.04849743f, 
    0.11778815f, 0.16561575f, 0.30323976f, -0.07272077f, -0.03740906f, 0.02444614f, -0.07709582f, 0.05579206f, 
    -0.03076274f, 0.09248339f, 0.07685001f, 0.07053746f, 0.00312058f, -0.04985274f, -0.07683650f, -0.03140292f, 
    0.00689346f, 0.20430520f, 0.02135939f, -0.27732196f, 0.03168704f, 0.07550629f, -0.02515130f, 0.07354083f, 
    -0.04380952f, -0.02335149f, 0.18473378f, -0.04420748f, 0.09440367f, -0.06525923f, 0.08746618f, 0.07401080f, 
    0.04242909f, -0.07453586f, -0.02521434f, 0.27690339f, 0.31901583f, -0.06874830f, 0.05445482f, -0.00047121f, 
    0.02704404f, -0.08247703f, 0.17865343f, -0.05135072f, -0.15760513f, 0.05605235f, -0.05698975f, 0.11494897f, 
    0.00047725f, -0.07023490f, 0.09940036f, 0.04680949f, 0.05522948f, -0.09174160f, -0.16088229f, -0.34535462f, 
    0.16668642f, -0.03331108f, -0.05531769f, 0.16765884f, 0.04806903f, -0.05765845f, 0.14858040f, -0.11682446f, 
    0.09856956f, -0.08158621f, 0.00630640f, -0.15828513f, 0.00578096f, 0.04627846f, 0.05317885f, 0.12512346f, 
    -0.03043020f, -0.08085411f, -0.03408208f, -0.04741444f, -0.00824598f, 0.05103467f, 0.04622591f, -0.01500890f, 
    0.16347694f, 0.12004556f, 0.03436182f, 0.03534408f, 0.01161596f, -0.05530877f, -0.01364996f, 0.03080150f, 
    0.05575627f, 0.11340655f, -0.11537895f, 0.00427394f, -0.25835299f, -0.03206889f, -0.08081251f, 0.01078161f, 
    -0.02532334f, 0.02036291f, -0.10416366f, 0.07263459f, -0.02939985f, 0.10545595f, 0.08878706f, 0.15549049f, 
    -0.10430708f, -0.18916981f, -0.01623191f, -0.06911749f, -0.02098267f, -0.17185000f, 0.09855457f, 0.03815458f, 
    0.10993977f, -0.04310852f, -0.05842960f, -0.13190053f, -0.06371036f, -0.05132814f, -0.02180520f, -0.13423967f, 
    0.14940003f, -0.19250357f, -0.06017859f, -0.00439234f, -0.07157784f, 0.10716024f, 0.22131936f, 0.08887833f, 
    0.04264774f, 0.08963145f, 0.14756621f, 0.00162179f, 0.12268797f, -0.12457140f, -0.01296361f, 0.04829622f, 
    -0.01631267f, -0.28144363f, -0.12210254f, -0.01537834f, -0.04245850f, 0.02788088f, -0.06021821f, -0.27187851f, 
    -0.02112112f, 0.04057504f, 0.08231755f, -0.00364348f, -0.04054184f, -0.00689620f, -0.16126361f, 0.04364018f, 
    -0.06010539f, -0.01074235f, 0.26616314f, -0.09292982f, 0.04304041f, -0.06097274f, -0.03480866f, 0.04433408f, 
    -0.02523457f, 0.24285316f, 0.14528222f, 0.00765481f, 0.00402828f, -0.16345969f, -0.06023210f, -0.07690672f, 
    -0.05583286f, -0.01464167f, 0.27400336f, 0.00811308f, 0.09768117f, 0.06061378f, -0.08182963f, -0.02968200f, 
    -0.00343249f, 0.16295737f, -0.15173000f, 0.01998395f, -0.24150860f, -0.13135627f, -0.14390171f, -0.09878802f, 
    -0.02654123f, 0.01933122f, -0.04604373f, 0.01359397f, -0.01550886f, 0.04805188f, 0.01301791f, 0.05790050f, 
    -0.03929618f, 0.01454038f, -0.07237005f, -0.05179158f, -0.01575673f, 0.12734731f, -0.02386511f, -0.02433065f, 
    -0.02568956f, -0.09809754f, 0.05482779f, 0.06421451f, 0.04046025f, 0.04472757f, 0.04680125f, -0.05505416f, 
    -0.07479325f, -0.10566595f, 0.06242026f, -0.06133807f, -0.02838505f, -0.07955123f, -0.03584884f, -0.38972408f, 
    -0.10528303f, 0.04440890f, -0.01598869f, 0.03400975f, -0.09375378f, 0.00770217f, 0.09866446f, -0.11588565f, 
    0.24219361f, 0.04136031f, -0.04167361f, 0.04411361f, 0.04933223f, 0.25567800f, 0.02944811f, -0.02134864f, 
    0.12925909f, -0.28864825f, 0.12649406f, 0.00745639f, 0.05512444f, 0.09134693f, -0.06905392f, -0.01835903f, 
    -0.02518279f, -0.08872729f, -0.09254752f, -0.01043174f, 0.12715408f, -0.07593463f, -0.01472078f, -0.05687607f, 
    0.16260047f, 0.11336930f, 0.04194839f, 0.01069906f, 0.05836859f, 0.13928932f, -0.08200914f, 0.12687041f, 
    -0.06080726f, -0.01588063f, 0.01174142f, -0.00293810f, -0.06757463f, -0.06875084f, 0.04633990f, 0.13306025f, 
    -0.04394858f, -0.02402241f, 0.08862142f, -0.22827657f, -0.01047820f, 0.01304806f, -0.03566044f, -0.31202498f, 
    -0.00399542f, -0.07372887f, -0.25366780f, -0.00506673f, -0.12291216f, -0.00745006f, 0.19309081f, -0.04716920f, 
    -0.17306636f, -0.11458737f, 0.09388260f, 0.11590286f, 0.01339943f, -0.06240839f, -0.07361660f, -0.07669707f, 
    -0.31759620f, -0.17234339f, -0.08095232f, -0.06080265f, -0.10985596f, 0.03171534f, 0.02049978f, 0.17255817f, 
    0.17977345f, -0.07498281f, -0.18949553f, 0.15925933f, -0.03635431f, 0.04427974f, -0.13110973f, 0.12067263f, 
    0.01892220f, 0.66410667f, -0.17365474f, -0.37672144f, 0.10532326f, 0.08405819f, 0.12794897f, -0.00600209f, 
    -0.06250028f, -0.16279714f, 0.13620080f, 0.09077329f, 0.03540863f, -0.00200953f, -0.01174157f, 0.10231512f, 
    0.10883595f, 0.07291181f, 0.12139288f, -0.24817069f, -0.18088295f, 0.10876624f, 0.19495901f, -0.04560690f, 
    0.00981369f, 0.01086635f, -0.00007020f, -0.05744595f, -0.19278273f, 0.11454804f, 0.33195263f, 0.12208077f, 
    -0.06825291f, 0.04965436f, 0.12513945f, 0.06671085f, 0.05369165f, 0.17626539f, -0.05469659f, -0.31553471f, 
    -0.00578606f, -0.10338946f, -0.02977410f, 0.04086740f, 0.09014867f, 0.05054398f, -0.02949202f, -0.16967134f, 
    -0.07555428f, 0.08046640f, 0.00269903f, 0.06250605f, -0.07720386f, -0.05882850f, -0.01803225f, -0.06098344f, 
    -0.15851961f, -0.09896666f, 0.04099478f, -0.05913860f, -0.17000246f, -0.00438835f, 0.03486941f, 0.10077249f, 
    0.02259090f, -0.05000340f, 0.16772315f, 0.11064610f, 0.05667298f, -0.07915107f, 0.08339189f, 0.06855999f, 
    0.05991329f, 0.01251572f, -0.00327684f, 0.12412713f, -0.04446647f, 0.05362459f, -0.05002806f, 0.06605662f, 
    0.07265677f, 0.08218519f, -0.07088229f, -0.14058858f, 0.08566726f, -0.04572305f, 0.02426563f, -0.13093886f, 
    -0.01463903f, 0.03204967f, -0.03712530f, 0.07219689f, 0.16056576f, 0.12330941f, 0.02853425f, -0.25465676f, 
    -0.06369227f, 0.15306310f, 0.12981343f, 0.16882519f, -0.54852188f, -0.03268734f, -0.04557399f, 0.03470889f, 
    -0.01996309f, 0.05309351f, 0.15670498f, -0.03685231f, -0.02945927f, -0.11046122f, -0.14072014f, -0.11171210f, 
    0.00884401f, 0.03333338f, -0.12255570f, -0.04496834f, -0.04961556f, -0.13172381f, -0.38582712f, 0.07360069f, 
    0.16764574f, 0.07017186f, 0.01266628f, -0.09810131f, -0.03790208f, 0.10072951f, 0.04064133f, -0.15153688f, 
    -0.02385967f, -0.02275725f, 0.02935124f, -0.00818279f, 0.14781989f, 0.04782562f, 0.03552570f, 0.08814636f, 
    -0.51110774f, 0.20539758f, -0.04448065f, -0.07038688f, -0.08080686f, 0.10143325f, 0.07171153f, -0.06114126f, 
    -0.05805851f, -0.39191654f, 0.21384695f, 0.19024442f, -0.20402995f, 0.06206622f, -0.00607346f, -0.09638069f, 
    0.04373803f, -0.07865389f, -0.30850801f, -0.20655666f, -0.28801721f, 0.03510747f, -0.00833747f, -0.00326071f, 
    -0.06949052f, 0.12027992f, -0.03779483f, 0.06455453f, -0.04733865f, -0.05281599f, -0.02219783f, 0.05889305f, 
    0.13956720f, -0.00182948f, 0.13498785f, 0.07916090f, -0.07047888f, -0.16896099f, -0.33666870f, 0.03865676f, 
    -0.16740805f, 0.05755745f, 0.02946613f, 0.02844421f, 0.04495116f, 0.25236574f, -0.15727183f, -0.39957508f, 
    -0.18290593f, -0.17167562f, -0.18106601f, 0.07235061f, -0.09925346f, -0.04492217f, -0.05864213f, -0.13569587f, 
    0.07477411f, -0.00641920f, 0.05768200f, -0.04473350f, -0.19718161f, 0.00993720f, 0.03063091f, -0.24834158f, 
    -0.05729821f, 0.13986167f, 0.15579627f, 0.06568334f, 0.09116143f, -0.10266004f, 0.00769902f, -0.05962915f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.01465430f, -0.00071291f, 0.07431047f, -0.01053556f, -0.10529661f, -0.04610470f, -0.01164297f, -0.02748517f, 
    -0.02165765f, -0.02038456f, 0.08159669f, 0.09411494f, -0.06196653f, -0.02637856f, -0.02060576f, 0.03705568f, 
    0.08791752f, -0.01368833f, 0.14200738f, -0.06148625f, -0.04755856f, -0.02007020f, -0.00401214f, 0.15823098f, 
    0.02909728f, 0.03217120f, -0.05327122f, 0.00258103f, -0.04847832f, 0.00760138f, -0.07155930f, 0.18315879f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.25785732f, 0.14615828f, 0.09767906f, 0.17582589f, 0.11693814f, 0.12275786f, -0.16636592f, -0.08966565f, 
    -0.38026229f, 0.06485763f, -0.26276258f, 0.01807178f, -0.14406505f, 0.10307433f, 0.15245828f, -0.13806731f, 
    0.30097035f, -0.15188335f, 0.01843863f, 0.07545360f, 0.11867052f, -0.11855729f, 0.06560364f, -0.07499965f, 
    0.09772571f, 0.35211042f, 0.17139797f, -0.14164661f, -0.10920563f, 0.08007749f, 0.41057900f, -0.26292270f, 
    -0.10215765f, -0.11031733f, -0.07515557f, 0.06902691f, 0.01734382f, -0.01092116f, 0.04926140f, 0.00623906f, 
    -0.14095089f, -0.00627808f, 0.08654286f, 0.05534400f, 0.05110481f, 0.05112701f, -0.06914523f, 0.12384390f, 
    -0.14875245f, 0.00722390f, -0.14323018f, 0.12363498f, 0.12977543f, -0.07609630f, 0.01380483f, -0.01187106f, 
    0.06973657f, -0.12626129f, -0.16228595f, 0.00675870f, -0.06213565f, 0.11191677f, -0.16115487f, -0.02251406f, 
    -0.07836444f, -0.24273467f, 0.12754716f, -0.09396242f, 0.52249229f, 0.02920825f, 0.16820623f, -0.10580758f, 
    -0.07913586f, -0.07270916f, -0.09453304f, -0.26247287f, 0.09007959f, 0.08907863f, -0.16312674f, 0.05489591f, 
    0.30633456f, 0.15574457f, 0.04374197f, 0.12922937f, 0.13115209f, 0.02682407f, 0.12689184f, 0.12051942f, 
    0.08708404f, -0.28400898f, -0.05952839f, 0.13588056f, -0.07100544f, -0.14837736f, 0.35331914f, 0.58283776f, 
    -0.16846552f, -0.06377102f, 0.24666478f, -0.09191681f, -0.02525436f, 0.04080700f, 0.04418746f, 0.12634577f, 
    -0.26823151f, 0.08102584f, -0.33842823f, -0.16193947f, -0.02085941f, -0.11401082f, -0.10143229f, -0.16433440f, 
    0.17712337f, 0.04035756f, 0.27457699f, 0.14169477f, 0.04237312f, -0.07041524f, 0.16287938f, -0.14517897f, 
    -0.07615825f, -0.16847923f, 0.08123108f, -0.03854354f, -0.03296926f, -0.10426182f, 0.20380026f, 0.53284967f, 
    -0.03642041f, 0.09940010f, 0.04248697f, 0.03006208f, 0.01405377f, -0.03341613f, 0.11769845f, -0.02315575f, 
    0.03468705f, -0.11561392f, -0.06100086f, -0.26114151f, 0.14938210f, -0.09509870f, 0.10818324f, 0.16082373f, 
    -0.30456620f, 0.42476827f, -0.09937387f, 0.07293677f, 0.10558812f, -0.12081381f, 0.15237969f, -0.03311320f, 
    -0.07269806f, -0.07920763f, -0.10927657f, -0.12645178f, -0.10875202f, -0.02526895f, 0.37764752f, 0.32494831f, 
    0.26148853f, 0.26517290f, -0.01129481f, -0.22633323f, 0.05489695f, -0.17804225f, 0.09917374f, -0.03852922f, 
    -0.23696700f, -0.20840511f, -0.17961882f, -0.25750405f, -0.03916489f, 0.05344024f, 0.00611297f, 0.15685882f, 
    -0.07178091f, 0.17415391f, 0.32369500f, -0.09589224f, 0.00503824f, 0.14098671f, 0.07142895f, 0.09059295f, 
    -0.01127277f, -0.09973262f, -0.13324998f, 0.12060164f, -0.15747795f, 0.10015778f, 0.32370752f, -0.08735316f, 
    -0.03268882f, 0.16962609f, -0.16596438f, -0.00019827f, 0.62707675f, -0.02166208f, 0.09518652f, 0.04245068f, 
    -0.14794181f, -0.01808104f, -0.07940620f, -0.31478110f, -0.14262924f, -0.09984322f, -0.14057882f, 0.10150508f, 
    -0.09741890f, 0.16104260f, 0.29876614f, -0.03323720f, 0.17426221f, 0.00589887f, 0.04766321f, -0.01973438f, 
    0.14000307f, -0.04282042f, -0.06908485f, 0.05269030f, 0.12499023f, -0.05519098f, 0.12654306f, -0.15693344f, 
    0.17888053f, -0.00593147f, 0.29902533f, -0.03383293f, -0.58094829f, 0.00968614f, 0.09457500f, -0.11745340f, 
    -0.18901697f, 0.11145203f, 0.30559790f, 0.27735001f, -0.09568910f, 0.13288523f, -0.01268919f, 0.02728109f, 
    -0.31675920f, 0.04637025f, 0.08647636f, -0.02605037f, -0.00940643f, 0.00185094f, 0.00616978f, 0.12227666f, 
    0.07455228f, 0.20376439f, 0.14409342f, 0.05366121f, 0.12280522f, 0.13103491f, -0.29198325f, -0.45273387f, 
    0.03960407f, 0.25126946f, -0.13238604f, 0.13434805f, -0.28594962f, 0.09757442f, -0.07890041f, -0.07142687f, 
    0.23073182f, 0.05853644f, 0.15358858f, 0.40778553f, -0.14470853f, -0.02826652f, 0.14330415f, -0.03108877f, 
    -0.10123184f, -0.14403933f, -0.13357018f, 0.02098348f, -0.05321084f, 0.08970864f, 0.12803794f, 0.13306956f, 
    0.10895558f, -0.24380997f, 0.06375790f, 0.04858923f, -0.05204099f, -0.06232962f, -0.10329380f, 0.12990978f, 
    -0.13302402f, -0.47156090f, 0.03139240f, 0.10296232f, -0.09841985f, -0.02160960f, -0.15195216f, -0.02395812f, 
    0.06061995f, 0.06639751f, 0.03006005f, -0.39502430f, 0.03481391f, 0.09167810f, -0.08658516f, -0.14670591f, 
    0.24280685f, 0.56931239f, -0.01089587f, -0.03882473f, -0.08342551f, 0.01519232f, -0.10560817f, 0.05848008f, 
    0.10669415f, 0.49254006f, 0.03896262f, 0.15724203f, 0.02667052f, 0.05156583f, -0.07457068f, 0.36055914f, 
    0.16180073f, -0.11182012f, 0.20823313f, -0.14975409f, -0.24722041f, 0.01294911f, 0.07926358f, 0.14646347f, 
    0.44578409f, 0.00170907f, 0.03830676f, -0.02979504f, -0.13618486f, -0.14942099f, -0.11781260f, -0.16039672f, 
    0.16276270f, 0.17119941f, -0.16442282f, -0.07202703f, 0.12367529f, -0.03124013f, 0.15001462f, -0.18301219f, 
    -0.03593894f, -0.00881954f, 0.01454295f, 0.08642171f, 0.01680182f, -0.06553999f, -0.01618345f, 0.47290358f, 
    -0.20544758f, 0.10948131f, 0.28216925f, 0.00555839f, 0.02837574f, -0.15000600f, -0.08415964f, -0.04540091f, 
    0.27365378f, 0.18419623f, -0.59055448f, 0.25922024f, -0.15992665f, 0.11731779f, 0.17826708f, 0.10037834f, 
    -0.19771838f, 0.08143514f, -0.19211397f, -0.12750363f, -0.11451557f, 0.01224678f, 0.08923553f, 0.30113032f, 
    0.04539101f, -0.04479140f, 0.07880573f, 0.19841240f, 0.16426584f, 0.13937372f, 0.37527210f, -0.09513453f, 
    0.03109966f, -0.12069571f, -0.05245713f, -0.10833242f, -0.15453920f, -0.01403988f, 0.12356913f, -0.00578711f, 
    -0.15866423f, 0.08269771f, -0.10716604f, -0.11527130f, -0.02101975f, 0.13788778f, -0.16222680f, 0.10328889f, 
    0.00248982f, -0.13681929f, -0.02519098f, 0.16747352f, 0.14032380f, 0.08224357f, -0.03325982f, 0.06346241f, 
    0.14691657f, -0.02338970f, 0.07715417f, 0.09656304f, -0.09939365f, -0.06313735f, -0.07451390f, 0.00794787f, 
    -0.05768270f, -0.07804866f, 0.10216916f, -0.07296941f, -0.03131953f, 0.12809691f, 0.12348210f, 0.08104904f, 
    -0.04508671f, -0.16003385f, -0.09720295f, -0.06355768f, 0.05095382f, -0.10231483f, -0.12038681f, -0.05172190f, 
    -0.13925685f, 0.07023393f, -0.17929398f, 0.08143664f, 0.11204499f, 0.06188228f, -0.03283702f, -0.05879295f, 
    0.02695654f, 0.13410537f, 0.17000720f, 0.11218347f, 0.01352864f, -0.14752516f, -0.07913211f, -0.07523669f, 
    0.06774805f, 0.01715888f, 0.01394140f, -0.30666125f, -0.31942371f, 0.08791352f, 0.02880767f, -0.10578110f, 
    -0.12487122f, -0.04159903f, -0.03063794f, -0.39846122f, -0.14780891f, 0.07147878f, 0.02797855f, -0.07181986f, 
    -0.13309658f, 0.33746603f, 0.35093027f, -0.00737433f, -0.08569571f, 0.04603641f, 0.08595578f, 0.06245275f, 
    -0.01166658f, -0.36936033f, -0.03339992f, 0.05629563f, 0.03254281f, 0.10788029f, -0.04689093f, 0.23861666f, 
    0.17955935f, -0.00374226f, 0.16226175f, 0.10196707f, -0.07918014f, 0.15089414f, -0.05145380f, -0.12213616f, 
    -0.04784690f, 0.11840275f, 0.00417808f, -0.15888177f, 0.12739517f, -0.03027164f, 0.08484714f, -0.13411997f, 
    -0.15506384f, 0.03992194f, 0.17722373f, -0.01760426f, -0.05127575f, -0.01389714f, 0.07459990f, -0.11313152f, 
    -0.06568160f, -0.60073048f, 0.19057137f, 0.06527522f, 0.05487213f, 0.00058040f, 0.10935200f, 0.22694325f, 
    0.28840968f, -0.01712419f, 0.21078184f, 0.01822754f, -0.20498830f, 0.15790631f, -0.00726102f, -0.06558148f, 
    0.14443180f, 0.07861784f, 0.17542545f, 0.42522079f, 0.13498595f, 0.05192302f, 0.06208162f, -0.14851244f, 
    -0.19966120f, 0.01465283f, -0.02968349f, 0.05022772f, 0.03246100f, 0.03070115f, -0.09865024f, -0.49512213f, 
    -0.15889235f, -0.58729559f, 0.04800514f, 0.06493463f, 0.09906083f, 0.01161776f, -0.11759614f, 0.17832641f, 
    -0.21124165f, -0.05843116f, 0.11639444f, 0.06353481f, 0.02741898f, -0.10665972f, 0.11975521f, -0.09297444f, 
    0.13441212f, -0.09825070f, 0.25322378f, 0.21547192f, 0.15501934f, 0.15167983f, 0.05517780f, 0.04104297f, 
    0.39336497f, -0.40776753f, 0.00301767f, 0.05928847f, -0.15414220f, -0.00168516f, 0.14482719f, 0.18818274f, 
    -0.02833957f, -0.02610258f, 0.01853393f, -0.13428850f, -0.07855306f, -0.16606183f, -0.12074420f, 0.33422759f, 
    0.26413491f, -0.11744671f, 0.15239996f, -0.30263752f, -0.33597440f, -0.06820646f, 0.05991831f, 0.01475811f, 
    0.13943100f, 0.11910310f, -0.25092345f, -0.31284654f, 0.04804233f, 0.01870423f, 0.14596133f, -0.04626815f, 
    0.26908693f, -0.22717442f, 0.26987562f, 0.10973055f, -0.06733374f, -0.10746584f, 0.09430077f, 0.23218869f, 
    0.01671513f, -0.12580299f, -0.09959882f, -0.15117246f, 0.08746236f, -0.13722731f, -0.15242907f, 0.08557082f, 
    0.05285224f, -0.41960222f, -0.19992051f, 0.07830487f, -0.43385220f, -0.14272510f, 0.10068266f, 0.10753313f, 
    -0.10605431f, 0.19323204f, -0.18872152f, 0.02019910f, 0.06278519f, -0.11683428f, -0.14817096f, -0.01690815f, 
    0.34023175f, -0.11750172f, 0.22503160f, 0.14656846f, 0.02984388f, 0.03575155f, -0.14873362f, -0.01728736f, 
    -0.05720082f, 0.24349590f, 0.05897807f, 0.07948370f, 0.04312820f, -0.02739538f, 0.17508657f, -0.11322355f, 
    -0.03191470f, -0.33222160f, -0.20800254f, 0.14222360f, 0.51921779f, 0.05508422f, 0.11469262f, -0.06431393f, 
    -0.14541265f, 0.08460170f, 0.36101648f, -0.04674065f, -0.14886075f, -0.01490508f, 0.09667616f, 0.06536795f, 
    0.51480234f, -0.27608621f, 0.17580606f, 0.00123411f, 0.12639529f, -0.04816200f, -0.02568026f, 0.28565121f, 
    0.14032392f, 0.28197819f, 0.06445817f, -0.11995585f, 0.14644943f, -0.01368141f, 0.14216663f, 0.01725679f, 
    -0.00143170f, 0.12326489f, -0.12426881f, 0.33656573f, 0.41746232f, -0.11859611f, 0.13266708f, -0.09189062f, 
    0.02723773f, -0.14059386f, -0.08533848f, 0.09286223f, -0.03309432f, -0.02697518f, -0.08707830f, -0.11819496f, 
    0.14970966f, 0.12049319f, -0.16053589f, -0.02284573f, -0.00912618f, 0.12005837f, 0.16964103f, 0.06586187f, 
    0.10409196f, 0.01705217f, -0.17450002f, -0.03401588f, 0.05698963f, -0.04681773f, 0.31218919f, 0.10609654f, 
    -0.25188771f, -0.28619930f, -0.02462685f, 0.11719731f, 0.23847474f, -0.13251354f, 0.02780712f, -0.12165723f, 
    -0.21560740f, -0.07247896f, 0.18997285f, -0.12902591f, -0.05352402f, 0.15915988f, 0.02581790f, 0.05679516f, 
    0.27791572f, -0.14189860f, 0.24453892f, 0.10165127f, -0.07614828f, 0.11293889f, -0.11284553f, 0.07545525f, 
    -0.11093156f, 0.47128356f, -0.05979639f, 0.03372477f, -0.13120025f, -0.12581855f, 0.19585527f, -0.27158636f, 
    0.15128523f, 0.10571417f, -0.14499477f, 0.13092387f, 0.01001147f, 0.00734768f, 0.12750639f, 0.09310237f, 
    -0.10778230f, 0.13421986f, -0.31894797f, 0.09537169f, -0.11647962f, 0.04956727f, -0.02096597f, 0.08986546f, 
    0.08391944f, -0.13218965f, 0.06061194f, -0.11235638f, -0.01012967f, 0.00702577f, -0.01267422f, 0.39853075f, 
    -0.06608747f, -0.09253405f, 0.16686934f, -0.07775892f, -0.03916081f, -0.09106518f, 0.28407353f, 0.12813492f, 
    -0.18976039f, -0.02665283f, -0.16303752f, -0.17302342f, -0.13784692f, 0.10791112f, 0.02515869f, 0.04727003f, 
    0.05160606f, 0.16338548f, 0.10210448f, -0.02156643f, 0.14491139f, 0.03466028f, -0.16364627f, 0.09306615f, 
    -0.06080766f, 0.03827062f, -0.15322372f, 0.03498877f, 0.09195965f, -0.03010452f, -0.10298087f, 0.01055567f, 
    -0.13623556f, -0.01601955f, 0.14091961f, 0.02628075f, 0.05928816f, 0.09592421f, -0.01417988f, -0.10412747f, 
    -0.16107287f, 0.21702199f, 0.14160033f, 0.11790726f, -0.26626173f, -0.02608043f, -0.13156989f, 0.00593558f, 
    0.03218778f, 0.02781446f, 0.49062982f, 0.45150849f, 0.05837077f, 0.13824083f, -0.01310438f, -0.11287192f, 
    0.04086423f, -0.10972951f, -0.17629969f, 0.09867768f, 0.12812229f, -0.02250530f, 0.10847493f, -0.06170595f, 
    -0.15732926f, 0.32123297f, -0.06881633f, -0.19502738f, 0.06051298f, 0.04191072f, -0.48773417f, 0.23985852f, 
    -0.14008686f, 0.23791085f, 0.05647488f, 0.19157645f, 0.25270158f, -0.12198278f, 0.14318435f, 0.11356269f, 
    0.19501410f, 0.16621912f, -0.55225855f, 0.22391582f, 0.15266225f, -0.08921242f, -0.13622081f, -0.14522080f, 
    -0.09168217f, -0.13553686f, -0.03245899f, 0.03066211f, 0.13320525f, -0.11790926f, -0.02191791f, 0.21630283f, 
    -0.11846450f, 0.35785869f, -0.12074327f, -0.08974252f, -0.03767435f, 0.03956595f, 0.32871851f, -0.17289637f, 
    -0.32598084f, 0.07221790f, 0.05732901f, 0.38193834f, 0.10898752f, -0.02134367f, -0.02953263f, 0.11199394f, 
    -0.31068623f, -0.04742602f, -0.08353958f, -0.00936596f, -0.08677118f, 0.00960807f, 0.06599341f, -0.16269849f, 
    -0.02170696f, -0.21405119f, 0.04928461f, 0.09417123f, 0.10979337f, -0.10148761f, 0.05799381f, -0.05840514f, 
    0.08750954f, -0.00435326f, 0.08539642f, -0.12292191f, 0.10796989f, 0.17209847f, 0.32075194f, 0.22001544f, 
    0.27054381f, 0.21517235f, -0.03946485f, -0.29735577f, 0.20641948f, -0.10197217f, 0.08731447f, 0.06544157f, 
    -0.20557652f, -0.22510830f, -0.14892210f, -0.19378032f, 0.04638910f, -0.16504429f, -0.11291175f, 0.00248406f, 
    -0.12761424f, 0.14602478f, 0.33432317f, -0.09501662f, 0.08696016f, -0.03440209f, 0.02337693f, 0.19166841f, 
    0.16663161f, -0.32867169f, 0.05015674f, -0.04033860f, 0.15096527f, -0.05543676f, 0.13389730f, 0.27534351f, 
    -0.12182480f, -0.34653431f, 0.06556069f, -0.09918771f, 0.07574314f, 0.16174586f, 0.06929368f, 0.11816158f, 
    0.13672462f, 0.02369018f, 0.37496054f, 0.06459934f, -0.13612321f, 0.14593300f, 0.07718439f, -0.10299398f, 
    0.55101383f, -0.30223626f, 0.13782534f, -0.04642160f, -0.05814397f, 0.02689013f, -0.11410282f, 0.20101249f, 
    -0.09301510f, -0.33409345f, -0.03035415f, -0.09936322f, 0.03971820f, 0.11481971f, -0.06438258f, 0.12045044f, 
    0.02031185f, -0.36488509f, 0.34863961f, -0.01588280f, -0.25935933f, 0.11890347f, -0.01547995f, -0.06219806f, 
    0.25721827f, 0.01598480f, -0.35736588f, 0.25768459f, -0.11366543f, -0.15017463f, -0.11178364f, -0.09485506f, 
    -0.03615481f, -0.07260873f, -0.24851234f, 0.12764940f, 0.18045256f, -0.05627114f, -0.09519062f, 0.20950484f, 
    -0.02791097f, 0.33315977f, -0.12788065f, -0.07265621f, -0.06644805f, 0.15868969f, -0.15093376f, 0.30544373f, 
    -0.13445839f, 0.11257194f, 0.00043826f, 0.07713418f, -0.27433816f, 0.01070471f, 0.15478387f, 0.04585550f, 
    -0.17109719f, -0.09103920f, 0.22685887f, 0.24114370f, 0.00187521f, -0.04166478f, -0.06089842f, 0.00207704f, 
    -0.22774747f, 0.26115310f, -0.02824957f, -0.13530177f, 0.00791332f, -0.00071173f, -0.14044702f, 0.08869717f, 
    0.06867193f, 0.02012045f, 0.05170718f, 0.12410336f, 0.03527742f, -0.12770914f, -0.44874030f, 0.82519138f, 
    0.12157886f, 0.01396004f, 0.24951291f, 0.01603659f, -0.73319864f, 0.08328797f, -0.05640338f, -0.16699946f, 
    0.26937133f, -0.07571418f, -0.58418989f, 0.00959295f, 0.02532758f, 0.14023896f, -0.16484821f, -0.02992540f, 
    0.25665164f, 0.06727020f, 0.19335021f, -0.15390462f, 0.16510609f, 0.05479676f, 0.14896251f, -0.07186866f, 
    0.12764134f, -0.51073188f, -0.12608962f, -0.00714840f, 0.14650770f, 0.11885898f, 0.01363168f, 0.01643759f, 
    0.26256707f, 0.23811927f, 0.23459564f, 0.04767406f, -0.40308127f, 0.05690644f, -0.15325309f, 0.13923022f, 
    -0.09225424f, -0.12843366f, -0.16787659f, -0.14137818f, 0.12521859f, -0.16763513f, 0.11105493f, -0.10458715f, 
    -0.28324035f, 0.39438230f, 0.29968709f, -0.11149026f, -0.16093500f, 0.07251766f, -0.13028717f, 0.21051176f, 
    0.15678772f, 0.17771265f, -0.07764222f, 0.04288676f, 0.00563932f, -0.10140032f, -0.11525222f, -0.06748905f, 
    0.35205907f, -0.21094264f, 0.30961043f, -0.19410282f, -0.34145680f, 0.13905452f, -0.02648875f, 0.13245197f, 
    0.06549111f, -0.05174145f, 0.15968654f, -0.20185746f, -0.08631845f, -0.13524340f, 0.09908655f, -0.07061303f, 
    -0.25896713f, 0.13947013f, 0.22062989f, -0.01758410f, -0.06995603f, -0.06578008f, 0.04342720f, -0.08897413f, 
    -0.07210618f, 0.23343444f, 0.15104866f, -0.07784584f, -0.12471537f, -0.14773202f, -0.24776666f, 0.19163328f, 
    -0.16831753f, -0.43762743f, 0.11509492f, -0.02529151f, 0.24645592f, -0.16426364f, -0.15383552f, 0.05132814f, 
    0.34288853f, 0.00946878f, 0.35998842f, -0.08815713f, 0.03927129f, 0.16000730f, 0.00265664f, 0.04264036f, 
    0.11847671f, 0.07898261f, 0.00620583f, 0.05713784f, 0.15229341f, 0.16717322f, 0.00810648f, -0.16518840f, 
    -0.16461168f, 0.49743459f, -0.02806867f, -0.09793187f, -0.10093504f, -0.12671922f, -0.23577979f, -0.03287053f, 
    0.16970401f, 0.29083651f, 0.01436153f, 0.05016818f, -0.21322639f, 0.13488293f, -0.13173129f, 0.12200850f, 
    -0.04897047f, 0.00836928f, -0.49353006f, 0.24085267f, 0.14967385f, -0.08160256f, -0.12546083f, -0.05146388f, 
    -0.08645785f, 0.05257982f, 0.05835873f, 0.11614916f, 0.07882216f, 0.14726840f, -0.15346146f, 0.22279499f, 
    -0.16574001f, 0.46459013f, -0.06819094f, 0.00780213f, 0.10411641f, 0.10813081f, -0.16023853f, -0.16547933f, 
    -0.19839931f, -0.41861463f, 0.17483948f, 0.10498158f, 0.23026706f, 0.02050413f, -0.15755399f, 0.14835528f, 
    -0.10818509f, 0.00083820f, 0.21733995f, 0.01335137f, -0.06195408f, 0.03720159f, -0.12194971f, 0.07640977f, 
    0.44924036f, 0.08830986f, -0.07868845f, -0.09375980f, -0.14804852f, -0.12799922f, 0.13387592f, -0.09194773f, 
    -0.02069470f, -0.16746864f, -0.03209619f, 0.01873371f, -0.06327532f, 0.08074704f, 0.14287266f, 0.52043456f, 
    0.02661866f, 0.01550485f, 0.08732857f, 0.31440461f, 0.17332624f, 0.17159289f, 0.08326110f, -0.02854320f, 
    0.17954625f, 0.07272017f, -0.24590585f, -0.06530150f, -0.14556113f, 0.16540231f, 0.10491431f, -0.09596002f, 
    -0.27090952f, -0.02283898f, -0.15853660f, -0.06440446f, 0.07360885f, -0.12089988f, -0.03460370f, 0.41215193f, 
    -0.13278271f, 0.31990439f, -0.06244951f, 0.13906674f, -0.09389468f, 0.12003124f, 0.16929431f, -0.18701935f, 
    0.05405176f, 0.02030336f, 0.15198193f, -0.03938556f, -0.58039272f, 0.08431936f, -0.16761138f, 0.00011748f, 
    0.13577789f, -0.03396543f, 0.11788781f, 0.07367213f, -0.14165656f, 0.12923735f, -0.07542177f, 0.07883841f, 
    0.37168300f, -0.02792819f, 0.15207164f, 0.17577000f, 0.11565415f, -0.12148959f, 0.12795404f, -0.14158155f, 
    -0.01181178f, -0.05858267f, -0.17477202f, -0.00276455f, 0.09557106f, -0.11834049f, -0.02516106f, -0.21568342f, 
    -0.04504494f, -0.12753157f, -0.17026478f, 0.04717128f, 0.11822136f, 0.06578560f, -0.15687735f, -0.09581669f, 
    -0.11800081f, -0.04120935f, -0.17433307f, -0.01680342f, 0.15166268f, -0.17571101f, 0.10276988f, 0.17320471f, 
    -0.13490930f, 0.15552312f, -0.15249538f, 0.05201749f, -0.06058013f, -0.15504022f, 0.04252145f, -0.06046884f, 
    -0.04760714f, -0.10398748f, 0.15152441f, 0.02832308f, -0.11007793f, 0.05896188f, -0.07036289f, -0.09608550f, 
    0.08022723f, -0.33310416f, 0.16165031f, -0.14948548f, -0.34075361f, 0.10767438f, -0.04613255f, -0.08539923f, 
    0.04585712f, -0.01291591f, 0.22955258f, -0.30689040f, -0.02641688f, -0.15881859f, 0.04302834f, -0.14540216f, 
    -0.20546508f, 0.21592391f, 0.04899079f, -0.06391757f, -0.03310725f, 0.09217147f, 0.06277658f, 0.08249781f, 
    -0.00344602f, 0.51917171f, -0.06175207f, -0.12437095f, 0.06979586f, 0.16361722f, 0.09385683f, -0.37689549f, 
    0.14742729f, 0.59393072f, 0.08336676f, -0.12749849f, -0.09993534f, 0.08338562f, -0.03835340f, 0.15770732f, 
    -0.12110376f, 0.09286003f, -0.12392689f, -0.00237555f, -0.08434441f, -0.15056704f, 0.06650685f, 0.13077873f, 
    -0.28328913f, 0.19279128f, 0.22865607f, 0.08239599f, -0.00260594f, 0.11275318f, -0.04524294f, 0.15362258f, 
    -0.07607285f, -0.16863251f, 0.02526188f, 0.12722798f, 0.03613620f, 0.15284030f, -0.03458055f, -0.32748079f, 
    0.03097596f, -0.09584897f, 0.17903218f, 0.08384074f, -0.33896032f, 0.11457244f, 0.02748534f, 0.06184496f, 
    0.25084478f, -0.04792031f, 0.21898222f, 0.20651300f, 0.16634454f, -0.08708193f, 0.16195063f, -0.04827961f, 
    0.14826415f, -0.17647178f, -0.09808300f, 0.14502069f, 0.06790012f, -0.02065333f, -0.06192899f, -0.16881065f, 
    0.07450012f, 0.37976164f, -0.00135058f, -0.12615541f, -0.10677263f, -0.11100654f, 0.03807456f, 0.06286354f, 
    0.08773666f, -0.27268228f, 0.27017492f, -0.11607812f, -0.21596810f, 0.12255899f, -0.01730862f, -0.06458829f, 
    0.01155786f, -0.11280473f, 0.18288958f, 0.00526134f, -0.10965914f, 0.16514814f, -0.02405555f, -0.12792110f, 
    0.01323919f, 0.00860678f, 0.14397858f, 0.03478324f, 0.16590716f, -0.07825500f, 0.02291266f, 0.07244316f, 
    0.04916533f, 0.07950510f, 0.06231823f, -0.02037502f, 0.06388789f, -0.12826887f, -0.33334523f, -0.21120813f, 
    -0.20279564f, 0.40091100f, -0.25413629f, 0.09860127f, -0.07667616f, 0.08106441f, -0.03852686f, -0.16754104f, 
    0.10326491f, 0.05338345f, 0.42761382f, -0.17846750f, -0.16192821f, 0.07795210f, 0.08136898f, -0.04322639f, 
    0.28217769f, 0.11997718f, -0.01188146f, -0.11493156f, -0.06611411f, -0.11593652f, 0.13685632f, -0.26337111f, 
    0.06935668f, 0.38683450f, 0.12598884f, 0.14373331f, 0.08933340f, -0.15997176f, 0.00348552f, 0.01407767f, 
    -0.20873871f, -0.26876268f, 0.09264606f, -0.06493239f, 0.01167647f, -0.00059513f, -0.11546740f, -0.03107278f, 
    -0.09065061f, 0.07518059f, 0.37740248f, -0.04894895f, -0.08994757f, -0.16063885f, 0.00580149f, -0.16370463f, 
    0.12918927f, -0.26177412f, 0.29597184f, -0.06869424f, -0.15558837f, 0.08107050f, -0.15719746f, 0.05970574f, 
    0.03654465f, -0.41754714f, -0.19254243f, 0.04682042f, 0.15033528f, -0.12399542f, -0.13187085f, 0.48316145f, 
    -0.02316703f, 0.28371841f, 0.14621365f, 0.30821621f, -0.13715559f, 0.02145780f, 0.14262199f, 0.11360487f, 
    -0.36173144f, 0.16148448f, -0.17100681f, -0.07489467f, -0.03255183f, -0.07210410f, 0.00522736f, 0.04588665f, 
    -0.43480131f, -0.16616914f, 0.19913371f, 0.11155347f, -0.01354246f, -0.04630512f, -0.00224758f, 0.17059194f, 
    -0.03877542f, -0.20653251f, 0.01689143f, 0.09408674f, 0.05695804f, 0.11496788f, 0.04664675f, 0.14624359f, 
    0.22230302f, 0.25790527f, -0.07202366f, -0.09229485f, -0.26240832f, 0.10274673f, -0.03728024f, -0.01422905f, 
    0.12625614f, -0.03299419f, 0.34456456f, 0.38303480f, 0.02794345f, -0.16945662f, -0.01416446f, 0.12129816f, 
    0.27289644f, -0.10463964f, 0.15699869f, -0.15176418f, 0.10044852f, -0.05796334f, 0.02260437f, 0.02305797f, 
    -0.06317030f, 0.32084784f, -0.04868324f, -0.04098567f, -0.09747669f, 0.12069723f, -0.25774771f, -0.50530088f, 
    -0.18850137f, 0.33168602f, 0.00698604f, 0.33630449f, 0.18520662f, 0.12686838f, 0.10994774f, 0.02763074f, 
    -0.06382515f, 0.12020320f, -0.33629185f, 0.26180699f, -0.04937974f, -0.16380131f, -0.16444454f, 0.01154784f, 
    0.18487553f, -0.02533513f, -0.11135108f, -0.02953788f, -0.11823846f, 0.03066723f, -0.07616033f, 0.30910414f, 
    -0.06462567f, -0.21685725f, 0.15255056f, -0.01913351f, -0.13794211f, 0.13595708f, 0.29107824f, 0.05256884f, 
    -0.19109069f, 0.09371665f, -0.04574070f, 0.17192459f, -0.02086094f, 0.11101258f, 0.11650059f, -0.04510849f, 
    0.17830905f, 0.01598588f, 0.18110703f, 0.06709301f, 0.06464332f, 0.09766088f, -0.05851940f, 0.10126737f, 
    0.09468354f, -0.37834173f, 0.16490778f, 0.18153206f, 0.01886915f, -0.07343673f, -0.08216546f, 0.28514960f, 
    -0.01705031f, 0.16847320f, -0.08268143f, 0.06099445f, 0.07345846f, 0.16279677f, -0.21437170f, -0.35065448f, 
    -0.27815005f, -0.31592578f, 0.04191157f, 0.29620540f, 0.05567341f, -0.16824546f, 0.16774765f, 0.13868828f, 
    0.16189919f, -0.00962689f, 0.18797527f, -0.14103888f, -0.12302940f, -0.01076953f, -0.00859035f, -0.15563434f, 
    0.47628772f, -0.21601178f, 0.03611897f, -0.09267750f, 0.05759471f, -0.16942997f, -0.05809049f, 0.24943057f, 
    0.14467931f, -0.20609874f, 0.14746866f, -0.02027045f, -0.11964311f, 0.12249978f, -0.09169637f, 0.48397258f, 
    0.01981079f, 0.02499202f, -0.20587704f, 0.08718347f, 0.05354116f, -0.01660173f, 0.09634753f, 0.06195188f, 
    0.15411215f, -0.08141286f, -0.25547945f, -0.06002678f, 0.03817088f, 0.14121343f, 0.15435657f, -0.01514026f, 
    0.43037611f, 0.06690058f, 0.00173094f, -0.03861062f, -0.11128241f, -0.10092512f, -0.06462130f, -0.01905520f, 
    -0.01887439f, -0.18845730f, -0.00485706f, -0.13873300f, -0.07289971f, -0.16748053f, 0.01914638f, 0.32411715f, 
    0.18770134f, 0.10307384f, -0.05671364f, 0.01279412f, 0.18743441f, 0.00678267f, -0.08308689f, -0.09343254f, 
    -0.26177651f, -0.06539916f, -0.09579373f, 0.15944539f, 0.17013064f, -0.06088473f, -0.09093611f, 0.01181877f, 
    -0.06952927f, -0.01178182f, 0.00852520f, -0.15776424f, 0.15829697f, 0.16944382f, -0.11242676f, 0.40010276f, 
    0.08877115f, -0.04534597f, -0.04096541f, 0.06372080f, 0.09582926f, 0.12389924f, 0.04573151f, -0.17527229f, 
    0.26182052f, 0.10917116f, 0.01632979f, -0.27259213f, 0.32200831f, -0.08563437f, 0.10596508f, -0.15892871f, 
    -0.48937780f, -0.01707812f, 0.30575219f, -0.06871650f, 0.14078537f, 0.14626053f, 0.09526337f, 0.11958774f, 
    -0.18586870f, 0.18190245f, 0.12627299f, -0.14700776f, 0.00374819f, 0.17457852f, 0.15490857f, 0.16432491f, 
    0.02149285f, -0.14854829f, -0.06585281f, 0.03166234f, 0.03438475f, 0.16941515f, 0.22586609f, -0.31148985f, 
    0.13124119f, 0.02900915f, -0.01204197f, 0.20076421f, 0.25291574f, 0.06153848f, -0.04082887f, 0.11001205f, 
    0.24419808f, 0.03274568f, -0.32079494f, 0.34777400f, 0.11155097f, -0.10565858f, 0.01115293f, 0.03351861f, 
    0.07570314f, 0.37294051f, -0.15975848f, 0.02008703f, -0.16562599f, -0.07079668f, -0.07666276f, 0.00105442f, 
    0.02809640f, 0.44113398f, 0.17450723f, 0.12543747f, -0.14911458f, 0.10555895f, -0.06027861f, 0.06763848f, 
    -0.00316801f, 0.07726147f, 0.25970712f, -0.34445900f, -0.53562653f, -0.02209765f, -0.04612505f, -0.01664296f, 
    0.13350850f, -0.05895622f, -0.04158105f, -0.28627205f, 0.10384195f, 0.15734243f, 0.14997324f, -0.03189131f, 
    -0.34905916f, 0.46467647f, 0.30557090f, 0.06474762f, -0.10722815f, -0.03917613f, -0.16811475f, -0.08759922f, 
    0.00396045f, -0.22145753f, 0.09003312f, -0.01257157f, -0.00734812f, -0.00163343f, 0.05231735f, 0.12170380f, 
    0.28676203f, 0.25832084f, 0.06761161f, -0.08913340f, -0.06544329f, 0.00156901f, 0.01815107f, -0.08192515f, 
    0.11588784f, -0.11686595f, -0.18267630f, 0.44221312f, 0.07178004f, 0.01230300f, 0.05030052f, 0.04307487f, 
    0.00219097f, 0.11817314f, -0.16451430f, -0.07069384f, 0.03291547f, 0.08002504f, 0.04775212f, 0.12456696f, 
    0.15676564f, 0.27420259f, 0.04922012f, 0.08965813f, 0.10767763f, 0.10131234f, -0.20834558f, -0.30345806f, 
    -0.06690995f, 0.34203184f, 0.16019084f, 0.28533080f, -0.09580081f, 0.05995338f, 0.04974028f, -0.06771868f, 
    -0.12398609f, -0.04915000f, -0.06851938f, 0.00272801f, 0.16015743f, -0.14412317f, 0.00427144f, -0.11708649f, 
    -0.27189255f, 0.13134496f, -0.10383987f, -0.11046950f, -0.10550686f, 0.03480105f, 0.03169016f, 0.18528813f, 
    0.08184796f, -0.19051994f, 0.10283049f, -0.18261337f, 0.12836735f, -0.03665444f, 0.16965230f, 0.08726864f, 
    -0.20632905f, -0.26594615f, 0.19805863f, 0.04072392f, 0.11154117f, -0.05370910f, -0.12957546f, 0.16171111f, 
    -0.04255594f, 0.02791641f, 0.12470075f, -0.30932650f, 0.12989157f, -0.17297851f, 0.08325634f, 0.15124117f, 
    -0.19363753f, 0.14092614f, 0.22944087f, -0.04043503f, -0.04822242f, -0.06030611f, -0.09389637f, -0.15329269f, 
    0.11532623f, -0.20817499f, -0.15636037f, -0.00771390f, 0.13002941f, -0.08723314f, 0.17052816f, 0.65946621f, 
    -0.01831109f, -0.02761091f, -0.11667672f, -0.14286628f, -0.06898493f, 0.07828307f, -0.03101165f, 0.00849474f, 
    0.09810547f, -0.02081176f, 0.02189565f, -0.19446969f, -0.17150092f, 0.09716769f, 0.01055043f, 0.01443095f, 
    -0.11676521f, -0.17582099f, -0.13080077f, 0.13920316f, -0.01730130f, 0.08740927f, 0.10559604f, 0.07000699f, 
    -0.09979528f, 0.02077497f, -0.07619069f, 0.00042931f, 0.00697996f, -0.02579695f, -0.04921384f, 0.03797899f, 
    0.08892761f, 0.05612919f, -0.21133098f, 0.13102286f, 0.43929109f, -0.17204861f, -0.17156450f, -0.17012450f, 
    0.11743210f, 0.10326256f, 0.58366883f, -0.05669570f, -0.10651688f, -0.08267744f, -0.05383938f, -0.00494985f, 
    -0.02798904f, 0.17654966f, -0.08318794f, -0.07776471f, -0.11054983f, 0.05608435f, -0.08856550f, 0.31702861f, 
    0.12550457f, 0.02118968f, -0.14032666f, -0.12686239f, -0.03032762f, 0.09559350f, -0.27644363f, -0.01726519f, 
    -0.18275659f, -0.14684492f, -0.00789716f, 0.30860746f, 0.11161318f, 0.12313873f, 0.13058050f, -0.08375863f, 
    -0.30508795f, 0.12194355f, -0.05169152f, -0.18237662f, -0.14253286f, 0.02345465f, -0.00111799f, -0.16293730f, 
    0.18305944f, -0.17255221f, 0.32507366f, -0.02301499f, -0.03722408f, -0.11292045f, 0.16834700f, 0.04355840f, 
    -0.03966987f, 0.17624441f, 0.08093084f, 0.15639728f, -0.01760968f, 0.10688064f, 0.33173606f, -0.09075069f, 
    0.02027963f, 0.19637100f, 0.11246940f, 0.26687831f, 0.15006067f, -0.01918782f, 0.17058234f, 0.10016394f, 
    -0.33172569f, -0.02323233f, 0.06809714f, -0.18827680f, 0.06541153f, 0.15407468f, 0.06271265f, 0.14117377f, 
    -0.32723460f, -0.08617189f, 0.15940443f, -0.09170520f, 0.05144429f, 0.05590132f, -0.06506395f, 0.02799935f, 
    -0.09203666f, 0.01914855f, -0.16985318f, 0.19608851f, -0.06409997f, 0.01328846f, 0.29552105f, 0.15179139f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.33603811f, 0.03468148f, 0.25293070f, 0.04726816f, 0.18994762f, 0.24518310f, 0.19428730f, 0.23668657f, 
    -0.10233454f, -0.16230401f, 0.03411459f, 0.07792316f, -0.19030564f, -0.01817932f, 0.32615224f, 0.26926821f, 
    0.08532497f, 0.16283934f, 0.19309358f, 0.15235043f, -0.05689933f, 0.02141713f, -0.06970358f, 0.21043713f, 
    0.10573195f, -0.17932276f, -0.07605861f, -0.10205850f, 0.33942848f, 0.30873781f, 0.01602591f, 0.22803396f, 
    0.14389627f, 0.12124978f, 0.12847930f, 0.01749791f, -0.06493694f, 0.19334717f, 0.13290808f, 0.30366629f, 
    -0.12433987f, 0.05120199f, 0.31294012f, 0.18408252f, 0.21741642f, -0.19409826f, 0.18112774f, -0.09501445f, 
    0.24305296f, -0.10647431f, 0.25744259f, 0.11589151f, -0.02487478f, 0.16260000f, 0.13114753f, 0.07346092f, 
    0.00279444f, -0.12005357f, -0.00128133f, 0.02017814f, -0.15266979f, 0.03074679f, 0.23560733f, 0.04969894f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.10162510f, 0.06877573f, -0.10991853f, 0.16180667f, -0.21894956f, 0.40524134f, -0.10558991f, 0.38809681f, 
    0.05115076f, -0.55713546f, -0.03340109f, -0.15080424f, 0.04308153f, 0.08624990f, 0.21952610f, 0.26823163f, 
    0.40733513f, -0.00861475f, 0.41746548f, 0.15394634f, -0.04484781f, -0.04543252f, 0.11732256f, 0.02876341f, 
    0.09322378f, -0.31260213f, -0.10928594f, -0.29876485f, 0.28609398f, 0.14910199f, -0.01715941f, -0.59880042f, 
    0.23032989f, 0.11085533f, 0.30265644f, -0.16738436f, 0.08630886f, -0.18180883f, 0.00724318f, 0.10702853f, 
    0.00973690f, 0.03081578f, 0.28691560f, 0.08244526f, 0.26946509f, -0.05511105f, -0.07415359f, -0.01148792f, 
    0.25207311f, 0.08746058f, 0.08436269f, -0.30263838f, -0.28178746f, 0.19045265f, 0.16504502f, -0.05773690f, 
    0.14203529f, 0.27118868f, -0.04379846f, -0.17530084f, 0.09251624f, -0.30935389f, 0.05147554f, -0.07037500f, 
    -0.03755906f, -0.04262052f, -0.04781837f, -0.03646713f, -0.04495914f, -0.02900359f, 0.07764022f, 0.07217974f, 
    0.01023080f, -0.10402417f, 0.04141047f, -0.06479905f, -0.05152756f, 0.06240482f, 0.00290918f, 0.03645485f, 
    -0.10958833f, 0.03442852f, 0.03684814f, -0.02526599f, -0.01706480f, -0.02452141f, -0.02558783f, 0.02221854f, 
    0.02897894f, 0.09437007f, -0.02209763f, -0.06489450f, -0.01684909f, -0.03997796f, -0.02833055f, 0.03792068f, 
    -0.00157934f, -0.07368163f, -0.10418355f, -0.14758834f, 0.06990016f, 0.01155923f, 0.01509279f, 0.03015080f, 
    -0.02558978f, 0.08278415f, -0.09943794f, -0.11712721f, -0.12509090f, -0.02202389f, -0.02085459f, -0.12880550f, 
    -0.00574363f, -0.11500560f, 0.00070105f, 0.01709317f, 0.09823114f, 0.02722886f, -0.09461492f, 0.04564799f, 
    0.03421584f, -0.14780845f, -0.10975937f, 0.05931947f, 0.00862299f, 0.10374042f, 0.11061002f, -0.10396954f, 
    0.02900001f, 0.09317881f, -0.01039348f, 0.08286323f, 0.08241434f, -0.01559237f, -0.09894453f, 0.07833221f, 
    -0.10859279f, -0.05193499f, -0.09376145f, -0.11798649f, -0.10875852f, -0.02797724f, -0.12441795f, -0.13226518f, 
    0.05130003f, 0.04304082f, -0.02828821f, -0.06464304f, -0.01712659f, -0.12207044f, -0.06099068f, -0.11264984f, 
    0.01567593f, -0.09023278f, 0.03494327f, 0.09750414f, 0.10469525f, -0.04317745f, -0.11018110f, 0.06397893f, 
    0.01990576f, -0.12416429f, -0.09690776f, -0.13044457f, -0.11137494f, -0.02490632f, -0.00197572f, 0.08996525f, 
    -0.04663239f, 0.00536652f, 0.04990884f, 0.02054388f, 0.03084062f, 0.09273484f, 0.10853609f, -0.10665618f, 
    -0.00273412f, 0.07774748f, -0.10200147f, -0.12304093f, 0.03451325f, -0.03631236f, -0.04829607f, 0.01128002f, 
    0.00438473f, 0.08087517f, 0.01245711f, 0.06551861f, -0.03349793f, -0.03985407f, -0.09185983f, -0.03498288f, 
    0.13029516f, 0.07908382f, -0.19721809f, 0.06126631f, 0.04000071f, 0.07355711f, -0.02354765f, 0.32857570f, 
    -0.15180650f, -0.13400662f, -0.04616997f, 0.10240769f, 0.02557527f, 0.00813291f, 0.35355872f, 0.08057979f, 
    0.32707828f, -0.13900766f, 0.05931889f, -0.20922469f, -0.31142464f, -0.16826946f, 0.10209130f, -0.01842276f, 
    0.08507917f, -0.01984081f, 0.16897152f, 0.26286405f, 0.02505595f, -0.12526631f, 0.10348392f, 0.19254492f, 
    0.34270597f, 0.09642407f, 0.13594797f, 0.00086211f, 0.26832449f, -0.26219475f, -0.18705076f, 0.17338368f, 
    0.01887302f, 0.09550079f, 0.31547263f, -0.03768703f, 0.08597645f, 0.17811868f, -0.25989527f, 0.01692186f, 
    0.21006808f, 0.06039076f, 0.03288014f, -0.16708735f, -0.26593941f, -0.12233440f, -0.13415265f, 0.06761906f, 
    0.36048269f, 0.11569576f, 0.05335210f, -0.07664076f, 0.07099286f, -0.30259454f, 0.08148003f, -0.13992418f, 
    0.09971893f, 0.02592105f, 0.05924298f, -0.08877352f, 0.04740813f, -0.09201911f, 0.03218482f, -0.01361548f, 
    -0.10509276f, -0.13252094f, -0.02057732f, -0.06133151f, -0.04756607f, -0.00473139f, -0.05229370f, 0.02747656f, 
    0.04527401f, -0.06789020f, -0.00387372f, -0.00926253f, 0.03908812f, -0.00306534f, -0.01932305f, -0.06096959f, 
    0.05053557f, -0.12144324f, -0.01479085f, -0.06923494f, -0.14730245f, -0.10382161f, 0.09161575f, 0.03085423f, 
    -0.01198946f, -0.00957120f, -0.08554868f, -0.08214761f, -0.11303474f, 0.00479442f, -0.00439954f, -0.03338601f, 
    -0.04841515f, -0.02143554f, -0.07343329f, 0.05415182f, -0.07959066f, 0.08188458f, 0.02517672f, 0.11175720f, 
    0.08653583f, 0.00089330f, -0.10839209f, -0.01148269f, -0.10492972f, -0.08364524f, 0.04170571f, -0.12146123f, 
    -0.12726969f, -0.05153027f, -0.06263946f, -0.13688233f, 0.07487644f, -0.12903406f, -0.06984244f, 0.04628888f, 
    0.17906518f, 0.05404304f, -0.12431873f, 0.11844912f, 0.00204617f, -0.09327190f, -0.00395171f, 0.01110727f, 
    0.01224055f, 0.02068380f, 0.01175104f, -0.03794142f, -0.02045471f, 0.10732218f, -0.16376941f, 0.02252972f, 
    0.00481338f, 0.07165055f, 0.02199819f, -0.02868773f, -0.11102314f, 0.04610999f, -0.06717385f, -0.10333255f, 
    0.02400089f, 0.05658318f, 0.02253362f, -0.02819848f, -0.10905602f, 0.00919380f, -0.07922929f, -0.16110535f, 
    -0.05698365f, -0.13630858f, -0.12618463f, -0.03091080f, -0.09786178f, -0.12123750f, -0.10659248f, -0.06955760f, 
    0.03378813f, -0.01864919f, 0.01554501f, 0.02449241f, -0.00971582f, -0.04006378f, -0.03904798f, 0.08280987f, 
    -0.04556411f, -0.04037179f, 0.01819016f, 0.05479860f, -0.05965735f, -0.00199326f, -0.06443502f, 0.05774926f, 
    0.08035060f, 0.01297393f, 0.09921415f, 0.08835496f, -0.06110223f, 0.06676624f, 0.08211555f, -0.05147664f, 
    0.10539535f, -0.11383002f, 0.08453450f, 0.08571063f, -0.04225185f, -0.07480647f, -0.09352943f, 0.05845563f, 
    0.09465768f, -0.10533911f, 0.00084933f, 0.04197353f, -0.07579842f, -0.02680214f, -0.09182289f, -0.05332712f, 
    -0.07523277f, 0.00761871f, 0.05925006f, -0.12863888f, -0.03730221f, -0.09885357f, -0.13029672f, -0.10347079f, 
    0.09508826f, 0.04929079f, -0.05857927f, 0.12464011f, -0.18161879f, -0.07529470f, 0.01629297f, -0.14603218f, 
    -0.17076248f, -0.05671220f, -0.07930725f, -0.09758835f, -0.16510080f, -0.04909550f, -0.10049818f, -0.07138588f, 
    0.01516692f, -0.15393485f, -0.00809195f, -0.04317422f, -0.13502693f, 0.06159742f, -0.02241123f, -0.02984610f, 
    -0.00559776f, -0.00721394f, 0.03432573f, -0.03457839f, -0.02390782f, -0.04055808f, 0.00189842f, -0.05960022f, 
    -0.13923587f, -0.07783001f, -0.11298139f, 0.08096915f, -0.06226431f, 0.04181762f, 0.00456627f, -0.00977232f, 
    0.04762030f, 0.08772127f, -0.09767044f, 0.04778562f, 0.05297789f, 0.07121560f, -0.00403407f, 0.06981095f, 
    0.11282066f, 0.06314675f, -0.04671870f, -0.02672737f, 0.12458751f, 0.10188001f, -0.01364457f, -0.00485702f, 
    -0.15862712f, -0.02256059f, -0.01840774f, 0.04543146f, -0.09101789f, -0.07395834f, -0.07072561f, -0.08340311f, 
    -0.05050781f, -0.10305728f, -0.03621799f, 0.11854541f, -0.09022383f, -0.01863378f, 0.01760112f, 0.11461349f, 
    0.07099742f, -0.15930678f, -0.06258574f, -0.00946734f, 0.03406912f, -0.13174877f, 0.05039274f, 0.00002612f, 
    0.10192700f, 0.02517730f, -0.05363967f, 0.06145001f, -0.01696130f, -0.00950276f, -0.05295371f, 0.03821008f, 
    -0.10387878f, 0.08925898f, -0.13515383f, -0.11043920f, 0.01838783f, 0.04455484f, 0.10376106f, -0.07533713f, 
    -0.09922343f, -0.12257630f, -0.10133474f, -0.11012170f, 0.10620598f, 0.00369778f, -0.14591020f, -0.15103820f, 
    -0.20650895f, -0.06967258f, 0.32137358f, 0.21885030f, 0.11146955f, 0.37292337f, 0.56756556f, -0.17448431f, 
    -0.14693792f, 0.22481456f, -0.17981258f, -0.17452838f, 0.13701023f, 0.12128149f, 0.19485006f, 0.04572313f, 
    -0.55489558f, -0.06662964f, 0.06584415f, 0.52876294f, 0.48062980f, -0.15826777f, 0.19866575f, 0.25512052f, 
    0.03726862f, -0.54537165f, -0.13836274f, 0.04416990f, 0.45952943f, 0.20209835f, -0.31229964f, 0.02192565f, 
    -0.03831732f, 0.08685915f, -0.06818360f, -0.06575481f, -0.15112582f, 0.27170712f, 0.03235020f, -0.02073557f, 
    0.00935322f, 0.24598095f, 0.10751872f, -0.26546806f, 0.07839528f, -0.01541446f, 0.38477448f, 0.13568535f, 
    0.03523292f, 0.03035316f, 0.02349474f, 0.17685579f, 0.23444426f, 0.21640041f, 0.51433539f, -0.13780560f, 
    0.17102255f, -0.28910068f, -0.01415044f, 0.31747925f, -0.04799768f, 0.10691858f, 0.38115460f, 0.14355965f, 
    -0.58700252f, -0.12476671f, -0.25115964f, -0.29359385f, -0.04251543f, 0.34780422f, 0.33930126f, 0.34392402f, 
    0.14945208f, -0.10888521f, -0.05705653f, -0.02267249f, -0.06221532f, -0.09578600f, 0.05131983f, 0.00592090f, 
    0.10799523f, -0.17743033f, 0.01320959f, -0.39778385f, 0.07978947f, 0.05907848f, 0.22135918f, 0.07947037f, 
    -0.01566773f, 0.33308199f, 0.07038714f, -0.48701617f, 0.07290757f, 0.11548059f, -0.13519004f, -0.29982382f, 
    0.06744307f, 0.26332560f, 0.09548490f, -0.05379425f, 0.21794021f, -0.17744020f, -0.00180992f, 0.14886585f, 
    -0.12062395f, 0.20468791f, 0.40348628f, 0.00677822f, 0.11464117f, 0.38957033f, -0.16110745f, -0.11154169f, 
    0.37526190f, -0.07060360f, 0.14609975f, -0.38928774f, 0.04607477f, 0.16294204f, 0.74986988f, 0.15509686f, 
    0.04827449f, 0.54092330f, 0.03158668f, -0.34487355f, 0.10559961f, 0.38834369f, -0.05145527f, 0.08206921f, 
    0.40788364f, -0.07665906f, 0.10447272f, 0.26438802f, 0.27490634f, 0.13810411f, 0.32455552f, -0.15061778f, 
    -0.28276524f, 0.30290657f, -0.11253449f, -0.11750936f, -0.17340599f, 0.02664296f, -0.05402058f, -0.10148533f, 
    -0.16467422f, -0.20935579f, -0.26016510f, 0.05962392f, 0.12565485f, 0.21987100f, 0.03566091f, -0.02247095f, 
    -0.10982098f, 0.17877270f, -0.05081145f, 0.60895175f, -0.05106341f, -0.06380635f, -0.02286925f, 0.39875478f, 
    -0.17160478f, 0.13755210f, 0.10098238f, 0.00106917f, -0.02558112f, 0.13407597f, 0.04795888f, -0.17036976f, 
    0.04783189f, 0.18131717f, 0.06268553f, -0.13416293f, -0.03756497f, -0.03939281f, 0.13095206f, 0.27387139f, 
    -0.10599875f, 0.16272408f, -0.11126883f, -0.10085846f, -0.09826352f, 0.05614970f, 0.02198525f, 0.17846136f, 
    0.08901686f, -0.22509436f, 0.20941375f, 0.35221988f, 0.05863389f, 0.13912646f, 0.13675331f, 0.26837024f, 
    0.52493221f, 0.03782623f, 0.06702554f, 0.15552671f, 0.07035460f, -0.10989740f, -0.25131011f, 0.02089334f, 
    0.06252685f, 0.01189045f, 0.03532701f, 0.30374560f, -0.02845394f, -0.06120289f, -0.26102597f, -0.13333796f, 
    0.30441651f, 0.37261918f, -0.11504541f, 0.12485223f, 0.12296338f, 0.05837941f, 0.05411618f, 0.08976950f, 
    0.00212681f, 0.51649988f, 0.28491050f, 0.38675067f, -0.31388423f, 0.19199866f, 0.34438679f, 0.19952288f, 
    0.11558222f, -0.11882915f, -0.08524623f, 0.24818325f, 0.08031560f, 0.22195940f, 0.02125867f, -0.00507832f, 
    0.05353049f, -0.19186454f, -0.19334593f, 0.30897725f, 0.01502673f, -0.07438549f, 0.38382348f, -0.09891804f, 
    -0.02531084f, 0.25883165f, 0.02624735f, 0.30384901f, 0.04768460f, -0.17318188f, -0.60978985f, 0.07651889f, 
    -0.14109299f, -0.03683649f, 0.09172110f, 0.14339797f, 0.12625854f, 0.02599673f, 0.05902126f, 0.02287679f, 
    0.24169363f, -0.02401509f, 0.11622149f, 0.18278623f, -0.29981893f, -0.17231809f, -0.35639134f, 0.07640357f, 
    -0.21980633f, -0.35818294f, 0.25391644f, 0.07194056f, -0.06771517f, -0.00533175f, -0.07276244f, -0.08505330f, 
    0.65238565f, 0.41095716f, 0.32708180f, 0.04306543f, 0.13927107f, -0.11140443f, 0.07011668f, 0.07765455f, 
    0.10010578f, -0.00176950f, -0.02857641f, 0.03233747f, -0.13007820f, 0.18678369f, 0.41706586f, -0.15393986f, 
    0.09731936f, 0.13729799f, 0.20115671f, 0.08971134f, 0.03932811f, 0.21806003f, -0.07006502f, 0.16886413f, 
    0.07674287f, -0.22382075f, 0.00909165f, 0.27670547f, 0.19186854f, -0.61289626f, 0.22157450f, -0.02038587f, 
    0.02676461f, 0.05634042f, 0.11953456f, 0.18715495f, -0.09314582f, -0.07213186f, -0.33123603f, 0.04661349f, 
    0.06298009f, 0.10536373f, -0.09456795f, 0.13320525f, 0.08817275f, -0.39013937f, 0.05841921f, -0.20423505f, 
    -0.16721080f, -0.13134176f, 0.12186750f, 0.18222758f, 0.01939646f, -0.33740798f, -0.24522929f, 0.06272885f, 
    -0.20608637f, 0.49603462f, 0.38660732f, -0.25369170f, 0.10310265f, 0.06663362f, 0.08931558f, 0.28781888f, 
    0.48294327f, 0.17849702f, -0.03371742f, -0.03963113f, -0.00509604f, -0.11246762f, -0.05348160f, -0.38417488f, 
    -0.04154750f, 0.22029531f, -0.21760429f, 0.48467419f, -0.09144695f, 0.02245222f, 0.33149377f, 0.45196584f, 
    -0.04698614f, 0.09918863f, 0.34530094f, 0.37152675f, -0.21573092f, 0.31475961f, -0.13636446f, -0.02768105f, 
    -0.01564604f, 0.33321506f, -0.28296271f, 0.10547894f, 0.12693697f, -0.25403208f, 0.24165347f, 0.10511113f, 
    -0.19584230f, -0.44033191f, -0.09680828f, 0.11596774f, -0.06785265f, -0.39510411f, -0.25970334f, -0.01445464f, 
    0.23635632f, -0.10825910f, -0.03858910f, 0.43572572f, 0.06269008f, 0.33532220f, -0.35790929f, 0.06077354f, 
    0.04899652f, -0.10578124f, 0.07694568f, -0.09442057f, -0.13927725f, -0.01068865f, -0.11036538f, -0.03525025f, 
    -0.09825055f, -0.00829569f, 0.05039879f, -0.06724509f, 0.08505839f, 0.07258038f, -0.07623844f, -0.02548290f, 
    0.00773985f, -0.05978013f, -0.11953324f, -0.09679629f, -0.05657960f, 0.07098713f, -0.08533001f, -0.04829852f, 
    -0.06403108f, 0.08506870f, -0.00337153f, -0.14839455f, 0.10098792f, -0.09827422f, 0.10848248f, 0.03029145f, 
    0.03378192f, -0.15005097f, 0.10405902f, -0.01620057f, -0.15179873f, 0.07172866f, -0.13517304f, -0.02988515f, 
    -0.12436369f, 0.11007744f, -0.11517669f, -0.10966444f, 0.09644230f, -0.11854266f, -0.06681071f, 0.03429869f, 
    -0.11614176f, -0.08722687f, 0.08064076f, -0.08795385f, 0.00593406f, 0.00944145f, 0.02002510f, -0.04755069f, 
    0.01801369f, -0.05221983f, -0.00491850f, -0.15250903f, 0.09727350f, 0.01153630f, -0.01799366f, -0.05466007f, 
    -0.11154602f, 0.00062595f, 0.04933291f, -0.05606966f, -0.13624208f, 0.05931184f, 0.07078286f, -0.01626555f, 
    -0.09271842f, -0.16787659f, -0.03345261f, 0.12360689f, -0.05320789f, -0.10720621f, -0.09255797f, -0.07492992f, 
    0.06860085f, 0.00297460f, 0.00474143f, -0.07180263f, -0.16155984f, -0.12043028f, 0.08223763f, -0.07621976f, 
    -0.06623968f, -0.04349557f, -0.11892201f, 0.10835274f, 0.04571537f, 0.05938945f, -0.14729941f, -0.14592856f, 
    -0.11188692f, -0.09073935f, 0.07877704f, -0.02813197f, -0.09662881f, 0.05338647f, 0.06732917f, 0.04022664f, 
    0.09998733f, 0.09110074f, -0.12820879f, -0.08419894f, -0.12225492f, 0.04839470f, 0.07372156f, -0.01896527f, 
    -0.09591382f, 0.04501103f, -0.08405587f, -0.14602652f, 0.04893071f, -0.08801465f, -0.11576861f, 0.05316732f, 
    0.01055837f, 0.04537835f, -0.04617912f, 0.02302340f, -0.06311500f, -0.10729562f, -0.12819698f, -0.06761669f, 
    0.16177967f, -0.03095294f, -0.22511058f, -0.01005515f, 0.20887385f, 0.01563661f, 0.17845161f, 0.11353832f, 
    -0.20577961f, 0.14508860f, -0.10606444f, 0.25903022f, -0.06769477f, -0.05618498f, -0.04733555f, -0.09558803f, 
    -0.46953848f, -0.13589522f, -0.09223743f, -0.30381623f, -0.08049477f, 0.14873837f, 0.14944999f, 0.09234556f, 
    -0.09635880f, 0.44796494f, 0.28498033f, -0.13889095f, -0.12000033f, -0.35495633f, -0.02108311f, -0.03174037f, 
    -0.06605286f, 0.01381630f, -0.08374334f, 0.11033738f, 0.16075118f, -0.17889896f, 0.19104977f, 0.00574655f, 
    0.04722108f, 0.26438031f, 0.07702810f, 0.18534018f, -0.13040535f, 0.63840044f, -0.21922657f, -0.03376001f, 
    0.04314290f, 0.09254294f, 0.04677911f, -0.39680830f, -0.28709009f, -0.03795307f, 0.11170850f, 0.15805000f, 
    0.12173742f, 0.15288973f, 0.27703530f, -0.03805491f, -0.03238249f, -0.14516914f, -0.00489066f, 0.17528638f, 
    -0.37629035f, -0.07438724f, 0.32496917f, 0.17209193f, 0.32445139f, 0.31072524f, 0.36891231f, 0.01639902f, 
    0.09505947f, 0.08880206f, -0.03007377f, 0.13784386f, 0.09329209f, -0.03955916f, 0.35494196f, 0.19551270f, 
    -0.52892333f, -0.03999980f, 0.07983233f, 0.06265324f, 0.15292963f, 0.08759423f, 0.04216406f, 0.42719394f, 
    -0.08794757f, -0.26568472f, 0.01609690f, 0.20797649f, 0.43763310f, 0.06274817f, -0.18618792f, 0.29664057f, 
    0.15142868f, 0.08917910f, -0.11691252f, -0.24289981f, 0.09334766f, 0.02180696f, 0.20920147f, -0.01627192f, 
    0.11486275f, -0.09595481f, 0.33691540f, -0.19944540f, -0.11246721f, 0.20723052f, 0.14598699f, 0.43020332f, 
    -0.03105984f, 0.16960719f, 0.12410459f, 0.20323806f, 0.28006443f, 0.33939224f, 0.42056715f, -0.19032754f, 
    0.03058208f, -0.24887381f, 0.21978724f, 0.11127628f, -0.02906163f, 0.12332761f, 0.34179792f, 0.26816165f, 
    0.08592223f, -0.11427969f, -0.11266598f, -0.05026720f, -0.06256278f, -0.08326788f, 0.09443708f, 0.04702520f, 
    0.05670698f, 0.08575859f, -0.06037591f, -0.04276496f, -0.01954940f, 0.06387246f, -0.01216267f, -0.07169659f, 
    0.08563555f, -0.12727956f, -0.01953836f, -0.09825681f, -0.01809163f, -0.11659059f, -0.04060656f, -0.11560196f, 
    0.06667410f, 0.00782932f, 0.02362843f, -0.10959014f, -0.04729892f, -0.11627642f, -0.00594650f, 0.10183380f, 
    -0.05555822f, -0.09978531f, -0.09638665f, -0.05291670f, -0.12294188f, -0.11213114f, -0.03482283f, -0.12574939f, 
    0.07604080f, -0.00037099f, -0.08513150f, 0.09119667f, -0.06205212f, 0.02654255f, -0.00571924f, 0.02603191f, 
    -0.01655932f, -0.10948937f, -0.08433592f, 0.09745989f, 0.07003792f, 0.04256326f, -0.06699346f, 0.11281275f, 
    0.10323618f, 0.07966085f, 0.04834895f, -0.07202511f, -0.01713529f, -0.10867204f, -0.11493655f, -0.00140186f, 
    -0.14935832f, 0.05717703f, -0.09282631f, 0.05885556f, 0.07946617f, -0.00007130f, 0.00959315f, 0.11060827f, 
    0.09435860f, 0.10140542f, -0.03391880f, -0.08943255f, 0.03407078f, -0.08381830f, -0.06825798f, -0.01161905f, 
    -0.06862030f, -0.05702700f, 0.00566088f, 0.04134775f, 0.04626780f, -0.10866237f, -0.05744247f, -0.03447823f, 
    0.09908171f, 0.13567714f, 0.07054666f, 0.07662981f, -0.09988582f, -0.02592279f, -0.07644746f, 0.13678648f, 
    -0.11698432f, -0.05501731f, -0.04455136f, 0.04897421f, -0.05310249f, -0.12047099f, -0.12728710f, -0.00052650f, 
    0.11642252f, 0.07625581f, 0.09057189f, -0.09877721f, 0.00020469f, 0.05857725f, 0.06494835f, -0.10870605f, 
    -0.05292247f, -0.06932126f, -0.14374442f, -0.11617221f, 0.00004827f, -0.16068862f, -0.13528737f, -0.08245746f, 
    -0.05399726f, 0.03873922f, 0.07955088f, 0.05350237f, -0.01738435f, 0.04568240f, -0.14614186f, 0.09547435f, 
    -0.02093995f, -0.00671597f, 0.11072254f, -0.12169369f, -0.04528050f, 0.03522416f, 0.07729566f, -0.07842508f, 
    0.00336758f, -0.05942971f, -0.02210773f, -0.06520484f, -0.04764373f, 0.05804776f, 0.11402900f, -0.09683249f, 
    -0.07354245f, -0.02747423f, -0.11812748f, -0.06611665f, -0.09125894f, -0.06970161f, -0.05980796f, -0.08358163f, 
    0.00865805f, -0.14197904f, 0.06502166f, -0.08896541f, -0.10927614f, -0.12369318f, 0.04145055f, -0.05023133f, 
    -0.06270888f, -0.00577886f, -0.06909987f, -0.08797473f, 0.03725939f, 0.08970032f, -0.01193981f, 0.05946843f, 
    0.05317946f, -0.07597841f, -0.10876877f, -0.09594549f, -0.02660082f, -0.05864284f, -0.06174141f, -0.11091610f, 
    0.05578997f, -0.03115598f, 0.08497996f, 0.01812643f, 0.03481700f, -0.12152031f, -0.06694529f, 0.09764680f, 
    -0.06383345f, 0.00899508f, 0.07515641f, 0.10311376f, 0.08118558f, 0.04692195f, -0.04798960f, -0.04756879f, 
    -0.69066298f, -0.07650568f, 0.03054983f, 0.10874300f, 0.35503849f, 0.25893310f, -0.05340536f, 0.26840547f, 
    -0.17473221f, 0.01459364f, 0.07452761f, -0.00799800f, -0.03038955f, -0.06819230f, 0.25981203f, 0.16938111f, 
    -0.01852313f, -0.17632923f, 0.16516705f, -0.39556617f, -0.30927047f, -0.04415618f, -0.08501948f, -0.02337842f, 
    0.03698583f, -0.21444915f, 0.06222757f, -0.18270400f, 0.33187082f, -0.24487565f, 0.23352830f, -0.00371652f, 
    0.11177380f, 0.17110579f, 0.16412511f, -0.17716616f, 0.22202466f, -0.14041239f, 0.20015831f, -0.07792066f, 
    0.02872965f, 0.30544987f, 0.35163426f, -0.06745479f, 0.10649145f, 0.01509097f, -0.25393507f, 0.19269009f, 
    -0.06389415f, -0.11557826f, -0.17006284f, -0.34315172f, -0.01408178f, 0.18152827f, 0.48229045f, -0.10995748f, 
    0.30919188f, 0.17661414f, 0.32863745f, 0.07412235f, 0.02200551f, -0.09770098f, -0.23982333f, 0.25784165f, 
    0.03985365f, 0.04312757f, -0.06985834f, 0.00945675f, -0.09780519f, 0.09133945f, -0.09105109f, 0.02887587f, 
    0.07846121f, 0.02732583f, -0.04034298f, -0.13182621f, -0.07339647f, 0.02581991f, -0.06390030f, 0.01295477f, 
    -0.09339569f, 0.05371735f, -0.11043887f, -0.00891268f, 0.05512632f, 0.03202339f, 0.06776650f, -0.00546396f, 
    0.07585854f, -0.14388719f, -0.06477804f, -0.07971605f, -0.12664849f, 0.04931436f, -0.00585688f, 0.07060006f, 
    -0.04070463f, -0.10885794f, 0.00373641f, -0.01813286f, -0.04845320f, -0.08402532f, -0.07146239f, -0.00321476f, 
    0.09009343f, 0.04548143f, -0.05448455f, 0.10671434f, -0.04940604f, -0.05590320f, -0.08106317f, -0.07411443f, 
    -0.09314489f, 0.05034664f, 0.04410043f, -0.06553125f, -0.03477122f, 0.00954474f, 0.02964745f, 0.00438201f, 
    0.03890228f, -0.08294144f, -0.06939179f, 0.03838031f, -0.09297776f, -0.08494033f, -0.13040155f, 0.05846907f, 
    0.34387738f, -0.11025953f, 0.04926796f, 0.30163351f, -0.40681753f, -0.06515633f, 0.06260996f, 0.00106165f, 
    -0.04770416f, -0.14805262f, -0.11486793f, -0.32507378f, 0.00289692f, 0.03027110f, 0.08800845f, -0.11387142f, 
    -0.15793350f, 0.38871261f, 0.23561975f, 0.54341608f, 0.53532487f, -0.06668328f, 0.34976277f, 0.12250342f, 
    0.05246831f, -0.09281321f, -0.13191736f, 0.13981779f, 0.04495821f, 0.47492492f, -0.16902445f, -0.16502874f, 
    0.07804587f, 0.08781158f, 0.02729618f, 0.16907328f, 0.08094276f, 0.31150314f, -0.10298607f, 0.02543315f, 
    0.10006100f, 0.15598448f, -0.25401127f, 0.15695217f, 0.19112475f, -0.60437417f, 0.54303998f, -0.06501948f, 
    -0.02167743f, 0.07999387f, 0.24837951f, 0.43615788f, -0.15658373f, -0.01936917f, 0.07105068f, -0.19035162f, 
    -0.16906175f, -0.18287231f, -0.20835572f, 0.12226126f, -0.03412632f, -0.23841614f, 0.51300550f, -0.09515844f, 
    -0.51331502f, -0.02757835f, -0.39241511f, -0.41194451f, -0.15182142f, -0.26366651f, -0.18053898f, 0.16567509f, 
    0.11878435f, 0.09193287f, 0.13784039f, 0.12795748f, 0.05645589f, -0.06534059f, -0.09821883f, -0.22627689f, 
    0.24259004f, 0.20365059f, 0.04795099f, -0.41671091f, -0.02129319f, -0.05745676f, -0.01904583f, -0.20618030f, 
    -0.07613850f, 0.35088181f, 0.03733010f, -0.12885615f, -0.30720076f, -0.03728035f, 0.18723996f, 0.18811476f, 
    -0.10733812f, 0.07876533f, 0.10541840f, 0.42354110f, 0.17388974f, 0.01331955f, 0.15862353f, -0.04297215f, 
    -0.10369278f, 0.23967257f, -0.12884396f, 0.26230365f, 0.16356201f, 0.12257616f, -0.07274255f, 0.00771998f, 
    0.13434049f, -0.27821621f, 0.06983148f, -0.04617074f, -0.04622023f, -0.04518241f, -0.37192717f, 0.28301266f, 
    0.08325987f, 0.25133494f, -0.06078945f, -0.10856149f, -0.11543092f, 0.25223425f, -0.27377874f, -0.17712179f, 
    -0.09978830f, 0.08861777f, 0.06285852f, 0.08687718f, -0.36303949f, -0.03275738f, -0.03732090f, 0.07240159f, 
    0.05538275f, -0.17982699f, -0.01503360f, 0.12436926f, 0.07030057f, -0.02352279f, -0.02518144f, 0.02071760f, 
    -0.08747661f, 0.28588963f, 0.31987888f, 0.25231385f, 0.10762674f, 0.05660884f, 0.17091577f, 0.20509996f, 
    0.05051169f, 0.00414044f, 0.21652082f, -0.17942299f, -0.08225069f, 0.28000250f, 0.20770414f, -0.51844627f, 
    0.32187819f, -0.04449033f, -0.07423831f, 0.08987089f, 0.14843361f, -0.10207976f, -0.08118183f, 0.26566163f, 
    0.07021330f, 0.07033475f, 0.02090910f, 0.11113692f, 0.24706995f, -0.07871167f, -0.00393584f, -0.16298297f, 
    0.32258937f, -0.02441338f, 0.25625512f, 0.20797412f, 0.25927427f, 0.21317214f, -0.23002024f, 0.09901084f, 
    -0.07263602f, 0.29805779f, -0.24034692f, -0.35218075f, -0.02089448f, -0.11773831f, 0.02498189f, -0.36203480f, 
    -0.03542694f, 0.05480628f, -0.02130654f, -0.00440732f, 0.04448298f, 0.03509391f, -0.10468471f, -0.01656425f, 
    0.19651861f, 0.04999775f, 0.06234614f, 0.01391955f, 0.09320099f, 0.09158758f, -0.06220082f, -0.13224865f, 
    0.05066061f, 0.08852797f, -0.03138866f, 0.05581646f, 0.14537880f, 0.04549878f, 0.01906351f, -0.10572200f, 
    0.00144441f, 0.01495908f, 0.03630148f, -0.03324308f, 0.07384346f, 0.15449725f, -0.02619213f, 0.16475882f, 
    -0.06841557f, -0.11701705f, -0.10746659f, 0.06880733f, -0.09880936f, -0.08350915f, -0.05486990f, -0.00564795f, 
    0.02340632f, -0.08220340f, -0.10265589f, 0.09083015f, 0.11416933f, 0.08001628f, 0.04821520f, 0.14013992f, 
    -0.03173938f, 0.11688924f, -0.01836662f, -0.03757176f, 0.09510350f, -0.02105900f, 0.03899837f, 0.06374767f, 
    -0.11188751f, 0.05792717f, -0.10163915f, -0.00646904f, -0.04098563f, -0.04543777f, 0.04977175f, 0.12621412f, 
    0.03498798f, -0.05020142f, -0.10492539f, 0.03549350f, 0.28111568f, 0.11107893f, -0.15717506f, 0.07867178f, 
    -0.08444238f, -0.18586852f, 0.22419418f, -0.10617664f, 0.09305662f, -0.11378568f, 0.22644570f, 0.24860716f, 
    0.65494412f, -0.22021174f, -0.01735056f, -0.48873228f, -0.56705105f, -0.09259120f, -0.21190363f, -0.14662379f, 
    -0.03211860f, 0.04198791f, 0.02548706f, -0.39054576f, 0.14784300f, -0.10402995f, -0.09067387f, 0.05856518f, 
    0.17033395f, 0.08496629f, 0.29105788f, 0.11179399f, 0.15438266f, -0.27734569f, -0.07791428f, 0.10678907f, 
    0.11416030f, 0.13585609f, 0.16709250f, 0.23804195f, 0.00542726f, 0.14614177f, -0.04813940f, 0.09210608f, 
    0.17462517f, -0.19207428f, 0.02815575f, -0.39536801f, 0.07193255f, -0.07725608f, 0.08206943f, 0.09870432f, 
    0.37549195f, 0.16430348f, -0.00511825f, 0.08937855f, 0.09782527f, -0.26628527f, -0.27680477f, -0.04009520f, 
    0.11824965f, -0.11886310f, -0.06133686f, 0.31688467f, 0.01597479f, 0.19620253f, -0.30123252f, 0.27807549f, 
    -0.18674232f, 0.16163950f, 0.25347996f, -0.02434740f, 0.09244262f, -0.03774039f, 0.22329991f, 0.27766755f, 
    0.25958055f, 0.07786970f, 0.23416659f, 0.25854024f, -0.34203681f, -0.09794370f, 0.07230103f, -0.14437579f, 
    -0.09482677f, -0.32984728f, -0.10904761f, -0.16152136f, 0.11751045f, 0.04940460f, 0.37356591f, 0.04472085f, 
    0.23587057f, 0.07077771f, 0.34223607f, 0.04576659f, -0.02490961f, 0.16307336f, -0.17790292f, 0.27121398f, 
    -0.07914075f, 0.36791804f, -0.01883251f, 0.27002111f, 0.32719913f, -0.19557551f, 0.13356519f, 0.01420431f, 
    -0.03945272f, -0.23272422f, -0.17715472f, 0.03324872f, -0.09252623f, -0.17609693f, -0.08517220f, -0.15491423f, 
    0.29697418f, 0.07144967f, -0.16261628f, 0.32357159f, 0.12117770f, -0.41130000f, -0.01983922f, 0.00835689f, 
    -0.37224922f, 0.04742108f, -0.07061788f, -0.34839693f, 0.08174923f, -0.16501905f, -0.10445306f, 0.07540007f, 
    0.19896138f, 0.00544448f, 0.11072885f, 0.23180245f, -0.00273607f, -0.06897958f, -0.42435226f, -0.08256725f, 
    -0.16726910f, 0.21280339f, 0.00137549f, -0.42658547f, -0.00914405f, 0.17310145f, 0.06415486f, 0.22946763f, 
    0.10868794f, 0.37656012f, 0.26292655f, 0.21783823f, -0.10032404f, 0.10771137f, 0.33330509f, 0.25480318f, 
    -0.17460252f, -0.00790092f, -0.17565836f, 0.04228165f, -0.00524341f, -0.07610793f, 0.35203338f, -0.08007985f, 
    0.08697408f, -0.19445530f, -0.14781603f, 0.13575165f, 0.04423973f, 0.21056670f, -0.19629866f, 0.12212592f, 
    0.06519346f, 0.28176287f, 0.23869121f, 0.14344919f, 0.18263845f, 0.14369126f, -0.22785278f, 0.10503606f, 
    -0.19477916f, 0.04126902f, 0.11380750f, -0.24089307f, 0.00100172f, 0.35516983f, 0.00621703f, 0.07702736f, 
    -0.05212897f, 0.02258006f, 0.04998582f, -0.07242207f, -0.02389175f, 0.01912288f, 0.03348335f, 0.07142493f, 
    0.01532206f, 0.07505769f, 0.00156586f, 0.08377519f, 0.10108586f, 0.03997378f, -0.02568618f, -0.02092251f, 
    -0.04717200f, 0.04071811f, -0.12969953f, -0.11844407f, 0.01727233f, 0.03637261f, -0.00170505f, -0.00695514f, 
    0.01937570f, -0.08344349f, -0.10105623f, -0.06086744f, -0.04673040f, 0.00499974f, 0.03737490f, 0.10501400f, 
    -0.11521939f, -0.03994504f, 0.03100637f, -0.12343587f, -0.11233399f, 0.01610136f, -0.09297764f, -0.11249283f, 
    -0.06386331f, -0.00629325f, -0.12720674f, -0.03608640f, -0.11892810f, -0.12715791f, -0.06112623f, 0.04251041f, 
    0.06327665f, 0.02348076f, 0.08040705f, -0.10300324f, -0.01028839f, 0.01493554f, 0.00182965f, -0.00262598f, 
    0.05081528f, -0.11514837f, -0.10983817f, -0.11657207f, -0.02329750f, -0.05583632f, 0.05493916f, 0.01001509f, 
    -0.13474168f, -0.00532499f, -0.00883522f, -0.05677373f, -0.09151624f, -0.09900817f, -0.06489849f, -0.11331841f, 
    -0.05833291f, 0.00669541f, -0.08498957f, -0.02090559f, -0.04667611f, -0.09222184f, -0.13473044f, -0.01444058f, 
    0.10705237f, -0.11680293f, -0.09513773f, -0.06306730f, 0.04160324f, -0.03505633f, -0.12676936f, 0.01488609f, 
    -0.05936642f, -0.08219452f, 0.01314546f, -0.08621589f, 0.01200127f, -0.16303536f, 0.01284964f, 0.10357356f, 
    -0.11948761f, 0.02127525f, -0.08809406f, 0.00179224f, 0.06401663f, -0.05716794f, -0.09855062f, -0.03896238f, 
    0.11369249f, 0.04740465f, 0.03732409f, -0.13553537f, -0.09078068f, -0.00104044f, -0.12305191f, -0.03331368f, 
    0.03437581f, -0.01741879f, 0.03946633f, -0.15462483f, 0.04830013f, -0.08460041f, 0.08982757f, 0.01854804f, 
    -0.07255436f, 0.04479022f, -0.08081752f, -0.08758432f, 0.01576003f, 0.03867297f, -0.05755772f, -0.09248108f, 
    0.36977717f, 0.11539503f, 0.34783730f, 0.49445260f, 0.32084164f, 0.33298311f, 0.28876680f, -0.10508540f, 
    -0.04783674f, -0.00625760f, 0.03795260f, 0.00381536f, 0.01032492f, 0.01896076f, 0.44174951f, 0.26917711f, 
    0.09976012f, -0.23515071f, 0.20010310f, 0.01485169f, -0.10499856f, -0.07156870f, 0.02838182f, 0.09212612f, 
    0.09400217f, -0.33261204f, 0.01712101f, 0.57462955f, 0.40921825f, -0.08117308f, -0.08941812f, 0.06400141f, 
    0.12704371f, 0.09954233f, -0.02729922f, 0.02538615f, -0.12498517f, 0.11182925f, -0.19026707f, 0.10114605f, 
    0.09205192f, 0.04619515f, 0.09335914f, -0.14300220f, -0.06526127f, 0.03727428f, 0.15507697f, 0.18816930f, 
    -0.12063122f, -0.01089772f, -0.15660734f, -0.04762670f, 0.15910511f, 0.00530098f, 0.06011349f, -0.18469080f, 
    0.32259274f, -0.32567593f, 0.09400700f, 0.49055189f, -0.07841313f, -0.16558413f, 0.32133952f, 0.34334826f, 
    0.07958204f, -0.07539254f, -0.09166127f, -0.00929167f, 0.02994541f, -0.11207876f, -0.02092721f, -0.02476407f, 
    0.06726931f, -0.01040499f, 0.01432059f, 0.00879178f, -0.07142745f, 0.05773057f, -0.11755086f, -0.13110836f, 
    0.05327911f, -0.01403768f, -0.07743758f, 0.03623985f, -0.07054830f, 0.02167083f, -0.02929656f, 0.06128937f, 
    -0.00908576f, 0.05657872f, 0.00591590f, 0.09276011f, -0.04750511f, -0.11970215f, -0.12972791f, 0.01383014f, 
    -0.12211064f, 0.03460320f, 0.07318374f, -0.13723132f, 0.04803469f, 0.05305178f, -0.09640013f, -0.09088512f, 
    0.02391914f, -0.04616941f, -0.14381222f, -0.11139863f, 0.10157162f, -0.06645130f, -0.10435446f, 0.07141815f, 
    -0.14521009f, 0.05387396f, 0.02872294f, -0.10128220f, 0.11671071f, 0.08602419f, -0.12718286f, -0.09538938f, 
    -0.01537037f, 0.08738835f, -0.06568096f, 0.04398997f, 0.06957066f, -0.05697416f, -0.09246121f, -0.12244897f, 
    0.60701150f, -0.05884505f, -0.08279677f, 0.13786529f, 0.09288432f, -0.01328268f, 0.03256989f, -0.00871922f, 
    -0.27014214f, -0.11183299f, 0.23362283f, 0.37614399f, 0.04713906f, 0.12669176f, -0.11140785f, 0.05818944f, 
    0.59058952f, -0.10666677f, -0.05265452f, -0.30789763f, -0.42954972f, -0.03637056f, 0.04600081f, -0.27284417f, 
    -0.09995884f, 0.01021635f, 0.10109632f, 0.69392669f, -0.22679253f, -0.24107872f, 0.42374125f, 0.29384723f, 
    0.24013057f, 0.11732914f, 0.23213999f, 0.20376749f, 0.06425236f, 0.05143182f, 0.16721784f, 0.00475479f, 
    -0.06395271f, 0.09363882f, 0.11730360f, 0.32035184f, -0.03043224f, 0.17016172f, 0.02212714f, 0.23266019f, 
    0.06457862f, -0.04558648f, -0.04020851f, -0.23078433f, -0.35133481f, -0.22675721f, -0.24263513f, 0.18510611f, 
    0.19118549f, -0.01620829f, 0.05711944f, 0.26042372f, 0.05199125f, -0.61921257f, 0.15106083f, 0.19292915f, 
    -0.57849169f, 0.02319002f, -0.10249574f, 0.09268668f, 0.09986937f, 0.38289225f, 0.00497108f, 0.41463012f, 
    -0.27416289f, 0.03954916f, -0.02978360f, 0.03133578f, -0.12723844f, -0.06103056f, 0.21003102f, 0.02315334f, 
    -0.18100044f, -0.31165189f, 0.02252377f, -0.40255818f, -0.28374618f, -0.16931085f, -0.11026008f, 0.04691893f, 
    0.03303790f, -0.04439695f, 0.09452312f, -0.20273241f, 0.29184151f, -0.17866854f, 0.30473089f, -0.21505252f, 
    0.03595822f, 0.22926722f, 0.28414869f, -0.09130462f, 0.19008675f, -0.29532853f, 0.19298880f, 0.04319890f, 
    0.09676594f, 0.53358698f, 0.30518237f, -0.11770062f, 0.22762744f, 0.02320044f, -0.28033239f, 0.24136861f, 
    0.02217591f, -0.18086803f, 0.00316599f, -0.42712322f, -0.13992625f, 0.08208086f, 0.48401374f, 0.12172607f, 
    0.36208749f, 0.31063813f, 0.19107677f, -0.01108797f, -0.10585186f, 0.01756145f, -0.20325945f, 0.16239674f, 
    -0.05420847f, 0.11519641f, -0.03825756f, -0.06246528f, -0.08865780f, -0.09911985f, 0.00818751f, 0.03231998f, 
    0.05525587f, -0.11296743f, -0.08659206f, -0.06386193f, -0.04038806f, -0.06867605f, 0.07614056f, 0.06168996f, 
    -0.13463144f, -0.08189360f, 0.01457370f, 0.02776477f, -0.12729466f, -0.01720579f, -0.14701889f, -0.14809412f, 
    -0.02051367f, -0.01821130f, 0.07094618f, 0.03352125f, -0.11056539f, 0.01446401f, -0.02074578f, 0.09561510f, 
    -0.13614792f, -0.02289412f, -0.05344196f, -0.11978488f, -0.07815842f, 0.06206728f, -0.02151813f, 0.04338388f, 
    0.07201083f, 0.06846487f, 0.08608976f, -0.03124289f, 0.03412369f, -0.03222252f, -0.04357168f, 0.07250668f, 
    -0.01304851f, -0.00580841f, -0.03534538f, 0.01863398f, 0.04997357f, 0.04993907f, -0.01554379f, -0.07510857f, 
    -0.06133720f, 0.04228551f, -0.04897623f, -0.11445522f, 0.09545729f, -0.12414007f, 0.00664838f, 0.09207321f, 
    -0.18046069f, -0.04338898f, 0.01273462f, -0.04101292f, -0.00977700f, -0.12484914f, 0.05232134f, 0.04929657f, 
    0.00975626f, -0.11794535f, -0.16069837f, 0.02417575f, 0.11679807f, -0.11511587f, 0.06083670f, -0.08220766f, 
    -0.12651347f, -0.08998766f, -0.11417218f, 0.04349305f, -0.04219919f, 0.02673690f, -0.02761137f, -0.00883694f, 
    0.10267242f, 0.03292299f, -0.04840203f, -0.09042284f, -0.07553230f, 0.05591763f, -0.10108576f, 0.04126080f, 
    -0.05508360f, -0.02040098f, 0.08667099f, 0.07852744f, -0.04874432f, -0.00946859f, -0.01629778f, -0.12419023f, 
    0.02128887f, -0.13821258f, -0.12685302f, -0.06084760f, -0.01853633f, -0.13140278f, 0.06426225f, -0.16180578f, 
    0.03813126f, -0.09897879f, 0.02104735f, 0.04757652f, 0.00289940f, -0.07532840f, 0.01206594f, 0.00097005f, 
    -0.10550147f, -0.12023691f, 0.02131802f, -0.03064074f, -0.01513427f, -0.10320072f, -0.04762999f, -0.10450898f, 
    0.44596940f, 0.00637611f, -0.34519249f, 0.02020478f, -0.09311090f, 0.00596821f, -0.16775106f, 0.31014794f, 
    -0.08224384f, -0.15968154f, 0.13635111f, 0.06078381f, 0.11547004f, -0.05352194f, -0.14332552f, 0.10935247f, 
    0.71993506f, -0.16468133f, 0.11732477f, -0.07503841f, -0.15867145f, -0.05677503f, -0.02111971f, -0.23470426f, 
    0.02300308f, 0.04962911f, 0.14595467f, -0.34286726f, 0.01966681f, -0.11646976f, 0.02022828f, -0.54276437f, 
    0.27416560f, 0.14066993f, 0.12539478f, -0.05994336f, 0.13154174f, -0.04909239f, -0.04937952f, 0.22044414f, 
    -0.05146819f, 0.17092077f, 0.14781037f, 0.16935158f, 0.12644330f, 0.10627912f, -0.20982574f, -0.17803586f, 
    0.30958554f, -0.12867476f, -0.03670685f, -0.36375752f, -0.31517318f, -0.00511199f, -0.13753700f, 0.10030413f, 
    -0.03102150f, 0.44212899f, -0.02340210f, -0.12228392f, 0.10900746f, -0.48509228f, -0.02511498f, -0.19205219f, 
    0.11129553f, -0.12261192f, 0.01236313f, 0.01666671f, 0.00966525f, -0.03924345f, -0.04329553f, -0.00306086f, 
    -0.01100870f, -0.11879190f, -0.11145151f, -0.11190924f, 0.06899700f, 0.10043541f, -0.08533626f, 0.04187919f, 
    -0.06467717f, 0.02387343f, 0.04738674f, -0.09137515f, -0.05484675f, 0.11551803f, -0.08815200f, 0.07066508f, 
    -0.07202151f, -0.15186994f, 0.02523133f, 0.02973937f, 0.04862722f, 0.00956910f, 0.09835334f, 0.04964404f, 
    0.07132576f, 0.03073497f, -0.03409145f, 0.00655907f, -0.06415775f, 0.00159948f, 0.09839448f, -0.05360444f, 
    0.04159528f, -0.10844773f, -0.09051769f, -0.16344926f, -0.01915908f, -0.06828562f, -0.08499385f, -0.08927017f, 
    -0.06519980f, -0.11240626f, -0.07019492f, -0.09814277f, 0.04347820f, -0.08224396f, 0.03461140f, 0.10277061f, 
    -0.11992492f, -0.07772680f, -0.08570575f, 0.04463103f, 0.11110732f, -0.03012371f, 0.02836827f, -0.08661306f, 
    -0.11670080f, 0.06309663f, -0.08125219f, -0.04406294f, -0.11303910f, -0.04087966f, 0.06159998f, -0.08955353f, 
    -0.04907368f, 0.03262442f, 0.01932617f, 0.10762332f, -0.11974187f, -0.05964705f, 0.04907931f, -0.01235208f, 
    0.00038466f, 0.01675271f, 0.10044428f, 0.03100192f, -0.14844045f, -0.04016214f, 0.10578567f, -0.14057977f, 
    -0.06150019f, -0.03293107f, -0.04596855f, 0.07145000f, 0.02530664f, -0.07586215f, -0.11047149f, 0.05783997f, 
    0.04775971f, 0.03086860f, -0.02711968f, -0.05752192f, -0.05138021f, -0.07508302f, -0.04594189f, -0.07090399f, 
    -0.05526157f, -0.12515269f, -0.05167626f, -0.02690812f, -0.09195960f, 0.01816332f, 0.06094939f, -0.04546650f, 
    0.02893209f, -0.09661990f, -0.07257045f, -0.00186696f, -0.09698969f, 0.07131311f, -0.12039987f, -0.09567032f, 
    -0.09806553f, 0.06656548f, -0.06087885f, -0.01426610f, -0.10681562f, 0.04643588f, -0.02838249f, 0.00732037f, 
    0.12627147f, -0.04495381f, 0.08391253f, 0.05032634f, -0.03134585f, -0.14230449f, -0.39577043f, 0.27115539f, 
    0.28949618f, -0.30958301f, 0.14517716f, -0.03711052f, -0.02567989f, -0.09503363f, 0.11950475f, 0.29087111f, 
    0.87492341f, 0.08752529f, -0.03494143f, 0.05730114f, -0.11995129f, -0.14651895f, -0.14198573f, -0.06988084f, 
    -0.05426574f, 0.22135524f, -0.26175258f, 0.15940969f, 0.12841316f, 0.16593537f, -0.16290200f, 0.33771074f, 
    0.20001000f, 0.06640084f, 0.12023449f, -0.08706980f, 0.06913405f, 0.22913541f, -0.06166458f, 0.17759979f, 
    0.05816145f, -0.29638317f, 0.09338471f, 0.17910416f, 0.18769956f, -0.70640773f, 0.48982820f, 0.12070008f, 
    0.03123677f, 0.11669929f, -0.04193729f, 0.15749671f, -0.38131517f, -0.02115192f, -0.09621502f, -0.17316845f, 
    0.05758305f, 0.00955980f, 0.22173370f, 0.08319031f, -0.07802196f, -0.00726109f, -0.02348950f, 0.05396994f, 
    -0.07747520f, 0.06313881f, 0.09304773f, -0.15730180f, -0.25387841f, 0.00227071f, 0.05604595f, -0.00704508f, 
    0.38506743f, -0.10557795f, -0.03052632f, 0.26984510f, -0.03382437f, 0.04864034f, 0.00589847f, -0.14950442f, 
    -0.23037279f, 0.32648423f, 0.27709654f, 0.40095010f, 0.34913674f, 0.06856165f, -0.00881611f, 0.10644709f, 
    -0.02321623f, -0.13143046f, 0.27464360f, -0.71209949f, 0.07986429f, 0.14145125f, 0.07514707f, -0.46723711f, 
    0.15208568f, 0.08053777f, -0.00649126f, -0.05233225f, 0.20729235f, -0.02118686f, 0.05827349f, 0.22060651f, 
    -0.07095980f, -0.18119922f, 0.12005528f, 0.16346803f, -0.04843023f, 0.23302360f, -0.02461909f, -0.19753233f, 
    0.30723554f, 0.20025708f, 0.23816289f, 0.20228130f, 0.20794572f, 0.15852033f, -0.13229071f, 0.14453129f, 
    0.01671909f, 0.33943102f, -0.28464860f, -0.38376877f, 0.03447529f, -0.05431104f, -0.05659358f, -0.40538329f, 
    -0.15461653f, 0.06303038f, 0.34307134f, 0.15471572f, 0.31654355f, 0.28691295f, 0.32913542f, -0.21761627f, 
    -0.13937257f, 0.17146002f, 0.17143542f, 0.07331274f, -0.12079308f, 0.05363401f, 0.18633260f, 0.29082066f, 
    -0.10286466f, -0.20755918f, 0.18797649f, -0.00553880f, 0.00598932f, 0.16803202f, 0.04136401f, 0.16743600f, 
    0.04151766f, -0.36425808f, 0.09764390f, 0.10023431f, 0.36969778f, 0.03532349f, -0.12343808f, -0.26983216f, 
    0.00413798f, 0.17216969f, -0.10945626f, -0.02111294f, -0.03965216f, 0.13385843f, -0.00541192f, 0.02675291f, 
    -0.03283318f, -0.04032365f, -0.01202707f, -0.09392020f, -0.04023978f, 0.10484034f, 0.05557497f, 0.01193754f, 
    -0.03872985f, 0.09466622f, 0.03424088f, -0.07852170f, 0.35113549f, 0.10039360f, 0.32925087f, -0.07822707f, 
    0.10211151f, -0.01527280f, -0.04026263f, 0.27730387f, -0.07678194f, 0.11305560f, 0.10472807f, 0.21126224f, 
    0.11451384f, -0.08649795f, -0.23551065f, 0.04446860f, 0.05833455f, 0.05817155f, 0.10329133f, -0.14302100f, 
    -0.23831542f, 0.19062047f, 0.04875806f, -0.02249020f, 0.04299782f, -0.01707815f, -0.17325367f, -0.19325814f, 
    -0.20270073f, -0.03278761f, -0.16333491f, -0.16504960f, -0.18265018f, -0.04024593f, 0.00703649f, -0.25312033f, 
    -0.04898395f, 0.39796144f, 0.18836996f, -0.13966440f, -0.06265887f, -0.17818043f, 0.12854385f, 0.02370672f, 
    -0.23996434f, 0.01788675f, -0.01627344f, 0.18505709f, 0.14043960f, -0.11445159f, 0.24185178f, 0.00656966f, 
    0.05956557f, 0.13606896f, -0.03730419f, 0.17303431f, -0.11900904f, 0.43090862f, -0.14133069f, -0.09719323f, 
    0.10012596f, 0.02419297f, 0.06664380f, -0.00183703f, -0.03383059f, -0.16314006f, -0.28122661f, -0.01837091f, 
    -0.09861064f, 0.20597684f, -0.06789716f, -0.10466373f, -0.08654658f, -0.10657079f, -0.15234376f, -0.07247369f, 
    -0.02668056f, 0.07064360f, 0.01216541f, 0.02508368f, -0.13767172f, 0.02216119f, 0.07655463f, -0.06231407f, 
    0.04565128f, 0.30768880f, 0.05348289f, -0.06967457f, -0.01722898f, -0.06320935f, 0.12460300f, -0.11673547f, 
    -0.58260655f, -0.14311549f, 0.20657131f, 0.21866162f, 0.38384974f, -0.09418600f, 0.21784317f, 0.15981251f, 
    0.06771553f, -0.35615224f, 0.12803650f, -0.36295617f, -0.06369902f, 0.03325097f, 0.17448850f, -0.29712835f, 
    -0.04951802f, -0.07829090f, 0.20686740f, 0.20060931f, 0.22284250f, 0.02094891f, 0.20276931f, 0.00102616f, 
    -0.01518838f, 0.49713054f, 0.00549548f, 0.13969800f, 0.09204702f, -0.06893110f, -0.01117073f, 0.00149375f, 
    0.14268382f, -0.22153838f, 0.12586750f, 0.00205859f, 0.32842496f, 0.11552994f, 0.26322010f, 0.14984207f, 
    -0.02536575f, -0.02751203f, -0.27659634f, -0.01662895f, 0.08621503f, -0.05797365f, 0.06500178f, -0.05680446f, 
    0.24863513f, 0.06291646f, 0.24938755f, 0.47605053f, 0.09754261f, 0.12530604f, -0.17006426f, -0.14321433f, 
    -0.08311587f, -0.17919144f, 0.15172853f, 0.31955719f, -0.15490817f, -0.06146610f, 0.37763250f, 0.30497473f, 
    0.53807986f, -0.06203717f, 0.21830301f, 0.08798597f, -0.30868116f, -0.08948475f, -0.17526774f, 0.26396385f, 
    -0.06042330f, -0.30861455f, 0.01791938f, 0.27269202f, 0.44001922f, 0.07113705f, 0.00699083f, 0.07895461f, 
    0.37488455f, 0.11298994f, 0.07789584f, -0.29459280f, 0.01187429f, 0.01576889f, -0.31301603f, 0.10047281f, 
    0.10063598f, -0.38980290f, 0.27842328f, -0.00264632f, 0.05469927f, -0.11305039f, 0.05539228f, 0.10717706f, 
    -0.16065134f, 0.11699343f, -0.05479047f, 0.19188224f, 0.01801958f, -0.09865769f, -0.28611541f, 0.01973956f, 
    0.27805778f, -0.11157726f, 0.13454218f, 0.31525233f, 0.10717384f, -0.30413392f, 0.18177252f, -0.05455779f, 
    0.40631175f, 0.07077664f, 0.28272861f, 0.20898680f, -0.13258404f, 0.25252566f, 0.61260593f, -0.36760557f, 
    -0.18212497f, -0.29778597f, -0.19642180f, -0.05045698f, 0.04368958f, 0.07268443f, -0.09557944f, 0.14828433f, 
    -0.12666209f, -0.00948906f, -0.04944836f, 0.06265943f, 0.41764179f, 0.25134075f, 0.07059973f, 0.16693839f, 
    0.09256967f, -0.37122619f, 0.18914497f, 0.23338889f, 0.22934379f, 0.10403146f, -0.22512728f, -0.38116783f, 
    -0.00870701f, -0.03589847f, -0.16876581f, -0.17518340f, -0.04146273f, 0.17849360f, -0.03791289f, -0.13337994f, 
    -0.08429148f, -0.48781690f, 0.02116891f, -0.14377300f, -0.09700240f, -0.12829800f, 0.17464225f, -0.02638433f, 
    -0.01692235f, 0.20097904f, -0.06680971f, 0.16911359f, 0.15701042f, 0.02209979f, 0.19490042f, 0.03497204f, 
    -0.25457114f, -0.02973476f, -0.16233589f, 0.11078266f, -0.07857458f, 0.10992799f, 0.30311844f, 0.04417999f, 
    0.29945874f, 0.11197569f, 0.15060332f, 0.22228265f, 0.25073308f, -0.06332214f, -0.01890257f, -0.15316515f, 
    0.11192139f, 0.21748631f, 0.04694484f, 0.57514787f, 0.06975726f, -0.09793931f, -0.14446025f, 0.10389071f, 
    -0.29770276f, 0.05476131f, 0.05511881f, 0.03747983f, -0.09784564f, 0.13620153f, -0.05943121f, 0.28015515f, 
    0.03233722f, -0.09853424f, 0.31991205f, 0.25923261f, -0.08910441f, -0.09073742f, 0.35993296f, 0.20579696f, 
    0.14019465f, 0.13492304f, -0.21805075f, -0.26567149f, 0.13071510f, -0.08392128f, 0.33859909f, 0.01773579f, 
    0.10127008f, -0.08514903f, 0.13941123f, -0.19600442f, -0.09997933f, -0.17247126f, 0.04821945f, 0.37422422f, 
    -0.28848907f, 0.38304466f, 0.00278162f, -0.00926784f, 0.33181754f, 0.16905448f, -0.28250059f, 0.09686673f, 
    0.01117201f, 0.13747875f, 0.40824160f, -0.01625908f, -0.09523936f, -0.31529903f, 0.08252707f, 0.22587840f, 
    0.24366120f, -0.13414665f, 0.00002080f, -0.01455050f, -0.04408813f, -0.19975892f, -0.29346702f, 0.03074433f, 
    0.16575174f, -0.01029296f, 0.13699578f, 0.10400128f, -0.06653766f, -0.06681522f, -0.15013175f, 0.10980835f, 
    0.44478440f, 0.34122273f, -0.04082813f, 0.04185527f, 0.10244132f, 0.03128759f, 0.04261202f, 0.07670031f, 
    0.14260039f, 0.29933229f, -0.06790266f, 0.62068546f, -0.18255146f, 0.30180687f, 0.13387395f, 0.40004903f, 
    0.11877003f, 0.07779662f, -0.09646465f, 0.15279874f, -0.11398580f, 0.31434372f, 0.14556035f, 0.22591901f, 
    0.00456404f, 0.01318414f, -0.19635740f, 0.25129527f, 0.08262872f, -0.59624183f, 0.33603364f, 0.13935870f, 
    -0.03441687f, 0.20486690f, 0.17371780f, 0.46224335f, -0.21423833f, -0.09959952f, -0.33581120f, -0.21533503f, 
    -0.10412242f, -0.11128959f, 0.07923021f, 0.13437238f, -0.03845743f, -0.09193365f, 0.21992506f, 0.04624007f, 
    0.23720102f, -0.10182381f, -0.21825340f, -0.24013640f, 0.14526305f, -0.05263828f, -0.14381115f, 0.21204478f, 
    0.08326758f, 0.32069585f, -0.14617562f, 0.07825855f, 0.10261895f, 0.02494898f, -0.30981481f, -0.21724059f, 
    -0.05371616f, -0.28645059f, -0.18187276f, 0.31107768f, 0.06852728f, 0.19155857f, 0.14332402f, 0.20054886f, 
    0.10016045f, -0.03091085f, 0.25419047f, -0.12790515f, -0.23647237f, -0.41733888f, 0.17243779f, -0.18697053f, 
    -0.01448786f, 0.15457022f, -0.04320860f, -0.00297194f, 0.25506499f, -0.15958577f, 0.33547440f, -0.09059461f, 
    -0.07711038f, 0.30018118f, 0.13362290f, 0.04261566f, 0.02667896f, -0.08604061f, -0.53061712f, -0.06235877f, 
    0.01369450f, 0.09671407f, 0.05131109f, -0.09990351f, 0.02325476f, 0.08419420f, -0.37712094f, 0.43218729f, 
    -0.03652079f, 0.20765100f, 0.13748379f, -0.34348860f, 0.02282803f, -0.11454169f, 0.23656082f, 0.10292635f, 
    0.09998886f, 0.09406051f, -0.00901089f, -0.04029391f, -0.11885411f, 0.00773482f, 0.00752094f, -0.00666131f, 
    0.03421485f, 0.02854842f, 0.07078353f, -0.04966796f, -0.05655585f, 0.09772404f, 0.03593375f, -0.12313420f, 
    -0.06455596f, -0.03102604f, 0.07871358f, 0.09301906f, 0.07508844f, -0.11347887f, -0.12827091f, -0.06761876f, 
    -0.00122842f, 0.03501895f, -0.02371866f, 0.05045186f, 0.01549778f, 0.07030728f, 0.07534844f, 0.00394014f, 
    -0.10690639f, -0.14565742f, -0.04958221f, -0.09799457f, 0.04607195f, 0.00455664f, -0.10147804f, -0.01604898f, 
    0.02292947f, -0.04930404f, 0.01537365f, 0.07732553f, 0.07465318f, -0.08794410f, -0.01727013f, 0.03765317f, 
    -0.00690240f, 0.05950295f, -0.08459435f, -0.10381250f, -0.01791438f, 0.11012696f, 0.06325698f, -0.12613742f, 
    -0.12204767f, 0.00570600f, 0.08809843f, 0.01545634f, -0.12397659f, -0.10450272f, -0.07412554f, -0.01207056f, 
    0.12518947f, -0.08648300f, -0.03103828f, 0.00406240f, 0.04916624f, 0.01187422f, 0.43015674f, 0.09521483f, 
    -0.27330586f, 0.49806383f, 0.10561068f, -0.12990032f, -0.09418440f, -0.07833871f, 0.15996137f, -0.22957247f, 
    -0.71806520f, -0.28057501f, 0.05348238f, 0.00488095f, 0.16472928f, -0.14092529f, 0.28251296f, -0.06946763f, 
    0.11091569f, -0.23316875f, 0.17061672f, -0.15641949f, -0.13640846f, -0.14713232f, 0.14623174f, -0.14858092f, 
    -0.08626737f, 0.13721377f, 0.07013378f, 0.28596207f, 0.20615631f, -0.00201704f, 0.09382161f, 0.02445160f, 
    -0.08294114f, 0.68490303f, -0.03192785f, 0.08071797f, 0.11768158f, 0.35685620f, -0.20185709f, 0.05676849f, 
    0.01990508f, -0.23001307f, 0.04211638f, -0.14626594f, -0.04296205f, 0.06377584f, 0.10180416f, 0.23026370f, 
    0.03787612f, 0.09251103f, -0.27654928f, 0.13654847f, -0.02757728f, 0.00644496f, 0.21063659f, 0.17050967f, 
    -0.22499329f, 0.02933718f, 0.00637620f, -0.27182385f, 0.13930053f, -0.00621198f, 0.08482817f, 0.07938965f, 
    0.40726724f, -0.63714427f, -0.12762022f, 0.36483023f, 0.06800180f, 0.01575429f, -0.26111293f, 0.22480816f, 
    0.49723768f, -0.09300642f, -0.24485399f, -0.01784482f, -0.06419989f, 0.35189703f, 0.00425230f, 0.29546186f, 
    -0.05934075f, 0.57126009f, 0.22855008f, 0.12872869f, 0.14870010f, -0.20176618f, 0.04411354f, 0.00268353f, 
    -0.02591511f, -0.06265365f, -0.24782519f, -0.40447205f, -0.00886097f, -0.24830116f, 0.11985280f, -0.12403093f, 
    0.07213459f, -0.06971659f, 0.01625139f, -0.02313190f, -0.05975348f, -0.18137711f, -0.63092691f, 0.24257603f, 
    0.03784715f, 0.17725471f, -0.04544153f, -0.30546516f, -0.25086951f, 0.33058438f, 0.27073416f, 0.20966074f, 
    -0.12058670f, 0.21288083f, 0.22839206f, -0.20694935f, -0.03709579f, 0.35801533f, -0.06392113f, 0.24855240f, 
    0.71577632f, -0.05449556f, -0.02357746f, 0.24976854f, 0.19566433f, 0.06722329f, 0.12220004f, -0.01525212f, 
    -0.01209125f, 0.18497866f, -0.09221782f, 0.14250320f, -0.00142728f, 0.01306877f, -0.44524398f, -0.04955643f, 
    0.18469702f, 0.01379958f, -0.32915241f, 0.29362762f, 0.12830000f, 0.32426712f, 0.25775117f, 0.11141244f, 
    0.00112495f, 0.13138305f, 0.27544200f, 0.61119145f, -0.18499309f, -0.24267079f, 0.02873003f, -0.07615564f, 
    -0.03341789f, 0.07859424f, -0.18882562f, -0.07538100f, 0.06910109f, 0.12850118f, 0.14119262f, 0.05840363f, 
    0.08952733f, 0.05008605f, 0.02804653f, 0.06183492f, -0.17538489f, -0.16077414f, -0.25126347f, 0.13551763f, 
    -0.05580199f, 0.19401522f, -0.00458560f, 0.01847367f, -0.20180617f, 0.10250864f, -0.15716836f, 0.16173829f, 
    -0.19112815f, 0.03703891f, 0.26456404f, 0.14127067f, -0.07203513f, -0.26690772f, 0.38966474f, 0.40073994f, 
    -0.07169594f, 0.11319082f, 0.43211910f, 0.25082800f, 0.33700994f, 0.24740739f, 0.21154754f, 0.12633321f, 
    0.11105519f, 0.30260825f, 0.08995807f, -0.01651481f, -0.12218531f, 0.09161092f, 0.37187394f, 0.27955627f, 
    -0.32515991f, -0.23820415f, 0.12100757f, 0.35118109f, -0.11708704f, 0.09946198f, 0.05718480f, 0.18407065f, 
    -0.00332339f, -0.30991414f, -0.07877395f, -0.01907671f, 0.50523162f, 0.11797092f, 0.03851161f, 0.20169878f, 
    -0.00728408f, 0.12628454f, 0.08541687f, -0.07127217f, -0.01809092f, 0.25896651f, -0.08522489f, -0.02545648f, 
    0.09222328f, 0.05212592f, 0.15405719f, -0.09844275f, -0.01755225f, 0.10205668f, 0.03032241f, 0.14955536f, 
    -0.11451544f, -0.01941666f, -0.13059986f, -0.07088012f, 0.47042057f, 0.15889451f, 0.37656844f, -0.08920214f, 
    0.25935647f, -0.11329991f, 0.08965176f, 0.36417669f, -0.10086007f, -0.08223798f, 0.12321788f, 0.08349512f, 
    0.43323100f, 0.11243968f, 0.37949464f, 0.21833070f, -0.00319801f, -0.02070746f, 0.12314337f, -0.10889348f, 
    0.04308784f, 0.12225342f, -0.08259922f, -0.03593007f, 0.02480801f, 0.08327517f, 0.09850442f, 0.14541389f, 
    0.12569301f, 0.33822641f, 0.07520005f, 0.44214928f, 0.45244133f, 0.04419836f, 0.23662643f, -0.03844579f, 
    0.03264150f, -0.24974436f, -0.07294890f, 0.47688976f, -0.02695795f, 0.40005571f, -0.13531184f, -0.09839281f, 
    0.03969089f, -0.12145314f, -0.03113214f, -0.00073160f, -0.08668450f, 0.39939678f, -0.10172515f, 0.03540261f, 
    0.09700549f, 0.02042568f, -0.24791557f, -0.00768333f, -0.08894948f, -0.57874823f, 0.45892340f, -0.09291493f, 
    0.03783346f, -0.01053750f, 0.14427884f, 0.46255085f, 0.21186379f, 0.04373027f, -0.05620593f, -0.22708894f, 
    0.01334265f, -0.47390348f, -0.13040960f, 0.22495362f, -0.06556420f, -0.19465584f, 0.30196223f, 0.22834924f, 
    -0.18297911f, -0.07451965f, 0.07202201f, 0.07226546f, 0.17060356f, 0.00220590f, 0.13992716f, 0.16158310f, 
    0.01872635f, 0.12366586f, -0.27077666f, 0.46583277f, -0.13429801f, 0.09684817f, 0.14237869f, 0.05455278f, 
    -0.45007917f, -0.14857973f, -0.16556855f, 0.09409353f, -0.34488416f, 0.08564235f, -0.12710361f, 0.29465634f, 
    0.03462476f, 0.17402121f, 0.01059940f, 0.15244557f, 0.09559868f, -0.19670300f, 0.05080868f, 0.41348949f, 
    0.01219223f, 0.19433510f, 0.09416883f, -0.19275920f, 0.22706302f, -0.18752481f, 0.05948922f, -0.23103829f, 
    0.10089958f, -0.10762260f, 0.19506666f, -0.26880467f, 0.09797435f, -0.09048259f, -0.13886343f, 0.35427141f, 
    -0.18117216f, 0.30687317f, -0.05685805f, -0.08869014f, 0.01104274f, 0.22387092f, 0.01450105f, 0.13395327f, 
    0.11245961f, 0.12644541f, 0.35936809f, 0.07894349f, 0.08279716f, 0.09270611f, 0.06127980f, 0.32893425f, 
    0.18951297f, 0.09824985f, -0.29648209f, -0.23438920f, -0.41566634f, -0.20573048f, -0.02037716f, 0.34861174f, 
    0.28275111f, 0.00535934f, -0.01827689f, -0.59226269f, 0.03222358f, -0.00998080f, -0.11455774f, -0.11803006f, 
    0.40332946f, 0.18821870f, -0.12475926f, -0.06602983f, 0.32197890f, -0.07191575f, 0.09587622f, -0.35513285f, 
    0.10387749f, 0.63917053f, -0.26183417f, 0.08642125f, -0.26542988f, 0.32204166f, -0.21023813f, 0.13618602f, 
    -0.13126169f, 0.17229177f, -0.02333789f, 0.33621886f, -0.02371662f, 0.07395151f, -0.36947721f, 0.13929820f, 
    -0.01792678f, 0.09073006f, 0.03009222f, 0.24901403f, 0.19294493f, 0.05447255f, 0.24951002f, -0.13119498f, 
    0.45576742f, -0.23596540f, 0.22444953f, 0.13060376f, -0.22775874f, -0.06014409f, 0.21016309f, -0.03853877f, 
    -0.07058728f, 0.17804286f, -0.02435150f, -0.19402190f, -0.04473382f, 0.32319772f, 0.10889302f, -0.02170964f, 
    -0.16164817f, -0.00567635f, 0.38628182f, -0.02802618f, 0.30721766f, -0.18921117f, -0.27229539f, -0.24206081f, 
    -0.27477080f, 0.70486873f, 0.42146417f, 0.50781024f, 0.07282257f, 0.09275911f, -0.11032403f, -0.14677447f, 
    -0.14669344f, 0.08118652f, 0.10356472f, 0.10961422f, 0.23214245f, 0.30726689f, 0.00939257f, 0.05280900f, 
    -0.01687265f, 0.10029794f, -0.00912264f, -0.60912704f, -0.16590519f, 0.08114737f, 0.62832969f, 0.17414397f, 
    0.23354378f, -0.01790636f, -0.04171989f, 0.31646010f, 0.00952179f, 0.38174567f, 0.14498319f, 0.12870540f, 
    -0.06383340f, 0.06840125f, -0.47696865f, 0.30565223f, -0.00807567f, 0.47290245f, -0.06510792f, -0.78067261f, 
    -0.04825408f, -0.03106933f, -0.24929930f, 0.31627086f, 0.69721699f, -0.09965957f, -0.57743144f, 0.63134438f, 
    0.04341709f, 0.28955543f, -0.22799282f, 0.08641421f, 0.09282730f, 0.21045384f, -0.23176651f, -0.75242418f, 
    -0.10600656f, 0.06149653f, -0.02884368f, -0.09467059f, -0.07734807f, -0.08580081f, -0.30497310f, 0.28598619f, 
    0.27624249f, -0.28043914f, 0.06245192f, -0.21959077f, 0.08508486f, 0.01260381f, 0.07518103f, 0.11372118f, 
    0.17056364f, 0.37024906f, 0.24139382f, 0.08530688f, 0.23259166f, -0.14391987f, 0.14017439f, -0.14868927f, 
    0.02129629f, 0.33902246f, -0.19701399f, 0.07685143f, -0.08656003f, 0.15856358f, -0.10256225f, 0.38822711f, 
    -0.09852292f, 0.10479143f, 0.26739550f, 0.13044631f, -0.07630703f, 0.26846796f, 0.02436945f, 0.00617290f, 
    0.00808418f, 0.16703741f, -0.02808644f, 0.07708159f, 0.14584349f, -0.66162670f, 0.57544577f, 0.21636242f, 
    0.21715944f, -0.10136089f, 0.09619989f, 0.33234075f, -0.39374262f, 0.11738125f, 0.02599089f, -0.11557724f, 
    0.02468916f, -0.05511055f, 0.03782412f, 0.15205714f, -0.08080882f, 0.15347914f, 0.15742350f, 0.04109784f, 
    0.19086125f, 0.02717474f, -0.00135173f, -0.10542785f, 0.16068348f, 0.00317588f, 0.13968447f, -0.09451686f, 
    0.29231429f, -0.29202724f, -0.24421757f, 0.13445963f, -0.08887483f, 0.03353962f, -0.61301923f, 0.07472384f, 
    0.16853195f, -0.12806346f, -0.39823443f, -0.01507562f, 0.16187738f, 0.30822340f, 0.08681973f, 0.18705799f, 
    0.11717491f, 0.22500920f, 0.23993111f, 0.28862488f, 0.01000493f, -0.19945802f, -0.21475218f, 0.09663258f, 
    -0.18190892f, -0.10277759f, -0.17365305f, -0.11072938f, -0.00093579f, -0.02765311f, 0.32063165f, -0.16278373f, 
    -0.06196820f, -0.27511469f, 0.13042545f, 0.00436312f, -0.26219681f, -0.50170058f, -0.38181040f, 0.09723642f, 
    -0.11622602f, 0.34313089f, 0.06136683f, -0.23722123f, -0.38143378f, 0.28129926f, 0.20738190f, 0.12746824f, 
    -0.36397302f, 0.26609993f, 0.30385739f, -0.13151304f, 0.06565336f, 0.24049617f, 0.23432422f, 0.17409998f, 
    -0.33024386f, -0.04146926f, 0.07419056f, -0.08243877f, 0.09783410f, 0.21128719f, 0.12943149f, -0.17770322f, 
    -0.02020966f, 0.09859455f, 0.08558830f, 0.37448511f, -0.02108137f, -0.05320952f, 0.08078479f, -0.01320822f, 
    -0.53058910f, 0.03539300f, 0.07948405f, 0.10200984f, -0.06685238f, 0.14944009f, -0.09625721f, 0.46033677f, 
    -0.06703404f, -0.20244800f, 0.31116286f, -0.62367117f, 0.29148316f, 0.09138551f, 0.31125674f, -0.23438889f, 
    0.15223786f, 0.17939992f, -0.02450199f, -0.23240972f, 0.34164235f, -0.16206384f, 0.34714028f, -0.15644021f, 
    -0.11392118f, -0.23802043f, 0.11902138f, -0.19337757f, -0.11053896f, 0.25411442f, -0.28150967f, 0.14354184f, 
    0.02543393f, 0.34068349f, 0.15437883f, 0.04979385f, 0.55607754f, 0.30153951f, -0.10945804f, 0.23667179f, 
    -0.08405472f, 0.17768867f, 0.01310646f, -0.23898423f, -0.01356629f, -0.03225516f, -0.15817839f, -0.08689646f, 
    0.28715023f, 0.05188282f, -0.02776620f, 0.05614337f, -0.01079877f, 0.22445548f, 0.39233431f, 0.07496928f, 
    -0.12212345f, -0.00829974f, -0.14572822f, -0.19937700f, -0.07543465f, 0.06051137f, 0.00952870f, -0.05292490f, 
    -0.20055310f, 0.07297540f, -0.10286791f, -0.17145795f, 0.28676280f, 0.00713585f, 0.26668379f, 0.09516841f, 
    -0.06362990f, 0.31487584f, 0.05828220f, 0.20328493f, 0.04024310f, -0.03531973f, -0.47651574f, 0.27000716f, 
    -0.11740841f, 0.02404320f, -0.09610951f, 0.09265146f, 0.12821473f, -0.04917924f, 0.04560196f, 0.15358172f, 
    0.07205062f, 0.22048874f, 0.24106474f, 0.08517071f, -0.03876564f, 0.13792588f, 0.23436892f, 0.08227693f, 
    0.11665475f, -0.06338722f, 0.23577031f, -0.17121193f, -0.36922091f, 0.09380629f, 0.26843965f, -0.19821590f, 
    -0.01288756f, -0.05326151f, 0.12206879f, 0.10141166f, -0.01439770f, 0.20868206f, 0.23425452f, 0.33131072f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.11277347f, -0.12437011f, -0.05517604f, 0.33770338f, -0.06695338f, -0.01684357f, -0.13645791f, -0.13895069f, 
    0.10034697f, 0.27281454f, -0.18339883f, -0.02423054f, -0.00971488f, -0.09117040f, -0.14273003f, -0.10234474f, 
    -0.05895177f, 0.15654285f, -0.05612970f, 0.12117554f, 0.09047150f, 0.07203428f, 0.02742568f, 0.20231488f, 
    0.04852269f, 0.10342563f, -0.03051393f, 0.09013395f, -0.10337237f, 0.09664665f, -0.00482388f, -0.12072323f, 
    0.18422166f, 0.00976402f, 0.03513998f, 0.01166357f, -0.03642186f, 0.00944276f, 0.06329366f, -0.12060845f, 
    -0.05068989f, 0.20538829f, 0.13772482f, 0.02439874f, -0.02076748f, -0.12993330f, 0.22812006f, -0.02998582f, 
    0.05631213f, 0.09069856f, -0.03322770f, 0.06876016f, -0.10452660f, 0.12191743f, -0.11840317f, 0.18806969f, 
    0.16652729f, 0.06762320f, -0.00611267f, -0.11520574f, 0.17940249f, -0.03789219f, 0.28287262f, 0.06805985f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.03609772f, 0.01806599f, 0.06836055f, -0.31687394f, 0.00898889f, -0.08294060f, 0.02275574f, -0.01974772f, 
    0.10524981f, -0.30487236f, -0.31441569f, 0.08886980f, 0.15740182f, -0.57826251f, 0.10355019f, 0.11014260f, 
    -0.18136583f, 0.14466973f, 0.04178254f, 0.04558854f, -0.01847233f, -0.08255925f, 0.07918407f, 0.13825405f, 
    -0.44753096f, 0.22343478f, 0.06606966f, -0.54364508f, -0.06357954f, 0.19978578f, 0.09741131f, -0.10679333f, 
    0.08039394f, -0.02455883f, -0.24271195f, -0.35318330f, -0.12036968f, -0.11294224f, -0.37399203f, 0.11761977f, 
    0.03438379f, -0.12955084f, 0.30306411f, 0.20043817f, 0.12444231f, 0.15634835f, 0.17512147f, 0.27445668f, 
    0.14844324f, 0.05040846f, -0.45867231f, 0.10376941f, -0.26313105f, -0.31917039f, -0.21620266f, 0.06634896f, 
    0.21801676f, -0.21976824f, -0.60235828f, 0.39463407f, -0.11277947f, -0.39705023f, 0.34298766f, -0.30729285f, 
    -0.21936910f, -0.09884945f, -0.02907899f, -0.29838896f, -0.08360822f, -0.08065879f, -0.10164990f, -0.00008506f, 
    -0.09169611f, -0.21124317f, -0.05273886f, 0.21079025f, 0.15474099f, 0.23847276f, -0.05159989f, -0.11026709f, 
    -0.19178851f, -0.30059621f, 0.10276581f, -0.08015732f, -0.06882960f, -0.47279277f, -0.02270327f, 0.26318344f, 
    0.00722943f, 0.15020829f, 0.13451023f, -0.57812220f, -0.01391020f, 0.03839704f, -0.07300472f, -0.08114131f, 
    -0.61966926f, 0.03118597f, -0.19871253f, -0.31840909f, -0.06325612f, -0.06182518f, -0.02738610f, -0.08664072f, 
    0.04244785f, 0.04625009f, 0.14361751f, -0.32894379f, -0.30812535f, 0.17184441f, -0.37299106f, -0.25628641f, 
    -0.03999723f, 0.18523619f, 0.36838061f, 0.00867379f, 0.02567782f, 0.27508026f, 0.18516040f, -0.15160167f, 
    0.18790320f, 0.25405154f, 0.31795144f, 0.14086138f, 0.12140646f, 0.27986658f, -0.00001586f, -0.15273140f, 
    0.26807511f, 0.03393576f, -0.07563954f, 0.23286867f, 0.11120840f, 0.02283365f, -0.06547207f, -0.02806750f, 
    -0.36537343f, 0.24474877f, -0.41882533f, -0.28189272f, 0.14729324f, 0.02946310f, 0.00819672f, -0.08664880f, 
    -0.37438172f, -0.38983122f, -0.08609532f, 0.01007974f, -0.02168549f, 0.19533746f, -0.11196087f, -0.26729035f, 
    0.09661864f, 0.12250891f, -0.06855744f, 0.36873323f, 0.19390801f, -0.40162870f, 0.09823609f, -0.12568760f, 
    -0.04515959f, -0.00723910f, 0.20533562f, 0.21498121f, 0.05074021f, -0.04221437f, 0.31912309f, -0.08998553f, 
    0.04715170f, 0.21141981f, -0.06583211f, -0.05171959f, -0.20869011f, -0.09566727f, 0.20427841f, -0.06865386f, 
    -0.37740245f, -0.08879207f, -1.16842186f, -0.07499390f, -0.23487511f, -0.33800331f, -0.75501567f, -0.04180048f, 
    -0.46166202f, -0.23874277f, 0.02748050f, 0.17465973f, -0.04669290f, -0.49349818f, -0.22724912f, -0.66563421f, 
    -0.03198079f, 0.06767600f, 0.11026080f, -0.20028584f, -0.03581335f, -0.03104876f, 0.04927902f, 0.08448223f, 
    0.12513103f, 0.29499799f, 0.13007432f, -0.51634800f, -0.41286409f, -0.44723424f, 0.00375135f, 0.08090691f, 
    0.18293725f, 0.13231714f, -0.10779794f, 0.01346542f, 0.03929805f, 0.23021689f, -0.11033089f, -0.45267290f, 
    -0.41774058f, -0.33570123f, 0.03366020f, -0.11327350f, -0.62249565f, -0.00413106f, 0.08581109f, -0.06801173f, 
    -0.04729144f, 0.09767782f, -0.70694780f, 0.14374797f, 0.01362800f, 0.01057958f, -0.21507174f, -0.04103261f, 
    -0.12804045f, -0.36286280f, -0.05725128f, 0.11310130f, -0.24689777f, -0.12592016f, -0.11527071f, 0.14983204f, 
    -0.02353297f, -0.65794563f, -0.14837602f, 0.05414807f, -0.14421396f, 0.18208906f, -0.06033730f, 0.14749566f, 
    -0.31866717f, 0.21557838f, 0.20381227f, 0.10347930f, -0.26738378f, 0.15294066f, 0.25431910f, 0.11408383f, 
    -0.03022977f, 0.03107612f, -0.06495255f, 0.12897716f, 0.10386664f, 0.00430897f, 0.03714224f, 0.03084003f, 
    0.22423136f, -0.05049846f, 0.17312874f, -0.37232354f, -0.11702892f, -0.16350400f, 0.00436486f, -0.08043317f, 
    -0.10783483f, 0.21558003f, 0.08038108f, -0.07213838f, 0.01661206f, 0.09437781f, -0.11249410f, -0.01547968f, 
    0.17737724f, -0.04303138f, -0.05014115f, -0.12970509f, -0.02673024f, -0.34002411f, -0.06621171f, -0.02396689f, 
    0.27133814f, -0.05051434f, -0.16702524f, 0.16122830f, -0.09683937f, -0.05414658f, -0.40982682f, 0.01428555f, 
    0.01180170f, -0.13908681f, -0.10966068f, 0.08609276f, -0.08991971f, 0.14213097f, 0.13785893f, 0.12351704f, 
    -0.02429404f, -0.16968696f, -0.68120867f, -0.03133710f, 0.26733780f, -0.61966908f, -0.17912523f, 0.24564813f, 
    -0.05855512f, 0.18406834f, -0.38839325f, 0.12739223f, -0.10623520f, -0.37641627f, 0.04446379f, -0.03706109f, 
    0.03429892f, -0.07013955f, 0.10422438f, 0.13610099f, -0.07419445f, 0.04919829f, 0.10112347f, -0.06929971f, 
    0.02662246f, -0.30085000f, 0.07584875f, 0.22823307f, 0.20021090f, 0.06559801f, -0.09014557f, 0.07769272f, 
    0.03604754f, -0.06018077f, 0.03214458f, 0.01584761f, 0.07853058f, -0.72603053f, 0.09667929f, 0.27264649f, 
    -0.18605764f, 0.02506128f, 0.09305062f, 0.25839484f, -0.07489233f, -0.23061402f, 0.10918595f, 0.06411488f, 
    0.11563421f, 0.01719344f, 0.14354216f, -0.72936708f, -0.03469303f, 0.07244700f, 0.18790561f, 0.04867588f, 
    -0.04260699f, 0.18668759f, -0.03798985f, -0.09765591f, 0.00728796f, -0.16911989f, 0.18825279f, 0.34335700f, 
    -0.03850412f, 0.12384453f, 0.01435779f, 0.00007857f, -0.36804181f, -0.19579224f, 0.37561089f, -0.08170316f, 
    0.27191409f, -0.29374260f, 0.21514717f, -0.45047346f, 0.07466851f, 0.29276809f, -0.31133729f, 0.08828399f, 
    0.24672550f, -0.01273585f, 0.11580838f, -0.03336535f, 0.05231850f, 0.02683049f, -0.06076964f, 0.05439113f, 
    0.24407583f, 0.24184288f, -0.13023463f, -0.41357449f, 0.02378341f, -0.15246245f, 0.05424461f, -0.02686593f, 
    -0.17581238f, 0.11524673f, 0.00992228f, 0.03071402f, 0.09471611f, 0.11275958f, -0.01387452f, 0.23790714f, 
    -0.28643966f, 0.00690806f, -0.07962658f, -0.03605581f, 0.10024720f, -0.07774253f, 0.01544247f, 0.02007744f, 
    0.03053906f, 0.10492881f, -0.39457214f, 0.09059309f, -0.03770613f, -0.08238299f, -0.07277277f, -0.13552609f, 
    -0.02170593f, 0.11012012f, -0.08176378f, 0.06463020f, 0.13708831f, 0.21873483f, -0.05830782f, -0.17951728f, 
    -0.75319362f, 0.04446968f, -0.08044632f, -0.02028444f, 0.09997501f, -0.51630038f, -1.01300800f, 0.08980707f, 
    0.17216393f, -0.44782650f, 0.11851092f, -1.00479484f, 0.23747350f, -0.66309047f, -0.36364380f, 0.17755982f, 
    -0.69721043f, -0.09049274f, 0.12202960f, -0.53433019f, -0.12358159f, 0.17881165f, -0.05073880f, -0.03432168f, 
    0.08171993f, -0.26172516f, 0.23932056f, 0.21238659f, -0.38842919f, 0.23519580f, 0.05199076f, -0.02465734f, 
    0.14941563f, 0.06710082f, 0.05052462f, 0.05884417f, -0.07199540f, -0.28975990f, 0.00164540f, -0.27894121f, 
    -0.29462790f, -0.42020065f, -0.06641515f, -0.26797754f, -0.34180492f, 0.10174330f, -0.08341122f, 0.12894192f, 
    0.23752749f, -0.09065745f, 0.28083348f, -0.35633820f, -0.08362836f, -0.09184494f, -0.33673173f, 0.03351770f, 
    -0.02669391f, -0.51235366f, -0.26120538f, 0.22216073f, -0.28658503f, -0.21452168f, -0.20494781f, 0.22264758f, 
    0.08629780f, 0.09186756f, -0.12314583f, -0.04087836f, -0.03516893f, 0.21209283f, 0.28640267f, -0.00624617f, 
    0.22630943f, 0.02578579f, 0.34607702f, 0.24914309f, -0.49686655f, 0.27827346f, -0.15796119f, 0.19460954f, 
    -0.16685638f, -0.07371937f, -0.09907431f, -0.11110502f, 0.03061977f, -0.10383296f, -0.00935104f, -0.09057517f, 
    -0.60234994f, 0.12811661f, -0.07678431f, 0.14642517f, 0.09318975f, 0.21117517f, -0.09330104f, -0.06287793f, 
    0.21059002f, -0.51332444f, -0.11134700f, -0.01547340f, 0.00605260f, 0.01388985f, 0.00463668f, -0.05031581f, 
    0.45274135f, 0.01225229f, -0.08644401f, 0.22671475f, -0.09909238f, 0.22747840f, -0.10033203f, 0.00520115f, 
    -0.62789869f, -0.03195249f, 0.31677094f, 0.19107121f, -0.07519502f, -0.02295045f, -0.01467513f, -0.01505959f, 
    0.04152206f, -0.40359733f, -0.10709759f, -0.50630242f, 0.21317811f, 0.17376670f, -0.60514337f, -0.12102642f, 
    -0.20756295f, -0.01355811f, 0.15552291f, -0.09861160f, 0.33527917f, -0.46236667f, 0.02207316f, -0.73771524f, 
    -0.35853735f, -0.26316661f, 0.21438403f, 0.10314015f, -0.10175420f, -0.02155733f, -0.13454363f, 0.01395800f, 
    -0.10411001f, -0.08559165f, -0.02500949f, -0.05519923f, -0.06989329f, -0.06006724f, -0.09759512f, 0.09988083f, 
    -0.02039905f, -0.69708228f, 0.21847992f, 0.13169880f, 0.13433233f, 0.32015800f, 0.01830962f, -0.09464183f, 
    -0.04202868f, 0.00634559f, 0.00476202f, 0.10829832f, 0.02630818f, 0.13373312f, 0.03552981f, -0.10003181f, 
    -0.67627460f, -0.37212321f, -0.13733535f, 0.15411699f, 0.20724729f, -0.03019108f, 0.05010245f, -0.01382175f, 
    0.20408811f, -0.02466242f, 0.32653224f, -0.08301052f, 0.04789905f, -0.00043469f, -0.16305798f, -0.04598762f, 
    -0.03383376f, 0.19894390f, -0.58412635f, 0.01655434f, -0.16902521f, -0.16798490f, 0.23841050f, -0.31354821f, 
    0.17061409f, 0.13813457f, 0.15134400f, 0.02212834f, -0.28019893f, -0.17893031f, 0.32162970f, 0.20697284f, 
    0.01781190f, 0.03872217f, -0.54080766f, -0.08711816f, 0.12403090f, -0.13812721f, -0.33147606f, -0.23265438f, 
    -0.02041132f, 0.06832037f, 0.06400071f, 0.12558363f, 0.07707141f, -0.03113544f, 0.01207375f, -0.09501143f, 
    -0.30969268f, 0.20283484f, -0.22358437f, 0.16584095f, -0.06464253f, -0.39513758f, 0.10076771f, -0.12008840f, 
    0.16349651f, 0.07250089f, -0.00071726f, -0.15796265f, 0.03367111f, 0.11813924f, -0.09138305f, -0.29508340f, 
    0.22246525f, 0.02594027f, -0.07861570f, -0.06701859f, -0.40672031f, 0.33439365f, 0.06764093f, 0.04674275f, 
    -0.36465824f, -0.06070642f, -0.15319747f, 0.02568164f, 0.09303816f, 0.06105315f, -0.05234848f, -0.14571466f, 
    0.03394744f, 0.07641410f, 0.09196103f, -0.15055035f, -0.12090264f, -0.39344874f, -0.03160310f, -0.43872195f, 
    0.24531361f, 0.18751776f, 0.00936272f, 0.00480225f, -0.56391329f, 0.24363974f, -0.03636638f, -0.21312629f, 
    -0.33293808f, 0.27510712f, 0.16856411f, -0.37975684f, 0.00039410f, -0.02589168f, 0.21353024f, -0.01764007f, 
    0.22491388f, -0.03080098f, 0.10346489f, 0.22348253f, -0.01450057f, 0.04927314f, -0.11181121f, 0.02216155f, 
    -0.12224296f, 0.11544968f, -0.10865862f, -0.07483863f, -0.00186985f, -0.79889065f, -0.12463313f, -0.03994282f, 
    0.21894686f, -0.03157321f, 0.08687367f, 0.04437870f, -0.12235011f, 0.17132227f, -0.03193067f, -0.28778979f, 
    -0.40072608f, 0.01860172f, 0.03761615f, 0.31020376f, 0.08552524f, -0.29300573f, -0.03617768f, -0.04715923f, 
    0.07997997f, -0.08994915f, 0.17426050f, 0.27664697f, -0.07597177f, 0.01672446f, 0.25196737f, 0.02165520f, 
    -0.11390421f, -0.11345337f, 0.14510523f, -0.00519191f, 0.24587348f, 0.01396061f, 0.05228183f, -0.28083074f, 
    0.03912210f, -0.36854434f, -0.16440839f, -0.08626311f, 0.09534203f, -0.29019994f, -0.14464484f, 0.06911919f, 
    -0.57145751f, 0.04280683f, -0.20167544f, -0.30868259f, -0.26143393f, -0.48403874f, 0.15368560f, -0.05759111f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.09291520f, -0.06057328f, -0.02944493f, -0.03827297f, 0.01090600f, 0.10374155f, 0.13269104f, -0.14788146f, 
    -0.17763785f, -0.09740078f, 0.08116092f, 0.03421136f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
