#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.26952061f, -0.42091829f, -0.24608742f, 0.53175497f, 0.46748745f, 0.29661849f, 0.07434542f, -0.13515978f, 
    0.15379050f, 0.10869256f, -0.13463441f, 0.33992365f, -0.54182237f, -0.11464603f, -0.41620880f, -0.06986032f, 
    0.16298111f, -0.19961286f, -0.36896986f, -0.03867370f, -0.26224694f, 0.24349426f, 0.74784726f, -0.43410248f, 
    0.21756229f, 0.34893838f, -0.34576508f, 0.62666351f, -0.30580434f, 0.52758908f, 0.51589912f, 0.24212088f, 
    -0.41461608f, 0.48224539f, -0.07224526f, -0.27642724f, 0.48545110f, 0.59658241f, 0.37097263f, -0.25129491f, 
    -0.12766834f, -0.20701197f, -0.07611003f, 0.21582344f, -0.08099502f, 0.37326366f, 0.33101115f, 0.15416536f, 
    -0.62450707f, -0.01528168f, -0.49675000f, 0.29480839f, 0.02921324f, 0.02117459f, 0.71746749f, 0.14566994f, 
    0.18350138f, -0.17025675f, 0.32235023f, -0.04321322f, -0.26010019f, -0.13403408f, -0.20431460f, -0.24708860f, 
    0.21163933f, 0.04409916f, -0.21372506f, -0.10791138f, 0.26224628f, -0.32817850f, -0.04107002f, -0.46903402f, 
    0.48100948f, 0.59159499f, 0.21292713f, 0.09272204f, 0.43114302f, -0.18691565f, 0.39969924f, 0.28900760f, 
    0.21782844f, -0.27302024f, -0.43897048f, 0.27373809f, -0.30679986f, 0.65316510f, -0.36856079f, 0.22372654f, 
    0.19173758f, 0.23508804f, -0.51869333f, 0.66403127f, 0.06618655f, 0.52811784f, -0.15142363f, -0.26352763f, 
    -0.04235623f, -0.20771921f, -0.29812613f, -0.40163323f, -0.26714131f, 0.10287466f, 0.18217570f, 0.24999200f, 
    -0.49571139f, 0.03482885f, -0.24123251f, 0.03821748f, 0.43155819f, -0.43897885f, 0.31893033f, 0.43817809f, 
    0.08366343f, 0.07835168f, -0.61517805f, -0.13309012f, 0.20203716f, -0.64561355f, 0.50213754f, -0.05858174f, 
    -0.47466296f, -0.15886533f, -0.48056906f, 0.13606261f, 0.42402172f, -0.30649796f, 0.64995342f, 0.12394384f, 
    -0.35664099f, 0.05325083f, -0.30052119f, 0.07363961f, 0.31932148f, -0.19265309f, 0.05710011f, -0.53563172f, 
    -0.40597621f, 0.42957097f, 0.13363904f, -0.62637156f, 0.23615004f, -0.03512962f, 0.07871894f, 0.02015462f, 
    -0.56423545f, -0.42136154f, -0.40318733f, 0.05805679f, 0.07970414f, 0.39237159f, 0.06386231f, 0.19064534f, 
    0.14941618f, 0.28891647f, -0.38410011f, 0.11934691f, -0.54354542f, -0.31143856f, 0.36469090f, 0.17661765f, 
    0.35307276f, 0.20206857f, 0.23765492f, -0.39327392f, -0.23878255f, -0.40168306f, -0.54583663f, -0.51709509f, 
    -0.38187528f, 0.10763754f, 0.37810957f, -0.52618438f, 0.45217606f, -0.40112042f, 0.43918949f, 0.06372388f, 
    -0.41795087f, -0.16034505f, 0.08289244f, 0.35755160f, 0.46997365f, 0.34446865f, 0.43094251f, -0.09949999f, 
    -0.60304868f, 0.43716529f, 0.22621490f, 0.16639608f, 0.09084759f, -0.39338386f, -0.53248894f, -0.51793939f, 
    0.02151757f, -0.34009120f, -0.19499472f, -0.52236271f, 0.24276729f, -0.29878014f, -0.23182015f, -0.41294634f, 
    -0.40644008f, -0.28348732f, 0.34966627f, 0.69681597f, -0.13115108f, -0.21998465f, 0.09201691f, -0.49528378f, 
    -0.08616118f, -0.04772776f, 0.29894751f, 0.81873840f, 0.14397714f, -0.19619043f, -0.18383889f, -0.26280993f, 
    0.41902578f, 0.01209485f, -0.26971328f, -0.69118333f, 0.40350851f, 0.33908251f, 0.01910293f, 0.16410837f, 
    0.14430955f, 0.24765882f, -0.47623628f, 0.11842570f, -0.49396598f, 0.24579908f, -0.43977198f, -0.03139037f, 
    0.19018374f, 0.33027035f, 0.56847286f, 0.44090888f, -0.93179649f, -0.22076593f, 0.23022543f, -0.48893508f, 
    -0.11227994f, 0.01151534f, -0.17129084f, 0.06509548f, -0.82549149f, -0.60850805f, -0.39010796f, -0.06894372f, 
    -0.18769327f, 0.19780716f, 0.12269712f, -0.09239170f, 0.06503464f, -0.15808105f, -0.72263569f, 0.04898138f, 
    -0.61925811f, -0.01375958f, -0.16810313f, -0.16170512f, -0.21469845f, -0.52269864f, -0.55808765f, 0.29484180f, 
    -0.21374777f, -0.26840055f, -0.43145561f, -0.10445461f, -0.41307971f, -0.25310999f, 0.03032326f, 0.40249285f, 
    -0.39389101f, -0.24831529f, -0.39680433f, 0.13410179f, -0.09448199f, -0.42879203f, 0.28057235f, 0.41337684f, 
    0.27361211f, 0.51491308f, 0.27878383f, 0.33789852f, 0.51805890f, -0.11053209f, -0.25812358f, -0.25540677f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09225775f, -0.16416040f, -0.10458872f, -0.34324312f, -0.15387727f, 0.04068459f, 0.23285832f, 0.21169733f, 
    0.14001545f, -0.57809359f, -0.14948189f, -0.01043882f, 0.09838014f, 0.22108726f, 0.02545835f, -0.25346085f, 
    -0.02321195f, 0.09213921f, 0.30383733f, -0.28760636f, 0.05253469f, -0.13987331f, -0.05208644f, -0.08397073f, 
    -0.08639234f, -0.13704921f, -0.07676758f, 0.15347539f, 0.10996649f, -0.29091606f, -0.19687665f, 0.25703675f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.25711331f, 0.28098986f, -0.02386513f, 0.02251439f, 0.11426157f, -0.07923496f, 0.07867599f, 0.07632186f, 
    -0.02865317f, 0.09270237f, -0.10532880f, 0.01059210f, -0.10415687f, -0.09066799f, 0.08128614f, -0.27645534f, 
    0.10268715f, -0.06739943f, 0.02719501f, 0.27499673f, 0.19419776f, -0.03037290f, -0.12256053f, -0.02549903f, 
    0.05479338f, 0.00070445f, 0.02014513f, 0.05019921f, -0.03867211f, 0.05969950f, 0.01296919f, 0.06914096f, 
    -0.12041792f, 0.37274042f, -0.02337555f, 0.18309470f, -0.25344869f, -0.22965291f, -0.11743823f, -0.09596048f, 
    -0.18625702f, 0.08007121f, -0.21071482f, -0.11894733f, 0.06067133f, -0.19635427f, -0.29539147f, 0.04109791f, 
    -0.02460029f, -0.22831707f, 0.13176441f, -0.06797657f, 0.07377608f, -0.07220096f, -0.01651043f, -0.16077822f, 
    0.10811768f, 0.09405079f, -0.16274101f, -0.06385402f, -0.05781243f, 0.08620511f, 0.06453316f, 0.11412501f, 
    -0.02946804f, 0.10640792f, 0.04210484f, 0.01785777f, -0.13524398f, 0.00509057f, 0.11023391f, -0.06217090f, 
    -0.07896930f, -0.04862392f, 0.10056291f, 0.02251416f, -0.01938305f, -0.04057345f, 0.14883493f, 0.07457852f, 
    0.16909723f, -0.12595630f, -0.01275691f, 0.17988788f, -0.04037984f, -0.15310021f, -0.15474734f, 0.10629526f, 
    0.01387984f, -0.04476541f, -0.35595304f, 0.14004189f, -0.02639308f, 0.11476579f, -0.02728647f, -0.07374161f, 
    -0.15763071f, 0.12992223f, -0.06089649f, 0.16722627f, 0.18391390f, 0.04110734f, 0.01006164f, -0.08240473f, 
    0.07552052f, 0.06024981f, 0.02774643f, -0.12812158f, 0.12890510f, 0.10049240f, 0.05386577f, 0.08460382f, 
    0.00262288f, -0.08616644f, -0.05204690f, 0.08410035f, 0.03093128f, 0.06261796f, -0.14876537f, 0.02256798f, 
    0.05117336f, -0.09324089f, 0.07916234f, 0.03716467f, 0.00517728f, -0.16604120f, -0.20291950f, -0.24490045f, 
    -0.07958619f, 0.01069700f, -0.02544413f, 0.06973190f, 0.01872416f, -0.00750411f, 0.02195526f, 0.09786204f, 
    0.19387014f, 0.20010597f, 0.09138969f, 0.02258046f, -0.02623014f, -0.03273586f, 0.03774894f, -0.02998753f, 
    0.18368162f, 0.21453510f, 0.19597203f, 0.04139072f, -0.00675725f, 0.11482477f, 0.08000554f, 0.03081753f, 
    0.09184907f, 0.10467578f, 0.02682332f, -0.03865957f, -0.18334265f, -0.17853928f, 0.03808311f, 0.04796015f, 
    -0.06033785f, 0.05478304f, 0.01712818f, 0.04818623f, 0.03926469f, -0.16932121f, 0.05677138f, 0.18876906f, 
    -0.14214773f, -0.08981746f, -0.21948765f, -0.20338005f, -0.03048838f, -0.03985473f, -0.04376677f, -0.01269926f, 
    -0.00446907f, -0.02594142f, -0.03795205f, -0.16852163f, -0.01194225f, -0.01746310f, -0.13347092f, -0.05732045f, 
    -0.07479628f, -0.03802215f, -0.02171327f, 0.07255321f, 0.15892760f, 0.21667965f, 0.17691082f, -0.01118201f, 
    0.12966351f, 0.00387681f, 0.04809495f, -0.05041636f, 0.15863934f, -0.30044737f, 0.15562604f, 0.08725799f, 
    0.06707776f, -0.05118098f, 0.08251536f, -0.26361760f, 0.06231266f, 0.07235260f, 0.11753012f, 0.16784632f, 
    0.28966627f, 0.08612842f, 0.15539226f, 0.00105434f, -0.14290962f, 0.12723023f, -0.04609733f, -0.07233518f, 
    -0.12943216f, -0.02145870f, -0.02165573f, 0.07587004f, 0.07422348f, -0.14983238f, 0.05354357f, 0.03747862f, 
    0.03388904f, -0.05535813f, 0.04047015f, 0.19948016f, -0.00704085f, 0.06424065f, -0.00650111f, -0.10994375f, 
    -0.02071855f, -0.00421794f, -0.32105318f, 0.04415948f, 0.07099326f, -0.06493888f, 0.00865368f, -0.05900818f, 
    -0.10687777f, 0.07434070f, -0.10178550f, -0.03135911f, 0.16199297f, 0.12532851f, -0.05677122f, -0.00860700f, 
    0.01781259f, 0.02469883f, 0.05111140f, -0.06838705f, 0.09719496f, 0.03597927f, -0.12762460f, 0.10936103f, 
    0.09804200f, 0.07734310f, -0.13342629f, 0.12566875f, -0.04823996f, 0.34305888f, 0.06340309f, 0.06083695f, 
    0.01835747f, 0.13078292f, 0.15828070f, -0.11387829f, -0.04182066f, -0.10881801f, 0.11325467f, 0.04751529f, 
    -0.03537788f, 0.01182204f, -0.11775143f, 0.09862776f, -0.11855468f, -0.12511539f, -0.17519574f, 0.09486824f, 
    -0.08380358f, 0.03972488f, -0.04974904f, -0.06389498f, -0.11942241f, -0.06363750f, -0.08600590f, 0.16358568f, 
    0.15708268f, 0.04548413f, -0.03380099f, 0.00992609f, 0.07651868f, 0.04952001f, -0.03453676f, 0.06437951f, 
    0.01569254f, 0.10226848f, 0.12495001f, 0.14557417f, -0.02334312f, -0.03149199f, 0.10696509f, -0.09444374f, 
    0.12469565f, 0.01667853f, 0.15578905f, 0.03430235f, -0.02991424f, -0.00833433f, 0.05366315f, -0.12452850f, 
    -0.08437085f, 0.07711549f, 0.00974799f, -0.19507065f, -0.15694197f, -0.08333253f, 0.09352594f, -0.08273995f, 
    0.03953131f, 0.13322812f, 0.07768142f, -0.04280638f, 0.25397122f, -0.22835393f, -0.06607430f, 0.02087744f, 
    0.01629418f, 0.13559085f, 0.13824481f, -0.02500913f, -0.03805537f, 0.09019026f, 0.04938789f, 0.05583091f, 
    0.07662606f, 0.05131865f, 0.02857804f, -0.06904998f, 0.01385888f, 0.02978725f, -0.08317281f, 0.07905648f, 
    0.00194238f, 0.01749118f, 0.03340928f, 0.06330632f, 0.01539750f, 0.00806297f, 0.01606381f, -0.02156331f, 
    0.08556076f, -0.02746938f, 0.06851920f, -0.02706510f, 0.17076878f, -0.04612874f, 0.03619185f, -0.05719461f, 
    -0.05046367f, -0.03564267f, 0.08271214f, 0.02754798f, 0.03133830f, 0.07369883f, -0.03892441f, 0.06206572f, 
    0.05408403f, 0.04834983f, 0.11296987f, -0.06519020f, -0.04576872f, -0.03409158f, 0.05226405f, 0.00600834f, 
    0.11283692f, 0.02416637f, 0.06130750f, -0.36891508f, 0.02466388f, -0.05554093f, -0.01552994f, 0.05108060f, 
    -0.03276926f, -0.08876668f, -0.01352026f, -0.08103530f, 0.08636720f, 0.01769695f, -0.07102590f, -0.07563247f, 
    0.05104584f, -0.05318325f, 0.04530306f, 0.11776862f, -0.40165856f, -0.16656230f, -0.07680655f, 0.04161581f, 
    0.00856765f, 0.10560893f, 0.01295827f, -0.00833836f, 0.07805207f, 0.30807501f, 0.02806005f, 0.01778145f, 
    -0.04484662f, -0.10427888f, 0.17459489f, 0.01571919f, -0.01642636f, -0.14867814f, 0.20179760f, -0.02995531f, 
    -0.12239951f, 0.15587291f, -0.05375087f, -0.05681168f, -0.04192007f, 0.04404815f, -0.01457362f, -0.19550239f, 
    0.01964503f, -0.09783667f, -0.09522552f, -0.09020323f, -0.00909934f, -0.29934463f, 0.04222904f, 0.04082027f, 
    0.09303569f, 0.07277853f, -0.06141638f, 0.20568793f, 0.09960652f, -0.13636766f, -0.00062448f, 0.07954799f, 
    0.08318227f, -0.10303025f, -0.02499729f, -0.07166114f, -0.06364168f, -0.06174007f, -0.01349774f, 0.17804308f, 
    0.00896930f, 0.10547793f, 0.15460871f, 0.10909597f, -0.00134518f, 0.07732520f, -0.12620689f, 0.00941064f, 
    0.10176833f, 0.03079486f, -0.10666137f, 0.18346123f, -0.41552502f, -0.01129138f, -0.14621291f, -0.06790785f, 
    -0.18540421f, -0.00456245f, -0.07091751f, 0.03936329f, -0.01008141f, -0.42108154f, 0.02193840f, 0.04049723f, 
    -0.09781565f, 0.10554922f, 0.12913293f, 0.07122562f, -0.15389128f, 0.19885613f, 0.05848882f, -0.04731939f, 
    -0.11466511f, 0.05872829f, -0.07518874f, -0.04027652f, 0.04478224f, 0.00489030f, 0.03932218f, -0.11259488f, 
    -0.01599068f, 0.01135585f, 0.05779357f, -0.01756609f, 0.02744208f, 0.16650213f, -0.12110475f, -0.13301826f, 
    0.07491025f, 0.10372253f, 0.12571277f, 0.02774553f, -0.03713204f, -0.15724447f, 0.08883263f, 0.13834986f, 
    -0.27283782f, 0.15372276f, -0.00804298f, -0.03912351f, -0.04910965f, -0.11584927f, -0.00609759f, 0.00240391f, 
    0.06859430f, -0.15379466f, 0.05137827f, 0.01923887f, 0.07422417f, -0.16503601f, 0.06152194f, -0.06027910f, 
    -0.09442614f, 0.08734799f, 0.00550058f, 0.27871931f, -0.25422263f, -0.09372647f, 0.07946219f, -0.05334112f, 
    0.03303821f, 0.01829844f, -0.10900095f, -0.00848425f, 0.01291542f, -0.14664283f, 0.10814007f, -0.05881660f, 
    -0.05178551f, 0.03400521f, 0.07995722f, -0.15148197f, 0.24068065f, -0.03059229f, -0.04453133f, 0.00884669f, 
    0.10113303f, -0.10222202f, -0.00177855f, 0.00790663f, 0.06574652f, -0.14062855f, 0.22424045f, -0.06451064f, 
    0.08645762f, 0.05976849f, -0.00477041f, -0.22733194f, -0.14556763f, 0.05490648f, 0.17095183f, -0.11036402f, 
    -0.18185158f, -0.07504010f, -0.04143800f, 0.09875292f, 0.08415546f, -0.09022161f, -0.17910178f, -0.30178162f, 
    -0.07764971f, 0.02251372f, 0.13557477f, 0.16950676f, -0.04130760f, 0.12324347f, 0.11098764f, -0.03142831f, 
    0.00547846f, 0.08429594f, 0.24159968f, 0.00290692f, 0.02896804f, 0.06625919f, 0.00647185f, -0.02629031f, 
    0.06678650f, 0.25759417f, 0.01241959f, -0.26416853f, 0.14944616f, -0.19915496f, 0.11602022f, -0.04238325f, 
    0.06090327f, 0.04361781f, 0.00936549f, 0.25680476f, 0.11035254f, 0.10576758f, -0.04234970f, -0.07301641f, 
    -0.13818721f, -0.01968198f, 0.08233857f, 0.07753335f, -0.06169197f, -0.00006696f, -0.12990685f, -0.13583662f, 
    0.01460428f, 0.09311412f, 0.03643895f, -0.05835927f, 0.03101080f, -0.00689103f, -0.28488535f, -0.01596274f, 
    -0.01483034f, -0.04515360f, -0.05500749f, 0.00776173f, -0.08614023f, 0.08271758f, -0.01788490f, -0.21633020f, 
    -0.04992159f, -0.03254208f, -0.19675665f, 0.03706422f, -0.06378787f, 0.10934938f, 0.16615479f, -0.05193080f, 
    -0.25676101f, -0.05379309f, 0.04398392f, 0.01540214f, -0.01656487f, -0.01562286f, 0.06499243f, -0.08715286f, 
    0.04842530f, -0.01992767f, 0.11087856f, 0.12359025f, 0.00326934f, 0.02768214f, -0.02565174f, 0.08445361f, 
    0.06109066f, -0.00609156f, 0.08117020f, 0.01630244f, -0.01503696f, 0.02342387f, 0.02523832f, 0.01988491f, 
    -0.04932473f, -0.13014348f, 0.06785573f, 0.10178767f, -0.01984220f, 0.01242473f, 0.00246727f, -0.01531027f, 
    0.07825277f, -0.11509702f, -0.11927586f, -0.09568453f, -0.08627616f, -0.02263669f, -0.01858364f, 0.12369732f, 
    0.00314733f, 0.04951253f, 0.01660970f, -0.03410532f, 0.00200110f, 0.27170464f, 0.07894720f, 0.13939929f, 
    0.00243867f, -0.07803463f, 0.01226750f, 0.01117405f, 0.04418596f, -0.04281407f, -0.23114517f, -0.03713258f, 
    0.04131833f, 0.14632042f, -0.06892066f, 0.02246249f, -0.05188296f, 0.03910868f, 0.02307690f, -0.04027981f, 
    -0.01210225f, -0.03319342f, -0.04701702f, 0.04438833f, -0.08512249f, -0.05292122f, 0.09219796f, 0.10863875f, 
    0.01408409f, 0.03212671f, 0.01883333f, -0.05119461f, -0.10668460f, 0.08110184f, -0.10715915f, 0.09946370f, 
    -0.08494934f, -0.05067305f, 0.02794000f, 0.03017239f, 0.11263050f, -0.00075032f, -0.07822551f, -0.05748682f, 
    0.02809433f, -0.19425745f, 0.20576304f, 0.07905404f, 0.03657348f, 0.02276685f, -0.01342763f, 0.02132364f, 
    0.12124135f, 0.21583542f, 0.03315558f, -0.11684833f, -0.01313738f, -0.06155070f, -0.11786509f, -0.00695155f, 
    -0.15614182f, 0.00889551f, 0.23178215f, 0.04201376f, -0.02262944f, 0.00307455f, -0.01408413f, -0.05853476f, 
    -0.01819651f, -0.09067900f, -0.07504484f, -0.04920022f, -0.01027003f, 0.15694913f, -0.01577310f, -0.11656639f, 
    0.03538976f, 0.04051379f, 0.03748567f, 0.13464861f, -0.04517091f, -0.09222817f, -0.29012254f, 0.00493628f, 
    -0.01507138f, 0.02356564f, 0.05870234f, -0.10797248f, -0.19991459f, -0.00658404f, -0.07383785f, 0.26344761f, 
    -0.15270805f, 0.13921691f, 0.08852981f, 0.06786826f, -0.03420991f, 0.05558005f, 0.11591847f, -0.14607045f, 
    0.24116680f, -0.08693958f, 0.02896463f, -0.07040668f, -0.06640188f, 0.05548140f, 0.03527870f, -0.15602504f, 
    0.22281127f, 0.27245072f, -0.02014208f, 0.01451196f, 0.01973913f, -0.09931638f, 0.03313104f, 0.18280281f, 
    0.14642815f, -0.02230017f, -0.07140376f, -0.10812507f, 0.05299664f, -0.15891428f, 0.00770625f, 0.04893488f, 
    -0.03353680f, 0.11032778f, -0.04528053f, -0.01051526f, -0.02642035f, 0.02630025f, -0.01559994f, -0.06756648f, 
    0.02267289f, -0.11325442f, -0.08098183f, 0.07515516f, -0.01234748f, -0.07416821f, -0.14162274f, 0.02114814f, 
    -0.02785388f, -0.09412318f, 0.12646766f, 0.10105661f, 0.09709007f, 0.22777714f, -0.06616230f, 0.04340550f, 
    -0.14787255f, -0.06803785f, -0.02098711f, -0.04211605f, 0.15438882f, 0.21357901f, 0.12526301f, -0.14374612f, 
    0.02028655f, -0.03115852f, 0.03638549f, 0.06127368f, 0.01277130f, 0.17132936f, -0.15538034f, 0.25521961f, 
    0.16717966f, 0.11578801f, 0.02700103f, -0.12411375f, 0.07151853f, 0.13757147f, -0.05318534f, 0.10519820f, 
    0.04300797f, 0.07787105f, 0.00931388f, -0.00271246f, -0.14628603f, 0.05979662f, -0.03729909f, 0.13284901f, 
    0.07400196f, -0.15948741f, -0.07165444f, -0.00376839f, 0.20295270f, 0.00735217f, -0.04085241f, -0.14500695f, 
    0.06922532f, 0.01520975f, 0.23758100f, -0.22554575f, -0.09076322f, -0.06921916f, 0.11206565f, -0.03701120f, 
    0.00489352f, 0.01949313f, 0.16295202f, -0.08009636f, -0.00040032f, 0.02507084f, -0.03617110f, -0.07261146f, 
    -0.11974572f, 0.03021088f, 0.25308576f, -0.17187257f, -0.00867007f, 0.04661404f, -0.02699333f, -0.06946749f, 
    -0.02977789f, -0.05122698f, -0.13262190f, -0.06810219f, 0.07618096f, 0.15615730f, -0.10069767f, 0.10372414f, 
    0.25401926f, 0.03266485f, -0.05490336f, 0.01051025f, -0.19739375f, 0.12967427f, 0.03912540f, 0.12689352f, 
    0.12754473f, 0.14513078f, -0.04592815f, 0.06199061f, -0.19070624f, 0.10914972f, 0.17544256f, -0.06554657f, 
    0.11986911f, 0.04697633f, 0.09422418f, 0.04261045f, -0.05020729f, -0.04664895f, -0.04505895f, 0.18016024f, 
    0.07543210f, 0.06840193f, -0.10505855f, 0.08291992f, 0.00057610f, -0.04061725f, -0.02170546f, 0.04317593f, 
    0.01414630f, -0.27426133f, -0.10264289f, 0.06218506f, 0.11151464f, -0.04261247f, 0.03916547f, 0.11523589f, 
    -0.12114312f, 0.07278781f, 0.06223075f, -0.01384066f, -0.00322917f, 0.15390964f, -0.07882954f, -0.13431874f, 
    -0.05905040f, 0.37390000f, 0.04237628f, -0.08734853f, -0.16601123f, -0.07725083f, 0.13625190f, 0.05411842f, 
    -0.07035715f, -0.16011153f, 0.27819073f, -0.15969782f, -0.05843984f, -0.10818259f, 0.14955470f, 0.08779696f, 
    0.10291306f, -0.04379353f, -0.14489374f, 0.14443512f, -0.18000145f, -0.07197833f, -0.11926858f, -0.01384260f, 
    -0.03360830f, 0.06365656f, 0.06100413f, -0.05408617f, -0.21957776f, -0.13111097f, 0.12370553f, 0.02479061f, 
    0.14576592f, -0.07531714f, -0.00594015f, 0.08049158f, -0.08801576f, 0.12055153f, -0.13956179f, -0.05821767f, 
    0.06521881f, 0.09480746f, 0.00844243f, -0.15275662f, 0.02844967f, 0.00001197f, 0.15739691f, -0.05560558f, 
    0.07375880f, -0.06447701f, -0.16266620f, 0.06791121f, -0.06781633f, 0.07139467f, 0.03235437f, 0.14845300f, 
    -0.22352466f, -0.25085059f, -0.11963039f, -0.13014381f, 0.09407990f, -0.01378408f, -0.02312538f, -0.09357211f, 
    0.27548492f, -0.04166697f, 0.06836372f, -0.19635248f, -0.07533634f, -0.16251650f, 0.07447764f, -0.03142431f, 
    -0.09894224f, 0.05585930f, 0.02264102f, 0.04064206f, -0.02703862f, 0.14726706f, 0.13904049f, -0.11724436f, 
    0.05874440f, 0.00550865f, -0.03912357f, -0.00879235f, 0.00545356f, -0.01309824f, 0.02879785f, -0.02139248f, 
    0.03622388f, 0.17691648f, -0.07870673f, -0.04587980f, -0.02337553f, 0.03298677f, 0.11151044f, -0.13353595f, 
    0.04468102f, -0.00478425f, 0.04735747f, 0.05090663f, -0.42903122f, 0.17593084f, 0.06156183f, -0.02907254f, 
    0.17806649f, 0.08575843f, -0.04823415f, -0.05205607f, -0.07323807f, -0.35213345f, -0.25167051f, 0.06841046f, 
    -0.04351741f, -0.01970553f, 0.10260847f, 0.10340904f, 0.06099584f, 0.11333188f, 0.26153001f, 0.02043394f, 
    0.07642755f, -0.07914099f, -0.02384189f, -0.08827282f, 0.02607717f, 0.00624414f, 0.06176670f, 0.27311599f, 
    0.07412010f, -0.03489373f, -0.21783023f, -0.26541597f, 0.11715787f, 0.03976283f, 0.12944362f, -0.00391629f, 
    -0.03074395f, 0.23911515f, -0.10570798f, -0.05329174f, -0.11441820f, 0.14668217f, 0.00622991f, 0.00849700f, 
    -0.11899491f, 0.06760490f, 0.18681991f, -0.11041541f, 0.03200316f, -0.01727996f, 0.04236195f, 0.10683588f, 
    -0.15866157f, 0.02435561f, 0.16392970f, -0.31502196f, -0.07601116f, -0.08124567f, 0.09518791f, -0.02398231f, 
    0.01867850f, -0.03625244f, -0.16290282f, 0.30082500f, -0.21192154f, 0.13499373f, -0.12403587f, 0.11821324f, 
    -0.02336477f, -0.03656342f, 0.01613819f, -0.04223514f, -0.18216309f, -0.38113666f, 0.16354191f, -0.05702876f, 
    -0.01295570f, -0.02409015f, -0.03019057f, -0.10331558f, 0.07301158f, -0.08640027f, -0.09033070f, 0.09096889f, 
    -0.04403984f, -0.09494910f, -0.00978403f, 0.00110623f, -0.03849842f, -0.12520750f, -0.16824031f, -0.04584298f, 
    -0.10002085f, 0.04461437f, 0.03804794f, -0.05878632f, -0.03515474f, 0.06601962f, -0.01964905f, -0.26255539f, 
    0.13077952f, -0.05948032f, -0.03352930f, 0.05282752f, 0.07654940f, -0.01214330f, -0.09072224f, -0.03478213f, 
    0.16496837f, 0.08377770f, 0.06057948f, 0.04663638f, 0.16150151f, -0.00298353f, 0.07595415f, 0.06325851f, 
    -0.00377065f, -0.04160435f, -0.07440570f, 0.15672053f, 0.14351964f, 0.13500704f, -0.00039786f, 0.09183439f, 
    -0.02322842f, 0.05363840f, 0.02569321f, 0.15385842f, -0.07751774f, 0.01042075f, -0.12008191f, -0.02285222f, 
    0.05009137f, -0.01551147f, -0.03934567f, -0.23904105f, -0.03612154f, -0.05156521f, 0.02831158f, -0.13457741f, 
    -0.16806172f, -0.13057150f, -0.14593099f, 0.07712474f, -0.23906183f, -0.18085761f, -0.11128309f, -0.02989398f, 
    0.02654332f, -0.09055550f, -0.05720188f, -0.09233903f, -0.08905498f, -0.16013432f, -0.11275487f, 0.05447537f, 
    0.00644695f, -0.00313193f, -0.04873062f, -0.12295928f, 0.01779591f, 0.11958408f, -0.05903111f, -0.04802105f, 
    -0.14710124f, -0.01200422f, 0.12986650f, -0.00645979f, 0.01379197f, 0.01643028f, -0.04196762f, -0.01248955f, 
    0.07533483f, 0.06948061f, 0.02444301f, 0.12947237f, -0.00014499f, 0.05527041f, -0.11204247f, -0.06176475f, 
    -0.12917104f, 0.08929543f, 0.08938661f, 0.02490649f, 0.00796859f, -0.06554369f, -0.04091662f, -0.06024133f, 
    0.00920388f, -0.06272726f, 0.02249490f, 0.07470439f, -0.05282088f, -0.18966445f, -0.16869092f, 0.15551598f, 
    -0.06235231f, -0.07692695f, 0.28698394f, 0.02763916f, 0.00700662f, -0.00882486f, -0.12608792f, -0.04126380f, 
    -0.03638123f, -0.01423937f, -0.02838740f, 0.01596075f, 0.12206762f, 0.09381398f, 0.05119043f, -0.04853124f, 
    -0.09793771f, -0.04189922f, 0.07544851f, 0.07245702f, 0.01046106f, 0.00514335f, -0.07654794f, 0.00813028f, 
    0.13346365f, -0.02991729f, -0.00255353f, 0.10021068f, 0.01348180f, 0.06136974f, 0.07500854f, -0.14775895f, 
    0.05543864f, -0.05925394f, -0.16052398f, 0.01033772f, 0.03474082f, -0.06522704f, -0.11145419f, -0.00759783f, 
    -0.13828881f, -0.05529334f, 0.01756035f, -0.03727495f, -0.04272304f, 0.02008040f, -0.01937666f, -0.00472665f, 
    -0.10094913f, 0.15519710f, -0.07942630f, -0.04016856f, 0.09955516f, 0.02834094f, 0.04415012f, -0.04516445f, 
    0.22046636f, -0.05712243f, 0.04261801f, 0.00956318f, 0.03025280f, 0.00474917f, 0.01103844f, 0.02728860f, 
    0.00161575f, 0.05137501f, -0.01101657f, -0.02530440f, -0.02347793f, 0.01520666f, -0.04266535f, -0.01392304f, 
    -0.10449005f, 0.08861620f, 0.18593776f, -0.08196810f, -0.00636613f, 0.00206696f, 0.00134070f, -0.01847060f, 
    0.04287000f, 0.02273321f, 0.00231518f, 0.14092466f, 0.01920635f, 0.09536538f, -0.10421728f, -0.08669697f, 
    0.03857835f, 0.08829602f, -0.07197029f, 0.05428853f, -0.07886937f, -0.10587891f, 0.01461382f, 0.01013469f, 
    0.02932047f, -0.06522016f, 0.09888410f, -0.18046859f, -0.02613210f, 0.09801345f, -0.01785734f, 0.11230672f, 
    -0.03768795f, -0.03230265f, -0.00893298f, -0.04084028f, 0.09271493f, -0.03385176f, 0.09956026f, -0.03419692f, 
    0.11477946f, 0.05324848f, -0.11062252f, 0.05100780f, -0.05220703f, -0.03027560f, 0.00429984f, 0.07530714f, 
    0.17915751f, 0.03502231f, 0.10752828f, -0.02903665f, -0.05773341f, -0.02468688f, -0.07070971f, -0.03857140f, 
    -0.10350823f, 0.09058217f, -0.13324448f, 0.01088578f, -0.00854272f, -0.05113605f, 0.05898270f, -0.07243690f, 
    0.11018393f, 0.01342865f, -0.08942398f, 0.04327762f, -0.03733200f, 0.05125263f, -0.05857423f, 0.08201779f, 
    -0.09834754f, -0.00891631f, 0.00122176f, -0.07728840f, -0.01421699f, 0.02553793f, -0.05210816f, 0.10003167f, 
    0.07508963f, -0.06002113f, 0.08237812f, 0.10581198f, 0.00882338f, 0.01693252f, -0.07965673f, -0.03932620f, 
    -0.00163289f, -0.05530171f, 0.03997686f, 0.09360107f, 0.05662542f, 0.07889060f, 0.08123373f, 0.02143407f, 
    0.02796626f, -0.04207324f, 0.04714879f, -0.03843346f, 0.09483168f, -0.11486204f, 0.08017242f, 0.17920829f, 
    0.06118689f, 0.03236554f, -0.10675532f, 0.00998082f, 0.01942391f, 0.07292680f, 0.21239844f, -0.12379529f, 
    -0.16214292f, -0.02515213f, -0.09212151f, -0.01251024f, -0.01192328f, -0.07153822f, -0.04356191f, -0.15018205f, 
    -0.03551389f, 0.03996244f, 0.03859043f, 0.08540213f, 0.07459634f, -0.02186312f, -0.01742897f, -0.07305979f, 
    -0.12214852f, -0.11343299f, 0.01862263f, -0.01771177f, 0.03585195f, -0.14916110f, -0.08236869f, -0.16879037f, 
    0.05208295f, -0.01973495f, 0.04650318f, -0.20125347f, 0.04558725f, 0.08167367f, 0.12414206f, 0.01614604f, 
    -0.07992110f, -0.04031811f, 0.00231023f, -0.00869965f, -0.17339157f, 0.01540279f, -0.07938001f, -0.00583349f, 
    0.07475190f, -0.03780624f, 0.02925167f, 0.26023531f, -0.16073942f, -0.05881853f, 0.09162593f, -0.00728645f, 
    0.04004507f, -0.01016919f, 0.03505369f, 0.03946602f, 0.16210060f, -0.00547499f, -0.05386520f, -0.04539605f, 
    0.02760103f, 0.04637817f, -0.02572956f, -0.01176685f, 0.03198490f, 0.30508354f, -0.12556280f, -0.19545703f, 
    0.01364937f, 0.11603378f, 0.06595208f, 0.10791346f, -0.04879906f, 0.06377497f, -0.06308001f, 0.05903671f, 
    -0.10596349f, 0.15185873f, -0.01501682f, 0.01287427f, -0.02093185f, -0.01285323f, 0.07534385f, -0.06318764f, 
    0.00448188f, 0.01782970f, -0.05827455f, -0.09989217f, -0.02110208f, -0.01714449f, -0.01000890f, -0.05281625f, 
    0.27109459f, 0.09277989f, -0.02996291f, -0.02974601f, -0.00135929f, -0.01817930f, 0.02961120f, -0.10925895f, 
    0.10438828f, 0.03012174f, 0.08880635f, -0.13318713f, 0.05407269f, 0.10207447f, 0.11107104f, -0.04793082f, 
    -0.02471177f, -0.01636924f, -0.21738951f, -0.14182708f, 0.04059039f, 0.16679206f, -0.06681766f, -0.21152298f, 
    0.00709000f, -0.10219168f, 0.01487056f, -0.16268249f, -0.05497511f, -0.00707115f, 0.02656524f, 0.04350637f, 
    0.02802435f, 0.06439894f, 0.04414175f, -0.08781038f, -0.02386618f, 0.04625671f, -0.00496964f, 0.10393587f, 
    -0.09416530f, -0.20390627f, 0.10159142f, 0.02651459f, 0.08369996f, -0.01799920f, -0.08752885f, -0.11936569f, 
    0.03982642f, 0.19292615f, 0.10125121f, 0.02006669f, -0.08668607f, -0.05098767f, 0.02095511f, 0.16558899f, 
    0.11410654f, 0.02705957f, 0.03939364f, 0.09288673f, 0.01345926f, 0.05118174f, -0.02462190f, 0.15969570f, 
    0.02799011f, 0.00799295f, -0.14919324f, -0.02814939f, 0.00655048f, 0.06700376f, 0.12165899f, 0.01736995f, 
    -0.20524353f, 0.05558419f, 0.11515994f, -0.01143467f, -0.00345656f, -0.04850180f, -0.01264258f, -0.12050183f, 
    0.02169427f, 0.14393058f, 0.07221831f, -0.04854264f, 0.18415056f, 0.06397637f, 0.03270295f, 0.03227449f, 
    0.09717429f, 0.05486256f, -0.04574534f, 0.06552870f, -0.09864413f, 0.06295776f, 0.07210173f, 0.10240023f, 
    0.01239154f, -0.07973196f, -0.03362842f, -0.19512637f, -0.06684128f, -0.18633744f, 0.19017553f, 0.12247701f, 
    0.08548016f, -0.08712285f, -0.04422535f, -0.00373790f, 0.25294551f, 0.09218864f, 0.01405317f, 0.01977329f, 
    0.07301378f, 0.07390314f, 0.14013793f, 0.06113623f, 0.15328346f, 0.19416136f, -0.07848552f, -0.02782093f, 
    0.04573311f, -0.04968694f, 0.09330627f, 0.05491024f, 0.12747930f, 0.03907465f, -0.20405886f, 0.15749682f, 
    0.02956832f, 0.16736107f, -0.17181849f, -0.08367538f, -0.07224420f, 0.02654507f, -0.06298587f, -0.21035774f, 
    -0.25687891f, -0.16102694f, 0.07624013f, -0.05768858f, -0.13497132f, 0.09486231f, -0.14980976f, -0.07511846f, 
    -0.05695276f, 0.08889563f, 0.06090950f, 0.06360017f, -0.04719164f, -0.02929601f, 0.03750460f, 0.02780386f, 
    0.07640546f, -0.04692817f, 0.02231710f, -0.00816771f, 0.02109284f, 0.01875445f, 0.10258739f, 0.12836564f, 
    -0.06963576f, 0.06942335f, 0.14648183f, 0.23649418f, -0.13374886f, 0.07260200f, 0.03255451f, 0.02554679f, 
    -0.09090895f, -0.09699464f, 0.04763390f, 0.00301553f, 0.16243689f, 0.00959243f, 0.06000499f, -0.08791901f, 
    0.04103827f, -0.09119243f, -0.00153362f, -0.10568754f, 0.14493436f, 0.17700784f, -0.06145529f, 0.08742055f, 
    -0.07146459f, 0.04559316f, 0.06776522f, -0.01571685f, -0.02168723f, -0.04612669f, -0.03156926f, 0.00022704f, 
    -0.02335103f, 0.06226758f, 0.15617500f, -0.07855255f, 0.04654396f, -0.09042504f, -0.02643660f, 0.10082795f, 
    -0.08292135f, 0.13100086f, -0.07816117f, 0.15806551f, -0.00948081f, 0.04609964f, -0.05149279f, -0.03723741f, 
    0.03533662f, -0.00150559f, 0.08037391f, -0.09536970f, 0.03291462f, 0.01564384f, 0.06285060f, -0.05730945f, 
    0.29637676f, 0.21879952f, -0.02491391f, 0.06122310f, 0.05640027f, -0.12776943f, 0.02024059f, 0.14287439f, 
    0.12273818f, 0.11722946f, -0.06178997f, -0.21161211f, -0.03176619f, 0.02321265f, -0.08479624f, 0.04955966f, 
    -0.00591500f, -0.16136788f, 0.10806954f, -0.31311917f, 0.10648219f, -0.11464932f, 0.09789814f, 0.02263746f, 
    0.20571454f, 0.09430501f, 0.01906810f, -0.46448642f, -0.21575232f, 0.10316668f, 0.08727387f, -0.00460532f, 
    -0.00255540f, -0.02558171f, 0.06256741f, 0.10024063f, 0.10433944f, -0.11796158f, -0.18974687f, -0.17564362f, 
    0.03701668f, 0.14252521f, -0.10946225f, -0.18536733f, -0.15927534f, 0.01714448f, -0.24836478f, 0.00508997f, 
    -0.08888691f, -0.02710737f, 0.12628311f, -0.04301936f, -0.02584954f, -0.09633314f, 0.06538859f, 0.00605359f, 
    0.03807307f, 0.01507186f, -0.04189438f, 0.16925935f, -0.08228564f, -0.11281976f, 0.09419283f, 0.10778898f, 
    0.05106032f, -0.23277523f, 0.19394502f, 0.02367701f, 0.00118666f, 0.06421878f, 0.08313394f, 0.06778995f, 
    -0.34806862f, -0.06070238f, 0.16285753f, -0.06264003f, 0.04095085f, 0.03868977f, -0.01293551f, 0.01522381f, 
    0.13669734f, -0.32049736f, -0.17905515f, 0.05684122f, 0.03918575f, -0.22751403f, 0.11125664f, 0.29277897f, 
    0.06771290f, -0.08965871f, -0.16609924f, -0.32512075f, -0.13006683f, 0.16762187f, 0.10193028f, -0.07022239f, 
    0.04010747f, 0.00472255f, -0.13276963f, -0.04622844f, -0.13151930f, -0.03612490f, -0.00362469f, 0.03479349f, 
    0.06559685f, 0.04948581f, 0.02382249f, 0.18380165f, 0.12703383f, 0.03373649f, 0.19887067f, 0.09383922f, 
    0.18071952f, -0.01562088f, -0.00117904f, 0.05135870f, -0.00279736f, -0.01703232f, -0.09977992f, -0.12893428f, 
    0.03538809f, 0.18199882f, 0.04731482f, 0.06401843f, -0.03503498f, -0.10464030f, -0.23327206f, -0.09200979f, 
    0.22173056f, -0.14591819f, -0.00571749f, -0.01596321f, 0.05023001f, 0.00343677f, -0.03511267f, -0.02866387f, 
    0.07579590f, -0.03058765f, 0.05462885f, -0.02003715f, 0.01303780f, -0.05574115f, -0.09600950f, 0.03693258f, 
    0.27023652f, 0.29880470f, 0.00855235f, 0.06850883f, -0.11910493f, -0.05323304f, 0.06028223f, 0.08437203f, 
    0.12299301f, -0.18418415f, -0.09072711f, -0.11157074f, 0.09858379f, 0.00279277f, 0.01668290f, 0.06447466f, 
    -0.09573086f, 0.05290601f, -0.06519111f, -0.24068540f, 0.22972967f, 0.00140776f, 0.12549943f, 0.15378059f, 
    -0.04415459f, -0.05368021f, 0.03879025f, 0.17593652f, -0.19580178f, -0.12729999f, 0.05439862f, -0.02609286f, 
    -0.05971940f, -0.04567819f, 0.01007377f, -0.04650306f, -0.09109450f, -0.00952832f, -0.10006981f, -0.01218636f, 
    -0.07369217f, 0.11798526f, -0.06289990f, -0.04675958f, 0.16021505f, 0.10169338f, -0.27535024f, 0.02641774f, 
    -0.00247517f, 0.01244128f, 0.09606903f, -0.07045625f, 0.17540476f, -0.01398467f, 0.28461540f, 0.15097037f, 
    -0.25130782f, -0.03145346f, -0.07901470f, -0.11137428f, 0.23013982f, 0.08752909f, 0.04588136f, 0.24458948f, 
    0.11928116f, -0.00283846f, 0.11476677f, 0.15466732f, -0.14631534f, 0.09791780f, 0.09890950f, -0.11281650f, 
    -0.08423299f, -0.09278749f, -0.11704966f, -0.00654918f, -0.11062356f, 0.10444322f, 0.14700045f, 0.00640284f, 
    0.01996376f, -0.04409656f, -0.25795409f, 0.07423558f, -0.03444768f, -0.02167824f, 0.12542756f, 0.12204395f, 
    0.01586913f, -0.09897938f, 0.06236215f, -0.27275816f, 0.09888450f, 0.01051980f, 0.08529706f, -0.01681236f, 
    -0.11024832f, 0.11702640f, -0.00917791f, -0.14408049f, -0.13049273f, 0.27968180f, -0.01480648f, -0.17126596f, 
    0.09593460f, 0.17916286f, -0.02526172f, -0.02532930f, -0.21488972f, 0.14025809f, 0.04644497f, -0.04398796f, 
    0.07873632f, -0.07570959f, -0.05540637f, 0.04921971f, -0.00672345f, -0.16470073f, -0.02865483f, -0.11077397f, 
    0.01572607f, 0.03500795f, 0.17476705f, -0.00305178f, -0.04054121f, 0.01472763f, 0.05626818f, -0.14385116f, 
    0.02783206f, -0.05404664f, -0.06985652f, 0.10096636f, -0.19914919f, 0.00870187f, -0.08514891f, -0.18674770f, 
    0.06975098f, -0.05845306f, 0.06908187f, 0.14931166f, 0.10332464f, 0.06133274f, -0.03064325f, 0.03280363f, 
    0.03034123f, 0.03331346f, 0.02346071f, 0.04434297f, 0.01390696f, 0.04698448f, -0.02247674f, -0.00153858f, 
    -0.00899668f, -0.04327827f, -0.06567942f, -0.01170128f, 0.01323061f, -0.02258625f, 0.02623742f, 0.01579250f, 
    0.03229662f, -0.01863030f, -0.00003298f, -0.00280540f, 0.03716677f, -0.06354635f, 0.04758872f, -0.04976042f, 
    -0.05744108f, -0.05180432f, -0.02123269f, -0.04388627f, -0.04619915f, -0.03262813f, -0.06176910f, -0.02786007f, 
    -0.02942205f, 0.01960645f, -0.03369528f, 0.01869120f, 0.04413157f, 0.03111460f, -0.03966110f, 0.03629072f, 
    -0.03456092f, -0.04636617f, -0.01405707f, 0.04326236f, -0.00599503f, -0.06584939f, 0.01986375f, -0.05337713f, 
    -0.00907244f, -0.04370010f, 0.01353215f, 0.03980166f, 0.04381512f, -0.05612269f, 0.03074283f, -0.01851287f, 
    -0.04316486f, -0.04614597f, -0.06382479f, 0.02496820f, 0.04726674f, 0.03005228f, 0.04548376f, 0.03852027f, 
    0.03073423f, 0.01462945f, -0.03469915f, 0.01621409f, -0.04915283f, 0.01730287f, -0.06421727f, -0.02413250f, 
    0.04416768f, 0.01862492f, -0.03628963f, 0.01121354f, -0.03182839f, -0.06171615f, -0.01789693f, 0.03451535f, 
    -0.01194371f, 0.03347991f, -0.02523391f, -0.00588710f, 0.03086166f, -0.00725478f, -0.00795930f, 0.04870130f, 
    -0.01421129f, -0.05669302f, 0.01215700f, 0.01682035f, -0.05995047f, 0.00704659f, -0.00816819f, 0.01186787f, 
    -0.01069174f, -0.03217079f, -0.05667403f, -0.04085040f, -0.01586619f, 0.01118322f, -0.03103494f, -0.00231146f, 
    -0.03846447f, -0.06023731f, -0.04842161f, 0.04741068f, -0.00446071f, -0.06731826f, 0.02278741f, 0.04284651f, 
    -0.00447870f, -0.03512433f, -0.01469773f, -0.05348251f, 0.02593783f, -0.03426395f, -0.04221094f, 0.02241933f, 
    0.04080658f, -0.04509619f, 0.04265674f, 0.03174647f, -0.05350270f, 0.03144300f, 0.03613492f, -0.03562295f, 
    -0.04499578f, 0.03080053f, 0.00363647f, -0.01822499f, -0.00383244f, -0.01969144f, 0.02934527f, -0.00189126f, 
    0.03724802f, 0.02451764f, -0.00937621f, 0.03274271f, -0.05451309f, -0.02501349f, -0.02347032f, -0.06261879f, 
    -0.00378616f, -0.03493976f, -0.06018934f, 0.00508556f, 0.00140359f, -0.01182323f, 0.05228268f, -0.04522607f, 
    0.02154453f, -0.02210128f, -0.05506158f, 0.02648306f, 0.01421912f, 0.02090960f, -0.02213898f, -0.03052301f, 
    0.01946850f, -0.05278602f, 0.00591308f, -0.00387479f, -0.00335832f, -0.03241879f, 0.01568603f, -0.00054120f, 
    -0.04333014f, -0.04079822f, 0.01642235f, 0.02879924f, -0.00726665f, -0.02017559f, 0.02986512f, -0.02181036f, 
    -0.01937125f, 0.04728838f, 0.04550287f, 0.02673585f, 0.02668365f, -0.05915717f, -0.02949704f, -0.06367455f, 
    0.00339569f, 0.03748560f, 0.01053792f, 0.00559887f, -0.01521783f, 0.03074018f, -0.01562422f, -0.03049737f, 
    -0.02719182f, 0.04383162f, -0.03964121f, -0.06436563f, 0.04242259f, 0.01817354f, 0.01224714f, 0.01786263f, 
    -0.04275651f, -0.06634797f, 0.00991080f, -0.04715041f, -0.03083803f, -0.02225684f, 0.04001578f, -0.05101674f, 
    -0.03196244f, 0.03445782f, -0.06395823f, 0.01093366f, 0.04149891f, 0.04210238f, 0.02781072f, -0.05312008f, 
    0.04511187f, -0.05706576f, 0.04784294f, -0.06091442f, -0.02119585f, 0.00149207f, -0.04029094f, -0.06556564f, 
    -0.06591139f, -0.05774380f, 0.04766473f, -0.05994109f, -0.05978562f, -0.03674610f, -0.02625364f, -0.01239102f, 
    0.04963521f, -0.04245688f, -0.00703912f, 0.02657560f, -0.00338859f, 0.00039806f, 0.05094306f, 0.03942328f, 
    0.01771206f, 0.02503346f, -0.00168018f, -0.03582468f, 0.00972249f, 0.02521588f, -0.06355139f, 0.00679365f, 
    -0.04302604f, 0.01296728f, -0.04642588f, 0.00837914f, -0.02750495f, -0.03759930f, -0.02568604f, -0.06039387f, 
    -0.00437398f, -0.05296338f, -0.01177705f, 0.04128828f, 0.02672285f, -0.02669286f, -0.00948043f, -0.05950288f, 
    -0.01712419f, -0.03238611f, -0.06410021f, -0.02176195f, -0.00837920f, 0.03140488f, 0.00133578f, -0.02340124f, 
    -0.01533869f, -0.04315022f, 0.04465582f, -0.06480753f, -0.02130156f, 0.03213302f, -0.00507392f, 0.02753838f, 
    0.03287167f, 0.02266790f, 0.02933707f, -0.01201989f, -0.05771193f, -0.04678323f, -0.00629391f, 0.01300276f, 
    -0.02314319f, -0.06426738f, 0.01792469f, -0.01185574f, -0.02157851f, 0.02344703f, 0.04184572f, -0.06651670f, 
    0.01026033f, 0.02403252f, -0.02128829f, -0.02168164f, 0.03807491f, 0.00115292f, -0.06555746f, 0.00285816f, 
    -0.06111678f, -0.03655943f, -0.02561303f, 0.02523828f, -0.03803023f, 0.00811865f, 0.02136529f, -0.05319049f, 
    -0.00784925f, -0.03580797f, -0.03067750f, -0.04988693f, 0.00314574f, -0.02203694f, 0.00592266f, -0.02088961f, 
    -0.05244579f, -0.00536141f, -0.03381978f, -0.01348231f, -0.04553511f, -0.05360915f, -0.06279689f, -0.06305195f, 
    -0.01939532f, -0.02759568f, -0.05409335f, 0.01781197f, -0.04668256f, 0.02201686f, -0.03088548f, 0.00429767f, 
    -0.05598020f, 0.03152530f, 0.03447471f, 0.03013490f, -0.02141858f, -0.04247442f, -0.04606273f, -0.04332030f, 
    -0.01916718f, -0.04160247f, -0.03432832f, 0.02120372f, -0.04585642f, -0.02179958f, -0.00545570f, -0.02399475f, 
    0.02910752f, 0.01002148f, -0.06707472f, -0.06883357f, -0.06576771f, -0.05618984f, -0.02042067f, -0.00644231f, 
    0.03839739f, -0.03406307f, -0.00774916f, 0.02403537f, -0.05531673f, -0.07112268f, 0.01813575f, 0.01038045f, 
    -0.04873726f, -0.06972579f, 0.00652768f, -0.02146289f, 0.01297564f, -0.01192526f, 0.02479063f, -0.02122631f, 
    -0.05151850f, -0.01148973f, -0.07416540f, 0.00056868f, 0.04106029f, -0.05150188f, -0.01357887f, -0.05341238f, 
    -0.04751090f, -0.00881471f, -0.01674790f, 0.02654651f, -0.04837384f, -0.01444974f, 0.02662222f, -0.06171484f, 
    -0.02123191f, 0.01900813f, -0.05886629f, -0.01157935f, -0.04367938f, -0.05745576f, -0.06740098f, -0.01314408f, 
    -0.00728063f, -0.03511655f, -0.02202205f, -0.03115502f, -0.04962817f, 0.01389031f, -0.05766878f, -0.02244712f, 
    -0.01876531f, -0.01037295f, 0.01390281f, -0.03285921f, -0.05437796f, -0.05182199f, 0.01109111f, -0.01039875f, 
    0.01171601f, 0.03664683f, -0.01115265f, -0.05603473f, -0.04130697f, -0.00535619f, -0.06804635f, -0.02519392f, 
    -0.00720490f, 0.01204877f, 0.02426553f, -0.05337148f, 0.01587698f, 0.04780136f, 0.01099481f, -0.05578477f, 
    0.01559839f, 0.00481455f, 0.03864501f, -0.00380982f, -0.06455927f, 0.02575367f, -0.04952177f, 0.01081739f, 
    0.01992003f, 0.03583277f, 0.04217680f, -0.01656727f, -0.06216519f, -0.07125235f, -0.03964540f, -0.07297341f, 
    0.03451319f, -0.06392765f, -0.06110204f, -0.04542590f, -0.02289155f, -0.04021390f, -0.06613529f, 0.02173047f, 
    -0.06421950f, -0.01395804f, -0.03507121f, -0.00543512f, -0.02243133f, -0.01379267f, 0.01996600f, 0.00897349f, 
    -0.04378490f, 0.05848989f, 0.02077505f, 0.03359256f, -0.05579377f, 0.00460835f, -0.05645154f, -0.00037209f, 
    0.00279413f, 0.02949946f, 0.01389662f, -0.06773068f, -0.00045014f, -0.05073032f, -0.02764467f, 0.02299049f, 
    -0.00287457f, 0.01636389f, 0.02819504f, 0.02842691f, 0.02358628f, -0.02443814f, -0.06693396f, 0.00727225f, 
    -0.02423877f, -0.00797639f, -0.04980528f, 0.02891867f, -0.05056082f, 0.01657969f, -0.02319150f, 0.00222327f, 
    -0.04066473f, -0.03833199f, 0.04351346f, -0.02143244f, -0.01312159f, 0.01527884f, 0.03329457f, -0.01930661f, 
    0.00413668f, 0.02538658f, 0.01223373f, -0.07372410f, -0.04416773f, 0.00920234f, -0.02853491f, -0.02706473f, 
    -0.06515418f, -0.00765712f, -0.06131205f, -0.02313889f, 0.00563988f, -0.03093632f, -0.07093342f, -0.06719997f, 
    -0.05972427f, 0.00281074f, -0.06902578f, -0.02055306f, -0.07311085f, -0.02270336f, 0.04120386f, 0.01194751f, 
    -0.03726511f, 0.04049206f, -0.01977645f, -0.05324813f, 0.03754301f, 0.00971400f, -0.01468100f, -0.03369289f, 
    -0.04732016f, -0.04702450f, 0.03621165f, -0.03881378f, -0.01810748f, -0.04969488f, -0.05204571f, 0.01028789f, 
    0.00427711f, 0.01256549f, 0.00966607f, -0.06944855f, 0.00412482f, 0.02386249f, -0.02717820f, 0.01302939f, 
    0.03333896f, 0.00547684f, -0.04173050f, -0.03689997f, 0.00236718f, -0.03397826f, -0.04026883f, -0.05491190f, 
    0.01132811f, 0.00011640f, -0.04673034f, -0.06888558f, -0.02165391f, 0.03033537f, -0.03447951f, 0.01828701f, 
    -0.04022539f, -0.02249172f, -0.05636640f, -0.06863531f, 0.03385258f, 0.01888618f, -0.05740950f, -0.04428925f, 
    0.19482388f, 0.12269756f, -0.14822486f, 0.13945121f, 0.02470635f, -0.00516439f, 0.04201641f, 0.12890199f, 
    -0.00227105f, 0.01729465f, -0.08477383f, 0.14675051f, -0.05676104f, 0.03141608f, -0.09108522f, -0.12277281f, 
    -0.17660965f, 0.08304963f, -0.26061794f, 0.05873223f, -0.04784794f, 0.08008662f, 0.06886703f, -0.01436183f, 
    -0.07833454f, -0.08907091f, -0.05705472f, -0.39533636f, -0.02436098f, 0.02232921f, -0.00637056f, 0.02939415f, 
    -0.15037945f, -0.09997696f, 0.02435345f, 0.17984094f, -0.13097297f, 0.10380743f, 0.43942985f, -0.06400293f, 
    -0.04491020f, 0.10508276f, 0.03763308f, -0.03413247f, 0.02413910f, -0.05179722f, 0.17000687f, 0.17055020f, 
    -0.25191048f, 0.12861449f, -0.01863450f, -0.09028943f, -0.00311783f, 0.08535588f, 0.00126976f, 0.22131635f, 
    0.16886783f, 0.05709425f, 0.06538752f, -0.05738404f, 0.13980870f, 0.01637150f, 0.01235755f, 0.16998671f, 
    0.07553024f, 0.12965427f, -0.11051159f, 0.11961295f, 0.00365160f, 0.07431050f, 0.00066488f, 0.01325577f, 
    -0.21779785f, 0.12816915f, 0.05775173f, 0.08272893f, 0.09195451f, 0.05058803f, 0.05292197f, -0.11329651f, 
    -0.03147636f, -0.31152526f, -0.23244835f, -0.03536832f, 0.04129709f, -0.14028320f, 0.12528531f, -0.16146153f, 
    0.11712963f, -0.16914326f, 0.21274257f, 0.13543595f, 0.19541577f, -0.15065922f, 0.10969178f, -0.04361799f, 
    -0.05956588f, -0.07736195f, 0.10553731f, -0.20788804f, -0.15983960f, -0.07985085f, -0.01579341f, -0.10374810f, 
    0.01268091f, 0.10666003f, 0.04745815f, 0.04135039f, 0.20757961f, 0.04972121f, -0.03445955f, -0.06734026f, 
    0.03005289f, 0.00552873f, 0.18583965f, 0.12191125f, 0.01963027f, -0.09730890f, -0.02792649f, 0.20660961f, 
    0.08607285f, 0.08541466f, -0.10940161f, -0.15527996f, 0.06870288f, 0.12262397f, -0.05190525f, 0.02029283f, 
    -0.08457574f, -0.27502653f, 0.05978817f, -0.01598156f, -0.03291478f, -0.06831525f, 0.13528600f, -0.29585460f, 
    -0.40051746f, -0.20123473f, 0.19642612f, -0.04744856f, -0.12354885f, 0.02827661f, -0.01779393f, -0.07058124f, 
    -0.01038123f, 0.19463274f, -0.19539161f, 0.19615278f, 0.12217742f, -0.01815413f, 0.08201277f, -0.02227305f, 
    -0.00781995f, -0.15747194f, -0.15222561f, -0.19833429f, -0.03598787f, -0.02530495f, -0.08148020f, -0.08250055f, 
    0.00907176f, 0.03924292f, 0.02964150f, 0.02798375f, 0.12823983f, -0.04865156f, 0.08462099f, 0.00344802f, 
    0.04771344f, 0.01126870f, -0.00815968f, -0.22478434f, -0.09676807f, -0.08871496f, -0.06411738f, 0.01227095f, 
    0.01496041f, 0.09125820f, -0.01380678f, 0.04036071f, -0.14774255f, -0.05459247f, 0.16821532f, 0.02173531f, 
    0.08380377f, -0.09858269f, 0.04588246f, 0.11501803f, -0.00684764f, 0.02213734f, 0.05265020f, 0.01907310f, 
    0.21263421f, 0.06911955f, 0.02147114f, -0.13753195f, -0.10104100f, -0.11675800f, 0.03594561f, -0.05881504f, 
    -0.21976501f, 0.11239681f, 0.06689227f, 0.00008284f, 0.09542312f, -0.05982587f, 0.18177208f, 0.12087413f, 
    0.15892768f, -0.09641294f, 0.09015386f, 0.06336787f, 0.07639349f, 0.02417201f, -0.17494422f, 0.01899218f, 
    -0.25347963f, -0.01540661f, -0.10797349f, 0.00971157f, 0.00450594f, 0.02019577f, -0.00543801f, -0.08308304f, 
    0.08268879f, -0.09570183f, -0.00264990f, 0.03724165f, 0.00709873f, 0.00166882f, 0.09168708f, -0.19620851f, 
    -0.06576057f, -0.00415589f, -0.04783718f, -0.10151822f, 0.09167551f, -0.00951938f, -0.19670521f, -0.26381561f, 
    0.04623850f, 0.08789296f, -0.04472972f, -0.10993996f, -0.09701387f, 0.14234917f, 0.05177895f, 0.06271610f, 
    -0.05143915f, -0.00072297f, -0.06079879f, 0.04772678f, -0.09491032f, -0.01218119f, 0.08139674f, -0.04724026f, 
    0.12508595f, 0.01961072f, -0.07277056f, 0.04428596f, 0.01168865f, -0.09169003f, 0.06992450f, -0.10353544f, 
    0.05028839f, -0.20457268f, -0.18533337f, 0.29113826f, 0.01902451f, -0.04402638f, -0.06944913f, -0.09041137f, 
    0.03610778f, -0.20818980f, 0.01834842f, -0.21423337f, 0.03609510f, 0.06289338f, 0.28718513f, 0.10865009f, 
    0.14834990f, 0.23892185f, 0.18657357f, 0.07984227f, 0.00375293f, 0.15088034f, 0.04775876f, 0.04606422f, 
    0.07323348f, 0.02688629f, -0.30969518f, -0.15371682f, -0.06226618f, 0.07226468f, 0.03560622f, 0.00977767f, 
    -0.08591504f, -0.01033395f, -0.12326290f, -0.14090188f, 0.07582364f, -0.01083922f, 0.01746765f, 0.07870849f, 
    0.00229612f, 0.00776433f, 0.04940549f, -0.05174832f, -0.05097203f, -0.13196947f, -0.03962533f, 0.11746666f, 
    0.02909622f, 0.07983736f, -0.09406312f, -0.12400626f, -0.07839074f, 0.12694043f, 0.02734254f, 0.02766232f, 
    -0.01915187f, 0.02549145f, -0.07141078f, 0.05752640f, 0.11644379f, 0.10154878f, -0.13194229f, 0.01705144f, 
    -0.12650090f, -0.02539815f, 0.00969638f, 0.18998069f, -0.10159340f, 0.20256191f, 0.09986695f, -0.06356049f, 
    0.04762915f, -0.10571867f, 0.00602539f, 0.02161783f, -0.06114302f, 0.02702883f, -0.00808729f, 0.03561248f, 
    0.03178234f, 0.04397583f, 0.16459160f, -0.05399136f, 0.03040420f, 0.10070319f, 0.03660889f, -0.04857900f, 
    0.03182076f, 0.03360593f, 0.10376010f, -0.18296807f, 0.11723693f, 0.17407586f, -0.02931713f, -0.03691293f, 
    0.28211805f, 0.12834744f, 0.04012090f, 0.08853930f, 0.01520131f, 0.03352360f, -0.05330531f, 0.04693418f, 
    0.09115510f, 0.08792903f, -0.24043800f, -0.03500958f, -0.15311252f, 0.00435804f, 0.03465271f, 0.05429873f, 
    -0.05425258f, -0.04568699f, 0.06151832f, -0.03228237f, -0.00944813f, 0.03211897f, 0.14027596f, -0.25754797f, 
    -0.03930628f, -0.11206647f, -0.13352530f, -0.03032976f, -0.04754503f, 0.01936224f, -0.01925997f, 0.07972550f, 
    -0.01434862f, 0.02435865f, 0.01734994f, 0.05061582f, -0.05195489f, 0.01930946f, 0.06843057f, -0.16648455f, 
    0.03791007f, -0.06886314f, 0.00475567f, 0.21683809f, 0.09922510f, 0.01837639f, -0.05955373f, -0.08836437f, 
    -0.00059468f, 0.14713283f, 0.07089313f, 0.14116547f, -0.07483228f, 0.01419680f, -0.19593644f, 0.02710049f, 
    0.08333815f, 0.10911819f, -0.05778932f, 0.09418690f, 0.02539807f, 0.05489820f, 0.12000030f, -0.23737444f, 
    -0.09043708f, 0.08964555f, 0.03631842f, -0.03362946f, 0.09977876f, 0.03071542f, 0.05255715f, 0.03525295f, 
    0.07347406f, -0.07053286f, -0.07237641f, -0.16714057f, -0.02378526f, 0.01880823f, -0.06645281f, -0.00860105f, 
    -0.06484816f, 0.13392879f, -0.04782045f, 0.06636010f, 0.14698827f, -0.00126149f, 0.00702877f, -0.08787955f, 
    0.16229846f, 0.02277725f, -0.04075743f, -0.02057025f, 0.03516169f, 0.06329320f, 0.07098354f, 0.17270857f, 
    -0.09906768f, -0.08318827f, -0.17122838f, 0.08376969f, 0.01897721f, -0.16235422f, 0.14144491f, 0.00237545f, 
    -0.02400013f, -0.08132032f, -0.00910940f, 0.03125605f, 0.08479754f, 0.27666125f, 0.02837161f, -0.02409383f, 
    0.05017079f, 0.03763424f, -0.07276148f, 0.13015926f, 0.13747317f, -0.02029136f, -0.04055722f, -0.13984506f, 
    -0.03582343f, -0.10628632f, 0.10995468f, 0.02197290f, 0.02772664f, -0.09182424f, 0.18909307f, -0.05977475f, 
    -0.14818296f, -0.07012963f, 0.08853337f, -0.03993681f, -0.04786066f, -0.07599990f, 0.01461952f, 0.18482053f, 
    -0.03298794f, -0.21028098f, -0.06567314f, -0.16794901f, -0.05286986f, 0.10820704f, -0.16479564f, -0.10483862f, 
    0.06425873f, -0.04273087f, -0.05342389f, -0.04083047f, 0.09947734f, -0.01974719f, -0.12870099f, 0.12254936f, 
    0.17348434f, 0.04593211f, -0.08869964f, 0.12598230f, -0.00032759f, 0.12729047f, -0.02239344f, 0.11439636f, 
    -0.03770019f, -0.00311342f, 0.00620933f, -0.01761538f, -0.01645951f, 0.12045231f, 0.03140362f, 0.10007640f, 
    -0.02959290f, -0.07381767f, 0.00396224f, -0.13366309f, -0.00525798f, -0.04237244f, 0.10619880f, 0.04205030f, 
    0.09976615f, -0.08014662f, -0.00546093f, -0.03485047f, -0.11002433f, 0.00469920f, -0.03710072f, 0.13485160f, 
    -0.12019733f, 0.09819506f, 0.12741713f, -0.16944517f, -0.12807617f, -0.21230298f, -0.06324774f, -0.14092869f, 
    -0.00271818f, 0.08880521f, 0.12612046f, -0.09832617f, 0.04643014f, 0.16845232f, 0.07508469f, 0.12448440f, 
    -0.09961084f, 0.08833967f, 0.01211212f, 0.15166718f, -0.02110196f, 0.11660540f, -0.10524374f, 0.09152000f, 
    0.11477505f, 0.08074569f, -0.01133258f, -0.04703041f, -0.02081088f, 0.00096246f, 0.04102357f, 0.01759219f, 
    0.07093392f, -0.13700402f, -0.12866718f, 0.05533266f, 0.00379686f, 0.04624615f, -0.05357217f, -0.06466208f, 
    -0.05346616f, 0.04704969f, -0.02374663f, -0.11113530f, -0.14369500f, -0.06885348f, 0.15214211f, -0.02055667f, 
    0.05785657f, 0.04126144f, -0.23737063f, -0.02288110f, -0.04326246f, 0.14777321f, -0.03037035f, -0.07569902f, 
    -0.05786974f, 0.09477290f, -0.17633168f, 0.07969745f, -0.25959703f, -0.25481120f, 0.02823183f, 0.04567025f, 
    -0.29623184f, 0.10021523f, -0.17148170f, 0.10555292f, -0.10711620f, 0.27217525f, 0.06846724f, 0.09090149f, 
    -0.08953502f, -0.15937883f, -0.03912568f, 0.04366146f, -0.04022275f, 0.15724987f, 0.24350995f, 0.10667738f, 
    -0.03410544f, 0.08455361f, 0.06593546f, 0.07032711f, -0.02652143f, -0.07877060f, 0.02930024f, 0.23461802f, 
    0.16504350f, 0.16390400f, 0.02308846f, 0.02048594f, 0.04043282f, 0.13790077f, 0.12266768f, -0.10273351f, 
    0.06433010f, 0.13202065f, 0.01927288f, 0.08035196f, 0.06060893f, 0.01873143f, -0.08904506f, 0.10039850f, 
    -0.04192694f, 0.08628152f, 0.07953142f, 0.18851379f, -0.01374369f, -0.09224240f, 0.23156579f, -0.13022056f, 
    0.09449281f, 0.04143438f, -0.20158130f, -0.05430533f, 0.06921072f, 0.00686766f, 0.04254363f, 0.07128443f, 
    -0.15938056f, -0.17784631f, -0.03071269f, -0.05642093f, 0.04332699f, -0.13096496f, -0.03905073f, -0.12975341f, 
    -0.08699769f, 0.01651573f, -0.11634726f, -0.02299190f, -0.00747460f, -0.26401696f, -0.07264424f, 0.02209767f, 
    -0.08387686f, 0.19088000f, 0.02147183f, -0.11635751f, -0.01321035f, -0.20291209f, -0.04203102f, 0.04410987f, 
    0.00185270f, 0.05242931f, 0.06654109f, 0.06105960f, 0.09974712f, 0.07811601f, 0.08246334f, 0.05690144f, 
    0.04056805f, 0.02452966f, 0.00038067f, 0.08266702f, -0.05298578f, 0.25738305f, -0.03939201f, -0.05842461f, 
    -0.12729597f, 0.05698580f, 0.09303064f, 0.01344447f, 0.10756858f, -0.03115012f, 0.04942609f, -0.00508239f, 
    -0.40334901f, -0.46261933f, 0.03372965f, -0.07627828f, 0.23510239f, -0.17591809f, -0.11398767f, 0.08874536f, 
    -0.01515548f, 0.10634945f, 0.08394261f, 0.09047719f, 0.04683389f, -0.00565105f, 0.16795936f, -0.08202185f, 
    -0.08526415f, 0.06835681f, 0.05242117f, -0.03679850f, -0.04327144f, -0.05021084f, -0.03261668f, 0.24720806f, 
    0.04873666f, -0.06394657f, 0.16614814f, 0.09157163f, -0.19756296f, 0.05100787f, 0.06922330f, 0.09163205f, 
    0.08313690f, 0.00899528f, 0.12847538f, -0.15612289f, -0.13584185f, 0.14225008f, -0.00672200f, -0.07598138f, 
    0.04887877f, 0.08160820f, -0.00638890f, -0.14021684f, -0.04096121f, 0.11211043f, 0.18020968f, 0.09643399f, 
    0.12640695f, -0.05114798f, 0.02636418f, 0.12003693f, 0.00885304f, 0.08299951f, 0.27154690f, -0.02180671f, 
    0.19345754f, 0.05748437f, 0.11693277f, 0.03050495f, -0.02759392f, -0.02491846f, 0.05748880f, -0.19910972f, 
    -0.06052845f, 0.03012937f, 0.00293535f, 0.01710049f, -0.10611281f, -0.07127576f, -0.11328863f, 0.05477068f, 
    -0.17147531f, -0.06937906f, 0.03306279f, -0.02966136f, 0.01334848f, -0.01247741f, -0.13636911f, -0.06387846f, 
    -0.07658264f, -0.03560315f, 0.11596609f, 0.11162746f, -0.03649649f, -0.00105301f, -0.01525026f, 0.00454724f, 
    -0.02397742f, 0.06291375f, 0.00883539f, -0.22073048f, -0.03692947f, -0.01329322f, 0.12631731f, 0.07826496f, 
    -0.07311657f, 0.08214749f, -0.09028930f, -0.03957453f, 0.05973190f, -0.03840131f, 0.11411469f, 0.01678305f, 
    -0.05502177f, 0.05135045f, -0.01344738f, 0.17242453f, 0.07074176f, -0.20616455f, -0.02723688f, 0.09045824f, 
    0.06052149f, 0.02484343f, 0.09700738f, 0.11388497f, -0.06061031f, -0.03069684f, 0.11373914f, 0.04895758f, 
    0.09557380f, -0.06884592f, -0.04336334f, 0.00186489f, 0.02430011f, 0.26101300f, 0.02587314f, -0.07854871f, 
    -0.01025184f, -0.02724283f, 0.11032754f, -0.05032356f, -0.02753113f, -0.01009810f, -0.04114942f, -0.07240438f, 
    0.21029501f, -0.02831410f, 0.00629559f, 0.06782434f, 0.00898179f, 0.06019592f, 0.07660222f, 0.08422031f, 
    0.22620079f, 0.18899575f, 0.22064464f, 0.05963758f, -0.03065845f, 0.07955323f, 0.01645108f, 0.07850104f, 
    0.04159302f, 0.01400296f, -0.01296016f, -0.05857956f, 0.01175206f, 0.03536689f, -0.00208505f, 0.02549523f, 
    0.00214400f, -0.00182487f, -0.01986511f, -0.07028623f, -0.04003374f, 0.02723195f, 0.00703624f, -0.01321121f, 
    -0.02463829f, -0.00917103f, 0.03190543f, 0.01060524f, 0.02928640f, -0.02316552f, 0.03081519f, 0.02987786f, 
    -0.10669460f, -0.01428395f, -0.04094245f, -0.01297961f, -0.04551297f, -0.04651945f, 0.03373649f, -0.02811563f, 
    -0.01896369f, -0.04730439f, -0.00584239f, -0.06159111f, 0.04678613f, -0.00845488f, 0.05672101f, -0.02495137f, 
    0.03705825f, -0.07449143f, -0.02334240f, 0.00330242f, -0.03785000f, -0.04065209f, 0.02366224f, -0.04757350f, 
    -0.05944079f, 0.02293934f, 0.00059313f, -0.07113317f, -0.02347912f, -0.06281586f, -0.04710602f, 0.01841086f, 
    -0.00285459f, -0.01123263f, -0.04563284f, -0.00303994f, 0.03205793f, -0.02345128f, -0.05613660f, 0.03538403f, 
    0.04912546f, -0.05460895f, -0.04985897f, 0.00244257f, 0.05480124f, 0.01081711f, -0.02880920f, 0.04507706f, 
    -0.08942112f, -0.01147145f, 0.00892147f, -0.04517761f, 0.03148760f, -0.05948513f, 0.00197077f, -0.04362746f, 
    -0.07126098f, -0.07157091f, 0.03115881f, 0.00306839f, -0.07042989f, -0.07403108f, 0.03695113f, -0.06640244f, 
    -0.02691549f, -0.06229122f, -0.08700283f, 0.04497828f, -0.00228570f, -0.01468715f, -0.05669237f, -0.00136353f, 
    -0.01140984f, 0.04087856f, 0.02063755f, -0.00728754f, 0.03414255f, 0.03309943f, -0.03926732f, -0.03711042f, 
    -0.03441828f, -0.01461085f, 0.00166581f, -0.02788123f, -0.01388505f, -0.04123698f, 0.02506963f, -0.03099554f, 
    -0.02790584f, 0.00662481f, 0.01972642f, -0.03559560f, -0.07730186f, 0.02785652f, -0.03933286f, -0.05236958f, 
    -0.05459912f, 0.00077187f, 0.02450807f, -0.02929295f, 0.00673395f, -0.04147537f, 0.01521888f, 0.04236744f, 
    0.01781357f, -0.04305248f, 0.00802129f, -0.02845666f, 0.01044278f, 0.01237535f, -0.01409644f, 0.03227598f, 
    0.02348461f, -0.04892957f, -0.03812500f, -0.01587208f, 0.06479883f, -0.04912997f, -0.06853341f, -0.03724923f, 
    -0.04075239f, -0.07408196f, -0.03758957f, -0.06267326f, -0.03979495f, -0.00754284f, -0.03570105f, -0.05906190f, 
    -0.00135157f, -0.08572381f, 0.00132165f, 0.01648792f, 0.01941501f, -0.00178197f, -0.00349288f, -0.02686103f, 
    -0.06760994f, 0.00854079f, 0.02796035f, -0.01870357f, -0.05858960f, 0.03636376f, 0.02895634f, -0.01268042f, 
    -0.03497775f, -0.06375797f, 0.04292691f, -0.03400414f, 0.03064272f, 0.03122191f, 0.01872253f, -0.00072168f, 
    -0.04039699f, -0.06209701f, -0.04746767f, -0.05280346f, -0.05570834f, -0.02698440f, -0.02561383f, 0.03245944f, 
    -0.07387514f, 0.02910339f, -0.05284434f, -0.06452277f, 0.02453901f, 0.03878282f, 0.01831841f, -0.07489176f, 
    0.03004399f, -0.03029794f, 0.05323623f, 0.03614437f, 0.01376946f, -0.03810053f, -0.00318886f, 0.01000196f, 
    -0.02382364f, 0.00936756f, -0.03659995f, -0.02613785f, 0.00177443f, -0.09272115f, 0.02146303f, -0.02182888f, 
    0.00723862f, 0.02337158f, 0.02086496f, 0.03816798f, -0.00277323f, -0.00841357f, -0.03815679f, 0.00969906f, 
    0.04739581f, -0.04105026f, -0.00476801f, -0.06669920f, 0.00434277f, -0.05416842f, -0.05737400f, -0.08193929f, 
    0.02034927f, -0.01898284f, -0.03350496f, 0.01723578f, -0.03053402f, 0.02483124f, 0.05299235f, -0.03460917f, 
    -0.02513667f, -0.05918571f, -0.05819348f, 0.04172532f, -0.04422177f, -0.05066841f, -0.00585153f, -0.07491557f, 
    -0.01420038f, 0.03311956f, 0.01370279f, -0.04107291f, -0.03129191f, -0.01554122f, 0.01463348f, 0.00008125f, 
    -0.05655212f, -0.05361169f, -0.03699635f, 0.01041166f, 0.03844021f, 0.02020895f, 0.02432610f, -0.03165012f, 
    0.06045930f, -0.04610180f, -0.05801950f, -0.03556901f, 0.00527128f, -0.01025294f, 0.06775613f, 0.04592043f, 
    -0.02369624f, 0.00170926f, 0.04146913f, -0.02264196f, -0.05018052f, -0.00103905f, -0.04035328f, -0.00234503f, 
    0.05563471f, -0.02979969f, 0.00932635f, -0.00657562f, 0.02376739f, 0.02825452f, 0.03751328f, -0.08749959f, 
    0.01231673f, 0.02978830f, -0.03333934f, -0.08626807f, -0.01455512f, -0.06155893f, -0.01279668f, -0.07738952f, 
    0.15309888f, 0.02327888f, -0.00251291f, -0.00140118f, 0.06910264f, 0.05379578f, 0.04192341f, -0.01386042f, 
    0.02819309f, -0.08408234f, 0.10325524f, 0.19204244f, 0.14608915f, -0.11502916f, -0.01174188f, -0.03778135f, 
    -0.07947484f, 0.10374027f, 0.11866073f, 0.13922605f, 0.01865101f, -0.04993221f, 0.07342397f, -0.00428994f, 
    -0.10293674f, 0.15150060f, -0.01232571f, -0.20035410f, -0.18664981f, 0.14686336f, -0.12880902f, -0.08579836f, 
    -0.02927764f, -0.02909657f, 0.00467060f, 0.03795860f, -0.24449769f, -0.42658880f, -0.17714360f, 0.11113046f, 
    -0.03832175f, 0.06449596f, -0.02492253f, -0.07153081f, 0.03612575f, -0.02339274f, -0.01292972f, 0.01041246f, 
    -0.08114588f, 0.04066064f, -0.04020093f, -0.06759193f, -0.08383263f, -0.06980503f, 0.07844820f, -0.17985155f, 
    -0.03401668f, 0.06477018f, 0.02857433f, -0.03131930f, 0.01689769f, 0.01106387f, -0.00741470f, 0.02479675f, 
    0.08853800f, 0.10176580f, 0.04930562f, 0.09581660f, 0.02430213f, 0.02521623f, -0.03567103f, 0.11251974f, 
    -0.08470362f, -0.09496787f, 0.05497212f, -0.03466269f, -0.06538607f, 0.07171559f, -0.07228035f, 0.00110885f, 
    -0.07158569f, -0.14999321f, 0.00503690f, 0.08860776f, -0.09368027f, -0.19781888f, -0.02535527f, 0.08389562f, 
    -0.00225590f, 0.11535132f, 0.55114263f, -0.13366842f, -0.10828993f, 0.12931669f, -0.04771153f, 0.03895819f, 
    -0.01740679f, 0.04405960f, -0.09904847f, 0.02288043f, 0.04960033f, 0.05074375f, 0.11674877f, -0.09682700f, 
    0.10311467f, 0.02895793f, -0.05155636f, 0.04036976f, 0.02858996f, 0.07909526f, 0.04423285f, 0.07148787f, 
    -0.03408096f, 0.05529245f, 0.03856336f, 0.01564659f, -0.06259780f, 0.24498859f, 0.07687297f, -0.01110376f, 
    -0.06806120f, -0.01885226f, -0.04782920f, 0.01728152f, 0.06354421f, -0.04659268f, 0.12772074f, 0.01539727f, 
    -0.18201339f, 0.04353192f, -0.11711180f, -0.04796607f, -0.00240675f, 0.02749901f, -0.02583127f, 0.15425435f, 
    0.01586361f, -0.03588959f, -0.07880361f, 0.02883836f, 0.01422472f, -0.03551466f, -0.00772646f, 0.05133141f, 
    0.09073766f, -0.00348116f, 0.02935905f, 0.02624160f, 0.11579856f, -0.09576850f, -0.01747278f, 0.11773731f, 
    0.09991480f, -0.07733796f, -0.08845997f, -0.15445240f, 0.01274889f, 0.04001451f, 0.00964135f, 0.00759482f, 
    -0.03258541f, -0.07327502f, 0.15552647f, -0.02559104f, 0.02298970f, 0.09172095f, -0.03345301f, -0.06515979f, 
    0.06042537f, -0.14978753f, 0.00125898f, 0.31334287f, 0.02385395f, 0.07096905f, 0.14927307f, -0.01678992f, 
    -0.02183907f, 0.06951740f, 0.02329381f, 0.07477348f, -0.05522129f, -0.19075538f, -0.03642333f, -0.04885031f, 
    0.10321885f, 0.01599639f, 0.03429406f, -0.00312828f, -0.01193972f, 0.00751499f, 0.09006723f, 0.03003262f, 
    -0.07711268f, 0.08011624f, 0.01144885f, -0.07293499f, -0.03479607f, -0.04615017f, 0.06024808f, -0.05112812f, 
    0.05885398f, -0.05816438f, -0.02565738f, 0.04200730f, 0.06714329f, -0.08041665f, -0.09871434f, -0.00863419f, 
    0.15105341f, -0.02958228f, 0.05532002f, -0.10116211f, 0.07430805f, -0.09189096f, 0.03477402f, -0.03683004f, 
    -0.03770731f, 0.08211784f, -0.05478284f, -0.00714905f, -0.02816322f, -0.00135127f, -0.01496678f, 0.08605141f, 
    -0.01576118f, -0.08763748f, 0.04676668f, 0.12898371f, -0.00806614f, 0.02966047f, 0.08627972f, 0.02868508f, 
    -0.01367043f, 0.09480303f, 0.08414575f, -0.05466918f, -0.17284383f, -0.04955861f, 0.01266620f, -0.01116327f, 
    -0.00660792f, 0.10405778f, 0.05542024f, 0.03013691f, -0.00809042f, 0.01411803f, 0.10446048f, -0.02896336f, 
    -0.06268346f, 0.00504292f, 0.06648216f, -0.09597919f, 0.03421383f, 0.03980559f, -0.11358991f, 0.03277769f, 
    0.00816315f, 0.07307057f, -0.11484686f, 0.04906472f, -0.03449848f, -0.01903580f, 0.12402945f, 0.06483737f, 
    0.11963646f, -0.02485997f, -0.01085503f, -0.07655533f, -0.09279478f, 0.02912885f, 0.20487644f, -0.05937125f, 
    -0.23672490f, -0.09619312f, 0.04090308f, 0.00281590f, -0.03714237f, -0.01434724f, -0.10717336f, -0.11932150f, 
    -0.16712610f, 0.10960183f, -0.02916764f, 0.02768539f, 0.06559170f, 0.03488079f, 0.02137933f, 0.05139694f, 
    -0.19659404f, -0.13800249f, -0.05796016f, -0.11995309f, 0.05262773f, -0.04640599f, 0.03456223f, 0.04718224f, 
    -0.02160714f, 0.00053953f, -0.04133827f, -0.08422482f, -0.00127787f, 0.16558820f, -0.03037197f, -0.09048452f, 
    0.04683610f, -0.16647133f, -0.12933944f, -0.07653818f, 0.02721322f, 0.09999108f, -0.01610967f, -0.03303083f, 
    -0.02789200f, 0.01039188f, -0.00412483f, -0.11684598f, 0.02468289f, -0.16739520f, -0.13384485f, 0.07916045f, 
    -0.03193890f, 0.10415235f, -0.05607376f, -0.03418685f, 0.24603382f, 0.09540688f, 0.10195483f, 0.03398400f, 
    -0.01555742f, 0.01624504f, -0.06910931f, 0.10055687f, 0.01677630f, 0.18790701f, 0.18589960f, 0.00706254f, 
    -0.04177964f, -0.02100243f, 0.13863131f, 0.01448259f, -0.04835687f, 0.06410058f, 0.10345706f, 0.04507780f, 
    0.13699439f, -0.04858719f, 0.01358195f, -0.05126376f, -0.12926190f, 0.12682125f, 0.00273369f, -0.04499298f, 
    0.02151180f, -0.02920683f, 0.02694378f, 0.04946347f, -0.13353734f, 0.02976098f, 0.13180736f, -0.04576181f, 
    0.24741203f, 0.08235180f, 0.15809774f, 0.00220378f, -0.00824928f, 0.01066867f, -0.05879793f, -0.01210934f, 
    -0.00516094f, 0.03577834f, -0.01862183f, 0.09931672f, -0.08676160f, 0.08421341f, 0.09959449f, 0.05386079f, 
    -0.07863645f, -0.06703293f, -0.14829428f, -0.04706091f, 0.18844438f, 0.07665137f, 0.04830204f, -0.02719546f, 
    0.04987738f, 0.00501964f, 0.13652602f, -0.06705786f, -0.11765169f, -0.13918616f, -0.11493150f, 0.06140892f, 
    0.06539211f, 0.03632480f, -0.14305790f, -0.01963429f, -0.08695177f, -0.07690678f, -0.00616416f, -0.05167082f, 
    0.01328320f, 0.00173773f, 0.05917218f, 0.01238061f, 0.19753475f, -0.06231916f, -0.04198192f, -0.10807654f, 
    0.00800131f, 0.00281854f, 0.04837910f, -0.09723382f, 0.04152221f, -0.00004476f, -0.01397823f, -0.22027211f, 
    -0.06893916f, 0.08050159f, 0.02984357f, -0.10405174f, 0.02119195f, -0.04225910f, -0.02656816f, -0.18466894f, 
    -0.16268669f, -0.07546208f, -0.06444507f, -0.02337879f, -0.11910478f, -0.05001943f, -0.12104599f, 0.09503504f, 
    -0.22415181f, 0.05749315f, -0.00802444f, -0.02313696f, 0.09505519f, -0.10680927f, 0.05726245f, -0.03585244f, 
    -0.04116356f, 0.05212601f, 0.10610516f, 0.14350200f, 0.03555769f, -0.04454160f, -0.06612581f, 0.14460650f, 
    -0.02017062f, 0.03152375f, 0.05164028f, -0.01374805f, -0.09580910f, -0.08687665f, 0.08948827f, 0.14028414f, 
    -0.09204178f, -0.05317435f, 0.02613483f, -0.34507826f, -0.00043755f, 0.16985407f, 0.05445703f, 0.19267978f, 
    0.01211204f, 0.11087899f, -0.02273814f, -0.02715326f, 0.11842691f, 0.12909821f, 0.13806912f, 0.07149272f, 
    -0.01760720f, 0.05226326f, 0.15908368f, -0.12914252f, 0.03204388f, -0.13789357f, 0.12564935f, -0.21900967f, 
    0.04200348f, -0.00556402f, 0.04028370f, -0.10033304f, 0.07106859f, -0.12677787f, -0.03806427f, -0.03756714f, 
    -0.06642696f, 0.16895394f, 0.12164284f, 0.02221500f, -0.02762176f, 0.05710692f, -0.04611476f, -0.17987271f, 
    -0.24827503f, -0.13740665f, 0.00748234f, -0.01919902f, 0.08647120f, 0.00319726f, -0.00601311f, -0.04679725f, 
    0.04361740f, 0.02495923f, 0.21868415f, -0.05098125f, 0.01200329f, -0.05456078f, -0.00195589f, 0.10738453f, 
    0.03053792f, 0.06955765f, 0.03264813f, -0.05150507f, 0.00179008f, -0.06106302f, -0.02820941f, -0.00758452f, 
    -0.14883471f, 0.07007911f, 0.12337796f, -0.31145599f, 0.15997595f, 0.02111921f, -0.08358555f, -0.15469798f, 
    -0.00908933f, -0.17258967f, -0.02568877f, -0.06757969f, 0.05326544f, -0.21717581f, 0.07974353f, 0.01420395f, 
    -0.02880059f, 0.04798713f, 0.04333294f, -0.00116029f, -0.09391315f, 0.14886038f, -0.12526503f, 0.00687101f, 
    0.00228296f, -0.06245546f, -0.07732478f, -0.00484305f, -0.07154833f, 0.12969695f, 0.01678764f, 0.04253642f, 
    0.04032634f, 0.02893043f, 0.05939852f, 0.00452589f, 0.10800485f, -0.01750434f, 0.08944662f, 0.03020236f, 
    0.07348391f, -0.02599605f, -0.15553522f, 0.00258349f, 0.02874659f, -0.10929231f, -0.02036929f, 0.24577855f, 
    0.03255865f, 0.15962417f, -0.01385289f, -0.10456374f, -0.00635143f, -0.05480523f, 0.11844164f, 0.08252214f, 
    0.07090203f, 0.11771930f, 0.06702586f, -0.11094624f, 0.05779325f, -0.01691210f, 0.03366045f, 0.00062735f, 
    -0.09651966f, -0.22569716f, -0.18005712f, -0.01846208f, 0.02422482f, 0.13654959f, -0.16202989f, -0.01257231f, 
    0.04197254f, 0.06605684f, -0.14813682f, -0.20487928f, -0.01205226f, -0.10885417f, 0.01144354f, 0.09055685f, 
    -0.02072268f, 0.07715202f, 0.07650483f, 0.11059268f, 0.07027794f, -0.02685547f, 0.09529152f, 0.14252521f, 
    -0.07835443f, -0.07000245f, 0.17275400f, -0.00398952f, -0.33179647f, -0.17325112f, 0.05809551f, 0.03443314f, 
    -0.04120672f, -0.01049167f, -0.06646513f, -0.09853439f, -0.02654700f, 0.09388877f, -0.31079420f, -0.21054360f, 
    0.02817046f, -0.01793128f, 0.07640443f, -0.01457879f, 0.08488094f, -0.04201548f, 0.13945018f, -0.11671025f, 
    0.08414333f, 0.05621012f, -0.04883550f, -0.00849868f, 0.00164670f, -0.04728384f, -0.12884486f, -0.06264421f, 
    -0.03049449f, -0.02852577f, -0.00994465f, -0.05680792f, -0.09008835f, 0.05423931f, -0.03298654f, -0.04205691f, 
    0.20899473f, 0.07427953f, 0.07033493f, 0.08876485f, -0.01697338f, -0.04149260f, -0.06010281f, 0.03512245f, 
    0.08808596f, -0.10004769f, -0.03404098f, -0.05895215f, 0.07172409f, 0.06147815f, -0.01088849f, 0.06037972f, 
    0.03318088f, 0.00096757f, -0.12992564f, -0.03006002f, -0.06149413f, -0.07674474f, 0.03009913f, -0.02569452f, 
    0.03294691f, -0.10451069f, 0.05268503f, -0.16362810f, 0.00121067f, -0.09442607f, 0.03304560f, -0.03386886f, 
    -0.14296204f, -0.00612779f, -0.03283133f, 0.01465580f, 0.24589163f, 0.09965141f, 0.02241431f, -0.08585127f, 
    -0.03840603f, -0.00817768f, 0.11888212f, -0.05282285f, 0.05666952f, -0.09482747f, -0.17521468f, -0.20247944f, 
    -0.07676021f, -0.02545889f, 0.10297031f, 0.01827669f, 0.05464875f, -0.01810955f, 0.10639694f, -0.05996786f, 
    0.01646769f, -0.00153795f, -0.00586592f, 0.05336896f, 0.19156650f, 0.00715764f, -0.03661659f, -0.14525364f, 
    0.37650773f, 0.09656859f, 0.06487243f, -0.21256757f, -0.08217385f, 0.00014058f, -0.00167117f, 0.02297736f, 
    -0.10740034f, 0.14141630f, -0.03635422f, 0.07600561f, -0.07324281f, -0.07384744f, -0.04461798f, -0.04222143f, 
    0.12578849f, -0.13431172f, 0.08078681f, -0.11797661f, 0.10672343f, -0.04080818f, 0.02147391f, -0.01011740f, 
    0.05505161f, -0.01441689f, 0.00544780f, -0.09004702f, -0.18303138f, 0.02788164f, 0.02964650f, 0.05856452f, 
    -0.05262583f, -0.06233656f, 0.06557821f, -0.29459569f, -0.02723620f, -0.10514206f, -0.06595763f, -0.03131950f, 
    0.01933634f, 0.02702166f, 0.00651716f, 0.07884853f, 0.09738234f, 0.04640879f, 0.21339168f, 0.10829535f, 
    -0.04645472f, -0.12542503f, -0.00899178f, -0.12002877f, 0.01956205f, -0.02348210f, 0.11786561f, -0.00342549f, 
    0.00944342f, -0.01098624f, 0.03154771f, 0.08678949f, -0.04142733f, 0.11874507f, 0.04988850f, 0.22591017f, 
    0.01256441f, -0.03319680f, 0.04536404f, 0.02588721f, 0.15051395f, -0.06891114f, -0.02632835f, -0.04983659f, 
    0.04382628f, 0.02284474f, -0.13250408f, 0.05374176f, -0.10739592f, -0.00597949f, 0.05283948f, -0.15399779f, 
    0.15208997f, -0.04808315f, -0.05214857f, -0.08404624f, -0.07911699f, -0.00668422f, -0.03096129f, -0.12203325f, 
    -0.01387856f, 0.03500366f, -0.09372780f, -0.18079595f, 0.03366073f, -0.02295179f, 0.12156421f, 0.00261514f, 
    -0.04395160f, 0.06337778f, 0.26979470f, -0.22790438f, -0.21616015f, 0.00821928f, -0.12256000f, 0.02175489f, 
    -0.03141190f, 0.00870592f, -0.03915024f, 0.35747048f, 0.15659787f, 0.05406597f, 0.03189797f, 0.00894679f, 
    -0.02457476f, 0.01923923f, 0.02123311f, 0.06782067f, -0.00185334f, 0.21026494f, -0.13430457f, 0.01651966f, 
    -0.09079121f, -0.01166353f, 0.03562256f, -0.05436978f, -0.06827329f, 0.04502892f, -0.03106125f, 0.06552442f, 
    0.06319474f, -0.02911416f, -0.01853275f, -0.05729431f, 0.03777565f, -0.03854248f, -0.05762573f, -0.21406294f, 
    -0.11978349f, -0.00665699f, -0.07954286f, 0.05037757f, -0.07009619f, 0.05664225f, 0.09191620f, 0.16757210f, 
    -0.02461631f, 0.04405157f, 0.20725836f, -0.09827588f, -0.05128424f, 0.00463694f, 0.10977851f, -0.14385155f, 
    -0.00331604f, -0.01654360f, 0.08517934f, -0.00658357f, 0.02725371f, 0.01206083f, -0.06961813f, -0.04256102f, 
    0.04552920f, -0.16322580f, 0.04676905f, -0.02328271f, 0.12861757f, -0.02564134f, 0.06154183f, -0.01278058f, 
    0.12842637f, -0.10188185f, 0.09335083f, 0.14673926f, -0.10542275f, 0.18514691f, -0.11068994f, -0.01225220f, 
    -0.11682425f, 0.00402288f, 0.04486737f, 0.13066697f, -0.10629958f, 0.08258174f, 0.00491578f, 0.08046198f, 
    0.00065164f, -0.01944535f, 0.04654147f, -0.05201558f, 0.08832507f, 0.06860472f, 0.04222510f, -0.04990240f, 
    0.06029559f, -0.02408229f, 0.07079025f, 0.12578800f, 0.16089672f, -0.06427903f, -0.01692408f, -0.00612379f, 
    -0.06259411f, 0.03534677f, -0.10446914f, -0.09356604f, 0.05325518f, -0.03953956f, -0.07817609f, 0.01757321f, 
    -0.03167317f, 0.11183142f, 0.09109109f, 0.14406762f, 0.02899125f, 0.00556798f, 0.07932080f, -0.10086951f, 
    0.05125349f, -0.03712222f, -0.02503537f, 0.01774310f, 0.06998274f, -0.01902171f, -0.07922556f, -0.03469530f, 
    0.18483207f, -0.03718351f, 0.08685556f, 0.03512926f, 0.08800892f, 0.14360207f, 0.11410272f, 0.05764453f, 
    0.03447866f, 0.07295782f, -0.00078340f, -0.08012521f, 0.12419804f, -0.18599689f, -0.00218150f, -0.06120876f, 
    0.05036069f, 0.11276954f, 0.04857460f, -0.13824068f, 0.14582784f, -0.05615054f, -0.07184919f, 0.06680340f, 
    0.00961305f, -0.03061356f, 0.02523946f, 0.06239435f, 0.03003227f, 0.07958908f, -0.00363378f, 0.01395738f, 
    -0.12428490f, 0.03221900f, 0.12603003f, -0.08117181f, -0.03695513f, -0.15825844f, -0.18607378f, 0.07443118f, 
    -0.09724348f, 0.24363658f, 0.05661722f, 0.11154444f, 0.07552465f, -0.05922885f, -0.02761054f, -0.02296470f, 
    -0.08632032f, -0.19008505f, 0.04225162f, -0.08881220f, 0.03556543f, -0.03116273f, 0.08936160f, 0.03692942f, 
    0.04732245f, 0.08019900f, -0.00616660f, -0.03890666f, 0.03723023f, -0.03545308f, -0.05138800f, 0.04922758f, 
    -0.19909769f, -0.07042487f, -0.08250787f, 0.02360319f, 0.06794932f, -0.13543741f, 0.13291244f, -0.23756965f, 
    -0.04732163f, 0.03687267f, 0.11700398f, 0.08688252f, 0.07659590f, 0.10390921f, 0.04738437f, 0.04443605f, 
    0.00920185f, -0.00978254f, -0.10857663f, -0.28287765f, 0.03567292f, 0.07421180f, 0.06486619f, 0.10718559f, 
    -0.00846675f, 0.01088272f, 0.13988699f, -0.11768641f, -0.07583016f, 0.01255765f, -0.09148451f, -0.08068610f, 
    0.01946151f, 0.03858277f, -0.03467605f, -0.02279592f, -0.03646115f, 0.10740662f, 0.05374437f, 0.04236029f, 
    -0.06694657f, 0.07414370f, 0.00333133f, -0.04225885f, 0.09428953f, -0.20045441f, -0.16001303f, 0.06738007f, 
    -0.09509173f, 0.16872106f, 0.18726167f, -0.02071569f, -0.05304182f, 0.12563284f, 0.09213658f, 0.13939351f, 
    -0.04129026f, 0.00998257f, -0.18029846f, 0.01312421f, -0.13815400f, -0.02867815f, 0.13318671f, 0.00692096f, 
    0.01635616f, 0.00592956f, -0.00072365f, -0.15190868f, 0.00029496f, 0.07455587f, 0.03570563f, -0.08088840f, 
    0.09832717f, 0.00784935f, 0.12617496f, -0.02852158f, -0.18224812f, -0.18902531f, 0.16805154f, 0.17166582f, 
    -0.24795505f, 0.00437676f, -0.10528997f, 0.04657725f, 0.12464464f, 0.04372968f, 0.02712615f, -0.00503788f, 
    0.06546577f, -0.00618595f, -0.14357413f, -0.04707203f, -0.16062361f, 0.01089663f, 0.01782941f, 0.00733572f, 
    -0.00827511f, 0.05432402f, 0.04426038f, 0.09213580f, 0.12624831f, 0.02526750f, 0.00736547f, -0.20387487f, 
    0.10838399f, 0.08021285f, -0.01642650f, 0.06466483f, -0.05298894f, 0.08236489f, 0.05781640f, 0.01410058f, 
    -0.15456112f, 0.12332860f, -0.03439542f, -0.07790458f, 0.34368929f, 0.07485035f, -0.06316614f, -0.14770438f, 
    -0.05157455f, -0.02841058f, 0.15572952f, 0.21763501f, -0.03125344f, 0.03321541f, 0.12705751f, -0.04262500f, 
    0.01816592f, 0.03067999f, -0.12638555f, 0.05592059f, 0.07720367f, -0.17059955f, 0.21742459f, -0.07087170f, 
    0.04889726f, -0.02594726f, 0.03538682f, 0.00103045f, 0.14946224f, -0.06430984f, -0.24431062f, -0.06233986f, 
    -0.00351301f, -0.17745739f, 0.07058437f, -0.01206685f, 0.13483091f, 0.18795955f, 0.04095935f, -0.03182890f, 
    0.25087395f, -0.03824838f, 0.02381773f, 0.13428056f, -0.02525318f, 0.08071163f, -0.00831594f, 0.06497452f, 
    -0.11262715f, -0.00396598f, -0.01713089f, -0.28421474f, 0.10628909f, -0.10926331f, -0.09913296f, 0.15327905f, 
    0.01627884f, 0.27157530f, 0.01401067f, -0.31586099f, -0.06775902f, 0.05728611f, 0.18180862f, 0.03585535f, 
    -0.09976823f, 0.08226963f, -0.03706869f, 0.22287053f, -0.30536428f, 0.01323562f, -0.28435564f, 0.09171734f, 
    -0.07661848f, 0.08925980f, -0.14207606f, -0.07555737f, 0.03679850f, 0.19905016f, -0.04681433f, -0.17272767f, 
    -0.24462922f, -0.07209457f, -0.03519364f, 0.13598770f, 0.08845861f, 0.08181217f, 0.05757156f, -0.14379786f, 
    0.00230250f, -0.14547907f, -0.08817440f, 0.11333676f, 0.09242514f, 0.09497663f, 0.20582627f, -0.01582323f, 
    0.08991307f, -0.22022893f, -0.20833883f, -0.01796039f, -0.06663072f, 0.00556128f, 0.16638541f, -0.00359052f, 
    -0.01660478f, 0.17790058f, -0.01520967f, 0.05403561f, 0.09182572f, 0.12434908f, 0.01035749f, 0.03753302f, 
    0.00149796f, 0.12324715f, 0.01003004f, -0.19632095f, -0.11640478f, -0.05301958f, 0.04826161f, -0.03974053f, 
    0.03486298f, 0.14872316f, -0.14546505f, -0.00639042f, 0.10092489f, -0.08087236f, 0.02117429f, -0.07207957f, 
    -0.12144446f, 0.09418583f, -0.08601417f, -0.11303730f, -0.23918298f, -0.03218357f, 0.06393075f, 0.00713738f, 
    -0.07306686f, -0.02723388f, -0.01485548f, 0.02283810f, -0.20861718f, -0.14148103f, 0.01380856f, -0.00985588f, 
    0.01628373f, 0.02274694f, 0.04350896f, 0.03519151f, 0.15072182f, -0.11903920f, -0.01538717f, -0.03929313f, 
    -0.03017324f, -0.12868148f, 0.12169077f, 0.07087404f, 0.05296367f, -0.08453119f, -0.06692684f, -0.13896184f, 
    0.08276346f, 0.12868720f, -0.03726934f, -0.01006754f, 0.04785705f, -0.01527700f, 0.14868252f, -0.04654779f, 
    0.16309962f, -0.13496016f, -0.06735347f, -0.01396956f, 0.02671042f, 0.09041144f, -0.05516867f, -0.00247368f, 
    0.04458557f, -0.05368755f, 0.05818437f, 0.00464510f, 0.09664293f, -0.07798289f, 0.01739883f, -0.07772295f, 
    0.04799372f, 0.08627471f, 0.25518554f, 0.06002480f, 0.00082792f, -0.02888438f, -0.11502670f, 0.02901964f, 
    -0.02044889f, -0.03838177f, -0.00690399f, 0.00440738f, 0.10423364f, 0.18898246f, 0.02902099f, 0.02357938f, 
    0.08121249f, -0.06526046f, -0.02452163f, -0.09908435f, -0.12616248f, 0.21433015f, 0.08181671f, -0.05130259f, 
    0.00040050f, -0.02103508f, 0.04880062f, 0.07474626f, -0.05110444f, 0.02845912f, 0.05336032f, -0.03622885f, 
    0.03100027f, 0.05767815f, -0.07203902f, 0.13177310f, -0.06837306f, 0.20963277f, 0.13865681f, -0.19476102f, 
    0.01829111f, -0.02552171f, 0.02600875f, 0.13800839f, -0.11401591f, 0.02524113f, -0.07733657f, 0.29569265f, 
    0.05637549f, -0.09902579f, -0.02432908f, -0.01138506f, -0.07025728f, 0.05934580f, 0.25750431f, -0.06293038f, 
    -0.00873253f, 0.09877040f, -0.01619221f, 0.10085240f, -0.03019550f, -0.00695688f, -0.00837656f, 0.07479206f, 
    -0.13839523f, -0.10603461f, 0.06466220f, 0.11442569f, -0.12130097f, -0.00406369f, -0.01466317f, -0.02392830f, 
    0.15853253f, -0.07022832f, 0.12525356f, -0.07318902f, -0.15429577f, 0.02259729f, -0.12445164f, -0.14303033f, 
    0.06207152f, 0.04540578f, -0.08029380f, -0.03955049f, 0.08814283f, 0.01668032f, 0.08791994f, 0.00411312f, 
    -0.05607683f, -0.01691516f, 0.31806070f, -0.05660354f, -0.05358651f, 0.02945339f, -0.15488073f, 0.13821629f, 
    -0.09009123f, 0.04820140f, 0.07096772f, 0.18375862f, 0.02997562f, -0.00445774f, 0.13592638f, 0.04844125f, 
    -0.05863660f, -0.15419097f, 0.10393386f, -0.04897401f, -0.04430973f, 0.10091649f, 0.10912426f, 0.02796452f, 
    -0.10932896f, -0.06582817f, -0.06673641f, 0.02104402f, 0.04812909f, 0.16996151f, -0.21439247f, -0.19243455f, 
    -0.10274326f, 0.13461058f, 0.05831391f, -0.10260177f, -0.03973501f, 0.11014037f, -0.18521349f, -0.15251487f, 
    0.02454049f, -0.10204295f, 0.10263650f, 0.10293723f, 0.03284337f, 0.06423564f, 0.04438909f, 0.09043572f, 
    0.20429607f, 0.06888224f, 0.05184351f, -0.15805219f, -0.12121749f, -0.04994076f, -0.02370249f, -0.09585454f, 
    -0.01205772f, -0.02932066f, -0.09217237f, -0.01893833f, -0.07049124f, -0.08991278f, 0.00039791f, -0.03773076f, 
    -0.02070845f, -0.02112162f, -0.04101357f, 0.02374785f, -0.06876259f, 0.01425620f, -0.04978063f, -0.02227788f, 
    -0.03243501f, -0.07824812f, -0.07014436f, 0.01600298f, -0.02233420f, -0.01588998f, -0.06838532f, -0.03896736f, 
    0.03660755f, -0.08133414f, 0.02307756f, -0.01441204f, 0.01157657f, -0.00536166f, 0.01676730f, 0.01877908f, 
    -0.03880472f, 0.02522063f, -0.03310543f, -0.02973342f, 0.03670164f, -0.08429125f, -0.03114001f, -0.02738414f, 
    -0.06144350f, -0.01342385f, -0.06427133f, -0.01020430f, -0.01871292f, -0.04894588f, -0.04685061f, -0.04401794f, 
    0.00155435f, 0.00115307f, 0.01962106f, -0.03806124f, -0.00460863f, -0.09095559f, 0.00344577f, -0.02829889f, 
    -0.01966373f, -0.05387589f, -0.08652435f, -0.06525781f, -0.06127071f, -0.01228545f, -0.00721087f, -0.04572123f, 
    -0.01462149f, -0.03039887f, -0.07025424f, -0.04228739f, 0.01052719f, -0.02483382f, -0.01038838f, -0.01013855f, 
    -0.00149356f, -0.00921875f, 0.00669361f, -0.08219713f, 0.01483490f, -0.01248243f, 0.01904133f, -0.02364182f, 
    -0.03902364f, -0.00683389f, -0.05658162f, -0.05776745f, -0.05641083f, -0.07452872f, -0.04061423f, -0.08958906f, 
    -0.01012124f, -0.02975056f, -0.04398006f, -0.00578535f, 0.00983762f, -0.07700504f, -0.01043618f, -0.01626325f, 
    -0.02244048f, -0.03458846f, -0.07024145f, -0.03174149f, 0.00306313f, -0.00331213f, 0.01036197f, -0.08986066f, 
    0.01882458f, 0.01830338f, -0.01748621f, -0.02919073f, 0.00455706f, -0.01231747f, -0.06557389f, -0.05496391f, 
    -0.07096397f, -0.01275649f, 0.01052518f, -0.05185949f, -0.01468268f, 0.01026009f, -0.01494229f, 0.02121155f, 
    -0.05010137f, -0.06175859f, 0.00682458f, -0.05927752f, -0.03255964f, -0.03075466f, -0.00292208f, -0.03267039f, 
    -0.05486438f, -0.03382083f, 0.00762932f, 0.02263466f, 0.02912706f, -0.07653113f, 0.05332845f, -0.05218985f, 
    0.02975939f, -0.01908858f, -0.02265803f, -0.03073433f, -0.03103690f, 0.00980534f, -0.04114308f, -0.05433788f, 
    -0.04194243f, 0.01564038f, -0.07488754f, -0.04689264f, -0.01064410f, -0.08358459f, -0.01809748f, 0.03741491f, 
    0.01442317f, -0.07879702f, -0.04402771f, -0.07996204f, -0.00877091f, -0.00672414f, -0.05265083f, -0.06676185f, 
    -0.03582164f, -0.08709279f, -0.04945082f, -0.02895682f, -0.02668491f, -0.01089390f, -0.02230339f, -0.06935065f, 
    -0.09157379f, -0.04292351f, 0.02087099f, -0.07987760f, 0.02084581f, -0.05595708f, 0.01928817f, -0.01703389f, 
    -0.03776316f, -0.07481042f, -0.04662768f, 0.01227996f, 0.01225476f, -0.03578337f, -0.03967411f, -0.04877641f, 
    0.02503683f, -0.01364822f, -0.02423268f, -0.03593425f, -0.05501804f, -0.01075252f, 0.00741451f, -0.07653130f, 
    -0.07530016f, -0.02892922f, 0.01658533f, -0.04292391f, -0.04150310f, 0.03559046f, -0.08499654f, 0.02679890f, 
    0.00971690f, -0.00898025f, -0.07606763f, -0.00703182f, -0.07682085f, -0.01658537f, -0.08155546f, -0.08211695f, 
    -0.01366797f, 0.01390762f, -0.03037754f, 0.03012661f, -0.08640977f, -0.06360547f, -0.08377811f, 0.02302009f, 
    -0.00915517f, -0.02706020f, -0.08142057f, -0.06765108f, -0.02611097f, -0.05417643f, -0.01554258f, 0.02173345f, 
    -0.05802607f, -0.02495800f, -0.06268803f, -0.08998887f, -0.05277844f, -0.03948042f, -0.09283628f, -0.04288127f, 
    -0.05099352f, 0.02145900f, -0.04311575f, -0.00782742f, -0.03661618f, -0.06368240f, -0.09071372f, 0.02155844f, 
    -0.01633164f, -0.03409897f, 0.03229096f, 0.01553173f, -0.05334843f, -0.06004785f, 0.01576144f, -0.03246323f, 
    -0.02426533f, -0.02190423f, -0.08156641f, -0.07174470f, -0.00587643f, 0.02113222f, 0.02743303f, -0.08373653f, 
    0.00698545f, -0.04763211f, 0.01936520f, 0.00931505f, -0.04152580f, -0.06870243f, -0.05878364f, -0.03918946f, 
    -0.04079549f, 0.02053836f, 0.00034254f, 0.01374073f, -0.05159052f, -0.03623220f, 0.00245854f, -0.03903220f, 
    0.00491434f, 0.01043495f, -0.03098419f, -0.01669823f, -0.07542906f, -0.07960685f, -0.02958334f, -0.02384450f, 
    -0.04622437f, -0.06175268f, 0.01452497f, -0.05497180f, -0.02711583f, -0.02485048f, -0.07380056f, -0.05196676f, 
    -0.05032662f, -0.01194088f, -0.04711741f, -0.04056105f, -0.04034670f, -0.06643078f, -0.02667230f, 0.02049368f, 
    -0.02007404f, 0.02107359f, 0.03229124f, -0.00954622f, -0.05628076f, -0.02686120f, -0.06047428f, -0.03632733f, 
    -0.02618338f, 0.05133666f, 0.03591233f, -0.03835976f, 0.04478942f, 0.05606877f, -0.05181164f, -0.01706010f, 
    0.04551971f, -0.03710162f, -0.04395128f, -0.01802575f, -0.00887818f, -0.00639394f, -0.02642044f, -0.03262483f, 
    -0.03952557f, 0.01327695f, -0.03748031f, -0.01427767f, 0.04374370f, 0.01450971f, -0.01575998f, -0.00530216f, 
    -0.04380107f, 0.03721141f, -0.01694743f, -0.05968916f, 0.04794681f, -0.03260439f, -0.01935551f, 0.02583196f, 
    0.01243271f, -0.01833088f, -0.02433407f, 0.03195303f, -0.04942254f, -0.04426530f, 0.04196828f, -0.03257203f, 
    -0.02521408f, -0.04593129f, 0.01016148f, -0.03525978f, -0.07223934f, 0.01976080f, 0.04409007f, 0.02913304f, 
    -0.02711778f, 0.04272535f, 0.03611115f, 0.00665745f, -0.05359618f, -0.01825402f, -0.01897464f, -0.05801815f, 
    0.02267499f, 0.03315234f, 0.00958436f, 0.03500659f, -0.01071777f, 0.01312178f, 0.04369727f, -0.05807308f, 
    0.00819765f, -0.06363744f, -0.02775191f, -0.03160812f, 0.03777777f, -0.03527672f, -0.05086624f, -0.05770256f, 
    -0.04129956f, 0.00530072f, 0.04434737f, -0.06092567f, -0.01046961f, 0.03829667f, 0.04631915f, -0.00046053f, 
    0.01904954f, 0.02230826f, -0.01030449f, -0.02204808f, -0.07157630f, -0.02445108f, 0.04183065f, 0.05042421f, 
    -0.05765685f, -0.00670050f, -0.02981594f, 0.01201365f, -0.01176307f, 0.01918281f, -0.03494820f, -0.00467464f, 
    0.02250190f, 0.03406820f, -0.02359264f, 0.03535858f, -0.04983945f, 0.04073716f, 0.03646316f, -0.04830787f, 
    0.01863009f, -0.04775895f, -0.00864007f, -0.01946296f, 0.04347287f, 0.03948776f, -0.01430571f, -0.00201624f, 
    0.04083840f, -0.00385878f, -0.00130736f, 0.02517843f, -0.02046238f, -0.01996029f, -0.03601138f, -0.03920484f, 
    0.00092741f, 0.02396143f, 0.03986907f, 0.04605792f, -0.03327940f, -0.04407580f, -0.01129450f, 0.03948850f, 
    0.01293208f, -0.02581567f, 0.01762231f, 0.01101083f, 0.00757273f, -0.00448081f, -0.05655160f, 0.04210130f, 
    0.04989600f, -0.03605322f, -0.05319196f, -0.07089346f, -0.06158079f, 0.02099025f, -0.00684442f, 0.01099171f, 
    0.02776901f, -0.04666363f, -0.05412911f, 0.00512029f, -0.01557049f, -0.01535853f, -0.03255915f, -0.00058190f, 
    0.01811850f, 0.00788462f, -0.05506832f, -0.03880113f, -0.00969060f, 0.00058131f, -0.01041185f, -0.04912672f, 
    0.04416426f, 0.04515729f, -0.06454767f, 0.01357758f, 0.04059131f, -0.02355242f, -0.04612016f, 0.02948388f, 
    -0.06162386f, 0.03355969f, 0.03962605f, -0.04858906f, 0.02199336f, 0.00870967f, 0.01902121f, -0.00407126f, 
    -0.00311660f, -0.00031903f, 0.00343617f, 0.00487893f, -0.05399468f, 0.00635603f, -0.06041890f, -0.02965714f, 
    0.01637325f, 0.03901635f, -0.02793247f, 0.00369593f, 0.03379677f, -0.02400966f, -0.05441118f, 0.01167770f, 
    -0.05401241f, -0.05509271f, -0.01741481f, -0.05316871f, 0.03837662f, 0.01532061f, -0.04321459f, 0.03843907f, 
    -0.00208637f, -0.04142052f, -0.01903154f, -0.00416879f, 0.00073195f, 0.00982249f, -0.05001983f, -0.01835789f, 
    -0.02747997f, -0.03766732f, 0.04140433f, 0.00903197f, 0.04877354f, -0.02805228f, -0.03494107f, 0.04720742f, 
    0.01912062f, -0.04836445f, -0.07059474f, -0.05577979f, -0.06076837f, 0.02147973f, 0.03336054f, 0.00637634f, 
    0.03221970f, -0.04036492f, 0.04149320f, -0.03935686f, -0.04708273f, 0.00481646f, -0.06390740f, -0.01454352f, 
    -0.05472274f, -0.04198975f, -0.05030131f, -0.02167028f, -0.00962442f, -0.04340065f, 0.01820458f, -0.05958461f, 
    0.04622236f, -0.05067668f, 0.04356860f, 0.02688608f, -0.03547794f, -0.03389556f, 0.03193104f, -0.00980793f, 
    -0.04528674f, -0.00864654f, 0.05163691f, 0.04579897f, 0.00602854f, -0.02531306f, -0.04090756f, -0.05049863f, 
    -0.05641542f, 0.05153410f, -0.06220878f, -0.07058672f, -0.00632192f, 0.01755505f, -0.00986190f, -0.02953855f, 
    -0.01676775f, -0.01471054f, -0.03709319f, 0.00734641f, 0.03849934f, 0.03491594f, -0.06188344f, 0.01455980f, 
    -0.17429067f, -0.35241795f, 0.15599257f, 0.11913019f, 0.04381211f, 0.08009631f, -0.17481798f, -0.09263451f, 
    0.02347722f, -0.07162580f, -0.00592289f, -0.12150412f, -0.06952964f, -0.06743186f, -0.10742255f, 0.03781255f, 
    -0.03109138f, 0.20524275f, -0.03599364f, -0.01481463f, 0.01459641f, -0.00288535f, -0.14666486f, -0.07197274f, 
    0.02012640f, 0.00512026f, 0.07708339f, 0.10995656f, -0.03765333f, -0.18196976f, 0.06153177f, 0.05009633f, 
    -0.08815208f, -0.02168610f, 0.05346541f, -0.17196830f, -0.00576846f, 0.19946401f, -0.04741246f, 0.11191409f, 
    0.06464788f, 0.00301514f, 0.04327479f, -0.02164198f, 0.11656386f, -0.03331539f, 0.13368118f, 0.05257266f, 
    -0.10382333f, 0.03563083f, -0.13268784f, 0.00813247f, 0.01522874f, 0.06422268f, 0.16260500f, 0.24214369f, 
    0.00900034f, -0.01390031f, 0.05205235f, 0.25209752f, 0.02043382f, 0.11975454f, -0.06257845f, -0.10930128f, 
    0.09517270f, 0.09363265f, -0.08291406f, -0.02165586f, 0.06734439f, 0.15959063f, 0.00033428f, 0.13671573f, 
    -0.14905435f, -0.04180528f, 0.12559061f, 0.04430105f, 0.03692468f, 0.04473141f, -0.08165794f, 0.02424704f, 
    -0.01232246f, -0.09867825f, -0.01674440f, -0.10198182f, 0.00774849f, -0.09451047f, -0.02795364f, -0.02001723f, 
    0.12561366f, -0.17668802f, 0.35506868f, 0.05625731f, -0.12686618f, -0.30384973f, -0.01628587f, 0.10778909f, 
    -0.12118018f, 0.07330028f, -0.15734780f, -0.05619843f, -0.34333342f, -0.06639820f, 0.08978239f, -0.03809657f, 
    0.03139777f, 0.10327327f, 0.13278461f, -0.06945405f, -0.13911344f, 0.07546421f, -0.10238546f, 0.02413181f, 
    0.01184367f, 0.10958588f, -0.03139101f, 0.07085268f, -0.03853538f, -0.03678801f, 0.16932233f, 0.04601591f, 
    -0.03151505f, -0.04562349f, -0.02192952f, 0.05176041f, -0.00092648f, 0.07100593f, 0.03087486f, 0.15027454f, 
    0.08980102f, 0.00987265f, 0.16180295f, 0.10901658f, -0.11364664f, 0.08221515f, 0.05686197f, -0.18696228f, 
    0.06599525f, -0.17278799f, -0.15709788f, 0.12282268f, -0.01396057f, 0.09823289f, -0.20215537f, 0.10407886f, 
    -0.11175175f, -0.14986096f, 0.08546787f, 0.08789335f, -0.02406661f, -0.11215136f, 0.02547177f, -0.20921253f, 
    -0.12934874f, -0.09204980f, -0.11386837f, -0.02843583f, 0.08542356f, 0.11729504f, 0.06356282f, 0.07055932f, 
    0.11227077f, -0.09468535f, 0.09569944f, 0.01028666f, 0.05585788f, 0.10821772f, -0.05186408f, -0.11442526f, 
    0.13294114f, -0.02103343f, 0.05923255f, 0.06578845f, 0.04270525f, 0.09970696f, -0.03993284f, -0.00636391f, 
    -0.09703723f, -0.09437642f, -0.11233439f, -0.06049224f, -0.00403365f, -0.07272155f, 0.01890122f, 0.04122034f, 
    0.15924297f, -0.02505229f, 0.02929648f, -0.07536790f, -0.03446443f, -0.11528561f, -0.17788978f, 0.19090699f, 
    -0.14797129f, -0.08967587f, 0.04504511f, 0.10837191f, -0.05846448f, 0.19556281f, -0.23869459f, -0.16705044f, 
    0.07909421f, 0.03225059f, 0.00883096f, -0.07333387f, -0.04959644f, -0.04214812f, -0.05660683f, -0.52534389f, 
    -0.29176787f, -0.05104716f, 0.05633206f, -0.14562704f, 0.13644147f, -0.00911060f, 0.00178064f, 0.19331877f, 
    -0.05699275f, 0.10552461f, -0.01852765f, -0.06528860f, 0.05504536f, 0.11890853f, 0.07535576f, 0.09198332f, 
    -0.19890513f, -0.08869368f, -0.01157182f, -0.09317315f, -0.02675621f, 0.00168733f, -0.07559109f, 0.22038327f, 
    0.14996848f, -0.03333361f, 0.27493730f, 0.19814648f, 0.02647049f, -0.09685325f, -0.02647139f, 0.05937752f, 
    0.16372144f, -0.05583169f, 0.04558398f, 0.00075928f, 0.02220332f, 0.03947566f, 0.03413492f, 0.05302274f, 
    0.00921341f, -0.09098727f, 0.17470792f, -0.00714158f, 0.02706316f, -0.08622577f, 0.06515974f, -0.08946314f, 
    0.04762539f, 0.06871070f, 0.00631094f, 0.14633135f, 0.13323408f, 0.03029356f, -0.07109200f, -0.06819435f, 
    -0.10012750f, -0.04273330f, -0.02942502f, -0.00472899f, -0.07609354f, 0.12103847f, 0.08177211f, -0.02845140f, 
    -0.01779643f, -0.01200598f, 0.20649484f, -0.12262682f, 0.00457901f, 0.08204920f, -0.01827909f, -0.04669086f, 
    0.02142389f, -0.16712615f, 0.09568413f, -0.05097804f, 0.30974963f, 0.06999800f, -0.00270013f, -0.11171064f, 
    0.06309138f, -0.03900466f, 0.04937320f, -0.06033675f, 0.04207299f, -0.03948873f, 0.02288041f, -0.02040088f, 
    -0.01015802f, -0.06602540f, -0.02167761f, 0.02721608f, -0.05831284f, 0.03169865f, 0.02896846f, -0.03551062f, 
    0.01776539f, -0.02660388f, 0.00035908f, -0.01793082f, -0.02685700f, -0.05903389f, 0.02494116f, -0.01315078f, 
    -0.01749022f, -0.01816821f, -0.04045028f, -0.00160269f, -0.01949790f, 0.01215480f, -0.00237798f, -0.00846574f, 
    -0.02598443f, -0.06082886f, 0.01526956f, -0.02841004f, 0.02981509f, 0.02641757f, 0.00631180f, 0.00729013f, 
    -0.00517977f, 0.02569005f, -0.02992149f, -0.05479033f, -0.01469379f, 0.00083096f, 0.02352177f, 0.03955810f, 
    -0.00367480f, 0.03852084f, 0.02113524f, -0.00335268f, 0.01529715f, -0.00805035f, -0.05099413f, 0.04255948f, 
    -0.02464035f, -0.02634616f, -0.05602390f, 0.00784503f, 0.04808320f, -0.02587131f, -0.03576715f, -0.01069195f, 
    -0.02590058f, -0.02493583f, -0.01017681f, -0.00388416f, -0.03522898f, -0.05678610f, 0.00272912f, -0.03190345f, 
    -0.03688940f, 0.00236658f, 0.03041430f, -0.02375560f, -0.03340536f, -0.05358983f, 0.03944441f, -0.00366121f, 
    0.00023607f, -0.01794071f, -0.00198165f, -0.02426584f, -0.02101201f, -0.02240788f, -0.06496863f, -0.05152224f, 
    0.04060178f, -0.01602512f, -0.03214901f, -0.04479679f, -0.02784802f, -0.04763641f, -0.06239919f, 0.04641508f, 
    0.02270761f, 0.01208934f, 0.01559367f, 0.03456432f, 0.03797591f, -0.01915592f, 0.01910211f, 0.02728184f, 
    0.01058205f, 0.04332663f, -0.00753756f, 0.04505906f, -0.05669013f, -0.05518375f, 0.03817567f, 0.03202540f, 
    -0.01626804f, -0.06339297f, -0.03347688f, -0.03968337f, -0.01193462f, 0.03799358f, -0.00372919f, 0.01113069f, 
    0.00961004f, -0.05166483f, -0.00189115f, -0.05604037f, 0.05440592f, 0.02044685f, 0.00234763f, -0.04795520f, 
    0.05012281f, 0.01433105f, 0.03829397f, 0.04909546f, -0.06630369f, 0.02993089f, -0.04179142f, 0.01936237f, 
    0.02469429f, -0.00960216f, -0.05138165f, 0.01305821f, 0.03750150f, -0.03964074f, 0.03646785f, 0.00158942f, 
    -0.01131560f, 0.05766524f, -0.06122591f, 0.00989489f, 0.03106413f, 0.01038392f, -0.05404538f, -0.00473045f, 
    0.03731856f, 0.03449587f, -0.01264086f, -0.02507520f, 0.02267204f, 0.00466893f, -0.03121685f, 0.05320916f, 
    -0.05677230f, 0.01755109f, -0.04242166f, -0.04293755f, -0.05770215f, 0.04163668f, -0.04453177f, 0.02987728f, 
    -0.00043912f, -0.05043560f, -0.00829746f, -0.00845147f, -0.04371165f, -0.05902402f, 0.02803090f, 0.02763141f, 
    0.03974540f, 0.00607398f, -0.05448065f, 0.02863227f, 0.01708171f, 0.00140813f, 0.03089512f, -0.03505858f, 
    0.03381436f, -0.01067162f, -0.04839134f, -0.00355103f, -0.01068280f, 0.03312349f, 0.02819073f, 0.04798901f, 
    -0.05709147f, -0.06436343f, 0.04624361f, 0.03885556f, -0.05599180f, 0.03567688f, -0.01985442f, -0.04744095f, 
    0.03603171f, -0.06678846f, -0.03230176f, 0.03582684f, 0.03005543f, -0.04321840f, -0.03028372f, -0.05338071f, 
    -0.02597351f, 0.03876621f, -0.02258860f, -0.04085131f, 0.04627271f, 0.02981348f, -0.01314143f, 0.03757550f, 
    -0.04978579f, 0.04402393f, -0.04235761f, 0.03050866f, -0.01896340f, -0.03963380f, -0.05212764f, -0.00125182f, 
    -0.00087542f, -0.01854020f, -0.02612446f, -0.02680258f, 0.01635492f, 0.00328959f, -0.03814746f, 0.00727781f, 
    0.02909806f, -0.05681630f, 0.03463025f, -0.01979987f, -0.04091911f, -0.02203554f, -0.00040138f, -0.05987315f, 
    0.01752343f, 0.01918225f, -0.05312901f, -0.01192799f, -0.04599698f, 0.01352126f, -0.05465556f, -0.06097298f, 
    -0.00101758f, -0.00809720f, -0.04324460f, -0.05739420f, 0.04208163f, -0.03175191f, 0.04444247f, 0.01942643f, 
    0.02994246f, 0.01281987f, 0.04032276f, -0.00100061f, 0.01379207f, 0.02229766f, -0.06749378f, 0.03743536f, 
    0.02288901f, 0.02616858f, -0.03306303f, 0.04095941f, -0.04188235f, 0.06558353f, -0.01044363f, 0.00088019f, 
    0.03297462f, -0.06357381f, 0.02695900f, 0.02179344f, 0.03826238f, 0.04281651f, -0.02393715f, 0.05089557f, 
    0.04340063f, -0.02426385f, -0.03387025f, -0.02979702f, 0.02497922f, -0.01388662f, -0.02390870f, 0.03198909f, 
    -0.03914359f, -0.03892298f, 0.03730272f, 0.03096550f, 0.03378202f, 0.04029594f, -0.00633917f, -0.02075692f, 
    -0.06857678f, 0.00129249f, 0.01613050f, 0.04325922f, 0.03227543f, 0.02657738f, -0.03289598f, 0.05188397f, 
    -0.01986136f, 0.03845417f, 0.03614537f, 0.02473838f, -0.05005224f, -0.04224891f, -0.02075951f, -0.01016982f, 
    -0.04741667f, 0.05205723f, -0.04338834f, 0.03537359f, -0.04484975f, 0.02204548f, -0.04173898f, -0.02823554f, 
    0.02832599f, -0.00477411f, -0.02471469f, 0.04998026f, 0.01594691f, 0.02694977f, 0.01506992f, 0.01575414f, 
    0.01697393f, 0.03088457f, 0.04530727f, -0.03631222f, -0.06167702f, 0.03462585f, -0.01055815f, -0.02131928f, 
    -0.03815641f, -0.00077707f, -0.05014205f, -0.03275081f, -0.04470146f, 0.04070428f, -0.00948637f, 0.00264048f, 
    -0.05158566f, -0.04921129f, 0.01331932f, -0.03383094f, -0.04977018f, -0.03994254f, -0.02483668f, -0.00642655f, 
    0.00754626f, -0.03077942f, -0.00572586f, -0.03090192f, 0.03842584f, 0.00249072f, 0.04590354f, -0.04594529f, 
    0.01010515f, -0.04380964f, -0.01010050f, -0.05832735f, -0.01188642f, -0.04284910f, 0.01300001f, -0.04978991f, 
    -0.04637397f, -0.04053808f, -0.01121408f, -0.05063028f, 0.00474016f, -0.04457065f, -0.06834789f, -0.04712222f, 
    0.01606147f, 0.04392784f, -0.03270404f, 0.01406274f, -0.04783516f, -0.01551335f, 0.01346370f, 0.04983421f, 
    -0.00886444f, -0.05949823f, 0.01778498f, 0.00974284f, 0.00344384f, -0.00221132f, -0.03735947f, -0.00121328f, 
    -0.02459248f, 0.00631000f, 0.04238699f, 0.00134671f, 0.02934643f, 0.02517911f, -0.01802769f, 0.03928612f, 
    0.05365340f, -0.01362611f, -0.03852409f, -0.02620997f, -0.02854454f, -0.00134926f, -0.04138388f, -0.04262586f, 
    0.05552590f, -0.03825424f, -0.06216273f, -0.00704720f, 0.04785839f, 0.01333178f, -0.05130008f, 0.01889307f, 
    0.02631958f, -0.06072776f, -0.02079160f, 0.01011475f, 0.04845857f, -0.02862364f, -0.04940145f, 0.00285562f, 
    -0.02663528f, -0.03566509f, 0.00408190f, -0.02120586f, -0.02247603f, -0.02026643f, -0.01936688f, -0.04910406f, 
    -0.05663950f, 0.02103734f, 0.02453892f, 0.04296935f, -0.03848403f, -0.04867066f, -0.05856417f, -0.03451250f, 
    -0.02741464f, -0.03421270f, -0.03538408f, 0.04064454f, -0.04395809f, 0.05168700f, 0.04039483f, 0.02546299f, 
    0.02919482f, 0.03891688f, -0.00394522f, 0.01376011f, 0.01148004f, 0.00190916f, 0.01908464f, -0.07040983f, 
    -0.03670590f, -0.01926360f, -0.04663819f, 0.02253995f, 0.01662336f, 0.00071189f, -0.04334071f, -0.03434869f, 
    -0.04130078f, -0.01386956f, 0.00092154f, 0.02415822f, -0.06681289f, -0.00978729f, -0.02421112f, 0.00065594f, 
    -0.06283402f, 0.00220891f, 0.04176827f, 0.00227468f, 0.01220609f, -0.02548542f, -0.00775956f, 0.00265931f, 
    0.05050343f, 0.02332034f, 0.01940196f, 0.04352168f, 0.04694803f, -0.01444854f, 0.05678598f, 0.02573483f, 
    -0.04813525f, 0.02961905f, -0.03122054f, 0.00447531f, -0.02493811f, 0.01152730f, 0.01278014f, 0.02237715f, 
    -0.00910636f, -0.05913462f, 0.05618886f, -0.03477019f, 0.03050875f, 0.01723145f, 0.00639867f, -0.05140581f, 
    0.03763047f, -0.01427363f, -0.01757773f, -0.04924856f, 0.04782986f, -0.02769608f, -0.04777457f, 0.03656840f, 
    -0.01238658f, 0.05751770f, 0.04408307f, -0.00292437f, 0.00667940f, -0.05126922f, 0.03828374f, 0.00273886f, 
    -0.03073136f, -0.01429346f, -0.01104880f, -0.02017165f, -0.01503986f, -0.05940538f, 0.05683057f, -0.06055412f, 
    -0.02572372f, 0.00238854f, -0.05282910f, -0.04830146f, -0.03479808f, 0.00402675f, -0.02711944f, 0.04768279f, 
    0.03833994f, 0.01764433f, 0.05030559f, -0.02064550f, -0.02485542f, 0.04084199f, -0.05785302f, 0.01885094f, 
    0.05245031f, -0.01408869f, -0.04607406f, 0.03314358f, -0.02376672f, 0.06004290f, 0.03637974f, 0.01284934f, 
    -0.04496975f, 0.02591290f, -0.05892783f, -0.06198023f, 0.03554412f, -0.04932356f, -0.01859619f, -0.02093131f, 
    -0.03177657f, -0.02056841f, -0.05278384f, 0.04902431f, -0.00705273f, -0.02670570f, 0.03732399f, 0.05043698f, 
    0.01736833f, -0.04967436f, 0.04851627f, -0.04061241f, -0.05244408f, -0.01284202f, 0.01559074f, -0.02131015f, 
    0.13044840f, -0.25522542f, -0.25827482f, 0.10085770f, -0.04058665f, 0.09916306f, -0.05656484f, -0.02244727f, 
    -0.00422388f, -0.02129429f, -0.15244885f, -0.09145756f, 0.09303119f, 0.10046469f, 0.04826600f, -0.16052341f, 
    0.00758551f, 0.15639642f, -0.22572435f, -0.15450193f, 0.00989557f, -0.02723362f, 0.18165931f, -0.00504457f, 
    0.00700415f, -0.00256182f, -0.06105901f, -0.08966582f, -0.23199627f, -0.00774727f, -0.22704364f, -0.05720763f, 
    -0.01568471f, -0.02224854f, -0.02257502f, -0.05478936f, -0.03686218f, 0.04185000f, 0.14587548f, -0.09177702f, 
    -0.00339273f, 0.02929510f, -0.04600782f, 0.01273978f, 0.04858483f, 0.07444856f, 0.06057078f, 0.09212191f, 
    0.02632709f, -0.03419432f, 0.03522458f, 0.00141381f, 0.02158444f, 0.12317667f, -0.05027460f, 0.05633966f, 
    0.05775505f, 0.15794779f, 0.12960240f, 0.05046973f, 0.06495633f, 0.02610711f, 0.05949138f, 0.14102601f, 
    0.01948571f, -0.08283172f, 0.04400767f, 0.05274862f, -0.08649729f, 0.14780845f, 0.25953460f, 0.18258798f, 
    -0.06407128f, 0.15487376f, 0.19281629f, -0.13557991f, -0.03449558f, 0.12418513f, -0.02686232f, -0.09071919f, 
    -0.05181221f, -0.13763313f, -0.19767506f, -0.18718611f, -0.12757011f, 0.14056483f, -0.04613392f, -0.04062214f, 
    -0.23873478f, -0.04004880f, -0.12131907f, -0.08422926f, 0.02438776f, 0.16417405f, 0.10025993f, -0.12002473f, 
    -0.02183278f, 0.00125126f, -0.06128868f, -0.00244881f, -0.12682408f, -0.06875175f, -0.03247479f, -0.00982086f, 
    0.11103874f, -0.02685961f, 0.05832547f, 0.06014394f, 0.03423139f, 0.05601565f, -0.05123157f, -0.11111218f, 
    0.01807601f, -0.08215497f, 0.03345418f, 0.16224176f, 0.07764800f, 0.09425909f, -0.23802142f, -0.16589396f, 
    -0.02055095f, 0.09839287f, -0.07793007f, 0.11422304f, 0.11994186f, 0.00940494f, -0.12704256f, -0.07161351f, 
    0.08837060f, 0.13988966f, -0.14242847f, 0.01682009f, -0.03715319f, -0.00250590f, 0.02495250f, -0.20379438f, 
    -0.42389795f, -0.31888932f, -0.03028432f, -0.05881340f, -0.10467901f, -0.11018849f, -0.20426485f, 0.07610727f, 
    -0.16557005f, -0.16797511f, -0.17210835f, 0.03530782f, 0.00707407f, -0.04168964f, 0.09351817f, -0.05535404f, 
    -0.07080574f, -0.03412937f, 0.05661236f, -0.12210686f, 0.09395867f, -0.02126555f, 0.01289042f, 0.08098106f, 
    0.06087391f, 0.06005493f, -0.02976906f, 0.01747795f, -0.01670504f, -0.07948209f, 0.13816395f, 0.00710603f, 
    -0.00973545f, 0.04852126f, 0.09069256f, -0.11308545f, -0.27048883f, -0.04824744f, 0.09070627f, 0.12094530f, 
    -0.05023389f, -0.06432457f, -0.08006436f, 0.05468404f, -0.00708572f, 0.16670698f, 0.00104949f, -0.12420388f, 
    -0.02217434f, 0.07111093f, -0.10229977f, 0.07420507f, -0.10124664f, 0.01199735f, -0.03812416f, -0.02975348f, 
    -0.02711221f, 0.01127863f, 0.01904693f, 0.00748652f, 0.07464302f, -0.05474901f, 0.03480689f, -0.15916543f, 
    -0.35491556f, 0.01915950f, 0.00650693f, 0.05695635f, 0.06118208f, -0.12293613f, 0.04376595f, 0.12935436f, 
    -0.14062871f, -0.24204174f, 0.01820513f, 0.06753114f, -0.06439798f, -0.01662898f, -0.05756198f, -0.13242802f, 
    -0.21624136f, -0.01533158f, -0.10984898f, -0.06505258f, -0.11768096f, -0.05354684f, -0.01502476f, -0.03333509f, 
    0.09498018f, -0.04164372f, 0.02228956f, -0.13465585f, 0.09132053f, 0.04739058f, 0.04557130f, -0.01214353f, 
    -0.03160212f, 0.18973753f, -0.08092925f, -0.07105280f, 0.11116384f, 0.02275101f, -0.02610063f, 0.04332256f, 
    -0.00822200f, -0.02290964f, -0.00668923f, -0.45641059f, -0.18698527f, -0.07545963f, 0.13923305f, 0.07630745f, 
    0.03446000f, 0.10921538f, -0.00204220f, 0.01599758f, -0.05496971f, 0.01410758f, 0.30323428f, -0.03614436f, 
    -0.05115017f, -0.08056362f, 0.07402252f, 0.20112525f, 0.00151477f, -0.15589395f, -0.12359028f, 0.07242312f, 
    0.02929806f, 0.02408595f, -0.03695600f, 0.03998561f, 0.22144982f, -0.06752206f, -0.12688988f, 0.04055189f, 
    0.02490141f, 0.02096916f, -0.04066350f, -0.04835917f, 0.17639565f, -0.03341297f, 0.08601466f, 0.08958944f, 
    0.10325195f, 0.13711169f, -0.01756900f, -0.06314578f, -0.07745291f, 0.14288615f, 0.06708160f, 0.04736981f, 
    -0.05228664f, -0.01299181f, 0.02648361f, 0.04128585f, 0.05093851f, 0.00546666f, -0.03506996f, -0.02857136f, 
    0.04781320f, -0.04443726f, -0.03539921f, 0.00392318f, -0.02569530f, -0.01581979f, -0.02299319f, 0.02417639f, 
    -0.02649197f, -0.01525910f, 0.03475812f, 0.01985953f, 0.00014532f, -0.03562718f, 0.04203579f, 0.04178144f, 
    -0.00020815f, -0.03435694f, -0.03778230f, 0.05068101f, 0.03343966f, 0.01354066f, 0.04601733f, -0.01265064f, 
    0.02748143f, 0.02475280f, -0.02913578f, -0.02761218f, 0.03820578f, -0.04314086f, -0.05469206f, -0.05482471f, 
    0.02431564f, -0.05079070f, 0.02197236f, -0.00203059f, -0.05504611f, 0.00685929f, -0.05508755f, -0.01323210f, 
    0.02575388f, -0.03298251f, -0.05997891f, -0.01370266f, 0.03733838f, -0.06120706f, -0.03008300f, 0.01619458f, 
    0.00911453f, -0.00894482f, 0.01436623f, 0.03687798f, -0.03733717f, -0.03173950f, -0.04309120f, -0.04872051f, 
    -0.05431878f, 0.02179200f, 0.02051016f, 0.04624442f, -0.05842011f, -0.02442333f, -0.04824705f, -0.04810467f, 
    -0.04291626f, -0.03146053f, -0.00380627f, -0.05845436f, 0.03587919f, 0.02879667f, 0.01649818f, 0.05089065f, 
    -0.05057183f, -0.05434630f, 0.04430385f, 0.02858935f, 0.05259802f, -0.01452248f, 0.01341125f, 0.02499972f, 
    0.03023352f, -0.04518897f, 0.00475037f, -0.00812413f, -0.05814414f, -0.01080756f, -0.03651134f, 0.01535261f, 
    -0.04937546f, -0.03640809f, 0.04640251f, -0.03784570f, -0.01972317f, 0.04399853f, -0.02946186f, -0.00932759f, 
    -0.03663765f, 0.01314452f, -0.01488604f, 0.04574649f, -0.05977442f, -0.02054311f, -0.03200235f, -0.04407814f, 
    0.05034125f, -0.02391984f, -0.05443674f, -0.05029805f, 0.03435877f, 0.03205588f, 0.01210322f, -0.03153269f, 
    -0.00112514f, 0.04445532f, -0.03075488f, -0.04821162f, 0.00381462f, 0.03401902f, 0.05403410f, -0.00649325f, 
    -0.05797824f, -0.03125338f, -0.03655605f, 0.01205465f, -0.01459354f, -0.05721458f, -0.05993589f, -0.05890302f, 
    0.02021934f, -0.04703052f, 0.03172398f, 0.00704141f, 0.04683173f, -0.01006961f, 0.05451703f, 0.04041538f, 
    0.01609110f, -0.03519753f, -0.06203305f, 0.02839314f, 0.01619328f, 0.00946775f, 0.01891874f, -0.03624049f, 
    -0.02754022f, 0.01607809f, 0.03422204f, -0.03561749f, -0.03018131f, -0.03934933f, -0.01250133f, -0.04315238f, 
    0.00952056f, -0.00078549f, -0.05907439f, -0.02108001f, -0.03142509f, -0.03898849f, 0.00393041f, -0.03370889f, 
    0.03083718f, 0.04830750f, -0.03488936f, 0.05370131f, -0.04079675f, 0.02683238f, 0.03261958f, 0.03886002f, 
    0.04893717f, -0.02156933f, -0.04018659f, -0.04159858f, -0.01886828f, 0.02560714f, -0.04040377f, -0.00445957f, 
    -0.06203858f, -0.00267002f, 0.00476902f, 0.01909324f, -0.01524965f, -0.01187788f, -0.01793013f, -0.03613122f, 
    -0.02673564f, 0.05280517f, 0.04640386f, 0.01283664f, -0.05888298f, -0.03997417f, -0.02681331f, -0.01175585f, 
    -0.05022319f, -0.05153352f, -0.02156857f, -0.02736682f, 0.02252246f, -0.03544772f, -0.05413802f, 0.01828386f, 
    0.03616440f, 0.02080073f, 0.01430427f, 0.03631109f, 0.04528555f, -0.01286913f, -0.05713449f, -0.00566590f, 
    -0.03617564f, 0.02826337f, -0.05628945f, -0.03278995f, -0.02468168f, -0.00465125f, 0.01551697f, 0.02594131f, 
    0.03802033f, 0.00944209f, -0.03231364f, -0.00695362f, -0.04983443f, 0.01465219f, 0.00139186f, -0.01938834f, 
    0.02142583f, -0.01021922f, -0.01799796f, 0.01406937f, -0.04037632f, -0.02152501f, 0.01482015f, 0.05023965f, 
    -0.04278485f, 0.02425906f, 0.02943666f, 0.01151690f, 0.01791288f, 0.01664497f, 0.04025922f, 0.02046248f, 
    -0.02563399f, -0.02891747f, -0.01239823f, -0.01102997f, 0.02861252f, 0.04436712f, -0.01620162f, 0.04647575f, 
    -0.02951728f, -0.01119622f, 0.05290679f, 0.04314069f, 0.00064255f, 0.02775985f, 0.01675926f, 0.04268787f, 
    -0.04826405f, 0.04956282f, 0.03628949f, -0.01253818f, -0.04778864f, 0.01729294f, -0.02931431f, 0.03781673f, 
    0.01850994f, -0.02193487f, -0.02542746f, 0.03040501f, 0.02420902f, 0.00115473f, -0.05763962f, 0.02879476f, 
    -0.05051462f, 0.04463454f, -0.06276677f, -0.04371973f, 0.01186586f, -0.04981398f, -0.00960462f, -0.03376455f, 
    0.04997401f, 0.01659828f, 0.05426290f, 0.04628377f, 0.09746899f, 0.13636608f, -0.17507328f, -0.03543631f, 
    -0.00729644f, 0.06243365f, -0.27114844f, 0.07795133f, 0.26233488f, 0.08844502f, -0.07028538f, -0.09768315f, 
    -0.07838513f, 0.02285885f, 0.05494902f, -0.25997335f, -0.09493134f, -0.17768635f, -0.04828608f, 0.06081666f, 
    -0.17160369f, -0.01646097f, 0.15108065f, 0.04598801f, 0.06598531f, 0.00819343f, 0.11764390f, 0.07624857f, 
    -0.07361772f, 0.09700336f, -0.04855020f, 0.01369037f, 0.19989848f, -0.07088111f, -0.08940229f, 0.00898933f, 
    -0.04926328f, -0.09916321f, 0.04447095f, -0.14229599f, 0.00476834f, 0.23492886f, 0.00397247f, -0.12145638f, 
    0.07564169f, 0.02148467f, 0.02024973f, 0.02450475f, 0.02334941f, -0.00369727f, 0.14585036f, 0.03617103f, 
    0.01606046f, -0.13488226f, 0.07159635f, -0.06057407f, 0.11164834f, -0.03255406f, 0.04903742f, 0.04971626f, 
    0.07616583f, -0.10360836f, 0.14954263f, -0.04009466f, -0.01051402f, 0.07186464f, 0.12388181f, -0.01110693f, 
    0.31272069f, 0.14847937f, -0.10120031f, 0.05524310f, 0.02760961f, -0.05799564f, 0.00911961f, -0.05620704f, 
    0.06145186f, -0.01694452f, -0.13568150f, -0.08989029f, 0.10603447f, 0.11629010f, 0.05396577f, -0.09417433f, 
    -0.09914588f, -0.13212265f, -0.23747879f, -0.06876999f, -0.14811838f, -0.25968155f, -0.08283180f, -0.02297175f, 
    -0.05595726f, -0.01668930f, 0.07249522f, -0.25289112f, -0.03429414f, 0.16232686f, -0.11589877f, 0.08380501f, 
    -0.08509799f, -0.02730110f, -0.00741681f, -0.01515269f, 0.00575602f, 0.08202098f, 0.12640557f, 0.03797527f, 
    0.09001344f, -0.13556014f, 0.06538530f, -0.03094086f, -0.00437004f, -0.11938558f, -0.21923068f, -0.14206170f, 
    0.00145415f, 0.02893913f, 0.00904004f, 0.09754742f, -0.07329394f, -0.02200257f, -0.05782166f, 0.17760855f, 
    0.12164111f, 0.00779635f, -0.06834729f, 0.09872136f, 0.01224438f, 0.06839643f, 0.02616223f, 0.03460836f, 
    0.10666844f, 0.07511191f, -0.07069544f, -0.18317670f, 0.02553331f, 0.03623876f, -0.00174117f, 0.09700024f, 
    0.15955393f, -0.14827894f, -0.07991043f, 0.05640173f, 0.03671523f, 0.06624880f, -0.08530702f, 0.00266243f, 
    -0.00850687f, 0.01595411f, -0.03271198f, 0.00096220f, 0.09624332f, 0.02531545f, 0.12007695f, -0.05635726f, 
    0.08637181f, -0.06346044f, 0.02351427f, 0.00188018f, -0.02109203f, 0.05331791f, 0.03336729f, -0.03358681f, 
    -0.01394834f, 0.14365603f, 0.04332651f, -0.19782448f, -0.28486463f, -0.39422593f, -0.11156777f, -0.09803487f, 
    -0.06449664f, -0.13923332f, 0.02065773f, 0.00105142f, 0.17138569f, 0.15474439f, 0.07891610f, 0.02246898f, 
    -0.04046907f, -0.01738098f, 0.07610395f, -0.06883258f, 0.06480747f, -0.21928461f, -0.19487078f, 0.00016475f, 
    -0.08024981f, -0.08260709f, 0.00040644f, -0.10549675f, -0.06779198f, 0.05096301f, 0.16739570f, -0.10870845f, 
    0.13290584f, -0.09728444f, -0.04791071f, -0.00526447f, -0.07625407f, 0.08164535f, 0.01619682f, 0.12394997f, 
    0.01478184f, -0.04305102f, -0.04373509f, -0.05491141f, -0.06414746f, -0.08821572f, 0.07910284f, 0.07104403f, 
    -0.02380154f, 0.09067979f, -0.04658550f, 0.00134675f, 0.04645174f, -0.04238081f, 0.03607669f, 0.07370707f, 
    0.18669625f, 0.01523374f, -0.12471622f, -0.06090394f, 0.21532758f, 0.06138559f, -0.04166548f, -0.12410373f, 
    0.04483767f, -0.04022423f, 0.05839639f, 0.20977801f, -0.31227788f, -0.08820651f, 0.10632386f, 0.02190420f, 
    -0.10236309f, -0.00058643f, 0.07346316f, 0.01329380f, 0.13109197f, -0.03207701f, 0.07183374f, -0.01950222f, 
    -0.03163290f, 0.02129247f, -0.04814473f, -0.05091806f, -0.00775536f, 0.15604387f, 0.00924587f, 0.15522350f, 
    -0.01140998f, -0.02358522f, 0.04692141f, 0.02283032f, 0.03028840f, -0.17587779f, -0.07541207f, 0.09890498f, 
    0.10344672f, 0.10236374f, -0.10098893f, 0.00891244f, -0.08061033f, 0.12109190f, 0.06845266f, 0.08393335f, 
    -0.09816090f, -0.06471911f, -0.01797602f, 0.01379756f, 0.15422800f, 0.05391458f, 0.12171350f, 0.09153396f, 
    0.02360696f, 0.04043797f, -0.00188171f, -0.06882963f, -0.00719777f, 0.13912286f, -0.02665436f, -0.09603523f, 
    -0.02790944f, -0.00571705f, -0.02146131f, -0.01546770f, 0.05178226f, -0.03973824f, 0.04946766f, -0.00308534f, 
    0.02326426f, -0.02427839f, 0.05938479f, 0.02764092f, -0.02293612f, -0.03448805f, 0.02219984f, -0.04672118f, 
    0.04578346f, -0.06274167f, 0.01325969f, -0.01906846f, -0.05098824f, 0.01984314f, 0.00539401f, -0.05512874f, 
    -0.04125730f, 0.02236333f, -0.05398712f, -0.00722942f, 0.00525740f, 0.04203314f, -0.05033242f, 0.00069277f, 
    0.00902264f, 0.01428855f, -0.03623594f, -0.03135543f, 0.00940647f, 0.01745098f, 0.03882079f, -0.01091966f, 
    0.03545194f, -0.02730417f, -0.04983425f, 0.04997762f, -0.01947657f, 0.00466063f, -0.00164518f, 0.02565708f, 
    0.02025068f, -0.01602973f, -0.03306559f, 0.03175778f, -0.06366059f, 0.04180733f, -0.03440440f, -0.03530517f, 
    -0.00084209f, 0.02068097f, 0.04139253f, -0.00674889f, -0.00946626f, -0.05483383f, 0.02075110f, 0.02735121f, 
    -0.00523803f, -0.04368368f, 0.04218022f, 0.04479049f, 0.01595253f, 0.02478685f, -0.00320052f, -0.01839342f, 
    0.02728154f, 0.00474769f, -0.02013643f, -0.02311050f, -0.01132681f, 0.00005145f, 0.04988311f, -0.05552483f, 
    -0.06081586f, -0.06198815f, -0.00834762f, 0.04467186f, -0.01233871f, 0.02133382f, -0.01641186f, -0.02835425f, 
    0.02980954f, 0.04041958f, -0.00904307f, -0.05980294f, 0.00811899f, -0.01388310f, -0.01587105f, 0.01374767f, 
    -0.04739791f, -0.01121198f, 0.04026910f, 0.03955792f, -0.05195634f, 0.01522959f, -0.03885746f, 0.01613389f, 
    0.00208459f, 0.04661384f, -0.06088884f, -0.06749301f, 0.01841678f, -0.03581497f, -0.01517068f, 0.01886605f, 
    -0.00277110f, -0.06053413f, 0.00635005f, -0.04131366f, -0.01443216f, 0.01845971f, 0.03460364f, -0.01655772f, 
    -0.05876065f, 0.05058419f, -0.06119318f, 0.01534925f, 0.01050394f, 0.01856638f, -0.01053667f, -0.06689952f, 
    -0.02873264f, -0.02048001f, -0.03023533f, 0.01416759f, -0.06219064f, 0.02532201f, -0.02861277f, -0.05782032f, 
    0.00583992f, 0.00146969f, -0.02655431f, -0.05395718f, -0.03088071f, -0.04692137f, -0.03502075f, -0.05024084f, 
    -0.03101011f, -0.02587885f, -0.00661830f, 0.00563308f, 0.01612730f, -0.02380068f, -0.00124622f, -0.04630687f, 
    0.00534442f, 0.04432814f, -0.00368414f, 0.04769767f, -0.01065330f, 0.01357847f, 0.00193989f, -0.05556378f, 
    -0.03374001f, -0.03047029f, 0.00120658f, -0.04913611f, -0.00853603f, -0.03260339f, -0.05609307f, -0.03813745f, 
    0.02347459f, 0.03401738f, -0.02421824f, -0.02668804f, 0.00040328f, 0.05304731f, -0.03089225f, -0.00528232f, 
    0.01761386f, -0.04257755f, -0.04522183f, 0.01754066f, -0.00303551f, -0.06926940f, 0.01560706f, 0.02935644f, 
    -0.02623002f, -0.06554304f, -0.02854428f, 0.00339495f, -0.06304649f, -0.02616645f, -0.02776479f, -0.06143995f, 
    -0.01790921f, 0.00326443f, 0.00754160f, 0.00906220f, -0.01495187f, -0.06955352f, 0.04847176f, 0.01592571f, 
    0.03162190f, 0.01528056f, -0.03587750f, 0.03576912f, 0.03409413f, -0.02916862f, -0.06661468f, 0.04764502f, 
    -0.01009521f, 0.02926755f, -0.04473510f, -0.04809082f, -0.06812062f, 0.00256504f, 0.00740584f, -0.05150519f, 
    -0.04480737f, -0.05550699f, 0.00558986f, 0.01328717f, -0.00617388f, 0.02062687f, -0.02610105f, -0.04342447f, 
    0.04843089f, -0.04684657f, 0.02224557f, 0.04633417f, -0.04735181f, 0.04477102f, -0.04775453f, -0.03968828f, 
    0.04266666f, -0.05009710f, 0.02236913f, 0.01465688f, -0.02376057f, 0.03772815f, -0.04660457f, 0.02055411f, 
    -0.01792586f, -0.03928559f, 0.01372368f, -0.02254948f, 0.04289949f, 0.02778163f, -0.06901565f, 0.03225220f, 
    -0.04040793f, -0.06644697f, 0.04191194f, 0.02442588f, 0.00551464f, -0.02498616f, 0.01342381f, 0.02780969f, 
    0.04179438f, -0.04564331f, -0.05864038f, 0.02617549f, 0.02185952f, -0.00885766f, -0.02912869f, 0.00717325f, 
    -0.06192847f, 0.01285574f, -0.00798579f, -0.03524032f, -0.03995180f, -0.05167750f, -0.05057609f, 0.00551529f, 
    0.04095621f, -0.05101895f, 0.04333035f, 0.03201755f, -0.04931527f, 0.02722806f, -0.02605519f, -0.06648190f, 
    -0.02221220f, 0.04097038f, -0.06827681f, -0.00915468f, 0.03917126f, -0.02431921f, -0.03807897f, 0.04801578f, 
    0.06891382f, -0.15389457f, -0.00927711f, -0.02246151f, 0.05033373f, -0.06403209f, 0.06005545f, 0.07314569f, 
    -0.00225953f, 0.12132997f, 0.16121693f, 0.12415126f, 0.11263123f, 0.05221712f, -0.01044950f, 0.16658269f, 
    -0.12770176f, 0.05081802f, -0.07982254f, 0.22603974f, -0.11640014f, 0.11690660f, -0.02784273f, 0.09937010f, 
    0.04930050f, 0.04627699f, 0.13090490f, -0.25626218f, -0.00306173f, -0.10663812f, 0.04744243f, -0.08477466f, 
    -0.13817905f, -0.00345290f, 0.02718540f, 0.05870599f, -0.51725984f, 0.18867645f, 0.08433289f, 0.03525971f, 
    -0.04183656f, -0.03186945f, 0.11768156f, -0.00804783f, -0.06596377f, -0.00461777f, 0.04239476f, 0.07969310f, 
    0.09855590f, 0.07471179f, 0.01690844f, 0.00322919f, 0.07970586f, 0.06165055f, -0.27749398f, 0.19926859f, 
    0.05775326f, -0.12680154f, 0.08195652f, 0.01259793f, 0.06374895f, 0.02026400f, -0.02972661f, 0.01409869f, 
    -0.00437404f, 0.09528948f, 0.06590644f, 0.10857754f, 0.03968071f, 0.05019221f, -0.07907194f, 0.05606354f, 
    -0.39248925f, -0.10532473f, 0.06188480f, 0.00613516f, 0.00022830f, 0.03766109f, 0.08338527f, 0.04775068f, 
    0.00768491f, -0.23068851f, -0.02923998f, 0.06326809f, 0.05862849f, -0.06459169f, 0.09666055f, -0.00118528f, 
    -0.10814433f, 0.11601461f, 0.31386355f, 0.06663679f, -0.22447948f, 0.00690743f, -0.06276979f, 0.11265741f, 
    -0.02578041f, -0.02914003f, 0.04286495f, -0.09720146f, 0.03887939f, -0.02810570f, 0.04471014f, -0.01369501f, 
    0.00354800f, 0.00236147f, -0.00927020f, -0.07774703f, -0.20046362f, 0.05286830f, -0.07684267f, 0.18324217f, 
    -0.05493249f, -0.09103199f, 0.04635926f, -0.02694137f, 0.02092421f, 0.25300655f, 0.03915370f, -0.10487228f, 
    0.07507865f, 0.02042549f, -0.03610593f, 0.03699948f, 0.05075907f, 0.04476748f, -0.06930038f, 0.08841518f, 
    -0.02270553f, 0.05663119f, 0.11030460f, -0.18882811f, -0.10983585f, 0.10258821f, 0.01371500f, -0.03709301f, 
    -0.35430500f, 0.05169806f, 0.05212950f, 0.01147430f, -0.03912526f, 0.05616018f, 0.02303460f, -0.04480340f, 
    0.11047519f, 0.00755947f, 0.04286094f, 0.01391153f, -0.08957926f, -0.07368533f, -0.13104203f, 0.03426829f, 
    -0.00531683f, 0.05813381f, -0.04199294f, 0.00626867f, -0.01012407f, 0.00431285f, -0.11369671f, 0.02471078f, 
    0.02265665f, -0.05877680f, 0.10873029f, -0.02877229f, 0.16314374f, -0.01037752f, 0.05737499f, -0.01895128f, 
    0.07073582f, 0.00120817f, 0.02370081f, 0.10812312f, 0.02518407f, -0.02344732f, -0.11015462f, 0.03261773f, 
    -0.08506528f, -0.02894202f, 0.13287145f, -0.01555709f, -0.11832619f, -0.12533912f, 0.03425119f, 0.05013384f, 
    0.19395955f, -0.04450611f, -0.09446859f, 0.03951088f, 0.04639785f, 0.04549937f, -0.10936297f, 0.05429564f, 
    -0.01062831f, 0.08456428f, 0.02817081f, -0.05188842f, -0.05942406f, 0.09560321f, 0.05742290f, -0.24292390f, 
    0.13097470f, -0.04175356f, -0.03244796f, 0.03400632f, -0.06001884f, 0.06855867f, -0.06088297f, 0.09543958f, 
    -0.13111769f, -0.21458176f, -0.09481597f, -0.12239962f, 0.00282865f, 0.01601484f, -0.01742640f, -0.00568248f, 
    -0.14711592f, -0.12252709f, 0.10301758f, 0.07251569f, 0.05126867f, -0.02145798f, 0.01394858f, 0.00497338f, 
    0.04939611f, -0.06656050f, -0.01552376f, 0.08490490f, 0.01212798f, 0.03065178f, -0.02271771f, 0.11334205f, 
    0.05422090f, 0.10426851f, 0.05271839f, -0.15018176f, 0.01831540f, -0.03621770f, -0.09982768f, 0.13527517f, 
    0.01225526f, -0.05892034f, 0.04014770f, 0.06563201f, 0.02097883f, 0.18531670f, -0.00367310f, -0.07710788f, 
    -0.02745658f, 0.08541209f, -0.12957257f, 0.05029859f, -0.05108515f, -0.11368839f, 0.10213348f, 0.08511402f, 
    0.08182937f, 0.04874720f, -0.02362041f, 0.03870412f, -0.01375361f, -0.15734194f, -0.01073876f, 0.16057770f, 
    0.02937579f, -0.03144529f, -0.06515379f, -0.07364564f, -0.03567612f, -0.06771126f, -0.08021624f, -0.09248029f, 
    -0.05208004f, 0.04329927f, 0.07433734f, -0.01956581f, -0.03112705f, -0.10706384f, -0.12222210f, -0.16320965f, 
    0.03559355f, 0.14106001f, -0.00574090f, -0.05778323f, 0.12802339f, 0.06148247f, -0.12887010f, -0.03725329f, 
    -0.05053237f, 0.01054706f, -0.00485573f, 0.04535757f, 0.00822122f, -0.01133778f, -0.02986316f, -0.03328980f, 
    -0.03177845f, -0.04944895f, -0.03900840f, -0.07502341f, -0.03484989f, -0.04137903f, -0.04726581f, 0.02287236f, 
    -0.06030155f, -0.02335985f, -0.06241056f, 0.00631511f, 0.00055381f, 0.01033392f, -0.03925353f, 0.04990726f, 
    -0.04433823f, -0.03098213f, -0.04895967f, -0.02059955f, -0.01261147f, 0.02201534f, -0.06627489f, 0.01314795f, 
    -0.03609866f, 0.04451105f, 0.04340886f, 0.02913083f, -0.03795558f, -0.04639269f, 0.03958998f, 0.00214487f, 
    -0.04330601f, -0.01061790f, -0.04701357f, -0.06869583f, 0.01990856f, -0.05903659f, -0.03311087f, -0.00819752f, 
    0.03629451f, 0.03131174f, -0.05723230f, 0.02436659f, 0.04399805f, -0.04694798f, 0.02769638f, -0.06133138f, 
    0.00163188f, 0.00357218f, -0.03909806f, 0.01754913f, -0.05273875f, 0.04643995f, 0.01045036f, -0.01830949f, 
    0.05089875f, 0.05115811f, -0.05555508f, -0.04615803f, -0.02852250f, -0.04186180f, -0.00203556f, -0.01202868f, 
    0.01412630f, 0.03012618f, 0.01439114f, -0.03311110f, -0.01129451f, 0.04979848f, -0.05938409f, -0.03130253f, 
    -0.00697142f, -0.00615406f, -0.04292629f, -0.00236824f, 0.01805875f, 0.02786920f, -0.05409317f, -0.05045086f, 
    -0.04503591f, -0.01936805f, -0.00639238f, -0.03296879f, 0.03325094f, -0.04009433f, 0.02788966f, 0.03222374f, 
    -0.03259440f, -0.02007299f, 0.02167518f, 0.01300368f, 0.01479707f, 0.01083871f, -0.01214526f, -0.04437362f, 
    -0.05881241f, -0.01710579f, -0.01082785f, -0.04429213f, -0.03932338f, -0.02549916f, -0.04606715f, -0.03390489f, 
    -0.05567014f, 0.01627547f, 0.04280683f, -0.02875348f, -0.05423585f, 0.02344437f, -0.00567384f, 0.02162853f, 
    -0.01110503f, -0.01016147f, 0.02427473f, -0.01544417f, -0.00699587f, 0.02711891f, 0.03924222f, -0.05547751f, 
    -0.02972103f, -0.03507853f, -0.01209186f, -0.01502187f, -0.00593321f, -0.06150008f, -0.01728641f, -0.05627772f, 
    0.00268184f, 0.02781637f, -0.04583145f, -0.01217232f, -0.06040432f, -0.00090435f, 0.00076597f, -0.03236823f, 
    0.02624742f, 0.03045221f, -0.03785563f, 0.02096262f, -0.01878737f, -0.06151385f, -0.04864698f, -0.00743107f, 
    -0.02262037f, -0.03271191f, 0.00517902f, 0.01569830f, 0.02150082f, 0.04163884f, 0.00960745f, 0.03487139f, 
    0.03403583f, -0.02380078f, -0.02732221f, 0.03372251f, -0.04613740f, -0.00826072f, -0.00824990f, -0.03635536f, 
    -0.00927491f, -0.02904752f, -0.02279433f, 0.00673917f, -0.03777044f, -0.00103148f, -0.03981550f, -0.03556568f, 
    -0.06257578f, 0.00848350f, -0.05789322f, 0.04507302f, -0.06091225f, 0.00908562f, -0.05173869f, 0.03139384f, 
    0.01927705f, 0.03777842f, 0.00985177f, 0.00542462f, -0.00288022f, -0.00619415f, -0.03203045f, -0.05689484f, 
    -0.06552436f, 0.01776615f, 0.02957856f, -0.02537143f, -0.05229040f, 0.04289088f, 0.01201849f, -0.05646442f, 
    0.03848390f, -0.02122932f, -0.01650274f, -0.00113931f, -0.05952293f, -0.00147439f, 0.02398475f, -0.04655052f, 
    -0.03601914f, -0.04967444f, -0.04210360f, -0.00900912f, 0.02256479f, -0.03117679f, 0.01993212f, 0.00645616f, 
    0.04836403f, -0.00576745f, 0.02079793f, -0.00341849f, 0.03358141f, 0.05172668f, 0.02523163f, 0.01761866f, 
    -0.05680526f, -0.02493994f, -0.04230203f, -0.02124766f, 0.03579924f, 0.02037770f, -0.04419886f, -0.02405494f, 
    0.04524908f, 0.03827322f, -0.05553779f, 0.04419394f, -0.03188564f, -0.00699286f, 0.00794945f, 0.01532524f, 
    0.02557579f, 0.03204196f, -0.04828741f, -0.06145538f, -0.01314671f, -0.06811198f, -0.04518401f, 0.00973318f, 
    -0.05426224f, 0.03307755f, 0.04444938f, 0.02356795f, -0.03622467f, 0.02512274f, 0.01109254f, -0.00061896f, 
    -0.03798432f, 0.00611950f, -0.06482718f, -0.04475203f, 0.03059312f, 0.03149045f, -0.05558177f, -0.02912124f, 
    -0.06930278f, 0.00307365f, 0.03990619f, 0.04944392f, -0.04192086f, -0.01266979f, -0.05752946f, 0.01681418f, 
    0.05391759f, 0.01180464f, -0.01532444f, -0.05977206f, 0.04586018f, 0.01643671f, -0.06039140f, -0.02617152f, 
    0.00151097f, -0.00283209f, 0.00504412f, 0.04518054f, 0.03414666f, -0.01050255f, 0.03184923f, -0.02000073f, 
    0.19399445f, 0.23571162f, 0.02574666f, -0.17719877f, -0.03670441f, 0.08780498f, 0.07961666f, 0.14569397f, 
    -0.03728078f, 0.34885794f, 0.37852743f, -0.03819589f, -0.11576388f, -0.13106672f, -0.06355044f, 0.10865029f, 
    0.09522458f, -0.02927824f, 0.14998746f, -0.14339055f, -0.09584055f, -0.15284993f, -0.01520909f, 0.15387855f, 
    0.00018381f, 0.05643732f, -0.06642953f, -0.50746441f, -0.15118898f, -0.03530046f, 0.04079998f, -0.04878559f, 
    -0.12000666f, -0.04002373f, 0.10598863f, 0.18719502f, -0.01067505f, -0.20618844f, -0.03775831f, 0.13447820f, 
    0.02124574f, 0.00003343f, -0.08953611f, 0.01048159f, -0.08072409f, 0.41870227f, 0.10879352f, 0.06979436f, 
    0.05566510f, 0.06739233f, 0.03283550f, 0.02093893f, -0.02083382f, 0.08242486f, -0.15198195f, -0.16036764f, 
    -0.02750956f, 0.02750777f, 0.06620909f, 0.03102807f, 0.03678880f, -0.03088821f, -0.05819953f, -0.12840551f, 
    0.13843854f, -0.08328557f, 0.03674379f, -0.13556187f, 0.01375024f, 0.01184389f, -0.12489976f, -0.08158601f, 
    -0.14499085f, -0.11591766f, -0.09333835f, -0.01887345f, 0.07356680f, -0.01203348f, -0.10873707f, 0.05642973f, 
    0.04472177f, 0.06158691f, -0.03631878f, -0.10459352f, -0.06345009f, 0.00557608f, 0.09147572f, 0.04375625f, 
    -0.02935681f, -0.10896959f, -0.09512885f, -0.14732096f, -0.32805267f, -0.03145007f, 0.10147324f, 0.01948112f, 
    0.02256211f, -0.07640383f, 0.00938396f, -0.20358476f, -0.06851155f, -0.03560098f, -0.11698689f, 0.02342616f, 
    0.03130436f, -0.01902389f, 0.08748509f, 0.09831444f, -0.26906270f, 0.09121862f, 0.08763185f, 0.11599634f, 
    0.09027393f, 0.02729439f, -0.07210562f, -0.09219234f, 0.11000293f, 0.16669229f, 0.09428927f, -0.04588276f, 
    0.03415259f, 0.04468977f, 0.07890510f, -0.02065816f, -0.04481788f, -0.04334370f, 0.09527483f, -0.18947627f, 
    0.02287830f, 0.01998356f, -0.01133946f, 0.10694780f, 0.04027838f, -0.00069845f, -0.06716847f, -0.35281146f, 
    0.14088584f, -0.14788406f, -0.06426950f, -0.06695016f, -0.03689163f, 0.07213439f, 0.03359008f, 0.02763906f, 
    0.11086717f, 0.07500623f, 0.00613603f, -0.01358071f, -0.03667806f, -0.02685507f, -0.08984558f, 0.07211184f, 
    0.02368490f, 0.01723778f, 0.12072238f, -0.00781181f, 0.15285762f, -0.00228713f, 0.10453968f, 0.07106531f, 
    0.03324252f, 0.07474335f, 0.24738534f, 0.13123061f, 0.07296348f, 0.14144488f, 0.07314469f, 0.02619986f, 
    0.07780848f, 0.00145126f, 0.07742798f, 0.11415547f, -0.30928084f, -0.28829503f, -0.06515235f, -0.20416352f, 
    0.00631808f, -0.05513882f, 0.00465954f, 0.08219412f, -0.21076827f, 0.00615654f, -0.00469722f, 0.17189047f, 
    0.04887358f, 0.10288625f, -0.19090818f, 0.01295221f, 0.05076109f, -0.17898117f, 0.01090364f, -0.11892539f, 
    -0.10083763f, -0.06916262f, 0.04206101f, -0.00969490f, 0.15576534f, -0.00553806f, 0.18153618f, 0.13804767f, 
    -0.09181327f, 0.05682521f, 0.03014109f, 0.04357692f, -0.04381086f, 0.03103290f, -0.05114724f, 0.13547570f, 
    0.03695385f, -0.07718476f, -0.23461957f, -0.02892974f, 0.00820473f, -0.01768121f, -0.05497079f, -0.05574679f, 
    -0.19113390f, -0.07827475f, -0.00537003f, 0.10640000f, 0.04962558f, 0.15396902f, 0.13363279f, -0.10144337f, 
    0.14566174f, 0.19041942f, 0.02485899f, -0.06056785f, 0.08851822f, -0.00400877f, 0.09209586f, 0.07120302f, 
    -0.00065133f, -0.03795319f, -0.04339288f, -0.02999462f, 0.00399064f, -0.04183819f, 0.03730186f, -0.00288939f, 
    -0.14460985f, -0.06185829f, 0.11185201f, 0.16329242f, 0.07400964f, -0.08908109f, 0.11585286f, 0.05312233f, 
    -0.03397102f, 0.04159395f, -0.06529920f, -0.00366422f, -0.05613842f, -0.11189068f, -0.08447015f, -0.01875289f, 
    0.11863532f, -0.05856891f, -0.01082723f, 0.07616328f, 0.05923934f, -0.21436295f, 0.10327594f, 0.02115443f, 
    0.04871346f, -0.00646812f, -0.03994625f, -0.13823001f, -0.00743747f, 0.07782222f, -0.03120513f, -0.30080283f, 
    -0.21813157f, 0.07747803f, 0.04818799f, 0.11686851f, -0.03241230f, 0.02052079f, -0.03589289f, -0.25651196f, 
    -0.11679410f, 0.03562782f, 0.16005296f, 0.14644372f, -0.03373792f, -0.15738079f, 0.01762098f, 0.10099515f, 
    -0.02085614f, -0.00030500f, -0.02568988f, -0.06107813f, -0.01119720f, -0.02924850f, 0.02133380f, 0.03787348f, 
    -0.02683102f, -0.01228969f, -0.02369890f, 0.06185894f, -0.01583678f, -0.00082532f, 0.02379143f, -0.02976118f, 
    0.01621407f, -0.04827568f, -0.04577816f, 0.04010397f, -0.00415640f, -0.04408951f, 0.00382379f, 0.03373108f, 
    -0.01957334f, -0.02568577f, 0.01286733f, 0.00049173f, 0.00432569f, -0.01928443f, -0.02293694f, -0.05800555f, 
    -0.01458194f, -0.05089109f, 0.03355035f, 0.04572231f, 0.04064129f, -0.04038274f, 0.00226427f, -0.05301826f, 
    -0.05293785f, 0.00780649f, 0.01848688f, -0.05493989f, 0.02771921f, 0.03645022f, -0.02527132f, 0.04171693f, 
    -0.01518181f, 0.04285329f, -0.00438023f, -0.03722412f, 0.04488937f, -0.00286294f, 0.00334491f, -0.01689445f, 
    0.04949180f, 0.00862371f, -0.00433516f, -0.01580035f, -0.04557161f, -0.03293196f, 0.04834802f, -0.01510374f, 
    -0.01818230f, -0.00651975f, -0.02787706f, 0.05179259f, -0.02461904f, 0.02711907f, 0.02333600f, 0.02852160f, 
    0.02000471f, -0.03794768f, 0.03693706f, -0.00754683f, -0.01074504f, -0.06478420f, -0.01173215f, 0.02677396f, 
    -0.02235392f, -0.06153968f, 0.00139497f, -0.01374286f, -0.02948917f, -0.06146666f, -0.01983805f, -0.05664065f, 
    0.01421491f, 0.00812817f, -0.06200223f, -0.06396510f, -0.05937566f, 0.03410354f, -0.05227747f, -0.04672583f, 
    -0.04231732f, -0.06564187f, -0.01543180f, 0.02754466f, -0.01292813f, -0.05074780f, 0.01908984f, 0.04981517f, 
    -0.00318851f, 0.00346520f, 0.02489404f, -0.05617563f, -0.02553776f, -0.00959585f, -0.02697300f, -0.05849632f, 
    -0.03673113f, -0.02173520f, -0.05585129f, -0.01754545f, -0.05574441f, 0.05002313f, -0.00945053f, 0.03568716f, 
    -0.00592160f, 0.00350524f, -0.02025811f, 0.05213442f, -0.05456961f, 0.00277367f, 0.00422446f, 0.00956658f, 
    -0.06256898f, -0.05884045f, -0.00858994f, -0.05957436f, -0.03700865f, 0.02008784f, 0.03626758f, 0.04525822f, 
    -0.04856165f, -0.01204028f, -0.06158747f, 0.03456965f, 0.04388094f, 0.00717016f, -0.01925192f, -0.00212461f, 
    0.03515538f, 0.03202309f, 0.02702132f, 0.01967750f, -0.03793592f, 0.00409051f, 0.04150873f, 0.02625835f, 
    -0.02234329f, 0.04856360f, -0.02580786f, 0.00541029f, 0.00994202f, -0.03262468f, 0.04440649f, -0.04852603f, 
    -0.06169469f, -0.02155144f, 0.03589613f, -0.03539783f, -0.05257817f, 0.01877520f, -0.00844241f, 0.03069807f, 
    -0.04262987f, 0.03313320f, -0.03749824f, -0.06098707f, -0.05270711f, -0.01774285f, 0.05026229f, -0.02777824f, 
    0.02757513f, -0.01938292f, -0.05896486f, 0.01633376f, -0.01517347f, -0.04982138f, -0.03064884f, 0.04566962f, 
    -0.00674929f, 0.00190806f, -0.00412862f, 0.01060370f, -0.01101455f, -0.00821579f, 0.04328022f, 0.06162408f, 
    -0.00139047f, -0.05396098f, -0.05272335f, -0.03692024f, -0.02487454f, 0.04314363f, -0.06669343f, -0.02249684f, 
    -0.01941437f, 0.05145803f, -0.04950088f, 0.01058775f, -0.00392453f, 0.04111911f, -0.04027459f, 0.02253390f, 
    0.03814371f, -0.02635352f, -0.02730147f, -0.01720838f, 0.00928770f, 0.00955917f, -0.03912294f, 0.03288421f, 
    -0.05707256f, 0.00084098f, 0.03929604f, 0.00012874f, 0.00696968f, -0.02126676f, -0.06397476f, -0.00716376f, 
    0.01413662f, 0.05122681f, -0.02402407f, -0.02211987f, -0.02411231f, 0.04754714f, 0.01108002f, -0.03344629f, 
    0.00249128f, 0.04531780f, 0.01085920f, 0.05886120f, 0.02832208f, 0.01487600f, -0.00394191f, -0.00668260f, 
    -0.01398791f, 0.02783273f, -0.00903879f, -0.02682738f, 0.03345525f, 0.02492721f, -0.01398505f, -0.03066177f, 
    0.04597327f, -0.05251623f, 0.02960270f, -0.02210852f, -0.03241986f, 0.00400217f, -0.04267567f, 0.04091732f, 
    -0.04623973f, -0.02822401f, -0.03351295f, 0.03176055f, -0.04637985f, -0.03043765f, -0.05743722f, 0.01593707f, 
    0.01245693f, -0.00538239f, -0.01229496f, -0.03278381f, 0.03587672f, 0.02132692f, 0.04003169f, 0.01718269f, 
    -0.02973900f, -0.04388937f, 0.00581009f, 0.02756203f, -0.02067985f, -0.01780195f, -0.03908481f, -0.00337313f, 
    0.01783489f, -0.06491714f, -0.02870644f, 0.01899575f, 0.03372047f, -0.06441080f, -0.03062153f, -0.00107582f, 
    0.17020923f, 0.09328920f, -0.09312645f, -0.00809440f, 0.10680651f, 0.03446856f, 0.03542562f, 0.09474228f, 
    -0.01878852f, 0.09520421f, -0.07863954f, 0.14758819f, 0.03392896f, -0.12257545f, -0.03521011f, -0.00364980f, 
    -0.00975980f, 0.13380349f, 0.19941418f, 0.25773975f, -0.02869127f, -0.01137760f, 0.06418981f, 0.07548566f, 
    -0.06288279f, -0.00273667f, -0.05190834f, 0.09994290f, 0.13965708f, -0.03555360f, 0.17163146f, 0.08812438f, 
    -0.02255530f, 0.24733318f, -0.03304825f, -0.06288439f, -0.10915310f, 0.12329058f, 0.13109900f, 0.10194377f, 
    -0.06972069f, -0.09963556f, 0.04635356f, 0.00459594f, -0.03791433f, -0.14057666f, -0.02208667f, 0.05192760f, 
    0.09460033f, -0.20982105f, -0.08025163f, -0.11368826f, -0.03562219f, 0.14061575f, -0.03050188f, 0.18950620f, 
    0.10242585f, -0.07669609f, 0.04063461f, 0.07129225f, -0.04750431f, 0.08352134f, 0.05196708f, 0.01417454f, 
    0.10453124f, -0.04690114f, -0.03616056f, 0.07130364f, 0.11024039f, 0.03588720f, -0.01431107f, -0.01933540f, 
    0.06793898f, 0.03187015f, 0.07067470f, -0.05861390f, -0.03977439f, 0.05357664f, 0.07438351f, -0.01603050f, 
    -0.08813035f, -0.08233091f, 0.10575347f, -0.01665320f, -0.05206643f, -0.16527140f, -0.00308042f, -0.06337404f, 
    -0.07789853f, 0.01014227f, 0.38479817f, 0.13769165f, 0.03856637f, -0.10331856f, 0.06960924f, 0.00972342f, 
    0.06351850f, 0.05655991f, 0.03098335f, 0.00555995f, 0.10338585f, -0.04029502f, -0.15041257f, -0.25239906f, 
    0.06122512f, -0.08120832f, 0.12418247f, 0.10060750f, 0.01611537f, 0.03948364f, -0.04096682f, 0.06052686f, 
    0.04744494f, -0.02138016f, 0.04392289f, 0.05286275f, 0.01693099f, 0.00488794f, 0.04436482f, 0.00338698f, 
    0.10099571f, -0.04647157f, -0.14678565f, -0.08330279f, 0.00006674f, 0.12280538f, 0.03094759f, 0.01285610f, 
    -0.06892715f, -0.04952158f, 0.09143367f, -0.04768610f, 0.04038795f, 0.03828782f, 0.05127032f, -0.01450550f, 
    -0.22885676f, 0.20522542f, 0.03631001f, 0.10273934f, 0.14325204f, -0.18729706f, -0.07427750f, -0.07351849f, 
    0.16055994f, 0.20821731f, -0.14354487f, 0.11602288f, 0.05604397f, 0.04922558f, 0.04005444f, -0.06212152f, 
    -0.10030011f, 0.04084990f, -0.21100718f, -0.08205212f, -0.11273585f, -0.04084291f, -0.03966643f, 0.04351787f, 
    -0.00631170f, -0.00768329f, 0.02820640f, -0.04653997f, -0.06127558f, -0.03918549f, -0.05887325f, -0.05114073f, 
    0.06933368f, 0.05885339f, 0.00973053f, 0.31731206f, -0.11255889f, -0.21642378f, -0.00623781f, -0.06180388f, 
    -0.03336332f, 0.12682028f, 0.10270140f, -0.04157944f, 0.16013186f, -0.10335194f, -0.01183321f, 0.00514583f, 
    0.00600022f, -0.04414617f, -0.06358851f, 0.00904764f, -0.10774118f, 0.09531492f, -0.07878615f, -0.10613336f, 
    -0.07282998f, -0.24074909f, 0.12572546f, -0.09619345f, 0.03605741f, 0.09591307f, 0.07013389f, 0.06366026f, 
    -0.18314345f, -0.01936068f, 0.05462076f, 0.03435915f, -0.08304307f, 0.03044446f, -0.11614959f, 0.03189394f, 
    0.32211447f, 0.07123064f, 0.05068674f, -0.07811992f, 0.08483774f, 0.00777919f, 0.12519194f, 0.07772592f, 
    -0.12813768f, -0.00143807f, -0.11474860f, -0.04060903f, 0.05064861f, -0.01733564f, 0.03076309f, 0.00134916f, 
    -0.07061426f, -0.08753220f, 0.07616404f, -0.01661467f, -0.01244971f, 0.04177524f, 0.00675852f, -0.09285531f, 
    -0.07778493f, 0.07068869f, -0.15237954f, -0.03575534f, -0.07280065f, 0.01297114f, 0.03599561f, -0.01189749f, 
    0.01465105f, 0.03314686f, 0.06886142f, -0.03822864f, -0.00399636f, -0.05147674f, -0.12988873f, 0.05714384f, 
    -0.13043180f, 0.05641697f, -0.04088716f, 0.01277543f, 0.16550380f, -0.05739180f, -0.19864756f, -0.08093984f, 
    -0.06488916f, -0.06491107f, 0.00651338f, 0.21065564f, 0.04517257f, -0.04039941f, -0.12878470f, 0.00681505f, 
    0.04026271f, -0.01582359f, -0.16754423f, 0.01740361f, -0.05021013f, 0.22162461f, 0.12148692f, -0.08993261f, 
    -0.16943562f, -0.02356018f, 0.02120154f, -0.00066534f, -0.08594241f, 0.11343908f, 0.02096719f, -0.00673367f, 
    0.04751601f, 0.06339873f, -0.06786262f, -0.05466153f, 0.04077987f, 0.10372787f, 0.06115004f, -0.04911052f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.03392825f, 0.05707018f, 0.00293908f, -0.01126975f, 0.08968065f, 0.01546972f, 0.13509358f, -0.05668221f, 
    -0.00162956f, 0.08728969f, 0.05953041f, 0.12251361f, -0.01783249f, -0.00430714f, 0.02557210f, 0.00388451f, 
    -0.03664544f, 0.05657885f, 0.00262390f, -0.05500290f, 0.08000907f, -0.04635975f, -0.01654623f, 0.19047132f, 
    -0.05557916f, 0.00605512f, 0.04488974f, 0.08922621f, 0.05236368f, 0.01687640f, 0.04990584f, -0.02237055f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.17326096f, -0.07203441f, 0.11843906f, -0.18190089f, -0.11353321f, 0.00953509f, -0.04491693f, -0.07883060f, 
    0.06213014f, 0.10060807f, -0.15286161f, -0.17220414f, -0.10556331f, -0.03085317f, -0.06486537f, -0.15398452f, 
    -0.13246490f, 0.04008731f, 0.04812401f, 0.09780433f, -0.12700501f, -0.14705275f, -0.11276927f, 0.05574983f, 
    0.15702412f, -0.11742637f, 0.03724822f, -0.08400813f, -0.05735659f, -0.14244689f, 0.13313173f, -0.04762413f, 
    0.28921881f, -0.28002971f, 0.06094635f, -0.43549600f, -0.15485513f, 0.18872952f, 0.13104972f, 0.01588676f, 
    -0.03609759f, 0.20543963f, 0.00117373f, 0.21297467f, 0.01764622f, -0.11303069f, -0.00826510f, 0.25163248f, 
    -0.08967337f, 0.23633321f, 0.14366622f, -0.04596301f, -0.21118359f, -0.16357791f, 0.05349981f, 0.58635372f, 
    0.08149852f, -0.08671582f, 0.11180801f, -0.03940880f, 0.09881330f, 0.00176766f, 0.03962611f, 0.04035748f, 
    0.08224007f, 0.12962618f, 0.05838634f, -0.10191324f, -0.29335153f, 0.31840089f, 0.02802899f, 0.13856538f, 
    0.09625030f, 0.01311610f, 0.11506498f, -0.03954098f, -0.10568585f, -0.18947400f, -0.11940803f, 0.28551081f, 
    0.06047875f, 0.27474079f, 0.11372166f, -0.00550752f, -0.17846890f, -0.06699411f, -0.01080087f, 0.13181016f, 
    -0.16919290f, 0.25951275f, -0.05909786f, -0.19551706f, -0.01312202f, 0.14776121f, 0.16687219f, -0.16185577f, 
    -0.00826344f, -0.05567689f, -0.05685119f, -0.13215613f, 0.10292365f, 0.14193018f, -0.04822980f, 0.07625061f, 
    -0.12929496f, 0.13526946f, -0.13299231f, -0.16505685f, -0.11369020f, -0.07684848f, 0.10198463f, -0.09952150f, 
    -0.16120967f, -0.02904919f, -0.17595173f, 0.11885875f, -0.03553692f, 0.03067370f, 0.17611358f, -0.16181245f, 
    0.16435063f, -0.00778886f, -0.06223401f, -0.08043064f, 0.15962616f, -0.16362728f, -0.03076163f, -0.01628904f, 
    0.38601497f, -0.20221092f, 0.12657742f, 0.08939098f, 0.18004996f, -0.00689688f, 0.34037036f, 0.10708723f, 
    -0.11517765f, 0.02300899f, 0.11424099f, 0.09978236f, 0.14407533f, 0.20230238f, -0.08884969f, -0.19313520f, 
    -0.29849204f, -0.00277936f, -0.13287067f, -0.04428284f, 0.03255060f, -0.01544893f, -0.12082293f, 0.41174573f, 
    0.07980748f, 0.10406293f, 0.09797922f, 0.08716936f, -0.02216581f, -0.33240852f, -0.16348274f, 0.30828610f, 
    0.29747841f, -0.01257899f, -0.26942396f, -0.29380745f, -0.00574424f, -0.04501155f, 0.23498361f, -0.06583983f, 
    -0.18115503f, 0.17501350f, 0.25034374f, 0.32834208f, -0.08928745f, 0.15408376f, 0.35064352f, 0.25217548f, 
    -0.01446415f, 0.25122073f, 0.03381544f, -0.02302957f, 0.13588184f, 0.13239883f, -0.14889920f, 0.27758229f, 
    -0.11069244f, -0.04643006f, 0.04297820f, -0.17645162f, -0.11367848f, -0.23028670f, -0.06620797f, 0.29589152f, 
    0.10619630f, 0.15658954f, -0.37057254f, -0.15608180f, -0.22101156f, -0.06117158f, -0.00633954f, 0.15977916f, 
    -0.17913629f, 0.33731383f, -0.17556834f, 0.32174170f, 0.06239968f, 0.03888946f, -0.03867062f, -0.38827446f, 
    0.33420566f, 0.10069618f, 0.09461259f, 0.00388788f, 0.19172218f, -0.13213800f, 0.04917154f, 0.37669334f, 
    0.09780442f, -0.03362401f, -0.00454406f, -0.20134203f, 0.09267078f, -0.35182852f, -0.16461499f, 0.05909128f, 
    0.33251712f, 0.11206334f, 0.21861053f, -0.27741322f, 0.33063674f, 0.23995815f, 0.04515203f, -0.16532351f, 
    0.02131797f, -0.24261889f, 0.14795527f, -0.03578961f, -0.01997907f, -0.02902287f, -0.13235191f, 0.04030623f, 
    0.01540850f, 0.00859045f, 0.06120313f, 0.03070476f, -0.20744756f, -0.17483950f, 0.06762403f, -0.13697276f, 
    0.10836791f, 0.09962939f, -0.05403372f, -0.05665151f, 0.06419891f, 0.08496491f, 0.15022445f, 0.10014440f, 
    -0.08192279f, -0.09642672f, 0.00561048f, 0.01655403f, -0.11942139f, 0.07874791f, -0.02821446f, 0.18034139f, 
    -0.16766125f, -0.09356920f, 0.03859333f, -0.05229197f, 0.12413465f, 0.09927333f, 0.06172908f, 0.05205956f, 
    -0.07500094f, -0.16781378f, 0.09037832f, 0.05595672f, -0.06152027f, 0.00415258f, -0.05567666f, -0.16860054f, 
    0.05087627f, -0.18681332f, -0.03958375f, -0.12046367f, -0.02407005f, 0.15260406f, 0.01269372f, -0.11538880f, 
    0.08807528f, 0.00808745f, -0.17609869f, -0.08621625f, 0.10187690f, 0.04737647f, -0.21252948f, 0.07428724f, 
    0.16254841f, 0.03915984f, -0.19129972f, -0.08873116f, -0.01368380f, -0.13674156f, -0.07451298f, -0.03713436f, 
    -0.06624845f, -0.04523769f, -0.07431332f, 0.13734400f, -0.14488131f, -0.02186882f, 0.11142603f, -0.16847566f, 
    -0.07129125f, -0.05048880f, -0.12304920f, -0.09748693f, 0.09028171f, -0.09230760f, 0.05176769f, 0.13214917f, 
    0.06485518f, 0.13215038f, 0.23847978f, -0.01263970f, 0.21132697f, -0.26437744f, 0.06370078f, -0.10209835f, 
    -0.05021393f, 0.21169344f, -0.14556143f, -0.09012224f, -0.05318011f, 0.15536962f, -0.28024411f, 0.24612805f, 
    -0.03288908f, -0.16342978f, 0.11301006f, 0.09041542f, 0.05827378f, 0.02348911f, 0.10944242f, -0.15004611f, 
    0.06712657f, -0.10245576f, -0.09808490f, 0.23891813f, 0.02964756f, -0.03543492f, 0.00251113f, 0.25671878f, 
    -0.10081487f, 0.22406150f, 0.41857421f, -0.23032928f, 0.11401937f, 0.12965070f, 0.25155473f, 0.05646760f, 
    -0.00320355f, -0.14615972f, -0.13008425f, -0.04121068f, 0.13809709f, -0.06386752f, -0.44174883f, 0.35125127f, 
    0.31563666f, 0.10600454f, 0.12661813f, -0.01270853f, 0.17284097f, 0.11413702f, -0.13967898f, -0.23753615f, 
    -0.05243072f, 0.39574927f, -0.16029806f, -0.09372718f, 0.07764117f, 0.08958375f, 0.02395901f, 0.00719376f, 
    -0.00136108f, 0.26510927f, 0.10478074f, 0.19261704f, 0.18840809f, -0.05578814f, 0.23128323f, 0.04874739f, 
    -0.04034783f, -0.08277475f, -0.03365991f, -0.07026435f, 0.08596867f, 0.03841688f, -0.21610892f, 0.17039140f, 
    0.02911639f, -0.14758736f, -0.01817498f, 0.00344093f, -0.04025792f, -0.05171840f, -0.08903711f, -0.17852339f, 
    -0.02813921f, 0.40056911f, 0.01439779f, 0.11045238f, -0.09543656f, 0.10565300f, -0.10597590f, 0.23906474f, 
    -0.10684267f, 0.14411305f, -0.13892005f, 0.27215677f, -0.25923949f, 0.02036131f, 0.06527951f, -0.16999805f, 
    -0.12169064f, 0.12970392f, 0.01262971f, -0.11109434f, 0.07359362f, -0.19976591f, 0.23306803f, -0.00977426f, 
    -0.12406078f, -0.42370024f, -0.13287674f, -0.14771520f, 0.08696008f, -0.03351206f, 0.13221329f, -0.02906363f, 
    0.06325011f, -0.25795388f, 0.02985211f, 0.26719263f, -0.02673172f, -0.32857627f, 0.10411302f, 0.13496110f, 
    -0.08618538f, 0.25469735f, -0.37945592f, 0.16982855f, 0.22851142f, 0.04608145f, 0.25776958f, -0.13484143f, 
    0.07177536f, -0.24665397f, 0.16040219f, -0.04207733f, 0.00609488f, 0.04177983f, -0.27080503f, -0.41440308f, 
    -0.00136356f, -0.14799379f, -0.12916194f, 0.16303977f, 0.06925878f, 0.02864805f, 0.11888658f, -0.39739317f, 
    0.05488561f, 0.23637635f, -0.13439769f, 0.33148435f, 0.14197673f, 0.45643055f, -0.07877948f, 0.18921417f, 
    0.34352732f, 0.06881797f, 0.16362531f, 0.02577459f, 0.11218626f, -0.08578370f, 0.09643619f, -0.03849770f, 
    -0.13096303f, 0.02490123f, -0.42929479f, 0.11478421f, 0.02371334f, -0.00301834f, 0.31793860f, 0.44592583f, 
    0.17733277f, 0.25519609f, -0.10220129f, 0.01471871f, -0.31470972f, 0.14098845f, -0.00351919f, 0.04114598f, 
    0.08188754f, -0.20420609f, 0.16735163f, -0.28980294f, 0.05129248f, -0.03043299f, 0.16912903f, -0.08374446f, 
    -0.28583992f, -0.01903126f, 0.20568183f, -0.15628292f, 0.03413151f, -0.07241764f, -0.20063636f, 0.01640441f, 
    -0.11884216f, -0.07528098f, -0.12988210f, 0.30843714f, 0.01570264f, 0.20909622f, 0.19004013f, -0.08640043f, 
    -0.21791130f, 0.20113066f, -0.13362858f, -0.15639180f, 0.26217738f, 0.13462511f, 0.12296367f, -0.00234903f, 
    0.13912037f, -0.09148867f, -0.02724989f, 0.26115152f, 0.05474956f, 0.03897377f, -0.07041076f, -0.16427478f, 
    0.24946213f, -0.16700004f, 0.35709423f, -0.55846637f, 0.09811725f, 0.07554736f, 0.16409439f, 0.14839120f, 
    -0.12615459f, -0.00242672f, 0.06703438f, 0.10393253f, 0.14875348f, -0.18825479f, -0.34928176f, 0.19395459f, 
    0.06188734f, 0.34659246f, 0.00636652f, -0.00707990f, -0.06506090f, 0.08738719f, 0.04132162f, 0.34191951f, 
    -0.14794567f, 0.29154852f, 0.10094793f, 0.00863655f, 0.02745868f, -0.06885822f, 0.14808692f, -0.11201344f, 
    -0.10197892f, 0.07424645f, -0.05158008f, 0.24889183f, -0.36713657f, 0.31997487f, 0.24454865f, -0.10158394f, 
    0.14800072f, -0.06155839f, 0.13114528f, -0.03564527f, -0.07174107f, -0.13473730f, -0.04775614f, 0.13491350f, 
    -0.00407802f, 0.25393766f, -0.17255385f, 0.14505652f, 0.24754743f, 0.06823729f, -0.06823188f, -0.12747039f, 
    0.01181533f, 0.34809247f, 0.11439922f, -0.21126349f, 0.11712354f, -0.02586508f, 0.16409539f, -0.06275200f, 
    0.34541759f, 0.19603977f, 0.25784335f, 0.06220187f, 0.32801992f, -0.20534378f, 0.26503715f, 0.06714942f, 
    0.07378697f, 0.17012008f, -0.16120744f, -0.18999515f, -0.14025608f, 0.23429237f, -0.25116056f, 0.14249553f, 
    0.02194195f, -0.15236850f, -0.12285078f, -0.11325932f, -0.12169633f, -0.15740301f, 0.02737861f, 0.07537230f, 
    0.13300140f, -0.00943743f, 0.09721276f, 0.02746120f, -0.16359311f, -0.09063733f, 0.14293516f, 0.22386658f, 
    -0.01393180f, -0.10913481f, 0.11694669f, 0.02082964f, 0.02683317f, -0.19960310f, -0.12045929f, 0.05412231f, 
    -0.17560254f, 0.13211353f, -0.09422877f, -0.04687684f, -0.03772724f, 0.10479125f, -0.17667934f, -0.04034940f, 
    -0.11315529f, 0.02044852f, -0.06458162f, -0.14007194f, -0.02276902f, -0.04912744f, -0.09435155f, -0.09332927f, 
    -0.12534910f, -0.11562914f, 0.09960925f, -0.13423298f, -0.12912053f, -0.15954080f, -0.10463671f, -0.16247496f, 
    -0.33153471f, 0.06129345f, -0.15447953f, 0.30841580f, -0.21132070f, 0.17602910f, -0.05246125f, -0.09321181f, 
    -0.09271857f, -0.04952649f, 0.10524395f, 0.34946769f, 0.03605679f, -0.10347563f, 0.26357725f, 0.19953609f, 
    -0.04271121f, 0.26869708f, -0.17548893f, 0.04641759f, 0.34477115f, -0.03816339f, -0.12284217f, -0.20998977f, 
    -0.04307244f, -0.08218326f, -0.04185960f, 0.15342487f, -0.13186277f, 0.20925871f, 0.15237093f, 0.05573035f, 
    0.02522835f, 0.35979599f, 0.29354945f, -0.11240721f, 0.12887174f, 0.31241220f, -0.10858222f, -0.13981318f, 
    -0.07236561f, -0.42307732f, -0.14685169f, 0.04611000f, -0.05515897f, -0.08156989f, -0.17673343f, -0.13644911f, 
    0.23080628f, 0.09808681f, 0.08952622f, -0.12035960f, -0.06624312f, -0.06136840f, -0.17153282f, -0.41834477f, 
    0.01215365f, 0.14311500f, -0.01247589f, -0.25310075f, 0.10071611f, -0.04951648f, 0.15971561f, 0.27912229f, 
    -0.11153897f, 0.16775471f, -0.03019921f, 0.09527000f, 0.21459712f, 0.14740968f, 0.17357722f, 0.11338229f, 
    0.03454664f, -0.18285964f, -0.22702521f, 0.33692631f, -0.15177576f, 0.28479677f, 0.09784472f, 0.25147912f, 
    -0.11952688f, -0.21230111f, 0.12482202f, 0.08970691f, 0.20628481f, 0.08625446f, -0.11830101f, -0.00310302f, 
    -0.12936711f, -0.31042784f, 0.03669576f, 0.46601266f, -0.07612199f, 0.05736768f, -0.15763554f, -0.19266953f, 
    -0.07501481f, 0.21954091f, 0.31476295f, -0.09588142f, 0.20481589f, -0.02632511f, -0.22404125f, 0.09833573f, 
    0.00666059f, 0.24241847f, -0.00243456f, 0.10012471f, -0.01904376f, 0.10948472f, -0.13339099f, -0.49645457f, 
    0.34194213f, -0.28039467f, 0.14670537f, -0.01789659f, 0.23752089f, 0.13939308f, -0.04283057f, -0.20764311f, 
    -0.09478478f, -0.11786471f, 0.04650270f, 0.16162099f, -0.00891871f, 0.02125919f, 0.03378949f, 0.19301838f, 
    -0.02657476f, -0.08678782f, -0.24609613f, 0.49259666f, 0.01931383f, 0.06389140f, -0.00032117f, 0.07698352f, 
    -0.08525222f, -0.10549206f, 0.32641694f, 0.03673049f, -0.04284165f, 0.24554670f, 0.13110054f, 0.27040312f, 
    -0.31169257f, 0.28597906f, -0.06666798f, 0.02470276f, -0.09755745f, -0.02720367f, 0.16149180f, -0.02811880f, 
    0.07418568f, 0.09434488f, 0.13515390f, 0.39041999f, 0.02223089f, 0.39239436f, -0.01783660f, -0.08503821f, 
    0.21650214f, 0.00986724f, 0.26470220f, 0.04042398f, 0.20444664f, -0.03519706f, -0.08151442f, -0.00827113f, 
    -0.14656407f, -0.05422161f, -0.25985715f, 0.03886709f, -0.02686467f, -0.03839073f, 0.07212090f, 0.41879815f, 
    0.35103542f, 0.12433258f, 0.02931706f, -0.14417957f, -0.35227054f, 0.05000460f, -0.10645385f, -0.02922987f, 
    0.08470960f, -0.13183270f, -0.08746035f, -0.22968079f, -0.07114553f, -0.13788486f, -0.01505941f, 0.21569963f, 
    0.07788891f, 0.10488274f, -0.02654229f, -0.22309087f, 0.17055249f, -0.21862485f, -0.00972301f, 0.07742289f, 
    -0.15576300f, 0.27751365f, -0.14180410f, 0.17518790f, 0.03277889f, 0.16399990f, -0.16364774f, -0.56635565f, 
    0.13628243f, 0.25416335f, -0.11449844f, 0.12092109f, 0.19595392f, -0.00353416f, -0.09041692f, 0.20656928f, 
    -0.13554908f, 0.07752756f, 0.10053544f, -0.07772466f, -0.15071434f, -0.26406249f, 0.14699054f, 0.20706598f, 
    0.14461382f, 0.01656123f, -0.25175866f, 0.08291686f, 0.40291387f, -0.20368728f, 0.01916453f, -0.05252437f, 
    0.03002575f, 0.04901432f, 0.09839854f, 0.19338524f, 0.00636667f, 0.09722766f, -0.09799131f, -0.48086163f, 
    -0.09190277f, -0.11768653f, -0.16655891f, -0.13989043f, 0.04881112f, -0.00732714f, -0.13733105f, -0.15170904f, 
    0.10244258f, 0.05509738f, 0.03229585f, 0.43658769f, 0.01896621f, 0.15754880f, -0.04938887f, 0.18139270f, 
    -0.35469985f, 0.00160394f, 0.20127238f, 0.31548807f, 0.11849937f, 0.08644703f, -0.27951598f, -0.16968696f, 
    0.18661027f, -0.00203882f, -0.24350123f, 0.32669875f, 0.01032058f, -0.04156306f, 0.26321143f, -0.13537033f, 
    0.13630973f, -0.03067700f, -0.08319842f, 0.10476366f, 0.27125609f, -0.00787619f, 0.12327875f, -0.02212796f, 
    -0.05047652f, -0.23514816f, -0.06693618f, 0.27496833f, -0.00343351f, -0.12130162f, 0.01493480f, 0.12799011f, 
    0.27845684f, 0.04735639f, -0.27293596f, 0.07546750f, -0.18790090f, 0.20507053f, 0.30065036f, 0.02836997f, 
    -0.11555979f, -0.17299815f, 0.19891848f, -0.09733833f, 0.06992700f, -0.01880669f, -0.00216703f, 0.59369558f, 
    -0.03070086f, 0.19863318f, 0.11017799f, -0.12419735f, -0.36935529f, -0.05754271f, -0.08953034f, 0.11919650f, 
    0.12496164f, 0.26972440f, -0.08986222f, 0.01295947f, 0.04637185f, 0.27856302f, -0.09020533f, -0.10996512f, 
    0.26713103f, -0.02957488f, 0.01256064f, 0.16854344f, -0.09171241f, 0.34371001f, 0.15819623f, 0.04931119f, 
    -0.07519257f, 0.02433523f, 0.29138908f, 0.21623127f, -0.06230462f, -0.26160470f, 0.10169674f, 0.41060546f, 
    0.07169194f, 0.17690425f, -0.15693712f, 0.14287439f, -0.11923112f, 0.09352366f, 0.09515539f, -0.02895347f, 
    0.03798182f, 0.17144947f, -0.14214244f, -0.11037855f, 0.12476839f, -0.01038231f, 0.16434227f, -0.23342200f, 
    0.13897584f, 0.28864050f, -0.01244166f, 0.42470631f, 0.12706938f, -0.17596711f, 0.19408403f, -0.11020830f, 
    -0.14921296f, -0.13949591f, 0.07746040f, -0.23575486f, -0.12575285f, 0.30896053f, -0.21996978f, 0.02866587f, 
    -0.16983964f, 0.14828692f, 0.14414284f, 0.07070526f, -0.15657821f, 0.03447668f, 0.05495747f, -0.21838333f, 
    0.02922551f, 0.36173257f, 0.08057766f, 0.37691075f, -0.14516826f, 0.25938147f, 0.07287198f, 0.31218058f, 
    0.11568734f, 0.13107121f, -0.15565784f, 0.04484046f, 0.13733414f, -0.13938867f, -0.16515908f, 0.17246990f, 
    -0.00646122f, -0.09434908f, -0.12268165f, -0.03757478f, 0.05484472f, -0.13488701f, 0.04260673f, -0.09829655f, 
    0.03649531f, 0.00054651f, -0.17628545f, 0.13350233f, -0.13067280f, -0.10239121f, 0.11139098f, -0.08933768f, 
    0.00154401f, 0.02779037f, -0.03795678f, -0.13879882f, 0.08864919f, -0.15594926f, -0.11396120f, -0.07093296f, 
    0.04459173f, -0.19137341f, -0.10963529f, -0.20937358f, -0.04764615f, 0.15349986f, 0.07748861f, -0.03605930f, 
    0.10218747f, 0.00171361f, 0.25292003f, -0.10115705f, -0.06468723f, 0.14570348f, 0.21405165f, 0.09854209f, 
    -0.24209404f, 0.27898818f, 0.11983939f, 0.03394330f, -0.09397420f, 0.08191065f, -0.05439890f, 0.43612733f, 
    0.04159452f, 0.22644615f, -0.15757555f, -0.15489240f, 0.11083287f, 0.20526688f, 0.17654175f, -0.01949255f, 
    -0.20074141f, -0.50406194f, 0.09164514f, 0.30841774f, -0.34025660f, 0.04330868f, 0.09141000f, -0.02245668f, 
    0.03672181f, -0.06309099f, 0.07559945f, -0.07639962f, -0.14348099f, -0.12792420f, 0.04514415f, -0.40029550f, 
    0.13041374f, 0.11923432f, 0.10535321f, 0.05285498f, 0.01107126f, 0.00777570f, 0.10082554f, -0.03608293f, 
    -0.09036748f, 0.33297756f, -0.04618563f, 0.02614943f, -0.06787980f, -0.09120827f, -0.14463428f, 0.16287108f, 
    0.17925790f, 0.41192219f, -0.21604197f, -0.14068213f, 0.00065327f, 0.10191065f, 0.09623452f, -0.01162843f, 
    -0.11020278f, -0.33020824f, 0.31239188f, 0.12693822f, -0.03953387f, 0.13667624f, -0.15581253f, 0.29730874f, 
    -0.05679196f, -0.12386265f, 0.03718824f, 0.06833154f, 0.04451676f, 0.05784446f, -0.11258818f, -0.44995621f, 
    0.01434511f, 0.23433904f, 0.14563262f, -0.01557015f, -0.07385068f, 0.43316844f, -0.07846835f, -0.08692648f, 
    -0.23617680f, -0.22520454f, 0.11717897f, -0.03531611f, -0.04145690f, -0.21007672f, 0.16850251f, 0.15054756f, 
    -0.00381480f, 0.15985525f, -0.00611945f, 0.08938276f, 0.08474023f, 0.30361405f, -0.27786005f, 0.12316581f, 
    -0.08364753f, 0.15394105f, 0.10515532f, 0.03572670f, 0.17784658f, -0.11598748f, -0.01673775f, -0.16222878f, 
    0.02771522f, -0.03082883f, -0.10794971f, 0.38793933f, 0.01567735f, -0.15003023f, 0.14994583f, 0.22325763f, 
    0.14068669f, 0.13200574f, -0.24193037f, -0.46972889f, -0.04575678f, 0.00090301f, -0.15546609f, -0.09468437f, 
    0.00500673f, 0.29599795f, 0.25984237f, 0.28379989f, -0.07518364f, -0.06503904f, 0.28188437f, -0.48505843f, 
    0.17692125f, -0.14628154f, 0.18015794f, -0.13281170f, 0.11420942f, 0.16374756f, -0.14150690f, 0.46146595f, 
    -0.01938335f, -0.16008645f, -0.02038015f, -0.06031014f, 0.11081424f, -0.07734244f, -0.03546076f, 0.01935613f, 
    -0.00020237f, -0.24069126f, -0.31664276f, -0.30198380f, -0.45873484f, 0.31538314f, 0.13365291f, 0.03881313f, 
    0.08517531f, 0.10127420f, 0.28208807f, 0.08000856f, -0.06571262f, -0.18555285f, -0.22062203f, -0.66675621f, 
    0.05229648f, -0.19948803f, 0.12905712f, 0.09466385f, 0.16763921f, 0.10552071f, -0.03088834f, 0.45816916f, 
    -0.02280585f, 0.05526308f, 0.01030691f, -0.18032767f, -0.02131204f, -0.25643224f, -0.12135594f, -0.13914672f, 
    -0.08110987f, -0.48724189f, 0.06232699f, 0.32759896f, -0.06875419f, 0.00268377f, 0.18971011f, -0.05490192f, 
    0.13222161f, 0.12198339f, 0.14666463f, -0.09974986f, -0.10902345f, -0.15647992f, 0.28564268f, 0.05034122f, 
    -0.20225377f, 0.11027788f, 0.04282159f, -0.08098421f, -0.26889372f, -0.01952746f, 0.08285744f, 0.02354054f, 
    -0.17484409f, 0.18890101f, -0.05952271f, -0.09291171f, 0.06353243f, -0.09041476f, -0.04947452f, 0.39632848f, 
    0.12318888f, -0.07104885f, -0.29657871f, -0.33626842f, -0.00460027f, 0.20150363f, -0.02963294f, -0.16156679f, 
    -0.07526986f, 0.26710862f, 0.26992384f, 0.24453424f, 0.05607758f, 0.02834001f, 0.36953080f, 0.44091365f, 
    0.12211917f, -0.04755629f, -0.00984326f, -0.07558860f, -0.14319086f, 0.05887794f, -0.16273443f, 0.34629378f, 
    0.05704454f, -0.18471453f, 0.06167697f, -0.02580094f, -0.01005509f, -0.04783639f, -0.05788358f, -0.11853632f, 
    -0.30080935f, -0.11163302f, 0.40043956f, 0.17376719f, -0.08996855f, -0.20711993f, 0.21956694f, -0.12242539f, 
    -0.06697164f, 0.15473777f, -0.02325842f, 0.10220356f, 0.13675134f, 0.18559311f, -0.28944680f, -0.13266538f, 
    0.03050787f, 0.29169923f, -0.10121404f, -0.10098855f, 0.08497010f, 0.04694895f, -0.15261908f, -0.19068183f, 
    0.12425650f, 0.41458419f, 0.01327465f, 0.06457756f, -0.01387976f, -0.39101818f, -0.03487848f, 0.22435842f, 
    0.03345273f, 0.14572315f, 0.07437164f, -0.20142502f, 0.35710335f, -0.04884103f, 0.11333993f, -0.17384820f, 
    0.15571383f, 0.09067691f, 0.05694195f, -0.11863066f, 0.04231630f, 0.28830311f, -0.12007200f, -0.44073334f, 
    -0.04246177f, -0.18489458f, 0.05452110f, 0.15815488f, -0.17721590f, -0.14960566f, -0.01750158f, 0.07670974f, 
    0.06616925f, 0.21915662f, -0.11997438f, 0.38883099f, 0.10165919f, -0.08035578f, -0.06162883f, 0.24355572f, 
    0.16576214f, -0.10539435f, -0.14827675f, -0.09015411f, -0.16982773f, -0.10836283f, -0.07053475f, 0.07370626f, 
    -0.02517214f, -0.17928652f, -0.09310610f, 0.13705727f, 0.11507232f, 0.03064189f, -0.02513070f, -0.11248477f, 
    -0.01286701f, 0.08411758f, -0.16132724f, 0.10697308f, -0.04688951f, -0.09361888f, 0.08248854f, -0.23009793f, 
    0.11291872f, -0.15015374f, -0.15808830f, -0.12634124f, -0.03830255f, 0.16949454f, -0.14359532f, 0.12005313f, 
    -0.08469940f, -0.00543967f, -0.11280137f, 0.22155617f, 0.36315551f, 0.04657366f, 0.00460975f, -0.13804407f, 
    -0.16876118f, 0.13234091f, -0.14296176f, 0.06354677f, -0.15165420f, 0.29145026f, -0.22824605f, -0.41840687f, 
    0.07806948f, 0.01674095f, -0.09432800f, -0.00758632f, 0.30495122f, 0.06088500f, -0.07323532f, -0.18036577f, 
    -0.14451969f, -0.09054379f, 0.03930932f, 0.42142105f, 0.10423084f, 0.21517658f, 0.13948321f, 0.18100758f, 
    -0.19163793f, -0.30160874f, -0.13332948f, 0.23257014f, 0.09337370f, 0.02100004f, -0.23742531f, 0.04866954f, 
    -0.09476204f, 0.08635688f, -0.19769917f, 0.14935842f, -0.03659807f, 0.05499303f, -0.09624494f, 0.11608177f, 
    0.17791852f, 0.12076638f, -0.01743422f, -0.02182851f, -0.03828766f, -0.07823433f, -0.13764252f, -0.00923903f, 
    -0.15653846f, -0.12151086f, -0.03320953f, -0.06868625f, -0.16898692f, 0.28561887f, 0.05040596f, -0.01364642f, 
    -0.38968116f, -0.22474067f, 0.34943548f, 0.07113404f, -0.04949738f, 0.29243547f, -0.04575476f, 0.13120875f, 
    -0.06444331f, -0.00952845f, -0.01523036f, 0.18345672f, 0.09229792f, -0.09964468f, -0.17450409f, -0.36426404f, 
    0.04063370f, 0.37860230f, -0.06102697f, -0.17492290f, 0.38547733f, -0.12594017f, -0.00924997f, 0.07833663f, 
    -0.01144046f, 0.08564083f, -0.02273748f, -0.18431672f, -0.13649519f, -0.19120495f, -0.11393392f, 0.08102322f, 
    -0.16390270f, -0.07334258f, 0.00799593f, -0.02601948f, -0.25687605f, 0.29952413f, -0.13789803f, -0.12812169f, 
    -0.09516088f, -0.00098543f, 0.13505344f, 0.29485363f, 0.01065785f, -0.05914691f, 0.40136757f, 0.44638422f, 
    0.00877502f, 0.20321433f, -0.14615583f, -0.14718805f, 0.21552774f, 0.07429446f, -0.12674050f, 0.22643092f, 
    -0.05139373f, -0.09084265f, -0.00097734f, -0.22885001f, 0.17160217f, 0.27270782f, 0.17402855f, -0.06202366f, 
    0.11653730f, -0.35188493f, 0.17599167f, 0.34506708f, 0.12449360f, -0.12431884f, -0.25113103f, 0.05683806f, 
    0.02192424f, -0.18060008f, 0.15161894f, 0.20684993f, 0.13645416f, -0.03291526f, -0.01078045f, -0.14757155f, 
    -0.09988841f, -0.07473268f, 0.02909566f, 0.12176962f, -0.02516010f, -0.11658198f, -0.12351515f, -0.22450991f, 
    -0.04228391f, 0.18649454f, 0.13978487f, -0.33333373f, -0.17019315f, 0.20633462f, -0.12750955f, 0.08115692f, 
    0.23779465f, 0.19070630f, 0.27637056f, -0.02829788f, 0.35906383f, 0.02626529f, 0.02743864f, 0.14029741f, 
    0.12006878f, 0.02101249f, -0.30686411f, -0.08037064f, -0.06622542f, 0.21380174f, -0.13382299f, -0.03261240f, 
    -0.20239508f, -0.33086607f, -0.09362414f, -0.07222509f, 0.14889878f, -0.09818561f, 0.14574529f, 0.02089145f, 
    0.04098948f, -0.24370453f, -0.09830537f, 0.28922424f, -0.06416697f, 0.31137133f, -0.15175565f, -0.05782443f, 
    -0.11465357f, 0.12517901f, -0.13915080f, -0.06315459f, -0.06009910f, 0.33176154f, 0.28673169f, -0.17676066f, 
    -0.01229238f, -0.01236163f, -0.02584121f, 0.01702666f, -0.07777090f, -0.28775826f, -0.05925856f, 0.44373187f, 
    0.04223401f, -0.15053669f, -0.03304997f, 0.08371365f, 0.08203135f, -0.13330595f, 0.08153742f, 0.35693029f, 
    0.06957142f, 0.15570958f, -0.09174056f, -0.13258687f, -0.04903805f, 0.26497984f, -0.01115657f, -0.26958019f, 
    0.02843863f, -0.21023908f, -0.00748069f, -0.06469747f, -0.03395011f, 0.10196901f, -0.04667717f, 0.16084129f, 
    0.16878828f, 0.10717472f, -0.19182980f, 0.04740472f, 0.16221295f, -0.03159131f, -0.01225283f, -0.17084162f, 
    -0.21181691f, -0.18372549f, 0.06293406f, 0.15968455f, -0.09945682f, 0.11492526f, 0.10911234f, -0.03884599f, 
    -0.10588045f, -0.18485633f, 0.04274897f, -0.03695326f, -0.12121241f, 0.06045590f, 0.10697361f, -0.10590588f, 
    -0.04606831f, -0.02781422f, -0.08164793f, 0.10859539f, -0.32628945f, 0.17754544f, 0.11832120f, -0.15118414f, 
    -0.00396914f, 0.06462587f, 0.17436373f, -0.13315079f, 0.00455713f, -0.06085178f, -0.01906999f, 0.39608437f, 
    -0.06114186f, 0.39432564f, -0.03067032f, -0.07718173f, 0.03106479f, 0.05442412f, 0.00441246f, 0.00685844f, 
    -0.06427103f, 0.23022777f, -0.08884856f, -0.01306567f, 0.04210204f, 0.02111083f, 0.15455198f, 0.01599407f, 
    0.01507875f, 0.02643259f, -0.12598330f, -0.39411458f, 0.12086985f, -0.30631715f, -0.08724666f, 0.09760083f, 
    0.02500453f, 0.25644732f, 0.20525223f, 0.23465595f, -0.04023080f, -0.01644817f, 0.04943507f, -0.50475550f, 
    -0.17049465f, 0.12327941f, 0.10097963f, 0.11748917f, -0.11410063f, 0.06629549f, -0.00573842f, 0.43826061f, 
    0.09190857f, -0.06212933f, -0.13416460f, 0.23479187f, 0.14774032f, 0.01891789f, 0.07958123f, 0.29577455f, 
    0.12850024f, 0.41790366f, 0.14260189f, 0.05490324f, 0.05626877f, -0.03846765f, 0.24650794f, -0.03632054f, 
    -0.04679267f, 0.08594371f, -0.27092525f, -0.01577071f, -0.13032427f, 0.23479728f, -0.30089006f, -0.14651930f, 
    0.16927049f, -0.33543044f, 0.16765793f, 0.03423461f, 0.19360727f, -0.04449064f, -0.17127655f, -0.23092678f, 
    -0.03631221f, -0.19049339f, 0.12575030f, -0.07597838f, 0.07517240f, 0.14491469f, -0.16306488f, 0.08557592f, 
    0.03868937f, 0.00325029f, 0.11166076f, 0.26598427f, 0.25865787f, -0.18515755f, -0.11592505f, -0.14783287f, 
    -0.01538735f, 0.10116962f, 0.07683413f, -0.01625844f, 0.07092781f, 0.27323061f, -0.03261975f, -0.46515754f, 
    0.09539111f, -0.05901448f, 0.06716800f, 0.05376906f, 0.00229101f, -0.10546351f, -0.09554878f, -0.10266570f, 
    0.11258905f, 0.14014673f, 0.14660464f, 0.16606301f, 0.08551802f, -0.04102251f, 0.00560669f, 0.19113298f, 
    -0.22583528f, -0.00564342f, 0.40288860f, 0.02440363f, 0.08719157f, 0.05673212f, 0.10178175f, -0.13241756f, 
    -0.12770911f, 0.14364634f, -0.31384036f, -0.11498594f, -0.06665649f, 0.12049501f, -0.39717063f, -0.36589393f, 
    0.25962487f, 0.23462231f, -0.15210052f, 0.09519131f, 0.04180845f, 0.08864439f, 0.15204325f, -0.22674412f, 
    0.14384209f, 0.39062873f, -0.00775549f, -0.04319933f, -0.08506261f, -0.25095361f, -0.07656682f, 0.24443483f, 
    -0.13875706f, 0.26437289f, 0.10393328f, -0.11039519f, 0.19205129f, 0.04817348f, 0.20220517f, 0.05566890f, 
    0.09241426f, 0.06246782f, -0.34791368f, -0.03755002f, -0.02744425f, 0.23487033f, -0.37825564f, -0.25237775f, 
    0.34503597f, -0.02240248f, -0.08922411f, 0.08375023f, 0.15011933f, -0.03829673f, 0.09967306f, 0.00248119f, 
    0.01282886f, 0.03364754f, 0.11669275f, -0.00450145f, 0.12026819f, 0.11652106f, 0.01575309f, 0.01497525f, 
    -0.13710053f, -0.10060629f, -0.17460214f, -0.02940274f, 0.10997127f, 0.06744885f, -0.11746600f, 0.17584123f, 
    0.17553522f, -0.16203471f, -0.05121724f, -0.16414809f, -0.04377696f, 0.05000326f, 0.12770304f, 0.14281788f, 
    -0.03189676f, 0.01001540f, 0.03447985f, -0.02817730f, 0.04650230f, -0.11022918f, -0.14363556f, -0.11174655f, 
    -0.04140196f, -0.05792385f, -0.01638823f, 0.01978158f, -0.02269521f, 0.01664759f, 0.01632784f, -0.15688837f, 
    0.08830158f, 0.16399312f, -0.22893301f, -0.02767919f, -0.18968207f, 0.13604282f, 0.33531603f, -0.00644791f, 
    0.08524478f, 0.09740525f, -0.02047212f, 0.14146362f, -0.13216507f, -0.17076544f, -0.26944810f, 0.09609699f, 
    0.12832621f, 0.44164601f, 0.00536521f, 0.02342590f, -0.06764777f, 0.10132051f, -0.05553572f, 0.14642005f, 
    -0.10805239f, 0.24572127f, -0.15521301f, -0.07937855f, -0.03194301f, 0.25575626f, 0.12681188f, 0.03785131f, 
    0.20179924f, 0.11153232f, 0.07417090f, -0.13307923f, -0.01084567f, 0.30713809f, 0.23821841f, 0.02207776f, 
    0.10362454f, -0.25572190f, 0.18762679f, 0.15351819f, -0.09229710f, -0.30011091f, 0.12113902f, 0.40679598f, 
    0.08124867f, -0.18267095f, -0.18836887f, -0.00347339f, -0.21174371f, -0.14121693f, -0.03416009f, -0.12601636f, 
    0.10646941f, 0.15608658f, -0.16542709f, -0.13920045f, -0.18170872f, 0.30896434f, 0.11123765f, -0.10242832f, 
    -0.11299382f, -0.00112648f, 0.02753858f, -0.07613729f, 0.02516915f, 0.04684264f, 0.10790775f, -0.09186919f, 
    0.11585827f, -0.09984687f, -0.16607362f, 0.00313642f, -0.09373581f, -0.11041058f, -0.02140055f, -0.10865554f, 
    -0.05956260f, -0.04146205f, 0.07280162f, 0.12189271f, -0.10165999f, -0.11972484f, 0.02556503f, -0.10339288f, 
    0.12752439f, -0.15540691f, -0.11225370f, 0.06204644f, -0.12996621f, -0.17576781f, -0.13912997f, -0.02670643f, 
    0.03190744f, 0.24072014f, 0.03147268f, 0.24482356f, 0.25084338f, -0.12371045f, -0.09726121f, -0.06149573f, 
    0.10728735f, -0.13334499f, -0.05510353f, 0.28655079f, -0.09402128f, 0.30189297f, 0.05444698f, -0.49900043f, 
    0.07908345f, -0.09826925f, -0.16156471f, -0.10883664f, 0.17809471f, 0.02425659f, -0.03408836f, -0.12434044f, 
    -0.02072585f, -0.20369808f, -0.16780457f, 0.34598380f, -0.04122960f, 0.18133080f, -0.05605206f, 0.20451200f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00089217f, 0.01483260f, -0.07110783f, 0.07157346f, 0.21519119f, 0.21064933f, 0.30725214f, -0.11126659f, 
    -0.18219414f, 0.04452943f, 0.04235248f, 0.07518897f, -0.02835396f, -0.08668096f, 0.20475811f, -0.24979216f, 
    0.06941058f, -0.05583544f, 0.18910596f, 0.06201420f, -0.12773359f, 0.10872965f, -0.11020974f, 0.09315308f, 
    -0.00709704f, 0.02752211f, -0.23968199f, 0.20657887f, 0.29141864f, 0.24597393f, 0.14654692f, 0.10339192f, 
    0.13636906f, -0.12577383f, -0.04141867f, -0.13423851f, -0.06678367f, 0.06244982f, 0.02199628f, 0.35196352f, 
    -0.02504314f, 0.17714626f, -0.03995343f, 0.18410300f, -0.16275796f, -0.09801342f, -0.04795447f, -0.04617723f, 
    0.16593352f, 0.02127717f, -0.03775476f, -0.00425630f, -0.16665614f, 0.11980336f, 0.32736245f, -0.00427781f, 
    0.11411776f, 0.08820627f, 0.11463168f, -0.05488139f, 0.33815324f, -0.13932508f, -0.12393837f, 0.00056786f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.05620924f, 0.25465673f, 0.25775045f, 0.09315832f, 0.08457863f, -0.03859513f, -0.04015587f, -0.11839942f, 
    0.10818112f, -0.03074838f, -0.19648984f, 0.26031879f, -0.03502762f, 0.10715163f, -0.22457361f, 0.19293801f, 
    0.48688132f, 0.24513526f, 0.21678999f, -0.25991800f, 0.02082963f, 0.25453886f, -0.33042490f, 0.10636026f, 
    -0.15053754f, 0.16127461f, -0.05614438f, -0.01327086f, -0.03122548f, 0.13175440f, 0.11589880f, 0.10823111f, 
    -0.07438765f, -0.09537990f, 0.14426348f, -0.04276432f, -0.07942511f, 0.39529911f, -0.03938087f, -0.36916053f, 
    -0.13580829f, 0.16989291f, 0.33903977f, -0.14773737f, -0.03065303f, 0.04106048f, 0.17914799f, 0.37946606f, 
    0.21076970f, -0.29970437f, -0.27650174f, -0.02391875f, -0.08363375f, 0.27619681f, -0.05650106f, -0.23448975f, 
    -0.11751173f, 0.15012144f, -0.05240247f, -0.06445563f, 0.03594532f, 0.04598824f, -0.00605105f, -0.15152267f, 
    -0.03500716f, -0.35946190f, -0.21386786f, -0.09349419f, 0.00044576f, 0.04028581f, -0.42644960f, 0.21676834f, 
    -0.01080948f, 0.01242777f, 0.21466625f, 0.17663595f, 0.16541718f, 0.01219548f, -0.10223317f, 0.43148991f, 
    0.18427779f, 0.00232829f, -0.11201885f, 0.40690652f, 0.03097237f, 0.00100858f, 0.20430300f, 0.17845540f, 
    0.21117873f, 0.12529077f, 0.47035271f, -0.03429111f, -0.15113589f, 0.11273063f, 0.07117845f, 0.07743495f, 
    0.19073510f, 0.00887688f, -0.29138893f, -0.04594587f, 0.12052601f, 0.07664110f, -0.37586814f, -0.39353392f, 
    0.18950722f, -0.26670587f, 0.09661549f, 0.07216219f, 0.00624141f, -0.07385418f, -0.09438053f, -0.11638755f, 
    -0.19092357f, -0.29366541f, 0.50560474f, 0.05813143f, 0.11842846f, -0.17064947f, -0.57773215f, 0.35744098f, 
    0.09643858f, 0.04411710f, 0.07639932f, 0.00892423f, -0.14144765f, 0.17009567f, 0.11939523f, 0.01669108f, 
    0.05628996f, -0.05276807f, 0.08860345f, 0.12495176f, -0.00278834f, 0.16438293f, -0.04818066f, 0.35221562f, 
    0.07189880f, 0.07089686f, -0.17444889f, 0.18127440f, 0.05160497f, 0.34368494f, 0.34915426f, -0.51796144f, 
    -0.21649992f, -0.06420190f, 0.09212293f, -0.00253377f, -0.00911749f, -0.05016657f, 0.41184321f, -0.29133895f, 
    0.03321928f, 0.04389711f, -0.26911491f, -0.10514927f, 0.12223528f, -0.25068817f, 0.18436742f, 0.14415519f, 
    0.11687668f, -0.04424712f, 0.01785573f, -0.15717521f, 0.43010372f, -0.21416198f, 0.15264635f, -0.38151783f, 
    0.15598737f, 0.16548434f, 0.04264488f, -0.04167529f, -0.05300072f, 0.06056188f, -0.03083843f, -0.26800641f, 
    0.06226393f, 0.25082099f, -0.49514002f, 0.04651464f, 0.01365357f, 0.10169152f, -0.11064684f, 0.08433324f, 
    0.00711827f, 0.07413720f, -0.14357485f, -0.05654034f, 0.16986178f, 0.41595852f, -0.11899754f, -0.09863432f, 
    -0.05522157f, -0.12001780f, 0.12528813f, -0.02923369f, 0.04541324f, -0.10653150f, -0.21854870f, 0.03994676f, 
    0.05366470f, 0.04111277f, -0.26627094f, 0.11029106f, 0.17179340f, -0.16648994f, -0.05825968f, -0.04401439f, 
    -0.31778720f, -0.18173748f, 0.13714956f, -0.04185603f, -0.04357082f, 0.06265949f, -0.01316417f, -0.23902832f, 
    -0.04997803f, 0.14579310f, 0.01005155f, -0.22052434f, 0.05790035f, 0.17819169f, 0.02707507f, 0.23165782f, 
    0.15771897f, 0.00062773f, 0.03273628f, 0.52985275f, -0.33805048f, -0.19313642f, -0.18073143f, 0.16770071f, 
    0.34339309f, -0.03156196f, 0.17811204f, -0.18167034f, 0.01195691f, -0.10034928f, 0.45658714f, 0.31321725f, 
    0.09160783f, 0.71069068f, -0.07827117f, 0.02647352f, -0.15229025f, 0.19686654f, -0.32623419f, -0.07699507f, 
    0.29214180f, 0.16198631f, -0.27980965f, 0.06295933f, 0.00628020f, 0.12977327f, 0.07963097f, -0.06922961f, 
    0.05715954f, 0.08367624f, -0.09336749f, 0.12288357f, -0.03281882f, -0.14198822f, -0.09157427f, -0.05455911f, 
    -0.05859265f, 0.05940357f, 0.11418334f, -0.10076597f, -0.01742197f, -0.07008918f, 0.06102189f, 0.10304191f, 
    -0.01908486f, 0.03408643f, -0.05006280f, -0.04132254f, -0.04527873f, 0.00619109f, 0.00725780f, 0.05016521f, 
    0.00503550f, -0.00116526f, 0.00350460f, -0.04280531f, -0.12682931f, -0.01747372f, -0.01322882f, -0.02423108f, 
    -0.00563925f, -0.10435934f, -0.02611166f, -0.11291955f, -0.02336855f, -0.09680269f, 0.08545996f, -0.03224777f, 
    -0.00212583f, -0.00859185f, 0.03428849f, -0.09683299f, 0.03640953f, -0.02684739f, 0.11438602f, -0.13227464f, 
    -0.00338780f, 0.10884735f, -0.06725314f, 0.01513501f, -0.02209094f, -0.03969993f, 0.03615766f, -0.12307824f, 
    -0.04800425f, 0.09861010f, 0.03508146f, -0.00680226f, -0.04613006f, 0.08453985f, -0.11265561f, -0.14329924f, 
    -0.05343623f, -0.19830401f, -0.32715648f, -0.04638276f, -0.05677546f, 0.11687231f, 0.02677326f, 0.12132142f, 
    -0.10888138f, 0.06055177f, 0.28726000f, -0.01878385f, 0.11232962f, 0.03594154f, 0.31519234f, -0.46341193f, 
    -0.07089930f, 0.03244562f, -0.28080517f, 0.06194537f, -0.11224667f, -0.01014001f, -0.12921330f, 0.17741305f, 
    0.27432847f, 0.01149904f, -0.67103201f, 0.19406219f, 0.45981637f, -0.00989941f, -0.18799542f, -0.02016103f, 
    0.22787690f, 0.06890129f, -0.07731351f, 0.16146003f, 0.22360934f, 0.12494892f, 0.07984313f, -0.38731092f, 
    0.21454917f, 0.00009384f, -0.17190652f, 0.23264864f, -0.07026607f, 0.23256196f, -0.00386535f, -0.41133088f, 
    -0.10421243f, 0.22688644f, 0.25602290f, -0.28224334f, -0.15339279f, -0.21908128f, 0.22511014f, 0.26279408f, 
    0.14559445f, -0.08843168f, 0.25523630f, -0.04083768f, -0.04697585f, -0.02071816f, 0.00886004f, 0.25996366f, 
    -0.04624797f, 0.09324368f, 0.00571266f, -0.05206479f, 0.00249401f, -0.11611643f, 0.00526330f, 0.03519148f, 
    -0.12296674f, 0.00366338f, 0.06469637f, 0.06785517f, -0.14522423f, -0.09663177f, 0.07664000f, -0.18153125f, 
    0.05735515f, 0.03305672f, 0.03368864f, -0.05738736f, 0.02249649f, 0.00262942f, -0.08647059f, -0.10401588f, 
    -0.09600713f, 0.03633682f, -0.11331922f, -0.06040087f, 0.04832298f, -0.03234618f, -0.01749749f, -0.01528833f, 
    -0.06796011f, -0.08087273f, 0.04498759f, -0.01932872f, -0.00305096f, -0.10055949f, -0.07697205f, -0.17411384f, 
    0.00195219f, -0.04939137f, 0.04010465f, -0.02027640f, 0.00630891f, 0.06145716f, 0.03008429f, -0.13590215f, 
    0.10740045f, -0.02377112f, 0.04531980f, -0.14589421f, -0.11510924f, 0.10397325f, -0.05885649f, -0.12595476f, 
    -0.06001439f, -0.02559265f, -0.04320335f, 0.04662964f, -0.11738642f, 0.06346527f, -0.07263429f, 0.00906015f, 
    0.07232102f, -0.15865706f, 0.03559966f, -0.02813548f, -0.03421054f, 0.17659998f, 0.49262455f, -0.40735447f, 
    0.06274490f, 0.02376820f, -0.18604149f, -0.12438226f, -0.06965414f, -0.20161809f, -0.12642619f, 0.24218108f, 
    -0.04204871f, -0.15252623f, 0.26954168f, -0.16451497f, 0.09331426f, 0.26120460f, -0.04068096f, -0.20828240f, 
    0.22924873f, 0.01186337f, 0.08095840f, 0.27758110f, -0.11041876f, 0.38714749f, -0.21519601f, 0.13152671f, 
    0.01210649f, 0.00277010f, -0.11075281f, 0.34305653f, -0.16719727f, -0.07823977f, 0.23174037f, -0.03786441f, 
    -0.08067214f, 0.06983648f, 0.27254826f, -0.22789922f, 0.04299458f, 0.15341131f, 0.16081668f, 0.48661819f, 
    0.33648658f, 0.16696841f, -0.28998283f, -0.27619877f, -0.12646036f, 0.20750622f, 0.11544408f, 0.11528584f, 
    0.14410533f, 0.31722704f, -0.06241089f, -0.11617517f, 0.01915567f, -0.32412335f, 0.02216202f, 0.11485539f, 
    -0.12570436f, -0.09473875f, 0.10710718f, 0.08667773f, -0.04818974f, 0.00745617f, -0.00661873f, -0.00697345f, 
    -0.03871459f, -0.02925244f, -0.07643405f, 0.37788653f, 0.13612206f, 0.08299635f, -0.12285346f, 0.18713871f, 
    0.27780023f, 0.18376406f, 0.24113761f, -0.14669240f, -0.00943631f, 0.19388153f, -0.07953285f, -0.05837918f, 
    0.08378439f, -0.09900138f, 0.15012288f, 0.04595527f, 0.01486963f, 0.22676051f, -0.33173794f, 0.00662381f, 
    -0.09817915f, -0.02332645f, -0.00867346f, 0.23529330f, -0.23311184f, 0.23857173f, -0.08741316f, -0.10862294f, 
    -0.16314948f, -0.23946455f, 0.41262132f, -0.07870554f, 0.03092781f, 0.14831281f, 0.29275909f, 0.55934626f, 
    0.16236669f, 0.00709904f, -0.42302901f, -0.31470227f, 0.01666478f, 0.08004808f, -0.17422782f, -0.02699312f, 
    0.14879434f, 0.41749007f, 0.13721070f, 0.06886569f, -0.00622585f, -0.08666776f, -0.09031199f, 0.13880585f, 
    0.10885873f, -0.50251544f, -0.21910812f, 0.02555835f, 0.14727533f, -0.08722033f, -0.12024644f, -0.00350020f, 
    0.05601696f, -0.00831746f, -0.02791201f, -0.02182670f, 0.30098099f, -0.23898715f, 0.46862936f, -0.46743137f, 
    0.21508867f, -0.35586143f, 0.07255808f, 0.06744779f, -0.08395498f, 0.08384114f, 0.30792314f, 0.06945971f, 
    0.41532207f, 0.09345686f, -0.22875470f, 0.09346272f, 0.34579563f, 0.29718497f, -0.06933823f, 0.10204753f, 
    0.34445554f, 0.16585337f, -0.10216869f, 0.05857413f, 0.26737800f, 0.06658328f, -0.09213283f, -0.59173262f, 
    0.11898673f, -0.11548999f, -0.02746165f, 0.17262115f, -0.17427470f, 0.22995535f, -0.01938214f, 0.08909725f, 
    -0.04391183f, 0.27029303f, 0.02239254f, -0.28693449f, 0.06898620f, -0.04576385f, -0.10418573f, 0.27761197f, 
    0.38813069f, 0.12626353f, 0.10035899f, -0.02967015f, 0.04483154f, -0.05391673f, -0.04553887f, 0.41808665f, 
    0.03142412f, -0.03437340f, 0.12066580f, 0.08169881f, 0.04786718f, -0.11285017f, 0.02307886f, -0.00297102f, 
    -0.11393002f, 0.02419353f, -0.08246849f, -0.09486593f, -0.07865408f, -0.11842874f, 0.00017144f, 0.11997496f, 
    0.08816266f, -0.09995808f, 0.01436163f, -0.06814662f, -0.00417516f, 0.01695675f, 0.07166450f, -0.02435914f, 
    -0.02428403f, 0.06692509f, 0.06884938f, 0.01542786f, -0.05842689f, -0.08403936f, 0.09692112f, -0.06425406f, 
    -0.02296813f, 0.00081185f, -0.05508868f, -0.04276919f, -0.03217974f, 0.06152919f, 0.07467535f, -0.05312243f, 
    0.00506617f, -0.05986173f, -0.04589467f, -0.10184303f, 0.12149063f, -0.02875242f, -0.05502975f, -0.01413013f, 
    -0.08908315f, 0.03812851f, -0.08402549f, -0.01000004f, -0.09105256f, 0.12329073f, 0.12171380f, -0.04011057f, 
    -0.02724275f, -0.04596609f, -0.08209266f, -0.00516297f, -0.08274622f, 0.03921278f, -0.05882105f, 0.02663831f, 
    0.02855781f, 0.18353315f, -0.30685252f, -0.04826194f, 0.21396242f, -0.00183036f, -0.12784651f, 0.13220754f, 
    -0.02420142f, -0.02942994f, 0.34302390f, 0.01259793f, 0.07963645f, -0.02371439f, -0.35607016f, 0.22822788f, 
    0.11779355f, 0.13693450f, -0.24856418f, 0.22251171f, 0.03958274f, -0.22858080f, 0.03773988f, 0.16994341f, 
    0.24857129f, -0.26289821f, 0.57918936f, 0.02714858f, -0.04953873f, 0.33380941f, -0.30823883f, -0.00716232f, 
    -0.14297654f, 0.00178931f, -0.31607419f, 0.13975567f, 0.01085225f, 0.01864911f, -0.10467024f, -0.17990670f, 
    0.32185498f, 0.02326574f, -0.01899344f, -0.01843894f, -0.02542824f, 0.11256730f, 0.11986157f, -0.06034131f, 
    -0.02003514f, 0.18665817f, 0.43041819f, -0.08538377f, -0.06104039f, -0.15862794f, -0.13790916f, 0.23511004f, 
    0.12124299f, 0.15333021f, -0.04934966f, -0.11518316f, -0.12788379f, 0.14320637f, -0.08525182f, 0.18260735f, 
    -0.02462724f, 0.10529763f, -0.10898355f, 0.11296824f, -0.01080427f, 0.01664242f, -0.12388030f, 0.01821904f, 
    0.10951506f, 0.11487131f, 0.10241733f, -0.13853891f, -0.08816117f, -0.01778591f, 0.10995795f, 0.02418972f, 
    0.06786764f, -0.02111032f, 0.07626712f, 0.03462209f, -0.09791240f, -0.06791338f, -0.08469245f, 0.06187784f, 
    -0.00624932f, 0.03429930f, -0.01405774f, -0.04439418f, -0.02450649f, 0.07086142f, -0.09167229f, -0.09102344f, 
    -0.13614470f, -0.11030380f, -0.00971617f, -0.02226575f, 0.00975706f, -0.09254450f, 0.03358185f, -0.11728777f, 
    -0.05929930f, 0.09760274f, -0.05345436f, -0.05880461f, -0.02469797f, -0.03311494f, -0.10333812f, -0.00439418f, 
    -0.09277676f, 0.07341711f, -0.07540775f, 0.04558443f, 0.02805027f, -0.11943077f, -0.05566311f, 0.08900181f, 
    -0.03385246f, 0.03585448f, 0.09178493f, -0.02716660f, -0.02785672f, 0.06002506f, 0.07715596f, -0.08959271f, 
    -0.00630368f, 0.17346635f, 0.09610708f, -0.11530140f, 0.16604680f, 0.21063964f, 0.03800789f, 0.11788018f, 
    -0.05851732f, 0.05552499f, 0.13911022f, -0.19306172f, 0.12775192f, 0.28916779f, 0.14443035f, -0.12149072f, 
    -0.30301574f, 0.19818959f, 0.21502686f, 0.09391019f, 0.12706698f, -0.04809068f, -0.10383460f, -0.54345894f, 
    -0.13865621f, 0.26394269f, -0.01616581f, 0.25132319f, 0.08817432f, -0.44265038f, 0.18488528f, -0.04854233f, 
    0.33844522f, -0.09944822f, 0.33947003f, 0.53438336f, -0.21543580f, 0.08237421f, -0.06906727f, 0.46707833f, 
    0.34558466f, 0.05373813f, 0.21675926f, 0.08018690f, 0.08248843f, -0.04683834f, 0.07674008f, -0.02591142f, 
    -0.17776480f, 0.39111078f, -0.19323356f, -0.28393832f, -0.03153020f, 0.13695005f, 0.40008789f, -0.42428994f, 
    0.28512183f, 0.12793057f, -0.43285573f, -0.03498761f, 0.07103291f, -0.26495469f, -0.11918379f, -0.15016191f, 
    -0.07429318f, 0.17540807f, -0.02478499f, -0.04945524f, 0.11848852f, 0.18531083f, 0.19121993f, -0.17673799f, 
    0.08324710f, 0.08854908f, -0.35340190f, -0.34521261f, -0.37639654f, -0.38761425f, -0.11635191f, 0.10940360f, 
    0.26619911f, -0.04417377f, -0.04762817f, -0.58230954f, -0.05914193f, 0.32148281f, -0.41235849f, 0.19929706f, 
    -0.06945679f, 0.14159487f, 0.23562652f, 0.03159949f, 0.11246036f, 0.49404424f, -0.17900780f, 0.16403535f, 
    -0.16444282f, -0.02295887f, 0.15678142f, 0.07975717f, -0.16937080f, 0.05351590f, 0.18481410f, 0.31070969f, 
    -0.09840450f, 0.16495769f, -0.06104814f, -0.25472564f, 0.12061127f, 0.06129927f, -0.08139818f, 0.31805676f, 
    0.37893984f, 0.03698194f, -0.06086811f, -0.08766063f, 0.08911326f, 0.00623790f, 0.21928950f, -0.37102392f, 
    0.03325177f, -0.13984823f, -0.18228200f, 0.08494969f, 0.05817389f, -0.13403603f, -0.08256638f, 0.20238371f, 
    -0.04668887f, 0.09529924f, -0.24206033f, 0.05080456f, 0.06337171f, 0.18239440f, 0.32394773f, -0.47337368f, 
    -0.11261099f, 0.07273503f, 0.24911998f, -0.19978262f, 0.01362505f, -0.26604941f, 0.07949489f, 0.03137105f, 
    -0.09370859f, -0.17504226f, 0.24852622f, -0.05255246f, 0.06973229f, 0.11436919f, -0.62240613f, 0.15435266f, 
    -0.09198342f, 0.14976014f, -0.14028245f, -0.00584048f, 0.07678010f, 0.23451573f, -0.06021783f, 0.12716150f, 
    0.22793335f, 0.01180874f, -0.20497948f, 0.40076572f, 0.00478358f, 0.24596919f, -0.14019066f, 0.03136075f, 
    0.13498802f, -0.12309755f, 0.34048766f, -0.18673302f, 0.02285241f, 0.16151246f, 0.26894340f, 0.24869135f, 
    0.03785029f, -0.10679926f, 0.02414446f, -0.18228157f, -0.08736017f, 0.09962054f, -0.02996347f, -0.02137944f, 
    -0.02992882f, -0.06298742f, 0.01050334f, -0.09464150f, 0.21835504f, -0.37995473f, -0.02430101f, 0.00184011f, 
    0.00690917f, -0.43140253f, 0.01530972f, 0.03195477f, -0.23661301f, -0.11849317f, 0.05767028f, -0.14121746f, 
    -0.12880749f, -0.03993253f, 0.14820851f, -0.01316377f, 0.02490637f, -0.13013272f, 0.11580720f, -0.46444067f, 
    0.20815895f, -0.25060427f, -0.01248118f, -0.13090338f, 0.12506571f, 0.16786373f, 0.23540397f, 0.19080907f, 
    0.24457414f, 0.01423244f, -0.27996126f, -0.11574809f, 0.07096525f, 0.04189035f, -0.22482759f, -0.00691627f, 
    0.11517428f, -0.12240024f, -0.03656676f, -0.22717328f, 0.19647978f, 0.08395604f, 0.00067466f, -0.51362735f, 
    -0.36552757f, 0.03785356f, 0.08607174f, 0.17087686f, -0.04401811f, -0.01054630f, -0.24886429f, 0.04392844f, 
    0.15851669f, -0.16977546f, 0.14408100f, -0.00274510f, 0.09667867f, 0.01543021f, 0.00859458f, 0.19131997f, 
    0.14512299f, 0.09633097f, 0.20845653f, 0.10779488f, -0.05396914f, 0.07501397f, 0.04741557f, 0.13323423f, 
    0.04300632f, -0.27335677f, 0.27644894f, 0.01326853f, 0.10423825f, -0.10009558f, 0.00772341f, 0.13716988f, 
    0.10738387f, 0.02478078f, -0.02365081f, 0.30135298f, 0.21973749f, 0.24472870f, 0.66285998f, -0.22974537f, 
    -0.33278120f, -0.00720835f, 0.16672514f, -0.15328123f, -0.08502534f, 0.04476934f, 0.26677608f, 0.07044377f, 
    -0.14033905f, 0.17738521f, -0.21036668f, -0.18109994f, 0.12507454f, -0.19388229f, 0.43879905f, 0.22280759f, 
    0.37020016f, 0.13637386f, 0.06346220f, -0.13578255f, 0.46558332f, -0.08115862f, -0.13197115f, -0.11250501f, 
    0.01378341f, 0.01816440f, -0.16580273f, 0.06176920f, -0.06866832f, 0.05326372f, -0.17289285f, -0.40879732f, 
    0.08810344f, -0.00654349f, -0.14617442f, 0.48112488f, 0.05304220f, 0.11664482f, -0.08971588f, 0.10887340f, 
    -0.02738307f, -0.17969123f, 0.05312860f, -0.02707367f, 0.25126782f, 0.44377065f, 0.06571046f, 0.01060175f, 
    0.09565301f, -0.12187628f, 0.01585777f, 0.00696841f, -0.04087742f, -0.07115214f, -0.02999111f, -0.09844272f, 
    -0.07080875f, 0.03767757f, 0.00362472f, -0.04811114f, -0.06805988f, 0.07654093f, -0.03344594f, -0.08918481f, 
    -0.09160611f, -0.09419444f, -0.10973951f, -0.01049957f, 0.12014821f, -0.08546059f, 0.01599662f, -0.08254752f, 
    0.08138677f, 0.07620998f, -0.10207896f, 0.09378526f, -0.07426934f, -0.04001237f, 0.01364158f, 0.00728290f, 
    0.08842872f, 0.07950398f, -0.12124430f, 0.01717097f, -0.07584207f, 0.00125517f, -0.09232511f, 0.10193366f, 
    -0.12068653f, 0.08814332f, -0.04954349f, 0.09013790f, 0.08178030f, -0.03435256f, 0.09345271f, 0.07553430f, 
    0.04478881f, 0.04581353f, -0.10090600f, -0.01723367f, -0.07054865f, -0.06249741f, 0.04658674f, -0.05475132f, 
    0.04316533f, 0.06766231f, -0.06578283f, -0.01173592f, -0.02455431f, -0.11760943f, -0.07627422f, 0.05675606f, 
    0.01881971f, -0.18035999f, 0.14247890f, -0.04654065f, -0.06877231f, -0.18236952f, -0.18716469f, 0.19651829f, 
    0.07766730f, -0.06831148f, -0.02553204f, 0.48963311f, 0.33142459f, 0.15232518f, 0.49417505f, -0.19769081f, 
    0.27327684f, 0.09013025f, 0.21940541f, -0.09300937f, -0.04082337f, 0.20998177f, 0.25060520f, 0.25324565f, 
    0.08760364f, 0.16779785f, -0.12801614f, 0.06171563f, 0.00708236f, 0.09624062f, 0.09822174f, -0.02685107f, 
    0.32423031f, -0.05731341f, -0.15070078f, 0.28623465f, 0.17839999f, -0.07026611f, -0.06911050f, -0.06435214f, 
    -0.05655697f, -0.34923926f, 0.25146720f, 0.15537798f, -0.09824217f, 0.27233693f, -0.02852831f, 0.31691119f, 
    -0.02431734f, -0.11643863f, 0.06204914f, 0.08843837f, 0.00676436f, -0.05230670f, -0.30810595f, 0.23997726f, 
    0.04576396f, 0.41628808f, 0.52273309f, 0.11142657f, 0.11001758f, 0.15110941f, 0.10405761f, 0.25057703f, 
    0.06662787f, 0.08281280f, -0.04827430f, 0.05915724f, 0.00113594f, -0.01554394f, 0.22085373f, 0.09938200f, 
    -0.01847023f, 0.08811253f, 0.19198833f, 0.05087660f, -0.05469866f, -0.31983307f, -0.17478272f, 0.34787363f, 
    -0.04545534f, -0.01851623f, 0.00617921f, 0.20983827f, 0.04719094f, -0.02922018f, 0.36299682f, 0.09165113f, 
    0.33990330f, -0.24119107f, 0.46261817f, 0.17329763f, 0.05766884f, 0.16072311f, -0.25178900f, 0.06057815f, 
    -0.09305456f, 0.04329446f, -0.29959679f, 0.02249505f, -0.15961529f, -0.16690595f, 0.08041957f, 0.37376642f, 
    -0.14649211f, 0.14180553f, 0.08198930f, 0.17818339f, -0.12523741f, 0.06477915f, -0.12217960f, 0.01782730f, 
    -0.10291984f, 0.05618941f, 0.19202898f, 0.28398269f, -0.11409672f, -0.09450985f, -0.10959662f, 0.26891261f, 
    0.10958243f, 0.20155798f, 0.36977455f, 0.02253857f, -0.05508452f, 0.00496827f, 0.06862278f, 0.16742478f, 
    0.08125961f, 0.00096211f, 0.04143576f, 0.09701407f, -0.11567830f, -0.03347947f, -0.00087112f, -0.05142955f, 
    -0.06220533f, 0.04235481f, -0.00805648f, 0.12194359f, -0.05050686f, 0.10723270f, -0.02083884f, -0.07391702f, 
    -0.07787117f, -0.04477254f, -0.04043488f, -0.00335523f, 0.02910356f, -0.03739628f, 0.04185951f, -0.11315784f, 
    0.08877349f, 0.04665469f, 0.12103516f, 0.09366880f, -0.06729130f, -0.11009857f, -0.09511293f, -0.10526356f, 
    -0.02725714f, 0.05217503f, 0.05413342f, 0.11732447f, -0.01971482f, -0.03046367f, 0.01730734f, -0.02492674f, 
    -0.11424114f, -0.12142839f, -0.04962315f, -0.06058452f, -0.01985572f, -0.11805151f, -0.10620585f, 0.10178834f, 
    0.02222709f, -0.04316267f, 0.01742598f, 0.07688852f, -0.04093061f, -0.03753069f, -0.01693381f, 0.08522546f, 
    0.00371921f, -0.08525971f, 0.09096250f, -0.10191900f, -0.07511231f, -0.09593397f, -0.11569032f, -0.11246742f, 
    -0.10826972f, 0.21377814f, 0.00111041f, -0.02368487f, -0.03962714f, 0.10786047f, 0.17132306f, -0.00292773f, 
    -0.06697372f, -0.10359070f, -0.01593203f, -0.23207755f, -0.07939558f, 0.04913455f, 0.16826956f, 0.05461373f, 
    -0.17201591f, 0.19431122f, -0.07025883f, -0.03156077f, -0.05474019f, 0.06034124f, -0.37660691f, 0.12056400f, 
    -0.19106033f, 0.10890228f, -0.18989743f, 0.03883589f, 0.23811102f, -0.10771176f, 0.23152266f, 0.19085734f, 
    -0.00125017f, -0.04827312f, 0.21026647f, 0.06869008f, 0.01661823f, 0.07187399f, 0.19679175f, 0.93937099f, 
    -0.15154327f, 0.05328568f, -0.07534418f, 0.10308722f, -0.03796752f, 0.17699033f, -0.07550807f, -0.11020265f, 
    -0.06890713f, -0.09731825f, 0.00875444f, -0.13563740f, 0.03926364f, 0.07178566f, 0.33569396f, -0.16742781f, 
    0.05425771f, -0.27794719f, -0.12442874f, 0.10886727f, 0.23490015f, 0.02561196f, 0.07345141f, 0.11454809f, 
    0.06878443f, -0.01645326f, -0.17356622f, -0.09814455f, 0.01395638f, 0.07821023f, -0.15792426f, 0.05547194f, 
    -0.00165974f, -0.01091616f, -0.00981236f, -0.05488113f, -0.10971735f, 0.02269226f, -0.08348606f, -0.04343008f, 
    0.11844353f, -0.07566705f, -0.13375117f, 0.02092217f, -0.05388102f, -0.13083129f, 0.04097949f, 0.00121103f, 
    0.04350398f, -0.14297445f, -0.12221313f, 0.04737316f, -0.12944508f, -0.12059651f, 0.02439786f, -0.11853611f, 
    -0.03624542f, -0.01687613f, -0.12324712f, -0.01219921f, 0.06090632f, -0.13438396f, -0.10960212f, 0.09443173f, 
    0.06086076f, 0.04538540f, -0.06090933f, 0.04496159f, 0.00814717f, -0.10904177f, -0.10007660f, -0.02127104f, 
    -0.03623797f, 0.00520553f, -0.11079536f, 0.02659295f, -0.07127622f, 0.04570308f, -0.04484922f, 0.04554608f, 
    -0.01807903f, -0.10348400f, -0.06191701f, 0.11158554f, -0.01007935f, -0.04272904f, -0.04431996f, 0.00223059f, 
    0.00778475f, 0.08243365f, 0.30216387f, 0.07390161f, -0.10581410f, 0.19628999f, 0.28655130f, 0.09483333f, 
    0.09557161f, -0.08830290f, -0.00137797f, 0.29878113f, 0.20328189f, 0.13941266f, -0.06663354f, 0.42812747f, 
    -0.69131374f, -0.04928928f, 0.32324266f, 0.27224165f, 0.04309967f, 0.09336221f, 0.58001882f, -0.10436672f, 
    -0.11432487f, -0.14798753f, 0.42491430f, -0.11514252f, -0.23714919f, -0.10752529f, 0.21348122f, 0.27787021f, 
    -0.12759419f, 0.04771696f, -0.09753424f, -0.09202431f, 0.09816342f, -0.17330022f, 0.09199718f, 0.35905626f, 
    -0.21941331f, 0.09715638f, -0.18602946f, -0.23550715f, -0.05516691f, -0.22415920f, -0.02250994f, -0.16524233f, 
    0.14645086f, 0.18263173f, -0.13350673f, 0.37246898f, -0.00207638f, 0.06465266f, -0.28482282f, 0.28204051f, 
    -0.21707328f, -0.12873343f, 0.27905786f, -0.01334411f, 0.03003170f, 0.48974335f, 0.02616028f, -0.22336954f, 
    0.10876161f, 0.00041146f, 0.05174770f, 0.08532642f, -0.02548720f, 0.19979739f, 0.29254818f, 0.04151976f, 
    0.00454485f, 0.15117246f, 0.30045778f, 0.06496113f, 0.17656556f, 0.29250944f, -0.12257971f, 0.26644871f, 
    -0.31813690f, 0.15409166f, -0.05908685f, 0.27873626f, -0.09091724f, -0.09979322f, 0.39418253f, -0.07751860f, 
    0.13860323f, -0.11857883f, 0.54078180f, 0.20173858f, 0.02023861f, -0.14267620f, -0.12110452f, -0.12149142f, 
    -0.00631855f, -0.12511918f, -0.06806242f, -0.13865824f, -0.09263965f, 0.00379262f, 0.25149560f, 0.52984995f, 
    -0.19699147f, 0.13536708f, 0.15254208f, 0.20491728f, 0.01671280f, -0.04988339f, -0.06498805f, -0.11850401f, 
    -0.14499038f, -0.13976464f, 0.16729271f, 0.16088496f, -0.08373449f, 0.09874709f, 0.22197364f, 0.25435311f, 
    0.06090182f, 0.23386480f, 0.45227727f, -0.05243130f, 0.05570893f, -0.16566950f, 0.01537184f, 0.01533664f, 
    -0.07470140f, 0.06132885f, -0.16758755f, 0.02066579f, 0.20599759f, 0.11132512f, 0.52652353f, -0.40186271f, 
    -0.07283974f, -0.09241845f, 0.21867821f, -0.08742710f, -0.12443855f, -0.13867739f, -0.07718036f, 0.12480833f, 
    -0.31717488f, -0.12965487f, 0.09604575f, 0.18518698f, 0.10363657f, 0.01639075f, -0.11086924f, 0.20836216f, 
    0.17185959f, -0.14147352f, 0.15409259f, 0.37369281f, 0.15434866f, 0.26163670f, -0.04074131f, -0.03726228f, 
    -0.19961542f, 0.02312164f, -0.26801732f, -0.17891955f, -0.07290760f, 0.15869275f, 0.27952209f, 0.61293256f, 
    -0.17683047f, 0.19977984f, 0.12638849f, 0.08053008f, 0.02704093f, 0.19963136f, -0.11586741f, 0.02648717f, 
    -0.09694012f, -0.47942489f, -0.00603319f, -0.09189245f, 0.03886646f, -0.00493233f, 0.25368777f, 0.24051818f, 
    -0.01825844f, -0.02970304f, 0.24384749f, 0.09131038f, 0.13060977f, -0.26192045f, 0.05780044f, 0.20131440f, 
    0.08341469f, 0.25043559f, 0.03414194f, -0.07633780f, 0.21121715f, 0.19655100f, -0.12269025f, 0.10607767f, 
    -0.05468677f, 0.14333254f, -0.11614823f, -0.37103122f, -0.12859704f, 0.10755377f, 0.07209837f, -0.05171236f, 
    -0.26561603f, 0.04693203f, -0.06096321f, 0.17087674f, 0.06767616f, -0.02960640f, -0.20351212f, -0.06104333f, 
    -0.32949504f, 0.33173540f, 0.05445618f, -0.09270021f, 0.11680929f, -0.11411916f, 0.45877498f, 0.15712629f, 
    0.16505249f, 0.04430296f, 0.27383327f, -0.00840048f, 0.18216859f, -0.18567699f, 0.20195974f, 0.14374179f, 
    0.25095662f, 0.35030520f, -0.20850378f, 0.04415281f, -0.01888901f, -0.11738560f, -0.14686832f, -0.36223146f, 
    0.22290353f, 0.18766661f, 0.12202530f, 0.23025894f, -0.08329620f, 0.15159722f, 0.07853970f, -0.20474286f, 
    -0.07183804f, -0.63186979f, -0.41982144f, 0.05030707f, -0.00192722f, 0.19617946f, 0.08958630f, 0.03065400f, 
    0.09171686f, -0.04756593f, -0.09586362f, -0.08201373f, 0.03776532f, 0.16728428f, 0.01595200f, -0.07472557f, 
    0.04292075f, -0.02706499f, -0.19092172f, 0.09003948f, -0.03434042f, -0.31944376f, 0.06064041f, -0.05657172f, 
    0.14515620f, 0.01004775f, 0.17587014f, -0.35437208f, 0.04540171f, 0.36151397f, -0.57039875f, 0.23499551f, 
    0.03572292f, 0.03005221f, -0.34722599f, -0.10077714f, 0.22149959f, 0.43945450f, 0.00620688f, 0.24009968f, 
    -0.15075457f, 0.02315374f, -0.06490780f, -0.00639543f, 0.01780593f, 0.24990539f, 0.12628637f, -0.72562796f, 
    -0.13378775f, 0.20249160f, -0.02460268f, -0.21221526f, 0.00520005f, 0.11596429f, 0.07688637f, 0.34206408f, 
    0.16401872f, 0.03453138f, -0.22990747f, 0.07022844f, -0.02166412f, 0.16574520f, -0.06841601f, -0.08331010f, 
    -0.03362599f, 0.08464918f, -0.17901020f, -0.01076090f, 0.14025147f, 0.28051171f, -0.00082678f, 0.12557045f, 
    0.08295245f, 0.08646203f, -0.05790344f, 0.09088221f, 0.10379622f, -0.03363030f, -0.11361399f, -0.11093903f, 
    -0.04305986f, 0.09920822f, 0.06181691f, 0.11444209f, -0.09329011f, 0.09354542f, 0.00084622f, -0.05406758f, 
    0.05316694f, -0.10787147f, -0.11422907f, -0.08353291f, -0.02560090f, -0.09171088f, -0.09595518f, -0.12999390f, 
    0.02485969f, -0.07563207f, 0.10296571f, 0.10566608f, -0.03464425f, -0.04022205f, -0.04383575f, -0.09693891f, 
    0.11001409f, 0.10180436f, 0.08582354f, -0.05911654f, -0.09297241f, -0.11298568f, 0.01550479f, 0.01429131f, 
    0.01055601f, -0.05840439f, 0.02154328f, 0.08097864f, -0.00365110f, -0.13314679f, -0.12255768f, -0.04780009f, 
    0.10482092f, -0.00332947f, 0.06490529f, -0.01840387f, -0.04251651f, 0.05330988f, -0.09909986f, -0.10853504f, 
    -0.01481551f, 0.03325685f, -0.02690549f, -0.12242921f, -0.05668401f, 0.00249441f, 0.11130823f, -0.07432302f, 
    -0.03656089f, -0.03041034f, 0.38063854f, -0.10183443f, 0.10573877f, -0.09422886f, 0.10170844f, 0.20523560f, 
    0.14517906f, -0.06750387f, -0.11590476f, 0.41637954f, 0.27635276f, -0.05958362f, -0.11493894f, 0.32128131f, 
    -0.19718081f, 0.21171951f, 0.30795908f, 0.07469963f, 0.13022675f, 0.02569184f, 0.61944348f, 0.03580502f, 
    0.05454479f, -0.09679013f, 0.63407636f, -0.05348682f, -0.26935661f, -0.10253937f, 0.29683068f, 0.21953754f, 
    0.04259590f, 0.03134019f, 0.08736559f, 0.09441666f, -0.04433221f, -0.24230996f, -0.10643981f, 0.44287130f, 
    -0.08943801f, -0.01130562f, 0.01744101f, -0.11193235f, -0.00595307f, -0.14363439f, -0.22106758f, 0.15266359f, 
    0.02619775f, 0.07991751f, -0.01598371f, 0.46659198f, 0.06249301f, 0.19718926f, -0.48433605f, 0.15261990f, 
    -0.18263842f, 0.20828593f, 0.19238403f, -0.12245732f, 0.17588003f, 0.44054961f, 0.05157264f, -0.17692703f, 
    -0.06032765f, 0.09440000f, 0.19002868f, 0.02399686f, 0.01915975f, -0.16837052f, 0.09147187f, -0.00441469f, 
    0.07451876f, 0.03664520f, -0.35892218f, 0.17399782f, -0.30603230f, 0.12143698f, -0.02554522f, -0.06237179f, 
    -0.03532793f, 0.27244818f, 0.30813166f, -0.63501567f, -0.08638494f, 0.09860938f, -0.09085469f, -0.24449974f, 
    0.11140203f, -0.23070467f, -0.45557624f, 0.03524390f, -0.28853926f, 0.05690735f, -0.16467835f, 0.01538353f, 
    -0.57929701f, -0.04184107f, -0.05371536f, 0.60571843f, -0.29769996f, 0.07071061f, 0.03932792f, 0.79951972f, 
    -0.15931168f, 0.08105359f, 0.18298054f, -0.18914221f, 0.10566851f, -0.07948461f, 0.22974268f, 0.46292832f, 
    0.09446776f, 0.18653756f, 0.19456311f, 0.28348583f, 0.06722299f, 0.05795300f, -0.14020473f, -0.16021979f, 
    -0.14304346f, 0.29377133f, 0.34625190f, 0.00590478f, 0.00069891f, -0.03729907f, 0.12106666f, -0.25845182f, 
    0.02289782f, 0.09489934f, -0.09795749f, 0.07740454f, 0.04434879f, 0.13924055f, -0.03344514f, -0.14405546f, 
    0.02956256f, -0.07437309f, 0.00471147f, 0.36338803f, -0.01150410f, 0.28176665f, -0.11524044f, 0.22303806f, 
    0.15770245f, 0.05355584f, 0.14276515f, -0.03728505f, -0.11130098f, 0.02989668f, -0.12730482f, 0.12047488f, 
    0.03711911f, 0.07454147f, -0.06579075f, 0.19838750f, -0.02617623f, 0.09844439f, -0.08159612f, -0.11212475f, 
    0.07532504f, 0.06507041f, -0.11552770f, -0.01818771f, -0.17974842f, 0.33246443f, -0.16805997f, -0.12733792f, 
    -0.09242368f, -0.09278721f, 0.48612627f, -0.04972757f, -0.19372247f, 0.17000644f, -0.03956418f, 0.53835326f, 
    0.04571345f, -0.60227859f, -0.16968730f, -0.23883827f, -0.02826734f, 0.20861125f, -0.11263204f, -0.08390943f, 
    -0.02917672f, 0.54349083f, 0.30996507f, 0.09223783f, 0.01794096f, -0.28157410f, 0.09470655f, -0.13419290f, 
    -0.00198948f, -0.15272804f, -0.06120941f, 0.12391204f, -0.07996750f, -0.14202639f, 0.05057725f, 0.05837755f, 
    0.07535200f, 0.11834757f, -0.08559092f, 0.10120284f, -0.05725188f, 0.05500109f, -0.06174768f, 0.02585597f, 
    -0.00998930f, -0.08271053f, 0.10437904f, -0.07397155f, 0.09023708f, -0.09516238f, -0.07201792f, 0.06440566f, 
    0.03157700f, 0.07785471f, -0.11424647f, 0.06681808f, -0.03100955f, -0.04065441f, -0.04154451f, -0.09578662f, 
    0.09506531f, -0.06998315f, -0.08585003f, -0.10660425f, 0.05959547f, -0.11337773f, 0.07187887f, 0.08544875f, 
    -0.05754088f, 0.09625708f, -0.10799585f, -0.13286762f, 0.00647190f, -0.02691206f, -0.04209884f, -0.06679408f, 
    0.04808614f, -0.07547891f, -0.06940661f, -0.14791580f, -0.01485841f, -0.06116000f, 0.10239778f, -0.01762174f, 
    -0.10844082f, 0.03375489f, -0.11979026f, 0.10784394f, -0.09571874f, -0.05171448f, -0.11125088f, -0.04215213f, 
    -0.09089582f, -0.09448033f, -0.17196831f, -0.00185141f, 0.26925489f, 0.06649057f, 0.06042567f, -0.19824283f, 
    -0.08439382f, 0.01319443f, 0.46464056f, 0.05910435f, 0.21096954f, 0.37655199f, 0.27760667f, -0.37965429f, 
    -0.13038045f, 0.07330348f, -0.09919531f, 0.27373511f, 0.08460711f, 0.12228873f, -0.38319129f, -0.01168258f, 
    0.05399677f, 0.12896290f, -0.46159798f, 0.30532199f, 0.42112905f, 0.00124668f, -0.12456145f, -0.06872952f, 
    0.28212923f, -0.05167454f, 0.05896354f, 0.37665588f, -0.02832509f, 0.39174968f, -0.09445752f, -0.24952359f, 
    0.26461792f, -0.10104472f, 0.37106490f, 0.32110044f, -0.12494539f, 0.28303212f, 0.21155894f, -0.05898882f, 
    -0.14476514f, -0.16588536f, 0.12378908f, -0.41429472f, -0.08312850f, 0.04925712f, 0.24124783f, 0.03492504f, 
    0.20982625f, 0.17818841f, 0.02514880f, -0.00236337f, 0.06346334f, -0.18750180f, 0.00764689f, 0.06282923f, 
    -0.09770665f, -0.03607821f, -0.02751024f, -0.08482768f, -0.01129218f, -0.12101855f, -0.12825397f, -0.11014193f, 
    -0.02313000f, 0.04272443f, 0.05041197f, 0.01734858f, 0.05554826f, 0.09380333f, 0.04145645f, -0.01373071f, 
    -0.07100946f, -0.05578656f, -0.03136938f, 0.02883400f, 0.09121871f, 0.02020220f, -0.00056073f, -0.09915823f, 
    0.02393806f, -0.11038702f, -0.11320965f, -0.01511686f, -0.06710710f, -0.09046233f, -0.04637036f, -0.10269871f, 
    -0.14089887f, -0.00629658f, 0.02972704f, 0.06341855f, 0.03220294f, -0.02910446f, -0.10811293f, 0.01986526f, 
    -0.09936838f, 0.04268214f, 0.00797268f, -0.06754059f, 0.08140159f, -0.03275639f, -0.05944371f, 0.08509991f, 
    0.06060553f, -0.00815548f, -0.06555001f, 0.06216018f, 0.11160471f, -0.11292290f, -0.12834361f, 0.06984895f, 
    -0.13097641f, 0.01774341f, -0.02102874f, 0.11932738f, 0.02529444f, 0.07327068f, 0.02281746f, -0.02964942f, 
    -0.00630346f, 0.17824319f, -0.01734304f, 0.08437814f, 0.16053423f, 0.05700354f, 0.23261780f, -0.07152303f, 
    0.02286252f, 0.13022071f, 0.00978958f, 0.04861103f, -0.15858424f, 0.19874860f, -0.28803512f, 0.30082077f, 
    -0.25770122f, 0.33015934f, -0.03522596f, 0.23260973f, -0.07346061f, -0.19468522f, -0.10188627f, -0.30945364f, 
    0.13336036f, -0.14635107f, 0.28192502f, 0.45634347f, 0.11134887f, -0.01675379f, -0.29081467f, 0.05008360f, 
    -0.07590798f, -0.03401278f, 0.17367323f, 0.10694312f, -0.18423374f, 0.13586646f, 0.33637410f, 0.60653013f, 
    -0.27491403f, 0.06814210f, 0.35318068f, 0.35899287f, -0.08631220f, -0.02041505f, 0.23959398f, 0.28092191f, 
    -0.06527064f, 0.16481529f, -0.32117727f, -0.38254347f, -0.09426525f, 0.10178106f, 0.50501782f, -0.00527678f, 
    0.13241313f, 0.29447585f, 0.10367967f, 0.04733419f, 0.14632361f, -0.32215160f, 0.06261942f, -0.10307475f, 
    0.11362405f, 0.14279400f, 0.12585586f, 0.00393474f, -0.00427063f, 0.04759286f, -0.19962953f, 0.15196370f, 
    -0.06511759f, -0.07518595f, -0.02455371f, 0.13109006f, 0.06580899f, -0.23750877f, 0.34108084f, 0.10259536f, 
    -0.24922155f, -0.03835310f, 0.20791206f, -0.13819590f, 0.03541564f, 0.14061770f, 0.01957745f, -0.02243087f, 
    -0.22627540f, 0.03271725f, -0.37216485f, -0.27556309f, -0.19103546f, 0.07552985f, 0.14124817f, 0.11997289f, 
    -0.11714179f, 0.06321876f, 0.16351241f, 0.43557465f, 0.21646395f, -0.12145955f, -0.07105906f, 0.55010706f, 
    -0.04701994f, -0.02909140f, -0.03017060f, -0.17636065f, 0.17243698f, -0.06395920f, 0.13071832f, 0.23620176f, 
    0.19513930f, 0.35146365f, 0.37437525f, 0.55791694f, -0.05655849f, 0.11034719f, -0.42878810f, 0.07901604f, 
    -0.08592303f, -0.22368097f, -0.03846825f, 0.05700786f, 0.13230877f, 0.23960459f, -0.02392052f, -0.19333680f, 
    0.00944626f, -0.17984669f, -0.12845697f, -0.09760824f, -0.16091083f, -0.05531999f, 0.05788594f, 0.07402372f, 
    0.03324597f, -0.09784286f, -0.00869710f, 0.06181778f, 0.02754481f, -0.01313478f, -0.06924814f, 0.02222324f, 
    -0.07466524f, -0.12941268f, -0.14296965f, -0.08415738f, -0.08833894f, -0.06236733f, 0.06393703f, 0.08514123f, 
    0.03670610f, -0.10242951f, -0.09496740f, 0.00950278f, 0.01009942f, 0.04450382f, 0.04188484f, 0.01609400f, 
    0.05794066f, 0.06885815f, -0.13780202f, 0.09231088f, 0.03310529f, -0.11820586f, -0.15262584f, -0.01238222f, 
    0.02745511f, -0.14040369f, 0.01196269f, -0.04868361f, 0.03138319f, 0.00514140f, 0.05477228f, -0.00401953f, 
    -0.13605423f, -0.09741314f, 0.00813525f, -0.04268850f, -0.05099891f, 0.03266613f, 0.00991006f, -0.09136373f, 
    -0.01526023f, -0.02566290f, -0.07076983f, -0.00180422f, -0.05121162f, -0.02647947f, -0.04507177f, -0.13026379f, 
    0.07543016f, 0.08264862f, -0.00911313f, -0.07962883f, 0.16593379f, 0.19493383f, 0.03484434f, 0.03222655f, 
    0.08643589f, -0.11830274f, -0.14935467f, -0.19875886f, -0.13518696f, -0.06233737f, 0.28487650f, 0.01037498f, 
    0.02539568f, -0.21426105f, 0.08796698f, -0.04643756f, 0.05759881f, 0.28532952f, -0.11531147f, 0.10137386f, 
    -0.07613232f, 0.33240634f, -0.18026790f, 0.05137106f, 0.14697032f, -0.08771925f, 0.26713356f, -0.03037827f, 
    0.11733044f, 0.03249765f, 0.30724397f, -0.13970579f, 0.15953715f, -0.03346203f, 0.13524988f, -0.06291898f, 
    -0.00511321f, 0.32971346f, -0.23681089f, 0.09487596f, 0.11490238f, 0.14733477f, -0.17906381f, -0.27574679f, 
    0.10717542f, -0.03115121f, 0.18246825f, -0.24503863f, 0.03949866f, 0.12350564f, 0.16414681f, -0.04043389f, 
    0.08897451f, -0.46395731f, -0.28196627f, -0.05504252f, 0.11437063f, -0.06969643f, 0.01202823f, 0.20356967f, 
    0.05502211f, -0.15488096f, -0.25465417f, -0.03600672f, -0.00133435f, -0.12174828f, 0.13869143f, 0.21301235f, 
    -0.06430947f, -0.03229684f, 0.23807986f, -0.04046151f, 0.19383809f, -0.30993339f, 0.46334079f, -0.32379305f, 
    -0.03506748f, -0.15664209f, -0.21514863f, 0.17902200f, -0.08193475f, -0.01459489f, 0.01532391f, 0.46585977f, 
    0.36414763f, 0.12155958f, -0.32994172f, 0.11738932f, 0.39106533f, 0.18138447f, -0.02383201f, -0.07457671f, 
    0.13678864f, 0.09809060f, -0.25420511f, -0.01440488f, 0.21134506f, 0.07187605f, 0.14083265f, 0.10481098f, 
    -0.22675338f, 0.02200015f, -0.43963182f, 0.10193373f, 0.08133791f, 0.24086280f, 0.01100812f, -0.45321375f, 
    -0.09760889f, -0.01963708f, 0.35697633f, 0.13122092f, -0.08296780f, -0.29029962f, 0.03016314f, 0.15796696f, 
    0.12864079f, -0.22988540f, 0.37102205f, 0.04270230f, 0.08763706f, 0.12786536f, 0.03509468f, 0.24238230f, 
    0.08174782f, 0.10789887f, 0.10660496f, -0.10136470f, 0.08005986f, 0.19284716f, 0.37133679f, 0.07130572f, 
    -0.07063367f, 0.04364709f, 0.16215792f, 0.09780913f, 0.01228488f, 0.24382262f, -0.13326515f, 0.23178695f, 
    -0.29279825f, 0.10676403f, -0.01769560f, 0.10808018f, 0.11138966f, -0.06227555f, 0.21181685f, -0.41362751f, 
    0.34998813f, -0.19985355f, 0.33308500f, 0.17702380f, -0.08265381f, 0.09206969f, -0.21876964f, 0.00112569f, 
    -0.21322352f, -0.02371486f, -0.07154532f, -0.08906260f, -0.26406366f, 0.04666680f, 0.24032532f, 0.06576879f, 
    -0.20330489f, 0.10225462f, 0.03427891f, -0.00005717f, 0.07102142f, -0.04051355f, 0.19347759f, 0.10887838f, 
    0.13268676f, 0.52091008f, -0.33820847f, 0.04651694f, -0.15697321f, -0.01177868f, 0.07666600f, 0.02960632f, 
    0.19415548f, 0.23390545f, 0.01577137f, 0.07550647f, 0.13217640f, 0.01962834f, 0.00184196f, -0.05287370f, 
    0.03814024f, 0.06455221f, -0.01575164f, 0.01297471f, -0.12290709f, 0.11085407f, 0.07451689f, -0.09032234f, 
    0.05277282f, 0.04059938f, -0.12858552f, -0.07675634f, -0.10066973f, -0.00576355f, 0.07443163f, -0.06467018f, 
    -0.08486468f, -0.06898718f, 0.01098708f, 0.01705213f, 0.00982837f, -0.09646681f, -0.07408206f, 0.02907738f, 
    -0.07503477f, -0.07457184f, -0.01430611f, -0.08536915f, 0.03304844f, 0.07036363f, 0.08683015f, -0.00537023f, 
    -0.02148167f, 0.03102361f, 0.11665650f, -0.03998366f, 0.06523409f, -0.01536382f, -0.03034606f, 0.05069781f, 
    -0.08215215f, -0.10847546f, 0.10599883f, 0.01866393f, -0.08069840f, 0.06400821f, -0.02744555f, -0.00520131f, 
    0.01933761f, -0.09639770f, -0.04289433f, -0.08210948f, -0.09658388f, -0.11373883f, 0.02096551f, 0.08506006f, 
    0.01837052f, -0.09991798f, 0.01863586f, -0.11874098f, -0.07616582f, -0.06029003f, -0.05751048f, 0.00386472f, 
    -0.05526631f, -0.15210904f, -0.02182933f, 0.04749231f, -0.01167211f, 0.06526339f, 0.01255992f, -0.07446635f, 
    -0.08327003f, 0.02008350f, -0.09600665f, 0.09092230f, -0.07139564f, 0.11608616f, 0.03127450f, 0.06553198f, 
    -0.09855690f, 0.02026968f, -0.11531141f, 0.07903544f, 0.03534339f, -0.06961585f, -0.04554604f, -0.00858816f, 
    -0.10750639f, 0.01676994f, 0.06751437f, -0.10304609f, 0.05856394f, 0.09601490f, -0.06280615f, 0.00431705f, 
    -0.12450361f, 0.09362698f, 0.00304874f, -0.04664836f, -0.11873782f, -0.10316779f, -0.02388044f, -0.02464482f, 
    0.04136907f, -0.12601365f, 0.06019053f, -0.02109719f, 0.08938196f, 0.02781154f, -0.03450848f, -0.15040338f, 
    -0.07325704f, -0.11339661f, 0.01388925f, 0.00413359f, -0.01508181f, -0.05942513f, 0.02076721f, 0.09676226f, 
    0.13837063f, -0.10587633f, -0.08522457f, -0.01986901f, -0.09727323f, 0.07633192f, 0.02631804f, -0.04612994f, 
    0.12371307f, -0.17044546f, -0.29298341f, -0.11263557f, 0.15078829f, 0.20921372f, 0.14272009f, -0.20914201f, 
    0.02506974f, -0.06613476f, 0.20839721f, -0.04634750f, 0.16494383f, -0.35438439f, 0.14279975f, -0.05952846f, 
    0.18619581f, -0.11523792f, -0.01529459f, -0.01776687f, 0.06254562f, 0.18773374f, -0.13054094f, 0.20599258f, 
    0.16042891f, 0.12684542f, -0.13387109f, 0.18929487f, 0.05226952f, 0.39500418f, -0.17017762f, -0.12903219f, 
    0.10767608f, 0.16648152f, -0.17177966f, 0.12831242f, 0.10568546f, 0.28679782f, 0.02294246f, -0.07212713f, 
    0.03343516f, -0.09371217f, 0.26761076f, 0.09816117f, -0.03998586f, 0.26081765f, 0.13819277f, 0.13183418f, 
    0.01974868f, -0.26467162f, 0.10169654f, -0.05449164f, 0.08572899f, -0.11413563f, 0.19078794f, 0.20092356f, 
    0.25222740f, 0.06347132f, 0.17105789f, 0.07013023f, 0.10214695f, -0.32858232f, 0.02111958f, 0.27177551f, 
    -0.07352494f, -0.03400288f, 0.18120235f, 0.09816080f, 0.04550615f, 0.11914632f, -0.24528709f, 0.39859959f, 
    -0.02373831f, 0.04004611f, -0.01881057f, 0.41931099f, 0.36493370f, 0.28341061f, 0.20232306f, -0.12318276f, 
    -0.09429453f, 0.33970827f, 0.23880641f, 0.03998770f, -0.00615612f, -0.09924193f, 0.36313301f, -0.23037511f, 
    -0.26880595f, -0.00327420f, 0.02645697f, -0.00240109f, -0.03422888f, -0.37787780f, 0.36805287f, 0.12403677f, 
    0.40568471f, 0.00854301f, 0.29525703f, -0.08169132f, 0.17283811f, 0.11283231f, -0.18036519f, 0.15652777f, 
    0.05762376f, -0.21203159f, 0.21795392f, 0.11873049f, 0.05735282f, -0.14710553f, 0.12201922f, 0.04366187f, 
    -0.07118509f, -0.15061495f, -0.36698997f, 0.09070870f, -0.09595691f, 0.27839661f, -0.06337276f, 0.00914967f, 
    -0.09003297f, 0.30025801f, 0.13905340f, 0.07333478f, 0.14894167f, 0.24747445f, 0.08888547f, -0.09459106f, 
    -0.03193950f, -0.16258532f, 0.07094962f, 0.10788739f, -0.08235738f, 0.15019566f, 0.13583308f, -0.16443166f, 
    -0.11008728f, -0.02235651f, -0.08906064f, 0.09354836f, 0.02931954f, -0.25988322f, 0.14626540f, 0.19506182f, 
    0.30283654f, -0.15433286f, 0.13425554f, -0.12802726f, 0.11600072f, 0.26323289f, -0.19666259f, 0.29911381f, 
    -0.01540187f, 0.26237419f, -0.17567888f, 0.05231567f, -0.08491214f, 0.24698526f, -0.07389819f, 0.21569721f, 
    -0.11783185f, -0.03720963f, -0.06693388f, 0.00775854f, -0.03793855f, 0.08286458f, -0.01774330f, -0.50881618f, 
    -0.25123620f, 0.23586115f, -0.08273641f, -0.15556887f, -0.06320766f, -0.01150750f, 0.08323401f, 0.39049685f, 
    0.39523178f, -0.12196364f, -0.14410639f, 0.14851952f, -0.16539304f, 0.15318352f, -0.21976314f, 0.12441143f, 
    -0.14788404f, -0.00330007f, -0.05310465f, -0.00722599f, 0.19538730f, -0.00908198f, 0.10908440f, 0.07205631f, 
    -0.02126862f, 0.03910571f, -0.09810008f, 0.11363637f, 0.12357262f, -0.02793148f, 0.02703488f, 0.34158522f, 
    -0.09580217f, 0.13966915f, 0.24253421f, 0.28930211f, 0.12556188f, 0.11028867f, 0.21357854f, 0.06552935f, 
    -0.17407118f, 0.16831270f, -0.09941556f, 0.29508626f, 0.13038115f, -0.26345566f, 0.05533337f, -0.09889329f, 
    0.30515978f, -0.18340802f, 0.03089038f, 0.02153463f, 0.28147694f, 0.03613031f, -0.07888424f, -0.13716775f, 
    0.15511131f, -0.06078106f, -0.01644973f, 0.08895552f, -0.15634623f, 0.09975980f, -0.05399997f, 0.29574999f, 
    0.07017481f, -0.13636762f, 0.15098763f, 0.23832642f, -0.03275691f, 0.23379722f, 0.09448392f, -0.06620429f, 
    -0.25565821f, 0.22098871f, 0.40608728f, 0.12302189f, 0.03903632f, -0.22288096f, -0.00979097f, 0.33420435f, 
    0.23205237f, 0.39292946f, 0.37544903f, 0.00776114f, 0.06222945f, -0.05232320f, -0.07138741f, 0.20527124f, 
    -0.04178867f, 0.10947549f, 0.24656460f, 0.09293669f, 0.07005322f, 0.07383088f, -0.25038701f, 0.38576844f, 
    -0.03352743f, -0.06194616f, 0.15833436f, 0.22551113f, 0.40305668f, 0.41666922f, 0.21941236f, -0.19736075f, 
    -0.34927425f, 0.34148160f, 0.02869310f, 0.20932889f, 0.02772981f, -0.09385360f, 0.39381441f, 0.08920125f, 
    -0.12301446f, 0.09810931f, 0.21881765f, -0.29764673f, -0.10321917f, -0.43885928f, 0.46987396f, 0.23236127f, 
    0.30292624f, 0.04031634f, 0.08950970f, -0.27462837f, 0.34849772f, 0.02939576f, -0.18630780f, -0.12639071f, 
    0.32548726f, 0.11636923f, -0.11449214f, 0.24516886f, 0.05824449f, -0.02634690f, -0.02541922f, -0.31766349f, 
    -0.11716603f, -0.06910244f, 0.22610652f, 0.39694065f, 0.00698871f, 0.17217337f, -0.09590016f, -0.00297008f, 
    -0.03141512f, 0.03993992f, 0.07012077f, -0.05374273f, -0.00560908f, 0.54287535f, -0.11432773f, -0.16771625f, 
    -0.06804759f, -0.00057746f, -0.22751966f, 0.00279027f, -0.04263137f, 0.20460172f, 0.30656201f, -0.16985171f, 
    -0.00837367f, -0.11560906f, 0.15573178f, 0.08823143f, -0.06134531f, -0.02728138f, -0.14433378f, -0.30989340f, 
    0.26713601f, -0.14881013f, -0.17965052f, 0.00757854f, -0.08202852f, 0.04269091f, -0.09711948f, 0.21158452f, 
    0.37824574f, -0.15195630f, -0.34435794f, 0.18157536f, 0.00049749f, 0.36394984f, -0.39920101f, 0.00137509f, 
    -0.18426307f, -0.03663232f, -0.10130528f, -0.21404859f, 0.15286480f, 0.25007671f, 0.30419472f, -0.26837441f, 
    -0.00129083f, 0.07955672f, 0.20226915f, 0.10667246f, -0.04963394f, 0.13947546f, -0.20511535f, 0.13845524f, 
    0.19473484f, -0.14787424f, 0.03214977f, -0.21779732f, 0.02951458f, -0.14343292f, 0.26552695f, 0.11329856f, 
    -0.02212326f, 0.03277901f, 0.09382139f, -0.01953761f, -0.03595351f, -0.16453725f, 0.10484152f, 0.19954413f, 
    0.04266583f, 0.49959862f, 0.20506395f, 0.08517344f, 0.04496823f, 0.20612915f, 0.23576459f, 0.09514674f, 
    -0.05179030f, -0.09725544f, -0.18034524f, -0.14171679f, -0.10382804f, 0.17866565f, 0.03339349f, 0.41665539f, 
    0.02629079f, 0.11284776f, 0.03937989f, 0.04300840f, 0.01036204f, 0.01142165f, -0.17038552f, -0.03795840f, 
    -0.05744626f, 0.06688195f, 0.11289984f, 0.03051977f, 0.10791884f, -0.17717120f, 0.05699579f, 0.21081951f, 
    -0.15195648f, -0.07980934f, 0.28841850f, -0.20240495f, 0.09350315f, -0.03504854f, 0.32373103f, 0.77592367f, 
    -0.39581519f, 0.29537132f, -0.19185932f, 0.02296129f, 0.07916892f, -0.12462134f, -0.07543235f, -0.06332686f, 
    0.14927556f, -0.16854835f, -0.12571286f, 0.05947672f, 0.10052812f, -0.06056937f, 0.39540392f, -0.16151716f, 
    -0.22294724f, -0.28211907f, -0.13468657f, 0.02373903f, 0.17694493f, 0.14289923f, 0.10764419f, -0.03325541f, 
    0.08287012f, 0.15636402f, 0.21677291f, 0.06878589f, -0.07886940f, 0.18232816f, -0.12525636f, 0.02262774f, 
    -0.11369901f, -0.03334883f, -0.25369808f, 0.09968722f, -0.12401164f, -0.08481286f, 0.09824464f, 0.01954570f, 
    0.14955600f, 0.04844116f, 0.35040545f, -0.23247474f, 0.09240308f, 0.34691581f, -0.05202829f, 0.30230367f, 
    -0.24063565f, 0.24314786f, -0.00895074f, -0.04796444f, 0.00805532f, 0.28657556f, 0.27911103f, 0.20488796f, 
    -0.14607336f, 0.08344560f, 0.09143083f, -0.29420561f, 0.23558690f, 0.13074091f, -0.10074686f, -0.75114691f, 
    -0.04311821f, 0.24831747f, -0.11303962f, -0.30519128f, 0.13257642f, 0.12901621f, 0.01758010f, 0.06018272f, 
    0.40098929f, -0.01957159f, -0.17847279f, 0.36944538f, 0.03771771f, 0.29033253f, -0.18605548f, -0.03309750f, 
    -0.19340454f, -0.29466489f, -0.07345299f, -0.03414013f, 0.22071350f, 0.24892381f, -0.04198399f, 0.03314920f, 
    -0.05653078f, 0.20925991f, -0.21552992f, 0.01169753f, 0.29983470f, -0.00141656f, -0.08099238f, -0.15269376f, 
    0.06903813f, 0.01488217f, 0.33545655f, 0.03848905f, 0.23941991f, 0.11671241f, -0.10454939f, -0.19242023f, 
    -0.02316683f, 0.10549188f, -0.02625271f, 0.25853381f, -0.08580256f, -0.00018009f, -0.55876583f, -0.02832031f, 
    -0.02634245f, 0.13493291f, -0.08255050f, 0.05940197f, 0.17799005f, 0.00221838f, 0.02298676f, 0.07767425f, 
    0.24261652f, 0.09040438f, 0.03633163f, 0.65445518f, -0.26155367f, 0.60301369f, -0.14631237f, 0.13241117f, 
    0.30088854f, -0.11086362f, 0.48460421f, 0.15808176f, -0.03319756f, 0.16439839f, 0.43655750f, 0.08964963f, 
    -0.23732705f, 0.05857988f, 0.35909000f, -0.23673563f, -0.03662437f, 0.13438590f, 0.20031627f, 0.06251653f, 
    0.19997248f, 0.21949260f, 0.00454043f, -0.05593629f, 0.00938960f, -0.35530198f, 0.03072272f, -0.02585831f, 
    -0.06043996f, 0.00555661f, -0.01114202f, 0.05927695f, 0.06803846f, 0.16085432f, 0.21438582f, 0.27082351f, 
    0.08825540f, 0.00394754f, 0.50557643f, 0.09115935f, 0.32280228f, 0.25763792f, 0.21828017f, -0.43159583f, 
    -0.50239289f, -0.00821123f, -0.00928956f, 0.41938064f, 0.15390129f, -0.22350156f, 0.42856416f, -0.10244324f, 
    0.04141313f, -0.19492215f, -0.00643272f, 0.07895241f, 0.18217851f, -0.23681708f, 0.09828297f, -0.08103723f, 
    0.14470491f, -0.12185646f, -0.20112212f, 0.03301885f, 0.24144912f, 0.17495108f, 0.15066691f, -0.02529405f, 
    0.26575235f, 0.05601550f, 0.13308203f, 0.27524105f, -0.17554054f, -0.08646512f, 0.03302455f, -0.41140911f, 
    -0.27083322f, -0.01355387f, 0.12672564f, 0.03950736f, 0.09011340f, -0.06510177f, 0.20372440f, 0.39641517f, 
    0.14170732f, 0.19644071f, 0.09168634f, 0.05983539f, -0.07134809f, -0.01923150f, 0.02178539f, 0.05844811f, 
    -0.13889365f, 0.37889886f, 0.31517950f, -0.03524402f, 0.10470767f, 0.01381264f, 0.06556101f, 0.43019819f, 
    0.09135038f, -0.06569344f, -0.15846726f, 0.24737252f, -0.02273677f, 0.16373388f, 0.01987693f, 0.34222689f, 
    -0.23033869f, 0.44511557f, 0.18174674f, 0.12794037f, 0.10901589f, -0.15282843f, 0.43165529f, -0.06859130f, 
    -0.16358548f, -0.03402180f, 0.46942851f, 0.12823732f, -0.14051050f, -0.38608828f, 0.40201849f, 0.20640001f, 
    -0.13189344f, -0.03609006f, 0.31773919f, -0.27482626f, 0.10451140f, -0.06255044f, 0.04803765f, 0.50732130f, 
    -0.30665016f, 0.10041945f, -0.03460679f, -0.04471681f, 0.15551051f, -0.17666531f, -0.05318804f, -0.07771683f, 
    0.11151361f, -0.15311168f, 0.04618712f, 0.44855756f, 0.02579812f, 0.08003727f, 0.01418418f, -0.02059657f, 
    -0.15583551f, -0.11987586f, 0.04834103f, 0.10000859f, 0.14239173f, 0.47627714f, 0.04775153f, -0.06764835f, 
    -0.09245314f, -0.04246493f, 0.07536173f, -0.06049980f, -0.00612818f, 0.05161760f, -0.01696070f, -0.00815315f, 
    0.05393998f, -0.04177143f, -0.03418646f, 0.11757518f, -0.03824715f, -0.01306559f, -0.11884703f, 0.03581285f, 
    -0.12859964f, -0.08639531f, -0.09393483f, 0.02291639f, 0.09843390f, 0.05242205f, 0.07307430f, 0.06745000f, 
    -0.08004585f, -0.03393233f, -0.06750938f, 0.05944363f, 0.05481114f, -0.12246651f, -0.01309820f, -0.08369941f, 
    0.00365300f, -0.04259267f, -0.01597367f, -0.02904838f, 0.08266816f, 0.11633322f, 0.02316613f, 0.00774717f, 
    0.07014893f, -0.04649650f, -0.12330749f, 0.02816701f, -0.05828868f, 0.08069889f, -0.10473816f, -0.11227211f, 
    0.06924085f, -0.12020369f, -0.11583339f, 0.06272401f, -0.01569140f, -0.08939645f, -0.12444333f, -0.05375737f, 
    -0.07205532f, -0.05116761f, 0.06426730f, 0.04231808f, -0.10006366f, -0.10591842f, 0.10924147f, -0.06113721f, 
    -0.04588827f, 0.50042510f, 0.10059207f, -0.08901019f, 0.14624135f, 0.26331484f, 0.28742397f, 0.15798043f, 
    -0.03680243f, -0.02668035f, 0.00186021f, -0.04124211f, -0.25056151f, 0.13810545f, -0.21715233f, 0.40383437f, 
    0.00828040f, 0.45954609f, -0.09988723f, 0.10559668f, -0.12731875f, 0.02409649f, 0.05490163f, -0.05674995f, 
    0.13671167f, -0.15892388f, 0.35959584f, 0.14950195f, -0.12179180f, 0.10047556f, -0.08743548f, 0.20666060f, 
    -0.13499223f, -0.01631595f, 0.14300245f, -0.31434008f, -0.05519716f, -0.04987824f, 0.19039707f, 0.39649957f, 
    -0.29761285f, 0.45173866f, -0.12494482f, -0.02795781f, 0.16724245f, -0.12810297f, 0.00351970f, 0.13029912f, 
    0.24217820f, -0.13878758f, -0.21464245f, 0.19156647f, -0.05420671f, 0.05464999f, 0.30539826f, -0.17770621f, 
    -0.12997621f, 0.00895498f, -0.06046380f, 0.11285978f, 0.21175823f, 0.05419359f, -0.09902464f, -0.17829657f, 
    -0.06703907f, -0.04516365f, -0.04594069f, 0.09568071f, -0.08848154f, 0.17343087f, -0.01013622f, 0.32853270f, 
    -0.08422055f, 0.04088146f, -0.12409368f, -0.18669325f, -0.01253523f, -0.29471943f, 0.11157455f, -0.07215617f, 
    0.34474245f, -0.13318598f, -0.28163508f, -0.17088908f, -0.01139375f, 0.15040258f, 0.05018481f, 0.21028437f, 
    0.27432030f, 0.12018317f, -0.16066861f, -0.08090311f, 0.29526883f, 0.18466999f, -0.11242848f, 0.08301619f, 
    -0.01309507f, 0.13536206f, 0.11746493f, -0.20463021f, 0.15276057f, -0.17011324f, 0.34017202f, -0.32929778f, 
    -0.00704919f, 0.13890268f, -0.46236250f, 0.12372330f, 0.14930834f, 0.17440131f, -0.13306132f, -0.24746582f, 
    0.05312004f, 0.24669184f, 0.10989593f, -0.20084426f, 0.00279386f, -0.23192440f, 0.19696322f, -0.11313196f, 
    0.20569845f, -0.40332815f, -0.18076536f, -0.11090458f, -0.15678354f, 0.29057842f, 0.06310441f, 0.29636046f, 
    0.00344273f, 0.07941742f, -0.11443566f, -0.00151420f, -0.07719783f, 0.03739752f, 0.02511896f, 0.11087327f, 
    0.11256883f, 0.10304491f, 0.06531098f, -0.06932653f, -0.11135604f, 0.09031360f, 0.05286705f, -0.07280838f, 
    -0.01289112f, -0.03116039f, 0.01926189f, 0.05998447f, -0.00724284f, -0.05727196f, 0.09774727f, -0.10061973f, 
    -0.06360460f, 0.11302792f, 0.07395224f, -0.08874673f, 0.04194981f, -0.10709409f, 0.04599601f, -0.12752128f, 
    0.02613564f, -0.07664318f, 0.07131689f, 0.04207281f, 0.00069087f, -0.12272790f, -0.01942819f, 0.01225903f, 
    0.06858153f, -0.05478677f, -0.01135426f, -0.09274775f, -0.11772409f, -0.12857477f, -0.02934990f, -0.00263628f, 
    -0.12282521f, 0.06534586f, -0.04315835f, 0.03491988f, 0.06260522f, 0.08854380f, 0.08117753f, -0.07119772f, 
    -0.09806787f, -0.12971370f, 0.00521443f, -0.03480968f, 0.00982334f, -0.08287758f, 0.10328528f, 0.04883980f, 
    0.10011515f, -0.07913373f, 0.00194629f, -0.01533836f, -0.09076332f, -0.02272082f, -0.07110342f, 0.02353838f, 
    0.01398210f, -0.08251368f, -0.11580368f, 0.07908209f, 0.01661951f, 0.03787695f, 0.07064313f, -0.03259129f, 
    -0.12858963f, 0.09578691f, -0.00540265f, 0.00607743f, -0.02163649f, -0.03789637f, 0.03483929f, 0.06090870f, 
    0.08046030f, 0.08955336f, -0.16633078f, -0.08979513f, -0.11726043f, -0.02838113f, -0.08122643f, -0.10805713f, 
    0.04131657f, 0.02828248f, -0.11768530f, -0.08404163f, 0.02298714f, 0.03318172f, 0.08741332f, 0.05386307f, 
    -0.02008235f, 0.03411043f, -0.02533591f, 0.04518843f, -0.02707566f, -0.10363532f, -0.01522058f, -0.03934170f, 
    0.05272816f, -0.10432594f, -0.04498471f, -0.04825690f, -0.03425203f, 0.02334215f, 0.04234218f, -0.09836208f, 
    0.00970787f, -0.07243935f, 0.00831738f, -0.07907370f, -0.03258469f, -0.11070321f, 0.01168364f, -0.03899587f, 
    0.07865491f, 0.52945465f, 0.17680813f, 0.01190066f, 0.11257428f, 0.09266819f, 0.17550772f, 0.22283131f, 
    0.01381455f, -0.05503180f, -0.19329090f, 0.04943510f, -0.27283776f, 0.00598678f, -0.38072771f, 0.69228375f, 
    0.00520032f, 0.40721494f, 0.02310010f, 0.06837834f, -0.04608067f, 0.08097686f, 0.23154975f, -0.10687002f, 
    0.06855509f, -0.05373933f, 0.57610714f, 0.23097058f, -0.05331510f, -0.00435711f, 0.09249054f, 0.14035529f, 
    -0.29283226f, 0.04262040f, 0.30755889f, -0.17137352f, -0.01508532f, -0.21656838f, 0.30541199f, 0.65772033f, 
    -0.35618067f, 0.24040915f, -0.16086267f, -0.05020320f, 0.21555175f, -0.07859359f, -0.00185169f, 0.27440450f, 
    0.19198667f, -0.02427230f, 0.05524962f, 0.37814924f, -0.06526986f, 0.10838094f, 0.13629930f, -0.10185608f, 
    -0.17305373f, -0.14442952f, 0.06101809f, 0.01737798f, 0.08725870f, 0.18755957f, -0.09495427f, -0.09250689f, 
    -0.00328227f, 0.37333995f, -0.07984743f, 0.10461509f, 0.12222223f, 0.20969686f, 0.29430902f, 0.00029507f, 
    0.16310492f, 0.08985892f, 0.27761167f, 0.04799117f, -0.05948972f, 0.01549476f, -0.09357140f, 0.60243654f, 
    -0.19631337f, 0.08978926f, -0.08772875f, 0.42617175f, -0.07332624f, -0.12804161f, -0.29189989f, 0.22949301f, 
    -0.00977250f, -0.06820179f, 0.53164160f, 0.24316166f, 0.04537400f, -0.16003297f, 0.04196610f, -0.02720006f, 
    0.01698337f, 0.05477600f, 0.16095567f, -0.09423816f, -0.21196727f, 0.05180731f, 0.14591245f, 0.75786352f, 
    -0.06612752f, 0.12134506f, -0.11622220f, 0.16620874f, 0.11375127f, 0.05459127f, -0.00777037f, 0.00321424f, 
    -0.06704532f, -0.16942282f, 0.61353666f, 0.15607330f, -0.04513152f, -0.08475962f, 0.26086676f, 0.02952276f, 
    0.07100415f, 0.00019600f, 0.10564797f, 0.06839839f, 0.00382957f, 0.03439456f, 0.10371587f, -0.06694610f, 
    -0.02365199f, -0.04559216f, 0.03579605f, -0.02712227f, -0.01642494f, -0.08428521f, -0.14203291f, 0.04461709f, 
    -0.04209252f, 0.08138165f, -0.02438510f, 0.00455049f, 0.06974881f, 0.07703711f, -0.11928130f, -0.05429779f, 
    0.08424819f, -0.02711852f, 0.04720839f, 0.06656806f, -0.05742049f, -0.07940910f, -0.02807886f, 0.03621474f, 
    0.07474327f, 0.09616660f, 0.05131664f, -0.12716170f, -0.05511279f, -0.05539699f, -0.06588482f, -0.05983670f, 
    -0.09515578f, 0.10008158f, 0.02001422f, 0.03872196f, -0.10968852f, -0.11558305f, -0.07896276f, 0.00775161f, 
    0.03644766f, 0.00760282f, 0.00929115f, 0.02645694f, 0.00108859f, -0.08269335f, 0.00439955f, -0.12729079f, 
    -0.00608404f, -0.04033706f, 0.09121507f, -0.08839262f, -0.00349152f, -0.06623781f, -0.08510298f, -0.15247951f, 
    -0.05882444f, -0.05577625f, 0.01859810f, 0.09719966f, -0.04386405f, -0.00021747f, -0.01507621f, -0.05819613f, 
    0.00483310f, -0.06143098f, -0.04949584f, 0.09223305f, -0.01747094f, -0.05792131f, 0.07069579f, -0.08327746f, 
    0.00726502f, -0.09868874f, -0.00975497f, 0.01126485f, -0.07957058f, 0.06720357f, -0.02240119f, -0.02433712f, 
    0.09738195f, 0.05422467f, -0.13928035f, -0.04028814f, 0.05733804f, 0.02679537f, 0.05207593f, -0.03649560f, 
    0.10193834f, -0.07436793f, 0.12039462f, -0.08218358f, -0.03467238f, -0.08681650f, 0.05890974f, -0.09417176f, 
    -0.12984908f, 0.00558104f, 0.00337310f, -0.02507632f, -0.10804070f, -0.04905723f, -0.07640501f, 0.03619684f, 
    0.00815104f, -0.13928077f, 0.04822780f, -0.00799965f, 0.09290084f, -0.03886702f, -0.09711245f, 0.08989646f, 
    -0.06989186f, 0.03709179f, 0.00490579f, -0.04330663f, -0.06104577f, -0.14777313f, 0.01307223f, -0.07677936f, 
    -0.04091349f, 0.04745188f, -0.12026212f, -0.01755318f, 0.03360523f, 0.04813250f, -0.04358703f, 0.07953301f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.14546062f, -0.18130621f, 0.15272856f, 0.00845819f, -0.05692638f, 0.11803349f, -0.09231346f, 0.04827238f, 
    0.09336006f, 0.02580555f, -0.11525966f, -0.06845895f, 0.06815947f, 0.16743033f, 0.06980471f, 0.19286811f, 
    -0.04252990f, 0.20756361f, -0.05683990f, 0.03513768f, -0.04696301f, -0.00262891f, 0.22143200f, -0.10982002f, 
    0.20491523f, 0.15949614f, 0.05478654f, -0.02815479f, 0.09545410f, 0.07433030f, -0.17300808f, 0.21999641f, 
    0.08638040f, -0.02842635f, 0.25585267f, 0.03319783f, 0.27764529f, 0.08792054f, -0.03637353f, 0.01710732f, 
    0.04194769f, 0.09584553f, -0.08918253f, 0.00450403f, 0.04456961f, -0.09857133f, 0.06416923f, 0.00223285f, 
    -0.07946406f, 0.15326734f, 0.13200393f, 0.02241290f, -0.03928815f, 0.06012860f, -0.04262989f, -0.09562571f, 
    0.05481579f, -0.02984908f, -0.04847760f, -0.02613847f, -0.01981099f, -0.05796028f, 0.00653600f, -0.03405244f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.03353246f, -0.42102182f, 0.30630979f, -0.22335362f, 0.11308852f, 0.15735805f, -0.10734148f, -0.03055674f, 
    0.03582290f, -0.03565228f, 0.04051822f, -0.53760767f, 0.00759860f, 0.41513467f, -0.75421417f, -0.07902861f, 
    -0.26021367f, -0.00249609f, -0.09989834f, -0.00998885f, -0.19441102f, -0.07017757f, -0.00431264f, 0.01736729f, 
    -0.27113137f, 0.13255723f, -0.03430075f, -0.17607532f, -0.10999639f, -0.06193613f, -0.24040751f, -0.59538692f, 
    0.11003230f, -0.06274265f, 0.28942162f, -0.01334379f, 0.28521875f, -0.62446803f, -0.09247800f, -0.06422517f, 
    -0.21573815f, 0.18594113f, -0.10990559f, 0.05419811f, -0.06516095f, 0.39717612f, -0.19490789f, 0.08366698f, 
    0.02261080f, 0.03899759f, -0.05127525f, -0.21547002f, 0.15867521f, 0.27838078f, -0.02134454f, -0.13813893f, 
    0.00161020f, -0.20374461f, -0.01602230f, -0.03611965f, -0.18742912f, -0.08671740f, -0.11222650f, 0.07876707f, 
    0.15004349f, 0.29787508f, -0.03821393f, -0.25684217f, 0.02892143f, -0.42473406f, 0.10091107f, -0.18221793f, 
    -0.26817751f, -0.37638587f, -0.11711322f, 0.19501823f, 0.08216551f, 0.29696661f, -0.05376104f, 0.16339926f, 
    -0.25203046f, 0.15987705f, 0.05755760f, -0.18808517f, -0.41645625f, -0.10535485f, 0.15278293f, 0.03731688f, 
    0.01327931f, -0.02365391f, -0.06636766f, 0.37499884f, -0.05373363f, -0.11890105f, 0.05013224f, -0.49221635f, 
    0.07347810f, 0.09965653f, -0.02350185f, -0.00661150f, -0.15498374f, 0.05996458f, -0.08509113f, 0.15284148f, 
    -0.50418937f, -0.30611759f, -0.04400434f, 0.06531151f, -0.12793125f, 0.32961312f, -0.00643140f, -0.29177144f, 
    0.24534427f, -0.35556769f, 0.05573352f, 0.08132240f, 0.10775795f, -0.02696009f, 0.23134708f, 0.06705166f, 
    0.03041010f, -0.43279946f, 0.04770436f, -0.00166398f, -0.01174139f, 0.12800936f, -0.04176900f, -0.13514368f, 
    0.06281640f, -0.41368103f, 0.06157370f, 0.51320457f, -0.03131251f, -0.17906548f, -0.07655624f, 0.27822956f, 
    0.23968324f, 0.12220234f, -0.03157058f, -0.14330526f, -0.01259367f, 0.17563988f, 0.01917453f, 0.28185025f, 
    -0.09237009f, 0.10984533f, 0.04549833f, 0.23014414f, -0.33628392f, -0.07218282f, 0.02755733f, -0.02704476f, 
    -0.20748176f, -0.52976215f, -0.25222614f, -0.15540472f, 0.15104356f, -0.02509090f, 0.03038963f, -0.13630985f, 
    -0.00364180f, 0.10500032f, 0.03871361f, -0.09060454f, -0.27807665f, 0.09493351f, -0.13617723f, 0.06614091f, 
    -0.20234495f, -0.25287199f, -0.06938268f, 0.01349679f, -0.02737054f, 0.14368601f, 0.16765881f, -0.11487416f, 
    -0.23819849f, -0.38485703f, -0.18814617f, 0.10107420f, 0.11228067f, -0.37360841f, -0.38710660f, 0.02005735f, 
    -0.54565394f, -0.18177623f, -0.06934375f, -0.11981300f, -0.42302492f, -0.62329704f, -0.06795897f, 0.11165005f, 
    -0.47788376f, 0.21011065f, -0.13359754f, 0.05599162f, 0.03289160f, 0.26157796f, -0.14247365f, -0.22181539f, 
    -0.24909905f, 0.23344423f, 0.09905514f, -0.06511376f, -0.01598000f, -0.04593697f, -0.39886498f, -0.13490640f, 
    0.23490945f, 0.06354909f, 0.11455399f, 0.27413824f, 0.01540860f, -0.10668096f, -0.16501208f, 0.07495506f, 
    -0.58802134f, 0.10702758f, 0.02833684f, -0.19502367f, -0.28356224f, -0.12509191f, -0.26695490f, -0.09517807f, 
    -0.05919505f, 0.08582187f, 0.22114031f, -0.00353817f, -0.22796950f, -0.74958408f, -0.03567695f, 0.08768006f, 
    0.24245135f, -0.41343772f, 0.11800718f, -0.00297646f, 0.23306361f, -0.07619790f, -0.09881494f, 0.13964121f, 
    -0.00178682f, 0.16206133f, -0.43201423f, -0.29182595f, -0.04413056f, 0.13147515f, -0.51088697f, -0.05179051f, 
    -0.69249088f, 0.19558297f, -0.02970426f, 0.09112098f, -0.79499000f, -0.03501275f, -0.07123544f, -0.13600892f, 
    0.00621493f, -0.26918322f, -0.35467690f, -0.06429347f, -0.04119937f, 0.10903267f, -0.07773442f, 0.15905917f, 
    0.06810637f, -0.08560719f, 0.04143645f, 0.00481650f, -0.08033156f, -0.29251042f, -0.09048831f, 0.24610633f, 
    -0.00921697f, -0.40891838f, -0.02159502f, -0.15446883f, 0.09886692f, -0.07339816f, -0.09056336f, 0.05302067f, 
    -0.13320711f, 0.11781323f, 0.23411617f, -0.42786980f, 0.13873266f, -0.04734304f, -0.35162985f, -0.39328718f, 
    0.18288308f, -0.08271039f, 0.22939089f, -0.04109427f, 0.08792701f, -0.11021844f, -0.09555572f, -0.12791018f, 
    -0.00473166f, 0.17691304f, -0.11163016f, -0.04664584f, 0.14217488f, -0.43171126f, 0.06489773f, 0.01758221f, 
    -0.44042283f, 0.25586209f, -0.19369848f, -0.09955601f, 0.25494531f, 0.08318334f, -0.50393379f, -0.07640867f, 
    -0.03856413f, -0.18825769f, -0.06395295f, 0.02191967f, -0.19976312f, 0.09422997f, 0.04707875f, 0.04143004f, 
    -0.24352098f, -0.13229184f, 0.03378467f, -0.21509968f, -0.03932131f, -0.03376323f, -0.01289579f, 0.07480630f, 
    -0.45203525f, -0.23804627f, -0.06064206f, 0.08564688f, -0.02117583f, 0.14512530f, 0.09030291f, -0.06834041f, 
    -0.21981636f, -0.10148564f, 0.03581606f, -0.61652565f, 0.06000840f, -0.04610491f, 0.13989048f, 0.03980704f, 
    0.26057175f, 0.21949311f, 0.19108529f, 0.31049883f, -0.17148866f, 0.02340795f, -0.08771396f, 0.31218085f, 
    -0.38647750f, 0.06399945f, -0.22667852f, -0.04135804f, 0.19026959f, 0.10912074f, 0.06028413f, 0.14450385f, 
    -0.03355417f, 0.24595270f, 0.08108283f, 0.07730503f, -0.12327104f, -0.26285461f, -0.06964890f, -0.13667412f, 
    -0.26341537f, -0.04047792f, 0.19160719f, -0.15026297f, -0.28660187f, 0.13529286f, 0.15011744f, 0.01768196f, 
    0.21644081f, 0.13900030f, -0.03537763f, 0.12059289f, 0.21720344f, 0.23640126f, -0.01749068f, -0.03114915f, 
    0.20501012f, -0.27322504f, 0.04264018f, -0.61210984f, 0.03014275f, -0.03117928f, -0.01615425f, 0.19516236f, 
    0.02116633f, 0.04621564f, -0.00691444f, -0.55843592f, 0.06589925f, -0.12448013f, 0.44460911f, 0.07579194f, 
    0.19052392f, -0.18115821f, 0.05680226f, -0.29207456f, -0.34957194f, 0.03787686f, 0.06374227f, -0.08882028f, 
    -0.58503914f, -0.21273930f, 0.03428980f, 0.25742468f, 0.28341687f, -0.05178653f, -0.70909923f, -0.52617019f, 
    -0.02897682f, -0.10927454f, -0.04950706f, -0.10130822f, -0.04520392f, -0.33111629f, 0.04193623f, 0.25788543f, 
    -0.21724707f, 0.00468813f, 0.12500559f, 0.00781279f, 0.10634010f, -0.42370909f, 0.15910207f, -0.62665772f, 
    -0.49982691f, 0.27959362f, 0.07020418f, 0.22005266f, -0.19069190f, -0.34476009f, -0.27272248f, 0.02507851f, 
    0.15357220f, 0.43931222f, 0.06650817f, -0.00132387f, 0.02411068f, -0.17437269f, -0.06688807f, -0.13857631f, 
    -0.16243532f, 0.22817290f, -0.19977070f, 0.31097099f, 0.03565451f, -0.10382926f, -0.00392217f, -0.20717286f, 
    0.02395272f, 0.05228893f, -0.01072493f, 0.39416409f, -0.09960632f, 0.20736016f, 0.39575747f, -0.39346859f, 
    -0.01026128f, -0.42836186f, 0.03453556f, 0.04608894f, 0.17885107f, -0.05033936f, -0.51564282f, -0.03281917f, 
    -0.19039805f, 0.10248648f, -0.11663846f, 0.16354127f, -0.38687611f, -0.06866302f, 0.22416449f, 0.19541931f, 
    -0.05942061f, 0.10258510f, -0.01044655f, -0.10595609f, 0.05225950f, -0.09833568f, -0.02309635f, -0.46005452f, 
    -0.06044104f, 0.07812547f, 0.03847066f, -0.08704051f, -0.01303869f, 0.04405860f, -0.46571109f, 0.23855522f, 
    0.18898320f, -0.11609992f, -0.39763495f, -0.44560689f, 0.10073193f, 0.14609519f, 0.00613851f, -0.09420989f, 
    -0.12341961f, -0.12795635f, -0.03187482f, 0.03927713f, -0.05007657f, 0.10398567f, -0.10536198f, 0.07543987f, 
    0.16213825f, -0.42161629f, 0.23578797f, 0.06068277f, -0.03619459f, -0.33749175f, -0.01279532f, -0.16504072f, 
    -0.16488238f, -0.51438582f, -0.07472013f, -0.25867417f, -0.08354571f, -0.34598589f, -0.40923458f, -0.27809829f, 
    0.07993504f, 0.13585049f, 0.07986650f, -0.18541776f, -0.20418979f, -0.05481221f, -0.16993141f, 0.06339526f, 
    0.43673429f, -0.15909553f, -0.58048767f, 0.24696475f, 0.04066159f, -0.04625002f, 0.31112468f, -0.00089462f, 
    -0.25899872f, 0.01414872f, -0.80153531f, 0.03193553f, -0.42661649f, 0.32408249f, 0.07678078f, -0.02129038f, 
    -0.48113099f, 0.08129186f, -0.01934651f, -0.02820726f, -0.68544841f, 0.22178784f, 0.10640749f, -0.28391698f, 
    0.36349827f, -0.29894960f, 0.04670057f, 0.24461366f, -0.68077803f, -0.14307140f, 0.28546870f, -0.04442310f, 
    0.20197132f, -0.08046965f, -0.06280011f, -0.10331007f, 0.20376977f, -0.22169541f, 0.02223634f, -0.08135843f, 
    0.17379606f, 0.03614964f, -0.34654456f, -0.17722189f, -0.07316306f, -0.26714283f, 0.09439892f, 0.07977111f, 
    0.25759041f, -0.29121020f, 0.01641124f, -0.16539675f, 0.04496622f, -0.23976597f, -0.00127403f, -0.04566310f, 
    -0.69198853f, -0.30409878f, 0.05534653f, 0.06038481f, 0.09819409f, -0.12214747f, 0.04404413f, -0.06664483f, 
    -0.18918337f, 0.09287107f, 0.05366305f, -0.72729719f, 0.04415454f, 0.00390942f, 0.04396398f, 0.70552212f, 
    0.25060150f, 0.04990733f, -0.11990298f, -0.06979722f, 0.20998985f, 0.06334930f, 0.07481084f, -0.17738593f, 
    -0.23701409f, 0.12588163f, -0.00246567f, -0.01606561f, -0.07509837f, 0.00313771f, 0.06711508f, 0.00873499f, 
    -0.32829979f, -0.01324481f, 0.08199800f, -0.03758615f, -0.08808490f, -0.26662320f, 0.10361390f, 0.05167156f, 
    0.19815677f, -0.11573010f, -0.01373727f, 0.06581482f, 0.21014944f, 0.13167116f, 0.11197406f, -0.00838320f, 
    -0.23813896f, -0.04611952f, 0.17265466f, -0.05128933f, -0.11889527f, 0.23340663f, -0.05965689f, -0.59194368f, 
    -0.55316108f, 0.01153335f, -0.04652353f, 0.03175978f, -0.03748987f, -0.29977253f, -0.33594877f, -0.15641735f, 
    -0.04840732f, 0.30176497f, -0.09536394f, 0.06732495f, -0.08422426f, 0.08712065f, 0.16883728f, -0.12332924f, 
    -0.21208090f, -0.12996440f, -0.06639515f, 0.29814729f, 0.11928048f, -0.04909215f, -0.10927155f, -0.25133309f, 
    -0.60479701f, 0.11397067f, 0.02426190f, 0.01727452f, -0.39529231f, 0.20849238f, -0.09595285f, 0.11389337f, 
    0.22716461f, -0.42190719f, 0.10609524f, 0.03094758f, -0.14791429f, -0.00119110f, -0.06163190f, 0.08396459f, 
    0.28743729f, -0.12997143f, 0.03836348f, 0.04666384f, -0.15410389f, 0.09953278f, 0.09327397f, 0.08042697f, 
    -0.24137142f, 0.35577226f, 0.02173681f, 0.06125762f, -0.24798138f, -0.00641206f, 0.11065096f, -0.00112207f, 
    -0.03180782f, -0.05183064f, 0.25073686f, -0.34498626f, -0.04550544f, -0.14063293f, -0.11470214f, 0.11515322f, 
    0.12770492f, 0.12972322f, -0.08807147f, -0.38701895f, 0.05697001f, -0.83703464f, -0.48081455f, -0.03547837f, 
    0.12681833f, 0.21514046f, 0.08493976f, 0.25809136f, 0.04766398f, -0.10319445f, -0.24553211f, -0.02600784f, 
    0.31248286f, 0.06665390f, 0.05104841f, -0.48329285f, 0.07735014f, 0.05208961f, 0.37084156f, -0.28599161f, 
    0.09467497f, -0.05834723f, -0.19771008f, -0.15758334f, -0.25365198f, -0.06476418f, -0.10094048f, -0.12267745f, 
    -0.11226564f, 0.06019425f, 0.11013805f, 0.08867528f, 0.00738141f, 0.15990676f, 0.11806561f, -0.12876773f, 
    -0.01374830f, 0.02639495f, -0.17745019f, 0.09273166f, -0.49242580f, 0.04179814f, 0.05506732f, 0.03276847f, 
    -0.11803709f, -0.23010832f, 0.01175934f, -0.01122678f, -0.16606937f, -0.25881755f, 0.01896349f, 0.03098746f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.02887213f, -0.08884428f, 0.06626321f, -0.12470726f, -0.00294141f, 0.14953621f, 0.09076729f, -0.09468216f, 
    0.00544125f, 0.06634443f, 0.10722389f, -0.00924748f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
