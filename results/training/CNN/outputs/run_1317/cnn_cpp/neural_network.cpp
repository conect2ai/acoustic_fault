#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.91730994f, -0.06099579f, -1.08443284f, -1.55258179f, -1.57047284f, 0.50172776f, 0.58134109f, 0.67753947f, 
    0.04487232f, -0.19741781f, -0.01421134f, 0.05581329f, 0.01818019f, -0.09145237f, 0.14703076f, 0.27934638f, 
    -0.03691609f, -0.14665106f, -0.20161648f, 0.13604546f, -0.04769427f, -0.47353646f, -0.15689936f, -0.22419196f, 
    -0.48600352f, -0.08498934f, -1.73962641f, -0.13827805f, 0.28895536f, 1.23049176f, 0.79803550f, -0.30928832f, 
    -0.10784487f, -0.35323521f, 0.12279711f, -0.38652515f, -0.53813338f, 0.31953827f, -0.64914203f, 0.03373577f, 
    0.15546121f, -0.32403764f, -0.37900347f, -0.21395884f, -0.48054305f, -0.16519807f, -0.01492590f, -0.77052987f, 
    -0.30241024f, -0.44294870f, 0.70068419f, 0.45774472f, 0.66650784f, 0.42940539f, 0.51855785f, -0.34786502f, 
    -0.35179502f, -0.72073150f, -0.56963223f, 0.47697872f, -0.28197467f, -0.07927390f, -0.23855464f, -0.10046433f, 
    -0.20447260f, -0.27963781f, -0.39208275f, 0.05117594f, 0.44707516f, -0.17588575f, 0.12068898f, -0.42789194f, 
    -0.07556691f, -0.18029742f, 0.28264776f, -0.63708556f, 0.60025382f, -0.61188370f, -1.34873700f, -0.31695250f, 
    0.77184796f, 0.00426784f, -1.14580083f, -1.04182363f, 0.58348662f, -0.06950649f, -0.03795971f, 0.44927496f, 
    0.62867039f, 0.57612777f, -0.00008332f, -0.27051482f, -0.04226965f, -0.47757825f, -0.60990858f, -0.00142492f, 
    0.45136720f, -0.25538620f, -0.07237649f, 0.62105620f, -1.28228879f, -0.93810320f, -0.75079703f, -0.88811541f, 
    -0.87099278f, -0.25250232f, -0.80374712f, -0.98331010f, -1.25912285f, -0.90546328f, -0.73110336f, 0.01619097f, 
    0.00013009f, -0.67288333f, -0.52265334f, 0.21391258f, -0.11843328f, -0.23173161f, 0.32571757f, -0.12347030f, 
    -0.16511966f, 0.24656461f, 0.12098528f, -0.24044548f, 0.28171062f, -0.23867492f, 1.22550440f, 0.05523635f, 
    -0.50852954f, 0.37664965f, -0.28633252f, -0.41884017f, -0.01824014f, 0.29310143f, -0.74627531f, -0.07629531f, 
    0.50683773f, -0.04800619f, -0.01670455f, -0.41417259f, -0.07272243f, 0.03512695f, 0.42437008f, 0.36454886f, 
    -0.01229336f, 0.29158023f, 0.12696777f, -0.51504326f, -0.02536413f, -0.04465928f, -1.04265916f, -0.40023687f, 
    0.41214129f, 0.53422779f, 0.50387597f, -0.25211141f, -0.85985357f, -0.41970858f, -0.30023503f, -0.19233334f, 
    0.43301198f, -0.11123328f, 0.69189316f, -0.67803651f, 0.06487296f, -0.01689159f, -0.10404699f, 0.12542491f, 
    -0.17656986f, 0.17425655f, 0.03503995f, 0.07014565f, -0.00779216f, 0.14645177f, 0.65681720f, -1.69760859f, 
    -1.35334432f, -0.35479772f, 0.64028591f, 0.82326919f, -0.20127158f, -0.52621889f, -0.31225383f, 0.80091316f, 
    0.48215488f, 0.13372935f, -0.38801169f, -0.27111930f, -0.05272689f, -0.18834613f, 0.03989275f, -0.07877870f, 
    -0.21499759f, -0.46283448f, -0.20166868f, -0.59392875f, -0.20630151f, -0.16747747f, 0.02619160f, -0.05460038f, 
    1.11444771f, -0.63568598f, -0.60035241f, -0.03010495f, -0.11841099f, 0.85541964f, 0.49043664f, 0.75603408f, 
    -0.21860677f, 0.02805855f, -0.23774868f, 0.45069319f, -0.10962341f, -0.49214748f, -0.12131488f, 0.01306903f, 
    0.20967266f, -0.17921561f, -0.42249039f, -0.25872982f, -0.07760273f, -0.44185284f, -0.33551851f, -0.17850761f, 
    -0.09886518f, 0.42358103f, -0.32689878f, -0.13469887f, 0.05601231f, -1.07807314f, -0.58144480f, -0.34241366f, 
    -1.29889774f, -1.26154685f, -1.20381796f, 0.71039367f, 0.03262379f, 0.14271858f, 0.26243713f, 0.25362185f, 
    -0.29920775f, -0.35769984f, -0.31044424f, -0.50657105f, -0.13650954f, -0.38482162f, -0.53222555f, -0.01148494f, 
    0.11041205f, -0.64287937f, -1.21455514f, -0.78165567f, 0.38424334f, 0.93734431f, 0.55992740f, 0.53123897f, 
    0.84901619f, 0.07379833f, -0.28745928f, -0.36506888f, -0.31501710f, -0.47338641f, 0.34033999f, 0.41533929f, 
    -0.41896439f, -0.32970947f, 0.16519468f, -0.35710174f, 0.14547135f, -0.19110146f, 0.05837272f, 0.00196805f, 
    -0.02796516f, 0.07714368f, 0.22069681f, -0.23352368f, 1.37888551f, -0.57967210f, -0.91656518f, -0.17508584f, 
    0.15504448f, 0.27367276f, 0.89148253f, -0.86742890f, -0.85978478f, 0.38198784f, -0.07633043f, 0.60767245f, 
    -0.38094714f, -0.42194912f, -0.23603922f, -0.16852748f, -0.17571858f, -0.17826469f, -0.38187203f, 0.11307450f, 
    0.22461419f, -0.22577125f, 0.03220380f, 0.43690845f, -0.66733426f, 0.29955387f, 0.12069222f, 0.33456269f, 
    0.39621767f, 0.79596227f, 0.97455502f, 0.32800332f, 0.40562356f, 0.02641370f, 0.40564829f, 0.26432106f, 
    -0.05991876f, -0.29118669f, 0.06182078f, 0.50498694f, -0.05415573f, -0.13377847f, -0.23469055f, -0.26870987f, 
    0.07116194f, 0.03723371f, 0.28392503f, -0.10618882f, 0.05125242f, 0.68908226f, 0.77213639f, 0.46417457f, 
    0.19945018f, -0.14583735f, -1.03905964f, -0.68102866f, 0.10825099f, 0.01287358f, 0.08822839f, -0.14099091f, 
    0.42139116f, 0.42454383f, -0.16520852f, 0.24277915f, 0.40841481f, 0.01603900f, -0.09226760f, 0.33783996f, 
    -0.40631849f, 0.02972804f, -0.05698097f, -0.10438254f, 0.10260083f, 0.19354905f, 0.65287060f, 0.82424068f, 
    0.52740109f, -0.03001794f, 0.03059454f, -0.25996014f, -0.23100041f, -0.05664370f, 0.28219128f, -0.03364119f, 
    0.19964209f, 0.13087146f, 0.17787421f, 0.21731952f, -0.31875300f, 0.24094607f, -0.08602268f, -0.22040200f, 
    -0.11066671f, -0.13993736f, 0.03411621f, -0.28403977f, -0.47892177f, -0.24350472f, -0.60593903f, -0.94178772f, 
    -0.04741982f, -0.91622716f, -1.03333855f, -0.95754230f, 0.77629799f, 0.81311077f, 0.45893061f, 0.38100350f, 
    0.20850322f, -0.15866476f, 0.56904405f, -0.08664169f, -0.21141560f, -0.44217893f, -0.82764828f, -0.03739060f, 
    0.04325010f, -0.19281878f, -0.10482468f, -0.03387017f, 0.13390802f, 0.45393416f, 0.17196155f, 0.36854765f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.43257913f, 0.27472493f, 0.62840337f, 0.62862277f, -0.45358935f, 0.21749866f, 0.57776779f, 0.51657683f, 
    0.36016595f, -0.20978774f, 0.75815088f, 0.65445870f, 0.28079158f, 0.63637143f, -0.07478528f, 0.59803712f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.12623228f, -0.51787823f, -0.15143752f, 0.16956121f, 0.17916301f, 0.16852778f, -0.18832044f, 0.11503676f, 
    -0.04669171f, -0.01157572f, -0.03462214f, -0.00471444f, 0.33573881f, -0.04601109f, -0.12261561f, 0.17672648f, 
    -0.19463788f, 0.01334592f, 0.10232627f, -0.08662187f, -0.08341537f, 0.04706214f, 0.12114087f, 0.03342976f, 
    -0.75609845f, 0.47992602f, -0.68823421f, 0.02974314f, 0.01942042f, 0.00408284f, 0.06066708f, 0.03212082f, 
    -0.01980575f, -0.02111072f, 0.00440947f, 0.09205163f, 0.57850200f, 0.20657246f, -0.53064519f, -0.14831959f, 
    0.02657473f, -0.05299081f, -0.14952579f, -0.53244340f, -0.14081801f, -0.21703988f, 0.01807162f, -0.00199157f, 
    0.68792343f, 0.52787870f, -0.22837475f, -0.29102230f, 0.29883909f, 0.30242234f, 0.14874420f, 0.23181637f, 
    -0.07025167f, -0.07173119f, -0.02184803f, -0.08532599f, -0.22873969f, 0.16376111f, -0.52737588f, 0.11183426f, 
    -0.21633790f, 0.04049513f, -0.23268881f, 0.13365239f, 0.21190678f, 0.06115065f, -0.00663424f, -0.00416756f, 
    0.20152864f, 0.52920526f, 0.08558116f, -0.30279118f, 0.09842610f, -0.04545237f, 0.00107045f, -0.12947330f, 
    0.17257400f, -0.13834313f, 0.01390913f, -0.20436569f, 0.55111986f, 0.45727447f, 0.34970403f, -0.33523959f, 
    -0.04385535f, 0.03369329f, 0.11086101f, -0.14932637f, -0.13147022f, -0.13543862f, -0.07187287f, -0.20573556f, 
    -0.46297354f, -0.32460308f, -0.51547033f, 0.05146142f, -0.09833323f, 0.04523234f, 0.10503370f, 0.05845832f, 
    -0.02534928f, -0.06245110f, 0.03770808f, 0.04664860f, 0.65281284f, 0.07608537f, -0.20954114f, -0.30866244f, 
    -0.05665824f, -0.28982389f, -0.04955487f, 0.14796674f, -0.18794964f, 0.11897049f, -0.23308371f, 0.01937247f, 
    0.50824732f, -0.43911496f, -0.08842023f, -0.52009922f, -0.17778882f, -0.11418424f, 0.03847925f, 0.06510603f, 
    0.05566354f, -0.17218751f, -0.37036744f, -0.03578145f, 0.17181323f, -0.33855176f, -0.71038806f, 0.07605181f, 
    0.19073276f, -0.02162674f, -0.12372466f, -0.31546116f, -0.07058227f, -0.12984911f, -0.27591375f, -0.36874148f, 
    -0.08295418f, -0.13512544f, -0.12970704f, 0.01782770f, -0.06196551f, 0.00971201f, 0.01512832f, 0.00082962f, 
    -0.31603989f, -0.03767398f, -0.10258267f, -0.08688166f, -0.25729933f, -0.12007774f, -0.09569591f, -0.21788847f, 
    -0.32584023f, -0.20203833f, -0.51369059f, -0.13221663f, -0.04221943f, -0.01891302f, -0.08139519f, 0.02348610f, 
    -0.09898781f, -0.06343763f, -0.03277759f, 0.18369485f, 0.11294484f, 0.04219645f, -0.00002942f, 0.05960765f, 
    -0.06143394f, 0.11582101f, -0.01915178f, 0.16845036f, 0.17426611f, -0.34251612f, -0.41940412f, 0.00763429f, 
    0.12308166f, 0.20897068f, -0.22054434f, -0.15925473f, 0.04649549f, 0.00255225f, 0.06063092f, 0.07817341f, 
    0.51238960f, -0.32055062f, -0.02984116f, -0.26690748f, -0.09941201f, 0.16171770f, -0.11015360f, -0.33952156f, 
    -0.03191107f, -0.06741378f, 0.03421173f, -0.17886065f, -0.11844656f, -0.19349714f, -0.32187319f, 0.42630401f, 
    0.01979882f, 0.08331635f, -0.02470740f, -0.11781155f, -0.14810486f, -0.39554533f, -0.24758103f, -0.44816166f, 
    0.39049208f, 0.41770470f, 0.08718587f, -0.23927708f, -0.13096176f, 0.01624190f, -0.26220611f, -0.02459037f, 
    0.02375458f, -0.01119839f, 0.08275425f, -0.05873642f, -0.24820158f, -0.55569214f, 0.20780939f, 0.38758570f, 
    0.29873216f, 0.14900352f, -0.04435227f, 0.20398378f, -0.09683227f, 0.14550759f, 0.06197300f, -0.17242047f, 
    0.24651986f, 0.38026285f, 0.15709817f, 0.40506351f, -0.26256979f, 0.13505654f, -0.16280030f, -0.14300038f, 
    -0.07953035f, -0.02527670f, -0.03006477f, -0.04852574f, -0.06341082f, -0.23496792f, 0.10932460f, -0.01105899f, 
    -0.00188154f, -0.20273790f, -0.07219420f, -0.17380102f, -0.13383234f, -0.22504605f, 0.07957055f, 0.15067419f, 
    -0.46572411f, 0.22582589f, -0.44945031f, 0.23594078f, 0.06874354f, 0.08221894f, 0.19788159f, 0.11732274f, 
    -0.02587348f, 0.10641011f, -0.08316767f, 0.22985886f, -0.11958137f, 0.27727062f, -0.29551548f, 0.03799642f, 
    0.12451233f, -0.09077899f, 0.17394905f, -0.22215192f, 0.10862853f, 0.01240755f, -0.22555348f, -0.02750169f, 
    0.98677272f, -0.34357226f, 0.05673449f, -0.12857956f, -0.11307858f, 0.00040544f, 0.03281125f, -0.07798698f, 
    -0.02805250f, -0.22678252f, -0.47181931f, -0.11200747f, 0.04842065f, -0.17824718f, 0.18413863f, -0.61322302f, 
    -0.17748222f, 0.02133344f, 0.19174598f, 0.17330779f, 0.08702572f, -0.22968198f, -0.00504203f, 0.12188039f, 
    -0.13134933f, -0.47180542f, 0.55937558f, 0.33383468f, -0.08737320f, 0.08245131f, 0.15146534f, -0.00785021f, 
    0.08063149f, 0.02924988f, 0.19275615f, 0.26353931f, -0.14539024f, -0.75233030f, -0.27549326f, -0.12196685f, 
    0.10059191f, 0.17730543f, 0.00442831f, -0.08899316f, -0.06673661f, -0.04702676f, 0.05966892f, 0.40131941f, 
    0.11680007f, -0.07603052f, 0.09955522f, 0.32013214f, -0.05302450f, -0.04258168f, -0.09823368f, 0.02760847f, 
    0.01832460f, 0.15635261f, 0.08526048f, 0.13893080f, 0.11694407f, -0.00458167f, 0.05138922f, -0.19223103f, 
    -0.00934128f, 0.14306313f, -0.08211315f, -0.08656452f, -0.08347344f, -0.08821202f, 0.09983867f, 0.07731172f, 
    0.07478131f, 0.08813322f, 0.09798420f, 0.11861843f, -0.02562789f, -0.04402594f, -0.08550457f, 0.09116522f, 
    0.20566325f, 0.10850914f, -0.18228133f, 0.23550652f, -0.08431264f, -0.04673123f, -0.37732655f, -0.52515417f, 
    -0.08949722f, 0.01244658f, 0.13015482f, -0.01836424f, -0.16286710f, 0.10881858f, -0.25687167f, -0.08517504f, 
    -0.00972975f, 0.61606324f, 0.40456221f, 0.11825527f, -0.04217853f, -0.03420360f, 0.23440935f, -0.19692722f, 
    0.11373176f, 0.25434625f, -0.25779194f, 0.10230321f, 0.27920893f, -0.06150033f, -0.11746063f, 0.33667183f, 
    0.07167591f, -0.00982816f, -0.07355577f, 0.09199969f, 0.11549090f, 0.13215543f, 0.12436077f, -0.05187397f, 
    -0.56967288f, 0.11710152f, 0.52806818f, -0.66617256f, 0.03359302f, 0.03465075f, 0.07306024f, 0.17439814f, 
    -0.06538671f, -0.04323700f, 0.05132720f, -0.12099136f, 0.16951700f, -1.07244539f, 0.21756615f, 0.40369380f, 
    0.15638649f, -0.01804642f, -0.41225496f, 0.02220627f, 0.04140490f, -0.13569003f, -0.07812513f, 0.06428269f, 
    -1.05605173f, -0.65003669f, -0.09079066f, 0.20153554f, -0.25082728f, 0.03371052f, 0.04213480f, 0.22219737f, 
    0.00157409f, -0.07267113f, -0.03917558f, -0.10475409f, 0.01814232f, -0.23029841f, 0.14760119f, -0.17241758f, 
    0.01917861f, -0.24175461f, -0.18997620f, 0.26343897f, -0.02703050f, -0.15559447f, 0.08949562f, 0.06132845f, 
    -0.08962925f, 0.02251973f, -0.36692807f, -0.05383695f, 0.27363905f, 0.30900684f, -0.20856465f, -0.06628463f, 
    -0.17896745f, 0.03375680f, 0.08743200f, -0.11214092f, 0.02984030f, -0.02039756f, 0.48418534f, 0.55836350f, 
    -0.04209442f, -0.06835949f, -0.22187491f, 0.18328354f, -0.08274285f, -0.16025111f, -0.26583624f, 0.16581821f, 
    -0.08185176f, 0.08658252f, 0.10316396f, -0.01069633f, -0.02841159f, 0.03036808f, 0.05599232f, -0.06889691f, 
    0.19437990f, 0.09694069f, 0.09094118f, 0.26862103f, -0.82576561f, -0.33060178f, 0.17927507f, -0.36442012f, 
    -0.07035923f, -0.15176348f, -0.09633934f, -0.42711750f, 0.00622806f, 0.04156363f, 0.06637358f, 0.04474229f, 
    0.03047787f, 0.09002031f, -0.29967463f, 0.15055248f, 0.12959310f, 0.03705765f, 0.04872608f, 0.21028799f, 
    -0.05071676f, 0.10878474f, 0.08031881f, -0.19863774f, 0.34738830f, 0.03247050f, -0.15222017f, -0.63150293f, 
    0.24046220f, -0.16909693f, -0.03617381f, 0.00769471f, 0.01617464f, -0.04447274f, -0.06496699f, -0.38300419f, 
    -0.03440987f, -0.46251392f, -0.21473354f, 0.03039878f, 0.06075878f, 0.08533894f, 0.16837424f, 0.09671528f, 
    -0.25375336f, -0.19733414f, -0.31593043f, 0.23013198f, -0.45986357f, -0.27480370f, 0.30664194f, 0.15380411f, 
    -0.42110863f, 0.06580857f, -0.10702996f, -0.07875871f, 0.12946866f, 0.02389955f, -0.05748809f, 0.03652995f, 
    -0.31216434f, -0.14061987f, 0.01126275f, 0.01924796f, -0.11184873f, -0.06072188f, -0.01267588f, 0.07866359f, 
    -0.06451607f, -0.31100124f, -0.00934336f, 0.47544777f, -0.08883911f, 0.87041748f, 0.76659942f, 0.32999808f, 
    -0.12138817f, 0.03204793f, 0.06411387f, -0.16236845f, -0.07025856f, -0.16658036f, -0.05064253f, -0.09778134f, 
    -0.24190877f, -0.18614890f, 0.13008016f, 0.70532537f, 0.01146412f, 0.02007608f, 0.07933332f, -0.13388817f, 
    -0.06163363f, 0.04289557f, 0.11517044f, 0.30337670f, -0.46925434f, 1.03084302f, -0.57236868f, -0.16812381f, 
    0.05963602f, 0.11598204f, 0.06185934f, -0.23735012f, -0.18509182f, 0.00437041f, -0.20038460f, 0.07419404f, 
    -0.54605210f, 0.04698847f, -0.02583948f, 0.28581807f, -0.09809889f, -0.12216283f, 0.08168484f, -0.38610226f, 
    0.06780042f, -0.04587705f, -0.07668739f, 0.15876146f, 0.00191541f, -0.21098401f, -0.12728666f, 0.41056308f, 
    0.12873517f, -0.02981559f, -0.03384702f, -0.00688720f, -0.01096704f, -0.09900849f, -0.10743526f, -0.16009101f, 
    -0.08746332f, -0.34554410f, -0.05890979f, 0.16717547f, 0.16672651f, 0.05973426f, -0.06828737f, -0.01973004f, 
    -0.07538195f, 0.12481537f, -0.09802260f, -0.01480609f, 0.26609993f, -0.33068806f, 0.74583924f, -0.34866965f, 
    -0.29523870f, 0.04866714f, -0.40320086f, -0.08202726f, 0.12405179f, -0.06353856f, -0.18826094f, 0.03039893f, 
    0.16188040f, 0.00780427f, -0.20848870f, -0.00498370f, 0.18744132f, -0.16045131f, -0.27537543f, 0.03214838f, 
    -0.05570347f, 0.02493413f, -0.13273075f, -0.20863310f, -0.00060212f, 0.07368093f, -0.30122256f, -0.44939578f, 
    0.16818996f, 0.00109520f, -0.01258503f, 0.05854670f, -0.13567056f, 0.01260133f, -0.21813090f, -0.04286870f, 
    -0.50147110f, 0.90851885f, -0.31225839f, -0.10663673f, 0.18780173f, 0.09070861f, 0.30896571f, -0.01889431f, 
    -0.14013150f, 0.01866939f, -0.19024755f, 0.01556935f, -0.02312214f, -0.25873110f, 0.11363862f, 0.43351573f, 
    0.04871123f, -0.00220234f, 0.39342630f, 0.34056813f, 0.00916987f, 0.00920622f, 0.02061633f, -0.04928625f, 
    -0.35875177f, 1.30697823f, -0.66406852f, -0.89104474f, 0.32802093f, 0.10449735f, -0.02016617f, 0.13630804f, 
    -0.26433167f, -0.19316892f, 0.07286483f, 0.10271060f, -0.00436231f, 0.23616649f, -0.17869258f, 0.59869981f, 
    -0.06239539f, -0.22448334f, -0.21177606f, -0.27150899f, -0.11218142f, 0.10922879f, 0.19307461f, -0.22090530f, 
    -0.31572422f, 0.33550826f, -0.33875328f, -0.49800745f, 0.19085748f, 0.20746168f, 0.08779962f, -0.00723715f, 
    -0.36235315f, 0.01265961f, -0.05179225f, -0.43718633f, -0.20741710f, 0.26680100f, 0.16652644f, -0.00760700f, 
    -0.24000637f, 0.06592378f, -0.15071388f, -0.15184048f, -0.16084597f, 0.06312673f, -0.10094899f, -0.31592518f, 
    -0.51626420f, 0.21468668f, 0.07086030f, -0.56450784f, -0.38995627f, -0.20429274f, -0.18379793f, 0.07339124f, 
    0.23833957f, 0.21256177f, 0.18388148f, 0.07256779f, 0.37377742f, -0.12652670f, -0.09724911f, 0.38597488f, 
    0.28186530f, -0.08055599f, -0.02836326f, -0.08231324f, -0.05799532f, 0.17062159f, 0.01243905f, 0.23350909f, 
    -0.39867276f, 0.11127321f, 0.13109793f, -0.03062833f, 0.09738289f, -0.21721581f, -0.17681104f, -0.18218866f, 
    -0.09566314f, 0.01342176f, -0.09860545f, 0.22602467f, 0.05961176f, -0.67267102f, 0.02757948f, -0.30860761f, 
    -0.03375660f, 0.06477765f, -0.17591152f, 0.10679649f, 0.19180471f, 0.02762017f, 0.04746315f, 0.27689540f, 
    0.05789217f, -0.69692516f, 0.19247478f, 0.52308679f, 0.08425742f, -0.05877681f, 0.12884571f, 0.09983552f, 
    0.04381267f, 0.05002676f, -0.05744854f, 0.02691334f, 0.14153159f, 0.47189301f, 0.02230516f, 0.18431780f, 
    -0.11819080f, -0.17762445f, -0.10498361f, 0.07037788f, -0.00560335f, -0.11389311f, 0.07042295f, -0.06400672f, 
    -0.01643082f, -0.05973758f, 0.07596933f, 0.04450642f, -0.13008118f, 0.03963272f, 0.23366457f, 0.07217434f, 
    -0.00496140f, 0.02769554f, 0.02398975f, 0.01435209f, 0.46489844f, 0.03665842f, -0.04346841f, 0.48984766f, 
    -0.00837663f, -0.14481497f, 0.21540762f, -0.06087746f, 0.12938625f, 0.00225522f, -0.01551833f, -0.31682110f, 
    0.03233428f, 0.13505454f, 0.24766378f, 0.03999250f, -0.22780888f, -0.23673640f, -0.12567516f, 0.02836554f, 
    -0.15380470f, -0.19510081f, -0.07436221f, -0.14154007f, -0.05654203f, -0.23507375f, -0.04580568f, 0.19489691f, 
    -0.33002162f, -0.00151654f, -0.05587959f, -0.07463405f, -0.08176296f, 0.20712385f, 0.24182615f, 0.04087285f, 
    0.02184954f, -0.28975904f, 0.08295856f, -0.11810850f, -0.03928524f, 0.00455095f, -0.04717914f, 0.05069392f, 
    0.08476929f, 0.01734534f, 0.10408366f, -0.01509862f, 0.29669172f, 0.64734501f, 0.18793786f, 0.28472701f, 
    0.09031593f, -0.02204806f, -0.32734102f, 0.09341150f, 0.03349934f, 0.12477312f, 0.16728033f, 0.07007855f, 
    0.24801527f, -1.34766960f, 0.13113742f, -0.08521199f, 0.08740856f, 0.06865584f, -0.05118879f, -0.13938245f, 
    -0.09753433f, 0.00301489f, -0.14943916f, -0.39101332f, 0.06219608f, -0.02574539f, -0.06422954f, -0.38624316f, 
    -0.07252396f, -0.01292127f, -0.09949216f, -0.12801091f, -0.16523485f, -0.23626490f, -0.34999332f, -0.56293213f, 
    0.30655119f, 0.04630266f, -0.00727346f, -0.19689760f, 0.01445146f, -0.00594956f, 0.01792210f, 0.15139933f, 
    0.05682191f, -0.30561444f, -0.13916452f, -0.25363600f, -0.02797318f, -0.06386068f, -0.03388298f, 0.04499299f, 
    -0.17269377f, -0.15078366f, 0.07318227f, 0.06622157f, 0.16396725f, -0.01418915f, -0.14394885f, -0.21066807f, 
    -0.00556569f, -0.06042464f, -0.10357581f, 0.05366023f, 0.07747347f, 0.02358733f, -0.04323319f, -0.01324692f, 
    0.11113711f, 0.13823445f, 0.13318367f, 0.10547700f, 0.38755777f, 0.19337888f, 0.25240126f, 0.10208187f, 
    0.01056187f, -0.30719852f, -0.21969959f, -0.09346261f, 0.02137385f, -0.19275700f, -0.00209053f, -0.14716010f, 
    -0.07019062f, -0.08660476f, -0.86950737f, -0.38149640f, 0.04949299f, 0.04780758f, -0.17861876f, 0.27699381f, 
    0.10937469f, -0.25739545f, -0.18281557f, -0.27445129f, 0.17124532f, -0.07382675f, 0.80879253f, -0.19551879f, 
    -0.09346489f, -0.00021560f, -0.00296768f, 0.00235132f, -0.00261216f, -0.22144006f, -0.41845566f, -0.14913696f, 
    -0.10191766f, -0.15920377f, -0.14350674f, 0.15226884f, 0.08927900f, -0.07996884f, 0.05491721f, 0.05870074f, 
    -0.00063038f, -0.07962448f, -0.07582407f, 0.17928289f, -0.03628656f, 0.37434006f, 0.01088247f, -0.68454546f, 
    -0.15867478f, 0.17198682f, 0.15886106f, 0.21196519f, 0.15501614f, 0.09513464f, -0.13916802f, 0.13898599f, 
    -0.05658024f, 0.21294183f, 0.33411103f, -0.12164669f, 0.33051434f, -0.02466883f, 0.02476773f, -0.14406005f, 
    0.02740321f, 0.10947680f, 0.07214234f, 0.20176944f, -0.16980091f, 0.16945386f, -0.31822038f, -0.07354719f, 
    0.11785500f, 0.03893220f, -0.11213422f, 0.23108657f, -0.07944008f, 0.23818758f, -0.15651479f, 0.09663530f, 
    0.23388813f, -0.14798833f, 0.35050160f, 0.03912310f, 0.03678681f, 0.18251215f, 0.18628968f, 0.01761087f, 
    0.21598312f, 0.01379047f, 0.09854303f, 0.13905075f, -0.27783775f, -0.22430822f, 0.31611037f, 0.13407017f, 
    -0.12326437f, 0.06396575f, -0.03614435f, 0.09126844f, 0.22583830f, -0.25192219f, -0.12727349f, 0.08761137f, 
    -0.46320370f, -0.22799920f, -0.31861174f, -0.00998669f, 0.00088415f, 0.02516846f, 0.02923243f, -0.00258443f, 
    0.03858006f, -0.21988848f, 0.10466277f, -0.18383773f, 0.10107515f, 0.17896330f, -0.07336238f, -0.02521694f, 
    0.22646274f, 0.08559565f, -0.09254212f, -0.40599504f, -0.19473688f, -0.02028538f, -0.09091749f, -0.15773487f, 
    -0.21638283f, -0.00304107f, 0.08682367f, 0.20831004f, -0.06183390f, -0.26504126f, -0.04806210f, 0.09392740f, 
    0.05773652f, 0.12194588f, -0.11026881f, -0.04386923f, 0.03503294f, 0.31758288f, -0.34747085f, 0.03000790f, 
    0.01666982f, 0.02232386f, -0.04106250f, -0.00073300f, 0.00513887f, -0.07375073f, 0.17065443f, 0.30563664f, 
    -0.13563624f, -0.01762568f, -0.15785381f, 0.03318828f, 0.02319454f, -0.10050914f, -0.19157830f, -0.17696172f, 
    0.22423342f, -0.08338205f, -0.00552227f, 0.19116451f, -0.04438801f, 0.03975205f, -0.22080147f, 0.19714822f, 
    0.22667021f, -0.14599872f, -0.11399996f, 0.16964993f, -0.05931554f, 0.14855915f, 0.16126275f, 0.05823042f, 
    -0.08283337f, -0.03018524f, -0.09269240f, 0.07968381f, 0.04807115f, 0.10308997f, -0.06606617f, -0.11519833f, 
    -0.02570898f, -0.09976239f, 0.11055293f, -0.57080352f, -0.46927717f, -0.30919746f, -0.45922890f, -0.14700744f, 
    0.00578376f, 0.09193254f, 0.20800143f, -0.15997340f, 0.33768457f, -0.02495665f, 0.13922495f, 0.04930793f, 
    0.70814115f, 0.63355422f, 0.05206970f, 0.01346520f, -0.07472299f, 0.13742670f, -0.05490375f, 0.19932100f, 
    0.20359908f, 0.07136227f, 0.15570255f, 0.10958643f, 0.11155621f, 0.13223755f, 0.19244094f, 0.00327086f, 
    -0.05527366f, 0.04445603f, -0.01610962f, 0.29269898f, 0.07237523f, 0.18580839f, 0.25984076f, 0.13871840f, 
    0.05810814f, -0.28798983f, -0.78714210f, 0.16580275f, 0.18241563f, 0.20080771f, 0.23505864f, -0.11729334f, 
    0.02505452f, -0.01733665f, 0.03508273f, 0.09628540f, 0.14092359f, 0.03699869f, 0.24013843f, -0.38604251f, 
    -0.01036878f, -0.48592031f, 0.06759214f, 0.04453334f, 0.01810775f, -0.06532630f, 0.03676609f, 0.16967162f, 
    -1.41848838f, -1.30542076f, -1.67681396f, -0.65090239f, -0.09913427f, -0.25197423f, -0.24122176f, -0.76397842f, 
    -0.14885680f, 0.00330166f, -0.04711608f, -0.09011269f, -0.02550299f, -0.32997972f, -0.06206467f, -0.40708169f, 
    -0.03901561f, 0.07122272f, 0.33615589f, -0.25305533f, 0.14446421f, 0.17963642f, 0.00211938f, 0.02025316f, 
    -0.64275509f, -0.71288782f, 0.07939100f, 0.17969929f, -0.31828055f, -0.13539615f, -0.35463002f, -0.26262686f, 
    -0.04919504f, -0.08342348f, -0.15502666f, -0.06693570f, -0.42140093f, -0.60886461f, -0.01752130f, -0.26060972f, 
    -0.11325484f, -0.16842204f, 0.00512657f, 0.33449855f, -0.06704642f, 0.20393562f, 0.35443112f, 0.02725562f, 
    -0.13662301f, 0.38320503f, 0.27953425f, 0.04384018f, -0.02422512f, 0.01731792f, 0.10229916f, 0.00094468f, 
    0.04815513f, 0.20340842f, 0.32548091f, 0.20703775f, -1.25280774f, -1.24797559f, -0.36923698f, 0.09283856f, 
    0.16424538f, 0.15769748f, -0.00597133f, -0.35692137f, 0.04458260f, -0.14742191f, 0.07731557f, 0.11573658f, 
    -0.20746057f, 0.12149756f, 0.12781087f, -0.33342963f, 0.11051087f, 0.03486731f, -0.08512980f, -0.12572786f, 
    0.08733270f, 0.11378971f, -0.18680826f, 0.17446184f, -0.38773453f, -0.27326792f, 0.47474626f, -1.00146198f, 
    0.13503915f, 0.04346872f, 0.00868628f, 0.14142790f, 0.16012700f, 0.15490773f, -0.11021309f, -0.22816606f, 
    -0.02578196f, -0.18216565f, 0.24566203f, 0.03619516f, 0.13141149f, -0.03518279f, -0.12780960f, 0.11433806f, 
    -0.05870639f, -0.14278241f, 0.02639969f, -0.13998941f, 0.45588762f, -0.24936415f, -0.49546966f, -0.09020270f, 
    -0.34004402f, -0.08306246f, 0.72953862f, 0.18604527f, -0.09830547f, 0.01101582f, -0.11228994f, -0.06372537f, 
    0.36835611f, -0.01295350f, -0.30423483f, -0.20133410f, 0.04017696f, 0.05443353f, 0.19805892f, 0.02552117f, 
    -0.23428297f, -0.04039147f, -0.09625278f, -0.34267303f, -0.91811758f, 0.39379492f, 0.82927871f, 0.29732779f, 
    -0.00741179f, -0.11354865f, -0.34214815f, 0.22203973f, -0.19902809f, 0.22338969f, -0.16588019f, 0.24459235f, 
    -0.72402233f, 0.17438757f, -0.53214574f, 0.20782620f, -0.12161446f, -0.10730748f, 0.35092920f, -0.04098036f, 
    0.04897718f, 0.02281905f, 0.13681421f, -0.10870646f, 0.14834057f, -0.29440594f, 0.23191178f, -0.37962753f, 
    0.09538613f, -0.21325570f, -0.10262499f, 0.00291647f, 0.08193482f, -0.08306532f, 0.27692392f, -0.05740224f, 
    0.10666270f, -0.07954243f, -0.08379679f, -0.44004339f, 0.06273835f, -0.04105449f, -0.23463036f, -0.10247232f, 
    0.04368256f, 0.06771032f, 0.07103810f, -0.07059698f, -1.12592471f, -0.31458235f, 0.88748735f, -0.39982903f, 
    -0.16333069f, 0.19316348f, -0.06627694f, -0.09414805f, -0.06764992f, 0.10653515f, 0.09172969f, 0.01776090f, 
    -0.64343858f, -0.55775392f, 0.00024340f, -0.19583088f, 0.24616905f, -0.02350453f, -0.05062379f, 0.29571509f, 
    0.02337501f, -0.06659087f, -0.08423579f, -0.06434615f, 0.07037514f, 0.15905118f, -0.26840097f, -0.04258558f, 
    -0.05431923f, -0.00843415f, 0.00717149f, -0.09120275f, 0.01059530f, 0.06722923f, 0.10602965f, 0.12495512f, 
    0.08902282f, -0.24774422f, 0.23586589f, 0.00631220f, -0.12808205f, -0.00892925f, -0.21696946f, 0.05524017f, 
    -0.14059597f, 0.01102531f, 0.05450586f, -0.06565600f, 1.07812214f, -1.15339589f, 0.18121035f, -0.32416126f, 
    -0.20858769f, 0.18777327f, -0.28694648f, -0.11488893f, -0.06307203f, 0.05768083f, -0.20450029f, -0.20753668f, 
    -0.08171605f, 0.22171536f, 0.26700050f, 0.17976220f, 0.00214908f, -0.09634899f, 0.03459716f, -0.06977236f, 
    0.18223868f, 0.07482612f, 0.20258439f, -0.20812857f, -1.25119317f, 0.28192925f, 0.28292340f, 0.35180259f, 
    0.23417288f, -0.31813183f, 0.00377017f, 0.23333235f, -0.05221524f, -0.18652716f, 0.07872968f, -0.06546721f, 
    0.47782013f, 0.17203699f, -0.19283155f, -0.37666515f, -0.01265936f, -0.03571446f, 0.03592547f, -0.00552044f, 
    -0.17070642f, 0.18036315f, -0.20566948f, -0.41591012f, -0.39865896f, 1.21981096f, -0.50338751f, 0.56450981f, 
    0.03207175f, -0.41018677f, 0.36941224f, 0.03485379f, -0.10581164f, -0.02245758f, -0.22904365f, 0.20099461f, 
    0.26039580f, 0.19547401f, 0.00157984f, -0.21565746f, -0.07281681f, 0.02826506f, -0.00262641f, -0.13002524f, 
    -0.04904977f, -0.33758903f, -0.08967328f, -0.22500905f, -0.15135165f, -0.00521662f, -0.07916608f, 0.06279854f, 
    0.04383157f, -0.03163899f, -0.06503087f, -0.09584707f, -0.05112471f, 0.08740322f, -0.00921223f, -0.06835660f, 
    0.09773120f, 0.08825399f, -0.01750649f, 0.01860449f, 0.02396188f, 0.02907072f, 0.09182572f, 0.04786355f, 
    0.01353557f, 0.04872420f, 0.08277746f, 0.02217769f, 0.55739564f, -0.58000028f, -1.18864441f, -0.74109805f, 
    -0.19984697f, -0.14625828f, 0.41298112f, 0.25060442f, 0.07779432f, -0.17775497f, 0.12449787f, -0.02225255f, 
    -0.69178510f, -0.62563783f, 0.32478711f, 0.21323395f, 0.01302057f, 0.38664433f, -0.11105573f, 0.25973845f, 
    -0.46270755f, -0.07826766f, 0.00957188f, -0.25020066f, 0.70308781f, -0.01336189f, -0.27243194f, -0.25705388f, 
    0.06453575f, -0.11145959f, 0.00522703f, -0.05651909f, -0.00859749f, -0.07417522f, -0.14084446f, -0.33754215f, 
    0.07064892f, 0.04929622f, 0.34408602f, 0.11144074f, -0.08222820f, -0.12813707f, -0.07488427f, -0.20664479f, 
    -0.15032999f, -0.01158988f, 0.03162830f, -0.12134958f, -0.80857360f, -1.18391979f, -0.07555461f, -0.08998570f, 
    0.18790455f, 0.12070113f, 0.19197963f, -0.07278777f, 0.04125332f, 0.20277052f, -0.08253807f, 0.08154231f, 
    0.15356533f, -0.34313732f, -0.37715098f, -0.22664744f, -0.21916457f, -0.14703996f, 0.13248616f, -0.22370903f, 
    -0.08980712f, 0.08078896f, 0.01940948f, 0.11653157f, 0.01872336f, 0.27027470f, 0.02927683f, -0.00325108f, 
    0.13284762f, 0.12063472f, 0.22294369f, 0.04816052f, -0.10211017f, -0.16087694f, -0.06702350f, -0.04909285f, 
    0.71718711f, 0.01719295f, -0.21954311f, -0.20845036f, -0.04763338f, -0.43726397f, 0.02585875f, -0.35794657f, 
    0.29105571f, 0.29462051f, 0.21071753f, 0.10973307f, 0.13576837f, -0.22525658f, -0.84784400f, -0.87558413f, 
    0.16849582f, 0.21316351f, 0.14561127f, 0.14864556f, -0.00195873f, 0.00560683f, 0.05221789f, -0.05369057f, 
    -0.65560156f, -0.26978800f, -0.14143771f, -0.17582616f, -0.12649086f, 0.02996053f, -0.09912822f, -0.06731776f, 
    -0.00869464f, -0.17004754f, -0.17567240f, 0.03472728f, -0.09214550f, -0.24540943f, -0.27476537f, -0.42882875f, 
    0.21136884f, -0.00145419f, 0.08882807f, -0.13559550f, 0.10396430f, -0.04316403f, 0.06221388f, -0.25174072f, 
    0.24123064f, 0.33016357f, -0.30313209f, -0.53262287f, -0.22710554f, -0.18523833f, -0.01929411f, -0.01292062f, 
    0.06800399f, -0.06195504f, 0.10414521f, 0.12869756f, -0.34713811f, 0.00323289f, -0.05210279f, 0.41093409f, 
    -0.04767542f, 0.14281082f, 0.42198437f, 0.13756704f, 0.12350937f, 0.39258477f, 0.23620300f, 0.09592570f, 
    -0.07807980f, -0.01003732f, -0.16458601f, -0.40702069f, -0.14476617f, 0.03985752f, -0.00426161f, 0.02921640f, 
    0.23329023f, 0.18760675f, 0.13531254f, 0.11183743f, -0.11890284f, -0.04521317f, 0.15207690f, 0.24863012f, 
    0.22545837f, 0.10366123f, 0.12904657f, 0.08461869f, 0.10885153f, 0.00028122f, 0.14302111f, 0.02808275f, 
    -0.24305601f, 0.05115097f, -0.04704736f, -0.10567982f, 0.03453323f, -0.09854488f, -0.11173630f, -0.05866245f, 
    -0.66130286f, -0.23747657f, -0.22602069f, -0.36019528f, -0.61021423f, -0.56955570f, 0.14143941f, 0.76498348f, 
    -0.30377346f, 0.18741950f, 0.18376791f, 0.23946527f, 0.13710859f, 0.17521472f, 0.05786615f, 0.29170296f, 
    -0.17997263f, 0.29503459f, 0.52884746f, -0.67885941f, 0.00105047f, -0.34061721f, 0.01706894f, 0.03733055f, 
    -0.17242454f, 0.09527950f, 0.12279308f, 0.01580617f, -0.16707847f, -0.46166822f, 0.05088000f, 0.09774833f, 
    0.16648684f, 0.06121042f, 0.05448188f, 0.03043591f, -0.19499628f, 0.15815918f, 0.10822748f, 0.27014661f, 
    -0.19878428f, -1.02391386f, -0.01601689f, -0.10815110f, 0.16354628f, 0.36302379f, 0.28737435f, 0.01061698f, 
    -0.10768711f, 0.02363054f, -0.06478266f, -0.05953554f, 0.11199219f, 0.23988053f, 0.18408656f, -0.78698283f, 
    -0.58045429f, -0.04538599f, -0.03554377f, -0.02055429f, -0.02549024f, -0.01791227f, -0.07184300f, -0.02378210f, 
    -0.67615479f, -0.12979451f, 0.36328810f, -0.37711769f, -0.56506097f, -0.08046930f, -0.11025304f, 0.45531482f, 
    0.09876982f, 0.05328926f, 0.12640707f, -0.04657454f, -0.73615420f, 0.32885596f, -0.68726844f, -0.15905763f, 
    0.08729677f, -0.05553513f, 0.17309764f, -0.25301787f, 0.00177974f, -0.01075360f, -0.29209995f, -0.06155501f, 
    -0.11506934f, -0.56556618f, -0.37575084f, -0.05301458f, -0.15004940f, -0.05766945f, 0.20550869f, 0.20674257f, 
    0.08752136f, -0.29818696f, -0.03307863f, -0.19149263f, -0.05611780f, 0.52212542f, 0.44271332f, 0.80524272f, 
    0.09571680f, -0.10467471f, -0.02845400f, -0.41195193f, 0.01973626f, 0.07465021f, 0.05119113f, -0.07546594f, 
    0.30519477f, -0.13202026f, 0.28058380f, 0.11097868f, 0.06290035f, -0.15940838f, -0.23256360f, 0.01885805f, 
    0.05195273f, 0.13635276f, 0.12989670f, 0.07283238f, 0.38644609f, -0.14870463f, -0.00042007f, -0.39377525f, 
    -0.13580525f, 0.17608087f, -0.13862994f, 0.29221275f, 0.12029410f, 0.14737113f, 0.00874783f, -0.08295742f, 
    -0.38399151f, -0.54088056f, 0.13211860f, 0.61999714f, 0.16728687f, 0.30873287f, -0.35354549f, 0.18406028f, 
    -0.09438521f, -0.17886123f, 0.09005640f, -0.00069490f, -0.88619733f, 0.30206469f, 0.03715532f, -0.34181672f, 
    -0.01052933f, -0.37754187f, -0.07829200f, -0.13619247f, 0.00745024f, 0.05036100f, -0.30081430f, -0.12905182f, 
    -0.21005382f, 0.24348439f, 0.11157087f, 0.45720989f, -0.00507261f, 0.09255996f, -0.23423657f, -0.09966689f, 
    0.17870091f, 0.07594926f, 0.21769983f, -0.31090036f, -0.00327974f, 0.47357458f, -0.58779776f, -0.13880470f, 
    0.19346583f, 0.00506731f, 0.25087872f, -0.06365316f, 0.07957218f, -0.36484981f, 0.04287817f, 0.00481783f, 
    -0.29473868f, 0.09304477f, -0.24293332f, 0.13940246f, 0.15612124f, 0.04911501f, 0.27126077f, -0.05458426f, 
    0.29587317f, 0.01515561f, 0.12729371f, 0.06908088f, 0.43233174f, 0.28300935f, 0.13075183f, -0.67897809f, 
    0.14314049f, -0.36288771f, -0.20264594f, -0.01752462f, 0.03531318f, -0.22179490f, 0.06056055f, 0.12192930f, 
    0.12855580f, -0.55193782f, 0.20448111f, 0.18803112f, 0.05432735f, -0.21688005f, -0.04178713f, -0.05653666f, 
    -0.06625466f, -0.09405737f, -0.32825202f, -0.62118101f, -0.58623302f, 0.42257556f, -0.14757311f, 0.08506710f, 
    -0.20643817f, 0.11425339f, 0.10248068f, 0.02606385f, 0.06813440f, -0.49636638f, -0.32776681f, -0.28976229f, 
    -0.40333784f, 0.30350313f, -0.37109998f, -0.13813262f, -0.22818503f, 0.08223414f, -0.06749184f, -0.09686686f, 
    0.14395478f, 0.26945171f, -0.01062256f, 0.15049100f, 0.12738329f, 0.15269500f, -0.27903011f, 0.14224498f, 
    -0.07697682f, -0.04281392f, 0.39804402f, -0.04380742f, -0.34028715f, 0.03507287f, 0.07776818f, 0.11426757f, 
    -0.18840629f, -0.73060375f, -0.26148424f, 0.17365940f, -0.14630206f, 0.19531831f, -0.10986600f, 0.09375557f, 
    0.06755727f, 0.03824139f, 0.15026031f, 0.13810791f, 0.00580579f, 0.55886668f, 0.50214374f, -0.16361178f, 
    0.00921159f, 0.12658027f, 0.10031146f, -0.02245826f, 0.01665912f, 0.22158453f, 0.15301439f, -0.28197488f, 
    -0.36691701f, -0.76503503f, 0.58903915f, 0.11134159f, -0.12885225f, 0.31743747f, 0.24361645f, 0.27566439f, 
    -0.00961464f, -0.11051521f, 0.34853914f, 0.39265662f, -0.61798489f, 0.45277676f, -0.63843971f, -0.01408665f, 
    0.08118546f, 0.05209991f, 0.20531650f, 0.09631166f, -0.19846906f, 0.08084185f, -0.23071437f, -0.24328086f, 
    -0.62653089f, 0.41528234f, -0.03945351f, 0.01099215f, 0.15215841f, -0.36757120f, -0.52220571f, 0.08030681f, 
    -0.11140007f, -0.36508834f, -0.06805080f, -0.52133399f, -0.24291053f, -0.19074090f, -0.37029073f, 0.23073933f, 
    -0.05386649f, 0.15095986f, -0.23617630f, -0.06381307f, 0.09340388f, 0.06039704f, -0.27055365f, -0.28798205f, 
    -0.13959458f, 0.51638776f, 0.31129724f, -0.05069479f, -0.05226014f, 0.12611060f, -0.10394615f, -0.01316133f, 
    0.20447288f, 0.28801456f, 0.08467040f, 0.41679227f, 0.82555407f, -1.07870305f, 0.70333219f, 0.50432205f, 
    -0.53646153f, 0.15998034f, 0.21824834f, 0.29154858f, 0.13123898f, -0.40166223f, 0.10438204f, 0.41867951f, 
    0.08810031f, -0.26740515f, 0.04425712f, -0.37441880f, -0.11177807f, -0.09267387f, 0.25415644f, -0.12412969f, 
    0.02317870f, 0.17904316f, -0.13219926f, 0.26817515f, -0.43278804f, -0.34315556f, 0.01465912f, -0.20734532f, 
    -0.03239150f, 0.03108940f, -0.03893759f, 0.15377954f, -0.30576068f, 0.09826646f, 0.03266692f, 0.01176053f, 
    -0.06927232f, -0.15024705f, -0.65157998f, -0.22851042f, -0.29495955f, -0.33568579f, -0.01360262f, -0.03101273f, 
    -0.44466782f, 0.08378042f, -0.70691246f, -0.31774417f, 0.53474617f, -0.12863012f, 0.66574019f, -0.11406735f, 
    -0.26569924f, -0.08134715f, -0.04089347f, 0.05663779f, -0.13185219f, 0.20063201f, -0.00967499f, -0.05467186f, 
    -0.35417521f, -0.15701026f, 0.26861295f, -0.37225804f, -0.18788926f, 0.11278951f, 0.12634452f, 0.15453900f, 
    -0.01590413f, 0.15518358f, 0.05779031f, 0.11996792f, -0.90608001f, 0.06220296f, -0.41079801f, 0.30056098f, 
    0.15170476f, 0.14705834f, 0.16733897f, -0.02041921f, 0.03037874f, 0.07653350f, 0.16448747f, 0.11429549f, 
    0.59197056f, 0.40756243f, 0.29599348f, -0.00715273f, -0.02829874f, -0.15987170f, -0.05549783f, -0.02782381f, 
    -0.10377931f, 0.00945628f, -0.08247445f, -0.04923242f, -1.33605683f, 0.52454072f, -0.15784556f, 0.16640939f, 
    0.11424274f, -0.00640821f, 0.01413726f, -0.08967259f, 0.09663980f, -0.01082348f, -0.08146165f, 0.07541751f, 
    0.14950316f, -0.30834672f, 0.08505647f, -0.01382608f, -0.11080052f, -0.02620467f, 0.02910371f, -0.50745702f, 
    0.03814167f, -0.08357384f, -0.16042483f, -0.15663671f, 0.35083082f, -0.54897618f, 0.53938556f, 0.12544222f, 
    -0.14480934f, 0.34022176f, -0.22757564f, 0.17929178f, -0.17304415f, -0.03850055f, -0.05423496f, 0.06827566f, 
    -0.07173467f, 0.14514858f, -0.22756934f, -0.22943877f, 0.06229009f, -0.08988363f, -0.00592297f, -0.10730535f, 
    -0.09636633f, -0.18059060f, -0.16502331f, -0.53659332f, -0.14324182f, -0.52334094f, 0.02674169f, -0.08436429f, 
    0.32079780f, 0.19296797f, 0.14443141f, -0.08540536f, 0.08681440f, 0.11908694f, 0.30302972f, 0.15313753f, 
    -0.44937751f, 0.16552068f, -0.20510882f, 0.20272684f, 0.03500814f, -0.05123107f, -0.04396108f, 0.29145518f, 
    -0.40354612f, 0.09402646f, 0.16695082f, 0.16211486f, -0.60368145f, -0.84999698f, 0.08316351f, 0.18934970f, 
    -0.36635119f, -0.22213386f, 0.07074737f, -0.13700540f, 0.17950276f, 0.10955189f, 0.00464050f, 0.05078861f, 
    -0.56979209f, 0.00557457f, -0.45407814f, 0.35598341f, 0.22033879f, 0.19361494f, 0.15943304f, -0.08304241f, 
    -0.03681007f, -0.16709705f, -0.03858282f, 0.06034028f, 0.27097371f, -0.05044678f, 0.71032470f, -0.79744905f, 
    -0.07483760f, 0.29155827f, -0.22479218f, 0.58769166f, 0.04173263f, 0.15922670f, 0.01902372f, -0.33600196f, 
    -0.69075519f, 0.05932860f, -0.26536405f, -0.08299591f, -0.08212246f, 0.04855694f, -0.07549377f, -0.00047769f, 
    -0.18500878f, 0.15526523f, 0.08134885f, -0.07395740f, 0.81046844f, 0.22518291f, 0.54268008f, 0.12842117f, 
    0.20107009f, 0.11873700f, -0.16419445f, 0.28176218f, -0.31354249f, 0.04536811f, -0.06738760f, 0.04204939f, 
    0.51325870f, -0.15644583f, 0.35436583f, -0.24762116f, -0.04365014f, 0.32012480f, -0.24846977f, 0.16463470f, 
    -0.26329410f, 0.03132055f, 0.25606883f, 0.05805340f, -0.44466710f, -0.05266723f, -0.11182804f, -0.17738226f, 
    0.08633476f, -0.01593586f, -0.07467871f, -0.00624527f, -0.10848702f, 0.08295738f, -0.09519165f, -0.31631804f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.27144992f, 0.15969521f, 0.13543902f, -0.20747662f, -0.28653899f, 0.25237849f, 0.11145291f, -0.25487372f, 
    0.08540919f, -0.09849235f, 0.05547038f, -0.14100674f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
