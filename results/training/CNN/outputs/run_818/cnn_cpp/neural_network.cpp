#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.71560365f, 0.55221814f, -0.14222509f, -0.19004950f, 0.27935645f, 0.24142118f, -0.19144540f, -0.55207193f, 
    0.17670475f, 0.21390229f, 0.11683840f, 0.44308743f, 0.09428336f, 0.12237082f, -0.28599012f, -0.07685315f, 
    -0.03737922f, 0.24890077f, 0.19876923f, -0.32519817f, 0.12948091f, -0.19634695f, -0.20687988f, 0.02816400f, 
    0.12631854f, 0.41630799f, 0.40896973f, 0.33558494f, 0.14764950f, 0.42227367f, 0.33054739f, -0.07918312f, 
    0.26012748f, -0.12077621f, 0.44936541f, -0.18656959f, -0.04035344f, 0.18135913f, -0.20763712f, -0.28507704f, 
    -0.20568000f, -0.33339843f, -0.02655082f, -0.17906393f, -0.21017013f, 0.28754908f, -0.34689188f, 0.19412114f, 
    0.11282392f, -0.19473879f, 0.82510281f, 0.59270382f, 0.30124173f, 0.63379961f, 0.13130192f, 0.12707742f, 
    -0.39503193f, -0.11235403f, 0.17028099f, -0.08427900f, 0.22213306f, 0.22473660f, -0.42575535f, 0.23058045f, 
    -0.18320388f, 0.15647712f, -0.22631317f, 0.11598419f, -0.19857426f, 0.09724763f, -0.03075474f, 0.36896545f, 
    0.16552712f, -0.10817946f, 0.56677806f, -0.27525690f, 0.41430697f, 0.72477603f, 0.86420184f, -0.49031499f, 
    -0.80687773f, -0.29910377f, -0.16646545f, -0.04872938f, -0.32496336f, 0.42376521f, 0.14817937f, -0.08963185f, 
    0.10914753f, 0.15664415f, -0.09355908f, 0.06866337f, 0.22134760f, -0.02105379f, 0.08301694f, -0.03606946f, 
    -0.14979471f, 0.15652564f, 0.10511162f, 0.01750482f, -0.58373964f, -0.40227941f, 0.53929240f, 0.51602042f, 
    -0.19729167f, 0.15827827f, 0.70916486f, -0.56772292f, -0.40362260f, 0.07360141f, 0.15921287f, -0.02844791f, 
    -0.26057512f, -0.13917044f, -0.11377471f, 0.03286780f, 0.31282556f, 0.19071919f, -0.15454412f, 0.16577877f, 
    -0.23299330f, -0.10773703f, 0.24979556f, 0.07412715f, -0.05849022f, 0.83985472f, 0.40757635f, 0.08867703f, 
    -0.13153368f, 0.09282693f, -0.00112283f, 0.26605392f, -0.01813574f, 0.37259907f, 0.09337414f, -0.19121896f, 
    0.16878602f, -0.13929830f, 0.19380881f, 0.08098716f, 0.08692503f, 0.15132384f, -0.25877395f, -0.14903261f, 
    0.31658068f, -0.13548444f, 0.10010450f, 0.38388020f, 0.16510402f, -0.12968561f, -0.58116758f, -0.29074925f, 
    -0.50195742f, -0.26429197f, -0.17762913f, 0.59235185f, 0.62996721f, -0.18147339f, 0.24733958f, 0.47326693f, 
    -0.10913969f, -0.19211699f, -0.00319247f, -0.48160520f, 0.10614707f, 0.00245405f, -0.07380352f, -0.12792172f, 
    0.28004396f, 0.03833795f, -0.09835003f, -0.29888090f, 0.06272955f, 0.15293847f, 0.15067266f, 0.39929995f, 
    0.62555379f, 0.13563275f, 0.02453906f, 0.51804018f, 0.03654774f, 0.17715102f, 0.54359090f, 0.25736415f, 
    0.31333750f, -0.10520715f, -0.23394084f, -0.04076616f, -0.16635637f, 0.04916704f, 0.17660192f, 0.15846767f, 
    -0.27559772f, 0.30682766f, 0.22039491f, -0.30402842f, -0.15292826f, -0.35550457f, -0.07171378f, -0.07568701f, 
    -0.43630567f, 0.35221377f, 0.08159508f, -0.45363712f, 0.42119008f, -0.46375090f, 0.41872472f, 0.40019247f, 
    0.06403220f, 0.25492412f, -0.55735672f, 0.07254748f, 0.28712004f, -0.02830179f, 0.07308211f, 0.28552330f, 
    -0.15369931f, 0.28124645f, 0.11265332f, -0.41896129f, -0.27140185f, 0.10992228f, 0.10651302f, 0.01999989f, 
    0.20690334f, 0.99592632f, -0.17031240f, -0.64321876f, 0.24155428f, 0.56978822f, -0.10850552f, -0.37616545f, 
    0.14261039f, -0.07167109f, 0.00530530f, -0.60257703f, -0.03475471f, 0.19153045f, 0.01490790f, 0.16382493f, 
    -0.03167972f, -0.31332386f, -0.07842583f, 0.01660461f, 0.04021396f, 0.23413268f, 0.16971521f, 0.03041319f, 
    -0.28554258f, -0.08439200f, -0.84919888f, 0.12724608f, -0.79226619f, -0.11630711f, 0.38071483f, -0.08736153f, 
    0.49155095f, 0.48912951f, 0.29617420f, 0.10677575f, -0.07079986f, -0.38837031f, -0.13515939f, -0.34063894f, 
    0.00651339f, 0.10537363f, 0.16932735f, -0.19823886f, -0.16255865f, -0.17016071f, -0.15962446f, 0.06975371f, 
    -0.06028860f, 0.08211947f, -0.30075485f, 0.41028714f, 0.11276639f, -0.14291623f, -0.83900511f, -0.02306116f, 
    0.59802032f, 0.00081703f, -0.15612514f, -0.51570451f, -0.66255546f, 0.31363478f, 0.16153927f, -0.05854100f, 
    0.25729805f, -0.23471530f, 0.03998714f, 0.20701425f, -0.20710033f, -0.17952850f, 0.03239248f, 0.18076049f, 
    -0.06081862f, 0.27237859f, 0.18641511f, -0.02354663f, 0.67911613f, 0.41236672f, 0.67322540f, 0.59350234f, 
    0.76203781f, 0.15409866f, -0.07210442f, -0.41800115f, -0.32321426f, -0.47644368f, 0.30897349f, -0.04861744f, 
    -0.10859634f, 0.05829094f, 0.08735245f, 0.28040886f, 0.28792503f, -0.00863058f, 0.18208526f, 0.17857340f, 
    0.18969637f, 0.03992312f, 0.21166782f, -0.11214456f, -0.04271828f, 0.00080458f, -0.15410511f, 0.21666360f, 
    0.26580629f, 0.58326852f, 0.58344114f, -0.28338814f, -0.62838793f, -0.36246309f, 0.10520793f, 0.02418153f, 
    0.36853346f, 0.07915988f, -0.06770276f, 0.06428232f, -0.15147099f, -0.31369695f, -0.07385420f, -0.13922518f, 
    0.22502591f, 0.27561626f, -0.05775993f, 0.24480286f, 0.03060853f, -0.07722488f, -0.37277091f, -1.11989903f, 
    -0.70656139f, -0.17062959f, -0.09257451f, -0.43117374f, 0.01126199f, 0.17257394f, -0.04058050f, 0.13261916f, 
    0.26694843f, 0.12732431f, -0.03986598f, 0.12578344f, 0.13991994f, 0.06318714f, -0.01371112f, -0.04033779f, 
    0.05726670f, -0.17526625f, 0.13315423f, 0.01076258f, 0.17655914f, 0.17964794f, 0.07046929f, -0.59085315f, 
    0.83755386f, 0.58830559f, -0.50987989f, 0.29839492f, -0.25520098f, 0.28527725f, -0.08419240f, -0.62469345f, 
    -0.13988072f, 0.18063375f, 0.26805490f, -0.31831387f, 0.12447686f, -0.15492280f, -0.12978134f, -0.24107660f, 
    -0.31435037f, -0.16392811f, 0.09286831f, -0.08022086f, 0.22241355f, 0.22760215f, 0.06205704f, -0.00099347f, 
    0.37017345f, 0.05986338f, -0.70490241f, -0.19875674f, 0.28961617f, -0.05196147f, -0.63347441f, -0.45252767f, 
    -0.19401059f, 0.01545583f, 0.01270335f, -0.18898310f, 0.42174998f, 0.22227621f, -0.01525183f, -0.10003084f, 
    0.35778818f, 0.00123404f, 0.01208745f, 0.13978490f, -0.15646249f, 0.09519418f, 0.28993261f, 0.11041173f, 
    0.04733655f, 0.77552021f, 0.48894867f, 0.08050319f, 0.51390958f, 0.08546856f, -0.17554252f, 0.36284900f, 
    -0.29594365f, 0.01995194f, 0.02969209f, 0.06263861f, -0.31080118f, 0.01006971f, -0.11141316f, -0.35955814f, 
    -0.06403007f, 0.32857448f, 0.13936856f, -0.24717055f, -0.08787381f, -0.14516994f, 0.24456507f, -0.23721021f, 
    -0.04559660f, 0.10516127f, -0.32718441f, -0.08569818f, 0.07826065f, -0.21465755f, -0.20644194f, -0.67504442f, 
    -0.37179750f, -0.42591268f, -0.23070097f, -0.12376270f, 0.18120328f, -0.32731321f, 0.18230215f, -0.06203913f, 
    -0.12620147f, -0.15881263f, -0.32927155f, -0.08685401f, 0.28608891f, -0.04214144f, 0.34100974f, 0.04694154f, 
    -0.07809598f, 0.00036308f, -0.13023375f, -0.42293236f, 0.56758350f, 0.13839023f, 0.16840602f, 0.30613309f, 
    -0.58685833f, 0.59135383f, 0.21706337f, -0.58692199f, -0.34181792f, -0.13042326f, -0.22671087f, 0.31361869f, 
    0.50007236f, 0.39426503f, 0.32685459f, 0.18775330f, -0.03387459f, 0.13986976f, -0.01004476f, 0.06803041f, 
    -0.18475579f, -0.17442921f, 0.14491683f, 0.00581024f, 0.45152456f, 0.43231833f, -0.00271520f, -0.43985718f, 
    -0.68699938f, 0.34907979f, 0.02789257f, 0.39208451f, -0.10371408f, 0.36651227f, -0.37433064f, 0.07309213f, 
    -0.19189902f, -0.17722723f, -0.48288572f, 0.11018804f, -0.13393527f, -0.20341860f, -0.15095635f, -0.11618368f, 
    -0.13085359f, -0.04643727f, -0.26679087f, -0.05160663f, -0.09908801f, -0.61175120f, -0.27659434f, 0.38573050f, 
    -0.36090547f, -0.59941334f, 0.29698813f, -0.22548084f, -0.41919324f, -0.38952282f, 0.15533368f, -0.06581613f, 
    0.40409461f, -0.26055384f, 0.12082078f, 0.01391264f, 0.08216102f, 0.14884271f, 0.01124131f, -0.12858114f, 
    -0.18874633f, 0.05463441f, 0.01291683f, 0.08658723f, -0.02358043f, -0.13446192f, -0.52600867f, 0.57822710f, 
    0.44549850f, -0.20630357f, 0.60545504f, 0.55181730f, -0.25522169f, -0.54783803f, -0.17671302f, -0.29468793f, 
    -0.16846436f, 0.03135657f, 0.06693736f, 0.49017084f, -0.24987267f, -0.32580817f, -0.19358410f, 0.00837363f, 
    -0.07750110f, -0.07704698f, 0.04754208f, 0.01574712f, -0.20075789f, -0.14025909f, -0.15791239f, -0.20942293f, 
    -0.39329156f, -0.10523350f, -0.23335135f, 0.14950104f, -0.00769330f, 0.39159170f, -0.25940555f, -0.36693332f, 
    0.22029363f, 0.33918294f, -0.30146980f, -0.16391601f, -0.36451116f, -0.39376336f, 0.09757284f, -0.45831442f, 
    -0.19627836f, -0.37139308f, -0.51221597f, 0.10358817f, -0.06188140f, 0.12701558f, 0.30674854f, -0.04473548f, 
    0.42560509f, 0.38915256f, 0.33454013f, 0.73547560f, 0.47025278f, -0.07667701f, 0.27750912f, 0.13857011f, 
    0.08070398f, 0.06940836f, -0.14722501f, 0.28500962f, 0.28387442f, 0.15232351f, -0.03225036f, 0.11102074f, 
    -0.27965584f, -0.16903667f, 0.11601883f, -0.12743792f, 0.24778567f, 0.03595424f, 0.19491230f, 0.10840846f, 
    -0.38468572f, -1.03414702f, 0.36754698f, -0.02872558f, -0.46732664f, -0.56657028f, 0.28994209f, 0.58094931f, 
    -0.16571091f, 0.39969507f, 0.32489899f, 0.19512288f, 0.03080905f, -0.15437512f, 0.02240290f, 0.19512644f, 
    0.08878137f, -0.02739397f, 0.09212598f, 0.12482192f, -0.19292936f, 0.11227009f, 0.01558750f, 0.09553678f, 
    -0.01261004f, 0.15301733f, -0.38525972f, 0.13484380f, 0.62925321f, 0.52540815f, 0.14253643f, 0.22250675f, 
    -0.12396686f, 0.10073045f, 0.31362435f, 0.23388708f, -0.29888982f, 0.14603265f, -0.22166981f, 0.38543025f, 
    0.03231143f, -0.23584393f, 0.05820687f, -0.03293464f, -0.15808843f, -0.21354213f, -0.22336107f, -0.18384717f, 
    -0.31609339f, -0.06427076f, -0.30443355f, 0.37838864f, 0.47874114f, -0.17265603f, 0.61212260f, 0.18745068f, 
    0.37471363f, 0.33238485f, 0.22851907f, -0.11879259f, 0.28914544f, -0.35353175f, 0.12466603f, 0.15719214f, 
    -0.06484507f, 0.13838015f, -0.10080301f, 0.00877899f, 0.08074839f, -0.10866981f, 0.01675864f, -0.13838203f, 
    -0.01210677f, 0.02210284f, -0.00588705f, 0.15264311f, -0.23598215f, -0.39286560f, -0.59715521f, -0.50736743f, 
    -0.51696342f, 0.08666282f, 0.73924416f, 0.46579331f, -0.19962625f, 0.16431038f, -0.06990897f, -0.13412023f, 
    -0.12779966f, 0.00215090f, -0.17422442f, -0.16274633f, 0.18664953f, 0.21717383f, 0.05013734f, -0.01110719f, 
    -0.17806943f, 0.01926396f, 0.01034380f, -0.31363943f, 0.00415759f, -0.42188379f, -0.84252274f, 0.01064616f, 
    0.64967257f, 0.28859621f, -0.42477375f, 0.07048152f, 0.46167561f, 0.01529804f, -0.34871393f, 0.30827761f, 
    0.16496825f, 0.22581181f, 0.25620985f, 0.13137357f, -0.25486866f, 0.00504455f, 0.18424694f, -0.42171809f, 
    0.12029133f, 0.00625760f, -0.02717825f, -0.32619160f, -0.33003679f, 0.13934068f, 0.64516306f, -0.92531097f, 
    0.27119184f, -0.31281519f, 0.41425872f, -0.68642259f, 0.67547721f, 0.10073576f, -0.24893099f, 0.18750964f, 
    0.08226341f, 0.15721281f, -0.13081746f, -0.12367745f, 0.06365415f, -0.15205134f, 0.05219527f, -0.09647142f, 
    0.09863994f, -0.13706128f, 0.12446284f, -0.09367690f, 0.15144779f, -0.11331658f, 0.19442393f, -0.50353271f, 
    0.47561297f, -0.45061755f, -0.18813093f, -0.54444021f, 0.16856462f, -0.21671478f, -0.21147463f, 0.12081482f, 
    -0.28050083f, -0.25763527f, -0.21669725f, 0.10641701f, -0.04939255f, -0.11254927f, 0.18466198f, 0.38906479f, 
    0.25644833f, -0.09536646f, -0.10898549f, 0.10874901f, -0.20996407f, -0.29762378f, 0.06037221f, 0.37593511f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10509060f, 0.09869481f, -0.00267915f, 0.17680301f, -0.06105899f, 0.01285554f, -0.02513701f, 0.00463060f, 
    -0.06142563f, 0.10390763f, 0.06252602f, 0.27034512f, 0.15291920f, 0.01060459f, 0.19891238f, 0.06346173f, 
    0.14177558f, 0.19030145f, 0.09053756f, -0.08908685f, -0.03940957f, 0.08063912f, -0.01457542f, 0.09070714f, 
    0.11074314f, 0.05740085f, 0.13692018f, 0.22303011f, 0.10017808f, -0.02195883f, -0.00874062f, 0.16064563f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.14712337f, 0.06606311f, 0.15375723f, 0.01885683f, -0.00619623f, -0.03477459f, 0.02045021f, 0.07116409f, 
    0.07508962f, 0.01923108f, 0.00537256f, -0.04185112f, 0.12863776f, 0.17669579f, 0.18312088f, 0.07368111f, 
    -0.08154295f, -0.03518932f, 0.05210084f, 0.08962102f, -0.06580795f, -0.04253741f, 0.08853243f, 0.05213300f, 
    0.12251754f, -0.03479055f, 0.05882770f, 0.18063527f, -0.01715797f, -0.02144699f, -0.01544361f, 0.02372808f, 
    0.00693784f, 0.00599629f, 0.02545296f, 0.01288512f, 0.22793077f, 0.04582293f, -0.20903306f, -0.02822666f, 
    0.11768769f, -0.02409241f, -0.06070917f, -0.05053821f, -0.03196734f, 0.06208111f, 0.09941815f, 0.14236656f, 
    0.32998723f, -0.32783404f, 0.02881468f, 0.09724355f, 0.00709413f, -0.07727005f, 0.20041776f, -0.03962132f, 
    -0.04720017f, 0.05361619f, 0.21919315f, -0.02455324f, 0.30366307f, 0.03497086f, 0.04388069f, 0.06495830f, 
    0.02478633f, 0.01331641f, 0.19266374f, -0.10277779f, -0.17699847f, -0.01045237f, 0.07956387f, -0.04835717f, 
    0.30323318f, 0.11627916f, 0.03260615f, -0.18215615f, -0.03861553f, 0.12998551f, -0.03495542f, 0.00730296f, 
    0.07501518f, 0.12261385f, -0.08302416f, 0.11091091f, 0.05487933f, 0.29279119f, 0.19192584f, 0.06439158f, 
    0.00121303f, 0.00887124f, 0.09319450f, 0.01732189f, 0.00449655f, 0.02305027f, -0.05011848f, 0.01394662f, 
    -0.13525671f, 0.04938378f, 0.05772128f, -0.11710119f, -0.02134706f, 0.14412595f, -0.13196753f, 0.06882829f, 
    0.02145953f, -0.03789670f, 0.01389669f, 0.06114266f, -0.12575583f, -0.19128925f, 0.17546655f, -0.32820490f, 
    0.01843549f, 0.05197015f, -0.10752014f, 0.10435383f, -0.02097287f, -0.02206476f, -0.03109747f, 0.00957341f, 
    -0.10037003f, 0.14817850f, 0.12094013f, -0.15718295f, 0.14790484f, 0.03030245f, -0.05351264f, -0.04041271f, 
    0.16677943f, 0.04347929f, -0.09086727f, -0.05399726f, -0.09037289f, -0.12680043f, -0.10475638f, -0.04006432f, 
    -0.07997334f, -0.00773722f, 0.11851234f, -0.06948347f, 0.03128655f, -0.00872765f, -0.11439059f, 0.08292168f, 
    0.26676756f, -0.01467018f, 0.04334794f, 0.12534621f, -0.02282285f, 0.02476704f, -0.00026708f, -0.07305877f, 
    0.01604104f, 0.01111418f, -0.06328481f, 0.02046249f, 0.13057652f, -0.11358815f, 0.09494415f, -0.00809027f, 
    -0.14667167f, 0.05564195f, 0.04967090f, -0.00349655f, 0.01362548f, 0.01504396f, 0.02376500f, -0.06750415f, 
    0.03470843f, -0.10860762f, 0.05456081f, -0.02390906f, -0.03405951f, 0.03128269f, 0.02390159f, -0.02958745f, 
    -0.04181616f, -0.13920698f, -0.00845239f, 0.07818986f, 0.06996669f, -0.09487953f, -0.15763810f, 0.06971115f, 
    0.04363648f, 0.08175871f, 0.13170923f, -0.08043880f, -0.05810400f, -0.02202514f, -0.01848025f, -0.02480970f, 
    -0.06648512f, -0.08925844f, -0.02183106f, -0.24383564f, 0.10137882f, -0.11895292f, 0.03512683f, 0.02659546f, 
    -0.11980081f, -0.01971230f, 0.11813598f, -0.03454202f, 0.38791281f, 0.14442396f, 0.00920282f, 0.05539955f, 
    -0.12643689f, -0.07249771f, 0.00050311f, -0.01663400f, -0.02406345f, -0.12512524f, -0.06376015f, -0.06283808f, 
    -0.12604903f, -0.14075921f, -0.15507947f, -0.12272803f, -0.02774214f, -0.02663308f, -0.04030567f, -0.00967864f, 
    -0.07278538f, 0.00829724f, 0.00453765f, -0.02229545f, 0.14725237f, 0.01709368f, -0.05757195f, -0.04436938f, 
    -0.03707344f, 0.05232964f, -0.07227628f, -0.06541124f, 0.12779425f, 0.02773280f, 0.01738566f, -0.00427544f, 
    0.16484308f, 0.06075570f, -0.10579782f, -0.07487810f, -0.02369066f, -0.02697792f, -0.04516919f, -0.07184266f, 
    -0.06653790f, -0.02920558f, -0.06417764f, -0.10945223f, -0.20611595f, 0.02145320f, -0.02447375f, 0.04727552f, 
    -0.01740050f, -0.14312778f, 0.06235388f, -0.00442288f, 0.05562453f, -0.02237459f, 0.10285224f, -0.15802063f, 
    -0.08170467f, -0.14051142f, 0.16639441f, 0.03875896f, -0.01447421f, 0.00274187f, 0.04378775f, -0.11594172f, 
    0.01671895f, 0.03340123f, -0.06398277f, -0.09008130f, 0.19483148f, -0.12897927f, 0.03431932f, -0.06867297f, 
    -0.04406691f, 0.11112048f, -0.06347500f, -0.00298935f, -0.07732200f, -0.04696559f, 0.01994017f, 0.05519935f, 
    0.23784578f, 0.15055540f, 0.15813978f, 0.09881192f, 0.04728939f, 0.06208954f, -0.00454955f, -0.03807317f, 
    0.04694930f, 0.01072452f, 0.03899375f, 0.03754289f, 0.16593669f, 0.02703827f, -0.11915792f, -0.01350107f, 
    0.02567484f, 0.03276937f, -0.05465835f, -0.02442816f, -0.04701231f, -0.00537263f, -0.04668848f, -0.11692698f, 
    0.12705918f, 0.03527788f, -0.01171465f, 0.08627556f, -0.04066176f, 0.06409549f, -0.07819201f, -0.12266779f, 
    -0.04695693f, -0.01668854f, 0.04842749f, -0.08768714f, 0.15967686f, 0.17172907f, 0.15541054f, 0.09489625f, 
    -0.11236525f, 0.04762492f, 0.01589780f, -0.04759530f, 0.03819626f, 0.06218191f, 0.06749827f, -0.03841233f, 
    0.24661483f, 0.20285347f, -0.09660951f, -0.14145516f, 0.01211009f, -0.06754967f, -0.01271013f, 0.01886946f, 
    0.03065702f, -0.08800375f, 0.01646032f, -0.04490639f, 0.13741526f, -0.07941759f, 0.10765830f, 0.12690486f, 
    -0.05094348f, 0.16931802f, -0.04693653f, -0.03812874f, -0.03874117f, -0.04044377f, 0.15922712f, 0.02634193f, 
    0.50697345f, -0.10500194f, 0.11338551f, -0.03393084f, -0.02205267f, -0.05778349f, 0.04273705f, -0.00897920f, 
    0.06804383f, -0.00861856f, -0.08356749f, 0.07711709f, -0.10873493f, 0.06059027f, -0.14220275f, 0.09468644f, 
    0.02786971f, 0.01333924f, -0.07125767f, -0.04999071f, 0.06526276f, -0.05693606f, -0.06659094f, -0.09719499f, 
    -0.21746209f, -0.28290182f, 0.16940019f, -0.07482766f, -0.04606908f, -0.04557231f, 0.08122142f, 0.04977812f, 
    0.01306895f, 0.05289343f, -0.04842575f, -0.04000431f, -0.10390209f, -0.02910104f, 0.08891629f, 0.10485552f, 
    -0.09510627f, 0.05063516f, 0.11693708f, 0.07254612f, -0.09311755f, 0.01478095f, -0.02235454f, 0.15890864f, 
    -0.06484325f, -0.04283551f, 0.16210899f, 0.22275037f, -0.13862839f, -0.13959885f, 0.06661188f, 0.06162984f, 
    0.14742945f, 0.06288414f, -0.00219218f, 0.04711809f, -0.24662401f, 0.00368167f, -0.18211941f, 0.16455194f, 
    -0.04575446f, 0.09043642f, -0.04144826f, -0.10990257f, 0.04386398f, 0.09910050f, 0.02166283f, 0.00809221f, 
    -0.15228750f, 0.11235229f, -0.01986720f, -0.09003661f, -0.11681397f, 0.09345564f, -0.18627976f, 0.05076839f, 
    0.02312518f, 0.02341533f, 0.02269332f, -0.00247501f, -0.06277291f, -0.05887906f, 0.03917133f, -0.17117704f, 
    0.02167664f, 0.05074935f, 0.02932463f, -0.02218298f, -0.02037992f, 0.13707954f, 0.05393795f, 0.05723120f, 
    0.13020223f, 0.06898364f, 0.06020372f, 0.09058630f, 0.02067582f, -0.11747404f, 0.01918944f, 0.06604202f, 
    0.09762993f, 0.08440587f, 0.02129416f, 0.11268511f, -0.01581959f, -0.02526670f, -0.08915910f, -0.06662311f, 
    0.03890575f, 0.04540861f, 0.03789360f, 0.07621645f, -0.00676534f, -0.03111462f, 0.01341383f, -0.11424460f, 
    -0.03496805f, -0.01028283f, -0.04160951f, -0.00571877f, -0.03634513f, 0.05505512f, 0.01873991f, -0.03883825f, 
    -0.01307813f, -0.01107037f, -0.09092510f, 0.08163486f, 0.40385786f, -0.32418051f, 0.12866473f, 0.12536015f, 
    0.02001479f, 0.09960948f, 0.11133944f, 0.10121179f, -0.02681943f, 0.08989799f, -0.06985831f, 0.02272599f, 
    0.23259534f, 0.07090662f, -0.03108027f, -0.00207009f, -0.01640741f, 0.18185373f, -0.01777991f, 0.06162630f, 
    0.03278174f, 0.05547143f, 0.06349780f, 0.06933174f, -0.12166148f, 0.00571760f, 0.12249160f, -0.36832684f, 
    0.05888809f, -0.13175520f, 0.11381435f, -0.07345972f, -0.01322253f, 0.04783171f, 0.04363773f, -0.01403584f, 
    -0.17489827f, 0.10389809f, 0.07481122f, -0.08382022f, -0.10304534f, -0.03603417f, -0.00840554f, 0.10870724f, 
    0.03157121f, -0.07837471f, -0.00337101f, -0.06830738f, -0.22782154f, 0.03587325f, 0.08724631f, 0.00156417f, 
    0.01283337f, -0.15285330f, -0.06682440f, -0.07970288f, -0.01120434f, -0.08178295f, 0.05896561f, 0.01054018f, 
    0.28651342f, -0.02451849f, -0.12328746f, 0.13392393f, 0.05939604f, 0.07075321f, 0.04442757f, 0.13064837f, 
    -0.11078856f, 0.07082489f, 0.04604973f, 0.02239829f, -0.12486986f, 0.22264963f, 0.06583308f, -0.23409484f, 
    0.10358377f, 0.02052091f, -0.02150055f, -0.12886728f, -0.01656099f, 0.03952147f, -0.06221785f, -0.11261116f, 
    0.07194538f, -0.18346472f, 0.12564132f, 0.04374752f, 0.04545151f, 0.02332364f, 0.07124785f, 0.03680998f, 
    -0.06770869f, 0.08571378f, 0.01132998f, -0.02041317f, 0.04614879f, -0.02263802f, 0.10615326f, -0.00658108f, 
    -0.09816379f, 0.04981326f, 0.09402182f, -0.00376620f, 0.01155180f, -0.04033497f, -0.07312988f, -0.10202549f, 
    0.00465216f, -0.00423275f, 0.01159416f, 0.06587160f, 0.07979912f, 0.11870622f, -0.13798749f, 0.07137188f, 
    -0.03657070f, 0.01520288f, 0.01453339f, -0.06715047f, -0.20822476f, 0.16833445f, -0.05884503f, 0.06855007f, 
    -0.04384195f, 0.04733494f, 0.03551277f, -0.04914135f, -0.02855337f, 0.02124792f, -0.06779302f, -0.00154740f, 
    -0.28949955f, -0.18901332f, 0.18385564f, 0.03439008f, 0.09402302f, 0.10755830f, 0.13806751f, -0.04726176f, 
    -0.08592195f, -0.02821283f, 0.04984091f, -0.01010276f, 0.23907858f, 0.17184490f, 0.16970466f, -0.01934149f, 
    0.08298917f, 0.00422037f, -0.00802005f, 0.04119499f, 0.02515794f, 0.00667710f, -0.07498689f, 0.07182310f, 
    0.05332113f, 0.34689283f, -0.05846507f, -0.13725822f, 0.07961617f, -0.00438885f, 0.00100654f, 0.02233370f, 
    -0.00998919f, 0.02999029f, -0.05523050f, -0.01690999f, -0.08543449f, 0.16522448f, 0.10289356f, -0.05043908f, 
    -0.11378306f, 0.03177482f, -0.14800204f, 0.08284014f, 0.06430390f, -0.08828961f, -0.02060525f, 0.00217216f, 
    -0.08127583f, 0.16437083f, -0.11215604f, 0.21430115f, -0.11220006f, 0.09487345f, 0.05785403f, -0.00893579f, 
    0.03743739f, 0.02474293f, -0.00884322f, 0.03217096f, 0.25222418f, 0.20573610f, -0.00367487f, -0.06385095f, 
    0.07581740f, 0.03599328f, 0.03516407f, 0.03747829f, 0.02232055f, 0.06437470f, -0.03159572f, 0.00209369f, 
    0.01858827f, 0.10250524f, -0.21766084f, 0.10473656f, -0.05697980f, 0.04133981f, -0.04842230f, 0.02107666f, 
    -0.07220345f, 0.00877184f, 0.08918012f, 0.01285218f, -0.03002954f, 0.05818093f, -0.02838791f, 0.03676558f, 
    -0.01752699f, -0.03747532f, 0.05673362f, 0.07697974f, -0.01178316f, -0.05634788f, 0.04743944f, -0.02517711f, 
    -0.00908760f, 0.11838027f, 0.21959917f, 0.06250530f, -0.05217781f, -0.01176618f, 0.12705438f, 0.11931042f, 
    0.01863552f, 0.01226681f, -0.05914985f, -0.00577207f, 0.04297048f, 0.13512333f, -0.16877048f, 0.11689334f, 
    -0.00569161f, -0.01524027f, 0.01594918f, 0.02111504f, -0.10679074f, -0.01511291f, -0.03180911f, -0.04174400f, 
    0.13651846f, -0.24727999f, 0.20797455f, -0.20014450f, -0.02620666f, 0.07462607f, -0.06240037f, -0.05564722f, 
    -0.00202528f, 0.03082438f, 0.03493074f, -0.02547247f, 0.16415967f, 0.03788083f, 0.05607378f, 0.05287758f, 
    0.04364058f, 0.08221834f, 0.15529512f, 0.20456481f, -0.05872538f, 0.12019290f, -0.01870687f, -0.03870068f, 
    -0.11145225f, 0.04557725f, 0.23440951f, -0.16431549f, -0.07736348f, -0.07597526f, -0.01997411f, -0.01111396f, 
    -0.00098971f, -0.01956176f, 0.00499599f, -0.08309318f, 0.21521789f, 0.16038321f, 0.12674071f, 0.18410045f, 
    -0.10467024f, 0.09657724f, 0.13427316f, 0.00033864f, -0.03605902f, -0.02058448f, 0.00774025f, 0.11605044f, 
    0.02854698f, 0.23017173f, 0.31117779f, 0.31552976f, -0.06101850f, -0.02122532f, -0.01493534f, -0.06880124f, 
    -0.02830996f, 0.00220328f, 0.03216961f, -0.02177386f, -0.20749447f, -0.11835836f, -0.12879939f, 0.10218824f, 
    -0.00860801f, 0.00163965f, -0.03856477f, -0.14432523f, 0.06918457f, 0.05077202f, -0.02086689f, -0.04756201f, 
    -0.06687032f, -0.14508207f, -0.24991226f, -0.17810966f, -0.10376026f, 0.10380016f, -0.07211306f, -0.02611675f, 
    0.01174194f, 0.03115047f, 0.01530036f, 0.04231723f, 0.19801034f, 0.16888557f, 0.05500786f, -0.13282146f, 
    0.05678315f, 0.02728423f, -0.04409793f, -0.04427053f, 0.02300556f, 0.09499483f, 0.11605129f, 0.08325731f, 
    0.02716204f, -0.09376127f, 0.18043122f, 0.14374179f, 0.10621760f, -0.06750072f, 0.01522259f, 0.06352449f, 
    -0.01295793f, 0.08603312f, 0.02710036f, 0.08914905f, 0.34118235f, -0.03332968f, 0.07204181f, 0.09780328f, 
    0.03751890f, 0.04130169f, 0.15052576f, 0.10288943f, 0.05987484f, -0.00026913f, 0.04303629f, -0.14731114f, 
    0.22568163f, -0.10744786f, -0.03519537f, -0.07140777f, 0.01378440f, 0.07643691f, -0.02614016f, 0.01773560f, 
    0.05592290f, -0.04885893f, -0.08371407f, 0.07128666f, 0.13029420f, -0.23056245f, 0.08396941f, -0.03666920f, 
    -0.13804087f, 0.09521422f, 0.06386875f, 0.00786739f, -0.02802502f, 0.04477790f, -0.02817235f, 0.11688416f, 
    0.36772433f, -0.06168378f, -0.12191010f, 0.08769603f, 0.05319739f, 0.18950117f, -0.09691929f, 0.09961759f, 
    0.05917835f, -0.04278903f, 0.06823690f, 0.09931298f, -0.10680882f, 0.10675037f, 0.12325172f, -0.32164589f, 
    0.11645392f, -0.09617934f, 0.00217239f, -0.03496973f, -0.10876040f, -0.03866088f, 0.11400227f, 0.02036162f, 
    -0.11525967f, 0.20803672f, 0.12341324f, 0.04288967f, -0.00659953f, -0.08410531f, -0.01294782f, 0.11605193f, 
    0.06207356f, 0.00608178f, -0.02170669f, -0.06089751f, -0.39411139f, 0.04648550f, -0.10520148f, -0.27388057f, 
    -0.01843845f, -0.08630438f, -0.11484724f, -0.02526293f, -0.05102575f, -0.08477262f, 0.04810597f, -0.05064431f, 
    0.06952383f, -0.16051330f, -0.09052426f, 0.24311739f, -0.03466993f, 0.08894414f, 0.04021156f, 0.10487055f, 
    -0.09696860f, 0.02533032f, 0.03154786f, 0.03619849f, 0.06059246f, -0.02094668f, -0.01742685f, -0.24469215f, 
    -0.00104234f, -0.05422156f, -0.00279488f, -0.13987546f, -0.05566525f, 0.01523046f, -0.11472984f, -0.03244254f, 
    -0.16142945f, -0.16719575f, 0.17098030f, -0.06337224f, -0.01251145f, 0.05172117f, 0.08426058f, -0.01359571f, 
    -0.06399745f, -0.08964393f, -0.03189912f, -0.04637268f, 0.21994926f, 0.10049363f, 0.12097786f, 0.07219319f, 
    -0.15151760f, -0.02384219f, 0.09778238f, 0.00411282f, -0.01721375f, -0.01367755f, -0.01817551f, 0.00639936f, 
    -0.22641294f, -0.27561584f, 0.03903682f, 0.00980183f, 0.00142800f, 0.06169757f, -0.02253246f, 0.11687414f, 
    0.02245356f, 0.03863297f, -0.00561901f, -0.06162532f, 0.35595936f, 0.13003604f, -0.20555249f, -0.00520552f, 
    0.02788120f, 0.04699405f, 0.08238475f, -0.07167894f, 0.06163549f, 0.05238046f, 0.01194715f, -0.14648087f, 
    0.05462964f, 0.05269727f, 0.21509948f, -0.10358387f, 0.09370103f, -0.05649026f, 0.09213405f, 0.04121188f, 
    -0.01953131f, 0.02124417f, 0.10117339f, 0.06942096f, -0.02632684f, -0.00028165f, 0.05997234f, -0.07824413f, 
    0.10925078f, -0.13829020f, -0.01564275f, 0.09420438f, -0.01251299f, 0.00970732f, -0.03454873f, 0.04896037f, 
    -0.14086427f, 0.24023996f, -0.23925455f, -0.26532215f, -0.06462966f, -0.07937668f, -0.04994352f, -0.00502086f, 
    -0.16967195f, -0.01139741f, 0.01963379f, -0.03174937f, -0.05070839f, 0.00978906f, 0.00395065f, -0.09735943f, 
    -0.05277013f, 0.08826225f, -0.03458254f, 0.00694183f, 0.02399475f, -0.00259372f, -0.05058674f, 0.04346422f, 
    0.16312557f, 0.18997885f, -0.00231487f, 0.39473307f, -0.07251642f, 0.04033146f, 0.08026823f, 0.02143790f, 
    0.03059041f, -0.02735331f, 0.01604441f, -0.02709823f, 0.15372449f, 0.01868619f, -0.00578603f, -0.00918917f, 
    0.05149204f, -0.01201294f, 0.00649378f, 0.14852940f, 0.10447447f, 0.02780622f, 0.01194026f, -0.00862755f, 
    0.19712763f, 0.05094970f, -0.20217796f, 0.18018821f, -0.00854171f, 0.14161630f, -0.05867934f, -0.01253458f, 
    -0.04142648f, -0.08189893f, 0.07380839f, -0.00694901f, 0.28162044f, 0.20351131f, 0.07613400f, 0.18096863f, 
    -0.02681027f, 0.04578418f, 0.03353443f, 0.00917048f, 0.03075333f, 0.03561567f, 0.02793238f, -0.02791681f, 
    -0.04112065f, 0.14032972f, 0.24260299f, 0.06556299f, -0.03146332f, 0.00844179f, 0.07026176f, 0.16654229f, 
    -0.02050740f, -0.03846644f, -0.04400310f, -0.01166654f, 0.08494931f, 0.00906521f, -0.21920721f, 0.18950191f, 
    0.00427143f, -0.07588912f, 0.08240366f, 0.01907371f, -0.00641346f, -0.09102955f, -0.02181883f, 0.00568679f, 
    0.21459910f, -0.26631549f, 0.01940065f, -0.12909539f, -0.03339662f, -0.06372313f, -0.09204009f, -0.03619267f, 
    -0.00302912f, 0.01764050f, 0.02916934f, 0.01918643f, -0.11572038f, -0.07070137f, 0.16572851f, -0.07497232f, 
    0.06939505f, -0.04640869f, 0.11557928f, 0.26537088f, -0.00923893f, 0.05459092f, -0.02022380f, 0.01440868f, 
    0.03199591f, 0.02093692f, -0.00974416f, 0.01580771f, -0.03181380f, -0.03842405f, 0.00596021f, 0.00485725f, 
    -0.02638192f, -0.05341024f, 0.03461583f, -0.00462226f, -0.02458590f, -0.03057039f, -0.02303968f, -0.05812227f, 
    -0.05714354f, 0.01360602f, -0.02277655f, -0.00050873f, 0.03775989f, 0.02909236f, 0.01628183f, -0.05399565f, 
    -0.01390278f, 0.04372629f, -0.02873615f, -0.01451716f, 0.02370150f, -0.00297976f, 0.03978513f, -0.04246388f, 
    -0.05222803f, -0.01124667f, 0.00705716f, 0.02505632f, -0.03199891f, 0.00127105f, -0.02997776f, -0.03091844f, 
    0.03916445f, -0.00648676f, -0.05494605f, 0.04164705f, 0.03490649f, -0.03145864f, -0.01091781f, -0.01472994f, 
    -0.01185726f, 0.01410814f, -0.05160107f, -0.05759738f, -0.01471463f, 0.02903701f, -0.05595019f, -0.05651248f, 
    -0.02319184f, -0.03040184f, 0.00073829f, 0.02484815f, 0.03774105f, 0.02278516f, 0.01115309f, -0.02946764f, 
    0.00224739f, 0.00462419f, 0.03470888f, -0.03554877f, -0.04411639f, 0.00611359f, -0.05117633f, -0.01952556f, 
    -0.00220361f, 0.00871545f, 0.00046922f, 0.00835842f, -0.04877511f, 0.03521238f, 0.00964337f, -0.02729714f, 
    0.00557157f, -0.04128410f, 0.03935020f, -0.04662244f, -0.04798796f, 0.01584579f, -0.02831302f, 0.03183770f, 
    -0.03327620f, -0.02732327f, -0.02201644f, 0.02562897f, 0.01837292f, -0.03517301f, -0.01294984f, 0.02572321f, 
    0.01427162f, -0.00199611f, -0.05299636f, -0.02308823f, -0.02619968f, -0.02012318f, -0.00702902f, 0.03296996f, 
    0.02902887f, 0.01023170f, -0.01654007f, -0.00219638f, 0.00308065f, 0.02486395f, 0.02309178f, -0.00244232f, 
    0.02060185f, 0.02478213f, 0.00933374f, -0.02079790f, 0.01523685f, -0.00641928f, -0.00336635f, -0.04673059f, 
    0.01487460f, -0.04060584f, -0.03520262f, 0.03785889f, -0.00106979f, 0.01786673f, -0.03788188f, -0.03201655f, 
    -0.04345747f, 0.00516445f, 0.00262190f, 0.02990688f, 0.02256476f, -0.01748521f, -0.03838259f, 0.02911627f, 
    0.02635135f, 0.00552076f, -0.00666297f, -0.03270733f, 0.00431035f, 0.02597780f, -0.00470479f, -0.00594339f, 
    0.00030387f, 0.00872322f, -0.05656283f, 0.03582063f, -0.03228943f, -0.02161835f, -0.02547844f, -0.00654028f, 
    -0.05807976f, -0.05027964f, -0.00372032f, -0.00513973f, -0.00337009f, -0.05334591f, -0.02672552f, 0.02887899f, 
    -0.02018489f, 0.00752579f, 0.02454800f, 0.00240249f, -0.01754964f, -0.03542386f, 0.01535167f, -0.03373855f, 
    -0.03650499f, -0.02965453f, 0.03243788f, 0.03178545f, -0.05598585f, 0.01810535f, 0.00410023f, -0.04820560f, 
    0.02972889f, -0.01048793f, 0.00785967f, -0.04761727f, -0.04331525f, 0.01245491f, -0.03881771f, -0.05443650f, 
    0.01673933f, 0.00990608f, -0.01126644f, -0.00689886f, 0.01538201f, -0.02174140f, -0.05377961f, -0.02762178f, 
    -0.01958650f, -0.04885846f, 0.02241223f, -0.05661592f, -0.03487629f, 0.00885310f, 0.04470998f, -0.05289190f, 
    0.01358116f, -0.05111768f, -0.05654278f, -0.00076255f, 0.01289994f, 0.00517631f, -0.00824345f, 0.00527415f, 
    0.00630763f, -0.05471018f, -0.05278427f, 0.01257826f, 0.03824797f, 0.01749472f, -0.03084148f, -0.03987406f, 
    -0.01201980f, 0.01592315f, -0.03930691f, -0.03500034f, 0.01169249f, -0.05679456f, 0.02309565f, 0.00114700f, 
    0.03703296f, -0.04724320f, 0.01565174f, -0.05476709f, -0.02010515f, 0.03757177f, 0.01376144f, -0.00311872f, 
    0.00683980f, -0.01431679f, -0.01607825f, 0.02378951f, -0.03578589f, 0.02457856f, 0.01235429f, 0.02251825f, 
    0.01380766f, -0.01593395f, -0.00309297f, -0.03487585f, -0.04463282f, -0.00649340f, 0.03921239f, -0.01379886f, 
    -0.02290293f, -0.02397621f, 0.01604207f, 0.02225574f, -0.01566087f, -0.05543059f, 0.03380562f, -0.03114137f, 
    0.00471994f, -0.05846680f, 0.03832893f, 0.00230633f, -0.00746001f, -0.02191377f, -0.04025707f, -0.00777557f, 
    0.00173390f, -0.04888763f, -0.04772338f, -0.02247392f, 0.04454176f, 0.02780664f, -0.04029584f, -0.01043258f, 
    -0.02663191f, -0.02675549f, 0.00537127f, 0.04001133f, 0.01329608f, -0.05675819f, -0.03842598f, 0.01646282f, 
    -0.04136153f, -0.05187519f, -0.01793865f, 0.02199600f, -0.03028876f, -0.02811369f, 0.03314322f, 0.02793149f, 
    -0.04698580f, 0.04227328f, -0.01914410f, -0.03007755f, 0.04368472f, -0.01969751f, -0.00725582f, -0.03480746f, 
    0.02885349f, 0.00747928f, 0.00865946f, 0.04115630f, -0.03372895f, -0.02426450f, -0.01133735f, -0.03405307f, 
    -0.04169909f, 0.03052926f, 0.03402172f, 0.02639385f, 0.02206359f, -0.02025811f, 0.03173221f, -0.03151916f, 
    0.03547663f, 0.00592895f, -0.02486984f, -0.00300463f, -0.06134216f, 0.02091309f, -0.05418512f, 0.02430438f, 
    0.01466458f, -0.00092732f, -0.00424803f, -0.00892372f, -0.04533705f, -0.00070196f, -0.03047764f, 0.03079308f, 
    0.00775918f, -0.03579205f, -0.04074292f, 0.00562828f, 0.00755355f, 0.00225343f, -0.04327207f, -0.03760989f, 
    -0.03450703f, 0.01578614f, 0.02716309f, 0.01958323f, -0.00101562f, -0.02083059f, -0.02385989f, 0.02336107f, 
    0.00335755f, 0.04030333f, -0.05280821f, -0.01562153f, -0.03953056f, -0.03777391f, -0.03852991f, -0.02211028f, 
    -0.04312407f, -0.01474456f, 0.01423101f, -0.01843843f, -0.03746747f, 0.01169844f, -0.02689927f, 0.02793380f, 
    0.02515498f, 0.02817600f, -0.00500363f, -0.05475389f, 0.02786446f, -0.02415871f, -0.04781199f, -0.00287380f, 
    0.02123941f, 0.01865819f, -0.05768202f, 0.00801574f, -0.05702936f, -0.01115001f, -0.00480339f, 0.03246327f, 
    0.02907838f, 0.03789115f, -0.03650669f, 0.02288506f, 0.01013273f, -0.03035446f, 0.01532727f, 0.02968056f, 
    0.00928630f, 0.02398427f, -0.00530956f, -0.01875206f, -0.04419977f, 0.03493398f, -0.00814913f, -0.05043600f, 
    -0.05055919f, -0.00392082f, -0.05155009f, -0.03183822f, -0.02813479f, -0.01157741f, 0.03568229f, -0.05857847f, 
    -0.01870981f, 0.04801087f, 0.03891757f, -0.02240960f, -0.00786790f, 0.00716434f, -0.06268316f, 0.03261308f, 
    -0.00833302f, 0.00876621f, -0.01777943f, 0.00951372f, 0.00308826f, -0.00451362f, 0.01215299f, -0.01234646f, 
    -0.04501261f, 0.04217029f, 0.03991049f, -0.03612080f, -0.01711210f, 0.00565947f, 0.04780916f, 0.03719737f, 
    -0.05049312f, 0.01598368f, -0.03113690f, -0.00544281f, 0.01456116f, -0.01491799f, 0.00186571f, -0.05232183f, 
    -0.02870858f, 0.00086304f, -0.05171776f, 0.03803410f, 0.00563612f, -0.05200111f, -0.01462020f, -0.02296655f, 
    0.01751556f, -0.01574547f, 0.02151101f, -0.00328289f, 0.01771283f, -0.04873225f, 0.02968773f, -0.02860432f, 
    0.04176672f, -0.00038155f, 0.02063891f, 0.00004716f, 0.00613690f, -0.03103370f, 0.03521600f, 0.00566973f, 
    -0.06208964f, 0.02366560f, 0.02840353f, 0.03119460f, -0.02824642f, -0.03391194f, 0.01806562f, 0.04031323f, 
    -0.05310265f, 0.01069223f, -0.04177030f, 0.00471980f, -0.00567961f, 0.01998509f, -0.04935043f, -0.01256307f, 
    -0.01398566f, -0.04369032f, 0.00245489f, -0.04343157f, -0.00066308f, 0.04591209f, -0.03782671f, -0.02974186f, 
    -0.05264919f, -0.04261051f, -0.01053538f, 0.02246382f, -0.00616679f, -0.01539701f, 0.04408439f, 0.01595598f, 
    0.00981058f, -0.02932883f, -0.03008152f, 0.02226388f, 0.00404338f, -0.00518639f, -0.02820774f, -0.03726906f, 
    -0.00815853f, 0.01317999f, -0.00370019f, 0.02834930f, 0.01164612f, 0.02406660f, 0.02715806f, 0.03904904f, 
    0.02599841f, 0.00044218f, -0.04194748f, 0.02912731f, -0.05018361f, -0.00239425f, -0.01100597f, 0.04211094f, 
    -0.00677696f, -0.02276148f, -0.02461188f, 0.01505863f, 0.05432758f, 0.00300758f, -0.04900100f, -0.05719485f, 
    -0.04903657f, -0.04204554f, 0.02729822f, -0.02119489f, -0.02117276f, -0.00706146f, 0.03704367f, 0.03834499f, 
    0.03213738f, -0.01602299f, -0.01511296f, -0.01850349f, -0.04431907f, -0.02898948f, -0.01758605f, -0.02132681f, 
    -0.00592214f, 0.01499500f, 0.04728363f, 0.00881052f, 0.03565492f, 0.01638896f, -0.00010141f, 0.02326441f, 
    -0.01635665f, -0.03766337f, -0.01466481f, 0.00098650f, 0.01721741f, 0.02965208f, -0.02608614f, 0.03088031f, 
    0.00815170f, -0.03982071f, -0.02880730f, -0.03009692f, -0.00023100f, -0.05024259f, 0.01259436f, -0.03596270f, 
    0.01445059f, 0.03122926f, -0.04932649f, 0.00941677f, 0.00385312f, 0.03907088f, 0.03448726f, -0.00419328f, 
    0.04515025f, 0.00923343f, -0.03810789f, -0.05044182f, 0.02577353f, 0.00022599f, -0.02503458f, -0.01246215f, 
    -0.03668582f, -0.03924650f, 0.02759783f, 0.01863142f, 0.02321174f, 0.00018226f, 0.00322154f, -0.02794843f, 
    -0.01923055f, -0.02846690f, -0.03434046f, 0.04847977f, -0.01454826f, -0.05015630f, 0.00751567f, 0.00967746f, 
    -0.03916739f, 0.00709725f, -0.04955541f, -0.01291126f, 0.00454259f, -0.03062718f, 0.02507007f, -0.02113262f, 
    -0.05137919f, -0.05298353f, -0.04952794f, -0.02169900f, 0.03341266f, 0.00182749f, -0.02520030f, 0.02579185f, 
    -0.03327918f, 0.03662802f, -0.04171565f, -0.04467643f, 0.00300791f, -0.03910039f, -0.03667958f, 0.00302410f, 
    0.02174304f, -0.06000973f, -0.04408699f, -0.02846738f, -0.02439106f, 0.01070604f, 0.01868028f, 0.00784444f, 
    -0.03473001f, -0.00470248f, -0.00107881f, -0.04567433f, -0.03262518f, -0.01404220f, 0.00976755f, 0.01743747f, 
    -0.00565945f, -0.01906771f, 0.01229504f, 0.03608732f, 0.03616859f, -0.02502842f, 0.02306912f, 0.00795122f, 
    -0.04995638f, -0.03159567f, -0.05596614f, 0.04039942f, -0.01506625f, -0.02702676f, 0.03839681f, 0.03905102f, 
    0.02472308f, -0.05818290f, -0.01224919f, -0.03838986f, -0.04912440f, 0.01997683f, 0.02910386f, 0.01010222f, 
    -0.04933995f, -0.05113705f, -0.05448182f, 0.01288725f, -0.01456613f, -0.02589620f, 0.03474792f, -0.04979952f, 
    0.02822786f, -0.03786965f, 0.03170783f, -0.05087919f, -0.01177718f, 0.00209936f, 0.01414681f, -0.03071425f, 
    -0.02961097f, -0.01787499f, 0.00053060f, -0.01721566f, 0.04218779f, 0.01137904f, 0.01519690f, -0.05513737f, 
    0.02728057f, 0.01313197f, 0.02042669f, -0.01616396f, 0.04522872f, -0.02576817f, 0.02300937f, -0.05260149f, 
    0.02470907f, -0.04731772f, 0.04109721f, -0.01286624f, 0.00345933f, -0.03855935f, -0.00041097f, -0.00924547f, 
    -0.04560979f, -0.01123553f, -0.00721816f, -0.00250096f, 0.02329560f, -0.05701248f, -0.00574666f, -0.02913969f, 
    -0.03916331f, -0.01714165f, -0.02487984f, -0.01915367f, -0.03164308f, -0.00446520f, 0.01926896f, 0.02798243f, 
    0.03151857f, -0.04674080f, 0.01801407f, 0.03003206f, 0.01176426f, -0.00100102f, -0.04252766f, 0.00171286f, 
    0.01341503f, -0.00362058f, 0.02669382f, -0.02270146f, 0.01116601f, -0.03608160f, -0.03878449f, -0.04453126f, 
    0.04332574f, -0.03979356f, 0.03417657f, 0.03080322f, -0.05109970f, -0.00460247f, -0.01421973f, 0.00842224f, 
    -0.04251292f, 0.01592270f, 0.01398543f, 0.00986764f, -0.02665558f, 0.01479857f, -0.01142680f, 0.02138449f, 
    0.04044760f, 0.01118307f, -0.00457898f, -0.04273623f, 0.00886433f, 0.01988211f, 0.02615862f, -0.05375818f, 
    0.01379620f, -0.02241281f, 0.02134695f, 0.01930356f, 0.03591741f, 0.00062269f, 0.02637284f, -0.00718442f, 
    -0.03814810f, -0.04884565f, -0.03855409f, -0.01541328f, -0.05337525f, 0.03410082f, -0.03772646f, 0.00373777f, 
    -0.00134203f, -0.13644864f, -0.01482012f, -0.04285213f, -0.05787025f, -0.02180192f, 0.10350398f, -0.04357011f, 
    -0.02490645f, -0.02509608f, -0.07733591f, 0.07818747f, -0.07795414f, -0.14423053f, -0.12994598f, 0.07075571f, 
    -0.03662831f, 0.03171362f, -0.06858039f, -0.10171268f, 0.00301093f, -0.04433247f, -0.03971528f, 0.06841025f, 
    0.11224104f, -0.09120797f, -0.07625513f, 0.12806322f, -0.10476913f, -0.04474034f, -0.13938461f, -0.07972356f, 
    -0.02207920f, -0.09832107f, -0.02439912f, 0.03412110f, -0.04650968f, -0.23221350f, -0.01164228f, 0.05779282f, 
    -0.00610532f, 0.02636917f, -0.04597151f, -0.01057433f, 0.05732683f, -0.02938369f, -0.12000062f, -0.08146757f, 
    -0.28250062f, 0.13028276f, 0.11620856f, -0.13747166f, 0.04818733f, 0.04971842f, -0.12049988f, 0.11519555f, 
    -0.04340480f, -0.02943671f, -0.13998528f, 0.05909600f, 0.05773494f, -0.09291115f, -0.12289772f, -0.26802388f, 
    -0.03090335f, -0.06576663f, -0.08385287f, 0.05879466f, -0.04406190f, -0.11229954f, -0.13145630f, -0.05844951f, 
    -0.02785757f, 0.11574803f, -0.02211233f, -0.20602682f, 0.08249815f, 0.06564571f, 0.07648388f, 0.05757293f, 
    -0.06593944f, -0.15433469f, 0.16781086f, 0.03466639f, 0.10038777f, -0.10453033f, -0.08452433f, -0.17710911f, 
    -0.14939274f, -0.03356177f, -0.01520822f, -0.02559541f, -0.00604863f, 0.03588651f, 0.10602855f, 0.00716684f, 
    -0.25298044f, 0.05159781f, -0.07343964f, 0.08642667f, 0.04431673f, -0.13399777f, -0.02566314f, -0.06036261f, 
    0.03734984f, 0.01694447f, -0.08997312f, -0.10099220f, 0.61959732f, 0.04604916f, -0.07899203f, 0.17387491f, 
    0.07911431f, 0.01582237f, 0.05136465f, -0.10171900f, 0.00642506f, -0.05168948f, 0.09688889f, 0.02157253f, 
    -0.11746882f, 0.24884059f, 0.01869908f, -0.22920452f, 0.04958817f, 0.07733083f, 0.09406112f, 0.01639326f, 
    0.02906987f, 0.10670674f, 0.13976853f, 0.09142119f, -0.10830215f, 0.10977659f, 0.16637245f, -0.03383124f, 
    -0.08345171f, -0.04888080f, 0.09355140f, 0.00279479f, -0.03233538f, 0.01851701f, 0.04337305f, -0.03981501f, 
    0.12691930f, 0.01402290f, 0.16589999f, 0.23590858f, -0.05646028f, 0.08043399f, -0.18798770f, -0.17805761f, 
    0.01100899f, -0.14851649f, 0.00779478f, -0.11410344f, -0.22151098f, -0.10897936f, 0.07935490f, 0.07007603f, 
    0.04386531f, 0.08695650f, 0.01857256f, -0.09045106f, -0.02263114f, -0.00032814f, -0.09627257f, 0.06898995f, 
    -0.19682972f, 0.19298998f, -0.17944659f, 0.06091511f, 0.11126780f, -0.09684841f, -0.00295188f, 0.00241370f, 
    -0.00086237f, 0.02224076f, 0.06291930f, -0.06352970f, -0.01809416f, 0.04609744f, 0.28563857f, 0.17011850f, 
    0.03913178f, -0.08617899f, -0.10408755f, 0.02175966f, 0.03025226f, 0.03397280f, -0.00414440f, 0.04966322f, 
    0.23831987f, 0.16041653f, 0.20016272f, 0.25184128f, -0.11772496f, -0.11766758f, -0.04924004f, -0.01729582f, 
    -0.01584367f, 0.08442336f, -0.01357255f, -0.01053379f, 0.14868835f, 0.09458720f, -0.02133214f, 0.09679709f, 
    0.06791513f, 0.04162970f, 0.00495519f, -0.08523986f, -0.02998317f, 0.09764804f, -0.04755107f, 0.10201779f, 
    0.02666095f, 0.03584445f, 0.12348697f, 0.14010938f, 0.05424852f, 0.01363392f, -0.02324251f, 0.05415906f, 
    0.01175641f, 0.06571037f, 0.03383578f, 0.08589262f, -0.40331924f, 0.10769848f, 0.24318253f, 0.04031886f, 
    -0.03056059f, -0.11250296f, -0.00880278f, 0.01260390f, 0.02585641f, -0.10555297f, -0.05074211f, -0.01097349f, 
    -0.05686398f, -0.28735876f, -0.02567662f, 0.03925734f, -0.04858141f, 0.09562919f, -0.01141374f, -0.03601349f, 
    -0.00160180f, 0.22269031f, 0.08122311f, 0.09121548f, 0.13698819f, -0.01146543f, 0.23195384f, -0.17925791f, 
    -0.01322414f, 0.04745506f, -0.19551767f, 0.08510875f, 0.02520946f, 0.07799619f, -0.09357362f, 0.05761148f, 
    0.16754110f, 0.13157952f, 0.16566417f, 0.08216766f, -0.02133103f, -0.03887782f, -0.02239809f, -0.00208431f, 
    0.04421061f, 0.05086726f, -0.05334184f, 0.01724160f, -0.37684727f, 0.16250385f, 0.12946634f, -0.02013174f, 
    0.08106785f, 0.01367130f, -0.01546812f, 0.11140347f, 0.02121503f, 0.09782699f, 0.14132491f, 0.10101632f, 
    -0.00113010f, 0.02494010f, 0.01847129f, 0.11698075f, -0.02158219f, -0.00374805f, -0.10616444f, -0.04370050f, 
    -0.12536016f, -0.05094269f, -0.07538459f, -0.08629546f, 0.24913841f, 0.11113260f, -0.01727853f, -0.19327821f, 
    0.01044291f, 0.05039962f, 0.15566319f, 0.00125885f, 0.13090123f, 0.01802530f, -0.05703013f, 0.05132269f, 
    0.03509147f, 0.04101786f, -0.17272842f, 0.03159774f, -0.04930594f, 0.04794214f, 0.09009362f, 0.06871822f, 
    -0.02150534f, 0.07754465f, -0.00641904f, 0.07865575f, 0.07852179f, -0.06193620f, -0.03845525f, 0.02404439f, 
    0.00234055f, -0.03174448f, 0.05695811f, -0.09874109f, 0.01142823f, -0.04261551f, -0.15012509f, 0.02797900f, 
    -0.28101030f, 0.04312638f, 0.12824447f, -0.03681605f, 0.09107013f, 0.05550182f, 0.18872242f, 0.10279467f, 
    0.09496938f, 0.10796647f, 0.03099529f, 0.28886363f, -0.30411252f, 0.05278438f, -0.11714284f, -0.15735750f, 
    0.09678583f, 0.01865640f, 0.03291678f, -0.06877724f, 0.05783439f, 0.05909159f, -0.06378832f, 0.02980342f, 
    -0.42721498f, 0.13573976f, 0.16742665f, -0.22627799f, -0.05275969f, -0.01108242f, -0.04532110f, -0.06906877f, 
    0.03493500f, -0.01012222f, -0.05547804f, 0.01044885f, 0.24267334f, 0.06794120f, 0.07801509f, 0.03420376f, 
    0.11174510f, 0.06364042f, 0.13738841f, 0.01889873f, -0.02075230f, 0.19515677f, -0.03168141f, 0.07621250f, 
    -0.11591555f, 0.07674364f, -0.11422979f, -0.04355481f, -0.01496947f, 0.02194722f, -0.01407693f, 0.08353617f, 
    -0.02083270f, 0.16439600f, -0.03592061f, -0.05372294f, -0.14939997f, 0.01443111f, -0.14463164f, -0.04272822f, 
    -0.05728753f, 0.03047264f, 0.02822134f, -0.00900917f, 0.06191733f, 0.01899835f, 0.15556397f, 0.12632553f, 
    -0.18688905f, 0.14110170f, 0.03277779f, -0.19527946f, -0.02181294f, -0.02394700f, 0.02695317f, 0.00195009f, 
    0.06124403f, 0.05624979f, 0.03590066f, -0.01536419f, -0.16763796f, -0.12078439f, 0.26293334f, -0.07041287f, 
    -0.03038198f, 0.02303087f, 0.01782606f, -0.09414825f, 0.03539483f, 0.03536980f, -0.12353078f, -0.09388794f, 
    0.06364370f, 0.11135860f, 0.03809371f, -0.08899722f, -0.04694783f, 0.03483548f, -0.10931427f, 0.09382271f, 
    0.03849325f, 0.05332357f, -0.12036251f, -0.07752500f, -0.35366467f, 0.13190199f, -0.00540595f, 0.00068493f, 
    0.05038879f, 0.04511881f, -0.15261447f, 0.05475489f, 0.09199995f, 0.03725639f, 0.04741471f, 0.06896737f, 
    -0.19007947f, -0.06451239f, -0.01471475f, 0.17582822f, -0.05249510f, -0.06414513f, 0.06138191f, 0.02049017f, 
    0.02519946f, 0.05638743f, 0.07459876f, 0.08515608f, -0.30336076f, -0.12018356f, -0.14816852f, -0.03801086f, 
    -0.04789319f, 0.10364291f, 0.11541228f, 0.15419920f, 0.08238868f, -0.02724361f, 0.05091392f, -0.10438114f, 
    0.01044514f, -0.08220974f, 0.08005448f, 0.19367932f, 0.04717036f, -0.06132789f, 0.00150536f, -0.05036008f, 
    -0.08104252f, 0.05305439f, -0.13933696f, -0.01266954f, 0.03659780f, 0.11134726f, -0.10037348f, 0.15187992f, 
    0.00726534f, 0.12480257f, 0.08573192f, 0.04200261f, -0.08562861f, -0.03107869f, 0.07386030f, 0.02661877f, 
    0.04932653f, -0.26843923f, -0.01195827f, 0.21525376f, -0.02823795f, 0.01799505f, 0.05323495f, 0.07210344f, 
    -0.04596728f, 0.02694734f, 0.24167833f, 0.07093810f, 0.08447017f, 0.14141369f, -0.06958652f, 0.01434825f, 
    0.04676918f, 0.05525580f, -0.06618926f, -0.02780424f, -0.14433570f, -0.01445682f, 0.11991115f, -0.04278786f, 
    -0.18485248f, 0.15852049f, -0.02422535f, -0.28401408f, -0.03071067f, 0.07851219f, -0.01013194f, 0.09429985f, 
    0.01514100f, -0.07416482f, 0.07027487f, -0.13793245f, -0.18350118f, 0.24723771f, -0.14335491f, -0.03021737f, 
    0.08521655f, -0.06616034f, -0.11605579f, -0.04273963f, 0.04578952f, -0.14481311f, -0.03861044f, 0.00268772f, 
    0.05894633f, 0.06805827f, -0.01532553f, 0.10409848f, -0.07365493f, -0.02901111f, -0.03423763f, 0.00225174f, 
    -0.03482921f, 0.09220975f, 0.01929767f, -0.22256413f, 0.12959462f, 0.03957272f, 0.11405623f, -0.10713402f, 
    0.13405430f, -0.03540515f, -0.06674824f, -0.03603322f, -0.03725276f, -0.05372858f, 0.06435186f, 0.01511036f, 
    0.05924524f, 0.06440810f, 0.05412268f, 0.19081132f, -0.02027184f, 0.16665010f, -0.02422612f, 0.00098558f, 
    0.02260177f, 0.02269073f, -0.13550626f, -0.06791861f, -0.22494844f, 0.15572639f, 0.06199470f, -0.14813082f, 
    0.10099465f, 0.09386041f, 0.02816649f, 0.05084936f, 0.02185072f, 0.05934263f, 0.05199082f, -0.04542101f, 
    0.00567095f, -0.05159357f, 0.06376002f, 0.01274896f, -0.01343544f, 0.02854115f, -0.01463466f, 0.00655458f, 
    0.09397058f, -0.12217469f, 0.01966203f, -0.04433744f, 0.01572495f, 0.00997997f, 0.18627656f, 0.07149108f, 
    -0.03361706f, 0.00934202f, 0.13319299f, 0.04157929f, -0.03928392f, 0.05201976f, -0.11636575f, -0.12021590f, 
    -0.18373115f, -0.14354245f, 0.14487126f, 0.27179074f, 0.00135528f, 0.15720516f, 0.20825736f, 0.11936884f, 
    0.03687524f, 0.05653619f, 0.05493522f, 0.10028705f, 0.32142565f, 0.10584643f, 0.11269575f, -0.03944795f, 
    0.15126948f, 0.07841259f, -0.05687970f, -0.04593097f, -0.03957583f, -0.00045643f, -0.06360508f, 0.06883065f, 
    0.16654883f, 0.28555354f, -0.12618488f, -0.08163635f, 0.04989263f, 0.00677449f, -0.01385893f, 0.03710839f, 
    0.11968650f, 0.06584847f, -0.06535306f, 0.08009823f, -0.12470790f, 0.02388142f, 0.07860685f, -0.03891966f, 
    -0.03145318f, -0.11607097f, 0.00072836f, 0.12611741f, 0.02509163f, 0.13003963f, 0.10714442f, 0.11980157f, 
    -0.15196033f, -0.01535501f, -0.04226244f, -0.08655054f, -0.10315195f, -0.01611037f, 0.00984119f, -0.02410435f, 
    -0.07167324f, 0.09635749f, 0.07066648f, 0.01178665f, -0.00770787f, 0.15466596f, 0.12455294f, 0.08424835f, 
    0.08726847f, 0.06183858f, 0.09682086f, -0.03421551f, -0.09942210f, 0.06500915f, 0.04718865f, -0.03176970f, 
    0.06333246f, 0.00270772f, -0.01956094f, -0.05948310f, -0.04202678f, -0.02762003f, 0.05080817f, 0.17402825f, 
    0.07602821f, 0.09960956f, 0.10450798f, 0.20630614f, -0.20105685f, 0.03645043f, -0.10030653f, -0.02709934f, 
    0.03444139f, 0.02472099f, 0.04086179f, 0.10078210f, 0.02654937f, 0.00009242f, -0.07516353f, -0.00923641f, 
    -0.14552714f, -0.10311075f, 0.20868640f, 0.18759049f, 0.03646197f, 0.09104225f, 0.04276485f, 0.01840054f, 
    0.04193756f, 0.03368482f, 0.00363043f, 0.11109938f, 0.20324740f, 0.04227671f, 0.02956172f, -0.01337862f, 
    0.11038211f, 0.00308726f, 0.17177977f, 0.02174173f, 0.09812520f, 0.05133895f, -0.10801269f, 0.06720764f, 
    -0.10621625f, 0.06904690f, 0.04758272f, 0.12044213f, 0.00756445f, -0.04152960f, -0.09641118f, -0.03294302f, 
    0.01184190f, -0.01767577f, -0.00049055f, 0.08201536f, 0.15126644f, 0.06530612f, 0.04385933f, 0.07002136f, 
    -0.00564428f, -0.10330430f, 0.17574263f, 0.15504859f, -0.05840706f, 0.19298734f, -0.03640303f, 0.05674333f, 
    -0.10832136f, -0.17919871f, 0.10372322f, -0.18358348f, -0.05315997f, 0.02923907f, -0.03591498f, -0.00472277f, 
    -0.06996046f, -0.08685548f, 0.05869654f, 0.05084222f, -0.03340951f, -0.11210154f, -0.01599862f, 0.08865991f, 
    0.07363181f, 0.08311830f, -0.00247572f, 0.03332147f, 0.01551306f, -0.02462682f, -0.11549924f, -0.18489057f, 
    -0.10355922f, -0.01709601f, 0.00419838f, 0.23797050f, -0.04211352f, 0.00891555f, 0.05026412f, -0.09726457f, 
    0.04565386f, -0.06484607f, -0.07640091f, 0.03721816f, -0.21492127f, -0.03616542f, 0.03213618f, 0.07919912f, 
    -0.07552798f, -0.01715991f, 0.00681158f, 0.00316184f, 0.00161528f, 0.04658686f, -0.02032651f, 0.02043784f, 
    -0.38239849f, 0.19343004f, -0.02824759f, -0.14944227f, -0.01468111f, 0.11863542f, -0.00468803f, -0.03239919f, 
    0.02268264f, -0.01829140f, -0.04967728f, 0.17404343f, 0.09045547f, -0.11676573f, -0.01069418f, -0.15637940f, 
    -0.07838167f, -0.04912789f, -0.07278620f, -0.01024187f, 0.04076760f, 0.01486199f, -0.10170127f, 0.05509067f, 
    -0.18750447f, 0.10667823f, -0.02317391f, -0.04351787f, 0.20994060f, 0.01572107f, 0.08520990f, -0.01186787f, 
    0.00939212f, -0.04638496f, 0.04485694f, -0.03915819f, 0.30590105f, -0.09256792f, 0.00116903f, -0.10088786f, 
    -0.04914831f, -0.06086236f, -0.16264822f, -0.11726002f, -0.00986521f, 0.00828603f, 0.08038279f, 0.09907104f, 
    0.13608566f, 0.03230739f, -0.02592927f, -0.06515548f, -0.15949944f, 0.01512713f, 0.03119824f, -0.17330939f, 
    0.05019639f, 0.00636399f, 0.07753368f, -0.05465522f, 0.42428005f, -0.04164848f, -0.03336818f, 0.18246666f, 
    0.01202737f, 0.00964822f, -0.00783543f, 0.00954979f, -0.04335702f, 0.04485576f, 0.00943779f, -0.07621599f, 
    0.16379270f, 0.05741308f, -0.08515876f, -0.01982684f, -0.10822788f, 0.07017629f, 0.04780785f, -0.11481000f, 
    0.06146941f, -0.00495317f, -0.12610851f, 0.04299102f, -0.07846171f, 0.18614562f, 0.34776965f, -0.14778230f, 
    0.10542294f, -0.02690836f, 0.07805182f, 0.07308050f, 0.07474200f, 0.08568178f, -0.00320570f, -0.00215206f, 
    -0.01955744f, -0.01789260f, 0.09419167f, 0.15489301f, -0.03323248f, 0.00201857f, -0.07353417f, -0.02264058f, 
    0.08472378f, 0.09089435f, 0.08163976f, 0.11734270f, -0.10352521f, -0.00536487f, 0.16485044f, -0.06962848f, 
    0.09821170f, -0.02510759f, -0.02941902f, -0.02128288f, 0.03133498f, 0.03588798f, 0.06425518f, 0.12151092f, 
    -0.33109197f, -0.06997202f, -0.12596244f, 0.07250196f, 0.18199532f, 0.06462923f, 0.09933168f, 0.18510708f, 
    -0.00544984f, 0.11436887f, 0.04029499f, 0.11749178f, -0.24900635f, 0.19024077f, 0.25480124f, -0.04060452f, 
    -0.09810069f, -0.11872606f, 0.00850318f, 0.00717536f, 0.03581971f, 0.05355332f, -0.11532415f, 0.03605390f, 
    0.04647043f, 0.00530877f, 0.28607205f, 0.16147523f, -0.07455222f, 0.02622247f, 0.08730977f, 0.04191548f, 
    0.15955105f, -0.01764244f, 0.03552245f, 0.06569485f, -0.07154944f, -0.14795703f, 0.00770580f, 0.19142918f, 
    -0.00190675f, 0.03990440f, -0.00738225f, -0.00633767f, -0.00387350f, 0.02242665f, -0.03891482f, 0.07021396f, 
    -0.04004268f, 0.16055478f, 0.08913488f, 0.22414547f, 0.13919665f, 0.05892130f, 0.03384655f, 0.08091684f, 
    0.03463123f, 0.05646729f, 0.08303337f, 0.10244481f, -0.19027220f, 0.08961403f, 0.05875847f, 0.05459443f, 
    0.06205371f, -0.02958078f, 0.05097573f, 0.01162724f, -0.02039910f, -0.00501304f, 0.14928886f, 0.06668498f, 
    -0.01856821f, -0.05631344f, 0.10376231f, -0.06110717f, 0.03477740f, -0.01108313f, -0.07815483f, 0.07289331f, 
    -0.05713248f, -0.03813744f, -0.02203765f, 0.05457841f, -0.08354311f, -0.01465186f, 0.12643950f, -0.19593889f, 
    0.02128167f, -0.00656258f, -0.06466181f, 0.06588227f, 0.04720867f, 0.00944693f, -0.09402799f, 0.08551045f, 
    -0.02452744f, 0.15109783f, 0.03641797f, -0.06808127f, 0.01607107f, 0.01937825f, -0.07463689f, -0.03128402f, 
    -0.11843742f, 0.04450942f, 0.06986202f, 0.00122757f, -0.24373433f, 0.10841126f, -0.01103387f, 0.06782452f, 
    0.19936617f, 0.00871572f, 0.03889458f, 0.08306216f, 0.04585562f, -0.06355008f, -0.08163712f, -0.07879891f, 
    -0.04192755f, -0.00015238f, -0.03488096f, 0.04623729f, 0.03776373f, -0.09885989f, 0.00096389f, -0.01470335f, 
    -0.07776096f, 0.05449771f, -0.04955173f, 0.05917852f, 0.09284994f, -0.12353388f, 0.07639847f, -0.21008481f, 
    0.00966634f, 0.00816965f, 0.07274900f, -0.04103642f, 0.08870945f, -0.01878636f, 0.03949553f, 0.15926565f, 
    -0.10014551f, 0.02261080f, -0.05304163f, 0.09753567f, -0.02903065f, 0.01523787f, 0.08260025f, 0.00520604f, 
    0.01641212f, 0.00252999f, -0.05498667f, -0.01108227f, 0.04801967f, -0.01433304f, -0.04691882f, 0.05464936f, 
    -0.02493520f, -0.04115023f, 0.09591425f, -0.06304083f, -0.01178107f, -0.00595574f, -0.00662199f, 0.02500149f, 
    -0.27997369f, -0.02598125f, 0.03956511f, -0.03260671f, 0.04403268f, 0.03620402f, 0.05601518f, 0.16782060f, 
    0.06235152f, 0.02587071f, 0.03840842f, 0.03505589f, -0.28963321f, 0.01979203f, -0.20102862f, -0.11571506f, 
    0.04602527f, -0.01850803f, -0.00762556f, -0.02234377f, -0.08250417f, 0.12007940f, -0.00721672f, 0.00811274f, 
    -0.60442001f, 0.02022775f, 0.13944273f, -0.17544343f, -0.05579915f, 0.12059061f, -0.05941710f, -0.08799143f, 
    0.02975372f, 0.02576612f, 0.06648804f, -0.11258239f, 0.04962751f, -0.06360684f, 0.23947996f, -0.09919816f, 
    0.13680314f, 0.09479667f, 0.00772587f, 0.00959231f, 0.08331344f, 0.05361087f, 0.09636631f, 0.23874244f, 
    0.22392887f, -0.17195794f, -0.01231599f, 0.16002001f, -0.01558440f, -0.10382563f, 0.05571286f, -0.01017005f, 
    0.12384834f, -0.00071006f, -0.02015566f, 0.02758709f, 0.00577385f, -0.01628868f, 0.06100540f, 0.08549377f, 
    -0.03679865f, -0.02470864f, 0.01102810f, -0.02584272f, -0.00527272f, -0.00747408f, 0.06009927f, 0.25035942f, 
    0.23778774f, -0.14823276f, -0.04281777f, 0.02676840f, 0.07649333f, -0.00677397f, 0.05684208f, -0.00182408f, 
    0.08966769f, -0.01234040f, 0.07009931f, -0.05952261f, -0.11701957f, -0.02028543f, -0.11452704f, 0.05727302f, 
    0.07382783f, 0.05324953f, -0.02646232f, 0.05413344f, -0.00524297f, 0.01728400f, -0.02956571f, 0.10100627f, 
    0.03332113f, -0.17091000f, -0.04990088f, 0.00202587f, -0.00872886f, -0.00447009f, -0.02834370f, 0.03750252f, 
    -0.08516529f, -0.09269617f, 0.05514264f, -0.10150475f, 0.01055707f, -0.00452670f, 0.00963671f, -0.02279335f, 
    0.01696991f, -0.02252967f, 0.04358860f, 0.01965442f, -0.03850877f, 0.06556752f, 0.05773843f, -0.00557117f, 
    0.01656361f, -0.14834976f, -0.09532561f, -0.03372035f, -0.11432384f, -0.02579313f, -0.15264821f, 0.08124743f, 
    -0.05230187f, 0.04299821f, 0.01594691f, 0.00912150f, -0.26776424f, 0.01457642f, -0.15075882f, -0.13361529f, 
    0.00708687f, -0.06964312f, 0.06797989f, 0.08956248f, -0.04824763f, -0.00625501f, 0.00839233f, -0.01587988f, 
    -0.34237215f, 0.22766642f, -0.14352870f, -0.09091957f, 0.10075244f, 0.00825355f, -0.02387856f, 0.05450629f, 
    -0.05754452f, -0.01364476f, -0.11779537f, 0.05124034f, 0.08083974f, -0.18689951f, 0.12719493f, -0.04942413f, 
    0.06357830f, 0.05907762f, 0.02705086f, 0.02758453f, 0.19626479f, 0.00099691f, -0.03479791f, 0.11089543f, 
    -0.14334060f, -0.01139766f, -0.04743367f, -0.08747769f, 0.01169864f, -0.02593926f, 0.01224495f, 0.08676869f, 
    0.03656523f, 0.08227435f, 0.08010807f, -0.02065710f, 0.06088373f, -0.24609168f, -0.05091618f, -0.10235095f, 
    0.06331314f, -0.04501733f, 0.09547152f, 0.00682765f, -0.04948147f, -0.01457282f, -0.03738741f, -0.06480765f, 
    0.20315465f, -0.12005226f, 0.14078619f, 0.17357570f, 0.07349354f, 0.01560382f, -0.06599149f, -0.02032942f, 
    0.01367530f, -0.07002020f, 0.05577487f, -0.05334754f, 0.20827220f, -0.17368773f, 0.17502072f, 0.12255132f, 
    0.03802428f, 0.04825576f, -0.09506784f, -0.02052662f, -0.01343637f, -0.12722768f, 0.05341120f, 0.08674157f, 
    0.30106443f, -0.03059413f, -0.14920823f, 0.02755637f, -0.06525905f, -0.02347033f, -0.01709978f, -0.01235403f, 
    0.04172337f, -0.03920357f, 0.05857236f, -0.04835162f, 0.06112393f, 0.21842857f, -0.18100886f, -0.01496213f, 
    0.01865035f, 0.10850742f, 0.00209694f, 0.06072596f, -0.01187670f, 0.12550154f, 0.17873162f, -0.08230089f, 
    0.13754418f, -0.07302520f, -0.08830621f, 0.02254242f, 0.11237338f, -0.04811860f, 0.08601473f, -0.07659669f, 
    0.04431950f, 0.07263001f, -0.02138983f, 0.05642014f, 0.14944404f, -0.00920149f, -0.00494771f, -0.10405850f, 
    0.07069650f, 0.14287454f, 0.01917076f, 0.00531354f, -0.00360054f, 0.02164379f, 0.04668532f, -0.01184882f, 
    0.03233971f, 0.11905759f, -0.07343803f, 0.06845006f, -0.01972758f, 0.05262396f, 0.00955387f, -0.08263620f, 
    -0.05604936f, 0.01317339f, 0.14144365f, 0.15378599f, -0.32411721f, 0.25748932f, -0.03728668f, -0.01702593f, 
    0.00395404f, 0.03023957f, -0.05204199f, -0.06424337f, -0.00825087f, 0.00074131f, -0.12449918f, 0.06596360f, 
    -0.24530512f, -0.07076932f, 0.18570538f, 0.10674585f, 0.03229388f, 0.18147545f, 0.07661548f, 0.01942870f, 
    0.02447009f, 0.04250677f, 0.06524415f, 0.00759959f, 0.05096393f, -0.07930885f, -0.05335925f, -0.09640115f, 
    -0.20996656f, 0.03571064f, -0.10063482f, 0.04888406f, 0.03832266f, 0.00420875f, -0.03082441f, 0.03250996f, 
    0.44115999f, 0.01026201f, 0.02235236f, 0.14813749f, 0.03163966f, 0.04592096f, 0.03912054f, 0.07961766f, 
    0.06666889f, 0.04481073f, -0.09499053f, 0.09585278f, 0.07989219f, -0.07183577f, -0.00383256f, -0.05227476f, 
    -0.04481791f, 0.07614969f, -0.01096435f, 0.04222124f, -0.01601743f, -0.02203904f, 0.04866577f, 0.05855876f, 
    0.02793494f, 0.08340351f, 0.03677272f, 0.09487586f, -0.01380383f, -0.00833127f, 0.05314039f, -0.00636180f, 
    0.06416580f, 0.02628747f, 0.00998029f, 0.02839083f, -0.18333770f, 0.04200344f, -0.10459121f, -0.11557880f, 
    -0.17091332f, 0.04222915f, -0.05985830f, 0.10284621f, -0.13505988f, 0.01664135f, -0.02893688f, -0.01876171f, 
    0.24194771f, 0.07757448f, -0.10159770f, -0.00843066f, -0.13414980f, 0.07840101f, 0.02631476f, 0.03165476f, 
    -0.00237914f, 0.02089668f, 0.06068240f, 0.10537602f, -0.04056882f, -0.12579633f, -0.01821343f, 0.04815225f, 
    0.09486243f, 0.03758883f, 0.04655483f, 0.06314208f, 0.01468959f, -0.08081412f, 0.03141840f, 0.04120941f, 
    0.04961428f, -0.11480566f, -0.13471024f, 0.07232716f, -0.07430611f, -0.02718553f, 0.18765754f, -0.02071962f, 
    0.03818598f, 0.03444125f, -0.05931595f, 0.01907007f, -0.02645550f, 0.23121306f, 0.03414121f, 0.07574949f, 
    -0.00627543f, 0.08746678f, 0.03795546f, 0.06223902f, 0.06148807f, -0.06486958f, 0.18173406f, -0.08726577f, 
    0.18944085f, 0.09923613f, 0.06648733f, 0.13854888f, 0.18106741f, 0.07613287f, 0.01676261f, 0.11662826f, 
    0.02206405f, -0.02082161f, 0.03955864f, -0.02359174f, 0.03808678f, 0.00970228f, -0.08623409f, -0.03842930f, 
    -0.04574056f, 0.02469480f, 0.04343466f, 0.00017971f, 0.11806301f, 0.02104488f, -0.05782565f, -0.05725917f, 
    0.10914122f, 0.03380143f, -0.00939229f, -0.01038411f, -0.01751142f, -0.00717141f, -0.08676861f, 0.05468214f, 
    0.07303248f, -0.05825869f, -0.13183244f, 0.10141633f, 0.06838321f, 0.12833589f, 0.15413663f, 0.15582176f, 
    -0.07329669f, 0.05389317f, 0.00402973f, 0.07502864f, -0.01163905f, -0.05273704f, 0.11498276f, -0.00748064f, 
    -0.03159534f, 0.19148326f, 0.12162106f, 0.18093054f, -0.03808533f, 0.04968708f, 0.01598770f, -0.01097072f, 
    -0.01801657f, -0.09764236f, 0.00587223f, 0.01678421f, 0.01391394f, -0.34828052f, 0.22371975f, -0.07697297f, 
    0.03690530f, -0.07417579f, -0.02649802f, -0.00793965f, 0.07390915f, -0.08669162f, -0.08767294f, -0.05134670f, 
    -0.16402213f, -0.08412571f, -0.06243753f, -0.04162692f, 0.01474922f, -0.06652009f, 0.02889612f, -0.01103910f, 
    -0.00528637f, -0.00722167f, -0.01737072f, 0.04622001f, 0.19363040f, 0.07033867f, 0.15999138f, 0.06573885f, 
    -0.03118820f, -0.07308358f, 0.00526242f, -0.10083596f, -0.03046633f, 0.12421820f, -0.08487453f, 0.10733124f, 
    -0.25820673f, 0.01323607f, -0.14396544f, -0.09435085f, 0.01729270f, 0.09398952f, 0.00339940f, -0.14097318f, 
    0.00315469f, -0.00729189f, 0.00750314f, -0.00856178f, 0.18522292f, 0.08578222f, 0.13373286f, 0.04373310f, 
    0.02528309f, -0.12733069f, -0.06093863f, -0.04112367f, -0.12475023f, 0.05883796f, 0.06764192f, 0.09402065f, 
    -0.18178187f, 0.03761587f, 0.05017076f, -0.01196306f, 0.10137329f, 0.04506133f, -0.04550818f, -0.08857203f, 
    -0.02061179f, -0.15916002f, -0.07426662f, 0.04068071f, 0.31428236f, -0.06775018f, 0.07444617f, -0.12817760f, 
    -0.09203234f, 0.05616255f, -0.09946290f, 0.07224431f, 0.03280758f, -0.11415813f, 0.02104517f, 0.01010450f, 
    -0.14929058f, 0.09489705f, 0.04094573f, -0.05278910f, 0.04197194f, -0.02369923f, -0.01509822f, -0.10700839f, 
    0.01703900f, 0.02728362f, -0.03489533f, 0.15210594f, 0.19591559f, 0.00645344f, -0.02503388f, -0.04802172f, 
    -0.05173944f, 0.03861288f, 0.07520229f, 0.02702614f, -0.01619976f, -0.00975846f, -0.06048378f, 0.00933221f, 
    0.11236583f, 0.15746598f, 0.18992887f, 0.11786564f, -0.04203535f, 0.01808356f, -0.03213194f, 0.05398529f, 
    0.05170786f, 0.07492781f, 0.05857052f, 0.07163829f, -0.11290872f, -0.01054555f, -0.04577669f, -0.13203689f, 
    -0.10036528f, 0.11226639f, 0.10229366f, 0.01959917f, 0.06609826f, -0.03165781f, -0.04603881f, -0.00224088f, 
    -0.22623898f, 0.07777728f, 0.07308743f, -0.07515052f, 0.02071842f, 0.02577714f, 0.10081518f, 0.07600001f, 
    0.02591966f, -0.02453872f, -0.00415931f, 0.01187358f, -0.05713540f, 0.05450806f, 0.10101125f, 0.11779536f, 
    -0.04228305f, -0.06940061f, 0.09435976f, -0.09372943f, -0.03809636f, 0.05997379f, -0.03623488f, -0.00822806f, 
    0.01390651f, 0.03913501f, -0.04342633f, 0.03875871f, -0.08380266f, -0.03363705f, -0.07513139f, 0.03946756f, 
    0.13453938f, -0.04890352f, 0.00140893f, 0.05840296f, 0.25604701f, 0.13850376f, -0.01118816f, 0.08088088f, 
    -0.05895708f, 0.06775345f, 0.05489158f, 0.01725222f, 0.01151155f, -0.06634537f, 0.08595350f, 0.01005723f, 
    -0.14321727f, -0.17413214f, 0.02876287f, -0.00425447f, 0.02949596f, -0.00702284f, -0.03886704f, 0.00577495f, 
    -0.12914881f, -0.02964911f, 0.01830801f, -0.00182476f, -0.02942317f, 0.11220521f, 0.22432390f, 0.11170994f, 
    0.04203974f, -0.12104010f, 0.05213876f, -0.08182859f, -0.00181077f, 0.06751091f, 0.09892725f, -0.00416415f, 
    0.14334199f, 0.06753860f, -0.08455983f, 0.09272369f, 0.05603877f, -0.04940689f, -0.08521597f, -0.03666380f, 
    0.02961972f, 0.00499760f, -0.03979354f, 0.07533313f, 0.01480236f, 0.13379952f, -0.01665965f, -0.07329576f, 
    -0.00479317f, -0.06118818f, -0.05109968f, -0.03436474f, -0.00393876f, 0.03891489f, -0.02862552f, 0.08505945f, 
    0.13374621f, -0.05687518f, 0.05104195f, 0.05166934f, 0.05626510f, 0.04048743f, -0.06490141f, 0.01741951f, 
    -0.06796651f, -0.00718180f, 0.03038739f, -0.02631969f, -0.13747974f, 0.08582537f, -0.08672620f, -0.03946361f, 
    -0.05464872f, 0.02563457f, 0.06814837f, 0.02649697f, -0.02331955f, -0.14204918f, -0.03792274f, 0.15280980f, 
    0.18108302f, 0.07667922f, 0.20830189f, 0.10947491f, -0.05139127f, 0.00756598f, 0.03191533f, 0.08126663f, 
    0.04790832f, 0.04890895f, -0.03315130f, 0.09683242f, -0.23223291f, -0.03709191f, -0.09649937f, -0.00266318f, 
    0.07446487f, 0.05258005f, -0.01131696f, -0.03443606f, 0.05288090f, 0.10493535f, -0.00656601f, -0.03530631f, 
    0.19888934f, 0.10290151f, 0.07400908f, -0.04412584f, 0.01970724f, 0.01324043f, -0.05397823f, 0.01153913f, 
    -0.02890220f, -0.03461618f, 0.03526018f, 0.03768876f, 0.13013650f, 0.18928008f, 0.05712499f, 0.14139321f, 
    -0.04014040f, -0.04010998f, -0.03482781f, -0.04416915f, -0.00787308f, -0.01541399f, -0.03803887f, -0.09078142f, 
    -0.24367355f, -0.12049912f, -0.08470432f, 0.02490403f, 0.09823369f, -0.03280523f, 0.05319374f, 0.00129958f, 
    0.06043826f, -0.05210294f, 0.06263398f, 0.13507451f, -0.19046111f, -0.14424570f, 0.14268029f, -0.03015061f, 
    0.11858123f, 0.05840966f, -0.02837339f, -0.02853638f, 0.04489953f, -0.04400107f, 0.15685274f, 0.03325229f, 
    0.05695903f, 0.00099408f, 0.16878259f, -0.03431164f, -0.02604607f, 0.01585585f, -0.17248908f, -0.01495834f, 
    0.12786230f, -0.06534604f, -0.00261333f, -0.00017881f, 0.08106355f, 0.10008620f, 0.07850466f, 0.03690083f, 
    0.03457566f, -0.02254248f, -0.03385999f, 0.08053306f, 0.05816548f, 0.07349561f, 0.02415880f, -0.00137797f, 
    -0.13116524f, 0.17407258f, -0.17934170f, 0.00344201f, 0.04754077f, 0.03453835f, -0.08187318f, -0.00321321f, 
    -0.07001936f, -0.05816273f, -0.00404403f, 0.10727278f, 0.02225805f, 0.03322774f, 0.05243441f, 0.07950864f, 
    0.01987825f, 0.05887409f, -0.02857156f, 0.01845654f, 0.07093555f, -0.03826213f, 0.02951682f, -0.04598805f, 
    -0.27079615f, 0.25127286f, 0.10072716f, -0.08587479f, 0.07498501f, 0.13708535f, -0.00832598f, -0.08613455f, 
    -0.04063188f, -0.03182143f, -0.09975508f, 0.04293541f, 0.06831009f, -0.26175275f, 0.38931116f, -0.25245973f, 
    0.00950563f, -0.04711031f, 0.02923744f, -0.01419178f, 0.07920296f, 0.00031658f, -0.03358914f, -0.06252829f, 
    -0.08127897f, 0.02887510f, -0.12168736f, -0.24706249f, -0.01789732f, 0.04821133f, 0.00272624f, 0.03356742f, 
    0.05105804f, 0.05669913f, -0.11366454f, 0.05851860f, -0.07785524f, 0.09141225f, 0.10888024f, 0.17052139f, 
    -0.01960063f, 0.08347919f, -0.04524137f, -0.05779422f, 0.13225891f, 0.03240201f, -0.05849512f, 0.08349568f, 
    -0.41911063f, -0.08687980f, -0.06738911f, 0.23996021f, -0.00363762f, 0.03964530f, 0.08780247f, 0.02634779f, 
    -0.01822055f, 0.05811474f, 0.08977059f, -0.03984867f, 0.13283195f, 0.06541277f, 0.03973404f, 0.08636007f, 
    0.02484923f, -0.07979609f, -0.14396138f, -0.06685200f, -0.07566701f, 0.06394588f, 0.03449916f, 0.05693018f, 
    0.20974168f, -0.13214062f, 0.08547670f, 0.27903157f, 0.02413463f, -0.04154155f, 0.08752814f, -0.07010385f, 
    0.05062494f, 0.05561183f, 0.04916003f, -0.04181422f, -0.07909761f, 0.24286918f, -0.11359066f, 0.08474834f, 
    -0.14624017f, -0.01187750f, -0.01387317f, -0.01624215f, 0.08981320f, -0.07704547f, 0.10189364f, 0.01757249f, 
    -0.05391290f, -0.24096774f, -0.01463007f, 0.17345382f, -0.02660015f, -0.09555965f, 0.06458336f, 0.01302036f, 
    0.03976689f, -0.06198531f, -0.00307167f, 0.12927702f, 0.10254299f, 0.13742462f, -0.00801883f, 0.13250178f, 
    -0.00016109f, 0.07567942f, -0.01193943f, 0.01439267f, 0.11812708f, 0.02408485f, 0.04028030f, -0.01132985f, 
    -0.18539974f, 0.18921407f, 0.11616009f, -0.09360053f, 0.14850472f, -0.04367147f, 0.01939258f, -0.02317274f, 
    -0.09604389f, 0.03313989f, 0.03361031f, 0.06140973f, -0.11639636f, 0.13815884f, -0.12097264f, -0.20870697f, 
    -0.00305275f, -0.00854308f, 0.07672915f, 0.02643001f, 0.12720458f, 0.03736805f, -0.01718673f, 0.02001299f, 
    -0.33124301f, 0.16615684f, 0.09916300f, -0.02129693f, 0.15310407f, 0.10291073f, 0.06062358f, 0.05808125f, 
    -0.01422581f, 0.05798334f, -0.04226593f, 0.02800347f, 0.19774681f, -0.12162492f, 0.09038059f, 0.11614627f, 
    -0.07965732f, -0.15438496f, 0.03857301f, 0.05187284f, -0.02399421f, -0.00951806f, -0.06363398f, 0.04507002f, 
    -0.17496942f, 0.04011247f, -0.18391435f, 0.10714979f, -0.05998624f, 0.14232364f, -0.00550578f, -0.01793274f, 
    0.20449778f, 0.06129088f, -0.03082787f, 0.01297597f, -0.07608124f, 0.10536966f, 0.13171579f, 0.00223046f, 
    0.07972590f, 0.03432447f, -0.07002436f, -0.02121474f, 0.07814859f, -0.01889439f, 0.05081472f, 0.08180542f, 
    0.08491284f, -0.09194256f, 0.17773527f, -0.01506278f, 0.03275683f, -0.08723727f, 0.15580279f, -0.04371730f, 
    0.06038584f, 0.02129154f, -0.10479460f, -0.05129963f, 0.22605474f, -0.20086636f, 0.07521168f, 0.09822578f, 
    0.01947764f, -0.06594149f, -0.02534873f, 0.01538304f, 0.00741878f, 0.09263629f, 0.12059775f, -0.03582741f, 
    0.13755928f, 0.06432502f, -0.03524054f, 0.15554152f, -0.03857690f, -0.08458016f, -0.01400649f, 0.06823350f, 
    0.11386689f, -0.00643951f, 0.03524981f, 0.06930499f, 0.13765845f, -0.07921031f, -0.00174523f, -0.05876548f, 
    0.08347125f, -0.00268437f, 0.01668892f, -0.05886449f, -0.07420595f, -0.00011592f, 0.03257991f, 0.08880762f, 
    -0.13978635f, 0.03588563f, -0.12425956f, -0.04902455f, 0.00791601f, 0.00187023f, -0.10153540f, 0.10200983f, 
    -0.09604765f, -0.03832940f, 0.06786987f, -0.04665636f, -0.04843673f, 0.06849523f, -0.08929336f, 0.08053747f, 
    0.12389408f, 0.06418635f, 0.16180597f, 0.02056407f, 0.05555733f, -0.09171552f, -0.07328077f, 0.08602914f, 
    0.00479924f, -0.05347089f, 0.12279157f, -0.05823868f, 0.06425089f, -0.08128075f, 0.01775408f, 0.05106011f, 
    -0.11223736f, -0.01586439f, -0.04801196f, 0.01764379f, -0.09993479f, -0.09490883f, -0.01893351f, 0.15156423f, 
    0.07402727f, -0.08243276f, 0.10381567f, -0.09419795f, 0.01389066f, 0.02182818f, 0.16152383f, 0.04121639f, 
    0.08468356f, 0.01447567f, 0.19004536f, -0.17541894f, 0.08375094f, 0.05441899f, -0.08075759f, 0.03384101f, 
    0.02068058f, -0.04272586f, -0.02004111f, 0.04937498f, 0.04563038f, 0.14656809f, 0.05137855f, -0.07292945f, 
    0.01897317f, -0.01684168f, -0.02055160f, -0.02954784f, -0.03867478f, 0.02317018f, -0.03658049f, -0.10949442f, 
    -0.21942578f, -0.08415756f, -0.02179888f, 0.22388566f, 0.03736631f, 0.08089440f, -0.02749031f, -0.08923206f, 
    0.01762608f, -0.00008259f, 0.10590672f, 0.08600729f, -0.06634762f, -0.20805767f, 0.03780105f, -0.21324827f, 
    0.19205053f, -0.09185764f, -0.03474478f, 0.03498949f, 0.00392407f, 0.13815635f, -0.07709799f, 0.03486599f, 
    -0.22308365f, 0.02149465f, -0.14735375f, -0.00989589f, 0.05838952f, -0.08088360f, -0.03040069f, -0.07261397f, 
    0.05609107f, -0.05280243f, 0.08025224f, 0.06866717f, -0.01702975f, -0.06335444f, 0.12590045f, 0.00795746f, 
    0.04163938f, -0.10446000f, 0.01782751f, -0.02921015f, 0.00953281f, 0.09482238f, 0.10380422f, 0.10173531f, 
    0.07518940f, -0.07252527f, -0.11027405f, 0.03461025f, 0.09443820f, 0.04727537f, -0.01213931f, 0.02001280f, 
    0.08651856f, 0.00727711f, -0.02888442f, 0.03833323f, -0.04289557f, 0.13379477f, 0.17590529f, -0.04417783f, 
    -0.00275917f, -0.01338202f, -0.02914347f, 0.15232393f, 0.06309609f, 0.04442919f, 0.06735781f, -0.08368103f, 
    -0.06166442f, 0.09840705f, 0.00988291f, -0.14323048f, 0.00239476f, 0.11380614f, -0.09324514f, 0.05337353f, 
    -0.02143526f, -0.01559652f, 0.01274125f, 0.03093724f, 0.32818782f, 0.04116882f, 0.34626085f, -0.24926481f, 
    0.10094118f, -0.10192847f, 0.02147388f, 0.07553696f, 0.03336636f, -0.05567191f, -0.01823440f, 0.09758564f, 
    0.16250077f, -0.04646313f, 0.01718767f, 0.00214920f, 0.05411538f, -0.03809614f, 0.16431887f, -0.04354733f, 
    0.00351994f, 0.03201596f, 0.04184889f, 0.02740674f, -0.01349115f, 0.07038571f, 0.06916154f, 0.11843358f, 
    0.01360113f, 0.04562291f, 0.06823752f, -0.10182381f, 0.08187919f, 0.05534670f, -0.06683931f, 0.08010006f, 
    -0.02155881f, -0.01070901f, -0.24724312f, -0.05953019f, -0.13920374f, 0.18649690f, -0.01194460f, -0.11040565f, 
    0.02337713f, 0.01971989f, -0.09086344f, 0.07646000f, -0.09616624f, 0.17207888f, 0.13293539f, 0.02200458f, 
    0.05896101f, -0.00592711f, -0.11984029f, -0.02599961f, -0.02335895f, 0.10747347f, -0.01855556f, 0.17362723f, 
    -0.07973048f, 0.03702010f, 0.05551225f, -0.02861710f, 0.03907819f, 0.05002699f, 0.10594945f, -0.08954164f, 
    0.05613197f, -0.05561475f, -0.04101551f, -0.06850751f, -0.05594028f, -0.01943783f, -0.03524097f, -0.13213368f, 
    -0.02366386f, -0.02535195f, -0.05615181f, 0.12162960f, 0.06989286f, -0.15455151f, 0.05626472f, -0.04783954f, 
    -0.27772579f, -0.06534934f, 0.17919543f, -0.09097097f, 0.06184154f, -0.14972733f, 0.06816857f, -0.09428519f, 
    0.03512453f, -0.04746452f, -0.08074123f, 0.09690117f, 0.11619723f, -0.10597927f, -0.06552696f, 0.24609467f, 
    -0.02748570f, 0.06974076f, 0.03816107f, 0.02945919f, 0.13303693f, 0.03867948f, -0.01903171f, 0.11931864f, 
    0.12129494f, 0.16240871f, 0.09984126f, -0.13906521f, 0.03083831f, -0.02969615f, 0.05356111f, -0.00730495f, 
    0.04447052f, 0.07079469f, 0.09581134f, 0.05931154f, 0.23330444f, -0.08584027f, 0.09090710f, 0.04068476f, 
    -0.00363656f, 0.02933780f, 0.14694096f, 0.03790489f, 0.07615606f, -0.01557276f, 0.03533002f, -0.01372429f, 
    -0.37532482f, 0.18216906f, 0.03920513f, -0.18750386f, 0.09115642f, -0.01194259f, 0.12600186f, 0.01092780f, 
    0.07678285f, -0.06963433f, -0.04550985f, 0.02706883f, -0.05923285f, -0.07826176f, -0.01835487f, 0.25726387f, 
    -0.00177982f, 0.07087729f, 0.06663830f, 0.10892121f, 0.02345193f, -0.05773707f, -0.04543906f, 0.08553174f, 
    0.07904287f, -0.01862975f, -0.10596661f, 0.13851574f, 0.03069706f, -0.00133100f, -0.01489618f, 0.05389024f, 
    0.01008654f, 0.03752260f, 0.04307867f, 0.02997003f, 0.06598502f, 0.19390751f, 0.03668040f, 0.01763545f, 
    0.06628875f, -0.03682722f, 0.02353270f, -0.04414399f, 0.01809129f, -0.02250273f, 0.05886481f, 0.07139838f, 
    -0.02279984f, -0.08428468f, 0.01781687f, -0.11782433f, -0.01181810f, 0.01972539f, 0.07000811f, -0.03065532f, 
    -0.07552922f, -0.02040777f, -0.10436843f, -0.09397795f, 0.00293155f, -0.04470451f, 0.10074261f, 0.05053797f, 
    0.00898833f, -0.07988063f, -0.08824781f, 0.01335535f, -0.03277396f, -0.03232864f, 0.16535030f, 0.02661864f, 
    0.08853754f, 0.11770086f, -0.26399380f, 0.05919050f, -0.03912812f, -0.04977480f, -0.03078892f, -0.11001460f, 
    0.07766646f, -0.07874610f, -0.06893823f, -0.05325232f, -0.22207382f, -0.01574067f, -0.07690415f, 0.13845284f, 
    -0.06341262f, 0.03350957f, -0.04147980f, -0.18257268f, -0.00316807f, 0.09558517f, 0.08542453f, -0.04216213f, 
    -0.26899683f, -0.19628051f, 0.11211009f, 0.10800416f, 0.02926717f, 0.02183790f, 0.02739410f, 0.03076849f, 
    0.10985744f, -0.03204780f, 0.03714412f, 0.01271850f, 0.13191193f, -0.00250684f, 0.01786392f, 0.03892851f, 
    0.06767140f, -0.05695596f, 0.13226168f, 0.05592580f, -0.03462695f, -0.14068861f, 0.02761229f, 0.09987339f, 
    0.11801273f, -0.01035305f, 0.08687057f, -0.22973804f, 0.06192369f, -0.06004454f, -0.02411870f, 0.09613563f, 
    -0.00041726f, 0.03864054f, -0.01347820f, 0.00300446f, -0.02346931f, -0.20462005f, -0.11017087f, 0.13311425f, 
    -0.03291056f, -0.01209729f, 0.06885071f, -0.12059201f, -0.01889182f, 0.02725764f, 0.03495320f, -0.04436330f, 
    0.04118596f, 0.00057125f, 0.12473127f, -0.10259759f, 0.12224019f, 0.03139493f, -0.03750897f, -0.00465040f, 
    0.03087896f, 0.00630684f, -0.00291226f, 0.00043600f, -0.00451085f, 0.07962711f, 0.14481390f, -0.10866455f, 
    -0.07654783f, 0.07736865f, -0.05831966f, 0.01849470f, -0.09296221f, 0.02993755f, -0.06838021f, -0.00460673f, 
    -0.02803287f, -0.04224500f, -0.29069510f, -0.12316008f, 0.08942725f, 0.00083202f, -0.07803103f, -0.10380251f, 
    0.05672687f, 0.00556936f, 0.05232293f, -0.01193177f, -0.09651494f, -0.20060633f, 0.09002805f, -0.04178816f, 
    0.14384584f, 0.04011339f, -0.07631726f, 0.00212228f, 0.06760342f, 0.05964591f, 0.03748656f, -0.01870798f, 
    0.08972892f, -0.00334236f, 0.16034287f, -0.07630177f, -0.12216692f, -0.06765186f, 0.03797356f, 0.08137172f, 
    0.04736584f, -0.00242235f, 0.07283212f, 0.03482624f, -0.03699807f, -0.03893618f, 0.11911757f, 0.21010046f, 
    -0.06598314f, 0.03558727f, -0.15859902f, -0.11992550f, 0.13183996f, -0.01822335f, 0.09961781f, -0.02825546f, 
    -0.12592590f, -0.20436965f, 0.08086761f, -0.03412291f, -0.04255811f, 0.01455888f, 0.01886731f, 0.04408299f, 
    0.05912586f, -0.05920748f, 0.00759525f, 0.06682910f, -0.10023627f, -0.04207976f, 0.22398186f, 0.20791860f, 
    -0.00615696f, 0.03582015f, -0.02389537f, 0.14453125f, -0.05085975f, 0.09596766f, -0.00561884f, -0.09505504f, 
    -0.20070732f, -0.09716834f, 0.06666811f, 0.38029975f, -0.05862037f, 0.00823446f, -0.04944203f, 0.06565206f, 
    0.04711191f, 0.00963514f, -0.00082746f, 0.10479393f, -0.15836215f, 0.03509869f, 0.08114945f, 0.05016438f, 
    0.07646555f, -0.03338907f, 0.06583638f, -0.00777910f, 0.03177303f, -0.01953392f, 0.06172317f, 0.15381746f, 
    -0.26158684f, 0.02296174f, -0.12290876f, 0.01025942f, -0.02628342f, -0.08335035f, 0.04609897f, -0.03911642f, 
    0.00044406f, 0.02735254f, 0.03508971f, 0.11618524f, -0.05280171f, -0.09624428f, 0.03272171f, -0.10189446f, 
    -0.01966443f, -0.04825815f, 0.05217906f, -0.06415222f, 0.05997533f, 0.10836004f, 0.00887062f, 0.12451541f, 
    0.09117047f, 0.19190568f, -0.14729178f, -0.10490952f, -0.00195634f, -0.01921269f, 0.00773915f, -0.08869901f, 
    0.11053883f, 0.06367892f, -0.08245414f, 0.02544299f, 0.12997925f, 0.08805900f, 0.05496045f, 0.02327818f, 
    0.04271509f, -0.01096927f, -0.11451670f, -0.09353045f, -0.02884186f, 0.07858940f, 0.09833729f, 0.09336588f, 
    -0.18298171f, 0.00390092f, 0.07477145f, -0.18120822f, -0.02265657f, 0.07744414f, -0.03772224f, -0.09286849f, 
    0.04661585f, 0.00113338f, -0.02231816f, 0.01356467f, 0.26693997f, -0.36481544f, 0.18831839f, 0.00905166f, 
    -0.06480151f, 0.02914298f, -0.01955457f, 0.08315054f, -0.02916760f, -0.00991488f, -0.01594371f, -0.01363553f, 
    0.11847602f, 0.12081564f, 0.05342308f, -0.06955354f, -0.08809379f, 0.03580293f, -0.04060393f, -0.20901398f, 
    0.12653179f, 0.04208175f, -0.13496362f, 0.04437841f, 0.07044429f, 0.15089533f, 0.10037517f, -0.27299261f, 
    0.03225558f, 0.06955945f, 0.11079567f, 0.02344556f, 0.06896958f, 0.07791631f, -0.05343881f, -0.01404192f, 
    -0.05512608f, 0.07830365f, 0.14993264f, 0.03230828f, -0.09956012f, -0.04907781f, 0.07022545f, 0.07858357f, 
    0.01657465f, 0.13586608f, 0.09831218f, 0.10570907f, 0.02826196f, 0.03933582f, 0.22249712f, -0.05912421f, 
    -0.02820039f, -0.00720204f, 0.10894917f, 0.00250048f, 0.01028407f, 0.02404588f, 0.07167750f, -0.03475248f, 
    -0.16330683f, -0.02579715f, -0.02656689f, -0.04667622f, 0.10434077f, 0.05121274f, 0.06663156f, 0.06722185f, 
    -0.03950141f, 0.05019234f, 0.07427900f, 0.13118693f, -0.46203974f, 0.27223176f, 0.07304320f, -0.15087920f, 
    0.10167636f, 0.01642756f, 0.08974589f, 0.02500475f, 0.13690820f, 0.07143619f, -0.08983917f, 0.06432577f, 
    0.06028518f, -0.02533548f, 0.08563302f, 0.01198520f, 0.02065405f, -0.01036778f, 0.03374752f, 0.02356009f, 
    0.11486725f, 0.07775421f, 0.02819539f, -0.02684889f, 0.03178676f, -0.08802216f, 0.00044570f, 0.20172684f, 
    -0.01994560f, 0.02544198f, 0.01175541f, -0.00306970f, -0.04522862f, -0.08633128f, 0.05678104f, 0.02800948f, 
    -0.08994614f, 0.08812997f, 0.12681898f, -0.03278367f, 0.11688058f, 0.07604132f, -0.01223539f, 0.04056055f, 
    -0.07188959f, 0.05727320f, 0.11566103f, 0.06714518f, -0.30784276f, 0.15133022f, 0.06692953f, 0.10434647f, 
    0.05002195f, -0.01935042f, -0.02326494f, 0.02104559f, -0.01419372f, 0.04901548f, 0.19767344f, -0.01251621f, 
    -0.04413191f, 0.01791706f, -0.14949469f, 0.00593407f, 0.09313808f, -0.01486671f, -0.06823948f, -0.08915801f, 
    0.03757435f, -0.18981782f, -0.10909217f, -0.03822096f, -0.16755325f, 0.04210079f, 0.06081844f, -0.03103185f, 
    -0.06186260f, -0.03392858f, -0.03346385f, 0.01306524f, -0.00702429f, 0.04764121f, 0.01150334f, 0.04240489f, 
    -0.06720495f, -0.02402265f, 0.06336033f, -0.10805434f, 0.11537895f, -0.03182884f, -0.06012383f, 0.03745752f, 
    0.02732639f, -0.08753767f, 0.04058416f, -0.12911130f, -0.02460684f, 0.09176616f, -0.02237414f, -0.00594356f, 
    -0.00225275f, 0.03490775f, -0.01464169f, 0.09475760f, 0.02276210f, -0.15085472f, -0.10178103f, 0.00969900f, 
    -0.03122818f, -0.00213149f, 0.02614826f, 0.15596899f, 0.05386432f, 0.00111315f, -0.04384275f, 0.10904230f, 
    -0.02752397f, -0.00786247f, -0.00879426f, 0.10751247f, 0.13619281f, 0.03720212f, -0.12630732f, -0.12984681f, 
    -0.06831868f, 0.02785049f, -0.00024397f, 0.04904164f, 0.08713404f, 0.00582648f, 0.00851588f, 0.08893596f, 
    -0.04754398f, -0.04424148f, 0.01397229f, 0.23027310f, 0.02266875f, -0.04484829f, -0.01577227f, -0.04991847f, 
    0.00422717f, -0.16739421f, 0.02915449f, -0.11153866f, 0.10289624f, 0.15094960f, -0.01137230f, 0.15158056f, 
    0.00552385f, 0.02582305f, -0.04083584f, -0.05041430f, 0.02996259f, 0.03517256f, 0.05761075f, 0.02166140f, 
    0.04290012f, -0.00635281f, -0.09682427f, -0.26572752f, -0.01753911f, 0.00299760f, 0.10272224f, 0.01303143f, 
    0.10256132f, -0.06820230f, -0.02246395f, 0.07590061f, -0.12640685f, -0.05453557f, -0.03343590f, 0.12496784f, 
    0.10913132f, -0.01301991f, -0.05639109f, 0.15173055f, -0.01070400f, -0.04495898f, 0.03016804f, -0.04135891f, 
    0.00376053f, -0.05898227f, 0.20816991f, -0.11098345f, -0.11105624f, 0.15361317f, -0.04473637f, -0.01066480f, 
    0.11519975f, 0.03677738f, 0.01302181f, -0.03237193f, 0.07979380f, 0.02199467f, 0.14299658f, -0.04178692f, 
    0.02113973f, 0.03980204f, -0.00479628f, 0.05968191f, 0.04602833f, 0.03689969f, -0.02563008f, 0.01493259f, 
    0.23407741f, -0.18049134f, -0.10367493f, 0.17778210f, 0.02546583f, -0.06578730f, 0.03886051f, 0.02026704f, 
    0.04215461f, 0.02538921f, -0.06162622f, 0.04003048f, 0.09532184f, 0.08563211f, 0.01451715f, 0.01213385f, 
    -0.01592407f, -0.05488436f, 0.01163658f, 0.00331295f, -0.04091740f, 0.00458114f, 0.16606274f, 0.14801818f, 
    0.22790761f, -0.07955537f, -0.07543735f, -0.08481231f, 0.07300668f, -0.05155475f, -0.04907344f, -0.02318623f, 
    0.11541032f, 0.02995593f, 0.12039825f, 0.00008704f, 0.10492720f, -0.08257932f, -0.02428850f, 0.02082096f, 
    0.09723976f, 0.04039373f, -0.01181528f, 0.01390981f, 0.00241287f, 0.05317113f, -0.02252175f, 0.10760200f, 
    0.17686595f, -0.20833504f, -0.01792924f, 0.04772892f, 0.01972323f, -0.04590786f, 0.05724451f, -0.06318550f, 
    -0.10918923f, -0.07917266f, 0.03500468f, -0.12758625f, 0.04321516f, -0.01279883f, 0.06296700f, 0.03114212f, 
    0.04376366f, -0.02247916f, 0.13285126f, -0.01910844f, -0.07857431f, 0.01634201f, -0.04506246f, 0.04562926f, 
    0.05181159f, -0.05111723f, -0.09085160f, 0.03190061f, -0.13359527f, -0.00416458f, -0.14888078f, 0.06917003f, 
    -0.07253953f, 0.01853490f, -0.04312845f, 0.04694774f, -0.22804439f, 0.03991482f, -0.09676638f, -0.04784624f, 
    -0.00123928f, 0.00460660f, 0.04697691f, -0.00387535f, 0.04035270f, 0.01918563f, -0.07602581f, -0.02825377f, 
    -0.39578387f, 0.23899195f, -0.11372750f, -0.01405745f, 0.05382097f, 0.00060822f, -0.04492095f, 0.03065705f, 
    -0.02502409f, 0.00899984f, -0.14601895f, -0.01653942f, -0.08242998f, -0.03429224f, 0.10397800f, -0.05116896f, 
    0.05031382f, 0.04041690f, 0.03518712f, 0.01418756f, 0.15736011f, -0.02515791f, -0.10617793f, -0.04354751f, 
    -0.31985146f, -0.00707305f, 0.06479522f, -0.11648003f, 0.07927033f, -0.04504305f, 0.05484517f, 0.06687933f, 
    0.10154512f, -0.02194882f, 0.12141351f, -0.07058720f, 0.08390132f, -0.24518259f, -0.22611329f, 0.05341104f, 
    -0.05254106f, -0.04376486f, 0.02317479f, -0.08233590f, -0.05339921f, 0.00239268f, -0.08659200f, -0.02842037f, 
    0.17322698f, -0.12837388f, 0.13756195f, 0.13954352f, -0.05238491f, 0.00053104f, -0.04523973f, -0.07804724f, 
    0.11371186f, -0.05602755f, 0.06761467f, -0.08990127f, 0.28736141f, -0.19363193f, -0.00121854f, 0.14964554f, 
    -0.07522413f, 0.13594961f, -0.01358286f, -0.00379817f, 0.03798934f, -0.04880557f, -0.06647332f, 0.04862463f, 
    0.29642859f, 0.14852372f, 0.14976834f, -0.08294126f, -0.07456560f, -0.02614340f, -0.00379642f, -0.05437060f, 
    0.09007031f, -0.00591779f, 0.09483977f, -0.00972386f, 0.32157949f, 0.09832782f, -0.24734971f, 0.24662164f, 
    0.04434506f, 0.10397820f, 0.02733750f, 0.00136429f, -0.02772006f, 0.02346575f, 0.17967367f, -0.13214590f, 
    0.05572801f, 0.00825352f, -0.20553115f, -0.03054272f, 0.10216788f, -0.07872622f, -0.03526780f, -0.07847814f, 
    -0.02617903f, 0.14959648f, -0.03022812f, 0.01646896f, 0.26673058f, 0.10175695f, -0.03732108f, -0.10702489f, 
    0.02394374f, 0.12430758f, 0.00974880f, -0.04878784f, -0.00291091f, -0.03732401f, 0.11325812f, -0.06826960f, 
    0.03280592f, -0.03215576f, -0.02372009f, -0.09700222f, -0.04154897f, 0.03303082f, -0.06324434f, -0.13213985f, 
    0.00413116f, -0.00281588f, 0.03010702f, 0.08645849f, -0.25036946f, 0.11662547f, 0.00163668f, -0.01634285f, 
    -0.01019419f, 0.03588992f, -0.07071712f, -0.05357297f, 0.01551965f, 0.00161206f, -0.04552637f, 0.07645069f, 
    -0.17400619f, -0.06016866f, 0.07573826f, 0.05223479f, -0.04736348f, 0.13205446f, 0.01244730f, -0.03639823f, 
    -0.01337070f, 0.05133802f, 0.02103532f, 0.02815576f, 0.16375020f, -0.04224965f, -0.04994667f, 0.04646539f, 
    -0.09039537f, 0.06341920f, -0.00478646f, -0.04250137f, 0.08012795f, 0.05815905f, -0.02155329f, -0.00914218f, 
    0.26338601f, -0.09618460f, 0.12629887f, 0.24830064f, 0.00187859f, 0.05909484f, 0.03263785f, 0.03709975f, 
    0.08902831f, 0.05629309f, -0.00325288f, 0.03932448f, 0.12659281f, -0.09320285f, -0.00145429f, 0.02728638f, 
    -0.08745990f, 0.09885887f, 0.05243306f, -0.09731828f, -0.01196226f, 0.00037351f, 0.07789916f, 0.07746468f, 
    0.09422575f, 0.05228955f, -0.05423176f, 0.08334805f, -0.09273446f, -0.05911274f, -0.01962208f, -0.02204074f, 
    0.06647884f, 0.08967745f, 0.06818844f, 0.01365322f, -0.15344685f, 0.19431850f, -0.08163818f, 0.08096352f, 
    -0.06794636f, 0.02035974f, 0.03758244f, 0.09238429f, -0.16220263f, 0.14569066f, 0.01562151f, -0.15114351f, 
    0.23302871f, 0.09146614f, -0.10935232f, -0.20895979f, -0.04705575f, 0.06605359f, 0.02335803f, -0.01800995f, 
    0.00797542f, 0.08533459f, 0.06120749f, 0.04489668f, 0.00219426f, -0.04126906f, 0.04308211f, -0.02120047f, 
    0.04368590f, -0.06588957f, 0.03056442f, 0.05327410f, -0.01588360f, -0.07859701f, -0.06073799f, -0.01975759f, 
    0.12518381f, -0.00167202f, -0.00690591f, 0.10046882f, -0.09437691f, -0.08527326f, 0.08309825f, -0.10982607f, 
    0.07190220f, -0.01184286f, 0.06358835f, -0.03556142f, 0.10349289f, 0.02085576f, 0.15811686f, -0.08642766f, 
    -0.06789234f, 0.14303823f, 0.11699515f, -0.00430343f, -0.01011467f, -0.00925040f, 0.15660480f, -0.09230032f, 
    0.26838753f, 0.20300849f, 0.03287315f, 0.01031864f, 0.08149897f, 0.06443503f, 0.04888843f, 0.06021171f, 
    0.05490142f, -0.01456588f, 0.04988211f, 0.00013848f, -0.00824753f, 0.16576307f, -0.25297710f, 0.11694260f, 
    -0.06894173f, 0.07814946f, -0.09351221f, -0.02044053f, 0.03277418f, -0.05482427f, -0.01374582f, -0.11271926f, 
    -0.06709812f, -0.05264938f, 0.32470635f, -0.14046904f, 0.03621862f, 0.06821573f, 0.10869947f, 0.02681407f, 
    0.03702779f, 0.00867971f, 0.08009356f, -0.06394104f, -0.02956773f, 0.11416014f, 0.24597602f, 0.01305112f, 
    -0.06676480f, -0.03498203f, -0.02516099f, 0.06148960f, 0.05651873f, 0.06683637f, -0.00642028f, -0.02591327f, 
    0.03743901f, 0.19853283f, -0.00159251f, 0.07173431f, -0.17912161f, -0.07258467f, 0.01858622f, 0.01870711f, 
    0.00044566f, -0.02997437f, 0.06549606f, -0.00176914f, 0.06184694f, 0.19027627f, 0.01105855f, 0.06938047f, 
    -0.09700987f, -0.06524646f, 0.03142448f, 0.05692093f, 0.06045859f, 0.09848344f, -0.00149415f, 0.01236694f, 
    -0.11299998f, 0.13367933f, 0.12873690f, -0.05201362f, -0.02227797f, 0.10942338f, 0.04527780f, -0.05534139f, 
    0.12906159f, 0.05247317f, 0.09936550f, 0.00872470f, -0.01616784f, 0.12692156f, 0.07184161f, -0.10468286f, 
    -0.03345044f, 0.00400446f, 0.02729497f, 0.04013805f, 0.08885740f, 0.05812546f, 0.01568498f, -0.02581399f, 
    0.13833503f, -0.02309130f, -0.05947197f, -0.20117491f, 0.15551406f, 0.09028192f, 0.05409905f, -0.03893162f, 
    -0.00063257f, 0.00943082f, 0.05633445f, 0.08472088f, 0.14508188f, 0.16129434f, 0.16180748f, -0.09770904f, 
    0.02199952f, 0.05763079f, -0.03883443f, -0.03612557f, 0.02022329f, 0.02669017f, 0.10037417f, 0.09634111f, 
    0.12123555f, -0.15934743f, -0.01527901f, -0.25808635f, -0.03648701f, 0.07960334f, -0.00068252f, -0.03889554f, 
    0.10209975f, -0.10007612f, 0.07825077f, -0.02404331f, 0.12787502f, -0.14502592f, 0.05722644f, -0.03358958f, 
    0.09028453f, -0.09496771f, 0.11058300f, 0.09718513f, -0.06488436f, 0.00481184f, 0.13193050f, 0.03239542f, 
    0.08016136f, 0.03454968f, -0.03208759f, -0.05472797f, -0.00491029f, 0.05351439f, 0.00099312f, 0.03905490f, 
    -0.00271382f, -0.02716434f, -0.05291390f, -0.00982210f, -0.21547714f, -0.14543249f, 0.28816861f, -0.01839436f, 
    0.00410574f, 0.06574614f, -0.01524699f, 0.06199657f, 0.02556926f, 0.04923646f, 0.07705220f, -0.00527670f, 
    0.19528022f, 0.16704483f, 0.05804992f, -0.15180077f, -0.13761765f, -0.10696100f, 0.02052804f, 0.02870581f, 
    0.01699760f, 0.03168660f, -0.04749268f, 0.03998297f, -0.06662644f, -0.03827945f, 0.20454787f, -0.02550786f, 
    0.03428674f, -0.15719126f, 0.07176934f, 0.03958922f, 0.09320436f, -0.08937642f, 0.17881630f, 0.00947198f, 
    -0.42983305f, -0.24895199f, -0.32745811f, -0.05742904f, 0.18631434f, 0.03250023f, 0.07284635f, 0.15908086f, 
    0.04047497f, 0.06789758f, 0.00763613f, -0.01930869f, -0.38686046f, -0.04545083f, 0.11077330f, 0.10285945f, 
    -0.08930735f, 0.03749620f, 0.06702259f, 0.03588756f, -0.00971845f, -0.03051443f, -0.12595941f, 0.08480184f, 
    0.07338042f, -0.17177278f, 0.24132754f, 0.20358109f, -0.01126509f, -0.08966735f, 0.11165258f, 0.04508940f, 
    0.03390940f, -0.05482057f, 0.06526653f, -0.05694386f, 0.07922027f, 0.17181805f, 0.05080343f, 0.09481310f, 
    -0.10829888f, -0.12851018f, -0.01591846f, 0.08472053f, -0.00907805f, 0.02517847f, 0.01561071f, 0.09491679f, 
    -0.14639772f, -0.10159830f, 0.04648368f, 0.08363824f, 0.04371228f, 0.12951715f, 0.00170239f, 0.08925480f, 
    -0.00841354f, 0.02899892f, -0.08383308f, -0.09989239f, 0.04282529f, 0.06183822f, 0.06259660f, 0.05843318f, 
    -0.05148137f, -0.08977245f, 0.01480726f, 0.04067456f, 0.02378932f, 0.01744830f, 0.09636793f, -0.05125162f, 
    -0.01824330f, 0.08495956f, -0.05519248f, -0.02552136f, -0.06029956f, -0.07507411f, 0.05759935f, 0.00196351f, 
    -0.11916597f, -0.02120810f, -0.02117939f, -0.04333343f, -0.38614407f, -0.00167849f, 0.06766392f, -0.02858284f, 
    0.03391197f, 0.01793877f, -0.11019041f, 0.02226399f, 0.07308555f, -0.01377209f, 0.02107722f, -0.02934460f, 
    -0.41755900f, 0.05128050f, 0.13500714f, -0.06607238f, -0.09959310f, 0.07457291f, 0.06161465f, 0.00351935f, 
    -0.12095727f, -0.03846979f, -0.04922053f, 0.13279411f, -0.05653904f, 0.01269942f, 0.09711744f, -0.08283696f, 
    0.09106801f, -0.13878495f, 0.01161609f, 0.15056230f, -0.06018449f, -0.09352084f, 0.08860577f, -0.09746964f, 
    0.07520989f, 0.19261362f, 0.09651129f, -0.06241558f, 0.00949918f, 0.04433375f, 0.01503699f, 0.05688035f, 
    0.05602521f, 0.00939991f, -0.01780684f, -0.00794662f, 0.29449537f, -0.29252556f, 0.02680488f, -0.11749461f, 
    0.11227721f, 0.09800021f, 0.06825424f, -0.01061374f, 0.16230062f, -0.03438926f, -0.09091849f, -0.00152466f, 
    0.00506018f, 0.04428523f, -0.07259250f, 0.11590658f, 0.01464718f, 0.03124579f, -0.01658369f, -0.01904196f, 
    -0.00358174f, 0.01946262f, 0.00706976f, 0.02538039f, 0.02195491f, 0.16759714f, 0.15195464f, -0.04493770f, 
    -0.11811535f, 0.09078754f, 0.10012195f, -0.02581155f, -0.02261921f, 0.07784346f, 0.00748975f, 0.13582073f, 
    -0.22975807f, -0.01794068f, -0.16596009f, -0.16430810f, 0.11538877f, 0.09378058f, 0.01153858f, 0.19172743f, 
    0.01192749f, 0.00044962f, -0.01184986f, 0.05437248f, -0.23873699f, 0.00326832f, -0.21600410f, 0.04558249f, 
    0.03168081f, 0.08472028f, -0.10226169f, 0.01519381f, -0.02733604f, 0.03395044f, -0.06596801f, 0.05105961f, 
    -0.16083691f, -0.22601205f, 0.30113059f, -0.18339914f, -0.13882953f, -0.02476200f, 0.00507319f, 0.05064717f, 
    0.04023644f, -0.08491556f, 0.01980422f, -0.00691941f, 0.08092991f, -0.00543458f, 0.24458508f, 0.07667059f, 
    0.13020790f, 0.05427629f, 0.06874611f, -0.00913048f, 0.10236891f, 0.01605891f, -0.03749928f, 0.04612348f, 
    -0.07392719f, -0.16880010f, 0.05647362f, 0.05918514f, 0.01618264f, 0.03911227f, -0.00112969f, -0.01185741f, 
    0.04089123f, -0.11304605f, 0.01544575f, 0.04610904f, 0.07172521f, -0.03563415f, 0.08997627f, 0.10213804f, 
    0.04126907f, -0.04034051f, -0.03897740f, 0.08235718f, -0.08846647f, -0.00986129f, -0.11487859f, -0.05876316f, 
    0.02352465f, -0.11357541f, -0.02407506f, 0.43005618f, 0.02135734f, -0.04750879f, 0.04665388f, -0.06613632f, 
    0.07817775f, -0.01031550f, 0.03760358f, 0.13846238f, -0.01808698f, -0.00644335f, -0.28015491f, 0.12744893f, 
    0.02282747f, -0.04996109f, -0.02283880f, 0.06427875f, -0.06852357f, 0.01684329f, 0.07581714f, 0.11374407f, 
    -0.09440511f, -0.16007163f, -0.02006562f, 0.01972067f, -0.00151177f, -0.09302124f, 0.10926470f, -0.06960569f, 
    -0.02286750f, -0.08940525f, 0.21857136f, 0.10598436f, 0.15633066f, -0.17968535f, 0.02001613f, -0.01662181f, 
    -0.10726743f, -0.02235723f, 0.10852847f, -0.05964292f, -0.05529233f, 0.13496722f, -0.00830847f, -0.02419626f, 
    0.09658857f, 0.28661510f, 0.01440863f, -0.10102079f, 0.04415818f, -0.07567765f, -0.04038993f, -0.05267165f, 
    0.04150879f, 0.05675288f, -0.04233998f, 0.02172899f, 0.15051578f, 0.07974153f, 0.07877785f, -0.01127857f, 
    0.08928657f, -0.09745714f, -0.07469887f, -0.10095828f, -0.07524066f, 0.08603691f, -0.04230897f, 0.12264999f, 
    -0.13740321f, 0.15818191f, -0.05397947f, -0.13844539f, -0.07552201f, 0.10000006f, -0.10629167f, -0.02136519f, 
    0.01620059f, -0.05347774f, 0.09714182f, 0.06384879f, 0.21302299f, -0.30081528f, 0.13276635f, -0.09546553f, 
    -0.01176032f, 0.00290110f, -0.05861469f, 0.00270524f, 0.00147629f, 0.07157904f, -0.12165684f, -0.07788276f, 
    -0.00194471f, 0.39248535f, -0.06751327f, -0.12392570f, -0.00008257f, 0.11028260f, -0.02558189f, -0.07537317f, 
    0.22963712f, 0.00325156f, -0.15904853f, -0.08446897f, -0.11716847f, -0.11232323f, 0.13854484f, -0.22609420f, 
    0.00779192f, -0.11717321f, 0.15194243f, 0.02068478f, 0.00082675f, 0.06780358f, -0.08610871f, 0.02432017f, 
    -0.05280001f, -0.17041500f, 0.08027687f, 0.32157046f, -0.03799025f, -0.08412321f, -0.02337186f, -0.01712961f, 
    0.09934213f, 0.02246580f, -0.01795803f, 0.17055064f, 0.12039641f, -0.22573373f, 0.12656942f, 0.07529646f, 
    -0.06805554f, 0.02923149f, 0.02028995f, 0.00421882f, -0.06286507f, 0.04018636f, 0.05282922f, 0.02713240f, 
    0.20741849f, -0.08035953f, 0.06293700f, 0.12382266f, 0.01785003f, 0.04677920f, 0.05912568f, 0.10971890f, 
    0.02884238f, -0.02624888f, 0.03480067f, 0.22393325f, -0.12164324f, 0.20042506f, 0.05686632f, 0.00270681f, 
    -0.03676074f, 0.03497076f, 0.07906684f, -0.03757788f, 0.07417680f, 0.02420467f, -0.03596890f, -0.01173596f, 
    -0.02949337f, -0.02241353f, 0.08594190f, -0.11242669f, 0.03869270f, -0.11141260f, 0.02395011f, 0.01533588f, 
    -0.04050887f, -0.01022383f, 0.11682688f, 0.00607949f, 0.18155806f, -0.21440326f, 0.00670632f, 0.16240722f, 
    -0.11387946f, -0.07066169f, 0.02611976f, -0.04983314f, -0.05503774f, -0.03944910f, -0.01733023f, -0.02023315f, 
    0.05997485f, 0.19085559f, 0.01286934f, 0.18087858f, 0.05240520f, 0.00316295f, -0.01647635f, 0.06548817f, 
    -0.17441562f, 0.01643916f, 0.10921162f, 0.05906914f, -0.20253910f, 0.05629720f, 0.00216346f, 0.01459464f, 
    0.12747130f, 0.09845012f, -0.12875408f, -0.09699833f, 0.09332565f, 0.02518209f, 0.04285914f, 0.11360887f, 
    0.05114220f, -0.10849465f, -0.01053847f, -0.19566306f, 0.06344900f, -0.00598974f, -0.10126959f, -0.08934212f, 
    -0.05909830f, -0.07709319f, -0.09768167f, -0.04805899f, 0.02545284f, 0.09350752f, 0.03555554f, 0.15132876f, 
    0.01180772f, -0.06394881f, 0.05108095f, 0.12095761f, 0.00012783f, -0.01471673f, 0.00277181f, 0.03273408f, 
    0.19837843f, -0.01419332f, 0.15103228f, 0.14004683f, 0.06032499f, -0.01052747f, 0.00396879f, 0.01243045f, 
    -0.05926794f, 0.02593513f, 0.03808441f, -0.10514227f, 0.14003292f, 0.08169675f, 0.05580172f, 0.11145545f, 
    -0.02790037f, 0.14457566f, -0.07889104f, -0.01633715f, -0.03715532f, -0.13211000f, -0.10671984f, -0.02797806f, 
    0.06485625f, 0.11851574f, 0.00173257f, 0.26309854f, 0.00940261f, 0.00794683f, 0.01050792f, -0.03321166f, 
    0.11237876f, 0.00448522f, -0.04262064f, 0.07296587f, 0.06477648f, 0.20954253f, -0.03923032f, -0.11698269f, 
    -0.06228019f, 0.01656598f, 0.03139673f, 0.06051956f, 0.08307522f, -0.00412402f, -0.01356521f, 0.03621627f, 
    -0.06489475f, 0.06549913f, -0.17406568f, 0.09812415f, -0.01951682f, 0.07058060f, -0.04295439f, -0.11385943f, 
    -0.00828523f, 0.00735184f, -0.00948605f, -0.19411035f, 0.13934164f, -0.02756548f, 0.04937424f, -0.03030643f, 
    0.01075956f, -0.05850724f, -0.03112905f, 0.01333880f, 0.03270892f, 0.03026531f, 0.09469388f, 0.01508831f, 
    0.21436135f, 0.14078292f, 0.01879925f, -0.07291773f, -0.02392539f, -0.09440535f, 0.04984042f, 0.00708991f, 
    -0.01735313f, -0.07452749f, -0.02121843f, -0.02648958f, 0.01906098f, 0.02678430f, -0.01206554f, 0.03153891f, 
    -0.02018053f, 0.01633125f, -0.04733658f, 0.01205970f, -0.09354148f, -0.01912806f, 0.14841868f, -0.05023345f, 
    0.28994292f, -0.03794187f, 0.11152580f, -0.20144010f, -0.06692234f, 0.16307040f, 0.04427916f, 0.02341894f, 
    0.07286595f, 0.10242570f, -0.04853295f, -0.10586149f, 0.00574262f, 0.13353004f, -0.08807399f, -0.01975526f, 
    0.11287086f, 0.17630202f, -0.07630708f, 0.07794498f, 0.05605266f, -0.06639907f, 0.10684168f, 0.03149172f, 
    0.07882290f, 0.01258797f, 0.05862080f, 0.07169626f, 0.16404451f, -0.02253897f, 0.05109958f, 0.01247853f, 
    0.11279441f, 0.00910792f, 0.05497139f, -0.10225692f, 0.01878614f, 0.17644697f, 0.12778074f, -0.02838475f, 
    -0.07782933f, -0.03597528f, 0.06008432f, 0.04125555f, -0.02561623f, 0.01703512f, 0.09977008f, 0.13601199f, 
    -0.06519569f, 0.11283077f, 0.03718365f, -0.10154146f, 0.00249356f, 0.05623225f, -0.01095189f, 0.02089604f, 
    -0.02074649f, 0.01919593f, 0.08642412f, 0.03549396f, 0.21584073f, 0.18399490f, 0.09422780f, -0.10846988f, 
    0.10933294f, 0.03125351f, 0.04637194f, 0.08010808f, -0.06640579f, -0.03124386f, 0.03430442f, 0.03802466f, 
    0.42523757f, -0.15960407f, -0.01029302f, 0.06593069f, -0.00060783f, -0.00811527f, 0.12876193f, 0.03803186f, 
    0.07578249f, 0.04197504f, 0.19309092f, -0.06517483f, -0.06805868f, 0.17677996f, 0.08782872f, 0.04204902f, 
    0.00610687f, 0.12381592f, 0.17822517f, -0.09634869f, -0.06119920f, 0.03785871f, 0.00980547f, -0.00015667f, 
    0.13493744f, -0.10563735f, -0.24273589f, -0.10512895f, -0.11232687f, 0.08578105f, -0.10430834f, -0.07706469f, 
    0.06363381f, 0.01071484f, -0.04327804f, 0.08905099f, -0.17510383f, 0.28340563f, 0.21248530f, 0.03750306f, 
    0.05983368f, -0.05675739f, 0.05804307f, 0.00002323f, -0.07606812f, 0.00564060f, -0.09031931f, 0.10115241f, 
    0.05047397f, -0.08635204f, -0.01532216f, -0.17299588f, 0.09584478f, 0.07092305f, 0.01547180f, 0.04340861f, 
    -0.00041924f, -0.05573257f, -0.05048260f, 0.11908180f, -0.18204972f, -0.20235921f, 0.14142896f, -0.36787951f, 
    -0.01569001f, 0.05325410f, 0.08706705f, 0.09861409f, 0.00106162f, -0.07482634f, 0.08185024f, 0.06403252f, 
    -0.08021495f, -0.09623804f, -0.02822080f, -0.02896703f, 0.05958526f, 0.02528862f, -0.00507009f, 0.06901323f, 
    0.04368984f, -0.03976252f, 0.03752747f, 0.01293514f, -0.03622766f, -0.24667570f, -0.14263171f, 0.22209094f, 
    0.06455813f, 0.05879810f, -0.07417349f, -0.02622336f, 0.03560705f, 0.05838978f, 0.04272700f, -0.00287881f, 
    0.05418885f, 0.15524994f, 0.01627464f, -0.22716154f, 0.06807464f, -0.00147981f, 0.03801288f, -0.02917528f, 
    -0.05951566f, 0.04723145f, 0.01442643f, 0.07509329f, 0.19944483f, 0.04078311f, 0.06613651f, -0.14794916f, 
    -0.02630209f, 0.03141650f, -0.00020391f, 0.02753645f, 0.00324800f, 0.03240820f, 0.12033001f, -0.03500176f, 
    0.11299413f, -0.20938128f, -0.06220527f, -0.10766457f, -0.06333498f, 0.02789256f, 0.00950545f, -0.06906079f, 
    0.03291092f, -0.00738222f, 0.02375004f, 0.05649805f, 0.10496876f, -0.08438966f, -0.23188180f, 0.07216011f, 
    0.03176876f, 0.13324358f, 0.07872956f, 0.01946721f, -0.01375768f, 0.04435768f, -0.02585850f, 0.00005728f, 
    -0.02276291f, -0.14248867f, -0.13421343f, -0.17119877f, 0.06529330f, -0.04410461f, 0.11072975f, 0.00817526f, 
    -0.04857691f, 0.01958636f, -0.00571718f, -0.00111440f, -0.00313832f, 0.12338767f, 0.11010300f, -0.09226134f, 
    -0.05468245f, -0.02792154f, -0.02137882f, 0.01078699f, -0.01853032f, -0.07236435f, 0.04720115f, 0.09006955f, 
    0.00475636f, -0.08369344f, 0.04510296f, -0.03224247f, -0.02717512f, 0.11232914f, 0.07848714f, 0.03470991f, 
    -0.05113954f, -0.01508138f, -0.04840259f, 0.05331694f, 0.27673349f, 0.05648959f, -0.07771062f, -0.12505737f, 
    -0.01770578f, -0.01777069f, -0.06420214f, 0.01662446f, -0.00403157f, 0.01228754f, 0.03171840f, -0.04282494f, 
    0.10683008f, 0.19334011f, -0.06204150f, 0.10833202f, -0.01697535f, -0.02529066f, 0.06182790f, -0.02340530f, 
    0.01998693f, -0.07915637f, -0.01222603f, 0.03126688f, -0.13364217f, 0.07984726f, -0.18966556f, 0.19809072f, 
    0.02761724f, -0.06462628f, -0.00136034f, 0.02249796f, 0.09541652f, 0.03719328f, 0.10613841f, 0.01975252f, 
    0.07081854f, -0.06490897f, 0.06344961f, -0.06584396f, 0.07750934f, 0.07479075f, 0.03932456f, -0.03884282f, 
    -0.09352352f, 0.08726709f, -0.05160289f, -0.00041489f, 0.31844440f, -0.10217099f, -0.02259058f, -0.03465585f, 
    -0.06438205f, 0.05878384f, 0.00360699f, -0.02877406f, -0.01126814f, -0.04747482f, 0.01967173f, 0.01846212f, 
    0.02577691f, 0.16035873f, 0.10848467f, -0.18074951f, 0.00263702f, 0.05301293f, 0.03568667f, 0.00463592f, 
    0.06316068f, 0.00077474f, 0.04018838f, 0.09672728f, -0.15716723f, -0.20956574f, -0.22448118f, 0.02020684f, 
    -0.00155240f, 0.01442928f, 0.00855401f, -0.01754752f, -0.06833720f, 0.05592542f, 0.02020482f, -0.10952566f, 
    0.18295899f, 0.04319011f, 0.02469089f, -0.02060468f, 0.08947389f, 0.06176397f, -0.10538675f, -0.05227747f, 
    0.02040244f, 0.01958388f, 0.02196630f, -0.00638831f, -0.16587910f, 0.13607639f, 0.17330183f, -0.14589538f, 
    -0.04222421f, 0.07034449f, -0.03275261f, -0.01526885f, -0.01765962f, -0.00860899f, 0.07151275f, 0.07391435f, 
    0.15844597f, -0.04580407f, -0.31669188f, 0.00686636f, 0.05867231f, -0.04973485f, -0.00619931f, 0.01972613f, 
    0.05740193f, -0.01671200f, 0.02010768f, 0.01452578f, 0.29388642f, 0.04502347f, 0.01236722f, 0.01907959f, 
    -0.05996994f, 0.10402674f, 0.00789326f, 0.00941119f, 0.03809305f, 0.03445647f, 0.09557538f, 0.00427125f, 
    0.51340032f, -0.12185454f, 0.17142323f, 0.10343403f, 0.01747663f, 0.00326900f, 0.02484361f, 0.14462589f, 
    0.01125015f, -0.06387851f, 0.00872852f, 0.08510565f, -0.14919211f, -0.03689103f, -0.02192653f, 0.25018743f, 
    0.01502715f, 0.05197825f, -0.05252390f, -0.09686551f, 0.13662727f, -0.05550710f, 0.00683336f, -0.11691974f, 
    -0.08290334f, 0.03516201f, -0.14541291f, 0.14399923f, 0.12951216f, 0.10279360f, -0.01422882f, 0.04740750f, 
    -0.03431116f, -0.04472817f, 0.01619927f, 0.16442890f, -0.07719562f, 0.00967318f, -0.05615580f, -0.09670312f, 
    0.13590175f, -0.01976002f, -0.04150137f, 0.05221338f, 0.05332538f, -0.00756905f, -0.14650869f, -0.19163814f, 
    -0.14871958f, 0.03427142f, -0.18258460f, 0.09623371f, -0.09285949f, 0.13401540f, 0.03899505f, -0.00462036f, 
    -0.09793428f, -0.05149749f, -0.00488500f, 0.08531433f, 0.14570238f, -0.18532662f, 0.18246277f, -0.03984292f, 
    0.04497576f, -0.04244301f, -0.02312349f, 0.12951665f, -0.01244915f, -0.09672626f, -0.01717552f, 0.02688493f, 
    -0.17769313f, 0.12006335f, 0.15100352f, -0.05587613f, -0.00373180f, -0.08889145f, 0.07874114f, 0.00040440f, 
    -0.00265925f, -0.01500944f, 0.01987451f, 0.04519084f, -0.04978156f, -0.07446432f, -0.00389280f, 0.05117115f, 
    -0.06971470f, 0.05598031f, 0.03694765f, 0.02498631f, 0.06738624f, 0.07487214f, -0.12784609f, -0.04266991f, 
    -0.28255472f, 0.34374410f, -0.12763302f, -0.03990730f, 0.07117786f, -0.00649840f, 0.08257786f, -0.08062556f, 
    -0.01830773f, -0.01261464f, 0.01978894f, -0.12167208f, 0.12163334f, 0.08831289f, 0.15877114f, -0.05975689f, 
    0.02815001f, -0.06444378f, -0.09003965f, -0.06098988f, -0.15419659f, 0.08945376f, -0.06999477f, 0.15461834f, 
    -0.02765014f, 0.06555049f, 0.01859391f, 0.16691269f, -0.05709150f, 0.03878032f, -0.04214662f, -0.17272256f, 
    0.06048397f, -0.03131714f, 0.08625983f, 0.03205417f, 0.20925932f, -0.00939135f, 0.06446484f, 0.04177784f, 
    -0.04218116f, -0.01558464f, -0.04745899f, 0.01824223f, -0.01965213f, -0.06608316f, 0.10008730f, -0.15936315f, 
    -0.27944875f, 0.20947294f, 0.09018859f, -0.01999264f, -0.01052503f, -0.03629162f, 0.00282874f, -0.10412773f, 
    -0.01170929f, -0.06782380f, -0.21392855f, 0.09677520f, -0.09100318f, 0.05502737f, 0.05962071f, 0.18689981f, 
    -0.12267030f, -0.10881378f, 0.00892398f, 0.07578979f, 0.17260699f, 0.04934486f, -0.06811576f, 0.05701813f, 
    -0.14906134f, -0.01871333f, 0.07402489f, 0.24315830f, -0.02555898f, -0.00394009f, -0.01438881f, 0.00450277f, 
    0.05653533f, 0.14671335f, 0.06048938f, 0.12209612f, 0.01230430f, -0.08037028f, 0.03518004f, 0.02993230f, 
    -0.01973132f, 0.13148166f, 0.06247965f, 0.03237759f, -0.00626730f, 0.10129879f, -0.02502498f, 0.08146096f, 
    -0.15147635f, 0.05591010f, 0.18166296f, -0.12381663f, 0.05115579f, -0.01417557f, 0.04578905f, -0.00889150f, 
    0.00520723f, 0.02552618f, -0.03713089f, 0.08543897f, 0.05674677f, -0.03517830f, 0.26134288f, 0.41861346f, 
    -0.06793304f, -0.10998742f, 0.04307811f, 0.02633223f, -0.01760503f, 0.05306061f, -0.08790834f, 0.12219435f, 
    -0.07695094f, 0.07997905f, 0.00479726f, 0.09728714f, -0.03362232f, -0.13207701f, -0.14050326f, 0.02386892f, 
    0.02427166f, 0.05822518f, 0.05984631f, 0.09398623f, -0.01268008f, -0.06259271f, 0.00224258f, 0.07583446f, 
    -0.00084368f, -0.01784249f, -0.05719243f, -0.03224644f, 0.00064375f, -0.03236488f, 0.03931163f, 0.11984956f, 
    0.05046689f, 0.17976893f, 0.07163256f, 0.14839020f, 0.05238496f, -0.12540635f, -0.01071720f, -0.05885663f, 
    -0.10526538f, 0.01221569f, -0.05811701f, -0.04713004f, -0.09346048f, -0.08015117f, 0.26029369f, 0.10883036f, 
    0.05213990f, -0.07650288f, -0.00660722f, -0.00932372f, 0.05238629f, 0.02123458f, 0.10388858f, 0.08167019f, 
    0.15694830f, -0.12865704f, -0.18033078f, 0.04375229f, -0.05970882f, -0.11692625f, -0.07579859f, 0.00343195f, 
    -0.10511726f, -0.00676009f, -0.12240397f, -0.10071392f, 0.24141277f, 0.11430769f, 0.12550968f, 0.23278312f, 
    0.00700146f, -0.01901467f, -0.09187165f, 0.05389811f, -0.06295140f, 0.04641972f, -0.02817970f, -0.03145839f, 
    0.13952696f, -0.09623479f, 0.17830977f, 0.36265656f, 0.00226044f, 0.04554120f, 0.03900483f, 0.00250383f, 
    -0.06369211f, 0.01116782f, -0.02189318f, -0.10176683f, -0.04741349f, 0.17070214f, -0.01721734f, 0.11057585f, 
    0.09533099f, 0.01822867f, 0.01398781f, 0.06034924f, 0.01922226f, -0.13014190f, -0.03930918f, -0.06565274f, 
    -0.05442238f, 0.06075692f, 0.14085400f, -0.17079732f, 0.07712192f, -0.00477435f, 0.01161520f, 0.04726415f, 
    0.00286389f, -0.00328695f, -0.04049142f, 0.07490317f, -0.09872426f, 0.13272540f, -0.01390915f, 0.08194818f, 
    0.05674191f, 0.00393814f, 0.09261081f, -0.02818883f, 0.09866115f, -0.02695743f, 0.05035010f, 0.04942752f, 
    -0.07471450f, 0.05293038f, 0.12747785f, -0.26980010f, 0.14435643f, 0.00866235f, 0.00249661f, -0.00845301f, 
    0.05053204f, 0.02884246f, -0.05221453f, -0.19070025f, -0.00331009f, 0.00712375f, 0.15331040f, -0.13031054f, 
    -0.04826191f, -0.05168096f, -0.00185184f, 0.02432680f, -0.05295070f, 0.05009243f, -0.04445130f, -0.00635696f, 
    0.00857837f, 0.06227013f, -0.06115103f, 0.10955287f, 0.02452619f, 0.03082816f, -0.02791725f, -0.06068781f, 
    0.00810635f, -0.02846017f, 0.04156148f, 0.01884118f, -0.11619020f, -0.19617468f, 0.06823386f, -0.27522904f, 
    0.08547579f, 0.01665136f, -0.03416372f, -0.07158414f, -0.08940594f, 0.12431874f, -0.02560541f, 0.02394563f, 
    -0.04126200f, 0.10127427f, 0.10400617f, -0.17824119f, -0.09192620f, -0.01183698f, 0.03033335f, -0.03046261f, 
    0.08955663f, 0.02608374f, -0.05112167f, -0.01318865f, 0.06282020f, 0.12979546f, 0.05348098f, 0.09647483f, 
    0.08860059f, 0.06264336f, -0.17826606f, -0.13831197f, -0.03607220f, 0.05480900f, 0.09224807f, 0.01093579f, 
    -0.01468465f, -0.18266097f, -0.01504891f, 0.02784883f, 0.04505936f, 0.07806071f, 0.01893879f, 0.03837545f, 
    -0.08696599f, -0.03225152f, 0.05437735f, 0.08541140f, 0.13556515f, -0.09833840f, -0.10482682f, -0.09153893f, 
    0.09485950f, -0.07695366f, -0.05398333f, -0.01572045f, -0.01121162f, -0.01369182f, -0.12252883f, -0.13727453f, 
    0.23872505f, -0.08488287f, -0.06643929f, 0.00279075f, -0.00246324f, 0.05271278f, -0.05766446f, 0.05998435f, 
    0.00085653f, 0.00082618f, 0.00878277f, -0.09295621f, 0.28978696f, -0.23970225f, -0.14742392f, 0.04411909f, 
    -0.03375857f, -0.07289256f, -0.01502845f, 0.01072825f, 0.04249321f, 0.04687041f, -0.04279914f, 0.00135238f, 
    0.02867158f, -0.08201917f, 0.13059856f, -0.16571636f, 0.02312711f, -0.03174243f, 0.02313587f, -0.04537790f, 
    -0.11301429f, -0.05476928f, -0.01974658f, 0.09676069f, 0.20084207f, -0.02534324f, -0.09717993f, -0.01184724f, 
    0.03429544f, -0.04437206f, -0.03894742f, 0.06843484f, 0.03529808f, 0.01735700f, -0.11180938f, -0.08847917f, 
    0.13571730f, 0.14711879f, 0.23311944f, 0.11851654f, 0.01346663f, -0.02553338f, 0.06632223f, 0.12220922f, 
    -0.08683005f, 0.01989403f, 0.04371203f, 0.00626457f, 0.18027398f, 0.04371245f, -0.07199558f, -0.02836134f, 
    -0.02149982f, 0.01142199f, -0.03039365f, 0.04734859f, 0.02073406f, -0.00412679f, 0.00908519f, 0.05827985f, 
    0.04690857f, 0.22712190f, -0.07622258f, 0.24087442f, -0.11143726f, -0.00620033f, 0.06744077f, -0.00123178f, 
    0.01746866f, -0.06013038f, 0.02505145f, 0.02551641f, 0.01934100f, 0.15919881f, -0.04282263f, 0.15482110f, 
    0.04289561f, -0.09714228f, -0.04974153f, -0.08388142f, 0.10086143f, 0.04052176f, -0.02529811f, -0.02363030f, 
    -0.11306845f, 0.20699008f, 0.07336187f, -0.02660004f, -0.07233036f, -0.00748636f, -0.01128766f, -0.08560225f, 
    -0.02711119f, 0.03246622f, -0.02443999f, -0.01315008f, -0.25867128f, 0.05470664f, 0.19962724f, 0.03203680f, 
    -0.01786029f, -0.14436662f, 0.06442700f, -0.07946560f, 0.05636485f, 0.05437265f, -0.03819748f, 0.03852851f, 
    0.12385204f, -0.13250142f, 0.01425889f, 0.28430915f, 0.03318600f, 0.02129971f, -0.05351013f, -0.02751714f, 
    0.08626929f, -0.02868409f, -0.01001673f, 0.03896414f, -0.09400740f, -0.18303305f, 0.00612437f, 0.12874980f, 
    -0.02692538f, -0.08819366f, -0.01331343f, 0.00901655f, -0.02643074f, 0.07065406f, -0.01798414f, 0.08977990f, 
    -0.12179565f, 0.24273992f, 0.14537191f, 0.02885876f, 0.14450358f, 0.04136873f, -0.01513917f, 0.05065857f, 
    0.00644559f, 0.05162489f, 0.00648003f, -0.00502849f, 0.23274691f, 0.02317306f, 0.05167401f, 0.26058707f, 
    0.00733348f, 0.03674800f, -0.01949083f, 0.07298084f, -0.06389635f, -0.03851054f, 0.07282002f, -0.04928826f, 
    -0.08331607f, 0.08359209f, 0.04843778f, 0.17361538f, -0.05236290f, 0.00603204f, -0.02025168f, 0.02206976f, 
    -0.06363893f, 0.01222994f, 0.10184703f, 0.06832088f, 0.22979808f, 0.07406004f, 0.03576661f, 0.02256277f, 
    0.07382464f, -0.00885374f, 0.00777017f, -0.05168393f, 0.06532472f, 0.00728384f, -0.07122325f, -0.02975060f, 
    0.05556421f, -0.14174567f, 0.00233549f, 0.04754894f, 0.08106030f, -0.13620135f, -0.02283807f, -0.03432931f, 
    0.03141157f, -0.00899239f, 0.00155408f, -0.10277320f, -0.07762705f, 0.06158359f, 0.00133892f, 0.11424999f, 
    0.09975787f, -0.04688250f, -0.00710797f, 0.02706263f, 0.02189349f, -0.02102001f, 0.04974111f, 0.05458034f, 
    0.07994678f, -0.05993334f, 0.02508991f, -0.21240771f, -0.02221387f, -0.02462471f, -0.11667805f, -0.07991062f, 
    -0.04834511f, 0.04639689f, 0.04561975f, -0.11335809f, 0.25453371f, -0.19418636f, 0.20290317f, -0.13004340f, 
    -0.02933745f, 0.06171231f, 0.03554561f, 0.08728159f, -0.04158730f, 0.00289630f, -0.03727152f, -0.08554786f, 
    -0.23361872f, 0.00356564f, 0.09637341f, 0.28663605f, -0.04384993f, 0.04673925f, 0.04865441f, -0.02131728f, 
    0.04663209f, 0.07763506f, 0.04605025f, -0.00568914f, -0.23516355f, 0.00004598f, 0.08349406f, -0.04896777f, 
    0.08670181f, 0.05973842f, 0.05229637f, 0.02984128f, -0.09631302f, -0.03571432f, 0.09622436f, 0.01975645f, 
    0.14921926f, 0.00470008f, -0.11735189f, 0.06275104f, 0.06984928f, -0.00278551f, -0.03261362f, -0.01022721f, 
    -0.01031954f, -0.04831268f, 0.09338110f, -0.12704334f, 0.37664592f, 0.12953354f, 0.13713977f, 0.19873744f, 
    0.04113317f, -0.04921763f, 0.08133548f, 0.05099520f, 0.03952603f, 0.00661201f, -0.01052207f, 0.01329113f, 
    -0.04832602f, -0.06639604f, -0.08616292f, -0.08080655f, -0.00123582f, 0.04188664f, 0.07287239f, 0.05839244f, 
    -0.01076198f, 0.04922427f, -0.04766882f, -0.01469595f, 0.17809451f, -0.07017470f, 0.05362787f, -0.04585105f, 
    0.02342838f, -0.08533429f, 0.05047006f, -0.04396939f, -0.06544864f, 0.02318328f, -0.08020009f, -0.00202109f, 
    -0.01026812f, 0.22654195f, 0.24075769f, 0.19686288f, 0.08764692f, -0.06747829f, 0.01092417f, 0.08375850f, 
    0.02163005f, 0.02205052f, -0.03501314f, -0.07347760f, -0.14707667f, -0.13147792f, -0.04116997f, -0.07867251f, 
    -0.01487604f, 0.06540729f, -0.00429801f, -0.08989561f, -0.04773973f, 0.04820275f, -0.05954573f, 0.01669091f, 
    -0.15996845f, 0.13071713f, -0.11801585f, -0.32046574f, -0.11026391f, -0.07427355f, 0.04849992f, -0.04762561f, 
    0.01191032f, 0.08371726f, -0.01387835f, -0.01565900f, 0.11172249f, 0.04941709f, -0.05748146f, -0.02819448f, 
    0.06735305f, 0.03946291f, -0.05622880f, -0.09213013f, -0.08151978f, -0.02810377f, 0.05988027f, 0.06545001f, 
    0.00959748f, -0.02224910f, 0.01039011f, 0.02593110f, -0.00029681f, -0.06237467f, -0.00505444f, -0.00211350f, 
    0.03912128f, 0.00068682f, -0.03187091f, -0.05546803f, -0.05478461f, -0.00776555f, 0.02734302f, -0.02242942f, 
    0.00034757f, -0.01610854f, 0.00685592f, 0.02435444f, -0.04397563f, -0.01126298f, -0.00512433f, 0.03160857f, 
    0.02135814f, -0.05027404f, -0.02881645f, 0.01137040f, 0.01775861f, -0.03019417f, 0.01624553f, 0.00022846f, 
    0.01037655f, -0.05509808f, 0.00140551f, 0.02166918f, -0.00583040f, -0.06081323f, -0.03845477f, -0.04058851f, 
    -0.05438583f, 0.01891984f, -0.04691897f, -0.01060040f, -0.00101176f, -0.01779638f, 0.01819931f, -0.00255444f, 
    -0.02959011f, 0.05082680f, -0.03254936f, -0.00719862f, 0.02546544f, -0.01242933f, -0.04359957f, -0.04021182f, 
    0.00835676f, -0.01599855f, 0.00111280f, -0.05288101f, -0.05774196f, -0.02409403f, -0.05376357f, 0.01087114f, 
    -0.03401648f, -0.00796093f, -0.04842917f, -0.02724839f, 0.03177048f, 0.01495460f, 0.01956397f, -0.01922267f, 
    -0.00261886f, -0.05718250f, 0.04092989f, 0.04151277f, 0.02123291f, 0.01380317f, 0.01662107f, 0.02683609f, 
    0.02056313f, -0.03478926f, 0.01404962f, 0.03556963f, -0.04469895f, 0.01835573f, 0.00087368f, -0.04107397f, 
    0.02280983f, 0.00582165f, -0.00162679f, 0.00195206f, -0.04289018f, 0.00864667f, -0.04956143f, -0.03194172f, 
    0.03908843f, -0.01523060f, -0.05505117f, -0.02856268f, -0.02192025f, 0.00998904f, -0.01433920f, 0.00301660f, 
    0.00507283f, -0.02678015f, 0.02935698f, 0.01746064f, -0.00637083f, 0.03497285f, -0.02390912f, 0.00670205f, 
    0.02022807f, -0.02911990f, 0.02745603f, -0.02940809f, -0.04252883f, -0.05455622f, -0.03184427f, -0.04660372f, 
    0.04459888f, 0.00272538f, -0.03990521f, -0.03521930f, 0.02697761f, -0.03071911f, 0.02088673f, 0.02062061f, 
    -0.01496333f, 0.03623618f, -0.04157001f, 0.02712388f, -0.00777856f, -0.03273644f, -0.00837257f, -0.01826141f, 
    -0.05940896f, 0.02190345f, 0.01754942f, 0.00639757f, 0.01082559f, -0.03928223f, 0.03436144f, 0.03355108f, 
    -0.01491425f, 0.04260672f, 0.03334975f, -0.05697943f, -0.01769985f, -0.02724883f, 0.01623060f, -0.01978807f, 
    -0.03073549f, 0.03904100f, 0.01897415f, 0.03175729f, -0.01374376f, -0.01507445f, -0.04861443f, -0.04657392f, 
    -0.05658592f, -0.06422111f, -0.03261001f, -0.03795036f, 0.02797848f, -0.00419937f, -0.01788020f, 0.02120849f, 
    -0.04173866f, 0.01745713f, 0.00298453f, 0.06408766f, -0.03766969f, 0.03880452f, -0.00641005f, -0.01137256f, 
    0.02232539f, -0.03856371f, -0.01305853f, 0.00848038f, 0.05062361f, -0.01568343f, -0.00475287f, -0.00410771f, 
    -0.00396576f, 0.04250104f, 0.03027974f, -0.01354337f, -0.03664591f, 0.00520086f, -0.04344014f, 0.01373362f, 
    -0.05333710f, 0.03913821f, -0.00020848f, 0.02703181f, 0.01936425f, -0.01994698f, -0.04363463f, 0.02477957f, 
    0.00110973f, -0.04845181f, -0.00924118f, 0.02377066f, 0.03829463f, -0.02428247f, -0.04013695f, -0.01740882f, 
    -0.04222273f, -0.07566615f, -0.02480293f, -0.05764788f, 0.02289710f, -0.00130932f, -0.02820832f, -0.01204905f, 
    0.03456149f, -0.04270945f, 0.04689451f, 0.03960184f, -0.02989218f, 0.00530197f, -0.05368056f, 0.00411324f, 
    0.00769937f, -0.03013469f, -0.03919823f, -0.02871916f, 0.00487454f, -0.06753352f, -0.01360260f, -0.01028276f, 
    -0.02239908f, -0.02222620f, -0.04874452f, -0.03735843f, -0.02481236f, -0.03000424f, -0.05058773f, -0.02460973f, 
    -0.03838221f, 0.02237372f, -0.02736558f, -0.02214423f, 0.01547843f, -0.04090401f, -0.02177234f, -0.04094550f, 
    -0.02666597f, 0.01653127f, 0.04679510f, -0.00534321f, -0.01196804f, 0.03627292f, -0.01801505f, 0.03955124f, 
    0.05814099f, 0.02876697f, 0.03707373f, 0.01170124f, 0.03696398f, -0.06414689f, -0.02240103f, -0.04734150f, 
    -0.04057929f, 0.03409526f, -0.03664473f, 0.01189764f, -0.06153316f, -0.00507740f, -0.04539131f, -0.02755822f, 
    -0.01838702f, 0.03785714f, 0.02797494f, -0.00231242f, 0.03346795f, -0.02935355f, -0.00619214f, -0.00121728f, 
    0.02454299f, -0.02004344f, -0.00251270f, -0.03440358f, -0.04061105f, 0.02215140f, -0.04033322f, 0.02467325f, 
    0.04045058f, -0.05740735f, -0.05215142f, -0.03179793f, 0.01997839f, -0.04848694f, -0.03013255f, -0.03669735f, 
    -0.05157591f, -0.02028753f, 0.00170926f, -0.02787977f, 0.00826475f, -0.05728195f, 0.01980978f, -0.01763715f, 
    0.06204576f, -0.04014121f, 0.00636553f, 0.02819838f, -0.00795351f, 0.01839378f, 0.01359215f, 0.00843189f, 
    -0.03067154f, -0.02637444f, 0.00578156f, 0.01109974f, 0.04164831f, -0.04775126f, -0.06094790f, -0.03242943f, 
    -0.04174500f, -0.01316852f, 0.00498066f, -0.05780146f, -0.05278463f, -0.05499277f, 0.02769921f, -0.05504336f, 
    0.00023826f, -0.03834526f, -0.02744392f, -0.01730814f, 0.03877435f, -0.02352113f, -0.06689613f, 0.02210367f, 
    -0.03458186f, -0.02246857f, -0.00147086f, 0.03452194f, 0.00470382f, 0.05942824f, 0.00089574f, -0.00898608f, 
    0.00607807f, 0.04600642f, -0.03692681f, -0.05055410f, -0.01577242f, -0.04995823f, -0.06744173f, 0.02259810f, 
    -0.03482198f, -0.02788317f, -0.01591324f, -0.04394625f, -0.03173787f, 0.00545888f, 0.00965822f, -0.02137596f, 
    0.02997749f, 0.00664083f, -0.00974180f, -0.03359229f, -0.06750523f, 0.04092607f, 0.00295031f, -0.04336761f, 
    0.03958970f, 0.00837958f, -0.00001309f, 0.01030734f, 0.02898156f, -0.01488522f, -0.01471982f, 0.05585942f, 
    0.00251534f, 0.03198317f, -0.03631647f, 0.02015730f, 0.03775283f, 0.01335650f, 0.00573852f, -0.04147133f, 
    0.05495901f, 0.11742852f, 0.03995819f, 0.05146952f, 0.00828095f, 0.04580241f, 0.01362075f, -0.02508057f, 
    0.00902535f, 0.00597370f, -0.09872160f, 0.02693124f, -0.15663947f, 0.04862139f, 0.06301095f, -0.00327383f, 
    -0.02100497f, 0.03892151f, 0.00223842f, 0.03331575f, 0.16783632f, 0.02642545f, 0.07113229f, 0.10392556f, 
    -0.11576298f, 0.23460141f, -0.07724929f, -0.16886780f, -0.05226404f, 0.02351119f, -0.00779328f, -0.05051247f, 
    0.00624413f, -0.01097422f, -0.02097799f, -0.10374250f, -0.16889864f, 0.10983382f, 0.32311386f, -0.06047745f, 
    -0.04884275f, 0.06982410f, 0.09345966f, 0.13011201f, -0.02007107f, -0.00457465f, -0.17111729f, -0.11362595f, 
    -0.09829796f, 0.13406898f, -0.00569654f, -0.02232927f, 0.00749730f, 0.13963540f, -0.10149310f, 0.16414969f, 
    0.08940378f, -0.03255746f, -0.08519974f, -0.10371067f, -0.21792383f, 0.12663347f, 0.07005946f, -0.01151672f, 
    -0.00486176f, 0.00832166f, -0.04930190f, 0.00438559f, 0.06887640f, -0.01088088f, 0.00704674f, 0.03879941f, 
    -0.37126562f, -0.22983500f, -0.14391732f, 0.00186949f, 0.01108939f, -0.04076722f, -0.05617636f, 0.02170007f, 
    -0.04049952f, -0.05658292f, 0.19075629f, -0.07676136f, -0.14813350f, -0.03909698f, -0.00207744f, -0.11893866f, 
    -0.05365641f, -0.05123419f, -0.04404017f, 0.05762199f, 0.05772115f, 0.06192524f, 0.03921927f, 0.02001505f, 
    0.08070175f, -0.10459457f, 0.07892647f, 0.02953156f, 0.01568792f, -0.04294275f, 0.06637151f, -0.08296530f, 
    -0.02881574f, 0.00276676f, -0.04003585f, 0.02428781f, 0.14498064f, 0.17779824f, -0.10373048f, -0.03996854f, 
    0.09382237f, 0.03292215f, 0.10422643f, -0.05078154f, -0.02979209f, -0.06328373f, 0.14998187f, 0.05786184f, 
    -0.13630147f, -0.13434932f, -0.16500293f, 0.13158654f, -0.02650140f, -0.09656793f, 0.06351032f, 0.05134146f, 
    -0.09959351f, 0.04637241f, 0.06831665f, 0.10413484f, 0.09687239f, -0.11350428f, -0.01153683f, 0.20897485f, 
    0.11213730f, 0.07547750f, -0.05987941f, 0.04966081f, -0.01255422f, -0.02848703f, 0.07946783f, -0.05162586f, 
    0.05587625f, 0.17554751f, 0.14299253f, -0.11400611f, 0.12785588f, 0.08973446f, -0.00669726f, 0.06906684f, 
    -0.03084409f, -0.04249049f, 0.00811588f, 0.02474036f, -0.04763833f, 0.05295267f, 0.07370528f, -0.02318598f, 
    0.15891737f, 0.07687125f, -0.03018083f, 0.10767481f, 0.10652351f, -0.06658390f, 0.06124785f, 0.05581739f, 
    -0.18359420f, -0.01683163f, -0.21807332f, -0.09565193f, 0.05552794f, -0.03813821f, -0.03326014f, 0.02114466f, 
    0.03663196f, 0.03119514f, -0.07070130f, -0.10651220f, 0.03746555f, 0.00497323f, 0.09790248f, 0.17071065f, 
    -0.10859288f, -0.07807916f, -0.06988785f, 0.06626033f, -0.04295187f, 0.06282203f, 0.05933686f, 0.09371687f, 
    0.14403901f, -0.04695852f, 0.10039960f, 0.23891942f, -0.04352333f, 0.03128582f, -0.09417998f, 0.09248745f, 
    0.12340818f, -0.00826242f, -0.06337304f, 0.05471762f, -0.20103525f, 0.10367947f, 0.00930311f, -0.14548409f, 
    0.05921330f, 0.04601151f, -0.01646801f, 0.09743084f, 0.07124040f, 0.10605003f, 0.09237012f, 0.12413575f, 
    -0.08904252f, -0.01474012f, 0.08263604f, 0.13186067f, -0.03327559f, 0.06645739f, 0.03701089f, -0.03732692f, 
    0.00932426f, 0.01007916f, 0.03115714f, 0.09569039f, 0.02978106f, 0.07991268f, 0.19713974f, 0.06632999f, 
    -0.04932373f, -0.03998501f, 0.12209896f, 0.10726889f, -0.02642842f, -0.04373799f, -0.01859295f, 0.03310930f, 
    -0.05392667f, 0.01161422f, 0.15244558f, 0.26972845f, -0.02956660f, 0.10323440f, 0.04173741f, 0.14187469f, 
    0.03089752f, 0.04359961f, 0.08795296f, 0.16026613f, 0.01465159f, -0.02699270f, -0.07569785f, -0.15130204f, 
    0.01367592f, 0.00536905f, -0.17782457f, 0.00012830f, 0.08122952f, 0.05684201f, 0.05901713f, 0.13562690f, 
    0.23200954f, 0.04065949f, -0.00778539f, 0.00549094f, 0.03869937f, 0.16055165f, -0.01399825f, 0.03266010f, 
    -0.02953198f, 0.00618481f, 0.00376595f, 0.17461067f, -0.10816397f, 0.04661486f, -0.07807149f, -0.02535473f, 
    0.10620195f, -0.11642503f, 0.09631915f, 0.13082507f, 0.05009779f, 0.12939250f, 0.04218825f, 0.05779384f, 
    -0.06292764f, 0.01620409f, 0.14575484f, -0.24355213f, -0.01837854f, -0.10158415f, 0.01002673f, 0.08689943f, 
    -0.03790826f, 0.06699381f, -0.01280086f, 0.10261635f, -0.24494770f, -0.21384639f, -0.00275939f, -0.09863030f, 
    -0.01482903f, 0.01297673f, -0.04853040f, -0.06295210f, 0.06548069f, -0.03105079f, 0.09650248f, 0.04585127f, 
    0.04558674f, 0.06878448f, 0.18144275f, -0.09718141f, 0.00726549f, 0.04313549f, 0.04842225f, 0.11367516f, 
    0.05528651f, 0.05597652f, -0.01160708f, 0.15234479f, -0.12065874f, 0.01757802f, 0.11071994f, -0.04524336f, 
    -0.00423035f, 0.10699283f, 0.05592529f, 0.04925868f, -0.01375841f, -0.03824318f, -0.00335120f, 0.01722948f, 
    -0.36747760f, -0.24128282f, -0.12418766f, 0.03047243f, 0.02658584f, 0.12550242f, -0.03385892f, -0.01085320f, 
    0.03761011f, 0.11910012f, 0.03743140f, 0.16486426f, -0.12002071f, 0.11508030f, 0.01801709f, -0.14239998f, 
    0.06785909f, -0.04620650f, 0.06582904f, 0.01655849f, 0.06676747f, 0.12453341f, 0.01309996f, 0.03853248f, 
    -0.38570714f, 0.14565258f, 0.09426636f, 0.21918775f, 0.10896683f, 0.04957640f, -0.05655597f, 0.04406011f, 
    -0.05379082f, -0.11719447f, 0.07165921f, 0.00089714f, 0.04190684f, 0.03535890f, 0.20254314f, 0.04089811f, 
    0.03494149f, -0.05619023f, 0.10530332f, -0.04166872f, 0.06657837f, 0.17063834f, 0.01594005f, 0.03505583f, 
    0.12500000f, 0.11654072f, -0.11480086f, 0.15748729f, 0.02387787f, 0.00958876f, -0.14994653f, -0.05520768f, 
    -0.00720223f, -0.16631439f, -0.03174689f, 0.08402962f, 0.13823195f, -0.08562510f, 0.00185408f, 0.00816120f, 
    0.09178466f, 0.04716833f, -0.02636414f, -0.04769941f, 0.12461151f, 0.04770258f, -0.09026754f, -0.09780317f, 
    0.03982498f, -0.00459271f, 0.00903051f, -0.01203650f, 0.13764371f, 0.06080854f, 0.06283857f, -0.09071584f, 
    -0.02533396f, -0.03201624f, -0.02565447f, 0.04616031f, -0.01675493f, 0.10261832f, 0.13619924f, -0.07460789f, 
    0.10722359f, -0.06127546f, 0.04155441f, 0.08327712f, 0.02112105f, -0.04977862f, 0.04611610f, 0.12336108f, 
    -0.30310041f, 0.11683567f, -0.11234076f, 0.11755778f, 0.14384058f, 0.01771030f, 0.07882296f, -0.10784714f, 
    0.00532357f, -0.06828493f, -0.01140702f, -0.01284571f, 0.09283365f, -0.08764280f, 0.06964891f, 0.15253536f, 
    -0.03121635f, -0.00941840f, 0.05746067f, -0.06544366f, -0.01239294f, 0.06291065f, -0.04563131f, 0.08096170f, 
    -0.27854711f, 0.01438653f, -0.07648452f, -0.01928363f, -0.03585978f, 0.03524421f, -0.01094012f, -0.02121167f, 
    0.02186866f, -0.06252213f, 0.05086440f, -0.19449048f, 0.08623629f, -0.05642566f, 0.06779791f, 0.01871039f, 
    0.07128559f, -0.07743214f, -0.11955519f, -0.07696700f, -0.02412552f, 0.06755936f, 0.00779740f, 0.17474470f, 
    0.06623872f, 0.11837204f, 0.04631050f, -0.12022619f, 0.05391251f, 0.03373680f, 0.04364751f, 0.00930331f, 
    0.00919982f, 0.10216986f, 0.22330320f, -0.08753597f, -0.15298274f, 0.12422539f, 0.01584647f, 0.04465372f, 
    0.06896885f, -0.06761739f, 0.01908950f, -0.06361191f, 0.21038754f, -0.04598481f, 0.03193185f, -0.05878656f, 
    -0.12094583f, 0.07370016f, -0.00347742f, 0.04620550f, 0.03329507f, -0.10607432f, 0.07352901f, -0.06406949f, 
    0.07948343f, 0.01605497f, -0.14601685f, -0.08621442f, 0.19510292f, -0.01821431f, 0.07960103f, 0.21768153f, 
    -0.00178518f, 0.04663415f, 0.00950305f, 0.12921205f, 0.07832460f, 0.06906689f, 0.04257152f, 0.02281201f, 
    0.02423614f, -0.10689538f, 0.03385238f, 0.17783663f, 0.07389975f, 0.03252065f, 0.01459846f, -0.04895605f, 
    -0.01146954f, 0.10513172f, -0.00125103f, 0.14939336f, 0.23738962f, 0.06585210f, 0.05055882f, 0.11321934f, 
    0.01595146f, 0.23647158f, 0.08892166f, 0.15008694f, 0.08842774f, 0.18820384f, -0.06640721f, 0.09195093f, 
    -0.03638774f, -0.00803468f, 0.04178788f, -0.15704273f, 0.09774729f, 0.01327742f, 0.05145723f, -0.05455443f, 
    0.11604024f, -0.01770734f, -0.05129116f, 0.09123930f, -0.11269347f, 0.03532121f, 0.03773260f, 0.13342953f, 
    -0.06281900f, -0.07598537f, 0.01843075f, 0.13371453f, 0.02334840f, 0.12692375f, -0.04319790f, 0.01214080f, 
    0.02448752f, 0.12587409f, -0.08628082f, -0.00194057f, 0.06130644f, -0.02970963f, -0.02063276f, 0.03793361f, 
    0.13882577f, 0.00622574f, -0.07130940f, 0.17822863f, -0.00808769f, -0.19025990f, -0.00741198f, 0.05987534f, 
    0.02386429f, 0.03443835f, -0.09242657f, -0.07060716f, 0.03697877f, -0.01870576f, 0.04526664f, 0.12297367f, 
    0.02893235f, 0.23770261f, 0.04001667f, 0.12669449f, 0.01908383f, -0.04613329f, 0.13605425f, 0.01849934f, 
    0.00043759f, 0.04851231f, 0.08313813f, 0.08656662f, 0.03609387f, -0.17300937f, -0.02156670f, -0.02501130f, 
    0.02680710f, 0.08412223f, -0.09749318f, 0.08956639f, 0.02352311f, 0.04362704f, 0.10959179f, 0.13057944f, 
    0.07303992f, 0.13227521f, -0.08690248f, -0.16127913f, -0.02517514f, 0.00466557f, -0.15802370f, 0.04088812f, 
    0.11467251f, -0.08602477f, -0.04336653f, 0.00453740f, -0.25930935f, -0.05419417f, -0.19744334f, 0.08774880f, 
    -0.00873012f, 0.09486163f, 0.06634040f, -0.10096638f, 0.04221579f, -0.07475966f, 0.04368045f, 0.06204126f, 
    0.24646063f, -0.24275859f, 0.01528495f, 0.11890770f, 0.07328299f, 0.09927439f, -0.06753399f, 0.09151480f, 
    -0.00476164f, -0.06905627f, 0.13189402f, -0.09030695f, 0.16726761f, -0.06289959f, -0.14395736f, 0.21159817f, 
    0.06457815f, 0.04222037f, 0.16007479f, -0.16001379f, 0.07173145f, -0.07696990f, -0.16784729f, -0.00621807f, 
    0.00948769f, -0.13091749f, 0.09632266f, -0.05244546f, 0.16659294f, -0.11516837f, -0.03344877f, 0.00438837f, 
    0.09195156f, -0.05745544f, -0.07350178f, 0.17187099f, -0.62377679f, -0.07697321f, -0.05615028f, -0.04216225f, 
    -0.10302589f, -0.00600604f, -0.04949594f, -0.02484751f, 0.02660463f, -0.00246348f, 0.04673102f, 0.03988062f, 
    -0.07762189f, 0.09940951f, 0.19839747f, -0.06262673f, 0.12957969f, -0.03761414f, -0.07530776f, -0.05738568f, 
    0.02758545f, -0.05853040f, -0.11320542f, -0.16134186f, -0.00937331f, -0.05899711f, 0.00212323f, 0.01919601f, 
    0.07837748f, 0.07751379f, -0.05744047f, -0.03180382f, 0.07001844f, 0.03963037f, 0.00621058f, -0.01740923f, 
    0.08136953f, -0.07942731f, -0.25720385f, -0.05412881f, -0.10913066f, -0.01564531f, -0.10367510f, -0.10443971f, 
    -0.03373744f, 0.07354806f, 0.03858298f, -0.12485899f, -0.26192617f, 0.05877566f, 0.15101190f, -0.07148709f, 
    0.05536416f, -0.09092317f, -0.10679837f, -0.00680091f, -0.04935057f, 0.01409135f, 0.16074896f, -0.04536067f, 
    -0.31026319f, 0.20811184f, -0.10202155f, 0.23406415f, 0.14911042f, 0.17485541f, 0.04704745f, 0.08643896f, 
    0.07678487f, -0.00606177f, 0.06036334f, -0.08390449f, -0.16815424f, -0.06978337f, 0.07075108f, -0.07674955f, 
    -0.00620509f, 0.07975761f, -0.15154183f, -0.04226612f, 0.01371487f, -0.08919320f, 0.19101204f, -0.00136249f, 
    0.15065806f, 0.22037315f, 0.12764363f, 0.00089892f, -0.03276537f, -0.09363841f, -0.06989179f, -0.02429779f, 
    -0.00320781f, -0.12820150f, 0.04994771f, -0.01682371f, 0.27563769f, -0.06695017f, -0.08503971f, 0.03976238f, 
    0.17990105f, 0.10718095f, 0.02027776f, -0.06977274f, -0.03909161f, 0.00573442f, -0.05730962f, -0.09671685f, 
    0.29425430f, -0.11553162f, 0.04208091f, 0.16371928f, 0.19412686f, -0.03249919f, 0.09000979f, -0.01059689f, 
    -0.05465749f, -0.05231869f, 0.02078426f, 0.01777823f, -0.16298702f, 0.06593980f, -0.37591356f, 0.10841586f, 
    0.06471606f, 0.00305352f, -0.01033018f, -0.02142690f, -0.01464202f, -0.07603582f, 0.08661863f, 0.07006305f, 
    -0.16440155f, -0.06227576f, -0.07939507f, 0.17378280f, 0.03506885f, 0.03608980f, 0.02748971f, -0.02678467f, 
    -0.08072104f, -0.06674453f, 0.09556385f, 0.05445942f, 0.37807867f, -0.02642853f, -0.12399942f, 0.03126135f, 
    -0.01447754f, -0.08389407f, 0.02322407f, 0.01145783f, -0.11123961f, -0.08683934f, 0.02517924f, -0.03996482f, 
    -0.06526460f, -0.01489649f, 0.09592488f, -0.10218346f, 0.07231818f, -0.08397524f, -0.00621576f, 0.04689391f, 
    -0.01638761f, -0.04371649f, 0.10099376f, -0.20715450f, 0.30612931f, -0.07425740f, -0.01927292f, 0.04756521f, 
    0.05757290f, -0.03355132f, 0.05015333f, -0.03608375f, -0.03991831f, -0.04504270f, -0.00040713f, 0.05708531f, 
    0.00612913f, 0.09360837f, -0.02610960f, -0.08761283f, 0.03264894f, -0.01695255f, -0.05369618f, 0.11057854f, 
    -0.09117714f, 0.15075147f, 0.22568807f, 0.00150437f, -0.18783575f, 0.18963480f, 0.01515916f, 0.05932437f, 
    0.06442348f, 0.00276507f, -0.02571081f, -0.00624984f, 0.10965016f, 0.14153187f, -0.03555471f, -0.03347820f, 
    0.09074958f, 0.20922500f, -0.04794651f, 0.08736631f, 0.01233593f, 0.03371498f, -0.04188207f, 0.00548828f, 
    0.04709510f, 0.03823971f, -0.03097579f, -0.12699488f, 0.04287693f, 0.17321350f, 0.10480933f, -0.11785405f, 
    0.02501049f, -0.04593090f, 0.03317214f, 0.06966572f, -0.03033273f, 0.02355419f, -0.00668659f, 0.06499361f, 
    0.06290133f, -0.19240798f, -0.12324971f, 0.30408499f, 0.10783794f, 0.00758215f, 0.04812797f, -0.02041193f, 
    -0.03622505f, 0.02197256f, -0.05512523f, 0.09314555f, 0.03829618f, 0.02312753f, -0.05944154f, 0.14716041f, 
    0.06680606f, 0.09108818f, 0.02654503f, -0.05766250f, -0.03449971f, 0.08406772f, -0.04565618f, -0.04923172f, 
    0.25411099f, -0.06845479f, 0.05480891f, 0.12504405f, -0.12983355f, -0.04058385f, -0.11983883f, -0.01674564f, 
    0.07514039f, -0.01592202f, -0.03334084f, 0.09436695f, 0.01302475f, 0.04433609f, -0.05736427f, -0.18550745f, 
    -0.02549651f, 0.00755613f, 0.04279628f, -0.08576846f, 0.01634500f, 0.09181628f, 0.03072917f, 0.01157031f, 
    -0.06870578f, 0.08687219f, 0.06189317f, -0.16506061f, -0.03292787f, -0.02248267f, 0.00048354f, -0.01136830f, 
    0.00997432f, -0.04499240f, 0.04264777f, 0.05260399f, 0.18317358f, -0.23122270f, -0.07502840f, 0.11868712f, 
    0.01370229f, 0.05134591f, -0.06792942f, 0.01543808f, -0.05361412f, -0.00485512f, 0.03687084f, 0.07749410f, 
    -0.12811892f, 0.08701533f, -0.01479286f, 0.16669880f, -0.05812161f, -0.09302592f, 0.09659772f, 0.01116246f, 
    0.10669194f, 0.07944332f, 0.09561175f, 0.16880329f, 0.21114653f, -0.05391064f, -0.18951505f, -0.03655868f, 
    0.14895369f, 0.12225437f, 0.04553897f, -0.00728721f, 0.10157332f, 0.02940592f, -0.06559279f, 0.04056703f, 
    0.23292384f, 0.07271370f, 0.02022947f, -0.29168549f, 0.07219645f, 0.02999038f, -0.07250639f, 0.04304717f, 
    0.05531234f, 0.05257963f, -0.00578132f, 0.08115947f, -0.11996696f, -0.00739280f, -0.02967302f, -0.03100122f, 
    -0.03125218f, -0.09450071f, 0.10498100f, 0.04570780f, 0.03854605f, -0.06710941f, -0.12025739f, 0.00021183f, 
    0.27659181f, -0.15699168f, -0.04391329f, 0.10469857f, 0.05214910f, -0.04534215f, -0.04993315f, -0.02701368f, 
    -0.06261429f, -0.01334490f, 0.11324327f, -0.10667370f, -0.01795220f, -0.02027272f, -0.05014080f, 0.13066565f, 
    0.01138569f, 0.08308402f, -0.05164564f, -0.05943108f, 0.00761415f, 0.02766166f, -0.10810638f, -0.09167708f, 
    0.17959180f, -0.01733722f, -0.02579762f, 0.24988776f, 0.10718824f, 0.02978092f, -0.00300157f, -0.01530004f, 
    0.05466960f, -0.07521055f, 0.01022815f, 0.01227587f, -0.34926024f, 0.05578819f, -0.01204554f, -0.14063835f, 
    0.05989202f, -0.04575666f, -0.09857977f, 0.00151564f, 0.11088704f, -0.01406648f, -0.02914690f, 0.13760050f, 
    -0.07290780f, 0.04429734f, -0.01446495f, 0.10980845f, 0.00751116f, -0.06518874f, -0.05518663f, -0.12125893f, 
    0.00187089f, -0.03200286f, -0.02354566f, -0.11005148f, 0.27108079f, -0.08475033f, -0.15495738f, 0.03688053f, 
    0.15390359f, 0.05134051f, -0.01626646f, -0.05712740f, 0.01790385f, -0.08269454f, 0.09924094f, -0.04597023f, 
    0.11522654f, 0.06548622f, -0.08881024f, -0.16404605f, -0.09494363f, 0.00218024f, 0.00395200f, 0.05811698f, 
    -0.01587051f, -0.04684307f, -0.07608937f, -0.10913047f, -0.11561277f, 0.14592756f, 0.11913165f, 0.12199905f, 
    -0.17448363f, -0.07402021f, -0.01269687f, 0.04437010f, -0.02696110f, -0.05723155f, 0.12128375f, -0.04221971f, 
    -0.02721464f, 0.12932919f, -0.23007350f, 0.12467578f, 0.20710565f, 0.14565288f, 0.11822928f, 0.04762686f, 
    -0.02780204f, 0.05335441f, 0.06148201f, -0.04507406f, -0.22249290f, 0.04541688f, 0.00742931f, -0.20714539f, 
    -0.04573782f, 0.00198893f, 0.04054278f, 0.12121452f, 0.02303312f, -0.10719490f, 0.00572822f, 0.02761339f, 
    -0.01673422f, 0.21280216f, 0.03283382f, -0.00268016f, 0.09096824f, -0.06685195f, 0.01718656f, -0.10432602f, 
    0.02297531f, 0.19371779f, 0.04485209f, -0.01123080f, -0.05746440f, 0.07047066f, -0.15437357f, -0.17466329f, 
    -0.03047999f, -0.08012464f, -0.10066313f, -0.12882519f, 0.04273258f, 0.09101862f, 0.10122254f, 0.11427698f, 
    -0.00064540f, -0.02350487f, -0.00187679f, -0.24921533f, 0.06251126f, -0.04745711f, -0.22527270f, -0.03499405f, 
    -0.02370143f, -0.08596123f, -0.00951378f, -0.09016695f, 0.19153616f, 0.17619203f, 0.12712285f, 0.10186659f, 
    0.11461502f, 0.06671541f, 0.01481698f, -0.11050630f, -0.05152511f, 0.04838561f, 0.07794791f, -0.08038685f, 
    0.43384379f, 0.01671388f, 0.20283012f, 0.13124283f, 0.10142125f, -0.03090168f, -0.13289477f, 0.17319858f, 
    -0.07958160f, 0.13229670f, -0.09356483f, 0.08080802f, -0.18793777f, 0.07874785f, -0.06107292f, -0.12675285f, 
    0.09829228f, 0.01948359f, -0.11272902f, 0.01897383f, 0.15169252f, -0.24080142f, 0.05523848f, -0.05496594f, 
    0.33860898f, -0.03284611f, 0.12891729f, -0.10823710f, -0.08462805f, 0.12684001f, 0.13768807f, 0.13426436f, 
    -0.00838491f, -0.15244643f, 0.00640353f, 0.18237278f, -0.20357212f, 0.00726824f, -0.12476560f, -0.01804638f, 
    -0.07979310f, 0.02557049f, -0.00999307f, -0.05917773f, 0.28632167f, -0.00387806f, 0.01432801f, -0.09060768f, 
    0.01211437f, -0.18540739f, -0.03106296f, 0.29405773f, 0.10259379f, -0.10508103f, 0.01995278f, 0.14369524f, 
    0.04031188f, 0.06419008f, -0.14728397f, -0.16177861f, -0.11801761f, 0.30611962f, -0.00602607f, 0.16401708f, 
    0.03988447f, 0.04858973f, 0.09636322f, -0.15657279f, -0.02885580f, -0.03573437f, 0.03588442f, 0.11579835f, 
    0.09480371f, -0.12795323f, 0.19647507f, 0.12076636f, 0.09261178f, -0.01681247f, 0.10253372f, 0.10706990f, 
    -0.20792271f, 0.07632972f, 0.18136868f, 0.08470588f, -0.06229584f, 0.19880377f, -0.11568175f, 0.03884180f, 
    0.04318430f, 0.05469705f, -0.10850655f, -0.02840282f, 0.03152417f, -0.09772850f, 0.04217891f, 0.05438284f, 
    0.03035653f, 0.15860289f, -0.10337460f, -0.20867500f, 0.04562242f, -0.06046861f, -0.11300812f, -0.11276691f, 
    -0.11066125f, -0.15928635f, 0.04072323f, -0.15760921f, 0.10817464f, 0.22676967f, -0.08039179f, -0.03595645f, 
    0.07251500f, -0.16539845f, -0.08683524f, -0.17873475f, 0.00817885f, -0.06397686f, 0.08125330f, 0.02803050f, 
    0.07006381f, -0.00695773f, 0.05389166f, -0.02189690f, -0.01355604f, -0.08361169f, -0.11647274f, -0.18765241f, 
    -0.08992157f, 0.09278811f, 0.03677978f, -0.19229078f, 0.18433900f, -0.15045480f, -0.01576526f, 0.02343430f, 
    0.15658316f, 0.09795783f, -0.18476495f, 0.04299751f, -0.02118701f, -0.05435495f, 0.17695849f, 0.08723462f, 
    -0.02875389f, 0.17549665f, -0.07683313f, 0.09401298f, 0.08251879f, 0.13817742f, -0.17036028f, -0.02776851f, 
    0.02412608f, 0.02991739f, -0.08994079f, -0.11171987f, -0.13975686f, 0.14548673f, -0.07842385f, 0.00309962f, 
    0.13556412f, -0.04443486f, -0.03734707f, -0.04402251f, 0.05279282f, 0.15522875f, 0.01824539f, 0.04770063f, 
    0.12719028f, 0.06950835f, 0.02319448f, -0.08676624f, 0.03758915f, 0.06763634f, -0.07622015f, -0.06254759f, 
    0.05903035f, -0.03109748f, 0.03095084f, -0.01502757f, 0.18777882f, -0.06035063f, -0.01376513f, 0.00791196f, 
    -0.13232554f, -0.05461563f, 0.14651789f, 0.02164628f, -0.07454072f, -0.05419650f, -0.12346312f, -0.20296279f, 
    -0.01904872f, 0.08774134f, -0.13198057f, 0.04011504f, -0.05014497f, 0.06622179f, 0.09737954f, 0.13633688f, 
    0.04250665f, 0.18368338f, 0.09202283f, 0.17189646f, 0.15465641f, -0.00934922f, 0.16064611f, 0.01253902f, 
    0.14968337f, 0.05514031f, 0.12818155f, -0.01583121f, -0.07044797f, 0.20569059f, 0.06650173f, 0.10154244f, 
    -0.00408916f, 0.09022973f, 0.05642962f, -0.03460303f, 0.05358573f, -0.12546510f, -0.05272338f, 0.01496672f, 
    0.18013732f, 0.03958214f, -0.00581844f, 0.06731675f, 0.13837764f, -0.08564983f, 0.11339810f, -0.03738821f, 
    0.01470663f, -0.03211267f, -0.07690427f, 0.07342736f, 0.01191956f, 0.27138939f, 0.22522697f, 0.16511156f, 
    0.03413786f, -0.05545465f, -0.15404278f, -0.13146023f, 0.01466508f, 0.01049930f, -0.17201640f, -0.16118726f, 
    -0.07293725f, -0.04714602f, 0.08278594f, -0.13682325f, 0.61704797f, 0.02778048f, 0.14939412f, 0.10127567f, 
    0.08290674f, 0.07281738f, 0.05414411f, 0.03689638f, -0.08194131f, -0.04206943f, 0.00712014f, -0.03963716f, 
    -0.03267947f, -0.16052809f, -0.00890551f, 0.03965849f, -0.10756723f, -0.10219856f, 0.00993043f, 0.10147540f, 
    -0.02567570f, 0.05206848f, 0.09370314f, 0.10563449f, -0.10534451f, 0.01788494f, -0.12959003f, -0.12922175f, 
    -0.01280630f, -0.10360604f, -0.13345604f, -0.10730603f, 0.11481012f, 0.07990616f, -0.10369057f, 0.11884693f, 
    0.01733277f, 0.07011896f, 0.16131327f, -0.13660109f, -0.03654671f, 0.12561378f, -0.00859678f, 0.05739844f, 
    0.00808348f, -0.09068294f, -0.03751189f, 0.05481548f, 0.50865847f, -0.03079536f, -0.01324238f, 0.00501997f, 
    -0.05225570f, -0.00121438f, 0.16302034f, 0.07158543f, 0.05184736f, 0.00029619f, -0.15483505f, -0.05980142f, 
    0.24760145f, -0.00286324f, -0.16331249f, 0.18541390f, 0.03239241f, -0.09098642f, 0.00063061f, -0.10236967f, 
    -0.05815016f, 0.05890730f, -0.06352608f, 0.17045428f, 0.23701201f, 0.05139231f, -0.03090991f, 0.17082700f, 
    -0.00540252f, -0.08995625f, 0.11032379f, 0.09236878f, 0.01406166f, 0.11454556f, -0.12022559f, 0.04985570f, 
    -0.01831013f, -0.01944848f, -0.04395860f, 0.02792859f, 0.00461986f, 0.02151088f, -0.04212349f, 0.03486362f, 
    -0.01205662f, -0.05025783f, -0.03228991f, 0.02731739f, 0.01383612f, -0.02014399f, -0.01113070f, -0.03851507f, 
    0.03061593f, -0.03516240f, -0.04695782f, -0.01866014f, 0.04518808f, -0.02743894f, -0.01346605f, 0.03104079f, 
    -0.02649345f, 0.02011223f, 0.02105244f, 0.00781113f, -0.03514072f, 0.02292585f, 0.01463559f, 0.00284705f, 
    0.03278819f, -0.02841673f, -0.03109827f, 0.03077650f, -0.00118199f, 0.03053708f, -0.05081128f, 0.03469752f, 
    -0.00084920f, -0.03712707f, 0.03825677f, -0.05079703f, -0.05281918f, -0.00368065f, 0.01755881f, -0.05099460f, 
    -0.03713340f, -0.00728642f, -0.01897452f, 0.02101300f, -0.02520930f, -0.01363002f, 0.01551699f, -0.00365474f, 
    0.00627284f, 0.01115083f, -0.01954768f, 0.01933170f, -0.00491585f, 0.00341245f, -0.04710360f, 0.03179513f, 
    -0.03085041f, 0.02241414f, -0.03094454f, -0.01500224f, 0.03071831f, -0.03873645f, -0.02725923f, -0.01948724f, 
    -0.01518541f, -0.04485332f, -0.02142247f, 0.00523685f, 0.02933794f, 0.03192675f, -0.03237180f, 0.00252181f, 
    -0.00256190f, 0.01904901f, 0.02041071f, -0.01687620f, 0.04058822f, -0.01549480f, -0.04449797f, 0.00336388f, 
    -0.00612211f, -0.00101569f, -0.00219758f, 0.00459191f, 0.01770242f, 0.00753461f, 0.01882842f, -0.03827364f, 
    -0.05508674f, 0.03032641f, 0.03453294f, 0.02789889f, 0.04647936f, -0.03839600f, -0.03592106f, -0.03822854f, 
    0.04232201f, 0.00213948f, 0.02735324f, 0.01565376f, -0.00688137f, 0.04034996f, -0.00909205f, -0.04996128f, 
    0.00136877f, 0.04678536f, -0.05238225f, -0.01870221f, -0.02552145f, -0.00350567f, -0.03960831f, 0.01676035f, 
    0.03939892f, -0.01347977f, -0.04924053f, -0.02517308f, 0.00526436f, -0.00554810f, -0.01607091f, 0.02607184f, 
    0.02578412f, -0.01914280f, -0.01057695f, -0.02307002f, -0.03524894f, 0.03137524f, 0.02954821f, 0.00639169f, 
    -0.04213702f, 0.01281349f, -0.04598863f, -0.04017819f, -0.05001310f, 0.01840138f, -0.03510869f, 0.00013718f, 
    0.00851407f, -0.05152615f, -0.04443697f, -0.02730230f, -0.00357449f, 0.03844503f, 0.03139843f, 0.01379669f, 
    -0.04365723f, 0.01104810f, -0.00085142f, 0.00302052f, 0.02718867f, -0.02718774f, -0.03785353f, -0.01442081f, 
    -0.04125167f, 0.01277558f, 0.01424416f, 0.04622025f, -0.02941637f, 0.03863418f, -0.03004749f, 0.02021283f, 
    -0.00470589f, -0.03324507f, 0.01521517f, 0.02324472f, -0.02170017f, -0.03533107f, -0.00664199f, -0.05100830f, 
    -0.01721426f, -0.04247232f, 0.02385668f, 0.02860457f, -0.02778988f, 0.03153710f, 0.04270278f, 0.02973201f, 
    0.01739353f, -0.04912017f, -0.03800917f, -0.00790679f, -0.01804194f, 0.04603168f, 0.00183820f, -0.04705913f, 
    0.03949744f, -0.02603919f, 0.03303197f, 0.03287301f, -0.00299725f, -0.05175003f, -0.03652737f, 0.04384169f, 
    0.00629823f, 0.01313885f, 0.02693467f, -0.01879334f, 0.02450177f, 0.03129206f, -0.04097378f, -0.05113260f, 
    -0.02807392f, 0.03731626f, -0.03513964f, -0.00598889f, 0.00594431f, -0.05232587f, -0.02681527f, -0.00336064f, 
    0.00792908f, -0.03665739f, 0.01596201f, -0.00914427f, -0.04670171f, -0.01616561f, 0.01094232f, -0.04723657f, 
    0.02277075f, 0.03941109f, 0.00531899f, -0.05261386f, -0.01292496f, 0.04191808f, 0.03844409f, 0.02116727f, 
    -0.01034171f, 0.04920134f, 0.04233653f, -0.00102371f, -0.01026360f, -0.01548526f, 0.03695257f, -0.04069236f, 
    -0.04499950f, -0.00738443f, -0.04496368f, 0.02074066f, -0.01106743f, -0.04006620f, 0.04050963f, -0.04191842f, 
    -0.03193885f, -0.03372622f, -0.02219636f, -0.01343892f, 0.02764418f, -0.01398173f, -0.05416705f, 0.01718139f, 
    0.01594117f, -0.01040676f, -0.03156656f, -0.05125461f, 0.02284645f, 0.02162223f, -0.00753809f, 0.04290283f, 
    0.02281203f, 0.02426846f, -0.04657397f, 0.00019892f, -0.05014523f, 0.00466568f, 0.04587113f, -0.01164022f, 
    0.00014680f, 0.01926436f, 0.04424429f, -0.03929713f, 0.02988997f, -0.04264165f, -0.01453612f, -0.01557010f, 
    -0.00716542f, -0.01516678f, -0.02116402f, 0.02032087f, -0.03290085f, 0.01830676f, 0.04634308f, 0.03714501f, 
    0.02140224f, -0.02005682f, -0.01099097f, -0.04560241f, 0.03055572f, -0.02133713f, -0.04263527f, -0.02796046f, 
    0.03629304f, 0.00404390f, -0.00011381f, -0.03793399f, 0.02265690f, -0.04859197f, -0.00050683f, 0.04674368f, 
    -0.00442163f, -0.01788838f, 0.00597631f, -0.01377761f, 0.03815314f, 0.02058448f, -0.02957376f, -0.04021129f, 
    -0.00587948f, -0.03941964f, -0.00531197f, -0.04337369f, -0.02012229f, -0.04985287f, -0.04177378f, -0.00906790f, 
    -0.01096952f, -0.01720519f, -0.05387985f, 0.04107160f, 0.03721945f, 0.01927889f, -0.04867180f, -0.05178937f, 
    -0.02278887f, -0.01946235f, -0.00893312f, -0.04130666f, -0.03998672f, 0.02923177f, -0.04033922f, -0.00877245f, 
    0.01570275f, -0.04006806f, -0.01078625f, -0.00048826f, 0.00162281f, 0.01154403f, -0.01854080f, -0.03754454f, 
    0.02568864f, 0.02094164f, -0.02657517f, 0.03933011f, -0.05605616f, -0.04031331f, 0.02594980f, -0.01903354f, 
    0.04010278f, 0.01957273f, 0.04471450f, -0.04459017f, -0.02783024f, 0.04919966f, -0.03113485f, -0.04116833f, 
    0.00435328f, 0.04060645f, -0.01877182f, -0.04735523f, 0.01042190f, -0.00680539f, 0.01170113f, -0.04437470f, 
    -0.00486468f, -0.03447921f, 0.03935735f, -0.02770442f, -0.05480953f, 0.01308676f, -0.05335535f, 0.04847793f, 
    -0.02268974f, 0.03325181f, 0.02956003f, -0.01431450f, 0.02032740f, -0.05363102f, -0.00827144f, -0.05177346f, 
    0.15852079f, -0.16091394f, -0.13099773f, 0.11171288f, 0.02895362f, -0.10924550f, -0.12823501f, -0.00418991f, 
    0.09064518f, -0.23446447f, -0.00313690f, 0.09838609f, 0.28119883f, -0.00543257f, 0.00085565f, 0.00865835f, 
    0.03493445f, 0.00142719f, 0.02781746f, 0.12081158f, -0.00547987f, -0.02106802f, -0.03391000f, 0.02232553f, 
    0.32070473f, -0.04566025f, -0.00141507f, 0.00979946f, 0.09945377f, 0.02675656f, 0.01229867f, -0.04001500f, 
    0.06746960f, -0.04090325f, 0.05399764f, -0.03438473f, 0.20119882f, -0.17743385f, -0.05249964f, -0.00752741f, 
    0.02182529f, -0.00661252f, -0.11409643f, -0.00665606f, 0.06735403f, -0.04675393f, -0.08890991f, 0.04433655f, 
    -0.17704175f, 0.08401970f, -0.06663773f, -0.08655111f, 0.03886268f, 0.09751306f, -0.00383859f, -0.12958919f, 
    -0.08733840f, -0.04601410f, -0.04067795f, -0.06718597f, 0.32726428f, -0.00309401f, 0.06395859f, 0.12265564f, 
    0.01105529f, -0.01608446f, 0.00119939f, -0.05811336f, -0.04168953f, 0.05365263f, -0.11726267f, 0.02527033f, 
    -0.22939041f, -0.04707848f, -0.03039458f, 0.11410151f, 0.06986597f, -0.00555515f, 0.01638716f, 0.03936022f, 
    -0.09327665f, 0.01335456f, -0.05584773f, -0.13935058f, 0.24159893f, 0.00501748f, -0.02010971f, 0.00614724f, 
    0.09240717f, -0.03051897f, -0.05339361f, -0.05266838f, -0.13155797f, 0.07237354f, -0.08698358f, 0.07719199f, 
    -0.05441229f, 0.23729725f, -0.14571954f, 0.02187769f, -0.00839492f, 0.04779581f, 0.03761512f, 0.03858328f, 
    -0.02839787f, -0.08473052f, 0.02974842f, 0.09754872f, 0.00585254f, 0.11991846f, -0.02775487f, 0.09226041f, 
    -0.03571557f, -0.10281675f, -0.05545744f, -0.00934234f, 0.21419026f, 0.01235685f, -0.05813712f, 0.03943146f, 
    -0.13655740f, 0.07696738f, -0.01288422f, -0.06492468f, 0.04569527f, -0.04350570f, 0.05341952f, -0.04631457f, 
    0.09232042f, -0.09809397f, -0.04611628f, -0.04990503f, 0.00646567f, -0.23351282f, 0.02775646f, 0.07325059f, 
    0.06518114f, -0.08646993f, 0.08233967f, -0.01474039f, 0.10074646f, 0.05742893f, -0.01609750f, 0.07265462f, 
    0.19603805f, -0.09184093f, 0.10739712f, 0.29955816f, 0.08626601f, -0.08392397f, -0.00444984f, -0.07061010f, 
    0.05648400f, 0.09261944f, 0.02795518f, 0.04636368f, 0.07374746f, -0.20926063f, 0.03766245f, -0.00462692f, 
    -0.06625045f, 0.08819184f, 0.00544642f, 0.14038271f, -0.03187023f, 0.06490678f, -0.08966996f, 0.13881610f, 
    -0.11471508f, 0.26398617f, 0.12835674f, 0.06183885f, 0.10064738f, 0.09332711f, 0.02361388f, 0.05593237f, 
    0.05708148f, -0.05862265f, -0.01473560f, 0.10051062f, 0.28224283f, 0.02395200f, -0.09376828f, 0.20868126f, 
    -0.07624114f, -0.09066857f, 0.01762020f, -0.00425008f, -0.06991068f, 0.10095826f, 0.08998857f, -0.08336821f, 
    -0.01217942f, -0.02073758f, -0.10821993f, 0.10668115f, -0.05222661f, -0.18391497f, 0.03703700f, 0.01787284f, 
    -0.03580379f, 0.08001617f, -0.03871255f, 0.18020256f, 0.28112289f, -0.03692595f, 0.10994495f, -0.03156991f, 
    0.01515539f, -0.02980518f, -0.03061149f, -0.00258646f, 0.02898467f, -0.05377815f, 0.00821746f, 0.01465075f, 
    0.07343842f, -0.05489461f, 0.01093285f, 0.13239883f, 0.00639239f, -0.10780609f, 0.09801462f, -0.07466962f, 
    0.00806668f, 0.09090346f, 0.01244599f, -0.01455676f, 0.01745837f, 0.03863927f, -0.08893300f, 0.05307319f, 
    -0.00036957f, -0.01663052f, -0.17412065f, -0.00865070f, 0.03111516f, -0.01536685f, 0.09119070f, 0.10284843f, 
    0.11774624f, -0.03185388f, 0.05144123f, -0.18449566f, 0.02251972f, 0.01192227f, -0.04839224f, -0.11214484f, 
    0.11592194f, 0.00192333f, 0.06106989f, -0.06149003f, 0.03355292f, -0.09645589f, -0.06379721f, -0.03889475f, 
    -0.07965738f, 0.05899244f, -0.08815238f, -0.02227175f, 0.05222778f, -0.08390477f, -0.05558459f, 0.02490466f, 
    -0.09322967f, -0.01878469f, 0.00592060f, 0.34950849f, -0.10993395f, 0.07790849f, 0.04002440f, 0.06742218f, 
    -0.08983187f, 0.00189511f, 0.08079258f, -0.02011989f, -0.06270652f, -0.05440892f, -0.10846289f, 0.01087415f, 
    0.01457752f, 0.18233484f, 0.20180598f, -0.08198153f, -0.04598492f, -0.13523082f, -0.10153516f, -0.07426047f, 
    0.12749881f, 0.10750165f, 0.06450143f, 0.08750658f, 0.04825318f, -0.04571294f, 0.04636337f, 0.07673986f, 
    0.06075457f, 0.04689592f, -0.01358274f, 0.05991286f, -0.31312871f, -0.03022625f, -0.09609186f, 0.06903441f, 
    -0.00822434f, -0.03906160f, 0.06168526f, 0.01535288f, 0.03368649f, 0.09154215f, -0.02743916f, -0.00409209f, 
    0.00681533f, 0.12006620f, 0.03299769f, -0.19992234f, -0.00160107f, 0.11471694f, -0.07467909f, 0.05575275f, 
    -0.02860950f, -0.00459620f, -0.09817974f, -0.07521575f, 0.14373548f, -0.10485763f, 0.15716991f, -0.09031612f, 
    0.14011481f, 0.10572641f, 0.00823807f, -0.00764694f, -0.00081994f, -0.03511907f, 0.02702283f, -0.08899085f, 
    -0.09518683f, 0.01045474f, -0.04285109f, 0.27683350f, 0.05028651f, 0.00096833f, -0.04839493f, -0.02381739f, 
    0.03707974f, 0.01125580f, 0.00472241f, -0.10088939f, -0.42442787f, 0.11409531f, 0.00438982f, -0.10383093f, 
    0.02942834f, -0.01678669f, -0.12183180f, -0.04955050f, -0.06922786f, 0.03360641f, 0.15190175f, 0.01131138f, 
    -0.29466823f, 0.09108938f, -0.04903065f, -0.21334329f, 0.08896264f, 0.00682607f, 0.03248933f, -0.00410255f, 
    0.06848065f, -0.01356854f, 0.07042600f, -0.07272062f, -0.16378270f, 0.02532355f, 0.04771577f, 0.00649675f, 
    -0.03130438f, 0.11576334f, -0.07347500f, -0.05224908f, 0.02718058f, -0.07216918f, 0.15887243f, 0.00039487f, 
    0.15429507f, 0.17169774f, 0.01714961f, 0.00054981f, -0.09485645f, -0.13204233f, -0.12386419f, -0.01206340f, 
    0.07972296f, -0.05936213f, 0.02189498f, 0.00219318f, 0.37350464f, 0.04709633f, -0.07609179f, 0.07186420f, 
    0.03819063f, 0.04694405f, 0.06197560f, -0.00123389f, -0.09112061f, 0.01694373f, 0.13315198f, 0.10237671f, 
    0.40760559f, 0.04817836f, 0.29258072f, -0.10509169f, 0.07399520f, -0.03592296f, -0.05021967f, 0.00392416f, 
    0.01427420f, -0.01372000f, -0.00527063f, -0.05482510f, 0.03032046f, -0.14459561f, -0.09075288f, 0.00659938f, 
    0.01837069f, 0.07392068f, -0.08660915f, -0.04698470f, 0.05806915f, 0.08808049f, 0.00357454f, -0.03831201f, 
    -0.07719260f, -0.02235575f, -0.20815389f, 0.00318127f, 0.05945982f, 0.05381567f, -0.13072075f, -0.14572604f, 
    -0.04206827f, -0.04627616f, -0.04932688f, 0.01669081f, 0.33393720f, 0.03669473f, 0.02133859f, 0.13967517f, 
    0.01848928f, 0.05454530f, -0.10332170f, -0.01907527f, -0.09560254f, 0.01090615f, 0.05270184f, 0.09715090f, 
    0.00313433f, -0.30808786f, 0.16688634f, 0.19773673f, 0.08060279f, 0.03219554f, 0.02656767f, 0.06602626f, 
    -0.08468580f, 0.06122443f, -0.04921266f, -0.00234869f, 0.15522322f, -0.17237806f, -0.12930317f, 0.17178300f, 
    0.07851931f, 0.07117222f, 0.09389351f, 0.15500538f, 0.14862385f, -0.02027154f, 0.04365945f, -0.10807056f, 
    0.02442571f, 0.11634681f, 0.02027147f, -0.00196231f, 0.09757766f, -0.03992957f, 0.06475772f, 0.18637049f, 
    -0.03522394f, -0.01663890f, -0.03840079f, -0.06617776f, -0.12923266f, 0.27675000f, -0.19468810f, 0.15694034f, 
    -0.02726403f, -0.05524504f, 0.05461119f, -0.09869307f, 0.11498702f, 0.04463508f, -0.09017910f, 0.07820841f, 
    0.17743374f, -0.19995204f, -0.04607212f, 0.01330705f, 0.07077837f, 0.06653009f, 0.05015586f, 0.10211959f, 
    0.05600196f, 0.06533799f, 0.15939850f, -0.02346099f, 0.14417057f, -0.09088824f, -0.05975118f, -0.08640144f, 
    0.09433233f, 0.07173526f, -0.04563689f, -0.03266702f, -0.05874474f, -0.01580126f, 0.11528475f, 0.05913462f, 
    0.29840550f, -0.02625941f, -0.05801329f, 0.02673775f, -0.04691863f, -0.05910559f, 0.04977321f, 0.06402087f, 
    0.01252647f, -0.01191346f, -0.07105935f, -0.04107400f, -0.11079951f, 0.07355074f, -0.17245151f, -0.01912597f, 
    0.03793935f, -0.05192818f, -0.02126263f, 0.02972350f, -0.03955730f, 0.01645423f, -0.11198782f, 0.04327447f, 
    0.01289531f, 0.25364456f, 0.03872173f, 0.07013399f, 0.07457939f, 0.07927489f, 0.02557245f, 0.07340102f, 
    0.04355593f, 0.04175842f, 0.05680100f, -0.06338236f, 0.15692039f, -0.14162804f, -0.19692419f, -0.16958259f, 
    -0.09161206f, 0.04981864f, 0.01590028f, -0.00738677f, -0.04903855f, -0.02365921f, 0.14359570f, -0.07582925f, 
    0.00431022f, -0.01316821f, -0.12078629f, 0.03301499f, -0.02580172f, 0.03109393f, 0.04899603f, -0.00157730f, 
    0.03211580f, 0.03749219f, -0.10918771f, 0.07498222f, 0.36717126f, 0.14607692f, 0.00984359f, 0.00002846f, 
    0.07512928f, -0.00068106f, 0.02766244f, 0.01085175f, 0.04834658f, -0.00262139f, 0.01420962f, -0.02907644f, 
    -0.03450095f, -0.22793096f, -0.09355952f, -0.12421652f, -0.07880705f, -0.03408249f, 0.04686181f, 0.05099340f, 
    0.12819028f, 0.02099185f, 0.03052910f, -0.01918124f, 0.23698270f, -0.01147558f, -0.19981243f, 0.01766649f, 
    0.00089503f, 0.05276483f, -0.03701848f, -0.01217963f, 0.01169980f, -0.03155363f, -0.04202917f, -0.04203695f, 
    -0.00230690f, 0.11511453f, 0.12216947f, -0.15883233f, 0.08999781f, 0.04355074f, 0.05087725f, -0.00611158f, 
    0.09834320f, 0.09475582f, 0.24323022f, 0.05033046f, -0.10599396f, -0.07370038f, -0.03540646f, -0.01883022f, 
    -0.01862559f, 0.06051937f, 0.05441420f, -0.06788918f, 0.05561428f, 0.00818871f, -0.04644141f, 0.06443813f, 
    -0.26442182f, 0.04316345f, -0.23093815f, -0.03810686f, -0.11397343f, -0.02528541f, -0.05768295f, 0.00199822f, 
    0.09352192f, -0.00492855f, 0.09898658f, 0.03476895f, -0.07939578f, -0.11065356f, -0.12468396f, 0.00717771f, 
    -0.00527472f, 0.11790381f, 0.06735671f, -0.08524317f, -0.04958952f, 0.06723619f, 0.09783271f, 0.03615863f, 
    0.19496955f, 0.03808930f, -0.09750172f, 0.17935318f, -0.09569541f, 0.02183715f, -0.01381465f, 0.04314108f, 
    0.05877149f, -0.04600494f, 0.00864709f, 0.04668847f, -0.09158093f, -0.20223992f, 0.00687502f, 0.08083218f, 
    0.04684009f, 0.03111450f, -0.03603495f, 0.00530952f, -0.01640554f, 0.06887822f, -0.06896891f, -0.08698073f, 
    0.13714284f, 0.01667123f, -0.00741915f, -0.08360989f, -0.02521387f, 0.00906723f, 0.03687098f, 0.11038186f, 
    0.00271696f, 0.03319224f, 0.02663759f, 0.13182898f, 0.28546172f, 0.02955784f, -0.11425310f, 0.15351115f, 
    0.11491646f, 0.05311934f, 0.02428687f, 0.02449351f, 0.04935065f, 0.04468620f, -0.00295580f, 0.04269578f, 
    -0.02243453f, -0.05064943f, 0.19481325f, 0.04641951f, 0.06680512f, 0.05755632f, 0.02648641f, 0.03686806f, 
    0.01303498f, 0.01517338f, 0.01818016f, -0.12829903f, -0.37647992f, 0.19078925f, 0.01318462f, 0.06021042f, 
    -0.00869174f, -0.04272418f, -0.00430289f, 0.06138196f, 0.07347763f, -0.09688406f, 0.05592516f, -0.02286487f, 
    -0.22139771f, 0.01315561f, -0.34491378f, 0.03432685f, 0.11789852f, -0.04881200f, 0.10246304f, 0.01194844f, 
    -0.03211641f, 0.04098209f, 0.09385365f, -0.01761929f, -0.11515232f, -0.09388214f, 0.05602577f, -0.13944668f, 
    -0.17318778f, -0.02234565f, 0.08526494f, 0.15046352f, 0.06722938f, -0.09472843f, -0.04129796f, -0.04249479f, 
    -0.00722496f, -0.05886200f, 0.02702775f, -0.04320414f, -0.02425510f, -0.03136667f, 0.01879127f, 0.03211651f, 
    0.00425656f, 0.02071665f, -0.01469997f, -0.04430130f, 0.00337490f, 0.01380854f, 0.01222575f, 0.00878708f, 
    -0.02812091f, -0.01012274f, -0.00963143f, -0.01109306f, -0.03962904f, -0.00350322f, 0.03850920f, -0.03533299f, 
    0.00874075f, 0.01512548f, 0.03999237f, 0.04107415f, -0.02357104f, -0.01261404f, 0.01939001f, 0.01672316f, 
    -0.02916053f, -0.04871124f, 0.03647939f, 0.02439875f, -0.01826190f, -0.01966949f, 0.00371065f, 0.00560530f, 
    0.01441928f, 0.01765520f, 0.01754801f, 0.00559640f, 0.03055424f, -0.04919337f, 0.03759455f, 0.00208656f, 
    -0.00907026f, -0.03482622f, 0.02679567f, -0.00596076f, -0.02218302f, -0.05315968f, 0.00934855f, 0.01706827f, 
    -0.04412486f, -0.02215509f, 0.01475805f, -0.05369213f, 0.03352698f, -0.00903350f, 0.03622290f, -0.01249893f, 
    -0.02462247f, -0.05979206f, -0.03901631f, -0.04564847f, -0.02534277f, 0.05478183f, -0.02665671f, 0.02549573f, 
    -0.04409715f, 0.00907133f, 0.02187539f, 0.01145901f, 0.04106170f, -0.02274897f, 0.01017873f, -0.05749878f, 
    -0.01228826f, 0.04262843f, -0.05698960f, -0.00179420f, -0.03473730f, 0.04436957f, -0.04681078f, -0.03545333f, 
    0.00381045f, 0.04367227f, 0.03880759f, -0.01948244f, -0.04494957f, 0.00244429f, 0.03047734f, -0.03714139f, 
    -0.01175161f, 0.03697054f, -0.00736046f, 0.01250570f, -0.02135112f, -0.01952067f, -0.03783971f, -0.03300471f, 
    -0.04622402f, -0.05578943f, 0.01636724f, -0.01158184f, -0.01046725f, 0.04026050f, -0.03375813f, -0.01166446f, 
    0.02146150f, -0.01180089f, -0.01741769f, 0.01271635f, 0.00514573f, -0.02861251f, 0.01564723f, -0.05210673f, 
    -0.02129837f, 0.02174133f, -0.01684820f, 0.02566259f, -0.03643482f, 0.02216496f, -0.03151033f, 0.03616281f, 
    -0.03797015f, -0.03751826f, 0.00136062f, -0.03230962f, -0.00322735f, -0.04761923f, 0.02088851f, 0.01575554f, 
    0.03882625f, 0.01753969f, 0.00461272f, -0.01575614f, -0.00325793f, -0.03745610f, 0.02809595f, -0.00259513f, 
    0.00425366f, 0.03047595f, -0.00440735f, 0.04024473f, -0.02258295f, -0.03898912f, 0.02114243f, -0.00593806f, 
    0.00156104f, -0.00050845f, 0.01038543f, 0.03499660f, 0.00307604f, 0.03546152f, -0.03020751f, -0.01043947f, 
    -0.00445484f, 0.02598716f, -0.03154374f, 0.00744864f, -0.00823461f, -0.03574740f, 0.02930740f, -0.01397042f, 
    -0.00977625f, -0.04083698f, 0.01309799f, -0.05856866f, 0.00727299f, 0.04052590f, 0.02883159f, -0.05613593f, 
    -0.00568304f, -0.01312768f, -0.04096907f, 0.03593151f, -0.02718872f, -0.01903493f, -0.03101126f, -0.00115381f, 
    -0.01409588f, -0.04926223f, 0.00723758f, 0.00416898f, -0.04518002f, 0.03437855f, 0.00651228f, 0.04012587f, 
    0.03950126f, 0.02899875f, -0.05616579f, -0.02465926f, 0.01561004f, -0.05125026f, 0.00241012f, -0.02491591f, 
    -0.02731941f, 0.03301491f, -0.03695873f, 0.02888141f, 0.01372994f, -0.02022561f, -0.01592523f, -0.04509755f, 
    0.01108522f, 0.02035662f, -0.03671309f, -0.03577009f, 0.00793027f, -0.03078148f, -0.02424161f, -0.04938123f, 
    -0.05484723f, -0.01001524f, -0.03231335f, 0.01065974f, -0.05145553f, 0.01051060f, 0.03843872f, -0.04192932f, 
    0.03547397f, -0.05196231f, -0.03789164f, 0.03960854f, -0.04551773f, -0.04455933f, -0.05285601f, 0.03228059f, 
    0.03221342f, -0.02504642f, 0.01607454f, 0.02576695f, 0.03295866f, 0.03772552f, -0.05113441f, 0.04208989f, 
    -0.02115964f, -0.00464153f, -0.00835352f, -0.00313497f, -0.00333723f, 0.01500660f, -0.02829456f, -0.04724304f, 
    0.03275026f, 0.02213370f, -0.03274295f, 0.03230952f, 0.00163641f, 0.03643500f, 0.01130352f, -0.02621616f, 
    0.02273247f, -0.06005105f, -0.03944414f, 0.02605167f, 0.00844632f, -0.04218782f, 0.02444000f, -0.01689312f, 
    -0.04688328f, 0.01021639f, -0.04870296f, -0.00939016f, -0.02530463f, 0.03040590f, 0.03022848f, -0.05431619f, 
    -0.00349528f, 0.01976016f, 0.00287457f, 0.03806669f, 0.01623548f, -0.00874528f, 0.01598930f, 0.01257598f, 
    0.01987427f, 0.00428464f, -0.05019632f, 0.04569611f, 0.03148008f, -0.00718049f, 0.03091605f, -0.03727465f, 
    -0.03246127f, 0.01233123f, 0.03693295f, 0.03331217f, 0.01980231f, 0.04337453f, 0.03961685f, 0.04014861f, 
    -0.04099699f, 0.03127427f, -0.02596094f, -0.05487241f, 0.03837835f, -0.05285514f, 0.01034994f, -0.05939241f, 
    -0.04792230f, 0.00044250f, -0.01653356f, -0.00279458f, 0.01300763f, -0.04958778f, -0.04080766f, -0.01797234f, 
    -0.01571271f, -0.05244433f, -0.04511912f, 0.04355103f, -0.01154195f, -0.00541936f, -0.00839738f, 0.01936124f, 
    -0.04585686f, -0.03928156f, -0.03317732f, -0.01100875f, 0.02385729f, -0.04782819f, -0.03781071f, -0.03741563f, 
    0.03600676f, -0.03146233f, 0.00260490f, -0.03011078f, -0.05471947f, 0.01359109f, -0.02887680f, 0.04054629f, 
    -0.03177696f, -0.05164962f, -0.03854749f, -0.05544567f, -0.00850600f, -0.03095680f, -0.00546230f, -0.01613196f, 
    0.01035891f, 0.00075808f, 0.01910315f, 0.01419527f, -0.03374192f, -0.04257314f, -0.00264605f, -0.00338320f, 
    -0.00575463f, 0.04000109f, -0.03000060f, -0.02046616f, -0.00127256f, -0.00602612f, -0.02680345f, 0.01228266f, 
    0.00952766f, -0.02045376f, -0.03887027f, 0.02461945f, -0.00243022f, -0.05932102f, -0.03684509f, 0.03901956f, 
    -0.01695214f, -0.01480942f, -0.04085793f, 0.02043610f, -0.02084441f, 0.02801022f, -0.00861169f, -0.00495001f, 
    -0.00277579f, 0.03580637f, -0.05181287f, -0.03803541f, -0.05222557f, -0.00392288f, -0.05041385f, -0.05305801f, 
    0.00038757f, 0.03760406f, 0.08529451f, 0.11312727f, 0.17187926f, -0.02994638f, -0.06429775f, -0.02568050f, 
    0.12782340f, -0.02369636f, 0.11604895f, 0.00578649f, -0.02570831f, 0.05123210f, 0.22576609f, -0.07221028f, 
    0.00251157f, -0.02380537f, -0.00163279f, 0.06067945f, 0.03013441f, 0.03960881f, 0.06604119f, -0.04432837f, 
    0.02086335f, 0.01521062f, 0.09976506f, -0.23720635f, 0.11271055f, -0.01309296f, -0.01885826f, 0.04856920f, 
    -0.00465548f, -0.00567255f, -0.00382098f, 0.16205212f, 0.29100358f, 0.41088086f, 0.22051138f, -0.05624828f, 
    0.02412216f, 0.02535229f, 0.07082780f, 0.07040186f, 0.01341304f, 0.05560026f, 0.09948384f, 0.09796106f, 
    0.07610051f, 0.19367081f, -0.05901242f, 0.15863524f, 0.15213987f, 0.00020069f, 0.15587771f, -0.05226341f, 
    0.08666409f, 0.05761660f, 0.20033540f, 0.03132599f, -0.13805641f, -0.04058821f, 0.11331469f, 0.10161026f, 
    -0.02812684f, 0.09902635f, 0.01745900f, -0.10521942f, 0.04614390f, 0.08289059f, -0.01347419f, 0.06718323f, 
    0.21138270f, 0.03579183f, -0.17405516f, -0.18117988f, -0.07902920f, 0.08036304f, 0.02025172f, -0.04946995f, 
    0.17487715f, -0.03021139f, -0.09762109f, 0.02483907f, -0.11205227f, 0.14157258f, 0.15359771f, -0.02772942f, 
    0.09718463f, -0.02416462f, -0.09546415f, -0.10411969f, -0.03602367f, -0.06207998f, -0.01659365f, 0.08863240f, 
    -0.02054531f, -0.11378958f, 0.03312917f, -0.24331589f, 0.05891681f, 0.10311747f, 0.01882849f, 0.03658563f, 
    0.13231254f, -0.01728727f, 0.10550717f, 0.00229416f, -0.28043470f, -0.04809425f, 0.04596463f, -0.02751234f, 
    0.04034203f, -0.07230812f, 0.02392164f, 0.07027346f, -0.00476507f, 0.00918730f, 0.05480218f, 0.09157573f, 
    0.07248440f, -0.02695241f, 0.07573427f, -0.12796631f, 0.11094166f, 0.00595421f, -0.05161446f, -0.03110260f, 
    0.04589705f, -0.05089752f, -0.07198719f, -0.08236938f, 0.05169151f, -0.19600397f, 0.04206718f, 0.20639965f, 
    -0.02962865f, 0.12068304f, -0.05420984f, 0.00229720f, 0.17615901f, 0.11151078f, -0.00132827f, 0.08865244f, 
    0.11836626f, 0.12229034f, -0.07748817f, -0.32435265f, -0.01186368f, -0.12090039f, 0.02278184f, 0.02367780f, 
    -0.07354669f, 0.15711363f, 0.07487742f, 0.08384548f, 0.44141343f, 0.06068065f, 0.05460601f, 0.06483735f, 
    -0.01361580f, 0.00509374f, 0.17552878f, 0.07257295f, 0.02951398f, 0.05126147f, 0.08021273f, 0.04005197f, 
    -0.14618580f, -0.01277063f, 0.00192867f, -0.08739866f, 0.01676941f, 0.06632755f, 0.04132708f, -0.07597832f, 
    0.05642113f, 0.03590779f, 0.05238460f, 0.10918143f, -0.27240807f, -0.10656995f, -0.09350752f, 0.01321674f, 
    0.00959966f, 0.14214708f, 0.12725009f, 0.05805806f, 0.01844181f, 0.04844509f, -0.05915245f, 0.05352713f, 
    0.13166480f, -0.09194501f, -0.09080959f, -0.01964967f, 0.16471790f, -0.05310765f, 0.07241706f, 0.00312558f, 
    0.06927226f, 0.05846542f, -0.03694905f, 0.03125837f, -0.06449535f, 0.02934446f, 0.08155381f, -0.03458319f, 
    -0.01466300f, -0.07099766f, -0.06012399f, 0.01434203f, 0.01506833f, -0.07797261f, -0.00364471f, 0.03787776f, 
    0.10177515f, 0.03200891f, 0.02252663f, -0.04754006f, 0.00348377f, 0.05129786f, 0.09052441f, 0.11458939f, 
    0.00329796f, 0.04196301f, -0.00448236f, -0.00976370f, 0.03041255f, -0.13484614f, -0.11775922f, -0.09471580f, 
    -0.13701698f, 0.07085390f, -0.12654917f, 0.06400494f, 0.00167521f, -0.00265984f, 0.14018324f, 0.01174655f, 
    0.09663729f, 0.18357176f, -0.17201668f, 0.00055878f, -0.01848789f, 0.00638445f, -0.03621301f, -0.12515268f, 
    0.12270162f, -0.18878858f, -0.06886967f, -0.08875358f, -0.37914252f, 0.09349740f, -0.18863869f, 0.29140550f, 
    -0.00483921f, -0.00256872f, 0.05811134f, -0.12542684f, 0.11662633f, 0.04354774f, 0.09415796f, -0.09231715f, 
    -0.35807598f, -0.18404567f, 0.00006438f, -0.11891823f, 0.04843878f, -0.06457946f, 0.01973849f, 0.04091099f, 
    0.04379646f, -0.06276465f, 0.09224752f, 0.00033232f, 0.35084069f, -0.00730676f, -0.05209306f, 0.14102791f, 
    0.00088564f, -0.02393365f, 0.06004189f, 0.00312932f, 0.10113277f, -0.10712538f, -0.02847538f, -0.02484753f, 
    -0.03196611f, 0.00666969f, 0.03355252f, -0.28627187f, 0.05928006f, -0.00103404f, -0.08431323f, -0.00482037f, 
    0.00205584f, -0.07144196f, 0.03515829f, 0.10292438f, -0.11505833f, -0.22753961f, -0.14569025f, -0.03391175f, 
    0.00705750f, -0.00108483f, -0.00661157f, -0.07163556f, 0.00944568f, 0.09089691f, 0.04540789f, 0.02712849f, 
    -0.20824845f, 0.00720476f, 0.11748596f, 0.04902790f, 0.22963965f, -0.08112051f, -0.13544814f, -0.03916999f, 
    -0.02024776f, -0.09159136f, -0.04564843f, -0.02907267f, -0.14212820f, 0.14191374f, 0.07973359f, -0.06017156f, 
    -0.04898070f, 0.05820573f, 0.01766903f, 0.00587010f, 0.01889615f, 0.04095434f, 0.05062990f, -0.00102161f, 
    0.31561509f, 0.01020213f, -0.31011680f, -0.23741078f, -0.00682571f, 0.05254713f, -0.10726266f, -0.04187627f, 
    0.05145172f, -0.00142247f, 0.07148707f, -0.03096040f, -0.03842978f, 0.13469692f, -0.06479823f, 0.04186036f, 
    0.04752282f, -0.03331672f, -0.19550024f, 0.08867744f, 0.01816147f, 0.03960975f, 0.10277358f, -0.05891179f, 
    0.18484172f, -0.13130713f, 0.04048639f, 0.15747030f, -0.03702925f, 0.01739305f, 0.07979821f, 0.10689104f, 
    0.08318300f, 0.05708877f, -0.00406017f, 0.04072382f, -0.05882602f, -0.10343812f, 0.13236365f, 0.15155680f, 
    -0.06633770f, 0.14402877f, -0.04564160f, -0.04590232f, 0.16365710f, -0.10894462f, 0.02639394f, -0.08801588f, 
    -0.01574117f, -0.00009923f, -0.02069539f, 0.03266868f, 0.02464603f, -0.04498401f, -0.03120328f, -0.02198847f, 
    -0.03371235f, -0.02457917f, 0.02171710f, -0.00451288f, -0.03416844f, 0.03278977f, 0.03627852f, -0.03629391f, 
    0.02941894f, 0.01807215f, -0.04199576f, -0.00802978f, -0.03124605f, -0.05206326f, -0.02535365f, 0.03136521f, 
    -0.05187112f, -0.04918760f, -0.03417225f, -0.01466046f, 0.00379224f, 0.03190136f, -0.00803507f, 0.02684410f, 
    -0.04141334f, 0.03997620f, 0.02797982f, 0.02785411f, 0.02155185f, 0.02377983f, -0.05921277f, 0.02073084f, 
    0.00446204f, -0.00515718f, -0.01329945f, 0.02771801f, -0.01871930f, -0.04404702f, -0.00177999f, -0.03437132f, 
    0.03411405f, 0.04497158f, 0.01431538f, 0.04247767f, -0.04221295f, -0.01851332f, -0.02054421f, 0.01821469f, 
    -0.04015010f, -0.00104995f, 0.01466769f, -0.00814409f, -0.05878982f, 0.03760861f, 0.00803626f, -0.02319641f, 
    0.04618368f, -0.03912156f, 0.03663955f, -0.04105325f, 0.00841693f, -0.04754379f, -0.03909271f, -0.00509112f, 
    0.01668759f, 0.04651823f, -0.02196684f, 0.01331790f, -0.03710415f, 0.05021798f, 0.02203350f, 0.03268186f, 
    0.01979152f, -0.04460227f, -0.02920921f, 0.05079272f, -0.03166428f, 0.03036863f, 0.03043568f, 0.02347571f, 
    -0.05706507f, 0.00007056f, -0.00347707f, 0.04576112f, -0.02507373f, -0.03782700f, 0.02085465f, -0.05130358f, 
    0.02032219f, 0.02968430f, 0.03189262f, -0.04404500f, -0.04598798f, -0.00023540f, -0.04580239f, -0.03872770f, 
    -0.00614355f, 0.00047778f, -0.04172668f, 0.03160445f, -0.01445676f, -0.00243980f, -0.03502997f, 0.01946094f, 
    -0.00824004f, -0.03209029f, 0.02677921f, -0.03525218f, -0.01976554f, -0.01350962f, -0.05027395f, -0.02411177f, 
    0.05319253f, -0.04869445f, 0.00578500f, 0.00867211f, -0.02810136f, -0.00003099f, -0.02995381f, 0.00009483f, 
    0.03605596f, -0.01274919f, -0.04191880f, 0.03664957f, -0.00509829f, 0.03940693f, 0.00397431f, 0.02688994f, 
    -0.02594261f, -0.01782185f, -0.01037892f, -0.00907924f, -0.00546576f, 0.00999548f, 0.01328099f, -0.03339909f, 
    -0.03138975f, 0.01253272f, 0.00535772f, 0.00189341f, -0.02496549f, 0.01467347f, -0.01486721f, 0.03503199f, 
    -0.03564536f, -0.04741723f, -0.00389129f, 0.05586131f, -0.03573461f, -0.04203569f, -0.04764654f, -0.03334884f, 
    0.05035239f, 0.00400132f, -0.02400188f, -0.05243711f, 0.04018251f, 0.00971846f, -0.01848463f, 0.01742647f, 
    0.02026465f, -0.00075865f, -0.03942977f, -0.00651611f, -0.01149137f, 0.03826596f, -0.02312442f, 0.03289806f, 
    -0.02859043f, 0.00795107f, -0.02489710f, 0.01907079f, -0.01887392f, 0.02801657f, -0.00860820f, -0.00341159f, 
    -0.01920077f, 0.03767579f, 0.03820346f, 0.03816410f, -0.03813607f, -0.00430402f, -0.01347478f, -0.00314309f, 
    0.02159666f, 0.00330926f, -0.02166945f, 0.03334723f, 0.03929361f, 0.00832912f, 0.00277310f, -0.03536225f, 
    -0.01346244f, -0.01168638f, -0.05749756f, -0.02976531f, -0.05505016f, -0.03160548f, -0.04226308f, -0.01594132f, 
    0.02267867f, -0.02661689f, 0.02760034f, -0.02942034f, -0.04228824f, 0.02541224f, -0.03367426f, -0.02018270f, 
    -0.05066760f, 0.05215275f, -0.01071822f, 0.02049128f, 0.02521818f, -0.02292446f, -0.02386961f, 0.00496325f, 
    0.00239589f, -0.04582679f, -0.01157738f, -0.05455088f, -0.02197422f, 0.01470440f, -0.00971388f, 0.00177400f, 
    0.01184488f, 0.03861281f, -0.02548867f, -0.04148164f, -0.02697904f, 0.02323920f, 0.04062828f, -0.05883548f, 
    0.02028826f, -0.03855848f, 0.03216349f, 0.01649918f, 0.01923169f, 0.03803406f, -0.04325576f, 0.03779984f, 
    0.00664701f, -0.03980050f, -0.01329019f, -0.04703102f, 0.01545231f, 0.04441011f, -0.03404431f, 0.01600756f, 
    0.05093509f, 0.01396072f, -0.00757952f, -0.02823407f, 0.01978840f, -0.03338142f, -0.01389625f, -0.04247207f, 
    0.02655071f, 0.02843807f, 0.01432518f, 0.02291940f, -0.05317931f, -0.01896513f, 0.02645852f, -0.02152555f, 
    0.03383803f, 0.04004391f, -0.04868680f, -0.00785527f, -0.04488819f, -0.01055989f, -0.03806870f, 0.01800406f, 
    0.03273774f, -0.00528584f, -0.01537949f, -0.00164885f, 0.00524281f, -0.04319446f, -0.01824618f, 0.01905982f, 
    -0.04004577f, -0.01145900f, -0.03075574f, -0.03814718f, -0.00752410f, -0.00376545f, -0.00588086f, -0.00240599f, 
    -0.01088266f, -0.04684252f, -0.00538027f, 0.01012659f, 0.02024989f, -0.02593473f, -0.04933274f, -0.00470414f, 
    0.00324638f, 0.01707426f, 0.00331703f, 0.00866245f, -0.05179965f, -0.02671783f, -0.01031656f, 0.02183501f, 
    -0.01509096f, -0.00906838f, -0.04420501f, 0.02454701f, 0.03187488f, 0.00632037f, 0.03457264f, -0.01286936f, 
    0.01664135f, 0.05154978f, -0.02454339f, -0.03883908f, 0.03439076f, 0.00969004f, 0.01247722f, -0.04914458f, 
    0.03749967f, -0.01373583f, 0.00620485f, 0.01007507f, 0.02552170f, 0.04873711f, -0.01349200f, 0.05478136f, 
    -0.01320478f, 0.03464153f, -0.05592285f, -0.01261069f, -0.01896099f, -0.01333172f, 0.02499570f, 0.00673961f, 
    0.03484912f, -0.00557455f, 0.01665509f, 0.01206296f, -0.02600830f, 0.02544028f, -0.03606886f, -0.01192596f, 
    -0.00723596f, 0.01173213f, -0.05293870f, 0.04248030f, -0.04724856f, 0.03994942f, -0.02828795f, 0.00467190f, 
    -0.01770888f, -0.02362662f, 0.00949685f, -0.02895626f, -0.00132303f, -0.02194693f, -0.04652580f, -0.00796126f, 
    -0.04113365f, -0.01613613f, 0.02748084f, 0.03446534f, -0.00747862f, 0.00521351f, 0.01040379f, 0.02017650f, 
    -0.02225411f, 0.04559907f, -0.01619801f, -0.03394968f, -0.03159065f, 0.02638495f, 0.01222842f, 0.03203802f, 
    0.17780747f, -0.00616704f, 0.06397234f, 0.08008845f, -0.04403156f, 0.05001859f, 0.04115652f, -0.06691293f, 
    -0.00472196f, 0.11260446f, 0.02690884f, -0.01507231f, -0.00013203f, -0.06412692f, -0.01065797f, -0.03229703f, 
    0.08795177f, 0.03970808f, -0.04918513f, 0.03058996f, 0.05351021f, 0.07481992f, 0.10901562f, 0.03792098f, 
    0.25873104f, -0.12975958f, -0.07258806f, -0.18867533f, 0.10773987f, 0.04288505f, -0.01488403f, 0.12013968f, 
    0.07229859f, 0.02390136f, -0.01429592f, -0.05639280f, 0.05788206f, 0.27118766f, 0.04885891f, 0.08201185f, 
    0.03093799f, 0.02162754f, 0.02129804f, 0.07412089f, -0.00317721f, 0.03823857f, 0.05729413f, 0.05907293f, 
    0.07745807f, 0.06961560f, 0.05701961f, 0.10003398f, 0.04318970f, 0.03979284f, -0.01924709f, 0.04403503f, 
    0.02000134f, 0.08322375f, -0.11803889f, -0.01659325f, -0.00135008f, -0.08793843f, -0.03093524f, 0.01721504f, 
    0.07970806f, -0.01143543f, -0.07387243f, 0.06315783f, -0.03609964f, -0.01424439f, 0.08048359f, -0.02201036f, 
    0.20896542f, -0.14674415f, 0.07322799f, -0.01420984f, -0.03293074f, 0.05786896f, 0.02099580f, 0.05662383f, 
    0.00796414f, -0.10584226f, -0.05868955f, 0.03269028f, -0.14671174f, -0.09573349f, -0.10180674f, 0.08197463f, 
    0.05929263f, 0.11426614f, 0.01757468f, 0.04591335f, 0.15245150f, 0.01509843f, 0.06392461f, -0.03944095f, 
    0.01972716f, 0.11680953f, -0.03839195f, -0.03427184f, -0.00789354f, -0.13458973f, 0.12290162f, 0.07374960f, 
    0.04875520f, 0.11298529f, 0.02984323f, -0.10327827f, -0.25040868f, 0.25783330f, -0.14388613f, 0.17920403f, 
    0.09007700f, -0.09049147f, 0.04791899f, -0.00605324f, 0.05956426f, 0.06259587f, -0.03086885f, 0.08915736f, 
    0.09858543f, -0.10659689f, 0.05810956f, 0.02921194f, -0.09620659f, -0.04335262f, 0.07072474f, -0.02591794f, 
    -0.10393281f, 0.05847214f, 0.06771890f, -0.16162120f, 0.14169398f, 0.08183575f, 0.08378077f, 0.04846234f, 
    0.00344633f, 0.08896847f, 0.02427868f, -0.01286258f, 0.00373604f, 0.00276190f, 0.04945398f, 0.06137113f, 
    0.18414566f, -0.09004433f, -0.20714033f, -0.10480766f, 0.07586167f, 0.05136766f, 0.01581504f, 0.05119336f, 
    0.03692898f, 0.02116746f, -0.02025209f, -0.10499444f, 0.21991612f, 0.04719207f, 0.09132504f, 0.14448439f, 
    0.16430613f, -0.03518173f, 0.07010712f, 0.01962176f, 0.06478718f, 0.01509941f, 0.07699654f, 0.08298095f, 
    -0.16734537f, 0.06655246f, -0.07162556f, -0.02588819f, -0.02565330f, -0.01205001f, -0.04347011f, -0.08467603f, 
    0.05926394f, 0.05530066f, 0.08216704f, -0.06522812f, -0.14469214f, 0.09257469f, -0.13765971f, -0.11272497f, 
    0.13215029f, 0.10371989f, -0.03440506f, 0.13900839f, 0.09748530f, -0.02156431f, 0.18348989f, 0.06400340f, 
    0.10651549f, 0.06848244f, -0.01091563f, 0.04221179f, 0.02742367f, 0.04842281f, 0.05137968f, -0.01927251f, 
    0.04322550f, 0.06282732f, 0.03102723f, 0.02472702f, -0.05646299f, 0.02778735f, -0.10516224f, -0.01895014f, 
    0.20027344f, 0.04111774f, 0.05360071f, -0.00891081f, 0.07219498f, 0.13365114f, 0.06932285f, -0.05886943f, 
    0.02266018f, -0.00827771f, -0.05450707f, -0.12741111f, -0.05163167f, 0.02360690f, 0.04896306f, 0.07998129f, 
    0.11250650f, 0.08642086f, -0.02319760f, 0.05511308f, -0.03620881f, -0.01079686f, -0.16970867f, -0.04212629f, 
    -0.02500867f, 0.00787834f, -0.01747107f, 0.13077302f, -0.07350034f, -0.07860187f, 0.07198735f, 0.05417386f, 
    -0.05912078f, 0.13852890f, 0.04587643f, -0.05382134f, 0.00518368f, 0.03941399f, -0.03169389f, -0.02968407f, 
    0.04331677f, 0.06473181f, 0.05987123f, 0.04676537f, -0.17919528f, -0.18885593f, -0.04964842f, -0.16341196f, 
    -0.15111291f, 0.05563596f, 0.09964182f, -0.05485698f, -0.00433280f, 0.07976034f, 0.10081587f, -0.02186014f, 
    -0.10958242f, -0.09095065f, -0.00453886f, -0.07684374f, 0.04148016f, -0.01927664f, -0.02474344f, 0.09992854f, 
    0.18238772f, -0.03822676f, 0.06468923f, 0.08460442f, 0.01131406f, -0.12238884f, 0.06107320f, -0.03588164f, 
    0.05782942f, -0.09297799f, 0.01021401f, -0.05200692f, 0.04978085f, 0.17559034f, 0.09268209f, 0.01177366f, 
    0.00390846f, -0.17371145f, -0.17064522f, -0.00786471f, 0.09030017f, -0.00409112f, -0.04512674f, 0.03389497f, 
    -0.05213717f, 0.01339305f, -0.00673766f, -0.04168394f, 0.14001891f, -0.11909316f, 0.05509885f, -0.08585243f, 
    -0.13198867f, 0.05122461f, -0.07671963f, 0.00991318f, -0.04310067f, 0.01866098f, 0.04029933f, 0.01358102f, 
    -0.03359701f, -0.11808632f, 0.10079081f, 0.17595705f, 0.02267257f, -0.11283100f, 0.07521613f, 0.14199233f, 
    0.04597659f, 0.06346855f, 0.00080153f, 0.21754394f, -0.03637588f, -0.08953218f, -0.21923050f, 0.08579373f, 
    0.08492413f, 0.02329447f, 0.05645161f, 0.00986345f, -0.00631385f, 0.04818671f, 0.03292273f, 0.11391029f, 
    -0.01274252f, -0.06423232f, 0.05069774f, -0.14338979f, -0.02402249f, 0.08345405f, -0.00854837f, 0.05206361f, 
    0.08686288f, 0.06291470f, -0.01906339f, -0.02906485f, -0.02843137f, 0.12906843f, -0.02299021f, 0.04050014f, 
    -0.04163448f, 0.00954893f, 0.01526884f, 0.04130912f, 0.10217708f, 0.07631746f, -0.11463182f, -0.04416821f, 
    -0.27513099f, 0.21408117f, -0.22384290f, 0.19317082f, 0.08047316f, 0.00102569f, 0.13479288f, -0.00266933f, 
    -0.01056184f, 0.02063797f, 0.08600273f, 0.00689654f, 0.04165437f, -0.12616803f, 0.01876156f, -0.08382012f, 
    -0.10385905f, -0.03532756f, 0.06346330f, -0.04201334f, 0.01875839f, 0.00617334f, -0.07926942f, 0.02253971f, 
    -0.00116752f, 0.21297564f, 0.20957069f, -0.05243595f, -0.02606759f, -0.07610374f, -0.01973699f, -0.03827852f, 
    -0.01841025f, -0.10338984f, 0.10165874f, -0.01696262f, 0.29768211f, 0.04547928f, -0.01778337f, 0.14020678f, 
    0.05453799f, 0.06343532f, 0.00346396f, 0.02935993f, -0.00922522f, -0.01451347f, -0.06681667f, -0.13316600f, 
    0.16287339f, 0.07608186f, 0.19532944f, 0.28434154f, 0.10922246f, 0.00891460f, 0.06658608f, -0.04259792f, 
    -0.09387019f, 0.03011912f, 0.00675506f, 0.10465388f, -0.24651037f, -0.03921391f, -0.18887594f, -0.03711369f, 
    -0.05495485f, 0.00245444f, -0.13757148f, -0.03606454f, 0.02364024f, -0.03813500f, 0.00377410f, -0.09709015f, 
    -0.13022025f, -0.01239949f, -0.11821380f, -0.07675042f, 0.00722150f, 0.05974643f, -0.05176711f, -0.09446606f, 
    0.05567218f, 0.03343597f, 0.03953185f, 0.06879739f, 0.34473297f, 0.08804269f, -0.04590175f, 0.05179722f, 
    -0.00239942f, 0.04648957f, -0.02613249f, -0.00584488f, -0.06119142f, -0.01404035f, -0.02059792f, 0.01884163f, 
    -0.00266135f, 0.04155958f, 0.21690293f, 0.01423179f, 0.15776788f, -0.09872115f, 0.02335660f, 0.09006634f, 
    0.05965095f, -0.03069939f, 0.01875293f, -0.06455902f, 0.47299868f, -0.02826544f, 0.09234391f, 0.24127534f, 
    0.17561917f, 0.03896776f, 0.01114041f, 0.01499322f, 0.02407761f, 0.00375061f, -0.02727115f, -0.02187575f, 
    0.40435010f, -0.02786728f, 0.08257887f, 0.06751201f, -0.02516298f, 0.03036977f, -0.04573814f, 0.05748555f, 
    -0.05774258f, 0.08198403f, 0.18393284f, 0.00324279f, -0.20696466f, 0.03605877f, -0.10546468f, 0.03091300f, 
    -0.04348845f, 0.05182632f, 0.00527987f, -0.09816512f, -0.01080215f, 0.07775876f, 0.01156686f, -0.01588240f, 
    0.30868131f, 0.13835527f, -0.08681502f, 0.05100398f, -0.08474420f, 0.09200510f, -0.09279783f, 0.00587280f, 
    0.07260534f, -0.07389590f, -0.06962194f, -0.06120925f, 0.01643717f, 0.21617673f, 0.12876561f, -0.18603954f, 
    0.09717257f, -0.04685700f, 0.04444455f, 0.09571635f, 0.04050792f, -0.07130592f, 0.14305414f, -0.00363570f, 
    -0.11274116f, 0.00658677f, -0.08768061f, 0.16598935f, -0.00364710f, -0.03252553f, 0.04683106f, 0.01872392f, 
    0.05502550f, 0.08467396f, -0.09292348f, 0.07686584f, -0.29457182f, 0.01558681f, -0.16060400f, -0.16435476f, 
    0.06558339f, -0.08905695f, 0.03824041f, -0.00596376f, -0.01360065f, 0.06649619f, -0.00129073f, -0.10765308f, 
    0.06005872f, -0.06960087f, 0.08639623f, 0.16908582f, -0.07498804f, 0.06630823f, -0.07446436f, 0.15286484f, 
    -0.07722048f, -0.02954610f, 0.01131038f, 0.09382737f, 0.03252689f, -0.12888215f, 0.09196183f, -0.32316920f, 
    -0.09476809f, -0.00201894f, 0.02363625f, -0.12314022f, -0.08194761f, 0.02844365f, -0.12989689f, 0.05219390f, 
    -0.23362145f, -0.07793739f, 0.03345420f, -0.18005122f, -0.02996232f, 0.02823331f, 0.06800898f, 0.00125940f, 
    0.08571893f, -0.11403432f, -0.02125885f, 0.08880554f, 0.14688472f, -0.10122136f, 0.11051860f, 0.19240150f, 
    -0.05739073f, -0.05543763f, 0.00017826f, 0.00943806f, -0.05493168f, 0.03109395f, -0.02794742f, 0.06810119f, 
    -0.11126444f, -0.18638158f, 0.02524470f, -0.03589958f, -0.01529466f, -0.03939519f, 0.11394579f, 0.15990026f, 
    0.07489944f, 0.09375241f, 0.03799038f, -0.00234963f, 0.28820029f, -0.12877113f, -0.22122361f, -0.05216317f, 
    0.04560965f, 0.17311037f, 0.01447234f, -0.02245181f, 0.04524644f, 0.03242046f, -0.02762650f, 0.00335891f, 
    0.29877490f, 0.03856665f, 0.16259372f, -0.25308838f, 0.14254534f, -0.09536111f, -0.02967133f, 0.18696699f, 
    -0.03513093f, -0.03485988f, -0.00278506f, 0.02382052f, -0.15054150f, -0.07976498f, 0.00164498f, -0.12702763f, 
    0.03067265f, -0.05361321f, 0.17621437f, 0.10098989f, -0.06858773f, -0.05004536f, 0.00038265f, 0.08528104f, 
    -0.10203251f, 0.03152854f, -0.10849455f, -0.11478591f, -0.01728442f, -0.05028855f, -0.06891562f, -0.08356305f, 
    -0.11495712f, -0.01453670f, 0.10897283f, -0.09018971f, -0.12892628f, -0.03370776f, -0.03806481f, 0.06330840f, 
    -0.07013126f, 0.01306502f, -0.04924545f, -0.02693960f, 0.03478577f, 0.00624850f, -0.14626923f, -0.10914185f, 
    0.14166716f, 0.08012900f, 0.02703450f, 0.27822819f, 0.03028757f, 0.01916857f, 0.10314590f, 0.03320736f, 
    0.08648933f, -0.03225821f, 0.02310650f, -0.03379772f, -0.01996047f, -0.04097130f, 0.07219820f, -0.07216661f, 
    0.00109583f, -0.05997159f, -0.03349298f, 0.07827863f, 0.16798416f, -0.08123215f, 0.03347407f, 0.11141112f, 
    0.03455209f, -0.01066984f, -0.01363885f, 0.16040979f, 0.09679406f, 0.02858779f, 0.01877618f, -0.07454419f, 
    -0.07904302f, -0.06817150f, -0.01238045f, -0.13961373f, 0.36394382f, 0.12831682f, -0.03703729f, 0.12691967f, 
    0.12833783f, 0.08469710f, 0.04525507f, -0.00006284f, 0.04720100f, 0.03223021f, 0.09616765f, 0.02614832f, 
    0.11706721f, 0.09997458f, 0.13450055f, -0.03663651f, -0.04323739f, -0.01533759f, -0.08681925f, 0.11512543f, 
    -0.01504550f, -0.01844303f, 0.02480058f, -0.06134400f, -0.07116999f, 0.04314061f, -0.19966860f, 0.11131170f, 
    -0.00278601f, -0.08315836f, -0.10209197f, 0.02584696f, 0.02273074f, -0.03101320f, 0.01483268f, -0.04188029f, 
    -0.06927535f, -0.13451338f, -0.23148277f, -0.05791274f, 0.06157687f, -0.02224481f, 0.01310907f, -0.01309371f, 
    -0.03972259f, -0.03246198f, -0.01549580f, -0.09148652f, -0.17440952f, -0.10507892f, 0.03546343f, -0.23341537f, 
    -0.05402861f, -0.00207983f, -0.03051109f, 0.17467317f, -0.06800855f, -0.07363372f, 0.04835182f, 0.19283427f, 
    -0.03689741f, 0.04100967f, -0.01537523f, -0.05505814f, -0.03511013f, -0.03850719f, -0.02069042f, -0.04728473f, 
    0.04018671f, 0.00343571f, -0.03912779f, 0.03283577f, 0.01307228f, -0.03831025f, -0.01437119f, 0.00394962f, 
    -0.05038032f, -0.03489152f, -0.02476627f, -0.03874699f, -0.04789445f, -0.04443181f, -0.00487974f, -0.04625529f, 
    0.03606853f, 0.00330011f, -0.02411486f, 0.02143382f, -0.00055322f, -0.04887292f, -0.05302858f, -0.00553357f, 
    -0.05342732f, -0.04552497f, -0.03597056f, -0.05471729f, 0.03700006f, -0.04099218f, -0.01664805f, 0.02469075f, 
    -0.05320826f, 0.02693315f, 0.03635551f, -0.04270262f, -0.03198852f, 0.03174124f, 0.01718516f, 0.02575625f, 
    -0.02208183f, 0.03925738f, 0.04476607f, 0.04468717f, -0.00653902f, -0.04907559f, -0.04935202f, -0.01917735f, 
    -0.02290319f, 0.02072272f, 0.00577160f, -0.01144973f, 0.03061153f, -0.01499788f, 0.00268252f, -0.01841529f, 
    -0.05014438f, -0.00375641f, -0.05659507f, 0.03274600f, 0.02526119f, -0.05567447f, 0.02368941f, -0.02823656f, 
    -0.03539350f, 0.04162804f, 0.04189250f, 0.04734816f, -0.02531918f, -0.01639312f, -0.05198700f, -0.02399082f, 
    -0.03319730f, -0.02243451f, 0.01574335f, -0.05036085f, -0.02848029f, 0.00212534f, -0.04300938f, 0.02971802f, 
    -0.00296489f, -0.02430724f, 0.01288031f, -0.01996520f, -0.02660167f, 0.01196097f, 0.03578677f, -0.03490157f, 
    -0.01862565f, -0.03182897f, -0.02912981f, -0.00735141f, 0.02953600f, -0.03470520f, -0.03474361f, -0.01765241f, 
    -0.00018107f, 0.01186729f, -0.00031058f, -0.01344546f, -0.04815134f, -0.00502404f, 0.02972889f, -0.00982944f, 
    0.02111161f, -0.01683689f, -0.00916436f, 0.04831035f, -0.02830736f, -0.04413217f, -0.02486717f, 0.02213052f, 
    -0.01964558f, -0.00535100f, 0.03130566f, 0.03849938f, 0.04349336f, -0.04498579f, 0.00406947f, -0.02930214f, 
    -0.02655326f, -0.00603089f, 0.00971473f, -0.02371983f, 0.00327495f, -0.00989192f, -0.05088679f, -0.03854040f, 
    -0.00068257f, -0.04228793f, -0.00809366f, -0.01894700f, 0.04994543f, -0.00218644f, 0.03014203f, -0.01943979f, 
    0.01951869f, 0.02986207f, 0.00911137f, -0.01200618f, 0.01512336f, 0.02254512f, 0.02654603f, -0.03116024f, 
    0.02116982f, -0.01600166f, -0.03893944f, -0.03923210f, 0.02313510f, -0.04731071f, 0.01404043f, 0.00838777f, 
    -0.03449722f, -0.02432971f, 0.02306144f, -0.05530660f, 0.03771939f, -0.03391171f, -0.02659614f, -0.04950196f, 
    -0.04417541f, -0.04939970f, -0.05510735f, -0.03134590f, -0.00185119f, 0.04261398f, -0.01956547f, 0.00383461f, 
    -0.01991685f, -0.00730077f, -0.01928694f, -0.02805888f, 0.03183510f, -0.02022486f, 0.02742046f, -0.02070103f, 
    0.02007250f, -0.03936983f, 0.04236491f, -0.00010061f, -0.02237407f, -0.05650936f, -0.04353711f, -0.05122777f, 
    0.02299195f, -0.05237889f, -0.00997000f, -0.01723670f, 0.00415526f, 0.00063233f, -0.01744625f, 0.00227116f, 
    0.03684150f, -0.02880660f, -0.04819493f, 0.01691759f, -0.02417422f, 0.00906160f, 0.03546824f, 0.01947174f, 
    -0.03168023f, -0.03363469f, -0.02673412f, -0.03626555f, -0.00444409f, 0.02798769f, 0.02318479f, -0.04503741f, 
    0.02819267f, 0.00161456f, 0.03750123f, -0.05556997f, -0.03403095f, 0.03848367f, -0.04468764f, -0.04055261f, 
    0.01524794f, 0.01967504f, -0.00084755f, 0.01913477f, -0.00809303f, 0.02499107f, 0.03861468f, 0.02956788f, 
    -0.05356929f, 0.00697002f, 0.01398196f, -0.02247741f, -0.01306341f, -0.04898859f, 0.00108239f, -0.05101620f, 
    -0.01213817f, -0.01937809f, 0.04833629f, 0.02409043f, 0.02844238f, 0.02626058f, -0.00054813f, 0.03300127f, 
    0.02999098f, -0.05046934f, -0.05407124f, 0.01059031f, -0.00190556f, 0.04983808f, -0.03779941f, 0.00389552f, 
    -0.03259478f, 0.01902294f, -0.04282163f, 0.03420650f, 0.03070604f, 0.00919269f, 0.00457866f, 0.03424530f, 
    0.01742440f, -0.03730535f, -0.01108075f, -0.04625193f, -0.05569698f, -0.05124557f, -0.01119072f, -0.01054115f, 
    -0.02432890f, 0.01315812f, 0.02864887f, 0.00613799f, 0.01306961f, 0.04347949f, 0.02348565f, -0.01557610f, 
    -0.04124922f, -0.04943508f, 0.01758849f, 0.04376832f, -0.04484628f, -0.04028452f, 0.01414438f, 0.02504951f, 
    -0.00858718f, -0.02949607f, -0.00664591f, -0.00788617f, -0.04193451f, 0.03830885f, 0.01203576f, -0.00587893f, 
    0.03228113f, -0.02335045f, -0.04846079f, 0.01556638f, -0.00380898f, 0.02716022f, 0.00049380f, 0.00854877f, 
    -0.00528458f, 0.04176348f, 0.02631971f, 0.03185903f, 0.02280547f, 0.01208143f, -0.01863720f, -0.03384996f, 
    -0.01166198f, -0.03297531f, -0.05515226f, -0.03771583f, 0.03304043f, 0.04300911f, -0.02387129f, -0.01796376f, 
    -0.00302578f, -0.05683030f, 0.00870820f, -0.00844349f, -0.04812120f, 0.01240655f, 0.02974899f, -0.03027859f, 
    -0.03573807f, 0.01100135f, -0.02393359f, -0.00748370f, -0.05563355f, 0.01022744f, 0.04077316f, -0.00843624f, 
    0.03309431f, 0.04171881f, 0.04470818f, 0.01747226f, -0.01599989f, -0.04317364f, 0.03626812f, -0.02858388f, 
    -0.01819744f, -0.03483821f, -0.05007902f, -0.05446245f, 0.02920917f, -0.02845175f, 0.03812840f, -0.03524942f, 
    -0.00859853f, 0.01582938f, -0.01346170f, -0.00046451f, -0.02347740f, 0.03234376f, 0.03033360f, -0.05033419f, 
    -0.00361220f, 0.01560429f, -0.05531785f, -0.00571815f, -0.05639652f, -0.00928197f, 0.03957302f, 0.02758100f, 
    -0.04880344f, -0.05325480f, -0.04037490f, 0.00449068f, 0.02670595f, -0.01238573f, -0.02156369f, -0.00089358f, 
    -0.03107116f, -0.01821073f, 0.00397624f, 0.03319427f, 0.00066877f, 0.01772889f, -0.05231212f, 0.00625405f, 
    -0.04890313f, -0.01731368f, 0.05095657f, 0.03251911f, 0.01171576f, -0.00315307f, 0.03134766f, 0.03615136f, 
    -0.02706906f, -0.03891830f, 0.00462588f, -0.03190827f, -0.02399656f, -0.03460925f, -0.05190662f, -0.04911762f, 
    0.01255873f, -0.03101165f, -0.00470855f, 0.03874427f, 0.03991781f, -0.03176082f, 0.00427661f, 0.02922084f, 
    0.03428034f, -0.05461022f, -0.01661487f, 0.00196400f, 0.02038807f, 0.01831435f, 0.00572372f, -0.00413589f, 
    -0.00945587f, 0.03078668f, -0.02026978f, 0.00796423f, 0.00497882f, -0.05077277f, -0.03511997f, 0.03511573f, 
    0.00176839f, 0.03992440f, -0.05307942f, -0.04126226f, -0.02153815f, 0.02921105f, 0.01813297f, -0.04360809f, 
    0.00982993f, 0.01180227f, 0.03724972f, -0.05770929f, -0.03727200f, 0.01527571f, 0.02255213f, 0.02771944f, 
    -0.03247812f, 0.00150312f, -0.02004234f, 0.00433959f, 0.03040702f, -0.05269906f, -0.00941252f, 0.02409462f, 
    0.03255489f, -0.04482510f, 0.00438652f, -0.02162284f, -0.00290058f, 0.03562525f, 0.02250401f, -0.03472675f, 
    -0.05620865f, -0.00987881f, -0.03697475f, -0.02867015f, -0.05497715f, -0.02280641f, -0.03773978f, -0.03497701f, 
    0.00068248f, -0.02308257f, -0.00616544f, 0.03633439f, 0.02755051f, -0.00216051f, -0.04224249f, -0.02444512f, 
    -0.04474842f, -0.01690107f, -0.05678841f, -0.02119152f, 0.02763583f, -0.03883461f, -0.01763750f, 0.01752006f, 
    -0.03157369f, 0.04282011f, -0.02186363f, -0.02175531f, 0.01264618f, 0.02056060f, -0.00374892f, -0.05281820f, 
    -0.02035589f, -0.04889057f, -0.01876538f, 0.01127807f, 0.04634042f, 0.03902527f, -0.00017542f, 0.01134030f, 
    -0.05488252f, 0.00120056f, -0.05539642f, -0.03717875f, -0.03935355f, -0.05274216f, -0.02603787f, 0.03797280f, 
    -0.02587315f, -0.00593388f, -0.06070722f, -0.05960287f, -0.03911862f, 0.04147846f, -0.04783507f, -0.01078390f, 
    -0.02745552f, -0.03436876f, -0.01431551f, -0.01870288f, 0.03945700f, -0.01760872f, -0.01135559f, -0.05694892f, 
    0.04804995f, -0.02582005f, -0.05392960f, -0.01874358f, -0.02103333f, -0.01735935f, -0.05299851f, 0.02044506f, 
    0.02858188f, 0.00440291f, -0.01849755f, -0.01909513f, -0.04205550f, 0.02836574f, 0.00344347f, 0.03174978f, 
    -0.00276283f, 0.03335720f, -0.00239636f, -0.05712586f, -0.05525489f, 0.00407222f, 0.00885462f, 0.04510596f, 
    0.02721139f, -0.01549034f, -0.02893218f, 0.00306777f, 0.01504316f, 0.03398912f, -0.02139447f, -0.01385935f, 
    0.03597809f, 0.03286184f, 0.02429021f, 0.02766434f, 0.03665719f, -0.05094250f, -0.00054088f, 0.03765418f, 
    -0.05237836f, 0.03531155f, -0.00286103f, -0.01354657f, 0.02516076f, 0.00649480f, -0.03149366f, -0.01935172f, 
    -0.03852814f, 0.02094187f, -0.01826140f, 0.01355195f, 0.00190738f, -0.00767451f, -0.05933360f, 0.00596667f, 
    0.01603472f, 0.00371081f, 0.00275673f, -0.04254289f, -0.03463474f, 0.00384615f, 0.02217601f, 0.00151748f, 
    -0.04499373f, -0.02758556f, 0.00991034f, -0.01017351f, -0.02544419f, -0.05422518f, -0.05004721f, -0.00674592f, 
    -0.02566927f, 0.01889782f, -0.04738719f, -0.01463746f, -0.01038494f, -0.01333387f, -0.05429723f, 0.03354289f, 
    0.04105083f, -0.03390259f, -0.04856794f, 0.00039104f, -0.00058385f, -0.00783215f, 0.02154019f, 0.00655619f, 
    -0.03159517f, 0.00268191f, 0.03483261f, 0.02081478f, 0.01799305f, -0.02868864f, -0.00179170f, 0.01974556f, 
    0.02348272f, -0.02177481f, -0.05726153f, 0.02401037f, 0.03129674f, -0.02146367f, -0.03811064f, -0.04203168f, 
    0.02876936f, -0.05541912f, -0.01060324f, 0.04326112f, -0.00452215f, 0.02772906f, -0.04929274f, -0.00606624f, 
    0.01809300f, -0.00841425f, -0.02821002f, -0.04853284f, -0.01746540f, 0.04129950f, -0.00259099f, 0.04751673f, 
    0.01519965f, -0.01253738f, 0.02238241f, 0.04080511f, -0.00025669f, -0.04613600f, -0.03268585f, 0.01670385f, 
    -0.03229425f, 0.03485598f, -0.05908233f, -0.02319377f, 0.02688559f, -0.05338951f, 0.00794215f, -0.03240001f, 
    0.03587993f, -0.01060070f, 0.00225475f, -0.00730906f, 0.00098714f, -0.00225439f, 0.00347889f, -0.01810064f, 
    -0.04931952f, -0.04533026f, 0.01864761f, -0.02540108f, -0.03015611f, -0.04241756f, -0.01632073f, -0.02813859f, 
    -0.03226303f, 0.02813480f, -0.04084603f, -0.01953166f, -0.03102998f, -0.05799348f, -0.04982905f, 0.03221232f, 
    -0.05358372f, 0.01489284f, -0.02266675f, 0.00801070f, -0.03912543f, -0.03975226f, -0.00935358f, 0.02711122f, 
    0.02501540f, 0.02781225f, -0.02896922f, 0.00810254f, 0.03542421f, -0.00994093f, -0.03821017f, -0.00403687f, 
    -0.04734360f, 0.04155023f, 0.01355040f, 0.02271068f, -0.05358188f, 0.01276794f, 0.03297876f, -0.02910739f, 
    0.03431072f, -0.05477423f, -0.04671777f, 0.02145384f, -0.05502003f, -0.02501107f, 0.00466448f, 0.02215270f, 
    -0.05882242f, 0.04066628f, 0.01435245f, -0.05278799f, 0.00879219f, 0.02488193f, 0.00652649f, -0.02236917f, 
    -0.03443021f, 0.03319534f, -0.01317406f, 0.02681600f, -0.00206457f, 0.01379421f, 0.04011063f, 0.00464612f, 
    -0.01810833f, -0.03035439f, 0.02779594f, -0.04608202f, -0.05738908f, -0.05443389f, 0.00687175f, -0.02805638f, 
    -0.00774492f, 0.02480111f, 0.00079929f, 0.00637536f, 0.01197262f, 0.02313381f, 0.00217401f, -0.04182287f, 
    0.01188205f, 0.02130046f, 0.04348928f, 0.00074908f, 0.00344173f, -0.04615032f, 0.02166325f, -0.01777700f, 
    0.02842301f, -0.00581727f, 0.03477686f, -0.00245900f, -0.05741015f, 0.03859508f, 0.03836362f, 0.00665016f, 
    -0.05177155f, 0.01268507f, -0.02650036f, -0.03327452f, 0.02850032f, -0.00558743f, 0.01771137f, -0.00270267f, 
    0.01424319f, 0.00386601f, -0.03322106f, -0.05957578f, 0.02058958f, 0.02514231f, -0.02337323f, -0.06481268f, 
    -0.04321199f, -0.02147808f, -0.02660618f, -0.05889288f, -0.01212827f, -0.06379864f, -0.00396263f, -0.05274999f, 
    -0.05423257f, -0.05213393f, 0.00646352f, -0.04573601f, -0.03871595f, -0.04273116f, -0.06295328f, -0.02169488f, 
    -0.03640717f, 0.02715325f, -0.04429250f, -0.00704598f, 0.00528857f, 0.00673862f, 0.00472418f, -0.00541062f, 
    0.00477826f, 0.01659483f, 0.00269449f, -0.07020599f, -0.04347862f, -0.06671280f, 0.00420896f, 0.01044722f, 
    0.01607993f, 0.01340209f, 0.00670420f, -0.02499515f, -0.03694457f, -0.05215089f, -0.01030513f, 0.01962241f, 
    -0.00267854f, -0.05287169f, -0.05235990f, -0.06902684f, -0.00566101f, -0.01440560f, 0.01834361f, -0.02195446f, 
    -0.00870730f, -0.03402900f, -0.02390460f, -0.03122982f, 0.01858755f, -0.03126219f, -0.04912416f, 0.01044672f, 
    -0.04143813f, -0.01410474f, -0.00334139f, 0.01312767f, -0.06553772f, 0.02539298f, -0.03693226f, -0.06156889f, 
    -0.05231555f, -0.06604654f, -0.06366928f, -0.06462791f, 0.01354659f, -0.06652004f, -0.04580181f, -0.04595467f, 
    0.02740321f, -0.02751612f, 0.02003222f, -0.00137642f, -0.01785489f, -0.00845401f, -0.01784158f, 0.00759038f, 
    -0.01862596f, -0.04821001f, -0.02054790f, -0.05743588f, -0.05669224f, -0.05804421f, -0.05564027f, -0.01741247f, 
    -0.04169847f, -0.02484513f, 0.01637882f, -0.05168045f, 0.02796510f, -0.06802633f, -0.01850082f, 0.01872867f, 
    -0.01376179f, 0.02146912f, -0.01003549f, -0.03570201f, -0.05686351f, -0.01754048f, -0.01818953f, 0.04635395f, 
    -0.05577749f, -0.00012962f, -0.04129834f, -0.01305456f, -0.04269614f, -0.01858374f, -0.04378166f, -0.04118549f, 
    0.02729351f, 0.01255345f, -0.05478171f, -0.00087207f, -0.00834956f, 0.00936664f, -0.03704071f, -0.03754177f, 
    0.00654674f, -0.03946397f, -0.03836964f, 0.01374279f, 0.00975751f, -0.00557940f, 0.02786209f, -0.01680353f, 
    -0.00303812f, -0.04815317f, -0.04788770f, -0.04845567f, 0.00762023f, -0.07174541f, -0.03678381f, -0.00542733f, 
    -0.00003958f, -0.04481924f, -0.05022972f, -0.02855460f, -0.06212746f, 0.00507677f, -0.05956110f, 0.01639620f, 
    -0.06151651f, -0.02433491f, -0.05092106f, 0.02125161f, -0.00867958f, -0.04526192f, 0.01137442f, -0.06229471f, 
    -0.06409520f, -0.04115944f, 0.01218962f, 0.00700711f, -0.02925128f, -0.04465649f, -0.06735241f, -0.04381876f, 
    -0.06382423f, -0.04286919f, -0.06785204f, -0.04791447f, 0.02387361f, -0.01072932f, -0.04807487f, -0.04113033f, 
    -0.01500199f, -0.06783096f, 0.01480585f, -0.03669499f, -0.06324531f, 0.01289930f, -0.02871676f, -0.05191933f, 
    -0.06470558f, -0.03867672f, 0.02243368f, -0.06450518f, 0.01297995f, -0.06564870f, 0.02944627f, -0.00730067f, 
    0.02520340f, 0.00022512f, -0.02002786f, -0.05051170f, -0.00033726f, -0.06697904f, -0.06526125f, -0.02643657f, 
    -0.04283451f, 0.02443071f, -0.00469302f, -0.03373184f, -0.05809251f, -0.03833763f, 0.02369571f, 0.02685227f, 
    0.01648754f, -0.02434805f, -0.04234001f, -0.04054306f, -0.05310931f, -0.04504424f, -0.01718858f, -0.06120359f, 
    0.02718187f, -0.04528631f, -0.04133155f, 0.02534171f, -0.00898638f, -0.05084931f, -0.06088703f, -0.02226485f, 
    -0.05539658f, -0.02986662f, -0.04941639f, -0.01259501f, -0.06233805f, -0.05486081f, -0.02699941f, -0.00047756f, 
    0.00745529f, -0.05358122f, -0.03189940f, -0.05901068f, -0.02724524f, -0.01416020f, 0.00672536f, -0.05679069f, 
    0.01175732f, -0.04249898f, -0.05120375f, 0.02056197f, -0.02154050f, 0.00311553f, 0.04450888f, -0.00485889f, 
    -0.03414242f, 0.02511257f, 0.01743424f, -0.04353465f, 0.02746005f, -0.00405604f, 0.00983851f, -0.03029912f, 
    -0.05731768f, -0.04612390f, -0.05486618f, -0.02669156f, -0.06067618f, 0.01012795f, 0.01223438f, -0.02031770f, 
    -0.01190388f, 0.00079102f, -0.06373312f, -0.04502163f, -0.03112298f, 0.01540384f, -0.02319153f, 0.02393980f, 
    -0.05587008f, -0.00429531f, -0.05182345f, 0.00191230f, 0.01695921f, -0.00647388f, -0.03396624f, -0.04306323f, 
    0.04483848f, -0.03526354f, 0.02659842f, -0.04761685f, 0.00674891f, -0.00855219f, -0.03718290f, 0.03038735f, 
    -0.02378118f, -0.04897175f, -0.06878530f, -0.04738203f, -0.03071668f, -0.00806900f, -0.01072173f, -0.03483375f, 
    0.01671684f, -0.03752063f, 0.02296206f, -0.00021907f, -0.05331989f, -0.05933675f, -0.07063628f, -0.05042523f, 
    -0.01049262f, -0.02053050f, 0.00222778f, 0.00756666f, -0.04368191f, -0.06611882f, -0.01309196f, -0.02334367f, 
    -0.04030399f, -0.06039317f, -0.06225290f, -0.04649807f, 0.00039846f, 0.02298161f, 0.02686240f, 0.00710197f, 
    -0.06147094f, -0.07152228f, 0.02287810f, -0.03765486f, 0.01196981f, -0.01107470f, -0.03871624f, 0.00631436f, 
    0.01843805f, -0.00687164f, 0.00493551f, -0.01661097f, -0.01440851f, 0.01196972f, -0.04711264f, 0.02639526f, 
    -0.05037150f, 0.00204770f, 0.01963628f, -0.05475992f, -0.03645886f, -0.00517059f, -0.04755645f, -0.00590790f, 
    0.01132419f, -0.06920697f, -0.02504465f, 0.00847677f, -0.02360352f, -0.04644859f, -0.02617163f, -0.04460059f, 
    0.01930770f, -0.00923215f, 0.02841484f, 0.01402984f, 0.00072959f, -0.03530017f, -0.00495235f, -0.01496743f, 
    -0.07124183f, -0.05195849f, -0.04083987f, -0.07013243f, 0.01864475f, -0.03668118f, -0.05113862f, -0.01944494f, 
    0.00585580f, -0.06802939f, -0.03823977f, -0.00960409f, -0.02809014f, -0.03051059f, -0.00248997f, 0.00237713f, 
    -0.01099650f, 0.01786665f, 0.03453210f, -0.05726645f, -0.01458126f, -0.03206038f, 0.01341424f, -0.05505318f, 
    -0.00082313f, -0.04042019f, 0.01568554f, -0.01449331f, 0.03368823f, -0.00777329f, -0.02023384f, 0.01674766f, 
    0.02976855f, -0.02973722f, -0.00830095f, -0.04759723f, -0.06686161f, -0.00856251f, -0.05090161f, 0.03407167f, 
    -0.03282240f, -0.07277384f, 0.01138349f, 0.02090730f, -0.01234595f, -0.00843728f, -0.05128892f, 0.03417113f, 
    -0.04102980f, -0.00300875f, 0.05098439f, -0.03283893f, 0.05754863f, 0.00479466f, 0.01809081f, 0.01288601f, 
    -0.02370348f, -0.00790537f, 0.02019254f, 0.02180762f, -0.00214333f, 0.00132687f, 0.01795777f, -0.00614234f, 
    -0.01810075f, 0.01720919f, -0.00474709f, -0.01671510f, -0.02386821f, -0.05572659f, 0.00052786f, -0.02267058f, 
    0.02905295f, -0.00226145f, 0.05729927f, 0.03846797f, 0.05073064f, -0.03603186f, 0.00744173f, -0.04070376f, 
    0.03533732f, -0.03980286f, 0.02384925f, -0.05546073f, 0.04790500f, 0.00917152f, -0.02036714f, 0.04018945f, 
    0.04600288f, 0.00399199f, -0.02959682f, -0.02026217f, 0.00662205f, -0.03782892f, -0.01276467f, -0.04097928f, 
    -0.02965426f, 0.02091702f, -0.01203944f, -0.04133093f, -0.03587292f, -0.01837070f, -0.04630205f, -0.03206689f, 
    -0.00100443f, 0.02800600f, -0.04220706f, -0.01137031f, -0.01439432f, 0.02001973f, -0.04412001f, 0.02136471f, 
    0.02600177f, -0.04027387f, -0.03416279f, -0.07729486f, -0.06271519f, -0.00117410f, 0.05113568f, 0.00343865f, 
    -0.04313807f, -0.04146532f, -0.06128332f, 0.03410770f, -0.04305540f, -0.03964735f, 0.00919716f, -0.01098352f, 
    -0.01729790f, 0.02390016f, 0.06847336f, -0.00628062f, -0.02134785f, -0.03059240f, -0.03455703f, -0.03680371f, 
    0.03927802f, -0.05535143f, 0.00006415f, -0.00166409f, 0.03122406f, 0.03090972f, 0.04097357f, -0.03714382f, 
    0.01552207f, -0.00006840f, 0.04337314f, 0.01038311f, 0.04550285f, -0.04112205f, -0.00122314f, -0.01403608f, 
    0.02421825f, -0.00200394f, -0.00036471f, -0.02396357f, -0.00190106f, 0.03640307f, -0.01249566f, -0.05914099f, 
    -0.05561163f, 0.01321303f, -0.05982315f, -0.00765350f, 0.02220666f, -0.03057129f, -0.06106747f, 0.01134885f, 
    -0.02987180f, -0.00357856f, 0.04140560f, -0.00319708f, -0.00121327f, -0.00079572f, -0.07570142f, -0.00318202f, 
    0.04153996f, 0.00409276f, 0.01016078f, 0.01231449f, -0.01584987f, 0.05581646f, 0.05490185f, 0.04793322f, 
    0.01600290f, 0.01304739f, 0.03510109f, -0.01025388f, -0.04711884f, -0.02135695f, 0.03617812f, 0.00339302f, 
    -0.04390213f, 0.02226667f, 0.05409382f, -0.01145787f, 0.04286237f, 0.01686672f, 0.01936515f, 0.01961523f, 
    0.02396382f, 0.00267273f, 0.01092459f, 0.01081428f, 0.00522165f, -0.02885951f, 0.04434941f, -0.02619167f, 
    0.00765584f, 0.04260919f, -0.04221595f, 0.02916985f, -0.01093794f, -0.00993584f, -0.00677916f, -0.06325197f, 
    0.01449718f, -0.01870002f, -0.05699916f, -0.04397253f, -0.02498629f, -0.05176177f, 0.03458238f, 0.04057627f, 
    0.01168223f, 0.01947927f, -0.05429710f, -0.02116131f, -0.06211709f, -0.01995485f, -0.03503256f, 0.01853682f, 
    0.02239951f, -0.01434521f, 0.01323793f, -0.05035739f, -0.00353329f, 0.00154616f, -0.00389327f, -0.00056465f, 
    0.02923085f, -0.00714954f, -0.00990288f, -0.00242344f, 0.03485602f, 0.01873861f, -0.03165681f, -0.00729502f, 
    -0.03687518f, -0.05453249f, -0.01158773f, -0.06981983f, -0.02622985f, -0.02043082f, -0.00967544f, 0.07421639f, 
    0.00751403f, -0.01008598f, -0.05560910f, -0.01738436f, -0.00057410f, -0.07358173f, -0.02936988f, -0.02089078f, 
    0.02962471f, 0.01126329f, -0.03739272f, -0.05240893f, 0.02819759f, 0.02988611f, -0.03769293f, -0.04631321f, 
    0.01814917f, -0.01172167f, 0.03202928f, 0.00894874f, 0.02339165f, 0.01310864f, -0.00614751f, -0.04691736f, 
    -0.05163702f, 0.04016700f, -0.00733719f, -0.01524282f, -0.04845597f, -0.02760445f, -0.04279214f, -0.04940922f, 
    0.01971080f, 0.01630625f, 0.05230048f, 0.07197870f, -0.06737717f, 0.02066340f, 0.01423576f, -0.05351726f, 
    0.02539403f, -0.03266462f, 0.00130530f, 0.04208168f, 0.01309966f, -0.00121025f, -0.02774313f, 0.05389531f, 
    -0.03927263f, -0.00512536f, -0.04073147f, -0.02647582f, -0.05810503f, -0.01513584f, 0.00594316f, 0.02391291f, 
    -0.05052706f, 0.02006621f, 0.03544413f, 0.00919249f, 0.01223822f, 0.00014065f, -0.04076886f, 0.01902180f, 
    0.01490020f, -0.02270507f, -0.00333860f, -0.01710264f, -0.00452474f, 0.02797196f, -0.05920150f, -0.03524906f, 
    0.02283512f, 0.02150518f, -0.04153015f, -0.00972638f, -0.04532880f, -0.03920655f, -0.03585896f, 0.00229058f, 
    -0.02927041f, -0.06015829f, 0.01131173f, 0.04133238f, -0.03133960f, -0.06276263f, 0.01499279f, -0.02940478f, 
    0.02507840f, -0.03062921f, -0.03492755f, -0.04979054f, -0.04443430f, -0.05647462f, 0.03320079f, 0.01567258f, 
    -0.01524554f, 0.05405238f, -0.02977822f, 0.00429907f, 0.03456658f, -0.03596658f, -0.01006134f, 0.00418877f, 
    -0.00227533f, 0.02861961f, -0.09981089f, -0.03040886f, 0.01301600f, -0.04308603f, 0.05436926f, 0.01214401f, 
    -0.00267486f, 0.02218013f, -0.00886664f, -0.03614932f, 0.03050134f, 0.02874082f, 0.04944011f, 0.02361045f, 
    -0.02316065f, -0.02093546f, -0.02558626f, -0.00117983f, -0.01812762f, 0.01813989f, -0.03716459f, -0.05142018f, 
    -0.01691036f, 0.02773628f, -0.05323594f, -0.01435232f, -0.04078498f, -0.02304018f, 0.00946078f, -0.02343721f, 
    0.03837197f, -0.01553941f, -0.01721343f, -0.00109795f, 0.02170748f, 0.01933235f, -0.02395522f, 0.01833304f, 
    -0.05982466f, -0.06281617f, -0.04644532f, 0.00209234f, -0.00545950f, 0.00131540f, 0.02634145f, 0.01809349f, 
    0.23675755f, 0.15892707f, 0.14389570f, 0.00888140f, -0.08858802f, 0.06166996f, 0.02060848f, 0.04282278f, 
    0.04499344f, -0.06687976f, -0.01103974f, 0.03266139f, 0.21269082f, -0.11365134f, 0.00876170f, 0.13935077f, 
    -0.08741825f, -0.06014600f, 0.03124063f, 0.05419789f, 0.01722472f, 0.11539677f, -0.00031440f, -0.09684369f, 
    0.35906562f, -0.16286524f, -0.17505755f, 0.34957722f, -0.07367914f, -0.07013772f, -0.03829981f, 0.05485428f, 
    0.00073127f, -0.12951733f, -0.03522229f, -0.03290657f, 0.07248810f, -0.10165789f, -0.30377221f, 0.10532278f, 
    -0.00996313f, -0.03650386f, 0.02735403f, 0.01884506f, 0.04989778f, -0.08526187f, 0.03020826f, 0.03666911f, 
    -0.19112916f, -0.12514415f, 0.07198230f, 0.08308033f, 0.07223129f, -0.04187576f, 0.18703814f, 0.01267671f, 
    -0.04508971f, -0.06762120f, 0.05370834f, 0.08667105f, 0.49849808f, -0.08742104f, -0.10160313f, -0.05758036f, 
    -0.07376417f, -0.23251268f, -0.02538297f, 0.06308702f, -0.10294654f, -0.02316675f, -0.01274958f, -0.04327331f, 
    0.04181266f, 0.09878851f, 0.13008843f, -0.20015380f, 0.12447524f, 0.11775752f, -0.03536009f, 0.02022720f, 
    -0.01628885f, -0.02639127f, 0.08194336f, -0.00437992f, 0.33518404f, 0.10561413f, 0.12348426f, 0.03829731f, 
    -0.10401461f, -0.02714435f, 0.00256876f, -0.04918275f, -0.03000774f, 0.04793211f, 0.09164183f, 0.17280674f, 
    -0.18978645f, 0.12502156f, -0.01368718f, -0.12031654f, 0.03370846f, 0.01707757f, -0.06930439f, 0.01573461f, 
    0.00135751f, -0.04946966f, 0.03884854f, -0.03773666f, 0.29634798f, 0.02247937f, 0.16063306f, -0.07776370f, 
    0.00423796f, -0.02517277f, -0.11855469f, -0.06708460f, -0.04260447f, -0.01595400f, -0.05337553f, -0.01099105f, 
    -0.02014180f, 0.40719181f, 0.05567634f, -0.12658991f, 0.05440833f, 0.06342428f, 0.01535306f, -0.07067061f, 
    -0.00149545f, 0.06709016f, -0.13084170f, -0.02941039f, 0.07414656f, 0.06374882f, 0.08303436f, -0.13442975f, 
    -0.09100880f, -0.03532502f, 0.08938849f, 0.05574323f, 0.01684533f, -0.04614529f, -0.09692299f, 0.06668999f, 
    0.30887330f, -0.14985414f, 0.10185619f, 0.35857791f, -0.08334503f, 0.09831260f, 0.07139264f, 0.00848165f, 
    0.03255889f, 0.06185699f, -0.04740695f, 0.01633787f, -0.10665280f, -0.23394020f, -0.01910474f, 0.15074548f, 
    -0.03384629f, 0.02387710f, 0.05937976f, -0.02559899f, -0.07621974f, 0.02361763f, -0.02354354f, 0.00494275f, 
    -0.11721624f, 0.04836509f, -0.05933829f, 0.05402160f, -0.00769109f, -0.04533048f, 0.05632887f, 0.01347196f, 
    0.04423195f, -0.01867343f, -0.01074282f, 0.07845064f, -0.22985232f, 0.04012858f, 0.05051681f, 0.06455520f, 
    -0.09471051f, -0.07785855f, 0.04402571f, 0.05593463f, -0.05429719f, -0.00246215f, 0.03636089f, 0.07914244f, 
    0.03978674f, 0.08177411f, 0.16603854f, -0.17319535f, -0.08389144f, -0.12589559f, 0.00918370f, 0.03496315f, 
    -0.01883079f, -0.04347914f, 0.04500143f, 0.09540267f, 0.51250178f, -0.03686531f, -0.15526076f, 0.24288473f, 
    -0.19376887f, -0.00252990f, 0.02486346f, -0.00342123f, -0.05647513f, -0.00781956f, -0.00384764f, 0.02879760f, 
    -0.22105722f, -0.00000544f, -0.03744635f, -0.00244600f, 0.00217701f, -0.05263804f, 0.01656737f, 0.04777264f, 
    0.02581975f, 0.02660374f, 0.12933838f, 0.12622680f, -0.02569660f, 0.11327149f, 0.04696573f, 0.08218871f, 
    0.06295220f, 0.01237719f, 0.03671870f, -0.04079205f, 0.03874777f, -0.02388222f, 0.04262637f, 0.07712138f, 
    0.35576403f, 0.06525233f, -0.09859528f, -0.16874576f, 0.09740716f, -0.07741845f, -0.28199634f, -0.13277915f, 
    -0.03004993f, 0.22183339f, 0.00882263f, -0.06042882f, -0.24146664f, -0.02026484f, 0.07091463f, -0.12277234f, 
    -0.08323126f, -0.04399348f, 0.01956889f, 0.09402005f, 0.09934436f, -0.00426950f, -0.07205936f, -0.05500224f, 
    0.11582202f, -0.15569597f, 0.26607904f, 0.22156540f, -0.09254312f, 0.05173061f, 0.11557638f, -0.09401841f, 
    -0.01884726f, -0.08395287f, 0.07411741f, 0.01381395f, -0.08002782f, 0.00831269f, 0.06693442f, -0.07217168f, 
    0.05192141f, 0.02025518f, -0.01242301f, -0.00705646f, -0.13746586f, 0.02917751f, 0.00242570f, -0.03636268f, 
    0.23777723f, 0.04757503f, 0.10982941f, 0.30788848f, 0.01893511f, -0.00032121f, 0.01005831f, 0.05705980f, 
    0.00847992f, -0.00676120f, -0.01870664f, 0.04146895f, 0.01485433f, 0.05220868f, 0.07375188f, -0.12801565f, 
    0.11134356f, 0.07602075f, -0.09569731f, 0.03914709f, 0.21749826f, -0.03108026f, -0.05229843f, 0.05812310f, 
    0.01553016f, 0.01281605f, -0.03555068f, 0.21762735f, -0.08894759f, 0.03843350f, 0.05883213f, -0.10963507f, 
    -0.00463877f, -0.01698318f, -0.03331235f, 0.03529773f, 0.36669007f, 0.03208720f, 0.05562394f, 0.12450157f, 
    -0.13799445f, -0.01394713f, 0.06816202f, -0.01970393f, -0.04440189f, 0.08117209f, -0.01075656f, 0.10025462f, 
    -0.07946073f, 0.02256313f, -0.10254486f, -0.17197013f, 0.10736164f, -0.01891561f, -0.00609050f, 0.14643049f, 
    -0.02939249f, -0.07485048f, 0.01526483f, 0.01183224f, -0.32349578f, -0.09428863f, 0.11747830f, 0.13461064f, 
    -0.03482003f, 0.02295344f, 0.05263231f, -0.12391703f, 0.00027453f, -0.10943054f, 0.08934889f, 0.07921488f, 
    0.06637166f, 0.07408291f, 0.01605905f, -0.09996098f, -0.01626652f, -0.01454231f, 0.00420288f, -0.01116473f, 
    0.07304494f, 0.03995370f, -0.03896802f, -0.02993698f, 0.04420946f, 0.17717014f, 0.03670717f, -0.19388755f, 
    0.01834722f, -0.00861004f, -0.04736487f, 0.03645916f, 0.07231967f, -0.04658937f, -0.05597980f, 0.05719736f, 
    -0.04614311f, 0.03980942f, 0.03761810f, -0.05203394f, -0.03684684f, -0.00144243f, 0.04412113f, -0.04987695f, 
    0.03113097f, -0.05150409f, -0.04970165f, -0.00523085f, 0.01930515f, 0.01710877f, -0.04765868f, 0.03307230f, 
    -0.02667609f, -0.03647020f, 0.01846995f, -0.00244194f, -0.02490708f, 0.00627946f, 0.03623907f, 0.03358534f, 
    0.00614147f, 0.02937316f, 0.03263145f, -0.04280205f, 0.03618293f, 0.04322320f, -0.01115707f, 0.01075378f, 
    -0.02139624f, -0.00056753f, -0.02376602f, -0.04145649f, -0.02926877f, 0.00968006f, 0.00532670f, 0.01354758f, 
    0.04816097f, -0.02858858f, -0.01760704f, -0.04681239f, 0.02058255f, -0.02911100f, -0.00564652f, -0.00062815f, 
    -0.00905981f, 0.03080178f, 0.00319927f, -0.05086504f, -0.01045982f, -0.04146302f, 0.00010042f, 0.01793610f, 
    -0.00998848f, 0.00740135f, -0.04043939f, -0.01231561f, -0.00258802f, -0.02574903f, -0.01174022f, -0.04397907f, 
    0.03148896f, -0.02947775f, -0.01502189f, -0.04426610f, -0.02873595f, 0.01283534f, 0.01733047f, 0.02185300f, 
    0.01618817f, 0.02691830f, -0.03491784f, 0.00551446f, 0.00908691f, -0.01143785f, -0.00985884f, -0.00781888f, 
    0.01697496f, -0.04906015f, -0.03851400f, 0.02701053f, -0.02626229f, -0.04785564f, 0.00968167f, 0.03273201f, 
    0.00898040f, -0.01060423f, -0.01335568f, -0.00048757f, -0.03180204f, -0.01789678f, -0.01433799f, -0.02866439f, 
    -0.01606215f, -0.02180843f, -0.04759876f, -0.04196897f, 0.00638289f, -0.01857484f, -0.00962118f, -0.03855130f, 
    0.04146717f, 0.00641582f, -0.01151912f, -0.04497721f, -0.01058775f, -0.05317434f, -0.02543302f, -0.00313117f, 
    0.01380230f, 0.03989309f, -0.05283920f, 0.02077883f, -0.03714596f, -0.05262123f, -0.01766424f, 0.03793200f, 
    -0.05364225f, 0.02993678f, 0.01437674f, -0.02709142f, 0.01474732f, -0.05019649f, -0.05126980f, -0.01761918f, 
    0.00066398f, -0.04904287f, -0.01000131f, -0.01340195f, -0.05085806f, -0.02795824f, 0.01649061f, 0.03699584f, 
    -0.01654477f, 0.00393505f, -0.04029536f, -0.00088078f, -0.00023942f, 0.04118017f, -0.00716905f, 0.00010258f, 
    -0.04420533f, -0.01034141f, 0.02605933f, -0.05491346f, 0.00850658f, 0.03342658f, -0.01831263f, 0.02425276f, 
    -0.01844862f, -0.01442927f, 0.02151346f, -0.01154838f, -0.04513279f, 0.02635423f, -0.03603241f, 0.03032571f, 
    0.01193298f, 0.03197519f, -0.01683809f, 0.00554674f, 0.00745826f, 0.02579343f, 0.04396289f, -0.03086013f, 
    -0.04275006f, 0.01980201f, -0.03114170f, 0.03742062f, -0.02518063f, -0.04779037f, 0.02676428f, -0.05210847f, 
    0.03532967f, 0.04183407f, -0.00458204f, -0.03807370f, -0.04221112f, -0.04181134f, -0.05186529f, 0.00128539f, 
    0.03801244f, 0.03640026f, -0.05122267f, 0.03208770f, -0.05625235f, -0.01742496f, -0.02508654f, 0.04483530f, 
    0.02780408f, -0.04510838f, 0.00238531f, -0.02489751f, 0.03184657f, -0.00882684f, -0.03329663f, 0.02755201f, 
    -0.03803236f, -0.01143195f, -0.00069133f, 0.01348895f, 0.01631987f, 0.01229012f, 0.02860819f, 0.02488974f, 
    0.00976909f, 0.04009251f, 0.04671789f, -0.02440257f, 0.03884885f, -0.01817471f, -0.04864682f, -0.01560533f, 
    -0.00004254f, -0.02486868f, -0.01946736f, 0.02066982f, 0.01479658f, -0.04719146f, -0.03639242f, -0.05130330f, 
    0.03551726f, -0.03953185f, -0.03820259f, -0.04679656f, -0.03048667f, 0.02589287f, -0.03511800f, 0.00248424f, 
    -0.00663679f, -0.03387461f, -0.01468031f, -0.05912777f, 0.03054874f, -0.05263408f, 0.01380012f, -0.05336351f, 
    -0.01272665f, 0.00912849f, -0.01471066f, -0.02259533f, -0.02069077f, 0.00352869f, 0.03011164f, 0.02247073f, 
    -0.02009261f, -0.03864872f, 0.02260614f, 0.02179098f, -0.02749007f, -0.01745403f, 0.04406468f, 0.02707668f, 
    0.04123061f, 0.01158833f, -0.04817563f, 0.01713081f, 0.02031827f, 0.03514874f, 0.03340998f, -0.00566309f, 
    0.03739969f, 0.00697213f, -0.00882620f, 0.02502644f, 0.01545085f, 0.00892869f, -0.00155685f, 0.00364630f, 
    0.03005185f, 0.01295260f, -0.01093159f, -0.05032532f, -0.04409898f, 0.03814142f, -0.00946212f, -0.00626015f, 
    0.02464495f, -0.01526224f, 0.00909487f, 0.03893425f, -0.01327822f, -0.01268854f, 0.01130073f, -0.02277773f, 
    0.01450491f, -0.03757481f, 0.02102941f, -0.02197459f, -0.04806713f, 0.02427548f, -0.02410112f, 0.00449001f, 
    0.00121399f, 0.02891824f, -0.00543546f, -0.02059306f, 0.00930181f, -0.03027294f, -0.05499849f, -0.00854963f, 
    -0.02674957f, 0.00532037f, -0.03584888f, 0.00033832f, -0.03444057f, -0.02557979f, 0.01168436f, -0.03226540f, 
    -0.04702567f, -0.04670838f, 0.03419061f, -0.03452506f, -0.03774526f, 0.01802430f, 0.04144150f, 0.02147497f, 
    0.02728217f, -0.05258064f, -0.02715245f, 0.01423838f, -0.01177288f, -0.05642969f, 0.03653323f, -0.02354093f, 
    0.01314943f, 0.00895195f, -0.04979256f, -0.02357243f, -0.03640933f, 0.00958423f, 0.00548361f, -0.00611241f, 
    0.03372775f, 0.00239873f, 0.01916559f, -0.02462078f, -0.00914023f, -0.05311565f, 0.00314897f, 0.02606106f, 
    0.01846496f, 0.03586308f, 0.00444690f, -0.01714861f, -0.04663803f, -0.01477451f, 0.03699706f, -0.02841732f, 
    0.02019933f, -0.02552685f, 0.01081555f, -0.01992883f, 0.01202078f, -0.02043633f, 0.01009352f, -0.00887052f, 
    -0.00328689f, -0.04460841f, -0.03299512f, -0.03467728f, -0.03530945f, 0.01778432f, -0.03797184f, 0.00868621f, 
    0.03744783f, 0.04469337f, 0.01525636f, 0.00586867f, 0.03152788f, -0.05391931f, -0.03984859f, -0.05150449f, 
    0.01501877f, -0.05087675f, 0.01025975f, -0.05140949f, 0.03119851f, -0.02872330f, -0.04682283f, -0.00966347f, 
    -0.04813854f, -0.17793606f, -0.18071277f, 0.14748275f, 0.02810168f, 0.03798468f, -0.04288385f, 0.04549647f, 
    -0.02440360f, 0.05403684f, 0.06921802f, 0.14240649f, -0.04142262f, -0.03556455f, -0.01913072f, 0.00155073f, 
    0.02368719f, 0.03770720f, -0.08357273f, 0.02595823f, -0.00119610f, -0.06128499f, 0.05573390f, -0.06409568f, 
    -0.04841153f, -0.10781118f, 0.12074614f, -0.08837477f, 0.08675531f, 0.11063500f, -0.00520527f, 0.05349633f, 
    0.11731791f, -0.00450154f, 0.03463099f, 0.09553898f, 0.14042906f, -0.11353294f, 0.23561138f, -0.14953315f, 
    0.05407355f, -0.07677455f, 0.08246312f, -0.04911785f, 0.06413225f, 0.04495858f, 0.01941198f, 0.00080945f, 
    0.04443713f, -0.05912372f, -0.05912954f, -0.08514388f, -0.05828733f, -0.09341858f, -0.01502281f, -0.10737080f, 
    -0.02061312f, 0.06384281f, -0.14047575f, 0.05177572f, -0.16284996f, -0.05463909f, -0.02372538f, 0.09496669f, 
    0.05482945f, 0.08184950f, 0.02964149f, 0.07701252f, 0.06527249f, 0.09167224f, -0.04376385f, 0.16455340f, 
    -0.02328788f, 0.00304178f, 0.06466307f, 0.22531307f, -0.18622111f, 0.05686399f, 0.03065598f, 0.09577065f, 
    0.01477023f, 0.01456283f, -0.11492424f, 0.03665014f, -0.08271957f, 0.00204030f, -0.12024880f, 0.06381196f, 
    0.02104816f, -0.02718041f, -0.10908910f, 0.04181702f, 0.05290405f, 0.07223486f, -0.03217812f, -0.07415653f, 
    -0.01744444f, 0.19813903f, -0.02119132f, 0.30431074f, -0.08047104f, -0.05235856f, 0.11550885f, -0.07662754f, 
    -0.00925003f, 0.08215988f, -0.00997834f, -0.00863761f, -0.07202227f, 0.05807819f, -0.13282485f, 0.18391450f, 
    -0.01326055f, -0.00816923f, -0.01373012f, 0.02566019f, 0.15839168f, 0.01944746f, 0.04156790f, -0.07379325f, 
    -0.03589818f, -0.13219568f, 0.11264849f, 0.04150250f, -0.10403854f, -0.13146712f, 0.02250125f, -0.05041640f, 
    -0.06516594f, -0.07664815f, 0.00974184f, 0.04920329f, 0.11823379f, 0.15175056f, -0.00437440f, -0.04138919f, 
    -0.03977464f, 0.03041748f, -0.00743424f, 0.02179145f, 0.06136270f, 0.06565826f, 0.01805510f, 0.11544448f, 
    -0.15369692f, 0.01463093f, -0.04421673f, 0.08027017f, 0.03779405f, 0.03583272f, -0.01091312f, 0.01160353f, 
    0.06340505f, 0.12634088f, 0.09020703f, 0.06216641f, 0.16070361f, 0.05091198f, 0.01715246f, 0.08050054f, 
    0.04840485f, -0.04554403f, 0.02610360f, -0.06386727f, 0.17063999f, 0.03848076f, -0.10212432f, 0.04008996f, 
    -0.12236230f, 0.28820807f, 0.20288777f, -0.14744259f, 0.02549606f, 0.09334125f, 0.06755549f, -0.03050130f, 
    0.05273711f, 0.07103432f, 0.05425899f, 0.07565592f, 0.05093505f, 0.24857202f, -0.16036674f, 0.05500432f, 
    0.11177406f, 0.01421802f, 0.00249958f, 0.06290715f, 0.10216857f, -0.00841338f, 0.03533291f, -0.04848001f, 
    -0.07085459f, 0.02393341f, -0.23395978f, 0.17632209f, -0.00692435f, 0.14404547f, 0.00721709f, -0.02454572f, 
    0.14498679f, 0.19224599f, 0.02847998f, -0.04851336f, -0.14316578f, 0.08818398f, 0.01304371f, -0.03596215f, 
    0.20674331f, 0.07808629f, -0.02018995f, 0.02647687f, 0.06377599f, -0.04551937f, 0.05341826f, 0.05729859f, 
    0.14563981f, -0.03225205f, -0.05166281f, -0.22358936f, 0.04492127f, -0.02074318f, -0.02258795f, -0.08045151f, 
    0.02086242f, -0.05777002f, -0.03595311f, -0.11958473f, -0.24944828f, -0.06524210f, -0.02192436f, 0.08797243f, 
    0.06035529f, -0.07135529f, 0.00793425f, 0.02911519f, -0.07204480f, 0.08362251f, 0.12565722f, 0.03949532f, 
    -0.25800711f, -0.00070597f, -0.09996867f, -0.01004020f, 0.02928454f, 0.06598788f, 0.04892054f, -0.09349880f, 
    0.08829090f, -0.13519563f, -0.07530948f, 0.01356787f, 0.22112742f, -0.18560369f, 0.03114036f, -0.22254512f, 
    -0.09898793f, 0.16250296f, 0.10880484f, -0.12577559f, -0.08700330f, 0.03198383f, 0.05766938f, 0.09455503f, 
    -0.14245331f, 0.09364422f, -0.05164019f, 0.13734049f, 0.15199083f, -0.06811841f, -0.07054915f, 0.16201402f, 
    0.22666839f, 0.05879532f, 0.09390077f, -0.01696591f, -0.11889019f, 0.05901981f, -0.00622535f, -0.03731224f, 
    0.09256633f, 0.03957076f, 0.06991845f, -0.06273527f, 0.00599607f, -0.14609087f, -0.06692679f, 0.04158211f, 
    -0.01244251f, -0.07922878f, -0.05272248f, 0.05012406f, 0.06084226f, -0.02757378f, -0.07660574f, 0.03101320f, 
    -0.01219617f, 0.00182744f, 0.06101987f, 0.00342343f, 0.28781691f, 0.07889716f, 0.04382862f, 0.24087435f, 
    -0.17075087f, -0.00996700f, 0.00422447f, 0.00628490f, -0.07671707f, 0.08169726f, 0.05859818f, -0.02798634f, 
    -0.00493883f, -0.09069242f, 0.09504271f, 0.01283402f, 0.05697446f, -0.10330027f, 0.02160801f, 0.08607157f, 
    0.00753181f, 0.05426034f, -0.06926914f, 0.02505437f, 0.05515879f, -0.07982136f, -0.05487165f, 0.03017381f, 
    0.15247034f, 0.00625913f, -0.01742869f, -0.02365804f, -0.07705395f, -0.02896389f, -0.04290752f, -0.08161823f, 
    0.03977634f, 0.06852907f, 0.11634491f, 0.08712550f, -0.11900716f, -0.01906335f, 0.00046886f, -0.09535195f, 
    -0.00947598f, 0.02255822f, 0.01900569f, -0.07579689f, 0.03456021f, -0.09153414f, 0.06250390f, -0.05057259f, 
    0.12389188f, -0.02045601f, 0.06258686f, 0.12450137f, 0.02753991f, 0.04842630f, -0.02388162f, -0.04187013f, 
    -0.29627576f, 0.12826203f, -0.14726815f, -0.11065700f, 0.02071350f, 0.07998229f, -0.06051874f, 0.00669252f, 
    0.08445217f, 0.08283489f, 0.06280702f, -0.00386926f, 0.02921766f, -0.03628354f, -0.17045209f, -0.11344050f, 
    -0.09368802f, -0.04183751f, -0.04069132f, -0.03174540f, -0.00077437f, -0.04867527f, 0.08172217f, 0.02509880f, 
    0.02485344f, 0.03101543f, -0.04328445f, 0.03203535f, -0.04449719f, 0.03870201f, -0.01093324f, -0.02450581f, 
    0.03491528f, 0.02390550f, -0.01974145f, 0.00537211f, -0.03130332f, 0.02792946f, -0.00442289f, -0.00379169f, 
    0.00831003f, 0.04140555f, -0.00821989f, -0.05262277f, 0.03689651f, -0.04447074f, 0.03878687f, -0.04075896f, 
    0.00575551f, -0.01870813f, 0.03024080f, 0.03363060f, -0.03027120f, -0.02757974f, 0.00404349f, 0.03716896f, 
    -0.00633694f, 0.04224404f, 0.03299613f, -0.01117889f, -0.01192744f, 0.01721378f, -0.05608717f, 0.01645776f, 
    -0.03093428f, -0.01846584f, 0.00743157f, -0.01887149f, 0.00505257f, 0.01704585f, -0.05640292f, -0.03151422f, 
    -0.05576422f, -0.03555856f, 0.04017960f, -0.02266577f, -0.05461894f, -0.00211947f, -0.03213909f, 0.04323321f, 
    0.01160020f, 0.00398815f, 0.02152407f, 0.03953928f, 0.03050485f, -0.04529108f, 0.01981614f, -0.04360745f, 
    -0.02964566f, -0.05473938f, -0.03389435f, -0.05056989f, 0.01571297f, -0.00462681f, -0.00222174f, 0.02279406f, 
    0.03756053f, -0.00724241f, -0.02884033f, -0.03305220f, 0.00541148f, -0.02473857f, 0.03511080f, 0.00397053f, 
    -0.04651180f, -0.00272932f, 0.04377491f, -0.03315285f, -0.02732259f, -0.05496122f, 0.02556044f, -0.05245244f, 
    0.02220024f, -0.02993887f, -0.02502691f, -0.04561198f, 0.01186098f, -0.01834172f, 0.03219119f, -0.02643209f, 
    0.02747492f, 0.00494618f, 0.01768272f, -0.02175870f, 0.04038192f, 0.03135688f, -0.01575166f, 0.02639216f, 
    0.00315236f, 0.02816635f, -0.00889139f, -0.03549348f, -0.03372516f, -0.01623716f, -0.04034637f, -0.01058017f, 
    0.02024560f, -0.04488109f, 0.03889706f, 0.02056012f, -0.00722540f, 0.03810963f, 0.01501559f, -0.04184834f, 
    -0.03783087f, 0.01160245f, -0.03857801f, 0.02027688f, 0.02456933f, 0.04093421f, 0.01763296f, -0.05881951f, 
    -0.05231499f, -0.04684724f, 0.02659125f, 0.03142790f, 0.02726092f, -0.00460324f, -0.02750857f, -0.03843788f, 
    -0.03216922f, -0.04407156f, -0.00596821f, -0.03978883f, 0.01499677f, 0.01366834f, 0.00278532f, 0.03340191f, 
    0.01795054f, -0.03143202f, 0.00256618f, -0.00930035f, 0.04230614f, 0.00043581f, -0.03447178f, -0.03201699f, 
    0.02356806f, -0.04289809f, -0.02887784f, -0.03354310f, 0.00716213f, -0.00352062f, 0.03677510f, -0.05126342f, 
    0.02717004f, -0.04710122f, -0.03809763f, 0.01091681f, -0.04423726f, -0.02830870f, -0.02637145f, 0.00242097f, 
    -0.00769973f, -0.04505014f, -0.03231005f, 0.03266938f, 0.02709657f, 0.02928343f, 0.03154593f, -0.02867077f, 
    -0.05691574f, -0.04531553f, -0.01158592f, -0.04440441f, -0.05553805f, -0.00612970f, 0.02553173f, 0.00673961f, 
    -0.01967245f, -0.02411819f, -0.03991713f, -0.00247821f, -0.04042101f, 0.01391429f, -0.03077198f, -0.04665061f, 
    -0.02647499f, -0.05064488f, 0.01117062f, -0.00890815f, -0.00244711f, -0.05652189f, -0.04480134f, -0.05044906f, 
    -0.02495319f, 0.03643060f, -0.04707145f, 0.00179635f, 0.01817938f, -0.04198574f, 0.04303100f, -0.03424066f, 
    -0.03752539f, 0.03926614f, -0.01751346f, -0.04856521f, -0.01460940f, 0.04054044f, -0.04518547f, -0.02623616f, 
    0.02560310f, 0.03560469f, 0.03247342f, -0.00350558f, 0.04212962f, -0.04898047f, 0.01162955f, -0.00563141f, 
    0.02874515f, 0.01608816f, -0.03585108f, 0.00169982f, -0.02538173f, 0.00554742f, -0.03017801f, -0.03647025f, 
    -0.02388261f, 0.01054361f, -0.05095562f, -0.04378799f, -0.00511807f, -0.01061974f, 0.00390617f, 0.03162907f, 
    -0.01778428f, 0.00415300f, -0.02732868f, -0.01008646f, -0.00006975f, -0.00971965f, 0.01542100f, -0.01257206f, 
    -0.03532743f, 0.02372501f, 0.01008696f, 0.03410320f, -0.04957736f, 0.00818771f, 0.01111945f, -0.02067780f, 
    -0.05955373f, -0.00502468f, -0.00074334f, -0.01484325f, -0.04825266f, 0.03366287f, -0.05266355f, 0.03821673f, 
    -0.02624428f, 0.01240998f, 0.03086698f, 0.04321799f, -0.02744717f, -0.03916831f, -0.04279785f, -0.01671709f, 
    0.01932272f, -0.02992677f, -0.01802644f, -0.02227528f, -0.03091912f, -0.05094366f, 0.02394805f, 0.01477974f, 
    -0.04530004f, -0.05795762f, -0.04709136f, -0.05573866f, 0.02652822f, -0.03902392f, -0.02016969f, 0.01112622f, 
    0.03199413f, -0.02698139f, -0.04612540f, -0.01673744f, -0.00059904f, 0.00996089f, -0.04931470f, -0.00398627f, 
    0.00751973f, 0.01749175f, 0.04216864f, -0.04729539f, -0.02503895f, -0.03508373f, 0.01993538f, -0.04245812f, 
    0.00532775f, -0.01652213f, -0.00059527f, -0.03476623f, -0.04691099f, 0.02468720f, 0.04036577f, 0.01402196f, 
    -0.00636422f, 0.02524994f, -0.05512033f, -0.03927371f, -0.02719283f, 0.04466295f, -0.00348638f, -0.05610964f, 
    -0.03023656f, -0.03435184f, -0.05883444f, -0.02992746f, -0.03091085f, -0.04683361f, 0.00603496f, -0.04937249f, 
    -0.03316819f, -0.04249515f, -0.01181441f, -0.00381499f, -0.01070439f, 0.04072708f, -0.02876816f, -0.03991286f, 
    -0.05481117f, -0.05446204f, 0.02232625f, 0.00126968f, 0.00114097f, 0.00661420f, -0.05845712f, 0.03767578f, 
    -0.05292143f, 0.04132066f, 0.04012150f, -0.05605329f, -0.04358941f, 0.00784076f, 0.00248644f, 0.02646032f, 
    -0.01023006f, -0.04121644f, 0.00314548f, 0.01876958f, 0.02705234f, 0.01790644f, -0.02192803f, 0.03737737f, 
    0.01585317f, -0.03968276f, -0.03826075f, 0.02541268f, -0.03926218f, 0.02929442f, 0.01439028f, 0.02947765f, 
    -0.04333495f, -0.01412301f, 0.01931273f, -0.02179306f, -0.02814626f, -0.01962125f, 0.02138971f, 0.02634732f, 
    0.00302827f, -0.00749672f, 0.02291391f, -0.02118478f, 0.02391707f, 0.01714771f, -0.02157226f, 0.04017328f, 
    -0.03248759f, 0.02412608f, -0.04984538f, -0.00565912f, -0.03312187f, 0.02926458f, 0.10585821f, -0.02651161f, 
    -0.03921129f, 0.06774480f, -0.01030257f, 0.05891216f, -0.13213585f, 0.02890945f, -0.08236714f, 0.05244013f, 
    -0.04805422f, -0.00814954f, 0.00605333f, 0.00192843f, 0.04701013f, -0.04411943f, 0.05088577f, 0.10839233f, 
    -0.06341714f, 0.20303698f, -0.01227486f, -0.09238335f, -0.04351598f, 0.09497715f, 0.07047824f, 0.06266686f, 
    0.02270603f, -0.05543272f, 0.03851951f, -0.09718744f, -0.19360873f, -0.21898213f, 0.24197274f, 0.00107162f, 
    -0.01512044f, 0.03808926f, 0.05249829f, 0.00572625f, 0.00286177f, 0.03781281f, -0.15545675f, -0.14677449f, 
    0.00613107f, 0.06583515f, 0.07269055f, -0.16847561f, -0.00767320f, 0.02141720f, -0.16201358f, 0.15575564f, 
    0.05361981f, -0.00543529f, -0.15287323f, -0.10191830f, -0.26418748f, 0.17890707f, 0.03745022f, -0.06231197f, 
    0.10147712f, 0.00102393f, -0.03587386f, 0.05587001f, 0.05264732f, 0.03212540f, 0.01419463f, 0.00476315f, 
    -0.33015573f, -0.20713782f, -0.05365410f, 0.21305946f, -0.04613283f, -0.00697079f, -0.04033144f, 0.10047844f, 
    -0.12300052f, -0.03159592f, 0.07110566f, 0.00744508f, -0.24370539f, -0.12342833f, -0.06296936f, -0.05528280f, 
    -0.04332269f, 0.03636517f, 0.09928022f, 0.10115840f, 0.02053953f, 0.07961598f, 0.05222772f, -0.04007443f, 
    -0.00341348f, -0.00087268f, -0.01065810f, 0.22428416f, 0.02136677f, -0.02749912f, 0.12601316f, -0.11278933f, 
    -0.01869935f, -0.01232014f, -0.12253578f, 0.00830828f, 0.13882647f, 0.19871123f, -0.11968400f, 0.13275060f, 
    0.09413998f, 0.11500849f, 0.03615529f, -0.03466568f, 0.02970049f, -0.05348745f, 0.11011112f, 0.05663121f, 
    -0.11492178f, -0.25015032f, -0.12109105f, 0.22531937f, -0.04323769f, -0.09389874f, 0.07493190f, 0.08619044f, 
    -0.05590372f, 0.02472664f, 0.20036781f, 0.07736092f, 0.06100091f, -0.01759420f, 0.01797470f, 0.13932718f, 
    0.02398776f, -0.00984616f, -0.09775324f, 0.03621031f, -0.01994438f, 0.00514251f, 0.02104057f, -0.12575141f, 
    -0.04973999f, 0.16041259f, 0.12676594f, -0.02770026f, 0.11368108f, 0.08425178f, -0.07045814f, 0.03359639f, 
    -0.00318483f, -0.09068508f, 0.02004495f, -0.07758327f, -0.19110303f, 0.05375323f, -0.03519892f, -0.02056501f, 
    0.10204733f, 0.02768918f, -0.03326380f, 0.00159497f, 0.04162532f, -0.09971976f, 0.05669054f, 0.01713655f, 
    -0.07100529f, 0.03891968f, -0.09660298f, -0.02707818f, -0.02070330f, -0.02907895f, 0.01781634f, -0.01286596f, 
    0.04891279f, 0.02997740f, -0.03657758f, -0.19291702f, 0.23441565f, 0.09954216f, 0.07186363f, 0.07654685f, 
    0.01247497f, -0.09109774f, -0.02541581f, 0.02366931f, 0.04362326f, 0.04428468f, 0.11304443f, 0.06520248f, 
    0.06806084f, 0.01028685f, 0.03041815f, 0.24618360f, -0.03880394f, 0.10295344f, -0.03841658f, 0.07838064f, 
    0.05419359f, 0.01022214f, -0.03400624f, 0.02886265f, -0.16221757f, 0.13485500f, 0.04868193f, -0.12866181f, 
    0.12120251f, 0.10726549f, 0.08151345f, 0.05871111f, 0.03779241f, 0.06366721f, 0.09132023f, 0.09860607f, 
    0.02754843f, -0.05532309f, 0.05028036f, 0.06386699f, 0.01071821f, 0.04727751f, -0.03139188f, -0.02746849f, 
    0.06987719f, -0.03116144f, 0.00104844f, -0.00068154f, -0.05606565f, 0.01281105f, 0.13286594f, 0.08430889f, 
    -0.01192186f, -0.03093648f, 0.15240662f, 0.02335296f, -0.04158446f, -0.05466475f, -0.03794889f, -0.02743880f, 
    -0.21575996f, -0.09453546f, 0.16476659f, 0.19101529f, -0.03928850f, 0.15531071f, 0.16266289f, 0.14452912f, 
    -0.01151450f, 0.13097499f, 0.06985171f, 0.16605668f, 0.31574899f, -0.04775368f, 0.15666991f, -0.22798243f, 
    0.02143198f, 0.07272858f, -0.13121288f, 0.05542608f, -0.01271099f, 0.00346243f, -0.00565292f, 0.13825536f, 
    0.29335439f, 0.22385423f, -0.01664397f, 0.03625066f, 0.05347360f, 0.12034497f, 0.01548790f, 0.12603565f, 
    0.04793666f, 0.08280507f, -0.04425760f, 0.17518619f, -0.17826255f, 0.04817829f, -0.05338412f, -0.09535661f, 
    -0.02836904f, -0.11086511f, 0.07161605f, 0.05450895f, 0.02529951f, 0.10830516f, 0.05215470f, 0.09708299f, 
    -0.06827057f, -0.01324222f, 0.00095772f, -0.05684374f, -0.08684763f, -0.06297185f, 0.08045304f, 0.00954103f, 
    -0.04820900f, 0.12289879f, -0.02363337f, -0.08277544f, -0.12789743f, -0.03671885f, 0.01663355f, 0.06223099f, 
    -0.06213741f, -0.02685336f, 0.01971860f, -0.00760419f, -0.06483426f, 0.05092745f, 0.01433816f, -0.01870178f, 
    0.13867269f, -0.00543989f, 0.07478723f, -0.11654696f, -0.05043343f, 0.04396387f, 0.13842781f, 0.19672073f, 
    0.09764008f, 0.12282316f, 0.03068647f, 0.19906473f, -0.10400447f, -0.04096552f, -0.00410179f, -0.04229859f, 
    0.09417041f, 0.01935209f, 0.04670260f, 0.06710117f, 0.00215936f, 0.00636502f, -0.02794014f, -0.01571071f, 
    -0.41356665f, -0.26579571f, 0.14931224f, 0.27899081f, 0.00032364f, 0.01835982f, 0.10194603f, -0.00355623f, 
    -0.03289748f, 0.01857096f, 0.05927865f, 0.10201127f, 0.04772088f, -0.01870287f, -0.03029144f, -0.16900933f, 
    0.06402081f, -0.01610242f, 0.10867878f, -0.06370258f, 0.03406638f, 0.05296754f, -0.12943605f, 0.02487721f, 
    -0.33471218f, 0.22031048f, 0.04780541f, 0.07228786f, 0.04426819f, -0.05524656f, -0.05438410f, -0.05951477f, 
    -0.01270788f, -0.05870612f, 0.07226732f, 0.04923413f, 0.11387083f, -0.03997951f, 0.05108535f, 0.06463873f, 
    0.02964802f, -0.12336054f, 0.09853878f, 0.01581211f, -0.07933497f, 0.18592840f, -0.07123713f, 0.07529642f, 
    -0.03944998f, 0.03334941f, -0.05277205f, -0.02563286f, -0.01570733f, 0.03812618f, 0.00195674f, -0.02840755f, 
    0.02247629f, -0.05457389f, -0.05525816f, 0.03967205f, -0.05636052f, 0.02533964f, 0.01886343f, -0.02492232f, 
    0.01785570f, -0.00343718f, 0.01481938f, 0.04300805f, -0.05343629f, -0.02258923f, -0.05708274f, 0.01253964f, 
    -0.00310567f, 0.01427749f, -0.03571370f, 0.03923197f, 0.01579029f, -0.04207534f, -0.05403138f, 0.02666752f, 
    0.03792377f, -0.01469934f, 0.04104105f, 0.03147240f, -0.00899866f, -0.02058811f, -0.04991800f, -0.02789680f, 
    -0.01923195f, -0.01954625f, 0.02339280f, -0.05689077f, 0.00851758f, -0.00857644f, -0.01179020f, 0.04254379f, 
    -0.00662635f, 0.03510213f, -0.03640668f, -0.02402320f, -0.02171664f, -0.04573303f, -0.05172590f, 0.03150610f, 
    -0.00507949f, 0.00847331f, -0.02112436f, -0.01538991f, 0.03961653f, 0.01781873f, 0.03870414f, -0.02289988f, 
    -0.03105106f, -0.04040644f, 0.00629447f, -0.03813089f, -0.01407299f, 0.02950636f, -0.01205072f, -0.02349838f, 
    -0.03184947f, 0.04025988f, -0.05177089f, -0.04923701f, 0.03123007f, 0.03813259f, -0.00589277f, -0.02119736f, 
    -0.01003337f, -0.00310293f, -0.00870320f, 0.03988481f, 0.00561075f, -0.00879818f, -0.02679316f, -0.00186248f, 
    0.00593631f, 0.00745293f, 0.00862518f, -0.01317768f, -0.05160190f, 0.03634315f, -0.00258118f, 0.02361454f, 
    -0.00249562f, -0.04010134f, 0.03339290f, 0.02661940f, -0.03294966f, 0.01052549f, -0.01673585f, -0.00874047f, 
    -0.03237260f, 0.00451931f, 0.00323369f, 0.00239024f, -0.05197012f, 0.00473799f, 0.03903481f, -0.03123390f, 
    -0.04999393f, -0.02642417f, -0.00760653f, -0.05549246f, -0.03686370f, 0.00484328f, 0.03967929f, -0.02969063f, 
    0.00015648f, 0.03120920f, -0.04689149f, 0.02556034f, 0.02990276f, 0.02932682f, -0.02065462f, 0.03227708f, 
    0.03824014f, -0.04905325f, 0.00582838f, 0.02702516f, -0.00107546f, -0.00298311f, -0.02833711f, -0.02593344f, 
    0.02322676f, -0.01170368f, -0.03326171f, 0.00568007f, 0.00361821f, -0.02559496f, -0.04204739f, 0.00174207f, 
    0.00414254f, 0.03893976f, 0.02838449f, 0.01446602f, -0.04859763f, -0.00428416f, -0.00802721f, -0.01474884f, 
    -0.05199836f, -0.03146668f, -0.00737635f, 0.03235396f, 0.00486554f, 0.00598549f, 0.01283743f, 0.01298136f, 
    0.00598419f, 0.02471803f, 0.00626966f, -0.05652109f, -0.04468420f, 0.01943449f, 0.00767564f, 0.01190628f, 
    0.01790057f, -0.00411603f, -0.05389114f, -0.00751276f, 0.03715071f, -0.02335737f, -0.01979524f, -0.04752415f, 
    0.01085998f, 0.01160522f, -0.05104181f, -0.02266470f, 0.03291694f, 0.02326783f, 0.01432547f, 0.02004302f, 
    -0.00517005f, -0.01292405f, -0.05458983f, 0.02778689f, -0.02666811f, -0.00659317f, 0.01887805f, 0.02404719f, 
    -0.03359003f, 0.01520788f, -0.01091373f, 0.03095640f, -0.04067109f, -0.01066584f, 0.03792550f, 0.04313906f, 
    -0.00929937f, -0.05824587f, -0.01576301f, 0.03439839f, -0.02985109f, -0.05450842f, -0.02651108f, 0.00732442f, 
    -0.05766954f, 0.01327147f, 0.03997357f, -0.00689837f, -0.04799251f, -0.00336494f, 0.02577479f, -0.01178355f, 
    0.04419567f, 0.02455088f, -0.05391804f, -0.02382133f, -0.05648248f, -0.03190285f, 0.00566590f, -0.03483269f, 
    -0.05687590f, 0.01011933f, -0.05259904f, -0.05881029f, 0.01171938f, 0.04002082f, 0.02542547f, 0.00025355f, 
    -0.04469748f, -0.01403724f, 0.02298426f, -0.00804349f, -0.05580649f, -0.03507150f, -0.01958125f, 0.01928737f, 
    -0.04155518f, -0.04244154f, -0.03196612f, 0.01973193f, 0.03279236f, 0.01361289f, -0.04823325f, -0.02096524f, 
    0.00675203f, -0.02045151f, -0.01856636f, -0.02599749f, 0.02810962f, -0.04141399f, 0.01173147f, 0.02724500f, 
    -0.04383779f, 0.02961412f, -0.04020705f, 0.03905153f, -0.05253099f, -0.00694270f, -0.00086161f, -0.01454379f, 
    -0.02624410f, -0.03528222f, 0.01688227f, -0.00110989f, 0.00317149f, -0.02177502f, 0.03619301f, -0.04112387f, 
    -0.00253294f, -0.03258819f, 0.03780784f, -0.03517055f, -0.01867834f, 0.03483557f, 0.02569269f, -0.03240668f, 
    -0.00610184f, -0.02993578f, -0.01966007f, 0.00626811f, 0.00804616f, -0.05972894f, -0.05041415f, -0.00537190f, 
    -0.03429674f, -0.05834708f, -0.05959564f, -0.05914192f, 0.00039422f, -0.04776343f, 0.01326257f, -0.03492404f, 
    -0.00259181f, 0.03283779f, -0.03036707f, -0.00206231f, -0.01526693f, -0.04285587f, 0.01809626f, -0.01858571f, 
    -0.05250141f, -0.03124607f, -0.00587036f, -0.03097663f, -0.02601895f, 0.03307403f, 0.01519878f, -0.00489002f, 
    -0.00241770f, 0.02322904f, -0.05565047f, -0.05610250f, 0.04230090f, -0.00669311f, -0.05943029f, 0.01264833f, 
    -0.01818711f, -0.02362972f, 0.00979637f, 0.03438849f, 0.02076692f, -0.02204845f, 0.02800664f, -0.02615968f, 
    -0.00444826f, -0.02623502f, -0.02372937f, 0.03525699f, -0.04992207f, 0.03144479f, 0.02785633f, -0.05867494f, 
    0.01179782f, 0.00996320f, 0.02148400f, 0.02214224f, -0.02087390f, -0.03087585f, -0.01226902f, -0.03379117f, 
    0.01596404f, 0.00085515f, -0.00273369f, 0.03862738f, -0.00677798f, 0.00528305f, 0.02256093f, -0.05662139f, 
    0.01842872f, -0.02013055f, 0.00121340f, -0.04552355f, -0.01713619f, -0.03961959f, 0.02944378f, 0.01173471f, 
    -0.00453024f, -0.03708027f, 0.03434161f, -0.04594757f, -0.03602491f, 0.00107932f, -0.05690084f, 0.03938337f, 
    -0.01839287f, 0.01181189f, -0.01339778f, -0.00003186f, -0.01356091f, -0.02948272f, 0.04196943f, 0.02570578f, 
    -0.02801518f, -0.02266976f, -0.02725971f, 0.00451412f, -0.02943657f, 0.00959736f, 0.00299497f, -0.01811432f, 
    0.10921098f, 0.19463156f, -0.00193734f, 0.00437279f, 0.00146306f, -0.02110255f, 0.01362202f, 0.04962540f, 
    -0.02122403f, -0.02016913f, -0.05156099f, -0.01169360f, -0.03545803f, 0.11715458f, -0.00707624f, -0.08215867f, 
    0.03082427f, -0.03839664f, 0.05642077f, -0.03090345f, 0.08477160f, -0.05221966f, 0.01635381f, 0.12851289f, 
    -0.13539062f, 0.22552273f, -0.03895819f, -0.11400213f, -0.01725620f, 0.06347015f, 0.08724578f, -0.03977581f, 
    -0.12184345f, -0.00812984f, 0.03363432f, -0.07555777f, 0.02173581f, -0.04600456f, 0.06733985f, -0.04509358f, 
    0.01139060f, 0.04058774f, -0.02743612f, 0.05437301f, -0.05550680f, -0.04066109f, -0.12195406f, -0.10097393f, 
    0.15481985f, 0.00656725f, 0.08133974f, 0.01651488f, 0.00264592f, 0.05915844f, 0.03291268f, 0.11036985f, 
    0.10722702f, -0.04617151f, 0.00624279f, -0.13747580f, -0.10266503f, 0.26339883f, 0.11867630f, -0.01814863f, 
    -0.01732372f, 0.07064322f, 0.00807375f, -0.05590370f, 0.01702020f, -0.05526494f, 0.06120094f, -0.11062247f, 
    -0.24116005f, -0.09496671f, -0.11211891f, -0.00768303f, 0.11237276f, -0.04194268f, 0.02747808f, -0.06028665f, 
    -0.01454556f, 0.02277311f, 0.11672747f, 0.03097885f, -0.08629349f, 0.14277440f, 0.06200992f, -0.02485568f, 
    -0.07778202f, 0.01733000f, 0.07751339f, -0.03799722f, -0.05077874f, -0.01472994f, -0.04621890f, 0.01691542f, 
    0.06099574f, -0.23853128f, 0.04019913f, 0.02962329f, 0.06898663f, 0.04641276f, -0.02466295f, -0.02548902f, 
    -0.10668726f, -0.00933021f, -0.06346063f, 0.14737579f, 0.08991217f, 0.10939257f, 0.04623991f, -0.22657585f, 
    0.02938496f, 0.10613243f, -0.02333136f, -0.01741578f, -0.10647651f, -0.08968420f, 0.07474452f, 0.04747317f, 
    -0.19347875f, -0.07719895f, -0.11564297f, 0.04307307f, 0.06117426f, -0.01835163f, 0.11568595f, 0.15162951f, 
    -0.03143616f, -0.02116413f, 0.16513050f, 0.07214887f, 0.02738944f, -0.16361725f, -0.09746327f, 0.33250982f, 
    0.07163836f, 0.01778522f, -0.13137452f, 0.04175323f, 0.01345573f, -0.04589356f, 0.03520320f, -0.06098454f, 
    -0.06139024f, 0.10674745f, 0.14959793f, -0.01594619f, 0.08266287f, 0.03815511f, -0.01537316f, -0.05807510f, 
    -0.03347097f, -0.10624990f, -0.01508463f, -0.06015260f, -0.17367198f, 0.06921115f, -0.12722000f, -0.10423214f, 
    0.01717452f, 0.12505870f, -0.09525476f, 0.02278063f, -0.03125855f, -0.05862329f, -0.01075058f, -0.10539599f, 
    0.21779719f, -0.06324828f, -0.08834502f, 0.07882662f, -0.11056403f, -0.08582222f, -0.04402075f, -0.05427895f, 
    0.01982026f, 0.02868993f, -0.01512858f, -0.14211109f, 0.39620835f, -0.20104957f, 0.06599934f, 0.24516986f, 
    -0.04947386f, -0.03211687f, -0.02704329f, -0.03368362f, -0.10610638f, 0.02794092f, -0.03043788f, 0.08339779f, 
    0.04432951f, -0.00993305f, -0.02134648f, -0.07357655f, -0.01222114f, -0.02963649f, -0.06508236f, -0.01173816f, 
    0.00641008f, -0.05963415f, -0.06795024f, 0.04535352f, -0.03465607f, 0.10336322f, 0.13045713f, -0.12515335f, 
    -0.06888657f, -0.03303213f, 0.00412593f, 0.03846073f, -0.01199085f, 0.04969578f, 0.02204438f, 0.05155227f, 
    -0.01708653f, -0.00650193f, 0.02200499f, 0.13291049f, 0.01116991f, 0.02616632f, -0.00725935f, -0.08964171f, 
    0.00957620f, -0.03847947f, 0.00546983f, 0.01490330f, 0.29405805f, -0.04547766f, 0.20915559f, 0.04064592f, 
    -0.04826062f, -0.06166488f, 0.06045489f, -0.00194666f, 0.01700532f, -0.01129328f, -0.12956209f, -0.00943497f, 
    0.06575318f, -0.03800488f, 0.11461326f, 0.29372492f, 0.02232579f, 0.01460074f, 0.10796441f, 0.10887443f, 
    0.05471853f, 0.12493813f, -0.02810954f, 0.06857330f, 0.24600372f, 0.15469414f, -0.03467802f, 0.16529225f, 
    0.15705547f, -0.04487989f, -0.20114911f, 0.01564070f, 0.06343797f, 0.00786807f, -0.00678495f, 0.02396370f, 
    0.38333222f, 0.07259899f, 0.02604689f, 0.11299507f, 0.00949899f, 0.10873844f, 0.12044172f, -0.09456670f, 
    -0.10789873f, 0.03766813f, -0.03425407f, 0.06115764f, 0.05484465f, -0.00630079f, -0.06404722f, -0.02270024f, 
    0.00536257f, -0.01887695f, 0.00836568f, -0.01670751f, 0.03905976f, 0.09436718f, 0.01612184f, 0.07421368f, 
    -0.06642025f, 0.14328787f, 0.17842260f, -0.12751155f, -0.04778104f, 0.00560693f, 0.10068608f, -0.06542800f, 
    -0.06521957f, -0.03303892f, 0.01293726f, 0.00202099f, -0.36318314f, 0.02295051f, -0.02364781f, 0.07031667f, 
    0.11304370f, -0.00613242f, 0.06238173f, 0.03498188f, 0.03700763f, -0.01362459f, 0.14274596f, 0.04278096f, 
    0.13967422f, 0.08215178f, 0.11503518f, -0.22531685f, 0.01729172f, 0.08061896f, 0.00699087f, 0.00514229f, 
    0.06548452f, 0.06680308f, 0.04157203f, -0.01247686f, -0.17289402f, 0.09736906f, 0.25451255f, -0.17005014f, 
    -0.05009576f, 0.02597382f, -0.00615397f, 0.03960692f, -0.01222769f, 0.02095530f, 0.04642899f, -0.03522954f, 
    -0.12014835f, -0.18701419f, -0.17477685f, 0.24259648f, 0.13805437f, -0.01714983f, 0.01278451f, 0.00428596f, 
    -0.05978354f, 0.10536207f, 0.09956788f, 0.07242148f, 0.18523739f, -0.01434161f, 0.01914934f, -0.07223232f, 
    -0.02922852f, 0.06267016f, 0.07279211f, -0.08396257f, 0.04304353f, 0.03100467f, 0.06158812f, -0.01316996f, 
    0.18604980f, -0.02436031f, 0.10236590f, 0.21380164f, 0.07022430f, -0.06805404f, 0.01543305f, -0.00987133f, 
    0.01937178f, -0.06478228f, -0.06699076f, 0.10340042f, -0.04772482f, 0.08910973f, 0.02061241f, 0.19753496f, 
    0.09530472f, -0.08924771f, 0.09618201f, 0.02628391f, -0.01725396f, 0.09702841f, 0.02947515f, -0.08158025f, 
    -0.15627721f, 0.15779330f, 0.06540036f, 0.01385360f, -0.02106072f, -0.05304898f, -0.00765872f, -0.03935352f, 
    -0.01888438f, 0.06022551f, 0.01682957f, -0.10207681f, -0.00045158f, -0.01326947f, -0.11906315f, -0.03535921f, 
    0.07058425f, 0.07768469f, 0.04287425f, -0.07151730f, -0.02755840f, -0.03484276f, 0.04518850f, 0.05139241f, 
    -0.08432575f, -0.17405990f, 0.08051907f, -0.09046946f, 0.11202069f, -0.06231348f, 0.08853114f, -0.00331312f, 
    0.00362541f, 0.12626393f, 0.05385252f, 0.03029317f, -0.20716526f, 0.19528544f, -0.17175680f, 0.11018564f, 
    0.02151191f, 0.05810992f, -0.00490910f, -0.03644801f, -0.06076941f, -0.01158862f, 0.12600000f, 0.05566553f, 
    -0.04648260f, 0.19738795f, -0.05252938f, 0.23091215f, 0.02838986f, 0.11419389f, -0.07637344f, 0.00007934f, 
    0.01909739f, 0.02836406f, 0.10512857f, 0.03797631f, -0.11931172f, -0.05109275f, -0.05077460f, -0.01840563f, 
    0.07455597f, 0.04106226f, -0.08211368f, -0.02299119f, -0.02779367f, -0.07410994f, 0.07897704f, 0.01821231f, 
    0.16233094f, 0.06371318f, 0.16141729f, 0.05509245f, 0.05829063f, -0.10701474f, 0.08885062f, 0.03973011f, 
    0.13956361f, 0.05615143f, 0.06639284f, -0.00823500f, -0.00811635f, -0.19104372f, -0.05398393f, 0.04577937f, 
    0.03325893f, 0.14768314f, 0.04259226f, 0.01380113f, 0.05276572f, -0.12872037f, 0.01326003f, -0.11425087f, 
    0.17368335f, -0.17867567f, 0.09725656f, -0.08911335f, 0.07714583f, 0.03603658f, -0.06044878f, 0.20508258f, 
    -0.06518123f, 0.13829486f, 0.11103768f, -0.05689735f, -0.18760943f, 0.06152161f, 0.00434681f, 0.09855556f, 
    0.02247884f, 0.02023522f, 0.12485773f, -0.03646756f, -0.10987934f, 0.15381932f, -0.10880627f, 0.07961681f, 
    0.35200241f, -0.01938290f, -0.05696170f, 0.14317048f, 0.08777580f, 0.00664495f, -0.05386497f, 0.19005167f, 
    -0.02507220f, 0.02133043f, 0.10085595f, -0.07306708f, 0.06562847f, 0.13744989f, -0.00359272f, -0.02498571f, 
    0.02209904f, -0.00372371f, 0.00650655f, 0.01729333f, 0.01087464f, 0.03357141f, 0.03144426f, -0.01446268f, 
    -0.20916207f, -0.16599973f, -0.19982317f, -0.21367171f, -0.05609361f, 0.00656871f, -0.01303442f, 0.05117866f, 
    -0.03600993f, 0.03833910f, -0.03799712f, 0.00450745f, -0.04705514f, 0.27576214f, -0.13877231f, 0.00284224f, 
    0.06305648f, -0.07436613f, -0.01226419f, -0.05316123f, -0.06095158f, 0.03193587f, 0.05172639f, 0.03277922f, 
    0.44295141f, -0.11632939f, 0.07113408f, 0.17939724f, -0.00879108f, 0.05001168f, -0.01174700f, -0.00228265f, 
    -0.01622012f, 0.04448201f, 0.06706615f, 0.01912195f, -0.03538920f, -0.00606349f, 0.07717720f, -0.28713876f, 
    0.05182169f, 0.11301345f, -0.09515230f, -0.01399558f, -0.00667376f, 0.01204881f, -0.00858307f, -0.00895854f, 
    0.00213124f, 0.06264750f, 0.04354691f, -0.14290795f, 0.05024846f, 0.14366862f, 0.11461923f, 0.01212425f, 
    0.01698994f, 0.02511136f, -0.04978237f, -0.06994706f, -0.12489987f, -0.18824019f, 0.04961192f, -0.04318408f, 
    -0.03869625f, -0.02156020f, 0.02651711f, -0.02014240f, 0.00510774f, 0.02787301f, -0.09708954f, -0.05307812f, 
    0.20618075f, 0.16409443f, 0.00557054f, 0.11048045f, 0.02270296f, 0.04306018f, 0.04669695f, 0.03796834f, 
    0.09950939f, 0.02312934f, 0.09419438f, 0.00676005f, 0.14308448f, -0.16368379f, -0.14377072f, -0.11290804f, 
    -0.09696139f, 0.11905295f, 0.01750262f, -0.04340336f, -0.01637498f, 0.09340978f, -0.05908596f, -0.02625740f, 
    -0.03135884f, 0.05230590f, 0.15462227f, -0.01261816f, 0.02485472f, 0.04937403f, 0.04914566f, 0.07831375f, 
    0.05102013f, -0.05857533f, 0.03784927f, 0.00119074f, 0.01082465f, 0.08690263f, -0.06440639f, 0.22596897f, 
    0.16177402f, 0.01384912f, 0.13531755f, 0.00578451f, -0.03228407f, -0.05247941f, 0.02061161f, 0.04579414f, 
    -0.03495548f, 0.14290458f, -0.18250130f, -0.20332953f, 0.05650257f, -0.12659496f, -0.05740271f, -0.01133719f, 
    0.03449830f, 0.04380461f, 0.05723353f, -0.02847271f, 0.16493572f, 0.03509815f, 0.07699610f, 0.15681389f, 
    -0.05476124f, 0.05006963f, -0.01728166f, -0.02309392f, 0.11447835f, 0.16247049f, 0.03455434f, -0.02925304f, 
    -0.17464472f, -0.05328486f, -0.14313124f, 0.02848241f, 0.03855374f, 0.08371560f, -0.04648537f, -0.04350795f, 
    0.09795481f, -0.00062659f, 0.08401041f, 0.09170417f, -0.10336061f, 0.18739282f, 0.08052868f, 0.00165635f, 
    0.02120577f, -0.07405867f, -0.04844010f, 0.10424852f, 0.01452982f, -0.02788137f, 0.03827550f, 0.01991250f, 
    -0.11567396f, 0.00221462f, -0.05613613f, 0.02789449f, 0.02745072f, -0.06819727f, -0.01228049f, -0.09057940f, 
    -0.02899333f, -0.01116582f, 0.09737670f, -0.02278605f, -0.16739579f, -0.06126009f, -0.14478140f, 0.03848562f, 
    0.08353040f, 0.04481762f, -0.01019936f, -0.04133992f, 0.10403587f, -0.04923063f, 0.12761030f, 0.00245275f, 
    0.37110668f, 0.08286380f, 0.19751789f, -0.04102910f, -0.08004367f, 0.11531683f, 0.06337905f, 0.00912918f, 
    0.01369479f, 0.01578954f, -0.03964415f, -0.06753448f, 0.18822399f, 0.18439026f, -0.03596110f, 0.07887374f, 
    -0.04862389f, -0.11669106f, 0.04296793f, 0.01484017f, 0.00804274f, -0.01411463f, 0.01402572f, -0.03644645f, 
    0.08123581f, -0.11400200f, -0.15171471f, 0.24677004f, 0.08613798f, 0.08757862f, 0.04894464f, 0.03871602f, 
    -0.07516693f, 0.13020982f, -0.01382503f, -0.00572476f, -0.08303900f, 0.00905942f, 0.03324917f, -0.01560479f, 
    -0.06265455f, 0.05805445f, 0.13883616f, 0.18460581f, -0.08999630f, -0.13538554f, -0.09504145f, 0.03408714f, 
    0.02202535f, -0.02512454f, 0.00581269f, -0.03196957f, -0.03064963f, -0.00264393f, -0.02591387f, 0.01808000f, 
    0.04989704f, 0.03697253f, 0.00054832f, 0.00587308f, 0.01174894f, 0.03332192f, -0.05523187f, -0.05911955f, 
    0.03777443f, 0.00489020f, -0.04772258f, -0.03502632f, -0.01252768f, 0.03367868f, 0.02187426f, 0.04214099f, 
    -0.04000643f, 0.03468714f, -0.04546750f, 0.02355806f, -0.03498797f, -0.03172414f, -0.00858544f, -0.04331641f, 
    0.03386344f, 0.04501581f, -0.03458394f, 0.00297574f, 0.02157135f, 0.01044495f, -0.05348989f, 0.03213477f, 
    -0.01329524f, -0.01283590f, -0.03381713f, -0.04151187f, -0.00982016f, -0.03296080f, 0.00574665f, -0.00413918f, 
    -0.03903636f, -0.00172130f, -0.05221081f, 0.00710777f, -0.00130941f, -0.02934659f, -0.04310540f, 0.00000977f, 
    -0.03610021f, 0.02459780f, -0.00705743f, -0.03710065f, 0.02511141f, -0.04425497f, -0.05016644f, -0.04220140f, 
    -0.05551984f, 0.00220123f, -0.00430053f, 0.02922543f, 0.01773530f, 0.01470190f, 0.01800800f, 0.04267886f, 
    -0.03398106f, -0.02941122f, 0.03807080f, -0.02562385f, -0.03002610f, 0.03274933f, -0.03892418f, -0.04150604f, 
    -0.04900474f, -0.01402722f, -0.04276575f, 0.01352035f, -0.05151894f, -0.04409062f, -0.01213754f, -0.02949899f, 
    0.02891332f, -0.02018404f, 0.03758027f, -0.01135573f, -0.00114537f, -0.03930868f, -0.04741138f, -0.01790502f, 
    0.03168134f, -0.04439848f, 0.01196100f, 0.00135135f, 0.00949941f, -0.05142803f, -0.05490201f, 0.01351033f, 
    -0.01354299f, -0.02630023f, 0.00337742f, -0.00408903f, -0.02354239f, 0.00242678f, -0.05011091f, -0.04681938f, 
    -0.02900765f, -0.04179569f, -0.03438143f, -0.04633205f, -0.01627421f, 0.01501229f, -0.01110386f, 0.04069417f, 
    -0.00918785f, 0.00038673f, -0.02924285f, 0.03078875f, -0.05095190f, 0.02305922f, -0.03092460f, 0.03227690f, 
    -0.03549346f, -0.01457262f, -0.03530318f, 0.03875988f, -0.00478085f, -0.00253330f, 0.00482011f, 0.03853719f, 
    -0.03521705f, -0.00471040f, -0.01722650f, -0.00112128f, 0.03577872f, 0.02810702f, -0.01732013f, -0.05525745f, 
    0.02527489f, 0.01902891f, -0.00681496f, -0.01519103f, -0.04313717f, -0.05509334f, 0.00608766f, -0.03640838f, 
    0.03065055f, 0.02077219f, -0.01592296f, 0.02778458f, -0.04003206f, 0.03761914f, -0.05113485f, -0.01921309f, 
    -0.03514132f, -0.00153639f, 0.02717626f, -0.03068938f, -0.02916266f, 0.04159914f, 0.00406917f, 0.00551877f, 
    0.02161205f, 0.00162106f, -0.00151721f, -0.00377619f, -0.05404976f, -0.01962875f, 0.03068941f, 0.00973274f, 
    -0.04390621f, -0.03102199f, -0.01378524f, 0.04058989f, -0.01141800f, 0.03786542f, -0.05030862f, 0.02304258f, 
    0.02164337f, -0.05247915f, 0.01032075f, 0.02313213f, 0.02059371f, -0.05469004f, 0.00056639f, -0.00842630f, 
    0.01085243f, -0.02137945f, 0.03370870f, 0.01672943f, 0.01532235f, -0.02235460f, -0.05607169f, -0.02841367f, 
    0.01563117f, -0.02830880f, 0.02243171f, -0.03447035f, 0.02329553f, 0.03671348f, -0.01794226f, -0.00108074f, 
    0.01226448f, -0.00002377f, -0.02136115f, -0.03385485f, -0.02685005f, -0.02372259f, 0.03293298f, 0.02380206f, 
    0.00589720f, 0.04572565f, -0.03684603f, -0.03572183f, 0.00115177f, 0.02231756f, -0.00976531f, 0.00457242f, 
    0.02359222f, -0.01655059f, 0.03486818f, -0.03400312f, 0.01196752f, -0.00550936f, -0.05915149f, -0.05282817f, 
    0.01416361f, -0.04556972f, -0.00422297f, 0.00976504f, 0.02205045f, -0.00157764f, -0.04018982f, -0.05434149f, 
    0.04589798f, 0.02662784f, -0.03139100f, -0.04335047f, -0.03708092f, -0.04300387f, 0.03637527f, -0.04595886f, 
    -0.02345733f, -0.02859254f, -0.00826278f, -0.04712755f, 0.00591121f, -0.03059470f, 0.00376604f, 0.04376131f, 
    -0.03399636f, -0.01052039f, 0.00152499f, -0.00466777f, -0.02722118f, 0.01961304f, -0.01862757f, 0.04469424f, 
    -0.02031689f, 0.00100203f, 0.02092484f, -0.01731331f, -0.05678958f, 0.02725226f, -0.01578239f, 0.04493270f, 
    -0.01658845f, 0.02245680f, -0.03466587f, 0.00745203f, -0.03263117f, 0.00888095f, -0.05406682f, 0.01780664f, 
    -0.05466680f, 0.00758105f, -0.00541859f, -0.01757227f, -0.00851367f, 0.01014622f, -0.01128743f, 0.03114862f, 
    0.04043345f, 0.03076123f, 0.00297532f, -0.04318180f, -0.05198243f, -0.01306843f, -0.02595463f, 0.00272802f, 
    -0.00329118f, -0.04455845f, 0.02643726f, 0.03143192f, -0.05428298f, -0.04180760f, 0.02740038f, 0.01804787f, 
    -0.05249176f, -0.00358597f, -0.03827989f, 0.00988290f, 0.04444369f, 0.03027729f, -0.00695895f, 0.00562497f, 
    -0.00004269f, -0.00947540f, 0.02056695f, 0.00106322f, 0.02310886f, 0.03938841f, 0.03438943f, -0.02090073f, 
    0.04069411f, -0.01392108f, -0.03473875f, -0.04229946f, -0.02698164f, 0.01383729f, -0.00781183f, 0.01563285f, 
    -0.04351644f, 0.01530633f, -0.05823438f, -0.01420928f, 0.02848007f, -0.03193007f, 0.04050930f, 0.02513272f, 
    -0.05456389f, -0.02368461f, 0.00284560f, -0.02826840f, -0.00666379f, 0.00488232f, -0.05223979f, -0.02303461f, 
    0.02870965f, -0.03511438f, -0.04080133f, 0.03154669f, -0.03744046f, -0.04699740f, 0.03374211f, 0.03051253f, 
    0.04275394f, -0.01925467f, -0.01109562f, -0.02522894f, 0.00060330f, 0.01132443f, -0.03860280f, -0.00949434f, 
    -0.00071367f, 0.02104434f, -0.00643930f, -0.00406874f, -0.00302898f, 0.04123459f, -0.02365874f, -0.02422920f, 
    0.04514471f, 0.01678442f, -0.01809900f, -0.01874357f, 0.04884762f, 0.02881319f, 0.01956260f, 0.03401361f, 
    -0.02693969f, 0.04201779f, 0.02914324f, -0.01863849f, 0.01022994f, -0.00760787f, 0.02565441f, 0.04675457f, 
    -0.01021943f, 0.03247542f, -0.00117537f, -0.02980480f, -0.03607501f, 0.04212531f, -0.04742377f, -0.00283907f, 
    0.01149353f, -0.01802814f, 0.02617987f, -0.04780304f, -0.01036109f, 0.02282023f, 0.01225929f, 0.00382071f, 
    -0.03692133f, -0.02288512f, -0.00506967f, -0.01612742f, -0.04328266f, -0.03401475f, -0.02109236f, -0.03622663f, 
    -0.03407793f, 0.01704048f, 0.04351371f, 0.02953012f, -0.02628828f, -0.02119859f, -0.01788202f, -0.04134824f, 
    0.02604715f, -0.00577756f, -0.03827908f, 0.00385650f, 0.02518654f, 0.01783613f, -0.02245105f, -0.03180350f, 
    -0.03806986f, 0.03896374f, -0.05160772f, 0.04388388f, 0.00772463f, -0.02342983f, 0.00368659f, -0.05067897f, 
    -0.03204841f, -0.01416452f, 0.02330247f, 0.01314219f, -0.04707669f, -0.01747015f, -0.04139093f, 0.02056964f, 
    -0.04691085f, 0.00965984f, -0.00789806f, -0.01994002f, 0.04631604f, -0.01544624f, 0.02652369f, -0.02758543f, 
    -0.02727206f, -0.00587173f, 0.02698637f, 0.02316104f, -0.02049924f, 0.02211399f, 0.01577024f, 0.03621641f, 
    -0.03311343f, 0.03847676f, -0.02470113f, -0.02024349f, -0.02031718f, -0.03203240f, -0.02967569f, 0.00845525f, 
    -0.03215576f, 0.01526167f, -0.05456077f, -0.06001319f, 0.02186803f, -0.00386453f, 0.04939795f, -0.03075056f, 
    0.01235700f, 0.02909433f, 0.02548780f, -0.04477553f, -0.05067907f, 0.01463033f, 0.02388411f, 0.02293478f, 
    -0.04397668f, -0.01537584f, 0.00752491f, -0.00809399f, 0.03965633f, 0.00209754f, -0.00932583f, -0.02214860f, 
    0.03692322f, 0.01050366f, 0.02533355f, 0.03486611f, -0.05293787f, -0.04728129f, -0.03927772f, -0.02583414f, 
    -0.05623771f, -0.00862851f, -0.02165935f, 0.01407157f, 0.03894088f, 0.04243563f, 0.03780768f, -0.03668905f, 
    0.00802961f, 0.02051057f, -0.00479103f, 0.03366113f, 0.03872605f, -0.05382621f, -0.04453076f, -0.02767357f, 
    -0.03346927f, -0.00511970f, 0.00011025f, -0.03023205f, -0.04086083f, -0.04392940f, 0.02389361f, 0.00812832f, 
    0.00491326f, -0.01721620f, -0.03271871f, 0.04757917f, 0.01825732f, -0.01571826f, -0.04540496f, 0.01447317f, 
    -0.00218686f, -0.03979238f, -0.01259603f, -0.04688959f, -0.03391847f, -0.02670740f, -0.00846852f, -0.00808884f, 
    -0.02154622f, 0.01081032f, -0.01476171f, -0.00524417f, 0.00153490f, -0.01795695f, -0.03385157f, -0.03980539f, 
    -0.02791296f, -0.03745063f, 0.00095551f, 0.04537965f, 0.01931967f, -0.04319176f, -0.04277882f, -0.00291016f, 
    0.01979925f, 0.03160949f, 0.01527930f, -0.02997182f, 0.03342723f, 0.01793000f, -0.05063278f, 0.01885464f, 
    0.04713591f, 0.01191538f, -0.05069460f, -0.03129161f, 0.01699549f, 0.00065028f, -0.02519102f, 0.00303253f, 
    -0.04832737f, -0.04183742f, -0.04481240f, 0.02552792f, 0.02612216f, -0.05567919f, -0.00972015f, 0.01110607f, 
    0.01928283f, 0.02170278f, -0.01261268f, -0.02488451f, -0.04794433f, 0.02666491f, 0.00740533f, 0.02257078f, 
    0.00028241f, -0.01442218f, 0.03085468f, 0.04023472f, -0.03349694f, -0.03967627f, 0.01391471f, -0.02044535f, 
    0.01468042f, -0.02116478f, 0.02807741f, -0.02347383f, -0.02601143f, 0.03138593f, 0.01774569f, 0.04582925f, 
    0.03845892f, -0.05274003f, 0.00091457f, -0.02021514f, -0.04020669f, -0.02763961f, -0.01215658f, -0.00844890f, 
    -0.03476487f, -0.02770405f, -0.00768077f, -0.02107022f, -0.01004173f, -0.03264892f, 0.01767652f, -0.01789308f, 
    -0.05385681f, -0.02945745f, 0.03937330f, -0.01216359f, -0.05255631f, 0.04177704f, -0.02477461f, 0.00398909f, 
    0.00470745f, -0.02704308f, -0.04525833f, -0.02353505f, 0.01305606f, -0.03433567f, -0.04686384f, -0.02411732f, 
    -0.02081750f, 0.04050785f, 0.02125941f, -0.04408848f, 0.03746513f, 0.01974039f, -0.03033550f, -0.03828510f, 
    0.03749290f, -0.05410336f, -0.03458452f, -0.04108830f, -0.02874591f, -0.05447276f, -0.01560098f, -0.01756953f, 
    -0.02724935f, -0.05766921f, 0.00648110f, -0.04938962f, 0.01450286f, -0.03805386f, 0.02925820f, 0.00026744f, 
    -0.02987380f, -0.00193264f, 0.01544809f, -0.02445552f, 0.02506632f, 0.02682863f, 0.03872042f, -0.01757999f, 
    -0.03382203f, -0.01876146f, -0.01655743f, -0.00986478f, 0.00613269f, -0.04009078f, 0.03540231f, -0.03472530f, 
    0.02549369f, -0.03008526f, -0.02632405f, -0.00705691f, 0.03528639f, -0.00840584f, -0.04700536f, -0.00558704f, 
    0.00876998f, 0.04354315f, -0.01093692f, 0.03750816f, 0.00120211f, -0.02795709f, -0.02553977f, 0.03002889f, 
    0.01944087f, -0.03968654f, 0.00242593f, -0.04097259f, -0.04824830f, -0.04144238f, -0.02435068f, 0.04234020f, 
    0.02355781f, -0.03119423f, -0.02896037f, -0.02624712f, 0.01834429f, 0.03976425f, -0.01325244f, -0.00490580f, 
    0.00046201f, 0.01888822f, -0.03830261f, 0.03326683f, -0.01565892f, -0.00977357f, -0.03197549f, 0.04013887f, 
    0.02561634f, 0.02879416f, -0.03902311f, 0.00270652f, 0.02002728f, 0.00552852f, 0.00190019f, 0.00280412f, 
    0.04297715f, -0.01911505f, 0.03378452f, 0.02427780f, -0.02889424f, 0.01172150f, 0.04168596f, -0.00367959f, 
    0.03157819f, 0.03620787f, -0.00274148f, -0.04104347f, 0.04910405f, -0.01664031f, 0.03055156f, 0.00032480f, 
    -0.01091190f, 0.02423331f, -0.00068152f, 0.03534880f, -0.00836090f, 0.01969869f, 0.02715108f, -0.01506168f, 
    -0.02720901f, -0.02191758f, 0.03185217f, -0.05086553f, 0.01409957f, -0.00757067f, -0.00259385f, -0.00029510f, 
    -0.05494822f, -0.02934383f, -0.03138818f, 0.02643297f, 0.04417932f, 0.02283783f, 0.03754148f, -0.03013399f, 
    0.02131545f, -0.02829256f, 0.02077995f, 0.03795198f, -0.03902362f, -0.04533896f, -0.02002674f, 0.03696930f, 
    -0.03686209f, 0.02645877f, -0.04579941f, -0.01160854f, -0.00064873f, 0.02110220f, 0.04684205f, -0.05206675f, 
    -0.03324175f, -0.05515297f, -0.05069216f, 0.02068484f, 0.03313904f, -0.02740898f, -0.00633373f, -0.00243822f, 
    -0.02598368f, 0.00023176f, -0.03214590f, 0.02881222f, -0.03010013f, 0.03612241f, -0.04436881f, 0.02717887f, 
    -0.03494370f, -0.00307938f, 0.03317079f, 0.00276906f, -0.04025596f, -0.01228907f, -0.03955560f, 0.02737112f, 
    0.00480695f, -0.02513938f, -0.03007569f, -0.00686526f, -0.01367559f, -0.02049898f, -0.03941575f, 0.02421654f, 
    0.02418889f, -0.05294830f, -0.02472043f, -0.00873604f, -0.01557696f, 0.00328770f, -0.03793369f, -0.02336643f, 
    0.03042010f, -0.00604629f, 0.03333458f, 0.00881317f, 0.00144756f, -0.01316487f, -0.01616399f, 0.03342905f, 
    0.03832742f, -0.05665528f, -0.02164027f, -0.00570493f, -0.03012092f, 0.02635623f, 0.03127329f, -0.04794119f, 
    0.02661105f, -0.04268765f, 0.03654128f, 0.04106081f, 0.00607523f, -0.01037216f, 0.02235312f, 0.04777570f, 
    -0.01652376f, 0.02526341f, -0.01425501f, -0.01287245f, -0.05496408f, 0.03494148f, -0.04916849f, -0.01286847f, 
    0.01956923f, -0.04302214f, 0.02404033f, 0.02072454f, -0.03403123f, 0.04040077f, -0.01496630f, 0.01845427f, 
    -0.03664644f, -0.04091777f, 0.02134473f, -0.04573644f, 0.01066124f, -0.03049247f, -0.05182119f, -0.05415870f, 
    -0.02531722f, 0.02787049f, -0.04785335f, -0.03725740f, -0.01607649f, 0.00517044f, 0.01995536f, 0.03917637f, 
    0.02687503f, -0.04207887f, -0.00588403f, -0.04883437f, -0.01217062f, -0.04317668f, -0.00731964f, -0.01064058f, 
    -0.04268188f, -0.00070459f, 0.01389687f, 0.03893157f, -0.00013166f, -0.01417136f, 0.00273492f, 0.04780339f, 
    -0.02815929f, 0.01363675f, -0.00264347f, -0.04568796f, 0.03205846f, 0.03890595f, -0.05278858f, -0.05387549f, 
    -0.02303750f, 0.03929354f, 0.03396562f, 0.02112283f, -0.01666780f, -0.04341208f, 0.04020455f, 0.00215416f, 
    -0.04402431f, -0.04849519f, 0.03822153f, 0.03669567f, 0.00601353f, -0.04931328f, -0.05595535f, 0.01029241f, 
    -0.01231018f, -0.05259496f, 0.00915432f, 0.04108388f, 0.03319939f, 0.02548310f, -0.03467264f, -0.04235527f, 
    -0.04031358f, -0.04270811f, 0.04325664f, -0.02710049f, 0.00898507f, 0.00171168f, -0.04733708f, -0.01042093f, 
    -0.05312046f, 0.00802150f, 0.04599471f, 0.04271977f, 0.03581417f, 0.03379745f, -0.04917087f, 0.02479731f, 
    -0.04926602f, -0.04447676f, 0.01420619f, -0.00792108f, 0.04037303f, -0.03520168f, 0.01127431f, 0.01958954f, 
    -0.02055482f, 0.02159870f, 0.02900798f, 0.01920716f, -0.02182051f, -0.04181603f, 0.03767772f, -0.01503745f, 
    0.04357652f, -0.00481821f, 0.04441886f, -0.02472447f, 0.03863072f, 0.00638545f, -0.01892808f, 0.04310183f, 
    0.02295073f, -0.04322886f, -0.01290946f, 0.01191095f, 0.01646358f, -0.02520762f, 0.02583005f, 0.00974944f, 
    -0.02811479f, 0.04163444f, -0.03807830f, -0.05148742f, -0.00353205f, -0.04798508f, 0.01532933f, -0.01034671f, 
    -0.04937269f, -0.02107981f, -0.03730191f, -0.04177150f, 0.04344200f, -0.01196307f, 0.04014029f, -0.01466560f, 
    0.03392537f, -0.00419780f, 0.02884360f, 0.02933327f, -0.01115301f, -0.01317371f, -0.00176058f, -0.04384963f, 
    -0.00185071f, 0.00043704f, 0.00120728f, -0.02701195f, 0.05394812f, -0.00380723f, -0.02616402f, -0.04930272f, 
    -0.02282190f, 0.00171555f, -0.00550802f, -0.03157120f, -0.01241754f, -0.05172624f, 0.02261570f, 0.04440100f, 
    0.02252808f, 0.03286216f, -0.00915242f, -0.01268321f, -0.00579078f, 0.04006990f, 0.00983903f, 0.02411151f, 
    -0.00806194f, -0.00897602f, 0.04465443f, -0.01530856f, 0.00306261f, 0.02290423f, -0.04080738f, -0.05093066f, 
    -0.04444076f, 0.04308038f, 0.03948621f, -0.02416479f, 0.04121552f, 0.04246807f, -0.05512290f, 0.04492188f, 
    -0.04951872f, 0.04311988f, -0.03574924f, -0.05811533f, 0.03725322f, -0.03200312f, 0.03621945f, 0.03435303f, 
    -0.00754193f, -0.04274082f, -0.01458523f, -0.00844507f, 0.03108735f, -0.04747917f, 0.00344670f, 0.00474154f, 
    -0.03285725f, 0.01594932f, 0.01130855f, 0.03645163f, -0.01704895f, 0.02687046f, 0.01218022f, -0.03740813f, 
    -0.04713013f, -0.05377846f, 0.04012115f, -0.03993077f, -0.01578404f, -0.04648009f, -0.01132656f, -0.04821808f, 
    0.02261322f, -0.01202467f, -0.04575263f, -0.04266962f, -0.04837676f, 0.03436032f, 0.00829033f, -0.04808694f, 
    -0.03064318f, 0.00651408f, -0.04809296f, 0.04150244f, 0.02504038f, 0.03457996f, 0.04009457f, 0.01390467f, 
    0.02600574f, 0.01065269f, -0.05399059f, 0.04310234f, 0.03171436f, -0.04220936f, -0.03903833f, -0.02402725f, 
    0.02573099f, 0.00753058f, 0.03398738f, -0.01730091f, 0.04464670f, -0.04612247f, -0.02425843f, -0.00144593f, 
    -0.00797176f, 0.02865620f, 0.04100096f, 0.00138682f, -0.01160718f, 0.00003482f, 0.04199839f, -0.02767324f, 
    0.04208358f, 0.04175450f, -0.03171572f, -0.02951582f, -0.01497714f, 0.02359753f, -0.03446658f, 0.01556268f, 
    0.02982649f, 0.01692565f, 0.02334928f, -0.02477034f, 0.02342006f, 0.03456562f, 0.02283119f, 0.03099754f, 
    -0.01563885f, -0.04972425f, -0.05200802f, -0.03816411f, -0.00046967f, -0.05359179f, -0.03102037f, 0.02056800f, 
    -0.00361241f, 0.02977334f, 0.03837020f, -0.04869808f, 0.03118421f, -0.03378183f, 0.03615960f, 0.00971735f, 
    0.00692873f, -0.03498606f, 0.00795836f, 0.00043247f, -0.04394838f, -0.02070130f, -0.01045192f, -0.04034478f, 
    0.00749499f, -0.03759699f, -0.04135435f, 0.01758357f, -0.02460540f, -0.05176418f, -0.02977396f, -0.03093796f, 
    -0.01595174f, 0.02257339f, -0.01946806f, -0.02747069f, -0.03147388f, -0.05004878f, -0.02251559f, 0.01033871f, 
    -0.04472531f, 0.03753379f, 0.01604416f, -0.01227811f, -0.04048273f, 0.01504377f, -0.01995068f, 0.01792987f, 
    0.02721877f, -0.04555914f, 0.00476197f, -0.04109800f, 0.01183233f, -0.04600865f, -0.00551738f, -0.05359696f, 
    -0.04106692f, 0.03708800f, -0.00299449f, -0.03175301f, 0.02050106f, -0.01893769f, -0.04697625f, -0.02667765f, 
    0.04296697f, 0.01993307f, 0.02566382f, 0.00283741f, -0.05369445f, 0.01978073f, -0.03176445f, -0.04321005f, 
    -0.03057097f, -0.00340862f, 0.00528909f, 0.02375175f, 0.03426399f, 0.01378859f, -0.01638692f, -0.04375248f, 
    0.03582340f, -0.00371913f, 0.03728879f, -0.05730367f, -0.00682822f, 0.01720617f, 0.02859998f, -0.01094634f, 
    0.03228189f, -0.02295834f, 0.04193038f, 0.01336209f, 0.01401798f, 0.02209730f, -0.02925104f, -0.04917817f, 
    0.00967681f, 0.00165124f, 0.04382648f, -0.03299451f, -0.03564420f, -0.02547512f, -0.01472833f, -0.02289110f, 
    0.04405206f, -0.02760387f, -0.02773678f, -0.03939809f, -0.05052114f, 0.04033176f, 0.04153676f, -0.05503398f, 
    0.01710331f, 0.02608114f, 0.04494516f, -0.01615162f, -0.01638525f, 0.00567592f, 0.00850717f, -0.04060203f, 
    0.01333965f, -0.00716261f, -0.04848304f, -0.02532896f, 0.04426884f, 0.00519578f, 0.04090393f, -0.04796586f, 
    -0.03246637f, 0.00968563f, -0.04378101f, -0.01875639f, 0.00534985f, -0.01059653f, -0.05116981f, 0.05101954f, 
    -0.05621508f, 0.00253208f, 0.02816852f, -0.01997557f, -0.00513973f, 0.01727748f, -0.05662406f, -0.01841995f, 
    0.02648712f, 0.02122379f, 0.02597886f, 0.02967625f, -0.04750385f, -0.04362738f, -0.00134089f, -0.00084573f, 
    0.00512129f, 0.02790587f, -0.02731775f, -0.05433328f, -0.04239795f, -0.04233252f, -0.00828612f, -0.00800880f, 
    -0.00072205f, 0.02797062f, -0.00021730f, -0.04557565f, -0.04643678f, 0.00949987f, 0.02198342f, 0.02190182f, 
    0.02112300f, -0.05072642f, -0.04120110f, -0.03209995f, 0.03702092f, 0.01477894f, 0.02724671f, 0.01671500f, 
    -0.04478162f, 0.01208330f, -0.01113780f, -0.02279057f, 0.01414415f, 0.04047609f, -0.04275342f, 0.00148983f, 
    -0.04516481f, -0.01543367f, 0.01503277f, 0.00631312f, -0.04746276f, -0.05482375f, -0.04659342f, -0.04651460f, 
    0.00988425f, -0.05816111f, -0.04804372f, 0.03833239f, 0.01094576f, -0.04021778f, 0.04087199f, -0.04613881f, 
    0.01633621f, -0.05140043f, 0.04147718f, 0.02863760f, -0.04965585f, -0.05241452f, -0.03248238f, -0.01151760f, 
    -0.02082602f, -0.02681239f, -0.00357721f, 0.04160926f, -0.03734815f, 0.03651701f, -0.05529897f, 0.02843231f, 
    -0.02444854f, 0.00522601f, 0.03166710f, 0.03260529f, -0.02961856f, -0.04476192f, -0.04811201f, -0.00872361f, 
    0.04264252f, 0.01510154f, 0.02353364f, -0.02682609f, 0.02011705f, 0.04079800f, 0.03275852f, -0.01431183f, 
    -0.03390987f, -0.00956795f, -0.02547106f, 0.00565657f, 0.00672833f, 0.01057046f, 0.00289160f, 0.01691031f, 
    -0.05287621f, -0.04733455f, -0.02966472f, -0.05297600f, -0.04454114f, -0.03685115f, -0.05348974f, -0.02607732f, 
    -0.01266293f, 0.01462092f, 0.04171691f, 0.03187803f, 0.00269105f, 0.00234712f, -0.02085250f, 0.03543155f, 
    0.00722585f, -0.03343000f, 0.01380573f, 0.03927759f, 0.04600015f, -0.02790386f, -0.02417639f, 0.01439085f, 
    0.02653456f, -0.02152167f, 0.01263736f, 0.04643319f, 0.00090522f, -0.03024817f, -0.03213349f, -0.00102491f, 
    0.03219386f, -0.03158547f, -0.02400632f, -0.02381645f, 0.00023097f, 0.02255422f, -0.00681637f, 0.01341240f, 
    -0.05074577f, -0.02865602f, -0.04356210f, -0.02175679f, -0.04747397f, 0.02329381f, -0.00974370f, 0.00891801f, 
    -0.01522855f, -0.00459550f, 0.02806336f, -0.02972476f, -0.03502906f, 0.03182602f, -0.05675701f, -0.00605618f, 
    -0.00388175f, -0.00090199f, 0.01528263f, -0.00640697f, 0.03753070f, -0.03101194f, -0.01271353f, -0.02934565f, 
    0.04225691f, -0.01870444f, 0.00092012f, -0.02451598f, 0.04115691f, 0.03169994f, 0.03812497f, -0.00990791f, 
    -0.02193769f, -0.04524812f, 0.01916682f, -0.03859964f, 0.02336790f, -0.01751040f, 0.00379056f, -0.01192060f, 
    0.02013351f, -0.00849337f, -0.05115001f, -0.04287138f, -0.01710337f, -0.04254501f, 0.04275494f, 0.01864208f, 
    0.04845776f, -0.03676236f, 0.04108793f, -0.00487243f, -0.01421851f, 0.04301513f, -0.02026546f, -0.01267068f, 
    -0.04525860f, -0.04827054f, -0.02342801f, 0.03243222f, -0.05691585f, -0.04701089f, 0.00057743f, 0.02310360f, 
    -0.02449128f, 0.02707495f, -0.03964625f, 0.01422575f, -0.03159730f, -0.00371793f, -0.00893841f, 0.01031297f, 
    0.02157837f, -0.00472016f, 0.00242237f, -0.01814500f, 0.01879734f, -0.04041960f, -0.03914446f, 0.03590402f, 
    -0.05184548f, 0.00188181f, 0.03956374f, -0.05105197f, 0.02253107f, -0.04151419f, -0.02433754f, -0.01988181f, 
    0.00545205f, 0.00841977f, -0.00900503f, -0.04438497f, 0.02366331f, -0.00317164f, 0.02881468f, -0.00179789f, 
    -0.02471850f, -0.04089851f, 0.01391630f, -0.02486091f, -0.01328840f, -0.01531920f, 0.02630380f, -0.05494782f, 
    -0.01963949f, -0.01172897f, -0.00173411f, -0.01727949f, -0.03083590f, -0.00926039f, -0.05504481f, 0.02390842f, 
    0.00091967f, -0.03936994f, 0.02406726f, 0.03375492f, -0.00754866f, 0.00980934f, -0.05183917f, -0.01502910f, 
    0.04078579f, -0.02751358f, -0.03433200f, 0.00055961f, -0.04403649f, -0.00744917f, 0.01551510f, 0.02206562f, 
    0.03417849f, 0.00324509f, -0.02665090f, -0.03182230f, 0.02156207f, -0.02533040f, 0.01176045f, 0.02454454f, 
    0.02322086f, -0.05494297f, -0.28039774f, 0.15582991f, -0.09757093f, -0.01630234f, -0.12623039f, 0.10169401f, 
    0.06762709f, 0.02745520f, -0.00500625f, 0.05847676f, 0.01741190f, -0.02106825f, -0.24568604f, -0.05550491f, 
    0.10310465f, 0.02855734f, -0.05246929f, 0.05734772f, 0.04648796f, 0.02676719f, 0.10852142f, 0.08997778f, 
    0.10119964f, -0.08161104f, -0.11971641f, -0.16729884f, 0.11827739f, -0.10191005f, 0.01734868f, 0.01379506f, 
    0.07795963f, 0.03877649f, 0.06711262f, 0.07205527f, -0.17071742f, -0.28660643f, 0.12680580f, -0.09255604f, 
    0.04954747f, -0.04287166f, -0.02170371f, 0.08879790f, -0.00603500f, -0.04076002f, -0.08748632f, 0.06029779f, 
    -0.29476705f, 0.27284810f, 0.04924857f, 0.02878723f, -0.04645581f, 0.02060684f, -0.11218847f, 0.08211244f, 
    -0.25602826f, -0.02508812f, -0.01104266f, 0.06758133f, -0.04074540f, -0.21262124f, -0.05276577f, 0.00336155f, 
    0.03350896f, -0.05639319f, -0.08201514f, -0.02088735f, 0.04293489f, -0.04933076f, 0.00802434f, 0.17350660f, 
    -0.16638340f, 0.27710977f, 0.08897787f, 0.17915015f, 0.03644688f, -0.20251827f, 0.14029832f, 0.14949191f, 
    0.01267915f, -0.05133187f, 0.03076432f, -0.08615753f, 0.01285290f, -0.22828412f, -0.25365010f, -0.15505539f, 
    0.04061412f, 0.02160158f, -0.03255791f, 0.00073786f, 0.11644493f, 0.00625133f, 0.00040256f, 0.01655539f, 
    -0.31365123f, -0.02153367f, 0.08689742f, -0.03860487f, -0.03904529f, -0.06774595f, -0.05305814f, -0.01104734f, 
    -0.10469760f, 0.05704199f, -0.11807225f, -0.01024837f, 0.27535364f, 0.04723327f, -0.02460488f, 0.21490683f, 
    -0.06688309f, 0.01399151f, -0.06639828f, -0.06697374f, 0.14807643f, -0.06288476f, -0.02004539f, 0.10780375f, 
    -0.16055834f, 0.12493252f, 0.06265058f, 0.09229948f, -0.02926970f, -0.02612248f, -0.05487247f, 0.12204138f, 
    0.11131085f, 0.03191942f, 0.08338775f, 0.06652395f, 0.28437999f, 0.02915947f, -0.14943874f, 0.12908514f, 
    0.06276545f, 0.01212367f, -0.03607826f, -0.07618462f, -0.16878426f, 0.09216070f, -0.02588728f, -0.06937188f, 
    -0.07641926f, -0.07672292f, 0.08550087f, 0.06357842f, 0.03081896f, -0.01980212f, 0.05365807f, 0.00536112f, 
    0.03949661f, -0.13771324f, -0.00322111f, -0.11662865f, -0.12957887f, 0.00004854f, -0.23772955f, 0.02028898f, 
    0.07320699f, 0.06058187f, -0.06613635f, -0.07092712f, 0.01547640f, -0.08848929f, -0.09437243f, -0.00711273f, 
    0.43450364f, 0.34688240f, 0.10425679f, 0.26549563f, 0.01566929f, -0.00291174f, 0.03530789f, 0.01591825f, 
    -0.04399599f, -0.01236966f, -0.02396735f, -0.03862673f, -0.09792683f, 0.06575753f, 0.07236750f, -0.03236529f, 
    -0.05743464f, -0.12386888f, -0.02291512f, -0.05591497f, 0.03296492f, 0.19660135f, 0.17793366f, -0.01718814f, 
    0.20532443f, 0.08069478f, -0.13370883f, 0.21778443f, 0.06856231f, -0.01622790f, 0.04352377f, -0.04156197f, 
    -0.01687554f, 0.11367015f, -0.10562871f, 0.08465977f, 0.08925948f, -0.10993427f, -0.07624663f, 0.01251933f, 
    0.06500222f, 0.10771745f, -0.02475709f, -0.05937076f, 0.07014629f, 0.01089993f, 0.02421870f, -0.06751252f, 
    0.14643569f, 0.22943901f, 0.21207550f, 0.22903916f, -0.02063685f, 0.03671941f, 0.01373283f, -0.01181632f, 
    -0.00729239f, -0.06189462f, 0.03908101f, 0.13569413f, -0.32968330f, -0.24289688f, 0.14371182f, -0.09030376f, 
    -0.01840385f, 0.02342055f, -0.04597346f, -0.01335444f, -0.01339421f, -0.09888791f, -0.13586360f, 0.13809802f, 
    -0.08939445f, -0.22373490f, 0.13675490f, 0.09462260f, 0.01524522f, 0.07791616f, 0.08386849f, 0.14642845f, 
    0.12561974f, 0.09851772f, 0.20075263f, 0.05676907f, 0.30980960f, 0.19616562f, 0.16322875f, 0.34276468f, 
    -0.08876836f, 0.11829383f, -0.00291081f, 0.01536670f, -0.12135269f, -0.07682952f, -0.04123187f, 0.07794485f, 
    0.20238571f, 0.06670541f, -0.22503985f, 0.02772234f, 0.02253325f, -0.10854439f, -0.08452055f, 0.07980151f, 
    -0.03728196f, -0.01637380f, 0.01607797f, 0.00511618f, -0.09003536f, 0.21872623f, 0.03046457f, 0.15303792f, 
    -0.05503611f, 0.10285427f, -0.08104536f, 0.03155904f, 0.08859243f, -0.09686469f, 0.03120327f, 0.03019592f, 
    -0.11269647f, -0.17813222f, -0.06572003f, -0.12597437f, -0.00002138f, -0.08159303f, 0.00226950f, 0.05353839f, 
    0.08498431f, 0.00740656f, -0.05259221f, 0.02106972f, -0.28014085f, 0.37256378f, 0.12068523f, 0.00719611f, 
    -0.00068932f, -0.03912312f, 0.07775435f, 0.14382507f, -0.04370466f, 0.02510713f, -0.03528665f, 0.09785761f, 
    -0.18302955f, -0.07757328f, -0.07289681f, -0.23562019f, 0.01144456f, -0.09156219f, 0.02157336f, 0.02935088f, 
    0.03914054f, 0.03497873f, 0.08010268f, 0.06658200f, -0.14696090f, -0.18840851f, -0.19372506f, -0.07224173f, 
    0.15656750f, -0.06347548f, 0.00937177f, 0.06610359f, 0.11469260f, -0.05080692f, 0.11097158f, -0.09671497f, 
    0.15705165f, 0.15789774f, 0.20755155f, 0.30502594f, -0.05686431f, 0.05589082f, 0.06148765f, 0.03132773f, 
    -0.03598302f, 0.01166409f, -0.08155490f, 0.03952320f, -0.27964595f, 0.11498801f, 0.11154990f, -0.11660097f, 
    -0.05098755f, -0.15182558f, 0.05809944f, 0.11238629f, -0.07621947f, 0.05569572f, 0.04372388f, -0.17944363f, 
    -0.12261107f, 0.00985836f, 0.00026572f, 0.18723410f, 0.02933592f, 0.05820202f, -0.04260011f, 0.11020479f, 
    0.01526960f, 0.04299173f, -0.01209505f, -0.06802634f, 0.06581293f, 0.05426655f, 0.20835969f, 0.20141397f, 
    -0.05457309f, 0.12753604f, 0.16118015f, 0.00482614f, -0.09546281f, 0.06473835f, 0.07955876f, 0.09688056f, 
    0.14816520f, -0.07765786f, 0.00528021f, 0.12998226f, 0.06935151f, 0.04103357f, 0.16350356f, -0.08735067f, 
    -0.04545669f, 0.09190368f, 0.12453276f, 0.02600270f, -0.08575997f, -0.12688829f, -0.08271275f, -0.21905977f, 
    0.14244702f, -0.06810714f, -0.04013542f, -0.02045002f, 0.04412493f, 0.09900094f, -0.06006912f, -0.01859802f, 
    0.24550629f, -0.20526835f, -0.26549286f, -0.08121463f, 0.07030289f, 0.02794788f, 0.05941169f, 0.08452838f, 
    -0.02878589f, -0.00338676f, 0.08052897f, -0.06044008f, 0.05035581f, 0.24987590f, -0.25714153f, 0.12001426f, 
    -0.07861309f, 0.06670842f, -0.00847381f, 0.04432939f, -0.10797539f, -0.01221079f, 0.04133191f, -0.02386114f, 
    0.14664209f, 0.06374890f, 0.23630236f, 0.08333463f, 0.01559468f, 0.02704296f, -0.02137593f, 0.06121710f, 
    -0.01546702f, -0.00130850f, -0.03179343f, -0.03771812f, -0.01581593f, -0.03796813f, -0.15301710f, -0.11546960f, 
    0.01061094f, -0.03383661f, 0.09559042f, 0.18199204f, 0.04434526f, -0.12728088f, 0.06054669f, -0.12453172f, 
    0.24269117f, 0.01970745f, 0.18641564f, 0.02880579f, -0.01962594f, -0.00492937f, -0.05421437f, 0.20499417f, 
    0.00057113f, -0.12512836f, 0.05831274f, -0.03019612f, -0.17992482f, -0.13507223f, -0.15989916f, -0.14390738f, 
    -0.03793006f, 0.04999730f, 0.07653680f, 0.04887007f, 0.06066495f, -0.05601646f, 0.00728240f, 0.04175540f, 
    0.06298079f, 0.12544352f, -0.10420349f, 0.11278843f, -0.08938449f, -0.05576127f, 0.03969492f, 0.06519304f, 
    0.03496685f, 0.11790787f, 0.06287722f, 0.03026611f, -0.20269297f, 0.21631105f, -0.09254084f, 0.10529098f, 
    0.21657901f, -0.06474237f, 0.03676066f, -0.10215144f, 0.01501965f, 0.04854461f, -0.02514009f, -0.02348922f, 
    -0.10951787f, 0.13044678f, 0.04277531f, -0.00677412f, -0.12203847f, -0.04456301f, 0.03377064f, 0.04951715f, 
    -0.01377022f, 0.07868189f, -0.06465469f, -0.16005078f, -0.14533940f, -0.04087916f, 0.15985712f, 0.08413380f, 
    -0.01424461f, -0.05332836f, -0.00599315f, -0.00599019f, -0.00659618f, 0.04174365f, -0.06327901f, 0.05585364f, 
    0.11118640f, -0.25411704f, -0.14153229f, 0.14072645f, 0.10467605f, 0.08144144f, -0.04259514f, -0.02087692f, 
    0.04618192f, -0.03735443f, 0.02233029f, 0.01095712f, 0.23203638f, -0.14685428f, 0.09078215f, 0.30236295f, 
    0.16498655f, 0.00350484f, -0.09941468f, 0.10229494f, 0.05556916f, 0.08810799f, 0.07740873f, 0.04026580f, 
    0.08841522f, -0.04849901f, -0.08108158f, 0.02024958f, -0.05645562f, -0.13641901f, -0.15726329f, -0.07898159f, 
    0.10646071f, 0.05053700f, 0.03315076f, -0.07999834f, 0.10261296f, 0.09699842f, -0.06684472f, 0.17534365f, 
    0.06500584f, 0.10403515f, -0.12712795f, 0.13501476f, 0.04772318f, -0.01407684f, 0.08208826f, 0.01467835f, 
    0.05332471f, 0.01211511f, 0.07613675f, -0.00649417f, 0.03502919f, 0.00994652f, 0.04518132f, 0.04510976f, 
    -0.04945882f, -0.01338693f, 0.07727375f, -0.01987903f, -0.13551812f, -0.06911812f, -0.08145235f, -0.04487795f, 
    0.08611826f, -0.00687482f, -0.02872353f, -0.00888094f, 0.03212839f, 0.08057863f, 0.04405446f, 0.07622692f, 
    0.08046861f, 0.19173360f, -0.09329147f, 0.12933490f, -0.03268936f, -0.09912527f, 0.01831390f, -0.00314689f, 
    0.02168803f, 0.09736700f, 0.03774140f, -0.01620761f, -0.10897650f, 0.06713971f, -0.13350269f, -0.05907175f, 
    0.09956251f, 0.05866893f, 0.03404944f, 0.12548639f, 0.02335418f, -0.02439924f, -0.09098911f, 0.08705255f, 
    -0.02579173f, 0.02069060f, 0.08197551f, -0.10744018f, -0.09345009f, 0.01818534f, -0.00157087f, 0.03484314f, 
    -0.05863338f, 0.04351235f, 0.01789025f, -0.07127011f, 0.01038648f, -0.17087887f, 0.05688889f, -0.15969822f, 
    -0.15243010f, 0.07149421f, 0.03133141f, 0.15288150f, 0.02624052f, -0.07094800f, 0.05970229f, -0.10326611f, 
    0.11399556f, -0.06296746f, 0.11510948f, 0.31162167f, 0.03139069f, 0.12685157f, 0.10629482f, -0.07492517f, 
    0.13069710f, 0.01928588f, -0.03322539f, 0.02011033f, -0.04156597f, -0.10046017f, 0.12609935f, 0.04238660f, 
    0.06888915f, -0.05323839f, -0.01304365f, -0.08784974f, 0.00614220f, 0.16094925f, 0.12731254f, -0.06703816f, 
    -0.02937865f, -0.08343503f, -0.15120302f, -0.16519859f, 0.11096852f, 0.07827213f, -0.07244886f, -0.04436936f, 
    0.02997099f, -0.02099626f, 0.02886769f, -0.00056530f, 0.23787193f, 0.06608584f, 0.12110256f, -0.06896218f, 
    -0.07266482f, 0.01832805f, 0.00520639f, 0.00313296f, 0.03484787f, -0.07943017f, -0.03164314f, 0.06842329f, 
    -0.15132028f, -0.09833100f, -0.05825291f, 0.03202372f, -0.00478803f, -0.02118156f, 0.11917184f, 0.03672099f, 
    0.07218865f, 0.09777541f, -0.04116451f, 0.07623920f, -0.00865065f, -0.28438643f, -0.04946201f, -0.13976164f, 
    0.10130572f, 0.01423795f, 0.06176254f, 0.05935908f, 0.05001502f, 0.02976342f, -0.01360213f, 0.12642506f, 
    0.04546041f, 0.08911952f, 0.06561574f, 0.00603937f, -0.05657222f, -0.04094210f, -0.00551526f, 0.07116461f, 
    -0.04154289f, 0.01861445f, -0.06906228f, -0.07417279f, 0.06060660f, 0.16749445f, -0.01916815f, -0.02451752f, 
    -0.10467971f, 0.04450168f, -0.02279936f, -0.08512530f, 0.00993633f, 0.12198125f, -0.10522038f, -0.01657238f, 
    -0.08879849f, 0.26478356f, -0.06721310f, 0.03143134f, 0.08952153f, 0.09217884f, 0.21015461f, 0.05567483f, 
    -0.06183174f, -0.00818211f, -0.02664821f, -0.05340141f, 0.07749917f, 0.00714504f, -0.13422662f, -0.04221971f, 
    -0.02550755f, 0.04509654f, -0.00264555f, -0.20935707f, -0.03278678f, -0.00901034f, -0.10453149f, 0.07046697f, 
    0.11058792f, -0.28910914f, -0.07638334f, 0.14779392f, 0.03656135f, -0.04881498f, -0.02329028f, 0.05827909f, 
    0.08069149f, -0.12292463f, 0.05910119f, 0.11786176f, -0.00483815f, 0.01701330f, 0.04199286f, 0.09898365f, 
    0.06172619f, 0.04570502f, -0.06155756f, 0.09049173f, 0.00665396f, 0.08995417f, 0.02980246f, 0.02386897f, 
    -0.01037573f, -0.20310922f, 0.05105170f, 0.21686158f, 0.18911289f, -0.00248393f, 0.00114633f, -0.01395055f, 
    0.08940302f, -0.05721574f, 0.09463815f, 0.03259773f, -0.03111521f, -0.09494633f, 0.00437528f, -0.03308019f, 
    0.15191403f, 0.00982803f, 0.11130383f, 0.03500373f, 0.02901571f, 0.03911039f, 0.02411129f, 0.13324524f, 
    -0.06760425f, -0.22541781f, -0.20081440f, 0.03388919f, 0.02210055f, -0.07733839f, 0.00576390f, -0.11738192f, 
    -0.09630092f, -0.06104289f, 0.06558397f, 0.01961887f, 0.05506405f, -0.18141535f, 0.01899379f, 0.04633673f, 
    0.07574594f, -0.00972350f, 0.08362564f, -0.11819819f, -0.03955490f, 0.09416644f, -0.04036547f, 0.21092582f, 
    -0.00036536f, -0.02178489f, -0.12324444f, 0.07721225f, -0.17567775f, -0.03500924f, -0.07299846f, 0.03524747f, 
    -0.00577682f, -0.02965373f, -0.09158790f, 0.03350221f, -0.13266765f, 0.00902900f, -0.02805989f, -0.00307966f, 
    0.06188226f, -0.04482735f, -0.05456126f, -0.02858279f, -0.10790569f, -0.00173765f, -0.02753732f, 0.01095661f, 
    -0.24937326f, 0.22794735f, -0.04722072f, -0.11311967f, 0.05342662f, 0.10951422f, 0.03340463f, -0.04569475f, 
    -0.04150269f, -0.04441025f, -0.05019594f, -0.03438883f, -0.01740897f, -0.29334489f, 0.15644544f, -0.11304869f, 
    -0.04759665f, 0.09738281f, 0.01567751f, 0.10973689f, 0.26934054f, 0.07215361f, -0.06477129f, -0.06494689f, 
    -0.11710834f, -0.03804822f, -0.03628473f, -0.03090273f, -0.08832160f, -0.04061291f, 0.05757845f, -0.11571243f, 
    0.12787831f, -0.03814003f, -0.02498958f, -0.02989615f, 0.15454514f, -0.02077858f, -0.02677979f, -0.22203648f, 
    0.04753862f, 0.04466493f, 0.15009454f, 0.05939897f, -0.03288022f, 0.06885169f, -0.07101608f, 0.06839563f, 
    0.00883020f, -0.10048150f, 0.15192600f, 0.20868073f, 0.14164399f, -0.05285177f, -0.03335916f, -0.03436440f, 
    0.11371372f, 0.04044034f, 0.05332058f, 0.12211698f, 0.27790725f, -0.15075162f, 0.32111672f, 0.12258182f, 
    -0.07330865f, 0.11917910f, 0.14183038f, 0.00458432f, 0.08463906f, 0.03339854f, -0.03925056f, -0.01720350f, 
    0.13903746f, 0.05954268f, 0.06033863f, -0.11160578f, 0.00252712f, -0.00391466f, 0.02895063f, 0.05420141f, 
    0.05583069f, -0.08503627f, 0.07525162f, 0.15215749f, -0.01342584f, 0.33001128f, -0.27155626f, 0.00601022f, 
    0.06138326f, 0.04150732f, 0.06067414f, 0.04974094f, 0.11850572f, 0.15410952f, 0.10302345f, -0.03706001f, 
    0.05557889f, -0.01987218f, -0.12597813f, -0.11921173f, 0.13008665f, -0.00708490f, 0.10559377f, -0.02392366f, 
    0.14646289f, 0.16254672f, 0.07484290f, 0.07815182f, 0.06540269f, -0.08426039f, -0.03772928f, 0.02050504f, 
    0.14917998f, 0.10376396f, 0.05163829f, 0.02575811f, 0.01636789f, -0.11499605f, 0.07460032f, 0.12122416f, 
    0.05909670f, 0.08064639f, -0.01183543f, -0.12998499f, 0.04891681f, 0.00839995f, 0.09868430f, -0.02930706f, 
    -0.04279619f, 0.07107831f, 0.10505167f, 0.05955566f, -0.33453840f, 0.12366781f, -0.12749568f, 0.05020242f, 
    0.20924395f, 0.04431598f, -0.13947025f, -0.01126570f, 0.01424435f, 0.07761910f, 0.09504786f, 0.14974147f, 
    -0.17997904f, 0.09392674f, -0.07560003f, 0.00380154f, 0.06364945f, 0.16811760f, 0.04798754f, -0.00553741f, 
    0.03745285f, -0.11068302f, -0.01334906f, 0.09977197f, 0.04385244f, -0.11201593f, -0.12455142f, -0.16701251f, 
    -0.18757667f, 0.00617842f, -0.00378607f, -0.04050900f, 0.00199626f, 0.10526688f, 0.04487574f, 0.03454334f, 
    0.32845417f, -0.07764015f, 0.05923804f, 0.07317977f, 0.14571816f, 0.03659908f, -0.10876425f, 0.12316689f, 
    0.06372028f, -0.03689007f, -0.02278896f, -0.09975938f, 0.12875615f, -0.07024105f, -0.14110750f, -0.04296362f, 
    0.02333483f, 0.13040894f, -0.03436487f, -0.04738641f, 0.06416790f, -0.15007031f, -0.04495787f, 0.08964159f, 
    0.12176642f, -0.09844068f, 0.02499642f, 0.21167010f, 0.02453212f, 0.00519072f, -0.01510636f, 0.04674234f, 
    0.11073315f, 0.02530761f, 0.02158700f, 0.05331272f, -0.09033240f, 0.07317355f, -0.12120002f, -0.02854293f, 
    -0.14609070f, -0.01349305f, 0.02805095f, 0.11618982f, -0.07487021f, 0.12968889f, 0.00693327f, -0.01102603f, 
    0.22035810f, 0.04082393f, -0.04840538f, 0.02248932f, 0.02392261f, -0.01495520f, -0.00979549f, -0.00385685f, 
    -0.01732855f, -0.02806213f, 0.07955255f, 0.01010230f, 0.03664933f, -0.07495686f, -0.15260422f, 0.10349311f, 
    0.17516422f, -0.02872504f, -0.03116363f, -0.00204279f, -0.01349191f, -0.03278673f, 0.06348904f, -0.05913879f, 
    0.09355676f, -0.00442309f, -0.07753424f, 0.00515276f, -0.20595045f, -0.09276497f, 0.08345120f, -0.07064779f, 
    0.01005909f, 0.00642331f, 0.00203122f, -0.00691123f, 0.03940480f, 0.03832976f, 0.12381771f, 0.01140070f, 
    0.04861225f, 0.01806107f, 0.03105568f, 0.13072936f, 0.01786628f, -0.06929632f, 0.18175991f, -0.07151626f, 
    0.18210460f, 0.11647024f, -0.04422701f, -0.08862728f, 0.13676621f, 0.11975313f, 0.00144124f, 0.08968198f, 
    0.15654942f, 0.08246401f, 0.06530882f, -0.01487465f, -0.08845656f, -0.00942672f, -0.14206743f, -0.09790298f, 
    -0.03838647f, 0.05539240f, -0.09870323f, 0.06374892f, 0.09467538f, -0.03572115f, 0.06332548f, -0.01943677f, 
    0.03687489f, -0.04751796f, 0.02792260f, -0.03828297f, 0.02200587f, 0.01505648f, -0.02011252f, 0.00085870f, 
    0.02822132f, -0.01158581f, -0.04899956f, -0.01893700f, 0.02897885f, -0.01411028f, 0.01846840f, 0.00315441f, 
    -0.01267394f, -0.01572145f, -0.05704640f, 0.02946887f, -0.03413550f, 0.01535011f, -0.03892669f, 0.02394978f, 
    0.03775196f, 0.00991429f, -0.00271990f, 0.02432876f, 0.00579305f, 0.02723370f, 0.00671711f, -0.03984352f, 
    -0.04774828f, 0.00797516f, -0.01986880f, -0.01750824f, 0.01827156f, -0.03952051f, 0.04673773f, -0.03162408f, 
    -0.00194677f, -0.05585977f, 0.02826221f, 0.00863814f, 0.02429717f, -0.01837027f, -0.00318089f, -0.00635472f, 
    -0.01761153f, 0.03186435f, -0.00649720f, 0.03437762f, -0.04040921f, -0.04673922f, -0.00308197f, -0.00147966f, 
    0.01993586f, -0.04992773f, -0.04099750f, 0.01257385f, -0.01702795f, 0.02725687f, -0.04384410f, -0.04045337f, 
    -0.03286713f, 0.02022727f, -0.03336013f, -0.01270477f, 0.01998067f, 0.01816669f, -0.04839400f, 0.03261640f, 
    -0.04947823f, -0.00157111f, -0.01228980f, 0.03255954f, -0.03594270f, -0.00158767f, 0.01839374f, 0.03637121f, 
    -0.05210098f, 0.03250734f, 0.01684715f, -0.04146780f, -0.03068963f, 0.01740162f, 0.03948379f, 0.05418687f, 
    -0.02544593f, -0.00239029f, -0.02502680f, -0.03777390f, 0.01765403f, -0.00486870f, -0.05863692f, 0.00266514f, 
    0.03663772f, -0.00876531f, 0.04162272f, -0.00040426f, -0.01178819f, 0.02370116f, -0.03011697f, -0.02467927f, 
    -0.03000560f, -0.03522104f, 0.02226903f, -0.01456629f, -0.03109702f, -0.02749927f, 0.00761423f, -0.01671405f, 
    -0.04738603f, -0.01935890f, 0.04003539f, -0.03706222f, 0.00210870f, 0.02192875f, -0.01290302f, 0.02570594f, 
    0.02236412f, -0.05667685f, -0.02170141f, -0.04472901f, 0.01101295f, -0.03255413f, -0.05364669f, -0.00049991f, 
    -0.00988114f, -0.03034747f, 0.02878883f, -0.00039721f, 0.00162068f, -0.04448178f, -0.01808258f, -0.04309955f, 
    -0.05832432f, -0.03081334f, -0.00198236f, 0.03710128f, -0.04277284f, 0.02727878f, -0.01175567f, -0.03565284f, 
    -0.04530992f, -0.05297010f, -0.00142427f, -0.02128975f, 0.01180492f, -0.04600263f, 0.02895369f, -0.01584039f, 
    -0.05091302f, -0.02379778f, 0.02751217f, 0.02463756f, 0.00868173f, 0.01503088f, -0.04426996f, -0.04402082f, 
    0.01564252f, 0.01621106f, -0.01816444f, 0.00869677f, -0.01401076f, -0.02025032f, 0.02347488f, -0.01601535f, 
    0.03881586f, -0.05287826f, 0.03687559f, -0.05190259f, -0.00094258f, -0.02273168f, 0.01089700f, 0.03061742f, 
    0.01748453f, 0.01579412f, 0.02760810f, 0.01027161f, 0.02158772f, 0.00207005f, 0.02338772f, 0.00112926f, 
    0.02968532f, -0.04644945f, 0.02194334f, -0.01745530f, -0.04537931f, 0.00057108f, 0.00413771f, 0.03772341f, 
    0.02342254f, 0.01965255f, -0.03393398f, -0.01358392f, -0.04272573f, 0.02961757f, 0.00801588f, -0.04118014f, 
    0.02989356f, -0.04827467f, 0.04653862f, 0.03802688f, 0.04083140f, -0.00548071f, 0.03163037f, -0.03248920f, 
    -0.03897892f, -0.03181226f, -0.02589201f, 0.01970795f, -0.05428380f, -0.02726479f, 0.04280504f, -0.03617309f, 
    -0.03048578f, 0.02346710f, 0.02832109f, 0.01361140f, 0.00209297f, -0.01158658f, -0.04860042f, 0.01997733f, 
    0.04402015f, -0.02114742f, -0.05449480f, -0.04728723f, 0.03405587f, 0.00842424f, -0.04635885f, -0.03717326f, 
    -0.00228788f, 0.03763467f, 0.04482741f, -0.04547362f, 0.00769832f, 0.04220311f, -0.01053966f, -0.03777010f, 
    -0.03467296f, 0.01428324f, 0.04084681f, 0.03725401f, -0.05753863f, -0.00123722f, -0.01587870f, 0.01895401f, 
    -0.03341519f, -0.03769675f, -0.05090378f, -0.05407215f, -0.02452023f, 0.00891253f, 0.02925443f, 0.03605596f, 
    0.01505596f, 0.01271282f, -0.04903239f, -0.00899512f, 0.01698457f, -0.05554029f, -0.00250014f, -0.04079030f, 
    0.00822112f, -0.00804823f, -0.00154463f, -0.05482957f, 0.01306613f, -0.00837128f, -0.02953408f, 0.02756896f, 
    0.02218997f, -0.03056377f, 0.03415686f, 0.03013726f, 0.00247584f, -0.05738956f, 0.00762601f, 0.00874850f, 
    0.00057442f, 0.00782428f, 0.00469394f, -0.04955853f, 0.03013660f, -0.02894994f, 0.02637292f, 0.02232506f, 
    0.00267952f, 0.01601105f, -0.01208648f, -0.01994362f, 0.01917706f, 0.00466534f, -0.03975982f, 0.00683427f, 
    -0.05436189f, 0.03193174f, -0.03482332f, -0.04437274f, -0.00530790f, -0.03061414f, 0.00137816f, -0.01773315f, 
    -0.04927922f, 0.04386190f, 0.02799071f, -0.04748551f, 0.02641307f, -0.04907425f, 0.01501041f, 0.00061753f, 
    0.02007127f, 0.00370026f, -0.00605326f, -0.04409418f, 0.00171768f, -0.00284022f, 0.04020192f, -0.01847348f, 
    0.01120341f, -0.03883572f, -0.02362825f, 0.01399252f, -0.03141851f, -0.01996234f, -0.02063994f, -0.00661222f, 
    -0.02987204f, 0.00576769f, 0.00793047f, 0.04233690f, -0.02468917f, 0.01555007f, -0.05600226f, 0.02535757f, 
    -0.00436241f, 0.00202922f, 0.02875161f, -0.01652462f, 0.04045322f, -0.01619365f, -0.02850235f, -0.00125882f, 
    0.00037483f, -0.00443724f, -0.01905630f, -0.01696992f, -0.02561516f, -0.01958640f, 0.01297731f, -0.03394407f, 
    0.02694158f, 0.03006958f, -0.01598794f, -0.00117121f, -0.01764220f, -0.03368555f, 0.01321675f, 0.02621943f, 
    -0.03394586f, 0.00379134f, -0.00226440f, -0.03722917f, 0.00531258f, 0.01298551f, -0.02173456f, -0.04885162f, 
    -0.05339546f, 0.01004077f, -0.04394742f, 0.04367625f, 0.00158810f, -0.02200944f, -0.01673034f, -0.02407232f, 
    -0.00158392f, -0.01387334f, -0.03653184f, -0.01823272f, -0.02629519f, 0.02302582f, 0.02152310f, 0.03915289f, 
    -0.13617246f, 0.17603911f, 0.02479314f, -0.13025828f, 0.00077226f, -0.01840469f, -0.00324903f, -0.09306505f, 
    -0.07959035f, -0.00414933f, 0.13271131f, -0.03559057f, 0.16560692f, 0.07933094f, -0.04742761f, -0.08781698f, 
    0.12652789f, -0.00052296f, -0.02234137f, -0.11295511f, 0.04440030f, -0.09328369f, -0.07569829f, -0.07471216f, 
    -0.24796236f, 0.21882956f, 0.10003966f, -0.09225791f, 0.12417914f, 0.11685729f, 0.06360705f, -0.14652817f, 
    -0.12134986f, -0.03851062f, -0.07055518f, 0.06579199f, 0.08916918f, -0.10162073f, -0.00291674f, -0.12912047f, 
    -0.02779932f, 0.01081526f, -0.15543903f, 0.03709530f, 0.02773068f, -0.02492034f, -0.04196919f, -0.09513817f, 
    0.18440892f, -0.03651967f, -0.02399865f, -0.13663283f, -0.00604673f, 0.12277577f, -0.02999581f, 0.01492294f, 
    0.14736022f, -0.01789083f, -0.05061541f, -0.05368508f, 0.02622035f, 0.12816571f, -0.02511225f, 0.07656538f, 
    0.12678289f, 0.04135291f, -0.01415916f, -0.05042867f, 0.04873781f, -0.06379461f, 0.03640534f, -0.08005459f, 
    -0.18059942f, -0.02105790f, 0.22851460f, 0.21145383f, 0.13868900f, 0.04305301f, 0.09828945f, 0.07932251f, 
    -0.00834987f, 0.07203345f, 0.11638869f, -0.04971827f, 0.23306695f, 0.01199542f, 0.11786020f, 0.10914115f, 
    0.10080492f, 0.04282631f, 0.05823258f, -0.09136466f, -0.03276420f, -0.04088584f, 0.03507634f, 0.05516163f, 
    0.55485833f, -0.20267409f, -0.08366541f, 0.15437207f, -0.01353672f, 0.03816914f, 0.01934636f, 0.06808303f, 
    0.03695913f, -0.01015998f, 0.09791302f, 0.16594051f, -0.22825713f, 0.24945356f, -0.09554802f, -0.05316013f, 
    -0.03632849f, 0.06141019f, 0.09059234f, -0.06670124f, -0.06795806f, 0.01164026f, 0.05968238f, 0.07821847f, 
    0.12773366f, -0.13299026f, -0.10769158f, 0.20393503f, -0.02455685f, 0.01318372f, -0.01029149f, 0.10090081f, 
    0.05201570f, -0.05551496f, 0.12913908f, 0.10132591f, -0.10356761f, 0.14339790f, -0.00414501f, 0.12172250f, 
    0.11973846f, -0.06035053f, -0.12673695f, 0.08470868f, 0.15924279f, -0.01959445f, 0.14836666f, -0.01542722f, 
    -0.22455274f, 0.01544952f, -0.03771274f, -0.01141987f, 0.18723759f, 0.03947026f, -0.03902982f, -0.04561796f, 
    0.00595913f, -0.05130205f, -0.10888846f, 0.06348846f, -0.33841616f, 0.05267057f, -0.23012383f, -0.21038805f, 
    -0.01491154f, 0.03982408f, -0.03088443f, 0.11946494f, 0.04773940f, 0.07310154f, 0.00119322f, 0.00398387f, 
    0.03184465f, -0.08608235f, 0.13132718f, 0.20469429f, -0.04703083f, 0.09988922f, -0.01619330f, 0.07443614f, 
    -0.08577918f, 0.03076193f, -0.06287317f, 0.00315966f, 0.33402237f, -0.28464529f, -0.00026863f, 0.06249757f, 
    -0.09548189f, -0.05207041f, 0.01137095f, -0.10639732f, -0.05596551f, -0.02549144f, -0.05248134f, 0.08907679f, 
    -0.26275772f, 0.02718546f, -0.01286943f, 0.03227628f, -0.13421175f, 0.02848130f, 0.07413172f, -0.00196346f, 
    0.00262723f, -0.07409233f, 0.02646900f, 0.06306516f, -0.09135026f, -0.04127779f, 0.10280237f, -0.10757643f, 
    0.05803625f, -0.06968878f, -0.06155687f, -0.00233067f, 0.13695979f, 0.05107350f, -0.04494948f, 0.12124862f, 
    0.06933466f, -0.16135505f, 0.05589719f, 0.05017100f, -0.01599733f, -0.01538462f, 0.15965940f, -0.00970368f, 
    0.06680472f, 0.04164205f, -0.07730701f, -0.02734771f, 0.52103835f, -0.21990751f, -0.18962765f, -0.08359089f, 
    0.05189812f, -0.00628200f, 0.00038433f, -0.03607264f, -0.01297228f, 0.01638093f, -0.05985571f, -0.08318601f, 
    0.23307225f, 0.10585425f, 0.14457923f, -0.09126498f, -0.00245360f, -0.09512473f, 0.05022150f, 0.10217705f, 
    0.10453949f, 0.07306062f, 0.02398841f, 0.07722352f, 0.18278365f, -0.04580888f, -0.00603603f, -0.03356662f, 
    0.13284068f, 0.01541155f, 0.05779982f, 0.08702231f, 0.04515338f, 0.01905177f, -0.01129856f, 0.01742547f, 
    -0.16924939f, 0.07935047f, -0.16008712f, -0.01452735f, -0.01406051f, 0.05345976f, -0.00814407f, 0.02640386f, 
    -0.22607438f, 0.07369649f, 0.08212601f, 0.00826720f, 0.02339782f, -0.07716008f, -0.01108676f, 0.08847889f, 
    0.07334992f, 0.06303310f, 0.17689750f, -0.05796600f, 0.01720422f, 0.15423091f, 0.00081673f, -0.10109124f, 
    0.00702972f, 0.12289667f, 0.03780786f, -0.02971153f, 0.08053031f, -0.03251341f, 0.02828834f, -0.10989290f, 
    -0.11433403f, -0.00400648f, -0.00994652f, -0.04246476f, 0.04792909f, -0.18481649f, 0.13607603f, 0.17425725f, 
    0.13787322f, -0.08702265f, 0.03078793f, 0.06079781f, 0.02438945f, -0.01956349f, 0.08251812f, -0.01256329f, 
    0.03683181f, -0.02388905f, 0.08240229f, -0.07903668f, 0.07049020f, 0.07145950f, -0.05326143f, -0.02573806f, 
    0.00357508f, 0.00724099f, -0.07141402f, -0.02563603f, 0.13110198f, 0.04309652f, 0.13808213f, -0.13718626f, 
    0.07491397f, 0.06883601f, -0.04263002f, -0.07711089f, 0.02055730f, 0.07698137f, 0.07389956f, -0.02659478f, 
    -0.10845974f, 0.09076703f, 0.19163765f, 0.25729087f, 0.16613387f, -0.01081494f, -0.04716007f, 0.06163678f, 
    -0.01448524f, 0.01800196f, 0.03500448f, -0.04524918f, 0.21894032f, -0.14734860f, -0.14801322f, -0.10303763f, 
    -0.02804617f, -0.01958206f, -0.05150879f, 0.05835091f, 0.00110226f, 0.06495810f, -0.07207444f, 0.06782152f, 
    0.02312206f, -0.08923414f, -0.16014580f, -0.08424211f, -0.01086089f, -0.09843323f, -0.00688892f, -0.03517253f, 
    0.00177496f, -0.12850000f, -0.00426364f, 0.00513919f, -0.23353983f, -0.08399278f, 0.03992635f, 0.07884923f, 
    0.08233119f, -0.09032237f, -0.00114024f, 0.02087471f, -0.04142078f, 0.00718390f, 0.14922087f, 0.05578695f, 
    0.09570622f, 0.23329201f, 0.04110976f, -0.03056243f, 0.04833030f, 0.09359070f, 0.07263119f, 0.01089137f, 
    -0.03591462f, 0.18135849f, -0.01094644f, -0.03978964f, -0.19880690f, -0.06706678f, 0.01065924f, -0.10105511f, 
    0.02336846f, -0.06174036f, 0.01070762f, -0.05017151f, 0.10462803f, 0.00662084f, -0.03483681f, -0.09101398f, 
    -0.01682029f, 0.04675695f, -0.22386223f, -0.11906934f, -0.13016233f, -0.00721226f, -0.01396223f, 0.04867398f, 
    -0.13671678f, 0.04999826f, -0.08296572f, -0.08985250f, 0.16640456f, 0.18319176f, -0.06479585f, 0.06342679f, 
    0.02533150f, -0.03259628f, 0.00724938f, 0.03496356f, 0.02763207f, -0.00423393f, 0.05691213f, -0.13927598f, 
    0.18652892f, 0.03146219f, 0.29569906f, 0.15961485f, 0.04082951f, 0.01112409f, 0.12248792f, 0.13993734f, 
    0.07597484f, 0.05790817f, 0.05037258f, -0.03934015f, -0.15404174f, 0.06736290f, -0.09248569f, -0.07321877f, 
    -0.02621101f, -0.02663702f, -0.03968034f, 0.09633466f, -0.00735137f, -0.13130294f, 0.05357290f, -0.13556953f, 
    0.08780474f, 0.17455587f, 0.07540836f, -0.14785825f, 0.12204177f, 0.12260073f, 0.08159397f, 0.02522893f, 
    0.00872241f, -0.02095425f, 0.14430672f, 0.06831206f, -0.01116784f, 0.10860715f, 0.07664674f, 0.01273680f, 
    -0.21708219f, -0.02571553f, 0.13188848f, -0.02481299f, 0.07951056f, -0.00496206f, 0.04568902f, 0.07197484f, 
    0.05255767f, -0.11445396f, 0.07727026f, 0.04664413f, 0.03455129f, -0.14727934f, -0.01993409f, 0.06158353f, 
    0.07701071f, 0.03591349f, -0.01334093f, -0.01600200f, 0.05599617f, 0.31949610f, -0.00785484f, 0.01551131f, 
    0.14560369f, 0.02554996f, 0.00108306f, -0.05605038f, -0.21893370f, -0.07491029f, 0.04675187f, -0.00628701f, 
    -0.11642767f, 0.22716334f, 0.15925536f, -0.08593875f, 0.07633539f, 0.00613532f, 0.05105809f, -0.00459178f, 
    -0.13514385f, 0.09540937f, -0.06096769f, 0.01552138f, -0.17804322f, 0.09535118f, 0.04222650f, 0.29657391f, 
    -0.08616401f, 0.02726395f, -0.06593301f, -0.01147192f, -0.01984099f, -0.07401798f, 0.04606221f, -0.03201193f, 
    0.01347915f, -0.06292788f, -0.06504317f, -0.00893245f, -0.09593005f, 0.08769336f, 0.00808204f, -0.06305503f, 
    -0.03383150f, -0.06440921f, -0.02807396f, -0.06261823f, -0.06387415f, 0.00648600f, -0.10371517f, 0.09764120f, 
    0.00514100f, -0.07066574f, -0.02551661f, -0.08765457f, -0.04054181f, -0.00007785f, 0.04228811f, -0.05121584f, 
    -0.05012509f, -0.07129732f, -0.05496660f, -0.07254626f, -0.04183698f, -0.08701211f, -0.00693110f, -0.08226376f, 
    0.01713434f, -0.00907385f, -0.03137496f, -0.09422334f, -0.06932110f, -0.18876259f, 0.31358659f, 0.18143246f, 
    0.08631340f, 0.03333597f, 0.01726655f, 0.12114776f, 0.00003050f, -0.13795245f, -0.05593999f, 0.15208028f, 
    -0.00385977f, 0.18913817f, 0.11000384f, -0.08083873f, -0.07374663f, -0.03843668f, -0.12140572f, 0.07967756f, 
    -0.11074592f, -0.05659553f, 0.01558293f, -0.05099855f, -0.17287044f, 0.11545730f, -0.11773826f, 0.10812181f, 
    -0.15653037f, -0.05845475f, -0.02496438f, 0.04965575f, -0.08707042f, 0.15282556f, -0.01625356f, 0.00937144f, 
    -0.06993991f, 0.09555394f, -0.00036328f, 0.08503333f, 0.02203412f, -0.00600102f, -0.06070817f, 0.00771565f, 
    0.08157793f, -0.03659273f, -0.00688170f, -0.02706452f, 0.12946858f, -0.10989098f, 0.21469130f, 0.04378375f, 
    -0.07614667f, -0.01652250f, 0.17691742f, 0.10730709f, 0.05360429f, 0.01297645f, -0.11545978f, -0.01475701f, 
    0.20966487f, 0.04459521f, -0.04959077f, 0.10624810f, -0.07140265f, -0.04480037f, -0.03097408f, 0.07458896f, 
    -0.06543329f, 0.21031909f, -0.02476888f, -0.02070750f, -0.00409674f, 0.05907037f, 0.15358947f, 0.12081167f, 
    0.16160621f, -0.01024826f, -0.02853296f, 0.07062494f, 0.03419911f, 0.04664877f, 0.02885064f, -0.08891950f, 
    0.07597365f, -0.01121901f, 0.21278214f, 0.17592210f, 0.00115320f, 0.03756676f, 0.11783454f, -0.10604728f, 
    0.08961488f, 0.06214231f, -0.04090469f, 0.05864624f, 0.00837187f, 0.03203947f, 0.20384976f, 0.05297683f, 
    0.04621890f, -0.14976008f, 0.00592669f, 0.12004937f, -0.10018268f, 0.17265028f, 0.11930782f, -0.04365319f, 
    -0.05029757f, -0.09483138f, 0.01160265f, -0.21928222f, 0.01621561f, 0.07889961f, -0.04540474f, -0.02623529f, 
    -0.04578942f, -0.07851619f, 0.04422880f, 0.00330754f, 0.21456301f, 0.01588983f, 0.21298908f, -0.02058559f, 
    0.07980590f, 0.10281685f, 0.01075551f, -0.08699909f, 0.06350479f, -0.09713355f, 0.06435563f, 0.01279123f, 
    -0.10347158f, -0.11311033f, 0.10664117f, 0.05017556f, 0.04352871f, -0.04367318f, 0.06431457f, -0.04069943f, 
    0.02226584f, 0.06620738f, 0.04455367f, 0.04528736f, -0.04353854f, 0.04716316f, 0.09466409f, -0.02518685f, 
    -0.15984482f, -0.07581130f, -0.02873502f, 0.02943956f, -0.02667698f, 0.04858687f, -0.10050136f, 0.11309478f, 
    0.00825536f, 0.02880984f, -0.00022229f, -0.11800109f, 0.09282932f, 0.09057633f, -0.07096509f, 0.05030325f, 
    0.02255548f, -0.03500554f, -0.00405782f, 0.07561763f, 0.15167053f, -0.10063660f, 0.06205949f, -0.00635554f, 
    -0.07025808f, 0.12577720f, 0.05864085f, -0.09858352f, 0.11689169f, -0.01355604f, -0.11248285f, 0.05971995f, 
    0.12250000f, 0.08340780f, 0.12962928f, 0.10289951f, -0.11880380f, -0.03525136f, 0.03722188f, -0.07401484f, 
    -0.06980364f, 0.04353683f, -0.14494218f, 0.02967176f, 0.14876847f, 0.08279321f, -0.04296151f, 0.18955375f, 
    0.14118187f, -0.06832103f, -0.00446436f, -0.05828508f, -0.08538447f, 0.03594832f, -0.11918900f, 0.01039492f, 
    -0.00762025f, -0.09648025f, 0.13836461f, -0.05900282f, 0.09307785f, 0.05982329f, 0.07717866f, -0.04417911f, 
    0.05282594f, -0.03095544f, 0.16574579f, -0.01540389f, 0.11563916f, 0.07254428f, 0.20511435f, 0.06504934f, 
    -0.01720529f, 0.06732660f, -0.03790518f, 0.03548210f, -0.08012928f, 0.08795629f, -0.00578089f, -0.09636620f, 
    -0.06429023f, -0.00844500f, 0.08319612f, 0.11300053f, 0.11275007f, 0.06949890f, -0.00194805f, 0.00687871f, 
    -0.00325934f, -0.00124869f, 0.03091584f, 0.10648408f, 0.16652292f, 0.25860506f, -0.01380059f, 0.02201073f, 
    0.04004667f, -0.03701517f, 0.03138274f, 0.03963238f, 0.04608958f, 0.01360275f, 0.06734777f, 0.08252788f, 
    0.25586250f, -0.20964992f, -0.10589644f, -0.00952268f, 0.04461053f, -0.03493492f, 0.08934720f, -0.02348301f, 
    0.09618042f, 0.06161496f, 0.15923780f, 0.07067531f, 0.08728044f, 0.06665904f, 0.05554973f, 0.05911972f, 
    0.05486279f, 0.10759991f, 0.09447411f, -0.12685814f, -0.02231693f, 0.08798984f, -0.00421735f, 0.03567281f, 
    0.34122184f, -0.04710732f, 0.09536357f, -0.03889171f, -0.08163252f, 0.06496526f, -0.10146519f, 0.05793674f, 
    0.03847755f, 0.02277783f, -0.16057949f, 0.07963967f, 0.11639687f, 0.14507495f, 0.17298490f, 0.09373006f, 
    0.18245570f, -0.07209850f, -0.09601195f, -0.08055864f, -0.09652901f, -0.01643976f, 0.01540547f, -0.00741740f, 
    0.17410965f, -0.04440851f, -0.10675629f, -0.15040155f, -0.04844633f, 0.10733678f, 0.09359079f, -0.02291922f, 
    0.04655507f, -0.07400659f, 0.14523886f, 0.09599378f, -0.16096912f, -0.19963484f, 0.01093433f, -0.15924338f, 
    0.02195592f, -0.06349126f, 0.10019025f, 0.06185061f, 0.02379506f, 0.04406471f, -0.02046378f, 0.01093655f, 
    0.17123522f, -0.03281416f, 0.04941760f, -0.05071343f, -0.01639146f, 0.10213061f, -0.02132449f, -0.08289500f, 
    0.08073283f, -0.01902135f, -0.06199036f, -0.02517157f, -0.08099180f, -0.01004304f, 0.13497898f, -0.15801778f, 
    0.07559980f, 0.07487990f, 0.11419021f, 0.00445400f, 0.12454019f, 0.00088503f, 0.02455541f, 0.11973419f, 
    0.08101927f, 0.11272389f, -0.02458995f, -0.07376877f, 0.08073304f, -0.06507716f, 0.04013664f, -0.05714085f, 
    0.04442409f, 0.01684434f, -0.06670405f, 0.11115459f, 0.06805195f, 0.03644989f, 0.16219456f, -0.10996634f, 
    0.00564574f, -0.04467207f, 0.10842624f, -0.00485825f, 0.11078592f, 0.05344657f, 0.09765817f, -0.03624544f, 
    -0.11343629f, -0.13672984f, 0.02772629f, -0.04158305f, -0.00004037f, 0.00839752f, 0.03673373f, 0.09301882f, 
    0.04105102f, -0.06531557f, 0.06132289f, 0.14360888f, -0.06708965f, -0.01647728f, -0.24192679f, -0.12737958f, 
    0.05384533f, 0.15549959f, 0.02561351f, 0.02831775f, 0.03771629f, -0.01220743f, -0.10150804f, 0.01907134f, 
    -0.10530388f, -0.08756827f, -0.04963381f, -0.05763387f, 0.02186718f, -0.00072026f, 0.13490145f, 0.02510260f, 
    -0.05719011f, 0.00847662f, 0.07345571f, 0.04239092f, 0.09189513f, -0.02480418f, 0.10381350f, 0.06779712f, 
    0.00124851f, -0.03993443f, 0.04958335f, -0.01415849f, 0.05039682f, -0.02154977f, 0.03273073f, 0.03698508f, 
    -0.00957017f, -0.12477930f, 0.01919194f, -0.09928165f, 0.05014665f, 0.08613740f, 0.06816492f, 0.05832306f, 
    -0.01470978f, 0.03152810f, 0.03967512f, -0.00350474f, 0.26448017f, 0.04407134f, -0.31310296f, -0.00275176f, 
    0.08480419f, -0.04064392f, -0.09515195f, 0.01753098f, -0.01810706f, 0.05738265f, 0.11597447f, -0.05041324f, 
    0.18344495f, 0.23515931f, -0.14712922f, -0.09833772f, -0.01421878f, -0.02014159f, 0.02133349f, -0.05134053f, 
    0.03457729f, -0.16441691f, -0.08624391f, -0.06089839f, -0.25131732f, -0.07109768f, -0.01564980f, -0.10451978f, 
    -0.06345367f, -0.02153765f, 0.13875853f, 0.04375970f, 0.05233284f, 0.07682196f, 0.10075603f, -0.01945172f, 
    -0.32790649f, -0.02452572f, -0.03832822f, -0.07883616f, -0.00317710f, -0.05448354f, -0.00315290f, -0.02912821f, 
    -0.00324029f, 0.06901769f, 0.05955825f, -0.05880392f, 0.21427126f, -0.12598652f, 0.00878404f, -0.07065466f, 
    0.02942299f, 0.02070846f, 0.05517504f, -0.04182782f, 0.07150652f, -0.09036209f, -0.03021116f, -0.01319189f, 
    0.02940819f, 0.06429099f, 0.04297404f, 0.03370516f, 0.06419541f, 0.04538852f, 0.01120195f, -0.07843304f, 
    -0.02079174f, 0.05551720f, 0.04090041f, -0.02877720f, 0.31471330f, -0.24119978f, -0.04510659f, 0.03713626f, 
    -0.03005145f, -0.01516384f, 0.03553687f, -0.00558076f, 0.02754892f, 0.02693169f, -0.05894080f, -0.02110454f, 
    0.07406002f, 0.00133704f, 0.00094868f, 0.23757835f, 0.08221202f, 0.06799128f, -0.12306010f, -0.03918449f, 
    -0.06039600f, -0.02272439f, 0.00698085f, -0.07639626f, 0.16905347f, 0.05830264f, 0.00095282f, 0.05803277f, 
    0.03152334f, 0.09105639f, -0.00513588f, -0.07124037f, -0.02283124f, 0.11352106f, 0.09605380f, 0.08585178f, 
    0.08510207f, 0.17507434f, -0.06133864f, -0.11373636f, -0.00506557f, -0.04696694f, -0.00654003f, 0.15006922f, 
    0.08337499f, -0.00571196f, -0.00736868f, -0.03301876f, 0.16997558f, -0.04217104f, -0.08727869f, 0.10242289f, 
    -0.03891554f, 0.00904979f, -0.12343930f, 0.13289095f, 0.04613438f, 0.05658191f, 0.01210501f, 0.01552049f, 
    0.28253487f, -0.08844258f, 0.01247878f, -0.21775745f, -0.01511973f, -0.01382428f, 0.05288508f, 0.04305915f, 
    0.07214552f, -0.02808899f, 0.02998542f, 0.07454024f, -0.11113850f, -0.09658765f, -0.03401718f, -0.02981580f, 
    0.02126844f, 0.07222805f, -0.05379445f, 0.01679467f, 0.16822605f, -0.03954792f, 0.02590880f, 0.06258707f, 
    -0.16742049f, 0.08054402f, -0.07642207f, -0.06418612f, 0.15651178f, 0.00504106f, 0.03385570f, -0.06834135f, 
    -0.08283623f, 0.01226730f, 0.19873425f, 0.03489535f, -0.11717977f, -0.05009106f, -0.15709160f, -0.17497021f, 
    0.10901175f, 0.09428014f, -0.06666855f, -0.04898006f, -0.00592327f, -0.10193356f, -0.06987292f, -0.09835441f, 
    -0.19968419f, 0.01781840f, -0.06456938f, -0.25076607f, 0.10649695f, 0.15506247f, 0.06058858f, -0.07146581f, 
    -0.12496503f, -0.01585262f, 0.00669126f, 0.09152602f, 0.21093301f, 0.15929464f, -0.07041828f, -0.05659690f, 
    -0.07812837f, 0.08107510f, -0.01510666f, 0.07998500f, -0.11561445f, 0.04146060f, 0.06427746f, 0.05466774f, 
    0.22346693f, 0.12533192f, 0.12725575f, -0.01559880f, 0.10322408f, 0.05808565f, -0.01304878f, 0.00992466f, 
    0.11934251f, 0.05712259f, -0.02830959f, 0.06639034f, -0.14514959f, 0.00217980f, 0.01104976f, 0.11732472f, 
    0.13439776f, 0.11302011f, 0.06479684f, -0.05044274f, 0.09978095f, -0.04849669f, 0.04846654f, -0.09926859f, 
    -0.02400885f, 0.03361857f, 0.22590992f, 0.15397269f, -0.01792313f, -0.00588948f, 0.08776280f, 0.11850565f, 
    0.00607235f, 0.00218130f, -0.02257814f, -0.04875284f, 0.04606766f, 0.02642469f, -0.01938320f, -0.01650922f, 
    0.09899776f, 0.01455077f, 0.00986425f, -0.04532734f, 0.03359723f, 0.03370065f, 0.01181275f, 0.09981734f, 
    0.45023933f, -0.09109962f, -0.05387884f, 0.24115814f, -0.06447712f, -0.05242040f, 0.08422268f, 0.04346593f, 
    0.01131985f, 0.10689235f, 0.15107362f, 0.11514010f, -0.43588075f, 0.22539859f, -0.16677299f, 0.06681476f, 
    0.12397052f, -0.06860818f, 0.05974837f, -0.02160511f, -0.03885492f, 0.07143909f, 0.03220070f, -0.03616039f, 
    0.06634741f, -0.17727654f, -0.01159836f, 0.17650728f, -0.03564762f, -0.14891005f, 0.02599931f, -0.02004021f, 
    0.04477476f, -0.11823875f, -0.10836013f, -0.01305402f, -0.23553512f, 0.14465186f, 0.05931898f, 0.21780252f, 
    -0.03787598f, -0.08053167f, -0.07765859f, 0.02829960f, 0.21473347f, -0.01061182f, 0.12861148f, 0.05939238f, 
    -0.34622264f, -0.06900474f, -0.20650873f, -0.08479611f, 0.18050206f, 0.02244736f, 0.01324070f, -0.03725183f, 
    -0.00540225f, 0.04709996f, 0.04668806f, 0.15558736f, 0.05813915f, 0.02548306f, -0.08519452f, 0.03760089f, 
    0.02872767f, -0.07836082f, -0.04631394f, 0.17386530f, 0.07340841f, 0.09281091f, 0.11597308f, 0.03048095f, 
    0.08559790f, -0.02898978f, 0.20155695f, 0.04753713f, -0.10074969f, 0.06012316f, -0.07687560f, -0.05196775f, 
    -0.06060262f, -0.00650466f, -0.03011211f, 0.05590011f, 0.32299414f, -0.20334898f, -0.04667168f, 0.10864668f, 
    0.00796117f, 0.03604808f, -0.04412051f, 0.00161115f, 0.04774829f, 0.00185055f, -0.03231147f, 0.10154849f, 
    -0.23337270f, 0.05909818f, -0.08883145f, 0.08270981f, 0.00334268f, 0.10352604f, 0.01995486f, 0.02969433f, 
    0.01093945f, -0.00491377f, 0.07398539f, -0.00408622f, -0.26940966f, -0.14019749f, 0.03939853f, -0.16202460f, 
    0.08392476f, -0.09740977f, -0.04868001f, -0.00503364f, 0.05326439f, 0.06534222f, -0.04766964f, 0.08531173f, 
    0.14861371f, 0.03180471f, -0.01222850f, 0.09888504f, -0.03504396f, -0.11940106f, 0.09457500f, -0.04942044f, 
    0.07829376f, 0.01014758f, -0.14036824f, 0.01283460f, 0.33375618f, -0.22455895f, -0.15565839f, -0.01317526f, 
    0.07355352f, 0.03349419f, -0.00668244f, 0.04062278f, -0.02052177f, 0.06034751f, 0.00262125f, 0.02641414f, 
    0.12263693f, 0.07055198f, 0.04405942f, -0.11354364f, -0.05320435f, -0.17235698f, 0.07997949f, 0.09698039f, 
    0.09848739f, -0.14013162f, -0.01788787f, -0.00013830f, 0.13279352f, -0.08975533f, -0.00126810f, 0.13782647f, 
    0.02318039f, 0.00243477f, 0.08976052f, 0.07428063f, -0.03266883f, -0.05369601f, 0.01721718f, -0.01045352f, 
    -0.13489947f, 0.00099377f, -0.00384479f, 0.10265277f, 0.06427341f, 0.00449029f, 0.01985054f, 0.03654855f, 
    0.00640189f, 0.02177451f, 0.05669689f, -0.01477330f, 0.07948653f, -0.00274628f, 0.01355021f, 0.19221188f, 
    0.03873733f, -0.07643477f, 0.08823355f, -0.10076478f, 0.08265861f, 0.13939255f, 0.00510577f, -0.05297684f, 
    -0.15145591f, -0.07800763f, -0.08795855f, -0.25916186f, 0.12501626f, -0.02100546f, -0.03676344f, -0.09575408f, 
    -0.09609716f, -0.01679338f, 0.10636389f, -0.05450080f, 0.22193719f, -0.04747599f, 0.16446403f, 0.17912722f, 
    0.02126030f, -0.09954500f, 0.04646421f, -0.01153494f, -0.02869979f, -0.05110546f, 0.05787703f, 0.03452762f, 
    -0.03378110f, -0.11674523f, 0.11135638f, -0.12355439f, 0.13565794f, 0.07208953f, -0.02904012f, -0.05067797f, 
    0.07128586f, 0.03532148f, -0.01618646f, -0.05819173f, -0.01982865f, -0.03971303f, 0.02556589f, -0.16633645f, 
    0.13259049f, 0.08554026f, 0.03229703f, -0.03148989f, 0.06042309f, 0.07816281f, 0.00104961f, -0.01659697f, 
    0.11888486f, 0.16978182f, 0.12674290f, 0.22263150f, 0.00643256f, 0.00880167f, -0.14882262f, 0.07040298f, 
    -0.03973070f, 0.02734716f, -0.01354857f, -0.15949138f, 0.33255485f, -0.08216556f, -0.06492723f, -0.11917981f, 
    -0.00441390f, -0.06438851f, -0.03979269f, 0.02226617f, -0.03291393f, 0.14739612f, -0.10202051f, 0.07267346f, 
    -0.05682212f, -0.06438907f, -0.17566246f, 0.01594515f, 0.07289696f, -0.00944789f, 0.08904903f, -0.03820889f, 
    -0.11170308f, -0.04628330f, -0.02121450f, -0.02768299f, -0.24458250f, -0.06869742f, 0.00329330f, 0.07316099f, 
    -0.02573767f, -0.02087320f, -0.09344023f, -0.12207910f, -0.01777014f, -0.04713954f, 0.06216086f, 0.08861836f, 
    0.12780334f, 0.06556559f, 0.07043541f, 0.06509028f, 0.00998902f, -0.02006190f, -0.06847291f, -0.03649393f, 
    0.10711759f, 0.10184061f, -0.05270961f, -0.03498546f, 0.20413551f, 0.06468409f, -0.00865222f, -0.14873150f, 
    -0.00601751f, -0.05872812f, 0.01234679f, 0.06224454f, 0.08572014f, -0.01494313f, 0.04409547f, 0.07962565f, 
    0.41102865f, 0.21580876f, -0.03527588f, -0.34945264f, -0.03545741f, -0.08254500f, -0.05581084f, 0.00041594f, 
    0.01046675f, 0.03687662f, -0.06525644f, -0.04834552f, 0.21705976f, 0.04125302f, 0.09133888f, 0.02813362f, 
    -0.11877517f, -0.02152822f, -0.11047299f, -0.03746384f, 0.08186479f, 0.01875587f, 0.02982029f, -0.08803953f, 
    -0.10003342f, 0.36869743f, 0.02558980f, 0.08182886f, 0.07464099f, 0.18489939f, -0.06805956f, 0.01999815f, 
    -0.04364132f, 0.04779813f, -0.06153382f, -0.11379475f, 0.15413098f, 0.15163213f, 0.10816553f, -0.00824160f, 
    0.03972865f, -0.00270954f, -0.11495860f, 0.02994335f, 0.12673232f, 0.00553491f, 0.00459047f, -0.07502155f, 
    -0.06007960f, -0.12548460f, -0.03414017f, -0.11164373f, 0.12188350f, 0.06454980f, 0.01173838f, 0.03152894f, 
    0.01821141f, -0.07124836f, 0.11062373f, 0.01089504f, 0.08548461f, -0.02748027f, -0.05251510f, -0.08929742f, 
    -0.04266661f, 0.08381677f, 0.08193301f, 0.16168042f, 0.15566541f, -0.04153927f, 0.04429705f, 0.10380342f, 
    -0.01108902f, 0.01710075f, -0.02044802f, -0.05926163f, 0.00558800f, -0.01152973f, -0.01593244f, 0.08050559f, 
    0.02211457f, -0.04723276f, 0.04094788f, -0.00465781f, 0.15203758f, 0.33748880f, -0.18841399f, 0.28120849f, 
    0.09669910f, -0.16521706f, -0.00999428f, -0.10842335f, 0.00066490f, -0.06659605f, 0.06609794f, 0.08056349f, 
    0.04472382f, -0.03010901f, 0.05137973f, -0.10321971f, 0.14463072f, -0.00083607f, 0.12181982f, 0.09228523f, 
    -0.18750405f, 0.02465554f, 0.11970971f, -0.00560350f, -0.05172110f, -0.25003850f, 0.17960773f, 0.25988668f, 
    0.01881265f, 0.09382945f, -0.08653943f, -0.01801564f, 0.00093871f, -0.00106920f, 0.06742329f, 0.04112676f, 
    0.36807638f, 0.15182227f, -0.06168709f, -0.11081294f, -0.12991609f, -0.01289759f, 0.02501947f, -0.00598866f, 
    0.07528813f, 0.06890479f, 0.01998702f, -0.05211988f, 0.04713615f, 0.06516571f, -0.13164113f, -0.01337648f, 
    0.08992438f, -0.09082765f, -0.02406916f, 0.10926200f, 0.06782375f, -0.04517217f, -0.00874252f, 0.20150909f, 
    -0.40557924f, 0.19347921f, -0.28832346f, -0.00286296f, 0.27608642f, 0.03656858f, 0.06793053f, 0.00489878f, 
    -0.03657893f, 0.05253094f, -0.05855149f, -0.17392583f, -0.05995061f, -0.21464914f, 0.14248876f, 0.17728484f, 
    -0.16416974f, -0.02320048f, -0.03517552f, 0.15181848f, -0.08703029f, -0.05107732f, 0.12342251f, -0.00292678f, 
    0.22767165f, -0.02337943f, 0.02845572f, 0.28844026f, -0.01991173f, -0.08900744f, -0.06694719f, 0.08488624f, 
    0.00232003f, -0.02012730f, -0.07030555f, 0.01417737f, 0.26094881f, 0.29791492f, -0.00018027f, -0.10804635f, 
    0.02929246f, -0.06338291f, 0.00931352f, -0.00987595f, 0.06826650f, 0.09420407f, 0.00184137f, 0.00482437f, 
    -0.03623126f, -0.15943500f, -0.09089193f, 0.17629071f, 0.02059076f, 0.04821167f, 0.03197961f, -0.03294153f, 
    0.04392118f, -0.02052600f, -0.07900123f, -0.00640356f, 0.02786524f, -0.00468477f, 0.11773401f, 0.08959836f, 
    -0.22846571f, -0.00124433f, 0.00809684f, 0.09987552f, 0.02053553f, -0.11183950f, -0.02529548f, -0.00860283f, 
    0.11795877f, -0.14049886f, 0.01642887f, -0.01581401f, -0.04987468f, -0.02510913f, -0.05194845f, -0.06932606f, 
    -0.01077836f, 0.15185143f, 0.14799117f, -0.04625004f, -0.22280486f, 0.03694034f, -0.00636252f, 0.16792877f, 
    0.04251110f, 0.14990349f, -0.06994466f, -0.03967409f, 0.10717283f, -0.01779192f, -0.09654894f, -0.07329623f, 
    -0.40813500f, 0.07294699f, -0.00756122f, 0.01166204f, -0.19414641f, 0.04787072f, 0.07693820f, 0.04957739f, 
    0.01239329f, -0.01263023f, 0.05613013f, 0.18409297f, -0.15898907f, 0.05206706f, 0.01869447f, 0.04516151f, 
    0.12043960f, -0.08557758f, 0.02316513f, 0.13492151f, -0.09528138f, 0.04314778f, 0.15055937f, -0.00566809f, 
    0.07875306f, 0.09705515f, -0.03774847f, -0.23008309f, -0.09790441f, -0.09360558f, -0.03356112f, 0.09893387f, 
    -0.00571574f, -0.03697139f, -0.04333008f, 0.08442079f, -0.00973540f, -0.24296595f, -0.02838873f, -0.05465858f, 
    0.09375708f, 0.07259815f, 0.03201868f, -0.04051195f, 0.11626118f, 0.10223898f, 0.00361601f, 0.00831908f, 
    -0.16090684f, 0.07764877f, 0.01502904f, -0.16119698f, 0.07988878f, -0.01291676f, 0.09228981f, 0.15468957f, 
    0.02267280f, 0.01482332f, -0.03372468f, 0.19467217f, -0.00334376f, 0.11413150f, 0.10604740f, -0.08646663f, 
    -0.02949436f, 0.02059193f, 0.17294767f, 0.04769988f, -0.03399792f, 0.08162833f, -0.00684398f, 0.12900023f, 
    -0.19573459f, -0.04784069f, -0.07119650f, -0.00720877f, 0.25576150f, 0.21102980f, -0.05451735f, 0.02412543f, 
    0.06832877f, 0.07132752f, 0.04052399f, -0.00040882f, -0.50606602f, 0.22725311f, -0.19160074f, -0.05207138f, 
    0.05114724f, -0.01476340f, -0.10511758f, -0.07935561f, 0.00495830f, 0.01765956f, -0.04338969f, 0.10605249f, 
    -0.47608322f, -0.03209818f, -0.05676364f, 0.07198298f, -0.08905002f, -0.04270982f, 0.09830958f, 0.00935807f, 
    -0.03796653f, 0.00410566f, 0.04472742f, -0.03502703f, 0.14714898f, -0.06374390f, 0.31444260f, 0.18309489f, 
    -0.04915475f, 0.02183158f, 0.11970332f, -0.10156925f, 0.08553273f, 0.05255685f, -0.02065183f, -0.03784259f, 
    -0.04562560f, 0.03944001f, 0.02365915f, 0.00237663f, 0.12334158f, -0.00007456f, 0.00210973f, -0.04548618f, 
    -0.04175418f, -0.14286235f, -0.02278247f, -0.02217909f, -0.05303704f, -0.00707700f, 0.03528033f, -0.13493535f, 
    0.09246717f, -0.01358547f, 0.01751290f, -0.00659999f, 0.04234229f, -0.04325285f, -0.18330908f, -0.07572612f, 
    -0.02753774f, -0.00702846f, -0.11259340f, -0.01740631f, 0.01914471f, 0.00433602f, 0.11175619f, -0.06956001f, 
    -0.06920292f, -0.01484724f, -0.00095328f, 0.11416715f, 0.00550019f, 0.24066083f, 0.07566618f, 0.02878886f, 
    -0.03803455f, 0.03087017f, -0.10026832f, 0.05872772f, -0.11277020f, -0.01124729f, 0.08614159f, 0.05070956f, 
    -0.28096154f, 0.43885618f, 0.13475212f, 0.11025215f, 0.07249760f, 0.04593005f, 0.02276343f, -0.09305817f, 
    0.02907413f, -0.00346390f, 0.11156611f, 0.00297111f, 0.03594734f, -0.06610978f, 0.10275609f, 0.08300610f, 
    -0.06071928f, -0.01312419f, 0.04813295f, -0.05312477f, 0.10542975f, -0.03404281f, -0.02494931f, -0.05247542f, 
    -0.12335331f, 0.25762466f, -0.13645343f, -0.11077107f, 0.17472978f, -0.03079294f, 0.06936437f, -0.05472951f, 
    0.04449620f, 0.00228390f, 0.11733989f, -0.11691254f, 0.12071359f, -0.00952930f, 0.03017124f, -0.07991734f, 
    0.06517811f, 0.03945505f, -0.07580420f, -0.06962247f, -0.07203381f, -0.01196181f, -0.05547144f, 0.12470616f, 
    0.12135159f, -0.00695749f, -0.02701949f, -0.10195329f, -0.01152415f, 0.02080628f, -0.00264785f, -0.04699947f, 
    0.02203570f, -0.01031255f, 0.19159383f, 0.09046841f, 0.06885263f, -0.04579108f, 0.07782263f, -0.00082409f, 
    0.05377769f, -0.04918389f, 0.03694282f, 0.00811698f, -0.05805162f, -0.00025248f, 0.07247686f, 0.05100997f, 
    -0.01658652f, 0.16157088f, -0.02175356f, -0.06267294f, 0.13063289f, -0.03678665f, -0.01424890f, -0.02360671f, 
    0.00049041f, -0.02865859f, -0.06754435f, -0.02806936f, -0.09408811f, -0.15817264f, 0.16869235f, 0.23957776f, 
    0.04053826f, 0.04759135f, -0.05217144f, 0.06927985f, 0.16453049f, 0.14185296f, -0.01395142f, 0.00080022f, 
    -0.02816306f, -0.02199979f, 0.08712015f, 0.06424776f, 0.02613222f, -0.09057854f, 0.03917860f, -0.05470002f, 
    -0.03039687f, 0.09479272f, 0.03130089f, 0.09614056f, 0.11594874f, -0.03549413f, 0.02225317f, 0.01988331f, 
    -0.01263527f, 0.06828128f, 0.01997018f, 0.17617603f, -0.06007525f, 0.06876957f, 0.11130975f, 0.08960041f, 
    0.05619012f, -0.04955283f, -0.01176515f, 0.02854853f, 0.09352224f, 0.03315187f, -0.00749949f, -0.01345935f, 
    -0.01716483f, 0.05683899f, -0.01424009f, 0.13049862f, -0.13036910f, -0.05741427f, 0.22226822f, 0.12504481f, 
    -0.11930153f, -0.04160253f, 0.03665014f, 0.03787616f, 0.02013838f, 0.09892446f, -0.10430720f, 0.06232083f, 
    0.11752460f, 0.01854117f, 0.07726374f, 0.07503867f, 0.02369363f, -0.10267366f, -0.01668533f, 0.00892065f, 
    0.03852389f, -0.00793914f, -0.02886289f, 0.09801724f, -0.05061034f, -0.13011195f, 0.04607844f, 0.06802938f, 
    -0.12090763f, -0.01131938f, -0.06785903f, -0.04595836f, -0.01213091f, 0.01630784f, -0.08251661f, 0.02716748f, 
    0.18818575f, 0.29148161f, 0.05845552f, 0.37910244f, 0.10504738f, 0.00293376f, 0.05503849f, 0.04688403f, 
    -0.04868354f, 0.02381809f, -0.03944193f, 0.06833602f, 0.01283572f, -0.13129535f, 0.10996762f, -0.03038821f, 
    -0.02933096f, 0.09831007f, -0.01308353f, 0.03700943f, 0.07276718f, -0.06682180f, 0.03460842f, 0.11026093f, 
    0.09234269f, -0.02494309f, 0.02079134f, -0.05582037f, -0.04925335f, -0.05718302f, -0.03145873f, -0.03503753f, 
    -0.01064700f, -0.12288230f, -0.03607066f, -0.08020372f, -0.15241940f, 0.23169269f, -0.18751907f, 0.42889425f, 
    0.12499749f, 0.09745076f, -0.05866006f, 0.03681253f, 0.01555028f, -0.07446872f, -0.01912235f, -0.03173713f, 
    0.04285465f, -0.01367947f, 0.06928865f, 0.06138773f, -0.03031682f, 0.05741882f, -0.02016348f, -0.05118877f, 
    -0.18061115f, -0.03246186f, 0.04445669f, -0.02218019f, 0.11725321f, 0.13079700f, -0.01345857f, 0.27957171f, 
    0.00236955f, 0.02541103f, 0.07633847f, 0.06542373f, 0.07497974f, -0.09145671f, -0.10757722f, -0.11851335f, 
    -0.13516808f, 0.02328246f, 0.12550142f, -0.21178319f, 0.07383874f, -0.05812393f, 0.03259474f, 0.05662031f, 
    0.06721951f, 0.00843420f, -0.04875305f, 0.14257371f, -0.41016826f, -0.01609176f, -0.07253261f, -0.11049030f, 
    0.08320781f, -0.02535669f, 0.01152563f, 0.00196743f, 0.14145495f, -0.00435088f, -0.01005047f, 0.13322423f, 
    -0.23866966f, 0.13704209f, 0.09400413f, -0.10703554f, 0.18788940f, 0.01510594f, -0.05423887f, -0.07436766f, 
    -0.00442547f, -0.02855939f, -0.06200675f, -0.17994900f, -0.16061813f, -0.04825712f, 0.11468971f, -0.17969239f, 
    0.02862693f, 0.05990683f, 0.06192917f, -0.03460811f, -0.01215730f, 0.04661423f, 0.07143588f, -0.00856717f, 
    0.20676000f, 0.02817036f, -0.24546324f, 0.02513217f, 0.06487362f, 0.06433630f, -0.09412494f, 0.01007072f, 
    -0.00366568f, 0.09055437f, -0.00259689f, -0.03228117f, -0.28330582f, 0.23911913f, -0.08863071f, -0.18187660f, 
    0.00734071f, -0.08480009f, -0.20110078f, -0.05630311f, -0.10604800f, 0.09466243f, 0.11219120f, 0.02420910f, 
    -0.25124553f, -0.13310248f, 0.10061114f, 0.06312282f, -0.03787790f, 0.11091806f, 0.06748565f, 0.01157511f, 
    0.03438237f, 0.05934134f, -0.03549105f, -0.03069029f, -0.11200844f, 0.01720070f, 0.19190592f, 0.11402790f, 
    0.05074571f, 0.13273810f, -0.00402905f, -0.12549621f, -0.00750697f, 0.03321316f, 0.13801603f, -0.01626563f, 
    -0.01574786f, -0.03246691f, -0.02763872f, -0.04865580f, -0.03813231f, 0.03412472f, -0.01194147f, -0.00549624f, 
    -0.04223983f, 0.03212794f, 0.01111137f, -0.02034093f, -0.05949719f, -0.02390852f, -0.02822304f, 0.01482761f, 
    0.01576168f, -0.01625076f, -0.04906182f, -0.00777272f, -0.05577162f, 0.01912569f, -0.01363348f, -0.02881035f, 
    -0.02990441f, -0.06576270f, 0.02545095f, 0.05274074f, 0.03247196f, 0.01153139f, 0.03677043f, 0.00055295f, 
    -0.05953981f, -0.04242988f, -0.00436390f, -0.02689111f, 0.03351495f, 0.03172651f, -0.04203152f, -0.03813655f, 
    -0.04070430f, -0.01608925f, -0.03515477f, -0.02820905f, -0.06356657f, 0.03805394f, 0.01753319f, -0.05360029f, 
    -0.02033908f, -0.00654208f, -0.05551162f, 0.01726446f, 0.00029669f, -0.00000892f, -0.01073421f, 0.04707265f, 
    -0.02603693f, -0.02263935f, 0.00952263f, -0.03023344f, -0.05302271f, 0.01815257f, -0.04864594f, -0.04473992f, 
    0.00442511f, -0.02340673f, -0.01360117f, 0.03784300f, 0.03751038f, 0.03650460f, -0.04814871f, 0.04109945f, 
    -0.02375979f, -0.04371104f, -0.01372405f, 0.03017907f, -0.06129681f, -0.02659526f, -0.02251939f, -0.06240297f, 
    0.02088046f, -0.03442899f, -0.03208683f, 0.00477964f, -0.03027330f, 0.04734226f, -0.04192898f, 0.02465232f, 
    -0.00554165f, -0.04663052f, -0.05728711f, -0.04444879f, 0.01092851f, -0.03846597f, -0.00555035f, 0.02256343f, 
    0.02991535f, -0.02628853f, 0.01155898f, -0.04265629f, -0.03522813f, -0.00872236f, -0.05063526f, -0.04054232f, 
    -0.02521465f, 0.01131705f, -0.00634343f, 0.04908322f, -0.04504319f, -0.01981734f, -0.04470110f, -0.00212331f, 
    -0.01762874f, 0.01205584f, 0.02613990f, 0.00908183f, 0.02507408f, -0.03713955f, -0.01783953f, -0.05283319f, 
    0.00249475f, 0.04050624f, 0.03515635f, 0.03681066f, -0.05140726f, 0.02271495f, -0.04977283f, 0.02966545f, 
    -0.01076951f, -0.02287055f, 0.00184285f, -0.03789181f, -0.05148505f, 0.03035234f, -0.02725081f, -0.04914189f, 
    -0.00879356f, 0.02812850f, -0.05064137f, -0.02864742f, -0.00036180f, -0.01269070f, 0.03771826f, 0.00562981f, 
    0.02168660f, -0.02165710f, 0.00447914f, -0.01146258f, -0.01293926f, -0.02384807f, -0.04401376f, 0.00971581f, 
    -0.01925350f, -0.00530018f, -0.01733190f, -0.02362353f, 0.01026564f, -0.04183760f, -0.03575130f, 0.00810381f, 
    0.02829804f, -0.03424841f, 0.01520269f, 0.01408083f, 0.02562491f, 0.04028325f, -0.02140629f, 0.02430635f, 
    0.02258506f, 0.02805223f, -0.04546256f, -0.01289317f, -0.06319018f, -0.00458840f, 0.02239880f, -0.00112602f, 
    -0.04732888f, 0.02987434f, -0.01535461f, -0.03753045f, -0.06049577f, -0.01375004f, 0.04068947f, -0.03831263f, 
    0.03861194f, -0.00609501f, -0.02955206f, -0.01171830f, -0.00388863f, -0.04124590f, 0.01371793f, -0.01666330f, 
    -0.01284535f, -0.05489562f, -0.03337982f, -0.00219933f, -0.02337905f, -0.00848284f, -0.03408357f, -0.00018849f, 
    -0.02035753f, -0.04626554f, -0.02202729f, 0.00859136f, -0.01120665f, -0.06497946f, 0.01430725f, -0.02170125f, 
    0.04263999f, 0.04704624f, -0.02091119f, 0.00919565f, 0.02098377f, 0.00704958f, -0.03917388f, 0.02771558f, 
    -0.03426137f, -0.03540299f, -0.00949527f, -0.04676184f, -0.03998301f, -0.03533777f, -0.05051113f, -0.04561384f, 
    -0.00918652f, 0.01973203f, 0.03679346f, 0.01227113f, -0.03994568f, -0.02921583f, -0.04144800f, 0.00256824f, 
    -0.02632065f, 0.01517597f, -0.01939896f, -0.02895034f, -0.00952167f, -0.01709592f, 0.04576173f, -0.02176872f, 
    -0.00375771f, 0.00466885f, -0.05067861f, -0.01672996f, 0.03285495f, 0.02915946f, 0.00192019f, 0.03331655f, 
    0.02178795f, -0.04421225f, -0.06108169f, -0.05305564f, -0.00976972f, 0.03686536f, 0.00902895f, 0.00897985f, 
    -0.02907896f, 0.04441789f, -0.05007309f, -0.05263003f, 0.02514241f, 0.02898686f, 0.00963960f, 0.03562316f, 
    0.00971418f, -0.00234775f, 0.02400232f, -0.02506612f, -0.01752187f, 0.02755996f, 0.02684599f, -0.05331859f, 
    -0.02728653f, 0.04185564f, -0.04893472f, 0.00101237f, 0.01436062f, -0.03525800f, 0.02942860f, 0.04193281f, 
    0.04052400f, -0.01688666f, -0.04697547f, -0.03379897f, 0.00876464f, -0.06375154f, -0.04975279f, -0.00979324f, 
    0.00642567f, -0.00886608f, -0.02095650f, -0.03531283f, 0.04087619f, -0.03366737f, -0.04921717f, 0.02334387f, 
    -0.05029351f, 0.03241349f, 0.02181822f, -0.03245824f, 0.00099541f, -0.02399571f, 0.04320864f, -0.06657954f, 
    -0.01386282f, -0.05993505f, -0.02510105f, 0.03451369f, -0.00618211f, 0.04303494f, -0.02223537f, -0.03477253f, 
    0.00835557f, 0.00543964f, 0.03668294f, 0.03901914f, 0.00574711f, 0.02641951f, 0.02172930f, -0.01020612f, 
    0.00893361f, 0.03754874f, -0.05259170f, -0.00528222f, -0.05409807f, -0.00557291f, 0.04715768f, -0.02585236f, 
    -0.03296043f, -0.03226065f, 0.01050672f, -0.03663929f, 0.02227324f, -0.01440381f, 0.00665965f, 0.03776570f, 
    -0.03416689f, -0.03260497f, 0.02327710f, -0.01946464f, -0.02650308f, 0.00141686f, 0.00375274f, -0.03943655f, 
    -0.01918328f, -0.01000963f, -0.05184004f, 0.01661005f, -0.03105688f, -0.00459645f, 0.02642820f, -0.01204376f, 
    0.00029873f, -0.05106715f, -0.01998465f, 0.02007778f, -0.03329844f, 0.04026666f, 0.00748160f, 0.02597619f, 
    -0.03446108f, 0.03330726f, 0.01481870f, -0.01632285f, -0.01162552f, 0.04334627f, -0.00336491f, 0.00833375f, 
    0.03713540f, -0.04122613f, -0.01398772f, -0.02934391f, 0.02620132f, 0.02748694f, 0.00599956f, 0.04147540f, 
    -0.03795068f, -0.01138493f, -0.03096488f, 0.03121929f, 0.04468269f, 0.04627017f, 0.01091102f, -0.03737481f, 
    -0.23414837f, -0.09106984f, -0.00315649f, -0.08947243f, -0.02890671f, -0.00972873f, 0.01561338f, -0.01060086f, 
    -0.11989637f, 0.01072834f, 0.11329490f, 0.01010006f, -0.20640694f, -0.07013482f, 0.03808000f, -0.14908093f, 
    -0.01077116f, 0.00790820f, -0.06896549f, -0.00557223f, 0.03448425f, 0.03264226f, -0.15000294f, -0.15118730f, 
    -0.26508668f, -0.01398633f, -0.15099698f, -0.01592457f, -0.10057405f, -0.00222410f, 0.02319356f, 0.04170370f, 
    -0.05853603f, 0.07871627f, 0.02021820f, 0.11755994f, 0.02088932f, 0.32566926f, 0.00880659f, 0.07731885f, 
    -0.13376218f, -0.02336581f, 0.01628274f, -0.00084062f, -0.11287682f, 0.06121445f, 0.15083036f, -0.01397898f, 
    -0.16633491f, 0.26324558f, 0.16672340f, 0.04900246f, 0.05572834f, -0.06280491f, 0.02870196f, 0.03337541f, 
    0.04871197f, -0.00294492f, 0.02490590f, 0.10182617f, -0.24427044f, -0.20622146f, -0.05465692f, -0.00414502f, 
    -0.11731632f, 0.01076044f, -0.04721659f, 0.01653733f, 0.10272484f, -0.01356696f, 0.00702029f, -0.15169513f, 
    0.25833309f, 0.25579649f, 0.04793801f, -0.06469917f, 0.16737841f, 0.05927378f, 0.11379550f, -0.04626899f, 
    0.10442226f, -0.02566516f, 0.04528889f, -0.01528913f, 0.01504012f, 0.04109311f, 0.08407985f, -0.04738479f, 
    -0.09792185f, 0.02593497f, -0.09811525f, -0.10252731f, -0.08317146f, -0.05812348f, 0.01757469f, 0.04703011f, 
    0.13666801f, -0.06289598f, 0.05282909f, 0.01411676f, -0.03276439f, 0.07819555f, -0.07495673f, -0.00924687f, 
    0.03729465f, 0.09563159f, 0.06753475f, 0.01704260f, 0.06580438f, 0.00177209f, 0.09442947f, 0.09478211f, 
    0.01566206f, -0.01946835f, -0.00348841f, 0.01080027f, -0.15392289f, -0.08582130f, 0.02138587f, -0.05614754f, 
    0.10263020f, 0.20015804f, 0.09738226f, -0.05822209f, -0.02382248f, 0.04348433f, -0.03410612f, -0.05081033f, 
    -0.04896886f, -0.08109036f, -0.20258704f, 0.04879939f, -0.10321302f, 0.09404714f, 0.16001070f, 0.12689391f, 
    0.03608493f, -0.02172025f, 0.00963888f, 0.00890026f, 0.08685546f, 0.09428403f, -0.00183437f, 0.02453818f, 
    -0.17187895f, 0.05080155f, -0.11824816f, -0.03474164f, -0.05653853f, -0.01605858f, -0.01213070f, -0.04460612f, 
    -0.00250325f, 0.06746793f, 0.00815193f, 0.05390387f, 0.16077682f, 0.13471282f, 0.11677523f, 0.00652308f, 
    0.03246252f, -0.09060146f, -0.01985496f, 0.01106783f, -0.02757650f, 0.07638440f, 0.10966909f, -0.00920293f, 
    0.01286817f, -0.10216284f, 0.01994294f, -0.09425317f, 0.15956920f, 0.14417751f, 0.05742882f, 0.01499420f, 
    0.03119190f, 0.06195300f, 0.00162164f, 0.04010485f, -0.23924696f, 0.09066600f, 0.16039434f, -0.02082901f, 
    -0.00506805f, -0.05813625f, 0.01424950f, 0.04645155f, 0.07509464f, -0.04707247f, -0.15867585f, 0.11386370f, 
    0.06099261f, 0.13071056f, 0.15384430f, 0.06602322f, 0.00911138f, 0.03648237f, -0.06345535f, 0.06120463f, 
    -0.02846989f, 0.05790742f, 0.10775980f, -0.01199082f, -0.34237280f, -0.15702009f, -0.01214847f, 0.07256971f, 
    -0.15016522f, -0.11567153f, -0.01007827f, 0.02108986f, -0.06668547f, 0.03452870f, -0.05972118f, 0.03252599f, 
    0.18921241f, 0.33000764f, 0.04442200f, 0.12540591f, 0.19776163f, 0.08051886f, -0.01818308f, 0.01784823f, 
    -0.04350878f, 0.06843641f, -0.03232375f, -0.00730695f, -0.12081299f, -0.07090332f, 0.10536378f, 0.02859331f, 
    -0.01976013f, 0.06412779f, -0.01544012f, 0.03290737f, 0.01272846f, 0.04047430f, -0.01557134f, 0.04336118f, 
    0.08145373f, -0.07620236f, -0.04940082f, -0.06129458f, -0.12233041f, -0.02728205f, -0.03888606f, -0.00493791f, 
    -0.08372153f, -0.10835353f, -0.14191614f, -0.12032370f, 0.05427692f, 0.12576999f, 0.05942605f, 0.19911367f, 
    0.17118798f, 0.07527432f, 0.07327395f, 0.00936590f, -0.05301029f, 0.02137127f, 0.04160310f, -0.11249155f, 
    -0.13466287f, 0.07812253f, 0.09325518f, 0.03101580f, 0.04901966f, 0.03502283f, -0.01446362f, 0.01658201f, 
    -0.07841014f, 0.06274001f, -0.00524745f, -0.08117855f, 0.04554316f, 0.18251765f, 0.04454530f, 0.15161586f, 
    0.15214239f, -0.04519368f, -0.05681631f, 0.04122019f, 0.04959555f, -0.00364003f, 0.05293362f, -0.09844127f, 
    -0.20964536f, -0.13671792f, -0.05553197f, -0.14912157f, 0.04299864f, 0.00152570f, -0.06696405f, -0.00464812f, 
    -0.03362468f, -0.02344670f, -0.02577479f, -0.00520025f, 0.27861425f, 0.07890008f, 0.12582499f, -0.01049454f, 
    0.15303051f, 0.03370274f, 0.08755829f, -0.00790920f, 0.05587409f, -0.01714554f, 0.03420538f, 0.11361990f, 
    -0.32390562f, 0.02813642f, 0.07843357f, 0.07052609f, 0.15403250f, -0.06666474f, -0.06596363f, -0.05641589f, 
    -0.00006315f, -0.09034429f, -0.06046392f, -0.13268127f, -0.20443362f, -0.03615612f, 0.04823315f, -0.09436485f, 
    -0.11366772f, -0.01427433f, -0.04495568f, -0.06509145f, 0.04160881f, 0.08648606f, 0.03799396f, 0.07672632f, 
    0.14508955f, 0.21639252f, 0.00920357f, -0.10689063f, 0.07684564f, 0.08160602f, 0.04825155f, -0.10289611f, 
    0.01206755f, 0.02813456f, -0.02649748f, -0.01794311f, -0.00810779f, 0.04358193f, -0.10849997f, -0.09287092f, 
    0.06274617f, 0.00580653f, -0.04315224f, 0.01916297f, -0.03511679f, 0.12158623f, -0.04012207f, 0.08621954f, 
    -0.06141185f, -0.14406559f, 0.08801945f, -0.10363664f, -0.15945630f, 0.04353247f, 0.03101206f, -0.01250671f, 
    0.01128652f, 0.10730144f, -0.02703439f, -0.07253844f, 0.14836948f, 0.03189927f, 0.05010276f, 0.02820433f, 
    0.18375249f, 0.11758337f, -0.05702286f, -0.07276715f, -0.03851645f, 0.05255559f, 0.04311089f, 0.03719915f, 
    0.20501733f, 0.20815426f, 0.13460274f, -0.00117361f, -0.10752581f, -0.04293117f, 0.04318656f, 0.02151358f, 
    0.06168101f, 0.07600281f, -0.05977535f, -0.01546456f, 0.14285433f, 0.07119761f, 0.04879456f, 0.23002933f, 
    -0.03092801f, 0.03586405f, 0.03151593f, -0.07072426f, -0.04393546f, 0.09962916f, 0.21387887f, 0.17833661f, 
    0.23558103f, -0.04578342f, 0.05814768f, 0.28221628f, -0.05500707f, -0.07435732f, 0.01308814f, 0.06764813f, 
    0.03733038f, 0.03447025f, 0.02459579f, -0.09956775f, -0.25831196f, -0.05114307f, -0.19377166f, 0.12880659f, 
    0.06907155f, 0.05973508f, 0.02436346f, -0.02980440f, 0.00304918f, 0.06215304f, 0.03338914f, 0.02795546f, 
    -0.00022148f, -0.27301919f, -0.05485549f, 0.06391054f, -0.05825141f, 0.00270057f, 0.04165951f, 0.13436867f, 
    -0.02579375f, -0.06898866f, 0.04120402f, -0.06367806f, 0.18328284f, 0.01334635f, -0.10500467f, -0.07274349f, 
    -0.01166267f, -0.10737908f, 0.02104958f, -0.02637264f, -0.18857107f, -0.01648663f, 0.09629628f, 0.02597751f, 
    0.06289137f, -0.13237004f, 0.05955806f, -0.15514709f, -0.04679680f, -0.00057017f, -0.00919431f, -0.02000719f, 
    0.03578800f, -0.02465146f, 0.03098320f, 0.06052279f, -0.00380965f, -0.03297281f, -0.00664293f, 0.03508567f, 
    -0.12984714f, 0.00463810f, 0.16471002f, 0.05132613f, 0.03830318f, -0.05646849f, 0.05505967f, -0.05381561f, 
    -0.20025218f, -0.04899308f, 0.07444458f, -0.15506664f, 0.10776760f, -0.04140493f, -0.03595738f, 0.05149021f, 
    -0.10475917f, 0.05912412f, -0.13777952f, -0.02634425f, 0.14798079f, -0.04769006f, 0.10459153f, -0.11293741f, 
    0.02667381f, 0.08135166f, 0.01851561f, 0.00383864f, -0.02182684f, 0.12944175f, -0.04036529f, 0.09538231f, 
    0.09032974f, 0.05541160f, -0.06871249f, 0.00148431f, 0.04707247f, 0.07258303f, 0.01546263f, 0.08899780f, 
    0.08454435f, 0.10693014f, 0.15514411f, 0.02502473f, 0.17042401f, 0.13500281f, -0.16459528f, -0.27880371f, 
    0.00885999f, 0.06629132f, 0.05442654f, 0.00984269f, -0.19524671f, -0.08861893f, -0.01855416f, -0.00186430f, 
    0.15587562f, -0.11125021f, 0.11595191f, 0.13049121f, -0.04772761f, 0.07330487f, 0.06575821f, 0.02156449f, 
    -0.03173233f, -0.06146418f, -0.05368562f, -0.16044414f, -0.05301317f, 0.06152089f, 0.03163982f, 0.01974447f, 
    -0.04979285f, 0.04404329f, -0.03234226f, -0.16511765f, 0.00747723f, -0.11405275f, 0.01561726f, -0.11374858f, 
    0.14430036f, -0.13742921f, -0.04674703f, 0.02773932f, -0.13797139f, -0.10274418f, -0.01155664f, 0.03561554f, 
    -0.01328664f, 0.00397982f, 0.06243028f, -0.02534437f, -0.02626183f, 0.04094208f, -0.09185008f, -0.20983753f, 
    0.09745196f, 0.03561325f, 0.01117029f, -0.10033149f, 0.05672022f, -0.01336433f, 0.18083267f, -0.05876881f, 
    -0.03477649f, 0.01383501f, 0.11919987f, -0.27874702f, 0.06680290f, 0.00222118f, 0.04612812f, 0.00704830f, 
    -0.04197494f, -0.05957554f, 0.03809121f, 0.01344227f, 0.17616615f, 0.06452399f, -0.07313193f, 0.07786592f, 
    -0.01999487f, 0.10524356f, 0.02962935f, 0.04871209f, -0.07925797f, 0.05668585f, 0.02278862f, -0.10874342f, 
    -0.21465619f, -0.06590787f, 0.01305424f, -0.13007152f, -0.04894782f, 0.10305921f, -0.06520325f, 0.01833488f, 
    0.05330234f, -0.04156215f, 0.12858355f, 0.09890669f, 0.04461843f, 0.19022714f, -0.03576274f, -0.05191784f, 
    0.08086269f, -0.01410267f, 0.13622731f, -0.04316568f, -0.02076190f, 0.02980834f, -0.08547415f, -0.08978420f, 
    -0.06958011f, 0.11793455f, 0.10113360f, 0.03336228f, 0.10496400f, 0.06283713f, 0.01969479f, 0.03380490f, 
    -0.03611225f, 0.13388954f, 0.05194439f, 0.17262039f, -0.02592517f, 0.06616898f, 0.04221197f, -0.16717759f, 
    -0.00140959f, -0.07507014f, 0.04430897f, 0.07136562f, 0.02740384f, 0.03639697f, 0.00759935f, 0.02730802f, 
    0.32155409f, 0.02638114f, 0.00356771f, -0.10971425f, -0.00438612f, -0.00173731f, 0.01949701f, -0.06599918f, 
    0.10819419f, -0.04872528f, -0.02150474f, 0.07058851f, 0.02482209f, -0.03110318f, -0.00759933f, -0.14819473f, 
    -0.11822230f, 0.00111896f, -0.14603429f, 0.06061995f, -0.01650138f, 0.11469517f, 0.06140193f, 0.13678135f, 
    0.20312671f, 0.02908945f, 0.00222860f, 0.34377527f, -0.11493073f, 0.00576507f, 0.01579845f, -0.02602671f, 
    0.04155096f, -0.01826741f, -0.01084458f, -0.02316674f, -0.03561632f, 0.01153322f, -0.02530320f, -0.21943489f, 
    -0.00304330f, 0.08822064f, -0.06453799f, 0.10781855f, -0.04879952f, -0.02292296f, -0.02918272f, 0.05335517f, 
    0.25942996f, 0.01134833f, -0.15109047f, 0.15630227f, -0.12286188f, -0.05684045f, 0.09017976f, 0.02070962f, 
    0.02244477f, -0.02169288f, 0.14442964f, 0.11461350f, 0.12427934f, 0.07576027f, -0.10365494f, 0.25320810f, 
    -0.04391530f, -0.05958330f, -0.04972291f, -0.00344852f, -0.01793064f, -0.02602828f, -0.00008464f, 0.03899007f, 
    -0.07525407f, -0.11172140f, 0.01976429f, -0.17899349f, -0.03318135f, -0.01100040f, 0.08257714f, 0.09046172f, 
    0.03171827f, 0.00406280f, -0.00196632f, 0.03799591f, 0.12835304f, -0.02621294f, 0.17024121f, 0.27909124f, 
    -0.07361201f, 0.04549952f, 0.12912415f, 0.04807710f, 0.07467677f, -0.14101882f, 0.10849486f, 0.03084880f, 
    0.25685713f, 0.10907026f, -0.03336423f, 0.20208766f, 0.19152275f, 0.01421730f, -0.02386510f, 0.00955588f, 
    0.05787942f, 0.05063634f, -0.00829677f, 0.07053357f, 0.08050960f, 0.07102927f, -0.06293219f, -0.18649898f, 
    0.02341636f, -0.08215801f, 0.12467048f, 0.14115420f, 0.03878305f, -0.00489797f, -0.15487105f, 0.00587680f, 
    0.03170427f, -0.01030217f, -0.02758255f, 0.01403773f, -0.05255587f, 0.04321374f, -0.02424619f, 0.03588057f, 
    -0.05179495f, -0.02653726f, -0.00489585f, 0.01393904f, 0.01208352f, -0.01577665f, 0.01817991f, -0.01674776f, 
    -0.00655786f, 0.03526685f, 0.00298510f, 0.01986218f, -0.03725147f, -0.01452427f, 0.02419379f, -0.03976472f, 
    0.01567132f, -0.03355588f, 0.02915840f, -0.04778969f, -0.03168295f, -0.01472885f, -0.05459525f, -0.02077326f, 
    -0.05032506f, -0.01969037f, -0.00476690f, 0.03608607f, 0.03078260f, 0.03528172f, -0.00100219f, -0.00866616f, 
    0.01485069f, -0.01362770f, -0.01129236f, 0.04390134f, -0.03809276f, 0.03989970f, 0.02370375f, 0.04308152f, 
    -0.05321051f, -0.02662392f, -0.03009422f, 0.03088483f, 0.00007007f, -0.05072894f, 0.03843419f, -0.03749090f, 
    -0.02099461f, 0.02576553f, 0.02398401f, -0.01769707f, -0.03343621f, 0.01160734f, -0.05063325f, 0.04034098f, 
    -0.03468431f, -0.00481364f, -0.00341372f, -0.03117642f, -0.04524448f, 0.00728506f, 0.01122139f, 0.00825932f, 
    -0.05539495f, -0.00854012f, -0.01428792f, 0.00682535f, 0.00660155f, 0.03628081f, 0.03790428f, 0.02738990f, 
    -0.05547548f, -0.00398192f, 0.00149751f, -0.01434143f, 0.00454194f, -0.00726408f, -0.01831512f, 0.03778935f, 
    0.01876294f, 0.01773761f, -0.05158021f, -0.02043942f, -0.00171941f, -0.04547489f, -0.02686322f, 0.02119473f, 
    -0.00927747f, 0.01926364f, -0.01445345f, 0.02318938f, 0.00593453f, 0.02198670f, -0.00944126f, 0.01562903f, 
    0.03316729f, 0.03156903f, -0.04357605f, 0.03345587f, -0.00206916f, 0.01930022f, 0.01998968f, -0.00689502f, 
    -0.02086130f, -0.03357493f, -0.05334720f, -0.03277908f, 0.02882935f, 0.03791285f, -0.05193403f, -0.01177565f, 
    -0.03253069f, 0.03808524f, 0.03334318f, 0.02635546f, -0.04063157f, -0.01327862f, 0.04265051f, -0.03386740f, 
    -0.02368358f, 0.01575380f, -0.05397614f, -0.00240279f, -0.01733229f, 0.02087522f, -0.05324391f, 0.01519634f, 
    -0.00613379f, -0.01388230f, -0.04778411f, -0.02578708f, 0.01837883f, -0.04241258f, -0.04653636f, -0.03445105f, 
    0.02512978f, 0.00319065f, 0.02814459f, -0.05512420f, -0.01110945f, -0.00484380f, 0.03086666f, -0.00424322f, 
    0.00239697f, 0.02012535f, -0.02355168f, -0.02854235f, 0.04215510f, -0.00401323f, -0.05560433f, 0.03654139f, 
    0.02347500f, 0.01967848f, 0.02278574f, -0.00965724f, -0.04193868f, -0.03093513f, -0.02097118f, 0.02814296f, 
    -0.04711979f, 0.00602247f, -0.03421104f, 0.03552148f, -0.01834588f, -0.02626475f, -0.00341468f, -0.00975102f, 
    0.01655897f, -0.01162733f, -0.00206110f, -0.01183043f, -0.04984903f, -0.03331050f, -0.02336176f, -0.01426065f, 
    -0.05493515f, 0.04198075f, -0.00699571f, 0.00397458f, -0.05465288f, -0.00749901f, 0.01734704f, 0.01654671f, 
    -0.00846765f, 0.01243833f, 0.03786888f, 0.00636562f, -0.01111801f, -0.03143003f, 0.00235223f, 0.04027559f, 
    -0.04942321f, -0.02479369f, -0.04710588f, 0.02240850f, 0.02152864f, 0.03206404f, 0.03712485f, 0.03189822f, 
    -0.02823414f, -0.02369751f, -0.02739513f, -0.03271573f, -0.05027212f, 0.03616551f, 0.02371848f, -0.04064277f, 
    0.03635865f, 0.00841586f, -0.03366235f, 0.02778658f, 0.02298314f, -0.04480810f, 0.00469232f, -0.04253223f, 
    -0.01951396f, -0.04662199f, 0.02799098f, -0.01480758f, -0.02006107f, -0.03959969f, -0.04367173f, 0.02062613f, 
    -0.02407061f, 0.01087463f, 0.02948679f, 0.04394506f, -0.00070448f, -0.03975113f, -0.03204245f, -0.00221269f, 
    -0.03620776f, -0.04566202f, 0.00104369f, -0.04444404f, -0.03501805f, -0.04476600f, 0.00397031f, -0.04025108f, 
    -0.00889362f, -0.05450357f, -0.01327105f, -0.03773614f, 0.02826599f, 0.00584809f, -0.05258971f, 0.02357872f, 
    -0.02716383f, -0.04363005f, -0.00665646f, 0.00913200f, 0.00752712f, -0.00430057f, -0.03679634f, 0.00342452f, 
    -0.00690131f, -0.02003465f, -0.02786517f, 0.01928583f, 0.03783410f, 0.02982884f, -0.01760205f, 0.02727584f, 
    0.00964115f, 0.02366525f, 0.02700756f, -0.02147599f, -0.01098631f, 0.01324196f, -0.03769737f, 0.03953009f, 
    0.02800727f, 0.01064750f, -0.00699557f, 0.00714142f, -0.04593938f, -0.04359299f, -0.01734806f, 0.01433343f, 
    0.03439996f, -0.04952962f, -0.02826743f, 0.04291598f, -0.03488321f, -0.05439852f, 0.01026268f, -0.00374689f, 
    -0.00372857f, -0.03065023f, -0.04892772f, -0.02930564f, -0.05325037f, 0.02303739f, 0.02135861f, -0.03742710f, 
    -0.05079696f, 0.04365496f, 0.03154689f, 0.01203685f, -0.02741000f, 0.00452623f, 0.04018436f, -0.04212651f, 
    -0.04287260f, -0.04027696f, -0.05368548f, -0.04144515f, 0.00803891f, -0.01165043f, -0.03497552f, -0.04040229f, 
    -0.01045492f, -0.03476184f, -0.02292299f, 0.00021201f, -0.00181312f, 0.03994535f, -0.00111900f, -0.00246202f, 
    -0.04191012f, 0.01167345f, -0.00275112f, -0.05195538f, -0.03980627f, -0.03261245f, 0.02126652f, 0.02824457f, 
    0.00832479f, 0.00782211f, -0.02222501f, -0.03123792f, 0.03518876f, -0.04988292f, 0.02723397f, -0.04308644f, 
    0.01286993f, 0.02989001f, -0.01406446f, -0.02283073f, 0.02405431f, 0.03844335f, -0.03891827f, -0.02903135f, 
    -0.01064044f, -0.02233259f, -0.01015382f, -0.03134695f, -0.04668620f, -0.03823151f, -0.01485242f, -0.04300689f, 
    0.01333168f, -0.04625256f, 0.00501533f, 0.00120106f, -0.01887484f, -0.01962590f, -0.00076602f, 0.01400080f, 
    -0.04441492f, 0.00243725f, -0.03540543f, -0.04267498f, -0.03277396f, -0.01531723f, 0.03858830f, 0.00104107f, 
    0.03294757f, -0.01436659f, 0.04076770f, -0.04702920f, -0.02517577f, -0.04473180f, -0.05528763f, 0.02628586f, 
    0.01094594f, 0.02978563f, -0.03590349f, 0.03036842f, 0.04443638f, -0.05464817f, -0.05132047f, -0.01905392f, 
    -0.02814946f, -0.00906989f, 0.00794163f, -0.05063846f, -0.00665742f, -0.02715102f, -0.00820760f, 0.02634937f, 
    0.04144926f, -0.02299054f, -0.01314904f, -0.01508252f, -0.02938173f, -0.00453048f, 0.00570229f, -0.02940970f, 
    0.02401677f, -0.05322069f, 0.03606961f, -0.02969723f, 0.02053598f, 0.05366558f, -0.03618952f, 0.02054465f, 
    -0.02917732f, -0.03889050f, -0.01820559f, -0.04262117f, 0.00421530f, 0.01327800f, 0.02528309f, -0.04122579f, 
    -0.03821279f, -0.01795075f, -0.05270227f, 0.00429638f, 0.03355164f, -0.04030570f, 0.04395855f, -0.03119785f, 
    0.01235038f, -0.03703075f, 0.02728519f, 0.02613409f, 0.00450251f, -0.01695636f, -0.01947670f, 0.00836870f, 
    -0.02180423f, -0.04635853f, -0.04584187f, 0.03790286f, -0.02478299f, -0.01328964f, 0.00943546f, -0.02379025f, 
    -0.01498963f, -0.03998488f, -0.00390736f, -0.00720318f, -0.00562905f, 0.00278633f, -0.04757731f, -0.00007361f, 
    0.00591689f, -0.03551744f, 0.01177195f, -0.00780881f, -0.01255154f, -0.05010768f, -0.04454559f, -0.03243120f, 
    -0.02457281f, -0.02656467f, 0.03964965f, -0.01084355f, -0.03278150f, 0.01166376f, 0.03389421f, -0.00598151f, 
    0.02904518f, -0.05892092f, -0.03437319f, -0.01465404f, -0.02747515f, 0.01607301f, 0.00777219f, -0.00895220f, 
    -0.01566496f, -0.05319930f, -0.05381918f, 0.03244657f, 0.05575739f, -0.01184831f, -0.03917945f, 0.03181420f, 
    0.05052726f, 0.02017005f, -0.00375457f, 0.03851799f, 0.04426507f, -0.03671879f, -0.02124915f, -0.05841948f, 
    0.02250334f, 0.00682983f, 0.03595479f, -0.04661695f, -0.01811840f, 0.00978893f, -0.01205987f, 0.02374758f, 
    -0.01490128f, 0.01361290f, 0.03334348f, -0.03855448f, 0.02883383f, 0.01515550f, 0.02932701f, -0.05800917f, 
    -0.00656073f, -0.04564016f, -0.05291987f, -0.03905456f, -0.02385721f, -0.00559110f, -0.04258072f, 0.03580438f, 
    0.01375784f, -0.00915127f, 0.04506960f, 0.00224648f, 0.03658942f, -0.05283045f, 0.00645446f, 0.03265011f, 
    -0.04436580f, 0.01191481f, -0.04491374f, -0.00858103f, 0.02841409f, -0.03185660f, 0.00142617f, -0.03328036f, 
    -0.01105026f, 0.01817139f, -0.03381899f, -0.02467915f, 0.02072616f, -0.05836037f, 0.02508648f, 0.04492721f, 
    0.00027489f, -0.01308938f, 0.02053459f, 0.03575830f, -0.00744583f, 0.02464983f, -0.02419198f, -0.03619962f, 
    0.01333190f, 0.00783443f, -0.02620190f, 0.03151248f, 0.02292409f, 0.03942565f, -0.00903594f, -0.01934598f, 
    -0.01053254f, -0.05421124f, -0.03300605f, -0.00326188f, 0.02535996f, -0.02241755f, -0.02392282f, 0.05139659f, 
    0.03164599f, 0.01678875f, -0.01693416f, -0.03246852f, -0.00954581f, 0.02745989f, 0.02861302f, -0.00729959f, 
    0.03535983f, 0.00122272f, -0.00749894f, 0.03383939f, -0.02717053f, 0.00506575f, -0.03412846f, -0.03610789f, 
    0.03867365f, -0.02875646f, -0.00869518f, -0.02031007f, -0.06124554f, -0.05177685f, -0.01238865f, 0.03214568f, 
    0.04328689f, 0.02790041f, 0.01787194f, 0.03963218f, -0.00225297f, 0.00966974f, 0.03240126f, -0.00742798f, 
    -0.02967972f, -0.04423002f, -0.06001444f, 0.03206420f, -0.04912043f, -0.01327625f, -0.00520856f, -0.04514412f, 
    0.01179151f, 0.00730906f, 0.04131561f, -0.05265124f, -0.00313782f, -0.02566765f, -0.01796410f, -0.00715123f, 
    -0.00859235f, 0.02117675f, -0.02329003f, 0.00041483f, -0.01988837f, 0.01529054f, 0.03533226f, -0.03469127f, 
    -0.03160144f, -0.02954132f, -0.01722305f, -0.02014370f, -0.02670688f, 0.04112043f, -0.02483643f, 0.02063426f, 
    0.04005846f, 0.01458243f, -0.05201371f, 0.02085964f, -0.02112937f, -0.03311583f, -0.03506206f, -0.02828670f, 
    -0.02842959f, -0.00313629f, -0.02218110f, -0.04801336f, -0.05676102f, 0.04040779f, 0.00912821f, 0.01301741f, 
    0.01161859f, -0.03337085f, -0.01363921f, 0.00301807f, 0.05466456f, 0.02755465f, 0.02956638f, 0.00346193f, 
    -0.04990969f, -0.04178820f, 0.04524522f, -0.02272334f, 0.02832804f, 0.02869241f, 0.02520620f, -0.01900376f, 
    0.03339161f, -0.03924784f, -0.02914004f, -0.03783526f, -0.01429543f, 0.02480945f, 0.01712356f, -0.01063308f, 
    0.02795013f, 0.00845180f, -0.00414055f, -0.00985927f, 0.02345044f, -0.01718795f, 0.02352059f, 0.02158544f, 
    0.02393800f, 0.03603373f, 0.02291324f, -0.02628650f, -0.01048764f, -0.01272445f, -0.04085430f, 0.03311591f, 
    0.00528864f, -0.01021407f, 0.01310385f, 0.02020555f, 0.03504209f, 0.00684409f, -0.00883288f, -0.00812059f, 
    0.02507556f, -0.00191745f, -0.04571708f, -0.03634794f, 0.01160419f, -0.03072467f, 0.01095922f, -0.03753825f, 
    0.01439768f, 0.01696651f, -0.00986946f, -0.03209257f, 0.02638837f, 0.01816869f, -0.02058868f, -0.01148446f, 
    -0.05267533f, 0.00452277f, -0.03725189f, 0.03019002f, -0.02206970f, -0.01677150f, 0.01094607f, -0.00406325f, 
    0.04509502f, 0.01913133f, 0.03908963f, 0.02434031f, 0.03566674f, 0.01035815f, -0.02502159f, 0.01043189f, 
    -0.02178376f, 0.00610707f, -0.04586276f, -0.04779802f, -0.01213723f, -0.00541541f, 0.02927542f, 0.03704365f, 
    -0.00497591f, 0.01363233f, -0.03687436f, -0.03321202f, -0.03810006f, -0.02449225f, 0.02111154f, -0.00995438f, 
    -0.03844940f, 0.00289850f, -0.03767363f, 0.04491719f, 0.01499241f, 0.03562529f, 0.01598764f, 0.03524182f, 
    0.03817504f, 0.00707293f, -0.00596134f, -0.04471312f, 0.03585299f, -0.03090483f, 0.03688590f, -0.02853059f, 
    -0.00097480f, -0.03369058f, 0.04245264f, -0.01261710f, -0.03794307f, 0.00945509f, 0.02419141f, -0.02581027f, 
    0.00894002f, 0.03794867f, -0.01855513f, 0.03556025f, -0.00784005f, 0.03853125f, -0.01374917f, -0.01427339f, 
    0.03806450f, 0.00916019f, -0.01459428f, -0.05687799f, 0.02828133f, -0.00729910f, -0.03353630f, 0.03223189f, 
    0.01272300f, 0.01203359f, 0.00719027f, -0.04477719f, 0.04336714f, -0.00975562f, -0.05600008f, 0.02701359f, 
    -0.02615021f, -0.04738495f, 0.00614211f, -0.02796979f, -0.00449846f, -0.00066975f, 0.03662906f, 0.00883791f, 
    -0.05567471f, 0.04002177f, 0.03219264f, 0.00446390f, 0.01923461f, 0.03333171f, 0.01187581f, 0.01912336f, 
    -0.01994937f, -0.04027359f, 0.00109038f, -0.04480618f, -0.05852941f, -0.02795745f, 0.03213113f, -0.02819544f, 
    0.02781360f, -0.00479977f, -0.05077518f, -0.00842162f, 0.00030774f, -0.00338829f, -0.05836055f, 0.02716692f, 
    0.03383084f, 0.02162121f, -0.05838005f, 0.00488476f, 0.03651199f, -0.05587880f, 0.02444069f, -0.04108080f, 
    -0.03471914f, -0.02835119f, -0.00887527f, -0.04444050f, -0.03835411f, 0.00354243f, 0.04031799f, -0.01828670f, 
    -0.03125856f, -0.00877163f, -0.00336904f, 0.01481283f, -0.01177003f, -0.01741422f, -0.02388146f, 0.01514374f, 
    -0.01768575f, 0.00599831f, -0.02587311f, -0.04020198f, 0.02486834f, 0.03098364f, 0.01788704f, 0.03231173f, 
    -0.05061308f, -0.00611728f, 0.01223832f, -0.03047191f, -0.05096507f, -0.03302990f, -0.03314289f, 0.02283651f, 
    -0.02728669f, -0.05805222f, -0.01589357f, -0.04375362f, 0.00046063f, 0.01575584f, 0.03818699f, 0.00715333f, 
    0.00181447f, 0.02120502f, -0.01230464f, 0.02622908f, -0.02895995f, 0.00270228f, -0.02286954f, 0.01193157f, 
    -0.04995817f, -0.01637295f, 0.03161196f, 0.02733803f, -0.01310712f, 0.01061145f, 0.00539064f, 0.02313910f, 
    0.02908944f, 0.03488054f, 0.03190985f, 0.01626257f, 0.00591795f, 0.02222143f, 0.01017736f, 0.03136770f, 
    0.02848068f, -0.00173437f, 0.00150733f, 0.02386051f, -0.05885732f, 0.01778187f, -0.03016583f, 0.02875045f, 
    -0.01196804f, 0.02973430f, 0.04049812f, -0.03745950f, -0.00047422f, 0.02429044f, 0.02941671f, 0.03395191f, 
    -0.04947903f, -0.02177742f, 0.04061468f, -0.04424744f, -0.00710368f, 0.00644798f, -0.03817703f, 0.02955515f, 
    -0.02781983f, 0.02266384f, 0.02524438f, 0.03015332f, -0.05504380f, 0.02066748f, -0.03811615f, 0.02463718f, 
    0.00395272f, 0.02121303f, -0.00681525f, -0.00536172f, -0.03788376f, -0.02807272f, -0.05420090f, 0.02906124f, 
    -0.04430586f, 0.04283127f, -0.00310097f, 0.02245546f, 0.03446821f, -0.01851863f, -0.02927576f, 0.04102155f, 
    0.04341414f, 0.02354600f, -0.01312718f, 0.03486316f, -0.01174540f, 0.00881961f, 0.04789146f, -0.05354116f, 
    -0.00964599f, 0.00539837f, 0.03499544f, -0.00616986f, 0.01901705f, 0.01509235f, 0.00302095f, -0.02181153f, 
    -0.03602277f, -0.05514445f, -0.05548333f, -0.05260959f, -0.00716969f, -0.01340173f, -0.01638728f, 0.00372098f, 
    0.04465140f, -0.05601600f, -0.01678206f, -0.02328185f, 0.03136760f, 0.01462744f, -0.04935562f, -0.04224323f, 
    -0.04425215f, 0.02789820f, 0.01230369f, 0.02677655f, -0.05712971f, 0.00709129f, -0.03549298f, 0.01568311f, 
    0.02197305f, 0.04443906f, -0.04121733f, -0.03509267f, -0.00042489f, -0.00207254f, -0.05188414f, 0.03784244f, 
    -0.01624911f, -0.04530530f, -0.00860552f, -0.03621882f, 0.03859755f, 0.03837198f, -0.03423286f, -0.02517489f, 
    0.01877909f, -0.00649954f, -0.02503402f, 0.03427526f, 0.03451032f, -0.03771811f, -0.01432188f, -0.05658463f, 
    -0.03860800f, -0.02815642f, 0.00907013f, 0.03664884f, -0.03551526f, 0.03652060f, -0.02232100f, 0.01339074f, 
    0.04641302f, -0.02366223f, -0.04451755f, -0.03053904f, 0.05283530f, 0.04695908f, -0.04515841f, -0.02638062f, 
    0.02556823f, -0.00712146f, 0.03575924f, -0.02423430f, -0.02513132f, -0.05041417f, 0.04793606f, 0.01877193f, 
    0.00393004f, 0.00964433f, 0.01703791f, -0.01589459f, -0.01274215f, 0.00913746f, 0.02395785f, -0.02208003f, 
    -0.02841803f, 0.00943634f, -0.00980114f, 0.02270029f, 0.02865707f, 0.02343011f, -0.00789812f, -0.04966699f, 
    -0.00615759f, 0.00400122f, -0.04577777f, -0.04505470f, -0.03331255f, -0.04633893f, 0.04317515f, 0.01551834f, 
    -0.03098277f, -0.03490296f, 0.01746349f, 0.00048457f, -0.02365482f, -0.03312149f, 0.01105608f, -0.00463240f, 
    0.00234968f, 0.00984738f, 0.03968415f, 0.03340420f, -0.05567367f, -0.02502257f, -0.05189531f, -0.04749156f, 
    0.00852754f, -0.03913188f, -0.02246864f, -0.03833113f, 0.02114296f, -0.00426778f, 0.00448082f, -0.05604710f, 
    0.00610471f, -0.01418321f, 0.00860234f, -0.02003156f, -0.04361474f, -0.04029496f, -0.03603709f, -0.01727487f, 
    -0.03821687f, -0.00658354f, -0.03993614f, -0.05717513f, 0.02143807f, -0.05498618f, 0.01382273f, 0.02822098f, 
    0.00757641f, -0.04445997f, 0.04185559f, -0.05840589f, 0.03507995f, -0.00457489f, -0.04673178f, -0.03162980f, 
    0.04078858f, -0.04089502f, 0.00645951f, 0.01588024f, 0.02895184f, 0.01049990f, 0.02812326f, -0.00853910f, 
    0.01896540f, 0.01449475f, -0.02647181f, -0.02412201f, -0.04234919f, 0.01174614f, -0.05567665f, 0.02125984f, 
    -0.04064729f, -0.02568351f, 0.02748113f, 0.03766637f, -0.02681645f, 0.04601334f, -0.02291576f, -0.00902461f, 
    0.01123898f, -0.01435175f, 0.02658969f, -0.03141522f, 0.04111098f, 0.02273937f, -0.01023709f, 0.00288251f, 
    0.02784971f, 0.00600580f, -0.00390958f, -0.02422771f, -0.03840734f, -0.00103248f, -0.02694254f, -0.02260996f, 
    0.02284017f, -0.04483508f, -0.00052449f, 0.04974528f, 0.02791633f, 0.02586478f, -0.02813629f, -0.03391971f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06920886f, -0.04122985f, -0.06862359f, -0.04351975f, 0.02393883f, -0.02418611f, 0.05730611f, 0.09459173f, 
    0.09040309f, -0.03315672f, 0.08382157f, 0.00415257f, 0.07294767f, 0.02003461f, 0.04514247f, 0.00000400f, 
    0.05313047f, -0.03944805f, -0.04578836f, -0.01068526f, 0.09103414f, 0.06455767f, 0.03340742f, 0.01829873f, 
    0.02421788f, 0.03318380f, -0.02753126f, -0.04826503f, 0.11721767f, -0.04781679f, 0.07627101f, -0.01433010f, 
    -0.01866654f, -0.05534738f, -0.01080921f, -0.00434700f, -0.01962625f, -0.02024606f, 0.05799615f, 0.03125744f, 
    0.04744146f, -0.05804543f, -0.01312284f, 0.05357114f, -0.04408333f, 0.01092606f, -0.02303613f, 0.02112446f, 
    0.11827740f, -0.02554201f, 0.11853538f, -0.04791605f, -0.03729383f, 0.00278663f, -0.00955953f, 0.03990535f, 
    0.06348294f, 0.06294975f, -0.01198302f, 0.00142936f, -0.05230267f, 0.03168256f, 0.02357535f, 0.01518446f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.13941076f, 0.24015279f, 0.15795884f, 0.06618145f, 0.06878680f, 0.29528478f, -0.16264552f, 0.21287781f, 
    -0.12444198f, -0.04721473f, -0.49423993f, -0.07187984f, 0.25785911f, -0.28169301f, 0.28711939f, 0.13080752f, 
    -0.17178684f, -0.18189399f, 0.16312180f, 0.04794717f, -0.21442950f, -0.45818290f, -0.05176126f, 0.22422430f, 
    0.07439344f, -0.31851739f, -0.06519400f, 0.10290797f, -0.01112748f, 0.06791731f, 0.07773989f, 0.07779461f, 
    -0.10892427f, -0.05700718f, 0.00430428f, 0.02399977f, 0.26464167f, -0.09205674f, -0.18035926f, -0.11236862f, 
    -0.29546076f, 0.10704722f, -0.32089171f, -0.05684235f, 0.04488280f, 0.05269616f, -0.08616636f, 0.05055469f, 
    -0.50579947f, 0.02145374f, -0.13719155f, -0.11696257f, -0.34567201f, 0.21797466f, 0.10179554f, -0.36188459f, 
    0.14663200f, -0.17386107f, 0.06959180f, 0.14693849f, 0.17806442f, 0.02782598f, -0.12602659f, -0.09937654f, 
    0.19718134f, 0.15396614f, 0.23836394f, -0.03983600f, -0.07721817f, -0.36273673f, -0.26319721f, -0.07443043f, 
    0.19192109f, 0.15299135f, -0.24929480f, -0.14458638f, 0.13128671f, 0.10170094f, -0.01833530f, 0.24784920f, 
    0.06661101f, -0.17665832f, -0.17770508f, 0.09997004f, -0.17427188f, 0.14040534f, 0.25524068f, -0.61764824f, 
    -0.03656333f, 0.19534479f, 0.13992755f, 0.05522030f, 0.00500535f, 0.04648495f, -0.17183976f, 0.21990165f, 
    0.06613513f, 0.01896674f, -0.01637291f, -0.04164964f, 0.17997472f, -0.01620823f, -0.30247808f, 0.09275471f, 
    -0.33454198f, 0.02548411f, -0.01599086f, 0.04242892f, -0.06341460f, -0.01146201f, 0.06516058f, -0.01779792f, 
    0.35784489f, -0.28932229f, 0.13911079f, 0.00212877f, -0.15237349f, -0.28645831f, 0.02743397f, -0.47437778f, 
    -0.06059965f, 0.06111427f, 0.07466899f, -0.30707806f, 0.24731350f, 0.04457618f, -0.00276711f, -0.06312421f, 
    0.17726003f, 0.14135838f, 0.21107079f, -0.11288729f, -0.00023393f, -0.33717677f, -0.12869798f, -0.38370422f, 
    0.21924265f, -0.38529238f, -0.37911803f, -0.32979441f, -0.25841525f, 0.16520250f, -0.07723942f, 0.15902346f, 
    0.16477016f, -0.33920699f, 0.20833166f, -0.00502541f, -0.21341927f, -0.46542674f, 0.06546646f, 0.15559499f, 
    0.11873344f, 0.00524280f, -0.04734389f, -0.02051908f, -0.28792471f, -0.11067684f, -0.01236485f, 0.14502372f, 
    0.04604103f, -0.10597051f, 0.01845941f, -0.03912318f, -0.07313123f, 0.05073289f, -0.11857149f, -0.06714296f, 
    -0.01058960f, 0.11808605f, 0.07501025f, 0.03156006f, -0.01448156f, -0.03185431f, -0.00937949f, 0.09700386f, 
    -0.53438002f, 0.28372586f, 0.10768890f, -0.00363282f, 0.32839984f, -0.06374904f, 0.22265773f, 0.27980953f, 
    -0.38000217f, -0.45700771f, 0.09150811f, -0.12688757f, 0.13587338f, 0.08654405f, 0.04940635f, -0.05698458f, 
    -0.42821130f, -0.01781033f, -0.55277240f, 0.03127279f, -0.10495095f, 0.33514521f, 0.11005913f, 0.20819540f, 
    0.22683068f, -0.07149043f, -0.26282471f, -0.40341765f, 0.04451142f, 0.04289685f, -0.43776131f, 0.11563382f, 
    -0.32158545f, 0.10272762f, -0.17315955f, -0.12103397f, 0.21730743f, 0.22014578f, 0.28326926f, -0.01191160f, 
    -0.01693405f, -0.35169819f, -0.56605154f, -0.09178429f, -0.40234771f, -0.04272143f, 0.01529942f, -0.35584262f, 
    -0.01612381f, 0.04056048f, 0.04944611f, -0.02200660f, 0.12992467f, 0.06286839f, -0.14177553f, -0.04262300f, 
    0.21090069f, 0.07235526f, 0.11863022f, 0.04868690f, -0.06931685f, -0.02724067f, -0.10418196f, -0.08239298f, 
    0.24422833f, 0.22009601f, 0.09209218f, 0.10024434f, -0.47876444f, 0.21622950f, -0.45712489f, -0.17784804f, 
    -0.24058093f, 0.08345974f, 0.06226213f, 0.06827370f, 0.29596317f, -0.11676375f, 0.05926899f, 0.06987903f, 
    -0.41359961f, 0.27060041f, 0.23006129f, -0.07358651f, 0.02202322f, 0.46925816f, 0.21653682f, 0.41713473f, 
    0.04601373f, 0.16210890f, 0.21198326f, -0.13989268f, 0.05242265f, -0.13899326f, 0.06634653f, -0.12116452f, 
    -0.29251009f, -0.05821659f, 0.11357272f, 0.02616258f, 0.20314893f, -0.16794507f, -0.24235573f, -0.24935138f, 
    -0.05133969f, 0.15986528f, 0.09900093f, 0.03531037f, -0.39082468f, -0.00730881f, -0.07770539f, 0.04716858f, 
    -0.02979879f, 0.09798262f, -0.09227829f, -0.07400679f, -0.11416850f, -0.02705844f, 0.08112747f, -0.03981899f, 
    0.35562864f, 0.04643500f, 0.00250899f, -0.20116556f, 0.02386319f, 0.01566833f, 0.00972978f, -0.11016988f, 
    0.10422496f, -0.20542133f, -0.00495377f, 0.01514532f, 0.03020206f, -0.26768944f, -0.14577071f, -0.20995305f, 
    0.14768279f, -0.12992208f, -0.13048770f, -0.17235461f, -0.02781999f, -0.10354732f, -0.06384396f, 0.07716946f, 
    0.01214570f, -0.25780761f, -0.20845193f, -0.10921623f, -0.11558192f, 0.06209982f, -0.34877282f, 0.21883084f, 
    -0.14728491f, 0.13985640f, 0.14897230f, 0.24016590f, 0.06074440f, -0.20016180f, 0.21699286f, 0.05957951f, 
    0.10435957f, 0.28843632f, 0.04000483f, -0.07667274f, 0.14768840f, 0.25152600f, -0.09825668f, -0.41148314f, 
    0.02006380f, 0.23941012f, -0.25040415f, -0.01745795f, 0.17089318f, -0.11892096f, -0.12820542f, -0.04860394f, 
    0.09324428f, 0.08970827f, 0.08570490f, 0.04798186f, 0.10345636f, 0.08243318f, -0.21768627f, 0.01614168f, 
    -0.12751509f, 0.07241722f, 0.07810941f, -0.37139866f, -0.09264127f, 0.07762012f, 0.02899740f, -0.12106251f, 
    -0.42163160f, -0.00695529f, -0.09579585f, 0.07075439f, 0.10745301f, 0.09663341f, 0.05164566f, 0.19579747f, 
    0.16962141f, 0.32365116f, -0.05518918f, 0.20770246f, -0.32421637f, -0.07127727f, 0.02699051f, 0.05274377f, 
    0.16430588f, -0.08404576f, -0.11349061f, 0.05911307f, -0.05412285f, -0.30926618f, 0.21629380f, -0.60700256f, 
    0.14749070f, 0.24103384f, 0.13638799f, 0.31587520f, 0.03068784f, 0.23427063f, 0.05024741f, -0.31333736f, 
    0.33724040f, -0.10039467f, -0.36936742f, 0.03494337f, 0.20822193f, -0.19199720f, -0.63528126f, 0.22547568f, 
    0.11715611f, -0.28689221f, -0.12911467f, -0.04421470f, 0.12739120f, 0.01299874f, -0.01771159f, -0.63259852f, 
    -0.11500477f, -0.12837137f, -0.06536043f, -0.07518800f, -0.18491879f, 0.03117961f, 0.02038710f, -0.08246153f, 
    0.20020047f, -0.09639895f, 0.20953532f, -0.29061016f, -0.04435886f, -0.04125194f, -0.01254577f, 0.09747683f, 
    -0.25494310f, -0.32698753f, 0.08023292f, 0.04654211f, -0.17808323f, 0.07754049f, 0.01545295f, -0.23299810f, 
    0.02805663f, -0.31574875f, 0.00553408f, -0.35127315f, 0.15786901f, 0.00191321f, 0.04047040f, 0.01451775f, 
    0.09141313f, 0.13942702f, -0.02843404f, 0.02444116f, -0.00599533f, 0.04302099f, 0.15685189f, -0.29218152f, 
    -0.28264278f, -0.07867881f, 0.11613577f, -0.12368705f, -0.25345916f, 0.02853534f, -0.35192606f, 0.08243542f, 
    -0.09893550f, 0.23834740f, 0.20257789f, 0.13780987f, -0.29939672f, -0.22588967f, -0.11477246f, 0.21381727f, 
    0.04552017f, -0.03747917f, -0.22856189f, 0.08525892f, -0.20751376f, -0.07593156f, -0.36038679f, 0.11951068f, 
    -0.04812253f, -0.09364309f, -0.05372426f, -0.00431640f, -0.19825205f, -0.10760845f, -0.03104554f, 0.09710024f, 
    -0.07062095f, 0.07969081f, 0.17037965f, 0.15603994f, 0.09987956f, -0.07786340f, -0.04116980f, 0.03073303f, 
    0.15104048f, -0.08892252f, -0.29274204f, -0.11316256f, 0.23437795f, 0.23364812f, -0.26486096f, 0.31476399f, 
    -0.01617524f, 0.12099827f, 0.01590117f, 0.20606667f, -0.24387096f, 0.00415565f, -0.03814777f, -0.00569109f, 
    0.02628309f, -0.35067636f, -0.00980178f, -0.11065730f, 0.07450415f, -0.27004468f, -0.27254376f, 0.08610141f, 
    -0.29842541f, 0.18923309f, 0.35597438f, 0.09330366f, 0.15369688f, -0.08147527f, -0.38706374f, 0.06214141f, 
    -0.26076716f, 0.08857729f, 0.29580060f, -0.01195995f, -0.38838032f, 0.22972843f, 0.20872009f, -0.10322495f, 
    0.02272275f, 0.14234851f, 0.13275097f, 0.11302923f, -0.14231299f, 0.03691806f, 0.05515111f, 0.31907997f, 
    -0.09332944f, -0.02510282f, 0.08637996f, 0.05312177f, 0.16168429f, -0.11398020f, 0.32574281f, -0.05268239f, 
    -0.22876617f, -0.01011291f, -0.37107038f, -0.17566068f, 0.03908294f, 0.02065100f, 0.05769481f, 0.04030454f, 
    -0.18052968f, -0.17211607f, 0.21061151f, 0.06568822f, 0.20047659f, -0.21200489f, 0.13577195f, 0.15894313f, 
    -0.38379914f, -0.38801822f, 0.07244462f, -0.16297665f, 0.01553107f, -0.02003821f, 0.02819171f, -0.05692209f, 
    -0.28071430f, -0.19102837f, 0.14140043f, -0.09647612f, -0.04430112f, -0.43726596f, 0.17054290f, -0.10953923f, 
    -0.26549062f, -0.21174812f, 0.19731884f, -0.16317686f, -0.34719208f, -0.48296237f, 0.02576678f, -0.68018770f, 
    0.00327551f, -0.48364297f, -0.33865526f, 0.08288489f, 0.21378919f, 0.06810497f, 0.20945729f, 0.23132242f, 
    -0.05241535f, -0.23901148f, 0.26582518f, -0.12241930f, 0.09720907f, 0.10031420f, 0.18718673f, 0.37314203f, 
    -0.10995364f, -0.00127993f, -0.11495636f, -0.04228334f, -0.23878832f, -0.04726581f, -0.23489931f, -0.00521123f, 
    0.10443024f, -0.04865036f, 0.11860573f, 0.28954625f, -0.10425322f, -0.07008490f, 0.09352818f, -0.02405834f, 
    -0.22854827f, -0.05351098f, -0.36986318f, -0.10265534f, 0.36815429f, 0.11086458f, -0.01409238f, 0.31277832f, 
    0.21300837f, 0.00326197f, 0.04075567f, 0.01432289f, 0.04847524f, 0.04266225f, -0.08303698f, -0.05943957f, 
    -0.25703233f, 0.18494390f, -0.29672280f, 0.02038254f, 0.10307468f, -0.49067518f, 0.01736764f, 0.13808998f, 
    0.04951456f, -0.41526854f, -0.02898193f, 0.04391491f, 0.29219893f, -0.09327072f, -0.06417919f, 0.09801492f, 
    0.06959930f, -0.08417066f, -0.28865364f, -0.02471206f, -0.07231832f, 0.16537127f, -0.10707436f, -0.02401624f, 
    -0.10305714f, -0.19239689f, -0.30634278f, -0.09812120f, 0.40134951f, 0.11610172f, 0.11663523f, -0.16254625f, 
    0.06860430f, 0.04787093f, -0.09090143f, 0.09736221f, -0.64570999f, 0.09714760f, 0.19413541f, -0.05429983f, 
    -0.15876819f, 0.03287921f, -0.25951821f, 0.24700773f, -0.09342915f, -0.05046191f, 0.04315998f, 0.08173558f, 
    0.15936916f, 0.04468317f, 0.22080961f, -0.01053157f, -0.33148918f, -0.24829876f, 0.10668928f, 0.22771896f, 
    -0.20400178f, 0.19174598f, 0.10918909f, 0.31473753f, -0.29881305f, 0.03328977f, 0.04967001f, -0.05546940f, 
    -0.05584399f, -0.22656909f, -0.57456136f, 0.09484284f, 0.10351214f, 0.08591881f, -0.07046837f, -0.33382189f, 
    0.26130432f, -0.18972504f, -0.21517563f, 0.04978275f, -0.35551968f, 0.38152778f, -0.21787030f, -0.15123542f, 
    -0.14161888f, -0.14250542f, 0.29284093f, -0.03860806f, 0.00250611f, 0.13649641f, 0.07278024f, 0.05713483f, 
    0.05826771f, 0.38314623f, 0.31154570f, -0.09212034f, 0.02953139f, -0.02053384f, 0.25552332f, -0.44746214f, 
    0.05036958f, -0.02474415f, -0.08871828f, 0.03889510f, 0.04095130f, -0.08018221f, 0.11446719f, 0.11601726f, 
    0.03154638f, 0.07398910f, -0.13060591f, -0.12448034f, -0.01285566f, -0.04385959f, 0.05566521f, 0.05388252f, 
    0.09633983f, 0.27887180f, 0.06076716f, 0.05145052f, -0.38004762f, -0.04335424f, -0.16529331f, -0.04609436f, 
    0.34286845f, -0.05998283f, -0.11078846f, -0.26703089f, -0.05902762f, -0.06809932f, -0.06629947f, -0.09956782f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.03275748f, -0.05532924f, -0.09405248f, -0.06748253f, 0.02463933f, 0.02692857f, 0.09858052f, -0.15017886f, 
    0.06036791f, 0.10088085f, 0.15270555f, -0.05754001f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
