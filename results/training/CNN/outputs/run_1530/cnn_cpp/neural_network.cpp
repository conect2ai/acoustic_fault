#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.70726001f, -0.19341004f, -0.30813649f, -0.73880452f, -0.65779412f, 0.45555380f, 0.71492052f, 0.02004090f, 
    0.49394327f, 0.32416004f, -0.08651306f, 0.10974351f, -0.22971630f, 0.05065060f, -0.15307453f, -0.38930759f, 
    -0.40064192f, -0.44138315f, 0.46935377f, -0.06612320f, 0.06097326f, 0.11001018f, -0.12084279f, 0.53297836f, 
    0.54575855f, 1.41943109f, 0.40656343f, 0.47686833f, 0.43613759f, -0.09421641f, -0.04959716f, -0.17624325f, 
    0.34242481f, 0.22323935f, -0.17034151f, -0.00843468f, 0.01082924f, -0.39746058f, -0.40583703f, -0.28534794f, 
    -0.33864942f, -0.00269994f, 0.02815057f, -0.46925923f, -0.21226500f, 0.15820648f, -0.44526425f, -0.08699767f, 
    -0.11148256f, 0.07156394f, 0.48215517f, 0.45909196f, 0.36696452f, -0.64900202f, 0.15339357f, -0.77091688f, 
    -0.48266628f, 0.45679843f, 0.03968128f, 0.39359477f, -0.32303482f, -0.42381367f, 0.14532231f, 0.23156540f, 
    0.41901493f, 0.41867539f, -0.07914164f, -0.55872244f, -0.03449869f, 0.13066226f, -0.03211960f, -0.19301158f, 
    0.31647864f, 0.07737318f, 0.30722192f, -1.74963725f, -0.76106977f, -0.56423461f, -1.00347233f, -1.07621706f, 
    0.71933311f, -0.35563812f, -0.96913689f, 0.12122335f, 0.14830869f, -0.50299186f, -0.35611448f, -0.16933727f, 
    -0.43800715f, -0.30393994f, 0.05898936f, 0.15432009f, -0.20484830f, -0.22987635f, 0.02559655f, -0.15355855f, 
    0.18363163f, -0.01520630f, -0.09058650f, 0.06782698f, -1.78080356f, -1.10976648f, -0.64169413f, 0.55250102f, 
    0.58519739f, -0.11653215f, 0.31075817f, -0.17735827f, 0.46630955f, 1.32798302f, 0.47451463f, 0.27181870f, 
    -0.12113542f, 0.27132964f, -0.08392733f, -0.40843308f, -0.24928014f, -0.18995161f, -0.23016088f, -0.52523673f, 
    0.14090796f, 0.02044163f, 0.14145352f, 0.11402025f, 0.22733960f, -0.43034312f, 0.05010551f, 0.57746905f, 
    0.35937962f, -0.29044175f, -1.00141203f, -0.65260589f, -0.01190645f, -0.09001236f, -0.46588171f, 0.06105994f, 
    0.48639002f, -0.22463885f, 0.12025595f, 0.38774732f, -0.12159708f, -0.22310059f, 0.29350707f, -0.03405974f, 
    -0.63520628f, 0.25169143f, 0.17967807f, 0.08181971f, 0.34974432f, 0.44630513f, 0.47798890f, -0.31288731f, 
    -0.28210229f, 0.93661046f, -0.18117090f, 0.70093542f, 0.06585593f, -0.04895125f, -0.18800862f, 0.04030621f, 
    0.30149543f, 0.79540288f, -0.12782012f, -0.53110498f, 0.15170197f, -0.03215862f, 0.39969000f, -0.32704294f, 
    -0.15567800f, -0.28580728f, 0.42742088f, 0.27812827f, 0.21119577f, 0.27447280f, -0.03006963f, 1.45223260f, 
    -0.57615536f, -1.17668200f, -1.08893740f, -1.65331936f, 0.63176376f, 0.13651612f, 0.24704078f, 0.06208106f, 
    0.35721964f, -0.09507605f, 0.57630789f, -0.03541232f, -0.20870697f, 0.17386676f, -0.05170495f, 0.25202373f, 
    0.12452611f, -0.21228388f, 0.03248321f, 0.23418540f, -0.39446554f, -0.42334503f, 0.25142482f, -0.26182944f, 
    -1.24609458f, -0.75652522f, 0.21358517f, 1.05714130f, 0.39370707f, 1.14185643f, 0.30236006f, -0.12971805f, 
    0.02847608f, 0.07254468f, -0.22650984f, -0.22849232f, -0.58614892f, 0.23578109f, -0.45153216f, 0.11934629f, 
    0.05554157f, -0.09188154f, 0.06039798f, -0.04392121f, 0.03369794f, -0.39428070f, -0.23954147f, -0.08500884f, 
    -0.32277688f, -0.61027467f, 0.18693438f, -0.11604624f, 0.87939692f, -0.09238981f, 0.17585903f, -0.87664694f, 
    -0.20627894f, 0.60741270f, 0.57695484f, 0.47069943f, -0.85251385f, 0.49104843f, -0.32474768f, -0.17160054f, 
    -0.26910365f, -0.26119709f, 0.24397415f, 0.21827251f, -0.32635295f, -0.40950027f, -0.33883202f, 0.42903656f, 
    0.42383498f, -0.01528922f, -1.24216378f, 0.63328719f, 0.54348373f, -1.37415719f, -0.85870236f, 0.25081545f, 
    0.42745662f, 0.43320313f, 0.27071553f, 0.34399447f, 0.03774127f, -0.40510714f, -0.21567850f, -0.28785822f, 
    0.11389113f, 0.12502562f, -0.05920894f, -0.51792717f, -0.50783795f, -0.20462143f, -0.19946651f, -0.23589271f, 
    -0.19878094f, -0.50489175f, -0.78777885f, 0.19382851f, 0.29301080f, 0.90614927f, 0.85045362f, 0.57598585f, 
    -0.13631231f, -0.65499270f, -0.54278880f, -0.43249020f, -0.33900836f, -0.59686273f, 0.01797673f, -0.01702444f, 
    0.27002227f, -0.03703363f, 0.20812722f, -0.08666174f, -0.05561898f, -0.00826295f, 0.29952660f, -0.07083890f, 
    -0.14177737f, 0.23969127f, -0.31982225f, -0.22461899f, 0.10695746f, -1.09271145f, -0.98957646f, -0.67284584f, 
    -0.64653242f, -0.93270355f, -1.08184731f, -1.18874133f, -1.12307322f, -1.11173487f, 0.27987504f, -0.45698723f, 
    0.14774597f, 0.75976986f, 0.24443834f, 0.04574949f, -0.14030920f, -0.28387162f, 0.20744874f, -0.09659472f, 
    -0.27016619f, -0.19929659f, -0.20340261f, -0.00116092f, -0.28177238f, 0.68541646f, -1.50872946f, -0.82552910f, 
    -0.05396837f, 0.91447026f, -1.16245484f, -0.45260879f, -0.55005836f, -0.41597027f, -0.25203183f, 0.34908813f, 
    -0.52797866f, 0.34992349f, -0.47461572f, -0.42550197f, 0.36149737f, 0.03520003f, -0.00903139f, -0.03094184f, 
    0.07713928f, 0.04953143f, -0.00521967f, 0.20658350f, 0.16674653f, 0.63929802f, -0.00216874f, 0.74174744f, 
    0.09726288f, -0.15188171f, -0.01605766f, -0.70635259f, -0.56599188f, 0.71113759f, 0.06148119f, 0.09842379f, 
    -0.75214243f, -0.46118423f, 0.80624497f, -0.33004981f, -0.19045652f, 0.26664385f, 0.69021040f, -0.07069601f, 
    -0.38543111f, -0.19127791f, 0.02977602f, 0.30054814f, -0.13349059f, 0.04415719f, -0.56572098f, -0.17458542f, 
    -0.00390410f, 0.74087793f, -0.27290350f, -0.49052644f, 0.11935288f, -0.28917876f, 0.10326312f, -0.30617344f, 
    0.26099777f, -0.11927544f, 0.05529293f, 0.38250473f, 0.46621436f, -0.57170570f, 0.19068626f, -0.15894125f, 
    0.15442143f, 0.37930173f, -0.12865035f, 0.81389296f, -0.07205964f, -0.12414489f, -0.24661426f, -0.15682441f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.45511615f, 0.43853876f, 0.40873280f, -0.10715328f, 0.43752146f, 0.37618554f, 0.18761788f, 0.67252278f, 
    0.57735068f, 0.50782460f, -0.04504330f, 0.42346758f, -0.30033073f, 0.32396895f, 0.68917006f, 0.55252755f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.25986478f, -0.29843044f, -0.24469902f, 0.09572078f, 0.01889353f, -0.00370827f, -0.08672229f, 0.00417914f, 
    0.05896736f, -0.34420964f, -0.48957908f, -0.15295491f, -0.54578358f, -1.23990893f, -0.32776031f, 0.33966389f, 
    0.05951978f, 0.15302303f, -0.01414564f, 0.12673463f, -0.01096868f, -0.00932764f, 0.07476225f, 0.11219811f, 
    0.06145668f, 0.09837396f, 0.09856646f, 0.03193200f, -0.09261847f, -0.08841236f, -0.06731780f, 0.04632352f, 
    -0.10658501f, -0.06554882f, -0.17348412f, -0.03724216f, 0.54100543f, 0.41319066f, -0.06813778f, -0.28041112f, 
    0.15475179f, 0.41838884f, 0.24804884f, 0.11001904f, -0.05821622f, -0.03786560f, -0.10644321f, -0.07194284f, 
    0.14014396f, 0.53326052f, 0.27968481f, -0.28743553f, 0.11658069f, 0.20659234f, 0.22478127f, -0.04704103f, 
    -0.06218595f, 0.07946978f, -0.08748896f, -0.13740328f, 0.28386092f, 0.19059056f, 0.16372527f, -0.15232733f, 
    0.05195382f, 0.07538840f, -0.14124325f, 0.00018666f, 0.04600955f, 0.01420870f, -0.10169261f, -0.15728590f, 
    -0.12040288f, -0.06836059f, 0.04566252f, 0.14616881f, -0.21755257f, 0.10532412f, -0.04913347f, 0.02724010f, 
    -0.10106248f, 0.02108167f, 0.07514518f, -0.06996559f, 0.12903459f, -0.15139711f, -0.30744028f, 0.06598300f, 
    0.17130792f, 0.09680142f, -0.39386624f, -0.28019553f, -0.30208200f, 0.14463410f, 0.17749453f, 0.02871625f, 
    0.76590073f, -0.15119037f, -0.16732264f, -0.24693136f, -0.08863303f, -0.03806386f, -0.02834779f, 0.01348639f, 
    -0.22443943f, -0.03525479f, -0.02652333f, 0.15698889f, -0.76770073f, -0.15540630f, 0.22306243f, -0.42442062f, 
    0.06185215f, 0.01942465f, 0.02773380f, 0.10793757f, -0.11955389f, -0.10970721f, -0.12263250f, -0.12705190f, 
    -0.33580226f, -0.21722393f, -0.05148323f, -0.30837160f, 0.01883857f, 0.05142608f, -0.10774206f, 0.08907334f, 
    -0.05821533f, 0.02394546f, -0.08653948f, -0.00635440f, -0.49146482f, -0.10888766f, 0.10041694f, -0.27178720f, 
    0.06689832f, -0.11654630f, -0.19955462f, 0.00480175f, 0.06361169f, 0.03237231f, 0.00331676f, 0.07958113f, 
    0.56340855f, 0.18797824f, -0.10890529f, -0.33183256f, 0.23498702f, 0.07164098f, 0.00512836f, 0.13073473f, 
    -0.10665482f, 0.06043406f, 0.00453277f, 0.01423013f, 0.43318409f, 0.42388877f, -0.14569601f, -0.71032685f, 
    0.26949450f, -0.07124538f, 0.05848787f, -0.24182890f, -0.10141978f, 0.03860248f, -0.05237703f, -0.07324240f, 
    -1.36221218f, -0.33152524f, 0.33013666f, -0.05430266f, -0.11170965f, -0.19285086f, 0.00906936f, -0.06090996f, 
    0.08250698f, -0.13742104f, -0.18028663f, 0.04517579f, -0.22179484f, -0.18834582f, -0.05756276f, -0.08987209f, 
    -0.36233521f, -0.24779047f, -0.12831987f, -0.21912640f, 0.15641072f, -0.18154666f, -0.14306369f, -0.00533877f, 
    0.54258078f, 0.06559018f, -0.22493325f, -0.16969591f, -0.04565510f, 0.01610004f, 0.14032426f, 0.06479116f, 
    0.01423774f, 0.26637229f, -0.04683765f, -0.08868826f, 0.73962986f, 0.42991510f, 0.29841927f, 0.24005315f, 
    -0.14851333f, 0.04046969f, -0.05153246f, -0.11725930f, 0.00971182f, 0.01806413f, -0.08345463f, 0.22763042f, 
    0.33725026f, 0.00654511f, -0.03175407f, 0.01092638f, 0.06115752f, 0.11813582f, 0.11670437f, -0.10009846f, 
    -0.00388573f, 0.01306112f, 0.09229590f, 0.05274033f, 0.27578771f, 0.61623263f, 0.09295664f, 0.22852512f, 
    0.05947009f, 0.07517164f, -0.26111200f, 0.06406673f, -0.01915474f, 0.04150551f, -0.02586461f, -0.12617789f, 
    -0.41885272f, -0.35722941f, -0.59840953f, -0.12505452f, -0.16633098f, 0.10879288f, -0.00537352f, 0.01842962f, 
    -0.00328954f, -0.13741188f, 0.03273186f, 0.03319572f, -0.46234483f, 0.19244829f, -0.08477619f, -0.31098068f, 
    -0.08031733f, 0.00755223f, 0.03815839f, 0.35906282f, -0.13912301f, -0.06739441f, 0.00023938f, 0.03535674f, 
    0.17500657f, -0.00995768f, -0.10714585f, 0.11045875f, -0.02988791f, 0.01843863f, -0.05675169f, 0.26703888f, 
    -0.10572574f, 0.02152574f, -0.19093813f, 0.16188788f, 0.79339939f, -0.53672397f, 0.05030086f, -0.45237818f, 
    -0.00112742f, -0.02950750f, -0.14474684f, -0.23006512f, 0.31616762f, 0.02783618f, -0.25068584f, -0.00429192f, 
    0.39907494f, -0.13178943f, -0.11542412f, 0.24108198f, -0.14383918f, -0.11251834f, -0.02888725f, 0.06873523f, 
    0.21294628f, -0.11816525f, -0.06000158f, -0.24472871f, -0.61280853f, 0.67050517f, -0.00545663f, -0.27978575f, 
    0.08759066f, -0.09543373f, 0.12622523f, -0.13263388f, 0.12632436f, 0.12306083f, 0.03100467f, -0.01800757f, 
    -0.25459060f, -0.22214922f, 0.24189286f, -0.02939784f, 0.10502343f, -0.02130194f, -0.18316416f, -0.07705612f, 
    -0.33446795f, -0.24547803f, -0.29840618f, -0.52442300f, 0.12961450f, 0.16485527f, -0.35542539f, -0.27901912f, 
    0.00799678f, -0.17976579f, -0.05845588f, -0.01305966f, -0.08299600f, 0.06099955f, 0.08962940f, 0.06639118f, 
    -0.07667965f, -0.00854360f, 0.18058127f, -0.04565058f, -0.02257681f, -0.26046962f, 0.21690342f, -0.25037506f, 
    0.01157471f, -0.06934965f, 0.14266069f, 0.03322719f, -0.15543777f, 0.18871552f, -0.24669407f, 0.02610547f, 
    -0.21438591f, 0.02875537f, 0.13581036f, -0.33520654f, -0.04478601f, -0.09264953f, -0.00250999f, 0.02684739f, 
    -0.43408522f, 0.00894754f, 0.26156762f, -0.03887174f, 0.11322030f, -0.11323003f, -0.05759381f, 0.02866738f, 
    0.01936623f, 0.37223566f, -0.11302687f, 0.07443336f, -0.25119546f, -0.19186272f, 0.10656735f, -0.13401300f, 
    0.06460623f, 0.14205484f, 0.01731770f, 0.24694498f, -0.37816691f, -0.11136912f, 0.18136707f, 0.21057579f, 
    -0.26838028f, 0.32342643f, 0.09654679f, -0.24892852f, -0.01212950f, -0.00670838f, -0.11704157f, 0.07545120f, 
    -0.25179222f, -0.29959360f, -0.03744236f, -0.21004730f, -0.88214755f, -0.04747728f, 0.22789189f, -0.01565131f, 
    -0.01848958f, -0.10897736f, 0.00161178f, 0.10234257f, 0.05701418f, -0.03108141f, -0.10812853f, 0.03493450f, 
    -0.26670393f, -0.14115056f, 0.08265208f, 0.17783667f, -0.08297185f, 0.13112748f, -0.00149733f, -0.06309055f, 
    -0.06186826f, 0.08620695f, -0.06476716f, 0.09992580f, -0.18965124f, 0.43448374f, 0.58372492f, 0.99375600f, 
    -0.18394597f, -0.04810729f, -0.14650133f, 0.00399171f, -0.04494182f, -0.06804504f, -0.17339168f, -0.01670330f, 
    0.30558732f, -0.41294998f, 0.34764925f, 0.35263821f, 0.14764868f, 0.02364838f, -0.01982284f, 0.17248985f, 
    -0.02538569f, -0.16232818f, -0.05061781f, -0.01941920f, -0.51024419f, -0.10686862f, -0.20326495f, 0.05284787f, 
    0.12101872f, -0.01729235f, -0.19869141f, -0.00333283f, 0.02586851f, -0.06552052f, 0.01282890f, -0.02278393f, 
    -0.17203756f, -0.13156940f, -0.10713560f, -0.06685315f, -0.02468727f, -0.25713661f, 0.03050677f, 0.00144959f, 
    0.14469619f, -0.17905965f, 0.01016467f, 0.01843568f, 0.00034835f, 0.65502250f, 0.31391597f, 0.04192216f, 
    -0.03599957f, 0.00506429f, 0.32625958f, -0.26407343f, 0.03753588f, 0.11399812f, -0.14632429f, 0.19053356f, 
    0.03959377f, -0.04142657f, -0.09426343f, -0.01859031f, -0.05426485f, 0.03982237f, 0.01955123f, 0.27414519f, 
    0.26200849f, 0.04362002f, -0.09888332f, 0.12772889f, -0.46901110f, 0.23493662f, -0.29534805f, -0.33219457f, 
    -0.02378449f, 0.04721486f, 0.09147663f, 0.05693317f, -0.06999118f, -0.04465216f, 0.24626301f, 0.02385443f, 
    0.53673971f, 0.44254315f, 0.36573756f, 0.27246046f, 0.00079984f, -0.02896650f, 0.11908184f, -0.25115845f, 
    0.02823986f, 0.17201759f, -0.07075555f, 0.09250446f, -0.38064584f, 0.44871247f, -0.47436705f, -0.22375575f, 
    -0.00983088f, -0.06902216f, 0.05372638f, 0.06122947f, 0.04143356f, -0.04205017f, 0.08849985f, -0.03699998f, 
    -1.40631866f, -1.25700819f, -0.07479209f, -0.62820917f, -0.00527509f, -0.19923757f, -0.06927558f, -0.28645244f, 
    -0.00284762f, 0.02225519f, -0.00013614f, -0.15963401f, -0.11224493f, -0.33982280f, -0.26531366f, 0.08617972f, 
    -0.08572423f, 0.23528296f, 0.16027237f, -0.07995468f, -0.03706827f, -0.15289992f, -0.03610543f, -0.05159771f, 
    -0.18010537f, -0.46017563f, -0.37486553f, 0.24426179f, 0.03130078f, 0.07721291f, 0.15223226f, -0.13008267f, 
    -0.07331365f, -0.05385096f, 0.01636759f, 0.10435989f, 0.30347094f, 0.00527326f, 0.06290010f, 0.12758240f, 
    0.09424059f, -0.00742428f, -0.09364551f, 0.06309862f, 0.15542080f, -0.21254280f, 0.28017810f, -0.04550432f, 
    -0.39464477f, 0.05144287f, -0.36242142f, 0.49945065f, 0.37099114f, 0.17747723f, 0.19091105f, -0.03801989f, 
    -0.08802266f, -0.13168587f, 0.31494918f, 0.00339389f, -0.99552900f, -0.17237593f, 0.23723033f, -0.27227533f, 
    -0.35149148f, 0.02378780f, -0.15912654f, -0.18237162f, 0.14449866f, 0.22644889f, -0.02365022f, 0.01822150f, 
    0.04328873f, 0.18711743f, 0.16854407f, -0.22585621f, -0.02724341f, -0.18124750f, -0.27470273f, -0.17099771f, 
    0.03827212f, -0.20731005f, 0.10536402f, -0.17307840f, 0.23960756f, -0.23310865f, 0.05707113f, 0.29892296f, 
    -0.09440383f, -0.17737867f, -0.03479771f, 0.03781497f, -0.05946106f, 0.17192844f, -0.04452746f, 0.25501391f, 
    0.24493891f, 0.03043352f, -0.18980491f, -0.23707332f, 0.26961505f, -0.01545365f, 0.00391954f, -0.18594825f, 
    -0.10284431f, 0.00946172f, -0.10439434f, 0.03201281f, 0.29573134f, 0.09500697f, 0.19293372f, -0.01083006f, 
    -0.03155402f, -0.05186184f, -0.01699923f, 0.04523220f, 0.05363964f, -0.00545136f, 0.08183671f, -0.00513220f, 
    -0.36574751f, -0.12019467f, -0.12931482f, -0.06079474f, 0.03687375f, -0.28997898f, 0.00720645f, -0.33926830f, 
    -0.07502623f, 0.29105192f, -0.07342179f, 0.13758256f, -0.63634861f, -0.10815239f, 0.03711927f, 0.60730761f, 
    -0.00082202f, -0.05712932f, 0.15948482f, -0.16180998f, -0.05058867f, -0.05015609f, -0.14018567f, 0.16079190f, 
    -0.60564405f, 1.11947429f, -0.41382593f, -0.83243668f, 0.26864791f, 0.30725744f, 0.20750721f, 0.06815573f, 
    -0.54068106f, -0.02553052f, 0.07057272f, 0.09696651f, 0.18548852f, -0.12602565f, 0.13850178f, -0.51736814f, 
    -0.33860686f, 0.21132439f, -0.15556872f, -0.27424911f, -0.00477945f, 0.01814427f, 0.06805389f, -0.04135004f, 
    0.99743229f, -0.19958037f, 0.29472089f, 0.37234044f, 0.08448918f, 0.14740857f, 0.13356689f, 0.02770104f, 
    -0.19893375f, 0.00490399f, -0.02044420f, 0.17237982f, 0.03931936f, 0.45665556f, 0.36688504f, 0.24973686f, 
    -0.56077665f, 0.12251769f, -0.07604685f, 0.00893604f, 0.04875905f, 0.04904307f, 0.10299437f, 0.15569189f, 
    -0.24712396f, -0.32846168f, -0.27002642f, 0.32801729f, 0.07075293f, 0.20127308f, 0.09374260f, 0.22042815f, 
    0.02371790f, -0.09161359f, 0.08774246f, -0.14047928f, -0.19211635f, 0.22326158f, -0.36822656f, 0.41349304f, 
    0.09458539f, 0.03965499f, -0.16417232f, -0.35113811f, -0.21443594f, -0.00717392f, -0.03551564f, -0.40571114f, 
    0.37715074f, -0.20532621f, -0.39935505f, -0.49171773f, -0.44626069f, -0.19308133f, -0.14270833f, 0.05597178f, 
    -0.15839383f, 0.14102389f, -0.00861622f, -0.04876182f, -0.06948128f, 0.03259759f, -0.05208226f, 0.18558285f, 
    0.09007521f, 0.16561760f, -0.33618838f, -0.35591939f, -0.10444146f, 0.04050234f, 0.15090783f, -0.15408304f, 
    -0.05154280f, 0.25548539f, 0.00632928f, -0.10149591f, -0.12630381f, -0.06273995f, -0.13872485f, 0.21814725f, 
    -0.36777449f, -0.27776197f, -0.34004492f, 0.04586169f, -0.04595583f, -0.77021337f, -0.27130711f, 0.05390442f, 
    0.03758930f, -0.02019133f, 0.11041702f, 0.07690842f, 0.06331265f, 0.03109738f, 0.05034631f, -0.09434886f, 
    -0.08449442f, -0.25595105f, -0.00478810f, 0.09928568f, -0.24669899f, 0.17124157f, -0.07101534f, 0.13493545f, 
    -0.03076007f, -0.07485940f, -0.09277804f, -0.13458955f, -0.23387101f, -0.23155987f, -0.06327358f, 0.12328374f, 
    -0.10786793f, -0.07578070f, 0.08560573f, -0.04005222f, 0.04136165f, -0.09988490f, 0.13929197f, -0.01848309f, 
    0.31933030f, 0.37659535f, -0.08158309f, 0.28114438f, -0.07831663f, -0.04181724f, -0.04456844f, -0.13403389f, 
    -0.05909010f, -0.09372502f, -0.16104995f, -0.00499836f, -0.10187432f, 0.00832733f, 0.25696924f, 0.25279340f, 
    -0.27291948f, -0.33995295f, 0.16440128f, 0.07226799f, -0.06842482f, -0.12141576f, -0.13427521f, -0.09345629f, 
    0.38154349f, 0.11749472f, 0.08769152f, 0.02268590f, 0.27526888f, 0.10466895f, 0.06775668f, -0.03933561f, 
    0.13771592f, -0.01428996f, -0.12032704f, -0.15741757f, -0.15832488f, 0.00353300f, 0.13611421f, 0.03874818f, 
    0.04184168f, -0.15881516f, -0.30999455f, -0.14862186f, -0.01237207f, -0.07291196f, 0.03080641f, -0.12408119f, 
    0.17819595f, -1.02116370f, 0.31489971f, -0.01441948f, -0.06538296f, 0.09189493f, 0.10530206f, -0.01068467f, 
    -0.00411414f, 0.19438598f, -0.16567652f, 0.07174302f, -0.30168647f, -0.24005418f, -0.57546109f, -0.11927570f, 
    -0.22469418f, -0.05528774f, 0.19339623f, 0.22093323f, -0.17613290f, -0.11635011f, -0.09191615f, -0.03675105f, 
    -0.07142073f, 0.05780398f, -0.42384914f, 0.02290752f, -0.13880453f, -0.20261674f, 0.10767832f, -0.07834303f, 
    0.32070726f, -0.06755906f, 0.16665703f, 0.37045506f, 0.29613951f, -0.28685534f, 0.50819850f, 0.74109763f, 
    0.00247211f, 0.00192262f, 0.11890004f, -0.16618109f, 0.11728780f, -0.02490230f, -0.11433219f, 0.04779392f, 
    0.17556621f, 0.46322116f, 0.43027732f, 0.30505371f, -0.22594221f, 0.12237730f, -0.03008780f, 0.38818380f, 
    0.10995837f, 0.03186380f, -0.09078868f, 0.07811511f, 0.14629911f, -0.27018514f, 0.45367938f, 0.04855096f, 
    -0.02343135f, 0.02449841f, -0.32057846f, 0.02970052f, 0.03786222f, -0.11343840f, -0.00070905f, -0.01083518f, 
    0.01555049f, -0.26267886f, -0.20791554f, -0.50479150f, -0.02536153f, -0.11760049f, -0.12516339f, -0.01504163f, 
    0.08228116f, -0.12518299f, 0.06666239f, -0.11937759f, 0.13414611f, -0.18194771f, -0.13714387f, 0.00177581f, 
    -0.07119494f, -0.01003009f, 0.25061291f, -0.21966039f, -0.00504142f, 0.17129557f, -0.27268314f, 0.03001065f, 
    -0.09429738f, -0.45100215f, 0.05603546f, -0.16551891f, -0.15487987f, -0.07102618f, -0.14092487f, -0.30455029f, 
    0.45645708f, 0.23933019f, 0.04004143f, 0.23074137f, -0.19762285f, -0.43626004f, -0.11327281f, 0.27833909f, 
    0.19079377f, -0.03310217f, 0.03264335f, 0.05525379f, 0.01297886f, -0.05234906f, 0.04536591f, -0.06635369f, 
    -0.62827605f, 0.26533294f, 0.15376526f, 0.12292710f, 0.13232565f, -0.02214464f, -0.35497683f, -0.07890112f, 
    0.07516898f, 0.07500452f, -0.18539932f, 0.12801044f, -0.33694407f, -0.04965654f, 0.21590030f, -0.33777791f, 
    0.18096013f, 0.08430189f, 0.07593345f, -0.00623622f, 0.05931995f, 0.01534123f, -0.00986075f, -0.01605698f, 
    -0.53353918f, -0.40804961f, 0.43940729f, -0.01289247f, -0.09352003f, -0.13559864f, -0.08700725f, 0.19051757f, 
    0.13045588f, 0.00805115f, 0.06092678f, 0.03532607f, 0.11555389f, -0.22464325f, 0.01795666f, 0.06614909f, 
    0.20252210f, 0.30630338f, 0.12783477f, -0.04864080f, 0.03984079f, 0.14844964f, -0.01140515f, 0.15201327f, 
    -0.00789820f, -0.03836440f, -0.01158675f, 0.01749417f, 0.05181933f, -0.18138036f, -0.07805794f, -0.31535047f, 
    0.25442261f, -0.03811156f, 0.24077074f, -0.11203837f, -0.03055476f, -0.15460274f, -0.58374017f, -0.33990878f, 
    0.04507747f, 0.15927142f, -0.12741326f, 0.17386600f, -0.03597284f, -0.28579974f, 0.12354602f, -0.10847722f, 
    -0.42722997f, -0.27677304f, 0.10627054f, -0.07123972f, -0.03180620f, -0.14094065f, 0.00222110f, -0.19321878f, 
    -0.08964563f, -0.18032244f, -0.20106961f, -0.11854951f, 0.10287014f, -0.52434814f, 0.18905634f, 0.38400850f, 
    0.09597433f, -0.07380554f, -0.26331231f, 0.05529914f, -0.01142646f, -0.05375776f, 0.09698568f, 0.20730908f, 
    -0.75108278f, 0.19637802f, -0.34158152f, -0.27722237f, 0.00728643f, 0.04703272f, 0.04584615f, 0.01904255f, 
    0.13743684f, -0.11597500f, -0.32530585f, -0.42554021f, -0.34129888f, -0.47023013f, 0.08022664f, 0.16002528f, 
    0.05692453f, -0.10808803f, 0.07102388f, 0.06850436f, 0.04211090f, -0.10064828f, -0.09107272f, -0.20090671f, 
    0.16545835f, 0.25057453f, 0.16290246f, -0.13231570f, 0.30613455f, 0.10629819f, -0.12032577f, -0.37703434f, 
    -0.01561897f, -0.04727417f, -0.03706467f, 0.04184666f, 0.26889285f, 0.07203455f, 0.43712267f, 0.01296800f, 
    0.10280649f, 0.14581931f, 0.22550736f, 0.17833367f, 0.20122561f, 0.07157312f, -0.05398325f, 0.25688070f, 
    0.42715931f, 0.05853144f, -0.05693046f, 0.40108973f, 0.28928536f, 0.30682772f, -0.03891721f, 0.12652956f, 
    -0.04344431f, -0.23120411f, 0.33809879f, -0.16987427f, 0.21577409f, -0.12801218f, -0.17128496f, -0.05404700f, 
    0.01616137f, -0.20938289f, -0.13544333f, 0.03125994f, 0.00441169f, 0.10546084f, 0.00453841f, -0.20202327f, 
    -0.18565851f, 0.17698777f, 0.03363322f, 0.75134170f, 0.15327804f, -0.35535040f, 0.12362672f, -0.03478637f, 
    -0.23646618f, -0.33404893f, -0.01520528f, -0.10264190f, -0.04400638f, 0.17210855f, -0.14436023f, -0.48934156f, 
    0.00051728f, 0.08511946f, 0.02775118f, -0.09245837f, 0.00098199f, 0.06873541f, -0.07125275f, -0.08300947f, 
    0.58976448f, 0.03334181f, -0.27744940f, 0.16573505f, -0.37901378f, 0.05499101f, 0.25822300f, 0.34186649f, 
    -0.16277446f, -0.22304040f, -0.01889906f, -0.25325868f, -1.20823336f, -1.33722150f, 0.05080927f, 0.07202775f, 
    -0.02266726f, -0.11618073f, -0.02956106f, -0.26658073f, -0.03522288f, -0.01041674f, 0.05404239f, -0.04167014f, 
    -0.50665677f, -0.29532456f, 0.53882039f, 0.05745573f, -0.12026727f, -0.14407341f, -0.05687153f, 0.14723046f, 
    -0.15569125f, 0.34388870f, 0.25345972f, -0.01844824f, -0.34039998f, -0.41890785f, -0.19251610f, -0.23240729f, 
    -0.14199612f, -0.04391595f, -0.11491930f, -0.91083658f, 0.01142331f, -0.02220153f, -0.09171335f, -0.01547350f, 
    0.06774420f, -0.13058329f, 0.03537772f, 0.03371283f, 0.02077818f, 0.04123154f, -0.12915026f, -0.19174168f, 
    0.01484025f, 0.03466158f, -0.09587976f, -0.25210759f, 0.71890187f, 0.80994850f, -0.09657273f, 0.35613722f, 
    0.00757471f, -0.11408107f, 0.19434822f, 0.11076134f, -0.01330908f, 0.21350436f, 0.15751590f, -0.00556302f, 
    0.00237396f, -0.11642331f, 0.12189583f, 0.24936403f, 0.14252768f, 0.04071010f, 0.03177761f, 0.03802569f, 
    0.18312530f, 0.34627637f, 0.35957131f, 0.01832761f, 0.36299214f, -0.15298595f, 0.04112571f, 0.32783741f, 
    -0.12603779f, 0.06431173f, 0.00955674f, 0.28311688f, -0.02231558f, 0.18199606f, -0.19778937f, -0.03690415f, 
    -0.02072053f, -0.01965016f, 0.18118425f, 0.30931324f, -0.15628465f, 0.10447711f, 0.04637200f, 0.00334540f, 
    0.12886006f, 0.08312719f, 0.47404692f, 0.18203191f, -0.59544569f, -0.35969552f, -0.48905841f, 0.43565181f, 
    0.16654137f, 0.44335705f, 0.06583537f, 0.04418573f, 0.06158247f, -0.11573023f, 0.00915565f, 0.03349710f, 
    -1.47301447f, -0.98929524f, -1.40791309f, -0.06892356f, -0.14795989f, -0.08901510f, -0.19264060f, -0.50961989f, 
    0.04223582f, -0.08872461f, 0.06735837f, 0.09214991f, -0.97518873f, -0.91400385f, -0.58685213f, 0.02255316f, 
    -0.48547632f, -0.45724034f, -0.26603863f, 0.05722567f, 0.00660577f, -0.00508611f, -0.19410570f, -0.22883907f, 
    0.31129938f, 0.24119353f, -0.38462335f, -0.48044139f, -0.32991394f, 0.13637595f, 0.03458800f, 0.15297413f, 
    -0.06380418f, 0.12175973f, -0.24141222f, -0.10454520f, 0.04186838f, 0.04791152f, -0.04930720f, -0.13394588f, 
    0.36309436f, 0.10030533f, 0.02938983f, -0.17177922f, 0.15577571f, 0.11092716f, -0.16626818f, 0.15749468f, 
    -0.11625369f, -0.00612833f, -0.19656287f, -0.20904949f, -0.07438706f, 0.23764206f, 0.11989794f, -0.05034653f, 
    -0.10906804f, 0.02466011f, -0.10870069f, -0.14017162f, 0.06890875f, -0.16787355f, 0.04134969f, -0.30459374f, 
    0.03585707f, 0.05996916f, -0.09220161f, -0.06954477f, 0.13582666f, -0.02587838f, 0.04486124f, -0.12861450f, 
    -0.29357073f, 0.01335677f, -0.04339521f, 0.10788956f, 0.13197923f, -0.00333030f, -0.00196140f, -0.03142003f, 
    0.03855993f, 0.04986930f, 0.01192761f, -0.05762919f, -0.27028829f, -0.60896581f, -0.41588819f, -0.83653814f, 
    -0.14243665f, 0.05733609f, -0.14632398f, 0.48525831f, 0.12645957f, -0.03142194f, -0.14629398f, 0.05150421f, 
    1.18336642f, -0.70055789f, -0.46481106f, -1.00124776f, 0.15975478f, -0.11011807f, -0.08283528f, -0.09029484f, 
    0.10835118f, 0.07385428f, -0.22138651f, -0.08366451f, -0.22080611f, -0.05635023f, -0.06366332f, 0.56631672f, 
    0.07747320f, -0.00439195f, 0.00672417f, -0.21081577f, -0.06455258f, 0.02530497f, 0.03808070f, 0.02607349f, 
    -0.04262768f, 0.08665185f, 0.27326858f, -0.14095218f, -0.08782065f, 0.11651789f, 0.11406576f, 0.04893563f, 
    0.03143818f, -0.06979857f, -0.09749639f, -0.03112349f, -0.75772297f, -0.38609323f, -0.16468099f, -0.11939831f, 
    -0.63349175f, -0.00060102f, 0.20930170f, -0.14248239f, -0.02183907f, 0.19573307f, 0.10221854f, -0.13374434f, 
    0.16908062f, 0.05327024f, 0.10136694f, -0.22430246f, -0.00798905f, -0.04047175f, -0.07677958f, 0.02939757f, 
    -0.22833072f, 0.03539843f, -0.06975731f, -0.11414042f, 0.37611333f, -0.05721401f, 0.37438229f, -0.43035600f, 
    -0.01107979f, 0.19356319f, -0.05496147f, 0.03045549f, -0.01099420f, -0.09737889f, -0.12761953f, -0.24992463f, 
    0.13383527f, -0.13672736f, -0.51933587f, 0.50133747f, 0.06946144f, 0.18957552f, -0.02258520f, 0.07731035f, 
    0.18733609f, 0.04044038f, 0.05689423f, 0.05502192f, 0.16456449f, -0.18934433f, -0.03755174f, -0.16730733f, 
    -0.01793237f, -0.27303314f, -0.11429704f, 0.02689751f, 0.07116415f, 0.13067923f, -0.06435630f, 0.02019518f, 
    -0.83011049f, -0.52427977f, 0.19547385f, 0.40724033f, 0.21970034f, -0.00107182f, 0.11334034f, 0.33474752f, 
    -0.12412240f, 0.05563417f, -0.10329863f, -0.08363594f, -1.45765483f, -0.95678395f, 1.12358677f, 0.20379956f, 
    -0.00873646f, -0.10906817f, 0.42363715f, 0.09352177f, -0.04975061f, 0.07685003f, -0.05464791f, -0.01006316f, 
    -0.21290146f, 0.14308062f, -0.35377344f, 0.35010973f, -0.04749799f, 0.07628021f, 0.11526769f, -0.19909252f, 
    0.06888890f, -0.19541682f, 0.03032252f, -0.05605747f, 0.01172253f, 0.05142661f, -0.10862093f, 0.03924371f, 
    -0.19727166f, -0.02617019f, -0.38081574f, 0.05271978f, 0.05140705f, 0.06216230f, -0.04946161f, -0.02123478f, 
    -0.21494350f, -0.04762080f, 0.13020748f, 0.24908428f, -0.33072078f, -0.01774666f, 0.05130238f, -0.12598562f, 
    0.17409664f, 0.06812731f, 0.33962089f, 0.16363619f, -0.56710762f, 0.38123623f, 0.16115101f, -0.12566845f, 
    -0.06915952f, -0.05696507f, -0.17705712f, -0.11594999f, -0.16073406f, -0.12257454f, 0.09741411f, 0.11441349f, 
    -0.15771140f, 0.09305765f, 0.04919119f, 0.09883222f, 0.34565690f, -0.23711610f, -0.05506289f, 0.07781302f, 
    0.03076133f, 0.02041749f, 0.33106688f, 0.23861231f, 0.09235349f, -0.65788144f, -1.30060303f, -0.10510087f, 
    0.22771427f, -0.07694075f, 0.16408561f, -0.13829449f, 0.00663129f, 0.03153240f, 0.07278266f, 0.05905022f, 
    -0.00815294f, -0.65632975f, -0.89363712f, -0.77161628f, 0.05483846f, 0.02729757f, 0.11308549f, 0.04610951f, 
    0.08194575f, -0.00549147f, 0.35320657f, 0.04342613f, 0.49910384f, -0.02334097f, -0.26301304f, -0.04254032f, 
    0.17934763f, -0.26796347f, -0.37519741f, 0.10332015f, 0.22278050f, 0.24351971f, 0.30047119f, 0.10236583f, 
    -0.35614035f, -0.15631112f, 0.03048221f, -0.11221270f, -0.16362736f, -0.15781352f, -0.06211356f, -0.10919107f, 
    0.12328935f, 0.15780370f, 0.05175266f, 0.28620467f, -0.93724406f, -0.45439878f, -0.09871653f, 0.50827116f, 
    0.06590904f, 0.24725464f, 0.36376315f, 0.01285271f, -0.03359874f, -0.20533894f, 0.02681030f, 0.00545105f, 
    0.15286666f, 0.19789751f, -0.31858024f, -0.57685435f, -0.18552896f, -0.24824020f, 0.09539337f, -0.09171315f, 
    -0.04142066f, -0.02821012f, 0.04109047f, -0.17110229f, 0.85837805f, 0.15970887f, -0.32118991f, -0.28727362f, 
    0.16047311f, -0.32074597f, -0.07116272f, -0.07216540f, 0.04568753f, 0.09672163f, 0.24701555f, 0.24412437f, 
    -0.48623237f, -0.20559904f, -0.00453322f, 0.07420055f, 0.11705112f, 0.14377694f, -0.10903966f, 0.04228615f, 
    -0.27426764f, 0.25424859f, -0.24406715f, -0.93518746f, -0.01923565f, 0.09272509f, 0.28741890f, -0.15222616f, 
    0.04549595f, -0.01403973f, 0.00098856f, -0.26675323f, -0.11539602f, -0.07343593f, -0.14216655f, -0.13772923f, 
    -0.12737623f, -0.42293301f, -0.24661265f, -0.27518997f, -0.13090368f, -0.00755819f, 0.11855003f, -0.22032656f, 
    -0.03486689f, -0.11131755f, -0.03947145f, -0.06410657f, 0.88491821f, -0.69695848f, -0.26462537f, 0.25854203f, 
    0.18277149f, -0.08502213f, -0.02609951f, -0.07466337f, 0.14557403f, 0.18809523f, 0.03375405f, 0.11762775f, 
    -0.17383836f, 0.11383209f, -0.08266538f, 0.34721848f, 0.21844822f, -0.04081549f, -0.04415552f, 0.04215150f, 
    -0.20366141f, -0.07904252f, -0.04556616f, -0.04790236f, 0.10209319f, -0.23723549f, -0.13342738f, 0.23912810f, 
    0.15786816f, 0.12066497f, 0.23095229f, 0.13698989f, -0.28092873f, -0.25580209f, -0.05055965f, 0.06766602f, 
    0.28469473f, -0.12334448f, 0.28034237f, -0.76302457f, 0.10016288f, -0.12426091f, -0.03025957f, 0.06646889f, 
    -0.29142267f, 0.10567776f, -0.04479853f, -0.14407666f, -0.04608442f, -0.57874900f, -0.64620954f, 0.35842237f, 
    0.09053060f, 0.22256739f, 0.16844425f, 0.00211135f, 0.00623226f, 0.01746606f, 0.03629457f, -0.01701470f, 
    -0.46722829f, 0.27047166f, -0.39779845f, -0.07733618f, 0.21205620f, -0.23860630f, 0.20725302f, -0.26417348f, 
    0.08674458f, -0.21945767f, 0.23361954f, 0.03064255f, -0.42963073f, -0.02036868f, -0.23047245f, -0.40670213f, 
    -0.24507731f, -0.00937670f, -0.09044030f, -0.06645943f, 0.22784966f, -0.02239075f, 0.05237305f, -0.03586417f, 
    0.25557923f, 0.13434240f, 0.80225259f, 0.60318339f, 0.03890308f, -0.13363869f, -0.33209243f, -0.32188898f, 
    -0.17255586f, -0.01845871f, -0.03716417f, 0.18612583f, 0.31882790f, 0.27199170f, -0.59085602f, -0.02847579f, 
    0.03281165f, -0.13352315f, 0.13073382f, 0.02347575f, 0.00299842f, -0.13151608f, -0.16267045f, -0.13137348f, 
    0.30471045f, -0.48571578f, 0.19418110f, -0.11410563f, 0.30647779f, 0.14242469f, -0.40167385f, 0.31362376f, 
    -0.13054559f, 0.15010417f, -0.33830282f, -0.00203314f, -0.02003640f, 0.17958508f, 1.00136364f, -0.97402656f, 
    -0.20346765f, -0.15186538f, -0.03347638f, -0.19999561f, -0.20004877f, 0.06366757f, 0.25390527f, 0.04627729f, 
    -0.19929200f, -0.09576096f, 0.05184440f, 0.41265267f, 0.02690396f, 0.07356388f, -0.10455576f, 0.02350676f, 
    0.17603678f, 0.11140706f, 0.25385189f, 0.10831933f, -0.26497009f, -0.47823465f, -0.29351938f, 0.29204565f, 
    -0.00300519f, 0.24465589f, -0.00306437f, -0.32775784f, -0.08714682f, -0.16462032f, -0.19498000f, -0.07127300f, 
    -0.36083445f, 0.31017378f, -0.14548667f, 0.12784512f, -0.18545285f, -0.04691957f, -0.05227998f, -0.07420268f, 
    -0.01417686f, 0.09395997f, 0.22439082f, 0.13381468f, 0.33249548f, -0.61248171f, -0.12920421f, -0.06215624f, 
    0.54970086f, 0.11808670f, 0.21961480f, 0.21520372f, -0.01896812f, -0.07726882f, -0.07707614f, -0.03032729f, 
    -0.30339453f, 0.09643863f, 0.29910374f, 0.09732877f, -0.19515368f, 0.16749813f, 0.23562017f, 0.16408740f, 
    0.02316619f, 0.07947997f, 0.07628633f, -0.03151935f, -0.38296413f, -0.18057528f, 0.04797759f, -0.74279284f, 
    0.25229907f, -0.49815857f, -0.08939869f, 0.07430300f, -0.09240618f, 0.01690195f, -0.01234113f, -0.19175993f, 
    -0.47851986f, 0.57992822f, -0.92553747f, 0.29937109f, 0.20570748f, -0.46658650f, 0.00012156f, -0.30252442f, 
    0.21735489f, -0.17191778f, 0.06351613f, -0.04430708f, -0.21104872f, 0.47643399f, -0.27437696f, -0.32046834f, 
    -0.12349494f, 0.07365613f, 0.19807796f, -0.22767256f, 0.18738271f, 0.22074096f, -0.21838118f, 0.15171401f, 
    0.53500313f, 0.16896190f, 0.63524967f, -0.06637905f, -0.26913843f, 0.04073988f, -0.05117572f, -0.08372927f, 
    0.33104593f, 0.12660536f, 0.16207089f, -0.03071605f, -0.47876823f, 0.22133382f, -0.65259916f, -0.40153730f, 
    -0.23544323f, -0.36336827f, -0.14952411f, 0.10785572f, -0.06748020f, 0.03842631f, 0.16835216f, -0.14829156f, 
    -0.07882929f, -0.09113102f, -0.11078680f, -0.27674356f, -0.27663457f, 0.09255988f, 0.00923109f, -0.00850836f, 
    -0.17025618f, 0.18123913f, 0.09248760f, 0.05165937f, 0.03113787f, -0.25878906f, 0.05709381f, -0.05107852f, 
    -0.15946819f, -0.17108883f, -0.06858592f, 0.17282698f, -0.13191603f, 0.24341567f, -0.03329720f, -0.06718344f, 
    -0.64793861f, 0.73643190f, -0.31968194f, -0.54297042f, -0.10221556f, 0.07816770f, -0.09040955f, 0.09766749f, 
    0.06413631f, -0.01467740f, 0.03034576f, -0.03411163f, -0.08586646f, -0.12270109f, 0.31987295f, -0.21237274f, 
    -0.31569442f, 0.16443609f, -0.02977227f, 0.05066263f, 0.15065266f, 0.28076029f, 0.27753541f, 0.11593129f, 
    -0.51825303f, 0.11054727f, -0.09851074f, 0.05320349f, -0.24100944f, 0.22054005f, -0.32277435f, -0.16276295f, 
    -0.22638294f, -0.06306785f, 0.35830027f, 0.23740898f, -0.23106433f, 0.28963575f, 0.07979210f, 0.41040429f, 
    0.22286554f, 0.04355019f, -0.10821412f, 0.36594003f, 0.00814091f, -0.13250554f, -0.16889693f, -0.17998384f, 
    -0.22444503f, 0.47881433f, -0.09273475f, -0.04973831f, -0.01910073f, 0.24243224f, -0.27510166f, -0.26232830f, 
    -0.00845092f, 0.00022676f, -0.23632415f, -0.49357924f, -0.55321503f, 0.17260285f, 0.12709852f, 0.80079693f, 
    -0.02970946f, 0.07106066f, 0.24156052f, -0.25878140f, -0.03793815f, 0.09142744f, 0.01787105f, 0.42419618f, 
    0.89121729f, -0.63283640f, 0.17399836f, -0.40109095f, 0.12613915f, -0.18380678f, 0.02396735f, 0.08893235f, 
    -0.44713855f, -0.05309656f, -0.59526646f, -0.66302776f, -0.41399157f, 0.00855423f, -0.48398525f, 0.10320900f, 
    -0.52492881f, -0.08168106f, 0.05059907f, -0.15157795f, 0.05273326f, 0.05976620f, -0.29050195f, 0.03409453f, 
    -0.26767272f, -0.06733575f, -0.61787868f, 0.17438486f, -0.02412218f, -0.25414738f, -0.24269420f, -0.01898686f, 
    0.04675108f, 0.05393010f, -0.09250420f, -0.04600615f, -0.86130434f, 0.00085859f, -0.44792181f, 0.60672718f, 
    0.00911075f, 0.34664020f, 0.07187881f, 0.57261127f, -0.03203645f, -0.03002220f, 0.31304076f, 0.31397825f, 
    0.16396734f, -0.10218831f, 0.50719208f, 0.12511103f, -0.38329348f, -0.19172786f, 0.01549048f, 0.13126257f, 
    -0.14698099f, -0.15004833f, -0.18134089f, -0.01375599f, -0.27794120f, 0.40341368f, 0.25866890f, 0.28854260f, 
    -0.04962717f, -0.41792700f, 0.00409491f, 0.14766718f, 0.02823087f, 0.18218988f, -0.07123143f, 0.10960986f, 
    -0.35413882f, -0.09463643f, -0.06133017f, 0.01068762f, 0.07867350f, 0.28752449f, 0.05107481f, 0.16297208f, 
    -0.51166874f, -0.15785670f, -0.05955474f, 0.02956759f, 0.58532137f, 0.07020158f, 0.14374746f, 0.13337520f, 
    -0.13204060f, -0.12183443f, -0.02298193f, 0.12785693f, -0.19344556f, 0.03723307f, -0.04723575f, -0.17914164f, 
    0.86772418f, -0.59308022f, 0.54467291f, -0.50919127f, 0.14701287f, -0.00553470f, -0.06163443f, 0.09039526f, 
    -0.11380468f, -0.13789642f, -0.05310939f, 0.03329462f, 0.03594656f, 0.14703551f, 0.21689714f, -0.48122096f, 
    -0.12301777f, 0.14284824f, 0.22189364f, -0.08699046f, 0.09045941f, 0.09585345f, 0.13078445f, 0.09260426f, 
    -0.82272416f, -0.07745226f, -1.18268442f, 0.48380515f, 0.26700440f, -0.28620720f, 0.03673021f, -0.13106866f, 
    -0.00663592f, 0.10535299f, 0.05667182f, -0.12850116f, 0.45895877f, 0.21229459f, -0.12968218f, -0.04291508f, 
    0.08855794f, -0.25850585f, -0.07666426f, -0.16436486f, -0.38708401f, -0.09173612f, -0.14964065f, -0.06485022f, 
    -0.26312342f, 0.41584221f, -0.63012177f, 0.12133296f, -0.22747871f, -0.11793603f, 0.66449648f, 0.27339506f, 
    -0.30449903f, -0.12884429f, -0.04729642f, -0.35813886f, -0.68967390f, 0.16891752f, 0.03871574f, 0.18915206f, 
    -0.17615414f, 0.05423214f, 0.24746086f, 0.29882318f, -0.03557276f, 0.11101904f, -0.12779973f, 0.02657959f, 
    -0.70334435f, -0.12056771f, -0.47593477f, 0.19706891f, 0.16362217f, -0.09468118f, 0.21359839f, -0.14109725f, 
    0.00260723f, 0.02622800f, 0.43364745f, 0.39614743f, 0.21071786f, -0.30846998f, 0.07650105f, 0.37960303f, 
    0.09950100f, -0.10960799f, 0.02741219f, 0.06438655f, 0.02824551f, -0.07674748f, -0.06885978f, -0.20137551f, 
    -0.26806685f, 0.20851527f, -0.16669644f, -0.80199522f, 0.01146673f, -0.02532213f, 0.21588524f, 0.04429070f, 
    0.04758684f, -0.02362071f, 0.06074075f, 0.14094074f, 0.57916355f, 0.59902823f, 0.42803198f, -0.59691048f, 
    0.04354311f, -0.09094805f, -0.05463801f, -0.07741542f, -0.12970564f, 0.04286385f, 0.23805867f, -0.05454670f, 
    -0.18208462f, -0.83472878f, -0.40830338f, -0.06148023f, -0.03095252f, -0.34171975f, -0.22069801f, -0.14056003f, 
    0.06507397f, -0.03025169f, -0.04448102f, 0.03731671f, -0.10797969f, -0.16837893f, 0.10907761f, 0.21300499f, 
    -0.19772923f, -0.17267498f, -0.44999969f, 0.25306046f, -0.10991894f, 0.05343822f, -0.04592920f, -0.47174770f, 
    0.57791877f, -0.14011104f, 0.56408674f, -0.77757478f, -0.03359238f, 0.35251665f, -0.18033844f, 0.29778713f, 
    -0.04396332f, 0.20455931f, 0.30659676f, -0.10446583f, -0.20427543f, 0.07373066f, 0.68256617f, -0.13992745f, 
    0.08349157f, -0.03554647f, 0.38409111f, -0.17475690f, 0.18663195f, -0.10157216f, -0.16637920f, -0.00357441f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.37700668f, 0.05482865f, 0.22649227f, -0.15251400f, -0.13993682f, 0.07462718f, 0.02624232f, -0.16204205f, 
    0.09092686f, 0.04244097f, -0.05539480f, -0.02043818f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
