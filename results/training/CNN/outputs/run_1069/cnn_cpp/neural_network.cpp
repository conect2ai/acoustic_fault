#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.65090746f, -0.28622481f, 0.11357815f, 0.41584635f, 0.33250272f, 0.43098921f, 0.25237426f, -0.59699273f, 
    -0.23046857f, 0.37265551f, 0.35511515f, -0.04768521f, 0.06511888f, -0.35760006f, -0.19096144f, -0.22568479f, 
    0.25156966f, -0.03084948f, 0.01390819f, 0.20048670f, 0.09007008f, -0.11840519f, 0.01303550f, -0.02967930f, 
    -0.05301403f, 0.04059725f, 0.62825501f, 0.08980443f, 0.17358220f, -0.84011149f, -0.15398672f, -0.04317197f, 
    -0.17223620f, -0.42199796f, -0.27338284f, 0.34589291f, -0.11763442f, 0.10766868f, -0.08309793f, -0.11740862f, 
    0.09272835f, 0.31109357f, 0.23470636f, -0.06771396f, -0.04661366f, -0.04953941f, -0.06050073f, 0.00871890f, 
    -0.20943843f, 0.23824255f, -0.14532377f, -0.01248613f, 0.18714076f, 0.13941403f, 0.23579368f, 0.03358854f, 
    0.00191286f, -0.09446664f, -0.04715142f, 0.13758081f, -0.01207034f, -0.07205494f, -0.10778541f, 0.00355338f, 
    0.13451333f, -0.05941879f, -0.10461465f, -0.03418603f, 0.23008958f, -0.09832308f, 0.13009050f, -0.26381105f, 
    -0.35497135f, 0.22656421f, 0.05633219f, 0.36127335f, -0.59061295f, -0.71870935f, -0.36882579f, -0.61457008f, 
    0.83703488f, -0.24660712f, 0.38234863f, 0.34959751f, 0.39218888f, -0.16853377f, 0.02509943f, -0.09020437f, 
    -0.10476190f, 0.28766462f, -0.33939385f, -0.12743093f, 0.33577010f, 0.18165922f, -0.17762561f, 0.20315513f, 
    -0.17313512f, 0.26569504f, 0.04202774f, -0.04541724f, 0.15527053f, -0.50275707f, 0.09236947f, 0.10088913f, 
    -0.39765203f, -0.47219753f, -0.66443735f, -0.76053929f, -0.56144851f, -0.24379776f, 0.22564240f, 0.39006281f, 
    0.36663535f, 0.36319986f, 0.29869360f, -0.32461441f, -0.18360730f, -0.02704055f, -0.28509310f, -0.18317001f, 
    0.10180194f, -0.22947221f, -0.13419096f, 0.07566030f, -0.08719407f, 0.14346990f, -0.06633130f, -0.93872088f, 
    -0.48652589f, 0.21001901f, 0.38276675f, 0.53740990f, -0.02119073f, 0.21688557f, -0.63857633f, 0.36480817f, 
    0.40293008f, -0.25130633f, 0.11525238f, -0.32146299f, -0.24776952f, -0.34649578f, 0.14313252f, 0.29158184f, 
    -0.09327557f, 0.10244140f, -0.12576155f, 0.22796662f, 0.01325055f, -0.08975694f, 0.67782801f, 0.44056377f, 
    -0.07959524f, 0.08822984f, -0.35412738f, 0.05824723f, 0.31343079f, 0.44207150f, -0.37069985f, 0.13527375f, 
    -0.19634689f, -0.18846928f, 0.03830910f, 0.18381256f, -0.34925595f, 0.36321554f, 0.00194341f, -0.13660698f, 
    -0.12277256f, -0.25188842f, -0.17469767f, 0.12696271f, 0.24843642f, 0.22411783f, -0.08979541f, -0.80607021f, 
    0.03524033f, 0.02676176f, -0.07397410f, 0.06757093f, -0.05891346f, -0.09718733f, -0.28042579f, 0.12136719f, 
    0.32805118f, -0.01939937f, 0.40161332f, -0.36264488f, 0.15809512f, -0.08070986f, -0.42740613f, 0.05849399f, 
    -0.10847253f, -0.31948429f, -0.24344355f, -0.10341378f, 0.29263070f, 0.09829776f, 0.35922369f, 0.03870242f, 
    -0.38409454f, 0.31456560f, 0.39825115f, 0.17991757f, 0.26326761f, -0.56577110f, -0.52379566f, -0.17620724f, 
    -0.13969903f, 0.14053875f, -0.20174530f, 0.06247898f, -0.32838085f, 0.21357684f, 0.09253966f, 0.05806392f, 
    -0.22630163f, -0.22231919f, -0.16257913f, 0.16661485f, -0.12644313f, -0.08309783f, -0.28614086f, -0.14733563f, 
    -0.26410097f, -0.40282792f, -0.21932366f, 0.07520805f, 0.53942603f, -0.33401784f, -0.27813828f, -0.22612818f, 
    0.28338966f, 0.38027516f, 0.22532973f, -0.24075201f, 0.37724531f, -0.47453982f, 0.33396304f, -0.23242220f, 
    -0.12024761f, -0.18724968f, 0.14445405f, 0.01277962f, 0.13883542f, -0.05394844f, 0.24751672f, -0.14947055f, 
    -0.08313599f, 0.34092736f, 0.24724574f, 0.63937515f, -0.23419948f, 0.24789876f, 0.26527318f, -0.64331347f, 
    -0.72613060f, -0.21195598f, 0.46064109f, 0.33082992f, -0.03807649f, -0.14653225f, 0.06664377f, -0.18095969f, 
    -0.42487100f, 0.37597898f, -0.06137397f, 0.40930498f, -0.23918614f, -0.15314755f, -0.16732119f, 0.15750498f, 
    -0.00635175f, 0.23548423f, -0.07626908f, -0.58083987f, 0.47095883f, 0.20603909f, 0.58611733f, -0.49587935f, 
    -0.19532399f, -0.48076096f, -0.34738794f, 0.17934993f, 0.50373876f, 0.32593256f, -0.28155416f, -0.11941618f, 
    -0.08605240f, -0.20131558f, 0.11234485f, 0.24395807f, 0.10941866f, 0.04435137f, -0.28419936f, -0.05143982f, 
    -0.24310148f, 0.21899998f, -0.02957889f, 0.13803521f, 0.34643352f, 0.66351640f, 0.30937859f, -0.23988779f, 
    -0.64224070f, -0.06295760f, -0.20438194f, -0.17082463f, 0.12560315f, 0.03170255f, 0.30451044f, -0.44974205f, 
    -0.12705199f, -0.20354915f, 0.08015120f, -0.34725004f, 0.08413734f, 0.00912475f, 0.07368261f, -0.15045457f, 
    -0.21933442f, -0.15831518f, -0.38939112f, -0.40991411f, -0.39228195f, -0.30247915f, 0.50227183f, 0.59253353f, 
    -0.22943421f, -0.36481488f, 0.24964119f, -0.12896408f, -0.24359065f, 0.70645630f, -0.46453363f, -0.14898299f, 
    -0.12788036f, 0.28269759f, -0.20709562f, -0.06848057f, 0.08598190f, -0.20563608f, -0.14847271f, -0.04262623f, 
    0.47609952f, -0.06423368f, 0.14528954f, -0.10221860f, -0.02834445f, -0.18590285f, -0.14814015f, -0.53162611f, 
    0.42874259f, 0.37367681f, -0.04180409f, 0.12746865f, -0.25554687f, 0.18485132f, -0.06892908f, 0.09043012f, 
    -0.19921254f, -0.25855362f, 0.10040506f, 0.36100373f, -0.34598154f, -0.01519999f, -0.21094552f, -0.01541572f, 
    0.61797881f, -0.22809644f, -0.14247085f, 0.17218977f, -0.32376531f, -0.19794492f, -0.34239015f, -0.05805122f, 
    -0.56604606f, -0.49255800f, -0.27183911f, -0.24260250f, 0.32024643f, 0.25976598f, 0.64669681f, -0.50718743f, 
    -0.18990101f, -0.07687359f, -0.15379634f, -0.02808435f, -0.40141559f, 0.24001354f, 0.29106402f, 0.23517817f, 
    0.19082905f, 0.28873098f, -0.22443032f, -0.13957855f, -0.01090481f, -0.29303041f, -0.04080547f, 0.41568503f, 
    0.36137483f, 0.59177685f, 0.48273537f, -0.11566993f, 0.07319528f, -0.35454074f, -0.46436894f, -0.13033405f, 
    -0.12373828f, -0.20182149f, 0.08551947f, 0.00476560f, 0.32681727f, -0.28467011f, 0.12642005f, -0.11443307f, 
    0.08068755f, 0.12988780f, -0.00815613f, 0.13889235f, -0.09816965f, -0.02784204f, 0.06932961f, 0.04295652f, 
    -0.00819943f, -0.55361623f, 0.03252212f, 0.21729542f, 0.60143912f, -0.52872050f, 0.08402129f, -0.29953051f, 
    -0.39597869f, -0.23483463f, 0.10701019f, 0.37925437f, 0.09399795f, 0.27755585f, -0.15970832f, -0.02369811f, 
    -0.26874769f, 0.12388579f, 0.08461622f, -0.06961679f, -0.09072362f, 0.00427223f, -0.23581642f, 0.14955203f, 
    0.32492346f, 0.27417791f, -1.03056276f, 0.32979757f, -0.64842290f, -0.56147724f, -0.27012637f, 0.30292192f, 
    0.45123646f, 0.26010364f, 0.19482610f, -0.02190196f, 0.37525165f, 0.29981250f, 0.28308228f, 0.04360724f, 
    0.00513395f, -0.04453938f, -0.15241419f, 0.18039192f, -0.12226155f, -0.13790087f, 0.04610207f, 0.10082991f, 
    -0.00686608f, -0.20567644f, 0.12314229f, -0.27655169f, 0.31648052f, -0.14535677f, -0.75180477f, -0.09268623f, 
    0.05698613f, 0.26044697f, 0.25745526f, 0.06020477f, 0.23771058f, -0.34090793f, -0.46857196f, -0.06561670f, 
    -0.34697786f, 0.47686312f, 0.27333239f, -0.00693473f, -0.25520021f, -0.04790140f, -0.06023623f, -0.11420244f, 
    -0.17583665f, -0.21775658f, -0.32940573f, -0.52307457f, 0.09859108f, 0.26268128f, 0.25403538f, 0.19521414f, 
    -0.25297722f, -0.10864869f, 0.21373491f, -0.05478843f, 0.19181302f, 0.17948924f, 0.26024792f, 0.02041237f, 
    -0.10812330f, -0.01559558f, -0.05133201f, 0.03677092f, 0.00951343f, -0.31844079f, 0.01070134f, 0.13044731f, 
    0.21990108f, 0.08740941f, 0.09019320f, -0.23258263f, 0.20522159f, -0.71986192f, -0.68217254f, 0.08104578f, 
    -0.07310252f, -0.04885085f, 0.75038707f, -0.11035039f, 0.37657642f, -0.22608015f, 0.76341492f, 0.26067001f, 
    -0.22821465f, -0.09193752f, -0.05595459f, -0.01039524f, -0.04653832f, -0.02588123f, -0.05539249f, 0.05624880f, 
    -0.09152785f, 0.17521918f, 0.12203152f, 0.18788253f, -0.09054893f, -0.17603162f, -0.12483007f, -0.27271977f, 
    0.29519096f, -0.58990598f, -0.31495413f, -0.10620907f, -0.10390611f, -0.35146588f, -0.02244516f, 0.04416190f, 
    0.27977285f, 0.13594493f, -0.00949136f, 0.09605889f, 0.28555986f, -0.25593442f, 0.15474367f, -0.05142415f, 
    -0.19273598f, -0.34621781f, 0.12383359f, -0.27246013f, -0.17778459f, -0.27129298f, -0.05497891f, -0.46057761f, 
    -0.03773227f, 0.44467053f, 0.07304790f, 0.14700660f, 0.16775326f, 0.31654111f, -0.31597158f, -0.21137945f, 
    -0.18636365f, -0.04935715f, 0.31502539f, -0.13908240f, -0.26766837f, 0.35514808f, -0.27352366f, 0.13185444f, 
    -0.05962498f, 0.06949448f, 0.04385868f, 0.04251411f, 0.18463743f, 0.21892753f, -0.28220460f, 0.12246887f, 
    0.07762673f, -0.38281929f, 0.23074923f, 0.02627101f, 0.26416916f, 0.02923048f, -0.12281770f, 0.18081307f, 
    0.31588691f, 0.27532914f, 0.11522027f, 0.07670536f, -0.20607398f, 0.21417318f, -0.03891983f, -0.19016373f, 
    0.19024557f, -0.03539882f, 0.04454787f, -0.32955495f, 0.08994815f, -0.15724581f, 0.15606976f, -0.03369061f, 
    0.19450662f, -0.95511836f, -0.68992895f, -0.48758993f, 0.00424898f, 0.31496170f, -0.22245049f, -0.54887033f, 
    -0.10351704f, -0.02843795f, 0.39193869f, 0.05869762f, 0.33975628f, 0.52422655f, 0.40774485f, 0.11593147f, 
    -0.09263382f, -0.22500190f, -0.19416274f, 0.09915335f, 0.17996261f, 0.02119612f, 0.18907581f, 0.14095844f, 
    0.03941343f, 0.01840341f, 0.00793842f, -0.11454555f, -0.11100046f, 0.15329179f, 0.29397488f, -0.17518911f, 
    -0.50659007f, 0.01352341f, 0.53008658f, 0.00030176f, 0.50062400f, -0.11421227f, -0.22293548f, -0.20305227f, 
    -0.31228775f, 0.38110718f, 0.37391463f, -0.03327158f, -0.14968283f, -0.48107344f, -0.01155088f, 0.19129018f, 
    -0.16613247f, -0.14891529f, -0.40227580f, 0.71482050f, -0.07289844f, 0.19400592f, -0.29030484f, 0.33317986f, 
    -0.20762390f, 0.48334309f, 0.26437432f, -0.41116986f, -0.37814090f, -0.41076025f, 0.10919977f, 0.06437939f, 
    -0.20717010f, 0.09645779f, -0.01862236f, -0.16183417f, 0.37207106f, -0.08144571f, 0.00121960f, 0.16857626f, 
    -0.19498892f, -0.21182528f, -0.19903843f, -0.31794363f, 0.10344066f, 0.17517185f, 0.08751576f, 0.39286223f, 
    -0.03641536f, 0.02909144f, 0.11353308f, 0.23844703f, -0.02198664f, -0.03309656f, 0.09761390f, 0.12231087f, 
    -0.03318650f, -0.17680660f, -0.12727346f, 0.19735689f, 0.01913362f, -0.22643657f, 0.12961540f, -0.08599121f, 
    -0.14801356f, -0.00246324f, -0.19163711f, -0.13753223f, -0.39998206f, -0.00988354f, -0.46065417f, 0.47464603f, 
    0.70431262f, -0.73516327f, -0.17998447f, -0.43646112f, -0.20985734f, -0.05894376f, -0.16591536f, 0.23846568f, 
    -0.14827621f, 0.38503093f, 0.10579475f, 0.18633400f, -0.11239009f, 0.18642230f, -0.04993845f, -0.13340399f, 
    -0.13475244f, 0.04825641f, 0.22266929f, -0.01666667f, -0.18588632f, 0.17122313f, -1.11812639f, -0.76598692f, 
    0.43267736f, 0.21940883f, 0.04318310f, 0.20067318f, 0.37131310f, -0.12580362f, 0.20317721f, 0.15643668f, 
    -0.13279872f, -0.42885450f, -0.27596465f, 0.20519395f, -0.13239032f, 0.11740419f, 0.25802445f, -0.12573928f, 
    -0.13122198f, -0.02053517f, -0.13350791f, -0.31148827f, 0.00433846f, -0.04325449f, -0.25666377f, 0.24033010f, 
    -0.22741471f, -0.00456711f, 0.05648030f, 0.02712584f, 0.15048096f, -0.05953084f, -0.27459556f, -0.01654507f, 
    -0.00821330f, 0.47151908f, -0.56029505f, -0.33580163f, 0.12125726f, 0.31203818f, -0.18030396f, -0.20018686f, 
    0.01460410f, 0.12687093f, 0.22221778f, 0.15303411f, 0.08695611f, -0.29252318f, -0.02036728f, 0.04315361f, 
    -0.63697624f, -0.38792726f, -0.42432079f, -0.41198763f, -0.41479909f, -0.04421339f, -0.38956565f, -0.03451766f, 
    0.05158570f, 0.00649862f, -0.44773123f, -0.35465065f, -0.03328458f, -0.35384881f, -0.29367965f, 0.02055994f, 
    -0.18444076f, -0.21683790f, 0.18555239f, -0.00179724f, 0.06288089f, -0.10829346f, -0.29232579f, -0.16373073f, 
    -0.00775444f, -0.59238678f, -0.23010573f, -0.27590984f, 0.29091513f, 0.26692024f, -0.36047396f, 0.26775691f, 
    0.04061180f, 0.40008810f, 0.51486421f, -0.10154874f, -0.22222634f, -0.34966341f, 0.30152652f, 0.07932265f, 
    -0.12119907f, -0.21833888f, -0.01817523f, 0.26128611f, -0.30745423f, 0.20964114f, 0.11869382f, 0.34494388f, 
    -0.05261908f, 0.07383512f, -0.26111630f, -0.20661525f, -0.40194452f, -0.45870018f, -0.26605642f, -0.04550648f, 
    -0.19894995f, -0.03873090f, 0.05279162f, -0.43940321f, 0.13381638f, 0.06709161f, 0.21363631f, -0.09138308f, 
    -0.23928833f, -0.16565269f, -0.25101373f, 0.05529466f, 0.13234334f, -0.08130715f, 0.33308458f, 0.44133252f, 
    0.17808591f, 0.17623267f, 0.27636534f, 0.80943370f, -0.48018101f, -0.04547210f, -0.36227307f, -0.73577738f, 
    0.62738311f, -0.06832421f, -0.06368379f, 0.25983801f, 0.10243904f, 0.28890783f, 0.09872019f, -0.18124102f, 
    -0.10784239f, -0.28086257f, 0.03927096f, -0.13492905f, -0.03975968f, 0.03031614f, 0.12932658f, 0.28161836f, 
    -0.05575714f, -0.16893238f, 0.20007777f, -0.13655928f, 0.80802268f, -0.35240856f, -0.35055166f, -0.51036823f, 
    -0.62616509f, 0.45761457f, 0.40938497f, 0.05599003f, -0.09337863f, 0.30810755f, -0.13884416f, -0.10767801f, 
    -0.21559523f, 0.16154958f, 0.03867889f, -0.15325889f, 0.09182742f, 0.12234138f, 0.25497189f, -0.31121749f, 
    -0.22550629f, 0.08832147f, -0.07423577f, 0.10515960f, 0.23311864f, 0.28829795f, 0.40971115f, 0.40343115f, 
    -0.04500087f, 0.02700704f, 0.11843103f, -0.14700131f, 0.15173669f, 0.18173397f, 0.04483850f, 0.15015186f, 
    -0.26185399f, 0.20382543f, -0.20262766f, -0.22915867f, 0.08532839f, 0.20136729f, 0.04712280f, -0.06289276f, 
    -0.05085020f, -0.24276993f, -0.27233604f, -0.21706785f, -0.11142896f, -0.06277461f, -0.03594042f, -0.85928446f, 
    -0.11885240f, 0.04593696f, 0.26638368f, -0.44584802f, -0.29403612f, 0.04154712f, -0.07485829f, -0.49557996f, 
    -0.32848251f, -0.44011039f, 0.30690029f, -0.30013013f, -0.08404427f, -0.28954691f, -0.05379555f, -0.07429061f, 
    -0.32295945f, -0.42955220f, 0.07198748f, 0.17701221f, -0.08766840f, -0.12760982f, -0.09548801f, 0.06827712f, 
    -0.31700483f, -0.16377844f, 0.14777969f, 0.39657447f, 0.32791206f, -0.49099764f, -0.12315068f, 0.63596171f, 
    -0.01604440f, 0.02525538f, 0.37716696f, -0.28544304f, -0.19078229f, -0.11771067f, -0.34766877f, -0.04158496f, 
    -0.16079263f, 0.02800487f, 0.25595126f, -0.21337891f, 0.16582930f, -0.01912572f, 0.00978862f, 0.08299360f, 
    -0.16648018f, 0.69805789f, 0.46321878f, -0.44030911f, -0.16845848f, -0.32491973f, -0.36854786f, -0.02833379f, 
    -0.03487551f, 0.04120243f, -0.13918194f, 0.14303014f, 0.26934689f, 0.32504359f, -0.17955220f, 0.12490428f, 
    0.16490665f, -0.05881524f, 0.28645116f, -0.08167425f, 0.13909614f, -0.12150998f, -0.45852065f, -0.32754135f, 
    -0.24006306f, -0.01271775f, 0.04519572f, 0.24769801f, 0.16321573f, 0.25872824f, 0.19544676f, 0.31546843f, 
    0.15614244f, -0.12846045f, 0.02985397f, -0.32550335f, 0.25902838f, 0.30214888f, 0.03389021f, -0.19563922f, 
    0.15510982f, -0.24805470f, -0.21658914f, -0.13976038f, -0.10859974f, -0.21567293f, 0.36290756f, -0.11341329f, 
    -0.24522093f, 0.27004570f, 0.01771939f, -0.13162057f, -0.12391935f, -0.05115763f, 0.29118854f, 0.20087512f, 
    -0.34526563f, -0.57899016f, -0.35829684f, -0.36226290f, -0.01613485f, -0.10620203f, 0.15448640f, -0.25273094f, 
    -0.24741331f, 0.36342272f, 0.08764928f, 0.33371142f, -0.40156567f, -0.13692759f, -0.17814866f, -0.12551738f, 
    0.04312851f, -0.08298437f, -0.13793200f, 0.03473458f, -0.13592295f, -0.50130528f, -0.53105742f, -0.28175840f, 
    -0.30868030f, -0.35977268f, -0.21466891f, -0.33958137f, -0.46750894f, -0.06995296f, -0.29720199f, 0.09613770f, 
    -0.22560129f, -0.05959462f, -0.10341716f, -0.56921601f, -0.13265853f, -0.44706035f, -0.29429302f, 0.09369207f, 
    0.34147304f, 0.22184257f, 0.24537037f, 0.29667667f, -0.05844544f, -0.61889267f, -0.74909866f, -0.55441344f, 
    -0.41053548f, -0.20663613f, -0.06295600f, 0.23459888f, 0.03146428f, 0.14843027f, 0.10268573f, 0.16961934f, 
    0.11694919f, 0.28923935f, -0.10794976f, 0.04382494f, 0.15396217f, -0.17944548f, 0.01877090f, -0.07317383f, 
    -0.30890563f, -0.30880216f, 0.20515101f, -0.27367672f, -0.31371915f, -0.68290001f, -0.46601188f, -0.35293469f, 
    -0.37431031f, -0.44502401f, -0.12709264f, -0.04864160f, 0.00801784f, 0.12741621f, 0.06921854f, 0.05542068f, 
    -0.12333440f, -0.13162421f, -0.04722864f, -0.07823318f, 0.06311679f, -0.02487568f, 0.14507028f, -0.36600527f, 
    -0.24028957f, -0.03052593f, 0.49269274f, 0.14197110f, 0.05319895f, -0.22042744f, 0.25766301f, 0.45888135f, 
    0.65051627f, -0.13252416f, -0.35856321f, -0.68319833f, -0.24722327f, 0.23809840f, 0.33129856f, -0.06091978f, 
    0.17394786f, 0.11132794f, -0.20939232f, 0.48990938f, -0.13058455f, 0.16533060f, 0.10496654f, -0.27931935f, 
    -0.34547296f, -0.14847036f, -0.19054563f, 0.06333920f, -0.00975853f, -0.09035068f, 0.24119709f, -0.54944956f, 
    -0.23731239f, 0.01124847f, 0.30141076f, 0.47844195f, 0.26056165f, 0.01069668f, 0.09682510f, 0.11481787f, 
    -0.05640544f, -0.03516782f, 0.08157235f, -0.00381806f, -0.24624698f, 0.24438892f, 0.10687995f, -0.18880841f, 
    0.10654740f, -0.23399039f, -0.25386542f, -0.21370061f, 0.14923978f, 0.14526594f, 0.10896014f, 0.36481225f, 
    -0.77886564f, -1.00806093f, 0.16021162f, 0.85219383f, 0.16559720f, 0.00228074f, 0.11560944f, -0.41609797f, 
    -0.66232729f, -0.51648617f, -0.03289954f, -0.08541671f, 0.10190390f, -0.41640446f, -0.16863056f, -0.07795899f, 
    -0.37744257f, -0.32009175f, 0.22978708f, 0.07181002f, 0.05702296f, -0.08090084f, -0.20367691f, -0.14686051f, 
    0.08534646f, 0.50806016f, -0.79803073f, -0.60805064f, 0.15090334f, 0.12795983f, -0.10741153f, 0.51430130f, 
    0.32158595f, -0.30336469f, -0.46508786f, -0.43045425f, -0.30371207f, -0.31684089f, -0.14086626f, 0.50954616f, 
    0.05379878f, -0.04538936f, 0.18903825f, 0.01340777f, -0.19283049f, 0.13683031f, -0.25467527f, -0.06416208f, 
    -0.10008764f, -0.24579881f, 0.14321043f, 0.08662846f, -0.03887084f, 0.05434394f, -0.11730950f, 0.02604606f, 
    -0.20128827f, 0.10675138f, -0.24670255f, -0.30634171f, -0.19027914f, 0.22021219f, -0.12677898f, 0.22306046f, 
    0.00726663f, -0.09396230f, 0.08007263f, 0.10609873f, 0.25124189f, -0.47680968f, -0.09116874f, -0.03482575f, 
    0.10227638f, 0.31708607f, 0.32753637f, -1.28237092f, -0.05625774f, -0.10521314f, -0.87767851f, -0.34894904f, 
    0.17600371f, 0.23423424f, 0.26684576f, 0.77537060f, 0.55594051f, -0.01827926f, 0.20859553f, -0.04232565f, 
    0.08296551f, -0.25699645f, -0.08161818f, -0.01111700f, 0.05987200f, 0.34584945f, 0.02295760f, -0.09678788f, 
    -0.01794689f, 0.13500988f, -0.13207750f, -0.21857853f, 0.54586309f, 0.04215299f, -0.27832386f, -0.10676721f, 
    -0.28520086f, 0.41833472f, -0.24920702f, -0.10260356f, -0.19161813f, 0.29590529f, -0.32609072f, 0.26546571f, 
    -0.25137824f, 0.02907960f, 0.26794776f, -0.20303203f, 0.15713967f, 0.31476033f, -0.17439762f, -0.19431020f, 
    0.19116911f, -0.08958475f, -0.10800841f, 0.08343357f, -0.02593069f, -0.18990074f, -0.50875843f, -0.59650218f, 
    -0.23719265f, -0.57426304f, -0.17515680f, 0.02024947f, -0.11596795f, -0.17947572f, -0.27377722f, -0.09170256f, 
    -0.10856276f, -0.17299478f, 0.07377861f, -0.03839906f, -0.06076162f, -0.20559500f, -0.13509984f, -0.14301477f, 
    -0.38408372f, -0.25986594f, -0.31975961f, -0.20926179f, 0.17989019f, -0.16196980f, 0.30427918f, -0.40435010f, 
    0.03708555f, 0.08702818f, 0.11535461f, 0.55184406f, -0.15593980f, -0.33400166f, -0.03443276f, 0.06526680f, 
    0.13204375f, 0.11067139f, 0.10030162f, -0.40613452f, -0.40982392f, 0.30287275f, 0.06563565f, 0.05563438f, 
    0.22584137f, 0.11996699f, -0.05351434f, -0.28594321f, -0.10343972f, -0.18177220f, -0.30791104f, -0.61372715f, 
    -0.78842396f, -0.06353555f, 0.66855681f, 0.67435247f, -0.39955929f, -0.13386552f, -0.17674980f, -0.31581911f, 
    -0.31267607f, -0.08444539f, -0.25815594f, 0.01915784f, 0.50309938f, -0.37513381f, -0.05652628f, -0.13351442f, 
    0.15864649f, -0.10643128f, 0.15861109f, 0.11810647f, -0.21583800f, -0.16638565f, 0.24140395f, 0.24252619f, 
    0.09559140f, -0.18214160f, -0.11162186f, 0.09036603f, -0.84777814f, -0.54529089f, -0.07768235f, -0.58001328f, 
    -0.53473932f, -0.53162158f, 0.20762518f, -0.01500678f, -0.07172155f, -0.28550273f, -0.25072914f, -0.25929263f, 
    0.03982632f, -0.05050092f, 0.08886910f, -0.01442260f, 0.02029865f, -0.05754143f, -0.22547850f, 0.07369179f, 
    -0.26763225f, 0.46497828f, 0.61709642f, -0.50988996f, -0.74165642f, -0.82350647f, -0.30612198f, -0.34424087f, 
    0.38875139f, 0.53855902f, 0.36492848f, 0.27246225f, -0.08852197f, 0.02018715f, 0.24171568f, -0.17727481f, 
    0.09411801f, -0.11776403f, -0.20326079f, -0.22408506f, 0.04418547f, 0.02607838f, 0.07808800f, -0.09438635f, 
    -0.13415182f, 0.42711061f, 0.03636869f, -0.10490992f, 0.35389978f, 0.23574807f, -0.07272686f, -0.26222873f, 
    0.10542744f, 0.37548953f, -0.12569220f, -0.37023300f, -0.21325965f, 0.24846062f, 0.15501243f, -0.15486079f, 
    0.21746187f, -0.32398316f, 0.16770752f, 0.02249403f, 0.04273144f, -0.11039449f, 0.03363893f, 0.29687372f, 
    -0.06576333f, -0.29197535f, -0.31341586f, -0.03193100f, -0.09616634f, 0.36331376f, 0.49740079f, -0.40753683f, 
    -0.17100503f, -0.31046993f, 0.02507247f, -0.04578707f, -0.41053599f, -0.15038158f, -0.02834180f, 0.02234632f, 
    -0.10185108f, -0.04421111f, 0.01593564f, -0.06410079f, 0.12433119f, 0.05556270f, 0.09434039f, 0.12216213f, 
    0.19328162f, 0.16193920f, -0.16392514f, -0.27790502f, -0.96658611f, -0.01900980f, 0.26865718f, 0.63659662f, 
    0.36466622f, -0.74920630f, -0.57712245f, 0.80185860f, -0.04118404f, 0.03341250f, 0.05426316f, 0.11311831f, 
    0.04546631f, -0.05069185f, 0.06362845f, 0.07164272f, 0.17225794f, 0.02791390f, -0.26270190f, -0.10481102f, 
    0.05004939f, -0.10482569f, 0.02802847f, 0.29464197f, -0.13596149f, -0.12289889f, 0.26418510f, -0.14249076f, 
    -0.41506639f, -0.46707028f, -0.11585625f, -0.21563096f, -0.25764585f, -0.30496633f, 0.09371370f, -0.23204236f, 
    -0.08680703f, -0.02844296f, 0.06334330f, 0.38617957f, 0.20381945f, -0.03758276f, -0.00851657f, -0.14641100f, 
    -0.30509791f, -0.09577164f, -0.31486806f, -0.23809771f, -0.18069647f, -0.41269663f, 0.28241068f, 0.36549965f, 
    -0.50468463f, -0.35460609f, 0.36764604f, -0.02688031f, 0.49723053f, 0.16318457f, -0.48090911f, -0.38069692f, 
    0.09334210f, 0.06818355f, 0.04378202f, -0.03014847f, 0.13022788f, 0.08109197f, -0.07414743f, -0.18195429f, 
    -0.39954579f, 0.23589997f, -0.22469419f, 0.18358585f, 0.10047937f, 0.27438614f, 0.08938848f, -0.01721160f, 
    0.06264311f, -0.01422588f, -0.04244614f, -0.00593871f, 0.20771492f, 0.25408611f, 0.30374017f, 0.29306453f, 
    0.31415629f, 0.16501376f, -0.05542035f, 0.01348850f, 0.21200798f, 0.16512144f, -0.01432496f, 0.10054797f, 
    0.02276075f, -0.01532841f, 0.26864296f, -0.09257662f, -0.05854502f, 0.26244721f, 0.06040940f, -0.24666224f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.26229331f, 0.22690444f, 0.07779145f, 0.12690872f, -0.13292132f, 0.07532672f, 0.21904619f, 0.29350501f, 
    0.10427748f, -0.01526257f, 0.21930364f, 0.14967090f, 0.14969726f, 0.07565324f, -0.13575053f, 0.26877069f, 
    0.16070446f, 0.01001256f, 0.07008548f, 0.07813394f, -0.21850331f, -0.01861145f, 0.16180907f, 0.09841453f, 
    0.24555518f, -0.00504578f, 0.18812934f, -0.01032069f, 0.05336439f, -0.01730486f, 0.11029213f, 0.38411814f, 
    0.00836088f, 0.24948770f, -0.20417804f, 0.27745363f, 0.30064663f, -0.26308003f, -0.03596031f, 0.38689494f, 
    -0.19106969f, 0.12001045f, -0.28171283f, 0.05317708f, -0.22448941f, 0.01348663f, 0.29778042f, 0.14987524f, 
    -0.07512097f, 0.22932604f, -0.04392520f, -0.04744189f, 0.37816122f, -0.02270496f, -0.07219538f, 0.26629186f, 
    -0.24511842f, 0.17346740f, -0.10265837f, -0.02528701f, 0.14522552f, -0.15510900f, 0.11528189f, -0.29272684f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.32988256f, 0.00865136f, -0.19098349f, 0.12405616f, 0.16279772f, 0.15202010f, -0.04548667f, -0.10279556f, 
    -0.02246644f, 0.07944840f, -0.07053533f, 0.02906032f, 0.06050830f, 0.16519336f, 0.17167704f, 0.06611632f, 
    -0.01206214f, -0.06813744f, 0.03561936f, -0.06913635f, 0.01597655f, -0.08980805f, -0.08937776f, -0.09906463f, 
    0.02957088f, 0.01367632f, -0.07357303f, -0.02842690f, 0.00259804f, -0.04170618f, 0.04416778f, -0.05425973f, 
    0.06000684f, 0.02955869f, -0.07918572f, 0.01866681f, 0.02842234f, 0.09644088f, 0.06103817f, 0.04856328f, 
    0.00262460f, 0.02389789f, 0.15475932f, 0.04321180f, 0.04050120f, -0.12202846f, -0.01347274f, -0.01324309f, 
    -0.07849579f, -0.09593623f, 0.17611687f, 0.26976225f, -0.00432445f, -0.06212127f, 0.09436324f, 0.05139504f, 
    0.04345534f, -0.06628222f, -0.01221982f, 0.05974236f, -0.25083816f, -0.00280320f, 0.20254362f, 0.04132409f, 
    -0.08386505f, 0.15440036f, -0.09267937f, 0.01260169f, 0.05464024f, 0.13676140f, 0.24260265f, -0.02632293f, 
    0.32538736f, -0.04913367f, -0.02936288f, -0.18102589f, 0.01674670f, -0.03288697f, -0.03064317f, -0.01463824f, 
    0.01617830f, -0.05024236f, 0.08819506f, -0.16194510f, -0.10638906f, -0.03976051f, -0.19558510f, 0.20425484f, 
    0.03362595f, -0.06522173f, -0.04712867f, 0.02961843f, -0.00734233f, -0.01978623f, 0.03068002f, -0.12215438f, 
    0.25170940f, -0.13836892f, -0.06902623f, 0.07845131f, -0.00945447f, 0.02164031f, 0.07282562f, 0.01496093f, 
    0.01333862f, -0.02398392f, 0.09828123f, 0.09227177f, 0.12051133f, -0.25380206f, -0.18897039f, 0.11072662f, 
    0.17672180f, -0.14387128f, 0.00349298f, 0.01633124f, 0.06688527f, 0.05215247f, -0.08398117f, 0.01668737f, 
    0.39989713f, -0.30941689f, 0.06312528f, 0.02492446f, -0.08170427f, -0.04808706f, -0.10359925f, 0.10564186f, 
    -0.02289415f, 0.05875335f, -0.00426822f, -0.14148960f, 0.01954048f, -0.10890905f, -0.07415754f, 0.27294978f, 
    -0.07275325f, -0.14401807f, 0.05918908f, -0.14315797f, -0.01338695f, 0.06013886f, 0.01252575f, -0.10340955f, 
    0.20941719f, 0.05557565f, 0.09457475f, 0.02437739f, -0.07498077f, -0.03889661f, -0.01115217f, -0.05501998f, 
    0.07104175f, 0.02572389f, 0.04506823f, 0.03164178f, 0.35608128f, -0.22299902f, 0.17849097f, -0.07408094f, 
    -0.03504882f, 0.07295913f, 0.06885254f, -0.16945916f, -0.01825582f, 0.03213099f, 0.07044341f, 0.06776143f, 
    -0.05642049f, -0.08396512f, -0.05296556f, 0.09524047f, 0.00971440f, 0.05981728f, -0.06934918f, -0.01750939f, 
    -0.09233707f, 0.01978346f, 0.18406013f, 0.10569222f, -0.16784231f, 0.16638041f, 0.11896219f, 0.08455403f, 
    -0.05636908f, -0.12116126f, 0.00789398f, -0.15722108f, -0.02632750f, 0.00141444f, 0.02395412f, -0.11350462f, 
    0.34440708f, 0.11122872f, 0.08416495f, -0.04914365f, 0.03542065f, 0.11339057f, -0.06515777f, -0.03146658f, 
    0.01608261f, -0.04363035f, -0.01479988f, 0.00871838f, -0.17728879f, 0.12721218f, -0.09603272f, 0.16274145f, 
    0.08763589f, 0.02734338f, 0.01348633f, -0.16348745f, -0.12905672f, 0.09670172f, -0.08988402f, -0.10744501f, 
    -0.28688490f, 0.01527170f, 0.07460201f, 0.01173884f, 0.00632484f, -0.02651719f, -0.12378546f, 0.08419339f, 
    0.08022279f, 0.03508661f, 0.01463073f, -0.04774194f, 0.30920056f, 0.01386540f, -0.03664938f, -0.02926066f, 
    -0.00521312f, 0.01012865f, -0.00065724f, 0.02762902f, -0.05355440f, 0.00232147f, 0.02372965f, 0.09826926f, 
    0.06750868f, -0.02351609f, -0.02108127f, 0.04425899f, 0.08716550f, -0.02520852f, 0.03130893f, -0.06700682f, 
    0.00940419f, 0.02206429f, -0.06675837f, -0.16267416f, -0.16770665f, 0.29990613f, -0.31526318f, -0.03477984f, 
    0.08235636f, 0.03814511f, 0.09241456f, -0.10741803f, 0.00624688f, -0.18482631f, 0.03504162f, 0.09779450f, 
    -0.10240074f, -0.03816628f, 0.09883193f, 0.19907357f, 0.07209144f, 0.03033864f, 0.05386845f, -0.00839059f, 
    0.11959717f, 0.15897642f, 0.08661393f, 0.08833706f, -0.12807304f, -0.05545461f, -0.14017311f, 0.07457419f, 
    0.14943981f, 0.23422977f, -0.04341245f, -0.14570490f, 0.05842560f, -0.11887356f, -0.05604854f, 0.02863122f, 
    -0.06653617f, -0.09646179f, -0.03111964f, -0.00742486f, 0.04225075f, 0.03036138f, -0.06386962f, -0.03760632f, 
    -0.02726556f, 0.07512315f, -0.00941191f, 0.05677677f, -0.25089914f, -0.14222324f, -0.01018212f, 0.16788153f, 
    0.08368192f, 0.02442743f, 0.01426158f, 0.10287999f, 0.09358802f, 0.06844451f, -0.02349435f, 0.01581486f, 
    0.18124193f, -0.07222837f, 0.09107505f, 0.04734027f, -0.05249694f, 0.01964814f, 0.09216433f, 0.18409355f, 
    0.14767466f, 0.12601595f, 0.03612489f, -0.04085007f, 0.28212738f, 0.22456707f, -0.09280581f, -0.01313954f, 
    -0.01783760f, -0.04654086f, 0.05481201f, -0.07131997f, 0.09729844f, 0.16780850f, -0.03420827f, 0.05723613f, 
    -0.00959843f, 0.01904354f, -0.08684288f, -0.07759780f, -0.04483782f, -0.07815190f, 0.02267921f, -0.00326789f, 
    0.13390180f, 0.07116058f, 0.12254174f, 0.06207465f, -0.07549009f, 0.05491617f, -0.05339437f, 0.21533906f, 
    0.05499601f, -0.05838380f, 0.06538727f, 0.00351301f, 0.02525305f, -0.01350441f, -0.01902957f, -0.00927084f, 
    -0.24135858f, -0.09618961f, 0.06468983f, 0.10049976f, -0.01867796f, 0.06193540f, -0.02519321f, -0.15277126f, 
    -0.01349681f, 0.09872850f, 0.04401242f, 0.11681671f, -0.02722828f, 0.09250371f, -0.03487131f, 0.21427718f, 
    0.15963852f, 0.04797247f, 0.04556557f, 0.02538687f, 0.17863543f, -0.00777968f, 0.05352369f, 0.06414311f, 
    -0.16867961f, -0.17518942f, -0.02260918f, -0.00215880f, -0.05801443f, -0.11647104f, -0.01132478f, -0.04601920f, 
    0.00241917f, 0.05419225f, 0.04464801f, 0.10862518f, -0.05461193f, -0.07282291f, -0.26635391f, 0.01535365f, 
    0.03257724f, 0.01005792f, 0.08956068f, -0.01131530f, -0.05843452f, 0.03657473f, 0.06167414f, 0.06040343f, 
    0.00634399f, 0.00132365f, 0.16240610f, 0.06457693f, -0.04889452f, -0.10213859f, -0.00878477f, -0.08314391f, 
    -0.01603681f, 0.03873021f, -0.09055344f, -0.05431253f, 0.12986416f, 0.14822674f, 0.23846759f, 0.12155029f, 
    0.05413795f, 0.03009441f, 0.08333129f, 0.01875855f, 0.07363294f, 0.14595363f, -0.04482862f, 0.14407006f, 
    0.09471022f, 0.30720618f, -0.01099418f, 0.00188294f, 0.06864032f, 0.00517828f, 0.13071720f, 0.03256064f, 
    -0.00220718f, -0.06367640f, 0.18338697f, 0.07188967f, 0.08593073f, -0.11152379f, 0.01342213f, -0.15616198f, 
    -0.10528924f, -0.03850284f, -0.05594767f, 0.00499167f, 0.06114088f, 0.16692278f, 0.06429009f, -0.07345548f, 
    -0.14591515f, -0.06575385f, 0.01615340f, -0.01896684f, 0.01108180f, -0.02235074f, 0.07058074f, 0.02611569f, 
    -0.01815392f, 0.01505592f, 0.13753039f, -0.05381915f, 0.11754850f, -0.10493664f, -0.06685445f, 0.18089116f, 
    0.03755563f, 0.05164470f, -0.10076804f, 0.06248355f, -0.07037147f, -0.04269255f, -0.09347799f, 0.16863647f, 
    0.12885775f, -0.08679219f, -0.03008698f, -0.13394907f, 0.06190293f, 0.03257826f, -0.00610405f, -0.19965361f, 
    0.16100137f, -0.00386370f, 0.10530494f, 0.10155962f, 0.17728184f, 0.04445109f, 0.00819988f, -0.24316604f, 
    -0.02319262f, -0.00398303f, -0.06862522f, -0.02505174f, -0.06266177f, 0.04659837f, 0.09274513f, 0.03551645f, 
    -0.07025818f, 0.00589436f, 0.18045007f, 0.06847434f, -0.05042980f, -0.00452653f, -0.02068331f, -0.00009865f, 
    0.07913166f, -0.01483116f, 0.02274225f, -0.01796972f, -0.08429664f, -0.00679891f, 0.18382278f, 0.08702964f, 
    -0.06438845f, -0.08944985f, -0.01352596f, 0.05133644f, -0.03173656f, -0.02268410f, -0.04457963f, -0.04427664f, 
    -0.15333791f, 0.04297690f, 0.16679280f, 0.03860966f, -0.07817078f, 0.03046021f, 0.07062273f, -0.07605617f, 
    0.07910317f, -0.00811097f, 0.08247312f, 0.06440179f, -0.05136826f, -0.02647920f, 0.08178567f, 0.10217246f, 
    -0.10940062f, -0.10262605f, 0.06810733f, 0.07503373f, 0.05402470f, 0.03009446f, 0.03607989f, -0.09067770f, 
    0.39654079f, -0.05953594f, -0.00284668f, -0.13059741f, 0.04103620f, -0.05097623f, 0.00154250f, -0.05679592f, 
    0.09213344f, 0.03115112f, 0.09769347f, -0.07897581f, -0.12522523f, -0.05585644f, -0.04981331f, 0.00188226f, 
    0.16230893f, -0.01664691f, -0.05728864f, 0.04835384f, -0.18381163f, 0.06066878f, -0.13392739f, -0.11052598f, 
    -0.40257946f, -0.14778952f, 0.10731068f, 0.26511350f, -0.03332717f, -0.01839388f, -0.02051092f, -0.10528290f, 
    0.01044250f, 0.04019004f, 0.01346683f, 0.07931588f, -0.12685050f, 0.03439140f, -0.00272833f, 0.09829590f, 
    -0.01563667f, 0.06613475f, -0.00968125f, -0.11551414f, -0.07951506f, -0.05237995f, 0.01338118f, -0.00201496f, 
    0.11708954f, 0.00425862f, -0.05851199f, -0.02530674f, 0.07768268f, 0.06780880f, 0.12565897f, 0.05987022f, 
    -0.07175586f, -0.05490578f, -0.12594575f, -0.09227598f, 0.04550384f, -0.06764209f, -0.01065489f, 0.09943873f, 
    -0.00129702f, -0.05300654f, 0.04102929f, -0.04069405f, -0.07220467f, -0.01463708f, 0.06333630f, 0.03968238f, 
    0.20804510f, -0.03547100f, -0.01889412f, -0.00508821f, -0.02609812f, 0.00030657f, 0.03892936f, -0.08679520f, 
    0.20240638f, 0.05904039f, -0.03724277f, 0.03505651f, -0.16262849f, -0.05069131f, 0.09167524f, 0.08691755f, 
    -0.10737727f, -0.04651213f, 0.03484219f, 0.02510479f, 0.08970001f, 0.16867881f, 0.16280305f, 0.14733817f, 
    0.03315727f, 0.03079754f, 0.07122807f, -0.07543121f, -0.08526542f, 0.19196109f, 0.12625971f, 0.12981498f, 
    0.03099582f, -0.03739763f, -0.02102703f, 0.04146647f, -0.18139732f, -0.05820439f, 0.08926453f, 0.21037591f, 
    -0.03967834f, -0.05110452f, -0.06653222f, -0.05729937f, -0.05357936f, -0.03334473f, -0.00508880f, 0.03147788f, 
    -0.09227766f, -0.03436799f, 0.07411259f, 0.17817478f, -0.10672235f, -0.14457567f, 0.01738717f, 0.00789850f, 
    0.01626484f, 0.03049351f, -0.03347275f, 0.03735938f, 0.16004087f, -0.00454930f, 0.10531409f, 0.00645932f, 
    0.09430657f, 0.04803595f, -0.07807714f, 0.25182059f, 0.02918328f, 0.11467933f, 0.06287804f, -0.01006956f, 
    0.12921821f, 0.02169933f, -0.16997574f, -0.12949350f, 0.10941137f, 0.04738343f, -0.05547759f, -0.05476993f, 
    0.02230012f, -0.00868512f, 0.05749989f, 0.09105248f, 0.06758854f, -0.02935470f, 0.08187773f, 0.06936207f, 
    0.12806100f, -0.01316944f, 0.11406739f, -0.03840805f, -0.01034915f, -0.10538635f, -0.04634221f, -0.00816347f, 
    0.01823738f, 0.03197318f, -0.29509252f, 0.03586075f, 0.15617812f, -0.05740758f, 0.00255704f, 0.05921110f, 
    -0.07160178f, 0.10123834f, 0.13622059f, -0.05607923f, 0.05383255f, -0.02064629f, 0.08305223f, 0.11645167f, 
    0.05566126f, -0.00039450f, 0.10345398f, -0.01086692f, 0.10223358f, 0.12681317f, 0.09087835f, 0.18823077f, 
    -0.01074134f, -0.00194097f, -0.00887317f, -0.00054049f, 0.09726102f, 0.16338550f, -0.15948622f, 0.06052977f, 
    -0.07968753f, 0.02058331f, 0.03871182f, -0.08540118f, -0.07577261f, -0.10308982f, -0.08411206f, -0.01090904f, 
    0.00418411f, -0.01570766f, -0.05391493f, -0.01377106f, 0.14911912f, 0.03173443f, 0.13008939f, 0.08438361f, 
    0.09341952f, -0.08244393f, 0.03929802f, 0.03370538f, 0.01395685f, 0.12832558f, 0.00567524f, 0.16393252f, 
    0.11100467f, 0.04419607f, -0.05912323f, 0.12427643f, -0.12514539f, -0.03056843f, 0.05012413f, -0.08838811f, 
    0.06378292f, 0.07958290f, -0.02034644f, -0.07921309f, -0.07851423f, 0.05227741f, -0.05011915f, 0.09350958f, 
    0.00122069f, 0.08554351f, 0.07772409f, -0.03815593f, -0.08362063f, -0.01227666f, 0.02877020f, -0.00521754f, 
    0.18159938f, -0.04364796f, 0.04656424f, -0.00049537f, 0.12194263f, 0.00010950f, 0.11634859f, -0.11314066f, 
    0.07544807f, -0.08291733f, -0.00978580f, 0.06257022f, -0.12820175f, 0.09016339f, 0.26427585f, -0.15052074f, 
    -0.07844695f, -0.09769052f, -0.14133994f, -0.05856647f, 0.01565878f, 0.06063708f, -0.00997996f, -0.02579618f, 
    -0.00320075f, -0.10004389f, -0.01014966f, -0.08656877f, 0.29829797f, 0.06522368f, -0.00186526f, -0.20127212f, 
    0.07705423f, -0.15680274f, 0.16409570f, 0.12669790f, 0.04140727f, 0.10142216f, 0.04265226f, 0.14427090f, 
    0.09025481f, -0.01449230f, 0.15309794f, 0.07575103f, -0.13118291f, -0.09091555f, -0.06386334f, -0.10172050f, 
    0.01357923f, 0.07247175f, 0.00930677f, 0.17330658f, 0.09965256f, -0.10895719f, 0.01983037f, -0.10579380f, 
    0.11250348f, 0.07124556f, -0.01004283f, 0.19335459f, 0.08928167f, 0.11230615f, 0.16107951f, 0.18843555f, 
    0.00797560f, 0.16831692f, 0.09618405f, -0.13901468f, 0.10070702f, -0.05810663f, 0.07632388f, 0.03129422f, 
    -0.11272011f, -0.00295060f, -0.12950739f, -0.24864866f, -0.18889673f, 0.01966631f, -0.14567734f, 0.03192993f, 
    0.01159947f, 0.09132203f, -0.09243076f, -0.03652064f, -0.01125733f, -0.06673168f, 0.11679313f, 0.15129015f, 
    -0.23403528f, 0.19009791f, 0.22651485f, 0.12613355f, 0.10185419f, -0.03987818f, -0.00698959f, -0.17728738f, 
    -0.00056486f, -0.03414448f, -0.01439138f, 0.02221084f, -0.11677913f, 0.11393308f, 0.31183171f, -0.15407948f, 
    0.21358405f, 0.08672544f, -0.13871698f, 0.03096603f, -0.04006999f, -0.00085436f, -0.10952457f, -0.00558731f, 
    -0.08664184f, 0.04454165f, 0.16036765f, -0.08547115f, -0.09825689f, 0.02059806f, 0.01056746f, -0.03456256f, 
    -0.00684913f, -0.03871142f, -0.23491497f, -0.21517672f, 0.01202328f, 0.09761710f, 0.04796155f, 0.08256619f, 
    -0.07766464f, -0.05795668f, 0.03797264f, 0.08158790f, -0.10566991f, 0.04939728f, 0.00996780f, -0.11198194f, 
    -0.04122710f, 0.10096318f, -0.12465899f, 0.15469249f, -0.13831075f, -0.02489343f, -0.12263296f, -0.06838616f, 
    -0.07772452f, -0.26408499f, 0.13548723f, -0.27623266f, 0.21994270f, 0.01273153f, 0.06923676f, 0.12747584f, 
    0.18397003f, 0.13686104f, -0.05945403f, 0.02000577f, 0.02322060f, -0.10917783f, -0.03921122f, 0.01819932f, 
    -0.06720658f, -0.06487224f, 0.02466994f, -0.03717231f, 0.13570386f, -0.01907510f, -0.00149939f, -0.03133582f, 
    -0.04000585f, 0.02633383f, 0.00752324f, 0.03033323f, 0.06231841f, -0.12574762f, -0.11450913f, -0.16018827f, 
    0.06302945f, 0.00319422f, -0.13656929f, 0.06460102f, 0.01227921f, 0.00377377f, 0.18974474f, 0.07202538f, 
    -0.20847094f, 0.01783923f, -0.04548796f, 0.00900328f, 0.04554600f, 0.08947492f, -0.06849614f, 0.01432205f, 
    -0.07555999f, 0.14677037f, 0.06771263f, 0.05892942f, 0.22095737f, 0.05977964f, 0.16981271f, 0.11759681f, 
    0.00180803f, -0.08487461f, -0.12515561f, -0.09775787f, -0.10425644f, 0.07236060f, -0.15982828f, -0.26827031f, 
    -0.01826573f, 0.00683013f, 0.01463581f, 0.00690549f, -0.04281292f, -0.03798584f, -0.06497388f, -0.01897096f, 
    -0.03681345f, 0.03206727f, 0.05177821f, 0.05729188f, 0.05478701f, -0.31479448f, 0.06245405f, 0.12556250f, 
    -0.03808266f, -0.00750022f, -0.17775661f, 0.05958126f, -0.03599082f, 0.04245163f, 0.07886857f, 0.02430946f, 
    0.04563712f, 0.04225358f, 0.13687840f, -0.03231084f, 0.02056143f, 0.02962348f, -0.01908478f, 0.17118007f, 
    -0.10773343f, 0.08879632f, -0.04035462f, -0.14896111f, 0.10591183f, -0.01686931f, 0.02502712f, -0.17699094f, 
    0.11599184f, 0.02609471f, 0.00427843f, 0.22707912f, 0.06813466f, 0.24116939f, -0.02080505f, 0.05319107f, 
    0.07796337f, 0.14627366f, 0.04726599f, 0.08280162f, -0.13188192f, -0.05846635f, -0.01779012f, -0.07027594f, 
    0.03927775f, 0.09629449f, 0.13882945f, 0.14689630f, -0.29674619f, -0.31863046f, -0.16177011f, 0.15519939f, 
    0.10097215f, 0.08854195f, 0.18835896f, 0.02984068f, 0.02012327f, -0.11826928f, -0.11435766f, -0.08283509f, 
    -0.24643607f, 0.05572267f, -0.01253603f, 0.23988374f, 0.02081519f, -0.05722828f, 0.03412832f, 0.09183215f, 
    -0.01822368f, 0.05612626f, -0.18309389f, -0.02490597f, 0.19020014f, -0.07063890f, 0.26768729f, -0.11533503f, 
    -0.09415360f, -0.08799389f, -0.16722798f, -0.02792691f, -0.05368980f, -0.08697756f, 0.07609790f, -0.09174750f, 
    -0.01279537f, 0.00443827f, 0.08945096f, 0.03341243f, -0.00044090f, 0.04400600f, -0.05902904f, -0.00087844f, 
    -0.07071564f, -0.15115616f, -0.02612048f, -0.12181830f, 0.04183508f, 0.09482007f, -0.18296695f, -0.09455376f, 
    -0.05279140f, -0.02418864f, -0.03812972f, 0.04300321f, -0.00404863f, 0.00345356f, 0.03567791f, -0.05539090f, 
    0.22015087f, 0.23055626f, 0.06155048f, 0.17826925f, 0.07835247f, -0.04056102f, -0.15074591f, -0.02080682f, 
    0.01907437f, -0.16145661f, -0.10134459f, -0.20183633f, 0.15581486f, 0.12473496f, -0.01412825f, 0.02862312f, 
    0.09908977f, 0.14160138f, -0.05486692f, 0.16159265f, 0.07541271f, 0.07331736f, 0.04106846f, 0.06257305f, 
    0.12116325f, 0.16025692f, 0.05883519f, 0.17532896f, 0.10434735f, 0.10425795f, -0.07563767f, -0.00631528f, 
    0.01263593f, -0.03038921f, -0.01506752f, -0.07515416f, -0.01340249f, 0.10696420f, 0.27473298f, 0.18472584f, 
    0.02544563f, -0.00652039f, -0.03778638f, -0.06016304f, 0.01188918f, -0.00785008f, 0.17399980f, -0.08705677f, 
    -0.04961259f, 0.06454545f, -0.04480943f, 0.04529215f, 0.02295160f, 0.05782601f, 0.08803170f, 0.18845204f, 
    -0.10796168f, 0.00569087f, -0.01317197f, -0.03738031f, 0.08904738f, 0.15363641f, 0.02819407f, -0.20321032f, 
    -0.08441107f, 0.03705737f, 0.01250211f, -0.00484164f, 0.00591260f, 0.13976496f, 0.21560377f, 0.04180819f, 
    0.33318704f, 0.00830644f, 0.23636740f, -0.16396424f, -0.06935306f, -0.03855616f, -0.11451653f, 0.02513478f, 
    0.05343178f, 0.02982054f, 0.05838283f, -0.06123203f, -0.06967577f, -0.01223005f, -0.02081521f, 0.00607713f, 
    -0.05641771f, -0.05941167f, -0.05911236f, -0.16027796f, 0.07109016f, 0.01183274f, -0.06627227f, -0.09238613f, 
    -0.06265540f, 0.21183994f, -0.14346379f, 0.22739981f, 0.00925379f, 0.08564783f, 0.06579399f, 0.11492714f, 
    0.12579969f, 0.04706856f, 0.02888887f, -0.10748360f, 0.10592838f, 0.08727691f, -0.05636406f, 0.18315837f, 
    0.02999027f, -0.11832679f, 0.03562053f, 0.03129064f, 0.03771352f, 0.10065890f, 0.03116398f, 0.03195146f, 
    -0.22915068f, -0.02281575f, 0.08646249f, -0.10119879f, -0.00182014f, -0.07208894f, -0.07718047f, 0.14685553f, 
    -0.20140392f, -0.06797842f, -0.06953491f, -0.10724571f, 0.07417189f, 0.09885176f, 0.17553797f, 0.16814791f, 
    -0.08328393f, -0.04700941f, -0.05378966f, -0.05560269f, 0.02429077f, -0.02772422f, -0.02570451f, 0.04101929f, 
    -0.13722154f, -0.01327941f, -0.21301854f, 0.02088500f, 0.07609683f, -0.06585447f, 0.12958668f, -0.09902917f, 
    0.00852141f, -0.01150477f, -0.04307610f, -0.01374367f, 0.01936932f, 0.02483813f, -0.00289465f, -0.03636064f, 
    -0.04327891f, 0.16244657f, 0.16555646f, 0.06703427f, 0.01272142f, 0.02017167f, 0.01359882f, 0.07731435f, 
    -0.13358466f, -0.13032128f, -0.10843839f, 0.04713187f, 0.07273109f, -0.08040749f, -0.04429273f, -0.04364892f, 
    0.00790059f, -0.03224170f, -0.11081495f, -0.14753763f, 0.03841539f, 0.21622935f, 0.09761929f, 0.11557172f, 
    0.07687330f, 0.06238655f, 0.03359869f, 0.14207965f, -0.10887212f, -0.04436930f, -0.02447443f, -0.00778079f, 
    0.03591624f, 0.14157318f, 0.02403973f, -0.04184286f, 0.06208218f, -0.10443368f, -0.00859096f, -0.01402107f, 
    0.08558654f, -0.01045575f, 0.06445087f, 0.20263752f, 0.00409598f, 0.02370611f, -0.02214976f, 0.04108923f, 
    -0.07953615f, 0.00837969f, -0.00748479f, 0.03137083f, 0.05539019f, 0.17361152f, 0.07471482f, 0.20924801f, 
    -0.28504962f, 0.15910527f, -0.16159880f, -0.09617425f, 0.00951080f, 0.11629349f, -0.05169759f, 0.13275012f, 
    0.08779965f, -0.06911310f, 0.02087555f, -0.05761849f, 0.29396257f, 0.12197638f, 0.24817783f, 0.11927417f, 
    0.12807059f, 0.01231553f, -0.06838391f, 0.14881569f, 0.00753845f, -0.10567775f, 0.06318347f, -0.09041931f, 
    -0.03329401f, -0.05098971f, -0.02512313f, -0.04435961f, 0.01387347f, -0.03207068f, -0.08915474f, -0.12275965f, 
    0.10563690f, -0.08145025f, 0.08377299f, 0.12311970f, 0.09901925f, 0.02043991f, -0.09771880f, -0.03011016f, 
    -0.01539664f, -0.11075218f, -0.00344883f, -0.07113794f, -0.04328380f, -0.05492761f, 0.02762190f, -0.00362217f, 
    0.07604921f, 0.10252013f, 0.20080251f, -0.09529822f, -0.00724741f, 0.05520521f, 0.01218248f, 0.02576543f, 
    0.19076417f, 0.08840892f, 0.11235794f, 0.11300107f, 0.03155572f, 0.05843477f, 0.14132585f, 0.00970962f, 
    0.22752652f, 0.16701928f, 0.00697707f, 0.04403049f, 0.04020040f, -0.00277629f, 0.01874328f, -0.07270944f, 
    -0.13193265f, -0.00267909f, -0.09115448f, -0.03556084f, -0.03178669f, 0.06054311f, -0.15816908f, -0.01641987f, 
    0.02638460f, -0.06332896f, -0.08931089f, -0.03819409f, -0.19144580f, 0.27948499f, -0.18428384f, 0.06853795f, 
    0.01522349f, 0.06492468f, 0.19766465f, 0.03214511f, 0.12983553f, -0.01076107f, 0.03381033f, -0.07777314f, 
    -0.05088951f, -0.12557594f, -0.02128460f, -0.07309547f, -0.05293955f, -0.15735587f, -0.10461683f, -0.13336833f, 
    -0.04564397f, -0.01674774f, 0.06987491f, 0.04904606f, -0.11566200f, 0.35217935f, -0.08228600f, -0.15673548f, 
    -0.00697824f, -0.02444026f, 0.11990950f, -0.17720158f, 0.04436446f, 0.04790472f, -0.09502745f, 0.15658453f, 
    0.06280981f, 0.05534116f, -0.00811228f, 0.00554962f, -0.04753764f, -0.03473446f, -0.13698350f, -0.03230410f, 
    -0.04772124f, 0.12043239f, -0.00835349f, 0.01160205f, 0.06769197f, 0.10574877f, -0.21952179f, -0.00890143f, 
    -0.09046132f, -0.09089366f, -0.06642032f, 0.14254856f, -0.06651520f, -0.03395739f, -0.04056850f, -0.02585774f, 
    -0.09793283f, 0.07633382f, -0.23157263f, 0.05455215f, 0.14033343f, 0.03515688f, 0.14967591f, -0.00610575f, 
    0.10239833f, 0.17418446f, -0.04283510f, -0.03875400f, -0.04975248f, -0.01975438f, 0.16906999f, -0.01798103f, 
    0.10807621f, 0.00583365f, 0.04225188f, -0.03888026f, -0.13709311f, -0.00188140f, -0.07969113f, -0.20761679f, 
    0.09319824f, -0.13226277f, 0.14923985f, -0.12209842f, -0.05262169f, -0.15799430f, 0.04327567f, -0.10176904f, 
    -0.01659828f, 0.02791158f, -0.14757223f, 0.21345690f, -0.09515042f, 0.01128023f, 0.00780908f, -0.07356710f, 
    -0.11918300f, -0.11494942f, -0.09493189f, -0.15093328f, 0.14223710f, 0.28233242f, 0.15254134f, -0.02749371f, 
    -0.19774677f, -0.36442840f, 0.38929534f, 0.15388925f, 0.12220632f, -0.00341673f, -0.17300181f, -0.07100251f, 
    -0.01091327f, -0.04201661f, 0.08739138f, 0.01041389f, 0.15505180f, 0.12895040f, -0.26596719f, 0.16392013f, 
    0.07937830f, 0.08688829f, 0.05465868f, 0.16743481f, 0.03648223f, 0.05624625f, 0.00608897f, -0.12613076f, 
    -0.12836376f, -0.27812383f, -0.00998339f, 0.14677952f, 0.13386942f, 0.03485010f, -0.00733058f, 0.07871976f, 
    -0.08880268f, -0.00997951f, -0.02119352f, 0.02989731f, 0.12262671f, 0.00547861f, 0.24729401f, 0.01851340f, 
    -0.00757466f, -0.13812454f, -0.04708021f, -0.07156415f, 0.13213722f, -0.03224845f, -0.08585465f, 0.26443985f, 
    0.40137783f, 0.27606413f, 0.02316844f, -0.12902997f, -0.01365863f, 0.00419357f, 0.07687204f, -0.00379532f, 
    0.10925957f, 0.08257495f, -0.13128498f, -0.00240266f, -0.16046914f, 0.13356870f, 0.47712579f, -0.12714401f, 
    0.10250692f, -0.11662240f, -0.16060039f, -0.21834698f, -0.04848716f, 0.05185562f, 0.00845465f, -0.00419663f, 
    -0.16819035f, -0.07609103f, -0.13372110f, -0.06969204f, 0.15850085f, -0.02800542f, 0.02079165f, 0.03320905f, 
    0.07730874f, -0.05432831f, -0.04106710f, -0.24088515f, -0.02393151f, 0.12092619f, 0.23425353f, 0.13203099f, 
    -0.07584779f, -0.06440765f, -0.09664384f, -0.11561330f, -0.01392915f, -0.00663360f, -0.03225038f, -0.04209405f, 
    -0.10077979f, -0.06465875f, -0.03860143f, 0.34305355f, 0.07357414f, 0.15169396f, 0.08291114f, 0.00652979f, 
    0.10642641f, -0.04236066f, 0.08276075f, 0.16943996f, -0.02283997f, -0.03723041f, -0.01529426f, 0.30099627f, 
    -0.01509962f, -0.13470851f, 0.03779824f, -0.04492611f, 0.05244482f, -0.02851326f, -0.11939421f, -0.13094559f, 
    0.10393354f, -0.28451452f, -0.44243404f, 0.10485803f, -0.02964068f, 0.12415553f, 0.12277735f, 0.10129833f, 
    0.03309090f, -0.09539807f, -0.00376244f, -0.14022718f, 0.04053767f, -0.17546485f, -0.30187809f, 0.20181651f, 
    -0.03464356f, 0.09363715f, 0.17104909f, 0.02167418f, -0.02243768f, 0.03924144f, 0.03576688f, -0.09455145f, 
    0.16321839f, 0.07016522f, -0.27300861f, 0.08716597f, 0.05745690f, -0.02141071f, 0.08220144f, 0.06175951f, 
    0.14294532f, 0.09302071f, 0.19841833f, 0.25559315f, -0.25747898f, -0.08094375f, -0.27969155f, 0.06933377f, 
    0.03876088f, 0.17135964f, -0.03730520f, 0.06212572f, 0.12923828f, -0.23580804f, 0.05083876f, 0.19412087f, 
    0.01538488f, -0.23994890f, 0.04165841f, -0.14942436f, 0.06612048f, -0.02651561f, -0.10033906f, -0.06994407f, 
    0.35893065f, 0.25355837f, -0.00318812f, 0.09432428f, -0.10753339f, -0.06381323f, -0.04514487f, -0.05857442f, 
    -0.07293809f, -0.07080374f, 0.01578403f, 0.18746799f, -0.04115648f, -0.08075175f, 0.05795937f, 0.06636541f, 
    -0.13869561f, -0.16573741f, -0.32835650f, 0.18391965f, 0.11372489f, 0.29661477f, 0.23110922f, 0.06593882f, 
    0.01512298f, -0.15996447f, -0.06970485f, -0.14529563f, 0.14224452f, -0.05711068f, -0.04746791f, -0.00731426f, 
    -0.02698427f, 0.03110196f, 0.13068561f, 0.14114514f, -0.06696424f, 0.01046103f, -0.18546887f, -0.17582928f, 
    -0.09032410f, 0.56005198f, 0.36870176f, 0.15152480f, -0.09484094f, -0.19574311f, -0.04306796f, -0.13478217f, 
    0.15735255f, 0.05201002f, 0.07898861f, 0.14905162f, 0.04506077f, 0.10387390f, -0.06133065f, 0.01229899f, 
    -0.12406348f, -0.02400640f, 0.12111438f, 0.11413625f, 0.20660691f, 0.03428782f, 0.23904648f, 0.34675887f, 
    -0.12235384f, -0.12742251f, -0.28533041f, 0.13190244f, 0.11565978f, 0.05309745f, 0.01848525f, 0.01622384f, 
    -0.04283826f, -0.13092221f, -0.08115880f, -0.06236882f, 0.00332711f, 0.17150381f, 0.34763193f, 0.09981466f, 
    -0.02843542f, 0.00652412f, -0.02701184f, -0.13793649f, 0.09525917f, 0.04340006f, -0.01048108f, 0.02044888f, 
    0.26483461f, 0.29788002f, 0.07483764f, 0.14166743f, 0.03050670f, -0.06338857f, -0.07496060f, -0.04049681f, 
    0.12561552f, 0.11693727f, 0.12303033f, 0.15088122f, -0.21165872f, -0.25651804f, 0.02920658f, 0.12010285f, 
    0.03110160f, 0.04771966f, -0.17192180f, -0.12477308f, -0.05138431f, -0.30317849f, -0.09721802f, -0.05995626f, 
    0.13486063f, -0.08172175f, -0.03695861f, 0.16590400f, 0.08305906f, -0.02337835f, -0.06711254f, -0.00321417f, 
    -0.00389549f, 0.03020959f, 0.04380110f, -0.04507934f, -0.11105636f, 0.23478037f, 0.24705142f, -0.02257863f, 
    -0.18477726f, -0.14649510f, -0.06814056f, 0.08501052f, 0.17201611f, -0.03442861f, -0.02570716f, -0.01363798f, 
    0.25969633f, 0.03213908f, -0.10160588f, -0.05798717f, 0.01742859f, 0.07501388f, 0.07426844f, -0.00970540f, 
    0.15366411f, 0.07279211f, 0.31057605f, -0.02336411f, -0.39312673f, -0.18535496f, -0.06713342f, -0.15615121f, 
    0.16033876f, -0.00447983f, 0.15063313f, -0.02414913f, 0.14069878f, 0.06471186f, -0.07185607f, 0.19129568f, 
    -0.02572910f, -0.12474453f, -0.11204253f, -0.08266138f, -0.00745749f, 0.01599517f, -0.01514101f, -0.06071283f, 
    0.16123813f, 0.16555713f, 0.10441212f, 0.16438326f, 0.38380793f, -0.10348681f, -0.24972451f, -0.06657359f, 
    0.11844616f, 0.01668647f, -0.09066837f, 0.07758001f, 0.11075244f, -0.09037004f, -0.19267862f, -0.07553049f, 
    -0.29129910f, 0.06293879f, 0.14394483f, 0.24092273f, -0.08161332f, 0.04586606f, -0.00390453f, 0.04222216f, 
    0.09363911f, 0.11788746f, 0.12456238f, 0.22948636f, 0.00353150f, -0.19508696f, 0.07281262f, 0.00767988f, 
    0.03552515f, 0.00363304f, 0.03830713f, -0.04566159f, 0.02564126f, -0.05687353f, -0.10092618f, 0.06355768f, 
    -0.10871562f, -0.09378478f, -0.05906750f, -0.04553449f, 0.00154212f, -0.09267820f, 0.12068352f, 0.06816798f, 
    -0.01726861f, 0.05389757f, 0.03404646f, 0.08972809f, -0.02347716f, 0.00342922f, 0.08403570f, 0.26696402f, 
    0.00785341f, -0.04489002f, -0.16304852f, 0.06096867f, 0.01013826f, -0.15509886f, 0.01049478f, 0.09392105f, 
    -0.03410362f, -0.02655873f, -0.07648677f, -0.15358633f, 0.06966557f, -0.03207146f, -0.00059117f, -0.10358828f, 
    0.00634065f, -0.07209694f, -0.05348070f, -0.09232131f, 0.15973847f, 0.16508463f, 0.10721294f, -0.14496493f, 
    0.03654950f, 0.08517364f, -0.03454882f, -0.03566473f, 0.07725155f, 0.00096639f, -0.01655184f, 0.01757836f, 
    0.01755662f, 0.10336281f, 0.06736720f, -0.01402774f, -0.05813824f, -0.09672213f, -0.00226785f, -0.10245520f, 
    0.08785770f, 0.02765779f, 0.00432341f, 0.05837731f, -0.15013950f, -0.12766178f, -0.29531088f, -0.06559093f, 
    0.03975805f, 0.00467031f, 0.05373469f, 0.01808062f, 0.05506330f, 0.09240510f, 0.11145907f, 0.07352080f, 
    0.19162178f, -0.20123228f, -0.07831100f, -0.15662822f, 0.21137667f, 0.00390312f, 0.05353020f, 0.01960874f, 
    0.00723101f, 0.02618439f, 0.05560088f, 0.11176886f, -0.01651646f, -0.18169025f, 0.09874629f, -0.05329658f, 
    0.03379970f, 0.01615979f, -0.05724827f, -0.04553942f, -0.05160794f, -0.15858079f, 0.14266941f, 0.05941280f, 
    -0.05178947f, 0.10079850f, -0.20481494f, 0.03322185f, -0.03623484f, 0.07261831f, 0.00314995f, -0.06254086f, 
    0.27664939f, 0.11366297f, 0.03559626f, -0.06267626f, -0.16901103f, -0.09249153f, 0.03787051f, -0.02238357f, 
    0.22093119f, 0.01147945f, -0.04618674f, 0.04864484f, -0.00142368f, 0.05427794f, 0.06480578f, 0.06826764f, 
    0.05276189f, 0.04314873f, 0.11239434f, -0.05671174f, 0.03728708f, 0.03888740f, 0.07158252f, 0.12775344f, 
    -0.03710893f, 0.06841224f, 0.05344424f, -0.04330356f, -0.01821076f, -0.06502791f, -0.13204309f, -0.15191305f, 
    0.14876029f, -0.03936965f, 0.02622356f, 0.10541903f, 0.01101389f, 0.00985035f, -0.04190302f, -0.06663326f, 
    0.13591781f, 0.26051632f, 0.38271004f, 0.00110156f, -0.07437041f, -0.03100938f, -0.05370878f, 0.03005275f, 
    0.01129835f, 0.16383268f, 0.09308408f, 0.19276747f, -0.06045230f, -0.03708589f, -0.02279665f, -0.01741100f, 
    0.04936030f, -0.03384748f, 0.06482061f, -0.00371899f, 0.05038042f, -0.09178238f, -0.05060891f, 0.04355397f, 
    -0.23137791f, 0.13179745f, -0.40193129f, 0.19676182f, -0.00283158f, 0.07730937f, -0.00967822f, -0.01231078f, 
    -0.02454020f, 0.01500164f, 0.01259359f, -0.07567625f, -0.06690013f, 0.02079196f, 0.26996145f, 0.09841929f, 
    0.10335119f, -0.01604040f, -0.20342323f, -0.05470583f, -0.07630319f, -0.10261254f, -0.14356346f, -0.09824080f, 
    0.19984777f, -0.02755431f, 0.09263639f, 0.02433693f, 0.06215370f, 0.08161827f, 0.01507125f, -0.01036978f, 
    0.01332186f, 0.04706356f, -0.01612080f, 0.05396642f, -0.11921428f, -0.23015188f, -0.24363700f, -0.14424720f, 
    0.04330431f, 0.03978679f, 0.07930485f, 0.01411526f, 0.04605082f, -0.09007721f, 0.00156426f, 0.19939566f, 
    -0.14282909f, -0.19508545f, -0.11369105f, -0.04578574f, 0.12434730f, 0.05171274f, 0.10011076f, 0.09581961f, 
    -0.09340427f, -0.12756655f, -0.26868981f, -0.17613113f, -0.45245251f, 0.17502698f, 0.36837256f, 0.33540753f, 
    -0.07288028f, -0.11565053f, -0.02774073f, 0.01585679f, 0.00143245f, 0.02035355f, 0.11206712f, 0.19359884f, 
    0.00251308f, -0.05217394f, -0.08696569f, -0.22646517f, -0.06027600f, -0.02568897f, 0.00191827f, -0.06133640f, 
    0.09904033f, 0.03072023f, -0.02481224f, 0.10753441f, -0.06138498f, 0.10046002f, -0.03059048f, -0.02654031f, 
    -0.00897234f, 0.01691779f, 0.11042678f, 0.01068425f, -0.00874881f, -0.00503408f, 0.09762243f, 0.10949911f, 
    0.06331611f, -0.38475585f, 0.08400372f, -0.14067298f, 0.09925459f, -0.03988506f, 0.06790894f, 0.03635073f, 
    0.19024552f, 0.26005590f, 0.11748169f, -0.04673214f, 0.09956552f, -0.20681946f, -0.05764965f, 0.05202572f, 
    0.08990648f, 0.00162971f, -0.08401914f, 0.13480066f, -0.10945299f, -0.01485874f, -0.04572097f, 0.02756056f, 
    0.06461864f, 0.29896015f, -0.03796013f, 0.00343671f, 0.11495727f, 0.20068198f, 0.23240183f, 0.12477507f, 
    0.07902020f, 0.00755047f, 0.03905669f, -0.10447951f, 0.30144307f, 0.53631109f, -0.04193579f, 0.08928374f, 
    -0.12025769f, -0.17676559f, 0.07890528f, 0.04974603f, 0.08391447f, 0.11885383f, 0.06174149f, -0.08034519f, 
    -0.19866459f, -0.15321028f, -0.09008188f, 0.18153419f, 0.13192041f, 0.09359161f, -0.07084925f, -0.03351573f, 
    0.07031466f, -0.10933880f, -0.01553372f, 0.09053439f, 0.01380933f, -0.19969749f, -0.10220684f, 0.20791352f, 
    0.03375720f, 0.12233645f, 0.04568354f, -0.05383396f, 0.09543651f, -0.15506023f, -0.04684773f, -0.05653048f, 
    -0.07413568f, -0.07902005f, -0.17715511f, 0.23292363f, 0.05095296f, -0.00577102f, -0.07747883f, -0.07375468f, 
    0.03739366f, -0.20698333f, -0.01232148f, -0.14526394f, 0.19962615f, 0.21395557f, -0.08552492f, 0.08194972f, 
    -0.11407501f, -0.06604742f, 0.01726967f, -0.03359047f, 0.13666426f, 0.04612446f, 0.07685590f, 0.26007807f, 
    -0.11267744f, -0.10298523f, -0.04581705f, -0.17403454f, 0.19085985f, -0.00071588f, -0.11601567f, -0.06937180f, 
    -0.01329761f, -0.11277175f, -0.01324955f, -0.04081987f, 0.05731025f, 0.14312190f, 0.01172032f, 0.15076700f, 
    -0.05474734f, -0.03888588f, -0.10078605f, 0.04198294f, 0.01017720f, -0.07080953f, 0.02596528f, 0.01602246f, 
    -0.01731174f, -0.00610449f, -0.01346341f, -0.03275857f, 0.00119410f, -0.00966560f, -0.03910206f, -0.02355829f, 
    -0.04001248f, -0.01697815f, 0.01065975f, -0.04149366f, -0.02234090f, -0.00247025f, -0.01447676f, -0.02121220f, 
    0.01261069f, 0.00748048f, -0.03771541f, -0.00564784f, 0.00346961f, -0.03415106f, -0.02588203f, -0.02411160f, 
    -0.02485247f, 0.00343644f, 0.01210861f, 0.02222407f, 0.00827699f, 0.00846366f, -0.01738106f, -0.00850448f, 
    -0.00691561f, -0.02407306f, 0.01793046f, -0.00822760f, -0.00069633f, -0.03365279f, -0.01109141f, 0.00658176f, 
    -0.03934968f, -0.02739961f, 0.00850781f, -0.00973901f, -0.02821484f, -0.03269972f, -0.02993400f, 0.02890272f, 
    -0.00977211f, 0.02286993f, -0.01517116f, -0.00595314f, -0.02452865f, 0.02070315f, -0.03420143f, 0.01184075f, 
    -0.02811273f, 0.01915739f, 0.00358430f, 0.02414767f, -0.02579007f, -0.02339561f, 0.00776656f, 0.02640470f, 
    0.02383253f, -0.01947003f, -0.03880803f, -0.02963356f, 0.00664593f, -0.00666911f, 0.01522200f, 0.01375069f, 
    0.01994077f, 0.02529428f, 0.02742952f, -0.04269339f, -0.03393957f, -0.02301196f, -0.02454319f, -0.01453749f, 
    0.02312044f, -0.04237890f, -0.03319183f, 0.01094061f, -0.04043910f, -0.03246533f, -0.03206493f, -0.03731966f, 
    0.00475122f, -0.03255366f, -0.01358034f, 0.01864764f, 0.00167388f, 0.00361439f, 0.01155127f, -0.03565423f, 
    0.00283628f, -0.01141581f, -0.02467377f, -0.01195154f, -0.03111674f, -0.00749859f, 0.00311232f, 0.00468791f, 
    0.00809376f, 0.02256765f, 0.02783537f, -0.03394324f, -0.01101303f, 0.01693570f, -0.03031673f, 0.01432699f, 
    0.00030243f, -0.02925822f, -0.01033148f, 0.00524013f, -0.03811909f, 0.01981408f, 0.02350379f, -0.03352865f, 
    0.02010030f, -0.02021496f, -0.00382212f, -0.01405731f, -0.02590116f, -0.04106535f, -0.03902525f, 0.00652179f, 
    -0.03299303f, 0.02205610f, -0.01685933f, 0.00027021f, 0.00264894f, -0.02300156f, 0.02056314f, -0.01199943f, 
    -0.03408819f, -0.03788352f, -0.01196707f, 0.00726948f, -0.01070745f, 0.00056290f, 0.00499249f, 0.02529358f, 
    0.02643675f, -0.01143298f, 0.00452882f, -0.01037526f, -0.02486746f, -0.02869974f, 0.01292713f, -0.03172000f, 
    -0.01955712f, -0.01804017f, -0.02303394f, -0.01196412f, -0.00587647f, 0.00167548f, 0.00928550f, 0.00058083f, 
    -0.02618919f, 0.01943657f, -0.01537906f, 0.02555599f, -0.02829890f, -0.02936291f, -0.03288129f, 0.00852029f, 
    -0.01959128f, -0.02946856f, 0.01320461f, -0.02949535f, 0.00954750f, 0.00853700f, 0.02722282f, -0.03280499f, 
    -0.02448232f, 0.03706078f, 0.00467229f, -0.01997062f, -0.03723765f, -0.00685646f, -0.01706573f, -0.02259854f, 
    0.01583274f, 0.02133073f, -0.02821772f, -0.03711166f, 0.01074185f, 0.01405135f, 0.02783453f, -0.00089389f, 
    -0.03648365f, -0.00031924f, 0.02691495f, 0.00016050f, -0.03143525f, 0.02268809f, 0.02332202f, -0.01697279f, 
    -0.03613402f, -0.03555116f, -0.01663751f, -0.04222596f, 0.01690056f, -0.03707981f, -0.00568649f, 0.00297367f, 
    0.01877080f, -0.03663550f, -0.00978705f, 0.00110910f, 0.00492967f, 0.02366453f, -0.03135146f, 0.01608781f, 
    0.01274166f, -0.01684423f, -0.03796161f, 0.02295410f, -0.02466271f, -0.01209890f, -0.02459017f, 0.00103497f, 
    -0.01226455f, 0.02887538f, -0.02444046f, 0.01000686f, 0.01983063f, -0.02574335f, 0.02378899f, -0.02462245f, 
    0.00875593f, 0.00092386f, 0.01049313f, -0.02008852f, 0.00471341f, -0.03772596f, 0.02393361f, -0.01070921f, 
    -0.02078065f, 0.01657793f, -0.03513706f, 0.01027775f, -0.00753105f, -0.02068974f, -0.02688184f, -0.02157439f, 
    -0.03878092f, -0.00495908f, -0.01803453f, 0.01570649f, -0.00004394f, 0.00876493f, 0.01944162f, -0.02222527f, 
    -0.02041643f, -0.02461732f, 0.02986157f, -0.00076474f, -0.00226113f, 0.02287769f, -0.02769403f, -0.00930809f, 
    -0.02811785f, 0.02554194f, 0.00687931f, 0.00863299f, 0.01117755f, -0.02902620f, 0.01039785f, 0.02742898f, 
    -0.03644311f, -0.03879560f, -0.00868823f, -0.02461173f, 0.01322319f, 0.00162855f, -0.01315698f, 0.01183702f, 
    0.00024885f, -0.00860687f, 0.02882585f, 0.01223806f, 0.01072349f, -0.00095377f, 0.01926452f, -0.00433546f, 
    0.01567355f, -0.01624643f, -0.03835854f, -0.02936367f, -0.03231755f, -0.02884380f, 0.00002280f, -0.00739340f, 
    -0.02647486f, 0.02767791f, -0.02188434f, 0.00383416f, -0.00114766f, -0.00022416f, 0.00145657f, -0.04020567f, 
    -0.00347006f, -0.02465603f, -0.03268921f, 0.01512887f, -0.00370166f, -0.00760174f, -0.01943154f, -0.03713790f, 
    -0.03680747f, 0.00865821f, 0.01689595f, -0.02288803f, -0.01564560f, -0.03977969f, 0.02618464f, -0.00333233f, 
    0.02901249f, -0.01121463f, 0.00528050f, -0.00300714f, -0.03198662f, 0.01392211f, -0.00762773f, -0.02094874f, 
    -0.02346052f, -0.03810299f, -0.02970188f, -0.02384599f, -0.01207848f, -0.00017070f, 0.02982899f, 0.01164725f, 
    0.02803349f, -0.00546895f, -0.02534935f, 0.01670908f, 0.01226235f, -0.03104633f, 0.02576384f, 0.01515402f, 
    -0.03538756f, 0.02851867f, -0.02797677f, 0.00222686f, -0.01332814f, -0.01720754f, 0.00155109f, 0.01543749f, 
    0.01984571f, -0.00939733f, -0.00357611f, -0.03561356f, -0.03865991f, -0.01860924f, 0.01404176f, -0.01345978f, 
    0.00810461f, -0.01791775f, 0.02017758f, 0.00854609f, 0.02276862f, -0.03496660f, -0.01058478f, 0.02450053f, 
    -0.00621343f, 0.01032498f, -0.00148378f, -0.00734084f, -0.00518746f, 0.01737827f, 0.01040706f, -0.01278015f, 
    0.00129655f, 0.00273100f, -0.02060880f, -0.03134686f, 0.01417792f, -0.02997411f, 0.01843125f, 0.01941005f, 
    -0.03062960f, -0.02835934f, 0.00505865f, 0.01901275f, -0.02900604f, 0.00330783f, -0.03575819f, 0.02362756f, 
    0.02020289f, -0.01932577f, -0.01483023f, -0.01644809f, 0.01280611f, -0.01698248f, 0.01959693f, -0.01878808f, 
    -0.00668464f, -0.04435313f, 0.01653843f, 0.01957470f, -0.01519048f, -0.00622446f, -0.02990501f, 0.01241108f, 
    0.03563456f, -0.02791211f, 0.02312820f, -0.02881189f, -0.01707782f, 0.00402617f, -0.00048483f, 0.00471743f, 
    0.02558359f, -0.02347804f, -0.01041370f, -0.02409277f, 0.01289523f, 0.02790035f, 0.02768992f, 0.01449501f, 
    -0.03836472f, 0.01948602f, -0.03457295f, -0.02280009f, -0.03581028f, 0.02021174f, -0.03122855f, -0.02232422f, 
    0.00663642f, 0.01471629f, -0.01730120f, 0.00172615f, -0.00669815f, 0.01430525f, 0.00337514f, 0.01578482f, 
    -0.01117497f, 0.00636736f, -0.00629962f, -0.00121433f, 0.01925486f, 0.00597054f, -0.04029576f, 0.02065019f, 
    -0.00886794f, -0.01846932f, -0.02387821f, -0.01886196f, 0.01798617f, 0.02189857f, -0.02936004f, 0.01795315f, 
    0.02435463f, 0.00991614f, 0.02938234f, -0.00334304f, -0.00927341f, -0.02610943f, 0.01937660f, 0.02082804f, 
    -0.00191054f, -0.00297838f, -0.03739940f, 0.00054592f, -0.00553253f, -0.01892918f, -0.02749382f, 0.00184721f, 
    0.00923772f, -0.01469264f, -0.01902980f, -0.01954727f, -0.02814473f, -0.01385975f, -0.01170959f, -0.00036074f, 
    -0.03636037f, -0.03396423f, -0.02630546f, -0.02083983f, 0.00854399f, -0.02008123f, 0.00534887f, 0.00671116f, 
    0.00338382f, -0.01021199f, -0.01953967f, 0.00518499f, -0.02909467f, 0.02352675f, -0.04079124f, -0.03998044f, 
    -0.04223693f, 0.00669177f, -0.01879992f, -0.00772046f, 0.00170035f, -0.00593819f, -0.02424891f, 0.02223200f, 
    -0.03132466f, -0.02457657f, -0.01612656f, 0.00358335f, -0.01965061f, 0.03082904f, -0.00835657f, 0.00709333f, 
    -0.00315237f, -0.00551372f, 0.00667478f, -0.01740279f, 0.01876052f, 0.01397999f, 0.01366892f, 0.02288542f, 
    0.01297635f, -0.02957682f, -0.02668101f, -0.02936827f, -0.04394279f, -0.00706749f, -0.01362784f, 0.02478468f, 
    -0.00140863f, 0.01578342f, -0.01780640f, 0.02323217f, 0.01334121f, -0.00721914f, -0.02081957f, -0.03174278f, 
    0.01013270f, 0.01354329f, 0.01978329f, -0.01287695f, -0.01287169f, 0.01302033f, -0.02302038f, 0.02972886f, 
    -0.01562617f, -0.00080050f, 0.03118127f, -0.01275924f, 0.00092869f, -0.00433844f, -0.01762606f, 0.00830934f, 
    0.01467495f, 0.01692806f, -0.02167976f, -0.01120080f, 0.01508196f, 0.00936239f, -0.03745330f, 0.01372513f, 
    -0.02016638f, -0.03254468f, 0.00472224f, -0.00526624f, -0.00933642f, -0.01634487f, 0.02632117f, 0.00023742f, 
    -0.00078144f, -0.00775769f, 0.02812688f, 0.00886710f, -0.02455616f, 0.01105275f, -0.01611246f, -0.03570465f, 
    0.01045979f, -0.03169101f, 0.00370363f, 0.03481473f, -0.02716910f, -0.03886520f, 0.00283538f, 0.01705612f, 
    -0.03792410f, 0.00478192f, -0.00438090f, -0.00577964f, 0.01514413f, -0.02321420f, 0.00736816f, 0.02707087f, 
    -0.01005332f, -0.02056223f, -0.00126227f, 0.02941292f, -0.03004856f, 0.01464011f, -0.02692158f, 0.02293233f, 
    -0.02500395f, -0.00894313f, -0.02515386f, 0.01424214f, -0.01977524f, -0.03678922f, -0.01029444f, -0.00793195f, 
    0.00282094f, -0.01445711f, 0.00548997f, -0.04033255f, 0.00322471f, 0.02791568f, -0.02754142f, -0.01691523f, 
    0.04092860f, -0.01030883f, -0.00759310f, -0.03708523f, 0.00157745f, 0.01972261f, -0.00657397f, 0.00239525f, 
    0.02631056f, -0.03680058f, -0.00059573f, 0.02540441f, 0.01816273f, -0.01375170f, 0.00239632f, 0.01490493f, 
    0.01562284f, -0.03609489f, 0.02178144f, -0.01432340f, 0.00132963f, -0.00634913f, -0.01767158f, -0.01457515f, 
    -0.01028675f, -0.03010165f, -0.02829213f, 0.02943835f, 0.00011246f, 0.02186173f, -0.03781888f, -0.01990948f, 
    -0.01793151f, -0.04211697f, -0.01006190f, 0.02393756f, -0.02193191f, -0.03830127f, 0.00565826f, 0.01316259f, 
    0.01990859f, 0.02108540f, -0.00640191f, -0.00928663f, 0.00497533f, -0.02704779f, 0.00121743f, -0.03222769f, 
    0.01098710f, -0.01843580f, -0.02959783f, -0.00731909f, -0.04322483f, -0.00749237f, 0.02184823f, -0.03563613f, 
    -0.01959164f, -0.00230063f, 0.02840201f, 0.00636526f, -0.01207488f, -0.03674076f, 0.01279157f, 0.02270424f, 
    -0.03477640f, -0.02021305f, 0.00362480f, 0.00339674f, -0.00633904f, 0.02481120f, -0.03487960f, 0.00115656f, 
    -0.04298637f, -0.01616252f, 0.02048820f, -0.00994427f, 0.00540434f, -0.01264802f, 0.02214506f, -0.02337769f, 
    0.00605126f, -0.03613853f, -0.04014205f, -0.03507250f, -0.03078754f, -0.02947353f, -0.01262149f, 0.01967233f, 
    0.01441444f, -0.04196972f, 0.01810817f, 0.01910811f, 0.02473841f, 0.01367834f, -0.01630407f, -0.00015550f, 
    -0.01593426f, -0.02583139f, -0.00402505f, -0.00435604f, 0.01322002f, 0.01344697f, 0.00991927f, 0.01086345f, 
    0.00055749f, -0.00616772f, -0.04273120f, -0.02246623f, -0.02974547f, 0.03387626f, -0.03351888f, -0.00927715f, 
    -0.03157197f, 0.00965082f, -0.00670394f, -0.04150799f, -0.01212488f, 0.02995180f, -0.00718237f, -0.00467879f, 
    -0.01861578f, -0.00044199f, -0.01793630f, 0.00712759f, -0.02160208f, -0.01021239f, -0.01093654f, -0.01430270f, 
    -0.03901955f, -0.02823405f, -0.00572707f, -0.00514538f, -0.00470185f, -0.00839150f, -0.03108319f, 0.00689730f, 
    -0.04131019f, 0.01138731f, 0.00257490f, -0.02486568f, -0.01872279f, 0.00988469f, -0.01805539f, 0.02416360f, 
    0.01258115f, -0.01371895f, -0.02814700f, -0.00174933f, -0.01128320f, -0.02307596f, -0.01388077f, -0.02040895f, 
    0.39843562f, 0.05007195f, 0.00030446f, -0.05399444f, -0.06475672f, -0.17816976f, -0.09668484f, 0.02887457f, 
    0.04247340f, -0.06666820f, -0.03319108f, 0.00036299f, -0.03811889f, 0.40405104f, -0.19234771f, 0.03457796f, 
    0.09075826f, -0.08232002f, -0.12594688f, 0.26561421f, 0.00199689f, -0.01446336f, 0.09312733f, -0.05644711f, 
    0.05722692f, -0.04968652f, 0.11334301f, 0.07583752f, -0.00531593f, 0.02488772f, -0.06376234f, -0.03556725f, 
    0.04799508f, 0.16220988f, 0.03263900f, -0.00004950f, 0.41000065f, -0.47014737f, 0.12851469f, -0.44745091f, 
    -0.01072537f, 0.00475675f, -0.02748167f, 0.01397752f, -0.02747970f, -0.14250132f, -0.07331862f, -0.07585897f, 
    0.48657188f, 0.43083256f, 0.33111480f, 0.03987331f, 0.00071059f, 0.08417092f, 0.12584910f, 0.11968128f, 
    -0.06825059f, 0.03651820f, 0.06582021f, -0.02232436f, 0.30612642f, 0.07963315f, -0.20784035f, -0.32149687f, 
    0.10727932f, -0.03263090f, 0.15397173f, 0.01269093f, 0.13279964f, 0.06538396f, -0.02499653f, -0.02189179f, 
    0.05283912f, 0.22169119f, -0.02196850f, 0.30967107f, 0.09670872f, 0.01002749f, -0.05252892f, -0.03452003f, 
    0.06390737f, -0.00160029f, 0.11134168f, 0.03147607f, 0.09904703f, -0.17940226f, 0.10417733f, -0.03336189f, 
    -0.13578527f, 0.01845832f, -0.01893400f, -0.00231354f, -0.00668584f, -0.05211448f, 0.17360376f, -0.02516615f, 
    -0.00085909f, -0.03535895f, 0.04789000f, 0.10928765f, 0.10436192f, -0.12823087f, -0.04586175f, -0.08671326f, 
    0.03542132f, 0.06274290f, -0.02649221f, 0.07365546f, 0.18392193f, -0.24861313f, 0.02621030f, -0.05000988f, 
    -0.06482173f, 0.00454166f, 0.06537461f, -0.04182838f, 0.04679053f, -0.03720453f, -0.03978728f, 0.00324184f, 
    0.00947679f, 0.19686964f, 0.23454382f, 0.10699897f, 0.17299284f, -0.07567465f, -0.08533897f, -0.05864447f, 
    0.13031544f, 0.03044902f, 0.01918733f, 0.01423436f, 0.06220617f, 0.02039198f, 0.13736786f, 0.04403117f, 
    0.13550000f, -0.13602170f, -0.20211007f, 0.17595249f, -0.01382360f, 0.03182051f, 0.11715882f, -0.03357054f, 
    -0.13337322f, 0.05775750f, -0.14599162f, -0.09139907f, 0.04940039f, 0.09073344f, 0.02896492f, 0.01139395f, 
    -0.01141818f, -0.13357429f, -0.00853480f, -0.00340417f, -0.04456259f, 0.13198921f, -0.40492383f, 0.26893210f, 
    0.06354037f, -0.03028205f, 0.09551474f, 0.06952465f, -0.18050899f, 0.01211829f, -0.01506346f, 0.09151679f, 
    0.14240733f, -0.20609911f, 0.01626652f, -0.00110180f, 0.00586888f, -0.02544879f, -0.03675072f, -0.12543543f, 
    -0.00972636f, 0.03668115f, -0.14746876f, 0.02999306f, 0.17420642f, -0.18926974f, -0.22677630f, 0.00121457f, 
    0.02437981f, -0.01569139f, 0.06923378f, 0.07058634f, -0.02148345f, 0.02282906f, -0.12555525f, 0.07949473f, 
    0.01014458f, 0.18497157f, -0.21182522f, 0.07657567f, 0.08775482f, -0.06795768f, -0.10341248f, -0.01355555f, 
    0.04774280f, 0.00292183f, 0.02184979f, -0.08115604f, 0.18639451f, 0.16311708f, -0.07108263f, -0.05408864f, 
    -0.06908586f, -0.03571919f, -0.00551270f, 0.35792971f, -0.00448507f, -0.02767834f, 0.10411648f, -0.02678888f, 
    -0.04317511f, -0.03232754f, -0.38194761f, -0.17350659f, 0.05103847f, 0.06145509f, -0.03125223f, 0.02784324f, 
    0.21668516f, -0.01411441f, -0.04357649f, -0.05147294f, -0.37660789f, -0.05195443f, -0.08979734f, 0.02515477f, 
    0.07054782f, -0.00906618f, -0.02415392f, 0.01348931f, 0.00408154f, 0.01633742f, -0.04249322f, -0.08076776f, 
    0.01087986f, 0.12378617f, 0.12089114f, 0.05947655f, 0.10821581f, 0.04628662f, -0.07779503f, -0.01350563f, 
    0.00185577f, 0.05475930f, -0.00827049f, 0.14405948f, 0.45709342f, -0.09843174f, -0.12232140f, -0.19691117f, 
    -0.11055343f, 0.00406830f, -0.11860462f, 0.08289900f, 0.13759471f, -0.04583073f, -0.06158788f, 0.05296154f, 
    -0.11696643f, 0.07021096f, 0.10161751f, 0.09632351f, -0.02246566f, 0.04943763f, 0.03267627f, 0.05700393f, 
    0.08349106f, -0.02642501f, 0.04789481f, -0.12561329f, 0.11963677f, -0.05461036f, -0.00077797f, -0.07441658f, 
    0.03320189f, -0.04111657f, -0.11951781f, 0.05098155f, 0.03028746f, -0.02728934f, -0.02087726f, -0.03281038f, 
    0.20584543f, -0.00432360f, 0.09292474f, -0.02827101f, 0.04439630f, -0.05365280f, -0.02264128f, -0.03855341f, 
    0.04258836f, -0.02437541f, -0.03952510f, -0.02047797f, 0.52588570f, -0.24305156f, 0.02076657f, -0.14935608f, 
    -0.01721594f, 0.10244658f, 0.21434987f, 0.02310247f, 0.11195815f, -0.00622841f, 0.00855596f, -0.03054004f, 
    -0.05367855f, -0.14138143f, 0.20767371f, -0.04082196f, 0.01947094f, -0.01993389f, 0.18472341f, -0.10645998f, 
    -0.04228637f, -0.01891757f, 0.17210986f, 0.11324409f, -0.03938340f, -0.03559502f, 0.02560553f, 0.05278005f, 
    0.01967660f, 0.04214994f, -0.07986050f, -0.06309221f, 0.09815700f, 0.14893512f, 0.08539826f, 0.02702570f, 
    0.09711091f, 0.00549759f, 0.04276412f, 0.05441738f, 0.00845517f, -0.02595729f, -0.03706905f, 0.00344347f, 
    -0.03947205f, -0.07813568f, -0.01627164f, 0.00714167f, 0.24409205f, 0.10513061f, -0.18195926f, -0.08763310f, 
    -0.04992567f, 0.00105950f, 0.06121083f, 0.32705215f, -0.02256058f, 0.07446430f, -0.00551150f, 0.00302961f, 
    0.11802568f, -0.15848072f, 0.02858950f, -0.00576999f, -0.06193361f, -0.03781036f, -0.06140231f, 0.03119146f, 
    0.05391347f, 0.00990321f, -0.15333882f, -0.02371307f, 0.01538392f, -0.23527330f, 0.30473509f, -0.24289566f, 
    -0.01287813f, -0.10488347f, -0.00435509f, 0.11276866f, -0.03614521f, 0.00956359f, -0.02468843f, -0.05476307f, 
    0.06607171f, 0.21738435f, 0.09792661f, -0.02474296f, 0.09092081f, 0.06681685f, -0.01581558f, 0.07862494f, 
    -0.02939680f, -0.08277066f, 0.00537506f, 0.11535535f, 0.36944768f, -0.13084632f, 0.15841940f, 0.04896762f, 
    0.02763489f, -0.03976884f, 0.01544619f, 0.01425226f, 0.08261438f, -0.07074171f, -0.09290969f, -0.01774836f, 
    0.08319664f, 0.07333678f, 0.07983732f, 0.06364611f, 0.16500971f, 0.19590282f, 0.14167891f, 0.16175269f, 
    0.01303338f, 0.01128084f, 0.09355891f, 0.00406550f, 0.18109198f, -0.14392430f, 0.00798450f, -0.26787543f, 
    -0.09626013f, 0.10453852f, -0.01544625f, 0.06741976f, 0.06620227f, -0.19444050f, 0.03835537f, 0.05952954f, 
    0.21794541f, -0.33143046f, 0.04616699f, -0.16069862f, -0.07726778f, 0.10686892f, -0.03027827f, 0.01968833f, 
    0.08188625f, -0.03170951f, -0.11476260f, 0.12556516f, 0.00647130f, 0.10839312f, -0.03704207f, 0.06989292f, 
    0.08700500f, 0.03696020f, 0.01912114f, -0.04934434f, 0.10741135f, -0.12000675f, 0.12018228f, 0.06720226f, 
    0.28475180f, 0.05089257f, 0.09502258f, 0.07928364f, 0.10350653f, 0.01623694f, 0.11085733f, 0.05442536f, 
    0.01870269f, -0.03227472f, 0.07822488f, -0.09706691f, 0.25621781f, -0.26279891f, 0.05915930f, -0.23686562f, 
    0.07091661f, -0.06959987f, -0.00489396f, -0.07668320f, -0.03059330f, 0.05289607f, 0.00819372f, 0.03470138f, 
    -0.07587546f, 0.10897539f, 0.01494542f, 0.15984581f, 0.11900540f, 0.09129234f, -0.02690435f, 0.09357172f, 
    -0.10798947f, -0.05071126f, 0.05368209f, -0.12839420f, 0.03330404f, 0.02155868f, 0.11377361f, 0.19169781f, 
    0.05379086f, -0.05577968f, 0.01765182f, -0.06800213f, 0.05426692f, 0.15980367f, 0.02166931f, -0.07692698f, 
    0.14312579f, 0.31793272f, 0.36258903f, -0.24762191f, 0.38133726f, 0.01668712f, 0.12760067f, 0.15023486f, 
    -0.02646074f, -0.01716897f, 0.06082129f, -0.00366062f, 0.08749530f, 0.23584041f, 0.11769436f, 0.15554474f, 
    0.10217608f, 0.08730724f, 0.12706393f, 0.06536283f, -0.01612792f, 0.02771292f, 0.08336337f, 0.09026134f, 
    0.01495989f, -0.19426537f, -0.06964083f, -0.04242314f, 0.05751802f, 0.02076524f, 0.07994998f, -0.06350082f, 
    0.00702984f, -0.10260328f, -0.04555912f, 0.00578716f, 0.04068617f, -0.02733292f, -0.06104197f, 0.01472885f, 
    0.21063159f, 0.17438914f, 0.02765882f, 0.04553761f, 0.02832369f, -0.00219536f, 0.00406280f, 0.01149771f, 
    -0.24231657f, 0.08396474f, -0.13948081f, 0.30162281f, 0.13330851f, 0.00096099f, -0.08984420f, -0.01944380f, 
    0.08270416f, 0.00054850f, 0.09480778f, 0.08262667f, 0.21920569f, 0.00684947f, 0.05947448f, 0.01687463f, 
    -0.05695119f, -0.01484722f, -0.01242621f, -0.09794798f, 0.05376046f, -0.03606257f, 0.01908413f, 0.01029999f, 
    0.41294944f, 0.15586236f, 0.33026785f, -0.29902875f, -0.02376731f, -0.08883990f, 0.14986448f, 0.13525389f, 
    0.00911828f, -0.00227296f, -0.08447917f, 0.07121745f, 0.24023311f, -0.16627447f, -0.00810327f, -0.24385563f, 
    -0.00360770f, -0.02302047f, 0.05848319f, 0.08033003f, -0.09091594f, -0.00155278f, -0.10654318f, 0.01682365f, 
    0.08687670f, 0.02981830f, -0.05454388f, 0.02388253f, 0.06528848f, 0.00733503f, -0.19223540f, 0.03007563f, 
    0.06451634f, -0.01728575f, -0.02155976f, 0.04929600f, -0.11206633f, -0.32312101f, -0.14612260f, -0.09193313f, 
    -0.02265831f, -0.01241380f, 0.08107533f, 0.13800518f, 0.01177363f, -0.17024373f, 0.02063150f, -0.11094551f, 
    -0.07267249f, -0.11371572f, 0.03894285f, -0.25083324f, 0.00204699f, 0.01635079f, 0.00671688f, -0.03773856f, 
    0.14895295f, -0.06910510f, 0.08641876f, -0.10032156f, 0.17780732f, 0.17513484f, 0.00559604f, -0.02707286f, 
    0.07580815f, 0.07084963f, 0.00004312f, -0.02570434f, 0.06022667f, -0.07664857f, -0.02275280f, 0.03938587f, 
    0.11510405f, 0.03742119f, 0.14678112f, -0.11509349f, -0.02132254f, -0.13894761f, 0.01528703f, 0.03956882f, 
    -0.03162164f, 0.13304344f, 0.03009601f, -0.01247545f, 0.27992919f, -0.14690956f, 0.32822388f, -0.15330081f, 
    -0.00080402f, 0.01849768f, 0.09444278f, 0.09709577f, 0.06077860f, 0.04519134f, -0.08967469f, -0.01991538f, 
    0.30137113f, 0.53187150f, 0.28171143f, 0.05188926f, 0.09140058f, -0.06010919f, 0.00413838f, 0.27336907f, 
    0.03144259f, 0.00575288f, 0.09484691f, 0.03276693f, -0.55123901f, -0.11369105f, -0.06089098f, -0.18893951f, 
    0.05920350f, -0.05456729f, -0.00536512f, -0.00690606f, -0.04225672f, 0.02972635f, -0.05080692f, 0.07399129f, 
    -0.00070220f, -0.03349931f, -0.02780328f, 0.17612684f, 0.07355846f, -0.03004248f, -0.05239714f, -0.00129531f, 
    0.07658337f, 0.05029143f, 0.01658494f, -0.04840255f, 0.05994360f, -0.06316300f, -0.06701638f, 0.16884257f, 
    0.01271119f, 0.06276336f, -0.01549428f, 0.18201827f, 0.03413931f, 0.02669740f, 0.00281682f, -0.05718366f, 
    0.30382353f, -0.02597472f, 0.04703545f, 0.17569204f, 0.20678262f, 0.02434751f, 0.19477607f, -0.09051801f, 
    0.14471960f, 0.02927072f, 0.09373358f, -0.01768994f, -0.16367032f, 0.01346730f, 0.00238727f, 0.03361488f, 
    0.07276829f, 0.07846721f, -0.00407755f, -0.00032046f, -0.06211758f, -0.07049187f, -0.06454735f, -0.05957578f, 
    -0.14771271f, 0.37489268f, -0.06397122f, 0.11462377f, 0.15897672f, -0.02644922f, -0.05644153f, -0.11473236f, 
    0.07348879f, -0.07052064f, -0.02108059f, 0.08637392f, 0.04939492f, 0.05113900f, 0.01613867f, -0.04609450f, 
    0.02921571f, 0.00849744f, -0.07953182f, 0.02024056f, -0.01351720f, -0.01632010f, 0.05049586f, 0.03833747f, 
    -0.10478351f, -0.18339963f, 0.23608308f, 0.48878559f, 0.04386300f, 0.05086050f, 0.05732950f, 0.14285991f, 
    0.10378870f, 0.11348152f, -0.16258645f, 0.04542153f, 0.09882771f, -0.09165694f, -0.01133563f, -0.25870743f, 
    0.07415881f, 0.03111118f, 0.21700120f, 0.05028367f, 0.03660303f, -0.01929801f, -0.06045818f, 0.07165164f, 
    0.02248833f, 0.01424292f, 0.00935270f, 0.00297285f, 0.02855936f, -0.00079638f, 0.02621826f, 0.02325172f, 
    0.02129501f, 0.00843776f, 0.06052381f, -0.08880112f, 0.22498131f, 0.45790666f, 0.02445044f, -0.03131936f, 
    -0.14587402f, 0.08695773f, -0.00639249f, 0.18261909f, 0.07508857f, 0.10289659f, 0.07659573f, -0.10236446f, 
    -0.20458283f, -0.07888437f, -0.03854812f, -0.15338135f, -0.20823194f, -0.11103015f, -0.05312954f, -0.14812508f, 
    0.14183839f, -0.13918149f, -0.05057081f, 0.05088674f, -0.17981768f, 0.19707239f, 0.38839975f, -0.19272089f, 
    -0.04399914f, 0.02253111f, 0.00597742f, 0.00227138f, 0.08423713f, 0.16261716f, -0.07130319f, 0.05652905f, 
    0.50905037f, -0.09844386f, 0.04628951f, -0.17815766f, -0.05567915f, -0.06845283f, -0.00888807f, -0.01417845f, 
    -0.05196979f, 0.00252209f, -0.06942774f, 0.06074575f, -0.29607171f, -0.05247232f, 0.09999716f, 0.12521647f, 
    0.04239523f, -0.06234990f, -0.02805033f, 0.19552097f, 0.12171007f, 0.06915153f, 0.03295697f, -0.09912166f, 
    -0.02989930f, -0.17381380f, -0.10473169f, 0.09395032f, 0.15233478f, 0.05169727f, 0.15455982f, 0.17388622f, 
    -0.00716825f, -0.02431237f, 0.06811801f, -0.19234964f, -0.26315659f, 0.05496927f, -0.03380941f, 0.43036923f, 
    -0.05765353f, 0.10624597f, -0.12760498f, 0.03038939f, -0.07921525f, -0.06294845f, -0.01876585f, 0.15561478f, 
    -0.03507401f, -0.08623058f, -0.13612369f, 0.13885489f, 0.09836094f, 0.09768187f, -0.04479522f, 0.03909628f, 
    -0.06511542f, -0.04388807f, 0.06165792f, 0.01349380f, -0.35735258f, -0.03583745f, 0.00362336f, 0.05178062f, 
    0.19820985f, 0.23976910f, -0.07080586f, 0.13401350f, 0.14933488f, 0.10934434f, 0.00648537f, -0.02657614f, 
    0.34707543f, 0.12810454f, -0.01868142f, -0.06360647f, 0.05230821f, -0.00654783f, 0.03356785f, 0.02852295f, 
    0.07044555f, 0.11438072f, 0.15985462f, 0.13617545f, -0.08090044f, 0.24101992f, -0.06547817f, -0.00034590f, 
    -0.03539056f, 0.10070901f, 0.00061740f, -0.03690536f, 0.04484368f, -0.10881282f, 0.19693333f, 0.04840072f, 
    0.03044071f, 0.12776250f, -0.16812117f, -0.03811766f, -0.00983870f, 0.14029434f, 0.07524433f, 0.10795925f, 
    0.01349046f, 0.13185839f, 0.04072766f, 0.10450121f, -0.00663973f, 0.08224265f, 0.32741788f, -0.05096134f, 
    0.03075835f, 0.06417548f, 0.13851850f, 0.07057264f, 0.09837449f, 0.05323679f, 0.03739780f, -0.01733394f, 
    0.12303894f, -0.03835394f, -0.10509973f, -0.05512709f, 0.15128848f, 0.19643378f, 0.11839416f, 0.10583372f, 
    -0.08402910f, -0.05448272f, -0.01951709f, 0.03489211f, -0.26520202f, 0.05667481f, -0.00010417f, 0.01855585f, 
    -0.01374261f, 0.11005023f, -0.12668510f, 0.03984112f, 0.07184012f, 0.05242173f, -0.04275435f, -0.01164462f, 
    -0.35599688f, 0.27312636f, 0.15080316f, -0.16150734f, -0.16102974f, -0.03255875f, -0.00509267f, 0.04073925f, 
    -0.05162465f, 0.01704362f, 0.03368761f, 0.09016329f, -0.07860522f, 0.14630656f, 0.13543019f, -0.02660066f, 
    -0.03542649f, -0.02472041f, -0.00082300f, -0.01186299f, 0.09180434f, -0.08456600f, 0.03382471f, 0.05436608f, 
    0.02834123f, -0.06266826f, -0.03241841f, 0.03211645f, -0.06474098f, -0.05629165f, 0.01655714f, -0.06264971f, 
    -0.00258479f, -0.08736871f, 0.07448482f, -0.03939006f, -0.18943864f, 0.15673268f, 0.02239825f, 0.30502936f, 
    -0.14249849f, -0.05753909f, -0.10475310f, 0.00133214f, -0.05083678f, -0.03736063f, -0.01490372f, 0.03296103f, 
    0.09347399f, 0.05874206f, 0.12070001f, -0.11385357f, -0.06131552f, 0.01351880f, 0.08690198f, 0.05138969f, 
    0.01226844f, 0.02797050f, 0.05417271f, -0.01932898f, -0.09071159f, -0.06061037f, 0.02890076f, 0.08556086f, 
    0.11692118f, -0.08633246f, 0.11993538f, 0.14462641f, 0.12007591f, 0.02718566f, -0.01292901f, 0.01129134f, 
    -0.07486123f, -0.01093787f, 0.07285623f, 0.17159855f, -0.03344112f, -0.01027453f, 0.01957557f, 0.02124273f, 
    0.00006901f, 0.02303868f, 0.10615765f, 0.04400174f, -0.45092764f, 0.07590775f, 0.16134354f, 0.40528849f, 
    -0.07173299f, -0.03577843f, 0.05422091f, 0.01934946f, -0.04969976f, 0.03102060f, 0.01052609f, 0.03679128f, 
    -0.16240747f, -0.01005031f, 0.03609699f, 0.32757884f, 0.09279909f, 0.09195872f, -0.15155032f, 0.07331126f, 
    0.16721854f, 0.09766593f, 0.07693863f, -0.10305596f, 0.24740297f, -0.04096185f, -0.19240345f, -0.20503438f, 
    -0.01775461f, 0.04782716f, 0.08467435f, 0.17142959f, -0.02232957f, -0.03997016f, -0.11459755f, 0.09058475f, 
    0.11347038f, 0.05675166f, -0.00149373f, 0.05195069f, -0.02326142f, -0.01833467f, 0.00958792f, -0.03423277f, 
    0.15156265f, 0.14490698f, 0.23050943f, 0.14689600f, -0.19616641f, 0.09065570f, -0.08359325f, -0.08172935f, 
    0.06222671f, 0.14603850f, 0.11234811f, -0.13073276f, -0.06507490f, -0.16573228f, 0.03770383f, 0.09323405f, 
    -0.08617877f, -0.29132757f, -0.01182978f, 0.30533651f, -0.01246053f, -0.02657428f, -0.00171547f, 0.03178169f, 
    0.16868311f, -0.03157772f, 0.02156662f, 0.09814463f, 0.24512604f, 0.12339976f, -0.04106500f, 0.25944903f, 
    0.22079438f, 0.12097456f, -0.03639746f, 0.03633750f, 0.08389492f, 0.07834898f, 0.03582308f, 0.03152370f, 
    -0.12629330f, 0.12882565f, 0.12032024f, 0.07259312f, -0.10007160f, 0.04374982f, 0.09936455f, 0.00440847f, 
    0.06427234f, 0.09229904f, -0.04050403f, -0.03483389f, -0.45380983f, -0.21126565f, 0.19419558f, 0.39331004f, 
    -0.02859492f, -0.06269297f, 0.08847328f, 0.05010751f, -0.01536994f, 0.10613426f, 0.19138300f, 0.03430415f, 
    -0.11070720f, 0.19826412f, 0.08700232f, -0.14003825f, -0.12961999f, -0.00884628f, 0.01527136f, -0.05951411f, 
    -0.03230571f, 0.00536276f, -0.07652184f, -0.06913849f, 0.51053220f, 0.16162346f, -0.03578905f, -0.22858644f, 
    -0.03872840f, -0.00343996f, 0.06732649f, 0.04056280f, 0.00007205f, 0.23054768f, 0.10443702f, -0.06221256f, 
    0.62858158f, 0.33279744f, 0.02322081f, -0.35444906f, 0.01914858f, 0.03571256f, 0.09216690f, 0.12363247f, 
    0.03673440f, -0.03666862f, 0.14484872f, -0.09635172f, 0.15684336f, -0.06850991f, 0.04682379f, 0.02378816f, 
    -0.02908937f, -0.05708377f, -0.08114332f, -0.03263782f, -0.02732562f, 0.04889509f, -0.18111295f, 0.04982732f, 
    -0.06942830f, -0.10984772f, 0.16624177f, -0.01072227f, -0.09544401f, -0.05605906f, 0.02246868f, -0.04817782f, 
    0.07908994f, 0.12809499f, 0.00647667f, 0.04755992f, 0.07737893f, 0.24371503f, 0.11494120f, 0.59421748f, 
    -0.02373986f, 0.07067853f, -0.09047926f, 0.00751334f, 0.16415006f, -0.03038516f, 0.09959299f, 0.15668605f, 
    -0.04271865f, -0.11409950f, -0.13895123f, -0.09164956f, 0.09991319f, -0.05946327f, 0.06401744f, 0.19521523f, 
    0.04727989f, 0.13029921f, -0.07950222f, 0.16887501f, 0.23296998f, 0.03071640f, 0.11330109f, 0.17908968f, 
    -0.00262317f, -0.04601490f, -0.02657792f, 0.02226991f, 0.00241786f, -0.01048450f, 0.05270080f, 0.07615981f, 
    -0.17090522f, -0.22056589f, -0.02882694f, -0.15728155f, -0.07917900f, -0.00969541f, -0.02992763f, -0.08009925f, 
    0.02583934f, -0.02471560f, -0.00425630f, 0.03538832f, -0.12850125f, 0.02634650f, 0.11492509f, -0.13718334f, 
    -0.07152351f, -0.05925493f, 0.02420218f, -0.16296452f, -0.01950978f, 0.02292872f, -0.02414767f, -0.02057727f, 
    -0.03968049f, 0.16833641f, 0.03162203f, -0.09061764f, -0.17437257f, -0.07770730f, -0.00665391f, 0.05187121f, 
    0.23708041f, 0.01387701f, 0.00519104f, -0.13496266f, -0.24951456f, 0.20694195f, 0.03010433f, -0.02640892f, 
    -0.10642533f, -0.03662143f, 0.08626486f, 0.07016256f, -0.02025409f, -0.01158968f, 0.02736311f, -0.14185891f, 
    0.26415062f, -0.11036362f, -0.04884518f, 0.09320131f, 0.04199402f, 0.02491242f, 0.07240476f, -0.01169248f, 
    -0.05415566f, -0.01105599f, -0.00991266f, 0.03017892f, -0.19053027f, -0.06296920f, 0.11189651f, 0.22910430f, 
    0.03476840f, -0.03081385f, 0.01058620f, 0.03466745f, 0.00378539f, 0.07822952f, 0.03969747f, 0.04516773f, 
    -0.15047242f, -0.39067736f, 0.16898252f, 0.01698912f, 0.02176478f, 0.03375264f, 0.02911797f, 0.02681943f, 
    0.09807462f, 0.09857577f, 0.16444343f, -0.04101120f, -0.06455228f, -0.12404353f, 0.33681396f, -0.00864046f, 
    0.10017779f, -0.00342829f, -0.02902630f, 0.12532140f, 0.18819726f, -0.04601515f, 0.09999435f, -0.00739204f, 
    -0.00676208f, -0.00955047f, -0.01926948f, -0.06857286f, 0.04983398f, 0.08902689f, 0.19496182f, -0.01307806f, 
    -0.11944222f, -0.05587318f, -0.05263712f, 0.02679029f, -0.64992380f, 0.22186080f, 0.08644647f, 0.02643389f, 
    -0.13144943f, -0.08648267f, -0.11835124f, 0.07627235f, -0.07481991f, 0.07999714f, -0.02007063f, 0.04169795f, 
    0.39972597f, 0.13993762f, -0.02174300f, -0.03666745f, 0.05002559f, 0.08543244f, 0.09452291f, 0.10296147f, 
    0.15965958f, 0.05911289f, -0.01622940f, 0.13919891f, 0.04640670f, 0.16457325f, 0.14122303f, -0.08199006f, 
    -0.06509530f, 0.01469231f, -0.01253661f, 0.09300443f, 0.09073929f, 0.01885022f, -0.01162829f, -0.10293227f, 
    0.00009839f, -0.07364551f, 0.02616149f, -0.09141696f, -0.03733628f, 0.21958253f, -0.10750721f, 0.09030700f, 
    0.06186909f, 0.08985802f, 0.08635967f, 0.01803518f, -0.20217602f, -0.23122363f, 0.18045793f, 0.04727628f, 
    0.06258244f, 0.00115388f, 0.07106198f, 0.03886966f, 0.04818384f, 0.02316002f, 0.03065589f, 0.03783524f, 
    -0.06537393f, 0.00534243f, -0.00216209f, -0.15131266f, -0.12961347f, -0.02578036f, -0.07681670f, -0.11671365f, 
    -0.00215800f, 0.00070118f, -0.05240967f, -0.00298977f, 0.40619221f, 0.18329158f, 0.06783179f, -0.17665988f, 
    0.01929674f, -0.00898604f, 0.14558049f, 0.18044628f, 0.21902470f, 0.06179812f, 0.01927886f, -0.02797266f, 
    0.15733726f, 0.00552130f, -0.13161993f, -0.15516114f, 0.06609617f, 0.07940949f, 0.05116698f, 0.03601347f, 
    0.04937494f, -0.00189300f, -0.01467402f, 0.13028038f, 0.01235352f, -0.02922735f, -0.20204383f, -0.25411582f, 
    -0.05975768f, -0.00265127f, 0.08895779f, 0.00276524f, -0.03419112f, 0.00453856f, 0.02871839f, -0.00102226f, 
    -0.67279816f, -0.32400659f, 0.11478364f, 0.44939566f, 0.12632406f, 0.12841345f, 0.05782409f, 0.20098992f, 
    -0.00453812f, 0.15786934f, 0.06971741f, -0.03278715f, 0.04503817f, 0.05202814f, -0.00699968f, -0.18764271f, 
    -0.02624319f, 0.06034074f, -0.05801973f, -0.02671250f, 0.08252703f, -0.02145240f, -0.02340353f, -0.08373955f, 
    0.16301635f, -0.10715563f, 0.25476268f, -0.29333290f, 0.01360107f, 0.08656505f, 0.02686904f, 0.07133330f, 
    -0.01623139f, 0.02140978f, -0.03608008f, 0.10890333f, -0.01814503f, -0.06229363f, -0.00631448f, 0.08119882f, 
    -0.06443292f, -0.01819420f, -0.08357024f, -0.05441315f, 0.10088963f, 0.03284635f, 0.02888129f, -0.10584306f, 
    0.00026418f, -0.00097000f, 0.01489495f, 0.00929122f, 0.01803167f, 0.02848323f, -0.03402373f, -0.00234961f, 
    0.01290340f, 0.01159205f, -0.01714525f, -0.02100570f, 0.02127241f, -0.03588722f, -0.00141147f, -0.00267908f, 
    -0.02241039f, -0.02451617f, -0.00088567f, -0.03455429f, -0.03913682f, -0.00567465f, -0.00931755f, -0.03012327f, 
    0.02186028f, 0.00715533f, 0.01701970f, -0.01070560f, -0.00227510f, -0.03756813f, 0.02447576f, -0.00100077f, 
    -0.01170710f, -0.03376166f, -0.02917724f, -0.01385974f, 0.01629401f, -0.00026703f, 0.01024561f, 0.02457197f, 
    0.03436548f, 0.00820037f, -0.02430710f, -0.03225276f, -0.02963756f, -0.00347823f, -0.03764357f, -0.02414729f, 
    -0.00344749f, -0.02147528f, -0.00806107f, -0.02741473f, 0.01332792f, -0.00520001f, -0.03954804f, -0.00337511f, 
    -0.02529147f, 0.00806011f, -0.03309039f, -0.01547857f, -0.03129659f, -0.03786178f, -0.01351035f, 0.02819935f, 
    -0.02260596f, -0.00349078f, -0.01663862f, 0.03211411f, 0.00036600f, 0.02726248f, -0.01632082f, 0.02991424f, 
    -0.02994197f, -0.01998128f, 0.02099806f, -0.01442669f, -0.00728650f, -0.01359665f, -0.01732963f, -0.00346983f, 
    0.01803586f, -0.01318797f, 0.02141197f, -0.02330682f, 0.02322867f, -0.03095669f, 0.02294544f, 0.03044368f, 
    0.00370822f, -0.01511737f, -0.01922355f, 0.01070452f, 0.02223091f, 0.01859342f, 0.02447410f, 0.01687039f, 
    0.02024570f, 0.00773659f, -0.02052398f, -0.01175852f, -0.01358359f, -0.03346033f, -0.02550275f, -0.02240244f, 
    0.01386231f, 0.02226713f, -0.02150360f, -0.04019045f, -0.02970656f, 0.03535719f, 0.02200039f, 0.00793613f, 
    0.03460630f, 0.01588701f, -0.00535755f, 0.01197269f, -0.00307665f, -0.02502374f, 0.01385053f, 0.03162489f, 
    0.00457723f, -0.00756790f, 0.00038049f, 0.03029538f, 0.01653628f, -0.03458475f, -0.03791732f, -0.02736650f, 
    -0.03383956f, -0.01781853f, -0.03654637f, -0.00492141f, -0.00146208f, 0.01531594f, 0.01226754f, -0.02564648f, 
    0.00896775f, -0.01400568f, -0.02948941f, -0.00073108f, 0.00671335f, -0.04046542f, -0.00494860f, -0.01679023f, 
    0.00235375f, 0.03025220f, -0.02604564f, 0.00701956f, -0.00053552f, -0.00836771f, -0.01710658f, 0.00121778f, 
    -0.03075868f, 0.01971436f, -0.03934153f, 0.02841072f, 0.01929235f, -0.01211864f, -0.00973250f, -0.02960368f, 
    0.01888002f, -0.01486012f, 0.00127826f, 0.00029978f, -0.02047968f, -0.02534637f, 0.01296825f, 0.02078293f, 
    0.02503123f, 0.02397442f, 0.00296000f, -0.03545916f, -0.02238851f, 0.02857155f, 0.01052813f, 0.02427774f, 
    0.02936395f, -0.02298843f, 0.00163894f, 0.01782905f, 0.00311868f, -0.01579448f, -0.03483401f, 0.00098886f, 
    0.01643269f, 0.00408021f, -0.03543646f, -0.00242219f, -0.03924901f, -0.01832717f, 0.00144389f, 0.01701765f, 
    0.01037862f, 0.00416855f, 0.00091978f, -0.03763922f, 0.02690433f, -0.03451211f, 0.03015400f, -0.02301364f, 
    0.01099214f, 0.00471822f, 0.00346401f, -0.00460733f, -0.02879649f, -0.02797150f, -0.02012699f, -0.01880287f, 
    -0.03614699f, -0.03507044f, 0.00797656f, 0.02784226f, -0.02508125f, -0.01998826f, -0.03380338f, -0.03588603f, 
    -0.02024783f, -0.00067911f, 0.01182306f, 0.02113136f, -0.00277292f, -0.03451104f, -0.03989801f, -0.01668560f, 
    0.00257831f, -0.01087673f, -0.03267722f, -0.01143454f, -0.00557048f, -0.02585687f, -0.00962928f, -0.03124343f, 
    -0.01173629f, 0.00806640f, 0.01171890f, 0.02746831f, -0.02964784f, -0.00235767f, -0.02120728f, 0.02601781f, 
    -0.03034201f, 0.02928864f, 0.00645655f, -0.00311568f, -0.02151546f, -0.00886152f, -0.03747886f, 0.00516696f, 
    0.01994748f, 0.01847661f, -0.01181591f, 0.01136499f, 0.00917070f, -0.03182897f, -0.01118534f, -0.02118573f, 
    0.00397200f, -0.02594907f, 0.00513501f, -0.01201600f, 0.03046158f, 0.01815610f, -0.02783107f, -0.01390405f, 
    -0.03433326f, -0.00978758f, -0.01980159f, -0.03876457f, 0.02116057f, 0.03002470f, -0.01734740f, -0.02351679f, 
    -0.03585728f, -0.01900763f, -0.03620445f, 0.02019365f, -0.03958369f, 0.02452209f, 0.00420017f, -0.03409159f, 
    -0.01058773f, -0.02665663f, -0.01129764f, 0.00839073f, 0.01971069f, -0.03560966f, 0.00393548f, -0.01523753f, 
    -0.00335021f, -0.00749696f, -0.04011999f, -0.03192537f, -0.03474352f, -0.03776909f, 0.02722381f, -0.01972405f, 
    -0.01409044f, -0.03559921f, 0.02444752f, -0.02603836f, -0.04134906f, 0.00781096f, -0.00489170f, -0.00415956f, 
    -0.03427106f, 0.00903405f, -0.00314597f, 0.02975966f, -0.00025787f, -0.02518914f, -0.00273455f, 0.02578925f, 
    -0.02966075f, 0.02731081f, 0.02668774f, -0.02233305f, -0.02633351f, -0.01137459f, 0.01762295f, 0.01425608f, 
    -0.00345441f, -0.00586346f, 0.02124936f, 0.02541642f, -0.02662760f, 0.01315412f, -0.01375813f, -0.03359020f, 
    -0.02901775f, -0.01647124f, -0.03592013f, 0.02326290f, -0.02602090f, 0.02747715f, -0.00429914f, 0.00688334f, 
    -0.00862583f, 0.00385145f, -0.02457743f, 0.02422529f, -0.03887422f, 0.02042743f, -0.04042437f, -0.03100190f, 
    -0.01400037f, 0.00492907f, -0.01273562f, -0.04099827f, -0.01767691f, 0.03440791f, -0.00680949f, 0.02101091f, 
    -0.02076687f, 0.02431057f, 0.02418455f, -0.01676060f, -0.03884220f, -0.01695634f, 0.02125093f, -0.00930349f, 
    0.02692839f, 0.02126726f, 0.02670146f, -0.00826002f, 0.01269390f, -0.02680894f, 0.02945734f, -0.00292221f, 
    0.01533537f, 0.02846820f, -0.03372722f, -0.03784773f, 0.00307090f, -0.03539505f, -0.00115812f, -0.03093561f, 
    -0.02766737f, 0.02948276f, 0.01714705f, -0.02918087f, 0.01323979f, 0.01577933f, -0.02300184f, 0.01214903f, 
    0.01946937f, -0.01968613f, 0.00751408f, 0.00766080f, -0.01027429f, 0.01632516f, 0.01697796f, 0.01654882f, 
    -0.00998476f, 0.01473444f, -0.01919857f, -0.01733803f, -0.01294581f, 0.00304005f, -0.03355755f, -0.00236946f, 
    0.01312013f, 0.00578539f, -0.00487185f, 0.01029337f, -0.01597565f, -0.01554723f, -0.01320561f, 0.00146948f, 
    -0.02564695f, -0.01841449f, -0.02021001f, -0.03550700f, -0.00054815f, -0.01051098f, 0.00385738f, -0.02675992f, 
    0.01024300f, 0.00477687f, 0.02766451f, 0.01743483f, -0.03209118f, -0.02195452f, 0.00664854f, -0.02565089f, 
    0.01395801f, -0.03780392f, -0.03996485f, -0.02100008f, 0.02571056f, -0.01759704f, -0.03214231f, -0.00319319f, 
    0.00732696f, 0.02558385f, -0.03985554f, 0.00144908f, -0.03761492f, -0.03029106f, 0.00898359f, -0.01733549f, 
    0.02287320f, -0.03256848f, -0.03845163f, -0.03007266f, 0.02284883f, 0.02374334f, -0.01615771f, -0.01854226f, 
    -0.03188603f, -0.01308288f, -0.03195032f, -0.02754359f, -0.02965855f, -0.02132214f, -0.01171162f, -0.00558122f, 
    -0.03562254f, 0.03000360f, -0.00702358f, 0.02107914f, -0.01851285f, 0.02124057f, -0.02772348f, -0.01116373f, 
    0.02556404f, -0.02798378f, -0.01849501f, -0.00310531f, -0.00458020f, -0.00602603f, 0.00274980f, 0.00422972f, 
    0.00282762f, 0.02820239f, 0.00465215f, 0.00100358f, 0.01602751f, 0.00638020f, -0.03889275f, -0.01741690f, 
    -0.01600918f, 0.01483158f, -0.02973881f, -0.01855073f, -0.01440263f, -0.02380228f, -0.02869121f, -0.02998710f, 
    0.02067160f, 0.02768306f, 0.00250619f, -0.02500734f, 0.01684865f, -0.00882714f, -0.02043854f, -0.01394283f, 
    0.01917822f, -0.02355471f, -0.02085961f, 0.02051765f, 0.01136076f, 0.00039636f, 0.03278621f, 0.02937563f, 
    -0.00087006f, -0.01474442f, -0.00447338f, -0.02357895f, 0.03022570f, -0.00895532f, -0.02820461f, -0.00947173f, 
    -0.01322530f, 0.00521347f, -0.03965430f, 0.02089546f, -0.01068175f, 0.01469600f, 0.01826988f, -0.03078679f, 
    -0.01067735f, -0.02470926f, 0.02110750f, -0.01013085f, -0.01158300f, -0.02764736f, -0.01048933f, -0.00561437f, 
    -0.01139497f, -0.00723650f, 0.01188307f, -0.02238434f, 0.00309609f, 0.01555997f, 0.00539593f, 0.00930778f, 
    -0.00398831f, 0.02510882f, 0.01064093f, 0.02340412f, 0.02698139f, 0.02825232f, -0.03211510f, -0.03521050f, 
    -0.01675955f, -0.02551374f, -0.01982133f, -0.01908873f, -0.03005239f, -0.02335745f, -0.02389240f, -0.00841552f, 
    -0.01527844f, -0.02538379f, 0.00124297f, 0.00762937f, -0.01173323f, -0.02513231f, 0.00640695f, 0.02893494f, 
    -0.03116825f, 0.02339639f, -0.02155516f, 0.00584073f, -0.02884631f, 0.02841086f, -0.02914823f, -0.03641327f, 
    -0.03492597f, 0.00142852f, -0.03557094f, 0.01511596f, 0.02627605f, -0.02721106f, -0.03209531f, -0.03312486f, 
    -0.01815204f, 0.02278410f, -0.03097465f, -0.00828863f, -0.01197551f, -0.01653185f, 0.01376585f, -0.03955256f, 
    -0.00202665f, 0.00475171f, -0.02652181f, 0.01710312f, -0.00877020f, 0.02752606f, 0.01140582f, -0.01020697f, 
    -0.03800122f, -0.00640670f, 0.00145835f, -0.00254671f, -0.01909018f, -0.00046378f, -0.04011365f, 0.00953952f, 
    -0.00631134f, -0.01634283f, 0.01094057f, -0.02714189f, -0.02252019f, 0.01743107f, 0.03098445f, -0.02606311f, 
    0.00425563f, 0.02062509f, 0.00964680f, 0.02632225f, -0.03809090f, -0.03441321f, -0.00248813f, -0.00365898f, 
    -0.02725198f, -0.00253307f, -0.04119259f, -0.03590627f, 0.02255730f, -0.00965769f, -0.03452547f, 0.02378642f, 
    0.01635144f, 0.03030839f, 0.01347064f, -0.00818584f, -0.03307427f, 0.01360562f, 0.02158464f, -0.03037647f, 
    0.00405903f, -0.02383706f, -0.03028980f, 0.02771488f, -0.00090857f, 0.02404146f, 0.02997477f, -0.00910096f, 
    0.00029610f, -0.00953127f, 0.01642622f, 0.01204254f, -0.03212241f, 0.01302957f, -0.03680591f, 0.01735633f, 
    -0.00906362f, 0.01382560f, -0.01253212f, -0.03432140f, -0.01534612f, -0.01165231f, 0.02305928f, 0.02787106f, 
    -0.01423706f, -0.03008244f, 0.01060941f, -0.00083867f, 0.01700398f, 0.00821643f, -0.00219527f, -0.04069267f, 
    -0.02786187f, -0.00203970f, -0.01119462f, 0.02908882f, 0.02447068f, 0.00820556f, -0.03219237f, 0.00769999f, 
    0.01912143f, 0.01628435f, -0.02412168f, -0.01624796f, 0.00862825f, 0.02502730f, -0.01937640f, 0.03065461f, 
    -0.02674582f, -0.03576457f, -0.03565850f, 0.03049328f, -0.03418470f, -0.02964243f, 0.02135026f, -0.03632125f, 
    0.00385029f, 0.00426827f, -0.00636843f, 0.00197889f, -0.01003737f, 0.02060464f, 0.02340252f, -0.03468208f, 
    -0.02358791f, 0.01178235f, 0.02121239f, 0.02815169f, -0.00466454f, 0.02074202f, 0.02167975f, 0.01781616f, 
    -0.03144338f, -0.02382942f, -0.03232946f, -0.03014661f, -0.03279883f, -0.01596767f, -0.00441652f, 0.00835920f, 
    -0.01903966f, -0.02693884f, 0.00009952f, 0.02946100f, -0.02508203f, -0.00528758f, -0.03475590f, 0.01169807f, 
    0.02787205f, 0.00143158f, 0.02527851f, 0.02855931f, -0.01979810f, -0.00481513f, 0.00669147f, -0.00740488f, 
    -0.00457094f, -0.01231666f, -0.03630793f, 0.02863302f, 0.00452275f, -0.00932345f, -0.00068157f, -0.01762016f, 
    -0.01636073f, -0.02156635f, 0.01060302f, 0.00284156f, 0.02881567f, -0.03349151f, -0.01815383f, 0.00209817f, 
    0.00616983f, -0.02867938f, -0.01465266f, -0.01815595f, -0.03841575f, -0.01890448f, 0.00074369f, -0.04016123f, 
    -0.03897490f, -0.03903978f, -0.03031077f, 0.02192407f, -0.02571285f, -0.00064391f, -0.02063049f, -0.02524139f, 
    0.01272761f, -0.03008823f, -0.02228456f, -0.02503945f, -0.01465166f, -0.02626431f, 0.02119606f, 0.02658445f, 
    0.02007818f, 0.01066948f, 0.01469370f, 0.00209488f, -0.03371306f, -0.03517186f, -0.02767616f, -0.03825275f, 
    0.01556203f, -0.04377345f, -0.01414530f, -0.00444373f, -0.03227805f, 0.02195634f, 0.01238051f, 0.00404662f, 
    -0.03646596f, -0.03558953f, -0.02955193f, 0.00483680f, 0.02130667f, -0.02436409f, -0.01062854f, 0.00662553f, 
    -0.02614838f, -0.02897033f, 0.03310628f, 0.00738269f, -0.03536367f, -0.02661726f, -0.02086342f, -0.02463619f, 
    0.01030111f, -0.00599713f, 0.00306500f, 0.01219951f, -0.00297081f, -0.01838896f, -0.01722143f, -0.04365952f, 
    -0.04240611f, -0.00079295f, -0.03374228f, 0.01565885f, 0.00268915f, -0.03047507f, -0.00686133f, -0.02433976f, 
    -0.04380821f, -0.02248337f, -0.03218644f, 0.00517317f, -0.02405501f, -0.01036788f, -0.01478433f, -0.02343122f, 
    -0.03824087f, -0.01195111f, 0.00987237f, -0.02240156f, -0.01353180f, -0.02264136f, -0.00449271f, 0.01752770f, 
    -0.01416269f, -0.03877580f, 0.02172386f, 0.02437515f, -0.04151324f, -0.04627327f, -0.02904924f, -0.03023489f, 
    0.04177974f, 0.02951958f, -0.03126000f, -0.00051304f, -0.00187568f, -0.01334104f, -0.02771339f, -0.00746914f, 
    -0.00578997f, 0.00756872f, -0.04363211f, 0.02557049f, 0.00058485f, -0.04373488f, -0.01021446f, 0.00767608f, 
    -0.01524576f, 0.01189351f, -0.03435591f, -0.03013889f, -0.02128215f, -0.00269869f, -0.03261505f, -0.00008677f, 
    -0.00108723f, -0.04561911f, -0.02450135f, -0.00955001f, -0.03118832f, 0.00970711f, 0.00024479f, -0.01291399f, 
    0.00901316f, 0.00184730f, -0.02100809f, -0.00969177f, -0.02237999f, -0.01928192f, 0.00406769f, 0.00500709f, 
    -0.00906496f, 0.02411193f, -0.01916522f, -0.00526907f, -0.02485895f, -0.01951559f, -0.00177767f, -0.00710993f, 
    -0.01132683f, -0.01672982f, -0.00044822f, 0.00444765f, 0.01882612f, -0.03686718f, -0.03545501f, -0.00204711f, 
    -0.02947707f, 0.00983406f, 0.01771980f, 0.01414255f, -0.02799078f, -0.03429022f, -0.03950868f, -0.02687474f, 
    -0.03903711f, -0.00119071f, -0.02958419f, -0.04121440f, 0.01677313f, 0.00597199f, -0.01102616f, 0.01573416f, 
    0.01900313f, -0.00092414f, -0.00362474f, -0.02000245f, -0.03643180f, 0.00195671f, -0.01810458f, -0.01548993f, 
    0.00064022f, 0.01018077f, -0.04017932f, -0.04136258f, -0.02131266f, -0.01041966f, -0.00140223f, 0.02423601f, 
    0.00405054f, 0.01158600f, -0.02384274f, -0.02167855f, -0.00716403f, -0.04087773f, -0.03754377f, 0.00657079f, 
    -0.00196355f, -0.02353346f, -0.03444466f, -0.01304269f, -0.03878259f, 0.02776585f, 0.02027543f, -0.02776465f, 
    -0.04726449f, -0.01795609f, -0.01949329f, -0.04726237f, -0.03387475f, -0.03506692f, -0.02950014f, -0.01389984f, 
    -0.03320222f, -0.03654359f, -0.00447406f, 0.01515014f, -0.00430389f, 0.02703684f, 0.01945644f, -0.04843029f, 
    -0.01496462f, 0.02028701f, 0.03424190f, 0.02675461f, -0.03349952f, -0.00801625f, -0.02184992f, 0.00537962f, 
    0.00654051f, -0.01846721f, 0.02461994f, 0.01938380f, -0.01925204f, 0.00122266f, 0.00807578f, -0.01441899f, 
    -0.00597896f, -0.00219159f, -0.02479085f, -0.04115602f, -0.01035016f, 0.01533877f, -0.00213817f, 0.01457991f, 
    -0.02011357f, -0.02531465f, -0.01965037f, 0.00389565f, -0.03751264f, -0.01977759f, 0.01072158f, 0.02303333f, 
    -0.01179487f, -0.03119200f, -0.02474090f, 0.01122634f, -0.00152593f, 0.02568226f, -0.00656598f, 0.02207608f, 
    0.01859579f, 0.01939378f, -0.00896565f, -0.02476666f, -0.00802686f, -0.04535833f, -0.04528346f, 0.01040501f, 
    0.03331494f, 0.00182638f, 0.00062242f, 0.02712929f, -0.02451811f, 0.03271029f, 0.01524150f, 0.02646349f, 
    0.02827552f, 0.01502874f, -0.02811051f, -0.00843570f, -0.00299714f, 0.00965829f, -0.01848124f, 0.01704262f, 
    -0.02230062f, 0.02816963f, 0.02474602f, -0.00271598f, 0.01007291f, -0.00928662f, 0.01622699f, -0.01463948f, 
    -0.00404135f, -0.00306202f, 0.01242107f, -0.01321825f, 0.01217540f, 0.00258233f, -0.04453307f, -0.02261792f, 
    -0.01001483f, 0.00791586f, -0.01999452f, -0.02494610f, -0.00330584f, 0.01743808f, 0.02009858f, -0.02911390f, 
    0.00716317f, -0.03846540f, -0.01898959f, 0.02846438f, -0.00833381f, -0.03299451f, 0.00079260f, 0.02920542f, 
    -0.00974119f, 0.00811120f, 0.01195685f, 0.03174992f, -0.02759433f, -0.03115042f, -0.01658445f, 0.00571769f, 
    0.00459103f, 0.00073730f, -0.02931359f, 0.01731413f, -0.00242186f, 0.01520245f, -0.00144049f, -0.00287179f, 
    -0.00247799f, 0.00685478f, -0.02622339f, 0.01426379f, -0.01581732f, -0.02788448f, -0.04102735f, -0.03185423f, 
    0.02587581f, 0.00911434f, 0.02214408f, -0.02291926f, -0.00917186f, -0.04206076f, 0.01428857f, -0.02387905f, 
    -0.03533057f, -0.04704829f, -0.04256883f, 0.02341247f, -0.02231989f, -0.01447374f, -0.02384977f, -0.03750083f, 
    0.03038396f, 0.02640355f, 0.02091711f, 0.01727183f, -0.00400745f, 0.01020000f, -0.03460925f, 0.01438656f, 
    -0.00600588f, -0.02961887f, 0.02722998f, 0.01517312f, 0.01119538f, 0.02701720f, 0.00361501f, 0.01859044f, 
    -0.01927715f, -0.02040972f, -0.00140245f, -0.00923057f, -0.02394742f, -0.01573403f, 0.01038866f, -0.02954214f, 
    0.00817205f, -0.03534718f, -0.03073085f, -0.03951320f, 0.02584667f, -0.03401712f, -0.02860709f, -0.02271502f, 
    -0.03236987f, 0.02564825f, 0.00314794f, -0.03342527f, 0.02742698f, -0.02851362f, -0.02016051f, -0.00240770f, 
    -0.01099956f, 0.00320231f, -0.04900740f, -0.01496160f, -0.00725254f, -0.03305215f, -0.02300860f, 0.02782368f, 
    -0.03508920f, -0.01827687f, -0.03797727f, -0.03492227f, -0.02969528f, -0.03605570f, -0.03649889f, -0.02911644f, 
    -0.05095591f, 0.01225320f, -0.04178105f, -0.01272923f, -0.04241638f, -0.03345501f, -0.03864501f, -0.01260214f, 
    -0.03887089f, -0.02030971f, -0.01004460f, -0.02772820f, -0.01047863f, 0.02426023f, 0.00471613f, -0.00735690f, 
    0.00337690f, -0.01844818f, 0.01085231f, 0.01481811f, 0.00539692f, -0.02261699f, -0.03253437f, 0.02860414f, 
    0.00210293f, -0.04925238f, -0.01747490f, 0.00205568f, -0.00953186f, -0.04490864f, -0.03198188f, 0.02201232f, 
    0.02806814f, 0.00967258f, -0.00031105f, -0.00905232f, -0.00220273f, -0.00898897f, -0.00612549f, -0.04247563f, 
    0.01717418f, 0.00009577f, 0.02263533f, -0.03897692f, -0.00383388f, -0.00753980f, -0.00509150f, 0.00435519f, 
    0.03993759f, -0.01609612f, -0.02865672f, 0.01118613f, -0.02026119f, -0.01363804f, -0.02159609f, -0.00203767f, 
    0.00078417f, 0.02072933f, 0.02217461f, 0.01873912f, 0.03585501f, -0.00844630f, -0.01884439f, 0.02809817f, 
    0.03563643f, 0.01955580f, -0.01585842f, -0.01350864f, 0.00903688f, -0.03935486f, 0.00428168f, -0.02301077f, 
    -0.04871798f, -0.02597776f, -0.03808157f, -0.03735568f, -0.04875427f, -0.04203628f, -0.04000926f, 0.00507906f, 
    0.01072184f, -0.01417128f, 0.00943009f, 0.00015912f, 0.00270315f, 0.00773473f, -0.02406447f, 0.00224005f, 
    0.00948903f, -0.02672355f, -0.01789360f, -0.00157747f, -0.04394670f, -0.02149078f, -0.01256257f, 0.02228918f, 
    -0.04556537f, 0.01439749f, 0.01175103f, 0.00189428f, -0.03217342f, 0.01712940f, -0.04935665f, -0.04213593f, 
    -0.02743892f, 0.02353817f, 0.01666079f, 0.02617910f, 0.00376513f, -0.00734058f, -0.00045188f, -0.00293923f, 
    -0.02333610f, -0.00133849f, -0.00720329f, 0.01178230f, -0.01329459f, -0.01435408f, -0.00335948f, 0.01876109f, 
    -0.03838998f, -0.01557373f, -0.03554253f, -0.00280044f, -0.03759154f, -0.00796962f, -0.03324175f, -0.02816991f, 
    0.01828907f, -0.02934678f, -0.02270239f, -0.01774612f, -0.00585847f, 0.02063553f, 0.00003897f, 0.01185371f, 
    0.01880326f, -0.02560297f, -0.01735028f, -0.02197094f, -0.00479084f, -0.01759777f, -0.04478004f, -0.00875747f, 
    -0.03697125f, 0.00016480f, -0.03629062f, 0.01414741f, -0.00598009f, 0.01323351f, -0.00371537f, 0.00895212f, 
    -0.00372833f, 0.01888371f, -0.00608896f, -0.03288629f, -0.02750208f, -0.02190813f, -0.03117927f, -0.04569830f, 
    -0.03731817f, -0.04954809f, 0.00986410f, -0.02415482f, -0.01676369f, 0.02230835f, -0.02397885f, 0.00048163f, 
    0.00532534f, 0.01510369f, -0.02866892f, 0.03398515f, 0.00909797f, 0.03454900f, -0.01782723f, 0.00597821f, 
    -0.01675428f, -0.04343243f, -0.02501706f, -0.03561194f, -0.01590225f, -0.03211127f, 0.03681440f, -0.00525376f, 
    -0.03199154f, -0.01275114f, -0.02990412f, -0.00879734f, 0.02408787f, 0.01269072f, 0.01972100f, -0.02175928f, 
    0.01259167f, -0.04835234f, -0.02313518f, -0.00987702f, -0.04824532f, 0.00854839f, -0.02414226f, -0.00177999f, 
    0.01435803f, -0.00189917f, 0.00245442f, -0.00844895f, -0.01664391f, 0.00288579f, -0.03934580f, -0.03876923f, 
    -0.05058455f, 0.00798356f, 0.00071233f, -0.02796951f, -0.02240054f, -0.01202731f, -0.02303316f, -0.03915745f, 
    0.00557136f, -0.01628860f, 0.00535522f, 0.00515595f, 0.00565997f, -0.01214232f, -0.02121802f, -0.01969028f, 
    -0.00928557f, -0.02442588f, -0.01042473f, -0.04282691f, -0.02056948f, -0.01979373f, -0.03063350f, -0.00943258f, 
    -0.02300142f, -0.01000541f, 0.00581079f, -0.00932477f, -0.04519562f, -0.01782465f, -0.00801165f, -0.04070045f, 
    0.00625657f, 0.00387277f, -0.00012652f, -0.03893337f, -0.00182977f, -0.03026557f, -0.03257075f, -0.01926257f, 
    -0.02459653f, 0.01212998f, -0.04798172f, -0.00701343f, -0.01801981f, 0.01112635f, -0.00594397f, -0.00862927f, 
    -0.04796444f, -0.00588790f, -0.02128753f, -0.02500293f, 0.00690445f, 0.02569918f, -0.04735119f, -0.02986925f, 
    0.01126045f, 0.03526155f, -0.01963740f, -0.01797632f, -0.00494068f, 0.00212653f, -0.03829013f, -0.00730876f, 
    0.01965074f, -0.01641753f, 0.02047296f, 0.01026324f, 0.00386337f, -0.05054368f, 0.01117112f, 0.01850952f, 
    -0.00592072f, -0.03823048f, -0.00140685f, -0.02028133f, -0.02744792f, -0.00540804f, -0.01092644f, 0.00546816f, 
    -0.00285272f, -0.02244134f, 0.00993618f, -0.04734041f, -0.04946503f, -0.00467831f, 0.01376816f, 0.01668040f, 
    -0.04031139f, -0.04113651f, -0.01543023f, -0.00638762f, 0.01835686f, -0.00735282f, -0.01852503f, -0.04148037f, 
    -0.01586828f, 0.00224700f, 0.02958306f, -0.03848675f, 0.01193402f, -0.00321787f, 0.00024835f, 0.01595160f, 
    -0.02956948f, -0.03338524f, -0.02495637f, -0.02400057f, 0.00906778f, 0.00920140f, -0.03394995f, -0.01081295f, 
    -0.01168693f, -0.00438397f, -0.03268006f, 0.01230898f, 0.01147362f, -0.01954411f, -0.02596759f, 0.00816075f, 
    0.00248585f, 0.01682812f, -0.01150440f, -0.04517009f, 0.02475805f, 0.01256911f, -0.03360511f, -0.02447386f, 
    -0.01704014f, -0.01719649f, -0.03154165f, -0.02639792f, 0.00982822f, 0.02313521f, 0.01998649f, -0.01347079f, 
    0.00151007f, -0.00219681f, 0.00065640f, -0.00777142f, -0.02629152f, 0.02226557f, -0.01502327f, -0.02559344f, 
    -0.00464234f, -0.01868227f, -0.00667476f, 0.01973655f, -0.01653403f, -0.01878116f, -0.02853917f, -0.00076799f, 
    -0.00716504f, -0.02674207f, -0.03281997f, 0.01332536f, -0.02004267f, -0.00254418f, -0.03417099f, 0.02405009f, 
    0.01616305f, -0.02756417f, 0.02253447f, -0.01831336f, -0.02048742f, 0.04248664f, -0.02490469f, 0.01491337f, 
    0.00806916f, -0.01515225f, -0.02797583f, 0.01813788f, -0.02593093f, -0.00456148f, 0.02359767f, 0.01249127f, 
    0.23719420f, 0.04231001f, 0.04301776f, 0.15550299f, -0.02590972f, 0.24415980f, 0.09603258f, 0.05982827f, 
    0.16240893f, 0.12710077f, 0.03537676f, 0.13491863f, 0.14521436f, -0.11152226f, -0.05685896f, -0.09209424f, 
    0.03173379f, 0.07701980f, 0.11621848f, -0.01961236f, 0.04704560f, 0.05824891f, -0.06223391f, 0.04700602f, 
    0.01612745f, 0.03133881f, 0.02800818f, 0.09424789f, -0.02749167f, 0.02210571f, 0.04033879f, 0.02030445f, 
    0.10126876f, -0.00381477f, 0.04892282f, 0.04869645f, -0.13152546f, 0.14252011f, -0.48102933f, -0.14398558f, 
    -0.00475131f, -0.00194104f, -0.14663871f, 0.15943508f, -0.12788209f, 0.10011477f, 0.09186018f, -0.14676873f, 
    -0.32827610f, -0.24288867f, -0.16809124f, 0.21099852f, 0.00348219f, 0.12167095f, -0.01232394f, 0.11094405f, 
    -0.05025176f, -0.13495278f, -0.00355009f, 0.01290695f, -0.11424281f, -0.20168191f, -0.01222140f, -0.10506142f, 
    -0.02805408f, 0.09401491f, 0.00687622f, -0.04044760f, -0.02447327f, 0.21424088f, 0.03006169f, 0.16346936f, 
    0.41011700f, 0.18259093f, 0.19071822f, 0.09255678f, -0.07621228f, -0.03222481f, 0.02908507f, 0.04869260f, 
    0.02011982f, 0.08000596f, 0.04069382f, 0.01606632f, -0.04688102f, -0.27649611f, -0.12208943f, 0.04338651f, 
    -0.03688357f, 0.03058410f, 0.07158750f, 0.07059620f, 0.08581822f, 0.00418736f, 0.00406463f, -0.07218447f, 
    -0.26623821f, 0.00856188f, -0.00645841f, 0.02753934f, -0.07322340f, -0.05263500f, 0.02080166f, 0.06812333f, 
    0.00900788f, -0.10950479f, 0.02651477f, -0.03325478f, -0.08929222f, 0.09874802f, 0.06775399f, 0.01821622f, 
    -0.03889093f, 0.05053275f, -0.05027131f, -0.02839899f, -0.02947543f, 0.00087492f, -0.01162762f, -0.05449234f, 
    0.17736985f, 0.15355307f, 0.05655061f, 0.10459526f, -0.13043523f, -0.09961677f, 0.02723108f, -0.01281396f, 
    -0.01631910f, 0.02040000f, -0.04606434f, 0.05554053f, 0.02599701f, 0.00639317f, 0.08918366f, -0.09619741f, 
    -0.08425441f, 0.05994007f, 0.16943122f, 0.15006034f, 0.06561992f, 0.09143601f, -0.00930702f, -0.00078944f, 
    0.11893529f, -0.07993103f, -0.01397139f, -0.03994076f, -0.02458521f, -0.07521386f, -0.01575429f, 0.10333917f, 
    -0.04297349f, 0.05617822f, 0.00871586f, -0.02178130f, 0.10336844f, 0.10648590f, 0.23160686f, 0.00235432f, 
    -0.08074559f, 0.00545951f, 0.02029748f, -0.03346749f, 0.07054145f, 0.07845366f, 0.10051673f, -0.08309571f, 
    -0.10910483f, 0.13884841f, 0.00610906f, -0.10344292f, -0.00929370f, 0.06674978f, 0.09181815f, 0.00545836f, 
    -0.00872943f, -0.14087851f, 0.11153679f, 0.11526909f, -0.35474893f, -0.04431150f, -0.14314625f, -0.16388009f, 
    0.09701222f, 0.01961976f, -0.15236525f, -0.14077207f, -0.05044099f, -0.05096103f, -0.08848208f, 0.02693647f, 
    0.12057121f, 0.06302343f, 0.03030370f, 0.05072234f, -0.08735792f, -0.06766313f, -0.06563059f, -0.01415098f, 
    -0.00176926f, 0.01780839f, -0.04251780f, 0.03399535f, -0.02461372f, -0.05747484f, -0.03579514f, 0.00497230f, 
    0.09925590f, 0.14896797f, 0.01491243f, 0.12679510f, -0.05180334f, 0.00794706f, -0.02432663f, -0.02203822f, 
    -0.50153428f, -0.34312588f, -0.09618067f, -0.12705648f, 0.00255458f, -0.01114760f, 0.01618061f, 0.06103652f, 
    0.02764297f, 0.02363404f, 0.01236724f, 0.03212050f, 0.12882218f, -0.07363484f, -0.06633695f, -0.05354255f, 
    0.01346415f, -0.00661846f, -0.02632246f, 0.05400966f, -0.13531178f, -0.24279475f, -0.06078604f, -0.03980685f, 
    0.13159467f, 0.13437127f, 0.06720606f, 0.06165559f, 0.00315104f, -0.01308197f, -0.03943135f, -0.02035515f, 
    0.06236620f, -0.00761694f, 0.01839343f, -0.00586659f, 0.14442019f, 0.02197545f, -0.16492867f, -0.21911266f, 
    -0.02843188f, -0.05561608f, 0.01305102f, 0.05975258f, -0.11223616f, 0.15183578f, -0.00431061f, 0.02801831f, 
    -0.08255068f, -0.21875958f, 0.06784835f, 0.12135764f, 0.02138827f, 0.02718026f, -0.00886816f, -0.05265585f, 
    -0.01572591f, -0.06594653f, 0.14490506f, -0.02253103f, 0.03449180f, 0.03814737f, 0.03484689f, 0.03728358f, 
    0.12524195f, 0.01614236f, -0.02257246f, 0.11008801f, 0.01890528f, -0.04219476f, -0.03107204f, 0.04571867f, 
    0.10242795f, 0.11323712f, 0.04660529f, 0.03467490f, 0.00217770f, -0.00338610f, 0.01420237f, 0.02495410f, 
    0.08509014f, 0.00691761f, 0.04798433f, 0.02503135f, -0.49775696f, -0.06559495f, -0.14829573f, -0.09311040f, 
    0.11570488f, 0.14947984f, -0.01260056f, 0.05207600f, -0.21936487f, -0.13147473f, 0.01832059f, -0.02146910f, 
    -0.06326226f, 0.02817929f, 0.10150769f, -0.15061754f, 0.05707438f, 0.09061840f, -0.06666324f, 0.14579080f, 
    -0.02501184f, 0.27738887f, -0.05482096f, -0.00574106f, 0.13453655f, 0.06333619f, 0.10317659f, 0.08267213f, 
    0.04526393f, -0.02835481f, 0.06388643f, -0.06316495f, 0.13645253f, -0.02171416f, 0.07382295f, 0.04287032f, 
    0.05673783f, 0.01124929f, 0.02260120f, -0.00736233f, 0.02005248f, 0.05016391f, 0.05785481f, -0.01065736f, 
    0.24571361f, -0.00319397f, 0.14937901f, -0.02920599f, -0.20704252f, -0.10643726f, -0.01008577f, -0.04354352f, 
    0.02363934f, 0.13267483f, -0.09498800f, 0.03947740f, -0.03425911f, -0.09131955f, 0.03548764f, -0.00812054f, 
    0.29762453f, 0.06020137f, -0.05202563f, -0.27563414f, -0.02735366f, 0.00580226f, -0.01398017f, 0.02649534f, 
    -0.15911683f, -0.12176605f, -0.03610491f, 0.01746845f, 0.25086883f, 0.20758532f, -0.03752279f, 0.30574289f, 
    0.07767859f, 0.00922279f, 0.08474123f, 0.15198965f, 0.15165052f, 0.11671919f, 0.08942942f, -0.05722763f, 
    -0.45173752f, -0.30202100f, -0.24982606f, 0.02103941f, -0.03306076f, -0.01276356f, 0.04371098f, -0.00552340f, 
    -0.10281892f, -0.01113594f, -0.11806241f, -0.05244960f, -0.02325786f, 0.10177952f, 0.06097566f, -0.23118676f, 
    -0.03547509f, -0.04196294f, 0.03906459f, 0.09281961f, 0.04965153f, 0.07087980f, 0.10011112f, 0.05617728f, 
    -0.07060106f, 0.01307731f, -0.35397905f, -0.31854135f, -0.01636975f, 0.02082144f, 0.00796551f, -0.09517551f, 
    -0.01634636f, 0.00868728f, -0.01494713f, -0.03284309f, 0.32951352f, -0.03401105f, -0.28997546f, -0.14564210f, 
    0.06470746f, -0.04710461f, -0.06968082f, 0.17842001f, 0.11414669f, 0.17423405f, 0.09534727f, -0.08315198f, 
    0.13632786f, -0.01443254f, -0.17585219f, -0.11365922f, 0.08773563f, -0.08509357f, 0.09652045f, 0.10868289f, 
    0.08929233f, 0.17323287f, 0.17504346f, 0.05218552f, 0.09962505f, 0.01351157f, 0.08357607f, 0.06755950f, 
    -0.04624056f, -0.01995648f, 0.01535143f, 0.00576676f, 0.33829123f, 0.26120862f, -0.05696717f, 0.11737521f, 
    -0.23464032f, -0.16905218f, -0.31374606f, -0.19937989f, 0.14885704f, 0.15326340f, -0.01938454f, 0.09876700f, 
    -0.08090435f, -0.01292637f, -0.06596366f, 0.02103026f, 0.14744215f, 0.35753000f, 0.09736429f, 0.15201059f, 
    0.00601116f, 0.03457710f, -0.02304021f, 0.02805259f, -0.00676047f, 0.04352010f, 0.03672563f, 0.21785705f, 
    -0.10402789f, -0.05275752f, -0.00752270f, 0.02631831f, 0.00153577f, 0.22365288f, -0.04268013f, 0.09230346f, 
    0.21292709f, -0.09709080f, -0.01778164f, 0.03017002f, 0.23085627f, 0.13185965f, 0.19372927f, 0.14990361f, 
    -0.02196660f, -0.00660156f, -0.04172540f, 0.03213461f, 0.03621797f, 0.11540448f, 0.01884737f, 0.16049753f, 
    -0.22181067f, -0.28067321f, -0.05903085f, 0.01147465f, 0.06154126f, 0.02613072f, -0.17207883f, -0.01367418f, 
    -0.03230609f, -0.02985402f, -0.04579956f, 0.01785140f, -0.26290345f, -0.39857510f, -0.29083252f, -0.07209110f, 
    0.13781270f, 0.12917106f, -0.04628910f, 0.06663422f, -0.05019910f, -0.06693255f, 0.02615808f, -0.01603219f, 
    -0.28721592f, -0.11649488f, -0.06883895f, -0.04682253f, -0.07753385f, 0.15187454f, -0.06269713f, -0.01452692f, 
    0.10284113f, -0.11049832f, -0.02680738f, -0.05908091f, -0.14146182f, -0.15881966f, -0.37113777f, -0.24521160f, 
    0.03788015f, 0.08936130f, -0.08795638f, 0.08187264f, -0.09095926f, -0.06550813f, -0.05716707f, -0.03935982f, 
    0.14899682f, 0.13933533f, 0.15260908f, 0.07268634f, -0.05490671f, -0.01796615f, 0.02417186f, 0.01315838f, 
    0.09442906f, 0.07548948f, 0.00897873f, 0.02802186f, 0.05729545f, 0.03545413f, 0.08934026f, 0.11900461f, 
    -0.01917854f, 0.05528707f, -0.02771694f, 0.00907238f, 0.00203810f, -0.01092592f, -0.00952879f, 0.02635217f, 
    -0.25133336f, -0.37047052f, -0.14377417f, 0.13080196f, 0.08482864f, 0.11252286f, -0.06368407f, 0.04654479f, 
    0.03020511f, 0.00831954f, 0.03139970f, -0.07699284f, -0.01808226f, 0.14737462f, -0.07508881f, 0.07381510f, 
    0.00031518f, 0.15472437f, 0.02642429f, -0.22005297f, -0.04873628f, 0.03110571f, 0.01893899f, 0.02642727f, 
    0.01363339f, -0.00739321f, 0.05569268f, -0.01052341f, -0.03492223f, -0.01003897f, 0.03812469f, -0.08225381f, 
    -0.08041395f, -0.04188178f, -0.03970811f, 0.02475550f, -0.33141479f, -0.24655633f, -0.09789731f, -0.13293558f, 
    -0.07396413f, -0.00726478f, -0.01658542f, 0.18915656f, -0.11797228f, -0.14840078f, -0.09500609f, -0.12947670f, 
    0.17892727f, 0.12461736f, -0.03545477f, 0.03350418f, 0.06207475f, 0.02667821f, 0.05896788f, 0.11490301f, 
    0.27462268f, 0.27348277f, 0.17246440f, -0.00594144f, -0.35970497f, -0.32149664f, -0.28575355f, 0.09437852f, 
    0.04733944f, 0.05830123f, 0.03060543f, 0.05541835f, -0.01938164f, -0.04078277f, -0.04182997f, -0.01523602f, 
    -0.00044062f, -0.06056894f, 0.03193729f, -0.00761155f, 0.01748816f, 0.23657306f, 0.07761406f, 0.07090826f, 
    0.17460378f, -0.06659171f, 0.03161750f, -0.00788860f, -0.16471224f, -0.03877591f, -0.12722315f, 0.00842016f, 
    -0.16516872f, -0.00542539f, -0.01187831f, 0.08112328f, -0.06544808f, -0.10201397f, -0.03843824f, 0.03555327f, 
    -0.14341079f, -0.47483316f, -0.00506213f, 0.11839566f, 0.16871873f, -0.02282084f, 0.01381274f, -0.16246967f, 
    -0.09173223f, -0.01274439f, -0.10459778f, -0.01029651f, 0.04672181f, 0.12948802f, -0.29521099f, 0.00147179f, 
    -0.05492912f, 0.07382755f, 0.01498623f, 0.17084061f, 0.22674701f, 0.06148686f, 0.10647164f, -0.15382808f, 
    0.00131226f, 0.03879822f, 0.07512652f, 0.04858704f, 0.01131979f, 0.00380876f, 0.01330409f, -0.03124253f, 
    0.11246398f, -0.09000237f, 0.00241658f, 0.07094775f, 0.05849703f, 0.12559362f, 0.04086701f, 0.02187213f, 
    0.02122586f, 0.03748775f, -0.05143198f, -0.06076058f, -0.03501246f, -0.05864433f, 0.00599381f, -0.04114496f, 
    0.08962456f, 0.00994638f, 0.16343613f, -0.10413752f, -0.04080442f, -0.06525821f, -0.02582335f, 0.06547664f, 
    -0.02368123f, -0.11828128f, -0.06987812f, 0.06320936f, -0.14965990f, -0.16488591f, -0.08194243f, 0.13660072f, 
    0.04149555f, 0.04338462f, 0.01364702f, 0.08659412f, -0.09602771f, 0.03250818f, 0.09148648f, -0.01867539f, 
    0.30996147f, -0.07256139f, 0.01650084f, 0.17044729f, -0.00256104f, -0.04322789f, 0.07956599f, -0.03131078f, 
    -0.03748984f, 0.02923900f, -0.01081682f, 0.10535523f, 0.04487017f, 0.02718332f, 0.02587410f, -0.00276764f, 
    -0.03324519f, -0.02623078f, -0.01495990f, -0.01904032f, -0.00308077f, -0.11881617f, -0.08251181f, -0.07222141f, 
    -0.09997419f, -0.12455644f, 0.14518069f, -0.11008482f, 0.13850121f, -0.11317772f, 0.02294700f, 0.10178620f, 
    0.02294897f, 0.02784195f, 0.14486146f, 0.13890050f, 0.05013938f, 0.17000681f, -0.04183279f, 0.19976836f, 
    0.01687270f, 0.05902948f, 0.00263410f, 0.12680949f, -0.01880295f, -0.00166951f, 0.10626788f, 0.01072564f, 
    -0.12094817f, -0.13996944f, -0.02785230f, -0.04182743f, 0.01625052f, -0.03649794f, -0.07816621f, 0.06092088f, 
    -0.06676423f, 0.05224992f, -0.00472533f, -0.01757715f, -0.21904247f, -0.37869599f, 0.06898823f, 0.02933705f, 
    0.05062850f, -0.10052910f, -0.04134976f, -0.00994775f, 0.00807554f, -0.01557795f, 0.07747744f, 0.03983287f, 
    0.31258887f, 0.20491953f, 0.09378117f, -0.00410822f, 0.04562761f, 0.07582807f, 0.02810800f, 0.09265342f, 
    -0.04046754f, 0.05919619f, -0.00323856f, -0.03919946f, 0.13656652f, 0.08771813f, -0.01681181f, -0.11770394f, 
    0.08783833f, -0.10889259f, 0.05504797f, -0.05912124f, 0.00477650f, -0.06185968f, 0.15003945f, -0.11486982f, 
    -0.46979082f, -0.07315153f, -0.02919697f, 0.07568688f, -0.02683529f, 0.00304734f, -0.07440614f, -0.03320798f, 
    0.17565335f, -0.01940611f, 0.02836630f, -0.02657091f, 0.14395542f, 0.06758486f, 0.18810214f, 0.01880189f, 
    -0.05790855f, 0.00181148f, 0.09214398f, -0.03376558f, 0.10080236f, 0.22814856f, 0.10179146f, 0.24312331f, 
    -0.04691333f, 0.06440078f, 0.25679144f, 0.06090445f, 0.05505224f, 0.02878957f, -0.06995314f, -0.03477335f, 
    0.04932588f, 0.00223324f, -0.13081343f, -0.00936976f, 0.00819105f, -0.03150586f, -0.02457514f, 0.07570174f, 
    -0.00066478f, 0.00870823f, 0.02551514f, -0.01016807f, -0.02673335f, 0.03772447f, 0.09648279f, 0.26361838f, 
    0.05557008f, 0.01772164f, -0.11204074f, -0.02292251f, -0.01727607f, 0.00926039f, 0.14232513f, -0.02390674f, 
    0.08066607f, -0.06329539f, -0.03629126f, 0.05689553f, 0.16637371f, 0.06808959f, -0.00248177f, 0.12874554f, 
    0.09769265f, 0.08580887f, 0.06293656f, 0.06951778f, 0.00167433f, 0.01535715f, 0.11278747f, 0.02955558f, 
    -0.07290204f, 0.00582751f, -0.16101135f, 0.09680619f, 0.08495297f, -0.03207704f, 0.02832397f, 0.00619820f, 
    -0.01130739f, -0.03738145f, -0.16744721f, -0.20082085f, -0.08205130f, -0.24712355f, -0.03733575f, 0.08420935f, 
    -0.00381039f, -0.00837899f, 0.03279899f, 0.13555695f, 0.06474447f, -0.02863501f, -0.03778265f, 0.10452315f, 
    -0.07975572f, -0.04737034f, 0.07832029f, -0.10225084f, 0.01463620f, -0.00761735f, -0.14086099f, -0.00657168f, 
    -0.00056451f, -0.00024606f, -0.03565517f, -0.23610349f, 0.10945904f, -0.07974309f, -0.06794479f, 0.08915155f, 
    0.05708027f, -0.00797699f, -0.06183630f, 0.12238734f, -0.00679455f, -0.01947654f, -0.00439925f, 0.12512967f, 
    -0.24229001f, -0.12556942f, -0.14134552f, -0.00841720f, 0.04499953f, 0.05257756f, 0.15053786f, -0.00896980f, 
    0.02400905f, -0.05710034f, -0.03656477f, -0.05585063f, 0.23701479f, 0.05611523f, -0.15467939f, -0.09824160f, 
    0.07509629f, 0.06175535f, 0.16396688f, 0.16787685f, -0.04922049f, -0.00488143f, 0.13682272f, 0.14840820f, 
    0.03508513f, 0.06552789f, 0.01654474f, 0.09174224f, 0.07305192f, -0.04132007f, 0.06864081f, -0.02738502f, 
    0.00354256f, -0.04576652f, 0.02500488f, 0.03068551f, 0.11726025f, 0.03435510f, -0.06688061f, 0.00949337f, 
    0.02917086f, 0.00059797f, 0.03091115f, 0.09196857f, 0.06330231f, 0.02850983f, -0.04364370f, -0.10176326f, 
    -0.30971751f, -0.12902617f, -0.13802694f, -0.06373415f, 0.02224394f, -0.13574238f, -0.07624932f, -0.04269009f, 
    0.00459426f, -0.05371524f, 0.01164414f, 0.07422317f, -0.15363476f, -0.08852795f, 0.15884124f, -0.19087264f, 
    0.06519057f, -0.00837493f, -0.00967376f, 0.01684536f, 0.17774741f, 0.06220651f, 0.02886173f, -0.02358430f, 
    0.18460451f, 0.17860880f, 0.05412236f, 0.18901587f, 0.05525998f, -0.04470416f, 0.09169577f, 0.00543205f, 
    -0.12742884f, -0.07279768f, 0.02824075f, -0.06281742f, 0.01139745f, -0.10492168f, -0.01596035f, -0.03529087f, 
    -0.01582196f, -0.15091456f, -0.12118048f, 0.08294535f, 0.06798156f, -0.10390124f, 0.01245951f, 0.11349033f, 
    -0.05058759f, -0.07417929f, -0.04874226f, -0.07348672f, -0.03761262f, -0.08893123f, -0.02988393f, -0.01807789f, 
    0.06522354f, 0.05103697f, 0.13753629f, 0.14729160f, -0.00883458f, -0.07454683f, 0.07634751f, -0.06133468f, 
    -0.10763365f, -0.04123525f, -0.08148705f, 0.18211913f, -0.01460365f, -0.01699138f, -0.04383584f, 0.03978980f, 
    0.12760539f, 0.05315939f, -0.06309061f, -0.08886508f, -0.00397368f, 0.04023080f, 0.12775305f, -0.03205074f, 
    0.03243719f, -0.07839423f, 0.09834611f, 0.10676787f, -0.22754313f, -0.16520537f, -0.00049847f, 0.03818777f, 
    0.06757634f, 0.02206873f, -0.03209523f, -0.04421531f, 0.05168985f, -0.00034780f, -0.04741252f, -0.07518035f, 
    -0.16584903f, -0.13898616f, -0.06036736f, -0.03853515f, -0.00093478f, 0.01188845f, -0.06009679f, -0.03787473f, 
    -0.00321991f, -0.00976160f, -0.04201623f, 0.04167984f, 0.49733236f, 0.04003026f, -0.19046406f, 0.02106218f, 
    0.03912994f, 0.04696025f, -0.15062252f, 0.22533509f, 0.00686531f, 0.10870187f, 0.01203078f, 0.07669760f, 
    -0.21894325f, 0.25741985f, 0.00502880f, 0.01177568f, -0.01035185f, 0.05617240f, 0.00555469f, 0.10613527f, 
    0.03538056f, -0.17933695f, -0.09253461f, -0.09121098f, -0.02757639f, -0.09127953f, 0.07881986f, -0.03393365f, 
    0.11247122f, -0.01426046f, 0.03055827f, 0.02245063f, -0.03376818f, 0.02947254f, 0.00786873f, 0.04996649f, 
    0.00450560f, -0.13011438f, 0.00314946f, 0.04230743f, -0.00006867f, -0.12246227f, -0.13001129f, 0.01870398f, 
    0.05193697f, 0.06327008f, 0.03711277f, -0.08419235f, 0.03575311f, 0.04248856f, 0.08427364f, 0.12967846f, 
    -0.09181646f, 0.01715004f, -0.12463813f, 0.06950954f, 0.17941934f, -0.03358369f, 0.02419135f, 0.09883443f, 
    0.04817165f, -0.05291442f, -0.10210475f, 0.08830233f, 0.02558628f, 0.10027647f, 0.14929064f, 0.05812029f, 
    0.08087394f, 0.06166257f, 0.10381782f, 0.00367385f, -0.05981183f, -0.06555893f, -0.11723306f, -0.02347293f, 
    -0.00385225f, 0.15315546f, -0.03516984f, -0.07542085f, 0.02875127f, -0.12972824f, 0.04056814f, -0.01584564f, 
    -0.15998217f, -0.24138847f, 0.16688083f, -0.01089960f, -0.05429969f, -0.00870076f, -0.12144302f, -0.11516076f, 
    0.08824408f, 0.02767341f, 0.02664983f, 0.07964540f, -0.31813404f, -0.15575662f, -0.20970756f, -0.05065734f, 
    0.03131706f, -0.04200404f, -0.02427565f, -0.07654398f, 0.09354169f, -0.05636649f, 0.00472985f, -0.03569069f, 
    0.25621331f, 0.08076891f, -0.12452345f, 0.00923765f, 0.08972167f, 0.02037692f, -0.08530988f, 0.05384996f, 
    0.06622977f, 0.05339291f, 0.05747344f, 0.07376313f, 0.04450617f, -0.26324755f, 0.16556540f, -0.33211109f, 
    -0.02048775f, -0.08525459f, 0.05217060f, -0.04128636f, 0.05470098f, 0.06364302f, 0.05527199f, 0.07840647f, 
    -0.02129988f, 0.06673857f, 0.04797895f, 0.11358529f, -0.14784878f, -0.10648582f, -0.05165721f, 0.02975451f, 
    -0.07117130f, 0.07040115f, 0.03041407f, -0.20931695f, -0.32138276f, -0.17083728f, 0.05923351f, -0.16836496f, 
    -0.00652427f, -0.06305341f, -0.05619072f, 0.00920978f, 0.13853562f, -0.02701112f, 0.02148305f, 0.13310060f, 
    0.06352902f, 0.23388216f, 0.11849467f, -0.02116639f, -0.03448040f, -0.01088787f, 0.00519635f, 0.03894132f, 
    0.07278783f, 0.00404772f, 0.01442747f, -0.01738061f, 0.12598443f, 0.04449844f, 0.00432936f, 0.01205916f, 
    0.08522360f, 0.09004338f, 0.06101412f, 0.18760251f, 0.13820201f, 0.08694688f, 0.07027311f, 0.04926717f, 
    0.07006534f, -0.02914261f, 0.06171856f, 0.03957934f, 0.12219107f, -0.02352666f, 0.00380590f, 0.02257869f, 
    -0.04273152f, -0.07020614f, -0.04061877f, 0.02741340f, -0.00851915f, -0.13763605f, -0.03228015f, 0.09370586f, 
    0.06427780f, 0.02965101f, 0.04636410f, -0.02463500f, 0.03510064f, -0.01430796f, -0.03709688f, 0.13338199f, 
    -0.34851980f, 0.16345200f, -0.21648586f, 0.11643553f, -0.01327695f, -0.04584568f, -0.07157692f, -0.05101968f, 
    0.04936370f, 0.03842973f, 0.09061144f, 0.17088793f, 0.02262072f, -0.06012010f, -0.06827249f, -0.16580370f, 
    -0.08903005f, -0.02539832f, -0.03738827f, -0.07958697f, 0.09106982f, -0.00856924f, -0.02750068f, 0.25614479f, 
    -0.03175782f, 0.24825244f, 0.06999212f, -0.02722078f, -0.05047299f, 0.10183700f, -0.13372734f, 0.01118201f, 
    -0.03468992f, 0.05600300f, -0.05323751f, 0.07592043f, 0.00133208f, 0.01116704f, -0.20870714f, -0.03507803f, 
    -0.04919463f, 0.09396891f, -0.06033725f, 0.01447278f, -0.02035284f, -0.00438607f, -0.05450017f, -0.00320654f, 
    -0.12617302f, -0.10974948f, -0.04274976f, -0.03561825f, -0.01467724f, 0.11980516f, -0.01540900f, 0.11528333f, 
    0.11914667f, 0.10248879f, 0.06757908f, 0.06937840f, -0.09176882f, -0.18530031f, -0.07176646f, 0.02984679f, 
    0.04494047f, 0.00617900f, 0.06658246f, 0.17294715f, -0.08703957f, -0.04597417f, 0.05835810f, 0.00027226f, 
    -0.24284285f, -0.15983960f, -0.01441202f, 0.00652333f, 0.05277246f, -0.04407480f, -0.01488367f, -0.01497198f, 
    0.08366308f, -0.07169943f, 0.11855014f, 0.00555865f, -0.05972196f, 0.04042387f, -0.05496305f, 0.01452569f, 
    0.03966380f, 0.06547089f, 0.00306158f, -0.11626510f, 0.01877753f, 0.02192276f, -0.02734548f, -0.01826477f, 
    0.00301525f, -0.18272375f, -0.08562966f, -0.12660375f, 0.08176589f, -0.18553847f, -0.06502714f, 0.07542805f, 
    0.08589371f, 0.04622631f, -0.09760821f, -0.17458038f, 0.19819808f, 0.20633775f, -0.06549463f, 0.07297406f, 
    -0.03645498f, 0.15203950f, -0.02809014f, 0.22619031f, 0.01128137f, 0.09919886f, 0.06863457f, 0.07286954f, 
    -0.04281457f, 0.09218884f, 0.05894316f, 0.16827907f, 0.05044794f, 0.13413990f, 0.06948614f, 0.01023570f, 
    0.03416340f, 0.03003650f, 0.07121508f, -0.03081684f, -0.04047624f, 0.28032267f, -0.08253601f, 0.23828636f, 
    -0.02720604f, -0.00015706f, -0.05155372f, -0.01228245f, -0.01483690f, -0.04552560f, 0.04239773f, 0.04911702f, 
    -0.24773337f, -0.19473529f, 0.02468979f, 0.14459257f, 0.01613840f, -0.09501644f, -0.11722171f, -0.01811628f, 
    -0.04657553f, -0.00916377f, -0.10173376f, 0.04558988f, 0.09343123f, -0.02220383f, -0.04416169f, 0.23188685f, 
    -0.01219786f, 0.10484222f, -0.03020046f, 0.08195495f, 0.02405412f, 0.02054128f, 0.01677656f, -0.00430186f, 
    0.54358208f, 0.28543788f, -0.18707377f, 0.11040060f, 0.01491073f, 0.06130758f, -0.05168541f, -0.07951973f, 
    0.06365149f, -0.04932604f, -0.07142812f, 0.04024398f, 0.10618667f, 0.14051123f, 0.08245286f, 0.10403350f, 
    0.04328374f, -0.07675511f, 0.03793826f, -0.06048508f, -0.11944767f, -0.06694700f, -0.03443915f, -0.06175425f, 
    -0.08986417f, -0.12729865f, -0.12510552f, -0.05084256f, 0.06613341f, -0.04815887f, 0.08097596f, -0.01682734f, 
    0.09507962f, -0.06870517f, 0.20100984f, 0.11762091f, -0.23215428f, -0.11153753f, -0.12180092f, -0.05293650f, 
    0.00292226f, -0.07286701f, -0.07642005f, -0.03472586f, 0.00719505f, 0.03113765f, 0.03733288f, 0.09862497f, 
    0.02164371f, -0.03149803f, 0.03552477f, 0.00139978f, -0.01195220f, -0.00345741f, -0.02841301f, -0.00053599f, 
    -0.01161582f, -0.00972290f, 0.00514422f, 0.01157780f, -0.03841625f, -0.02467335f, -0.00629284f, 0.00650263f, 
    -0.02861865f, -0.03094472f, -0.03313375f, -0.04068210f, 0.00666821f, 0.00839241f, -0.02443163f, -0.01697936f, 
    0.01809277f, 0.03209351f, 0.00389425f, 0.03324618f, -0.02531577f, -0.02771445f, -0.03555615f, 0.00059004f, 
    -0.00325936f, -0.00753340f, 0.00705970f, -0.02851410f, -0.02890583f, -0.01112222f, -0.02114199f, -0.01647262f, 
    0.02152174f, -0.01413316f, 0.00774898f, -0.00652771f, -0.01005077f, -0.00921132f, -0.00380138f, -0.03778571f, 
    -0.02051579f, -0.00128992f, 0.01034448f, -0.03139541f, -0.03239520f, 0.01545358f, -0.03479245f, -0.01511103f, 
    -0.00762870f, 0.01046317f, -0.03050653f, 0.00887815f, -0.03464353f, 0.01211439f, -0.03149846f, 0.02718417f, 
    -0.01237540f, -0.01107632f, -0.01872330f, 0.02592859f, -0.04188453f, 0.02735572f, -0.01442754f, 0.01217522f, 
    -0.02736961f, 0.02489581f, -0.01858410f, -0.00785046f, -0.01604857f, 0.02502870f, 0.00570160f, 0.02951196f, 
    -0.03871160f, 0.00540569f, 0.00034974f, -0.02455397f, -0.03164586f, -0.03466283f, -0.01789249f, 0.00263155f, 
    -0.00853098f, -0.02456513f, -0.02029339f, 0.02910400f, -0.02082918f, -0.02090344f, 0.02569853f, -0.00524760f, 
    0.01570686f, -0.00404461f, -0.00580897f, 0.02180230f, 0.00797490f, 0.01936975f, 0.01500253f, -0.02749131f, 
    -0.03910315f, -0.01366324f, -0.01407692f, -0.02483829f, 0.01110201f, 0.02364577f, 0.01449474f, -0.00893685f, 
    -0.01797715f, -0.02328943f, -0.00659407f, -0.04015082f, 0.01994926f, -0.00315476f, 0.01309819f, 0.01972241f, 
    -0.03550271f, -0.00792257f, 0.01142053f, -0.00384044f, -0.02040459f, -0.00969094f, 0.02197622f, -0.00489738f, 
    -0.02497073f, 0.01386782f, -0.02473028f, 0.02485417f, 0.02569986f, -0.00910527f, 0.02880112f, 0.02526418f, 
    0.01785250f, -0.00827726f, -0.01460443f, -0.03998025f, 0.00203208f, -0.01485680f, 0.00065515f, 0.02791223f, 
    -0.02874978f, -0.02223757f, 0.02196030f, 0.01697291f, 0.01100540f, -0.00491638f, -0.00314809f, -0.01478098f, 
    -0.03667484f, 0.02152564f, -0.01445281f, -0.02549631f, 0.00006772f, -0.01770727f, -0.02821979f, 0.01496760f, 
    -0.02255422f, 0.00804452f, -0.01367802f, -0.02984282f, 0.02171735f, 0.00806564f, 0.01910103f, -0.01345719f, 
    0.02603713f, -0.00333005f, -0.03621356f, 0.00892918f, -0.01078062f, -0.00543714f, -0.03221022f, -0.04115660f, 
    0.01101892f, -0.00268684f, -0.01831003f, 0.00034699f, -0.03303743f, 0.01526294f, 0.00839048f, 0.02969898f, 
    0.01386668f, -0.02982515f, -0.02823156f, 0.01902377f, -0.01414209f, -0.03696503f, -0.04086747f, 0.00252711f, 
    0.00116070f, -0.00099268f, 0.00403577f, 0.00789467f, 0.00516503f, 0.02992872f, -0.02383160f, 0.00100521f, 
    -0.02735208f, -0.03695617f, -0.04098751f, -0.04050149f, -0.02720163f, -0.00370707f, -0.01074629f, -0.02582200f, 
    -0.03876984f, 0.00234088f, -0.03002170f, -0.01304236f, -0.02594346f, -0.01556790f, -0.03933166f, -0.01637660f, 
    -0.01526249f, -0.00393749f, 0.02482473f, -0.00886663f, 0.01911922f, 0.00959878f, 0.01321147f, 0.02938614f, 
    -0.01670451f, -0.01048998f, 0.01928496f, 0.00759906f, -0.00981037f, -0.03698182f, 0.01162733f, 0.00175043f, 
    -0.00951393f, -0.01404294f, 0.01490228f, 0.00498009f, -0.00492578f, -0.01483999f, 0.01442868f, 0.00256194f, 
    -0.03470633f, -0.01449399f, 0.01019579f, -0.03096725f, -0.01294274f, 0.00020546f, -0.00833017f, 0.00546004f, 
    -0.02091349f, 0.00908385f, 0.00704999f, -0.00004968f, -0.02206000f, -0.01032050f, 0.01306609f, 0.02928581f, 
    0.02565256f, 0.00881139f, -0.03154847f, -0.02760462f, -0.01186359f, -0.00901324f, 0.00767189f, -0.02666591f, 
    0.01682422f, -0.02839658f, -0.00758936f, 0.02051464f, 0.01328472f, -0.03713346f, 0.00675053f, -0.03518255f, 
    0.00320994f, -0.01130946f, 0.00091727f, -0.00408140f, -0.03533951f, -0.02823693f, 0.00449067f, 0.02575860f, 
    0.01264988f, -0.01186573f, -0.00559972f, 0.00432726f, -0.02637098f, -0.00763419f, -0.01046913f, -0.02417196f, 
    0.03155398f, -0.00018989f, 0.02166595f, -0.03595782f, -0.02470262f, 0.01035605f, -0.03231506f, 0.00003627f, 
    0.00405138f, -0.00227489f, -0.02374906f, -0.02328065f, -0.03435833f, -0.03062389f, -0.03797375f, -0.00348645f, 
    0.02904664f, 0.01856828f, -0.02505873f, 0.00592063f, -0.01166555f, 0.02653044f, 0.02307374f, -0.00674346f, 
    0.00029950f, -0.03744649f, 0.02606701f, -0.02272737f, -0.02910361f, 0.01701743f, -0.00726498f, 0.02523631f, 
    0.01608738f, 0.01889712f, 0.01641722f, -0.04138901f, 0.02504000f, 0.01005538f, -0.02722416f, -0.03728998f, 
    -0.02906310f, -0.02225353f, -0.02830374f, -0.03681621f, -0.03017745f, -0.02195121f, 0.02186093f, -0.01905798f, 
    -0.01132442f, -0.02850534f, -0.03719470f, 0.02409741f, 0.01612101f, 0.00803055f, -0.02837777f, 0.02815684f, 
    -0.01334972f, -0.02503951f, 0.02069287f, -0.03716165f, 0.02827921f, -0.01007684f, -0.02591169f, -0.03307306f, 
    -0.03259812f, -0.00456859f, 0.01595210f, -0.03233460f, 0.02022153f, -0.02454809f, -0.02174078f, -0.00803922f, 
    0.02737704f, -0.02179575f, 0.02968565f, -0.01310208f, -0.01260502f, -0.00972833f, 0.01477066f, -0.02913933f, 
    0.02803472f, 0.01550309f, 0.02447467f, -0.02153641f, 0.00645824f, 0.01329392f, -0.01912476f, 0.00448278f, 
    0.02462436f, 0.01374887f, 0.01250478f, 0.00347914f, -0.03845594f, 0.01919271f, -0.00986494f, 0.02283154f, 
    0.00052541f, -0.00057831f, -0.02207845f, -0.02139253f, -0.02305588f, 0.01778918f, 0.00178050f, 0.00720556f, 
    -0.03091493f, -0.03300153f, -0.00729210f, -0.01088211f, -0.02995240f, -0.02980473f, 0.01696461f, 0.01510087f, 
    -0.01746704f, -0.00214464f, 0.01854578f, -0.02639291f, -0.03879584f, -0.04201744f, -0.03702140f, -0.00169614f, 
    0.00969731f, 0.00094553f, 0.01761564f, 0.01795407f, -0.02075401f, -0.03820411f, 0.00045630f, -0.02167101f, 
    -0.03078849f, 0.03353876f, 0.00786589f, -0.02532929f, -0.02905894f, 0.00522261f, -0.02523158f, 0.02827580f, 
    0.02667292f, -0.03813085f, -0.00972288f, -0.03723729f, -0.00653896f, -0.04193914f, -0.02550402f, -0.00354761f, 
    -0.00523868f, -0.02049544f, -0.04082094f, 0.01438470f, 0.01550971f, 0.02042346f, -0.02580470f, -0.01737347f, 
    -0.00812828f, 0.02588367f, 0.02975371f, -0.03945848f, -0.00533008f, -0.01877703f, -0.00086555f, -0.00778306f, 
    -0.01631722f, -0.00012214f, 0.02634160f, 0.01418470f, 0.01044065f, -0.01557903f, 0.00517757f, -0.01338515f, 
    -0.03994972f, 0.00882902f, -0.00836121f, 0.00422278f, -0.00797042f, -0.04174198f, -0.00380838f, 0.02332679f, 
    0.01871910f, -0.00472751f, 0.00656083f, -0.02289744f, -0.02149367f, 0.01649977f, 0.02321610f, -0.02091420f, 
    -0.02113322f, 0.00854303f, 0.02132032f, -0.02091873f, -0.00281508f, -0.03616786f, -0.02778494f, -0.02626549f, 
    -0.03290451f, 0.01676760f, -0.00374957f, -0.03253792f, -0.00152128f, -0.00348242f, 0.00659259f, 0.01612900f, 
    -0.03542119f, 0.02164678f, -0.00768305f, -0.01075943f, 0.03357709f, -0.00293577f, -0.02672287f, -0.00152513f, 
    -0.03232501f, 0.01890479f, 0.01284509f, -0.02750509f, -0.01104407f, 0.01555774f, -0.01872509f, 0.00027404f, 
    0.00777820f, 0.01281630f, -0.04195403f, -0.01312059f, 0.00030948f, -0.01050030f, 0.00418031f, -0.02284294f, 
    0.01773693f, 0.02856690f, -0.01471374f, 0.00610623f, 0.01887166f, 0.00687939f, -0.00615046f, -0.02875642f, 
    0.01606990f, 0.00721569f, -0.03872353f, 0.02237506f, -0.03589049f, -0.03297173f, -0.02007877f, -0.03030382f, 
    -0.03308912f, -0.00272376f, -0.01647485f, 0.00196919f, -0.04141198f, 0.01062087f, -0.02127222f, -0.04154546f, 
    0.01320017f, 0.01601970f, 0.01506839f, -0.02786143f, 0.01064759f, 0.02897756f, 0.02310306f, -0.03521545f, 
    -0.00500202f, -0.01157131f, -0.03082105f, -0.02414219f, 0.01026490f, -0.01221023f, 0.02767249f, -0.00393539f, 
    0.02933978f, -0.01653759f, 0.00963848f, 0.02436393f, -0.00784746f, -0.04200888f, 0.02212861f, -0.00488429f, 
    0.01687776f, 0.00468999f, 0.02016174f, -0.02602661f, -0.00121017f, 0.00122046f, -0.02090291f, -0.01244196f, 
    0.02658438f, 0.02909164f, 0.02401717f, -0.02492703f, 0.01628739f, 0.01743283f, 0.00169343f, 0.00381208f, 
    0.02158450f, -0.02583722f, 0.02233884f, 0.02630126f, -0.00764242f, 0.00703004f, -0.02070807f, 0.01025081f, 
    -0.00659568f, -0.00542949f, 0.01211515f, -0.00241748f, 0.02146387f, 0.01844246f, -0.01934690f, -0.01766570f, 
    -0.02577353f, 0.02504379f, -0.00943972f, -0.03612965f, -0.03613865f, -0.00422578f, -0.01605405f, 0.01030902f, 
    -0.00727111f, 0.01424505f, -0.00831505f, 0.00963506f, 0.00807352f, -0.03476588f, -0.01726012f, -0.01205327f, 
    0.00638362f, 0.00269715f, -0.01797103f, -0.00274686f, -0.02909173f, -0.02899036f, 0.02254436f, 0.01943689f, 
    -0.01361587f, 0.02274424f, -0.03990376f, -0.00749233f, -0.00338823f, -0.03367237f, -0.00009022f, 0.01758705f, 
    -0.01047202f, 0.02480188f, 0.00783093f, -0.00077913f, 0.02479155f, -0.00168547f, -0.02377726f, -0.03748701f, 
    -0.03746197f, 0.00347749f, 0.01781742f, 0.02033711f, -0.04086469f, 0.00700277f, -0.02407706f, -0.00966965f, 
    -0.00180405f, 0.00257297f, 0.01937859f, 0.00565263f, -0.02588008f, 0.02159008f, -0.01221930f, -0.00337265f, 
    0.02716745f, -0.01577245f, 0.01054025f, -0.01635118f, -0.00173618f, -0.00536048f, 0.00259851f, 0.00788625f, 
    0.01800141f, -0.02404748f, -0.02811291f, 0.00579262f, 0.00495673f, 0.02654770f, 0.00611313f, 0.01663475f, 
    -0.02071254f, 0.01305786f, -0.02543314f, -0.01248656f, -0.02230632f, -0.01224462f, 0.00684552f, -0.03565054f, 
    0.02510080f, 0.00271438f, 0.00246113f, -0.00277359f, -0.00460854f, 0.01089750f, 0.00301037f, 0.02259187f, 
    -0.00092719f, 0.01915645f, -0.01506231f, 0.00563662f, 0.01487968f, 0.01548480f, -0.02032598f, -0.01997004f, 
    -0.01319150f, -0.02596924f, 0.01817801f, 0.01982068f, 0.00662946f, -0.02745449f, -0.01891857f, -0.00923691f, 
    0.01161446f, 0.02441397f, -0.03565276f, 0.02828669f, -0.03287910f, -0.03575951f, -0.01755857f, 0.01667905f, 
    0.02591676f, -0.00412166f, -0.01212324f, -0.00241550f, -0.02412716f, 0.00025863f, 0.01720590f, -0.00014421f, 
    -0.03826705f, -0.01734116f, -0.01112728f, -0.01131379f, 0.02169052f, -0.02178888f, -0.01888062f, -0.03216289f, 
    -0.01505870f, 0.02649528f, -0.01412064f, 0.01201888f, -0.02055091f, -0.03976235f, -0.02887710f, 0.02926632f, 
    -0.00242916f, -0.01449984f, 0.01610530f, -0.04128136f, -0.02741970f, -0.02042887f, 0.00225821f, -0.01414262f, 
    0.01707646f, -0.01880992f, 0.00681383f, -0.01411423f, -0.02058584f, -0.00724946f, 0.00164711f, -0.02472853f, 
    -0.01829982f, -0.03163385f, -0.01296133f, -0.00912450f, 0.02426661f, 0.00530870f, 0.00461017f, 0.02202360f, 
    -0.00097854f, 0.00976224f, -0.03895521f, 0.00257975f, -0.01290724f, 0.00047574f, -0.01053298f, 0.00756707f, 
    -0.01783199f, 0.02872486f, -0.03832432f, 0.00945090f, -0.00990486f, 0.02432388f, 0.01688185f, -0.03759541f, 
    -0.00184437f, 0.02691265f, -0.03608051f, 0.03042356f, -0.03092490f, -0.01522290f, -0.03877882f, -0.00860411f, 
    -0.01522356f, -0.03623531f, 0.01758145f, -0.02194185f, 0.01982867f, -0.03566821f, -0.02510805f, 0.02817100f, 
    -0.02449658f, -0.02350825f, 0.00014192f, -0.00940133f, 0.02645795f, 0.01385839f, -0.01641743f, -0.01331151f, 
    0.01625831f, 0.00733565f, -0.00111423f, -0.00835661f, 0.00376155f, -0.01625630f, 0.00702058f, 0.00886920f, 
    -0.02609914f, 0.00067583f, -0.03356784f, -0.00703005f, -0.01158301f, 0.00182314f, -0.03592558f, 0.00777136f, 
    -0.02070529f, -0.01576723f, -0.02750770f, 0.02329531f, -0.04123806f, -0.01060758f, -0.01511281f, 0.00985654f, 
    0.00220520f, 0.02829550f, -0.00851921f, -0.02458724f, 0.01602942f, -0.01514711f, -0.03768181f, -0.01342164f, 
    -0.04073398f, 0.02771320f, 0.01217654f, -0.01870201f, -0.01923923f, -0.00793577f, -0.02723265f, -0.00705898f, 
    -0.01678499f, -0.02343774f, 0.01489609f, -0.02931641f, 0.01548341f, 0.01102700f, 0.02906036f, 0.01852259f, 
    -0.03702559f, -0.03865697f, -0.03145285f, -0.02650025f, -0.02917539f, 0.01509228f, -0.01541082f, -0.00746825f, 
    0.00608975f, 0.00635208f, 0.01130495f, 0.02886772f, -0.02261003f, -0.00333109f, 0.00840464f, -0.01655206f, 
    -0.02945768f, 0.02652442f, -0.03636582f, 0.01556863f, -0.01763355f, -0.02909670f, 0.02859473f, 0.00192816f, 
    -0.00243884f, 0.01865672f, -0.02732340f, -0.00106843f, -0.01294498f, 0.02068278f, 0.00304783f, -0.01191484f, 
    -0.01719084f, 0.02805582f, -0.03480511f, -0.00756733f, -0.01764484f, -0.02630992f, -0.01158980f, -0.01367514f, 
    -0.02628334f, 0.01764635f, -0.03812670f, -0.02760844f, -0.00133553f, 0.00781392f, 0.03482907f, -0.03161051f, 
    0.01591055f, 0.01855392f, -0.02310769f, 0.03600420f, -0.02708793f, 0.01053627f, -0.04105787f, -0.01687139f, 
    -0.01426533f, -0.00975980f, 0.01590473f, -0.01491150f, -0.03355474f, -0.00756198f, -0.00028923f, -0.00779405f, 
    -0.03663032f, -0.02196445f, -0.03961208f, 0.02669599f, -0.03197071f, -0.02608959f, 0.01169149f, 0.01732577f, 
    0.00976010f, 0.01497536f, -0.02329223f, 0.02180190f, -0.01806482f, 0.01018922f, 0.01520148f, -0.00868712f, 
    0.00852582f, -0.01400303f, -0.01162615f, 0.02409531f, 0.01622454f, -0.01924503f, -0.02087094f, -0.01302317f, 
    0.01291911f, -0.01189896f, 0.01060053f, 0.01542630f, -0.04127442f, 0.01657568f, 0.01899709f, 0.00063630f, 
    -0.00539241f, -0.01746441f, -0.00712795f, -0.02024384f, -0.03962755f, 0.03049089f, 0.01030204f, 0.00524323f, 
    0.01764165f, -0.00893526f, 0.00638380f, 0.01850068f, 0.02824605f, -0.02202424f, -0.00287060f, 0.02965830f, 
    -0.00626009f, -0.03288294f, 0.00614048f, -0.03375778f, 0.02162967f, -0.03701378f, -0.03012647f, -0.00638977f, 
    0.00204203f, -0.00869538f, -0.03253113f, -0.01408073f, -0.02232445f, -0.02341021f, -0.00844033f, 0.02864919f, 
    -0.03760610f, -0.00425424f, 0.01254047f, -0.03718306f, 0.02059850f, -0.01215828f, -0.01993224f, 0.00692024f, 
    0.00714122f, -0.00868080f, 0.00622691f, -0.01803379f, -0.00856370f, 0.01640422f, 0.00534512f, -0.01308779f, 
    0.00000711f, 0.02365558f, -0.03029805f, -0.00389104f, 0.01882229f, 0.01516491f, 0.00955705f, 0.00909679f, 
    -0.03658424f, -0.02260786f, -0.01641141f, -0.01313588f, 0.01241580f, -0.02259252f, 0.02124022f, 0.02853069f, 
    -0.00198882f, -0.02035292f, -0.00281083f, -0.02735839f, -0.02682430f, -0.02720249f, -0.01020713f, 0.01549061f, 
    -0.03475121f, 0.00361991f, -0.02463241f, -0.03969650f, -0.03583285f, -0.01992046f, 0.00616611f, -0.01186807f, 
    -0.01663811f, -0.01653782f, -0.00001056f, 0.02340682f, -0.02336067f, 0.02975788f, -0.01149533f, -0.02465834f, 
    -0.01121512f, -0.00103931f, 0.01796903f, 0.03412085f, -0.01985207f, -0.03363654f, -0.01023877f, 0.02279616f, 
    -0.00334026f, 0.01634010f, -0.02886222f, 0.03039818f, 0.01196075f, 0.00447665f, -0.00490883f, 0.02517786f, 
    0.00711345f, -0.03223351f, -0.01526481f, -0.03605699f, -0.00659993f, -0.01737246f, 0.00351878f, -0.03153342f, 
    -0.03989461f, -0.01243942f, 0.00622335f, -0.00620879f, -0.01738894f, -0.01507767f, 0.00730749f, 0.00770232f, 
    0.01293769f, -0.00798884f, 0.00608949f, -0.01380244f, -0.00888737f, 0.01936491f, -0.00852941f, -0.00801498f, 
    -0.02027286f, -0.02695810f, 0.00379423f, 0.00107522f, -0.03242137f, -0.03059789f, 0.00117643f, 0.00762896f, 
    -0.01541253f, -0.03308297f, -0.03077520f, -0.02258562f, -0.02950838f, 0.00864070f, -0.03307436f, 0.02016462f, 
    0.01359616f, 0.01772002f, -0.03286320f, 0.01889349f, -0.00970618f, 0.01042085f, -0.03853974f, 0.00087884f, 
    -0.00142456f, 0.02746993f, 0.00992494f, -0.00399925f, -0.00210930f, 0.02441903f, -0.02754671f, -0.01790405f, 
    0.00974284f, -0.00526305f, -0.03567374f, 0.02595077f, 0.01934727f, -0.00356692f, -0.00966396f, -0.02643555f, 
    -0.01567422f, 0.01475365f, -0.00597899f, -0.01032826f, 0.01774718f, -0.02765248f, -0.02233515f, -0.00386320f, 
    0.00228426f, -0.03178828f, 0.02796016f, -0.00758271f, 0.02385033f, -0.02340645f, 0.01866232f, 0.00103995f, 
    -0.00350587f, 0.02265996f, 0.01049936f, -0.01932487f, -0.01221501f, 0.02055101f, -0.00549788f, -0.03851144f, 
    0.02060820f, 0.02681242f, -0.04135567f, -0.01311889f, -0.03999211f, -0.02946663f, -0.03542216f, -0.00608534f, 
    0.00969210f, 0.02982945f, 0.01805142f, 0.00837480f, 0.00731130f, -0.01336932f, 0.02915681f, 0.00516749f, 
    -0.03644779f, -0.00870619f, 0.02406013f, -0.03860795f, -0.01154790f, -0.00903796f, -0.01151054f, 0.02910179f, 
    -0.01915082f, -0.02407188f, -0.04044554f, -0.00448462f, -0.02670324f, -0.00656481f, -0.01186207f, 0.01031598f, 
    0.00184708f, 0.01927455f, -0.01696861f, -0.02876711f, 0.02051189f, -0.01692337f, -0.03527399f, -0.01350411f, 
    -0.01710731f, -0.02817321f, 0.02729513f, -0.03519467f, 0.00846286f, 0.00546992f, 0.02523318f, 0.00441990f, 
    -0.03871346f, -0.03506044f, -0.00932317f, 0.02434170f, 0.02366737f, 0.02204038f, -0.01902939f, 0.01124363f, 
    0.02919032f, 0.01263096f, -0.02805364f, 0.02228364f, 0.01546109f, -0.00316426f, -0.03529491f, 0.02059054f, 
    -0.02711057f, 0.01584812f, 0.01928209f, 0.01654732f, -0.02494748f, 0.01780887f, -0.03671983f, 0.01588453f, 
    -0.00530492f, -0.01868670f, -0.03185886f, 0.01811115f, -0.02153431f, 0.02602105f, -0.00034048f, 0.02735731f, 
    0.00265492f, -0.03870143f, 0.01549884f, 0.02558996f, 0.00145004f, -0.00205134f, -0.00091333f, -0.03391966f, 
    0.01711023f, 0.00892190f, 0.00170963f, -0.01027899f, 0.00003008f, -0.01932610f, -0.02940108f, 0.00738651f, 
    0.02331867f, 0.01200758f, 0.03525408f, -0.01854877f, -0.04104482f, -0.03013555f, -0.02304001f, -0.02009597f, 
    0.02317902f, -0.01777047f, -0.00881662f, -0.03675459f, -0.02321603f, -0.00002555f, -0.03514260f, -0.00039492f, 
    0.01909274f, -0.03377198f, -0.01450728f, 0.00395065f, -0.00371459f, 0.02098241f, -0.03171119f, -0.02590183f, 
    -0.01194519f, 0.00389322f, -0.01402242f, 0.01673510f, -0.03233541f, -0.01782458f, -0.00525830f, 0.02192622f, 
    0.01920282f, 0.00731079f, 0.02319032f, 0.02729429f, -0.02018783f, 0.01100083f, -0.00733592f, -0.01800590f, 
    -0.01859268f, -0.02782848f, -0.04115364f, 0.01052575f, 0.01802785f, 0.03127661f, -0.02707483f, -0.02508894f, 
    0.01316855f, -0.02971020f, 0.02934026f, 0.01237031f, -0.02792380f, 0.01327325f, 0.01588047f, -0.02067549f, 
    -0.03180631f, -0.01841516f, -0.02245381f, -0.01963299f, -0.02138253f, -0.01573184f, 0.01571130f, -0.04007256f, 
    -0.02268798f, -0.00489303f, 0.02420375f, 0.03074220f, 0.00981177f, 0.01551280f, 0.02007050f, -0.03978569f, 
    -0.02879536f, -0.00215950f, -0.01979497f, -0.00429654f, -0.01016699f, 0.02524941f, -0.02691120f, -0.03546858f, 
    -0.00748245f, -0.00403797f, 0.00254016f, -0.04102691f, -0.00841788f, -0.03854977f, 0.01647734f, -0.03173393f, 
    0.00872477f, -0.03101219f, 0.03050993f, 0.02641976f, -0.04021646f, 0.01231335f, -0.03992992f, -0.01870705f, 
    0.01423374f, 0.01179886f, -0.01422748f, -0.03334644f, -0.03335384f, -0.00311956f, -0.03304604f, 0.00029960f, 
    -0.03916782f, -0.00505756f, -0.02760256f, -0.02203817f, -0.03952824f, -0.02728216f, -0.01807943f, 0.02120991f, 
    0.02014420f, -0.00075707f, 0.01538704f, -0.02593808f, -0.03908698f, 0.03493420f, 0.02201866f, -0.01084459f, 
    0.00290944f, -0.01982382f, -0.03676291f, 0.02739908f, 0.01062368f, -0.02979377f, -0.03849710f, 0.02033665f, 
    -0.01784779f, -0.02840647f, 0.01993104f, -0.00435716f, -0.02532261f, -0.02667698f, -0.01043109f, 0.01612603f, 
    0.01882276f, 0.00033734f, -0.00889089f, -0.03523700f, -0.00073998f, 0.02409250f, 0.01430977f, 0.01215924f, 
    -0.03806910f, 0.02085620f, -0.00169700f, -0.01751298f, -0.02382784f, -0.00042633f, -0.03443274f, -0.03148433f, 
    0.01266596f, -0.02788299f, -0.01343385f, 0.02987910f, 0.02214538f, -0.00052496f, 0.01696305f, 0.01957820f, 
    -0.03080277f, -0.02604229f, 0.00542071f, -0.03178716f, -0.03275485f, -0.00404672f, 0.02710637f, -0.02682053f, 
    -0.03003518f, -0.01409181f, -0.01499057f, 0.00622814f, 0.00265990f, -0.01149845f, 0.00784392f, -0.01689113f, 
    -0.00732774f, 0.00197996f, -0.00462951f, 0.03004706f, -0.03668876f, -0.00331621f, 0.01063013f, -0.00155737f, 
    -0.03238188f, -0.01034465f, -0.02497851f, -0.03840129f, -0.00146989f, 0.00011670f, 0.02403107f, -0.04008165f, 
    0.01909694f, -0.02535877f, -0.00752962f, -0.02629256f, 0.02598912f, -0.03100294f, 0.02091151f, -0.03470510f, 
    0.02355792f, -0.01960944f, 0.00022980f, -0.01399404f, 0.00326252f, -0.03555150f, -0.00001619f, -0.00868694f, 
    -0.01958383f, 0.00856580f, 0.00382484f, -0.03339005f, -0.03570397f, 0.01459101f, -0.00125787f, -0.04110486f, 
    -0.00185555f, -0.01730903f, 0.02402115f, -0.01962538f, -0.00783627f, -0.02980918f, -0.01218193f, 0.01848533f, 
    -0.00243209f, 0.00365240f, 0.01840921f, -0.00633681f, 0.00084621f, -0.02555252f, -0.01772741f, -0.01311718f, 
    -0.00899186f, -0.00231816f, -0.02235566f, -0.02536833f, 0.02154175f, -0.03148285f, 0.00929304f, 0.01225189f, 
    0.01308414f, -0.00718538f, 0.03033119f, 0.01748614f, 0.01620918f, -0.03222095f, 0.00693966f, 0.00338826f, 
    0.00129996f, -0.02524727f, -0.01364967f, 0.01520896f, -0.02550858f, -0.01782378f, -0.01874582f, -0.01607667f, 
    -0.03365456f, -0.03802808f, -0.03701295f, 0.01645960f, 0.02261897f, 0.02726341f, -0.01216543f, -0.00981758f, 
    0.00854748f, -0.02271371f, 0.02451960f, -0.02076273f, -0.02158496f, 0.00288615f, -0.02997462f, -0.03242915f, 
    -0.01014507f, -0.03329280f, 0.00470513f, -0.03387250f, -0.02624568f, 0.01159496f, 0.00703646f, 0.01791376f, 
    -0.00531640f, -0.03591483f, -0.00789714f, 0.02615083f, 0.01681035f, 0.01423444f, 0.00540051f, -0.01616757f, 
    -0.02494956f, -0.01348062f, 0.00893598f, 0.00970385f, -0.03193860f, -0.01487563f, -0.03019549f, 0.00644643f, 
    0.02239643f, -0.01191095f, -0.01880013f, -0.03058074f, 0.02977811f, 0.02603257f, 0.01311953f, -0.02379177f, 
    -0.00542136f, 0.02073810f, -0.03500169f, -0.01211217f, -0.03986063f, 0.00855874f, -0.03235603f, -0.03261951f, 
    -0.19086181f, 0.24666739f, -0.12103501f, 0.12497336f, 0.10321581f, -0.07225541f, 0.01201956f, -0.02360307f, 
    -0.04020313f, 0.10968237f, -0.06488945f, 0.02970009f, 0.19788043f, -0.00981538f, 0.15544008f, 0.10508126f, 
    0.04481234f, 0.11758558f, 0.06388001f, 0.00323298f, 0.01974662f, -0.01128754f, 0.04759939f, -0.06789038f, 
    -0.10080125f, -0.01525899f, -0.05586465f, -0.03978516f, -0.02787188f, -0.09511702f, -0.07521868f, -0.04862803f, 
    0.09706205f, 0.09887477f, -0.10922134f, 0.00382593f, -0.13184121f, 0.25636193f, -0.15998541f, 0.23281284f, 
    -0.03461172f, 0.08017717f, -0.08970193f, 0.19605258f, 0.03259792f, 0.01262140f, -0.05257776f, -0.12530769f, 
    -0.03491418f, 0.19480257f, 0.29029796f, 0.01693701f, 0.14262581f, 0.03749603f, -0.03934826f, 0.12374175f, 
    -0.07744981f, 0.12608157f, 0.04622544f, -0.03880557f, 0.00521678f, 0.14202215f, -0.13760370f, 0.19700590f, 
    -0.05305920f, 0.10138215f, 0.04631830f, 0.02373644f, -0.02363858f, -0.01669554f, 0.06141927f, -0.03597134f, 
    0.31948733f, -0.02914678f, -0.07458638f, 0.02342713f, -0.02803659f, 0.04601070f, -0.06016422f, 0.00021065f, 
    -0.05042426f, -0.00477970f, -0.03014414f, 0.02552124f, -0.09179594f, 0.30674815f, 0.09418446f, -0.02743904f, 
    0.00770025f, 0.09744191f, 0.11263648f, -0.02524087f, -0.05457179f, -0.08305192f, 0.10096772f, -0.05342096f, 
    -0.07013410f, 0.10260683f, 0.33372313f, 0.05769058f, -0.05024721f, -0.05939076f, -0.05061311f, 0.03485393f, 
    0.02519528f, 0.02632130f, -0.13565516f, -0.01126720f, -0.09762960f, 0.01205811f, 0.32556856f, -0.12843138f, 
    -0.10932058f, 0.11015081f, -0.01287983f, 0.10519534f, -0.13206339f, -0.05857584f, 0.09192622f, 0.05835010f, 
    0.20537190f, 0.19492602f, 0.29338551f, 0.03872842f, -0.09972573f, 0.00881665f, -0.12317100f, 0.01527067f, 
    -0.00938691f, -0.09037399f, 0.06195271f, 0.00961741f, -0.02369722f, 0.15008414f, 0.08029553f, 0.01673188f, 
    0.08043744f, -0.01980112f, 0.00935816f, 0.12497903f, 0.00397707f, -0.02587804f, -0.02101957f, -0.02234325f, 
    0.00930824f, 0.06969509f, -0.01825915f, 0.05307982f, -0.02237149f, -0.02387796f, -0.04070960f, -0.00242493f, 
    0.10574565f, -0.06153127f, -0.02823765f, -0.04255548f, 0.34283623f, -0.15367472f, 0.20544304f, -0.02535417f, 
    -0.01572457f, -0.02599343f, 0.06676137f, -0.07340989f, 0.02704290f, -0.05384934f, -0.01182689f, -0.08562149f, 
    -0.11569264f, 0.08960035f, 0.11846793f, 0.01649783f, 0.01799363f, -0.12005976f, 0.04908416f, -0.00229058f, 
    -0.08268058f, 0.27523515f, -0.14562763f, 0.15619202f, 0.08379728f, 0.13438688f, 0.27185205f, 0.07278369f, 
    0.07884598f, 0.13755523f, -0.01639792f, 0.01991440f, -0.08336346f, -0.03355265f, 0.04872323f, 0.02079306f, 
    -0.06887854f, 0.09034353f, 0.21030597f, -0.11358617f, -0.09273245f, -0.08099080f, -0.12212574f, -0.00226664f, 
    0.01204100f, 0.04616726f, 0.07502214f, -0.02494869f, -0.13933583f, 0.25732100f, 0.03652110f, -0.04259815f, 
    0.09407409f, 0.28040591f, 0.13124865f, 0.01282913f, 0.05128341f, -0.02507229f, -0.05491411f, -0.04396088f, 
    0.23821782f, -0.12223922f, -0.02091253f, 0.05400178f, 0.00258544f, 0.01886155f, 0.10624889f, 0.11318018f, 
    -0.00149407f, -0.13261044f, 0.07317396f, -0.10514817f, -0.15891264f, 0.09326933f, 0.11548113f, -0.11954983f, 
    0.02392997f, 0.01290099f, -0.01827238f, 0.05254437f, 0.15145168f, -0.00727212f, -0.15138036f, -0.00386801f, 
    -0.09364336f, -0.15345789f, 0.04280738f, -0.11370108f, 0.00601470f, -0.09010322f, -0.00980016f, -0.03829379f, 
    0.01089138f, -0.00774546f, -0.03682427f, 0.05858031f, -0.17559336f, 0.24494256f, 0.16147833f, 0.07496289f, 
    0.02548369f, -0.06214169f, 0.08643740f, 0.06390726f, -0.10098585f, 0.14430213f, -0.08823295f, -0.06179728f, 
    0.06603301f, 0.16401447f, 0.04545475f, 0.15075494f, 0.01232625f, -0.02714699f, 0.14668432f, 0.02316863f, 
    -0.01430807f, 0.00672148f, 0.04669698f, 0.00052242f, 0.05113276f, 0.12077688f, -0.07082083f, 0.05302854f, 
    0.08157856f, -0.08222080f, 0.24092522f, 0.03560810f, -0.03254997f, 0.10002947f, -0.01437585f, -0.05782740f, 
    -0.24019447f, -0.13262165f, -0.05812811f, -0.06486479f, -0.09520642f, -0.00948233f, 0.06039599f, 0.01145238f, 
    0.04365942f, -0.04442541f, -0.00776082f, 0.09312844f, 0.08972300f, 0.36464971f, 0.01892821f, -0.09613639f, 
    0.21151814f, 0.10330010f, -0.04549113f, 0.11783674f, 0.07289001f, 0.14813645f, -0.04360363f, -0.04143326f, 
    -0.00339237f, 0.14817436f, -0.04938744f, -0.05561303f, -0.05254179f, -0.01501928f, -0.03005507f, 0.01368153f, 
    -0.06781273f, -0.24239269f, 0.10108688f, 0.11017203f, 0.08043918f, 0.11145863f, -0.11833021f, -0.00392672f, 
    -0.06642503f, 0.01098751f, -0.00004724f, 0.05135744f, 0.02363522f, 0.00042316f, -0.00311932f, -0.12695076f, 
    -0.02303103f, -0.05269503f, -0.09703764f, -0.04320513f, -0.03086712f, -0.06385104f, -0.00619731f, -0.03567238f, 
    -0.08522211f, -0.05474910f, -0.02490880f, 0.06835085f, -0.21458866f, 0.04900620f, 0.30236569f, -0.02125807f, 
    0.08760318f, 0.13865231f, 0.06941741f, 0.13445210f, -0.04173909f, -0.01538462f, 0.05847721f, -0.00289657f, 
    -0.02789652f, -0.10183799f, 0.11496241f, -0.12072152f, 0.01825367f, -0.04050200f, 0.12102283f, 0.04510243f, 
    -0.07463697f, 0.00415375f, -0.10964805f, 0.02189394f, -0.04291363f, 0.21238819f, -0.08972418f, 0.24928099f, 
    -0.06090088f, -0.04471164f, -0.01180355f, 0.17048100f, 0.11618062f, 0.07366356f, -0.10872675f, 0.03029620f, 
    0.01197932f, 0.12822308f, 0.18065968f, 0.03012391f, 0.02722458f, 0.08058046f, -0.03585644f, 0.09608469f, 
    -0.02647175f, 0.02065568f, -0.00597359f, 0.01616420f, -0.14348073f, 0.00351569f, 0.07339903f, -0.12207741f, 
    -0.02910245f, -0.06964347f, 0.00973447f, -0.00426632f, 0.04640446f, 0.09761856f, -0.15768458f, 0.12788136f, 
    0.30342227f, 0.26105678f, 0.23036879f, 0.16372322f, -0.09977625f, 0.12162555f, 0.04208925f, 0.09503256f, 
    0.03639825f, 0.06925130f, 0.00635933f, -0.02285040f, 0.01356642f, -0.10967337f, -0.23544414f, 0.12406532f, 
    0.03434878f, -0.03780027f, 0.06546762f, 0.11816983f, 0.03743087f, -0.03306093f, -0.08538578f, -0.00092532f, 
    -0.11533754f, 0.18428499f, -0.30151308f, -0.05010358f, 0.03170633f, 0.04608278f, 0.01248437f, 0.07360423f, 
    -0.02490818f, -0.09406547f, -0.00762428f, -0.06259419f, 0.03069599f, -0.14015676f, 0.11340683f, -0.01019030f, 
    -0.03086494f, -0.03364637f, -0.04722115f, -0.03412416f, 0.09874369f, -0.13205980f, -0.02346343f, 0.08722162f, 
    0.12125579f, 0.05535236f, 0.31599158f, 0.02861685f, -0.05004412f, 0.18137746f, 0.05466645f, 0.16353650f, 
    -0.06393135f, -0.07671423f, 0.11008692f, 0.18035644f, -0.08347979f, 0.30795544f, -0.05269918f, 0.16367397f, 
    -0.08318135f, 0.08272934f, -0.02930075f, 0.05356768f, 0.04922957f, -0.13634488f, -0.02891732f, 0.04128571f, 
    0.09669681f, -0.07138943f, 0.04280836f, -0.03855958f, 0.14148113f, -0.11692014f, 0.00679988f, -0.07014598f, 
    0.04688002f, 0.12513030f, -0.08123461f, 0.07061831f, 0.05515952f, -0.15585819f, -0.12986965f, -0.08288088f, 
    -0.06414478f, -0.02007566f, 0.04408887f, -0.07809092f, -0.01387912f, -0.03760307f, 0.03552043f, 0.03790316f, 
    0.22252116f, 0.15167238f, 0.02437652f, -0.02768617f, -0.02307994f, 0.11415908f, -0.07974638f, 0.02611426f, 
    -0.04504911f, -0.11616639f, 0.05799727f, 0.02947985f, 0.20042598f, 0.19163914f, 0.10036139f, 0.13043411f, 
    0.07986149f, 0.16975445f, 0.01843189f, 0.06890925f, 0.03555547f, -0.02402432f, -0.00025013f, 0.06511150f, 
    0.15904485f, 0.12069926f, -0.04938760f, 0.04721636f, 0.11169661f, -0.05868030f, 0.10456196f, 0.09529053f, 
    0.00834771f, 0.07444251f, -0.05801829f, 0.03915894f, 0.21936896f, 0.19069782f, 0.11721072f, 0.00495146f, 
    -0.05837449f, -0.06081325f, 0.13183944f, -0.02206105f, -0.03090859f, 0.02842005f, 0.05720790f, -0.01030295f, 
    -0.01756812f, -0.25944829f, 0.28671509f, 0.01711649f, -0.07074715f, 0.00276922f, -0.00254157f, -0.05929080f, 
    -0.18400829f, -0.00500058f, -0.01894466f, 0.06376731f, -0.07563261f, 0.04047357f, -0.16578436f, -0.05015102f, 
    -0.06149681f, 0.03160208f, 0.05422608f, -0.05638572f, 0.01320166f, -0.12596674f, 0.10512551f, 0.10967687f, 
    0.23884815f, -0.02020605f, 0.13406417f, 0.05049595f, 0.10920827f, 0.19955029f, 0.01781027f, -0.00666852f, 
    0.05233366f, -0.01788650f, -0.05540906f, 0.09510151f, -0.01308612f, 0.34008941f, 0.12739179f, -0.00223709f, 
    0.04938335f, 0.02717234f, -0.03239316f, 0.16941842f, -0.00748648f, -0.00890667f, -0.01382844f, 0.06891858f, 
    0.07414118f, 0.02840784f, 0.01696281f, 0.05870827f, 0.03688994f, 0.11843226f, -0.03943356f, 0.01866912f, 
    -0.15121053f, 0.08979190f, 0.08574763f, -0.03109730f, 0.03046305f, 0.17162985f, -0.08896144f, -0.14874813f, 
    0.07908787f, 0.00852093f, 0.11883370f, 0.07844362f, -0.03127356f, 0.14120376f, 0.08592680f, -0.13563237f, 
    -0.11017652f, 0.13154620f, -0.16593599f, 0.24582955f, -0.03850441f, 0.04407086f, -0.09117161f, 0.06535785f, 
    -0.04300592f, -0.02598109f, 0.17262802f, -0.06004077f, 0.20846079f, 0.08026852f, 0.02960322f, 0.04548796f, 
    0.11255389f, 0.15408719f, -0.01170224f, 0.06422175f, 0.02458689f, -0.03575913f, -0.06646866f, 0.05129917f, 
    -0.00657278f, 0.07600474f, -0.03493092f, 0.03178188f, -0.08640288f, -0.08483857f, 0.03350989f, 0.11874066f, 
    -0.15532453f, -0.04474914f, 0.09242638f, 0.06186480f, 0.13958335f, 0.22142349f, 0.33574587f, 0.06488349f, 
    0.05607073f, 0.21071567f, -0.07298891f, 0.03020434f, -0.00034842f, -0.02652778f, 0.00233285f, -0.01644987f, 
    0.13292396f, 0.04101818f, 0.09881318f, 0.03387474f, 0.16779189f, 0.18460883f, -0.06198535f, 0.10689702f, 
    0.00936569f, 0.00224371f, -0.04041329f, 0.00827849f, 0.17769253f, -0.35310191f, 0.05878558f, 0.04450142f, 
    -0.04105383f, 0.07834478f, -0.00413712f, 0.03526876f, 0.15881489f, -0.10467690f, -0.09046200f, 0.04470693f, 
    -0.02911423f, -0.10910103f, 0.01853755f, -0.08242864f, -0.00760834f, -0.07756459f, 0.04714027f, -0.03031378f, 
    -0.06886333f, 0.04584403f, 0.06367299f, -0.11468700f, 0.03487509f, 0.04383079f, 0.24154748f, -0.06645797f, 
    0.04435564f, -0.03818482f, 0.16846310f, 0.25149220f, 0.02369864f, -0.00362157f, -0.04653584f, -0.02879566f, 
    -0.49246073f, -0.25946108f, 0.76775014f, -0.12291726f, -0.00286319f, 0.04159926f, -0.05175680f, 0.19441457f, 
    -0.17714906f, -0.07794318f, 0.01327593f, 0.09114502f, 0.11576725f, 0.17569041f, 0.01330792f, 0.14175947f, 
    0.05139491f, -0.00645382f, -0.00525831f, 0.05197209f, 0.00515227f, -0.00399071f, 0.00303827f, 0.05418715f, 
    0.25774986f, 0.10681222f, -0.13933204f, 0.20709082f, -0.01168854f, 0.12842157f, -0.06211368f, 0.11353587f, 
    -0.04923565f, -0.04081834f, -0.09877920f, 0.06578407f, -0.09318710f, -0.19641502f, -0.03639361f, -0.06694708f, 
    0.01306325f, -0.02712082f, 0.00250443f, 0.01893097f, 0.03534794f, 0.04699417f, -0.11112183f, 0.02236945f, 
    -0.02435027f, -0.04107351f, -0.01514794f, -0.02177425f, -0.00305129f, 0.01670647f, -0.00956201f, -0.01930141f, 
    -0.00365351f, -0.01241736f, 0.02050788f, -0.02743320f, 0.01607303f, -0.03754415f, 0.02140382f, 0.01609144f, 
    -0.02789188f, -0.00181614f, -0.03567429f, -0.01682636f, -0.00526261f, -0.03443675f, -0.02756434f, -0.03656192f, 
    -0.00531804f, -0.03524104f, -0.01439021f, 0.02798452f, 0.00303665f, 0.02821420f, -0.01087258f, 0.02754771f, 
    -0.02779913f, 0.02623824f, 0.01022132f, 0.00792270f, 0.00323196f, 0.00101411f, 0.01375684f, -0.00136629f, 
    -0.03030317f, -0.00430814f, -0.02459848f, -0.01785939f, 0.02558297f, -0.03054812f, 0.00626401f, -0.01050855f, 
    -0.00744471f, -0.03991522f, -0.02999777f, 0.00901224f, 0.01497737f, -0.00809037f, -0.01289001f, -0.01187558f, 
    -0.00139712f, 0.02939417f, -0.01925422f, -0.01943178f, 0.02378884f, 0.00419446f, -0.02375143f, -0.03346765f, 
    0.01228986f, -0.02139707f, 0.02507945f, -0.02647700f, 0.00177375f, -0.02175411f, -0.02883257f, 0.01995748f, 
    0.02067948f, -0.00398276f, -0.00117005f, 0.00297882f, -0.01635166f, -0.01567057f, 0.02601135f, -0.01506221f, 
    0.00503197f, -0.00820258f, 0.00621389f, 0.02089108f, -0.03409813f, 0.00078826f, -0.02170258f, 0.02292904f, 
    -0.00239008f, -0.00064029f, -0.03994820f, -0.01575932f, 0.01140099f, 0.02171251f, 0.01891547f, 0.00580783f, 
    0.02578760f, 0.00429096f, 0.00353113f, -0.00617881f, 0.00802751f, -0.01812672f, -0.03257940f, 0.02199384f, 
    -0.01370251f, -0.02570805f, 0.02394623f, 0.02733633f, -0.01052480f, 0.00366138f, 0.00790746f, 0.01123390f, 
    0.00843257f, -0.03322260f, 0.00730706f, 0.00653457f, 0.02398028f, -0.03063140f, -0.02718089f, -0.03446503f, 
    -0.02049129f, -0.03839627f, -0.00261362f, -0.00327930f, -0.02993310f, 0.01483806f, -0.03939874f, 0.02991204f, 
    -0.01838697f, -0.01068964f, -0.01025331f, -0.02175785f, -0.04110216f, -0.01684600f, -0.04168742f, 0.00621418f, 
    -0.01896064f, -0.02117251f, 0.02269488f, -0.01606500f, -0.00607061f, -0.01029852f, -0.03908100f, 0.01805898f, 
    -0.02089818f, -0.01527627f, -0.01740015f, -0.04191713f, -0.01046914f, -0.02903671f, 0.01924430f, 0.01227945f, 
    0.02860399f, 0.02802747f, -0.02367754f, -0.04009748f, -0.02591959f, 0.00549930f, -0.01079123f, -0.01261065f, 
    0.00923700f, -0.03066580f, -0.01221054f, -0.01847953f, 0.02046083f, 0.00740632f, 0.01795490f, -0.02226053f, 
    -0.01954240f, -0.02995509f, -0.01916403f, -0.04110809f, 0.01842219f, 0.01462312f, 0.00682934f, 0.01929572f, 
    0.02681111f, 0.00093359f, -0.00052648f, -0.00850467f, -0.04005896f, -0.01906412f, -0.00357707f, -0.01767386f, 
    0.00814977f, 0.01542693f, -0.00125010f, -0.01621796f, 0.02889770f, 0.01302733f, 0.00725968f, 0.01126276f, 
    -0.01812883f, 0.01928188f, -0.00497945f, -0.02188630f, -0.00070734f, 0.01532508f, 0.02168840f, -0.02017128f, 
    0.02284421f, -0.04018182f, -0.02016557f, -0.01394239f, -0.01238874f, -0.03545600f, -0.02900483f, -0.03329588f, 
    0.02515231f, -0.03699303f, -0.00479983f, -0.02808142f, -0.00705025f, -0.02719149f, 0.00998302f, 0.01349513f, 
    -0.01680492f, 0.02580150f, -0.01507215f, 0.00613768f, 0.01781492f, 0.01117008f, 0.00582579f, -0.00118709f, 
    0.01674267f, -0.02407059f, 0.02504781f, 0.02401506f, -0.03765059f, 0.02857777f, -0.04086303f, -0.00572738f, 
    -0.04133503f, -0.03104720f, -0.01159680f, -0.03791523f, -0.00166700f, -0.02696123f, -0.04074341f, -0.02957275f, 
    0.01376832f, -0.01857279f, 0.01978613f, -0.01991305f, 0.01285546f, -0.02430798f, -0.03491204f, 0.02675852f, 
    -0.00935472f, -0.01948988f, -0.00824548f, 0.01688263f, 0.00434094f, -0.01168510f, -0.02171847f, -0.01160885f, 
    -0.03178727f, 0.01667670f, -0.03220963f, 0.01155519f, -0.04137610f, -0.02364150f, -0.02676408f, 0.00694979f, 
    0.02284528f, -0.01057027f, -0.03345807f, -0.04087717f, -0.01441739f, -0.02171728f, -0.04148798f, 0.00511148f, 
    0.01769423f, 0.02732057f, -0.00317980f, -0.03067589f, -0.02704543f, -0.00420829f, -0.02689355f, -0.02739690f, 
    -0.03432776f, -0.03451342f, -0.00570480f, 0.01325854f, -0.03130741f, -0.03921750f, 0.03272132f, -0.00566976f, 
    -0.01707437f, -0.00868957f, 0.02157294f, 0.00386977f, -0.01628987f, -0.04066961f, -0.00728746f, 0.01134514f, 
    0.00127657f, 0.02148505f, -0.01782755f, -0.00527653f, -0.02792792f, 0.00529907f, 0.00008497f, -0.02993020f, 
    0.00279151f, 0.01231515f, -0.03348588f, 0.01697988f, -0.00240125f, -0.00645943f, -0.01182862f, -0.02012784f, 
    0.00179473f, -0.00836538f, -0.04149935f, -0.02028201f, 0.02068662f, -0.00021327f, 0.01687461f, 0.00785366f, 
    -0.00408341f, -0.00506411f, 0.01935758f, 0.00640635f, -0.00235717f, 0.01459991f, -0.00823015f, -0.03691242f, 
    0.00302859f, 0.02851531f, 0.01806972f, 0.00247948f, -0.01708846f, 0.02909211f, -0.00600700f, -0.01716309f, 
    0.02839264f, 0.00336152f, -0.00663842f, -0.02078505f, -0.01887360f, 0.01562410f, -0.00997816f, -0.01821825f, 
    0.01298615f, 0.01172246f, -0.00290389f, -0.00887215f, -0.02014618f, 0.01958245f, -0.03259619f, -0.03196294f, 
    -0.00529818f, -0.01613876f, -0.00229732f, 0.00802571f, 0.00307708f, -0.03840320f, -0.00784298f, 0.01057754f, 
    0.00628230f, 0.00820164f, 0.01531717f, 0.00360914f, -0.02632523f, 0.01964113f, 0.00019561f, 0.02507645f, 
    0.00278517f, 0.00940608f, 0.00510803f, 0.00074412f, 0.01437910f, -0.03533575f, -0.03008837f, -0.00244597f, 
    -0.00398852f, 0.01049656f, -0.02379839f, -0.02574519f, 0.01957615f, 0.00122698f, -0.00889385f, 0.00211332f, 
    -0.02938521f, 0.00226212f, 0.01417686f, -0.02056609f, 0.01231657f, 0.01094057f, -0.02122080f, -0.03214027f, 
    0.01008504f, 0.01117320f, -0.00367507f, -0.01992641f, -0.03036587f, 0.00750003f, 0.02935535f, -0.03225654f, 
    -0.03973486f, -0.00582791f, -0.00098392f, 0.02165990f, 0.01383809f, -0.02386413f, 0.02883101f, -0.01686421f, 
    -0.02449950f, 0.01714324f, 0.02839257f, -0.00786326f, 0.01356613f, -0.02623546f, -0.02637987f, -0.03940913f, 
    -0.01362153f, 0.01101592f, 0.02905032f, 0.02318786f, 0.01161834f, -0.03410275f, 0.01574900f, -0.00618917f, 
    -0.00128074f, -0.03797573f, -0.03175075f, -0.02556848f, -0.00171943f, 0.02096417f, -0.03533379f, 0.00764420f, 
    0.02020253f, -0.00578141f, -0.03316812f, 0.00182413f, -0.03718299f, 0.02818778f, -0.01699147f, -0.03564826f, 
    0.01395573f, 0.01573054f, 0.00498934f, -0.00442050f, -0.02852160f, -0.01121424f, 0.02070156f, 0.01252925f, 
    -0.03023931f, 0.01757153f, 0.01506204f, 0.02664500f, -0.02362475f, 0.02227296f, 0.01019563f, 0.00483529f, 
    -0.03566263f, 0.01770961f, 0.00966252f, -0.03644473f, -0.00849845f, -0.01283396f, 0.01102087f, 0.02660693f, 
    -0.00959008f, -0.01361960f, -0.01069574f, 0.02542305f, -0.03907152f, 0.02068669f, -0.02858671f, -0.03734038f, 
    -0.02018265f, -0.02898438f, 0.01705250f, 0.00710300f, -0.03473342f, 0.00720748f, -0.03452745f, 0.02185730f, 
    -0.00057058f, 0.00967641f, -0.00684146f, 0.01711813f, 0.01046250f, -0.02237407f, -0.02744696f, 0.01148018f, 
    0.00453172f, 0.00634279f, 0.00673525f, 0.00274501f, -0.02204963f, -0.02093610f, 0.00362908f, 0.02382264f, 
    -0.02394751f, -0.03216277f, -0.01174457f, -0.00752472f, 0.02127771f, 0.00596010f, 0.00785288f, -0.00645035f, 
    -0.03927686f, 0.00299909f, -0.03877983f, 0.02734646f, 0.00991958f, -0.03166588f, -0.01192252f, -0.01223858f, 
    0.02318790f, 0.00761214f, -0.00134316f, -0.00352147f, -0.03291116f, -0.01956741f, 0.01873540f, 0.02100326f, 
    -0.00209408f, -0.03312202f, -0.03203465f, -0.00067950f, -0.02643840f, -0.00726703f, 0.00053400f, -0.02305813f, 
    0.00812941f, -0.02348818f, 0.01828755f, 0.01603431f, -0.03174758f, 0.02801621f, 0.01751180f, 0.00664274f, 
    -0.03672149f, 0.01990787f, -0.00063656f, 0.00040173f, -0.03206997f, 0.00931287f, 0.01712455f, -0.03343224f, 
    -0.02394333f, -0.01296783f, 0.01608467f, -0.02312353f, -0.00792856f, 0.00344795f, 0.01076848f, 0.00819121f, 
    0.02866321f, -0.01873858f, 0.00555232f, -0.03827074f, -0.01154801f, -0.02597672f, 0.03063512f, -0.01163109f, 
    0.02250044f, 0.01481882f, 0.00633278f, -0.03910997f, 0.02447890f, 0.00674277f, -0.02488058f, -0.00888820f, 
    0.01474609f, 0.02185714f, -0.03185120f, 0.01089678f, 0.00014074f, 0.01618468f, 0.03040863f, 0.01042894f, 
    0.01750236f, -0.01630391f, 0.02158212f, -0.04205913f, 0.02721710f, 0.00019238f, 0.00209874f, -0.03696127f, 
    -0.02230709f, 0.00730393f, -0.03566447f, -0.03758338f, -0.01118446f, 0.01930674f, -0.02389837f, 0.00342588f, 
    -0.01087653f, -0.01879311f, 0.00215951f, -0.02407133f, 0.01216547f, -0.02505261f, -0.02501482f, -0.03734242f, 
    -0.04116121f, -0.00868038f, 0.01774262f, -0.03986093f, -0.00277274f, 0.02099008f, -0.03001310f, -0.02423142f, 
    -0.02291170f, -0.00989199f, 0.02982447f, 0.01492270f, 0.01619358f, -0.04031410f, -0.02629305f, -0.03502205f, 
    0.00535135f, -0.00093211f, 0.01408423f, 0.02630076f, 0.02704008f, -0.03140127f, -0.01265819f, -0.01949559f, 
    0.02586733f, -0.00661872f, -0.02267876f, -0.02867671f, -0.03694220f, -0.03886869f, -0.02105913f, -0.04126394f, 
    -0.01747996f, -0.02128021f, 0.00497067f, -0.02663676f, -0.03303665f, -0.02792927f, -0.03978639f, -0.02582205f, 
    -0.04013254f, 0.02884813f, -0.00292924f, 0.01457454f, -0.01197833f, -0.03838783f, 0.00373013f, -0.02539989f, 
    -0.03449766f, -0.03358281f, 0.00995280f, -0.02390263f, 0.01977816f, -0.03621057f, -0.04145074f, 0.01294191f, 
    0.02137682f, -0.00542232f, 0.00657384f, -0.00892382f, -0.03133232f, 0.01411696f, 0.00766031f, 0.01103648f, 
    -0.03313540f, -0.00746702f, -0.02417183f, -0.03302301f, 0.02138191f, -0.02035821f, -0.01175835f, -0.02677486f, 
    0.02447839f, -0.00201148f, 0.02808135f, 0.00877444f, -0.03709603f, 0.01159194f, 0.02872388f, 0.00463319f, 
    -0.03610008f, 0.00339038f, 0.02314305f, 0.00449252f, -0.00820849f, -0.03663113f, -0.00533396f, -0.01073283f, 
    0.02360508f, -0.00018086f, 0.02628353f, -0.01915044f, -0.02757128f, -0.02961781f, 0.02770596f, -0.02143302f, 
    0.02334728f, -0.01986484f, -0.02648654f, -0.02540568f, 0.00314382f, -0.03103063f, 0.01209793f, 0.00080806f, 
    0.01005523f, -0.01716896f, -0.02578891f, 0.01893872f, 0.01761234f, -0.04060243f, 0.01631790f, -0.03085666f, 
    0.02401774f, 0.00232402f, 0.00663651f, -0.00232616f, -0.01086470f, -0.01247090f, -0.01786899f, 0.00967040f, 
    0.01248950f, 0.02314706f, 0.02008757f, 0.00442342f, 0.02115886f, 0.01571772f, -0.02149585f, 0.01374233f, 
    -0.03098290f, 0.01498558f, 0.01112239f, 0.00431674f, -0.00599424f, 0.02034680f, 0.00113018f, -0.00267985f, 
    -0.00247265f, -0.00420944f, -0.03141716f, -0.02253684f, -0.01739679f, -0.01273788f, -0.01700872f, -0.04183756f, 
    0.00223637f, 0.00425140f, -0.01886139f, -0.04002481f, -0.03801376f, 0.01618619f, 0.01928042f, 0.01259784f, 
    0.00513714f, -0.00168896f, -0.00955942f, -0.00600789f, -0.00975293f, 0.01060730f, -0.01960096f, 0.01863467f, 
    -0.02058817f, 0.02176561f, -0.01903126f, -0.01049123f, 0.01475573f, -0.03387479f, -0.03422284f, 0.01761281f, 
    -0.02195689f, -0.02750148f, 0.01832131f, -0.00193102f, 0.02801710f, 0.00003747f, -0.02385040f, 0.02796406f, 
    0.01190982f, -0.00895693f, -0.02966377f, 0.02372204f, 0.01162823f, -0.00566619f, -0.02852621f, -0.00715908f, 
    -0.00089007f, -0.00076667f, 0.01442864f, 0.02272410f, 0.00751346f, -0.01239168f, 0.00381701f, 0.00805434f, 
    0.01132340f, -0.02676206f, 0.00237241f, 0.01589748f, -0.03685227f, -0.01678577f, 0.03104697f, 0.01737302f, 
    -0.00671163f, 0.00876803f, 0.02739782f, 0.00196449f, -0.02319082f, -0.03522545f, -0.02862140f, -0.02336768f, 
    -0.00399626f, 0.02836129f, -0.02519372f, -0.03531569f, -0.00366149f, -0.02725247f, 0.02741106f, 0.03101031f, 
    0.02230469f, -0.01994832f, 0.00486664f, 0.01548464f, -0.03357359f, 0.02744622f, -0.02499330f, -0.00661027f, 
    -0.03388865f, -0.02686606f, -0.01134531f, -0.02155521f, 0.01020669f, 0.02082565f, 0.01585093f, 0.01092211f, 
    0.02795456f, -0.00954165f, 0.00293631f, -0.02612239f, -0.02947905f, 0.00645196f, -0.02284591f, 0.02769703f, 
    -0.03563880f, 0.03240085f, -0.02321225f, -0.02968995f, -0.01813944f, -0.01817797f, -0.01588519f, -0.01486589f, 
    0.00344423f, -0.03274757f, -0.00353920f, -0.03806316f, -0.01529587f, 0.01645021f, -0.01863278f, -0.01865904f, 
    -0.01421695f, 0.02313859f, 0.01739869f, 0.00825084f, -0.00211791f, 0.02745864f, 0.02124668f, 0.00896178f, 
    0.01941708f, 0.03156198f, 0.02267729f, -0.02713156f, -0.02466361f, 0.00357645f, -0.01046866f, 0.00232077f, 
    -0.00752895f, -0.02960782f, 0.02878761f, -0.03093115f, -0.00216571f, 0.01388165f, -0.03595028f, -0.00826628f, 
    0.03034177f, -0.01857628f, -0.00817029f, -0.00448048f, -0.01375393f, 0.02583989f, -0.03770422f, 0.01600227f, 
    -0.03304702f, -0.03287728f, -0.01664070f, 0.01665485f, -0.02316826f, -0.02413756f, 0.01668013f, 0.02473984f, 
    0.02842164f, -0.02409160f, -0.02786474f, 0.00051803f, -0.00932702f, 0.00705267f, -0.00205808f, -0.02273187f, 
    0.03379970f, 0.02849731f, 0.00011304f, -0.00251589f, 0.02316082f, -0.04153378f, 0.01459549f, 0.03216439f, 
    -0.01451224f, 0.00523614f, 0.01249036f, -0.00149849f, 0.00897474f, -0.03101429f, -0.00493232f, 0.00044523f, 
    0.01675418f, 0.01192618f, -0.01081022f, 0.01527453f, 0.00301991f, -0.01169120f, -0.02723180f, -0.02977509f, 
    0.00830746f, 0.01294159f, -0.00231845f, 0.02520208f, -0.02273825f, -0.00231728f, -0.03764941f, -0.00448497f, 
    0.01219607f, 0.02000876f, 0.01537579f, -0.03459217f, 0.03121965f, -0.01789952f, 0.00620174f, -0.01635630f, 
    0.02884487f, -0.00261408f, 0.03285181f, -0.03142896f, -0.01959723f, -0.00862011f, -0.03236674f, -0.02774874f, 
    -0.00455283f, -0.02249385f, 0.00453950f, -0.00131286f, -0.01675098f, -0.02318283f, 0.03136854f, 0.02700403f, 
    0.02252432f, 0.01917927f, 0.01500973f, 0.02536276f, -0.00228450f, -0.02831119f, 0.02652968f, 0.03191818f, 
    -0.02383807f, 0.00611779f, 0.02762716f, -0.02906960f, -0.01353519f, -0.03330787f, 0.00573912f, -0.00917792f, 
    -0.03714591f, 0.01573803f, -0.02006530f, 0.02941641f, -0.00595988f, -0.03647744f, 0.01175867f, 0.02758016f, 
    -0.01020619f, -0.02934907f, 0.00731131f, -0.02093661f, -0.02976087f, -0.03540573f, -0.02144807f, 0.01627930f, 
    -0.00227872f, 0.00296515f, 0.03282117f, 0.01877231f, 0.00186418f, 0.00757987f, -0.02978471f, 0.02380344f, 
    -0.00108314f, -0.03965902f, 0.02757828f, -0.00435178f, -0.02051628f, -0.03310176f, 0.00450860f, -0.03884740f, 
    0.00356521f, 0.01286626f, -0.04003376f, 0.01316487f, -0.02632505f, -0.02708525f, 0.02235823f, -0.02748269f, 
    0.00109101f, 0.03117694f, -0.03352776f, -0.01571898f, 0.02877118f, 0.00470743f, 0.00146420f, 0.02483789f, 
    -0.02209858f, 0.02804364f, -0.00594910f, -0.01862525f, -0.01401124f, -0.02627579f, -0.00759877f, 0.02154319f, 
    -0.03723131f, -0.01165467f, 0.01818100f, -0.01868683f, 0.02363883f, -0.01297739f, 0.02381134f, 0.01391944f, 
    0.02054282f, 0.01156692f, 0.00281473f, 0.01358148f, -0.01395261f, 0.01876277f, 0.01298659f, 0.00768156f, 
    0.01627258f, -0.01764844f, -0.02453588f, 0.00466678f, 0.02913773f, 0.00778934f, -0.00930807f, -0.03461248f, 
    -0.02915521f, 0.00849788f, -0.00682421f, -0.01390542f, -0.02863337f, -0.01982893f, -0.01131311f, -0.02133230f, 
    -0.03734985f, -0.03446510f, 0.00261728f, -0.02455755f, -0.01312358f, -0.01206720f, -0.01533689f, -0.02300809f, 
    0.01348514f, 0.00494876f, 0.01746605f, 0.00959725f, 0.01588240f, 0.00584422f, -0.00854624f, 0.02091101f, 
    -0.02119182f, -0.01649322f, -0.03547188f, -0.03058475f, -0.03953327f, -0.01247120f, -0.02789052f, -0.01585254f, 
    -0.03220599f, -0.00050481f, 0.01667089f, -0.02201732f, -0.02322133f, -0.02274096f, 0.02350492f, -0.00912325f, 
    -0.03495714f, -0.00791601f, -0.03482406f, -0.01671517f, -0.02453795f, -0.01522376f, 0.03181446f, 0.01869340f, 
    -0.02580152f, 0.00223422f, -0.01733702f, -0.02547988f, 0.00237105f, -0.03934367f, 0.01184275f, -0.00096248f, 
    0.02519361f, -0.03060199f, 0.03015238f, -0.01970587f, -0.00352397f, -0.03515885f, 0.01853354f, 0.02892799f, 
    0.00350106f, 0.02309927f, -0.00185747f, 0.02682953f, 0.02721297f, -0.03372945f, 0.01606153f, -0.02001514f, 
    0.02012691f, -0.02454120f, -0.02117756f, 0.00276783f, -0.00929294f, -0.00149610f, -0.02097877f, 0.02415184f, 
    0.03383622f, -0.00408197f, -0.00184986f, 0.01412637f, -0.00225579f, -0.03194920f, 0.00753666f, -0.03647453f, 
    -0.03212717f, -0.03525332f, 0.02125679f, -0.03933847f, -0.01313717f, 0.01859084f, 0.01880648f, -0.02653636f, 
    -0.01008208f, -0.01804741f, -0.02225576f, -0.00698738f, -0.01564645f, 0.00226557f, -0.02572640f, -0.02880048f, 
    0.02794985f, 0.00245572f, -0.00623532f, 0.02757720f, -0.03225598f, -0.02789571f, -0.01606329f, 0.01874079f, 
    0.02304121f, 0.00733115f, -0.00172299f, -0.01153779f, 0.02912567f, -0.00831157f, 0.03340943f, 0.00398949f, 
    -0.01514807f, -0.02841131f, -0.03811571f, 0.01237651f, 0.01948188f, -0.02410151f, -0.00071588f, 0.01973313f, 
    -0.03497557f, 0.01861205f, -0.01294261f, -0.00928359f, -0.02099148f, 0.02943940f, 0.00283129f, -0.02504514f, 
    0.02376719f, -0.02822673f, 0.02161710f, -0.03813657f, 0.01420308f, -0.00736615f, 0.00762449f, 0.00477865f, 
    0.01750535f, -0.02865736f, 0.03054927f, -0.03246179f, 0.03101903f, -0.02294832f, -0.00723626f, -0.03250742f, 
    -0.00258487f, 0.02634241f, -0.00898023f, -0.03554909f, -0.00270284f, 0.01021235f, -0.03189617f, -0.01421455f, 
    -0.01828943f, -0.01306023f, -0.00903578f, 0.00606789f, -0.02411998f, 0.02312916f, -0.01992217f, -0.02096674f, 
    -0.02813622f, 0.01180681f, 0.02072728f, -0.01642485f, 0.02277230f, -0.03347686f, 0.00936689f, -0.00071978f, 
    -0.03105034f, -0.00778387f, 0.01578761f, 0.01123445f, 0.02631122f, -0.00450430f, -0.02928138f, -0.01295419f, 
    -0.00811880f, -0.00807647f, -0.00790095f, 0.01377659f, 0.02845935f, -0.02900080f, 0.02685019f, -0.00266375f, 
    0.00335177f, -0.03909724f, -0.01955421f, -0.01918690f, -0.02086302f, -0.00851948f, -0.00770400f, -0.00874832f, 
    -0.02667983f, -0.01247091f, -0.03307854f, 0.01890556f, -0.03112775f, -0.01063055f, 0.02501361f, -0.00737269f, 
    0.01024878f, 0.02733620f, -0.00058144f, -0.01360572f, 0.00902546f, 0.01861028f, -0.01769125f, 0.00029737f, 
    -0.00243311f, 0.02489197f, -0.01083415f, -0.00437849f, 0.00238120f, 0.03310712f, -0.03038991f, -0.00230271f, 
    -0.02522749f, -0.01912794f, 0.02102369f, -0.00890025f, -0.02659017f, -0.02604366f, 0.02477770f, -0.01152553f, 
    -0.03598041f, 0.01455541f, -0.01072635f, 0.01921760f, -0.03107505f, 0.02088520f, 0.00506853f, 0.00972128f, 
    -0.04310283f, 0.03210236f, -0.02233976f, -0.00468522f, 0.02102515f, -0.00252938f, -0.00266257f, 0.01874183f, 
    -0.00640654f, -0.02074510f, -0.03707692f, -0.01238933f, -0.01904167f, -0.01112582f, 0.01790660f, -0.03315429f, 
    -0.00010050f, -0.00630423f, 0.00442775f, -0.01069271f, 0.02035164f, 0.02374409f, -0.00442015f, -0.02013218f, 
    -0.01931466f, 0.03146120f, 0.01510300f, -0.02329951f, 0.00306950f, 0.00032207f, 0.00024386f, -0.01109834f, 
    0.02603545f, -0.01983405f, 0.03228236f, -0.01775351f, 0.00681404f, -0.03948284f, 0.01105972f, 0.02242068f, 
    -0.03277839f, -0.01342929f, 0.00186535f, -0.00185361f, -0.03171026f, 0.02809219f, -0.02281728f, 0.01552048f, 
    -0.02727544f, 0.01310853f, -0.03074113f, 0.00764991f, -0.00708371f, -0.03000454f, 0.01287047f, -0.00298596f, 
    -0.02139881f, -0.00253087f, -0.02518359f, -0.02565738f, 0.00018116f, 0.00799569f, -0.01416130f, 0.01325860f, 
    0.03266873f, -0.00558663f, -0.02203008f, -0.01404815f, 0.02030725f, -0.01525269f, 0.00338552f, -0.01577344f, 
    0.01635174f, -0.03563754f, -0.03801148f, 0.01659102f, -0.03457348f, 0.01330756f, -0.03567595f, -0.03464726f, 
    0.00195086f, -0.02566743f, -0.03122107f, 0.02411818f, 0.00104122f, 0.01579837f, 0.03014267f, 0.01390297f, 
    0.01092013f, 0.00735225f, -0.03299382f, -0.03136864f, -0.00296980f, -0.00552470f, -0.02771323f, 0.00268172f, 
    0.00505223f, -0.00609571f, -0.03804111f, -0.03659737f, 0.02769156f, 0.02712566f, -0.02449523f, 0.00319117f, 
    0.00700255f, -0.00000637f, -0.00621238f, 0.00535396f, 0.02200612f, -0.03207065f, -0.01367759f, -0.01096875f, 
    0.03363522f, 0.01796505f, -0.01170691f, 0.00695505f, 0.02190337f, 0.00910661f, -0.00855192f, -0.03987651f, 
    0.00424556f, -0.02659267f, 0.01624065f, -0.02702622f, 0.02487606f, -0.02685646f, -0.01980817f, 0.00914667f, 
    -0.02666460f, -0.04168032f, 0.02622289f, -0.02416557f, -0.00970250f, -0.02672134f, 0.02105154f, -0.02482208f, 
    0.00459248f, 0.02450672f, 0.03111413f, -0.00329472f, 0.00579912f, 0.02193655f, 0.00787980f, -0.01033494f, 
    -0.01343367f, -0.02576716f, -0.00861886f, -0.01639079f, 0.01457916f, 0.00814890f, -0.01412095f, -0.04009414f, 
    0.02292519f, 0.01075449f, -0.01351700f, 0.00672965f, -0.02506745f, 0.00474448f, 0.00889687f, -0.01648466f, 
    -0.01470492f, -0.02444020f, -0.03485027f, 0.00407030f, -0.03308717f, -0.00969856f, -0.02074270f, -0.00380605f, 
    -0.01455321f, -0.00577691f, -0.01960632f, 0.00221494f, 0.02844304f, 0.02498687f, -0.01452908f, -0.01796503f, 
    0.01363680f, -0.02802774f, 0.02524263f, 0.01246640f, 0.01195411f, 0.00128315f, 0.00472049f, 0.00554070f, 
    0.00750880f, 0.02787489f, 0.00917940f, 0.02643338f, -0.01844493f, -0.02332762f, -0.03493516f, -0.01244437f, 
    -0.01696179f, 0.00012869f, -0.00906258f, -0.02688467f, -0.01079538f, 0.01535773f, -0.00602195f, 0.01523662f, 
    -0.02888243f, 0.01427978f, -0.03348587f, 0.00914346f, -0.03376380f, 0.01654867f, -0.03882634f, -0.03498656f, 
    -0.00882046f, 0.02284027f, -0.03754967f, -0.02329460f, 0.00571375f, -0.01802489f, 0.00514991f, -0.03540120f, 
    -0.01128637f, -0.03097642f, 0.01737897f, 0.03343946f, -0.01286116f, -0.03256508f, 0.01909914f, -0.03694082f, 
    0.02946827f, -0.03087920f, 0.01276934f, -0.03915847f, 0.01235993f, 0.01343611f, 0.02186592f, -0.02176905f, 
    0.01258394f, -0.03855249f, -0.00210642f, -0.00479749f, 0.02410433f, 0.02120836f, -0.00557541f, -0.03290490f, 
    0.23473220f, 0.02927068f, 0.18296430f, -0.10265062f, 0.05523680f, 0.01023505f, -0.01296511f, 0.01409604f, 
    -0.04407642f, -0.05032353f, 0.07016640f, -0.05697095f, -0.08148753f, -0.00143605f, -0.09129126f, -0.02806351f, 
    -0.01678809f, 0.05784529f, 0.16011263f, 0.11561322f, 0.01243365f, 0.00578781f, 0.09895807f, 0.07025062f, 
    -0.03677152f, -0.01083344f, 0.02131875f, -0.04813763f, 0.01562631f, 0.01208360f, -0.08075321f, -0.03872858f, 
    -0.04610278f, 0.03048061f, -0.06096152f, -0.02319051f, 0.21670608f, -0.11613359f, -0.02667434f, 0.08448761f, 
    0.00730642f, -0.12517092f, -0.01406585f, 0.19272023f, 0.16393603f, 0.14650619f, 0.11304600f, 0.09348588f, 
    0.04246807f, 0.07678397f, -0.11298323f, -0.11209805f, 0.17450009f, 0.22539881f, -0.04078241f, 0.00426667f, 
    0.14616342f, 0.17118979f, 0.05733402f, 0.00245649f, 0.12495372f, 0.10919724f, 0.09420385f, 0.06259480f, 
    0.09509674f, -0.08666487f, 0.11908259f, 0.14997168f, 0.00239469f, -0.04437023f, -0.06244835f, 0.12736505f, 
    -0.22097152f, 0.11787186f, -0.05928588f, 0.04950733f, -0.06817798f, 0.02452459f, 0.00344023f, -0.06417374f, 
    0.05916431f, -0.00823012f, -0.04909257f, -0.00177325f, 0.23456752f, -0.00118452f, 0.25179404f, -0.05846173f, 
    0.12873124f, 0.13583158f, 0.06310987f, 0.05191369f, -0.05627816f, 0.09704719f, 0.20978364f, 0.05175481f, 
    -0.12201877f, 0.04634809f, -0.09507450f, -0.07073145f, -0.07028235f, 0.01964680f, 0.15916201f, 0.02639145f, 
    -0.05537814f, 0.05116800f, -0.04983490f, -0.04560766f, 0.14826596f, 0.08367348f, -0.02888365f, 0.08313631f, 
    0.12840298f, 0.09260359f, 0.09798340f, -0.05919559f, 0.01594104f, 0.06091771f, 0.12317502f, -0.03782550f, 
    -0.11837856f, 0.11666957f, -0.18314581f, -0.01807200f, 0.06385472f, 0.00967903f, 0.07487890f, -0.08649218f, 
    -0.03093821f, -0.00627494f, -0.00240495f, 0.00670469f, 0.15561397f, 0.04657903f, 0.15362161f, 0.01157124f, 
    -0.01762008f, 0.24016540f, -0.03390619f, 0.14810170f, -0.02051168f, -0.11193269f, -0.02339468f, 0.07969757f, 
    -0.09681691f, -0.00219703f, -0.02274109f, 0.01884409f, -0.03865733f, 0.03459748f, 0.15825756f, 0.02395307f, 
    0.03017762f, 0.09508668f, 0.11100347f, 0.10688545f, -0.23835106f, 0.37789631f, -0.05136736f, 0.20182166f, 
    -0.01521897f, -0.06447015f, -0.07354295f, 0.10932594f, 0.04170644f, 0.11783436f, -0.06334493f, 0.04864280f, 
    0.21458881f, -0.05515647f, -0.02703336f, -0.07505339f, 0.00734333f, -0.02591435f, -0.06166516f, -0.03448686f, 
    0.15277685f, 0.22390679f, -0.21090776f, 0.04197483f, 0.13124697f, -0.13450490f, -0.13404424f, 0.01489328f, 
    0.02339142f, 0.04314674f, 0.21710579f, 0.23409209f, 0.01974202f, 0.00215945f, 0.05524272f, 0.02066449f, 
    -0.06537494f, -0.10678027f, -0.15981273f, 0.07769730f, 0.06580611f, 0.07237677f, 0.09068198f, 0.14284775f, 
    0.00936769f, 0.00623479f, 0.00888730f, 0.00854826f, 0.09772045f, -0.14941829f, 0.18305537f, -0.08152524f, 
    -0.15004934f, 0.02068677f, 0.21963070f, 0.13887319f, 0.02459283f, -0.09914298f, 0.09013812f, 0.00758288f, 
    0.50422734f, 0.07711779f, 0.11061490f, -0.05220215f, -0.02248610f, 0.00398536f, 0.07365770f, -0.07293782f, 
    0.03013072f, 0.00081932f, 0.23587473f, 0.13694991f, -0.07596176f, 0.15346864f, 0.09515222f, 0.14805062f, 
    -0.06523394f, -0.07601362f, -0.04324619f, -0.03221413f, 0.15078829f, 0.07017499f, 0.08752707f, 0.08452239f, 
    -0.05255200f, -0.03011316f, -0.06467950f, -0.07387221f, -0.04252232f, 0.00665792f, -0.00906024f, -0.06354433f, 
    0.03039151f, 0.05169795f, 0.01969999f, 0.03953050f, 0.20351207f, -0.15865310f, 0.31931639f, 0.04864163f, 
    0.01631878f, -0.07375111f, -0.13234892f, 0.02248338f, 0.05439925f, 0.20918144f, 0.08881278f, -0.06131803f, 
    0.09141811f, 0.07733133f, -0.13507710f, -0.07474478f, 0.03559427f, -0.05901912f, 0.01228547f, 0.01885633f, 
    0.05508467f, -0.00241016f, 0.12092569f, -0.01955406f, -0.01947122f, 0.01713279f, 0.08915704f, -0.10157062f, 
    -0.16621928f, 0.10612968f, 0.09813017f, 0.02486240f, 0.03214199f, 0.04926240f, 0.04876860f, -0.07549222f, 
    0.05922735f, 0.01821437f, 0.04485232f, -0.12594971f, -0.00697256f, -0.03598391f, -0.02670229f, -0.04330300f, 
    -0.03184992f, 0.02605045f, 0.01981487f, -0.06910051f, 0.53526151f, 0.14101705f, 0.09117772f, -0.23306859f, 
    0.04230275f, -0.05718528f, -0.02402955f, 0.00446312f, -0.01513146f, 0.12586270f, 0.02511837f, -0.00853856f, 
    0.11524196f, 0.16607647f, 0.08616128f, -0.06048542f, 0.01302312f, 0.05180207f, 0.10464036f, -0.14367293f, 
    -0.02762851f, 0.01107300f, 0.05601956f, 0.02565407f, -0.26343653f, -0.03980269f, 0.16761650f, 0.09475120f, 
    -0.03819523f, -0.08567050f, 0.04126786f, 0.03674300f, 0.01492010f, -0.14311783f, 0.12046153f, 0.06303678f, 
    0.01086097f, 0.05763315f, 0.01802249f, -0.03506931f, -0.05964899f, 0.01376150f, -0.06217701f, -0.08135876f, 
    -0.09698953f, 0.02213847f, -0.17733553f, -0.10598499f, 0.08899812f, -0.18657975f, 0.14123502f, -0.04678298f, 
    -0.00090330f, 0.08841762f, 0.11741332f, -0.02175176f, 0.02220242f, 0.09736889f, -0.01608411f, 0.06822412f, 
    0.31786001f, 0.21192919f, 0.05774470f, 0.08152659f, -0.00066394f, -0.05001547f, -0.04930320f, 0.03036903f, 
    0.19464934f, 0.14135525f, 0.12469703f, 0.07319761f, 0.10115273f, -0.09991903f, 0.19492203f, -0.05959843f, 
    -0.03002319f, -0.00002633f, 0.09356667f, -0.01622203f, 0.02747241f, -0.00549425f, 0.05460323f, 0.00704793f, 
    0.09848484f, 0.08791024f, 0.01170199f, -0.13328329f, 0.17779697f, 0.10293178f, 0.13550743f, 0.08992235f, 
    -0.04303796f, -0.10235796f, -0.07429188f, -0.01858935f, 0.29637313f, 0.08076954f, 0.08550848f, -0.05096988f, 
    0.00318654f, -0.00216042f, -0.08835124f, 0.06428955f, 0.06696650f, 0.13597256f, 0.04457511f, 0.00380013f, 
    0.04789624f, -0.03380986f, -0.15243317f, -0.09805720f, 0.05615744f, -0.00620955f, 0.02417149f, 0.03462064f, 
    0.00558328f, -0.06081431f, 0.01252385f, -0.01080128f, -0.11126260f, -0.14631875f, 0.18392208f, 0.00440424f, 
    0.02077071f, 0.08200093f, 0.10816702f, 0.01160618f, 0.04830680f, -0.00720418f, 0.05153949f, -0.02662887f, 
    0.05363193f, -0.14883976f, 0.14057167f, 0.27419618f, 0.00184038f, 0.08929314f, 0.11880170f, -0.11204784f, 
    0.08275222f, 0.22026160f, -0.08847660f, -0.04554658f, -0.05031766f, 0.14924824f, -0.11094537f, 0.00213562f, 
    0.01114713f, 0.01121893f, -0.01980482f, -0.05951333f, -0.13999291f, -0.08265433f, -0.08940057f, -0.01513235f, 
    0.08595221f, -0.03876760f, 0.06475876f, 0.07008313f, 0.18518719f, 0.10076077f, 0.02474145f, 0.05121028f, 
    -0.04958208f, -0.08924911f, -0.09138906f, 0.12795389f, -0.05885254f, 0.01432897f, 0.30390474f, -0.17205411f, 
    0.03718895f, -0.05874527f, 0.04107681f, -0.04038293f, 0.02100391f, 0.03632741f, 0.03223425f, -0.16366878f, 
    -0.06084610f, 0.07379418f, -0.19615673f, 0.00058589f, -0.10654847f, 0.04927122f, 0.26624578f, 0.18279631f, 
    -0.08697370f, 0.11829583f, -0.04327331f, 0.03327372f, -0.08133309f, -0.01047215f, 0.00818443f, -0.01611597f, 
    0.00073956f, -0.05329025f, 0.02607574f, -0.01646695f, 0.08394642f, 0.04768544f, -0.15018395f, -0.02093071f, 
    0.05815451f, -0.02515443f, -0.05202965f, 0.01891469f, 0.07992236f, 0.09316409f, 0.06230828f, 0.10165291f, 
    -0.02424630f, -0.08265969f, -0.04771303f, 0.03291966f, 0.05801111f, 0.01201909f, -0.14833619f, -0.10968537f, 
    0.11517878f, -0.01636835f, 0.12198940f, 0.10646747f, 0.04923568f, 0.02057473f, -0.01555077f, 0.01497408f, 
    0.11950548f, 0.03330037f, -0.06490593f, -0.21105938f, 0.00607329f, 0.02517402f, -0.09776777f, 0.22820513f, 
    -0.00276471f, 0.09429659f, 0.14477204f, 0.02498873f, 0.05241387f, -0.05716041f, -0.07302628f, -0.10833841f, 
    0.08333212f, 0.12880285f, -0.06373304f, 0.01842561f, 0.01560444f, -0.02192176f, -0.08230194f, 0.02639364f, 
    -0.03044125f, 0.18099967f, -0.18355855f, 0.01562918f, -0.04851704f, -0.00999379f, -0.01815533f, 0.00081251f, 
    -0.03276132f, 0.01418214f, 0.03069840f, -0.08764357f, 0.08405361f, -0.02480018f, 0.02179912f, -0.13864224f, 
    0.02290188f, -0.01646465f, 0.00148696f, 0.01202644f, 0.12354714f, 0.02452751f, 0.15758494f, 0.03576362f, 
    0.32199228f, 0.06237881f, 0.05106428f, -0.22821641f, 0.05387037f, 0.06657450f, 0.10516015f, 0.16043566f, 
    -0.07218801f, -0.05763152f, -0.05633832f, -0.06584381f, 0.04058167f, -0.02601564f, -0.00716791f, -0.05077664f, 
    0.17300752f, 0.07517552f, 0.17298074f, 0.13150494f, 0.00414042f, 0.05367861f, -0.01167562f, 0.11010472f, 
    0.01142104f, 0.08124105f, -0.03079021f, -0.06042311f, 0.02795657f, 0.11650328f, 0.08026990f, 0.06523069f, 
    0.08724366f, 0.03579812f, 0.03605288f, 0.01990889f, 0.24318826f, -0.00990473f, 0.12210923f, -0.23063445f, 
    -0.01826222f, -0.05066081f, -0.08928731f, 0.09941749f, 0.22491486f, 0.10409758f, 0.15245950f, 0.14580971f, 
    -0.09956864f, 0.06756442f, 0.13735931f, 0.03082439f, -0.02668921f, 0.01667285f, 0.00638473f, 0.00958489f, 
    -0.13290846f, 0.01858422f, 0.15179050f, -0.02671715f, 0.06341202f, 0.02443268f, -0.11522309f, -0.09022975f, 
    0.07251579f, 0.01307405f, 0.13695675f, 0.02660502f, -0.02766552f, -0.04121733f, -0.09163397f, -0.01313647f, 
    -0.02574881f, 0.03779022f, 0.01613252f, -0.02202768f, 0.13245583f, -0.22601235f, -0.05302908f, -0.11468781f, 
    -0.01716474f, 0.10757952f, 0.13319750f, 0.13582671f, 0.15168744f, -0.01574777f, -0.05418599f, -0.03990703f, 
    0.10397248f, 0.06549861f, 0.05083409f, 0.07683270f, 0.02047418f, 0.01602297f, -0.04043794f, 0.07618012f, 
    0.13278255f, 0.01374298f, -0.06245001f, -0.06449631f, 0.08287347f, 0.12111599f, 0.08246762f, -0.00893268f, 
    -0.00585216f, -0.10365671f, -0.00469688f, -0.12764004f, 0.07192939f, 0.03810266f, -0.06938777f, -0.04730494f, 
    -0.01594609f, -0.12489401f, 0.28882536f, -0.14589970f, 0.06074888f, 0.07895197f, 0.16322316f, 0.04121967f, 
    -0.04838171f, 0.02218455f, 0.01733901f, 0.05488587f, -0.06936691f, 0.06915455f, 0.03317683f, -0.09144115f, 
    0.08189993f, 0.00895679f, 0.00007257f, -0.14287543f, -0.15375422f, -0.06369275f, -0.09100214f, -0.01026704f, 
    -0.04243729f, 0.13551636f, -0.08920906f, -0.06655516f, 0.00844238f, 0.06022854f, -0.04524270f, 0.05054808f, 
    0.30407599f, -0.02167662f, 0.17124283f, 0.02241589f, -0.01417343f, 0.21011303f, 0.06451333f, -0.10589600f, 
    0.06322715f, 0.00032347f, -0.04231593f, -0.07397292f, -0.00579385f, 0.06054353f, -0.08687934f, -0.11829163f, 
    0.01414623f, 0.06082312f, 0.05641517f, 0.16897216f, 0.01055154f, -0.05590397f, 0.14387225f, -0.04579780f, 
    -0.17432584f, 0.23121296f, 0.06712343f, 0.12192887f, 0.12539546f, 0.08336268f, 0.11564270f, -0.00526104f, 
    0.12932892f, -0.03187367f, 0.04442227f, 0.10051686f, 0.05250568f, 0.06446359f, -0.04332854f, -0.08378889f, 
    -0.00467125f, -0.06848732f, -0.02319951f, -0.03634059f, -0.05750491f, -0.00210163f, -0.01120098f, 0.08925197f, 
    0.09090449f, 0.11303840f, -0.03403821f, -0.14132158f, -0.02804508f, 0.27831334f, -0.01607171f, -0.08793908f, 
    -0.08743750f, 0.03714174f, -0.04421244f, 0.00316266f, -0.05699683f, 0.07612624f, 0.18763278f, 0.00214242f, 
    -0.13134699f, -0.11844168f, -0.14934759f, -0.21495743f, 0.03899187f, 0.05006251f, -0.05613741f, -0.01257518f, 
    0.09552965f, 0.05529686f, -0.03856841f, 0.05852673f, -0.04102832f, 0.01379696f, 0.02712891f, -0.09795325f, 
    0.08788633f, 0.01687415f, 0.01341485f, 0.00460562f, 0.45339492f, -0.06900750f, 0.13840635f, -0.25032228f, 
    0.01984781f, -0.00110982f, 0.04060744f, 0.00483299f, -0.12008789f, -0.08553120f, -0.01829726f, -0.00091549f, 
    0.05262773f, 0.03889693f, 0.02326851f, 0.16386247f, 0.01221444f, 0.01896748f, 0.18039300f, 0.10725870f, 
    0.05267666f, -0.06680629f, 0.03385133f, 0.13606776f, 0.12925868f, -0.17627305f, -0.23206325f, 0.10643543f, 
    0.04938192f, 0.05016812f, -0.06818785f, 0.13632634f, 0.01183204f, 0.08787085f, 0.17256184f, 0.19532689f, 
    0.00284710f, -0.04844335f, -0.02878174f, 0.03919077f, -0.05633047f, -0.04610967f, 0.01719531f, 0.03641745f, 
    -0.10219807f, -0.03167893f, 0.10142487f, -0.03273381f, 0.07008512f, -0.15445034f, -0.15814047f, 0.03083310f, 
    0.09082574f, 0.05147069f, -0.01973766f, 0.07913353f, -0.06256738f, -0.05615431f, -0.13172007f, -0.17262417f, 
    0.14682783f, 0.11402430f, -0.35544035f, -0.20056958f, -0.02885599f, 0.05440775f, 0.06553724f, 0.02573288f, 
    0.00404781f, 0.04781891f, 0.15362923f, 0.07709534f, 0.17935802f, -0.01648885f, -0.11817189f, -0.11728732f, 
    0.07970297f, 0.01921056f, -0.00141669f, -0.04240201f, 0.10915815f, 0.12375595f, -0.04490643f, -0.14231758f, 
    -0.18674108f, -0.12544325f, 0.24811006f, 0.12696105f, -0.03803316f, -0.08462213f, -0.15858951f, -0.04114238f, 
    -0.05666077f, -0.00446969f, -0.02070089f, -0.02638151f, -0.02901385f, 0.06764397f, 0.28531414f, -0.03663029f, 
    -0.17796108f, -0.03967231f, -0.08675404f, -0.18992075f, 0.03041659f, 0.05863213f, 0.03979439f, 0.00065860f, 
    0.01515898f, -0.07731669f, 0.14418538f, -0.10935891f, -0.11483358f, 0.06347299f, -0.03202522f, -0.02562689f, 
    0.08697574f, 0.00131942f, 0.17003119f, 0.13289876f, 0.03183360f, 0.08956464f, -0.02162895f, -0.08680902f, 
    -0.00600457f, -0.01949478f, -0.06104321f, 0.00360427f, -0.00164868f, 0.16350019f, 0.10921637f, -0.06131302f, 
    0.00756593f, -0.08296482f, -0.04666098f, 0.07288242f, 0.06468012f, 0.08830803f, -0.07549632f, 0.04666167f, 
    0.02508325f, -0.18766570f, 0.20357892f, 0.26624721f, 0.04275784f, 0.11061442f, -0.13618653f, 0.06607826f, 
    -0.03662026f, -0.11425226f, 0.07505538f, -0.15311439f, 0.02188059f, 0.02932294f, -0.14306560f, -0.11018908f, 
    0.31254199f, 0.07952745f, 0.01709470f, 0.03019967f, 0.07118465f, -0.02073478f, -0.14113656f, -0.07973470f, 
    -0.00886205f, -0.03840125f, -0.02231107f, -0.00659978f, 0.00251346f, 0.17229287f, 0.02884829f, 0.06584582f, 
    0.03044200f, -0.09873460f, 0.04405242f, 0.05833303f, -0.17583363f, 0.05037294f, -0.09292757f, -0.06563218f, 
    0.03239491f, -0.15071982f, -0.04713063f, 0.04023057f, 0.01137010f, -0.01362708f, -0.14885551f, -0.02706611f, 
    -0.15922020f, 0.12881497f, -0.00284233f, 0.08548503f, 0.13941467f, -0.02653602f, 0.00506809f, 0.08098399f, 
    0.05755637f, -0.02539076f, -0.10592547f, -0.03074776f, -0.14837371f, 0.08035037f, 0.12510873f, 0.20114778f, 
    0.06192164f, 0.05736989f, 0.04663123f, 0.06954154f, -0.01123744f, 0.09138720f, 0.02058893f, -0.05225556f, 
    0.02604796f, 0.06194018f, -0.05116968f, -0.11097072f, 0.38437447f, 0.09452542f, -0.16007845f, -0.10607725f, 
    -0.04023469f, -0.02257504f, -0.08574541f, 0.03377584f, -0.16266835f, -0.29901654f, 0.04844331f, -0.01301348f, 
    -0.10609591f, -0.09441752f, 0.02606392f, -0.03899978f, 0.06584005f, 0.14640018f, -0.08504540f, 0.04310943f, 
    0.07948206f, 0.14566270f, 0.03411134f, 0.12293422f, -0.02689398f, 0.04506941f, -0.04120349f, -0.06407824f, 
    0.08403346f, 0.18127109f, -0.15803927f, 0.00435819f, -0.06546042f, 0.04163498f, -0.07335439f, -0.04482271f, 
    0.09136684f, 0.00704467f, 0.04213828f, 0.00243371f, 0.02336026f, 0.07066076f, -0.03431397f, -0.05602378f, 
    -0.03417976f, 0.05085271f, -0.04367128f, -0.06070532f, 0.27710146f, -0.00863553f, 0.00350951f, -0.00345211f, 
    0.08275404f, 0.16142221f, 0.21558034f, 0.05884754f, -0.07548108f, 0.02723735f, 0.03706407f, 0.05334704f, 
    0.00176327f, -0.14688386f, 0.19612922f, 0.08898574f, 0.01689519f, 0.01039039f, 0.02865922f, 0.14420770f, 
    0.16060147f, 0.26156321f, 0.01984988f, 0.06234699f, 0.13472511f, 0.17663752f, 0.18292949f, 0.07582814f, 
    -0.05634290f, -0.11068146f, 0.04074570f, -0.10420162f, 0.07821333f, 0.16042350f, 0.12454428f, 0.15590394f, 
    0.05800516f, 0.01274008f, 0.05806834f, 0.03320987f, -0.04167130f, -0.05687894f, 0.03982934f, -0.02242745f, 
    0.19847625f, 0.10717776f, 0.18980783f, 0.12452405f, -0.01651695f, 0.03227502f, -0.00555085f, -0.11014397f, 
    -0.10603603f, -0.02859154f, 0.10371288f, 0.05797004f, 0.12819211f, -0.00328603f, 0.04061668f, -0.05669199f, 
    0.18940134f, 0.15558411f, 0.04461181f, 0.09445497f, 0.13375250f, 0.04393804f, -0.10768642f, -0.11289649f, 
    0.13179408f, 0.18655108f, 0.19148967f, 0.12087567f, 0.02868312f, -0.03535577f, 0.09149137f, -0.04330226f, 
    -0.02702610f, 0.01586366f, -0.02631719f, 0.04057728f, 0.19039743f, -0.05262988f, 0.15228505f, -0.13554238f, 
    0.05389598f, 0.04674273f, -0.05339538f, 0.00467294f, 0.06074107f, 0.01438903f, 0.09354280f, -0.06274667f, 
    -0.00270167f, 0.00255738f, -0.01630398f, 0.06462777f, 0.29464710f, 0.17870444f, 0.01321686f, -0.03458723f, 
    0.16836815f, 0.04863118f, 0.08501036f, -0.03739806f, -0.10482514f, -0.06914807f, 0.16170107f, -0.06314126f, 
    0.12893178f, 0.08278242f, 0.12954932f, 0.06508176f, 0.07529839f, -0.07181931f, -0.11832777f, 0.07757293f, 
    -0.04107876f, -0.06313691f, -0.07816548f, -0.03963269f, -0.08593604f, -0.11222305f, 0.24736723f, -0.11138355f, 
    -0.01778718f, -0.11801818f, 0.14702933f, 0.00432713f, 0.01343485f, 0.12381743f, 0.05605374f, 0.12654197f, 
    0.19147560f, -0.06719943f, -0.00996125f, 0.15339875f, 0.07917996f, 0.02772328f, 0.15114787f, -0.00281732f, 
    -0.16393653f, 0.02883606f, 0.10713920f, -0.01179266f, 0.03089183f, -0.00762310f, 0.08636144f, -0.02659183f, 
    -0.07655241f, 0.00519700f, -0.02948924f, 0.02029722f, 0.15836832f, 0.25911054f, 0.21343905f, 0.05828158f, 
    -0.20661531f, 0.04807075f, -0.12093772f, 0.00792802f, 0.02655702f, -0.08373068f, 0.00749198f, -0.04348704f, 
    -0.03491791f, -0.04569821f, -0.12342874f, -0.21966137f, -0.00149124f, -0.01887574f, -0.04086171f, 0.07109363f, 
    0.07492203f, 0.07206538f, -0.07322428f, 0.03256581f, -0.02984519f, 0.10869104f, 0.03307600f, 0.02212798f, 
    -0.05181408f, 0.02382956f, -0.00098518f, -0.04816234f, 0.05429417f, 0.22200803f, 0.03167000f, -0.04297333f, 
    0.22573502f, -0.14091687f, 0.18723081f, 0.26288000f, 0.16769861f, 0.12310223f, 0.15844682f, 0.03842918f, 
    -0.00266150f, -0.00858857f, -0.05782023f, -0.05813508f, -0.04030636f, 0.15275803f, -0.00458917f, 0.00809724f, 
    0.07426806f, -0.04836816f, 0.00700940f, 0.22891329f, 0.01939787f, -0.05700928f, 0.20462126f, 0.03196379f, 
    0.04681060f, 0.10534533f, -0.11824137f, 0.01241109f, -0.01391464f, 0.03633785f, 0.00175643f, 0.08735204f, 
    -0.10900482f, -0.05208040f, 0.05184218f, 0.06775218f, -0.02476104f, -0.06023347f, -0.05115899f, -0.19173804f, 
    -0.01201523f, 0.04420146f, 0.12576921f, 0.06786276f, -0.07058696f, 0.12879828f, -0.00816006f, -0.12055300f, 
    0.17396772f, 0.04534440f, 0.17903525f, 0.15937157f, 0.14375038f, 0.05299681f, 0.08337780f, 0.01645712f, 
    -0.02154739f, 0.03285844f, -0.09834534f, 0.05663998f, -0.03045869f, -0.02011244f, -0.01223526f, -0.09614403f, 
    0.22739518f, -0.11845098f, 0.04969010f, -0.06160076f, -0.00575750f, 0.02199085f, -0.03217484f, -0.00419517f, 
    0.07849026f, -0.09256046f, 0.08319783f, -0.04684580f, -0.00303726f, 0.05530903f, 0.08154029f, 0.03358505f, 
    0.12923001f, 0.06041146f, -0.00395040f, 0.02321089f, -0.13471958f, 0.13521466f, -0.06255691f, -0.19795556f, 
    -0.17360747f, 0.09230288f, -0.11504210f, 0.04455779f, 0.05412124f, -0.12935930f, 0.14132148f, 0.05148949f, 
    0.06136511f, -0.05367775f, 0.01001576f, -0.02610112f, 0.13412178f, -0.05181143f, -0.00340115f, 0.12898971f, 
    0.06794237f, 0.01985419f, 0.11351894f, -0.18861714f, -0.00423654f, 0.00709479f, 0.01140779f, 0.03474882f, 
    0.12216382f, 0.06655110f, 0.04171423f, -0.04552855f, -0.03239227f, 0.01727136f, 0.18842916f, -0.08546755f, 
    -0.09948363f, -0.08419424f, -0.13420062f, -0.12772475f, 0.57227725f, 0.00050071f, 0.08731914f, -0.06842849f, 
    0.02969728f, 0.06214920f, -0.04838271f, -0.00563230f, -0.07583084f, -0.10471333f, 0.00967116f, 0.10217787f, 
    0.14997765f, -0.09808420f, 0.10811987f, -0.15082134f, -0.01924798f, 0.05748979f, -0.05722846f, 0.00788148f, 
    0.02935874f, 0.13536336f, -0.11443684f, 0.04500462f, 0.03052666f, -0.01641303f, 0.11056989f, 0.08296058f, 
    -0.01108531f, -0.08915508f, 0.00924586f, 0.10475175f, -0.01000587f, 0.02308599f, 0.03970286f, 0.04028934f, 
    0.00335159f, 0.05644661f, 0.15655780f, -0.00944552f, -0.09532244f, 0.14985353f, 0.12251107f, -0.06474054f, 
    0.17236781f, 0.02454780f, 0.07075228f, 0.29795176f, -0.16859299f, -0.05663671f, 0.00977757f, -0.12014630f, 
    0.00014891f, -0.05636468f, 0.02380469f, -0.03819608f, -0.04231644f, -0.02196874f, -0.08448388f, -0.07554079f, 
    0.09265332f, 0.08189814f, -0.02041736f, -0.00036450f, -0.02753960f, -0.31189787f, 0.06945699f, 0.18373090f, 
    -0.04613835f, -0.02751267f, -0.09017947f, -0.01273205f, -0.25998488f, -0.12825397f, 0.18258448f, -0.15702215f, 
    0.01224397f, -0.00711780f, 0.07064849f, 0.03490434f, -0.05979200f, 0.14023516f, 0.06460740f, -0.09994844f, 
    -0.00047917f, 0.18021406f, -0.10332367f, -0.05137296f, 0.00838039f, 0.08388860f, -0.05940584f, -0.04788380f, 
    0.11580637f, 0.03071492f, -0.01657922f, 0.05063562f, -0.05430618f, -0.00201738f, 0.02979415f, -0.08027296f, 
    0.03897963f, -0.07669120f, -0.10404760f, -0.05770078f, -0.01928755f, -0.05678271f, -0.02910912f, -0.03328376f, 
    -0.15142405f, 0.26543725f, -0.11642901f, -0.05818577f, 0.09758132f, -0.06345298f, 0.07202999f, -0.07672196f, 
    0.00235360f, 0.12927710f, -0.07878960f, -0.00172770f, 0.08680744f, 0.01237285f, 0.10896697f, 0.07521068f, 
    0.06056856f, 0.13207972f, -0.00923520f, 0.05884336f, 0.22434160f, 0.19907199f, 0.12559617f, 0.22052917f, 
    0.04697671f, 0.09729874f, 0.01299937f, 0.20367904f, 0.04009702f, -0.05236978f, 0.07075366f, -0.01488966f, 
    -0.10810505f, 0.04322999f, -0.12224957f, -0.11296915f, 0.07075477f, 0.07802532f, 0.01313798f, -0.04058868f, 
    -0.02450391f, 0.04087119f, -0.04792545f, -0.05468260f, -0.04330092f, -0.07582144f, -0.00335654f, -0.04714983f, 
    0.25647542f, -0.06749405f, -0.02467369f, 0.30119836f, 0.04112098f, -0.01647742f, -0.08318967f, -0.20061690f, 
    -0.15082178f, 0.06084860f, -0.14094371f, 0.01821552f, -0.06423936f, 0.08235986f, 0.07016884f, -0.03572889f, 
    -0.00186191f, 0.04304780f, 0.01188780f, -0.00988162f, -0.00546955f, -0.05319703f, -0.18037207f, -0.07014364f, 
    -0.04634647f, -0.05781388f, -0.00579475f, 0.08260121f, -0.07695717f, -0.00567008f, -0.06965925f, -0.08461932f, 
    -0.01141664f, -0.02731779f, 0.00778250f, -0.13977787f, 0.01889018f, 0.49910071f, 0.27157444f, 0.16050531f, 
    -0.11376064f, -0.02897394f, 0.02273893f, 0.00059113f, 0.08049859f, -0.02230940f, -0.12175555f, 0.05784095f, 
    -0.10322870f, 0.12999704f, 0.11622144f, -0.02049942f, -0.08379859f, -0.00100088f, 0.00172619f, 0.07649983f, 
    0.03715399f, 0.11602101f, -0.00296711f, 0.06168254f, -0.00056457f, -0.03665124f, 0.42426500f, 0.05716489f, 
    -0.07830734f, -0.11020548f, -0.00094877f, -0.00523497f, 0.11441737f, -0.00533173f, -0.07878878f, -0.04438223f, 
    -0.10963894f, -0.05963755f, 0.25235352f, 0.02638232f, -0.03396499f, -0.02310414f, -0.00048522f, -0.05170462f, 
    -0.04639903f, -0.02754979f, 0.02057776f, 0.08335563f, 0.00731920f, 0.21098459f, -0.07542209f, 0.16373684f, 
    0.12496536f, -0.00837720f, 0.05786208f, -0.08087884f, -0.14293547f, -0.17219594f, -0.03420416f, -0.02431482f, 
    0.15275213f, 0.00673406f, -0.17544396f, 0.10758565f, 0.06463150f, 0.01524448f, -0.02282417f, -0.10297819f, 
    0.03344660f, 0.02848622f, -0.03446841f, 0.04323139f, -0.26189286f, 0.24626268f, -0.12829059f, -0.25628588f, 
    -0.08787631f, 0.11275449f, -0.10719678f, 0.03604519f, -0.04810826f, -0.10849515f, -0.07854313f, -0.00490069f, 
    -0.15956104f, -0.14835927f, -0.01607125f, 0.12784995f, 0.05492535f, 0.19843857f, 0.05642501f, -0.11397493f, 
    0.02982657f, -0.07151648f, 0.02441264f, 0.03428784f, -0.04033263f, -0.14643148f, -0.33314741f, 0.04620913f, 
    0.05831636f, 0.09985746f, 0.15099567f, -0.02091479f, 0.12969019f, 0.05854331f, -0.08553540f, 0.14160606f, 
    0.15169506f, 0.27190703f, -0.11638212f, -0.01960724f, 0.02064996f, -0.04855245f, -0.00189679f, -0.16995420f, 
    0.04494903f, 0.11137629f, 0.07276913f, 0.28345516f, 0.16658729f, 0.17820665f, -0.16651265f, -0.10721326f, 
    0.03888005f, -0.08738465f, 0.05723677f, -0.00255379f, -0.09660887f, -0.03552348f, -0.11781751f, 0.09825566f, 
    -0.01627193f, -0.02142834f, -0.14602076f, 0.02414950f, 0.03179357f, 0.04824937f, -0.02665921f, -0.03495162f, 
    0.09336403f, -0.02359204f, -0.05384172f, 0.23533386f, -0.01986529f, -0.04984774f, 0.23239042f, 0.10121660f, 
    -0.00918726f, 0.10161695f, -0.05939741f, -0.04877733f, 0.12559126f, 0.09542462f, -0.07645652f, -0.13122483f, 
    0.02459024f, 0.07352394f, 0.01962813f, 0.01904341f, 0.01769109f, 0.13691425f, 0.11840557f, -0.07282829f, 
    -0.04861696f, -0.05262638f, 0.03312066f, -0.03897352f, -0.08579731f, 0.03010472f, -0.08818159f, -0.04918021f, 
    -0.04942727f, 0.04525613f, -0.06237694f, 0.01821708f, -0.13897802f, 0.06331127f, -0.04351499f, 0.02478788f, 
    0.30392647f, 0.06926663f, 0.22482659f, -0.04530689f, -0.09252527f, -0.09750213f, -0.05549545f, 0.02438648f, 
    0.04350378f, -0.07633306f, 0.07979993f, -0.02726943f, -0.13902241f, 0.01576091f, 0.09779998f, -0.10298125f, 
    -0.00360055f, -0.07207680f, -0.05425989f, -0.11793477f, 0.03084459f, 0.08137809f, -0.03388494f, 0.12494642f, 
    0.03858021f, -0.02258480f, 0.05513323f, -0.14618728f, -0.02587889f, 0.05103224f, 0.05061451f, 0.05790696f, 
    -0.03554278f, 0.05029055f, -0.04819273f, 0.05680870f, 0.22695191f, 0.35410818f, 0.31848204f, 0.34878600f, 
    -0.14826599f, -0.11862113f, -0.00581431f, -0.10425290f, -0.06278793f, -0.03333405f, -0.13634688f, 0.04826016f, 
    0.00127158f, 0.07564653f, 0.00447824f, -0.01411426f, -0.01601853f, -0.09797298f, 0.03135881f, -0.02701444f, 
    0.01517535f, 0.06468610f, 0.03642164f, 0.00270674f, 0.11237029f, -0.08212300f, 0.07760386f, -0.05041928f, 
    0.22196937f, -0.13794163f, -0.01362991f, 0.04006883f, -0.03202064f, 0.09384912f, -0.04767713f, -0.01435595f, 
    -0.09805779f, 0.07618009f, -0.11340650f, 0.06579584f, 0.00092719f, 0.06904747f, 0.02769258f, 0.01837123f, 
    0.00646845f, -0.03331609f, -0.06048298f, 0.03765569f, -0.00645030f, 0.19447286f, 0.00134951f, 0.28848007f, 
    -0.14808725f, -0.04919655f, -0.01304546f, 0.16679999f, -0.00744762f, 0.13403948f, 0.06030431f, 0.06390206f, 
    -0.09080827f, 0.10584074f, -0.25589982f, 0.16171643f, -0.01334307f, -0.05203068f, 0.01977273f, 0.02120318f, 
    0.23225230f, -0.00774197f, -0.20153804f, 0.19104914f, 0.14830475f, -0.02360326f, -0.07970904f, -0.24974714f, 
    -0.05580891f, -0.04953941f, -0.03054382f, -0.04223273f, 0.01967817f, -0.02606330f, -0.04318867f, 0.05842570f, 
    0.01634449f, -0.06820443f, 0.01124023f, -0.02541543f, -0.10233935f, -0.14016020f, -0.02873268f, -0.09600072f, 
    0.19401628f, 0.13506706f, 0.08258723f, 0.16874376f, -0.34659162f, 0.16450489f, -0.05501070f, -0.30347016f, 
    0.03978471f, 0.02808950f, -0.04377626f, -0.01664506f, -0.11935684f, 0.07657932f, 0.04155128f, -0.06208536f, 
    0.13489361f, -0.10428484f, 0.10599592f, 0.16550097f, -0.08265892f, -0.13968897f, 0.06343676f, 0.02056959f, 
    0.06732062f, 0.03777098f, 0.09023554f, 0.04431228f, -0.07403135f, 0.03764838f, -0.01379543f, 0.02702822f, 
    -0.00330786f, -0.10280446f, -0.06120395f, 0.08507679f, -0.00226934f, 0.08136429f, -0.15849298f, -0.21190433f, 
    -0.10929018f, 0.10935481f, 0.02234351f, 0.14037292f, -0.20907044f, -0.02366429f, -0.03303830f, -0.03138517f, 
    -0.00725424f, 0.01789953f, -0.03920902f, -0.17221731f, -0.19652121f, 0.17109852f, 0.02518468f, 0.09832694f, 
    0.11078219f, 0.11402603f, 0.02038077f, 0.01568542f, 0.01647855f, -0.11166589f, -0.14765242f, 0.08128926f, 
    -0.01192985f, 0.15776274f, 0.23357470f, 0.12135171f, -0.04808334f, -0.11031447f, -0.08897325f, 0.14713742f, 
    -0.01463981f, -0.10950314f, -0.03176863f, 0.03080512f, 0.16238123f, 0.30559245f, 0.16164188f, 0.03960752f, 
    0.05225190f, -0.12111469f, 0.02137757f, 0.17873938f, -0.00623404f, -0.06084036f, -0.15988989f, 0.06477980f, 
    0.20021144f, 0.25814071f, 0.22568992f, 0.00418180f, 0.09176207f, 0.02812279f, 0.00470025f, -0.02871170f, 
    -0.10612181f, -0.06302487f, 0.02556563f, 0.01527253f, -0.06418181f, 0.02546209f, -0.06212157f, -0.03886431f, 
    -0.04255094f, -0.10532207f, -0.01019987f, -0.10013278f, 0.06406864f, 0.11613233f, 0.00820464f, 0.07247769f, 
    -0.15003371f, -0.07353497f, 0.13476171f, 0.00658372f, -0.05283113f, 0.08012481f, 0.12689285f, 0.18136328f, 
    0.06325277f, -0.07194193f, 0.01508094f, 0.15784489f, -0.00350080f, 0.24564202f, -0.19578540f, 0.23684479f, 
    -0.05230170f, -0.01508435f, 0.06951324f, 0.04436981f, 0.02799608f, -0.01877864f, -0.12190905f, 0.01306912f, 
    0.04954862f, -0.01313404f, -0.07365678f, -0.01025036f, 0.20316730f, -0.20760964f, 0.03022139f, -0.16611879f, 
    0.05584457f, 0.01543674f, -0.09017658f, 0.07543033f, 0.01518519f, -0.11510168f, 0.06648054f, 0.00686565f, 
    -0.02727260f, -0.03843845f, -0.03280821f, -0.06059194f, -0.01181959f, -0.05646464f, 0.00852987f, 0.04705991f, 
    -0.03060775f, -0.22029378f, 0.01624444f, -0.05414181f, -0.01796418f, 0.07476926f, -0.09623516f, 0.05978560f, 
    0.07373693f, -0.02709501f, -0.01843206f, -0.04928100f, -0.06669602f, 0.00466385f, 0.17717332f, 0.16769002f, 
    -0.05188906f, 0.02850142f, 0.04222661f, 0.08797101f, -0.02788737f, -0.07295600f, 0.06220492f, 0.04081893f, 
    -0.13148522f, 0.11407602f, 0.12330024f, 0.08514947f, -0.17666031f, -0.29732442f, 0.07831997f, 0.01340357f, 
    0.15597466f, 0.05887490f, 0.06631180f, 0.00849939f, 0.00426766f, 0.20942539f, 0.11220851f, 0.14360268f, 
    -0.14879210f, -0.13072047f, 0.01343212f, 0.11093228f, -0.07314277f, -0.07148111f, 0.04946096f, 0.02033237f, 
    -0.26004288f, 0.05181821f, -0.15760009f, -0.07834003f, 0.01546385f, -0.05144370f, -0.08512140f, -0.04141551f, 
    0.03753333f, -0.04819695f, 0.01004736f, 0.10188971f, 0.03614796f, 0.00938903f, -0.12857796f, 0.18687008f, 
    0.06676549f, 0.00368301f, 0.05184771f, -0.03140571f, -0.08848269f, 0.01107954f, -0.03074517f, -0.00060907f, 
    0.02203847f, -0.35780269f, 0.05744109f, -0.04670281f, -0.13337649f, 0.08649379f, -0.15701631f, 0.04544762f, 
    0.05363405f, 0.07371896f, -0.01697415f, 0.00291337f, -0.08248461f, -0.02305281f, 0.14162759f, 0.04411623f, 
    -0.01394001f, 0.13572349f, -0.06008301f, 0.09573086f, 0.16876847f, -0.04354993f, -0.01871314f, -0.00004384f, 
    0.06270964f, -0.03574612f, -0.08467265f, 0.12112076f, 0.04578803f, -0.00677988f, 0.12576471f, -0.00181065f, 
    -0.02403017f, -0.05501529f, -0.00501631f, -0.14416611f, 0.01515417f, 0.47132725f, 0.05517310f, 0.07713141f, 
    -0.09748146f, -0.21590227f, -0.09999769f, -0.03040255f, 0.07067556f, -0.04601692f, -0.04705139f, 0.03131500f, 
    0.19920759f, 0.08830260f, 0.06744266f, -0.00054701f, 0.01146547f, 0.01823916f, -0.01113049f, -0.08045834f, 
    -0.06779027f, -0.02773144f, -0.02527747f, 0.20477755f, 0.05119257f, 0.11978563f, 0.17468776f, 0.05399077f, 
    -0.12875092f, -0.01878737f, 0.07762820f, 0.07437113f, 0.05959166f, 0.15435460f, 0.00103890f, 0.02566561f, 
    0.19431104f, -0.15920587f, -0.05584877f, 0.01913559f, -0.10162618f, -0.00142151f, -0.03047727f, 0.08958993f, 
    0.09016325f, -0.14584835f, 0.00675533f, -0.08699507f, -0.15131237f, -0.05236193f, 0.14199951f, 0.05630332f, 
    0.00215930f, 0.08407726f, -0.07764804f, -0.00030444f, -0.09086163f, 0.05630850f, 0.02751182f, -0.09031866f, 
    -0.08492890f, 0.01467271f, 0.03078194f, -0.13010228f, -0.05300842f, 0.01388371f, -0.15093195f, 0.04223165f, 
    0.06005635f, -0.03883800f, -0.02944828f, -0.01119305f, -0.31988260f, 0.25478789f, 0.23429249f, -0.32573521f, 
    -0.04828576f, -0.03618941f, 0.05498782f, 0.00794737f, 0.02776153f, -0.00669582f, 0.04431811f, -0.00030153f, 
    -0.02042365f, -0.04951021f, 0.08240070f, -0.22553460f, 0.03168609f, -0.15588367f, -0.06677012f, -0.06218973f, 
    0.13203035f, -0.05858139f, -0.00649633f, 0.10876916f, -0.04256476f, 0.05713043f, -0.06480011f, -0.23064035f, 
    0.04862592f, -0.02945417f, -0.03798561f, 0.07027075f, -0.02241504f, -0.07685584f, -0.01217780f, -0.08711796f, 
    -0.53946239f, -0.22643408f, -0.09258276f, 0.25593373f, -0.08267768f, -0.07919446f, -0.09425591f, -0.06697419f, 
    -0.08665837f, 0.01466982f, 0.00983421f, 0.12872057f, 0.07751262f, 0.02852679f, 0.02627209f, 0.04006154f, 
    0.04654330f, 0.02665054f, 0.01153422f, -0.03194320f, 0.03171358f, 0.03769909f, -0.05717133f, 0.04100654f, 
    0.19136092f, -0.11877237f, 0.17909817f, -0.09171432f, 0.01413780f, 0.11185281f, 0.03050877f, -0.02441137f, 
    0.05187782f, -0.09023449f, 0.02900044f, -0.13767830f, -0.02397386f, 0.02593054f, 0.09706019f, -0.03291057f, 
    0.00561477f, -0.03448660f, 0.13241932f, -0.01528884f, 0.09269953f, 0.05512412f, 0.11521372f, 0.05450671f, 
    0.10160176f, -0.01791884f, -0.12020757f, 0.15498751f, -0.16762659f, -0.01768366f, 0.06204566f, 0.00648741f, 
    0.14354250f, 0.07148105f, -0.00416551f, -0.05471395f, 0.16602208f, 0.03970739f, -0.10243776f, -0.00739916f, 
    0.14236321f, 0.00897727f, -0.02694031f, 0.12270012f, 0.04908041f, 0.01308745f, 0.03128952f, -0.07191953f, 
    -0.07764428f, -0.06644543f, -0.00773612f, -0.03757737f, -0.01676041f, 0.07733725f, -0.01002615f, 0.04541890f, 
    0.01614563f, 0.05818456f, 0.00328555f, -0.00697902f, -0.00763879f, 0.33314154f, 0.06319439f, 0.18303899f, 
    0.02282782f, 0.13194221f, 0.03482623f, -0.17412192f, -0.06874921f, 0.02223913f, -0.12130123f, -0.02927229f, 
    0.18096529f, 0.19351509f, 0.16785792f, -0.10632178f, -0.05251807f, -0.06553703f, -0.05009319f, 0.01689746f, 
    -0.08557321f, -0.04362377f, -0.01942837f, -0.00986768f, -0.05566232f, 0.02289434f, -0.04708695f, 0.00302020f, 
    0.06957065f, 0.03669171f, -0.03250828f, 0.00735384f, 0.10661779f, 0.03764724f, -0.17713489f, -0.04744256f, 
    0.20835023f, -0.13986419f, -0.23918252f, -0.09451774f, 0.09120508f, 0.03454859f, 0.03976692f, 0.03372996f, 
    0.02125788f, 0.06390762f, 0.03854546f, 0.08739801f, -0.06374621f, 0.11761730f, 0.13291009f, 0.00222940f, 
    -0.01206228f, 0.05077605f, 0.02806098f, -0.06315544f, -0.07499491f, -0.22474307f, -0.07862016f, -0.05834951f, 
    -0.11124325f, -0.00662015f, 0.01325964f, 0.11896239f, -0.01276886f, -0.13282394f, -0.09781916f, -0.09770861f, 
    0.04251750f, -0.01004870f, -0.07115629f, 0.01401062f, -0.10694873f, 0.03976777f, 0.15407979f, -0.12017640f, 
    -0.23149812f, 0.13755707f, -0.03252702f, 0.04087259f, -0.11378548f, -0.05596989f, -0.08912022f, 0.00768334f, 
    -0.03437950f, 0.07051441f, 0.12914814f, 0.04890951f, 0.03040062f, -0.00965448f, 0.02378839f, 0.07687333f, 
    0.05179645f, -0.02229911f, 0.13143724f, 0.02883202f, -0.02127133f, 0.05257776f, -0.02654303f, -0.14787106f, 
    0.07364801f, -0.09762739f, 0.00378775f, 0.22568920f, 0.08368909f, 0.03713173f, 0.06130979f, -0.06337694f, 
    -0.15345481f, 0.04880415f, -0.21961424f, -0.06745351f, 0.07875323f, -0.02610228f, -0.07438745f, -0.05006774f, 
    -0.05162691f, -0.05880739f, -0.00503432f, 0.09850349f, -0.23271547f, -0.05700054f, -0.35346270f, 0.07037738f, 
    0.09304879f, -0.04929484f, 0.03395812f, -0.01607398f, -0.07842367f, 0.02433995f, 0.02199804f, 0.04685243f, 
    -0.07725375f, -0.01169025f, -0.10349435f, -0.08388626f, 0.06214733f, -0.03041778f, 0.05321462f, -0.03892578f, 
    -0.03832611f, 0.07870225f, -0.16585663f, 0.14855868f, 0.12839445f, 0.13110024f, 0.21631695f, -0.09043088f, 
    0.03308620f, 0.09692740f, 0.10991966f, 0.09801650f, -0.02185614f, -0.01117309f, 0.05658055f, 0.05990148f, 
    -0.11793644f, 0.06988832f, -0.00880932f, -0.12171062f, -0.06411888f, -0.05108927f, -0.03918255f, -0.08618101f, 
    0.02342922f, -0.01452329f, 0.08610331f, 0.04434978f, 0.00205450f, 0.10052601f, 0.03375928f, 0.02625681f, 
    -0.01106384f, 0.09411842f, -0.05378603f, 0.15388285f, 0.08739772f, -0.00979239f, 0.00405143f, -0.01869470f, 
    0.10028565f, 0.18629149f, 0.10877468f, 0.11746674f, 0.02806332f, 0.10374948f, 0.12423047f, 0.10631505f, 
    0.08918618f, -0.13082618f, 0.02978496f, -0.07340167f, -0.42222306f, 0.02613471f, 0.05020800f, -0.10293731f, 
    0.02643651f, -0.00321201f, -0.01080603f, -0.00599555f, 0.14053208f, 0.01985940f, 0.04274514f, 0.01229067f, 
    -0.08846384f, -0.12114536f, -0.07276769f, -0.03691781f, 0.03321261f, 0.00956343f, -0.02299183f, 0.08590352f, 
    0.01330222f, -0.01319519f, -0.00805161f, 0.10589933f, -0.10430839f, 0.03247678f, -0.04213485f, 0.20507555f, 
    -0.04355676f, 0.01733723f, 0.11832453f, 0.05619030f, 0.13656284f, 0.12678045f, -0.10820875f, 0.05447925f, 
    0.08509615f, 0.10672948f, 0.07763006f, 0.02606180f, 0.01875828f, -0.03550978f, -0.03365858f, -0.02848207f, 
    0.04305941f, -0.01247032f, -0.07341126f, -0.01347763f, 0.04470130f, 0.06639078f, 0.00407970f, 0.05438948f, 
    0.04659508f, -0.22270517f, 0.09812642f, -0.05811530f, -0.02558233f, -0.00262746f, -0.02971444f, -0.12632781f, 
    -0.17933032f, -0.12769063f, -0.06929296f, 0.07888685f, -0.02349426f, 0.02346120f, 0.04771995f, 0.05639256f, 
    0.14803033f, -0.10060018f, -0.06165551f, -0.09531339f, 0.26045910f, 0.38317889f, 0.16365738f, 0.22898589f, 
    0.10519947f, 0.09880953f, 0.07288085f, -0.05940668f, -0.00586094f, -0.00316019f, -0.01468563f, -0.03027156f, 
    -0.11912153f, 0.09939712f, -0.11014703f, -0.04682205f, -0.00430094f, -0.00664859f, -0.09898862f, -0.04096746f, 
    0.03459410f, -0.07661151f, 0.06689886f, -0.00865489f, -0.04902608f, -0.27534127f, -0.33732015f, -0.29807171f, 
    0.04936137f, 0.06383706f, -0.05163778f, 0.03031510f, 0.01185167f, 0.04003355f, 0.03738360f, -0.03504162f, 
    -0.10105196f, -0.15768909f, -0.06611845f, -0.00745059f, 0.03674063f, -0.00426763f, 0.05354903f, 0.01025747f, 
    0.00343686f, -0.05683330f, 0.11590734f, 0.14210139f, -0.10039292f, 0.20016417f, 0.07311963f, -0.07735736f, 
    -0.06923769f, 0.04801561f, 0.04777418f, 0.06316424f, 0.01167598f, -0.04536115f, 0.00057004f, 0.01004445f, 
    0.14311297f, -0.31027073f, 0.07613119f, -0.10040113f, -0.06912818f, -0.02865484f, 0.06831460f, 0.06816690f, 
    0.08014292f, -0.01233998f, -0.01281299f, 0.09085967f, -0.01156358f, 0.00850846f, -0.04738283f, 0.07471374f, 
    -0.06407150f, -0.06632080f, -0.02185489f, 0.09789658f, -0.12361217f, 0.09682734f, -0.11967862f, 0.04772962f, 
    0.00922545f, 0.23508486f, 0.13247597f, 0.07972723f, -0.03447483f, 0.07499467f, 0.09360176f, 0.07871085f, 
    -0.00543496f, -0.03264518f, -0.08857087f, -0.01228997f, -0.23429540f, -0.03822656f, 0.17084199f, 0.03760621f, 
    0.00611516f, -0.00999179f, 0.05007701f, 0.02902878f, -0.00217724f, 0.00300318f, -0.23204027f, -0.02664319f, 
    0.22486290f, 0.36118701f, 0.19245866f, 0.08182155f, 0.00868528f, 0.13218662f, 0.01121320f, 0.07304462f, 
    0.01936964f, -0.04440093f, -0.01191905f, -0.04066987f, 0.21306099f, 0.10423867f, -0.26226959f, 0.01430982f, 
    0.08656102f, -0.04697818f, -0.06151787f, 0.05141231f, -0.03281843f, 0.00835904f, -0.04373504f, -0.00304243f, 
    0.06524809f, 0.19308309f, -0.04687868f, -0.15436530f, 0.06215651f, -0.00567139f, -0.10988233f, -0.01646992f, 
    -0.08528416f, -0.03565991f, 0.05620636f, -0.02324831f, -0.10182316f, -0.16286741f, -0.01213636f, -0.01037257f, 
    0.00479277f, 0.00751220f, 0.05626945f, 0.04281993f, 0.06518319f, -0.07713847f, -0.01433769f, 0.13599169f, 
    0.11393058f, -0.05003301f, 0.26101455f, -0.03469041f, -0.00375892f, 0.05367390f, 0.04836408f, 0.02021726f, 
    -0.02472436f, -0.15426774f, 0.06366758f, 0.00037751f, 0.02672703f, 0.12411350f, -0.24967805f, 0.16428123f, 
    -0.05170903f, 0.09124731f, 0.01821744f, 0.00495747f, 0.05819251f, -0.05352576f, -0.06594477f, 0.00839293f, 
    0.05279087f, 0.00359742f, 0.05550545f, 0.07969742f, 0.16101322f, -0.13457449f, -0.10425966f, -0.23426287f, 
    0.03506530f, -0.02715456f, -0.07986841f, -0.03231829f, -0.06061141f, -0.29347432f, -0.24197961f, -0.04452534f, 
    0.02903084f, 0.06256545f, 0.06624930f, 0.03241991f, 0.03543762f, 0.05569383f, 0.09153990f, -0.06413793f, 
    0.08668677f, 0.07702342f, 0.08442178f, -0.21575607f, 0.03916727f, 0.00359605f, -0.05665419f, 0.04098288f, 
    -0.02648628f, -0.08801325f, 0.06451601f, -0.05598198f, 0.05350332f, 0.10004951f, 0.11205184f, -0.03569554f, 
    0.04399005f, 0.11157511f, 0.05113607f, -0.05054026f, -0.06965894f, -0.08003213f, 0.01233786f, -0.00002254f, 
    0.25026679f, 0.15598001f, 0.10009471f, 0.10318156f, 0.09752709f, 0.04862417f, 0.13172428f, 0.01168771f, 
    0.03885705f, 0.09838649f, -0.05588223f, -0.02868417f, 0.08064840f, 0.18997137f, 0.09848256f, -0.02847791f, 
    0.00098772f, 0.06462224f, 0.10263218f, 0.00704206f, -0.04813658f, -0.10622846f, 0.03127212f, -0.00967386f, 
    -0.37000057f, -0.36891651f, 0.11352696f, 0.09299036f, 0.02867086f, -0.00331784f, -0.04197719f, 0.01143551f, 
    0.05448712f, 0.06094227f, -0.17461285f, 0.11705926f, -0.04246222f, -0.09169453f, -0.08355997f, 0.10294510f, 
    -0.02660692f, 0.05626890f, 0.10207675f, 0.01499732f, 0.10412250f, -0.03190170f, -0.02841873f, 0.03645605f, 
    0.36646885f, -0.04770158f, 0.24875247f, -0.08946605f, -0.00250884f, -0.00252868f, 0.07950676f, 0.04803520f, 
    0.11725733f, 0.01319971f, -0.08723857f, -0.07834407f, 0.14780191f, -0.02169888f, 0.19980328f, -0.10646608f, 
    0.00688515f, -0.01913558f, -0.00728304f, 0.08263480f, -0.02274657f, 0.02572772f, 0.04210929f, -0.00637029f, 
    0.00233500f, 0.01780056f, 0.00018488f, 0.11321530f, -0.02502988f, 0.00670815f, -0.04463745f, -0.02070191f, 
    -0.06469226f, 0.01550790f, 0.03852268f, -0.01088527f, -0.32907304f, 0.37420934f, 0.10627691f, 0.13730884f, 
    0.08053470f, 0.09720768f, 0.23167770f, 0.16342205f, 0.09507819f, 0.11031294f, 0.02165698f, -0.10250508f, 
    -0.02582420f, 0.04132617f, -0.08235223f, -0.01835326f, -0.00434786f, 0.02112050f, -0.01640435f, -0.01883873f, 
    -0.08410883f, 0.00419597f, 0.09682315f, 0.02552179f, 0.22724903f, 0.16654126f, 0.06743949f, -0.03808530f, 
    -0.02721151f, 0.00918814f, 0.03917024f, 0.00441536f, -0.10505161f, -0.09359452f, -0.07631850f, -0.02194147f, 
    0.01530097f, -0.04975167f, -0.02233748f, 0.03011326f, -0.05633563f, -0.01118317f, -0.04461252f, -0.01351771f, 
    0.10038617f, 0.02168948f, 0.09655821f, -0.12471215f, 0.23529275f, -0.05003717f, 0.31571957f, -0.04230878f, 
    0.04192062f, -0.01018542f, 0.01491869f, 0.13420905f, 0.02920906f, -0.04969463f, -0.03809475f, -0.05098289f, 
    0.13161384f, 0.20739150f, 0.06429478f, -0.10784317f, 0.10130626f, 0.08429017f, -0.04708762f, 0.11852024f, 
    -0.00707349f, 0.01405584f, 0.02831488f, 0.01903131f, -0.01278847f, -0.14307684f, 0.09862544f, -0.02611201f, 
    0.00501143f, 0.05668999f, -0.13978739f, -0.07877383f, 0.05647772f, -0.03840618f, -0.19250205f, 0.05275861f, 
    -0.07541560f, -0.07655130f, -0.05642194f, -0.05976446f, 0.02649770f, -0.16323787f, 0.07413094f, 0.01454089f, 
    0.04192637f, -0.05913251f, 0.09855818f, -0.10492722f, 0.13393860f, 0.18108387f, 0.04868996f, -0.11297885f, 
    -0.03472573f, -0.07595860f, 0.12288143f, 0.12067859f, 0.00494841f, 0.02530741f, -0.02159493f, -0.04909360f, 
    -0.45446542f, -0.30137742f, 0.42691800f, 0.10084007f, -0.04762646f, 0.04696174f, 0.05427486f, 0.12261903f, 
    0.14635584f, -0.08957352f, 0.01735678f, 0.08632790f, 0.02195080f, 0.07754040f, 0.03377922f, 0.11746755f, 
    0.03241647f, 0.06093457f, -0.11395724f, -0.15185946f, -0.06762083f, -0.01567800f, -0.04747544f, -0.01268290f, 
    0.12227581f, -0.04316066f, 0.00250224f, -0.06932899f, -0.08890428f, 0.01178095f, -0.02220281f, 0.02104037f, 
    -0.01919442f, 0.01289336f, -0.07657068f, -0.03729669f, -0.05456811f, -0.01646982f, 0.02923363f, 0.06716557f, 
    0.05106408f, 0.03121319f, 0.09035673f, 0.04923234f, -0.08237013f, -0.05939768f, -0.08958227f, -0.03728209f, 
    -0.33897126f, -0.05157305f, -0.12202770f, 0.07211205f, 0.06400589f, -0.14840765f, 0.01649838f, 0.01618418f, 
    0.04328319f, -0.00539371f, -0.04648722f, -0.02609328f, 0.12408429f, 0.27338269f, 0.05907649f, 0.04901591f, 
    0.15914156f, 0.01548739f, -0.13924788f, 0.02785050f, 0.01688537f, 0.12236455f, 0.21116593f, -0.07823964f, 
    -0.02294742f, -0.04526138f, 0.00244486f, 0.02464149f, 0.03312697f, -0.08442619f, 0.02716374f, 0.03512118f, 
    -0.03040430f, 0.20161855f, -0.01156478f, -0.05446469f, -0.03112416f, -0.06245721f, 0.40948212f, -0.19656061f, 
    -0.06999705f, -0.10098688f, -0.05041661f, -0.07562307f, -0.04704345f, 0.07656806f, -0.05240550f, -0.01771121f, 
    0.20740558f, 0.09118848f, 0.19954124f, 0.01003582f, 0.10599475f, -0.06156795f, 0.03660770f, -0.06680947f, 
    -0.10712799f, 0.11790840f, -0.01563969f, -0.00190349f, -0.02010766f, 0.17671657f, -0.19628575f, -0.20738670f, 
    0.04500356f, -0.01993132f, -0.07252504f, 0.01741790f, 0.02682307f, 0.04563029f, 0.17402273f, 0.02837746f, 
    0.20150912f, -0.18180469f, -0.17803387f, 0.01711708f, 0.10232358f, -0.11517190f, -0.09312864f, 0.02697654f, 
    0.14868766f, -0.10799803f, 0.05091580f, -0.05356523f, -0.06331317f, 0.03773613f, 0.01591328f, -0.04846895f, 
    0.00118099f, -0.05722613f, -0.01436167f, -0.06946336f, -0.10862926f, -0.08127404f, -0.20457099f, -0.06561624f, 
    -0.00799601f, 0.07192044f, 0.32284328f, 0.04909706f, 0.08994666f, 0.00116138f, -0.12219564f, -0.00534301f, 
    0.08091104f, 0.00851971f, -0.06776298f, 0.12790245f, 0.07789582f, -0.53924537f, -0.03898624f, -0.05036603f, 
    -0.00023396f, 0.05329665f, -0.06424347f, 0.18455571f, -0.02143467f, 0.00760211f, -0.01077628f, -0.09117412f, 
    0.29304734f, 0.00445159f, 0.44832155f, 0.25113088f, 0.10938188f, 0.00235602f, -0.19099639f, 0.11357832f, 
    -0.01543570f, -0.04746777f, 0.03285373f, -0.05085551f, -0.01437583f, 0.04862683f, 0.08632198f, 0.09714729f, 
    0.03100950f, -0.10024153f, -0.14153910f, -0.00201347f, -0.03840489f, -0.06300343f, 0.04747678f, -0.04267811f, 
    -0.15282264f, 0.14799111f, -0.05130387f, -0.11604302f, 0.03049404f, 0.01740460f, -0.04905091f, 0.08851482f, 
    0.13627161f, -0.01123210f, 0.01664974f, 0.14290722f, -0.09502079f, -0.25873521f, -0.08258586f, 0.10121328f, 
    0.06599127f, 0.01177560f, -0.03914924f, 0.14016895f, 0.00856924f, -0.14091843f, 0.04122337f, 0.00426681f, 
    -0.12364113f, -0.14481227f, 0.00900647f, 0.05021917f, 0.06070969f, -0.06676652f, 0.00259238f, 0.07989193f, 
    0.09952191f, -0.02272375f, 0.10536834f, -0.07582895f, 0.08389623f, 0.09127210f, 0.15126440f, 0.00484984f, 
    0.04399738f, 0.00431534f, -0.08448201f, 0.15578865f, -0.13832171f, -0.09641998f, 0.05291294f, 0.12092910f, 
    -0.11641842f, 0.23442188f, 0.23307693f, -0.07972249f, 0.11878870f, -0.00235351f, -0.15164378f, 0.05157256f, 
    0.01032251f, 0.00877952f, 0.05474810f, -0.17297439f, 0.14077953f, 0.25252709f, -0.07411351f, -0.01459977f, 
    0.16666308f, 0.00723850f, 0.12255263f, 0.08706591f, 0.03330448f, -0.01004367f, -0.13367420f, -0.15438531f, 
    0.04828050f, 0.23210068f, -0.25554016f, 0.11487716f, 0.05998411f, -0.12953338f, -0.14330930f, -0.03137962f, 
    0.02510075f, -0.06031820f, 0.07656468f, -0.01040300f, -0.17438850f, 0.08516652f, 0.00173496f, -0.07235964f, 
    -0.05982494f, 0.00598248f, -0.02625550f, 0.07065187f, 0.17672956f, 0.07142130f, -0.06218450f, 0.21484978f, 
    -0.19546404f, -0.13493189f, -0.02601329f, 0.05888758f, 0.17009431f, -0.08498184f, -0.09636670f, 0.09043529f, 
    0.09797407f, -0.02792560f, -0.02287864f, 0.05178226f, -0.26967776f, -0.02247337f, 0.08057122f, 0.13872591f, 
    0.13794443f, -0.03641977f, 0.03518118f, -0.15172845f, 0.17347699f, -0.19287619f, -0.00665925f, -0.01598496f, 
    -0.00971091f, 0.14939380f, 0.11106811f, 0.13628612f, 0.01265353f, -0.00753059f, -0.06127597f, -0.09052546f, 
    0.00321069f, 0.15708151f, 0.04634617f, 0.18252438f, 0.05635713f, 0.28886175f, -0.19407910f, -0.06921393f, 
    0.10358176f, 0.04591300f, -0.04778534f, 0.04995681f, 0.00897444f, -0.02024264f, -0.16789064f, -0.13690072f, 
    -0.03720747f, -0.20723510f, -0.07985593f, 0.23129232f, -0.06061798f, -0.11907586f, -0.04481579f, -0.12114016f, 
    -0.00954268f, 0.07963260f, 0.01742378f, 0.05974220f, 0.33430642f, -0.24739656f, 0.10795522f, 0.07342156f, 
    0.05438224f, -0.02925791f, -0.08054397f, -0.10158518f, 0.15826194f, 0.04080890f, -0.05523753f, -0.12980066f, 
    0.04266370f, -0.06439701f, 0.10274482f, 0.19887912f, -0.02132295f, 0.11511426f, 0.02252215f, -0.03436783f, 
    0.03627964f, -0.03893366f, 0.17960726f, 0.16896784f, 0.00078634f, -0.04722433f, -0.16347963f, -0.11371442f, 
    0.03785347f, 0.08866699f, -0.03819433f, 0.02802757f, 0.03706014f, 0.16106975f, -0.05545815f, -0.01584574f, 
    -0.05018284f, -0.17973897f, -0.16578765f, 0.06606831f, 0.04894629f, 0.06903726f, 0.04833456f, 0.06417885f, 
    0.11307308f, 0.05600708f, 0.10781784f, 0.24814765f, 0.16115175f, 0.29837900f, -0.07505693f, 0.10403787f, 
    0.03669212f, -0.01856877f, -0.03063002f, 0.24595018f, 0.12448193f, -0.03274080f, -0.00068237f, 0.01564895f, 
    -0.27707547f, -0.10120775f, 0.10620780f, 0.28286475f, 0.02798563f, 0.03245341f, 0.03093779f, -0.07387880f, 
    -0.02610939f, 0.01650563f, 0.01135275f, 0.15667383f, -0.05744608f, -0.02219608f, -0.04786113f, 0.03507063f, 
    -0.05012291f, 0.02640708f, 0.00416551f, 0.06118879f, 0.13504823f, 0.03487084f, -0.08667105f, 0.12861256f, 
    0.00588051f, 0.10583363f, 0.25070161f, 0.08297394f, 0.01065882f, -0.03772930f, 0.02039730f, 0.16245475f, 
    0.02178391f, 0.05236764f, 0.10949396f, 0.04952544f, -0.09040663f, -0.16320288f, 0.15884775f, 0.39120772f, 
    0.09609640f, -0.02032133f, 0.00229012f, -0.06422492f, -0.03337022f, -0.08195675f, 0.03745208f, -0.09808471f, 
    0.09517370f, 0.16662110f, 0.07818398f, -0.01096860f, 0.11296476f, 0.04893905f, 0.07699773f, 0.12249977f, 
    0.06271432f, -0.07407185f, 0.00877634f, -0.17149432f, -0.18515252f, 0.13002685f, 0.04839454f, -0.21486311f, 
    -0.13226567f, 0.06232024f, 0.01245501f, 0.02027488f, 0.02641058f, 0.09342944f, 0.03854561f, 0.15583058f, 
    -0.24340585f, 0.07338554f, 0.02660335f, -0.33742845f, -0.08827756f, 0.01336443f, -0.21587713f, -0.04719079f, 
    0.03535571f, -0.11599543f, -0.01757989f, 0.00443605f, -0.13687152f, -0.20696144f, -0.02354200f, -0.11404737f, 
    0.05825867f, 0.02000798f, 0.02650629f, 0.03351470f, 0.21869805f, 0.02514470f, 0.15032664f, 0.10803106f, 
    0.44408652f, 0.15248109f, 0.05411713f, 0.00126523f, 0.12745243f, -0.02617524f, 0.04925918f, -0.03626557f, 
    0.00392006f, -0.03944950f, 0.04584615f, -0.07203414f, 0.06392425f, -0.21682601f, 0.10686380f, 0.12906712f, 
    -0.05099188f, 0.12533872f, -0.11069949f, -0.09232571f, 0.13398683f, -0.04404869f, -0.15243928f, 0.04678833f, 
    -0.09983411f, 0.07994153f, 0.20866488f, -0.17045954f, 0.16229631f, -0.05105033f, -0.07361298f, -0.11140959f, 
    0.05175605f, -0.00761401f, 0.13837026f, -0.01011300f, -0.02333296f, -0.00648466f, -0.10369281f, -0.01940999f, 
    0.05625731f, -0.05276607f, -0.06789482f, -0.02943670f, 0.10687708f, 0.01118514f, 0.15640588f, -0.06852525f, 
    0.03459458f, 0.26010364f, 0.25555041f, -0.08921137f, -0.04439811f, 0.02466620f, 0.10828963f, 0.02524674f, 
    -0.10867932f, -0.03713103f, 0.08015881f, -0.09937678f, 0.19208495f, 0.14961874f, 0.12947680f, -0.08128109f, 
    0.00215385f, 0.10165174f, 0.07603095f, 0.04498349f, 0.04293149f, -0.05168372f, -0.11106525f, -0.10068560f, 
    0.15520230f, 0.00406899f, 0.03135845f, -0.06830660f, 0.02178337f, -0.19787763f, 0.00964722f, -0.10615171f, 
    -0.15843682f, 0.10963698f, 0.06564526f, 0.26950285f, 0.18912631f, 0.18752600f, 0.24281694f, 0.22830808f, 
    0.02292509f, -0.03541880f, 0.06835096f, -0.05903625f, 0.09647980f, -0.12545834f, 0.05706099f, -0.06679785f, 
    -0.16235845f, -0.25734293f, 0.12559922f, 0.29005072f, 0.04799122f, 0.00246597f, -0.06614996f, -0.07707434f, 
    -0.04391705f, 0.05744214f, 0.00397615f, 0.12927745f, -0.10422450f, 0.09335363f, -0.09613502f, 0.00589061f, 
    -0.00448475f, -0.02333045f, 0.02224622f, -0.23449820f, -0.15874098f, -0.11357468f, -0.18615888f, -0.10119764f, 
    -0.01249499f, 0.36134094f, 0.09901761f, 0.06815800f, 0.10056157f, 0.06948505f, 0.05587895f, 0.17223188f, 
    0.03199909f, 0.03924689f, -0.06751755f, 0.04068126f, 0.04625965f, -0.02891609f, 0.05904735f, 0.00345934f, 
    0.15059505f, -0.05266076f, 0.04407707f, 0.27160293f, -0.07262762f, 0.00896979f, -0.04569962f, 0.04892746f, 
    -0.03116608f, 0.02286982f, -0.07259325f, -0.02658066f, 0.03624052f, 0.05405907f, 0.02761662f, 0.08349811f, 
    -0.16761573f, -0.14843130f, -0.16261590f, -0.15341209f, -0.08721605f, 0.23254356f, -0.12466239f, 0.07153878f, 
    0.04500262f, -0.08857632f, 0.00254624f, -0.01503864f, -0.09104906f, -0.05808775f, 0.21085472f, 0.05901400f, 
    -0.26680079f, 0.00403073f, -0.05039990f, -0.20059995f, -0.00032289f, -0.03182025f, -0.06788210f, 0.00504842f, 
    0.05290943f, 0.09295879f, 0.10890765f, 0.05830817f, 0.05933511f, 0.22638138f, 0.11943262f, 0.02453544f, 
    -0.00712531f, 0.00426460f, 0.01978354f, 0.09907164f, -0.04696104f, -0.05653500f, -0.00928120f, 0.00730874f, 
    -0.19040638f, -0.12567148f, -0.04525818f, -0.02159444f, -0.05155550f, -0.12463827f, 0.08433984f, 0.02975938f, 
    -0.03013247f, 0.13827567f, 0.07628351f, 0.12069612f, 0.14257395f, 0.01657471f, 0.08828363f, 0.02672099f, 
    0.01670725f, 0.04577799f, 0.03890894f, 0.15688173f, -0.07789037f, -0.01866026f, -0.04733333f, -0.06755079f, 
    -0.06044969f, 0.22413936f, 0.11778604f, 0.00710935f, 0.08116295f, 0.07563611f, 0.13998710f, 0.26807764f, 
    0.00724874f, 0.03656865f, 0.01540420f, 0.01300952f, -0.05949710f, 0.02568627f, 0.09590004f, -0.23720668f, 
    -0.05477862f, 0.03947487f, -0.05861633f, -0.11898626f, 0.06330338f, 0.04651618f, -0.04275196f, 0.13193288f, 
    0.00335104f, 0.05171235f, -0.17100261f, 0.18641973f, 0.10188614f, -0.00382094f, -0.05672456f, 0.05583859f, 
    0.08971082f, 0.04237608f, -0.05200351f, -0.04305866f, 0.18315487f, 0.06401791f, 0.02875832f, 0.06606219f, 
    0.00169757f, -0.17356935f, 0.01753112f, 0.19657330f, 0.09787935f, -0.04488731f, -0.06866413f, -0.18570757f, 
    -0.13643424f, 0.02813608f, 0.27257523f, 0.20907934f, 0.16626537f, -0.02853622f, 0.00277749f, -0.05894404f, 
    -0.05103325f, -0.00829560f, -0.09700761f, -0.00173188f, -0.07069012f, 0.23369008f, 0.04083471f, 0.03451415f, 
    -0.07488741f, -0.01499844f, -0.05070806f, -0.07369229f, 0.02799080f, 0.17512165f, 0.01497750f, 0.17967512f, 
    0.19474792f, 0.05974031f, -0.19938180f, -0.10669228f, 0.08071638f, 0.01045651f, -0.13009594f, 0.02352386f, 
    0.01123586f, -0.15821105f, -0.22139731f, -0.11032140f, -0.09504686f, -0.10714088f, 0.02023076f, 0.08714452f, 
    0.12361400f, -0.06279791f, 0.02263206f, -0.11546103f, -0.00638811f, 0.09816583f, 0.01802674f, 0.04939945f, 
    -0.15019506f, 0.32183617f, -0.19222456f, 0.03313158f, -0.00588032f, -0.16890806f, 0.12125757f, 0.02703932f, 
    0.14871632f, -0.05358051f, 0.03163081f, 0.03978665f, -0.07759389f, 0.06638065f, 0.12645809f, 0.10183470f, 
    0.13043915f, 0.00584443f, -0.04510441f, 0.14599915f, -0.03708429f, -0.05964183f, 0.12135587f, 0.00484502f, 
    0.07285129f, 0.08235651f, 0.03856604f, -0.05253986f, 0.09416349f, -0.02879139f, 0.04383351f, 0.06449678f, 
    -0.00715061f, 0.04832329f, -0.01482861f, 0.00650740f, -0.30219281f, -0.41157740f, -0.12832557f, 0.14542587f, 
    0.03529175f, 0.03686920f, 0.20486209f, 0.12776808f, 0.02376873f, 0.04184382f, 0.06326479f, -0.02303031f, 
    0.06500925f, -0.17075087f, -0.03291451f, -0.24031699f, 0.06298342f, -0.19344619f, -0.00308891f, -0.12000234f, 
    0.05133542f, 0.09247751f, 0.01282778f, -0.06303608f, -0.17860673f, -0.10504608f, -0.25748488f, 0.04648569f, 
    -0.14147492f, 0.13200875f, 0.00034396f, 0.21643287f, -0.05614324f, 0.05170153f, 0.06876813f, -0.16207698f, 
    0.04513393f, 0.04628962f, 0.09286534f, 0.11380669f, -0.05263058f, -0.03591878f, -0.12438864f, -0.01352856f, 
    0.01882369f, -0.10770934f, 0.02493535f, -0.05558327f, -0.11675474f, 0.02010886f, -0.14715609f, 0.00680169f, 
    0.09919931f, 0.06627025f, -0.00767253f, -0.04708302f, 0.10813536f, 0.11173066f, -0.01745180f, 0.07212209f, 
    0.24974559f, 0.04499827f, 0.33209154f, 0.03878641f, 0.13394624f, 0.03162701f, -0.04436353f, -0.03186654f, 
    0.03091633f, 0.02519934f, -0.01042722f, 0.09150933f, 0.19204544f, -0.15327117f, 0.13015038f, 0.13713600f, 
    0.21765529f, -0.07934796f, 0.05885821f, 0.11812928f, 0.05372200f, 0.02095927f, 0.12508145f, 0.12035611f, 
    0.42293933f, 0.15152089f, 0.38455549f, 0.09671707f, 0.11178478f, -0.01536469f, -0.03319512f, 0.09360731f, 
    -0.00130639f, 0.02364342f, -0.03930930f, -0.06708393f, 0.07017284f, 0.16663605f, 0.05526960f, 0.15290624f, 
    0.21508060f, -0.14524655f, 0.06011581f, 0.18042807f, -0.02387543f, -0.07244342f, 0.06182678f, -0.10625179f, 
    -0.12465043f, 0.01521149f, 0.06745651f, 0.15663838f, 0.05436970f, 0.00576510f, -0.05390432f, 0.06913058f, 
    0.06377985f, 0.01990909f, -0.04472967f, -0.04707648f, 0.09724821f, -0.16925846f, 0.29739070f, 0.21427292f, 
    0.06018045f, -0.04008799f, 0.06293255f, -0.03005175f, 0.06155404f, 0.03473645f, -0.03464584f, 0.07361127f, 
    0.11201803f, 0.01530672f, 0.09292746f, 0.02363849f, 0.09449354f, -0.04304271f, 0.00220797f, 0.03234636f, 
    0.00024313f, 0.18859845f, 0.13954693f, -0.13226481f, 0.08082235f, -0.01939142f, -0.03478173f, -0.02313086f, 
    0.01806233f, 0.00934385f, 0.08037525f, 0.18625857f, -0.08724641f, -0.04668074f, 0.02585878f, 0.03497609f, 
    0.03344759f, 0.18442518f, 0.30913380f, -0.06570721f, 0.04693148f, -0.03480126f, 0.00634736f, 0.11713814f, 
    -0.00494296f, 0.04542035f, 0.01581364f, -0.00491368f, -0.02745103f, 0.08011559f, -0.06753100f, 0.00781430f, 
    0.07466751f, -0.08144213f, 0.11487119f, -0.05653503f, 0.20329520f, -0.01156356f, 0.03897310f, -0.06384933f, 
    -0.25332111f, -0.22669268f, -0.36141866f, -0.02442968f, -0.10848808f, 0.04427613f, 0.01386950f, 0.14057906f, 
    0.12719920f, 0.04526168f, -0.07916451f, -0.13036402f, -0.16927214f, 0.04285808f, 0.08230048f, -0.12181120f, 
    -0.04013469f, 0.02330947f, -0.02122688f, 0.09839930f, 0.12653193f, 0.14688909f, 0.09183695f, -0.12865411f, 
    -0.05544575f, 0.07611445f, 0.09498538f, 0.07921106f, -0.00750525f, -0.06958146f, 0.02179650f, 0.01648257f, 
    -0.05486064f, -0.06933391f, 0.02317906f, 0.05932673f, -0.46983701f, 0.07220855f, -0.20010452f, -0.07068751f, 
    -0.01347052f, -0.01143748f, 0.11042392f, -0.02330630f, 0.19916342f, 0.08433893f, 0.09696095f, 0.05476918f, 
    -0.04043894f, -0.00219764f, -0.08220819f, -0.04230333f, 0.03234371f, 0.01149520f, 0.05343264f, -0.03632833f, 
    0.04244629f, 0.03593988f, 0.01117161f, -0.00007561f, -0.11673956f, 0.22909631f, -0.16841373f, 0.00716654f, 
    0.01303301f, 0.02337783f, 0.15098894f, -0.07072762f, 0.01777223f, -0.03595542f, -0.06814309f, 0.05486754f, 
    0.01563469f, -0.00620553f, -0.02025346f, 0.02964462f, 0.01704265f, -0.01257021f, 0.01124293f, 0.02036290f, 
    0.08113082f, 0.08774923f, 0.15419778f, 0.15269437f, 0.24315090f, -0.22929528f, -0.01917687f, -0.15472454f, 
    0.08609834f, -0.16210030f, -0.09464427f, -0.08760916f, 0.12173677f, -0.03829066f, -0.08927456f, -0.16245557f, 
    0.09737241f, 0.04045050f, 0.05066715f, 0.10160392f, -0.02404786f, -0.01267117f, 0.13303804f, 0.00996553f, 
    0.07108254f, -0.04203353f, 0.03729175f, 0.07146066f, 0.02051955f, 0.00340310f, -0.09681501f, 0.17443249f, 
    -0.01932625f, 0.13126989f, -0.11377370f, 0.05120648f, -0.06227197f, 0.09556992f, -0.16385181f, -0.12802924f, 
    -0.11101469f, -0.04246081f, -0.05885900f, -0.02465993f, 0.00899694f, -0.06213882f, -0.01846533f, -0.01027139f, 
    -0.09164511f, -0.02857514f, -0.02462729f, 0.06373577f, 0.08315976f, 0.12607393f, 0.07349911f, 0.14597666f, 
    0.14342515f, -0.02135833f, 0.03574604f, 0.04224993f, -0.03753448f, 0.02568708f, -0.00055470f, -0.02993099f, 
    -0.28544289f, -0.16107132f, -0.11992516f, -0.07813653f, 0.00245748f, -0.01416603f, 0.09782362f, -0.04127920f, 
    0.07745527f, 0.10065514f, 0.02994473f, 0.11424809f, 0.05311804f, 0.10831457f, 0.10062143f, 0.13169852f, 
    0.06029319f, 0.08021811f, 0.07516571f, -0.07425827f, -0.04207386f, 0.04881324f, 0.04111716f, 0.10423927f, 
    -0.03090257f, -0.17030241f, 0.02305437f, -0.17625110f, 0.06114483f, -0.01933080f, 0.08525766f, -0.01131665f, 
    0.03771352f, -0.00041020f, 0.08215921f, 0.04825032f, -0.06518088f, -0.22935636f, -0.26582876f, 0.13104008f, 
    0.04758573f, -0.03115981f, 0.03081272f, -0.05904110f, 0.14254764f, 0.09512120f, 0.06417228f, 0.14875323f, 
    -0.06728406f, -0.31597605f, -0.08777554f, -0.12068549f, 0.05109153f, 0.07200917f, 0.08378351f, -0.00354239f, 
    -0.04637036f, 0.04635229f, -0.00101316f, -0.04055348f, -0.29100791f, -0.16073340f, -0.05376131f, 0.26151225f, 
    -0.07043110f, 0.09959102f, 0.10539734f, -0.01638947f, -0.00319438f, 0.04323441f, 0.05033414f, 0.07001912f, 
    -0.31566006f, 0.05105714f, 0.02009962f, 0.18639791f, -0.06855521f, 0.02134235f, -0.05293903f, 0.01674224f, 
    -0.03504737f, 0.00802760f, -0.00084834f, 0.08734924f, -0.01655719f, -0.03325886f, 0.10849864f, -0.06420408f, 
    -0.05273724f, -0.06063583f, -0.01490969f, -0.05309045f, -0.13651778f, -0.19287361f, -0.01035913f, -0.02100917f, 
    0.30636993f, -0.14819467f, 0.01023710f, -0.22027087f, 0.03702355f, -0.02935196f, -0.08480798f, -0.07989054f, 
    0.04669522f, 0.09390423f, 0.09027843f, 0.04386899f, 0.29552439f, 0.08750251f, 0.10451619f, 0.14091310f, 
    -0.05320941f, 0.04583477f, 0.01547795f, -0.05810727f, 0.06290338f, -0.06853762f, 0.00318731f, 0.03911858f, 
    -0.03799811f, -0.15586206f, 0.05934907f, -0.11649635f, 0.19729996f, 0.00731970f, -0.04200993f, 0.05935678f, 
    0.00636003f, 0.01914514f, 0.03543841f, -0.16357778f, 0.04925704f, 0.11915746f, -0.05365654f, -0.08036930f, 
    -0.03572218f, -0.00638813f, 0.02475036f, 0.03704998f, -0.02171189f, 0.01673032f, 0.10601269f, 0.07184788f, 
    0.00564140f, 0.20275645f, 0.03348140f, -0.20575880f, -0.11586796f, 0.10102909f, -0.00283041f, -0.02818723f, 
    0.00137073f, -0.03482986f, 0.04296673f, -0.03552606f, -0.06657766f, -0.16494027f, -0.07744434f, -0.28889892f, 
    -0.00161598f, 0.00576058f, -0.11988972f, -0.10569710f, 0.05320188f, 0.07707506f, -0.05781466f, 0.00253888f, 
    0.00938390f, -0.17975776f, -0.19842558f, -0.21341152f, 0.08823052f, 0.04364021f, 0.06847306f, 0.03086375f, 
    -0.12094938f, 0.00709367f, -0.01800082f, -0.05598133f, -0.13454980f, -0.21208008f, -0.09579360f, -0.08541982f, 
    0.01262963f, 0.02948031f, 0.11006923f, -0.04173841f, 0.03166634f, 0.01667801f, -0.03752104f, -0.04411282f, 
    0.15967907f, -0.01176849f, 0.29985121f, 0.15509163f, 0.14611010f, -0.02024118f, 0.02002269f, 0.00058691f, 
    -0.08857498f, -0.02930065f, 0.12457661f, 0.12042484f, -0.02716340f, 0.00154252f, -0.13331522f, -0.08139940f, 
    -0.07474172f, -0.01048438f, 0.00932233f, -0.06633791f, 0.05887118f, 0.03160308f, 0.12223835f, 0.07520831f, 
    0.23201764f, -0.00322934f, -0.00082775f, 0.06884967f, 0.06985743f, 0.00500961f, 0.15156500f, -0.16615202f, 
    -0.03238532f, 0.02213740f, 0.01071041f, 0.11103565f, 0.00547801f, -0.00035636f, -0.10769364f, -0.01844783f, 
    0.00845029f, -0.08108154f, 0.13755880f, 0.10292826f, -0.06329117f, 0.03729401f, 0.01323987f, 0.06325749f, 
    -0.09928549f, 0.02177794f, 0.01593934f, -0.02870231f, 0.15959927f, 0.04090225f, -0.09060249f, 0.05999244f, 
    0.07545660f, 0.01928087f, -0.01084714f, 0.05374901f, -0.25528243f, -0.26730609f, -0.30408981f, -0.15716392f, 
    0.03039921f, 0.15485698f, 0.20344710f, 0.15299630f, 0.09324272f, 0.11602868f, 0.14312680f, -0.10650509f, 
    -0.24741969f, 0.03491163f, 0.01484668f, 0.17549938f, 0.08281184f, -0.02913239f, -0.01458304f, 0.05062013f, 
    -0.01718587f, 0.04922150f, 0.09253315f, -0.02683201f, -0.14276445f, -0.25985333f, -0.20321453f, -0.21281610f, 
    -0.03474047f, -0.02252099f, -0.06196956f, -0.04771784f, 0.06578491f, -0.00406046f, 0.01306039f, 0.02192224f, 
    -0.12453522f, -0.01405934f, -0.08613738f, -0.00949408f, -0.11297634f, -0.09810503f, 0.07901778f, 0.05268830f, 
    -0.18666978f, 0.07994255f, -0.05204596f, -0.04545928f, 0.52984953f, 0.02891966f, 0.10184007f, 0.01002397f, 
    0.04565485f, -0.07249247f, 0.09948880f, -0.01479510f, 0.08502472f, -0.00465614f, 0.02589215f, 0.05553091f, 
    -0.13495250f, -0.06088911f, -0.16612270f, -0.25640315f, -0.16416748f, 0.02815406f, -0.06561888f, -0.04472519f, 
    0.03946657f, 0.00706628f, 0.00865078f, 0.03299475f, 0.12273659f, -0.47218469f, 0.17143872f, 0.12862642f, 
    0.08369065f, 0.11471278f, -0.00703373f, 0.10008372f, -0.04566363f, -0.01940940f, 0.07202905f, 0.11532078f, 
    -0.00110344f, 0.15590601f, 0.00062720f, 0.06996752f, 0.07943740f, 0.01434564f, -0.04817180f, 0.05283165f, 
    -0.10795626f, 0.09681786f, 0.03029129f, 0.00502531f, -0.02461339f, 0.09289036f, 0.20021309f, 0.01132269f, 
    0.11577462f, -0.04021654f, 0.18321395f, 0.06375530f, -0.00201612f, 0.02040253f, -0.06750953f, -0.06111446f, 
    0.45736283f, 0.12934455f, 0.27313104f, -0.05392703f, 0.19968985f, 0.12219376f, -0.00020305f, 0.08736338f, 
    0.14987570f, 0.01987584f, 0.18698956f, -0.00805296f, -0.14651187f, 0.02793820f, -0.04134439f, -0.06343542f, 
    0.02877254f, 0.01487633f, -0.08852487f, 0.04861726f, 0.05186816f, 0.06709258f, -0.08213751f, -0.02821163f, 
    -0.02596117f, 0.04319853f, -0.16099983f, -0.08359315f, -0.03168311f, 0.19006583f, -0.17146669f, 0.06816781f, 
    0.02870114f, -0.01785675f, -0.02790789f, 0.08922741f, -0.15376569f, -0.05572931f, -0.02073667f, -0.00560198f, 
    0.00222329f, 0.00411058f, -0.01037528f, 0.00164512f, 0.07308997f, 0.15691999f, 0.02774902f, 0.12910131f, 
    -0.18618351f, -0.11618964f, 0.08569638f, -0.03082797f, 0.02343209f, 0.08024082f, -0.01768803f, 0.12728314f, 
    0.18279910f, 0.02600659f, 0.12660666f, 0.11611368f, -0.08686394f, 0.04050627f, 0.02617323f, 0.06702175f, 
    0.03535942f, 0.12119784f, 0.11598320f, 0.02766184f, -0.01060225f, 0.00662678f, 0.03725078f, 0.10017444f, 
    -0.03833938f, -0.00013632f, -0.01153096f, -0.13931876f, -0.05571906f, -0.02113279f, 0.04294295f, -0.03482392f, 
    0.14894417f, 0.08563413f, 0.06893995f, -0.04894436f, 0.06580275f, -0.25494194f, 0.00376188f, -0.12772790f, 
    0.05292033f, -0.15346222f, 0.08627672f, 0.11352148f, 0.00817677f, 0.06753039f, 0.13757220f, -0.12940589f, 
    -0.07175359f, -0.05534150f, -0.08171558f, 0.03912726f, 0.09035137f, 0.15256426f, 0.11342689f, 0.07202967f, 
    0.03155026f, 0.00950837f, -0.01552457f, -0.12060319f, 0.27049476f, 0.12590536f, 0.14756419f, -0.04262605f, 
    0.01508910f, -0.03758188f, 0.06553006f, 0.05852893f, -0.01912564f, 0.12482808f, 0.13413602f, 0.04289134f, 
    -0.05367575f, 0.16299470f, 0.18399717f, 0.15453179f, -0.06329274f, -0.04109582f, -0.07926215f, -0.10805966f, 
    0.11577076f, 0.12830265f, 0.02868223f, 0.07028478f, 0.10073681f, 0.01192589f, 0.17265993f, -0.01914898f, 
    -0.02522824f, 0.02569149f, -0.01005080f, 0.14056039f, 0.15583271f, 0.31955433f, 0.22692452f, 0.20073991f, 
    -0.02095371f, 0.01997426f, 0.10252009f, -0.06543676f, 0.10071018f, 0.03920727f, 0.21212724f, 0.08642090f, 
    -0.08136791f, 0.01474033f, -0.11882726f, -0.10444000f, -0.09233316f, 0.08140758f, -0.09939726f, 0.10484923f, 
    0.16649535f, 0.06097811f, -0.07732592f, -0.06279872f, 0.05921605f, 0.08005054f, 0.14359997f, 0.07380205f, 
    0.13016213f, 0.21684617f, -0.15291317f, 0.14554736f, 0.10426371f, -0.01029990f, 0.07028722f, -0.20130032f, 
    0.01751702f, 0.05912931f, -0.07435485f, 0.06178025f, 0.01562885f, 0.05521156f, 0.13504478f, 0.15703268f, 
    0.14466247f, 0.06917822f, -0.05393406f, -0.08353496f, -0.07987481f, 0.00736132f, 0.02396876f, 0.05697830f, 
    -0.01894072f, -0.05637671f, 0.04495583f, -0.00275200f, -0.03320672f, 0.04325972f, 0.10228182f, 0.08170798f, 
    -0.03713372f, 0.00186676f, -0.15718828f, -0.19271863f, 0.08808634f, 0.06833474f, 0.18749836f, 0.11740416f, 
    -0.10048844f, 0.02103790f, 0.05379178f, 0.10010272f, 0.02833272f, -0.01560909f, -0.02021938f, 0.01891151f, 
    -0.05073584f, 0.07415762f, -0.02326683f, 0.09106553f, -0.07438711f, 0.01368017f, -0.05890453f, -0.00104271f, 
    -0.01559180f, -0.05951676f, 0.07347151f, -0.33132094f, 0.06879287f, 0.00975123f, -0.02629351f, 0.16047099f, 
    0.16016749f, -0.02681244f, 0.00941490f, 0.08922215f, -0.04336303f, -0.05968038f, 0.00085152f, 0.07906558f, 
    -0.01088006f, -0.11596941f, -0.03602206f, 0.01368138f, 0.13924411f, 0.03643529f, 0.14314528f, 0.09049301f, 
    -0.05755597f, 0.05673691f, -0.00432309f, -0.01518383f, 0.05667765f, -0.19993564f, 0.02840443f, 0.02527999f, 
    -0.00621130f, 0.06628501f, 0.01212732f, 0.01212850f, 0.04530104f, 0.03219824f, 0.16731398f, 0.08656860f, 
    -0.11099149f, 0.02722278f, -0.00939980f, -0.03575263f, 0.00025945f, -0.01919178f, 0.07178089f, 0.00175415f, 
    0.07018923f, 0.14261702f, 0.04748624f, -0.05531270f, 0.25449026f, 0.09910786f, 0.03676844f, 0.03515922f, 
    -0.01080586f, -0.05309785f, -0.04504027f, 0.03765196f, -0.05127572f, 0.00333101f, -0.12854090f, -0.17798953f, 
    -0.11237704f, -0.00654590f, -0.05169457f, 0.00070054f, -0.03662259f, 0.00467220f, -0.07483950f, -0.03354220f, 
    0.04336970f, 0.04587202f, 0.10955847f, 0.05817184f, -0.10529900f, -0.23690528f, 0.04468484f, 0.03795775f, 
    -0.00032119f, -0.01354134f, -0.09494566f, 0.03066363f, 0.01417385f, 0.08857244f, 0.12720025f, 0.05449582f, 
    -0.04780652f, 0.07963862f, 0.02436575f, 0.05500262f, -0.00255338f, 0.01068183f, 0.05793515f, 0.17394313f, 
    -0.06062858f, 0.02857903f, -0.09119320f, -0.11141369f, 0.00349939f, -0.05661990f, 0.03593231f, -0.19235711f, 
    0.03148034f, 0.08168517f, 0.00354305f, 0.13987611f, 0.13674930f, 0.12577207f, 0.05973471f, 0.06965484f, 
    0.12261506f, 0.16830906f, 0.09532458f, -0.03401231f, -0.08162776f, -0.03507905f, -0.06968358f, -0.09570093f, 
    0.11230708f, 0.20468323f, 0.24216966f, 0.15703146f, -0.25631282f, -0.27164778f, 0.00469657f, -0.07616897f, 
    0.08793765f, 0.03531133f, 0.09762459f, 0.03222026f, 0.00010046f, -0.10038099f, -0.13154551f, -0.10561471f, 
    -0.03250077f, 0.13849260f, 0.08080354f, 0.14749180f, 0.06303488f, 0.05150977f, 0.12240002f, -0.00705980f, 
    -0.07703149f, 0.09231111f, -0.02908035f, 0.02941844f, -0.08300685f, 0.04377133f, 0.28015015f, -0.01936323f, 
    -0.04539397f, 0.04743559f, -0.05327847f, 0.10697435f, -0.05343347f, -0.10224230f, 0.00286490f, -0.08847003f, 
    -0.05545009f, -0.02509231f, 0.03378642f, 0.00686876f, -0.06046402f, 0.05196627f, -0.04651423f, 0.01569334f, 
    -0.05628109f, -0.03088576f, -0.16018964f, -0.11649338f, 0.22190578f, -0.00067229f, -0.02309779f, 0.14379019f, 
    0.14026333f, 0.07536053f, 0.05027859f, 0.07220657f, -0.05207633f, 0.09341044f, 0.03826309f, -0.02001463f, 
    -0.09558655f, 0.36356291f, -0.04320027f, 0.12428129f, 0.02902787f, 0.07043850f, -0.11023375f, 0.02114787f, 
    -0.01888850f, -0.14799489f, -0.05198856f, -0.20709081f, 0.17911555f, 0.09796306f, 0.12356810f, -0.02301278f, 
    0.05744571f, 0.10692857f, -0.01234469f, 0.06819342f, 0.05604651f, 0.01928932f, 0.02722872f, 0.04620075f, 
    0.02191122f, -0.06957091f, -0.05421731f, -0.03389220f, 0.08319281f, -0.04548117f, -0.04747464f, 0.08905680f, 
    -0.01654142f, 0.03315929f, 0.05998391f, 0.08436765f, 0.12175731f, 0.10101120f, 0.14732690f, 0.15392241f, 
    -0.00545191f, 0.01736702f, -0.10752854f, -0.00698638f, 0.04918196f, 0.04452949f, 0.21283120f, 0.01724885f, 
    -0.09338836f, -0.10882750f, -0.00728592f, 0.07923997f, 0.01603688f, -0.01897341f, 0.15621132f, 0.08809331f, 
    -0.11705042f, 0.03632222f, 0.10202746f, -0.00255509f, -0.02545598f, 0.01017491f, 0.14868677f, -0.00748140f, 
    -0.09834465f, 0.13517910f, 0.03331013f, -0.03501818f, 0.02206107f, 0.07487937f, 0.18459126f, -0.06318863f, 
    0.20615141f, -0.17980480f, 0.17785734f, -0.01718853f, -0.09629024f, 0.04118556f, -0.02433677f, -0.07614852f, 
    0.19865771f, 0.12205523f, 0.04417590f, 0.00255226f, -0.11957770f, 0.06487576f, -0.07668087f, 0.01455628f, 
    -0.08450354f, -0.10841908f, -0.02801875f, -0.11310904f, 0.00240028f, 0.08242778f, -0.03625791f, -0.08901840f, 
    -0.05165492f, 0.16345538f, -0.08777758f, 0.22399592f, 0.06343574f, 0.02963614f, 0.06209697f, 0.14545095f, 
    0.07330230f, 0.13019359f, 0.06459550f, 0.10147433f, 0.10031860f, -0.04443252f, 0.19831905f, -0.06246928f, 
    -0.03863116f, -0.09089848f, -0.01453001f, -0.05695076f, 0.04243245f, 0.10741483f, 0.08854680f, 0.03064088f, 
    -0.17658786f, 0.00997886f, -0.01667646f, -0.09367076f, -0.02884556f, -0.04051505f, 0.14973167f, 0.27319574f, 
    -0.24581647f, 0.13412541f, 0.00418458f, -0.21487466f, -0.13897477f, 0.16794771f, 0.21471567f, 0.09219841f, 
    -0.05635277f, -0.04399795f, -0.03092431f, -0.05482964f, 0.10720278f, 0.06298763f, 0.04388603f, 0.14010307f, 
    -0.11991535f, 0.00365775f, -0.07927491f, 0.10038542f, 0.00159601f, 0.02962871f, 0.15197821f, -0.01510593f, 
    0.07086825f, 0.00980977f, 0.02270233f, -0.00696204f, 0.05056409f, -0.03214455f, 0.02543548f, 0.05069233f, 
    0.02687735f, 0.01198699f, 0.09627592f, 0.10726102f, 0.03419631f, 0.08336212f, 0.06880115f, 0.15141647f, 
    -0.14397235f, -0.20969220f, -0.07791208f, -0.06659088f, 0.07838169f, -0.02328428f, -0.04277065f, 0.05593112f, 
    -0.05599738f, -0.05572428f, -0.09537543f, -0.17857698f, -0.05590998f, -0.04951035f, 0.00142388f, 0.09052902f, 
    0.12890242f, -0.01242198f, 0.07421809f, 0.11811393f, -0.06841645f, 0.01877839f, -0.05241017f, 0.06339464f, 
    0.07621160f, 0.30746946f, -0.16910787f, -0.02060841f, 0.05504724f, -0.05407374f, 0.04006555f, 0.00974279f, 
    0.04467956f, 0.04575402f, 0.12467397f, 0.12265448f, 0.03269284f, -0.02240579f, -0.00827351f, -0.08356792f, 
    -0.04835154f, 0.04375429f, -0.01837748f, -0.03958804f, 0.20206338f, 0.18622677f, 0.16935548f, 0.20657310f, 
    -0.35866764f, 0.00146613f, -0.04167438f, 0.08941420f, -0.06191622f, 0.16829662f, -0.03766866f, 0.14676982f, 
    0.08032621f, -0.01780943f, 0.08979580f, 0.07842023f, 0.04303206f, 0.13092117f, -0.05493958f, 0.11508009f, 
    0.11097033f, -0.04393069f, -0.05304180f, 0.20767727f, -0.07340027f, -0.02499174f, -0.01848518f, 0.01383182f, 
    -0.06298699f, -0.05428602f, 0.00530234f, -0.08973789f, 0.08209161f, 0.13260412f, -0.04799332f, 0.00503448f, 
    0.13991526f, 0.06751277f, 0.10713695f, 0.13127214f, 0.10070129f, -0.26422563f, -0.08475573f, -0.14772493f, 
    0.05030451f, -0.09596526f, -0.05592488f, -0.02874057f, -0.08280940f, -0.07484585f, -0.02748403f, -0.06248057f, 
    -0.05154417f, 0.03968051f, 0.15927318f, -0.04890120f, -0.03332987f, 0.02121869f, 0.06453627f, 0.09531271f, 
    0.07761981f, 0.04211900f, 0.07393836f, 0.04408206f, -0.13198461f, -0.03807596f, -0.01101431f, 0.05973001f, 
    0.15742034f, 0.12342175f, 0.02135181f, 0.07290871f, 0.04923945f, 0.00225037f, -0.00255277f, -0.03418431f, 
    -0.11849438f, -0.04657241f, -0.09595227f, -0.07021187f, -0.00931808f, -0.03975061f, -0.06382571f, 0.06783739f, 
    0.00867932f, 0.02667357f, -0.08293877f, -0.00766734f, -0.18283823f, 0.16028489f, -0.19580898f, 0.17175338f, 
    0.05354365f, 0.08041406f, 0.03071927f, 0.03156443f, 0.08565514f, 0.06308867f, 0.02512457f, 0.08449856f, 
    -0.10875345f, -0.16693458f, 0.00581461f, 0.17511627f, -0.09288090f, -0.05558401f, -0.00132025f, -0.02300422f, 
    -0.02525015f, 0.03978445f, 0.12455049f, 0.05423465f, 0.00188388f, 0.21637098f, -0.03831039f, -0.05670225f, 
    -0.01557708f, -0.06257591f, 0.14454836f, -0.03962009f, 0.01781994f, 0.10612215f, 0.03902802f, 0.06309880f, 
    -0.04385570f, -0.04061897f, -0.01259228f, 0.01745746f, 0.03164649f, 0.07698277f, -0.02957563f, -0.00248153f, 
    -0.03249439f, 0.11724778f, -0.05564178f, -0.00554052f, 0.06722870f, -0.10017508f, -0.13633014f, 0.13021669f, 
    0.04954308f, 0.08664494f, -0.03695640f, 0.10741032f, -0.07314028f, 0.03786387f, -0.06308933f, 0.00626808f, 
    0.25500619f, 0.20395915f, -0.21462455f, 0.00868313f, 0.22019593f, 0.19124056f, 0.05398703f, -0.08319382f, 
    0.15806331f, 0.10032430f, -0.03017119f, -0.08001383f, -0.09850493f, 0.01637234f, 0.06953531f, -0.06391118f, 
    0.04957704f, -0.04208666f, 0.15298495f, 0.12660277f, -0.05932683f, -0.05738597f, -0.09609969f, -0.20109968f, 
    -0.02943429f, 0.04508521f, 0.12427863f, -0.02706219f, 0.03179277f, -0.09875771f, 0.03876671f, -0.04115438f, 
    0.09227609f, -0.02264032f, 0.10820748f, 0.27596566f, -0.10198737f, -0.03424533f, -0.08795827f, -0.15260325f, 
    -0.05859290f, -0.03562630f, -0.07256178f, -0.07437105f, 0.19385722f, 0.28423494f, 0.17822662f, 0.07171291f, 
    0.00286486f, -0.03269629f, -0.00879255f, 0.02724366f, -0.00195727f, 0.02846821f, 0.00384295f, 0.00028976f, 
    -0.01238731f, 0.00644092f, -0.03013741f, -0.03441190f, 0.01136751f, 0.03466244f, 0.00881671f, 0.01244599f, 
    -0.03413011f, -0.02592794f, 0.01557298f, -0.00226211f, -0.03518732f, 0.01971147f, 0.01576142f, 0.01772430f, 
    0.00876640f, -0.02930285f, -0.01662005f, 0.02170441f, 0.03486722f, 0.02990997f, -0.02478366f, 0.02602968f, 
    0.00676920f, 0.01420955f, -0.02875965f, 0.02018218f, -0.01337697f, 0.00309352f, 0.01462817f, 0.01321520f, 
    0.01422621f, 0.01529108f, 0.00567297f, 0.01674016f, 0.02497174f, -0.02599843f, -0.04170268f, 0.01317307f, 
    0.00315693f, -0.00864701f, 0.02221546f, 0.01573073f, 0.01237741f, -0.03402306f, 0.01925625f, 0.03937386f, 
    0.00911818f, -0.01480883f, -0.01425516f, 0.00420222f, -0.02390258f, 0.03344918f, 0.00875411f, 0.02432744f, 
    0.01214760f, -0.02962155f, 0.00611854f, 0.00715851f, -0.02561334f, -0.00102601f, -0.02986891f, 0.02317449f, 
    -0.01334355f, 0.01377054f, 0.00137558f, 0.02283973f, 0.02126121f, -0.03268915f, 0.01500209f, -0.03522256f, 
    -0.02079386f, 0.01817426f, -0.01943710f, -0.00190898f, 0.00607718f, -0.00734265f, -0.02594847f, -0.02194895f, 
    0.00342225f, -0.00347901f, 0.00032594f, 0.01107449f, -0.03221279f, 0.02495394f, 0.01860005f, 0.01624527f, 
    0.02238314f, 0.02726175f, -0.02918463f, -0.02256805f, -0.00797674f, 0.02077663f, -0.03082709f, -0.03135137f, 
    -0.00540158f, 0.01843351f, 0.02396734f, 0.01165204f, -0.02025989f, 0.01852809f, -0.00394633f, -0.01303050f, 
    0.01262734f, -0.00387825f, 0.01005177f, -0.00435601f, -0.01292566f, -0.01173263f, -0.01659057f, 0.03676978f, 
    0.00795053f, 0.02208916f, -0.00029082f, -0.02842743f, -0.00860441f, 0.03386470f, 0.00218087f, 0.01830366f, 
    -0.00875481f, -0.02610932f, -0.01189022f, -0.02355246f, -0.03255836f, 0.01919643f, -0.01839291f, 0.02759689f, 
    0.01802853f, 0.00989339f, -0.00294685f, -0.00528870f, -0.00521572f, -0.03564660f, 0.01078903f, -0.01681088f, 
    -0.03536749f, 0.01605958f, 0.01507108f, -0.02345540f, -0.01822582f, -0.00711867f, -0.02862526f, -0.03544577f, 
    -0.00851354f, -0.00145106f, 0.01155005f, -0.01938736f, 0.00509620f, -0.01587125f, 0.00634642f, 0.01153064f, 
    0.00183880f, 0.00354905f, 0.01436046f, -0.01976337f, -0.02078676f, -0.00996458f, -0.00001489f, 0.02515678f, 
    0.00714580f, -0.01601308f, 0.03061156f, 0.00841010f, -0.02012452f, 0.02313395f, -0.03441732f, -0.00730720f, 
    0.01958360f, -0.01039789f, 0.01836377f, 0.00989344f, -0.02213288f, -0.01162916f, 0.00107672f, -0.00271912f, 
    -0.02607002f, -0.01913093f, -0.00272876f, -0.02793242f, -0.01691454f, 0.01673129f, 0.01376511f, 0.00949013f, 
    -0.00995898f, 0.00245918f, 0.02606792f, -0.02233137f, 0.01101500f, 0.00662391f, -0.03370666f, 0.02426102f, 
    -0.00521415f, -0.03632354f, -0.01507672f, -0.02281100f, -0.02219131f, 0.03653457f, -0.01199437f, 0.01796989f, 
    -0.01664631f, 0.02354561f, 0.00998372f, -0.00297118f, -0.00198490f, -0.01725663f, 0.01414345f, -0.00478546f, 
    -0.02874672f, -0.00425538f, -0.03201002f, 0.01328318f, 0.02634717f, 0.02838572f, 0.01753240f, -0.01815218f, 
    -0.01025137f, 0.02380007f, -0.04368963f, -0.00882856f, -0.04058113f, 0.00356002f, -0.04894529f, -0.00413587f, 
    -0.02452692f, -0.02849477f, 0.00737274f, -0.03188765f, -0.02182564f, 0.00464936f, -0.00077543f, 0.02620613f, 
    0.00417210f, 0.02205969f, 0.00918295f, -0.01850179f, 0.02280699f, 0.03401712f, 0.03214920f, -0.00555727f, 
    0.02447081f, -0.00245320f, 0.03627592f, 0.01259304f, -0.05166993f, -0.01330764f, 0.00741988f, -0.00916827f, 
    -0.02941707f, 0.03150323f, -0.02828592f, 0.02720233f, -0.03799557f, 0.00768628f, 0.00515775f, 0.03016928f, 
    0.00820944f, -0.01861014f, 0.01509319f, -0.01810751f, 0.01989168f, -0.03988241f, 0.02165037f, -0.03755030f, 
    0.02202448f, -0.02572154f, -0.02250814f, -0.02301884f, -0.01176645f, 0.00279664f, 0.00154909f, 0.03605271f, 
    0.02212829f, 0.00047190f, 0.01776948f, -0.01533792f, -0.01073630f, 0.02989897f, -0.01875765f, 0.02533291f, 
    -0.04118791f, -0.03423336f, -0.00099742f, -0.00899035f, -0.02805413f, -0.01901468f, -0.02813453f, -0.01935903f, 
    -0.03584367f, -0.03092949f, 0.02062690f, -0.03361318f, 0.01864466f, -0.00191488f, 0.02899030f, 0.00108708f, 
    -0.03263095f, -0.00562607f, -0.01257327f, -0.03336389f, -0.00917353f, -0.03084984f, 0.00661665f, -0.02687159f, 
    -0.01248053f, 0.00003013f, 0.01745124f, -0.01489637f, -0.00632056f, 0.02818725f, -0.00215490f, -0.03750277f, 
    -0.00418073f, -0.04642042f, -0.01028117f, 0.01176145f, 0.01188909f, -0.04268696f, 0.00350573f, -0.00532966f, 
    0.00269060f, -0.04100479f, -0.01808086f, -0.02648476f, -0.02699489f, 0.01997565f, -0.00611792f, -0.00940457f, 
    -0.01646678f, -0.04170135f, -0.04419370f, -0.01547473f, -0.00404344f, 0.01512019f, -0.02436955f, -0.03177415f, 
    0.01412507f, 0.01451278f, -0.01553457f, 0.02816295f, 0.01924569f, 0.00568135f, 0.01005277f, -0.02904302f, 
    -0.04139979f, -0.01247487f, -0.02576363f, -0.00419937f, 0.00532988f, -0.02893299f, 0.01713775f, -0.03414252f, 
    0.02069623f, 0.02070800f, -0.03409113f, -0.03432607f, 0.01385312f, -0.01264083f, -0.02018302f, -0.00937398f, 
    0.02570927f, 0.00711781f, 0.02815282f, -0.01352831f, 0.01778106f, 0.01302605f, -0.04027310f, 0.00044651f, 
    0.02656029f, -0.01129382f, -0.01781785f, 0.02518061f, 0.03467101f, -0.03312651f, -0.00691045f, 0.00449643f, 
    -0.03518942f, 0.01159733f, 0.01628298f, -0.03475848f, -0.00821072f, -0.01234859f, -0.03204296f, -0.01871104f, 
    -0.03535560f, 0.00309698f, -0.02792787f, 0.03230695f, -0.01771151f, -0.00822467f, -0.01226577f, 0.00680287f, 
    -0.02835908f, -0.03505792f, -0.02714142f, -0.03919400f, 0.01014351f, -0.03038466f, 0.01621216f, -0.00180875f, 
    0.01465615f, 0.00710199f, -0.01581810f, -0.00281916f, 0.01759402f, -0.00647390f, 0.03057151f, 0.00510492f, 
    -0.00075206f, 0.02255829f, -0.00232121f, -0.03487365f, 0.00067077f, 0.01185749f, -0.03808882f, -0.02843546f, 
    -0.01376824f, -0.01841982f, 0.03015321f, -0.03135807f, -0.01302648f, 0.00258231f, -0.04316040f, -0.03602035f, 
    0.01617250f, -0.00852117f, -0.00086531f, -0.02663544f, -0.04305805f, 0.00963290f, 0.01589005f, 0.01184511f, 
    -0.00399171f, -0.00940178f, 0.02066167f, 0.00146917f, -0.00081138f, -0.00726805f, -0.00904151f, 0.02594839f, 
    -0.03138946f, -0.03353909f, -0.00547404f, 0.00546508f, -0.00388555f, 0.02484675f, -0.00833626f, -0.03748480f, 
    -0.03464924f, 0.00358228f, -0.00720737f, -0.02402139f, -0.04102408f, -0.00195406f, 0.02207308f, 0.01780213f, 
    -0.04512318f, -0.02257917f, -0.02627860f, -0.03318464f, -0.02640955f, -0.04202721f, 0.02664794f, -0.01560596f, 
    -0.02594729f, -0.00547462f, -0.04024674f, 0.00715404f, -0.01872804f, -0.03113879f, 0.01260159f, 0.00045713f, 
    0.02871953f, -0.01030095f, 0.01118419f, -0.04156609f, -0.04204154f, 0.00537572f, 0.00259891f, -0.00905910f, 
    0.00936774f, -0.00966446f, 0.00977033f, -0.01438178f, -0.01625512f, -0.00644091f, 0.00386461f, 0.00240016f, 
    -0.03470673f, 0.02644896f, -0.01065940f, -0.00058364f, -0.03900746f, 0.00670278f, -0.02181569f, -0.02584887f, 
    -0.00893310f, -0.02269475f, -0.01858631f, -0.01431171f, -0.01015400f, -0.04498910f, -0.02442525f, 0.00941080f, 
    -0.02791529f, -0.02022899f, 0.01571310f, -0.02723905f, 0.00851818f, -0.00843053f, -0.02999506f, 0.00018405f, 
    -0.02165053f, 0.01471942f, -0.02734283f, -0.03856562f, 0.01922606f, -0.00138808f, -0.00336778f, 0.02075363f, 
    0.03206832f, 0.03009872f, 0.00360084f, 0.02175744f, -0.02256079f, -0.00806912f, -0.03659035f, -0.02089685f, 
    -0.00141316f, -0.00102995f, -0.01514556f, 0.00304083f, -0.00405414f, -0.03083906f, -0.02913998f, 0.03500563f, 
    0.01325167f, -0.00180026f, -0.01317371f, 0.00544269f, -0.01679629f, 0.00320753f, 0.00210266f, 0.00886143f, 
    -0.02064843f, 0.01297570f, -0.02505480f, 0.02885431f, -0.03296138f, -0.00582220f, -0.00729672f, -0.02376201f, 
    0.01205646f, 0.01646602f, -0.00521282f, -0.00524875f, 0.02084401f, 0.02727478f, 0.02542746f, 0.00540750f, 
    -0.01981569f, -0.03573598f, 0.03287452f, 0.03015190f, -0.03456045f, 0.01978325f, 0.00159554f, -0.03168764f, 
    0.00679655f, 0.02243421f, -0.02351335f, -0.03218310f, -0.00197250f, -0.02722200f, -0.03568153f, 0.00267119f, 
    0.01116180f, -0.02428101f, -0.02795622f, 0.01900174f, -0.00085469f, -0.03204096f, 0.01607668f, -0.02939761f, 
    0.02333906f, -0.01695572f, 0.02520303f, 0.01120999f, -0.01803976f, -0.00475726f, -0.02548360f, -0.02552510f, 
    0.00526367f, -0.03224276f, 0.00993504f, 0.03703095f, 0.02022722f, 0.00268857f, 0.02017030f, 0.00953550f, 
    -0.02842731f, -0.01358955f, -0.02242300f, 0.01577820f, -0.01626933f, -0.02101835f, -0.00736537f, -0.02624096f, 
    -0.00237156f, -0.02697729f, -0.02859168f, 0.01850467f, -0.02996121f, -0.01085146f, 0.02457112f, 0.00210508f, 
    -0.03441098f, 0.00471337f, 0.00558692f, 0.00319507f, -0.01695951f, -0.02428108f, 0.03100856f, -0.00903075f, 
    -0.01711731f, -0.00324716f, 0.01379197f, 0.00920630f, -0.03247213f, -0.02238880f, -0.03645599f, -0.02724684f, 
    0.01324945f, -0.03933405f, -0.03353805f, -0.01381072f, 0.01672488f, -0.02708728f, -0.02635260f, -0.00237934f, 
    -0.01406897f, -0.02454364f, -0.03370996f, 0.01204117f, -0.01490405f, -0.03331148f, -0.02518038f, 0.01326700f, 
    0.03301916f, 0.03412005f, -0.02962249f, 0.02628871f, -0.00637267f, -0.00695615f, -0.01223730f, -0.01112063f, 
    -0.04791083f, 0.00626948f, -0.01487912f, -0.03183757f, -0.02609095f, -0.03667780f, 0.01505432f, -0.04284170f, 
    -0.03651791f, 0.00763405f, 0.00321513f, -0.01978944f, 0.00767131f, 0.02381318f, 0.02921296f, 0.01689706f, 
    0.02808190f, -0.03148088f, -0.02925511f, -0.00147100f, -0.01563001f, 0.00043559f, 0.00362321f, -0.02950605f, 
    -0.02559327f, 0.01444114f, -0.02790312f, 0.01912061f, 0.00659943f, 0.02632977f, -0.01309913f, -0.03422711f, 
    -0.01343371f, -0.03085860f, -0.01445367f, -0.02508121f, 0.00684069f, -0.02179957f, 0.02894326f, 0.02222138f, 
    -0.01352374f, 0.00301868f, -0.01669483f, -0.00932162f, 0.02796010f, 0.01666158f, -0.03244578f, -0.01760207f, 
    -0.01852927f, -0.02061653f, 0.01543426f, -0.02269943f, -0.03255044f, -0.01245494f, -0.00978369f, 0.00650452f, 
    0.02788550f, -0.00193304f, -0.00521427f, 0.02698803f, -0.00162256f, -0.02928820f, -0.01132111f, -0.02319877f, 
    0.00997960f, 0.01870022f, 0.01941714f, -0.03862299f, 0.00328948f, 0.00375640f, 0.01388101f, 0.00691049f, 
    -0.03549692f, 0.01579744f, -0.00831966f, 0.01174887f, 0.02454091f, 0.00641624f, 0.00166387f, -0.00752172f, 
    -0.00563466f, 0.01182200f, -0.02144924f, -0.02622965f, 0.02104907f, 0.01739390f, -0.03981914f, 0.02585997f, 
    0.02087864f, 0.01182842f, 0.01377971f, -0.03440800f, -0.02539745f, -0.01838736f, -0.03329362f, 0.02960185f, 
    0.02043566f, -0.00825947f, -0.00375550f, -0.00379514f, -0.03648692f, -0.04165966f, -0.02981376f, 0.03776705f, 
    0.23890945f, 0.01775242f, -0.12241028f, 0.04996651f, -0.00990278f, -0.07593574f, 0.13384990f, 0.07693683f, 
    0.18941130f, -0.03617145f, 0.00308196f, 0.19188753f, -0.12221149f, -0.01100678f, 0.04717058f, -0.11204470f, 
    0.08329628f, -0.05205195f, 0.03252202f, 0.05685640f, -0.00389786f, -0.03281067f, -0.03641171f, 0.02252426f, 
    0.05461943f, 0.02594874f, -0.05322062f, -0.00148243f, 0.03773877f, -0.10867806f, -0.00289884f, 0.00241380f, 
    0.02002200f, -0.07787678f, 0.07350656f, 0.01808950f, -0.14233594f, 0.24750486f, 0.01157878f, 0.12409735f, 
    -0.00118101f, 0.08290297f, 0.06016390f, 0.12298135f, 0.06275795f, -0.03326863f, 0.15803571f, -0.03851839f, 
    -0.05302109f, -0.20996401f, 0.02567786f, 0.00219869f, -0.06417061f, -0.02226659f, -0.07146353f, -0.09605133f, 
    0.07223142f, -0.12180717f, 0.06926844f, 0.01364443f, -0.25878817f, -0.17636035f, 0.13410933f, -0.14913672f, 
    -0.13484682f, 0.06394155f, 0.02333006f, 0.08795768f, 0.07458358f, 0.13141885f, -0.09030753f, -0.02086443f, 
    0.04530799f, 0.06226740f, 0.18174310f, -0.05175553f, -0.05595930f, -0.01556543f, -0.04557350f, -0.05262329f, 
    0.04108843f, -0.02807192f, 0.01513894f, 0.08342617f, 0.04177380f, -0.12197261f, -0.22516432f, 0.16809377f, 
    0.07059526f, 0.14267756f, 0.06876971f, 0.23505446f, 0.18209513f, 0.02827445f, 0.05433672f, 0.11372374f, 
    0.23243682f, -0.12883987f, 0.01071403f, 0.13764238f, 0.09985548f, -0.00332539f, -0.01243268f, 0.06250137f, 
    -0.10073435f, -0.03948871f, -0.01727000f, 0.01610988f, -0.03795357f, 0.02739982f, -0.26185051f, 0.08915494f, 
    0.08372208f, -0.07778654f, -0.05221790f, 0.02733991f, -0.05265960f, -0.11044343f, -0.02046045f, 0.14530867f, 
    0.22601755f, 0.03179173f, 0.06751978f, -0.16092651f, 0.00588364f, -0.01871762f, -0.00256113f, 0.01832871f, 
    -0.00539267f, 0.11419169f, -0.07757109f, 0.04192543f, 0.19280095f, 0.04004956f, 0.00120632f, -0.09573036f, 
    0.26241085f, -0.08159284f, 0.02134255f, 0.13237697f, 0.01833721f, 0.08596944f, -0.02118891f, 0.02576563f, 
    -0.00964089f, 0.02357897f, 0.04973361f, 0.06467320f, 0.05582130f, -0.04983383f, -0.06587552f, 0.03199914f, 
    0.02933193f, 0.06634983f, -0.05147837f, -0.07618260f, 0.09556348f, 0.08443780f, 0.12350445f, 0.01267039f, 
    0.04115286f, -0.12041286f, -0.01076103f, -0.07269625f, -0.04674774f, 0.13513105f, 0.11892740f, 0.01644792f, 
    0.05125389f, 0.04194281f, -0.10830256f, -0.09873759f, 0.09543348f, -0.04513347f, -0.06762642f, -0.05713354f, 
    -0.06552458f, 0.00495427f, 0.14512280f, -0.08412675f, 0.05346586f, 0.07958438f, 0.11464864f, 0.04429339f, 
    0.04494305f, 0.08856416f, 0.02249703f, -0.13247314f, 0.08793247f, 0.01219364f, -0.05637011f, -0.08713491f, 
    0.05036559f, 0.05573565f, 0.00023929f, -0.06284393f, 0.00407713f, -0.03535911f, -0.07520008f, -0.10415877f, 
    -0.04363952f, -0.00810561f, 0.01718097f, 0.00497141f, -0.02754779f, -0.03562977f, -0.20769839f, -0.08307239f, 
    0.05478875f, -0.12141649f, -0.12502408f, 0.00344867f, 0.17095454f, 0.04607952f, 0.09172362f, -0.03575850f, 
    -0.49205074f, -0.00479464f, -0.01121265f, -0.11927868f, -0.10181754f, 0.01257216f, -0.01995407f, 0.11001357f, 
    0.05746398f, 0.04353821f, -0.05062798f, 0.02959907f, -0.05309455f, -0.06813568f, 0.05831582f, -0.02803957f, 
    0.01532934f, -0.00430936f, -0.00155719f, 0.06916694f, 0.01988118f, -0.07803703f, -0.01618838f, -0.17541233f, 
    -0.05976525f, 0.04593313f, -0.01785134f, -0.08101543f, -0.02626347f, -0.12948832f, -0.11062357f, -0.04343063f, 
    -0.08882163f, -0.04696979f, 0.02784370f, -0.05208292f, -0.15425576f, 0.02004781f, -0.33009535f, -0.13206734f, 
    -0.08771960f, -0.04680172f, 0.01564040f, -0.00359790f, 0.05091684f, 0.08277822f, 0.01227741f, 0.15598026f, 
    0.08860032f, -0.08696216f, 0.08753653f, 0.12805450f, 0.01746614f, 0.04925377f, 0.08972862f, 0.07954188f, 
    -0.03401900f, -0.02119527f, 0.02373513f, -0.07140020f, -0.04732197f, -0.07786139f, -0.11456151f, -0.01554038f, 
    0.01140989f, -0.06289098f, 0.04370169f, 0.00744479f, 0.09890717f, 0.04055998f, 0.01908747f, 0.02404238f, 
    -0.03270897f, 0.03343131f, -0.07041770f, -0.08806039f, 0.00819583f, 0.00380521f, -0.06810256f, 0.03691863f, 
    0.10506527f, -0.06923283f, 0.13973016f, 0.12749781f, -0.17921881f, -0.26101094f, -0.17254668f, 0.16046835f, 
    -0.04945358f, 0.03610953f, 0.07165063f, 0.06640830f, -0.07470797f, -0.14142773f, -0.03436138f, 0.05299740f, 
    -0.00774757f, 0.00013937f, -0.02477089f, -0.04469406f, 0.11308735f, -0.00652637f, 0.09055205f, 0.07908911f, 
    0.11328229f, 0.06070989f, -0.09800515f, 0.05395646f, 0.14730819f, -0.08646423f, -0.10739217f, -0.01407292f, 
    -0.05758080f, -0.00571225f, -0.16069967f, 0.00845271f, -0.07842092f, 0.02439738f, -0.01657259f, -0.04450250f, 
    -0.08231460f, -0.03128584f, -0.01894360f, -0.04257098f, -0.04341012f, -0.08399674f, -0.07096778f, -0.02684885f, 
    0.08701637f, -0.04235876f, 0.02755406f, -0.07819398f, -0.15352592f, 0.03002879f, -0.22076869f, -0.04047678f, 
    0.06580088f, -0.04868344f, -0.01167048f, -0.12684940f, -0.08432776f, -0.01038236f, -0.01154344f, 0.00216263f, 
    0.06628457f, -0.27158800f, -0.01241114f, -0.01789916f, -0.03788718f, -0.05650112f, -0.00930858f, -0.03140905f, 
    0.14661144f, -0.08527537f, -0.10486156f, -0.01517508f, 0.17518508f, 0.16503520f, 0.00400040f, 0.11351643f, 
    0.32601765f, -0.02112138f, 0.06373778f, 0.09747154f, 0.01929191f, 0.06130608f, 0.12264889f, 0.06454606f, 
    -0.06306400f, 0.04044629f, 0.04781107f, 0.15832198f, -0.10318416f, -0.03462167f, 0.01871315f, -0.12655218f, 
    -0.02995121f, -0.01066656f, -0.03286007f, 0.06151023f, -0.10221475f, -0.06414644f, -0.10669170f, -0.18213424f, 
    -0.12253501f, 0.01773270f, -0.01946298f, 0.08813197f, 0.06412852f, 0.05491412f, 0.06093958f, 0.08347543f, 
    -0.15995364f, -0.11573068f, 0.00860881f, 0.06705498f, 0.04822826f, 0.06204823f, 0.01491985f, -0.07875793f, 
    -0.10527375f, -0.00098570f, -0.00690825f, 0.04334773f, 0.34577227f, 0.27044290f, -0.05567383f, 0.20020209f, 
    0.17244615f, -0.05965022f, -0.01640262f, 0.02228706f, 0.17388248f, 0.12948798f, 0.13154550f, 0.01690533f, 
    0.24030583f, 0.33187664f, 0.22195677f, 0.04776314f, 0.10020870f, 0.06031039f, 0.01422781f, 0.06279960f, 
    0.15445164f, 0.15954867f, 0.10922030f, 0.05544933f, -0.11571888f, -0.06346042f, -0.01026690f, -0.06843162f, 
    -0.06810004f, -0.10144787f, -0.11893914f, -0.10103533f, -0.10020354f, -0.10219527f, -0.12423925f, -0.07680568f, 
    0.04684604f, -0.08406983f, 0.01621401f, -0.09938062f, -0.01850878f, 0.03005088f, -0.05282167f, 0.19862899f, 
    0.04673744f, 0.01796188f, 0.04969080f, 0.16460569f, 0.25214651f, 0.11744060f, -0.19399093f, 0.14121339f, 
    -0.02135679f, -0.04726365f, 0.01299857f, 0.04004574f, 0.08416337f, 0.03350742f, -0.00388486f, 0.18529005f, 
    0.01445692f, -0.23282151f, 0.01292549f, 0.01977061f, 0.05024491f, 0.08243614f, -0.08846156f, 0.12876712f, 
    -0.16569673f, -0.15266597f, -0.00101669f, -0.14622848f, 0.02497282f, -0.06836911f, -0.06472810f, -0.04685371f, 
    -0.13002612f, -0.02421626f, 0.02084458f, 0.00834718f, 0.02002315f, 0.06853841f, -0.02859717f, 0.12547788f, 
    -0.15071534f, -0.02709711f, 0.09164646f, -0.18490544f, 0.02065264f, -0.08936530f, -0.14456910f, -0.14964262f, 
    0.07752082f, -0.05282674f, 0.06001672f, 0.06908747f, -0.12211262f, -0.05353124f, 0.13114904f, 0.00632131f, 
    0.02299742f, 0.01999489f, 0.08015232f, 0.06366723f, -0.01382029f, 0.01867809f, 0.03914919f, 0.11355872f, 
    -0.09889802f, 0.04403035f, -0.01947456f, 0.01044249f, -0.10795215f, 0.20761463f, 0.07408392f, 0.12209988f, 
    0.00234302f, -0.21027315f, -0.04592933f, -0.05980340f, -0.20161702f, 0.04606356f, -0.01630611f, 0.02822091f, 
    0.01533828f, 0.05293696f, 0.05569023f, 0.12602618f, -0.07130175f, -0.01683948f, 0.00836616f, 0.05002242f, 
    0.14622065f, 0.10732190f, -0.04450581f, -0.12782277f, 0.12773490f, -0.05935411f, -0.06814805f, -0.01747762f, 
    0.09146847f, -0.01168773f, 0.07062300f, 0.10441163f, -0.00984301f, -0.08479130f, -0.10144805f, 0.02952790f, 
    -0.09686192f, -0.01963129f, -0.01775065f, 0.04103095f, 0.11964513f, 0.05253632f, -0.00304250f, 0.13808167f, 
    0.07233880f, -0.14297666f, 0.01945699f, 0.14251143f, -0.10930344f, -0.06957860f, 0.03849299f, -0.19868600f, 
    0.04588985f, 0.13411070f, 0.11255445f, 0.08350743f, 0.10621115f, -0.01914272f, 0.22744539f, -0.02787771f, 
    -0.10330633f, 0.15710263f, 0.00881844f, -0.09914601f, 0.09125545f, -0.00818781f, 0.02463130f, -0.05239441f, 
    -0.05998447f, -0.02441668f, -0.08409398f, -0.06415989f, -0.00023712f, -0.07652420f, -0.03004332f, -0.09311690f, 
    0.05744473f, 0.00388452f, 0.00509636f, 0.05034428f, -0.40643775f, 0.04943268f, -0.09900747f, 0.11615690f, 
    -0.10539658f, 0.03079803f, 0.00883633f, 0.09056479f, -0.03113947f, -0.02137340f, -0.06546984f, -0.02178892f, 
    0.05792964f, -0.01608368f, -0.00541788f, 0.01144871f, 0.07018012f, 0.06869222f, 0.06148283f, -0.00306258f, 
    0.22420719f, 0.06381139f, 0.09567142f, 0.13672315f, 0.00974963f, -0.03183972f, 0.07439555f, -0.05322921f, 
    -0.03079342f, 0.06796266f, 0.00927215f, -0.09065838f, 0.00923004f, -0.02343265f, 0.07793487f, 0.10582662f, 
    -0.01106863f, -0.07032952f, -0.06885672f, -0.05851003f, -0.06676777f, -0.00509113f, -0.09126553f, -0.02438557f, 
    0.05919980f, -0.09632810f, -0.04032297f, -0.10030966f, 0.26316303f, 0.00663551f, 0.11219477f, 0.05692476f, 
    -0.09141335f, -0.02790909f, 0.15109296f, -0.12699074f, 0.11180595f, 0.00083754f, 0.02205839f, 0.12354058f, 
    -0.06531814f, 0.03773945f, 0.05836885f, -0.07277267f, -0.15619966f, 0.02399813f, -0.23673974f, -0.22835012f, 
    -0.02061475f, -0.06377131f, 0.02696577f, 0.14646439f, 0.16365981f, 0.20524831f, -0.11238390f, 0.16947238f, 
    0.09922826f, 0.01897857f, -0.04746937f, 0.26466984f, 0.06334636f, 0.04688288f, -0.00390221f, 0.06304102f, 
    0.01465216f, 0.06933799f, -0.02217766f, -0.04190129f, -0.05451507f, -0.09774683f, -0.06392366f, -0.02977468f, 
    0.02166459f, 0.07291205f, -0.04020810f, 0.04560273f, 0.00928269f, 0.13873424f, -0.11854980f, -0.14040929f, 
    -0.01629191f, -0.06244959f, 0.08071393f, -0.08543711f, -0.07591932f, 0.06340189f, 0.04525985f, 0.01027888f, 
    0.36255118f, -0.03202169f, -0.43109891f, 0.02271288f, -0.02695173f, -0.02609085f, 0.11943707f, -0.08293204f, 
    0.13121557f, 0.05781662f, 0.10172082f, 0.12465551f, 0.00760891f, -0.12821050f, 0.14584501f, 0.11167234f, 
    0.13991663f, 0.02449082f, -0.00321935f, 0.06338810f, -0.09080351f, -0.02452207f, -0.00860877f, -0.20536360f, 
    -0.07709509f, -0.18311369f, -0.04195309f, -0.17182149f, -0.18901460f, 0.04052989f, -0.05495348f, 0.00954904f, 
    0.00605176f, 0.04070444f, 0.11374655f, 0.01958179f, -0.18408906f, -0.12081841f, -0.10588067f, -0.14715335f, 
    -0.10580629f, -0.08113015f, -0.15177672f, -0.06872469f, 0.13927998f, 0.06584582f, 0.01220501f, -0.03168833f, 
    -0.00978985f, 0.01454324f, 0.02148177f, -0.02974929f, 0.01933873f, -0.03609777f, 0.01946786f, -0.02912995f, 
    -0.02292862f, -0.00039460f, -0.02620617f, 0.01112843f, -0.03172631f, 0.00119835f, -0.04133509f, 0.00443879f, 
    -0.00977365f, 0.00319153f, 0.02078222f, 0.02018063f, -0.02440519f, -0.03783403f, 0.02716808f, -0.04383203f, 
    -0.03775108f, 0.01837971f, -0.00719413f, 0.01379195f, -0.01116014f, -0.02534535f, -0.00605845f, 0.01189588f, 
    -0.04034803f, 0.00171331f, 0.00396322f, 0.00295376f, -0.00147232f, 0.01265970f, 0.01925386f, -0.02179831f, 
    -0.04450714f, -0.01276266f, 0.01873623f, 0.02104913f, -0.03129048f, 0.01465668f, -0.01019682f, 0.01657769f, 
    0.00288715f, -0.02644336f, -0.01508728f, -0.00676681f, -0.01213306f, -0.01595156f, -0.03036861f, -0.00727400f, 
    0.02582608f, -0.01163766f, 0.02385901f, -0.00086608f, -0.03644378f, -0.01407797f, -0.01036516f, -0.01338989f, 
    0.02081716f, 0.01492781f, 0.00727617f, -0.02201860f, -0.03108582f, -0.00579681f, -0.00634322f, 0.01957986f, 
    -0.00220977f, 0.02149220f, -0.02650220f, 0.01978893f, -0.03388999f, -0.03067750f, 0.00215340f, -0.00541104f, 
    0.00345708f, 0.02208025f, 0.01296950f, -0.01626581f, 0.02445964f, -0.02619040f, 0.02169422f, 0.02117207f, 
    -0.02175122f, 0.01143239f, -0.03976214f, 0.01178506f, 0.02703559f, 0.01355642f, 0.01236494f, -0.02738298f, 
    -0.04217554f, -0.04222040f, 0.01749721f, -0.00340435f, -0.03580764f, -0.00654365f, 0.00135133f, 0.02718372f, 
    -0.01384170f, -0.02428428f, -0.00775409f, 0.00576606f, -0.03949631f, -0.04360384f, 0.03605604f, 0.03885116f, 
    -0.04291855f, -0.00845866f, -0.02646110f, -0.03739614f, -0.03049984f, -0.04189101f, 0.01859038f, -0.03245132f, 
    -0.01531263f, -0.03039972f, 0.00256501f, -0.00180491f, -0.02008662f, -0.04098623f, -0.03072730f, 0.02369145f, 
    -0.00571092f, -0.02490913f, -0.03981923f, 0.02561846f, 0.00166425f, 0.02061819f, -0.00928791f, -0.04302665f, 
    -0.01169005f, 0.01872382f, 0.00011454f, 0.00558741f, 0.01672680f, -0.03009477f, -0.01893722f, -0.02525062f, 
    -0.02088382f, -0.02212118f, 0.02426697f, -0.01490003f, -0.01834896f, 0.02069424f, -0.03068661f, -0.02894855f, 
    0.00385101f, 0.01263322f, -0.00140003f, 0.00541758f, -0.04561717f, -0.01440557f, -0.01625855f, -0.01097344f, 
    -0.00382151f, -0.00333993f, 0.01850132f, 0.00595100f, 0.01762103f, 0.00099747f, 0.02173117f, -0.03400917f, 
    0.02260404f, 0.01788069f, -0.00022463f, 0.02042745f, 0.01712275f, -0.02501178f, 0.00071156f, 0.02786621f, 
    0.02162407f, 0.02219031f, -0.03148861f, -0.01316265f, 0.00226309f, 0.01456547f, -0.02312667f, -0.00524744f, 
    -0.04028814f, -0.01813494f, 0.01252453f, -0.00233383f, 0.00048824f, -0.03641506f, -0.01786712f, -0.02738826f, 
    -0.02548775f, -0.03291265f, -0.03713301f, -0.00336601f, -0.04136644f, -0.03676261f, 0.02223413f, 0.01708477f, 
    -0.03471280f, -0.03892139f, -0.00073502f, -0.02317707f, 0.01943026f, -0.04294154f, 0.02133267f, 0.00270664f, 
    -0.01386328f, 0.02556247f, 0.01443709f, 0.01120800f, -0.04360021f, 0.00766513f, 0.02363609f, 0.00197888f, 
    -0.01657371f, 0.01517077f, -0.01879374f, -0.04301271f, 0.01402240f, -0.02545474f, -0.01405555f, -0.00019157f, 
    0.01203272f, 0.01160129f, -0.01565531f, 0.00691780f, 0.01632273f, -0.01989973f, -0.02894579f, 0.01217826f, 
    -0.03410357f, 0.00615106f, 0.00378029f, 0.02308738f, -0.02990130f, 0.00134384f, 0.00673619f, -0.00989977f, 
    0.00331983f, -0.00376168f, -0.04063453f, 0.01154964f, -0.02535344f, -0.02387185f, -0.01881799f, -0.00516247f, 
    -0.03514903f, -0.00421858f, -0.04433798f, -0.00973930f, 0.00681894f, -0.01457480f, -0.02956549f, -0.01641371f, 
    -0.01818666f, -0.04192970f, 0.02499934f, -0.01479118f, 0.00705580f, 0.02615619f, 0.01717873f, 0.01571302f, 
    -0.03333047f, -0.02283430f, 0.01100549f, -0.02048302f, -0.00948411f, -0.04174350f, -0.00119657f, 0.01695377f, 
    -0.03484989f, -0.00531707f, -0.00361965f, -0.03654539f, -0.02995046f, -0.02884394f, 0.01087467f, 0.02118024f, 
    -0.01578586f, -0.00973711f, -0.01185097f, -0.02057149f, -0.04312739f, 0.02177123f, -0.03321210f, 0.01463490f, 
    0.00471804f, -0.04014235f, -0.04174633f, 0.02042275f, 0.01811446f, -0.04304700f, 0.01219088f, 0.00135889f, 
    0.02347332f, 0.01614418f, -0.01347342f, 0.01693323f, 0.00413461f, 0.01412139f, -0.02653569f, 0.00641533f, 
    -0.03370679f, -0.03787774f, 0.01549050f, 0.00683408f, -0.04053316f, -0.03385544f, -0.01948639f, -0.00587348f, 
    -0.00544542f, -0.01141234f, 0.00520180f, -0.01834072f, -0.04229664f, -0.00813071f, 0.00038369f, 0.00597242f, 
    0.00996699f, -0.01849657f, 0.01045203f, -0.00711353f, -0.00277219f, 0.01028224f, 0.02489306f, -0.01597814f, 
    -0.02999965f, -0.02582624f, 0.01788475f, 0.00204597f, 0.01089253f, -0.02688512f, 0.02565635f, -0.01148353f, 
    0.00075589f, -0.01316734f, -0.02497475f, 0.02014618f, 0.00655726f, -0.02767115f, 0.00683529f, 0.00717956f, 
    -0.02273705f, 0.02523946f, 0.01671370f, -0.01756632f, -0.00629815f, 0.02173424f, 0.02373493f, 0.02559963f, 
    0.01412074f, 0.01472340f, -0.03225389f, 0.01575589f, 0.01681691f, 0.02026619f, -0.01994842f, -0.00309888f, 
    0.00150561f, -0.04483529f, 0.02575156f, 0.00740474f, 0.02668436f, -0.00064213f, 0.02170191f, -0.03073873f, 
    0.01696447f, -0.01395035f, 0.02266136f, 0.02389139f, -0.03554941f, -0.04030285f, -0.02423193f, -0.03964905f, 
    0.01637609f, -0.04461149f, 0.02827773f, -0.01094926f, -0.02494266f, -0.03486685f, -0.03423341f, -0.02019317f, 
    -0.00712872f, 0.01495321f, 0.00336538f, -0.03038250f, -0.01280174f, 0.00367849f, -0.00169781f, -0.04136498f, 
    -0.02872208f, -0.03077045f, -0.00869856f, -0.00485485f, 0.01963490f, -0.03397293f, 0.00708206f, -0.00074832f, 
    0.00059749f, -0.00688841f, 0.00702657f, 0.01305332f, -0.01428694f, -0.02544401f, -0.02682383f, 0.00839613f, 
    -0.03090444f, 0.01082631f, -0.02127218f, 0.01998835f, 0.01925186f, -0.03779063f, -0.04565145f, -0.01424909f, 
    -0.00785079f, 0.00330406f, 0.02248080f, -0.02647137f, -0.02056958f, -0.02525593f, -0.02398425f, 0.00261982f, 
    0.01793131f, 0.00890496f, -0.00955726f, 0.02218986f, -0.04214685f, -0.01123867f, 0.00535517f, 0.02212566f, 
    -0.03073166f, -0.03356827f, -0.01512812f, 0.00810220f, -0.00040876f, 0.01349234f, 0.00273680f, -0.01261200f, 
    -0.02997286f, -0.02185223f, -0.02437641f, -0.01793142f, -0.02424796f, 0.00160140f, -0.00456416f, 0.01967663f, 
    -0.00270505f, -0.00188566f, -0.03877547f, -0.03369920f, -0.00166442f, -0.03896195f, 0.00850544f, -0.00440932f, 
    -0.00655808f, -0.03992664f, -0.00622644f, 0.00438146f, -0.04099432f, -0.02507311f, 0.00022435f, 0.01957623f, 
    -0.00214681f, -0.01069406f, -0.01775410f, 0.02244200f, -0.01616112f, 0.01396078f, 0.02781080f, 0.01440816f, 
    0.00799124f, 0.01707438f, 0.00545795f, -0.00889883f, -0.02917244f, -0.01395230f, -0.01689469f, 0.00582895f, 
    0.00635853f, 0.02417822f, 0.00855058f, 0.01668824f, -0.02440600f, -0.02501204f, 0.02573389f, -0.00754035f, 
    0.00729672f, 0.02676244f, -0.02106909f, -0.00288528f, -0.00655500f, -0.02473203f, 0.00363992f, -0.01735148f, 
    -0.02737968f, 0.00594579f, -0.00086890f, 0.01305687f, -0.03686145f, -0.01957207f, -0.02174548f, 0.02415571f, 
    -0.01444819f, -0.02465471f, -0.02509016f, -0.00910037f, 0.00167869f, 0.02561386f, -0.02927259f, -0.02693398f, 
    -0.03679047f, -0.02902047f, -0.00844848f, 0.01238472f, 0.02643123f, 0.02946012f, 0.01149407f, -0.03781166f, 
    0.01363922f, 0.02445740f, -0.01422170f, -0.00644868f, -0.02017936f, 0.01460704f, -0.02220254f, -0.04289849f, 
    -0.00792908f, -0.00481919f, -0.04214146f, 0.02436100f, -0.02939701f, 0.00637225f, -0.01314427f, -0.00142263f, 
    0.01219493f, -0.02188714f, 0.00951407f, 0.00873978f, -0.02734425f, 0.00780477f, -0.02005640f, 0.00443256f, 
    0.01209319f, 0.00767399f, -0.03035774f, 0.00605679f, 0.01842269f, 0.00954018f, 0.01609924f, 0.00444854f, 
    0.01295778f, -0.02460512f, -0.03296562f, 0.00904628f, 0.02100379f, 0.01632079f, -0.02709925f, -0.02234727f, 
    -0.03066598f, -0.01304296f, -0.03400363f, 0.02099122f, -0.01217670f, -0.03332919f, 0.00692998f, -0.03791771f, 
    0.01973176f, -0.03463085f, 0.00676487f, 0.02413206f, -0.03686177f, -0.00647466f, -0.03173054f, -0.01417992f, 
    -0.02696407f, -0.04040332f, -0.01105925f, -0.00916545f, 0.02362278f, -0.01608994f, 0.02108084f, 0.01533874f, 
    0.01651550f, -0.03072548f, -0.03295553f, 0.02237638f, 0.02224603f, -0.02259389f, 0.01715602f, -0.04423960f, 
    -0.02031019f, 0.01525006f, -0.02835067f, -0.01858006f, 0.01623336f, 0.00027790f, 0.01110053f, -0.03234413f, 
    0.00267558f, -0.02559645f, 0.02015392f, 0.02652076f, -0.04289144f, -0.03597249f, 0.01776810f, -0.00192553f, 
    0.01009290f, -0.03553214f, 0.01175085f, -0.02276313f, -0.00341365f, -0.03880882f, -0.03670457f, -0.01718827f, 
    0.01929766f, 0.00306081f, -0.02084609f, -0.02159558f, -0.00847732f, -0.04169314f, -0.00659061f, -0.00181443f, 
    -0.03462119f, -0.02428234f, 0.00423110f, -0.02915197f, -0.03260108f, -0.04289521f, -0.02700073f, -0.01298305f, 
    -0.00409161f, -0.00823994f, -0.01721049f, -0.03499728f, -0.01331360f, -0.03685249f, -0.03468220f, -0.01739264f, 
    -0.03636242f, -0.04263916f, -0.02709893f, -0.01239196f, 0.00835300f, -0.00403796f, 0.01841110f, 0.00971016f, 
    -0.00593158f, 0.00245409f, -0.01266339f, -0.00423574f, -0.02020306f, 0.01176551f, -0.03747081f, -0.02204139f, 
    -0.01261424f, 0.00842584f, -0.00981605f, 0.00919013f, 0.01944959f, -0.03695926f, 0.01482884f, 0.02012288f, 
    0.00296544f, -0.03131130f, 0.00101984f, 0.01242201f, -0.02710577f, -0.00740237f, 0.01453539f, -0.03272773f, 
    -0.03304215f, -0.01199164f, -0.01040385f, -0.01035123f, 0.01721487f, -0.01738780f, -0.03980398f, 0.01427002f, 
    -0.03853941f, 0.01929096f, -0.03944200f, -0.00900528f, 0.00989195f, -0.03276771f, 0.01885106f, -0.02594507f, 
    -0.03116109f, 0.01159254f, -0.02723386f, -0.02446748f, -0.00149883f, -0.03299646f, 0.01422800f, -0.02382339f, 
    0.00724731f, -0.03019590f, 0.00906574f, -0.03340312f, -0.03778658f, -0.00243519f, 0.00196896f, 0.00867737f, 
    -0.04470318f, 0.00021005f, 0.01778580f, -0.02984970f, 0.00587733f, -0.02164892f, 0.00158452f, 0.01132942f, 
    -0.03020845f, -0.01202985f, 0.01095972f, -0.02443075f, -0.01649229f, 0.00132616f, -0.00925616f, 0.02857225f, 
    -0.00856505f, -0.01860715f, -0.03805405f, -0.03038184f, -0.01017751f, 0.02088132f, 0.01119582f, -0.04452016f, 
    -0.00215837f, -0.02580121f, -0.03570766f, 0.01594500f, 0.02055828f, 0.00528038f, -0.02235069f, -0.03364950f, 
    -0.01711104f, 0.00235066f, 0.01567502f, -0.03730703f, -0.01973970f, -0.00539035f, -0.00467204f, 0.01148542f, 
    -0.02259319f, 0.01752688f, -0.00429114f, 0.02125025f, -0.02145894f, 0.00054906f, 0.02079654f, -0.02709512f, 
    -0.03847211f, -0.03445825f, -0.03875247f, -0.03769531f, -0.00220235f, -0.02549453f, -0.00880268f, -0.00056657f, 
    -0.01336940f, -0.01896988f, 0.02604351f, -0.02874209f, -0.02871654f, 0.01178906f, -0.02142354f, 0.00219997f, 
    0.02828098f, 0.18386018f, -0.05345119f, -0.34113249f, 0.07152172f, 0.11732325f, -0.01861710f, 0.02778134f, 
    -0.01567872f, 0.08622050f, -0.00351442f, -0.13355814f, -0.10929164f, -0.04608338f, 0.14525375f, 0.07381673f, 
    -0.01183849f, 0.10494437f, -0.05089166f, -0.08251952f, -0.02447679f, -0.02042397f, -0.10112397f, -0.00492755f, 
    -0.01492475f, 0.08335535f, -0.03319481f, -0.12011944f, -0.14077793f, -0.14260297f, -0.06985974f, -0.27021685f, 
    -0.10958271f, -0.02392648f, -0.09529737f, -0.02229198f, -0.17411070f, 0.09310924f, 0.03913110f, 0.00208889f, 
    -0.05724895f, 0.12388267f, 0.09033853f, -0.12426327f, -0.02491272f, -0.09976604f, 0.00092252f, 0.06265052f, 
    -0.25683188f, -0.06831035f, 0.16427806f, 0.35742459f, 0.09716278f, 0.04459078f, 0.09681180f, 0.16661362f, 
    0.06236180f, 0.11008793f, 0.05980625f, 0.05226800f, 0.17139415f, 0.25443655f, -0.16542010f, 0.27460602f, 
    -0.04800616f, -0.06012982f, 0.07734216f, -0.00670835f, 0.12274245f, -0.01387698f, 0.12979139f, -0.01764749f, 
    0.06784751f, 0.05181878f, -0.11528425f, 0.07522982f, -0.00234589f, 0.08456495f, -0.04149304f, -0.04870597f, 
    -0.13699719f, -0.11382429f, 0.06884690f, -0.04136606f, 0.21658175f, 0.01139103f, -0.12839095f, 0.05553647f, 
    0.01654856f, -0.05623724f, -0.03579399f, -0.04525661f, -0.07030399f, -0.03944761f, -0.06750732f, -0.10501284f, 
    -0.00229370f, 0.03767277f, -0.03341287f, 0.01093526f, -0.05251149f, 0.02291608f, 0.06044282f, -0.04293005f, 
    0.11002033f, 0.04362927f, -0.00109463f, 0.08228970f, 0.12604633f, -0.04359429f, -0.14578325f, -0.42684034f, 
    -0.00840497f, 0.05509301f, -0.09675224f, 0.02620603f, 0.07331766f, 0.15541120f, 0.03691246f, -0.16381630f, 
    -0.09374337f, -0.22484118f, 0.27154163f, 0.05171631f, 0.01108480f, 0.00667272f, -0.13413107f, -0.05186434f, 
    -0.01242637f, -0.01502789f, 0.03912121f, -0.08089031f, 0.07903104f, -0.02997771f, 0.20655057f, 0.19609162f, 
    -0.12647827f, 0.09391544f, 0.00271723f, -0.09176239f, 0.03145658f, 0.07802489f, -0.07313833f, 0.11320972f, 
    0.03396457f, -0.02467548f, 0.16780110f, -0.07226502f, -0.13086085f, 0.02931800f, -0.00230427f, -0.06976447f, 
    0.08952076f, 0.09590987f, -0.04207223f, 0.08586250f, 0.41583326f, 0.13765848f, 0.03413232f, -0.10816393f, 
    -0.10464639f, 0.06273746f, -0.01573366f, 0.01136389f, 0.01358621f, 0.11337371f, -0.02407852f, -0.01636382f, 
    -0.18725599f, 0.10943733f, 0.03795648f, 0.11752976f, -0.08406624f, 0.07760685f, 0.00416622f, 0.02396941f, 
    -0.00123801f, -0.08938292f, 0.18107045f, 0.11099836f, -0.16780986f, 0.00935265f, 0.00154454f, 0.07169079f, 
    0.07134690f, -0.07300292f, -0.04954478f, -0.01081576f, 0.01238276f, -0.00511325f, -0.00376918f, 0.03173379f, 
    -0.20333079f, -0.02953063f, 0.21759911f, -0.04338605f, 0.00727663f, -0.02827153f, -0.11611658f, 0.00118990f, 
    0.02893307f, 0.03424849f, -0.12709776f, -0.03382108f, -0.03148661f, 0.08301258f, 0.12107621f, 0.18508932f, 
    0.08998693f, 0.11306084f, -0.05437281f, -0.13766941f, -0.15810287f, 0.05214291f, -0.17797528f, -0.01101764f, 
    0.71312833f, -0.10726257f, -0.04892509f, 0.15439583f, 0.07907850f, -0.07116945f, -0.01636283f, -0.09258769f, 
    0.04357199f, -0.02459568f, 0.00559533f, -0.03947243f, 0.23394920f, -0.11491066f, -0.09735547f, 0.18023390f, 
    0.07646869f, 0.03140194f, 0.05973219f, -0.11741585f, -0.01459204f, 0.07416131f, -0.07010739f, 0.18589540f, 
    0.03184758f, -0.08503129f, 0.08654198f, -0.21875077f, -0.04361739f, -0.08806463f, -0.04574547f, -0.03801800f, 
    0.02936228f, -0.05435118f, -0.11725317f, -0.06718294f, 0.24721408f, -0.00084131f, 0.23445813f, -0.12469325f, 
    0.09490395f, 0.02074538f, -0.05741011f, -0.01661895f, 0.03342989f, 0.02315530f, -0.02568784f, 0.03401837f, 
    -0.07509273f, -0.08730941f, -0.01770535f, 0.14447670f, 0.08055025f, 0.06754071f, 0.00624918f, -0.09905866f, 
    0.12510097f, 0.13060969f, -0.06104814f, 0.04488276f, 0.11839470f, 0.01741692f, -0.17591675f, -0.20457484f, 
    0.08061841f, 0.00376746f, 0.03936183f, 0.07023336f, -0.02006241f, -0.02048374f, -0.03213325f, -0.06215733f, 
    -0.01516303f, -0.13525246f, -0.04397693f, -0.25778571f, -0.16100742f, -0.06529310f, -0.03498242f, -0.31980026f, 
    -0.13457571f, -0.06477383f, -0.11258058f, -0.09674612f, 0.25789553f, -0.06978111f, -0.18868628f, -0.00284881f, 
    0.05710565f, 0.09703614f, -0.00937907f, 0.13352776f, 0.00295373f, 0.10029610f, -0.10128871f, -0.02261580f, 
    0.01810522f, -0.11845410f, 0.12706231f, 0.03404702f, -0.00950852f, -0.02606713f, 0.01849465f, 0.00785787f, 
    0.02352554f, 0.00226501f, -0.03987096f, 0.18039273f, 0.17667447f, 0.35437518f, 0.13763283f, 0.14127183f, 
    -0.01351468f, -0.15037879f, 0.03812393f, -0.03316949f, 0.08230913f, 0.04940054f, 0.00817180f, -0.05178272f, 
    0.08840539f, 0.03806318f, 0.01245971f, 0.02723935f, -0.08392099f, -0.06956785f, -0.03804689f, -0.03737352f, 
    0.06740476f, 0.06110394f, -0.00210412f, 0.08343308f, -0.22624980f, -0.10594986f, 0.19762965f, 0.30837432f, 
    0.00513985f, 0.02399667f, -0.05249650f, -0.02384402f, -0.00956264f, 0.03468121f, -0.05064737f, -0.01020745f, 
    0.09352951f, 0.17577629f, 0.10330787f, -0.06783848f, 0.07239930f, 0.05714477f, -0.02961720f, -0.06531498f, 
    0.01414117f, 0.10333502f, -0.02155323f, 0.01158134f, -0.16751163f, 0.06604572f, -0.02536033f, -0.23107103f, 
    -0.06579069f, 0.07602609f, -0.02790858f, 0.00198320f, 0.09133800f, 0.01014353f, -0.05350496f, -0.04326395f, 
    -0.07217649f, -0.17313781f, -0.06346674f, 0.04672867f, -0.02340003f, 0.00152597f, -0.07669356f, 0.05801254f, 
    0.05636704f, 0.03152478f, 0.03835316f, -0.02478004f, 0.18767400f, 0.04184781f, -0.12299880f, -0.21985467f, 
    -0.07210682f, 0.05218331f, 0.02321821f, -0.22106986f, 0.00195204f, -0.06393104f, -0.01485743f, -0.02826630f, 
    -0.05325379f, -0.02593973f, 0.07762402f, 0.18370040f, -0.00087321f, -0.00017927f, 0.02693277f, 0.08073281f, 
    0.04557678f, -0.01536673f, -0.00504396f, -0.04724002f, -0.37250781f, 0.04329768f, 0.03579933f, 0.03014117f, 
    -0.09923189f, -0.00074236f, 0.04541395f, 0.01897898f, -0.01060531f, -0.00262397f, -0.05710074f, 0.12733582f, 
    -0.24565923f, -0.00852943f, 0.05232615f, 0.11380941f, -0.04461133f, 0.03842371f, -0.08808261f, -0.11195370f, 
    0.01985111f, -0.11359324f, 0.03236401f, 0.05753068f, 0.09227589f, 0.08883508f, 0.10672910f, -0.01759348f, 
    -0.11709493f, 0.02543554f, -0.08297965f, -0.00538634f, 0.19314568f, 0.08837799f, 0.17188784f, 0.02740106f, 
    -0.14642544f, 0.20699623f, -0.04135972f, 0.17507851f, 0.03925140f, 0.07511349f, 0.09783620f, 0.04504590f, 
    -0.08608174f, -0.01964656f, -0.04550841f, -0.05319390f, -0.12604977f, -0.04575322f, 0.07114220f, -0.20635517f, 
    0.01455306f, -0.00532319f, -0.04116715f, -0.00917953f, -0.09642813f, 0.07270340f, -0.08364367f, -0.08781693f, 
    0.15215306f, 0.02262967f, 0.10203311f, -0.01623665f, -0.02835451f, 0.04674385f, 0.08978171f, -0.13235438f, 
    0.13769364f, 0.08696661f, 0.13184334f, 0.14772351f, 0.18487912f, 0.13398047f, -0.01849808f, -0.01206176f, 
    -0.10271826f, -0.15274136f, -0.15836275f, -0.10793986f, -0.18577255f, -0.10155612f, -0.01224302f, -0.04295128f, 
    -0.01007580f, 0.01427081f, 0.03178964f, 0.14803517f, 0.07763490f, 0.10855814f, 0.02835485f, 0.04971732f, 
    0.06714223f, 0.05470576f, -0.00287901f, -0.04602490f, -0.03222797f, 0.03113405f, 0.05024710f, 0.29545406f, 
    0.05804340f, 0.05799482f, 0.12255207f, 0.08210162f, -0.01223714f, -0.04063149f, -0.01432345f, -0.09306385f, 
    -0.07118621f, -0.10140210f, -0.02289601f, 0.20430006f, 0.03917250f, -0.03713994f, 0.17481928f, -0.10988593f, 
    0.05221877f, 0.04921789f, 0.03019492f, 0.11712144f, 0.06586621f, -0.06367763f, 0.09034446f, 0.19957359f, 
    0.02144090f, -0.08468220f, -0.01342111f, -0.01465181f, 0.03713674f, 0.00944972f, -0.05369813f, -0.01680828f, 
    -0.01087853f, -0.09647494f, 0.14727996f, -0.04061342f, -0.18659654f, -0.05924976f, -0.11500741f, -0.08501843f, 
    -0.03323690f, -0.10111044f, -0.01223588f, -0.10465790f, 0.09941304f, 0.03773205f, -0.12983258f, -0.32450953f, 
    -0.04968858f, -0.10437323f, 0.00311158f, -0.04212353f, -0.07983761f, 0.03532650f, 0.00120486f, -0.12287494f, 
    -0.32853901f, 0.14211826f, 0.00667956f, 0.16395427f, 0.12760706f, 0.05301502f, 0.01972471f, 0.17863749f, 
    0.03961962f, -0.05342266f, -0.00109707f, 0.03913154f, -0.16902070f, 0.25177017f, -0.05171894f, 0.12111136f, 
    0.09021173f, 0.08692861f, 0.06697019f, 0.02871384f, 0.01053733f, 0.08964017f, 0.02711632f, 0.03876330f, 
    -0.01929649f, -0.04430073f, 0.09953129f, 0.04921778f, -0.03451322f, 0.05021737f, 0.00684652f, 0.01611873f, 
    -0.12121750f, -0.14648211f, -0.04127724f, -0.21987039f, 0.84563649f, 0.05589375f, -0.03534844f, 0.09978087f, 
    -0.00086318f, 0.00228064f, -0.11323141f, -0.07999712f, 0.06057744f, -0.04858147f, -0.03229454f, 0.04642580f, 
    -0.08604462f, -0.04682284f, 0.13388744f, -0.00871835f, -0.08937354f, -0.03342979f, -0.07197604f, -0.03672482f, 
    -0.12822452f, -0.02162794f, -0.03747409f, 0.00783771f, -0.09196525f, -0.08839546f, 0.03427968f, 0.21341798f, 
    -0.03273818f, -0.00552784f, -0.02379318f, 0.05773900f, 0.05185091f, 0.11847189f, -0.02855205f, 0.02638843f, 
    -0.07608554f, 0.33306649f, 0.08928526f, 0.06295832f, -0.02430939f, 0.10866809f, 0.11264613f, 0.02159373f, 
    0.00366859f, -0.04013751f, 0.08723663f, 0.07680503f, -0.20524453f, 0.10245138f, -0.00069661f, 0.01716786f, 
    0.04497207f, 0.13552897f, -0.06829627f, 0.08660161f, -0.07061929f, 0.03305737f, -0.04736582f, -0.03423538f, 
    -0.07935383f, -0.11802939f, 0.08494102f, 0.29960987f, 0.07600571f, 0.01199156f, 0.09808231f, 0.18486777f, 
    0.06043693f, 0.02945362f, -0.11389200f, 0.01959589f, -0.23500685f, -0.08213025f, -0.07272923f, 0.08430310f, 
    -0.01547988f, 0.07516324f, -0.00244585f, -0.14083590f, 0.02397075f, 0.01622899f, 0.03871137f, 0.01480032f, 
    0.16042352f, -0.00621362f, -0.11926796f, 0.07526776f, -0.04405905f, -0.10432080f, 0.09262212f, -0.06700855f, 
    -0.01007113f, 0.02120449f, -0.11392496f, 0.05924997f, -0.03010974f, 0.09297071f, 0.04977202f, 0.15938370f, 
    0.07231472f, 0.04257330f, 0.11119968f, 0.07769853f, 0.01094420f, -0.08548694f, -0.08380003f, -0.04710634f, 
    0.03941394f, 0.17769991f, -0.11586624f, 0.10830873f, -0.02434597f, -0.03127477f, 0.01992149f, 0.04971864f, 
    -0.14855921f, 0.05331259f, -0.12663150f, 0.09331533f, -0.01919503f, -0.08189509f, 0.06640425f, 0.08371717f, 
    0.10345532f, 0.09901699f, 0.18760760f, 0.00682613f, 0.11482155f, 0.14832900f, -0.01037765f, 0.11115370f, 
    0.11341880f, 0.17755705f, 0.10563370f, 0.27636230f, 0.05940175f, -0.11161255f, 0.15106921f, 0.06104347f, 
    -0.08528644f, -0.03407765f, -0.03324324f, -0.14420348f, 0.17152129f, -0.09293563f, -0.07410467f, -0.26393780f, 
    -0.07530221f, -0.06719454f, 0.11664525f, -0.10319190f, -0.07482835f, -0.08757675f, -0.05493605f, 0.00767443f, 
    -0.07652286f, 0.11045399f, -0.05657168f, -0.20088853f, -0.07144744f, 0.11873551f, 0.04680975f, -0.13989575f, 
    -0.01770535f, 0.01111198f, -0.05318784f, 0.10340160f, 0.03875599f, -0.04866778f, 0.12467995f, 0.04357066f, 
    -0.11017714f, 0.05535755f, -0.08480186f, -0.08319190f, -0.01192192f, -0.02378338f, -0.02889340f, 0.03517305f, 
    -0.16938379f, -0.05526225f, -0.10662629f, -0.04172163f, -0.08939231f, -0.09599583f, -0.08652940f, -0.09108556f, 
    0.09018757f, -0.06248586f, -0.01550483f, 0.00668185f, 0.37714946f, 0.06610940f, -0.02845781f, 0.04374237f, 
    0.15632926f, 0.09531198f, 0.01655582f, 0.11095601f, -0.02599379f, -0.05680987f, -0.04514104f, -0.00629509f, 
    0.21421112f, 0.35514781f, 0.07451171f, 0.31956550f, 0.06370098f, 0.13356146f, 0.09464443f, 0.34148845f, 
    0.00287756f, -0.04784330f, 0.02404843f, 0.03554481f, 0.33577815f, -0.01737317f, -0.39817563f, 0.24901660f, 
    0.07706284f, 0.05224509f, -0.04519483f, 0.12923364f, -0.01676226f, 0.03990572f, 0.07185879f, 0.02620458f, 
    -0.11708651f, -0.28441170f, -0.21398500f, 0.03159248f, -0.02669413f, -0.02103706f, -0.05810734f, -0.04037378f, 
    -0.10088728f, -0.00345060f, -0.01243354f, 0.03789736f, 0.05321755f, 0.22327292f, 0.11698032f, 0.07035946f, 
    0.04386102f, 0.07551909f, 0.01288784f, 0.05132297f, -0.06937095f, -0.02050913f, 0.00068128f, -0.04211382f, 
    -0.09305610f, 0.16062061f, -0.04785933f, -0.21056719f, -0.00431825f, -0.11436499f, -0.00904533f, -0.03531136f, 
    -0.01892645f, 0.00986036f, 0.06453836f, -0.04558199f, -0.15443429f, 0.01927684f, 0.20110619f, -0.21010458f, 
    0.03737937f, -0.00162590f, 0.06884346f, 0.00432866f, -0.00413534f, 0.04681870f, 0.00512647f, -0.04262878f, 
    -0.53111875f, 0.05320602f, 0.08624186f, -0.11247518f, -0.13792343f, -0.13495891f, -0.14383496f, -0.05746245f, 
    -0.04514082f, 0.02227645f, -0.00500221f, 0.01360957f, -0.17321357f, 0.26048419f, 0.21958689f, -0.06883361f, 
    -0.00698380f, -0.02305507f, -0.06020357f, -0.01349417f, 0.05408907f, 0.00765653f, -0.03639194f, -0.00287137f, 
    -0.15679480f, -0.22385970f, 0.01006307f, -0.13388963f, -0.07439280f, -0.06633613f, -0.06901896f, -0.07922520f, 
    -0.09517448f, -0.08562684f, -0.08715808f, -0.12626053f, 0.09084541f, -0.25064644f, -0.01452367f, -0.16061784f, 
    -0.09175155f, -0.01392140f, 0.05885071f, 0.00071415f, -0.06058033f, -0.01755917f, -0.00422006f, -0.12039027f, 
    -0.21303189f, -0.02208154f, -0.01285708f, 0.08441605f, -0.07184698f, -0.08162711f, 0.04629596f, -0.08676070f, 
    -0.08754299f, -0.12642969f, -0.08152977f, 0.18936446f, 0.27959090f, 0.21892005f, -0.03485434f, 0.24624775f, 
    0.20398323f, 0.05209637f, -0.01730376f, -0.15458299f, -0.04257496f, -0.03584360f, -0.10297932f, -0.02788824f, 
    0.06776970f, -0.07510904f, -0.07472616f, -0.07842627f, -0.03024142f, 0.02004018f, 0.03092785f, 0.02204293f, 
    -0.00011919f, -0.00043152f, -0.01285299f, 0.04428587f, -0.05689087f, 0.21855666f, 0.11655445f, 0.04509326f, 
    0.02647587f, 0.10009990f, -0.01901511f, 0.03085241f, -0.00282934f, 0.02822360f, -0.03459985f, 0.02095565f, 
    0.06978258f, -0.30366257f, -0.07036030f, 0.04785633f, 0.08705074f, 0.08807739f, -0.03260158f, 0.00595824f, 
    -0.05311109f, 0.13631953f, 0.05412412f, -0.06539366f, 0.08613267f, -0.10555130f, 0.02708819f, 0.00521388f, 
    0.03895200f, 0.01942076f, -0.08198905f, -0.06423819f, -0.10360512f, 0.07143690f, -0.00673296f, -0.11273731f, 
    -0.06831262f, -0.24559401f, -0.11654200f, -0.06032848f, -0.06416445f, 0.01925811f, -0.00386647f, -0.03032106f, 
    -0.00527511f, 0.04439164f, 0.01796839f, -0.01329146f, 0.11260778f, 0.27126002f, -0.01482530f, -0.17507429f, 
    0.02974199f, 0.02408976f, 0.06057584f, 0.01770604f, -0.21510948f, 0.04498568f, 0.06957881f, 0.04707809f, 
    -0.00246072f, 0.03424946f, 0.11840923f, 0.04100410f, -0.00399926f, 0.06332999f, -0.07979494f, 0.04929060f, 
    0.00781095f, -0.01190861f, -0.00685807f, 0.00656456f, 0.00397521f, -0.06387470f, -0.00411150f, -0.08887047f, 
    0.04045356f, 0.08579752f, 0.03728417f, 0.02734503f, 0.02436901f, 0.01148006f, 0.04248178f, 0.05238339f, 
    -0.23042312f, -0.14126119f, -0.09434325f, -0.11521483f, -0.05553051f, -0.00536631f, -0.01042622f, -0.04842205f, 
    -0.01729041f, 0.03089722f, -0.00411564f, 0.03148251f, 0.01846356f, 0.31835261f, 0.04040566f, -0.03041542f, 
    0.20198810f, 0.20869787f, 0.14400382f, 0.07369133f, 0.01500848f, 0.01843311f, -0.01519094f, 0.01229879f, 
    -0.19310859f, -0.04395311f, 0.02922210f, -0.11606112f, -0.08319058f, -0.08201478f, -0.01789074f, 0.10325292f, 
    -0.04132345f, 0.05399746f, 0.03953625f, -0.01455342f, 0.06747636f, 0.01625329f, -0.04991177f, 0.03622287f, 
    -0.02691962f, -0.07064233f, 0.00862714f, -0.10537538f, -0.04042265f, 0.02448819f, 0.04421942f, 0.01479358f, 
    -0.14761327f, -0.12179422f, -0.04310297f, -0.04792406f, -0.04425151f, -0.05684604f, -0.05554549f, -0.04881364f, 
    -0.11484973f, -0.07279672f, -0.01938770f, -0.08839720f, 0.08382069f, 0.12419876f, 0.17835806f, -0.12256766f, 
    -0.04677020f, 0.09458599f, 0.06860211f, 0.18124090f, 0.03599533f, 0.04924022f, 0.00075996f, -0.01319040f, 
    0.11611272f, 0.29816863f, 0.01307572f, -0.16186100f, 0.06008429f, -0.01363767f, 0.04303642f, -0.02438503f, 
    -0.14961480f, 0.02907675f, 0.00005696f, -0.16973837f, -0.09242798f, 0.03185476f, -0.11200164f, -0.09288800f, 
    -0.09544560f, -0.04817926f, 0.04000112f, 0.02391305f, 0.00728801f, -0.14091347f, 0.01467011f, -0.07372472f, 
    0.25773990f, 0.19565187f, 0.07698365f, 0.03185897f, 0.11144945f, 0.16439478f, 0.00869494f, -0.02836780f, 
    -0.02816802f, -0.05739766f, -0.05728994f, -0.01147196f, -0.02111288f, 0.30730972f, 0.04026713f, -0.16473845f, 
    0.04320473f, 0.04263067f, 0.07818722f, -0.03310929f, 0.07297603f, 0.00431736f, 0.00546768f, 0.02843825f, 
    0.29421270f, 0.26985964f, 0.22797181f, 0.26638430f, 0.05781644f, 0.08847414f, -0.07145790f, 0.15161259f, 
    -0.04053129f, 0.00894305f, -0.04632351f, 0.02782964f, 0.11157869f, -0.25763115f, -0.02301040f, 0.03413596f, 
    0.01393766f, -0.03836944f, 0.04466749f, 0.11589545f, -0.07649152f, 0.06538500f, 0.01926351f, 0.05769340f, 
    0.24153723f, -0.23117837f, -0.22652616f, 0.21881837f, 0.07327363f, 0.00490282f, -0.00225912f, 0.04128238f, 
    -0.03546425f, 0.08139747f, 0.09784637f, 0.08410510f, -0.09985650f, -0.16824372f, -0.04172374f, -0.03043140f, 
    -0.10655866f, -0.04400883f, -0.05624006f, -0.02861106f, 0.06387284f, 0.00994826f, 0.02594491f, -0.01579531f, 
    -0.03639009f, 0.28246102f, 0.12114250f, 0.10101577f, -0.10553011f, 0.06522966f, 0.09393357f, 0.09215833f, 
    -0.03420081f, -0.03291832f, -0.04612046f, -0.10565235f, -0.28509551f, -0.03873827f, -0.19165052f, -0.07513206f, 
    -0.04962078f, -0.01798354f, -0.08975802f, 0.02457200f, -0.10544011f, 0.01023018f, 0.00495719f, -0.01341482f, 
    0.04713824f, 0.02641406f, 0.09710782f, 0.00211146f, -0.04181408f, 0.06767966f, 0.06118365f, 0.06223601f, 
    0.08292708f, 0.04348075f, 0.05571618f, 0.13200215f, -0.20740524f, -0.20107588f, -0.12102147f, -0.02338836f, 
    -0.00487022f, -0.03220740f, -0.00995705f, -0.07363793f, -0.15681441f, -0.08441271f, -0.02682139f, 0.00439617f, 
    0.30291542f, 0.19059055f, -0.08626572f, 0.27034622f, 0.11852627f, 0.00219576f, 0.10880832f, 0.09850159f, 
    0.01444043f, -0.00601354f, -0.07957169f, 0.03004090f, 0.28066036f, 0.26606339f, 0.19729544f, 0.35300767f, 
    -0.00323252f, 0.09086492f, 0.04779970f, 0.08577259f, -0.09478760f, -0.05708307f, 0.01639373f, -0.02491084f, 
    0.14272180f, -0.00305774f, -0.00153739f, 0.16935942f, 0.11980434f, 0.13903826f, -0.06543650f, -0.01914022f, 
    0.12925684f, 0.12096443f, 0.01665553f, -0.03312283f, 0.39462078f, 0.22655360f, 0.17659312f, 0.14528713f, 
    0.12860517f, 0.14426725f, -0.02458417f, -0.05588654f, -0.05643375f, 0.04398251f, -0.03252869f, 0.00279572f, 
    -0.02872419f, -0.29756218f, 0.07750954f, -0.20125923f, -0.04167277f, 0.01348998f, -0.01340185f, 0.02360605f, 
    -0.00478679f, -0.05239784f, -0.05453521f, 0.06191193f, -0.17049293f, 0.07098362f, -0.01834791f, -0.03805138f, 
    0.02252573f, -0.00835206f, 0.00332958f, -0.02219982f, -0.09290592f, 0.10062660f, 0.14399152f, 0.12304058f, 
    0.04879691f, 0.30725655f, 0.04936762f, 0.11813541f, -0.01212666f, 0.00363305f, 0.11540188f, -0.03450847f, 
    -0.03257017f, -0.09246494f, -0.02516875f, 0.05404066f, 0.31151539f, 0.28279662f, 0.18157582f, 0.12811005f, 
    -0.05160717f, -0.00969296f, -0.03350711f, -0.07059588f, -0.00779988f, -0.09222810f, -0.05250796f, 0.03967109f, 
    0.09818926f, -0.08652763f, 0.00338316f, 0.06985201f, 0.01881618f, 0.00788528f, 0.00662292f, -0.08448700f, 
    -0.02696042f, 0.00410190f, -0.02014424f, 0.03004758f, 0.45802593f, -0.03244411f, 0.05958438f, -0.03226891f, 
    0.14386344f, 0.12833950f, 0.03801937f, 0.08911927f, -0.04811614f, 0.11177696f, -0.04574922f, -0.03347005f, 
    0.03497455f, -0.17785907f, -0.11204961f, -0.05546913f, -0.00516598f, -0.06101381f, -0.04315686f, -0.02609738f, 
    -0.06591067f, -0.03327793f, -0.05408175f, -0.09205268f, 0.23130691f, 0.10074624f, 0.14842580f, 0.23023881f, 
    0.14218847f, 0.08195709f, -0.05708635f, 0.00342071f, 0.04588044f, -0.04213805f, 0.02848592f, -0.02474829f, 
    -0.02061696f, 0.00233704f, -0.02913245f, 0.01127089f, -0.11051486f, 0.12328142f, 0.12533200f, 0.03017427f, 
    -0.05181832f, 0.04016164f, 0.00743848f, 0.10979212f, 0.01460043f, 0.24152344f, 0.23436181f, 0.07856306f, 
    0.04659490f, 0.04504253f, 0.06747017f, -0.09107181f, 0.04543308f, -0.07056441f, -0.02105190f, -0.08549538f, 
    0.31959122f, 0.16542356f, 0.14155680f, 0.21480536f, 0.04155751f, -0.19476384f, -0.13213046f, 0.12952571f, 
    -0.02687265f, -0.04318793f, 0.01343286f, 0.02213258f, 0.06101473f, -0.31862327f, 0.25972670f, 0.00893677f, 
    0.05720233f, 0.07141484f, -0.04135863f, 0.05823743f, 0.04283489f, 0.01536637f, 0.02372365f, 0.00859966f, 
    -0.07149041f, -0.25102890f, 0.01751072f, -0.07860234f, -0.06311195f, 0.01119982f, -0.00737189f, -0.02726661f, 
    -0.06982389f, -0.00814589f, 0.04381444f, 0.07940327f, -0.02011914f, -0.08744489f, 0.07724194f, -0.03362851f, 
    -0.06278280f, 0.11727639f, -0.08506177f, 0.08744573f, 0.01332587f, -0.00996012f, -0.03037949f, -0.02146313f, 
    -0.48954502f, 0.24568857f, 0.36247474f, -0.20046622f, 0.07890578f, -0.06801490f, 0.04169204f, 0.02235241f, 
    -0.03868436f, 0.04306089f, 0.02362269f, 0.05835288f, 0.14982070f, 0.07370440f, 0.11345765f, 0.11730018f, 
    0.08439790f, 0.01576519f, -0.02692716f, 0.11305016f, 0.05495306f, 0.07509769f, -0.01941891f, -0.00110869f, 
    0.14066811f, 0.00547667f, -0.08119361f, 0.23637694f, -0.00362874f, 0.00965110f, -0.05510436f, -0.04618739f, 
    -0.09036067f, -0.05467066f, 0.06289408f, -0.02896688f, -0.07880652f, -0.13709143f, -0.07994333f, -0.06130466f, 
    -0.05768460f, -0.05331483f, 0.00388953f, -0.01532994f, 0.03248965f, 0.03710592f, 0.01257327f, -0.00271421f, 
    -0.03820011f, -0.00045064f, 0.02652841f, -0.02796203f, -0.00833515f, -0.03815806f, -0.00499092f, 0.00456978f, 
    0.02122919f, 0.02609766f, -0.02763525f, -0.02792190f, 0.01099947f, 0.00030796f, 0.00812443f, -0.01554602f, 
    -0.01516060f, -0.03601589f, 0.02498803f, 0.02244363f, -0.03927160f, 0.01967216f, -0.03101700f, 0.00361068f, 
    -0.03091319f, 0.00789592f, -0.03159913f, 0.00147217f, -0.03500334f, -0.04180767f, 0.00909820f, -0.00997006f, 
    0.02648232f, 0.02007004f, -0.01635704f, -0.00181296f, -0.00742506f, -0.02822733f, -0.02962424f, 0.04166629f, 
    -0.02970534f, -0.02312700f, -0.01380012f, -0.03099916f, -0.03289614f, -0.03663411f, 0.03715724f, -0.03709009f, 
    -0.01643826f, -0.01403972f, 0.02409366f, -0.02917457f, 0.01475403f, 0.01652895f, 0.00955596f, 0.00455909f, 
    -0.00740993f, -0.03439190f, -0.01593165f, -0.02207806f, -0.02462600f, -0.00412703f, 0.02695780f, 0.01291891f, 
    0.00261953f, -0.03765040f, -0.02481802f, 0.00680409f, 0.00506815f, -0.01611740f, -0.01853186f, 0.03343637f, 
    0.00716838f, -0.00537432f, 0.02240384f, 0.03595327f, 0.00449414f, -0.03183709f, 0.00748102f, -0.03969749f, 
    0.02594114f, 0.02215921f, -0.01567191f, 0.00510724f, -0.01605359f, 0.02357820f, 0.01763211f, -0.03131058f, 
    0.02137630f, -0.00999511f, 0.00678242f, -0.03918440f, 0.01052273f, 0.00168708f, -0.03697264f, -0.03855915f, 
    0.00792212f, 0.03229846f, -0.02709040f, 0.00713318f, -0.02793888f, -0.02883092f, -0.01662556f, -0.03279020f, 
    0.02647244f, 0.02489783f, -0.00002816f, 0.02576139f, 0.02393391f, -0.00101012f, 0.02416737f, -0.01894740f, 
    -0.01417609f, -0.00213354f, -0.01962884f, -0.01369851f, 0.01050292f, 0.00391014f, 0.01462190f, -0.01572619f, 
    0.01148430f, -0.03216843f, -0.00685841f, -0.01054301f, -0.00223486f, 0.02354661f, -0.02616979f, 0.03967676f, 
    0.02331469f, -0.01305114f, -0.00173510f, -0.02927061f, -0.03955703f, -0.02735682f, -0.03672846f, 0.00883054f, 
    -0.00022652f, -0.02385920f, -0.04099656f, -0.03586840f, 0.00193454f, 0.02585846f, -0.01739278f, -0.01899481f, 
    0.00402997f, 0.01577991f, -0.03347144f, 0.00402297f, 0.01795676f, 0.00235624f, 0.02950595f, -0.00672657f, 
    -0.02272370f, 0.01569143f, -0.00251478f, 0.02919442f, -0.03885454f, 0.02054337f, -0.04206590f, -0.00533907f, 
    -0.01774697f, -0.02756455f, 0.01802046f, -0.00854776f, 0.01506991f, 0.02770926f, 0.00461747f, -0.04169990f, 
    -0.01833367f, 0.01725601f, 0.00871077f, 0.01896415f, -0.02043658f, -0.04042736f, -0.00931111f, 0.02907035f, 
    -0.01690164f, 0.01758835f, 0.01937912f, 0.00753772f, -0.01649049f, 0.02252419f, -0.03392571f, 0.02947582f, 
    0.01932775f, -0.02143657f, 0.02023791f, 0.01771525f, -0.00661014f, -0.03600467f, -0.01155514f, 0.00332815f, 
    -0.00131981f, -0.00196283f, 0.00160635f, 0.01067478f, -0.02284869f, 0.00629543f, -0.00242187f, -0.00189748f, 
    0.00934860f, 0.00911114f, -0.00961146f, 0.02444222f, -0.02032968f, 0.02258038f, 0.01796341f, -0.01908173f, 
    0.00875651f, 0.02175153f, 0.01836689f, -0.03839145f, -0.03040057f, -0.03338045f, -0.02642313f, -0.01707668f, 
    -0.03087312f, -0.00069760f, -0.02086512f, -0.01034953f, -0.03781765f, -0.04108569f, 0.01728669f, 0.00317608f, 
    0.01233740f, -0.02266713f, -0.03308805f, 0.01123361f, -0.01870091f, -0.02412812f, -0.03211114f, -0.01858415f, 
    0.00609461f, -0.00320334f, -0.02986407f, -0.02403589f, 0.02656001f, 0.01580044f, 0.01269997f, -0.03081430f, 
    -0.03131002f, 0.01629738f, 0.02675526f, 0.02451481f, 0.02142285f, -0.02195903f, -0.00054687f, 0.01067450f, 
    0.01151542f, -0.01730269f, -0.01180035f, 0.00201548f, 0.01431698f, 0.02895821f, -0.00648785f, 0.02291235f, 
    -0.02484442f, -0.01711636f, -0.02836517f, 0.02293857f, -0.00090251f, 0.00967100f, -0.01233197f, -0.00672642f, 
    -0.02513381f, 0.02262177f, -0.02965905f, 0.00867531f, -0.00792857f, 0.00147517f, -0.01145264f, 0.01401509f, 
    -0.00058749f, 0.00209277f, 0.02242095f, -0.02493200f, -0.04039077f, -0.02885883f, 0.01127892f, -0.00456496f, 
    0.00710296f, -0.00440060f, -0.01889356f, 0.02592185f, -0.03135523f, 0.00565393f, 0.02095357f, 0.03192048f, 
    -0.00869854f, 0.00358725f, 0.01506475f, -0.00138888f, -0.03575996f, -0.01551052f, -0.02552479f, 0.01550131f, 
    -0.00457579f, -0.03987297f, -0.03072147f, -0.00868819f, -0.02888958f, -0.01445981f, -0.02762401f, 0.02889374f, 
    0.02936229f, -0.03447708f, 0.01964694f, -0.02309431f, 0.02181434f, -0.02066362f, -0.00400956f, 0.02850916f, 
    0.01096825f, 0.00077301f, -0.01164580f, 0.02158413f, -0.01479681f, -0.03853759f, -0.03256396f, 0.02355003f, 
    -0.03969837f, 0.02634885f, 0.02777870f, -0.02275347f, -0.01117179f, -0.04039618f, -0.02537245f, -0.01528498f, 
    -0.01069243f, 0.01585574f, 0.01456034f, -0.03482017f, -0.00113571f, 0.00287605f, -0.00497754f, -0.02761784f, 
    -0.04133601f, 0.01402419f, 0.01857135f, -0.01302949f, -0.00538878f, 0.00753481f, 0.01114014f, -0.03710829f, 
    0.02054819f, -0.01672937f, -0.03441970f, -0.02563272f, -0.01026462f, -0.01069020f, -0.03007416f, -0.03699287f, 
    -0.00261026f, 0.01942459f, -0.01096932f, -0.01951387f, 0.01810690f, 0.00570729f, -0.00738235f, -0.00992110f, 
    -0.00160144f, 0.02622793f, -0.01534221f, -0.02156301f, 0.00085597f, -0.00594510f, 0.00026360f, 0.02272399f, 
    0.01227900f, -0.03602474f, -0.03426927f, 0.01562387f, 0.02398942f, -0.03357141f, -0.01902005f, 0.00405669f, 
    -0.03426227f, -0.01001890f, -0.03800834f, 0.00959090f, -0.03181897f, 0.01816952f, 0.00124795f, -0.03025247f, 
    0.01153588f, 0.02956572f, -0.01559382f, -0.01856808f, -0.04168094f, -0.03167433f, 0.02084903f, -0.00889637f, 
    -0.01667567f, 0.00145930f, -0.01112701f, -0.02215409f, -0.01751989f, -0.00107329f, -0.01875515f, 0.01851375f, 
    0.01662529f, 0.00578440f, -0.02023223f, 0.01029671f, -0.02788140f, -0.02721017f, -0.02831947f, -0.00085220f, 
    -0.03907575f, 0.01477175f, 0.00868016f, -0.01654209f, -0.03590968f, 0.03991761f, 0.00163814f, 0.01963199f, 
    0.02345739f, -0.01016184f, 0.01024858f, -0.03751408f, 0.01962981f, 0.00569663f, -0.03402644f, 0.01947397f, 
    -0.04196531f, -0.04147203f, -0.01071953f, -0.02781643f, 0.01978559f, -0.02411587f, 0.03202156f, 0.02421326f, 
    -0.02383956f, 0.01471320f, -0.03983904f, 0.00735167f, 0.00673323f, -0.00258731f, 0.02871712f, -0.00065205f, 
    -0.01985472f, 0.02811012f, 0.00654780f, -0.03937524f, -0.01198645f, -0.02868379f, 0.01796112f, -0.02593284f, 
    -0.03020185f, 0.01334820f, 0.00119594f, -0.00524169f, 0.01977155f, 0.01366393f, 0.00205262f, -0.00319436f, 
    0.02664345f, -0.00005374f, 0.00711077f, 0.01823172f, 0.01537118f, 0.00357786f, 0.00321438f, 0.00249644f, 
    -0.03286142f, -0.00881283f, -0.01761414f, -0.01224669f, -0.03597057f, 0.01487982f, -0.00617124f, -0.00357592f, 
    -0.03047192f, 0.02217715f, 0.02925480f, 0.00234137f, 0.02338568f, -0.03027773f, -0.03028926f, 0.02994580f, 
    -0.03784972f, -0.02188151f, -0.03970177f, 0.00373647f, 0.01988018f, -0.00153257f, 0.02648300f, 0.02739896f, 
    -0.02388144f, -0.01737242f, 0.01749021f, 0.02940498f, 0.00614574f, -0.00844489f, -0.00076502f, 0.01097162f, 
    -0.02123146f, 0.00535903f, 0.01281822f, 0.03976433f, -0.03524148f, 0.01590030f, -0.00463263f, -0.02830610f, 
    -0.01348145f, -0.02133449f, 0.00842146f, -0.01681701f, -0.00228201f, 0.00666039f, -0.03463687f, 0.03825431f, 
    -0.03272466f, -0.00485074f, 0.02013901f, 0.02832254f, 0.00526729f, 0.01648169f, -0.01060137f, -0.01326222f, 
    0.02582301f, 0.02520649f, -0.00350461f, -0.00458720f, -0.01720299f, 0.02278101f, 0.02719453f, -0.00806297f, 
    0.02816905f, -0.03522224f, -0.01841404f, 0.00076142f, -0.01241815f, 0.00250843f, -0.01245882f, -0.03999862f, 
    -0.02485593f, -0.02914254f, -0.03087047f, -0.03869271f, 0.00435054f, 0.02712065f, -0.03577247f, -0.01470891f, 
    0.01895705f, 0.01607230f, -0.00260117f, -0.02951176f, -0.02600882f, -0.02452366f, 0.02875862f, -0.03737058f, 
    -0.00357133f, -0.02511227f, -0.00396758f, -0.00293127f, 0.02543864f, 0.00131705f, -0.02500088f, -0.01525311f, 
    -0.00190069f, -0.00650554f, -0.03365133f, -0.02173623f, 0.01843093f, -0.03082251f, -0.00388655f, 0.01534247f, 
    -0.02714060f, 0.03741704f, -0.01972006f, 0.00863292f, -0.03911840f, 0.00489905f, -0.01980403f, 0.00017847f, 
    -0.02054065f, 0.03291568f, 0.02449975f, -0.02269036f, -0.02977719f, -0.00360094f, -0.01328102f, -0.01213824f, 
    -0.02108462f, -0.04095440f, 0.01108131f, -0.00652297f, -0.00032134f, 0.00144199f, -0.02795237f, 0.02175134f, 
    0.02300667f, -0.02207948f, 0.02356997f, -0.02948659f, 0.02532329f, -0.02093188f, -0.01958734f, -0.03919296f, 
    -0.03634587f, -0.03130839f, 0.02267785f, -0.03731626f, 0.01835417f, 0.02222493f, 0.02930714f, -0.01762126f, 
    0.00180901f, 0.01610452f, 0.00192946f, -0.00806949f, 0.02096206f, -0.00080134f, 0.03891612f, -0.02971384f, 
    -0.00013104f, -0.02099203f, -0.00967535f, -0.01037516f, 0.02853295f, 0.03001426f, -0.00401837f, 0.00399407f, 
    -0.02566497f, -0.01460336f, -0.01319010f, -0.00050198f, -0.02646983f, -0.00479699f, -0.03342854f, -0.00961232f, 
    -0.02285845f, -0.03879074f, -0.02678560f, -0.02223057f, -0.03960562f, 0.00925594f, -0.02041123f, 0.01150629f, 
    -0.02668319f, -0.01368631f, -0.03172938f, -0.01350878f, 0.01682826f, -0.00561107f, 0.00268355f, 0.01931104f, 
    -0.03441915f, -0.04041758f, -0.03458285f, -0.03955529f, -0.02027503f, -0.02799578f, 0.01051392f, 0.03369481f, 
    0.02696848f, -0.01491658f, 0.02994057f, 0.00674938f, -0.01865163f, 0.01287400f, -0.01209889f, 0.01599079f, 
    0.00779619f, -0.00901117f, -0.03257208f, 0.00084539f, 0.00147419f, -0.02726680f, -0.00227413f, 0.02366878f, 
    -0.01921589f, -0.02965854f, 0.02705543f, 0.01168161f, 0.00437138f, 0.00667717f, -0.02540665f, 0.00874648f, 
    0.02795909f, -0.00427103f, 0.00489027f, -0.01719288f, 0.01543654f, -0.03366195f, -0.03326341f, 0.01756573f, 
    -0.02239172f, -0.02774426f, 0.00487213f, 0.00771664f, 0.01708000f, -0.01295661f, -0.02639398f, -0.02564401f, 
    0.02385236f, -0.00665228f, 0.01311747f, -0.00857880f, 0.00300911f, -0.03963328f, 0.01230539f, 0.00145472f, 
    -0.03635208f, -0.00727407f, 0.01743990f, -0.04205398f, 0.00501625f, -0.02756615f, -0.01965002f, 0.01244565f, 
    0.01643040f, -0.03657651f, -0.00719634f, 0.02650832f, 0.00088298f, -0.01005714f, -0.03133683f, 0.00653683f, 
    0.00009642f, 0.02942794f, 0.01512454f, -0.04084240f, 0.01456342f, -0.03092178f, -0.00027953f, -0.00701478f, 
    -0.00201073f, 0.00511675f, -0.03421234f, -0.03184544f, 0.01086428f, -0.02368185f, -0.02826623f, -0.00034553f, 
    -0.02491802f, -0.01804917f, -0.02390341f, -0.01968182f, -0.00408918f, -0.01328404f, -0.01665530f, 0.00091841f, 
    -0.02449843f, 0.00237363f, 0.00480942f, 0.00476248f, -0.01837164f, 0.00080013f, 0.00083507f, 0.02465941f, 
    0.00431643f, 0.00712903f, -0.00381968f, -0.00985214f, -0.01175721f, 0.02179974f, -0.01597599f, -0.00434912f, 
    -0.01878461f, -0.01905582f, 0.00334277f, 0.00207398f, -0.00397893f, -0.02813834f, -0.01907312f, 0.03837890f, 
    -0.03741283f, 0.00700313f, 0.02759301f, -0.00935558f, 0.00966042f, 0.01089116f, -0.00265376f, 0.00080566f, 
    -0.00148280f, -0.01063836f, -0.03194047f, -0.02945675f, 0.02399613f, -0.02918903f, -0.04143677f, -0.03848223f, 
    0.01582773f, -0.03317990f, -0.00101286f, -0.03792057f, 0.03015177f, 0.01728615f, -0.03265864f, -0.03633597f, 
    -0.00440297f, -0.00447121f, -0.03139236f, -0.03663107f, -0.04015928f, 0.02708328f, -0.01338218f, -0.00138248f, 
    -0.02697594f, 0.01347482f, -0.01001698f, -0.00771159f, -0.00335379f, -0.02463344f, 0.00887744f, -0.03346351f, 
    -0.04088043f, -0.02788614f, -0.01039592f, 0.01870750f, -0.03601707f, 0.02044392f, 0.02979923f, -0.01094038f, 
    0.00517224f, 0.00484319f, 0.02865978f, -0.00030179f, -0.00616697f, 0.01960837f, -0.00763147f, -0.00778691f, 
    -0.00481685f, -0.03407860f, 0.00273731f, 0.01142479f, -0.03585013f, 0.01095780f, -0.03988046f, -0.04154873f, 
    -0.03550946f, 0.02144136f, 0.01763991f, -0.01090567f, 0.01581843f, -0.03444098f, 0.02717420f, -0.02443595f, 
    -0.01371938f, -0.01294672f, -0.00161401f, -0.03618047f, -0.02235461f, 0.02567937f, -0.01167443f, -0.04046966f, 
    0.00922420f, 0.02647475f, -0.01898930f, -0.03660573f, -0.01167310f, 0.00937870f, -0.01053434f, -0.00417071f, 
    -0.00153983f, -0.03043661f, -0.01582574f, -0.03929998f, 0.01820198f, -0.01560494f, 0.02489181f, 0.00482666f, 
    0.02350293f, -0.03879669f, -0.02493416f, 0.01604465f, 0.01298335f, -0.00381959f, 0.00645106f, -0.03694841f, 
    0.01645176f, -0.01536801f, 0.02409913f, 0.01690078f, 0.01511821f, -0.00359267f, -0.03691944f, -0.04034012f, 
    0.01659646f, -0.03225687f, 0.00600943f, -0.00564646f, -0.01440240f, 0.00416737f, 0.00639957f, -0.03155145f, 
    0.00912785f, -0.04073342f, -0.02663196f, 0.02269210f, 0.01067060f, -0.00339135f, -0.03620381f, 0.02553393f, 
    -0.03065518f, 0.00798734f, 0.01476850f, 0.02878105f, -0.02622750f, -0.03681722f, -0.01458317f, 0.02715786f, 
    0.01104204f, -0.03718043f, 0.00666967f, -0.00137273f, -0.02503768f, 0.02785216f, 0.00442923f, -0.03798503f, 
    -0.02339697f, -0.02159539f, -0.00266069f, 0.00904518f, -0.02655276f, -0.03596082f, -0.02548929f, -0.00992019f, 
    -0.00992418f, -0.03919119f, -0.03954061f, -0.02649924f, 0.01205724f, -0.00363398f, -0.03521105f, 0.02555423f, 
    0.01671203f, -0.01184074f, -0.01448236f, 0.02075708f, -0.02050512f, -0.01633034f, 0.02164930f, 0.01254803f, 
    0.01541885f, 0.00671505f, -0.00057653f, -0.03609802f, 0.01722239f, 0.00677222f, 0.01042161f, 0.00809639f, 
    -0.00209927f, -0.03349382f, 0.00231458f, -0.01264747f, -0.00428620f, 0.02632436f, -0.02742075f, -0.01702085f, 
    0.01980339f, 0.02703861f, 0.02618346f, -0.00748564f, 0.00708854f, -0.00644651f, 0.00185363f, -0.01335035f, 
    0.02592707f, 0.01857261f, -0.03412689f, -0.03091516f, 0.00489178f, 0.02552188f, 0.02952052f, -0.02860606f, 
    -0.00343529f, 0.00683754f, -0.01894674f, -0.00422184f, -0.02240975f, 0.00879444f, -0.00634404f, -0.03867750f, 
    -0.00085876f, -0.03469509f, -0.03436863f, 0.02851402f, -0.01982363f, 0.01891685f, 0.02299199f, -0.03445150f, 
    0.01598402f, -0.00170554f, -0.00384596f, 0.01878483f, -0.03436119f, 0.02750649f, -0.02443755f, -0.00492210f, 
    -0.02596164f, 0.01144591f, -0.03745488f, 0.03186037f, -0.01431947f, -0.01304281f, -0.01947017f, 0.00106636f, 
    0.02375541f, 0.02922400f, 0.00543378f, -0.03591276f, -0.03762878f, 0.01842437f, -0.01781934f, 0.00781670f, 
    -0.00237648f, 0.01083634f, 0.02809087f, -0.02812886f, 0.02252353f, -0.02421630f, -0.03617271f, 0.00224766f, 
    -0.02297873f, 0.02316712f, 0.01696554f, 0.02583298f, 0.01828775f, -0.00047194f, 0.01880523f, -0.00802411f, 
    -0.00500802f, 0.02251434f, -0.00484244f, 0.01552893f, -0.00749045f, -0.01470069f, -0.00550880f, -0.00099710f, 
    -0.01306875f, -0.02721704f, -0.00055229f, -0.01920401f, -0.00307977f, -0.02215544f, -0.03219642f, 0.02362205f, 
    -0.00849629f, 0.00841032f, 0.00855171f, -0.04063140f, -0.03816293f, 0.01895814f, -0.01445629f, 0.01999885f, 
    -0.00044293f, -0.01508763f, -0.03011288f, -0.01260015f, 0.02033928f, -0.02129302f, 0.02905445f, -0.00041778f, 
    -0.03829262f, -0.01577255f, -0.00929648f, 0.01566323f, 0.00155800f, -0.01550477f, -0.00823104f, -0.01697755f, 
    -0.00703306f, -0.03483918f, 0.00166348f, -0.03447581f, 0.02964097f, 0.02860701f, -0.04001237f, -0.03693952f, 
    0.01636357f, -0.01179059f, 0.01633445f, 0.00691988f, -0.03662103f, -0.03546028f, -0.03835878f, -0.00847861f, 
    -0.02623981f, -0.01782928f, -0.01555774f, 0.01515200f, -0.02515685f, 0.02296763f, -0.03832176f, 0.02346862f, 
    -0.03448475f, -0.00183168f, -0.02242394f, -0.00752219f, 0.02461864f, -0.03241528f, -0.01968251f, -0.00826462f, 
    -0.00484652f, -0.00808490f, -0.01701507f, -0.02848843f, 0.02448013f, 0.00473030f, 0.01524905f, -0.00596213f, 
    0.01541333f, 0.01491329f, -0.01315052f, -0.00161142f, -0.03562703f, -0.00309135f, -0.02836662f, -0.01245974f, 
    0.01666294f, 0.00728711f, 0.01811893f, 0.00526577f, -0.02863078f, -0.03502751f, -0.01821819f, 0.01094123f, 
    -0.03326002f, 0.01347133f, -0.03747109f, -0.01597784f, -0.01338552f, -0.03336201f, -0.01428604f, -0.01660410f, 
    -0.02008115f, -0.00636908f, -0.00340583f, -0.01219313f, -0.03796077f, -0.02978316f, -0.02287661f, -0.00634809f, 
    -0.04061105f, -0.01467899f, -0.02421862f, -0.04075350f, 0.02829812f, -0.01327603f, -0.00899627f, -0.00351149f, 
    0.02277142f, -0.00186230f, -0.01279342f, -0.03162681f, 0.02136099f, 0.02377636f, -0.01305982f, -0.03385218f, 
    0.02122264f, 0.01315721f, -0.00418340f, -0.00690165f, -0.02562430f, 0.01648778f, -0.02956093f, 0.02417879f, 
    0.02251016f, -0.02814955f, 0.00515030f, -0.02464747f, 0.01035774f, -0.00694127f, -0.03196480f, 0.00111520f, 
    -0.03930018f, 0.02669212f, 0.01138852f, -0.00578726f, -0.01233220f, 0.02724269f, -0.00340174f, -0.02822132f, 
    0.02375179f, 0.02000688f, 0.00228797f, -0.00715645f, -0.01100063f, 0.03283324f, 0.02746026f, -0.03728296f, 
    -0.02206133f, -0.00996886f, -0.03171005f, -0.02228718f, 0.00236332f, -0.03490880f, 0.01669817f, 0.00545561f, 
    -0.03456793f, 0.01897156f, -0.03106541f, -0.01027554f, 0.02900694f, -0.03750430f, -0.03935404f, 0.02727134f, 
    0.00550907f, 0.00650369f, -0.01726600f, -0.02610017f, -0.01161562f, -0.02833994f, 0.01177874f, -0.01013779f, 
    0.00102655f, 0.01680488f, 0.02095509f, -0.01780398f, -0.02378582f, -0.01835955f, -0.00635121f, -0.04019101f, 
    -0.01929528f, -0.02614752f, 0.02079248f, 0.00504509f, -0.03884649f, 0.00699761f, 0.01625124f, 0.00048523f, 
    -0.01799363f, 0.01694099f, 0.01947449f, 0.02806273f, -0.03714250f, 0.00521497f, 0.00628003f, 0.01983315f, 
    -0.02654164f, 0.01129274f, -0.01479960f, 0.02247517f, -0.02187010f, -0.00675419f, -0.00705514f, 0.00777567f, 
    -0.01669978f, -0.03620587f, -0.01271901f, -0.00180613f, -0.01169594f, 0.01027639f, 0.00551534f, 0.01070521f, 
    0.01417663f, -0.03193450f, 0.00978255f, -0.01981593f, -0.03225520f, 0.01517638f, 0.01517423f, 0.01520852f, 
    -0.03170716f, -0.02294606f, 0.01632589f, -0.01447346f, -0.01713174f, -0.02868666f, -0.02000907f, -0.02309049f, 
    -0.01241455f, 0.00555479f, -0.02047513f, 0.01144059f, -0.02931939f, 0.01780947f, 0.02468964f, 0.02763748f, 
    0.00264244f, -0.01646315f, -0.01519467f, -0.02014110f, -0.00919382f, -0.03617004f, -0.01303923f, -0.01117602f, 
    -0.01055996f, 0.02168899f, 0.01203397f, -0.03085124f, -0.02370921f, 0.02444203f, 0.01493559f, -0.02415711f, 
    -0.02831523f, -0.01520577f, -0.00487121f, -0.03257772f, 0.02848951f, 0.01788669f, 0.00305335f, -0.03051838f, 
    0.01869619f, -0.03907189f, 0.01047673f, -0.00194728f, -0.00177778f, -0.00557180f, -0.02214952f, -0.02132551f, 
    -0.02149582f, 0.00232486f, 0.00280627f, -0.03104133f, -0.02234118f, -0.00530909f, 0.02286614f, 0.02995434f, 
    -0.01955149f, 0.00242123f, 0.01068110f, -0.02578971f, -0.01616256f, 0.01702588f, -0.00308250f, -0.02383915f, 
    -0.02153066f, -0.02999871f, 0.00896735f, -0.03885023f, -0.01895795f, 0.02601741f, -0.00476619f, -0.01058731f, 
    0.02998247f, 0.00012656f, -0.00481594f, -0.03637677f, -0.03458185f, -0.01516366f, -0.02133075f, -0.01673795f, 
    0.02446149f, -0.00690083f, 0.02091068f, 0.01941702f, 0.02062838f, -0.02056880f, -0.04053681f, -0.01265941f, 
    0.00181640f, -0.00019223f, -0.00724212f, -0.00727452f, -0.00833040f, 0.01847849f, 0.01081832f, 0.01543840f, 
    -0.01969200f, 0.02297796f, -0.03457647f, -0.01823437f, -0.02700437f, -0.04105972f, 0.03096821f, -0.03241336f, 
    0.00012395f, -0.00578338f, 0.01881984f, -0.04128798f, 0.02743535f, 0.00295223f, -0.02234285f, 0.01298630f, 
    0.01049290f, 0.00247555f, -0.03853079f, -0.00200573f, -0.02172616f, -0.04111431f, 0.02988923f, -0.01242638f, 
    0.02378463f, -0.00934018f, 0.01578499f, 0.00882500f, -0.04100860f, 0.01599164f, 0.04018342f, -0.02159796f, 
    -0.02573265f, 0.02547060f, 0.01036853f, 0.02216756f, 0.01066934f, -0.01737341f, 0.01604437f, -0.00886359f, 
    -0.03899619f, -0.01245845f, 0.01529868f, 0.02763881f, -0.01033058f, -0.01053041f, 0.01270743f, 0.02345810f, 
    0.00122701f, -0.02580423f, -0.02104457f, -0.01273733f, -0.03674489f, -0.01955977f, 0.00395526f, 0.00699696f, 
    0.02328179f, -0.03848112f, -0.02553858f, -0.04202928f, 0.01413229f, -0.00809467f, -0.03915360f, -0.01287082f, 
    -0.02305602f, -0.01546110f, -0.03252205f, 0.02855317f, -0.00040497f, 0.01506068f, 0.01518776f, -0.03363188f, 
    0.03495463f, -0.01415299f, 0.00668223f, 0.03771210f, -0.03164949f, -0.02492282f, 0.01089035f, -0.01746821f, 
    0.02373537f, 0.02491705f, 0.02942905f, -0.00082219f, -0.03444619f, 0.01379582f, 0.00448669f, -0.02117428f, 
    -0.01064307f, 0.02948426f, -0.02438658f, -0.01583533f, 0.02944620f, -0.03364813f, -0.01664496f, 0.01605202f, 
    0.00858015f, 0.01179982f, 0.02730177f, 0.01035683f, -0.02093202f, -0.00440347f, -0.03863977f, 0.02534097f, 
    -0.00737899f, -0.01200276f, -0.01083785f, -0.00773704f, 0.00406913f, 0.02779767f, 0.01686347f, -0.02120541f, 
    -0.02763500f, -0.00638451f, -0.04091175f, -0.02370376f, -0.04004936f, -0.00385592f, -0.00301231f, -0.00150831f, 
    0.02999994f, 0.00848620f, 0.02599231f, -0.03001578f, -0.01330818f, 0.00492314f, -0.01544789f, -0.03311741f, 
    -0.03482118f, 0.02049432f, -0.00973965f, -0.02312642f, 0.01641494f, -0.00678033f, 0.00566816f, -0.01134403f, 
    0.00111058f, 0.01865401f, -0.01618470f, -0.02618276f, -0.03529553f, -0.01950209f, -0.01917331f, 0.00760932f, 
    -0.02187402f, 0.01346337f, -0.01838837f, 0.02133392f, -0.01066827f, 0.00482314f, -0.03786778f, -0.02523155f, 
    0.02514962f, -0.01030194f, -0.02714026f, -0.01596395f, 0.00657408f, -0.02641455f, -0.02569509f, 0.01820144f, 
    0.00303620f, 0.01901361f, 0.01176615f, 0.01841152f, 0.01977946f, -0.01864367f, -0.00274502f, -0.04155930f, 
    -0.02179988f, 0.02051876f, -0.01935216f, 0.00762328f, 0.00678191f, 0.01845973f, -0.01525728f, 0.01590855f, 
    0.02314578f, -0.02411456f, -0.01793143f, 0.00300097f, 0.02552449f, 0.02741402f, -0.00617068f, -0.02658866f, 
    -0.20443077f, 0.13279870f, -0.27632615f, -0.06643893f, 0.14363208f, 0.10671160f, 0.02311515f, -0.14695294f, 
    -0.17600724f, 0.07005598f, -0.06221829f, -0.02674898f, -0.11875454f, -0.06095449f, 0.40025988f, 0.10675747f, 
    -0.09037274f, 0.02492329f, -0.05603614f, -0.10988275f, -0.03981339f, -0.04181863f, -0.07339611f, -0.08338244f, 
    0.04380189f, 0.09026364f, -0.08326285f, -0.06095579f, -0.12431508f, -0.05959118f, 0.03934636f, -0.03439438f, 
    0.11442818f, -0.04814331f, -0.06717751f, -0.07339492f, -0.16913031f, 0.28420797f, 0.19537564f, 0.29334688f, 
    0.09508865f, 0.00654739f, 0.23601478f, -0.00349152f, -0.05256877f, -0.04293046f, -0.02456038f, 0.01026276f, 
    -0.27887860f, -0.14116046f, -0.10390660f, 0.17549832f, 0.06342482f, 0.00691617f, 0.13123272f, 0.03834768f, 
    0.05650824f, 0.12266231f, -0.02918568f, 0.02365237f, 0.08651546f, -0.13675101f, 0.17482111f, 0.35637987f, 
    -0.03860798f, 0.03685876f, -0.09814383f, 0.08511535f, -0.04922502f, 0.00748772f, 0.15636806f, -0.05085148f, 
    -0.25046483f, 0.00577316f, 0.24722272f, -0.00866244f, -0.04951802f, -0.03273432f, -0.00655859f, 0.01747230f, 
    -0.14076035f, -0.05944207f, 0.11092155f, 0.01181023f, 0.10774425f, 0.13086331f, -0.22268270f, 0.03062980f, 
    0.21150492f, 0.03785562f, 0.04648505f, -0.03258515f, -0.10125154f, 0.02390821f, -0.07444941f, 0.06061723f, 
    0.33194870f, 0.18623948f, 0.00232628f, -0.09288906f, -0.12713543f, 0.14713116f, -0.02092608f, 0.03020785f, 
    0.03793317f, 0.02206020f, 0.10728004f, 0.11447886f, 0.20999479f, 0.18580563f, -0.14585048f, -0.22387213f, 
    0.17819721f, -0.16537927f, 0.00002932f, 0.01461129f, 0.10928129f, 0.03057661f, 0.14615110f, -0.05903029f, 
    0.17558697f, -0.04847247f, 0.28808832f, 0.15097873f, -0.04380887f, -0.02548352f, -0.10535622f, -0.02738849f, 
    -0.10235808f, -0.05428038f, 0.02182389f, -0.06193450f, 0.17692702f, 0.09805658f, -0.03477820f, 0.10578980f, 
    -0.04146071f, -0.05058040f, 0.13229130f, -0.19425985f, -0.00271155f, 0.02831031f, -0.03835305f, 0.00996355f, 
    -0.01499243f, 0.07231592f, 0.14835386f, 0.05845670f, -0.11823784f, -0.04083466f, -0.07729720f, -0.16715716f, 
    0.11611550f, 0.18176350f, 0.07787053f, 0.12317494f, 0.43339384f, -0.01264880f, 0.44841412f, -0.15787725f, 
    -0.07943849f, 0.00573617f, 0.05347456f, -0.04888500f, 0.08298410f, 0.07548212f, -0.07111152f, 0.06294925f, 
    -0.12395720f, -0.01952783f, 0.01649673f, 0.15956604f, -0.01130428f, -0.03688075f, 0.03800676f, 0.18667436f, 
    0.10996459f, -0.18782599f, 0.30315784f, 0.09773337f, -0.02305699f, 0.00575556f, 0.12910439f, 0.19655854f, 
    0.00675229f, 0.02391590f, -0.04185754f, -0.01401552f, -0.04723917f, 0.00990990f, -0.03007036f, -0.14504381f, 
    0.16034909f, 0.06916463f, 0.48227939f, -0.03512374f, -0.03966888f, 0.00868777f, -0.06502919f, -0.02316883f, 
    -0.00868604f, 0.01344508f, -0.04878889f, -0.04304623f, -0.02237876f, -0.04899779f, -0.13718964f, 0.07762259f, 
    0.12379511f, -0.08870292f, 0.03877468f, -0.11683577f, -0.15720284f, 0.10199265f, -0.10367063f, -0.02805586f, 
    0.33714941f, -0.14202769f, 0.14941965f, 0.17222595f, 0.01467654f, -0.01218824f, -0.08234319f, 0.01599208f, 
    -0.08525822f, 0.12816711f, -0.03725129f, -0.12862767f, 0.29956144f, -0.06018794f, 0.02119664f, -0.06235137f, 
    0.01925124f, 0.05598534f, -0.02267464f, -0.03110753f, -0.10848764f, 0.19367160f, 0.10128058f, 0.13899511f, 
    -0.04028620f, 0.04869536f, 0.08619422f, -0.05852328f, -0.12041453f, 0.00280849f, 0.06289788f, -0.01542694f, 
    -0.05351456f, -0.01507754f, -0.02972935f, -0.10370523f, -0.13661367f, 0.16519073f, 0.16502869f, 0.18633573f, 
    0.05874386f, 0.05096093f, 0.12877995f, -0.17445345f, -0.15049586f, -0.06094446f, 0.15845861f, 0.08483488f, 
    -0.12683967f, -0.02714176f, -0.08101445f, 0.01928872f, 0.06392159f, 0.01415636f, 0.03940101f, -0.04316553f, 
    0.06792131f, 0.13474301f, -0.04601955f, 0.11416674f, -0.08674838f, 0.12207831f, -0.07906602f, -0.17346400f, 
    -0.00080349f, 0.15325162f, 0.00416323f, 0.00269617f, -0.12338472f, 0.08387986f, -0.10409597f, -0.01346399f, 
    -0.08534195f, 0.10090886f, -0.07890755f, -0.03883806f, 0.01640975f, -0.00974707f, 0.01631065f, -0.06341557f, 
    -0.04029647f, 0.06144873f, -0.07270674f, 0.06438475f, -0.08351426f, -0.07247648f, -0.19908819f, 0.07199197f, 
    0.07458437f, 0.04160994f, -0.00306000f, 0.03728596f, -0.04941750f, 0.05398630f, -0.05991456f, -0.11308202f, 
    0.10607056f, 0.06308869f, -0.13050513f, 0.15652257f, -0.07160466f, -0.03784993f, 0.07708555f, 0.15308571f, 
    0.10270171f, 0.20908260f, -0.14905828f, 0.06274291f, 0.08082831f, 0.31506509f, 0.25525531f, 0.10763274f, 
    -0.18020223f, -0.02982914f, -0.00684180f, -0.01336122f, 0.05468554f, 0.14787360f, -0.05560454f, 0.16608207f, 
    -0.18422846f, 0.02084233f, -0.07231465f, -0.13230535f, -0.07405905f, -0.01058557f, -0.00502495f, 0.01369712f, 
    0.21180204f, 0.21962643f, 0.08659087f, 0.13326068f, -0.12259856f, 0.04812623f, 0.11141994f, 0.11785232f, 
    0.05104992f, -0.08379070f, -0.01648829f, -0.00163155f, -0.02436946f, 0.03505811f, 0.11168383f, -0.08743273f, 
    -0.08427481f, 0.27972952f, 0.03782265f, -0.00395313f, 0.15031587f, 0.06233289f, 0.04277825f, -0.08201621f, 
    -0.00296284f, 0.10409632f, 0.19315474f, 0.08323291f, -0.10680942f, 0.22602418f, -0.02911864f, 0.15519607f, 
    -0.13500229f, 0.02749050f, 0.02340385f, 0.00174437f, 0.06219922f, -0.03436944f, 0.05438978f, -0.04959556f, 
    0.05618809f, -0.11818272f, -0.08697365f, 0.07502338f, -0.04893439f, -0.10459966f, -0.00085803f, -0.05236040f, 
    -0.01211115f, 0.06266578f, 0.11044613f, -0.05361919f, 0.10880195f, 0.26772246f, -0.18052083f, 0.09597209f, 
    0.16572122f, 0.14002922f, 0.05632711f, -0.16664985f, -0.01268687f, -0.07673688f, 0.09543873f, 0.05899188f, 
    -0.04253658f, -0.09314371f, 0.07122304f, 0.08023692f, 0.03295121f, -0.18511496f, -0.11752099f, 0.10411052f, 
    -0.06385887f, 0.01029871f, -0.08773819f, -0.08319592f, -0.33138853f, 0.20807973f, 0.21174507f, 0.37927717f, 
    0.10411801f, -0.04491801f, 0.12098906f, 0.08718430f, -0.07368139f, 0.07442269f, -0.04117212f, 0.09504116f, 
    -0.29291639f, 0.15991586f, 0.22468677f, 0.27849257f, 0.11814146f, 0.01623554f, 0.00041756f, 0.03063400f, 
    -0.09906583f, 0.00383683f, -0.03938204f, 0.16529134f, -0.14746194f, -0.13379462f, -0.02547757f, -0.21103272f, 
    -0.12110060f, -0.12046338f, -0.02935285f, -0.00635693f, 0.10745449f, 0.31185541f, 0.12762366f, -0.10881892f, 
    -0.25675118f, -0.01108873f, -0.11355195f, 0.00759507f, -0.11306448f, 0.02113591f, 0.00366038f, 0.00383215f, 
    -0.00617244f, 0.01247291f, -0.05345939f, 0.10395028f, -0.05239440f, 0.23056605f, -0.15222056f, 0.19488156f, 
    -0.04110762f, -0.06376716f, 0.10238940f, 0.10012267f, -0.05312580f, 0.09388176f, -0.07832181f, 0.06856180f, 
    0.10661570f, -0.01359156f, 0.15267514f, -0.18895200f, 0.09255194f, 0.05165221f, 0.12584189f, -0.10934416f, 
    0.06478090f, -0.03771523f, 0.00874560f, 0.18285446f, 0.02947766f, 0.24934763f, -0.04821444f, -0.17462853f, 
    -0.06112915f, 0.00201417f, -0.05283430f, -0.05773863f, -0.09875789f, -0.05463864f, 0.01679169f, -0.01293352f, 
    -0.01514374f, -0.10689551f, -0.07845754f, 0.24421798f, -0.21942252f, 0.04139309f, 0.03870370f, 0.01786950f, 
    0.03276287f, 0.14572190f, -0.06473117f, -0.11371853f, -0.05156369f, -0.14163187f, -0.03362896f, 0.11862563f, 
    -0.09250400f, -0.02395701f, -0.05787302f, 0.05212172f, -0.00064549f, -0.00008656f, -0.00742542f, -0.02419299f, 
    -0.23048627f, -0.01911054f, 0.00403876f, 0.09229727f, -0.03314052f, -0.10149629f, 0.08733949f, -0.07976226f, 
    0.00508280f, 0.05534282f, -0.03926608f, 0.06695582f, 0.09447089f, -0.02582860f, 0.09593862f, 0.11049899f, 
    -0.06306368f, -0.10765212f, -0.09408424f, 0.02219169f, -0.03189640f, 0.05832440f, -0.04667826f, -0.03265718f, 
    0.24042682f, 0.03667501f, 0.28873003f, -0.21435975f, -0.07031120f, -0.09786254f, -0.01460271f, -0.08055416f, 
    -0.01282259f, -0.06059238f, 0.16824435f, 0.04410607f, -0.03935654f, 0.10291989f, -0.20164190f, -0.02561781f, 
    0.16491970f, 0.04203738f, -0.03797372f, 0.05590703f, -0.12731995f, 0.14435633f, 0.05457024f, -0.15047938f, 
    -0.29058275f, -0.04750273f, -0.23822218f, 0.14302656f, -0.05942635f, 0.04727493f, -0.06668155f, 0.03389694f, 
    -0.03442143f, -0.07941170f, -0.01057519f, 0.00087253f, -0.11039457f, 0.13023829f, -0.03691487f, 0.22612920f, 
    -0.01613675f, 0.10845718f, 0.07332738f, 0.07815483f, -0.00307341f, -0.00899687f, -0.00076109f, 0.08122323f, 
    0.04614636f, -0.02915822f, 0.02116683f, 0.05980549f, 0.00669628f, -0.06880786f, 0.03480333f, 0.04280338f, 
    0.00902966f, 0.00403053f, -0.04569396f, -0.15475285f, 0.76742095f, 0.16838072f, 0.01333799f, 0.09094293f, 
    0.09735207f, -0.08077044f, 0.07941795f, -0.09950902f, -0.01718423f, -0.00456580f, 0.02806988f, 0.04030579f, 
    -0.12142398f, 0.02860272f, 0.08205808f, 0.27960828f, 0.08312131f, 0.00353650f, -0.00961572f, -0.01784151f, 
    0.00486204f, 0.07755247f, -0.07498871f, 0.12996653f, -0.13206191f, -0.11966762f, 0.05359702f, 0.09424811f, 
    -0.03291644f, -0.03537185f, 0.01869901f, 0.12089516f, 0.06294861f, 0.12250537f, 0.04467725f, 0.01971071f, 
    -0.13606817f, 0.09294458f, -0.10334826f, 0.17535333f, -0.10592594f, 0.08692017f, 0.20593087f, 0.13704343f, 
    0.01389439f, -0.09694404f, -0.05285855f, 0.04142380f, -0.19744770f, 0.18255974f, -0.19854052f, 0.19305877f, 
    0.02551785f, 0.04508011f, -0.06391598f, -0.01671238f, -0.04979676f, 0.06051062f, 0.08368754f, -0.12695946f, 
    -0.16797429f, -0.32201862f, -0.13242508f, 0.04501706f, -0.11734649f, -0.10886389f, -0.04700015f, 0.04195128f, 
    0.00625721f, 0.10804615f, -0.05371618f, 0.01960579f, -0.09355999f, 0.12507065f, 0.16937855f, -0.00430358f, 
    0.03700122f, 0.00443177f, -0.01157157f, -0.00896242f, -0.06484634f, 0.06416170f, 0.06391522f, 0.10794108f, 
    -0.01714068f, 0.17263333f, 0.06956144f, -0.17215939f, -0.05326752f, 0.03702409f, -0.02792593f, 0.02188239f, 
    0.03782371f, 0.02117942f, -0.09462042f, 0.20273925f, -0.06746528f, 0.09498844f, 0.26846027f, -0.01989682f, 
    0.09283517f, -0.09954549f, -0.00130375f, -0.01492590f, -0.05013636f, -0.12019137f, -0.04495368f, 0.00578263f, 
    0.18869033f, 0.32511523f, -0.15838465f, -0.10644040f, 0.02996619f, -0.01692298f, -0.11338438f, 0.09989396f, 
    -0.08533353f, 0.02851535f, -0.05948550f, 0.10538960f, -0.03708964f, -0.03931240f, 0.04532771f, -0.02397691f, 
    0.02848171f, 0.02241382f, 0.14071099f, 0.11186381f, 0.09882627f, 0.11660480f, -0.05197660f, 0.21248612f, 
    0.16373615f, -0.11996455f, 0.06141030f, 0.18521768f, -0.07503889f, 0.02510306f, -0.03302379f, 0.09843628f, 
    -0.10449086f, 0.07004559f, 0.01593256f, -0.13976331f, -0.16298573f, -0.09772965f, -0.03212430f, -0.12460635f, 
    -0.04837131f, -0.03842941f, 0.04322273f, -0.07083738f, -0.00642449f, 0.05469051f, -0.04719144f, -0.03223659f, 
    0.38629225f, 0.10778653f, 0.07220808f, -0.17909519f, 0.01081050f, -0.02792937f, 0.08944518f, 0.12419187f, 
    0.04731565f, 0.02574912f, -0.01239100f, 0.11688434f, -0.09821044f, -0.21111414f, 0.07637177f, -0.33358654f, 
    0.11082855f, 0.01326396f, -0.15768941f, -0.10376357f, -0.00005447f, 0.07852554f, -0.02687328f, 0.13784876f, 
    0.02314071f, 0.14695698f, -0.00092061f, 0.12010399f, -0.06418197f, -0.09928071f, -0.06534223f, -0.00771371f, 
    -0.01731300f, -0.17709537f, 0.08267274f, -0.02927876f, 0.01682089f, 0.24333034f, 0.07007954f, 0.10983776f, 
    -0.02443150f, 0.17220671f, 0.00645971f, -0.12689790f, 0.01106731f, 0.05546520f, 0.04066822f, 0.02957278f, 
    0.02771769f, -0.12782224f, -0.25252220f, -0.13464510f, -0.07204364f, 0.00010927f, -0.06288283f, -0.01681033f, 
    0.07695594f, -0.05786025f, 0.06227684f, 0.05725079f, 0.19328292f, -0.09436333f, -0.31097865f, -0.09521811f, 
    -0.04553362f, -0.11708514f, 0.10162847f, 0.16290148f, 0.16314588f, 0.02188353f, -0.06950327f, 0.06672443f, 
    -0.04569839f, -0.12835009f, 0.08940688f, -0.02033787f, -0.03911990f, -0.01703963f, -0.00523582f, 0.00294909f, 
    -0.09731276f, -0.09444679f, 0.10585117f, 0.10625474f, 0.08997583f, -0.05402339f, -0.05548872f, -0.02543158f, 
    0.18855248f, 0.13362911f, 0.00909666f, 0.20043547f, 0.00631885f, -0.09394204f, -0.06047447f, 0.04652032f, 
    -0.09219866f, 0.13378809f, -0.16926946f, -0.10947821f, 0.03971887f, -0.01351956f, -0.09906465f, 0.09965613f, 
    -0.11080177f, 0.03372126f, 0.01324860f, -0.01833487f, -0.27242371f, 0.04124411f, -0.09670081f, -0.17734556f, 
    -0.09198169f, -0.01944896f, -0.01384140f, 0.02404705f, -0.05832839f, -0.01159167f, -0.10800888f, -0.00866914f, 
    -0.60622305f, 0.09782612f, 0.40088996f, -0.04815480f, -0.03297596f, -0.03198693f, -0.10319342f, 0.00441513f, 
    -0.05713173f, 0.07353115f, -0.01194770f, 0.07952932f, -0.05418431f, 0.16268484f, 0.37868229f, -0.44880888f, 
    0.14035343f, -0.00564722f, -0.12761390f, 0.06318598f, 0.04784738f, 0.13977438f, -0.09060956f, 0.08316135f, 
    -0.16872512f, -0.05705551f, 0.20566235f, -0.12313837f, 0.03590655f, -0.02595532f, -0.13009974f, -0.01096617f, 
    0.03303000f, 0.06759011f, 0.00698951f, 0.02787263f, -0.03739709f, 0.14069207f, -0.06572606f, -0.07180260f, 
    0.03106700f, -0.15760319f, -0.07690947f, 0.06926817f, -0.07109229f, 0.07053790f, 0.04425166f, -0.09418367f, 
    -0.02789411f, 0.07783887f, -0.10872826f, -0.05050231f, -0.06502344f, -0.07857898f, -0.02808548f, -0.06298395f, 
    -0.00642414f, -0.21779050f, 0.23179919f, -0.02956969f, 0.15936390f, 0.14350691f, -0.01156620f, 0.04273055f, 
    0.15331626f, 0.14393847f, 0.06552059f, -0.12492134f, 0.11819792f, 0.03013344f, -0.03372875f, 0.00183130f, 
    -0.20599127f, -0.11885333f, 0.02571447f, -0.09057867f, 0.05013674f, -0.03546963f, -0.04351721f, -0.15226051f, 
    -0.02122762f, 0.00720687f, -0.01217059f, 0.08442386f, 0.01772775f, 0.03042837f, 0.01555101f, -0.31623268f, 
    0.08412771f, -0.16788456f, -0.18309535f, 0.03354203f, 0.04203425f, 0.03776578f, 0.00862746f, -0.03739050f, 
    -0.08361959f, 0.01902398f, 0.01027369f, 0.00616967f, 0.02235108f, 0.11791291f, -0.03737382f, 0.03500227f, 
    -0.07062718f, 0.02028010f, -0.05988698f, 0.05172158f, 0.10803197f, -0.19559632f, 0.11384588f, 0.21656087f, 
    0.01810506f, 0.04369629f, -0.06158904f, -0.03361396f, 0.03409080f, 0.09107253f, -0.00428508f, -0.08508847f, 
    -0.03031319f, -0.04313041f, -0.04616248f, -0.02541181f, -0.05407578f, -0.09660991f, -0.10941473f, 0.01075502f, 
    -0.10309993f, -0.04663486f, 0.01574543f, 0.02210822f, 0.11215491f, -0.22980319f, -0.12320092f, -0.04820656f, 
    -0.01151688f, -0.02275436f, -0.08246394f, 0.09013966f, -0.04387397f, 0.02823463f, 0.02562822f, 0.04124639f, 
    0.14975296f, -0.14608528f, 0.02280007f, -0.14319038f, 0.02734228f, 0.08712887f, -0.08891295f, 0.10190649f, 
    0.09181633f, 0.05606613f, 0.05525932f, 0.06201355f, 0.12392731f, -0.04154010f, -0.06667744f, -0.02640091f, 
    0.10354069f, -0.00373946f, 0.00261993f, 0.07645809f, 0.00950356f, 0.09112515f, -0.04161208f, 0.08010961f, 
    -0.06754171f, 0.03391380f, -0.06156513f, 0.00982603f, -0.08990813f, -0.05453925f, 0.00631793f, 0.00570639f, 
    -0.04518848f, -0.05029016f, -0.03825514f, -0.01113769f, 0.02893603f, 0.08219490f, -0.19112471f, 0.09615853f, 
    -0.00200354f, 0.08251788f, 0.14666851f, -0.03177069f, -0.05352144f, -0.06067481f, 0.05233348f, 0.02838240f, 
    -0.25917867f, -0.07382153f, 0.01223573f, 0.01260218f, 0.05897260f, -0.07850602f, -0.00799718f, 0.15201660f, 
    0.03022945f, 0.20540646f, -0.05918930f, 0.08613844f, 0.23549747f, -0.17603950f, 0.13453615f, 0.01244651f, 
    -0.12485176f, -0.11549010f, -0.14630739f, -0.08131199f, -0.00113358f, 0.05838533f, 0.01860588f, -0.06198742f, 
    0.02060708f, -0.02007964f, -0.04445190f, 0.06549397f, -0.06597072f, -0.12088984f, -0.10713977f, 0.02213427f, 
    -0.11440984f, -0.13175443f, 0.12903769f, 0.01061445f, -0.18286863f, 0.00996552f, -0.20718415f, -0.34971794f, 
    -0.09546273f, -0.08538065f, -0.05374709f, -0.16002643f, 0.06306811f, 0.01155159f, 0.03143496f, -0.03558612f, 
    0.51469982f, 0.06059711f, 0.16412999f, -0.14895815f, 0.01024108f, -0.06283532f, -0.03884458f, 0.00891961f, 
    0.04367764f, 0.05810640f, -0.01171742f, 0.05991590f, 0.02842099f, 0.07368429f, -0.10977402f, -0.09410531f, 
    0.09479887f, 0.09842697f, 0.00056757f, 0.18587756f, 0.08644655f, 0.01020928f, -0.00578259f, 0.01768809f, 
    0.17694081f, 0.27284002f, 0.02900749f, 0.16755454f, 0.06604324f, 0.19518523f, 0.04937351f, -0.12453885f, 
    0.00506186f, -0.02817059f, -0.05479510f, -0.03827079f, -0.12763034f, 0.11185703f, 0.09437833f, -0.10861757f, 
    0.01077601f, 0.09677773f, 0.10223999f, -0.01740367f, 0.00021439f, 0.00979015f, 0.07443609f, -0.08211727f, 
    -0.09930956f, 0.05716122f, -0.16625780f, -0.00808846f, 0.04842028f, 0.12197474f, -0.03067503f, 0.00221589f, 
    -0.09285168f, -0.09010871f, 0.03651303f, -0.00662124f, 0.08197145f, 0.16724852f, -0.14534926f, -0.00428941f, 
    0.08551342f, -0.09735568f, 0.05579011f, 0.06566720f, 0.06170792f, 0.15003088f, 0.16446503f, 0.13635504f, 
    0.14954776f, 0.15510905f, 0.04190300f, 0.08889648f, 0.11983553f, 0.06048270f, -0.03591597f, 0.04909847f, 
    0.10289212f, 0.00054408f, 0.12320304f, -0.03049617f, -0.06497424f, 0.01919748f, 0.03150934f, -0.13902591f, 
    -0.06312910f, -0.05238070f, -0.13331677f, 0.00349149f, -0.10512246f, -0.07131767f, -0.05239508f, 0.01767844f, 
    -0.02352209f, 0.11430012f, -0.14788827f, -0.12535012f, -0.06363930f, 0.09388730f, 0.04411180f, -0.00681834f, 
    0.00474442f, -0.01090949f, -0.05469454f, -0.02613571f, -0.04552326f, 0.25645700f, -0.30816612f, 0.11063761f, 
    -0.04111134f, -0.12423383f, 0.01575847f, 0.05114171f, 0.08275694f, 0.14424370f, -0.04689996f, 0.03746584f, 
    0.02602804f, -0.18296300f, -0.01943940f, 0.05021527f, -0.06208009f, 0.12828766f, -0.12212862f, 0.06814811f, 
    0.07801932f, -0.08998192f, 0.04858791f, 0.12092661f, 0.24087609f, -0.04012298f, -0.12220372f, 0.15858950f, 
    -0.15392342f, -0.10248491f, -0.02635355f, 0.02518373f, -0.18037848f, -0.05276742f, 0.05478710f, -0.05376681f, 
    -0.02716000f, -0.04189593f, -0.29034081f, -0.05026091f, 0.12835884f, -0.10496718f, 0.05900389f, -0.09411542f, 
    -0.00266185f, 0.07339878f, 0.01594944f, 0.05298166f, 0.01747496f, -0.01410367f, -0.09524312f, -0.04646885f, 
    0.07910968f, 0.18627355f, 0.13035242f, -0.14160617f, -0.09098082f, -0.09560616f, -0.04687279f, -0.04785123f, 
    0.10955787f, 0.07526480f, -0.08840908f, 0.15746602f, -0.04983284f, 0.24378167f, 0.12444548f, -0.06797723f, 
    0.08956698f, 0.03962899f, 0.06657141f, 0.07470666f, 0.05967511f, 0.20840161f, 0.11587702f, 0.01831439f, 
    0.07366389f, 0.23329176f, -0.01969908f, 0.06390234f, -0.12675714f, -0.04213126f, 0.00705684f, -0.00576691f, 
    0.09425270f, -0.09822563f, 0.09525523f, -0.14107180f, 0.01612789f, -0.03748211f, -0.09854490f, 0.02497413f, 
    0.00466792f, -0.08964738f, -0.11239661f, -0.00494124f, -0.06690040f, -0.02808013f, -0.03685438f, 0.15042765f, 
    -0.04543234f, -0.08902896f, 0.04436653f, 0.11309807f, -0.03989811f, 0.14581487f, 0.06506101f, 0.06029483f, 
    0.28183866f, 0.39961728f, -0.31073672f, -0.12314668f, 0.10740378f, -0.06474737f, 0.14252938f, 0.01604228f, 
    0.02719345f, -0.05400828f, 0.04929053f, -0.01334688f, 0.30333179f, -0.03358285f, 0.31160578f, 0.00561551f, 
    0.00181569f, 0.09301885f, 0.03549078f, -0.10628472f, 0.11564472f, -0.02819278f, 0.02385905f, -0.02028373f, 
    -0.14141050f, -0.10757283f, -0.02504875f, -0.00705736f, -0.10254601f, -0.12329964f, -0.01492159f, -0.19441646f, 
    -0.00830219f, -0.10593687f, 0.04602357f, -0.03076523f, 0.20503262f, 0.26497895f, 0.04078151f, 0.28602335f, 
    -0.09102185f, 0.16867593f, 0.04123743f, 0.04945102f, 0.08458372f, 0.05184213f, -0.01268086f, -0.03279790f, 
    0.11876772f, -0.06108012f, 0.02905678f, -0.10360281f, 0.05983321f, 0.09676710f, -0.03154407f, 0.01994396f, 
    0.04889788f, 0.11898318f, 0.01140876f, 0.19454041f, 0.17847988f, 0.00833315f, 0.11012066f, -0.07472581f, 
    0.11566143f, 0.10679778f, 0.06737789f, -0.09416229f, -0.03362906f, -0.04575584f, 0.06836381f, 0.04726478f, 
    -0.18503304f, -0.01994942f, -0.12328390f, -0.05254588f, 0.02065644f, 0.10892403f, -0.09666382f, -0.07852338f, 
    0.09707857f, 0.10263046f, 0.21881171f, 0.03120042f, 0.12231607f, 0.14238374f, -0.04062452f, -0.15423211f, 
    0.02636356f, -0.07050916f, 0.18993247f, -0.08637724f, 0.07696126f, -0.05206235f, 0.04686455f, -0.07029586f, 
    0.03010362f, -0.09942692f, -0.14385679f, -0.31049272f, 0.10856792f, -0.04029298f, -0.10777701f, -0.14262839f, 
    -0.08644510f, -0.05638205f, -0.00049678f, 0.07946055f, 0.12597746f, 0.23233420f, -0.17173769f, 0.21789749f, 
    0.00418183f, 0.09798061f, -0.07593156f, -0.00292819f, 0.04053970f, -0.03954288f, -0.10890674f, 0.05035508f, 
    0.14743559f, 0.02398987f, -0.04669938f, 0.05663616f, -0.16638030f, -0.12314279f, -0.03922581f, -0.00946773f, 
    -0.05677516f, 0.03901459f, -0.09348104f, 0.02696983f, -0.12896910f, 0.18073921f, -0.02413104f, -0.17411254f, 
    -0.06398627f, -0.03896035f, 0.00738815f, -0.06076998f, -0.03783718f, 0.01722986f, 0.08013030f, 0.02898447f, 
    -0.27902082f, 0.20028971f, -0.22110593f, -0.08573987f, -0.17240091f, -0.09149465f, 0.12466155f, -0.03552642f, 
    -0.04701233f, 0.13121516f, -0.02742287f, 0.15834124f, 0.06523319f, -0.20207904f, 0.06627304f, 0.09035801f, 
    0.14902052f, 0.15385236f, -0.00569423f, -0.04589355f, 0.06909390f, 0.09181385f, 0.01807287f, -0.01661935f, 
    0.14483130f, -0.13416535f, -0.05592251f, 0.04043742f, -0.09153689f, -0.08929144f, 0.04129946f, 0.03170226f, 
    -0.01096520f, 0.09105523f, -0.12942806f, -0.03203646f, -0.06989925f, -0.06136899f, 0.02415663f, 0.02832896f, 
    -0.10508879f, -0.10490286f, -0.00257436f, -0.08623315f, 0.03298261f, 0.09133843f, 0.02154428f, -0.05214021f, 
    -0.11988202f, 0.12356023f, 0.13180394f, -0.22569609f, 0.18349087f, -0.05013864f, 0.00161486f, 0.19767947f, 
    -0.04299016f, 0.10778709f, 0.04665734f, -0.03091910f, -0.03627053f, -0.06173902f, 0.14257875f, 0.29114869f, 
    0.07388341f, 0.07686476f, 0.12430415f, -0.00025698f, -0.06120924f, -0.03508361f, -0.03744831f, -0.03492976f, 
    0.01999561f, -0.00822170f, -0.05534374f, -0.08499245f, -0.00515683f, -0.09354599f, 0.00326955f, 0.10568957f, 
    -0.13161524f, 0.06828653f, -0.04143269f, 0.04585801f, -0.43144453f, 0.16738804f, -0.00869092f, 0.37504205f, 
    0.02467172f, 0.03610602f, 0.05129561f, 0.08846295f, 0.05049471f, -0.05079613f, -0.00278457f, 0.10084276f, 
    -0.16853485f, -0.37441289f, 0.00818388f, 0.23627442f, 0.20531142f, 0.05881781f, 0.02642644f, 0.02604752f, 
    -0.02230525f, 0.04446136f, -0.06887563f, -0.19602910f, -0.26169017f, 0.35743630f, 0.34761259f, 0.09151988f, 
    -0.09240781f, -0.03691861f, -0.02421840f, -0.12502916f, 0.03553604f, -0.07062520f, 0.15120800f, -0.13141108f, 
    -0.20744461f, 0.08103077f, -0.10239524f, -0.15568119f, 0.05066981f, 0.05753332f, -0.09073056f, -0.06305023f, 
    0.07153935f, -0.10029788f, 0.08693755f, -0.07816224f, 0.24513392f, 0.05627383f, 0.00275121f, 0.17273013f, 
    -0.00420818f, -0.04390208f, 0.08616363f, 0.00033997f, 0.10806566f, 0.08475245f, 0.11425494f, -0.00502539f, 
    -0.00445909f, -0.20190117f, 0.08906323f, 0.24557492f, -0.10241106f, 0.08034845f, -0.02199313f, -0.03525102f, 
    0.06091525f, -0.02485467f, 0.01878028f, 0.15525252f, 0.50539511f, 0.03272393f, -0.01703631f, 0.29817629f, 
    0.11938862f, -0.01335921f, 0.04053417f, 0.07697649f, -0.00557293f, 0.00469421f, 0.17918976f, 0.01813426f, 
    0.34122142f, -0.33096918f, -0.00238346f, -0.05075681f, -0.14511631f, -0.03687778f, -0.00814259f, 0.23016158f, 
    -0.00203170f, -0.01755612f, 0.04026213f, -0.04992431f, 0.37346646f, -0.09644381f, -0.03445497f, 0.23386498f, 
    -0.02536677f, 0.03154317f, 0.05846164f, 0.11025517f, -0.11871482f, 0.06061235f, -0.03820454f, -0.04044027f, 
    0.03592221f, 0.00899695f, -0.02939265f, 0.11101379f, 0.02383595f, -0.03808460f, -0.05879492f, 0.06734495f, 
    0.18248042f, 0.14695987f, 0.07008028f, 0.02742113f, 0.36526445f, 0.05025198f, 0.22808911f, -0.01861262f, 
    -0.08419810f, 0.13659532f, -0.13442248f, -0.04172458f, 0.13686553f, -0.01033109f, 0.13256195f, 0.13602579f, 
    -0.05745419f, 0.16828607f, 0.03019155f, -0.19511156f, 0.00982154f, -0.06436528f, -0.10461015f, -0.02626007f, 
    0.06136277f, 0.20486563f, 0.21710454f, -0.11796688f, -0.19228104f, 0.05729644f, 0.07535583f, 0.02970758f, 
    -0.02390739f, -0.06169545f, -0.01313287f, 0.07249401f, -0.17772566f, -0.10022537f, 0.01653266f, 0.09542941f, 
    -0.46249646f, -0.19871239f, 0.26717475f, 0.12725554f, -0.03062044f, -0.01114924f, -0.08046942f, 0.06541824f, 
    0.03339600f, -0.03761740f, 0.07633103f, -0.04205439f, 0.08656016f, -0.02395961f, 0.04319739f, 0.22234391f, 
    0.09276970f, 0.02204407f, 0.05287369f, -0.03856416f, 0.02718598f, 0.12682460f, -0.09979158f, -0.16073269f, 
    0.44047853f, 0.23249348f, 0.21466890f, 0.23942079f, -0.09914066f, -0.11960358f, 0.14287062f, 0.07580541f, 
    0.10782268f, -0.07736320f, 0.02106761f, -0.06035127f, 0.25577024f, -0.03032346f, -0.05264755f, 0.01643546f, 
    -0.07209466f, 0.00333061f, 0.18670179f, 0.22968835f, 0.09412547f, -0.07212113f, 0.05886308f, 0.14222510f, 
    -0.11936497f, -0.09612110f, -0.06793159f, -0.11826465f, 0.00597800f, -0.16107048f, -0.09094995f, 0.00160732f, 
    0.00564232f, -0.12535030f, -0.06769393f, -0.02435371f, -0.13702334f, 0.01133147f, 0.25736839f, -0.10088114f, 
    0.24732150f, 0.01278692f, 0.10897329f, 0.03656038f, 0.08357473f, 0.14048739f, 0.10952543f, 0.00936195f, 
    0.00000282f, -0.05976870f, -0.02389903f, 0.23069619f, 0.09672558f, 0.05164348f, 0.05093158f, 0.00975089f, 
    0.10474070f, 0.01755620f, -0.03076874f, 0.01953332f, -0.05473690f, 0.07225704f, -0.08813073f, 0.06443302f, 
    -0.05807866f, -0.10975391f, 0.10241856f, -0.03747437f, -0.06572554f, -0.14834511f, -0.04169694f, -0.03842673f, 
    -0.05167860f, -0.08390362f, -0.14386521f, -0.25369221f, 0.01123758f, -0.02317841f, 0.09176110f, 0.11387267f, 
    -0.00958385f, -0.07797587f, 0.02269558f, 0.00870365f, 0.15820386f, -0.18109423f, -0.13056135f, -0.09426288f, 
    0.05375610f, 0.05241174f, -0.09133274f, 0.11979461f, 0.03235584f, 0.04399101f, -0.14231518f, -0.13894941f, 
    0.23292437f, -0.01817081f, -0.09561823f, -0.24416041f, -0.01604035f, 0.04036126f, 0.12527059f, 0.01471783f, 
    0.05058572f, -0.03032620f, 0.06665697f, 0.03440715f, -0.28711790f, 0.27574241f, -0.06352578f, 0.14353654f, 
    -0.04426772f, 0.03143403f, 0.07156011f, -0.02576907f, 0.11228855f, 0.12241432f, -0.05298468f, 0.05968124f, 
    -0.05688695f, -0.00294416f, -0.12881815f, -0.23735008f, -0.06333233f, 0.01646082f, -0.04614592f, -0.01143959f, 
    0.18010731f, 0.08161128f, 0.01607744f, -0.02193661f, -0.02624568f, -0.27683091f, 0.17467423f, 0.55323786f, 
    0.20210811f, 0.08665707f, -0.11863206f, -0.06506704f, -0.03372218f, -0.00358129f, -0.06963083f, 0.00905176f, 
    -0.15765378f, 0.03173860f, 0.13366586f, -0.17849004f, -0.07576093f, 0.08089611f, 0.06058948f, 0.05269598f, 
    -0.00910081f, 0.02026350f, 0.03858733f, 0.09882736f, -0.05315448f, 0.19641049f, 0.05910059f, 0.06588209f, 
    0.06233276f, 0.07366843f, 0.04418109f, -0.00070091f, -0.01786473f, 0.15021582f, -0.00019880f, 0.07300274f, 
    -0.16899519f, -0.28711390f, -0.07075293f, 0.05572475f, -0.00714070f, -0.06566547f, -0.02086025f, 0.07615339f, 
    -0.01687423f, -0.04414812f, 0.02221080f, 0.03524819f, 0.25413990f, -0.09280796f, -0.16060551f, -0.17547657f, 
    -0.13262680f, 0.10457098f, -0.05355779f, 0.08867647f, -0.05124084f, 0.05089200f, 0.14220890f, 0.05207542f, 
    -0.10579097f, -0.20210512f, -0.04074337f, 0.06422675f, -0.04022304f, 0.01237735f, 0.11677971f, -0.14210488f, 
    0.03265404f, 0.05455350f, 0.00125599f, -0.00016504f, -0.20941944f, 0.34090340f, 0.01029803f, 0.46130660f, 
    0.10109598f, 0.10857882f, 0.11510155f, 0.02504095f, 0.10287833f, -0.02480666f, 0.02801109f, 0.05165210f, 
    -0.39556167f, 0.27148432f, 0.19716878f, 0.25873500f, -0.02799930f, 0.00524528f, 0.02148237f, 0.04935740f, 
    0.10098357f, -0.04908852f, 0.04535599f, 0.10822774f, -0.21252830f, -0.07973190f, -0.07332960f, -0.23522547f, 
    -0.17454988f, -0.06149700f, -0.14902677f, -0.01994765f, 0.13045421f, 0.04107989f, 0.14320797f, 0.02737841f, 
    0.05210314f, -0.04868140f, -0.07433853f, 0.05605855f, 0.02462347f, 0.05794359f, -0.04644530f, -0.04847088f, 
    -0.00814955f, 0.04386054f, -0.00427379f, 0.11014853f, 0.08517510f, 0.04353687f, 0.09521376f, -0.26666766f, 
    -0.14905421f, 0.06463574f, -0.00370324f, -0.02227104f, 0.05145295f, -0.01827023f, 0.01393709f, 0.18199238f, 
    0.15764576f, -0.28227508f, 0.00163438f, 0.05288282f, -0.05436763f, 0.19680126f, 0.04945661f, -0.07590842f, 
    0.06078115f, 0.12490242f, 0.00001336f, -0.11835904f, 0.01631042f, 0.03321528f, -0.22173618f, -0.30006400f, 
    0.03568578f, -0.02943519f, -0.03135361f, 0.10051603f, -0.00403657f, 0.01158720f, 0.07064334f, 0.09347867f, 
    -0.18140459f, 0.00955747f, 0.22597803f, 0.03829489f, -0.14176999f, 0.01921546f, -0.17778555f, -0.00560983f, 
    -0.03707575f, -0.05553908f, 0.02600965f, -0.04432624f, -0.10828497f, -0.11510901f, 0.00242002f, 0.09558196f, 
    0.12714404f, 0.07092415f, -0.02997917f, -0.06496813f, 0.06022001f, 0.01918623f, -0.08832755f, 0.01647200f, 
    -0.07985301f, -0.02113914f, 0.03796711f, 0.01733502f, -0.02627815f, 0.08529933f, 0.15231842f, 0.10398404f, 
    0.02363033f, -0.03045401f, -0.13405399f, -0.02746403f, -0.06279658f, -0.23305893f, -0.05040778f, 0.05739552f, 
    -0.02230291f, -0.10174605f, 0.08448107f, -0.02861730f, 0.02593796f, 0.01204737f, -0.06081858f, -0.02347092f, 
    -0.01291301f, -0.00592796f, -0.06355805f, -0.07545644f, -0.07511151f, -0.02689399f, -0.08509329f, -0.12987286f, 
    -0.01133860f, -0.05832388f, 0.13308997f, -0.08916823f, 0.15909266f, 0.00800570f, -0.03435284f, -0.26706710f, 
    -0.02412483f, -0.03431750f, -0.03433137f, 0.04916020f, 0.00815785f, -0.00511896f, -0.04332452f, -0.00345856f, 
    -0.22875908f, 0.04291866f, -0.04312810f, 0.26770341f, 0.05386146f, 0.05420514f, -0.05119538f, 0.01426416f, 
    -0.11985434f, 0.04257312f, -0.05817154f, -0.04520656f, -0.28957385f, 0.16267948f, -0.20467409f, 0.10443793f, 
    -0.06092631f, 0.07713285f, 0.04346100f, -0.00598038f, -0.05557293f, -0.01298539f, 0.01434464f, 0.07265626f, 
    -0.21787786f, -0.03159969f, 0.07162680f, 0.01907091f, -0.02101399f, -0.00425699f, -0.12833430f, -0.00092483f, 
    0.02240561f, -0.07125553f, 0.04617292f, -0.01602575f, 0.37508991f, 0.06868820f, 0.08127372f, 0.27687353f, 
    0.04809459f, -0.03170624f, 0.06999382f, 0.25667289f, -0.07454085f, 0.01443377f, 0.11976930f, 0.03193587f, 
    -0.34143764f, -0.02094500f, 0.06213502f, 0.20317157f, 0.02981334f, 0.05529822f, 0.00454780f, 0.10056871f, 
    0.06408160f, -0.02877030f, 0.01347077f, 0.04970134f, -0.21806993f, -0.15326326f, -0.11295497f, 0.02247651f, 
    -0.06733382f, -0.03747128f, 0.01302908f, -0.07203973f, -0.03696842f, 0.02509158f, -0.03275464f, 0.00792532f, 
    -0.11149980f, 0.02856573f, 0.02972101f, -0.09336187f, -0.00308228f, -0.01018034f, 0.12385194f, 0.06561049f, 
    0.00501907f, -0.05612336f, 0.03315274f, -0.04673320f, 0.05763382f, 0.09945567f, -0.13213120f, 0.22083676f, 
    -0.05172668f, 0.03427947f, -0.00612893f, 0.07175682f, -0.08262281f, 0.04025794f, -0.05147054f, 0.16708526f, 
    -0.19550999f, -0.22155885f, -0.01596827f, 0.23198096f, 0.06311472f, 0.27415541f, 0.22049318f, -0.05277925f, 
    0.02966645f, -0.07296078f, -0.15824495f, -0.08104034f, 0.41747823f, 0.34874254f, -0.37574431f, 0.54704952f, 
    -0.08587532f, 0.07550143f, 0.00286423f, 0.26450622f, 0.04796705f, 0.07461132f, 0.00378650f, 0.03842165f, 
    -0.06440328f, 0.02677428f, -0.18898094f, 0.07092127f, -0.07021686f, -0.02225609f, 0.09124810f, -0.06307174f, 
    -0.03096143f, -0.01339855f, -0.13204090f, 0.07622594f, -0.06381007f, 0.08764983f, 0.14598079f, 0.40614492f, 
    0.10203911f, 0.04156426f, 0.12966159f, -0.18517250f, 0.02885766f, -0.01740651f, -0.06774997f, -0.00279501f, 
    0.86669117f, 0.09450860f, -0.31876320f, 0.22324128f, -0.06698794f, 0.03790143f, 0.01926515f, 0.05681139f, 
    -0.05282902f, -0.09437712f, -0.01992847f, 0.00388543f, -0.02455269f, -0.13753647f, -0.09081876f, 0.06997993f, 
    0.00125917f, 0.03254756f, 0.06834500f, -0.04163086f, 0.04411747f, -0.02085207f, -0.07379569f, 0.04235776f, 
    -0.08658999f, 0.18128826f, 0.01527368f, 0.10435151f, -0.04832148f, -0.11159298f, -0.03334551f, 0.06875411f, 
    -0.04309556f, 0.05774964f, 0.11801585f, -0.00258177f, -0.06003508f, -0.13400215f, -0.11433717f, -0.21282782f, 
    0.03532656f, 0.00787523f, 0.02146658f, 0.17826161f, -0.12077381f, -0.12489896f, -0.13091853f, 0.00024995f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00891548f, 0.16779880f, 0.02146975f, -0.00976211f, -0.00273590f, 0.18032497f, -0.02162367f, -0.02745055f, 
    0.17456554f, 0.10401992f, -0.02653166f, 0.00452650f, -0.02683474f, 0.00122340f, -0.03399510f, 0.01607095f, 
    -0.02621521f, 0.03313657f, 0.05659294f, 0.07769844f, 0.01451115f, 0.13789497f, 0.02102604f, 0.19515942f, 
    -0.00684578f, -0.05675919f, -0.02330592f, 0.00997622f, -0.00025353f, -0.00799733f, 0.06724861f, -0.00743184f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.63093179f, -0.22226188f, 0.13229616f, -0.02385535f, 0.16964659f, -0.30368239f, 0.15886576f, 0.06115630f, 
    -0.35061577f, -0.00099264f, -0.16024399f, -0.01950010f, 0.15293281f, 0.15407266f, 0.16036180f, 0.09078015f, 
    0.10539811f, -0.20118748f, 0.22378495f, 0.11305235f, -0.00445868f, -0.34778300f, -0.14179911f, -0.43260768f, 
    -0.07554889f, -0.07314786f, 0.16580445f, 0.07738201f, 0.04363445f, -0.26277041f, 0.30130529f, -0.37237826f, 
    0.09320589f, 0.31053704f, -0.60711533f, -0.14062604f, 0.04299783f, 0.21339728f, 0.05804336f, 0.11308993f, 
    0.30953595f, -0.18119363f, 0.16735570f, -0.17236388f, 0.01390691f, -0.10993478f, 0.12946948f, -0.21181597f, 
    0.20978671f, 0.22421083f, 0.10518135f, -0.17501651f, -0.13565820f, 0.05812730f, -0.10656786f, 0.20599838f, 
    -0.04152480f, -0.06557734f, 0.17060687f, 0.14958517f, 0.02303576f, -0.17538463f, 0.36121964f, -0.72602999f, 
    -0.15165934f, 0.25169194f, -0.04580415f, 0.16183920f, -0.28889811f, 0.18434058f, -0.03714037f, 0.12819745f, 
    -0.25209597f, 0.05770124f, -0.04103222f, -0.10719456f, -0.20416726f, -0.01327829f, 0.03798521f, -0.19619673f, 
    -0.06782043f, 0.34343213f, 0.22492403f, 0.27329457f, -0.22226551f, -0.19976498f, -0.13462345f, 0.16514827f, 
    -0.11276962f, 0.14886577f, -0.68600464f, 0.13147174f, -0.03465236f, 0.23310363f, 0.46759391f, 0.32903406f, 
    0.18209851f, -0.02195554f, -0.05675247f, 0.01347142f, -0.06103834f, -0.56895483f, -0.01245472f, -0.09653223f, 
    -0.36776459f, 0.16546433f, 0.15210837f, 0.13355133f, 0.02693325f, 0.05573466f, 0.07903603f, -0.22621545f, 
    0.17324595f, -0.31720763f, -0.21081828f, 0.07359371f, -0.12301779f, 0.07648242f, -0.19055910f, -0.29325742f, 
    0.08138005f, 0.37083736f, 0.18654220f, -0.11204261f, 0.02896238f, 0.32537723f, -0.04222824f, 0.34705052f, 
    0.20759387f, -0.53170162f, 0.26561883f, 0.14973027f, 0.22311638f, -0.15940545f, 0.08209196f, 0.14895239f, 
    0.28171873f, 0.09303624f, -0.15286073f, 0.00416755f, 0.17524980f, -0.04757716f, -0.13499813f, -0.23943156f, 
    -0.09156295f, 0.46696851f, 0.11953998f, 0.10078488f, -0.02158296f, -0.43359718f, 0.14085168f, -0.07137872f, 
    0.00839954f, 0.07857278f, 0.00289882f, -0.15526290f, -0.12064582f, -0.04604905f, -0.34953398f, 0.16751604f, 
    -0.11832897f, 0.10535705f, 0.05621984f, 0.00784859f, 0.27175981f, 0.09816618f, -0.13727880f, -0.14417547f, 
    -0.20395115f, 0.17442074f, 0.14894177f, 0.07488731f, 0.09092116f, 0.12084387f, -0.12029306f, -0.08050919f, 
    -0.30291912f, -0.41131693f, 0.06958602f, 0.21376424f, 0.20072880f, 0.14600000f, 0.09177770f, 0.07158844f, 
    0.12142590f, -0.27525875f, -0.05743526f, 0.14052470f, 0.01523951f, -0.70000005f, -0.25366813f, 0.05649756f, 
    0.27302608f, -0.31055501f, 0.41814983f, -0.17961910f, -0.61690193f, 0.35820651f, -0.04202847f, 0.07170482f, 
    0.06327521f, -0.25682449f, 0.00513874f, -0.03663587f, -0.28883916f, 0.04356644f, 0.07351119f, -0.01622522f, 
    0.06396198f, -0.11491556f, -0.24632101f, -0.66136801f, -0.18642920f, -0.10109953f, 0.05733987f, 0.22483550f, 
    0.09456421f, -0.31523517f, -0.39395922f, -0.04249308f, 0.02149466f, 0.01296750f, 0.01569926f, 0.40840778f, 
    0.02248004f, -0.16108650f, -0.36001140f, 0.02818424f, 0.24993929f, -0.19712871f, -0.09641535f, -0.18805371f, 
    0.01032317f, -0.32323426f, 0.14870617f, 0.03203014f, -0.18724363f, -0.06267554f, -0.02692342f, 0.27031055f, 
    0.26640218f, -0.23482740f, -0.26309201f, -0.24733166f, -0.20595796f, 0.01106306f, 0.02150710f, -0.15460037f, 
    -0.07913253f, 0.55720806f, -0.43421984f, -0.08055391f, -0.15927310f, -0.19633035f, -0.32115683f, 0.31416729f, 
    -0.20568836f, 0.20109740f, -0.22435945f, -0.13408205f, 0.19158876f, -0.29586765f, -0.15368032f, -0.14442351f, 
    -0.15073545f, 0.35744891f, -0.02339622f, 0.12301553f, -0.35167393f, -0.06788554f, 0.02520685f, 0.02631182f, 
    -0.25906906f, -0.38220868f, -0.30143064f, -0.56482559f, 0.36752948f, 0.25872108f, -0.02374908f, 0.32384899f, 
    -0.06027757f, -0.43925419f, -0.23603140f, -0.03405320f, 0.02136424f, 0.11566379f, -0.06118607f, 0.25192600f, 
    0.01100234f, 0.13855293f, 0.50692064f, -0.15558760f, 0.07105984f, 0.11193937f, -0.05200249f, 0.08354343f, 
    -0.24091333f, 0.24970391f, 0.16891618f, -0.05903678f, -0.50416827f, 0.01100049f, -0.04168375f, 0.07961458f, 
    0.20614180f, 0.24336466f, -0.16545562f, 0.19675997f, -0.50018388f, 0.18009742f, -0.09192339f, -0.33033407f, 
    -0.14611864f, -0.23357259f, -0.27027914f, -0.16431244f, 0.11429542f, 0.04531261f, -0.57200837f, -0.39665899f, 
    -0.32709891f, 0.24707027f, -0.44771802f, 0.15039855f, -0.48004168f, 0.05509225f, -0.03676753f, -0.03258449f, 
    -0.17657807f, 0.04432625f, 0.03691358f, -0.16872343f, 0.34689045f, 0.14405531f, -0.07559316f, 0.05241737f, 
    -0.52939659f, 0.30117145f, -0.04635353f, -0.41776043f, -0.12139437f, 0.25439465f, 0.04071155f, -0.10733504f, 
    -0.01226189f, 0.05582136f, 0.00499849f, 0.10802962f, 0.14260824f, 0.30139577f, -0.32669905f, 0.11636516f, 
    0.35824654f, -0.13513024f, -0.37450624f, -0.15511817f, -0.31249028f, 0.11659040f, -0.10137602f, -0.10224450f, 
    -0.12987034f, -0.45510054f, -0.09488135f, -0.14803115f, 0.15418455f, 0.02378879f, -0.10845806f, -0.21352801f, 
    0.16486835f, -0.22346056f, -0.09524497f, 0.34050748f, 0.45287421f, -0.09273050f, 0.10088142f, 0.02194727f, 
    0.10510071f, -0.09592850f, -0.21132366f, 0.06935001f, -0.07928114f, 0.42845657f, -0.56651366f, -0.01350407f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03990759f, -0.08630691f, 0.13755037f, -0.17156693f, -0.10360975f, 0.15133609f, -0.00765544f, 0.03805895f, 
    -0.08841442f, -0.15269843f, 0.06427576f, 0.07197442f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
