#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.02329576f, -1.17400432f, -1.26198530f, 0.01366029f, -0.44788364f, 0.59669542f, -0.21798533f, -0.01322755f, 
    -0.07208771f, 1.69675016f, 0.49104866f, 0.72198522f, 0.75452155f, 0.50129032f, -0.34563932f, 0.02857110f, 
    0.49998263f, -0.04718957f, -0.38757461f, -0.57942891f, 1.19653940f, 1.14682710f, -1.29803658f, -0.22000472f, 
    -0.24141057f, -0.39927992f, -0.03603959f, 0.55211800f, 0.48502740f, -0.57258821f, -0.71469820f, -1.14107049f, 
    -0.84219569f, 0.14500771f, -0.25276351f, -0.10343481f, -0.41376284f, -1.04550672f, -0.97462261f, -0.37917638f, 
    1.11746490f, 0.53591627f, 1.00687313f, -0.40025270f, 0.27930433f, 1.51346886f, 0.64442927f, 0.54079890f, 
    -0.43103322f, -0.69963515f, 0.45708308f, -0.19042024f, 0.33846933f, -0.34007776f, -1.21425402f, -0.78865951f, 
    -0.74453127f, -0.11885719f, -0.62948829f, -0.74181169f, 0.52353621f, 0.52928144f, -0.59096307f, -1.21815109f, 
    -0.68749928f, -0.14374621f, -1.05679619f, -0.13792352f, 0.95938849f, 0.42394465f, 0.42464852f, 0.73891765f, 
    -1.43126583f, -0.28216350f, -0.50862211f, 0.79550910f, 1.27921677f, 0.48527327f, -0.28947344f, -0.63063431f, 
    -0.27177498f, 0.85964942f, 0.90670228f, 0.91301495f, -1.38044882f, -0.89807689f, -0.94181776f, -0.13199528f, 
    0.41876861f, 0.52100039f, 0.66661310f, 0.93436116f, 0.96244544f, -0.26811406f, 0.18087791f, -0.33023423f, 
    -0.74013358f, 0.05893092f, -0.71153879f, 0.58564013f, -1.54231596f, -0.75164819f, -1.01427138f, -0.26635617f, 
    -0.57498300f, 0.22520468f, 0.41387367f, 0.10139899f, 0.71423388f, 1.40349019f, -0.25157806f, 0.71226990f, 
    -0.26512542f, 0.09320568f, 0.82156760f, 0.34700370f, 0.00728516f, -0.53342956f, 1.23174524f, 1.17649794f, 
    -0.21591160f, -0.05659342f, 0.78047204f, -0.11803652f, 0.28359401f, -0.14210990f, 0.34487212f, 1.37849987f, 
    -0.72402269f, 0.85768175f, -0.65301687f, -0.90766418f, -0.59452432f, -0.30770186f, 0.21394330f, 0.30809751f, 
    0.61647302f, 0.90931964f, 1.06782699f, 1.08301198f, -0.28012198f, -0.32036591f, -0.55763572f, -0.09946594f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.46101424f, 0.35856432f, -0.45893487f, 0.57406431f, 0.08073580f, -0.25798181f, -0.13376583f, -0.01199311f, 
    0.11588193f, -0.04748115f, 0.54720086f, 0.95363051f, -0.37103066f, 0.29950494f, -0.09060058f, -0.01380274f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.23332523f, -0.51987040f, 0.24768268f, -0.13108586f, -0.21017511f, 0.12292614f, -0.15905032f, -0.02680560f, 
    -0.02286115f, 0.71335191f, -0.01213895f, -0.08118702f, -0.15937142f, -0.12942992f, -0.09041199f, 0.11565457f, 
    -0.01000571f, 0.12371629f, 0.10822812f, -0.20556112f, -0.78553379f, -0.33825356f, -0.05905068f, 0.13223265f, 
    0.18832727f, 0.16077836f, 0.27696258f, 0.18814385f, 0.22619542f, -0.14271009f, 0.00494868f, 0.06469357f, 
    0.09865988f, 0.13628006f, 0.21754095f, -0.01294811f, -0.08035176f, -0.40501943f, 0.29099604f, 0.10516340f, 
    0.00719996f, 0.08975422f, -0.09296191f, -0.01277376f, 0.02906250f, 0.05470448f, -0.10429057f, 0.33755234f, 
    -0.02922678f, 0.31299224f, -0.12527899f, 0.01128018f, -0.04044858f, -0.09707621f, -0.50540239f, -0.41323331f, 
    0.46013647f, 0.32465029f, -0.03558014f, 0.19934167f, 0.22583346f, 0.08761794f, -0.04196556f, -0.25195393f, 
    0.14928830f, 0.35994422f, -0.00895896f, -0.06463476f, 0.01993952f, -0.08000598f, -0.21619631f, -0.02038191f, 
    -0.16513312f, -0.27963501f, 0.24236430f, 0.07124144f, -0.24215648f, 0.13303573f, 0.06995758f, 0.05056832f, 
    0.10144491f, -0.19705191f, 0.17836078f, -0.60892075f, 0.35186040f, 0.08735623f, -0.12287261f, 0.04541533f, 
    0.00736076f, 0.09541606f, -0.03066088f, 0.20190017f, 0.06966375f, 0.08842802f, 0.08395125f, 0.03438293f, 
    -0.09566423f, 0.07409049f, 0.08251034f, -0.04537749f, 0.02672055f, -0.03047070f, 0.15573786f, 0.14554472f, 
    -0.02991961f, -0.02555793f, -0.08823807f, 0.02583614f, -0.08698562f, 0.53608555f, -0.35749379f, -0.18503058f, 
    -0.03380543f, -0.27742550f, -0.12984544f, 0.01929687f, -0.23929800f, -0.35759690f, 0.41307053f, 0.17486513f, 
    0.16679020f, -0.08960538f, -0.18242362f, 0.14757641f, 0.02889381f, -0.14027095f, -0.57041717f, 0.08405495f, 
    -0.50925314f, -0.17564163f, -0.03479816f, -0.15268779f, -0.11914943f, -0.01606271f, 0.17458485f, -0.05135739f, 
    -0.08040394f, -0.23835091f, -0.07881220f, 0.04802584f, 0.13932647f, 0.08579544f, -0.23989739f, 0.20214036f, 
    0.06492524f, 0.33540425f, 0.47766474f, 0.23925349f, -0.08562879f, 0.16197392f, -0.31262293f, 0.10697550f, 
    -0.15163366f, -1.03766978f, -0.81827199f, -0.19318287f, 0.15346490f, 0.17024128f, -0.01696438f, 0.11956418f, 
    -0.04037340f, 0.10007752f, -0.00316844f, -0.16917747f, -0.28137994f, -0.08779387f, -0.17689086f, -0.06389805f, 
    0.00566685f, 0.32063761f, 0.09480396f, -0.04082379f, 0.02991192f, -0.06405624f, 0.11422740f, 0.04887287f, 
    0.11205742f, -0.14645481f, 0.12117269f, -0.17318124f, 0.18505162f, 0.25047320f, 0.02314574f, 0.08679169f, 
    -0.19080023f, -0.11062267f, 0.03544610f, 0.16044404f, 0.08759051f, -0.77303272f, -0.16458398f, 0.24818002f, 
    0.20376503f, -0.11802223f, -0.03719961f, -0.08925636f, -0.00039423f, 0.16264695f, 0.35999620f, 0.12123041f, 
    0.17505750f, 0.00975184f, 0.04738780f, 0.30467680f, -0.06673799f, -0.08109091f, -0.09349803f, -0.30814886f, 
    0.05188401f, 0.07840566f, -0.14747915f, -0.11424316f, 0.20149784f, 0.05526624f, 0.22318216f, 0.36067513f, 
    0.46707359f, 0.22057848f, 0.07877057f, 0.10960001f, 0.06880343f, -0.19976605f, 0.21218050f, 0.33341798f, 
    -0.08839775f, -0.07397610f, 0.02633798f, -0.14645724f, 0.22005484f, -0.12503852f, -0.09303896f, -0.55257595f, 
    0.12057406f, -0.00989212f, -0.75085962f, 0.22801842f, 0.00022246f, 0.11849188f, 0.05870599f, 0.24005361f, 
    -0.36269179f, -0.18070298f, -0.28489381f, -0.01941361f, 0.22537404f, 0.15612122f, 0.01250166f, -0.05586428f, 
    -0.12094641f, -0.22328915f, -0.05582611f, -0.01026731f, -0.59817541f, 0.02555545f, -0.66133714f, 0.16307954f, 
    -0.15052027f, 0.17110755f, -0.05440262f, -0.04395983f, 0.10235306f, -0.37404263f, 0.23780273f, -0.39795357f, 
    0.00139855f, 0.05897873f, -0.31829706f, 0.27623764f, 0.01021883f, 0.06954459f, 0.16138956f, 0.31205192f, 
    0.15100318f, -0.03725160f, 0.10652390f, 0.09532756f, 0.20218593f, -0.03522401f, -0.09373821f, -0.38894472f, 
    0.06357647f, -0.42826697f, 0.05112248f, 0.17607665f, -0.11529390f, 0.05218614f, 0.05831667f, 0.09315662f, 
    0.23241806f, 0.14392291f, 0.07201431f, 0.10034621f, 0.00415744f, -0.02633105f, 0.25567961f, 0.00365799f, 
    0.12174861f, 0.42345250f, 0.12057023f, 0.23403373f, 0.07216986f, -0.16448388f, -0.07933991f, -0.00837024f, 
    -0.02098612f, 0.21612927f, -0.25324774f, -0.02811720f, -0.48882091f, -0.11100584f, -0.03182441f, -0.04492615f, 
    -0.18197696f, -0.14692436f, 0.06294172f, -0.23738243f, -0.23365179f, -0.18106805f, -0.25912300f, 0.16540945f, 
    0.10590149f, 0.03853848f, 0.21219550f, 0.03790094f, 0.47261205f, -0.12107275f, 0.19048943f, -0.10337447f, 
    -0.11078496f, 0.00470379f, 0.19744015f, -0.08314069f, 0.11607090f, -0.05371899f, 0.28621313f, 0.20987999f, 
    0.33983737f, 0.03968992f, -0.06703572f, -0.08355072f, 0.08764288f, 0.08868824f, 0.29580310f, 0.06150720f, 
    -0.02212041f, 0.32538769f, 0.11162625f, 0.00245566f, 0.01071661f, -0.15911965f, -0.07303174f, 0.50534093f, 
    0.36865020f, 0.02076969f, 0.07766268f, -0.09503294f, -0.04721998f, -0.13721949f, -0.13782004f, -0.15376107f, 
    0.29826382f, 0.02973314f, 0.17501937f, 0.20513259f, -0.20177847f, 0.08295415f, -0.06861997f, -0.04926420f, 
    -0.19102150f, -0.92646205f, 0.06480253f, -0.14285819f, 0.09716690f, -0.00477365f, -0.04187831f, -0.28788966f, 
    0.06524079f, -0.17941159f, 0.00097663f, 0.25083125f, -0.01961183f, 0.00266212f, -0.00030003f, -0.00127236f, 
    0.14730874f, 0.07121616f, 0.18680216f, 0.38895118f, -0.32610112f, -0.01973637f, -0.09930547f, 0.22325209f, 
    0.25297382f, -0.01146145f, -0.07460355f, 0.07254925f, 0.16558373f, -0.21388392f, -0.17065898f, -0.24016497f, 
    -0.13821296f, 0.27062327f, 0.08555630f, 0.00998489f, -0.05310263f, 0.36794978f, -0.28174022f, -0.13055429f, 
    -0.15213352f, 0.11083307f, -0.17414460f, -0.08316652f, 0.12937962f, 0.12529257f, -0.24006844f, -0.22470358f, 
    -0.44561735f, -0.12637073f, 0.08443818f, 0.02834996f, -0.33068883f, 0.09391377f, -0.22084689f, 0.26463330f, 
    0.02708013f, -0.00432754f, -0.13693962f, -0.04169195f, -0.03403325f, 0.14372864f, 0.06030767f, -0.01400247f, 
    0.07357127f, -0.39752090f, -0.15965731f, -0.64415532f, -0.33061400f, -0.13373500f, 0.00170428f, 0.19817431f, 
    0.07572377f, -0.80183798f, -0.75026923f, -0.09443434f, 0.18477854f, 0.17941375f, 0.16556849f, 0.35811636f, 
    0.08717134f, 0.26532024f, -0.95767069f, -0.13541678f, 0.05688307f, 0.08822375f, -0.08248691f, 0.35555261f, 
    -0.06009500f, 0.03956339f, 0.03687959f, 0.61525178f, 0.35409024f, 0.42893374f, 0.09208786f, 0.03821019f, 
    -0.02689132f, 0.27876148f, 0.09455495f, 0.05885463f, 0.19046368f, 0.18933560f, -0.04313219f, -0.07273188f, 
    0.10081154f, 0.02738374f, -0.00488189f, 0.13720299f, -0.19659057f, -0.33434361f, -0.80971014f, -0.11544579f, 
    0.21978399f, -0.04843674f, 0.12073159f, 0.31747279f, -0.00118782f, -0.18127643f, 0.12585266f, -0.09584045f, 
    -0.07449997f, -0.14575098f, 0.09506720f, 0.01724875f, -0.08600681f, -0.03822092f, -0.24091581f, 0.22391893f, 
    0.04463589f, -0.08788126f, -0.18974714f, 0.07523809f, -0.18726736f, 0.19653611f, 0.21198523f, 0.06237530f, 
    0.12634635f, 0.16606751f, -0.28332150f, -0.22565335f, -0.16318555f, -0.01580274f, -0.08047429f, 0.10133301f, 
    -0.02752443f, 0.66326922f, 0.05783574f, 0.36735186f, 0.13206311f, -0.01046500f, 0.01321953f, 0.14952308f, 
    0.20141555f, 0.05951332f, 0.39213154f, 0.11955152f, -0.02572720f, 0.12711078f, 0.26597890f, 0.22854106f, 
    -0.30100179f, -0.04603787f, -0.12194469f, 0.45207831f, -0.17895889f, 0.02203319f, 0.14747348f, -0.02941187f, 
    0.18424553f, 0.02754133f, 0.11706804f, -0.03413513f, -0.45304587f, -0.36706337f, -0.20047869f, 0.02759857f, 
    -0.03848165f, -0.30216002f, 0.20649849f, 0.07133144f, -0.02956228f, -0.31578174f, -0.29614356f, -0.01758816f, 
    0.11856247f, -0.23750213f, 0.29334643f, 0.14962900f, 0.03545487f, 0.14683063f, 0.43971926f, -0.06362864f, 
    0.34635305f, 0.12858181f, -0.08124336f, -0.00551804f, -0.12694661f, -0.10470734f, 0.25994989f, -0.69588476f, 
    -0.40110365f, -0.19916138f, 0.07381465f, 0.14001638f, 0.06493974f, -0.27267876f, -0.04647101f, -0.05595820f, 
    0.39375356f, 0.02455510f, 0.71571481f, 0.14215590f, -0.10040955f, 0.15180102f, -0.02377512f, 0.05892080f, 
    0.45037150f, 0.09680942f, -0.24665774f, -0.26285785f, -0.00857597f, 0.08661053f, 0.07260676f, -0.04574545f, 
    -0.09230137f, -0.24656528f, 0.34796655f, -0.25420228f, -0.86871916f, -0.06323107f, -0.14094390f, 0.23568800f, 
    -0.22597598f, 0.08109657f, 0.12738758f, 0.34223241f, 0.16058572f, -0.01009197f, 0.10115650f, 0.21177036f, 
    -0.28233466f, 0.27595904f, 0.25421479f, 0.11539541f, -0.20128410f, 0.01607530f, 0.33220515f, 0.02624495f, 
    0.18835260f, -0.17126498f, -0.05562330f, -0.35467425f, -0.00863033f, -0.21583900f, -0.03728711f, -0.62939918f, 
    0.01669764f, 0.05652165f, -0.14745627f, -0.16945456f, 0.08968498f, -0.21358232f, -0.16303590f, 0.13990857f, 
    0.37141928f, -0.13995188f, -0.06906269f, 0.22113912f, -0.13526455f, -0.11180647f, -0.12568653f, 0.03572107f, 
    -0.23840290f, -0.18934897f, 0.02410305f, 0.15537311f, -0.15698318f, 0.15226686f, 0.03749496f, -0.36713788f, 
    -0.21946821f, 0.14085276f, 0.30548540f, 0.13254847f, 0.12860486f, 0.26392677f, -0.39406854f, 0.19454274f, 
    0.37649375f, 0.18386759f, -0.20577732f, -0.03378725f, -0.24240203f, 0.01027028f, -0.33008093f, 0.00596362f, 
    0.11786176f, -0.11533835f, 0.49162799f, -0.08254303f, 0.03917986f, 0.09767093f, -0.02281591f, 0.19342926f, 
    -0.03011156f, 0.02353364f, 0.17859098f, 0.14954729f, -0.02620982f, 0.11855085f, -0.16322938f, -0.09485099f, 
    0.02277813f, 0.01963643f, 0.01727222f, -0.00251271f, -0.43916988f, 0.05424373f, 0.36336797f, 0.24848895f, 
    0.01414341f, 0.04771758f, -0.16742529f, 0.06260100f, -0.48416144f, 0.25664017f, 0.03432693f, 0.11126398f, 
    -0.05842890f, -0.16969967f, 0.17405708f, 0.07032835f, -0.28831071f, -0.14234221f, 0.67137635f, 0.17466486f, 
    0.28700733f, 0.00156926f, -0.00326600f, -0.02834711f, -0.18538129f, -0.08225321f, -0.09932516f, -0.12708239f, 
    -0.02213457f, -0.12445746f, 0.23773667f, -0.23378068f, 0.49095887f, 0.26213533f, 0.20766599f, -0.17953539f, 
    0.61334026f, 0.74888319f, 0.15233858f, 0.34472543f, 0.09080335f, 0.24278228f, -0.03490775f, 0.20315933f, 
    0.08131256f, -0.30062294f, -0.19944414f, 0.14137501f, -0.01081887f, -0.21282077f, -0.17795719f, 0.04241098f, 
    0.09468725f, 0.03246450f, 0.13157581f, -0.28911969f, -0.09847648f, -0.01467245f, -0.20850372f, -0.05878622f, 
    0.00841652f, -0.03360504f, -0.01441478f, 0.04640132f, -0.29614797f, -0.26966798f, 0.01903570f, -0.08909588f, 
    -0.00323812f, -0.33246511f, -0.15630125f, -0.31855857f, 0.14507084f, 0.34727508f, -0.08553910f, 0.09090152f, 
    -0.09379216f, -0.02442083f, 0.14053319f, 0.15361042f, -0.40697160f, -0.51927239f, -0.74059057f, 0.28687119f, 
    0.12576087f, -0.11924788f, 0.07699575f, -0.03520681f, -0.23975624f, 0.19026674f, -0.11712815f, 0.62038589f, 
    0.09679811f, 0.06886273f, 0.20650510f, 0.02856936f, 0.08174846f, 0.02309243f, 0.02589143f, -0.28842759f, 
    0.49128824f, 0.04989719f, -0.18025795f, 0.09535752f, -0.27315634f, -0.08067144f, 0.07017684f, 0.35747743f, 
    0.10336094f, 0.22777973f, 0.15198037f, 0.04145456f, 0.25768086f, -0.34560621f, -0.02660470f, 0.10799035f, 
    0.10563244f, -0.19738962f, -0.63998568f, 0.11178523f, -0.05909229f, 0.02690409f, 0.19153260f, -0.05437365f, 
    0.05262270f, 0.08564506f, 0.24520153f, -0.23063192f, 0.40254405f, 0.00996215f, 0.02448340f, 0.06896658f, 
    -0.27836892f, -0.18465567f, -0.09243909f, 0.30735847f, 0.17354348f, -0.24542570f, -0.09838063f, -0.06340274f, 
    0.08518619f, -0.09421885f, -0.30763611f, -0.10157100f, 0.62670493f, 0.16995339f, -0.19503839f, -0.10562867f, 
    -0.12084897f, 0.18124159f, 0.13408214f, 0.12466948f, 0.12529023f, -0.11110303f, -0.11089636f, -0.07986329f, 
    0.07312363f, -0.08378799f, -0.10587474f, 0.17036557f, -0.08509436f, 0.23587377f, 0.43603617f, -0.24177684f, 
    0.13178767f, -0.28555557f, -0.09180315f, -0.02835881f, 0.10889513f, -0.09166197f, 0.03277621f, 0.33641922f, 
    0.00938121f, -0.27174482f, 0.05514940f, 0.02776730f, -0.07162844f, 0.06236377f, 0.20306326f, -0.11087769f, 
    -0.10564096f, -0.07734050f, -0.10327780f, -0.05528792f, -0.00560990f, -0.09006714f, -0.01048663f, 0.03876090f, 
    0.03976867f, 0.00108609f, -0.01029007f, -0.04441189f, -0.05796275f, 0.05384412f, -0.06610078f, -0.05954340f, 
    -0.06254515f, 0.05651626f, -0.02548739f, -0.01328301f, -0.00731752f, -0.08944789f, -0.09716136f, 0.05146385f, 
    -0.09610617f, -0.05604177f, 0.01031226f, -0.08375184f, 0.04983164f, -0.04761088f, 0.02985389f, 0.00614919f, 
    -0.01819809f, -0.01720662f, -0.01068299f, -0.01804930f, -0.00010627f, -0.07200704f, -0.09097782f, -0.05425517f, 
    0.03435868f, 0.04682952f, -0.05304227f, 0.02960885f, 0.04511102f, -0.01805390f, -0.03247434f, -0.06649026f, 
    -0.08203126f, 0.04211031f, -0.03564331f, -0.07882398f, -0.05265815f, -0.04253772f, 0.04817596f, 0.01837025f, 
    0.01552823f, -0.05834780f, 0.02292510f, -0.05784097f, -0.01542548f, -0.03472159f, 0.00323328f, -0.06672589f, 
    0.02505435f, 0.00450689f, -0.01134289f, 0.04745546f, 0.05042228f, -0.01987341f, -0.02615563f, 0.03324857f, 
    -0.04676617f, -0.00687858f, -0.03280789f, 0.05120404f, 0.06011217f, -0.01590777f, 0.03078469f, 0.01870616f, 
    0.06149802f, -0.02957989f, -0.08306891f, 0.01390163f, -0.04582071f, -0.09262147f, -0.04689773f, 0.04009528f, 
    -0.05958299f, -0.00707723f, 0.00522641f, 0.06554059f, -0.01642742f, -0.02539249f, -0.04323293f, -0.07187974f, 
    -0.04859554f, -0.02221339f, 0.02104758f, 0.05240989f, 0.02501677f, -0.03177001f, 0.00991940f, -0.08608670f, 
    0.05458721f, 0.00338318f, 0.02053513f, -0.01649296f, 0.02927464f, -0.03880134f, 0.04643169f, -0.03056973f, 
    -0.00901515f, 0.00860294f, 0.01824162f, -0.06261604f, -0.09884348f, 0.01363742f, 0.06117625f, 0.00047272f, 
    -0.03256923f, -0.07925282f, -0.00957274f, -0.09815359f, -0.06788628f, 0.02193155f, 0.00255681f, 0.00361509f, 
    -0.06468620f, -0.06440587f, 0.03953456f, 0.02135603f, 0.01555843f, 0.03349028f, -0.01900508f, -0.05045683f, 
    -0.07003762f, -0.08166029f, 0.02838088f, 0.04771081f, -0.07770985f, 0.03733087f, -0.01571530f, 0.04684515f, 
    -0.30101427f, 0.03384246f, -0.00933772f, -0.04416609f, 0.13876127f, -0.17728978f, 0.35911614f, 0.00727497f, 
    0.33318138f, -0.07731482f, 0.22655733f, 0.12412530f, 0.19352916f, 0.02398641f, -0.07461447f, -0.00814225f, 
    0.10808231f, 0.21235301f, -0.60360134f, -0.38029703f, 0.04902994f, -0.01652029f, 0.11085150f, -0.06885733f, 
    0.00575184f, -0.10159782f, -0.05783778f, -0.05754615f, -0.23101196f, 0.14658643f, -0.01880439f, -0.05268499f, 
    0.09639952f, 0.14447364f, 0.14290817f, 0.16977534f, -0.03877218f, 0.01378622f, -0.59889185f, 0.20764075f, 
    0.50455409f, 0.28264257f, -0.23904385f, -0.20020565f, 0.11314108f, 0.04402216f, -0.07767955f, 0.29687300f, 
    -0.23415296f, -0.05237145f, -0.14452890f, 0.09216342f, -0.10991398f, -0.08489423f, -0.41964629f, -0.05075629f, 
    -0.08096710f, 0.05502840f, 0.05271661f, -0.37492877f, 0.28331059f, 0.16853498f, -0.07663004f, -0.50426787f, 
    -0.17054844f, -0.36014986f, 0.33405465f, 0.06171181f, -0.03798869f, -0.00208020f, -0.24188276f, 0.00097917f, 
    0.64121199f, 0.18953179f, -0.21589708f, 0.17148106f, 0.20232221f, 0.26990229f, 0.35812265f, -0.16976614f, 
    0.18353833f, -0.29778597f, -0.01063527f, 0.47389928f, -0.48896495f, -0.12884723f, -0.17282081f, -0.03104834f, 
    0.00187285f, 0.15037677f, 0.65677744f, 0.34803933f, 0.64035612f, 0.26131263f, -0.03899610f, -0.05029044f, 
    0.25289926f, -0.00009163f, 0.01967075f, 0.03101582f, -0.46766075f, 0.35121047f, 0.00407263f, 0.12907295f, 
    0.09679392f, 0.04880245f, 0.04220648f, 0.10180354f, -0.66976225f, -0.24887900f, -0.35175553f, -0.47955555f, 
    -0.01442796f, 0.17798986f, -0.16596963f, -0.04382923f, -0.18803574f, -0.17559050f, 0.04335314f, 0.23392604f, 
    0.01894889f, 0.58526355f, -0.02193816f, -0.28260013f, -0.11378618f, 0.03752393f, 0.04498976f, -0.21261996f, 
    -0.00330332f, -0.26816231f, 0.30933926f, -0.23128320f, 0.01480206f, -0.17363177f, -0.06792410f, 0.14795615f, 
    0.18434775f, 0.29968217f, -0.32241669f, -0.11974458f, 0.00230797f, 0.40117201f, 0.14896227f, 0.15734144f, 
    -0.00830140f, 0.05674991f, 0.03363331f, -0.02219313f, 0.06870200f, 0.00275335f, -0.06135975f, 0.00484336f, 
    -0.07203563f, 0.04880757f, -0.02492676f, -0.00832270f, -0.01015364f, -0.05879272f, 0.04758261f, 0.00001706f, 
    0.05045864f, -0.08277407f, -0.06146481f, 0.02165505f, 0.02649771f, -0.00998724f, -0.06975657f, 0.02708570f, 
    -0.01975512f, -0.01058948f, -0.07338870f, 0.03949554f, 0.03300465f, -0.05810795f, 0.07337518f, 0.01714783f, 
    0.06423828f, 0.03372596f, 0.01490578f, -0.01869232f, -0.08389734f, 0.02527176f, 0.04127317f, 0.00406142f, 
    0.00269581f, 0.01688248f, -0.02332613f, -0.01967062f, -0.07648040f, 0.07398515f, 0.00873169f, -0.04464259f, 
    0.04677551f, 0.04957357f, -0.01878239f, -0.03561818f, -0.05925801f, 0.06240597f, 0.03323923f, 0.03111545f, 
    -0.05194079f, 0.01532832f, -0.07109228f, -0.09370615f, -0.00190082f, 0.01912538f, -0.06910088f, 0.04804155f, 
    0.04570020f, -0.08603677f, -0.04393100f, -0.03065765f, 0.03130624f, 0.00807935f, -0.00876160f, -0.08026967f, 
    0.00808225f, -0.01151865f, -0.07369882f, 0.01962161f, -0.09948870f, -0.06104060f, 0.01091922f, -0.00927949f, 
    -0.04166587f, -0.03122473f, -0.00532628f, -0.04273362f, -0.06522483f, -0.07361162f, -0.00840536f, -0.07869696f, 
    0.00593926f, -0.04170653f, 0.04063436f, -0.00654690f, -0.06183559f, -0.05506591f, -0.05012445f, -0.05490601f, 
    -0.06949341f, 0.01694041f, 0.07024889f, -0.00916244f, 0.06430158f, 0.05351592f, 0.01829612f, 0.00697909f, 
    0.03847961f, -0.06823917f, -0.02639441f, -0.02957792f, 0.00407652f, 0.01877028f, 0.05088210f, -0.06307760f, 
    0.04909167f, -0.04193912f, -0.09003228f, -0.04491848f, 0.01518930f, 0.02837217f, -0.00422980f, 0.00591755f, 
    0.04407590f, -0.01507166f, -0.06148809f, -0.04915247f, -0.09478282f, -0.02059155f, -0.04844748f, -0.05764253f, 
    -0.01962743f, -0.03153949f, 0.05309542f, -0.00820675f, -0.08449049f, -0.06389380f, 0.07196142f, -0.01575843f, 
    -0.03954446f, 0.04187481f, -0.06787607f, 0.00806296f, -0.00027849f, -0.00043414f, 0.04011883f, 0.01382792f, 
    -0.67581409f, 0.05916371f, -0.49900171f, -0.07956752f, 0.08694337f, -0.16902557f, -0.03894329f, -0.01560447f, 
    -0.18572547f, -0.51235586f, 0.20453689f, 0.24758084f, 0.20813148f, 0.15096593f, 0.14114967f, -0.25572485f, 
    0.25946864f, 0.01695215f, 0.22078162f, -0.32720795f, 0.08130326f, -0.12300766f, 0.05670629f, 0.15570657f, 
    -0.01992781f, -0.12259210f, -0.09768514f, -0.03947683f, 0.35847950f, 0.12608691f, 0.01740559f, -0.01242660f, 
    -0.05926746f, -0.13078395f, 0.13105556f, 0.25907537f, -0.43921757f, 0.13841426f, -0.09714204f, 0.05749796f, 
    0.00814570f, -0.21465738f, -0.24860744f, 0.02975241f, 0.05559191f, -0.54454350f, 0.57791609f, -0.18759121f, 
    -0.21482027f, 0.05726937f, 0.11682352f, -0.26447785f, 0.15150841f, -0.18412857f, -0.44410759f, 0.12369262f, 
    -0.31551448f, 0.39613873f, 0.25313088f, 0.02351806f, 0.01950459f, -0.12950814f, -0.05315934f, -0.06227732f, 
    -0.46882465f, -0.31773213f, 0.15767613f, 0.08481289f, 0.22368716f, -0.05684686f, -0.05811427f, -0.14900844f, 
    0.55897337f, -0.33147535f, 0.18099479f, 0.15676369f, -0.10987452f, 0.20627424f, 0.04593731f, -0.17665906f, 
    -0.05929767f, 0.28701162f, 0.50320500f, -0.14076854f, -0.23674969f, 0.04078212f, 0.00637479f, -0.09899451f, 
    0.03268464f, 0.07561202f, -0.38001335f, 0.03835825f, 0.09157629f, 0.16800971f, 0.09557431f, -0.02418855f, 
    -0.17636958f, -0.03913321f, -0.18032679f, 0.16775170f, 0.48422897f, -0.37436616f, -0.09751717f, 0.02585952f, 
    -0.20837244f, -0.03511149f, 0.18546647f, 0.15587099f, -0.06211352f, -0.08434162f, 0.06050307f, 0.21428216f, 
    0.15304136f, -0.07461135f, 0.10728452f, -0.03192123f, 0.13384572f, -0.06284869f, -0.32161313f, 0.07068370f, 
    -0.08203536f, 0.02481951f, -0.09223162f, -0.30467695f, 0.04005089f, 0.02134223f, 0.08585262f, 0.43461400f, 
    -0.00324716f, 0.07397278f, 0.05038220f, -0.12731746f, 0.13703817f, -0.07189942f, 0.21208319f, 0.13093744f, 
    -0.33020338f, 0.18246914f, 0.15842918f, 0.05618061f, 0.11272416f, 0.11998889f, -0.06504075f, -0.19409181f, 
    -0.16982013f, -0.18638246f, 0.04179757f, -0.08874584f, -0.00272891f, 0.01658976f, 0.03518150f, -0.00601802f, 
    0.40058741f, -0.16118751f, -0.26976588f, 0.30811796f, 0.00614174f, 0.02020566f, -0.00262075f, -0.26709807f, 
    -0.01849481f, 0.00561816f, -0.37853932f, -0.08353744f, 0.18139356f, -0.20857386f, 0.31053144f, 0.09821337f, 
    0.08252268f, -0.07124713f, -0.04360531f, -0.25101447f, -0.45620352f, -0.33434170f, 0.02369012f, 0.15119062f, 
    -0.01675861f, 0.00563364f, 0.23368119f, -0.20370278f, 0.88304168f, -0.00064326f, -0.11471310f, -0.23329090f, 
    -0.09007529f, 0.01097404f, -0.04532996f, 0.05588014f, 0.08433920f, -0.62883276f, 0.34545040f, 0.03310446f, 
    0.14162698f, -0.00899722f, 0.15317066f, -0.11821426f, 0.02757301f, 0.10689256f, -0.49445906f, -0.29883379f, 
    0.00587186f, -0.16402212f, -0.06861763f, -0.04312347f, 0.02456679f, 0.09617097f, -0.23223263f, 0.25267532f, 
    0.06305400f, -0.01349475f, 0.20334069f, -0.03952503f, -0.22580338f, -0.29829752f, -0.07638466f, 0.11694825f, 
    0.21978524f, 0.39201668f, -0.30743456f, 0.05598498f, 0.09731586f, -0.10834731f, 0.29997662f, 0.07602105f, 
    -0.09869501f, 0.10995527f, 0.51661623f, -0.03978880f, 0.00086483f, 0.07394237f, -0.05480380f, -0.26337168f, 
    -0.26409090f, 0.01460598f, 0.29476467f, -0.03345712f, -0.11175916f, 0.05904297f, 0.09945742f, -0.00410900f, 
    -0.08915498f, -0.10277921f, -0.29152039f, 0.18771034f, -0.29844084f, -0.27817667f, 0.06846575f, 0.23437615f, 
    0.15309663f, 0.11214102f, -0.06962942f, -0.02653989f, -0.07821349f, -0.43068314f, 0.29049492f, 0.15683171f, 
    -0.07600265f, 0.08914106f, 0.13134183f, -0.09138084f, 0.02970857f, 0.44822475f, 0.29670268f, -0.76503104f, 
    -0.22336486f, 0.14809601f, 0.04897932f, 0.08895649f, 0.02278449f, 0.13366126f, -0.14529410f, -0.71824646f, 
    -0.14708301f, -0.02505534f, 0.11240842f, 0.00012049f, -0.24701811f, 0.11211509f, 0.24510744f, -0.06370835f, 
    -0.54711640f, 0.31460312f, -0.02890311f, -0.01313130f, -0.06073175f, -0.14381233f, 0.22583812f, 0.10121445f, 
    -0.30372667f, -0.20047329f, 0.30901051f, -0.00714126f, 0.37062567f, -0.24840704f, 0.06017759f, 0.09142102f, 
    -0.14428878f, 0.16284689f, 0.09536581f, 0.32452458f, 0.21936758f, 0.04415303f, 0.15688534f, 0.15052964f, 
    -0.04305938f, 0.00014274f, -0.28254962f, -0.16229853f, -0.02507850f, -0.15205416f, -0.02486876f, 0.00903825f, 
    0.20455381f, -0.21929094f, -0.10795822f, 0.12812488f, -0.08281966f, 0.21673919f, 0.08037718f, 0.10785563f, 
    -0.17563613f, -0.11426266f, 0.13582546f, -0.12509955f, 0.02465811f, 0.17328531f, 0.24777649f, 0.01501002f, 
    -0.19959465f, 0.13903536f, -0.00122595f, 0.07094181f, 0.04492359f, -0.13680713f, -0.01842513f, -0.11643557f, 
    0.31635341f, -0.02627807f, -0.10060107f, 0.26897836f, 0.13386795f, 0.07280757f, -0.26228681f, -0.33976671f, 
    0.16277741f, -0.20053838f, -0.05132592f, -0.11091079f, 0.10423212f, 0.16766883f, 0.10622587f, 0.18179706f, 
    -0.23611608f, -0.22280000f, -0.14268000f, 0.38799050f, -0.02785089f, -0.14064825f, 0.00549098f, 0.26224712f, 
    0.52108353f, 0.20485087f, 0.32922018f, -0.32421750f, -0.15840557f, 0.14050265f, -0.10075944f, 0.09051964f, 
    -0.08778758f, -0.28420803f, 0.13484988f, -0.22929521f, 0.00384305f, 0.07067967f, -0.02611921f, 0.09342665f, 
    -0.22140375f, 0.11538470f, -0.28387251f, 0.04696295f, -0.15630336f, 0.25293913f, -0.00736731f, 0.08905295f, 
    -0.24153550f, 0.12755330f, -0.06094416f, -0.11200248f, 0.10758608f, -0.36581051f, -0.00079120f, -0.17211290f, 
    0.04378704f, 0.14458065f, -0.02223047f, -0.14850633f, 0.30853602f, 0.15437475f, -0.14148873f, -0.12780434f, 
    0.11801510f, 0.16623096f, 0.07431274f, -0.08731969f, 0.09679212f, -0.12936738f, -0.01335384f, -0.04388075f, 
    0.09468991f, 0.06609799f, 0.16316466f, 0.05493895f, -0.45941392f, -0.14058137f, 0.02426047f, -0.10375836f, 
    -0.23068020f, -0.10749981f, -0.06827007f, -0.05385073f, 0.14272222f, -0.02579922f, 0.14756492f, 0.02165947f, 
    -0.12557550f, -0.40675399f, 0.23523563f, -0.11152897f, 0.09319231f, -0.10387281f, 0.15818509f, 0.09249247f, 
    -0.07482462f, -0.00765430f, 0.01545988f, -0.01663472f, 0.01256218f, 0.00043509f, -0.04845115f, 0.07079510f, 
    0.06459051f, -0.04361125f, 0.00843200f, -0.08378617f, 0.00131537f, -0.04475514f, 0.07203393f, 0.02531808f, 
    -0.02575714f, 0.07334892f, 0.03465680f, -0.07815686f, 0.03046150f, -0.03823340f, 0.01133186f, 0.01518837f, 
    0.02973160f, 0.06728344f, -0.08905648f, 0.03857131f, 0.03576818f, 0.00376320f, -0.01655842f, 0.01781220f, 
    0.02987721f, 0.04730053f, 0.00937519f, -0.06413526f, 0.04770997f, -0.07232238f, -0.05304595f, -0.06829639f, 
    -0.02526423f, -0.06161490f, 0.01428638f, -0.00431467f, -0.05998858f, -0.04496773f, -0.09017164f, -0.05431938f, 
    -0.01365242f, 0.07008401f, -0.03542312f, 0.00768696f, -0.07040575f, 0.05269526f, -0.03833544f, -0.04744944f, 
    -0.05602420f, -0.03824527f, 0.06045037f, -0.02615628f, 0.06133255f, 0.04699801f, -0.04525157f, -0.07252323f, 
    -0.04693105f, -0.08668564f, 0.05004421f, 0.03784969f, 0.01642254f, 0.00835613f, -0.08466464f, -0.00426620f, 
    -0.02485246f, 0.02045152f, 0.02483907f, -0.07285174f, -0.08172484f, -0.03151026f, -0.06920321f, 0.04219696f, 
    0.07081402f, 0.01878999f, -0.02597974f, -0.08545730f, -0.01940750f, -0.07102142f, -0.05129726f, -0.02435610f, 
    -0.02525901f, -0.02136856f, -0.00026719f, 0.05541687f, -0.04224106f, 0.06433139f, 0.03456271f, -0.05275000f, 
    0.05166928f, 0.05462078f, 0.02253863f, 0.07041664f, -0.03555254f, -0.06528290f, 0.03748320f, -0.04325793f, 
    -0.01045043f, 0.06697657f, -0.07802684f, 0.02995992f, -0.01814525f, -0.06902852f, -0.02959192f, -0.03041670f, 
    0.02826818f, -0.00339693f, -0.01067462f, -0.03970977f, -0.01548704f, 0.02817744f, -0.04839775f, 0.01971321f, 
    -0.06054012f, 0.05209615f, -0.02985578f, -0.04520641f, -0.07414021f, -0.02438498f, -0.06776443f, 0.03310849f, 
    -0.04224924f, -0.01002946f, -0.08763468f, 0.00094531f, -0.01502558f, -0.08045515f, -0.01216353f, -0.02410576f, 
    -0.07732515f, 0.04181082f, -0.04035720f, 0.03588731f, -0.01131461f, -0.01349367f, 0.00006066f, 0.06866550f, 
    0.07959647f, 0.37210661f, -0.19192304f, 0.08315535f, 0.22995687f, -0.17195261f, 0.10474125f, 0.07707134f, 
    0.11831143f, 0.49374616f, 0.13667272f, 0.06308730f, 0.03518364f, -0.15796256f, 0.06816338f, 0.12911272f, 
    0.23785537f, 0.00079883f, -0.82817018f, -0.07666045f, 0.02626331f, 0.11187290f, 0.23345369f, -0.01790685f, 
    0.07052597f, 0.32846871f, -0.22335954f, -0.04245251f, -0.10342079f, 0.12641202f, 0.26374274f, 0.08788694f, 
    0.18515129f, 0.02434231f, -0.12738380f, 0.00697493f, 0.01629975f, 0.34087452f, -0.40055001f, 0.10330804f, 
    -0.12033906f, 0.04478166f, -0.03759605f, -0.10720871f, -0.15291010f, 0.35980558f, 0.33574200f, -0.23958813f, 
    0.01231588f, -0.37993351f, -0.03874322f, -0.14826383f, 0.15424629f, 0.19891708f, -0.09641145f, -0.19249201f, 
    -0.33317095f, -0.07584204f, -0.07742028f, 0.24742088f, -0.05806622f, -0.04404579f, -0.13046761f, -0.45283398f, 
    0.59159994f, 0.11396204f, -0.06464475f, -0.04502779f, -0.00187350f, -0.09329318f, 0.10200915f, 0.09910335f, 
    0.16103089f, 0.15838522f, -0.07886492f, -0.05878589f, 0.15676984f, -0.45119005f, 0.01138696f, -0.15617521f, 
    -0.22735566f, 0.45379797f, 0.04127845f, -0.23105545f, 0.00981968f, -0.19015385f, 0.22613718f, -0.09893082f, 
    -0.01851715f, 0.17016938f, 0.00908003f, 0.18983911f, 0.02540265f, 0.01601346f, -0.10881665f, -0.08915703f, 
    0.04297445f, -0.10512828f, -0.12297869f, 0.39459506f, -0.59836465f, 0.07969522f, 0.17483349f, 0.02574576f, 
    -0.10007307f, 0.06383538f, -0.10983476f, 0.06596928f, 0.32630625f, -0.31176552f, 0.00307527f, -0.27615064f, 
    0.14029491f, 0.05058423f, 0.04431703f, 0.24881233f, 0.01866649f, -0.23277450f, 0.01461559f, 0.00299042f, 
    0.24602050f, -0.18408297f, -0.22980860f, -0.12885910f, -0.03192842f, 0.09756508f, -0.39454269f, -0.01125050f, 
    -0.18443209f, 0.01315178f, -0.02324531f, -0.08755342f, 0.15940487f, -0.03145806f, -0.21650748f, 0.10914773f, 
    0.09128947f, 0.17135884f, -0.26541370f, -0.02136034f, -0.07511253f, -0.11993635f, 0.18536592f, 0.27419731f, 
    -0.93587375f, 0.18620203f, -0.17330901f, 0.11447989f, 0.11032896f, 0.13021258f, -0.23632112f, -0.13061959f, 
    -0.04008357f, -0.29672128f, 0.03715368f, 0.26595309f, 0.25967512f, 0.13139252f, 0.20762512f, 0.13565502f, 
    -0.24909644f, -0.05233696f, 0.03053164f, -0.48507074f, -0.25850427f, 0.08954959f, -0.11554463f, -0.00359060f, 
    0.13366394f, 0.00079395f, -0.06842218f, -0.01565109f, -0.20675722f, 0.31265113f, 0.16679965f, 0.06553642f, 
    0.09983674f, 0.10516143f, -0.09963524f, 0.05494227f, -0.56201100f, -0.18039794f, -0.39350456f, -0.09213568f, 
    -0.12507631f, -0.13568757f, 0.12433348f, -0.01917407f, 0.04077270f, -0.19801112f, 0.04945050f, -0.21470705f, 
    0.11091410f, 0.12894954f, 0.13926612f, -0.04406894f, -0.06176692f, 0.04734085f, -0.16618042f, -0.14991987f, 
    -0.33827487f, -0.14747910f, 0.26790786f, -0.24909371f, 0.36107567f, 0.02333657f, 0.12118651f, -0.00503675f, 
    -0.35696965f, -0.57442427f, -0.04317048f, -0.04705667f, -0.09015081f, 0.10902439f, -0.12060675f, 0.26570755f, 
    -0.35543787f, 0.06751656f, -0.73055583f, 0.23184666f, -0.03688962f, -0.17514662f, 0.33035469f, 0.03509102f, 
    -0.25398871f, 0.37045392f, -0.11363743f, -0.06695731f, -0.17608657f, 0.13905516f, 0.09713580f, -0.26518950f, 
    0.16581742f, 0.32289353f, -0.14572033f, 0.06774108f, 0.16548879f, 0.13377771f, 0.05187628f, 0.19408546f, 
    0.35106546f, -0.01358068f, -0.05424761f, -0.70910865f, -0.18636441f, 0.23352557f, 0.03848709f, 0.18330687f, 
    0.01331973f, 0.11299989f, -0.01326834f, 0.24246262f, -0.08258086f, 0.04135504f, -0.09034900f, 0.18425769f, 
    0.09757680f, -0.19900051f, -0.01100162f, 0.04495981f, -0.08022780f, 0.00575232f, 0.05455871f, -0.14302602f, 
    0.13507980f, 0.03536965f, 0.10850254f, 0.18502960f, 0.33091620f, 0.00144289f, -0.27667820f, -0.23173198f, 
    0.00795262f, 0.01458407f, -0.00535983f, -0.12808694f, 0.05244173f, -0.10326955f, 0.08118221f, 0.06347047f, 
    0.22257560f, 0.18401171f, -0.35873261f, 0.07780502f, -0.14727493f, 0.04672499f, -0.13633305f, 0.23192041f, 
    -0.02814621f, 0.31330362f, -0.17326565f, -0.29595509f, 0.10119127f, -0.07689118f, 0.02843373f, 0.00623558f, 
    -0.01651419f, 0.00752557f, 0.18817735f, 0.04755423f, -0.21571100f, 0.12334066f, -0.17057060f, 0.04710699f, 
    0.09959651f, -0.12240725f, -0.26471579f, -0.14217161f, -0.20188299f, -0.05164750f, 0.08854532f, 0.17860299f, 
    0.06643040f, -0.01932621f, 0.11849744f, 0.03219388f, -0.00751912f, -0.40716088f, 0.07113842f, -0.06061088f, 
    0.01339664f, 0.15153448f, 0.05769330f, 0.03246328f, 0.10520241f, -0.36348411f, -0.06904741f, -0.09088788f, 
    0.07736520f, 0.30625531f, -0.10975483f, -0.02576496f, -0.05355879f, 0.27483487f, 0.06827992f, 0.25224313f, 
    -0.04804441f, -0.00837411f, 0.09897130f, 0.03836912f, 0.01109255f, -0.01675864f, 0.16254514f, 0.00475899f, 
    -0.34018248f, 0.07153619f, -0.15191092f, -0.07607208f, -0.11368299f, 0.20899092f, -0.09600982f, -0.52993059f, 
    -0.07300126f, -0.02743892f, -0.01297174f, 0.32303175f, -0.16328469f, -0.20002122f, -0.11726759f, 0.11158963f, 
    -0.76619285f, -0.62813014f, -0.32039553f, -0.28493622f, 0.13074721f, 0.00164005f, -0.28230485f, 0.11329007f, 
    -0.05303506f, 0.63098419f, 0.23881546f, 0.19699055f, 0.29791671f, 0.01096297f, 0.03609779f, 0.14367507f, 
    -0.09489559f, -0.14538966f, 0.45447934f, 0.15484682f, 0.18862133f, 0.05059152f, 0.03329556f, -0.03192803f, 
    0.03581849f, -0.02168423f, 0.15638207f, 0.37584329f, 0.12065853f, -0.62495840f, 0.07885948f, 0.09090900f, 
    0.02167136f, 0.15377744f, -0.17173682f, -0.27174324f, 0.59500933f, -0.12746051f, 0.14274742f, 0.00945644f, 
    -0.22384876f, 0.02632589f, 0.42501768f, -0.01623583f, -0.03099232f, 0.54843342f, 0.02068941f, -0.01771042f, 
    0.13527675f, 0.02902311f, -0.06425301f, 0.30310082f, -0.08255353f, 0.17767805f, 0.03138601f, -0.22709785f, 
    0.06979337f, 0.00544343f, 0.19120555f, 0.03747985f, -0.18342188f, 0.15922382f, 0.27230212f, -0.19079696f, 
    0.12983745f, -0.11982239f, 0.12315334f, 0.02951069f, -0.02746541f, 0.04828822f, -0.07498438f, -0.05458835f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.15405311f, 0.04316447f, 0.07399172f, 0.34530199f, -0.09201676f, -0.23371269f, -0.03832552f, 0.21645460f, 
    -0.03811270f, 0.08630548f, 0.10907915f, 0.04289696f, -0.07525794f, 0.08352187f, 0.44136539f, 0.01056255f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.15361400f, 0.01308559f, -0.02239455f, -0.33901218f, -0.10326383f, -0.36207747f, -0.00224348f, 0.59783465f, 
    0.06484155f, 0.02235047f, -0.04809201f, -0.13289753f, -0.13876489f, 0.82176864f, -0.65618205f, -0.94816798f, 
    0.00107453f, 0.17054056f, 0.38118151f, -0.44246465f, -0.39986160f, 0.04357414f, 0.13428959f, 0.20438030f, 
    -0.14608817f, -0.63705856f, 0.75774282f, -0.77927840f, -0.00094977f, 0.47135597f, 0.36191553f, 0.14976090f, 
    0.28786391f, 0.27383059f, 0.69865894f, -0.15181316f, -0.15654995f, -1.25605059f, -0.19032791f, -0.49628627f, 
    0.08951427f, 0.29800335f, 1.02469456f, 0.49764109f, 0.08358859f, -0.08220657f, -1.07657206f, -0.05208426f, 
    -0.28146577f, -0.11504168f, -1.15136337f, 0.57077861f, 0.16917647f, 0.70711881f, 0.02922469f, -0.38678733f, 
    0.18474717f, -0.29359704f, 0.31902999f, 0.14737207f, -0.10268186f, -0.57858503f, -0.64758658f, -0.00296101f, 
    -0.01603914f, -0.00654183f, 0.38782173f, -0.26884404f, 0.35582140f, -0.28132853f, -0.22238858f, 0.41598538f, 
    0.02174288f, -0.15903194f, -0.60183609f, 0.20030232f, -0.19099960f, -0.91550016f, -0.17203039f, -0.10367963f, 
    -0.71512908f, 0.04023530f, 0.04817727f, -0.27516657f, -0.27938882f, 0.18910162f, 0.24239174f, 0.25661811f, 
    -0.03544603f, 0.47880983f, -0.31347412f, -0.13391571f, -0.12314275f, 0.23528941f, 1.26222813f, -0.44229904f, 
    -0.02124150f, -0.31639966f, -0.15970059f, -0.14899009f, -0.12776144f, -0.35617736f, 0.22071753f, 0.18561994f, 
    0.02694403f, 0.47622281f, -0.39017597f, -0.85469246f, -0.04139335f, -0.06418502f, -0.22508779f, 0.89134985f, 
    -0.64515013f, 0.47627494f, -0.32603779f, -0.73512030f, 0.68513030f, 0.67952234f, -0.23660403f, -0.37602764f, 
    -0.18163145f, -0.29553974f, 0.07778397f, 0.17448808f, -0.09077549f, -0.33437872f, 0.69329804f, -0.34026471f, 
    0.86371434f, -0.43171692f, 0.05930997f, -0.29888338f, -0.63373619f, 0.68916512f, -0.20667541f, -0.33878055f, 
    0.02768705f, -1.10458493f, -0.25583860f, 0.53284097f, -0.04803573f, 0.30113000f, -0.27802220f, 0.39499936f, 
    1.02144217f, -0.00390148f, -0.08187548f, -0.38812843f, 0.18309312f, -0.26986709f, 0.17565231f, -0.04204018f, 
    0.07204363f, 0.79385459f, -0.56809843f, 0.16055706f, 0.05633463f, -0.25761762f, -0.16032639f, -0.13776360f, 
    -0.44227064f, 0.72781783f, 0.20165814f, 0.62934804f, -0.63506025f, -0.19171356f, 0.10233403f, -0.81439388f, 
    -0.07165106f, -0.23217635f, 0.66845560f, 0.19618221f, 0.02357712f, 0.05460402f, -0.16419117f, -0.16298218f, 
    -0.85935265f, -0.80673182f, -0.10247558f, 0.59609622f, 0.36017638f, -0.03915090f, 0.03604238f, -0.70371246f, 
    -0.12323835f, -0.29803020f, -0.09501514f, 0.12026342f, 0.12373307f, 0.30668738f, -0.47909555f, 0.43885827f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10923631f, 0.05570953f, -0.16002668f, -0.15413179f, 0.33057278f, 0.02567372f, 0.00888562f, -0.35385987f, 
    -0.64751923f, 0.09062924f, 0.26312858f, 0.01960230f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
