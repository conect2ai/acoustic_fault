#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.34661174f, -0.00983671f, -0.54882765f, -0.34749237f, -0.56019938f, 0.52337259f, 0.67098200f, 0.49999404f, 
    0.55302685f, 0.43459451f, 0.27103826f, 0.30393609f, -0.28470194f, -0.15838178f, 0.09777372f, 0.13974936f, 
    -0.19662666f, 0.08989943f, 0.11007972f, 0.20943052f, -0.00073995f, -0.05123379f, -0.12779713f, -0.09113011f, 
    -0.04906650f, 0.86179382f, -0.56162822f, 0.19478583f, -0.38143542f, 0.03773935f, 0.71533209f, -0.25117642f, 
    0.39812529f, 0.47462839f, -0.05416030f, -0.18243437f, -0.10185990f, -0.47040191f, 0.12640837f, 0.11862450f, 
    0.11260232f, 0.08620422f, -0.11903626f, -0.08757883f, -0.15968695f, 0.10333206f, 0.23569551f, 0.09385717f, 
    0.12126166f, -0.02225403f, -0.29674608f, 0.22548401f, 0.77953017f, 1.04572856f, -0.18110719f, 0.08795845f, 
    0.25564960f, 0.33760020f, 0.23749368f, 0.01556497f, 0.00028103f, -0.38803589f, -0.14688826f, 0.20763765f, 
    0.00376493f, -0.25484589f, 0.05440906f, 0.06673672f, -0.05274799f, 0.04515522f, -0.05662552f, 0.10211152f, 
    -0.15505946f, -0.00644649f, -0.33137769f, -0.83427835f, 0.17956947f, -0.61251765f, -0.59884077f, -0.05657567f, 
    -0.25481394f, 0.58051580f, 0.50369173f, -0.02958163f, 0.27173939f, -0.04643375f, -0.00866278f, 0.10147843f, 
    -0.18910900f, 0.33470652f, 0.05539983f, -0.06474161f, -0.04705194f, 0.04137801f, -0.38127625f, -0.06761134f, 
    0.21825211f, 0.09637052f, -0.05266210f, 0.00724321f, 0.55840188f, -0.08202678f, 0.38938230f, 0.49226218f, 
    0.52626467f, 0.09982053f, -0.31911132f, 0.37180865f, 0.14322415f, -0.42183971f, 0.27034852f, -0.09014108f, 
    -0.07753568f, -0.18018994f, 0.06356180f, 0.50413513f, 0.19016623f, -0.07740115f, 0.03000934f, 0.00382084f, 
    0.00876806f, -0.04234365f, 0.17367539f, -0.14597906f, 0.12075704f, -0.49339694f, -0.61853838f, -0.07655803f, 
    0.36738744f, 0.44218972f, -0.72636205f, 0.17388825f, 0.32777926f, -0.62759823f, 0.02735644f, 0.17485453f, 
    0.18530102f, 0.40613675f, 0.13246015f, 0.28505287f, -0.15997660f, 0.21950091f, 0.13091712f, 0.21501572f, 
    0.30323499f, 0.01771937f, -0.13085215f, -0.20158590f, -0.02334590f, 0.15748437f, 0.01174007f, -0.65071869f, 
    -0.71233189f, -0.15755734f, 0.23637058f, -0.25087050f, -0.61123043f, 0.03996395f, -0.20761998f, -0.09256446f, 
    -0.50307751f, 0.23253199f, -0.07893150f, -0.24862856f, -0.30428150f, 0.22448377f, -0.36543885f, -0.08902073f, 
    -0.16578844f, -0.02758361f, -0.29371649f, -0.29128790f, -0.00775636f, -0.00340374f, -0.10151907f, 0.61657292f, 
    0.80634123f, -0.07212599f, 0.52759272f, -0.61578035f, 0.03850894f, -0.05478270f, -0.35376656f, -0.39804593f, 
    0.31516504f, 0.22925192f, 0.42302620f, 0.39420441f, 0.04035012f, -0.07865854f, -0.12244561f, -0.06863781f, 
    0.39594829f, 0.27135178f, -0.14431046f, -0.08716914f, -0.01901401f, 0.16740161f, 0.07030936f, -0.08524567f, 
    -0.69195539f, -0.76360142f, -0.45943689f, 0.61004841f, 0.60284549f, 0.59610355f, 0.55536604f, -0.46257609f, 
    0.45231852f, -0.56237262f, -0.15419342f, 0.33267552f, -0.09715386f, 0.21913895f, -0.01922263f, 0.02124200f, 
    -0.01211860f, 0.13542125f, 0.03811687f, -0.05379510f, -0.06335465f, -0.01366795f, -0.04817820f, 0.01585113f, 
    -0.09703202f, 1.03753507f, 0.17573063f, -0.08297171f, -0.50412244f, 0.27456436f, -0.46806738f, -0.71258271f, 
    0.14727014f, -0.19379324f, 0.27101660f, -0.17109001f, -0.24594104f, 0.21192940f, -0.15426585f, -0.04845636f, 
    -0.17160013f, -0.12068302f, -0.21216761f, -0.04436802f, 0.03731405f, 0.06531599f, 0.23260415f, 0.07064349f, 
    0.09090981f, -0.10952534f, 0.81333297f, 0.56019652f, 0.07088386f, 0.53144884f, 0.58054686f, -0.43588954f, 
    -0.06339586f, -0.34737992f, 0.14168303f, 0.48597538f, -0.12032646f, -0.19608364f, -0.00315130f, 0.09704357f, 
    0.15157188f, 0.03303342f, 0.12394872f, 0.06206468f, -0.02711528f, 0.33462682f, -0.01972911f, -0.08186670f, 
    -0.10577416f, -0.26908037f, 0.03712177f, -0.34812239f, 0.50076050f, 0.40127662f, -0.32485715f, 0.10395806f, 
    -0.24732907f, 0.18943645f, -0.66366392f, -0.72243738f, -0.03259097f, 0.30704394f, 0.29703647f, 0.26552451f, 
    0.23220254f, 0.05246682f, -0.04825373f, -0.02815454f, 0.11395821f, 0.10483418f, 0.28578630f, 0.08285321f, 
    0.36481833f, 0.15819323f, 0.05965897f, 0.18060367f, 0.70794368f, 0.04065467f, -0.60732591f, -0.14530191f, 
    -0.62391269f, -0.23958607f, -0.47602269f, -0.38809124f, -0.15258557f, -0.55178469f, 0.12606117f, -0.03813307f, 
    0.34725842f, 0.18134046f, 0.05710177f, 0.13410023f, -0.08485366f, -0.23600402f, -0.00650595f, 0.15496109f, 
    0.00149033f, 0.02859436f, 0.04471097f, 0.05668373f, 0.25430253f, -1.13836837f, -0.30201542f, 0.00391637f, 
    -0.23659752f, -0.61213154f, 0.29113767f, -0.14553201f, 0.14404765f, -0.12609164f, 0.11139713f, -0.13426757f, 
    -0.02958874f, -0.09615703f, 0.27287734f, 0.16474049f, -0.28587282f, -0.12574024f, -0.12745208f, -0.02463524f, 
    -0.10138224f, 0.22365047f, 0.16062896f, 0.32609662f, 0.16278696f, 0.14506748f, -0.33138624f, -0.87259501f, 
    -0.44121498f, -0.30538526f, -0.05947378f, -0.56682974f, 0.69440168f, 0.55545717f, 0.15243287f, 0.04025263f, 
    -0.19490914f, -0.19546762f, -0.10436653f, -0.20523936f, -0.38936108f, -0.13791710f, 0.17112164f, 0.00356365f, 
    0.00002503f, -0.13371876f, 0.07877179f, 0.16720930f, -0.19343743f, -0.05507516f, -0.15933347f, 0.82136178f, 
    0.36719027f, 0.58710289f, 0.78020322f, 0.83220500f, 0.45951205f, 0.16525766f, -0.40858334f, 0.17733838f, 
    -0.08426278f, -0.09979025f, -0.01208683f, -0.23196794f, 0.21981128f, -0.41014501f, -0.11979458f, -0.17277046f, 
    -0.03094677f, 0.04540982f, -0.18122259f, -0.03364151f, 0.16404058f, -0.02416480f, 0.12232205f, 0.11775941f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02152704f, -0.17153625f, 0.09753036f, 0.10160836f, 0.06196929f, 0.10542447f, 0.28448641f, 0.07962520f, 
    0.29720399f, 0.21020281f, 0.26413640f, 0.25725397f, 0.22210293f, 0.06453039f, 0.13982247f, 0.07675110f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08083834f, 0.11574924f, 0.19483618f, 0.20359120f, 0.08066803f, 0.03510335f, -0.00889990f, 0.14848010f, 
    0.03272325f, 0.05740686f, -0.11684912f, 0.04569267f, 0.18582304f, 0.21586768f, -0.14696948f, -0.01682677f, 
    0.05835511f, -0.03196907f, 0.00480291f, -0.03919598f, 0.00805040f, -0.11120374f, -0.00366036f, 0.16642356f, 
    0.00177657f, 0.16806635f, -0.04391832f, 0.05747408f, -0.05907157f, 0.02545742f, -0.11498343f, 0.04340766f, 
    0.00760376f, 0.03522648f, -0.15595999f, 0.11162233f, 0.27866957f, -0.26457700f, -0.03235149f, 0.29851675f, 
    0.05602279f, -0.02559565f, -0.04708283f, 0.12465504f, 0.10543028f, 0.05715847f, 0.00950857f, 0.00880679f, 
    0.04929953f, 0.06167789f, -0.07353275f, 0.01435391f, 0.03709653f, -0.13136484f, -0.09398868f, 0.04404030f, 
    0.07430570f, -0.06814200f, -0.01504643f, 0.01722720f, 0.03072653f, -0.12581745f, -0.10069799f, -0.09626779f, 
    0.03856008f, -0.10222948f, -0.09251450f, -0.04019795f, 0.07553767f, 0.07590622f, 0.13956094f, -0.01599546f, 
    -0.11710878f, 0.05869651f, -0.01653564f, 0.12018052f, 0.08784632f, 0.21602231f, 0.02972163f, -0.02755341f, 
    -0.11865255f, 0.05422120f, 0.15994582f, 0.02178301f, -0.23314713f, -0.10362771f, -0.10394608f, -0.24408489f, 
    0.02112063f, -0.13910434f, 0.06484503f, -0.07952042f, 0.13182217f, -0.07251807f, 0.14964785f, -0.10202099f, 
    -0.13266242f, 0.06654573f, -0.10506632f, 0.05459380f, -0.00604103f, -0.01854727f, -0.14079769f, -0.07054922f, 
    -0.12142495f, 0.02517566f, 0.07201929f, 0.12975301f, -0.20012245f, 0.02257838f, -0.18317640f, 0.12857874f, 
    -0.01341530f, 0.00054515f, 0.15087494f, -0.09332193f, -0.00274319f, -0.01293159f, -0.06648190f, 0.06102725f, 
    0.00196311f, -0.15446734f, -0.01360449f, -0.00771704f, 0.01149794f, -0.11173183f, 0.07045554f, -0.01994061f, 
    -0.02872197f, 0.01878550f, 0.07194667f, 0.00503836f, -0.00093509f, -0.08613412f, -0.01667564f, -0.14044026f, 
    -0.02035390f, 0.02028251f, 0.00540899f, -0.01276845f, 0.01035504f, 0.04221768f, -0.02691871f, 0.06548731f, 
    -0.00607374f, 0.37050855f, -0.15535490f, -0.04242887f, -0.08338697f, 0.03316552f, 0.10105892f, 0.04897159f, 
    -0.12303394f, 0.11070343f, 0.03377628f, -0.07661662f, -0.28297293f, -0.04857348f, -0.04470425f, 0.13402677f, 
    0.06621173f, -0.08814394f, -0.03470881f, 0.06159359f, 0.04081723f, -0.14373991f, -0.01266720f, -0.00698321f, 
    0.30414525f, -0.21598963f, 0.07143863f, 0.20186253f, 0.08622027f, 0.02894240f, -0.06232873f, 0.12597470f, 
    0.02517338f, 0.13544227f, -0.06826485f, 0.00674443f, -0.03601226f, 0.38850856f, 0.00886896f, 0.01751552f, 
    0.16738839f, 0.11578708f, -0.01529963f, -0.00232013f, -0.03641046f, -0.01129963f, -0.04685555f, -0.07690004f, 
    -0.01987287f, -0.05907420f, -0.00974282f, -0.04298565f, -0.00133634f, 0.02408127f, 0.00897289f, 0.02911897f, 
    -0.03444410f, -0.02955114f, -0.00025141f, -0.05729935f, -0.03309504f, -0.04285552f, 0.03625761f, -0.07270623f, 
    0.04571525f, -0.06394477f, -0.01631640f, 0.02456560f, -0.03065040f, -0.04456148f, -0.03861785f, 0.03189721f, 
    -0.02190243f, -0.02686951f, -0.03620220f, -0.07516720f, 0.04980201f, -0.02572476f, -0.06926218f, -0.01081384f, 
    -0.06395968f, 0.04544448f, -0.01062386f, 0.02513673f, 0.01674403f, -0.00662416f, -0.07291882f, 0.02863840f, 
    -0.07171284f, 0.05304978f, -0.01007417f, 0.03002491f, 0.01816178f, 0.01161885f, -0.00117676f, -0.06191695f, 
    -0.07734542f, -0.03555214f, 0.00427140f, 0.05314751f, 0.00180448f, 0.00702679f, -0.04949446f, 0.02581481f, 
    0.01862366f, 0.00613184f, -0.02965227f, -0.06146564f, -0.05650840f, 0.03267768f, -0.07245420f, -0.04288967f, 
    -0.05502483f, 0.02065067f, -0.06567780f, -0.03451737f, -0.05807029f, -0.02898815f, 0.01210559f, 0.04663356f, 
    0.06280567f, -0.00872683f, -0.02384871f, 0.03018118f, 0.00626475f, -0.02770485f, -0.08139307f, -0.00526875f, 
    -0.03260274f, 0.02087932f, -0.00357996f, -0.03560150f, 0.02295361f, 0.02389008f, 0.02815500f, 0.05105201f, 
    -0.02488253f, -0.02956301f, -0.00252014f, 0.03827110f, 0.02452165f, -0.04004503f, 0.04145832f, -0.05618212f, 
    -0.06325085f, -0.03046022f, 0.02177222f, -0.00872189f, -0.06292703f, -0.06582601f, -0.02962409f, -0.06536206f, 
    0.05089260f, 0.04250751f, -0.04918180f, 0.01757247f, 0.02436246f, 0.03212426f, -0.03257937f, 0.07725690f, 
    -0.02720591f, -0.01852442f, -0.06009534f, -0.06813800f, 0.00437260f, 0.02414578f, 0.00407924f, 0.04924000f, 
    -0.03498061f, 0.05409067f, -0.04564287f, -0.04327449f, -0.02919870f, -0.02041596f, -0.02214088f, -0.07117156f, 
    -0.02273086f, 0.03026683f, -0.03466522f, 0.02325564f, -0.04687902f, 0.00713304f, 0.02442208f, -0.03355312f, 
    0.03022875f, 0.05173051f, -0.03161646f, 0.05206472f, 0.04226274f, -0.01580763f, -0.07150524f, 0.01971226f, 
    -0.01977067f, -0.03613791f, -0.01424413f, -0.06020334f, 0.02476910f, 0.05354489f, 0.01521594f, -0.01242600f, 
    0.06401626f, -0.05757678f, -0.01213546f, -0.03618942f, -0.00491144f, -0.00386431f, -0.03992454f, 0.04636539f, 
    0.05001035f, -0.05472886f, 0.03210710f, 0.05923469f, 0.04711942f, 0.00034849f, -0.06698990f, -0.02134758f, 
    -0.05368852f, 0.00353876f, 0.00538723f, -0.04318215f, -0.04026032f, -0.05894452f, -0.00096571f, 0.01957489f, 
    0.01260499f, -0.05093978f, 0.03359622f, -0.03427927f, 0.05407264f, 0.01380924f, 0.02056502f, -0.02624306f, 
    0.01475233f, 0.02720495f, -0.05012134f, -0.01257153f, -0.00562798f, 0.06019265f, 0.00502944f, 0.03416498f, 
    0.09466098f, -0.07091358f, -0.18054274f, -0.06945298f, 0.05726278f, -0.09355218f, -0.06972914f, -0.09507135f, 
    -0.04451031f, 0.04829975f, -0.19186780f, 0.10575693f, -0.05006748f, -0.26457646f, 0.08520970f, -0.04141624f, 
    0.00205643f, -0.12235201f, -0.04735181f, -0.01617681f, 0.13143158f, 0.03158270f, -0.02615058f, -0.05782978f, 
    -0.09776184f, 0.02934454f, 0.10896238f, -0.10496922f, 0.07488130f, -0.17762013f, -0.08820152f, 0.01124525f, 
    -0.03479066f, 0.04670470f, 0.10484528f, -0.19337027f, -0.24393663f, 0.06102723f, -0.15446055f, -0.21480961f, 
    0.11375338f, 0.00591326f, -0.00062811f, 0.02920523f, 0.01208400f, 0.10097174f, 0.06749452f, 0.08217871f, 
    -0.21723253f, -0.04792838f, 0.12037559f, 0.13028307f, 0.09964842f, 0.08185970f, -0.05580058f, -0.04899064f, 
    -0.05552899f, 0.16977078f, -0.04426468f, 0.18082605f, -0.21958394f, 0.05239192f, -0.07796656f, 0.00591576f, 
    0.14431059f, 0.01966091f, -0.06847594f, -0.02068036f, -0.03939201f, 0.06078383f, 0.10376521f, 0.15867424f, 
    0.05466862f, -0.05678433f, -0.03999270f, -0.18120471f, 0.06070536f, 0.00790864f, 0.10143345f, -0.03682770f, 
    -0.04826363f, -0.06698539f, 0.08955764f, 0.05320055f, 0.25939685f, 0.02216680f, -0.01655551f, 0.14498538f, 
    0.06558450f, -0.11308897f, 0.17162831f, 0.09175465f, 0.08819240f, -0.05877804f, 0.13115016f, 0.10036933f, 
    0.05233150f, 0.08375432f, -0.01347481f, -0.01181809f, 0.06364068f, 0.05699813f, 0.02407210f, -0.02234624f, 
    -0.05065358f, 0.03801345f, 0.08692668f, 0.04018108f, 0.05847926f, 0.07557765f, 0.20831639f, 0.07973375f, 
    0.01074398f, -0.01604594f, 0.09740324f, -0.05004299f, 0.16188413f, 0.01188361f, 0.00691294f, -0.03003430f, 
    0.19162540f, -0.08382911f, -0.11936760f, -0.02414031f, -0.01080631f, -0.02819360f, -0.10853398f, -0.07921617f, 
    0.08277921f, 0.04101295f, 0.09254706f, 0.04351727f, 0.03782634f, 0.13107547f, -0.12198567f, 0.18264808f, 
    0.02168058f, -0.10058574f, 0.06493729f, -0.03356814f, 0.06605107f, 0.21906528f, 0.21220896f, 0.13601273f, 
    0.16968384f, -0.18350832f, 0.03133610f, 0.04250208f, 0.01065688f, -0.03743220f, 0.01174513f, 0.15590681f, 
    0.02554800f, 0.12618642f, 0.08277003f, 0.04914795f, -0.30465496f, 0.01753727f, -0.13746694f, 0.09805762f, 
    -0.03689595f, 0.08425785f, 0.15934923f, -0.01267338f, -0.00560646f, -0.02109054f, -0.00618475f, -0.11799014f, 
    -0.15224059f, 0.04828081f, -0.12311406f, -0.18770388f, 0.14912605f, -0.02429306f, -0.01086379f, -0.01153667f, 
    0.07069727f, 0.04316517f, -0.11082403f, -0.15346171f, 0.10292666f, -0.26222682f, 0.17562839f, 0.09346377f, 
    -0.16090345f, 0.13508967f, -0.02059479f, -0.08990455f, 0.14829949f, -0.12457020f, 0.09658987f, -0.01202788f, 
    0.20047840f, 0.04183596f, -0.07461977f, -0.09464820f, -0.01838528f, -0.06371063f, -0.06168352f, -0.06347755f, 
    0.00189691f, 0.10715952f, -0.00632309f, 0.11211985f, -0.08160367f, -0.19062537f, 0.18503946f, -0.00096034f, 
    0.01357944f, 0.00200330f, -0.00844038f, -0.09313915f, 0.14986862f, 0.02993284f, -0.08775323f, -0.10389632f, 
    -0.25676855f, 0.11077905f, -0.05158125f, 0.06456278f, -0.03594773f, 0.00203701f, 0.01836627f, 0.13667804f, 
    -0.12782364f, 0.01648021f, 0.02464714f, -0.08659104f, -0.12245855f, 0.17074735f, -0.06963047f, -0.17450176f, 
    0.13015614f, -0.04605319f, 0.14175585f, -0.06694147f, 0.18294238f, -0.14881815f, -0.05175265f, 0.11178140f, 
    0.03879371f, -0.04268655f, 0.14089563f, 0.22017829f, 0.00306924f, -0.02092312f, 0.02029865f, -0.10644531f, 
    0.07381741f, -0.05634640f, -0.04421490f, 0.10941695f, -0.16712390f, 0.00806903f, -0.03023537f, 0.10712525f, 
    -0.01044646f, -0.03565511f, -0.04188159f, -0.01506162f, -0.06694402f, 0.17298150f, 0.05999429f, 0.12455285f, 
    0.00152402f, -0.19657171f, 0.11620983f, 0.08517448f, 0.09863103f, 0.06594764f, 0.06968484f, -0.10530411f, 
    0.07626890f, -0.06707245f, -0.04203450f, -0.02315129f, -0.08010014f, -0.03001414f, -0.05545571f, 0.15367262f, 
    -0.15433590f, 0.02362975f, 0.10032959f, 0.06689311f, 0.04759416f, -0.23652303f, 0.06933357f, 0.08075915f, 
    -0.33711761f, 0.13371333f, -0.10969879f, -0.30953589f, 0.00760724f, 0.10557592f, 0.02151792f, 0.00104284f, 
    -0.06557462f, -0.08196107f, 0.03406515f, -0.00563524f, 0.06480227f, -0.24859898f, 0.17770472f, -0.14737603f, 
    -0.02412908f, -0.03365619f, -0.06484393f, 0.02386540f, -0.02210941f, 0.01230701f, 0.00897861f, -0.13290721f, 
    0.14232852f, -0.25627252f, -0.04925561f, 0.21696930f, -0.20482737f, -0.05524023f, -0.09159694f, -0.02103048f, 
    0.01917278f, 0.08013162f, 0.15354826f, 0.10305911f, -0.30419376f, 0.16932391f, 0.29154134f, 0.14800847f, 
    0.01934809f, -0.08644088f, 0.08543263f, 0.03367362f, 0.03187320f, 0.01359197f, 0.11684676f, 0.05161132f, 
    0.05276899f, -0.00018348f, 0.12211962f, 0.03992683f, -0.07117423f, 0.00504706f, 0.10948616f, 0.12673533f, 
    0.08263356f, 0.03884955f, 0.14128073f, 0.10689250f, 0.08888675f, 0.05270297f, 0.07023438f, -0.03827267f, 
    0.13580583f, 0.05733532f, 0.08531481f, 0.01058023f, -0.01665521f, -0.05949908f, -0.08527938f, -0.05371130f, 
    -0.14007534f, 0.19621348f, -0.02619614f, 0.04718607f, 0.06019791f, 0.00889223f, 0.03425233f, 0.16501939f, 
    -0.00761777f, -0.02866863f, -0.07250638f, -0.13386136f, 0.11097128f, -0.09217785f, 0.18465433f, 0.45590818f, 
    -0.02813228f, 0.10167087f, -0.01649198f, 0.14963971f, 0.03811375f, -0.06476533f, 0.14933784f, 0.06606412f, 
    0.01006871f, -0.01068919f, 0.01835623f, 0.03398376f, 0.03420440f, -0.04557413f, 0.02375059f, 0.04232216f, 
    0.04320767f, 0.01902459f, 0.05950277f, -0.06427214f, -0.07213053f, 0.06478111f, 0.01048066f, -0.07028183f, 
    -0.01844138f, -0.03341747f, -0.05392958f, -0.04202773f, -0.06653048f, -0.07627242f, 0.02176883f, -0.03484486f, 
    0.00572838f, 0.00058721f, -0.06068015f, -0.07421505f, -0.00179450f, -0.05756005f, -0.03914769f, -0.07659234f, 
    -0.05862185f, -0.05685307f, -0.05276717f, -0.02757414f, 0.03493679f, 0.00407862f, -0.07358900f, 0.04658328f, 
    -0.04757581f, 0.03535978f, 0.02519925f, -0.03323949f, 0.05646167f, 0.00789229f, 0.00779550f, -0.00680379f, 
    0.05826034f, 0.05906622f, -0.05648083f, -0.01008856f, 0.04272804f, -0.05093743f, 0.00774485f, 0.02510026f, 
    -0.00082460f, 0.04174571f, 0.05895995f, 0.01663036f, 0.00981778f, -0.07272010f, -0.05826536f, -0.04721301f, 
    -0.01711987f, -0.01740448f, 0.02239036f, -0.00803722f, -0.05413558f, -0.04990121f, -0.04549003f, -0.06932472f, 
    -0.06538419f, 0.01774386f, 0.05738905f, -0.05849628f, 0.03876162f, 0.00919394f, 0.00484198f, 0.05720524f, 
    -0.06797836f, -0.05009316f, -0.02648943f, -0.04964417f, -0.06177497f, 0.03680635f, -0.03342092f, -0.04651084f, 
    0.02408348f, -0.02673328f, -0.01671829f, 0.06033558f, -0.02378591f, -0.06751971f, -0.03989537f, -0.04159473f, 
    -0.01311737f, -0.03577894f, -0.05663989f, -0.04350915f, -0.06013558f, 0.01462229f, 0.05724553f, 0.06119175f, 
    -0.07152102f, -0.00152167f, -0.03547394f, -0.06507862f, 0.00078611f, -0.07447556f, 0.02732616f, -0.05420605f, 
    -0.05856247f, -0.02088582f, -0.01504284f, -0.03166699f, 0.04352773f, 0.01673926f, 0.04737141f, -0.06192023f, 
    -0.01337235f, 0.02169272f, -0.01606629f, -0.00313023f, 0.02081671f, 0.05455154f, 0.01809189f, -0.05354792f, 
    0.01332336f, -0.05168217f, -0.07472061f, -0.04755417f, 0.02615874f, -0.03775726f, 0.00488938f, -0.02452628f, 
    0.01783957f, -0.04228060f, -0.05112900f, 0.01547732f, 0.03655873f, -0.00857480f, -0.04235074f, 0.06374887f, 
    -0.00969874f, -0.01383950f, 0.04425664f, 0.05245214f, -0.06975748f, -0.03925326f, -0.00698736f, 0.05653898f, 
    -0.04510465f, 0.05218654f, 0.06567245f, -0.00766185f, 0.00004607f, 0.06590683f, -0.03672753f, 0.00352348f, 
    0.00453401f, 0.06030536f, 0.01745592f, -0.02168215f, -0.07240764f, 0.06415968f, 0.03666067f, -0.01183193f, 
    -0.00296655f, -0.04759333f, -0.01296946f, -0.05715230f, 0.01383278f, -0.02270648f, 0.00141070f, 0.02216745f, 
    -0.06383184f, -0.06551623f, 0.06275543f, 0.01422776f, 0.03537006f, -0.06426356f, -0.00901341f, 0.06564257f, 
    -0.03724563f, -0.01396025f, 0.00167597f, -0.01668831f, 0.05485330f, 0.06375334f, -0.01512759f, -0.06367491f, 
    0.24035513f, -0.12063604f, 0.02861971f, -0.15923114f, 0.02400281f, -0.16948441f, -0.02111251f, -0.00650560f, 
    -0.06280129f, -0.08898263f, -0.06621324f, 0.09281170f, 0.36919764f, 0.20918277f, -0.01796230f, 0.01343620f, 
    0.03721002f, -0.05493869f, -0.07592893f, 0.11304758f, 0.13622710f, -0.13398680f, -0.06778207f, 0.08956245f, 
    -0.10162064f, 0.32825336f, 0.01054604f, 0.26327485f, -0.07280169f, 0.02870778f, 0.05735195f, 0.07028867f, 
    -0.00440369f, 0.06842040f, 0.17753799f, 0.01365774f, 0.04291654f, -0.11899378f, -0.07537665f, -0.06306128f, 
    0.11965415f, -0.05756622f, -0.06706273f, 0.17587933f, 0.16403683f, 0.12689872f, 0.05253116f, 0.09430681f, 
    0.06876355f, 0.11543868f, -0.02132912f, 0.27778533f, 0.00920565f, 0.03315261f, 0.11125714f, -0.11815695f, 
    0.03044444f, -0.04281351f, -0.07173709f, 0.08079864f, -0.01863756f, -0.10076393f, -0.09012169f, -0.04522711f, 
    0.08886768f, 0.02716602f, 0.04317501f, -0.17224781f, -0.06326514f, -0.01951218f, 0.12673700f, -0.02041689f, 
    -0.20782688f, -0.08172255f, -0.06748662f, -0.03384674f, -0.01429772f, 0.04437606f, 0.01539003f, -0.06529437f, 
    0.00887276f, 0.04449209f, 0.04217707f, 0.00716492f, 0.30145991f, 0.17151009f, -0.04406282f, -0.02517954f, 
    -0.07837928f, 0.02481489f, 0.14485270f, 0.05678571f, -0.00080296f, -0.16194063f, 0.11993633f, 0.01741090f, 
    -0.08863909f, -0.04125811f, -0.16331482f, 0.01866971f, 0.07165284f, 0.11044843f, -0.03024021f, -0.06602953f, 
    0.01502027f, 0.15737921f, 0.02412063f, 0.01004566f, 0.21189092f, 0.21206489f, 0.04999048f, -0.03841309f, 
    0.09730657f, -0.11433624f, 0.13925545f, 0.03220365f, -0.04075325f, -0.00603527f, 0.07258078f, -0.02194608f, 
    0.37573975f, -0.11604666f, 0.03189275f, -0.17533419f, -0.11394326f, -0.03420793f, 0.06429598f, -0.01282662f, 
    -0.07565895f, -0.01940827f, -0.02785735f, 0.14566681f, -0.12005308f, 0.08477504f, 0.12665784f, 0.00075832f, 
    -0.06646973f, 0.04467557f, -0.02179945f, 0.03428959f, 0.00767715f, 0.12540661f, 0.00749614f, 0.07260233f, 
    0.08737194f, 0.06774285f, 0.09492636f, -0.02697136f, 0.03364670f, -0.00350984f, 0.07350768f, 0.11960295f, 
    -0.02511689f, -0.01612586f, -0.01180540f, -0.03648434f, -0.29745907f, -0.09784899f, 0.03269423f, 0.04865524f, 
    -0.00116739f, -0.05749239f, 0.01015140f, -0.09116866f, 0.07650053f, -0.07164866f, 0.12514104f, 0.02299181f, 
    0.01930219f, -0.05410831f, -0.30301669f, 0.14315265f, 0.10527296f, 0.02962571f, -0.03834824f, 0.07274161f, 
    0.13218610f, 0.12620449f, -0.11797701f, -0.08631109f, 0.20718186f, -0.02337801f, 0.07902251f, 0.13429379f, 
    0.12011420f, -0.01450106f, 0.01931780f, -0.06420524f, 0.05158635f, -0.06093022f, -0.00653116f, -0.07028893f, 
    0.11389325f, 0.00336848f, 0.36596948f, -0.00351306f, 0.09484323f, 0.06742407f, 0.08455312f, 0.23018385f, 
    0.03925696f, 0.08214019f, -0.05110909f, -0.02832543f, 0.20843726f, 0.06312598f, 0.09573401f, -0.12976290f, 
    0.19426005f, 0.10176102f, -0.02658257f, -0.09472796f, 0.00494711f, -0.11536053f, 0.00363558f, 0.13977930f, 
    -0.17636953f, 0.24637900f, -0.10168433f, 0.10448218f, 0.02808467f, 0.18391047f, 0.06943491f, -0.04016274f, 
    -0.13043076f, -0.06198774f, 0.01751607f, 0.15581132f, 0.41759086f, -0.05444011f, -0.02223985f, 0.11879884f, 
    -0.06473424f, 0.06791398f, -0.04301202f, 0.12346095f, -0.01501484f, -0.01893900f, 0.04216323f, -0.06533629f, 
    0.18022300f, 0.00821103f, -0.04574001f, 0.13901585f, 0.02366092f, -0.07172790f, -0.00606230f, 0.08930879f, 
    0.05837991f, -0.02630720f, -0.08795986f, 0.01062660f, 0.09448611f, 0.00231869f, -0.06663463f, 0.07517780f, 
    0.10070810f, -0.12118852f, -0.11024460f, -0.02799967f, -0.00749199f, 0.06436177f, 0.02886437f, -0.05300670f, 
    0.00193012f, -0.03533045f, 0.07304271f, 0.12316276f, -0.04835824f, 0.00327717f, -0.14082403f, 0.03000900f, 
    0.01504852f, -0.01785660f, 0.04498467f, 0.03553597f, -0.20780770f, -0.28116956f, -0.04701106f, -0.17959437f, 
    -0.03373642f, -0.09698161f, 0.05710058f, -0.10878789f, 0.04761776f, -0.03979166f, 0.06978144f, -0.05871574f, 
    0.21802890f, -0.02175255f, -0.41646352f, 0.18477324f, 0.06404853f, 0.00732976f, -0.02174393f, 0.13832200f, 
    -0.06230871f, 0.04328963f, 0.00614099f, 0.07717405f, 0.05627833f, -0.17111552f, 0.00978808f, 0.10295578f, 
    0.01574475f, 0.00249141f, 0.17740956f, -0.01309283f, -0.07482903f, 0.08263420f, -0.07836536f, 0.14203247f, 
    0.16138630f, -0.19956712f, -0.11115168f, 0.22135338f, -0.00647568f, -0.12448120f, 0.04958284f, -0.00010767f, 
    0.01382983f, -0.03884370f, 0.04518708f, -0.01531730f, -0.16130693f, -0.02098328f, 0.08029675f, -0.25041166f, 
    -0.07125705f, -0.00672790f, -0.03616367f, -0.08829618f, 0.08443712f, 0.08561255f, 0.03435939f, -0.04594161f, 
    0.04871755f, 0.04287770f, 0.07066771f, -0.21991515f, 0.01360113f, 0.01996298f, 0.09604822f, 0.04810069f, 
    -0.11962879f, 0.15414450f, -0.08011395f, -0.05040254f, -0.14546123f, 0.06683446f, -0.03761160f, 0.02238306f, 
    -0.01785992f, -0.01314881f, -0.09862182f, -0.08050098f, 0.02737324f, -0.04734122f, -0.07395380f, 0.04565659f, 
    0.14566490f, -0.10817780f, 0.11899810f, 0.28675592f, -0.05369324f, -0.00666834f, -0.02211588f, 0.08868232f, 
    0.05856445f, 0.01031919f, 0.05094564f, -0.02216091f, 0.07025300f, 0.14480434f, -0.03407233f, 0.09449790f, 
    0.08838670f, 0.04359808f, -0.07822616f, 0.10759251f, -0.04468381f, 0.04715531f, -0.03513546f, -0.12185701f, 
    -0.08096099f, 0.07149791f, -0.05330407f, 0.00813959f, 0.11750015f, 0.07321235f, 0.06921504f, 0.06902032f, 
    -0.01178078f, -0.04192586f, -0.01012251f, 0.01187134f, -0.01953421f, -0.05467845f, -0.23003030f, 0.04654561f, 
    -0.10256524f, -0.07501872f, 0.10901815f, -0.00636535f, -0.13323273f, 0.04319718f, -0.01127294f, -0.12605971f, 
    0.11216985f, -0.18966724f, 0.19076599f, -0.29602185f, 0.11422557f, -0.04561969f, -0.08813804f, 0.00236918f, 
    0.14770998f, 0.07601626f, -0.09477652f, 0.04339687f, -0.17447469f, -0.01290036f, 0.06676905f, 0.05014422f, 
    -0.05248989f, 0.12765628f, -0.00870727f, 0.02583603f, -0.09476621f, 0.12677462f, 0.03766828f, 0.02538227f, 
    -0.12287348f, -0.04341722f, -0.00698331f, -0.21237937f, 0.07407688f, 0.00313020f, -0.09061895f, -0.03322263f, 
    -0.06215548f, -0.01301548f, 0.09050526f, 0.03129569f, -0.14159445f, 0.06855329f, -0.06645057f, -0.25725976f, 
    0.02199754f, -0.00186877f, 0.06943055f, 0.04707159f, 0.10813770f, -0.07342950f, 0.05902614f, -0.02728503f, 
    0.18366672f, 0.31687841f, -0.04663561f, 0.03375767f, 0.13106821f, -0.10252266f, -0.03016075f, -0.00377668f, 
    0.02037922f, 0.03953582f, -0.00160093f, 0.09633847f, -0.00319671f, 0.02554864f, -0.00684774f, 0.03375328f, 
    0.13554160f, -0.04057391f, 0.04996913f, 0.06835447f, -0.02019819f, 0.09118694f, 0.07244833f, -0.01455323f, 
    0.08056820f, 0.14534876f, 0.25964737f, 0.01605621f, -0.01411410f, -0.00407255f, 0.05329358f, 0.01755403f, 
    0.07515531f, 0.02626983f, 0.09062664f, 0.02628622f, -0.07184024f, 0.25156280f, -0.16696629f, 0.29094958f, 
    -0.12477393f, -0.06378250f, 0.07967346f, -0.10579956f, 0.09091363f, -0.04086888f, 0.00693762f, 0.06412093f, 
    -0.25505477f, 0.25386137f, 0.08988325f, -0.24659866f, 0.15463445f, 0.04840602f, 0.04709388f, -0.00196802f, 
    0.10302131f, -0.03695513f, -0.01116592f, 0.01730872f, 0.30684853f, -0.02614915f, -0.23986822f, 0.11954905f, 
    0.00707527f, -0.03468716f, -0.03320965f, 0.08762623f, -0.03599546f, -0.04572592f, -0.01180430f, 0.01985039f, 
    0.12626952f, 0.08842072f, -0.07866155f, 0.26767701f, 0.02395518f, -0.08113517f, -0.17440583f, -0.01928804f, 
    0.00844494f, 0.06891823f, -0.03314354f, 0.01820816f, -0.18475285f, 0.06568696f, -0.04544745f, 0.22344489f, 
    0.06716212f, -0.01778307f, 0.11527579f, 0.04742075f, -0.02678552f, 0.03326126f, -0.02943617f, 0.00220843f, 
    0.12185948f, -0.02126149f, 0.10186805f, -0.07364937f, 0.13259207f, 0.09196220f, -0.00821462f, -0.03233117f, 
    -0.04642605f, 0.04633654f, 0.01220548f, 0.04609586f, -0.19398725f, 0.13826889f, -0.15469913f, -0.38279462f, 
    -0.08323798f, 0.00625396f, 0.06000198f, -0.12336840f, 0.06184058f, -0.07751394f, -0.03546639f, -0.01137258f, 
    0.04336229f, 0.00150680f, -0.05562386f, -0.06676891f, -0.06898167f, 0.00478699f, -0.07839131f, -0.03724865f, 
    -0.05517421f, -0.05659202f, 0.04559714f, 0.00730086f, -0.05229782f, 0.00118961f, 0.00029887f, -0.06118933f, 
    -0.06906810f, -0.05368026f, -0.07331002f, 0.02139568f, -0.01148500f, -0.08006828f, 0.00006562f, 0.01529769f, 
    -0.04234962f, -0.07383141f, -0.02208203f, -0.07642458f, -0.00563440f, -0.06997848f, -0.07965547f, 0.00363829f, 
    0.02686456f, -0.07701545f, -0.04486184f, -0.00611261f, -0.01442415f, -0.00096808f, 0.05198544f, 0.00929315f, 
    -0.05547788f, 0.04461008f, -0.07162292f, -0.01559671f, -0.07833771f, -0.04205196f, 0.05643322f, -0.07751977f, 
    0.02142005f, -0.04421016f, 0.05861369f, 0.03208704f, -0.04464057f, -0.00225736f, -0.05382553f, 0.02606400f, 
    0.01192756f, -0.03193719f, -0.03362085f, 0.00377074f, 0.03026947f, -0.00581139f, 0.02852245f, -0.04884573f, 
    -0.02830749f, -0.06717926f, 0.06026388f, 0.04371174f, -0.07329264f, 0.04175390f, 0.05523580f, 0.04251624f, 
    -0.03780371f, -0.05794955f, -0.05973781f, -0.05091405f, -0.07682110f, -0.04542679f, -0.07227663f, 0.03236216f, 
    -0.01061376f, 0.00338976f, 0.03042578f, 0.00178146f, -0.00902611f, 0.04026871f, -0.01422508f, -0.05213076f, 
    -0.00151549f, 0.04706565f, -0.08026624f, -0.01176783f, -0.00819724f, 0.00345891f, -0.04035534f, -0.05893584f, 
    -0.05619999f, 0.06039939f, 0.05969809f, -0.07219396f, -0.06291101f, -0.05524776f, 0.06015807f, -0.05577661f, 
    0.02197704f, -0.00592152f, 0.03207485f, 0.05294010f, 0.04044862f, 0.06002408f, 0.01929763f, -0.04427619f, 
    -0.02311580f, 0.05641457f, -0.03307136f, -0.00713919f, 0.04133903f, 0.03515906f, -0.05586853f, -0.06746592f, 
    -0.03954095f, -0.04267147f, 0.00926824f, 0.05669006f, -0.04520633f, 0.04790090f, -0.07877167f, 0.02809914f, 
    0.02280342f, 0.02102993f, 0.01068559f, 0.05827339f, 0.05961969f, -0.06580182f, -0.05760994f, -0.02380155f, 
    -0.06271801f, -0.05212506f, 0.03738418f, -0.04130189f, -0.06098575f, -0.01241345f, -0.04710397f, 0.03695527f, 
    -0.03332460f, -0.00094696f, -0.01753734f, -0.06614199f, -0.06178464f, -0.05334155f, 0.03265220f, 0.05449146f, 
    -0.00237615f, 0.00656370f, 0.04699429f, 0.05590089f, 0.02920393f, -0.03186375f, 0.04962245f, 0.06538808f, 
    -0.07133261f, -0.03422781f, -0.00701407f, 0.00310865f, 0.03208241f, -0.04917511f, -0.03958952f, 0.05804645f, 
    -0.05521007f, 0.02408247f, 0.05396376f, -0.04729593f, 0.05607769f, -0.07490536f, 0.01836603f, 0.05117971f, 
    0.05073662f, -0.06005343f, 0.02574967f, 0.04844562f, -0.00763438f, 0.03112882f, 0.01594605f, 0.02954344f, 
    -0.04574519f, 0.01057816f, -0.04112466f, 0.03022098f, 0.05986606f, -0.06221519f, 0.04179296f, -0.05585986f, 
    -0.08171535f, -0.03580907f, -0.05365852f, 0.01861122f, 0.05438197f, 0.08348949f, 0.06574067f, -0.01722342f, 
    0.04078982f, 0.05259022f, -0.00535756f, -0.00872777f, 0.36247581f, 0.08008027f, -0.00913688f, -0.14654884f, 
    -0.12570672f, 0.01045083f, -0.13658562f, 0.05442740f, 0.05395324f, -0.13076389f, 0.07001630f, -0.02392954f, 
    0.37168208f, -0.09467825f, -0.03397116f, 0.26607230f, 0.00701732f, -0.15076713f, 0.01565580f, -0.11852989f, 
    -0.00093286f, 0.05212467f, 0.12801962f, 0.06945424f, -0.06709671f, 0.13085259f, 0.02197150f, -0.06421665f, 
    -0.03298273f, 0.07665682f, -0.05094484f, 0.10663313f, -0.05207640f, 0.00194593f, 0.04532469f, -0.03644569f, 
    0.09656131f, -0.04761216f, 0.11423515f, 0.01030177f, -0.15621057f, 0.04850254f, 0.05771282f, 0.01184159f, 
    -0.01482344f, 0.17489690f, -0.02510821f, -0.17608896f, -0.21680151f, -0.02489534f, 0.31814513f, 0.03812441f, 
    -0.10507639f, 0.06930932f, 0.14654841f, -0.10578305f, 0.09478901f, -0.03440201f, 0.06443775f, -0.08806876f, 
    -0.15132095f, 0.09789485f, 0.13155836f, -0.13408509f, -0.06531578f, -0.01458241f, -0.02430164f, 0.04028390f, 
    0.03098567f, 0.04158527f, -0.04183685f, 0.06316964f, 0.31085461f, 0.06246346f, -0.21051259f, 0.08676021f, 
    0.04149433f, 0.00982173f, -0.21634810f, -0.00905500f, -0.01784337f, 0.06425068f, -0.06455311f, -0.01263527f, 
    0.14056724f, -0.28740472f, -0.03207982f, 0.18123533f, 0.00028973f, -0.01232521f, 0.00033735f, -0.00616200f, 
    -0.01012904f, 0.11016648f, 0.04858446f, 0.02299259f, 0.13692921f, 0.16779491f, -0.25417376f, -0.12467806f, 
    0.04074467f, 0.23339468f, -0.14783356f, 0.06794775f, 0.11270517f, 0.00606997f, 0.01114422f, 0.16868739f, 
    0.06210927f, 0.22897317f, -0.11288334f, 0.06275741f, 0.08017188f, 0.05532922f, -0.01562968f, -0.01091061f, 
    0.07135815f, -0.11836813f, -0.07568881f, -0.09881052f, 0.10805649f, -0.04029820f, -0.08560664f, -0.16927239f, 
    0.10527102f, 0.08869205f, -0.03055549f, 0.00919273f, 0.03621412f, -0.06109693f, -0.04990447f, -0.15320675f, 
    0.20955786f, -0.08894205f, -0.22454031f, -0.16390282f, 0.02603969f, 0.05945588f, -0.02173958f, 0.04451043f, 
    -0.02839768f, 0.02614918f, -0.06067661f, 0.01107537f, -0.02780228f, 0.05795909f, 0.26409677f, -0.08254684f, 
    -0.18731448f, -0.01055344f, 0.05098001f, -0.09310330f, -0.07270659f, -0.07174306f, -0.08634353f, 0.10476682f, 
    -0.10882591f, -0.02227433f, 0.07871885f, -0.12128557f, -0.00867526f, -0.00421516f, 0.03702422f, -0.02040119f, 
    0.05408896f, 0.04534144f, 0.06861297f, 0.15068859f, 0.14401779f, 0.03785029f, 0.00885529f, 0.00049154f, 
    -0.02865287f, -0.04388050f, 0.00808992f, 0.04856913f, -0.09539274f, 0.02523885f, 0.03387263f, 0.02650084f, 
    0.09527006f, -0.26822111f, -0.18636870f, -0.06319086f, 0.07319894f, -0.07024553f, -0.12332363f, -0.11061211f, 
    -0.12037392f, 0.04634533f, -0.11008235f, 0.14862970f, 0.04195491f, -0.09831347f, 0.02128926f, -0.06073573f, 
    -0.08986729f, -0.06754673f, -0.02361899f, 0.04568616f, 0.05639053f, 0.06633426f, -0.00333821f, -0.04704876f, 
    0.09694070f, 0.06679139f, 0.05359147f, -0.02986390f, 0.07410055f, -0.22050203f, -0.01903334f, 0.09118982f, 
    -0.04955748f, 0.05923023f, 0.14025630f, -0.09892968f, -0.23018563f, 0.00690317f, -0.08550889f, -0.12526546f, 
    -0.03939616f, 0.02746473f, 0.01496828f, 0.12756723f, -0.08912518f, 0.10654257f, -0.02077428f, 0.02455710f, 
    0.00912522f, -0.13083361f, 0.11426722f, -0.01665732f, 0.15144090f, 0.01653246f, 0.03497263f, -0.07831167f, 
    -0.09641096f, 0.18455742f, -0.03578926f, 0.10513896f, -0.19912291f, 0.12703007f, 0.09062380f, -0.01044601f, 
    0.14069718f, 0.06869117f, 0.07563996f, 0.01197832f, 0.05604170f, -0.01200569f, 0.11088872f, 0.00249704f, 
    -0.09749690f, 0.03606610f, -0.14036395f, -0.17774063f, -0.00946676f, -0.00219577f, 0.09708247f, 0.02308095f, 
    0.00783606f, -0.02812066f, 0.05703845f, 0.05908775f, 0.34540007f, 0.06351601f, 0.06005897f, 0.22499283f, 
    0.11004178f, -0.04182552f, 0.10480858f, 0.00358346f, 0.02897631f, -0.04620248f, 0.06294138f, 0.11715778f, 
    0.31410134f, -0.06559562f, -0.06125799f, 0.20600611f, 0.11428005f, 0.08537006f, 0.03314379f, 0.04507251f, 
    0.05353390f, 0.13694030f, 0.01178309f, 0.02518881f, 0.04746243f, 0.11953394f, 0.01922503f, 0.13060115f, 
    0.02381364f, 0.06914444f, 0.07291467f, -0.00663174f, 0.10888038f, 0.08982795f, 0.01579951f, 0.04444409f, 
    0.10369526f, 0.13301486f, -0.10070637f, -0.16093484f, 0.07536547f, -0.04822124f, 0.01736850f, -0.05934476f, 
    0.00399872f, 0.06012454f, 0.05971800f, 0.08759167f, -0.07260815f, 0.01983804f, -0.04207240f, 0.03993402f, 
    -0.00444717f, 0.01346977f, -0.05184770f, 0.07946572f, 0.04812866f, 0.01538380f, 0.01574996f, -0.01343681f, 
    0.18680900f, -0.23851433f, -0.04491550f, 0.02128615f, 0.06277823f, 0.06974935f, 0.04998613f, 0.13934976f, 
    0.08878652f, 0.09112646f, -0.08339529f, 0.00524706f, -0.28239614f, -0.03480001f, -0.02883990f, 0.12938951f, 
    -0.19659793f, -0.07957935f, 0.09396449f, -0.03562699f, 0.05457720f, -0.00219535f, 0.10457888f, 0.01050947f, 
    0.02757408f, -0.09932107f, -0.16936232f, -0.03143142f, 0.00990348f, -0.05713219f, -0.02820551f, 0.03028251f, 
    0.04229909f, 0.04511637f, -0.04155677f, 0.00592347f, -0.05440914f, -0.25185442f, 0.22550930f, -0.03008980f, 
    -0.08201954f, 0.01615240f, 0.01703113f, 0.02213147f, 0.03787557f, 0.01665602f, 0.03371650f, -0.02563915f, 
    0.10185033f, -0.13483196f, -0.16984707f, -0.14667511f, 0.14420772f, -0.01958498f, 0.01160535f, -0.13785279f, 
    0.07409718f, 0.01487808f, 0.10588036f, -0.04078082f, 0.51169306f, 0.10985730f, -0.03402421f, 0.13355657f, 
    -0.02978394f, -0.04883763f, -0.01227866f, 0.04519221f, 0.03020939f, -0.01077708f, 0.09591354f, 0.10361663f, 
    0.18682387f, 0.15994669f, 0.18081033f, 0.27714029f, -0.03708220f, 0.02582831f, 0.04294027f, 0.05396473f, 
    0.15326712f, -0.12563053f, 0.08756339f, -0.00756085f, -0.01399356f, -0.22122785f, -0.00904105f, -0.19878186f, 
    0.10173154f, 0.10031953f, 0.02341357f, 0.07792405f, 0.10647540f, -0.06706972f, 0.01906639f, 0.08256086f, 
    0.16229770f, 0.10860749f, -0.00253083f, 0.09808283f, 0.02071236f, -0.00103293f, 0.13055621f, -0.05616323f, 
    0.07151680f, -0.00146596f, 0.05002249f, -0.00200895f, 0.12610708f, -0.14566872f, -0.19197178f, -0.11050722f, 
    0.10162431f, -0.04493199f, 0.03708166f, -0.01050165f, 0.11874734f, -0.06277204f, 0.07874609f, 0.01297754f, 
    -0.00733884f, -0.10850706f, 0.03451697f, -0.18596108f, -0.08087730f, 0.12597926f, 0.11618390f, -0.03733353f, 
    0.09221782f, 0.08996796f, 0.05503587f, 0.08067483f, 0.14074534f, 0.36922956f, 0.27878687f, -0.11991648f, 
    -0.16080363f, 0.10865754f, -0.01909682f, 0.01924529f, 0.05609137f, -0.05090606f, -0.01791654f, -0.07011671f, 
    -0.39050555f, 0.02603797f, -0.05332191f, 0.03901619f, 0.06527676f, 0.16199088f, -0.00801204f, -0.07238088f, 
    0.08978441f, 0.01430834f, -0.08753483f, 0.00173970f, 0.14497504f, 0.04298664f, 0.18182725f, -0.08525135f, 
    0.11862870f, -0.02000976f, -0.05701187f, 0.10111134f, -0.09529988f, -0.10670359f, 0.12395120f, -0.06411044f, 
    0.21442716f, 0.24115190f, 0.18138227f, -0.27292645f, -0.20997205f, -0.07804907f, 0.05571137f, 0.01019797f, 
    -0.10448442f, -0.00114196f, 0.08485612f, 0.02183858f, -0.13107379f, -0.05327514f, 0.05129400f, -0.06612795f, 
    -0.05789100f, 0.00481363f, -0.00063960f, 0.07392475f, -0.03294215f, -0.07511689f, -0.10891019f, -0.01396933f, 
    -0.10674724f, -0.00877642f, 0.05680525f, 0.25910345f, 0.07064436f, -0.05312149f, 0.03068059f, 0.12094107f, 
    -0.05430862f, -0.12595233f, 0.03111818f, 0.03447950f, -0.24091353f, 0.04817428f, -0.13396074f, 0.11772931f, 
    0.11110458f, -0.02122187f, 0.05044552f, -0.04324432f, 0.05613203f, 0.02328473f, 0.00590146f, -0.03774442f, 
    0.18829149f, -0.17068465f, -0.12506074f, -0.07760231f, 0.15648216f, 0.00895552f, 0.03758443f, 0.02551491f, 
    0.09134097f, -0.04972263f, -0.00767928f, 0.09209550f, 0.04386619f, 0.26471785f, 0.14455631f, 0.01048499f, 
    -0.02223837f, -0.06070905f, 0.07950887f, 0.07233191f, -0.05088248f, 0.04937835f, -0.10520729f, 0.03702712f, 
    -0.04871502f, 0.07844920f, 0.07909694f, 0.06880958f, 0.28028038f, 0.20211899f, 0.11705549f, 0.09586759f, 
    -0.12364198f, -0.08264452f, -0.04642025f, -0.12705684f, 0.22434981f, 0.21682794f, -0.00522759f, -0.14843951f, 
    0.17330767f, -0.12408034f, 0.17367564f, 0.15700413f, 0.18077654f, -0.12614264f, 0.11134630f, 0.09292852f, 
    0.21536012f, 0.18850695f, 0.04584963f, 0.18058603f, 0.05989278f, 0.09579339f, -0.09495286f, 0.06610429f, 
    0.15326945f, 0.04612526f, 0.04132823f, 0.11884054f, 0.09440710f, -0.39548448f, -0.18411712f, 0.01277344f, 
    0.09358938f, 0.09514121f, 0.03917233f, 0.10806530f, 0.04558906f, -0.07639641f, 0.01377026f, -0.04216523f, 
    0.24920644f, 0.33878931f, 0.09909577f, 0.13109049f, 0.16773655f, -0.06428193f, -0.06113191f, 0.04378765f, 
    0.10502650f, -0.02966025f, 0.00994566f, -0.03355358f, -0.10006725f, -0.00722418f, -0.30593377f, -0.08890726f, 
    0.24696609f, -0.10656083f, -0.01795875f, 0.07891852f, 0.11008298f, -0.08620891f, 0.07979123f, 0.02940302f, 
    -0.36647391f, -0.06714411f, -0.20096239f, -0.05419001f, 0.16633579f, -0.03743026f, 0.11772934f, -0.03606424f, 
    0.05639742f, 0.02647924f, 0.15028048f, 0.17308903f, 0.10378815f, 0.23675402f, 0.21341684f, -0.18536821f, 
    0.06513495f, 0.05123730f, 0.04944601f, -0.04259497f, 0.10048819f, -0.02368191f, 0.08966742f, -0.04404371f, 
    -0.31287816f, 0.03536540f, 0.03971827f, -0.07417670f, 0.06432424f, -0.01617796f, -0.03034555f, -0.06406499f, 
    0.06944823f, 0.09913253f, -0.09713538f, 0.14366254f, -0.03327339f, 0.05345858f, 0.06741147f, 0.03918970f, 
    0.02137812f, -0.00873798f, 0.00215214f, 0.01467909f, -0.02024643f, -0.00701484f, 0.06336188f, 0.02135108f, 
    0.19837822f, -0.02626369f, 0.26448080f, 0.11750814f, 0.01395767f, 0.00541481f, 0.04134826f, 0.04981777f, 
    0.13528578f, -0.00669133f, 0.08322292f, 0.03540469f, -0.05755913f, -0.15059741f, -0.02551929f, 0.01351419f, 
    -0.12007633f, 0.08378637f, 0.08050559f, -0.09774654f, -0.04781356f, -0.02224760f, -0.02246135f, 0.05982495f, 
    -0.27857012f, 0.37932652f, 0.04672469f, 0.09381763f, 0.01033203f, -0.11286003f, -0.06602808f, -0.08728111f, 
    -0.05689939f, -0.10930245f, 0.12448753f, -0.01359540f, -0.41194317f, -0.36680394f, -0.21426678f, -0.14465983f, 
    0.17095396f, 0.14512777f, -0.22173698f, -0.08137501f, -0.10486811f, -0.14986406f, -0.02637797f, 0.01656526f, 
    -0.38016438f, 0.00823360f, -0.13046233f, 0.03271266f, 0.10953747f, 0.06637231f, -0.02893044f, 0.07213687f, 
    -0.02597605f, -0.12761104f, 0.12687549f, 0.06239988f, 0.30212530f, 0.43000421f, 0.05751349f, 0.10632139f, 
    0.24462505f, -0.05899624f, -0.02231690f, -0.02986343f, 0.01099857f, 0.09986182f, -0.08953690f, 0.00336325f, 
    0.20438428f, -0.22306690f, -0.10636078f, -0.12975352f, -0.16229695f, -0.19456761f, 0.03221209f, -0.11986325f, 
    0.02819384f, 0.04894469f, -0.04858725f, -0.18026440f, -0.23321518f, -0.11702805f, 0.09592198f, 0.06639018f, 
    -0.00864214f, 0.00224458f, 0.05718064f, -0.06677181f, 0.13190167f, 0.00899411f, -0.12797965f, -0.13294296f, 
    0.19635467f, 0.03733426f, 0.17038287f, -0.30861887f, 0.01162002f, -0.08457147f, -0.00054366f, 0.12215587f, 
    0.08455387f, 0.17182140f, 0.14001442f, -0.24222033f, -0.36669171f, 0.14853245f, -0.14104730f, -0.02996144f, 
    0.04420425f, 0.20568860f, 0.15909898f, -0.01540993f, -0.01238141f, -0.03290269f, 0.06011056f, 0.14998482f, 
    0.06261176f, 0.08773406f, 0.17168501f, 0.05505924f, 0.02701645f, 0.11907293f, 0.00124365f, -0.22172299f, 
    0.04151074f, -0.00040541f, -0.07205386f, -0.06733687f, 0.09681469f, -0.13294974f, 0.08244880f, -0.19436169f, 
    0.07225627f, 0.15275595f, -0.06788049f, -0.11160587f, -0.14258997f, -0.15735763f, 0.03563196f, -0.04052646f, 
    0.10160590f, 0.02782386f, 0.11407533f, -0.15862878f, -0.07799744f, 0.09993093f, 0.07427862f, 0.10322850f, 
    0.03899328f, 0.11770311f, 0.03631791f, 0.04425277f, 0.20875841f, 0.08156852f, 0.26187849f, 0.27645814f, 
    0.05365797f, -0.07852235f, 0.03844841f, 0.00792061f, 0.03675083f, -0.02683368f, -0.04821013f, 0.04240886f, 
    0.04171212f, -0.07634537f, -0.07164416f, -0.17042555f, 0.05541037f, 0.06507354f, -0.01628833f, -0.03568717f, 
    -0.03773304f, 0.16006958f, 0.06561075f, 0.02993836f, -0.03495673f, -0.07784872f, -0.02079543f, 0.04669672f, 
    0.01658711f, -0.07983324f, 0.04204526f, -0.02434760f, 0.06979556f, 0.04804745f, 0.01907195f, 0.00454909f, 
    0.16452804f, 0.33543944f, 0.01121980f, -0.16611642f, -0.06995675f, 0.04395505f, 0.08121364f, -0.06394645f, 
    -0.04126010f, -0.12953784f, -0.06552633f, -0.03849774f, 0.14212793f, -0.07117690f, 0.03455984f, 0.21382178f, 
    0.03833800f, -0.03313202f, -0.02545027f, 0.07594449f, -0.05406066f, -0.05654429f, 0.01179551f, -0.08927591f, 
    0.20911072f, -0.34559682f, -0.17813855f, 0.13313232f, 0.02190495f, -0.15285379f, 0.05526628f, 0.12880895f, 
    0.04516494f, 0.01797196f, 0.15348437f, 0.02192786f, 0.00798154f, 0.16202323f, -0.09026788f, -0.01529594f, 
    -0.11262654f, 0.05837199f, 0.16936280f, 0.09413674f, -0.07091435f, 0.05577853f, -0.03271098f, 0.14361179f, 
    0.21480103f, -0.00409508f, -0.09379467f, -0.04641454f, -0.04143547f, 0.01479830f, 0.00964967f, -0.02703393f, 
    0.00407100f, 0.16314197f, -0.00319978f, -0.01959487f, 0.09331191f, -0.19668347f, 0.32462978f, -0.14050877f, 
    -0.15488319f, -0.04860928f, 0.01040724f, -0.06297003f, 0.10714263f, 0.03388017f, 0.02353127f, 0.06994116f, 
    0.19834578f, 0.10239306f, 0.08946297f, 0.06720821f, -0.12651126f, -0.06866810f, 0.07929788f, 0.05371530f, 
    -0.06215793f, 0.06400621f, 0.00700937f, -0.00255702f, -0.05383218f, -0.12505549f, 0.31498906f, -0.12479825f, 
    0.01181161f, 0.04857638f, -0.08012988f, -0.05097619f, -0.09899442f, 0.00805351f, -0.00474430f, -0.03023204f, 
    0.02673211f, -0.00229194f, -0.06919060f, 0.12158504f, 0.07894616f, -0.09137699f, 0.00298170f, -0.12494653f, 
    -0.09226478f, 0.05649424f, 0.03238642f, -0.04783724f, 0.05865439f, 0.38781458f, 0.07862877f, -0.00429816f, 
    0.06441018f, -0.00646765f, -0.06729888f, -0.03804060f, -0.00793138f, -0.02963579f, 0.06382844f, -0.03515321f, 
    -0.06510095f, -0.10810671f, 0.03765621f, 0.10601803f, -0.11089576f, 0.12590410f, 0.02880317f, 0.00725728f, 
    0.02595523f, 0.02175921f, 0.07944658f, -0.04667251f, 0.02333832f, 0.05991258f, 0.29892251f, 0.34998316f, 
    -0.01388347f, 0.06037455f, -0.03182673f, 0.01666449f, -0.04643862f, -0.00054887f, -0.00079109f, 0.03881058f, 
    -0.00753645f, -0.05914797f, 0.17366217f, -0.17186956f, 0.00887923f, -0.10124967f, 0.03147584f, -0.00673737f, 
    0.13052075f, -0.04635419f, -0.02476184f, -0.01892107f, 0.19573066f, -0.09242142f, -0.03131832f, 0.22595011f, 
    0.05874343f, -0.07432888f, -0.18097569f, -0.06368937f, -0.01349787f, 0.06398874f, 0.07843748f, 0.10964770f, 
    0.20645155f, -0.23739299f, 0.06068685f, -0.09718487f, -0.07689162f, -0.01447819f, 0.05326438f, -0.03339840f, 
    -0.06439735f, -0.07013418f, 0.04132541f, 0.05936399f, -0.02646257f, 0.07266184f, -0.08886421f, -0.14510423f, 
    0.02695602f, -0.01062765f, -0.05279820f, 0.11548376f, 0.06549285f, 0.03602497f, -0.03488522f, 0.04627193f, 
    0.15636039f, -0.04482139f, -0.30901685f, 0.30403617f, 0.05960651f, -0.01024861f, 0.02241034f, 0.04897281f, 
    0.00767647f, -0.02601404f, 0.01963731f, -0.00414933f, 0.03492007f, 0.13475199f, 0.07602542f, 0.07893307f, 
    -0.00282460f, 0.06775723f, 0.02208867f, -0.05488945f, 0.06162278f, -0.00011946f, 0.13441752f, -0.03626440f, 
    0.05666889f, -0.14559600f, -0.15204795f, -0.15941586f, -0.00397071f, 0.03293858f, 0.00553985f, 0.04119741f, 
    0.04093868f, 0.12651800f, 0.00233824f, 0.05493006f, 0.30501992f, 0.04730368f, 0.27799645f, -0.13153093f, 
    0.02935147f, 0.05077749f, -0.10168191f, 0.00590818f, 0.13637999f, 0.02873925f, 0.01440588f, 0.01836346f, 
    -0.10418920f, 0.37754554f, 0.15676843f, -0.03094982f, -0.03333640f, -0.01660821f, 0.03113135f, -0.00323541f, 
    0.05369916f, -0.05761796f, -0.05856113f, -0.02066009f, 0.29895544f, -0.21963434f, 0.02487156f, 0.38594866f, 
    -0.05714676f, -0.05839527f, -0.00150625f, 0.04295589f, 0.02856467f, 0.07901657f, 0.16850720f, -0.03035702f, 
    0.29781708f, 0.21076365f, -0.05643418f, -0.05008195f, -0.06409036f, 0.04614679f, -0.08107719f, -0.11005078f, 
    0.02616023f, -0.00053856f, -0.22476141f, 0.11419364f, 0.28398323f, -0.02468589f, 0.04169356f, -0.04595790f, 
    -0.11706981f, 0.07202532f, -0.15449716f, -0.11403491f, -0.03205347f, 0.11324763f, -0.04501772f, -0.04417938f, 
    -0.06305870f, -0.06101758f, 0.04608454f, 0.20694692f, -0.02268549f, -0.18080516f, -0.08795802f, -0.05118134f, 
    -0.01447514f, -0.08339868f, 0.15418482f, -0.15503515f, 0.14882250f, 0.14761527f, 0.10921799f, -0.08490221f, 
    0.14918466f, 0.22244748f, -0.03657457f, -0.07274801f, -0.13126765f, 0.04222295f, -0.08722522f, 0.02196366f, 
    -0.09635030f, -0.09510902f, -0.11832336f, 0.04902973f, -0.02266239f, 0.01851928f, -0.06912685f, -0.03144765f, 
    0.06603715f, -0.06476429f, -0.03797178f, 0.13707246f, -0.06968596f, 0.03860812f, 0.16171464f, -0.12595472f, 
    0.02302223f, 0.00881432f, 0.03900845f, -0.08299095f, -0.07403971f, 0.04958926f, 0.08423546f, 0.03888559f, 
    0.33665356f, 0.00575524f, -0.00436346f, 0.05380859f, 0.05228136f, 0.03193820f, 0.03778887f, -0.06166761f, 
    -0.22649916f, -0.01264853f, 0.09806721f, -0.03322173f, -0.04729684f, 0.02866338f, -0.15471710f, 0.12815268f, 
    0.17442615f, -0.08561271f, 0.01163517f, 0.01459584f, 0.04673263f, -0.08290540f, 0.04795530f, 0.07984368f, 
    0.00433549f, 0.23495527f, 0.08480863f, 0.14658418f, 0.11229240f, -0.02694698f, 0.17589931f, -0.07386728f, 
    -0.16729976f, -0.09325426f, 0.08898740f, -0.13663968f, 0.19430095f, 0.25459674f, -0.13688982f, 0.00059159f, 
    0.04323898f, -0.23438951f, -0.04384626f, -0.06222273f, 0.01856298f, 0.07718373f, 0.01840129f, -0.09596421f, 
    -0.00269969f, -0.10366291f, -0.06184632f, 0.06815328f, -0.08491014f, -0.14177936f, -0.10789908f, -0.01878973f, 
    -0.13470039f, 0.14924651f, -0.09423969f, -0.02967886f, 0.27452075f, 0.12156644f, -0.04681777f, 0.14422204f, 
    -0.04787074f, -0.14966770f, 0.02519115f, -0.03573722f, -0.05342941f, 0.14229907f, 0.03491521f, -0.00290092f, 
    0.24195427f, 0.03060470f, 0.02337314f, 0.02889641f, -0.13759966f, -0.02217961f, -0.04599715f, -0.01299836f, 
    -0.05971197f, 0.07899867f, -0.18858135f, 0.04678316f, 0.04703530f, 0.12088811f, 0.06847127f, 0.16535127f, 
    0.14505471f, -0.10256298f, 0.15929997f, -0.13526198f, 0.05899573f, 0.00777018f, 0.12917584f, 0.15152296f, 
    0.38829064f, 0.15419728f, 0.08360358f, 0.00867278f, 0.15529349f, 0.06718878f, -0.00058124f, 0.08233209f, 
    0.09942225f, 0.01395992f, -0.14547442f, -0.20859468f, -0.13271962f, -0.30301967f, -0.11304741f, 0.19190468f, 
    -0.16772078f, -0.05411046f, -0.02039802f, -0.08189296f, 0.14657483f, -0.04364556f, -0.12363219f, -0.02637020f, 
    0.02392299f, 0.00458969f, 0.03284538f, -0.02774603f, 0.05216969f, -0.01978655f, -0.00224333f, -0.03955751f, 
    0.04791218f, -0.00052406f, -0.00250169f, 0.05149656f, -0.03257481f, 0.05716695f, 0.03083321f, 0.04669136f, 
    -0.07656908f, -0.05254180f, 0.01088789f, -0.06511842f, 0.02494165f, 0.03837277f, -0.01333736f, 0.04887773f, 
    -0.03047037f, 0.03809145f, 0.04880824f, -0.00914814f, -0.02584573f, 0.01198932f, 0.03246072f, 0.03005446f, 
    -0.02886550f, 0.02850022f, 0.00593036f, -0.01248172f, -0.04702210f, 0.00983710f, -0.01739114f, -0.07668661f, 
    -0.05839926f, 0.04385239f, 0.01194797f, -0.07220704f, 0.00853266f, 0.02597960f, 0.03115656f, -0.05666857f, 
    0.02891066f, 0.06042937f, 0.02279641f, -0.05547605f, 0.00658084f, -0.06360304f, 0.02313264f, 0.00478443f, 
    0.04890772f, 0.03800035f, -0.06184375f, -0.00293756f, 0.05883356f, -0.03287387f, 0.04248942f, 0.01897237f, 
    -0.05276226f, 0.00189651f, -0.00550629f, -0.06585310f, 0.00471080f, 0.02086947f, 0.03558467f, -0.03741609f, 
    0.02837016f, -0.01425888f, -0.05643081f, 0.05007796f, 0.00372883f, 0.04323964f, -0.00060658f, -0.02880218f, 
    0.02057101f, 0.01238935f, -0.02231918f, 0.00507205f, -0.00265759f, 0.02946627f, -0.00373283f, 0.03356419f, 
    -0.02043749f, -0.04702547f, -0.04668268f, 0.01596300f, -0.01793700f, 0.03116675f, 0.02271132f, -0.04586622f, 
    -0.07754335f, -0.03731454f, 0.02611414f, 0.00597378f, 0.03388906f, -0.03595722f, -0.04639197f, 0.02368960f, 
    0.04687912f, -0.02588951f, -0.00705292f, -0.03655829f, -0.04324736f, -0.07206887f, 0.06496447f, 0.02413437f, 
    -0.05848020f, -0.07575933f, 0.04637798f, 0.01956704f, -0.00237688f, -0.06489485f, -0.05178475f, -0.06154152f, 
    -0.06808006f, -0.02687875f, -0.02927157f, -0.00092520f, -0.07463229f, -0.04062899f, 0.05229884f, -0.06948963f, 
    -0.03669417f, -0.06845956f, -0.05893373f, -0.01691302f, 0.03088363f, -0.04813338f, -0.03601684f, -0.05977702f, 
    -0.00498172f, -0.07250638f, 0.06265859f, -0.07896801f, 0.05099535f, 0.04090682f, 0.02728623f, 0.05929143f, 
    -0.02454547f, -0.02768147f, -0.04005757f, -0.01506209f, -0.05018502f, -0.01774613f, 0.00704611f, 0.02067266f, 
    -0.07889924f, -0.04989054f, 0.05860082f, 0.00612299f, -0.02612440f, 0.02469830f, -0.07341391f, 0.03436704f, 
    -0.03573667f, 0.05455104f, 0.02084726f, -0.06279578f, 0.03827933f, -0.05741392f, 0.00752662f, 0.02527142f, 
    -0.04077812f, 0.00005763f, 0.03746844f, 0.05369817f, 0.01270956f, 0.00121083f, -0.07277668f, -0.00951655f, 
    0.01559357f, -0.00185733f, -0.06117013f, -0.06548958f, 0.01497926f, -0.04744773f, 0.00606695f, 0.05524664f, 
    -0.05260741f, 0.04056925f, -0.02315570f, -0.01031197f, -0.02158302f, -0.04217521f, -0.08016670f, -0.06219298f, 
    0.07676488f, 0.09938040f, 0.23376782f, -0.13701987f, 0.03856974f, -0.07905012f, 0.00906312f, 0.20925413f, 
    0.01366924f, -0.00409287f, -0.04819045f, 0.09861334f, 0.13708587f, 0.23309337f, 0.03300122f, 0.06353156f, 
    0.12221070f, -0.08305139f, 0.13905063f, 0.02640693f, 0.22061728f, -0.14084974f, 0.00970703f, 0.16620761f, 
    -0.20261326f, 0.35009989f, -0.07656898f, 0.11335666f, -0.01839824f, 0.16374415f, 0.13882917f, 0.08137799f, 
    0.05066890f, 0.07309034f, -0.06673098f, 0.00956167f, 0.05031092f, -0.28984880f, -0.19713973f, 0.03862727f, 
    -0.01021740f, -0.03492884f, 0.03901678f, 0.18812832f, 0.05067793f, 0.02611516f, 0.15047036f, -0.00593788f, 
    0.22025079f, 0.22606455f, -0.02494534f, 0.15980947f, 0.11621103f, -0.05100656f, 0.04139735f, 0.03438976f, 
    0.21527916f, -0.04311763f, -0.01509725f, 0.18617265f, 0.01755449f, -0.21970117f, -0.29779249f, -0.11990233f, 
    -0.00344811f, -0.09779532f, -0.13160479f, -0.12073338f, -0.04624373f, 0.03133325f, 0.05639928f, -0.03879601f, 
    -0.26373854f, -0.28778052f, -0.08968061f, 0.24012582f, 0.10196477f, 0.20544578f, -0.05649535f, 0.00344960f, 
    0.12441964f, 0.02683539f, 0.08038658f, 0.05825664f, -0.20173232f, 0.05626857f, 0.14178140f, -0.16993664f, 
    -0.23142110f, -0.02517687f, 0.25680828f, -0.00343193f, -0.06810303f, -0.07162236f, 0.14127606f, -0.08030433f, 
    -0.19842787f, -0.01361013f, -0.22934306f, -0.07715479f, 0.04919226f, 0.07133479f, -0.08273484f, -0.05774506f, 
    -0.00835231f, 0.04615542f, 0.01467391f, 0.03993210f, -0.10390598f, -0.22518103f, 0.15026201f, 0.13768692f, 
    0.01515529f, -0.14232440f, 0.11215553f, 0.02114759f, -0.01048499f, -0.06422576f, 0.01436076f, 0.08468873f, 
    0.21190830f, -0.25634065f, 0.05876379f, 0.01909321f, 0.00681265f, -0.05320528f, 0.02225502f, 0.04173709f, 
    -0.12093085f, 0.05766567f, 0.11483336f, 0.14329711f, -0.21836701f, -0.01312657f, 0.27551827f, -0.01894316f, 
    -0.13188043f, 0.03500082f, -0.00135476f, 0.01994515f, -0.05616741f, 0.09689996f, 0.00295781f, 0.07669896f, 
    -0.29335278f, 0.08534768f, 0.35951218f, 0.01947555f, -0.02302342f, -0.05225769f, 0.11758378f, -0.08030588f, 
    -0.15437955f, -0.02286610f, 0.08781710f, 0.04357883f, -0.34017792f, -0.03312006f, -0.28334817f, -0.06369048f, 
    0.18744105f, -0.07608110f, -0.05070212f, -0.00556392f, 0.02367402f, -0.04717677f, -0.03822602f, 0.06000780f, 
    -0.04397485f, -0.20085022f, -0.22404680f, 0.19481124f, 0.07677976f, -0.03574974f, -0.00712770f, 0.26088977f, 
    0.02789214f, -0.04392011f, 0.01458525f, -0.13529934f, 0.22131637f, 0.32922488f, 0.15477453f, 0.07309183f, 
    0.07962326f, 0.03483882f, -0.02572373f, 0.07349458f, -0.01072278f, 0.07017395f, -0.04169884f, -0.04388825f, 
    0.05630185f, -0.02868239f, 0.03728393f, -0.02723132f, -0.01937366f, -0.03267250f, -0.04346713f, -0.03293258f, 
    -0.02982167f, -0.02002073f, -0.01550945f, -0.02934874f, -0.08373289f, -0.04287775f, -0.08678314f, -0.07652529f, 
    -0.04960546f, 0.04595852f, 0.01265643f, -0.00908699f, 0.05604085f, 0.03102451f, -0.04171492f, -0.02468353f, 
    0.04033222f, -0.03966181f, 0.01152294f, 0.03487922f, -0.04350870f, 0.00884580f, 0.02282099f, 0.02273887f, 
    -0.05742139f, 0.03838400f, 0.00244617f, -0.02744355f, 0.03863908f, 0.04065161f, 0.01442732f, 0.03301650f, 
    -0.07880881f, -0.02400734f, -0.03345659f, 0.05181509f, 0.02632813f, 0.03956066f, 0.02639244f, -0.00326691f, 
    -0.01928801f, -0.07193103f, -0.01455766f, 0.05005446f, 0.05269431f, 0.01272431f, -0.01201355f, -0.07273329f, 
    -0.01902400f, -0.03580838f, -0.05503266f, 0.01418551f, -0.06122746f, -0.05394994f, 0.01272512f, -0.07202512f, 
    -0.05160378f, 0.00478847f, 0.04128755f, 0.03863248f, 0.04823125f, -0.04313270f, -0.01093619f, -0.04743086f, 
    0.03399400f, 0.01487827f, -0.07300583f, -0.05341828f, -0.04300703f, -0.05234943f, 0.01304341f, -0.06197138f, 
    0.05072382f, -0.07388860f, -0.02911754f, -0.05536376f, -0.04806013f, -0.01016855f, 0.04552810f, 0.05069315f, 
    -0.01470462f, -0.02773590f, -0.04409211f, 0.05606872f, 0.03453325f, 0.02089416f, 0.04116714f, -0.01112580f, 
    0.03556813f, 0.01205830f, 0.05768560f, -0.07452058f, -0.00970701f, -0.03322532f, -0.04915665f, 0.00671512f, 
    0.03641173f, 0.04851349f, -0.07523809f, -0.08735988f, -0.05028586f, 0.04140199f, 0.00152565f, -0.05907749f, 
    -0.05195059f, -0.06335709f, 0.05446289f, -0.06127835f, -0.03407747f, 0.04704764f, -0.06288461f, -0.06091801f, 
    0.00397207f, 0.04485548f, -0.04553684f, -0.06591720f, -0.00574847f, -0.06083259f, 0.05582908f, -0.02820983f, 
    -0.01669686f, -0.05533571f, 0.03692976f, -0.06641033f, 0.03133355f, -0.01688221f, 0.01777722f, 0.04397216f, 
    0.05675491f, 0.04398433f, -0.02703660f, 0.04505856f, 0.04446801f, 0.05658817f, -0.05416162f, 0.05477351f, 
    -0.03869233f, -0.01333628f, 0.05950117f, 0.04173019f, -0.03418205f, -0.05194847f, 0.03098144f, -0.07690487f, 
    0.02227942f, 0.01058469f, -0.01490107f, -0.00462062f, -0.06286320f, -0.02029471f, -0.01194571f, -0.01864969f, 
    0.00095222f, 0.00067045f, -0.06673179f, -0.02468066f, 0.01611130f, -0.06882694f, -0.00882141f, 0.02202092f, 
    -0.06160153f, 0.05955875f, -0.02730915f, 0.05865445f, -0.00119830f, -0.06332492f, -0.02277427f, 0.02650386f, 
    -0.02046413f, -0.04747356f, -0.08036389f, 0.00940357f, -0.08287107f, 0.03654755f, -0.00030199f, -0.03935630f, 
    -0.06679241f, 0.00756964f, -0.07475103f, 0.01757973f, -0.02377598f, 0.04967050f, -0.05505341f, -0.06990416f, 
    0.04850619f, -0.01418514f, -0.05832179f, -0.26294571f, -0.05007626f, -0.01803604f, 0.20781401f, 0.16219863f, 
    -0.04773290f, -0.09501639f, 0.07186529f, -0.21510442f, 0.10060838f, 0.02752041f, -0.09750813f, 0.05455932f, 
    0.08841344f, -0.03236781f, 0.06465398f, 0.05859676f, -0.08839495f, 0.08798921f, 0.05501987f, 0.04824351f, 
    0.02116657f, -0.02657879f, -0.12988311f, 0.03261014f, -0.06039050f, 0.02984533f, -0.01170348f, -0.21566403f, 
    0.06073563f, -0.01569987f, 0.10422721f, 0.07765112f, 0.34955135f, 0.05118098f, -0.00642828f, 0.09412384f, 
    -0.08070325f, 0.11716244f, 0.03898480f, 0.06117679f, -0.08780706f, -0.06458833f, 0.01225990f, 0.01382987f, 
    -0.08452637f, 0.01234795f, -0.19837444f, -0.08737370f, 0.00148092f, -0.14719996f, 0.00831714f, -0.02305811f, 
    0.06916565f, -0.07588678f, 0.00141043f, -0.19615006f, 0.37618759f, 0.20151332f, -0.16949400f, 0.11212657f, 
    -0.04287678f, 0.08620721f, 0.20392157f, 0.01553518f, 0.05928199f, -0.10120188f, -0.11942370f, -0.06917118f, 
    0.25057092f, 0.01178194f, 0.01791178f, 0.05075395f, -0.02318392f, -0.07446656f, -0.04139085f, 0.16729996f, 
    0.06529865f, 0.18321897f, 0.02169096f, -0.09905760f, 0.11576763f, 0.16699111f, 0.02318492f, -0.04016066f, 
    0.03980562f, 0.11092731f, -0.24915664f, -0.08313534f, -0.02963826f, 0.24008685f, -0.09223837f, -0.00176464f, 
    0.07258402f, -0.13302399f, 0.14988896f, 0.18159434f, 0.06347031f, -0.21562693f, 0.14309339f, 0.07502619f, 
    -0.07237883f, -0.02918260f, -0.08711363f, -0.08579290f, 0.01876864f, 0.23430271f, 0.05366828f, -0.11631922f, 
    0.03084978f, 0.04974927f, -0.06596148f, -0.13934012f, -0.05569322f, -0.05843892f, 0.15599166f, 0.14661571f, 
    0.11710141f, 0.04104058f, 0.06536455f, 0.09311517f, 0.04011277f, 0.00365847f, -0.02473570f, -0.09165939f, 
    0.05029986f, 0.00219470f, 0.01856824f, -0.01435493f, 0.19990601f, -0.04834454f, -0.06101169f, -0.04596889f, 
    0.06244132f, 0.03296851f, -0.01383979f, -0.00606067f, 0.02716369f, -0.15950656f, -0.09428035f, -0.09571849f, 
    -0.28543717f, -0.09535404f, 0.01454076f, 0.08676297f, 0.16224670f, 0.01451591f, -0.04966860f, -0.01483732f, 
    0.09201589f, -0.10819373f, 0.03310306f, 0.09626779f, 0.34242168f, -0.01193909f, 0.01811141f, 0.09217677f, 
    -0.05122510f, -0.03487104f, -0.07657978f, -0.06913356f, -0.04042951f, 0.20990109f, 0.16509023f, 0.09083650f, 
    0.14527741f, 0.28322583f, -0.15509738f, 0.12258199f, -0.03177211f, 0.15868294f, 0.08866822f, 0.00926810f, 
    -0.01653626f, 0.11059812f, 0.05772160f, 0.13089541f, 0.04707987f, -0.02068666f, -0.15195431f, -0.23891194f, 
    0.05720931f, -0.22957894f, -0.06142868f, -0.09690473f, -0.00661200f, 0.01491867f, -0.05267177f, 0.05786738f, 
    -0.07128820f, 0.00539206f, -0.11636336f, -0.21629596f, 0.07688333f, 0.08796361f, -0.05536930f, -0.17174797f, 
    0.05649201f, -0.02660450f, -0.01112847f, 0.11178818f, 0.02807526f, 0.05371426f, -0.08786836f, 0.00295990f, 
    0.02545464f, 0.02187120f, 0.02184141f, 0.01849809f, -0.05033651f, -0.00725635f, 0.16125090f, -0.03352479f, 
    -0.46616465f, 0.05050876f, 0.04303580f, 0.09350830f, 0.00900207f, -0.08216441f, -0.14340250f, -0.09492481f, 
    -0.15487334f, 0.03728053f, -0.07678221f, 0.07904852f, 0.14001979f, -0.06809641f, -0.04130966f, -0.02692126f, 
    0.18883309f, 0.16449274f, 0.10889561f, 0.08074924f, -0.06887493f, 0.15188931f, -0.09935849f, 0.07726927f, 
    -0.06458101f, -0.23127191f, 0.04049043f, -0.04407094f, -0.01922399f, -0.09031947f, 0.01119361f, -0.05994534f, 
    -0.06824387f, -0.05747637f, 0.03171568f, -0.02491792f, 0.01971915f, 0.07930841f, 0.08898757f, -0.19997329f, 
    0.08571936f, -0.03943701f, -0.11068440f, 0.03655946f, 0.01356365f, 0.09046492f, -0.03898782f, 0.01161333f, 
    0.40733558f, 0.19325262f, 0.12376497f, 0.25758722f, 0.13832551f, 0.16000979f, 0.01220621f, 0.01281018f, 
    0.00004823f, -0.07450980f, 0.10717173f, -0.06022753f, -0.42471796f, -0.17851056f, -0.22179495f, -0.00388694f, 
    -0.09251086f, 0.03963666f, 0.07231645f, 0.01205906f, 0.00589535f, 0.01577944f, 0.02176488f, -0.00927334f, 
    0.09212162f, 0.35718125f, 0.08214921f, 0.07625872f, 0.09383811f, 0.01217561f, 0.07733710f, 0.05400747f, 
    -0.21404566f, 0.08293463f, -0.00976855f, 0.00385773f, -0.06982791f, 0.08663252f, 0.11306586f, 0.27341914f, 
    -0.08784629f, -0.11427111f, 0.06434334f, -0.01547326f, -0.03591346f, -0.01616650f, -0.03970109f, 0.04360808f, 
    -0.29886982f, -0.15318458f, 0.06573241f, -0.03042082f, 0.00420584f, -0.07412758f, -0.12924549f, -0.08678991f, 
    0.05172771f, -0.04091989f, 0.02403477f, -0.01762954f, 0.10467068f, 0.14241292f, 0.01097847f, 0.11037568f, 
    0.00682090f, -0.03908768f, -0.14433984f, 0.00316143f, 0.04281338f, 0.17357127f, -0.05199163f, 0.03933853f, 
    0.26256034f, 0.18627274f, 0.24454199f, 0.04783528f, 0.01683278f, -0.03551161f, 0.06660503f, -0.12598240f, 
    -0.06697790f, 0.02817054f, 0.03067315f, 0.05251369f, 0.10788234f, 0.12920390f, -0.05183878f, 0.24575421f, 
    0.29376000f, 0.08667179f, 0.19955920f, -0.13147749f, -0.15316223f, 0.03650626f, -0.09332974f, 0.09158352f, 
    0.42295259f, 0.02621453f, -0.01430099f, 0.02950235f, 0.08119231f, 0.28352317f, 0.15821837f, 0.07393362f, 
    -0.05675785f, 0.04882653f, -0.11059961f, -0.07715280f, -0.35996619f, -0.10195962f, -0.11101790f, -0.10130811f, 
    -0.09224049f, -0.00754911f, -0.11041096f, -0.16862586f, 0.06298834f, -0.09198133f, 0.01403747f, -0.05819057f, 
    0.04791778f, -0.03874002f, -0.06404476f, 0.05777828f, -0.04960733f, -0.02991156f, -0.02736261f, -0.05425769f, 
    -0.02406083f, -0.05627345f, -0.03956171f, -0.00356591f, -0.05776623f, -0.01071951f, -0.01985048f, 0.04797765f, 
    0.01902506f, -0.07886824f, -0.01910052f, -0.02229418f, 0.05037519f, 0.04247323f, 0.01138558f, 0.02791293f, 
    -0.06459319f, 0.02659694f, -0.03078609f, -0.07106590f, -0.00570583f, -0.06647149f, 0.04891904f, 0.01548103f, 
    0.04784326f, -0.00117186f, -0.04021949f, 0.00360229f, 0.00664917f, -0.04920518f, -0.05574108f, 0.04081899f, 
    -0.02729258f, -0.03724306f, -0.07505564f, 0.05373527f, -0.05365236f, 0.02829378f, 0.03035956f, 0.06708137f, 
    -0.07484215f, 0.00571394f, -0.04920486f, -0.01958014f, -0.02703087f, 0.03079428f, 0.01989268f, -0.03971831f, 
    -0.01524810f, 0.00784366f, -0.05654498f, -0.02136492f, -0.00041486f, -0.05632877f, -0.05094752f, 0.01008391f, 
    -0.03540551f, -0.00571716f, 0.00981521f, 0.01551321f, 0.04635402f, 0.02785042f, 0.05551757f, 0.00869769f, 
    0.01714366f, 0.04046560f, 0.01150158f, 0.05237383f, -0.06256625f, -0.00944939f, -0.07866459f, -0.01562254f, 
    -0.03896787f, -0.06901361f, 0.03436342f, -0.01272431f, 0.01155641f, 0.04312201f, 0.01384001f, -0.00045089f, 
    0.03435269f, -0.06375318f, -0.05270074f, 0.03914282f, -0.04369834f, 0.01779072f, 0.04456281f, 0.01972114f, 
    -0.06679846f, 0.04546605f, 0.03077159f, 0.02689282f, 0.02874124f, -0.02347152f, -0.05850665f, 0.02973065f, 
    0.00355804f, 0.03180401f, 0.05913949f, -0.02492641f, -0.02168202f, 0.02310435f, 0.04191613f, -0.06077909f, 
    -0.03570332f, 0.00071208f, -0.02218606f, 0.04880824f, 0.00404659f, -0.06760073f, -0.06270242f, -0.07737864f, 
    0.02892738f, -0.07416891f, 0.02825229f, -0.04674719f, -0.06713033f, -0.01316639f, -0.06056396f, 0.03338235f, 
    -0.07542712f, -0.04686394f, -0.05385968f, 0.04706508f, -0.02542874f, -0.06851903f, -0.05166380f, -0.07929070f, 
    -0.07602441f, -0.06503784f, 0.00682271f, 0.00524163f, 0.04802925f, -0.02613882f, -0.02148337f, 0.00745016f, 
    0.03865854f, -0.03605908f, 0.01489374f, 0.00546212f, -0.04507231f, -0.04514502f, 0.05312795f, -0.06588011f, 
    -0.05056699f, 0.01522469f, 0.05730617f, -0.04826054f, 0.01030828f, -0.01039263f, -0.02617899f, 0.00157684f, 
    0.01365780f, -0.06681719f, 0.05929667f, -0.02175060f, -0.02816105f, -0.00388588f, -0.02802548f, -0.00666867f, 
    -0.03307143f, 0.03745491f, 0.05803446f, 0.01291445f, 0.03366731f, 0.02880939f, -0.00665367f, -0.00428771f, 
    0.00886472f, 0.00002010f, -0.05178450f, -0.00051502f, 0.02836478f, -0.03009213f, 0.04583792f, 0.05927975f, 
    0.07057159f, 0.01553053f, -0.01893591f, -0.07448052f, 0.05462499f, 0.01229284f, -0.04750130f, 0.01246514f, 
    -0.05453895f, -0.18056546f, 0.11356822f, -0.05101532f, 0.01984958f, 0.07267638f, 0.11788631f, 0.08252243f, 
    -0.15879764f, 0.00883489f, -0.05955349f, 0.06379548f, -0.01597304f, -0.31243202f, 0.01101198f, -0.13511851f, 
    0.07984304f, 0.07549964f, -0.03954396f, -0.07604288f, -0.03027299f, -0.00745370f, 0.09868005f, 0.08114211f, 
    -0.21815073f, 0.18908772f, -0.11130524f, -0.04287870f, 0.02361358f, 0.02273474f, 0.00498958f, -0.07744312f, 
    -0.03219837f, 0.01434391f, -0.02896435f, 0.15886627f, 0.18887420f, 0.04222065f, 0.06734082f, -0.06150145f, 
    -0.11172097f, -0.02151976f, -0.13405643f, 0.14963539f, -0.10352052f, 0.00247121f, 0.05884759f, -0.01853592f, 
    0.09643526f, -0.02296150f, -0.06020606f, -0.01809613f, -0.07046763f, -0.08225472f, 0.06664772f, 0.03411376f, 
    0.02337188f, -0.01807274f, -0.00067693f, -0.07215223f, -0.12307405f, 0.18405603f, 0.04867905f, 0.19291891f, 
    -0.01543266f, -0.00341608f, -0.08905144f, 0.12903893f, 0.02105209f, 0.04397313f, -0.03416432f, 0.00980150f, 
    0.24236640f, -0.07785683f, 0.12779318f, 0.19405645f, 0.00069670f, -0.07884128f, -0.15498826f, 0.05381262f, 
    0.02834051f, -0.11394863f, -0.01354197f, 0.01875190f, -0.14167963f, -0.30795333f, -0.06366501f, -0.01555791f, 
    0.07465333f, -0.03006467f, 0.08955768f, -0.08179770f, 0.06577120f, 0.01491766f, -0.08083311f, 0.06443416f, 
    0.39804259f, 0.08527660f, -0.34944904f, 0.18539289f, 0.08315020f, -0.00860635f, 0.03139972f, 0.15783066f, 
    -0.15125179f, -0.02372784f, 0.07965558f, 0.09597601f, -0.02579202f, -0.19681737f, 0.08249182f, 0.15646374f, 
    -0.03809750f, 0.04525722f, 0.11658914f, 0.07047554f, -0.02506134f, 0.00454692f, 0.04751762f, 0.20904966f, 
    0.01646272f, -0.27029383f, -0.15987685f, 0.14652260f, -0.00887731f, -0.03333552f, 0.07308675f, -0.05676330f, 
    0.09334697f, -0.02216754f, 0.04249036f, 0.01510115f, -0.15025689f, 0.10331195f, 0.12855996f, -0.12033372f, 
    0.07056812f, 0.04765036f, 0.02148406f, -0.01757432f, 0.05109595f, 0.13666232f, 0.05436824f, -0.01324336f, 
    0.25407463f, -0.14617470f, 0.07865252f, -0.15798239f, -0.04931569f, 0.12724750f, 0.08541443f, 0.12511170f, 
    -0.06126283f, 0.14857483f, -0.02478174f, 0.03565563f, 0.09190779f, 0.14043126f, 0.00184362f, 0.01944688f, 
    -0.00937466f, -0.10759592f, -0.07766856f, -0.05445914f, 0.10108515f, -0.07579684f, -0.01747704f, 0.06192327f, 
    0.18392591f, -0.14301671f, 0.09711946f, 0.09292089f, -0.06953066f, -0.09129072f, -0.00890888f, 0.01500568f, 
    0.01060600f, 0.11301019f, 0.01992342f, 0.01086915f, 0.00820085f, -0.01252135f, -0.09498710f, -0.06459471f, 
    -0.02262937f, 0.05631788f, -0.02214400f, 0.02465146f, -0.05713348f, 0.02758794f, 0.09640352f, 0.05093795f, 
    -0.33135474f, -0.18741366f, -0.09578186f, 0.03651747f, 0.08761927f, 0.12530079f, -0.14106205f, -0.07437482f, 
    0.03860161f, 0.03437225f, -0.02902963f, -0.00427011f, -0.23642811f, -0.17675209f, -0.04273886f, -0.03825320f, 
    0.07245836f, 0.14139758f, 0.00777262f, 0.03253163f, -0.02314145f, 0.02927887f, 0.04925174f, 0.02702780f, 
    -0.05031732f, 0.05172223f, 0.12529637f, -0.18724786f, 0.07969154f, 0.07343465f, 0.12211930f, 0.05396597f, 
    0.07174145f, 0.03691294f, 0.12896715f, -0.08363064f, -0.16892000f, 0.12843733f, 0.06809454f, -0.00621955f, 
    0.00362719f, -0.00202075f, 0.06108516f, -0.11750878f, 0.01004617f, 0.04516387f, 0.07673211f, 0.07578336f, 
    0.20791002f, -0.00392786f, 0.11418961f, 0.00225753f, 0.02226020f, 0.00423837f, 0.12829416f, -0.06670924f, 
    -0.03372107f, 0.06522159f, -0.02643578f, -0.13159600f, -0.42708981f, 0.09735005f, 0.15005235f, -0.01233274f, 
    -0.00782416f, -0.13118818f, 0.06962146f, 0.01800020f, -0.01594978f, -0.11197168f, -0.16266310f, -0.03515130f, 
    0.02670134f, 0.03834597f, -0.02518472f, 0.24413854f, 0.01115942f, -0.10833970f, 0.02960320f, 0.05118246f, 
    0.08819803f, 0.08930831f, 0.00387939f, 0.10757042f, 0.12633821f, -0.10889334f, 0.04739211f, 0.28393283f, 
    -0.04213081f, 0.03513648f, 0.00261433f, 0.05093388f, -0.02467503f, -0.18319021f, -0.17718944f, 0.10663144f, 
    0.02897972f, 0.21169068f, 0.00647135f, -0.04554062f, -0.02830599f, -0.02718914f, 0.05776375f, 0.10370572f, 
    0.06699532f, 0.00296421f, 0.02907187f, 0.00240533f, 0.31683725f, -0.05723784f, -0.04405959f, 0.15353906f, 
    -0.03213370f, 0.00679233f, -0.10393106f, 0.00668817f, 0.05658350f, 0.07025187f, -0.11033937f, 0.03012485f, 
    0.02748855f, 0.09091391f, -0.00095179f, 0.12129289f, -0.03153852f, 0.16458426f, -0.05818162f, -0.02343994f, 
    0.06761750f, -0.05625939f, 0.03511570f, -0.02292284f, 0.02044605f, 0.00937930f, 0.23007412f, 0.29234228f, 
    -0.01569835f, -0.00965281f, -0.16574369f, 0.13008122f, 0.01629149f, -0.03849929f, -0.01801424f, 0.03277181f, 
    0.29245803f, 0.03663135f, 0.08601378f, 0.14358012f, -0.07116258f, -0.00175139f, 0.05570982f, 0.12326697f, 
    0.14113200f, -0.02989376f, 0.12376965f, -0.01616097f, 0.26454529f, -0.03244023f, 0.01580131f, -0.19891611f, 
    -0.01352638f, 0.09769145f, 0.00653301f, 0.06777029f, -0.07719406f, -0.14306316f, -0.05556569f, 0.09820266f, 
    -0.44323388f, 0.13109949f, 0.02690002f, 0.00697737f, -0.03964669f, -0.02566034f, 0.15367520f, -0.00651842f, 
    -0.06178474f, 0.06779750f, 0.06222249f, 0.06670782f, 0.11972211f, -0.08264146f, -0.04324093f, 0.08033185f, 
    -0.01424743f, 0.00292264f, -0.08928645f, 0.10141329f, -0.01764312f, 0.02626185f, -0.02431853f, 0.02003488f, 
    0.19736809f, -0.00348519f, 0.03697878f, 0.01251496f, 0.02122858f, -0.00799706f, 0.02704310f, -0.03461030f, 
    -0.03289552f, 0.11653005f, -0.00079118f, -0.01861095f, 0.03123235f, -0.17796059f, 0.08709691f, -0.09015842f, 
    -0.00340052f, 0.14669617f, -0.04011264f, -0.12543480f, 0.00414151f, -0.01861269f, 0.09272345f, -0.11267284f, 
    -0.00639116f, 0.03577760f, -0.05631329f, -0.05167119f, -0.05527249f, 0.12083164f, 0.10539898f, 0.00507972f, 
    0.01836670f, -0.00570677f, 0.08599058f, -0.04352095f, 0.06040428f, 0.08722237f, 0.05146887f, 0.00396248f, 
    0.20977908f, 0.07044842f, 0.01771562f, -0.03453256f, 0.14244872f, -0.09215967f, 0.07709096f, 0.05374555f, 
    0.06521898f, 0.12800133f, 0.11244669f, 0.09950415f, -0.09431236f, 0.02340998f, -0.00490648f, -0.02306912f, 
    0.16069338f, -0.03396577f, -0.00101055f, -0.02040369f, 0.09135376f, -0.14595702f, -0.07952538f, 0.09480450f, 
    0.01242256f, 0.01989023f, -0.21120843f, -0.02548889f, -0.03022537f, -0.02457636f, 0.12603861f, -0.00770035f, 
    0.08873747f, -0.11886010f, 0.32884470f, -0.11389111f, 0.09281034f, 0.16182826f, 0.02395992f, -0.08891604f, 
    0.03571282f, -0.10824925f, -0.02756998f, -0.05043225f, -0.09797353f, 0.08473900f, 0.09717751f, -0.10230493f, 
    -0.09202659f, -0.14705278f, -0.00690624f, -0.07497010f, 0.03030790f, -0.20518553f, -0.09351177f, -0.00241553f, 
    -0.25471687f, 0.00782444f, -0.01225021f, -0.33889198f, 0.03131280f, 0.19316721f, -0.06110649f, -0.05479649f, 
    -0.09784757f, -0.06071263f, 0.04357234f, -0.04842174f, 0.14907803f, -0.20243125f, 0.00084261f, -0.10328177f, 
    0.04529220f, -0.17729796f, 0.02033667f, 0.04503331f, -0.08932722f, 0.03683094f, -0.05446880f, -0.02003426f, 
    0.29003891f, -0.03415645f, -0.08818680f, 0.10056656f, -0.09877830f, -0.00716765f, -0.07613230f, 0.02123033f, 
    -0.06636196f, -0.02984850f, 0.06235905f, -0.03784253f, -0.24638943f, -0.15949212f, 0.25025094f, 0.06626090f, 
    0.01536934f, -0.01663574f, 0.01558003f, -0.05044147f, -0.03703135f, 0.00178243f, 0.01417312f, -0.02387321f, 
    -0.03372053f, 0.06217988f, -0.07964713f, 0.09094771f, -0.17644146f, 0.00172499f, 0.05836613f, 0.13589717f, 
    -0.18752363f, 0.11717961f, 0.07400116f, 0.03614024f, 0.02289809f, 0.08814085f, -0.02503639f, 0.05411320f, 
    0.18879710f, 0.19274732f, -0.02238848f, 0.04626424f, 0.04167525f, 0.02290853f, -0.12820037f, -0.05189427f, 
    0.12818608f, 0.22477114f, 0.12823734f, 0.04646142f, 0.11574568f, 0.06966829f, 0.04327250f, -0.05186740f, 
    0.07618215f, 0.07053385f, 0.05240548f, 0.08473465f, 0.28351328f, 0.12419711f, 0.24538223f, 0.28642863f, 
    -0.15013406f, 0.06658230f, 0.06849994f, 0.24134989f, -0.07607275f, 0.06527853f, -0.01483458f, -0.01225141f, 
    -0.00198495f, -0.03626160f, -0.04783889f, -0.01007679f, -0.04667550f, 0.06082360f, 0.05192585f, 0.01150111f, 
    0.05957235f, -0.04801545f, -0.05186382f, 0.00249097f, -0.03774317f, -0.00192446f, 0.03381697f, -0.04620421f, 
    -0.05951076f, -0.06630785f, -0.00140161f, -0.05096180f, 0.01095003f, 0.04581384f, -0.01905329f, 0.02204287f, 
    0.01417872f, 0.01210065f, -0.06016504f, -0.05520162f, 0.05776251f, -0.05991558f, -0.01703643f, -0.06157142f, 
    -0.01424972f, -0.02229606f, 0.00641825f, 0.01820192f, -0.02317374f, -0.04756699f, 0.01359921f, -0.03928559f, 
    -0.04054531f, 0.04164196f, -0.00404133f, 0.01614991f, -0.01003058f, -0.02433570f, 0.04600241f, -0.01159740f, 
    0.04858658f, 0.06346553f, 0.00391434f, -0.00288084f, 0.04081265f, -0.08032014f, 0.00700181f, 0.02819895f, 
    -0.07398081f, -0.07563600f, -0.00810091f, -0.05404884f, -0.03153870f, -0.04111425f, 0.06188428f, -0.02803513f, 
    -0.06077339f, 0.05887808f, -0.05690687f, -0.02613637f, 0.02291824f, 0.06183215f, -0.04004564f, -0.05044140f, 
    0.00119438f, -0.06794382f, 0.05220703f, -0.00872326f, -0.07176815f, 0.02591775f, -0.03739819f, -0.06663776f, 
    -0.05715009f, -0.04819162f, 0.05687525f, 0.02893523f, 0.04081132f, -0.06267865f, -0.03219057f, -0.06821884f, 
    0.05747424f, 0.05848588f, 0.05049501f, 0.03969334f, -0.02817722f, 0.02159471f, 0.04577585f, -0.03589207f, 
    0.04595619f, -0.04603020f, 0.05038119f, -0.06276546f, 0.04185120f, 0.00160319f, -0.02963529f, 0.04900593f, 
    0.01981907f, 0.04898087f, -0.03128349f, 0.01538447f, -0.05619740f, 0.01358858f, -0.00717040f, -0.05396429f, 
    -0.02820936f, 0.00745212f, -0.05787551f, -0.05391339f, -0.01639335f, 0.04434854f, 0.01452471f, 0.05069545f, 
    -0.06260969f, 0.01313933f, 0.02383087f, 0.00367105f, -0.00435578f, 0.02041803f, -0.03140967f, 0.00892426f, 
    0.03034789f, 0.03300444f, 0.01905262f, -0.02877372f, -0.01976552f, -0.04903010f, 0.00490866f, -0.06089645f, 
    -0.01360617f, -0.02108874f, -0.07406510f, -0.00100267f, -0.05978363f, -0.04802560f, -0.00927474f, -0.02436244f, 
    -0.03640023f, -0.07304581f, -0.06243860f, -0.03853628f, 0.01305095f, -0.07315938f, 0.02131446f, 0.02746475f, 
    0.03520101f, -0.00238293f, 0.04112905f, -0.00950366f, 0.02995148f, 0.00427288f, 0.02260485f, -0.03978162f, 
    0.00546677f, 0.02719476f, -0.00626498f, 0.06441750f, -0.07735037f, -0.06392714f, -0.05797284f, 0.05123676f, 
    -0.05760079f, -0.05345839f, 0.02817627f, 0.06208066f, 0.02458559f, 0.03019898f, -0.00887457f, -0.03885058f, 
    -0.02225810f, -0.02417387f, 0.02783526f, -0.02967953f, -0.03849151f, -0.03371341f, 0.06224387f, 0.02168342f, 
    -0.03858061f, -0.05416825f, 0.01748877f, -0.05752204f, -0.05758569f, 0.04858353f, 0.05700244f, 0.03360323f, 
    0.01249072f, -0.07695288f, -0.00169140f, -0.00638981f, 0.04300663f, -0.00994473f, 0.02668120f, -0.07438803f, 
    -0.03766304f, -0.06643830f, 0.02143156f, 0.01389458f, 0.02710020f, 0.04206866f, 0.03788487f, -0.02146945f, 
    0.05613112f, -0.04970257f, 0.01318217f, 0.06594922f, 0.06013824f, 0.04774522f, 0.02710515f, -0.03041592f, 
    0.01249833f, 0.04160513f, -0.04836103f, 0.02971784f, -0.06048697f, 0.00130708f, -0.06969534f, 0.04883652f, 
    -0.03160658f, -0.03953482f, -0.05691628f, 0.00395127f, 0.06492113f, 0.01495080f, 0.00200741f, -0.02969321f, 
    -0.05334518f, -0.04081310f, 0.03369332f, -0.01314204f, -0.05589774f, 0.02181695f, 0.01993841f, 0.02660073f, 
    -0.00322403f, 0.05908571f, -0.05100454f, 0.02317071f, 0.00900707f, 0.00997971f, -0.04689785f, 0.02908308f, 
    -0.05047077f, -0.06558722f, -0.01980912f, 0.03377968f, 0.04822906f, 0.04996694f, 0.05280293f, 0.05253552f, 
    -0.02652694f, 0.00774169f, 0.00764601f, -0.06965195f, 0.01553965f, 0.00981592f, -0.00024201f, -0.02084880f, 
    0.05247938f, -0.06551161f, -0.06975042f, -0.05929992f, 0.02209892f, 0.05518465f, -0.04252349f, -0.06834654f, 
    0.04290601f, -0.07381494f, -0.01561883f, -0.07344812f, -0.06334946f, -0.05290660f, 0.05885327f, -0.02953339f, 
    -0.01778904f, -0.06161059f, 0.05383749f, -0.03707767f, -0.04448551f, 0.00914189f, 0.04858190f, 0.06082137f, 
    -0.02531377f, 0.00243543f, 0.03822728f, -0.03429462f, -0.04643413f, 0.06502946f, -0.03042288f, -0.04894461f, 
    0.05854669f, 0.02469433f, 0.03566547f, -0.07014098f, -0.00755507f, -0.01487959f, -0.01799874f, -0.01244370f, 
    -0.06537362f, 0.03395971f, -0.03859075f, -0.02927668f, -0.02668055f, -0.06857504f, 0.04323798f, 0.04506151f, 
    -0.05595537f, -0.02070615f, 0.00312849f, -0.01726943f, 0.02548363f, 0.04796451f, -0.03274100f, -0.03015073f, 
    -0.07396681f, 0.04217275f, 0.03988406f, 0.00577000f, -0.03995859f, 0.03855197f, -0.01653183f, -0.07334340f, 
    -0.08300523f, -0.06426282f, 0.03823091f, -0.01552769f, -0.03699842f, -0.04145460f, -0.05927336f, -0.01332566f, 
    -0.06558447f, 0.01733347f, -0.03101621f, -0.06865709f, -0.04388606f, -0.04646430f, -0.00285731f, -0.05818049f, 
    -0.05337078f, -0.03511843f, -0.02635053f, 0.02636768f, -0.00709782f, -0.05331416f, -0.02140770f, -0.01116739f, 
    -0.00964177f, 0.06976869f, 0.01378949f, -0.00031628f, -0.06571258f, 0.05937352f, 0.01314084f, 0.01923655f, 
    -0.04119568f, -0.03332921f, -0.01585435f, 0.03603595f, -0.00016229f, -0.01516817f, 0.03697428f, -0.06285039f, 
    -0.06240803f, 0.02131139f, -0.01565482f, -0.05127751f, 0.02882854f, 0.03055466f, 0.03814803f, -0.04526928f, 
    -0.03581107f, 0.04148657f, -0.06382120f, 0.04729170f, 0.00429638f, 0.05883890f, 0.01887899f, 0.00621526f, 
    0.02150574f, -0.11460797f, 0.12252967f, -0.18486634f, -0.08035009f, 0.01535959f, 0.11959475f, 0.12767024f, 
    0.10679089f, -0.03467084f, 0.16233777f, -0.06084600f, 0.11665659f, 0.02161423f, -0.11102293f, 0.13099341f, 
    0.16155140f, -0.02652228f, 0.02958287f, -0.05313889f, -0.05017059f, 0.05091646f, 0.10486865f, 0.12391771f, 
    -0.05443996f, 0.04745483f, -0.10573953f, 0.13087036f, -0.10382559f, 0.08693343f, 0.02006933f, 0.00068300f, 
    0.06634022f, -0.04269597f, 0.05058890f, 0.10866883f, 0.30352917f, -0.04416114f, -0.01556836f, -0.11130002f, 
    -0.08650684f, 0.00191336f, -0.05756679f, 0.07186604f, -0.00602261f, -0.05248138f, 0.02471450f, -0.05142885f, 
    -0.02385761f, 0.05469074f, -0.10779732f, -0.12104299f, -0.09071016f, 0.02618771f, 0.10107755f, 0.03618231f, 
    0.01827832f, -0.05711167f, 0.08007623f, -0.10836682f, 0.23317730f, -0.00662633f, -0.13472167f, 0.07134869f, 
    -0.05095484f, 0.01317132f, -0.01381578f, 0.06424451f, 0.05868844f, -0.08769342f, -0.05348720f, 0.00779141f, 
    0.21181814f, -0.07264435f, 0.13654700f, -0.01919872f, -0.11496698f, 0.04190733f, -0.11225248f, 0.17117737f, 
    0.06436860f, 0.04767671f, 0.09899574f, -0.06609290f, -0.14952593f, 0.08306304f, 0.14699338f, -0.04517564f, 
    -0.11342692f, 0.11452290f, -0.03115563f, -0.01525963f, 0.04616907f, 0.17818411f, -0.12600692f, -0.03009738f, 
    0.12096574f, 0.02312031f, -0.15322401f, 0.30749702f, 0.12377937f, 0.06934749f, -0.05694579f, 0.24471405f, 
    0.05868618f, 0.05130195f, -0.05817546f, 0.01763064f, -0.13438591f, -0.07207260f, 0.26903275f, 0.03156044f, 
    0.05156213f, 0.18985753f, 0.14665192f, -0.00743307f, -0.11784989f, -0.03877557f, 0.00402917f, 0.15256318f, 
    -0.06003898f, 0.00315308f, 0.22591597f, -0.09927927f, -0.01596965f, 0.06133179f, 0.07284974f, 0.04082749f, 
    0.02959838f, 0.06504616f, 0.00589496f, 0.07989275f, -0.21352686f, -0.03401958f, 0.02159505f, -0.24782921f, 
    -0.02575901f, 0.06715933f, 0.06139923f, 0.00353958f, -0.02502763f, -0.04257540f, -0.11190051f, -0.08435874f, 
    -0.15875417f, -0.09786394f, 0.17952125f, 0.03849281f, 0.16545843f, 0.02613722f, 0.00095623f, 0.00503084f, 
    -0.07944977f, -0.03336274f, -0.09712847f, 0.04251493f, 0.24814500f, 0.18354301f, -0.06953815f, 0.10422456f, 
    0.02981761f, -0.01330889f, -0.09365921f, 0.04966174f, 0.02564396f, 0.13733283f, 0.07930456f, 0.08243989f, 
    0.44102412f, -0.09895021f, -0.12621410f, 0.09384139f, 0.05740989f, 0.02975979f, 0.08916094f, -0.01418002f, 
    -0.00516007f, -0.01652215f, 0.08034238f, 0.10763475f, -0.17308760f, 0.10928639f, -0.01176614f, -0.23009543f, 
    0.00826445f, -0.05368747f, -0.03079514f, 0.11431661f, -0.09990281f, 0.10313004f, -0.07217256f, 0.05198550f, 
    -0.29642391f, 0.04908336f, -0.06786016f, 0.11389720f, 0.04578221f, 0.17581959f, -0.14043444f, 0.03673717f, 
    0.07590638f, -0.03082123f, 0.05767453f, 0.05204248f, 0.01275044f, 0.27239656f, -0.05825699f, -0.02415135f, 
    -0.03503409f, 0.14132112f, 0.01441841f, 0.10990543f, 0.01629630f, -0.00226717f, -0.09914266f, 0.08577362f, 
    0.31756714f, -0.19158788f, 0.20441660f, -0.02585233f, 0.06479080f, 0.01344476f, -0.01701563f, 0.00980590f, 
    0.00686537f, -0.00234956f, 0.06390150f, 0.02826358f, -0.23291610f, -0.10656004f, -0.00649105f, 0.17645615f, 
    -0.08570089f, -0.11382826f, 0.08805168f, -0.02434107f, -0.01894113f, 0.02389757f, -0.07989738f, 0.16803433f, 
    0.29244590f, 0.05336107f, 0.17638260f, -0.03886326f, -0.03816341f, 0.00128188f, 0.02169233f, -0.01551326f, 
    0.02030181f, -0.00120828f, 0.06265712f, -0.07009758f, -0.19004750f, -0.13835973f, 0.19470900f, -0.12293964f, 
    0.04317983f, -0.08771414f, 0.18759099f, -0.06054233f, 0.11068536f, -0.03463570f, -0.15446854f, 0.04573480f, 
    -0.12642644f, 0.17217648f, -0.14419554f, 0.30436209f, -0.04076473f, -0.08504760f, -0.01979379f, 0.06983393f, 
    -0.07295766f, 0.12431951f, 0.09897416f, 0.12262254f, -0.01343093f, 0.04154144f, -0.15689413f, 0.14935595f, 
    0.04704029f, 0.05731655f, -0.06265122f, 0.09299478f, -0.04132704f, -0.10042221f, 0.02724199f, -0.05961551f, 
    -0.14611238f, 0.00848721f, 0.19041926f, -0.02899121f, 0.05533903f, 0.04770725f, 0.16244933f, -0.06041851f, 
    0.14799923f, 0.08121181f, 0.05279352f, -0.01767935f, 0.02562445f, -0.06740073f, -0.15898760f, 0.07024159f, 
    -0.03686135f, 0.16717525f, -0.13944538f, -0.01810635f, 0.11754856f, -0.00884338f, -0.02083411f, 0.04652686f, 
    -0.33666313f, 0.17122220f, 0.13905643f, -0.05062772f, 0.00675087f, 0.09531094f, 0.02505437f, -0.03812021f, 
    0.08573946f, -0.02853512f, 0.04504764f, -0.01881975f, 0.04859008f, 0.05975939f, 0.09559494f, 0.09390323f, 
    0.15849708f, 0.01481478f, -0.04094348f, 0.06417698f, -0.09985727f, -0.05926032f, -0.02662877f, 0.00099144f, 
    0.25301078f, 0.15681154f, -0.08989587f, 0.02970984f, -0.01348424f, 0.02391697f, 0.01605041f, -0.00928226f, 
    0.15760021f, -0.01552290f, 0.06568649f, -0.02978815f, 0.18901038f, -0.10004973f, 0.14563721f, -0.16640386f, 
    0.02340106f, 0.03083939f, 0.12361166f, -0.01735594f, -0.15004958f, -0.07361150f, 0.02396356f, 0.02776070f, 
    -0.29797351f, -0.15643303f, 0.08063941f, 0.09094749f, -0.04601451f, 0.03583218f, 0.09858530f, 0.00250490f, 
    -0.18314210f, -0.01987374f, 0.02667575f, 0.07995488f, -0.18052614f, 0.21156713f, -0.11225707f, -0.04826217f, 
    0.07102737f, 0.00952873f, -0.06174699f, -0.06422466f, -0.04336145f, -0.01589535f, -0.07401670f, -0.02375250f, 
    0.10301501f, -0.10548559f, -0.09049793f, 0.02060850f, -0.05917216f, -0.12654355f, 0.06203220f, -0.04836421f, 
    -0.08045348f, -0.04249643f, 0.06129945f, -0.03699994f, -0.23429075f, -0.08533332f, 0.03680984f, 0.07813604f, 
    0.02680635f, -0.04575620f, 0.00665420f, 0.02746952f, 0.03454809f, 0.06133209f, 0.01647280f, -0.08609116f, 
    0.07386168f, -0.06671344f, 0.03052117f, -0.10796069f, -0.04658699f, -0.02826848f, 0.03104120f, 0.03820899f, 
    -0.00386695f, 0.13444626f, 0.14003159f, 0.00103196f, -0.19238274f, 0.26102033f, -0.00551554f, -0.11830691f, 
    -0.00422191f, -0.03618145f, 0.11725337f, -0.14626890f, -0.05356410f, -0.06154586f, 0.03576344f, 0.11540105f, 
    -0.16508113f, 0.02833253f, 0.05908198f, 0.01237230f, 0.02311647f, 0.06033593f, 0.05664179f, 0.01765428f, 
    0.00760853f, 0.07648456f, -0.03475499f, -0.04651942f, 0.02671777f, 0.04479707f, 0.12647459f, 0.23349947f, 
    0.06255379f, 0.16685811f, 0.19439393f, -0.01714419f, -0.04009961f, -0.16311252f, 0.01382261f, 0.07594562f, 
    -0.05272488f, -0.01527929f, -0.09417280f, -0.23857786f, 0.01320408f, -0.04879801f, 0.10282318f, -0.05100212f, 
    0.12551080f, 0.02509660f, -0.06631283f, -0.01271814f, 0.39979941f, 0.14461011f, 0.08966212f, 0.23279266f, 
    0.04880755f, -0.02317602f, -0.17428473f, 0.04493814f, -0.05397063f, 0.07462444f, -0.04705911f, 0.01280635f, 
    0.09019584f, -0.22102959f, 0.19285947f, -0.02625668f, -0.10692505f, 0.11043036f, 0.01746039f, 0.01538937f, 
    0.08173775f, -0.08962847f, -0.10807580f, 0.01179434f, 0.16568218f, 0.20476104f, 0.07713883f, -0.14963326f, 
    0.12123499f, -0.00551896f, -0.03629706f, 0.03395048f, 0.12158697f, -0.05274867f, 0.06108611f, -0.10858790f, 
    0.23361507f, 0.27059060f, 0.00899389f, -0.11199558f, -0.04801153f, 0.11625550f, -0.01427664f, -0.01203824f, 
    0.01567526f, 0.02331111f, -0.08605452f, -0.05374886f, 0.07577274f, 0.01948601f, -0.03651713f, 0.26850235f, 
    0.08867966f, 0.04658110f, 0.09757288f, 0.10949666f, -0.08553075f, -0.12009713f, -0.06196827f, -0.05195872f, 
    0.01579554f, -0.13394138f, -0.16221261f, 0.07958275f, 0.09163049f, -0.05789317f, -0.08969375f, 0.04147760f, 
    0.08320991f, -0.09518143f, 0.08809282f, -0.03565562f, 0.13099377f, 0.00901837f, 0.05017960f, -0.10980080f, 
    -0.01601020f, 0.14684317f, 0.06524869f, 0.08802178f, -0.05619013f, 0.09645750f, 0.06787602f, 0.05513490f, 
    -0.22837803f, 0.31151992f, -0.14161651f, -0.15407665f, -0.07264703f, -0.02624495f, 0.11127709f, -0.11353039f, 
    0.03220182f, -0.06749721f, -0.00348283f, 0.10105703f, 0.19413731f, -0.38517183f, 0.11570169f, 0.00762718f, 
    -0.00406457f, -0.01106307f, 0.02004723f, -0.01994594f, 0.17421518f, -0.01542176f, 0.11781903f, 0.02381908f, 
    0.27504611f, 0.10654967f, 0.12954304f, -0.04019855f, -0.21294418f, -0.08571502f, 0.00323513f, 0.17200169f, 
    -0.03080728f, -0.14951289f, -0.20743594f, 0.22271834f, -0.27954030f, -0.19572844f, 0.08808383f, -0.09096985f, 
    0.00849652f, 0.00953450f, 0.16198082f, 0.04003793f, 0.13505998f, -0.00344418f, -0.06224276f, 0.22444005f, 
    -0.17806768f, 0.03635640f, -0.15893421f, -0.23377022f, 0.12454708f, -0.14484914f, -0.11648522f, 0.00716288f, 
    0.03994134f, 0.18826890f, 0.03722177f, 0.12861465f, 0.19031738f, 0.12475652f, -0.09552918f, 0.09692734f, 
    -0.17575695f, 0.03053134f, 0.06248116f, 0.00136003f, 0.03901058f, 0.07126664f, -0.04581311f, -0.03484932f, 
    -0.30682352f, -0.13289596f, -0.07997160f, 0.00695524f, 0.25071469f, -0.01617830f, -0.03678531f, -0.04480267f, 
    -0.03167161f, 0.15494446f, -0.06774361f, 0.35835722f, 0.24196956f, 0.07172028f, -0.04119927f, -0.00097192f, 
    0.03238324f, 0.07634787f, -0.13797285f, 0.07879429f, 0.05236350f, 0.12663169f, 0.22105423f, 0.22058317f, 
    -0.15199891f, -0.02132483f, 0.02447058f, -0.15482615f, -0.07782571f, 0.03319471f, -0.07067454f, -0.16310845f, 
    0.00424009f, -0.05744646f, 0.21115081f, -0.20878266f, -0.10747498f, -0.23370609f, -0.12327794f, 0.08280570f, 
    0.12374970f, -0.06712186f, 0.15838492f, 0.04086529f, 0.10548069f, -0.13811016f, 0.34283251f, 0.08317954f, 
    0.31842768f, 0.00798543f, -0.07504368f, 0.13030241f, 0.03430592f, -0.10506030f, -0.15820654f, -0.05060102f, 
    -0.01513253f, -0.08190189f, 0.17199694f, 0.05348917f, -0.29266095f, -0.14054964f, 0.07206034f, -0.10401291f, 
    0.05034144f, -0.02645190f, 0.15398854f, 0.02536173f, 0.22323646f, -0.04307173f, 0.08054578f, 0.03199201f, 
    0.03840805f, -0.23978603f, -0.17665102f, -0.03155508f, 0.21859418f, 0.13990593f, 0.07214486f, -0.11775109f, 
    0.00961938f, 0.04282457f, 0.00564385f, 0.08375304f, 0.06742813f, 0.05070364f, -0.06799125f, 0.12708181f, 
    0.07327601f, -0.02811784f, 0.02051739f, 0.01028969f, 0.07037143f, 0.26394883f, 0.23651025f, 0.18280132f, 
    -0.10788803f, -0.19697188f, 0.10566246f, -0.22744039f, -0.06948096f, 0.05016956f, -0.06945005f, 0.14245892f, 
    0.07090809f, 0.25786823f, 0.03615567f, 0.10816254f, -0.18401866f, -0.00716209f, 0.05662595f, 0.12351114f, 
    -0.23164988f, -0.20685792f, 0.06384642f, 0.06258726f, -0.04337168f, -0.02053871f, -0.01689230f, -0.03526656f, 
    0.16124856f, -0.01443480f, -0.07451600f, 0.00478164f, -0.13776845f, -0.06906087f, -0.06468154f, 0.05649838f, 
    0.00858456f, -0.06165167f, -0.15140298f, -0.17953335f, -0.01641410f, -0.26506403f, -0.00970191f, -0.09250093f, 
    0.11749038f, 0.17574479f, -0.10267715f, -0.18789765f, 0.18042767f, -0.03253792f, 0.08120739f, 0.01191430f, 
    -0.10844398f, 0.19161813f, 0.20567583f, 0.03078615f, 0.04621356f, 0.06834461f, 0.09913880f, 0.09518769f, 
    -0.07966333f, -0.08521654f, 0.04360161f, 0.02150372f, -0.01997186f, 0.07126068f, 0.03532192f, -0.06624217f, 
    0.03049488f, -0.06130533f, 0.06878658f, 0.09977987f, -0.08455992f, -0.08157629f, 0.01657148f, 0.10781240f, 
    -0.13930067f, 0.11505231f, -0.18978453f, -0.03484562f, 0.04127182f, 0.15715066f, -0.00058648f, -0.01478121f, 
    -0.08672608f, -0.05049467f, 0.02823545f, 0.12478517f, 0.25697380f, 0.02090614f, 0.00845810f, 0.20545474f, 
    -0.14349689f, -0.11416230f, -0.02738908f, 0.13153620f, -0.03561220f, 0.03414360f, 0.02661413f, 0.01766558f, 
    0.20034204f, -0.09029922f, -0.15350515f, -0.00037552f, 0.03439724f, -0.09196144f, -0.03851715f, 0.13894930f, 
    -0.01579079f, -0.05255239f, -0.03700284f, -0.02115161f, -0.16281831f, 0.16408531f, -0.02348303f, 0.16506968f, 
    0.07944392f, -0.06459460f, 0.06560800f, -0.04174276f, -0.06807917f, -0.04770902f, -0.15295996f, 0.06020525f, 
    -0.06096416f, 0.00557635f, -0.21464950f, 0.36558619f, 0.04128302f, -0.15798399f, 0.02281659f, 0.01206674f, 
    0.12521945f, 0.06961152f, 0.10516924f, 0.06682174f, 0.06759938f, -0.24346955f, -0.19869402f, -0.08678852f, 
    0.19067332f, 0.01980788f, -0.05617536f, -0.04295566f, -0.05025839f, 0.04524692f, -0.00404925f, -0.00309458f, 
    0.09769583f, 0.02433707f, 0.01940566f, 0.06938203f, -0.06876470f, -0.08955698f, -0.03257136f, 0.02083228f, 
    0.00349974f, 0.02547853f, 0.01360837f, 0.01805394f, 0.16564344f, 0.20374793f, -0.15836838f, 0.08210640f, 
    0.01058850f, -0.02841452f, 0.09089585f, -0.00825831f, 0.09274442f, 0.07409754f, -0.05954813f, 0.07534395f, 
    0.11650277f, -0.18359667f, -0.10959478f, 0.31541705f, 0.01035638f, 0.03725098f, 0.01548040f, -0.07797255f, 
    0.13224202f, 0.01761548f, -0.00633112f, -0.05246541f, -0.03732958f, 0.09121247f, 0.05430321f, 0.12286443f, 
    -0.00699681f, 0.09618283f, -0.00537100f, 0.01427975f, 0.03334016f, -0.04544952f, 0.00050806f, -0.01513671f, 
    0.07868414f, 0.15936413f, 0.04050556f, -0.12374093f, -0.00092486f, 0.11042395f, 0.02273334f, 0.02739715f, 
    0.10197088f, -0.03747778f, 0.01125336f, 0.03963969f, 0.00592128f, -0.11339267f, 0.05179987f, -0.18321836f, 
    -0.12218564f, -0.05022209f, -0.12721550f, 0.03808125f, 0.02837911f, -0.15565227f, 0.09294838f, 0.11432282f, 
    -0.38307595f, 0.29181233f, -0.00377890f, 0.20570135f, -0.09274652f, -0.02050980f, -0.01198309f, 0.10458832f, 
    -0.00851130f, 0.00608277f, -0.03257814f, -0.01806110f, 0.12600327f, -0.05658692f, -0.31468770f, 0.20326363f, 
    0.11661740f, 0.01627012f, -0.04887518f, -0.01313289f, 0.05750253f, 0.02297184f, 0.06458144f, -0.06085614f, 
    0.31877837f, -0.05506937f, 0.02461249f, -0.17481551f, -0.01109460f, -0.10785455f, 0.07230764f, -0.00223124f, 
    -0.00732712f, -0.05488109f, -0.02626481f, 0.10138896f, 0.32250929f, 0.17443736f, -0.01190603f, 0.00854575f, 
    0.07316914f, -0.08880652f, -0.00115615f, 0.08664756f, 0.02644910f, 0.03290357f, -0.02179868f, -0.00782823f, 
    -0.29734012f, 0.18131518f, -0.09101403f, 0.35033643f, -0.04940638f, -0.11524186f, 0.01554589f, -0.07324709f, 
    0.00427003f, 0.04140558f, 0.02378290f, 0.00260976f, 0.18930961f, 0.07256064f, -0.03489979f, -0.11674159f, 
    0.11064794f, -0.02851146f, -0.05381401f, 0.20065284f, 0.04011268f, -0.02382331f, -0.03794554f, 0.10193533f, 
    0.08039818f, -0.04106647f, -0.08771765f, 0.23099019f, 0.03839270f, 0.02529448f, 0.09120265f, -0.14154799f, 
    0.00630877f, -0.01299311f, 0.00247653f, 0.12049472f, 0.20064336f, -0.10520053f, -0.14552607f, -0.00761497f, 
    0.06772587f, -0.09885886f, -0.02467327f, -0.09193496f, -0.02947986f, -0.02907523f, 0.04975164f, 0.01555507f, 
    -0.15454927f, -0.24661054f, -0.00505184f, 0.07355039f, -0.08830970f, 0.11945435f, -0.03006443f, -0.06850471f, 
    0.09566074f, 0.06084611f, 0.00285335f, -0.00009020f, 0.17731595f, 0.05439587f, -0.07822108f, -0.12277485f, 
    -0.03407359f, 0.07566322f, 0.10180531f, -0.02468783f, 0.01872531f, 0.05020943f, 0.02727960f, 0.04485590f, 
    0.03313364f, -0.09691284f, -0.21943434f, 0.21066263f, -0.02320453f, -0.03272958f, -0.08583471f, -0.03293266f, 
    -0.04009483f, 0.00965008f, -0.01617553f, -0.02165588f, 0.07821669f, 0.04266216f, 0.15108418f, -0.20071675f, 
    0.15476376f, 0.07427211f, 0.10248119f, 0.09925993f, 0.06790377f, -0.08570245f, 0.05214831f, 0.03245070f, 
    0.15387793f, -0.26662362f, -0.00990562f, 0.01760763f, -0.00046868f, -0.05453463f, 0.04106938f, -0.08168474f, 
    0.00293544f, 0.07562599f, 0.00375036f, 0.09901031f, -0.11571500f, 0.20014396f, 0.13749929f, -0.03641048f, 
    0.01914605f, -0.05677323f, -0.07422789f, 0.00104099f, 0.04255064f, 0.11376023f, -0.05209990f, -0.01851193f, 
    0.02728996f, -0.07582410f, 0.23268640f, -0.15824047f, 0.00270456f, 0.11860823f, 0.07177731f, 0.03337501f, 
    -0.06046230f, 0.04195170f, -0.11442027f, -0.00056804f, -0.18110195f, -0.05127151f, 0.14407547f, 0.02690659f, 
    -0.00942592f, -0.18977082f, 0.04141847f, 0.04131958f, 0.15485153f, -0.02673614f, 0.16204700f, 0.02080635f, 
    0.10746640f, -0.06424391f, -0.10475354f, 0.08091173f, -0.01834525f, 0.05570745f, 0.05741444f, 0.19520722f, 
    0.11851140f, 0.02038331f, -0.27965784f, -0.00131332f, 0.02584240f, -0.16722947f, 0.07015660f, 0.22033133f, 
    0.10547063f, 0.09310344f, 0.00163687f, -0.13234438f, -0.03020971f, -0.08179299f, 0.02654868f, -0.09208944f, 
    0.04157234f, -0.27867225f, 0.11435843f, 0.03791112f, -0.00559497f, -0.16762850f, 0.22258930f, 0.21617350f, 
    -0.12306028f, 0.05674684f, -0.10860631f, -0.16607980f, -0.14681634f, -0.13150090f, 0.02520266f, -0.01184128f, 
    -0.05593056f, -0.08124367f, 0.00857978f, 0.04802033f, -0.10283067f, -0.21462736f, -0.10929236f, 0.07149868f, 
    0.27464572f, -0.04959992f, 0.05471071f, -0.23636489f, -0.02221669f, 0.09541604f, -0.07370105f, -0.04432790f, 
    -0.00404778f, 0.23396726f, 0.12346975f, 0.12969686f, -0.08331850f, 0.09940411f, -0.08440705f, 0.11833057f, 
    -0.04227839f, 0.10916144f, 0.04953061f, 0.01053430f, -0.09616112f, -0.07916402f, 0.09058769f, -0.02087302f, 
    -0.06667048f, -0.00032262f, -0.00065907f, -0.17266227f, 0.02272239f, 0.05730602f, -0.06139198f, 0.00740504f, 
    0.05693879f, 0.01010570f, -0.01305293f, -0.16397505f, 0.00502212f, 0.09393192f, -0.11302324f, 0.07297992f, 
    -0.01323185f, 0.19142352f, -0.02566862f, 0.01637734f, 0.04706299f, -0.27447206f, 0.03116228f, -0.13872576f, 
    0.01511258f, 0.07624720f, -0.03987008f, -0.21384048f, 0.08247504f, -0.08511124f, -0.03999735f, 0.12423477f, 
    0.04003239f, 0.13300771f, 0.03102701f, 0.10641421f, 0.26516500f, -0.08908350f, -0.01319882f, 0.09762912f, 
    0.18545836f, -0.14759158f, -0.03784857f, -0.05530479f, -0.05949861f, 0.01655836f, -0.07588911f, 0.03425875f, 
    0.34130573f, -0.08556661f, -0.09620089f, -0.02056582f, -0.07305229f, 0.05658850f, -0.04595674f, -0.02322274f, 
    -0.13120848f, 0.08404763f, -0.03175273f, -0.08005883f, 0.08653664f, 0.21258323f, -0.10265757f, 0.12326516f, 
    0.05233400f, -0.06027928f, 0.06227658f, 0.01828883f, -0.06983089f, -0.04582708f, 0.02949370f, 0.18734357f, 
    0.31965521f, 0.27832359f, -0.19152988f, -0.00113096f, -0.00261556f, 0.04057851f, 0.11127656f, 0.04546922f, 
    0.06892116f, -0.02358443f, -0.09018173f, -0.09936651f, 0.16396201f, -0.20149931f, -0.23941080f, 0.03544797f, 
    0.08734801f, 0.17643404f, 0.11959254f, -0.04783304f, -0.04836707f, -0.07854854f, 0.03393503f, -0.03069092f, 
    0.06214048f, -0.04182861f, -0.24975272f, 0.08833654f, 0.07464863f, 0.02814989f, -0.03933728f, 0.23648727f, 
    -0.24268010f, -0.00188807f, -0.08057956f, -0.09025387f, -0.23501773f, 0.16985726f, 0.01864848f, 0.10611099f, 
    -0.06825264f, 0.15739903f, -0.05450236f, 0.01126664f, -0.13408911f, -0.13520859f, -0.10766286f, 0.12273758f, 
    0.17208405f, 0.15535109f, -0.05732974f, 0.07067010f, -0.10907637f, -0.08855919f, 0.06464574f, 0.01201936f, 
    0.13369776f, -0.02124438f, 0.00196003f, -0.02571553f, 0.40186155f, -0.12469965f, 0.04250086f, -0.07356892f, 
    -0.08742771f, -0.03312143f, -0.00852489f, -0.03129814f, 0.02010131f, 0.19017863f, 0.00557958f, 0.02735731f, 
    -0.03920342f, -0.07660952f, 0.00068521f, -0.09439901f, -0.09722252f, -0.02490229f, 0.13935010f, -0.01279668f, 
    -0.04096280f, 0.03838719f, -0.01643452f, -0.02810284f, -0.30592346f, -0.35624132f, 0.06590038f, -0.09245031f, 
    0.07895447f, -0.02687236f, 0.01388419f, 0.01104641f, -0.08947803f, 0.13197191f, 0.12091067f, -0.03774095f, 
    -0.27122515f, 0.04356382f, -0.12079875f, -0.19968896f, 0.06664249f, -0.05707487f, -0.07193203f, 0.00056584f, 
    0.00237558f, 0.03351453f, 0.02664869f, 0.03410274f, 0.22114116f, 0.14248075f, 0.04489458f, -0.07960393f, 
    -0.06292234f, 0.04596892f, -0.12064984f, 0.04741892f, -0.15383258f, 0.02692810f, 0.13511565f, -0.14249539f, 
    -0.21092463f, -0.25665933f, -0.11048469f, -0.17482398f, 0.08929615f, -0.10256781f, -0.11879437f, 0.03229434f, 
    -0.00790067f, 0.01388476f, 0.03923110f, -0.01566478f, 0.05230216f, 0.23404996f, 0.02996853f, 0.12437913f, 
    -0.05432537f, 0.06917387f, -0.00136307f, 0.10065585f, -0.07251912f, 0.04251163f, 0.00195174f, 0.06630670f, 
    0.29885149f, 0.07412960f, -0.05328418f, 0.03577686f, 0.02909542f, -0.20242882f, 0.05261570f, 0.10121939f, 
    0.06007043f, -0.03806638f, -0.04103003f, -0.03731406f, -0.00779186f, -0.16065508f, -0.00346806f, 0.04055688f, 
    0.22874056f, -0.01953336f, 0.02258978f, -0.14209799f, 0.05450318f, 0.20718206f, -0.06087449f, 0.07305946f, 
    0.44689518f, 0.03853288f, 0.00534270f, 0.09347012f, 0.00354610f, -0.14099841f, 0.11193150f, 0.10128199f, 
    -0.02191496f, -0.06251895f, 0.02868459f, 0.12170165f, -0.02777137f, 0.12954508f, 0.14000811f, 0.11692968f, 
    0.05684375f, -0.08886298f, 0.06771995f, -0.05908081f, 0.08252131f, 0.08088186f, 0.10455839f, 0.09167242f, 
    0.01099348f, -0.09093191f, -0.07371543f, 0.11131786f, 0.05681036f, -0.09438264f, 0.03005140f, 0.05893111f, 
    0.08816341f, 0.07996115f, 0.02731893f, 0.05373884f, 0.15159844f, 0.09342840f, -0.13685378f, 0.07887050f, 
    0.06011718f, -0.02681692f, -0.00569643f, 0.00433221f, 0.12306207f, -0.02342208f, 0.09156323f, -0.04818045f, 
    0.04442389f, -0.17595972f, 0.06407132f, -0.11306468f, 0.11981190f, 0.08418754f, -0.04358770f, 0.01661418f, 
    0.00519675f, 0.24140617f, 0.01103574f, 0.01842367f, 0.12756915f, 0.06824789f, -0.13074261f, 0.05473467f, 
    -0.15634160f, 0.06391192f, -0.10212693f, 0.00988866f, 0.06502937f, 0.11083169f, 0.00438196f, 0.01922646f, 
    -0.02383017f, 0.13601740f, -0.08663389f, 0.01753845f, -0.06711374f, 0.00970543f, 0.09549338f, -0.09980782f, 
    0.14652541f, 0.09255203f, 0.09133362f, -0.14670055f, 0.12694196f, -0.18414828f, -0.08439932f, -0.20531112f, 
    -0.13068375f, 0.00187597f, -0.09925217f, -0.01850503f, 0.02884567f, 0.10730402f, 0.02829791f, -0.02210557f, 
    -0.09458509f, -0.03909041f, -0.14593811f, 0.02390341f, -0.05985094f, 0.06949432f, 0.06254174f, -0.05154334f, 
    -0.08966109f, -0.05436799f, 0.09807066f, 0.14514142f, -0.07445616f, -0.15083310f, -0.02717679f, -0.17215741f, 
    -0.02890993f, 0.04243505f, 0.02336548f, -0.09089208f, -0.02818153f, 0.15229365f, 0.15124372f, 0.03328675f, 
    -0.13976404f, 0.06019520f, -0.14794618f, 0.16043115f, -0.04857380f, 0.23606834f, 0.09278122f, 0.00867768f, 
    -0.02772683f, -0.07757955f, 0.01474570f, 0.12684222f, -0.05293883f, 0.02624782f, -0.13591148f, 0.07463276f, 
    -0.04900431f, -0.13613829f, 0.12423860f, 0.03373194f, -0.05551048f, 0.09356891f, 0.02521658f, 0.07062263f, 
    0.23670027f, -0.06502207f, 0.08998704f, 0.14488566f, -0.08693647f, -0.04187330f, -0.09310506f, -0.02429554f, 
    0.04907808f, -0.11684836f, 0.10111377f, -0.13467433f, -0.38201529f, -0.03644453f, -0.00091169f, 0.03507063f, 
    0.04747722f, -0.14673850f, 0.11337647f, 0.05065364f, 0.01096007f, -0.03600093f, -0.13781451f, -0.09063675f, 
    -0.10385576f, 0.05791512f, -0.00921525f, 0.23028667f, 0.07813761f, -0.07274121f, -0.00150139f, 0.15586567f, 
    0.14506954f, 0.09162990f, 0.11678380f, 0.16233416f, 0.12391571f, -0.20502228f, -0.23125032f, -0.04104401f, 
    -0.05180461f, 0.04378533f, 0.04073212f, -0.14219826f, 0.03023979f, -0.00479500f, -0.09108394f, 0.02831319f, 
    -0.10417044f, 0.02779240f, -0.08933186f, -0.14569674f, 0.08795396f, -0.08469255f, -0.03031060f, 0.12454596f, 
    0.16541429f, -0.00038131f, -0.01407269f, 0.10283198f, 0.34181067f, -0.13189359f, -0.10869542f, -0.10443678f, 
    -0.05648015f, 0.01940352f, 0.04870088f, -0.06591494f, 0.14805311f, -0.01740686f, -0.06680076f, -0.05202345f, 
    0.14748797f, -0.24155971f, -0.02808213f, 0.18878950f, 0.09591286f, 0.06961094f, -0.01985517f, -0.01200721f, 
    0.10582969f, -0.05762590f, -0.01172030f, 0.00165531f, -0.15047781f, 0.16314110f, 0.14578800f, 0.02992496f, 
    0.03829533f, 0.00425729f, -0.08335640f, -0.01868980f, 0.01755483f, -0.08749354f, -0.01407040f, 0.01216503f, 
    0.24387507f, 0.09864427f, 0.14658183f, -0.02233929f, -0.13143778f, 0.11432876f, 0.14007230f, -0.04479901f, 
    0.06040327f, -0.02500162f, 0.09482612f, 0.04201316f, 0.11977137f, -0.09348733f, 0.11258604f, -0.19755180f, 
    0.04669463f, 0.05552430f, -0.16241683f, 0.02142361f, -0.01607356f, -0.24892893f, 0.02286010f, 0.09969632f, 
    -0.51874197f, 0.25652140f, -0.02143400f, 0.01646713f, -0.11293361f, 0.08463885f, 0.12621869f, 0.09107693f, 
    -0.10562860f, 0.09125337f, 0.11009176f, 0.07041069f, 0.18660669f, -0.06951083f, -0.05813855f, 0.19582331f, 
    0.13223280f, -0.01926358f, -0.18899266f, 0.02239419f, -0.06189362f, -0.11088710f, 0.02406989f, 0.09709012f, 
    0.03498949f, 0.09342463f, -0.11166629f, -0.01555189f, -0.10617181f, -0.04484425f, -0.11012208f, 0.05870357f, 
    0.01752054f, -0.01456238f, -0.13563715f, 0.02013359f, -0.16581906f, 0.29277357f, -0.15610810f, 0.14929937f, 
    -0.04989658f, -0.01249414f, -0.14409107f, 0.13146603f, 0.18906207f, -0.10759665f, -0.09378862f, 0.11516750f, 
    0.37450114f, -0.03092344f, 0.28502253f, 0.05626920f, -0.03945539f, -0.12620756f, -0.21032472f, -0.02430289f, 
    0.05184848f, 0.09086565f, -0.06850365f, -0.17139198f, -0.38687304f, -0.29335439f, -0.07890144f, 0.03013870f, 
    0.10537855f, 0.08624394f, -0.02288941f, 0.06845331f, 0.03686596f, 0.03165488f, 0.16603540f, 0.04506288f, 
    -0.04429710f, 0.17904936f, 0.14816438f, 0.02317654f, 0.24618275f, 0.02829227f, -0.00787660f, -0.14286421f, 
    -0.04787007f, 0.06909682f, -0.02861266f, 0.12953056f, 0.11723773f, -0.14201589f, 0.03695805f, -0.26785588f, 
    0.14414197f, -0.00157506f, -0.05430686f, 0.03962712f, -0.00132733f, -0.03479560f, 0.10258006f, 0.03234392f, 
    -0.24931110f, 0.09642368f, -0.10945190f, -0.08305474f, -0.04534090f, 0.12725027f, 0.11795601f, -0.02891127f, 
    -0.06389729f, 0.13320538f, 0.02685718f, 0.09683013f, 0.06683230f, 0.09235069f, 0.07615725f, 0.11272835f, 
    0.03597105f, -0.02283611f, 0.11991928f, 0.13626768f, -0.04556505f, -0.00487242f, 0.27102649f, -0.01278377f, 
    -0.20299780f, -0.06439471f, 0.12643990f, -0.01241135f, 0.09525911f, -0.01808283f, -0.01206789f, -0.10548525f, 
    -0.01194964f, 0.12538487f, 0.04213743f, 0.06983697f, -0.23138820f, 0.18269892f, -0.09999093f, 0.20918272f, 
    -0.07255721f, 0.07802950f, 0.10446467f, 0.01415584f, 0.09503762f, -0.02500618f, 0.02988064f, -0.05908072f, 
    -0.02523145f, 0.17693433f, 0.10698190f, -0.07756615f, 0.13356808f, 0.16150530f, -0.08476470f, -0.07368124f, 
    -0.17734146f, -0.05457698f, 0.04492252f, 0.08433127f, 0.38626066f, -0.15046096f, -0.14949426f, 0.08383593f, 
    0.13476390f, 0.05549024f, 0.12524967f, 0.00411468f, -0.06725433f, 0.09549158f, 0.08480370f, 0.06111100f, 
    -0.09288321f, 0.13236648f, -0.17682528f, -0.03017334f, -0.04208643f, 0.00584487f, 0.07650322f, 0.08803836f, 
    0.07542440f, -0.07397490f, -0.10483234f, 0.00830172f, -0.41796890f, -0.31532773f, -0.02256193f, -0.02098703f, 
    -0.01207663f, 0.00012971f, 0.11939606f, -0.08096194f, -0.14517877f, 0.03093096f, 0.08716075f, -0.01893613f, 
    0.11013384f, -0.36695281f, -0.12085325f, -0.18997867f, 0.17683460f, -0.03791479f, -0.00671331f, 0.04662830f, 
    -0.07577933f, 0.08123013f, 0.01140526f, -0.10135391f, -0.07168882f, 0.16304114f, 0.15378489f, 0.10042605f, 
    0.14479381f, 0.17345552f, 0.01010661f, -0.26198378f, -0.04430036f, -0.09190558f, -0.05005003f, -0.07190648f, 
    0.04739860f, -0.01176834f, -0.05731037f, -0.01714852f, -0.07164647f, -0.04727021f, 0.03929373f, 0.00548890f, 
    0.00500329f, 0.03423853f, 0.01964018f, 0.06460185f, -0.05294890f, -0.01013214f, -0.02530804f, -0.07207061f, 
    -0.03325482f, -0.06264754f, 0.02526767f, 0.03524235f, 0.03107447f, -0.06446025f, -0.02235481f, -0.02407533f, 
    -0.06817870f, 0.01391707f, -0.00190325f, -0.07098597f, -0.04060125f, 0.01380026f, 0.05052482f, 0.05783979f, 
    -0.01824245f, 0.02838027f, -0.06529038f, -0.01046840f, -0.03097093f, -0.05030054f, -0.05463591f, 0.03974849f, 
    -0.07464665f, -0.01269826f, -0.05631595f, 0.05800259f, 0.01682630f, -0.00605906f, -0.02463480f, -0.04925342f, 
    -0.06103880f, 0.04993854f, 0.04555767f, 0.03191952f, 0.01173956f, -0.03070541f, -0.03776217f, 0.00392990f, 
    0.04918920f, -0.02755673f, -0.03245076f, -0.05463638f, -0.07439782f, 0.05419182f, 0.05327283f, -0.03729560f, 
    -0.04775549f, 0.06520814f, 0.03974709f, -0.00914927f, -0.02516519f, -0.03217912f, -0.07296524f, 0.03007192f, 
    -0.01479793f, 0.00141803f, -0.06107787f, -0.07028461f, -0.06675448f, -0.02248051f, 0.00721702f, -0.04364037f, 
    0.05957428f, -0.06017648f, 0.01728761f, 0.06341530f, -0.04402429f, 0.02587217f, 0.03901573f, -0.03057104f, 
    -0.02103347f, -0.04411193f, -0.04377955f, -0.02200661f, 0.06352904f, -0.04845887f, -0.05578136f, -0.03107146f, 
    -0.02529439f, -0.00893579f, 0.04275588f, -0.01850539f, 0.06097524f, 0.04061056f, -0.07114948f, 0.02835278f, 
    -0.04314937f, -0.00135284f, 0.00111449f, -0.02681016f, 0.05445205f, 0.01147076f, 0.02118872f, -0.05790559f, 
    -0.00817866f, 0.00112107f, -0.00531829f, 0.06080363f, -0.06570584f, 0.01966219f, -0.01398222f, -0.04332847f, 
    0.05479195f, 0.06306337f, -0.03657279f, 0.00607982f, 0.01300058f, -0.02921229f, -0.01788555f, -0.04845301f, 
    0.03635745f, -0.05432214f, -0.01298849f, -0.03847331f, -0.02734008f, 0.01893277f, 0.04382211f, -0.01227314f, 
    -0.06480059f, 0.04964665f, -0.06941197f, -0.01209984f, 0.02174167f, 0.03249394f, 0.02423299f, -0.04648784f, 
    0.06172505f, 0.01975805f, -0.00394087f, -0.01019055f, -0.03973613f, -0.02488871f, -0.05241275f, 0.03856704f, 
    0.06111548f, 0.02713549f, 0.03112667f, -0.00992915f, 0.01245601f, 0.01738269f, -0.06572510f, -0.05613632f, 
    -0.03839526f, 0.03312019f, -0.02519905f, -0.04094322f, 0.05725669f, 0.05795270f, 0.02631550f, -0.04807492f, 
    0.04831281f, -0.01681891f, 0.01871413f, 0.02814551f, -0.05264619f, 0.02242540f, 0.03418569f, 0.02357171f, 
    -0.05873742f, 0.03491534f, -0.05578588f, 0.04675230f, -0.01213208f, -0.01243951f, -0.04743818f, -0.02329089f, 
    0.00077677f, -0.02773306f, -0.06419483f, -0.06478713f, -0.01051910f, 0.06393331f, -0.07371895f, -0.04238585f, 
    0.06376467f, 0.14836861f, -0.11905783f, -0.10791491f, 0.01231481f, 0.02764454f, -0.15556140f, -0.05089074f, 
    -0.03196641f, -0.01265668f, -0.04497028f, 0.13079014f, 0.44242087f, 0.20495175f, -0.13253392f, 0.13605341f, 
    -0.03328132f, 0.04230985f, -0.04534299f, -0.01026916f, 0.16924262f, 0.01331373f, -0.02582842f, 0.00363646f, 
    -0.07286528f, 0.08938251f, 0.01767903f, 0.24781464f, 0.00260777f, 0.05224505f, 0.11925967f, 0.05819284f, 
    0.09064507f, -0.10563523f, 0.07734421f, -0.01159116f, -0.08055839f, -0.14741582f, 0.07725315f, 0.01146891f, 
    0.12578845f, 0.00748346f, 0.12540719f, -0.00138312f, 0.17564204f, 0.00455339f, -0.00005697f, 0.11709722f, 
    0.19122191f, 0.05327705f, 0.07406896f, 0.14771117f, -0.06227137f, 0.06843951f, 0.06353141f, -0.08777203f, 
    0.08212866f, -0.01426236f, -0.00160086f, 0.05936376f, -0.14921881f, -0.24180993f, 0.12559630f, -0.24795075f, 
    -0.06305087f, -0.06714108f, -0.03354226f, -0.02956774f, 0.02298845f, 0.03081998f, -0.01389809f, -0.00489731f, 
    0.08124619f, 0.01516719f, 0.17623115f, 0.27521664f, 0.05107295f, 0.17031039f, 0.08838778f, -0.03069379f, 
    -0.02262619f, 0.02155348f, 0.07400861f, 0.05936841f, -0.19269060f, 0.11107522f, -0.06266236f, -0.08105685f, 
    -0.20775117f, 0.10081047f, 0.05947791f, 0.07571352f, -0.02574080f, -0.13691269f, 0.00043392f, -0.03828666f, 
    -0.56349248f, 0.15229245f, 0.03916961f, -0.08131430f, -0.04832586f, 0.02157326f, 0.00737868f, -0.07424029f, 
    0.07978271f, 0.04251456f, 0.10036232f, -0.07749723f, 0.11764220f, -0.12731633f, 0.03048237f, 0.04438322f, 
    -0.10031590f, -0.05177931f, -0.08059207f, 0.01619552f, -0.06089781f, -0.03936154f, 0.02029156f, -0.15607676f, 
    -0.09779525f, -0.16545071f, 0.07171698f, -0.04009012f, -0.16674286f, 0.05043196f, -0.10357836f, -0.05758675f, 
    -0.09506103f, -0.05454584f, 0.07581875f, 0.10579555f, -0.11506839f, -0.00484200f, 0.17516544f, -0.04609375f, 
    -0.00371449f, -0.01562481f, -0.09538426f, -0.06088075f, 0.01871822f, 0.02771747f, -0.08470295f, 0.13999042f, 
    0.15247448f, 0.15366139f, 0.17298801f, 0.23196605f, -0.20984653f, 0.03466890f, 0.10765970f, 0.05999095f, 
    -0.01042072f, -0.05511133f, 0.13848625f, 0.09689725f, 0.04237794f, 0.05087019f, 0.18055263f, 0.03148292f, 
    0.27417725f, 0.05226046f, 0.21034917f, 0.06245876f, -0.07265721f, -0.10797485f, 0.08063824f, 0.01991664f, 
    0.01640814f, -0.09354576f, 0.13335395f, 0.01573716f, 0.07390741f, 0.16539432f, -0.03141289f, 0.19280422f, 
    -0.05075817f, 0.08153004f, -0.07618212f, 0.06120587f, -0.05940148f, 0.12862034f, 0.04996486f, 0.17654370f, 
    -0.00845327f, 0.00467156f, -0.05472350f, -0.06879371f, -0.11992617f, -0.09663682f, -0.01185572f, -0.03811825f, 
    0.32892439f, 0.15663533f, -0.16636808f, 0.06400116f, -0.03977524f, -0.12296013f, 0.05825247f, -0.07678156f, 
    0.02523044f, -0.01138267f, 0.06235411f, -0.04709946f, -0.10740669f, 0.16510330f, -0.08779596f, 0.03367788f, 
    -0.17439999f, -0.00301058f, -0.00512765f, 0.01736573f, 0.07016066f, 0.02200389f, 0.05304182f, -0.00009760f, 
    0.22406709f, -0.03318539f, 0.24164517f, 0.07487825f, 0.05511378f, -0.10097219f, -0.01988222f, 0.06394318f, 
    0.04319480f, 0.13243791f, 0.07870643f, -0.18338071f, -0.43991554f, -0.12136761f, -0.14743328f, -0.05496146f, 
    0.02362044f, 0.07506064f, 0.06307049f, 0.00893314f, 0.02229999f, -0.02653924f, -0.15000287f, 0.06293528f, 
    -0.05730429f, 0.21100706f, 0.21218106f, 0.14912821f, 0.09611470f, 0.11814772f, 0.01830021f, -0.04989468f, 
    -0.09588112f, 0.01362058f, -0.04483485f, 0.15632896f, 0.23854434f, -0.19676609f, 0.01056826f, -0.08576453f, 
    0.04658237f, 0.10973031f, 0.02315900f, -0.02140155f, 0.11332441f, 0.07927881f, 0.17111632f, 0.04967559f, 
    -0.18726586f, -0.05533090f, 0.10530607f, -0.31338188f, 0.02221942f, 0.12267812f, 0.03837259f, -0.09867409f, 
    0.08780605f, 0.04710325f, 0.01242458f, 0.00469520f, 0.02813121f, 0.31498811f, 0.11157217f, -0.00090245f, 
    -0.06795572f, 0.01631165f, 0.00012627f, 0.11378870f, -0.05265284f, -0.13943376f, 0.01459253f, 0.04328437f, 
    -0.30076244f, -0.17832305f, 0.12875497f, -0.19514695f, 0.02587260f, 0.10823823f, 0.02153208f, 0.02340327f, 
    0.05455767f, 0.04919929f, 0.01022398f, -0.05273524f, -0.19521317f, 0.00942607f, 0.07457728f, -0.17312174f, 
    0.06012992f, -0.01374153f, -0.05339096f, -0.01904520f, -0.06993014f, -0.05832542f, 0.09769073f, -0.14790879f, 
    0.00989880f, 0.17346872f, 0.20547095f, -0.19708644f, -0.03068825f, 0.06486303f, -0.01293986f, 0.01516445f, 
    -0.13293993f, -0.01027245f, 0.04229082f, 0.03150941f, 0.14576152f, 0.02925840f, -0.08182650f, 0.03176255f, 
    -0.04268459f, -0.03781796f, 0.05120254f, 0.01924985f, 0.04054841f, -0.07772041f, 0.05521635f, 0.06535955f, 
    -0.19491056f, 0.05982074f, -0.11155134f, 0.11525487f, -0.01601733f, -0.13130754f, -0.03401616f, -0.01047822f, 
    -0.00627366f, -0.01412491f, 0.02078217f, 0.01381480f, -0.15546983f, -0.04845262f, 0.03642486f, 0.01240341f, 
    0.09668522f, 0.10638510f, 0.12086830f, -0.01980615f, -0.06487900f, 0.05726590f, -0.01270050f, -0.18799904f, 
    0.20786978f, -0.12332021f, 0.03602387f, -0.15421599f, 0.21665788f, 0.07879869f, -0.00905708f, 0.04486115f, 
    -0.02241206f, -0.10798355f, -0.09150302f, 0.06430453f, 0.09068258f, -0.00946416f, 0.31080008f, 0.10830177f, 
    -0.00840102f, 0.07796057f, 0.04013082f, -0.01396234f, 0.05294301f, -0.06793914f, 0.01791280f, 0.12316034f, 
    -0.08536746f, -0.05256032f, -0.15496002f, -0.18996619f, -0.00743154f, 0.02313092f, 0.04573619f, 0.05086105f, 
    0.21402471f, -0.03306016f, 0.02523473f, 0.03393344f, 0.17912337f, 0.02438686f, -0.06221898f, 0.08010112f, 
    -0.03170449f, -0.06608085f, 0.08762468f, 0.10849860f, -0.05231583f, 0.08081654f, 0.00283761f, 0.16524523f, 
    0.05880385f, -0.01623362f, -0.05227903f, 0.14946009f, 0.07998944f, -0.07613238f, -0.04692136f, 0.00888496f, 
    0.17272364f, -0.03192676f, -0.04458010f, 0.05347804f, 0.15017271f, -0.09402020f, -0.02585942f, -0.13211064f, 
    -0.16564322f, -0.17549278f, -0.12330611f, 0.04003016f, 0.03452868f, 0.09774841f, -0.10334370f, 0.09633770f, 
    -0.07540380f, -0.11301516f, -0.09252471f, -0.29101098f, 0.00653826f, 0.02484769f, 0.05425650f, 0.08081160f, 
    -0.14993717f, 0.09148549f, 0.04131994f, 0.11367822f, 0.01693415f, 0.03723250f, -0.08367117f, -0.05931264f, 
    -0.05460891f, 0.07750840f, -0.00586628f, 0.10493662f, 0.13150626f, 0.03600751f, 0.04610547f, -0.00292267f, 
    0.14548372f, -0.00711111f, -0.00669348f, 0.15982655f, -0.17063442f, -0.04473563f, -0.02754125f, 0.10075800f, 
    -0.13433181f, -0.10213055f, -0.01171701f, -0.02653843f, -0.17926204f, 0.23287013f, 0.09318727f, -0.08226930f, 
    0.08746269f, 0.20371009f, 0.05476326f, 0.05948464f, 0.03462347f, 0.19343458f, 0.04773305f, -0.00272967f, 
    -0.12010293f, 0.08003398f, 0.01199301f, 0.26243338f, 0.10731676f, -0.10669782f, 0.06166684f, 0.18467309f, 
    0.11138996f, 0.04604099f, 0.00978499f, -0.10907710f, -0.17067574f, 0.03466454f, 0.19549210f, 0.08975681f, 
    0.05241241f, 0.23276448f, 0.02607552f, -0.02142065f, -0.01432196f, -0.00400227f, 0.00576085f, 0.07661156f, 
    -0.47884214f, -0.00577299f, 0.16733979f, -0.18012001f, 0.09795580f, 0.06678504f, 0.04696485f, 0.07921899f, 
    0.08025107f, 0.00404900f, 0.00127475f, 0.08163400f, -0.03125687f, 0.12001036f, 0.01860611f, -0.17011921f, 
    0.14732361f, -0.00250146f, 0.08770803f, 0.06642940f, -0.04191198f, 0.03823282f, -0.02488843f, 0.11253601f, 
    -0.16377907f, -0.05333252f, 0.23758382f, 0.01824036f, 0.08057268f, -0.02574228f, -0.04536102f, -0.05609779f, 
    0.09194241f, -0.07829229f, -0.00314766f, 0.13026427f, 0.04459344f, 0.01398693f, -0.09514563f, 0.01683164f, 
    -0.21380593f, -0.10385954f, 0.09440014f, -0.03064575f, -0.06142618f, 0.22782612f, 0.14967750f, 0.06243057f, 
    0.14699157f, -0.28690127f, -0.08053654f, -0.15622203f, 0.02559855f, 0.02371243f, -0.04899809f, 0.09531084f, 
    0.03649336f, -0.06007036f, 0.03707481f, -0.00725119f, -0.48152906f, 0.21068124f, -0.21919264f, -0.48281881f, 
    0.15576048f, 0.03148996f, 0.09557810f, 0.01377866f, -0.00240286f, 0.06154881f, -0.00251576f, 0.04802527f, 
    0.12443158f, -0.17061512f, -0.08507533f, 0.02929636f, 0.07394266f, -0.14905900f, -0.00307099f, -0.11911260f, 
    -0.06231849f, -0.01781600f, -0.09180677f, 0.13559188f, -0.04924693f, -0.18193926f, 0.18187694f, -0.02487588f, 
    -0.01097908f, -0.10586220f, 0.11436903f, -0.07767718f, 0.14500616f, 0.10874571f, 0.06408040f, -0.09295274f, 
    -0.07819942f, -0.02366712f, 0.07299068f, -0.02841306f, 0.00008534f, -0.14538871f, 0.00942435f, 0.15698874f, 
    -0.00717267f, 0.05276261f, -0.01799184f, -0.07218825f, -0.25348222f, 0.08302487f, -0.11248002f, -0.11153992f, 
    0.13597353f, 0.00029662f, 0.02860077f, 0.01115338f, 0.05024188f, -0.01685748f, 0.06572332f, 0.09337705f, 
    -0.15713280f, -0.05240181f, 0.12910467f, -0.00402353f, 0.02391904f, 0.07589830f, -0.00247399f, -0.10491265f, 
    0.01833448f, 0.03831374f, -0.08906597f, 0.15451594f, -0.17285791f, 0.01569094f, -0.07588212f, 0.06055255f, 
    0.17443299f, 0.09206808f, -0.15719676f, 0.04594762f, -0.06391068f, 0.05820759f, 0.12723434f, 0.15978989f, 
    -0.06818371f, -0.04500647f, -0.04992485f, -0.23571528f, 0.00937717f, 0.09911028f, 0.06531563f, -0.01534047f, 
    -0.03650212f, -0.11328037f, -0.00809724f, -0.03820764f, 0.12593554f, 0.09746265f, 0.14767568f, 0.07673202f, 
    -0.00546097f, -0.12979138f, -0.00242820f, 0.10120370f, 0.03330948f, -0.11976276f, 0.08918834f, -0.00557466f, 
    -0.07867880f, -0.00359704f, -0.04721129f, -0.24092351f, 0.06643549f, 0.10329784f, -0.04889370f, -0.08361007f, 
    0.03126677f, 0.01476384f, 0.10915008f, 0.00298480f, 0.06962995f, -0.04194099f, 0.15876448f, 0.03631498f, 
    0.04649733f, -0.09392469f, 0.02606280f, 0.01606768f, 0.02771902f, 0.01287012f, 0.02914467f, -0.18193288f, 
    0.25437319f, 0.03411619f, 0.02768807f, 0.06127757f, -0.06851553f, -0.10473987f, -0.10317358f, -0.01936333f, 
    0.06685714f, 0.02710678f, 0.04470668f, 0.08786470f, -0.04888241f, 0.02758993f, -0.08583596f, 0.18691689f, 
    -0.08760596f, 0.02797355f, 0.12341904f, 0.07459570f, 0.02903234f, 0.13601640f, 0.18285289f, 0.04777326f, 
    0.04465523f, -0.01643702f, 0.03093261f, 0.14751656f, 0.05385236f, 0.01633830f, 0.06946647f, 0.14139988f, 
    0.01291433f, 0.01098158f, 0.00461460f, 0.10803729f, -0.30155188f, -0.14442062f, -0.13351688f, 0.00383421f, 
    0.00699935f, 0.18485095f, 0.07371069f, -0.01658549f, 0.10457846f, -0.00452884f, -0.00082620f, -0.08749542f, 
    -0.13111913f, 0.12149753f, -0.05329797f, -0.15760940f, 0.15216751f, 0.10451172f, 0.05750348f, 0.02508808f, 
    0.12882505f, -0.07091089f, -0.03534564f, -0.11634896f, 0.12598036f, -0.12434835f, 0.28027901f, 0.06174834f, 
    -0.10614059f, 0.06136607f, 0.05936747f, -0.02464890f, 0.07753563f, -0.04031844f, 0.12638576f, 0.00717693f, 
    -0.24294154f, 0.04263319f, 0.08353933f, 0.15515953f, -0.02809070f, 0.07448746f, -0.03009402f, 0.15197669f, 
    0.10599238f, -0.03815052f, 0.08883832f, -0.04581603f, -0.42317447f, 0.12497489f, -0.15297702f, -0.00622466f, 
    -0.05337375f, 0.17914076f, 0.05987624f, -0.02984217f, 0.06415706f, -0.09258868f, -0.13486396f, 0.13234116f, 
    -0.09314746f, -0.10148247f, 0.01647339f, -0.25923958f, -0.11396225f, 0.07569805f, -0.02809440f, -0.05817391f, 
    -0.00614838f, 0.12707540f, -0.05889031f, 0.00597080f, -0.01749572f, 0.04025496f, 0.07336069f, 0.23600747f, 
    0.04390066f, -0.06975072f, 0.14659150f, -0.04712622f, 0.04940958f, 0.02039520f, -0.00875632f, 0.04492076f, 
    0.02984482f, 0.03723131f, 0.07930133f, -0.06585409f, 0.01071723f, 0.02032686f, 0.02192384f, -0.05121489f, 
    0.11042495f, -0.07608715f, 0.07881650f, 0.02822080f, 0.04786257f, -0.10303485f, 0.21405067f, -0.07591591f, 
    -0.05839635f, 0.01015567f, 0.14577278f, 0.01063168f, -0.00657559f, 0.06961273f, -0.17114475f, 0.04748416f, 
    0.10699981f, 0.14343037f, 0.02233222f, 0.33483306f, 0.02284370f, -0.03347633f, -0.00836860f, 0.09459271f, 
    0.05654333f, 0.05609276f, 0.04354024f, -0.05099900f, -0.28962049f, -0.16848984f, 0.01584070f, 0.01049263f, 
    -0.02423470f, 0.05526777f, 0.04675224f, 0.04051052f, 0.02128001f, -0.04299126f, -0.01656565f, 0.06747926f, 
    0.00968559f, -0.01182863f, 0.08927277f, -0.09639953f, -0.03601781f, 0.01337371f, 0.05355855f, 0.03223157f, 
    0.03720355f, -0.00117817f, -0.01128478f, 0.03067707f, 0.02833877f, -0.03095371f, -0.21108361f, 0.08366302f, 
    -0.15771696f, -0.02889195f, -0.00477502f, -0.00466151f, 0.04781872f, -0.01375294f, -0.01113893f, 0.04040611f, 
    -0.21605891f, 0.13093922f, 0.03522512f, 0.09179599f, 0.09468445f, 0.16303754f, -0.00619133f, -0.05092362f, 
    -0.05517209f, -0.07382073f, 0.05777732f, 0.00465989f, 0.23098509f, -0.02893015f, 0.15369724f, 0.04208641f, 
    0.11449285f, 0.00767986f, -0.04967844f, -0.02562660f, 0.01854419f, -0.10036253f, -0.08535623f, 0.03882984f, 
    0.06638009f, 0.16837022f, -0.06008752f, 0.01485548f, -0.08127100f, -0.05340367f, -0.04269937f, -0.08058352f, 
    0.07882697f, 0.02513414f, 0.06746101f, -0.11048024f, 0.31854239f, -0.02597325f, 0.09674460f, -0.08400503f, 
    0.07199750f, 0.11866847f, -0.02814598f, 0.04184622f, -0.13604735f, -0.07980595f, 0.05014338f, 0.06660493f, 
    0.00353564f, 0.16582362f, 0.09122746f, 0.20433480f, 0.00704331f, 0.00893009f, 0.07061476f, 0.03545174f, 
    -0.12214804f, 0.11931762f, 0.02734742f, 0.09309439f, -0.02996928f, -0.01457923f, -0.09244195f, -0.03706682f, 
    0.12678754f, -0.01087705f, -0.09690653f, -0.05802944f, -0.06457674f, 0.01323589f, 0.05625547f, 0.07755063f, 
    0.33826080f, 0.18799146f, -0.03334847f, -0.13011739f, 0.01705095f, -0.23088190f, -0.05275731f, 0.15072381f, 
    0.05142095f, -0.13895559f, -0.05348131f, 0.01097908f, 0.30880687f, 0.11145958f, -0.00650038f, 0.18498212f, 
    0.03942208f, -0.05607875f, 0.05565693f, 0.22132163f, 0.10473941f, 0.07294643f, -0.06562290f, 0.08294585f, 
    0.10259967f, -0.01035563f, -0.20843367f, -0.12342513f, -0.01488256f, 0.00802110f, -0.03723510f, -0.04825146f, 
    0.09309556f, 0.03713929f, 0.01771948f, -0.02432811f, 0.20639510f, -0.04395656f, 0.10781847f, 0.13310392f, 
    -0.02298982f, -0.19961081f, -0.00164036f, 0.18313213f, 0.01052528f, 0.11011484f, 0.03054519f, 0.10661803f, 
    -0.00752368f, -0.12838116f, -0.24802950f, -0.17279378f, 0.23918912f, -0.04323488f, 0.01762492f, -0.10436240f, 
    -0.04386530f, -0.08488245f, -0.03415304f, 0.20176584f, 0.06376712f, -0.21820550f, -0.26835954f, -0.19048697f, 
    0.03676345f, -0.01966930f, -0.10785186f, 0.02297468f, 0.02889973f, 0.07479597f, 0.10564022f, 0.03462900f, 
    -0.19393802f, 0.03222983f, 0.06407121f, -0.00422483f, -0.14483370f, 0.11394046f, -0.04775694f, -0.05054932f, 
    0.05002054f, 0.12464248f, 0.10591064f, 0.01340934f, -0.01559263f, 0.25158060f, -0.02509343f, -0.24634825f, 
    0.06246779f, 0.10353442f, 0.09882821f, 0.06673508f, 0.10340658f, 0.02829916f, 0.17643012f, -0.04778941f, 
    -0.20302333f, -0.06580856f, 0.15440857f, 0.14263958f, -0.00080713f, -0.18556662f, 0.00804173f, -0.08030585f, 
    0.00866783f, -0.05456374f, 0.11590286f, 0.03776094f, -0.12936479f, 0.04259428f, -0.02815656f, -0.06808075f, 
    0.14792506f, 0.03829265f, 0.13555618f, -0.00127886f, 0.03999209f, 0.00555700f, 0.05490504f, 0.04377490f, 
    -0.11949237f, -0.03993766f, -0.08527631f, -0.26285058f, 0.05515202f, -0.04868450f, -0.02890551f, -0.01786011f, 
    -0.03574215f, 0.16376865f, 0.10280091f, 0.18870090f, 0.27901006f, -0.12307469f, -0.03907327f, -0.05904115f, 
    0.13748561f, -0.05111052f, -0.05187863f, 0.01511010f, -0.05690727f, 0.12584598f, -0.03703788f, 0.02432736f, 
    -0.32012782f, 0.10964303f, 0.09957268f, -0.08341511f, 0.03181287f, -0.00366993f, 0.03105592f, 0.02799517f, 
    0.03782630f, 0.02341654f, -0.07391751f, 0.15212902f, -0.30623731f, 0.00096950f, 0.15521264f, 0.37320799f, 
    -0.08725369f, -0.15751001f, 0.07398283f, 0.00122266f, 0.12381023f, 0.09882988f, 0.17817558f, -0.09677655f, 
    0.26337627f, -0.15402338f, 0.04245776f, 0.09230787f, 0.05464905f, -0.04180251f, -0.00552025f, 0.08913444f, 
    0.03717910f, -0.04712096f, -0.16776183f, -0.14617038f, -0.15109387f, 0.04535727f, -0.21713376f, -0.26128232f, 
    0.16611701f, 0.03317868f, 0.00893630f, -0.15187073f, -0.05527483f, 0.02149624f, 0.01128144f, 0.05248003f, 
    0.17403996f, 0.23026310f, 0.05959960f, 0.14206417f, 0.01850467f, -0.07146349f, -0.00981805f, 0.13632689f, 
    -0.01189601f, 0.05067479f, -0.14504755f, 0.01584374f, 0.10742096f, -0.10759041f, 0.17407562f, -0.00014071f, 
    -0.02647563f, 0.04291966f, -0.02908941f, -0.02847705f, 0.09269955f, 0.13053341f, -0.07312168f, -0.16181381f, 
    0.05609998f, -0.15337399f, -0.12950525f, 0.03922175f, 0.02738963f, -0.12743568f, -0.10372549f, -0.06187310f, 
    -0.09042578f, -0.00645952f, 0.03051061f, -0.03945513f, 0.08013502f, 0.21288912f, 0.12036338f, 0.14901252f, 
    -0.02627700f, -0.00193132f, -0.08599393f, 0.10206832f, 0.00620698f, 0.06505664f, 0.00240635f, -0.05740199f, 
    -0.16768728f, -0.05518745f, -0.17511190f, 0.08763143f, 0.13959636f, -0.08173969f, -0.11375301f, -0.04645666f, 
    0.04437029f, 0.17501295f, -0.01929290f, 0.05889983f, 0.05726042f, 0.07074036f, 0.09832922f, 0.03857084f, 
    -0.10544876f, 0.01031358f, -0.06851195f, 0.01017724f, -0.10957034f, 0.00435204f, 0.10875268f, 0.00221179f, 
    -0.01148357f, 0.01207028f, 0.08579249f, -0.01257070f, -0.00998807f, 0.02805643f, -0.08385552f, -0.02957673f, 
    0.00513854f, -0.14434256f, -0.04444886f, -0.03882270f, 0.14009453f, -0.07529087f, -0.19027874f, 0.04430339f, 
    0.28987089f, -0.07635865f, -0.05873478f, 0.01184827f, 0.17939004f, -0.01303240f, 0.17447001f, 0.04422817f, 
    0.09551229f, -0.00828926f, 0.03198819f, -0.02591452f, -0.12928919f, -0.03418832f, 0.04154212f, -0.03963675f, 
    -0.13547841f, 0.00129497f, 0.05977526f, -0.07836218f, -0.07756697f, 0.11825924f, -0.21857472f, -0.02070685f, 
    0.01205778f, -0.04608855f, 0.02703635f, -0.04476269f, 0.16928731f, 0.14603058f, -0.03323011f, -0.01468881f, 
    0.11505470f, -0.07598413f, -0.27968681f, 0.15745661f, 0.09328873f, -0.07426036f, -0.05490782f, -0.08411144f, 
    0.04094603f, 0.02730025f, -0.06438743f, -0.06002113f, 0.24837290f, 0.09963814f, -0.14728996f, 0.19231954f, 
    -0.09187334f, 0.00891003f, 0.07550906f, -0.13932699f, 0.17148665f, 0.03495107f, 0.06072902f, 0.06475161f, 
    0.01039610f, 0.09335046f, -0.01080289f, -0.03838610f, -0.07332888f, 0.01611821f, -0.01973944f, 0.09364205f, 
    -0.03343086f, 0.24963786f, -0.04518685f, 0.05803829f, -0.17953709f, -0.05272982f, 0.17887390f, 0.25670439f, 
    -0.02556810f, 0.03245431f, 0.03513319f, -0.04548471f, -0.01762325f, -0.02683922f, 0.10320985f, -0.00977891f, 
    0.00721045f, 0.17680106f, 0.22943714f, 0.06753530f, -0.00586966f, 0.02212450f, -0.02736287f, -0.02321159f, 
    0.17887682f, -0.08697380f, -0.21695723f, -0.13403453f, 0.14781354f, -0.19533269f, -0.15771948f, 0.19162600f, 
    0.05886460f, 0.10350045f, -0.10411451f, -0.06340232f, 0.00265695f, -0.10302342f, 0.07114075f, 0.00575957f, 
    -0.03628114f, 0.00027677f, -0.02222016f, 0.01316128f, -0.00769027f, 0.02205925f, 0.06044731f, -0.05666069f, 
    0.05076864f, 0.02892238f, -0.05365490f, -0.04004046f, -0.02274522f, -0.07952747f, -0.00534357f, 0.05203718f, 
    -0.06246546f, -0.05873632f, -0.03676131f, 0.01828791f, 0.02849702f, -0.03548729f, 0.03872446f, -0.00760639f, 
    0.00436359f, -0.05485781f, 0.05776837f, -0.04783751f, -0.05438561f, -0.05846930f, 0.01690993f, -0.02078880f, 
    0.06106142f, -0.06113715f, -0.05985590f, 0.05907813f, -0.03939766f, -0.01331808f, 0.01671479f, -0.06755593f, 
    -0.07374785f, -0.01963263f, -0.05811413f, 0.06722388f, 0.05892325f, -0.06122738f, -0.06761976f, 0.01366723f, 
    0.03339603f, -0.01889466f, -0.06829555f, 0.06763952f, 0.03468834f, 0.04898237f, 0.02472938f, -0.03284952f, 
    -0.02062572f, -0.07156780f, 0.05011236f, -0.05783609f, 0.04296829f, -0.03514621f, 0.00386075f, 0.05803662f, 
    -0.05712079f, 0.04803122f, 0.01841583f, -0.03211207f, -0.05509882f, 0.00948458f, -0.03305487f, -0.02121640f, 
    0.01935726f, -0.01718875f, 0.05588973f, -0.00562196f, -0.03713433f, -0.02019654f, -0.04810747f, 0.05517823f, 
    -0.04988633f, 0.05478769f, -0.01142176f, -0.03607198f, 0.06195451f, 0.05773624f, -0.04368888f, 0.04177787f, 
    -0.05528500f, 0.01712659f, 0.01660968f, 0.00538092f, -0.02925317f, 0.00694380f, -0.08249421f, -0.00620663f, 
    -0.05634250f, -0.05472457f, 0.05118054f, 0.04528236f, -0.03675722f, -0.06684937f, 0.01761901f, 0.02471925f, 
    -0.06684341f, -0.02680729f, 0.00262082f, 0.05368865f, -0.07862600f, -0.07059923f, 0.00628668f, -0.07589420f, 
    -0.04739536f, 0.01472858f, 0.00134506f, -0.04480322f, -0.03949137f, 0.01837553f, 0.02360037f, 0.00241034f, 
    -0.01978430f, 0.01191400f, 0.01384669f, 0.01900479f, 0.05718672f, 0.00257451f, -0.07442561f, -0.03858850f, 
    0.05785241f, 0.00532234f, -0.03409103f, -0.07064587f, -0.03561922f, -0.05345801f, 0.04736438f, 0.01375417f, 
    -0.05095531f, -0.02903910f, 0.00769936f, 0.00534824f, 0.05911019f, -0.02856273f, -0.06149770f, 0.03521125f, 
    0.00387377f, 0.02428344f, 0.04228576f, 0.01437061f, 0.04501858f, -0.07242258f, -0.07697482f, -0.01264517f, 
    0.04499714f, 0.00259507f, -0.06532660f, -0.01889829f, 0.05399495f, 0.00986473f, -0.04404479f, -0.01396273f, 
    -0.01955243f, 0.00892954f, 0.00298594f, -0.04842862f, -0.00098917f, 0.00103014f, 0.01225964f, -0.06251626f, 
    -0.04704632f, -0.05733719f, 0.04663696f, 0.05741824f, 0.04898069f, 0.00850081f, 0.04225068f, -0.05074191f, 
    -0.07376567f, -0.01873519f, -0.03720701f, -0.06960361f, -0.02673894f, -0.03867516f, -0.03134871f, 0.02975843f, 
    0.01249986f, 0.01987027f, 0.03408867f, 0.01343347f, 0.03387851f, -0.06291450f, -0.07364330f, 0.02663029f, 
    0.17933883f, 0.15288411f, 0.27913690f, 0.20158480f, -0.03785978f, -0.08353649f, 0.00244663f, 0.06133674f, 
    0.05950516f, -0.05293252f, -0.02921028f, 0.11383882f, -0.12628262f, 0.23290552f, 0.12309568f, -0.03673816f, 
    0.10852851f, 0.05169027f, 0.12359609f, 0.06443649f, 0.06007882f, -0.00072682f, -0.17854807f, -0.03385897f, 
    -0.05515679f, 0.12446149f, -0.02556212f, 0.01386250f, 0.02068534f, 0.05576301f, 0.01769875f, 0.08182655f, 
    -0.06654504f, 0.14294451f, -0.01543190f, 0.01878782f, 0.15205258f, 0.24113904f, -0.02965295f, 0.26797712f, 
    -0.14694647f, -0.02095063f, 0.06855315f, -0.00614702f, 0.04331607f, 0.02921592f, 0.00467983f, -0.14906308f, 
    -0.03848472f, 0.27677625f, 0.00767057f, 0.20238237f, 0.21830516f, 0.02109167f, -0.04761969f, -0.03131099f, 
    0.04141425f, 0.06214747f, -0.04925119f, 0.12480758f, 0.24376787f, -0.03561164f, 0.14169830f, 0.07816294f, 
    -0.00163440f, -0.03331115f, 0.00616902f, -0.08793817f, -0.19497581f, 0.14861515f, 0.09325215f, 0.18883073f, 
    -0.35925061f, -0.16055831f, -0.23498662f, -0.02734047f, -0.06854463f, -0.03738998f, -0.14984497f, -0.11203188f, 
    -0.03058915f, -0.01835654f, -0.13183463f, -0.04261232f, 0.05764982f, -0.17591362f, -0.06008236f, 0.07667418f, 
    0.19629101f, -0.05015726f, 0.05415756f, -0.09244733f, 0.01387746f, -0.19564553f, 0.13682112f, 0.05770257f, 
    0.12260623f, -0.21724378f, -0.01081128f, -0.20612906f, -0.11984882f, 0.05357848f, -0.03974618f, -0.11722446f, 
    0.02912416f, 0.05827857f, 0.03231541f, -0.02887376f, -0.08050903f, -0.20683998f, -0.21981071f, -0.13122010f, 
    0.00086544f, -0.18120329f, 0.06212145f, -0.01946982f, 0.23592670f, 0.12783308f, -0.03324084f, -0.03506433f, 
    0.09421928f, -0.18021357f, -0.04044703f, 0.21483976f, 0.10856391f, 0.13806826f, 0.15660340f, -0.02782640f, 
    0.07847250f, -0.06085899f, -0.05487142f, -0.05762396f, -0.05004742f, -0.03107471f, -0.01401099f, 0.20588425f, 
    -0.15438528f, 0.03309824f, 0.09883893f, -0.07459574f, 0.06809287f, 0.04524518f, 0.19262604f, 0.08382072f, 
    -0.11606818f, -0.17065021f, -0.18209821f, -0.17952450f, -0.01040753f, -0.00142158f, -0.03990949f, 0.10681145f, 
    0.10412332f, 0.16884814f, -0.09904146f, -0.03539127f, -0.13619661f, -0.07774910f, -0.01398372f, -0.09455203f, 
    -0.07835139f, -0.01625389f, -0.04795847f, 0.02046205f, 0.00931364f, -0.07492378f, -0.15359592f, -0.04557274f, 
    -0.16635928f, 0.32847744f, -0.00360258f, 0.14951655f, -0.08135144f, -0.28460094f, -0.16200376f, 0.01399486f, 
    -0.01835122f, 0.03219737f, -0.14157681f, -0.21956207f, 0.17873837f, -0.09021744f, 0.14026986f, 0.35322678f, 
    0.10460275f, 0.10810873f, -0.01373932f, 0.01880260f, 0.08838795f, -0.03480953f, 0.17339572f, 0.04176257f, 
    0.20140861f, 0.09201575f, 0.12100671f, 0.10699371f, -0.00926968f, 0.02937243f, 0.12464022f, 0.21432793f, 
    -0.01350363f, -0.00104900f, -0.00546089f, 0.04525935f, 0.02163912f, -0.01800525f, -0.02899146f, -0.06268422f, 
    -0.03922965f, 0.01410917f, 0.08419572f, 0.02523563f, -0.01016936f, -0.08038337f, 0.03711161f, -0.06790525f, 
    0.19164263f, -0.26674032f, -0.00192906f, -0.16745660f, 0.13847199f, -0.07707681f, -0.12475275f, 0.01662922f, 
    0.02105699f, 0.22279234f, -0.01595671f, 0.01401093f, 0.06600043f, 0.11877597f, 0.12826440f, 0.30251390f, 
    0.01901565f, 0.18976337f, -0.10391768f, -0.00740270f, -0.18466055f, 0.08213659f, 0.05438597f, -0.11252214f, 
    -0.10547684f, -0.16941996f, -0.08473131f, -0.13589419f, 0.11016107f, -0.00398641f, -0.09454349f, 0.02282036f, 
    -0.02800570f, 0.00541788f, 0.02643146f, 0.02050834f, 0.05288470f, 0.05395820f, 0.07414844f, -0.03040360f, 
    -0.01407668f, 0.04279373f, 0.02176974f, -0.01328371f, 0.10728221f, -0.05363572f, 0.07059266f, -0.01576195f, 
    -0.01326217f, 0.23097783f, 0.03020502f, 0.03743533f, 0.00769136f, -0.05398269f, -0.02066892f, 0.03959771f, 
    -0.00827518f, 0.08255106f, -0.01267869f, -0.01830913f, 0.11469858f, -0.10881647f, -0.12693571f, -0.04766550f, 
    0.19038558f, -0.15441588f, 0.01301260f, 0.02396564f, -0.02988830f, 0.02544373f, 0.09208047f, 0.06206819f, 
    0.26300144f, 0.01244558f, 0.16361393f, 0.06448845f, -0.18814316f, -0.01697287f, 0.03675157f, -0.03949813f, 
    -0.15551428f, -0.10518160f, -0.06283530f, 0.02423025f, -0.17113452f, 0.23755208f, -0.30749241f, 0.13656503f, 
    0.01670984f, -0.08097490f, 0.04314817f, -0.04347133f, 0.09413075f, -0.01205967f, 0.13831362f, 0.07260171f, 
    -0.01749013f, 0.08929934f, -0.26929376f, -0.06512083f, 0.25842437f, -0.07560718f, -0.04773577f, -0.00749458f, 
    0.05546635f, -0.05473998f, -0.00768980f, -0.19498965f, 0.38166615f, -0.11603472f, -0.12493375f, -0.01589769f, 
    -0.05221054f, -0.01313938f, -0.03192530f, 0.05812678f, -0.01390317f, -0.04462094f, 0.00791257f, -0.04080138f, 
    0.08108975f, 0.16705458f, -0.24906018f, -0.12941855f, 0.04763141f, -0.06180103f, 0.04109266f, -0.06468356f, 
    -0.15193947f, 0.15560500f, 0.03792823f, -0.03807728f, -0.25520644f, 0.11445695f, 0.22391820f, 0.24143624f, 
    -0.04176728f, -0.02783195f, -0.13368744f, 0.06826213f, -0.00342065f, 0.03583252f, -0.06471698f, 0.02359430f, 
    0.09696601f, 0.22517666f, 0.16376796f, 0.21525407f, 0.00668750f, 0.02325189f, -0.14222586f, -0.05679228f, 
    0.04086316f, 0.02612154f, 0.02159950f, -0.05879766f, -0.01864754f, -0.19055797f, -0.19150703f, -0.15220802f, 
    0.10387003f, 0.03663990f, 0.00558469f, -0.07836618f, 0.04923061f, 0.12139345f, 0.04622982f, 0.02027634f, 
    0.17454407f, -0.11999534f, 0.09332147f, -0.03605243f, -0.22313187f, -0.05379478f, 0.02637135f, 0.15133439f, 
    -0.01316819f, -0.00947938f, 0.12341297f, 0.01016515f, -0.37863189f, 0.13493405f, 0.05094073f, -0.06743149f, 
    0.08867026f, 0.03453320f, -0.00756255f, -0.04373214f, -0.06373778f, 0.05722481f, 0.00541513f, 0.06238988f, 
    0.09982898f, 0.03041163f, -0.13736409f, -0.12505549f, -0.01858196f, 0.07732600f, -0.10184576f, -0.14219581f, 
    -0.03643388f, -0.07917352f, 0.01462379f, -0.06286803f, 0.14843896f, 0.17292222f, -0.12207726f, -0.01366402f, 
    -0.10744434f, 0.12680236f, -0.01814081f, 0.04021798f, -0.08906356f, 0.02612314f, -0.06617018f, 0.05366515f, 
    -0.25377321f, 0.06121340f, 0.05729101f, -0.07419389f, -0.08830944f, 0.07639502f, -0.02154241f, -0.04225115f, 
    -0.06461857f, 0.00841294f, 0.05301963f, -0.03065943f, 0.45070186f, -0.01959666f, 0.09419654f, 0.10668536f, 
    -0.05196628f, 0.17160557f, -0.00392245f, 0.06277376f, 0.04552801f, 0.07078509f, 0.05010548f, -0.00438223f, 
    0.10470944f, -0.02754930f, 0.28111750f, -0.31942379f, 0.08055141f, 0.10805858f, -0.03673202f, 0.11768012f, 
    0.03434440f, 0.06645384f, -0.13765061f, -0.08788947f, -0.18916766f, -0.19091585f, 0.03601031f, 0.04628460f, 
    -0.02613792f, -0.07787359f, -0.04240587f, -0.13762219f, 0.00202278f, 0.10152234f, -0.05848700f, 0.10577194f, 
    0.54415780f, -0.29656142f, 0.06236405f, 0.02704247f, 0.01944214f, 0.08192125f, -0.08255208f, 0.14341837f, 
    -0.05262602f, -0.03589923f, -0.02474001f, -0.00649187f, -0.31877658f, -0.09804299f, 0.00724878f, 0.07642576f, 
    0.05211270f, 0.18439946f, 0.15323211f, 0.01240142f, -0.00981183f, 0.09536584f, 0.05389090f, 0.19679148f, 
    -0.03748842f, 0.09819715f, 0.04644759f, 0.07911950f, -0.01952158f, 0.00126913f, 0.08913893f, 0.05140573f, 
    0.00749336f, -0.03346898f, -0.11980950f, -0.11237610f, 0.07202566f, 0.13009225f, -0.20046416f, -0.12891684f, 
    0.04947189f, 0.06219532f, 0.07064247f, 0.05657445f, 0.04180517f, 0.00475022f, 0.02408061f, -0.00333705f, 
    -0.05620719f, -0.27831095f, -0.34110194f, -0.20028368f, 0.08659395f, -0.05374488f, 0.08616576f, -0.01955006f, 
    -0.04417045f, 0.16911906f, -0.01102949f, -0.03317627f, 0.29908693f, 0.22229315f, 0.06481554f, -0.15489154f, 
    -0.03910412f, 0.12794718f, -0.07407866f, 0.01797656f, -0.10729183f, 0.08017957f, 0.09396639f, 0.12881581f, 
    0.68663919f, -0.26241231f, -0.03640901f, -0.11855803f, -0.00353450f, 0.00874815f, -0.04035914f, 0.02596466f, 
    -0.11012670f, -0.05351624f, -0.02325475f, 0.10548127f, 0.01714529f, -0.12541430f, 0.23092911f, -0.21188474f, 
    -0.04451958f, -0.00989332f, -0.03610840f, 0.04482704f, -0.12870921f, 0.10294890f, -0.03043795f, 0.02986459f, 
    0.03437744f, -0.11292753f, -0.02625570f, -0.27292433f, 0.02694156f, -0.03146801f, 0.03669245f, -0.06090893f, 
    0.02238267f, 0.06367031f, -0.00995328f, -0.00106748f, -0.23771189f, -0.53443211f, 0.18658361f, -0.12140685f, 
    0.05840137f, 0.09949476f, -0.03978528f, 0.00642782f, -0.00455107f, 0.11947814f, 0.05545620f, -0.03376532f, 
    -0.27814904f, 0.11852731f, -0.14259590f, -0.05292314f, -0.03112023f, 0.02103196f, -0.06105097f, -0.10292559f, 
    -0.15875812f, -0.14810453f, -0.02343168f, 0.04688378f, -0.00921353f, 0.26492727f, -0.11585382f, -0.29911628f, 
    0.10399137f, 0.02628222f, 0.06423300f, -0.02302438f, -0.02813680f, -0.05303285f, 0.08883362f, 0.07967953f, 
    -0.12879470f, -0.20253469f, 0.04229367f, 0.07120450f, 0.01323004f, -0.06928175f, -0.10215589f, -0.11899570f, 
    -0.01799292f, -0.03179096f, 0.00164524f, 0.14083576f, -0.22505605f, 0.06685767f, -0.15120631f, 0.17682993f, 
    0.04881628f, 0.06341789f, -0.06092266f, 0.12106188f, -0.12596244f, 0.01049791f, 0.03031867f, 0.16025129f, 
    0.24914257f, -0.08046716f, 0.14377636f, -0.02835733f, 0.06781197f, 0.00915369f, 0.13115361f, 0.06466966f, 
    -0.01319424f, -0.20361461f, -0.03033507f, -0.00544338f, 0.05629432f, -0.11974361f, 0.02830593f, 0.01483538f, 
    0.01893395f, -0.09889897f, 0.01291263f, -0.17806397f, 0.17742267f, 0.08500504f, -0.02635838f, 0.04495201f, 
    0.05862422f, 0.12508564f, -0.26677886f, -0.11663228f, 0.05477729f, 0.14646700f, -0.09610751f, 0.18013443f, 
    -0.04522782f, -0.03381918f, 0.05793377f, 0.07747442f, 0.21494929f, -0.12869357f, 0.30910519f, 0.01128955f, 
    0.01664894f, -0.00099429f, 0.15942930f, 0.10514635f, -0.03191874f, 0.14511038f, -0.06130915f, -0.03010239f, 
    0.21364859f, -0.17858000f, -0.11521445f, 0.26838392f, -0.08613727f, -0.02720769f, 0.00010547f, -0.09091355f, 
    0.07674598f, 0.07720301f, 0.11162178f, 0.12295093f, -0.22429459f, 0.10769132f, 0.10793752f, -0.00577003f, 
    0.01811329f, 0.00436494f, 0.12779544f, -0.04734526f, 0.16703951f, 0.14030188f, 0.15013634f, 0.01373619f, 
    0.10795210f, 0.04182288f, 0.27958652f, -0.10365620f, 0.01420759f, 0.01473467f, -0.08425665f, 0.19145560f, 
    -0.03417441f, 0.20887502f, -0.00060406f, 0.04747681f, 0.06974012f, 0.02557033f, -0.08201899f, 0.00080028f, 
    0.01089399f, 0.17178541f, 0.04682962f, -0.06111019f, 0.13797131f, 0.05293632f, -0.05377645f, 0.03019579f, 
    -0.19881092f, 0.31948888f, 0.05643635f, -0.10034350f, 0.05263474f, 0.04456242f, 0.16396463f, -0.00589524f, 
    0.09429877f, -0.06820198f, -0.01204006f, -0.00919044f, 0.29045457f, -0.26953682f, 0.08345623f, 0.21766417f, 
    -0.18175733f, 0.00930924f, -0.18705012f, 0.11353415f, 0.00749610f, -0.07327081f, 0.04145940f, -0.02116697f, 
    0.05582230f, -0.24753705f, -0.03035977f, 0.17372276f, 0.00365180f, 0.02410049f, -0.05614009f, 0.01283249f, 
    -0.05381616f, 0.10597558f, -0.00682266f, 0.03617381f, -0.27561957f, -0.05053504f, 0.10509766f, 0.02190513f, 
    0.05741431f, -0.03093818f, -0.08749852f, -0.04769893f, 0.17433307f, -0.10577856f, -0.00417286f, -0.07940037f, 
    0.21979238f, 0.05826794f, 0.03967448f, -0.02336095f, -0.01471078f, -0.07784011f, 0.00568361f, 0.12742761f, 
    -0.03536744f, 0.02739038f, 0.01411363f, -0.05725333f, -0.11088673f, 0.02728735f, -0.07692179f, -0.03915782f, 
    0.01294533f, 0.02750686f, 0.00367669f, -0.09341438f, 0.03334348f, -0.09802872f, 0.09072769f, -0.00715884f, 
    -0.04280107f, 0.19037668f, 0.05433528f, 0.04211868f, 0.06092377f, 0.05316689f, 0.02313847f, 0.04728842f, 
    0.05511641f, 0.11627464f, -0.00563645f, 0.06659396f, 0.17085311f, -0.06695877f, -0.00477885f, 0.14271797f, 
    0.06364605f, 0.08178408f, 0.01762344f, 0.04584111f, 0.07031946f, -0.10414533f, 0.09843319f, 0.06248121f, 
    -0.08756778f, -0.00665131f, -0.01447800f, -0.32928380f, -0.03761913f, 0.10182122f, 0.09434454f, 0.10115440f, 
    0.02711483f, -0.03281628f, 0.02381410f, 0.03344221f, 0.14812066f, 0.05592919f, 0.16871884f, 0.13000344f, 
    -0.04966113f, -0.00176980f, 0.06094489f, -0.03359614f, 0.07451397f, -0.08320484f, 0.01174430f, 0.03743865f, 
    0.21284181f, -0.15306036f, -0.15428215f, -0.09142309f, 0.07720462f, 0.09997511f, -0.12318221f, 0.09704211f, 
    0.03049904f, 0.03426598f, 0.00751753f, 0.09166699f, -0.09614548f, -0.09010024f, 0.28625223f, -0.06943995f, 
    -0.02651453f, 0.05917130f, 0.13481317f, 0.00048057f, -0.01376052f, 0.04667784f, 0.00861946f, 0.01771414f, 
    0.16879939f, 0.21541549f, 0.14625680f, 0.00184240f, 0.00936356f, 0.03805881f, 0.00306463f, -0.00666801f, 
    0.04447139f, 0.00777488f, -0.03305795f, 0.02493840f, -0.14900613f, 0.02479311f, -0.01297914f, -0.05325508f, 
    0.06347328f, -0.04011198f, 0.20312682f, 0.02542187f, 0.00101101f, 0.04393008f, -0.00723028f, -0.02931936f, 
    0.03891054f, -0.10531629f, -0.22236282f, 0.03486922f, 0.04090580f, -0.03639735f, 0.00713711f, 0.09333704f, 
    0.02618663f, 0.04733284f, 0.02126066f, 0.02608248f, -0.10787778f, 0.01022656f, 0.02283333f, -0.14906213f, 
    -0.03412550f, 0.01960040f, 0.09802435f, -0.02254924f, -0.08129892f, 0.06570363f, 0.03695574f, -0.04069320f, 
    0.06270609f, -0.18322146f, -0.12793563f, -0.10846729f, 0.01790940f, 0.02652462f, 0.05107396f, -0.05765835f, 
    0.01456259f, -0.02605778f, 0.11777995f, 0.14139487f, 0.15681562f, 0.09127630f, 0.31332216f, -0.06880666f, 
    0.01337419f, 0.10249598f, 0.09187434f, 0.17547417f, 0.13490579f, 0.10224139f, 0.03470771f, 0.02095884f, 
    -0.03178516f, 0.31090498f, 0.09722657f, 0.00939561f, -0.08755270f, -0.05903120f, 0.03310037f, 0.13488054f, 
    0.05082249f, -0.15086700f, -0.02336472f, -0.01611674f, -0.00442842f, 0.17689182f, -0.11004379f, -0.07017571f, 
    0.01209668f, -0.06558152f, 0.01371208f, 0.10747492f, -0.06007498f, -0.07148010f, -0.03254472f, 0.06900185f, 
    -0.02122266f, 0.00801470f, -0.05992994f, -0.01368275f, -0.03771713f, 0.01348671f, -0.04882947f, -0.09547665f, 
    0.01792199f, 0.01997045f, -0.05332435f, 0.08084812f, 0.24148440f, -0.03771418f, 0.13875651f, 0.17695925f, 
    -0.02579399f, -0.04306432f, -0.01536418f, 0.06512576f, -0.07563304f, 0.16615301f, -0.06784272f, -0.06324431f, 
    0.02181490f, -0.11694144f, -0.04359993f, -0.09136068f, 0.09673402f, -0.10597061f, -0.02695485f, 0.08964519f, 
    -0.08847564f, -0.01186075f, -0.02631736f, 0.11338829f, 0.04122854f, 0.01050562f, 0.07247782f, -0.12942794f, 
    -0.03644879f, 0.02239870f, 0.18674128f, -0.09145719f, 0.03759546f, 0.14586101f, -0.08147874f, -0.06585695f, 
    0.00599322f, 0.20127010f, -0.12269489f, 0.22469224f, 0.05677763f, -0.17610867f, 0.04845162f, -0.01165663f, 
    -0.02905318f, 0.10735526f, -0.01388779f, 0.09353854f, 0.05322366f, 0.02161143f, -0.15423805f, -0.10467182f, 
    0.04395965f, 0.00031019f, -0.01331757f, -0.02042707f, 0.03155992f, 0.12113371f, 0.10546939f, -0.03862645f, 
    0.03101178f, -0.03178861f, 0.29334983f, 0.18546037f, -0.09755332f, -0.19513838f, 0.07093707f, 0.00644162f, 
    0.04105448f, 0.02450207f, 0.03998399f, -0.01046882f, -0.12300205f, 0.32083282f, -0.29678485f, 0.02842546f, 
    -0.00478204f, 0.08367252f, -0.06709221f, -0.02953400f, 0.12269465f, -0.00398782f, -0.03591421f, 0.02872424f, 
    -0.09774524f, -0.04315136f, -0.16511962f, -0.00122796f, 0.14936307f, -0.04153604f, -0.02466189f, -0.09484396f, 
    0.09552754f, 0.09284706f, 0.03699300f, 0.00228036f, 0.34153405f, -0.03016239f, -0.05416469f, 0.13376397f, 
    0.08136316f, -0.01901325f, -0.04170536f, -0.00803845f, 0.05804274f, 0.01898994f, 0.06724389f, 0.12284740f, 
    -0.05587275f, 0.21324778f, 0.07707286f, -0.13629007f, 0.06603274f, 0.00535308f, -0.02234373f, -0.05295462f, 
    0.16030292f, 0.01812644f, -0.08384822f, 0.07898622f, -0.02828214f, -0.01970085f, 0.09115187f, -0.01833959f, 
    0.03270118f, -0.08716033f, 0.00352519f, 0.04358751f, 0.12331773f, 0.08778195f, 0.11212967f, 0.08972788f, 
    0.01749539f, 0.13903035f, 0.13084391f, 0.15466484f, 0.00688504f, -0.04680134f, 0.04587081f, 0.11801243f, 
    -0.03669375f, 0.05967026f, -0.04906972f, -0.12210587f, -0.11837062f, -0.04392117f, -0.31741297f, 0.06974775f, 
    0.15104844f, -0.03269356f, -0.05344928f, -0.19130176f, -0.09423410f, 0.07191214f, -0.04663967f, -0.00663399f, 
    0.02077451f, -0.01349868f, -0.00152417f, -0.07292756f, 0.01867862f, 0.05305411f, -0.00673391f, 0.05731060f, 
    0.05711848f, -0.04735102f, -0.00091898f, -0.03934792f, 0.02068129f, 0.05186072f, 0.04442345f, -0.03853197f, 
    0.03289986f, -0.03178041f, 0.03963138f, -0.05077080f, -0.01539558f, 0.02804372f, -0.07846426f, -0.06703487f, 
    0.00984003f, -0.04919702f, -0.02338214f, -0.07697182f, -0.04310754f, -0.07907455f, -0.00901124f, -0.05145200f, 
    -0.03255099f, 0.05032581f, -0.06488815f, -0.05565822f, -0.00409965f, 0.02785410f, -0.00835317f, -0.00147337f, 
    -0.02847865f, -0.08179480f, 0.02326137f, -0.01883388f, 0.00376070f, -0.03329407f, -0.02153150f, -0.07715277f, 
    -0.00346705f, 0.00081447f, -0.02613024f, -0.04937518f, -0.04669462f, 0.05574000f, 0.05226748f, 0.05066311f, 
    0.01449700f, -0.06384626f, -0.03689600f, -0.03479291f, -0.07488042f, -0.01033843f, 0.03673436f, 0.03093105f, 
    0.01787997f, -0.04502015f, 0.03131942f, -0.04989355f, 0.01087652f, -0.06877767f, -0.02836050f, -0.03258299f, 
    0.03994795f, 0.02099742f, -0.06041847f, -0.08050505f, -0.06340837f, -0.04799087f, 0.03623250f, -0.00764916f, 
    -0.02993478f, -0.00090817f, 0.00460455f, 0.00108189f, 0.01607169f, -0.04969022f, -0.05129929f, 0.01816946f, 
    0.04812358f, -0.03613806f, -0.07027090f, 0.02784553f, 0.01717665f, -0.03834960f, -0.00822799f, -0.02404451f, 
    -0.03477663f, 0.03120092f, -0.05604375f, -0.05311760f, -0.03648289f, -0.08125164f, 0.03265855f, -0.05306514f, 
    0.00732533f, -0.04654828f, 0.04742134f, -0.01550394f, 0.04624392f, -0.02770789f, 0.02987594f, -0.01179147f, 
    -0.08013767f, 0.01317258f, 0.01270454f, -0.01665083f, 0.03288466f, -0.01817161f, 0.03287243f, 0.04928426f, 
    -0.01756077f, -0.05598970f, 0.04276285f, -0.00121610f, -0.06228107f, -0.01463519f, 0.01124851f, -0.05229342f, 
    0.03936060f, -0.04193953f, 0.02416205f, -0.01568480f, 0.00764592f, 0.04934353f, -0.03785304f, 0.05593058f, 
    -0.05624117f, 0.01444672f, 0.01617002f, 0.03695340f, 0.01020909f, -0.04200643f, -0.05718795f, -0.00433484f, 
    -0.00572551f, 0.05179984f, -0.02054985f, 0.04220057f, -0.08097187f, -0.01090133f, 0.00824054f, 0.01734355f, 
    -0.02265480f, -0.03413669f, 0.02294820f, -0.03091071f, -0.01343358f, -0.06572071f, 0.02000316f, -0.00442854f, 
    -0.00246565f, -0.05997330f, -0.06110765f, 0.01699596f, -0.03077075f, 0.01633390f, 0.02989640f, -0.07573683f, 
    -0.04900865f, 0.02427411f, 0.03410465f, 0.03552978f, 0.00520905f, 0.03903599f, -0.01450384f, -0.02461346f, 
    0.06267721f, 0.04498661f, 0.02918978f, -0.06098783f, 0.03118018f, -0.07004782f, 0.05023373f, -0.05351700f, 
    -0.07277221f, 0.01316496f, 0.02079968f, 0.01754272f, -0.02700033f, -0.00950968f, 0.02026991f, 0.00850097f, 
    0.29328150f, -0.07697529f, 0.08716172f, -0.09719380f, -0.17592479f, -0.02111978f, -0.03127104f, -0.08396087f, 
    -0.03873595f, 0.03428405f, 0.08759505f, 0.03480154f, 0.14572023f, -0.21696649f, 0.23462750f, -0.04264412f, 
    -0.00759191f, 0.05611837f, 0.01054737f, -0.15311936f, 0.04401772f, 0.00715287f, 0.07529962f, -0.06256460f, 
    0.06089392f, 0.10646426f, -0.06651635f, 0.15613690f, -0.05561018f, -0.06561293f, 0.10619167f, -0.01448912f, 
    -0.06675659f, -0.06857794f, 0.11736964f, -0.01617140f, 0.15130776f, 0.22395948f, -0.04972439f, -0.17226455f, 
    0.11735265f, 0.09409828f, -0.06888533f, 0.05509912f, 0.05767434f, -0.03359867f, 0.10644201f, -0.01680716f, 
    -0.10528541f, -0.01590153f, 0.09459206f, 0.17212969f, -0.08271728f, 0.10823350f, 0.05323461f, -0.01739811f, 
    0.03259394f, 0.07165833f, 0.01428279f, -0.01435067f, 0.32487464f, -0.01871642f, 0.06907847f, 0.10358949f, 
    -0.03309496f, -0.00130117f, -0.15222421f, 0.01984377f, 0.04029870f, 0.07767325f, 0.19826560f, 0.01143146f, 
    0.07757096f, -0.33044493f, 0.28316063f, -0.22131576f, -0.05229622f, 0.17082837f, -0.01815184f, -0.10713528f, 
    0.09701023f, -0.16841941f, -0.15107709f, -0.00367629f, -0.01404001f, -0.05410811f, 0.03177969f, 0.02341428f, 
    -0.00877605f, 0.02431606f, 0.00780347f, -0.01513230f, 0.08501621f, 0.10520689f, -0.04524091f, 0.02234654f, 
    0.10049042f, -0.18436399f, -0.17483780f, -0.07560512f, -0.05323353f, 0.12239673f, -0.08968703f, 0.05143758f, 
    -0.13486090f, 0.01847479f, 0.01831814f, -0.02757018f, -0.06756070f, -0.28675681f, 0.05914450f, -0.21559961f, 
    0.10560001f, -0.05709582f, 0.04562750f, 0.05697984f, -0.02921566f, 0.03877189f, -0.01717188f, 0.03730915f, 
    0.24528998f, -0.04414035f, -0.13899243f, 0.05545189f, -0.01341232f, -0.00839090f, -0.03095728f, 0.04142801f, 
    -0.08488843f, 0.08700461f, 0.06313887f, 0.04126987f, -0.11099136f, 0.01918214f, 0.14201403f, -0.07712032f, 
    -0.02809049f, -0.01539490f, 0.14367566f, -0.06392630f, 0.07604798f, 0.07443046f, 0.04277622f, -0.01056358f, 
    -0.09155652f, -0.21506207f, -0.01479405f, -0.06329398f, -0.06191060f, 0.10668718f, 0.04772586f, 0.07777701f, 
    -0.04090835f, 0.11605065f, -0.09337433f, -0.03771458f, -0.05278323f, 0.10460804f, 0.08281868f, 0.08230828f, 
    0.06849085f, 0.03603992f, -0.08013570f, -0.05040741f, 0.01081141f, 0.02106559f, -0.14528395f, -0.02900023f, 
    0.28061259f, -0.06709134f, 0.06199431f, -0.13447325f, 0.00491730f, 0.06289154f, -0.06382925f, -0.05310501f, 
    0.08771505f, -0.03308958f, -0.15963209f, 0.00128681f, 0.22825520f, 0.00035573f, 0.28404316f, 0.23115119f, 
    -0.08618550f, 0.09217182f, 0.04195427f, 0.02658937f, 0.03217723f, -0.02350503f, 0.08235945f, 0.01347609f, 
    0.19843094f, 0.02718336f, -0.03910065f, -0.20120712f, -0.20619309f, -0.02389940f, -0.08426195f, 0.07782909f, 
    0.07553756f, 0.02084272f, 0.04580008f, 0.07353369f, -0.04761945f, 0.06992637f, -0.11692265f, -0.02011924f, 
    -0.11885662f, 0.14138135f, -0.00169622f, -0.04397406f, 0.04744145f, 0.20181651f, -0.13180654f, 0.05256836f, 
    -0.21176161f, -0.07451113f, -0.07348382f, 0.04798194f, -0.06341175f, -0.06149686f, 0.05536511f, -0.14916527f, 
    -0.00909902f, 0.00950374f, 0.10163295f, 0.04191045f, 0.14988501f, 0.06997303f, 0.02107590f, 0.00821953f, 
    0.03401475f, 0.05134167f, 0.02920719f, 0.05105122f, 0.00519215f, -0.01200406f, 0.02693897f, 0.05929400f, 
    -0.12962161f, -0.00952143f, -0.09023192f, 0.04322023f, -0.08477992f, 0.05316880f, 0.09970500f, -0.00715876f, 
    0.02523794f, 0.00429206f, 0.10543250f, -0.00163138f, 0.48337182f, -0.04129892f, 0.24161409f, 0.06881996f, 
    -0.15554363f, -0.00352669f, -0.07727812f, -0.08308008f, -0.08138832f, 0.14277114f, 0.07680044f, -0.00398946f, 
    0.21790943f, -0.11138854f, 0.33982259f, -0.05528207f, -0.04373796f, 0.07383718f, -0.03721838f, -0.01044078f, 
    -0.10018946f, -0.03131003f, 0.01388713f, 0.00159492f, -0.12641686f, -0.05670942f, -0.04839591f, 0.12482829f, 
    -0.04204413f, 0.08731736f, 0.07733379f, -0.01252851f, -0.09542484f, 0.15458816f, 0.04047574f, 0.10223594f, 
    0.13549748f, -0.17496760f, 0.06488171f, -0.05284063f, -0.06859713f, 0.11827407f, 0.07417774f, -0.07985707f, 
    -0.05304819f, 0.00688070f, 0.00361393f, 0.02511873f, -0.25907707f, -0.11354469f, 0.04112310f, 0.01912913f, 
    0.18783653f, 0.19199845f, 0.06756110f, -0.06957327f, -0.04658350f, -0.09886090f, -0.00497802f, -0.00694331f, 
    -0.12687895f, -0.11040089f, -0.16624561f, -0.11484092f, 0.07527620f, 0.05618088f, 0.02673771f, -0.00310511f, 
    -0.09104987f, -0.13767272f, -0.11224803f, -0.05263499f, 0.04817319f, 0.18283461f, 0.14800571f, -0.10252494f, 
    0.03459342f, 0.07626209f, 0.08290676f, -0.05560920f, 0.05025712f, 0.11114250f, -0.06529985f, -0.15021932f, 
    0.06175141f, -0.06830417f, -0.06808387f, -0.09680086f, 0.00390305f, -0.02779002f, 0.17976734f, -0.03204593f, 
    -0.03296217f, 0.06443807f, 0.05588245f, -0.00365422f, 0.40802035f, 0.29414105f, 0.15749048f, 0.01257881f, 
    0.00066545f, -0.10375111f, 0.02440867f, 0.00749356f, 0.10598460f, 0.02304294f, 0.06876393f, 0.19417715f, 
    0.43041906f, -0.09697004f, 0.14240035f, -0.04142318f, -0.02508748f, 0.06275529f, 0.06640839f, 0.08705118f, 
    -0.02979996f, 0.04815881f, -0.10781495f, 0.01839277f, -0.10603871f, -0.24986212f, 0.02394070f, 0.05099626f, 
    0.07899563f, 0.10094322f, 0.00936156f, -0.09409036f, -0.11700249f, -0.07601570f, -0.00809420f, 0.04260328f, 
    0.01141202f, 0.02645166f, 0.05254118f, -0.05876713f, -0.06399385f, -0.00385454f, -0.00281418f, 0.01100837f, 
    -0.06417410f, -0.07324238f, 0.00554660f, 0.00288122f, 0.01585414f, 0.04676734f, 0.03064840f, -0.05491236f, 
    0.02758264f, 0.05085833f, -0.03771187f, -0.04310415f, 0.04071122f, 0.01073063f, 0.06243309f, 0.03313359f, 
    -0.01489299f, 0.02144365f, -0.04543629f, 0.01682798f, 0.03146332f, 0.00933691f, 0.04803096f, 0.02730178f, 
    -0.02252519f, 0.04067498f, -0.03300566f, -0.06678735f, 0.02378576f, -0.02986091f, -0.03483703f, -0.02932854f, 
    -0.01030146f, -0.05530760f, 0.03669557f, -0.01248035f, -0.07264946f, -0.07776899f, -0.06754857f, 0.05465603f, 
    -0.01638253f, 0.03765707f, -0.07670102f, 0.05389656f, 0.03315714f, -0.01556951f, -0.06104318f, 0.00401177f, 
    0.03595368f, -0.07068303f, 0.00066311f, 0.04689823f, 0.04642909f, 0.02164024f, -0.05679668f, -0.05442036f, 
    -0.03998562f, -0.06348132f, -0.06021370f, 0.00621322f, 0.02165767f, -0.07735408f, -0.00234116f, -0.07494927f, 
    0.03388209f, 0.03831913f, 0.04933118f, 0.04209317f, -0.00880307f, 0.02759603f, 0.02669532f, 0.03937917f, 
    0.00647891f, -0.01149360f, 0.03977529f, 0.05007395f, -0.00554672f, 0.05035459f, 0.04851734f, 0.02972403f, 
    -0.05405519f, -0.04355583f, -0.00857239f, -0.05692255f, -0.03563871f, -0.03909852f, -0.01327006f, 0.03235723f, 
    -0.00633362f, -0.03058270f, -0.07405090f, 0.03748491f, -0.06814887f, -0.02290306f, 0.03690680f, -0.04520078f, 
    -0.04603786f, -0.01959863f, 0.05313817f, -0.02134279f, -0.01185657f, 0.02352211f, -0.02734947f, 0.05738489f, 
    -0.03312523f, -0.05467884f, 0.01160995f, -0.02798498f, -0.03477927f, -0.06041216f, -0.00614664f, 0.00382894f, 
    -0.02254477f, 0.03941693f, 0.03347242f, 0.04213917f, 0.00882091f, 0.02260384f, 0.03208471f, -0.02858956f, 
    -0.03063296f, 0.04769358f, 0.03461583f, -0.06425080f, -0.07011523f, -0.04481260f, 0.00189468f, -0.01294770f, 
    -0.03587237f, -0.06151805f, -0.03261121f, -0.04687237f, 0.04500271f, 0.03254049f, 0.02150305f, 0.06568240f, 
    0.03912669f, -0.00149066f, 0.06171232f, -0.00308254f, -0.01633214f, -0.06765403f, 0.06069681f, -0.06995381f, 
    -0.07113302f, -0.02297427f, -0.02690502f, -0.03417111f, -0.06079771f, -0.00783680f, -0.07275400f, 0.05262041f, 
    -0.03699507f, -0.02716962f, -0.07282034f, -0.01815023f, -0.04768319f, -0.04260406f, -0.01915425f, -0.05904578f, 
    0.00898973f, 0.03982635f, -0.00401597f, 0.01877996f, -0.05939134f, -0.00864746f, 0.01360777f, -0.07512556f, 
    -0.06203511f, -0.00191498f, -0.05622217f, 0.05032257f, -0.02558820f, -0.04738020f, -0.02199159f, -0.02185195f, 
    -0.03759679f, -0.02781221f, 0.05882077f, 0.00594212f, -0.02311057f, -0.00570816f, -0.06095053f, -0.00964742f, 
    -0.20837961f, 0.09078345f, 0.02027911f, 0.30936018f, 0.11866082f, -0.01828046f, 0.04691853f, 0.04587639f, 
    -0.00515829f, 0.10895737f, 0.04408356f, 0.03243069f, -0.16585244f, -0.07623547f, -0.00311986f, -0.08920547f, 
    0.07940080f, -0.06381974f, 0.10878202f, -0.00562761f, 0.04087910f, 0.00787569f, 0.00670989f, 0.01009661f, 
    0.31531411f, -0.11380521f, 0.09166715f, -0.23633552f, 0.01918885f, 0.18694215f, 0.03078184f, 0.06704034f, 
    0.04884542f, 0.01893179f, -0.11757857f, -0.06131375f, -0.11228453f, -0.02569895f, 0.08626289f, 0.24010792f, 
    0.02752613f, -0.03651298f, 0.04986100f, -0.09347377f, -0.02019866f, -0.10239746f, 0.05826576f, 0.03403952f, 
    0.10517893f, 0.07074843f, 0.04273165f, -0.12624383f, 0.05442807f, -0.06340350f, -0.02355951f, 0.10438258f, 
    -0.04901545f, -0.04622623f, 0.02093708f, -0.03035088f, -0.29423237f, -0.03037089f, -0.09109328f, 0.09005727f, 
    0.01146101f, 0.01137309f, 0.01667144f, 0.14548600f, 0.03991764f, -0.02224146f, -0.00739481f, 0.00227332f, 
    -0.08797481f, 0.14560455f, -0.12010913f, 0.04697605f, 0.14948203f, -0.09210952f, -0.02075136f, 0.06970186f, 
    -0.03387704f, 0.03042043f, 0.09541077f, 0.00337344f, 0.03883174f, 0.10318490f, 0.12784421f, -0.02729688f, 
    0.08259893f, -0.07742786f, -0.11322615f, -0.06783347f, 0.03464419f, -0.03611622f, -0.03815935f, -0.04279978f, 
    -0.28669569f, 0.06515463f, 0.24845856f, -0.33260405f, 0.01281623f, 0.04391732f, -0.08416908f, -0.05029912f, 
    0.14128412f, -0.05794314f, -0.00433599f, 0.04096633f, 0.05391894f, 0.02556509f, -0.12930945f, -0.05097294f, 
    -0.12561259f, -0.13204078f, -0.04549379f, 0.02515380f, 0.04433654f, 0.03839867f, -0.07678937f, -0.09403716f, 
    0.12293778f, 0.21199687f, 0.08226036f, 0.10217886f, 0.08974236f, -0.08354948f, 0.02651294f, 0.07168555f, 
    0.15642209f, 0.07090607f, 0.07610305f, -0.17252165f, 0.06921986f, -0.12745273f, -0.10452702f, 0.14794534f, 
    0.00048247f, 0.07348878f, 0.06048035f, -0.03265363f, -0.10526803f, -0.10755125f, 0.10252855f, 0.01723193f, 
    0.00324931f, 0.18468970f, -0.17575046f, 0.06566664f, 0.01507833f, -0.01678648f, -0.07810748f, 0.03433850f, 
    0.09329610f, -0.04743451f, 0.12156966f, 0.00022899f, 0.00512473f, -0.10367863f, 0.01172539f, -0.09385978f, 
    0.11258372f, 0.27515540f, -0.04276310f, 0.14548141f, -0.09245928f, 0.04586517f, -0.02180351f, -0.02579541f, 
    -0.33076659f, 0.32332376f, 0.15970108f, -0.00032479f, -0.03041899f, 0.01700090f, 0.00640233f, -0.02183551f, 
    0.01369604f, -0.10050661f, 0.26421511f, 0.05361120f, 0.24658537f, 0.25345433f, 0.01929733f, 0.00575804f, 
    -0.03941353f, -0.04081926f, 0.00211184f, 0.12378450f, -0.02984042f, 0.05596028f, 0.01098514f, -0.00210272f, 
    -0.04319528f, -0.04316534f, 0.00085031f, -0.03005068f, -0.03064120f, 0.01753428f, -0.07760896f, -0.03201470f, 
    0.04393998f, -0.07583974f, -0.04049532f, 0.00410825f, 0.00195415f, -0.05455879f, -0.00010097f, 0.05173885f, 
    -0.03689099f, 0.06272071f, -0.07755558f, -0.01994343f, -0.07073554f, 0.00101126f, -0.02497768f, 0.04649833f, 
    -0.07162013f, -0.03776588f, -0.00679914f, 0.06053560f, 0.00789829f, 0.06254955f, 0.00020480f, -0.01145408f, 
    -0.04607914f, -0.00626282f, -0.00774707f, 0.00590946f, 0.00012284f, 0.06153302f, -0.05014979f, -0.04611589f, 
    -0.01144293f, -0.04467132f, 0.03311908f, 0.00539967f, -0.00335228f, 0.00151377f, -0.03737105f, -0.00143916f, 
    -0.07909074f, -0.04106233f, -0.06575073f, -0.06203770f, 0.00673012f, -0.05075495f, -0.04280933f, -0.05245514f, 
    0.03282690f, -0.07921436f, 0.05204956f, 0.04194015f, -0.04709866f, -0.04818689f, 0.04583678f, 0.00999856f, 
    -0.01312121f, -0.02352700f, -0.05309801f, 0.02613073f, 0.03372652f, -0.06496813f, 0.02235968f, -0.04896529f, 
    0.00745379f, 0.02707613f, -0.07811844f, -0.07769609f, 0.02792522f, -0.05526089f, -0.02352831f, -0.05988716f, 
    -0.05809781f, 0.00735830f, 0.04103636f, -0.04243967f, -0.03876477f, -0.01039623f, 0.01945854f, -0.05686493f, 
    0.03959213f, -0.06919242f, -0.07635730f, -0.06557165f, 0.04081544f, -0.02155840f, -0.05547562f, 0.03012576f, 
    0.03937056f, -0.01029857f, -0.04516746f, -0.00870881f, 0.03282161f, 0.05372398f, -0.05313623f, -0.01853473f, 
    -0.00978465f, -0.06780024f, -0.07736792f, -0.00718561f, -0.07329102f, 0.03928163f, 0.00397701f, -0.01017216f, 
    0.06171463f, 0.04309692f, 0.02960243f, -0.03724465f, 0.05814350f, -0.03924319f, 0.01067902f, 0.05836403f, 
    0.01227477f, -0.04236900f, 0.05337549f, -0.03823808f, 0.00407086f, 0.05568777f, -0.05210929f, 0.04835702f, 
    -0.03013343f, -0.05943376f, -0.07561993f, -0.01616863f, -0.03502482f, 0.05950861f, -0.00527143f, 0.05107597f, 
    -0.00891154f, -0.06849492f, 0.05849376f, -0.00873738f, 0.04784870f, 0.01705297f, -0.07722802f, 0.00332965f, 
    -0.00528328f, 0.05045681f, -0.07807603f, 0.02060100f, 0.04724223f, 0.00918423f, -0.02952361f, 0.04715481f, 
    0.05883329f, 0.05216470f, 0.00118156f, -0.03645275f, -0.03505927f, 0.05888223f, 0.00976133f, -0.02455875f, 
    -0.05972723f, 0.03231252f, -0.01768496f, -0.00504381f, -0.00485502f, 0.04079024f, -0.01235947f, 0.02863838f, 
    0.00871117f, -0.07564764f, 0.02204561f, 0.03296242f, -0.04200504f, 0.02914184f, -0.03661979f, -0.03388856f, 
    -0.05651404f, 0.02100509f, 0.01291956f, 0.04808563f, -0.04040134f, 0.01909575f, -0.07807993f, -0.06389913f, 
    0.05729020f, -0.06906710f, 0.04235584f, -0.06296813f, 0.04170882f, -0.02728043f, -0.04771956f, -0.03378237f, 
    0.18100263f, 0.08008754f, -0.17369208f, -0.11347677f, 0.13899678f, -0.09222671f, 0.02300616f, -0.20409398f, 
    0.06591699f, 0.12339923f, -0.06962873f, 0.00919741f, 0.49567929f, -0.12602875f, 0.04301696f, -0.03717386f, 
    0.08831209f, -0.02108384f, 0.05979147f, -0.04905566f, 0.04094382f, -0.01788449f, 0.00158995f, -0.00170561f, 
    -0.01766161f, 0.02009089f, 0.01025380f, 0.11354910f, -0.05630753f, -0.02304994f, 0.12091751f, -0.00128828f, 
    -0.03377267f, -0.04429004f, 0.03799181f, -0.10888796f, 0.08828498f, 0.16243468f, 0.01991084f, -0.17519833f, 
    0.21815163f, 0.07994163f, -0.00422313f, 0.00507772f, 0.17671923f, -0.10045617f, -0.01821472f, 0.02913526f, 
    0.10428668f, 0.03959890f, 0.06382546f, 0.12564749f, -0.01412915f, 0.03485849f, 0.03565855f, -0.03649076f, 
    0.08835911f, -0.08286387f, -0.06970375f, 0.04540886f, -0.15528497f, -0.13002060f, -0.17740852f, -0.05420671f, 
    0.06559620f, -0.08931306f, -0.12929973f, -0.06113842f, -0.02516694f, 0.05048893f, 0.07687395f, 0.04950185f, 
    0.01227327f, -0.18899244f, 0.16763821f, 0.12525615f, 0.04637787f, -0.00375204f, -0.03105661f, -0.04803324f, 
    0.04955394f, -0.04145244f, -0.07221085f, 0.00263201f, -0.02131961f, 0.22815022f, 0.12889104f, -0.10516936f, 
    -0.13828503f, -0.01210634f, -0.03346727f, 0.04707164f, -0.03292230f, -0.10898764f, 0.04228838f, 0.02597070f, 
    -0.47624177f, 0.24789569f, 0.03321884f, -0.26921338f, -0.04008464f, -0.00287988f, 0.05797391f, -0.10786670f, 
    0.08293331f, 0.02714240f, 0.13485505f, -0.04836581f, 0.30184522f, -0.03799299f, 0.04487177f, -0.13485162f, 
    -0.01959584f, -0.21781430f, 0.00279346f, 0.09776597f, -0.09037634f, -0.02088580f, -0.02028914f, -0.17417021f, 
    0.26538706f, -0.14220515f, 0.01545069f, -0.01985442f, -0.16601647f, -0.10255775f, -0.11233389f, 0.02536945f, 
    0.00591365f, 0.00072324f, 0.06738711f, 0.05195419f, -0.13029233f, -0.04746960f, 0.24385217f, 0.19062249f, 
    -0.01773466f, 0.04388411f, 0.02698866f, 0.03810115f, -0.05073043f, 0.11386668f, 0.09444287f, 0.07054263f, 
    -0.04694664f, 0.12664637f, 0.16519435f, 0.22973368f, -0.05481030f, 0.06429881f, -0.04870230f, 0.04404262f, 
    -0.04869584f, 0.05342054f, 0.05427406f, 0.13486125f, -0.13052225f, -0.07472578f, 0.04959545f, 0.15983817f, 
    0.20437813f, 0.02446081f, 0.00951464f, 0.08438390f, 0.15388846f, -0.07741021f, -0.02245172f, -0.02056795f, 
    -0.13367508f, 0.29650626f, 0.12181764f, -0.02283036f, 0.11408830f, 0.12844078f, -0.05943882f, 0.05018833f, 
    0.02539873f, -0.04270231f, -0.07841246f, -0.12770419f, 0.15846814f, 0.03921223f, 0.08265758f, 0.42199725f, 
    -0.11074069f, -0.00219405f, 0.04549906f, 0.02441758f, -0.06170465f, -0.02481932f, 0.04777623f, -0.00354803f, 
    0.16676241f, -0.00932079f, 0.09649532f, -0.03158103f, 0.17135882f, -0.10759281f, 0.17587751f, 0.00160562f, 
    0.02334295f, 0.05466312f, 0.05308821f, -0.14807288f, 0.39500606f, -0.06866305f, 0.12829174f, -0.09222470f, 
    0.08919449f, -0.00495079f, -0.11317497f, 0.03300219f, -0.06328950f, -0.06614013f, 0.03394603f, -0.02174660f, 
    0.03948589f, 0.18978071f, -0.12363437f, 0.11497287f, -0.08966088f, 0.14880703f, 0.05937986f, -0.06423553f, 
    -0.02086061f, -0.05841745f, 0.12879480f, -0.00332285f, 0.28344581f, 0.23390938f, 0.15559958f, -0.16240102f, 
    0.13440710f, -0.04696332f, -0.12028596f, 0.04618955f, -0.02616322f, -0.00402066f, 0.07689169f, -0.13588013f, 
    0.20989454f, 0.01003862f, -0.17125523f, 0.10993911f, -0.13365504f, 0.02349689f, -0.06235966f, 0.08018956f, 
    0.05667238f, -0.05630206f, 0.02549941f, -0.14262271f, -0.06990681f, 0.10956329f, -0.01508065f, 0.09763654f, 
    -0.04246910f, 0.02965668f, 0.01513572f, -0.08688238f, 0.02105941f, -0.11996129f, -0.01754278f, -0.06208957f, 
    0.14364509f, -0.06102426f, 0.17464410f, 0.08156227f, -0.02709347f, -0.06335936f, -0.00515554f, 0.00713635f, 
    0.09589447f, 0.05363279f, -0.00329334f, 0.05145626f, 0.14859562f, 0.07408404f, -0.00303634f, -0.12290796f, 
    0.11321878f, -0.00023834f, -0.08340251f, -0.12519802f, -0.01834903f, 0.11472137f, -0.03850869f, 0.06211067f, 
    0.03937213f, 0.00072630f, -0.02171228f, -0.03817299f, -0.00117195f, -0.07637145f, -0.02064509f, -0.08791299f, 
    -0.06916112f, -0.03082235f, 0.00343934f, -0.02311615f, 0.22656545f, 0.12154782f, -0.04629319f, -0.11834327f, 
    0.12068472f, -0.12181274f, -0.03527859f, 0.04362739f, -0.11081880f, -0.01675786f, 0.06150134f, 0.07244431f, 
    0.33914861f, -0.05441022f, -0.14461662f, 0.11440806f, 0.01001750f, -0.00819270f, 0.05185160f, 0.03593622f, 
    0.10463154f, -0.05001835f, -0.03055221f, -0.02686493f, 0.02754208f, -0.17771566f, 0.08583880f, 0.01078700f, 
    -0.01941431f, 0.06100829f, -0.05682381f, 0.05414061f, -0.00358338f, -0.03776403f, -0.00602586f, -0.09076615f, 
    0.04323862f, -0.01369232f, -0.00628193f, -0.08505180f, -0.08169049f, 0.10767376f, 0.02771019f, 0.13207991f, 
    -0.09218764f, 0.02945706f, -0.09342827f, -0.02199241f, 0.03115130f, 0.04100547f, 0.01026068f, 0.11255570f, 
    0.09123739f, 0.04093220f, -0.20360972f, -0.08183674f, 0.13669367f, -0.04262590f, 0.05534861f, 0.07868300f, 
    -0.01560534f, 0.28198409f, -0.00161517f, -0.01206113f, 0.01573396f, -0.00709904f, -0.00595381f, -0.04491376f, 
    0.05735191f, 0.11564373f, 0.01517061f, -0.05613823f, 0.29199806f, -0.05162426f, -0.12487205f, 0.12081783f, 
    -0.05124979f, -0.09634037f, 0.00929389f, 0.08255925f, -0.10934013f, 0.05131333f, -0.03985932f, -0.04895914f, 
    0.03671824f, 0.20296051f, -0.12722614f, -0.03033124f, 0.02459183f, -0.13503779f, 0.06285968f, -0.07882904f, 
    0.02236037f, 0.01506406f, 0.12041809f, -0.02132039f, -0.14167951f, 0.09945668f, -0.00159731f, 0.18117942f, 
    -0.15497978f, -0.04903546f, 0.01851856f, 0.24466808f, -0.06759750f, 0.01934538f, -0.07360598f, -0.07213001f, 
    0.03012340f, -0.25673521f, 0.00784287f, -0.02845184f, 0.08702630f, -0.01069919f, -0.04228306f, -0.08390021f, 
    0.10227950f, 0.06592336f, 0.00713810f, -0.11264605f, -0.19127545f, 0.20884190f, 0.07307923f, 0.02656618f, 
    0.07103048f, -0.07807606f, -0.06134563f, -0.18719010f, 0.02088082f, 0.10031316f, -0.01906223f, 0.00823661f, 
    -0.27371109f, -0.10830808f, -0.15236145f, -0.03302391f, 0.15641165f, 0.14888290f, -0.11740244f, -0.01509530f, 
    -0.06967723f, -0.02800052f, 0.01501823f, -0.00533069f, 0.16962978f, 0.10682829f, 0.12583645f, 0.08043341f, 
    0.00385834f, 0.09667400f, 0.19398382f, -0.18129270f, -0.06334151f, -0.09114780f, -0.09918740f, -0.04645447f, 
    0.04249662f, 0.01751759f, 0.03934692f, -0.05509454f, -0.01979256f, -0.18927190f, 0.04795679f, -0.06568242f, 
    0.07936290f, 0.03956567f, -0.01162226f, 0.04148243f, 0.39694199f, 0.10623744f, -0.11437933f, 0.17196687f, 
    0.15463158f, 0.07149924f, -0.04840222f, -0.04058383f, -0.14994273f, 0.23795961f, 0.09709153f, 0.07993935f, 
    0.02999691f, -0.05446956f, 0.33378717f, -0.01730665f, -0.08854131f, -0.01651719f, -0.00910635f, -0.00035284f, 
    0.06401145f, -0.07705993f, 0.03495535f, 0.04124680f, -0.06126967f, 0.38786447f, -0.14243269f, -0.06304158f, 
    0.13522892f, -0.07495444f, -0.03026537f, -0.01306353f, 0.01552661f, -0.03717115f, 0.17653389f, -0.04480631f, 
    -0.05882605f, 0.20824283f, -0.21291587f, -0.03810911f, 0.05286809f, -0.01900855f, 0.01618205f, -0.00631391f, 
    -0.00654674f, 0.02145260f, -0.08455655f, -0.00085684f, 0.34770799f, 0.00561125f, -0.12336414f, 0.25088134f, 
    0.11227834f, 0.00881195f, -0.00299144f, 0.08980567f, -0.03952368f, -0.07696757f, -0.00754727f, -0.03983319f, 
    -0.11640809f, 0.00150206f, -0.13448799f, 0.05646931f, 0.09244191f, 0.04625083f, -0.03572542f, -0.09611084f, 
    0.23169842f, -0.07148199f, 0.08398045f, 0.07469436f, 0.16539763f, 0.01927976f, 0.17228045f, 0.02400739f, 
    -0.11210205f, -0.03215755f, 0.09231424f, -0.00339894f, 0.01532275f, 0.04672404f, 0.11312356f, 0.11811742f, 
    -0.16729994f, 0.28216341f, 0.01788703f, -0.03498829f, -0.04021803f, -0.03993234f, 0.09176536f, -0.15507130f, 
    0.05723988f, -0.04375032f, -0.00585138f, -0.04698412f, 0.03526804f, -0.30940330f, -0.11501840f, 0.08998692f, 
    0.04749806f, 0.06441623f, -0.00252642f, -0.14534566f, 0.06082590f, 0.12972397f, -0.07644846f, -0.02943684f, 
    -0.05283989f, -0.12273615f, 0.03113582f, -0.01619584f, -0.10330900f, 0.03898342f, -0.06954113f, 0.15890726f, 
    0.04404541f, 0.02449477f, 0.02802751f, -0.07759564f, -0.59972042f, 0.03917293f, -0.08757234f, 0.07861083f, 
    0.12956867f, -0.05561700f, 0.01458670f, 0.00350595f, 0.07590557f, -0.01907405f, -0.08988123f, 0.03310670f, 
    -0.09102435f, 0.05369985f, 0.14892682f, -0.24403663f, -0.04176862f, 0.04331817f, 0.00780140f, 0.04037083f, 
    -0.00693018f, 0.19490410f, 0.05770459f, 0.08547822f, -0.14681552f, -0.18790813f, -0.07036739f, 0.18595716f, 
    -0.08589804f, 0.08563676f, 0.06288896f, 0.09338786f, -0.04607689f, 0.15087764f, -0.08123808f, 0.10519657f, 
    -0.13984725f, 0.13095480f, 0.10556746f, -0.09877837f, 0.11333951f, 0.02190344f, 0.08306499f, 0.03046464f, 
    -0.04215018f, -0.02090286f, 0.03167575f, 0.06912901f, 0.25385255f, 0.02082950f, -0.01804877f, -0.11304924f, 
    0.06115812f, 0.14895913f, 0.04078582f, 0.15428624f, 0.06102005f, -0.05409681f, -0.07905959f, 0.05173204f, 
    0.18473731f, 0.12502286f, -0.14532594f, -0.04138869f, -0.02270138f, 0.15983950f, 0.08480947f, 0.07554553f, 
    -0.07031536f, 0.03371802f, 0.04643275f, -0.05243273f, -0.19032110f, -0.15968424f, 0.12048155f, 0.10953647f, 
    -0.01152310f, 0.05437968f, 0.13359641f, 0.16790393f, 0.01902524f, 0.00542984f, 0.01761488f, 0.00423003f, 
    0.28544745f, 0.01774367f, 0.01645275f, 0.10821438f, 0.08553768f, 0.03768994f, -0.02701306f, 0.11507870f, 
    -0.04968847f, 0.07315923f, -0.05740482f, 0.05134147f, -0.23826815f, -0.08366063f, 0.15211307f, 0.26486108f, 
    0.01591879f, 0.02133041f, 0.14426972f, -0.09958921f, 0.04406324f, -0.01402759f, 0.04989171f, -0.02891601f, 
    -0.23741113f, 0.11229944f, 0.18722206f, -0.22252131f, 0.09505573f, 0.13678621f, 0.06801976f, 0.01871492f, 
    -0.11750492f, -0.11955645f, 0.00109137f, 0.08151084f, 0.15750770f, 0.02507627f, 0.03029192f, 0.06199148f, 
    0.13488270f, -0.08184370f, -0.00098840f, 0.02949677f, 0.04677119f, -0.02810503f, 0.01810004f, 0.01670464f, 
    0.13596749f, -0.14054228f, 0.01841850f, 0.04806765f, 0.17495739f, -0.05291824f, -0.02037473f, -0.03806733f, 
    -0.00770448f, 0.11468404f, -0.00282468f, -0.03613538f, 0.15946127f, 0.05109364f, -0.16908468f, -0.08401730f, 
    0.03756832f, 0.01648296f, 0.12555903f, -0.02612794f, -0.17083873f, 0.08458949f, 0.09192739f, 0.08035810f, 
    0.40804693f, -0.21067025f, -0.20817399f, 0.17969498f, 0.01768570f, -0.05104808f, -0.03033693f, 0.04150062f, 
    -0.11428796f, 0.09110747f, -0.01976585f, 0.08639940f, -0.18636160f, 0.01328946f, 0.10298261f, -0.30089718f, 
    0.09340746f, 0.07827403f, 0.01680922f, -0.01064872f, 0.06811581f, 0.04484770f, 0.01200454f, 0.05565163f, 
    0.02562115f, -0.06594066f, -0.07931538f, -0.15149085f, 0.03885783f, -0.03392194f, 0.03056516f, -0.04588319f, 
    -0.03971759f, -0.00326820f, -0.10121903f, 0.10271351f, -0.02325222f, -0.29831460f, 0.04247548f, 0.04594310f, 
    0.16861774f, -0.04675271f, 0.09146418f, 0.02039998f, -0.04107054f, 0.03343856f, 0.02263178f, 0.03852826f, 
    -0.31437108f, 0.03575851f, 0.01047376f, -0.27379698f, 0.03070369f, -0.04767496f, -0.08074859f, 0.09580410f, 
    -0.02218097f, -0.00044518f, -0.04455181f, -0.02113471f, -0.05728581f, 0.06138111f, -0.05872932f, -0.18222718f, 
    0.05743077f, 0.07352515f, 0.04461398f, -0.02692983f, 0.03493978f, -0.02616956f, -0.06508557f, -0.08657508f, 
    -0.08324770f, -0.17074637f, 0.02906653f, -0.01015874f, 0.03448909f, -0.01239597f, 0.00136473f, -0.02438119f, 
    -0.07131667f, 0.02328823f, -0.08603690f, 0.21764742f, -0.24813817f, 0.23254120f, -0.25847334f, -0.13971086f, 
    0.09582247f, 0.05346022f, -0.13758542f, 0.09697305f, 0.00524442f, 0.10702823f, 0.05091265f, 0.14549460f, 
    0.26385036f, 0.01075811f, -0.03646817f, 0.18246891f, 0.03918083f, -0.09401850f, 0.04368912f, -0.01898954f, 
    -0.05837377f, -0.12446485f, 0.02879756f, 0.06455543f, -0.20239462f, -0.03087051f, 0.18132515f, 0.01062315f, 
    0.12296133f, 0.01972269f, 0.10746092f, 0.05507819f, 0.10603526f, -0.03097653f, 0.10108346f, 0.06103894f, 
    -0.13807493f, 0.27556825f, -0.08470055f, -0.16735390f, 0.10080287f, 0.02667578f, 0.04844887f, 0.03044332f, 
    -0.07983175f, 0.04445608f, 0.07179295f, 0.09294740f, 0.11550321f, -0.05431410f, 0.15051799f, 0.20874827f, 
    -0.03604852f, -0.14570129f, 0.04739657f, -0.02830616f, -0.03120073f, 0.05316492f, -0.03715566f, -0.05379374f, 
    0.01940012f, -0.10008976f, -0.08341251f, 0.12494578f, -0.04579592f, -0.06797799f, -0.08062579f, 0.05150390f, 
    0.11670352f, 0.11783320f, 0.10162658f, 0.11895503f, 0.01570919f, 0.10456940f, 0.03992859f, 0.21997826f, 
    -0.11824654f, -0.10281109f, -0.02020456f, 0.05874062f, 0.06661725f, 0.09169500f, 0.16141947f, 0.12802897f, 
    0.08100240f, -0.00402768f, 0.21239452f, 0.09391905f, -0.03471554f, 0.05448249f, -0.08718888f, 0.11130692f, 
    -0.01788499f, 0.06375349f, 0.01842757f, 0.10274670f, -0.12410562f, -0.02836806f, -0.13669942f, 0.11581526f, 
    0.09168989f, 0.11144839f, 0.11220963f, 0.07709714f, 0.12169693f, 0.03482363f, 0.01718767f, 0.00761450f, 
    -0.11559538f, 0.17330799f, -0.01089011f, -0.12695538f, -0.01060348f, 0.05957954f, 0.02389954f, 0.10260477f, 
    0.05752428f, 0.02953628f, 0.07855505f, -0.22284281f, -0.07003064f, -0.02846218f, 0.01827534f, -0.07684585f, 
    -0.01336689f, 0.09779625f, -0.04386631f, -0.02112357f, 0.05051862f, -0.10829750f, -0.03145187f, 0.11993917f, 
    -0.28903323f, -0.12753554f, -0.02801226f, 0.06173579f, 0.09806187f, 0.07791315f, 0.04711046f, 0.10549169f, 
    0.06711756f, -0.10979375f, 0.10190575f, -0.08693590f, 0.01625658f, 0.02396566f, -0.16161306f, -0.03116702f, 
    -0.01276275f, -0.02624183f, -0.08957123f, 0.09073921f, -0.03998742f, -0.12650722f, 0.03557038f, 0.09481027f, 
    0.34663010f, -0.02213884f, 0.07381453f, -0.06308511f, -0.06517310f, 0.08077785f, 0.05202879f, 0.02093016f, 
    0.03869731f, 0.06071223f, -0.02023671f, 0.05113848f, -0.04546427f, -0.25319499f, 0.00897172f, 0.12612741f, 
    -0.07998321f, -0.03119785f, -0.01929232f, 0.05921887f, -0.13637486f, -0.01085573f, -0.01464391f, 0.06493229f, 
    0.15345262f, 0.10268929f, -0.04282003f, -0.26944357f, -0.00711783f, 0.05910457f, 0.12187394f, 0.05172944f, 
    -0.10155067f, -0.05417951f, 0.11723696f, -0.08219938f, -0.03999973f, -0.05596860f, 0.11547988f, -0.10940018f, 
    0.08903208f, 0.03788359f, 0.11831845f, 0.05393057f, 0.07666291f, -0.16652983f, -0.15595117f, -0.17806655f, 
    0.00944855f, 0.27740794f, -0.03005939f, 0.12215780f, -0.00576334f, -0.03813585f, -0.00037831f, 0.16862038f, 
    0.04771537f, 0.28067788f, 0.09540477f, 0.04751454f, 0.18088754f, 0.12007978f, -0.02206234f, 0.03671289f, 
    0.05618975f, 0.13250589f, -0.06248977f, -0.04730737f, -0.14259011f, 0.10855687f, -0.17274134f, 0.06662800f, 
    0.27510810f, -0.09133089f, 0.04338109f, 0.22902927f, 0.00080891f, 0.05369433f, -0.03770687f, 0.11107351f, 
    0.02508409f, 0.05354790f, 0.05701353f, -0.03396957f, -0.03749109f, 0.32966208f, -0.17432742f, 0.14357661f, 
    -0.07114018f, 0.06470154f, 0.01862169f, 0.07576413f, -0.01217705f, -0.10375746f, 0.09560837f, 0.14151576f, 
    -0.10234864f, 0.34184092f, 0.09642369f, -0.09617344f, 0.10400441f, 0.12445405f, 0.15322544f, 0.06506373f, 
    0.00164555f, -0.11524305f, -0.09624277f, -0.01947094f, 0.21523194f, -0.05163265f, -0.18855035f, -0.13649312f, 
    0.15367690f, 0.03959739f, -0.06984270f, 0.12250480f, -0.13020134f, -0.19753912f, -0.16456524f, -0.10010446f, 
    0.11553534f, -0.05319422f, -0.12885305f, 0.11000302f, 0.04511789f, -0.04865276f, -0.02552785f, -0.05014962f, 
    -0.01375719f, -0.07535344f, -0.12075827f, -0.02881375f, 0.05360157f, 0.16581708f, -0.03298146f, -0.02569507f, 
    -0.10576651f, -0.03091889f, 0.01251483f, -0.07377043f, -0.14664012f, -0.02012866f, 0.09389961f, 0.12111764f, 
    0.11685375f, -0.15579182f, -0.04042475f, 0.00307449f, -0.08599133f, 0.01387332f, 0.05421945f, -0.05656469f, 
    -0.02132866f, 0.05862347f, 0.08796898f, 0.11110854f, -0.12824138f, 0.09649744f, -0.14195198f, -0.32315472f, 
    0.00942602f, -0.08316847f, 0.10352601f, -0.07719477f, -0.06213802f, 0.02384246f, -0.08205023f, 0.06514604f, 
    -0.10197601f, -0.02735009f, 0.03244920f, 0.16733013f, -0.00641533f, 0.04254243f, 0.05324291f, 0.10568040f, 
    -0.01037393f, -0.01998703f, 0.04455091f, 0.00949843f, -0.34388039f, 0.16793568f, 0.00878724f, -0.04691554f, 
    -0.00619456f, -0.01392229f, 0.01728377f, -0.03109363f, -0.00925368f, -0.03334700f, -0.02520782f, 0.04292194f, 
    0.18544145f, -0.18677990f, -0.03894566f, 0.02014563f, 0.04818170f, 0.00227384f, -0.02005880f, -0.01680648f, 
    -0.02729210f, 0.11493611f, 0.03807614f, 0.01390385f, -0.05541984f, 0.00539477f, 0.00873914f, 0.26549011f, 
    -0.18660757f, 0.01913520f, 0.03065033f, 0.02520542f, -0.14342923f, 0.09917191f, -0.04459093f, -0.04562451f, 
    -0.04918288f, 0.07985070f, 0.04029487f, -0.20901120f, 0.03261447f, -0.06526075f, -0.00335277f, 0.13130514f, 
    -0.11456097f, 0.06163752f, 0.01891836f, -0.05362388f, 0.04992506f, 0.19173087f, 0.08006366f, 0.05828333f, 
    0.05551437f, 0.06464911f, 0.17360877f, 0.07044270f, 0.09406586f, -0.08051936f, 0.00922139f, -0.04479952f, 
    -0.13550501f, 0.15728588f, -0.11612658f, -0.15466666f, 0.04474439f, -0.07681463f, 0.00506073f, 0.01565544f, 
    0.04945989f, 0.11164987f, 0.11644608f, 0.04204334f, 0.15088621f, -0.01582605f, -0.10916855f, 0.14410894f, 
    0.15849593f, 0.00142874f, 0.00086258f, -0.00812652f, -0.04377082f, 0.17033605f, 0.00517288f, 0.04021589f, 
    0.47340220f, -0.22842333f, 0.13378777f, 0.29325768f, -0.06952524f, 0.01942675f, -0.02848694f, 0.03396504f, 
    0.06277727f, 0.09661838f, -0.09284055f, 0.01380768f, -0.12700574f, 0.27943930f, -0.08195106f, -0.05586573f, 
    0.02358386f, 0.19736515f, 0.04457973f, -0.06341123f, 0.09980274f, 0.06936545f, -0.00532385f, 0.10125100f, 
    -0.17459819f, 0.21002173f, 0.05504801f, 0.01432560f, 0.17516010f, 0.09493905f, 0.02986344f, -0.06241659f, 
    0.00935775f, 0.03823594f, -0.09494799f, -0.05660836f, 0.13432065f, -0.01667887f, -0.22361284f, 0.01014292f, 
    0.13462028f, 0.03280523f, 0.06642707f, 0.05202778f, 0.04545675f, -0.14248519f, 0.08698124f, 0.03204731f, 
    -0.06687284f, -0.00797716f, -0.22085373f, -0.09306282f, 0.07525074f, 0.01895448f, -0.02995629f, 0.02435108f, 
    0.13907774f, 0.01111144f, 0.02549549f, 0.05259915f, 0.03441860f, -0.10986301f, 0.02714249f, -0.15973383f, 
    -0.20696548f, 0.02345374f, 0.05375828f, -0.03105249f, -0.09306026f, 0.11536650f, 0.14795910f, 0.03837954f, 
    -0.12096922f, -0.01618046f, -0.02229401f, 0.07254458f, -0.05426248f, -0.10547148f, 0.10404090f, -0.02890617f, 
    -0.07413178f, -0.07363039f, 0.14698362f, 0.18502443f, -0.07206552f, -0.05646641f, -0.07455190f, -0.17722268f, 
    0.06422132f, -0.05731619f, -0.04843960f, -0.05228460f, 0.10069770f, 0.09089654f, 0.06835046f, 0.05274812f, 
    -0.09000526f, -0.23166534f, -0.01442406f, -0.06960609f, -0.00955411f, -0.06771858f, -0.02839356f, 0.06512508f, 
    0.00823160f, -0.07404844f, -0.07209955f, 0.03192519f, -0.30224195f, -0.17135087f, -0.17251281f, -0.06823899f, 
    0.21329816f, 0.08979019f, 0.01826677f, 0.20971620f, -0.02922080f, -0.11248644f, -0.07786746f, 0.09640221f, 
    -0.10910149f, 0.08674699f, -0.08933021f, -0.27244610f, 0.04140454f, 0.11465157f, 0.04888654f, 0.03023714f, 
    0.01908718f, 0.09390230f, 0.16064830f, -0.03535659f, -0.18439436f, 0.02018764f, -0.05738476f, 0.03176862f, 
    0.05207462f, 0.04310835f, 0.00940445f, 0.05585302f, -0.00755953f, 0.09399079f, 0.07841492f, 0.09416557f, 
    0.11438373f, -0.05486377f, -0.03201595f, 0.05643855f, -0.06708641f, 0.07698226f, -0.01055511f, 0.04090678f, 
    0.02451838f, -0.05562787f, -0.05829454f, -0.08726884f, -0.20382443f, -0.00492872f, 0.19126701f, -0.02506214f, 
    -0.02080243f, 0.02982076f, 0.10397990f, -0.07910603f, -0.12174865f, -0.12313047f, -0.01959663f, 0.01195282f, 
    0.02083436f, 0.14374520f, 0.05738500f, 0.12697454f, 0.04549117f, -0.07668841f, -0.06044551f, -0.04656973f, 
    0.07801475f, 0.17135924f, 0.05557847f, 0.01448391f, 0.31293687f, -0.21972242f, -0.07922743f, 0.05446548f, 
    0.05477881f, -0.04097181f, 0.05190829f, 0.00940553f, 0.03122960f, -0.11300826f, -0.09473044f, 0.08235153f, 
    0.11807647f, 0.08583269f, -0.09331612f, -0.19691421f, 0.11091920f, 0.10684890f, -0.07044861f, 0.00660235f, 
    0.02197213f, 0.09298231f, 0.06157059f, 0.13202848f, 0.18920089f, 0.32986662f, -0.15687576f, 0.10015997f, 
    0.01171932f, -0.18275815f, 0.07867196f, 0.06290064f, -0.00062167f, 0.09043240f, 0.00124269f, -0.06856070f, 
    0.23818724f, -0.01667307f, -0.22274101f, 0.05872630f, 0.06623185f, 0.03935796f, 0.02814340f, 0.03302431f, 
    0.10944009f, -0.05831655f, -0.04233559f, -0.05350667f, 0.16134036f, 0.11330542f, -0.00083970f, 0.38581881f, 
    -0.05453981f, -0.03423007f, -0.07137487f, -0.10292855f, -0.05512571f, 0.10501067f, 0.02881304f, -0.01064941f, 
    0.28949323f, 0.06691525f, 0.02873752f, -0.00559391f, 0.04199090f, -0.02661895f, -0.02410853f, 0.07280040f, 
    -0.11642776f, 0.13385816f, -0.12508638f, -0.03289957f, -0.05008408f, 0.07116289f, -0.05654851f, -0.03471460f, 
    0.01844169f, -0.10200045f, -0.04053442f, 0.02007020f, 0.08436107f, -0.14465347f, -0.00012144f, 0.11169907f, 
    -0.15553448f, 0.13074493f, -0.03869804f, 0.22721973f, -0.11777247f, -0.03725035f, -0.06954929f, -0.04133208f, 
    0.05351362f, 0.12064854f, -0.12614074f, -0.07251113f, 0.17760356f, -0.43868205f, -0.21097627f, 0.09442667f, 
    0.01308756f, 0.01241038f, -0.14370747f, -0.08762636f, 0.08193468f, 0.02648912f, 0.10228616f, 0.00889456f, 
    -0.12781538f, 0.10202222f, 0.10647659f, 0.18869761f, 0.03920770f, 0.09321976f, -0.06149388f, 0.18075089f, 
    0.08318082f, -0.01024526f, 0.01053833f, -0.07968681f, -0.04822325f, 0.39468443f, -0.07898425f, 0.00230056f, 
    -0.00764142f, -0.08495978f, 0.06125733f, 0.12162031f, 0.03459594f, -0.13917118f, -0.06811049f, 0.10573692f, 
    0.33753884f, -0.05978598f, 0.02818783f, 0.00862035f, 0.05026225f, 0.04483199f, -0.00701613f, 0.10827123f, 
    0.05566588f, 0.05960139f, -0.03038325f, 0.08652186f, -0.09316818f, -0.07178799f, 0.03490617f, 0.27287742f, 
    -0.07123587f, -0.10773093f, 0.00997217f, -0.10235693f, 0.01438038f, 0.11812021f, 0.01815845f, 0.02226027f, 
    0.15494967f, 0.08601986f, -0.03018213f, -0.13660038f, 0.03876412f, -0.03128342f, 0.07704181f, 0.08986399f, 
    -0.06266522f, -0.12365342f, 0.01123857f, -0.03014048f, -0.07065612f, -0.09309779f, 0.06469419f, -0.09311599f, 
    0.07721002f, -0.08207005f, 0.13777927f, -0.01032472f, 0.11348506f, -0.11251465f, -0.07657449f, -0.04996474f, 
    -0.24519502f, 0.23947889f, -0.14371631f, 0.11999793f, -0.00372400f, -0.02716474f, -0.00328518f, 0.02769931f, 
    -0.01896732f, 0.22563103f, 0.14555113f, 0.18294446f, 0.10658687f, 0.01859717f, -0.04846956f, -0.09897932f, 
    0.10780255f, 0.00474038f, -0.10449886f, -0.04150615f, -0.10105832f, -0.08725665f, -0.00943118f, -0.04799924f, 
    -0.11278511f, -0.04897960f, 0.29513443f, 0.00783051f, 0.03108460f, 0.02184473f, 0.00779944f, -0.05096926f, 
    0.11867496f, 0.12563629f, -0.05836080f, -0.01820252f, -0.00094618f, 0.24826619f, -0.27422509f, 0.05010879f, 
    -0.04740270f, 0.05475008f, -0.04360393f, -0.01671919f, 0.05678135f, -0.02083142f, -0.01057006f, -0.01484355f, 
    -0.10940188f, 0.25522104f, 0.05906193f, -0.08732848f, 0.16669956f, 0.03445378f, 0.05447102f, 0.01326958f, 
    0.10420200f, -0.00635315f, 0.05560958f, -0.07591196f, 0.27336794f, -0.15400150f, -0.13894922f, 0.02556589f, 
    0.07444946f, 0.07397924f, -0.04627515f, 0.04424949f, -0.10606600f, -0.03839838f, -0.04229535f, 0.08577376f, 
    0.00040992f, 0.29462719f, -0.11442856f, 0.06879520f, 0.03410995f, 0.01284131f, -0.06697245f, -0.08807781f, 
    0.10008884f, -0.00925878f, 0.09280413f, -0.09408049f, -0.08935267f, -0.13459517f, 0.10096569f, -0.10291240f, 
    -0.08575380f, -0.01823328f, 0.07520311f, 0.09518834f, -0.11419822f, -0.06649894f, 0.06596796f, -0.00838481f, 
    -0.29758149f, 0.09209640f, 0.05297416f, 0.19280656f, -0.04144146f, 0.00497332f, -0.00680773f, 0.03504873f, 
    -0.13347431f, 0.01715631f, 0.07759529f, 0.12960792f, -0.01516726f, 0.20696282f, -0.10481172f, -0.02076250f, 
    0.17039977f, -0.00105228f, -0.01923953f, -0.07396286f, 0.01411699f, 0.00516450f, -0.08723420f, -0.00197544f, 
    -0.02971704f, 0.05778440f, -0.07339654f, 0.11873440f, -0.14136326f, 0.15507914f, -0.10368939f, 0.02910710f, 
    0.06375635f, 0.03499460f, 0.12300839f, 0.10091151f, -0.52601951f, 0.02272141f, 0.01764838f, 0.03269318f, 
    -0.09825269f, 0.01763884f, 0.08980957f, -0.08324143f, 0.00935974f, 0.07292421f, 0.02934660f, -0.06340372f, 
    0.15886939f, -0.19207628f, 0.08695269f, -0.23337016f, 0.08658611f, 0.00314475f, -0.03842119f, 0.05440790f, 
    0.01518450f, 0.14427938f, -0.05276916f, 0.02274866f, -0.15155505f, 0.05344402f, 0.02568567f, 0.21982381f, 
    -0.08999226f, 0.01390230f, 0.15008344f, -0.04595008f, -0.07015234f, -0.03052794f, -0.05519851f, 0.03981521f, 
    -0.11410912f, -0.05624443f, 0.14382915f, -0.20002407f, -0.03855972f, 0.00513751f, -0.00734080f, -0.02525858f, 
    -0.02190938f, 0.06596425f, 0.12605742f, 0.13014874f, 0.03554844f, 0.01440056f, 0.25365135f, 0.08792552f, 
    -0.10047980f, 0.12199796f, 0.09611978f, 0.16482440f, 0.00727989f, 0.02317485f, -0.06069992f, 0.02302280f, 
    0.00931290f, 0.11980642f, -0.00307552f, -0.09906747f, 0.05004811f, 0.09380384f, 0.00594207f, 0.15332703f, 
    0.06595372f, -0.02033696f, 0.03952001f, -0.00156224f, -0.15655887f, -0.14778970f, 0.01619560f, 0.21183011f, 
    0.02959935f, 0.06131627f, -0.00197360f, -0.02461109f, 0.05843518f, -0.02790982f, 0.03111490f, -0.03730845f, 
    0.25763690f, -0.14638928f, 0.16113077f, 0.04341343f, 0.03696266f, 0.01191215f, 0.10660042f, 0.16414830f, 
    0.06667551f, -0.05386923f, -0.04638518f, 0.04677110f, -0.25045016f, -0.11831556f, 0.11697478f, 0.16562812f, 
    -0.05706016f, 0.21072163f, 0.06988300f, -0.02792739f, 0.12679248f, 0.05240163f, -0.08940118f, 0.07302648f, 
    -0.36270773f, 0.11329427f, 0.19324023f, 0.03312918f, 0.13247171f, 0.14547929f, 0.01047503f, -0.04283322f, 
    -0.01920393f, 0.02990236f, -0.04123041f, -0.03312184f, 0.08558682f, 0.05543341f, -0.14401783f, -0.08310986f, 
    0.17963238f, 0.01289374f, 0.09003458f, 0.05543176f, 0.00817551f, 0.02597249f, -0.02122900f, -0.00009863f, 
    0.12135321f, -0.08171374f, -0.08108325f, 0.02369571f, 0.09257200f, 0.07985960f, 0.04686599f, -0.08932771f, 
    0.19728114f, 0.01980531f, 0.18459821f, 0.03997906f, 0.30794871f, 0.03567188f, 0.14788914f, -0.26459914f, 
    -0.12513667f, 0.08170996f, 0.08350790f, 0.09013599f, -0.15114526f, 0.04660038f, 0.02725853f, -0.02945315f, 
    0.02236016f, -0.18088336f, 0.15881068f, -0.01251564f, -0.07962701f, -0.04640293f, -0.02339840f, -0.00712296f, 
    -0.15567443f, 0.03234761f, 0.09856620f, 0.14794558f, -0.15611041f, 0.04281770f, 0.03215324f, -0.22378065f, 
    0.00928626f, 0.05145752f, 0.03627669f, -0.06812708f, 0.08200135f, 0.01744546f, 0.08900300f, 0.04387795f, 
    -0.06152680f, 0.24766526f, -0.08542857f, 0.14804338f, 0.10610665f, -0.00084832f, -0.02209867f, 0.05489362f, 
    0.04591606f, -0.02763888f, -0.05548237f, -0.01483485f, 0.05175005f, 0.17577529f, -0.05276274f, 0.07108778f, 
    -0.00614008f, -0.08744042f, 0.11370005f, 0.10217508f, 0.13734418f, -0.03814687f, -0.00322253f, 0.03919470f, 
    0.24141632f, -0.19842064f, 0.09694207f, -0.14665352f, 0.07262801f, 0.01674072f, -0.15010956f, 0.02332644f, 
    0.06869828f, 0.07038599f, -0.16975588f, -0.05444968f, -0.08540282f, -0.10076244f, 0.05258365f, 0.10625336f, 
    0.09419601f, 0.03685335f, 0.09088621f, -0.05097935f, 0.03583387f, 0.04981900f, 0.01109047f, -0.05724867f, 
    -0.06886380f, -0.07551724f, -0.06928802f, -0.21700744f, 0.14583617f, -0.00070479f, -0.13570723f, 0.05675246f, 
    -0.02155243f, 0.01960138f, 0.06567736f, 0.13803670f, 0.05819108f, -0.06129557f, -0.23647003f, -0.18134382f, 
    0.05572266f, -0.03748034f, 0.04722966f, 0.03332511f, 0.03395439f, 0.09330430f, 0.03929350f, 0.09012564f, 
    0.00232503f, 0.20625874f, -0.06291254f, -0.04884499f, 0.07070190f, 0.10250068f, 0.11973903f, 0.05598100f, 
    -0.08464846f, 0.05882335f, 0.13901515f, -0.01931042f, -0.08042854f, 0.26609159f, 0.09689641f, -0.13922532f, 
    0.09370430f, -0.03372509f, -0.01730054f, 0.00825309f, -0.02168034f, -0.04445284f, 0.12232940f, -0.08830437f, 
    -0.35825393f, 0.11445389f, 0.31272727f, -0.05188591f, 0.01343592f, 0.01931112f, -0.01908469f, -0.17113842f, 
    0.12908357f, 0.02140397f, 0.00611270f, -0.01814711f, -0.10019527f, 0.17139579f, -0.08354041f, 0.09858900f, 
    -0.09418841f, -0.04879385f, 0.03272620f, -0.01934765f, 0.05912573f, -0.03525745f, 0.00152994f, -0.06302072f, 
    -0.13041127f, 0.16064921f, 0.14227864f, -0.09070545f, 0.12481609f, -0.11231127f, -0.04347545f, 0.07138932f, 
    -0.02219938f, 0.09777527f, 0.04576147f, 0.00923147f, 0.27497086f, -0.02807045f, -0.17892572f, 0.01688113f, 
    -0.07635037f, 0.05491317f, 0.11204921f, -0.00872049f, -0.00751476f, 0.05507829f, -0.01828242f, 0.05788685f, 
    -0.17410319f, 0.18779382f, 0.08639610f, 0.26806837f, 0.10663716f, 0.00968836f, -0.05244559f, -0.08566401f, 
    0.04140368f, -0.06772493f, 0.10151995f, 0.03944697f, -0.16388467f, -0.06238646f, -0.05329270f, 0.20303105f, 
    0.09055045f, 0.15726469f, 0.10739893f, 0.05737603f, -0.02311241f, 0.18444876f, 0.11910469f, -0.12348753f, 
    0.01612482f, -0.02472792f, 0.10361347f, -0.13506670f, 0.12163394f, 0.14924149f, -0.07649499f, 0.00970564f, 
    0.02400485f, -0.07045169f, 0.02980834f, -0.00109985f, -0.20633329f, 0.19508716f, -0.11690956f, -0.16133623f, 
    0.08790112f, -0.06354135f, -0.00266075f, -0.11633927f, -0.00407964f, -0.02354934f, -0.07928175f, -0.00916361f, 
    -0.08881070f, 0.06090961f, 0.07506149f, -0.00186517f, 0.06127001f, 0.10107035f, 0.13339256f, 0.10541387f, 
    0.08967147f, -0.04340467f, 0.19868310f, -0.06173955f, 0.08523583f, 0.13069606f, -0.07149042f, 0.05698898f, 
    0.04284281f, 0.00632911f, 0.01570786f, -0.04813395f, -0.15796195f, 0.03529026f, 0.05131993f, -0.02107829f, 
    0.07793386f, -0.07076288f, -0.08573307f, -0.04870415f, 0.00167850f, 0.12559088f, 0.08385276f, -0.01466065f, 
    0.09739874f, -0.03921591f, -0.12286716f, 0.11081199f, 0.16479321f, -0.05539851f, 0.16593964f, 0.16539688f, 
    -0.00430542f, -0.10756160f, 0.02930584f, -0.00634507f, -0.03143847f, -0.06283981f, 0.04838625f, -0.05601650f, 
    0.11471530f, 0.00841762f, -0.02552692f, -0.21518438f, -0.12363421f, 0.06635648f, 0.02891261f, 0.04646737f, 
    -0.07265155f, -0.10684227f, 0.09873642f, -0.04891993f, 0.02855322f, 0.08886996f, -0.01091216f, 0.10230500f, 
    -0.04054319f, -0.01956617f, 0.15010700f, 0.05562653f, 0.13331102f, 0.00075001f, -0.17294465f, 0.00482370f, 
    0.12578738f, 0.20531502f, 0.04453578f, 0.28865814f, 0.03466652f, -0.12744495f, -0.01382295f, 0.17479345f, 
    0.05545534f, 0.10408881f, 0.08503213f, 0.04412365f, -0.10273720f, 0.13133189f, 0.03294861f, -0.17593360f, 
    -0.04500536f, 0.10122873f, -0.04341358f, 0.01884234f, -0.06190861f, 0.12015084f, -0.12627105f, -0.11161764f, 
    -0.15847082f, 0.13007979f, 0.19985484f, 0.09608336f, -0.03842752f, -0.02732743f, 0.03984619f, 0.06319439f, 
    0.16127682f, 0.02508582f, -0.01047617f, -0.07017864f, 0.03115481f, -0.01004977f, 0.07431371f, 0.07953326f, 
    -0.09630767f, 0.14721192f, -0.06465080f, -0.00995424f, -0.09678600f, 0.01825172f, -0.01981803f, 0.05025371f, 
    -0.22637884f, 0.08975355f, 0.09689362f, 0.04287456f, -0.09169257f, 0.00894695f, 0.07191572f, 0.10286790f, 
    0.04656373f, 0.03913486f, -0.01114548f, -0.00414816f, -0.05168521f, -0.06295285f, -0.02406806f, 0.00075609f, 
    0.03284092f, 0.09780608f, -0.01039394f, 0.07271659f, -0.03066588f, -0.09144091f, -0.09734189f, -0.05845924f, 
    -0.14558847f, 0.15756890f, 0.16618359f, 0.09927973f, 0.03763292f, 0.00756841f, -0.06042378f, -0.04860520f, 
    0.10795229f, -0.11154817f, 0.00365857f, 0.06828732f, 0.41744712f, 0.00165904f, 0.01355537f, -0.06616207f, 
    0.03686351f, 0.04334856f, -0.04018488f, -0.00506014f, -0.04568444f, 0.06627832f, -0.01140541f, 0.04574313f, 
    -0.09831888f, 0.10720341f, 0.12855136f, 0.08477545f, 0.01057035f, 0.05531342f, 0.15789418f, 0.00275967f, 
    -0.00950787f, -0.05429716f, 0.12217825f, 0.13220105f, -0.18511614f, 0.14486870f, -0.27402377f, -0.17577927f, 
    0.02064557f, -0.06749889f, 0.04625831f, 0.07043924f, -0.11638018f, 0.06797897f, -0.13202044f, 0.02545898f, 
    -0.06727818f, -0.01718149f, 0.04212840f, -0.06986677f, -0.03891895f, -0.00685998f, 0.05585297f, 0.06219501f, 
    0.00663663f, 0.00861507f, -0.03872480f, 0.03206656f, 0.03208483f, -0.05335560f, 0.02298042f, -0.02984774f, 
    0.00214900f, -0.03987486f, 0.03171556f, 0.02171510f, 0.04770812f, -0.02091556f, -0.04516149f, -0.02209720f, 
    -0.03466432f, -0.04958941f, 0.03529126f, -0.05737457f, -0.06009151f, -0.03856903f, -0.06899500f, 0.02858960f, 
    -0.04621781f, 0.00820827f, -0.00150160f, 0.00771365f, -0.04370789f, 0.01470014f, 0.05506396f, -0.02609068f, 
    0.01078379f, 0.05697776f, 0.01810069f, -0.03863641f, 0.00421923f, -0.02182315f, 0.07186549f, -0.02955971f, 
    0.03261489f, 0.01462589f, -0.06731478f, -0.07615097f, 0.05022032f, 0.02214962f, 0.05544061f, 0.03083975f, 
    0.04675988f, -0.05673702f, -0.02838391f, -0.03267365f, 0.05150708f, 0.00115034f, 0.04402778f, 0.05475076f, 
    -0.07706548f, 0.02244473f, -0.03821879f, 0.03066977f, -0.04901217f, 0.01244309f, 0.00945625f, -0.01589275f, 
    0.01792714f, -0.04614750f, 0.05376787f, -0.04281380f, 0.05067196f, 0.02043766f, 0.02512287f, 0.04599216f, 
    0.05273869f, 0.02709267f, -0.03332418f, -0.02605508f, -0.02102431f, 0.02770861f, -0.07323032f, 0.04049210f, 
    -0.06785730f, -0.01740753f, -0.06160183f, -0.04640079f, 0.00186237f, 0.01388381f, 0.04110768f, -0.02120584f, 
    -0.04958825f, -0.07677609f, -0.07561836f, -0.04695207f, -0.04359642f, 0.00104926f, 0.06599219f, 0.03308143f, 
    -0.07227020f, 0.04610487f, 0.02794327f, -0.01320325f, 0.02284706f, 0.00605458f, -0.00459759f, -0.04798701f, 
    -0.07917902f, -0.04433592f, -0.02018764f, 0.00342165f, -0.03591521f, -0.00671569f, 0.04333095f, 0.02608640f, 
    0.05268844f, -0.05705396f, -0.05314938f, -0.03793660f, 0.05193996f, 0.00556788f, 0.01678110f, 0.01508535f, 
    0.01781982f, -0.06475189f, 0.02827131f, -0.06391580f, -0.05998838f, -0.06209938f, -0.05131992f, 0.04172502f, 
    -0.07458784f, 0.01915869f, -0.07529160f, -0.01983616f, 0.05658041f, -0.00604973f, 0.04776985f, 0.00577094f, 
    -0.05649771f, -0.01054425f, 0.05184748f, 0.03616407f, 0.06127086f, 0.00523078f, -0.04491920f, 0.00983382f, 
    -0.02705673f, 0.02987307f, -0.04811530f, 0.03195854f, 0.06401519f, 0.00529860f, -0.05099260f, 0.05493173f, 
    -0.07038493f, 0.03896787f, -0.00461274f, 0.01167289f, -0.04753572f, 0.04724698f, -0.03340827f, -0.02941619f, 
    0.02617685f, -0.04162418f, 0.03883823f, -0.04751479f, -0.06247843f, -0.02067121f, 0.02224290f, -0.05055290f, 
    -0.03933509f, 0.02620095f, -0.07760990f, -0.02349607f, 0.03260605f, -0.06651634f, -0.06204660f, -0.02243401f, 
    0.05326391f, -0.02175179f, 0.04926665f, -0.04019969f, -0.03633538f, -0.01040577f, 0.04128045f, -0.07062618f, 
    -0.11921080f, 0.00101391f, 0.07195008f, 0.06608567f, 0.07547014f, 0.07863765f, 0.03112574f, 0.03617431f, 
    0.00005974f, 0.01618076f, -0.10771994f, 0.01755320f, 0.01367963f, -0.11232788f, 0.16155156f, -0.16865408f, 
    0.10146865f, -0.08492074f, 0.06630848f, -0.05958120f, -0.09771588f, -0.03255216f, 0.09845086f, 0.01987058f, 
    -0.10269252f, 0.03933848f, -0.11542097f, -0.09390400f, 0.14540783f, 0.00542863f, -0.01307832f, 0.01378296f, 
    -0.04532931f, -0.06229261f, -0.09301218f, 0.03515358f, 0.14898401f, 0.06373572f, -0.01774847f, 0.13024315f, 
    -0.05652350f, 0.02976843f, -0.02772296f, -0.00459094f, -0.08858626f, 0.06483600f, 0.08579700f, -0.08160718f, 
    -0.04679675f, -0.12447555f, -0.05200963f, -0.16410606f, 0.05021175f, -0.06262629f, -0.06380925f, 0.13477726f, 
    -0.04358960f, 0.01828689f, 0.02367576f, 0.08987850f, -0.34117049f, 0.29778749f, -0.07171428f, 0.05434132f, 
    0.10812283f, -0.02235419f, -0.01686383f, 0.10102556f, -0.05473870f, 0.04317692f, 0.05853609f, 0.01227831f, 
    -0.02492549f, 0.06310423f, -0.24008566f, -0.07169035f, 0.15142737f, -0.19371004f, 0.01000421f, -0.03991586f, 
    0.08609699f, 0.00592640f, 0.13401741f, 0.11197113f, 0.23053083f, -0.15810461f, -0.10776223f, -0.08164117f, 
    0.18575986f, -0.14112474f, -0.01153882f, -0.07645886f, 0.09586425f, 0.11979164f, 0.09919189f, 0.05923082f, 
    0.32484007f, 0.02087322f, 0.00364179f, 0.12924461f, -0.04149361f, -0.18548115f, -0.02034227f, 0.01675250f, 
    0.08385988f, 0.07847192f, 0.03084022f, 0.13006198f, 0.07356422f, 0.26489556f, 0.01457454f, 0.08297653f, 
    -0.06622544f, 0.00105828f, 0.05319934f, 0.02745588f, 0.13651831f, 0.07675431f, -0.00128972f, 0.07354788f, 
    0.10851980f, -0.06720652f, -0.07116154f, 0.17320164f, 0.19564213f, -0.00187719f, 0.09080012f, 0.06843286f, 
    0.14479336f, 0.13079940f, -0.00527986f, -0.04993725f, -0.04870275f, -0.02689915f, -0.19872750f, 0.04998069f, 
    -0.09789981f, 0.04141587f, 0.03808310f, -0.11835735f, 0.06003574f, 0.01099017f, 0.06667233f, 0.10894337f, 
    0.03464104f, 0.02172639f, 0.10179683f, -0.17038625f, 0.17633803f, 0.11921199f, -0.02989257f, 0.02455659f, 
    0.00111212f, 0.11895891f, -0.00844110f, 0.12970088f, -0.29934055f, -0.11097413f, -0.04098313f, -0.04704972f, 
    -0.07172161f, 0.05217348f, -0.14890246f, 0.04200384f, 0.08704695f, -0.03232688f, 0.07665662f, 0.08411863f, 
    -0.23805723f, 0.12473397f, -0.07946829f, 0.03080998f, -0.03460013f, -0.00972163f, -0.00007627f, 0.00100124f, 
    0.14118412f, -0.09254857f, 0.00612951f, -0.03140449f, 0.09959234f, -0.06278884f, -0.24763404f, 0.00568495f, 
    0.04292003f, 0.05214577f, -0.06321831f, -0.01372291f, 0.05751256f, 0.00462408f, 0.07268672f, -0.02199999f, 
    -0.09514700f, 0.00391667f, -0.13126044f, -0.11910979f, 0.03850201f, 0.15811116f, 0.10938428f, 0.14731194f, 
    -0.01049440f, -0.10542796f, 0.15174179f, -0.03176726f, 0.04061313f, -0.27082020f, -0.15643208f, -0.27106625f, 
    0.06242238f, 0.08556559f, 0.07486895f, -0.10094494f, -0.06066486f, 0.12474781f, 0.11303557f, 0.05722650f, 
    0.12245583f, -0.00409839f, -0.13047537f, 0.09762896f, -0.11968720f, 0.12649146f, -0.05249709f, -0.11213239f, 
    -0.01531339f, -0.07095281f, 0.11199472f, 0.19402410f, 0.03642135f, 0.16678028f, -0.03334127f, 0.08333232f, 
    0.09209134f, -0.08706953f, 0.18840972f, 0.05846657f, 0.08218150f, 0.01382021f, 0.03406478f, 0.11858964f, 
    0.16539210f, -0.00809231f, -0.06424363f, -0.05008307f, -0.01872678f, 0.02024408f, -0.05864563f, -0.06956760f, 
    0.07352782f, -0.03612886f, 0.13670413f, -0.04835504f, 0.04226208f, 0.00447416f, 0.06135449f, 0.14126961f, 
    0.10367326f, -0.08464346f, 0.12600042f, -0.00848523f, -0.00002327f, -0.12129410f, -0.27176732f, -0.14642501f, 
    0.04453873f, -0.04857739f, 0.00155426f, 0.29020026f, 0.07747474f, -0.24500771f, -0.03869863f, 0.09623700f, 
    0.14096896f, 0.17521164f, 0.18839477f, 0.10623070f, 0.10160974f, 0.03927246f, -0.11247398f, -0.13836390f, 
    0.00688514f, 0.07694440f, -0.15873541f, -0.16611774f, 0.06219794f, 0.02252805f, -0.24499486f, -0.08585392f, 
    -0.02272257f, -0.07831258f, -0.03793240f, -0.00536220f, 0.01744025f, -0.14502536f, 0.08673581f, 0.22031495f, 
    0.12880123f, -0.17683923f, 0.01645142f, -0.02895564f, 0.25026941f, -0.16171253f, -0.10931208f, -0.09413222f, 
    -0.00204013f, 0.03051965f, 0.05477303f, -0.07000452f, -0.01456517f, 0.07037083f, -0.01407557f, 0.10997213f, 
    0.13941067f, 0.02314043f, 0.06464455f, 0.26472965f, 0.00152609f, 0.06709834f, -0.03729742f, -0.06239821f, 
    0.00197300f, -0.08947153f, 0.00334594f, 0.08020830f, -0.00756547f, -0.02757897f, 0.07498735f, -0.15268095f, 
    0.00662335f, 0.04852807f, -0.00878926f, 0.01955027f, 0.07029147f, -0.16110078f, -0.15931870f, -0.08148250f, 
    0.00998032f, -0.02248513f, -0.02120921f, 0.12517528f, -0.02718361f, 0.00637477f, -0.03529968f, -0.11942341f, 
    0.06173126f, -0.12383615f, -0.01508959f, -0.04026230f, 0.41538832f, 0.01730774f, 0.07714940f, -0.15991774f, 
    -0.00626968f, -0.00467404f, -0.22401309f, -0.01165803f, 0.03776937f, -0.01061804f, 0.13042021f, 0.10612930f, 
    -0.30925587f, 0.27454236f, 0.02081755f, 0.08003166f, -0.06458075f, 0.07763118f, 0.20374875f, 0.11456478f, 
    -0.12850821f, 0.06497154f, 0.14474061f, 0.16436741f, 0.08137945f, 0.01334550f, -0.06060671f, 0.04613045f, 
    0.11348871f, -0.27574554f, -0.30341473f, -0.11694990f, 0.03200074f, 0.01271664f, 0.08528294f, 0.08676577f, 
    -0.25254148f, -0.12626649f, -0.04552973f, 0.02069062f, 0.11686507f, 0.11231303f, -0.03958962f, -0.11736664f, 
    0.09538414f, 0.09649386f, 0.00886442f, -0.01605367f, -0.13785778f, -0.18956363f, -0.06953324f, 0.08002754f, 
    -0.01866145f, 0.03829518f, 0.08950933f, -0.00624764f, -0.07940721f, 0.15677357f, -0.05919365f, -0.00423196f, 
    -0.06164321f, -0.09006549f, 0.06471279f, -0.12586735f, 0.00807887f, 0.13424478f, 0.08390769f, 0.06110232f, 
    0.10070355f, -0.04177912f, -0.00239627f, 0.05464949f, -0.13439643f, -0.03816639f, -0.04105747f, 0.03614093f, 
    0.04850677f, -0.01822672f, 0.19004953f, -0.02664833f, -0.03954104f, -0.03786953f, 0.01003712f, 0.17269538f, 
    0.13720757f, -0.02224886f, 0.03003099f, -0.09714276f, -0.06687944f, -0.00344669f, 0.07724664f, 0.01161561f, 
    0.00712066f, -0.07741150f, -0.03432506f, -0.03013147f, -0.35569111f, 0.13832906f, 0.05454404f, -0.12804714f, 
    -0.03382861f, -0.04510329f, 0.07804856f, 0.03394197f, 0.02186890f, -0.03322679f, -0.16028421f, 0.04026562f, 
    0.18143062f, 0.11535556f, -0.04976035f, 0.35052201f, 0.05811673f, -0.04338508f, 0.01684101f, 0.12736636f, 
    0.06408673f, 0.02404857f, 0.12367179f, 0.03659467f, -0.11432438f, 0.01650784f, 0.14743695f, 0.02848116f, 
    -0.05910647f, 0.11690094f, -0.00138471f, 0.03253388f, 0.06561591f, -0.08537105f, -0.17289597f, 0.04777329f, 
    -0.13803457f, 0.30862331f, 0.12466527f, -0.12097824f, 0.15062127f, -0.08322711f, 0.04474957f, 0.13950455f, 
    0.21077847f, 0.00544657f, -0.00245081f, -0.04963737f, 0.19134323f, -0.09962285f, 0.12462526f, 0.18102817f, 
    -0.09255459f, 0.00398633f, -0.02187511f, -0.03800898f, -0.00200710f, -0.02540233f, -0.01167171f, -0.00779406f, 
    -0.15638511f, 0.07974920f, 0.22945441f, 0.06354997f, -0.12393732f, 0.12895776f, 0.01953500f, 0.00676508f, 
    0.01410154f, -0.05305485f, 0.11880638f, -0.00519722f, -0.09825043f, 0.06319821f, 0.10413457f, 0.14181942f, 
    0.07911284f, 0.06345060f, -0.04754831f, 0.12061440f, -0.07301853f, -0.08331338f, -0.04033833f, 0.02659666f, 
    0.12296312f, 0.08410785f, 0.24390301f, 0.22982794f, 0.05709333f, 0.05345839f, 0.01916717f, -0.01002366f, 
    0.06767648f, -0.08389311f, 0.18394013f, 0.09272922f, 0.25784642f, -0.04148899f, -0.09337545f, -0.14662591f, 
    0.00933881f, 0.02205942f, 0.01912654f, 0.07502494f, -0.05689059f, -0.08154078f, -0.05807499f, 0.01225540f, 
    -0.34028822f, 0.15845445f, 0.01744764f, 0.12717280f, 0.00849202f, -0.02352747f, 0.19435683f, 0.00817034f, 
    -0.09812255f, 0.07467730f, 0.21877524f, 0.02511458f, -0.12072425f, 0.00184923f, -0.12642875f, -0.05482438f, 
    0.01956995f, -0.10432529f, 0.02304013f, 0.04485608f, 0.08410690f, 0.06484854f, -0.03263088f, 0.03379627f, 
    -0.17163420f, 0.20497538f, 0.01635959f, 0.18196809f, -0.06360098f, 0.23756579f, 0.13882007f, 0.20456100f, 
    -0.07328384f, 0.05032387f, 0.08477434f, 0.03911952f, -0.08708598f, -0.06184858f, -0.14475967f, -0.06864309f, 
    -0.06332393f, 0.12967905f, -0.05978676f, -0.16165635f, -0.13544977f, -0.04932922f, 0.07944876f, 0.16265999f, 
    0.16396563f, -0.18985361f, 0.06970576f, -0.38416934f, 0.10981491f, 0.02206554f, -0.00407132f, 0.04708052f, 
    0.02415559f, 0.10934269f, -0.05098292f, 0.18964818f, -0.06608113f, 0.06252693f, 0.18298885f, 0.28636855f, 
    0.07627308f, 0.03571710f, 0.16710110f, 0.08873852f, 0.07979175f, -0.03098407f, -0.00683268f, -0.05407153f, 
    0.18694530f, 0.00133330f, -0.05969217f, 0.00349711f, -0.16103821f, -0.04757670f, -0.07662946f, 0.06789729f, 
    0.00896469f, -0.08002122f, 0.07398694f, -0.06999168f, -0.31375277f, -0.13703158f, 0.18017434f, -0.04307941f, 
    0.04136589f, -0.06762839f, -0.00104441f, 0.12323245f, 0.02565404f, -0.06185088f, -0.02778291f, -0.10621206f, 
    -0.06436905f, 0.15056808f, 0.13763791f, 0.22769298f, 0.12237854f, 0.08614321f, -0.01118760f, 0.02020243f, 
    0.04588928f, -0.02320969f, -0.01259384f, 0.05850380f, -0.27065903f, -0.28660613f, -0.13472652f, -0.14533629f, 
    0.06124363f, -0.13183194f, -0.05242706f, -0.09161299f, 0.12863551f, -0.15699086f, -0.11607104f, -0.03707166f, 
    -0.14341006f, 0.00837125f, -0.10194386f, -0.23490556f, 0.06163026f, 0.00656730f, 0.08249979f, 0.21313375f, 
    -0.01386139f, -0.01377817f, 0.01572664f, 0.09715173f, -0.07167873f, -0.34480405f, -0.26542664f, 0.22977738f, 
    -0.26675090f, 0.08219890f, 0.02859461f, -0.04267590f, -0.04902129f, 0.22888510f, -0.05527269f, 0.07532104f, 
    -0.25855953f, -0.07105603f, -0.16586165f, 0.15377131f, -0.02091303f, 0.01103769f, -0.18356594f, -0.01723432f, 
    0.12274615f, 0.10772410f, 0.06862707f, -0.02251769f, -0.07152909f, -0.10737248f, 0.10593073f, -0.15377846f, 
    0.04497631f, 0.04088068f, -0.04777576f, 0.08226698f, 0.03533297f, -0.08375926f, -0.16441327f, 0.03365078f, 
    0.31582224f, 0.25954521f, -0.05945892f, 0.04030107f, -0.00730281f, 0.07517063f, 0.02217156f, -0.05783190f, 
    -0.03764012f, 0.07142072f, 0.04523888f, -0.14715041f, 0.17018557f, 0.09781644f, 0.28444844f, 0.08353727f, 
    0.19275349f, 0.12610942f, 0.02694291f, 0.06043387f, -0.06858486f, -0.05518684f, -0.11103916f, 0.00386358f, 
    0.02497533f, 0.06087744f, 0.46121550f, 0.04579433f, -0.03133235f, 0.03757542f, 0.00122751f, -0.06577842f, 
    -0.01011579f, 0.08919838f, 0.08407433f, 0.14623392f, 0.00430480f, 0.33175662f, -0.09754243f, -0.07608036f, 
    0.06575761f, -0.07054751f, -0.17549512f, -0.08790977f, 0.09184140f, 0.01109996f, 0.07499933f, 0.11318821f, 
    0.19057965f, 0.15991092f, 0.00056114f, -0.07369219f, 0.01904949f, 0.00358941f, 0.02342357f, -0.08000027f, 
    0.12471802f, 0.00678226f, 0.13409759f, 0.02814586f, 0.15610592f, 0.08487450f, -0.04027837f, 0.12672423f, 
    0.00835857f, 0.12959792f, 0.10277127f, -0.02532005f, -0.05817547f, 0.22011521f, 0.02133935f, 0.02935622f, 
    -0.19378686f, 0.03797106f, -0.11734474f, 0.13413604f, -0.06792463f, 0.03825217f, 0.06728655f, -0.11449379f, 
    0.09620417f, -0.08246589f, -0.00243884f, -0.02529302f, 0.15478095f, 0.06065100f, 0.13442159f, -0.10656851f, 
    0.13982755f, -0.06897654f, 0.03988447f, -0.06785858f, 0.10485724f, -0.14574105f, -0.06008097f, 0.07950499f, 
    -0.03292779f, -0.03329839f, -0.11722364f, 0.00149020f, -0.14022675f, 0.05292739f, -0.07455050f, -0.03060671f, 
    0.06124137f, -0.10130661f, -0.05774133f, -0.02153326f, 0.39127433f, -0.15190114f, -0.09505316f, 0.03715944f, 
    0.02872321f, -0.08295101f, -0.11550439f, 0.05560334f, 0.01576783f, 0.18160439f, -0.09943122f, 0.06004607f, 
    0.26880756f, -0.06343183f, 0.28418353f, 0.22503509f, 0.03503096f, 0.09510027f, -0.00168308f, -0.04221988f, 
    0.02599409f, -0.08885705f, 0.08639865f, -0.05372922f, -0.21347795f, 0.18777210f, 0.05618091f, -0.17064206f, 
    -0.13270234f, 0.09094786f, 0.02000410f, 0.07720432f, -0.09353420f, 0.00275578f, -0.09678445f, -0.06051318f, 
    -0.52233195f, 0.08007962f, 0.06500701f, -0.20451561f, -0.03857899f, -0.03312491f, 0.07437320f, -0.04064811f, 
    -0.11705142f, -0.10475595f, -0.01080393f, -0.12747478f, -0.01939936f, -0.16232547f, 0.15510598f, -0.13220185f, 
    -0.02828345f, -0.08003373f, -0.03337178f, 0.08698272f, -0.13644552f, 0.00909201f, 0.00570445f, -0.15443894f, 
    0.03440141f, -0.05665552f, 0.05809223f, -0.04654141f, -0.12278756f, 0.02238252f, -0.02119584f, 0.09275750f, 
    -0.04700628f, 0.08161661f, 0.05995449f, 0.06782515f, -0.05599912f, 0.10040634f, 0.22734237f, -0.04159883f, 
    0.02959792f, -0.02268161f, -0.04032791f, -0.06304824f, -0.02848415f, 0.06595748f, -0.07534321f, -0.00966312f, 
    -0.14725451f, 0.07318628f, 0.26296866f, 0.11232359f, -0.10421302f, 0.01263663f, -0.01773517f, -0.03028759f, 
    -0.08026212f, -0.02117400f, 0.08004576f, -0.01106582f, 0.43394718f, 0.15583687f, 0.05757203f, 0.11459057f, 
    0.30302370f, 0.07889640f, 0.01246079f, 0.02869819f, 0.08670852f, -0.03204054f, -0.05700164f, -0.01554856f, 
    0.25352204f, 0.19128831f, 0.10864425f, 0.01409865f, 0.04581464f, 0.14283848f, 0.10900468f, 0.02263782f, 
    -0.06022816f, 0.10713801f, -0.02730692f, 0.05357431f, -0.07699516f, 0.02679708f, -0.05492553f, 0.15630132f, 
    0.08406784f, -0.09826918f, -0.03125377f, 0.08140776f, -0.14218116f, 0.05417185f, -0.08673520f, 0.05381949f, 
    0.12944502f, -0.15151519f, 0.17482957f, 0.02662333f, 0.06061633f, 0.07033969f, 0.13694756f, 0.15539514f, 
    -0.03254179f, 0.04751988f, -0.08003290f, 0.00100110f, 0.22378562f, -0.02715904f, 0.04745444f, -0.02108879f, 
    0.05551618f, -0.10082385f, 0.01635540f, -0.06299437f, 0.00458861f, -0.02535987f, -0.00480861f, 0.08961696f, 
    -0.06525690f, 0.20871310f, -0.07293350f, 0.11073234f, -0.03622736f, -0.00082310f, -0.01347780f, -0.02903909f, 
    -0.09677763f, 0.07101303f, -0.07430138f, 0.10527879f, 0.27788022f, -0.12577166f, -0.10077738f, -0.06858311f, 
    0.04211491f, 0.07134589f, -0.03136854f, 0.25214958f, -0.07998940f, 0.06720283f, 0.11835155f, -0.10395242f, 
    -0.02149128f, 0.02124495f, -0.05497705f, -0.08990379f, 0.08837352f, -0.01889410f, 0.01596889f, 0.06001392f, 
    0.03554530f, 0.07795370f, -0.11043805f, -0.05288456f, 0.06949359f, 0.07895343f, -0.18193263f, 0.16728078f, 
    0.17941283f, -0.00129618f, -0.10032581f, 0.05770814f, -0.00179299f, -0.00475156f, 0.19670688f, -0.07622568f, 
    -0.07181988f, -0.05226528f, -0.11646327f, -0.22197725f, -0.00416427f, 0.04691419f, 0.02838156f, -0.01274226f, 
    0.05276582f, -0.04030349f, 0.02457469f, -0.00392725f, 0.06739471f, -0.06024463f, 0.03682047f, -0.21217918f, 
    0.12150903f, -0.05579071f, 0.08267207f, -0.09413332f, 0.13318650f, -0.00701200f, -0.00106815f, 0.00517458f, 
    0.26802427f, 0.00766022f, -0.24861819f, 0.30695301f, 0.09522113f, 0.01552574f, -0.11300434f, 0.02695681f, 
    -0.14562026f, 0.09492771f, -0.03705111f, 0.10139596f, -0.07836774f, 0.11505771f, 0.16641830f, 0.06151822f, 
    0.07964377f, -0.06691805f, 0.11200608f, -0.01807895f, -0.00085287f, 0.00420166f, -0.03761191f, 0.17929123f, 
    0.22573969f, -0.05582718f, -0.01273497f, -0.06417979f, 0.11170071f, -0.05667490f, 0.09779952f, -0.01302397f, 
    0.02474550f, -0.00423617f, 0.03969023f, 0.01586030f, -0.11682599f, -0.00543563f, -0.16068408f, -0.21420245f, 
    0.02904392f, -0.01099375f, 0.11819566f, -0.06909561f, 0.11575482f, 0.06193842f, 0.05443323f, -0.05481142f, 
    -0.08898554f, -0.00523555f, -0.03181751f, -0.11004170f, 0.08738858f, -0.03813354f, 0.07415934f, 0.05306065f, 
    -0.11172739f, 0.02450497f, -0.15262946f, 0.00136258f, -0.30193105f, -0.01892928f, -0.16583884f, 0.01698093f, 
    -0.01195534f, -0.03839301f, -0.02422681f, 0.01186313f, 0.07304917f, 0.04191784f, 0.06648599f, 0.02307589f, 
    0.14503954f, -0.11451307f, -0.07164147f, 0.05766530f, 0.09707234f, 0.00107216f, -0.04130111f, 0.01123430f, 
    0.05208361f, 0.00687689f, 0.03348394f, 0.04228358f, 0.04899042f, 0.19140543f, 0.11827096f, -0.16580290f, 
    0.10368536f, 0.12409849f, 0.12335195f, 0.01664967f, 0.03479942f, -0.03495498f, -0.03335923f, -0.07658377f, 
    -0.16977140f, -0.05174685f, -0.07410601f, -0.04617449f, 0.11969351f, 0.12828323f, -0.06107530f, -0.10990503f, 
    0.02731774f, 0.08946210f, -0.06722147f, 0.00371476f, -0.03171245f, -0.24134289f, -0.05997289f, -0.07430359f, 
    -0.01931734f, 0.16390620f, -0.02072997f, -0.04947729f, 0.01034156f, 0.02597661f, -0.00582231f, 0.01092522f, 
    -0.14225133f, -0.03777987f, 0.05706596f, -0.16565572f, 0.01919244f, 0.08831637f, 0.10975321f, 0.08581709f, 
    -0.10088034f, -0.08351842f, 0.07859135f, -0.07859232f, -0.06905283f, 0.07490386f, 0.11894699f, -0.03291259f, 
    0.11177699f, 0.10804111f, 0.06913488f, -0.12254094f, 0.08337106f, 0.00773271f, -0.05266942f, 0.14379472f, 
    0.13094109f, -0.03202171f, 0.15184972f, 0.03621669f, -0.06161661f, -0.00599506f, 0.08844841f, 0.02992963f, 
    0.02738687f, -0.03635172f, 0.05139955f, 0.06986983f, -0.26721451f, -0.03273771f, 0.12378600f, -0.02353348f, 
    -0.08446256f, -0.06569895f, -0.17745133f, 0.05411610f, -0.00672423f, 0.12829322f, 0.02333314f, 0.04269494f, 
    0.23173267f, -0.00889119f, 0.11016343f, 0.26222530f, 0.06255489f, -0.05271649f, -0.00813501f, 0.01006068f, 
    -0.08391327f, -0.07796600f, -0.06769729f, 0.05909547f, -0.09164356f, -0.16085008f, 0.10665116f, 0.24424216f, 
    -0.07944751f, -0.02116567f, -0.00793667f, 0.03663955f, 0.00214948f, -0.18661807f, -0.03997248f, 0.01008135f, 
    -0.08382696f, 0.26602253f, 0.01125732f, -0.26451778f, 0.02660468f, 0.06158820f, 0.12755398f, 0.11560660f, 
    0.01435449f, -0.02631395f, 0.11234950f, 0.02694763f, 0.22347614f, -0.25454158f, -0.02811243f, 0.15514728f, 
    0.04961713f, 0.01682187f, -0.03693256f, -0.00587563f, -0.01902138f, 0.12725483f, -0.04822935f, 0.02166148f, 
    -0.01820417f, -0.11266296f, -0.05157179f, 0.09992928f, -0.04311607f, 0.03336646f, -0.07791951f, 0.03007273f, 
    0.02706663f, 0.04158490f, -0.00262466f, 0.09580727f, 0.01307221f, 0.01430004f, 0.24509794f, 0.23392856f, 
    0.00433983f, -0.06455187f, -0.09577460f, 0.07514465f, -0.04188541f, 0.13827530f, 0.06168484f, -0.04362233f, 
    0.24928908f, -0.00681033f, 0.04448388f, 0.17777419f, -0.13590801f, -0.02303218f, -0.01913931f, 0.19494407f, 
    -0.06525436f, 0.12557580f, 0.08786154f, 0.02687427f, 0.29405078f, 0.14079392f, -0.08531632f, 0.05728430f, 
    0.06607600f, 0.04034186f, 0.07182123f, 0.00331334f, 0.00661278f, -0.08044884f, -0.13605550f, 0.02608284f, 
    -0.03460754f, 0.12255015f, 0.18539874f, -0.04653899f, -0.07675999f, 0.07912850f, 0.09456702f, 0.05888368f, 
    0.02572251f, 0.15364021f, 0.03044368f, -0.08928242f, 0.07932507f, -0.07982611f, -0.01279774f, 0.12991273f, 
    -0.14003998f, 0.02557881f, -0.08896404f, 0.01927659f, -0.04621813f, -0.04711283f, 0.01602761f, -0.00817148f, 
    -0.31767422f, 0.10008609f, -0.02773083f, 0.03385942f, 0.10235011f, 0.23855504f, -0.07653405f, 0.03474296f, 
    0.07105896f, -0.04862100f, 0.02729215f, -0.08123183f, -0.01910297f, 0.12351846f, -0.21101588f, -0.04927519f, 
    0.11852251f, 0.14750935f, 0.10923982f, 0.06793848f, -0.06947871f, 0.01620245f, -0.01934079f, 0.09850452f, 
    0.00951291f, -0.08740517f, 0.06863829f, -0.16919857f, 0.00551861f, 0.22395533f, 0.12073680f, -0.03889611f, 
    0.02108836f, -0.06149823f, -0.07263041f, 0.07957952f, 0.08852626f, -0.14518322f, 0.05303679f, 0.23897167f, 
    0.00128379f, -0.08294786f, 0.12682801f, -0.01524196f, -0.02511653f, -0.01247833f, -0.05229120f, 0.10153284f, 
    0.26959389f, 0.00296071f, 0.09904185f, -0.14831483f, -0.03017793f, -0.04200286f, 0.09360870f, 0.07089801f, 
    0.05899438f, -0.01011326f, 0.07019367f, 0.01754224f, -0.20388712f, -0.03876171f, 0.01729538f, -0.19523528f, 
    -0.07540803f, -0.03422673f, 0.07411090f, 0.04884838f, 0.08147428f, 0.00544615f, -0.15468837f, 0.02525685f, 
    0.18881781f, 0.22809066f, 0.00298319f, 0.45328477f, 0.03608548f, 0.01558387f, -0.06684431f, 0.08530051f, 
    -0.00346873f, 0.01818024f, 0.02109142f, -0.01731405f, -0.34524354f, -0.06445938f, 0.00878476f, -0.10893837f, 
    -0.08648860f, 0.11431370f, -0.01783579f, 0.05855483f, 0.01650786f, -0.05728137f, -0.08893719f, -0.02853101f, 
    -0.17437753f, 0.21087600f, 0.05742084f, -0.00799412f, 0.15087144f, -0.02813083f, -0.00237278f, -0.00338683f, 
    0.08642522f, 0.03756034f, 0.02436010f, -0.00238108f, 0.16737199f, -0.15891729f, -0.10447566f, 0.21008040f, 
    -0.18059917f, 0.05310846f, 0.01699571f, 0.02714304f, -0.15726775f, 0.01903021f, -0.11777512f, 0.06729963f, 
    -0.22315659f, -0.00975504f, 0.08325053f, 0.02031814f, 0.00495125f, 0.06746463f, 0.04078519f, 0.03306291f, 
    0.02100385f, -0.05296254f, 0.01142385f, 0.07895962f, 0.01899080f, -0.00054922f, 0.13397811f, 0.07730280f, 
    0.07723227f, 0.02278406f, -0.12078001f, 0.09643441f, -0.09063170f, 0.06113053f, -0.04738713f, 0.04665044f, 
    0.08618021f, 0.28002805f, 0.03810890f, 0.18604772f, -0.02840893f, -0.03396447f, 0.03625057f, -0.05048187f, 
    0.07916679f, 0.04225399f, 0.03543088f, -0.02292022f, 0.30625021f, 0.12695274f, -0.04465677f, 0.06683908f, 
    0.12016216f, -0.01403912f, 0.02595115f, 0.09871230f, 0.02114777f, -0.09803940f, -0.01164635f, 0.00860494f, 
    -0.07905680f, 0.02635408f, 0.16879241f, 0.09373739f, 0.03032708f, 0.07163891f, -0.00800730f, 0.05260247f, 
    -0.06136817f, 0.07518258f, 0.14307527f, 0.00839143f, -0.22533911f, 0.30030739f, -0.17273381f, -0.11741441f, 
    0.06064945f, -0.03751761f, -0.05535764f, -0.04777460f, -0.08186932f, 0.01061026f, -0.05105660f, 0.02392057f, 
    0.03980033f, 0.01762565f, 0.02854193f, -0.00878689f, -0.02126496f, 0.05222493f, -0.07513855f, 0.03122887f, 
    0.03754674f, 0.04084386f, -0.05261995f, 0.00628300f, 0.05019385f, -0.07340512f, -0.01624192f, -0.07219438f, 
    0.04079863f, -0.04000026f, 0.01861004f, -0.06372146f, -0.01809277f, -0.03434300f, -0.03168463f, 0.03447947f, 
    -0.05149117f, -0.02557756f, -0.04505668f, -0.04773712f, -0.05647699f, -0.00646812f, 0.03027263f, -0.01558785f, 
    -0.00043735f, -0.05604819f, -0.07072076f, -0.05140872f, -0.02368302f, 0.04164535f, -0.00942973f, 0.01225185f, 
    -0.07276620f, -0.08201515f, -0.00802086f, -0.04549892f, 0.00242667f, -0.04955071f, -0.00076694f, 0.04398667f, 
    0.04406214f, 0.03378303f, 0.01992359f, 0.03244470f, -0.03436252f, -0.00530337f, 0.02384933f, -0.06559423f, 
    0.04183521f, 0.04954755f, -0.08648296f, -0.06702077f, -0.04569429f, -0.09005637f, 0.02996902f, -0.03712639f, 
    0.02125902f, -0.00664057f, -0.03146840f, -0.06945558f, -0.04140046f, -0.00920731f, -0.07068677f, 0.06082470f, 
    -0.02078005f, 0.02113918f, -0.07818449f, -0.00802661f, -0.04123553f, -0.06995555f, -0.01558635f, -0.03350068f, 
    -0.01532204f, -0.01346069f, -0.04576059f, -0.06507874f, -0.04553444f, -0.02652058f, -0.04116716f, 0.05719506f, 
    -0.04776794f, 0.05338522f, -0.01046260f, -0.02019199f, -0.05578544f, -0.06970610f, 0.00769068f, -0.08357953f, 
    0.00928643f, -0.08108144f, -0.05786643f, 0.04205728f, 0.01874174f, 0.05354890f, -0.01428490f, 0.01679564f, 
    0.03989618f, -0.05732708f, 0.03378147f, -0.00268430f, -0.00599188f, -0.01288025f, 0.03597058f, -0.03127997f, 
    -0.07126007f, -0.08398351f, -0.05466583f, -0.07165834f, 0.01370231f, 0.01256288f, 0.05498320f, -0.07119060f, 
    -0.03104312f, 0.03868896f, 0.03669181f, -0.05083301f, 0.00253868f, -0.01944366f, -0.05947270f, -0.07296677f, 
    0.01423109f, 0.02627264f, -0.04330009f, -0.02655614f, -0.01084616f, -0.08065923f, -0.06388137f, 0.03907931f, 
    -0.03223493f, -0.07211386f, 0.00968675f, 0.03751567f, -0.01732068f, -0.00221667f, 0.00038459f, 0.04365985f, 
    0.02862488f, -0.09414917f, -0.08345020f, 0.00250829f, -0.07852217f, 0.03947683f, -0.01381181f, 0.01140584f, 
    0.02239808f, 0.01740361f, -0.04169481f, -0.02700969f, -0.07775620f, -0.05094944f, -0.00124178f, 0.03953191f, 
    -0.06623019f, -0.07439536f, -0.01662782f, -0.07487881f, -0.00600234f, -0.07596088f, 0.02604882f, -0.04769473f, 
    -0.07353776f, 0.03154840f, 0.01919898f, -0.00961655f, -0.06144943f, -0.06946417f, -0.02145476f, -0.00603265f, 
    0.05539746f, 0.02516470f, -0.05625699f, -0.06671728f, 0.03764328f, -0.05938516f, 0.01297770f, -0.02576720f, 
    -0.03571962f, -0.06967162f, -0.01075272f, -0.06261802f, -0.02594814f, 0.05263655f, -0.06813794f, 0.01424996f, 
    -0.05246167f, 0.03374190f, 0.05349979f, -0.02537327f, -0.00072123f, 0.05421420f, 0.04881279f, -0.02133160f, 
    0.01716074f, -0.03906197f, 0.00083236f, -0.05149033f, 0.07150465f, -0.03821044f, -0.07004151f, 0.01642665f, 
    0.05409945f, 0.01348389f, -0.01320260f, 0.01171282f, -0.07246429f, 0.04229426f, 0.03527403f, -0.01497351f, 
    -0.10988650f, -0.03584085f, 0.02690441f, 0.04587372f, -0.04041626f, -0.00650127f, -0.01201660f, 0.03071439f, 
    -0.01026464f, 0.04457751f, 0.01529923f, 0.07179355f, 0.00063393f, -0.04499937f, 0.05701162f, 0.03654213f, 
    0.02708234f, 0.02653399f, -0.02867110f, -0.08574712f, 0.05248084f, -0.05420832f, -0.12984519f, -0.03850600f, 
    -0.04182125f, -0.08497463f, 0.03792601f, -0.01252765f, -0.01752239f, -0.08053922f, 0.03069905f, 0.03648604f, 
    -0.01865557f, -0.00986156f, -0.00723545f, -0.03935840f, -0.00601013f, -0.02498702f, -0.00506403f, 0.05411012f, 
    0.02507534f, 0.02996012f, 0.07522621f, -0.02989432f, -0.02161029f, 0.00161970f, -0.02445736f, 0.07630055f, 
    -0.04091308f, 0.04977129f, -0.05916960f, -0.11979507f, -0.07215118f, -0.06455970f, 0.05916416f, 0.00881190f, 
    0.02602659f, -0.04275997f, -0.13742600f, -0.05687626f, -0.02238471f, 0.04179945f, -0.09019092f, -0.01437958f, 
    -0.11456923f, 0.01095243f, -0.05770018f, 0.07059652f, 0.07358530f, -0.07016198f, -0.06480065f, 0.02305572f, 
    -0.07862008f, -0.02896815f, 0.01699508f, 0.02842917f, -0.00737788f, -0.01131796f, 0.04322169f, 0.05959639f, 
    0.04462301f, 0.03705106f, -0.08270414f, -0.03072311f, -0.03058732f, -0.08202934f, 0.01904960f, -0.00900377f, 
    -0.08330122f, -0.03270131f, 0.01771924f, -0.09582240f, 0.04232707f, -0.02404103f, 0.05438885f, -0.07360062f, 
    -0.08707345f, 0.05223732f, -0.00904503f, 0.00536964f, -0.07569326f, -0.08101480f, -0.05746510f, -0.04658834f, 
    0.00837047f, 0.08335204f, 0.04690792f, -0.00890159f, -0.06020618f, 0.00208156f, -0.06331596f, 0.02871725f, 
    0.00660927f, -0.04661681f, -0.02268697f, -0.02304879f, 0.02051325f, -0.00008465f, 0.00565922f, 0.06422799f, 
    0.05419295f, -0.04752552f, -0.12208104f, -0.07304928f, -0.06446205f, -0.08993651f, 0.01172161f, -0.07077013f, 
    -0.07539799f, 0.00811048f, 0.02288461f, 0.01539829f, -0.04414075f, 0.05351232f, 0.07024194f, -0.05795284f, 
    0.02588501f, -0.08466762f, -0.03918720f, -0.07369283f, -0.00904096f, -0.01607937f, -0.12361898f, -0.11584063f, 
    -0.07092519f, -0.00535468f, -0.05615224f, -0.04975930f, -0.08844274f, -0.05581662f, -0.06758029f, -0.03931346f, 
    -0.06675864f, -0.02768603f, -0.00007923f, 0.02014146f, -0.00612024f, -0.07127526f, -0.09242355f, -0.08120986f, 
    -0.00951552f, -0.02951286f, -0.01773284f, 0.04451998f, -0.02743063f, 0.07342452f, -0.02388299f, 0.01801116f, 
    0.03085209f, 0.29053369f, -0.03763630f, 0.01878500f, -0.03654894f, 0.01578512f, 0.11095640f, 0.11556065f, 
    0.13996561f, -0.03262883f, 0.00355121f, -0.00186491f, 0.01365965f, 0.20449267f, -0.12689468f, -0.09286277f, 
    -0.00109767f, 0.10800420f, 0.03008566f, -0.12920004f, 0.09118603f, 0.11045115f, 0.09175859f, 0.12008862f, 
    -0.03890352f, 0.05329755f, -0.12728940f, 0.12683296f, -0.06033649f, 0.06603593f, -0.07384241f, -0.15185763f, 
    0.04894340f, -0.06382795f, 0.06065833f, 0.13866450f, 0.25747305f, 0.01124306f, 0.08459587f, 0.18212402f, 
    0.03645375f, 0.00687045f, 0.07490224f, 0.06063819f, -0.01741002f, -0.07505238f, 0.04692847f, 0.04201611f, 
    0.18344845f, 0.03987078f, -0.06735528f, 0.14831141f, 0.00506698f, 0.00796692f, -0.02283945f, -0.11436737f, 
    0.07620762f, -0.12686405f, 0.14686023f, -0.05315344f, 0.37637413f, -0.07976919f, 0.08558577f, 0.04137587f, 
    0.00754933f, -0.06380873f, 0.11066391f, 0.06080691f, -0.02850898f, 0.02239205f, -0.19485328f, -0.13932283f, 
    -0.17076051f, 0.03934453f, -0.05415002f, 0.27098188f, -0.04352730f, 0.02687631f, 0.01163655f, 0.08003120f, 
    0.04085439f, 0.11560259f, 0.04343562f, -0.04151187f, -0.08301588f, 0.09869214f, -0.11261198f, -0.15873773f, 
    0.00022191f, 0.09246372f, -0.13035385f, -0.09861865f, -0.06481861f, -0.01188980f, -0.02462595f, -0.09882334f, 
    -0.22162023f, -0.19040701f, 0.18039551f, 0.03075945f, 0.05606542f, -0.20223086f, 0.12783600f, 0.00547095f, 
    0.06072477f, -0.12787651f, -0.04564210f, -0.00395522f, 0.04338231f, -0.09490367f, -0.13856274f, -0.14022630f, 
    0.10495184f, 0.04125250f, -0.01469751f, -0.06030438f, 0.08963048f, 0.02892630f, -0.04531788f, -0.01249270f, 
    -0.01863223f, -0.14537469f, 0.09550837f, 0.10963510f, 0.00405346f, 0.05736168f, -0.10141284f, -0.12785512f, 
    -0.05861581f, -0.09952119f, 0.04698114f, 0.09103464f, 0.00180707f, -0.08306839f, 0.09137858f, -0.17352577f, 
    0.04606283f, 0.04509865f, -0.03372980f, -0.02243171f, -0.00101008f, -0.11686199f, -0.19035147f, 0.03380613f, 
    -0.13116094f, 0.10393938f, -0.03151475f, -0.03602904f, -0.02585942f, -0.02936933f, 0.00065162f, -0.23285146f, 
    0.02504814f, -0.10493860f, -0.00806396f, 0.04743557f, 0.42406908f, -0.06410604f, 0.26244751f, -0.22629382f, 
    0.17637256f, -0.04594148f, -0.20419295f, -0.03997851f, -0.02627878f, -0.04411932f, 0.12370812f, 0.01179943f, 
    -0.09552842f, 0.17520981f, 0.02908861f, 0.25165123f, -0.00810261f, 0.19856711f, 0.11601204f, 0.03885274f, 
    -0.03167247f, 0.08314938f, 0.17183077f, 0.11112357f, 0.09332772f, 0.14899245f, -0.05936121f, 0.04033077f, 
    0.23582380f, -0.22526473f, -0.18177082f, -0.06852756f, -0.09585759f, 0.04814080f, 0.11892080f, 0.07632899f, 
    0.13650961f, -0.04552358f, 0.12144668f, -0.11356782f, -0.13094282f, 0.05414806f, 0.01899101f, -0.03334662f, 
    -0.04761282f, -0.00142159f, 0.05226305f, 0.05359929f, -0.05472103f, -0.07262623f, 0.11747616f, -0.06710947f, 
    -0.02494637f, 0.05772727f, -0.06667297f, -0.08346081f, -0.10247461f, -0.05298162f, -0.01733109f, -0.09846043f, 
    -0.10777195f, 0.12485372f, -0.09232427f, 0.24828684f, -0.05571649f, 0.06321809f, 0.16197254f, -0.11429907f, 
    -0.03412165f, -0.10669956f, 0.02173013f, 0.04976181f, 0.30397907f, 0.14485063f, -0.00522378f, -0.04772576f, 
    0.04650655f, -0.09875904f, -0.11662129f, 0.01783763f, 0.05730059f, -0.02076018f, 0.03467298f, 0.09833223f, 
    0.07034486f, -0.00152571f, 0.00907778f, 0.13031827f, -0.12060846f, 0.13323845f, 0.00743295f, 0.06834365f, 
    -0.01533231f, -0.06142248f, 0.11506151f, -0.04753508f, 0.17748033f, 0.05353618f, 0.16760850f, 0.15584096f, 
    0.02380961f, -0.09783828f, 0.03110022f, -0.07900326f, -0.00591592f, 0.13083979f, 0.04954772f, 0.02824971f, 
    0.05180114f, -0.13203616f, 0.21968949f, 0.06118422f, -0.02375907f, -0.04092116f, 0.02523075f, 0.07515725f, 
    0.13275187f, 0.10045415f, -0.07577030f, 0.05271634f, -0.05121871f, -0.19390789f, -0.09829211f, 0.16011743f, 
    -0.16246772f, 0.02912664f, 0.03290201f, -0.09518968f, -0.08830683f, 0.11922567f, -0.10928174f, -0.01058757f, 
    0.27010760f, -0.15114020f, -0.10383401f, 0.11456978f, -0.09338807f, 0.09372517f, -0.01982111f, 0.06569090f, 
    -0.02746544f, 0.01207805f, -0.02791464f, -0.01429905f, 0.01582422f, -0.23295870f, 0.03489105f, -0.09413939f, 
    0.12160546f, 0.19566280f, 0.08271267f, 0.18682882f, 0.00550375f, 0.01164881f, -0.08831221f, -0.04905418f, 
    0.00140357f, -0.17742188f, 0.00148997f, 0.23061912f, -0.07493427f, 0.06975716f, 0.09436435f, 0.05409543f, 
    0.04077320f, -0.12972580f, -0.01496765f, 0.01356446f, -0.23412274f, 0.00945091f, 0.09230290f, -0.09682517f, 
    -0.01707521f, 0.07255779f, 0.08702163f, -0.03248658f, 0.00612428f, 0.00743423f, 0.04293916f, -0.01778772f, 
    -0.03211764f, -0.18870372f, -0.01629670f, -0.13451868f, -0.03024047f, 0.14538489f, 0.16000381f, -0.04568918f, 
    0.04631568f, 0.02914817f, -0.04982517f, 0.02554526f, 0.34498414f, 0.22245772f, 0.14731751f, -0.22967479f, 
    -0.13619165f, -0.06521552f, -0.19812012f, -0.02780197f, 0.05777525f, -0.03631641f, 0.06881565f, 0.15770923f, 
    0.07210477f, 0.01293489f, -0.00535201f, -0.05908205f, 0.00233106f, -0.04696818f, 0.00657399f, 0.02217431f, 
    -0.00902649f, 0.00211507f, 0.03991328f, 0.07156690f, 0.04833762f, -0.22202228f, 0.05797088f, 0.15974978f, 
    0.02401113f, 0.08718782f, -0.07569651f, 0.17045927f, -0.14098211f, -0.01218654f, -0.05127519f, -0.12269838f, 
    0.04229775f, -0.13901225f, 0.16292527f, 0.08259190f, 0.11768296f, 0.04254068f, 0.01453848f, 0.17798133f, 
    -0.02287423f, 0.07231708f, 0.00708648f, -0.04465168f, -0.01679558f, 0.11604916f, -0.02016664f, -0.01250024f, 
    0.09448748f, -0.00944486f, -0.01537883f, -0.00589587f, -0.03731946f, -0.15349238f, 0.02902338f, 0.12407792f, 
    0.29786456f, 0.01704135f, 0.07990304f, -0.13257720f, -0.06298044f, 0.15057263f, 0.05805624f, 0.04822004f, 
    0.04238364f, -0.03151381f, -0.02974878f, 0.04689363f, 0.09630734f, -0.23306848f, -0.05988118f, 0.01561641f, 
    -0.06720212f, 0.11664252f, -0.05272880f, 0.04418330f, 0.03983321f, 0.03181410f, 0.06564413f, -0.04375441f, 
    0.01768565f, 0.23768815f, 0.02824278f, -0.15806980f, -0.02110828f, -0.02009025f, -0.02605957f, 0.09837399f, 
    0.02624507f, 0.05541059f, -0.04896353f, -0.05746361f, 0.19920303f, -0.05088337f, -0.09293624f, 0.09676928f, 
    0.02770426f, 0.03291230f, 0.01618985f, 0.14708413f, 0.04915912f, -0.08834793f, 0.07759048f, -0.06050786f, 
    -0.00558722f, -0.00040476f, -0.02432618f, -0.14039885f, -0.06048080f, 0.09912957f, -0.03495833f, 0.19175778f, 
    0.04227459f, 0.07819670f, 0.03857390f, -0.05398642f, -0.10075033f, 0.12396586f, 0.22444133f, -0.22097845f, 
    -0.00999797f, 0.04706083f, -0.02368015f, -0.02269346f, 0.03766510f, 0.02254319f, -0.13058759f, 0.02803541f, 
    0.14508906f, -0.02776376f, -0.02668234f, 0.14571905f, 0.06334979f, 0.18109185f, -0.10688716f, 0.10088421f, 
    -0.02918422f, 0.04733652f, -0.14438288f, 0.06325726f, -0.12620686f, -0.08957033f, 0.12023401f, 0.08971397f, 
    -0.02676476f, -0.00451309f, 0.08753651f, -0.07199769f, -0.05236371f, -0.07966588f, 0.06124902f, 0.11979493f, 
    0.01943266f, 0.20472014f, 0.20497614f, -0.12346906f, -0.02509539f, 0.05425870f, 0.03076209f, 0.13820098f, 
    0.05781229f, -0.02740387f, -0.05977515f, 0.00397183f, -0.21958448f, -0.11299927f, -0.09581646f, -0.16353031f, 
    -0.04967750f, 0.01693235f, 0.05241407f, 0.01735000f, -0.02454320f, -0.09760477f, -0.05119329f, 0.00354842f, 
    -0.07920410f, 0.02251386f, -0.15937987f, -0.02376387f, 0.10063871f, -0.03632825f, 0.00668758f, -0.04856662f, 
    -0.08332588f, 0.00695208f, 0.06267054f, -0.08050174f, -0.06967486f, 0.05139260f, -0.08651292f, 0.00630535f, 
    0.02426635f, -0.01021451f, -0.02570960f, 0.00981534f, -0.13887700f, 0.03829434f, -0.03033097f, -0.02376237f, 
    0.20480265f, -0.12521800f, -0.07234463f, 0.04130752f, 0.13364483f, 0.02965735f, -0.06808593f, 0.03033914f, 
    -0.03057646f, 0.05358270f, 0.19764069f, 0.19497982f, -0.01616730f, 0.37121713f, 0.18343958f, -0.29944569f, 
    0.08170860f, 0.00435233f, 0.17080256f, 0.11360203f, 0.00469498f, 0.12983562f, -0.04629778f, 0.00498579f, 
    -0.22719832f, -0.03300225f, 0.14386961f, 0.03124106f, -0.03061947f, 0.15587521f, -0.00447104f, 0.14676133f, 
    0.07289336f, 0.03079039f, 0.07464059f, 0.03665121f, -0.01910010f, 0.25549686f, -0.07737453f, 0.01306056f, 
    0.07243980f, 0.04780096f, 0.02843338f, 0.13085476f, 0.07241656f, -0.11295287f, -0.09278470f, 0.13534081f, 
    -0.18825372f, 0.13933386f, -0.05403458f, 0.05062569f, -0.03429211f, 0.18182097f, 0.13060762f, -0.00727891f, 
    0.05158366f, -0.07539245f, 0.04794411f, 0.21750228f, 0.01235312f, -0.21460788f, -0.04600465f, 0.14852394f, 
    -0.10015914f, -0.17909047f, -0.00476233f, 0.02545887f, 0.09016056f, 0.03716903f, -0.03692036f, 0.03717436f, 
    0.30355775f, 0.16005678f, -0.08062875f, 0.03840977f, -0.01871590f, -0.08308281f, 0.11209401f, 0.01422618f, 
    0.08472449f, -0.05654923f, 0.10409281f, -0.07587280f, -0.12340683f, -0.06444304f, -0.03273129f, 0.03777116f, 
    0.06581624f, -0.07603846f, 0.13245821f, 0.06058991f, -0.01969265f, -0.03100852f, -0.07696854f, -0.04055880f, 
    -0.16879386f, 0.02654427f, -0.01285942f, 0.37836716f, -0.05588453f, 0.03195872f, -0.08923561f, 0.09053171f, 
    0.03862506f, 0.15133470f, 0.07768501f, -0.02193005f, -0.19574925f, -0.09214634f, -0.02801009f, -0.10147636f, 
    -0.08982138f, 0.06725005f, 0.11545705f, -0.01380855f, -0.03755474f, -0.06706042f, -0.13475387f, -0.03862915f, 
    -0.21247000f, 0.03258622f, -0.08051840f, 0.12857932f, 0.02508607f, -0.04837783f, -0.00279003f, -0.00731617f, 
    0.05920285f, 0.04770596f, 0.04160011f, -0.01868916f, 0.19546653f, -0.06230954f, 0.10162302f, 0.06828070f, 
    -0.00780643f, 0.06987853f, 0.06397917f, 0.02076045f, -0.01413092f, -0.06163466f, -0.10566635f, -0.05676757f, 
    -0.13645881f, -0.16280991f, 0.27011409f, -0.00870498f, -0.07172118f, 0.08452145f, 0.06963973f, -0.02230031f, 
    0.06155530f, -0.08834348f, -0.03396945f, 0.02942191f, -0.14371289f, -0.00044851f, 0.23628147f, -0.04198858f, 
    0.06614314f, 0.01113835f, -0.02316714f, -0.06402871f, -0.08081239f, -0.11037131f, -0.14059688f, 0.11345945f, 
    0.02315798f, 0.13018970f, 0.07727554f, -0.02642390f, -0.04378362f, 0.04707848f, 0.05694406f, -0.02351001f, 
    -0.08713460f, -0.03881061f, 0.07264555f, 0.00611914f, 0.07742168f, 0.00942594f, -0.04779275f, -0.24004184f, 
    0.08256664f, -0.02989980f, -0.02440385f, 0.04028020f, 0.06820948f, -0.07820489f, 0.05631394f, 0.09815785f, 
    -0.27273741f, -0.04717786f, -0.04623624f, 0.27055404f, -0.08591687f, -0.02377597f, -0.00296189f, 0.08295558f, 
    -0.05063467f, 0.08317652f, 0.00347098f, 0.10146537f, -0.05759792f, 0.20572512f, -0.14058533f, -0.01197435f, 
    0.11019479f, -0.07318780f, -0.01469784f, 0.11690071f, -0.01777818f, 0.09988007f, -0.09030160f, -0.04598061f, 
    0.00799081f, 0.02220329f, -0.07058602f, -0.05036326f, 0.04579389f, -0.03051087f, -0.04132484f, 0.02365470f, 
    -0.03595277f, -0.01070226f, -0.07258825f, -0.06506432f, -0.07329869f, 0.01889528f, 0.00122165f, 0.05527923f, 
    -0.04169145f, -0.05663434f, -0.06272495f, -0.00669971f, -0.07229334f, 0.05912738f, 0.02948719f, 0.05572145f, 
    -0.03578022f, 0.00575556f, 0.00332457f, -0.07239377f, 0.04485895f, -0.04682555f, -0.05565765f, -0.04869045f, 
    -0.06027956f, 0.04953092f, -0.07547966f, -0.05475119f, -0.01763710f, 0.05306841f, -0.05012836f, -0.04226930f, 
    -0.06592040f, 0.03121731f, 0.02875362f, -0.06552447f, -0.02404992f, -0.06251688f, 0.02432050f, 0.03334953f, 
    -0.06800231f, -0.02397531f, 0.03820591f, -0.02482176f, -0.06986495f, 0.00979648f, 0.00763140f, -0.04134052f, 
    -0.07568991f, -0.02397013f, 0.06038212f, -0.04859588f, -0.03857562f, -0.06027493f, -0.05989477f, -0.03826276f, 
    -0.03463365f, 0.05345334f, 0.00315318f, 0.01122385f, 0.02757172f, 0.00760402f, 0.01278614f, -0.01722662f, 
    -0.06280994f, -0.06287773f, 0.05125049f, 0.03587506f, 0.06028958f, -0.06509618f, 0.02159604f, 0.05019400f, 
    -0.01571109f, -0.04627764f, 0.01204814f, 0.00889651f, 0.03524236f, 0.01755154f, -0.04715611f, -0.04231890f, 
    0.06111939f, -0.06560139f, -0.03834629f, 0.04829975f, 0.01871662f, -0.03036060f, 0.06025022f, -0.01407076f, 
    0.02421560f, 0.04226139f, 0.04048337f, -0.00778904f, -0.03588196f, -0.05304449f, -0.02062984f, 0.04852362f, 
    -0.01786379f, -0.04423299f, -0.07299831f, -0.07346302f, 0.02350334f, -0.06506774f, -0.04545612f, 0.04539951f, 
    0.03726914f, 0.00604226f, -0.01565392f, -0.07355943f, -0.03028160f, 0.06375254f, 0.03152627f, -0.06090173f, 
    0.01555278f, 0.01652628f, -0.06183497f, -0.04176188f, -0.07390559f, 0.01587210f, -0.06561859f, -0.04423801f, 
    -0.06639797f, 0.00462564f, 0.03221714f, 0.02421338f, 0.05055740f, -0.04266795f, 0.06395290f, -0.06339639f, 
    0.04505819f, 0.04873188f, 0.01968559f, 0.01209735f, -0.06612694f, 0.04032505f, 0.06064490f, 0.03307253f, 
    -0.05066960f, -0.03673671f, 0.03999545f, -0.05134134f, 0.05801762f, -0.01167427f, 0.04158809f, 0.00773480f, 
    -0.01747637f, -0.04897512f, 0.04153794f, -0.03597847f, -0.07545597f, -0.05828829f, 0.06375923f, 0.02105033f, 
    -0.05688407f, -0.03438935f, -0.06619580f, -0.00620782f, -0.04534726f, 0.06596363f, 0.06656737f, 0.03277373f, 
    -0.02572995f, -0.05454714f, 0.02004256f, -0.02711778f, 0.05011319f, -0.06009607f, -0.05700985f, -0.05163291f, 
    0.01562999f, -0.04706996f, -0.00007321f, -0.03265753f, 0.05664437f, -0.07025456f, 0.01783151f, 0.02705440f, 
    0.04643148f, -0.04223101f, 0.02583643f, -0.07498082f, 0.05299759f, 0.01294442f, -0.02950117f, -0.01048576f, 
    0.20680769f, 0.17607777f, -0.03786918f, 0.17181808f, -0.03332143f, 0.04970193f, -0.00245601f, 0.11896784f, 
    -0.04561186f, 0.03123089f, 0.01134733f, 0.00231410f, -0.03289162f, 0.06263591f, 0.03870731f, -0.01210382f, 
    -0.18309881f, -0.01258153f, -0.08038621f, -0.04784122f, 0.05994343f, -0.01619014f, 0.09874451f, -0.04569159f, 
    0.45681944f, -0.13709447f, 0.14945228f, 0.04817195f, 0.06759574f, 0.00702050f, -0.07670261f, 0.04487005f, 
    0.03822623f, 0.11947244f, -0.00428036f, -0.13355827f, -0.14389530f, 0.03629138f, -0.05868606f, 0.09951254f, 
    -0.00081186f, 0.11232505f, -0.00175327f, 0.02206228f, 0.01147360f, -0.11960921f, 0.02004863f, -0.01145002f, 
    -0.05264942f, 0.13121392f, 0.19344920f, 0.14440291f, 0.00572645f, 0.04744915f, -0.05381040f, -0.06636811f, 
    -0.04265211f, 0.02383719f, 0.00443459f, 0.04272789f, 0.24693663f, -0.15818240f, 0.02960348f, -0.00617147f, 
    0.06244694f, -0.02319013f, -0.03363428f, 0.05694185f, 0.10121588f, -0.04465125f, 0.07866400f, -0.08927724f, 
    -0.16866647f, -0.02564598f, 0.13642767f, -0.34298199f, 0.05532254f, 0.11898987f, -0.05532433f, -0.00294886f, 
    0.05545075f, 0.07330915f, 0.00707726f, -0.12301023f, -0.09190458f, 0.11062277f, 0.16039081f, 0.06905472f, 
    -0.03915756f, -0.00580254f, -0.10960571f, 0.03670086f, -0.01735731f, -0.05513918f, 0.08380971f, 0.07327592f, 
    -0.03861062f, -0.30676231f, 0.15356974f, -0.18852928f, 0.00896045f, 0.14924110f, 0.02215604f, 0.00997239f, 
    -0.12851901f, 0.05093190f, 0.04871030f, -0.06342115f, -0.19594751f, -0.04490478f, -0.07676228f, -0.01723203f, 
    -0.01025981f, 0.01238797f, -0.00792225f, -0.03292289f, 0.09002838f, 0.05345665f, 0.02051848f, -0.02493311f, 
    0.03291205f, 0.25555950f, -0.00255798f, 0.08229044f, 0.03202539f, -0.00749137f, 0.00648407f, 0.06627078f, 
    -0.10765974f, -0.03903070f, -0.04330194f, -0.12264615f, 0.13988769f, -0.10489617f, -0.03072188f, -0.07414944f, 
    -0.04338646f, 0.06445987f, 0.16595666f, -0.12240907f, 0.05210039f, 0.02690947f, -0.01176491f, -0.05578336f, 
    -0.04817567f, -0.00519243f, -0.32666370f, 0.02392023f, -0.04317215f, -0.12707205f, 0.08438396f, -0.01940010f, 
    -0.01947490f, 0.07515877f, 0.08363853f, -0.08320185f, -0.10735842f, 0.04134434f, 0.07309838f, 0.03966809f, 
    0.04471139f, 0.06512304f, 0.10179610f, -0.01020358f, -0.17771915f, 0.01305119f, 0.00668576f, -0.13332172f, 
    0.23863183f, -0.20249230f, 0.19762936f, -0.10380662f, 0.08896758f, 0.03562063f, -0.09015851f, -0.06667242f, 
    -0.02057240f, -0.04014966f, 0.04442450f, 0.02047059f, 0.13725913f, 0.18936926f, 0.29349253f, 0.03688579f, 
    0.01231688f, 0.09082682f, 0.01365703f, -0.05142647f, -0.00489838f, -0.02237990f, 0.02683548f, 0.07177868f, 
    0.07443068f, 0.16808352f, 0.01982253f, 0.11176980f, -0.02747868f, 0.05070632f, -0.09227033f, -0.12780964f, 
    -0.03943641f, -0.02879857f, -0.04147355f, 0.18350932f, 0.03393223f, 0.17408039f, 0.13417731f, -0.12521401f, 
    -0.13249739f, -0.03121538f, 0.03945090f, 0.00991028f, 0.10058670f, -0.00235429f, -0.07558984f, -0.06576728f, 
    0.00523796f, -0.08584797f, -0.11633729f, 0.09724502f, 0.05688821f, -0.07744265f, 0.04240287f, 0.09836634f, 
    0.04028214f, 0.04350447f, 0.02652641f, 0.01523256f, -0.01555676f, 0.04038866f, -0.08356735f, 0.08180295f, 
    0.11095768f, -0.10184623f, 0.05276877f, -0.06427152f, 0.12725909f, 0.00986171f, -0.13734457f, 0.11584423f, 
    0.06002788f, 0.09635441f, 0.07839405f, 0.06124449f, -0.00046392f, 0.10055507f, -0.05215200f, -0.13390960f, 
    0.12598237f, -0.05151879f, 0.06548414f, 0.10988294f, -0.07453802f, -0.16766207f, 0.09964508f, 0.11356496f, 
    0.06000000f, -0.02762875f, 0.07139151f, -0.08317867f, -0.05429118f, 0.13690174f, 0.02650950f, 0.22272809f, 
    -0.23923373f, -0.07009024f, 0.04048033f, 0.13376673f, 0.06388484f, 0.05280893f, 0.06050225f, -0.09593276f, 
    0.02880547f, 0.00926705f, -0.00196547f, -0.00160178f, 0.07685055f, 0.03263441f, -0.10886294f, 0.01459641f, 
    0.01900299f, -0.05320692f, 0.00976068f, 0.10636579f, -0.04967194f, -0.04125952f, 0.05870176f, 0.03377028f, 
    -0.29158372f, 0.04921631f, 0.03061548f, -0.19285285f, -0.08465409f, -0.00305051f, 0.03814660f, -0.09860672f, 
    -0.02024802f, 0.03492557f, 0.11105421f, -0.04710827f, -0.07352819f, -0.12184273f, -0.00870271f, -0.33836415f, 
    0.06652287f, 0.01711836f, -0.08680950f, -0.03689221f, 0.01148106f, 0.06266517f, -0.13942271f, -0.13894399f, 
    0.09889296f, -0.12169722f, 0.06231260f, 0.06536092f, -0.05829897f, 0.03887993f, -0.14094429f, -0.07796375f, 
    0.05269970f, 0.04977962f, 0.09470413f, -0.01023331f, -0.14183521f, 0.12544313f, 0.12687728f, 0.07664008f, 
    -0.03645123f, 0.10250652f, 0.02599569f, -0.00114357f, -0.00588043f, 0.07109866f, 0.03930958f, 0.14074586f, 
    -0.04350821f, 0.16926156f, 0.12362301f, -0.12696360f, -0.06689636f, 0.01662794f, 0.11410845f, -0.07470170f, 
    0.12880340f, -0.02622066f, 0.08219893f, 0.01288143f, 0.07407282f, -0.16124859f, 0.17748165f, -0.16182852f, 
    0.04598502f, -0.00591797f, 0.14018297f, 0.07282490f, 0.07751366f, -0.09620180f, 0.08190394f, -0.04775295f, 
    -0.36684695f, 0.15183121f, 0.08183008f, -0.02610974f, 0.01374032f, 0.00948470f, 0.03251420f, 0.09411664f, 
    -0.01806253f, -0.07905757f, -0.05902142f, 0.08850420f, 0.14668585f, -0.12685502f, -0.04718996f, 0.40954512f, 
    0.02112421f, 0.07374956f, -0.00215711f, -0.02960147f, 0.00226092f, -0.05728883f, 0.11424972f, 0.05336597f, 
    0.14360330f, -0.07127652f, 0.12810881f, 0.08179535f, -0.02576000f, 0.06180903f, 0.11271726f, 0.11682316f, 
    -0.03352225f, 0.07736172f, 0.13800903f, 0.03659943f, 0.05380189f, 0.10955682f, 0.13754512f, -0.01969384f, 
    0.02847040f, 0.00231788f, -0.09565254f, -0.08645466f, 0.07743638f, -0.07310867f, 0.14358364f, 0.05514375f, 
    0.28697768f, 0.14939582f, -0.01612338f, 0.15135576f, 0.07602742f, -0.02185880f, -0.00633250f, -0.03712759f, 
    -0.04735777f, -0.04461647f, 0.03703858f, 0.12853132f, 0.03640811f, -0.02023458f, -0.09899730f, -0.06464975f, 
    -0.05980804f, 0.08792509f, -0.04629143f, 0.08722219f, 0.08051080f, -0.05412420f, 0.03936180f, -0.12697181f, 
    0.06177922f, 0.16061841f, 0.06447457f, 0.15294962f, -0.01221528f, 0.03789372f, 0.06599630f, -0.03461622f, 
    0.03348485f, 0.12781982f, 0.07612152f, -0.08265071f, 0.09690751f, -0.07561387f, 0.04635553f, 0.21712349f, 
    -0.01205842f, 0.02589424f, -0.04459631f, 0.13390173f, 0.09190303f, -0.03015579f, 0.04969766f, -0.13092250f, 
    -0.20450172f, -0.24979006f, 0.15545987f, -0.34480587f, -0.06550483f, 0.06922068f, -0.01424500f, 0.07523225f, 
    0.15285985f, 0.02720345f, -0.09967351f, 0.02548796f, -0.01238086f, 0.08652130f, 0.06346081f, 0.02479335f, 
    -0.02234893f, -0.03648600f, -0.00255606f, -0.05845476f, -0.00788580f, 0.03850497f, -0.03375988f, 0.05496266f, 
    0.18939249f, -0.26974753f, -0.22853529f, -0.00141847f, -0.02063222f, 0.03032287f, -0.05710145f, 0.05147006f, 
    -0.09005208f, 0.08487413f, 0.06389854f, -0.04771344f, -0.22049837f, -0.19868831f, 0.08375663f, -0.04901392f, 
    0.06824272f, 0.15745293f, -0.03879392f, 0.05267349f, 0.07259303f, 0.05086321f, -0.00029106f, 0.11405594f, 
    0.03879436f, 0.02742923f, 0.03161676f, 0.25329167f, -0.00640371f, 0.01750080f, 0.00127152f, -0.01515357f, 
    -0.01081191f, 0.06350555f, -0.04596123f, -0.11062223f, -0.19434150f, -0.07964749f, 0.01797016f, -0.27081496f, 
    0.08893560f, 0.01203089f, 0.11124129f, 0.02565593f, 0.04280154f, -0.08255041f, 0.05130580f, -0.06867237f, 
    -0.15200542f, -0.09777770f, -0.22762808f, -0.16531557f, 0.01215846f, 0.00776420f, 0.06371292f, -0.02818484f, 
    -0.10125066f, 0.01008891f, -0.04511449f, -0.04922015f, -0.14310266f, -0.09612074f, -0.16907370f, -0.10379683f, 
    -0.07640785f, 0.04099259f, 0.00472945f, -0.15447788f, -0.00132288f, 0.01134360f, -0.11234226f, 0.04248349f, 
    0.13142143f, -0.29901966f, 0.03175091f, 0.01729734f, -0.00861601f, -0.13326469f, 0.02863851f, -0.00266291f, 
    0.01172840f, 0.02932202f, -0.04269737f, 0.13630226f, 0.23487526f, 0.19888318f, 0.13974535f, 0.12603489f, 
    0.00526099f, -0.03513565f, -0.02533977f, 0.10273226f, -0.04493939f, 0.17435288f, 0.08774503f, 0.09598377f, 
    -0.23463139f, -0.08572453f, -0.00973792f, -0.03682372f, 0.13650461f, 0.06351563f, -0.09721966f, -0.02964150f, 
    -0.03803601f, -0.04862865f, 0.00374660f, -0.04671714f, 0.27026969f, 0.11545672f, -0.19144553f, -0.06719696f, 
    0.05236917f, 0.06131359f, 0.06944169f, 0.06059483f, 0.04986918f, -0.06075463f, -0.02342456f, 0.06654252f, 
    -0.11681975f, 0.20136335f, 0.00968232f, 0.02199480f, -0.07078752f, 0.12503606f, 0.15652917f, 0.06949606f, 
    0.02235653f, -0.09280393f, 0.06759707f, 0.04216113f, -0.07616532f, -0.17045495f, 0.02201407f, -0.05878651f, 
    0.12662667f, -0.10634325f, 0.09383187f, 0.06807210f, 0.03143646f, 0.12982181f, 0.01266669f, 0.07495774f, 
    0.38703892f, -0.01952683f, 0.07987829f, 0.13896586f, 0.02365278f, -0.01721308f, 0.07851485f, -0.06573667f, 
    0.09906545f, -0.01015035f, 0.04551344f, 0.02095288f, -0.33528221f, 0.00155507f, -0.09396720f, -0.07406092f, 
    0.04639623f, -0.18361801f, 0.07789908f, -0.08491069f, 0.01567286f, 0.02142073f, -0.06578758f, 0.03006674f, 
    -0.03280693f, 0.13372418f, -0.22541252f, 0.37104416f, -0.06415084f, -0.13386440f, 0.03050443f, 0.10489143f, 
    -0.01399517f, 0.10619893f, 0.05895103f, 0.13016915f, 0.15071826f, 0.06245263f, -0.05127773f, 0.00377421f, 
    -0.06622474f, 0.08672172f, 0.05720789f, 0.10792707f, 0.06547285f, -0.17202502f, -0.01595462f, 0.05574096f, 
    -0.33339852f, 0.17015310f, -0.00191848f, -0.05263831f, 0.02382580f, 0.00276881f, 0.03806841f, -0.04844327f, 
    0.17010552f, 0.06916314f, 0.03001799f, 0.01797123f, 0.42026672f, 0.03193227f, -0.03720999f, 0.11989225f, 
    -0.05972866f, 0.03792711f, -0.05825271f, -0.02587212f, -0.02559378f, -0.04189948f, -0.07010946f, 0.03842953f, 
    0.08502548f, 0.03300105f, 0.15563895f, -0.00020920f, -0.10031395f, 0.13684995f, 0.00592808f, -0.04352853f, 
    0.02007332f, -0.04230690f, 0.02725570f, 0.09246481f, -0.15577538f, -0.02735318f, 0.18238105f, 0.13524565f, 
    -0.08017757f, 0.09359330f, -0.07311013f, 0.04210680f, -0.03371952f, -0.04320020f, -0.08110530f, 0.12968251f, 
    0.16461287f, 0.19060725f, 0.08173028f, 0.17134967f, 0.08433061f, 0.04072371f, -0.01694447f, -0.01870451f, 
    -0.01355909f, -0.10568704f, 0.12722078f, -0.01866625f, -0.14652894f, -0.12393034f, -0.14451802f, -0.13045226f, 
    0.00259510f, -0.01707505f, 0.00917425f, 0.11983921f, -0.00609122f, -0.16083507f, 0.01363453f, 0.12727085f, 
    -0.33536071f, 0.06586754f, -0.08256294f, 0.12045214f, 0.04346211f, 0.00073631f, 0.01300592f, 0.04858543f, 
    0.00470895f, 0.10596771f, 0.04241588f, 0.04802782f, 0.04283570f, 0.14294475f, -0.16826396f, 0.13305376f, 
    0.09373610f, 0.01813398f, -0.03133877f, -0.04274720f, 0.06857868f, -0.03186763f, -0.04770310f, -0.06782899f, 
    0.00840990f, 0.04108487f, -0.00161402f, -0.03928172f, 0.00015613f, -0.04253080f, -0.03721351f, -0.05033199f, 
    -0.01409509f, -0.03524203f, 0.05876678f, -0.07852001f, 0.02316318f, -0.05461385f, 0.00792646f, 0.05325286f, 
    -0.01772634f, 0.05640871f, -0.01865622f, 0.05467571f, -0.01069313f, 0.05834335f, -0.01302443f, -0.04139706f, 
    -0.00334449f, -0.02167339f, 0.02464506f, 0.05454086f, 0.04451910f, -0.04562264f, -0.03122856f, 0.03399200f, 
    0.05094156f, 0.01356460f, -0.02114731f, -0.07756521f, -0.06948690f, 0.03843166f, 0.03756541f, 0.02416681f, 
    0.05796535f, 0.04592274f, -0.07653598f, 0.05122564f, -0.02493954f, 0.01212295f, 0.01767786f, -0.07125705f, 
    -0.05617809f, 0.00215220f, -0.06119689f, 0.02928339f, 0.03083853f, 0.02125774f, -0.06382416f, -0.00368088f, 
    0.02614792f, 0.01757686f, -0.03466149f, 0.00207545f, -0.06883042f, -0.04501032f, -0.02335867f, 0.01247413f, 
    -0.01787843f, 0.05339917f, -0.05215502f, -0.00108911f, -0.06159950f, -0.02845607f, -0.05207003f, 0.00520956f, 
    -0.03299999f, 0.00709442f, -0.05898136f, 0.05244085f, -0.01518972f, 0.02148743f, -0.04462187f, -0.06063335f, 
    0.03295847f, -0.03367461f, 0.02002721f, 0.04217973f, -0.02988764f, 0.01820985f, -0.02129178f, 0.01046749f, 
    -0.00799275f, 0.00371821f, -0.03273740f, -0.04290954f, -0.07074454f, 0.01340872f, 0.02668253f, -0.01053607f, 
    -0.01254073f, -0.01955239f, -0.04474758f, 0.01504428f, -0.04945217f, -0.03048804f, -0.06788632f, -0.04193460f, 
    0.01670837f, -0.05226285f, 0.01258860f, 0.04260187f, -0.04795963f, -0.07862743f, 0.02450120f, -0.05566800f, 
    0.03876114f, -0.02644232f, -0.01264681f, -0.03108707f, 0.04316526f, -0.02442415f, 0.05460040f, -0.05005129f, 
    -0.01776001f, 0.01416691f, 0.05663386f, -0.05581206f, 0.02653953f, 0.03317961f, -0.03119373f, 0.02103847f, 
    0.04183419f, 0.02866159f, -0.07436745f, 0.04968131f, 0.04965508f, -0.07725046f, -0.03539990f, -0.04338309f, 
    0.04391751f, 0.01526613f, 0.01291017f, -0.08053632f, 0.03392952f, 0.00396289f, -0.08555387f, 0.04753342f, 
    -0.03553772f, 0.01833026f, 0.02798793f, 0.00897935f, -0.07146809f, 0.03366404f, -0.02142418f, 0.03108193f, 
    -0.03797466f, 0.00572398f, 0.04944025f, 0.02221595f, -0.05659300f, 0.04121539f, -0.05980763f, -0.07713500f, 
    0.04293854f, 0.02255028f, 0.02878221f, -0.06893530f, 0.00836862f, 0.01517757f, -0.06591512f, -0.05741711f, 
    0.04562199f, -0.05736796f, 0.03973939f, 0.00483686f, 0.00956285f, 0.04784488f, -0.02552177f, -0.08062671f, 
    0.05235100f, -0.00456573f, -0.01512830f, -0.01831140f, -0.04348041f, 0.03097515f, -0.06040118f, -0.07037066f, 
    0.00736658f, -0.04339343f, 0.01996213f, -0.03229324f, -0.06234951f, -0.05633055f, 0.05414690f, 0.00159955f, 
    -0.04146370f, -0.02277435f, 0.01737786f, -0.03771978f, 0.01143228f, -0.05063483f, 0.01063183f, 0.00482248f, 
    -0.03052667f, -0.03820793f, -0.06488982f, -0.05441800f, 0.01093353f, -0.07444236f, 0.02060845f, 0.04797670f, 
    -0.00692584f, 0.04747687f, 0.00283578f, -0.02976918f, 0.03543133f, 0.03791678f, 0.04200699f, -0.03367043f, 
    0.05186322f, 0.00705967f, 0.00797366f, 0.01672056f, 0.05921509f, -0.03366661f, 0.03297604f, 0.01300921f, 
    0.04756469f, 0.05191526f, 0.01573653f, -0.06120832f, -0.01514068f, 0.03782741f, -0.01704776f, 0.00366209f, 
    0.05045967f, -0.01893636f, -0.04699514f, -0.05198139f, -0.05813624f, 0.01915768f, -0.05396293f, 0.04596965f, 
    0.03328905f, -0.04320178f, -0.04058063f, 0.06556287f, 0.05379161f, 0.02314531f, 0.00713447f, 0.01223313f, 
    -0.06591208f, -0.02829915f, -0.05876515f, -0.03061158f, -0.04409649f, -0.01842695f, -0.03052696f, 0.06265269f, 
    -0.02930141f, -0.05303759f, 0.06053822f, -0.02451452f, -0.02158604f, 0.04188964f, 0.00374112f, 0.03190494f, 
    -0.07782102f, 0.03955830f, 0.02051249f, -0.06352796f, 0.03099299f, -0.05146222f, -0.01405419f, 0.00898844f, 
    0.02315946f, 0.04590539f, -0.02027806f, 0.04230971f, 0.01489040f, -0.02795885f, -0.05664832f, 0.01820035f, 
    -0.00473252f, 0.01921051f, -0.01104577f, -0.00573276f, -0.01496993f, -0.04815630f, 0.06357515f, -0.05627567f, 
    -0.07505979f, -0.05829073f, 0.01326560f, 0.02058320f, -0.00410777f, -0.04153304f, 0.04920939f, -0.03163840f, 
    0.05920534f, -0.06061827f, -0.04409923f, -0.02132760f, 0.02456505f, -0.00579370f, 0.05009051f, 0.04551834f, 
    -0.05426417f, 0.03586292f, -0.03293277f, 0.05862394f, -0.05066968f, -0.07322671f, -0.06297505f, -0.05766514f, 
    0.06220443f, 0.00856446f, 0.02859101f, -0.03502436f, -0.04581223f, -0.07723644f, -0.06417877f, -0.06599261f, 
    -0.01640830f, -0.03555481f, 0.00806727f, 0.01456803f, -0.05194522f, -0.00980214f, -0.07203294f, -0.06849883f, 
    0.05478508f, 0.01304722f, -0.05170044f, 0.04062254f, -0.04787644f, 0.02856169f, -0.00469205f, 0.00136291f, 
    0.04410888f, 0.06198470f, -0.02180962f, 0.00564359f, -0.04804057f, 0.00801991f, -0.00050988f, -0.03233728f, 
    -0.01611000f, -0.04010567f, -0.04928808f, -0.05614492f, -0.04070432f, 0.01511032f, 0.04256619f, -0.02606956f, 
    -0.03531896f, -0.00984555f, -0.00674200f, 0.03582828f, -0.05344382f, -0.06048137f, -0.04379625f, -0.00237611f, 
    -0.02805582f, -0.04809661f, -0.07323380f, -0.06302419f, 0.03403771f, -0.04071965f, -0.05153071f, -0.06201959f, 
    -0.03908771f, -0.03985961f, 0.06248089f, 0.04645274f, 0.02306614f, -0.00393526f, 0.02835223f, 0.02077418f, 
    -0.00885210f, 0.00610311f, 0.03496620f, 0.04367733f, -0.01307404f, 0.04313909f, 0.06444678f, -0.06732889f, 
    0.01639408f, -0.02396588f, -0.05387294f, 0.05144398f, -0.05777349f, -0.06159249f, 0.03346157f, 0.03369382f, 
    0.04447113f, 0.02214875f, -0.02442116f, -0.04811528f, -0.05879938f, -0.04062802f, -0.06582823f, -0.04642001f, 
    -0.03283386f, 0.06529579f, -0.04264811f, -0.04800658f, -0.00101425f, 0.00448495f, -0.02956635f, -0.06577125f, 
    -0.05101131f, -0.03768153f, 0.00035554f, 0.03984867f, 0.05789362f, -0.06750055f, -0.00910976f, -0.06970909f, 
    -0.03733694f, -0.06928626f, -0.02147637f, -0.03900830f, 0.02335543f, -0.07583395f, 0.02472287f, 0.05132813f, 
    -0.05090197f, -0.02665223f, 0.05999359f, 0.04144967f, -0.02648638f, -0.03215343f, 0.05163400f, 0.02052816f, 
    0.00630797f, 0.04358434f, 0.02612439f, -0.00115067f, -0.01585835f, -0.03478898f, -0.07632741f, 0.03285787f, 
    0.03998710f, 0.05917700f, 0.06349209f, 0.05628786f, -0.04868313f, -0.06137138f, 0.02696745f, -0.05364296f, 
    -0.03504910f, -0.07113844f, -0.06674355f, -0.04550262f, 0.05901302f, -0.04327179f, 0.03357040f, -0.02806827f, 
    0.05954988f, -0.06257293f, -0.06564790f, -0.06597546f, 0.02617703f, -0.00979565f, -0.05635606f, 0.02576864f, 
    0.05898153f, 0.01992871f, -0.03220419f, 0.05808055f, 0.00678565f, 0.02995564f, -0.05372841f, -0.06494934f, 
    0.01203378f, -0.04502935f, 0.04402377f, -0.03538586f, -0.05432422f, 0.04847499f, 0.03007743f, -0.06476652f, 
    0.06004605f, 0.02018303f, -0.01482392f, 0.02047104f, -0.01227865f, -0.07151952f, 0.03522065f, 0.04740230f, 
    0.01575146f, 0.03057292f, -0.02210175f, 0.03141339f, 0.05249184f, -0.03688269f, -0.01563657f, -0.01329743f, 
    -0.05792468f, -0.00266302f, -0.07608288f, -0.02555175f, -0.07727398f, -0.07180500f, 0.06312948f, -0.02681474f, 
    -0.06001725f, 0.01430667f, -0.06283119f, -0.05492521f, -0.07319503f, -0.06134323f, 0.05278768f, 0.00392727f, 
    0.04548486f, -0.00319278f, 0.02974716f, -0.07450942f, 0.01682371f, 0.03143769f, -0.04899208f, -0.04017751f, 
    -0.06644966f, -0.07329224f, -0.05448560f, -0.04623249f, -0.04074880f, 0.02671476f, -0.07098021f, 0.03395618f, 
    0.02952954f, 0.05777854f, -0.02115960f, 0.01865658f, -0.03203784f, -0.02691402f, -0.03455329f, -0.02066481f, 
    -0.02089885f, 0.01677388f, -0.07126042f, 0.04714254f, 0.04443910f, -0.03756177f, 0.02711442f, -0.03327441f, 
    -0.06397625f, 0.00848270f, 0.01979536f, 0.01761336f, -0.06480525f, 0.02388469f, -0.05842016f, 0.05684835f, 
    -0.02188947f, -0.04022681f, 0.05445951f, -0.05417997f, 0.01356995f, 0.05690471f, 0.01706201f, -0.07508274f, 
    -0.03608280f, -0.05716124f, 0.03981570f, 0.01944205f, -0.00707881f, -0.04543694f, -0.00461980f, 0.03663338f, 
    0.03943155f, -0.01124060f, 0.03956640f, 0.03153768f, 0.03526310f, -0.00255026f, 0.00532827f, -0.05737892f, 
    -0.11641030f, -0.30639040f, 0.02819150f, -0.05151627f, 0.25767967f, 0.06956642f, 0.05848727f, -0.11908907f, 
    -0.07901714f, 0.02149012f, 0.01942884f, -0.07845762f, 0.24380015f, -0.19780801f, -0.04000783f, 0.07560343f, 
    0.05104559f, 0.00932168f, -0.11111280f, -0.03269501f, -0.06749296f, -0.06547303f, 0.03250520f, -0.00116732f, 
    0.20138344f, 0.06500091f, 0.03148143f, 0.10017919f, 0.08803963f, -0.03239260f, 0.08398895f, 0.11096406f, 
    -0.00419302f, -0.16288656f, 0.04644909f, 0.10327589f, 0.00728730f, -0.12609762f, -0.03063180f, -0.19863635f, 
    0.00808488f, 0.08211728f, -0.02724137f, 0.10335072f, 0.03566223f, -0.01509577f, 0.13884430f, -0.04433557f, 
    0.19783962f, -0.01755068f, -0.03169187f, 0.03318286f, 0.04499518f, 0.02272161f, 0.03736115f, -0.01380316f, 
    -0.03056717f, 0.08625477f, -0.04437360f, -0.12712739f, -0.22875772f, 0.13730821f, -0.17282237f, 0.03306472f, 
    0.08879481f, 0.01335671f, 0.04269455f, -0.05367288f, 0.04514629f, -0.20024203f, 0.13511679f, -0.00694216f, 
    0.00887881f, 0.09560281f, -0.11995827f, -0.20038618f, -0.09657031f, -0.15838712f, 0.04386357f, 0.10042345f, 
    0.01636605f, 0.04205297f, 0.07638731f, 0.07034786f, 0.28312987f, 0.19067805f, 0.21197742f, 0.02156101f, 
    0.07930851f, 0.09990735f, -0.02150234f, -0.02976128f, 0.00519870f, -0.01409952f, -0.12226170f, 0.02637340f, 
    0.11849269f, 0.12370957f, -0.16939442f, 0.14916502f, 0.07050074f, 0.02437788f, 0.04015167f, 0.18736912f, 
    0.08791338f, 0.06124976f, 0.00033317f, -0.03409121f, 0.30152431f, 0.16486324f, 0.19678168f, -0.03616865f, 
    0.08075533f, 0.15962543f, 0.11717844f, 0.07379144f, 0.02604022f, -0.01071079f, 0.08811488f, 0.17695153f, 
    0.17958529f, 0.19347884f, 0.10779451f, -0.02390855f, -0.05439758f, 0.06964749f, 0.05491444f, 0.13986145f, 
    0.08929518f, -0.03849403f, -0.01336461f, -0.00544493f, -0.27166349f, -0.17711879f, -0.04755508f, -0.09915608f, 
    -0.05818685f, -0.00327028f, 0.01550085f, 0.13951902f, -0.08555555f, -0.04991659f, -0.01625784f, -0.01757391f, 
    0.02035207f, -0.15272617f, 0.03467288f, 0.09076215f, 0.09764845f, 0.06136893f, 0.00819583f, 0.13899951f, 
    -0.04191608f, -0.03431452f, -0.04873846f, 0.10362541f, -0.27253157f, 0.03332032f, -0.14922404f, 0.03117258f, 
    -0.05255697f, 0.02723506f, -0.03296683f, -0.03421360f, -0.02014540f, -0.02261504f, 0.01348063f, 0.02624509f, 
    -0.03837800f, 0.04616222f, -0.16085224f, -0.09927980f, 0.02291567f, -0.03788604f, -0.01456836f, -0.08539546f, 
    0.01312961f, 0.04386029f, 0.07610464f, 0.12147184f, 0.08479267f, 0.18879922f, 0.04516684f, -0.13757141f, 
    -0.13907053f, -0.08564354f, 0.02554987f, 0.15066916f, 0.06809688f, 0.02991678f, -0.02447031f, 0.04333990f, 
    -0.02328739f, -0.04520514f, -0.04140968f, -0.04071842f, -0.04542575f, 0.02527363f, -0.07618516f, -0.01760135f, 
    -0.02263559f, -0.01842244f, 0.04088693f, -0.00692366f, 0.05171929f, -0.06176022f, -0.00017052f, 0.01887152f, 
    -0.03202714f, 0.04073253f, -0.07432153f, -0.05716801f, -0.07455304f, 0.01421084f, 0.02362794f, 0.05220323f, 
    -0.03741812f, -0.00277492f, 0.02184055f, 0.00702265f, 0.05198699f, -0.04366139f, -0.07521291f, -0.04787786f, 
    -0.05923646f, 0.02532985f, 0.00535579f, 0.00813551f, 0.05370536f, 0.05814385f, -0.07515647f, 0.00985500f, 
    -0.07624956f, 0.04414033f, -0.04949258f, -0.00641596f, -0.07720887f, 0.02680518f, 0.04268290f, -0.00594120f, 
    -0.03347721f, 0.03076384f, 0.02674976f, -0.00838827f, 0.06236890f, 0.03732035f, 0.06003491f, 0.03936943f, 
    0.06228299f, -0.04277881f, -0.00842505f, -0.06807681f, -0.07673930f, 0.00287975f, -0.04272000f, 0.00448760f, 
    -0.00210090f, -0.04007152f, -0.01588561f, 0.04231505f, 0.00757168f, -0.01149453f, -0.05830176f, -0.05720295f, 
    -0.01960178f, 0.05986862f, 0.04045057f, 0.02795009f, -0.01163545f, 0.01948095f, 0.02636192f, -0.01217939f, 
    -0.00018243f, -0.00057266f, -0.02924724f, -0.06207963f, -0.05901261f, -0.03576875f, -0.02396506f, -0.01205432f, 
    -0.06719240f, 0.05723055f, -0.00935708f, -0.06273599f, -0.03702993f, 0.01847833f, 0.05998427f, -0.02643219f, 
    -0.06791392f, -0.07576305f, -0.01978813f, -0.00579944f, 0.05248097f, -0.07752778f, 0.02044959f, 0.04710009f, 
    0.05643722f, -0.05821568f, 0.02627341f, 0.01084427f, -0.07500180f, 0.02498737f, -0.03066413f, -0.07320285f, 
    0.02135356f, 0.06656449f, 0.05017126f, -0.03818497f, -0.02784940f, -0.02298198f, 0.02727980f, 0.00025920f, 
    0.05385391f, -0.00422355f, 0.05077350f, -0.07384716f, 0.02779874f, -0.01911228f, -0.05314886f, 0.01092895f, 
    -0.02774987f, -0.03907635f, 0.06635009f, -0.00477874f, -0.04235393f, -0.05322675f, -0.04435652f, -0.03319402f, 
    -0.05252970f, -0.02323009f, -0.01178589f, 0.03851606f, -0.06980179f, -0.00848338f, -0.00937664f, 0.04801206f, 
    -0.01217076f, -0.01870859f, 0.05424232f, -0.04316354f, 0.03361020f, -0.04654669f, 0.01063485f, 0.06231691f, 
    0.05968782f, 0.01212803f, -0.05425445f, 0.02392844f, -0.03605802f, -0.04929424f, -0.04446710f, -0.01053156f, 
    -0.03112311f, -0.04566649f, -0.07002276f, -0.01434243f, 0.00958202f, -0.01028138f, 0.01075331f, 0.05996298f, 
    0.03727058f, -0.01010398f, 0.03221948f, -0.07583627f, -0.07335179f, -0.05578464f, -0.07071705f, -0.06002392f, 
    0.02322800f, 0.01561714f, 0.03110120f, -0.04341912f, 0.04648881f, -0.05046216f, 0.03909217f, 0.05734520f, 
    0.01106849f, -0.06210886f, 0.02720353f, 0.03803970f, -0.02940415f, -0.07507289f, -0.03287504f, 0.01593472f, 
    -0.00214246f, 0.05537765f, 0.00971429f, 0.01799306f, 0.00663075f, 0.05668217f, -0.03480378f, 0.00966065f, 
    -0.06778596f, 0.04237892f, 0.04847198f, 0.02479377f, -0.07623523f, 0.00486899f, -0.01200498f, 0.01799062f, 
    0.00311470f, -0.00166915f, -0.01773313f, -0.03624804f, 0.01842905f, -0.07485382f, 0.04226657f, -0.00225611f, 
    -0.05153938f, 0.06809671f, 0.05213090f, -0.04295899f, -0.04499871f, 0.01498718f, -0.05006052f, -0.00684304f, 
    0.06072176f, -0.00180847f, 0.02765787f, -0.05529350f, -0.01637721f, 0.06308278f, -0.06438156f, -0.01277309f, 
    -0.02559443f, 0.03921597f, -0.04662308f, 0.05095404f, -0.07997571f, -0.00131323f, -0.04290392f, 0.00056014f, 
    -0.01782089f, -0.01827456f, 0.00696352f, 0.00830024f, -0.01468416f, 0.02636276f, 0.03408278f, -0.04903978f, 
    -0.02578533f, -0.03764455f, -0.04972281f, -0.03044255f, 0.06560792f, 0.04762545f, 0.05584946f, -0.06370920f, 
    -0.03797916f, -0.02889069f, 0.03036836f, -0.02718815f, 0.00029405f, 0.05984875f, -0.07905732f, 0.03574588f, 
    -0.04361806f, 0.00285668f, -0.06953748f, 0.04443489f, 0.05024944f, -0.07156663f, 0.00489903f, -0.06240001f, 
    0.05964211f, 0.01366456f, 0.03676825f, 0.01901111f, -0.04859548f, -0.03941968f, 0.02953001f, 0.06456001f, 
    -0.01867055f, 0.06073927f, 0.01817306f, -0.06903736f, 0.05382551f, -0.06725697f, -0.01236917f, -0.07232872f, 
    -0.06362841f, 0.00339205f, -0.04391798f, -0.06264234f, 0.05552440f, 0.05940123f, 0.02499739f, 0.04039393f, 
    0.04115317f, 0.04351429f, -0.03903180f, 0.05099267f, -0.04203777f, -0.05292143f, 0.02450425f, -0.06508508f, 
    0.05753906f, 0.01390904f, -0.01833287f, -0.05804231f, 0.00606806f, -0.03806734f, -0.05953196f, -0.00757555f, 
    0.04147841f, -0.06412377f, -0.01459797f, -0.02660486f, 0.00745680f, -0.01612022f, 0.03475970f, 0.04857927f, 
    0.06061543f, -0.04692597f, -0.05122096f, 0.05947441f, 0.02741210f, -0.05691513f, -0.05416020f, -0.07660948f, 
    0.03936693f, 0.04965308f, 0.05030243f, -0.07154368f, -0.07151987f, -0.07039431f, 0.01106980f, 0.02747081f, 
    -0.07629269f, 0.06187901f, -0.01954134f, -0.00307173f, 0.04002571f, -0.07221339f, -0.02670162f, -0.06185562f, 
    -0.07370503f, -0.06548714f, 0.02277813f, 0.01380523f, -0.06224050f, -0.07496205f, 0.00640036f, 0.02879073f, 
    0.02046007f, -0.05456809f, -0.03383451f, -0.05081173f, -0.01196916f, 0.00994516f, 0.05401129f, 0.06548234f, 
    -0.07372411f, -0.04750713f, 0.02263133f, -0.07108711f, 0.01788381f, -0.03720806f, -0.04629304f, -0.06039528f, 
    0.00275073f, -0.00934122f, -0.05193219f, 0.01213351f, -0.04046598f, 0.03212874f, -0.07460958f, 0.03638993f, 
    0.02538195f, -0.04275003f, 0.02905074f, -0.04337967f, -0.05293177f, 0.01414184f, -0.07847098f, 0.03478643f, 
    0.04415412f, 0.00146940f, 0.02026299f, 0.01405866f, -0.06652787f, -0.04890296f, -0.03209058f, 0.01340997f, 
    0.01692823f, 0.01552627f, 0.03589776f, -0.05413352f, -0.06418560f, 0.00778075f, -0.07219513f, -0.03166914f, 
    0.00853471f, 0.01553135f, 0.04693191f, -0.07111303f, 0.02717279f, -0.00941614f, 0.02199701f, -0.01026664f, 
    0.03062703f, -0.02886142f, 0.04070012f, 0.01624424f, 0.02511141f, 0.05713639f, -0.07733358f, -0.04574283f, 
    0.03437964f, -0.05020320f, -0.01433275f, -0.05677868f, -0.00835623f, 0.01718719f, -0.06083830f, -0.03004096f, 
    0.01090081f, -0.04928027f, 0.01115914f, -0.03069824f, -0.03422784f, -0.02436155f, -0.08036831f, -0.01392536f, 
    0.05486915f, 0.04908359f, -0.01190128f, 0.03890248f, -0.06720012f, 0.03827751f, -0.04060542f, -0.04240017f, 
    -0.06670712f, -0.07123294f, -0.01443710f, 0.03267457f, 0.01249717f, 0.01767831f, 0.04106622f, 0.04930191f, 
    0.02520986f, -0.02903697f, -0.04149386f, 0.03799764f, -0.01877324f, -0.01048269f, 0.03611019f, 0.05218747f, 
    -0.00331341f, 0.02910745f, 0.05841648f, 0.00571836f, 0.04632277f, -0.05895419f, -0.01677002f, -0.03089360f, 
    -0.02751681f, 0.00516767f, -0.00525901f, -0.06444075f, 0.03621363f, 0.02394396f, -0.06506296f, 0.00253703f, 
    -0.06243568f, 0.03885584f, 0.01064853f, -0.03422769f, -0.01061087f, 0.04355698f, 0.03984823f, -0.04758862f, 
    -0.05133793f, 0.03243046f, -0.00385313f, -0.04167964f, 0.03803207f, 0.02883524f, -0.00784311f, -0.06630670f, 
    -0.06086218f, 0.03737900f, -0.00129572f, 0.01388845f, 0.01428462f, -0.05663920f, 0.05479687f, -0.03738508f, 
    0.01792515f, -0.05439432f, -0.00625732f, -0.02912742f, -0.02299081f, -0.03184884f, -0.05792832f, -0.03376066f, 
    0.03502728f, -0.05943051f, 0.00308556f, -0.03843161f, -0.07779839f, 0.04170703f, -0.00843984f, 0.04314506f, 
    -0.05610637f, -0.04997714f, 0.05002373f, 0.01929883f, -0.02656339f, -0.01012414f, -0.07569519f, -0.04572227f, 
    -0.07286227f, -0.02135044f, -0.02484944f, 0.01435316f, -0.02064965f, -0.03634597f, 0.00484139f, 0.02240972f, 
    0.00874800f, 0.04175798f, 0.01456134f, 0.03007729f, -0.07221181f, -0.01663885f, -0.03106938f, 0.03236175f, 
    -0.01442215f, -0.02975802f, 0.04245983f, -0.01684900f, 0.05523342f, 0.02172094f, 0.02760790f, 0.00764769f, 
    -0.03910210f, -0.04051718f, 0.00391610f, -0.05527182f, -0.04998678f, 0.02309508f, -0.05209111f, -0.01757858f, 
    -0.02344674f, -0.02466903f, -0.05932068f, 0.03850225f, 0.02720792f, 0.02195213f, -0.05831672f, -0.03284983f, 
    0.02551893f, -0.01670722f, 0.00054532f, -0.04691035f, 0.02262203f, -0.06736398f, 0.05252076f, -0.06968589f, 
    -0.01994490f, -0.01195040f, -0.03797014f, 0.05693393f, 0.02208418f, 0.03941733f, -0.02623101f, 0.01100275f, 
    -0.03680652f, -0.02768036f, 0.01817392f, 0.01905450f, -0.06652009f, -0.00162186f, -0.06529520f, 0.01400084f, 
    -0.02808389f, 0.03142575f, -0.01130924f, -0.04995400f, -0.05191179f, -0.05272068f, -0.05726320f, 0.04781348f, 
    -0.06150011f, -0.01441681f, 0.06316493f, -0.00677339f, 0.04271382f, 0.00842014f, 0.01741818f, 0.02071632f, 
    0.04572353f, 0.06132386f, -0.00441819f, 0.03510389f, -0.06567755f, -0.02827150f, -0.03401640f, 0.06105356f, 
    -0.00782817f, 0.02636595f, 0.01542805f, 0.04841640f, 0.06499247f, -0.00692264f, 0.01280919f, -0.05770081f, 
    -0.05114300f, -0.07012367f, -0.01544436f, -0.02537934f, 0.00868327f, 0.06046617f, -0.07056133f, -0.02508180f, 
    -0.04019494f, 0.01980648f, 0.00860877f, -0.05322979f, 0.02203335f, 0.02875448f, 0.00511581f, -0.04866387f, 
    0.03002848f, -0.00211326f, -0.04085756f, -0.06918160f, 0.03443915f, 0.03601911f, 0.00919960f, 0.05767928f, 
    -0.06962871f, 0.04091331f, 0.04859277f, 0.03533342f, -0.06960498f, -0.04853442f, -0.02710762f, -0.00053658f, 
    -0.04931684f, -0.07937362f, 0.02764385f, -0.03475143f, -0.06717543f, -0.02487331f, -0.01448317f, -0.07206390f, 
    0.04056017f, 0.04506329f, -0.07733975f, 0.01537898f, -0.07277955f, -0.00167364f, -0.00439981f, 0.04239316f, 
    -0.05237519f, 0.03279476f, -0.02350633f, 0.01671872f, 0.04861628f, -0.02088985f, 0.00094188f, -0.07084721f, 
    0.04612467f, 0.03215912f, -0.04826260f, 0.00832591f, -0.04057278f, -0.02741196f, -0.06560573f, -0.06802132f, 
    -0.02452339f, 0.03596424f, -0.04463873f, 0.03026580f, 0.05717081f, 0.03252921f, -0.06237132f, 0.01784852f, 
    -0.05988558f, -0.06297219f, 0.01013395f, -0.05580115f, 0.04503675f, -0.02505785f, 0.06769619f, -0.03205412f, 
    -0.01840722f, -0.00383598f, 0.02328028f, -0.07831758f, -0.04747156f, 0.02112570f, 0.00312070f, 0.06103729f, 
    -0.00412376f, 0.00256047f, 0.04522265f, -0.00726029f, -0.02821882f, -0.07361794f, 0.04824100f, 0.01052475f, 
    -0.03616880f, 0.03699211f, 0.00858187f, -0.02052446f, -0.07459409f, -0.07731614f, -0.06128730f, -0.05091499f, 
    -0.03427114f, 0.03405794f, 0.00828638f, 0.01862313f, -0.03141792f, -0.03537478f, 0.01802227f, 0.04501992f, 
    -0.06804182f, -0.05963342f, -0.05483494f, -0.05247993f, -0.00361285f, 0.04305851f, -0.04820572f, -0.03821738f, 
    0.02378528f, 0.00501667f, 0.05152527f, -0.02281060f, 0.04271441f, -0.00717374f, -0.00173208f, 0.02941219f, 
    0.01904666f, 0.03589833f, -0.06224094f, -0.04872114f, 0.02110712f, 0.03341752f, 0.00152371f, -0.01349751f, 
    0.02459904f, -0.01882593f, 0.05571095f, -0.05907911f, 0.05981327f, 0.02834199f, 0.03220602f, 0.01196083f, 
    0.03263770f, -0.07012197f, -0.00271293f, -0.05861816f, -0.03842089f, -0.02503334f, 0.03373886f, -0.06878651f, 
    0.20639046f, -0.14351980f, 0.00811819f, 0.01173430f, 0.01109366f, -0.04707158f, 0.08630806f, 0.05815220f, 
    -0.06037366f, 0.08588406f, -0.04225191f, 0.12815541f, -0.00525446f, -0.23021761f, 0.20801289f, -0.00477514f, 
    0.05403414f, -0.10551789f, 0.00966663f, -0.06839119f, -0.00519735f, 0.06034603f, 0.09154486f, 0.00403876f, 
    -0.18535998f, 0.10687996f, -0.12312277f, 0.15440519f, 0.10734095f, -0.05978590f, -0.05148841f, 0.02001240f, 
    -0.06953067f, 0.08820865f, 0.09841008f, -0.08851776f, 0.10921828f, 0.15862954f, -0.05778510f, -0.10726858f, 
    0.05030409f, 0.14203778f, -0.09250643f, 0.15492551f, -0.03977456f, 0.07692804f, 0.03320470f, -0.03438833f, 
    -0.23742911f, -0.06992447f, -0.01289166f, 0.03275782f, 0.03632375f, 0.04470931f, 0.01445724f, 0.05313212f, 
    -0.06473571f, 0.16710065f, -0.01509885f, 0.08351714f, 0.09494067f, 0.22201996f, -0.05661245f, 0.09041863f, 
    -0.00515258f, 0.06770749f, -0.07975820f, 0.07320046f, 0.01858769f, 0.02405225f, 0.22064333f, 0.00605844f, 
    0.02610666f, -0.10134035f, 0.03974188f, -0.30811727f, -0.04895878f, 0.06542040f, 0.01015356f, -0.08627554f, 
    0.00972578f, -0.07258827f, 0.04018548f, -0.04705606f, 0.12267695f, -0.10194544f, -0.01853395f, 0.16223435f, 
    0.12755308f, -0.06464474f, 0.11682308f, -0.01598641f, 0.08111786f, 0.11304087f, 0.13422289f, 0.09114766f, 
    0.38962874f, -0.08496518f, -0.14795020f, 0.05760759f, -0.01920521f, 0.01806564f, -0.04430733f, 0.09257818f, 
    -0.09873159f, -0.06295323f, 0.02571886f, 0.05383466f, -0.01558853f, 0.04455759f, 0.20050207f, -0.06356358f, 
    0.13340071f, 0.05677303f, 0.13592903f, 0.06526604f, 0.06205467f, 0.01939680f, 0.05740748f, 0.13060357f, 
    0.27517673f, -0.19368519f, -0.15001512f, 0.12345459f, 0.09509151f, -0.08303395f, -0.02924504f, -0.01784989f, 
    0.03073714f, 0.00047840f, 0.04586267f, 0.09488428f, -0.07086194f, 0.15796237f, -0.06524923f, -0.06836220f, 
    -0.06603941f, 0.04289074f, 0.18172410f, -0.07467990f, 0.07377008f, 0.05617201f, 0.09224767f, -0.01013941f, 
    -0.03745057f, -0.19918789f, -0.05124061f, -0.18163337f, 0.02862035f, -0.00286519f, 0.02758615f, 0.12587599f, 
    -0.02946221f, 0.18356816f, -0.08625095f, -0.02845387f, -0.10886297f, 0.02141940f, -0.03810927f, 0.06861059f, 
    -0.10363578f, -0.04552123f, 0.00878383f, -0.07428393f, 0.01573326f, 0.02157708f, 0.00668515f, 0.00893054f, 
    0.22129132f, -0.02156840f, -0.05897002f, -0.09567682f, -0.02343278f, 0.02144477f, -0.03448499f, -0.01811317f, 
    0.18452662f, -0.06792821f, -0.12653823f, -0.03672630f, 0.12681848f, -0.27609396f, 0.17624171f, 0.14144576f, 
    -0.11027323f, 0.05872190f, -0.04580051f, 0.00647052f, 0.05323121f, -0.06034409f, 0.04335842f, -0.03418998f, 
    -0.16018084f, -0.02627571f, -0.19161320f, -0.01022065f, 0.07634058f, 0.10100699f, 0.08606981f, 0.05802806f, 
    0.00796507f, -0.02961850f, -0.16527113f, -0.07014249f, -0.07916681f, -0.12125798f, -0.10117363f, -0.02908346f, 
    0.07506734f, -0.11867793f, 0.08544556f, 0.10360947f, 0.12598364f, -0.03556622f, -0.00207361f, 0.00642556f, 
    0.41521671f, -0.11458132f, 0.23492813f, -0.14616115f, 0.19256672f, 0.09038761f, -0.14736316f, 0.07207123f, 
    0.04624953f, 0.02966280f, -0.01353057f, -0.01919569f, -0.25945652f, -0.21737397f, -0.03072600f, -0.02604481f, 
    0.02364048f, 0.07290918f, 0.04743714f, -0.01162742f, -0.16640763f, 0.08013708f, 0.07343011f, -0.03077791f, 
    0.01447993f, 0.08497179f, 0.10316507f, -0.14020678f, 0.11781485f, 0.01616576f, -0.08012106f, 0.01049044f, 
    -0.06288698f, 0.14323516f, 0.03314172f, 0.07828160f, -0.19192107f, 0.17120169f, -0.23466375f, -0.08613972f, 
    0.13658448f, 0.03532846f, -0.01807261f, 0.06924072f, 0.11777345f, -0.14672542f, 0.01736806f, -0.12293734f, 
    -0.12374790f, 0.13984659f, -0.14824945f, -0.22783329f, 0.07041476f, -0.12844832f, 0.06858788f, 0.07738246f, 
    0.04872263f, 0.08867329f, 0.05127259f, 0.09085378f, 0.23915233f, 0.16220155f, 0.23264515f, 0.03423638f, 
    0.09644785f, 0.01619442f, -0.00055564f, -0.04646001f, 0.07325371f, 0.07239339f, 0.02452119f, -0.03114673f, 
    0.06043724f, 0.04271974f, 0.12843290f, 0.08401759f, 0.09168517f, 0.05449259f, 0.04526019f, 0.00302222f, 
    0.12765332f, 0.09504604f, -0.02549580f, 0.02500897f, -0.06179566f, 0.13673823f, 0.14912850f, 0.22678936f, 
    -0.16568120f, 0.06017140f, -0.03555158f, -0.06162583f, 0.02497444f, 0.02155049f, -0.00140797f, 0.09868887f, 
    -0.09322911f, 0.27836841f, 0.27663684f, -0.12170152f, 0.18492711f, 0.03681890f, -0.02349928f, 0.05517609f, 
    0.10694142f, 0.02186112f, 0.01011170f, -0.02643731f, 0.10699619f, -0.12638460f, -0.14851895f, 0.06512848f, 
    -0.12921315f, 0.04479653f, -0.03437202f, 0.02983974f, -0.03533448f, -0.02825173f, -0.08590779f, -0.00336394f, 
    -0.13910396f, 0.15015304f, -0.03009248f, 0.19817981f, 0.13117321f, -0.14795071f, -0.15539442f, 0.00538480f, 
    0.03154764f, -0.12342289f, 0.01786745f, 0.04661379f, -0.31798288f, -0.19813679f, -0.18574187f, 0.03190035f, 
    -0.06896693f, 0.16772655f, 0.04482600f, 0.00896332f, -0.09180948f, 0.11828277f, 0.06243980f, 0.01576152f, 
    -0.16609631f, -0.07561743f, -0.04091733f, -0.12900166f, 0.11937772f, 0.11954221f, -0.01902239f, -0.07120795f, 
    -0.13300972f, -0.09669023f, 0.14900883f, 0.13831599f, -0.03139287f, 0.13168761f, 0.18427974f, -0.30306363f, 
    0.05509812f, 0.03884958f, 0.18878959f, -0.04321827f, 0.05266207f, -0.04501185f, -0.01084394f, -0.00932961f, 
    0.12957044f, -0.08337484f, -0.11352007f, -0.29152462f, 0.07185575f, -0.02393022f, 0.10780757f, 0.00473375f, 
    0.04460436f, 0.06119008f, -0.05913331f, 0.03379067f, 0.58215249f, -0.12544340f, 0.18494248f, -0.04491212f, 
    0.00591490f, -0.08595557f, -0.01112795f, -0.05639146f, 0.05528221f, 0.01588638f, 0.14049807f, -0.01897375f, 
    -0.12682243f, 0.18919937f, -0.20569977f, 0.30404574f, 0.01574335f, -0.23975299f, -0.12506501f, -0.02335271f, 
    -0.02499522f, -0.14099212f, -0.03543670f, -0.03552882f, 0.28976461f, 0.09903718f, -0.01796571f, -0.18862012f, 
    0.12686329f, 0.09529153f, -0.16206236f, 0.19361341f, 0.06696021f, 0.05951432f, -0.02229182f, -0.03075536f, 
    -0.05633671f, -0.00949602f, -0.05254094f, 0.13829428f, 0.01122295f, -0.18543983f, 0.00001115f, -0.09903851f, 
    0.08806640f, -0.00527770f, -0.01917706f, 0.14027494f, 0.04820184f, 0.21731547f, -0.21158749f, -0.02960940f, 
    0.09249564f, -0.06625094f, 0.00932364f, -0.00182341f, -0.06087464f, 0.21346785f, 0.08363027f, 0.05549839f, 
    0.11414333f, -0.12596379f, 0.06661963f, -0.00184495f, -0.04322746f, 0.10820594f, 0.07370046f, -0.04205500f, 
    0.03048760f, -0.09501597f, 0.05964546f, 0.12122090f, 0.06650300f, 0.17570485f, -0.11739378f, -0.03155332f, 
    0.03964813f, 0.02439660f, -0.04638373f, -0.11821763f, -0.04547104f, 0.14567225f, 0.10589732f, -0.02284086f, 
    -0.01996567f, 0.11006146f, -0.14002709f, 0.22337291f, 0.06152249f, -0.09036829f, -0.03571954f, 0.01302799f, 
    0.00067066f, 0.02735470f, 0.07623135f, -0.07296903f, 0.03578340f, 0.20336089f, 0.22685440f, -0.01742462f, 
    0.14436053f, 0.05923868f, 0.05987041f, 0.03430983f, -0.03381934f, -0.06840984f, -0.00775312f, 0.02542138f, 
    0.13543394f, -0.33708414f, -0.02206935f, 0.04982248f, -0.09511842f, -0.16276713f, -0.02785007f, -0.02156666f, 
    0.01876252f, 0.11234002f, 0.17002109f, 0.07053331f, -0.26513281f, 0.15607727f, 0.03820122f, -0.01868076f, 
    -0.07408273f, -0.06936542f, 0.00666199f, -0.07280345f, 0.01917229f, 0.14028466f, 0.20739624f, 0.01150259f, 
    -0.17035931f, 0.02954948f, 0.33986142f, -0.03955128f, 0.10344631f, 0.10894672f, -0.06338294f, 0.02969777f, 
    -0.00840472f, -0.07435440f, 0.01965242f, 0.18404451f, -0.31397149f, -0.07573655f, 0.13316345f, 0.30824432f, 
    0.04457506f, -0.07960105f, -0.00503529f, -0.06031339f, 0.29374814f, 0.04841484f, 0.06813879f, -0.02074260f, 
    -0.01071886f, 0.03858707f, -0.13291372f, -0.01681070f, 0.06835300f, 0.06959660f, -0.03430270f, 0.15120044f, 
    0.16186725f, -0.06170090f, -0.12308169f, -0.10630707f, -0.04542783f, -0.09356438f, -0.00307130f, 0.15552539f, 
    -0.10656557f, 0.03970582f, -0.18230283f, -0.08347279f, -0.06644828f, -0.09591623f, 0.11849248f, -0.12077104f, 
    0.04889690f, 0.04799028f, -0.04389686f, 0.03337684f, -0.07144435f, 0.00830600f, -0.07093057f, -0.01602864f, 
    0.05457833f, 0.01605994f, 0.03221940f, 0.02996000f, 0.05277886f, -0.00266950f, 0.06454322f, -0.02522127f, 
    0.00876176f, -0.07601733f, -0.06155491f, -0.04909940f, 0.04609529f, 0.04438843f, 0.03586397f, -0.03767320f, 
    0.04162418f, -0.04200175f, 0.00939266f, -0.05496255f, 0.05784034f, -0.01754909f, 0.00657198f, 0.06481100f, 
    -0.01075648f, -0.06649647f, 0.01062644f, -0.03102509f, -0.05174097f, -0.07143742f, 0.03371710f, -0.07092831f, 
    0.01471637f, -0.02694455f, -0.05265018f, 0.03892056f, -0.07227840f, -0.02012772f, -0.05957681f, 0.04305765f, 
    -0.05203088f, -0.04970172f, -0.01091468f, 0.03231265f, -0.06112898f, 0.02239810f, -0.02904379f, -0.06748408f, 
    -0.06645068f, 0.02604252f, -0.06683219f, -0.07758776f, -0.02108710f, 0.05433495f, 0.01971662f, -0.05681560f, 
    0.00585638f, 0.03727224f, -0.00007429f, 0.01009530f, -0.01305535f, 0.03297149f, 0.00823125f, -0.06263039f, 
    -0.07737407f, -0.00404290f, -0.02134277f, 0.02141764f, -0.06955089f, -0.05341448f, 0.02344848f, -0.02176547f, 
    0.01352610f, -0.00828069f, -0.01318641f, 0.04607204f, -0.03122016f, 0.03927490f, -0.02547443f, 0.05555989f, 
    0.05651780f, -0.05909325f, 0.02218337f, -0.02665403f, 0.00131327f, -0.01298256f, 0.02762723f, -0.04317247f, 
    0.01206064f, 0.04997761f, -0.03538763f, -0.01895255f, -0.07389554f, -0.04750040f, -0.03516441f, -0.05577729f, 
    0.00339194f, -0.03562754f, -0.03213470f, 0.03999315f, 0.05290782f, -0.07584789f, -0.02506244f, 0.05283708f, 
    -0.06507865f, 0.06015996f, -0.02371267f, -0.06429890f, 0.02126657f, 0.03015589f, 0.00587174f, -0.07632520f, 
    0.06616157f, -0.03655987f, 0.01172497f, -0.00129461f, -0.02212613f, -0.05374220f, -0.05118201f, 0.02851767f, 
    -0.06716673f, -0.03259007f, -0.04012561f, 0.01125536f, 0.04983392f, -0.01960293f, 0.03323976f, 0.00264442f, 
    -0.03888767f, 0.00187119f, -0.03244141f, 0.02086398f, 0.04719333f, -0.03861947f, -0.01148182f, 0.04960066f, 
    0.04102923f, 0.01847964f, 0.01114236f, 0.06505057f, -0.01021180f, 0.04020017f, -0.03422572f, -0.00605850f, 
    -0.03295469f, 0.00581455f, -0.05032940f, 0.03358590f, 0.03019823f, 0.00917779f, 0.06118502f, 0.01819773f, 
    0.00161516f, -0.07324859f, -0.00735380f, -0.07347291f, -0.06659581f, 0.02854284f, -0.00988749f, -0.01072306f, 
    -0.05073776f, -0.05339094f, -0.06181257f, -0.01232618f, 0.00577812f, -0.01975809f, 0.03063536f, 0.03315295f, 
    -0.00555370f, 0.06479035f, -0.04934741f, 0.03854712f, -0.01776305f, -0.06409617f, -0.01149110f, -0.04758611f, 
    0.05809846f, -0.07002003f, 0.04010809f, -0.00531566f, 0.03900077f, -0.02325015f, -0.03813094f, -0.06052965f, 
    0.11281132f, 0.07700082f, -0.21300025f, -0.13877083f, 0.10562119f, -0.12171550f, -0.01124428f, -0.07129353f, 
    0.00542809f, -0.01569002f, -0.14248581f, 0.12693010f, 0.44658121f, 0.02377882f, 0.02846680f, 0.02900077f, 
    -0.06401799f, 0.05150064f, 0.04167786f, 0.10867121f, 0.08440861f, 0.04176220f, -0.05549214f, -0.01290346f, 
    0.07168110f, -0.04728159f, 0.09816314f, 0.03404236f, 0.09123063f, -0.14183758f, -0.01303718f, 0.05174645f, 
    -0.10094326f, 0.02368277f, 0.07855864f, -0.12348313f, -0.17488974f, -0.07410004f, 0.00753174f, -0.14223067f, 
    0.14347303f, 0.04596058f, -0.00892573f, 0.05339813f, 0.02068344f, 0.05477437f, 0.04624072f, 0.02484605f, 
    -0.03787132f, -0.13403988f, 0.09144608f, 0.04234777f, 0.03932112f, 0.01469105f, -0.01162632f, -0.10763557f, 
    -0.12233978f, 0.05836652f, -0.03435372f, 0.18814187f, -0.11173690f, -0.02337038f, 0.06233486f, -0.28373954f, 
    0.04419817f, -0.05126838f, 0.02118854f, -0.14768764f, -0.00876617f, 0.07876805f, 0.09330222f, 0.02597382f, 
    0.02328768f, 0.14476283f, -0.02186871f, 0.13250475f, -0.07337488f, 0.02251656f, 0.11544894f, -0.07000867f, 
    -0.05136900f, -0.03269968f, 0.01347172f, 0.04095955f, 0.15299819f, 0.05444587f, -0.12454330f, 0.18682551f, 
    -0.01356673f, -0.07582695f, -0.00311329f, 0.09401608f, -0.05290109f, -0.03228850f, 0.13626073f, 0.00860358f, 
    -0.13565603f, 0.23742369f, 0.17914858f, 0.01038126f, -0.02683833f, -0.01660502f, 0.09118586f, -0.15250362f, 
    -0.08599219f, 0.02710270f, 0.11426724f, 0.01460984f, 0.01515978f, 0.11193521f, -0.06008418f, 0.11617520f, 
    0.01295266f, 0.01994962f, -0.07543257f, -0.02029398f, 0.01758674f, -0.05909487f, 0.06073589f, 0.00689522f, 
    -0.07241482f, 0.00480648f, -0.03069485f, -0.04925561f, 0.03668571f, 0.05589702f, -0.08643203f, -0.03773998f, 
    -0.11611999f, 0.06974394f, 0.02541268f, 0.08335403f, 0.28513774f, 0.04411475f, 0.02560773f, 0.07239807f, 
    -0.05118741f, -0.03779675f, -0.03229960f, -0.02700288f, 0.06148977f, 0.08253882f, 0.11627700f, 0.09285279f, 
    0.10217115f, 0.05590188f, 0.00339882f, 0.18854734f, -0.02554341f, -0.01531231f, 0.00327511f, -0.00038065f, 
    0.10854443f, -0.06776012f, -0.01946598f, -0.01140394f, -0.22636043f, 0.03655900f, 0.16372383f, 0.32558915f, 
    0.04622985f, -0.03916818f, 0.08761811f, -0.00754150f, 0.00183650f, 0.07988352f, -0.00587204f, -0.07561731f, 
    0.06462642f, -0.03700583f, 0.00168947f, -0.11167481f, 0.10129311f, 0.04731047f, 0.00397994f, 0.04349115f, 
    0.08638196f, 0.09160747f, -0.06925993f, -0.08595099f, -0.06470358f, -0.08778868f, 0.05033392f, 0.20320775f, 
    -0.04374486f, 0.13436221f, 0.07630799f, -0.22374927f, -0.05521525f, -0.14687335f, -0.01108899f, 0.04364308f, 
    -0.02026932f, 0.04355735f, 0.03855419f, -0.00011347f, -0.05423850f, 0.02133494f, -0.07216606f, -0.02888418f, 
    0.01215589f, -0.00068710f, 0.00858390f, -0.01339550f, 0.04212759f, 0.03218139f, 0.00067589f, 0.01623585f, 
    -0.07978972f, 0.05527965f, -0.03711149f, -0.03135650f, 0.05201969f, 0.04387829f, -0.00347772f, -0.05813691f, 
    -0.04335909f, 0.00828924f, -0.06748527f, -0.03913286f, 0.01051479f, 0.01226466f, -0.07863490f, -0.06002678f, 
    -0.02954501f, -0.01530189f, -0.07698914f, 0.04621036f, -0.04347553f, 0.06240623f, 0.05729534f, -0.00574965f, 
    -0.00614377f, -0.04540174f, -0.05152589f, -0.00259074f, 0.01255562f, 0.01469450f, -0.01780823f, -0.03421983f, 
    -0.02138121f, 0.03789785f, -0.03761742f, 0.04043594f, -0.05201761f, -0.04581800f, -0.06156449f, 0.03299246f, 
    -0.02811627f, 0.05551958f, -0.01549135f, -0.01987863f, -0.06185886f, -0.04662394f, 0.06220933f, 0.03870834f, 
    0.00204563f, -0.06519375f, -0.00058658f, 0.01819561f, 0.04226042f, 0.01565843f, -0.02928285f, -0.02736300f, 
    -0.02159819f, -0.04704013f, -0.03250438f, -0.07077987f, 0.02767119f, 0.05586052f, -0.04679441f, -0.06933549f, 
    0.02745013f, -0.04991580f, -0.05265999f, -0.02936967f, 0.00801021f, 0.03384626f, 0.02602138f, -0.00556641f, 
    0.01685761f, -0.07392497f, 0.03094572f, 0.00321248f, -0.04043968f, 0.05917215f, -0.02280545f, 0.00956182f, 
    -0.00593922f, -0.03519830f, -0.04647757f, 0.06364363f, 0.00405617f, 0.00376837f, -0.00223471f, -0.03609008f, 
    0.05700845f, -0.05050097f, -0.06741652f, -0.04338267f, -0.03936540f, 0.03092138f, 0.05615084f, 0.05617004f, 
    -0.01581415f, 0.05790825f, 0.04383349f, 0.00375975f, -0.06950388f, -0.05393395f, -0.05875630f, -0.07922184f, 
    -0.02860353f, -0.06126170f, -0.04899878f, -0.00986584f, -0.04851111f, 0.04534427f, 0.05838663f, -0.06903906f, 
    0.00002090f, 0.01091933f, -0.02258922f, -0.03327005f, 0.04822985f, -0.07303075f, -0.00889900f, -0.03245174f, 
    -0.07042985f, -0.01043099f, -0.07441344f, -0.07484343f, -0.01112108f, 0.01827416f, 0.01492323f, 0.03054118f, 
    0.02085942f, -0.03419583f, -0.06713184f, -0.00666477f, -0.05785372f, -0.00160800f, 0.02943337f, 0.04714265f, 
    0.05376105f, -0.02256795f, -0.05189915f, -0.02512140f, -0.07191883f, -0.06435420f, -0.04672926f, 0.05532198f, 
    -0.04049938f, 0.03405448f, 0.03235720f, 0.00477269f, 0.05395190f, -0.03982271f, 0.01931171f, -0.06628414f, 
    0.00458343f, 0.05865274f, 0.00757380f, 0.01797319f, 0.04901939f, 0.05059495f, -0.06671755f, -0.05780360f, 
    0.02434313f, -0.06465492f, -0.05571434f, -0.06934347f, 0.03634800f, -0.00344279f, -0.01150414f, 0.06402276f, 
    0.02926548f, -0.06505939f, -0.01095101f, 0.01882595f, 0.05529931f, 0.01052714f, 0.03093665f, -0.01535650f, 
    -0.05810167f, 0.02642897f, 0.04061035f, -0.01393083f, 0.05482801f, 0.05296303f, 0.00849061f, 0.01651795f, 
    -0.02926557f, -0.04961675f, -0.05611636f, -0.04084103f, -0.00862842f, 0.05723087f, -0.04923359f, -0.03405307f, 
    -0.04812576f, 0.05268377f, -0.06403166f, -0.02039416f, 0.01200457f, -0.01841936f, -0.01729923f, -0.00278839f, 
    0.01317989f, 0.04772066f, -0.01582683f, -0.02730382f, -0.03459362f, 0.04031492f, -0.07960109f, 0.03901557f, 
    -0.03265305f, -0.05047807f, 0.04872441f, 0.00461456f, 0.03991277f, 0.01851588f, 0.01358930f, -0.00804786f, 
    -0.03053381f, -0.00062564f, -0.05366956f, 0.06084258f, -0.07577958f, -0.02518755f, 0.03645391f, 0.04681738f, 
    -0.02113567f, 0.03804011f, -0.04883082f, 0.06941652f, -0.01102329f, 0.05780991f, -0.05803190f, 0.02575593f, 
    -0.05639904f, -0.04162559f, -0.01206005f, 0.02512451f, -0.06034200f, 0.03760188f, -0.03400034f, -0.01910607f, 
    -0.03590533f, 0.00598883f, -0.04420191f, -0.07757214f, -0.01297343f, 0.01335615f, 0.04032209f, -0.07487708f, 
    0.05321238f, 0.04345805f, -0.05723357f, -0.05157586f, 0.00061041f, -0.06582993f, 0.01646243f, -0.07114518f, 
    -0.07322328f, -0.00902732f, -0.04559061f, -0.06085644f, 0.00351151f, -0.04633072f, -0.03745683f, -0.03750645f, 
    -0.06630961f, -0.03854969f, -0.04979572f, 0.04762210f, -0.06058684f, -0.01701956f, 0.01158313f, 0.04659743f, 
    -0.01219856f, 0.00085099f, 0.01219915f, 0.02556904f, -0.03863361f, 0.02670878f, 0.01722702f, -0.03946858f, 
    -0.06071794f, 0.04078071f, -0.02359208f, -0.01244543f, -0.07537109f, 0.05550507f, -0.07101386f, 0.04683631f, 
    0.01077966f, -0.05013430f, -0.06866570f, 0.01413981f, -0.03981637f, -0.04248974f, 0.02880844f, 0.02984121f, 
    0.05506184f, -0.04684738f, -0.02664591f, -0.06870619f, -0.06406512f, -0.02058749f, 0.02187017f, -0.04147407f, 
    0.01427308f, 0.01162048f, 0.04786649f, 0.03974266f, 0.01479703f, -0.01637103f, 0.05598566f, -0.04322683f, 
    -0.00078185f, 0.02464805f, 0.05296401f, 0.02797186f, 0.00421458f, -0.04137788f, -0.02538069f, -0.05172424f, 
    0.01595135f, -0.04567664f, -0.08328753f, -0.00476496f, 0.02855108f, 0.01232557f, -0.02986287f, 0.02385511f, 
    0.02373591f, -0.07677470f, 0.02809145f, 0.06161800f, -0.01082824f, -0.00761186f, -0.02758566f, 0.00689396f, 
    -0.02776241f, 0.06560101f, 0.06107378f, -0.07076925f, -0.06984234f, -0.03716290f, -0.01039016f, 0.02775341f, 
    0.06777003f, -0.05786088f, -0.06174781f, -0.03681799f, -0.03909228f, -0.01242200f, 0.02215600f, -0.05111310f, 
    -0.02624580f, 0.06270262f, -0.03651147f, -0.03778523f, 0.05756534f, 0.05006750f, -0.01413571f, 0.03741864f, 
    -0.04229467f, 0.06555713f, 0.01846436f, 0.02385996f, 0.05082418f, -0.04343477f, 0.05545770f, 0.04811471f, 
    -0.04252466f, -0.04176613f, -0.04984739f, -0.02114311f, -0.01586850f, -0.03833179f, -0.00832806f, -0.04636893f, 
    -0.06017505f, -0.01419968f, 0.01698247f, -0.01797027f, -0.03283156f, 0.06290753f, -0.01106977f, 0.06062968f, 
    0.02095631f, 0.03892680f, -0.05949135f, -0.05435841f, 0.00199313f, -0.04835859f, 0.02330130f, -0.04915373f, 
    -0.02860159f, 0.03381993f, -0.06675235f, -0.06978858f, 0.01052249f, 0.04887035f, -0.06686652f, -0.03332277f, 
    0.00859549f, 0.01913221f, -0.03905964f, 0.04902123f, -0.00193696f, 0.05887909f, 0.02083955f, -0.07318336f, 
    -0.04144846f, 0.05785020f, -0.07253408f, -0.00309164f, -0.05937921f, 0.04995488f, -0.03059107f, -0.05727497f, 
    -0.05955612f, 0.02427941f, 0.01887529f, 0.01705222f, 0.03336053f, 0.05402559f, 0.02625117f, -0.00351093f, 
    0.01401955f, 0.02065788f, 0.03895554f, -0.06312129f, -0.02840767f, 0.01304918f, 0.06086634f, -0.00587079f, 
    0.04500648f, 0.04923256f, -0.04174875f, 0.00888691f, 0.02625746f, -0.05945919f, 0.03873506f, 0.00704953f, 
    -0.04298402f, -0.01069889f, 0.03721113f, -0.02780724f, -0.02736752f, 0.01395012f, -0.02146928f, -0.04688032f, 
    0.04964646f, 0.04888743f, 0.00078049f, 0.00270236f, -0.06718744f, -0.04566490f, 0.04578679f, 0.02404809f, 
    -0.06855085f, -0.06823262f, 0.00830343f, 0.01612292f, 0.02803944f, 0.04868177f, -0.01299540f, -0.01849246f, 
    0.05765505f, -0.04138659f, 0.05785568f, 0.05327252f, -0.02004005f, -0.06756265f, -0.00543109f, -0.01106860f, 
    -0.07659521f, 0.03835383f, -0.04633774f, -0.03230224f, 0.04303445f, -0.05663385f, -0.06233837f, -0.06698459f, 
    -0.04054271f, -0.02786100f, -0.04344476f, -0.06028619f, 0.02830125f, -0.01433150f, 0.03353065f, -0.00782383f, 
    -0.03345660f, 0.05260407f, -0.05444384f, -0.02287531f, -0.04719364f, 0.00128408f, 0.02219993f, 0.06510030f, 
    -0.03931532f, -0.03042343f, 0.01404463f, -0.01533450f, 0.01616484f, -0.05780173f, 0.02571240f, 0.00372623f, 
    0.02853967f, -0.01531767f, -0.06650057f, 0.00923549f, -0.03379778f, 0.01202536f, -0.05438116f, 0.00456244f, 
    -0.05932927f, -0.02953705f, -0.01294176f, 0.06371557f, -0.03294916f, -0.03096635f, -0.02429445f, -0.07137102f, 
    -0.04961766f, -0.00923699f, 0.04720388f, 0.04052220f, 0.02982464f, -0.06151414f, -0.04796431f, -0.07105588f, 
    -0.02197189f, 0.02636431f, -0.02832747f, -0.05172512f, 0.05767601f, 0.01438487f, 0.00344251f, -0.05076381f, 
    0.01753530f, -0.04721870f, 0.06398637f, -0.03801190f, -0.05257301f, -0.01837995f, 0.05270372f, -0.05917679f, 
    -0.01370208f, -0.02465635f, -0.02910213f, 0.05739487f, 0.02522231f, -0.01552800f, -0.05118836f, -0.04789120f, 
    -0.05017389f, -0.04571038f, -0.01790258f, 0.02147905f, -0.02902568f, 0.01826300f, -0.03603470f, -0.07004981f, 
    -0.04167158f, 0.01420541f, 0.03699031f, -0.00243274f, -0.06747957f, -0.02401395f, -0.03671653f, -0.03654313f, 
    -0.05183873f, -0.03818350f, 0.00215701f, -0.03079668f, 0.00684993f, -0.02874102f, 0.04083880f, -0.02373135f, 
    -0.02720481f, -0.04510619f, -0.07803199f, -0.04806310f, 0.06068591f, -0.05778719f, 0.02508006f, -0.04753151f, 
    -0.02751086f, 0.04109285f, 0.01968231f, 0.04239928f, -0.03339420f, 0.02176828f, -0.05696734f, 0.03456537f, 
    0.04540839f, 0.04843586f, -0.05796961f, 0.00836665f, -0.00103024f, -0.02305065f, 0.06049965f, -0.00363608f, 
    0.04914661f, -0.05336606f, -0.06725463f, -0.06334098f, -0.06195198f, 0.04703341f, -0.00469157f, -0.04300493f, 
    -0.03990360f, -0.00736658f, -0.00007473f, 0.04241451f, 0.01381609f, -0.07297596f, 0.03391577f, -0.04135273f, 
    -0.02246216f, 0.04650647f, -0.04188549f, -0.04517641f, 0.06239126f, 0.03057110f, 0.05653654f, -0.04506398f, 
    0.02135242f, -0.07458544f, -0.04822362f, -0.00032129f, -0.03814306f, -0.03548961f, 0.04930658f, -0.03468098f, 
    0.05162054f, 0.07048614f, -0.01066805f, -0.04455801f, -0.04824142f, -0.05905202f, 0.03918866f, -0.05448362f, 
    -0.00951859f, -0.02836087f, -0.01378912f, 0.03637864f, -0.03570797f, -0.03714888f, 0.02621119f, -0.01788964f, 
    0.06286841f, -0.07868871f, 0.03018290f, 0.06018698f, -0.06508534f, -0.01424679f, 0.05617759f, -0.05610387f, 
    -0.00560082f, -0.04482232f, -0.05806610f, -0.00059040f, 0.00586777f, 0.04468071f, -0.00520828f, 0.02847237f, 
    0.04241021f, -0.04636215f, -0.05790089f, -0.05724179f, -0.04257338f, 0.01699541f, -0.03799575f, 0.05826764f, 
    -0.00653171f, -0.00728608f, -0.03322547f, -0.05150656f, -0.02115271f, 0.01828875f, 0.04568697f, 0.01603950f, 
    -0.04400928f, 0.02248120f, -0.02370011f, -0.02484751f, 0.04746196f, -0.06052386f, -0.03445686f, -0.01922369f, 
    0.05226745f, 0.01378209f, 0.01719707f, -0.03985251f, 0.00476784f, 0.01673313f, 0.06520997f, -0.07277860f, 
    -0.07936639f, -0.05824757f, -0.05610484f, -0.00524596f, -0.00024581f, -0.01580063f, -0.01558476f, 0.00508374f, 
    -0.01745147f, 0.02604024f, 0.00165769f, 0.01449942f, -0.05043962f, -0.07358482f, -0.02393043f, -0.06858499f, 
    -0.01390727f, 0.02007522f, 0.01729121f, 0.04289351f, -0.07359836f, -0.02571830f, -0.05525465f, -0.06717386f, 
    0.02701345f, -0.06354196f, -0.03098240f, -0.05272949f, -0.06342506f, -0.04261281f, -0.00194642f, -0.06315502f, 
    -0.01450507f, 0.00841236f, 0.02115038f, -0.01306365f, 0.06181099f, -0.02178696f, 0.02154819f, 0.05374989f, 
    -0.03523678f, 0.02540866f, 0.06718405f, 0.05125941f, 0.05904493f, -0.02377903f, -0.03802738f, -0.06227441f, 
    -0.00617857f, -0.03040695f, -0.00302039f, 0.06051619f, -0.05966426f, 0.02637018f, -0.00465359f, 0.03872243f, 
    0.12765598f, -0.01533247f, -0.04998490f, -0.11241982f, 0.01793189f, -0.05453664f, 0.20022824f, 0.10320713f, 
    0.15098719f, -0.11002766f, 0.03013500f, -0.07864203f, -0.20745708f, -0.10238270f, 0.04590771f, 0.18111654f, 
    0.10870649f, -0.15294118f, 0.06483434f, 0.07488258f, -0.10448056f, 0.05713221f, -0.00270887f, 0.15452106f, 
    -0.06352285f, -0.11646400f, 0.00205965f, -0.24287635f, 0.04103149f, 0.06190640f, -0.09289714f, -0.09974965f, 
    0.04447814f, 0.03640515f, 0.01050162f, 0.00881004f, 0.12938476f, 0.05777884f, 0.01552534f, -0.01355573f, 
    -0.16890374f, -0.04997038f, -0.07387171f, -0.03131127f, -0.13815343f, 0.10596518f, -0.00139308f, -0.13742062f, 
    -0.14859571f, -0.13919297f, -0.15100916f, -0.29094562f, 0.08583922f, 0.02951493f, -0.05929055f, 0.14083876f, 
    -0.08336653f, 0.03308151f, -0.00632478f, 0.03801082f, 0.20280750f, 0.16298628f, -0.27859595f, -0.00618052f, 
    -0.00735965f, 0.09604215f, 0.05432276f, 0.18831639f, -0.02922571f, 0.01232766f, 0.06152495f, -0.01798023f, 
    0.13164231f, 0.15069167f, -0.22679701f, -0.00960625f, -0.05103828f, -0.14501409f, 0.03598136f, 0.13725722f, 
    0.05027075f, 0.02209532f, -0.04295433f, -0.12247242f, 0.05412708f, 0.14325118f, 0.10862634f, -0.11650801f, 
    0.21663709f, 0.03823774f, -0.01422274f, 0.06245068f, 0.00272807f, 0.10123248f, -0.08024867f, -0.08042966f, 
    0.07540679f, -0.03549168f, 0.18655802f, 0.18902019f, 0.03835525f, -0.03118252f, -0.02468156f, 0.04589219f, 
    0.11541007f, -0.06012669f, -0.08626327f, -0.07414984f, -0.13543120f, 0.20846030f, 0.13517158f, 0.10167100f, 
    0.00366022f, 0.08152827f, 0.02479489f, -0.07627004f, -0.08974933f, 0.02748660f, 0.00828540f, -0.02632488f, 
    -0.09475827f, 0.16721356f, 0.05919489f, -0.11373937f, 0.18694007f, -0.02364914f, 0.10734890f, 0.04925693f, 
    0.05813313f, 0.07667159f, -0.05214150f, 0.03716584f, 0.19582927f, -0.01370123f, -0.10220140f, 0.07727153f, 
    0.05485391f, -0.08296084f, 0.07216695f, 0.08713228f, 0.01050443f, 0.03486458f, -0.01664102f, 0.03210425f, 
    -0.27215669f, -0.04119070f, 0.12054041f, 0.07939836f, 0.20520359f, -0.00040122f, -0.00596526f, -0.00307148f, 
    0.08289014f, -0.06421686f, -0.07772072f, 0.13708498f, 0.00515391f, -0.09134504f, -0.15873781f, 0.11515868f, 
    -0.17837606f, 0.00539780f, -0.05978370f, -0.02961377f, 0.10596628f, 0.17571570f, 0.07296420f, -0.00216118f, 
    0.08086351f, 0.08837046f, -0.14590232f, -0.01597800f, 0.05470603f, 0.02040894f, 0.00506596f, -0.00484562f, 
    0.05518583f, -0.02123679f, 0.17947800f, -0.11675581f, -0.28290635f, 0.01086266f, -0.12704477f, -0.41388437f, 
    0.15694642f, -0.06407072f, 0.11050845f, 0.00294165f, 0.00620888f, 0.10765988f, -0.00161947f, 0.15297064f, 
    -0.16766027f, 0.01639717f, 0.08620580f, 0.17148459f, -0.01055561f, 0.13457656f, -0.00364813f, 0.08688549f, 
    0.03610762f, 0.02665022f, -0.02610560f, -0.02213302f, -0.43666175f, -0.01009499f, -0.12039636f, -0.06260611f, 
    -0.00307240f, 0.01322527f, 0.12770934f, 0.08789879f, -0.00101773f, -0.06940081f, -0.06623909f, -0.03040823f, 
    -0.12948732f, -0.06255069f, 0.05199011f, -0.31536800f, -0.01883466f, 0.12742600f, -0.03560381f, 0.07248347f, 
    -0.02758285f, 0.11206914f, -0.04402304f, -0.03336699f, -0.20546138f, 0.06393202f, -0.02832092f, 0.30171791f, 
    -0.04373914f, 0.07726732f, 0.11077558f, -0.01094649f, 0.01247516f, 0.10113370f, 0.03658322f, 0.00265213f, 
    -0.04145500f, -0.01552673f, 0.08737143f, -0.00147757f, 0.07458773f, -0.06299987f, -0.02249607f, 0.04855764f, 
    0.06028868f, -0.02177460f, -0.03109022f, 0.03499115f, -0.17695063f, -0.03756477f, 0.04037362f, -0.05821600f, 
    0.00432797f, -0.06707154f, -0.04577436f, 0.10083064f, -0.08940227f, 0.03455018f, -0.04576109f, 0.08932465f, 
    0.07697853f, 0.21230651f, -0.11016221f, 0.29671112f, 0.07260980f, -0.02383102f, -0.01275941f, 0.04880075f, 
    -0.01086127f, -0.00529999f, 0.10030897f, 0.05994379f, -0.27615407f, -0.31832045f, 0.01411266f, -0.01571561f, 
    0.13092457f, -0.03901404f, 0.03558360f, 0.09647870f, 0.00773534f, -0.19025131f, -0.00727278f, 0.00809343f, 
    0.01706154f, 0.11893728f, 0.17605002f, -0.21525273f, 0.05331712f, -0.02706011f, -0.04480112f, -0.05500966f, 
    -0.00377094f, -0.02068901f, 0.00930537f, 0.10900922f, 0.05802545f, -0.13843700f, -0.05829582f, 0.28853160f, 
    -0.07569540f, -0.14499581f, 0.05459770f, -0.09039069f, 0.00232717f, 0.11231624f, 0.01969557f, -0.05714106f, 
    -0.04083556f, 0.01529729f, 0.00547896f, 0.04052835f, 0.13050717f, 0.06185452f, -0.02607920f, -0.08686329f, 
    0.04015885f, 0.01094980f, 0.08016213f, 0.05115604f, 0.23472647f, -0.02851781f, 0.09359737f, 0.30667835f, 
    0.04259492f, -0.03946790f, -0.10110911f, 0.05319910f, -0.00319216f, 0.07394978f, -0.01306004f, 0.00194810f, 
    0.20574403f, 0.17809828f, -0.06537544f, 0.09717236f, -0.01031742f, -0.08514573f, 0.00731501f, 0.01965364f, 
    0.10300608f, 0.15041678f, 0.05145133f, -0.02364749f, 0.13005863f, 0.03823614f, -0.02578256f, -0.06215575f, 
    0.10352125f, 0.11873617f, -0.03947111f, 0.08089012f, -0.06373069f, -0.04760446f, -0.05605040f, 0.01997383f, 
    -0.06849768f, 0.25726753f, 0.08054379f, 0.25188425f, -0.06150754f, 0.01971280f, 0.03273797f, 0.02700383f, 
    -0.07053018f, 0.01983906f, 0.08934502f, 0.03833629f, -0.03747619f, 0.02305590f, -0.09701220f, -0.05243298f, 
    0.03512640f, 0.05810776f, -0.03317537f, -0.05133459f, 0.10193036f, 0.00534969f, 0.09333003f, 0.07907922f, 
    0.04636611f, -0.05665898f, 0.05690594f, -0.03916362f, -0.06020685f, -0.00179633f, -0.05599172f, 0.05449240f, 
    -0.05208760f, 0.01678343f, -0.01113654f, -0.06643745f, -0.04968753f, -0.05628059f, 0.04717538f, -0.01147312f, 
    -0.05953517f, 0.03111833f, 0.01081381f, 0.06858512f, -0.03916232f, -0.04141939f, 0.01611466f, 0.01612017f, 
    -0.02896505f, -0.00931280f, -0.00499488f, 0.06100466f, -0.01598466f, 0.00095351f, -0.04055831f, -0.05930895f, 
    -0.01554685f, -0.06640168f, -0.05600076f, -0.07185815f, -0.06348749f, -0.02675545f, 0.03044505f, 0.05292672f, 
    0.05228250f, -0.06976937f, 0.01458383f, -0.03253686f, -0.03541785f, -0.05703559f, -0.03569669f, 0.07000616f, 
    0.01295509f, 0.03255584f, -0.07089414f, 0.01794847f, -0.05398851f, -0.03739005f, 0.00336311f, -0.01335768f, 
    0.02550840f, -0.01051593f, -0.02503094f, -0.01698894f, -0.05420391f, 0.02168058f, -0.03142693f, 0.01920357f, 
    0.04942816f, -0.05679224f, -0.00177978f, 0.02941354f, -0.01080395f, -0.03915786f, -0.05199834f, 0.03073322f, 
    -0.04125898f, -0.04098952f, 0.03104779f, -0.05961128f, 0.06480055f, -0.04562259f, 0.04404030f, 0.00932861f, 
    0.01929112f, -0.04802911f, 0.06941364f, -0.04655324f, 0.01665196f, -0.05780243f, -0.04287834f, -0.02536403f, 
    -0.03697581f, -0.02491287f, -0.05024948f, -0.06064148f, 0.06249791f, -0.05554022f, -0.04886181f, 0.02861940f, 
    -0.05286417f, -0.03826573f, -0.06198187f, -0.06552175f, 0.04031447f, -0.07020753f, 0.00981632f, -0.02354126f, 
    -0.06534857f, -0.01118391f, 0.00117955f, 0.04389018f, 0.03009119f, 0.01007262f, 0.00076007f, 0.01364807f, 
    0.03289706f, 0.05800693f, -0.01409935f, 0.06540662f, -0.04323775f, -0.04469916f, 0.01579276f, 0.00335816f, 
    -0.00429194f, 0.02234663f, 0.04428058f, 0.05772383f, 0.00205483f, -0.03094678f, -0.01829617f, 0.00751659f, 
    -0.04013728f, 0.07012168f, -0.06255681f, -0.04727429f, -0.00274482f, -0.04921106f, -0.05340183f, -0.03881632f, 
    0.01474804f, 0.06704832f, -0.03631645f, -0.00553104f, 0.01780303f, 0.05633861f, 0.02635628f, 0.06345735f, 
    -0.05020666f, 0.07081646f, 0.05018600f, -0.04969275f, 0.02550450f, 0.04596055f, -0.06725604f, 0.01757804f, 
    0.02097791f, 0.01993389f, -0.02613472f, 0.04206597f, -0.02224471f, 0.01958760f, -0.05560289f, -0.02919592f, 
    -0.00245665f, -0.03031816f, 0.06623189f, 0.00425053f, 0.01993467f, -0.00554737f, -0.02329448f, -0.02245280f, 
    0.02700317f, -0.00308695f, -0.04574678f, 0.00306440f, 0.02242713f, -0.07035574f, 0.02202250f, -0.01334880f, 
    -0.04960756f, -0.01618835f, -0.01018224f, -0.03336689f, -0.07012581f, -0.06621297f, 0.01696517f, 0.01088894f, 
    -0.01904337f, -0.03443256f, 0.00311648f, 0.02823873f, -0.06986823f, -0.04845929f, -0.03564925f, -0.03609574f, 
    0.04391182f, 0.03397144f, -0.07289924f, -0.06893592f, -0.05889813f, -0.00647204f, -0.00532255f, 0.06199420f, 
    -0.05932812f, 0.04436043f, -0.05891110f, 0.01785694f, 0.04179644f, -0.02566206f, 0.06701715f, -0.05133651f, 
    -0.04160669f, 0.04514436f, -0.04997756f, 0.01397336f, 0.00345423f, 0.00866521f, 0.05381508f, -0.01968562f, 
    -0.06090955f, -0.00567666f, -0.03074989f, -0.02497090f, 0.04118281f, -0.07021087f, -0.00944294f, 0.00621806f, 
    0.03840341f, 0.02037847f, -0.05956839f, -0.00628953f, 0.02958567f, 0.06433567f, -0.05709999f, -0.06869891f, 
    -0.01789657f, -0.03509620f, 0.00931305f, -0.06763166f, 0.02683244f, -0.04763325f, 0.02423346f, -0.07529893f, 
    -0.06187644f, 0.06187160f, 0.05984014f, 0.05929901f, 0.01055680f, -0.05576989f, -0.02582365f, -0.03727723f, 
    -0.07730231f, -0.00106812f, 0.05139525f, -0.02192145f, 0.00804321f, 0.06297879f, -0.04614839f, 0.01126380f, 
    0.03806545f, 0.05912199f, -0.01344920f, -0.07628785f, 0.04572997f, -0.06460476f, -0.04711696f, 0.05693270f, 
    -0.04146785f, -0.04542164f, -0.03313586f, -0.04466723f, -0.05155754f, 0.03629323f, 0.03575630f, -0.02486398f, 
    -0.03969795f, -0.00525844f, -0.07460386f, 0.02107205f, 0.00548107f, 0.04097684f, 0.00604558f, 0.00252585f, 
    -0.00040218f, -0.05941064f, -0.03069337f, 0.05214234f, -0.00843641f, -0.07236388f, -0.01642733f, 0.02574637f, 
    0.00801282f, 0.02360496f, -0.03245123f, -0.05643642f, 0.01878100f, -0.02907171f, 0.02112814f, 0.07042781f, 
    -0.00380917f, -0.02189580f, -0.00089788f, 0.03739774f, -0.01559204f, -0.06088883f, 0.00503111f, -0.06502984f, 
    0.04122415f, -0.01702322f, -0.07151334f, 0.05766159f, -0.06571182f, -0.04832308f, 0.05303651f, -0.07138051f, 
    -0.02235523f, -0.01439062f, 0.01319544f, -0.03562406f, -0.01065465f, 0.05232344f, 0.04843442f, -0.00796453f, 
    -0.03566710f, -0.00580445f, -0.02181009f, -0.03395597f, 0.04320669f, -0.03844897f, 0.05158677f, 0.00085066f, 
    -0.03374727f, -0.03602357f, 0.00228709f, 0.03274498f, -0.07252423f, -0.03425491f, 0.03698737f, 0.02304700f, 
    0.02259897f, 0.03923524f, 0.02007330f, -0.04703692f, -0.00224466f, 0.04102913f, 0.05244437f, -0.03181927f, 
    -0.00158247f, -0.06545746f, -0.06012025f, -0.01278786f, -0.05429646f, -0.05276043f, -0.04226834f, 0.05951820f, 
    -0.03856478f, -0.00891758f, -0.07352705f, 0.05140054f, 0.00464605f, -0.06318236f, 0.06030407f, -0.01878318f, 
    0.04790555f, 0.02904382f, 0.03369115f, -0.01878029f, 0.04632597f, 0.04511830f, -0.06438476f, -0.05725538f, 
    0.04149366f, -0.07471301f, -0.05515852f, 0.01452846f, -0.06244532f, -0.03585576f, 0.02261422f, -0.07728584f, 
    0.01183400f, 0.04824045f, -0.04360526f, -0.05437033f, -0.05717354f, 0.03246921f, 0.00372948f, -0.05255291f, 
    0.16130432f, -0.12475174f, -0.19507484f, -0.13594501f, 0.10957346f, -0.09067804f, -0.01291377f, -0.12434473f, 
    0.00266935f, -0.00023144f, 0.00670740f, 0.11458815f, 0.01115411f, 0.07917029f, 0.00425756f, 0.12602782f, 
    0.07413362f, -0.13157193f, 0.05487966f, 0.07014745f, 0.06583644f, 0.11319041f, -0.01902614f, 0.06860889f, 
    0.09217091f, 0.03101627f, 0.20505524f, 0.05794564f, -0.02129718f, -0.04010546f, -0.17175202f, 0.03086569f, 
    0.03502418f, 0.00703640f, 0.09229730f, -0.07651950f, -0.22531332f, -0.22679706f, -0.17617787f, -0.24250275f, 
    0.05187062f, 0.03460103f, 0.09793362f, 0.04253129f, 0.11611293f, 0.02481955f, -0.07990885f, 0.05835032f, 
    -0.19531472f, 0.01270805f, 0.09405250f, -0.13091992f, 0.12783946f, 0.04661917f, 0.05711099f, -0.12746517f, 
    0.03047388f, 0.13137060f, 0.05693484f, 0.28586715f, 0.21594368f, 0.05026197f, -0.22998762f, -0.16914527f, 
    0.14479306f, 0.02995570f, 0.02138369f, 0.15653597f, 0.00649815f, 0.08593315f, 0.13615905f, 0.06086928f, 
    -0.02433802f, -0.10198988f, -0.03312923f, -0.24424134f, -0.04392362f, 0.16378622f, 0.03389966f, -0.09297050f, 
    -0.05611108f, -0.07650533f, 0.07492132f, -0.09962767f, 0.00272198f, 0.26276445f, 0.22440793f, 0.09666746f, 
    -0.03815793f, 0.18006819f, 0.05528872f, 0.15917014f, 0.00587927f, 0.11255835f, 0.13358994f, -0.01304029f, 
    -0.16307206f, 0.01956730f, -0.03819562f, 0.09494133f, 0.05805086f, 0.12408787f, 0.01605133f, 0.10112097f, 
    0.03677183f, -0.02684671f, -0.01955195f, -0.06015408f, -0.22785932f, 0.08981410f, 0.27810770f, -0.00555882f, 
    0.07091954f, -0.00716906f, -0.02995371f, 0.00393056f, -0.01623041f, -0.12284490f, 0.09150564f, -0.12383935f, 
    -0.11445154f, 0.10918654f, 0.16465273f, -0.29013661f, -0.08930621f, 0.00893449f, -0.10447640f, -0.03712039f, 
    0.01807829f, 0.12339935f, -0.02112837f, 0.12870865f, 0.00517721f, 0.02832166f, -0.13422292f, -0.02148081f, 
    0.02736731f, -0.02066216f, 0.19732559f, -0.01450910f, -0.05729487f, 0.14187604f, 0.03890181f, 0.08083127f, 
    -0.16353181f, -0.06100536f, 0.15020056f, 0.22777228f, 0.13148053f, 0.00795719f, -0.02810379f, 0.00145897f, 
    -0.03037759f, -0.07665927f, 0.02515488f, 0.12069065f, -0.24298206f, -0.01168155f, -0.15908399f, 0.16609977f, 
    -0.01574712f, 0.01542646f, 0.15142207f, -0.08393767f, 0.03938230f, 0.16216424f, 0.11403968f, -0.07479833f, 
    0.20468102f, -0.24065851f, -0.23694479f, -0.09971971f, 0.18962762f, 0.05560752f, -0.03372661f, 0.03491437f, 
    0.04145220f, 0.06509435f, -0.08101926f, 0.00032653f, -0.18168361f, -0.01807125f, 0.30945334f, -0.13504682f, 
    0.01058417f, -0.00008429f, 0.02824482f, -0.03886632f, 0.10859448f, -0.03051180f, 0.00296291f, 0.14033696f, 
    -0.09190774f, 0.04546249f, -0.14217016f, -0.05942245f, -0.00530552f, -0.04491818f, 0.06920343f, -0.06815446f, 
    -0.02560002f, 0.05360121f, 0.08808016f, 0.01234752f, -0.05335925f, -0.35731074f, 0.05071028f, -0.02213774f, 
    -0.07946942f, -0.03281615f, -0.01366526f, -0.03069795f, -0.03157625f, 0.03340227f, 0.05493571f, -0.03199251f, 
    0.07132297f, -0.08118359f, -0.06851459f, -0.08173758f, -0.03873851f, 0.07279591f, 0.09174276f, -0.01299059f, 
    0.00847796f, -0.11726790f, 0.05007244f, -0.04720072f, -0.12320582f, 0.28419372f, 0.03574402f, -0.13557571f, 
    0.11183661f, -0.08511396f, 0.10769390f, -0.05799055f, 0.13815734f, -0.05833026f, 0.04010633f, 0.14278305f, 
    0.11214785f, -0.14415373f, 0.01474642f, -0.11472363f, -0.04745989f, -0.05554876f, -0.00310394f, -0.07998049f, 
    -0.03133134f, -0.01784623f, 0.03930236f, 0.01368841f, -0.42176142f, 0.09513634f, -0.17868559f, 0.05424615f, 
    -0.02483959f, -0.04675230f, 0.00049897f, 0.09806114f, -0.08536690f, -0.07325583f, -0.06034509f, -0.01827897f, 
    0.08200289f, 0.08056905f, 0.04575675f, -0.03776275f, 0.12711525f, -0.06368668f, 0.11701965f, 0.03252066f, 
    0.07698067f, 0.01143561f, 0.01195466f, 0.00333799f, 0.28255594f, 0.00504608f, 0.04436689f, -0.04738888f, 
    0.07060603f, -0.02517519f, -0.02050956f, -0.06223620f, 0.00827711f, -0.06344262f, -0.16521670f, 0.03646354f, 
    -0.16297579f, -0.00694379f, 0.04777235f, -0.23106843f, -0.11738341f, 0.01990996f, 0.01617926f, 0.11998123f, 
    0.02813941f, -0.10330141f, 0.02261778f, 0.10484080f, 0.24225162f, 0.09673399f, 0.12084224f, -0.16212298f, 
    -0.13855706f, 0.04691296f, -0.08499691f, 0.11099024f, 0.10849243f, 0.17745982f, 0.01289987f, -0.02522087f, 
    0.18015794f, 0.00539570f, -0.01746966f, 0.14300893f, -0.16434924f, 0.03198252f, -0.03803225f, 0.04729122f, 
    0.10100497f, -0.03334381f, 0.07816250f, 0.01706251f, -0.12766220f, -0.08938958f, -0.04623189f, 0.14403091f, 
    -0.05426377f, 0.09509382f, 0.01883812f, 0.03727571f, 0.06167535f, -0.02150488f, -0.03266865f, 0.12638538f, 
    -0.04625124f, 0.04092404f, 0.11776593f, 0.01222849f, -0.02659294f, 0.11861937f, 0.07959109f, 0.07008780f, 
    0.12178431f, -0.02770882f, -0.05780870f, -0.01516409f, 0.17322336f, -0.02883406f, -0.13918401f, -0.18886767f, 
    0.00489393f, 0.13846879f, 0.00829386f, 0.10265405f, 0.07077373f, 0.08149415f, -0.04003979f, -0.07250083f, 
    -0.47778183f, 0.39427331f, 0.02732614f, -0.06510875f, 0.03506110f, 0.04130946f, 0.14029126f, -0.02986706f, 
    0.18032014f, 0.05993121f, 0.16794832f, 0.03771587f, 0.25809023f, -0.21122409f, 0.06738338f, 0.21429814f, 
    -0.07757736f, -0.10299049f, -0.11091545f, 0.14217459f, 0.10687562f, 0.00959591f, 0.01217350f, 0.01569266f, 
    -0.15929545f, 0.09601563f, -0.08379413f, -0.03068376f, 0.05722191f, 0.05373106f, 0.12145574f, 0.17528887f, 
    0.08966962f, -0.14376146f, 0.04409084f, -0.11115092f, -0.00733644f, 0.08666062f, -0.14339614f, -0.01906346f, 
    0.00727031f, 0.08634749f, 0.09062243f, 0.01644615f, 0.00139192f, 0.02980763f, -0.05292073f, 0.10085575f, 
    0.25098401f, 0.00240767f, -0.14629427f, -0.11806701f, -0.11531290f, 0.15015544f, 0.03131363f, -0.17115556f, 
    0.10153512f, -0.06923652f, 0.16886282f, 0.11052968f, -0.01200912f, 0.02240872f, -0.03686410f, 0.27309704f, 
    -0.00723186f, 0.00689215f, 0.15315756f, 0.07175795f, -0.04705287f, -0.05544014f, -0.02584763f, -0.00328980f, 
    0.20972100f, 0.06089088f, -0.08865918f, -0.06838444f, 0.01248400f, 0.03873755f, -0.08830938f, -0.05571971f, 
    -0.01065464f, -0.09195041f, 0.20641792f, -0.06983231f, 0.23089112f, -0.01503152f, 0.06225990f, -0.10666911f, 
    0.01724183f, 0.02685649f, 0.25536743f, 0.06908866f, 0.00941541f, -0.09285078f, -0.21970323f, -0.09424331f, 
    0.13706762f, 0.17338102f, -0.16715476f, 0.29813242f, -0.01291751f, -0.24490532f, -0.03420407f, 0.10304160f, 
    0.01154416f, 0.30224541f, 0.13051593f, -0.02513814f, 0.15062864f, 0.19399382f, 0.06190667f, -0.04041750f, 
    0.00416222f, 0.07160045f, -0.18885872f, -0.02845151f, -0.06632359f, 0.08532879f, -0.11431291f, -0.04194079f, 
    -0.00890446f, -0.12626752f, 0.09720542f, 0.03443941f, 0.01475227f, -0.05909089f, 0.15788707f, 0.02503031f, 
    0.11350468f, 0.03597079f, -0.07326441f, -0.11073886f, 0.12778033f, 0.20773999f, -0.24253319f, 0.04651128f, 
    -0.06844112f, 0.04937162f, -0.02793225f, -0.13922448f, -0.02313331f, -0.11675899f, 0.04754305f, 0.14001341f, 
    0.04957781f, 0.14603549f, 0.01816284f, 0.07517363f, 0.07442912f, 0.11077594f, 0.00638743f, -0.10056242f, 
    0.07596726f, -0.14915076f, 0.01406286f, -0.01411746f, 0.21526352f, -0.13346073f, 0.03561919f, -0.00460382f, 
    0.07878724f, 0.03368007f, -0.07278100f, 0.03046893f, -0.01185636f, -0.19941507f, -0.14744850f, -0.03073717f, 
    0.02691358f, -0.00642375f, -0.15470508f, 0.14135185f, 0.01370879f, -0.05839126f, -0.12906900f, -0.06658113f, 
    0.01400828f, -0.19801711f, 0.01163919f, 0.04228121f, 0.44594601f, -0.07514583f, 0.02147477f, 0.02614239f, 
    -0.03363248f, 0.02570511f, -0.14113787f, -0.05665535f, -0.06086743f, -0.01879963f, 0.07088543f, 0.07270093f, 
    -0.09968531f, 0.21134777f, -0.07356371f, 0.20570658f, -0.01068770f, 0.02858936f, 0.15332542f, 0.05433927f, 
    -0.22273794f, 0.09962384f, 0.13636868f, 0.14417791f, 0.00584456f, 0.12167650f, -0.10912771f, -0.12651411f, 
    0.09871379f, -0.10741588f, -0.09604184f, -0.15239340f, -0.05882671f, 0.07491947f, 0.02145642f, 0.09968265f, 
    0.16046491f, 0.24684812f, 0.12074771f, 0.17174201f, -0.10778350f, -0.01653670f, 0.20011050f, -0.00221753f, 
    0.06152855f, 0.06847253f, 0.05444517f, -0.02786201f, -0.21955825f, 0.07024895f, 0.23397952f, -0.08571162f, 
    -0.06728182f, -0.00259492f, -0.02844933f, -0.04952369f, -0.07976267f, -0.03819027f, 0.08257870f, 0.00278420f, 
    0.22589232f, 0.01282814f, -0.11728813f, 0.15102419f, -0.03208327f, 0.13236865f, 0.03174398f, -0.03924846f, 
    -0.06301227f, -0.08065630f, -0.11760715f, -0.03093667f, 0.20904987f, 0.20484847f, 0.13710347f, 0.14431800f, 
    -0.02266230f, -0.07073703f, 0.07081416f, -0.07235430f, 0.06780066f, -0.05855642f, 0.05292347f, -0.07180694f, 
    -0.01874347f, -0.03532268f, 0.02560203f, -0.08327945f, -0.03891976f, -0.01399257f, -0.07836770f, 0.04029718f, 
    -0.14928959f, -0.07559706f, -0.03470761f, -0.15999509f, 0.30549487f, -0.06536147f, 0.06978738f, 0.14483510f, 
    -0.14546952f, 0.07961456f, 0.02307616f, 0.08395073f, -0.00503856f, 0.13736497f, -0.15896843f, 0.00051128f, 
    0.02738024f, -0.04386171f, 0.18204874f, -0.16734242f, 0.10622592f, -0.06480133f, -0.09438723f, 0.03817131f, 
    0.08529819f, 0.03294433f, -0.11577410f, -0.14946908f, -0.05026029f, -0.07313212f, 0.02006971f, -0.03790708f, 
    0.08603960f, -0.04896849f, -0.11172777f, -0.09770062f, -0.03386770f, 0.12036101f, -0.07713477f, 0.03566015f, 
    0.06799299f, -0.39573517f, 0.19021374f, -0.05821904f, -0.25233945f, 0.05491419f, -0.04191998f, 0.12501235f, 
    -0.03353583f, -0.12026312f, -0.03692247f, 0.03561130f, -0.26366174f, -0.16040686f, -0.05135009f, -0.13979767f, 
    -0.03964166f, 0.06598575f, -0.02423266f, 0.01496170f, -0.06760170f, 0.01134508f, 0.03884280f, 0.00833049f, 
    -0.01518312f, 0.02535355f, -0.07958787f, 0.32401577f, 0.04958915f, 0.07645880f, 0.05070402f, 0.00704547f, 
    0.05559314f, -0.04978701f, -0.05648154f, -0.16985716f, 0.07042651f, -0.08089017f, -0.11925420f, -0.08169217f, 
    0.01810741f, 0.09686971f, -0.04508685f, -0.02748717f, 0.05793044f, 0.03716626f, 0.07028261f, -0.03093442f, 
    -0.22824284f, -0.08237509f, -0.19910464f, -0.13465063f, -0.05106511f, -0.06866548f, -0.03818807f, -0.06217618f, 
    0.14923754f, 0.08744501f, 0.01848826f, 0.02261409f, 0.36856666f, -0.02282326f, 0.08471977f, -0.24407391f, 
    -0.05100238f, 0.11796866f, -0.06193974f, 0.02024236f, 0.00495635f, -0.04072449f, 0.05867392f, -0.00478971f, 
    0.08341777f, 0.21856873f, 0.27093253f, -0.11196624f, 0.00847753f, 0.18674649f, 0.00673892f, -0.02101467f, 
    0.05532296f, -0.03613430f, 0.17816094f, 0.11253263f, 0.12570772f, 0.09935956f, 0.17349735f, 0.22663267f, 
    0.05099092f, 0.02666712f, -0.02480728f, 0.10285899f, -0.09833348f, 0.01804071f, 0.04272669f, -0.09441148f, 
    -0.23898645f, -0.01974871f, 0.03606262f, 0.16064923f, -0.04326376f, 0.09303300f, 0.07501799f, 0.12492096f, 
    0.01044658f, 0.04626324f, 0.07296130f, 0.01358838f, -0.57942945f, -0.08980305f, 0.00151244f, -0.07341053f, 
    0.08692146f, 0.04606292f, -0.03620315f, -0.04718889f, -0.18686953f, -0.10728324f, -0.02216762f, -0.00745197f, 
    -0.17070071f, -0.06009081f, 0.02517674f, -0.28676504f, -0.01958448f, 0.09952317f, 0.00461540f, 0.06258486f, 
    0.00349079f, -0.00755700f, -0.01905905f, -0.00977780f, 0.03140698f, 0.14825116f, -0.02913909f, 0.28364438f, 
    -0.12965317f, 0.09633208f, -0.01503290f, -0.04332824f, -0.04902205f, 0.02383924f, 0.11645297f, 0.02989551f, 
    -0.13109513f, -0.06395424f, -0.05459422f, -0.06419279f, 0.00690351f, -0.05473873f, -0.09723409f, 0.06736177f, 
    -0.01705419f, -0.12647714f, 0.00158548f, -0.04983177f, 0.04098925f, 0.17721134f, 0.18964601f, 0.11816420f, 
    0.00307762f, 0.06871542f, -0.00914456f, 0.08186795f, -0.01388983f, -0.06015279f, -0.14099014f, 0.01085389f, 
    0.22170737f, 0.21868759f, 0.07749025f, 0.19278291f, 0.16426483f, -0.03087292f, 0.00747893f, 0.04710193f, 
    0.09282203f, 0.03868258f, -0.02660972f, -0.02234744f, -0.16513523f, -0.30548236f, 0.11314633f, -0.02305945f, 
    0.06210161f, -0.14211650f, 0.01374973f, -0.10187452f, -0.02370918f, -0.11614985f, -0.05625116f, 0.00815112f, 
    0.34963700f, -0.05204373f, 0.12792379f, -0.08828392f, -0.02580157f, -0.09072805f, 0.00875240f, 0.12302461f, 
    0.03858128f, 0.03476585f, -0.00051083f, 0.11427432f, -0.02861240f, -0.17621541f, -0.03943909f, 0.22809228f, 
    -0.12410025f, 0.03926075f, 0.04913890f, 0.02817046f, 0.01819146f, 0.07829433f, -0.04924580f, 0.02519769f, 
    -0.04387282f, 0.03956478f, -0.08701149f, 0.05626662f, 0.02182661f, 0.10082135f, 0.02271775f, -0.02114942f, 
    -0.09848809f, -0.15190525f, 0.00598066f, 0.01930177f, 0.13370550f, 0.07421921f, 0.00881262f, 0.14029343f, 
    0.09821083f, 0.03754369f, -0.06741098f, 0.14516953f, 0.05964474f, -0.10499984f, -0.02521962f, -0.01291737f, 
    0.16837905f, 0.05540234f, -0.12156495f, -0.02508487f, 0.07271599f, 0.07811300f, 0.04453949f, 0.07787751f, 
    -0.02689920f, -0.00086040f, 0.02792277f, -0.12238608f, 0.34263432f, 0.14831285f, -0.01215441f, -0.11694775f, 
    -0.08478618f, 0.06323354f, -0.04541338f, 0.03602156f, -0.02353143f, -0.01167471f, -0.05456373f, 0.06865636f, 
    -0.11236940f, 0.16272554f, 0.10810410f, 0.16102786f, -0.07782491f, 0.01825036f, 0.13150376f, -0.10669511f, 
    -0.04524684f, 0.08439537f, 0.04781814f, 0.09220845f, 0.06612489f, -0.07803144f, -0.12424184f, -0.18714280f, 
    0.07089541f, 0.05625447f, -0.06010927f, 0.07950674f, -0.04178900f, 0.08673309f, 0.03411172f, 0.00595802f, 
    0.03168561f, -0.17335269f, -0.16001202f, -0.09471006f, 0.11453778f, 0.05619171f, 0.03597207f, 0.03946416f, 
    -0.08348597f, 0.06727880f, 0.09423500f, -0.01574734f, 0.27260700f, 0.11684615f, -0.04542736f, 0.05748503f, 
    0.00934658f, -0.16752298f, -0.07115955f, 0.08437531f, 0.10333779f, 0.00626006f, 0.11840825f, 0.09912058f, 
    0.37010148f, 0.09918917f, 0.09057837f, 0.16714910f, 0.08733125f, 0.06051324f, -0.11730562f, -0.05443043f, 
    0.00556514f, -0.05497883f, 0.16137305f, -0.01735984f, -0.11408616f, -0.20355059f, -0.08304994f, -0.29285863f, 
    0.07672311f, 0.04003716f, 0.03201012f, -0.03652457f, 0.14208925f, -0.02771660f, -0.04137252f, 0.04688782f, 
    0.09352387f, 0.18244746f, 0.11066399f, 0.10195069f, -0.03022660f, 0.11282816f, 0.08387070f, -0.11248320f, 
    0.01341128f, 0.14085431f, 0.06278745f, -0.07056447f, -0.07771505f, -0.09643333f, -0.11460261f, -0.03528527f, 
    0.15550932f, 0.02845307f, 0.06223519f, -0.02402277f, 0.13459380f, 0.03084848f, 0.10570583f, -0.08110926f, 
    -0.18095402f, -0.01565581f, 0.01187024f, -0.21618468f, -0.00165737f, -0.02576592f, 0.00728509f, 0.04527903f, 
    0.05855160f, 0.11228905f, 0.01033342f, 0.04686188f, 0.36182305f, 0.29217309f, 0.16724761f, 0.03737610f, 
    -0.06111992f, 0.20770578f, -0.12864196f, 0.02068587f, -0.00268154f, 0.03823364f, 0.04607935f, -0.03036614f, 
    -0.23868628f, -0.04310856f, -0.05970977f, 0.17156725f, 0.13539518f, 0.06383689f, 0.01778652f, 0.06940940f, 
    0.07883559f, 0.12688984f, 0.05098978f, -0.08772803f, -0.04495425f, -0.00604933f, 0.28514439f, -0.08150840f, 
    0.03428515f, 0.15010868f, -0.00402711f, 0.04824335f, -0.04189461f, -0.04838498f, -0.00355740f, -0.03129215f, 
    0.15577920f, 0.10986016f, 0.22803414f, -0.06177463f, -0.07178885f, 0.01431611f, -0.07379693f, -0.00843741f, 
    0.02544859f, 0.07147475f, 0.01026489f, 0.06149191f, -0.08998203f, -0.08897673f, -0.03139953f, -0.05446008f, 
    -0.07134697f, 0.04193252f, 0.00152049f, 0.09576461f, -0.07592872f, -0.08866563f, 0.04988810f, -0.01776027f, 
    -0.23697579f, 0.01223213f, 0.00934765f, 0.07205287f, 0.02359786f, 0.04746396f, -0.12454683f, 0.04621002f, 
    0.07696848f, -0.15838891f, 0.08539203f, 0.04082951f, -0.26330265f, -0.17849100f, -0.11645168f, -0.00806322f, 
    0.00577593f, 0.05033843f, 0.03141616f, -0.07341468f, -0.09230049f, -0.04511515f, 0.01127995f, -0.00565563f, 
    -0.12083571f, -0.10414775f, -0.20930593f, -0.23336616f, 0.02863448f, 0.00327205f, 0.02332635f, 0.04339880f, 
    0.04233309f, -0.06478018f, -0.05228702f, 0.17981002f, -0.01128127f, 0.13052930f, 0.20270096f, 0.04894058f, 
    0.00830154f, 0.04007357f, -0.03455169f, -0.01857697f, 0.05193759f, 0.05566840f, -0.04143687f, 0.08453568f, 
    0.02667150f, 0.04099850f, 0.02267295f, -0.05226928f, -0.02450684f, -0.03893688f, -0.04694553f, -0.00686608f, 
    -0.01616069f, -0.02937946f, -0.02589963f, -0.03884336f, 0.00728260f, 0.06095966f, -0.02055843f, 0.04192422f, 
    -0.06531420f, 0.05858495f, -0.03852975f, -0.05583163f, -0.02586110f, -0.00632282f, -0.06101964f, 0.00271419f, 
    -0.04742289f, -0.07535405f, -0.07066087f, 0.02328800f, -0.06547374f, -0.05962932f, 0.05112935f, 0.01802882f, 
    0.04911172f, 0.01569649f, 0.00414473f, -0.08220526f, 0.02517178f, 0.00511641f, -0.00103010f, -0.01356229f, 
    -0.00439698f, 0.01597442f, -0.02726799f, 0.00480142f, -0.00128831f, -0.00148211f, -0.02984740f, 0.02557872f, 
    0.03195563f, -0.03390544f, 0.04226615f, 0.02656465f, -0.02585867f, -0.04650344f, -0.02766249f, -0.04063694f, 
    0.05477227f, -0.04077516f, 0.04272376f, 0.00205757f, -0.01307090f, 0.04852254f, 0.04652867f, 0.02799824f, 
    -0.04587388f, 0.01460642f, 0.04727815f, 0.04189605f, -0.01910121f, 0.01838340f, -0.04434042f, -0.06933403f, 
    0.01268326f, -0.00272593f, 0.04224095f, -0.00274358f, -0.07493986f, 0.03595993f, -0.02861463f, 0.00494646f, 
    -0.05592480f, 0.06344014f, -0.05774057f, -0.01201720f, -0.01597105f, -0.03704849f, -0.03394543f, -0.04378068f, 
    -0.01430655f, -0.06565984f, -0.07797391f, 0.02758453f, -0.02234968f, 0.00139375f, -0.07699283f, -0.07043641f, 
    -0.06156751f, 0.04874742f, -0.00271204f, -0.05369363f, -0.00621731f, -0.07263440f, -0.00585793f, 0.05180229f, 
    0.05317298f, -0.00249029f, -0.01664562f, 0.04358324f, -0.05480750f, -0.00533440f, -0.04367723f, -0.00329354f, 
    0.03499215f, 0.05514171f, -0.02520161f, -0.04130118f, 0.01813101f, -0.03097051f, -0.05901252f, -0.04984278f, 
    -0.02942306f, -0.05323025f, -0.03830958f, 0.05122388f, 0.04460714f, -0.00639968f, 0.02886064f, -0.04775635f, 
    -0.05272166f, 0.01279557f, -0.06060728f, 0.03739574f, -0.06265900f, -0.00639576f, -0.01923778f, -0.02601591f, 
    0.05315836f, 0.02519163f, 0.04946708f, 0.01848751f, -0.04479711f, 0.02925119f, -0.00722590f, -0.01084944f, 
    -0.04694862f, -0.05517894f, -0.00134125f, -0.02077506f, 0.03314833f, -0.01831360f, 0.01360804f, 0.03702375f, 
    0.05102694f, -0.06804646f, -0.04042742f, -0.00721525f, -0.06051816f, -0.03188724f, 0.04233477f, 0.04066586f, 
    -0.01272150f, 0.01627861f, 0.00802931f, -0.06274883f, 0.02167481f, 0.06247343f, -0.00524187f, -0.00932874f, 
    -0.05724268f, -0.02901992f, -0.04561765f, 0.05664835f, 0.05858102f, -0.07873265f, -0.00221530f, -0.02363103f, 
    0.05390618f, 0.05986420f, -0.00870454f, -0.07510822f, 0.03339306f, -0.06595492f, -0.01503148f, -0.07209434f, 
    0.00914784f, 0.04828789f, 0.03683711f, -0.05787428f, -0.03984517f, -0.02149235f, -0.04595961f, 0.02175271f, 
    -0.07185500f, -0.08137795f, 0.04683752f, -0.03618761f, -0.02103957f, -0.06430046f, -0.06580615f, 0.00754820f, 
    -0.02798058f, 0.01110908f, -0.00888220f, 0.00886661f, 0.04459763f, 0.04982559f, -0.02853252f, -0.03181113f, 
    0.06052851f, -0.03033855f, -0.00909200f, 0.04879893f, -0.00409972f, -0.00141830f, 0.05697103f, -0.01586179f, 
    0.06290190f, -0.05774737f, -0.04023647f, 0.02625152f, -0.06639043f, 0.02116036f, -0.02202412f, -0.06051401f, 
    -0.02245787f, -0.07336675f, 0.03832388f, 0.03471004f, -0.05119341f, 0.00569064f, 0.03323426f, -0.05532005f, 
    0.04256138f, -0.04660396f, -0.07270624f, -0.01199649f, 0.02384347f, 0.02650788f, -0.04132959f, -0.07136332f, 
    0.06944253f, 0.04867160f, -0.06984337f, 0.01081383f, 0.00882995f, -0.00035169f, -0.04786177f, -0.05897903f, 
    -0.00393744f, -0.03096261f, -0.03332072f, 0.02296497f, -0.01412420f, -0.00777331f, -0.04998318f, -0.00384503f, 
    -0.00331298f, 0.06616484f, -0.03550215f, -0.05841319f, 0.00198795f, -0.07618333f, -0.04462079f, -0.06407078f, 
    -0.01679039f, -0.00007008f, 0.00183316f, -0.04968753f, -0.00111476f, -0.06528202f, -0.03274360f, -0.00130453f, 
    -0.00795655f, 0.03991332f, -0.00912379f, -0.05863000f, -0.02682622f, -0.02536687f, -0.03270158f, -0.06375875f, 
    0.01347888f, -0.02822989f, 0.03305056f, -0.07094025f, -0.04734001f, -0.05418212f, -0.06103370f, -0.02734254f, 
    0.02124410f, 0.04078957f, 0.04597872f, 0.02352847f, -0.00390904f, -0.00049040f, -0.07498690f, -0.06981543f, 
    0.00784567f, -0.04694569f, -0.00986505f, -0.03977603f, -0.04999781f, -0.05635816f, -0.00383431f, -0.00694933f, 
    0.01953656f, 0.03555908f, 0.01530933f, 0.04896910f, 0.04313603f, -0.05684039f, -0.01599769f, 0.03014624f, 
    0.01132117f, 0.01668190f, -0.05705734f, 0.03271860f, 0.03473467f, -0.01190895f, -0.00234289f, 0.00090363f, 
    -0.06101223f, -0.01586704f, -0.06552633f, -0.02943979f, 0.00109146f, 0.00427439f, 0.04081715f, 0.02489066f, 
    -0.06580817f, -0.07831562f, 0.01143374f, -0.02487145f, 0.06207074f, 0.01227722f, -0.06050401f, -0.01257409f, 
    -0.08333392f, -0.01147281f, -0.00606877f, 0.03527696f, -0.03285277f, -0.02766287f, 0.01873039f, -0.07098085f, 
    0.03426954f, 0.01569787f, 0.03353475f, -0.07299927f, -0.01654499f, -0.01975532f, -0.07495893f, -0.07228339f, 
    -0.06188481f, -0.04969795f, -0.05416875f, -0.02989463f, -0.00057951f, -0.04581621f, 0.04399102f, -0.04192833f, 
    -0.06468922f, -0.00565693f, -0.03940109f, -0.08083147f, -0.03240897f, -0.07463200f, -0.04650908f, -0.01894159f, 
    -0.02963774f, 0.03791370f, -0.01838021f, -0.01517647f, 0.00621731f, -0.02126290f, 0.01934120f, -0.01219815f, 
    0.00876993f, -0.07545574f, -0.01476253f, -0.01553598f, 0.02980076f, -0.06245141f, 0.02859890f, -0.01035419f, 
    0.02754377f, -0.26762420f, 0.00242994f, -0.08521192f, 0.09342936f, 0.00168723f, 0.02338773f, -0.00649040f, 
    -0.04497916f, 0.02584750f, -0.00164997f, -0.12374225f, 0.15606445f, -0.10464919f, -0.02175380f, -0.02355398f, 
    0.08289320f, 0.04813668f, -0.16971613f, -0.08643471f, -0.02022416f, -0.00639683f, 0.09039186f, 0.01291170f, 
    0.10163378f, 0.18046731f, -0.04955927f, 0.15595205f, -0.03388280f, -0.03274309f, 0.10959979f, -0.08282255f, 
    -0.01412100f, -0.14182219f, 0.11910110f, 0.00682317f, 0.03446257f, -0.05957348f, -0.04257272f, -0.20432933f, 
    0.02063794f, 0.09321776f, -0.08005541f, 0.13578825f, 0.03877462f, 0.00106758f, 0.07481519f, 0.03376114f, 
    0.12442476f, 0.10045282f, 0.05546615f, 0.06440254f, -0.02837970f, -0.04440396f, 0.02028276f, 0.08985490f, 
    -0.09080683f, 0.06669779f, 0.07540926f, -0.15224515f, 0.01594091f, 0.03986131f, 0.06323794f, 0.15251857f, 
    -0.10504392f, -0.00791012f, 0.06384737f, -0.06851786f, 0.10402963f, -0.16629870f, 0.03871283f, -0.06334255f, 
    0.09286240f, 0.00923898f, 0.10355231f, -0.18582681f, -0.07258033f, -0.08239331f, -0.03756062f, 0.10586058f, 
    0.00876486f, 0.01486685f, 0.00119243f, 0.04018173f, 0.27685064f, -0.03966467f, 0.11118568f, 0.01680518f, 
    -0.06347992f, -0.01043205f, -0.03983052f, 0.00631181f, 0.07545209f, 0.09795421f, -0.16882224f, 0.13626949f, 
    0.33978906f, -0.04888318f, -0.24654812f, 0.20090997f, 0.08605092f, 0.11012486f, 0.04101496f, 0.13608959f, 
    -0.01048590f, 0.14674878f, 0.00473764f, -0.02630659f, 0.13473360f, 0.05378541f, 0.09831997f, 0.01627594f, 
    0.02735815f, 0.17052045f, 0.05355150f, 0.11652284f, -0.07848644f, -0.03258904f, 0.11112422f, 0.20534454f, 
    0.18833357f, 0.07138203f, 0.04631400f, 0.04297834f, -0.01910691f, 0.02851522f, -0.00174728f, 0.08031579f, 
    -0.03109632f, -0.07851285f, -0.06630884f, -0.01020553f, -0.21387088f, -0.07626417f, -0.01757297f, -0.09364209f, 
    -0.04750369f, 0.05168585f, 0.01195086f, 0.11200818f, 0.10936276f, -0.01588440f, -0.03408684f, -0.15418555f, 
    0.04065417f, -0.18617360f, -0.05183268f, -0.08759644f, 0.11379472f, 0.01672047f, 0.06953222f, 0.12761094f, 
    -0.06876697f, 0.05202989f, -0.12878853f, -0.07157980f, -0.00385596f, 0.13277620f, -0.05111349f, 0.02698406f, 
    -0.16259277f, -0.12032124f, -0.13199477f, -0.05297657f, -0.07045408f, 0.00567785f, -0.02759439f, 0.05741507f, 
    0.21286687f, -0.06762166f, -0.09898610f, -0.03004577f, 0.01850397f, -0.12967768f, 0.11630371f, -0.06680541f, 
    -0.01627988f, 0.05364655f, 0.06538532f, 0.02461749f, 0.04259356f, 0.06165287f, 0.06655948f, -0.17577316f, 
    -0.11908956f, 0.01551761f, -0.01886581f, 0.14037511f, 0.00889693f, 0.04739780f, -0.03162915f, -0.03854059f, 
    0.04460548f, 0.02198303f, -0.00791727f, -0.03654622f, 0.02398560f, 0.02483300f, -0.05964871f, 0.00805965f, 
    0.02405840f, -0.02293377f, -0.07332854f, -0.07194106f, -0.04928059f, 0.04040242f, -0.00918834f, 0.04171953f, 
    -0.07075395f, 0.01123434f, -0.04884376f, -0.03925051f, -0.06466819f, -0.01656520f, -0.08197564f, 0.00883916f, 
    -0.07957643f, -0.01865201f, -0.04916969f, 0.05448938f, 0.02672611f, -0.00571396f, -0.01338379f, 0.00858109f, 
    0.01629683f, 0.00178179f, 0.01943758f, -0.00357317f, 0.04003222f, -0.00167507f, 0.06152292f, -0.01985558f, 
    0.04769226f, -0.06850872f, 0.00330451f, 0.04215768f, -0.05531614f, -0.01331290f, 0.03548842f, 0.03820392f, 
    0.03079420f, 0.02198258f, -0.06455733f, -0.04785748f, -0.07251173f, -0.07606791f, -0.01877963f, 0.00686375f, 
    0.02014548f, 0.02419109f, 0.06036467f, 0.02747599f, 0.02707765f, 0.00300526f, 0.01214588f, -0.00775085f, 
    -0.07722613f, 0.05443407f, -0.05176771f, 0.05688130f, -0.07641590f, 0.03220711f, -0.05832554f, 0.00117448f, 
    0.04951882f, -0.05825527f, -0.02375473f, 0.05808230f, 0.02287091f, 0.01190270f, -0.02942845f, 0.02800124f, 
    0.04762378f, -0.02875448f, -0.04661019f, 0.01006942f, 0.04620679f, -0.06994936f, 0.02105419f, 0.02330741f, 
    0.04087331f, -0.00614583f, -0.04559981f, 0.00763351f, -0.07881424f, 0.01501713f, -0.07918359f, -0.07724774f, 
    0.02847592f, -0.06998470f, 0.03629931f, -0.00764693f, -0.02995723f, 0.01846088f, -0.02695012f, 0.05347208f, 
    -0.05652831f, 0.01045408f, 0.06019952f, 0.02076379f, 0.00639001f, 0.03254124f, -0.02087106f, 0.02152889f, 
    0.02327351f, 0.06143987f, 0.05852509f, 0.01611570f, -0.01717701f, -0.02601897f, 0.02278147f, -0.06889203f, 
    0.02704904f, 0.02085803f, -0.07690072f, 0.03426299f, -0.00693992f, -0.05629336f, -0.06001880f, 0.00120960f, 
    -0.05990189f, -0.03778133f, -0.02729796f, -0.00140448f, -0.02618562f, 0.01561413f, -0.05124659f, 0.00465846f, 
    -0.06938532f, -0.00104727f, -0.01714072f, 0.00734319f, -0.04072089f, -0.01192597f, -0.07481581f, -0.04901555f, 
    0.00626593f, 0.06248047f, -0.05461308f, -0.07017031f, 0.01393610f, 0.01491724f, -0.04588762f, 0.01575688f, 
    0.04646056f, -0.03185284f, 0.06222739f, -0.04417536f, 0.00573817f, -0.01858026f, 0.03384106f, 0.03843607f, 
    -0.04431431f, -0.03657614f, -0.05993562f, -0.03850123f, -0.03781892f, 0.05051900f, -0.06006766f, -0.03564565f, 
    0.04208302f, 0.03780264f, 0.02098610f, -0.07322774f, 0.02014951f, -0.01988928f, -0.07393914f, -0.05756523f, 
    0.05776206f, -0.07792196f, -0.02838785f, -0.04242202f, -0.01968471f, 0.03404042f, 0.00883173f, -0.04528163f, 
    0.06046094f, -0.04020237f, 0.01529472f, -0.03215913f, 0.01587323f, 0.00223657f, -0.01221778f, -0.04838440f, 
    0.16933013f, 0.06597012f, -0.00638952f, 0.04794122f, -0.10388281f, -0.01308408f, -0.06422363f, 0.07321603f, 
    -0.06753059f, -0.10610680f, -0.13492385f, 0.21943823f, -0.39789173f, -0.14433558f, 0.11175227f, 0.00696668f, 
    -0.20074575f, -0.10865018f, 0.08066915f, -0.07258346f, 0.18742159f, 0.13434292f, -0.01679886f, -0.00324026f, 
    -0.15409669f, -0.05166157f, 0.09036475f, -0.04353473f, 0.08827231f, -0.26027554f, -0.18610938f, 0.07223015f, 
    -0.01736372f, 0.12078326f, -0.03290014f, 0.05171622f, -0.01831592f, -0.04974414f, -0.07377095f, -0.05849497f, 
    -0.09462380f, -0.01875869f, 0.04462234f, 0.06886590f, 0.04418325f, 0.09676518f, -0.11607273f, 0.07093990f, 
    -0.21200271f, -0.12152444f, 0.17095159f, -0.04118290f, 0.01908848f, -0.08788887f, -0.04561756f, -0.09090494f, 
    -0.03958366f, 0.19447795f, 0.03637709f, 0.30428550f, -0.15786681f, 0.14508991f, 0.09791262f, -0.08872704f, 
    0.03411964f, -0.00193366f, -0.05426317f, 0.03594149f, 0.03552831f, 0.17985305f, 0.08740267f, 0.10939126f, 
    -0.03238209f, 0.12357693f, -0.01837790f, -0.04143564f, 0.05440128f, 0.06335834f, 0.06944431f, 0.10811379f, 
    -0.10203820f, -0.08064738f, 0.16211417f, 0.01695058f, -0.22285749f, -0.26547730f, -0.13336954f, 0.28571221f, 
    -0.03675393f, -0.05591531f, 0.10866573f, 0.01560450f, 0.16793635f, 0.04799865f, 0.12246234f, 0.06407101f, 
    0.13200879f, 0.14222904f, -0.12708084f, 0.17452127f, 0.10082257f, 0.01368197f, -0.05224696f, 0.03147086f, 
    -0.10213742f, 0.06368913f, 0.02532196f, -0.04567046f, -0.29452786f, -0.19988011f, 0.17187610f, 0.26649499f, 
    -0.11618321f, 0.14009380f, 0.19253129f, -0.09700772f, 0.16344711f, 0.13360694f, -0.05886142f, -0.07039761f, 
    -0.26753834f, -0.29636285f, 0.06232522f, 0.06033816f, 0.07854810f, 0.03520225f, -0.02508362f, -0.07013299f, 
    0.06945656f, -0.03078823f, 0.06654826f, 0.11069387f, -0.11823986f, 0.27720335f, -0.09706423f, -0.02616234f, 
    0.01948738f, -0.02113822f, 0.06371263f, -0.06468769f, 0.11190138f, 0.20564696f, 0.18155831f, 0.15474819f, 
    0.18285246f, -0.14133461f, 0.22584535f, -0.03779929f, -0.08869742f, 0.09354300f, 0.08850689f, 0.04499675f, 
    0.03331167f, 0.15881649f, -0.00102910f, 0.15015559f, -0.06858402f, -0.00484425f, -0.01390082f, -0.12273611f, 
    -0.04269652f, 0.03495688f, 0.14202751f, 0.06426263f, 0.02470145f, -0.01764729f, 0.01197634f, 0.00735220f, 
    0.02116025f, -0.22614926f, 0.00234289f, 0.02058203f, -0.12062889f, 0.02505498f, -0.06874198f, 0.13006391f, 
    -0.06313919f, -0.10816328f, -0.08797564f, -0.00902804f, -0.11921115f, -0.20315439f, 0.19993465f, 0.01492238f, 
    0.06551371f, 0.11030744f, -0.01173563f, -0.18049300f, 0.06500402f, -0.10773831f, 0.09368636f, 0.00780841f, 
    0.25129592f, 0.21126841f, 0.25114563f, 0.09484365f, -0.07160412f, -0.05337971f, 0.05103143f, 0.13106100f, 
    -0.01918856f, -0.00955122f, -0.01737874f, 0.10069438f, 0.35085231f, 0.22137927f, 0.08834440f, 0.05382435f, 
    -0.07096084f, -0.12968452f, -0.02398431f, 0.04738558f, 0.11827917f, -0.12398896f, -0.00397412f, 0.12197277f, 
    -0.12730263f, 0.15566832f, -0.06518228f, 0.28291541f, -0.00495153f, -0.06693456f, -0.00561676f, -0.04362448f, 
    -0.01271320f, 0.04099359f, -0.05364641f, 0.08878274f, 0.42669833f, -0.15054782f, -0.07103178f, 0.10544383f, 
    -0.05681762f, -0.06555192f, -0.16211572f, 0.20011155f, 0.07199630f, 0.07140889f, 0.00005527f, -0.15699872f, 
    -0.04822147f, 0.09709685f, -0.02363772f, 0.09092686f, -0.05232520f, -0.06787281f, -0.07264640f, 0.03887066f, 
    0.04922511f, 0.03988082f, -0.05485336f, 0.12542267f, 0.13274294f, -0.00808898f, -0.32654572f, 0.06854858f, 
    0.10148824f, -0.06920598f, -0.12968524f, 0.02243673f, 0.14634004f, 0.07911632f, 0.10442296f, 0.11005835f, 
    -0.11784039f, -0.04188545f, 0.07065233f, 0.05593590f, 0.06129379f, 0.24023822f, 0.01916820f, 0.02854958f, 
    0.08419987f, -0.11806144f, 0.05855199f, 0.02272185f, -0.29244277f, 0.04732789f, -0.01790300f, -0.30684924f, 
    0.04952627f, -0.01193037f, 0.06232624f, -0.12291316f, 0.02173429f, -0.06319381f, 0.15542659f, -0.08987575f, 
    -0.17777637f, -0.05047961f, -0.08119536f, 0.06611200f, -0.08802059f, -0.03287721f, -0.12036684f, -0.11763742f, 
    -0.05857370f, -0.01276644f, 0.00528506f, 0.06064844f, -0.17043455f, -0.00037705f, -0.06949838f, 0.05241365f, 
    0.09199444f, 0.05005506f, 0.06643422f, -0.02504498f, 0.05308907f, -0.06021592f, -0.05368133f, 0.06682959f, 
    0.10563704f, -0.25448835f, -0.11863346f, 0.10482101f, 0.03867899f, -0.11383287f, 0.01435182f, -0.05227095f, 
    0.05261163f, -0.01662112f, 0.07764535f, 0.10577456f, -0.11334390f, -0.03324262f, -0.06002926f, -0.25813618f, 
    -0.07086504f, -0.04153632f, 0.14730409f, -0.16679965f, -0.02278054f, 0.17287618f, 0.10872403f, 0.13836919f, 
    -0.24112849f, 0.13200006f, 0.07581294f, -0.11501529f, -0.00751787f, 0.12629810f, 0.13536559f, 0.01988181f, 
    -0.13670410f, 0.08977294f, -0.03847750f, 0.00168734f, -0.32505834f, -0.08886527f, 0.03302396f, 0.14970836f, 
    0.07079531f, -0.08479421f, 0.12861612f, -0.02075260f, 0.20519413f, -0.12095252f, 0.02449995f, -0.03702210f, 
    0.26225361f, -0.06697892f, 0.05820474f, 0.09543534f, -0.04693589f, 0.00488901f, -0.04520307f, 0.13462558f, 
    0.09199428f, 0.04963006f, -0.15084048f, -0.06428566f, 0.06725742f, 0.20890355f, 0.06317075f, 0.19728759f, 
    0.18145512f, 0.03860590f, -0.10166328f, 0.00946451f, -0.07315635f, 0.00505381f, 0.03979492f, -0.15095153f, 
    0.11999049f, -0.11843739f, 0.08705579f, 0.05827662f, -0.06954647f, 0.05733385f, 0.06515826f, 0.07164557f, 
    -0.12897587f, 0.03842618f, -0.06466593f, 0.03490973f, 0.02176648f, -0.20534781f, 0.13286912f, -0.13975888f, 
    0.03341870f, 0.03122658f, -0.03246501f, -0.13898499f, 0.04109190f, -0.09515280f, 0.07170172f, -0.01421722f, 
    -0.03688495f, 0.08555753f, -0.08503090f, 0.14451537f, 0.02574299f, -0.00026216f, -0.01941331f, 0.03599885f, 
    -0.09311219f, 0.03604747f, 0.02091511f, -0.05521911f, 0.14395273f, 0.17465411f, 0.08426023f, 0.00059373f, 
    0.01044733f, 0.07229349f, -0.11290792f, 0.07246968f, 0.00484494f, 0.05271930f, 0.01522229f, -0.06214311f, 
    0.05554003f, -0.01821794f, 0.01119195f, 0.10292512f, -0.05729773f, -0.02376647f, -0.00415885f, 0.08317706f, 
    0.07081757f, 0.09411325f, -0.03545038f, -0.06255642f, -0.03889918f, 0.10823206f, 0.09025852f, 0.17609514f, 
    0.05606976f, 0.07684979f, -0.00691264f, 0.03125487f, -0.04046205f, 0.00537401f, 0.03215771f, 0.06933209f, 
    -0.04792146f, -0.10631962f, 0.09848657f, -0.18452817f, 0.00360691f, -0.00655591f, 0.00695010f, -0.07063781f, 
    0.03057393f, -0.11506806f, -0.12707849f, 0.04217469f, 0.27146801f, -0.10980823f, -0.10747430f, 0.15036862f, 
    0.12051443f, -0.11799040f, 0.01807669f, -0.14129250f, 0.13275452f, 0.02308165f, -0.00054734f, 0.02222263f, 
    0.40284678f, -0.08963118f, -0.17375323f, 0.01025018f, 0.00939251f, 0.06401586f, -0.03392095f, -0.04389093f, 
    -0.05347850f, 0.04810575f, 0.05200548f, 0.05024580f, 0.09112903f, 0.03792967f, -0.12554745f, -0.06245060f, 
    0.05719257f, -0.00679968f, 0.03754567f, 0.01401060f, 0.10689357f, 0.09184825f, -0.05807889f, 0.04558627f, 
    0.26998100f, -0.19844812f, -0.31992826f, 0.30146003f, 0.05106194f, -0.00203439f, -0.06952672f, 0.03303588f, 
    0.12091522f, -0.00514980f, -0.00119314f, -0.06064286f, -0.03770225f, 0.00986882f, -0.02639818f, -0.04197837f, 
    0.06402397f, -0.01954856f, 0.08601355f, -0.11954568f, 0.09836791f, 0.09626162f, 0.13080090f, -0.03039274f, 
    0.05646620f, -0.03770045f, -0.18371876f, -0.24886335f, -0.03957180f, 0.13096504f, 0.04610304f, 0.07268974f, 
    0.02058761f, 0.19056983f, -0.01922276f, 0.02301449f, -0.11385953f, -0.04674414f, 0.20769416f, -0.10564824f, 
    -0.09816461f, 0.05270356f, -0.16049789f, -0.10229074f, 0.04749326f, -0.03557909f, -0.10365159f, 0.04811548f, 
    -0.14549392f, 0.15160081f, 0.09812702f, -0.05794126f, 0.00040560f, -0.03237763f, -0.00028159f, 0.04011791f, 
    0.16811460f, -0.01300690f, -0.01276371f, 0.02562042f, 0.41763419f, -0.20062321f, 0.04480639f, 0.26642725f, 
    -0.05889132f, 0.07217230f, -0.06373727f, 0.14004879f, 0.10160547f, 0.04885750f, 0.04610789f, -0.00581200f, 
    -0.18611906f, 0.00429541f, -0.15008758f, -0.09368183f, 0.06089548f, 0.16881697f, -0.11813668f, -0.06559125f, 
    0.02862875f, -0.09076541f, 0.01436718f, -0.04850256f, 0.09623908f, 0.06853818f, -0.06692810f, 0.16299649f, 
    0.01062648f, -0.04675559f, -0.01902167f, 0.00245354f, -0.07655719f, 0.13259473f, 0.06514078f, 0.07122202f, 
    0.04502789f, -0.07273976f, 0.04062935f, 0.08568332f, 0.07569157f, 0.03978555f, 0.04880695f, -0.08613804f, 
    0.01963635f, -0.12028783f, -0.11140706f, -0.00109659f, 0.07240197f, -0.11523072f, -0.01601898f, -0.07141171f, 
    -0.05612829f, -0.08175717f, 0.03422262f, 0.01180528f, -0.05078551f, 0.09295373f, -0.00125150f, 0.08566660f, 
    -0.01589229f, -0.04811980f, 0.05779550f, -0.21455963f, 0.01333240f, 0.02502231f, 0.11450408f, 0.01937543f, 
    -0.03972098f, 0.11857858f, 0.05368652f, 0.00031044f, -0.14971122f, 0.05215611f, -0.05860401f, -0.05083141f, 
    0.03938274f, -0.06871017f, 0.12151843f, 0.11497827f, 0.16530913f, 0.06252397f, -0.07294009f, 0.01822834f, 
    0.11617393f, 0.13666897f, -0.03878771f, 0.18126760f, -0.01400593f, 0.00305310f, 0.03786572f, 0.19182383f, 
    -0.06637393f, 0.13301839f, 0.02113670f, 0.00495673f, -0.14511423f, 0.04856090f, 0.05713532f, 0.05709540f, 
    -0.01760883f, 0.19567466f, 0.00066628f, 0.08964300f, 0.03167108f, 0.07675117f, -0.11052170f, -0.01752729f, 
    -0.06163334f, 0.04709195f, -0.03448843f, 0.38910961f, 0.09091423f, -0.04902383f, 0.15448886f, 0.17937101f, 
    0.17013955f, -0.03140683f, 0.04015502f, -0.02685891f, -0.07087943f, -0.08005246f, 0.18410160f, 0.09383529f, 
    0.03341652f, 0.33889815f, -0.03630418f, 0.05090898f, 0.01544682f, -0.06178576f, 0.03915583f, 0.04130053f, 
    -0.46560973f, 0.09349523f, 0.20524298f, 0.02924720f, 0.07548541f, 0.16244021f, -0.02362357f, -0.01880718f, 
    0.03870407f, -0.02283302f, -0.03826540f, 0.07596003f, -0.08766295f, 0.08135171f, -0.08842345f, -0.14755499f, 
    0.08115811f, 0.04742141f, 0.04330439f, 0.05231493f, 0.08106500f, -0.02778789f, -0.08798404f, 0.01437439f, 
    0.01019328f, -0.07760397f, 0.25135586f, 0.11436329f, 0.14669079f, -0.03053506f, -0.05225300f, 0.01955746f, 
    0.17655316f, -0.14457725f, 0.02014896f, 0.03645836f, 0.22994427f, -0.00495337f, 0.01566507f, -0.00685094f, 
    -0.08870217f, 0.00682683f, 0.07892707f, 0.04288126f, -0.05410384f, 0.10406467f, 0.00091193f, -0.02360369f, 
    -0.05533300f, -0.24139601f, -0.07662944f, -0.02914049f, -0.04210130f, 0.05574768f, 0.07382515f, 0.09762887f, 
    -0.05676367f, 0.02576594f, 0.15592875f, 0.07600795f, -0.40232104f, 0.20573537f, -0.08064294f, -0.32487553f, 
    0.04566719f, 0.00336073f, -0.06119663f, -0.03312281f, 0.03485054f, -0.00180222f, -0.01180111f, -0.02358362f, 
    0.18502368f, -0.08463613f, -0.04196852f, -0.19167359f, -0.01206325f, -0.13807707f, -0.01661678f, -0.15554863f, 
    0.00112119f, 0.11834846f, 0.03875653f, -0.02665118f, 0.11908519f, -0.17372246f, 0.01471714f, 0.03112980f, 
    0.04860011f, 0.17376839f, -0.03392488f, -0.05078937f, -0.02150980f, 0.11074780f, 0.03186979f, -0.05261831f, 
    -0.17593911f, 0.15013604f, -0.02822703f, 0.09625059f, -0.07316434f, 0.03059917f, 0.10244038f, -0.00523750f, 
    -0.11450264f, -0.00840934f, 0.13007464f, -0.03973951f, -0.00015965f, 0.20347704f, -0.02125776f, -0.26217470f, 
    0.08430605f, 0.11092047f, -0.04600926f, 0.05909093f, 0.00535625f, -0.06876672f, 0.01302939f, 0.06809312f, 
    -0.03193507f, 0.07722449f, 0.00022324f, 0.30712888f, -0.13287483f, 0.03540408f, 0.03911548f, -0.15096125f, 
    0.05325272f, 0.03750760f, -0.03786924f, -0.08965608f, 0.16320671f, -0.11723114f, 0.08523011f, 0.03584427f, 
    -0.06459517f, -0.01636386f, -0.11367131f, -0.01153889f, -0.11462163f, -0.07245895f, 0.04212702f, -0.03889032f, 
    0.20744573f, -0.24907175f, 0.27398339f, -0.01160043f, -0.14565426f, 0.16900082f, -0.00222980f, 0.02169763f, 
    0.00482817f, -0.08287408f, -0.12146593f, 0.00978296f, 0.02661040f, -0.00044554f, 0.13450357f, 0.18789920f, 
    -0.04473481f, 0.01235770f, 0.08098801f, 0.07534111f, 0.01338112f, 0.01268188f, -0.00089528f, 0.00351633f, 
    0.05416650f, 0.01445504f, -0.10623223f, -0.14706229f, -0.01764796f, 0.10051894f, -0.03981423f, 0.04224849f, 
    -0.08636488f, 0.02382459f, 0.07076190f, -0.04612250f, 0.03162967f, -0.14952643f, 0.16645597f, -0.11547088f, 
    0.06449439f, -0.06689965f, 0.03718881f, 0.02824343f, -0.12692662f, -0.01310775f, 0.10978469f, -0.00173735f, 
    0.25521290f, -0.15675472f, -0.10265066f, 0.02001698f, -0.23235130f, 0.04157723f, 0.02319036f, -0.07051522f, 
    -0.06977569f, 0.01057569f, -0.04794165f, 0.08559377f, -0.18382938f, 0.05412740f, 0.27657956f, -0.04481476f, 
    -0.01774119f, -0.03214348f, -0.06416959f, 0.05761680f, 0.06410054f, -0.03336690f, -0.00377631f, -0.14440039f, 
    0.16203302f, -0.16171907f, 0.00750063f, 0.01627061f, -0.07152478f, -0.01684847f, 0.05032822f, 0.14597066f, 
    -0.06360982f, 0.10858309f, -0.03409250f, 0.00724149f, 0.22472334f, 0.19701722f, 0.05318015f, 0.07494229f, 
    0.02594138f, -0.01799387f, 0.00228101f, 0.01126335f, -0.00763945f, -0.00823514f, -0.04204449f, 0.00222341f, 
    0.25726917f, 0.06734355f, -0.02061522f, 0.05786560f, 0.08350231f, 0.03561815f, 0.04926216f, 0.06587171f, 
    0.07846496f, 0.01664234f, -0.12017316f, -0.01626080f, 0.20759049f, -0.10525769f, 0.17586048f, 0.23107992f, 
    -0.17305048f, 0.07930672f, 0.05829694f, 0.03165745f, 0.02798497f, -0.03857493f, 0.10187208f, -0.00650398f, 
    0.20906293f, -0.05899170f, -0.10826165f, -0.05837036f, -0.14940280f, -0.02967243f, -0.19023439f, -0.24050190f, 
    0.00263799f, 0.01683083f, -0.04399059f, 0.13943952f, 0.10782331f, 0.03311590f, -0.11656070f, 0.06388768f, 
    -0.08372363f, 0.00541808f, 0.01862339f, -0.09304662f, 0.13950433f, 0.02747525f, 0.02252805f, -0.06458656f, 
    -0.25777030f, -0.47212324f, -0.13117409f, -0.08660665f, 0.03933388f, -0.12975177f, 0.04150187f, -0.02463398f, 
    -0.04970171f, -0.11061954f, -0.03962985f, -0.17278454f, 0.09940718f, 0.07091530f, 0.09551399f, 0.05478133f, 
    -0.14756891f, 0.12161136f, -0.13227662f, 0.09290878f, 0.03590462f, 0.08838100f, 0.12610035f, 0.00394177f, 
    0.08627903f, -0.26655743f, -0.32112843f, -0.18699901f, -0.04891409f, -0.04585608f, 0.09141303f, -0.06175989f, 
    -0.02952802f, -0.03468495f, -0.05276174f, -0.03455928f, -0.11671874f, 0.04435085f, 0.22578681f, 0.01995791f, 
    0.05726437f, -0.00797973f, -0.01830333f, -0.00589534f, -0.08569756f, -0.19097593f, -0.08343498f, -0.05389027f, 
    0.14243427f, 0.27721062f, 0.16744170f, 0.13584854f, -0.05801512f, -0.03477074f, 0.13931453f, 0.17845942f, 
    -0.09960016f, 0.09735311f, 0.05812258f, 0.08973219f, 0.19146465f, -0.21987471f, -0.16513966f, -0.00405121f, 
    0.11836929f, 0.08785218f, -0.05759002f, 0.05121357f, -0.06076295f, -0.03347038f, 0.04463897f, -0.13176425f, 
    0.33554780f, -0.01443812f, 0.02578382f, 0.26438159f, -0.07481805f, 0.03162273f, 0.08440893f, 0.06231321f, 
    -0.01647822f, -0.02487874f, -0.11863296f, 0.08876429f, 0.33465156f, -0.11041292f, 0.09791254f, 0.05793504f, 
    0.01588156f, 0.23247840f, -0.05609264f, -0.01811616f, -0.01463519f, 0.02784836f, 0.03384178f, 0.00534622f, 
    -0.07988647f, -0.25545269f, -0.27215460f, -0.04251999f, 0.09748327f, 0.05906701f, -0.08119033f, 0.01062748f, 
    -0.05510079f, -0.21876840f, -0.11006893f, -0.01613440f, -0.07993828f, 0.08715612f, 0.16098990f, -0.12858607f, 
    0.13482587f, -0.06433081f, -0.06779172f, 0.13686608f, 0.03297845f, -0.01300920f, 0.02293390f, -0.14441763f, 
    0.45460626f, 0.10879485f, 0.13364218f, -0.10189537f, 0.03937935f, 0.04833811f, 0.06646010f, 0.11254130f, 
    -0.11736299f, -0.04687671f, 0.07663599f, 0.03872130f, 0.23276691f, 0.21297289f, 0.28948861f, 0.08544795f, 
    -0.12846227f, -0.12957829f, -0.01188832f, -0.05842063f, 0.04625286f, 0.05593388f, 0.06860679f, 0.11233886f, 
    0.17206515f, -0.03522791f, 0.05586831f, 0.22437839f, 0.02661112f, 0.00921864f, 0.02607863f, -0.05431001f, 
    -0.07152062f, 0.10076896f, 0.08263802f, 0.08010469f, -0.12434855f, -0.44189629f, -0.31029567f, -0.07425076f, 
    0.06598411f, 0.00338002f, -0.00087999f, 0.07126798f, 0.14503016f, -0.00584209f, -0.08911937f, -0.04962644f, 
    -0.01261112f, -0.05917875f, 0.01519765f, 0.22106655f, -0.05977470f, -0.02598201f, -0.01551437f, 0.09164817f, 
    0.04687865f, -0.06201845f, -0.05148517f, 0.01229952f, -0.57971752f, 0.02799506f, 0.15358338f, 0.02255784f, 
    -0.07271698f, -0.08517243f, 0.07043966f, -0.00029475f, 0.20152421f, 0.01655004f, -0.09288721f, -0.06070759f, 
    -0.03022420f, -0.02380080f, 0.14523570f, -0.20763944f, 0.05722050f, -0.17005704f, -0.16499668f, 0.09530145f, 
    -0.06419875f, 0.25053951f, -0.04271425f, -0.00550472f, -0.29149476f, -0.02950073f, -0.17420451f, 0.16007447f, 
    -0.05001282f, 0.09559302f, 0.17731655f, -0.03469956f, 0.10543479f, 0.06087357f, -0.06919682f, 0.10570644f, 
    -0.15754353f, 0.21996832f, 0.13944231f, 0.02683899f, 0.13213500f, -0.06121814f, -0.02636690f, -0.07822893f, 
    0.04846276f, 0.09440316f, 0.01992139f, 0.14488910f, 0.13340011f, -0.06159498f, 0.06961814f, -0.01792456f, 
    0.05379919f, 0.11202899f, 0.02530093f, 0.10830029f, -0.07479433f, 0.12818143f, 0.08758990f, 0.06889550f, 
    -0.10106786f, 0.03075458f, -0.11236523f, -0.13218783f, 0.06359556f, 0.12050509f, 0.05163054f, -0.05945355f, 
    -0.06118945f, -0.07183266f, 0.04144898f, -0.07241473f, -0.26250839f, -0.20610748f, 0.10538641f, 0.14748093f, 
    0.03402380f, -0.12233379f, 0.13184184f, 0.02244063f, 0.11218953f, -0.13013992f, 0.10283914f, 0.01654241f, 
    0.11361355f, -0.16957697f, -0.04442146f, -0.14644453f, 0.06951135f, 0.10121375f, -0.10585571f, 0.00034838f, 
    -0.10049058f, 0.01406291f, 0.06890660f, 0.05720992f, -0.25164977f, -0.10154595f, 0.04790446f, 0.16236891f, 
    -0.04748378f, -0.05538576f, 0.09488454f, -0.03313878f, 0.14766009f, 0.08090718f, 0.03938973f, -0.09374944f, 
    0.00728325f, 0.04469756f, 0.05523369f, 0.07275461f, 0.06394289f, -0.02157554f, -0.05807428f, -0.00435570f, 
    -0.05555068f, -0.01598200f, 0.11063097f, 0.03414936f, 0.00059145f, 0.11242241f, 0.01051836f, 0.05458165f, 
    0.06103408f, 0.01423870f, 0.15053023f, 0.02724016f, -0.03003864f, 0.14580761f, 0.05499410f, 0.03427919f, 
    0.00410136f, -0.07917035f, -0.10524739f, -0.01046641f, 0.04316228f, 0.03065837f, 0.13969554f, -0.06034473f, 
    0.00972666f, 0.08445305f, 0.09946850f, -0.08205864f, -0.05238137f, -0.07106960f, -0.03410807f, -0.12301838f, 
    0.00530359f, 0.06654107f, 0.10213318f, -0.03083611f, -0.09785354f, -0.03873271f, -0.00518471f, 0.06100126f, 
    0.03531787f, -0.03748054f, 0.03111422f, 0.04142760f, 0.06165440f, 0.03294311f, 0.01744167f, 0.04057756f, 
    -0.01339210f, -0.07793125f, -0.03018281f, 0.05722492f, 0.00289220f, 0.05602340f, 0.27544177f, 0.05100945f, 
    0.03219045f, 0.01268759f, -0.05353422f, -0.01152855f, 0.13391644f, -0.03759594f, 0.12303550f, 0.03041594f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.08220293f, 0.05802859f, 0.12312499f, -0.05661912f, -0.01062941f, 0.02402334f, 0.00281788f, 0.12833756f, 
    0.02629621f, 0.02962681f, 0.13681281f, -0.02450662f, 0.11520446f, 0.03505733f, -0.01070974f, 0.02247856f, 
    0.01661814f, 0.06719340f, 0.03015877f, 0.05834652f, 0.12928309f, -0.00021025f, 0.01543600f, 0.02672808f, 
    -0.08921738f, 0.04789088f, -0.01263942f, -0.01072321f, 0.07998749f, 0.01314322f, 0.09467561f, 0.09261119f, 
    -0.02404420f, 0.02887480f, 0.01351065f, 0.07147603f, 0.01964071f, -0.02986292f, -0.06606553f, -0.06340482f, 
    0.18032175f, -0.00350318f, 0.05103556f, 0.02590749f, -0.07578778f, 0.03686559f, 0.02385294f, 0.08073719f, 
    0.03563952f, 0.08876762f, 0.03678088f, -0.04155156f, -0.03350604f, 0.00439108f, -0.05480304f, -0.04512982f, 
    -0.07441898f, -0.01959631f, -0.06222356f, -0.07078113f, -0.01194911f, 0.11007781f, 0.11393531f, 0.05048732f, 
    0.07723115f, -0.04195387f, -0.00486185f, 0.12496652f, -0.04606911f, 0.09125000f, -0.05117095f, 0.05658102f, 
    0.06144860f, 0.05779105f, -0.00409739f, -0.03353840f, 0.06124594f, 0.05562193f, 0.01419144f, 0.02443375f, 
    -0.09545226f, -0.00243388f, 0.04376828f, 0.11033170f, 0.08428609f, 0.02859067f, -0.10622690f, 0.01663022f, 
    -0.06934693f, -0.01428155f, -0.07237709f, -0.07351997f, -0.05218074f, 0.05974684f, 0.05868804f, 0.04808590f, 
    0.00674924f, -0.01895990f, -0.01971556f, 0.02730416f, 0.05610185f, -0.03042471f, -0.05010799f, -0.06513450f, 
    -0.07317016f, -0.00175450f, -0.06058938f, 0.02029813f, -0.01348600f, -0.03100825f, -0.04880531f, 0.08267161f, 
    0.00871710f, 0.06758405f, -0.09530111f, 0.06143485f, 0.09437428f, 0.05396736f, -0.03890789f, -0.04296901f, 
    0.01702716f, 0.11707594f, -0.00394080f, 0.06928460f, 0.08677544f, -0.03434332f, 0.08584613f, 0.04845980f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.29733676f, -0.02330775f, -0.01546429f, 0.24015228f, 0.04602749f, 0.10249923f, -0.04545655f, -0.49179617f, 
    0.05243487f, 0.02112476f, -0.04351589f, 0.18734331f, 0.06742889f, -0.18633515f, 0.13965565f, -0.02798876f, 
    0.08458672f, 0.06891936f, 0.02629367f, 0.32054913f, -0.17404039f, -0.01651163f, -0.05713787f, -0.00432369f, 
    0.16315591f, -0.07751989f, -0.00253512f, 0.09144162f, -0.18701687f, 0.09372988f, -0.44305336f, 0.03469502f, 
    0.20948710f, -0.24700628f, -0.07029929f, 0.18547811f, -0.59336847f, -0.03967043f, 0.19376911f, -0.03790309f, 
    0.02148237f, 0.05526360f, -0.32669055f, 0.00861750f, -0.04256901f, 0.04505197f, -0.18379298f, -0.70002460f, 
    -0.45114362f, 0.19960921f, -0.09507718f, -0.10418738f, -0.06451986f, 0.13257030f, -0.07325606f, -0.06626140f, 
    -0.00469011f, 0.07811213f, 0.31755185f, 0.31594157f, 0.08959486f, -0.48740464f, 0.05966242f, -0.47713703f, 
    -0.28486085f, -0.30889863f, -0.21732935f, -0.41495177f, -0.08129141f, 0.14216103f, 0.05791158f, -0.04470007f, 
    0.29212025f, 0.07316489f, -0.46138355f, 0.30606595f, -0.06029465f, 0.05117998f, -0.07462864f, 0.00323899f, 
    -0.09766523f, 0.23799218f, 0.13661544f, -0.11351123f, 0.07449140f, 0.08138952f, -0.16496210f, 0.15340459f, 
    -0.02788573f, 0.11474524f, 0.00964140f, -0.00200649f, 0.02752236f, 0.14102066f, -0.05038799f, 0.05826909f, 
    0.02020208f, 0.04017399f, -0.00595408f, -0.21162060f, 0.33814418f, -0.04120257f, 0.02746118f, -0.01253064f, 
    0.00229368f, -0.08969218f, -0.01322667f, 0.04979981f, -0.43269745f, -0.05571567f, -0.03572964f, -0.02536961f, 
    0.27469951f, 0.09851155f, 0.04942795f, -0.41839465f, 0.09793439f, -0.04098784f, -0.00478980f, 0.04690561f, 
    0.01468409f, -0.38192847f, -0.00085677f, 0.03265222f, 0.00277049f, 0.20395048f, -0.93404019f, -0.41812679f, 
    0.05925026f, 0.00234261f, 0.19377030f, 0.11195997f, 0.06012297f, 0.15175816f, 0.23606126f, -0.21723227f, 
    0.04837444f, 0.10901663f, 0.16262941f, 0.06878141f, -0.00201738f, 0.10486428f, 0.08601300f, 0.04107951f, 
    0.07693978f, 0.18610387f, -0.02528279f, -0.31395045f, -0.18553722f, -0.05160653f, 0.22646482f, -0.12092720f, 
    0.19902630f, 0.04118215f, 0.07297623f, 0.01592795f, -0.34563303f, -0.07073101f, 0.09212443f, -0.13536911f, 
    0.13829347f, 0.19128959f, -0.00659639f, -0.23105541f, -0.08162131f, 0.07385137f, -0.05725036f, 0.03297046f, 
    -0.31182358f, 0.11463103f, -0.35012454f, -0.14090993f, 0.08716480f, -0.07247334f, 0.06493914f, 0.08055422f, 
    0.34312111f, 0.21379042f, 0.08907885f, -0.30604762f, 0.01577438f, 0.29371992f, 0.10509846f, -0.04401806f, 
    -0.13624534f, -0.04884252f, 0.05435509f, 0.13264421f, -0.34178922f, -0.08651002f, 0.01518809f, -0.23357527f, 
    -0.16372117f, 0.09012622f, -0.27185392f, -0.20693710f, -0.28460002f, -0.32149380f, -0.05951409f, -0.03791098f, 
    -0.40496677f, -0.23298560f, 0.20601070f, -0.07736225f, 0.14713828f, 0.03566096f, -0.25749639f, 0.04094690f, 
    -0.07697649f, -0.47471029f, 0.17039241f, 0.07166947f, -0.17503016f, 0.01784042f, 0.11143743f, -0.07529548f, 
    0.25033781f, -0.11613213f, -0.06481201f, -0.03133315f, 0.00674318f, 0.12437162f, 0.03000803f, 0.02100720f, 
    0.05739833f, 0.05406262f, 0.22299214f, -0.09915845f, 0.13758227f, -0.07464451f, 0.00566749f, -0.07651398f, 
    -0.00268038f, 0.00786383f, -0.03740242f, -0.36867049f, -0.21609569f, -0.05283165f, -0.02263874f, 0.03161650f, 
    -0.07658619f, -0.56060541f, -0.05367989f, -0.13206790f, 0.05379149f, 0.08304078f, -0.05420798f, 0.24203508f, 
    -0.07042316f, 0.03946301f, 0.10944543f, 0.22256579f, -0.28470954f, 0.26640126f, 0.36748332f, 0.02260835f, 
    0.13088769f, 0.04370365f, -0.36321005f, -0.11375587f, -0.03280810f, 0.07838971f, 0.13161181f, -0.33618212f, 
    0.00467949f, -0.21554062f, -0.18986082f, -0.08365152f, 0.01812184f, 0.04575739f, 0.06287854f, -0.33087876f, 
    0.00698786f, 0.14028297f, 0.08483060f, 0.38284475f, -0.17854112f, 0.04958533f, -0.11855228f, -0.42218500f, 
    0.06927945f, 0.01682954f, 0.01931444f, 0.16191301f, -0.34669521f, 0.12051191f, 0.12309735f, 0.04539640f, 
    0.14638387f, 0.23239329f, 0.02442646f, -0.32516399f, -0.07630789f, 0.07104052f, -0.31845120f, 0.08289149f, 
    -0.22452867f, -0.14593536f, 0.18696417f, 0.09087270f, -0.03014337f, 0.05437025f, 0.20475599f, 0.13836654f, 
    0.43230498f, -0.31594974f, 0.04067331f, 0.08992068f, 0.06651380f, 0.04926557f, 0.22899765f, -0.07389200f, 
    -0.04914680f, -0.07404748f, -0.24309583f, 0.03206576f, 0.12313636f, 0.23178755f, -0.35597363f, 0.02438850f, 
    0.11291039f, -0.00977011f, 0.04348455f, 0.02231941f, -0.02346077f, 0.00428115f, -0.06816610f, -0.10797513f, 
    0.01795380f, -0.28834876f, -0.32218239f, 0.18285583f, 0.09219745f, -0.41571519f, -0.19940513f, 0.04791636f, 
    -0.03529278f, 0.36176631f, 0.06753908f, 0.16263606f, 0.12123463f, 0.02040695f, 0.09861915f, -0.12007654f, 
    0.03571602f, -0.32005093f, -0.04984291f, -0.00598617f, 0.01573232f, -0.20148379f, 0.07707769f, 0.05434075f, 
    0.02760163f, -0.09468285f, 0.01580359f, -0.25244632f, -0.27704242f, -0.08960243f, -0.47437626f, -0.02439881f, 
    0.05484061f, 0.06060318f, -0.02452949f, 0.18331723f, 0.05102830f, 0.08078364f, -0.09621016f, -0.05519827f, 
    -0.33263379f, 0.20264646f, 0.26781869f, 0.21490909f, -0.16453716f, 0.02974928f, -0.03453048f, -0.09117097f, 
    0.03638615f, -0.28589875f, 0.18486373f, -0.01903235f, -0.35332692f, 0.06256210f, -0.31437176f, 0.10882304f, 
    -0.36136511f, 0.04702464f, 0.00718325f, 0.10832139f, -0.07797204f, 0.04169581f, -0.05586861f, -0.11312442f, 
    0.08068427f, 0.11570764f, 0.14221357f, -0.34743086f, -0.77922469f, 0.17318638f, 0.10892568f, 0.11088522f, 
    0.03674833f, -0.26985070f, 0.07451129f, -0.10500179f, 0.17059559f, 0.03207969f, 0.17407037f, 0.26551810f, 
    -0.22580032f, -0.03138325f, 0.06635711f, -0.07148264f, 0.21881451f, 0.05176087f, 0.03060262f, 0.12580267f, 
    0.13522169f, -0.18670076f, 0.01304162f, 0.37054265f, -0.23901366f, 0.07376888f, 0.04555872f, -0.36737156f, 
    -0.17114441f, -0.17553268f, 0.21199372f, -0.18798728f, -0.05274235f, -0.03938514f, 0.03031887f, -0.12424959f, 
    0.03877291f, 0.09668408f, -0.13813874f, 0.07788931f, 0.03451285f, -0.10940275f, 0.16289365f, 0.04750980f, 
    -0.36271378f, 0.05359996f, -0.15538341f, -0.07150947f, 0.08140080f, 0.13484827f, -0.04553167f, 0.11908560f, 
    0.02941998f, 0.35699922f, -0.07711983f, 0.11215500f, -0.43912479f, -0.05605801f, -0.05931628f, -0.10283486f, 
    0.26542944f, 0.15494141f, -0.02809437f, -0.08664446f, -0.28017485f, 0.16141602f, 0.08438163f, 0.03435619f, 
    -0.08480766f, 0.03145289f, 0.20488854f, -0.30726087f, 0.24021156f, -0.04357504f, -0.39991727f, 0.08426961f, 
    -0.29791015f, 0.14949290f, 0.04769061f, 0.05854997f, 0.01547046f, -0.10825416f, -0.06590243f, -0.07951456f, 
    -0.00188773f, 0.02025789f, -0.08084338f, -0.55330926f, -0.15899336f, -0.07615399f, 0.05187267f, 0.00728471f, 
    0.04468518f, 0.03794071f, -0.06520185f, -0.27150360f, 0.14304227f, -0.01110314f, -0.06749275f, -0.34026653f, 
    0.02393719f, 0.10326228f, -0.25433075f, 0.17325316f, -0.30710176f, 0.05329974f, -0.01209319f, 0.06668468f, 
    0.03933619f, 0.10348282f, -0.48961166f, 0.01398128f, 0.07952652f, 0.16999651f, 0.18223828f, -0.05171860f, 
    0.09783252f, -0.08783221f, -0.12791902f, 0.15435153f, 0.06067366f, -0.13667038f, 0.14885870f, -0.11406199f, 
    0.06604064f, -0.13172829f, -0.14856865f, -0.14296138f, 0.17945975f, -0.20712915f, -0.04573499f, -0.38002041f, 
    0.03412006f, 0.17579038f, -0.03031896f, -0.29094946f, -0.04704836f, 0.07863696f, 0.09742124f, 0.16670391f, 
    0.15585962f, 0.07519923f, 0.00258239f, -0.07470538f, 0.13446665f, -0.16208693f, -0.26919946f, 0.12484697f, 
    -0.26060551f, -0.09671658f, -0.11887292f, 0.35123268f, -0.33551642f, 0.01977106f, 0.06062954f, -0.23972824f, 
    -0.26549223f, -0.01014598f, 0.16368505f, -0.48697266f, -0.12191651f, -0.04935392f, 0.23301916f, -0.22362036f, 
    -0.25991952f, 0.15661204f, -0.00801805f, -0.10320535f, -0.05480286f, -0.14720570f, -0.30627504f, 0.07614647f, 
    0.26382384f, 0.00484944f, 0.02569755f, -0.08045860f, -0.37831730f, -0.01681285f, 0.08791146f, -0.13941196f, 
    -0.06071739f, 0.09781504f, 0.09816168f, 0.09457120f, -0.01064921f, 0.13879034f, -0.04897118f, 0.03752564f, 
    0.23875363f, 0.21198155f, 0.44881970f, 0.03434001f, -0.05537671f, 0.14544688f, 0.22273090f, 0.04874884f, 
    0.00411531f, 0.12120970f, 0.01981528f, 0.06446993f, 0.28521544f, -0.09099583f, -0.06295840f, 0.16261341f, 
    0.02992431f, 0.15400703f, -0.03163015f, -0.00495731f, -0.03926286f, 0.00205709f, 0.07648839f, -0.09058898f, 
    0.01165874f, -0.00055093f, -0.20221369f, -0.00219247f, -0.24810064f, 0.01600004f, -0.22254971f, 0.04185346f, 
    0.00784122f, -0.04423898f, -0.01593040f, -0.23038636f, 0.26083848f, 0.06560445f, 0.04389333f, -0.31363952f, 
    0.20689797f, -0.02795849f, 0.15286174f, 0.23988001f, -0.08696685f, -0.00117565f, -0.06728834f, -0.13799275f, 
    -0.01082536f, -0.01315251f, 0.00817379f, 0.01235777f, -0.02137348f, -0.11991019f, -0.17920361f, 0.07070418f, 
    0.02575025f, 0.06211134f, 0.25745302f, 0.19011578f, -0.07851083f, 0.19495983f, -0.28716218f, 0.04333995f, 
    -0.03817812f, -0.35880989f, 0.14815156f, 0.16542816f, 0.11243755f, 0.16281101f, -0.24926455f, 0.19081646f, 
    0.04154384f, 0.23814227f, 0.05543425f, -0.30016732f, 0.25227672f, -0.03365704f, -0.35455960f, -0.01351033f, 
    0.05913974f, 0.07579399f, -0.03166062f, -0.12886618f, -0.00289190f, 0.03045834f, 0.19464640f, -0.20946315f, 
    0.04854547f, -0.21014260f, -0.29704288f, -0.11742239f, 0.32551658f, 0.08404892f, 0.21996002f, 0.24327736f, 
    -0.05479600f, 0.21829645f, -0.13500097f, 0.32732618f, -0.02403996f, 0.07239149f, 0.04135685f, -0.05718446f, 
    -0.49094221f, -0.05012014f, 0.03009888f, -0.11137386f, 0.06772676f, -0.10243893f, -0.19383146f, 0.06258579f, 
    0.02597438f, 0.03099348f, 0.17888102f, -0.23665971f, 0.04206018f, 0.09800737f, 0.18368770f, -0.23330061f, 
    -0.17223366f, 0.05245359f, -0.01201444f, -0.10466208f, 0.20893443f, -0.19217296f, -0.04852377f, -0.11715811f, 
    -0.40340510f, 0.06922985f, -0.57426029f, 0.06356912f, -0.03991888f, 0.04524916f, -0.04659805f, -0.07004254f, 
    0.06981497f, -0.26413944f, -0.42205891f, -0.00189587f, -0.03050071f, -0.05661280f, 0.02175220f, 0.10237936f, 
    -0.19472460f, 0.13717638f, -0.03827713f, -0.09049647f, -0.05320546f, 0.03190370f, -0.01116905f, -0.02706036f, 
    0.04173065f, -0.00661925f, -0.07471601f, 0.12249568f, 0.05640563f, 0.07412186f, 0.22736865f, 0.00547939f, 
    0.08102692f, 0.07690527f, 0.00048950f, 0.01384219f, 0.06599189f, 0.06981874f, -0.02343893f, 0.28781158f, 
    -0.00614801f, -0.27774248f, -0.57634854f, -0.33549064f, 0.08243653f, 0.05890965f, -0.03599456f, -0.18411453f, 
    -0.04364603f, 0.07878951f, -0.00989518f, -0.21555695f, -0.05837031f, 0.05253603f, 0.15031083f, 0.10541316f, 
    -0.33534345f, -0.02750584f, -0.06605634f, -0.21319416f, 0.07535905f, -0.15224367f, -0.40032968f, 0.09210481f, 
    -0.02913982f, 0.24756664f, 0.15502954f, 0.14243723f, -0.04283906f, 0.28716716f, -0.07902358f, -0.61638415f, 
    0.06755672f, -0.23635550f, -0.05241156f, 0.11509892f, -0.39657432f, 0.00127501f, -0.23549843f, 0.04115782f, 
    -0.06322382f, 0.05927178f, 0.02685747f, 0.12429325f, 0.17888942f, 0.23022489f, -0.50417870f, -0.33273593f, 
    -0.35192049f, 0.16671030f, -0.10345045f, -0.28335822f, 0.07204737f, 0.00505308f, -0.13824131f, 0.23246902f, 
    0.22338842f, -0.00731874f, -0.01823291f, -0.29667941f, -0.52328330f, 0.08820885f, -0.60339409f, -0.04453487f, 
    0.32558280f, -0.26374879f, 0.15310842f, -0.26729581f, -0.07498319f, -0.09176769f, 0.09663090f, 0.05052796f, 
    0.09432632f, -0.00559660f, -0.24290480f, -0.22911640f, 0.06388599f, 0.16742054f, -0.22576548f, 0.34529424f, 
    0.22140945f, -0.44569460f, 0.09099820f, 0.30488557f, 0.07081380f, 0.11986176f, -0.09019978f, -0.17198852f, 
    0.03313944f, 0.09825497f, -0.09647349f, -0.13867445f, -0.06217787f, -0.06430362f, -0.02844365f, 0.04005104f, 
    -0.02359794f, -0.15001129f, 0.03074672f, 0.19466648f, -0.07253437f, -0.06908020f, 0.21601866f, -0.22122599f, 
    0.14015850f, -0.09984705f, 0.06249963f, 0.05866594f, -0.02895714f, 0.18358427f, 0.02803105f, 0.03843182f, 
    0.02681435f, -0.06047300f, -0.12561847f, 0.21912900f, -0.42211747f, -0.00435756f, -0.09065729f, -0.02775814f, 
    -0.05592554f, 0.04309011f, 0.01630801f, 0.15411501f, -0.12954284f, -0.07100237f, 0.04219202f, 0.16370994f, 
    0.01632835f, 0.13291240f, 0.15806124f, 0.03802241f, 0.15354386f, -0.00756887f, 0.01638564f, 0.19237775f, 
    -0.04731638f, -0.13978831f, -0.52853853f, -0.17632818f, 0.22813354f, -0.04386223f, 0.30641675f, 0.02089055f, 
    0.10256409f, 0.05924685f, -0.29317588f, -0.14130628f, 0.06213958f, -0.31963524f, -0.11715218f, 0.24714459f, 
    -0.03240845f, -0.01994791f, -0.33483401f, -0.05729346f, -0.23495449f, 0.12448981f, -0.00236695f, 0.21891038f, 
    0.00825167f, -0.18507256f, 0.03010735f, 0.08063118f, 0.23857903f, -0.07787008f, -0.07811107f, -0.09497960f, 
    0.18481104f, -0.03898005f, -0.02078955f, -0.09323645f, 0.08552472f, -0.31273329f, -0.18834950f, -0.18891169f, 
    -0.31728965f, -0.13458839f, -0.08915441f, -0.34174490f, 0.17931767f, -0.09536102f, 0.21315582f, 0.15438108f, 
    -0.06602772f, -0.24015965f, 0.23866309f, 0.19993670f, 0.15937598f, 0.02299571f, -0.05240129f, 0.28540069f, 
    0.08866933f, -0.27187261f, -0.30004361f, 0.20700441f, -0.01831801f, 0.04580993f, 0.25200400f, -0.08188652f, 
    0.05107307f, -0.03436344f, 0.12725756f, 0.11315504f, 0.13853788f, -0.06832500f, 0.01522665f, 0.13586275f, 
    -0.27700263f, -0.04254963f, 0.03295443f, -0.03485453f, 0.23708241f, 0.15318431f, -0.04627329f, -0.48335770f, 
    0.03853690f, -0.03746944f, 0.34088340f, 0.26905647f, -0.32305035f, 0.19459109f, 0.23794104f, -0.01311168f, 
    -0.03027023f, 0.16143045f, -0.19604087f, -0.12281796f, -0.24804924f, 0.03172472f, 0.26021197f, -0.23990712f, 
    0.02859788f, -0.20820644f, 0.04152962f, -0.07621300f, -0.03328269f, -0.34985828f, 0.01938580f, 0.00302820f, 
    0.03607075f, -0.03796737f, -0.30689585f, -0.12981273f, -0.30702123f, -0.09078157f, 0.24834421f, -0.08357295f, 
    -0.05455424f, 0.02425382f, -0.01712093f, -0.03863214f, 0.18075027f, 0.01365741f, 0.03909309f, -0.28619677f, 
    -0.27164495f, 0.23472093f, 0.23484109f, 0.08501138f, -0.21674736f, 0.09122418f, -0.05141643f, -0.30957526f, 
    -0.00069933f, -0.31051448f, 0.02099219f, -0.24031445f, -0.14328179f, 0.11364264f, -0.12790038f, -0.24084988f, 
    0.04680950f, -0.06803957f, 0.09114006f, 0.03368266f, 0.00378511f, 0.01425588f, -0.13635938f, -0.11483068f, 
    -0.04133634f, 0.27093318f, 0.08934949f, -0.19710499f, 0.09491547f, -0.31381196f, 0.22833052f, 0.12756129f, 
    -0.05163678f, -0.24804004f, -0.07251499f, -0.28936100f, -0.37117943f, -0.03607387f, -0.27049521f, -0.17543681f, 
    -0.14791153f, -0.05018286f, -0.02483352f, -0.45440432f, 0.15102372f, 0.07385985f, 0.14757752f, 0.09309538f, 
    0.08123144f, -0.20594746f, -0.19768016f, 0.09419285f, 0.30191073f, -0.00046452f, 0.03597427f, 0.13955028f, 
    -0.29167506f, 0.04732578f, -0.06837816f, 0.07659597f, 0.25518170f, 0.01819539f, 0.18527111f, 0.16723360f, 
    -0.11417106f, -0.30785778f, -0.01221271f, 0.20333903f, 0.03780600f, 0.01495108f, -0.01958857f, 0.03601469f, 
    0.06032599f, 0.07170026f, -0.04083067f, -0.15666477f, 0.22501175f, -0.27603471f, -0.24313062f, -0.11850127f, 
    0.19779353f, -0.21285062f, 0.21042171f, 0.09672870f, 0.12560382f, -0.19648448f, -0.09211903f, 0.07935851f, 
    -0.06131738f, -0.36358932f, 0.15250175f, -0.19244081f, -0.04406070f, -0.20172991f, -0.28098813f, 0.03813491f, 
    -0.01761786f, 0.19743639f, -0.04014878f, -0.18224800f, -0.21670909f, 0.00797313f, 0.19623548f, 0.33081418f, 
    0.09156679f, -0.17487198f, -0.02480697f, -0.06236771f, -0.04473780f, -0.21492290f, -0.00521631f, -0.01161857f, 
    -0.07218479f, -0.03319621f, 0.05082106f, -0.04195282f, 0.07549535f, -0.03270722f, 0.16842161f, -0.02981061f, 
    0.04819705f, -0.08893217f, -0.03030148f, -0.30971807f, -0.14778820f, 0.02096229f, -0.06047210f, -0.13180967f, 
    -0.02291371f, -0.06644154f, 0.18793756f, -0.21451427f, 0.03548267f, -0.03403242f, 0.05364383f, -0.34160164f, 
    -0.07721624f, 0.13072653f, 0.16077314f, 0.19740725f, -0.17783739f, -0.20003150f, 0.03329645f, 0.11197980f, 
    0.30838323f, 0.06719528f, -0.28178993f, -0.48654002f, -0.09273518f, 0.13709082f, 0.20719783f, 0.11466221f, 
    -0.03413142f, 0.10265487f, 0.02194628f, 0.15813309f, 0.20115466f, -0.40590370f, -0.46740764f, 0.04898309f, 
    -0.00747186f, 0.23797931f, -0.00154572f, 0.07791726f, 0.21689554f, -0.00916790f, 0.04525158f, -0.17531337f, 
    -0.28826153f, -0.00834955f, -0.06696686f, 0.19024071f, 0.12509936f, -0.42301008f, -0.14083636f, 0.06888553f, 
    0.14330310f, -0.16531250f, -0.21431832f, -0.15604462f, 0.07157967f, 0.04726931f, 0.08788246f, -0.18456812f, 
    0.46210986f, -0.25258255f, -0.08973001f, 0.32260594f, -0.18782252f, -0.01454241f, -0.42299676f, -0.00884933f, 
    -0.19099870f, -0.52606499f, -0.10500234f, 0.17720936f, -0.04591384f, -0.40643677f, -0.18422411f, 0.07864150f, 
    -0.12846300f, -0.04823322f, -0.13459857f, -0.05126505f, -0.32946607f, 0.02005284f, -0.14927982f, 0.29690880f, 
    0.05186481f, -0.24852684f, 0.18433379f, -0.15024316f, 0.13996132f, 0.16676283f, 0.01259298f, 0.04084295f, 
    -0.04293118f, -0.01068989f, 0.01042944f, -0.09738089f, 0.16159809f, -0.21695191f, 0.15395334f, -0.08020642f, 
    0.03232338f, 0.03752707f, -0.14036632f, 0.15162545f, 0.28302544f, -0.09288161f, -0.11804020f, -0.27835628f, 
    0.00880830f, 0.18510437f, 0.04328676f, 0.07693074f, -0.00478494f, 0.15530463f, 0.02371033f, 0.00798908f, 
    -0.04491318f, 0.05546200f, -0.17926474f, 0.10205844f, 0.14069244f, 0.04178014f, 0.04276057f, -0.05842408f, 
    0.03982530f, -0.06929690f, 0.04220964f, 0.11834928f, -0.16657937f, 0.00417053f, -0.05592918f, 0.03999831f, 
    -0.50705034f, 0.06189553f, -0.42672196f, -0.27339742f, 0.08363289f, 0.03065984f, 0.04167204f, 0.11618040f, 
    -0.08829233f, -0.16855049f, 0.23113786f, -0.24379136f, 0.27260458f, -0.28963295f, -0.35902789f, -0.25669485f, 
    -0.13258931f, 0.05174590f, 0.12795047f, -0.07161564f, 0.00996939f, -0.37418965f, 0.01591774f, 0.10087300f, 
    0.07787690f, -0.43111461f, 0.06960113f, -0.44543421f, -0.51825547f, -0.34436381f, -0.00728936f, 0.12126988f, 
    0.07223709f, -0.30398759f, 0.06608216f, 0.08968715f, 0.30085620f, 0.04241093f, 0.26006955f, -0.19850771f, 
    -0.34649852f, 0.06142510f, -0.01249485f, 0.16332011f, -0.30529338f, -0.13385215f, 0.36115536f, -0.05620982f, 
    -0.05356126f, -0.41162142f, 0.33800647f, -0.53575426f, -0.11579384f, 0.00414306f, -0.33262855f, -0.27681500f, 
    0.45596611f, 0.02208412f, -0.07420689f, 0.13565588f, 0.10134249f, 0.04078415f, -0.16723362f, 0.04252182f, 
    0.34413376f, 0.21375015f, -0.07883347f, 0.10370735f, 0.08114703f, 0.04782247f, 0.13300127f, -0.01063526f, 
    -0.23528790f, -0.03717086f, -0.31403890f, -0.30329874f, -0.03370305f, 0.24449456f, 0.29437259f, -0.24834047f, 
    0.10893977f, -0.23660170f, -0.40648332f, 0.29789180f, 0.08486947f, 0.06556953f, 0.05798641f, 0.12383835f, 
    -0.30640459f, -0.00159646f, -0.08136382f, 0.02627626f, 0.07837237f, -0.00571711f, -0.04938157f, -0.03026082f, 
    0.03096368f, -0.22635970f, 0.02232022f, -0.05870501f, -0.30292076f, -0.08411434f, -0.10523666f, -0.36428976f, 
    -0.13444296f, -0.49913037f, -0.01751929f, 0.01828812f, 0.05477868f, -0.13007331f, 0.04381678f, 0.06416824f, 
    0.03214337f, 0.07159400f, 0.19858839f, 0.01455759f, 0.21575898f, 0.00357279f, -0.01026271f, -0.01213534f, 
    -0.02243846f, -0.02695000f, -0.05908981f, 0.37954384f, 0.01111786f, 0.00428847f, -0.02005056f, 0.22943906f, 
    -0.25528574f, -0.29184893f, 0.06306621f, 0.14457192f, -0.36397630f, -0.05176610f, 0.05500658f, -0.16228192f, 
    0.04099253f, 0.37468889f, 0.05637745f, -0.05535365f, 0.28227201f, -0.08854355f, 0.08417163f, 0.07168809f, 
    -0.24287683f, 0.03142195f, 0.16127080f, -0.23585382f, 0.01716596f, -0.02325322f, -0.15705866f, 0.21125561f, 
    0.01590671f, 0.12182711f, 0.18400344f, -0.22395806f, -0.00873887f, 0.10242307f, 0.11415411f, 0.00247294f, 
    0.01771031f, -0.49854654f, 0.03366076f, 0.11307304f, -0.16124663f, -0.09330621f, -0.05841916f, 0.14530027f, 
    -0.15414447f, -0.02234956f, -0.06171008f, -0.23230682f, -0.05915495f, 0.23227172f, -0.02187105f, 0.19983435f, 
    -0.21224999f, 0.56444120f, 0.20232753f, 0.02183053f, -0.10880239f, 0.08659858f, -0.51042622f, -0.31059119f, 
    -0.30527174f, 0.06595212f, -0.03578839f, -0.06785212f, 0.11590376f, 0.00963758f, 0.10489087f, 0.26091510f, 
    -0.23642939f, 0.06322916f, -0.06505306f, 0.16887932f, -0.05788499f, -0.30263895f, -0.42117083f, -0.04744701f, 
    0.22437148f, -0.05330507f, -0.07367987f, 0.20522657f, 0.31079423f, -0.09241907f, 0.10288900f, 0.24560003f, 
    0.20281167f, 0.38447016f, 0.16563204f, -0.11289948f, 0.04438365f, -0.01815562f, 0.01936664f, 0.27325112f, 
    0.03678677f, 0.04943557f, -0.27035925f, -0.43498501f, 0.01260128f, -0.00475546f, -0.09584109f, 0.01465145f, 
    -0.02850717f, -0.30056053f, -0.24709417f, -0.07156131f, -0.20979822f, -0.03468974f, -0.18599035f, -0.22710921f, 
    -0.40483272f, 0.07201543f, -0.08528269f, -0.09295524f, 0.08175124f, 0.16189215f, -0.01763117f, -0.01956618f, 
    0.05993387f, -0.02159677f, 0.01843736f, 0.18583190f, -0.11668500f, -0.06768836f, 0.03774294f, -0.01131360f, 
    -0.03043824f, -0.03072903f, -0.03360164f, 0.22670376f, 0.15539226f, -0.00116356f, 0.03450930f, -0.27051461f, 
    0.27633235f, 0.18464616f, -0.01078626f, 0.17111582f, -0.09188303f, -0.04022002f, -0.00498928f, 0.03908814f, 
    -0.07594299f, -0.21497381f, -0.36102238f, 0.15819493f, -0.20110513f, -0.19666819f, -0.22836064f, -0.14124313f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03582152f, -0.06284472f, -0.09904423f, -0.03901460f, -0.03154761f, 0.06602608f, 0.05818213f, -0.16673994f, 
    -0.11762242f, 0.00584957f, 0.06212180f, 0.04099970f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
