#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.46799228f, -0.46922982f, 0.10816335f, -0.02964125f, -0.62773436f, 0.38099110f, -0.20296434f, -0.75733268f, 
    -0.68123859f, -0.36511379f, -0.36613035f, -0.26863146f, -0.41170537f, -0.51323587f, -0.54910052f, -0.06293627f, 
    -0.10844684f, -0.05345313f, -0.02998578f, -0.01261396f, -0.17085116f, -0.12828791f, 0.06522886f, 0.06901196f, 
    0.05184112f, 0.09798048f, 1.22140229f, 0.39813471f, -0.87129354f, -0.21818197f, -0.26028308f, -0.05124049f, 
    0.32308215f, -0.09690274f, -0.34863225f, -0.10106267f, -0.08214886f, 0.41897097f, -0.33731398f, -0.02923523f, 
    0.25164995f, 0.04709579f, -0.03250141f, 0.26336259f, -0.45494434f, 0.06706745f, 0.30001444f, -0.06278826f, 
    -0.13743626f, -0.22854967f, 0.13465820f, -0.77010864f, -0.61166537f, 0.46822387f, 0.42451626f, 0.19745877f, 
    0.29411986f, -0.19972140f, 0.03930549f, 0.05955293f, -0.16936408f, -0.04787346f, -0.12722732f, 0.04419656f, 
    0.07059507f, 0.03441274f, -0.15340813f, -0.25721556f, -0.00051689f, -0.23574723f, -0.39151415f, -0.37618470f, 
    -0.38836581f, -0.42677176f, -0.37858742f, 0.36927024f, 0.14182533f, 0.34792101f, 0.02597991f, 0.17607865f, 
    -0.02019074f, -0.40904120f, 0.35076857f, 0.21640640f, 0.10784896f, 0.15674724f, 0.29350954f, -0.25869483f, 
    -0.32325712f, 0.18470727f, -0.32231289f, 0.32629237f, -0.34732860f, -0.21895383f, 0.08237343f, -0.32048401f, 
    0.37954667f, 0.13935567f, -0.28551510f, -0.21471970f, 0.43387470f, -0.94894469f, -0.28651372f, -0.31343591f, 
    -0.06896582f, -0.70536053f, -0.23787972f, -0.04644797f, 0.09834225f, -0.30130604f, -0.35280576f, 0.38573363f, 
    0.02586473f, -0.25074533f, -0.23024137f, 0.38725269f, 0.09448272f, -0.02765549f, -0.00675577f, 0.11491991f, 
    -0.15154047f, 0.14777038f, -0.02597724f, -0.05323749f, 0.41051927f, 0.54315829f, 0.08971241f, -0.17913556f, 
    -0.05733087f, 0.23213151f, 0.18372822f, -0.27710503f, -0.08155583f, 0.27720356f, -0.13937755f, -0.09601033f, 
    0.01730395f, -0.08780409f, -0.09745196f, -0.04528840f, -0.09507207f, 0.01547121f, -0.30798441f, 0.15929262f, 
    -0.10938087f, -0.00328288f, 0.14918980f, 0.39570379f, 0.26452440f, 0.23890556f, 0.80268461f, -0.40003219f, 
    0.06917051f, 0.28610724f, 0.37601438f, 0.19248848f, 0.32394537f, -0.01553577f, -0.36688277f, -0.12811102f, 
    0.21753874f, -0.10772249f, -0.06534427f, -0.38141283f, -0.21513125f, -0.05283783f, 0.05781239f, 0.25529584f, 
    0.19666001f, -0.13598955f, -0.15970774f, -0.05105313f, -0.32801601f, -0.14526659f, -0.31838998f, -1.14697659f, 
    -0.35013062f, -0.56855702f, -1.00955141f, -0.50539798f, 0.52703685f, 0.11614503f, -0.08034546f, 0.03739117f, 
    0.51560032f, -0.27241027f, -0.41653055f, -0.22266150f, -0.01288060f, -0.17649022f, 0.17018078f, 0.08929130f, 
    -0.06547620f, 0.18018216f, 0.07026029f, -0.15211885f, 0.03330964f, 0.17937036f, -0.21186586f, -0.19454893f, 
    0.60511470f, 0.11702216f, 0.09109091f, 0.29234099f, -0.63196528f, -0.46299103f, -0.38067281f, 0.09257019f, 
    0.52573931f, 0.49840012f, 0.27345765f, -0.14053495f, -0.18975420f, 0.29399273f, 0.04324195f, 0.09583366f, 
    -0.15894511f, -0.06914730f, -0.13527280f, -0.30914369f, 0.12329049f, -0.09813953f, -0.03962897f, 0.09789643f, 
    -0.22081338f, 0.17811288f, -0.31773669f, -0.86302668f, -0.76873624f, -0.72941327f, 0.59761971f, 0.32708025f, 
    0.45581710f, 0.41268697f, 0.25680259f, 0.03032004f, 0.04505064f, -0.09097818f, -0.08122660f, 0.21320058f, 
    -0.29365325f, -0.07908968f, 0.13392343f, -0.06776427f, -0.16225356f, 0.02486454f, 0.06519305f, -0.08437695f, 
    0.24901886f, 0.25315738f, 0.52627558f, 0.83848888f, 0.55671465f, 0.31882513f, 0.09059699f, -0.45757934f, 
    -0.56093401f, -0.27972052f, -0.01454118f, -0.30694446f, 0.04913937f, 0.06398384f, -0.01698324f, -0.03341658f, 
    -0.38885367f, -0.03038161f, -0.04360875f, -0.02391325f, -0.08635011f, 0.32609215f, -0.05792587f, 0.14997870f, 
    -0.31632060f, 0.07983784f, 0.38049451f, 0.50525153f, 0.10909262f, -0.53919041f, 0.14781745f, 0.15936518f, 
    0.00830867f, -0.03992136f, -0.10219661f, -0.05299107f, -0.28605711f, -0.15736453f, 0.51383471f, -0.25631064f, 
    -0.15072276f, 0.39369020f, 0.11723516f, -0.19126989f, 0.02331511f, -0.03509888f, 0.17069587f, 0.15742390f, 
    0.07004477f, 0.19834004f, 0.02717986f, 0.31355888f, -0.37933215f, 0.08270865f, -0.14104880f, -0.29772800f, 
    0.61815447f, -0.53301418f, 0.11163124f, 0.87412751f, -0.53310591f, 0.51875842f, -0.22006702f, -0.15700787f, 
    0.08261345f, 0.05471962f, -0.11890952f, 0.33225766f, -0.34066436f, -0.20852242f, 0.16132450f, -0.05276451f, 
    -0.08036153f, 0.07083777f, 0.19604942f, 0.01278871f, 0.04310352f, -0.14171302f, -0.73617607f, -0.44101346f, 
    0.41433921f, 0.68678528f, -0.70957762f, 0.16940774f, -0.33410051f, -0.18191871f, -0.57426441f, -0.38134250f, 
    -0.67811948f, 0.46718952f, 0.03408185f, -0.01524015f, -0.17455877f, 0.03667748f, -0.07659665f, -0.03171913f, 
    0.12522706f, 0.13956365f, 0.06908542f, 0.02959324f, -0.13034800f, 0.20708393f, -0.21997906f, 0.04416556f, 
    -0.53225631f, -0.94089085f, 0.05082725f, -0.27272224f, -0.08478992f, -0.39838123f, -0.26920226f, -0.46824065f, 
    0.46265060f, 0.64538670f, 0.65153247f, -0.00666481f, -0.17054541f, 0.12461912f, 0.13038474f, -0.22819085f, 
    -0.16097884f, -0.30188423f, 0.22869563f, -0.21354295f, 0.05904166f, 0.15966584f, -0.11341894f, 0.26294893f, 
    0.05283715f, -0.37574261f, 0.59861231f, 0.33215868f, -0.17063762f, -0.09050226f, -0.08564688f, 0.07795808f, 
    0.20598832f, 0.47875080f, -0.14120279f, -0.20080802f, 0.15659243f, 0.52626741f, -0.02093215f, 0.15178095f, 
    -0.02181235f, -0.07947676f, -0.26754642f, -0.26894495f, 0.13800050f, 0.11679025f, 0.33242127f, -0.05453705f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.24587730f, 0.23351693f, -0.04661669f, 0.32055342f, 0.27644995f, 0.28757185f, 0.17614427f, 0.01274061f, 
    0.46701083f, 0.33300260f, -0.01625565f, 0.34881371f, 0.11078141f, 0.36075854f, 0.20668119f, 0.10348552f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.25698099f, -0.20426846f, 0.16320054f, -0.02595193f, 0.01548493f, 0.07662612f, 0.04763320f, -0.08581049f, 
    0.16082060f, -0.00223218f, 0.14676665f, 0.04193517f, 0.17947504f, -0.02106426f, -0.21332978f, -0.22812286f, 
    0.15014531f, -0.07157212f, -0.07499781f, 0.04986387f, 0.09811961f, -0.02985456f, 0.11130846f, -0.06980103f, 
    -0.06134314f, -0.14275289f, 0.48079970f, -0.24268864f, -0.06422507f, -0.03507344f, -0.12685779f, 0.11317068f, 
    0.19721653f, 0.07032757f, -0.04326424f, 0.08754754f, 0.05498530f, 0.02811769f, -0.26422045f, 0.16738950f, 
    -0.14133817f, -0.04117782f, 0.06682859f, -0.14109087f, 0.14097100f, 0.01957921f, 0.39826068f, 0.10023562f, 
    -0.07087575f, -0.01288025f, 0.29455841f, 0.15994446f, 0.10070735f, 0.02333828f, -0.01951731f, 0.18032217f, 
    0.17438547f, -0.04277271f, -0.06869033f, -0.06357011f, -0.11281467f, -0.14179438f, -0.02149548f, -0.05615784f, 
    0.02668328f, 0.06268532f, 0.06698349f, 0.07216088f, 0.08315451f, -0.10184909f, -0.03516882f, -0.05192024f, 
    -0.01950003f, -0.55363196f, -0.09777465f, -0.09627803f, 0.00599865f, 0.01352145f, 0.03338984f, 0.15508366f, 
    -0.01388564f, 0.04526817f, 0.10014104f, 0.07028365f, -0.53167588f, -0.02886152f, 0.28225341f, 0.12365672f, 
    -0.15338416f, -0.06289004f, 0.07838643f, 0.14294419f, 0.12392528f, -0.00732392f, -0.06453189f, -0.02238180f, 
    0.40736663f, 0.21413603f, -0.42437696f, 0.22606844f, -0.03328925f, -0.14144261f, 0.02575306f, 0.01130252f, 
    0.07954308f, 0.21770614f, 0.12562676f, 0.02527193f, 0.25403798f, 0.56866443f, 0.23865674f, -0.02441929f, 
    -0.15777405f, -0.18637967f, -0.18933409f, 0.06881685f, 0.14264722f, 0.08010000f, 0.01443107f, 0.09753464f, 
    -0.10075601f, -0.28225225f, -0.35631970f, 0.22995144f, -0.08894446f, 0.26080951f, 0.16382517f, 0.19531265f, 
    0.01958361f, -0.05926480f, -0.10894238f, -0.08470318f, 0.00638313f, -0.02876291f, 0.01753682f, -0.06203052f, 
    0.18616128f, 0.16747506f, 0.22079901f, 0.12588590f, -0.00049340f, -0.10486590f, 0.00016521f, 0.09773770f, 
    -0.14768070f, -0.29630446f, 0.45404309f, -0.14087433f, 0.07165844f, -0.11224034f, -0.09596920f, 0.18581635f, 
    0.11433897f, -0.05222524f, 0.00038761f, -0.00801621f, -0.08715475f, -0.05110702f, 0.14003730f, 0.12724549f, 
    -0.12433113f, 0.03888681f, -0.07669474f, 0.16384341f, 0.04708563f, -0.03476530f, 0.04815017f, 0.16249481f, 
    0.09116669f, 0.26427025f, 0.27768704f, -0.10597753f, -0.01343167f, -0.05417625f, -0.13966064f, -0.05600186f, 
    -0.05903715f, -0.05852326f, -0.17618600f, -0.05735667f, 0.02571377f, -0.18405961f, -0.14363182f, 0.04338834f, 
    0.21968901f, -0.16895400f, 0.08191510f, 0.07207981f, -0.03487277f, -0.06568664f, 0.03939659f, 0.04886168f, 
    -0.24549915f, 0.01725884f, 0.15903264f, -0.08191032f, -0.06773639f, -0.03558609f, 0.06666777f, -0.10173386f, 
    -0.09626555f, -0.02813298f, -0.06163251f, 0.00810741f, 0.07397696f, 0.33047843f, 0.17318477f, -0.01923066f, 
    0.14611711f, 0.27179503f, -0.19665548f, 0.20722918f, -0.02751723f, 0.22097933f, 0.12906215f, -0.00495945f, 
    -0.03959259f, 0.20330839f, -0.21522161f, -0.01898582f, -0.04054749f, -0.01430476f, 0.14556348f, 0.01098893f, 
    -0.02442239f, -0.05229215f, 0.07266787f, -0.11985720f, 0.04857451f, 0.38758057f, 0.24870270f, 0.03826917f, 
    0.12707147f, 0.03688744f, -0.22411107f, -0.03442047f, -0.05022777f, 0.04608085f, -0.26565236f, 0.00966454f, 
    0.28254446f, -0.12580957f, -0.23494999f, 0.09830672f, 0.14574574f, 0.18926880f, 0.14342673f, 0.06384400f, 
    -0.00522436f, -0.02287677f, -0.07447474f, 0.17129666f, -0.15664002f, 0.01462837f, -0.06085313f, -0.14667538f, 
    -0.03254835f, -0.08686629f, -0.15264817f, -0.20328648f, 0.01054291f, 0.04986252f, -0.00568442f, 0.12625456f, 
    -0.17102985f, 0.60867447f, 0.03582516f, -0.03244894f, -0.20639673f, -0.07504505f, 0.04914634f, -0.30298769f, 
    -0.06340782f, -0.06955475f, 0.05868243f, -0.10375497f, 0.08136322f, -0.06161517f, 0.02470583f, 0.00689129f, 
    0.12901035f, 0.21823108f, 0.17185135f, 0.05022324f, -0.12888092f, -0.01866223f, 0.10714450f, -0.03655148f, 
    0.34719938f, 0.30286399f, 0.26745123f, 0.14455579f, 0.08416053f, -0.01775950f, 0.01801135f, 0.04551361f, 
    0.15706412f, 0.11724975f, 0.16470875f, 0.05265975f, -0.29187813f, -0.19317994f, -0.05085830f, 0.19257610f, 
    0.03208358f, -0.01697412f, 0.04400028f, -0.05614093f, 0.16190559f, 0.15487157f, 0.16055705f, 0.15471999f, 
    0.02771264f, 0.11833508f, 0.39432180f, -0.05636685f, 0.05893042f, -0.20640117f, -0.19100133f, -0.16880257f, 
    -0.20290981f, -0.24557783f, -0.16885640f, 0.06121786f, -0.21917030f, 0.01569256f, -0.18142475f, 0.02406008f, 
    -0.09921574f, 0.09825248f, -0.16489141f, -0.06547789f, 0.17882048f, 0.05207943f, 0.07654081f, 0.04143353f, 
    0.59952497f, 0.02046242f, -0.26609817f, 0.26526535f, 0.10496984f, -0.04235679f, 0.04371073f, 0.05394273f, 
    -0.00747822f, 0.21742205f, 0.25614551f, 0.07136745f, 0.14709377f, 0.15702222f, -0.26001123f, 0.25363970f, 
    0.10375672f, 0.00556316f, 0.24405742f, -0.01672862f, -0.02825752f, 0.06621958f, -0.03007420f, 0.03318992f, 
    -0.36661115f, -0.18488543f, -0.24362305f, -0.03380672f, 0.17591450f, 0.08549264f, 0.12513776f, 0.07345311f, 
    0.03103714f, -0.02341896f, 0.04055941f, 0.09250880f, -0.10462511f, 0.10187849f, -0.02369132f, -0.17901994f, 
    -0.30840483f, -0.17681789f, -0.02633919f, -0.03424658f, 0.14345245f, -0.08461066f, 0.00246870f, 0.13098051f, 
    -0.33014065f, -0.12868223f, -0.07841969f, 0.09783207f, 0.06492975f, -0.04018659f, -0.01213794f, -0.35371268f, 
    0.01090808f, -0.03604677f, 0.07818016f, 0.18661824f, 0.18627614f, -0.38183245f, 0.34533057f, -0.11168192f, 
    0.10064740f, 0.05257194f, -0.03538582f, 0.11752611f, -0.21053626f, -0.02989735f, 0.03156508f, 0.12049902f, 
    -0.24075194f, 0.27638596f, -0.15815966f, -0.16417138f, 0.08155838f, 0.06667907f, 0.11470179f, 0.15299328f, 
    0.01676607f, -0.02663783f, -0.12454429f, -0.19100620f, -0.07526145f, 0.19021074f, 0.05470036f, 0.08575343f, 
    -0.09519649f, -0.00941530f, 0.09908447f, 0.05874409f, -0.23140976f, 0.03275405f, 0.08523839f, 0.25974861f, 
    0.25177860f, -0.14526404f, -0.16610979f, 0.22916023f, -0.01517592f, 0.00043059f, -0.08602946f, 0.13300754f, 
    0.04335918f, -0.00381768f, -0.01293982f, -0.01772296f, -0.13268709f, -0.01301975f, 0.07433075f, -0.00730116f, 
    -0.06544138f, 0.14403565f, -0.12874544f, 0.07052510f, -0.07206368f, -0.00430601f, 0.07648552f, 0.19780788f, 
    -0.30971920f, 0.16703215f, -0.23052464f, -0.01458024f, 0.01596854f, 0.06086323f, 0.02339463f, 0.07719758f, 
    -0.01151129f, 0.07483478f, -0.10360405f, -0.08565227f, -0.11598816f, 0.06080610f, -0.02960632f, 0.11328617f, 
    0.04698334f, -0.05200122f, 0.17407693f, 0.01522394f, -0.06410165f, 0.10009900f, -0.01385856f, -0.06037500f, 
    0.20647511f, 0.01164066f, -0.01266836f, 0.17818271f, 0.19125067f, 0.10857355f, 0.16067468f, 0.08836927f, 
    -0.16381678f, 0.14883102f, -0.00949034f, 0.15182140f, -0.57837433f, 0.01571123f, -0.02254316f, 0.18344072f, 
    0.12814943f, 0.15717039f, 0.07215752f, 0.03771189f, 0.09393611f, 0.14315858f, -0.14420934f, 0.07724918f, 
    -0.28307310f, -0.10458013f, 0.40716508f, -0.28355193f, 0.04486915f, 0.12603670f, 0.04195035f, 0.03217697f, 
    -0.06128279f, -0.01345057f, 0.05647055f, 0.03819212f, -0.20448342f, -0.05965489f, 0.08277845f, 0.18282486f, 
    -0.10051489f, 0.12930445f, -0.10020705f, -0.03617688f, -0.13299997f, -0.16620494f, 0.14009586f, 0.11836182f, 
    0.33091605f, 0.14203010f, 0.56052387f, -0.11059112f, 0.07854111f, 0.11295721f, -0.06586970f, 0.15219688f, 
    0.07825685f, -0.05236975f, 0.00123255f, 0.05728620f, 0.09749602f, 0.09862307f, -0.14601822f, 0.42158490f, 
    -0.09559947f, -0.03787278f, -0.16121958f, 0.03925692f, 0.13760249f, 0.02150175f, 0.08226538f, 0.32844636f, 
    -0.01850871f, -0.25895643f, -0.07961006f, -0.01868114f, -0.17994782f, -0.14191760f, -0.06486087f, -0.00770657f, 
    -0.07756085f, 0.19447337f, -0.20053872f, -0.07521727f, 0.06296123f, 0.23497263f, -0.21570206f, 0.08692671f, 
    -0.03460844f, -0.02016305f, 0.09061871f, 0.12769392f, -0.20723976f, -0.02015566f, 0.01791132f, 0.19261481f, 
    -0.18712771f, -0.04957148f, -0.10254323f, -0.14804827f, 0.04986410f, 0.14931075f, -0.04852866f, 0.18994534f, 
    -0.00638560f, 0.01827572f, -0.09586602f, -0.00990842f, 0.05542855f, 0.07681981f, -0.25390089f, -0.36381638f, 
    0.08584321f, -0.22280097f, -0.04579718f, -0.07573169f, 0.24320783f, 0.02633561f, -0.03214962f, 0.02157777f, 
    0.15764022f, -0.21273310f, 0.45268345f, 0.20874077f, -0.03117546f, -0.13281447f, -0.13784899f, -0.11968479f, 
    0.17632772f, 0.25900176f, 0.20024137f, 0.30783099f, 0.23487958f, 0.01578781f, -0.06290963f, 0.09732310f, 
    0.02618430f, 0.08326832f, 0.04630696f, -0.06278735f, 0.14076613f, 0.00946550f, 0.11056269f, -0.09889051f, 
    -0.24977055f, 0.15032364f, 0.28228885f, -0.22702789f, -0.09898045f, -0.02011161f, 0.02632437f, 0.09537917f, 
    0.15700689f, 0.05151692f, 0.07754603f, -0.17664452f, 0.07444374f, -0.13814616f, -0.12192420f, -0.01024178f, 
    0.11515741f, -0.04173306f, 0.19785938f, 0.15462229f, 0.08961727f, -0.07618019f, -0.07171671f, -0.13642095f, 
    0.19448608f, -0.45580679f, 0.11719257f, 0.02692447f, 0.10360784f, 0.04123657f, 0.00616902f, 0.10814191f, 
    -0.12136508f, -0.06720236f, 0.05252749f, 0.08759750f, -0.28747508f, -0.00280873f, 0.33542955f, 0.14324734f, 
    -0.20533551f, 0.00361415f, 0.01190857f, -0.06614919f, 0.23550220f, 0.04880526f, 0.15248054f, 0.18843929f, 
    0.08820184f, 0.25772423f, -0.14117882f, 0.13562934f, -0.06076174f, 0.04145732f, 0.04475169f, -0.08788773f, 
    0.07785712f, -0.01216435f, 0.10615169f, -0.00048460f, 0.37979838f, 0.55490547f, 0.42335865f, 0.07880930f, 
    -0.01496620f, -0.20002195f, -0.15996355f, -0.11493423f, -0.13557817f, 0.13175373f, 0.19437042f, 0.02528476f, 
    0.03545135f, -0.08578494f, -0.31865066f, 0.11663014f, 0.08434235f, 0.15490010f, 0.19063607f, 0.13861308f, 
    0.13367681f, 0.00821354f, -0.05196191f, -0.04200663f, 0.20777838f, -0.05270638f, -0.07680026f, -0.07574844f, 
    0.09185918f, -0.04243804f, 0.10121100f, 0.16774258f, 0.18392365f, -0.04352542f, -0.17114899f, 0.02451510f, 
    -0.19414750f, -0.33460137f, 0.00977401f, 0.07477161f, 0.15974315f, -0.00782860f, -0.01281817f, -0.00039252f, 
    -0.11718965f, -0.15967102f, 0.08978354f, -0.06187670f, -0.07592877f, -0.15533771f, 0.09360273f, -0.14338584f, 
    0.08814365f, 0.05669104f, 0.14729948f, 0.03371007f, -0.06202421f, -0.15686211f, -0.06918627f, -0.08715219f, 
    -0.00828057f, 0.28863582f, 0.11807963f, -0.13443619f, -0.02634804f, 0.00626073f, -0.08566805f, -0.06172434f, 
    0.00564706f, 0.04330027f, 0.04933853f, 0.09108482f, 0.10470412f, -0.26027292f, 0.04925804f, 0.17585933f, 
    0.15262274f, 0.03536966f, 0.03318991f, 0.04961904f, -0.00545443f, -0.00881272f, -0.05906682f, -0.12651001f, 
    0.45709500f, 0.21346962f, -0.27226943f, -0.15950270f, 0.12628493f, 0.00874740f, 0.04989175f, 0.23158935f, 
    -0.06129551f, -0.05364740f, -0.00776924f, -0.07911938f, -0.24127041f, 0.16753021f, -0.15373158f, 0.39453703f, 
    -0.11748210f, 0.01196793f, 0.12162666f, -0.06925379f, 0.04371412f, 0.05985133f, -0.06065682f, -0.06647524f, 
    0.08639732f, -0.39073995f, -0.11674754f, -0.10009973f, -0.09159584f, 0.04118312f, 0.03029406f, -0.20409457f, 
    0.06230684f, 0.14847189f, 0.11830626f, 0.20954885f, 0.04041749f, -0.03976573f, 0.09429997f, -0.08896615f, 
    0.14027582f, 0.00297923f, 0.07397909f, 0.02668532f, 0.11367816f, 0.12773861f, 0.09486950f, -0.16725484f, 
    -0.05767158f, 0.02429673f, -0.07187615f, -0.38908631f, 0.06116010f, -0.06461247f, 0.17296042f, -0.04453857f, 
    -0.09245548f, 0.00808172f, 0.11968569f, 0.03083568f, 0.02972742f, 0.14726973f, 0.16787510f, 0.17204283f, 
    -0.00169438f, 0.05805580f, 0.14898407f, -0.08444552f, -0.00284716f, 0.02015810f, 0.03639423f, -0.03374913f, 
    0.21650687f, -0.07432591f, 0.22136426f, 0.16194290f, 0.07676453f, -0.04466245f, 0.05043534f, -0.01536052f, 
    0.10521055f, 0.16122249f, 0.04588388f, 0.14134473f, 0.27135307f, -0.15504430f, -0.29839495f, -0.22166805f, 
    0.05495535f, 0.12198856f, -0.04476508f, 0.15739444f, -0.06912273f, -0.07409625f, 0.03073455f, 0.03459492f, 
    -0.11815779f, -0.07615151f, 0.10908473f, -0.24110557f, -0.10496646f, -0.07136029f, 0.06444138f, 0.10890244f, 
    0.06789504f, -0.20485735f, -0.18171558f, -0.10465802f, 0.26662031f, -0.33393475f, -0.26429775f, 0.00074008f, 
    0.05690388f, -0.09726500f, -0.00844585f, 0.09517200f, 0.03646373f, -0.16241154f, 0.01932107f, -0.10609414f, 
    0.07632086f, 0.11346573f, -0.28288978f, 0.30733749f, -0.01404205f, -0.06854295f, 0.06774392f, -0.08135150f, 
    0.12355155f, 0.04418233f, 0.10627222f, 0.10709962f, 0.05357797f, -0.00110669f, 0.20908229f, 0.05041939f, 
    0.01517907f, -0.15406373f, -0.03631244f, -0.01649575f, -0.00300407f, 0.01546529f, 0.05451568f, -0.11107571f, 
    -0.05939554f, 0.40256912f, -0.08029085f, -0.18124898f, -0.05467942f, 0.10492928f, 0.15705967f, -0.03101014f, 
    0.11397154f, -0.01704399f, -0.04646766f, -0.08512896f, 0.15899944f, -0.13467368f, 0.11722827f, -0.36194924f, 
    0.20486709f, 0.05576561f, 0.04738260f, -0.06188505f, -0.12873092f, 0.03726861f, 0.00409015f, -0.12529540f, 
    0.29658782f, 0.13323638f, -0.26190978f, 0.02040768f, 0.07352208f, 0.13579793f, -0.02001207f, -0.01145689f, 
    0.06662000f, -0.13476878f, 0.06839976f, 0.02109014f, 0.05786730f, 0.02201227f, 0.27186444f, 0.04002554f, 
    0.08764961f, 0.09574752f, -0.00472228f, -0.01926127f, 0.15747820f, -0.01320886f, 0.09908513f, -0.05736806f, 
    0.25260600f, 0.24467537f, 0.01198449f, 0.04892023f, -0.07174821f, 0.04118247f, -0.00117381f, 0.09553889f, 
    0.01413039f, -0.11301895f, -0.15480325f, 0.05734554f, 0.14547837f, -0.03369709f, 0.33735475f, 0.18860550f, 
    -0.01913066f, 0.13651234f, 0.01713275f, 0.07847444f, -0.00430381f, 0.15893973f, 0.05374512f, 0.04518186f, 
    0.16657789f, 0.27995721f, -0.35565379f, 0.13550013f, 0.03427231f, -0.04574258f, -0.03796082f, -0.14546315f, 
    -0.06912079f, -0.22567216f, 0.06505169f, -0.18196099f, -0.06541301f, 0.17426522f, 0.27522850f, -0.07240082f, 
    0.04035637f, -0.06213848f, -0.12523513f, 0.01324993f, -0.12141932f, 0.02850210f, -0.21824709f, 0.09105951f, 
    0.09209223f, 0.10969573f, -0.13756286f, 0.15432747f, 0.10487163f, 0.18222895f, 0.01944884f, -0.01767947f, 
    -0.08375831f, -0.06421281f, 0.00772108f, 0.03566205f, 0.10982127f, 0.01603969f, -0.03834716f, 0.02520036f, 
    -0.06451701f, -0.03314193f, -0.07316970f, -0.05395905f, -0.00790794f, 0.07121103f, 0.01525439f, 0.04421219f, 
    0.21586941f, 0.45305783f, 0.02076730f, 0.06711864f, -0.19577670f, -0.08543821f, -0.13652334f, -0.04350297f, 
    -0.04712960f, -0.17543970f, -0.13342993f, -0.07745424f, 0.46750119f, 0.22092254f, -0.19995674f, -0.05894130f, 
    0.16269927f, 0.01233084f, 0.00897291f, -0.09215759f, -0.12752455f, 0.07012191f, 0.02754895f, -0.07152616f, 
    -0.13892266f, 0.02056818f, 0.36772123f, -0.08446087f, -0.02764278f, 0.11718594f, -0.07462774f, 0.06121736f, 
    0.03569469f, -0.09598110f, 0.11265859f, 0.04605153f, -0.13761538f, -0.41765538f, -0.16130133f, -0.05182406f, 
    0.11833352f, 0.00643527f, 0.06117719f, -0.10770383f, 0.07468434f, 0.04827759f, -0.03124501f, 0.01632807f, 
    0.22369774f, 0.13450511f, 0.38541469f, -0.24894843f, -0.04680891f, -0.23029929f, -0.15861772f, -0.23428588f, 
    -0.03505928f, -0.08346310f, -0.09253934f, -0.03139396f, 0.06558342f, 0.05898595f, -0.02427180f, 0.10171640f, 
    -0.01689896f, 0.01257810f, -0.02320974f, 0.02670477f, 0.08274585f, 0.11243642f, -0.00428406f, -0.06051464f, 
    -0.10485376f, 0.10119524f, 0.04844676f, 0.06703193f, -0.07326908f, 0.16545144f, 0.13590367f, -0.10917925f, 
    0.08030611f, 0.05840269f, 0.13579372f, 0.20954791f, -0.02936649f, 0.18894939f, -0.06897653f, 0.03666748f, 
    0.04748311f, 0.13172959f, 0.13193105f, 0.05109709f, 0.02742315f, 0.09926631f, 0.05601008f, -0.00577225f, 
    -0.03377379f, -0.35906368f, -0.10366546f, 0.15676060f, 0.17566024f, 0.07841329f, 0.16027866f, 0.11441574f, 
    0.06854885f, 0.10532116f, 0.10340372f, 0.03742679f, -0.11053464f, 0.11035010f, 0.05274384f, 0.01173137f, 
    -0.12411799f, 0.06997757f, -0.04833657f, -0.15700516f, 0.04722163f, 0.08757181f, -0.04092528f, 0.18263645f, 
    0.22111668f, 0.15472020f, 0.05539217f, -0.04994561f, 0.12058943f, 0.12407248f, -0.02966649f, 0.00210343f, 
    0.01674927f, -0.07355581f, 0.00288047f, 0.08441572f, -0.18159795f, -0.05717588f, -0.23131151f, 0.56374133f, 
    -0.08452214f, 0.04317926f, 0.34549749f, 0.08957031f, -0.02580396f, -0.05460016f, -0.14303902f, -0.06317157f, 
    0.18528016f, 0.02593737f, 0.02737338f, -0.37873471f, -0.08377046f, 0.01924723f, -0.06543942f, -0.00472485f, 
    -0.08632673f, -0.27132225f, -0.14545885f, -0.33497062f, -0.09586911f, 0.00488997f, 0.10223864f, 0.06105004f, 
    -0.07444430f, -0.31509322f, 0.08798619f, 0.09234001f, -0.01054875f, 0.11692625f, 0.12691456f, -0.02805765f, 
    0.12021180f, -0.05835341f, 0.05246755f, 0.14285149f, 0.26983702f, 0.25449887f, -0.06083341f, 0.19107161f, 
    0.04266240f, 0.11581871f, 0.01701883f, 0.31025603f, -0.20522954f, 0.11062242f, -0.03825860f, -0.04146796f, 
    -0.10238521f, -0.08869394f, 0.03550510f, -0.06645668f, 0.08763435f, 0.14516932f, 0.03561857f, 0.15918775f, 
    0.12955076f, -0.00385600f, 0.05978836f, 0.06260687f, 0.10845558f, -0.12726305f, -0.11312498f, -0.15772270f, 
    -0.20983203f, -0.17519334f, -0.08714436f, -0.09740881f, -0.08704676f, 0.01071705f, -0.34690544f, -0.37008989f, 
    0.09376925f, -0.22857574f, 0.11308142f, 0.10790174f, -0.04883651f, 0.05407033f, -0.18643251f, -0.10779615f, 
    0.33627486f, 0.13919076f, 0.02035306f, 0.01585411f, 0.05567101f, -0.09992496f, -0.07237095f, 0.09532683f, 
    -0.00241621f, 0.08316105f, -0.04755514f, -0.04953884f, 0.00811034f, -0.50188768f, -0.41411400f, -0.27756065f, 
    -0.17116144f, -0.03781499f, -0.01048899f, -0.00272646f, 0.27396801f, 0.10499658f, 0.05030318f, 0.11452024f, 
    -0.09509726f, 0.02630611f, -0.33194366f, 0.13568707f, -0.08863423f, 0.03120230f, 0.11910318f, -0.04849013f, 
    -0.17067555f, -0.12264908f, -0.13714229f, 0.07757400f, -0.21810429f, -0.00226425f, 0.04842018f, -0.26344934f, 
    -0.00168871f, -0.02985675f, 0.25396714f, -0.11640556f, 0.01106274f, 0.27101821f, 0.15985605f, 0.13935180f, 
    -0.21549205f, 0.33502308f, 0.42815724f, -0.02545985f, -0.01559353f, 0.11915556f, 0.01504109f, -0.00608723f, 
    0.16291071f, 0.26281568f, 0.01048748f, 0.23564436f, 0.11898316f, 0.22616908f, 0.21374820f, -0.00585391f, 
    0.08520997f, 0.25125870f, 0.17027122f, 0.19945645f, -0.07323715f, -0.00141506f, 0.02507274f, 0.14898507f, 
    0.11655986f, 0.10293382f, 0.04642639f, 0.01368312f, 0.05279619f, -0.01699947f, 0.00554247f, 0.10944664f, 
    -0.09091263f, -0.13363688f, -0.00985070f, 0.07115753f, -0.21129797f, -0.01914259f, 0.02629089f, -0.16866434f, 
    0.08087531f, 0.08804097f, 0.01882227f, -0.21982659f, -0.12697077f, 0.14482380f, 0.11683635f, 0.27941555f, 
    -0.31342161f, -0.17473094f, -0.11917469f, 0.12981927f, 0.02783276f, -0.12205198f, -0.06733654f, 0.02629238f, 
    -0.10370445f, 0.09285727f, -0.15479629f, 0.09917475f, 0.27098310f, -0.09188993f, 0.24769518f, -0.34254944f, 
    -0.16903700f, 0.17840083f, 0.01511830f, 0.16085865f, 0.09320408f, -0.13047577f, 0.21147016f, 0.14995642f, 
    -0.06467923f, 0.28060359f, -0.32644194f, 0.16398951f, 0.10008335f, 0.05780454f, 0.06668552f, -0.03454628f, 
    0.03206555f, 0.29106429f, 0.23580213f, 0.19452612f, 0.11205672f, 0.07037869f, 0.20437828f, -0.05557748f, 
    -0.09414469f, 0.27420303f, -0.06227769f, 0.11052114f, 0.10149404f, 0.03235831f, -0.14368208f, 0.10718073f, 
    -0.03975903f, -0.01629327f, -0.31426924f, -0.10919824f, -0.16733627f, 0.02100192f, 0.15988520f, -0.14004871f, 
    -0.04368793f, -0.01130193f, -0.02957790f, -0.22429997f, 0.01240754f, -0.02766588f, 0.02171777f, -0.01228153f, 
    0.17364065f, 0.07514677f, -0.01587636f, 0.11227394f, -0.11079553f, -0.08733224f, 0.04474589f, -0.17903194f, 
    -0.27874532f, 0.34432757f, -0.03135309f, 0.01734418f, 0.01088244f, -0.00657072f, 0.09615203f, 0.06650095f, 
    0.18746820f, 0.12789574f, 0.03994626f, 0.17106704f, 0.29510149f, -0.13299009f, 0.05072206f, 0.34876916f, 
    0.09999405f, 0.12361904f, 0.05997445f, -0.03884934f, 0.00173495f, 0.06532504f, 0.14443205f, 0.14454359f, 
    -0.07067034f, 0.06578253f, 0.09854621f, 0.07859907f, -0.13807756f, 0.14644703f, 0.08942650f, -0.09756379f, 
    0.06501903f, 0.03356099f, 0.22694583f, 0.09014398f, -0.07028547f, 0.29614243f, 0.20492969f, 0.38835326f, 
    0.04517404f, 0.03544076f, 0.07522997f, 0.11303116f, -0.11804375f, 0.03202746f, -0.01979902f, 0.10396687f, 
    0.00541009f, 0.07618574f, 0.48858759f, -0.31227472f, -0.11658980f, 0.13719818f, -0.03228809f, 0.09324889f, 
    -0.09516966f, 0.03375593f, -0.04742109f, -0.10364303f, 0.15727882f, -0.09754531f, -0.06986556f, 0.11915485f, 
    0.14951058f, 0.07024778f, -0.11551920f, 0.17763899f, 0.01321293f, -0.04480335f, -0.18095376f, -0.03967112f, 
    0.50277078f, -0.01431676f, -0.47912529f, 0.11617319f, 0.05914792f, 0.01441979f, 0.08975604f, -0.00792424f, 
    -0.03185658f, 0.00814835f, 0.11730123f, 0.06588626f, 0.08995108f, 0.04966877f, -0.27889737f, 0.01333976f, 
    -0.03770887f, -0.02098059f, -0.04903883f, -0.13097206f, 0.03851528f, -0.00961179f, -0.04912234f, -0.17689052f, 
    -0.15059590f, -0.21200198f, -0.18658888f, 0.08783599f, 0.11680506f, -0.14388801f, 0.16635096f, 0.05867422f, 
    -0.02431662f, 0.05637360f, -0.09848633f, 0.05979813f, 0.18733823f, 0.06650604f, -0.08194360f, 0.07466025f, 
    -0.18108468f, 0.07477014f, -0.07872213f, 0.09433389f, -0.05942075f, 0.11627909f, 0.03013402f, 0.01252125f, 
    0.05967771f, 0.05092271f, -0.02059310f, -0.00982914f, -0.06724954f, 0.01774065f, 0.02277162f, 0.03603813f, 
    -0.07286472f, -0.03068441f, -0.04270110f, -0.07658844f, -0.05232465f, -0.01511013f, 0.01861762f, 0.01770661f, 
    -0.00305039f, 0.05789834f, -0.05186958f, -0.07414219f, -0.01652329f, 0.06449062f, 0.00600413f, -0.03881604f, 
    0.01389353f, 0.02354883f, -0.04110691f, 0.06511908f, -0.06132757f, -0.05007227f, -0.07720894f, -0.07049271f, 
    0.04327486f, 0.00768925f, 0.02587589f, -0.01984071f, 0.06608992f, 0.04982726f, -0.03967634f, 0.06170112f, 
    -0.01647219f, -0.02984039f, -0.05617177f, -0.03856457f, -0.01353566f, -0.06741675f, -0.06847546f, 0.01209545f, 
    -0.04824719f, -0.05081522f, -0.03727544f, -0.00863960f, 0.02937306f, 0.04440683f, -0.03153502f, 0.04978246f, 
    -0.00015774f, -0.01566773f, -0.01799794f, 0.06461904f, -0.00738520f, 0.02225159f, 0.02736054f, -0.03431297f, 
    -0.00301809f, -0.03091335f, -0.03495250f, 0.06139989f, 0.02274744f, -0.06435146f, -0.05451100f, -0.00464962f, 
    -0.07551878f, 0.00003420f, -0.03405097f, 0.03661565f, -0.00316383f, -0.02795743f, -0.06153819f, -0.05193582f, 
    0.02687384f, -0.03141071f, -0.05657650f, -0.01941965f, 0.00080488f, -0.01258142f, 0.05528914f, 0.05631264f, 
    -0.06439954f, 0.04251982f, -0.00012774f, 0.01075908f, -0.05960337f, -0.04932802f, -0.04514175f, -0.00351143f, 
    -0.03581269f, -0.06757398f, -0.03544964f, -0.07169117f, -0.03544617f, 0.01035849f, 0.05722609f, -0.02390954f, 
    0.03765960f, -0.05848893f, -0.02319814f, -0.05841233f, -0.01804876f, 0.03722136f, -0.03270917f, 0.06071568f, 
    -0.05071613f, -0.06758695f, -0.01828864f, 0.04060445f, -0.01890484f, 0.06915992f, -0.04813273f, 0.00269251f, 
    0.03476286f, -0.02045681f, 0.05718698f, -0.01759698f, -0.07014614f, 0.01118930f, -0.04952310f, 0.05489253f, 
    -0.06560382f, -0.04533459f, 0.02410156f, -0.00706905f, 0.04634846f, -0.06528738f, -0.04109246f, 0.01572214f, 
    -0.01800486f, -0.06141780f, 0.02364532f, 0.03253515f, 0.05720190f, 0.05981876f, -0.05583765f, -0.05121503f, 
    -0.05418459f, -0.06675170f, 0.01018475f, -0.01420330f, 0.02058779f, 0.05251724f, 0.05893730f, 0.03484458f, 
    -0.01118017f, -0.03564553f, -0.00335012f, 0.06074587f, -0.05187785f, -0.03722929f, 0.00927518f, 0.06679308f, 
    -0.07077746f, 0.01633673f, 0.06278475f, -0.06417855f, 0.02098726f, 0.06586041f, -0.02067323f, -0.04583810f, 
    -0.07553782f, -0.00113807f, -0.02071635f, -0.00906961f, -0.02332087f, 0.03360994f, 0.05663789f, -0.04859376f, 
    -0.01238403f, -0.01056843f, -0.00138598f, 0.06482028f, -0.05222150f, -0.06349344f, -0.04021963f, 0.06831831f, 
    0.06553535f, -0.00039993f, -0.02682074f, 0.03745491f, -0.04497982f, -0.06115574f, -0.04969705f, -0.04777915f, 
    0.19774984f, 0.22823226f, -0.05766312f, -0.15694804f, 0.12357179f, -0.01521852f, 0.18193620f, 0.08513954f, 
    -0.00034097f, -0.04939669f, -0.00328774f, 0.03135051f, 0.06001130f, -0.46431062f, -0.32352242f, 0.10527675f, 
    0.00247762f, 0.04293648f, -0.16403939f, -0.11432607f, 0.10407643f, 0.16053498f, 0.00129153f, -0.10618249f, 
    0.01103151f, -0.07281263f, 0.11604647f, -0.04537343f, -0.15194453f, 0.06446119f, 0.03704041f, -0.00565951f, 
    0.15390351f, 0.10021487f, -0.00538654f, 0.19676620f, -0.31483498f, -0.22786282f, -0.11913645f, 0.02047982f, 
    0.21213895f, -0.05715415f, -0.05811359f, -0.03687390f, 0.02479636f, 0.05230525f, 0.22997451f, -0.01179205f, 
    0.14684001f, 0.12841639f, 0.11035359f, -0.11542640f, 0.19359908f, 0.37955421f, 0.08216756f, 0.06974808f, 
    0.18182789f, 0.04361915f, 0.02995310f, 0.01612462f, -0.10665377f, -0.11164354f, -0.06376651f, 0.02561354f, 
    0.11081260f, 0.05210434f, -0.04396274f, 0.02957465f, 0.04752186f, -0.12481044f, -0.07621068f, 0.14244206f, 
    -0.03190168f, -0.36125559f, -0.27605951f, -0.05493772f, 0.07961095f, -0.09970258f, 0.02183652f, 0.03918284f, 
    -0.02012791f, -0.03003698f, -0.00109020f, 0.16978233f, -0.12167894f, 0.10525986f, 0.11979090f, -0.02175390f, 
    0.08748608f, 0.15815757f, 0.11649676f, 0.25281310f, -0.01614702f, 0.06867086f, 0.01497163f, 0.01833919f, 
    -0.26219571f, -0.14992647f, -0.15753672f, 0.08062574f, 0.01671221f, -0.15740770f, -0.03138976f, 0.12904671f, 
    -0.02282640f, 0.10555118f, 0.06791138f, -0.11338912f, 0.25847980f, 0.16870911f, -0.11166685f, 0.15139608f, 
    0.05960530f, 0.19261076f, -0.14882231f, -0.08209930f, 0.14787176f, -0.24541967f, 0.00886921f, -0.01766351f, 
    -0.22294673f, -0.17230922f, -0.30801889f, 0.18456250f, 0.20512354f, 0.11546832f, 0.02866723f, 0.13481306f, 
    0.12042423f, -0.01084664f, 0.05680298f, 0.05651174f, -0.03600379f, -0.13400625f, -0.06309246f, -0.03215207f, 
    0.00658495f, -0.00165438f, 0.09870806f, -0.10997330f, 0.00393359f, -0.06495757f, 0.00522533f, -0.08232250f, 
    -0.12646838f, 0.15852444f, 0.25535455f, -0.12955059f, 0.05002507f, -0.01009877f, 0.08318498f, 0.07248077f, 
    -0.02355771f, 0.02328050f, -0.04710617f, -0.14041677f, 0.22803126f, -0.01072555f, 0.25503144f, -0.00423957f, 
    -0.00457787f, 0.16627827f, -0.02489213f, 0.18784928f, 0.00247412f, -0.01332630f, -0.02978228f, 0.07641867f, 
    0.49849349f, 0.34236097f, -0.19403939f, -0.09117892f, 0.10384964f, 0.10097402f, 0.01002696f, 0.08947075f, 
    0.12584244f, 0.11202011f, -0.06165654f, 0.03494301f, -0.37221584f, -0.16399637f, -0.12618510f, 0.00810049f, 
    0.09045448f, -0.08317003f, -0.03024501f, 0.08995509f, -0.03418269f, 0.02816224f, -0.10914767f, -0.05328003f, 
    -0.34057510f, -0.01426762f, 0.07490192f, 0.12639444f, 0.05226597f, -0.03838075f, -0.01822775f, -0.01029436f, 
    -0.13792130f, 0.12972818f, 0.08132389f, 0.14992706f, 0.05690903f, 0.44707659f, -0.05066706f, -0.05641582f, 
    -0.09520744f, 0.11141876f, -0.18925835f, 0.08935442f, 0.07059458f, 0.03750133f, 0.25530478f, 0.09301140f, 
    -0.22273794f, 0.17470273f, -0.13808256f, 0.01781505f, -0.01856098f, -0.01416862f, 0.03851778f, 0.21975894f, 
    0.19695908f, 0.23761255f, 0.15338521f, 0.20605013f, 0.02528070f, 0.00122131f, -0.01405931f, -0.00275401f, 
    -0.21915290f, 0.21458676f, -0.03982306f, 0.06045590f, 0.10257218f, -0.13731496f, 0.18794137f, 0.08672651f, 
    -0.00176742f, -0.07202899f, 0.10800759f, -0.02902743f, -0.06851418f, -0.10860176f, 0.12123269f, 0.15087268f, 
    -0.07903780f, 0.00275106f, -0.02805917f, -0.02745089f, -0.17226449f, -0.08384913f, 0.15879142f, -0.14010678f, 
    0.22060026f, 0.01535284f, -0.05904907f, -0.08767427f, -0.12979358f, -0.29159510f, -0.02418825f, -0.00849451f, 
    -0.50635922f, 0.10448773f, 0.08813351f, -0.03468452f, -0.05134178f, 0.03386722f, 0.27880481f, 0.04667115f, 
    0.25122717f, 0.44661632f, 0.10922938f, 0.02865393f, 0.21687911f, -0.25682220f, 0.09644301f, 0.07323983f, 
    0.10715695f, 0.24268991f, 0.16346999f, 0.24414726f, -0.08240051f, -0.11218325f, 0.00826637f, 0.26586375f, 
    0.32609612f, 0.07375942f, -0.23233207f, 0.17263499f, -0.20546593f, -0.03299603f, 0.10554381f, -0.05625091f, 
    0.04985680f, 0.09294023f, 0.03745275f, 0.08811589f, -0.08678443f, 0.10806993f, -0.10202380f, 0.44811943f, 
    0.07161283f, -0.14790912f, -0.12666778f, 0.12596746f, -0.04269318f, 0.00473031f, 0.01952623f, 0.08908246f, 
    -0.13706896f, -0.01424836f, 0.09386965f, 0.09922216f, 0.09939136f, 0.06082727f, 0.14470597f, 0.03114684f, 
    -0.02486679f, 0.01568213f, -0.03217528f, -0.08255232f, -0.19160296f, 0.06493392f, 0.08016945f, -0.08574294f, 
    0.09865253f, 0.08691415f, -0.15676604f, 0.01361525f, 0.04603849f, -0.37412465f, -0.00262710f, -0.07018135f, 
    0.62715077f, 0.25876316f, -0.36659274f, 0.11029118f, 0.38489994f, -0.01411409f, 0.00556568f, 0.09357935f, 
    -0.08666293f, 0.04933771f, 0.09836547f, 0.00646722f, 0.26212600f, -0.00475369f, -0.22908182f, 0.17955081f, 
    0.06377246f, 0.08439791f, -0.04228836f, 0.14171289f, 0.18034701f, 0.04545212f, -0.19614817f, 0.11977132f, 
    0.02175518f, 0.20625286f, -0.01730421f, -0.04505178f, 0.11045214f, -0.01192065f, 0.16156119f, -0.01916052f, 
    -0.06628475f, 0.10474120f, -0.15895465f, -0.23810054f, 0.17044999f, -0.16244338f, -0.05459385f, -0.05056414f, 
    -0.24344698f, 0.03065675f, -0.08527438f, 0.11443292f, -0.14577974f, -0.10636615f, 0.03517064f, -0.17665142f, 
    -0.33859611f, -0.24900208f, 0.11188597f, 0.24274474f, 0.06740807f, -0.03205471f, 0.16107531f, -0.29181746f, 
    0.09066323f, 0.09109719f, 0.02045319f, -0.07154714f, 0.60430342f, -0.39696822f, 0.36861557f, -0.51673758f, 
    0.30977458f, 0.06775314f, -0.14871302f, 0.19292136f, -0.08970582f, 0.10092891f, 0.16217655f, 0.09001195f, 
    -0.47592777f, 0.12856114f, -0.06088322f, -0.01750061f, 0.05375156f, -0.08852687f, -0.02634748f, 0.10902971f, 
    0.00974290f, -0.03367687f, 0.05537719f, 0.01813904f, 0.16957642f, 0.16814242f, -0.02284715f, 0.11873987f, 
    -0.07832880f, -0.07570033f, 0.08786048f, 0.06118405f, -0.06325497f, -0.05462642f, 0.09673503f, 0.06470276f, 
    -0.00696605f, 0.11348670f, 0.09804127f, 0.16140248f, 0.10896587f, 0.11458576f, -0.09073797f, 0.08840220f, 
    0.17112283f, 0.00457985f, -0.12939219f, -0.08793398f, 0.09025315f, -0.04281203f, -0.08054405f, 0.00182391f, 
    -0.11852391f, 0.23049159f, -0.12606911f, -0.02311659f, 0.03377051f, -0.23797481f, -0.10656010f, -0.22676462f, 
    -0.06320607f, 0.01716141f, -0.22885880f, 0.00090235f, -0.13288179f, -0.03371534f, -0.02190681f, 0.03192707f, 
    0.01309475f, 0.03791890f, 0.14153954f, -0.14353515f, -0.33707896f, 0.27105090f, 0.35047919f, 0.22144258f, 
    0.02916070f, 0.01375697f, 0.24315007f, 0.00993575f, 0.01864452f, 0.01177243f, 0.02477085f, -0.11355136f, 
    0.20027652f, 0.03604798f, -0.12505083f, 0.30489200f, 0.12156210f, -0.05670746f, 0.13977256f, 0.20874272f, 
    0.02112518f, 0.17665018f, 0.08707855f, 0.12330136f, -0.18089834f, 0.30385292f, 0.00467663f, -0.01379339f, 
    0.03979320f, -0.05165386f, -0.00185254f, 0.08916331f, -0.01287550f, 0.09529679f, 0.05682310f, -0.05971934f, 
    0.23436402f, -0.21886085f, 0.28252137f, -0.15856068f, -0.11380741f, 0.00574995f, -0.10476527f, 0.00801202f, 
    -0.19761616f, 0.00229477f, -0.24657194f, -0.13241307f, 0.20577604f, 0.03830202f, -0.20474684f, 0.20593816f, 
    0.07246958f, 0.24303845f, 0.04723159f, 0.27278981f, 0.18835619f, -0.12193525f, -0.09586605f, 0.12368028f, 
    0.00802777f, -0.04290660f, 0.53429419f, 0.06519358f, 0.10988430f, -0.01260683f, -0.12722550f, 0.12565289f, 
    0.04951569f, 0.05287696f, 0.00570443f, 0.07805277f, -0.05567371f, 0.01471848f, 0.10382041f, 0.42681292f, 
    -0.17601255f, 0.10622487f, -0.01623409f, 0.10962535f, 0.04897615f, -0.07121786f, -0.08469368f, 0.05306030f, 
    -0.02381121f, 0.06304406f, 0.22838050f, -0.03514997f, 0.00964890f, -0.15662777f, -0.04773187f, -0.01588424f, 
    0.02409808f, 0.01829623f, -0.01451043f, -0.10637948f, 0.03121419f, 0.27862838f, -0.33051255f, 0.22946334f, 
    -0.06534513f, -0.08265287f, 0.05407076f, 0.01840996f, 0.07715376f, -0.05303067f, -0.09571217f, -0.05314910f, 
    -0.02344920f, -0.35650498f, -0.10180924f, 0.45161521f, 0.21613228f, 0.22303851f, 0.00895464f, 0.06068078f, 
    0.03639354f, -0.11712280f, -0.09097059f, -0.09974316f, 0.49445853f, -0.30022603f, 0.74634206f, -0.36344764f, 
    0.05365070f, 0.03941459f, -0.01837453f, 0.00494528f, 0.01013418f, 0.02009098f, 0.05449864f, 0.17080761f, 
    -0.07594883f, 0.23708187f, -0.02650882f, 0.20832747f, -0.02182098f, -0.07452989f, -0.06240181f, -0.04929979f, 
    -0.09575120f, -0.15549016f, -0.04516706f, 0.12826659f, 0.14215384f, 0.09501738f, 0.02035962f, 0.08377330f, 
    -0.08045600f, 0.00873126f, 0.08463147f, 0.02832604f, -0.04844903f, 0.01645654f, -0.21188928f, 0.15317000f, 
    -0.30879351f, 0.18573046f, 0.02523098f, 0.16949354f, -0.04811911f, -0.04005717f, -0.02179438f, -0.00627116f, 
    -0.06069319f, -0.05905548f, -0.04499485f, -0.08509728f, 0.19525532f, -0.00580705f, -0.09570071f, 0.10664637f, 
    0.00005245f, -0.01326494f, -0.06429502f, 0.13441844f, -0.13341424f, 0.00899509f, 0.06628014f, -0.09626966f, 
    0.12466773f, 0.05196098f, -0.00436267f, 0.12484727f, -0.18304598f, 0.16283455f, 0.02848334f, 0.19067293f, 
    -0.04159871f, -0.10980196f, 0.09510826f, -0.02476128f, 0.18088455f, 0.35846466f, 0.02432080f, 0.26230973f, 
    0.09050520f, -0.18194464f, -0.04578906f, -0.18535562f, 0.00420162f, 0.02435504f, -0.00027218f, -0.15574539f, 
    -0.36726159f, -0.12863167f, 0.40033334f, 0.08851675f, -0.00995258f, 0.17608549f, 0.06885408f, 0.06089985f, 
    -0.01856570f, 0.03853210f, 0.00248103f, -0.07489967f, 0.04069918f, 0.06479627f, 0.17743255f, -0.19175522f, 
    0.11270504f, -0.04080362f, -0.13149463f, -0.25005567f, -0.20840490f, 0.04616428f, -0.07150511f, -0.07137045f, 
    0.51497316f, -0.02881286f, 0.33381033f, -0.15563968f, -0.07931630f, -0.07257203f, -0.19014019f, 0.03539624f, 
    -0.09194182f, 0.04277406f, -0.00530873f, 0.05914667f, 0.23987277f, 0.12519586f, -0.06306286f, 0.22987232f, 
    -0.05506131f, -0.01897909f, 0.04071823f, 0.04240862f, -0.11600722f, -0.06928973f, -0.08850429f, 0.04045804f, 
    -0.37191501f, -0.08412913f, 0.46644431f, 0.06131167f, -0.09825013f, 0.17562826f, -0.12087452f, -0.10384074f, 
    0.08740008f, -0.09939468f, -0.06980644f, 0.08299695f, -0.35190809f, 0.22310470f, 0.18703167f, 0.15288873f, 
    -0.11653670f, 0.11044203f, -0.05031002f, 0.12552644f, 0.01185298f, -0.15511365f, 0.04368448f, -0.16020679f, 
    -0.01634663f, -0.29517576f, 0.36803997f, 0.28057763f, -0.11448684f, 0.07383224f, -0.03485447f, 0.11246742f, 
    0.10664660f, -0.06060277f, 0.11265278f, 0.06054347f, -0.03905181f, 0.17405072f, -0.14133289f, 0.17138276f, 
    -0.04149029f, 0.07905035f, 0.10815541f, -0.09628268f, 0.00672795f, 0.06347342f, -0.07774069f, -0.04794786f, 
    0.46296155f, 0.37479937f, 0.14157082f, -0.26458076f, 0.02262023f, 0.09072177f, 0.05157803f, 0.14312281f, 
    0.17893143f, 0.07291984f, 0.02493710f, -0.08980770f, -0.50607789f, -0.00847138f, -0.46852282f, 0.22806574f, 
    -0.00049530f, -0.05240988f, 0.12914994f, -0.03331700f, 0.11647365f, 0.17282781f, -0.03770159f, 0.00196280f, 
    0.14370191f, -0.31013376f, 0.19240159f, 0.21186298f, 0.08253558f, -0.02182220f, 0.01286316f, 0.01621364f, 
    0.10201773f, 0.01796897f, 0.02687095f, 0.15911496f, -0.08020804f, -0.39286029f, -0.22409731f, 0.22027959f, 
    0.10774487f, -0.08502055f, -0.07657330f, -0.12705597f, 0.05888230f, -0.13462178f, 0.19114836f, 0.04297009f, 
    0.17808904f, 0.22352956f, 0.40377182f, -0.12771368f, 0.08731192f, 0.07442576f, 0.08439560f, -0.01620576f, 
    0.01849448f, -0.04430403f, -0.01879748f, -0.04980458f, -0.01841695f, -0.51222479f, -0.02282890f, 0.14135475f, 
    0.06207180f, 0.05651156f, 0.04669030f, 0.02598929f, -0.04140048f, -0.13657399f, -0.11348143f, -0.15254767f, 
    0.27592367f, -0.69835126f, -0.03411534f, -0.15250836f, 0.04134123f, 0.01889319f, 0.05898974f, 0.17665856f, 
    -0.21505958f, 0.06154725f, 0.09452829f, 0.20477794f, 0.03235992f, 0.23277245f, 0.08816858f, -0.07895677f, 
    -0.05270209f, 0.09714498f, 0.06845210f, 0.08932750f, 0.01141562f, -0.07672192f, 0.06129177f, 0.02456423f, 
    -0.31811175f, -0.31860450f, 0.28074345f, 0.01560415f, -0.00822202f, 0.02930797f, -0.05349012f, -0.17831653f, 
    0.13872397f, -0.08173686f, 0.11085551f, 0.24912970f, 0.35565731f, -0.42466217f, 0.04404258f, -0.40627152f, 
    -0.14937741f, -0.04014351f, 0.01084553f, -0.00589111f, -0.10882186f, 0.02879966f, 0.08855842f, -0.02482089f, 
    0.07050069f, -0.20257188f, -0.39459911f, 0.13426690f, -0.01893326f, -0.10780318f, -0.09982217f, 0.20565647f, 
    -0.10913906f, -0.04596073f, 0.00351145f, 0.05816594f, 0.16786909f, -0.14953482f, -0.28484964f, -0.29702628f, 
    0.02817166f, 0.01123515f, 0.28891346f, 0.02268083f, 0.03527522f, 0.13911605f, -0.13787387f, -0.14688928f, 
    -0.62744617f, 0.02570036f, -0.05250783f, 0.21621029f, -0.01113033f, -0.04964928f, 0.08401567f, -0.11657634f, 
    0.14926983f, 0.10134088f, 0.01585915f, 0.04486515f, 0.09243973f, 0.09088798f, 0.35226122f, -0.37648550f, 
    0.13502109f, 0.01094943f, 0.06969710f, 0.17588606f, 0.00431006f, 0.01071883f, 0.00666511f, -0.12185887f, 
    0.28534600f, 0.34947401f, 0.02441179f, 0.05538900f, -0.00915283f, 0.20576988f, 0.00827926f, 0.16173787f, 
    -0.10986811f, 0.00628622f, 0.05260343f, 0.03910299f, 0.06678880f, -0.31848463f, 0.36201486f, -0.10480984f, 
    0.18846248f, 0.08659739f, -0.00252855f, -0.09394334f, 0.08704259f, 0.08573832f, 0.21177411f, -0.01701108f, 
    0.11791092f, -0.02499171f, 0.12862453f, 0.35114184f, 0.00064222f, 0.15836284f, -0.05804216f, 0.06272428f, 
    0.19308254f, 0.08157608f, 0.00860955f, -0.01272634f, 0.10956355f, -0.02889283f, -0.04196287f, 0.11649195f, 
    0.04396550f, -0.10406721f, -0.08145593f, -0.14215699f, 0.15075473f, 0.07814452f, -0.03973088f, 0.05899922f, 
    -0.07193776f, -0.13477957f, 0.16991703f, 0.04071426f, 0.03774656f, -0.04210657f, -0.16587207f, -0.00722085f, 
    0.07817777f, -0.13249406f, -0.21742633f, -0.07386824f, -0.15527403f, -0.46308956f, -0.18775171f, 0.05144591f, 
    0.03447201f, -0.16397709f, -0.07757968f, -0.06476764f, 0.07840575f, 0.14525391f, 0.02116439f, -0.00508164f, 
    -0.11721567f, 0.36172989f, 0.21344770f, 0.31068504f, -0.05401415f, -0.05669799f, 0.13782671f, -0.00845638f, 
    -0.03106199f, 0.02837593f, -0.09235422f, -0.01017211f, 0.01526903f, -0.09372206f, -0.08949287f, 0.01201964f, 
    0.00383974f, -0.10618558f, 0.01924665f, 0.02297358f, 0.08168261f, -0.04956138f, 0.06629410f, -0.00956092f, 
    0.02139695f, -0.10667002f, -0.01846573f, -0.13277814f, 0.01694680f, 0.09816011f, -0.11058003f, 0.05793862f, 
    0.06221291f, -0.05133675f, 0.00394301f, 0.06812992f, 0.35886702f, 0.49810758f, 0.11820699f, 0.20917180f, 
    -0.02948479f, -0.18132304f, 0.03934188f, 0.18712603f, 0.03283157f, 0.01312293f, 0.03535668f, 0.03362530f, 
    -0.63896811f, -0.24617183f, 0.14178522f, -0.04740261f, -0.07229698f, 0.05044325f, -0.06701699f, -0.00909509f, 
    0.06235227f, 0.06757284f, -0.01902449f, 0.01021900f, 0.54424220f, 0.22145571f, 0.19222978f, -0.18923336f, 
    0.08380011f, 0.12512839f, 0.11645850f, -0.14385298f, -0.15947500f, 0.03681407f, 0.08628170f, -0.05966757f, 
    -0.18484846f, -0.28630692f, -0.08793278f, 0.25596538f, -0.08092349f, -0.10468691f, -0.11899822f, -0.03020613f, 
    0.00046454f, 0.06484690f, 0.03374838f, -0.01589929f, 0.09350541f, 0.04745546f, -0.05289053f, -0.07795645f, 
    0.12507628f, -0.03873662f, 0.14521571f, 0.01728478f, -0.06581776f, 0.05566308f, 0.03942291f, 0.05141950f, 
    -0.37965560f, -0.17589466f, 0.12806495f, -0.01323842f, -0.11029475f, -0.03526900f, -0.00921622f, -0.05438320f, 
    -0.02511735f, -0.05586228f, -0.22978963f, -0.04156507f, -0.22739212f, 0.16789685f, 0.45734540f, 0.25833890f, 
    -0.11503496f, 0.02656532f, 0.15444203f, 0.13583969f, -0.03774892f, -0.10822243f, 0.09604995f, 0.03561031f, 
    0.34670454f, 0.14457040f, 0.37429535f, 0.36149269f, 0.06720027f, 0.17197920f, 0.20712243f, 0.19056863f, 
    0.12474178f, 0.10873656f, 0.05227087f, 0.09159982f, -0.20407867f, -0.19032580f, -0.07188182f, -0.03932601f, 
    -0.04300848f, -0.07002924f, 0.16228823f, -0.01220688f, -0.02478680f, -0.00723868f, -0.00928778f, 0.01806705f, 
    -0.36466360f, -0.43866047f, 0.05922908f, 0.21046034f, 0.15004620f, 0.11389606f, -0.03795005f, 0.22305155f, 
    -0.06459476f, 0.05069126f, 0.20661663f, 0.13671586f, 0.86521572f, 0.28273055f, 0.07255463f, 0.24398702f, 
    -0.00723815f, -0.02545129f, 0.19253063f, 0.00160316f, 0.10644333f, 0.14886859f, 0.16213410f, 0.02061889f, 
    0.01578962f, 0.25311098f, 0.17081098f, -0.19791052f, -0.13834968f, -0.06235006f, -0.05814856f, 0.06093157f, 
    0.11066291f, 0.03863597f, -0.05233329f, 0.05955212f, 0.39376134f, 0.09447650f, 0.25174797f, 0.23558858f, 
    -0.14540817f, -0.09514898f, -0.01850519f, -0.10101708f, -0.09555963f, -0.03597495f, 0.31523800f, -0.00363584f, 
    -0.38037938f, -0.10128450f, -0.08231910f, 0.31614336f, 0.09046299f, 0.40109217f, 0.18869101f, 0.10903327f, 
    -0.00357492f, -0.00494816f, -0.01147705f, -0.01520007f, 0.15617673f, 0.21455193f, 0.10304704f, 0.03780874f, 
    0.13264528f, -0.19115371f, 0.01128898f, 0.02046173f, 0.04909966f, 0.03161952f, 0.02024653f, 0.01098567f, 
    0.19794005f, 0.25681427f, 0.27967709f, 0.05960650f, -0.06953340f, -0.05299689f, -0.06243056f, 0.03524457f, 
    0.37522471f, 0.05311753f, 0.13226587f, -0.03961373f, -0.15180191f, -0.07167489f, 0.02967484f, 0.21207651f, 
    0.03835025f, -0.01178188f, 0.06091931f, 0.09128154f, -0.13741297f, -0.07464468f, -0.05486555f, 0.08579209f, 
    0.53175193f, 0.52408272f, -0.12521434f, 0.09463406f, -0.02056464f, 0.10319329f, -0.07539389f, 0.05518038f, 
    0.04846340f, 0.30432427f, 0.20221879f, -0.03612721f, 0.56687587f, 0.46979427f, 0.13958663f, 0.28842071f, 
    -0.07083293f, -0.18969989f, -0.06658296f, -0.01059309f, 0.40251604f, 0.29147109f, 0.23887537f, 0.15023449f, 
    0.11677834f, -0.01471813f, -0.08034068f, 0.22293359f, -0.09358396f, -0.06871648f, 0.11494515f, -0.30439684f, 
    -0.08454737f, -0.09259945f, -0.06980729f, -0.04223311f, 0.03129438f, -0.05515574f, 0.18057948f, -0.01400286f, 
    0.22436263f, -0.01096665f, 0.04636493f, 0.05996548f, 0.12594613f, 0.02338436f, 0.11907337f, -0.04061290f, 
    0.03038784f, 0.01112595f, 0.13872015f, 0.01821786f, -0.04447272f, 0.02508907f, -0.01012566f, 0.20625179f, 
    -0.11887836f, 0.20734398f, 0.03135177f, 0.39886644f, -0.35797158f, 0.09801947f, -0.11014234f, 0.48065934f, 
    0.08926545f, 0.34623250f, 0.22473264f, 0.20443347f, -0.09503231f, 0.08915918f, 0.08906560f, 0.15077180f, 
    -0.21690214f, 0.02491338f, 0.33421019f, 0.01503997f, 0.29717943f, 0.01941363f, 0.20950861f, 0.14915751f, 
    0.08892034f, 0.09882446f, -0.00178707f, -0.04145128f, -0.06023450f, -0.08195966f, -0.08091751f, -0.05816591f, 
    0.09343032f, -0.09386674f, 0.09431338f, -0.03702017f, -0.09429019f, -0.13813852f, 0.03538310f, -0.16764414f, 
    0.41069692f, 0.38805187f, 0.17256266f, -0.29122472f, -0.05293996f, 0.12728721f, 0.29865673f, 0.08309504f, 
    0.02058386f, 0.02209142f, -0.06791382f, 0.05603154f, -0.39652401f, -0.36654258f, -0.15421359f, 0.10963045f, 
    0.14325738f, 0.12198552f, -0.08287810f, -0.08429075f, -0.07289548f, 0.12047154f, 0.11540151f, 0.05197356f, 
    0.11275949f, 0.01249938f, 0.07283194f, -0.01790405f, 0.01869736f, 0.05536259f, 0.11888728f, 0.00806749f, 
    0.03209703f, -0.18477076f, -0.15785378f, -0.21446382f, -0.28689626f, -0.02886165f, 0.10185979f, -0.01886957f, 
    0.14996974f, -0.08051670f, -0.03653504f, 0.01661105f, 0.00464823f, -0.06077136f, 0.06066949f, -0.16191842f, 
    0.28866586f, 0.12727320f, -0.02925049f, -0.07473709f, 0.17102684f, 0.24920365f, -0.02909176f, 0.09047288f, 
    0.12350567f, 0.07023393f, 0.05456157f, 0.24421196f, -0.14638114f, -0.15497538f, -0.12233133f, -0.07187708f, 
    -0.04009627f, 0.03033122f, 0.03691853f, -0.08486641f, 0.13779238f, -0.02106101f, 0.04010653f, 0.11019547f, 
    0.00503433f, -0.05149541f, -0.24598217f, -0.07090001f, 0.01192055f, -0.09705754f, -0.02376461f, -0.03541688f, 
    -0.19885291f, -0.07333407f, 0.05925475f, -0.11010883f, -0.02251884f, 0.21569616f, 0.07100510f, -0.27068961f, 
    0.05167585f, 0.09663416f, 0.07321891f, 0.05221805f, 0.02548884f, -0.10684045f, -0.08846170f, -0.09648918f, 
    0.02809880f, -0.28575090f, 0.19133374f, 0.06421147f, 0.16129880f, -0.00374074f, 0.06575225f, 0.11069606f, 
    0.03055576f, 0.25519693f, 0.11571492f, -0.08364665f, 0.04087250f, -0.24218409f, -0.14740930f, -0.19991738f, 
    0.06102810f, 0.10540321f, -0.11784949f, -0.02377506f, 0.26997656f, -0.04336713f, 0.07216000f, -0.08641681f, 
    -0.35591462f, -0.13564636f, -0.35907507f, -0.23856419f, 0.16741256f, -0.11206555f, -0.07861743f, -0.08588147f, 
    -0.03010224f, -0.06664057f, -0.03651953f, 0.01906947f, -0.05729705f, -0.11089543f, -0.07107585f, 0.04467896f, 
    -0.06840436f, -0.04574817f, 0.11000027f, -0.05394074f, 0.00149525f, 0.09547750f, -0.02679642f, 0.18239270f, 
    -0.20375268f, 0.18655907f, 0.14641869f, 0.29202920f, -0.05287614f, -0.15266792f, 0.04844099f, 0.10630824f, 
    -0.00364962f, 0.37309316f, -0.05095565f, -0.20939684f, 0.11421248f, 0.06975894f, 0.18443277f, -0.06245768f, 
    0.01596020f, -0.04431884f, 0.05368902f, 0.06023201f, 0.09365243f, 0.16494709f, -0.03996125f, 0.11230336f, 
    0.11852304f, 0.19838680f, -0.10961150f, -0.21893729f, -0.06059271f, 0.14999448f, 0.04764422f, 0.05269982f, 
    -0.06710684f, -0.05440345f, -0.00588050f, 0.16042979f, -0.23644249f, 0.07240789f, -0.07794552f, 0.00578078f, 
    0.02068634f, -0.09527350f, 0.02839736f, -0.07427187f, -0.02001962f, 0.06012893f, -0.10206800f, 0.00307018f, 
    0.16877775f, 0.08782443f, -0.19087742f, 0.24475330f, -0.02056262f, 0.12477902f, 0.06096821f, 0.18804951f, 
    -0.07355539f, -0.10423477f, 0.02415039f, 0.02043613f, 0.24483980f, -0.20275569f, 0.42045990f, 0.22098620f, 
    -0.22937515f, -0.08380159f, -0.05642993f, -0.15319575f, 0.00229721f, 0.25763670f, -0.18343894f, 0.09655000f, 
    0.01767998f, 0.10071918f, -0.02995499f, 0.33982319f, 0.09752575f, -0.08890081f, -0.13936393f, -0.07137264f, 
    0.04746907f, -0.00766991f, 0.04929090f, 0.13565923f, -0.12766047f, -0.41440848f, 0.01525905f, -0.01108888f, 
    -0.04801362f, -0.04490578f, -0.07954280f, -0.17471196f, 0.03570089f, 0.02579812f, -0.05737339f, 0.00733989f, 
    -0.22086792f, 0.17767912f, -0.18376862f, 0.01318769f, -0.21702085f, -0.08432960f, 0.19620481f, -0.01258607f, 
    -0.20042023f, -0.03054656f, -0.00673814f, -0.16530167f, 0.06102359f, -0.01049964f, -0.21180823f, 0.02004011f, 
    -0.03917371f, -0.01838054f, -0.01986764f, 0.06628579f, -0.14555401f, 0.05950161f, 0.04905255f, -0.10154484f, 
    0.01284046f, 0.12768553f, 0.07065107f, 0.08355416f, 0.00880295f, 0.00220114f, -0.22216991f, 0.02126190f, 
    0.09007628f, -0.05680179f, -0.10334998f, 0.13003010f, 0.59684134f, 0.40726390f, 0.17565584f, 0.39182472f, 
    0.11691997f, -0.02953088f, 0.00242643f, 0.03627438f, 0.01722884f, 0.07788033f, -0.05190464f, -0.06422830f, 
    -0.79338241f, -0.18733141f, 0.25034767f, -0.19735418f, -0.14446571f, 0.28870580f, -0.10060558f, -0.19188440f, 
    -0.13755803f, -0.22619297f, -0.03819565f, 0.10952664f, 0.38268909f, 0.37776086f, 0.11774845f, -0.08590745f, 
    -0.04242685f, 0.00755019f, 0.15584819f, -0.10980734f, -0.11532993f, 0.06775609f, -0.04169309f, -0.05723835f, 
    -0.47111493f, 0.01505857f, 0.37364295f, -0.14038950f, 0.10116886f, -0.00380976f, -0.15656993f, -0.11136622f, 
    0.11500543f, 0.11322274f, 0.18346734f, -0.13018039f, 0.08858148f, 0.02323092f, -0.01051098f, -0.06621505f, 
    0.05321698f, -0.16311558f, 0.06746703f, 0.05335738f, -0.23434658f, 0.12868452f, 0.03717423f, -0.02013789f, 
    -0.03073057f, 0.04130836f, 0.00125784f, 0.10237499f, -0.09551787f, 0.23763178f, -0.10232890f, -0.09831325f, 
    0.00557547f, -0.13886960f, -0.10436039f, 0.13421950f, -0.23882599f, 0.17898338f, 0.05153415f, 0.18733305f, 
    -0.01595973f, 0.03700051f, 0.05129203f, 0.13603589f, 0.05609932f, 0.01005822f, 0.11317521f, -0.14250310f, 
    0.21393703f, -0.18493623f, 0.05714663f, 0.25509503f, 0.03996425f, -0.02766035f, 0.08078150f, 0.06921279f, 
    0.10383368f, 0.03826502f, 0.04161874f, 0.06806903f, -0.16626158f, 0.01552486f, -0.03155497f, 0.23860444f, 
    0.08308704f, 0.01857680f, 0.08170000f, -0.07541719f, -0.02813310f, 0.00725837f, -0.02461417f, 0.00088809f, 
    0.04583146f, 0.02558936f, -0.02034417f, 0.01830088f, -0.07178532f, -0.02541411f, -0.01573452f, -0.00729453f, 
    0.00175956f, 0.07690687f, -0.02615405f, 0.09080821f, 0.12479348f, -0.24531226f, 0.48038584f, -0.25877064f, 
    -0.20400488f, -0.01201706f, 0.01320153f, 0.00224208f, -0.23476627f, 0.19932839f, 0.03199514f, -0.00532384f, 
    0.03754581f, 0.07889345f, -0.23009859f, 0.20122996f, -0.02223615f, 0.03429602f, 0.06646687f, -0.08856410f, 
    0.09043550f, -0.14040399f, 0.18715627f, -0.12516284f, -0.11271948f, 0.21857595f, 0.01553452f, 0.03076632f, 
    0.00301408f, 0.06420159f, -0.11195341f, 0.07412827f, -0.04113521f, 0.17922305f, -0.30589509f, 0.10990249f, 
    0.04271376f, 0.12290331f, -0.41455966f, -0.03914832f, -0.05453216f, 0.12269583f, 0.08521760f, -0.10098827f, 
    0.05064735f, -0.02388490f, 0.01243524f, -0.06346578f, 0.01767921f, -0.06510617f, -0.11297641f, 0.03279992f, 
    -0.13646972f, -0.14714028f, -0.13858788f, 0.03109074f, -0.01913537f, 0.20870243f, 0.12575227f, -0.02211846f, 
    0.04286532f, 0.25635827f, 0.01708277f, 0.01192734f, -0.16456507f, -0.05752622f, -0.00754384f, -0.12660250f, 
    -0.07467520f, -0.19634770f, 0.11630131f, 0.13516098f, 0.30493599f, 0.09454796f, 0.13052033f, 0.28270066f, 
    -0.01589662f, -0.01494001f, 0.00111023f, -0.07904589f, -0.03487670f, 0.07003566f, -0.03098517f, -0.02294188f, 
    -0.10908233f, 0.26517090f, 0.13459511f, -0.08939689f, 0.14055805f, 0.01507831f, -0.16297162f, 0.01157649f, 
    0.16575114f, 0.10908429f, 0.27342948f, 0.03551077f, -0.08598904f, 0.28491735f, 0.17700881f, 0.12987714f, 
    0.07993954f, 0.12612353f, 0.30155373f, 0.17508911f, 0.13914333f, 0.14346159f, 0.04436841f, 0.16162553f, 
    -0.12551576f, 0.12236493f, 0.12559137f, -0.44986609f, -0.07430305f, -0.06693625f, -0.15893242f, -0.07653630f, 
    -0.06283467f, -0.03939588f, -0.03568326f, -0.01307185f, -0.07032464f, -0.19005235f, -0.21342245f, 0.02294091f, 
    -0.01620260f, 0.15578045f, -0.18156864f, 0.00009607f, -0.06737042f, 0.07209644f, -0.05498413f, 0.07560834f, 
    0.08291157f, -0.34986606f, -0.17492688f, 0.08166227f, -0.13827688f, 0.06118924f, 0.03156989f, -0.11085065f, 
    0.13259442f, 0.19355077f, -0.02140397f, 0.13527797f, -0.13754801f, 0.01472863f, -0.30012080f, 0.10455649f, 
    0.11454342f, -0.11049666f, 0.20017484f, -0.11309697f, 0.15070932f, 0.13147803f, 0.10628190f, -0.03405688f, 
    -0.25857270f, -0.33213207f, -0.20525880f, 0.08527181f, -0.10448813f, 0.02031395f, 0.13941866f, 0.12145101f, 
    0.12067925f, -0.02565600f, 0.10806588f, 0.12716416f, -0.22247055f, 0.08730879f, -0.13395722f, -0.17892292f, 
    -0.20166665f, -0.05727139f, -0.14939150f, -0.04177406f, 0.09131765f, 0.00393187f, -0.06945600f, 0.11412118f, 
    0.34268221f, 0.23800634f, -0.11798520f, -0.30097154f, -0.03914097f, 0.04057445f, 0.03091409f, 0.24719124f, 
    0.11672086f, 0.01128675f, -0.07312635f, 0.03386755f, -0.16642958f, 0.08548527f, -0.10494448f, 0.56824529f, 
    -0.04907190f, -0.00330192f, 0.43721285f, 0.03675530f, -0.16220354f, 0.04337819f, -0.08202913f, 0.12421806f, 
    0.29789516f, -0.18955301f, 0.01676672f, -0.15687156f, -0.05870958f, 0.01068581f, 0.05465284f, -0.20846938f, 
    -0.03382927f, -0.17980090f, -0.08144878f, -0.30418658f, 0.07054172f, 0.16558823f, 0.25834844f, 0.01419854f, 
    0.11103817f, -0.06594566f, -0.13501328f, 0.03219968f, -0.03963019f, 0.12946184f, 0.11379467f, 0.18570530f, 
    0.15708639f, 0.00902398f, -0.13383086f, -0.09465567f, 0.19725749f, 0.25542027f, 0.12192119f, 0.10708841f, 
    -0.04940185f, -0.01406373f, -0.01606110f, 0.09509238f, 0.05229964f, 0.09441273f, 0.02453230f, 0.08517110f, 
    -0.09773929f, -0.04695681f, 0.00837848f, -0.02546116f, 0.02564571f, 0.10729467f, 0.09205691f, 0.08145287f, 
    0.32115120f, 0.07489865f, 0.14035124f, 0.02449938f, -0.05118668f, -0.16768342f, -0.13891965f, -0.19062354f, 
    0.15388606f, -0.03705509f, -0.06353153f, -0.02142281f, -0.04099302f, 0.00134874f, -0.29324874f, -0.36371231f, 
    -0.04167374f, 0.09243633f, -0.04757178f, 0.03319437f, -0.18904129f, -0.00533499f, -0.16313981f, -0.33987156f, 
    0.33447576f, 0.32428503f, 0.06673882f, -0.01101837f, 0.13498719f, 0.10076898f, -0.08021368f, 0.07917204f, 
    0.04727703f, -0.04694755f, 0.25173867f, 0.08081082f, 0.12068735f, -0.02372091f, 0.00751457f, -0.10649590f, 
    -0.19999523f, 0.04443440f, 0.11692204f, 0.06441534f, 0.31354356f, 0.20147836f, 0.02924327f, -0.06840231f, 
    -0.24136923f, 0.21224467f, -0.34401336f, -0.09916993f, -0.08436856f, -0.13139932f, -0.09935465f, -0.24939090f, 
    -0.18905112f, -0.06403127f, 0.04282724f, -0.00449155f, 0.03986401f, -0.00328861f, 0.12726459f, -0.00538982f, 
    -0.08729573f, -0.12165651f, 0.08229240f, 0.00130677f, 0.01130952f, 0.20454608f, 0.12103117f, 0.11971302f, 
    -0.07244296f, 0.12394340f, 0.15591927f, 0.32783258f, -0.14955683f, 0.02515923f, 0.00876756f, -0.01547111f, 
    0.10900520f, 0.27680650f, 0.17697668f, 0.21987998f, -0.12218606f, -0.04055347f, -0.06346262f, -0.08358781f, 
    0.22205457f, 0.04457067f, 0.30237237f, 0.06600299f, -0.09696018f, 0.22050583f, 0.06077037f, 0.11626583f, 
    -0.19510289f, -0.09169143f, -0.04645201f, -0.18018048f, 0.16136526f, 0.05820511f, 0.14593884f, 0.05955869f, 
    0.02469685f, -0.12334710f, -0.02543650f, 0.10190559f, -0.03609883f, -0.01857274f, 0.15876581f, 0.03523917f, 
    0.10025323f, 0.18365514f, 0.01336433f, 0.00213256f, 0.01011518f, 0.09176976f, 0.20476350f, 0.02825159f, 
    -0.03951820f, -0.05855486f, -0.01979693f, -0.05484661f, -0.03144500f, 0.03003643f, -0.05925401f, -0.01749670f, 
    0.05198830f, 0.06465978f, 0.01175288f, 0.02897296f, 0.03656799f, 0.06243066f, 0.06383038f, 0.04021865f, 
    -0.05457478f, 0.02469678f, -0.04534274f, -0.00862750f, 0.03540244f, 0.00588183f, -0.02178109f, -0.01546625f, 
    -0.01204462f, -0.06765577f, -0.03830335f, -0.05359279f, 0.05482988f, -0.00470191f, -0.05262007f, -0.03883255f, 
    -0.02798224f, -0.05936726f, -0.04445940f, -0.02432319f, -0.06373905f, -0.05605792f, -0.05161281f, -0.00342258f, 
    -0.04221407f, -0.06291250f, -0.06569089f, -0.04663606f, 0.01337298f, -0.07280039f, -0.06492748f, -0.02727567f, 
    0.04304507f, 0.05327348f, -0.03638609f, -0.01931034f, 0.03655171f, -0.00075261f, 0.00947704f, 0.05671049f, 
    -0.06907052f, -0.06661603f, -0.04310887f, -0.06415661f, 0.04941097f, 0.04010241f, -0.00246746f, 0.02707435f, 
    -0.06393457f, 0.00692405f, 0.03604365f, -0.06060599f, -0.00954845f, -0.03945385f, 0.00002152f, -0.05295821f, 
    0.01833017f, 0.00493628f, -0.05046170f, -0.03278410f, 0.00449753f, -0.06207519f, -0.01030411f, 0.05733442f, 
    0.05703920f, 0.05881755f, 0.03325381f, -0.03019505f, 0.03938422f, -0.06361864f, 0.03671353f, -0.00502382f, 
    -0.01258140f, -0.06840562f, -0.07524085f, 0.00562754f, 0.00853297f, 0.04127797f, -0.03066731f, -0.06187506f, 
    0.02308641f, -0.03532518f, -0.06420693f, -0.05234768f, 0.07207165f, -0.05259201f, 0.04177768f, -0.00887628f, 
    0.00066786f, 0.00519953f, -0.03894403f, -0.05377861f, -0.05718414f, -0.03758616f, 0.05034544f, -0.06223890f, 
    0.02505980f, -0.00183851f, -0.04618539f, -0.07248668f, -0.02009198f, -0.02470745f, -0.04071227f, -0.04407017f, 
    -0.06221386f, 0.02194494f, -0.02125802f, 0.05689065f, 0.05826715f, -0.01802978f, 0.07242599f, -0.03919760f, 
    0.06935789f, 0.05033739f, -0.05647148f, 0.03658336f, 0.06169700f, 0.02322270f, 0.06501748f, -0.07683208f, 
    -0.06491894f, -0.06516122f, 0.00133665f, 0.00873491f, 0.00914667f, 0.02716633f, 0.00947695f, -0.01727225f, 
    -0.01427203f, -0.07688443f, -0.02412646f, 0.04582070f, 0.02637133f, -0.06616356f, -0.04591786f, 0.04249085f, 
    -0.02066758f, 0.06736389f, 0.00689078f, 0.06364617f, -0.02419667f, 0.01217939f, -0.02391434f, 0.03472482f, 
    0.01143209f, -0.06858012f, 0.05404912f, -0.05391818f, 0.03798108f, -0.01781994f, -0.03591142f, 0.01990359f, 
    -0.00805224f, 0.02953549f, 0.04425625f, 0.02509062f, 0.03293040f, 0.00594121f, -0.04166233f, -0.07744317f, 
    0.00170637f, -0.02876267f, 0.01038125f, -0.03960596f, -0.06987429f, -0.05667552f, -0.06379870f, 0.01646880f, 
    0.01235884f, 0.03557269f, 0.04385516f, -0.07671265f, 0.02072708f, 0.04173675f, 0.01967858f, 0.03446664f, 
    0.16251869f, 0.24042566f, 0.25197038f, -0.32905445f, -0.03534585f, 0.06798796f, 0.16062291f, -0.12830012f, 
    0.15179381f, 0.04353510f, 0.11672144f, 0.00691503f, -0.17722945f, -0.08280647f, 0.02299400f, -0.28680852f, 
    0.29134396f, 0.04317605f, -0.04067530f, -0.06573744f, -0.19012430f, -0.06733851f, 0.11579110f, -0.07615405f, 
    0.09670596f, -0.27692148f, 0.33659592f, 0.05461975f, -0.04257049f, 0.03831443f, 0.10038867f, 0.01944729f, 
    -0.10202692f, -0.07771940f, -0.09543206f, -0.07640073f, 0.27066463f, 0.30878451f, 0.07038985f, 0.28547934f, 
    0.02619764f, 0.01262709f, -0.02587418f, 0.09896408f, -0.08182568f, 0.01095554f, 0.04281604f, 0.14882070f, 
    0.33190292f, 0.04694831f, 0.30693507f, 0.08438582f, 0.21544623f, 0.16927747f, -0.23729134f, 0.08062787f, 
    -0.01459697f, -0.14441732f, -0.03135474f, 0.14457342f, 0.25572902f, 0.00659955f, 0.07584606f, 0.18223685f, 
    0.02864256f, -0.01247024f, -0.02133153f, 0.03131181f, -0.06314385f, 0.00609891f, -0.01857433f, -0.07056354f, 
    0.44190812f, -0.04662939f, -0.11366481f, 0.03676584f, -0.22887489f, 0.06403686f, 0.04721330f, 0.06115049f, 
    -0.07984199f, 0.16814987f, 0.12525892f, -0.05595537f, -0.51007938f, 0.15194646f, 0.05760464f, -0.17884119f, 
    -0.07228315f, -0.02537326f, 0.12780185f, -0.19778557f, 0.05255983f, -0.09022839f, 0.04550350f, -0.12200249f, 
    0.38551867f, -0.14737816f, 0.22403041f, 0.37952173f, 0.18305621f, -0.03454370f, 0.03512406f, 0.10030153f, 
    0.09141839f, 0.17719644f, 0.29380876f, 0.09044155f, -0.32401815f, -0.24774423f, 0.18078838f, -0.59033316f, 
    -0.16438733f, 0.02080827f, -0.13595420f, -0.05072496f, -0.00444933f, 0.05758819f, 0.12869596f, -0.01327249f, 
    0.64843225f, 0.37533394f, 0.19941245f, 0.12679458f, -0.01412538f, -0.17551047f, -0.14349090f, 0.06572095f, 
    -0.14043987f, -0.13114385f, -0.12101698f, 0.05403382f, 0.22623223f, 0.07586871f, -0.11777434f, 0.04921439f, 
    -0.08595835f, 0.22671631f, 0.03250222f, 0.04977292f, -0.01848896f, 0.03537785f, -0.25554314f, 0.10291662f, 
    -0.49878517f, -0.35914174f, 0.40519509f, 0.47859183f, -0.04202257f, -0.22834821f, -0.05311660f, -0.03492608f, 
    0.33132923f, 0.22313149f, 0.04748670f, -0.10216989f, 0.19000989f, -0.07477792f, 0.28907627f, -0.14883286f, 
    -0.05045836f, -0.15836889f, 0.21307467f, -0.03125278f, -0.02861864f, -0.04289162f, 0.02316347f, 0.06761365f, 
    -0.28376541f, 0.09390193f, 0.16669130f, -0.12703323f, 0.04282239f, 0.20335598f, -0.02276254f, 0.05748930f, 
    0.09410270f, -0.04675175f, -0.08849426f, 0.03985934f, 0.06061601f, 0.15597756f, 0.00631171f, 0.01850953f, 
    0.12433562f, -0.14771058f, -0.06483512f, -0.01804549f, 0.04242343f, 0.01922095f, 0.08893268f, 0.04592203f, 
    0.23138955f, 0.51031315f, 0.32624480f, -0.04724003f, -0.02543276f, -0.03467640f, 0.28870043f, 0.02190881f, 
    0.06865881f, -0.05414210f, -0.08937943f, 0.06804763f, -0.30931067f, -0.00915570f, -0.18932234f, 0.05200493f, 
    0.25231221f, 0.12454956f, -0.12079111f, 0.10861953f, -0.03685509f, 0.20265517f, 0.08750609f, 0.07771117f, 
    0.00368542f, 0.06254587f, -0.04434888f, 0.08277880f, 0.06707254f, 0.05696403f, 0.11815970f, -0.01968626f, 
    -0.00048977f, -0.22971836f, -0.03546983f, -0.05924306f, -0.11804262f, 0.13513388f, 0.09646180f, 0.12795015f, 
    0.17843109f, 0.00583610f, -0.07527000f, 0.06666953f, 0.03655232f, -0.02173612f, -0.20073800f, 0.04182176f, 
    0.31276223f, 0.06174013f, -0.00395965f, -0.05181015f, 0.27440664f, 0.12067923f, 0.00091490f, -0.00302485f, 
    -0.02376314f, 0.01176274f, 0.01060217f, 0.19665365f, -0.21267514f, -0.20899114f, -0.12233374f, -0.03546782f, 
    -0.02159566f, 0.10038067f, -0.12209363f, -0.16160129f, 0.05635386f, 0.18729030f, 0.02068214f, 0.04111888f, 
    -0.13655987f, 0.20622110f, -0.28207329f, 0.01296668f, -0.12279928f, -0.08487254f, -0.03654909f, -0.15678313f, 
    -0.20000280f, 0.13842832f, -0.09859698f, -0.18319564f, 0.04741709f, 0.08260854f, 0.01378657f, -0.11916207f, 
    0.23388085f, 0.18002808f, 0.13394268f, -0.01098687f, -0.04826115f, -0.05415826f, 0.04967036f, -0.02564901f, 
    0.21802810f, -0.10365592f, 0.18213223f, 0.02212981f, 0.12871264f, -0.07339683f, 0.03814997f, -0.05940182f, 
    0.07711083f, 0.10625731f, 0.14131169f, 0.07928874f, -0.22442533f, -0.58530504f, -0.21723199f, -0.18593593f, 
    0.10731602f, 0.08573170f, -0.11368265f, -0.09987751f, 0.18389483f, 0.02246183f, 0.17516688f, 0.06803073f, 
    -0.06222514f, 0.06837591f, 0.32913515f, 0.10709625f, 0.14302261f, -0.20662175f, -0.19600885f, -0.12796149f, 
    -0.04268345f, -0.11608023f, -0.11252804f, 0.09023351f, -0.08087855f, -0.05663510f, -0.19650623f, 0.02823143f, 
    -0.03329808f, 0.07111809f, -0.03134697f, -0.04777193f, 0.11205284f, 0.04366737f, 0.12723793f, 0.03324676f, 
    0.18501067f, -0.07909027f, -0.28435916f, 0.34280139f, 0.06242867f, -0.09990118f, 0.10137660f, -0.05816423f, 
    0.07458023f, 0.19758514f, 0.04619437f, -0.12136115f, 0.24101944f, 0.29196382f, -0.02322211f, 0.01411949f, 
    0.15390472f, -0.19916713f, 0.15358892f, -0.05572064f, 0.03746510f, -0.01417083f, -0.06212415f, 0.14552003f, 
    -0.00581441f, 0.13457145f, -0.21122141f, -0.13059588f, 0.10750890f, 0.22490549f, 0.10948275f, 0.01910539f, 
    -0.11408202f, -0.04653756f, 0.05303597f, 0.08068849f, -0.18287966f, 0.03725281f, -0.06733111f, -0.05866110f, 
    -0.01641339f, -0.06480476f, -0.09592556f, -0.11645895f, 0.08491793f, 0.07552857f, 0.08801761f, 0.13803385f, 
    0.07415798f, 0.19699490f, -0.09660549f, 0.02097579f, 0.00075904f, 0.04768556f, 0.04274836f, 0.03505068f, 
    -0.05148930f, 0.10798486f, 0.06167172f, -0.00015958f, 0.12420674f, -0.21454242f, -0.01430231f, 0.05600309f, 
    0.00533007f, -0.12301538f, -0.31009364f, 0.01926381f, 0.19524412f, -0.10810877f, 0.07467230f, 0.17733571f, 
    0.03621626f, -0.02100337f, -0.17771782f, 0.39128119f, 0.07293945f, 0.09968677f, 0.07331190f, -0.01586459f, 
    0.18313852f, 0.17644230f, 0.27506429f, 0.40929818f, -0.22696288f, -0.40681225f, -0.14173301f, -0.11237289f, 
    0.06787512f, 0.12867506f, -0.19568986f, -0.19512717f, 0.17482252f, -0.09126475f, -0.06496842f, 0.21914081f, 
    0.10946612f, 0.17431100f, -0.02613327f, -0.09441503f, -0.01689108f, -0.09611885f, 0.13750875f, -0.20137760f, 
    -0.05997400f, -0.03730091f, -0.04428259f, -0.08117888f, -0.19069837f, -0.44567078f, -0.01282210f, 0.06323794f, 
    0.39075518f, -0.00005072f, -0.04323983f, 0.04151521f, -0.22179042f, -0.20218612f, -0.05370761f, -0.17913143f, 
    -0.14287651f, -0.10640071f, -0.08129688f, 0.06703930f, -0.02007777f, -0.16594163f, 0.02109940f, -0.07565278f, 
    0.15389276f, 0.23468517f, -0.01925829f, 0.34699067f, 0.20056760f, -0.03173608f, 0.23789161f, 0.33510625f, 
    0.04166468f, 0.26739410f, 0.08656294f, -0.04574752f, 0.03150693f, -0.05467081f, 0.14163932f, 0.17437153f, 
    -0.61696452f, -0.32292181f, 0.22680533f, -0.21587478f, -0.16941699f, -0.01238686f, -0.14941555f, -0.06519461f, 
    0.03221574f, -0.11249930f, 0.08907472f, 0.13393661f, 0.02025619f, 0.16716981f, 0.30230910f, 0.28951067f, 
    0.09662999f, -0.00606313f, -0.05778424f, -0.00543304f, -0.05031374f, -0.05141271f, 0.03009959f, -0.03169380f, 
    -0.32574072f, 0.18955864f, 0.47199553f, 0.03832915f, 0.21287528f, -0.01797045f, 0.00213643f, 0.21842346f, 
    -0.00470276f, -0.06834263f, 0.15908000f, -0.15239492f, 0.07177126f, -0.28497460f, -0.20678896f, 0.01020379f, 
    0.14039041f, 0.06977873f, 0.11142680f, -0.00881689f, -0.14070556f, -0.04551631f, -0.21854028f, -0.06375142f, 
    -0.00807035f, -0.20820682f, -0.63298196f, -0.09856054f, -0.12561482f, 0.13608648f, 0.10505173f, 0.08204607f, 
    0.01847312f, -0.11396451f, 0.12966986f, -0.01338854f, 0.18102770f, 0.11569729f, -0.11425440f, -0.12687132f, 
    0.10422232f, 0.01636229f, -0.03629131f, -0.18007608f, 0.03480710f, 0.05894861f, -0.10922462f, -0.14536163f, 
    0.29357779f, 0.18247539f, -0.24277070f, 0.09228034f, 0.13027844f, -0.02314967f, 0.06783354f, 0.05820818f, 
    0.20694669f, 0.13752474f, -0.00879627f, 0.07932255f, -0.11123151f, -0.69876599f, 0.17259318f, 0.04077395f, 
    -0.19294751f, -0.03058684f, -0.09666337f, 0.11237498f, -0.15289158f, 0.09664034f, 0.00821500f, -0.11661499f, 
    0.07750611f, 0.00253072f, 0.19148047f, 0.07508582f, 0.13716951f, 0.13271597f, 0.11262069f, -0.01096043f, 
    0.01234485f, -0.04216721f, 0.11767770f, -0.00030370f, -0.09624032f, 0.21916890f, -0.15186600f, 0.19842193f, 
    0.01855964f, -0.12528537f, 0.06224706f, 0.09149792f, 0.16396007f, 0.01779328f, 0.10133996f, -0.00792529f, 
    0.11906869f, -0.06892228f, 0.33523956f, -0.13743080f, 0.00411797f, -0.04467173f, -0.07762698f, -0.05210784f, 
    0.08374781f, -0.09372524f, -0.19379243f, 0.15002477f, -0.18580839f, -0.09559780f, -0.21459383f, 0.15643196f, 
    -0.02445703f, -0.10719574f, 0.03438405f, -0.21267122f, 0.11407003f, 0.04220573f, 0.12706114f, -0.02338498f, 
    -0.05146890f, 0.01400283f, 0.53284341f, 0.20254838f, 0.11584206f, -0.05256419f, -0.06147710f, 0.11454625f, 
    0.00529380f, 0.07580218f, -0.04863208f, 0.13525249f, -0.04517066f, 0.00697286f, 0.00502046f, -0.01030766f, 
    -0.02863982f, 0.06934244f, 0.00389469f, -0.01716061f, -0.03235875f, -0.05997035f, -0.07079906f, -0.07344412f, 
    0.08301619f, -0.34343502f, 0.00507431f, 0.02377617f, 0.05786586f, 0.05329879f, -0.00063093f, 0.17638291f, 
    0.15282056f, 0.04388824f, 0.13474174f, 0.10020295f, -0.16229334f, 0.01737056f, 0.01224810f, -0.06088312f, 
    0.08210212f, -0.18021806f, 0.06432046f, 0.03335275f, 0.14308414f, 0.01016864f, -0.04481864f, 0.02762830f, 
    -0.11718159f, 0.04198116f, 0.05381798f, 0.12781809f, -0.05000657f, -0.21049374f, -0.06490444f, -0.10188580f, 
    -0.00241541f, 0.02299048f, -0.16152284f, 0.02118580f, 0.28071350f, -0.05281987f, 0.03843306f, -0.17207640f, 
    -0.08272359f, -0.10140029f, -0.17459618f, -0.11133395f, 0.04459121f, 0.02138953f, 0.09492657f, -0.05838205f, 
    0.10139341f, -0.10249607f, -0.04642635f, 0.46114677f, -0.02892633f, 0.04145918f, -0.02943404f, 0.12763228f, 
    -0.03112928f, 0.02569065f, -0.05584092f, -0.03116424f, -0.12460682f, 0.06203365f, 0.04607665f, -0.17299217f, 
    0.02847173f, 0.12039360f, 0.23240454f, -0.03008678f, 0.05055466f, -0.03578811f, 0.04907288f, -0.03376815f, 
    -0.24949817f, -0.01923410f, 0.34056878f, -0.12280745f, 0.07982625f, -0.03844585f, -0.11878682f, -0.20264402f, 
    0.10538641f, -0.09932293f, -0.12736188f, 0.03373471f, 0.08035393f, 0.09801771f, 0.49702334f, 0.12268726f, 
    0.03374333f, 0.17645839f, -0.06398511f, 0.24716540f, -0.01283902f, -0.05280054f, 0.05643766f, 0.01005016f, 
    0.45297617f, 0.46216944f, 0.46835914f, 0.15602222f, 0.07267886f, 0.18078050f, -0.07936662f, 0.04907059f, 
    0.06285920f, -0.05462682f, 0.07321433f, -0.12289659f, -0.11939076f, -0.00981227f, -0.04171221f, -0.08179068f, 
    0.15782344f, -0.06363994f, 0.08780567f, -0.12095667f, -0.09065532f, -0.00637276f, 0.00846760f, 0.14410038f, 
    0.12797764f, 0.07855266f, 0.20166832f, 0.19235396f, 0.20594688f, -0.02436477f, -0.07992241f, 0.19642156f, 
    0.01743204f, 0.03754920f, 0.10088532f, -0.11208621f, -0.30596316f, 0.50098914f, 0.13010928f, 0.30688938f, 
    -0.07804611f, 0.01346423f, 0.09775127f, 0.08206613f, 0.13051400f, -0.06488742f, 0.19242081f, -0.05109201f, 
    0.18967488f, -0.17170106f, 0.03894953f, 0.16292645f, 0.07831878f, 0.09441356f, -0.13961996f, 0.10356953f, 
    0.15632816f, 0.19924194f, 0.12069229f, 0.28223920f, 0.03691911f, 0.01776068f, -0.05939478f, -0.10367388f, 
    -0.21877009f, 0.02938623f, -0.02787991f, -0.24026743f, 0.04987686f, -0.07897522f, 0.14552107f, 0.23316967f, 
    0.16300325f, -0.11363673f, 0.50945544f, 0.12371539f, 0.05158882f, -0.17938498f, -0.02111465f, 0.30609316f, 
    -0.13615210f, 0.08252593f, 0.01074571f, -0.10422940f, -0.02728012f, 0.06677346f, -0.00471172f, -0.14718039f, 
    0.18994652f, -0.06134333f, -0.10430622f, -0.18866797f, -0.40694553f, -0.18932167f, -0.23871912f, -0.57000315f, 
    0.03649029f, -0.05711515f, 0.20730473f, 0.05575799f, 0.01900309f, 0.09145594f, 0.22975896f, 0.30742031f, 
    0.10456779f, 0.23906556f, 0.00919253f, 0.04409246f, 0.07794435f, -0.23777205f, -0.20228475f, -0.09446754f, 
    0.01125778f, 0.05433009f, 0.10946748f, 0.14190084f, 0.18052615f, -0.01689646f, -0.06634513f, 0.33455661f, 
    0.05379093f, -0.13715887f, 0.07530452f, 0.07993692f, -0.13864906f, -0.07826322f, -0.15181284f, -0.35177895f, 
    -0.11621290f, 0.01821256f, 0.00570796f, 0.17458801f, -0.21534953f, -0.30795851f, 0.08083276f, -0.12744156f, 
    -0.08360402f, -0.01521223f, -0.27444482f, -0.27139780f, -0.05941128f, -0.01330127f, -0.13361341f, 0.04820148f, 
    0.47054407f, 0.25601628f, 0.14639625f, 0.34268630f, 0.03957925f, 0.00707617f, 0.05478341f, 0.22762690f, 
    -0.05514894f, 0.01572944f, -0.03555280f, -0.50473589f, -0.16753779f, 0.13298562f, 0.05835173f, -0.27663338f, 
    0.06757356f, 0.03357670f, 0.06166511f, -0.17325224f, -0.21339607f, -0.06054998f, -0.34375048f, -0.38834298f, 
    0.09849262f, 0.20104240f, -0.15750051f, 0.03368271f, -0.01711148f, 0.00144910f, -0.09241224f, -0.30647948f, 
    0.06797399f, -0.05669366f, 0.06931501f, -0.14180897f, 0.35833436f, -0.02777685f, 0.47559804f, -0.22328399f, 
    0.12257662f, 0.27724120f, -0.07412565f, 0.16933963f, -0.04507729f, -0.00743733f, -0.07738022f, -0.08986343f, 
    0.25413781f, 0.18557768f, 0.32756197f, 0.40590486f, 0.11959775f, 0.18601829f, -0.03819209f, 0.07099497f, 
    0.09755304f, 0.11579153f, -0.08665234f, -0.20150948f, 0.27830759f, -0.21713263f, 0.02141456f, -0.27602544f, 
    -0.02603566f, -0.07532227f, -0.24384579f, -0.35047764f, -0.20950086f, 0.13151093f, 0.06414345f, -0.31238467f, 
    -0.07407312f, -0.05906741f, 0.05331171f, -0.06166402f, 0.05207160f, -0.01024657f, -0.02310359f, 0.02825177f, 
    0.05135921f, -0.05316539f, -0.06706922f, 0.03851457f, -0.05084531f, 0.01104589f, -0.06254978f, 0.01648932f, 
    -0.01303314f, -0.00971795f, 0.04454192f, -0.02324469f, -0.04069995f, -0.01829327f, -0.03288431f, -0.01631575f, 
    0.05924224f, 0.03930864f, 0.00535646f, 0.03199054f, -0.04690360f, 0.01894207f, 0.02813349f, -0.04122242f, 
    0.06588759f, -0.06423121f, -0.08001100f, 0.03996761f, -0.05101284f, -0.00851226f, 0.03273286f, 0.00198148f, 
    -0.01339418f, -0.03557059f, -0.03483175f, -0.05441369f, 0.00271535f, 0.00521122f, 0.01113815f, -0.00870750f, 
    0.03890552f, 0.06595690f, 0.04432227f, 0.05643227f, 0.04900901f, -0.00157092f, 0.00381754f, 0.05181289f, 
    -0.03765695f, 0.05563426f, -0.04537733f, 0.05061131f, 0.03984011f, -0.01194808f, 0.01935294f, 0.00211568f, 
    -0.06053896f, -0.06183219f, -0.06074820f, -0.01286726f, -0.06121257f, 0.02619713f, -0.00073768f, -0.02821544f, 
    -0.07132013f, -0.01243532f, 0.00329899f, 0.01984022f, -0.05116353f, -0.05525025f, 0.02547481f, 0.06302280f, 
    -0.07492971f, 0.01300065f, 0.01783563f, 0.01672171f, 0.01093494f, -0.06725173f, -0.05121156f, 0.04230587f, 
    -0.07108529f, -0.05954652f, -0.01728957f, -0.04658562f, -0.06235840f, -0.02562877f, 0.05067774f, -0.03705474f, 
    0.01413968f, -0.02697722f, 0.03088884f, 0.01935698f, 0.05805553f, 0.06053403f, 0.00589195f, -0.01346541f, 
    0.06297311f, 0.03627296f, 0.01458642f, -0.04440672f, 0.04358771f, -0.01677896f, -0.02347221f, -0.03004359f, 
    0.06166974f, 0.02532044f, -0.00848229f, -0.06229524f, -0.03583670f, 0.03466496f, -0.03115536f, -0.04524239f, 
    -0.01177171f, 0.00651125f, 0.05795391f, 0.03173119f, -0.00530532f, -0.01281220f, -0.03842682f, -0.06847029f, 
    -0.05352381f, -0.03074162f, 0.00835976f, -0.05173383f, 0.05049630f, 0.06380032f, -0.00394991f, 0.06487974f, 
    -0.07496387f, -0.01423983f, -0.04063974f, -0.02886302f, -0.02585256f, 0.06022186f, -0.03264230f, 0.06550729f, 
    -0.00817689f, 0.06573623f, -0.07036056f, -0.00619717f, -0.07940272f, -0.04404435f, -0.01705684f, -0.06130265f, 
    -0.07059950f, 0.00026015f, -0.06691123f, 0.00236074f, -0.05993581f, -0.05185787f, 0.04662110f, -0.01759596f, 
    -0.04957971f, -0.05162234f, 0.03502578f, -0.06472125f, 0.04568216f, -0.04433638f, -0.03926026f, -0.05690910f, 
    -0.05290250f, 0.03573533f, -0.05676097f, 0.00007310f, -0.05920848f, 0.03341154f, 0.04293957f, -0.01148032f, 
    -0.02146225f, -0.07426780f, -0.02800041f, 0.06290419f, -0.05822094f, -0.05284598f, -0.05616634f, -0.04707875f, 
    -0.05713619f, -0.01722716f, -0.02636900f, -0.04819508f, 0.00690872f, 0.05812149f, -0.04626072f, 0.05239427f, 
    0.17144184f, 0.15150960f, -0.06141587f, 0.14764488f, 0.03981459f, -0.05610504f, -0.10768858f, 0.11017455f, 
    -0.06245546f, -0.01521654f, 0.08613513f, 0.03268330f, 0.01253601f, 0.46604928f, 0.18982296f, 0.29235521f, 
    -0.11293837f, 0.10112365f, 0.00278061f, 0.12024561f, 0.10345771f, 0.01906397f, 0.18437737f, 0.02004422f, 
    0.19635797f, 0.24859412f, -0.21701965f, 0.08386210f, 0.05525507f, 0.04497939f, -0.01310435f, -0.09514346f, 
    -0.04229590f, -0.02278282f, 0.12576315f, 0.19223525f, -0.14983073f, -0.08921867f, 0.05941364f, -0.14214814f, 
    -0.05025047f, -0.04317291f, -0.09876405f, 0.02534467f, 0.05821316f, 0.05864665f, -0.13509502f, -0.04338671f, 
    -0.09689575f, 0.02204844f, 0.11310941f, 0.06794561f, -0.09620439f, -0.15419184f, 0.07432100f, -0.05277368f, 
    -0.17520261f, 0.06036873f, -0.04688396f, -0.05550611f, -0.02719386f, 0.01668124f, 0.07806114f, 0.03323260f, 
    -0.02629937f, -0.03266645f, -0.06941184f, -0.01164231f, -0.19649558f, 0.00802705f, 0.05862195f, -0.16393341f, 
    -0.04932947f, 0.34816605f, 0.22719862f, 0.20034607f, -0.04559222f, -0.01106863f, 0.11715856f, 0.00991762f, 
    0.15197422f, 0.21739613f, -0.02862081f, 0.23739426f, 0.70753336f, -0.18918972f, -0.28144622f, -0.11480622f, 
    0.20613320f, 0.03920121f, -0.13923813f, 0.03516469f, -0.01752483f, 0.00908682f, 0.05830954f, 0.13982359f, 
    -0.31317422f, -0.22626314f, 0.46227178f, -0.21748845f, -0.13906625f, 0.01208746f, -0.10532638f, -0.05951121f, 
    0.02111224f, -0.10143925f, -0.08749511f, -0.02526551f, 0.01051071f, -0.62839240f, -0.14754017f, 0.01721250f, 
    0.05104520f, 0.05356716f, -0.05648318f, 0.05704180f, -0.11467727f, -0.01304725f, -0.01138738f, 0.01172473f, 
    0.38095859f, 0.07514854f, 0.31726417f, 0.21077304f, -0.04344151f, -0.14366637f, -0.14549142f, -0.06275561f, 
    0.12445489f, -0.03878014f, 0.02942736f, -0.00230286f, -0.00264588f, 0.08957146f, 0.04622236f, -0.05442043f, 
    0.04392897f, -0.06502574f, -0.01379175f, -0.07074782f, -0.03938990f, 0.03311448f, -0.02851570f, -0.22953048f, 
    0.13557874f, 0.41073832f, -0.43446115f, -0.08455124f, 0.10257765f, 0.28184047f, 0.04100085f, -0.24850027f, 
    0.04355645f, 0.00126639f, 0.11473345f, 0.08629035f, 0.10712430f, 0.17704040f, 0.10840530f, -0.10696758f, 
    0.11402427f, 0.08841003f, -0.05109800f, -0.08390126f, -0.05378575f, 0.07647407f, 0.02224694f, -0.11992317f, 
    0.12453686f, 0.01576578f, 0.10064653f, 0.45418131f, 0.20619394f, 0.18673941f, 0.14418991f, 0.18600376f, 
    0.06778728f, 0.09963384f, 0.23965582f, -0.10734955f, 0.01557897f, -0.07138266f, 0.06462810f, -0.10253254f, 
    -0.05869049f, 0.07809438f, 0.02736255f, -0.06944233f, -0.01938028f, 0.09311007f, 0.12051279f, 0.05315433f, 
    -0.35429126f, -0.22861624f, 0.33059886f, 0.28693199f, -0.06750873f, 0.02400391f, 0.04653603f, 0.01966126f, 
    -0.08426845f, -0.02649736f, 0.12105019f, 0.04699505f, -0.27116084f, 0.78013670f, -0.22833793f, 0.36128712f, 
    0.06346398f, 0.17317541f, -0.21612738f, 0.08564007f, 0.09253170f, 0.06695671f, 0.20567200f, 0.01131286f, 
    0.10057943f, 0.14050475f, 0.19800824f, -0.20954382f, 0.08779815f, -0.12828593f, 0.00786431f, 0.08194011f, 
    0.07329489f, -0.10312692f, -0.15309218f, -0.04475677f, 0.04817067f, 0.19356669f, -0.02621918f, 0.09073866f, 
    0.01146783f, -0.09653546f, -0.00458719f, -0.15730786f, 0.10968010f, -0.06375944f, 0.15491511f, -0.13601770f, 
    -0.02975070f, -0.42001200f, 0.26515886f, 0.30776599f, 0.01729763f, -0.13704628f, -0.05753675f, 0.27126342f, 
    0.02283436f, 0.11305012f, -0.00906668f, -0.00620012f, -0.11103339f, -0.04323977f, 0.11624254f, -0.18286993f, 
    -0.07598870f, 0.04474339f, -0.09916339f, -0.10053165f, 0.06703871f, 0.04541181f, -0.04355721f, -0.05892189f, 
    -0.04935946f, 0.23887716f, 0.35091534f, -0.09643310f, 0.06527898f, -0.09149788f, 0.02080277f, -0.01815519f, 
    0.10282800f, 0.02409811f, 0.07650643f, -0.06359477f, -0.16061747f, -0.26655373f, -0.05383774f, 0.09909622f, 
    0.05549511f, -0.11845049f, 0.12714528f, 0.02214043f, 0.07932409f, -0.05027446f, -0.04185299f, 0.21075416f, 
    0.25040895f, 0.24847713f, -0.09019187f, 0.08574822f, 0.05953883f, -0.06433068f, -0.00436894f, -0.10204943f, 
    0.04129517f, 0.17668590f, 0.01817872f, 0.12817004f, -0.25055438f, -0.11614159f, 0.27624333f, 0.17887564f, 
    -0.11049160f, -0.07585768f, -0.04236079f, 0.10939062f, 0.06635475f, 0.10620978f, 0.00029129f, 0.27479213f, 
    -0.02939705f, 0.07762591f, 0.19719711f, 0.13160531f, 0.03150871f, -0.14821157f, 0.09733259f, 0.12441003f, 
    0.03748085f, 0.01171655f, 0.01517463f, 0.02225491f, -0.28263795f, 0.07559709f, 0.07312381f, -0.13997316f, 
    0.03015058f, 0.07781610f, -0.15857472f, -0.15130186f, 0.21297108f, 0.06395317f, 0.06419557f, 0.02706666f, 
    0.46822998f, 0.12078773f, -0.20224513f, -0.10507763f, 0.01181879f, 0.08370179f, -0.12756272f, -0.01084250f, 
    -0.15062107f, -0.02696288f, -0.01932147f, 0.10844935f, 0.23679671f, -0.01391404f, -0.05706102f, 0.30350772f, 
    -0.10614087f, 0.03282087f, -0.09166925f, 0.24708325f, 0.01558770f, 0.11141682f, 0.03330210f, 0.14269723f, 
    -0.22808941f, 0.05090345f, 0.32439369f, 0.22689961f, 0.13985503f, 0.11713695f, -0.01748366f, -0.02188079f, 
    0.04538363f, 0.07371466f, 0.03079021f, -0.10434029f, 0.06021070f, 0.00684416f, -0.04519539f, -0.09230436f, 
    0.06589966f, -0.15132551f, -0.04450327f, -0.10238399f, 0.07732718f, -0.10079544f, 0.01876647f, 0.01746816f, 
    0.01298987f, 0.18886749f, 0.09861670f, -0.02562985f, 0.05642383f, 0.10717687f, 0.11884725f, 0.00633620f, 
    -0.09738335f, -0.11626063f, -0.16090983f, -0.12204427f, -0.29796994f, -0.01305469f, 0.08772112f, 0.25730148f, 
    -0.02049225f, -0.13614306f, -0.09079384f, -0.24070901f, 0.06522648f, 0.03409758f, 0.07320385f, -0.08710791f, 
    0.25540146f, 0.11616996f, 0.06314957f, -0.07243573f, 0.01554531f, -0.00917341f, 0.04059036f, -0.12700786f, 
    0.07116565f, -0.06682446f, 0.00201981f, -0.01109800f, -0.29326615f, 0.03367251f, 0.12755382f, 0.11477216f, 
    0.07300409f, -0.10837161f, -0.10435376f, -0.27390951f, 0.13288583f, 0.08283572f, -0.09562424f, 0.10518333f, 
    0.17167801f, -0.12653635f, -0.39597833f, 0.05929676f, 0.10891844f, 0.44310769f, 0.19632888f, -0.03222963f, 
    0.00275309f, -0.08024026f, 0.06513698f, 0.04387402f, -0.13976873f, 0.04756942f, 0.01076620f, 0.02806543f, 
    0.00009883f, -0.07248686f, -0.07074000f, -0.01270382f, 0.06068445f, 0.19128570f, 0.11188448f, 0.26478085f, 
    -0.13114698f, 0.14807132f, -0.13013148f, -0.06731622f, 0.01282577f, -0.10836436f, -0.19651191f, -0.21757579f, 
    0.01379534f, -0.13414812f, -0.07614637f, 0.02422407f, 0.08938021f, 0.31033990f, 0.25970086f, 0.32614920f, 
    0.10010875f, 0.01261974f, -0.03062159f, 0.08159384f, -0.10913627f, 0.11696228f, -0.12409295f, -0.02722393f, 
    -0.42835635f, 0.16051744f, 0.03459199f, 0.05024976f, -0.09174502f, 0.11975157f, -0.19055828f, -0.13520893f, 
    0.10744169f, -0.00734919f, 0.14058338f, 0.15765329f, -0.04493251f, 0.29830024f, 0.30476570f, 0.35184386f, 
    -0.06104131f, 0.08934205f, 0.07632805f, -0.16847786f, -0.00877214f, 0.04152150f, -0.05035713f, 0.08322776f, 
    -0.84227973f, 0.23685692f, 0.19946519f, -0.08228666f, -0.00907055f, -0.01776729f, -0.04477550f, 0.07025603f, 
    -0.01174821f, 0.00622242f, 0.03742475f, 0.07422989f, -0.16871397f, -0.10603461f, -0.01966191f, -0.16976605f, 
    -0.06759980f, 0.04051968f, 0.09299826f, 0.03612652f, -0.00849940f, 0.22012179f, 0.25126353f, 0.20862253f, 
    0.16659060f, -0.02646923f, -0.15551487f, 0.08362935f, -0.15481755f, 0.12607014f, -0.14798671f, -0.01085642f, 
    -0.03175577f, -0.06244079f, 0.09082597f, -0.00232092f, 0.27858272f, 0.25408721f, -0.22609814f, 0.18833899f, 
    -0.07485001f, 0.14803812f, 0.14115624f, 0.12059742f, -0.00583359f, 0.06008401f, 0.01618886f, -0.00343704f, 
    0.10356439f, -0.10626452f, -0.36682487f, -0.00390587f, 0.14428283f, 0.05924638f, 0.10523129f, 0.19156681f, 
    -0.01612231f, -0.14308776f, -0.13424647f, 0.09578985f, -0.20864271f, -0.08696715f, 0.02190958f, 0.09186616f, 
    0.09285577f, -0.09789383f, -0.04914905f, -0.11690032f, 0.00164523f, 0.08072644f, 0.01097583f, 0.20115593f, 
    0.10735136f, 0.26585135f, 0.38060135f, 0.16155849f, -0.08375730f, 0.02804084f, 0.04666494f, -0.12032644f, 
    0.05561427f, -0.12364445f, -0.11457101f, -0.10461601f, -0.32200509f, 0.14973621f, 0.05013880f, 0.31743312f, 
    0.27801687f, 0.20109315f, -0.15695578f, 0.14653514f, 0.05331144f, 0.11675375f, 0.17051694f, -0.08082424f, 
    -0.15892625f, -0.03940945f, -0.28254521f, -0.26545563f, -0.02174697f, 0.07805640f, -0.04606122f, 0.00226361f, 
    -0.16600260f, -0.29409328f, -0.15720993f, -0.24277101f, -0.48457694f, 0.04160931f, 0.00108769f, -0.08640359f, 
    0.09945242f, 0.01100547f, -0.00564879f, -0.10604560f, 0.06352615f, 0.13560192f, 0.00165370f, 0.11695482f, 
    0.37213150f, -0.21568236f, 0.10288378f, 0.32025531f, 0.13791837f, 0.07470299f, -0.00064475f, 0.03653436f, 
    -0.07535736f, -0.04922875f, -0.00810383f, 0.04174161f, -0.14424789f, -0.09807192f, -0.04610286f, -0.07521453f, 
    -0.04813103f, 0.04762911f, -0.16894695f, -0.02153508f, 0.17811044f, 0.12645799f, 0.03818231f, 0.13939044f, 
    -0.35385805f, 0.09518214f, -0.23360385f, 0.04096813f, -0.03541533f, -0.06412912f, 0.03704968f, -0.15232821f, 
    -0.00583803f, -0.03553471f, 0.05305010f, -0.02521288f, 0.21779948f, 0.17910932f, -0.03015333f, 0.00344820f, 
    0.16144367f, -0.08551074f, 0.11678465f, 0.11672420f, -0.01329666f, 0.07255872f, -0.11091756f, 0.03845021f, 
    -0.06506956f, 0.06099774f, 0.20680156f, -0.07678070f, -0.02598776f, -0.07309747f, -0.02853339f, 0.01581666f, 
    -0.12692277f, 0.22953321f, 0.15212375f, 0.10248189f, -0.23635744f, -0.21925329f, 0.10626995f, 0.23628083f, 
    0.10548756f, 0.09600654f, 0.00920589f, 0.03495323f, 0.08607497f, 0.07569785f, 0.12775911f, 0.06351294f, 
    -0.20390195f, 0.13225509f, 0.26241177f, 0.01367735f, 0.09835545f, -0.17451721f, -0.02255510f, 0.19562216f, 
    -0.04719874f, -0.01718326f, 0.02672558f, -0.00954288f, -0.22723377f, 0.08624249f, 0.07827719f, -0.15402594f, 
    -0.01807064f, 0.14530578f, 0.11989147f, -0.06016046f, 0.02052126f, 0.16927810f, 0.21309356f, 0.16164356f, 
    0.17513473f, 0.05845337f, -0.13973545f, -0.06606602f, -0.06315309f, 0.00036953f, -0.06491514f, 0.02745902f, 
    0.11809921f, -0.01437827f, -0.05971884f, 0.04741691f, 0.44648761f, 0.28985712f, -0.08225380f, 0.13750657f, 
    -0.05215311f, 0.07003395f, -0.06780202f, 0.00352893f, 0.03401408f, 0.09379258f, 0.01256970f, 0.07997658f, 
    0.36290285f, 0.12895569f, 0.06226281f, 0.37093973f, 0.06882996f, 0.09412262f, 0.03690800f, 0.16620155f, 
    -0.11198325f, -0.12896329f, -0.00405420f, -0.05887778f, -0.06215887f, 0.04732406f, -0.06092984f, -0.16693018f, 
    0.09811999f, 0.01156220f, 0.11620688f, -0.11528328f, 0.03700931f, 0.05752740f, 0.12645531f, 0.21092443f, 
    0.03668403f, -0.08401915f, -0.08735599f, -0.22682586f, -0.13099745f, -0.06909029f, -0.15946403f, 0.05331542f, 
    -0.05786866f, 0.11679257f, -0.11678548f, 0.02023820f, -0.20878591f, 0.28357151f, 0.25055882f, -0.16643517f, 
    0.06606457f, 0.05467819f, 0.23733953f, 0.03581629f, -0.04708399f, 0.01332510f, 0.14133598f, 0.24061508f, 
    0.06363885f, -0.03833583f, 0.06297092f, 0.21712407f, 0.06838822f, 0.01667085f, 0.03207966f, 0.09577142f, 
    -0.09855682f, 0.18401529f, 0.25075138f, -0.01447572f, 0.32923213f, 0.12621997f, 0.05390752f, -0.04234928f, 
    -0.11942954f, 0.16551125f, -0.16775994f, 0.13957888f, -0.01730705f, -0.00434725f, 0.13052523f, 0.02101944f, 
    0.02163906f, 0.20325443f, 0.16197085f, -0.14135328f, -0.00927048f, -0.10325845f, 0.04644438f, 0.22697605f, 
    -0.05371201f, -0.08315768f, 0.02234072f, -0.01753665f, 0.17433622f, 0.03850586f, -0.01675804f, 0.07116066f, 
    -0.03076839f, -0.01767596f, -0.02732641f, 0.06819104f, 0.01088434f, -0.06028983f, -0.06952778f, -0.21237630f, 
    0.07322822f, 0.10278038f, 0.05161356f, -0.07393013f, -0.16902226f, 0.08811077f, 0.10209293f, 0.11660926f, 
    -0.00663238f, 0.07014842f, 0.18292651f, 0.04085326f, 0.21631528f, -0.06236472f, -0.07392383f, -0.24036060f, 
    -0.10263085f, 0.23020807f, 0.01475946f, -0.08481339f, 0.01598767f, -0.00845751f, 0.01189791f, 0.03190862f, 
    0.29237357f, -0.00242441f, 0.19366296f, 0.08407438f, 0.11867436f, 0.07531374f, 0.12801813f, -0.02699747f, 
    0.12388640f, 0.04135082f, 0.25426289f, 0.09478952f, 0.09655346f, -0.17820784f, 0.12809265f, -0.33837566f, 
    -0.10672687f, -0.13095051f, 0.00656326f, -0.05377284f, -0.10054611f, 0.14651763f, -0.01565112f, -0.05861616f, 
    0.52798003f, 0.18033189f, -0.04057860f, -0.10964063f, -0.02786450f, -0.08126022f, -0.10853608f, -0.15309955f, 
    -0.08508556f, -0.11012962f, -0.11372373f, -0.06735296f, 0.24456578f, 0.06858645f, -0.05543025f, 0.03987388f, 
    0.06846413f, 0.06735478f, 0.02587840f, 0.07264641f, -0.00400994f, -0.07193604f, -0.27324751f, -0.06798055f, 
    -0.07979587f, 0.01525541f, -0.12036262f, 0.32007071f, 0.20277795f, -0.11055896f, -0.16321029f, -0.12676683f, 
    0.12855290f, 0.28542823f, 0.19211632f, -0.03772681f, -0.15826663f, -0.06617510f, 0.07170954f, -0.22190019f, 
    0.14579366f, -0.10646003f, 0.12110011f, 0.05169035f, 0.10003039f, 0.03157207f, -0.03181607f, -0.13312589f, 
    -0.50432956f, -0.07294892f, 0.23524842f, -0.34270200f, -0.05266017f, 0.09133290f, -0.01839735f, 0.20018312f, 
    -0.09852367f, 0.07523292f, -0.02942795f, 0.03118926f, 0.17401411f, 0.04560653f, -0.03611974f, -0.07806958f, 
    -0.07705946f, 0.12426217f, -0.06608687f, -0.05332492f, -0.00449994f, 0.09967282f, 0.15918787f, -0.19112755f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.19834879f, 0.11246052f, 0.05520132f, 0.23157528f, -0.19402225f, 0.02226396f, 0.04018761f, 0.00718218f, 
    -0.05923535f, -0.02282824f, 0.07781608f, 0.21477677f, 0.00020648f, 0.06328666f, -0.02340002f, 0.45358855f, 
    0.05631552f, -0.01472759f, 0.05043260f, 0.16485491f, 0.05139131f, 0.26005012f, 0.05429568f, -0.11432239f, 
    0.10961474f, -0.03930794f, -0.07089804f, -0.22642529f, 0.03546580f, 0.06831740f, -0.03418557f, 0.18667802f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.43393752f, -0.00185727f, 0.01943579f, 0.21719678f, -0.35967690f, -0.29042175f, 0.14362015f, -0.10394776f, 
    0.05412469f, -0.06812873f, 0.42248058f, 0.20000359f, -0.07729313f, -0.20873676f, -0.09961750f, 0.27743939f, 
    0.12176687f, -0.28549892f, -0.08440626f, -0.11060005f, -0.13865861f, 0.12901092f, -0.05005640f, -0.04314870f, 
    0.11396577f, 0.18471499f, -0.11699301f, -0.20071264f, 0.28598136f, 0.16409600f, -0.11161997f, -0.11501743f, 
    -0.16256422f, 0.15351833f, 0.02835596f, 0.18781224f, -0.09483631f, 0.09078815f, -0.09042695f, 0.31643659f, 
    0.06148937f, -0.20201211f, 0.34939325f, -0.18031652f, 0.18511182f, -0.30774063f, -0.25730395f, 0.21720219f, 
    -0.21950416f, 0.11636096f, 0.45997444f, 0.08092630f, -0.01154082f, -0.31556317f, -0.03482086f, 0.05172629f, 
    0.07487934f, 0.11140539f, 0.03984980f, 0.07924095f, 0.26992834f, -0.08928631f, -0.11485337f, 0.28118497f, 
    0.00804473f, 0.27088866f, 0.09619470f, -0.21302417f, -0.42826429f, 0.27482015f, -0.11050082f, 0.13038884f, 
    -0.00340920f, -0.28377405f, -0.25173476f, 0.25493324f, 0.53303844f, -0.27009320f, 0.14042021f, 0.22184026f, 
    0.11377414f, 0.06206843f, 0.61939377f, -0.06795882f, -0.13698442f, 0.30675045f, 0.18400247f, -0.28660351f, 
    0.07235017f, -0.61459762f, 0.15820743f, -0.04086134f, -0.03777339f, -0.04999426f, 0.20823023f, 0.09525471f, 
    -0.16315256f, 0.11889963f, 0.01722928f, -0.42095473f, -0.33664078f, 0.46428415f, 0.72827965f, -0.32354566f, 
    -0.15467824f, -0.07581627f, -0.11545613f, 0.25313818f, 0.37304819f, 0.02916677f, 0.00125182f, 0.04303566f, 
    0.19279417f, 0.00274219f, -0.21314864f, 0.11179185f, 0.14291744f, 0.19151363f, 0.33990520f, -0.57390451f, 
    0.05646681f, 0.21935534f, -0.11751673f, 0.12609625f, 0.18387191f, -0.16205648f, 0.18123512f, 0.06077088f, 
    -0.13298009f, 0.01194198f, -0.15395980f, -0.18747570f, -0.11503383f, 0.09704585f, -0.06933931f, 0.02622861f, 
    -0.05167229f, 0.05286577f, -0.17847794f, -0.10327376f, 0.13589349f, -0.03337225f, 0.01608237f, 0.03369230f, 
    -0.13510241f, 0.10454788f, 0.06688369f, -0.01753363f, 0.13455160f, 0.01656654f, -0.17890604f, 0.10350877f, 
    -0.16694787f, -0.00072135f, -0.09256673f, -0.05389633f, -0.16570063f, -0.09269422f, 0.10947600f, -0.14405234f, 
    0.16191845f, 0.02640420f, 0.08671478f, 0.39137718f, -0.16934116f, -0.00614547f, -0.50904924f, 0.22505793f, 
    -0.04511023f, -0.01469394f, 0.01826849f, 0.27304733f, 0.22937606f, 0.13622572f, 0.02256186f, -0.12216891f, 
    -0.16223271f, -0.07125747f, 0.02197692f, -0.17249615f, -0.05887149f, 0.24277487f, -0.17157999f, 0.07669052f, 
    0.11283049f, 0.52258110f, -0.02920752f, 0.06335893f, 0.12596133f, -0.35643929f, -0.22759461f, 0.30693552f, 
    0.30774376f, -0.12582079f, -0.37209493f, 0.36306921f, 0.22189078f, -0.26987553f, -0.27662712f, -0.06994190f, 
    -0.04702842f, 0.24514458f, 0.34296453f, -0.20824565f, -0.21008883f, 0.20722115f, 0.02091154f, 0.25227919f, 
    -0.08640990f, -0.07211198f, -0.05835865f, 0.07461517f, -0.04200878f, -0.05929940f, -0.19814707f, 0.36754400f, 
    0.00121924f, 0.22912127f, -0.06323257f, 0.07127775f, 0.13382562f, 0.02864823f, -0.08488768f, 0.09460381f, 
    -0.22215027f, 0.44557858f, 0.12219465f, 0.07899904f, -0.02510720f, -0.00542501f, 0.04563374f, 0.30816951f, 
    -0.13200584f, 0.20482604f, -0.03958235f, 0.06473443f, -0.27824870f, 0.06051653f, -0.22340780f, -0.03404329f, 
    0.33034661f, -0.14925715f, 0.56996596f, 0.25297979f, 0.10030732f, 0.04179097f, 0.27106473f, 0.10519709f, 
    -0.16243093f, -0.48819464f, 0.15928157f, -0.13901114f, -0.15426885f, 0.43225020f, 0.10832585f, 0.01324247f, 
    -0.07424824f, -0.08417466f, 0.00154594f, -0.09940540f, 0.16784960f, 0.27887106f, -0.06338034f, -0.06619459f, 
    0.09392524f, -0.31619942f, -0.06199782f, -0.17212625f, 0.15617016f, 0.53048742f, -0.19357756f, 0.11427795f, 
    -0.35563019f, -0.04161577f, -0.17053777f, 0.19502613f, -0.05080326f, 0.30250353f, -0.20974529f, -0.19468226f, 
    -0.04931731f, 0.13439415f, -0.01590904f, 0.01006023f, -0.07033806f, -0.19383556f, -0.19419150f, 0.29840869f, 
    0.18532746f, -0.21724449f, -0.17243619f, 0.13585380f, 0.02204861f, 0.07293811f, 0.21871507f, -0.19968021f, 
    0.16080943f, 0.34817147f, -0.17828813f, 0.02953699f, 0.33867437f, 0.81134599f, 0.73762035f, 0.05605829f, 
    0.19229947f, 0.58221024f, -0.38365433f, -0.10497083f, 0.11830382f, -0.14736405f, 0.22591625f, 0.29314426f, 
    0.45849732f, -0.22504270f, -0.01880516f, 0.26559383f, -0.12179185f, 0.25882155f, 0.18330209f, -0.14121461f, 
    0.19385119f, 0.02357879f, 0.08408281f, -0.00733970f, -0.02402360f, 0.08035020f, 0.30053324f, -0.26013231f, 
    -0.00479486f, 0.12752278f, -0.53267962f, 0.10374531f, 0.29773343f, 0.40391263f, 0.20716809f, -0.02160208f, 
    0.28815460f, 0.01906092f, 0.23772639f, 0.13674302f, 0.10702943f, 0.32225826f, 0.05981912f, -0.29879612f, 
    0.20300400f, -0.22671577f, 0.15359429f, 0.07122697f, -0.12559949f, 0.21094313f, 0.26160422f, 0.21960443f, 
    0.10627671f, -0.23146239f, 0.12762468f, 0.17527711f, 0.19979914f, 0.01926799f, 0.16476470f, 0.16946939f, 
    0.07031137f, -0.02695023f, -0.27520266f, 0.04103215f, 0.22289671f, 0.36060259f, -0.00968935f, -0.07949194f, 
    -0.27860156f, 0.00354591f, -0.21290396f, 0.10364874f, 0.02183649f, 0.05268116f, -0.23186584f, 0.14815415f, 
    0.20263752f, 0.34054899f, 0.03020781f, -0.18065572f, -0.10754467f, 0.04441962f, -0.05801820f, -0.12302252f, 
    0.19558123f, 0.32553652f, 0.36234909f, -0.31496677f, -0.62911576f, -0.04841289f, -0.22683740f, 0.37970918f, 
    -0.14746352f, -0.00142416f, 0.24207664f, 0.21053328f, -0.04124836f, -0.42432714f, 0.07103638f, 0.17113279f, 
    -0.29557139f, -0.10213445f, -0.07364157f, -0.36160758f, -0.09230766f, -0.39098242f, -0.04053359f, -0.05831603f, 
    0.04472403f, 0.15949334f, -0.06834859f, 0.13268624f, 0.48484629f, 0.20323569f, 0.31926364f, -0.07568057f, 
    -0.40198332f, 0.31469750f, -0.22159916f, -0.14665475f, 0.34492263f, 0.34134996f, 0.32238552f, 0.04398838f, 
    -0.01744620f, -0.54146755f, -0.18428248f, -0.46491393f, -0.16799642f, -0.13944025f, -0.66402394f, 0.25629899f, 
    -0.17621632f, -0.83008254f, 0.06479974f, 0.40575328f, -0.13762385f, 0.16499129f, -0.09563194f, -0.45243645f, 
    -0.13380985f, 0.31722608f, 0.16992973f, 0.33389255f, 0.22859055f, 0.15840781f, -0.05476052f, 0.02197632f, 
    0.19067490f, -0.19241944f, -0.11371005f, 0.28290030f, -0.14143689f, 0.00765819f, 0.07374419f, -0.27244344f, 
    0.08327043f, -0.14223550f, 0.12393100f, -0.16221431f, -0.20075834f, 0.02913635f, 0.08211055f, -0.02642203f, 
    0.16487333f, -0.06711878f, 0.06545142f, 0.18720371f, 0.05211573f, -0.17543389f, -0.16841106f, -0.10147822f, 
    0.13471757f, 0.13546522f, -0.06379132f, -0.27675864f, -0.05238282f, 0.07203849f, -0.10303171f, 0.09848418f, 
    -0.22179808f, 0.05231949f, -0.01525246f, -0.21484806f, -0.08379457f, -0.03808143f, -0.20071532f, -0.17694856f, 
    0.03348266f, -0.01463703f, -0.04578814f, 0.07585990f, -0.04709147f, 0.10037177f, 0.05120634f, 0.04618473f, 
    -0.01908942f, -0.03462501f, 0.14339095f, -0.04310186f, 0.05488012f, -0.00526918f, -0.19256078f, -0.09173076f, 
    -0.04308229f, 0.01124516f, 0.04676176f, 0.03888498f, 0.01629298f, -0.01458022f, -0.06130555f, 0.02219281f, 
    0.07290612f, 0.13858144f, -0.41265580f, 0.36436450f, -0.26157978f, -0.19957463f, -0.11667068f, -0.12050338f, 
    -0.03313671f, -0.05833577f, 0.22304448f, 0.00795510f, -0.22457558f, 0.45447296f, 0.15668194f, -0.13562860f, 
    0.18713845f, -0.26201314f, -0.26616222f, -0.12657751f, 0.17861822f, 0.39483801f, 0.38180825f, 0.31944865f, 
    0.27265286f, 0.50245041f, -0.16110858f, 0.10927723f, 0.09674916f, -0.16289106f, 0.14835997f, 0.31581259f, 
    -0.33614078f, -0.10642923f, -0.23174787f, -0.31425092f, 0.32380676f, 0.12809141f, 0.08918619f, 0.14735632f, 
    -0.06845371f, 0.15917516f, 0.41346273f, -0.27216825f, -0.06953625f, 0.05947711f, -0.01718065f, 0.04057568f, 
    -0.06952015f, 0.22734347f, -0.16456899f, -0.27192193f, -0.12049223f, -0.52433729f, 0.18597955f, 0.42010579f, 
    0.19216813f, 0.53850579f, 0.08401933f, 0.54495370f, 0.02340381f, -0.11146113f, 0.05184909f, -0.09151655f, 
    0.02981324f, 0.11975326f, -0.03500155f, -0.20936561f, 0.15856783f, -0.11969238f, 0.25382906f, -0.02769666f, 
    -0.05665926f, -0.29964903f, 0.03760697f, -0.04815788f, -0.30172533f, 0.41880679f, -0.07347908f, 0.15695615f, 
    0.18614237f, -0.65343356f, -0.14018236f, 0.09958135f, -0.07169925f, 0.25285116f, 0.31492114f, -0.53200603f, 
    0.20290323f, 0.15960173f, -0.00964290f, 0.30016473f, 0.39584637f, -0.36710924f, 0.13346025f, 0.27504790f, 
    0.45243207f, 0.19425789f, 0.15373772f, -0.06722075f, -0.28288713f, -0.24744420f, 0.07773490f, -0.18084149f, 
    -0.15134309f, 0.16231172f, 0.25945738f, 0.36417386f, -0.21556538f, -0.20991354f, -0.06269830f, 0.17263268f, 
    0.05793311f, -0.38843518f, -0.02617637f, 0.07713246f, -0.06606638f, 0.28826424f, 0.21979168f, -0.33566990f, 
    0.19421491f, -0.11595616f, -0.10975544f, -0.18181242f, 0.35621271f, 0.03387599f, 0.04896042f, 0.15862742f, 
    -0.27804857f, 0.02394453f, -0.24637434f, 0.02724179f, -0.10244390f, 0.23297437f, -0.50653201f, 0.30728796f, 
    0.16264953f, -0.08143186f, -0.26568338f, 0.01933358f, 0.43807042f, -0.07269688f, 0.19049044f, -0.01029248f, 
    -0.30959827f, 0.24648742f, 0.35424578f, -0.15094414f, 0.11672409f, 0.31176350f, 0.12853673f, 0.40107554f, 
    -0.04316122f, -0.10873676f, 0.07188449f, 0.33140558f, 0.11273211f, -0.02068785f, 0.04205898f, 0.19418749f, 
    0.04137816f, -0.12412485f, -0.17032653f, 0.09590278f, 0.30261341f, 0.11582859f, 0.41463494f, -0.04439883f, 
    0.07102539f, 0.19279836f, -0.06395950f, -0.38616276f, -0.39942622f, 0.28743386f, -0.21765395f, 0.08919347f, 
    0.14275891f, -0.07477599f, -0.36764491f, 0.15665840f, 0.00384729f, 0.09966399f, 0.03569385f, 0.09906612f, 
    0.23005630f, 0.40646145f, 0.13838853f, 0.11319129f, 0.23291661f, 0.25677291f, 0.19311699f, -0.07556000f, 
    -0.33399075f, 0.14896679f, 0.01006893f, -0.19041836f, -0.21044058f, 0.37776387f, -0.01359174f, 0.21853314f, 
    0.16765794f, -0.23574071f, 0.01260661f, 0.03874374f, 0.31519258f, -0.36763439f, 0.24322031f, 0.33320886f, 
    -0.07837832f, 0.45800918f, 0.37908921f, 0.20705836f, -0.16226988f, -0.23361968f, -0.16844548f, -0.27345017f, 
    0.01525260f, -0.41697097f, -0.16313408f, 0.17385682f, -0.05582215f, 0.20625281f, -0.07273538f, 0.20300426f, 
    0.07817730f, 0.04718346f, 0.05407229f, 0.12962303f, 0.12138218f, 0.08803575f, 0.15351811f, 0.23692571f, 
    -0.07134818f, 0.16937757f, 0.04072818f, 0.56089073f, 0.21798602f, -1.12652206f, -0.28206655f, 0.24227418f, 
    -0.04622996f, -0.87983632f, -0.19503327f, -0.00986269f, 0.04773855f, 0.19792062f, -0.05713521f, -0.13212013f, 
    0.03035564f, -0.45989442f, -0.16413489f, 0.06234872f, -0.26407862f, -0.56903690f, -0.46788523f, 0.17726557f, 
    -0.40798783f, 0.06831585f, 0.22579607f, 0.06046369f, 0.25661477f, -0.04048770f, 0.01505224f, 0.11637249f, 
    -0.06310256f, 0.15601571f, 0.10760498f, -0.24090873f, 0.16207083f, 0.31212211f, 0.00345149f, -0.35068446f, 
    0.05704309f, 0.07055282f, -0.15005116f, -0.09275184f, 0.07897897f, -0.07814299f, 0.18653765f, -0.08512920f, 
    0.06218859f, 0.06579820f, 0.09795671f, 0.10084505f, -0.22194597f, -0.01367917f, -0.01396896f, 0.05756226f, 
    0.12986936f, 0.18455178f, -0.47442988f, 0.10727672f, 0.12082919f, -0.06107543f, 0.45443061f, 0.05371831f, 
    -0.02706074f, -0.09630097f, 0.14104368f, -0.22350802f, -0.20683582f, 0.40510896f, -0.06614893f, 0.22216728f, 
    -0.10566267f, -0.33048627f, -0.09468648f, -0.00670665f, -0.13094898f, -0.20692228f, -0.18532357f, -0.27287573f, 
    0.11914697f, 0.23687421f, -0.00907220f, 0.19454603f, 0.05831901f, -0.59775090f, -0.36106235f, 0.30807453f, 
    0.48980963f, 0.02494978f, -0.37601331f, 0.20296095f, -0.33830190f, 0.03140702f, 0.19398132f, -0.00237758f, 
    0.02163298f, 0.31140548f, -0.13278231f, 0.18621925f, -0.00242449f, -0.00647924f, 0.06401335f, 0.30796689f, 
    0.00480564f, 0.23559976f, 0.12742364f, -0.05202096f, -0.14959845f, 0.07866587f, 0.08177151f, 0.07903279f, 
    0.22055654f, -0.18534343f, -0.16117598f, -0.29067847f, 0.07308876f, 0.38346949f, -0.06759078f, -0.22015394f, 
    0.29890859f, -0.32731193f, 0.23522000f, 0.12728372f, -0.02537274f, -0.13394330f, 0.11675020f, -0.08064435f, 
    -0.00596814f, -0.00327296f, -0.06796679f, 0.12179356f, 0.44478071f, -0.21766804f, 0.21297036f, 0.19482617f, 
    -0.25169587f, -0.04873594f, -0.25946221f, 0.01110967f, -0.10212289f, -0.01292242f, -0.37991196f, 0.00191082f, 
    0.22629170f, 0.37082276f, -0.17165712f, 0.18092196f, 0.15330209f, -0.16815132f, -0.05001329f, -0.14011224f, 
    -0.23851787f, 0.28278241f, 0.05339367f, -0.03885186f, 0.08658076f, 0.14378797f, -0.43008882f, 0.43451208f, 
    -0.09321075f, -0.12104806f, 0.32669631f, 0.27329794f, 0.27313149f, -0.00886245f, -0.15943617f, -0.18304859f, 
    -0.07060084f, 0.11611621f, 0.11644932f, -0.39200705f, 0.02590132f, -0.14648174f, 0.19428320f, 0.44180730f, 
    -0.00845741f, 0.23382826f, -0.04555186f, 0.29073721f, -0.13152012f, 0.21110520f, 0.18876573f, 0.08402449f, 
    0.32396477f, 0.18010855f, -0.06011552f, 0.42384768f, -0.11963399f, -0.10150035f, -0.50328696f, 0.27992573f, 
    0.04984910f, -0.04679136f, 0.15683332f, 0.33482403f, 0.10919800f, 0.19622324f, -0.14328630f, 0.20024838f, 
    0.13094376f, -0.20573124f, -0.08884583f, 0.27218896f, 0.17556319f, 0.05837259f, -0.04956893f, -0.01491975f, 
    -0.18905845f, -0.05769546f, 0.15805092f, -0.20314726f, -0.13464428f, -0.42645159f, -0.45086506f, 0.24430649f, 
    -0.25020844f, 0.45167980f, 0.19175881f, -0.33688125f, 0.03454629f, 0.39147186f, 0.35336900f, 0.06584420f, 
    0.02522523f, 0.17456996f, -0.00849818f, -0.21080662f, -0.32300487f, -0.11547606f, -0.07443266f, -0.02471128f, 
    0.02799629f, -0.12663369f, 0.31318280f, 0.21258502f, -0.04371162f, 0.04075781f, 0.43372843f, 0.09267717f, 
    -0.07724769f, -0.11301497f, -0.15149750f, 0.32888710f, 0.05368497f, 0.14780784f, 0.28955138f, -0.05514922f, 
    0.03661126f, -0.11366577f, -0.10288034f, 0.04709968f, -0.02767404f, -0.14844540f, -0.22725894f, -0.04984108f, 
    0.02441723f, -0.06705496f, -0.13768081f, -0.08780500f, -0.11487812f, 0.03450397f, 0.08180175f, 0.06201396f, 
    -0.10365348f, 0.11736985f, 0.13099536f, -0.13473438f, 0.02591570f, -0.15436171f, -0.05648907f, 0.07112739f, 
    0.13743259f, 0.09946892f, 0.15859663f, 0.10199652f, -0.01711747f, -0.17154109f, -0.09316293f, 0.09107451f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.21067116f, 0.22956097f, 0.19728300f, -0.17669435f, 0.05902768f, 0.17335962f, 0.22881399f, 0.01331179f, 
    -0.09104716f, 0.20865652f, 0.17721392f, -0.19268538f, 0.00971380f, -0.00239124f, 0.04130932f, 0.06315137f, 
    -0.05276808f, -0.29353255f, 0.09394869f, 0.20749648f, -0.06698450f, -0.11942387f, 0.10896312f, 0.06808510f, 
    0.22765461f, 0.04900400f, 0.39734042f, -0.15131611f, -0.20656213f, 0.42277890f, -0.04326137f, -0.10090543f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.55744934f, -0.50387365f, -0.46534029f, -0.05622762f, -0.03226570f, -0.11825444f, 0.02797786f, 0.01033777f, 
    -0.16825354f, 0.17769943f, 0.12359698f, 0.10380099f, -0.89444309f, -0.50120568f, -0.13068938f, -0.03101001f, 
    0.04364105f, 0.43358451f, -0.23924683f, -0.45365086f, -0.11157421f, 0.30832285f, -0.28573772f, -0.08683551f, 
    0.05369092f, -0.29081851f, -0.06480905f, -0.21730684f, 0.15402068f, -0.32081309f, 0.29156017f, -0.17526087f, 
    -0.38397899f, -0.18945003f, 0.29880226f, 0.02680375f, -0.11856766f, -0.10436678f, -0.22372179f, 0.15171497f, 
    0.07556625f, 0.27548018f, 0.28665400f, -0.09357580f, -0.61429858f, 0.21895579f, -0.07599191f, -0.11654318f, 
    -0.22442892f, -0.33464575f, -0.06128851f, -0.16154402f, 0.44159010f, -0.23676571f, 0.27856320f, 0.29245961f, 
    0.22678471f, 0.25063357f, 0.19856289f, -0.30181971f, -0.27966872f, 0.07094676f, 0.03937175f, -0.07738625f, 
    0.26686516f, 0.30258349f, 0.01925754f, -0.52108675f, -0.17518525f, 0.09604787f, 0.03792244f, 0.25223443f, 
    0.04213652f, -0.07741456f, -0.18890001f, 0.00826680f, 0.17029506f, -0.48928037f, -0.07832053f, -0.06616593f, 
    0.00878595f, -0.64557952f, -0.74634707f, 0.11975774f, 0.18899015f, -0.07415611f, 0.25624916f, -0.36502710f, 
    0.18266766f, -0.63539940f, 0.16007546f, -0.14990276f, 0.22962894f, 0.05792597f, -0.00616973f, -0.30520180f, 
    -0.07468974f, 0.31767637f, -0.07173127f, -0.17490505f, 0.10744318f, -0.20481429f, -0.01187600f, -0.06839396f, 
    -0.21095553f, 0.10604537f, -0.27594522f, -0.36943135f, 0.42494884f, -0.23511451f, -0.17459927f, 0.04193692f, 
    -0.07118763f, 0.30638394f, -0.07343179f, -0.27793372f, 0.28507870f, -0.13191362f, 0.17983808f, -0.20696355f, 
    -0.09656554f, 0.19469498f, -0.09168220f, 0.00044913f, 0.30534256f, -0.58829057f, 0.20398355f, -0.13343410f, 
    0.14744040f, -0.42817888f, -0.19116728f, -0.19393113f, -0.12834257f, 0.14432999f, 0.20682333f, -0.46804452f, 
    0.24817140f, 0.19165461f, 0.02733121f, 0.10551611f, 0.09071517f, 0.14965746f, -0.08221200f, -0.07228567f, 
    -0.01607152f, 0.03607966f, -0.02484192f, -0.03539814f, 0.13912739f, 0.09863336f, -0.56790799f, 0.13592306f, 
    -0.10923185f, -0.76886314f, 0.18447277f, 0.39932537f, -0.04294651f, -0.31694272f, -0.30738798f, -0.05643406f, 
    0.14635777f, -0.29876629f, -0.05609591f, 0.27101502f, 0.07809617f, -0.46595654f, -0.15777914f, -0.01175881f, 
    -0.25439128f, 0.17126651f, 0.09864488f, 0.04433623f, -0.11555751f, -0.17856368f, -0.19367582f, 0.01058786f, 
    0.18815026f, -0.20946854f, 0.37537667f, 0.30269542f, -0.39536008f, 0.14037773f, -0.38969570f, 0.01124898f, 
    -0.06077347f, -0.14435065f, 0.12670670f, -0.11953189f, -0.35805637f, -0.21420816f, 0.17750736f, 0.00158023f, 
    0.27144900f, 0.06098139f, -0.00487123f, -0.58778268f, 0.05306102f, 0.02465893f, 0.24971449f, 0.16358057f, 
    -0.40712106f, -0.64221138f, -0.37318978f, -0.32668394f, 0.16851045f, -0.41677698f, 0.04340374f, 0.05940060f, 
    -0.16553989f, -0.02352099f, -0.11746442f, 0.32519975f, -0.70260620f, -0.27951810f, 0.10248229f, 0.47353902f, 
    -0.04495629f, 0.05407974f, 0.01569798f, -0.11179022f, -0.24577156f, 0.31599697f, -0.36472103f, -0.15151981f, 
    -0.25753060f, 0.20140858f, -0.43099284f, 0.20985907f, -0.01990277f, -0.00284816f, 0.05733018f, -0.17190473f, 
    0.07498826f, -0.47420442f, -0.23488018f, 0.11090761f, 0.00972365f, 0.39825836f, -0.06047054f, 0.13344979f, 
    0.14746754f, 0.47731301f, 0.18536575f, -0.16194069f, -0.21516801f, 0.13946214f, 0.06874081f, -0.39510718f, 
    -0.15188190f, 0.39839476f, -0.73222375f, -0.18609375f, -0.01436534f, -0.15274285f, 0.04139884f, -0.13553530f, 
    0.05296449f, 0.09198643f, 0.25754043f, 0.02377813f, 0.03904493f, -0.35839093f, -0.40648577f, 0.40363541f, 
    -0.29784968f, -0.65089673f, 0.11201081f, -0.26117724f, 0.33340561f, 0.18150255f, -0.02103297f, 0.12132633f, 
    -0.39581284f, -0.45953375f, 0.11875781f, 0.25204468f, -0.13474201f, 0.03509020f, 0.02663566f, -0.50768775f, 
    -0.25534430f, -0.32359162f, -0.19318451f, -0.55884898f, -0.05026333f, -0.28596261f, 0.43185875f, -0.06322499f, 
    0.13576850f, 0.17371812f, -0.30255920f, -0.55736727f, -0.08591744f, 0.31040442f, 0.35833058f, -0.37324250f, 
    0.18186133f, 0.11868832f, 0.02052541f, -0.18035029f, -0.35850561f, -0.19250697f, 0.29474914f, 0.11995506f, 
    0.42974144f, -0.38872778f, 0.03409276f, 0.08264854f, -0.02365375f, 0.03704290f, -0.30671817f, -0.33008695f, 
    -0.46924052f, 0.24780938f, -0.16848461f, -0.01133042f, -0.35335296f, 0.21245144f, -0.69128203f, -0.05551790f, 
    0.01294177f, 0.27039632f, 0.24208067f, 0.48415557f, 0.04494363f, -0.37361541f, -0.43715492f, -0.27705544f, 
    -0.53006923f, 0.21572398f, 0.21498379f, -0.16173013f, 0.20730259f, -0.54358733f, -0.20647891f, -0.08737104f, 
    -1.19116879f, -0.08588734f, -0.28664345f, 0.08205863f, -0.39445934f, -0.16505714f, 0.66883379f, -0.31895110f, 
    -0.51757121f, -0.27397761f, -0.01006299f, 0.45005327f, -0.63025337f, -0.16573943f, -0.06211852f, -0.03684342f, 
    -0.02134050f, 0.14365606f, 0.31584513f, 0.36642271f, 0.03150234f, 0.43833727f, -0.52928668f, -0.22741812f, 
    -0.02793838f, -0.26105735f, -0.02303624f, 0.09697608f, 0.23206335f, -0.37636116f, -0.22829273f, -0.06762413f, 
    0.12906840f, -0.47243974f, 0.10319429f, 0.14348866f, 0.28990665f, -0.63489443f, 0.03661431f, 0.09907422f, 
    -0.61904794f, -0.42561114f, -0.50980568f, -0.05424014f, 0.49173617f, 0.12653428f, -0.06955069f, 0.01528336f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.12150896f, -0.06499831f, -0.01907184f, 0.03670688f, 0.10656128f, -0.04764318f, 0.08550928f, -0.24511161f, 
    0.15639569f, 0.03525789f, -0.00800518f, 0.09333405f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
