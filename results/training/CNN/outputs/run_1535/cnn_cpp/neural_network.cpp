#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.50485784f, -1.13503432f, -0.80113167f, -0.02594865f, -0.70676982f, -1.60623372f, -1.14863408f, -0.72015971f, 
    -0.58924699f, -0.62209576f, 0.66914350f, 0.19519916f, 0.47396672f, -0.29051426f, -0.23203187f, 0.07333464f, 
    0.01058056f, -0.13261978f, 0.19601716f, -0.37517092f, -0.10502163f, -0.26085585f, -0.46565726f, -0.16869533f, 
    -0.02019620f, -1.50743997f, -0.43110639f, 0.64543819f, 0.53732848f, 0.32880691f, 0.28814501f, 0.46599385f, 
    0.54204673f, 0.38762549f, 0.54947543f, -0.19794150f, -0.17961003f, 0.27442887f, -0.03375840f, -0.19317800f, 
    -0.48563111f, -0.01865737f, -0.38140202f, -0.06862853f, 0.28834629f, 0.06511755f, -0.02850439f, 0.55631846f, 
    0.39105392f, -0.16085176f, -1.49177814f, -1.32092369f, -0.33661610f, -0.20527162f, -0.69917881f, 1.41344011f, 
    0.38838875f, -0.60183710f, -0.48151681f, 0.73992091f, 0.06152124f, -0.00574363f, 0.36605951f, 0.31846485f, 
    -0.08220746f, -0.14786854f, -0.16880950f, -0.20905073f, -0.12684125f, -0.19210164f, -0.02124898f, -0.00633913f, 
    0.07859982f, 0.09140175f, -0.05562273f, -0.84726870f, -1.02490234f, 0.06716713f, 0.94114149f, 0.52887666f, 
    0.26613852f, -0.43451563f, 0.33915180f, 0.61264110f, -0.36492175f, -0.03074469f, 0.08749270f, 0.10541255f, 
    0.34243852f, -0.32566872f, 0.05883975f, -0.23852998f, -0.30077910f, -0.09031011f, -0.12259717f, -0.65545750f, 
    -0.24472900f, 0.02024393f, -0.60230130f, -0.68774098f, -1.19953763f, 0.82178795f, 0.21507835f, -0.44845787f, 
    -0.53601235f, -0.83372003f, -0.08942369f, -0.90724546f, -0.95494819f, -1.14765811f, 0.16504471f, -0.11778034f, 
    -0.44437513f, -0.83465219f, -0.20161510f, -0.06218830f, -0.08914702f, 0.16284420f, 0.23383707f, 0.12515278f, 
    -0.05594969f, -0.09933082f, 0.25871757f, -0.04212465f, 0.09810434f, 0.69823903f, 0.98573828f, -0.48609820f, 
    -1.34674120f, -1.63643050f, 0.72493309f, 0.07684347f, 0.13630965f, 0.15267575f, -0.10047296f, -0.06565449f, 
    -0.30534080f, 0.72397101f, -0.20117627f, 0.36481047f, 0.04399537f, 0.20699857f, 0.30787504f, -0.33971322f, 
    -0.14393646f, -0.05028648f, 0.28788230f, -0.06642107f, -0.06064542f, 0.04422116f, 0.56854075f, 0.57216179f, 
    -0.51710969f, -0.41480073f, 0.92825162f, 0.11295476f, -0.10162281f, -0.52628678f, -0.49102947f, -0.38837025f, 
    -0.47657225f, 0.50187922f, 0.05212715f, -0.16539966f, -0.10188429f, -0.00465396f, 0.19729324f, -0.42111766f, 
    0.06051711f, -0.01631383f, -0.09689123f, 0.61819017f, 0.18114851f, 0.03999429f, 0.29772213f, 0.49195880f, 
    0.90607262f, 0.67794168f, 0.73372006f, 0.74183518f, 0.53518826f, 0.02149533f, 0.03635744f, 0.11993863f, 
    -0.04127029f, 0.29128402f, 0.08817976f, 0.13671149f, -0.26774964f, 0.08007980f, -0.04551754f, -0.23554394f, 
    -0.19184501f, -0.04289541f, 0.01588010f, -0.19004574f, 0.11179053f, 0.01044159f, 0.11734022f, -0.14957972f, 
    -1.21001112f, -0.68447793f, -0.97724217f, -1.09050596f, -1.04801881f, 0.00504071f, -0.35048109f, -0.28660968f, 
    0.44807008f, 0.58869898f, -0.51585168f, -0.33823821f, -0.39240739f, -0.73885572f, -0.72944617f, -0.32097277f, 
    -0.18274280f, -0.21121739f, -0.42454839f, -0.15201673f, -0.00319186f, -0.04065448f, 0.11610404f, 0.27109051f, 
    0.18005200f, -0.92641687f, -0.45787415f, 1.11667824f, -0.63548172f, -0.80376703f, -0.23257723f, -0.42967835f, 
    -0.14646702f, 0.04029232f, 0.07732555f, 1.32136428f, 0.13537483f, -0.14760317f, 0.20628896f, -0.04191316f, 
    -0.00070303f, -0.00569443f, 0.01869361f, -0.22589858f, -0.82648003f, -0.09706453f, 0.43775737f, 0.48796856f, 
    -0.29121798f, -0.13876499f, -0.31663269f, -0.70073324f, 0.45140910f, 0.84626472f, 0.69967014f, -1.17415059f, 
    -1.33257580f, -0.41339484f, 0.51536721f, 0.80827916f, -0.08742423f, 0.45978805f, -0.08327807f, 0.10128661f, 
    0.24630596f, -0.10373572f, 0.33215722f, -0.04910837f, -0.17922038f, -0.34188670f, 0.26307666f, -0.13111681f, 
    -0.06494715f, -0.06893791f, -0.05153995f, 0.36603585f, -0.55668467f, -0.12380089f, 0.30073795f, 0.48808831f, 
    0.37970200f, -0.34949118f, -0.14190046f, -0.00619837f, 0.69899052f, 0.06619368f, -0.08695588f, -0.20999891f, 
    0.03372095f, 0.62153840f, 0.26455212f, -0.56154853f, -0.35600773f, 0.19394203f, -0.56706250f, 0.11730845f, 
    -0.42380175f, 0.32635936f, 0.06723721f, 0.03630485f, 1.48470974f, -0.17496705f, -0.69252479f, -0.32557958f, 
    -0.40844926f, 0.20483199f, 0.31442612f, 0.27537456f, -0.12359478f, -0.16823819f, -0.30722564f, -0.23332687f, 
    -0.39278463f, -0.52433527f, 0.01908452f, 0.17088045f, 0.33987963f, -0.13676277f, -0.19287375f, -0.43979576f, 
    -0.66576165f, -0.50031716f, -0.72146267f, -0.71756554f, -0.67918551f, 0.21523973f, 0.61164683f, -0.10863283f, 
    -0.45056659f, -0.92114967f, 0.07944452f, 0.41394040f, -0.04548132f, 0.17958951f, 0.19289781f, 0.00156262f, 
    -0.08271110f, -0.01253006f, -0.55761200f, 0.07337940f, 0.25920159f, -0.08264695f, -0.17230096f, 0.09849098f, 
    0.17232834f, 0.23153867f, 0.25613844f, -0.39499623f, -0.12784803f, 0.82746828f, -1.78491533f, 0.39309448f, 
    -0.48406923f, -0.77914381f, -0.33357143f, 0.19151002f, -0.07055235f, 0.09641141f, 0.66655672f, 1.10272050f, 
    -0.02948799f, -0.25235590f, -0.04891325f, -0.43833178f, 0.31105205f, 0.16625951f, 0.02798496f, 0.08873283f, 
    -0.01026702f, -0.13765985f, -0.05514171f, -0.24636874f, -0.17334673f, -0.30338752f, -0.33627728f, -0.15722778f, 
    1.04721797f, 1.04944515f, -1.09506643f, -0.02514317f, -0.86641848f, -0.49815735f, -0.14202876f, 0.68296134f, 
    -0.52338117f, -0.68581557f, -0.47158864f, -0.27690870f, 0.30621231f, 0.24933630f, 0.51007605f, 0.27014801f, 
    -0.02660677f, -0.16548064f, 0.00780409f, -0.08291418f, -0.29654953f, -0.45053101f, -0.21457307f, 0.10813719f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.29955310f, 0.40264553f, 0.43677092f, -0.01996553f, 0.13619885f, 0.76131225f, 0.43054861f, -0.09281831f, 
    -0.09784461f, 0.64337409f, 0.70677078f, 0.68175381f, -0.15283759f, 0.14613551f, 0.10346026f, 0.72762930f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.66678447f, 0.52305722f, 0.19367890f, -0.37860894f, 0.18972479f, -0.04275969f, -0.07247973f, 0.17145921f, 
    0.02360130f, -0.09640279f, -0.11024303f, 0.02334915f, 0.01750832f, -0.33429193f, 0.26894930f, -0.33633253f, 
    0.05144252f, -0.05007993f, 0.08468913f, -0.02472357f, -0.24523549f, -0.08766278f, -0.13167840f, -0.26452500f, 
    0.65744913f, 0.06536065f, -0.20784403f, -0.33833522f, 0.04784414f, 0.11816965f, 0.08234762f, -0.17397477f, 
    -0.05253173f, -0.10787313f, 0.00407926f, -0.00467483f, 0.50269246f, -0.00675022f, 0.10766443f, -0.08214127f, 
    -0.02542769f, 0.01629679f, 0.11405292f, -0.00015513f, 0.16119644f, -0.09335449f, 0.15185058f, 0.19834284f, 
    0.31330347f, 0.48149866f, -0.36688235f, -0.18406774f, -0.12002645f, 0.08359294f, -0.03913681f, 0.12397499f, 
    -0.03335133f, -0.01941033f, 0.08682623f, -0.08614567f, 0.07249790f, -0.77556443f, -0.38537940f, -0.00307705f, 
    -0.13414648f, 0.16500759f, -0.25819686f, -0.18519816f, -0.14581205f, -0.13002674f, 0.03843529f, 0.06101284f, 
    -0.22509721f, 0.23245399f, -0.30513161f, 0.10505947f, -0.14800863f, 0.03792280f, -0.04422846f, 0.00380816f, 
    -0.07635618f, -0.03787533f, -0.03804657f, -0.01231769f, -0.27230510f, -0.17309125f, -0.12453186f, 0.10005523f, 
    0.08972346f, 0.13957231f, 0.03715412f, 0.05248378f, -0.03185982f, 0.07444740f, 0.04079005f, 0.12694992f, 
    0.46503404f, 0.13844988f, 0.14834593f, -0.24212910f, 0.25865614f, 0.23570909f, -0.06427669f, -0.19736247f, 
    -0.09574952f, -0.01313612f, -0.07737063f, -0.07458885f, 0.21452242f, -0.14786796f, 0.18437836f, -0.41714504f, 
    0.08485310f, 0.03378500f, -0.28244960f, -0.26837909f, 0.02903257f, -0.24554962f, -0.27052513f, -0.17075773f, 
    -0.49020147f, 0.62806368f, 0.53478205f, -1.03970623f, -0.10695470f, 0.12401637f, 0.02700272f, -0.13134012f, 
    -0.01119501f, -0.25117955f, -0.18726186f, 0.03772394f, -0.55357379f, 0.12658790f, -0.17366454f, 0.00167137f, 
    -0.05084358f, 0.12926324f, 0.03965990f, -0.07706287f, -0.08647034f, -0.32573962f, 0.02402729f, -0.33232898f, 
    -0.10363697f, -0.39116481f, -0.08603784f, 0.24805574f, 0.01240717f, 0.08124593f, -0.09502759f, -0.07709997f, 
    -0.08945705f, 0.01220343f, -0.03718421f, 0.20438525f, 0.00540909f, -0.21085329f, -0.08691642f, 0.02555394f, 
    -0.01963295f, -0.01069426f, -0.08149191f, -0.08273152f, 0.03075024f, -0.12336625f, 0.19331944f, -0.22687839f, 
    -0.30840954f, 0.21668452f, 0.23934275f, -0.11231378f, 0.00342194f, 0.33670795f, 0.22979534f, 0.15567538f, 
    0.08256819f, 0.27558461f, 0.00248710f, -0.02873925f, -0.72719532f, 0.09301133f, 0.03883298f, 0.08030190f, 
    -0.37352064f, -0.05751591f, -0.30560437f, 0.04236606f, -0.06992821f, -0.09571461f, -0.08591057f, -0.04241347f, 
    -0.25490910f, 0.17023845f, -0.18350364f, 0.08890062f, -0.37236941f, 0.08750232f, -0.13577043f, -0.17531757f, 
    0.04468357f, -0.04574532f, -0.06391314f, 0.05974210f, -0.03604387f, -0.06927034f, -0.11315989f, -0.07935020f, 
    -0.13064671f, -0.05485085f, 0.04267668f, -0.04915524f, -0.05662959f, 0.20625232f, 0.08874481f, 0.21981746f, 
    0.36798841f, -0.22462095f, 0.23354998f, -0.12183431f, 0.01084718f, 0.06771879f, 0.24410443f, -0.07424677f, 
    -0.00072077f, -0.16999464f, 0.09986301f, -0.12048176f, -0.13631424f, -0.05142722f, -0.09973993f, 0.00608888f, 
    -0.08721017f, -0.01443387f, 0.11145782f, -0.02696583f, -0.49502233f, -0.33585662f, -0.22704829f, -0.44548753f, 
    -0.03035788f, -0.11557057f, -0.02110862f, -0.35826415f, -0.04657175f, -0.05498618f, -0.24142165f, -0.05399404f, 
    -0.11760652f, 0.13131961f, 0.05643999f, 0.10797842f, 0.14534211f, -0.04085189f, 0.22134121f, -0.32965669f, 
    0.28918576f, 0.10873166f, 0.14256427f, 0.07536468f, -0.06090510f, 0.10868009f, 0.07585364f, -0.04804319f, 
    0.28533712f, -0.11972651f, -0.30319217f, 0.17948399f, -0.01339154f, -0.28587809f, -0.00684326f, 0.03927957f, 
    -0.14222755f, -0.03767690f, -0.04741935f, 0.14890045f, 0.30133140f, 0.21149729f, 0.10520361f, 0.30684763f, 
    -0.09318027f, -0.11388886f, -0.12324714f, -0.17263050f, -0.03018077f, 0.06641148f, -0.04433514f, -0.07024133f, 
    0.41252792f, 0.57745367f, 0.00493117f, 0.09708215f, -0.08799095f, 0.41588715f, 0.08475555f, 0.15588732f, 
    0.00775181f, 0.00653431f, -0.03882798f, -0.16219202f, -0.77990311f, -0.42293745f, -0.09605393f, -0.33558303f, 
    0.22149856f, 0.13597786f, -0.08891558f, 0.72441870f, -0.15552834f, 0.14745395f, 0.10402855f, 0.04024370f, 
    -1.14508712f, 0.46689186f, 0.10066424f, -0.04027668f, 0.10883678f, 0.00793195f, 0.09835218f, 0.19884053f, 
    -0.04477933f, -0.06242228f, -0.05006496f, 0.10087542f, 0.35969970f, 0.04177205f, -0.01304200f, 0.14453396f, 
    -0.02463907f, 0.02454340f, 0.02523274f, -0.06733933f, 0.08375306f, 0.15179630f, 0.06239377f, -0.19324920f, 
    0.57545590f, -0.23075533f, 0.04421941f, 0.00331098f, 0.03656200f, -0.03962321f, -0.26509547f, -0.08543497f, 
    -0.07091630f, -0.34991133f, -0.51728928f, -0.00158434f, 0.21889590f, 0.08030954f, 0.02654501f, -0.03825060f, 
    -0.19282590f, 0.03870321f, -0.04284265f, -0.01059195f, -0.08286746f, 0.04790939f, -0.24044275f, -0.09672350f, 
    -0.42174077f, 0.19004999f, -0.04448972f, -0.15692642f, 0.12309757f, 0.03844890f, -0.26468143f, -0.25397700f, 
    -0.21120596f, 0.05089790f, -0.12581234f, 0.00546629f, 0.20510533f, -0.11421698f, -0.02033828f, -0.21927218f, 
    0.45398992f, -0.08194203f, -0.02017018f, 0.24254933f, 0.15238464f, 0.31861135f, -0.02195403f, -0.07063416f, 
    -1.48527145f, -0.61477154f, -0.63433129f, -0.14042182f, 0.09168374f, 0.11960285f, -0.07461312f, -0.26163104f, 
    0.02856555f, -0.02967044f, 0.04872025f, 0.02671513f, 0.06106357f, -0.34101143f, -0.18459056f, 0.24205454f, 
    0.02100271f, 0.03031649f, 0.18421608f, 0.03922873f, -0.27168089f, -0.02729363f, 0.02014113f, -0.27543998f, 
    0.30833966f, -0.45689616f, 1.13196611f, 0.73138523f, -0.02258559f, -0.11899088f, -0.01081430f, 0.30004418f, 
    0.15108255f, -0.03841656f, 0.09830329f, 0.08272082f, 0.00032090f, 0.02770607f, -0.29558355f, 0.27065188f, 
    -0.08790539f, 0.01257025f, 0.01544162f, 0.05298094f, 0.11911853f, 0.09325851f, 0.11464082f, -0.15105580f, 
    -0.68028313f, -0.14447869f, 0.18679355f, -0.53343225f, 0.24142030f, -0.02801481f, -0.05923508f, -0.19145994f, 
    -0.06176298f, 0.03815403f, -0.04010002f, -0.09068458f, -0.25898471f, 0.25749737f, 0.21034272f, 0.06115511f, 
    -0.07496879f, 0.04096039f, -0.06994013f, -0.22257997f, 0.06735489f, 0.06836360f, -0.05989002f, -0.04738750f, 
    0.02671713f, -0.18360345f, 0.13471213f, -0.09233807f, -0.16954482f, -0.23284440f, 0.02413541f, 0.07251606f, 
    0.06602864f, -0.05074251f, -0.01850255f, -0.01866108f, -0.32357293f, 0.15818125f, 0.04091222f, -0.05300346f, 
    -0.06819473f, -0.14766993f, 0.04019907f, 0.05588850f, -0.05451644f, -0.09130037f, 0.03265953f, -0.00460924f, 
    -0.47999591f, 0.78907621f, 0.34855658f, 0.54912663f, -0.20193076f, -0.02923300f, -0.12224980f, -0.06768066f, 
    -0.12899874f, -0.10592876f, -0.15388456f, -0.03609898f, 0.31846029f, 0.01124949f, -0.17786999f, -0.10416374f, 
    -0.04805384f, -0.02409660f, -0.06884035f, 0.15730073f, 0.10028474f, -0.19023688f, 0.11672202f, 0.26400450f, 
    -0.24332212f, -0.40513772f, -0.07716636f, 0.37083387f, -0.18945242f, -0.00357484f, -0.46607822f, 0.04820898f, 
    0.09297297f, 0.08045569f, -0.07473790f, 0.13549383f, -0.20086335f, -0.13763803f, -0.05921731f, 0.21164158f, 
    -0.01355701f, 0.03999963f, 0.05769594f, 0.10510346f, -0.03190025f, -0.05886212f, -0.06628130f, -0.26234028f, 
    -0.24946919f, 0.14800006f, 0.27855065f, 0.02000402f, 0.07141338f, -0.01588011f, 0.00640007f, -0.26643771f, 
    0.13249633f, 0.07918341f, -0.17326212f, 0.13968912f, 0.11568300f, 0.01558601f, 0.10897100f, -0.21322623f, 
    -0.10790039f, 0.03517622f, -0.30922219f, 0.25294560f, -0.01395782f, -0.05466922f, -0.12981077f, 0.02478848f, 
    0.67091292f, 0.15628593f, -0.01162314f, 0.48302299f, -0.02182181f, 0.05354499f, -0.16146177f, -0.07420404f, 
    -0.09066035f, 0.05576649f, -0.12039503f, 0.23113903f, 0.14069688f, -0.23812646f, -0.13402104f, -0.01988176f, 
    0.01835508f, 0.05980133f, -0.07639991f, -0.11608837f, -0.07482677f, 0.08547212f, -0.05412755f, -0.04001720f, 
    -0.22155863f, -0.20795991f, -0.26819962f, 0.14753680f, 0.12406303f, -0.03491962f, 0.10451344f, 0.21648324f, 
    -0.05569168f, 0.13125877f, 0.14076932f, -0.08740267f, 0.23042759f, 0.80715084f, 0.10206566f, -0.43936023f, 
    0.46125448f, 0.52331513f, -0.05140663f, 0.20160653f, -0.20143199f, -0.17295048f, -0.02490545f, -0.09880120f, 
    -0.58261913f, -0.18744260f, -0.13851959f, 0.18566042f, 0.26607510f, 0.13236924f, -0.03731716f, 0.09738462f, 
    -0.30757317f, 0.00448795f, -0.04116388f, -0.03272871f, -0.37525439f, 0.48222393f, -0.38862541f, -0.49131078f, 
    -0.07315170f, 0.21309043f, -0.11939727f, 0.31464291f, -0.26195097f, -0.10498424f, 0.11089300f, -0.03814036f, 
    0.21396299f, -0.39477524f, 0.15169477f, 0.13813347f, 0.00210517f, 0.09445969f, -0.08215834f, -0.01772156f, 
    -0.11943187f, -0.13219064f, -0.10880570f, -0.09233996f, -0.09709297f, -0.26851657f, -0.02517555f, 0.75342226f, 
    -0.12410455f, -0.08611597f, -0.59027433f, -0.04628082f, -0.03722635f, 0.04928992f, -0.00800650f, 0.00760986f, 
    0.04947864f, 0.12942892f, 0.74620146f, 0.38076091f, 0.02022273f, -0.29639125f, -0.34714684f, -0.13011970f, 
    -0.34068805f, -0.23050536f, -0.19372204f, -0.13287851f, -0.62668163f, -0.29053876f, 0.33290052f, -0.07403145f, 
    -0.13498208f, 0.00089752f, -0.65827632f, 0.14341578f, 0.05791704f, 0.02623692f, 0.02102814f, -0.04876618f, 
    0.29771447f, -0.12400290f, 0.00863824f, 0.33063716f, 0.11624689f, -0.06174499f, 0.01688994f, -0.14668994f, 
    0.06666892f, 0.18109651f, 0.00375599f, 0.32698828f, 0.39234737f, -0.12037627f, 0.32934344f, 0.15904184f, 
    0.11196171f, 0.18664534f, -0.09364311f, -0.23471107f, 0.09657808f, -0.05651205f, 0.07031770f, -0.03767318f, 
    0.32624286f, 0.00437701f, -0.28333488f, -0.48419160f, -0.20374814f, -0.36841729f, -0.03160290f, -0.08701839f, 
    0.10475819f, 0.11623847f, -0.28194779f, 0.22697592f, -0.59580022f, 0.05344635f, -0.26047593f, -0.65079784f, 
    0.05954813f, -0.18924282f, 0.14987822f, -0.47493872f, -0.02834224f, -0.00369274f, -0.04882911f, -0.08228774f, 
    -0.05793471f, 0.10158453f, 0.16463567f, 0.42008981f, -0.04146837f, 0.00662994f, 0.02210631f, 0.08084210f, 
    -0.06072748f, 0.34521243f, -0.17653163f, 0.13240775f, -0.12086929f, -0.25950775f, 0.04324417f, 0.45395175f, 
    0.06160564f, -0.15923437f, -0.32459792f, -0.01139317f, -0.28744760f, -0.19530623f, 0.18385133f, -0.01820394f, 
    1.34566963f, -0.46970713f, -0.06860355f, 0.18624787f, 0.27172771f, 0.17127228f, 0.13562904f, -0.31764635f, 
    -0.29141328f, -0.03998509f, 0.00384219f, 0.05169342f, 0.44620895f, -0.42583844f, 0.70061529f, -0.48034570f, 
    -0.62149680f, 0.00246498f, -0.14652477f, -0.01005637f, -0.05771304f, 0.05678659f, 0.18751602f, -0.05787644f, 
    0.19583438f, 0.25905186f, 0.38581863f, 0.22799741f, -0.31188393f, 0.04684784f, -0.15692689f, 0.16497105f, 
    0.15250240f, 0.06714985f, 0.06215982f, 0.03874315f, 0.40874439f, 0.01884635f, 0.06196641f, -0.01013086f, 
    0.07186575f, -0.05546209f, 0.16653694f, 0.06325634f, -0.14151543f, -0.29986390f, -0.28962174f, -0.11598921f, 
    0.31530464f, 0.43914416f, -0.16054484f, 0.28768274f, -0.17358068f, -0.19735932f, 0.14575903f, -0.09366673f, 
    0.05366082f, 0.04913347f, -0.12447493f, 0.03767154f, -0.03862523f, -0.46283239f, 0.28095156f, 0.02236159f, 
    -0.02830103f, 0.00022537f, -0.04037333f, -0.12727836f, -0.01374462f, 0.51051718f, 0.20558430f, 0.46888581f, 
    0.15795065f, 0.18078928f, -0.00841205f, 0.33632952f, 0.13126221f, -0.12104633f, 0.01775836f, 0.00960613f, 
    0.07122055f, -0.11969712f, -0.00742376f, -0.07627274f, -0.25284514f, 0.05528844f, -0.11595360f, 0.02715197f, 
    0.05173393f, -0.31050617f, -0.33658618f, -0.31980211f, -0.06865437f, -0.09550969f, 0.10289862f, -0.04007977f, 
    0.03204025f, -0.00611580f, -0.13290340f, -0.01761728f, -0.02131796f, 0.17386198f, 0.11221506f, 0.01582278f, 
    -0.05068059f, -0.08504684f, -0.04424818f, -0.24414319f, -0.18431276f, -0.07460438f, -0.03072581f, -0.10649798f, 
    0.17819288f, 0.12318020f, 0.17581338f, 0.01254204f, 0.11788266f, 0.00061105f, 0.12010684f, 0.11481845f, 
    -0.39623064f, 0.07993341f, -0.06437215f, 0.25055158f, -0.14220117f, -0.07586445f, -0.23658234f, -0.04882311f, 
    0.01379631f, -0.01955394f, 0.11724627f, 0.09324125f, -0.11713085f, 0.32164475f, 0.27606088f, 0.25932539f, 
    0.09348881f, -0.13335997f, 0.05544239f, -0.73261648f, 0.14981630f, -0.06850383f, -0.05593150f, -0.14350154f, 
    -0.51399684f, -0.21041755f, -0.26454958f, 0.30326399f, -0.44451448f, 0.20306545f, -0.05227325f, -0.12519687f, 
    -0.11969338f, -0.16104798f, -0.02974386f, -0.10854749f, -0.05693426f, -0.30188558f, -0.11124142f, 0.06904636f, 
    0.02475544f, -0.12031844f, 0.01021730f, 0.04270264f, -0.17206796f, -0.30979747f, -0.43974715f, -0.01254829f, 
    -0.07737547f, 0.30994752f, -0.12420152f, -0.22022113f, 0.09192307f, 0.03657883f, -0.07780780f, 0.13571760f, 
    0.27407661f, -0.01199038f, 0.19757627f, 0.33649302f, 0.04200282f, 0.00853155f, -0.02491185f, -0.19245015f, 
    0.10029312f, -0.17149079f, 0.04312988f, 0.21483350f, 0.07188611f, 0.01522096f, 0.00485437f, -0.10417256f, 
    -0.26220784f, -0.18446940f, -0.26504734f, 0.18019751f, -0.16084002f, -0.08129770f, 0.12585530f, 0.24531315f, 
    0.01477316f, -0.10925645f, 0.08265308f, 0.10649581f, 0.25400072f, 0.21664067f, -0.60752922f, 0.19717628f, 
    -0.09414491f, -0.02296661f, -0.15709935f, -0.42331913f, 0.08541510f, -0.23137824f, -0.13537034f, -0.04846782f, 
    0.25960398f, 0.14216174f, 0.28164282f, 0.01989280f, 0.41093007f, 0.12369671f, -0.04884009f, -0.23311383f, 
    0.00931792f, -0.13596360f, 0.03581249f, 0.05656387f, -0.31680205f, -0.36516207f, 0.00028064f, 0.38936314f, 
    -0.09522387f, -0.20196536f, -0.02682843f, -0.01346607f, 0.13429140f, -0.07104976f, -0.06814490f, -0.19129558f, 
    -0.60557938f, -0.14180321f, -0.02357909f, -0.60155243f, -0.03494406f, 0.19030783f, -0.25464180f, -0.07648172f, 
    0.11463398f, 0.14762941f, -0.17887175f, -0.07755651f, 0.03325762f, -0.05928082f, 0.21105279f, -0.09498869f, 
    0.06025159f, 0.04088754f, 0.00119749f, 0.01074792f, 0.13702251f, -0.36067355f, -0.24424177f, -0.44387114f, 
    -0.06566435f, 0.57126302f, 0.22218506f, 0.20424701f, 0.01783580f, 0.11316887f, 0.38856745f, 0.24463299f, 
    0.08356774f, 0.00362267f, 0.10473920f, -0.00866049f, 0.23538226f, -0.06548848f, -0.69990826f, -0.51536798f, 
    0.16039053f, 0.12343454f, 0.00472273f, 0.28823110f, 0.18939430f, -0.00936895f, 0.02383063f, 0.01138711f, 
    -0.09554730f, 0.15415424f, 0.11366165f, -0.18628901f, 0.07832028f, 0.22624393f, 0.08092880f, -0.09952988f, 
    0.17715394f, -0.03616217f, 0.12946853f, 0.09702771f, -0.23394366f, -0.19900797f, -0.09819478f, 0.09536391f, 
    0.11760281f, 0.00656519f, -0.08672171f, -0.07241764f, 0.09440412f, -0.21631359f, -0.02448401f, -0.04159815f, 
    -0.05931542f, -0.17117447f, -0.00206851f, -0.14235877f, 0.13359664f, -0.04904458f, 0.03777642f, -0.07069236f, 
    0.10585589f, -0.02701562f, -0.00840559f, 0.04753652f, 0.16284531f, 0.23239870f, -0.21154375f, -0.00436545f, 
    -0.11558938f, -0.09416033f, 0.31303653f, -0.04003571f, 0.11931594f, 0.03188660f, 0.05042341f, 0.01104351f, 
    0.37391976f, -0.52661783f, 0.47495019f, -0.01086239f, 0.11198360f, 0.08364177f, 0.02640032f, 0.26292470f, 
    0.06262346f, 0.04900547f, 0.20904753f, -0.00461809f, -0.26308942f, 0.08094532f, 0.33552366f, -0.17000417f, 
    -0.02513504f, -0.16809314f, 0.00733906f, 0.11139245f, 0.26464656f, 0.25837764f, 0.04541643f, 0.36708546f, 
    -0.00795188f, 0.00538593f, -0.32476419f, -0.29659140f, -0.00036970f, -0.03644979f, 0.13275599f, 0.05350845f, 
    -0.03558324f, -0.62916577f, -0.20598131f, -0.91473055f, -0.02089768f, -0.09630699f, -0.34005722f, -0.13073094f, 
    0.25072190f, -0.06219746f, 0.01752966f, -0.13159922f, 0.13382122f, -0.02165171f, 0.08652842f, 0.48275137f, 
    -0.94103706f, -0.14443347f, -0.06704987f, -0.13855401f, -0.17036088f, -0.22616240f, 0.05622825f, 0.22334564f, 
    0.03120617f, -0.19420685f, 0.03435171f, -0.00587349f, -0.57528222f, -0.18749867f, 0.15465264f, 0.35068914f, 
    0.12703690f, -0.04847364f, -0.14100082f, 0.25641686f, -0.21533555f, -0.09083667f, -0.04063114f, 0.04576184f, 
    -1.34720242f, -1.53966749f, -0.36902708f, -0.31890535f, -0.20032766f, -0.00872184f, 0.28075838f, -0.42225477f, 
    0.02403220f, 0.02254662f, -0.12443510f, 0.00927402f, -0.10139025f, -0.17225569f, 0.20196962f, 0.08930486f, 
    -0.13973676f, 0.01010644f, -0.30960441f, 0.01339516f, -0.05162842f, 0.00263718f, 0.06907856f, 0.16153541f, 
    -0.82205623f, 0.33743742f, 0.94980681f, -0.33807513f, -0.10572205f, -0.24866328f, -0.06229952f, -0.07500169f, 
    -0.22446257f, 0.15514217f, 0.03019261f, 0.11151470f, -0.22684669f, 0.26331705f, 0.10126504f, -0.21630442f, 
    0.02447262f, 0.13172251f, -0.09565364f, 0.09155960f, 0.30468684f, 0.25050205f, 0.16195637f, 0.22199307f, 
    -1.15806127f, -1.33562350f, -0.35954702f, -0.14302671f, -0.21008883f, 0.06649344f, -0.13762271f, -0.50479567f, 
    -0.01496163f, -0.08415937f, 0.11407795f, 0.11139484f, 1.07260013f, 0.40379700f, 0.04389633f, -0.03369026f, 
    0.07851923f, -0.28861862f, 0.03232494f, 0.18453532f, 0.18294795f, -0.12181624f, 0.00742035f, 0.07942544f, 
    -0.26487708f, -0.21430387f, -0.03488041f, 0.08397275f, -0.18664686f, 0.16689713f, -0.03995411f, 0.02501288f, 
    -0.03632387f, -0.02877058f, -0.07700295f, -0.01669368f, -0.11397465f, -0.19033520f, -0.10081115f, 0.17038043f, 
    0.10832037f, 0.19986889f, -0.04018185f, 0.04439403f, -0.02704550f, -0.05792650f, -0.17384298f, -0.19928214f, 
    -1.27113152f, -1.44171846f, -0.31223202f, 0.58080912f, -0.03037312f, -0.14663413f, -0.18991359f, 0.00119187f, 
    -0.09844504f, -0.05244491f, -0.03116973f, -0.02997798f, -0.28831756f, -0.24323575f, 0.43213913f, -0.09862391f, 
    0.02420041f, -0.19137670f, -0.20114431f, -0.19585334f, 0.17109659f, 0.05588609f, 0.04460220f, -0.29101446f, 
    0.15539628f, -0.62143862f, -1.04014218f, 0.02690243f, -0.30366442f, -0.13199767f, 0.23833445f, 0.28509843f, 
    0.05158914f, 0.14183369f, -0.02796682f, -0.15441227f, 0.22826116f, -0.02161353f, -0.13989179f, 0.20450018f, 
    0.12085016f, 0.01220717f, 0.09190309f, 0.26833829f, -0.00134279f, 0.05188219f, 0.00168041f, -0.17949855f, 
    -0.11389783f, 0.09664210f, -0.17243922f, -0.08770290f, -0.04501507f, 0.10112450f, 0.13062875f, 0.02067564f, 
    0.21280931f, 0.25736481f, 0.55388159f, 0.24588853f, 0.03187962f, -0.12300367f, 0.15361117f, 0.04767495f, 
    -0.02395940f, -0.39681637f, 0.55182445f, 0.02233452f, 0.13927054f, -0.08014575f, 0.03132600f, -0.38267562f, 
    -0.09959330f, 0.16404095f, 0.25448963f, 0.41341338f, -0.12940563f, 0.00496191f, 0.20852120f, 0.15959466f, 
    0.13057849f, 0.02617418f, 0.26401007f, -0.05028025f, -0.05081384f, -0.15799530f, -0.08546030f, -0.19763727f, 
    -0.19850823f, 0.17918612f, 0.35045564f, -0.11964179f, -0.00771059f, -0.09408106f, 0.25505227f, 0.19900677f, 
    -0.60800427f, -0.68300754f, -0.10542630f, 0.44806463f, 0.07083926f, 0.04895290f, 0.14657828f, 0.33405396f, 
    0.03515586f, -0.01397768f, -0.13143273f, -0.02005286f, 0.35828471f, 0.20011923f, -0.48458537f, -0.40097046f, 
    -0.06766369f, 0.00623074f, 0.03430098f, 0.01841715f, -0.26976719f, 0.01176005f, -0.09159938f, -0.13608731f, 
    0.71665752f, -1.57729626f, -0.22048429f, -0.91418540f, -0.22626120f, -0.03190501f, -0.19481093f, 0.25268286f, 
    0.09189451f, 0.23297426f, 0.12297328f, 0.08209854f, 0.23608601f, -0.13420846f, 0.02993426f, -0.08504377f, 
    0.08233643f, 0.16429837f, -0.04933399f, 0.01352970f, 0.28941694f, 0.03720605f, 0.05904556f, -0.06825341f, 
    -0.65400100f, 0.36543307f, -0.57935208f, 0.68654782f, 0.18275772f, -0.12137374f, 0.00370665f, 0.07713470f, 
    0.06299031f, -0.09298368f, -0.09673543f, 0.00046655f, -0.49703565f, 0.41086203f, -0.18407895f, 0.10096447f, 
    -0.31900844f, 0.20382446f, 0.25335103f, -0.17385401f, 0.06604370f, 0.05952169f, 0.06097069f, -0.07298983f, 
    -0.09188713f, 0.05246457f, 0.26083148f, -0.05997903f, -0.00010745f, -0.30677903f, 0.14374352f, -0.09699777f, 
    0.08517892f, 0.06611943f, 0.02928153f, -0.05503067f, 0.10149209f, 0.14327671f, 0.09662531f, -0.13481154f, 
    0.02708777f, -0.13034442f, -0.09780645f, 0.05766460f, 0.03568056f, 0.00408861f, 0.03912495f, 0.00242628f, 
    0.02489158f, -0.75918132f, -0.54658747f, -0.83181441f, -0.01420988f, 0.03243767f, -0.03234603f, 0.24964066f, 
    0.04962308f, 0.01227880f, -0.04024899f, -0.05206405f, 0.18806845f, -1.05627191f, -0.31547043f, 0.84302008f, 
    0.02128138f, -0.05443721f, -0.02159790f, -0.04162047f, 0.08582675f, -0.09648057f, 0.15602817f, 0.01420568f, 
    0.20420711f, -1.03594291f, 0.03349258f, -0.09884494f, 0.13702683f, 0.11389850f, -0.02003256f, -0.24851973f, 
    0.08433174f, 0.04376393f, -0.04554756f, -0.04485669f, 0.08732139f, -0.25284454f, 0.18922621f, -0.37576571f, 
    0.05851431f, 0.04553755f, 0.02674958f, -0.10863054f, 0.02463853f, -0.12945813f, -0.41450539f, -0.29918182f, 
    -0.12648234f, -0.06379858f, -0.11527185f, 0.29771909f, 0.05989602f, -0.02678712f, 0.11489252f, -0.22901385f, 
    -0.11223566f, 0.15479767f, 0.35075021f, -0.00543851f, -0.01300510f, 0.01422947f, -0.07124620f, 0.05222735f, 
    -0.05881621f, 0.31228295f, 0.05725875f, -0.01259220f, 0.03948794f, 0.11037822f, -0.06564222f, -0.01669458f, 
    0.83743542f, -0.72009319f, -0.10490211f, -0.38483915f, 0.06537066f, -0.02691821f, -0.10325505f, -0.05352665f, 
    0.14036727f, -0.10657370f, -0.13488069f, -0.05212416f, -0.51000589f, 0.62540370f, -0.47142637f, 0.03656894f, 
    -0.11475150f, 0.16277020f, -0.24069214f, -0.23801185f, -0.09994587f, -0.04013703f, -0.02041104f, 0.06268163f, 
    0.25277391f, -0.45657071f, -0.75464326f, -0.44703570f, -0.12551345f, 0.10621553f, 0.11106808f, -0.07617015f, 
    -0.03510069f, -0.07196672f, -0.03894923f, -0.15248059f, -0.00155312f, 0.04040273f, -0.22218426f, -0.20525235f, 
    -0.27284279f, 0.04103374f, -0.06882231f, -0.04058668f, 0.32811350f, 0.25933585f, 0.28420421f, 0.20337470f, 
    -0.19907792f, -1.19906390f, -0.87027884f, -0.22334926f, 0.05899362f, 0.22543086f, 0.22702299f, 0.14668675f, 
    0.04940901f, -0.05677975f, 0.12173565f, -0.02770751f, -0.05830808f, -0.09834968f, -0.50909573f, -0.45981631f, 
    0.07588717f, -0.05879699f, -0.03866369f, -0.09565295f, 0.16616645f, 0.08318780f, -0.30007514f, -0.15441659f, 
    -0.02625828f, 0.21617721f, 0.09110296f, -0.11106269f, -0.04597098f, -0.08827142f, -0.18216644f, -0.15824164f, 
    0.04254047f, 0.20556827f, 0.15118718f, 0.06913605f, -1.07046998f, -0.20009649f, 0.28222665f, 0.56300640f, 
    -0.04567477f, 0.16736187f, 0.18896562f, 0.00892251f, -0.11165015f, -0.02018792f, -0.30056396f, 0.24398853f, 
    -0.16991489f, 0.02856469f, 0.10695191f, -0.12780485f, -0.08482571f, -0.01695695f, 0.02305740f, -0.08377811f, 
    0.07687833f, 0.36375263f, 0.12865369f, 0.17536962f, -0.08425641f, 0.08049953f, 0.18939808f, -0.20211913f, 
    -0.11814906f, -0.18665351f, -0.02029538f, -0.05547153f, -0.12875699f, -0.04242650f, -0.11495332f, 0.06876472f, 
    -0.43648267f, -0.94690520f, -0.86846697f, 0.15014455f, 0.28493577f, 0.01057291f, 0.26711100f, 0.15406737f, 
    0.11956404f, 0.05969958f, 0.14422165f, 0.17144126f, -0.06363472f, -0.16587324f, -0.59284425f, -0.06493761f, 
    0.03877461f, 0.07498363f, -0.07158376f, 0.30103868f, -0.30692020f, 0.12734771f, -0.03257981f, 0.10564426f, 
    1.09397542f, 0.27022848f, 0.08868043f, -0.28505772f, 0.22059725f, -0.34645122f, -0.25915977f, -0.52264321f, 
    0.04837313f, 0.21345824f, 0.17699842f, -0.07316381f, 0.14437950f, -0.21358925f, 0.04404623f, -0.37125787f, 
    0.03359110f, 0.00337541f, -0.01800546f, -0.11815128f, 0.07827193f, 0.14184207f, 0.24436228f, 0.25029585f, 
    -0.60526443f, -0.19160056f, 0.08379196f, 0.08311823f, -0.10197795f, 0.14386185f, -0.14723234f, -0.05475271f, 
    -0.21692176f, -0.01854820f, -0.27299434f, -0.65276027f, -0.33630624f, 0.03529474f, 0.01409013f, 0.33898079f, 
    -0.07916564f, -0.04382355f, -0.10620461f, -0.02068795f, -0.09896855f, 0.15387884f, 0.31523347f, 0.09478699f, 
    0.11226580f, -0.41712630f, -0.38419732f, -0.06604026f, 0.22646359f, 0.12228268f, -0.00155696f, -0.11191868f, 
    0.01356483f, 0.20165162f, -0.28163302f, -0.50165880f, -0.22133751f, 0.27370027f, 0.69718611f, 0.21649955f, 
    0.38221371f, -0.17270753f, 0.01884368f, 0.33133492f, -0.34143382f, -0.25630513f, 0.13860181f, -0.12903990f, 
    -0.38264859f, 0.39007530f, 0.16713390f, 0.05289664f, 0.02308823f, -0.29641548f, 0.23038994f, 0.41866207f, 
    -0.00132995f, 0.18659563f, 0.14756897f, -0.12323997f, -0.33476338f, 0.52260751f, 0.20293231f, 0.74210405f, 
    0.05547357f, -0.07671382f, -0.45822489f, -0.04583821f, -0.03758944f, -0.35524684f, -0.01363455f, -0.02601535f, 
    0.11171996f, -0.10699952f, -0.33632821f, 0.08795627f, -0.17526032f, 0.08912516f, -0.40971127f, -0.21746430f, 
    -0.01369302f, -0.10200861f, -0.06173398f, 0.10321712f, 0.10065814f, 0.09296391f, 0.27715480f, 0.63718534f, 
    -0.02975211f, -0.12640023f, -0.16501746f, -0.07106052f, 0.29584157f, 0.12422127f, 0.13188984f, 0.20611720f, 
    -0.78245038f, -0.32381886f, -0.15712960f, -0.41702050f, -0.10038172f, -0.21588911f, -0.00932507f, 0.14390898f, 
    0.01722345f, 0.00352581f, 0.08259798f, 0.03247462f, -0.11090444f, 0.73024648f, -0.50051177f, -1.17223883f, 
    -0.08783687f, -0.26690984f, 0.19004174f, 0.00171192f, 0.05978739f, 0.02636933f, -0.15527318f, -0.12055346f, 
    0.05969952f, -0.35817677f, 0.02923137f, -0.21659629f, 0.22837432f, -0.08276066f, 0.31943277f, 0.13295704f, 
    0.19979441f, -0.21116157f, -0.17109875f, -0.15806942f, 0.04317670f, -0.72653729f, -0.26091865f, -0.18700527f, 
    0.21871926f, 0.44920257f, 0.07004339f, 0.02875645f, 0.06398128f, 0.04856737f, 0.11704560f, 0.18767063f, 
    -0.33540753f, 0.24732371f, 0.49369279f, -0.64919478f, -0.11654439f, -0.48311833f, 0.14504164f, 0.06363207f, 
    0.01943688f, 0.00427382f, 0.11389776f, 0.00601066f, 0.26109019f, 0.41197807f, -0.27842820f, 0.13397798f, 
    -0.14017892f, -0.29507038f, -0.18295480f, 0.03605591f, -0.06629961f, -0.00526927f, -0.15120421f, 0.00515680f, 
    0.14056863f, -0.35484937f, -0.10685223f, 0.19278722f, 0.28827590f, 0.27438068f, 0.35676187f, -0.46153530f, 
    0.30861309f, -0.26976088f, 0.02866198f, -0.02036386f, 0.14421748f, -0.37861633f, 0.42009649f, 0.01360599f, 
    -0.05320097f, -0.08701783f, -0.19918652f, -0.30496085f, -0.14661145f, -0.02941276f, -0.02024402f, -0.07249146f, 
    0.06667562f, -0.15631069f, 0.26467514f, -0.16064362f, 0.15117924f, -0.06107585f, 0.09041013f, 0.22639704f, 
    0.14867803f, 0.21297362f, 0.23269206f, 0.23157986f, 0.08549090f, 0.10777558f, -0.46990246f, -0.60617179f, 
    -0.17114297f, 0.04126878f, 0.34469712f, -0.10301679f, 0.10465326f, 0.11366753f, -0.25412905f, 0.14271758f, 
    -0.06079144f, 0.02230346f, 0.46300375f, 0.15956837f, -0.30046076f, -0.16744833f, -0.15475154f, -0.68810099f, 
    0.13823150f, 0.01538696f, 0.03080816f, -0.01690196f, -0.65785128f, 0.52172178f, -1.28457570f, 0.00257545f, 
    0.05151844f, -0.23062426f, 0.08845754f, -0.07943985f, 0.12540077f, -0.06254435f, 0.15421022f, 0.23393962f, 
    -0.21594402f, -0.38577020f, -0.13263077f, 0.22631532f, 0.03249911f, 0.16166095f, -0.34915835f, 0.03522875f, 
    0.08368129f, 0.08983188f, -0.10975999f, -0.13725621f, -0.17535783f, 0.13566147f, 0.81953806f, -0.29136911f, 
    0.00725931f, -0.21201554f, -0.11223909f, -0.08305290f, 0.02160187f, 0.11604973f, 0.18475130f, 0.16578932f, 
    0.11762762f, 0.42266878f, -0.37008250f, 0.17242795f, 0.25071770f, -0.05167250f, -0.14508170f, 0.07495734f, 
    -0.13344321f, 0.29396641f, -0.09413461f, -0.23009397f, -0.63228709f, 0.80494231f, -0.44862524f, -0.19428559f, 
    -0.01457459f, 0.14710367f, 0.13420625f, 0.04798133f, -0.19058889f, -0.31357837f, -0.56215471f, -0.49622014f, 
    0.14957672f, -0.93754119f, 0.21142155f, 0.19556910f, -0.06289188f, 0.11879950f, 0.08804018f, 0.23423466f, 
    -0.00649846f, 0.04524962f, 0.09216081f, 0.00706968f, 0.21351771f, -0.27544987f, 0.70972657f, 0.71714574f, 
    -0.11297701f, -0.22286767f, 0.10197666f, -0.18515293f, -0.07657155f, -0.05721116f, -0.05598463f, 0.02898798f, 
    -0.26325861f, -0.13873523f, 0.49331918f, 0.03980936f, -0.06506143f, 0.06791595f, 0.16354489f, -0.02414612f, 
    -0.00536555f, 0.23307098f, 0.53074139f, 0.31103235f, -0.26502940f, -0.61353940f, -0.66502339f, -0.25204885f, 
    -0.40151051f, -0.10742341f, 0.06284420f, -0.30954108f, 0.07956754f, -0.04271246f, -0.07351399f, 0.04760863f, 
    -0.27510858f, -0.31338033f, -0.12237062f, -0.26921353f, -0.06664780f, 0.10720626f, 0.28742445f, 0.21516939f, 
    0.11631320f, 0.13194966f, 0.11308286f, -0.30193621f, 0.23965999f, 0.07813054f, -0.17542762f, 0.11282941f, 
    -0.28935245f, -0.14802729f, 0.30818173f, 0.10862005f, -0.25010595f, 0.08743992f, -0.12825015f, 0.50744694f, 
    -1.38488472f, 0.16565791f, -0.53614807f, 0.03328199f, 0.06613618f, 0.04538414f, 0.08676039f, -0.06905511f, 
    -0.26740626f, 0.03406411f, 0.04091780f, -0.03903695f, -0.67257625f, 0.67944199f, -0.32045069f, 0.00833245f, 
    -0.09355367f, 0.10658315f, -0.01113136f, -0.26523161f, -0.12313284f, -0.04076112f, 0.03265424f, 0.02002530f, 
    -0.15616009f, 0.36263704f, -0.21178634f, -0.27586722f, 0.08942728f, -0.14812833f, -0.28745258f, 0.12903307f, 
    -0.43106920f, -0.43630084f, 0.06467517f, -0.57929164f, 0.08523002f, -0.14917053f, 0.70423818f, 0.27855000f, 
    -0.39844248f, 0.16771659f, 0.47683483f, 0.06047959f, 0.31511432f, -0.47529384f, 0.46016100f, 0.06551014f, 
    0.07005940f, 0.22977464f, 0.08273529f, -0.12255222f, 0.05845811f, -0.37835541f, -0.08767094f, 0.31871799f, 
    -0.08919170f, -0.00350382f, 0.01830735f, -0.34846601f, 0.24812494f, 0.39972869f, -0.13550486f, 0.07016920f, 
    -0.35431266f, 0.04083380f, 0.42487672f, -0.01820731f, 0.02550947f, 0.00331994f, -0.16798654f, -0.28289279f, 
    0.35025853f, -0.61562854f, -0.14982030f, 0.13759467f, 0.14567210f, -0.41961855f, 0.04694816f, -0.14345126f, 
    -0.02603289f, 0.11209209f, 0.09801776f, -0.08520663f, -0.49510181f, -0.34166139f, -0.51804364f, -0.00196130f, 
    0.35875830f, 0.18632673f, -0.05799753f, -0.23372757f, -0.10563724f, 0.05006537f, -0.13090795f, -0.02709857f, 
    -1.13366389f, 0.52713776f, -0.96340919f, 0.70795262f, 0.05880776f, -0.29731569f, 0.02717875f, -0.09963414f, 
    -0.15816386f, -0.27000874f, -0.12543835f, 0.12514299f, -0.06257415f, -0.43884438f, 0.10407390f, 0.52358580f, 
    0.15835066f, -0.16931848f, -0.20615797f, 0.13485688f, 0.09650251f, 0.10125612f, 0.13903464f, 0.26853284f, 
    -0.08700287f, -0.45798647f, 0.23513278f, 0.24989812f, -0.30449522f, -0.17273533f, -0.20180570f, -0.15198456f, 
    0.04677369f, 0.07580880f, -0.19120833f, -0.04237377f, -0.38165608f, -0.04524728f, 0.96909791f, -0.26951930f, 
    -0.13182132f, 0.24764156f, -0.11117027f, 0.01157627f, 0.08505968f, 0.14273828f, -0.24607463f, -0.11276367f, 
    0.19337694f, 0.42156047f, 0.11283852f, -0.03557960f, -0.01214256f, 0.40382493f, -0.51651347f, 0.14682519f, 
    -0.17791387f, -0.05516336f, -0.02990675f, -0.06512118f, 0.52301598f, 0.51235908f, 0.01022198f, -0.30905721f, 
    -0.13369739f, 0.04861344f, -0.11960616f, 0.08199134f, -0.07330808f, 0.15725525f, -0.02200901f, -0.13895634f, 
    -0.22727929f, 0.06684412f, -0.06221583f, -1.03240752f, 0.06166520f, -0.34200507f, 0.01389664f, 0.13516633f, 
    0.00138140f, 0.21219009f, 0.04243349f, -0.04423840f, -0.44660661f, -0.09366720f, 0.15204777f, 0.39689803f, 
    -0.14656146f, 0.19326906f, 0.28584042f, -0.19452493f, -0.05150209f, -0.06239814f, -0.08740959f, -0.02218253f, 
    0.28497005f, 0.28649727f, -0.11500122f, 0.45630708f, 0.22433899f, -0.13329922f, -0.00973517f, -0.06481628f, 
    -0.06560974f, 0.21966100f, 0.14144523f, -0.08370397f, -0.22710598f, 0.19533166f, -0.70588464f, 0.27699834f, 
    -0.05565945f, -0.04606534f, 0.08688575f, 0.23265146f, -0.05425201f, -0.02951498f, 0.12001998f, 0.36961177f, 
    -0.20439942f, 0.27334315f, -0.17877640f, -0.02011413f, -0.04079058f, 0.07332305f, 0.02270508f, 0.25807634f, 
    -0.06143003f, 0.12145387f, 0.05793091f, 0.16350755f, -0.14067155f, -0.09628505f, 0.21408837f, 0.07158370f, 
    0.06630459f, -0.07376951f, -0.22845486f, 0.08503778f, -0.37193489f, -0.23282519f, -0.21098752f, -0.10562755f, 
    -0.04285070f, -0.05497412f, -0.29783636f, -0.67239350f, -0.14176103f, -0.27280596f, 0.13538702f, 0.25432315f, 
    0.10614551f, -0.02830082f, 0.20243593f, 0.00945468f, 1.08978474f, -0.63001281f, 0.57203913f, -0.21459986f, 
    0.00058166f, -0.00911198f, 0.32221133f, 0.10771185f, 0.01017773f, -0.13607147f, 0.02540657f, 0.08515877f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.43377784f, 0.29470909f, 0.11226632f, -0.21021515f, -0.17856026f, -0.05095365f, 0.01555163f, -0.22599049f, 
    0.05144473f, 0.04967032f, 0.05648567f, -0.07406177f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
