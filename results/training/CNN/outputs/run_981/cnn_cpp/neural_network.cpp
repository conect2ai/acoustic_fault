#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.45720765f, -0.99876547f, -0.93060011f, -0.16959856f, 0.34123760f, 0.65322852f, 0.06375413f, 0.26158467f, 
    -0.27387923f, -0.72148359f, -0.89380831f, -0.19306184f, 0.36083475f, -0.53167796f, 0.67763203f, 0.39884743f, 
    -0.20452282f, 0.58953696f, -0.45741490f, -0.53354764f, -0.95365524f, 0.36198476f, 0.79629672f, 0.40677848f, 
    -0.40402979f, -0.59933794f, -0.47922051f, 0.50282568f, 1.08731496f, -0.67738706f, -0.79702264f, -0.29073808f, 
    0.55285591f, -0.12590094f, 0.08582339f, 0.23188879f, -0.47123596f, 0.27659842f, -0.29752296f, -0.27351007f, 
    -0.60548347f, -0.83700347f, 0.65808928f, 0.86985153f, 0.23469488f, 0.46910813f, 0.57658964f, 0.16702898f, 
    -0.15531009f, -0.76872385f, 0.38985375f, 0.08034998f, -0.36024147f, -0.33685565f, 0.04117829f, 0.34268761f, 
    0.21159759f, 0.78421003f, 0.70677119f, 0.48901394f, 0.23895860f, 0.01683682f, -0.18437061f, 0.57977915f, 
    0.02522613f, 0.22221799f, 0.23349376f, 0.02299274f, -0.57899600f, -0.43087268f, 0.27187502f, 0.55757350f, 
    0.15667863f, 0.52273327f, -0.89249068f, -0.77545083f, -0.69906372f, -0.45505047f, 0.22496141f, -0.56681967f, 
    0.15488116f, 0.35205695f, 0.94202757f, 0.72863114f, -0.72408098f, -0.54864037f, -0.56222194f, -0.26912591f, 
    -0.38447738f, -0.31634653f, -0.52626342f, -0.78585356f, 0.56747001f, 0.18939143f, -0.01783230f, -1.03466582f, 
    -0.47958836f, -0.38929257f, -0.43738192f, 1.24921942f, -0.72840834f, -0.87052488f, 0.11216902f, -0.03472376f, 
    -0.19234918f, -0.52705759f, -0.24661960f, 0.61675560f, -0.46619990f, 0.18427300f, 0.75031012f, -0.86479330f, 
    -0.31831670f, 0.82005376f, 0.20948134f, 0.03869078f, -0.02311894f, -0.61251372f, -0.60900557f, 0.30340138f, 
    0.57047325f, 0.49275634f, -0.24253790f, 0.00541157f, 0.20371449f, 0.26573211f, 0.48188308f, -1.01363599f, 
    -0.37142253f, -0.58023250f, -0.55787766f, -0.56387657f, 0.01971415f, -0.54861283f, -0.30732292f, -1.19678259f, 
    0.53729451f, -0.26589897f, 0.03103687f, -0.84672576f, 0.72483128f, -0.57528806f, -0.33988339f, -0.46183866f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08623219f, 0.31592458f, 0.03479180f, 0.14262013f, -0.12495343f, 0.32678622f, -0.32558268f, 0.18538576f, 
    0.09655540f, 0.03072681f, -0.39399752f, 0.18788962f, 0.16284081f, 0.22146977f, 0.38237011f, -0.33640474f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.22720498f, 0.05761219f, -0.16581649f, -0.05576509f, -0.14852171f, 0.29626477f, 0.09046083f, 0.21791025f, 
    0.01425426f, 0.09540626f, -0.17129016f, -0.09430449f, 0.13938248f, -0.00113714f, 0.06252963f, 0.04140250f, 
    0.03666115f, 0.07014691f, -0.05519920f, 0.03978120f, -0.08967776f, 0.08025514f, 0.19372435f, -0.26389515f, 
    -0.21159080f, 0.10937689f, 0.03729592f, -0.02811231f, 0.02109348f, 0.10877556f, -0.00716820f, -0.09109896f, 
    -0.10219537f, -0.15189157f, 0.03765575f, 0.05398747f, -0.05513867f, -0.04327694f, -0.05143727f, -0.09752379f, 
    -0.01965358f, 0.15625829f, -0.33184242f, -0.05265420f, 0.02597473f, 0.12603749f, -0.01212532f, 0.10136321f, 
    -0.14349496f, 0.11329148f, -0.10429277f, 0.00630540f, 0.22070211f, 0.12173703f, 0.10461641f, -0.16271757f, 
    0.01188383f, -0.01200826f, 0.07880916f, -0.03991551f, 0.93740702f, -0.10057370f, -0.34933296f, -0.03433954f, 
    0.10529236f, -0.02730132f, -0.14372258f, -0.16837458f, -0.00447913f, 0.09986430f, 0.02314286f, 0.14722492f, 
    -0.03089799f, 0.00707315f, 0.10739148f, 0.07125750f, 0.03610666f, -0.08523888f, -0.04487823f, 0.03168109f, 
    0.17796136f, 0.07463492f, 0.06561867f, -0.08294658f, -0.08322171f, 0.03868761f, 0.07606621f, 0.02283687f, 
    0.17518567f, -0.04084872f, 0.16196097f, 0.07593118f, -0.22864985f, -0.24037676f, -0.01956538f, 0.01076348f, 
    -0.03200912f, 0.11669472f, -0.04896206f, 0.12265023f, 0.20734368f, -0.06100062f, 0.20602447f, -0.07461879f, 
    0.11924551f, -0.18367590f, -0.08059949f, -0.14902073f, -0.04267118f, 0.05091936f, 0.05440023f, 0.03295164f, 
    0.04991329f, -0.10789026f, 0.00752743f, -0.03303302f, -0.07968566f, -0.09726897f, -0.07063332f, 0.03789840f, 
    -0.15446422f, -0.09956596f, -0.43475741f, -0.13880268f, 0.28183448f, -0.12103350f, 0.07045298f, -0.01040411f, 
    -0.13858315f, -0.01264241f, -0.00721948f, 0.07542641f, -0.07164297f, 0.04072453f, 0.06716780f, -0.23037091f, 
    0.13548233f, 0.19615354f, -0.20672362f, 0.00866163f, -0.15088302f, -0.00316532f, -0.07770945f, 0.21631216f, 
    0.05106041f, -0.09325624f, 0.01614616f, -0.00063304f, -0.08450640f, -0.16744989f, 0.10253982f, -0.04580843f, 
    0.06477196f, 0.03979553f, 0.14490132f, 0.01520784f, 0.08115344f, -0.03373953f, -0.24383299f, 0.08911138f, 
    0.50697750f, 0.20340927f, 0.14833263f, -0.00770645f, 0.04509231f, -0.09690387f, 0.09594558f, -0.14582409f, 
    0.12791060f, -0.01482602f, -0.04973523f, -0.14549007f, 0.05936255f, -0.01706716f, 0.01544995f, -0.06684345f, 
    0.05198241f, 0.09982920f, 0.10953238f, 0.00844372f, 0.00511972f, 0.10067943f, 0.32297370f, 0.16034648f, 
    0.13612647f, -0.07521128f, 0.08385537f, -0.02548920f, 0.02784629f, -0.04712503f, -0.04200694f, -0.01257591f, 
    0.01972359f, -0.04863077f, 0.03750802f, 0.00681428f, 0.00320478f, 0.09023690f, -0.13311955f, 0.04044854f, 
    0.33309099f, 0.29074508f, 0.26753482f, -0.14386369f, -0.10286914f, 0.02897015f, -0.06841445f, 0.05303100f, 
    -0.03999486f, 0.14393669f, -0.12713996f, -0.07508352f, -0.10032064f, -0.04164559f, -0.01449103f, -0.03072502f, 
    -0.01071804f, 0.07860786f, 0.13576373f, 0.01906321f, 0.03359551f, 0.19977196f, 0.07896896f, -0.04880359f, 
    -0.06285759f, 0.00963564f, -0.14147685f, -0.00787574f, -0.01844873f, -0.06628834f, -0.04341947f, 0.20796095f, 
    -0.24000594f, -0.09741349f, 0.04283017f, 0.00612162f, -0.02418376f, 0.17847227f, 0.03791821f, 0.12116824f, 
    -0.24809511f, -0.09793288f, 0.22729766f, 0.23813279f, 0.13500428f, 0.07955191f, 0.11886763f, -0.31617591f, 
    -0.15548284f, 0.16060773f, -0.00981451f, 0.13863502f, -0.12368426f, 0.00824443f, 0.04271380f, 0.04103023f, 
    0.04827484f, -0.10154729f, -0.01799781f, -0.04600823f, -0.57695264f, 0.07331916f, -0.27929321f, -0.27230588f, 
    -0.27830100f, -0.02499809f, -0.07635797f, -0.02904409f, -0.09358047f, 0.05365050f, -0.03628949f, 0.07267918f, 
    -0.04042661f, 0.00253336f, -0.01615793f, 0.05799171f, 0.00614374f, -0.05621390f, 0.05680479f, 0.10035404f, 
    0.24964979f, 0.04507008f, 0.28897247f, -0.07653510f, -0.00741346f, 0.13276307f, 0.09204414f, 0.14678296f, 
    -0.05761577f, -0.01441121f, -0.07808207f, -0.09028351f, 0.10590097f, -0.05710754f, -0.14198314f, -0.00026344f, 
    -0.14533344f, 0.13247754f, 0.12380858f, 0.18208179f, 0.09123554f, 0.35258538f, 0.42559895f, -0.40247220f, 
    0.08481795f, -0.12317123f, 0.00693006f, -0.01386007f, 0.12649655f, 0.11516947f, 0.06496269f, -0.09632144f, 
    0.00309129f, 0.05879768f, -0.11213299f, -0.03358355f, -0.06436680f, -0.08476049f, -0.00086348f, 0.09684197f, 
    -0.03582002f, 0.00353313f, 0.04378764f, -0.00846226f, -0.04379916f, -0.01573356f, 0.03196653f, -0.03076859f, 
    -0.01502321f, -0.05300224f, -0.04806775f, 0.04030832f, 0.02556838f, 0.04035348f, 0.04015087f, -0.05495928f, 
    0.01635299f, -0.02075716f, -0.04963413f, 0.00362447f, -0.04551864f, 0.00605549f, -0.02369049f, 0.02125833f, 
    -0.03612375f, 0.02273820f, -0.00069907f, -0.00420697f, -0.04964203f, -0.03402832f, 0.01256660f, -0.02054877f, 
    -0.02441821f, -0.05574700f, 0.01675465f, -0.03640405f, 0.04761460f, -0.00992863f, 0.01368027f, 0.02378668f, 
    -0.00842925f, 0.04223470f, 0.00491237f, 0.01971893f, 0.02943047f, -0.00565571f, 0.01818444f, -0.02874565f, 
    0.01286854f, -0.05929304f, -0.00211207f, 0.01862088f, 0.00240935f, -0.04204478f, -0.01060856f, -0.01932069f, 
    0.01840215f, 0.04682056f, 0.05175250f, 0.01086163f, -0.04662602f, -0.05106232f, 0.03404009f, -0.04260845f, 
    0.00009719f, 0.04309380f, -0.01156245f, 0.04246736f, -0.02311596f, 0.01013713f, -0.04449171f, -0.01425526f, 
    -0.04671657f, -0.05658618f, 0.00629915f, -0.01259656f, -0.03449719f, 0.00106616f, -0.05544137f, -0.01462998f, 
    -0.02591994f, 0.02248372f, -0.05237797f, 0.03448189f, -0.03365436f, 0.00395329f, 0.03433396f, -0.02443687f, 
    -0.02943387f, 0.01793129f, -0.04246774f, 0.01891761f, 0.02749677f, -0.04980513f, -0.00546833f, 0.00752091f, 
    0.01961314f, -0.03215913f, -0.02404797f, -0.05226059f, 0.02776625f, 0.01616070f, -0.05458855f, 0.04634308f, 
    0.02151567f, -0.02798366f, -0.02737834f, -0.00312467f, -0.04388417f, -0.01910559f, -0.03136377f, -0.01339791f, 
    -0.04891994f, -0.03300555f, -0.02229456f, -0.05726644f, 0.02855506f, -0.05531162f, -0.05233656f, -0.05213799f, 
    -0.03602808f, 0.03807278f, 0.03140876f, 0.01506836f, -0.00731543f, -0.05272496f, 0.01337508f, -0.05266853f, 
    -0.03658620f, 0.02336542f, -0.00954284f, -0.03537633f, -0.05108115f, -0.00968568f, 0.02508584f, -0.02219582f, 
    0.04312249f, 0.00208228f, 0.03274289f, 0.00005047f, 0.04644065f, -0.04040300f, 0.02306947f, -0.04563298f, 
    -0.05533324f, -0.06033481f, 0.02204105f, -0.04735051f, 0.03538663f, -0.01159430f, 0.02323296f, -0.05230725f, 
    0.00431472f, -0.05049555f, 0.01900679f, -0.05568967f, 0.01731910f, -0.02426895f, -0.03383359f, -0.03188289f, 
    -0.04189732f, 0.04476454f, -0.02308727f, -0.05348302f, 0.01485832f, 0.04395538f, -0.00723404f, -0.02202354f, 
    0.00634278f, -0.00480704f, -0.04684000f, 0.03285973f, 0.02154772f, 0.00000394f, -0.00029722f, 0.04807278f, 
    0.03474288f, 0.04713413f, 0.02762126f, -0.05603467f, -0.03933806f, -0.03647273f, 0.03475243f, 0.02701052f, 
    -0.03805460f, -0.00136772f, 0.03065229f, 0.03844302f, -0.01956166f, -0.03207152f, -0.03829665f, -0.01028730f, 
    -0.04491249f, 0.04455814f, -0.04391980f, 0.01244598f, -0.04553816f, -0.03245961f, 0.01607374f, 0.02062630f, 
    0.00838268f, -0.03393999f, 0.02463799f, 0.05530568f, 0.02253876f, -0.02001358f, -0.01725113f, 0.02827295f, 
    0.02023760f, -0.01117107f, -0.02761774f, 0.02017601f, -0.03163061f, -0.01211817f, -0.04231041f, -0.05373678f, 
    -0.01419292f, -0.02747650f, 0.05196352f, 0.03853535f, -0.00074728f, -0.03396872f, -0.01986614f, -0.03192786f, 
    -0.01627886f, -0.00521972f, 0.03025359f, 0.02499518f, 0.01861758f, 0.03463358f, -0.03051307f, 0.04016262f, 
    0.04209078f, 0.04109737f, 0.03036857f, -0.00826361f, -0.00968889f, -0.02922618f, 0.01860133f, -0.04243793f, 
    0.04242412f, 0.02846508f, 0.02427264f, -0.00975926f, -0.01151482f, 0.05161675f, -0.03389870f, -0.03988626f, 
    -0.00093858f, -0.01102472f, 0.00571409f, -0.03491126f, 0.02520966f, -0.00887983f, 0.04362265f, 0.00427200f, 
    -0.01838350f, -0.05746338f, 0.02524587f, 0.02644894f, -0.03121368f, 0.02833640f, -0.05616028f, -0.00796789f, 
    -0.03236535f, 0.01209974f, -0.02481971f, -0.03870046f, -0.04580484f, 0.04097541f, -0.00744349f, -0.00407139f, 
    0.01608214f, 0.02259519f, -0.03025327f, -0.04353655f, -0.01030683f, -0.02500626f, 0.03453714f, -0.02881886f, 
    -0.03540101f, 0.03644453f, -0.04481737f, -0.05154260f, 0.03831690f, -0.04112977f, -0.01315168f, -0.04521394f, 
    -0.01662745f, 0.04249657f, -0.03150117f, -0.05621023f, -0.04705353f, -0.01830402f, 0.03652577f, -0.01927931f, 
    -0.04354745f, 0.02817947f, -0.03102279f, 0.04808781f, -0.03948934f, -0.05370818f, -0.01683019f, 0.03578395f, 
    0.01437889f, -0.02531596f, 0.04252825f, 0.03917113f, 0.04330044f, 0.00779462f, 0.02947781f, 0.00867442f, 
    -0.01196291f, -0.01805708f, 0.01469125f, -0.05179550f, 0.05066367f, -0.04249338f, -0.02686919f, 0.00349208f, 
    -0.15085535f, -0.09780638f, 0.17612559f, 0.05757884f, -0.00202862f, -0.14821009f, 0.00299942f, -0.18806946f, 
    0.12054497f, 0.11052528f, 0.11148629f, -0.10428665f, 0.02439082f, 0.00930845f, 0.06230046f, -0.00948739f, 
    0.08539407f, 0.04902481f, -0.08064562f, 0.01402270f, 0.26383689f, 0.11656676f, 0.17193596f, 0.25611648f, 
    -0.12877004f, 0.02320404f, -0.12278676f, -0.12266669f, -0.01650135f, 0.10310669f, 0.10941674f, -0.02322145f, 
    -0.13416775f, -0.02211820f, -0.08631103f, -0.10794053f, -0.08070229f, 0.00961350f, -0.00865968f, -0.08125951f, 
    -0.29371780f, 0.00492516f, 0.02901891f, 0.06911959f, 0.11159596f, -0.10127283f, -0.07764517f, -0.14617367f, 
    -0.02312646f, 0.05226073f, -0.00852519f, 0.01844630f, 0.07729804f, 0.25039902f, 0.09490299f, -0.04163639f, 
    0.20617947f, 0.01652655f, 0.06811542f, 0.12515093f, 0.43994170f, 0.14726283f, -0.29457101f, -0.12634730f, 
    0.16018918f, 0.08231870f, 0.07043264f, 0.02417504f, 0.02283178f, -0.05321909f, -0.00020469f, 0.08883310f, 
    0.14617978f, -0.21980211f, -0.05882162f, 0.05401994f, 0.01696949f, 0.02092414f, -0.14574315f, -0.09554085f, 
    -0.00490577f, -0.02456137f, 0.26679111f, 0.29234111f, 0.13533551f, 0.06786407f, -0.03630214f, 0.00292250f, 
    -0.14137356f, 0.13559020f, 0.08178569f, -0.00280739f, -0.09890203f, -0.14196490f, -0.12768596f, -0.19141032f, 
    -0.08694796f, -0.00471045f, -0.11321999f, -0.25972304f, 0.23127642f, -0.02107403f, -0.29828733f, 0.02834284f, 
    0.00328135f, 0.05346176f, 0.02941384f, -0.05808137f, 0.04196838f, 0.07444550f, 0.00488548f, -0.04757259f, 
    0.08608381f, -0.00856408f, -0.02474211f, 0.02439152f, 0.09328491f, -0.07236806f, 0.01301016f, 0.15095970f, 
    -0.08037340f, 0.19977905f, -0.04300231f, -0.30163267f, -0.17074449f, -0.01005355f, 0.08047742f, -0.01523963f, 
    -0.01704261f, 0.09174322f, -0.07549006f, 0.05726733f, 0.06963205f, 0.01575801f, 0.00345779f, 0.01512319f, 
    0.08183224f, -0.20926273f, -0.06546025f, 0.10573062f, -0.11808649f, 0.11950776f, 0.03565790f, -0.21666364f, 
    0.07905538f, 0.00041680f, 0.12902896f, 0.08526875f, 0.10105183f, 0.00233501f, -0.07614003f, -0.12160473f, 
    -0.10264079f, -0.03173444f, 0.02083246f, 0.24730200f, -0.15354699f, 0.07651994f, -0.17594813f, -0.08388906f, 
    0.01923069f, -0.13587166f, 0.03818443f, 0.24687041f, 0.20528486f, -0.10722666f, 0.01973014f, -0.10332604f, 
    0.14003927f, 0.03185650f, 0.10185634f, 0.04919917f, 0.01438714f, -0.11310171f, -0.06506477f, -0.08696984f, 
    0.13177435f, 0.01607157f, 0.18380950f, 0.03036785f, 0.18304722f, 0.01205210f, -0.24427374f, 0.34637171f, 
    0.11984014f, 0.14782202f, 0.09939131f, 0.05042934f, 0.01087082f, 0.18550794f, -0.11358786f, 0.01768510f, 
    -0.08755317f, -0.04212170f, 0.04772301f, -0.03319171f, 0.15790126f, 0.11365964f, -0.08912317f, 0.01566971f, 
    -0.32773960f, -0.26915130f, 0.12910879f, 0.23104182f, 0.01582012f, -0.02155940f, 0.04041993f, -0.11709794f, 
    -0.07383747f, -0.03964405f, 0.03091756f, 0.09941734f, -0.07504226f, 0.11996058f, -0.03974804f, 0.10649399f, 
    0.40371665f, 0.11552146f, 0.16625239f, 0.22762029f, -0.09680947f, -0.18060096f, 0.32992774f, -0.30312276f, 
    0.33214429f, -0.00038248f, 0.03772114f, 0.04842859f, 0.03816079f, -0.13403979f, -0.16447280f, -0.06329896f, 
    0.03678785f, 0.04279494f, -0.06523563f, 0.04111166f, 0.00688460f, 0.13526711f, -0.07567804f, -0.06284393f, 
    0.16781627f, 0.14445528f, -0.48383689f, 0.23826253f, -0.26422113f, 0.15647189f, 0.02180967f, -0.04035827f, 
    -0.09707191f, 0.05855813f, 0.17094527f, -0.01847092f, 0.10272973f, 0.01819479f, -0.00026692f, -0.08034127f, 
    0.02730754f, -0.15910080f, -0.12890181f, 0.02137075f, -0.21522693f, -0.03551824f, 0.09917295f, 0.10178092f, 
    0.03129666f, -0.09621234f, -0.05368333f, -0.05619867f, -0.22463922f, 0.07201573f, 0.13616794f, 0.08434949f, 
    -0.10365584f, 0.02331985f, 0.01612651f, 0.02129119f, -0.18783972f, -0.04751791f, -0.12835430f, -0.07583996f, 
    0.05614409f, -0.17235784f, 0.15083142f, 0.15230499f, 0.12068317f, -0.17338808f, 0.04109216f, 0.07074507f, 
    0.08178260f, -0.02709305f, 0.09699139f, -0.01108082f, -0.06215729f, 0.08695977f, 0.01083857f, -0.04781225f, 
    0.15774874f, 0.00392695f, 0.04626575f, -0.04179492f, 0.10962585f, -0.32729664f, -0.17845055f, 0.17094451f, 
    0.01883654f, 0.04313499f, -0.20225202f, -0.15310211f, 0.05635457f, 0.11073262f, 0.06955673f, -0.00159505f, 
    0.14544617f, 0.11745030f, 0.01932038f, 0.01662120f, 0.13180754f, 0.02457477f, 0.11394612f, 0.01350614f, 
    0.11221795f, -0.26627445f, -0.21621275f, 0.05150861f, -0.02252545f, 0.07626286f, -0.02193480f, -0.10833977f, 
    0.05872240f, 0.00209703f, -0.08558680f, -0.06588607f, -0.03008070f, -0.12363323f, 0.02053543f, 0.04315165f, 
    -0.05108596f, 0.00546264f, 0.02280746f, 0.05137898f, 0.18225983f, -0.14012137f, -0.06835537f, 0.00794820f, 
    0.05057065f, 0.15221548f, 0.04308250f, -0.12088883f, -0.00279657f, -0.02705888f, -0.00831366f, 0.10046091f, 
    -0.17131472f, -0.03977116f, -0.08700904f, 0.10373470f, -0.00026560f, -0.07852558f, 0.04374882f, 0.05497403f, 
    0.32148930f, 0.09197003f, -0.29983011f, 0.20719601f, 0.11095334f, -0.00523116f, 0.09481877f, -0.02886004f, 
    0.18281934f, 0.07812767f, -0.15411571f, -0.06565753f, -0.10729875f, 0.09746817f, 0.06029573f, 0.00682317f, 
    -0.00108185f, 0.02400648f, -0.14963032f, 0.02037162f, -0.61210030f, 0.51866657f, -0.10294556f, 0.18947770f, 
    0.11371421f, -0.05601916f, -0.08926513f, 0.08121525f, 0.09179746f, -0.25405002f, -0.04247417f, -0.09209723f, 
    0.03563648f, 0.07983027f, 0.00627691f, 0.07374865f, 0.08577891f, -0.00195963f, -0.05277281f, 0.01269521f, 
    0.08149417f, 0.19709246f, -0.07070683f, -0.08871396f, 0.18618743f, 0.18337367f, 0.06790057f, 0.36711609f, 
    0.11841906f, 0.47296989f, -0.03079201f, 0.05721522f, 0.06141629f, -0.09422215f, -0.05111050f, -0.02753173f, 
    0.03179547f, 0.25117818f, 0.25800601f, 0.32415894f, -0.21447936f, -0.02251934f, -0.14494273f, 0.18521665f, 
    0.13430533f, -0.07495054f, -0.02129105f, 0.10433902f, -0.09478429f, -0.10935493f, -0.01155443f, 0.01662497f, 
    -0.00114354f, -0.04932702f, 0.01831549f, -0.02633555f, 0.09387179f, 0.03148185f, -0.05813888f, -0.02753487f, 
    -0.20875852f, 0.08328486f, 0.15846275f, -0.05732872f, -0.19426808f, -0.09637962f, -0.05898175f, -0.05334654f, 
    0.03817227f, -0.05517025f, 0.06437555f, 0.02534770f, 0.16201857f, -0.04784008f, 0.02372438f, -0.13057731f, 
    -0.15062334f, -0.14419384f, -0.13129012f, -0.06632146f, -0.19534013f, -0.16698065f, 0.06955468f, 0.05394321f, 
    -0.28775668f, 0.04312530f, 0.02287981f, 0.07448878f, -0.00491683f, 0.17844366f, 0.09918097f, -0.03183781f, 
    -0.19057611f, 0.11409640f, 0.02598372f, 0.06971128f, 0.11043455f, 0.13159788f, -0.00472184f, 0.03257368f, 
    0.09806490f, 0.07213447f, -0.19862451f, 0.05920945f, 0.42102876f, -0.06255547f, -0.06712966f, 0.18062490f, 
    0.00796413f, 0.07983237f, 0.03393352f, 0.02802507f, 0.01404752f, -0.06961206f, 0.04765632f, 0.02362731f, 
    -0.08908956f, 0.17445867f, 0.02615519f, 0.00334062f, 0.05432189f, -0.01697146f, 0.03898812f, 0.16691463f, 
    0.20619507f, -0.13881764f, 0.05496884f, -0.00513706f, -0.10997837f, -0.03208325f, 0.00888409f, -0.05359407f, 
    0.03687596f, -0.01160395f, 0.06545500f, 0.07063115f, -0.08802819f, -0.06767195f, 0.11496124f, 0.00905773f, 
    -0.22672056f, 0.07764515f, -0.12808889f, -0.02679691f, 0.09469200f, -0.11690816f, 0.15043677f, 0.11033349f, 
    -0.02273959f, 0.11033933f, -0.02081362f, 0.05095751f, -0.07017244f, -0.00926911f, 0.07197417f, 0.12167133f, 
    0.06846822f, 0.05086726f, -0.02411387f, -0.02669703f, -0.20288618f, -0.27091193f, -0.19792937f, 0.17834851f, 
    0.37012500f, 0.05658191f, -0.03288412f, 0.17019053f, 0.04522063f, 0.14266813f, 0.04748235f, -0.00731295f, 
    0.00675046f, 0.21222141f, 0.15021464f, -0.07510594f, -0.03615885f, 0.11349358f, -0.03322379f, -0.03412882f, 
    0.22409227f, 0.27407381f, -0.07016566f, -0.12040923f, -0.37324390f, 0.00467873f, 0.08672205f, 0.08627832f, 
    -0.03595005f, -0.38143733f, -0.16549566f, -0.00649417f, 0.07960685f, 0.07865389f, 0.18049380f, -0.02082646f, 
    0.02525969f, -0.10326844f, 0.16649070f, -0.00126897f, -0.15625465f, 0.10718600f, -0.15650873f, 0.03945095f, 
    -0.05125625f, -0.16416726f, 0.05718261f, -0.11760730f, -0.07975425f, -0.03517473f, 0.01916080f, 0.07177097f, 
    -0.04437521f, -0.02785853f, -0.04301572f, -0.00932089f, 0.06946584f, -0.04831016f, -0.00417486f, 0.06981149f, 
    0.07369339f, -0.11942629f, -0.14837505f, -0.04064946f, 0.27434200f, -0.10825504f, -0.20994233f, 0.10587613f, 
    0.18304256f, 0.09280398f, -0.09075843f, 0.08391353f, -0.05452261f, -0.03535954f, 0.03166794f, 0.08500886f, 
    0.05796465f, 0.04020241f, 0.04291183f, -0.05111820f, 0.71513236f, -0.14673486f, -0.24007484f, -0.05393030f, 
    -0.03435055f, 0.08751765f, 0.09614573f, 0.13634606f, 0.08406392f, 0.08319579f, 0.05051419f, -0.00458631f, 
    -0.01188276f, 0.11331476f, 0.05309656f, 0.05750681f, 0.06259643f, 0.23096263f, 0.09035022f, -0.05657270f, 
    0.03535013f, -0.12558348f, 0.03268021f, 0.15371649f, -0.08808926f, 0.09943581f, 0.02642425f, 0.21467635f, 
    -0.02174917f, -0.02516486f, -0.04252168f, -0.03537720f, 0.01535962f, 0.15106969f, 0.01506801f, -0.04004676f, 
    0.08445188f, -0.04564061f, 0.03187869f, 0.02160478f, 0.21854928f, 0.02706797f, 0.06066113f, 0.07155954f, 
    -0.18334112f, -0.07725704f, 0.05048387f, -0.03094947f, -0.01122596f, 0.03208395f, 0.09696044f, 0.02635594f, 
    -0.02222365f, 0.00648736f, -0.05722994f, 0.08082395f, -0.09620638f, -0.08317004f, -0.01980163f, -0.02043631f, 
    -0.23657446f, 0.01856000f, -0.01676853f, 0.00484561f, -0.14701168f, -0.04713867f, 0.03839600f, -0.02194286f, 
    0.02712126f, -0.04034987f, 0.00561795f, -0.01646439f, 0.04073780f, 0.12573156f, 0.08682352f, -0.10153633f, 
    0.07765768f, 0.12918617f, 0.03867425f, 0.02606823f, -0.13010181f, 0.06715579f, -0.66257131f, -0.09564572f, 
    -0.16710255f, -0.01898929f, -0.22249952f, -0.13600007f, -0.22504847f, -0.11671700f, 0.07909804f, -0.04040527f, 
    -0.03589900f, -0.07551017f, -0.08752698f, -0.02136607f, 0.00884874f, -0.12813056f, -0.17829542f, -0.10124678f, 
    0.28974208f, 0.37296376f, 0.36613071f, 0.09666837f, -0.02682453f, 0.02564440f, 0.02271971f, 0.16704609f, 
    -0.04971661f, 0.30423677f, -0.05180341f, 0.04063614f, -0.00326162f, -0.02146702f, 0.00056068f, -0.07691933f, 
    -0.17058048f, -0.11820707f, -0.16534618f, -0.39816800f, 0.04809839f, 0.15591322f, -0.44611871f, 0.05308282f, 
    -0.02508232f, 0.00279413f, -0.10627609f, -0.02439066f, -0.01733065f, 0.03056370f, 0.04909348f, -0.05220959f, 
    0.04421534f, 0.00906659f, -0.05872241f, -0.03056911f, 0.05693087f, 0.01483623f, 0.03583324f, 0.03542790f, 
    0.00480651f, -0.19825488f, -0.34926638f, -0.23708037f, 0.03104828f, 0.06068819f, -0.00217782f, 0.04774366f, 
    0.01726455f, 0.09509274f, 0.14136124f, 0.10896269f, 0.15039439f, 0.15623748f, 0.17039046f, -0.03806341f, 
    0.03339094f, 0.06995314f, -0.20321745f, 0.00219908f, -0.14130957f, -0.35464627f, -0.29048136f, -0.13502927f, 
    0.07464776f, 0.04599354f, -0.02254052f, -0.09154688f, -0.13916139f, -0.10892312f, 0.11355874f, -0.14814469f, 
    0.10633700f, -0.13097884f, 0.00743730f, 0.09690862f, -0.09448120f, -0.10127562f, -0.22052822f, -0.09637808f, 
    0.27740863f, 0.39281249f, 0.39007005f, 0.07851056f, -0.08103970f, 0.01017823f, 0.12632498f, -0.04307573f, 
    0.00838174f, 0.16575231f, 0.06789540f, 0.08327595f, 0.07713899f, 0.08682535f, 0.09346461f, -0.04970924f, 
    0.08649870f, -0.02156479f, 0.11520801f, 0.06953061f, 0.08612791f, 0.45246705f, -0.47720620f, 0.42239723f, 
    -0.02836589f, 0.08838282f, -0.04904108f, 0.02538076f, 0.01059404f, 0.14529882f, 0.07285526f, 0.07113155f, 
    0.01243898f, 0.04701465f, -0.06771299f, -0.03167817f, 0.12405766f, 0.12575446f, 0.06439822f, 0.11287553f, 
    0.14049368f, -0.08907105f, 0.17660043f, -0.08882987f, -0.01053277f, -0.12468432f, 0.11102182f, 0.08143961f, 
    0.04257542f, 0.10447074f, 0.02629220f, 0.01567256f, 0.06218300f, 0.10056888f, 0.03153152f, 0.04836240f, 
    0.16475779f, -0.00506481f, 0.14415285f, 0.19202808f, 0.25081438f, -0.00203804f, 0.41364172f, -0.24094349f, 
    0.03923148f, 0.03708040f, 0.09656166f, 0.01341553f, -0.07970957f, -0.01001235f, 0.03374823f, -0.07993288f, 
    0.08106749f, 0.08595733f, 0.11220790f, 0.00865500f, -0.01614368f, 0.03112197f, -0.04556755f, 0.16689436f, 
    -0.78253865f, -0.33632824f, -0.25763416f, 0.22701193f, -0.17199074f, 0.07898375f, -0.12509339f, -0.28320169f, 
    -0.16175860f, -0.03230233f, 0.10301878f, 0.00892368f, -0.00612399f, 0.08243092f, -0.00994687f, 0.02052860f, 
    -0.09746605f, -0.16752745f, -0.14453286f, 0.02829358f, -0.17718409f, -0.30724424f, -0.31401756f, -0.04665469f, 
    -0.05908772f, -0.09657477f, 0.00290117f, -0.06544807f, -0.08925074f, -0.09380256f, 0.04897599f, -0.01409854f, 
    0.01638780f, 0.05334772f, -0.01471752f, 0.06620744f, -0.12292171f, -0.02560543f, -0.14252409f, -0.02279566f, 
    0.35085386f, 0.12829500f, 0.47912052f, 0.01509201f, 0.08252821f, -0.05491409f, 0.12819023f, 0.09877268f, 
    0.04761662f, 0.02559843f, -0.00571400f, -0.00321560f, 0.06677407f, 0.08010146f, 0.01039176f, 0.00376638f, 
    0.00787053f, -0.17911911f, 0.10417989f, 0.16580696f, -0.15197529f, 0.07671154f, 0.17699148f, 0.15618782f, 
    -0.10935257f, -0.05309561f, 0.00529355f, 0.06122481f, 0.08834065f, 0.04697027f, 0.07686000f, 0.00619028f, 
    0.00835937f, 0.14364317f, 0.14362906f, -0.02233560f, 0.15178353f, 0.07688274f, 0.00069073f, 0.19009915f, 
    0.28026274f, 0.10711716f, -0.07764368f, 0.20178492f, -0.04684708f, 0.04282720f, 0.05285923f, 0.30160427f, 
    0.10374007f, 0.15736306f, 0.02441159f, -0.05271526f, -0.04529197f, 0.00940730f, 0.01501369f, 0.09033068f, 
    -0.05532176f, -0.13546672f, 0.03022565f, -0.03466088f, -0.05134603f, -0.03189551f, -0.27382216f, -0.12536006f, 
    -0.05427422f, -0.09526346f, -0.01646108f, 0.05268766f, -0.00932348f, 0.21982943f, -0.01331357f, 0.00527534f, 
    0.00421913f, -0.13631034f, -0.08266968f, 0.01191229f, -0.00179585f, -0.02647182f, -0.05947866f, 0.03500788f, 
    0.22539242f, 0.01359521f, 0.09456570f, 0.12715878f, -0.06966611f, -0.05934551f, 0.11013030f, 0.10118622f, 
    0.15086243f, -0.02971373f, 0.15449907f, -0.04788289f, 0.02347427f, 0.04874856f, 0.09827990f, 0.13911523f, 
    -0.02472238f, -0.12833573f, 0.07065509f, -0.02082357f, -0.30085361f, -0.10920385f, -0.13755162f, -0.12334710f, 
    -0.26597521f, 0.01665153f, -0.07600918f, -0.25631452f, -0.07738944f, 0.11803459f, -0.08667099f, 0.01799860f, 
    0.01261558f, 0.01231223f, -0.00992437f, -0.05493572f, -0.06545986f, -0.24041435f, 0.04479372f, 0.13453321f, 
    0.16968903f, 0.21028654f, 0.01353711f, 0.06616123f, -0.12018096f, -0.24299516f, -0.13504364f, -0.14675882f, 
    0.02570464f, -0.00121108f, -0.05777261f, 0.11767827f, -0.10371446f, 0.06712206f, 0.06096361f, -0.04341089f, 
    0.12043035f, 0.07051747f, 0.09084038f, 0.01163162f, -0.09767704f, 0.27956051f, -0.24765475f, -0.06617200f, 
    -0.35546160f, -0.04333053f, -0.08788874f, -0.04554100f, -0.13089934f, -0.15084508f, -0.05823018f, 0.01269975f, 
    -0.04432207f, -0.04274098f, 0.06055722f, -0.02684448f, -0.04941995f, -0.03173300f, 0.04207411f, -0.03636904f, 
    -0.12391703f, 0.00900508f, -0.22409551f, -0.19037937f, -0.00017830f, -0.18230386f, -0.06096396f, -0.06647550f, 
    -0.08529280f, -0.01533455f, 0.06538925f, 0.06936346f, 0.11420706f, 0.11066020f, 0.12549035f, 0.03256307f, 
    -0.02729651f, -0.03740704f, -0.21790592f, -0.03206111f, 0.10953815f, -0.19129312f, -0.39419785f, -0.08428960f, 
    -0.12887032f, -0.08068714f, -0.02952291f, 0.01476434f, -0.18155512f, -0.02724946f, -0.06293605f, -0.00029137f, 
    -0.04281993f, -0.03148270f, 0.01260452f, 0.06651671f, 0.04496846f, -0.04842392f, -0.05174513f, 0.05584210f, 
    0.21438943f, 0.39088732f, 0.36834517f, 0.05242223f, -0.16819029f, -0.00450122f, -0.14826475f, -0.10234807f, 
    0.16966434f, 0.05616893f, -0.05073985f, 0.02136134f, -0.02438931f, 0.02646996f, 0.08455411f, 0.03473741f, 
    0.02240730f, 0.08735153f, 0.05863319f, 0.00285179f, -0.09397352f, 0.23838359f, -0.51625818f, 0.01801906f, 
    -0.48749667f, 0.01123876f, -0.17326820f, -0.23443827f, -0.14775164f, -0.08964393f, -0.01519204f, 0.04968191f, 
    -0.01019333f, 0.03400267f, -0.03443301f, -0.03374626f, 0.07551353f, -0.00315905f, 0.06000236f, -0.01408592f, 
    0.55220836f, -0.01055294f, 0.21002021f, -0.10763600f, 0.10195468f, 0.01323175f, -0.04309495f, 0.00572222f, 
    0.19504866f, 0.05230733f, 0.11230878f, -0.01513644f, 0.07270230f, 0.12963620f, 0.05063077f, -0.09465560f, 
    0.00986542f, -0.09483505f, 0.11654287f, 0.00899032f, 0.56434411f, -0.07558276f, 0.25026324f, -0.12753722f, 
    0.01495595f, 0.07935710f, 0.06626637f, 0.20471269f, -0.18238115f, 0.01956294f, 0.02779148f, -0.01840880f, 
    0.04572250f, 0.13914385f, 0.06564351f, 0.07681991f, -0.07054433f, 0.14825071f, -0.05694678f, 0.11571500f, 
    -0.38038796f, -0.13689664f, -0.26200962f, -0.06324577f, 0.12276002f, -0.02131773f, -0.04634814f, -0.05959714f, 
    0.02040686f, 0.02385027f, 0.04796464f, 0.06164160f, 0.01456870f, -0.17419571f, 0.02062365f, 0.02251460f, 
    0.10462832f, -0.13608225f, -0.07250234f, 0.11153758f, -0.11353277f, -0.13408056f, -0.23282851f, -0.05893038f, 
    -0.02750596f, -0.07243050f, 0.07702385f, -0.05072670f, -0.04379034f, 0.01936710f, 0.09559971f, -0.00904922f, 
    0.12347390f, -0.07205845f, 0.01920325f, 0.04516197f, 0.02870102f, -0.00412487f, -0.12641098f, 0.08966854f, 
    0.33971429f, 0.15354657f, 0.53378880f, 0.03438853f, 0.16035679f, 0.11398262f, -0.08557864f, 0.09602775f, 
    -0.08183758f, 0.02156087f, 0.06340526f, 0.01427434f, 0.03518749f, 0.06327422f, 0.11880521f, -0.06114072f, 
    -0.03073558f, 0.14155617f, 0.07510719f, 0.02707009f, -0.28706983f, 0.28423375f, 0.21200016f, 0.09360986f, 
    0.05442746f, 0.21192512f, -0.03615016f, 0.02674088f, -0.02405984f, -0.03180819f, 0.05654152f, -0.00917317f, 
    -0.06237440f, -0.01326938f, 0.05131238f, -0.03781983f, -0.09830814f, -0.10983053f, -0.05986713f, -0.12240733f, 
    -0.01156271f, 0.04845054f, 0.12993135f, 0.18128343f, -0.32469097f, -0.07246270f, -0.03940107f, -0.17618123f, 
    0.02858199f, -0.03044300f, 0.04495947f, 0.01760628f, 0.00961804f, 0.00846761f, 0.04420085f, 0.07326083f, 
    0.03622607f, -0.01643045f, 0.06899072f, 0.03891754f, -0.10965312f, -0.01354252f, 0.03323588f, 0.11325739f, 
    -0.18473774f, -0.20329863f, -0.16827042f, -0.02098310f, -0.02371501f, 0.02772795f, 0.06180885f, -0.08185655f, 
    0.03328983f, -0.00450502f, -0.04375580f, 0.06562250f, -0.02177525f, -0.11848301f, -0.08719797f, -0.04900588f, 
    0.02107243f, -0.17067006f, 0.14788593f, 0.02899810f, -0.32632193f, -0.00066631f, 0.02445271f, 0.03195179f, 
    0.05124061f, 0.00668373f, 0.03831313f, -0.03823186f, 0.05664216f, 0.00565135f, -0.00712981f, 0.17597328f, 
    0.03469450f, 0.02037660f, 0.05196245f, 0.17147157f, -0.20484486f, -0.12741551f, 0.14106198f, -0.12815854f, 
    -0.11108831f, 0.02633255f, -0.01077251f, -0.01227077f, 0.19954060f, -0.01313842f, -0.07941837f, -0.05452421f, 
    0.00634181f, 0.06400721f, -0.10100172f, -0.06876760f, 0.04311755f, -0.08957111f, 0.04016917f, 0.01277281f, 
    -0.16095230f, 0.08698497f, 0.07606088f, 0.26036417f, 0.00251210f, -0.13299382f, -0.08513729f, 0.06650570f, 
    -0.04194575f, 0.16283634f, -0.09624884f, 0.02867826f, 0.05996069f, -0.00227477f, 0.00679657f, -0.05491463f, 
    -0.12762845f, -0.11227182f, -0.21928617f, -0.24219564f, 0.27735901f, 0.13698821f, -0.11898264f, 0.17818740f, 
    -0.07020094f, -0.02514170f, -0.07728497f, 0.07393739f, 0.08066113f, -0.08978750f, -0.08063288f, 0.01454944f, 
    -0.01998157f, -0.02130464f, -0.05621618f, 0.09810786f, 0.12570965f, 0.03715301f, 0.07292181f, 0.10138551f, 
    0.10408546f, 0.10122943f, 0.14739242f, 0.03053407f, 0.11329082f, -0.00099549f, 0.01982618f, 0.02347775f, 
    -0.01044770f, -0.01551073f, 0.14312600f, 0.10632844f, 0.08721391f, 0.07482870f, 0.01157760f, 0.00309263f, 
    -0.06002522f, -0.13172185f, -0.11801409f, -0.01564681f, 0.30954581f, 0.04936424f, -0.08926431f, -0.04522127f, 
    0.00335373f, 0.00676150f, 0.06437826f, 0.08089136f, -0.02262038f, -0.00662190f, -0.15435697f, 0.10998288f, 
    -0.10878208f, 0.09503791f, -0.08651889f, -0.01763858f, 0.01331136f, 0.01579290f, -0.04168316f, -0.09712351f, 
    -0.04287105f, 0.22739691f, 0.26604363f, 0.01106189f, -0.16835138f, 0.06158401f, -0.22709179f, -0.05712200f, 
    0.12549432f, 0.15517172f, 0.02433654f, 0.02299066f, -0.05024019f, -0.02695918f, 0.05011361f, 0.04886617f, 
    -0.01424887f, 0.04854784f, 0.12375288f, 0.03959369f, 0.47330353f, 0.18546790f, -0.37902412f, 0.06052871f, 
    -0.04732465f, 0.00009775f, -0.00425579f, 0.00185467f, -0.09848779f, 0.07212526f, 0.00270987f, -0.02944819f, 
    -0.01167933f, -0.01635416f, 0.01289827f, 0.07251406f, 0.13004525f, -0.07780185f, 0.13059901f, 0.14564282f, 
    0.12841085f, -0.08729121f, -0.15995088f, -0.01787239f, 0.18002467f, 0.03431243f, 0.06814353f, 0.03264119f, 
    -0.03223873f, -0.05714235f, 0.20166898f, 0.00609193f, 0.13163944f, 0.05261833f, -0.03929041f, -0.00081918f, 
    0.06990018f, -0.01648325f, -0.01223073f, 0.08526689f, 0.26659262f, -0.07842388f, 0.27881265f, -0.16935645f, 
    -0.21023065f, 0.03365661f, 0.03420376f, -0.05336091f, 0.15342976f, -0.09807053f, -0.08102740f, -0.09385990f, 
    0.11176454f, 0.11211852f, 0.01225442f, 0.00987051f, 0.07633384f, 0.12750542f, -0.07895046f, -0.00711198f, 
    -0.22826734f, -0.22184876f, 0.18803519f, 0.05974405f, 0.24941263f, -0.04293918f, 0.08806992f, 0.20314696f, 
    0.11533847f, -0.17322561f, 0.10975989f, -0.03098145f, 0.11803059f, -0.02978211f, -0.05770888f, 0.10905208f, 
    0.01906049f, -0.21103983f, -0.03776941f, 0.04299918f, -0.00374006f, -0.04732021f, 0.01630032f, 0.12281882f, 
    0.02575268f, -0.10254946f, 0.06730379f, 0.01063038f, -0.15747777f, 0.00856410f, 0.00208416f, -0.10638171f, 
    -0.04233507f, 0.04882173f, 0.02597951f, 0.02700000f, -0.05754073f, 0.02414278f, -0.18684338f, -0.16479394f, 
    0.12969041f, 0.13863613f, 0.12011512f, -0.05319192f, 0.00857163f, -0.03973618f, -0.19455418f, -0.02145218f, 
    0.00590091f, 0.08039990f, -0.01293288f, 0.01524015f, -0.01071913f, -0.07366265f, 0.06073745f, 0.05583002f, 
    0.06682903f, -0.02014910f, 0.00556853f, -0.00710162f, -0.22641620f, -0.04281463f, 0.11629473f, 0.14165357f, 
    -0.01414761f, 0.02410100f, 0.06878976f, 0.03838772f, -0.09446767f, -0.03448070f, 0.08313731f, 0.04436775f, 
    0.04670199f, 0.02172047f, 0.09145620f, 0.19801737f, 0.05304824f, 0.11601398f, 0.00878594f, -0.01273394f, 
    -0.07991604f, -0.28918213f, -0.18365578f, -0.31190047f, -0.18894555f, 0.10481153f, 0.14485787f, -0.13218097f, 
    -0.02491491f, 0.05283684f, 0.09958770f, -0.07709426f, 0.01316888f, 0.04918584f, -0.03315770f, -0.07769436f, 
    -0.00483130f, -0.02628097f, -0.10936215f, 0.03394337f, 0.07425749f, -0.31376502f, 0.06237924f, 0.16915607f, 
    -0.08439896f, 0.08257125f, -0.02992866f, 0.04817033f, -0.06255604f, 0.04967457f, 0.06179521f, -0.01191747f, 
    0.00837150f, -0.03154355f, 0.01635229f, 0.03157881f, -0.08547426f, -0.15301125f, -0.11380951f, -0.18818596f, 
    -0.33530670f, -0.21500161f, -0.25713611f, -0.15096644f, -0.17340125f, 0.06466582f, 0.19500494f, 0.00368843f, 
    0.02629705f, -0.03111414f, 0.01369844f, 0.00859244f, 0.08097319f, 0.14220585f, 0.07548721f, -0.05742839f, 
    -0.13925043f, 0.05583352f, -0.03188200f, 0.07486111f, 0.37174892f, -0.26908064f, 0.34746039f, -0.06503086f, 
    0.03241291f, 0.05905351f, 0.25555268f, -0.17176630f, 0.25599855f, 0.01255356f, -0.15415907f, -0.05886880f, 
    -0.04329127f, 0.08576009f, 0.13545610f, -0.01368935f, 0.10076979f, 0.05485232f, 0.01587177f, 0.02810294f, 
    -0.05575824f, 0.13890661f, -0.06964318f, 0.08569952f, 0.09068782f, -0.21137817f, -0.18343624f, -0.03310982f, 
    -0.10484853f, -0.03056123f, 0.02746982f, 0.24625410f, 0.11726046f, -0.04430678f, 0.08338382f, -0.10977971f, 
    -0.25906059f, -0.06320971f, -0.23677826f, -0.06146196f, 0.32022381f, -0.03360485f, 0.28779578f, 0.09143631f, 
    0.03593509f, -0.01557417f, -0.10794994f, -0.16853318f, 0.01935353f, -0.04579467f, -0.08507271f, -0.08325560f, 
    -0.14389075f, -0.05210555f, -0.12723033f, -0.02876422f, 0.00042244f, -0.01889167f, 0.03257899f, 0.11121612f, 
    -0.31929961f, -0.12443752f, -0.09943539f, -0.04891011f, -0.09843437f, 0.08893893f, 0.06271090f, 0.06142974f, 
    0.02508990f, 0.01019336f, -0.11336733f, 0.07670553f, -0.09837129f, 0.16041198f, 0.00623823f, 0.03424259f, 
    -0.04576755f, 0.12585957f, -0.03292751f, -0.03781527f, 0.07775591f, 0.12512878f, 0.18843697f, 0.09426533f, 
    -0.12570056f, -0.09354003f, 0.07840393f, 0.01236400f, 0.16059488f, 0.05686277f, -0.14982834f, 0.02974504f, 
    0.08922040f, -0.04896925f, 0.12107127f, -0.06241857f, 0.06268857f, 0.10944830f, 0.14791135f, -0.09525007f, 
    0.22021770f, 0.00765547f, 0.33727470f, 0.04489366f, -0.01407339f, 0.03480652f, -0.15934087f, -0.09413081f, 
    0.14299624f, -0.01009385f, -0.00554645f, 0.00125350f, 0.07523654f, 0.13429168f, -0.05600247f, -0.11674520f, 
    -0.05327065f, -0.09799516f, 0.22733377f, 0.05698815f, 0.34998465f, 0.25219870f, 0.47918910f, 0.06427287f, 
    -0.11863153f, 0.09563792f, -0.09794214f, -0.07858550f, 0.00746029f, -0.00721438f, -0.07642479f, 0.00210472f, 
    -0.07352948f, -0.09659644f, -0.04793797f, 0.05007415f, 0.04224157f, -0.04674091f, 0.01235471f, 0.26228270f, 
    0.17342867f, 0.06164651f, -0.10516132f, -0.04275959f, -0.00057605f, 0.05246458f, -0.05849122f, 0.36766616f, 
    -0.13007860f, -0.01882609f, 0.00589889f, 0.07028219f, 0.06712621f, 0.05470877f, -0.08714969f, 0.04222100f, 
    -0.11027699f, 0.09758746f, -0.03673394f, 0.11121092f, -0.10355738f, -0.18330528f, 0.34720385f, -0.00766630f, 
    -0.02764202f, 0.05229846f, 0.13269459f, -0.12759988f, 0.24253157f, -0.12911160f, -0.06872523f, 0.02084835f, 
    0.07920439f, -0.01975441f, 0.07217441f, 0.01049334f, -0.02299231f, 0.01004481f, 0.15143079f, -0.02901527f, 
    0.08597964f, -0.06420214f, 0.61205089f, -0.14440984f, 0.22901054f, 0.08484745f, 0.03678413f, 0.04313433f, 
    0.05813697f, -0.04774392f, -0.09734280f, -0.07037923f, 0.05944660f, 0.19529007f, 0.12122884f, 0.22272553f, 
    0.04623909f, 0.14399642f, -0.20933102f, 0.11616726f, -0.19409515f, -0.07401654f, -0.35977548f, 0.03150691f, 
    -0.15468597f, 0.06465956f, -0.08740726f, 0.15228638f, -0.08873594f, 0.17553112f, 0.00876556f, 0.02715589f, 
    0.03599038f, -0.00615184f, 0.05786636f, -0.05950700f, -0.03690961f, -0.01134502f, -0.07070117f, -0.01827963f, 
    0.29832858f, 0.09644313f, -0.02563096f, -0.03685756f, -0.01258901f, 0.08041767f, -0.06372941f, -0.09468566f, 
    0.06511416f, -0.08021787f, -0.01963144f, -0.02060614f, 0.03262736f, -0.02704132f, -0.09495617f, 0.03052616f, 
    -0.09523571f, -0.10730705f, 0.05725093f, 0.01496087f, 0.02389727f, -0.29432544f, 0.60188580f, -0.22624829f, 
    0.06389564f, -0.14846182f, 0.05543439f, 0.18332635f, 0.19934577f, -0.08149493f, -0.07567886f, 0.13434985f, 
    -0.03215863f, 0.08110913f, -0.06214994f, 0.13096720f, -0.04407094f, -0.13938411f, 0.11601102f, -0.07671065f, 
    -0.02135563f, 0.04573911f, -0.03243593f, -0.00169107f, -0.04681369f, 0.01502679f, 0.01246053f, 0.00140193f, 
    -0.05046444f, -0.01372049f, -0.04897678f, 0.02777436f, -0.03148590f, 0.02437975f, 0.00013469f, -0.01979948f, 
    -0.03975024f, -0.05614276f, -0.05404984f, -0.02387654f, -0.01246813f, -0.01033472f, 0.00901376f, -0.01518416f, 
    -0.00274874f, -0.03951980f, 0.04445633f, 0.01982623f, -0.01123489f, 0.02353491f, 0.02538463f, 0.02580474f, 
    0.04343169f, 0.02985735f, -0.03926613f, -0.01428984f, -0.05026403f, -0.00571934f, 0.02900250f, -0.02786321f, 
    0.02875157f, -0.05796030f, -0.00523044f, -0.01505341f, -0.05972987f, -0.02768244f, 0.04073886f, -0.05845845f, 
    0.01237222f, 0.00364558f, -0.06159488f, -0.04526016f, 0.02882865f, -0.04553258f, -0.04635559f, -0.00500311f, 
    -0.06841437f, -0.01387076f, -0.03332019f, 0.02376123f, 0.01978356f, -0.00116807f, 0.04944239f, -0.02489142f, 
    0.02888008f, -0.02340798f, -0.03829571f, -0.01958402f, 0.01164801f, -0.06405134f, 0.00177878f, -0.04229727f, 
    -0.05502024f, 0.02361052f, -0.01562230f, -0.02776635f, -0.04901529f, -0.04857470f, -0.01721482f, -0.05476509f, 
    -0.02442433f, -0.05052360f, -0.00411657f, -0.00454517f, -0.02755348f, -0.03703679f, -0.03343726f, 0.00440868f, 
    -0.06236537f, 0.01844069f, -0.00372452f, 0.02848173f, -0.02607846f, -0.01690508f, 0.02579795f, -0.00256410f, 
    0.00997956f, 0.03471215f, 0.02335164f, -0.03536751f, 0.01586674f, 0.03559094f, 0.00049553f, -0.05310682f, 
    -0.01890916f, -0.02461954f, -0.03522670f, 0.02662516f, 0.00687359f, 0.03192481f, -0.05919706f, -0.05321443f, 
    0.00091735f, 0.02407009f, 0.03389475f, 0.03018745f, -0.02018039f, -0.06600337f, -0.01037183f, -0.02135589f, 
    -0.01093550f, -0.04825387f, 0.00882399f, -0.01078409f, 0.03123036f, -0.06189685f, -0.03137484f, 0.04999473f, 
    -0.02376506f, -0.05196647f, -0.01447956f, -0.01653099f, -0.05323967f, -0.00497721f, 0.02252715f, 0.00218449f, 
    -0.01320510f, 0.04579212f, 0.02941116f, 0.03019498f, -0.04435557f, 0.03299103f, 0.03888152f, -0.02836535f, 
    -0.05289587f, -0.01218698f, 0.03704034f, 0.02205350f, -0.03211495f, -0.01280825f, 0.02414607f, -0.00357180f, 
    0.03785175f, 0.04550612f, -0.01441028f, -0.00109070f, 0.02838021f, -0.01614092f, -0.03150381f, 0.00001637f, 
    0.02398593f, -0.06451207f, -0.05563435f, -0.02944098f, -0.00049397f, 0.03985289f, -0.04136407f, 0.01936062f, 
    0.00747762f, -0.00186398f, -0.00472522f, -0.00273715f, 0.03665241f, 0.04836384f, -0.02273454f, -0.04796211f, 
    0.02037095f, 0.01926452f, -0.01424780f, -0.01643242f, 0.02325688f, 0.02724596f, -0.05574380f, -0.03153364f, 
    -0.05731351f, 0.03610419f, 0.03769918f, -0.02467006f, 0.04144881f, 0.03699940f, -0.04677551f, -0.05493605f, 
    -0.03793330f, 0.00943455f, 0.05186104f, -0.02947061f, -0.01372632f, -0.02686821f, 0.04143223f, -0.03961003f, 
    -0.02522552f, 0.02595146f, 0.05097790f, -0.03154580f, 0.01285073f, 0.02675273f, 0.04498997f, 0.00448641f, 
    0.00843341f, -0.05109758f, -0.02689821f, 0.03339580f, -0.04090759f, 0.01851250f, -0.02289752f, -0.00501000f, 
    -0.02811773f, -0.06432807f, -0.05777742f, -0.01821546f, -0.00179037f, 0.04390413f, -0.02564754f, -0.05357104f, 
    -0.04449227f, 0.04429738f, -0.04165219f, 0.01288737f, 0.04889024f, -0.03821534f, 0.03747575f, -0.04194484f, 
    0.00064379f, -0.02139087f, 0.04322559f, -0.00443922f, -0.04844336f, -0.03129892f, 0.02257640f, 0.04173661f, 
    -0.03836453f, -0.04780694f, 0.00419510f, 0.01400061f, 0.03105817f, -0.03969708f, -0.01290059f, -0.04060262f, 
    -0.03517549f, 0.05374873f, -0.01762467f, -0.04827704f, -0.05944144f, 0.04617234f, 0.03446660f, -0.02000212f, 
    0.02929430f, 0.04214155f, 0.04834712f, -0.05355729f, 0.02481991f, -0.01592899f, -0.04712006f, -0.05737644f, 
    -0.05804511f, -0.00014898f, -0.02179847f, 0.00302787f, 0.00594604f, -0.05370337f, 0.03649104f, -0.05704750f, 
    0.02042927f, 0.00890125f, -0.03817827f, 0.00882265f, -0.03161936f, -0.04190106f, -0.05879443f, -0.04004031f, 
    0.00850644f, -0.01615670f, -0.03839622f, 0.03048450f, 0.02884882f, -0.03820506f, 0.00770313f, -0.00055002f, 
    -0.00420758f, 0.03369423f, 0.02378327f, -0.04085427f, -0.03193730f, -0.02908132f, -0.01187287f, -0.04053838f, 
    0.00464622f, 0.03125080f, -0.04284754f, 0.01617845f, -0.01380164f, -0.06545513f, -0.01577824f, 0.02084899f, 
    0.01290910f, -0.03834604f, -0.03382293f, 0.04411706f, -0.05318061f, -0.01782084f, -0.01664291f, 0.00073994f, 
    -0.04801004f, -0.05221104f, 0.01219402f, -0.02836826f, -0.03239758f, -0.05998562f, -0.00435089f, 0.04391757f, 
    -0.12062864f, 0.17202593f, 0.15695021f, -0.01376639f, 0.64909869f, -0.13038066f, 0.16681732f, 0.21590604f, 
    -0.03075527f, 0.06648002f, 0.04744247f, -0.02230048f, -0.01369698f, 0.00811987f, 0.02982548f, -0.04101208f, 
    0.02626480f, -0.12034535f, -0.11801085f, -0.04163030f, -0.08167821f, 0.03138487f, -0.13264066f, -0.01676195f, 
    0.14075747f, 0.02247712f, -0.02203379f, 0.19068606f, 0.05418866f, 0.08752356f, 0.07636572f, 0.06228531f, 
    -0.08870876f, -0.05101239f, -0.03154281f, -0.02568064f, 0.06990437f, 0.05334534f, -0.10729285f, -0.14176171f, 
    -0.18701312f, 0.00847439f, 0.34025255f, -0.05761175f, 0.43962675f, 0.02200780f, 0.04134050f, 0.05268475f, 
    -0.06616586f, 0.11215719f, -0.04187252f, -0.08370754f, 0.06551244f, 0.11130484f, 0.14705583f, -0.08549178f, 
    0.01511849f, -0.04863520f, -0.04785771f, -0.06197288f, 0.33548033f, -0.14896743f, 0.15363942f, -0.09060242f, 
    0.26288515f, -0.09036219f, 0.20330690f, -0.24180366f, -0.05816171f, 0.02377196f, 0.12837760f, -0.02604291f, 
    0.01195262f, -0.03771216f, 0.04497115f, 0.08984037f, -0.08241161f, 0.10450817f, -0.05281864f, 0.00137137f, 
    0.02423821f, -0.06425419f, -0.10237265f, 0.18824215f, 0.02760633f, 0.10083475f, -0.05608668f, -0.22748724f, 
    -0.04399860f, 0.00762483f, 0.09340578f, 0.01741159f, -0.10020074f, -0.03807883f, -0.01208308f, -0.04933240f, 
    0.04828792f, -0.09567639f, -0.03045593f, 0.01709086f, 0.00076228f, -0.02937912f, 0.31816280f, 0.00135716f, 
    0.05836564f, 0.02585068f, 0.06909563f, -0.04548143f, 0.09668668f, 0.00675603f, 0.08046920f, -0.02869315f, 
    0.02075270f, 0.01207103f, -0.00511805f, 0.00927746f, -0.02002515f, 0.07043908f, -0.02115008f, -0.00562742f, 
    -0.07805336f, -0.04027532f, -0.25538266f, -0.24702029f, -0.11956356f, 0.07216199f, 0.02675060f, 0.04807219f, 
    0.06951480f, 0.03886238f, -0.11319786f, -0.09598032f, 0.05162932f, -0.02535241f, 0.07223792f, 0.01440264f, 
    0.10530285f, -0.11059981f, 0.02294320f, 0.01941523f, -0.13589674f, 0.20158014f, -0.02043311f, -0.24946602f, 
    0.12266345f, -0.10332482f, -0.04564066f, 0.03699187f, 0.01249289f, -0.02619755f, 0.13675621f, -0.02595014f, 
    -0.01051678f, 0.07556294f, -0.00129183f, 0.18372102f, 0.05437030f, 0.12443992f, -0.06661564f, -0.06722615f, 
    -0.20691743f, -0.23478580f, 0.05640902f, 0.07925449f, 0.18516496f, -0.01754490f, 0.14049405f, -0.13352798f, 
    0.09696816f, -0.02860003f, 0.02157314f, -0.08429423f, 0.00061627f, 0.04022891f, -0.09385730f, 0.01407570f, 
    0.02369508f, -0.22835450f, 0.05143155f, 0.10927125f, 0.01328756f, -0.08409512f, 0.34666088f, -0.01347390f, 
    0.01677682f, -0.06476970f, -0.08951646f, -0.11032470f, 0.13205852f, 0.02516309f, 0.04923295f, -0.01598942f, 
    0.02098058f, 0.00199493f, -0.01144404f, -0.00653266f, 0.11739972f, 0.04451314f, -0.06374814f, 0.02276748f, 
    -0.27812377f, -0.12285077f, 0.12064466f, 0.05241003f, 0.07448876f, 0.00322076f, -0.00907964f, -0.12669173f, 
    -0.11940399f, 0.00014971f, -0.09135183f, -0.03527093f, -0.03067422f, -0.10046655f, -0.06823788f, -0.04103169f, 
    0.07864895f, 0.13150385f, -0.02631658f, 0.02306537f, 0.11599609f, 0.01683784f, 0.14403744f, 0.01805387f, 
    0.33174360f, 0.00030686f, 0.15315339f, -0.04386325f, -0.18789087f, 0.04905736f, 0.03173868f, -0.09207597f, 
    0.03677504f, 0.05556763f, -0.21637353f, 0.03614350f, 0.00830987f, 0.11086603f, 0.01455717f, -0.00046991f, 
    0.45937845f, 0.22850214f, -0.22428754f, -0.16997807f, -0.08503727f, 0.17167386f, -0.03454414f, -0.19259946f, 
    -0.07378603f, 0.22504932f, 0.09058794f, -0.01944942f, 0.08423224f, -0.07566866f, -0.00022956f, -0.03978193f, 
    0.01073635f, 0.07037725f, -0.06414680f, 0.06701656f, 0.01012060f, -0.08974539f, 0.00332970f, -0.01156971f, 
    0.00186948f, -0.01112933f, -0.10497942f, 0.18325669f, 0.05723319f, 0.09463586f, 0.05755875f, 0.03352285f, 
    0.06499754f, -0.08479317f, 0.09568018f, -0.02197727f, -0.07051252f, 0.02649211f, -0.00686824f, -0.02905628f, 
    -0.08278963f, -0.02999975f, 0.06479106f, 0.10610192f, 0.14414753f, -0.07186578f, 0.13398893f, 0.02584323f, 
    -0.14142847f, -0.07203700f, 0.04313943f, -0.07598045f, 0.00760056f, 0.08208232f, 0.04421848f, -0.05254060f, 
    0.04452584f, 0.10552179f, -0.03641271f, 0.03460323f, 0.12715232f, -0.33106044f, -0.36059320f, -0.05395058f, 
    0.00346613f, 0.07660984f, -0.11770336f, -0.12415114f, 0.12069162f, -0.01557747f, -0.06717590f, -0.11113153f, 
    -0.00387354f, 0.14537394f, 0.08294789f, -0.04785882f, 0.22800839f, -0.08404002f, -0.00350907f, 0.03400400f, 
    -0.25159028f, 0.07422235f, -0.12522300f, -0.11631442f, -0.00706403f, -0.05426535f, 0.17997591f, -0.09798449f, 
    0.10734576f, 0.07761594f, 0.05122646f, -0.02349041f, -0.11588836f, 0.00117701f, -0.05444722f, 0.07140631f, 
    0.02378040f, -0.02730350f, 0.05158455f, 0.04600505f, -0.37010187f, -0.30502626f, -0.40168303f, -0.15169932f, 
    -0.15655504f, -0.04447464f, 0.03065619f, 0.08875578f, 0.13600422f, 0.20370772f, 0.03335669f, 0.08588481f, 
    -0.03237142f, -0.03869577f, -0.01820429f, 0.00917636f, 0.03441064f, 0.00380944f, -0.07657909f, 0.05774209f, 
    0.05853110f, 0.13053364f, 0.20328501f, 0.00035262f, -0.07453280f, -0.03295442f, 0.07704601f, 0.15033667f, 
    0.00679150f, -0.01016012f, 0.00573757f, -0.02881386f, -0.04063616f, -0.01640313f, 0.08493389f, 0.24630108f, 
    -0.03712252f, -0.17797695f, -0.04743651f, -0.00374807f, 0.23651755f, -0.20124805f, 0.45249972f, -0.00691221f, 
    0.07925931f, -0.06050165f, 0.25283203f, -0.09891370f, 0.14793135f, -0.01835950f, -0.13084288f, -0.02414736f, 
    -0.01208587f, 0.08373438f, -0.03927517f, -0.04754547f, 0.05778944f, -0.04214789f, 0.01857502f, 0.03625776f, 
    -0.26376149f, -0.06350671f, -0.02523761f, 0.05670994f, -0.15401337f, -0.21863215f, 0.01848221f, -0.00722951f, 
    0.05258378f, 0.04071902f, -0.13320759f, -0.03650333f, -0.04936721f, 0.07830172f, 0.04923622f, -0.02036147f, 
    0.07136214f, 0.08743768f, 0.10457177f, 0.16901274f, 0.33893758f, 0.16355425f, 0.38889930f, 0.24447668f, 
    0.15306614f, -0.00352998f, -0.08769221f, -0.03464154f, -0.03153703f, -0.06555891f, -0.03820791f, -0.05360165f, 
    -0.03723625f, -0.06941979f, -0.00851556f, 0.04032189f, -0.02860719f, 0.13964692f, -0.00643819f, -0.06440105f, 
    0.09455887f, -0.01764072f, 0.03653450f, -0.00798864f, -0.10712555f, -0.14545666f, -0.07756230f, -0.18186985f, 
    -0.15803127f, -0.19879362f, -0.08919858f, 0.22048764f, -0.06595822f, 0.08310015f, 0.05807579f, -0.10614753f, 
    -0.11709270f, -0.12355974f, -0.16587050f, -0.22139654f, 0.15289190f, 0.18176900f, 0.00312615f, 0.09411614f, 
    -0.03421007f, -0.06304492f, 0.02834155f, -0.01822353f, -0.01041555f, -0.00014478f, -0.04744091f, 0.04508609f, 
    -0.00524496f, 0.09665384f, 0.04944932f, 0.09647018f, 0.26219699f, 0.16735846f, 0.07244033f, -0.00491269f, 
    -0.12166466f, -0.12618390f, 0.06140969f, 0.03859675f, 0.05998136f, 0.18916009f, -0.14917740f, 0.00736332f, 
    0.05424396f, 0.05073258f, -0.02221435f, 0.04639482f, 0.05475907f, 0.16677879f, 0.12367190f, 0.08093614f, 
    0.07497114f, 0.15249388f, 0.09208555f, 0.00780322f, 0.37971470f, -0.08329786f, 0.20448223f, -0.13698448f, 
    -0.15046389f, -0.04860618f, -0.03338690f, -0.13513932f, -0.08389302f, -0.14796886f, -0.12502447f, -0.02048478f, 
    -0.09637763f, -0.07842897f, 0.04342311f, 0.00324729f, -0.02862539f, -0.22780043f, 0.01256491f, -0.00452825f, 
    0.10384820f, -0.04488929f, 0.04849749f, 0.27495956f, 0.09847438f, 0.13983203f, -0.08736178f, 0.08187924f, 
    0.06334207f, 0.00020097f, 0.07799523f, 0.07523927f, 0.07533456f, 0.03073256f, 0.09599439f, 0.01632995f, 
    -0.14552650f, -0.02274503f, -0.18728147f, -0.19086671f, 0.44625726f, -0.02692232f, -0.07871859f, 0.22200596f, 
    0.10080855f, 0.06581126f, 0.16205077f, 0.00813845f, 0.16939189f, 0.12146475f, 0.12294652f, -0.01144794f, 
    0.05483451f, 0.04538538f, 0.12268119f, 0.17701378f, -0.01365309f, 0.06956788f, 0.16720329f, -0.05139970f, 
    0.25134483f, -0.01675456f, 0.20567028f, -0.12165432f, 0.23396400f, 0.04300534f, 0.01201683f, 0.07211544f, 
    0.03152109f, -0.01979698f, -0.03436060f, -0.02873433f, 0.05252511f, -0.02130701f, -0.02296410f, 0.16748685f, 
    0.09216731f, 0.07512952f, 0.09846275f, -0.06626069f, -0.09424492f, -0.04178652f, -0.18104143f, -0.05373593f, 
    -0.17942831f, -0.08326921f, 0.03573982f, 0.06468103f, 0.00401647f, 0.08695465f, -0.00943535f, 0.09370617f, 
    0.05974493f, -0.07011892f, 0.00867352f, -0.00534387f, -0.00060139f, 0.08689313f, -0.05730672f, 0.02568552f, 
    -0.04365122f, 0.12672378f, -0.16743608f, 0.19689916f, 0.17387997f, 0.08532561f, -0.08996382f, -0.08373329f, 
    0.04621570f, -0.06111497f, 0.07511079f, -0.03444299f, 0.00702727f, 0.01577960f, 0.22019796f, 0.11428372f, 
    -0.02300204f, 0.20673700f, -0.06139842f, 0.05432824f, -0.17817214f, 0.17043115f, 0.13199914f, 0.06461065f, 
    0.20063701f, 0.11708619f, 0.05744266f, -0.01153751f, 0.06522331f, -0.00647367f, -0.00160349f, 0.11286259f, 
    -0.00232311f, -0.02603543f, 0.14379838f, 0.19859992f, -0.03361761f, -0.08032835f, 0.15911576f, -0.18265176f, 
    0.21039745f, 0.41657603f, 0.24681348f, 0.29309550f, 0.31441090f, 0.20003517f, 0.19427739f, 0.17746751f, 
    0.05335497f, 0.21146555f, -0.08104961f, -0.09119139f, -0.11580045f, -0.16282533f, -0.12890789f, -0.07901099f, 
    0.00885296f, 0.02831913f, -0.05551672f, 0.05808841f, -0.14000499f, 0.27619952f, 0.30850440f, 0.24492489f, 
    0.38684466f, 0.01742223f, 0.21016943f, 0.20467314f, 0.13012917f, -0.08724787f, -0.13458507f, -0.17855358f, 
    -0.01002043f, -0.01924014f, -0.06110446f, -0.02328526f, 0.02220299f, 0.07555988f, 0.02267187f, 0.09579211f, 
    0.24680321f, 0.20722865f, 0.31625640f, 0.08037212f, -0.07750168f, -0.01418636f, 0.01842535f, 0.13905668f, 
    -0.26976696f, -0.27364510f, -0.00940385f, -0.05527988f, -0.06844605f, -0.00942424f, 0.22925359f, -0.05368189f, 
    -0.02877456f, -0.06701494f, -0.10686802f, -0.09209198f, -0.35050169f, -0.41394484f, 0.01980732f, -0.06735031f, 
    -0.09083186f, -0.01133676f, -0.16657159f, -0.00904522f, -0.26264387f, 0.08869364f, -0.08218727f, 0.04122028f, 
    0.01713371f, 0.17605287f, -0.02799443f, -0.16635649f, -0.02537732f, 0.11674315f, -0.08640730f, -0.23834816f, 
    0.29969233f, 0.35982338f, 0.21992354f, -0.07226918f, 0.04418986f, -0.01027264f, 0.15549795f, 0.00957329f, 
    0.19607921f, 0.13827130f, 0.16076811f, 0.07617101f, -0.03354869f, 0.09023196f, 0.01718932f, 0.06215876f, 
    -0.07553159f, -0.03780565f, 0.25984061f, 0.43057987f, -0.33873260f, -0.12785605f, -0.20137367f, -0.12441560f, 
    -0.08188898f, -0.05816573f, -0.08580367f, -0.04051637f, 0.01578906f, 0.18005449f, 0.07846311f, 0.00976813f, 
    0.01758002f, 0.11946076f, 0.07027484f, -0.03495484f, -0.01390324f, 0.10819191f, -0.07454045f, -0.21883500f, 
    -0.06135037f, -0.31847250f, -0.23024195f, 0.00676186f, 0.03580112f, 0.07083526f, 0.06126022f, 0.06816879f, 
    0.10343421f, 0.13804281f, -0.08337866f, 0.00182917f, -0.06694148f, -0.04662585f, 0.00921419f, -0.07054488f, 
    -0.00834541f, 0.05215286f, 0.07502968f, 0.03502570f, -0.15532079f, -0.16582137f, -0.21512172f, -0.14568041f, 
    0.00204028f, 0.02184053f, -0.13604471f, -0.07337187f, -0.00429608f, -0.05590700f, -0.01271342f, 0.06102683f, 
    0.11603420f, 0.00654848f, 0.10764696f, 0.00349002f, 0.04228546f, -0.23842353f, 0.07741077f, 0.00505037f, 
    0.00185205f, 0.20281428f, 0.30373055f, 0.20514907f, -0.27930981f, 0.11581714f, 0.08430967f, 0.00646682f, 
    -0.01696678f, 0.25108472f, -0.06476840f, 0.01179627f, 0.02462037f, 0.07171723f, 0.00715768f, -0.05670019f, 
    -0.03077947f, 0.00095191f, -0.09110388f, -0.01643148f, -0.38029668f, -0.33743882f, -0.21117936f, 0.10347353f, 
    0.05040810f, -0.03193852f, -0.19706795f, -0.10543559f, 0.03918952f, 0.11321207f, 0.04660778f, 0.03325688f, 
    -0.01047883f, 0.03542197f, 0.03618382f, -0.04622580f, -0.04493215f, -0.00761861f, -0.00348056f, 0.07971113f, 
    0.35844740f, 0.14853002f, 0.16437288f, 0.04603683f, 0.17269282f, 0.12573543f, -0.18666692f, -0.02446332f, 
    0.01817078f, 0.11160855f, 0.06669205f, -0.03707309f, 0.06634866f, -0.16709456f, -0.02887775f, -0.28391236f, 
    -0.08003938f, -0.04067035f, -0.02286523f, 0.05148766f, 0.26454875f, 0.26896766f, 0.20652649f, 0.16238841f, 
    -0.12008820f, 0.04129464f, 0.02263344f, -0.02223003f, 0.09710533f, -0.03201685f, -0.07520054f, -0.16087794f, 
    0.08553047f, -0.07609168f, -0.02730441f, 0.02825056f, 0.03319923f, -0.10904974f, 0.15411350f, -0.03544994f, 
    -0.40999165f, -0.44785088f, 0.18139270f, -0.10455833f, 0.00508004f, -0.21175081f, -0.17890893f, 0.17328149f, 
    0.03804170f, 0.19008955f, 0.12281255f, -0.00781394f, -0.01848812f, 0.11012852f, -0.06413729f, -0.01128079f, 
    -0.03998817f, 0.19116360f, -0.09111355f, 0.01173517f, -0.01711082f, -0.10488702f, -0.03411302f, 0.04556362f, 
    0.10546175f, 0.12902614f, 0.02747623f, 0.07338264f, 0.04187971f, 0.14773029f, -0.12929414f, 0.01952882f, 
    -0.11910170f, -0.13565008f, -0.11458112f, -0.01169831f, -0.04438759f, 0.00444653f, 0.02874830f, 0.01997511f, 
    -0.00132263f, 0.25682184f, 0.19712871f, 0.06471753f, -0.01807250f, 0.27714089f, 0.05885101f, -0.00223353f, 
    0.05323933f, 0.15431097f, 0.00393734f, -0.07324395f, -0.01170427f, -0.05259975f, -0.00567544f, -0.06409246f, 
    -0.03292945f, -0.03017008f, 0.10260393f, 0.05525718f, -0.27824679f, 0.33841217f, 0.35672116f, 0.30375546f, 
    0.03183556f, -0.08155490f, -0.09960309f, -0.10901663f, -0.32653940f, -0.08006464f, -0.02649818f, 0.01109481f, 
    0.05336902f, -0.13285339f, -0.11898318f, 0.02412325f, -0.12640122f, -0.02635143f, 0.04462935f, 0.17249390f, 
    -0.05339365f, -0.04974047f, 0.03037214f, 0.03971587f, -0.01864766f, -0.00143894f, -0.05273006f, -0.04018016f, 
    -0.01756716f, -0.04156847f, 0.01149451f, 0.03035733f, -0.02394008f, -0.03183485f, -0.00903464f, -0.01692625f, 
    0.00284219f, 0.00669831f, 0.03346713f, 0.04836399f, 0.01896749f, -0.03293124f, 0.00716852f, 0.04272972f, 
    0.03088975f, 0.01353700f, -0.05449554f, -0.03025420f, 0.04760654f, 0.03182322f, -0.02812676f, 0.00946743f, 
    -0.05155255f, -0.05208848f, -0.04022525f, 0.01363562f, 0.04501208f, -0.01008775f, -0.00487376f, 0.00005811f, 
    0.01075692f, -0.05515935f, -0.04360295f, -0.00184214f, -0.02015513f, 0.03618939f, -0.02598153f, 0.04239529f, 
    0.04710396f, 0.04293164f, 0.05079445f, -0.05236724f, 0.03649521f, -0.00484846f, 0.01770426f, -0.03516052f, 
    -0.04060170f, 0.04266225f, -0.02952266f, 0.02297363f, 0.01405280f, 0.00933235f, 0.03901944f, -0.04160723f, 
    0.02312288f, -0.05771952f, 0.01291067f, 0.01976067f, 0.01269647f, 0.05364074f, -0.01932352f, -0.02160361f, 
    0.01774994f, 0.02371670f, -0.03366375f, -0.00731730f, -0.05921672f, -0.01242408f, -0.04378782f, 0.02856131f, 
    0.02756920f, -0.03517256f, -0.02451337f, 0.02779582f, -0.02518615f, -0.01740348f, -0.00535035f, -0.02355925f, 
    0.03508721f, -0.05071664f, 0.05039556f, -0.03265054f, 0.04946274f, 0.01418725f, -0.03862655f, 0.03004445f, 
    -0.04937765f, 0.03493628f, 0.03085733f, -0.05343467f, -0.00140057f, 0.01966331f, -0.00577099f, -0.05687241f, 
    -0.02288134f, -0.02536755f, -0.05409811f, -0.03458394f, -0.05039379f, 0.00371429f, -0.03237732f, 0.02473468f, 
    -0.00887548f, -0.02746671f, 0.00974318f, -0.02670523f, 0.03783104f, 0.00734555f, -0.01163402f, 0.03053895f, 
    -0.04724049f, -0.01692860f, 0.00333540f, 0.03749754f, 0.02209401f, -0.02844345f, -0.01784868f, 0.04611626f, 
    -0.03318697f, -0.02561134f, -0.02634330f, -0.03452365f, -0.00443402f, -0.01681776f, 0.02375956f, -0.04786731f, 
    -0.05303606f, -0.01300529f, 0.05400670f, 0.01856236f, -0.00870257f, -0.03928159f, 0.03621234f, -0.02029711f, 
    -0.01539191f, -0.05292512f, -0.04465026f, -0.04318096f, -0.04712484f, 0.05038046f, 0.01516840f, 0.03500622f, 
    -0.04331793f, -0.05557725f, -0.00988967f, -0.05405302f, -0.00737971f, -0.02622861f, 0.03320519f, -0.05568951f, 
    -0.02570496f, -0.01227158f, 0.00175033f, -0.04239623f, -0.01617283f, -0.01652933f, 0.05029991f, 0.01144319f, 
    0.04116997f, 0.03576152f, 0.04973885f, -0.02429951f, 0.05050652f, -0.04974292f, 0.00962171f, -0.05794378f, 
    -0.02048046f, -0.00706808f, 0.04240720f, 0.03500579f, -0.02227810f, 0.03026021f, 0.05164183f, -0.05005803f, 
    0.03400956f, -0.03875822f, -0.04080323f, 0.03696655f, 0.00200170f, -0.02672889f, 0.04168467f, 0.04372946f, 
    -0.01549712f, -0.04870181f, -0.03615744f, -0.01331017f, 0.01579279f, 0.00787515f, 0.05114249f, 0.04717479f, 
    -0.00535985f, -0.03872528f, -0.02692227f, -0.05360641f, -0.00376722f, 0.02584143f, 0.01212455f, -0.02992967f, 
    -0.01881384f, -0.02088082f, -0.03342229f, -0.04458829f, 0.00001069f, -0.05418723f, -0.01015157f, 0.04350661f, 
    -0.06148866f, 0.03197731f, 0.05026136f, 0.03338630f, 0.04991087f, -0.03172226f, 0.02164878f, -0.01956638f, 
    0.04414903f, 0.03865033f, -0.05134993f, 0.05127593f, -0.00943954f, 0.02221806f, 0.01057652f, -0.01685729f, 
    -0.04064271f, 0.03101639f, 0.02089199f, -0.04117271f, 0.00662690f, 0.03751208f, -0.05619400f, 0.02190720f, 
    0.03856711f, -0.01042030f, -0.03923296f, -0.03300900f, -0.05850076f, 0.00041391f, 0.02556396f, -0.04997739f, 
    0.04736759f, 0.00147615f, 0.01846832f, -0.01413280f, -0.05275545f, -0.05310482f, 0.03592367f, 0.00491169f, 
    -0.02754489f, -0.01340924f, 0.00786394f, 0.04945435f, 0.01549962f, -0.01622055f, -0.02163756f, -0.02018525f, 
    0.01407105f, 0.00747197f, -0.02630067f, -0.04228086f, -0.05075650f, -0.02295995f, -0.06039928f, -0.03743338f, 
    -0.00210454f, -0.04137117f, -0.03831260f, -0.00649432f, 0.02332169f, -0.01862088f, -0.03360246f, -0.02380180f, 
    -0.00006639f, 0.00743162f, -0.03294904f, -0.05120477f, 0.00102654f, -0.04841875f, -0.03072239f, -0.01221908f, 
    -0.03686679f, 0.00728083f, -0.04226415f, -0.01850224f, -0.06010489f, 0.04071209f, -0.02611813f, -0.01813530f, 
    0.05006658f, -0.01129865f, 0.04927361f, 0.00834102f, -0.02743152f, -0.04381432f, 0.03907099f, -0.02904984f, 
    0.00967185f, -0.00289954f, -0.05498760f, -0.00509724f, 0.02818936f, 0.04179585f, -0.05681210f, -0.05674322f, 
    -0.02839594f, -0.01562171f, 0.00727532f, -0.04112232f, 0.02938683f, -0.00286183f, -0.01222798f, -0.00067377f, 
    -0.01126048f, 0.33740151f, 0.11478794f, 0.09643289f, -0.00159722f, 0.06102112f, -0.02317963f, -0.05326382f, 
    0.05498090f, -0.06962574f, -0.04232865f, 0.05991567f, -0.03020520f, 0.05889771f, 0.00727315f, -0.02385309f, 
    -0.08428407f, -0.03584712f, -0.14240684f, 0.00703169f, -0.15492752f, -0.19095503f, -0.14065874f, 0.08470414f, 
    0.07809693f, 0.07578287f, 0.10523341f, -0.08603749f, 0.06171481f, 0.03130204f, 0.06362773f, 0.15371986f, 
    0.12916380f, 0.15703695f, 0.09879787f, 0.11180841f, 0.08046507f, 0.18113330f, -0.06411894f, 0.13477829f, 
    0.19648008f, 0.50745744f, 0.28549460f, 0.23472764f, 0.04824847f, 0.11186922f, -0.06763139f, -0.01163393f, 
    -0.01657185f, 0.01294015f, -0.01306369f, 0.01407404f, -0.08572137f, 0.01581557f, 0.13651130f, 0.04021620f, 
    -0.21984735f, -0.02139287f, -0.10169638f, -0.19764154f, -0.29687026f, -0.02150831f, 0.29630047f, 0.11043874f, 
    0.20215091f, -0.08660056f, -0.01183912f, -0.15029180f, -0.32037568f, 0.05289565f, -0.05436064f, 0.01939081f, 
    0.03404732f, 0.14136589f, 0.12629500f, 0.05493773f, -0.00279067f, 0.16685523f, 0.10146357f, 0.00573239f, 
    -0.10329618f, -0.19038314f, -0.16522199f, -0.20538588f, 0.03532220f, 0.21431138f, 0.13013516f, 0.21691817f, 
    0.20923787f, -0.00047744f, 0.02969137f, -0.15894723f, -0.10599676f, 0.10554627f, -0.07726482f, 0.19828372f, 
    0.00813728f, 0.01009706f, 0.07972857f, 0.27909768f, -0.03549165f, -0.28524753f, 0.03893331f, 0.03347031f, 
    0.21652694f, -0.10491988f, -0.09463251f, -0.12372937f, -0.09343628f, 0.01594527f, 0.04150539f, 0.04595907f, 
    -0.05399335f, -0.03819072f, -0.07234563f, -0.00912624f, -0.05641954f, 0.20968740f, 0.02422759f, -0.00189937f, 
    -0.11071660f, -0.49700361f, -0.36525273f, -0.08226682f, -0.27011237f, -0.00202630f, -0.10319612f, -0.17093804f, 
    -0.12484862f, -0.21141276f, 0.00890638f, 0.14325134f, -0.01128564f, -0.03302806f, 0.08425519f, 0.13736729f, 
    0.19232340f, -0.00791631f, 0.04307058f, -0.14651968f, -0.15661788f, -0.15253498f, -0.03739025f, -0.16406278f, 
    0.00155401f, -0.04257007f, -0.21664941f, -0.06793742f, -0.07348081f, 0.06710509f, 0.05762713f, -0.00614835f, 
    0.10332984f, 0.04341375f, -0.00417043f, 0.03240532f, 0.13624454f, 0.16831470f, 0.16853493f, 0.12922311f, 
    0.07995867f, 0.04936967f, -0.00509792f, 0.18673553f, 0.18291190f, 0.03831080f, 0.10841514f, 0.06533241f, 
    -0.10884777f, 0.14027373f, -0.00327369f, -0.00191424f, -0.06090403f, 0.17384608f, 0.00724575f, 0.01546816f, 
    -0.09872021f, -0.15353417f, -0.07676225f, 0.03365712f, -0.07973290f, -0.35307312f, 0.25814012f, -0.04406842f, 
    0.05398681f, -0.15119149f, -0.19015221f, -0.12071469f, 0.08630645f, -0.02965358f, -0.07230691f, -0.01824557f, 
    -0.09988765f, -0.06750017f, -0.04112525f, -0.12587528f, -0.18182966f, -0.05372273f, 0.01668370f, -0.04579772f, 
    -0.26640725f, 0.20176974f, 0.18757501f, 0.26831791f, -0.10427432f, 0.06860430f, -0.02475909f, 0.01131697f, 
    0.03208198f, 0.05597246f, 0.05561799f, 0.00752732f, 0.08739451f, -0.24719922f, 0.12929930f, 0.02786222f, 
    -0.13362631f, 0.04399667f, -0.22991261f, -0.16172889f, 0.01491890f, 0.34813425f, -0.14366572f, 0.27046457f, 
    0.03616929f, 0.02509554f, 0.08149178f, 0.05305729f, -0.01328541f, 0.26758268f, 0.06807561f, 0.01136833f, 
    -0.01724507f, -0.06289648f, 0.01975479f, 0.08274920f, -0.01627944f, -0.10061710f, 0.06772891f, 0.16593945f, 
    -0.00232046f, -0.17728814f, -0.13484883f, -0.10532082f, -0.20461191f, 0.14814332f, -0.16481896f, -0.05318403f, 
    -0.17593063f, 0.07097199f, 0.04916634f, 0.05212161f, -0.09718524f, 0.00884980f, 0.05218748f, 0.09088250f, 
    0.06300566f, 0.40176183f, 0.11493006f, 0.07588360f, -0.04433924f, -0.02789319f, 0.02384667f, -0.11121862f, 
    -0.09434888f, 0.23131941f, -0.00591881f, -0.10392404f, 0.10864679f, -0.06749407f, -0.04989524f, 0.12768875f, 
    0.05874464f, 0.13370164f, 0.13784367f, 0.01014364f, -0.06134628f, -0.11177235f, 0.16807570f, -0.02195863f, 
    -0.07513177f, 0.24654864f, 0.03963057f, 0.24293576f, 0.05367400f, 0.10078512f, 0.07593838f, -0.04096415f, 
    0.13459095f, 0.19671276f, -0.08632849f, 0.00360587f, -0.02397906f, 0.05858611f, 0.08710539f, 0.06053710f, 
    -0.07579810f, -0.04092574f, -0.00801545f, 0.04189519f, 0.20374346f, 0.18724386f, -0.05025986f, 0.11263505f, 
    0.00303052f, 0.10099457f, 0.14149083f, 0.02793739f, -0.05991334f, 0.00474233f, -0.06877337f, -0.03715308f, 
    -0.02233113f, -0.05127981f, -0.09177092f, 0.02959974f, -0.08328458f, 0.14934723f, 0.01923818f, 0.15236425f, 
    -0.14003345f, -0.13540459f, -0.20618412f, -0.00462063f, -0.21043761f, 0.23869680f, 0.07947809f, 0.25842708f, 
    0.00367177f, 0.07670216f, 0.07785065f, -0.02170780f, 0.02049941f, 0.03225238f, 0.00327472f, -0.00890086f, 
    -0.06379618f, -0.02608849f, -0.15169984f, -0.01430398f, 0.09531844f, -0.33663735f, -0.31048670f, 0.01932566f, 
    -0.18533057f, 0.12409098f, -0.04597360f, -0.06314180f, 0.05537557f, 0.00124573f, 0.25008976f, -0.00465903f, 
    0.02758187f, -0.03373294f, -0.03868764f, -0.05046457f, 0.01552538f, 0.05434046f, -0.01219763f, 0.02302130f, 
    -0.09223562f, 0.14518678f, -0.01924907f, 0.12258960f, -0.02587377f, 0.15465295f, 0.01021451f, -0.08353731f, 
    -0.11268424f, -0.06365412f, 0.02264032f, -0.08504187f, 0.07146187f, 0.06641939f, 0.09232512f, 0.09582362f, 
    -0.03824647f, 0.03770995f, -0.01252898f, -0.00526224f, 0.14360128f, 0.24762680f, -0.03717578f, 0.18722625f, 
    0.04163065f, 0.12991604f, 0.22446395f, -0.17485808f, -0.05280411f, 0.02363544f, -0.03596361f, -0.05412774f, 
    -0.00876142f, -0.04196065f, -0.00827823f, 0.15253720f, 0.10197040f, -0.00469683f, 0.05043062f, 0.06646056f, 
    0.12972939f, -0.07130894f, 0.04880589f, 0.06381506f, -0.02211350f, -0.20240451f, -0.18690896f, -0.11950841f, 
    0.07848454f, -0.24073942f, 0.03668091f, 0.05074275f, -0.12754649f, -0.12119731f, -0.10641216f, -0.01107016f, 
    0.07295196f, 0.00931246f, 0.00276938f, 0.07914078f, 0.10369752f, -0.06342196f, 0.19176491f, 0.09233529f, 
    -0.04939216f, 0.11056944f, 0.02922582f, 0.04425881f, -0.00421001f, -0.02550953f, -0.01666184f, -0.08002027f, 
    -0.06543890f, -0.01819596f, -0.10255370f, 0.00621357f, 0.00209174f, 0.11407875f, 0.00070260f, -0.10362557f, 
    -0.39846957f, -0.08504545f, -0.17361577f, -0.10232148f, 0.03218842f, -0.13223496f, -0.05468667f, -0.08882495f, 
    -0.12841493f, -0.22147089f, 0.25108686f, 0.16762160f, 0.03050115f, 0.25450978f, 0.18271889f, 0.05476073f, 
    0.09396073f, 0.05746161f, 0.04229039f, -0.03120929f, -0.02021824f, 0.01956982f, 0.04853249f, -0.00466303f, 
    -0.00659907f, -0.09242445f, 0.07075810f, 0.00054034f, -0.07556318f, -0.04748668f, -0.03293314f, -0.02572933f, 
    -0.03900003f, -0.12558855f, 0.06458952f, 0.15006045f, 0.08943145f, 0.05689254f, -0.01454140f, 0.01108602f, 
    0.15772390f, -0.07321617f, -0.03061353f, -0.09249277f, -0.03937056f, 0.01678788f, -0.12847091f, -0.10853034f, 
    0.04964451f, 0.02735511f, -0.01861389f, 0.02832378f, 0.08594489f, 0.07975738f, 0.06494951f, 0.02223951f, 
    0.11027228f, 0.01852763f, 0.09025616f, -0.04050905f, -0.19955267f, 0.13442962f, 0.41324267f, 0.05968332f, 
    -0.19679253f, 0.21771844f, -0.06843036f, -0.00659586f, 0.04512831f, -0.02374829f, -0.09993998f, -0.04616283f, 
    -0.01539035f, -0.02494123f, -0.09900644f, -0.13643315f, -0.05383207f, 0.09995350f, -0.11361883f, -0.12713362f, 
    -0.11076996f, -0.08025902f, 0.21740502f, 0.07505563f, -0.24882175f, 0.01081205f, -0.10246131f, -0.10317577f, 
    0.22270085f, 0.00657327f, 0.11994720f, -0.01246545f, 0.02016639f, -0.07363739f, 0.09587857f, 0.12110244f, 
    0.13059059f, 0.04469016f, -0.13114494f, -0.16985513f, 0.06472037f, -0.15380812f, -0.00706969f, 0.05722124f, 
    0.07592828f, 0.12687802f, 0.00707968f, 0.02660133f, -0.09000300f, 0.37795496f, 0.09676177f, 0.09693914f, 
    0.02962930f, -0.10830904f, -0.01720664f, 0.21302533f, -0.02362903f, 0.13522966f, 0.07186531f, 0.20307519f, 
    0.19982253f, 0.29888213f, -0.42648110f, 0.34350356f, -0.10853124f, 0.25360420f, -0.03479591f, -0.10064486f, 
    -0.13853787f, 0.03287227f, 0.08753721f, 0.05097086f, -0.08121222f, -0.10291211f, 0.01537855f, -0.13743697f, 
    0.12242042f, 0.15236819f, 0.03523855f, -0.00584326f, -0.22090852f, -0.11796647f, -0.16144532f, 0.01999133f, 
    -0.12914427f, -0.08264869f, -0.00911476f, -0.04751617f, 0.11338092f, -0.11890291f, 0.25027180f, 0.13801806f, 
    0.09051353f, 0.07278680f, 0.05246246f, -0.06022499f, 0.03335306f, 0.01428939f, 0.09312224f, 0.06519740f, 
    0.14687920f, -0.12246203f, 0.13653941f, 0.00731799f, -0.05714105f, 0.09019154f, -0.09612127f, 0.13388503f, 
    0.16316077f, 0.07459491f, 0.06927801f, 0.00003610f, 0.05043890f, 0.00135451f, -0.00310453f, 0.11304604f, 
    0.05263399f, 0.15889642f, 0.02221830f, 0.06792195f, -0.22998089f, 0.05863193f, -0.13165008f, -0.14674151f, 
    -0.08811218f, 0.34237960f, -0.10803548f, -0.01050687f, 0.06991845f, -0.06218231f, 0.04771340f, -0.06475681f, 
    0.07143256f, -0.04541041f, 0.00889032f, 0.05695519f, 0.01991788f, 0.01195136f, -0.02531054f, 0.01033943f, 
    0.02689412f, -0.00493495f, 0.23589393f, 0.27534482f, -0.40693855f, 0.10545251f, -0.04239091f, -0.04180311f, 
    0.04462311f, -0.00526153f, -0.02757723f, -0.13611534f, -0.03910510f, 0.04611871f, 0.02489989f, -0.06337389f, 
    0.02606167f, 0.02238466f, -0.05748679f, -0.05324823f, 0.24044994f, 0.06159502f, 0.22896738f, 0.27215359f, 
    -0.24597915f, -0.04469015f, 0.02872752f, -0.06337706f, -0.12484892f, 0.04296261f, 0.13418630f, -0.05482621f, 
    0.12250664f, 0.01539811f, -0.01026505f, 0.06752232f, 0.05439370f, 0.00573241f, -0.08630943f, -0.03805769f, 
    -0.11906888f, 0.11877456f, 0.00655985f, 0.13556576f, -0.30149752f, 0.07333186f, 0.02657275f, 0.06246206f, 
    0.04867412f, -0.01025465f, 0.00295675f, -0.08339874f, -0.12368958f, 0.01716978f, 0.08279248f, 0.05165284f, 
    -0.01632262f, 0.10182939f, -0.04762942f, -0.06876703f, -0.21343602f, -0.16104892f, -0.42508867f, -0.08439658f, 
    -0.18932138f, 0.02767985f, -0.02407136f, -0.06590985f, -0.21775360f, 0.15197439f, 0.01082917f, 0.01819785f, 
    0.02743146f, 0.02821891f, -0.00934640f, 0.18381478f, 0.05414648f, -0.00239806f, 0.01596497f, -0.04324760f, 
    0.22977199f, 0.48597157f, 0.35276946f, 0.18570776f, -0.04121352f, 0.11079005f, 0.07040724f, 0.27820957f, 
    -0.02186185f, 0.20880763f, 0.00281978f, 0.02380381f, -0.07753245f, -0.02553135f, -0.17304470f, 0.02518427f, 
    -0.06365864f, -0.13993743f, -0.04122854f, -0.12278435f, 0.13168392f, -0.01654267f, -0.52354646f, 0.12509799f, 
    0.08715765f, -0.10541137f, -0.03339465f, 0.04619726f, -0.03773836f, 0.08045653f, -0.03836488f, -0.00305538f, 
    -0.00222770f, -0.10900906f, -0.01517876f, -0.00691458f, 0.04688470f, 0.02250818f, 0.06719711f, 0.09567863f, 
    -0.03212656f, -0.28160581f, -0.19695851f, -0.02284477f, 0.04530911f, -0.05113588f, -0.00929384f, 0.01302204f, 
    -0.12602805f, -0.03875460f, 0.19402960f, 0.10300276f, -0.00306178f, 0.04061814f, 0.03295522f, 0.10055882f, 
    0.19794495f, 0.15681262f, 0.03601392f, -0.00741635f, -0.03023839f, -0.26150107f, -0.30710953f, -0.09456668f, 
    0.10744318f, 0.07554635f, 0.08278896f, 0.03460050f, -0.02072448f, -0.03655782f, -0.00684099f, -0.05500242f, 
    0.11820555f, -0.02538584f, -0.00634336f, 0.10916437f, -0.09034815f, 0.00505929f, 0.09867825f, 0.08315529f, 
    0.16343965f, 0.40952504f, 0.33332863f, 0.16056125f, -0.14237052f, -0.00862481f, -0.08801664f, -0.00178559f, 
    -0.06178096f, 0.26624227f, -0.02093786f, 0.06843029f, -0.07384461f, 0.02584069f, -0.02018722f, -0.05736005f, 
    0.04904377f, -0.02327049f, 0.01647388f, 0.01286449f, -0.02602028f, 0.08994201f, -0.48962098f, 0.38679805f, 
    0.04982701f, 0.00508665f, -0.05300713f, 0.03428265f, 0.12566642f, 0.12721793f, 0.03834835f, 0.00396880f, 
    -0.11579575f, -0.04259801f, -0.13159880f, -0.07304787f, -0.06431911f, 0.10941704f, 0.00404980f, 0.00186266f, 
    0.04160995f, -0.15845098f, 0.15089765f, 0.02379277f, -0.15467028f, 0.12444166f, -0.03230610f, 0.00937972f, 
    0.01863325f, 0.09626631f, 0.01627832f, -0.00161205f, 0.02744667f, -0.12212512f, -0.06273935f, 0.04373792f, 
    0.14713834f, -0.09010270f, -0.02054542f, 0.06647406f, 0.30850503f, 0.09502283f, 0.43912545f, -0.30207062f, 
    -0.13238388f, 0.09466548f, -0.01756765f, 0.05715136f, 0.00343807f, 0.11946960f, -0.09058373f, -0.06489962f, 
    -0.05206337f, -0.07903324f, 0.00761836f, 0.02801134f, -0.00545660f, -0.01061593f, 0.07802079f, 0.10662667f, 
    -0.65857464f, -0.30612060f, -0.10622273f, 0.10575470f, -0.03634886f, 0.12272712f, -0.02314323f, -0.00142256f, 
    -0.02615846f, -0.05265931f, 0.17405812f, 0.04469307f, -0.06594646f, 0.03007773f, 0.08318351f, 0.06019042f, 
    -0.00530901f, 0.10929010f, -0.02924060f, 0.10100199f, -0.02234113f, -0.25912553f, -0.10592525f, 0.14753287f, 
    -0.05657133f, -0.07286374f, -0.00527418f, -0.13937350f, -0.15703887f, -0.05739468f, 0.07967677f, 0.00701795f, 
    0.02213122f, 0.17861500f, 0.08170550f, 0.10499440f, 0.04289328f, 0.10677895f, -0.06292705f, -0.01440277f, 
    0.21344350f, 0.16411768f, 0.46897787f, 0.08755860f, -0.05577857f, 0.04310389f, 0.02436519f, 0.05293076f, 
    0.16050006f, 0.09960563f, -0.06317402f, -0.02993356f, 0.00309689f, -0.06016271f, -0.02258299f, 0.02684833f, 
    0.05135332f, -0.19166011f, 0.00711728f, 0.10482516f, -0.39011022f, 0.02810189f, 0.16512793f, 0.20825088f, 
    -0.18835683f, 0.08887524f, 0.02267268f, 0.00927715f, -0.07479788f, -0.03446257f, 0.04264165f, -0.00026677f, 
    -0.03640593f, -0.00854647f, -0.04355915f, 0.05585884f, -0.05039508f, 0.16093177f, -0.00450025f, 0.00559434f, 
    0.25035450f, 0.05271167f, -0.19794545f, -0.23869498f, 0.46960166f, 0.03412735f, 0.08981074f, 0.29721674f, 
    -0.07802574f, 0.11332132f, 0.00695595f, 0.02949915f, 0.05946429f, 0.05603299f, 0.04412002f, -0.00508106f, 
    0.09713911f, 0.08286817f, -0.14316642f, 0.03661278f, 0.15624946f, -0.24769768f, -0.34296566f, -0.37252900f, 
    0.17194742f, 0.08751930f, 0.00455523f, 0.07438732f, 0.04761806f, -0.05442625f, -0.00221125f, -0.03775708f, 
    0.04141095f, -0.05097112f, -0.01644023f, -0.03075476f, 0.06446308f, 0.11083494f, -0.06279647f, -0.05800183f, 
    0.04185496f, 0.09971105f, -0.06012620f, -0.09356268f, 0.27464524f, 0.02613249f, -0.01142020f, 0.00925055f, 
    -0.08028107f, 0.05342428f, -0.00773682f, 0.03542807f, 0.01084773f, -0.03737127f, 0.11153931f, -0.11856653f, 
    -0.00524726f, 0.11429084f, 0.00731292f, -0.12838480f, 0.12747617f, -0.09563474f, 0.13048683f, 0.29215991f, 
    0.07359926f, -0.06925199f, 0.07680061f, -0.34800544f, -0.17764172f, 0.01707044f, 0.03041683f, -0.07148356f, 
    -0.01439972f, -0.01675606f, 0.11324272f, -0.00301818f, -0.06698506f, 0.09198594f, -0.08702979f, -0.09294491f, 
    0.40318739f, 0.15804653f, -0.09795614f, -0.31418651f, -0.27715805f, 0.31871539f, 0.10960037f, -0.17873642f, 
    0.03914104f, 0.03105383f, 0.05813948f, 0.09681164f, 0.03570263f, 0.05294850f, 0.06147575f, -0.03763450f, 
    -0.04150358f, -0.07585864f, 0.00708750f, 0.29427069f, -0.16141166f, -0.00498422f, 0.44294608f, 0.01860033f, 
    0.00192354f, -0.04014023f, -0.06271078f, -0.07491970f, 0.03026649f, 0.02654754f, 0.06856461f, 0.01029570f, 
    0.01762308f, -0.06477214f, 0.01772550f, -0.06671692f, 0.02307142f, 0.14519927f, 0.01936540f, -0.14663552f, 
    -0.07398073f, -0.07302502f, -0.25660011f, -0.17825769f, -0.14306389f, -0.04651248f, -0.04996394f, -0.07444759f, 
    0.04280752f, 0.06941295f, -0.11829762f, 0.03870957f, 0.07277787f, 0.13146734f, 0.14628540f, -0.22396071f, 
    0.03316492f, 0.00348853f, -0.18451755f, -0.09539418f, -0.48146957f, 0.11867091f, 0.05682338f, 0.01217238f, 
    0.16205035f, -0.01331353f, -0.15717576f, -0.20226713f, -0.09864698f, 0.09244167f, 0.17489934f, 0.01583799f, 
    0.04183153f, -0.07535854f, 0.08702384f, 0.02479977f, 0.03666887f, 0.05182402f, 0.04743538f, 0.02841431f, 
    0.16452962f, 0.02919390f, 0.11392274f, -0.02098918f, 0.01268754f, 0.04969125f, 0.20981048f, -0.03240122f, 
    0.11164269f, 0.03704668f, 0.02720129f, -0.12467173f, 0.08010577f, 0.14114033f, 0.00018975f, 0.05601997f, 
    0.07498348f, -0.03697902f, -0.00709722f, -0.07208866f, -0.28254271f, 0.11086190f, 0.74596822f, 0.10947818f, 
    0.02196627f, 0.03649367f, -0.00111225f, -0.16554162f, 0.17794152f, 0.00892524f, 0.04448211f, -0.06881900f, 
    0.05396452f, -0.05006281f, 0.11384369f, 0.05046106f, 0.12630990f, 0.17619422f, -0.07802229f, 0.04042102f, 
    0.18168506f, 0.25499576f, 0.26176426f, -0.27696297f, -0.08545848f, 0.02657001f, -0.01719775f, 0.10631144f, 
    -0.08183942f, 0.15582320f, 0.06593011f, 0.02799743f, -0.03933730f, -0.13480639f, -0.03673232f, 0.22199880f, 
    -0.00848987f, 0.26066443f, -0.13543144f, -0.04820936f, -0.16874678f, 0.01748527f, 0.03595313f, 0.19767091f, 
    0.24249050f, 0.08291706f, 0.02579448f, 0.01341709f, -0.15971069f, 0.11141833f, 0.02600971f, 0.10164450f, 
    -0.04949937f, -0.05299250f, -0.07466403f, 0.02257026f, -0.02705061f, 0.02231999f, 0.15329172f, 0.10010846f, 
    0.12469716f, 0.23820302f, 0.25111890f, 0.00567359f, -0.09693253f, 0.29940900f, -0.06407326f, -0.38445926f, 
    -0.17582445f, 0.12751362f, 0.04649475f, -0.11250376f, -0.06065160f, 0.05544583f, -0.02353754f, 0.02562301f, 
    0.01206180f, 0.20040029f, -0.16542639f, -0.05852399f, -0.02233433f, -0.02883670f, -0.26314455f, -0.15257908f, 
    -0.03152455f, -0.04425570f, -0.25377828f, 0.06910938f, 0.08078392f, -0.01362233f, 0.02545307f, 0.12082560f, 
    -0.00630241f, 0.01278929f, -0.00347768f, -0.04384805f, -0.13000622f, -0.00208582f, 0.05226462f, -0.02896323f, 
    0.30173835f, 0.00070945f, 0.14510812f, -0.16976435f, 0.03005653f, 0.05679487f, 0.16765824f, 0.07555829f, 
    -0.10039850f, -0.07328622f, 0.02757904f, 0.01922193f, 0.06671534f, 0.10977037f, -0.10610826f, 0.01965253f, 
    -0.01172372f, 0.06302113f, 0.07091568f, 0.12728649f, 0.25487065f, 0.05667211f, 0.16259882f, -0.26830229f, 
    0.00740469f, -0.01516900f, 0.04000454f, -0.04277451f, 0.12219747f, -0.06422965f, 0.06938620f, 0.07209831f, 
    0.09642792f, -0.01479195f, -0.02056281f, 0.05899034f, 0.12921089f, 0.03377160f, -0.04171413f, 0.14704305f, 
    0.49335489f, -0.17096068f, -0.22678424f, 0.09545879f, -0.24406199f, 0.16759974f, -0.16044056f, 0.11099145f, 
    -0.02790268f, -0.04033871f, -0.09952664f, -0.03621185f, -0.07715465f, 0.05936693f, -0.03873469f, -0.04009127f, 
    0.05446671f, 0.09735363f, -0.06464720f, 0.02742941f, 0.45733586f, -0.04361144f, -0.13145199f, -0.19461013f, 
    -0.13835144f, -0.03237742f, 0.02520216f, -0.07666410f, -0.00714321f, -0.15102458f, 0.11079065f, 0.03309132f, 
    -0.03017460f, 0.03524164f, 0.00965343f, 0.04573447f, 0.06668701f, 0.00747718f, 0.01567906f, 0.05442705f, 
    0.13739890f, -0.04989835f, -0.45188537f, -0.01739023f, -0.30201781f, 0.11614659f, 0.05333116f, 0.08513656f, 
    0.03839914f, 0.10452534f, 0.02513479f, 0.07365480f, -0.17059332f, 0.04210632f, 0.10038294f, -0.02671367f, 
    -0.00057932f, 0.07817790f, 0.03171305f, 0.02113307f, -0.37560931f, 0.19769077f, -0.35501927f, 0.11022390f, 
    -0.18355270f, 0.08100028f, -0.25179484f, 0.09001611f, -0.32705656f, -0.04412995f, 0.07015668f, 0.05316492f, 
    0.09769119f, -0.00933068f, 0.02989897f, 0.15939476f, -0.03915454f, 0.02770841f, -0.12136686f, -0.06726311f, 
    0.23314415f, 0.36482710f, 0.25184858f, -0.07386938f, -0.11225464f, 0.35796231f, 0.14250050f, 0.31604654f, 
    0.14902771f, 0.36463875f, 0.06092203f, 0.14075084f, 0.08845690f, -0.05400915f, -0.10703216f, -0.04211597f, 
    -0.07468545f, -0.16268800f, 0.14612490f, 0.17109264f, -0.13524361f, 0.08763693f, -0.16060121f, 0.15738504f, 
    0.12348112f, -0.03610893f, -0.03682547f, 0.02315241f, -0.09193671f, 0.04740150f, 0.05120336f, -0.04003276f, 
    0.00599083f, 0.03934524f, 0.02897425f, -0.02110015f, 0.02729393f, 0.03618858f, 0.02283734f, -0.06488530f, 
    0.27938908f, 0.20359565f, 0.14879398f, 0.12755191f, 0.03646428f, -0.02298446f, -0.04229374f, -0.00972017f, 
    -0.00013685f, 0.03932329f, 0.14013651f, -0.05343663f, -0.10348919f, -0.04370413f, -0.03762917f, -0.08601839f, 
    0.00427033f, 0.03781708f, -0.00052012f, 0.02781258f, -0.09033205f, -0.11421946f, -0.05878922f, -0.08970080f, 
    0.04868330f, -0.00056908f, -0.02053603f, -0.10110391f, -0.14112465f, -0.07617566f, 0.08986881f, -0.09503330f, 
    0.01743272f, -0.05228023f, -0.14816223f, 0.02122719f, -0.12335031f, -0.16787727f, -0.07877094f, -0.03462619f, 
    0.19049956f, 0.49154437f, 0.18718992f, 0.13418250f, -0.08533316f, -0.03823534f, 0.19580953f, 0.06658938f, 
    0.00823288f, 0.25825757f, 0.01958890f, 0.03833051f, 0.03223847f, 0.03170358f, 0.03945198f, -0.08700249f, 
    0.02431868f, -0.02084501f, -0.13290593f, -0.02463045f, -0.01089791f, 0.39481235f, -0.23423804f, 0.31184721f, 
    0.11299887f, 0.05732230f, 0.02706333f, -0.00874713f, 0.08455435f, 0.08484251f, 0.05613802f, -0.04474311f, 
    -0.02723664f, 0.02821624f, 0.00307031f, 0.11200086f, -0.04108646f, 0.06002121f, 0.00516349f, -0.02005416f, 
    0.15159896f, 0.12486902f, 0.22733110f, -0.27196187f, 0.08258840f, 0.10824063f, 0.09831355f, -0.00479510f, 
    0.08437897f, 0.20874374f, 0.00545445f, -0.05012251f, -0.03095591f, -0.02589009f, -0.01176758f, 0.03177163f, 
    0.00963374f, -0.14160348f, 0.13677804f, 0.18464759f, 0.12040438f, 0.04042985f, 0.25400776f, -0.09778062f, 
    0.13458520f, 0.06613088f, -0.07505946f, 0.16495122f, -0.01299935f, 0.23986150f, -0.00158931f, -0.01064967f, 
    -0.06099396f, -0.08158080f, -0.02677484f, -0.01451854f, 0.07132512f, -0.14572510f, 0.05173884f, 0.15030567f, 
    -0.46438792f, -0.17529380f, -0.04072898f, 0.10491891f, -0.27119240f, 0.07948884f, -0.12919050f, -0.05579032f, 
    -0.12173050f, -0.13221546f, -0.05941176f, 0.02325737f, -0.06834210f, -0.07706407f, 0.10659433f, -0.02876987f, 
    -0.08984156f, 0.09883595f, -0.10226915f, -0.04806795f, 0.25241062f, 0.02397136f, -0.10930286f, -0.09723295f, 
    -0.05104448f, -0.07804103f, -0.06111296f, -0.11037818f, -0.07701908f, -0.19558583f, 0.03688686f, 0.07701148f, 
    0.03448651f, -0.00512216f, -0.10180666f, -0.07897434f, -0.01316916f, 0.06008974f, -0.02840139f, 0.02576733f, 
    0.15725878f, 0.10187025f, 0.35465696f, -0.00820451f, 0.06000763f, 0.06808948f, 0.00651053f, 0.10052674f, 
    0.07302212f, 0.19364667f, 0.02112074f, 0.00344483f, -0.06927616f, -0.01632466f, 0.00616998f, -0.08482820f, 
    0.05000261f, -0.16689798f, 0.13446061f, 0.01573823f, -0.05995834f, 0.19003078f, 0.10620151f, 0.08047913f, 
    -0.18549769f, -0.02542158f, 0.20033568f, 0.03470996f, -0.00217171f, 0.02217313f, 0.08548429f, -0.04850890f, 
    -0.04530040f, 0.11159889f, 0.09205339f, 0.01381137f, -0.01665902f, 0.21270722f, -0.02574129f, 0.24425794f, 
    -0.02027542f, 0.08283009f, -0.16135658f, -0.11353346f, 0.29407719f, 0.02812859f, 0.08755828f, -0.02226765f, 
    -0.04732823f, -0.03243074f, 0.04066758f, 0.06436283f, 0.07210728f, 0.09626200f, 0.06498173f, 0.07388955f, 
    -0.03823361f, -0.01908754f, 0.01574856f, 0.08084971f, -0.42127404f, -0.00193144f, -0.02462448f, -0.21767929f, 
    0.19858862f, 0.07635357f, 0.04178032f, 0.02971531f, 0.00817836f, 0.04705497f, -0.05278602f, -0.01329022f, 
    0.05003083f, -0.07952319f, -0.01265702f, -0.10931092f, 0.01413030f, 0.10689111f, -0.05469985f, -0.17578477f, 
    0.18222049f, 0.07973610f, -0.02472673f, -0.02943246f, 0.15387355f, 0.16889341f, 0.07514491f, 0.12584203f, 
    0.07070750f, -0.00424532f, -0.10625924f, 0.04204367f, 0.11525967f, 0.11217275f, 0.12081568f, -0.06030852f, 
    -0.03291704f, -0.04555584f, -0.03765625f, 0.02776064f, 0.35572210f, -0.20710161f, 0.46157575f, -0.12080881f, 
    0.21761087f, 0.00264872f, 0.19534607f, -0.11129542f, 0.38393763f, -0.05929714f, -0.01244278f, 0.05654503f, 
    -0.06627850f, 0.06179995f, 0.05524549f, -0.13353005f, -0.02465997f, 0.03395826f, -0.03999141f, -0.03925179f, 
    -0.21908112f, -0.23136418f, -0.43095914f, 0.01090464f, 0.10890570f, -0.03845199f, 0.15877208f, -0.03553482f, 
    0.00807685f, -0.09847348f, 0.17842132f, 0.05234893f, 0.01175570f, 0.01352593f, 0.04834095f, 0.01014337f, 
    -0.09305808f, 0.05689935f, 0.03264116f, 0.23187985f, 0.05560122f, -0.13008313f, 0.49800956f, -0.13577829f, 
    0.03174597f, -0.05353767f, 0.01007821f, -0.08471538f, 0.10798419f, -0.07972905f, 0.00139793f, -0.00866251f, 
    0.00449403f, -0.02917695f, 0.01053177f, 0.00523101f, -0.00568617f, 0.15593198f, 0.00480226f, 0.02991557f, 
    -0.24107821f, -0.06080698f, -0.13027190f, -0.04948963f, -0.09216200f, 0.15294717f, 0.03105715f, 0.10733657f, 
    -0.00363907f, 0.01260573f, -0.23719756f, 0.01357321f, 0.09614303f, -0.09379746f, 0.02838677f, -0.08706761f, 
    -0.11958067f, -0.14778668f, -0.13524064f, -0.11086997f, 0.04193449f, 0.12091903f, 0.15117864f, 0.02453221f, 
    -0.19745001f, 0.00932185f, 0.06126952f, 0.09514316f, 0.07816771f, 0.05685313f, -0.09710746f, 0.06247706f, 
    -0.10227112f, 0.07571354f, 0.12598294f, -0.04451476f, 0.10341723f, 0.14959511f, -0.00410102f, -0.15659201f, 
    0.02114152f, -0.24158084f, -0.16293016f, -0.13650768f, 0.27481845f, -0.01955792f, 0.01484851f, -0.00218671f, 
    0.07319488f, -0.12989849f, 0.10192263f, -0.05415825f, 0.06790629f, 0.02992248f, 0.02822105f, 0.00535130f, 
    -0.06691113f, 0.07353231f, 0.10968349f, -0.05304029f, 0.20965376f, -0.39392459f, 0.60101408f, -0.31459847f, 
    -0.01060490f, -0.20916195f, -0.01718196f, -0.02629194f, 0.02017620f, -0.12919013f, 0.03397992f, 0.04602466f, 
    0.03046482f, -0.09121567f, -0.00918866f, 0.05689803f, 0.00702148f, -0.13891114f, 0.10491400f, 0.10971470f, 
    -0.06423594f, 0.21106654f, -0.17735533f, 0.03037364f, 0.15863632f, -0.00665753f, 0.00284601f, 0.08457309f, 
    -0.14121877f, -0.03189315f, -0.01691567f, 0.03033450f, 0.00616785f, 0.01471159f, -0.07198927f, 0.03654947f, 
    -0.07122660f, 0.30663380f, -0.05371942f, 0.00661993f, -0.08699390f, 0.15524726f, -0.30383232f, 0.32299075f, 
    0.11322704f, -0.08572204f, 0.08102783f, -0.11201942f, 0.14703007f, -0.00663547f, 0.00952941f, 0.14381114f, 
    0.04427451f, 0.07001366f, 0.05284649f, 0.08078261f, 0.03767532f, 0.12785880f, 0.03842559f, -0.02739973f, 
    0.58578533f, 0.15089841f, 0.19095853f, -0.34857947f, 0.21730146f, 0.03961941f, 0.16768979f, 0.04049245f, 
    0.09663656f, -0.06383905f, -0.01117575f, 0.00777726f, 0.03997001f, 0.06280846f, 0.09488972f, 0.14211267f, 
    0.10850853f, -0.15141293f, -0.05657405f, -0.17238806f, -0.38019952f, 0.26195514f, -0.01020940f, -0.03780369f, 
    0.03186378f, 0.10016744f, -0.13976896f, 0.08476152f, 0.06172327f, 0.11349878f, -0.09359019f, 0.06371699f, 
    0.03672262f, -0.05152147f, -0.01724426f, -0.08808620f, -0.05883034f, -0.08282813f, 0.00246837f, -0.19454516f, 
    -0.24101397f, -0.06435815f, -0.35998732f, 0.00353301f, 0.15263315f, -0.04574000f, 0.00405874f, -0.08863046f, 
    -0.02585304f, -0.06090247f, 0.05873061f, -0.03709343f, 0.01468252f, -0.00832163f, 0.06490080f, 0.08599039f, 
    -0.09770586f, 0.21232685f, 0.00682833f, 0.01842959f, 0.45303965f, 0.00916629f, 0.02351657f, -0.37458062f, 
    0.19764952f, 0.02378128f, 0.05498002f, 0.01601812f, 0.05830336f, -0.05634085f, -0.06684759f, 0.07693131f, 
    -0.01547297f, -0.01981387f, -0.11067554f, 0.15071510f, 0.20126700f, 0.07804768f, 0.01165008f, -0.01674750f, 
    0.14121106f, 0.01094317f, 0.16957550f, 0.18673095f, -0.16113107f, -0.01930908f, -0.00639793f, 0.02674623f, 
    0.02148906f, 0.05391303f, -0.07340571f, -0.00796132f, 0.01528808f, 0.06721891f, 0.01568205f, 0.07381374f, 
    0.01566665f, -0.08076453f, 0.12449073f, -0.09241166f, 0.23459339f, 0.32198861f, 0.29233649f, 0.07168490f, 
    -0.15168725f, -0.20954895f, -0.08821242f, -0.04427015f, -0.00498987f, 0.05543096f, 0.06643923f, -0.05584570f, 
    0.02914077f, 0.01085217f, 0.02511971f, -0.02901390f, -0.15643091f, -0.22050722f, -0.00508976f, -0.08607170f, 
    -0.07751221f, -0.19790398f, -0.00635370f, 0.02902314f, -0.09167607f, -0.06994265f, 0.06149651f, 0.02087987f, 
    0.12396015f, 0.00746941f, 0.14128926f, 0.01148727f, 0.02274145f, 0.02876461f, 0.03591982f, 0.22586034f, 
    0.28700000f, 0.14407673f, 0.08874714f, 0.07905473f, -0.20349877f, 0.16172704f, -0.62506872f, -0.22744015f, 
    -0.14800021f, 0.03046569f, -0.10883190f, 0.18758759f, -0.02515692f, -0.00087956f, 0.11282722f, 0.03019919f, 
    0.01328131f, -0.13624331f, -0.07377445f, 0.16129479f, 0.06958643f, -0.14858139f, -0.03523263f, -0.10705563f, 
    0.12029359f, 0.22028795f, 0.09092449f, 0.03072889f, -0.22099265f, -0.04344378f, 0.02103230f, -0.00190815f, 
    -0.02895718f, 0.12402119f, 0.06674369f, 0.18076020f, 0.02199606f, -0.19638026f, -0.12578402f, -0.25777465f, 
    -0.30038625f, -0.12814400f, 0.06419599f, -0.27887896f, -0.04471674f, 0.36237517f, -0.46298042f, 0.18154219f, 
    -0.06110331f, 0.04419386f, 0.06106481f, 0.17201555f, -0.09628785f, -0.03929614f, -0.01464564f, -0.07117862f, 
    0.00962638f, -0.02476752f, -0.11541717f, 0.09199673f, 0.15747392f, 0.00491408f, 0.07717104f, 0.15171334f, 
    0.31079119f, 0.36907208f, 0.26002058f, -0.07077271f, 0.31206712f, -0.28290933f, -0.20841640f, -0.02892578f, 
    0.05788738f, 0.16012198f, 0.14440235f, 0.03477769f, 0.07475030f, 0.07992727f, 0.03079307f, 0.04683438f, 
    0.02114753f, 0.03274103f, -0.26006201f, 0.12480357f, 0.17130822f, -0.24779436f, -0.25583696f, -0.00156086f, 
    0.12324359f, 0.20161259f, 0.11983071f, 0.12005872f, -0.17067057f, -0.18868019f, -0.07835122f, -0.11196255f, 
    -0.01875970f, -0.01610326f, 0.00295167f, 0.04551477f, -0.14734876f, -0.21794868f, -0.18254553f, -0.02843262f, 
    0.05170159f, 0.23854163f, 0.14687604f, -0.10855430f, -0.29365715f, -0.01172200f, 0.06909742f, -0.01072391f, 
    0.00958265f, -0.02924532f, -0.05846451f, 0.12036012f, 0.02153344f, -0.10631108f, 0.02831113f, -0.02448970f, 
    0.02210921f, 0.16650423f, 0.11392344f, 0.09474442f, -0.11613623f, 0.43129319f, -0.59845644f, 0.17118053f, 
    0.08056097f, 0.21960467f, 0.20081034f, 0.09985925f, -0.05970076f, 0.03535320f, 0.01659725f, -0.13771304f, 
    -0.06766278f, -0.07090304f, -0.21945661f, 0.11067158f, 0.16310118f, 0.14753406f, -0.02755023f, 0.11012913f, 
    0.28883478f, -0.12391559f, -0.12140810f, -0.26105556f, -0.02421976f, 0.05792853f, 0.02210921f, -0.06072130f, 
    0.04495961f, 0.05065687f, 0.05244721f, -0.03178723f, -0.05254223f, 0.13487303f, -0.08543237f, -0.00007668f, 
    0.19897206f, 0.09129883f, 0.24229544f, 0.23249762f, 0.11988772f, -0.13215324f, 0.23574972f, -0.31592047f, 
    -0.09189469f, 0.03247184f, 0.02802533f, 0.03135376f, -0.00227575f, -0.14521679f, -0.01237420f, -0.06662483f, 
    0.00888785f, 0.16183086f, 0.04165358f, 0.05174401f, 0.07625173f, 0.15512915f, -0.04014562f, 0.04487409f, 
    -0.65140527f, -0.10425536f, -0.34477925f, 0.34911290f, 0.15674099f, -0.05896403f, 0.08129119f, 0.15424141f, 
    0.07724574f, -0.15418780f, 0.05372465f, -0.02288620f, 0.13727131f, 0.01834612f, -0.07527471f, 0.04767609f, 
    0.05277025f, -0.26606652f, 0.06979223f, -0.04296288f, 0.21167919f, -0.03205067f, 0.19863637f, 0.16444419f, 
    0.04385780f, -0.25399598f, -0.03823960f, -0.16848433f, -0.10749391f, -0.02242120f, 0.07892983f, -0.07021265f, 
    0.02559092f, -0.00093424f, -0.03510050f, -0.02869644f, -0.04283471f, 0.00530473f, -0.13914239f, 0.02690567f, 
    0.21546902f, 0.04204631f, 0.32455206f, -0.14848129f, -0.11989177f, 0.07589389f, 0.04418662f, 0.04538620f, 
    -0.01048539f, 0.07123516f, 0.01710634f, 0.02226510f, -0.02556981f, 0.01268237f, -0.03657899f, -0.06468461f, 
    0.04034559f, -0.00477351f, 0.09351171f, 0.07356713f, -0.25707871f, 0.05201128f, 0.07212505f, 0.03562620f, 
    -0.11637157f, 0.03163801f, -0.06417913f, -0.00581069f, -0.05322324f, 0.15646765f, 0.04494226f, -0.09775090f, 
    0.10043354f, 0.13271199f, 0.05608487f, 0.05188973f, 0.13492769f, 0.01767692f, 0.01449162f, 0.12201171f, 
    0.03879315f, -0.06127746f, 0.08024542f, -0.26312780f, 0.63768053f, -0.30083767f, 0.11953478f, 0.18639967f, 
    0.09759582f, 0.15578924f, -0.04158011f, 0.01759820f, -0.02414018f, -0.08195625f, -0.07599393f, 0.02104339f, 
    -0.04476766f, -0.00600696f, 0.02188398f, -0.08748174f, 0.20184320f, 0.07137182f, -0.17254576f, -0.15426464f, 
    0.05622550f, -0.03185275f, 0.08649626f, 0.18223964f, 0.30219179f, 0.29247290f, -0.01543650f, 0.08418942f, 
    -0.09720679f, 0.10387356f, -0.12289986f, 0.02487542f, 0.04253959f, 0.04895636f, 0.15314350f, 0.05418737f, 
    -0.16475487f, -0.37857682f, 0.12536009f, -0.25886196f, 0.47014534f, -0.06006519f, 0.03207694f, 0.09306788f, 
    0.03037504f, 0.03284204f, 0.02003808f, 0.10304642f, -0.10284943f, -0.04890979f, -0.10108226f, -0.08773334f, 
    -0.10417755f, 0.03003070f, -0.00381650f, -0.09090156f, -0.02297633f, -0.01610253f, -0.18527727f, -0.04315853f, 
    -0.09660050f, -0.03725388f, -0.08123919f, 0.22825518f, -0.09011014f, 0.01720642f, 0.14223799f, 0.03429482f, 
    0.15759276f, 0.05169976f, -0.02406036f, 0.08166206f, -0.12153398f, 0.15419917f, -0.02084551f, 0.05696101f, 
    -0.33280975f, -0.41808900f, 0.17513238f, 0.14496556f, -0.13705911f, 0.17942321f, 0.04746713f, -0.01703139f, 
    -0.04390036f, -0.05109917f, -0.05309540f, -0.08062110f, 0.18829073f, 0.05389314f, 0.00971735f, -0.09955253f, 
    0.17112972f, 0.03112882f, 0.14496106f, -0.00823308f, -0.17360872f, 0.22921976f, 0.16340239f, 0.00093502f, 
    0.01818787f, -0.00154274f, 0.02602799f, 0.02016218f, -0.06456836f, -0.00262147f, 0.05923521f, 0.02347820f, 
    0.03724690f, 0.10136794f, 0.06144782f, -0.00103729f, -0.10773478f, -0.13579679f, -0.01065635f, 0.03574142f, 
    0.13346761f, 0.16174117f, 0.06656879f, -0.06476787f, -0.27665922f, -0.13399719f, -0.09535995f, -0.10081159f, 
    -0.04039818f, -0.07956963f, 0.10636521f, 0.08116508f, -0.01858443f, 0.00274538f, 0.16292749f, -0.08929218f, 
    -0.06533562f, 0.01316052f, 0.07959824f, -0.05239688f, -0.17958231f, 0.07735330f, 0.08176788f, -0.00028742f, 
    0.01683280f, -0.05028037f, -0.04195229f, -0.04706778f, 0.10543379f, -0.09799802f, 0.05952271f, 0.05964510f, 
    0.14877950f, 0.01749242f, 0.02936820f, 0.06988218f, 0.11107922f, 0.05582614f, 0.06181747f, 0.04832961f, 
    -0.42277232f, -0.35189691f, -0.10949728f, 0.28431565f, -0.02108390f, 0.17562906f, 0.27640533f, 0.26135728f, 
    -0.02902159f, -0.08524499f, 0.10235450f, -0.03138374f, -0.03159523f, 0.02828279f, 0.02018283f, 0.12052399f, 
    0.02465694f, -0.06727287f, -0.11298759f, 0.15587863f, -0.25711697f, 0.08373544f, -0.13833167f, -0.00154209f, 
    -0.08239947f, -0.19969374f, -0.02265952f, -0.17891964f, -0.12613299f, -0.12365959f, -0.06605985f, -0.05860791f, 
    -0.02400783f, -0.05223081f, 0.00526111f, 0.05407003f, -0.02224994f, -0.06217050f, -0.02742907f, -0.09331317f, 
    0.10865920f, -0.11207218f, 0.25104693f, 0.12337602f, 0.12655990f, 0.13788886f, -0.06314959f, -0.14609165f, 
    0.09477814f, -0.04955110f, -0.09200416f, -0.08755277f, -0.10480139f, 0.03484537f, -0.02964683f, 0.05024446f, 
    0.11523193f, -0.03712835f, 0.02381408f, -0.02676151f, 0.13233265f, 0.06371057f, 0.12260337f, 0.10261653f, 
    0.43837661f, 0.12454932f, 0.22573671f, 0.18089628f, -0.00014304f, 0.15657802f, 0.18677455f, -0.02450081f, 
    0.08589353f, 0.06857000f, -0.05285755f, 0.24020338f, 0.01172542f, -0.06260899f, -0.03250708f, 0.10503943f, 
    0.21710888f, 0.01216443f, -0.17335989f, 0.04512849f, -0.24906901f, -0.03448959f, 0.00642623f, 0.07438145f, 
    0.04924202f, 0.15806751f, 0.02029467f, 0.14284465f, 0.06818135f, 0.00372599f, -0.01435261f, -0.00718591f, 
    -0.10791340f, 0.12078205f, 0.11301911f, -0.06848761f, 0.35246766f, -0.03052597f, 0.17676683f, -0.20713268f, 
    -0.09444077f, -0.00606602f, -0.08906634f, 0.04945799f, 0.16466434f, 0.13389225f, 0.16263844f, 0.09964465f, 
    0.07153209f, -0.04706712f, 0.03958324f, -0.04635907f, 0.04945795f, 0.06363924f, 0.09808734f, 0.12368899f, 
    -0.04625674f, -0.09757727f, -0.19836755f, 0.18312554f, 0.05399560f, 0.08602642f, 0.29062790f, 0.19083026f, 
    -0.02512093f, -0.01666388f, 0.04538048f, -0.06473634f, -0.10878342f, 0.06047072f, 0.07097340f, -0.04445417f, 
    0.10362953f, 0.01318261f, -0.02616924f, -0.01539433f, -0.19828004f, -0.17207542f, -0.23876278f, 0.38461599f, 
    0.12128824f, -0.09736688f, 0.01559153f, -0.10666198f, 0.21144123f, 0.01702799f, -0.10552319f, -0.01171483f, 
    -0.09382590f, 0.05155475f, -0.00996593f, -0.01713229f, 0.03248335f, -0.08108205f, 0.00666387f, -0.11373517f, 
    -0.03398423f, -0.04960057f, 0.01811866f, 0.01662721f, 0.00394001f, -0.00085751f, -0.05412208f, 0.00141885f, 
    -0.00327023f, 0.02825188f, -0.03731762f, 0.01196310f, -0.05026764f, -0.02008377f, 0.04429478f, -0.04271201f, 
    -0.01632824f, -0.02299483f, -0.04721131f, -0.04102932f, -0.05799451f, -0.05537971f, 0.04986970f, -0.00325468f, 
    -0.06019263f, -0.05829248f, -0.01515114f, 0.04100250f, 0.01270488f, -0.05168270f, 0.02422416f, -0.04110374f, 
    -0.03285825f, -0.04915726f, 0.03829481f, -0.02611343f, 0.02724179f, 0.03301750f, -0.03256816f, -0.05639799f, 
    -0.01093917f, -0.03134444f, 0.04209525f, -0.04098518f, -0.04735885f, -0.03872262f, 0.01874437f, 0.00262861f, 
    -0.03435751f, -0.01061595f, 0.01392991f, -0.05979300f, 0.00320176f, -0.03465620f, 0.01921942f, 0.01092584f, 
    0.02749374f, 0.02047768f, -0.02093088f, -0.03355238f, 0.00348986f, 0.00457209f, 0.03754165f, -0.02126908f, 
    -0.00151165f, -0.05178498f, -0.04298724f, 0.00523336f, -0.03936046f, 0.02342751f, -0.06010952f, -0.05061600f, 
    0.00808350f, 0.03083106f, -0.04260755f, 0.05164879f, -0.01046926f, -0.00459935f, 0.00584387f, 0.03800731f, 
    0.02674792f, 0.01413363f, 0.00839771f, -0.00463461f, -0.03062896f, 0.03781609f, 0.01712774f, 0.02183453f, 
    -0.03678083f, -0.01876168f, 0.00999433f, -0.01744222f, 0.00554268f, 0.00812626f, -0.03604159f, -0.00779245f, 
    0.03254847f, 0.02698997f, -0.05342758f, -0.00120860f, 0.00235027f, 0.01684800f, -0.05061578f, -0.03504013f, 
    -0.04987587f, -0.01551430f, 0.03249555f, -0.05059575f, -0.05729001f, 0.04051795f, -0.05238580f, -0.03942481f, 
    -0.01460012f, 0.01116588f, 0.02750018f, -0.00611998f, 0.05341308f, -0.04445253f, 0.02999439f, 0.00482010f, 
    -0.02712988f, 0.00309431f, -0.02726114f, 0.02060565f, -0.03450510f, -0.01967638f, -0.02381795f, -0.03137377f, 
    0.02865107f, -0.02742791f, 0.01803058f, -0.05339163f, -0.00816695f, 0.03472250f, 0.01147209f, 0.03416513f, 
    -0.05596796f, -0.04944685f, 0.00444379f, 0.02471182f, -0.02827780f, 0.04138324f, 0.00606292f, 0.01614994f, 
    -0.00586689f, -0.04866692f, 0.03267245f, -0.00076339f, 0.03645891f, -0.00145030f, -0.02522450f, -0.04050317f, 
    -0.01368695f, -0.04603682f, -0.04797514f, -0.03506659f, -0.00169513f, -0.02700589f, -0.01123126f, -0.01565625f, 
    -0.01432219f, 0.02508022f, 0.02017378f, -0.02428782f, -0.03530535f, -0.02430188f, -0.03267609f, 0.02148816f, 
    -0.00327180f, 0.01674767f, -0.00982593f, 0.02030611f, 0.01903085f, 0.03036346f, -0.03922788f, -0.03187534f, 
    0.01686903f, 0.02237215f, -0.03413958f, -0.02856806f, 0.00734349f, 0.03820420f, -0.03415986f, 0.04453091f, 
    -0.03658462f, 0.00112137f, -0.02996632f, -0.01460476f, -0.00581206f, 0.04768539f, -0.00734550f, 0.00256772f, 
    -0.01663582f, 0.02103161f, 0.03885808f, -0.01897584f, -0.04585670f, 0.01049529f, -0.05292749f, 0.00602928f, 
    0.01983562f, 0.03077779f, -0.03654815f, 0.04515865f, -0.00088135f, 0.03289714f, -0.02040780f, 0.04785450f, 
    0.04269500f, 0.00021069f, -0.01057662f, 0.02312287f, 0.03512685f, -0.01933399f, 0.03663464f, 0.01068833f, 
    -0.05409786f, -0.03865190f, 0.02264456f, 0.02005388f, 0.03883821f, 0.01342797f, 0.03894392f, 0.03594112f, 
    0.00317785f, 0.04271522f, 0.02355018f, -0.05985285f, -0.04901965f, -0.04732361f, 0.00164590f, -0.01004405f, 
    0.00169747f, 0.03630967f, 0.00929007f, 0.04365074f, 0.00109674f, 0.03824174f, 0.04247781f, -0.04950830f, 
    0.00719318f, 0.04271916f, 0.04533223f, -0.00383895f, 0.05005107f, 0.01343146f, -0.01860154f, -0.03305048f, 
    -0.00014341f, -0.02466211f, -0.03418196f, -0.04413651f, 0.04177953f, 0.04894648f, 0.02722126f, 0.01594945f, 
    -0.05421973f, -0.03580977f, -0.02015254f, -0.05166646f, -0.01849029f, -0.03181376f, 0.00892124f, 0.03325172f, 
    -0.01393076f, 0.00693059f, -0.01578739f, -0.01675799f, 0.04184790f, -0.05201107f, -0.00403833f, -0.01209878f, 
    -0.04242523f, -0.00863998f, -0.05821390f, 0.02989299f, 0.04353673f, -0.03615204f, 0.01954828f, -0.03173139f, 
    -0.03380677f, -0.02744233f, 0.03993541f, 0.03566268f, -0.01381643f, -0.05867293f, -0.05260531f, 0.02477398f, 
    0.00989127f, 0.02731217f, -0.03516921f, -0.02758659f, -0.00682794f, 0.00201577f, 0.03655088f, -0.00603969f, 
    -0.04560442f, 0.02330622f, -0.00421061f, -0.00547709f, 0.02613631f, 0.05482997f, -0.00303966f, -0.04011356f, 
    0.01344702f, 0.00683876f, -0.00792182f, -0.00482584f, -0.03312334f, -0.03405102f, 0.02888389f, -0.01558895f, 
    -0.00355697f, 0.04475354f, -0.04228369f, -0.01501096f, -0.04060483f, 0.04312006f, -0.03840424f, -0.03217072f, 
    -0.04319183f, -0.03372137f, -0.00562231f, -0.00411503f, 0.03043181f, 0.04427548f, 0.05162062f, -0.05453305f, 
    -0.01040475f, -0.02350264f, -0.02450333f, 0.00476729f, 0.02964328f, -0.06038417f, -0.04572700f, 0.00302412f, 
    -0.04891901f, -0.05124099f, 0.00444953f, -0.01398086f, 0.04424740f, 0.01692188f, 0.03946887f, -0.02276062f, 
    0.02595954f, -0.05326214f, 0.04636673f, -0.05691953f, -0.02687989f, -0.00818795f, -0.02707718f, 0.00241176f, 
    -0.04734833f, 0.01724563f, -0.05422097f, 0.03250995f, 0.04629220f, 0.03950959f, -0.04707359f, -0.02787241f, 
    0.02032394f, 0.04961097f, -0.05316583f, 0.01138520f, 0.01710927f, 0.03349106f, -0.03790979f, -0.03795432f, 
    -0.03890905f, -0.00742103f, -0.02312384f, 0.05034605f, -0.04445000f, 0.01990438f, 0.04001641f, 0.02144900f, 
    -0.03770853f, -0.05600972f, -0.01960944f, -0.04098221f, -0.01058837f, -0.04518975f, 0.03428369f, 0.01857869f, 
    0.02388097f, 0.00870247f, 0.02744402f, -0.05184111f, 0.04216258f, -0.03733668f, -0.05946285f, -0.05612080f, 
    0.00697243f, 0.04127534f, 0.01728060f, 0.00666590f, -0.04015282f, 0.01225086f, 0.04050739f, 0.03809252f, 
    -0.01715724f, -0.00672022f, -0.03797858f, -0.01925618f, 0.00850046f, 0.03089509f, -0.03753944f, -0.01421409f, 
    -0.00542358f, 0.05786140f, -0.00165079f, 0.03284435f, 0.02183940f, 0.03906204f, 0.03625005f, -0.05845020f, 
    0.04601783f, 0.01354921f, 0.02726089f, 0.01659274f, 0.00966560f, 0.01736792f, 0.04251399f, -0.01340858f, 
    -0.04003846f, 0.04387740f, -0.02235951f, -0.05018947f, -0.04230309f, 0.02545972f, 0.03873881f, 0.00469052f, 
    -0.05921257f, 0.00874602f, -0.01848900f, 0.00342910f, -0.05618982f, -0.03963991f, -0.04540875f, 0.00665615f, 
    0.01416318f, 0.00650903f, -0.05348645f, 0.02576583f, 0.03747809f, 0.02142462f, -0.04825729f, -0.04220709f, 
    -0.01962285f, -0.01029635f, -0.03728874f, 0.05601982f, -0.05078349f, -0.00991912f, -0.04984362f, -0.05744096f, 
    -0.02807101f, 0.00970839f, -0.02802169f, -0.02823966f, -0.04055037f, 0.04056735f, 0.00112629f, -0.02551322f, 
    -0.02530453f, 0.04105845f, -0.03200179f, -0.00830682f, -0.05255492f, -0.00671931f, 0.03035814f, 0.00352304f, 
    -0.04280210f, 0.04409776f, 0.01377566f, -0.02220515f, 0.03989831f, 0.02515618f, -0.04507784f, -0.01747259f, 
    0.01278244f, 0.04244764f, -0.00999517f, 0.02035970f, 0.03801110f, -0.00689347f, 0.00128495f, 0.03854877f, 
    -0.00105775f, 0.02578985f, -0.04417626f, 0.02919916f, 0.02640039f, -0.04730866f, -0.00559936f, -0.02011443f, 
    0.00272846f, 0.00034599f, -0.02377883f, 0.00224276f, -0.02567080f, 0.03864167f, -0.02401642f, -0.05844780f, 
    -0.05920730f, -0.03800381f, 0.02193584f, 0.04554945f, 0.03448888f, -0.05666390f, -0.05701418f, 0.01987028f, 
    -0.04794925f, 0.03573152f, -0.02525534f, 0.01104480f, 0.02217402f, -0.00112977f, -0.02101932f, 0.02094501f, 
    -0.02906655f, -0.02988489f, -0.05229526f, 0.04316085f, 0.02198621f, -0.05614901f, -0.03223136f, 0.02191583f, 
    -0.04711774f, -0.01479798f, -0.04456814f, 0.00224234f, 0.04542280f, 0.00947721f, -0.04387994f, 0.00099333f, 
    0.01959585f, -0.00623839f, -0.06292001f, -0.02814106f, 0.05159987f, -0.05647691f, -0.00394852f, 0.04772047f, 
    0.00457194f, -0.05739184f, -0.01007280f, 0.01781140f, -0.03191628f, -0.00438177f, -0.03191491f, 0.03595143f, 
    -0.04009552f, -0.03924011f, 0.02339771f, 0.05247417f, -0.02026214f, -0.05789957f, -0.02226720f, 0.03860176f, 
    0.01053155f, -0.00403733f, -0.03876305f, -0.01052119f, -0.03244029f, -0.05810831f, -0.02784100f, -0.00726845f, 
    -0.01386141f, -0.01106694f, 0.00952398f, -0.02155524f, 0.02446110f, -0.01084303f, 0.03285686f, 0.00536841f, 
    0.04919558f, 0.00358776f, -0.00299336f, 0.04120743f, 0.04485790f, 0.03204910f, -0.04638656f, -0.00556359f, 
    -0.00458122f, 0.00240574f, -0.00198022f, 0.02566168f, -0.05379409f, 0.04230017f, 0.02851248f, -0.05237393f, 
    0.05004782f, -0.02996419f, -0.01674372f, -0.04397471f, -0.03455846f, 0.02232036f, -0.02747951f, 0.00320701f, 
    -0.02994988f, 0.00835401f, -0.04054201f, 0.02182400f, 0.02394209f, -0.04176664f, -0.03483329f, 0.00816822f, 
    -0.01961924f, 0.03892143f, 0.05239509f, 0.03682918f, -0.04395513f, -0.00646733f, 0.04535006f, -0.00872994f, 
    -0.04390251f, -0.03221008f, 0.00285881f, 0.00038798f, -0.03497053f, -0.04461684f, 0.03739780f, -0.01462047f, 
    0.01172214f, 0.04326129f, -0.04811617f, 0.05627573f, 0.02127950f, 0.04632711f, -0.04440538f, -0.01276950f, 
    -0.05158803f, -0.02179394f, -0.02101941f, -0.02838989f, 0.02634214f, -0.02224965f, -0.02783875f, -0.06334704f, 
    -0.05445747f, 0.00240047f, 0.03630802f, -0.00883862f, -0.00017051f, -0.06315020f, -0.01847972f, 0.04178401f, 
    -0.05641131f, 0.03717268f, -0.06053705f, -0.03757795f, -0.03017371f, 0.02907475f, -0.02136232f, 0.02477937f, 
    -0.03567875f, 0.02953506f, 0.03038990f, -0.02223814f, 0.02678377f, -0.03800692f, -0.04403706f, 0.01257425f, 
    0.04609754f, 0.03981160f, 0.00987614f, -0.02073194f, -0.01031072f, 0.04793955f, -0.01768051f, -0.01050495f, 
    -0.05693076f, 0.04595231f, -0.05748542f, 0.02570900f, -0.04210426f, -0.03586863f, -0.03171127f, 0.00667609f, 
    -0.04508206f, -0.05283181f, -0.01010000f, -0.02363260f, 0.01058779f, 0.02563648f, 0.04330222f, -0.03620922f, 
    -0.05123559f, -0.02847776f, -0.00532017f, -0.05072238f, -0.05439484f, 0.04302240f, 0.01564731f, 0.00578237f, 
    0.02381019f, -0.04248023f, 0.02079709f, -0.04312721f, 0.01371141f, -0.00406619f, -0.00160836f, 0.01628255f, 
    -0.02737773f, -0.01579558f, -0.03862268f, -0.04039599f, -0.01360932f, 0.02591373f, -0.02460466f, -0.00514295f, 
    -0.02885360f, 0.03881771f, 0.01930464f, 0.02760980f, 0.00967883f, -0.03481820f, 0.01654768f, -0.04707971f, 
    0.03495735f, -0.02695470f, 0.00108773f, 0.03256150f, 0.01025049f, -0.04258273f, 0.00466935f, -0.01238349f, 
    -0.04757795f, -0.05569943f, -0.05727926f, -0.00210512f, 0.04536344f, -0.01793958f, -0.02326742f, 0.03228622f, 
    -0.04362516f, 0.00736706f, 0.00805262f, -0.00908737f, 0.00967206f, -0.02223720f, -0.00201067f, -0.03367958f, 
    0.01896081f, -0.04636379f, 0.04599521f, -0.03687135f, 0.01296756f, 0.01436506f, -0.00513284f, -0.02190071f, 
    -0.01856110f, -0.05724562f, -0.00672843f, -0.00396393f, -0.00482989f, -0.02319607f, 0.02134773f, -0.01588609f, 
    0.02579283f, -0.00869973f, 0.01368682f, 0.03557506f, -0.01279423f, 0.01113770f, 0.04584236f, -0.03619559f, 
    -0.05186548f, -0.02935857f, 0.01531396f, 0.00046857f, 0.00411283f, -0.01563504f, 0.03956879f, 0.03601481f, 
    0.04840286f, 0.03777029f, -0.02421084f, -0.05535955f, 0.01181345f, -0.03107319f, -0.04199625f, -0.02321887f, 
    -0.04322422f, -0.04579320f, -0.01104096f, -0.00255119f, 0.02191855f, -0.04124905f, -0.03340350f, -0.04407381f, 
    -0.03773627f, 0.02310135f, 0.03476048f, 0.02533541f, -0.03686574f, 0.01308454f, 0.02559026f, 0.01310477f, 
    0.01534477f, 0.02319192f, 0.03342737f, -0.04802406f, -0.01911215f, -0.01388802f, 0.00440774f, -0.05374952f, 
    -0.04312405f, 0.01217170f, -0.03277034f, 0.00049541f, -0.04549544f, 0.04739022f, 0.01188758f, 0.00765408f, 
    0.00449860f, -0.05385541f, 0.00610017f, 0.04564143f, -0.04017949f, -0.03037469f, -0.05422176f, 0.00304679f, 
    -0.04380396f, 0.00924472f, -0.03741187f, 0.01535442f, -0.00170662f, 0.03749636f, 0.01103085f, -0.00111241f, 
    -0.01256382f, -0.01832586f, -0.03065413f, 0.01887140f, 0.00996466f, -0.00603104f, -0.03644775f, -0.03831372f, 
    0.03884505f, -0.00805874f, -0.01733568f, 0.00179020f, -0.04219048f, 0.03745058f, 0.03089906f, 0.04703656f, 
    0.00617458f, -0.04683861f, -0.05161511f, 0.00805222f, -0.04693269f, 0.04284814f, 0.00828939f, -0.00604570f, 
    0.00509784f, 0.00948577f, 0.02907407f, -0.01549362f, -0.02616643f, -0.02425776f, 0.03171796f, -0.01529200f, 
    -0.01269284f, -0.05648595f, 0.00975537f, -0.01588687f, -0.04217832f, 0.00278215f, -0.04663499f, -0.03984536f, 
    -0.03735526f, 0.02939340f, -0.02679902f, -0.04744042f, 0.00669999f, 0.03262461f, 0.01241835f, -0.03228759f, 
    -0.04826249f, 0.00148149f, 0.04708768f, -0.06103329f, 0.03461001f, -0.02909449f, -0.04885170f, 0.00268454f, 
    -0.05485846f, -0.04275066f, -0.05145631f, 0.03830969f, -0.03427133f, 0.01579111f, 0.01189946f, -0.01856470f, 
    -0.04151219f, -0.01277940f, -0.03004000f, -0.04427470f, 0.00871226f, -0.04133036f, 0.02892296f, -0.03539562f, 
    0.00013920f, 0.04440594f, 0.01927766f, 0.00945421f, -0.05429630f, -0.00478491f, 0.00386312f, -0.00206001f, 
    -0.01873632f, -0.03857090f, -0.02273370f, -0.04564170f, 0.03461193f, -0.06224907f, -0.01395254f, 0.00932067f, 
    0.01364956f, 0.02061205f, -0.04384546f, -0.03639811f, -0.03810622f, -0.06289150f, 0.02581877f, -0.04351402f, 
    0.03526150f, -0.05009219f, -0.02867489f, 0.02188258f, 0.02168020f, -0.01809297f, -0.02391455f, -0.04502353f, 
    0.01547065f, 0.03193142f, -0.02182121f, 0.03315213f, -0.04280172f, 0.02964453f, 0.00328654f, -0.02300865f, 
    0.06081101f, 0.01009167f, 0.00975138f, 0.01735437f, 0.03035362f, -0.03868749f, -0.05733585f, -0.04076943f, 
    0.04195784f, 0.03282319f, 0.01486492f, 0.00380259f, -0.05912852f, 0.00217278f, -0.05433308f, 0.04468316f, 
    -0.24592511f, 0.28288883f, 0.18797992f, 0.16508713f, 0.39714736f, -0.06546687f, 0.14730109f, 0.06361181f, 
    0.00213122f, 0.10065074f, 0.04311278f, 0.03395389f, -0.06468986f, 0.01321699f, 0.03410388f, 0.07175506f, 
    -0.04024554f, -0.06265066f, 0.04417308f, -0.01853397f, -0.46322131f, -0.01172499f, -0.29516423f, -0.09097219f, 
    0.13470621f, -0.05681856f, 0.08023346f, 0.19466136f, 0.09889799f, 0.12803049f, -0.02073768f, 0.10243057f, 
    0.09910078f, -0.00605861f, 0.01764135f, -0.08012902f, 0.09446869f, 0.07599571f, -0.12205321f, -0.00811849f, 
    0.22897181f, 0.20752162f, 0.41387257f, 0.21831360f, 0.33336055f, 0.03871332f, 0.13591370f, 0.18859278f, 
    0.10175730f, 0.06191447f, 0.07676517f, -0.11577737f, -0.01010071f, -0.10261849f, 0.00723558f, 0.15829001f, 
    0.04898361f, -0.17047213f, 0.03604385f, 0.00596055f, -0.09107561f, -0.08362736f, 0.52421224f, -0.11093035f, 
    0.21441533f, -0.02035593f, 0.15940829f, -0.11606769f, 0.07062824f, -0.02836138f, -0.05436566f, -0.08977894f, 
    -0.00315826f, 0.13206176f, 0.02981049f, -0.13404140f, 0.03697877f, -0.01434113f, 0.06888361f, -0.00449741f, 
    -0.23019993f, -0.26854596f, -0.44504037f, 0.01817180f, -0.01238646f, -0.01458565f, 0.04553833f, -0.17930850f, 
    0.14106472f, -0.10988317f, 0.03416919f, -0.09196606f, -0.10641348f, 0.05023612f, -0.09889188f, -0.01814184f, 
    0.07540347f, 0.03044145f, 0.16824107f, 0.10834619f, 0.12012835f, 0.07695892f, 0.24396101f, 0.05958157f, 
    0.20223531f, 0.00733722f, -0.06472778f, 0.03635897f, 0.02947069f, -0.05016056f, -0.04140481f, -0.04632951f, 
    0.01665175f, -0.01016972f, 0.09468333f, 0.03516481f, 0.05306425f, 0.09254532f, 0.02807446f, -0.00197613f, 
    0.07110335f, -0.10767697f, 0.11341830f, 0.01576206f, -0.07841467f, 0.01581054f, 0.02206607f, 0.02652951f, 
    -0.10363504f, -0.17862827f, -0.03640718f, 0.02034067f, 0.10542296f, -0.15695713f, 0.02523763f, 0.03313776f, 
    -0.09757576f, -0.22160760f, 0.00628862f, -0.11419586f, 0.21501720f, 0.11764760f, -0.00021671f, 0.03960636f, 
    -0.08890476f, 0.09908163f, 0.04732904f, 0.13054894f, -0.00573435f, -0.02003477f, -0.02651840f, 0.08957934f, 
    0.00026218f, 0.16622381f, 0.02359868f, 0.11832896f, 0.28039461f, 0.08556353f, -0.03947943f, -0.15198800f, 
    -0.27576232f, -0.29323408f, -0.20114623f, -0.08888454f, 0.15014854f, 0.10757860f, 0.02881595f, -0.03887770f, 
    0.08772388f, -0.04059178f, -0.05604238f, -0.00145813f, -0.01078639f, 0.03510288f, 0.07137129f, 0.00251953f, 
    -0.13404024f, 0.01413217f, -0.01975153f, 0.03668189f, 0.17404494f, -0.26541543f, 0.22355138f, -0.47505173f, 
    0.03782670f, -0.13969685f, -0.14850345f, -0.14751227f, -0.05615020f, -0.18958017f, -0.04530713f, -0.12025767f, 
    0.00412992f, 0.02844674f, 0.07635918f, -0.00464294f, -0.00063558f, -0.14756210f, 0.11098636f, -0.03001740f, 
    -0.02047043f, 0.09545317f, -0.14084230f, 0.16015917f, 0.13964078f, -0.01176662f, 0.00216739f, -0.02176423f, 
    0.03109065f, 0.00274148f, -0.04102475f, -0.07011894f, 0.05901682f, -0.14494917f, -0.00111020f, -0.08257927f, 
    -0.13419265f, -0.00113425f, -0.19845964f, -0.12710750f, 0.26887944f, 0.13600691f, -0.36909980f, 0.31596741f, 
    -0.00450699f, -0.02472578f, 0.10354567f, 0.00312002f, -0.08351238f, 0.01768417f, 0.08307613f, -0.01866551f, 
    0.08225631f, 0.09411503f, -0.01928338f, 0.10997908f, 0.14786117f, 0.15508950f, -0.01382790f, 0.05390115f, 
    0.47856361f, 0.15249009f, -0.15697518f, -0.29573664f, 0.20609507f, -0.11516593f, 0.10818905f, 0.11077628f, 
    0.09766750f, 0.12384279f, 0.03573796f, 0.02900265f, -0.00099225f, -0.05675883f, 0.03317313f, 0.03191793f, 
    0.06525031f, -0.02838273f, 0.10468691f, 0.01053071f, 0.04003454f, 0.07454935f, 0.14879805f, -0.07017669f, 
    0.04034641f, 0.06663002f, -0.03445793f, 0.10938356f, 0.12242163f, 0.06233625f, 0.00638465f, 0.01075309f, 
    0.10307709f, -0.04183155f, 0.01564492f, -0.05292785f, 0.08288671f, -0.00429094f, 0.01470763f, -0.15605955f, 
    -0.29979327f, 0.05149486f, -0.35424754f, 0.05355909f, 0.14903159f, -0.04444142f, -0.00372645f, -0.11991202f, 
    -0.04514645f, 0.05619855f, -0.00641601f, -0.09483373f, 0.00020689f, -0.01284145f, 0.08372217f, -0.05140190f, 
    0.01090661f, 0.26892880f, -0.13558741f, 0.09393772f, 0.07572737f, 0.08389141f, -0.19547796f, -0.03134633f, 
    0.15962809f, 0.09076573f, -0.05127246f, -0.03567026f, -0.03921211f, -0.00735158f, -0.20664582f, -0.04412032f, 
    -0.03134643f, -0.04838710f, 0.02135770f, -0.07349490f, 0.06568600f, 0.01479781f, 0.03336406f, -0.10285193f, 
    -0.18765573f, 0.09628925f, 0.22056672f, 0.16303009f, -0.05799066f, -0.14816512f, 0.14765404f, 0.13987948f, 
    -0.01552299f, 0.05797391f, -0.04372524f, -0.04172979f, -0.00166856f, -0.14918366f, 0.01558364f, -0.15789703f, 
    -0.03521953f, -0.21753050f, 0.00833818f, -0.07811409f, -0.33424255f, 0.06141366f, -0.17525016f, 0.02419183f, 
    -0.01741107f, -0.03409410f, 0.17061792f, 0.17559995f, 0.11826594f, 0.04109625f, -0.07113316f, 0.18230227f, 
    0.16178817f, -0.02997663f, -0.12473560f, -0.07244134f, -0.04742859f, 0.10236310f, -0.02160422f, 0.02300080f, 
    0.15353385f, 0.16714087f, 0.46688884f, 0.16043819f, -0.30244938f, 0.06596638f, 0.10771777f, -0.06419950f, 
    -0.07014034f, -0.19334279f, -0.08095670f, -0.12903607f, 0.03953202f, 0.04561896f, -0.02529709f, -0.12007784f, 
    -0.05683240f, -0.24837913f, -0.13457730f, -0.17926952f, -0.17002790f, -0.06678811f, 0.34463283f, 0.16116667f, 
    0.09187932f, 0.01197171f, 0.01105482f, 0.10971928f, 0.02051407f, 0.18808061f, 0.02213802f, 0.03979431f, 
    0.03101613f, 0.15086573f, -0.01204669f, -0.00256919f, 0.11942153f, -0.01721586f, -0.01478014f, 0.06175709f, 
    -0.32229975f, -0.01835958f, -0.00435269f, -0.20407052f, 0.03102517f, 0.21039034f, 0.20564622f, -0.02239634f, 
    0.13090864f, 0.11579821f, 0.01426305f, 0.00846540f, -0.03964823f, -0.04272966f, -0.05240652f, -0.19842324f, 
    -0.08630087f, -0.00935390f, 0.28981286f, 0.11927705f, 0.24473104f, 0.19353996f, 0.05754854f, 0.05624606f, 
    0.25047928f, -0.15995641f, -0.06927706f, 0.18710168f, 0.07803750f, 0.00867709f, -0.03335649f, -0.02986087f, 
    0.01858616f, 0.10252564f, 0.07755774f, 0.14555597f, 0.04009573f, 0.15918405f, 0.00909159f, -0.02396631f, 
    0.22589032f, 0.09915796f, 0.07628426f, 0.10726283f, 0.11283202f, 0.02693135f, 0.04986225f, 0.02627532f, 
    -0.01138496f, 0.06556983f, 0.09465076f, 0.12547310f, 0.06234604f, -0.04675841f, 0.10638142f, -0.20796022f, 
    -0.12832071f, -0.16236740f, -0.05947148f, -0.02516055f, 0.13829005f, 0.00281484f, 0.08312649f, 0.07283449f, 
    0.11379988f, 0.18188676f, -0.04097218f, 0.03568222f, 0.05678773f, 0.11905933f, 0.06229190f, 0.12433960f, 
    -0.03269224f, 0.17184016f, 0.07958337f, 0.02249792f, 0.17126718f, 0.07777382f, -0.04451692f, 0.00969661f, 
    -0.20316955f, -0.03066890f, -0.04602567f, 0.05041527f, -0.09363977f, -0.05151429f, -0.10120450f, 0.15724675f, 
    -0.08648670f, 0.12354747f, -0.17150003f, 0.01342623f, -0.02551258f, 0.07065130f, 0.06386087f, -0.10711375f, 
    -0.14809880f, -0.05015396f, 0.00624489f, 0.06113793f, 0.28689390f, -0.10832897f, 0.03689957f, 0.00220123f, 
    0.14784335f, -0.34459984f, -0.15086401f, 0.04594096f, -0.03480110f, -0.05260302f, 0.02558352f, 0.00913773f, 
    -0.02561518f, -0.00277822f, -0.01774885f, 0.22726139f, 0.09737398f, -0.17227833f, -0.01643328f, -0.18479545f, 
    0.01612228f, -0.05118731f, -0.01035360f, 0.10368947f, 0.08806166f, -0.09287984f, 0.06290107f, -0.01192456f, 
    -0.02918027f, -0.17412002f, -0.09573361f, -0.15438920f, 0.04998477f, -0.22269683f, -0.21957523f, 0.11887659f, 
    -0.06710616f, 0.12260658f, -0.29707929f, 0.01875502f, 0.35912490f, 0.02231589f, -0.06306729f, 0.10972272f, 
    -0.28389499f, -0.03281688f, 0.00186292f, 0.08955547f, -0.13308802f, 0.03577322f, 0.02820444f, -0.19395663f, 
    0.08943034f, 0.07962196f, -0.06447136f, -0.17850229f, 0.31008586f, 0.00755479f, -0.14297612f, 0.01286059f, 
    0.04838290f, -0.02746726f, 0.07179070f, 0.09359656f, 0.16864978f, -0.14238004f, 0.15761524f, 0.09257779f, 
    0.10798605f, 0.01261127f, 0.21292484f, -0.02391636f, 0.06768507f, 0.04751185f, 0.12665802f, 0.08775272f, 
    0.07567278f, -0.07944856f, 0.03072223f, -0.02431604f, 0.03673131f, 0.08291148f, 0.07964379f, 0.09844910f, 
    0.06342921f, 0.09954017f, 0.00907872f, 0.16499454f, 0.11948555f, 0.08795945f, -0.02574798f, 0.04582153f, 
    0.02173147f, 0.01519748f, -0.00791234f, -0.12465377f, -0.05338977f, 0.02756287f, 0.02542044f, -0.08438004f, 
    -0.21855026f, 0.16966344f, 0.02564462f, 0.03476577f, 0.09328800f, -0.03030041f, -0.06147974f, 0.04762577f, 
    -0.11012521f, 0.07656413f, -0.13291252f, -0.15493511f, 0.03627197f, -0.18427914f, 0.01184528f, 0.02711289f, 
    0.05149156f, 0.11427504f, -0.07756004f, 0.01081698f, -0.17271706f, 0.11267386f, -0.13547878f, 0.30653226f, 
    -0.08254863f, 0.00537094f, -0.04426208f, -0.13284357f, -0.07541458f, -0.25077948f, -0.14296633f, -0.10477440f, 
    -0.07522970f, -0.05636891f, -0.07851206f, 0.06614649f, 0.12333576f, 0.24893028f, -0.01631687f, -0.09109092f, 
    -0.05815034f, -0.04538156f, 0.01882952f, 0.01624410f, -0.02472268f, -0.02637932f, 0.01354657f, 0.02672215f, 
    -0.01841956f, 0.01868834f, -0.03064954f, -0.02657299f, -0.04343301f, -0.00246574f, -0.04253836f, 0.03027524f, 
    0.04018554f, -0.04746559f, 0.04643378f, -0.03662056f, 0.03569257f, -0.03634991f, 0.00502884f, 0.01395473f, 
    0.02943184f, 0.04577555f, -0.03522656f, -0.00583278f, 0.04084748f, 0.04718328f, -0.02198739f, -0.05722612f, 
    0.04248564f, 0.04490991f, 0.02108268f, -0.04491941f, 0.03398682f, 0.04368261f, -0.06150103f, -0.02050728f, 
    -0.03940362f, -0.00743316f, -0.05109406f, -0.00163546f, 0.02828579f, -0.06316252f, 0.02817103f, -0.03757332f, 
    -0.00504793f, -0.05446440f, -0.05032174f, -0.01681257f, 0.01724051f, -0.05534739f, -0.03822936f, -0.03370109f, 
    -0.05170377f, 0.01107797f, -0.06354801f, 0.03985198f, 0.03823451f, -0.05593571f, -0.01631581f, -0.06227863f, 
    -0.05964452f, -0.03329041f, -0.04195935f, -0.04538622f, -0.04112091f, -0.04033255f, -0.04561121f, 0.02481472f, 
    -0.04978064f, -0.03001645f, -0.04310634f, -0.02656352f, 0.04347045f, -0.05398535f, -0.02167841f, -0.05483001f, 
    -0.03139311f, -0.00582328f, -0.01254244f, -0.03470418f, -0.04796520f, 0.04220283f, 0.04643266f, -0.01842476f, 
    -0.06263611f, -0.04934779f, 0.02810656f, -0.02861594f, 0.04787124f, -0.01215971f, 0.00233214f, -0.04922228f, 
    0.03763554f, -0.00755717f, 0.01348940f, -0.01683040f, 0.02803374f, 0.00354562f, -0.03910149f, -0.00736718f, 
    0.00534500f, 0.02866009f, 0.00972919f, 0.02318615f, -0.00067255f, -0.04202529f, -0.03917535f, 0.04040695f, 
    -0.01449065f, -0.00437408f, 0.04016357f, -0.03955313f, 0.03079170f, 0.01396416f, -0.06174387f, -0.04957713f, 
    -0.02578964f, 0.01875929f, 0.01207517f, 0.00524364f, -0.05314806f, -0.01624689f, 0.04510542f, -0.01219116f, 
    0.03697656f, 0.03054120f, -0.03553289f, -0.03308145f, -0.04134396f, -0.04708781f, -0.03098627f, 0.04137773f, 
    0.03970469f, -0.02313279f, 0.01275829f, -0.05824850f, 0.04357764f, -0.02728663f, 0.02279282f, -0.01499185f, 
    -0.06299733f, 0.04042495f, 0.01064032f, -0.00671540f, 0.03574150f, -0.00593438f, -0.01413931f, -0.04055613f, 
    -0.00928905f, 0.02327532f, -0.00345015f, -0.03424664f, -0.02296145f, -0.00779784f, -0.03326338f, -0.02768458f, 
    -0.04249937f, 0.02423326f, 0.03517945f, -0.02036133f, -0.03546495f, -0.01104247f, -0.04498748f, 0.02676673f, 
    -0.00562260f, 0.01723045f, 0.00037622f, -0.00716068f, 0.02290409f, -0.01211139f, -0.00758607f, -0.01451903f, 
    -0.04261253f, 0.00804112f, 0.02473258f, -0.04468560f, -0.03835838f, 0.04014808f, -0.00472777f, -0.05001610f, 
    0.04513141f, 0.02791107f, 0.03389847f, -0.03642690f, 0.00571438f, -0.02142578f, -0.05139751f, 0.02627420f, 
    -0.05543269f, -0.00387961f, 0.04256843f, -0.05170418f, 0.04027295f, -0.01939072f, -0.02308640f, -0.06055035f, 
    0.03641399f, 0.03273508f, 0.04274770f, -0.01210426f, 0.01406244f, -0.04054931f, -0.05053363f, 0.00926957f, 
    0.01706135f, -0.04952672f, 0.00624401f, -0.04688764f, -0.04548392f, -0.01351776f, -0.03462138f, 0.02337492f, 
    -0.03379447f, -0.02907051f, -0.05171866f, -0.05794484f, -0.05197683f, -0.01998776f, -0.05745197f, -0.00083813f, 
    -0.00749372f, -0.00399888f, 0.03836047f, 0.01098251f, -0.03809352f, 0.01544956f, 0.00040908f, 0.01163796f, 
    0.01663136f, -0.05525471f, -0.00401176f, 0.01097908f, -0.03586668f, -0.05911232f, -0.00622090f, -0.02183550f, 
    0.01148224f, -0.05172143f, 0.02542063f, -0.00655623f, 0.03827174f, -0.00435014f, 0.00730412f, 0.01655236f, 
    0.01536288f, -0.04699347f, -0.03863806f, 0.02979254f, 0.00956643f, -0.00313012f, -0.04364917f, -0.03723212f, 
    -0.02799547f, 0.03510513f, 0.00794727f, -0.05911598f, -0.02172606f, -0.03399045f, 0.04214678f, -0.05847165f, 
    0.02527833f, 0.00026242f, 0.00600889f, -0.04367805f, -0.00086451f, -0.05958259f, -0.04745091f, -0.04385789f, 
    0.04507751f, -0.00960661f, -0.05961683f, 0.02668788f, 0.02975391f, -0.05142599f, -0.04330974f, -0.00408760f, 
    -0.05262185f, -0.02132333f, 0.02399786f, -0.00965013f, 0.04184291f, -0.02045712f, -0.00735137f, -0.02650799f, 
    0.00660982f, -0.00740596f, 0.02231741f, -0.00621962f, -0.03290764f, -0.01449880f, 0.00493254f, -0.00014294f, 
    -0.00696749f, 0.02703442f, 0.03414290f, -0.01555122f, 0.01166172f, 0.00488327f, 0.02202268f, -0.06308503f, 
    -0.03604134f, 0.00805343f, -0.04432881f, -0.02910541f, 0.01897462f, 0.03640605f, 0.04512052f, -0.00861380f, 
    0.03604213f, 0.02246921f, -0.05618436f, -0.04619775f, -0.03541506f, -0.00200372f, 0.03598337f, 0.02081066f, 
    -0.00649982f, 0.01940932f, -0.03540786f, -0.05467320f, -0.05073117f, 0.01784384f, -0.05899560f, -0.05570394f, 
    -0.05347946f, 0.04851380f, -0.04338615f, 0.03972917f, 0.01019392f, 0.02886454f, -0.04094205f, -0.01758653f, 
    -0.00649241f, 0.04282770f, 0.02124203f, 0.01618060f, -0.00821180f, -0.02824018f, -0.02776739f, -0.01443011f, 
    0.02307231f, 0.03660379f, -0.01540410f, -0.02911251f, -0.01243864f, 0.01927412f, -0.02244374f, -0.01542000f, 
    -0.01457092f, -0.01998467f, 0.01384316f, -0.05927608f, -0.03562465f, 0.01330097f, -0.05598532f, 0.03588812f, 
    -0.05754231f, 0.04418488f, 0.03330369f, 0.02723240f, -0.03949494f, -0.01555960f, 0.04996697f, 0.03318098f, 
    0.04376082f, -0.03171532f, -0.06050664f, -0.04999581f, -0.02919066f, -0.03933114f, 0.00889948f, 0.03214084f, 
    0.00651896f, -0.04338178f, 0.02523698f, 0.02925597f, 0.04100237f, 0.00659772f, 0.03725379f, -0.05001824f, 
    0.03852703f, -0.02733625f, -0.03828253f, -0.00261186f, 0.01265494f, -0.03374484f, 0.01279303f, 0.03924383f, 
    -0.04277398f, 0.00907166f, -0.00919843f, 0.00254293f, 0.04321384f, -0.00848952f, 0.02282048f, -0.04487953f, 
    -0.04551051f, -0.05009522f, 0.03147785f, -0.05385253f, -0.03634250f, 0.00871944f, 0.01601174f, -0.00439681f, 
    -0.04567255f, -0.03732481f, -0.01950177f, -0.01616683f, 0.00527777f, -0.03780098f, -0.05972317f, 0.00349094f, 
    0.00785661f, 0.02662238f, 0.02352201f, 0.00253368f, -0.01879164f, -0.02793775f, -0.01358206f, -0.01490622f, 
    -0.05288746f, 0.02042615f, 0.01282536f, -0.06165861f, -0.05370095f, -0.03359892f, 0.03183942f, 0.02048034f, 
    -0.03132698f, 0.03200845f, -0.00799863f, -0.01987702f, 0.01820208f, -0.04451849f, 0.00705808f, -0.02709983f, 
    -0.00365880f, -0.00729120f, -0.01656619f, -0.04715267f, 0.04660875f, 0.04504652f, 0.04550013f, -0.02094146f, 
    0.01042444f, 0.00405955f, -0.03426949f, 0.02500193f, -0.04748682f, -0.01780320f, -0.05898286f, -0.06146526f, 
    -0.01377275f, 0.01758507f, -0.05768066f, 0.01977857f, 0.02380371f, -0.00366233f, 0.03892399f, -0.01884604f, 
    -0.01348840f, -0.04987452f, -0.04985169f, -0.00503300f, 0.03216879f, 0.02169457f, -0.04771727f, -0.06270996f, 
    -0.00687778f, -0.05132162f, -0.04072143f, 0.04792649f, 0.01130280f, -0.02851266f, 0.01984801f, 0.02196909f, 
    0.02562770f, -0.03872664f, 0.01267526f, -0.03538902f, 0.04834884f, 0.01938711f, 0.05034792f, -0.03271780f, 
    0.01084928f, -0.03928963f, -0.04557472f, -0.05115851f, 0.02234737f, -0.05175169f, -0.03360765f, -0.00099689f, 
    -0.04750098f, -0.05324824f, -0.00900770f, -0.00541343f, -0.05143395f, 0.02813605f, -0.03239032f, -0.04215365f, 
    0.04561086f, 0.04699192f, -0.00618732f, -0.05010045f, -0.03728352f, 0.02660071f, -0.03656517f, -0.04268413f, 
    0.04291250f, 0.00430910f, -0.05433796f, -0.01854713f, -0.03055942f, 0.00393927f, -0.03007881f, -0.03110660f, 
    0.00617190f, -0.04936861f, 0.03594682f, -0.03894532f, -0.03148963f, 0.02716659f, 0.03864909f, -0.02117636f, 
    -0.03174970f, -0.02536637f, 0.03612095f, -0.01486470f, 0.00320788f, 0.02189143f, -0.02569556f, 0.01917501f, 
    -0.04978427f, 0.01561567f, 0.03273211f, 0.01216887f, 0.01585238f, -0.05998027f, 0.03722014f, -0.04021345f, 
    -0.00525032f, -0.03444101f, 0.00395966f, -0.01300040f, -0.00553932f, -0.00580703f, 0.04773562f, 0.00149945f, 
    -0.03210038f, 0.04153886f, 0.02642533f, -0.00496694f, -0.04707040f, -0.05001763f, 0.04888113f, -0.04937390f, 
    0.01080798f, 0.00616181f, -0.06021870f, 0.04267210f, -0.04298577f, 0.01600256f, -0.00609636f, 0.01872437f, 
    -0.01557206f, -0.01315655f, 0.00035708f, -0.04880483f, -0.01642014f, 0.00246646f, -0.03088962f, 0.03268795f, 
    0.01618126f, -0.02885212f, 0.01554636f, -0.05081870f, 0.02625562f, 0.02191764f, -0.03081508f, 0.00119188f, 
    -0.00138791f, -0.00410443f, 0.01522175f, 0.02272678f, -0.00564830f, -0.03625093f, 0.01361510f, 0.02479379f, 
    -0.01347592f, 0.02178385f, 0.01385707f, 0.00590715f, -0.05500347f, -0.02785562f, -0.03594851f, -0.01477641f, 
    -0.03865381f, 0.03737547f, 0.04793377f, -0.06067883f, -0.00108207f, -0.04821596f, -0.01803825f, -0.02841284f, 
    0.02794936f, -0.00222552f, -0.01223991f, -0.03660306f, -0.05394812f, 0.00901278f, -0.03553330f, 0.03449262f, 
    -0.04454233f, -0.04079391f, 0.01496880f, -0.00891979f, -0.01533665f, -0.02060565f, 0.01756009f, 0.04670032f, 
    0.01234987f, -0.01951276f, -0.04797692f, 0.04444503f, 0.03087615f, 0.01061659f, 0.00125183f, 0.00725773f, 
    -0.04778049f, -0.04075458f, 0.01070967f, -0.01527132f, -0.00947057f, 0.02068977f, 0.04055401f, -0.00825471f, 
    -0.02788144f, 0.00849305f, -0.00001693f, 0.03459146f, -0.01329617f, -0.00078547f, 0.03915022f, -0.02006049f, 
    -0.03495284f, -0.07359012f, 0.01122765f, -0.06545822f, -0.03453602f, -0.05249947f, -0.03630126f, -0.02391161f, 
    -0.00773700f, -0.02399731f, -0.06093530f, -0.04915165f, 0.01772737f, 0.01860791f, 0.02117562f, -0.03118145f, 
    -0.05379624f, -0.05227148f, 0.01357704f, 0.00814376f, -0.04404534f, 0.04547947f, 0.01073825f, 0.01919097f, 
    0.01438683f, -0.00805610f, -0.03018382f, 0.04414888f, 0.04191394f, -0.03315981f, 0.04076351f, -0.03743580f, 
    -0.03230326f, 0.01081016f, -0.05536304f, -0.04703488f, -0.03284723f, -0.01601512f, 0.02515079f, -0.04980119f, 
    0.03328053f, -0.07062788f, 0.02267969f, 0.00172122f, -0.00767907f, -0.00049088f, 0.02411970f, 0.02232892f, 
    -0.05441518f, -0.01265559f, -0.04810592f, -0.03376693f, 0.00982554f, -0.00769950f, -0.04195981f, -0.05004539f, 
    0.03393338f, -0.01841087f, -0.01408058f, -0.03993028f, -0.05763122f, -0.05477999f, 0.00095190f, -0.00999070f, 
    0.03741919f, -0.06325879f, -0.02060121f, -0.02891575f, 0.03183819f, 0.00326922f, 0.02020227f, 0.01939487f, 
    -0.02591746f, -0.05636721f, -0.01763970f, -0.00137898f, -0.02591634f, 0.03301085f, -0.00371407f, 0.01138769f, 
    -0.04823644f, -0.07338214f, -0.00466366f, 0.02719039f, 0.00264152f, 0.02676534f, 0.01837539f, -0.03407221f, 
    -0.04538416f, -0.03407836f, -0.01089938f, -0.04872839f, -0.01560657f, -0.04172287f, -0.02139850f, -0.04610172f, 
    0.01181744f, -0.06481330f, -0.03232280f, -0.05656069f, 0.00521014f, -0.02095083f, -0.05851125f, 0.01896028f, 
    -0.05070100f, -0.02046011f, -0.01682006f, -0.05866699f, -0.02610665f, 0.03990264f, 0.03551644f, 0.04761720f, 
    0.02390434f, -0.04482384f, 0.02587150f, -0.06116232f, -0.07766125f, 0.01866057f, -0.05149604f, 0.03517876f, 
    -0.03223792f, -0.03880956f, 0.03803543f, -0.00378553f, 0.03147108f, -0.05415136f, -0.00495418f, -0.04451708f, 
    0.00711231f, 0.01140022f, -0.04615652f, 0.02624669f, 0.01752194f, -0.02813217f, 0.02328911f, 0.02985735f, 
    -0.02058944f, -0.04289204f, 0.01671444f, 0.03617453f, -0.05996649f, 0.00416889f, 0.02542061f, 0.01971443f, 
    -0.07279732f, -0.04916406f, -0.04263645f, 0.02505456f, 0.01650416f, 0.02819272f, -0.03574697f, -0.03821331f, 
    -0.01075573f, 0.01650109f, -0.02563219f, -0.02938810f, -0.05248369f, -0.05993539f, -0.00543976f, 0.01087653f, 
    0.02227169f, -0.04723445f, -0.01211010f, 0.02753836f, -0.02419694f, -0.02582186f, -0.06774613f, -0.00430657f, 
    -0.01339810f, 0.03497933f, 0.03542152f, -0.05514194f, -0.01107412f, 0.05740150f, -0.05769924f, -0.02595799f, 
    0.01046304f, -0.04971990f, 0.00117242f, 0.00982403f, -0.05678172f, -0.06977168f, 0.00242905f, 0.01577041f, 
    -0.02181387f, 0.03049599f, 0.01219492f, -0.04793065f, -0.06312888f, 0.00155955f, 0.01529503f, -0.02685189f, 
    0.05504199f, -0.03846800f, 0.01800406f, 0.01704983f, 0.02572639f, -0.05891554f, -0.00367463f, -0.04672555f, 
    -0.06263892f, -0.01913737f, 0.01144571f, -0.00548127f, -0.06088036f, 0.01137462f, -0.01843733f, -0.02018323f, 
    -0.04626279f, -0.02585633f, 0.01922938f, 0.02089923f, -0.03323443f, 0.02060792f, 0.00109866f, 0.01408674f, 
    -0.02770807f, 0.01669233f, -0.03630671f, 0.01100336f, -0.01173286f, -0.02540658f, -0.02961433f, -0.05506053f, 
    -0.05162463f, 0.04142185f, -0.00128118f, -0.04658325f, -0.04051557f, -0.03504215f, -0.01732890f, -0.06961312f, 
    0.01825021f, 0.01338207f, -0.04759996f, -0.01809070f, 0.03296469f, -0.00043933f, 0.00990558f, -0.01811771f, 
    -0.02994798f, -0.01361090f, -0.06361572f, 0.03234873f, -0.03428779f, -0.07154812f, 0.01392796f, -0.01669143f, 
    0.02629413f, -0.03836150f, -0.01234029f, 0.03966731f, -0.02675596f, 0.04113887f, -0.02639107f, -0.01072790f, 
    -0.00488245f, -0.05804360f, 0.00755803f, -0.04554403f, 0.00852192f, -0.06010612f, -0.00233272f, -0.04247253f, 
    -0.02854079f, -0.01448614f, 0.02652922f, -0.00395805f, -0.05817782f, -0.06320196f, -0.00046492f, -0.00586079f, 
    0.00193009f, 0.00872536f, 0.02452879f, -0.05371303f, 0.03291031f, -0.08395643f, -0.07515807f, 0.00464505f, 
    -0.04875827f, -0.01773572f, -0.02680372f, -0.04343789f, -0.02100459f, -0.00175806f, 0.04140294f, -0.06668518f, 
    -0.05921905f, 0.01555098f, 0.03714778f, -0.02789249f, -0.00618046f, -0.05222198f, 0.02113177f, -0.04640080f, 
    0.02810805f, 0.01411109f, 0.00008290f, -0.03459179f, -0.04715997f, -0.00670523f, -0.00165777f, 0.02505425f, 
    0.00117858f, -0.00345847f, -0.04133763f, 0.02116486f, 0.02270030f, -0.03497965f, 0.00982860f, -0.01575108f, 
    -0.10038310f, 0.06869903f, -0.01346078f, -0.13029827f, -0.07765029f, 0.05953732f, -0.00783973f, -0.09191199f, 
    0.07465545f, -0.01476589f, 0.05947755f, 0.12237954f, 0.05701062f, -0.12528317f, -0.04673543f, -0.10167103f, 
    -0.06770434f, 0.03023406f, -0.04852068f, -0.01737032f, 0.05333956f, -0.10866158f, -0.05075214f, 0.01714799f, 
    -0.14080435f, 0.06823628f, -0.01583222f, -0.07487340f, 0.08421589f, 0.10557222f, -0.01876365f, 0.08485528f, 
    0.05104541f, 0.05709432f, -0.05194715f, 0.05844355f, 0.06383707f, 0.03746245f, 0.08003373f, 0.02082323f, 
    -0.14048527f, 0.12783721f, -0.16922660f, -0.07996324f, -0.01257425f, 0.24965383f, -0.06290332f, 0.10026561f, 
    -0.04985555f, 0.15546925f, -0.03399893f, 0.03840622f, -0.10062046f, 0.04770032f, 0.00589951f, -0.23048335f, 
    -0.17907612f, 0.08964237f, -0.05106193f, -0.00849595f, 0.50129968f, -0.01723600f, -0.09323192f, -0.03352137f, 
    0.00239368f, 0.07967062f, 0.08739015f, 0.13084002f, -0.05502326f, 0.07933757f, -0.01549744f, 0.06231129f, 
    0.05988893f, -0.04124866f, -0.01071970f, 0.09013086f, -0.02285235f, 0.09652658f, -0.03493400f, 0.05998576f, 
    -0.30042809f, -0.31383565f, 0.17601494f, 0.07692388f, 0.12078877f, 0.29015693f, 0.22732975f, 0.24827619f, 
    0.10664234f, -0.11036316f, 0.05505843f, -0.03181795f, 0.08344350f, 0.00921826f, 0.02023892f, -0.01045717f, 
    0.03291257f, -0.03482246f, 0.06339311f, 0.02840464f, 0.14016034f, -0.23970361f, 0.16118962f, -0.11063780f, 
    0.06300496f, -0.09260526f, 0.05063361f, -0.13449651f, -0.00687503f, -0.02503343f, -0.02688443f, -0.03269601f, 
    -0.02348158f, 0.01804289f, -0.04786716f, -0.02757973f, -0.09841511f, 0.01775332f, 0.06073952f, 0.11308165f, 
    0.02224365f, -0.02865556f, -0.04825300f, -0.03467266f, -0.12343756f, 0.03191674f, -0.16257195f, -0.09377995f, 
    -0.09705673f, -0.13002858f, -0.06357690f, 0.00030889f, -0.14220110f, -0.01888506f, 0.01343063f, -0.15010568f, 
    -0.13792495f, 0.05424694f, 0.01513175f, -0.04607667f, -0.08156584f, 0.06035095f, 0.11210679f, 0.01735287f, 
    0.02353362f, -0.05081145f, -0.04284810f, -0.08522184f, 0.06419131f, -0.04228155f, -0.01361047f, -0.01175715f, 
    0.08202650f, 0.04945393f, -0.08644965f, -0.08065128f, -0.04890853f, 0.15748593f, 0.10725840f, 0.07075278f, 
    -0.02037524f, -0.14394532f, -0.14563446f, 0.23567155f, 0.17262830f, -0.01462517f, 0.08443535f, 0.12902042f, 
    -0.07548610f, -0.09112261f, 0.07102883f, 0.00020906f, 0.01577415f, 0.09029206f, 0.00690197f, 0.03452886f, 
    0.03388856f, -0.08923088f, 0.03613729f, 0.03901852f, -0.11716440f, -0.22091751f, 0.12159544f, 0.00777860f, 
    -0.06403988f, 0.05636152f, 0.06549965f, 0.02492300f, 0.00448448f, -0.01473372f, 0.01709735f, 0.03516852f, 
    0.03501460f, -0.00715021f, -0.02719786f, -0.07413766f, -0.06096775f, -0.07678629f, 0.03404444f, -0.03586033f, 
    -0.27439803f, -0.07205062f, 0.29809567f, 0.28641510f, -0.05646351f, 0.00824800f, -0.01804148f, 0.08639753f, 
    0.07736240f, -0.07831143f, -0.09509386f, -0.01673899f, -0.11235651f, -0.02309334f, 0.11859543f, 0.20984936f, 
    0.16872594f, -0.04055753f, 0.01742644f, -0.06557595f, -0.15935750f, 0.23889901f, 0.06192162f, 0.06250181f, 
    0.23477992f, 0.07199403f, 0.04243436f, 0.03891886f, 0.29554179f, 0.11398353f, 0.00121585f, 0.05910958f, 
    -0.05211892f, -0.07007653f, 0.04912832f, 0.09957644f, -0.10491467f, 0.00812709f, 0.16456425f, 0.21630278f, 
    0.09541324f, -0.13788502f, -0.00516370f, 0.13060677f, -0.11177317f, 0.08683375f, -0.08603025f, -0.00476953f, 
    -0.04758196f, 0.17768458f, -0.11561582f, 0.18878257f, -0.03796916f, 0.06687518f, -0.07715187f, -0.05477930f, 
    -0.01017963f, 0.22287206f, -0.04405517f, -0.02257240f, 0.00090447f, 0.03356439f, 0.00365271f, -0.24306166f, 
    -0.14030613f, 0.05195282f, -0.09274660f, -0.02476912f, -0.04698594f, -0.08752085f, -0.01946247f, 0.15026744f, 
    0.03743298f, 0.02176817f, -0.04320610f, -0.05375183f, -0.02100726f, -0.02513985f, -0.04503408f, 0.03997132f, 
    -0.14618923f, -0.02764940f, -0.15650389f, 0.24092416f, 0.06763087f, -0.00282803f, 0.14415078f, 0.00812712f, 
    0.06453712f, -0.04964880f, 0.07509965f, -0.03392136f, -0.04446434f, -0.01158628f, 0.05742937f, -0.00288775f, 
    -0.04380579f, -0.07540942f, 0.02854825f, 0.03058793f, 0.00093519f, -0.04068057f, 0.04921399f, 0.02005470f, 
    0.13526100f, -0.11860981f, 0.18371151f, 0.01366469f, 0.15954715f, -0.00202772f, -0.04863647f, 0.02619751f, 
    -0.12987089f, 0.01392045f, -0.03665556f, 0.12603024f, -0.06529132f, 0.01812140f, 0.18375728f, -0.03161037f, 
    -0.31459156f, 0.33973587f, 0.30885702f, 0.17535745f, -0.32392865f, -0.00896262f, 0.02657183f, -0.13241395f, 
    0.02393612f, -0.02278273f, -0.00421882f, 0.08569714f, 0.04507536f, -0.01666416f, -0.07400004f, -0.05061848f, 
    0.02040289f, 0.05736587f, 0.02392923f, 0.08521426f, -0.38363206f, 0.05625121f, 0.13486199f, 0.12922810f, 
    -0.10908984f, -0.11869206f, 0.01066918f, 0.00292536f, -0.06967328f, 0.03547719f, -0.04490568f, 0.18066010f, 
    0.13608576f, 0.00393841f, 0.00754545f, -0.04076360f, 0.04404509f, -0.05776688f, -0.11508013f, 0.11118535f, 
    -0.14170888f, 0.34009790f, 0.33758688f, 0.10355566f, -0.33019453f, 0.25383535f, 0.03767429f, 0.02969761f, 
    -0.09090032f, 0.04991829f, 0.05348544f, 0.02198661f, 0.01455339f, 0.00234221f, 0.00122328f, 0.07468783f, 
    -0.04516926f, -0.03354541f, 0.11440923f, 0.14039731f, 0.27866495f, -0.22958317f, 0.33168158f, -0.10282278f, 
    0.01026416f, 0.10861482f, 0.09176666f, 0.00773232f, 0.03191281f, 0.16723070f, -0.11838660f, 0.02107568f, 
    -0.08870307f, -0.00052281f, -0.02321509f, -0.03198732f, 0.08556662f, -0.04353876f, 0.07738991f, 0.03453407f, 
    -0.32952690f, -0.14003865f, 0.06485622f, 0.00636841f, 0.02191264f, -0.07534292f, 0.13279380f, 0.03821082f, 
    0.08071512f, 0.02504517f, -0.00522035f, -0.12819073f, -0.14638473f, 0.10377627f, -0.08592049f, 0.00052210f, 
    -0.03514180f, -0.11730740f, -0.19548017f, -0.15299204f, 0.62145048f, 0.01550802f, 0.02448900f, 0.07666431f, 
    0.13473319f, -0.07564285f, -0.00850324f, -0.06776921f, 0.04927432f, -0.01168990f, -0.03182397f, 0.05119512f, 
    -0.07416166f, -0.02957553f, 0.01238797f, 0.08729248f, -0.02377746f, 0.20146236f, 0.14541550f, 0.10933764f, 
    0.16867234f, -0.04794322f, 0.01111791f, 0.06691316f, 0.13195744f, 0.00350276f, -0.04126916f, -0.03389499f, 
    -0.15311672f, -0.07527512f, -0.01256878f, 0.10881534f, -0.05211690f, 0.03147246f, 0.00795126f, -0.03822722f, 
    -0.04497569f, -0.09514939f, -0.02620893f, -0.11307422f, 0.32167256f, 0.02020857f, -0.04018868f, 0.04960534f, 
    0.04456065f, 0.06264163f, -0.00174112f, 0.03898693f, 0.04953818f, -0.02319068f, -0.10977642f, 0.05042574f, 
    0.02362906f, -0.02921266f, -0.05849668f, -0.06172203f, 0.01687094f, 0.01772871f, -0.01793465f, -0.11648773f, 
    -0.00187713f, -0.03811160f, 0.02088897f, 0.05364440f, -0.02743502f, 0.10261243f, -0.05730697f, -0.11515466f, 
    -0.03026798f, 0.07588383f, -0.06552130f, 0.05722512f, -0.08168861f, 0.14378546f, 0.09467176f, -0.00162168f, 
    -0.04874652f, -0.04773683f, 0.03893103f, 0.03173171f, 0.50366986f, -0.16353446f, -0.10199474f, -0.11840636f, 
    0.01942263f, 0.07304483f, -0.06789872f, 0.07480720f, -0.00210976f, 0.01828282f, -0.10874514f, -0.01468954f, 
    -0.06402925f, 0.02788739f, -0.02097092f, -0.09606291f, -0.01709508f, -0.13499950f, 0.08234883f, 0.08446182f, 
    -0.29056409f, -0.11461762f, 0.05303757f, 0.38811418f, 0.09781936f, 0.05128999f, 0.06329814f, 0.12905799f, 
    0.02087893f, -0.17475775f, 0.01124800f, -0.01504381f, 0.18836187f, -0.00298091f, 0.18854190f, -0.03177807f, 
    0.04992409f, -0.12578903f, -0.16254111f, -0.02580067f, 0.32851741f, 0.48175228f, 0.05807641f, 0.07871981f, 
    -0.44282496f, 0.00072197f, 0.02871392f, -0.21528974f, 0.26195771f, 0.01675310f, -0.04363194f, -0.00338321f, 
    0.04151980f, -0.02908938f, 0.05866126f, 0.00202598f, 0.17553629f, 0.15655963f, 0.20890133f, 0.10126296f, 
    -0.13071528f, -0.30530488f, 0.19835420f, -0.03554243f, 0.32584193f, 0.02891905f, -0.06048737f, 0.01689087f, 
    0.00811512f, 0.13483953f, 0.01713657f, 0.04785613f, 0.01935660f, -0.01208110f, -0.00211645f, 0.11515865f, 
    0.06679013f, 0.03793747f, -0.09469210f, -0.00864659f, -0.04961307f, -0.04990980f, 0.09992523f, 0.03791471f, 
    -0.06177158f, 0.10579976f, -0.00811615f, 0.03456230f, -0.08313490f, 0.01855609f, -0.05145329f, 0.08243383f, 
    -0.02421735f, -0.05736611f, -0.10006582f, -0.03992520f, -0.13683550f, 0.00818949f, -0.03003716f, -0.13689369f, 
    -0.35857219f, 0.26016951f, -0.02735585f, 0.26473361f, 0.00479959f, 0.07576789f, 0.00586269f, -0.19747578f, 
    0.09592534f, -0.03210547f, 0.03761881f, 0.02074014f, 0.01061195f, 0.06402744f, 0.11304845f, 0.03578521f, 
    0.01269900f, 0.06939768f, 0.05168211f, 0.03897340f, -0.42263383f, 0.09000785f, 0.14368582f, 0.15765373f, 
    0.05073967f, -0.06782370f, 0.08413798f, 0.01492553f, -0.03291503f, -0.01060021f, -0.08065520f, -0.00194096f, 
    0.07677639f, -0.04257761f, 0.09391614f, 0.19608845f, -0.07076458f, 0.07373777f, 0.30891454f, 0.04726192f, 
    0.04828010f, 0.03087033f, -0.02757006f, 0.02665996f, 0.03945842f, -0.00145290f, -0.01091659f, -0.02115533f, 
    -0.02642195f, -0.04238172f, -0.06134214f, -0.00593576f, 0.03896381f, -0.03415433f, 0.00730031f, -0.05233073f, 
    -0.05550152f, -0.01715740f, -0.05997001f, 0.02871066f, 0.04791287f, -0.00678105f, -0.04570820f, 0.00874879f, 
    0.01192169f, -0.04705503f, 0.02205005f, -0.02834050f, -0.02026241f, 0.04723457f, 0.03130683f, -0.00482645f, 
    -0.00281520f, 0.02525077f, 0.01945102f, 0.05000254f, -0.01737081f, -0.00478856f, -0.06074960f, -0.00593960f, 
    -0.03088303f, -0.06017170f, -0.03762222f, 0.04503063f, -0.00004479f, -0.04111412f, 0.00854542f, -0.03957938f, 
    -0.02426977f, -0.01060332f, -0.02625406f, -0.05041042f, 0.00617617f, 0.04187479f, 0.04376230f, 0.04540522f, 
    0.02452472f, -0.03909132f, 0.03171478f, -0.05279365f, -0.02633009f, -0.05532568f, -0.01808561f, 0.03885020f, 
    0.02806768f, -0.00201622f, 0.01648819f, 0.00257884f, -0.00854905f, 0.00797694f, -0.00051663f, 0.00185242f, 
    0.01846533f, -0.00712906f, -0.03681312f, -0.06027548f, -0.00030782f, -0.00411265f, 0.02119347f, -0.01237947f, 
    -0.02640843f, 0.04830429f, 0.01045385f, 0.03100245f, -0.05181088f, -0.01577837f, -0.00794467f, 0.00314621f, 
    -0.05112073f, 0.01206401f, 0.04689084f, -0.04060833f, -0.02964651f, -0.04460168f, 0.03380932f, 0.02078536f, 
    0.01200896f, 0.00285063f, -0.01553413f, -0.02584636f, 0.02390631f, -0.05701957f, -0.03923355f, -0.02778413f, 
    -0.01312230f, -0.00781903f, 0.00322807f, -0.04533191f, 0.01173367f, -0.00116907f, -0.01439478f, 0.01340852f, 
    -0.04432034f, -0.01924734f, 0.04104888f, 0.04056246f, -0.04106100f, -0.02450686f, -0.04595751f, -0.05700178f, 
    0.02375049f, -0.01886014f, 0.01081993f, -0.05535842f, -0.01938319f, -0.01209668f, -0.01587094f, -0.02549536f, 
    -0.03027981f, 0.03860008f, 0.03651379f, -0.03215027f, 0.04984925f, 0.02303231f, 0.01614152f, -0.04877466f, 
    -0.00008180f, -0.04523248f, -0.00051929f, 0.02163995f, -0.01232701f, 0.03792514f, -0.03665619f, 0.02831101f, 
    -0.05491058f, 0.04397539f, -0.06147495f, -0.03344681f, -0.00800401f, 0.00326697f, -0.02236181f, 0.01346335f, 
    0.03707624f, -0.05784442f, 0.04655819f, -0.04026423f, 0.01968531f, 0.04802779f, -0.05771957f, -0.05236641f, 
    -0.02894829f, -0.05252487f, -0.04271818f, 0.03516492f, 0.01700196f, -0.02846820f, -0.04034046f, 0.01380503f, 
    -0.01586954f, -0.01129173f, 0.01504046f, 0.03626702f, 0.01071214f, 0.04848205f, 0.03203733f, -0.02439421f, 
    0.03384324f, 0.03532762f, 0.01972411f, -0.05239983f, 0.00990188f, -0.05434916f, 0.03160201f, -0.00104589f, 
    -0.05007066f, -0.05211657f, -0.03716333f, -0.04493875f, -0.00866646f, -0.01302846f, 0.02556202f, -0.00323475f, 
    -0.02017268f, -0.04000825f, -0.03150805f, -0.02203975f, 0.03495265f, 0.01739812f, -0.05755761f, -0.00085004f, 
    -0.00201814f, 0.04394668f, 0.03535672f, -0.00782788f, -0.02344845f, 0.03935706f, 0.00034813f, -0.03767233f, 
    0.00973277f, 0.03775000f, 0.04109340f, 0.01255755f, 0.00341159f, 0.02173620f, -0.04806487f, 0.00219845f, 
    -0.03500131f, -0.05007219f, 0.01828918f, -0.02167343f, 0.02224497f, 0.01133618f, -0.02462787f, -0.00227718f, 
    0.04831577f, -0.03612788f, -0.05034773f, 0.00401625f, -0.05804415f, -0.04876866f, -0.04331277f, -0.04923296f, 
    -0.02532108f, -0.01018187f, 0.05439144f, 0.01973272f, -0.03317499f, 0.00663742f, 0.00533859f, -0.02242731f, 
    0.00667019f, -0.03269948f, 0.00331832f, -0.04625881f, 0.00169410f, 0.02235630f, 0.03324278f, 0.03249812f, 
    -0.05647984f, -0.05047789f, -0.03286700f, 0.02344879f, 0.03699935f, 0.04084731f, 0.01711581f, 0.02396442f, 
    0.01894278f, -0.06069798f, -0.04401289f, 0.04713427f, -0.05940068f, 0.02325482f, 0.01233861f, -0.01187380f, 
    -0.02008196f, -0.05805226f, -0.02938126f, 0.00853970f, 0.03095255f, -0.01704720f, 0.04850470f, -0.06011232f, 
    0.00977449f, 0.01290170f, -0.05559277f, -0.00646878f, -0.02886861f, 0.02909111f, -0.05789299f, -0.05644182f, 
    -0.01295064f, -0.02501107f, -0.04790303f, 0.04702163f, 0.03664259f, -0.01316759f, -0.03265574f, -0.05867327f, 
    -0.03891723f, -0.02726087f, -0.04893633f, -0.06110723f, 0.02677040f, -0.02069288f, 0.00357426f, -0.03410119f, 
    0.04341070f, -0.04851681f, -0.05306196f, 0.00063384f, 0.00053306f, -0.00171220f, 0.04544663f, 0.00501888f, 
    0.01589336f, 0.01933848f, -0.00023493f, -0.04024423f, 0.01030455f, 0.02825431f, -0.00660743f, 0.02361033f, 
    0.01394926f, -0.03559432f, 0.02632191f, -0.03011661f, 0.04659469f, -0.01080300f, -0.03972191f, 0.00851292f, 
    -0.02380361f, 0.34863997f, 0.50003946f, 0.21654370f, 0.55053610f, -0.02007871f, 0.01728879f, 0.21860166f, 
    -0.04711301f, 0.03043658f, -0.01338791f, 0.07722063f, 0.02873912f, 0.06995595f, 0.13442688f, 0.10865269f, 
    0.00515842f, -0.08918876f, -0.01202072f, 0.07095705f, 0.02963077f, 0.46051681f, 0.38925356f, 0.12634064f, 
    0.33346468f, -0.09692562f, -0.12251350f, 0.10511424f, 0.03285710f, -0.11229478f, -0.09437928f, -0.02529564f, 
    -0.06368115f, -0.13234076f, 0.03380654f, -0.18115640f, -0.07485861f, 0.08917832f, -0.14338158f, -0.24341449f, 
    -0.09258446f, -0.09022018f, 0.48979020f, 0.17503266f, 0.43197143f, 0.05236272f, 0.11281128f, 0.04548740f, 
    0.07813340f, 0.16486965f, 0.07467629f, -0.03575579f, 0.11151452f, 0.13038470f, 0.23620629f, -0.01094204f, 
    0.30594626f, 0.03023971f, 0.03390169f, 0.09461629f, -0.24273965f, -0.10179895f, -0.01995952f, -0.08518636f, 
    0.20323583f, -0.04275098f, 0.13326176f, -0.07898319f, 0.05673326f, -0.06565244f, -0.04639935f, -0.11665913f, 
    -0.02445015f, -0.07840638f, 0.00863614f, 0.14274068f, 0.00623764f, -0.07071199f, -0.09836516f, -0.16828766f, 
    0.12831123f, -0.19196483f, -0.46996218f, -0.00763281f, 0.03587439f, 0.21526276f, -0.02573172f, -0.15231346f, 
    -0.16770086f, -0.01462250f, 0.25247872f, 0.12949394f, -0.01027942f, -0.17953831f, -0.11609920f, -0.18240619f, 
    -0.39385089f, -0.40398028f, -0.12879539f, -0.10646450f, 0.04290141f, -0.09538702f, 0.19570407f, -0.04081168f, 
    0.13017619f, -0.09174081f, 0.04616882f, 0.05460137f, 0.08489539f, 0.01483966f, -0.00821772f, -0.04713041f, 
    -0.11862702f, -0.01336716f, -0.00831912f, 0.05212453f, 0.12340824f, 0.24723831f, 0.02006892f, 0.07753926f, 
    -0.12438495f, -0.24683981f, -0.29012966f, -0.52320421f, -0.03806918f, 0.18764456f, -0.12828849f, 0.10481978f, 
    0.21061149f, 0.01349068f, 0.02975465f, -0.15395156f, 0.23042808f, -0.07826490f, -0.04250965f, 0.07279450f, 
    -0.04568906f, -0.34805989f, -0.19685411f, -0.10843094f, -0.01190616f, -0.10440671f, 0.06184417f, -0.22332431f, 
    0.01310442f, 0.09497982f, -0.02390441f, 0.09422195f, -0.05900478f, 0.03165136f, -0.14499599f, -0.08376028f, 
    -0.15760666f, 0.00801691f, -0.06964219f, 0.05151968f, -0.13458617f, -0.05772344f, -0.12124388f, -0.28277418f, 
    -0.21747261f, -0.16547844f, 0.01118155f, -0.08756395f, 0.05169101f, -0.02960589f, 0.14984769f, 0.02355745f, 
    0.09599456f, 0.01605092f, -0.01889655f, 0.05684950f, -0.00384722f, -0.07426399f, -0.03963103f, -0.03658244f, 
    -0.10558661f, 0.00407420f, 0.12573192f, 0.07251202f, 0.14619732f, -0.01226665f, 0.32076126f, -0.13460252f, 
    0.39062524f, -0.16228035f, -0.00792450f, 0.04277234f, 0.06395209f, -0.05618739f, -0.07615524f, -0.18270126f, 
    0.02475907f, -0.17518832f, -0.08104684f, 0.12641332f, 0.14473929f, 0.21844612f, 0.08835258f, 0.19488372f, 
    -0.18049763f, 0.03806495f, -0.30388573f, 0.00757083f, 0.09402592f, -0.08040570f, 0.10878637f, 0.00715281f, 
    -0.11464833f, 0.15201661f, -0.08505275f, -0.01223827f, -0.03416414f, -0.02767812f, -0.12755926f, 0.05692823f, 
    0.13339463f, 0.21413065f, -0.00274408f, 0.27722797f, -0.11151855f, 0.22393090f, -0.01849141f, 0.18284556f, 
    -0.21024826f, -0.11213936f, 0.10926634f, -0.12226247f, -0.09251636f, -0.05562757f, -0.06806298f, 0.02224067f, 
    0.07222173f, 0.10659724f, -0.00315724f, 0.03227801f, 0.13020170f, 0.12861368f, 0.12748106f, 0.06538835f, 
    0.20506187f, -0.06547108f, -0.57446229f, -0.17715083f, 0.25079927f, 0.00336772f, 0.02140057f, -0.06447338f, 
    -0.07334483f, 0.00128931f, 0.07009509f, -0.05055841f, 0.04301495f, -0.09840766f, -0.03743690f, 0.06130820f, 
    -0.03038448f, -0.18383205f, -0.01180687f, -0.13230923f, 0.14756863f, 0.09482872f, 0.42914742f, 0.18411005f, 
    0.30937722f, -0.10360213f, -0.16808513f, -0.10037786f, 0.09816086f, -0.00671923f, -0.02195913f, -0.01942502f, 
    -0.02498289f, 0.03717483f, -0.04632464f, -0.16222316f, -0.11047126f, -0.11782683f, -0.13244392f, -0.31756884f, 
    -0.15315863f, -0.02669156f, -0.12426082f, -0.07802682f, -0.05607383f, -0.07097729f, 0.05737546f, -0.12623401f, 
    -0.02956793f, 0.06082829f, 0.04097904f, 0.07639831f, 0.04102715f, 0.02810326f, 0.04471774f, 0.05206697f, 
    0.08948903f, 0.12892270f, 0.10574041f, 0.22448753f, 0.30172646f, -0.39807814f, -0.34789205f, 0.01372276f, 
    -0.04584126f, -0.01368649f, -0.00508562f, -0.10789289f, 0.01905699f, 0.18847695f, -0.14347738f, -0.12479724f, 
    0.04280164f, 0.12994517f, 0.16288880f, 0.07034486f, 0.33501425f, 0.13879362f, 0.00242607f, 0.29172775f, 
    0.00733278f, 0.04685323f, 0.05431091f, -0.00598190f, 0.03609719f, -0.01105241f, -0.01228992f, -0.06231460f, 
    -0.02652742f, 0.01859500f, -0.00187735f, -0.02493218f, -0.00880461f, 0.02716293f, 0.04024533f, 0.00140735f, 
    -0.02455912f, -0.04359045f, 0.03098222f, -0.01180529f, -0.05471867f, 0.02580568f, -0.00786216f, -0.02633923f, 
    -0.01492854f, 0.00228270f, 0.00663972f, -0.06515443f, -0.00090348f, -0.03177150f, 0.03932018f, 0.00074534f, 
    -0.01642586f, -0.00031400f, 0.00093941f, 0.04226124f, 0.00785030f, -0.05162067f, 0.04800594f, 0.01830231f, 
    -0.06693246f, 0.03084263f, -0.01005483f, 0.04893668f, -0.00985451f, -0.02217773f, -0.00522024f, -0.05532237f, 
    0.03987889f, -0.03823233f, 0.02155404f, -0.04733301f, 0.01281365f, -0.03218497f, -0.03514827f, -0.00147641f, 
    0.03386187f, -0.04549838f, 0.01133039f, -0.05921239f, 0.00070292f, 0.04293492f, 0.02673917f, -0.06042892f, 
    0.01650068f, -0.00572337f, -0.01398385f, 0.03980816f, 0.02922605f, -0.01277148f, 0.03946130f, -0.00518109f, 
    -0.06264127f, 0.00527881f, 0.00640181f, 0.00504569f, -0.02415803f, 0.04344059f, 0.01270017f, -0.04951824f, 
    -0.02207856f, -0.06977269f, 0.04523175f, -0.02561112f, -0.00258954f, 0.00478809f, 0.01956858f, -0.03991995f, 
    -0.05015488f, -0.04356034f, 0.03999511f, -0.03134349f, 0.02065114f, 0.04017236f, -0.00273807f, -0.02349444f, 
    -0.01455947f, 0.04082438f, 0.01231029f, 0.01419730f, 0.00580869f, -0.04805607f, -0.05085249f, -0.01372003f, 
    -0.00328966f, -0.03908621f, -0.02468991f, -0.04582125f, 0.03615116f, -0.02864004f, 0.02521348f, -0.03169099f, 
    -0.04386010f, 0.04523040f, -0.02178010f, -0.04904468f, -0.01178154f, -0.04440821f, 0.04218702f, 0.01417991f, 
    0.01270588f, 0.04303066f, 0.03703255f, -0.00044934f, 0.02544210f, 0.01302772f, -0.01523089f, 0.05133468f, 
    -0.03672191f, -0.05833910f, -0.00278144f, -0.02611658f, -0.05285421f, -0.06283114f, -0.06019839f, 0.03433091f, 
    -0.01990379f, -0.01662614f, -0.03578416f, -0.02315830f, 0.03765697f, -0.05796071f, -0.02529508f, -0.02567598f, 
    -0.04696350f, 0.00085615f, -0.03396982f, -0.00723594f, 0.04814895f, 0.00741625f, -0.03622018f, -0.02801265f, 
    0.01147876f, 0.02684223f, 0.04920719f, -0.04089908f, -0.05124320f, 0.00761911f, -0.03203310f, 0.00051299f, 
    -0.00002596f, -0.00737323f, 0.00189807f, 0.00112102f, -0.01515159f, -0.01203260f, -0.06539942f, -0.03583319f, 
    0.02851673f, -0.05968058f, 0.01991485f, -0.01555577f, -0.03432595f, -0.05975432f, -0.00834717f, -0.04521549f, 
    -0.01494820f, 0.03899615f, -0.03750235f, 0.04595110f, -0.00226083f, 0.03320248f, 0.01465626f, 0.02165222f, 
    0.04128728f, -0.03432830f, 0.04389634f, -0.01669346f, -0.01012457f, 0.02055929f, 0.04860761f, 0.00212770f, 
    -0.04557717f, -0.01610820f, 0.01215472f, 0.03189421f, -0.02424939f, -0.05851407f, 0.04097469f, -0.04354624f, 
    -0.05419877f, -0.02725051f, 0.01106459f, -0.05165020f, -0.03532361f, -0.02138709f, 0.04236202f, 0.02376097f, 
    0.02357994f, -0.04897918f, 0.02080431f, 0.04056573f, -0.00262966f, 0.02287394f, -0.05393083f, -0.06009060f, 
    -0.05902323f, -0.06162670f, -0.01783418f, 0.01083297f, -0.02833134f, -0.06328688f, -0.02465814f, -0.04277813f, 
    -0.01346181f, 0.00387570f, 0.01478534f, -0.02829195f, 0.02715623f, -0.06405878f, 0.02959029f, -0.03124733f, 
    0.00449679f, 0.04324803f, 0.01325891f, -0.03653095f, -0.02751555f, 0.02674137f, 0.02103622f, 0.00672648f, 
    -0.06540398f, -0.06344899f, 0.00790279f, -0.01756564f, -0.04186955f, -0.01826635f, -0.01832636f, -0.04716726f, 
    0.03150373f, -0.04405788f, -0.04900020f, 0.00664506f, 0.02232260f, -0.05287266f, 0.00847566f, -0.00369166f, 
    0.00847548f, 0.02975515f, 0.03022312f, 0.03485148f, 0.00287450f, -0.04884755f, 0.00134832f, -0.01117628f, 
    0.03749720f, 0.03643699f, -0.03739271f, 0.02058654f, 0.01508666f, 0.04370479f, -0.00504948f, -0.01956970f, 
    0.00368140f, 0.01318298f, 0.03832424f, 0.00772722f, 0.02369313f, -0.05483346f, -0.03763609f, 0.02789414f, 
    -0.01493640f, -0.00468409f, -0.05417005f, -0.04170046f, -0.00709819f, 0.03498859f, 0.03579547f, 0.02847577f, 
    0.05241942f, -0.04486092f, -0.03004444f, -0.04242954f, 0.04727577f, 0.03657106f, 0.02315628f, -0.02392442f, 
    0.00485449f, -0.01795772f, -0.03624902f, -0.00332896f, 0.03545818f, -0.06329089f, 0.03478375f, 0.04952378f, 
    -0.00200748f, 0.02407654f, -0.03177286f, -0.00547427f, -0.03593466f, 0.02757237f, 0.03174388f, 0.04539481f, 
    -0.03011985f, 0.03600512f, -0.02923942f, 0.04896932f, -0.02677233f, -0.03332788f, -0.01541385f, -0.03499022f, 
    0.07427657f, -0.11501095f, 0.32784113f, 0.20700884f, 0.05024682f, -0.32628450f, -0.15965287f, -0.12082079f, 
    0.00422285f, 0.01219072f, 0.07379100f, -0.00600645f, 0.19336225f, 0.17876443f, 0.15699083f, 0.01625833f, 
    -0.06125522f, 0.01102512f, 0.04357045f, -0.01289898f, -0.00017563f, 0.04463025f, -0.10009232f, 0.01841224f, 
    -0.10835175f, -0.13637346f, -0.17570826f, -0.20820476f, -0.11772668f, 0.06730238f, 0.25044549f, 0.01224730f, 
    0.18266211f, 0.11276177f, 0.14847079f, 0.05084508f, -0.03077162f, -0.07581624f, -0.00217234f, -0.15483297f, 
    -0.05360330f, -0.10704108f, 0.19775483f, 0.08741476f, 0.09486105f, 0.06649893f, 0.02256564f, -0.11913364f, 
    0.22581317f, 0.34266829f, -0.01412116f, -0.00870153f, -0.00534766f, 0.11503635f, -0.02518485f, -0.00728182f, 
    0.13307305f, 0.10958114f, 0.09092066f, 0.10619398f, -0.11009375f, 0.39967039f, -0.19100323f, -0.12014077f, 
    0.17539845f, 0.00562310f, -0.17782563f, 0.00645086f, 0.02659274f, -0.10531060f, 0.27889067f, 0.07448979f, 
    0.02559159f, 0.00791761f, 0.01043395f, -0.03870811f, 0.11103641f, 0.00296357f, 0.16089453f, 0.02705292f, 
    -0.16789551f, -0.31988865f, -0.10336826f, 0.16891624f, -0.17062019f, 0.23561557f, -0.07002290f, -0.02218036f, 
    0.01624913f, 0.14800619f, -0.04090244f, 0.07389373f, 0.03901845f, 0.03009830f, -0.02952857f, -0.10697779f, 
    -0.05222365f, -0.14234295f, -0.20098096f, -0.45736521f, -0.11899816f, 0.12658553f, -0.32855743f, -0.00311838f, 
    -0.02651907f, -0.06093340f, 0.09042215f, 0.25974542f, 0.04916297f, -0.02023317f, 0.12341850f, 0.01661907f, 
    0.05948573f, 0.05456263f, 0.03755830f, 0.03137653f, 0.15092801f, -0.07011871f, 0.05017878f, 0.15843837f, 
    0.22644095f, 0.36137727f, 0.18064742f, -0.04259510f, 0.03071295f, -0.03939314f, 0.05478147f, -0.01850141f, 
    0.05140613f, -0.01547124f, 0.11416067f, -0.12018842f, 0.21120161f, -0.00618826f, -0.09014719f, 0.21603848f, 
    0.03409959f, 0.01512561f, -0.01186708f, 0.06493659f, 0.06934141f, 0.19101822f, 0.05208596f, -0.04977097f, 
    0.08998571f, 0.17308812f, 0.25916699f, 0.23010655f, -0.08037548f, -0.00205118f, 0.16088821f, 0.03953603f, 
    0.06042196f, -0.03598618f, -0.07587468f, 0.10552592f, -0.16410404f, 0.21796660f, 0.00412431f, 0.03935847f, 
    -0.22289841f, -0.06049649f, -0.03780963f, 0.07684743f, 0.06493443f, -0.03483877f, -0.03082351f, -0.11629657f, 
    0.07575097f, 0.00207984f, -0.01368190f, 0.01329190f, -0.01128323f, -0.12202387f, -0.07978611f, -0.09842550f, 
    -0.05960158f, -0.19674246f, -0.02704989f, -0.01220734f, -0.12984715f, 0.03458431f, -0.51146102f, 0.00147063f, 
    -0.05228751f, -0.13576728f, 0.14136678f, 0.27106321f, 0.06366660f, 0.00731834f, 0.09189706f, 0.03585851f, 
    0.02020945f, 0.05839822f, -0.03222838f, -0.05967192f, 0.10879170f, -0.00980318f, 0.07774313f, 0.01278854f, 
    -0.15638845f, -0.22069222f, -0.04451033f, 0.05959370f, 0.13215604f, -0.13016488f, 0.09982789f, -0.23046078f, 
    0.06918403f, 0.04940642f, -0.05770066f, -0.05696087f, -0.10565424f, 0.14275099f, -0.09326765f, -0.09137860f, 
    0.07744295f, -0.10246383f, 0.14745486f, 0.10317912f, 0.09301339f, -0.17010145f, 0.12064850f, -0.38428605f, 
    0.12149216f, 0.00707300f, -0.02531858f, 0.19706549f, -0.19884898f, -0.03412393f, 0.05930181f, 0.11311271f, 
    0.05087723f, -0.09594266f, -0.04288819f, -0.06679875f, 0.37538221f, 0.11799674f, -0.22664300f, -0.11765445f, 
    0.20751329f, 0.32704586f, -0.46561164f, -0.02760246f, 0.02694383f, 0.08179433f, 0.59864676f, -0.22375928f, 
    -0.08372911f, -0.05226370f, 0.31477961f, -0.02516643f, 0.05237534f, 0.00880550f, -0.05120561f, 0.14275883f, 
    -0.01191595f, -0.11254582f, 0.02821725f, 0.02749688f, 0.05119946f, 0.15002182f, 0.23976645f, 0.03205717f, 
    0.04447433f, -0.01027831f, 0.02902973f, -0.15400101f, -0.02287081f, -0.09166606f, 0.21869692f, -0.10152629f, 
    0.27677697f, 0.19761044f, 0.19811198f, 0.14729246f, -0.00431674f, -0.06088942f, 0.00845655f, -0.08178660f, 
    -0.08307900f, -0.19506778f, 0.16423182f, 0.01996322f, 0.02902199f, -0.18916950f, -0.01653691f, 0.07953097f, 
    -0.06200735f, 0.03196787f, -0.02733463f, 0.02522704f, -0.00886447f, -0.02576948f, -0.06552131f, 0.01470298f, 
    0.06494191f, 0.09061426f, -0.02275321f, -0.10246893f, 0.08926461f, -0.27301708f, -0.51829869f, 0.07029088f, 
    -0.08192679f, 0.23516442f, -0.10895983f, 0.09651205f, 0.08222794f, 0.18726039f, 0.08828561f, -0.13382411f, 
    -0.04726797f, 0.36084095f, 0.30640095f, -0.33134753f, 0.03514466f, 0.33923972f, 0.05426195f, -0.01036473f, 
    0.08521456f, -0.07037933f, 0.02894395f, 0.12764759f, -0.32258454f, 0.09307086f, -0.18687169f, 0.16247721f, 
    0.14902006f, 0.09275820f, 0.01123008f, -0.04455064f, 0.05081836f, 0.00630576f, 0.04710039f, -0.00848955f, 
    -0.00973712f, 0.00166309f, -0.00215372f, -0.04496419f, 0.14899565f, -0.00845629f, -0.08292233f, 0.03192262f, 
    -0.08208431f, 0.11103305f, -0.01859653f, -0.17921303f, 0.12050272f, -0.00919965f, 0.21055914f, 0.07840861f, 
    0.05299306f, -0.00372301f, 0.03000045f, -0.00011428f, 0.04753742f, 0.07776824f, 0.00767366f, 0.15050355f, 
    0.10512850f, -0.01912142f, 0.09828570f, 0.20231637f, -0.01828642f, -0.02896910f, -0.17853659f, -0.04757616f, 
    0.02046566f, -0.00684726f, 0.09042966f, -0.02750530f, 0.05396004f, 0.05081318f, 0.09314484f, 0.07536918f, 
    -0.04576232f, 0.07663761f, 0.07396583f, -0.06426135f, -0.31623548f, 0.42420605f, -0.33280775f, 0.15755725f, 
    -0.12682253f, 0.04974277f, -0.12580386f, 0.00770124f, -0.22750978f, 0.04079149f, 0.13798921f, 0.01322176f, 
    -0.04767185f, 0.02693242f, 0.00474119f, 0.21847709f, 0.11129764f, -0.01771193f, 0.09593202f, 0.11177891f, 
    -0.02359552f, -0.30177617f, -0.19140618f, -0.25423467f, -0.19434004f, 0.02838611f, 0.01180489f, 0.05638058f, 
    0.16215712f, -0.18923877f, 0.03959037f, -0.10653429f, -0.15325724f, -0.04256355f, -0.07061099f, -0.03626597f, 
    0.07306612f, 0.04274288f, 0.18392602f, 0.20782670f, -0.15533733f, 0.06306992f, -0.17328995f, 0.17547151f, 
    -0.00994785f, 0.02683373f, -0.02843219f, 0.12174193f, -0.05542330f, 0.02403051f, 0.07147992f, -0.00641987f, 
    0.00723766f, 0.01813321f, -0.03795734f, -0.02964471f, -0.02858740f, 0.01016162f, 0.11295556f, 0.05288465f, 
    -0.24996305f, -0.17674209f, -0.04217944f, -0.06060329f, -0.04667141f, -0.24392627f, -0.16687828f, -0.13619408f, 
    -0.12533621f, -0.26755491f, -0.08082129f, 0.07987506f, 0.05092996f, 0.07515873f, 0.03451867f, -0.02551420f, 
    -0.01519016f, 0.09299635f, 0.03310150f, 0.03793991f, -0.07772697f, -0.09499668f, 0.01916875f, -0.07745543f, 
    0.08851311f, -0.05022745f, 0.00851953f, -0.06377030f, -0.08990914f, -0.06402782f, 0.00977785f, -0.06424741f, 
    0.04717904f, -0.11623190f, -0.02404826f, 0.05424707f, 0.12756971f, -0.12922987f, -0.05786982f, 0.07701899f, 
    -0.11988927f, -0.05496043f, -0.22533770f, -0.06110803f, -0.23140596f, 0.07889142f, 0.06859776f, 0.17480624f, 
    -0.07562496f, 0.13902377f, -0.00617529f, 0.14646560f, 0.05700139f, 0.02217859f, 0.00773710f, 0.02569301f, 
    -0.04932122f, 0.10614251f, 0.01419072f, 0.15401609f, -0.45738336f, 0.06135634f, -0.09339076f, 0.07564975f, 
    -0.07559541f, 0.10131348f, 0.01870464f, -0.02981591f, 0.05042847f, 0.02742036f, -0.05946232f, -0.01119355f, 
    -0.02260599f, 0.00768041f, -0.11370230f, 0.01595513f, -0.07125429f, 0.04844704f, -0.08108599f, -0.17552480f, 
    -0.18141243f, -0.18674998f, -0.04119250f, 0.02861173f, -0.36069670f, 0.01546508f, -0.04431751f, -0.03352005f, 
    0.27765647f, 0.06712660f, -0.01188629f, -0.02209193f, -0.04649847f, -0.00112234f, 0.09232631f, -0.07383639f, 
    0.10159073f, -0.08762964f, 0.13052540f, 0.04847313f, 0.07262719f, 0.03309279f, -0.10379204f, 0.06561913f, 
    -0.06695582f, 0.21231623f, 0.00869413f, 0.24001671f, -0.11008027f, 0.32175925f, 0.08337282f, 0.15236661f, 
    0.01880981f, -0.02136867f, 0.15566586f, 0.01080723f, 0.04621341f, 0.03092484f, 0.01562618f, 0.13563025f, 
    -0.15031654f, 0.23685056f, -0.52903485f, 0.34976259f, -0.15862493f, 0.03730446f, 0.00244793f, 0.00919206f, 
    -0.05738813f, 0.07525005f, 0.14885496f, -0.04339369f, -0.14645694f, -0.01068010f, -0.08523873f, -0.11245609f, 
    0.15785836f, 0.09111765f, 0.15426707f, 0.00700276f, 0.02481839f, -0.03013296f, 0.09510941f, 0.05581718f, 
    0.07944866f, -0.02498224f, 0.09434450f, -0.19654219f, 0.01730040f, -0.16390112f, 0.05539712f, 0.09244504f, 
    0.17874752f, 0.11097001f, 0.06237580f, 0.01060862f, 0.01507467f, -0.08891201f, 0.09665453f, 0.08196641f, 
    -0.06193031f, -0.19373886f, 0.06895235f, -0.04808537f, -0.19526517f, 0.01447109f, -0.05806911f, 0.23118961f, 
    0.15825842f, 0.26608106f, 0.02985569f, 0.01924863f, 0.05822286f, -0.01142711f, -0.04093820f, -0.02904967f, 
    0.00232614f, 0.04169225f, 0.11086515f, 0.07540239f, -0.30570495f, -0.01308700f, -0.30269480f, 0.17180969f, 
    -0.26166213f, 0.10234607f, -0.12986445f, -0.00338836f, -0.01430890f, 0.15016548f, 0.07302964f, -0.10810842f, 
    0.07272241f, 0.01546386f, 0.01424509f, 0.00307015f, -0.10900585f, 0.00011908f, 0.07521816f, 0.32446554f, 
    0.26968625f, -0.05120268f, -0.20099227f, -0.05325995f, -0.04402214f, 0.24530557f, -0.03294018f, 0.36354432f, 
    -0.09446720f, 0.05649543f, -0.10471248f, -0.05031250f, -0.10118313f, -0.09733924f, -0.09431401f, -0.00781506f, 
    0.05564762f, -0.03143991f, 0.02988600f, 0.10442660f, 0.17944060f, -0.17039306f, -0.21863152f, -0.34793064f, 
    -0.02741548f, 0.06678090f, 0.09283420f, 0.21446694f, 0.14219721f, 0.00953458f, -0.08184616f, -0.09564786f, 
    0.01645766f, -0.07701983f, -0.15611358f, -0.02540567f, -0.02750244f, 0.10398499f, -0.01878522f, 0.09844230f, 
    0.11324826f, -0.05679571f, -0.01944262f, -0.09981845f, -0.16746515f, -0.04037040f, -0.08183748f, 0.34978294f, 
    -0.06416221f, -0.17387688f, -0.02567373f, -0.06579790f, -0.06384762f, -0.07034227f, 0.04116997f, 0.09461695f, 
    -0.08238792f, -0.18574122f, 0.02656520f, 0.00094621f, -0.04721960f, -0.01191847f, 0.06676363f, 0.19615787f, 
    -0.16645318f, 0.07699361f, 0.27965075f, -0.18411821f, -0.25420305f, 0.25007230f, 0.01432368f, 0.01053225f, 
    0.08639403f, 0.14292508f, -0.03104984f, 0.12763861f, -0.13520317f, -0.09730282f, 0.08375718f, 0.17552771f, 
    0.18097776f, 0.00699549f, -0.03660523f, -0.02989202f, -0.13620397f, 0.13178340f, -0.00178246f, -0.17243728f, 
    0.13754344f, -0.21884352f, 0.07806356f, 0.14483862f, -0.08728610f, 0.05594248f, 0.03703213f, -0.02817391f, 
    0.11908062f, 0.02636019f, 0.10152647f, 0.12053459f, -0.07481846f, 0.15939817f, 0.28082743f, 0.17947970f, 
    -0.01856869f, 0.07547422f, 0.03449271f, -0.16941278f, -0.07860962f, 0.05192810f, 0.02351667f, -0.01487200f, 
    0.11331106f, 0.00499636f, 0.06528708f, 0.00755210f, -0.06488238f, 0.08524871f, 0.22037119f, 0.02803777f, 
    0.07505130f, 0.04677002f, -0.14835843f, 0.07812931f, 0.09038571f, -0.11434989f, -0.06092696f, 0.04870374f, 
    -0.02207022f, -0.12156563f, 0.19754443f, -0.12266029f, -0.34009138f, -0.12429457f, 0.03826863f, -0.07735966f, 
    -0.01640309f, -0.09539127f, 0.13363050f, -0.03990674f, 0.10099994f, 0.04950846f, -0.03364161f, -0.00061726f, 
    0.13906725f, -0.08267830f, -0.03252514f, -0.07158919f, -0.01389339f, -0.11151584f, -0.05963882f, -0.02018567f, 
    0.06660526f, -0.00855735f, -0.05608815f, -0.04533594f, 0.08615152f, -0.09836028f, 0.08940713f, 0.06497269f, 
    0.02512413f, 0.12622826f, 0.04637001f, -0.11414679f, -0.32300568f, 0.16654617f, 0.05508589f, -0.09667057f, 
    0.06084064f, 0.21417487f, 0.02474784f, 0.04502179f, 0.04423727f, -0.03245978f, 0.03163992f, 0.06515752f, 
    0.04431248f, 0.07479008f, -0.04893102f, 0.04346398f, -0.08523865f, 0.29132664f, 0.27098793f, 0.05946198f, 
    -0.16664959f, 0.12474446f, -0.09770907f, -0.35039946f, -0.09968161f, -0.05158799f, -0.01482482f, 0.04262938f, 
    0.11742185f, -0.06034941f, -0.03317478f, 0.03599253f, 0.06002093f, -0.01486660f, 0.02295434f, -0.14735423f, 
    0.41561592f, 0.11626906f, 0.18018073f, -0.15804370f, -0.01991313f, 0.13594523f, -0.20426497f, -0.21189027f, 
    0.29165712f, 0.12692876f, 0.07797269f, -0.00608919f, 0.03033694f, -0.14301029f, -0.08975579f, -0.10631934f, 
    -0.09490876f, -0.04976872f, -0.04228870f, -0.03760901f, 0.48091647f, 0.10906182f, 0.09810637f, 0.14165586f, 
    -0.07256810f, 0.12141538f, 0.06769339f, 0.05432290f, -0.09302329f, 0.12636067f, 0.14505853f, 0.03180604f, 
    0.03299670f, -0.20409131f, 0.11189160f, 0.16671242f, -0.22658430f, 0.00310259f, 0.12622868f, 0.21216480f, 
    0.06088576f, -0.14910619f, 0.12599404f, 0.17667086f, -0.02271221f, 0.10470824f, -0.11254852f, 0.02205784f, 
    0.02026828f, 0.18356405f, 0.00297583f, 0.10300410f, 0.05455577f, -0.11939073f, 0.03383795f, -0.30006775f, 
    0.03780277f, 0.11127377f, 0.09649315f, -0.03047567f, 0.13040023f, -0.09987807f, -0.20413134f, -0.06172969f, 
    -0.02000396f, -0.01164599f, 0.04951183f, 0.10215341f, 0.11214615f, -0.06533211f, -0.01000758f, -0.03358742f, 
    0.09482434f, -0.06783120f, 0.00290185f, -0.05472333f, 0.06100331f, -0.00722546f, 0.06263189f, 0.08077876f, 
    0.19479062f, 0.02574676f, 0.20404223f, -0.10065556f, -0.07333570f, 0.20832726f, 0.02993637f, 0.15942253f, 
    -0.03412857f, 0.14653823f, 0.09956304f, 0.00373153f, 0.03199142f, -0.12946229f, 0.09731877f, 0.06929746f, 
    0.01039804f, 0.15149452f, 0.01638990f, 0.13435243f, -0.40048370f, 0.39127871f, 0.13825181f, -0.15319212f, 
    -0.09052116f, 0.16600694f, -0.17556992f, -0.30798364f, -0.14430672f, -0.35009122f, -0.03193139f, 0.03278255f, 
    -0.04508607f, -0.35407546f, -0.14573368f, -0.16593577f, -0.22797932f, -0.21591137f, -0.12188261f, 0.01412205f, 
    -0.23246892f, -0.05720843f, -0.04871614f, -0.01231728f, -0.03043173f, 0.08533206f, 0.09163120f, -0.04841715f, 
    0.07839073f, 0.06193583f, -0.01007766f, -0.06858684f, 0.13755071f, -0.07427663f, -0.07756498f, -0.14565790f, 
    0.00155310f, -0.01078301f, 0.08600149f, -0.03560611f, -0.02778289f, 0.22866949f, 0.36063886f, 0.06429286f, 
    -0.05586627f, 0.10680920f, -0.02510312f, -0.26541394f, 0.03339075f, 0.18102223f, -0.01171293f, 0.13009323f, 
    -0.03660847f, 0.04156115f, 0.14305331f, 0.01513191f, 0.06987704f, -0.05728703f, 0.08028200f, 0.12970325f, 
    0.00731510f, 0.23564543f, -0.29804483f, 0.03418664f, 0.31180137f, -0.01873473f, -0.01561092f, -0.03356596f, 
    0.05942053f, 0.03279695f, -0.11735287f, -0.02293624f, 0.06823866f, 0.07817420f, 0.01659344f, -0.16757727f, 
    -0.01137552f, 0.08116207f, 0.04063906f, -0.04348675f, 0.30945981f, 0.36855099f, -0.46748316f, -0.01494597f, 
    0.13562755f, -0.10976764f, -0.17095563f, 0.30618396f, -0.03636588f, -0.05196689f, -0.01018325f, 0.01296721f, 
    0.11543761f, -0.08965722f, -0.02736777f, 0.17179413f, -0.02470159f, 0.13114266f, 0.06342705f, -0.02800086f, 
    -0.21397480f, -0.24090332f, -0.03019405f, -0.42442206f, 0.03253288f, -0.02440739f, 0.01705056f, 0.22606681f, 
    0.08258363f, -0.19179294f, 0.15884610f, -0.00821553f, 0.02500152f, -0.09544578f, 0.02254301f, -0.04450499f, 
    0.10634892f, 0.19384924f, 0.12399434f, 0.28990236f, -0.08965043f, 0.06604386f, -0.13576646f, 0.05361848f, 
    0.18118182f, -0.04285231f, 0.06731103f, 0.03638628f, -0.04934040f, 0.03801902f, -0.07412361f, -0.00970308f, 
    -0.01146830f, -0.01292984f, 0.00359794f, 0.10959393f, -0.05701117f, -0.08244576f, 0.04219791f, 0.07303187f, 
    -0.12122764f, -0.04318189f, 0.02644072f, -0.05963555f, -0.10052180f, -0.13168772f, -0.19003275f, -0.16645285f, 
    -0.19352542f, -0.16732955f, -0.00009113f, 0.13501781f, -0.00063731f, 0.07498713f, 0.03938116f, -0.13183291f, 
    -0.02810044f, 0.09609488f, -0.04064391f, -0.12444504f, -0.16526067f, -0.25498372f, -0.01764692f, 0.18173909f, 
    0.00463691f, -0.07229064f, -0.01959646f, -0.02452977f, -0.02252620f, 0.03285925f, 0.07455447f, -0.09787476f, 
    -0.01262987f, -0.05228103f, 0.02120129f, 0.02570866f, 0.15124655f, -0.02897455f, 0.00712853f, 0.16698954f, 
    0.14912257f, 0.02503881f, -0.38723290f, -0.09717686f, 0.18653302f, -0.02902180f, 0.16042429f, 0.35684544f, 
    0.00811732f, -0.20231993f, 0.03841095f, 0.03669410f, -0.00477731f, -0.03928893f, 0.11586918f, 0.04959877f, 
    0.01865917f, 0.24891831f, 0.03751967f, 0.07839532f, -0.48238230f, -0.11674616f, -0.10659732f, 0.15360561f, 
    0.29174244f, 0.02031480f, 0.08965786f, 0.14203754f, 0.00581361f, -0.13148166f, -0.13470463f, -0.08692677f, 
    -0.09377749f, 0.03679211f, 0.01570603f, 0.06419635f, -0.13584600f, 0.11934878f, -0.04110197f, -0.10672663f, 
    -0.17292416f, -0.02623021f, 0.04694119f, 0.03269181f, -0.20597623f, 0.05935488f, 0.16765149f, 0.14227831f, 
    0.04571552f, -0.02997869f, -0.08187430f, 0.00249487f, -0.17080839f, -0.04390827f, 0.04123909f, 0.10667814f, 
    0.14973368f, 0.04825712f, 0.10327420f, -0.09890144f, -0.21872389f, 0.18089429f, -0.39762408f, 0.11572756f, 
    0.24183643f, 0.10983536f, 0.04112501f, 0.07297079f, 0.12975369f, 0.15196872f, 0.05398719f, 0.08702866f, 
    -0.06208302f, 0.02110127f, 0.10563909f, 0.04326911f, -0.02765619f, 0.11389253f, 0.10362202f, 0.14797397f, 
    0.07250711f, 0.26104897f, -0.30562600f, 0.04391453f, -0.13514550f, -0.02698216f, -0.03521358f, 0.12080555f, 
    -0.02834089f, 0.06550378f, -0.10814791f, 0.04133156f, -0.03066299f, 0.05293954f, 0.13685796f, -0.09134930f, 
    -0.00683546f, -0.02893558f, 0.21009274f, -0.06934488f, -0.26695836f, 0.05998329f, 0.12660107f, -0.02149886f, 
    -0.14207959f, -0.10272729f, -0.06533746f, -0.20946100f, -0.12380952f, -0.06571496f, 0.17775121f, 0.13364565f, 
    0.06032039f, 0.06954145f, 0.01229540f, -0.07415795f, 0.00033984f, -0.06426931f, 0.00140981f, 0.14383508f, 
    -0.00058162f, -0.10429084f, -0.24563824f, -0.06885500f, -0.07345240f, 0.05055266f, 0.14660531f, 0.09193531f, 
    0.10082402f, 0.06071043f, 0.00530489f, 0.01315070f, -0.03570975f, 0.03175084f, -0.05296053f, 0.00861444f, 
    -0.03620864f, 0.09897542f, 0.10545528f, -0.01469768f, 0.26500559f, 0.11056259f, -0.07086480f, -0.06688531f, 
    0.04209808f, -0.10250677f, 0.03927632f, 0.08651429f, 0.11604676f, 0.15332405f, 0.05008437f, 0.02662759f, 
    -0.02841241f, 0.00199319f, -0.09098471f, 0.08799726f, -0.12487806f, 0.05522932f, 0.10112356f, 0.09863307f, 
    -0.10527964f, 0.12715669f, 0.27781388f, 0.25004208f, -0.21847230f, -0.00998680f, -0.04225316f, -0.10048397f, 
    0.19595289f, 0.08227497f, 0.08356176f, -0.03292510f, -0.01740510f, 0.00680195f, -0.00798945f, 0.10400589f, 
    -0.04171180f, -0.09488800f, -0.01451194f, 0.00612931f, -0.12037382f, -0.15611821f, -0.12676661f, 0.19864549f, 
    -0.10749875f, -0.05897165f, -0.05400704f, 0.04140728f, 0.00687027f, 0.15136750f, 0.15059644f, 0.00913445f, 
    0.13943149f, 0.01843616f, 0.08691744f, 0.04159660f, -0.04152007f, 0.03990037f, -0.00401631f, 0.10734833f, 
    0.14628807f, 0.12290388f, 0.48465675f, 0.30136484f, -0.29131997f, 0.12971379f, 0.01394881f, 0.10064556f, 
    0.10547084f, -0.00675354f, 0.17793673f, -0.03925889f, 0.01175430f, -0.22384399f, 0.03910828f, 0.38042632f, 
    0.01820209f, -0.14108574f, -0.02390333f, 0.08387616f, -0.42416054f, -0.07701795f, 0.40773487f, -0.02980683f, 
    -0.11856383f, 0.02765834f, 0.14706367f, 0.03439189f, -0.08507869f, 0.01511040f, -0.12377047f, 0.00443035f, 
    -0.05598543f, 0.12949942f, -0.07518539f, -0.07410705f, 0.11216062f, -0.00594251f, 0.19892707f, 0.10520928f, 
    -0.11026710f, -0.13340779f, -0.15343359f, 0.14769137f, -0.07855157f, -0.15060316f, -0.08271217f, -0.06246163f, 
    0.15257710f, -0.05109839f, -0.15702955f, 0.05932005f, -0.03283888f, 0.05953211f, -0.03589031f, 0.11999135f, 
    0.04597754f, -0.01511400f, 0.00507591f, 0.17203563f, 0.14407003f, 0.06232364f, 0.06927648f, 0.30166474f, 
    0.00894666f, -0.00172646f, -0.06007444f, 0.06205066f, -0.10292175f, -0.00839451f, -0.15779015f, -0.02299671f, 
    -0.08924853f, 0.08984164f, 0.01773349f, 0.03680300f, 0.11360436f, 0.10290930f, 0.12087961f, 0.02810509f, 
    -0.09408212f, -0.25340566f, 0.05544407f, 0.03137073f, -0.02184594f, -0.24785668f, -0.15657926f, -0.13984028f, 
    -0.17464952f, -0.20417516f, 0.10808192f, 0.08824088f, 0.00664644f, 0.10957832f, 0.01853420f, 0.10451602f, 
    -0.06724990f, -0.06291969f, -0.06350374f, -0.11018490f, 0.23724772f, 0.05746455f, 0.01709589f, 0.01434253f, 
    -0.04922370f, -0.04438408f, 0.08068758f, 0.02280303f, -0.04103028f, 0.01800967f, -0.07468936f, 0.00918323f, 
    0.04333296f, 0.10061250f, 0.04649139f, 0.03154017f, 0.15185317f, 0.12845032f, 0.15134606f, -0.01151639f, 
    -0.35241103f, -0.11817425f, 0.01306322f, 0.01533867f, -0.38652918f, 0.23447545f, -0.18504421f, -0.00161150f, 
    -0.11790272f, 0.16728780f, -0.05871657f, 0.16621470f, 0.11361060f, 0.14314422f, 0.08375056f, 0.12274213f, 
    -0.00858942f, 0.09598918f, -0.09488050f, -0.05386369f, 0.21347414f, -0.09290215f, -0.05613398f, -0.13886110f, 
    -0.20609275f, 0.08147617f, -0.12236149f, -0.05604244f, -0.10907742f, -0.01276460f, -0.12301126f, -0.03499093f, 
    -0.09164201f, -0.06470222f, -0.09704252f, 0.01550982f, -0.12323808f, -0.19407724f, 0.05087129f, 0.01384678f, 
    0.04600484f, -0.16593648f, -0.21933424f, 0.17963529f, 0.01128284f, -0.02245547f, -0.05567982f, -0.00471282f, 
    0.12956622f, -0.08752151f, 0.23918377f, 0.04420324f, 0.17351379f, -0.02593585f, 0.02784939f, -0.13586584f, 
    -0.08090653f, -0.13939716f, -0.16596605f, -0.18598410f, 0.31894091f, 0.03752061f, 0.11166126f, 0.18508983f, 
    -0.36567363f, 0.12658320f, 0.01173474f, 0.01805274f, 0.21191530f, 0.06807962f, 0.09467947f, 0.06362960f, 
    0.07484408f, 0.08937015f, 0.05579174f, 0.11968457f, 0.04257811f, -0.11097557f, -0.01584755f, -0.08876767f, 
    -0.03646646f, -0.05521618f, 0.15656006f, -0.10292485f, 0.25792190f, -0.03484979f, 0.13373114f, 0.11850460f, 
    0.00132020f, -0.05530483f, 0.02992859f, -0.18814442f, 0.00013256f, 0.00559205f, -0.04760765f, 0.11488535f, 
    0.08787573f, 0.06960972f, 0.21598651f, 0.03042151f, 0.19742200f, -0.07747542f, -0.04681980f, 0.14067501f, 
    -0.06221712f, -0.09277514f, 0.11057021f, 0.05253760f, -0.00471062f, -0.04621179f, 0.00571853f, -0.03323246f, 
    0.05806204f, 0.04301404f, 0.04936683f, 0.03127817f, -0.06166787f, -0.00765815f, 0.09289850f, -0.05501241f, 
    -0.14304650f, 0.14293276f, -0.15092535f, 0.18764217f, -0.14421205f, 0.16224283f, -0.17600615f, -0.02072889f, 
    0.12267776f, 0.16675945f, 0.01578538f, 0.13372700f, 0.14076146f, -0.01064608f, 0.06750692f, 0.09197146f, 
    0.13102055f, 0.17490746f, -0.05408122f, -0.08788553f, -0.62908530f, 0.07578833f, -0.08171316f, 0.35143605f, 
    -0.01346490f, 0.14735468f, -0.05814115f, 0.13083020f, -0.15323006f, -0.18610355f, -0.07265557f, 0.07484658f, 
    0.12102212f, -0.12933494f, 0.07673759f, 0.06034218f, -0.12010550f, 0.00072982f, 0.03427418f, -0.04090850f, 
    -0.27224055f, 0.11861497f, 0.53004831f, 0.26806098f, 0.37993494f, -0.15216464f, 0.11504491f, -0.13500030f, 
    -0.09044827f, -0.00454155f, -0.03311336f, 0.00631423f, 0.02400681f, -0.08523471f, 0.08832861f, -0.10408373f, 
    0.04874919f, -0.05062572f, 0.07208135f, -0.03614881f, -0.09413302f, 0.34316391f, 0.41228560f, 0.29718307f, 
    0.21681696f, -0.03379885f, 0.00364493f, -0.00970508f, 0.01666998f, 0.11691426f, -0.01874590f, 0.11904181f, 
    -0.04615898f, 0.05302881f, 0.06660558f, 0.09271096f, 0.01729563f, -0.04096968f, 0.07614581f, 0.03501079f, 
    -0.33298698f, 0.06727526f, 0.22212635f, -0.02675484f, 0.35564336f, 0.02237581f, 0.07820784f, -0.02790320f, 
    0.06052843f, 0.14729191f, -0.01120888f, 0.09352072f, -0.01543037f, 0.01957706f, 0.00589005f, -0.18477888f, 
    0.02596468f, 0.17959353f, 0.02336365f, -0.00751008f, 0.09670258f, -0.08359670f, -0.26303416f, -0.27312344f, 
    0.12692550f, -0.11388153f, -0.12407727f, 0.13605864f, 0.00286630f, 0.05919219f, -0.02612098f, -0.08589482f, 
    -0.01911222f, -0.21839763f, -0.06155040f, 0.11346025f, -0.03223713f, 0.00468058f, -0.10758933f, -0.07872760f, 
    -0.12364564f, 0.07870957f, 0.09651196f, -0.09093640f, 0.22683121f, 0.28534445f, -0.10360930f, 0.11069352f, 
    -0.22392751f, 0.14579169f, 0.09395722f, -0.01636947f, -0.01994546f, -0.03784569f, -0.02844594f, 0.04992836f, 
    -0.05706981f, 0.03442701f, -0.06291417f, -0.14606062f, 0.14530466f, -0.06911346f, -0.41766992f, -0.05342457f, 
    0.11848206f, -0.07883511f, 0.12870225f, 0.04488358f, 0.02408350f, 0.12347350f, -0.01809934f, -0.03792130f, 
    0.01734819f, -0.05056296f, 0.02125958f, 0.15962537f, 0.00232345f, 0.04062668f, 0.03199236f, 0.21952191f, 
    -0.01371430f, -0.15072054f, -0.22932860f, -0.14544725f, -0.03959016f, 0.05319309f, -0.04367585f, -0.08575107f, 
    -0.10640194f, 0.05594000f, -0.04078571f, 0.02644274f, 0.06665877f, 0.06911157f, 0.04386874f, 0.04276573f, 
    0.09191836f, 0.06151886f, 0.04890595f, 0.07996424f, -0.06169872f, -0.19758835f, -0.12390457f, -0.19366586f, 
    0.06028749f, 0.04303023f, 0.00170935f, 0.03989894f, 0.00102808f, 0.01355297f, 0.00078425f, -0.12150501f, 
    -0.04543228f, -0.12764056f, 0.02433343f, 0.06761527f, -0.20997010f, -0.03800561f, 0.00129819f, -0.05038435f, 
    -0.11681248f, -0.01120709f, 0.06776862f, 0.02740755f, 0.07665442f, -0.10767175f, 0.12857302f, 0.10398837f, 
    0.01702316f, -0.14022374f, 0.05752726f, 0.03203001f, 0.01964987f, -0.00772330f, -0.00261712f, -0.06147075f, 
    -0.01494269f, -0.07631096f, -0.02721640f, 0.12491512f, 0.12491120f, -0.14114195f, -0.30555972f, 0.12559420f, 
    0.35331747f, -0.10099579f, 0.17279808f, 0.12511636f, 0.04576113f, 0.11163794f, -0.04513905f, -0.00699416f, 
    -0.00343710f, -0.03738686f, 0.00887830f, 0.06986500f, 0.00492075f, 0.09804685f, 0.02027252f, 0.08484378f, 
    -0.42410189f, -0.17311148f, -0.04290723f, 0.15401271f, -0.11403371f, -0.07091305f, 0.23827814f, 0.08043505f, 
    -0.20576286f, -0.06468997f, -0.07045653f, 0.00916016f, 0.01268702f, 0.06558498f, 0.08334632f, 0.02030369f, 
    0.15793836f, -0.03808010f, 0.11851636f, 0.20445023f, -0.11208977f, 0.20435035f, -0.03729727f, -0.06547250f, 
    -0.08733904f, -0.08500382f, 0.14315706f, -0.09187880f, 0.01277241f, -0.04329057f, -0.02929693f, -0.10125719f, 
    -0.02345384f, 0.15212548f, 0.01376066f, -0.05952322f, 0.09939568f, 0.02090736f, 0.02938270f, 0.00233938f, 
    -0.14923349f, -0.23690940f, -0.21179381f, -0.13916688f, 0.00495493f, -0.05773443f, -0.08182136f, -0.02405943f, 
    0.05110742f, 0.09002017f, -0.03686830f, -0.01254634f, 0.02221540f, -0.06350364f, -0.03040942f, 0.13864967f, 
    -0.10176518f, -0.15518720f, 0.01547028f, 0.08566681f, 0.01872960f, -0.08112140f, 0.29411915f, 0.13977480f, 
    0.10289573f, 0.02487265f, -0.09409450f, -0.04791636f, -0.07418084f, 0.11790787f, 0.05601664f, 0.01535919f, 
    -0.00276857f, -0.05829507f, 0.07328496f, 0.04324636f, -0.08119956f, 0.00097863f, -0.02591038f, -0.02018545f, 
    -0.18555979f, 0.07719002f, -0.07168211f, 0.06130783f, -0.02952596f, -0.05913829f, 0.21103127f, -0.12075637f, 
    0.04172206f, -0.07891224f, 0.00872473f, 0.00409964f, 0.05422879f, 0.08979167f, 0.00154630f, -0.01742297f, 
    0.08450886f, -0.17920023f, 0.05849614f, 0.01946010f, 0.24153845f, -0.43352413f, -0.26051739f, 0.19826747f, 
    0.02464378f, -0.33615425f, 0.03732425f, 0.08991778f, 0.05217228f, 0.27270249f, -0.02684286f, 0.02952119f, 
    -0.02983223f, 0.25494751f, 0.20073175f, -0.05389548f, 0.05598473f, -0.01776623f, 0.13087976f, 0.06643852f, 
    0.07278372f, -0.12940919f, -0.11969934f, -0.15422045f, 0.08803035f, -0.06392497f, -0.02646014f, -0.01173863f, 
    0.06040689f, 0.07897777f, -0.06508801f, -0.05674329f, -0.07735492f, -0.10172206f, -0.10421687f, -0.05330644f, 
    -0.04893933f, 0.00427449f, -0.05716286f, -0.10546022f, 0.10511638f, -0.25163952f, -0.15979300f, -0.03698462f, 
    -0.12261946f, -0.04898024f, 0.03226145f, -0.02800078f, 0.06736538f, 0.18021359f, -0.03246599f, 0.01750015f, 
    0.08520167f, 0.09305677f, -0.04884014f, 0.08696598f, 0.13472821f, -0.06746843f, 0.08109246f, 0.14849658f, 
    -0.15045819f, 0.04107886f, -0.15432867f, -0.10637888f, -0.03966505f, -0.05432111f, -0.08425578f, 0.05364163f, 
    -0.08167458f, -0.02113122f, -0.04590962f, 0.04117101f, -0.29330820f, -0.15505111f, 0.05134370f, -0.00039752f, 
    -0.13516477f, 0.02137243f, -0.11240371f, -0.29126695f, -0.11120795f, 0.04536410f, -0.06071495f, 0.15633553f, 
    -0.07323930f, -0.10584140f, -0.07556435f, 0.19983372f, -0.14895339f, 0.02108469f, -0.02853558f, -0.13156372f, 
    -0.00601890f, 0.01632621f, -0.00070382f, 0.14678198f, 0.01951620f, 0.19724691f, -0.05630390f, 0.11018702f, 
    -0.21520522f, -0.00245682f, 0.23790264f, -0.18456793f, -0.18374899f, 0.14241201f, 0.07955666f, 0.15976363f, 
    0.08026159f, 0.02569585f, -0.10561372f, -0.11171369f, 0.00355224f, -0.02899023f, 0.01677728f, -0.07327780f, 
    0.11933917f, 0.10084095f, 0.14701371f, 0.29416040f, 0.02178200f, 0.22264682f, 0.11100201f, 0.16503534f, 
    0.15290238f, -0.02307202f, -0.06416657f, -0.07120617f, -0.04061008f, 0.00175338f, -0.02013642f, -0.09676620f, 
    -0.08623443f, -0.00594335f, 0.06838930f, 0.11801240f, -0.16969326f, -0.02311594f, -0.02952174f, 0.06431787f, 
    0.28855366f, 0.00999250f, 0.04895835f, 0.08497078f, -0.11906678f, -0.17611420f, -0.26357532f, -0.15490888f, 
    -0.13978633f, -0.11255055f, 0.20382485f, 0.12520747f, -0.14230791f, 0.15036196f, 0.22984809f, -0.15478604f, 
    0.08145749f, 0.08293130f, 0.01352906f, -0.08846822f, -0.10133944f, -0.03600566f, 0.01539959f, 0.13333061f, 
    0.05681260f, 0.00677205f, -0.09623974f, -0.08445703f, 0.04719390f, -0.02729882f, 0.04838676f, -0.04108664f, 
    0.20813091f, 0.02218570f, -0.01063524f, 0.06181579f, 0.15324675f, -0.07349797f, 0.17783278f, 0.16537870f, 
    -0.03526894f, 0.12508258f, 0.07288729f, 0.28099105f, -0.18767025f, 0.12357194f, 0.26914996f, 0.33003461f, 
    -0.02245236f, 0.20093885f, -0.00505792f, 0.10470422f, 0.05655493f, 0.06425441f, 0.01167412f, 0.12788306f, 
    0.15067463f, -0.08551177f, -0.17354625f, 0.12808111f, -0.09330092f, 0.09311665f, -0.18989611f, 0.21420738f, 
    0.06196379f, -0.04926211f, 0.00913737f, -0.02844744f, 0.08033205f, -0.13822386f, -0.07016259f, -0.09489501f, 
    -0.11263359f, -0.06548327f, -0.03590475f, 0.13645656f, -0.06386741f, -0.08112169f, -0.04933112f, -0.17689238f, 
    0.06201806f, -0.01313282f, 0.30774489f, 0.05579673f, -0.09821737f, 0.14891055f, -0.01427213f, -0.06672837f, 
    0.06340884f, -0.03246678f, 0.04544805f, 0.01150414f, -0.05162098f, -0.15663268f, 0.00496382f, 0.10712437f, 
    0.13465530f, -0.20376340f, -0.17341818f, -0.10802604f, 0.19007799f, 0.12066743f, 0.12809350f, 0.16603746f, 
    0.19203241f, 0.11990824f, 0.10475791f, 0.06025195f, 0.06079404f, 0.36472693f, 0.16626585f, -0.06572621f, 
    0.00792571f, -0.02750875f, 0.03873907f, 0.08663867f, 0.01776654f, -0.34556016f, 0.07408504f, 0.13829431f, 
    -0.18924826f, -0.27930921f, 0.20352140f, 0.11004914f, -0.17932269f, 0.02707402f, -0.20585236f, 0.09925988f, 
    -0.03136221f, 0.04302733f, -0.09202249f, -0.00328306f, -0.02435073f, 0.05025240f, 0.03068212f, 0.09755531f, 
    -0.07833273f, 0.27956495f, 0.11628374f, 0.02324496f, 0.31988117f, -0.11817490f, 0.01577418f, -0.03840207f, 
    -0.18632759f, -0.01949793f, -0.07811126f, -0.02189876f, 0.06192056f, 0.06960718f, 0.14948785f, 0.12970474f, 
    0.08083592f, 0.03779518f, 0.04103010f, -0.00291755f, 0.08379164f, 0.07556286f, 0.04591970f, 0.13668552f, 
    0.19733937f, 0.12425555f, 0.10657044f, 0.10884142f, -0.04255404f, 0.15917799f, 0.24962805f, 0.16338009f, 
    0.09719595f, 0.08079275f, -0.03052143f, -0.03087213f, -0.04512784f, 0.00962890f, -0.00251487f, 0.01603290f, 
    0.08067764f, -0.20162611f, -0.05444762f, -0.01735832f, -0.35022399f, 0.10284873f, 0.14739227f, 0.33680528f, 
    0.06765348f, -0.13637273f, 0.19806969f, -0.07204049f, 0.04197901f, -0.07367586f, -0.00612142f, 0.09636796f, 
    -0.09595623f, -0.12130161f, -0.01794790f, 0.07458159f, -0.15573187f, -0.03582824f, -0.05572399f, -0.21430278f, 
    0.07994562f, -0.10971230f, -0.43305975f, -0.32171398f, 0.10405878f, -0.05365529f, 0.09147134f, -0.02276238f, 
    -0.09561884f, 0.04554249f, -0.01269747f, -0.02176845f, -0.05583420f, 0.09634100f, -0.00757380f, 0.06824109f, 
    0.03585947f, 0.01836932f, -0.02575086f, -0.05390209f, 0.05345270f, -0.27464086f, -0.35435531f, -0.21376009f, 
    -0.06576706f, -0.00309811f, 0.13897429f, 0.03591253f, -0.00255210f, 0.12875898f, 0.06513170f, 0.02875142f, 
    -0.08079334f, 0.05271579f, -0.05215429f, 0.07024906f, 0.18468170f, -0.02923382f, 0.05333573f, 0.04444790f, 
    0.02382015f, 0.08747088f, -0.38962907f, -0.20212930f, 0.08857223f, 0.00094594f, -0.02355641f, -0.00034964f, 
    0.02721064f, 0.11441687f, -0.09616008f, 0.05968971f, -0.15339985f, 0.07709333f, 0.01040418f, 0.03845957f, 
    -0.08402042f, 0.12157776f, -0.02179273f, -0.19331598f, -0.06236789f, -0.15301211f, 0.12518433f, 0.08092376f, 
    -0.10201526f, -0.18772706f, 0.00651471f, -0.06890117f, 0.02620241f, -0.02615308f, -0.07527228f, -0.06061454f, 
    0.00180175f, 0.06596034f, 0.01679718f, 0.04725723f, -0.02979388f, 0.18601941f, -0.07576674f, -0.02816739f, 
    -0.00903173f, 0.22805452f, 0.23755902f, -0.08655119f, 0.01213555f, 0.03138433f, 0.03657401f, 0.08334272f, 
    0.08507723f, 0.22809030f, -0.07959604f, -0.04228172f, -0.00618225f, 0.03490751f, 0.03731575f, -0.05384982f, 
    0.03107825f, 0.18532279f, 0.03392140f, 0.30782992f, 0.07150809f, 0.09332301f, 0.17872912f, 0.11142922f, 
    0.18130428f, 0.00534323f, -0.11842547f, -0.05209729f, -0.01586062f, 0.00193264f, -0.07460182f, 0.02698555f, 
    -0.00827555f, -0.09253661f, -0.03278876f, 0.00719923f, -0.06989462f, 0.01344595f, -0.05639041f, 0.00242794f, 
    0.01567198f, -0.08093245f, -0.06255965f, 0.00999440f, -0.18959928f, -0.11794621f, -0.03124901f, -0.10825862f, 
    -0.12732002f, -0.10122085f, 0.07199845f, 0.16747436f, 0.02107655f, 0.11055479f, 0.13037966f, -0.18326586f, 
    0.03564222f, 0.17687768f, -0.04334170f, -0.05990707f, -0.15153190f, -0.05656185f, -0.08984423f, -0.01005768f, 
    -0.13989936f, -0.12226828f, -0.10693583f, -0.14097103f, 0.10711582f, 0.04397761f, 0.00460145f, -0.07732127f, 
    0.05796044f, -0.01540906f, -0.07805637f, 0.07377108f, 0.15431662f, 0.14066799f, 0.12863137f, 0.12011560f, 
    0.31970116f, 0.17034021f, 0.25645566f, 0.24346016f, 0.19179969f, 0.00250406f, 0.08436132f, 0.18308625f, 
    0.05627065f, 0.09798984f, 0.02830792f, -0.01310574f, 0.04598160f, 0.10143679f, -0.01032276f, 0.04442487f, 
    0.13451676f, -0.07464551f, 0.02793921f, 0.09246719f, 0.06587422f, 0.06644408f, 0.26554945f, 0.25336444f, 
    0.09452479f, -0.04527253f, 0.00735842f, -0.03390027f, 0.13340653f, -0.07268967f, -0.01419319f, -0.06301504f, 
    -0.11845362f, -0.09005585f, 0.05855028f, 0.13023822f, -0.06723318f, -0.06308445f, -0.02670880f, -0.08442029f, 
    0.07504334f, 0.14785947f, 0.33693540f, -0.16008639f, -0.09814633f, 0.23583323f, 0.07224720f, 0.22001900f, 
    -0.00639374f, 0.11810015f, 0.05161854f, 0.01085367f, 0.00584998f, -0.01666306f, -0.00987392f, 0.16984278f, 
    -0.01594887f, -0.02735330f, -0.24404229f, -0.18021345f, 0.00592503f, -0.12154635f, -0.06730951f, 0.14608259f, 
    0.41167945f, 0.12027301f, 0.08065592f, -0.00664879f, 0.07538860f, 0.32413140f, 0.11631650f, -0.06980551f, 
    0.01695695f, 0.05427044f, -0.01506398f, 0.06955163f, -0.11544080f, -0.14170067f, 0.06154814f, 0.08235705f, 
    -0.04876966f, -0.08332313f, 0.42276624f, -0.05742150f, -0.31353506f, 0.09975126f, -0.13666497f, -0.15237255f, 
    -0.02155821f, -0.05997044f, -0.05770495f, 0.00708285f, -0.02452525f, 0.11563077f, 0.18262622f, 0.19202447f, 
    -0.03939603f, 0.17404851f, -0.05782203f, -0.07220849f, 0.02616426f, -0.09704563f, -0.19843285f, -0.17923266f, 
    -0.23070548f, -0.04862637f, -0.04602390f, 0.09834837f, -0.04499913f, 0.09157844f, 0.07454953f, 0.17853710f, 
    -0.00429290f, -0.00100740f, 0.01063722f, -0.06349676f, 0.08470567f, 0.14656226f, 0.10143459f, 0.14387715f, 
    0.34922537f, 0.16230597f, 0.07796349f, 0.00830243f, 0.12008861f, 0.06671807f, 0.12918875f, 0.20210668f, 
    0.05681634f, -0.03399592f, -0.05797767f, -0.02659033f, -0.02603222f, 0.12878361f, -0.01359291f, 0.00880232f, 
    -0.01918192f, -0.09711081f, 0.01448840f, -0.01442086f, 0.20262094f, 0.05231661f, 0.31823853f, -0.13654353f, 
    0.09820598f, 0.01830391f, 0.18471393f, -0.01134119f, 0.23719880f, 0.00563636f, 0.05191113f, 0.11177690f, 
    0.03191419f, 0.06129333f, 0.02918473f, 0.07592028f, -0.07693844f, 0.00366140f, -0.06038707f, -0.19636761f, 
    -0.03250718f, -0.15884383f, -0.02086041f, 0.01643563f, 0.18122457f, 0.21859750f, 0.16473070f, -0.21420808f, 
    -0.02574681f, -0.08022788f, -0.02087706f, -0.11627445f, 0.08620354f, -0.04194573f, -0.01126640f, -0.07047236f, 
    0.02492169f, 0.05489606f, -0.03107141f, 0.00519668f, 0.10586773f, 0.01090495f, 0.30833486f, 0.25620946f, 
    0.08766644f, 0.08404174f, -0.07601881f, -0.14318722f, -0.13515314f, 0.04465605f, -0.05101002f, -0.06006807f, 
    -0.20632224f, -0.10764746f, 0.01325484f, 0.11469579f, 0.06756829f, -0.02574333f, 0.01422240f, -0.06309958f, 
    -0.25511548f, 0.08612500f, -0.32351631f, -0.12979499f, 0.13885947f, 0.14049192f, 0.08686639f, -0.13883126f, 
    -0.00172830f, -0.01777232f, -0.22141708f, -0.01521321f, -0.05012161f, 0.23700957f, -0.00464400f, -0.18688360f, 
    -0.08967256f, 0.15959387f, -0.07878030f, -0.02012998f, 0.45362619f, -0.13670251f, -0.06766946f, -0.09049615f, 
    0.08494262f, -0.10036281f, 0.01674532f, -0.03326739f, 0.11567277f, -0.15016799f, -0.09263777f, -0.02807669f, 
    0.03775887f, -0.09527508f, 0.04233235f, 0.10887641f, -0.00480632f, 0.11784688f, -0.13344897f, -0.07004324f, 
    -0.01435540f, 0.19151609f, 0.14025362f, 0.01910275f, 0.24077539f, 0.07510649f, -0.01569182f, 0.31121981f, 
    -0.03570907f, 0.16135909f, 0.07769327f, -0.02821187f, 0.00494407f, -0.10346448f, -0.01226040f, 0.13285382f, 
    0.00318102f, 0.08446606f, -0.07058907f, -0.01333109f, 0.40574977f, -0.20592284f, 0.01488601f, -0.06162426f, 
    0.20191444f, -0.08647104f, -0.04998086f, -0.14978097f, 0.05443907f, 0.01109452f, 0.05207010f, -0.00078094f, 
    0.00574494f, -0.12128991f, -0.00208902f, 0.00052576f, -0.07282147f, -0.03358057f, -0.15668768f, 0.13064189f, 
    -0.17561014f, -0.15623282f, -0.20545119f, -0.03735125f, -0.16088809f, 0.19712770f, 0.07232789f, 0.00239490f, 
    0.02232481f, 0.09073999f, -0.03454940f, 0.12697092f, 0.00161111f, -0.01494087f, -0.03582803f, -0.01498630f, 
    0.08885597f, 0.07894364f, -0.07118352f, 0.00826439f, -0.16458257f, -0.15314999f, -0.04900050f, 0.03395995f, 
    -0.10539571f, -0.07158806f, 0.08522481f, -0.02388589f, 0.14091590f, -0.03767198f, -0.00391723f, -0.06620889f, 
    0.01535293f, -0.02308053f, -0.07124600f, 0.05162181f, -0.01798875f, 0.07500577f, 0.02018968f, 0.01154318f, 
    0.37584162f, 0.13116090f, 0.04373124f, 0.23614872f, 0.45804328f, -0.12531032f, -0.04420108f, 0.09068958f, 
    -0.00262934f, -0.11860593f, 0.05637795f, 0.03429780f, -0.04394920f, -0.02351559f, -0.05075036f, -0.08760045f, 
    0.02079566f, -0.02230770f, 0.14294930f, -0.03235005f, 0.30752325f, -0.05535403f, 0.28922299f, 0.35192892f, 
    0.29598114f, -0.06013613f, -0.13344570f, 0.03248472f, 0.00889728f, -0.00311684f, -0.01407099f, 0.01087794f, 
    -0.09117997f, -0.04678164f, -0.03617853f, -0.03816144f, -0.04951737f, 0.04263316f, -0.07349750f, 0.20973743f, 
    -0.32129654f, 0.03891122f, 0.18700188f, 0.10691764f, -0.12140846f, -0.04428145f, 0.12107407f, 0.18920779f, 
    -0.30882064f, -0.05728309f, -0.05280294f, 0.04810397f, 0.03489802f, 0.02248843f, 0.07265284f, 0.12342884f, 
    0.17283630f, 0.08794813f, 0.01414253f, 0.03604969f, -0.22440492f, 0.01880766f, 0.13184026f, 0.00534253f, 
    0.23087552f, -0.00213250f, 0.01828561f, -0.09151566f, 0.21847287f, -0.02121853f, -0.15883479f, 0.01547266f, 
    -0.03965433f, 0.02906659f, -0.02905633f, -0.02999954f, -0.20960608f, -0.08035619f, 0.08136919f, -0.08735546f, 
    -0.01976376f, -0.10780583f, 0.19407266f, -0.14717385f, -0.18872860f, 0.09088967f, -0.21161871f, 0.08515913f, 
    -0.04601178f, -0.10775148f, -0.21408866f, -0.06668172f, 0.02662394f, 0.10436173f, 0.18343927f, 0.04202706f, 
    -0.04482311f, 0.01147262f, -0.10112674f, 0.06788546f, -0.24020734f, -0.08332546f, -0.15120609f, 0.01134642f, 
    -0.12886854f, 0.10008168f, -0.07622339f, -0.03953190f, -0.18796785f, 0.08386548f, 0.02313939f, 0.07520675f, 
    -0.16329436f, -0.11448427f, -0.04220765f, 0.07902031f, -0.00208210f, -0.00788918f, -0.04225313f, 0.01460223f, 
    0.05747842f, -0.00230238f, -0.02563992f, 0.11063740f, 0.10656542f, -0.00952083f, 0.06023861f, -0.03338081f, 
    0.06673166f, -0.13994254f, -0.09973519f, -0.02874988f, -0.05359146f, 0.07918537f, -0.10650553f, -0.03745789f, 
    0.00580779f, -0.11106408f, 0.03816274f, -0.06163797f, 0.61838341f, -0.20787281f, 0.18051223f, -0.11105860f, 
    0.07136247f, -0.16005029f, 0.03491307f, 0.06866074f, 0.16261752f, 0.04570333f, -0.04139477f, 0.05104684f, 
    -0.04341657f, 0.18669558f, -0.02765580f, 0.08356078f, 0.00715511f, 0.05945269f, 0.11826388f, -0.10001659f, 
    -0.04382553f, -0.05401087f, 0.02144790f, -0.05248015f, -0.02746948f, 0.04320185f, 0.03015225f, 0.02243085f, 
    -0.06412817f, -0.04417124f, -0.05398933f, -0.05159463f, -0.02901727f, 0.01923221f, -0.00393779f, -0.06313667f, 
    -0.05202935f, 0.01733994f, -0.06256671f, 0.03632931f, -0.02082134f, -0.03703911f, -0.03820212f, -0.05108849f, 
    -0.04418045f, 0.00091533f, 0.04001986f, -0.04359125f, -0.04115429f, -0.02727825f, -0.01872546f, -0.00694851f, 
    -0.00917093f, 0.03403848f, 0.02692596f, 0.03225195f, -0.05940817f, -0.01392080f, 0.03741064f, -0.00415062f, 
    -0.01106662f, 0.03398032f, 0.01559612f, -0.03657467f, -0.04363048f, -0.00157330f, -0.02034545f, -0.05759498f, 
    0.01459157f, 0.02983920f, -0.04910738f, -0.03267153f, 0.00442773f, -0.00055516f, 0.02453441f, 0.02978085f, 
    -0.03697023f, 0.01541023f, -0.00239399f, -0.00028587f, -0.03354319f, -0.00373915f, 0.04523625f, 0.04801613f, 
    -0.01403235f, -0.01776749f, -0.01945432f, 0.02421327f, -0.04449469f, -0.00741046f, -0.01735383f, -0.04420232f, 
    0.01693701f, -0.02752866f, 0.04357148f, -0.06188569f, -0.06167199f, 0.00248058f, -0.01070811f, 0.03549293f, 
    -0.04328376f, 0.04188288f, 0.03304399f, -0.05591493f, -0.00772459f, 0.00830386f, 0.00127725f, 0.01064525f, 
    -0.03972297f, -0.02193554f, 0.00515979f, -0.04091168f, 0.02926130f, 0.02540576f, 0.01615124f, 0.00266723f, 
    0.03928704f, -0.04745820f, 0.04329783f, 0.03814688f, 0.01106977f, 0.03387198f, -0.03650524f, -0.04122159f, 
    0.03238908f, -0.01998021f, -0.00262624f, -0.05558755f, -0.03996430f, 0.04544181f, -0.04542901f, 0.00917712f, 
    0.04557843f, 0.02758045f, 0.02288817f, 0.04357833f, -0.00582825f, -0.03515466f, -0.04649696f, -0.04434614f, 
    0.04409255f, 0.04659067f, 0.03863723f, -0.03701817f, -0.03573766f, -0.05861973f, -0.02768392f, -0.03091827f, 
    0.02471746f, 0.04355196f, 0.02537943f, -0.00168837f, -0.01498011f, -0.01995905f, 0.03275064f, 0.02256686f, 
    -0.04379599f, -0.02060249f, -0.04123997f, 0.04400783f, -0.02636407f, -0.04725941f, -0.00926769f, -0.03506330f, 
    -0.02244744f, 0.02948037f, -0.03842272f, 0.04881283f, 0.03500617f, -0.01332333f, -0.04246700f, -0.04607100f, 
    0.04512116f, 0.00346235f, -0.00712805f, -0.04255876f, -0.03593952f, -0.05599104f, -0.01157042f, 0.03333752f, 
    -0.02296464f, -0.03212798f, -0.01417139f, 0.04022458f, -0.05993375f, 0.02635462f, -0.04372335f, -0.00035675f, 
    -0.05172062f, -0.00531240f, -0.04993591f, 0.01082366f, 0.02028508f, 0.02090107f, 0.04453899f, -0.02705175f, 
    -0.02599200f, -0.01264090f, -0.01040136f, -0.05694123f, 0.00292607f, 0.04723167f, -0.01882354f, -0.03523628f, 
    -0.05677439f, 0.00254252f, -0.01370240f, 0.04919513f, -0.02525166f, -0.04266291f, 0.00582330f, -0.05287057f, 
    -0.00634605f, 0.04063250f, 0.01571915f, 0.00348518f, -0.05156450f, -0.05455927f, 0.02371836f, -0.00118065f, 
    0.00647808f, -0.05750225f, -0.05506997f, -0.00448901f, -0.02329581f, -0.06305972f, 0.02052158f, 0.02152571f, 
    -0.00637519f, -0.00574017f, -0.00501428f, -0.05797390f, 0.02787639f, 0.02536205f, -0.02515644f, -0.01020233f, 
    -0.01756818f, -0.01744561f, 0.05405050f, -0.03831293f, -0.00560117f, 0.00263438f, 0.03439271f, -0.00265734f, 
    0.01742006f, -0.00459079f, -0.01782560f, -0.03108448f, -0.04697408f, -0.00401908f, 0.04372076f, -0.04683340f, 
    -0.01555592f, -0.03377774f, 0.01328253f, -0.03864043f, 0.02922804f, -0.00802433f, 0.03888917f, 0.00783712f, 
    -0.02917092f, -0.00604580f, 0.01339660f, -0.01700975f, -0.01659392f, -0.04985261f, -0.03509143f, -0.01729484f, 
    -0.00526055f, 0.05341148f, -0.03126510f, -0.01975979f, 0.00070335f, -0.02998238f, -0.00912879f, 0.01839777f, 
    -0.03306563f, -0.03450729f, 0.03301413f, -0.02410556f, -0.06408747f, 0.01307890f, 0.00813682f, 0.02568972f, 
    -0.02729413f, 0.00841810f, 0.04710232f, -0.05578234f, -0.01019612f, -0.04683447f, -0.06386393f, 0.01143887f, 
    -0.03127417f, 0.01452939f, 0.01456205f, -0.05217236f, 0.00594144f, -0.01092186f, -0.05733038f, -0.04993411f, 
    0.03518717f, -0.02646638f, -0.05498783f, -0.01720287f, -0.02621151f, -0.00489755f, 0.03280848f, 0.00851731f, 
    0.00280022f, 0.04060941f, -0.04356828f, -0.00056909f, -0.02948675f, 0.04660117f, 0.04172964f, 0.04387001f, 
    -0.04563491f, -0.00839970f, 0.03809668f, -0.01327429f, -0.00963332f, 0.02981303f, -0.02321112f, 0.01365566f, 
    -0.05096884f, -0.00500978f, -0.04622476f, -0.04782621f, 0.00261169f, 0.03016247f, 0.02837482f, 0.05089550f, 
    0.01660414f, -0.04865358f, 0.02240505f, 0.04151533f, 0.01397132f, -0.00903761f, 0.01672720f, -0.00009879f, 
    -0.16058490f, 0.16422892f, 0.43577379f, 0.22619343f, -0.20921546f, -0.05658344f, -0.14078565f, -0.20874593f, 
    0.27707034f, 0.10248693f, -0.00660545f, 0.05473132f, -0.03411221f, -0.11777232f, -0.01236795f, 0.06437556f, 
    -0.02124067f, 0.01714984f, 0.05888892f, -0.07800577f, -0.02892782f, 0.09999895f, 0.26907122f, 0.33494323f, 
    0.08461440f, -0.10560422f, -0.05733068f, 0.00644520f, 0.05652325f, 0.15596953f, 0.04000245f, 0.03794760f, 
    0.11240834f, 0.01365852f, 0.03788587f, -0.04265559f, -0.10153874f, -0.03147317f, 0.01276211f, 0.07495679f, 
    -0.03684014f, -0.06786507f, 0.33006945f, 0.27464110f, -0.01257656f, -0.00479567f, -0.08355060f, -0.03381630f, 
    0.23913835f, 0.02024742f, -0.01629343f, -0.01555383f, 0.02313830f, -0.03243089f, -0.14856538f, 0.12979716f, 
    0.09030659f, 0.04994397f, -0.04248276f, 0.11469412f, -0.11498653f, 0.01435272f, 0.12322575f, -0.01919885f, 
    0.04347015f, 0.08868673f, 0.00271959f, 0.29800993f, 0.10618633f, 0.06334715f, -0.10386413f, 0.02356281f, 
    -0.06839436f, 0.08358052f, -0.01368588f, -0.00451662f, 0.09453468f, -0.07049400f, 0.12319933f, 0.12601218f, 
    -0.16264084f, -0.30248788f, -0.14293887f, -0.03948294f, -0.10883340f, -0.03680326f, 0.02032539f, -0.14704111f, 
    0.00462765f, -0.11925908f, 0.04224454f, -0.01393601f, 0.05105880f, -0.10885562f, -0.04222969f, -0.00123537f, 
    -0.10713179f, 0.02068197f, 0.02810176f, 0.01355794f, 0.20925808f, -0.03095949f, 0.03899525f, 0.26035726f, 
    0.07040942f, -0.05310972f, 0.02076085f, 0.08387873f, -0.04447137f, -0.01593940f, -0.04431057f, -0.02792748f, 
    0.00148232f, 0.09756850f, -0.08696956f, 0.07540647f, 0.03241918f, -0.07218854f, 0.09138606f, 0.13573468f, 
    -0.20920846f, -0.16448395f, 0.10737076f, -0.01494551f, 0.03734770f, -0.03964962f, -0.05820163f, -0.06649700f, 
    -0.04641839f, -0.14882375f, 0.11192525f, 0.19640212f, 0.16107793f, 0.25842896f, 0.06569791f, 0.08887349f, 
    -0.11385226f, 0.00893791f, -0.12967299f, -0.07869585f, 0.12133679f, -0.00870125f, 0.12849140f, 0.07950930f, 
    -0.02965115f, 0.10333216f, 0.02377117f, 0.01502668f, 0.12599453f, 0.03176788f, -0.02811383f, 0.07345434f, 
    0.01022970f, 0.04999168f, 0.10299000f, -0.03743640f, 0.14286144f, 0.06761524f, 0.15794343f, 0.03497571f, 
    -0.24485393f, -0.17832515f, -0.27548832f, -0.14060453f, -0.30565870f, 0.08119763f, -0.01069203f, 0.07560626f, 
    -0.14693572f, -0.16530621f, -0.03462476f, 0.00094354f, -0.04142736f, 0.00154864f, -0.09323390f, 0.07583573f, 
    -0.04155690f, 0.20794223f, 0.11071219f, 0.01173396f, 0.13192414f, -0.16791396f, -0.06411032f, -0.14620481f, 
    0.10081707f, -0.01166221f, -0.03351983f, -0.03552375f, -0.13673544f, -0.10570304f, -0.09249604f, -0.01605538f, 
    -0.03240915f, -0.05070462f, -0.05600890f, 0.06807067f, -0.09729455f, -0.15463661f, 0.04993023f, 0.07054844f, 
    -0.10599033f, -0.09104830f, -0.37691000f, 0.23817202f, 0.00796062f, -0.07930072f, -0.06729383f, 0.10529916f, 
    0.18208948f, -0.13814636f, 0.03223052f, -0.03530708f, 0.06181712f, 0.02740350f, 0.08351833f, -0.06470449f, 
    -0.10175019f, 0.05610229f, 0.10553334f, -0.08235936f, -0.14913006f, 0.14777541f, -0.19539356f, 0.22025622f, 
    -0.31661856f, 0.05905530f, 0.05233845f, 0.10648622f, 0.34513083f, -0.09747998f, -0.16654979f, 0.11344615f, 
    0.02290088f, 0.14622886f, 0.12825714f, 0.04441002f, 0.10425574f, 0.13895375f, 0.09555172f, -0.01893635f, 
    0.14827582f, 0.02174374f, 0.03748148f, -0.04472230f, 0.34758675f, -0.18923207f, 0.21184997f, 0.37344667f, 
    0.01174388f, -0.02615538f, -0.04563391f, -0.01288563f, 0.00006072f, 0.10323897f, -0.02564775f, 0.14686896f, 
    0.14261782f, -0.07927986f, 0.21854024f, 0.06848606f, 0.06553295f, -0.00459781f, 0.18135402f, 0.16580364f, 
    0.10126051f, -0.03611512f, 0.07362846f, -0.05175198f, -0.00204401f, 0.07296140f, -0.01100814f, 0.05708499f, 
    0.00141930f, -0.02570656f, -0.00865441f, -0.03647870f, -0.06657341f, -0.07663687f, -0.00936335f, 0.01508691f, 
    -0.33234480f, -0.00923150f, -0.37675178f, 0.01040255f, -0.28229204f, 0.07124071f, -0.06229875f, -0.14233512f, 
    0.05580859f, 0.10012379f, -0.00442676f, -0.03378011f, 0.04198933f, -0.09984497f, -0.00143674f, 0.02556697f, 
    -0.01863282f, 0.05256416f, 0.12913789f, 0.03269567f, -0.38092566f, -0.16209555f, 0.09360033f, 0.35925066f, 
    0.00955742f, -0.24940328f, -0.04034176f, 0.09690545f, -0.08164842f, 0.14679624f, -0.12118438f, -0.02406872f, 
    -0.07562168f, -0.01511259f, 0.01894566f, 0.17142113f, 0.08242420f, -0.01889680f, 0.17450626f, 0.08377998f, 
    0.29379946f, -0.11612943f, -0.35079706f, -0.01093042f, -0.12125473f, 0.03002768f, -0.09150161f, -0.09763847f, 
    -0.06426617f, -0.13643838f, -0.05038925f, 0.12926649f, 0.05331670f, 0.21901058f, 0.24029624f, 0.09775071f, 
    -0.02381307f, 0.13240154f, 0.10169767f, 0.16155322f, 0.18730074f, -0.02306829f, -0.27364749f, -0.32364830f, 
    -0.10083938f, 0.08185763f, 0.01296693f, -0.25624442f, -0.08095783f, -0.33292636f, 0.07477354f, 0.03501888f, 
    -0.04860757f, 0.03116927f, -0.02605320f, -0.08119287f, 0.06971136f, -0.02540739f, 0.11289783f, -0.10473896f, 
    0.15159789f, -0.16436107f, -0.47165936f, -0.03589951f, -0.25657976f, -0.04014894f, -0.18309489f, 0.02422241f, 
    0.01847077f, -0.00493718f, 0.01731716f, 0.10924046f, -0.09195816f, 0.20031126f, 0.10106182f, 0.03879305f, 
    -0.05125184f, 0.03496825f, -0.02778910f, 0.23824966f, -0.22739908f, 0.35966316f, 0.06938972f, -0.02898792f, 
    0.09702816f, 0.07909647f, -0.20035709f, 0.17693639f, -0.00458176f, -0.16703945f, -0.05410760f, -0.00212925f, 
    -0.04073131f, -0.00263764f, 0.05171303f, -0.01200377f, 0.03730184f, -0.06297024f, -0.17975444f, -0.07606899f, 
    0.15730222f, -0.03896349f, -0.01510584f, 0.02981011f, 0.25087458f, -0.01597713f, 0.17143339f, 0.24209052f, 
    0.13974491f, 0.35487032f, 0.03208277f, -0.02542756f, 0.07825589f, -0.09843469f, -0.09456240f, 0.01982905f, 
    -0.25982869f, -0.13081445f, -0.03187272f, -0.17235425f, 0.10480075f, 0.06646310f, 0.15989922f, 0.06511232f, 
    0.09317102f, 0.01504450f, 0.08687675f, 0.16767879f, 0.09834506f, -0.00708458f, -0.12446091f, -0.06069498f, 
    -0.14169739f, -0.01313219f, 0.00089720f, -0.00624891f, 0.16671921f, 0.06221832f, -0.00429001f, 0.00104078f, 
    0.36757547f, 0.15604323f, 0.25809857f, 0.34957400f, -0.02359483f, -0.07054524f, -0.28020427f, -0.14673600f, 
    -0.35914668f, -0.55090874f, 0.14071018f, -0.01528402f, 0.16902405f, -0.11992221f, -0.04372222f, 0.10477348f, 
    -0.08946558f, -0.25345683f, -0.15064459f, -0.18511955f, 0.21250443f, 0.10354556f, 0.15230919f, -0.02923998f, 
    -0.03531742f, -0.20902456f, -0.01693808f, -0.04645387f, -0.07311519f, -0.14567414f, -0.02268050f, -0.07867305f, 
    -0.15639678f, 0.12427581f, -0.06226948f, -0.04193800f, -0.03364658f, 0.06670977f, -0.18610972f, -0.09443942f, 
    0.11913587f, 0.03389729f, -0.10633047f, 0.13355400f, 0.23329273f, 0.09563527f, 0.16204050f, 0.01526002f, 
    0.20269717f, 0.26908347f, -0.08549337f, -0.00579781f, -0.17909735f, -0.10879142f, -0.04417503f, -0.12319425f, 
    -0.08033831f, -0.07993139f, 0.07692026f, -0.06878063f, 0.43093780f, 0.09845380f, 0.15221956f, 0.07829384f, 
    -0.00776302f, 0.01023915f, 0.14464517f, 0.27108952f, 0.12818557f, 0.19209492f, -0.00211717f, -0.13928609f, 
    -0.01298464f, 0.00901524f, 0.00334336f, 0.06749779f, -0.00683728f, 0.07147443f, 0.11653308f, 0.06335835f, 
    -0.06101600f, 0.11623338f, -0.03954072f, -0.03475732f, 0.24405704f, 0.13451834f, 0.18640554f, -0.07651103f, 
    0.25986779f, 0.17803957f, -0.05348247f, -0.00273000f, -0.08960913f, 0.18060173f, 0.05713930f, 0.05781426f, 
    -0.23386602f, -0.01984742f, 0.04113510f, 0.12084626f, -0.04030600f, 0.03302821f, -0.07411005f, 0.12815595f, 
    0.19327067f, 0.01262509f, 0.10018737f, 0.24484682f, 0.05188712f, 0.12792201f, 0.00974079f, -0.06645621f, 
    -0.04809444f, 0.08599749f, 0.19323759f, -0.05229003f, 0.00655111f, -0.04291628f, 0.01967595f, 0.04677369f, 
    -0.12555052f, 0.12726282f, 0.20402725f, -0.04908549f, -0.10376488f, -0.10805365f, -0.00465036f, -0.11137713f, 
    -0.09055533f, -0.19550712f, -0.25146762f, 0.09013907f, -0.03292191f, -0.11205064f, -0.04361292f, 0.12099740f, 
    -0.14006224f, -0.23573947f, -0.08043912f, -0.05026913f, 0.21219617f, 0.31993589f, -0.10058580f, -0.28917238f, 
    -0.04176800f, -0.04017446f, -0.06127980f, -0.25409257f, -0.10204160f, -0.26798710f, 0.01120577f, -0.05372726f, 
    0.06449807f, 0.08122458f, 0.13026918f, -0.04088525f, -0.00145505f, -0.24632052f, -0.02586499f, -0.11468291f, 
    -0.29405290f, -0.02529449f, -0.09474814f, 0.11012674f, 0.27534184f, -0.02498064f, 0.00433993f, 0.09797301f, 
    0.08418728f, 0.13766883f, -0.07791199f, -0.03548634f, -0.07939330f, -0.10884956f, 0.03803953f, -0.13637456f, 
    0.02064792f, 0.02823702f, 0.00184191f, 0.00575855f, 0.43517846f, 0.02540769f, -0.23257411f, -0.13768864f, 
    -0.02162491f, 0.05096008f, 0.22321278f, 0.06437698f, 0.09898428f, 0.01530837f, 0.19422112f, -0.15420340f, 
    -0.07116468f, 0.06397879f, 0.25586486f, -0.09589902f, 0.21676005f, 0.15221974f, -0.00489418f, 0.07714225f, 
    -0.04763792f, -0.07977637f, -0.04696363f, -0.05545272f, 0.02135650f, 0.01752991f, -0.03769458f, -0.05698457f, 
    -0.02083597f, 0.04549091f, -0.02088546f, -0.04806627f, -0.05396516f, 0.03914876f, 0.05374099f, -0.07067015f, 
    -0.06269567f, -0.01039459f, -0.08045566f, -0.05997897f, -0.00402430f, -0.04424624f, 0.03205575f, -0.03239630f, 
    0.02682294f, 0.01556591f, 0.00648788f, 0.00737921f, -0.03384241f, -0.07668354f, 0.01422393f, -0.04414982f, 
    -0.08595365f, 0.02152001f, -0.03099437f, 0.02980516f, -0.01200695f, 0.01915224f, 0.00164673f, 0.03042423f, 
    -0.00830011f, -0.02601670f, -0.04863882f, -0.06755107f, -0.09005401f, -0.06791088f, -0.00293669f, 0.01961818f, 
    -0.05472188f, -0.01449638f, -0.02035583f, -0.04436974f, -0.07251625f, 0.02545544f, 0.01775527f, -0.00552171f, 
    0.01276193f, 0.04560791f, 0.00059627f, 0.00749754f, -0.06048058f, -0.05347900f, -0.01520800f, -0.03772467f, 
    -0.04816207f, -0.03020810f, -0.03172053f, 0.05656169f, -0.01396546f, -0.05589160f, 0.03049845f, 0.02497992f, 
    0.00893765f, 0.04069334f, -0.05495022f, 0.03590426f, -0.05221558f, -0.00373425f, -0.01959760f, 0.02847007f, 
    -0.02482659f, -0.05876463f, 0.01917916f, -0.00656239f, -0.01047518f, 0.00612616f, -0.00127848f, -0.04154560f, 
    -0.07506777f, -0.07048380f, -0.04859154f, -0.00305304f, -0.08080639f, -0.03454705f, 0.02402035f, -0.05072418f, 
    0.02582770f, 0.01605815f, -0.01098124f, 0.04490301f, -0.01143732f, -0.04557905f, -0.05108494f, 0.00055856f, 
    0.01657354f, -0.03952152f, 0.00959603f, -0.00466397f, -0.00162323f, 0.04437567f, -0.04644120f, -0.02248654f, 
    -0.05101066f, -0.01083532f, -0.07804396f, 0.01907931f, 0.02166519f, 0.02457084f, -0.02370500f, 0.01345993f, 
    0.00127163f, 0.00006876f, -0.02237879f, -0.01613829f, -0.02868524f, -0.03838751f, -0.01755958f, -0.02073724f, 
    0.01729040f, -0.05171431f, -0.04861945f, -0.08140970f, -0.02678447f, -0.06392383f, -0.02737214f, 0.01512298f, 
    -0.02854644f, -0.03347928f, -0.02800364f, 0.05770983f, -0.02528309f, -0.00438272f, -0.04500555f, -0.04189780f, 
    -0.06058265f, -0.05206888f, 0.02363388f, 0.02304004f, 0.00113937f, -0.01315854f, -0.04352010f, -0.01782077f, 
    0.00830212f, -0.05140705f, -0.04429929f, -0.02782853f, 0.03172319f, 0.00734901f, -0.05507151f, -0.01398568f, 
    0.02954146f, 0.03983318f, -0.05187175f, 0.01992775f, -0.07435554f, -0.02516848f, -0.04331129f, -0.03266754f, 
    -0.04205712f, -0.00304278f, -0.02250883f, 0.00575257f, -0.03153282f, -0.02632970f, -0.03396348f, 0.01433373f, 
    -0.03001302f, 0.04599028f, 0.00802405f, 0.00731141f, -0.01763353f, -0.03536941f, 0.03068881f, -0.04924360f, 
    -0.06995890f, -0.04511421f, -0.00051756f, 0.02267550f, 0.03370834f, 0.02889674f, -0.04057897f, 0.04327703f, 
    -0.03765796f, 0.04479768f, -0.06913956f, -0.07830615f, -0.00254410f, -0.08024124f, -0.06383529f, -0.06309368f, 
    -0.06749754f, -0.02195384f, -0.00220151f, 0.01910853f, -0.07200798f, 0.02572214f, 0.00829182f, 0.02520857f, 
    0.03066193f, 0.03059822f, -0.00425950f, 0.03769841f, -0.01462636f, 0.00060646f, 0.02329190f, 0.01482164f, 
    -0.02527541f, -0.00259630f, 0.00702309f, -0.09490670f, -0.00723399f, 0.00278305f, 0.01268329f, -0.01042002f, 
    -0.07157631f, -0.04677102f, -0.05223840f, 0.02017933f, -0.03052858f, -0.01331489f, 0.01670515f, 0.04680809f, 
    0.00953405f, -0.03538716f, -0.08538751f, 0.04714819f, -0.03750323f, -0.01154069f, -0.00561014f, -0.03279477f, 
    0.03651781f, -0.05568762f, -0.01963371f, 0.04165189f, -0.02779923f, 0.00180150f, -0.00966134f, 0.05815787f, 
    -0.06936271f, 0.00051349f, 0.02610355f, -0.02681388f, -0.02244061f, -0.02674129f, 0.06447354f, 0.01948337f, 
    -0.07142230f, 0.00416234f, 0.06007234f, 0.03809392f, -0.02686905f, -0.03897614f, -0.00322778f, -0.06566016f, 
    -0.07123363f, -0.00684155f, 0.00186999f, 0.01926317f, 0.02078440f, -0.03282661f, -0.04054343f, -0.01949072f, 
    -0.04522611f, -0.06882896f, -0.00187712f, -0.01419811f, 0.02678714f, 0.00417535f, 0.04357253f, 0.03083228f, 
    -0.00948496f, -0.04476710f, -0.02975531f, -0.03177762f, -0.06926066f, 0.00794065f, -0.01953043f, -0.01506609f, 
    0.05459673f, -0.03203457f, -0.03355002f, -0.03213039f, 0.04840340f, 0.05521918f, -0.02809188f, -0.06528977f, 
    0.04236476f, -0.05579337f, -0.00085716f, 0.00673151f, 0.01361616f, -0.04387127f, -0.02602588f, 0.00850882f, 
    -0.04104788f, 0.02902958f, -0.00357622f, -0.05727062f, -0.03472154f, -0.00147821f, -0.02923878f, -0.04591443f, 
    0.01199570f, 0.04934260f, 0.04336378f, -0.01023514f, 0.05350008f, 0.00555039f, -0.02163615f, 0.00443006f, 
    -0.21377189f, -0.00697982f, 0.17889161f, 0.15575396f, -0.37440756f, -0.02777882f, -0.03825457f, -0.16940796f, 
    0.04932022f, 0.03953693f, -0.04630264f, -0.06388635f, -0.07229173f, -0.01529491f, -0.04724122f, -0.08596538f, 
    0.04902634f, -0.04486292f, -0.06713845f, -0.09032492f, 0.01586585f, -0.21276468f, -0.05740044f, 0.23723263f, 
    -0.28914994f, -0.06513486f, -0.10353564f, 0.01356629f, -0.00512439f, 0.04790331f, 0.07183159f, 0.08645905f, 
    0.12165400f, -0.01787673f, -0.03013510f, 0.05772851f, 0.04503044f, -0.00523601f, 0.00310375f, 0.08309375f, 
    -0.24637921f, 0.00997658f, 0.22036274f, 0.13102172f, -0.37047529f, -0.04162586f, -0.01911730f, -0.10444003f, 
    -0.07280480f, -0.10477239f, 0.08309647f, -0.02030171f, -0.18007071f, -0.01903750f, 0.01785690f, 0.04496087f, 
    -0.06411649f, -0.00277993f, -0.11273761f, -0.01385473f, -0.08506315f, -0.12158001f, 0.06343524f, 0.00930304f, 
    -0.16107099f, 0.01822262f, 0.03000822f, -0.06608437f, -0.17977674f, 0.07810811f, -0.10386522f, -0.04467335f, 
    -0.02445596f, 0.02152588f, -0.01532982f, 0.14112820f, 0.10272590f, 0.13528648f, 0.00126876f, 0.01365043f, 
    -0.28853229f, -0.00395659f, 0.13932911f, 0.03713454f, -0.12177081f, 0.11472697f, 0.04965254f, 0.16417231f, 
    -0.00492504f, 0.19396883f, -0.20788966f, -0.01196068f, 0.01217664f, 0.02058235f, -0.07151503f, 0.03793049f, 
    -0.04129277f, -0.11195819f, -0.00039943f, -0.05750878f, 0.38099924f, 0.08756734f, -0.32101691f, 0.16660307f, 
    0.00692131f, -0.10577855f, -0.12256709f, -0.00040419f, -0.07763933f, -0.07498109f, -0.08636939f, 0.03283799f, 
    0.01535662f, 0.03190442f, 0.02666901f, 0.03698818f, 0.05461636f, 0.07315242f, 0.06785574f, 0.06852388f, 
    0.22014077f, -0.08062039f, 0.05146923f, 0.15354106f, 0.06553400f, -0.13518527f, -0.11953437f, -0.05807259f, 
    -0.05863153f, -0.06633767f, 0.15699840f, 0.15714687f, -0.11583009f, 0.12388809f, 0.11610944f, -0.01275724f, 
    -0.02979249f, 0.00396991f, 0.06089012f, -0.09781840f, 0.17812565f, 0.00145752f, -0.01333607f, -0.05909829f, 
    0.11886937f, 0.04992416f, 0.00581135f, -0.01991619f, 0.01389286f, -0.09771797f, 0.01045532f, 0.03941497f, 
    0.06795134f, -0.01121296f, -0.06558092f, 0.08680843f, 0.03784518f, 0.00067569f, 0.14631952f, 0.06964773f, 
    -0.06320822f, 0.21860924f, 0.29839474f, 0.21239597f, -0.20466378f, 0.05330598f, -0.09098651f, 0.03213711f, 
    -0.00213348f, 0.17865160f, -0.04324895f, 0.09767371f, 0.00927172f, 0.07392451f, -0.05130202f, 0.04919957f, 
    0.05334510f, -0.01341273f, -0.04693232f, 0.06797004f, 0.35482779f, 0.02588634f, -0.37715304f, 0.24220368f, 
    0.00468914f, -0.05857788f, -0.17701681f, -0.05978641f, -0.10784742f, -0.00425926f, -0.06267326f, 0.00867152f, 
    -0.10220136f, -0.11018424f, -0.04418797f, 0.02013830f, -0.02507645f, -0.01324601f, -0.07039983f, 0.04851606f, 
    -0.09172409f, -0.18038034f, 0.11909579f, 0.18269873f, -0.01658762f, 0.09006336f, -0.00472543f, 0.05093263f, 
    0.12661703f, -0.00982518f, 0.12625138f, -0.01273707f, 0.12383516f, 0.01900793f, 0.04712681f, 0.01389672f, 
    0.09670757f, -0.21290083f, -0.13957199f, 0.05112510f, 0.24005510f, -0.02694437f, 0.30774897f, -0.18496670f, 
    -0.10533549f, 0.09599667f, 0.00322546f, 0.02899102f, 0.17316143f, 0.08508000f, -0.03192492f, -0.10455336f, 
    0.07179647f, -0.04304943f, -0.00217170f, 0.10757873f, -0.02675263f, -0.06625296f, 0.06847619f, 0.00050944f, 
    -0.41141656f, -0.31108046f, 0.17833154f, 0.11730961f, 0.03982956f, -0.01187882f, -0.03852459f, 0.03590060f, 
    -0.03578617f, -0.02694608f, -0.00911051f, 0.00050039f, 0.04296827f, 0.08918739f, 0.03272158f, 0.06322765f, 
    0.08010217f, 0.22332744f, -0.04548576f, 0.11293935f, 0.13328928f, -0.16657762f, -0.05335708f, 0.12092359f, 
    -0.07880187f, -0.04571217f, 0.02922304f, -0.04979311f, -0.03314919f, -0.00997739f, 0.03105476f, 0.00392062f, 
    -0.01757432f, 0.03940201f, 0.06699751f, 0.01113456f, -0.06541868f, 0.05265277f, -0.04165991f, -0.05387802f, 
    0.11744257f, 0.15696755f, 0.29382658f, 0.16508445f, 0.05383683f, 0.13086024f, -0.06794582f, 0.03000128f, 
    0.18558888f, 0.13967644f, -0.01023454f, 0.05709179f, 0.01669117f, -0.04300196f, 0.03883765f, 0.03063317f, 
    0.00364987f, -0.16659458f, 0.03486883f, -0.10479221f, -0.42349923f, -0.08802643f, 0.15822163f, 0.31847200f, 
    -0.07381450f, 0.07835064f, 0.10816528f, 0.06881078f, -0.09990320f, -0.01583421f, -0.04578545f, 0.03995479f, 
    -0.00738888f, -0.03812989f, 0.02557871f, 0.08033726f, -0.10029191f, 0.01551379f, 0.04261487f, -0.05516388f, 
    0.13505463f, -0.02229003f, -0.19553465f, -0.06489312f, -0.03432593f, 0.04142600f, 0.13726681f, 0.25858247f, 
    0.02217183f, 0.10492379f, 0.02323745f, -0.05913189f, -0.01908047f, -0.00210510f, -0.06853831f, 0.06814001f, 
    -0.08384912f, -0.10826324f, 0.03306028f, -0.09074870f, -0.23187704f, 0.00655346f, -0.29587799f, -0.28727236f, 
    -0.16461974f, -0.03713185f, 0.06040811f, 0.16682890f, 0.10788050f, 0.16676839f, 0.03272801f, -0.00900127f, 
    0.00105426f, -0.05797482f, -0.08294143f, -0.10230048f, -0.00824432f, -0.09237524f, -0.03659447f, -0.02446148f, 
    0.24954465f, -0.07600985f, 0.02261937f, 0.00553473f, -0.03499583f, 0.04719739f, 0.12499403f, 0.16789505f, 
    0.06763379f, -0.09434607f, 0.08899774f, -0.09503566f, 0.07822096f, -0.01184818f, -0.01448109f, 0.16915323f, 
    -0.05692558f, -0.00412003f, 0.19211289f, 0.04757670f, 0.13028210f, 0.02083221f, 0.13642614f, -0.06732099f, 
    -0.03945946f, -0.01774564f, 0.00504507f, 0.00121654f, 0.12055616f, 0.04773519f, 0.08780053f, -0.00008030f, 
    -0.03429501f, 0.10945681f, -0.09589297f, 0.04194015f, 0.07256981f, -0.03741481f, 0.17055234f, 0.09587251f, 
    0.00462232f, -0.02175949f, -0.08807021f, 0.16790670f, -0.25705710f, -0.22720270f, -0.01997789f, -0.33047396f, 
    0.01735825f, -0.17898040f, 0.07312406f, -0.01450577f, -0.15576211f, 0.00966811f, 0.01200805f, -0.18293077f, 
    0.05099864f, 0.09562012f, 0.07236934f, -0.05838679f, 0.02843264f, 0.39342970f, 0.22010635f, 0.16648136f, 
    0.01138084f, -0.02118325f, -0.08758151f, 0.07871270f, -0.09106337f, -0.09487804f, -0.09704593f, -0.03223694f, 
    0.00921671f, -0.06022586f, -0.10607750f, 0.06509522f, -0.01738130f, -0.02378530f, 0.19666362f, -0.04124198f, 
    0.04006898f, 0.18047032f, 0.14018242f, 0.06453031f, 0.14461787f, -0.20061731f, -0.03730922f, -0.06355929f, 
    0.02330824f, -0.16466069f, 0.15520220f, 0.14525996f, 0.13709389f, 0.15126844f, 0.14878173f, -0.07017051f, 
    -0.07985968f, -0.05733269f, -0.04813774f, 0.00980397f, 0.24763152f, 0.10484484f, -0.02935892f, 0.23761670f, 
    -0.00396780f, 0.01298695f, 0.04944952f, 0.05779803f, -0.11571188f, -0.05073074f, 0.00882690f, 0.06846098f, 
    0.01660819f, 0.05521716f, 0.05626815f, 0.09428389f, 0.25908098f, -0.02720921f, -0.09685897f, 0.01943976f, 
    -0.01351921f, 0.08354215f, -0.03169474f, -0.27242756f, -0.27993926f, 0.11118798f, -0.10486380f, -0.06223404f, 
    0.11538202f, -0.08974247f, 0.01246527f, -0.08173642f, -0.01407482f, 0.05718433f, 0.02849813f, 0.10025036f, 
    0.02232041f, 0.11642269f, 0.01879682f, 0.05775409f, -0.00137271f, 0.27552956f, 0.00990930f, -0.26536250f, 
    -0.28156528f, -0.05283541f, -0.06676021f, -0.12946117f, -0.07078192f, -0.22467622f, -0.07841858f, -0.09443486f, 
    -0.08662752f, -0.05646535f, -0.06804495f, 0.05575278f, 0.11540365f, -0.00979874f, 0.05507708f, -0.02017626f, 
    0.49145988f, 0.08760555f, -0.09651840f, -0.25038970f, 0.06342795f, 0.07479265f, -0.02088492f, -0.02052414f, 
    0.23270965f, 0.08316007f, 0.01410688f, -0.10558433f, -0.08238803f, -0.01885081f, -0.09882026f, -0.07163861f, 
    -0.01875087f, 0.07575301f, 0.16211180f, -0.05955318f, 0.38114935f, 0.02478854f, -0.06881813f, -0.02030651f, 
    -0.06849350f, 0.06752524f, 0.10029317f, 0.06046206f, -0.01285332f, -0.07308065f, 0.09830894f, 0.07091638f, 
    0.04983393f, 0.04904649f, 0.14141679f, 0.13907841f, 0.12027094f, 0.22837649f, 0.02908404f, 0.09699966f, 
    0.11154862f, 0.20549902f, 0.09874196f, 0.06249222f, 0.40863645f, -0.01106311f, 0.15902753f, 0.12050126f, 
    0.16374995f, -0.02258796f, 0.03231876f, 0.12693484f, 0.00467929f, 0.02216380f, -0.00458524f, 0.00186553f, 
    0.11423466f, -0.10622635f, 0.13841085f, 0.00942104f, -0.03457702f, -0.01212813f, -0.01129611f, -0.05329711f, 
    0.00632070f, -0.17319317f, 0.04808499f, 0.00643772f, 0.09367739f, -0.00543425f, 0.18587913f, 0.04959792f, 
    0.18230313f, 0.07431051f, -0.02553642f, -0.09930311f, 0.07455204f, 0.03325778f, 0.05644028f, 0.06476282f, 
    0.14364481f, -0.05193540f, 0.00028305f, -0.13067466f, -0.06277131f, 0.18269561f, -0.04871187f, 0.09804970f, 
    -0.14889649f, 0.03688342f, 0.04144737f, -0.07403407f, -0.03409524f, -0.03644892f, 0.01040396f, -0.01015411f, 
    0.02798632f, 0.29603142f, -0.05052890f, 0.09355612f, -0.40251872f, 0.30634040f, 0.21078447f, -0.18221104f, 
    0.13326891f, 0.17523234f, -0.01484173f, 0.06996377f, 0.05218674f, -0.01053454f, -0.10898060f, -0.13999243f, 
    0.01265832f, -0.10536559f, -0.00118864f, 0.05397368f, -0.01193334f, -0.08763669f, -0.09005108f, -0.12993188f, 
    0.28608891f, 0.31124982f, 0.04195784f, 0.15580173f, 0.24735156f, -0.00727280f, 0.15506037f, 0.06402073f, 
    -0.07095294f, 0.07460886f, 0.10282749f, 0.17449661f, -0.11596068f, 0.06563175f, -0.01254877f, 0.09264296f, 
    -0.04325375f, 0.03360381f, 0.07633190f, 0.04258794f, 0.08670380f, 0.27498072f, 0.04348312f, -0.04652424f, 
    0.25569305f, -0.18286167f, 0.07500257f, 0.14774564f, -0.05618834f, -0.01607227f, 0.02196207f, 0.10163464f, 
    -0.04392009f, 0.01769616f, -0.18278600f, -0.06005181f, -0.10694193f, 0.03491976f, 0.13109289f, -0.14371556f, 
    0.29711771f, 0.06427860f, 0.15552843f, 0.06822371f, 0.00175132f, 0.16485192f, 0.19337893f, 0.17113297f, 
    0.17898813f, 0.10652664f, 0.04762496f, 0.06413636f, -0.03945968f, 0.04702894f, 0.07700176f, 0.04337362f, 
    -0.03767658f, 0.03525319f, -0.00322726f, 0.00166687f, -0.89231658f, -0.80866152f, 0.16102235f, -0.16077043f, 
    -0.38975194f, -0.08136224f, -0.09070890f, 0.00340642f, 0.00466173f, -0.08243643f, -0.06260041f, 0.06542292f, 
    0.01113799f, 0.03038893f, 0.02090385f, -0.10588454f, -0.05811412f, -0.04315851f, -0.04585762f, -0.06283011f, 
    0.12258729f, 0.41597423f, 0.12099353f, 0.13005254f, 0.15372284f, 0.00242881f, 0.26145113f, 0.20267364f, 
    0.06918570f, 0.27676424f, -0.03664371f, 0.08595486f, 0.16568674f, 0.00061043f, -0.01166836f, -0.15255913f, 
    -0.23631784f, -0.12741193f, 0.09172983f, 0.15344386f, -0.33548367f, -0.14663316f, 0.06255690f, -0.03900546f, 
    -0.06324836f, -0.09088480f, -0.14975536f, -0.15968052f, -0.04397531f, -0.10355011f, 0.01822517f, 0.03235550f, 
    -0.03269601f, -0.07838723f, -0.12733757f, -0.01689390f, -0.07370972f, 0.04871025f, 0.00671280f, -0.02022242f, 
    0.09906407f, -0.09683507f, -0.07647995f, 0.05135399f, -0.15211147f, 0.14244698f, 0.10877229f, 0.13892488f, 
    0.08464713f, 0.13213931f, -0.08133889f, 0.02709434f, 0.20286344f, -0.08315094f, 0.00721065f, -0.05939451f, 
    -0.09535673f, -0.10968938f, -0.04999065f, 0.04421613f, -0.19574395f, -0.19795538f, -0.40681094f, -0.12891698f, 
    -0.29531962f, 0.08941635f, -0.06467870f, -0.06947169f, -0.02594580f, -0.09412762f, -0.15260616f, 0.12657715f, 
    0.10158266f, 0.00250183f, -0.03847052f, -0.12300262f, -0.01021844f, 0.04512188f, -0.04150239f, -0.12147067f, 
    0.01682420f, 0.14901792f, 0.33497488f, 0.15403618f, 0.01131277f, 0.01302827f, -0.01817419f, -0.00628790f, 
    0.10312540f, 0.10228186f, -0.07704377f, -0.04523381f, -0.01755450f, -0.00496825f, 0.06655172f, -0.08917589f, 
    -0.10161105f, -0.06923401f, -0.09939633f, 0.08593774f, 0.01733635f, -0.09451897f, -0.19005254f, -0.16084249f, 
    -0.00963937f, -0.13318229f, -0.08666575f, -0.19073786f, -0.11659454f, -0.05324196f, 0.11638851f, 0.10440654f, 
    0.02552715f, -0.02080693f, -0.06406738f, 0.05499904f, 0.06155167f, -0.10428219f, 0.18371356f, 0.06715816f, 
    0.33339342f, 0.25108701f, 0.06329993f, -0.06256376f, 0.32406750f, 0.13114713f, -0.03521867f, 0.08864949f, 
    0.01887463f, 0.03497056f, 0.13500604f, -0.08498970f, -0.03204416f, -0.00364610f, 0.05742253f, 0.01989398f, 
    -0.10854464f, 0.07714371f, -0.01507688f, 0.05832780f, 0.24993573f, 0.08185831f, 0.04413671f, 0.20931752f, 
    0.03047570f, 0.02274160f, -0.02358581f, 0.02219531f, 0.05986371f, -0.10721733f, 0.06366035f, -0.13995650f, 
    -0.05689128f, 0.24803865f, -0.08244722f, -0.06737159f, 0.10067902f, -0.14681274f, 0.00659563f, -0.00667920f, 
    -0.63175249f, -0.57308537f, 0.54720235f, -0.40935555f, 0.00167198f, -0.31710723f, 0.01667611f, 0.02524201f, 
    0.18929499f, -0.22260225f, 0.07720608f, -0.02049484f, 0.07109994f, 0.03867930f, -0.10988490f, 0.21090701f, 
    -0.03575569f, -0.15686728f, -0.04861532f, -0.12367505f, 0.12115583f, 0.13847905f, -0.03046457f, -0.13397948f, 
    0.06752615f, -0.08020649f, -0.04427025f, 0.12431735f, -0.02209692f, -0.04049874f, -0.06518704f, -0.01709363f, 
    -0.01716285f, -0.11689854f, -0.14861433f, -0.21534392f, 0.07168362f, 0.07795420f, -0.09347884f, -0.06778105f, 
    0.07000594f, 0.27656946f, 0.06700139f, 0.04484704f, 0.23616816f, 0.00037678f, -0.06573319f, -0.01621551f, 
    -0.06429330f, -0.05594185f, -0.02949065f, 0.00163661f, -0.02565811f, -0.05106456f, 0.07000939f, -0.05947758f, 
    0.03223632f, -0.12493446f, -0.04718290f, 0.06675586f, 0.14093019f, 0.23741803f, 0.33385563f, 0.12175363f, 
    0.15176518f, 0.03461492f, 0.20263724f, 0.02282319f, 0.01769181f, 0.00157063f, -0.12070985f, 0.01180536f, 
    -0.03731189f, 0.08217420f, 0.04525361f, 0.07370197f, 0.12113342f, 0.16036852f, -0.09636647f, -0.13840061f, 
    -0.05108451f, 0.07032342f, 0.22292407f, 0.05956529f, 0.21211761f, -0.17941879f, -0.12443476f, -0.04248295f, 
    0.15126541f, -0.03025991f, -0.10237116f, 0.09165452f, 0.08522116f, 0.02784664f, 0.20675768f, 0.07479958f, 
    0.05545989f, 0.09864826f, 0.00248794f, 0.01643731f, 0.10184310f, -0.15162449f, 0.01517891f, 0.08278350f, 
    0.15181684f, -0.02749085f, -0.06534701f, 0.07449813f, 0.04026854f, -0.14075206f, -0.12509485f, 0.05091641f, 
    0.00162565f, -0.00983941f, 0.05208606f, -0.05005690f, -0.02745860f, 0.04771794f, -0.09857563f, -0.23807737f, 
    -0.03947810f, -0.11461343f, 0.22538504f, 0.20544036f, 0.09214937f, 0.01971376f, 0.00780589f, 0.00908227f, 
    0.06967736f, 0.13233021f, -0.07800730f, 0.00132693f, 0.08830327f, 0.11751461f, 0.10935479f, -0.01220983f, 
    0.19674395f, 0.05322950f, 0.01988275f, 0.17608531f, -0.18707584f, 0.00212655f, 0.43656275f, 0.01052828f, 
    0.22934917f, 0.13301124f, 0.21088313f, -0.05985351f, 0.11646364f, -0.11007782f, -0.05627623f, -0.03719940f, 
    -0.01631011f, -0.00099213f, 0.01096788f, 0.02714073f, -0.07657953f, -0.04622015f, -0.24018688f, 0.05350788f, 
    -0.18471809f, -0.32637119f, -0.26076403f, 0.34468651f, 0.25647032f, 0.10802220f, -0.01688833f, 0.20792539f, 
    0.01411914f, 0.08764256f, 0.10875798f, -0.03220599f, -0.01838547f, -0.11733063f, -0.08815332f, 0.00989301f, 
    -0.15217590f, -0.20046188f, 0.06326020f, -0.17676096f, 0.24337924f, -0.18674012f, 0.16871221f, -0.02248572f, 
    0.10623433f, -0.01783303f, 0.08895401f, -0.06560013f, 0.11847933f, -0.02941491f, 0.00990643f, -0.00778372f, 
    0.01320497f, -0.04956323f, -0.03741978f, -0.05248558f, 0.12712950f, 0.10693325f, 0.03275336f, 0.09555160f, 
    -0.20049691f, -0.17801858f, -0.04582181f, -0.26840109f, -0.34227958f, -0.06291801f, 0.01682056f, 0.05306520f, 
    0.00498404f, -0.07706349f, -0.14616583f, -0.21705225f, 0.15284771f, -0.17631255f, -0.09548679f, 0.10475744f, 
    -0.14100733f, -0.32852507f, -0.01816896f, 0.07549179f, 0.13875410f, 0.31875789f, 0.32803169f, -0.23263825f, 
    -0.14712176f, 0.00475473f, -0.01910026f, 0.04354980f, -0.02292502f, 0.06997494f, -0.11526066f, -0.00523415f, 
    -0.12974228f, 0.08743677f, -0.09758470f, 0.03397226f, -0.03714037f, 0.17083880f, -0.12864079f, -0.19711761f, 
    -0.16576035f, -0.28190196f, -0.08506033f, 0.16989832f, 0.30805728f, 0.00060921f, 0.03812457f, -0.08834495f, 
    0.04819687f, 0.17286772f, 0.04422319f, 0.03974639f, 0.00986619f, -0.07355107f, -0.07807548f, -0.06367031f, 
    -0.06059343f, -0.14532462f, 0.10298051f, 0.00388717f, 0.37625551f, -0.22397165f, 0.34718823f, -0.14747036f, 
    0.14370999f, -0.13722925f, -0.02020344f, 0.06657713f, 0.08831748f, 0.12396058f, -0.00298415f, -0.06779614f, 
    0.13999951f, -0.05834422f, -0.03082997f, -0.13800989f, -0.07446136f, -0.00948400f, 0.10724176f, 0.27615181f, 
    -0.41815925f, -0.07315672f, -0.16100350f, 0.25661567f, 0.25773808f, -0.10352582f, 0.10787896f, -0.04323794f, 
    -0.13944566f, 0.07039168f, 0.02457802f, 0.12576391f, 0.06281748f, 0.05039269f, -0.04952464f, 0.06910563f, 
    0.07899882f, 0.17160903f, 0.02995133f, 0.06163397f, -0.09336961f, -0.02483286f, 0.01703562f, 0.14407963f, 
    0.13100027f, -0.03792592f, 0.12456553f, 0.02160573f, 0.05256799f, -0.04338754f, -0.06207268f, -0.03337022f, 
    -0.03601106f, 0.04962888f, 0.04597177f, -0.01519665f, 0.05403609f, -0.01453292f, 0.10158435f, -0.05759349f, 
    0.48865589f, 0.08290520f, -0.12949835f, -0.22681212f, 0.00561137f, 0.02091344f, 0.14758608f, 0.00514386f, 
    -0.14054438f, -0.20010054f, -0.06825144f, -0.03156502f, 0.05071510f, -0.09073093f, -0.13301049f, -0.02331719f, 
    -0.12212629f, -0.12742624f, -0.12882988f, 0.06061867f, 0.00428767f, 0.12173881f, 0.01188104f, -0.01248866f, 
    0.02516468f, -0.02684000f, -0.13257171f, -0.01924889f, -0.03097699f, -0.13511841f, -0.08457778f, -0.12450078f, 
    -0.02148329f, -0.06092302f, 0.05860903f, 0.05305222f, -0.07638896f, -0.11303904f, -0.09848435f, -0.21909390f, 
    -0.28553537f, -0.08661027f, -0.08960583f, 0.17664401f, 0.15071294f, -0.09449509f, 0.01219299f, -0.01175968f, 
    0.06933387f, 0.10413367f, 0.00560772f, 0.07819257f, 0.02900607f, -0.03338117f, 0.03592188f, 0.04559183f, 
    0.06709302f, 0.15196575f, 0.06598457f, -0.00193996f, 0.31851986f, -0.36228240f, -0.32049635f, 0.13930225f, 
    0.04053643f, 0.06755196f, 0.07753039f, 0.03988393f, -0.05774131f, -0.00737775f, -0.00383682f, 0.03640536f, 
    0.08118349f, 0.11605774f, 0.14478150f, 0.04686291f, 0.37307164f, 0.08165612f, 0.30886126f, 0.10510417f, 
    0.07066511f, 0.42498717f, 0.29941306f, 0.24822068f, 0.17531097f, 0.01526669f, -0.09473098f, 0.16070595f, 
    -0.03806885f, 0.07509281f, -0.17502880f, 0.16736402f, -0.08454022f, 0.03273145f, 0.13021840f, 0.03867148f, 
    0.07913572f, -0.04572143f, -0.02405380f, -0.00071330f, -0.20677979f, 0.22444481f, -0.05140036f, -0.14175181f, 
    0.10089639f, -0.07839387f, -0.03717630f, 0.03032710f, -0.00109973f, -0.01324503f, -0.00639861f, 0.09496018f, 
    0.21843207f, 0.09358006f, 0.11170664f, 0.00953254f, 0.15997079f, 0.06926350f, -0.13359573f, 0.07768238f, 
    0.21559706f, 0.37303144f, 0.42727458f, 0.16692208f, 0.05986790f, 0.09590149f, -0.06247038f, 0.00999528f, 
    -0.07400959f, 0.00364874f, 0.09371630f, 0.09955484f, -0.02671558f, -0.08215196f, 0.10712587f, 0.14738354f, 
    0.04355773f, 0.04285722f, 0.08147347f, -0.00455386f, -0.25934425f, -0.04121181f, 0.06626885f, -0.09623177f, 
    0.05956231f, -0.04080957f, -0.05448341f, -0.18915850f, -0.25557527f, 0.32237217f, 0.03069031f, 0.00574063f, 
    -0.04136378f, 0.01618274f, -0.05877102f, 0.04583564f, 0.01065376f, 0.00503633f, 0.11216851f, 0.02101819f, 
    -0.03430387f, -0.19206028f, -0.49495840f, -0.25598332f, -0.20811680f, 0.20238449f, 0.06661493f, -0.11856343f, 
    0.14795738f, -0.17406033f, 0.03615607f, -0.11236301f, -0.09474684f, 0.08802977f, -0.11775159f, 0.01266779f, 
    -0.12117238f, -0.32699543f, -0.00097014f, -0.13360046f, -0.03090052f, 0.00891427f, -0.01360160f, 0.03769680f, 
    0.17124672f, -0.09312187f, 0.08643095f, 0.13375495f, 0.03572519f, 0.10147731f, -0.06232658f, -0.08515455f, 
    -0.12531051f, -0.01215050f, 0.04460785f, 0.02405587f, -0.00908304f, 0.20358407f, 0.08819766f, 0.08001785f, 
    0.23895612f, -0.16415665f, -0.08950640f, -0.00636784f, 0.16908059f, -0.11872119f, -0.52464753f, -0.43963134f, 
    -0.33135283f, -0.57500833f, 0.11053459f, -0.13246827f, -0.01446410f, -0.04294646f, 0.11585738f, 0.06675147f, 
    0.12478881f, -0.07641688f, 0.06396627f, -0.03822134f, 0.01188891f, -0.16992600f, -0.23453678f, -0.02427740f, 
    0.19428253f, 0.05740865f, -0.17439415f, -0.00232561f, -0.26850301f, -0.05780125f, 0.00502169f, -0.08244900f, 
    0.00197155f, 0.05602228f, -0.02413932f, -0.04009010f, 0.04456041f, -0.08758191f, 0.02493584f, -0.03215344f, 
    -0.18113519f, 0.02051665f, -0.08317193f, -0.10854180f, -0.18121701f, 0.13534304f, 0.22675286f, 0.00904804f, 
    -0.08323303f, 0.09882261f, 0.01165023f, 0.04483740f, 0.06889705f, 0.10061026f, -0.00231337f, 0.03577295f, 
    0.02120710f, -0.09854051f, -0.08127796f, 0.01579219f, -0.15365387f, -0.17241721f, 0.01690345f, -0.21409573f, 
    0.05363548f, -0.09913840f, -0.08750755f, -0.05853538f, 0.11388843f, 0.06599955f, -0.09315585f, -0.12015002f, 
    -0.05443117f, 0.03777711f, -0.09406235f, 0.01607455f, -0.00396562f, 0.05098691f, 0.14113338f, 0.04569420f, 
    0.07126053f, 0.14849448f, 0.11624591f, 0.01272167f, -0.01642376f, 0.02239183f, 0.06395591f, -0.06923119f, 
    0.15366320f, 0.07581258f, 0.05798995f, -0.12427253f, 0.03107997f, -0.09202384f, -0.10811222f, -0.09968012f, 
    0.02725630f, 0.08740842f, -0.10697150f, -0.12048812f, 0.40742218f, 0.45008159f, -0.18902679f, 0.22619367f, 
    -0.23382968f, 0.02274262f, 0.06548291f, -0.01490843f, -0.13302462f, 0.19521607f, 0.17694707f, 0.08356490f, 
    0.10517494f, -0.03545452f, -0.07265354f, 0.11364236f, 0.14138372f, 0.04538889f, 0.06158117f, 0.15552965f, 
    -0.25097990f, -0.26057824f, -0.33432963f, -0.14112903f, 0.13482760f, -0.02717962f, -0.15038757f, -0.12247621f, 
    -0.07665934f, 0.40073666f, 0.07180624f, 0.10393538f, -0.08887091f, -0.21857844f, -0.01796624f, -0.07201769f, 
    0.07767998f, 0.11260290f, 0.07365786f, 0.11076381f, 0.33088130f, -0.04842176f, 0.40720057f, -0.02878446f, 
    0.20696047f, 0.13415426f, -0.16055210f, -0.18149227f, 0.12601551f, -0.14552236f, -0.02551910f, -0.03053561f, 
    0.12048578f, 0.00140051f, 0.03582998f, 0.00943373f, 0.00359973f, -0.05879812f, 0.01149449f, -0.07386629f, 
    -0.27808547f, 0.23684193f, 0.04256829f, 0.00213139f, -0.09554050f, 0.10426015f, 0.21741536f, 0.03801034f, 
    -0.08651108f, 0.16211115f, -0.00819847f, 0.03386696f, 0.05047879f, 0.06501742f, 0.03160271f, 0.02158462f, 
    0.05970824f, 0.08978865f, -0.04178591f, 0.05416285f, -0.28270802f, 0.36888263f, -0.24744651f, 0.06388314f, 
    -0.07601889f, 0.00633734f, -0.00525302f, -0.09562917f, -0.08048225f, -0.02428459f, -0.08352655f, -0.02687954f, 
    -0.06187906f, -0.10740330f, 0.05340825f, -0.03588878f, 0.04968649f, 0.12842776f, -0.01444714f, 0.16265413f, 
    -0.38271287f, 0.16367601f, 0.41071486f, 0.17798182f, 0.04591976f, -0.03724011f, -0.02729243f, -0.27459648f, 
    0.03350538f, -0.08144683f, 0.00745634f, -0.02283182f, 0.16178966f, -0.03458215f, 0.03772536f, -0.05216566f, 
    0.09840922f, 0.10247115f, -0.03797041f, 0.01614310f, -0.34253073f, 0.16095679f, 0.41982692f, 0.34360665f, 
    0.06540066f, 0.01900585f, -0.13829176f, -0.07757043f, -0.02402689f, 0.14311601f, -0.10756428f, 0.04651873f, 
    0.04583665f, 0.00336713f, 0.06276986f, -0.00861652f, -0.05540624f, 0.03447823f, -0.05175003f, -0.05668256f, 
    -0.19313702f, 0.31259346f, 0.25711226f, 0.18840389f, 0.19647557f, 0.10359673f, 0.07812092f, -0.15114613f, 
    -0.04263109f, 0.02199828f, -0.09714445f, -0.01158854f, 0.12488944f, 0.08333211f, 0.05868242f, -0.04928220f, 
    0.12327795f, 0.00275294f, 0.02366815f, 0.02963535f, 0.57849121f, 0.03102604f, -0.02185159f, -0.11897493f, 
    0.33176357f, -0.00602849f, 0.16975538f, 0.03724327f, 0.11178519f, -0.03138091f, -0.16113243f, 0.01598082f, 
    0.01411839f, -0.06060582f, 0.00022420f, 0.08660973f, 0.13678081f, 0.16165547f, 0.02928231f, 0.04337888f, 
    -0.37733594f, -0.33650482f, -0.17199343f, -0.03985560f, 0.22831251f, 0.02645585f, 0.03286525f, 0.16004954f, 
    -0.09535769f, -0.08723509f, 0.05594694f, -0.13217513f, -0.12693343f, -0.13433102f, -0.15758665f, 0.08808322f, 
    -0.04916227f, 0.00584591f, -0.22580826f, -0.06529724f, 0.35323223f, -0.26757431f, -0.13671066f, -0.08544898f, 
    0.22068164f, -0.00509194f, 0.05159169f, 0.01316694f, 0.03308307f, 0.06601375f, 0.00666885f, 0.06851528f, 
    0.02001734f, -0.06539517f, -0.02971825f, 0.09942931f, 0.08744161f, 0.07650315f, -0.00127484f, 0.11353878f, 
    -0.18854806f, -0.13165955f, -0.05932884f, -0.05170220f, 0.00179242f, 0.09465736f, -0.07629710f, -0.03444781f, 
    -0.19523881f, -0.05029768f, -0.01247967f, 0.19445576f, 0.11354077f, 0.10350366f, 0.05220756f, 0.02826149f, 
    0.01541342f, -0.07320536f, -0.03963204f, -0.10872040f, 0.18052047f, -0.06758576f, 0.11247972f, -0.00774052f, 
    0.03129179f, 0.03904638f, 0.13043751f, 0.06140686f, 0.06618194f, 0.05995261f, -0.02334864f, -0.01932509f, 
    -0.00366044f, -0.01971689f, 0.07898226f, 0.14438945f, 0.00683532f, 0.05472985f, -0.01677325f, -0.03508062f, 
    -0.02376192f, -0.13411841f, -0.15343204f, -0.03993235f, 0.30015492f, -0.11797234f, 0.03590213f, 0.02455181f, 
    -0.00369876f, -0.18257004f, 0.02075593f, 0.10678970f, -0.00285151f, -0.03618963f, 0.07779526f, -0.05702570f, 
    -0.09719894f, 0.08763652f, 0.05081838f, 0.07270884f, 0.19095995f, -0.35120180f, 0.03128053f, -0.03202129f, 
    0.27760670f, -0.03483457f, -0.02916367f, 0.13931799f, -0.04123989f, -0.04750766f, -0.16788933f, -0.04363159f, 
    -0.03233205f, -0.03349748f, -0.02911571f, -0.14918748f, -0.04783386f, 0.00868226f, 0.05960079f, 0.07607168f, 
    -0.44459987f, -0.11593659f, -0.01737732f, 0.44869515f, -0.18857624f, -0.11440443f, 0.11519330f, 0.14869566f, 
    -0.11154904f, -0.15128183f, -0.10879124f, 0.02671151f, 0.06622953f, -0.01915883f, 0.11467808f, 0.04261611f, 
    0.16284660f, 0.04748659f, 0.05311234f, 0.01714167f, -0.17359690f, 0.19388750f, -0.23798729f, 0.04643752f, 
    -0.14153439f, -0.10092389f, 0.02018383f, -0.08005019f, 0.12530148f, 0.02573530f, -0.03714312f, 0.10736336f, 
    0.02089901f, -0.07325146f, 0.02663352f, 0.03801222f, 0.01826334f, 0.13135415f, 0.05251507f, 0.05617088f, 
    0.26146686f, 0.01033297f, -0.38451695f, -0.13534892f, 0.16841781f, 0.09331710f, 0.00009053f, 0.14530338f, 
    -0.04633038f, 0.08598268f, -0.03344050f, 0.04949379f, 0.06309455f, 0.03217751f, 0.02589712f, 0.04362200f, 
    0.07044183f, -0.05250690f, 0.06730419f, -0.01843701f, -0.24272302f, 0.02906306f, 0.23995186f, 0.21104485f, 
    0.02113031f, 0.06682336f, -0.05477926f, -0.11182472f, -0.03863459f, 0.06430131f, -0.03922357f, 0.10665140f, 
    -0.07532990f, 0.01757672f, 0.06989983f, 0.01145456f, -0.15456702f, -0.15466078f, -0.05415743f, -0.08689480f, 
    -0.26683944f, -0.03930426f, -0.20212577f, 0.15301317f, -0.07106311f, -0.11466069f, 0.08837700f, -0.15008995f, 
    0.14781086f, -0.07879631f, 0.02631932f, 0.00458380f, -0.00792373f, 0.07512053f, 0.03674292f, 0.10799975f, 
    0.05378503f, 0.04769905f, 0.04879471f, 0.01710742f, 0.22877762f, -0.19270626f, -0.24869378f, 0.14289106f, 
    -0.01424380f, -0.04267581f, -0.01620916f, -0.04768472f, 0.01234579f, 0.09513839f, -0.07060485f, 0.03536316f, 
    0.00490684f, -0.00236819f, -0.10907809f, 0.11960051f, 0.10056031f, 0.05695000f, 0.27712640f, 0.15317765f, 
    0.46782130f, 0.03305516f, 0.20323476f, 0.11843111f, 0.18613680f, 0.00601235f, -0.06589577f, 0.20484997f, 
    0.10883632f, -0.03962163f, 0.00960035f, 0.06431445f, -0.06972424f, 0.00850735f, 0.14662214f, 0.09975278f, 
    -0.03360960f, 0.00373238f, 0.16334797f, 0.09246860f, 0.60747832f, 0.09616325f, -0.03725959f, -0.05254202f, 
    0.13585320f, -0.06124025f, -0.08559342f, -0.02006467f, 0.13367280f, -0.31998053f, 0.11137563f, -0.02502414f, 
    -0.05684250f, -0.10821690f, -0.11012537f, -0.13253902f, -0.16143082f, -0.02613661f, 0.00007784f, -0.30396748f, 
    0.06454964f, -0.25151089f, 0.28307667f, 0.17755316f, 0.02826831f, -0.05000947f, 0.00664080f, 0.13417684f, 
    0.17978750f, 0.01498289f, 0.08518930f, 0.05295985f, 0.07845990f, 0.05421674f, 0.10220933f, 0.07734895f, 
    0.23316300f, 0.11491280f, 0.12659681f, 0.21369502f, -0.60621566f, 0.09978524f, -0.02296612f, 0.32906538f, 
    -0.14949280f, 0.19376254f, -0.04397308f, -0.01157338f, -0.14105202f, -0.21853371f, -0.02383957f, -0.03657293f, 
    -0.02156436f, -0.02258558f, 0.09956145f, 0.05444976f, 0.00528479f, -0.11944576f, -0.14020494f, -0.03235916f, 
    0.43694046f, 0.02081984f, -0.08976597f, 0.30667433f, -0.07265706f, 0.14183626f, 0.07656109f, 0.02398981f, 
    0.00637463f, 0.18494566f, 0.22988619f, 0.20562010f, -0.04234088f, -0.11280778f, -0.16976462f, -0.32676420f, 
    -0.42011246f, -0.41808066f, -0.03792134f, -0.24347395f, -0.07656246f, 0.13136657f, 0.15601350f, 0.09733681f, 
    -0.20476550f, 0.00212276f, 0.08435690f, 0.03125000f, -0.04490776f, -0.06226160f, -0.12188205f, -0.10090413f, 
    -0.09798729f, 0.03098475f, -0.03300206f, 0.02045508f, 0.25057524f, 0.16443966f, -0.01725867f, 0.07193955f, 
    0.02465280f, 0.03062013f, -0.05258293f, -0.26253849f, -0.20610507f, -0.26488590f, 0.05350185f, 0.35128754f, 
    0.32791403f, -0.11871320f, 0.05922712f, -0.05291186f, 0.20907626f, -0.04820327f, 0.00583990f, 0.02183681f, 
    -0.10205312f, -0.31365505f, -0.20876515f, 0.11161102f, -0.10579716f, 0.14661220f, 0.26038679f, -0.26327145f, 
    -0.18477499f, 0.06678813f, -0.04228830f, -0.08658087f, -0.16075449f, -0.09524895f, -0.09777186f, -0.01982050f, 
    -0.14706936f, -0.09906876f, -0.02687352f, 0.02600462f, -0.17284884f, -0.15187092f, -0.12391145f, -0.31452456f, 
    -0.13443226f, 0.04128239f, 0.27008247f, 0.16064602f, -0.01694368f, 0.01035342f, 0.02009077f, -0.10298166f, 
    0.09048127f, 0.19297057f, -0.08664212f, -0.02461892f, -0.01331636f, -0.15570116f, -0.09401072f, -0.06202182f, 
    0.01358908f, -0.13202564f, 0.03658279f, 0.03151645f, 0.14812008f, 0.40398213f, 0.24655585f, 0.02975445f, 
    -0.02368611f, 0.07009178f, 0.07062409f, -0.12153253f, -0.07280433f, 0.14018878f, 0.01188722f, -0.20331962f, 
    0.03514989f, -0.03138540f, -0.15215147f, 0.13569565f, 0.24239460f, 0.08196981f, 0.04083138f, 0.24532072f, 
    0.14132252f, 0.06456085f, -0.14747429f, -0.02832490f, 0.24693343f, -0.05950028f, 0.01413102f, -0.03183525f, 
    0.03564405f, 0.20410372f, 0.03654054f, 0.08065860f, 0.04303624f, 0.12208425f, -0.06934077f, 0.08622772f, 
    -0.08261582f, 0.25526917f, 0.17981359f, 0.35637897f, -0.16577882f, -0.05168234f, 0.39824617f, 0.12642625f, 
    0.04071408f, -0.00138837f, -0.00657751f, 0.16554739f, 0.02529996f, -0.02957856f, -0.16557986f, -0.05114238f, 
    -0.01476464f, 0.09743886f, -0.05902871f, 0.06313882f, 0.07830059f, 0.04022303f, -0.04413915f, -0.05525095f, 
    -0.18499838f, 0.11564057f, 0.04982064f, 0.15720227f, -0.02243304f, -0.05269545f, 0.13453294f, -0.08263619f, 
    -0.06812217f, -0.55283880f, 0.16345005f, -0.00118934f, -0.02320693f, -0.06396762f, -0.07718641f, 0.02818270f, 
    -0.05272387f, -0.21704420f, -0.15914725f, 0.09040520f, 0.42040998f, 0.07257117f, -0.07126640f, -0.18305482f, 
    0.16341732f, -0.20509273f, -0.00585406f, -0.04187921f, -0.00487490f, -0.25934640f, 0.07638299f, -0.08127811f, 
    0.01688704f, -0.06045411f, 0.01754303f, -0.20270856f, -0.17222747f, -0.17859705f, -0.08514747f, -0.12914701f, 
    0.02699587f, 0.05071064f, 0.11562330f, -0.02663284f, 0.05224685f, -0.05806090f, -0.03997606f, 0.12177311f, 
    0.02814369f, 0.15496629f, -0.09992636f, 0.05247452f, -0.10530468f, -0.05012229f, -0.00266953f, 0.01532567f, 
    0.11530200f, 0.08502536f, 0.04550238f, 0.11655045f, 0.19173624f, -0.21361963f, -0.06111585f, 0.12306001f, 
    -0.16271287f, 0.13495286f, 0.05875732f, -0.01981350f, 0.02254591f, 0.06875256f, 0.01381718f, -0.10571313f, 
    -0.00218349f, 0.16097513f, 0.18602556f, 0.14371771f, 0.29901841f, 0.14836523f, 0.01751775f, 0.31601548f, 
    -0.33148459f, -0.14149451f, 0.11288872f, -0.04901985f, -0.04091957f, 0.03814550f, 0.13900179f, 0.02354200f, 
    -0.13132209f, 0.08342137f, 0.14617088f, 0.03933216f, 0.08066766f, 0.04828575f, 0.01972104f, 0.02272402f, 
    -0.00318443f, 0.03841086f, 0.05169160f, -0.01715911f, -0.23284960f, 0.23878121f, 0.20788413f, 0.05094627f, 
    -0.11756800f, -0.07420411f, -0.01370723f, -0.08001434f, 0.03804955f, 0.15962964f, -0.04566500f, 0.14174820f, 
    -0.04956508f, -0.01060741f, 0.03265112f, 0.09188897f, 0.02324741f, -0.08546444f, 0.14347506f, 0.11011923f, 
    -0.40290847f, -0.05923164f, -0.26621148f, -0.23055743f, 0.30800563f, -0.07580503f, 0.11606626f, -0.05007260f, 
    0.11312753f, -0.03426825f, 0.03393440f, 0.16293223f, -0.05909079f, 0.13664348f, 0.04016639f, -0.09203608f, 
    -0.04705581f, 0.19778019f, 0.04480403f, -0.13400890f, 0.59218055f, -0.04963285f, -0.49553502f, 0.09363182f, 
    0.18248373f, -0.04479657f, -0.02041855f, 0.16253136f, -0.05041799f, 0.04206202f, -0.08896179f, -0.03027778f, 
    -0.01236998f, -0.13433494f, -0.05775252f, 0.13066944f, 0.08659237f, -0.10417122f, -0.15313455f, 0.10305455f, 
    0.06199610f, 0.16157268f, 0.16300884f, -0.45515069f, -0.09718519f, -0.22622547f, -0.23891522f, -0.11916785f, 
    -0.22305378f, -0.16415921f, 0.04505926f, -0.09779921f, 0.02385455f, -0.17015862f, -0.01633933f, -0.02059114f, 
    0.06872091f, 0.11234016f, 0.19136989f, 0.06030272f, 0.12443309f, 0.26806301f, -0.14328764f, -0.00989305f, 
    0.12686291f, 0.10102420f, 0.06041127f, -0.00820991f, 0.05406330f, 0.05486416f, -0.02650863f, -0.01770334f, 
    0.00385216f, -0.06704935f, -0.05996181f, 0.05533062f, -0.06614884f, -0.08966512f, -0.04956273f, 0.15010178f, 
    0.00492766f, 0.06739949f, -0.02569574f, -0.12904526f, 0.09537943f, 0.06697477f, -0.01747915f, -0.07808830f, 
    -0.10426016f, -0.02491224f, 0.11330124f, 0.21609196f, 0.11501246f, 0.22986358f, 0.20283593f, -0.10809828f, 
    0.14356652f, 0.15339907f, -0.04768235f, 0.02037218f, 0.02971824f, -0.21669856f, -0.09361367f, 0.11863764f, 
    0.08020946f, -0.02047307f, 0.05399566f, 0.07443736f, 0.01505525f, -0.05429229f, 0.07535358f, -0.14757384f, 
    -0.14122263f, -0.06488273f, 0.07114583f, 0.01750471f, -0.07426257f, -0.08379588f, -0.17988844f, 0.07941234f, 
    0.19605730f, 0.10176831f, 0.03091754f, -0.02602969f, -0.04326974f, -0.10914842f, 0.16759576f, 0.19199502f, 
    0.06276154f, -0.23747477f, 0.14753413f, -0.04807371f, -0.03703021f, 0.13540462f, -0.00425631f, 0.01448184f, 
    0.09104093f, 0.07112116f, 0.08360671f, 0.20231479f, -0.38000178f, 0.21727148f, -0.25455901f, 0.36967161f, 
    0.23629807f, 0.09188860f, 0.17380783f, 0.14655294f, 0.08504272f, 0.10843451f, -0.05407332f, 0.03789105f, 
    -0.09234626f, -0.03744652f, -0.00597568f, 0.02504360f, 0.06119465f, 0.30587959f, -0.02743908f, -0.09810365f, 
    -0.03998943f, -0.12841244f, 0.09433707f, -0.09961826f, -0.36717367f, -0.05512365f, 0.13981122f, 0.19111797f, 
    -0.00184565f, -0.14077273f, -0.13119932f, 0.01250493f, 0.06395947f, 0.16914219f, 0.11189380f, 0.32815501f, 
    0.14925227f, 0.02229895f, 0.24426033f, 0.06041083f, 0.02659448f, 0.05609390f, -0.14929019f, -0.10986549f, 
    0.06394593f, 0.03901166f, 0.08177804f, -0.08175112f, -0.01570340f, -0.03953431f, 0.04886668f, 0.00472159f, 
    -0.12458988f, 0.27888644f, 0.16976258f, -0.00455126f, 0.01530600f, 0.19678706f, 0.04552838f, 0.12799782f, 
    -0.22129761f, -0.00417326f, -0.21809964f, 0.22499846f, 0.08385271f, 0.16992757f, -0.44324595f, -0.18756412f, 
    0.02719687f, 0.18155475f, -0.17972475f, 0.05577299f, 0.02154821f, -0.10347356f, 0.04796255f, 0.03933182f, 
    0.11287326f, -0.23020531f, -0.01598998f, 0.14807060f, -0.14561354f, -0.07695551f, 0.15744384f, -0.05086547f, 
    0.00755057f, -0.08212593f, -0.00400801f, -0.04718811f, -0.02540867f, 0.06725137f, 0.22147666f, 0.10673736f, 
    -0.14421798f, -0.12883419f, 0.12114820f, 0.03304037f, 0.00656177f, 0.01521426f, -0.07249329f, 0.10503559f, 
    0.24601622f, -0.08010407f, 0.05763040f, -0.17600530f, -0.23726690f, 0.08292786f, 0.25380164f, 0.05748138f, 
    0.10426688f, -0.14944218f, 0.10569128f, 0.00809717f, -0.01667845f, 0.25682646f, -0.02574833f, -0.00436900f, 
    0.04248329f, -0.00758831f, 0.16573386f, 0.10689645f, -0.20509864f, -0.14359067f, 0.10878740f, -0.00784589f, 
    0.05470156f, -0.27615139f, -0.02433056f, -0.04473080f, 0.16801515f, 0.20430721f, 0.07352731f, 0.08799487f, 
    0.03742976f, 0.15046008f, -0.09534726f, 0.21392365f, -0.00518790f, -0.25960037f, 0.05568357f, -0.04312768f, 
    -0.05240672f, -0.21622701f, -0.18284070f, -0.15235198f, -0.08853958f, 0.13664810f, 0.04500264f, -0.01912126f, 
    0.09106638f, 0.07213762f, -0.01168481f, -0.02979489f, 0.11964085f, -0.15140148f, -0.12647541f, -0.03916962f, 
    -0.07449549f, 0.00481889f, -0.02727210f, -0.00815110f, 0.13158907f, -0.16590367f, 0.03413101f, 0.03637935f, 
    -0.09673399f, 0.08433240f, -0.02208204f, -0.11266378f, 0.02469135f, 0.15688823f, 0.06947921f, 0.00659891f, 
    -0.09201855f, -0.08115256f, 0.03816463f, 0.03037448f, 0.04619216f, -0.03641600f, 0.07006780f, 0.03050489f, 
    -0.05638316f, 0.03829087f, -0.36516210f, -0.02506717f, 0.18778399f, 0.04731843f, 0.00947811f, -0.02089890f, 
    -0.09988518f, 0.00995849f, -0.16971926f, 0.04452793f, 0.00705821f, 0.11601684f, 0.00636848f, -0.22914848f, 
    -0.12361158f, 0.02970076f, -0.11329952f, -0.02799967f, 0.42156628f, 0.14125720f, -0.17192641f, 0.10422056f, 
    0.04688454f, -0.04753120f, 0.07402907f, 0.10715972f, 0.22865093f, -0.03883509f, -0.02911002f, 0.06516872f, 
    0.07069217f, -0.08136873f, -0.08600161f, 0.20196910f, 0.02093613f, 0.19335425f, 0.00059472f, 0.09832851f, 
    -0.20155944f, -0.27244827f, 0.08606730f, 0.01341598f, 0.04758976f, -0.12666620f, -0.05756096f, 0.17497750f, 
    -0.04872541f, -0.16858730f, 0.10789716f, -0.01676986f, 0.07651280f, -0.16987844f, 0.07036251f, -0.00823642f, 
    0.06372597f, 0.25341934f, 0.07460078f, 0.16327061f, 0.08493987f, -0.07530423f, 0.23342639f, -0.03109078f, 
    -0.00921608f, -0.01824165f, -0.05564806f, -0.11602758f, -0.03122895f, 0.03253102f, -0.00050802f, -0.00776983f, 
    0.00285709f, -0.09561452f, -0.09590119f, -0.02724676f, -0.11987697f, -0.04519921f, -0.03085844f, 0.09531935f, 
    -0.22410499f, 0.00390853f, -0.00023898f, -0.10908359f, -0.16297163f, -0.09762792f, -0.10424951f, -0.10760270f, 
    -0.08632293f, -0.02850054f, 0.05636080f, 0.21331291f, 0.05770100f, 0.20680346f, 0.15808305f, -0.03545393f, 
    0.08195052f, 0.20375594f, 0.03968564f, 0.02577682f, -0.18553826f, 0.01843939f, 0.22332159f, 0.09947509f, 
    -0.01619705f, -0.00342439f, 0.06522524f, -0.03306552f, 0.15800819f, 0.00405732f, -0.01259755f, -0.03585044f, 
    0.02497234f, -0.01838259f, 0.10018619f, 0.11871058f, 0.12483129f, 0.03809605f, 0.08373782f, 0.04740386f, 
    0.14309150f, -0.16737169f, -0.16861498f, 0.06943428f, 0.31930935f, -0.00408351f, 0.09644833f, 0.17118205f, 
    0.08767471f, -0.11433160f, 0.08733677f, -0.01988989f, 0.05408576f, 0.00582056f, 0.00629094f, 0.05751710f, 
    0.01209512f, 0.10265002f, 0.09229060f, 0.07794121f, -0.16858809f, -0.00655917f, 0.30285874f, 0.10692715f, 
    0.00291498f, -0.00771807f, -0.00726905f, 0.03842326f, -0.07540281f, -0.10925640f, -0.08199406f, 0.04033188f, 
    -0.07351224f, -0.09408318f, -0.06806651f, -0.04707186f, -0.06159408f, 0.00233176f, -0.11623356f, -0.06881908f, 
    -0.21609361f, -0.02111309f, 0.09295193f, 0.06843358f, -0.20806393f, -0.00625170f, 0.02462074f, 0.06888935f, 
    0.00869956f, -0.07741908f, -0.10402911f, 0.01763994f, -0.18001410f, 0.02428773f, 0.01911348f, 0.15642694f, 
    0.19777420f, 0.09311834f, 0.08027635f, -0.18656509f, -0.31815457f, -0.04648314f, -0.05681814f, 0.04760892f, 
    0.42217758f, 0.08370995f, 0.01932653f, 0.10358848f, 0.14473984f, 0.14076950f, -0.07360012f, 0.22592264f, 
    -0.03089371f, -0.08166350f, 0.07731912f, 0.07460842f, -0.07337376f, 0.05467383f, 0.14416222f, 0.15554552f, 
    0.37212944f, 0.25433686f, -0.11899503f, 0.09516747f, -0.17569003f, 0.10738045f, 0.06217113f, 0.12228043f, 
    -0.06283884f, 0.05752322f, -0.00179953f, 0.14725424f, -0.00465657f, 0.03106459f, 0.04035123f, 0.00108007f, 
    0.06946732f, 0.08607574f, 0.05289894f, 0.04528119f, -0.20536590f, 0.00754582f, -0.05084359f, -0.08444311f, 
    -0.16233592f, -0.06179303f, 0.02664246f, 0.01126398f, 0.02975923f, 0.02163652f, 0.19915196f, 0.16342853f, 
    0.08030454f, 0.01572549f, 0.07130149f, 0.05260181f, 0.04496758f, -0.04552902f, 0.01938437f, 0.14405294f, 
    0.09670712f, -0.10520811f, -0.08385266f, 0.10018790f, 0.05387616f, 0.03135986f, 0.11637577f, 0.08203327f, 
    0.20094563f, 0.03119715f, 0.00746819f, -0.04211782f, -0.05399849f, -0.02455780f, -0.02317392f, 0.05153951f, 
    0.05469994f, 0.03860960f, 0.10537707f, 0.01552529f, 0.14832482f, -0.03482047f, 0.06923340f, -0.07312155f, 
    0.07018494f, 0.02748998f, -0.00489223f, -0.00269402f, 0.16891289f, 0.08817545f, 0.05344030f, -0.00742069f, 
    0.03323280f, 0.05344932f, -0.04992961f, 0.15806602f, -0.09944579f, 0.01902163f, 0.10230009f, -0.15043113f, 
    0.03632614f, -0.03619779f, 0.37958899f, -0.01132899f, -0.05958438f, -0.05954478f, -0.01909002f, -0.18930814f, 
    0.18304716f, 0.11635723f, 0.02335069f, -0.05990785f, -0.06619176f, -0.03882882f, -0.02720455f, -0.11649425f, 
    -0.04159582f, 0.01739122f, 0.01411226f, 0.03218262f, 0.43184802f, 0.09732278f, 0.41748786f, 0.41819385f, 
    0.08875278f, -0.01322646f, -0.15859848f, -0.17370972f, 0.02865534f, -0.02405500f, 0.04815041f, -0.09467764f, 
    -0.04609738f, -0.06343333f, -0.05319624f, -0.04213046f, -0.14553118f, -0.17531860f, -0.00863092f, -0.12079032f, 
    -0.25531921f, -0.14438732f, -0.04237338f, -0.03855381f, -0.03515925f, -0.07166432f, -0.04738387f, -0.21840194f, 
    -0.00393900f, 0.16626967f, 0.01216269f, 0.05398946f, 0.01569573f, 0.13393910f, 0.07190388f, -0.08814324f, 
    0.11471078f, 0.05809512f, -0.03603850f, 0.17004777f, 0.20238595f, -0.00532580f, -0.20323652f, -0.01743846f, 
    -0.05904149f, 0.12516505f, -0.03477500f, 0.26480785f, -0.02855814f, -0.12199315f, -0.11440318f, 0.06723246f, 
    0.12902908f, -0.12578708f, 0.08228104f, 0.10519159f, -0.07453958f, 0.09478685f, -0.11074787f, -0.19210786f, 
    0.01305808f, 0.10939732f, 0.30582938f, 0.14223656f, 0.11071365f, 0.14042795f, -0.04802087f, 0.18944439f, 
    -0.10447776f, 0.14944933f, 0.11498167f, 0.03250350f, -0.07348828f, -0.09982374f, -0.14153735f, 0.05037955f, 
    -0.19080855f, -0.16091330f, -0.11412007f, -0.09160449f, 0.08013732f, 0.05778304f, -0.09910510f, 0.01227467f, 
    -0.03957250f, 0.01877515f, 0.11405271f, -0.11808886f, 0.01655390f, 0.07296412f, 0.08612745f, -0.06066113f, 
    -0.01799077f, -0.02609382f, 0.04057523f, 0.14417325f, 0.04280607f, -0.01616563f, -0.01279086f, 0.17297125f, 
    -0.12908445f, -0.01200172f, -0.15631068f, -0.25156057f, -0.17449977f, -0.02113527f, -0.11413343f, 0.05385586f, 
    0.11191888f, 0.27142125f, 0.01109427f, 0.02306773f, -0.04993837f, 0.14940272f, -0.03951105f, -0.00731454f, 
    0.04570634f, -0.00594852f, -0.01073796f, 0.07889387f, -0.22975659f, 0.05268192f, 0.12447482f, -0.13438343f, 
    0.08543020f, 0.04926920f, 0.07320087f, 0.01454962f, 0.16040006f, -0.02826079f, -0.11440881f, -0.03789748f, 
    0.04394698f, -0.13334499f, 0.03219163f, 0.02545482f, -0.15352020f, 0.00232710f, -0.00729835f, -0.02506530f, 
    0.00691703f, -0.02049023f, 0.20743327f, 0.23952176f, 0.02409041f, -0.00597907f, 0.03127106f, 0.07505561f, 
    0.00586046f, 0.03441779f, -0.03338502f, -0.05946925f, -0.06001834f, -0.03275251f, -0.05185191f, 0.03395660f, 
    0.00239675f, -0.15501669f, 0.13279755f, 0.15973197f, 0.04455471f, 0.25217572f, -0.14833906f, 0.39909446f, 
    0.11353131f, 0.18313058f, 0.08154282f, 0.06191625f, -0.03993977f, 0.25318125f, 0.01595609f, 0.05639276f, 
    -0.08845230f, -0.03870860f, -0.02464822f, 0.09062456f, 0.07851414f, 0.11401027f, -0.03080379f, 0.11697949f, 
    -0.32930121f, -0.24103546f, 0.08945631f, 0.06540055f, -0.05008801f, -0.00606292f, 0.03597269f, -0.02009092f, 
    -0.03505994f, 0.03132075f, -0.04698533f, 0.09111839f, -0.03264985f, 0.05137033f, 0.05048637f, 0.14426622f, 
    0.29947573f, 0.06126856f, 0.23500325f, 0.31775594f, -0.27147081f, -0.03911915f, 0.45977253f, -0.21925806f, 
    0.14490826f, 0.10441011f, 0.03750425f, 0.05827434f, 0.19946320f, -0.14784524f, -0.24391685f, -0.01654972f, 
    -0.09249678f, 0.02948925f, 0.01459010f, 0.16366526f, -0.06123551f, 0.03561945f, 0.12672475f, -0.06740942f, 
    -0.22561181f, -0.14040856f, -0.00921700f, 0.12381700f, -0.12543392f, 0.01349059f, 0.05301532f, 0.11833059f, 
    -0.08479808f, -0.05770288f, 0.01935654f, -0.08121073f, 0.04422478f, 0.15724932f, -0.02179737f, 0.03089994f, 
    -0.01428052f, 0.03235564f, -0.23382765f, -0.06110562f, 0.04486103f, -0.01821997f, 0.12680557f, 0.04019973f, 
    0.06433889f, -0.07448956f, -0.02885318f, -0.03641939f, -0.09982947f, 0.04456533f, 0.05648026f, 0.03657333f, 
    -0.01315046f, 0.03818023f, -0.04760140f, -0.08918083f, -0.24475519f, -0.15574637f, -0.14354920f, -0.02850947f, 
    0.03995724f, -0.09891307f, 0.11303357f, 0.08009899f, -0.01586562f, -0.06360232f, 0.13309261f, -0.03070649f, 
    0.14950977f, 0.00105538f, 0.00026150f, 0.02531899f, -0.12757146f, 0.02527459f, -0.05455480f, 0.10316131f, 
    0.05120774f, -0.28862971f, 0.25728738f, 0.07113373f, 0.04078296f, -0.40075386f, 0.00741380f, 0.21202062f, 
    -0.02815969f, -0.00298408f, 0.01226693f, -0.01275570f, 0.04547973f, 0.13608333f, -0.01244476f, -0.00523097f, 
    -0.06504187f, 0.11712168f, 0.01330297f, 0.23436056f, 0.17162207f, 0.09959592f, 0.23295119f, 0.26315361f, 
    0.12420776f, 0.09616160f, -0.02935016f, -0.00821357f, 0.25343075f, 0.14168683f, 0.10112438f, -0.00569772f, 
    0.09924050f, -0.03712057f, -0.05553092f, 0.04169045f, -0.07606528f, 0.02924761f, 0.05171514f, 0.06509496f, 
    0.07152258f, -0.06058088f, -0.01948962f, 0.01563213f, 0.05440974f, 0.13301761f, 0.09768879f, 0.05292075f, 
    0.25770697f, 0.10161405f, 0.11193736f, 0.13344526f, -0.07631248f, -0.06745521f, -0.09194037f, 0.08654210f, 
    -0.03810790f, 0.09966560f, 0.06523667f, -0.00240865f, 0.01775701f, 0.11693268f, -0.06818382f, -0.03924765f, 
    0.40867096f, 0.08239442f, 0.16246305f, 0.23656337f, 0.03611450f, -0.02735252f, 0.01081877f, -0.10385499f, 
    0.09032982f, -0.01908287f, -0.03778053f, -0.00338210f, 0.15252972f, -0.08240922f, -0.04731353f, 0.21405262f, 
    0.28405061f, 0.07184131f, -0.02987902f, 0.03350779f, -0.76973480f, -0.06933626f, 0.42378703f, -0.05475452f, 
    -0.14493926f, 0.00649979f, -0.08561745f, 0.13249098f, 0.19660892f, -0.21491057f, -0.05451628f, -0.03986720f, 
    -0.04738723f, 0.07931177f, 0.12471368f, -0.13120301f, 0.09822457f, 0.14649926f, 0.31931865f, -0.14069259f, 
    0.13607404f, 0.03248856f, -0.23959139f, 0.15114827f, 0.23914410f, -0.08593892f, 0.17518583f, 0.06796329f, 
    0.09902754f, 0.02231232f, -0.01381713f, 0.05490065f, -0.09285218f, 0.08046042f, 0.01751206f, 0.02989775f, 
    0.02793029f, 0.11824865f, -0.03375082f, 0.13647221f, -0.38265535f, -0.21384205f, 0.08133062f, 0.00472316f, 
    0.00846413f, -0.04953550f, -0.05965150f, 0.14130613f, 0.04918313f, -0.08886111f, -0.10214525f, -0.02521988f, 
    -0.04475424f, -0.02059766f, 0.06116621f, -0.02881148f, 0.06765966f, -0.02781044f, 0.00974576f, -0.23405196f, 
    -0.38579792f, -0.45127603f, 0.06467637f, 0.03942788f, -0.10719176f, -0.06273000f, 0.01367594f, 0.05339696f, 
    0.03580685f, 0.01748584f, -0.24492089f, -0.13256203f, 0.13368542f, -0.07252458f, -0.05349502f, 0.13689058f, 
    -0.01061129f, -0.02541501f, 0.00289316f, -0.02300532f, -0.18672930f, -0.08170837f, 0.06022004f, -0.10212851f, 
    -0.29749623f, 0.00738159f, -0.12719458f, 0.01749294f, 0.08905477f, 0.09318205f, -0.11748526f, 0.08193563f, 
    -0.04876414f, 0.00197153f, -0.00665356f, -0.08242437f, 0.17570281f, -0.06690110f, 0.20595485f, -0.00432530f, 
    -0.11143221f, -0.04234659f, -0.11719169f, -0.09629560f, 0.16494508f, 0.00764392f, -0.03097821f, 0.06570559f, 
    0.00998284f, 0.03935226f, -0.10857899f, -0.02050447f, -0.05634512f, -0.04348019f, 0.01074018f, 0.00115645f, 
    -0.13399342f, 0.10355104f, -0.10145566f, -0.01307325f, -0.06062359f, -0.24444574f, 0.30456656f, -0.29011276f, 
    0.04038421f, -0.16543642f, -0.09509774f, 0.14008035f, 0.16575739f, 0.02209588f, -0.02601047f, -0.02210090f, 
    -0.00979748f, 0.01724646f, 0.09120543f, 0.10844100f, -0.06488091f, -0.11515021f, 0.14336576f, 0.12725899f, 
    0.12604234f, 0.27598971f, -0.16961168f, 0.05343568f, 0.21066423f, 0.03812206f, 0.02992976f, 0.16839238f, 
    0.07314965f, 0.04353473f, 0.03868026f, -0.06921128f, -0.00224305f, -0.11811066f, -0.05021119f, -0.19878078f, 
    -0.21580976f, 0.22190607f, -0.11895557f, 0.04287514f, -0.11353192f, 0.02091496f, -0.28011352f, 0.18155833f, 
    -0.04732003f, -0.00094629f, -0.00617318f, 0.13506639f, 0.06966885f, 0.04428574f, -0.06180072f, -0.00270167f, 
    0.06558685f, 0.01727116f, -0.00572105f, -0.17310534f, 0.09669792f, -0.19762683f, -0.00061439f, -0.14881259f, 
    0.12943083f, 0.07983684f, 0.33866015f, -0.38411790f, -0.00662937f, -0.29442897f, 0.09955810f, 0.16551487f, 
    0.13117284f, -0.21817113f, 0.15450433f, -0.07384924f, -0.04540262f, 0.15683937f, 0.01906141f, 0.04239269f, 
    -0.09100010f, 0.15885814f, 0.00824492f, -0.15893430f, 0.02748315f, 0.07138402f, -0.04761722f, 0.12978777f, 
    0.13181856f, 0.06075214f, 0.02498848f, 0.06204167f, 0.00764588f, 0.11396876f, -0.15080994f, 0.02361758f, 
    0.07147624f, 0.12974593f, -0.14378147f, -0.07014848f, 0.01491726f, -0.05695751f, 0.11594204f, 0.03830773f, 
    -0.12778828f, 0.05250498f, -0.28361171f, -0.05717700f, 0.16931781f, 0.00465982f, -0.06589337f, -0.05971380f, 
    -0.02452639f, 0.16476767f, -0.05866269f, 0.05799950f, -0.07849786f, -0.09353300f, -0.04195938f, -0.07842391f, 
    -0.01434693f, -0.07654469f, -0.10092824f, 0.04280942f, 0.28894749f, 0.11647459f, -0.06349911f, -0.06554030f, 
    0.09010185f, 0.06717043f, 0.16554260f, 0.25457200f, 0.06025697f, 0.13259847f, -0.10102891f, -0.02024451f, 
    0.03302054f, -0.07142011f, 0.09866103f, -0.09788306f, 0.00324192f, 0.09200300f, -0.00563607f, 0.08100719f, 
    0.13091266f, 0.02456992f, -0.01647833f, 0.11676756f, -0.01558282f, 0.22231835f, -0.03638633f, 0.02155270f, 
    0.04978222f, -0.06522847f, -0.12781943f, -0.02355087f, 0.10264702f, -0.02212015f, 0.11241729f, -0.06404408f, 
    -0.03403342f, 0.07052188f, 0.06237377f, 0.12258810f, -0.16218083f, 0.29188472f, 0.29844329f, -0.05004015f, 
    -0.00630129f, 0.09635797f, -0.04773743f, -0.21927305f, -0.02729778f, -0.08073588f, 0.06324016f, -0.01419100f, 
    -0.02299275f, -0.07420197f, 0.04216191f, -0.01198914f, -0.07655487f, -0.04074528f, -0.08752413f, -0.12947862f, 
    0.24443609f, 0.27629396f, -0.24895343f, 0.18333322f, 0.20494615f, 0.11559545f, -0.04948993f, -0.05738090f, 
    0.14081155f, 0.15204716f, -0.14506137f, -0.02893724f, 0.21932639f, 0.17499796f, 0.07875302f, -0.03473437f, 
    0.14505775f, 0.03497566f, 0.11816902f, 0.27333909f, 0.21124990f, 0.50481832f, -0.35846409f, 0.02227218f, 
    0.21619585f, -0.00527350f, -0.16501659f, 0.14753036f, 0.06941147f, -0.25610998f, 0.08737099f, 0.06485967f, 
    -0.01345696f, -0.13044636f, -0.01750707f, -0.00637522f, 0.19241160f, -0.06355546f, 0.01362612f, -0.14149305f, 
    0.17780128f, 0.00397229f, -0.18576160f, -0.09280113f, 0.23444143f, 0.07974733f, 0.08196209f, 0.08778266f, 
    0.05799958f, 0.01311818f, 0.23486219f, -0.16050427f, -0.23822492f, -0.10320031f, -0.00118517f, -0.01145670f, 
    -0.08328436f, 0.00526704f, 0.02404138f, -0.04222785f, -0.06338152f, -0.14508255f, -0.12327693f, -0.00844566f, 
    0.11116930f, 0.04691669f, 0.04799886f, 0.16665946f, -0.04879092f, -0.06325947f, 0.03167167f, 0.03832740f, 
    -0.07026558f, -0.16025880f, -0.06120336f, 0.02662535f, 0.16303366f, 0.03587412f, -0.03453292f, 0.10318659f, 
    -0.03690689f, 0.29645169f, 0.05374253f, -0.07767868f, 0.14047228f, 0.07951426f, 0.12147768f, 0.15516020f, 
    0.03478539f, 0.08673657f, -0.08637479f, -0.05635452f, 0.13562617f, -0.09027207f, -0.06528311f, -0.01320690f, 
    -0.01965376f, -0.06489538f, 0.08876497f, 0.07737688f, 0.05120989f, -0.07785547f, 0.01297838f, 0.13534196f, 
    -0.03399056f, 0.03961182f, 0.17278686f, 0.05096406f, -0.15300573f, -0.05307114f, -0.07423344f, -0.09117792f, 
    -0.03765478f, -0.03353261f, 0.00221329f, 0.04982034f, -0.02056478f, -0.01277127f, -0.31348974f, -0.15323648f, 
    0.26095152f, 0.13466300f, -0.30467659f, -0.04189483f, 0.31485093f, -0.01821190f, 0.07545988f, 0.01111269f, 
    0.09423993f, 0.03807267f, 0.04256286f, -0.04754950f, -0.00982977f, -0.17120847f, 0.10694142f, -0.06313837f, 
    0.04176725f, 0.23296382f, 0.05408608f, -0.09351585f, -0.09158723f, -0.18796138f, 0.05942860f, 0.04871349f, 
    0.24175650f, -0.00556745f, 0.11519710f, 0.18722115f, -0.06552096f, 0.02025626f, 0.04010329f, -0.01750197f, 
    -0.04697491f, -0.09004773f, -0.04156810f, 0.06537595f, 0.10124360f, 0.07265608f, -0.03352041f, 0.14123821f, 
    -0.08786044f, 0.19309524f, -0.08095181f, -0.07229733f, 0.06453514f, 0.04654764f, 0.09790539f, -0.00432722f, 
    -0.06684738f, 0.23548815f, -0.19208507f, -0.01561905f, -0.17801596f, -0.03223731f, 0.03846483f, -0.00612183f, 
    0.14223942f, 0.13142428f, 0.15581863f, 0.16145848f, -0.18629102f, 0.14280209f, -0.22059070f, 0.01368009f, 
    0.05369232f, -0.05459790f, -0.13294575f, 0.06362806f, 0.04251726f, -0.03739234f, -0.07230780f, 0.15719463f, 
    -0.08157504f, -0.04307273f, 0.05714149f, -0.10035968f, 0.09465775f, 0.13084298f, -0.01691854f, 0.10271286f, 
    0.28799275f, 0.36701250f, -0.52891481f, -0.02445648f, 0.03611523f, -0.02197832f, 0.25325823f, -0.00494086f, 
    -0.16067581f, -0.32846040f, 0.04909906f, 0.13169818f, -0.16060650f, -0.09840194f, -0.00278487f, -0.13437423f, 
    0.04929628f, -0.13421002f, 0.03938048f, -0.10319405f, -0.46274307f, 0.29734170f, 0.10607797f, -0.08873729f, 
    -0.04836809f, 0.06001285f, 0.08608217f, -0.20372443f, -0.05375380f, -0.16618127f, -0.02065814f, -0.03508814f, 
    -0.05658699f, 0.04803992f, -0.13810119f, -0.05715423f, 0.05475109f, -0.22069398f, -0.03850625f, -0.18734047f, 
    -0.08442558f, -0.01949659f, -0.07680465f, -0.08155744f, 0.06932384f, -0.02634200f, -0.05393937f, 0.02227606f, 
    -0.00450753f, 0.13238330f, -0.04222994f, 0.02608887f, -0.00668039f, -0.09541912f, 0.00265639f, -0.01619953f, 
    -0.02011777f, 0.15301357f, 0.05568188f, 0.03463618f, 0.51493859f, 0.18544507f, -0.07403274f, -0.34090903f, 
    0.04995213f, 0.17518370f, -0.01952153f, 0.05505487f, -0.00196628f, 0.22502692f, 0.12068574f, -0.16663729f, 
    -0.00076408f, 0.01750502f, 0.03844387f, 0.02620912f, 0.14833872f, 0.16586591f, 0.06437748f, 0.17307483f, 
    0.38114884f, -0.06328953f, -0.46298137f, -0.22186385f, 0.03994668f, 0.17841844f, 0.06561997f, 0.20398997f, 
    -0.02650159f, -0.04269221f, -0.10338759f, -0.02494272f, -0.03717715f, 0.08129093f, 0.07275561f, 0.14304048f, 
    -0.01499771f, 0.00133053f, -0.04983184f, 0.01380671f, 0.33648089f, -0.29595253f, -0.35435951f, -0.29685974f, 
    0.14272349f, 0.17211396f, 0.15171969f, 0.15523475f, 0.05428194f, -0.07851560f, -0.07323803f, -0.18491141f, 
    -0.10655695f, -0.11073358f, -0.07212874f, -0.03004816f, -0.02052564f, -0.00526612f, -0.02076526f, -0.09809370f, 
    0.36490262f, -0.03243376f, -0.26082814f, 0.09334369f, -0.06062999f, -0.05672148f, -0.00756221f, -0.07950116f, 
    0.07655913f, -0.01255043f, -0.12256662f, -0.01187553f, -0.00517084f, 0.03439106f, 0.03864006f, 0.07635891f, 
    0.07939867f, 0.01364626f, -0.07749133f, -0.00184705f, -0.56166190f, 0.09318391f, 0.29995787f, 0.29638487f, 
    -0.06707495f, -0.14408407f, 0.07610721f, -0.20902929f, 0.04348356f, -0.16976355f, -0.04746514f, -0.02511172f, 
    -0.00895795f, 0.07843146f, 0.10884441f, -0.13973506f, -0.01395487f, 0.05142161f, 0.02144387f, -0.14047581f, 
    0.20165810f, 0.21856672f, -0.08205564f, 0.08585669f, -0.07722021f, 0.14999494f, 0.19934033f, 0.12045074f, 
    0.16025743f, 0.12150828f, -0.00016109f, 0.08958796f, -0.02110261f, -0.00578278f, -0.03245706f, -0.05235325f, 
    0.02183367f, 0.00042494f, 0.08499996f, 0.23097448f, -0.23242334f, 0.10767297f, 0.47349665f, 0.07786539f, 
    -0.04483475f, -0.03732029f, -0.10554728f, -0.10548707f, -0.04226482f, -0.09153722f, 0.01738705f, -0.01016575f, 
    -0.05929794f, -0.01389165f, 0.03313595f, 0.00434189f, 0.03552877f, 0.15392999f, -0.05005751f, -0.14618884f, 
    -0.16744201f, -0.06658915f, 0.03688660f, -0.00202461f, -0.20777439f, -0.11908340f, -0.00524980f, 0.07270388f, 
    0.03455997f, 0.00208013f, 0.07062407f, 0.07318278f, 0.10668432f, 0.05255227f, -0.03803086f, -0.23736790f, 
    -0.19618042f, -0.17235856f, -0.22552741f, -0.18742418f, -0.17241949f, 0.04689176f, 0.13853602f, 0.06678151f, 
    -0.33077425f, -0.06205003f, -0.06799120f, -0.11446001f, -0.05922829f, -0.01619030f, -0.04390957f, 0.04661492f, 
    -0.04844215f, 0.02878176f, -0.02568592f, -0.17517160f, 0.11886467f, 0.11031048f, 0.02478397f, -0.07476989f, 
    0.17437126f, 0.09534063f, 0.02823929f, 0.00311117f, 0.11137668f, 0.14475638f, -0.06125360f, -0.03614274f, 
    0.04735856f, 0.12228697f, -0.01968420f, 0.01327933f, -0.02239048f, -0.02220248f, -0.08913552f, 0.02375780f, 
    -0.03686024f, 0.06515320f, 0.08487876f, -0.03005370f, -0.05173687f, 0.16095215f, 0.57006264f, -0.04255131f, 
    -0.10350341f, -0.15888457f, -0.15189357f, -0.15600824f, 0.01583686f, -0.00921945f, 0.09091156f, 0.02278837f, 
    -0.00985211f, 0.00133459f, -0.02336119f, 0.11888246f, 0.09157334f, 0.03082320f, 0.11932543f, 0.08703880f, 
    0.27797547f, 0.27295178f, -0.09487594f, -0.28770214f, 0.12477192f, 0.14869398f, -0.03588153f, 0.06477616f, 
    -0.05240598f, 0.23532876f, 0.06177567f, -0.02314071f, -0.03864974f, 0.01284741f, -0.11791322f, 0.31531000f, 
    -0.06106824f, 0.31860983f, -0.06651498f, -0.01685484f, -0.14212137f, -0.20262739f, 0.03792454f, 0.31682923f, 
    0.22902365f, 0.04968713f, -0.09850638f, 0.09540833f, 0.05468688f, 0.14290427f, 0.01669682f, -0.02871448f, 
    0.03074331f, 0.09810625f, -0.03077912f, 0.12018120f, -0.02532534f, -0.01428956f, 0.10414340f, -0.00453693f, 
    0.01956430f, 0.26113674f, 0.43618107f, -0.12259822f, -0.19955586f, 0.07479829f, 0.08705325f, -0.00499643f, 
    -0.01513391f, -0.35360071f, -0.02355349f, -0.13352808f, -0.11604153f, 0.06816371f, -0.01276120f, 0.06323369f, 
    0.17650200f, 0.04713902f, -0.07339460f, -0.17236985f, -0.02882812f, 0.04836603f, -0.40981427f, -0.10636178f, 
    -0.07346663f, -0.03182659f, -0.01502273f, 0.09444572f, -0.00246989f, 0.03754926f, -0.05754562f, 0.04680732f, 
    -0.02675973f, -0.11029419f, -0.08542696f, -0.09543599f, -0.02602110f, -0.02598557f, 0.02318581f, -0.10733613f, 
    0.12195876f, 0.03837471f, -0.03430989f, -0.13574733f, 0.14796072f, 0.05232250f, -0.09721284f, 0.03373462f, 
    -0.05472782f, 0.11132205f, 0.00195321f, -0.00515037f, -0.06144172f, -0.01295268f, 0.03198989f, 0.12655433f, 
    0.01776906f, 0.05854204f, 0.05122924f, 0.09489641f, 0.39432064f, 0.15904467f, 0.20878683f, -0.30784300f, 
    0.06934112f, 0.18813114f, 0.18677504f, 0.09977993f, 0.12426697f, -0.06340147f, 0.07394475f, -0.01648283f, 
    0.00740414f, -0.03418002f, 0.04759360f, 0.22775815f, 0.18914223f, 0.21035683f, -0.11017514f, 0.01721083f, 
    0.01299062f, -0.04287653f, -0.06164461f, 0.02642691f, 0.02083900f, -0.00394211f, 0.00343641f, -0.05032502f, 
    -0.03346958f, 0.03048551f, 0.01330347f, -0.05266853f, 0.00050928f, -0.01770237f, -0.03287893f, -0.03105688f, 
    -0.02320937f, 0.02776625f, 0.03964745f, -0.05904336f, 0.03561190f, -0.04511840f, -0.00709656f, -0.02779233f, 
    0.01839606f, -0.00191852f, -0.05786671f, -0.02452086f, 0.02265315f, 0.02012032f, 0.02301944f, 0.02103598f, 
    0.01528617f, -0.01809920f, 0.02482216f, 0.03179289f, -0.02694107f, -0.01430661f, -0.05378303f, 0.01549991f, 
    -0.00389625f, 0.02044548f, 0.01654496f, -0.03960370f, -0.04056284f, -0.01624742f, -0.04327356f, 0.02768967f, 
    -0.03145793f, -0.06282186f, 0.01464745f, 0.01483812f, -0.01922199f, -0.01976874f, 0.00501895f, 0.02291376f, 
    0.00617125f, 0.00794340f, -0.02969685f, 0.03656756f, -0.00900661f, -0.01219218f, 0.00842493f, -0.02552696f, 
    -0.05963708f, 0.00286479f, -0.00546622f, -0.06173217f, -0.02648224f, 0.02954672f, -0.04072715f, -0.04941905f, 
    -0.04060708f, 0.03967183f, 0.03743802f, 0.03403897f, -0.00180126f, 0.04002887f, -0.02743984f, -0.01537838f, 
    -0.05446517f, -0.01186528f, -0.03415666f, -0.00866046f, -0.02282358f, 0.03393805f, 0.00909279f, 0.03150551f, 
    0.04395290f, 0.01018710f, 0.03216564f, -0.03934095f, -0.04171482f, -0.03944803f, 0.00017127f, -0.02994868f, 
    -0.03471196f, -0.01928607f, -0.00650841f, -0.03599709f, -0.04885497f, 0.01344649f, 0.01894473f, -0.04280000f, 
    -0.01764006f, -0.06299005f, -0.03212447f, -0.02324268f, -0.04738292f, 0.02527544f, 0.04148748f, -0.05544504f, 
    0.00265408f, 0.01819641f, 0.01282643f, -0.02791183f, -0.02287432f, -0.05854760f, 0.03137909f, -0.04823580f, 
    -0.02731401f, -0.02110349f, 0.01480645f, 0.02855410f, 0.03310033f, -0.01036495f, -0.04399850f, 0.02684960f, 
    -0.02395933f, 0.00650340f, 0.01844891f, -0.00216935f, -0.02783262f, -0.03340318f, -0.01885118f, 0.01999123f, 
    0.02607022f, 0.02154999f, -0.03326503f, -0.04702891f, 0.00883828f, -0.04620470f, 0.00696310f, -0.02391937f, 
    0.04753333f, 0.00469616f, -0.02523423f, -0.01611066f, -0.04354151f, 0.00797309f, -0.05283653f, 0.03045821f, 
    0.03066083f, -0.06216265f, -0.02921968f, -0.06420159f, -0.02253132f, 0.00616378f, -0.05344585f, 0.01302110f, 
    0.04569282f, -0.01394235f, -0.01112306f, 0.01518469f, -0.04122874f, -0.01687043f, 0.04320060f, 0.01142818f, 
    -0.02277695f, -0.03989378f, 0.00300740f, 0.02899594f, -0.04719088f, -0.02269676f, 0.02971151f, -0.01868505f, 
    0.00650859f, 0.03912895f, -0.05430899f, -0.01832119f, -0.04533418f, 0.04503239f, -0.02478268f, -0.00482458f, 
    -0.04698170f, 0.04308695f, -0.01209632f, 0.01261187f, -0.05220849f, -0.05533880f, 0.02499312f, 0.01244924f, 
    0.02422518f, -0.05936018f, -0.05115437f, 0.00267077f, 0.02725673f, -0.04164491f, 0.01600999f, 0.02114432f, 
    -0.05888161f, -0.01117421f, 0.00016102f, 0.05690618f, -0.02818412f, -0.05443192f, 0.00776281f, 0.01999804f, 
    0.02882192f, 0.02124422f, 0.00668296f, 0.01846979f, -0.01559508f, 0.04828932f, 0.00094907f, -0.02712962f, 
    0.01780584f, 0.01989228f, 0.04309881f, -0.04188019f, 0.01763715f, 0.01505516f, -0.02002033f, 0.03890893f, 
    0.01800303f, -0.03800762f, -0.04782979f, -0.05298325f, -0.02664364f, 0.03343889f, 0.00811033f, -0.05308956f, 
    0.03416931f, -0.05252568f, 0.04588209f, -0.03380443f, -0.04569967f, -0.02024438f, 0.03964038f, -0.03684646f, 
    -0.00858792f, 0.00824456f, -0.04286805f, 0.01798792f, -0.05088823f, 0.00703843f, -0.00022174f, 0.03912797f, 
    0.00421235f, -0.04721931f, 0.00760723f, -0.04417884f, 0.00412948f, -0.04771867f, -0.03503382f, 0.01797574f, 
    0.03816079f, 0.03159626f, 0.03787066f, -0.02284208f, -0.02587918f, -0.05539802f, 0.03808099f, -0.01818173f, 
    -0.04705016f, 0.01311512f, -0.04721576f, -0.00056592f, -0.04090724f, -0.03867900f, -0.00313760f, 0.02903344f, 
    0.03144393f, 0.03031420f, -0.01500445f, -0.03994912f, 0.02873076f, 0.04451631f, 0.00069541f, 0.01823072f, 
    0.03073406f, 0.00739949f, 0.01363560f, -0.06320824f, -0.04710843f, -0.00706691f, -0.03245820f, -0.05810840f, 
    -0.00706988f, -0.03134947f, 0.03562708f, 0.00941361f, -0.05560746f, -0.01693233f, 0.04116116f, -0.00983021f, 
    0.01844156f, 0.03231004f, -0.06236466f, -0.05060421f, -0.01512587f, -0.01413466f, -0.04556295f, -0.00744792f, 
    -0.01582910f, -0.03649391f, -0.02117154f, -0.04512006f, -0.01264744f, 0.02857400f, 0.00484773f, -0.04019801f, 
    0.04541117f, -0.04372927f, -0.04043526f, 0.04011831f, -0.00392916f, -0.00269608f, -0.05951872f, -0.00103950f, 
    0.04133833f, -0.04166777f, -0.05187832f, -0.04343141f, -0.03111302f, 0.01465485f, -0.00142726f, -0.05905527f, 
    -0.01716519f, 0.04511301f, -0.02352763f, 0.02668410f, -0.01661770f, 0.00163947f, -0.05666493f, -0.05726883f, 
    0.00414707f, -0.05295080f, 0.01926681f, -0.00333617f, -0.05889015f, 0.01682218f, 0.01927388f, 0.01066527f, 
    0.01446444f, -0.05532722f, 0.03691206f, -0.02306065f, -0.03790610f, -0.02787578f, -0.03867337f, -0.00100354f, 
    -0.03411388f, 0.03544541f, 0.01581188f, -0.03811495f, -0.04756524f, 0.02847903f, 0.04246145f, 0.00822301f, 
    -0.01012591f, 0.01361102f, -0.06319380f, 0.02943399f, 0.03607147f, -0.04058525f, -0.02857552f, 0.04062641f, 
    0.02720937f, -0.01950249f, -0.04882865f, -0.01608697f, -0.05680731f, -0.01831890f, 0.03665988f, -0.05729861f, 
    0.02386675f, -0.02579795f, 0.03621751f, 0.02702865f, -0.00464275f, 0.01082074f, -0.02180752f, -0.03170110f, 
    0.04825647f, -0.01644866f, -0.02928358f, 0.02771949f, -0.02061875f, 0.03518209f, 0.00505115f, 0.02998482f, 
    -0.04633686f, 0.03237011f, 0.02287915f, 0.00615779f, 0.03943877f, 0.00028758f, 0.00434736f, -0.01229557f, 
    -0.06337117f, 0.03718459f, -0.02179514f, 0.00387861f, -0.02667137f, -0.04591357f, 0.03701966f, 0.00663741f, 
    0.01609859f, -0.02236522f, 0.03263528f, 0.01978694f, 0.01143862f, 0.01512136f, 0.05817161f, -0.02779488f, 
    -0.03122052f, -0.02431188f, -0.02620006f, -0.05831945f, 0.00462128f, -0.02449236f, -0.03415340f, -0.01479517f, 
    -0.05242549f, 0.05186880f, -0.05719890f, 0.04065069f, 0.01751613f, -0.01088691f, 0.03671655f, 0.02444495f, 
    0.03873989f, 0.02380098f, -0.03752083f, -0.03532713f, -0.00895194f, -0.00073785f, 0.03769057f, -0.05648513f, 
    0.04615961f, 0.00183305f, 0.01874401f, -0.03962535f, -0.01109858f, 0.05632742f, -0.03211159f, 0.02781937f, 
    -0.02562455f, -0.00435102f, 0.01886314f, -0.01718310f, 0.02920434f, 0.03386050f, 0.02392823f, 0.03539879f, 
    0.03691339f, -0.01400163f, -0.03393687f, -0.04525452f, -0.04614086f, 0.01754970f, 0.04134465f, -0.04464073f, 
    -0.04058523f, 0.04467947f, -0.00578235f, -0.03640884f, 0.04330005f, -0.02385727f, 0.03361634f, -0.06555297f, 
    -0.04344391f, 0.01910834f, -0.02723225f, -0.04946087f, 0.03203768f, -0.03082908f, 0.00303316f, 0.03351035f, 
    -0.03271571f, -0.04583461f, -0.06777593f, -0.05049307f, -0.01670629f, -0.02086241f, -0.04118578f, 0.02112226f, 
    -0.02643582f, -0.00631574f, -0.03430766f, 0.01319301f, -0.00856946f, -0.03823266f, -0.02563987f, -0.02898256f, 
    0.00766840f, -0.03401318f, 0.02058321f, 0.04122143f, -0.01134603f, -0.03640423f, -0.02149315f, -0.04702263f, 
    -0.02864912f, -0.05763896f, -0.00536687f, -0.03732489f, 0.00279129f, -0.05484283f, -0.03183554f, 0.04156188f, 
    -0.04817928f, -0.00353345f, 0.03383566f, 0.01759090f, -0.01693370f, -0.01491372f, 0.02335802f, 0.00137370f, 
    0.03360802f, 0.02909663f, 0.00533813f, 0.04207710f, 0.03347873f, 0.01051815f, 0.00331495f, -0.02926283f, 
    0.03001681f, -0.02801366f, -0.04027434f, -0.03595577f, 0.00312731f, -0.06089646f, -0.05268707f, -0.04802936f, 
    0.02762776f, 0.01501565f, -0.02497510f, 0.01482255f, -0.01531644f, -0.02300153f, -0.04046652f, -0.01041503f, 
    0.04466595f, -0.02798291f, 0.02190766f, 0.00416980f, -0.00630863f, 0.01101860f, 0.03329574f, 0.00456718f, 
    -0.01073604f, 0.04668918f, -0.03697029f, -0.05475529f, -0.01994528f, 0.04635310f, 0.00194827f, -0.04109361f, 
    0.01109736f, 0.02013558f, -0.03987301f, -0.05943162f, 0.00404592f, 0.04952361f, -0.05070222f, 0.04387357f, 
    0.03509280f, 0.04143322f, -0.00811670f, 0.03554669f, 0.01840489f, -0.05019933f, 0.00482297f, 0.04390313f, 
    0.01099213f, -0.02597553f, -0.04380070f, -0.04958945f, -0.05503582f, 0.02978934f, 0.03565306f, 0.02370767f, 
    -0.04481677f, -0.03524590f, -0.04791203f, -0.01616757f, -0.02984887f, 0.00007340f, -0.05898032f, 0.01606789f, 
    -0.03108891f, -0.04411572f, -0.04597300f, -0.05993800f, -0.04003530f, -0.04413994f, 0.05501064f, 0.00481044f, 
    0.03190361f, 0.01523173f, 0.01779578f, -0.05144818f, -0.06301554f, -0.05671898f, -0.00640267f, -0.03302406f, 
    -0.04203646f, -0.05936076f, -0.05399382f, -0.01759253f, 0.02764643f, -0.00980169f, 0.01901354f, 0.01166255f, 
    0.03172193f, -0.00883590f, -0.03685803f, 0.01289950f, -0.00408379f, 0.01462677f, -0.02807267f, 0.02238465f, 
    -0.04185455f, 0.02041953f, 0.01976371f, -0.01104159f, -0.04657713f, -0.03702147f, -0.01537653f, 0.01719707f, 
    -0.00851859f, -0.04176472f, -0.03500968f, -0.03905348f, 0.04736324f, 0.05025299f, -0.04310505f, -0.03442308f, 
    -0.21819764f, -0.55247974f, -0.51271403f, -0.64372402f, -0.49291676f, -0.27837470f, -0.17995290f, -0.15775521f, 
    0.07039564f, 0.04894254f, -0.12690131f, -0.14924659f, -0.07643864f, -0.05813988f, -0.10162148f, 0.04200525f, 
    0.15509821f, 0.06241446f, 0.01644515f, 0.06470501f, -0.17555453f, -0.07906692f, -0.08279811f, -0.24788912f, 
    -0.32967097f, -0.19206035f, -0.20106693f, -0.00545982f, 0.07853397f, 0.20182675f, -0.07599482f, -0.17336407f, 
    0.03022327f, -0.11940613f, -0.01945960f, -0.04356273f, -0.02195756f, 0.04480967f, -0.09643999f, -0.00923659f, 
    -0.44499657f, -0.59350407f, -0.61525857f, -0.44218415f, -0.16986015f, 0.06733461f, 0.04798895f, -0.12886311f, 
    -0.07516015f, 0.11174998f, -0.10424130f, -0.12430085f, 0.17716749f, -0.01323558f, -0.00503829f, 0.19384190f, 
    0.19086522f, 0.17143045f, 0.15797883f, 0.12715675f, 0.37725422f, 0.04893626f, 0.32798132f, -0.04758607f, 
    0.08631277f, 0.02757640f, 0.22022380f, 0.03696901f, 0.16693568f, 0.05380781f, -0.07126646f, 0.02428000f, 
    -0.03781256f, 0.01830045f, -0.10318461f, 0.09186951f, 0.15260078f, 0.07052936f, 0.04344223f, 0.12476667f, 
    -0.21694982f, -0.30556935f, -0.08594898f, 0.05490991f, -0.04643224f, 0.22181766f, 0.14098020f, -0.24667828f, 
    0.01233344f, 0.17657846f, 0.13542046f, 0.00156897f, -0.18424988f, -0.07876139f, -0.07518262f, -0.02414549f, 
    0.02088302f, 0.07928844f, -0.00506675f, -0.21160813f, 0.63645172f, 0.26453406f, 0.36711952f, 0.25959423f, 
    0.21132326f, -0.07889665f, 0.03687936f, -0.04415740f, 0.05209179f, -0.01193576f, -0.09031145f, -0.02748410f, 
    -0.01981490f, -0.08503859f, 0.02463154f, 0.16636750f, 0.17176349f, 0.11716501f, 0.10038384f, 0.23233293f, 
    0.18050553f, 0.12521105f, 0.09010221f, 0.10788210f, 0.04131942f, -0.09826902f, -0.05314085f, 0.01644444f, 
    -0.02216752f, -0.05478244f, 0.20848018f, -0.01187629f, -0.09986525f, 0.06600912f, 0.15115704f, -0.07151794f, 
    -0.20335031f, -0.07939219f, 0.02841943f, -0.09579185f, 0.22679745f, 0.25796580f, 0.22884193f, 0.14813949f, 
    0.16938120f, 0.07588947f, 0.06239822f, -0.01152629f, 0.02972924f, -0.09244493f, 0.02783586f, 0.03015161f, 
    0.02793664f, 0.07380787f, -0.01920973f, 0.08172566f, 0.15012339f, 0.02823733f, -0.00713947f, -0.07343857f, 
    0.02295354f, -0.43479109f, -0.46235856f, -0.33749008f, -0.00335619f, 0.14621796f, 0.09371735f, -0.14245652f, 
    0.04370018f, 0.10288916f, -0.00335698f, 0.00997509f, -0.00806974f, -0.07210906f, 0.03973816f, 0.04635796f, 
    0.10343629f, 0.09842706f, 0.26292452f, -0.09128389f, 0.65990239f, 0.41288868f, 0.32928762f, 0.06026282f, 
    0.01528468f, -0.08724999f, 0.01666868f, 0.08748296f, -0.06282992f, 0.01888252f, -0.12509528f, -0.04784219f, 
    0.03559504f, -0.07974660f, -0.07852687f, 0.02123175f, 0.03390181f, -0.10787002f, 0.01033577f, 0.28280517f, 
    -0.19219501f, -0.27551931f, -0.72925949f, -0.35064939f, 0.10625593f, -0.02949039f, -0.02105232f, -0.18279849f, 
    -0.16622819f, -0.04917519f, 0.06555799f, 0.05510775f, 0.07170525f, 0.07785241f, 0.00273586f, -0.17688192f, 
    -0.02132609f, 0.17347425f, 0.23640014f, 0.01335475f, 0.09387403f, -0.03366069f, 0.05788753f, -0.18672502f, 
    -0.11783307f, 0.09575958f, 0.13483657f, -0.06655173f, 0.19245197f, -0.06069529f, 0.03553432f, 0.06612352f, 
    0.04624477f, 0.05798431f, 0.10462125f, 0.11316413f, 0.31614798f, 0.15672269f, 0.25195980f, 0.01446880f, 
    0.24303888f, 0.05785757f, 0.28786534f, 0.03296016f, 0.18681379f, -0.00726037f, 0.19142468f, 0.16088279f, 
    -0.09213535f, 0.10614067f, -0.05656841f, -0.03429149f, -0.03138262f, 0.03313041f, 0.03907191f, 0.02467506f, 
    0.17971884f, 0.07373604f, -0.02425488f, -0.00186287f, 0.00475603f, 0.05891013f, -0.00586344f, -0.06007384f, 
    -0.16383979f, -0.00159532f, -0.09296310f, 0.08056147f, -0.00547471f, 0.00328343f, -0.00919193f, -0.02167765f, 
    -0.18120627f, 0.07452323f, -0.03103224f, -0.03768938f, -0.04662076f, -0.03038373f, 0.01640430f, 0.00454581f, 
    -0.27743259f, -0.31959528f, -0.52651048f, -0.10294586f, -0.07198819f, -0.01586619f, 0.11353362f, -0.04591012f, 
    -0.10997498f, 0.03824890f, 0.05919960f, -0.03393802f, 0.02363778f, -0.06602611f, -0.00414670f, 0.07005133f, 
    0.05264309f, 0.15172032f, 0.12614161f, 0.01092282f, -0.30681223f, -0.42315865f, -0.16065823f, -0.55245644f, 
    -0.08056628f, -0.09378573f, -0.03355495f, -0.14891560f, -0.07150286f, -0.00190753f, -0.00885099f, -0.06329629f, 
    0.11484297f, -0.09179041f, 0.06753181f, 0.01028593f, 0.26534241f, -0.26734772f, 0.19677539f, -0.03823067f, 
    0.01381145f, -0.11701609f, -0.07455748f, -0.15867595f, 0.12444732f, 0.13422485f, 0.03775371f, 0.08235316f, 
    0.02766282f, -0.04606053f, 0.04029376f, -0.11371198f, 0.07931691f, -0.01199672f, -0.02931854f, -0.12790871f, 
    -0.02367648f, 0.04610138f, -0.20269166f, 0.03767841f, 0.24778382f, -0.41166991f, -0.19919090f, 0.01012586f, 
    -0.00799867f, 0.18250649f, -0.10760248f, -0.06011511f, -0.04002315f, -0.07434508f, 0.11396392f, 0.01481635f, 
    -0.07395824f, -0.10025390f, -0.02518797f, -0.00541043f, 0.00533168f, 0.04795898f, -0.04317946f, -0.09688038f, 
    -0.02457714f, 0.09576143f, -0.03690084f, -0.00032037f, 0.17278047f, 0.09669759f, 0.05600545f, -0.04596172f, 
    -0.11503921f, 0.05775962f, -0.09791838f, -0.00345756f, 0.06724171f, 0.14581628f, 0.14386953f, -0.15200748f, 
    -0.14913033f, -0.03197561f, -0.09269969f, 0.01198799f, 0.22483042f, 0.09568960f, 0.16423009f, 0.20634143f, 
    0.21546143f, 0.05108117f, 0.21835245f, -0.25213757f, 0.16636701f, -0.02146963f, -0.03498253f, -0.03884010f, 
    -0.02466785f, -0.00425205f, 0.03654202f, 0.11644199f, 0.00727246f, 0.07227146f, -0.05548139f, 0.11339448f, 
    0.14265607f, -0.28118628f, 0.06065247f, 0.06556106f, 0.18575478f, 0.04372398f, -0.07791157f, -0.00789991f, 
    -0.03681349f, -0.04431111f, 0.04928090f, 0.08057051f, -0.01310381f, -0.10477187f, -0.01588314f, -0.00126975f, 
    -0.05698029f, 0.12401219f, 0.03277031f, 0.04156622f, 0.10551354f, -0.15909263f, 0.26008928f, -0.01670461f, 
    0.00876877f, -0.01137154f, -0.02867522f, -0.18224211f, -0.06930455f, 0.05720335f, 0.00613332f, -0.06068469f, 
    0.06277772f, -0.11998649f, -0.12941262f, -0.00623496f, -0.00362963f, 0.12332650f, -0.05843823f, -0.02068578f, 
    -0.25982299f, -0.06330583f, -0.15501687f, -0.08749796f, -0.09370635f, 0.04302134f, 0.08887280f, 0.05532294f, 
    0.03236344f, -0.09548050f, 0.00236450f, 0.09419681f, 0.04914993f, 0.03411651f, 0.03503772f, 0.08943277f, 
    0.05958840f, 0.07115235f, 0.10542354f, 0.06979477f, -0.25581491f, 0.18710896f, 0.26601055f, -0.08818870f, 
    0.00734346f, -0.03810627f, 0.05719561f, 0.01449321f, 0.07299561f, 0.07729392f, -0.00373989f, -0.03980157f, 
    0.03483835f, -0.00926748f, 0.09936105f, 0.15024205f, 0.03721529f, 0.15702760f, 0.01335919f, -0.03568581f, 
    0.09485192f, -0.17536201f, 0.05976450f, 0.17642024f, 0.27050608f, 0.01450249f, 0.03049240f, -0.01504199f, 
    0.04624695f, -0.01385710f, 0.04137581f, -0.01721080f, 0.08738261f, 0.05794287f, -0.01551108f, 0.01230913f, 
    0.07829124f, -0.16154163f, 0.12484994f, 0.01683826f, 0.08723360f, -0.00109453f, 0.57184821f, 0.11246482f, 
    -0.03505140f, 0.06769766f, -0.11452793f, -0.04698350f, 0.02166665f, 0.06985090f, -0.11742154f, -0.00243823f, 
    -0.01971108f, -0.06591629f, -0.00528239f, -0.07518272f, -0.04623384f, -0.02265008f, -0.05023254f, 0.00390177f, 
    -0.32869592f, 0.02382341f, 0.14360838f, 0.16299430f, -0.13152106f, -0.04465238f, 0.00519493f, 0.05224506f, 
    -0.10172842f, 0.04607332f, -0.05966947f, 0.00796747f, -0.05183662f, -0.04484298f, 0.10982835f, 0.10745389f, 
    0.04014546f, 0.03814615f, -0.03136156f, -0.09561551f, -0.20353685f, -0.12373818f, 0.16086587f, 0.11711830f, 
    0.39713013f, 0.03216884f, 0.07384773f, 0.04583402f, 0.03090011f, 0.14166753f, -0.13359006f, 0.10030280f, 
    -0.02184314f, -0.14159006f, -0.07858906f, -0.00086388f, -0.08452450f, 0.04447647f, 0.17884496f, 0.00282798f, 
    0.44935971f, 0.37690535f, -0.13466015f, 0.09105231f, -0.26718175f, 0.18463191f, 0.05784931f, -0.11803300f, 
    -0.17296498f, 0.02951930f, 0.01446908f, -0.02094401f, 0.05082345f, -0.02946924f, -0.06026774f, 0.00863246f, 
    0.07261247f, 0.23171338f, -0.15694734f, 0.10031854f, -0.25762042f, -0.04852118f, -0.30060858f, -0.06816276f, 
    -0.10743775f, 0.10474172f, -0.03122348f, 0.02258135f, 0.04742093f, -0.00446771f, 0.10147596f, 0.14899670f, 
    0.03830736f, -0.00590275f, 0.03856713f, -0.00218912f, -0.00498931f, -0.08822576f, 0.08172026f, 0.06743965f, 
    0.09620235f, -0.12910080f, 0.02771565f, 0.10794203f, 0.04181211f, -0.08218236f, 0.02468929f, 0.02837504f, 
    0.10340306f, 0.06509165f, -0.02191224f, -0.01134898f, -0.01291913f, 0.09610961f, -0.01514093f, 0.00968139f, 
    0.04278320f, 0.03382220f, 0.07767567f, 0.02826525f, 0.20785961f, -0.19069298f, -0.08387721f, -0.07031454f, 
    0.04581131f, 0.11207264f, -0.01695260f, -0.01038648f, 0.16107371f, -0.02678440f, 0.07619213f, -0.03501632f, 
    0.05731105f, 0.02606245f, -0.03401146f, 0.01384806f, 0.04335559f, 0.05253404f, 0.06864389f, 0.05985301f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04863759f, -0.05650080f, -0.02177018f, 0.05224635f, -0.04201278f, 0.01691168f, 0.02347891f, -0.04918819f, 
    0.00886314f, 0.11485106f, 0.14293641f, 0.00844888f, 0.01850584f, 0.09593416f, 0.08183889f, 0.13297123f, 
    0.04408814f, -0.02119914f, -0.03515308f, 0.01470182f, 0.12882099f, -0.04687279f, 0.03456347f, -0.04121365f, 
    0.13227300f, 0.17034850f, -0.02789686f, 0.03525081f, -0.02184124f, 0.09359464f, 0.09294439f, 0.01319582f, 
    0.03701359f, 0.00386693f, 0.09294830f, 0.22280051f, -0.00580351f, 0.11063481f, 0.12918855f, 0.12396404f, 
    0.19109544f, 0.06443090f, -0.00879227f, -0.01278486f, 0.08882216f, -0.04858741f, -0.07281633f, 0.16770452f, 
    -0.00842479f, -0.08278971f, 0.05542335f, 0.14199634f, 0.19435644f, -0.05367995f, 0.08213793f, 0.01137994f, 
    0.05131957f, -0.00973516f, 0.00772828f, -0.10996688f, -0.03415459f, -0.06019039f, 0.17129546f, -0.02053683f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.31867415f, 0.12317950f, -0.59491390f, -0.06085379f, 0.12575763f, 0.17545275f, 0.03968060f, 0.15472801f, 
    -0.04154573f, -0.20206028f, -0.23561925f, 0.26618835f, 0.02492922f, -0.10476680f, -0.22507575f, 0.08435314f, 
    0.22744581f, 0.23062921f, 0.00671842f, 0.29121715f, -0.29822475f, -0.03103234f, -0.08914154f, -0.04283274f, 
    -0.28593698f, -0.38411522f, 0.10587226f, -0.07127919f, -0.10829793f, -0.33841249f, -0.16586751f, -0.10226365f, 
    -0.00633941f, -0.07061582f, -0.24570917f, -0.05343179f, 0.13449407f, -0.18069088f, -0.26751095f, -0.15510736f, 
    -0.06888473f, 0.07207995f, -0.07387868f, -0.00428709f, 0.21272749f, 0.10957337f, 0.01558747f, -0.16999140f, 
    0.24790041f, 0.28210977f, -0.62544858f, 0.08112316f, -0.57324558f, 0.25253934f, -0.15054622f, -0.28844187f, 
    -0.15899874f, 0.19443581f, 0.09037407f, 0.15180975f, 0.06682892f, -0.10500840f, -0.19835137f, -0.35254398f, 
    -0.28814128f, 0.03655451f, -0.48056939f, -0.25430489f, -0.05263969f, 0.30070445f, 0.17247239f, -0.19203897f, 
    -0.01524607f, 0.02712910f, 0.17572527f, 0.17749228f, 0.10211459f, 0.13588122f, 0.04781570f, 0.06246575f, 
    -0.11682393f, 0.03120568f, -0.17930672f, -0.15371136f, 0.03886300f, -0.12812221f, -0.06220926f, -0.10429168f, 
    0.40874597f, 0.33291504f, -0.08658537f, -0.04811073f, 0.04370050f, -0.01719306f, 0.23904890f, -0.04518529f, 
    -0.25810239f, 0.04254039f, -0.05035927f, -0.00744478f, 0.22771551f, -0.28889897f, 0.18735124f, -0.16312025f, 
    0.05734184f, 0.02059606f, -0.32106751f, 0.05548004f, -0.06779566f, 0.27605215f, -0.07453393f, 0.17739625f, 
    0.22537610f, 0.23435885f, 0.02423453f, 0.34135419f, -0.17514122f, -0.25743532f, -0.16101658f, -0.26518685f, 
    -0.50721705f, 0.02071863f, -0.56539953f, -0.08936263f, -0.06966470f, -0.00131038f, 0.39151090f, -0.25232786f, 
    -0.37009776f, 0.10469107f, -0.02097370f, -0.42983472f, -0.26657704f, -0.36264524f, -0.21327932f, -0.31096968f, 
    0.07088913f, 0.22015390f, -0.19340773f, 0.14368390f, 0.12099963f, 0.29550236f, 0.02229490f, -0.23310150f, 
    0.19238441f, -0.18751459f, -0.07926799f, -0.12458344f, 0.13097292f, 0.08397214f, -0.07399925f, 0.00245348f, 
    0.25341082f, -0.22640102f, -0.10178620f, 0.01070726f, 0.06860463f, -0.06728033f, 0.00762247f, 0.02835672f, 
    0.41848779f, 0.06392273f, 0.08358752f, 0.15101574f, -0.10948249f, -0.13664898f, 0.13710566f, 0.06518637f, 
    0.00284928f, -0.23073398f, -0.25611815f, -0.03190166f, 0.21991612f, -0.71215266f, 0.00739653f, -0.01709986f, 
    -0.12236573f, -0.56196392f, 0.22418553f, 0.42058989f, 0.13339280f, 0.42474976f, -0.07972924f, -0.13388021f, 
    0.18470226f, 0.13097318f, -0.27787933f, -0.27219865f, 0.09572711f, 0.06310551f, -0.29364443f, 0.04738435f, 
    0.01406922f, -0.02354647f, -0.03527866f, 0.28335574f, -0.12304036f, -0.16037267f, -0.28199840f, -0.17528811f, 
    -0.07337116f, 0.20826691f, -0.13233489f, -0.00913211f, 0.05862039f, 0.21226522f, -0.13038883f, -0.20367984f, 
    0.19612437f, 0.06064767f, 0.36081451f, -0.47077277f, -0.17495131f, 0.00182361f, 0.05633631f, 0.01925355f, 
    0.25049537f, -0.00444118f, -0.07392043f, -0.04821289f, 0.07320680f, 0.00487412f, -0.04993683f, 0.02534475f, 
    0.10042207f, 0.04505209f, -0.08509363f, -0.06487838f, -0.16187535f, -0.00765293f, -0.34695891f, 0.03416241f, 
    -0.18352868f, 0.08329953f, 0.19858642f, 0.00226737f, -0.37195471f, 0.30607519f, -0.11769112f, -0.35909128f, 
    -0.32601705f, 0.08951862f, 0.36862642f, 0.08081876f, 0.05798952f, 0.08098255f, -0.38742420f, -0.03138606f, 
    -0.18737544f, 0.23535669f, 0.28341505f, 0.11675562f, 0.05423330f, 0.10706433f, -0.56767166f, 0.18207273f, 
    -0.21480078f, -0.08520953f, 0.35545972f, 0.01591175f, 0.27086028f, 0.06958298f, 0.16466627f, 0.05282212f, 
    -0.09875602f, 0.21788548f, -0.13440394f, 0.06212800f, 0.09509321f, -0.11509565f, -0.26791683f, 0.23395252f, 
    0.02098434f, 0.14339119f, -0.33336684f, 0.22670263f, -0.01447537f, 0.04368401f, -0.11785822f, -0.03177096f, 
    -0.29073235f, 0.11934275f, -0.06184205f, -0.04382926f, -0.02667899f, -0.06228279f, -0.05823515f, -0.09076288f, 
    0.03778997f, -0.02803247f, 0.18785116f, -0.51487279f, -0.04172892f, -0.31867346f, -0.27343637f, 0.25026375f, 
    -0.07540348f, 0.07148815f, 0.19286801f, -0.01338756f, -0.42131791f, -0.03312628f, -0.01809264f, 0.07616439f, 
    -0.27411211f, 0.14786002f, 0.02733662f, -0.11675186f, -0.12549478f, 0.19154659f, 0.10926683f, -0.24511324f, 
    0.35435319f, -0.23460026f, -0.20962331f, -0.11560136f, -0.08112471f, 0.07910966f, -0.17134987f, -0.10766196f, 
    0.28056702f, -0.01462062f, 0.06286700f, -0.13650782f, 0.14142531f, 0.11096299f, -0.18837647f, -0.00382979f, 
    -0.11107361f, 0.01639033f, -0.01388453f, 0.06860171f, -0.00278995f, 0.14861608f, 0.18459956f, 0.26702487f, 
    0.15956464f, 0.17976661f, -0.35542306f, -0.08649988f, -0.00400483f, -0.00391288f, 0.07163503f, -0.04838225f, 
    -0.32072219f, -0.31193748f, -0.03373526f, -0.01018969f, 0.04035102f, 0.11287487f, 0.09195941f, 0.02965710f, 
    -0.39722762f, -0.08978836f, -0.14277731f, 0.12527069f, 0.18447486f, 0.18372716f, -0.13984309f, -0.05888025f, 
    0.16528603f, 0.16459630f, 0.16531608f, -0.05134352f, -0.35603335f, -0.47847521f, -0.01428786f, 0.14322443f, 
    -0.00080305f, -0.22034700f, -0.76987052f, 0.11707959f, -0.03556443f, -0.46693319f, 0.32001570f, 0.20652491f, 
    0.03669652f, -0.39240786f, -0.04110604f, -0.11655978f, -0.07608335f, 0.03166750f, -0.19646014f, 0.11912061f, 
    0.07891499f, -0.11428791f, 0.18775624f, -0.17942575f, -0.55785233f, -0.14087051f, -0.03045277f, -0.43804914f, 
    0.03500555f, 0.07895700f, -0.12819490f, -0.35042804f, 0.03777464f, -0.56344420f, -0.10900893f, -0.50198305f, 
    -0.51981276f, -0.42362455f, 0.20818980f, 0.12297481f, 0.12512314f, 0.01022727f, -0.09531763f, -0.08912819f, 
    0.31719089f, -0.16914536f, -0.07616926f, -0.06484301f, -0.00349340f, -0.02925232f, 0.07498751f, -0.12515223f, 
    0.20925251f, 0.03560161f, 0.17514811f, 0.02017845f, -0.30422556f, 0.33001241f, -0.13356763f, 0.26316798f, 
    -0.31825984f, -0.42970866f, -0.03747986f, 0.03884472f, 0.23038012f, -0.31833148f, -0.05030718f, -0.33286062f, 
    0.15605754f, -0.36934391f, -0.06271677f, 0.00158145f, 0.35266113f, -0.38296056f, 0.32841054f, 0.08578259f, 
    0.06876399f, -0.11410266f, 0.29018542f, -0.68376946f, 0.07792255f, 0.02982151f, -0.00555912f, -0.32400927f, 
    0.13776979f, -0.05477486f, 0.20189886f, 0.12025657f, -0.03952327f, -0.20051968f, -0.13607492f, -0.33601910f, 
    0.07542564f, -0.03050973f, -0.14795916f, -0.25047952f, -0.01950637f, -0.53171659f, 0.03638640f, -0.29360652f, 
    -0.09091116f, 0.19614820f, -0.27535391f, -0.01746038f, 0.33813965f, -0.11871489f, -0.10450628f, 0.05241421f, 
    -0.44081232f, -0.39265752f, 0.01523846f, -0.09660653f, 0.09426676f, 0.17387398f, -0.18869309f, 0.06432322f, 
    -0.41987720f, -0.08908526f, 0.25399378f, 0.13021001f, 0.19926874f, -0.12386037f, -0.11048467f, -0.37156510f, 
    0.06058997f, -0.05707004f, -0.14638773f, 0.02506505f, -0.19045992f, 0.38248694f, 0.09518851f, -0.06893706f, 
    0.02189753f, -0.09511029f, 0.10501442f, -0.32822290f, -0.52391672f, 0.51158345f, -0.48315927f, 0.14604102f, 
    0.29317376f, -0.18382499f, 0.06971873f, 0.06837070f, -0.10448432f, -0.12731157f, 0.08639251f, 0.17502008f, 
    -0.37916932f, -0.12400921f, -0.15406160f, 0.43482929f, -0.48845965f, 0.21695065f, -0.24681288f, 0.08442832f, 
    0.02608807f, 0.11386597f, 0.19544417f, -0.41094896f, -0.12923279f, -0.09574939f, 0.28181976f, -0.56522387f, 
    0.21750024f, -0.13594766f, 0.08353031f, -0.24048442f, 0.22744632f, -0.11678040f, 0.01571275f, 0.07288576f, 
    0.19978224f, -0.02236470f, -0.02290223f, -0.06016539f, 0.07122771f, -0.15527031f, -0.49362469f, -0.03149568f, 
    -0.54975826f, -0.08815904f, -0.06892321f, 0.15250868f, -0.00540814f, 0.15606637f, 0.09885610f, -0.37813669f, 
    0.04148572f, 0.19843513f, -0.09628167f, 0.08703893f, -0.05698190f, -0.34964997f, 0.05135838f, -0.22762936f, 
    0.26990625f, -0.69099015f, -0.20892464f, -0.36258322f, -0.30712122f, -0.32005697f, 0.00966414f, 0.28259474f, 
    -0.52164298f, 0.22701615f, -0.26777866f, 0.26927322f, -0.12066906f, 0.00976839f, -0.07415157f, 0.24700513f, 
    -0.19474114f, -0.09255427f, 0.13536859f, 0.28458017f, 0.24305521f, 0.13514987f, 0.26780838f, -0.40867615f, 
    -0.10768022f, -0.44291165f, -0.24633314f, -0.23247626f, 0.01150702f, -0.07489631f, 0.08833382f, 0.33178166f, 
    -0.53715205f, 0.13320971f, -0.56593835f, 0.34706819f, -0.47276184f, 0.08932704f, 0.00022710f, 0.05189076f, 
    -0.19426623f, -0.00024869f, -0.07376071f, -0.09509017f, -0.07114289f, -0.23452923f, 0.02151652f, 0.11131252f, 
    -0.00075968f, 0.07001152f, 0.17804095f, 0.28639886f, -0.27578217f, 0.05278088f, 0.23177928f, 0.01306072f, 
    -0.23960125f, -0.45874006f, -0.12551479f, 0.06685910f, 0.16370152f, 0.08358835f, 0.14841218f, 0.23112653f, 
    -0.03974721f, -0.50826180f, 0.07861736f, -0.00459808f, 0.15517193f, 0.17820619f, -0.12513897f, -0.12057716f, 
    0.11521983f, 0.11058092f, 0.32749647f, -0.31848717f, -0.07617088f, -0.11590412f, -0.09615962f, -0.18539545f, 
    -0.67188627f, -0.03323670f, -0.48661020f, 0.26915947f, -0.42226335f, -0.50925899f, 0.04053223f, 0.14541753f, 
    0.08853430f, -0.46776736f, 0.11318804f, 0.06859165f, -0.02560719f, 0.21505363f, -0.32492539f, -0.09419542f, 
    -0.28381371f, 0.05409278f, -0.00370113f, -0.50128323f, 0.18456012f, 0.03506173f, 0.00679856f, 0.07298296f, 
    -0.00687979f, -0.02395522f, -0.12586546f, 0.07874858f, 0.06287134f, 0.27473500f, 0.23749477f, 0.03945817f, 
    -0.47618839f, 0.11820134f, -0.41150358f, -0.03711728f, -0.34952617f, 0.24822196f, 0.21929087f, 0.14327435f, 
    0.29055911f, 0.17818823f, 0.26575789f, -0.07293827f, 0.31146407f, -0.15942796f, 0.04389215f, 0.24044041f, 
    -0.29349676f, 0.21863580f, -0.09923540f, -0.13778067f, 0.18117736f, -0.50354648f, -0.06056366f, 0.20526469f, 
    0.17164274f, 0.25314304f, -0.50449103f, -0.02346008f, -0.06246737f, -0.06117290f, -0.42460805f, -0.24333957f, 
    0.41601646f, 0.07346144f, 0.15097353f, -0.13443279f, -0.24561802f, -0.16637301f, 0.27403161f, 0.59295851f, 
    -0.12521726f, 0.04766958f, 0.20754108f, -0.26416799f, -0.02918979f, -0.17276877f, 0.11181863f, -0.13388562f, 
    -0.11604954f, -0.44236460f, 0.36941150f, -0.29643849f, -0.47306490f, -0.09392860f, 0.02106502f, 0.01560663f, 
    0.09720422f, -0.19647147f, 0.00982557f, -0.07466757f, -0.03904936f, 0.07497540f, 0.24311991f, 0.03368199f, 
    -0.18766645f, -0.00080259f, -0.03667939f, -0.26718438f, -0.19834489f, -0.28494900f, 0.11650327f, -0.16543005f, 
    -0.38969895f, -0.10718668f, 0.22073053f, -0.05213745f, 0.14826173f, -0.19101837f, -0.13526951f, 0.00361744f, 
    0.06912811f, -0.14134449f, 0.31700110f, -0.57238752f, 0.22422417f, -0.01972644f, -0.10467308f, 0.14174409f, 
    0.08869168f, -0.00966251f, -0.04965270f, 0.03081595f, 0.05192232f, -0.00059855f, 0.26401657f, 0.26601732f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.31214651f, 0.21154554f, 0.09030575f, -0.13588153f, -0.01820830f, 0.00833528f, 0.08193758f, 0.06735387f, 
    0.04410995f, 0.05613028f, -0.00174248f, 0.06747904f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
