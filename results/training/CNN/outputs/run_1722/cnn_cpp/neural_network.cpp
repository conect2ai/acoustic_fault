#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.14203927f, -0.62707877f, -0.44186273f, -0.49524134f, -0.41382244f, 0.36810425f, 0.30278081f, -0.07718919f, 
    0.03680164f, -0.06935336f, 0.01758166f, -0.01936940f, -0.32401556f, -0.12589583f, 0.14066485f, -0.19281402f, 
    0.04883473f, -0.06624465f, 0.00534284f, -0.21267419f, -0.16785125f, -0.16507751f, -0.21945038f, -0.03322275f, 
    -0.29816428f, -0.10770360f, 0.12623775f, -0.54698837f, -0.41248041f, 0.35632342f, 0.18225674f, 0.21975969f, 
    -0.03879936f, -0.21145605f, 0.29751295f, 0.05954275f, -0.15818641f, 0.20420636f, 0.17349795f, 0.03495151f, 
    0.05005183f, 0.13522461f, -0.05991286f, -0.40918827f, -0.14937782f, -0.12909620f, 0.25085008f, 0.31556535f, 
    -0.00157066f, -0.01429883f, -0.91220093f, -0.28445929f, 0.20000981f, -0.27687457f, -0.45227736f, 0.53310382f, 
    0.21271119f, 0.22789969f, 0.28981805f, 0.48200801f, -0.05937438f, -0.13582183f, 0.06185622f, -0.14142519f, 
    -0.10022273f, -0.17196831f, 0.10213363f, -0.26231572f, 0.15546976f, 0.24859646f, -0.09279944f, 0.05093730f, 
    0.22257698f, -0.00934752f, -0.06915737f, -0.81301302f, 0.17476861f, -0.28346419f, -0.48588556f, -0.09603956f, 
    0.25404602f, -0.05778232f, 0.25183734f, 0.34307146f, 0.33850732f, 0.13649394f, 0.07667846f, -0.03838217f, 
    -0.01580201f, -0.05715033f, 0.20486285f, 0.04366485f, 0.13528927f, 0.06260175f, 0.12713522f, -0.08572683f, 
    0.22958818f, -0.07110336f, -0.15965167f, -0.29151294f, 0.14465295f, 0.23239437f, 0.07860710f, 0.15560420f, 
    0.23928434f, -0.01815920f, -0.05979317f, 0.26166791f, 0.27160615f, -0.13549995f, -0.07327085f, -0.18201458f, 
    -0.03552110f, 0.15871471f, 0.04694156f, -0.09105802f, -0.08749412f, -0.09997420f, 0.15951906f, 0.07453813f, 
    -0.12338062f, -0.08629460f, -0.02840775f, 0.22615290f, -0.09064377f, 0.19382407f, 0.22810966f, 0.23429720f, 
    0.26221839f, -0.49655288f, -0.36281931f, -0.28500414f, 0.05031988f, -0.12612306f, 0.36468139f, 0.43548796f, 
    -0.35572973f, 0.07165250f, -0.11123715f, 0.28601590f, -0.36807474f, 0.24587786f, -0.17644504f, -0.01593021f, 
    -0.26913154f, 0.20541057f, 0.04253384f, 0.16973867f, 0.20336710f, -0.12922058f, -0.38328037f, 0.49350813f, 
    0.30288237f, -0.19136313f, -0.50547498f, -0.31096843f, -0.03499781f, 0.19757877f, 0.31756997f, 0.28203076f, 
    -0.04416070f, -0.20023443f, -0.22245649f, -0.43568256f, -0.09480862f, -0.11599779f, 0.16660714f, 0.21704999f, 
    0.19559722f, -0.10101125f, 0.03620096f, 0.05260532f, -0.37864208f, -0.27551046f, -0.41282552f, 0.81378680f, 
    0.23193605f, -0.00807826f, -0.62896669f, -1.12188387f, -0.13344100f, 0.00909741f, 0.12214104f, 0.07736541f, 
    0.04945751f, 0.05845375f, 0.38660720f, -0.04462732f, 0.21917310f, 0.15681398f, -0.38550213f, -0.22229378f, 
    0.17002729f, 0.20239535f, -0.38324654f, 0.26561421f, -0.13746451f, -0.13005655f, 0.14104047f, -0.02349793f, 
    0.02429237f, 0.19456711f, 0.46508688f, -0.65306586f, -0.56399882f, 0.13801742f, 0.15573356f, 0.26108801f, 
    0.11100678f, -0.39765877f, -0.24539392f, 0.08090241f, 0.01284100f, -0.03810703f, 0.07276198f, 0.23256610f, 
    0.20702194f, -0.10669777f, -0.09380004f, 0.03970426f, 0.14943765f, -0.19091892f, 0.18464565f, -0.18773074f, 
    -0.19046004f, 0.13548417f, 0.30625942f, 0.45092121f, -0.33917817f, -0.53427255f, -0.52567941f, -0.15218100f, 
    0.37476286f, 0.44928238f, 0.07647937f, -0.21865970f, -0.19103630f, 0.62434089f, -0.14876629f, -0.03018979f, 
    0.18064655f, -0.17139938f, -0.23390761f, -0.26049602f, 0.43961298f, -0.00703727f, -0.11145704f, -0.20716687f, 
    0.14960365f, 0.11665733f, 0.71372753f, -0.47653860f, -0.03326588f, 0.28541863f, -0.23259692f, -0.05413663f, 
    -0.09002753f, 0.05754553f, 0.21135700f, -0.04202360f, 0.15701382f, 0.12645425f, -0.08791657f, -0.39441243f, 
    -0.03319227f, -0.22235282f, 0.16232724f, -0.01966043f, 0.11554586f, 0.01030204f, 0.13770947f, -0.23687725f, 
    0.07188248f, -0.02943573f, -0.29986483f, 0.18181612f, 0.43202871f, 0.11230087f, 0.15458769f, -0.05257144f, 
    0.03236227f, -0.02815757f, 0.33783668f, -0.19432931f, -0.00436456f, 0.07201950f, -0.01491703f, 0.20892307f, 
    -0.31447500f, -0.17895862f, 0.06565271f, 0.12028767f, -0.06365302f, 0.15039583f, -0.25810978f, 0.06060267f, 
    -0.08822342f, -0.09940293f, -0.11925091f, -0.39932260f, -0.01873314f, -0.38815469f, -0.34837458f, -0.09882692f, 
    -0.09304871f, -0.08663837f, -0.16015159f, -0.29622862f, -0.29489529f, -0.05611762f, -0.02982737f, -0.20108891f, 
    -0.06747683f, -0.24522822f, -0.08799068f, -0.05703001f, 0.21825854f, 0.07250164f, -0.18317743f, -0.14804995f, 
    -0.27991104f, 0.00625104f, -0.18395048f, -0.23617457f, -0.40512523f, -0.25727370f, 0.21843942f, -0.22931452f, 
    0.15482366f, 0.07727436f, 0.08696277f, -0.08631013f, 0.15292084f, -0.10273174f, -0.07752089f, 0.35121822f, 
    0.05025692f, -0.26553753f, -0.17158246f, 0.14959429f, 0.07207749f, 0.03230331f, -0.36736730f, -0.17160051f, 
    0.10383163f, 0.13991202f, -0.04253652f, 0.14343086f, 0.11479592f, 0.13376144f, 0.37887299f, -0.16546200f, 
    0.11362582f, -0.13082041f, -0.08343935f, 0.37105030f, -0.26183540f, 0.11083649f, 0.30405280f, -0.13610831f, 
    0.15470017f, -0.04493436f, 0.05484745f, -0.04060011f, -0.21374217f, -0.20865446f, 0.12077224f, -0.18140252f, 
    -0.23265049f, 0.25456727f, 0.34128684f, 0.28531903f, 0.27355111f, -0.36588466f, -0.15088132f, -0.10193156f, 
    -0.38902938f, -0.02100927f, 0.16457446f, -0.27148512f, 0.40911782f, -0.38075647f, -0.45927358f, -0.29089776f, 
    -0.17296645f, -0.05826196f, -0.13730104f, -0.32574040f, 0.12598172f, -0.34563398f, -0.05526898f, 0.11489461f, 
    0.06321242f, 0.23973934f, 0.02014976f, 0.07201920f, -0.21998131f, -0.20613973f, -0.11255194f, 0.07689786f, 
    -0.15120073f, 0.30473396f, 0.40903503f, 0.47098604f, 0.08322321f, -0.48596528f, -0.60732734f, 0.00094570f, 
    0.31323951f, -0.09711819f, 0.15136261f, -0.21677606f, -0.08809982f, -0.02636289f, -0.25533101f, 0.07896885f, 
    0.10688146f, 0.20630153f, -0.21939783f, 0.01419634f, 0.04609986f, -0.12212709f, 0.01174672f, 0.18354703f, 
    0.01598772f, 0.29639053f, -0.16798250f, 0.28120431f, 0.15196940f, 0.01812281f, 0.10101432f, -0.16216452f, 
    0.31828281f, 0.25146297f, 0.09174684f, -0.07933813f, 0.17498533f, -0.28105229f, 0.24660313f, 0.17879488f, 
    -0.08856876f, -0.06957976f, -0.14301169f, -0.12534316f, -0.08941407f, 0.11840440f, -0.02257288f, -0.23011817f, 
    -0.11485917f, 0.14057638f, 0.88443547f, 0.38039041f, -0.46483374f, -0.50752771f, -0.65713346f, 0.34459135f, 
    -0.12388843f, 0.17626707f, 0.02967409f, 0.19199294f, 0.14269011f, 0.18475573f, 0.14708784f, -0.06929861f, 
    -0.08391766f, -0.14977281f, -0.15064524f, 0.19877152f, 0.00895163f, -0.21425952f, 0.24813361f, -0.08944940f, 
    -0.08719426f, 0.02001259f, -0.20370549f, 0.35659796f, 0.02849148f, -0.18326136f, -0.03092219f, 0.17746258f, 
    0.11116549f, 0.08258022f, 0.01668698f, -0.00536398f, 0.07294413f, 0.15447845f, -0.25976965f, 0.05574503f, 
    0.09145079f, 0.33875751f, -0.03818788f, 0.14753836f, -0.38907313f, -0.18549220f, -0.03255530f, 0.13468303f, 
    -0.28053302f, 0.26584473f, 0.20550570f, 0.08915555f, -0.39816764f, -0.35046783f, -0.39625695f, -0.13782637f, 
    -0.14310148f, 0.51066267f, 0.26932815f, -0.15811293f, 0.10212457f, -0.17890918f, 0.07270351f, 0.22735089f, 
    0.04359002f, 0.01687074f, 0.01075653f, -0.28223410f, -0.17864816f, 0.03752635f, -0.16722775f, -0.30527365f, 
    0.41670004f, 0.32248646f, 0.13162267f, -0.11879680f, 0.07993294f, 0.21487923f, 0.49774092f, 0.39175865f, 
    0.06435261f, -0.07277117f, -0.28826082f, 0.18038532f, -0.24749018f, -0.22007284f, -0.15530638f, -0.05263269f, 
    0.11354249f, -0.10096738f, 0.11306250f, -0.05132511f, 0.04088327f, -0.10761904f, -0.10547245f, 0.21406057f, 
    -0.01285626f, 0.05843283f, -0.21680625f, 0.00653400f, 0.05817778f, 0.28077343f, 0.04679298f, 0.35096115f, 
    0.10962744f, 0.09661682f, 0.35408062f, -0.41446206f, -0.27045330f, 0.23960193f, 0.31984597f, 0.10216717f, 
    -0.26960489f, 0.03650171f, 0.15203507f, 0.12900695f, -0.21924679f, -0.03972667f, 0.04848704f, 0.04837874f, 
    0.03432249f, -0.24499972f, -0.08286388f, -0.09760898f, 0.16689289f, 0.26488110f, -0.02583151f, -0.22931328f, 
    -0.63570935f, -0.05475219f, 0.10812860f, 0.46803683f, 0.18713936f, 0.27719060f, 0.17707807f, -0.21106920f, 
    -0.26768962f, 0.32737401f, -0.35795161f, 0.29029626f, -0.19947742f, 0.26407287f, -0.03456566f, 0.09538823f, 
    0.02633083f, -0.05338772f, -0.40479386f, 0.06417569f, 0.10504191f, 0.15699743f, -0.12120974f, 0.12900820f, 
    0.00105677f, -0.28832373f, -0.40910116f, -0.16064434f, -0.36196882f, -0.40018320f, -0.20734049f, -0.27658620f, 
    -0.18841271f, -0.24419743f, 0.04137440f, 0.06343376f, 0.15051721f, 0.05497647f, 0.09596959f, -0.09798529f, 
    -0.08766832f, -0.21926962f, -0.16192016f, -0.30434468f, -0.22394073f, -0.02558001f, 0.17405216f, 0.02201181f, 
    -0.50345898f, 0.41686219f, -0.26587921f, -0.43480155f, -0.02693290f, -0.76799089f, 0.69786143f, -0.00124360f, 
    0.25472718f, 0.08165040f, -0.12570597f, 0.22759509f, 0.15222530f, 0.25749397f, -0.27940157f, -0.12680300f, 
    -0.25103292f, -0.12843399f, 0.24861786f, -0.20863572f, 0.01016197f, 0.03957677f, -0.08502509f, -0.07104555f, 
    0.23594147f, 0.29491523f, -0.79455823f, -0.36109689f, -0.65617514f, 0.05061755f, 0.08077499f, -0.26920095f, 
    -0.16577247f, 0.38265008f, 0.48688781f, 0.43923852f, 0.36956778f, 0.17215951f, 0.20787631f, 0.21379215f, 
    -0.02920049f, 0.20250964f, 0.02108560f, 0.06088062f, -0.18763444f, -0.20630760f, 0.02421020f, -0.06636190f, 
    0.27234149f, -0.14150974f, -0.07200792f, -0.62781870f, 0.50014621f, 0.42240280f, -0.02721724f, -0.30256465f, 
    -0.35693997f, 0.26976466f, 0.32688174f, 0.13990043f, -0.02262110f, -0.33390397f, 0.40806141f, 0.02512988f, 
    -0.27974260f, -0.26431328f, 0.07451343f, -0.33172980f, -0.36501887f, -0.36347157f, -0.18096676f, 0.14041036f, 
    0.21134594f, 0.12192308f, -0.17061710f, 0.08840373f, 0.43110552f, 0.48564678f, 0.41728851f, 0.34672794f, 
    -0.52533591f, -0.33279505f, -0.16112518f, -0.00289447f, -0.40802681f, -0.38610646f, -0.17680286f, -0.13314103f, 
    0.14035505f, 0.08034657f, 0.14564924f, -0.02075485f, 0.46855670f, -0.01588879f, -0.35453311f, 0.07513617f, 
    -0.21087094f, 0.00959647f, -0.07767765f, 0.17614816f, -0.12747599f, -0.23419297f, -0.06059819f, -0.20050906f, 
    -0.30297995f, -0.18034348f, 0.06798746f, -0.12071828f, 0.32662055f, -0.28630066f, 0.47017893f, -0.11746331f, 
    -0.03526307f, -0.22860560f, -0.06305519f, 0.16781053f, 0.12005990f, -0.15719295f, 0.13163313f, 0.11483452f, 
    -0.35896364f, 0.18880826f, -0.14323227f, 0.12231285f, -0.00263540f, 0.24583399f, -0.40448800f, -0.06737224f, 
    -0.22289734f, 0.25696695f, -0.23660402f, 0.21098019f, -0.10303091f, -0.15192886f, 0.53514218f, -0.40514442f, 
    0.07458761f, -0.08259987f, 0.05548568f, -0.00842202f, 0.18820314f, 0.11769544f, 0.15706988f, 0.13598396f, 
    0.02906992f, 0.17351599f, 0.08437201f, 0.19148135f, 0.15509908f, -0.16410773f, -0.30630365f, -0.72298849f, 
    -0.65562230f, -0.02060722f, 0.56530094f, 0.61033708f, 0.29370606f, 0.56716138f, -0.23776689f, -0.17144965f, 
    -0.58734554f, -0.41230205f, 0.16652775f, 0.04050503f, -0.17723604f, -0.40806809f, 0.22343725f, -0.24404910f, 
    -0.16318320f, 0.24445537f, 0.05243258f, 0.24649423f, 0.03279218f, -0.32420340f, -0.23491602f, -0.00359986f, 
    0.64294434f, 0.11126827f, -0.06721872f, -0.37291104f, -0.30118829f, -0.23474373f, -0.08230199f, -0.16977559f, 
    0.13525251f, 0.09239461f, 0.21837400f, 0.05094801f, 0.20929910f, -0.26836985f, 0.05860943f, 0.00527036f, 
    0.06218831f, 0.27199516f, -0.07156014f, 0.01287179f, 0.19654950f, 0.18093328f, -0.22408284f, 0.01246779f, 
    0.03205050f, 0.03873010f, 0.54928929f, -0.50180733f, -0.51825321f, 0.28614208f, -0.47509062f, -0.12162460f, 
    0.52766401f, -0.02209416f, 0.16630836f, -0.21713658f, -0.23586974f, 0.61071849f, -0.30735174f, -0.06794671f, 
    0.21400833f, -0.07305852f, -0.24504676f, 0.09400018f, 0.13568123f, -0.02903280f, 0.14316261f, -0.28640586f, 
    0.03601060f, -0.09416522f, 0.09965118f, -0.23630704f, -0.01310034f, -0.22797680f, -0.27206919f, -0.30228561f, 
    -0.58699644f, -0.25684932f, -0.15402161f, -0.57657808f, 0.17098975f, 0.33901432f, -0.23577906f, -0.03418522f, 
    0.27659655f, 0.17842731f, 0.11285116f, 0.21373372f, -0.19623393f, 0.26207253f, -0.16851805f, -0.03088981f, 
    0.01361811f, -0.05242858f, -0.08453837f, 0.40895957f, 0.42286214f, 0.21985050f, -0.21892498f, -0.02606973f, 
    0.01632369f, 0.11351620f, -0.05629678f, 0.03731747f, 0.04121743f, 0.13028161f, -0.05056748f, 0.15913633f, 
    0.14885616f, 0.01128939f, 0.11254323f, 0.15440272f, -0.38256145f, -0.02946146f, -0.02214317f, -0.13400927f, 
    0.23951003f, 0.01732206f, 0.09529785f, 0.08492216f, 0.59947360f, -0.50880116f, -0.75857794f, -0.53483182f, 
    0.25596797f, 0.28118330f, -0.25392973f, 0.26348338f, 0.14007679f, -0.23123676f, -0.27055955f, 0.11854748f, 
    0.33137667f, 0.14135234f, -0.07530143f, 0.23290806f, 0.04483666f, 0.11288390f, -0.19865210f, -0.16248381f, 
    -0.13352413f, -0.24859042f, 0.09375879f, 0.15776505f, -0.11702938f, 0.07750447f, -0.41911322f, 0.22201636f, 
    -0.17026460f, -0.01504484f, 0.00928306f, 0.14712845f, 0.06198026f, -0.32743913f, 0.25201607f, 0.06636035f, 
    0.22505060f, 0.00172279f, -0.36188218f, 0.09396017f, -0.27163985f, 0.23744464f, -0.32365632f, 0.10045727f, 
    -0.10977784f, 0.27081212f, 0.11558899f, -0.07396314f, 0.12933227f, 0.15376151f, -0.28325537f, -0.67212474f, 
    -0.53479594f, -0.08280779f, -0.07713258f, 0.29971671f, 0.19969873f, -0.19254445f, -0.10984794f, 0.55345494f, 
    -0.21008810f, -0.40499172f, -0.37864193f, 0.07788453f, 0.47759360f, -0.24976760f, -0.10188768f, -0.21902986f, 
    -0.18762922f, -0.32384893f, -0.04813129f, -0.19377981f, -0.02570688f, 0.24424116f, -0.31438816f, -0.02610682f, 
    -0.37359419f, -0.45458210f, -0.22123733f, -0.23171383f, -0.06842973f, 0.61447561f, 0.38311741f, -0.14787792f, 
    -0.10680313f, -0.10311498f, -0.14893429f, -0.23001647f, -0.22265139f, -0.03605773f, -0.15769407f, 0.13608323f, 
    0.19880106f, -0.16717039f, -0.02595835f, 0.00439757f, 0.15491427f, 0.08386306f, 0.34133136f, 0.09727610f, 
    -0.37302247f, -0.21549802f, -0.11171102f, 0.46411386f, -0.45532969f, 0.05329335f, 0.28420028f, 0.29406887f, 
    -0.08863842f, -0.08045118f, 0.02062839f, -0.01817534f, -0.12480292f, 0.45010206f, -0.24360491f, 0.00662485f, 
    0.08125306f, -0.11924163f, -0.04226029f, 0.18264437f, -0.13433547f, -0.25641927f, 0.25158587f, 0.22593579f, 
    -0.06084831f, 0.23228140f, -0.49045384f, -0.23038998f, -0.35089907f, -0.48550579f, 0.18544270f, 0.13285626f, 
    0.18677700f, -0.04938120f, -0.36065155f, -0.12129035f, -0.08576488f, -0.10925991f, 0.45245764f, 0.16904818f, 
    -0.17588687f, -0.41065341f, -0.01621271f, 0.02785425f, 0.28191596f, 0.08674759f, -0.29010320f, 0.21577419f, 
    -0.21264279f, -0.31611410f, -0.37159297f, -0.06183408f, -0.39129633f, -0.25396597f, -0.15060318f, 0.13181168f, 
    -0.08304926f, 0.27855077f, -0.15245533f, -0.15847708f, 0.39270285f, 0.46758246f, 0.20299099f, 0.21775921f, 
    -0.23899098f, -0.17081365f, -0.17813420f, 0.02601022f, 0.06727729f, 0.02711268f, 0.00599259f, -0.18281752f, 
    -0.12573728f, -0.17197192f, -0.07349747f, 0.85155398f, -0.57509947f, -0.08871868f, 0.15588878f, -0.06108730f, 
    0.45713034f, -0.20938191f, -0.12819168f, 0.07359427f, 0.41793635f, -0.16466385f, 0.30908635f, -0.33390030f, 
    -0.07171813f, 0.36780879f, -0.08986560f, -0.15133038f, 0.19302563f, -0.26407415f, 0.15876700f, 0.01539771f, 
    0.09385946f, 0.15698990f, -0.19930838f, -0.02390470f, 0.20389242f, 0.23730236f, 0.07021823f, 0.19578117f, 
    0.16921930f, -0.02575553f, -0.05541155f, -0.15567422f, 0.17370877f, -0.10974442f, -0.24187434f, -0.20017081f, 
    -0.03748557f, 0.08669557f, 0.06185897f, -0.01018611f, -0.07918456f, -0.18501888f, 0.25373876f, -0.06059914f, 
    -0.38781017f, -0.15271303f, -0.28697881f, -0.45318183f, -0.43975830f, 0.10857873f, -0.12238728f, -0.26397344f, 
    -0.29785746f, 0.05807532f, -0.53320968f, -0.13233422f, -0.35682976f, -0.31797189f, -0.47923434f, 0.08154088f, 
    -0.09157829f, 0.17820437f, 0.42266852f, -0.00698109f, -0.02631303f, -0.29388502f, -0.00620128f, -0.26393896f, 
    -0.19304876f, 0.05043771f, 0.34758404f, -0.13647054f, 0.18674152f, 0.18828949f, 0.33140257f, 0.17257889f, 
    -0.08899437f, -0.20872924f, 0.10964273f, 0.17224117f, 0.32464969f, 0.08831531f, -0.02334351f, -0.19472273f, 
    0.18023778f, 0.25703052f, 0.05100606f, -0.04348986f, -0.30374524f, -0.24280347f, 0.13853185f, -0.21429045f, 
    0.03496898f, 0.18065387f, -0.08789086f, 0.21362427f, 0.13049619f, -0.26287872f, 0.09106761f, 0.51965970f, 
    -0.27595860f, -0.31547201f, 0.12163927f, -0.20301978f, 0.03192991f, 0.21449742f, -0.08056197f, -0.04311455f, 
    0.05627333f, -0.21819562f, 0.22373670f, -0.09534045f, 0.01494645f, -0.00829299f, -0.26982370f, -0.11886697f, 
    0.07592420f, 0.01988987f, 0.08912214f, 0.13053219f, -0.01149982f, -0.03639054f, 0.06989595f, 0.20934662f, 
    0.39875391f, -0.25213623f, -0.05687284f, 0.30324391f, -0.23134477f, 0.47703972f, -0.07319064f, 0.06569529f, 
    0.22590250f, 0.36058724f, -0.17379692f, 0.19643195f, -0.08568548f, -0.15881245f, -0.26090685f, -0.25695056f, 
    -0.14164865f, -0.01966216f, -0.14245756f, 0.28874987f, -0.08881421f, -0.15643869f, -0.02969479f, 0.14347014f, 
    0.00548543f, -0.06367996f, -0.40380648f, -0.32831517f, -0.31801790f, -0.45823351f, 0.22642259f, 0.72544688f, 
    -0.00649594f, -0.27984947f, 0.06052645f, -0.00938663f, 0.37139404f, -0.34896508f, -0.34313408f, -0.17125222f, 
    0.17395410f, 0.19248797f, 0.30473581f, 0.06879657f, -0.14939760f, -0.11118977f, -0.21179739f, -0.14496328f, 
    0.07422023f, 0.25696737f, 0.44361389f, 0.09460696f, 0.09866383f, -0.20327266f, 0.11210310f, 0.06171514f, 
    -0.10859617f, 0.11317185f, 0.05757134f, 0.15242486f, -0.12719034f, -0.17185727f, 0.18910928f, -0.01431399f, 
    0.00879359f, 0.37368003f, 0.12029147f, -0.21211152f, -0.21668611f, -0.37654421f, -0.09909008f, 0.08172304f, 
    -0.11051299f, -0.04826699f, -0.26985452f, 0.40243277f, 0.75948668f, -0.06599329f, -0.35516527f, -0.04479316f, 
    -0.08571495f, -0.22217853f, -0.05429563f, -0.48761040f, -0.42141590f, 0.11153451f, -0.11305880f, 0.30697942f, 
    0.04231191f, 0.04548562f, -0.07388789f, 0.26228425f, 0.09189400f, -0.25519261f, -0.02459291f, -0.25808531f, 
    -0.02722369f, -0.12596749f, -0.26410905f, -0.42125085f, -0.21362838f, -0.04046105f, 0.34090707f, -0.23775779f, 
    0.00410931f, -0.29919651f, -0.31902686f, -0.02397693f, -0.04227846f, 0.19330698f, 0.12605341f, 0.33299616f, 
    0.47754925f, -0.29386139f, -0.27605957f, -0.17693441f, 0.26892519f, -0.27900791f, -0.25650424f, 0.01119378f, 
    0.28685755f, 0.13735089f, -0.16380109f, 0.07023343f, 0.11041621f, 0.81372976f, 0.54566586f, -0.01228986f, 
    -0.41475293f, -0.02763464f, -0.11266316f, 0.14939308f, -0.20611677f, -0.53173685f, -0.59445363f, 0.09826913f, 
    0.26641420f, -0.01070407f, -0.08590163f, 0.14956285f, 0.28411087f, -0.25566727f, 0.15607817f, -0.19157860f, 
    0.13585714f, 0.09201441f, -0.25648159f, 0.13000554f, 0.17438917f, -0.04577008f, 0.34828258f, -0.99467194f, 
    0.36105669f, -0.09505674f, 0.40946883f, -0.57178485f, -0.36311680f, 0.88930565f, -0.40914208f, -0.19756706f, 
    0.08932660f, -0.05193417f, -0.05552831f, -0.07791680f, 0.03083078f, 0.02518054f, 0.00668860f, -0.04871791f, 
    0.03021770f, -0.04121809f, -0.10367166f, 0.01219866f, -0.01634065f, 0.08739898f, -0.17763369f, 0.10045289f, 
    -0.22888866f, 0.06721872f, 0.10857838f, -0.24147584f, -0.17451175f, -0.08746420f, -0.06716748f, -0.37788078f, 
    -0.00173415f, 0.06136283f, -0.15235469f, -0.02889316f, -0.26656613f, 0.21244238f, -0.15356512f, 0.07012103f, 
    0.17458998f, -0.03924803f, -0.00344540f, 0.06082170f, -0.15358946f, 0.05794943f, 0.32525849f, -0.04068620f, 
    -0.62059641f, -0.06523844f, -0.26569605f, -0.31981185f, -0.22333167f, -0.00413629f, 0.20995231f, 0.30055135f, 
    0.56331378f, 0.55680597f, -0.19292635f, -0.21312200f, 0.25441870f, 0.03867529f, 0.23193903f, 0.00855916f, 
    -0.04137324f, -0.20173126f, -0.09580748f, 0.09364455f, 0.07888061f, -0.22224414f, 0.49274752f, -0.04627521f, 
    -0.15291020f, -0.48683676f, 0.05799127f, 0.30231872f, 0.41564354f, 0.41837993f, 0.20813785f, 0.04475481f, 
    -0.07013389f, 0.25512451f, -0.11138532f, -0.01305847f, 0.18465400f, 0.08998118f, -0.20779487f, -0.09017674f, 
    0.10964272f, -0.18923762f, 0.09268042f, 0.12105714f, -0.19801594f, -0.20402436f, -0.33243093f, 0.08979498f, 
    0.03925686f, -0.31490836f, -0.08910616f, 0.16470917f, -0.52168560f, -0.29947624f, 0.04954389f, -0.20201673f, 
    -0.07942646f, 0.18675992f, -0.37835309f, -0.56496185f, 0.07971464f, 0.00165957f, 0.07891282f, 0.09627537f, 
    -0.18227996f, -0.07040381f, -0.34099886f, 0.25041077f, -0.11515221f, -0.24469933f, -0.09123465f, -0.10813269f, 
    -0.35576057f, 0.21674287f, 0.51226658f, -0.42014965f, -0.19866078f, -0.55983496f, -0.25120941f, -0.15216930f, 
    0.51548481f, 0.21042502f, 0.08206493f, 0.12776215f, 0.33875147f, -0.08356047f, 0.29522282f, 0.08675948f, 
    0.34355581f, 0.12950200f, -0.04146701f, -0.21035708f, -0.14093404f, 0.21306430f, -0.12173988f, 0.00303463f, 
    0.00030564f, -0.00896880f, -0.11957880f, -0.16762243f, 0.21535337f, -0.48769343f, 0.10106570f, 0.53154254f, 
    -0.10534925f, -0.40437755f, -0.23253877f, -0.04523748f, 0.21815713f, 0.29385412f, 0.37283117f, -0.34153396f, 
    0.04633619f, -0.07599862f, 0.23134638f, -0.32472134f, 0.04459269f, 0.22538184f, 0.12426297f, -0.29490483f, 
    0.27565306f, 0.12235571f, -0.12495530f, 0.00401489f, -0.03895638f, -0.97529227f, 0.70445418f, 0.69518995f, 
    -0.70049614f, -0.08496430f, -0.17531013f, -0.04664711f, 0.17243768f, 0.51143044f, -0.16122113f, -0.43166846f, 
    -0.30369595f, -0.11432359f, 0.27920377f, 0.23780300f, 0.37291676f, 0.17045933f, 0.02417782f, -0.07359321f, 
    -0.30825889f, -0.16119261f, 0.06002861f, -0.20258023f, -0.13911223f, -0.31254089f, -0.57415086f, 0.30005899f, 
    -0.08314979f, -0.51437634f, -0.26440862f, -0.12239603f, 0.21267967f, 0.19180222f, 0.12078093f, 0.34470600f, 
    -0.09695315f, -0.09115952f, -0.21523611f, -0.41963568f, 0.11601018f, 0.06767239f, 0.06751812f, 0.04334768f, 
    0.15249275f, -0.07961816f, -0.08979487f, -0.16173647f, -0.33750725f, -0.25515839f, -0.17554325f, -0.69317365f, 
    -0.40564331f, -0.17608905f, 0.01177183f, 0.50726700f, 0.43166465f, 0.07918132f, -0.85950595f, -0.84293127f, 
    -0.20749085f, -0.26868954f, -0.05784404f, -0.06086948f, -0.39337492f, -0.12916377f, 0.02335960f, -0.43165165f, 
    -0.27028880f, -0.24165420f, -0.36359358f, 0.07086492f, 0.02837651f, -0.32815924f, 0.18697914f, -0.20488429f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.35524043f, -0.25679684f, 0.05497525f, 0.09974404f, -0.28341278f, -0.06207297f, -0.24124849f, 0.16050155f, 
    0.08964502f, 0.15128890f, 0.12147267f, 0.13662644f, -0.07399603f, 0.16123769f, -0.16889775f, -0.21774039f, 
    0.12067571f, 0.10382420f, 0.30670357f, -0.00850633f, -0.17210528f, -0.01235267f, 0.05568995f, -0.09693290f, 
    -0.04192652f, 0.12924975f, 0.02985726f, -0.03201662f, 0.12372445f, 0.17735147f, -0.03725694f, 0.29034942f, 
    -0.05878256f, 0.24542521f, -0.14600621f, -0.11737332f, 0.02979483f, 0.16110493f, -0.05781109f, -0.01322374f, 
    -0.25752389f, 0.17417122f, -0.20828858f, 0.06874741f, -0.15723230f, 0.00946752f, 0.01044823f, 0.12615135f, 
    -0.02237383f, -0.16754901f, 0.12014899f, -0.16179717f, -0.13963886f, 0.15348952f, -0.02762322f, 0.01231868f, 
    -0.00750279f, 0.01023449f, -0.18131743f, -0.26583660f, 0.30610651f, 0.19512849f, -0.04575970f, -0.24779990f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01824227f, -0.01286428f, 0.00979464f, -0.03805465f, -0.02382433f, -0.00605134f, 0.00895474f, -0.00887628f, 
    -0.01852276f, -0.00557010f, -0.00220748f, -0.02578788f, -0.00297788f, 0.02164099f, -0.01695727f, -0.01530888f, 
    -0.00156478f, -0.01732818f, -0.00919933f, -0.03178863f, -0.02807696f, -0.02304323f, 0.02835328f, -0.01764459f, 
    0.03307552f, -0.01889101f, -0.02561110f, -0.00225293f, -0.04076336f, -0.03125383f, -0.03813989f, -0.02405480f, 
    0.01279147f, 0.00288392f, -0.02587526f, -0.02207626f, 0.01136586f, -0.00606808f, 0.01907534f, -0.03051788f, 
    -0.03409252f, 0.01067002f, -0.02121677f, -0.04071041f, -0.02651772f, 0.03328356f, 0.03281349f, -0.02936447f, 
    -0.02186702f, -0.00873862f, 0.01374177f, -0.01665430f, -0.01088182f, -0.02956451f, -0.03865749f, 0.02705170f, 
    -0.02033029f, -0.01958913f, -0.00296168f, -0.01907361f, -0.01663590f, -0.01422923f, -0.02211705f, -0.01743669f, 
    -0.03423104f, -0.03091543f, 0.01801151f, -0.02703258f, -0.02258920f, 0.01446359f, -0.00511697f, -0.00602478f, 
    0.01061079f, 0.01004967f, -0.03580732f, 0.00766505f, 0.01404958f, 0.02668763f, -0.02372636f, -0.01447980f, 
    0.02306308f, 0.03877680f, -0.00882627f, 0.03365758f, -0.03027768f, 0.00859895f, 0.02130375f, -0.00596571f, 
    0.03645597f, 0.00998075f, 0.01700567f, -0.00404676f, 0.00745844f, -0.01441577f, -0.02502506f, -0.02149404f, 
    -0.03361884f, 0.01861089f, -0.00089264f, -0.01984808f, -0.01839110f, 0.03665603f, 0.02781481f, -0.03560121f, 
    -0.00405979f, -0.03302784f, 0.00376571f, 0.02793220f, 0.00475453f, 0.03112562f, -0.03090170f, 0.03259860f, 
    0.00047703f, -0.02594057f, 0.01699939f, 0.02084276f, 0.02266014f, 0.01919997f, -0.00908140f, -0.01463282f, 
    0.00851503f, 0.01994236f, 0.00566182f, 0.00606385f, 0.03136019f, 0.01740444f, -0.03302304f, -0.01053035f, 
    -0.02151743f, 0.01429880f, 0.03356215f, 0.01561165f, -0.00480943f, -0.03405560f, -0.00295254f, -0.01695995f, 
    0.01297736f, 0.02088100f, -0.01481616f, -0.02653416f, -0.00547590f, -0.03974614f, 0.02800970f, 0.01171124f, 
    -0.02019672f, -0.04420920f, -0.03773145f, -0.01361635f, 0.01058717f, 0.00414764f, -0.01498401f, 0.01577745f, 
    0.00497979f, -0.02513956f, 0.01168318f, 0.00585748f, -0.00359114f, 0.00519855f, 0.01944545f, -0.01198466f, 
    -0.00801991f, -0.03546526f, 0.00402652f, 0.01960607f, 0.00182747f, -0.03271540f, 0.02648539f, -0.01235481f, 
    0.00326904f, 0.01996513f, -0.02440446f, -0.03626400f, -0.01669498f, -0.02671045f, -0.03467016f, 0.02071147f, 
    -0.02670654f, -0.03356937f, 0.00646440f, -0.00763934f, -0.04931509f, -0.03830928f, -0.03327988f, -0.00909511f, 
    0.01891573f, 0.00675822f, 0.02078263f, 0.01563702f, -0.02367534f, -0.02870600f, 0.01424767f, -0.04141704f, 
    0.00628685f, 0.02507813f, 0.02524274f, 0.03077148f, 0.00718095f, 0.00940997f, 0.01538033f, 0.02353992f, 
    0.00466036f, 0.01697011f, -0.00033296f, -0.02045648f, 0.03242028f, 0.03490913f, -0.01379314f, -0.03258234f, 
    0.00816414f, -0.04391116f, -0.00217375f, 0.00551196f, -0.02331376f, -0.04015411f, -0.02564434f, -0.00587555f, 
    0.04143581f, 0.00165148f, 0.01363569f, 0.00295530f, 0.03477238f, -0.03468748f, -0.00443142f, -0.01139521f, 
    0.00944777f, 0.02743865f, 0.02294119f, -0.02916803f, 0.03566254f, 0.00531516f, -0.00660666f, 0.01104578f, 
    0.01695778f, -0.03091693f, -0.01177084f, 0.02618571f, -0.00927742f, -0.03817861f, -0.01718476f, -0.02050188f, 
    -0.03384679f, 0.01964939f, -0.00305083f, -0.02249892f, 0.01787708f, 0.00902975f, 0.00822575f, -0.02993379f, 
    0.00216904f, -0.02539906f, -0.04172097f, -0.01511233f, 0.00358617f, 0.01582245f, 0.00427537f, -0.02806694f, 
    0.01191791f, -0.02705809f, -0.03065869f, -0.00793838f, -0.00176194f, 0.01247302f, 0.02776818f, -0.02208197f, 
    0.01515987f, 0.03330035f, -0.02536311f, 0.00783893f, -0.00529928f, -0.02666211f, 0.01007741f, -0.00039671f, 
    -0.00205381f, 0.00873171f, 0.00811690f, -0.00558526f, 0.00171343f, 0.03336611f, 0.00566586f, -0.00901148f, 
    0.01492653f, -0.01903199f, -0.02356833f, 0.01226996f, 0.03414002f, 0.01311835f, -0.04082837f, -0.01370113f, 
    -0.04710804f, -0.00977536f, -0.04248082f, -0.02225168f, -0.03088054f, 0.03211401f, 0.02218657f, -0.01064561f, 
    -0.03403603f, -0.03055195f, -0.03934855f, -0.02243010f, -0.01046014f, 0.02405663f, -0.01886792f, 0.02247156f, 
    0.03375984f, 0.00329713f, -0.01277225f, -0.00872357f, 0.02823460f, -0.03426412f, -0.04577488f, -0.02398434f, 
    0.02487200f, -0.00620279f, -0.03332546f, -0.04523975f, 0.01317894f, 0.00845122f, -0.00435835f, 0.00606216f, 
    -0.02334719f, 0.00395462f, -0.03852390f, 0.02024982f, 0.00186920f, -0.01301197f, 0.03163246f, -0.01653099f, 
    -0.03919410f, -0.04336727f, -0.00647995f, -0.01001226f, -0.01885941f, 0.00898007f, 0.01537432f, 0.04075710f, 
    0.01703411f, 0.01304428f, -0.01363966f, -0.02700670f, -0.00742708f, -0.01450380f, -0.02437954f, -0.00255049f, 
    0.01893113f, -0.03676216f, 0.02994854f, -0.02885099f, 0.00619099f, -0.04390522f, -0.04133858f, -0.02788154f, 
    0.02307608f, 0.00348765f, 0.00071257f, -0.02775938f, -0.03146035f, 0.02304487f, -0.00690907f, -0.00413343f, 
    -0.02480788f, 0.02325303f, 0.00336498f, 0.00433303f, -0.02532784f, 0.00624287f, 0.01083854f, 0.02572754f, 
    -0.00662557f, -0.02109011f, -0.02201910f, 0.01416999f, 0.03941932f, 0.02362715f, 0.02563238f, -0.03232974f, 
    -0.01459078f, -0.01191520f, -0.00782551f, 0.00309880f, 0.03006966f, 0.01379579f, 0.03197435f, -0.03561233f, 
    0.03077956f, -0.01691462f, -0.02830948f, -0.03308778f, 0.03662558f, 0.01061726f, 0.02656109f, 0.02890888f, 
    0.02193611f, -0.04516010f, -0.03556624f, 0.00480922f, -0.03288999f, -0.02787647f, 0.01694738f, 0.02797371f, 
    -0.00189311f, -0.03387944f, -0.02563306f, -0.02835757f, -0.01282968f, -0.01202983f, -0.01370134f, -0.03024454f, 
    0.01977913f, 0.02232107f, -0.00206963f, -0.03237688f, 0.01292278f, -0.00300034f, 0.00043104f, 0.00800203f, 
    -0.03517165f, 0.00440425f, 0.00640352f, -0.02652310f, 0.00460145f, -0.02266796f, 0.01964117f, -0.02834190f, 
    0.01683400f, -0.00490621f, 0.01020556f, -0.00018055f, -0.03812357f, -0.02198107f, -0.01440633f, -0.00466717f, 
    -0.01484325f, -0.01198207f, 0.01321588f, -0.01520733f, 0.02709938f, 0.01838882f, 0.00672319f, 0.03626863f, 
    -0.00106830f, 0.00716828f, -0.02860400f, -0.01058008f, -0.01542270f, -0.02337221f, -0.00705433f, 0.02561959f, 
    -0.03088200f, 0.01953957f, -0.00458868f, 0.02626075f, -0.03735930f, -0.01463608f, 0.01605026f, -0.02433115f, 
    0.00741311f, 0.01374886f, -0.00667816f, -0.02335385f, 0.02210359f, 0.01266313f, 0.01890137f, 0.03011562f, 
    -0.00028180f, 0.01303869f, 0.01965542f, 0.01782844f, 0.00322250f, -0.00097785f, -0.04845624f, 0.01908226f, 
    -0.01219556f, 0.00249358f, -0.03497407f, 0.00750990f, 0.00047154f, -0.01121877f, 0.01633611f, -0.02179794f, 
    -0.04223678f, 0.00050900f, -0.02799745f, 0.02562001f, -0.02920364f, -0.03254245f, 0.00439670f, 0.03255745f, 
    -0.02093220f, -0.03148482f, 0.01383749f, 0.01076332f, -0.00722878f, 0.02935237f, -0.03383710f, 0.02173184f, 
    -0.03414254f, -0.02317503f, -0.03662122f, 0.03069421f, -0.00600683f, -0.03616199f, 0.00494639f, -0.02493872f, 
    -0.00233195f, 0.02369036f, 0.00151203f, -0.03350303f, -0.01767407f, 0.02782813f, -0.00917784f, 0.01188301f, 
    -0.02243344f, -0.01783534f, -0.01199547f, -0.01024966f, -0.03329076f, 0.00199422f, 0.01570162f, -0.03770021f, 
    -0.02678625f, -0.03411832f, 0.02088206f, -0.00609112f, -0.01251674f, -0.00971932f, 0.02401386f, -0.02779981f, 
    -0.02004844f, -0.02021647f, 0.01130030f, 0.02570789f, 0.00054000f, -0.03683248f, 0.00590471f, -0.01090700f, 
    0.00449559f, -0.00972689f, 0.01753886f, 0.02871828f, 0.00860502f, 0.01026679f, 0.01863836f, -0.00158076f, 
    0.02446508f, 0.01905757f, -0.00099809f, 0.01815557f, -0.03327517f, -0.01865427f, -0.02907177f, 0.00571218f, 
    -0.02287557f, 0.02933335f, 0.02470938f, 0.02962257f, -0.00715368f, 0.00208481f, 0.01471173f, 0.01838341f, 
    0.03013286f, -0.02876474f, -0.01958743f, -0.03503599f, -0.01469041f, 0.00738012f, 0.02330927f, -0.00960147f, 
    -0.02872452f, -0.03138802f, -0.00984815f, 0.02950497f, -0.01083588f, -0.02571760f, -0.01312704f, -0.03581235f, 
    -0.00137507f, -0.00058063f, -0.01008769f, -0.00371580f, -0.03925684f, 0.01657601f, -0.00962960f, 0.01699869f, 
    -0.00115730f, 0.01205492f, 0.02945893f, -0.01140936f, -0.03475589f, 0.01250879f, -0.00876659f, -0.03034205f, 
    -0.01847161f, -0.03837974f, 0.02797719f, -0.01969679f, 0.02087702f, -0.03281869f, -0.00840531f, 0.00731506f, 
    0.00540537f, -0.01213138f, 0.00438687f, -0.03872391f, 0.00029858f, -0.03895923f, 0.01077567f, 0.02271980f, 
    0.00656041f, -0.01776526f, 0.02801423f, 0.02873259f, 0.02317921f, 0.02253449f, 0.00248812f, 0.02060652f, 
    -0.02850112f, 0.00052826f, -0.02379528f, 0.02902086f, 0.02984570f, -0.01087554f, -0.02132516f, 0.00337386f, 
    -0.00030765f, -0.00073033f, -0.02726751f, 0.00888054f, -0.00550926f, 0.01345587f, 0.01864467f, -0.00956502f, 
    0.01273582f, -0.02115067f, -0.03509776f, -0.04139550f, 0.01239101f, -0.03899360f, 0.01537679f, -0.02881746f, 
    0.02434705f, 0.00996325f, -0.02060787f, 0.00942851f, 0.00220485f, -0.00907427f, -0.00859726f, -0.00386751f, 
    0.00398867f, -0.03904672f, -0.04200590f, -0.01410316f, -0.03071597f, 0.03142845f, 0.01111989f, -0.00897913f, 
    0.01911639f, -0.02682803f, 0.02817333f, -0.01512821f, -0.01521133f, -0.03673746f, 0.02042526f, 0.03221327f, 
    -0.01935592f, 0.02142478f, -0.01052721f, 0.02623529f, 0.01309179f, 0.01964157f, -0.03209572f, -0.01401846f, 
    0.03140008f, -0.02604658f, -0.02236476f, 0.00228943f, -0.03318935f, 0.02797018f, -0.02161988f, -0.02987325f, 
    0.02905786f, 0.03702519f, 0.00716525f, -0.02803008f, 0.02019126f, -0.01828894f, -0.00930775f, 0.01399363f, 
    0.01956678f, -0.03861523f, -0.00812361f, -0.00853631f, -0.02239972f, 0.00677774f, 0.01623448f, -0.03046895f, 
    0.01503270f, 0.01527367f, -0.04750401f, 0.01208002f, -0.00900392f, 0.00135132f, 0.03679643f, 0.00300766f, 
    0.01839435f, -0.02080930f, 0.01547849f, -0.01732509f, -0.02008291f, 0.02940200f, 0.01962429f, 0.02915080f, 
    0.00666661f, 0.01581377f, 0.01660729f, -0.02121344f, 0.03105042f, 0.03451682f, -0.02170499f, -0.00421808f, 
    -0.01833679f, -0.02387298f, 0.02287936f, 0.00419819f, -0.00876897f, -0.01076167f, -0.00568980f, -0.00230735f, 
    0.01343775f, 0.03110757f, 0.01459619f, -0.01143588f, -0.01572538f, 0.00833956f, -0.04131586f, -0.01866439f, 
    0.03014784f, -0.00599047f, 0.01287882f, -0.01643585f, -0.01948525f, -0.03764133f, 0.00833016f, 0.02882163f, 
    -0.02098829f, -0.00046132f, -0.00873067f, -0.00141022f, -0.01180760f, -0.02061032f, 0.02567022f, 0.02207316f, 
    -0.02115539f, -0.02749405f, 0.01153637f, -0.03493971f, -0.00441015f, -0.02987870f, 0.00594664f, 0.01204458f, 
    0.01701196f, 0.00781616f, 0.01402511f, -0.03878445f, -0.02569130f, 0.01176982f, 0.01859356f, 0.02743971f, 
    0.02083162f, 0.01490099f, 0.01509800f, -0.00800891f, -0.02956076f, 0.02284165f, 0.01720320f, -0.00780871f, 
    -0.01926537f, 0.00252973f, 0.00468668f, -0.01881508f, -0.02238041f, -0.01227049f, -0.01268414f, 0.01181100f, 
    -0.02334876f, -0.00834296f, 0.01570950f, -0.00226238f, 0.00697578f, -0.00826409f, 0.01486003f, -0.00207911f, 
    -0.00035458f, 0.01206028f, -0.02110608f, -0.02055283f, -0.01465954f, 0.00682091f, -0.02686245f, -0.00030047f, 
    -0.00347538f, 0.00356734f, 0.00075726f, -0.01083524f, -0.04014006f, -0.00074335f, -0.01963565f, -0.00952508f, 
    0.02530638f, -0.03915417f, 0.01251927f, 0.02766931f, 0.01679458f, 0.00625234f, -0.00571110f, 0.01293740f, 
    0.01552119f, -0.00862280f, -0.01069620f, -0.02884578f, 0.03097118f, -0.03424717f, 0.00506891f, -0.00249581f, 
    -0.02734588f, 0.01645723f, 0.02895291f, 0.01128976f, 0.00692078f, 0.02493461f, 0.01486097f, -0.01785659f, 
    0.00954793f, -0.02202496f, 0.02461157f, -0.00585706f, 0.00519824f, -0.03654642f, -0.02105281f, -0.03912952f, 
    0.00962447f, 0.00830907f, -0.02483154f, 0.02643078f, 0.01992986f, -0.04100170f, -0.01755439f, -0.00345481f, 
    0.01868127f, -0.01746484f, -0.02120600f, 0.00748856f, 0.02548741f, 0.00096939f, 0.02092115f, 0.00975809f, 
    -0.00627910f, -0.02318580f, -0.01055030f, -0.02699209f, -0.00200632f, 0.02214739f, 0.01938692f, -0.03315042f, 
    0.02058720f, 0.00057372f, -0.03844319f, -0.04051602f, -0.04290289f, -0.01652239f, -0.00271976f, -0.03545098f, 
    -0.00531386f, -0.02792526f, 0.00783821f, 0.01496463f, 0.02803314f, -0.03535076f, -0.03814119f, 0.01056260f, 
    -0.03748437f, -0.01843346f, 0.00940005f, -0.03817983f, -0.03480738f, 0.00882343f, 0.02848380f, -0.00890634f, 
    -0.02560428f, 0.02828356f, 0.01735596f, 0.02772051f, -0.00832576f, -0.03904685f, 0.02145775f, 0.00882259f, 
    0.02309422f, -0.01014708f, -0.00869344f, -0.04100846f, -0.03217361f, -0.01825107f, -0.00409002f, 0.02578775f, 
    -0.01226396f, 0.00595884f, 0.01018926f, -0.01109346f, 0.01725926f, 0.00788676f, -0.01066153f, -0.03480792f, 
    0.02169384f, 0.00838332f, 0.00100739f, -0.00643830f, 0.00978978f, -0.00767340f, 0.02752929f, 0.02102076f, 
    -0.00265733f, -0.03189163f, -0.01391101f, -0.00112948f, 0.02966731f, 0.01801302f, -0.04064186f, 0.00900862f, 
    -0.04198518f, -0.00038105f, 0.02373436f, 0.00075255f, -0.01858439f, -0.00663256f, 0.03217851f, -0.04241990f, 
    -0.00555970f, 0.00442492f, 0.01821952f, -0.00363407f, -0.02742776f, -0.02134451f, -0.01333078f, -0.02914381f, 
    0.00601388f, -0.04187812f, 0.00744595f, -0.03585261f, -0.00262284f, -0.00534456f, 0.02891870f, -0.01291872f, 
    -0.03475684f, 0.01055972f, 0.03361156f, -0.02400552f, 0.01386523f, -0.00645953f, 0.02951257f, 0.02524991f, 
    0.00816556f, -0.01574504f, -0.00526360f, -0.01314238f, 0.00944800f, 0.01749182f, -0.00571415f, 0.03407117f, 
    -0.01924647f, -0.04077935f, 0.01458715f, 0.00567142f, 0.03387305f, -0.02889641f, 0.01277430f, -0.02045374f, 
    0.01406580f, -0.01248246f, 0.02634396f, -0.03015289f, 0.00014022f, -0.01557382f, -0.01307747f, -0.02262483f, 
    0.02287197f, -0.01571413f, 0.01036740f, -0.01381736f, -0.01342409f, 0.02030041f, 0.01093623f, -0.01976963f, 
    -0.01451804f, 0.02757384f, -0.02480613f, 0.00339494f, 0.02046963f, 0.02434470f, 0.03385418f, -0.00843893f, 
    -0.02015185f, -0.01047447f, 0.00607523f, 0.01310482f, -0.02737716f, -0.02942821f, -0.03604747f, -0.00928960f, 
    0.02547791f, -0.00374648f, 0.01081331f, -0.00542435f, -0.03372971f, 0.02542460f, 0.00083682f, -0.03652526f, 
    -0.04114632f, 0.01064909f, 0.00808745f, 0.01685774f, 0.00123256f, -0.01699904f, 0.02146736f, -0.02119375f, 
    -0.02725299f, -0.01043595f, -0.03800247f, -0.00919963f, 0.00125569f, -0.01797960f, -0.03866515f, -0.00772830f, 
    0.00827951f, 0.02099558f, 0.01729866f, -0.01518341f, 0.02038531f, -0.03082354f, -0.00879079f, 0.01083681f, 
    0.01493229f, 0.00332679f, -0.02555716f, 0.01055699f, -0.04114079f, -0.02273785f, -0.02205684f, 0.01645796f, 
    -0.00906920f, 0.00193284f, -0.02014385f, -0.00779464f, 0.00315125f, -0.01393364f, -0.01689799f, -0.00814048f, 
    0.00464820f, 0.02979696f, 0.01458783f, 0.02432830f, -0.00433974f, -0.01108300f, -0.00323228f, 0.00671317f, 
    0.01018161f, -0.01817585f, 0.02953016f, -0.01747078f, 0.01647454f, -0.03982028f, -0.00741582f, -0.01068160f, 
    0.00733668f, -0.01334271f, -0.02059101f, -0.01411768f, -0.00466145f, 0.01393432f, 0.01472716f, 0.01282978f, 
    -0.01818880f, 0.02275966f, -0.03679075f, 0.01992508f, 0.01736042f, 0.02611775f, -0.01336995f, 0.00855734f, 
    -0.02518922f, 0.00348672f, -0.03040986f, -0.01464077f, -0.02639852f, -0.01186679f, -0.02623566f, -0.02591950f, 
    0.02234761f, -0.01509514f, -0.03483943f, -0.01703888f, -0.01966013f, -0.03616702f, 0.01643808f, -0.01936916f, 
    -0.04023062f, -0.01612213f, -0.03795383f, 0.00934252f, -0.01023061f, -0.02891775f, -0.04140989f, -0.02519122f, 
    -0.01964351f, -0.03841092f, 0.02060517f, -0.02084598f, -0.03679191f, -0.01773885f, 0.01370936f, -0.04182322f, 
    -0.00136822f, -0.01372128f, 0.01425767f, -0.02095854f, -0.01925635f, -0.03075812f, 0.01920674f, -0.02698185f, 
    -0.03164317f, 0.02285302f, 0.02406482f, 0.00001761f, -0.03936012f, 0.01041461f, 0.02345094f, -0.00310328f, 
    -0.03381436f, 0.00822004f, -0.00512593f, -0.00561817f, -0.02939925f, 0.00333873f, 0.01487042f, -0.00521639f, 
    0.00672334f, 0.02401848f, -0.02227918f, -0.02753469f, 0.00259658f, 0.01424314f, -0.02251815f, -0.00871075f, 
    0.02334684f, -0.00606748f, -0.00022757f, -0.02748173f, -0.00427042f, -0.01549462f, -0.02293504f, -0.02452100f, 
    0.02728551f, -0.03936118f, -0.00792452f, -0.00266144f, 0.01881207f, 0.01410540f, 0.00717953f, -0.01924182f, 
    0.01423752f, -0.03439045f, -0.03860988f, 0.00479608f, -0.03174876f, 0.00740396f, -0.02178700f, -0.02506812f, 
    -0.02744810f, 0.00806152f, 0.02365813f, -0.03354917f, -0.01189124f, 0.00188608f, 0.00369413f, -0.03039651f, 
    -0.00516846f, 0.01245925f, -0.04034963f, -0.00710684f, -0.02121441f, 0.01254507f, -0.04067669f, 0.02377451f, 
    0.03922253f, 0.02152427f, 0.02815887f, 0.02140262f, 0.02644477f, 0.01703217f, 0.00896213f, 0.00391902f, 
    0.00961003f, -0.00574457f, 0.01626049f, 0.01093368f, -0.00548115f, -0.00631884f, -0.01704750f, -0.01756343f, 
    -0.03298337f, -0.03756005f, -0.01769568f, 0.02692380f, 0.00077749f, -0.01130096f, 0.00116034f, 0.02558222f, 
    -0.02303039f, -0.02811576f, -0.00633016f, 0.02578877f, 0.01677655f, -0.00385475f, 0.02121836f, -0.02550422f, 
    -0.02978797f, 0.02036525f, 0.01716625f, 0.00444354f, -0.02573796f, -0.02914327f, -0.00764604f, -0.02503795f, 
    -0.00099689f, -0.01359035f, 0.02892657f, -0.03865614f, -0.00712935f, 0.00850962f, -0.02789366f, -0.00482412f, 
    0.02623207f, 0.02258671f, -0.02780117f, -0.01790119f, -0.03388355f, -0.01376392f, 0.01551004f, -0.01331993f, 
    -0.02838920f, 0.01156570f, -0.02919398f, 0.02567446f, -0.01744967f, 0.03258562f, -0.02729608f, -0.02939874f, 
    -0.03587270f, 0.03175694f, -0.00689877f, -0.02999715f, -0.00329484f, -0.01867936f, 0.01660389f, 0.02470021f, 
    -0.00726729f, 0.02128935f, 0.00410050f, 0.02240451f, 0.02545381f, -0.02768145f, -0.03126176f, 0.02475708f, 
    -0.02854794f, -0.02147809f, 0.01430062f, 0.02297140f, -0.02355196f, -0.03621221f, -0.01344003f, 0.01922927f, 
    -0.04088857f, -0.01110458f, 0.02867305f, 0.02964977f, -0.04019719f, -0.01033341f, 0.02453414f, -0.03636483f, 
    0.00611418f, -0.02355520f, 0.02763110f, -0.03185014f, -0.03363959f, -0.00792435f, -0.02148579f, 0.00703503f, 
    0.01116332f, 0.00871422f, -0.01621225f, 0.02415728f, -0.03399745f, -0.00319553f, 0.00429803f, -0.04050386f, 
    -0.00305911f, -0.01964509f, 0.01701370f, -0.03390409f, -0.00691344f, 0.00390248f, -0.02600719f, -0.02441323f, 
    -0.03993234f, -0.03787487f, -0.03172744f, -0.02562620f, -0.01909328f, -0.03172884f, -0.01035538f, 0.00118022f, 
    0.00295682f, -0.02983140f, -0.03744210f, 0.01526205f, 0.03388938f, -0.04184832f, -0.02638687f, 0.00084609f, 
    0.00557649f, -0.01565897f, -0.03505598f, -0.00338492f, 0.01214239f, -0.00313465f, -0.02755787f, -0.04148241f, 
    -0.00578598f, 0.00343264f, 0.00933569f, -0.01924811f, -0.00092743f, 0.01218552f, 0.01039486f, -0.03818580f, 
    0.00036291f, -0.01804537f, 0.00594224f, 0.03623100f, 0.00393240f, -0.02623410f, -0.03014547f, -0.01364392f, 
    -0.00803126f, 0.01776342f, 0.01781319f, -0.01982899f, -0.02102515f, 0.01514167f, -0.02121394f, -0.02009483f, 
    -0.03454018f, 0.01960917f, 0.00752829f, -0.03536291f, -0.03357586f, 0.00944255f, 0.01346017f, -0.03818055f, 
    -0.00377098f, 0.01973963f, -0.00641188f, -0.00324193f, 0.01052578f, -0.00341133f, 0.00218718f, 0.00525905f, 
    0.02138889f, 0.00629651f, 0.02263652f, 0.02006064f, -0.00759109f, -0.03293375f, -0.01911893f, -0.00935952f, 
    -0.01622107f, 0.00352956f, 0.01076061f, 0.02462429f, 0.00585915f, -0.01225387f, 0.02426335f, -0.02006722f, 
    0.00674813f, 0.02446509f, 0.02428715f, 0.00952694f, -0.03593393f, 0.02294739f, 0.00689844f, 0.01302700f, 
    -0.03603452f, -0.03224541f, -0.03358738f, -0.03582094f, 0.00989669f, 0.00645662f, 0.00109070f, -0.00489887f, 
    0.01956599f, 0.00808007f, -0.00141562f, -0.02975032f, 0.02312991f, -0.00370089f, 0.00833645f, -0.02188378f, 
    0.01822198f, -0.03793294f, -0.00211484f, -0.03963034f, -0.03682954f, -0.01022287f, 0.02920525f, 0.00680932f, 
    -0.01553769f, -0.04105621f, -0.03620784f, 0.01639993f, -0.03268905f, 0.01678480f, -0.00445214f, -0.02293443f, 
    0.01664059f, 0.01324717f, -0.00681370f, -0.02945002f, -0.01948164f, 0.01198420f, 0.02277680f, -0.02014173f, 
    0.01883109f, 0.01392430f, 0.03096810f, -0.02579535f, 0.01009033f, -0.03185945f, -0.02408173f, 0.01833979f, 
    0.01043647f, -0.03316535f, -0.02952466f, -0.02922593f, 0.01942743f, 0.00445299f, -0.03574240f, -0.02875368f, 
    -0.01462104f, -0.02026389f, -0.00587014f, -0.03986862f, -0.03996854f, -0.00577589f, -0.01490494f, 0.01352662f, 
    -0.04158293f, -0.04188169f, 0.01421033f, -0.02678796f, -0.00792257f, -0.01949260f, -0.03436359f, 0.02472145f, 
    -0.00569200f, -0.04224604f, -0.01613327f, 0.01484404f, -0.01603184f, -0.03480385f, -0.03606959f, -0.01203102f, 
    0.02783662f, -0.00700119f, 0.01010401f, -0.00459155f, -0.02314994f, -0.04083439f, 0.00737004f, 0.00520890f, 
    0.02292882f, -0.00831196f, 0.00768450f, -0.02394401f, 0.02470561f, 0.01851479f, -0.03757135f, -0.02478654f, 
    0.01783264f, -0.03433110f, 0.00232786f, -0.02711080f, -0.00256623f, 0.01807479f, 0.00651873f, 0.02804938f, 
    -0.03640888f, -0.01799323f, 0.00849031f, -0.04170065f, -0.02299026f, 0.02789190f, -0.03204380f, -0.00089589f, 
    0.02558878f, 0.01387731f, -0.04026428f, -0.01149804f, 0.02152695f, -0.01330523f, -0.01008105f, 0.02826367f, 
    0.01266871f, -0.00463220f, -0.03120083f, 0.01934597f, -0.02833243f, -0.03655098f, 0.00629977f, -0.03113605f, 
    0.00332586f, 0.02560980f, -0.03354463f, -0.02847713f, -0.03543640f, -0.02785460f, 0.01694415f, 0.01522278f, 
    0.26064673f, -0.02182420f, -0.00404302f, 0.12468032f, 0.13442382f, 0.10588815f, -0.02802186f, 0.06678379f, 
    0.05077136f, -0.00083823f, 0.08062153f, 0.04539136f, 0.10594714f, 0.01462987f, -0.02106638f, 0.03856199f, 
    0.08363146f, 0.10319600f, -0.03366982f, 0.02053099f, 0.15142028f, 0.07853615f, 0.11624519f, -0.19884782f, 
    0.15941429f, 0.20968269f, -0.06633665f, -0.21504419f, 0.02791776f, 0.07669372f, 0.14495648f, -0.01151954f, 
    0.03296102f, -0.04781214f, 0.01713714f, 0.07063687f, -0.15540703f, -0.05523182f, 0.02746507f, -0.05824094f, 
    0.06761146f, 0.13064708f, -0.04215097f, -0.01471931f, 0.02458441f, 0.05584915f, 0.01911575f, -0.02959639f, 
    -0.21940014f, -0.33437985f, -0.31455520f, -0.17116159f, 0.04600742f, -0.05695542f, -0.03907346f, -0.03335843f, 
    0.06620275f, -0.03327506f, 0.09336386f, 0.14287934f, -0.36281112f, -0.12079846f, 0.11855703f, 0.02184062f, 
    -0.11366487f, -0.05025733f, 0.04199793f, -0.00475675f, -0.00628249f, -0.01848354f, -0.00064020f, -0.08257497f, 
    -0.23841976f, 0.01984508f, 0.01768679f, 0.00782927f, 0.00339795f, 0.15416245f, 0.07576956f, -0.02552725f, 
    0.01954161f, -0.04547701f, 0.12326352f, 0.12963192f, 0.24519931f, -0.10749027f, 0.23765776f, 0.04025619f, 
    0.11899365f, -0.10222012f, 0.06234318f, 0.05870447f, 0.04079563f, 0.08134980f, -0.00276169f, 0.04675626f, 
    -0.18167771f, 0.00939452f, 0.05690715f, -0.02844073f, 0.00356512f, 0.05488992f, -0.02715583f, -0.01717415f, 
    0.02400783f, 0.02576918f, 0.09025741f, -0.01883673f, -0.20266661f, -0.30327061f, -0.03396221f, -0.16500406f, 
    0.03187399f, 0.01229189f, 0.09024564f, -0.04566831f, 0.06398088f, 0.02042973f, -0.03572021f, 0.11053330f, 
    0.08513489f, -0.21498707f, 0.05015985f, -0.12574360f, -0.01531376f, -0.14119093f, 0.03266761f, 0.02095395f, 
    -0.04829911f, -0.08567055f, 0.06949349f, 0.16461304f, -0.15829790f, -0.19839558f, -0.15176246f, -0.04775394f, 
    -0.02490349f, -0.02595877f, -0.02106301f, -0.07655516f, -0.16534358f, -0.07690087f, 0.04485769f, 0.16556236f, 
    0.19942717f, 0.10042014f, 0.08020543f, 0.00163818f, 0.07269407f, 0.12728386f, 0.03988294f, 0.07162925f, 
    -0.03052797f, -0.01326891f, 0.00178611f, 0.15034346f, -0.17386673f, -0.07586634f, 0.09778753f, 0.02451869f, 
    -0.02054291f, 0.18462247f, -0.02977441f, -0.05453077f, -0.17009549f, -0.04400571f, 0.01477501f, 0.00318604f, 
    0.06191580f, -0.14203773f, 0.05417403f, -0.11956635f, 0.06515580f, 0.06917271f, -0.00296885f, 0.09794026f, 
    -0.05717155f, 0.01956605f, -0.02446578f, 0.05540130f, 0.20847736f, 0.12760207f, 0.11421386f, -0.06475234f, 
    -0.01475448f, 0.05803900f, -0.06365985f, 0.17941418f, 0.01561358f, -0.08940219f, 0.01407000f, -0.00617282f, 
    -0.20406468f, -0.12198741f, -0.13822141f, -0.03853502f, 0.05810757f, 0.01617560f, -0.04381206f, 0.06434860f, 
    0.04648719f, -0.04343637f, -0.04224880f, 0.00037954f, -0.27583158f, -0.34120977f, -0.34231615f, -0.09055118f, 
    -0.04966898f, 0.05912525f, 0.02775894f, -0.05150711f, -0.03922553f, -0.04014920f, 0.00397249f, -0.09884809f, 
    -0.03431910f, -0.35855603f, 0.06919787f, -0.09225116f, 0.02330422f, -0.11143607f, 0.05544765f, -0.00631906f, 
    0.01505804f, -0.01680236f, -0.03785241f, 0.10125210f, 0.03575941f, -0.32029530f, -0.12460654f, -0.01937459f, 
    -0.05727936f, 0.06709306f, -0.01690075f, 0.02052060f, -0.05505910f, -0.01698408f, 0.09100696f, -0.12233768f, 
    0.22247024f, 0.17312272f, 0.10678922f, 0.07884868f, 0.05899971f, 0.09531552f, 0.06194387f, 0.08726386f, 
    0.07223749f, -0.04777288f, -0.04623351f, -0.01411699f, -0.09638832f, -0.16301283f, -0.34188792f, 0.01013410f, 
    -0.00976312f, 0.04550392f, -0.00466405f, 0.00685498f, 0.06362901f, 0.03155433f, -0.01363036f, -0.04572351f, 
    -0.43541387f, -0.43403876f, -0.34321189f, 0.00793645f, 0.12691389f, -0.02328681f, -0.01531046f, -0.01974455f, 
    0.06695037f, -0.08828424f, -0.03592762f, -0.07355999f, 0.01146682f, -0.22582884f, -0.03845450f, 0.00278867f, 
    0.07618526f, 0.06176966f, -0.01799158f, 0.04751221f, 0.05530153f, -0.04451795f, 0.08391310f, -0.04126781f, 
    0.22547276f, 0.16575275f, 0.15627719f, 0.06281120f, 0.06371044f, 0.01391636f, -0.07571869f, 0.06674584f, 
    0.00153045f, -0.02681220f, 0.02442833f, 0.15585689f, 0.30389601f, -0.07616664f, 0.00527572f, -0.14624670f, 
    0.06673041f, 0.00638485f, 0.09335421f, 0.12450285f, 0.00581954f, 0.05247276f, -0.04854514f, 0.09807055f, 
    0.04425051f, 0.06254640f, 0.06032000f, -0.01238088f, 0.08354989f, 0.04313629f, -0.02147883f, -0.01182799f, 
    0.03180517f, 0.15695012f, 0.05380749f, 0.03893096f, -0.51901573f, -0.08120392f, -0.05579845f, 0.05728890f, 
    0.03650860f, 0.03929569f, -0.00594806f, 0.03117046f, -0.02043521f, 0.03518586f, -0.02513221f, -0.26696962f, 
    0.17193785f, 0.17833468f, -0.09813260f, -0.12352498f, 0.03518061f, -0.02107595f, 0.04996118f, 0.11902593f, 
    0.11628596f, 0.06873387f, -0.03018565f, 0.02537717f, 0.18965794f, 0.12780924f, 0.05477904f, 0.01408438f, 
    -0.00428561f, -0.02631221f, 0.01243427f, -0.11507800f, -0.05836745f, -0.03273063f, -0.03069263f, -0.04536754f, 
    0.02847634f, -0.09084146f, 0.07243543f, 0.04477732f, -0.03196481f, -0.02223781f, -0.02460811f, 0.17760655f, 
    0.02746960f, -0.03241869f, -0.08186308f, -0.04895238f, 0.14274833f, -0.24713729f, 0.24318376f, 0.04720780f, 
    -0.06137530f, -0.00314180f, 0.05452588f, 0.01823176f, -0.02367650f, -0.00481964f, -0.00885204f, 0.05683291f, 
    0.19227099f, -0.14768204f, 0.21312197f, -0.00920512f, 0.02891294f, -0.00985574f, 0.15041871f, 0.02566293f, 
    0.01905784f, 0.10421830f, 0.00680657f, -0.03935301f, -0.27412713f, -0.01676910f, 0.09634883f, 0.03819710f, 
    0.01319931f, -0.00951508f, -0.13441585f, 0.07743334f, 0.03623889f, -0.03032196f, 0.02330319f, 0.04325329f, 
    0.31531522f, 0.25688472f, 0.20263909f, 0.17952329f, -0.13306110f, -0.03757051f, 0.01896534f, 0.09717233f, 
    -0.01408003f, -0.00686186f, -0.06275886f, -0.05465028f, -0.12723853f, -0.18124457f, -0.22660473f, -0.02298081f, 
    0.10246252f, 0.11007845f, -0.06674042f, -0.03971833f, 0.03421882f, 0.03846079f, 0.05377336f, -0.03919893f, 
    0.42838183f, -0.01331983f, 0.16288261f, 0.20039970f, -0.01393368f, 0.06173601f, 0.00475108f, -0.10111961f, 
    0.03601794f, 0.12960018f, -0.05971577f, -0.02969797f, -0.00247347f, 0.05271551f, -0.07537615f, -0.00349657f, 
    0.13880454f, 0.09617036f, 0.05028460f, -0.02311904f, -0.08627038f, 0.07685406f, -0.16353364f, -0.05040651f, 
    0.34085095f, 0.02603549f, -0.00590604f, 0.06771217f, 0.00240841f, 0.03313866f, 0.03780826f, -0.05190895f, 
    0.05257371f, -0.02376520f, 0.10212281f, -0.03529593f, 0.27204901f, 0.12956172f, 0.07495386f, 0.00436345f, 
    0.07584666f, 0.01300934f, 0.10575002f, 0.03934291f, -0.00772255f, -0.03437773f, 0.00687492f, -0.04652125f, 
    0.08713239f, -0.19579327f, -0.08072580f, 0.00601760f, 0.07043707f, -0.03457818f, 0.14742951f, -0.08172576f, 
    0.01723847f, -0.06228734f, -0.06091807f, -0.00731627f, 0.08530515f, 0.09373438f, 0.08754468f, -0.04950523f, 
    -0.00375471f, 0.09483560f, -0.03818106f, -0.05557984f, -0.06060420f, -0.03758936f, -0.09242306f, 0.17316262f, 
    0.13276826f, 0.02771642f, -0.00383179f, 0.01813226f, 0.02451920f, 0.05994825f, 0.02850368f, 0.03648255f, 
    0.06606926f, 0.11588044f, -0.02814602f, 0.01908227f, 0.16359934f, -0.40421605f, 0.03385559f, -0.18769735f, 
    -0.04304342f, -0.01984266f, 0.07232673f, 0.01850052f, -0.04239726f, -0.03439094f, 0.00569751f, 0.05728588f, 
    -0.10455654f, -0.04625123f, -0.06377611f, -0.01576915f, 0.00410255f, -0.03464360f, -0.03387735f, -0.06667062f, 
    -0.27301854f, 0.09833711f, 0.11133038f, 0.27370262f, 0.23889059f, 0.26189181f, 0.21553735f, 0.21825257f, 
    -0.10142151f, -0.07675025f, 0.00709753f, 0.07275262f, -0.06699334f, -0.00854438f, -0.03435422f, -0.06707955f, 
    -0.16821802f, -0.14458145f, -0.19225234f, -0.15076809f, 0.04315723f, 0.02100831f, -0.02998470f, -0.06268340f, 
    -0.04379100f, -0.00232648f, -0.09723308f, -0.06691365f, 0.13696368f, -0.13551340f, -0.17721695f, -0.10799596f, 
    0.01941101f, 0.06477378f, 0.09270144f, 0.03356597f, -0.07477979f, 0.00675552f, -0.05435470f, -0.07806838f, 
    0.32531551f, -0.23506825f, -0.04269237f, -0.19005953f, -0.01737823f, -0.01100637f, 0.04333395f, 0.04903096f, 
    -0.09734428f, -0.06073020f, -0.03602502f, -0.02392639f, 0.30657020f, 0.15831161f, -0.01209772f, 0.05680345f, 
    0.07002416f, 0.10919625f, 0.06946669f, 0.03696688f, 0.04214153f, 0.00913291f, 0.01452984f, -0.10533886f, 
    -0.12090325f, -0.34227425f, -0.10017832f, -0.00698748f, -0.01834051f, -0.04392157f, -0.06045064f, -0.04506801f, 
    -0.02937647f, 0.02082007f, -0.07822406f, 0.01008224f, 0.09171130f, 0.16126044f, -0.10882015f, -0.00246394f, 
    0.01697730f, 0.05831458f, 0.03376017f, 0.06164776f, -0.01159018f, 0.05744895f, -0.00584311f, 0.21409488f, 
    0.04008187f, 0.32066464f, 0.06298924f, 0.17345287f, 0.14088401f, 0.09009603f, 0.04575897f, 0.08274554f, 
    0.03026346f, 0.05150174f, 0.00871385f, -0.09622296f, 0.20908064f, 0.13519178f, -0.24958459f, 0.03352643f, 
    -0.10138989f, 0.15041097f, 0.19921024f, 0.04923819f, 0.00076258f, 0.08290882f, 0.02474839f, 0.04111143f, 
    0.01692251f, -0.00092798f, -0.05323020f, -0.11261477f, -0.06964328f, 0.07098243f, 0.00165678f, -0.13436122f, 
    -0.08453995f, 0.00468616f, 0.12037890f, 0.07647265f, 0.09725259f, 0.13987540f, 0.06678123f, -0.01649517f, 
    -0.07583484f, -0.16795233f, -0.01421645f, 0.01173120f, -0.02681881f, -0.07627286f, -0.08131623f, -0.01901217f, 
    0.08029593f, 0.13727021f, 0.00150492f, -0.07289354f, 0.10465423f, 0.03900403f, -0.10166672f, 0.02714187f, 
    0.06533988f, -0.02023187f, 0.09510008f, 0.09559806f, -0.26923987f, -0.26776266f, 0.00470669f, -0.07567798f, 
    0.00334631f, -0.08281678f, 0.02026173f, 0.02433812f, -0.13340153f, 0.06435561f, -0.10049181f, 0.04144474f, 
    0.16437511f, 0.17559916f, 0.12663862f, 0.14609976f, -0.02656235f, 0.03688406f, -0.05558453f, 0.07242659f, 
    -0.06101387f, -0.05124449f, -0.11393302f, -0.00779413f, 0.00174065f, -0.02761923f, -0.22408900f, 0.02075077f, 
    0.08167843f, 0.02064164f, -0.03859970f, -0.03257419f, 0.05020420f, -0.01935598f, 0.03311677f, 0.04450396f, 
    -0.28573924f, 0.01699477f, 0.10783296f, -0.23289482f, -0.08840711f, -0.03548924f, -0.03781697f, -0.03811306f, 
    -0.02953740f, -0.02551020f, -0.08909375f, -0.00814186f, -0.26540053f, -0.06081253f, 0.01409899f, 0.07866602f, 
    -0.00785015f, 0.06657666f, -0.11775149f, -0.01545542f, 0.04790343f, 0.09564817f, 0.01594860f, 0.05161820f, 
    -0.07787355f, 0.07517055f, 0.03918710f, 0.03556449f, 0.09503716f, 0.07562428f, 0.06007739f, -0.05936038f, 
    0.06232206f, 0.10092343f, 0.03562485f, -0.01444378f, 0.23779002f, -0.07363398f, 0.10404444f, 0.14718662f, 
    0.02572506f, -0.02843951f, 0.07595601f, 0.06149308f, -0.08666570f, -0.06080280f, 0.03052390f, 0.05007772f, 
    0.25704291f, 0.32600656f, 0.17701834f, -0.18723832f, -0.07014363f, -0.03348034f, -0.00896348f, -0.09063745f, 
    -0.05211648f, -0.06667860f, -0.04156300f, -0.09184379f, -0.23975939f, 0.17439134f, -0.00133066f, -0.06601933f, 
    -0.01392327f, 0.03595370f, -0.02305159f, 0.20229451f, 0.02715447f, 0.06911534f, -0.05629620f, 0.07823780f, 
    -0.29611298f, -0.05717241f, -0.06468899f, 0.13540766f, 0.05105376f, -0.03188941f, 0.03058049f, -0.08802209f, 
    0.10238048f, 0.07693604f, -0.00137170f, 0.03243946f, -0.42300305f, -0.00561460f, -0.14128301f, -0.10139755f, 
    -0.12898263f, -0.05065909f, 0.00262991f, 0.10298452f, 0.04497517f, 0.06026665f, 0.05058988f, 0.00078206f, 
    0.01324239f, -0.00164309f, 0.00277892f, -0.06382758f, -0.03637283f, -0.01496892f, -0.06430455f, 0.00139485f, 
    -0.06531662f, -0.13096054f, -0.08435231f, -0.07275755f, -0.03498255f, 0.09813014f, -0.04070636f, -0.04478405f, 
    0.12050965f, 0.05050413f, 0.03913370f, 0.07319017f, -0.04547340f, 0.09271397f, 0.17614159f, 0.09209991f, 
    -0.12722680f, 0.04179393f, -0.18463995f, -0.05671261f, 0.04849368f, -0.10636012f, -0.11619426f, 0.02765809f, 
    -0.07359619f, 0.02087967f, -0.04969376f, -0.17884074f, 0.26081821f, -0.11816389f, 0.12164292f, 0.02751390f, 
    -0.03059265f, 0.09333619f, -0.01316699f, 0.11068164f, 0.00652883f, -0.08481020f, 0.00774686f, -0.02853016f, 
    0.11814191f, -0.13186584f, -0.06376182f, -0.13759245f, 0.12303163f, -0.02850126f, 0.06478133f, 0.12523162f, 
    0.04139391f, -0.07044844f, -0.00655113f, -0.07568174f, 0.27229401f, -0.13549869f, 0.34221980f, 0.06631634f, 
    0.11335510f, -0.04587451f, 0.03741785f, 0.06446701f, 0.06738006f, -0.04430672f, -0.02816615f, 0.18388431f, 
    0.07861162f, 0.02874164f, -0.13928486f, 0.15288469f, -0.00811304f, -0.04786669f, -0.07010719f, 0.09311739f, 
    -0.01287592f, 0.00946042f, 0.05054092f, -0.09518821f, 0.03015746f, -0.00705330f, 0.02290529f, -0.06673320f, 
    0.02574247f, -0.07260852f, -0.10339447f, 0.00597158f, -0.11317493f, -0.03749780f, -0.04745227f, -0.22079954f, 
    0.11960077f, 0.13002504f, 0.12705906f, -0.03349826f, -0.10342445f, 0.00763550f, -0.02883730f, -0.07308317f, 
    -0.04112430f, -0.04931423f, 0.01685306f, -0.07667361f, -0.08991936f, -0.00850628f, -0.03005273f, 0.01765447f, 
    0.02076179f, -0.01166613f, -0.01311618f, 0.08649702f, 0.09980946f, 0.08438469f, 0.07673935f, 0.15733869f, 
    -0.02579167f, -0.01319660f, -0.00652345f, 0.14283870f, -0.08786378f, -0.04460414f, -0.06829845f, 0.01302798f, 
    0.01205388f, -0.07060321f, 0.23864806f, 0.11220829f, 0.13452144f, 0.15262809f, 0.00354856f, -0.01423488f, 
    0.02590496f, 0.05462265f, 0.01052528f, -0.10561059f, -0.07592471f, -0.05089668f, 0.03392473f, 0.01930286f, 
    0.20100355f, 0.00843268f, 0.08057274f, -0.00268918f, 0.11679345f, -0.00405003f, -0.01999285f, -0.01652103f, 
    -0.05630881f, -0.03113850f, -0.07618343f, -0.05575769f, -0.10138392f, -0.03557539f, -0.00253335f, 0.14794824f, 
    -0.02739698f, -0.04206652f, 0.00526667f, 0.05138019f, 0.03571063f, 0.00166571f, 0.06339406f, 0.18832335f, 
    0.32562396f, -0.04233643f, 0.07738805f, -0.01557386f, -0.01404203f, 0.12997280f, 0.02898479f, 0.05884720f, 
    0.03246715f, 0.01202791f, -0.00600677f, 0.01946313f, -0.10502455f, -0.00957480f, -0.14252056f, -0.01404741f, 
    -0.00449808f, 0.06867134f, -0.01631983f, 0.04786760f, -0.00622375f, -0.03381091f, 0.08590874f, 0.20096196f, 
    -0.09517740f, 0.17512362f, 0.08203461f, 0.09358254f, -0.13418962f, 0.05472225f, 0.07546408f, -0.09920928f, 
    -0.04828719f, 0.04796327f, 0.07684021f, -0.14790705f, -0.00444828f, 0.02898405f, 0.02633240f, -0.03463732f, 
    0.17782673f, -0.07689870f, 0.00733855f, 0.05364307f, 0.01790760f, -0.08205495f, -0.02107881f, -0.04060584f, 
    0.17408609f, -0.04799123f, 0.10275836f, 0.03968131f, -0.03661837f, 0.01365128f, -0.03764147f, 0.05127726f, 
    -0.05190550f, -0.00780899f, -0.00596656f, 0.01825643f, -0.12387941f, -0.05310716f, 0.03325007f, 0.16464928f, 
    -0.16921037f, -0.08631039f, 0.04444010f, 0.05633521f, 0.07094873f, 0.09280796f, 0.07867765f, 0.14009768f, 
    0.00542619f, 0.02281943f, 0.11662122f, -0.10599815f, 0.05644620f, 0.01025960f, -0.01603349f, -0.14465624f, 
    -0.05397204f, -0.01056272f, 0.04433950f, -0.01051533f, 0.07789086f, 0.06901540f, -0.01326217f, 0.10333117f, 
    0.00697453f, 0.12754190f, 0.08860941f, -0.03928227f, 0.08262648f, -0.03792544f, 0.03967608f, -0.00776555f, 
    -0.26839894f, -0.03065004f, -0.10416400f, 0.00421333f, -0.12366821f, -0.02263411f, 0.00902691f, 0.02524674f, 
    0.11724237f, 0.03005537f, 0.07628496f, -0.06858017f, -0.01936281f, -0.15583502f, -0.07493215f, 0.00153824f, 
    -0.07738517f, -0.04072481f, -0.04838165f, 0.00531838f, 0.04439032f, -0.04862663f, 0.00815394f, 0.10533213f, 
    -0.08010373f, -0.13478851f, -0.04007061f, -0.04729978f, 0.22722302f, 0.13998912f, 0.06577667f, 0.05398403f, 
    -0.08388145f, -0.07959320f, -0.03212273f, -0.05941992f, -0.09772927f, 0.25860855f, 0.25390792f, -0.02635901f, 
    0.02558453f, 0.04449879f, 0.12120377f, 0.20977728f, -0.02787298f, -0.07653324f, -0.00056827f, 0.05741628f, 
    -0.11307564f, -0.08486351f, 0.06379914f, 0.06385962f, 0.05682030f, 0.09259145f, 0.26585138f, 0.13296583f, 
    -0.00384650f, 0.13342643f, 0.01664743f, -0.06503698f, 0.10612947f, 0.04116335f, 0.07348110f, 0.12515645f, 
    -0.01325707f, 0.06504832f, 0.10082078f, 0.07603166f, 0.06550380f, 0.09392591f, 0.03262041f, 0.12243930f, 
    0.03691142f, -0.04177574f, 0.05600605f, 0.02254505f, 0.03546770f, 0.01643598f, 0.03504406f, 0.19370066f, 
    0.02652538f, -0.03671919f, 0.06609932f, 0.03318226f, 0.34933978f, -0.11458750f, 0.35673490f, 0.07480802f, 
    0.04977297f, 0.20513122f, -0.08056977f, 0.18763748f, 0.09336285f, 0.05250642f, 0.06906885f, 0.04530541f, 
    -0.04142060f, 0.10204937f, 0.04997862f, 0.00292450f, -0.16070180f, -0.11877275f, -0.09667440f, -0.14211953f, 
    -0.11267880f, -0.07868072f, -0.00424021f, 0.05784981f, 0.03416397f, -0.06612124f, 0.01558239f, -0.03408268f, 
    0.03741765f, -0.01030845f, -0.03767843f, -0.03992464f, 0.01014472f, 0.04532660f, 0.01745410f, 0.03656324f, 
    0.09459570f, 0.19433661f, 0.02578217f, 0.06357314f, 0.12836629f, -0.00651415f, -0.14599851f, 0.17659892f, 
    0.03668696f, -0.04616610f, 0.00161320f, 0.03740770f, -0.04090867f, -0.05043229f, 0.01004071f, 0.02710612f, 
    0.05160281f, 0.04308883f, 0.07554764f, -0.00039704f, 0.14012444f, -0.02990714f, 0.16576551f, 0.10958776f, 
    -0.16626279f, 0.31322959f, 0.16654216f, -0.09689435f, 0.03135963f, 0.05190175f, 0.05515972f, 0.14156553f, 
    0.04652287f, -0.01357915f, -0.06696261f, -0.03968432f, 0.14354086f, 0.11989739f, 0.16963908f, -0.00656489f, 
    0.00702796f, 0.10255256f, -0.00809502f, -0.02377625f, -0.01267062f, -0.05970164f, -0.06005876f, 0.00759970f, 
    -0.05841331f, 0.01967531f, -0.05659090f, 0.05846451f, 0.04527462f, 0.05125486f, -0.00057565f, 0.08630107f, 
    0.11886475f, 0.08239747f, -0.05165859f, 0.07588671f, 0.32053235f, 0.09737969f, 0.15149900f, 0.09507279f, 
    0.10029710f, 0.01861061f, -0.00292026f, 0.10450346f, 0.06548784f, 0.15754372f, -0.01808954f, -0.07842860f, 
    0.05644369f, -0.04088931f, 0.01362783f, -0.09935120f, -0.15770082f, -0.03891751f, -0.10377032f, -0.09045853f, 
    -0.13659911f, -0.04400027f, 0.03367871f, -0.03033590f, -0.12767354f, 0.15708953f, -0.13871081f, 0.22801115f, 
    0.01680690f, 0.00154160f, -0.00468747f, 0.10479003f, 0.05439866f, 0.19724859f, 0.05681860f, 0.09565464f, 
    -0.07900830f, -0.05853627f, 0.00532679f, -0.13568062f, 0.00733092f, -0.10598074f, -0.08637156f, 0.00230348f, 
    -0.08961712f, -0.03223763f, -0.20697001f, -0.28687963f, 0.07724400f, 0.07346532f, 0.10319150f, -0.08771862f, 
    -0.04646574f, 0.03675490f, -0.08295442f, -0.06802048f, -0.06526235f, -0.00724089f, 0.02176621f, 0.12316918f, 
    0.11007582f, -0.03345535f, -0.03111832f, -0.03822515f, -0.10170306f, 0.10080561f, -0.08534788f, 0.01842997f, 
    0.05077159f, 0.02566938f, 0.13573103f, 0.10831267f, -0.09007473f, 0.00356139f, -0.01969435f, 0.05976603f, 
    0.01134915f, 0.14056066f, 0.00937572f, 0.07581428f, 0.01602242f, 0.01944237f, 0.05651389f, 0.01019759f, 
    -0.21136352f, -0.06230858f, -0.16258292f, 0.33123842f, -0.10440598f, -0.08797717f, -0.06252360f, -0.08364802f, 
    0.08946095f, -0.07720505f, 0.04596993f, 0.13964406f, 0.31505433f, 0.28167522f, 0.06668918f, -0.14261939f, 
    0.03379846f, 0.04675781f, -0.07106318f, 0.01171328f, -0.02408454f, -0.10441044f, -0.01916840f, 0.10512229f, 
    -0.00406785f, 0.01075704f, 0.03358277f, -0.05358358f, 0.00188831f, 0.03258787f, -0.02096163f, 0.02693459f, 
    -0.06100184f, -0.10643567f, -0.08183935f, 0.04745564f, 0.03210114f, -0.04383991f, -0.07362603f, -0.17598191f, 
    0.14605476f, -0.01108499f, 0.00889868f, -0.00621670f, -0.14748870f, 0.03060128f, -0.02108825f, -0.09891934f, 
    0.12150165f, -0.17571533f, 0.24283919f, -0.05057907f, -0.06911084f, 0.09772560f, 0.02886474f, 0.11519082f, 
    -0.05698673f, -0.05486857f, 0.08499150f, 0.06866428f, 0.09132826f, -0.03249817f, -0.06401326f, -0.21113391f, 
    0.08007556f, 0.01362947f, -0.04234263f, -0.02534680f, -0.03382796f, 0.00263789f, 0.02707088f, 0.02818982f, 
    0.21294546f, -0.16136287f, 0.30509040f, -0.05838379f, -0.09199707f, 0.03030262f, -0.01147429f, 0.14136744f, 
    0.05510811f, 0.01436025f, 0.04530382f, -0.06479458f, 0.09846028f, 0.15953960f, 0.17777145f, -0.00657824f, 
    0.05830717f, 0.12452518f, 0.04338244f, 0.10057119f, 0.02624678f, -0.04907458f, 0.02458818f, -0.06775559f, 
    -0.31118906f, -0.02760617f, 0.07699870f, 0.00755023f, -0.08930940f, -0.04659971f, 0.02138490f, 0.05311400f, 
    0.06346466f, 0.03330437f, 0.04053674f, -0.06667691f, 0.00186534f, -0.14678676f, -0.12735115f, -0.07002033f, 
    -0.06521360f, -0.13683982f, -0.06331579f, -0.06029025f, -0.00746200f, -0.05765123f, -0.06409436f, -0.06906500f, 
    0.10572389f, 0.01314153f, 0.07596710f, -0.09267048f, 0.06277780f, 0.16517393f, -0.20836793f, 0.02691264f, 
    0.05238467f, 0.01340968f, 0.08105730f, 0.12097466f, -0.36116105f, 0.02872459f, -0.05616648f, -0.09814400f, 
    -0.04165949f, -0.05802798f, -0.01471232f, -0.02340116f, -0.01006644f, 0.13578956f, -0.00821878f, -0.06283629f, 
    -0.04314383f, 0.12819347f, -0.10944162f, 0.26264942f, 0.08054510f, -0.05148567f, 0.04820720f, 0.08382443f, 
    0.02391967f, 0.07262064f, 0.09763142f, 0.04510963f, -0.09988134f, -0.09941724f, 0.14358602f, -0.09636412f, 
    0.14230405f, -0.08880196f, 0.05162335f, 0.18484788f, 0.16780967f, 0.10365076f, -0.05771334f, -0.06770136f, 
    -0.07827790f, 0.33186904f, 0.06020413f, -0.00979873f, -0.03394675f, -0.03833716f, -0.03448617f, 0.15846452f, 
    0.04911605f, -0.08995345f, 0.02656307f, -0.09603979f, -0.08922361f, 0.12100539f, 0.11308651f, -0.11306050f, 
    -0.06839458f, -0.01408008f, 0.06560225f, 0.05525355f, 0.15607104f, -0.02837771f, 0.01234892f, -0.03253206f, 
    0.01336133f, -0.00929565f, 0.01176891f, 0.27672574f, 0.12709330f, 0.10103670f, -0.05015795f, 0.08008719f, 
    0.05948423f, 0.23182103f, 0.08669426f, 0.16900380f, 0.09242939f, 0.03476532f, -0.05701462f, 0.06481894f, 
    0.02273438f, 0.02529409f, -0.00190801f, -0.02512700f, 0.01539034f, 0.13043596f, -0.00018879f, -0.20217365f, 
    0.37820244f, 0.20473544f, 0.25507817f, -0.22382611f, 0.14915185f, 0.04462663f, 0.08451731f, -0.03293836f, 
    -0.07482606f, -0.01410609f, -0.01433187f, -0.03332565f, 0.15511869f, 0.00274372f, 0.09800664f, -0.01516745f, 
    0.02587061f, -0.02315726f, 0.01505054f, -0.02773557f, -0.08584189f, 0.08201200f, 0.00823070f, 0.00189692f, 
    0.12942718f, -0.15766616f, -0.20977022f, -0.01343254f, -0.05773444f, -0.00593897f, -0.01610446f, -0.07480311f, 
    0.05573557f, 0.11347950f, 0.02575343f, 0.00703963f, -0.15665109f, 0.00213562f, 0.17797825f, -0.07181949f, 
    -0.04538812f, -0.00074702f, 0.08919448f, -0.21456999f, -0.14398909f, -0.10440573f, -0.06407281f, 0.07702304f, 
    0.34551823f, 0.02749145f, 0.08236461f, -0.12621398f, -0.01183014f, 0.06189935f, 0.06577893f, -0.05767392f, 
    0.18179326f, -0.02056752f, 0.11182046f, 0.18505862f, -0.08970408f, -0.16759120f, 0.28881222f, -0.12534641f, 
    -0.05585440f, 0.09809416f, 0.07389879f, 0.01272951f, -0.02937281f, 0.13742696f, 0.05213063f, 0.08996897f, 
    0.04733677f, -0.17143263f, 0.20817730f, -0.07170628f, -0.10923208f, -0.06557772f, 0.03713296f, -0.02710945f, 
    -0.01756978f, 0.01511119f, 0.03074483f, 0.01734443f, 0.13751811f, -0.25324833f, 0.38948590f, -0.38262203f, 
    0.03221338f, -0.01399894f, 0.00274392f, -0.01988126f, 0.08065486f, 0.15875196f, 0.00051532f, -0.05737679f, 
    -0.27663291f, 0.08562079f, -0.00390396f, 0.13725416f, -0.13713402f, -0.04716793f, 0.04519521f, 0.02747442f, 
    -0.04204478f, 0.07635618f, 0.04152595f, 0.19676447f, -0.02312163f, -0.05000073f, 0.10161091f, 0.01435499f, 
    -0.04411861f, 0.02446222f, -0.06370619f, -0.05502272f, 0.13510875f, 0.03303245f, 0.00918059f, 0.33521563f, 
    -0.06000768f, 0.06336304f, -0.15232098f, 0.19739394f, 0.13902843f, 0.01502824f, -0.06163170f, 0.13010925f, 
    0.12571418f, 0.23826632f, 0.07143677f, 0.19014443f, -0.13401376f, 0.00264091f, 0.09707689f, 0.01565507f, 
    0.10259682f, 0.10104051f, 0.04305529f, 0.05471059f, -0.18738873f, -0.02994393f, -0.00530844f, 0.06516246f, 
    0.02145384f, 0.02352780f, 0.13274258f, 0.07110868f, -0.02356937f, 0.07750161f, 0.12734595f, 0.05639661f, 
    -0.04465238f, 0.08941906f, -0.15089387f, -0.07675990f, 0.02944190f, -0.08966799f, -0.11173596f, 0.22715101f, 
    -0.00120777f, -0.04352472f, 0.00349584f, 0.06093819f, 0.02571770f, -0.01517363f, 0.00598141f, 0.03617778f, 
    -0.12368590f, 0.00924175f, 0.21932015f, 0.03540877f, -0.08416089f, -0.13661723f, -0.00999669f, -0.07007751f, 
    -0.10352618f, -0.03051855f, -0.07229725f, 0.01037399f, -0.01526257f, -0.12980711f, -0.15373246f, 0.07100381f, 
    -0.02863411f, -0.00595193f, -0.02840171f, -0.06414104f, -0.12590657f, 0.01052768f, -0.05741509f, -0.11102883f, 
    -0.12923592f, -0.03353513f, 0.11197050f, 0.09288232f, -0.11937317f, 0.04693466f, 0.04389750f, -0.00231911f, 
    -0.00689909f, 0.05470469f, 0.07614238f, 0.12544829f, 0.18922943f, 0.03601604f, -0.10299765f, 0.17512769f, 
    0.00795807f, 0.00634309f, 0.06378595f, -0.09886677f, -0.11507535f, -0.05601881f, 0.00238909f, -0.08282932f, 
    0.21828328f, 0.16417222f, -0.10112617f, 0.25698483f, 0.00210228f, -0.02804753f, -0.02016845f, 0.27580765f, 
    -0.03576631f, -0.06049442f, -0.05763936f, 0.04861557f, 0.16255812f, -0.04249471f, 0.09545355f, 0.01457751f, 
    -0.12600885f, 0.05004968f, -0.05242955f, -0.03607951f, -0.00673306f, 0.00274775f, -0.01834114f, -0.15592863f, 
    0.03562456f, -0.01842639f, 0.01217755f, 0.07981314f, -0.04417196f, -0.01505804f, -0.13723786f, -0.06368353f, 
    -0.07127193f, 0.00912999f, 0.05994008f, -0.04728482f, -0.21907601f, 0.26365548f, 0.08685793f, 0.23705679f, 
    0.10154031f, 0.05918094f, -0.02894639f, -0.06852929f, -0.01717031f, -0.14778998f, 0.22532563f, -0.02477561f, 
    -0.00228587f, -0.08666335f, 0.00828711f, 0.15651745f, -0.01093042f, -0.06425212f, 0.02744509f, 0.20539223f, 
    0.06274353f, 0.13493232f, 0.03666921f, 0.23458041f, 0.16299701f, -0.03503850f, 0.12111723f, -0.01375511f, 
    0.05410687f, -0.02109976f, 0.07604123f, 0.15927435f, -0.13881566f, 0.11454707f, -0.01180146f, 0.00485208f, 
    -0.24556288f, 0.16955359f, 0.04524868f, -0.01873788f, 0.01842923f, -0.06953990f, -0.01868303f, 0.00037465f, 
    -0.08772995f, 0.18791582f, 0.01650039f, 0.03496324f, 0.08253402f, -0.08051977f, 0.27851111f, -0.13411976f, 
    -0.00349176f, 0.06240074f, -0.07948413f, -0.01086597f, -0.08079157f, -0.11364182f, -0.00908191f, -0.24138831f, 
    0.31482628f, 0.19027674f, 0.36723074f, -0.11550876f, -0.03622179f, -0.02015714f, -0.05007434f, -0.05187339f, 
    -0.04441635f, 0.10262357f, -0.08051349f, 0.03542209f, 0.20684525f, 0.16246824f, 0.09425516f, 0.03621508f, 
    -0.00626413f, -0.04690279f, 0.06164536f, -0.13930994f, -0.04489544f, -0.02672850f, -0.06347133f, -0.12993346f, 
    0.00666906f, 0.05428901f, 0.18378457f, -0.02482987f, 0.09186193f, 0.08383436f, -0.00526710f, 0.06323382f, 
    -0.14102215f, -0.09214083f, -0.10873171f, -0.13313703f, -0.21190907f, 0.01947991f, -0.06094732f, 0.07470181f, 
    -0.00808253f, 0.00034745f, -0.11197276f, 0.08099137f, 0.07517198f, -0.10576491f, -0.01473741f, 0.10131198f, 
    -0.03393009f, 0.01008113f, 0.26086250f, 0.09232800f, -0.04823480f, 0.22979933f, 0.14971316f, -0.04723839f, 
    -0.02149965f, 0.04636600f, -0.02357327f, -0.07487945f, 0.08226912f, 0.07183879f, 0.28269345f, -0.06782459f, 
    -0.03297084f, 0.03653884f, -0.16330859f, 0.15099299f, -0.01019913f, 0.00610389f, -0.07100024f, -0.00793854f, 
    0.07964445f, -0.06810326f, 0.06244493f, -0.02179555f, 0.03283215f, -0.04219913f, -0.01988683f, 0.02427697f, 
    0.05625138f, 0.06863470f, -0.13566767f, -0.06214458f, 0.27529931f, -0.09605715f, -0.06391886f, -0.11251327f, 
    -0.05417211f, 0.08486428f, 0.00678967f, -0.00295889f, -0.16845274f, 0.04333416f, 0.03146176f, -0.10386901f, 
    0.21590640f, -0.06837747f, 0.03442853f, 0.33358988f, -0.11258914f, 0.06980345f, 0.08684793f, -0.00141726f, 
    -0.06868318f, 0.09954619f, -0.05442009f, -0.09516632f, -0.20954637f, 0.27950311f, -0.06383357f, -0.04009397f, 
    0.03463230f, 0.00658696f, 0.06375157f, -0.09419753f, -0.14482610f, 0.04303179f, -0.11014688f, 0.00058456f, 
    -0.00675621f, 0.28837812f, -0.00882764f, 0.20243363f, 0.00749240f, -0.02294173f, 0.07009452f, -0.10394686f, 
    -0.04221912f, 0.05148298f, 0.08812462f, 0.03012227f, 0.10955121f, 0.19873869f, 0.17561337f, 0.06798831f, 
    0.04440557f, 0.02122360f, -0.06184096f, 0.05529760f, -0.00047893f, 0.02137818f, -0.12659688f, -0.06326151f, 
    -0.09208898f, 0.09279158f, 0.16149405f, -0.10151819f, 0.21512547f, 0.04335687f, 0.14954183f, -0.02273379f, 
    -0.09139072f, -0.05842364f, 0.03967616f, -0.02604337f, -0.05954154f, -0.09796026f, 0.08571381f, 0.05037908f, 
    -0.08674606f, -0.04783813f, 0.10663003f, -0.02611736f, 0.01783144f, -0.06242628f, 0.09535155f, 0.06018529f, 
    -0.07197765f, -0.14515933f, 0.00140874f, 0.01589179f, -0.02121312f, -0.07409690f, -0.00808673f, 0.03183843f, 
    0.05735426f, 0.15919895f, 0.03657871f, -0.06536787f, 0.03893930f, 0.09423468f, -0.18820404f, 0.16118951f, 
    -0.09573051f, -0.02351347f, -0.06702857f, 0.03541053f, -0.11127756f, 0.14238451f, -0.08480079f, 0.11253830f, 
    0.04878930f, 0.12740283f, 0.06919061f, 0.06430139f, -0.06101559f, -0.01548524f, -0.17190108f, -0.07232988f, 
    0.11212912f, 0.14172718f, 0.26387712f, 0.39509460f, 0.04332184f, 0.07872172f, -0.04525379f, 0.20076239f, 
    -0.13465551f, 0.03247320f, -0.02344778f, 0.21627818f, 0.06477865f, -0.01465476f, -0.00621534f, -0.09367393f, 
    0.16104156f, -0.00303136f, 0.08954162f, -0.04124005f, -0.00232447f, 0.04566631f, -0.05155047f, 0.05469471f, 
    -0.10582446f, -0.09875469f, 0.04001652f, -0.02488012f, 0.10164734f, 0.05250924f, -0.20674627f, 0.02977703f, 
    0.06749400f, 0.09223469f, -0.02318324f, 0.06345128f, -0.06939925f, -0.04471690f, -0.07032571f, -0.03634075f, 
    0.05609650f, -0.01574416f, -0.07242593f, -0.20250803f, 0.09659072f, -0.02370640f, 0.02081614f, 0.02617818f, 
    -0.21499135f, 0.05100021f, -0.00182700f, -0.11025452f, -0.05074668f, 0.02292237f, 0.03699008f, 0.15772104f, 
    0.13108227f, 0.07363679f, -0.00461927f, 0.01093180f, 0.05521980f, -0.02157246f, -0.02900188f, -0.09600739f, 
    0.09616157f, -0.00492214f, -0.02496159f, -0.06198004f, -0.13417625f, 0.04513608f, 0.03355931f, 0.01573887f, 
    -0.13309680f, 0.15328841f, 0.04100421f, 0.09017505f, -0.00564984f, -0.03424545f, 0.23174258f, 0.05807060f, 
    -0.06141901f, -0.09404410f, -0.17220329f, 0.06934197f, 0.10180487f, 0.14743055f, -0.01248328f, 0.35800868f, 
    -0.10997812f, 0.30165944f, 0.06948715f, -0.07391347f, 0.03918932f, 0.06330162f, 0.11429691f, -0.05538053f, 
    0.11413890f, 0.02172552f, -0.13322496f, -0.00480916f, 0.24104862f, -0.00310430f, 0.22859181f, 0.18068300f, 
    -0.12163577f, 0.15912710f, 0.08184628f, -0.03375732f, -0.04238145f, 0.06843614f, 0.01077719f, 0.02104909f, 
    -0.58976710f, 0.07742857f, 0.30867219f, -0.03921648f, 0.02090360f, 0.17728698f, -0.03546636f, 0.14972185f, 
    -0.09509746f, 0.11938277f, -0.01226380f, 0.16485640f, -0.01700408f, 0.07065471f, 0.07011982f, -0.06440308f, 
    -0.21165395f, -0.17379953f, -0.00405923f, -0.03429108f, -0.02064126f, -0.01223240f, -0.13568629f, -0.02178952f, 
    0.15351482f, 0.27930996f, 0.13225810f, -0.15998155f, 0.03274251f, -0.08098081f, 0.07155400f, -0.02024421f, 
    -0.06458215f, 0.03439268f, -0.05892863f, 0.07296474f, -0.37165990f, 0.01764119f, -0.08524606f, 0.10321707f, 
    0.03157201f, 0.10235971f, -0.00706408f, -0.05486483f, -0.01671322f, 0.21121556f, 0.03584220f, 0.03045716f, 
    0.17167790f, -0.10911343f, 0.09793349f, 0.11550239f, -0.03028074f, -0.02813688f, 0.07791245f, 0.16364530f, 
    -0.01127862f, -0.01321706f, 0.01815700f, -0.25266737f, 0.02052736f, 0.13283637f, -0.16214743f, 0.15808283f, 
    -0.02124456f, -0.09882317f, -0.07321092f, -0.10669430f, -0.07583710f, -0.06633393f, -0.06679233f, -0.03906883f, 
    -0.39088294f, 0.23595141f, 0.09441824f, -0.01763149f, -0.06871179f, -0.02025466f, -0.11693197f, -0.06670494f, 
    0.05767618f, -0.01968307f, 0.10124599f, -0.06875993f, 0.49490473f, -0.06151336f, 0.03300777f, -0.02184047f, 
    -0.00954433f, -0.03757869f, 0.08713702f, -0.01124803f, -0.00822686f, -0.04784793f, 0.07823147f, 0.09047265f, 
    0.35417199f, -0.01213275f, 0.07558755f, -0.06321705f, 0.23689951f, 0.03538774f, -0.02530150f, -0.09897522f, 
    0.08723125f, 0.22122231f, 0.02377168f, 0.14937313f, 0.05379684f, -0.02883420f, -0.33352536f, 0.47408360f, 
    0.13567488f, 0.11685343f, 0.03220737f, 0.00022120f, -0.09235234f, -0.02856268f, 0.07257922f, 0.20715451f, 
    0.01510967f, 0.01188763f, -0.01993638f, -0.00456820f, -0.00474058f, -0.01196300f, 0.03574381f, 0.01076391f, 
    0.03368835f, 0.00597680f, 0.00764255f, -0.00612183f, -0.04100522f, 0.00105479f, -0.01474225f, -0.00508283f, 
    -0.01050065f, -0.01987057f, -0.02944229f, 0.02013630f, 0.01558684f, -0.02350855f, 0.00726546f, 0.00545941f, 
    -0.02627514f, -0.00484220f, -0.02914909f, 0.00581306f, -0.02278436f, -0.02189063f, -0.00850909f, 0.01178622f, 
    0.02682383f, -0.03493376f, -0.00683148f, -0.02049023f, -0.04225512f, 0.01041393f, -0.03023040f, -0.00769423f, 
    0.01874105f, 0.02627339f, -0.03983002f, -0.00391753f, -0.00162259f, -0.00532872f, -0.03428352f, 0.00468868f, 
    -0.02459599f, 0.02074390f, -0.03310365f, -0.04582506f, -0.01073558f, 0.02468050f, -0.02325175f, -0.00197630f, 
    -0.02892698f, 0.00607283f, 0.02232823f, -0.04540454f, -0.01601386f, -0.00261650f, -0.01382728f, -0.02891363f, 
    -0.00449065f, 0.01656293f, 0.01580787f, 0.02414658f, -0.01022005f, 0.00797478f, 0.02541464f, -0.01811032f, 
    -0.03301832f, -0.01128768f, -0.01010022f, 0.02841585f, -0.01548623f, -0.02766983f, -0.04252397f, -0.00331963f, 
    0.01878655f, -0.03666402f, 0.02393562f, -0.02753469f, -0.00145198f, 0.01299442f, 0.03096491f, 0.03764328f, 
    -0.02061960f, 0.02312874f, -0.02499971f, -0.03711315f, -0.02830821f, 0.01057693f, -0.02506978f, 0.00134325f, 
    -0.03661532f, -0.01132295f, 0.00506374f, -0.03929013f, -0.02743718f, 0.01187273f, -0.02998490f, -0.00943123f, 
    -0.00198492f, -0.04320516f, 0.02526002f, 0.01274206f, 0.01640207f, -0.03231869f, -0.01052612f, -0.00520398f, 
    -0.01369832f, -0.03038375f, -0.00702323f, -0.02903936f, -0.04208865f, 0.00480414f, -0.02070228f, 0.02552735f, 
    -0.02564639f, 0.02148658f, -0.02170110f, 0.00290935f, -0.04277523f, 0.01006444f, 0.02197146f, -0.00482197f, 
    -0.03307888f, -0.01738958f, 0.00671236f, -0.02342692f, -0.03852588f, -0.02030323f, -0.01653013f, 0.00963161f, 
    -0.03761866f, -0.01948812f, 0.02351718f, -0.03604421f, -0.00717100f, 0.00219785f, 0.01548809f, -0.03546752f, 
    -0.01920604f, -0.01306019f, -0.02805548f, 0.00826071f, -0.01963497f, -0.01497825f, -0.01267427f, -0.00340837f, 
    0.03117824f, -0.00921844f, -0.02917880f, 0.02685634f, -0.02576701f, 0.01437915f, -0.04122890f, -0.02776169f, 
    0.00973131f, 0.02945463f, -0.02337555f, 0.00662805f, 0.01762804f, -0.01016918f, -0.03978731f, 0.00287898f, 
    -0.01166579f, -0.02182760f, 0.00754189f, 0.02563474f, 0.01431776f, 0.02781858f, -0.03882256f, -0.02692819f, 
    -0.01723536f, -0.02345209f, 0.02220453f, 0.02495602f, 0.02560722f, 0.01152447f, 0.01156669f, 0.00488517f, 
    -0.01848518f, -0.03424570f, 0.01337799f, 0.02689417f, -0.01558239f, -0.01922031f, -0.04273202f, -0.03185628f, 
    -0.01381044f, 0.01323224f, -0.02337698f, 0.00833256f, 0.00436283f, 0.01914863f, 0.00554096f, -0.03356018f, 
    -0.01310437f, -0.01448525f, 0.00398621f, 0.02556983f, -0.03136886f, -0.02512369f, 0.01444354f, -0.00914185f, 
    0.01639018f, -0.01016861f, 0.02358877f, -0.04241049f, -0.02610298f, -0.02363180f, -0.01023720f, -0.00772297f, 
    0.01528933f, 0.01238477f, 0.00320111f, -0.02498116f, -0.00333561f, -0.01714666f, 0.01505782f, 0.01926370f, 
    0.00093147f, 0.02003676f, -0.00982788f, -0.03976399f, 0.01626049f, 0.00874223f, -0.00871286f, -0.00994525f, 
    -0.00471424f, 0.02322501f, -0.00020805f, -0.00881415f, 0.00936450f, 0.00962586f, 0.02082264f, -0.01145658f, 
    0.01019550f, -0.03818514f, -0.01830463f, 0.01517150f, -0.00688172f, 0.00348981f, 0.00423892f, 0.01146576f, 
    0.02711614f, -0.01262213f, 0.00289044f, 0.01416307f, 0.00057778f, -0.00014486f, -0.02378000f, -0.03288395f, 
    -0.03809672f, -0.00809360f, 0.00477838f, 0.00019062f, 0.01636140f, -0.03024301f, 0.00595021f, -0.03117566f, 
    -0.03888088f, 0.02672877f, 0.02269669f, 0.02016363f, -0.00378997f, -0.03065407f, 0.00309360f, 0.02249034f, 
    -0.00972939f, -0.02645239f, -0.00406884f, -0.01752071f, -0.02281569f, -0.01465263f, -0.00467771f, -0.04362872f, 
    -0.00995306f, -0.03785202f, -0.01939445f, 0.00801896f, -0.01795972f, 0.01679005f, -0.00745146f, -0.03047412f, 
    -0.01667650f, 0.01603977f, 0.01410072f, 0.02798188f, 0.00780014f, -0.02493673f, 0.02242604f, -0.01283896f, 
    0.03141724f, 0.02493741f, -0.04241927f, 0.01697312f, 0.02022538f, -0.04195401f, -0.01780393f, 0.02894723f, 
    0.02227403f, -0.02706636f, -0.01695840f, -0.00357934f, 0.02946243f, -0.02427363f, -0.01937702f, 0.01956475f, 
    -0.03070194f, 0.00333395f, -0.03347921f, -0.02671343f, -0.00398595f, -0.01527411f, 0.00962081f, -0.02282194f, 
    -0.04228389f, -0.00478896f, 0.00681980f, -0.03678334f, 0.01036052f, 0.01008810f, 0.02445162f, -0.02818823f, 
    -0.01061620f, 0.01321066f, 0.01505005f, -0.00400032f, 0.01846334f, -0.00112165f, 0.01119371f, 0.00563273f, 
    -0.01083839f, 0.01013186f, -0.01849468f, 0.00247887f, 0.02080297f, -0.01932878f, 0.00436424f, -0.00077987f, 
    -0.00083788f, -0.03121446f, -0.03163971f, 0.01290529f, -0.00991639f, -0.00966642f, -0.00316671f, -0.03480954f, 
    0.02992024f, -0.03383695f, 0.02391623f, -0.01121920f, -0.03487411f, 0.00523275f, 0.01995897f, -0.03641821f, 
    -0.01894663f, -0.03344830f, 0.02020513f, -0.00274305f, -0.01915199f, -0.01349250f, 0.01477432f, 0.01838756f, 
    -0.02035353f, -0.03815292f, -0.02183956f, -0.00199829f, 0.01997785f, -0.03734337f, 0.02392124f, 0.02351960f, 
    -0.00852595f, 0.02770080f, -0.00518961f, -0.01683238f, 0.01321179f, -0.00695881f, -0.03581510f, -0.01403035f, 
    0.01239730f, -0.02674733f, -0.02504234f, 0.00128252f, -0.01516284f, 0.00876932f, 0.02146411f, -0.00370503f, 
    0.00444556f, 0.00196362f, 0.00956486f, -0.03886286f, 0.02964565f, -0.03097009f, -0.02636288f, -0.03415468f, 
    -0.00472699f, 0.02722591f, -0.02816012f, 0.01345465f, 0.02838710f, 0.00581564f, 0.00906009f, 0.01292030f, 
    -0.01269926f, -0.00345711f, -0.03238958f, 0.03719221f, -0.01798364f, -0.04515314f, -0.02994734f, -0.03866351f, 
    0.01575130f, 0.00369235f, -0.02325718f, 0.00925668f, 0.01013127f, -0.03760831f, -0.02110204f, -0.00264019f, 
    0.00306658f, -0.03782754f, -0.03383021f, -0.03490780f, -0.00026518f, -0.03379700f, 0.01991948f, 0.02069271f, 
    -0.03267947f, 0.01809878f, 0.01002102f, 0.00279948f, 0.01922943f, 0.03030472f, -0.01967416f, -0.01576228f, 
    -0.00136043f, -0.00244145f, 0.01977291f, -0.02001388f, -0.03379113f, -0.00603656f, 0.02331524f, 0.01265876f, 
    -0.00592359f, -0.01000153f, -0.03646407f, -0.01899457f, 0.01387728f, -0.00199472f, -0.03543186f, -0.02030163f, 
    0.01679828f, 0.02624227f, -0.00374876f, -0.01584357f, 0.01749818f, 0.02109957f, -0.01107407f, -0.00028090f, 
    0.00376735f, -0.01344548f, 0.02058040f, 0.00783306f, -0.03454690f, 0.00994896f, -0.03494904f, -0.01030887f, 
    0.01591568f, 0.00432519f, 0.00728836f, 0.01045059f, 0.00021368f, -0.03882612f, -0.02320857f, -0.04486149f, 
    0.01359006f, -0.02812508f, -0.01494939f, -0.01851789f, -0.00376961f, -0.02052164f, 0.02490201f, -0.03542088f, 
    -0.00487250f, -0.02538834f, 0.02545410f, 0.01362177f, -0.02975873f, 0.00009025f, -0.00886504f, -0.03420245f, 
    -0.03028041f, -0.04202350f, -0.03882144f, 0.02136132f, -0.01628274f, 0.01280769f, 0.02579340f, 0.00155129f, 
    0.02213841f, -0.04179531f, 0.01397003f, 0.01508979f, -0.02422416f, 0.01768094f, 0.01312971f, -0.03378256f, 
    0.00470196f, -0.00330199f, -0.03781087f, -0.01456914f, -0.03546825f, 0.00915600f, 0.01723252f, 0.01563950f, 
    -0.02891033f, -0.02939347f, -0.03935483f, -0.01972838f, 0.00899142f, 0.02643989f, -0.01286835f, -0.02221807f, 
    0.01971311f, 0.02219927f, -0.02146525f, 0.00741775f, 0.01883898f, -0.04179401f, -0.03206096f, 0.01582492f, 
    0.01242443f, -0.02335127f, -0.02336466f, 0.00333247f, -0.02533687f, 0.01999545f, -0.01667089f, 0.01079222f, 
    0.00418121f, -0.01058546f, 0.02019823f, -0.03592253f, 0.01575312f, -0.00506540f, 0.01971099f, -0.02455262f, 
    -0.03363027f, 0.02051491f, 0.00571123f, -0.02813501f, -0.02970450f, -0.00959152f, -0.01813292f, -0.01285807f, 
    -0.02873549f, 0.01451252f, 0.00006187f, 0.02836576f, 0.02272687f, 0.00354261f, -0.01128197f, -0.02580539f, 
    -0.02112872f, -0.03568345f, 0.01479107f, 0.02110466f, 0.02520560f, 0.01696369f, -0.01702119f, 0.00077604f, 
    0.01797758f, 0.02907773f, -0.00515677f, -0.00461235f, -0.02279656f, -0.03541500f, -0.03667372f, -0.00478784f, 
    0.02217450f, 0.00839655f, -0.02693268f, 0.02354986f, 0.00379948f, 0.01869310f, 0.02106066f, 0.02412064f, 
    0.00683933f, -0.01913353f, -0.02491253f, -0.03522965f, 0.03465871f, -0.03976422f, 0.01980497f, 0.02164209f, 
    0.02374731f, 0.01299418f, -0.03166001f, 0.00872197f, -0.03610947f, 0.00752530f, -0.02670329f, 0.01585607f, 
    -0.02574759f, 0.02373745f, 0.02198091f, -0.02974384f, 0.00564661f, -0.00291155f, -0.01627098f, 0.02591975f, 
    -0.03425071f, -0.03925653f, 0.00592995f, 0.02262420f, 0.01947492f, 0.01837196f, 0.01757947f, -0.04101464f, 
    -0.02020001f, -0.01121547f, 0.00129040f, 0.03109318f, 0.01115583f, -0.02041549f, 0.02136107f, 0.00981030f, 
    -0.02545146f, -0.01579256f, 0.01465314f, -0.03627122f, -0.04337110f, -0.00090322f, -0.02606682f, -0.01404069f, 
    0.01894297f, -0.00721143f, 0.01669042f, 0.00931909f, -0.02901709f, -0.01406276f, 0.00346840f, -0.03344816f, 
    0.02493898f, -0.00547908f, -0.01071207f, 0.01910196f, -0.02448175f, -0.03950292f, -0.02013132f, -0.01948447f, 
    0.00511270f, 0.00273519f, -0.02354892f, 0.01391386f, -0.03096787f, -0.00078166f, 0.01432694f, -0.02145627f, 
    -0.00725946f, -0.03638628f, -0.03106232f, 0.02352220f, -0.00973124f, -0.01191509f, 0.02652395f, -0.02685992f, 
    -0.00226957f, 0.01469366f, -0.02961644f, -0.03438414f, 0.02187114f, -0.00967915f, -0.04304911f, -0.02641274f, 
    -0.03179453f, 0.01348895f, -0.00118481f, 0.02095592f, -0.02649374f, -0.00195078f, 0.02191164f, -0.04506836f, 
    -0.02895899f, -0.03379096f, -0.02301594f, -0.04104138f, 0.02976630f, -0.01713484f, -0.01467637f, 0.00616629f, 
    0.01288950f, -0.02277312f, -0.00704783f, -0.00092500f, -0.03427686f, -0.01647759f, 0.02305997f, 0.02558801f, 
    -0.00263175f, -0.04265986f, 0.02061737f, -0.02642912f, 0.01562196f, -0.00240892f, -0.01004072f, -0.02436235f, 
    -0.00362461f, -0.02237178f, -0.03786467f, -0.02529630f, -0.01415113f, -0.03039067f, -0.03300155f, 0.00137629f, 
    -0.03853518f, -0.00316953f, 0.02151041f, -0.00858991f, -0.00422747f, 0.00963526f, -0.03940412f, 0.02363860f, 
    -0.00068520f, -0.00594041f, -0.01874171f, 0.00252353f, 0.00378609f, -0.02925348f, -0.01689553f, 0.02956348f, 
    -0.03443855f, 0.00955013f, -0.01284320f, 0.02545629f, -0.00479744f, 0.00713784f, -0.02981460f, -0.00648398f, 
    -0.04659186f, -0.03007735f, 0.01398247f, -0.03553596f, -0.00093197f, -0.00094974f, -0.01067887f, -0.01279411f, 
    -0.01968757f, 0.02393974f, 0.00356872f, -0.01343757f, -0.00069744f, -0.01731126f, -0.03207016f, 0.01175709f, 
    0.00453512f, 0.01059044f, -0.03809391f, 0.02209826f, 0.02520258f, -0.01322403f, -0.02286462f, -0.02036688f, 
    -0.04124523f, 0.19435391f, 0.05730630f, 0.03783961f, -0.02298798f, 0.02183419f, 0.04936735f, 0.06075751f, 
    0.00387105f, 0.10616478f, 0.06148271f, -0.01601152f, -0.12837529f, -0.00533700f, -0.03261758f, 0.00831815f, 
    -0.09458925f, -0.08267020f, -0.04935018f, 0.01889656f, -0.05018999f, 0.20790981f, -0.09869328f, 0.09581009f, 
    0.08744144f, -0.07977525f, 0.24008033f, 0.13981068f, 0.12147725f, 0.07521999f, -0.01208952f, 0.02736623f, 
    0.01029120f, 0.15639684f, 0.02999960f, 0.02849075f, 0.01608348f, 0.00745544f, -0.05118043f, 0.00121397f, 
    0.00463129f, 0.04508685f, 0.10611576f, 0.13994731f, -0.11195230f, 0.11237643f, -0.01859481f, 0.01167560f, 
    -0.12111820f, -0.09395196f, -0.07968289f, -0.17348585f, -0.11522163f, -0.05254601f, 0.01290441f, -0.11819131f, 
    -0.11412410f, -0.07886463f, -0.12732525f, -0.16327347f, 0.16529642f, 0.04222175f, -0.08484031f, -0.05449420f, 
    0.02163208f, 0.08990713f, 0.05093183f, -0.03566647f, 0.02323452f, 0.05622771f, 0.04194293f, 0.15922607f, 
    0.13986646f, 0.03155503f, 0.13789748f, 0.02971138f, 0.02303130f, 0.01771792f, -0.06041371f, 0.06265868f, 
    -0.02182173f, 0.18712336f, -0.11805751f, -0.16973650f, 0.09708973f, 0.00070703f, 0.00923830f, 0.18203171f, 
    0.01338638f, 0.00903542f, -0.00982143f, 0.21573322f, 0.03283878f, 0.00533500f, 0.04408845f, 0.07701965f, 
    0.25859278f, -0.19780888f, 0.18828948f, 0.10637422f, 0.02111417f, 0.14823467f, 0.08506754f, 0.11002688f, 
    0.00039308f, 0.04409260f, -0.04391694f, 0.01024693f, 0.52573645f, 0.12097190f, 0.21576151f, 0.08715787f, 
    -0.04955648f, -0.10026203f, 0.04498285f, 0.07588320f, 0.01314340f, 0.05628737f, 0.00183111f, 0.08950221f, 
    -0.29233021f, 0.21706891f, -0.11511239f, 0.17931387f, -0.01997562f, 0.05698837f, 0.00826379f, -0.03264306f, 
    0.06440905f, 0.12144751f, 0.02127029f, -0.03859575f, -0.11194383f, 0.10900176f, 0.06030033f, -0.06991517f, 
    -0.00674742f, 0.02549152f, -0.01599313f, 0.03308206f, -0.00896875f, 0.14241087f, -0.04791825f, -0.05369497f, 
    -0.06621373f, -0.01170917f, -0.14906807f, 0.07658473f, 0.03038890f, -0.01308224f, -0.02251218f, -0.07754043f, 
    0.03781363f, 0.10186957f, -0.00488450f, -0.04987850f, -0.07362400f, -0.12414269f, -0.11001999f, -0.06481234f, 
    -0.07029258f, -0.04131629f, -0.03004313f, 0.03819940f, 0.10499655f, 0.05944322f, 0.09800139f, 0.04481630f, 
    -0.21710788f, -0.01731689f, -0.03376156f, 0.06263101f, -0.19746448f, -0.01391452f, -0.03100940f, -0.04083966f, 
    -0.05157673f, 0.09716620f, 0.01028374f, 0.08564971f, -0.00313823f, -0.04291039f, -0.20504408f, 0.10115571f, 
    -0.03608644f, -0.07204125f, 0.11705960f, -0.14652097f, -0.05575394f, 0.00094070f, 0.04732803f, -0.01608894f, 
    -0.02431747f, 0.15711130f, 0.15994173f, -0.15888682f, -0.02778298f, -0.09098189f, -0.04964650f, -0.04555776f, 
    -0.06919036f, 0.02456997f, -0.03944764f, 0.10451998f, -0.10369691f, 0.05624435f, -0.00342290f, -0.02738505f, 
    0.00758577f, -0.02655704f, 0.06511534f, -0.03089391f, -0.05341671f, 0.01112365f, 0.02835660f, 0.15788478f, 
    0.02961455f, 0.11214317f, -0.02497585f, 0.34908122f, 0.07938389f, 0.05234203f, 0.06683171f, 0.10917306f, 
    0.00578031f, 0.15895051f, -0.01231898f, 0.01633235f, -0.18010758f, -0.00083927f, -0.21342261f, -0.04816339f, 
    -0.06519739f, -0.09840236f, 0.00670056f, -0.07203557f, -0.01939547f, -0.03430508f, 0.03466105f, 0.17820062f, 
    -0.11036400f, 0.04204423f, -0.05669013f, 0.13787213f, -0.10717077f, -0.00360823f, 0.10543185f, -0.00582749f, 
    -0.17228603f, 0.12611212f, -0.00374228f, -0.00688695f, -0.20856738f, -0.12511954f, 0.07158642f, -0.12428395f, 
    0.01952152f, -0.09767149f, -0.01630863f, -0.11645087f, -0.03681369f, -0.06095713f, 0.01897014f, -0.04506714f, 
    0.15883937f, 0.04964659f, 0.07523002f, -0.09874615f, -0.20449498f, -0.02012868f, -0.09898949f, -0.01181865f, 
    -0.06115223f, 0.03574175f, 0.01785571f, 0.07589641f, -0.33222720f, 0.35681948f, 0.06727368f, 0.03616283f, 
    -0.08824063f, -0.02678503f, -0.00026212f, 0.00313182f, -0.02615806f, 0.16487387f, 0.15384218f, 0.02828324f, 
    -0.09479086f, -0.13413608f, -0.10178418f, -0.06191876f, 0.02926397f, -0.02848751f, -0.00000170f, -0.00725735f, 
    -0.02785213f, 0.02265955f, -0.01891258f, 0.02834328f, -0.21677367f, 0.05735292f, 0.08556480f, 0.28401560f, 
    0.08940082f, -0.08197006f, 0.13788396f, -0.01987794f, 0.00735131f, 0.09473065f, 0.05478038f, 0.05427989f, 
    -0.23668101f, 0.14508060f, -0.12176920f, -0.05049532f, -0.04120217f, 0.07823170f, 0.02004474f, 0.06217896f, 
    -0.04446092f, 0.01421287f, -0.06035947f, -0.04124870f, 0.23412408f, 0.03758902f, 0.09684871f, -0.11418221f, 
    -0.02496611f, 0.02211808f, -0.09140284f, 0.03442634f, 0.01094109f, 0.01228901f, 0.09166132f, 0.23259698f, 
    -0.19652337f, -0.28836778f, 0.19109295f, -0.10168288f, 0.07052305f, 0.13507661f, 0.07091666f, -0.11494529f, 
    -0.02821424f, -0.00668692f, -0.03637563f, 0.14974838f, 0.05805878f, 0.06065850f, 0.06924860f, 0.14194521f, 
    0.08410685f, 0.04374615f, 0.02039072f, 0.11228759f, -0.05210672f, -0.04549013f, -0.00498320f, 0.06397847f, 
    -0.09666812f, 0.08554563f, -0.03955435f, -0.01443106f, 0.03039689f, 0.15742178f, 0.13866319f, -0.02009668f, 
    -0.14484760f, 0.03991665f, -0.10820813f, -0.04234001f, 0.14500421f, 0.40726534f, -0.25284928f, 0.03755902f, 
    0.01870102f, 0.01856091f, 0.05794612f, -0.00421098f, 0.06193035f, 0.02240913f, 0.10967253f, 0.07875045f, 
    -0.07709102f, 0.02484717f, -0.16442616f, 0.08185446f, 0.02727347f, -0.01847934f, -0.01470290f, 0.13022555f, 
    -0.12036899f, -0.09115132f, 0.01161705f, 0.01222498f, 0.39724761f, 0.09688242f, 0.08794366f, 0.22505555f, 
    0.03032251f, 0.12854794f, 0.12225526f, 0.19824494f, -0.02049344f, 0.13058189f, 0.02405140f, 0.04149992f, 
    -0.15615743f, -0.25274411f, -0.14850843f, -0.16493699f, 0.01264872f, -0.07156774f, -0.06103653f, -0.09567936f, 
    0.06860957f, -0.00360010f, -0.03237926f, 0.02301769f, -0.09301848f, -0.13671698f, -0.07486413f, -0.19890574f, 
    -0.14079945f, -0.15681446f, -0.09772749f, -0.09973513f, -0.13457395f, -0.09797676f, -0.05202501f, -0.07335650f, 
    -0.11598798f, 0.04954935f, -0.20811109f, 0.13920590f, 0.08052476f, 0.06564924f, -0.00238469f, 0.26390675f, 
    0.03031478f, 0.02960674f, 0.00818277f, -0.01807658f, -0.11483748f, 0.12428063f, -0.06802882f, 0.04024426f, 
    -0.11558586f, -0.11068372f, 0.04219727f, -0.04695985f, 0.06515519f, -0.03571415f, 0.18903063f, 0.11703388f, 
    -0.21852732f, 0.17462549f, 0.14509043f, 0.04173864f, 0.05656657f, 0.08541202f, 0.07111534f, -0.02359260f, 
    0.05607527f, 0.04225942f, 0.08099141f, 0.05308079f, 0.11511774f, 0.08527470f, 0.03346443f, 0.12748247f, 
    -0.05230159f, 0.10459552f, -0.11046459f, 0.00275730f, -0.00330446f, 0.02861606f, -0.06318419f, 0.11927172f, 
    -0.20068093f, 0.20855616f, 0.13822529f, -0.11363633f, 0.03834567f, 0.14694838f, -0.13440311f, 0.05313035f, 
    0.03699603f, -0.03735155f, 0.01787274f, 0.04251339f, 0.14487945f, 0.01470660f, 0.02482311f, 0.17205662f, 
    -0.02956464f, 0.07062747f, 0.05848831f, 0.04374864f, 0.03214481f, -0.02096142f, 0.07404181f, -0.08255012f, 
    -0.17060779f, -0.01654190f, 0.00409540f, 0.04777355f, -0.12176976f, 0.01773731f, 0.01600456f, 0.05462621f, 
    -0.11454342f, -0.04931026f, -0.13125545f, -0.12834972f, -0.29233408f, 0.32402295f, -0.21504535f, 0.28220585f, 
    -0.02143223f, 0.04502594f, 0.01499328f, 0.00689868f, -0.06353291f, 0.12777689f, -0.01769358f, 0.03810991f, 
    -0.14324112f, -0.05281928f, 0.10072605f, -0.05578911f, 0.00868147f, 0.01091146f, 0.02734857f, -0.04697532f, 
    0.07611767f, -0.01076071f, -0.00273310f, -0.13677587f, -0.04533102f, -0.09906591f, -0.21065299f, -0.14038531f, 
    0.01049008f, -0.05780385f, -0.03629357f, -0.09369067f, -0.00797072f, 0.09565761f, 0.02076495f, 0.05389436f, 
    -0.06534186f, -0.03940621f, 0.03877719f, -0.06171290f, -0.11235742f, 0.02177103f, -0.05249206f, 0.03406932f, 
    -0.08570037f, 0.03252965f, 0.04627158f, 0.05155506f, -0.16682833f, 0.06755583f, -0.06038274f, 0.14315838f, 
    0.05819687f, -0.01228310f, -0.02026421f, -0.08219181f, -0.04235772f, -0.01808519f, 0.06345662f, 0.00870060f, 
    -0.33334044f, -0.02775048f, -0.12517391f, 0.10723455f, -0.10865186f, -0.05016114f, -0.05160493f, -0.09558941f, 
    0.11814697f, 0.12588835f, 0.02422642f, 0.10329642f, 0.01834110f, 0.02790281f, 0.13485883f, 0.09658089f, 
    -0.00540593f, 0.01247909f, 0.03437295f, 0.07183266f, -0.05817002f, -0.04149053f, 0.01188417f, -0.02076861f, 
    -0.07501086f, 0.07204876f, -0.02904364f, -0.13281398f, -0.00421765f, 0.00981651f, 0.05962939f, 0.11223756f, 
    -0.14420518f, 0.02844951f, 0.06221654f, -0.00117183f, -0.18087570f, -0.35502294f, 0.13845541f, 0.00084326f, 
    0.09761065f, -0.02080330f, 0.06193564f, 0.06284551f, -0.03592270f, 0.10969975f, -0.02084601f, 0.00983273f, 
    0.13970220f, -0.15324256f, -0.00026113f, -0.11130792f, 0.02620606f, -0.07272547f, 0.06291233f, 0.03579054f, 
    0.00755157f, 0.01524604f, 0.05811429f, 0.13866164f, -0.21883942f, -0.35514897f, 0.22746989f, 0.01422967f, 
    0.05789466f, -0.08951691f, -0.07188690f, -0.12259251f, -0.07421389f, -0.06313601f, 0.03130699f, 0.05214716f, 
    -0.02014042f, 0.11455072f, 0.10681532f, 0.10208796f, -0.04152183f, 0.12426042f, -0.03087640f, 0.16631706f, 
    0.09179908f, 0.07747966f, -0.03573648f, -0.01920914f, -0.03628720f, -0.03646553f, -0.03158355f, 0.08900797f, 
    0.02584254f, 0.04012774f, -0.08275237f, -0.04261269f, 0.06440890f, -0.03668866f, -0.04242173f, 0.02120152f, 
    0.01114725f, 0.00205291f, 0.14786021f, 0.06679060f, -0.01162355f, 0.06723545f, 0.06529228f, 0.02432054f, 
    -0.00039125f, 0.10331820f, 0.04097315f, 0.01492090f, -0.03781258f, 0.08737351f, -0.20230818f, -0.16351981f, 
    0.04146465f, 0.02468249f, 0.05073765f, -0.06910834f, 0.18446389f, 0.02097795f, -0.00572176f, -0.05292835f, 
    0.06694866f, -0.12871195f, -0.04334439f, -0.10662582f, -0.04859912f, -0.10533706f, 0.02956690f, -0.02328882f, 
    0.09137539f, -0.00425143f, 0.13704883f, -0.00331536f, -0.26098222f, -0.00826078f, 0.11755921f, 0.10656511f, 
    -0.04149009f, -0.00136701f, -0.00262655f, 0.03018213f, -0.23191142f, 0.03840420f, 0.00273588f, -0.02198814f, 
    -0.03673653f, 0.14701176f, -0.12088265f, 0.05118809f, -0.01610260f, 0.00942962f, 0.02208197f, 0.05593628f, 
    0.05311270f, 0.02068174f, 0.16997546f, 0.06122749f, 0.52422649f, -0.06458742f, 0.21936549f, -0.12168839f, 
    0.07643735f, 0.04228130f, 0.07765406f, 0.21831937f, -0.01984892f, 0.00359794f, -0.00008539f, 0.04817399f, 
    0.22455208f, 0.07476081f, 0.08327404f, 0.08789844f, 0.04399213f, 0.08342005f, 0.11330389f, 0.10581882f, 
    -0.00593917f, 0.03556456f, 0.01019936f, -0.11465432f, 0.01624249f, 0.19642636f, -0.31413075f, 0.07369802f, 
    -0.02259140f, 0.00178174f, 0.08871697f, -0.04885742f, 0.08777270f, 0.09002290f, 0.10851243f, 0.01770872f, 
    0.01968528f, -0.01046799f, 0.02210070f, -0.03241835f, -0.02974287f, -0.00075083f, 0.01959641f, 0.02516392f, 
    -0.03109782f, -0.03358763f, -0.03434884f, -0.03076007f, -0.00624771f, -0.02665312f, -0.00558513f, -0.02933044f, 
    -0.02339842f, -0.01317390f, 0.00065669f, -0.00035788f, -0.00383787f, -0.01156890f, -0.01722019f, -0.01432486f, 
    0.02365698f, -0.03249791f, -0.02523268f, 0.00180317f, 0.00849481f, 0.01862883f, -0.03363227f, 0.02106969f, 
    0.00651335f, 0.01094541f, -0.02629369f, 0.02688267f, -0.02812166f, -0.00505872f, -0.01560304f, 0.02230672f, 
    -0.00823072f, -0.03075421f, -0.03407969f, 0.00726716f, -0.03326659f, -0.04497039f, 0.01050791f, -0.00189898f, 
    0.00487564f, 0.00355869f, -0.01112999f, -0.00518775f, 0.00883945f, 0.00299037f, 0.03043494f, 0.01600817f, 
    0.01282156f, 0.03104772f, 0.03363765f, -0.02161020f, -0.03929042f, -0.02797370f, 0.02116930f, 0.01735372f, 
    -0.01723428f, -0.04161985f, 0.01876534f, 0.01130913f, 0.03019829f, 0.02728164f, -0.00631085f, -0.03118225f, 
    0.01880916f, 0.02291557f, -0.00735624f, -0.02786665f, -0.01735611f, -0.02481232f, 0.01087003f, -0.03293326f, 
    -0.00550401f, 0.01603423f, 0.00043063f, -0.02970853f, 0.02548392f, -0.03095021f, 0.02384019f, 0.02288872f, 
    -0.01166685f, -0.02916702f, -0.00263697f, -0.01340217f, 0.02094933f, -0.00499861f, 0.03117012f, 0.01414664f, 
    0.00712062f, 0.03030587f, 0.03133515f, -0.02165203f, 0.01895980f, 0.00931067f, 0.01615942f, -0.02565617f, 
    0.00396643f, 0.02442487f, -0.00920933f, -0.00351047f, 0.01206816f, -0.01516093f, 0.01869326f, 0.01921585f, 
    0.01105966f, 0.02059570f, 0.00981236f, 0.02796513f, 0.01086128f, 0.02008167f, -0.01637159f, 0.02104444f, 
    0.00091808f, -0.02941208f, 0.02595907f, 0.00725571f, 0.01962129f, -0.00204345f, 0.01643437f, -0.01531030f, 
    -0.00882951f, 0.00746081f, 0.00383387f, -0.01566859f, -0.00667176f, 0.01890154f, -0.02596026f, -0.00895496f, 
    -0.02494910f, 0.01336636f, -0.00074965f, 0.01233170f, -0.02730530f, 0.02249548f, -0.04261228f, -0.02751511f, 
    0.02217605f, -0.00056597f, -0.03095266f, -0.03109719f, -0.00363543f, -0.03628129f, 0.00166980f, 0.02070951f, 
    0.01449040f, -0.02780109f, -0.01478347f, 0.02904012f, -0.02192060f, -0.03416748f, 0.00708470f, -0.00170863f, 
    -0.04085619f, 0.02410447f, -0.03832623f, -0.01515277f, -0.02699429f, 0.02529292f, -0.01082097f, -0.03572238f, 
    -0.03992918f, -0.00253622f, -0.00532574f, -0.01117191f, 0.00586091f, 0.01406682f, 0.01770740f, -0.01213497f, 
    0.00761137f, 0.01891053f, 0.00161099f, -0.03420078f, 0.00221725f, -0.02251613f, 0.00795997f, -0.04161184f, 
    0.01836026f, 0.00259213f, 0.00063462f, -0.03708756f, -0.02004558f, -0.00696523f, -0.00567422f, 0.02954201f, 
    -0.02849117f, -0.02109465f, -0.01716861f, 0.02686902f, -0.03021436f, 0.01921148f, 0.01169538f, -0.02798921f, 
    0.02187689f, 0.03405015f, 0.01478247f, 0.02540208f, -0.01369844f, -0.02077994f, 0.01600296f, 0.00189743f, 
    0.02440944f, -0.00715005f, -0.01648196f, 0.00029865f, 0.02153874f, 0.03082819f, 0.00506506f, -0.02695414f, 
    0.00024092f, -0.02190411f, -0.00383306f, -0.02723949f, -0.02900562f, 0.03429629f, -0.00257806f, -0.02760305f, 
    -0.03039981f, -0.04132738f, 0.01839600f, 0.01599842f, 0.00434702f, -0.01704597f, 0.01999835f, -0.00744595f, 
    -0.01535035f, 0.01728389f, 0.03241466f, -0.02785375f, -0.02072394f, 0.00172917f, -0.00468839f, 0.00278431f, 
    0.00805344f, 0.01977986f, 0.02297475f, 0.00522112f, 0.01980088f, 0.01370903f, 0.01496299f, -0.04046898f, 
    -0.01103424f, -0.04007123f, -0.02005425f, -0.02389316f, -0.00091704f, 0.00219634f, -0.03277786f, -0.01271494f, 
    -0.02270317f, 0.02113091f, -0.00370495f, -0.00887369f, -0.01477618f, -0.00298475f, -0.00527182f, -0.01933814f, 
    -0.03113527f, -0.04098954f, -0.00356248f, 0.00980044f, -0.02387630f, -0.02467828f, -0.03086725f, -0.00981287f, 
    -0.01936038f, 0.02875861f, -0.01784227f, 0.00438939f, -0.03873575f, -0.00807476f, 0.01906892f, -0.00328278f, 
    -0.01468673f, 0.03151460f, 0.02841835f, 0.01947827f, -0.03050502f, -0.01761048f, 0.02017534f, -0.02513311f, 
    -0.01218404f, -0.03634664f, 0.01040906f, 0.00984977f, 0.03315359f, 0.01000861f, 0.02741247f, -0.00456252f, 
    0.02566368f, -0.00559262f, -0.00026215f, -0.02418967f, -0.03181761f, -0.04564385f, -0.00673616f, -0.01253115f, 
    0.02105354f, 0.00678251f, 0.02206778f, 0.00788931f, -0.02025816f, 0.01455767f, -0.03243154f, -0.03267483f, 
    0.01078631f, -0.01787330f, -0.00298143f, 0.02504107f, -0.01031305f, -0.02527933f, -0.00651251f, 0.01334968f, 
    0.00867495f, 0.00344129f, -0.00450517f, -0.02469475f, -0.00522510f, 0.01707275f, -0.04626763f, -0.00160487f, 
    0.02676783f, -0.02223089f, 0.00413019f, 0.00389391f, -0.02895624f, 0.00767046f, -0.00964676f, -0.01229591f, 
    -0.00633956f, 0.00320131f, 0.00475473f, -0.04016849f, 0.02410266f, 0.01702050f, -0.01585261f, 0.01280754f, 
    -0.03691914f, -0.00448443f, -0.01858274f, 0.03137822f, -0.03715495f, 0.00279775f, -0.02894634f, 0.01696718f, 
    -0.00794277f, -0.01590283f, 0.00227071f, 0.00434407f, -0.03842874f, 0.02412041f, -0.00989127f, 0.02333480f, 
    -0.03476452f, 0.01572737f, 0.02258920f, 0.03369502f, -0.01495443f, -0.02941266f, -0.00724310f, -0.03988080f, 
    0.00923153f, 0.00172009f, -0.01099007f, -0.02264389f, 0.00647512f, 0.01994474f, -0.03120650f, 0.01317538f, 
    -0.01195848f, 0.00267433f, -0.01724142f, 0.02368875f, -0.03009771f, 0.02390888f, 0.00673657f, 0.02502120f, 
    -0.02589779f, 0.00327986f, -0.02869787f, 0.00715911f, -0.01682307f, 0.01260848f, 0.02433910f, -0.00372174f, 
    -0.01487854f, 0.00049522f, -0.02562102f, -0.01502569f, -0.00940466f, -0.00495218f, 0.00137127f, -0.01571014f, 
    -0.02309466f, -0.01755861f, -0.01094066f, 0.02954286f, 0.02144050f, -0.01310400f, -0.00401228f, -0.02513184f, 
    -0.00846054f, 0.02339248f, -0.02402269f, 0.03049926f, 0.00991308f, 0.00647837f, -0.02667900f, -0.03263798f, 
    0.02618536f, -0.00877053f, -0.00375805f, 0.03004574f, 0.02914442f, 0.00081535f, -0.02585464f, 0.03150707f, 
    0.03714431f, 0.02158512f, 0.00246968f, -0.00763702f, -0.03730561f, -0.04587339f, -0.01223688f, 0.00484668f, 
    0.01006670f, -0.03594992f, 0.02030095f, -0.03706903f, -0.03372467f, -0.03124146f, -0.03248687f, -0.01132540f, 
    -0.01891358f, -0.00060323f, 0.02041348f, 0.00568145f, -0.00632638f, -0.02605242f, 0.00803240f, 0.00128809f, 
    -0.03540570f, -0.01861792f, -0.03395134f, -0.01734949f, 0.01052566f, -0.02257334f, -0.01749741f, 0.01753741f, 
    0.01864903f, -0.04018953f, -0.00218579f, 0.02119951f, -0.01457512f, 0.02656390f, 0.01588690f, -0.02868363f, 
    -0.02866258f, -0.03672569f, -0.02401452f, -0.00198226f, -0.00406848f, -0.02733273f, 0.01307311f, 0.01959392f, 
    0.02368067f, -0.02309829f, 0.02061664f, -0.00965851f, -0.01338325f, -0.01714773f, -0.01812032f, 0.03530140f, 
    0.03166071f, -0.01793275f, -0.00847958f, 0.00112197f, -0.01445169f, -0.01837527f, 0.00563825f, -0.00317780f, 
    -0.02475184f, -0.00380346f, -0.01087284f, -0.02419605f, -0.01319859f, -0.03303098f, -0.01599136f, -0.03062897f, 
    -0.02739077f, 0.02364541f, -0.00967788f, 0.02849810f, 0.01550813f, -0.00753472f, -0.01546971f, -0.03739604f, 
    0.01356750f, -0.01811497f, -0.00316452f, -0.03292641f, -0.00161820f, -0.01311911f, 0.01492224f, 0.02613755f, 
    -0.03669801f, -0.03162739f, 0.00609297f, -0.00300638f, -0.02875553f, -0.00118417f, 0.03434531f, 0.02186027f, 
    -0.01491842f, 0.00111384f, 0.00793361f, -0.00617595f, -0.02802071f, 0.00820715f, 0.01648923f, -0.00772439f, 
    0.00336656f, -0.02988730f, 0.00032007f, -0.02166787f, 0.03429419f, -0.02617927f, -0.02813474f, -0.03349283f, 
    -0.01106623f, 0.01702005f, -0.03038995f, 0.00265730f, 0.00407375f, -0.01870309f, 0.01880743f, -0.03311945f, 
    0.02013198f, -0.04036260f, -0.00606099f, -0.04158682f, -0.03206176f, 0.01042068f, 0.01214434f, -0.01004860f, 
    -0.02772539f, 0.01527109f, -0.03009517f, 0.00886663f, -0.00779299f, 0.02140209f, 0.01073130f, 0.00141554f, 
    -0.02311165f, 0.02261640f, -0.03055956f, -0.00959651f, -0.00395869f, 0.02354610f, 0.02725087f, -0.00046777f, 
    0.01605162f, 0.01239641f, 0.01808150f, -0.01669282f, 0.01603059f, 0.02895375f, 0.02187953f, -0.01678162f, 
    -0.01602553f, -0.04260609f, -0.01813523f, -0.00891570f, -0.00091375f, 0.01470572f, 0.02026324f, 0.01871853f, 
    0.00873232f, -0.01496591f, -0.01024353f, -0.03788186f, -0.02004805f, -0.02167468f, -0.02694733f, 0.00622009f, 
    0.00053230f, 0.02691155f, 0.02745823f, -0.00237124f, 0.03315073f, 0.02163796f, 0.01749473f, 0.01317614f, 
    -0.00829445f, -0.00761001f, -0.03141487f, 0.02677112f, 0.03138015f, 0.00392662f, 0.01430915f, -0.03248223f, 
    -0.02423213f, -0.03511976f, 0.01814062f, -0.02421130f, -0.01489659f, -0.00531198f, 0.00096460f, -0.00840521f, 
    0.00973473f, -0.00546193f, 0.00850498f, 0.01195125f, 0.02281948f, 0.00992482f, -0.03321362f, 0.02427150f, 
    -0.00452775f, 0.00074469f, -0.03981407f, 0.00281957f, 0.00035484f, -0.01183464f, -0.02744328f, 0.01205571f, 
    0.01628427f, -0.03764370f, -0.03704908f, -0.00745987f, -0.02262845f, -0.01095405f, -0.03808477f, 0.00828505f, 
    -0.02599105f, -0.04431844f, -0.00948906f, 0.01061688f, -0.03699557f, -0.00753644f, 0.01294622f, -0.00149621f, 
    0.01133233f, 0.02788193f, -0.03190316f, -0.00193341f, -0.02230946f, -0.02150965f, -0.02577256f, -0.03725232f, 
    0.01568119f, -0.00353260f, -0.01753430f, -0.01748437f, -0.01059727f, -0.00791148f, -0.00666628f, -0.00922522f, 
    -0.03496935f, -0.02444967f, -0.03223652f, -0.00327696f, -0.01447917f, 0.01796285f, 0.01873778f, -0.02838463f, 
    -0.02542712f, -0.03487809f, 0.00091370f, -0.01008279f, -0.03137591f, 0.03171146f, 0.00894404f, 0.01659627f, 
    -0.02802956f, -0.00132852f, 0.02946389f, -0.03229287f, -0.02035775f, 0.02308998f, -0.02246355f, -0.03246291f, 
    0.01050874f, 0.03104537f, 0.00786662f, -0.02123742f, -0.03860091f, -0.03663749f, -0.03616063f, -0.01826350f, 
    0.02007458f, -0.03046962f, -0.04107171f, -0.02275348f, 0.02432831f, -0.00637520f, -0.03659422f, -0.02342793f, 
    -0.01107657f, 0.01235738f, -0.00016728f, -0.01777973f, -0.01405334f, -0.03308135f, 0.01738759f, -0.02456809f, 
    -0.02093665f, 0.02971581f, -0.02883743f, -0.01455847f, -0.04019470f, -0.01142098f, -0.02626891f, 0.02765902f, 
    -0.00603943f, -0.00417610f, 0.02501005f, -0.03569230f, -0.00434006f, -0.00021106f, -0.02266871f, 0.02754590f, 
    0.02596010f, -0.03125085f, -0.00409389f, -0.03740623f, -0.01879843f, -0.03196498f, 0.00358091f, -0.02582803f, 
    -0.02300577f, -0.02314655f, -0.02279430f, -0.01988093f, 0.02598966f, 0.02250308f, -0.02372607f, -0.00510536f, 
    0.00322015f, 0.01806973f, -0.02244670f, 0.00240474f, 0.02738253f, -0.01360703f, 0.00013841f, 0.00036397f, 
    0.01992898f, -0.02055936f, -0.01346973f, -0.01453350f, 0.01224305f, -0.03844129f, 0.01332086f, -0.00386040f, 
    -0.02304888f, -0.02158178f, 0.03338600f, -0.02528847f, 0.00485317f, 0.02230190f, -0.01232633f, 0.02501833f, 
    -0.00497315f, 0.01663001f, 0.01605765f, -0.04139378f, -0.01082641f, -0.00250120f, 0.02657154f, -0.01931201f, 
    0.01981562f, -0.03480915f, 0.01089774f, -0.02992844f, 0.00532144f, -0.01314988f, 0.02877844f, -0.01092866f, 
    -0.02417051f, -0.03928298f, -0.02405418f, -0.01100453f, -0.00497870f, -0.00681672f, 0.01482993f, -0.00812532f, 
    0.00457727f, -0.00201575f, 0.00473023f, 0.01085557f, -0.02501254f, 0.03428215f, 0.02574247f, -0.00083956f, 
    -0.00998327f, -0.01679749f, -0.03384618f, 0.00918050f, 0.00220027f, 0.01165660f, 0.02275077f, -0.00760612f, 
    0.00877666f, -0.02106616f, -0.00664216f, 0.01963449f, -0.02918882f, -0.00430362f, -0.03413727f, 0.00732960f, 
    0.01291407f, -0.01278212f, 0.00498991f, -0.03247140f, 0.04061693f, 0.02526570f, -0.01958428f, 0.02104158f, 
    -0.00184014f, -0.02170118f, 0.00746210f, -0.00114665f, 0.02362951f, 0.01233119f, -0.01786178f, -0.02739423f, 
    -0.02657721f, -0.00524727f, -0.01622357f, -0.04004972f, -0.00598549f, 0.02500940f, -0.00288407f, -0.02897093f, 
    0.00201007f, -0.01310820f, -0.01313222f, 0.00399985f, 0.02354906f, 0.00274823f, -0.00348476f, -0.02424770f, 
    -0.01469803f, 0.00643803f, -0.01460188f, -0.02460326f, 0.01593292f, 0.01633718f, -0.00825237f, -0.04071957f, 
    0.01363237f, -0.01514785f, -0.01970453f, -0.02096747f, 0.02120144f, -0.03742872f, 0.01709765f, -0.02991687f, 
    -0.01641158f, 0.01042298f, -0.00169180f, -0.02606978f, -0.02816017f, -0.01431116f, -0.03401240f, -0.00351479f, 
    0.01816524f, -0.03984110f, -0.01144535f, -0.01380692f, -0.03395058f, 0.02748734f, -0.04173137f, -0.00842799f, 
    0.02424801f, 0.01734045f, -0.00593777f, -0.02246231f, -0.01492059f, 0.01152266f, -0.02448320f, -0.04166347f, 
    0.01272323f, 0.02762678f, -0.01729496f, -0.00914485f, 0.00823701f, -0.02072353f, -0.00513852f, -0.01239657f, 
    0.02392134f, -0.03449428f, 0.00132054f, 0.02238759f, 0.01030667f, 0.00629908f, -0.03741025f, -0.00810628f, 
    0.01335256f, 0.02418681f, -0.00456645f, -0.01418154f, 0.02299866f, -0.02934730f, 0.01100555f, -0.02640835f, 
    0.02110085f, -0.03269565f, 0.01346488f, -0.01622329f, 0.00129939f, -0.01501302f, 0.01760494f, -0.02556998f, 
    0.03302488f, 0.01792435f, 0.02196763f, -0.02800867f, 0.03007383f, 0.02170252f, -0.01051926f, -0.02928528f, 
    0.03945090f, 0.01939484f, 0.02414314f, 0.02287531f, 0.02429166f, -0.02110831f, -0.01358243f, -0.01938057f, 
    0.00035348f, -0.03605802f, 0.01111422f, -0.04101868f, 0.01039478f, -0.01437955f, 0.00091414f, 0.02472860f, 
    0.03757621f, 0.04005989f, 0.01991718f, 0.01926922f, -0.03089714f, -0.01984649f, 0.02299476f, 0.00508257f, 
    -0.01538714f, 0.03587702f, 0.01061310f, -0.02218370f, 0.03634374f, -0.01034306f, -0.02974088f, 0.00552115f, 
    -0.00064718f, 0.02874223f, -0.02125855f, -0.01817008f, 0.00417713f, 0.03972453f, 0.00356296f, 0.00123656f, 
    -0.03764497f, -0.00051131f, -0.03556108f, -0.02163579f, -0.02103024f, -0.01747959f, -0.01223189f, -0.02337730f, 
    0.02198108f, -0.00093548f, -0.03096330f, 0.00794896f, 0.01257420f, 0.00346003f, -0.01088559f, 0.01135330f, 
    0.01605570f, 0.01233056f, -0.00958498f, -0.01753815f, 0.02052469f, -0.03166165f, -0.02053133f, 0.02191122f, 
    -0.00588306f, 0.01825089f, -0.03455238f, 0.01073193f, 0.00304877f, 0.01209260f, 0.03082428f, -0.02695009f, 
    -0.00687241f, -0.01979221f, -0.01532462f, -0.01559182f, -0.02364009f, -0.03343403f, -0.03711016f, -0.00387807f, 
    -0.02170010f, -0.00555349f, 0.00362866f, 0.00953736f, -0.01416526f, 0.01489344f, -0.02451456f, -0.02770555f, 
    0.01919636f, 0.02328910f, 0.02775793f, -0.03677150f, 0.00806526f, -0.00025212f, -0.02829577f, -0.00398341f, 
    0.01994191f, 0.00418823f, 0.00222270f, 0.01321813f, 0.02322164f, -0.00454978f, 0.00491719f, -0.00724021f, 
    -0.02605460f, 0.02001783f, -0.01731783f, -0.02859992f, -0.00746637f, -0.02219810f, 0.00837385f, 0.02326606f, 
    -0.02133494f, -0.00206808f, -0.03724553f, 0.03979922f, -0.02515775f, -0.03749265f, -0.01037450f, -0.02485491f, 
    0.02500513f, 0.01009029f, -0.01188161f, -0.04082293f, 0.03895639f, 0.01519450f, -0.01867551f, -0.02310759f, 
    -0.01584077f, -0.01161288f, -0.01276618f, 0.01507757f, 0.02578612f, 0.00002578f, 0.01723493f, -0.00272611f, 
    -0.01224218f, -0.03333752f, -0.00159362f, -0.02436768f, -0.00999490f, 0.00428846f, -0.00859579f, 0.02295107f, 
    -0.03723336f, 0.00999701f, -0.01776383f, -0.01577266f, 0.02864894f, -0.02840776f, -0.00734681f, 0.01166306f, 
    -0.02416792f, 0.01081424f, -0.02441248f, -0.01265866f, -0.01567314f, -0.01059848f, 0.02170367f, -0.01241435f, 
    -0.01014848f, -0.03001078f, -0.00919618f, -0.01656288f, -0.02712126f, -0.02708316f, 0.02056666f, 0.03667805f, 
    0.00932700f, -0.01174664f, -0.02189509f, -0.04038248f, -0.03810370f, 0.00049335f, 0.00690728f, 0.01267491f, 
    -0.02866090f, -0.02708293f, -0.03930948f, -0.01412669f, 0.02948191f, -0.01377898f, 0.00154700f, 0.02103948f, 
    -0.03700475f, -0.01240434f, -0.02221966f, -0.00582860f, 0.02198465f, -0.00122000f, -0.03869619f, -0.03914899f, 
    -0.03943519f, 0.01728577f, -0.03700447f, 0.01424862f, -0.02580513f, 0.01542724f, -0.01817085f, 0.02211254f, 
    -0.03835114f, -0.02423717f, -0.03051306f, 0.01723128f, -0.00199917f, 0.02700536f, -0.01563179f, 0.02712460f, 
    -0.00060747f, -0.00382131f, -0.02466206f, -0.01252722f, 0.00056450f, -0.01876762f, 0.02223373f, 0.01869406f, 
    -0.01845647f, -0.00992403f, 0.00920684f, 0.03586122f, -0.02069776f, 0.00521116f, -0.00611384f, -0.04134985f, 
    0.03494386f, 0.02520851f, -0.04086448f, -0.00588970f, 0.01361201f, -0.00563202f, -0.01830352f, 0.00775224f, 
    -0.03976815f, -0.00344981f, -0.00046473f, 0.01599638f, 0.01546665f, 0.02486106f, 0.00004904f, -0.02227752f, 
    0.00000360f, -0.02397301f, -0.01863352f, 0.01908339f, -0.00455419f, 0.00836787f, -0.00256660f, 0.02492233f, 
    0.00409007f, -0.03930223f, -0.03725114f, -0.02648154f, 0.01059396f, -0.02921796f, 0.02806297f, -0.01883706f, 
    0.01013074f, -0.03805953f, -0.01973856f, -0.00313920f, -0.02074229f, 0.01674022f, -0.00444162f, 0.02058994f, 
    -0.00089474f, 0.02597572f, -0.00328548f, 0.02331404f, -0.01064683f, -0.00564590f, -0.01637263f, -0.01621885f, 
    0.00928872f, 0.00905897f, -0.00049778f, -0.00649661f, -0.01866781f, 0.00026646f, -0.03761680f, 0.00869863f, 
    -0.00565463f, -0.00591739f, 0.00371708f, 0.00327870f, 0.00090359f, -0.02169090f, 0.01790000f, -0.00867596f, 
    -0.01353713f, -0.02609677f, 0.00856723f, -0.01709589f, 0.01527634f, -0.02509627f, -0.01961406f, -0.00757819f, 
    -0.02515797f, -0.01574870f, -0.01895183f, -0.02064950f, 0.01123619f, -0.03803611f, -0.01882249f, -0.01018695f, 
    0.01986593f, -0.04089188f, 0.02769258f, -0.02016861f, 0.02525853f, 0.00627199f, 0.00248389f, 0.01000509f, 
    0.00892570f, -0.02670186f, -0.00765616f, 0.01277304f, -0.01572395f, -0.00464681f, -0.01604853f, 0.03830875f, 
    0.00238824f, -0.00002387f, -0.01735901f, 0.00968710f, 0.01505960f, -0.02993659f, -0.01009451f, -0.02217376f, 
    0.01000765f, -0.00894244f, 0.01688678f, -0.04199029f, -0.01911610f, -0.02456145f, 0.02121916f, -0.03361503f, 
    0.00104350f, 0.01444067f, -0.00040316f, -0.02013263f, 0.02787974f, 0.00974521f, -0.03536132f, 0.02168292f, 
    0.03202186f, 0.03023535f, 0.02737459f, 0.01974156f, 0.00307171f, 0.02857333f, -0.01131582f, -0.00565804f, 
    -0.03532437f, 0.00805994f, 0.02025347f, -0.00711779f, 0.00381148f, 0.00415797f, 0.00668006f, -0.04086167f, 
    0.01262460f, -0.03394241f, -0.03795060f, -0.03882358f, 0.01347958f, 0.02708869f, -0.00022060f, -0.00440223f, 
    0.02429954f, -0.01241861f, 0.00579449f, 0.04111055f, 0.00356811f, -0.01776993f, -0.02618222f, 0.00548039f, 
    -0.01106236f, 0.02283594f, -0.01386861f, 0.02846638f, -0.01674896f, -0.00151700f, -0.01994845f, -0.02971913f, 
    -0.00004097f, -0.02260805f, -0.00813518f, -0.01258618f, 0.01856496f, -0.03615564f, -0.01145916f, -0.03637756f, 
    -0.01037000f, -0.02306290f, 0.01255366f, 0.01856390f, 0.03382953f, 0.02901073f, -0.00640050f, -0.03191677f, 
    0.02050717f, -0.03127711f, 0.00181011f, 0.02669523f, -0.01903437f, 0.01705854f, -0.03133715f, -0.02326799f, 
    0.01460982f, -0.02713040f, -0.02845272f, -0.03081693f, -0.02666615f, -0.02832450f, 0.02668769f, 0.00747076f, 
    0.03926144f, 0.02204148f, 0.01052963f, -0.00423910f, -0.00486929f, -0.01830333f, -0.04054896f, -0.02161325f, 
    -0.02957692f, 0.02438685f, 0.02641937f, 0.02323249f, -0.00875422f, 0.00366863f, 0.00076279f, -0.02163041f, 
    -0.01642378f, 0.02882509f, -0.01520085f, -0.00523443f, -0.02340863f, -0.03520801f, -0.02607986f, -0.00083186f, 
    -0.01556667f, -0.03815799f, 0.02040259f, -0.00379458f, -0.00427056f, 0.00992106f, -0.02683480f, -0.01138908f, 
    -0.02946378f, -0.02168439f, 0.02331897f, 0.02576872f, -0.01920448f, -0.00030276f, -0.03719167f, -0.00373952f, 
    0.00122676f, 0.01121167f, 0.02382722f, -0.02260998f, 0.03381341f, -0.04158847f, 0.01002031f, -0.01997799f, 
    0.03145143f, -0.03578080f, -0.00920198f, -0.00980107f, -0.02897033f, -0.02384171f, 0.01762068f, -0.04112542f, 
    -0.03740532f, 0.00070667f, 0.02821391f, -0.02349938f, -0.03833565f, 0.03322186f, -0.04189716f, 0.02890110f, 
    0.00482494f, 0.02408839f, -0.02457407f, -0.00014100f, 0.02270570f, 0.02604790f, -0.02172351f, -0.00173829f, 
    0.01765731f, 0.01600746f, -0.02038489f, 0.01322998f, -0.00382684f, -0.02485782f, 0.02036495f, -0.03947997f, 
    -0.02356206f, -0.01393648f, -0.02359181f, -0.00100207f, 0.02903030f, 0.00407886f, 0.00732823f, -0.02016128f, 
    -0.00573449f, 0.00821316f, -0.03612190f, -0.00260986f, -0.03309714f, 0.01073681f, 0.02279059f, -0.03890847f, 
    0.02616459f, -0.02707675f, -0.01832051f, 0.01165661f, -0.00615392f, -0.02196831f, 0.03252931f, 0.02674253f, 
    -0.03756426f, 0.01790414f, 0.00358373f, 0.00836517f, -0.02876138f, -0.02868475f, -0.03496087f, -0.01880752f, 
    0.01268458f, -0.00501360f, -0.03871182f, -0.03542484f, -0.01807889f, 0.00013397f, -0.03024690f, -0.03206576f, 
    -0.03996218f, 0.00481758f, -0.03453610f, 0.00669140f, 0.02303011f, 0.02424724f, 0.02460481f, 0.00598237f, 
    -0.00768356f, -0.00650346f, 0.00552414f, -0.00659398f, 0.02161696f, -0.00576338f, -0.00726342f, -0.01251107f, 
    -0.02096609f, 0.03387555f, -0.00476882f, -0.02170506f, 0.00998889f, -0.00178428f, -0.02067986f, -0.00675886f, 
    -0.02270026f, 0.01388176f, -0.03485603f, 0.01908998f, 0.02056565f, -0.01326375f, -0.01123089f, -0.02545037f, 
    -0.00265117f, -0.01705164f, -0.03166742f, -0.02718817f, -0.01105068f, 0.00143925f, -0.02012937f, -0.01430956f, 
    0.01230482f, 0.03031197f, -0.00203033f, -0.00216363f, 0.00757217f, -0.02302920f, -0.03068631f, 0.00359818f, 
    0.02796141f, 0.03003951f, -0.04021760f, -0.02750680f, -0.00390935f, 0.01002534f, 0.02736242f, 0.00362861f, 
    -0.02098308f, -0.01081648f, 0.02228274f, 0.02538421f, 0.00114286f, -0.01260716f, 0.02425282f, 0.02538125f, 
    -0.00816873f, -0.03531375f, -0.03454530f, 0.02792885f, -0.00325184f, 0.03196543f, 0.00117566f, -0.00269365f, 
    -0.02909552f, -0.02077582f, -0.02223286f, -0.03793303f, 0.00095787f, 0.01536617f, -0.02112612f, -0.00659331f, 
    -0.01559294f, -0.01780333f, -0.02786314f, 0.00046816f, -0.01651524f, -0.03371748f, -0.00360017f, 0.00391517f, 
    0.02126072f, 0.01483010f, 0.00055445f, -0.00002296f, 0.01839251f, -0.00964252f, -0.00068633f, 0.01472907f, 
    0.01261189f, -0.00280935f, -0.01117655f, -0.02932244f, -0.01584455f, -0.00700778f, 0.03400430f, 0.02130943f, 
    -0.01454855f, -0.02207603f, -0.03516403f, 0.03105077f, -0.02416698f, 0.01178235f, -0.03373532f, -0.01248952f, 
    -0.03849550f, -0.02276334f, -0.01337865f, -0.01018706f, -0.03114379f, -0.01374311f, -0.00408087f, -0.00761363f, 
    0.00738656f, -0.00162578f, 0.02457023f, 0.00970170f, -0.03953988f, -0.00952256f, -0.02273647f, -0.01101445f, 
    -0.01713257f, 0.01503960f, -0.02502974f, -0.01358388f, -0.01971252f, 0.03549543f, -0.00126328f, -0.02463580f, 
    -0.01067202f, 0.01001545f, -0.03039648f, -0.00134185f, -0.01987365f, 0.02436867f, 0.00748945f, -0.00888114f, 
    0.02420995f, -0.01296846f, -0.00301395f, -0.01246373f, 0.01501649f, 0.00301164f, -0.00655204f, -0.03876405f, 
    -0.02335047f, 0.00770372f, -0.00265017f, -0.00391518f, 0.03254620f, -0.01069187f, 0.00922207f, -0.01406729f, 
    0.02811839f, 0.01685359f, -0.00259727f, 0.02962427f, -0.03472068f, -0.01331902f, -0.01542247f, 0.00723919f, 
    -0.03009987f, 0.01373419f, -0.01176667f, -0.00727140f, 0.00572480f, 0.00052903f, -0.02024369f, -0.00164890f, 
    0.01874036f, -0.02724779f, -0.03848304f, 0.02880346f, -0.04187035f, -0.00864947f, -0.03405857f, 0.00300031f, 
    -0.00475797f, -0.00875205f, -0.03365145f, -0.01596784f, 0.01781911f, 0.01499459f, -0.03933154f, 0.01926459f, 
    0.02480691f, 0.00011041f, 0.00349133f, 0.00198675f, -0.01554798f, 0.00847057f, 0.00945728f, -0.01323046f, 
    0.03115112f, 0.02755116f, 0.01685404f, -0.01174985f, 0.01788276f, 0.01139768f, 0.00450222f, 0.02194191f, 
    -0.03693449f, 0.00145158f, -0.01621993f, 0.02296368f, -0.01129183f, -0.03562851f, -0.03422649f, 0.01349477f, 
    0.02860548f, 0.03545366f, -0.02362509f, -0.02826205f, 0.00172838f, -0.03612685f, -0.00945736f, 0.00508528f, 
    0.00426113f, -0.00924169f, -0.04035439f, -0.04101085f, -0.02616772f, -0.00349036f, 0.01363644f, -0.03112340f, 
    0.01584046f, -0.02336606f, -0.01488664f, -0.02169005f, 0.00806409f, -0.03199426f, -0.02681090f, 0.04075105f, 
    -0.04124141f, -0.03929574f, 0.02178438f, 0.02598940f, 0.00067288f, 0.02575609f, 0.02358405f, 0.01496876f, 
    -0.02394409f, -0.01935604f, -0.00982901f, -0.02281936f, 0.00294372f, -0.01374895f, 0.04029869f, -0.00303145f, 
    0.01792854f, -0.03228655f, -0.03687189f, 0.01505128f, 0.02356705f, 0.03266908f, 0.00889674f, -0.01809003f, 
    -0.02621529f, -0.01921346f, 0.02630955f, -0.03893330f, -0.04170219f, 0.02472184f, -0.00074792f, -0.02205567f, 
    -0.04219373f, -0.02148295f, -0.03220930f, -0.03817955f, 0.00562351f, -0.02207845f, -0.02459964f, 0.00180975f, 
    -0.03068364f, 0.00332953f, 0.00439400f, -0.03776598f, 0.01147085f, -0.02727648f, -0.02405153f, -0.01193751f, 
    -0.00835272f, 0.00219058f, -0.01460066f, 0.02644090f, -0.01593477f, -0.03448651f, 0.01430507f, -0.00521793f, 
    0.01022026f, 0.02978507f, 0.02214088f, -0.01776646f, -0.01871592f, 0.02201467f, 0.02565194f, -0.03790583f, 
    -0.03779498f, 0.02295459f, 0.02267371f, -0.03645210f, -0.03931486f, -0.00274544f, 0.01832689f, -0.01852268f, 
    -0.00635097f, -0.01000564f, 0.02390844f, 0.03940428f, 0.00198583f, -0.01768910f, 0.00134394f, -0.04080946f, 
    -0.01552331f, 0.01301770f, 0.02898454f, 0.00759742f, 0.01765494f, 0.01103724f, -0.02764553f, -0.02387741f, 
    -0.02178435f, -0.00216799f, 0.02607398f, 0.02917203f, 0.02210951f, -0.04142154f, -0.02256362f, 0.00996982f, 
    -0.02456020f, -0.01203353f, -0.03645517f, -0.02967751f, -0.00620539f, 0.00209052f, 0.01986776f, 0.02264441f, 
    -0.01261620f, 0.01355250f, 0.03051405f, 0.02278970f, -0.00887801f, -0.02934207f, 0.01496426f, 0.02905792f, 
    -0.01600536f, -0.03035991f, 0.02629320f, 0.01965758f, -0.03298567f, 0.03082931f, -0.01369520f, -0.02788603f, 
    -0.01371763f, -0.01670360f, 0.02225169f, -0.00109476f, 0.01127518f, -0.02751209f, -0.03640961f, -0.00333259f, 
    -0.00558029f, 0.02336194f, -0.03668892f, 0.00859400f, -0.01470654f, 0.00236352f, -0.00216673f, 0.00608457f, 
    0.02416377f, 0.02334174f, 0.02556159f, 0.00661698f, 0.00662343f, 0.01196946f, 0.03774318f, -0.04351893f, 
    -0.04435501f, -0.02974474f, -0.03647862f, -0.02417904f, -0.03584480f, -0.01602095f, 0.03367632f, 0.00937083f, 
    -0.02003726f, 0.02787650f, 0.02892212f, -0.02049745f, -0.04362202f, 0.00102134f, -0.03523318f, -0.02145006f, 
    -0.01535126f, -0.02831051f, 0.01473638f, -0.01491581f, -0.00045299f, -0.00241203f, -0.03469112f, -0.01626634f, 
    0.00236389f, -0.03554105f, -0.02633088f, -0.02240440f, -0.00568233f, -0.02039697f, 0.01283410f, 0.01169871f, 
    0.01613024f, -0.03725876f, 0.00340077f, 0.01926193f, 0.00930898f, 0.03611047f, 0.01585596f, 0.01252294f, 
    -0.00599291f, 0.02329681f, 0.02208583f, -0.02070878f, 0.01565620f, -0.00918875f, 0.01769030f, -0.00422158f, 
    0.00840156f, 0.01250180f, -0.00606077f, -0.00416825f, -0.02624661f, 0.01547996f, 0.01967799f, -0.01273349f, 
    -0.00535295f, 0.02140453f, -0.01292256f, -0.00654786f, 0.00346867f, -0.02686432f, -0.01425447f, -0.00857551f, 
    -0.01966867f, 0.01190501f, -0.01176600f, -0.00713381f, -0.01241214f, 0.00595956f, -0.02569366f, -0.03920050f, 
    0.00685730f, -0.03527598f, -0.00824280f, -0.02361748f, 0.02014063f, -0.01594536f, 0.00875864f, -0.02148094f, 
    0.02491696f, 0.00494684f, -0.01217192f, 0.02147442f, -0.01390870f, 0.01553473f, 0.03060261f, -0.01295294f, 
    0.02541946f, 0.02250507f, 0.00853439f, -0.03088393f, -0.00930524f, -0.01528863f, -0.03736066f, -0.03774694f, 
    -0.00823167f, -0.00758129f, 0.03883701f, -0.00655534f, -0.00711397f, -0.03496110f, 0.01561414f, 0.00308057f, 
    -0.00925272f, -0.00217675f, -0.03001130f, -0.01954690f, 0.02568425f, -0.00686820f, 0.01422035f, -0.03056210f, 
    0.02496704f, -0.01361221f, -0.03545041f, 0.02633664f, 0.01435106f, -0.03117500f, 0.03832225f, -0.01811974f, 
    0.01744629f, 0.03175335f, 0.00984834f, 0.00109219f, 0.00358627f, 0.00308723f, 0.01278331f, 0.01150293f, 
    -0.02922431f, 0.01847002f, 0.02270489f, -0.02509455f, 0.01424781f, 0.00188985f, -0.00288842f, 0.02114907f, 
    0.03229483f, -0.02292137f, 0.03321622f, -0.01328391f, -0.01986778f, -0.01376008f, 0.02846308f, -0.00968961f, 
    0.00692405f, 0.01493872f, -0.00714674f, -0.03195320f, -0.01942294f, 0.02924830f, -0.01060486f, -0.03688535f, 
    0.01996370f, -0.01011254f, 0.00578108f, -0.03046980f, 0.00507825f, -0.02269140f, -0.02661861f, 0.01436954f, 
    -0.01921553f, -0.00170134f, 0.00163935f, 0.01155912f, 0.02501565f, 0.01375230f, 0.00586400f, -0.00865658f, 
    -0.00257722f, 0.00788036f, -0.01831150f, -0.01521092f, -0.02041079f, -0.02820069f, 0.01562425f, -0.00547912f, 
    0.02331435f, 0.01712495f, -0.00726945f, 0.02969940f, 0.02808020f, -0.02561246f, 0.03484123f, -0.03636735f, 
    0.00117544f, -0.00505699f, -0.01995208f, -0.00795950f, 0.00894700f, -0.00397615f, -0.00607542f, -0.00034822f, 
    0.00550636f, 0.02042120f, -0.01453354f, -0.02026614f, -0.01785351f, -0.01395150f, 0.02124682f, -0.03747016f, 
    0.00443139f, -0.02538326f, -0.02613796f, -0.01144560f, 0.01735987f, -0.02551675f, -0.00481532f, 0.01632076f, 
    0.00469213f, 0.00482365f, -0.00910269f, 0.02576391f, 0.02878543f, 0.00873628f, 0.02664378f, 0.03233286f, 
    -0.02197477f, -0.00035023f, -0.04276571f, -0.01124155f, -0.01269349f, 0.01438948f, 0.01985495f, 0.00264091f, 
    -0.02707797f, 0.02204540f, 0.01564037f, -0.02569341f, 0.01495708f, 0.02720748f, -0.01709784f, -0.01491254f, 
    -0.03703272f, -0.02733854f, -0.01952117f, -0.01118908f, 0.00284345f, 0.02492513f, -0.02919694f, -0.01099872f, 
    -0.00882251f, 0.02566248f, -0.01413309f, 0.00836873f, -0.04271389f, -0.02260076f, -0.03676709f, 0.00734509f, 
    -0.00618808f, -0.03718765f, -0.01863350f, 0.00649194f, 0.00961043f, 0.01301924f, -0.02606659f, 0.01818462f, 
    -0.01297564f, 0.02538110f, 0.00235666f, -0.01468287f, -0.01291591f, 0.02727923f, 0.01923361f, -0.00901720f, 
    -0.03611103f, -0.03295618f, 0.00259177f, 0.01182643f, -0.01572743f, -0.00234469f, -0.00687026f, -0.01109078f, 
    0.01104762f, 0.02251069f, -0.02220124f, -0.03071778f, 0.02797671f, 0.02211519f, 0.00671720f, 0.03857442f, 
    -0.00477631f, -0.00278036f, -0.01092109f, -0.03182054f, 0.02222958f, 0.01489326f, -0.00488221f, 0.01685756f, 
    0.02514092f, -0.01659878f, 0.01553270f, 0.01073762f, -0.02021941f, 0.00323067f, 0.02126687f, 0.01071377f, 
    -0.03987187f, 0.01118349f, -0.02762243f, 0.01376150f, 0.02331005f, -0.02830258f, -0.03825460f, 0.01294957f, 
    -0.02197612f, 0.00569864f, -0.03348771f, 0.02645238f, -0.01972943f, -0.00362511f, 0.02013337f, 0.00177986f, 
    -0.02520966f, 0.01075565f, 0.00453420f, 0.01797801f, 0.02859393f, -0.04087924f, -0.00465601f, -0.01374073f, 
    -0.00985278f, -0.00149220f, -0.00802312f, -0.00544069f, -0.01100917f, -0.01317287f, 0.00982830f, 0.02240143f, 
    0.01128219f, 0.01144622f, -0.00474707f, 0.00691185f, -0.00896993f, -0.03851885f, 0.01432876f, 0.00763915f, 
    -0.03278948f, 0.02038933f, -0.03270994f, 0.00083246f, -0.03763559f, -0.02777312f, 0.01449964f, -0.03492363f, 
    -0.04015671f, -0.00175161f, -0.02750671f, -0.03151183f, 0.00152998f, 0.03502681f, 0.02176730f, 0.00418720f, 
    0.01380851f, -0.00696414f, 0.03161657f, 0.01592947f, -0.02642757f, -0.01411975f, -0.03229274f, 0.00408955f, 
    -0.00750993f, -0.02940345f, -0.01099234f, -0.03056612f, 0.02079662f, -0.02261928f, -0.01163469f, -0.00906422f, 
    0.02701932f, 0.00921390f, -0.04066280f, -0.03401017f, -0.02796878f, 0.00290636f, 0.00778767f, -0.01754210f, 
    -0.02333638f, 0.00582470f, -0.01714906f, -0.04059844f, 0.01982090f, 0.00680650f, -0.03056922f, 0.00582618f, 
    -0.02530348f, 0.02776298f, 0.01380452f, 0.02505404f, 0.01301956f, 0.02889041f, 0.00282241f, -0.03893523f, 
    -0.02123193f, -0.00188452f, 0.02465767f, -0.02051689f, 0.01833875f, 0.00136492f, -0.01312695f, 0.01400542f, 
    -0.02510560f, 0.02437319f, 0.01959427f, -0.01632759f, -0.00410851f, 0.00351375f, 0.02653686f, 0.02477190f, 
    0.01070940f, 0.02818689f, -0.03478412f, 0.01322465f, 0.02234935f, -0.03720107f, 0.00943076f, 0.00773866f, 
    0.03203356f, -0.01633376f, -0.00758846f, 0.01605407f, 0.01829093f, 0.03072532f, -0.01123990f, -0.03618414f, 
    -0.01512917f, 0.02258915f, 0.03488171f, -0.03405964f, 0.00227834f, 0.00144816f, 0.01292382f, 0.02835198f, 
    0.02450024f, -0.03199975f, 0.01917132f, 0.00785543f, 0.02243063f, -0.02261205f, -0.00087879f, 0.01973763f, 
    0.00758020f, -0.03565657f, -0.01581872f, -0.03303976f, 0.01258702f, -0.00475162f, -0.00789034f, -0.03218193f, 
    -0.02768990f, 0.03286169f, 0.00235524f, 0.00427417f, -0.03422348f, 0.00968368f, 0.00171063f, -0.01814023f, 
    -0.01420699f, -0.03169757f, 0.01904291f, -0.03917461f, -0.03847567f, -0.00220186f, 0.01759580f, -0.01021407f, 
    -0.00427956f, -0.02614073f, 0.01260841f, -0.00008282f, -0.01907772f, 0.01184062f, 0.00902369f, 0.00176609f, 
    -0.00601124f, 0.01075348f, 0.00262774f, -0.01732059f, 0.01293491f, 0.01238180f, 0.01605534f, -0.03127971f, 
    -0.00091949f, -0.00947895f, -0.02567525f, -0.00990416f, -0.00660978f, -0.03255225f, -0.01486434f, -0.01971061f, 
    -0.01737768f, -0.02151975f, -0.01411124f, 0.02595982f, -0.01747413f, -0.03604786f, 0.00229870f, -0.02813408f, 
    -0.01778671f, -0.01515559f, -0.02351440f, -0.03231047f, -0.04056128f, 0.01741164f, -0.04348030f, 0.00751878f, 
    -0.01760362f, 0.01762954f, -0.03996326f, 0.02594701f, -0.04163537f, -0.00144293f, -0.02736468f, -0.01977791f, 
    0.00732457f, -0.00228162f, 0.01622290f, -0.02195545f, -0.01504613f, 0.02940418f, 0.02447846f, 0.01664856f, 
    -0.00519657f, -0.04237443f, 0.00402005f, -0.00476490f, 0.02523355f, 0.00994203f, -0.03322756f, 0.00748204f, 
    -0.00653112f, -0.02656629f, -0.02388165f, -0.03065595f, -0.01379689f, 0.00863389f, 0.02922932f, -0.04179077f, 
    -0.04095417f, 0.00643775f, 0.01769132f, -0.01414468f, -0.02208993f, -0.00941213f, -0.03459560f, -0.03081850f, 
    0.00623455f, 0.02117190f, 0.01974441f, -0.01157069f, -0.01128651f, 0.01959288f, -0.03813231f, -0.02168252f, 
    0.00896852f, -0.02852542f, 0.01283843f, -0.03067013f, -0.00103218f, -0.04021135f, 0.00655835f, 0.00755372f, 
    0.02533477f, -0.03539022f, 0.01668658f, -0.01318368f, 0.02345855f, -0.00501559f, -0.00064326f, -0.03173480f, 
    0.00800083f, 0.00029980f, -0.02579695f, -0.01184128f, 0.02000127f, 0.00832016f, 0.01104217f, -0.00037617f, 
    0.00276343f, -0.00921177f, -0.03432307f, -0.03867649f, 0.01787213f, 0.01630843f, -0.00625505f, 0.00550743f, 
    -0.03788663f, -0.04349433f, -0.03337873f, 0.02792275f, 0.01918510f, -0.03267325f, 0.02111764f, 0.00151855f, 
    0.00499493f, 0.00924182f, -0.00185378f, 0.01528230f, -0.03142847f, 0.02508764f, -0.03627416f, -0.04191222f, 
    0.01054821f, -0.01041260f, 0.00571163f, 0.02746813f, 0.00504099f, 0.02155413f, 0.00101989f, -0.00983750f, 
    -0.01422975f, 0.01424476f, 0.01792959f, 0.02102455f, -0.01218349f, -0.01122544f, 0.02747540f, -0.02595435f, 
    -0.03695784f, 0.01135405f, -0.03947634f, -0.01323649f, -0.03384014f, 0.01519348f, 0.00857567f, -0.01153912f, 
    -0.02541469f, -0.02626676f, 0.01030202f, -0.00507812f, -0.03972623f, 0.00235834f, 0.00520521f, -0.04215289f, 
    0.00132919f, 0.01775307f, -0.02361867f, 0.01366497f, -0.00548544f, -0.03625910f, -0.03438643f, 0.00477812f, 
    -0.00271854f, -0.00053829f, 0.00856138f, 0.02619929f, 0.02204320f, -0.03200119f, 0.02347331f, 0.00247877f, 
    0.02581299f, 0.02325501f, 0.01069690f, 0.00804495f, 0.01921635f, 0.02624137f, 0.00669546f, 0.02580740f, 
    -0.03092991f, -0.04151593f, 0.02386665f, -0.01689033f, -0.04084318f, -0.02931461f, 0.01926787f, -0.00019262f, 
    0.01416262f, -0.02154528f, -0.03816551f, -0.01529242f, -0.02114586f, 0.00773463f, -0.03248482f, -0.01570091f, 
    0.00224522f, -0.03348357f, -0.00264752f, -0.03444074f, 0.00336830f, -0.01147593f, -0.01601160f, 0.00817968f, 
    0.02058570f, -0.00585017f, -0.00574949f, 0.02429110f, -0.00030565f, 0.02926044f, 0.00507977f, -0.00613006f, 
    -0.01522646f, -0.03028921f, -0.01554967f, 0.00792185f, 0.02313962f, 0.02863486f, -0.01955286f, -0.00822489f, 
    0.01920608f, -0.01520100f, 0.02595542f, -0.01463805f, -0.02406785f, 0.01332611f, 0.01328635f, 0.02643799f, 
    0.01224552f, -0.01587236f, -0.00121385f, -0.03920204f, -0.00293613f, 0.01544963f, 0.02622943f, -0.01688713f, 
    0.01983964f, 0.01876470f, -0.03005562f, 0.02353477f, -0.03001791f, -0.01044673f, -0.03360360f, -0.00556523f, 
    0.01790023f, -0.02389808f, -0.00505574f, 0.00980357f, 0.02126107f, 0.01448608f, 0.02503284f, -0.02455631f, 
    0.01721030f, 0.00014151f, -0.01388708f, -0.00489425f, -0.01658732f, -0.00342554f, -0.02636619f, 0.03415903f, 
    0.01849729f, -0.03413603f, 0.00852257f, -0.00510152f, 0.02221206f, -0.02024598f, 0.00526862f, -0.00584925f, 
    -0.01315695f, -0.00053231f, 0.00807495f, 0.02574355f, -0.03304728f, 0.00241761f, -0.03991606f, 0.00649819f, 
    -0.03642564f, 0.02186488f, 0.01262956f, 0.02327550f, 0.01558243f, 0.00787775f, -0.02173786f, 0.00280380f, 
    -0.03593927f, 0.00993666f, 0.00570753f, -0.03504372f, -0.01025850f, 0.02713546f, 0.00662211f, -0.01391391f, 
    -0.01953639f, 0.01176896f, 0.01280599f, -0.01272149f, 0.00953969f, -0.01272447f, -0.03925779f, 0.01812184f, 
    -0.01220632f, -0.02277493f, 0.02755284f, -0.01190249f, 0.01704270f, -0.01933294f, 0.02289272f, 0.03650141f, 
    -0.03034972f, 0.02447341f, -0.03555076f, -0.01364926f, -0.03649350f, 0.00155096f, -0.02242735f, 0.02235339f, 
    0.01454646f, -0.00503625f, 0.02052805f, 0.00966042f, -0.03347020f, -0.02546507f, -0.02846827f, -0.01209911f, 
    -0.00677654f, -0.01796879f, -0.01733499f, -0.00493104f, 0.01786512f, -0.01610462f, -0.01969502f, -0.03237521f, 
    -0.01429315f, 0.01964534f, -0.00251458f, 0.01584344f, 0.00979233f, -0.01911023f, -0.03444223f, -0.02158674f, 
    -0.02207956f, -0.02869284f, -0.03520303f, 0.00046765f, -0.03226330f, -0.00717293f, -0.02950585f, 0.00959946f, 
    -0.04212245f, 0.00124218f, -0.01183516f, -0.03735013f, -0.04069636f, 0.00153524f, -0.01472458f, -0.02028546f, 
    -0.03508152f, -0.04155952f, 0.01869348f, 0.00324937f, -0.03677529f, -0.00292844f, 0.02805158f, 0.00186198f, 
    0.01835479f, -0.00171398f, -0.02166975f, -0.01458061f, -0.04252943f, 0.02063295f, 0.01870532f, 0.00782503f, 
    -0.02436988f, -0.01868237f, 0.02453363f, -0.00932842f, 0.01207839f, -0.04004702f, -0.01714431f, 0.01092147f, 
    0.01226985f, -0.00293590f, -0.02476367f, 0.00574962f, 0.02252860f, -0.04115516f, -0.01497963f, 0.00793762f, 
    -0.03816206f, -0.00470868f, 0.01201073f, 0.02290585f, 0.00837476f, -0.00405067f, -0.03653777f, -0.03014733f, 
    -0.02051285f, 0.00614194f, 0.02279037f, -0.03756716f, 0.00943836f, -0.04045584f, -0.03988294f, -0.02630799f, 
    -0.00428666f, -0.03508808f, -0.03256753f, 0.01389874f, 0.01794059f, -0.00719781f, -0.04018790f, 0.01180586f, 
    -0.01130544f, -0.00741342f, 0.00045605f, -0.01497599f, -0.01375353f, 0.00700726f, -0.03218276f, -0.02341582f, 
    0.01605817f, 0.00953990f, -0.03967848f, 0.01828222f, 0.00866111f, 0.00007389f, -0.03950667f, -0.02319493f, 
    -0.03284492f, -0.02276909f, -0.03307273f, 0.01192056f, -0.01922788f, 0.01471399f, -0.03067765f, -0.03215531f, 
    -0.03568152f, 0.00429005f, -0.02241702f, -0.00281827f, -0.03118873f, -0.01559551f, -0.04102137f, -0.03504974f, 
    0.00524540f, -0.02989282f, 0.01896766f, -0.04196976f, -0.03510853f, 0.01354661f, -0.03244891f, 0.00381851f, 
    -0.01449645f, 0.00059309f, -0.00967728f, 0.01017665f, 0.02147199f, -0.02158904f, 0.00098658f, 0.00982971f, 
    0.00183156f, -0.02472265f, -0.01700490f, 0.01837178f, 0.02540465f, -0.03911975f, 0.02530685f, 0.00776156f, 
    -0.01041253f, -0.01448487f, 0.02272958f, 0.00501388f, 0.01300618f, 0.00138767f, -0.00457609f, -0.00592052f, 
    -0.00501182f, -0.00593986f, -0.03651031f, 0.01207802f, 0.02661249f, 0.01232283f, -0.04106861f, -0.03136514f, 
    -0.00267441f, 0.03310659f, -0.00231493f, -0.02428622f, 0.01823970f, 0.00047899f, 0.02885449f, 0.02726835f, 
    -0.00391130f, 0.00489243f, 0.00015567f, 0.01295996f, 0.01609434f, 0.02576348f, -0.04055785f, -0.04217959f, 
    0.01407929f, -0.03420108f, 0.00223912f, -0.00070172f, -0.03539204f, 0.01198999f, 0.00615972f, -0.01075259f, 
    0.02635545f, -0.03571657f, 0.00242726f, 0.00220009f, -0.04073627f, 0.00265596f, -0.01969331f, -0.02947557f, 
    0.01270270f, -0.02278101f, 0.00307413f, -0.01995205f, -0.02872284f, -0.00910101f, -0.03238302f, 0.00147398f, 
    -0.01983036f, 0.02541448f, -0.03151515f, -0.02273971f, -0.02421962f, -0.02006966f, 0.02236091f, 0.01795493f, 
    0.02323538f, 0.02874314f, -0.01521962f, -0.02528223f, -0.01761540f, -0.00689651f, -0.02411930f, -0.04281630f, 
    -0.01969528f, 0.01098090f, 0.02513143f, -0.02166182f, 0.01075021f, -0.01243335f, 0.00155187f, -0.02471276f, 
    -0.02599674f, 0.01580681f, -0.03008215f, 0.02317111f, -0.00888995f, 0.02514253f, 0.02603889f, -0.01910680f, 
    0.01944123f, -0.01078201f, 0.02698584f, 0.00631096f, -0.04167000f, -0.00035896f, 0.01804442f, -0.00627641f, 
    0.02445589f, -0.00066991f, -0.00060211f, 0.01618147f, 0.02674306f, 0.01301392f, 0.01850162f, 0.02774308f, 
    -0.03180496f, 0.01202614f, 0.00858612f, -0.00278727f, -0.00992112f, -0.00769364f, 0.00857492f, -0.03917916f, 
    -0.02190524f, -0.03816482f, 0.01930886f, -0.01131588f, -0.00224787f, 0.02410957f, -0.03433236f, -0.01904110f, 
    -0.02213811f, -0.01973693f, 0.01658675f, -0.02796871f, -0.00368646f, 0.01262917f, -0.04044718f, 0.00369051f, 
    -0.01055493f, 0.00147375f, 0.01992637f, 0.00582949f, -0.01503713f, -0.03180065f, -0.01418178f, 0.00929463f, 
    0.01320544f, -0.02923921f, -0.01414064f, 0.00185085f, -0.02019389f, -0.03613706f, -0.02463367f, 0.02290411f, 
    -0.02186147f, 0.00952998f, -0.03322475f, -0.02439583f, -0.00002941f, 0.01142125f, 0.01555805f, -0.03885052f, 
    -0.00344297f, 0.00979277f, -0.03322861f, 0.01933131f, -0.00715370f, 0.00793457f, 0.00612757f, 0.00388281f, 
    -0.00381178f, 0.01769488f, -0.03494225f, -0.00091497f, -0.00074178f, -0.00007581f, -0.02673765f, -0.04178505f, 
    0.02094506f, 0.00132793f, 0.01766147f, -0.04072133f, 0.01176752f, 0.00788682f, -0.00867455f, -0.03637600f, 
    -0.03122720f, -0.02602798f, -0.03620590f, -0.01968066f, 0.00755906f, -0.00742429f, 0.02308449f, -0.03400545f, 
    -0.01905688f, -0.01655277f, -0.00014453f, 0.02699697f, -0.02411657f, 0.01803146f, -0.01678286f, -0.03808341f, 
    -0.01346845f, -0.04193205f, 0.01148802f, -0.00856915f, -0.01288283f, -0.00483605f, 0.00067962f, 0.02758456f, 
    -0.03884035f, 0.01292773f, -0.01976538f, 0.02347272f, -0.02535227f, -0.00533906f, 0.02359083f, -0.02679783f, 
    -0.04081852f, 0.01287964f, -0.02249529f, -0.03467633f, 0.02649736f, -0.03119368f, 0.02030030f, -0.00436189f, 
    -0.01794473f, -0.03608142f, -0.02261849f, -0.01679192f, 0.00022963f, -0.00788131f, 0.02275796f, 0.02347587f, 
    0.02285185f, 0.02863710f, -0.03551332f, 0.02415181f, -0.00106446f, 0.00833330f, -0.03102266f, -0.01507647f, 
    -0.02516839f, -0.02169634f, -0.00005241f, -0.00300871f, -0.01060121f, -0.04143071f, 0.00868189f, -0.02606865f, 
    0.01857923f, 0.00661203f, -0.03722935f, -0.02320653f, -0.02899863f, -0.04046876f, -0.00400669f, 0.02914029f, 
    -0.03919950f, 0.01420039f, -0.03811657f, -0.03174520f, -0.00561476f, 0.00973685f, 0.02361442f, -0.00680175f, 
    0.01142291f, -0.02110644f, 0.02389806f, 0.02813952f, 0.02117786f, -0.01362204f, -0.03329930f, -0.00621234f, 
    -0.02685547f, 0.00309229f, -0.01504926f, -0.01114411f, -0.01726331f, -0.04117563f, -0.03837676f, -0.00627465f, 
    0.00620096f, 0.01024123f, 0.00080303f, 0.01151458f, -0.01855121f, -0.03153292f, 0.00227673f, 0.00155377f, 
    0.10682008f, -0.09569027f, 0.04692085f, -0.03333277f, -0.02834715f, 0.00715200f, -0.21844687f, -0.01132725f, 
    0.08889082f, -0.05309968f, -0.00120787f, -0.01446829f, 0.17649031f, -0.18130000f, 0.12587218f, -0.06742857f, 
    -0.01467716f, 0.05372921f, 0.06720123f, -0.06076720f, -0.06220264f, -0.13103598f, 0.18330128f, -0.11350141f, 
    0.01081671f, 0.38321468f, 0.08566552f, -0.03932418f, -0.19048546f, -0.09873258f, -0.00711359f, -0.04573590f, 
    -0.03098057f, -0.12747963f, -0.06377759f, 0.06791434f, -0.08935124f, 0.18017949f, 0.18966612f, 0.07745074f, 
    -0.02920922f, -0.00463923f, -0.15886405f, -0.09983875f, 0.00431137f, -0.05226814f, -0.02521090f, 0.10569522f, 
    -0.05483614f, 0.03004402f, 0.06179773f, 0.13543183f, 0.01391648f, -0.05047266f, 0.01414145f, 0.01762212f, 
    0.07031425f, 0.05756360f, 0.11383002f, 0.04042836f, -0.08212756f, 0.04987013f, -0.08653609f, -0.15829274f, 
    -0.00724539f, -0.02621643f, 0.09504599f, 0.10783766f, 0.00597953f, -0.16052672f, -0.12974228f, -0.04064770f, 
    -0.25701118f, -0.02257800f, -0.06828742f, -0.18122387f, -0.09962685f, 0.01150806f, 0.01522570f, -0.18992065f, 
    0.05725462f, -0.04561272f, 0.02223228f, 0.18639694f, 0.05070573f, 0.16456401f, 0.09163454f, -0.52800113f, 
    -0.00532003f, 0.00787058f, -0.04773606f, 0.02008607f, 0.21988975f, 0.17013915f, -0.03098564f, -0.00943984f, 
    -0.12741473f, 0.02790431f, -0.01924066f, -0.08654373f, -0.00003599f, -0.03922012f, 0.05603662f, 0.01691747f, 
    -0.04442859f, 0.03323824f, 0.03799789f, 0.02134521f, -0.27626649f, 0.20189333f, -0.08876387f, -0.00477079f, 
    -0.11755769f, -0.00735079f, 0.12889668f, 0.03825118f, 0.10054107f, 0.03510256f, 0.00979557f, -0.07792798f, 
    0.16277266f, -0.09716922f, 0.19318900f, -0.14102036f, -0.04998090f, 0.06004128f, -0.00295898f, -0.04047498f, 
    0.04798376f, 0.01448131f, 0.08336519f, 0.22330581f, 0.01683251f, -0.10187534f, -0.02546581f, 0.16174552f, 
    0.01564047f, 0.01882826f, 0.11780500f, 0.05107484f, 0.12468985f, -0.01100220f, 0.07260623f, 0.27966315f, 
    0.17582813f, -0.01860097f, 0.05053473f, -0.06374032f, 0.09586520f, 0.09300302f, 0.07411242f, 0.14034414f, 
    0.03337911f, -0.03209455f, -0.10329006f, 0.13325378f, 0.03157048f, -0.01294111f, 0.05277281f, 0.13604100f, 
    0.05741450f, 0.06321155f, 0.04647734f, -0.00250763f, -0.04505517f, 0.04099275f, -0.04209921f, 0.06605999f, 
    0.16426018f, 0.05340899f, -0.11116436f, 0.04823332f, 0.09891092f, -0.08122499f, -0.07812293f, 0.15453514f, 
    0.06742427f, -0.04725440f, -0.23217505f, 0.07327066f, 0.00589758f, 0.02667656f, 0.02797246f, -0.18779777f, 
    0.08956826f, 0.01575888f, -0.11524962f, 0.15314873f, 0.10755399f, -0.05598433f, -0.09514499f, -0.11469366f, 
    -0.35772082f, -0.10046601f, -0.32925510f, 0.17255931f, -0.01150666f, 0.26025444f, 0.20424941f, -0.01023014f, 
    -0.00443017f, -0.04558648f, 0.05976361f, 0.09173737f, 0.11127004f, 0.10084488f, 0.07252784f, 0.07733408f, 
    -0.08952262f, 0.01664416f, 0.02275615f, 0.00877715f, 0.14122866f, 0.06417935f, -0.06276750f, -0.08208175f, 
    0.20430720f, 0.18650712f, 0.13627651f, -0.24846770f, 0.04028927f, -0.08000822f, -0.08668611f, 0.02214790f, 
    0.16590609f, 0.02811323f, 0.02890459f, 0.09120772f, 0.16244645f, 0.09016045f, 0.14286217f, 0.12894924f, 
    -0.08109095f, 0.03026323f, 0.06653313f, -0.06117478f, 0.00912129f, 0.03854235f, -0.00328212f, -0.20650898f, 
    0.07738528f, 0.07447521f, 0.02870107f, -0.14490591f, 0.05228295f, -0.10829318f, -0.23934403f, 0.22622322f, 
    0.01663180f, -0.18649496f, -0.04315775f, 0.04845280f, 0.03818600f, -0.12159990f, -0.10205115f, 0.10275105f, 
    -0.09017982f, 0.13585503f, 0.02185090f, -0.00804004f, -0.02118628f, 0.00815558f, 0.03043937f, -0.05316855f, 
    -0.28430605f, 0.03735487f, 0.02164558f, 0.13847668f, -0.03101624f, -0.04516317f, 0.11057591f, -0.08165970f, 
    0.04891476f, -0.03157900f, 0.09711368f, 0.04970098f, 0.22075656f, -0.23561865f, 0.18745232f, 0.12232080f, 
    0.04464512f, -0.04767349f, -0.01321927f, -0.01796996f, -0.06261811f, -0.11847706f, -0.00935657f, 0.04810883f, 
    0.10205787f, 0.19824813f, 0.15684712f, 0.04176691f, 0.05126024f, 0.03051259f, -0.00523386f, 0.05408015f, 
    0.02149837f, -0.05435111f, -0.03697582f, -0.02857742f, 0.47390530f, 0.05214486f, -0.06335779f, -0.30990171f, 
    -0.03652909f, -0.09635665f, -0.17601430f, -0.03122510f, 0.10631315f, 0.08071443f, 0.07649768f, 0.05504130f, 
    -0.01963674f, 0.22255810f, 0.26817065f, 0.11032225f, -0.09115020f, -0.10620130f, -0.04675276f, -0.03931008f, 
    -0.05920296f, -0.03318660f, 0.04771370f, 0.19278476f, -0.31264839f, 0.13224331f, 0.11314033f, 0.23089138f, 
    -0.06778147f, 0.04647817f, 0.05182113f, 0.01233860f, 0.06803955f, -0.00388513f, -0.13698831f, -0.20212026f, 
    0.05517532f, 0.13080479f, -0.26334935f, -0.12106874f, 0.05335016f, -0.00813148f, 0.07579107f, -0.03273116f, 
    -0.05044783f, 0.03721786f, 0.02738431f, 0.06534179f, -0.00512060f, -0.07722536f, 0.02176586f, -0.00566467f, 
    -0.05078778f, 0.04986817f, -0.01233347f, -0.03854922f, -0.03929013f, 0.02071249f, -0.05522775f, -0.07524368f, 
    -0.08422915f, -0.00105875f, -0.06879668f, -0.04823272f, 0.01108739f, -0.04193683f, -0.07032143f, 0.01804537f, 
    -0.10099029f, -0.12407793f, 0.02518622f, 0.03152412f, -0.05828792f, -0.36228940f, 0.22379249f, 0.06339258f, 
    0.02509459f, 0.03399472f, -0.02944753f, 0.13155507f, 0.15164964f, 0.07316132f, 0.08254505f, -0.08726285f, 
    0.04081275f, 0.02790926f, 0.06435661f, -0.04819062f, 0.02000997f, 0.03519026f, 0.00296280f, -0.17074300f, 
    0.02042688f, -0.03956158f, 0.06543690f, 0.05644247f, -0.40384588f, 0.21579401f, -0.16525172f, 0.02380724f, 
    0.01127565f, -0.13981135f, 0.14302886f, -0.08148338f, -0.02053889f, 0.06379757f, 0.00445791f, 0.02889933f, 
    -0.14411643f, 0.03090929f, -0.09196573f, -0.04061275f, 0.01564641f, 0.08548348f, 0.00726057f, 0.17231412f, 
    -0.12868254f, 0.05706055f, 0.00211213f, 0.00044394f, -0.03423761f, -0.00513352f, -0.03006727f, 0.05837685f, 
    -0.01378274f, -0.01217742f, 0.06810583f, -0.00165062f, 0.02136072f, 0.02241635f, -0.02159067f, 0.01107337f, 
    0.33339390f, 0.08005340f, 0.10906968f, -0.11373122f, -0.13852358f, 0.07026789f, 0.13242315f, -0.20146495f, 
    0.00291679f, 0.12393257f, 0.02407511f, 0.00607001f, 0.17794304f, -0.06652062f, 0.04549755f, 0.06361827f, 
    0.11486184f, 0.08659346f, -0.07460392f, 0.10809335f, -0.03921545f, 0.10490875f, -0.14462481f, 0.03466471f, 
    0.35280854f, -0.02524349f, 0.10424878f, 0.11925211f, -0.11552603f, -0.04305058f, -0.16400039f, -0.01464360f, 
    0.05765215f, -0.01159796f, -0.00195901f, -0.16719003f, -0.04037070f, -0.16607010f, 0.08136134f, -0.13541856f, 
    0.05061568f, -0.09559175f, 0.05855936f, 0.00266476f, -0.03069858f, -0.05847305f, 0.00402470f, -0.02631044f, 
    0.08790738f, -0.19996551f, -0.01295356f, 0.02699347f, -0.02443385f, -0.09185720f, 0.13623992f, -0.06712855f, 
    0.03461095f, 0.00815420f, 0.06742314f, -0.05891458f, -0.05786380f, 0.10440590f, 0.04847021f, -0.23384914f, 
    0.08728661f, -0.01261311f, -0.08974749f, 0.00286934f, 0.01995094f, -0.02693374f, 0.00949634f, -0.00936921f, 
    -0.04312282f, 0.01783985f, 0.05574608f, -0.11340594f, -0.02933814f, -0.05784426f, 0.01436941f, 0.07887296f, 
    0.13734469f, 0.20272435f, 0.09264199f, 0.10805871f, 0.31022912f, 0.01699132f, 0.11863868f, -0.15861689f, 
    -0.05373031f, 0.02603183f, -0.02761695f, -0.00760907f, 0.04063153f, -0.01421033f, 0.02079113f, 0.01777594f, 
    -0.09717228f, 0.00773567f, -0.03722957f, 0.00499818f, 0.04146292f, 0.01316268f, 0.00570314f, -0.03015775f, 
    -0.10679524f, -0.00661614f, 0.13004866f, 0.23934631f, 0.01266127f, 0.13022402f, 0.03096060f, -0.00795422f, 
    -0.05232737f, 0.05141090f, 0.12914209f, 0.07718392f, -0.03472518f, -0.06898125f, 0.02043903f, -0.07349100f, 
    0.07953473f, 0.00994370f, 0.06270495f, 0.23768051f, 0.08220024f, -0.16318600f, 0.08873579f, 0.03498516f, 
    0.00541573f, 0.05235296f, -0.07024477f, 0.00844205f, 0.21403715f, 0.00733944f, 0.00885548f, -0.09921957f, 
    0.03099720f, -0.02083071f, -0.08962855f, -0.05598598f, -0.00526895f, -0.01044177f, -0.01704172f, 0.02918727f, 
    0.45226899f, 0.12396955f, 0.17610189f, -0.04621643f, -0.05030653f, -0.00178019f, 0.04592242f, -0.00564113f, 
    -0.00517563f, 0.06401408f, 0.04039201f, -0.12126869f, 0.12111617f, -0.21427830f, 0.06985957f, -0.16508220f, 
    0.11647103f, 0.00873063f, -0.05373736f, 0.03016499f, 0.07449529f, 0.03858139f, -0.05377559f, -0.00452936f, 
    0.07921235f, 0.00351018f, -0.03056040f, 0.12680607f, 0.09927377f, -0.05033462f, 0.08465305f, 0.05289804f, 
    0.15868315f, 0.18537208f, 0.00363326f, 0.16913655f, -0.02193704f, 0.05180940f, -0.27737278f, -0.01682924f, 
    -0.00534284f, -0.01350320f, 0.12594447f, 0.02434499f, -0.03016832f, -0.09390779f, -0.13218504f, 0.04062561f, 
    -0.18202583f, 0.12977147f, -0.08654971f, 0.04805452f, 0.04597162f, 0.18544298f, 0.01321814f, 0.07485071f, 
    0.07562829f, -0.09823957f, -0.16459098f, 0.07713404f, 0.25853971f, -0.00358176f, -0.24159329f, 0.01871398f, 
    -0.02934443f, 0.08231845f, 0.10946885f, -0.04035058f, 0.01240949f, -0.00212220f, -0.00486386f, 0.02314074f, 
    -0.26135698f, -0.15528439f, -0.30141598f, -0.01219398f, 0.11256076f, -0.08473630f, 0.11196466f, -0.11582240f, 
    -0.03709900f, 0.01571262f, 0.06784540f, 0.07937813f, -0.09873877f, -0.06019292f, -0.05707793f, -0.17722392f, 
    0.03476450f, 0.00153072f, 0.05896059f, -0.00268831f, -0.11315531f, -0.01924060f, 0.02176019f, 0.00552809f, 
    -0.04406518f, 0.43061131f, 0.14995612f, 0.06993914f, -0.12104361f, -0.07962971f, -0.09005406f, -0.06192766f, 
    -0.01399357f, 0.01559475f, 0.04462732f, 0.01652031f, -0.01088855f, -0.08357757f, 0.25826472f, 0.23696747f, 
    0.00294572f, 0.08371750f, 0.02760465f, 0.10995165f, 0.02160312f, 0.08263743f, 0.20891961f, -0.00449222f, 
    -0.04258864f, -0.00843839f, -0.02146887f, -0.04696894f, 0.04473192f, 0.12636772f, 0.12792055f, -0.02273809f, 
    -0.08157852f, -0.07292983f, -0.10659885f, -0.06886856f, 0.32136488f, 0.30268106f, 0.22102135f, -0.03146978f, 
    -0.07404286f, -0.05036370f, -0.06952906f, 0.01170527f, 0.02415239f, 0.04165459f, 0.10450724f, 0.00241308f, 
    -0.07255498f, 0.16091809f, 0.07240272f, -0.13699533f, 0.02631338f, 0.18426636f, 0.00480689f, 0.01266151f, 
    0.09945166f, -0.02445264f, -0.06043111f, 0.09676255f, -0.46087086f, 0.15158086f, -0.22911684f, 0.08082369f, 
    0.18102786f, 0.03248813f, -0.07338753f, -0.01864015f, 0.16995491f, 0.06886368f, 0.05526599f, -0.03815733f, 
    -0.17761631f, 0.01833125f, 0.05901606f, -0.09590304f, 0.00298451f, 0.06144692f, -0.13168760f, -0.19026358f, 
    0.10040948f, 0.05641619f, 0.02796874f, 0.12763983f, 0.20522463f, -0.35443419f, 0.14231677f, 0.06158469f, 
    0.15452242f, 0.03737718f, -0.00321137f, 0.09255607f, -0.09149611f, 0.00512088f, -0.07034232f, -0.02870051f, 
    0.26367825f, 0.11407693f, 0.06606379f, -0.07302322f, -0.07547107f, 0.08640797f, -0.08648731f, -0.00141289f, 
    0.15558900f, 0.00568236f, -0.08306718f, -0.05083827f, -0.08089592f, -0.11438394f, 0.01112506f, -0.04021632f, 
    -0.02081150f, 0.06828929f, 0.01468255f, 0.07277181f, 0.02134621f, -0.04009483f, 0.04282024f, -0.11021206f, 
    -0.11372141f, 0.13165653f, -0.29181284f, -0.21427755f, -0.13328290f, -0.04716943f, 0.00809033f, -0.02758170f, 
    -0.05395896f, 0.00673571f, -0.09642690f, 0.05731291f, -0.19955459f, -0.08914354f, -0.09248839f, -0.12395558f, 
    -0.05017376f, 0.02454292f, -0.06138119f, 0.07782312f, -0.12224242f, -0.06760322f, -0.07595950f, -0.12533894f, 
    0.17664394f, 0.09110939f, 0.13199939f, 0.07044878f, 0.01406294f, -0.00800279f, 0.02506292f, 0.01178826f, 
    0.03288953f, -0.04256186f, 0.00696144f, 0.06896213f, -0.13560882f, 0.27332953f, 0.17647856f, -0.18122138f, 
    0.04144160f, 0.00865177f, -0.01150288f, 0.13303831f, -0.06130834f, -0.01119055f, 0.07313174f, -0.00216967f, 
    -0.23016843f, -0.08723458f, -0.03806876f, -0.09777766f, -0.04114307f, -0.02737066f, -0.16027559f, 0.02129231f, 
    -0.17597081f, -0.19045685f, -0.05626820f, -0.08657094f, 0.15781039f, -0.44396317f, 0.02159780f, -0.14295496f, 
    0.13437729f, 0.16115700f, -0.06479657f, 0.05332700f, 0.08275729f, 0.00068195f, -0.04523723f, 0.00226704f, 
    -0.04774290f, -0.05730761f, 0.01195114f, -0.08021012f, -0.04121399f, -0.09163078f, -0.07192262f, 0.08546121f, 
    -0.07006344f, -0.05986844f, 0.00211046f, -0.06879426f, -0.04806684f, -0.22706193f, 0.30969071f, 0.02771560f, 
    0.02267559f, 0.06822764f, 0.09748376f, -0.00452190f, 0.14121123f, -0.07923692f, -0.10610063f, 0.03310570f, 
    0.26880997f, -0.08624737f, 0.01524633f, 0.07696918f, 0.03674206f, -0.07821119f, 0.01218432f, 0.06368756f, 
    -0.04036108f, -0.04448824f, 0.07340792f, 0.03669989f, 0.10057167f, 0.00652406f, 0.12467493f, 0.02236295f, 
    0.00370295f, -0.00696966f, 0.06108184f, -0.03987393f, 0.00432329f, -0.08094905f, 0.00622510f, 0.05466224f, 
    0.19292210f, 0.11325805f, 0.17626129f, -0.03946642f, -0.03798026f, 0.04519821f, 0.00197789f, -0.03343234f, 
    0.03425786f, 0.00251639f, 0.04757363f, 0.01198441f, 0.00986430f, 0.02810587f, 0.04198004f, 0.11193064f, 
    -0.03563929f, 0.09738082f, -0.00766897f, -0.01245524f, -0.07169925f, -0.02724271f, -0.04294105f, 0.13697948f, 
    0.16553284f, 0.07187135f, -0.02568343f, 0.03596886f, -0.02410338f, -0.02034756f, -0.07799323f, 0.04913975f, 
    -0.04686228f, 0.01276765f, -0.08652410f, 0.06083696f, 0.15916693f, 0.17693593f, 0.02599682f, -0.14683180f, 
    0.13372049f, 0.05009994f, -0.12827313f, 0.07339056f, -0.02793997f, -0.08653090f, 0.02595999f, -0.00799910f, 
    0.16946131f, 0.23271635f, 0.18038313f, 0.00074155f, 0.03534811f, -0.04882171f, -0.03111694f, -0.02905024f, 
    0.02336763f, -0.03296067f, -0.02714524f, 0.01164620f, 0.08834044f, 0.05927884f, 0.08388966f, 0.10579151f, 
    -0.00118094f, 0.03102056f, -0.01207965f, 0.05840940f, 0.13719018f, -0.05799166f, -0.00118301f, 0.13578980f, 
    0.26683593f, -0.31597662f, 0.08291341f, -0.08608376f, 0.02836107f, -0.02088458f, 0.04280992f, 0.16942023f, 
    0.06073487f, -0.12612738f, -0.02734996f, 0.08129384f, 0.09718958f, 0.00604858f, 0.08067013f, 0.11635126f, 
    -0.04064586f, 0.01773769f, 0.02274367f, 0.07670855f, -0.02879114f, 0.00802240f, 0.03096462f, 0.03040009f, 
    0.02825630f, -0.01662959f, -0.07021168f, 0.02488989f, -0.07229973f, 0.05903013f, 0.07413437f, 0.11005115f, 
    0.02704661f, 0.00141602f, -0.04300430f, -0.11267550f, 0.19983524f, 0.22336200f, 0.06865679f, 0.05672546f, 
    -0.11468778f, -0.06190119f, -0.07476354f, -0.01471257f, 0.07927428f, -0.01980881f, 0.04895607f, 0.05217244f, 
    0.12252897f, 0.15756479f, 0.21554232f, 0.18086040f, 0.04297546f, -0.05477839f, -0.02373563f, 0.05198843f, 
    0.02477450f, 0.05015101f, 0.02627982f, 0.11609694f, 0.08004877f, -0.40537256f, 0.11406653f, -0.05320458f, 
    -0.17063826f, -0.04145710f, 0.09120636f, 0.06515259f, 0.08083291f, -0.00728385f, 0.00865223f, 0.05175087f, 
    0.11279079f, 0.13554068f, 0.13712488f, -0.03371282f, 0.10486105f, 0.04323687f, -0.03332974f, 0.03715603f, 
    0.06182363f, 0.07210659f, 0.01023320f, 0.06787588f, 0.31372675f, -0.18977693f, -0.16008781f, -0.08888568f, 
    -0.00018646f, 0.04146282f, 0.03142872f, 0.03035549f, 0.17203416f, 0.03380156f, -0.09524820f, -0.01476147f, 
    -0.37702498f, -0.28689149f, -0.23071085f, -0.19531007f, -0.03221569f, 0.06587768f, 0.04268414f, 0.07335246f, 
    0.03643599f, -0.02501504f, -0.02440238f, -0.04671453f, -0.17413603f, -0.12033365f, 0.16423462f, 0.09892455f, 
    -0.04367262f, -0.00445608f, 0.01796122f, 0.05095422f, -0.00566158f, 0.02311883f, 0.07254353f, -0.12865984f, 
    0.02959744f, 0.16594242f, -0.00394454f, -0.07437297f, 0.04723467f, -0.05601424f, -0.08795448f, -0.04303737f, 
    0.02332744f, 0.05720404f, 0.01586121f, -0.00254350f, -0.12474237f, 0.12717834f, 0.05867247f, -0.05319875f, 
    -0.03791926f, 0.13466340f, 0.06516458f, 0.08672522f, -0.04234128f, 0.02983066f, -0.02429456f, -0.03425954f, 
    -0.13410600f, -0.05021610f, -0.02224799f, -0.08411333f, 0.01459542f, -0.13155958f, 0.15041769f, 0.15368210f, 
    -0.21770658f, -0.03377756f, 0.00114568f, -0.09659486f, 0.25708887f, -0.28217041f, 0.16908138f, 0.07858995f, 
    -0.12968008f, 0.05677236f, 0.12948047f, 0.06919383f, 0.05692797f, 0.02169398f, 0.04984497f, 0.04112790f, 
    0.09748575f, -0.03606123f, 0.09342644f, -0.02633869f, 0.13487451f, 0.06044839f, -0.06894998f, 0.06913816f, 
    -0.09025599f, -0.05511095f, 0.06758690f, 0.01454580f, -0.12344606f, -0.27232015f, 0.17468785f, 0.05922985f, 
    0.03419491f, 0.13773972f, -0.04435511f, 0.09563133f, 0.12412900f, -0.02047168f, 0.01778411f, 0.05348454f, 
    -0.01425944f, 0.21345091f, 0.08176662f, 0.01035796f, -0.04758590f, -0.04722166f, 0.01573522f, 0.09245538f, 
    -0.11399494f, -0.00679410f, -0.02438550f, -0.01074675f, 0.08757801f, 0.09537259f, 0.10236810f, 0.11748181f, 
    0.02106960f, 0.01555640f, -0.02076533f, 0.01733609f, -0.03439581f, 0.07072522f, -0.02150725f, 0.05507206f, 
    0.27017474f, -0.02015684f, 0.02984652f, 0.05088987f, 0.06638353f, 0.07448290f, -0.01231027f, 0.00005227f, 
    0.20515794f, -0.08083624f, -0.01899726f, -0.08842667f, 0.11286281f, 0.05115683f, -0.11669265f, 0.04831772f, 
    0.03724020f, 0.06070616f, 0.03917120f, 0.05770254f, 0.08299649f, 0.02609494f, -0.05024503f, 0.04225624f, 
    0.10752741f, 0.13101031f, -0.00019276f, -0.07951364f, -0.02706705f, -0.03164635f, 0.02142142f, 0.06615123f, 
    0.02154722f, 0.01665014f, -0.05200184f, -0.09659203f, 0.12869291f, -0.02517029f, 0.10661677f, -0.03721601f, 
    -0.00323758f, 0.13208243f, -0.02169960f, -0.01919501f, -0.03352409f, 0.02035163f, -0.06403645f, -0.05471599f, 
    0.05122085f, -0.13961363f, -0.02966912f, 0.00176862f, -0.08097757f, -0.00103586f, 0.17287479f, 0.00401396f, 
    0.08399444f, -0.01063177f, -0.12507945f, -0.02353027f, 0.18103950f, 0.03581746f, 0.13894945f, -0.03529660f, 
    0.05036004f, 0.09100292f, -0.05259021f, 0.00674345f, 0.10321446f, 0.03935717f, -0.09339435f, 0.01852531f, 
    -0.00187115f, -0.14520928f, -0.12085371f, -0.13560550f, -0.05660354f, 0.01103558f, 0.03008528f, 0.11418721f, 
    0.09663320f, 0.11189102f, -0.01926355f, -0.03389459f, 0.19677046f, 0.13574786f, 0.00731114f, 0.06303303f, 
    -0.02221143f, 0.02659296f, 0.05665466f, 0.11994649f, -0.04615476f, 0.10302869f, -0.03255410f, 0.00809572f, 
    0.01944893f, 0.09632806f, 0.02241305f, -0.04286396f, -0.01703417f, 0.01384531f, -0.02942978f, 0.04359113f, 
    -0.25260058f, 0.04496893f, -0.02492551f, -0.01967495f, 0.15021414f, 0.07553001f, 0.16392179f, 0.08292848f, 
    -0.05521423f, 0.11326671f, -0.06504646f, 0.04568978f, -0.10088877f, 0.03371995f, 0.03418510f, 0.06647584f, 
    0.20467423f, 0.12319246f, -0.00916808f, 0.07779578f, -0.01722174f, 0.01184778f, 0.03429540f, -0.01416976f, 
    -0.05944204f, 0.07798965f, -0.00380461f, 0.12718150f, 0.08951692f, 0.08826162f, -0.06065230f, 0.08022548f, 
    0.00751250f, 0.06499284f, -0.04355755f, 0.04258475f, -0.06375814f, 0.04870422f, -0.07070396f, 0.00513743f, 
    0.37023726f, 0.22084609f, -0.10221317f, 0.07847933f, -0.05662580f, 0.01146999f, 0.01413860f, -0.00721396f, 
    0.08018655f, -0.03823148f, -0.03780399f, -0.05653290f, 0.29487965f, 0.10021318f, -0.16855313f, -0.17826509f, 
    0.00662745f, 0.08496277f, -0.11230678f, 0.01042531f, -0.04856770f, -0.02447934f, -0.13419592f, 0.05369320f, 
    0.05789051f, -0.05107153f, 0.10074224f, 0.09621514f, 0.03895793f, 0.01971420f, 0.02346755f, 0.03091207f, 
    0.04451577f, 0.03650631f, -0.08910092f, 0.06083642f, 0.09321912f, 0.02996590f, -0.05974359f, -0.06647103f, 
    0.10573461f, -0.11004343f, -0.10661432f, 0.13856676f, -0.12711281f, -0.04266845f, -0.14294253f, -0.09380893f, 
    -0.04418225f, -0.01467563f, 0.04427794f, -0.09426829f, -0.01717138f, 0.12596549f, -0.02732214f, 0.06681120f, 
    -0.03232929f, -0.00231904f, 0.04759689f, 0.03495806f, 0.24719031f, 0.10390338f, -0.14939687f, 0.02142699f, 
    -0.03876667f, 0.01739775f, -0.06180161f, -0.10223828f, -0.04846385f, 0.06484015f, -0.01319848f, 0.02305209f, 
    0.21154039f, 0.03384510f, 0.16081630f, -0.08030210f, -0.09731825f, 0.01331541f, 0.08091734f, -0.04134785f, 
    -0.02959401f, 0.02093194f, -0.02750902f, 0.04284235f, 0.07138846f, 0.09697866f, 0.11458492f, -0.10338891f, 
    0.04377420f, 0.03481144f, 0.08647803f, 0.13503772f, -0.08627152f, -0.01395714f, -0.00590162f, -0.03969653f, 
    -0.40986201f, -0.09395523f, -0.16870318f, -0.26832613f, -0.08208518f, 0.01154622f, 0.03682172f, 0.09805521f, 
    0.03044559f, -0.06746015f, -0.03195219f, -0.06318711f, 0.09383915f, -0.07852159f, 0.12082317f, -0.00065291f, 
    -0.04344628f, 0.01371274f, -0.00857565f, 0.04048773f, -0.09328482f, 0.08664286f, -0.00330906f, 0.08627256f, 
    0.08514660f, 0.01834128f, 0.15710229f, 0.02014184f, 0.04965023f, 0.24941677f, -0.13974163f, 0.03659083f, 
    0.09049715f, 0.04354386f, -0.01459610f, 0.06264599f, -0.14809127f, -0.12997027f, -0.30065623f, -0.13978282f, 
    -0.06944254f, -0.00149774f, 0.01816153f, 0.04532735f, 0.03111717f, 0.03038740f, -0.11347551f, -0.16906586f, 
    -0.07944493f, 0.21062085f, 0.08805239f, 0.01040741f, -0.02346364f, -0.00209465f, 0.03582336f, 0.08101033f, 
    -0.01947505f, -0.02955305f, 0.07700113f, 0.03095561f, -0.47118834f, -0.05761449f, 0.10638577f, -0.11422440f, 
    0.22718939f, 0.10299586f, -0.04896085f, 0.14006077f, 0.11334229f, 0.02788585f, -0.02663888f, -0.10900620f, 
    -0.23061942f, 0.16589834f, -0.04073124f, -0.06777649f, -0.02430510f, 0.03548888f, -0.18379115f, -0.08568668f, 
    0.05594394f, -0.00464911f, -0.05729166f, -0.06887315f, 0.17953235f, -0.13948183f, 0.07888206f, -0.00661435f, 
    0.03072316f, -0.16078286f, 0.07416245f, 0.16461511f, 0.08493713f, -0.04102741f, -0.00145296f, 0.02789839f, 
    0.15312891f, 0.09581465f, -0.02775018f, -0.13689154f, 0.06117731f, -0.00356299f, -0.03038004f, 0.04168575f, 
    -0.05310388f, 0.04937277f, 0.04226575f, -0.02351638f, 0.27709526f, 0.08143964f, 0.05663224f, 0.07467238f, 
    0.11436283f, -0.09426396f, 0.07954323f, -0.04424068f, 0.09333925f, 0.01179998f, 0.00485941f, 0.08128213f, 
    0.27414480f, 0.02253575f, 0.38363773f, 0.06206745f, -0.02344924f, -0.06591702f, -0.01195856f, 0.07896865f, 
    0.10600828f, 0.12177363f, 0.01766463f, -0.07184424f, 0.13521862f, 0.09782791f, 0.03443697f, 0.05177603f, 
    -0.02231205f, -0.06046358f, 0.02426188f, 0.09027871f, 0.06509323f, 0.10675662f, -0.03563034f, -0.02179606f, 
    -0.33361644f, 0.00768294f, -0.12569214f, -0.05962497f, -0.02798870f, 0.00916605f, -0.02110820f, -0.08418832f, 
    -0.02342333f, 0.03434345f, 0.01273006f, -0.03865545f, -0.06794146f, -0.21978574f, 0.06772593f, 0.05512619f, 
    -0.05330427f, 0.28886616f, -0.01032058f, -0.04003461f, -0.04980506f, -0.05235250f, 0.03252311f, 0.07298455f, 
    -0.07314636f, 0.08199277f, 0.13580607f, 0.06590109f, 0.00028423f, 0.14049922f, 0.05327412f, 0.04174157f, 
    0.14401276f, 0.06782011f, 0.04062094f, 0.01981142f, 0.07454287f, -0.06981540f, -0.13579650f, -0.11750492f, 
    -0.05418542f, -0.04186859f, 0.01759670f, 0.05429095f, 0.06951964f, -0.03439108f, -0.00708302f, -0.08001132f, 
    0.13477565f, -0.14603156f, 0.04826612f, 0.07070953f, -0.04330650f, 0.08214354f, 0.10304209f, 0.09833042f, 
    0.01875849f, 0.05166905f, -0.03101435f, 0.05124203f, -0.00931622f, 0.12921344f, -0.01725223f, 0.11924244f, 
    -0.21924095f, -0.09348106f, -0.01339441f, 0.09689833f, -0.00576543f, -0.14387274f, -0.06708507f, 0.09574993f, 
    -0.20859672f, 0.24003047f, -0.07069607f, -0.07962997f, -0.02511125f, 0.02134369f, -0.09744867f, 0.03931373f, 
    -0.02243525f, 0.01352396f, 0.14007890f, 0.08444451f, -0.21550141f, -0.13437547f, -0.07802228f, 0.13044740f, 
    -0.03172957f, -0.04827309f, 0.01428892f, -0.05735133f, -0.04282577f, -0.02581824f, -0.03036417f, 0.04619741f, 
    0.09242719f, -0.00503423f, -0.04233272f, 0.03784711f, 0.08681206f, 0.12531847f, 0.10619885f, 0.02124759f, 
    -0.06824413f, -0.03993990f, 0.03413556f, 0.11855651f, 0.06050711f, -0.04887590f, 0.13266912f, 0.08778215f, 
    0.04290973f, -0.06563392f, 0.03415646f, -0.01535185f, 0.03529673f, 0.02895599f, 0.05377468f, 0.08406653f, 
    0.00263399f, 0.16758202f, -0.01881195f, 0.04724927f, -0.03573167f, -0.01417418f, 0.01333128f, 0.05022486f, 
    -0.02255807f, -0.02242048f, 0.03600105f, -0.00675606f, 0.08211876f, 0.00495417f, -0.28171590f, -0.05035898f, 
    0.17953266f, 0.08826207f, 0.07297840f, 0.05957104f, 0.01382329f, 0.01549023f, 0.00286473f, -0.05720333f, 
    -0.51777667f, 0.00470558f, -0.09961224f, -0.09542667f, -0.08379138f, 0.16033706f, 0.02410449f, 0.02965811f, 
    -0.01199114f, 0.02055739f, -0.01966481f, 0.02467983f, -0.03948184f, 0.10161547f, 0.01536529f, -0.01143224f, 
    -0.04014880f, -0.03214555f, 0.00511348f, 0.01744909f, -0.04166689f, 0.03443463f, 0.09575896f, 0.01252817f, 
    0.01971728f, 0.18175054f, -0.36566481f, 0.18762463f, -0.00965435f, -0.11169384f, 0.14722663f, -0.02293472f, 
    0.08210845f, -0.01851846f, -0.06844155f, 0.03203296f, -0.03250853f, 0.10747433f, -0.04724321f, 0.11609313f, 
    0.00939926f, 0.01469700f, 0.00163107f, -0.04500656f, 0.05980237f, 0.08101173f, -0.00587763f, 0.07750311f, 
    0.15125589f, 0.20075773f, -0.02719876f, -0.16331929f, 0.05129576f, 0.05867306f, 0.10194393f, 0.00852511f, 
    0.00407997f, 0.00014924f, -0.04514194f, 0.07769296f, -0.25786209f, -0.30730426f, 0.00214918f, 0.01267177f, 
    0.02221926f, 0.01332859f, -0.00292615f, 0.03566675f, -0.07218300f, 0.03741587f, 0.04259714f, -0.05601399f, 
    -0.35847947f, -0.02142594f, -0.12696742f, -0.08240611f, -0.17180915f, 0.02538335f, -0.00164460f, -0.07962052f, 
    -0.06539977f, 0.01427162f, -0.00871245f, 0.06485718f, 0.17209169f, 0.27488014f, 0.19556941f, 0.21333560f, 
    0.03618997f, -0.01996905f, 0.02301392f, -0.06464832f, 0.13822199f, 0.05790269f, 0.07608722f, 0.12750728f, 
    0.11324681f, 0.06204569f, -0.08293850f, -0.03647391f, 0.14981285f, 0.02010410f, 0.08196078f, 0.01350347f, 
    -0.05099217f, -0.06703121f, -0.07581221f, -0.05433534f, 0.13911879f, 0.18154944f, 0.02482558f, 0.07548390f, 
    0.07184215f, 0.00001103f, -0.00373032f, -0.08085769f, 0.15466575f, 0.01294230f, 0.04577716f, 0.10392678f, 
    0.12122765f, 0.29381928f, 0.10360500f, -0.01728489f, -0.04996100f, -0.00433719f, -0.04666194f, 0.16063505f, 
    -0.10026272f, -0.08499768f, -0.02158511f, 0.10246132f, 0.22416067f, -0.04105125f, 0.33639121f, 0.19158828f, 
    -0.09570181f, -0.04189530f, 0.06117095f, 0.04161093f, -0.09101176f, -0.15943398f, 0.04150433f, 0.10806761f, 
    -0.28479731f, -0.48388508f, -0.04195947f, -0.07648735f, -0.10304621f, 0.24042293f, 0.03697130f, -0.11423732f, 
    -0.03888807f, -0.00943429f, -0.04619200f, -0.02602690f, 0.11875205f, 0.11134848f, -0.01826560f, 0.15264523f, 
    0.09272785f, 0.06275412f, 0.06481243f, 0.12671374f, 0.01021644f, -0.00903139f, 0.03048291f, 0.00095410f, 
    -0.05421156f, 0.06985984f, -0.13264887f, -0.07611156f, -0.19422534f, 0.09977248f, -0.05915127f, 0.02609275f, 
    -0.04058464f, 0.06813102f, 0.06494194f, 0.06896357f, 0.25281078f, 0.14607966f, 0.10127285f, 0.10092194f, 
    -0.00839482f, -0.07875568f, -0.01221922f, -0.03741140f, -0.09673163f, -0.05098131f, -0.00116277f, -0.08240318f, 
    0.01724693f, -0.01908876f, -0.16121076f, -0.09972996f, -0.08791992f, -0.01507727f, 0.09497533f, 0.02480003f, 
    0.11666691f, -0.10221317f, 0.15173237f, 0.04804422f, -0.05949704f, 0.25459942f, -0.09348738f, 0.19945097f, 
    -0.02550950f, -0.04537496f, 0.28115088f, 0.01856614f, 0.02589979f, -0.03164844f, 0.00076998f, 0.09576888f, 
    -0.01207771f, -0.07221564f, -0.24314296f, -0.24671726f, 0.09286990f, 0.06278650f, 0.07870398f, 0.16523659f, 
    0.00698258f, 0.07299193f, 0.04616670f, 0.02205121f, -0.15649112f, -0.19620043f, -0.18125203f, -0.01402793f, 
    -0.03041859f, -0.03001521f, 0.05535760f, -0.06497391f, -0.02975177f, -0.00443796f, -0.03496432f, -0.03017752f, 
    0.02428134f, 0.18696146f, -0.34415060f, 0.05563387f, 0.01423515f, 0.05873744f, -0.08201756f, 0.20812808f, 
    -0.01055007f, 0.11812320f, -0.00877303f, 0.04562790f, 0.12020731f, 0.07264340f, 0.14533380f, 0.06050257f, 
    -0.10915422f, 0.01916008f, 0.11477897f, 0.07336777f, -0.02722775f, -0.05507306f, 0.09692688f, 0.01799270f, 
    0.14526972f, 0.20502661f, 0.07116155f, 0.05663405f, 0.06067570f, 0.06842047f, -0.04862982f, -0.02166579f, 
    0.08136335f, 0.01444758f, -0.02885845f, -0.07094783f, 0.06894546f, -0.01682241f, -0.05074029f, 0.10495459f, 
    0.06292086f, 0.08056572f, 0.02918725f, -0.04793506f, 0.07889679f, 0.06384431f, -0.02360114f, 0.05686732f, 
    -0.05450300f, 0.14991036f, 0.08362637f, -0.09507525f, 0.02045323f, 0.17950293f, -0.15353414f, -0.00550498f, 
    -0.02034028f, 0.09971886f, 0.06315177f, -0.00853211f, 0.02449778f, 0.19106592f, -0.10763877f, -0.04454857f, 
    -0.04024017f, 0.04387294f, -0.01871697f, 0.19603480f, 0.06116541f, -0.02925440f, -0.05637329f, -0.08791420f, 
    0.09861774f, 0.18435167f, 0.01872492f, 0.06354269f, 0.03348513f, -0.00919460f, 0.08157364f, 0.07251262f, 
    0.03570891f, 0.04068576f, -0.07762266f, -0.01774848f, -0.02166234f, 0.12585637f, -0.04056435f, 0.05581120f, 
    -0.06103324f, -0.07118841f, 0.03225606f, 0.02023819f, -0.05727252f, 0.05473297f, 0.05592014f, 0.03074550f, 
    -0.26861426f, 0.00641979f, -0.03165384f, -0.04302280f, -0.05453316f, -0.05608105f, 0.02978308f, -0.03092579f, 
    -0.04482445f, -0.14379817f, -0.08749839f, -0.01434588f, 0.06573694f, 0.08047386f, -0.24567962f, -0.07735186f, 
    0.09388573f, 0.04128880f, 0.11378294f, -0.03177943f, -0.03241093f, 0.00100491f, -0.05179028f, -0.02932470f, 
    -0.00428145f, -0.09830021f, 0.03384984f, 0.12042465f, 0.00030940f, -0.16657604f, 0.09981594f, -0.03032666f, 
    0.10865829f, -0.07212687f, -0.01597925f, -0.13743849f, -0.11661845f, 0.05530410f, 0.07191270f, -0.01804249f, 
    -0.02831366f, 0.07652796f, 0.02068911f, -0.06869778f, 0.02886279f, -0.07300156f, 0.06722400f, -0.00938519f, 
    0.01606220f, 0.12900709f, 0.09234311f, 0.07534551f, -0.07419423f, 0.03062548f, -0.06774499f, -0.01692094f, 
    -0.03851338f, 0.09437227f, 0.07556918f, 0.02788182f, 0.07512229f, -0.22168006f, 0.20547940f, -0.03276433f, 
    0.11510265f, -0.09549920f, 0.00542023f, 0.09558187f, 0.04837007f, -0.01620629f, 0.05412254f, -0.08664493f, 
    -0.13157561f, -0.00913146f, -0.10404161f, 0.07078310f, -0.03838091f, -0.03708803f, -0.01442179f, 0.02436522f, 
    -0.10555119f, -0.10685572f, -0.04130593f, 0.07853151f, -0.04546641f, -0.25249463f, -0.13225801f, 0.22246617f, 
    0.00924622f, -0.05298592f, 0.28309920f, -0.09641714f, 0.03214834f, 0.02354641f, 0.02261355f, -0.03771202f, 
    0.02425193f, -0.08594624f, 0.14085113f, -0.03347202f, -0.01257304f, 0.01532897f, 0.11192596f, 0.00836538f, 
    0.03430621f, -0.09164353f, 0.03149828f, 0.06656132f, -0.13631758f, -0.26611733f, -0.01781687f, -0.01030130f, 
    0.09908289f, -0.15968563f, 0.06563394f, 0.01748706f, 0.00856540f, -0.02626088f, 0.05531433f, -0.08702729f, 
    -0.22339055f, -0.16746838f, -0.02098084f, 0.08652323f, 0.13143565f, -0.06034596f, 0.13532631f, 0.16571376f, 
    -0.11377065f, 0.20811622f, 0.04372758f, 0.10322341f, -0.05486171f, -0.02082297f, -0.14180598f, 0.02051478f, 
    0.13467340f, 0.10718238f, -0.06729336f, 0.05046882f, -0.02882713f, 0.05543909f, -0.00795637f, 0.01622161f, 
    0.25305912f, 0.15475999f, 0.18039806f, 0.08451241f, -0.05963277f, -0.00338609f, -0.04542372f, 0.10018270f, 
    0.03314962f, -0.03093622f, -0.00942965f, 0.01713247f, -0.09975901f, 0.10574216f, 0.05447160f, 0.00354840f, 
    -0.01136022f, 0.05299202f, -0.00099592f, -0.05109158f, 0.00746126f, -0.14160545f, 0.05486897f, -0.03711043f, 
    0.10912092f, -0.04977652f, -0.21207023f, -0.01274761f, 0.13192990f, -0.00461170f, 0.13879919f, 0.02387852f, 
    0.02419406f, -0.06445997f, 0.07958245f, -0.06559330f, 0.23540206f, 0.17951603f, 0.14709488f, 0.04421710f, 
    -0.02047238f, -0.01397481f, -0.02129811f, -0.00259972f, -0.01029111f, 0.07582344f, 0.00184652f, -0.01708590f, 
    -0.22709075f, 0.06896758f, 0.06612800f, -0.16954628f, -0.17012587f, 0.19523866f, -0.02380024f, 0.07669014f, 
    -0.01816786f, -0.03350676f, 0.02044723f, 0.06292792f, 0.14036642f, 0.06464943f, -0.08888385f, 0.02132600f, 
    -0.17018326f, -0.00823733f, -0.01037390f, 0.01663197f, 0.01787159f, -0.01283414f, -0.06589952f, 0.06460967f, 
    0.07822160f, 0.06279745f, 0.06957391f, 0.09997996f, -0.00817290f, 0.05937921f, 0.06954886f, 0.13257432f, 
    0.05496000f, 0.04916836f, 0.06493741f, 0.02123450f, 0.28901273f, 0.14384013f, -0.31003734f, -0.03065551f, 
    0.01824026f, 0.07071429f, 0.04212295f, 0.13436644f, -0.09163979f, -0.01817730f, 0.06742337f, 0.06900799f, 
    -0.19546300f, -0.10008370f, -0.14052328f, -0.20111109f, -0.09119463f, -0.04711191f, 0.16900179f, 0.03287746f, 
    0.01818591f, -0.09646744f, -0.01646075f, 0.01560898f, -0.05662440f, 0.15047370f, -0.05734713f, -0.09137879f, 
    -0.10731652f, -0.12633170f, -0.08731302f, 0.09305494f, 0.01137292f, -0.00804412f, -0.00400255f, 0.15884952f, 
    -0.29696393f, -0.22690395f, -0.14696157f, 0.10835525f, -0.03753982f, -0.00577049f, -0.06322228f, 0.04909594f, 
    0.07445812f, 0.08119799f, 0.05550647f, 0.05630471f, -0.07502646f, -0.00037852f, -0.07259080f, -0.10077631f, 
    -0.06590692f, -0.01450425f, -0.03283528f, 0.03137960f, 0.14664537f, -0.02547032f, 0.07837868f, 0.05734135f, 
    0.05544396f, 0.09567322f, 0.12631214f, 0.00222132f, -0.03274526f, -0.03899863f, -0.04832177f, -0.02552079f, 
    -0.04337913f, -0.08190655f, 0.01479913f, -0.06001356f, 0.58387810f, 0.05698620f, -0.17045981f, 0.14561179f, 
    0.11126225f, 0.03010735f, -0.00513006f, 0.01493909f, 0.04956446f, 0.04989333f, 0.03124630f, -0.13207388f, 
    -0.06288821f, -0.06155906f, -0.09708273f, 0.00215672f, -0.02070441f, -0.04820310f, 0.20831008f, 0.11198037f, 
    -0.10329065f, 0.08973763f, 0.01829136f, -0.06899632f, 0.22476368f, 0.33617750f, -0.31156495f, 0.09140743f, 
    -0.00150864f, -0.00901031f, 0.26632789f, 0.10155193f, 0.02212605f, -0.02323077f, -0.07214473f, -0.10528345f, 
    -0.05301744f, 0.18548708f, -0.19024496f, 0.06421344f, 0.19138113f, 0.07559621f, 0.06868856f, 0.11217452f, 
    0.04129468f, -0.01073661f, -0.09604172f, 0.05609645f, 0.20939501f, 0.25552550f, -0.38964495f, 0.17700143f, 
    0.13993287f, -0.01267846f, 0.02194341f, 0.09005809f, 0.03658330f, 0.00566975f, 0.17804946f, 0.10207478f, 
    0.21678281f, -0.04208224f, 0.01678464f, -0.06173308f, 0.07385947f, 0.06473372f, 0.01309786f, -0.04738013f, 
    0.09788378f, 0.12103087f, 0.07345671f, -0.14233947f, 0.14698902f, 0.12735033f, -0.08351579f, -0.06122896f, 
    0.02710677f, 0.01992335f, 0.06981484f, 0.05753592f, 0.00447998f, 0.15887243f, 0.03204971f, -0.15296113f, 
    -0.07018717f, -0.05932781f, 0.06670913f, -0.09725519f, -0.01261305f, 0.01358324f, 0.08505841f, -0.03930575f, 
    0.04434839f, -0.01544360f, 0.12072401f, -0.05494271f, 0.08661985f, 0.08579248f, -0.00147155f, -0.07233461f, 
    0.03082887f, -0.01378679f, -0.04041804f, -0.05457524f, 0.19734173f, -0.01210050f, 0.03558401f, -0.12119406f, 
    0.01766357f, -0.08257684f, 0.08514787f, 0.03890133f, -0.00013773f, 0.06769823f, -0.05588363f, -0.18797940f, 
    0.11787879f, 0.00976506f, 0.27491891f, 0.09613135f, -0.07829814f, 0.02116171f, 0.14034766f, -0.06422369f, 
    -0.09217227f, -0.06193470f, 0.08718272f, -0.08373702f, -0.05698806f, 0.07409381f, 0.01826609f, 0.06395558f, 
    0.29826593f, -0.14470322f, -0.14476012f, 0.06666525f, 0.04505318f, 0.06925588f, -0.09196216f, -0.04012237f, 
    -0.04029912f, 0.01345465f, -0.05387944f, -0.08201290f, 0.22388445f, 0.14029296f, 0.13505009f, 0.03193500f, 
    0.01006101f, -0.02232345f, -0.05925422f, 0.00563913f, 0.07868519f, 0.00396890f, 0.08811855f, 0.14764093f, 
    0.22543447f, 0.20573853f, -0.12084255f, -0.16326524f, -0.02798832f, 0.02315148f, 0.08367596f, 0.01193602f, 
    0.07155594f, 0.14920203f, 0.09494887f, -0.03328452f, 0.03770593f, 0.09447578f, 0.10219204f, -0.13057752f, 
    0.04633858f, -0.01714828f, -0.02980865f, 0.01467567f, 0.04380818f, -0.00444949f, 0.04850865f, 0.13711424f, 
    -0.27208197f, -0.05013862f, 0.06411977f, -0.26656094f, 0.06799900f, -0.04383868f, -0.05056208f, -0.22341324f, 
    -0.05394813f, 0.09324974f, -0.01978320f, -0.10651906f, 0.06397720f, -0.02706320f, -0.14280248f, 0.01525956f, 
    0.07367267f, -0.03823756f, 0.08647510f, -0.03885987f, -0.03506295f, -0.00922057f, -0.07435470f, 0.04931814f, 
    0.23588182f, 0.07624812f, 0.02117026f, 0.01377537f, 0.05333985f, -0.05805821f, 0.01173062f, -0.00940868f, 
    -0.04263124f, -0.01150422f, -0.09567410f, -0.03447385f, 0.16567308f, 0.13858740f, -0.03996007f, -0.08590452f, 
    -0.01873409f, -0.09118665f, -0.15015596f, -0.06701362f, -0.03376198f, 0.19065298f, -0.08141166f, 0.05562554f, 
    -0.06766783f, 0.04185865f, -0.07286122f, -0.15753071f, 0.04095013f, 0.07314640f, 0.04458584f, -0.06143754f, 
    -0.01437718f, -0.01041689f, 0.03003661f, -0.11694923f, -0.14031900f, 0.07014485f, 0.04622746f, 0.11428159f, 
    -0.19807033f, -0.00614946f, 0.05773696f, 0.11272424f, 0.05199683f, 0.07536992f, 0.03912668f, -0.05677001f, 
    0.20903389f, -0.13716415f, 0.05474332f, -0.03058467f, -0.05639101f, -0.07589215f, -0.08264252f, -0.00217853f, 
    0.08263854f, -0.10245312f, 0.06999603f, -0.14362310f, -0.01996362f, 0.13217540f, -0.23154689f, 0.14341131f, 
    -0.01714097f, -0.03575597f, -0.01478916f, -0.05521589f, 0.01796372f, 0.04688121f, 0.13592568f, 0.30543718f, 
    0.07169617f, -0.19696486f, -0.07637293f, 0.29665309f, 0.06279213f, 0.11169477f, 0.25994566f, 0.17432986f, 
    -0.01149342f, -0.06161841f, 0.06351198f, 0.02009172f, -0.21160325f, -0.15775745f, -0.08504102f, -0.06770808f, 
    0.05080000f, -0.00059947f, 0.01502170f, 0.15172428f, 0.01093534f, -0.00380853f, 0.02278022f, 0.09087635f, 
    0.03811710f, 0.00865977f, -0.05768641f, 0.07191767f, 0.11329214f, 0.07927427f, 0.07988670f, -0.04937120f, 
    0.12262605f, -0.01378540f, 0.05184777f, -0.05546461f, -0.20149760f, 0.16325471f, 0.10135201f, 0.01839160f, 
    0.26646486f, 0.09650169f, 0.12726624f, 0.00756231f, -0.02224623f, 0.14726062f, 0.14845702f, 0.12193864f, 
    0.05775523f, 0.01719254f, -0.20156740f, -0.00995090f, 0.16028269f, -0.05083776f, 0.04055339f, 0.16399828f, 
    -0.04751412f, 0.07794071f, -0.01950223f, 0.00411127f, 0.08422815f, 0.16215697f, -0.10242311f, -0.12894495f, 
    0.20021485f, 0.06539147f, 0.11872483f, -0.04524168f, 0.00907122f, 0.15671691f, 0.12922905f, 0.03541725f, 
    -0.00104331f, -0.10706106f, -0.03584206f, -0.03618952f, 0.07112217f, 0.04093283f, -0.03954553f, -0.11191112f, 
    -0.01274065f, -0.12359560f, 0.08207831f, -0.08641404f, 0.02738122f, 0.10741767f, 0.02907019f, -0.01199162f, 
    -0.00113814f, -0.04323683f, -0.05083930f, -0.01135327f, 0.05779528f, -0.03280696f, 0.06457922f, -0.00600657f, 
    -0.30574885f, 0.07487041f, 0.12093778f, -0.49646565f, 0.13858292f, -0.06582558f, 0.03604215f, 0.13171908f, 
    -0.10256893f, -0.11945002f, -0.05595031f, -0.04372332f, 0.04983218f, -0.05483665f, 0.16166060f, 0.04876198f, 
    0.00408220f, -0.01710642f, -0.00635010f, 0.02809884f, 0.13491571f, 0.02126220f, 0.13774127f, 0.01158966f, 
    -0.17576163f, -0.22429614f, -0.23546916f, -0.24438310f, 0.02595269f, -0.02745644f, -0.03604769f, 0.16825855f, 
    0.03480323f, 0.10531841f, 0.06493453f, 0.12044285f, -0.16177581f, -0.18184587f, -0.30285102f, -0.03704843f, 
    -0.02275252f, -0.03880895f, 0.05541812f, 0.05863528f, -0.03002601f, -0.02883988f, -0.02345171f, 0.00914184f, 
    0.05317761f, -0.02611980f, -0.11494051f, 0.06756023f, -0.05206272f, -0.01491283f, -0.08801103f, 0.08271248f, 
    0.07577173f, 0.04195360f, -0.04612494f, 0.04269300f, 0.00237273f, -0.01618886f, -0.15591836f, 0.00620562f, 
    0.13175623f, 0.07726453f, 0.00353394f, 0.13635318f, 0.06931973f, 0.10801523f, 0.04412910f, -0.04199723f, 
    -0.18268305f, 0.03370707f, 0.06177269f, -0.09837326f, -0.00077411f, -0.01680138f, -0.09249748f, -0.08733494f, 
    0.03535913f, -0.15569967f, 0.07668395f, 0.00904472f, -0.02951718f, -0.13301538f, 0.04548835f, -0.12217887f, 
    0.04048366f, -0.01764770f, 0.02215407f, -0.01043382f, 0.24482758f, -0.05534894f, 0.22100230f, -0.07833379f, 
    0.12487451f, -0.09758655f, -0.03767195f, 0.00850374f, 0.00607184f, -0.07185131f, 0.11410581f, 0.02324503f, 
    0.16874556f, -0.07384706f, -0.07461125f, -0.25260282f, -0.08524715f, -0.06472014f, 0.02987429f, -0.23002414f, 
    0.19420621f, -0.02201405f, -0.00642118f, -0.15278758f, 0.03258564f, -0.02574208f, -0.07249980f, -0.00161330f, 
    -0.00459066f, 0.16389209f, 0.16277875f, 0.08645152f, 0.00548115f, -0.00337340f, -0.02170322f, -0.00442608f, 
    0.11675211f, 0.05212356f, 0.07788417f, 0.15297285f, -0.09048680f, -0.07354182f, 0.12751868f, 0.01331792f, 
    -0.04445119f, -0.03284395f, 0.13154821f, -0.03936552f, 0.05952733f, 0.11548991f, -0.01322961f, 0.04847803f, 
    -0.05692097f, -0.03311068f, 0.32918015f, 0.26617599f, -0.05266088f, -0.05780876f, -0.04659533f, -0.02270956f, 
    0.20919266f, -0.01219503f, 0.07689022f, 0.17362015f, -0.27377674f, -0.08669347f, -0.11135334f, -0.09197411f, 
    -0.08373370f, -0.00008597f, 0.11024567f, 0.03008610f, -0.08205847f, -0.00828770f, 0.06630983f, 0.05244844f, 
    0.16298696f, 0.13287565f, 0.04331849f, -0.05707358f, -0.03750871f, 0.00759075f, 0.00954729f, 0.00376866f, 
    0.12919064f, 0.05124765f, 0.13032039f, -0.03693314f, -0.12068602f, 0.00960319f, -0.05192572f, -0.01974514f, 
    0.06538918f, 0.28559217f, 0.32768464f, 0.05106697f, 0.08580827f, -0.02694734f, 0.23188767f, -0.12063543f, 
    0.00166112f, -0.14101608f, 0.07786427f, 0.00485471f, 0.01683457f, -0.01751793f, -0.05384632f, 0.02774306f, 
    -0.04690520f, 0.02192353f, 0.12666754f, -0.01904307f, -0.01699225f, 0.06480448f, -0.07230185f, -0.17275202f, 
    0.10784039f, -0.03302186f, 0.04358586f, 0.25832352f, 0.07460554f, -0.02401089f, -0.00930184f, -0.08456773f, 
    0.40017316f, -0.02843894f, -0.12602897f, -0.09053659f, 0.15833868f, 0.04386079f, 0.04279765f, 0.07437889f, 
    0.14427568f, -0.05205660f, 0.06224348f, -0.18337268f, 0.11966167f, -0.11833410f, -0.09053248f, 0.02466055f, 
    0.14502659f, 0.08366668f, 0.01835468f, -0.02878769f, -0.02275392f, 0.04434562f, 0.09192339f, -0.00438094f, 
    0.07291270f, -0.21268198f, -0.12296233f, 0.04447492f, -0.05140704f, -0.05052691f, -0.10107142f, 0.00999746f, 
    0.03895871f, 0.00794244f, 0.11881908f, 0.02357044f, 0.24817324f, 0.04566715f, 0.08937231f, -0.04521254f, 
    0.01038298f, -0.01597202f, -0.08620901f, -0.02851062f, 0.18771684f, -0.03945167f, 0.08528885f, 0.05158215f, 
    -0.18613832f, 0.06006983f, -0.05598748f, -0.11953918f, 0.09719661f, 0.00026078f, -0.09703732f, -0.06872784f, 
    -0.01908030f, 0.03318528f, -0.05099399f, 0.15287054f, -0.05336246f, -0.11069059f, 0.02334982f, -0.27627853f, 
    -0.10844956f, -0.07961243f, -0.04270272f, -0.00777750f, 0.14437300f, 0.01991577f, 0.08769323f, 0.03657838f, 
    0.54560816f, -0.17779545f, -0.00267210f, 0.21302971f, 0.20391059f, 0.08424998f, 0.14322068f, 0.14662597f, 
    0.08660813f, 0.19063973f, -0.06499346f, 0.19703789f, -0.14975695f, 0.13106263f, 0.04317879f, 0.00311847f, 
    -0.02182254f, 0.12614779f, 0.13505425f, 0.05023943f, 0.11610886f, 0.04393414f, -0.04042109f, 0.04342257f, 
    -0.19223730f, -0.07467244f, -0.11990575f, -0.03473954f, -0.07937745f, 0.00052302f, 0.22768322f, 0.22246920f, 
    -0.01996220f, -0.11220524f, 0.07950071f, 0.01354370f, -0.35997260f, 0.11105766f, 0.24999568f, -0.32079449f, 
    0.02434686f, 0.12919368f, -0.04749342f, -0.04710783f, 0.08232571f, 0.08358190f, 0.18444465f, 0.04310149f, 
    -0.03922560f, 0.00276471f, 0.16123325f, 0.01007940f, 0.02332700f, 0.16198988f, 0.15061539f, -0.02705602f, 
    0.14417097f, -0.07442817f, -0.01983107f, -0.12780166f, -0.10552637f, -0.30120054f, 0.12081262f, -0.18982232f, 
    -0.09780037f, -0.01841666f, 0.05168483f, 0.02514643f, -0.03544851f, 0.07607671f, 0.08134674f, 0.07847082f, 
    -0.04846871f, 0.19728403f, -0.06645062f, 0.12666619f, -0.07043209f, 0.02724801f, -0.03496787f, 0.02037339f, 
    0.06782264f, 0.12552109f, 0.11374796f, 0.10927672f, -0.13669315f, -0.01076608f, -0.03267280f, -0.00395569f, 
    -0.03564623f, -0.00885429f, -0.01554034f, -0.03279874f, -0.02506851f, 0.01887293f, -0.04490198f, 0.07696506f, 
    -0.19088873f, 0.02542895f, 0.06337897f, -0.05953539f, -0.04225000f, -0.10717093f, -0.00663375f, -0.05840240f, 
    -0.04105106f, -0.08260573f, 0.03619753f, -0.05432061f, 0.10885537f, 0.05505192f, -0.25271574f, -0.17378339f, 
    -0.02879661f, -0.10251015f, -0.11710051f, 0.10097311f, 0.10832147f, 0.00971028f, 0.06775038f, 0.09301897f, 
    -0.17699650f, -0.03760383f, 0.03842001f, 0.00204438f, -0.03857285f, 0.07306600f, -0.14720947f, -0.04819027f, 
    -0.26345780f, -0.03026070f, -0.17265093f, -0.13484405f, 0.04326151f, 0.27958629f, 0.03861578f, -0.10069864f, 
    0.08186387f, -0.01303155f, 0.02342689f, 0.05569084f, 0.22088453f, -0.08940395f, -0.00524527f, 0.13825658f, 
    -0.02054087f, -0.09537617f, -0.09902219f, 0.01467827f, 0.07384539f, 0.04487735f, 0.08030761f, 0.06588064f, 
    -0.04459738f, 0.01696052f, 0.00218472f, -0.02045681f, 0.07953321f, 0.46377850f, -0.32716843f, 0.28963873f, 
    -0.03715537f, -0.03665475f, 0.09252530f, 0.00562889f, -0.01090225f, 0.08066467f, -0.03018086f, 0.04212016f, 
    0.12711155f, 0.07719448f, 0.04194398f, 0.01265615f, 0.01341130f, 0.03162323f, -0.10229634f, -0.20002145f, 
    0.06461687f, 0.02650828f, 0.03382648f, -0.10054966f, -0.02335864f, 0.04168899f, -0.03125926f, 0.01282926f, 
    -0.03536513f, 0.03529337f, -0.01619765f, -0.00496392f, -0.12059039f, 0.07281235f, 0.02441052f, -0.14872883f, 
    -0.09133503f, -0.05052694f, 0.10588208f, 0.00824331f, -0.04567377f, -0.02171871f, 0.12780705f, 0.02306730f, 
    0.12274041f, 0.01197225f, -0.05810783f, -0.03762114f, 0.01643317f, -0.10040500f, 0.01596266f, -0.04348213f, 
    0.02292546f, -0.02226096f, 0.03258922f, -0.00899572f, 0.09386604f, 0.06212101f, 0.18593313f, 0.15839843f, 
    -0.12205921f, 0.03085188f, -0.17873640f, -0.13316828f, -0.07638308f, -0.21043313f, -0.12993139f, -0.03030686f, 
    0.00347055f, -0.01331234f, -0.11478171f, 0.16853817f, -0.16216967f, -0.00068279f, 0.05115392f, -0.06616571f, 
    -0.01853840f, -0.06920238f, -0.09620239f, -0.08555079f, 0.09754086f, -0.03995565f, 0.00900192f, 0.05628926f, 
    0.02775318f, 0.14117078f, -0.32230380f, -0.05675998f, 0.01117212f, 0.01085051f, 0.00204987f, -0.02329966f, 
    0.05888559f, 0.06720863f, 0.00001434f, 0.00751660f, -0.01675144f, 0.15831639f, -0.00221901f, -0.11588635f, 
    -0.06118726f, 0.01777447f, -0.02133194f, -0.07292198f, 0.07643244f, -0.03501644f, 0.09449411f, 0.29164788f, 
    0.25247189f, 0.25793815f, 0.23742944f, -0.13390301f, 0.07113633f, -0.02949317f, -0.03086297f, -0.03245354f, 
    0.13539132f, 0.12182494f, 0.04110631f, 0.02820976f, -0.25050521f, -0.04343594f, 0.07016332f, -0.03634344f, 
    -0.07855207f, -0.07661030f, 0.02651786f, -0.02862291f, 0.09595535f, 0.05442622f, 0.13879965f, -0.03710901f, 
    -0.30579129f, -0.10448176f, 0.22844771f, -0.05193751f, -0.02389577f, 0.00553864f, 0.06880599f, 0.13903792f, 
    -0.07332604f, 0.06656518f, 0.00081016f, 0.06266774f, -0.10864932f, -0.07015754f, -0.05238914f, -0.18338801f, 
    -0.03679946f, -0.03495961f, -0.03180275f, -0.03731871f, 0.02096944f, -0.05712018f, 0.07108680f, 0.01118746f, 
    -0.15858567f, 0.15963376f, 0.02772439f, -0.04364396f, -0.02771223f, -0.13503833f, 0.04097936f, -0.09337185f, 
    0.08087303f, 0.09421150f, 0.03416789f, 0.08990026f, -0.04581872f, -0.22811070f, -0.06260591f, -0.09182233f, 
    -0.07380519f, -0.13469218f, -0.02333685f, 0.10189784f, 0.04552041f, 0.10969193f, -0.12799017f, 0.11408857f, 
    -0.13177368f, -0.07978977f, 0.04296439f, 0.03107949f, 0.02096930f, 0.11541376f, 0.06217622f, 0.07186174f, 
    0.13655867f, 0.09021456f, 0.09974814f, -0.03415144f, 0.04889542f, 0.07584019f, 0.05850209f, -0.03243275f, 
    0.07762133f, -0.02570301f, 0.10241638f, -0.10487670f, 0.21917853f, 0.05927489f, 0.10345440f, 0.15900792f, 
    -0.17684808f, -0.10261136f, -0.09241700f, -0.00326024f, -0.02345040f, -0.00811986f, -0.04149621f, -0.02570787f, 
    0.15206602f, -0.01711834f, -0.00073599f, 0.13109262f, -0.17105046f, 0.25758860f, -0.08538926f, 0.15540464f, 
    -0.09447372f, 0.02108450f, -0.03405983f, 0.00392924f, 0.04022123f, 0.14511572f, -0.05191931f, 0.17499106f, 
    -0.29233006f, 0.07616370f, -0.19398871f, -0.04663143f, 0.06586126f, -0.04112357f, 0.12174416f, -0.08209982f, 
    0.00193876f, -0.08133256f, -0.10079133f, 0.00335177f, -0.06676698f, -0.17961334f, -0.00435724f, 0.18744515f, 
    0.09025032f, 0.15120405f, 0.06714521f, 0.15358301f, 0.04187135f, 0.07879952f, 0.02764248f, 0.05579072f, 
    -0.12005644f, -0.10271517f, -0.18036263f, -0.07526629f, 0.08590049f, 0.05361361f, 0.12155417f, 0.20774920f, 
    -0.03464429f, 0.03409723f, 0.02471032f, -0.04011653f, -0.00489424f, -0.01184959f, 0.00406649f, 0.02722635f, 
    -0.03205039f, 0.02158158f, 0.21946669f, 0.16202347f, 0.18572088f, 0.16149257f, 0.16012633f, -0.08145510f, 
    -0.00854536f, -0.03323216f, -0.00256043f, -0.04603317f, 0.17488469f, -0.00009819f, 0.06959394f, 0.00311236f, 
    0.02449225f, -0.07323689f, 0.03838017f, 0.15747958f, 0.09138502f, -0.09912648f, -0.30526721f, 0.37052402f, 
    -0.00090446f, -0.02458483f, 0.22265776f, -0.06215560f, -0.03152665f, 0.17297108f, 0.01556773f, 0.12654260f, 
    -0.26446775f, 0.00758553f, -0.06009279f, 0.16403297f, -0.07278667f, 0.10057982f, -0.02429591f, -0.03333603f, 
    -0.01913560f, -0.01142743f, -0.03072824f, 0.05512021f, -0.23643793f, -0.01054956f, -0.06230869f, -0.02108881f, 
    -0.05108650f, -0.11886805f, -0.02478665f, -0.03609385f, 0.05281059f, 0.01373201f, -0.00045942f, 0.03028536f, 
    0.11290868f, 0.12980320f, 0.00246339f, -0.01037290f, 0.15432492f, -0.00364046f, 0.17099717f, -0.04433077f, 
    0.15800074f, 0.06635583f, 0.03532798f, 0.12461801f, 0.17308336f, -0.19883864f, 0.02803316f, 0.04044434f, 
    0.07541922f, 0.08286658f, -0.00359170f, 0.09225280f, 0.17389758f, 0.05685678f, 0.15145352f, 0.24515985f, 
    -0.03440976f, -0.22220613f, 0.30010444f, 0.06019849f, 0.04962924f, 0.14947586f, 0.09118035f, 0.22414353f, 
    0.10109428f, -0.04887286f, 0.06067650f, -0.20117925f, -0.10775415f, -0.09156427f, 0.08215863f, -0.01798573f, 
    0.01869875f, -0.04409222f, 0.13449740f, 0.12606162f, 0.04829758f, 0.01242726f, 0.11788848f, 0.12287261f, 
    -0.09137350f, -0.03779054f, -0.02235503f, -0.03657624f, -0.09875224f, 0.07555157f, -0.00732090f, 0.05573240f, 
    0.16280134f, -0.05752196f, 0.15300032f, -0.04133940f, 0.01444332f, -0.01697241f, 0.05006280f, 0.08697097f, 
    0.19279876f, 0.24617301f, 0.02568112f, -0.02078516f, 0.03687027f, -0.07784234f, 0.09630211f, 0.02748927f, 
    -0.12000487f, -0.01780795f, -0.04592724f, -0.07334291f, -0.04428113f, 0.08217849f, 0.06816226f, 0.06063969f, 
    -0.18698782f, -0.07526448f, -0.10362677f, 0.02334872f, 0.08377303f, -0.04799569f, 0.02462441f, -0.17917840f, 
    0.01368783f, 0.03753815f, -0.01002755f, -0.11349763f, 0.09662181f, 0.02151233f, 0.20646171f, 0.10557915f, 
    -0.02967791f, -0.00531674f, -0.04157857f, -0.00729346f, -0.01767081f, -0.00173352f, 0.07492160f, -0.00237831f, 
    -0.11792089f, -0.12577958f, -0.05946481f, -0.19604520f, -0.16388659f, -0.23789789f, 0.03752263f, -0.05509183f, 
    0.00678582f, 0.00582888f, 0.08719439f, -0.07073577f, -0.00077713f, 0.06507711f, 0.06352105f, 0.09351738f, 
    -0.14749068f, -0.08446482f, 0.09652776f, -0.01572576f, -0.04379178f, -0.16591196f, 0.00328316f, -0.04020709f, 
    -0.03189556f, 0.05801390f, -0.14548387f, 0.12564044f, 0.02624393f, -0.05909623f, 0.01702831f, -0.05272222f, 
    0.19707431f, 0.02062309f, 0.02465295f, -0.01548687f, 0.12276924f, 0.05712581f, 0.09512629f, 0.21446083f, 
    0.10983177f, 0.17492363f, 0.02221327f, -0.00810531f, -0.11022620f, -0.08279947f, -0.03291330f, -0.02284456f, 
    0.17998420f, -0.01866991f, 0.03205485f, 0.16085295f, 0.13861991f, -0.11180145f, 0.23830909f, -0.10148213f, 
    -0.01534805f, 0.03257354f, -0.05508504f, -0.04132930f, 0.02027611f, -0.02588166f, -0.05453824f, 0.09053876f, 
    -0.08092545f, 0.02136106f, -0.01266553f, 0.06372926f, 0.01716781f, -0.08083735f, -0.00662631f, -0.07394677f, 
    -0.00135655f, 0.07301235f, 0.02005437f, -0.04294576f, -0.07786053f, 0.04271386f, -0.02792633f, -0.06611004f, 
    0.06162950f, 0.10725357f, 0.21652690f, 0.07708656f, -0.12212268f, -0.15550873f, -0.21589558f, -0.08261628f, 
    -0.03191610f, -0.16475584f, -0.28906426f, 0.21939926f, 0.12390910f, -0.01560307f, -0.05296284f, 0.04813169f, 
    -0.06769023f, 0.05199069f, -0.03009791f, 0.14677575f, -0.06188660f, -0.13196361f, 0.05271921f, -0.09101811f, 
    0.01992909f, -0.06626738f, 0.01610880f, -0.09810320f, 0.09592673f, -0.06633326f, -0.04741860f, 0.11898194f, 
    0.08745927f, 0.18836166f, -0.53097254f, 0.26880816f, -0.06950275f, -0.02211337f, -0.08530302f, -0.07830322f, 
    0.14907092f, 0.02928062f, 0.00140706f, -0.00755502f, -0.04758338f, -0.08223502f, 0.06789080f, 0.04874882f, 
    0.09967418f, -0.03951076f, 0.00897338f, 0.06629436f, 0.04461531f, -0.01080252f, 0.06304085f, 0.10080541f, 
    -0.16717172f, 0.08675683f, 0.00347600f, 0.12321381f, -0.04119303f, -0.03389672f, -0.10493876f, -0.04621709f, 
    0.10321927f, -0.01015466f, 0.03877210f, -0.03501622f, 0.20783131f, -0.02877547f, -0.01643648f, -0.07372270f, 
    -0.06351408f, -0.05042414f, -0.04194926f, 0.04187772f, 0.04001154f, -0.05230239f, -0.08271923f, -0.13721012f, 
    -0.22039163f, -0.09991704f, 0.13543716f, -0.11760795f, -0.14690308f, 0.10087642f, 0.20103100f, -0.15579388f, 
    0.03245037f, 0.05102782f, 0.04351222f, 0.24174401f, -0.04474364f, -0.08862048f, 0.09521810f, -0.11585689f, 
    -0.01900431f, -0.00003450f, 0.00963341f, -0.01048184f, -0.05455420f, 0.03765142f, 0.04982153f, -0.01409017f, 
    0.21249248f, -0.02678407f, -0.15466240f, -0.01963238f, 0.04317084f, 0.04461753f, -0.05125259f, 0.04274713f, 
    0.06977299f, 0.09506238f, 0.03381352f, 0.08679438f, -0.21108548f, 0.08516549f, -0.01391172f, 0.15971762f, 
    0.31805861f, -0.02206332f, -0.04883657f, 0.18744595f, -0.04847213f, 0.05271344f, 0.02551613f, -0.10391386f, 
    -0.07640317f, -0.04034126f, 0.13688715f, 0.19913267f, 0.04900980f, 0.16339900f, -0.01889962f, -0.11317354f, 
    0.01749297f, -0.08901186f, -0.11678694f, -0.09224480f, -0.13983034f, -0.36147159f, 0.26068425f, -0.17154470f, 
    0.12825571f, -0.11185236f, 0.08314100f, 0.09853621f, 0.20022582f, 0.16839819f, 0.08444704f, -0.01006768f, 
    -0.20857038f, -0.05231568f, 0.07725526f, 0.06573226f, 0.09101853f, -0.03260427f, 0.16605301f, 0.05999510f, 
    0.02180533f, -0.08813559f, -0.03565180f, 0.14554109f, 0.17616723f, -0.04952634f, -0.04114838f, 0.00513304f, 
    -0.01924564f, 0.02621038f, 0.04716650f, -0.20667583f, 0.13972266f, -0.09852424f, -0.14633974f, 0.10064510f, 
    -0.18525395f, -0.05941536f, -0.06590016f, -0.01192049f, 0.10500879f, -0.04284029f, 0.04710389f, 0.06235168f, 
    0.07255550f, -0.06480484f, 0.03959450f, 0.06545506f, 0.18487595f, -0.00562478f, -0.05245791f, 0.12973106f, 
    0.20796472f, -0.02149043f, 0.05413014f, 0.07644867f, 0.08998456f, -0.07355173f, 0.06656846f, 0.19310567f, 
    -0.01767099f, -0.19704233f, -0.10551808f, -0.01163493f, 0.04883303f, -0.00287523f, -0.07358307f, 0.03079260f, 
    0.05084704f, 0.00795238f, 0.03261140f, 0.04801305f, -0.20811500f, 0.01906561f, 0.07363074f, 0.26787189f, 
    0.16560261f, 0.12886056f, -0.16907577f, -0.05561597f, -0.02530958f, -0.04577446f, -0.08189204f, 0.04750467f, 
    0.12693393f, -0.10387831f, -0.25310975f, 0.05237089f, 0.07427526f, -0.10230656f, 0.06254611f, 0.04268772f, 
    0.11045366f, -0.08077847f, 0.11456908f, 0.11775398f, -0.46331093f, 0.48339590f, -0.02391865f, 0.13278091f, 
    -0.04610127f, 0.08169682f, -0.08370796f, -0.12782265f, -0.03933094f, 0.04231872f, 0.03365286f, -0.08924758f, 
    -0.16840762f, 0.46823534f, -0.33880487f, 0.04687160f, 0.12162475f, 0.03230529f, 0.03727077f, 0.02771194f, 
    -0.06231118f, 0.07843281f, -0.05908087f, 0.18524276f, -0.33338878f, 0.28384078f, -0.25217709f, 0.06904628f, 
    0.18349323f, -0.06976596f, -0.22191329f, -0.07752135f, 0.06651958f, -0.06302713f, 0.01337945f, 0.12175141f, 
    -0.02558809f, -0.16516343f, 0.03573482f, -0.17074136f, 0.02340733f, 0.14618468f, -0.02062562f, 0.07565708f, 
    0.11459775f, -0.01239344f, -0.04268787f, -0.05340685f, -0.10032599f, -0.05759369f, -0.06980850f, 0.14623968f, 
    0.09218369f, 0.10242943f, -0.06762005f, 0.03055920f, 0.18381079f, 0.06429309f, 0.20478947f, -0.05061634f, 
    -0.04820884f, 0.06296816f, 0.21900578f, 0.04920647f, -0.00178156f, 0.03957009f, 0.07186712f, 0.09828731f, 
    0.03430530f, 0.00795328f, 0.01639560f, 0.09545548f, 0.03627034f, 0.04675924f, -0.12483294f, -0.07364614f, 
    0.09485243f, -0.04126827f, -0.04118098f, -0.15236329f, 0.08759148f, -0.07389355f, -0.06873599f, 0.05829642f, 
    -0.10463107f, -0.05634146f, -0.03974976f, 0.02286596f, 0.09641744f, 0.14685908f, 0.07369500f, -0.22070673f, 
    0.07007854f, -0.00698350f, 0.13921735f, 0.12924159f, -0.08892392f, 0.03693661f, 0.33969569f, 0.16427933f, 
    -0.06826094f, 0.01522879f, 0.08532774f, 0.19602436f, -0.05578611f, 0.07103533f, 0.00066416f, 0.04696849f, 
    0.04788962f, -0.21538493f, 0.04159386f, 0.36053833f, 0.02932547f, -0.02913360f, -0.00705214f, 0.07224276f, 
    0.02673152f, -0.13045557f, -0.00765926f, -0.15456244f, -0.01412489f, -0.12685658f, 0.02122550f, 0.05548593f, 
    0.05277304f, -0.09189916f, -0.19701850f, -0.07386572f, 0.01289809f, 0.12239759f, 0.05618585f, 0.02389496f, 
    -0.25751698f, 0.31403422f, 0.05809657f, -0.13957962f, -0.09035558f, 0.12560280f, -0.03935215f, -0.16519906f, 
    0.03700283f, -0.03614623f, 0.14034876f, -0.02191027f, -0.05222937f, -0.04202630f, -0.03957166f, -0.14615467f, 
    0.05561921f, -0.13014816f, -0.27209362f, -0.19464615f, -0.05830953f, 0.04983450f, -0.12499265f, 0.15046966f, 
    0.11993268f, 0.05143476f, 0.15818000f, 0.00679033f, 0.13637523f, 0.03848919f, 0.03336408f, -0.09121066f, 
    0.05550860f, -0.03649892f, 0.11320440f, -0.10362317f, -0.27510971f, 0.00428595f, 0.00240326f, 0.04739867f, 
    0.17889374f, -0.11132533f, -0.01970359f, 0.17470951f, -0.05655591f, -0.01969638f, -0.09386288f, -0.00697674f, 
    -0.04229889f, -0.02462779f, 0.04958086f, 0.22343320f, 0.02614946f, -0.08450520f, -0.00812437f, -0.19413643f, 
    0.03871629f, -0.11186051f, -0.01685668f, -0.06743155f, 0.48414543f, 0.11321904f, -0.05683889f, -0.01985335f, 
    0.13615197f, 0.03191517f, -0.08685976f, -0.17915528f, 0.04506158f, -0.00788112f, -0.10403138f, -0.04231532f, 
    0.06837469f, 0.11530477f, 0.12273829f, 0.15118715f, 0.05055731f, 0.04297465f, 0.22408815f, -0.01299771f, 
    0.04437758f, 0.02808091f, -0.06412322f, -0.05369728f, -0.21605006f, 0.16282333f, 0.04241708f, -0.06707753f, 
    -0.08984842f, 0.17708246f, -0.09533437f, -0.01998329f, -0.03171561f, -0.02282725f, 0.15684892f, -0.08307657f, 
    0.45503470f, -0.08811931f, 0.17100467f, 0.25434336f, 0.11351854f, -0.17394666f, 0.02472132f, -0.07281623f, 
    0.00990931f, -0.08167469f, 0.01475989f, -0.01688218f, 0.11088245f, 0.07608996f, -0.21457633f, 0.31987026f, 
    0.03978523f, -0.01560714f, 0.00204186f, -0.06156342f, 0.03652341f, -0.17469285f, -0.02226321f, 0.21408737f, 
    -0.05452378f, 0.27717713f, -0.03384659f, 0.41714856f, 0.12213740f, 0.06338627f, -0.05619713f, 0.21916997f, 
    -0.05780021f, 0.00123202f, 0.13152090f, -0.07872767f, 0.06136873f, 0.05333911f, 0.08895136f, 0.00754303f, 
    0.06078935f, 0.07534543f, -0.14502852f, 0.04524485f, 0.01392499f, -0.03000477f, 0.07746319f, 0.10285990f, 
    0.44012633f, 0.10258166f, -0.12800218f, 0.13566804f, 0.04415955f, -0.07368714f, -0.02185013f, -0.07461311f, 
    0.12536189f, 0.08993630f, 0.12097616f, 0.13119990f, -0.25155437f, 0.27885956f, 0.13700885f, -0.06594258f, 
    0.06614561f, 0.09957152f, -0.04203198f, 0.22276284f, -0.06883369f, -0.00718187f, -0.05905240f, 0.09757718f, 
    -0.45174545f, 0.24105345f, -0.11896054f, -0.22198305f, -0.03150989f, 0.01083225f, -0.06607080f, 0.05198466f, 
    -0.00185338f, 0.01559923f, 0.03477873f, -0.00463167f, 0.03525548f, 0.21687463f, 0.00151663f, -0.01065552f, 
    0.18389943f, -0.02309166f, 0.08790395f, -0.16073835f, 0.02851307f, 0.03062687f, -0.02412289f, 0.00813302f, 
    0.21744613f, 0.13182847f, 0.19516703f, 0.12942429f, 0.12647265f, -0.00212996f, 0.09429367f, 0.12347196f, 
    -0.03928635f, -0.03654033f, 0.05807201f, -0.09834895f, -0.36553374f, -0.17033234f, -0.05667920f, 0.00165381f, 
    0.06247118f, -0.06635325f, 0.00509826f, -0.01797000f, 0.19191249f, -0.03259242f, 0.03345027f, 0.06334688f, 
    -0.25337863f, -0.10639281f, 0.39966077f, -0.08643484f, 0.04154976f, -0.01314674f, 0.10065084f, -0.11649787f, 
    -0.08193722f, -0.17220931f, -0.01678429f, 0.08853116f, 0.02656425f, -0.17314419f, 0.11586114f, 0.00218079f, 
    0.04896071f, 0.03350349f, -0.15349814f, -0.15476233f, 0.01070222f, 0.06823911f, -0.02130691f, -0.01072189f, 
    -0.04845706f, -0.05367479f, 0.12055688f, 0.13062066f, 0.07801753f, 0.02397739f, 0.02425954f, -0.02921745f, 
    0.11680627f, -0.00534495f, -0.10506350f, 0.06634858f, 0.01582284f, 0.16665418f, 0.05443976f, 0.11002586f, 
    0.03242363f, 0.02149512f, 0.03208988f, -0.03288434f, -0.04943304f, -0.06777032f, 0.05637573f, -0.02729703f, 
    0.15573174f, 0.08256209f, -0.40384412f, 0.11129078f, 0.10087437f, -0.10490024f, -0.08835396f, 0.04781977f, 
    -0.03419395f, -0.01345122f, -0.00451433f, 0.04601424f, -0.05297080f, 0.05370895f, -0.12067631f, 0.12069296f, 
    0.07752033f, -0.07805221f, 0.12193106f, 0.09212640f, 0.05885560f, 0.04187907f, 0.02673036f, -0.04137336f, 
    0.09545608f, 0.09365742f, -0.09289450f, 0.20337193f, 0.27305788f, -0.02538090f, 0.01334652f, 0.06081203f, 
    0.01100930f, -0.05982164f, 0.21727937f, 0.02965451f, -0.35640854f, -0.32983822f, 0.14615475f, -0.41439444f, 
    -0.06405298f, -0.05987849f, -0.09053426f, -0.18038265f, 0.15787899f, -0.00635080f, 0.07324799f, -0.08497021f, 
    -0.03475995f, -0.19496691f, -0.14248776f, -0.00005790f, -0.00645024f, 0.03828123f, 0.06023963f, 0.04951249f, 
    0.29642239f, 0.02226638f, 0.08496294f, -0.01447465f, 0.05733776f, 0.12309875f, 0.17383884f, 0.17936923f, 
    0.09215640f, 0.12002058f, 0.15029436f, 0.10285304f, 0.07289342f, -0.06062189f, -0.03292733f, -0.03045638f, 
    0.01965759f, -0.06907070f, -0.11360701f, -0.06665500f, 0.01251715f, -0.08259946f, 0.06718009f, -0.00368211f, 
    0.23044331f, -0.01198441f, 0.09033096f, 0.06187513f, -0.20199716f, -0.11819168f, 0.10601268f, -0.26483098f, 
    -0.08418931f, -0.09992045f, -0.06929760f, -0.05612740f, 0.09197825f, 0.07016513f, -0.07276323f, -0.02184216f, 
    -0.17134902f, -0.06386544f, 0.12138686f, -0.18313701f, 0.09068520f, 0.01627108f, -0.08501249f, -0.04279078f, 
    0.09615894f, -0.11503624f, 0.03995710f, 0.02111178f, -0.19497086f, 0.19107841f, 0.06047199f, -0.06448917f, 
    0.09721588f, 0.05059802f, -0.03892863f, 0.07539379f, -0.16199763f, -0.03190831f, 0.00628146f, 0.12650096f, 
    -0.16669689f, -0.09794744f, -0.01288666f, 0.08676624f, -0.01818955f, -0.04264671f, -0.08192300f, -0.15555920f, 
    0.21867311f, 0.04464844f, 0.14178738f, 0.00881451f, -0.11021014f, 0.29728940f, 0.04260571f, 0.16612037f, 
    -0.06604664f, 0.18642201f, 0.04047859f, -0.12262551f, 0.10132097f, -0.05173257f, 0.25640470f, -0.10159547f, 
    -0.00233525f, 0.13761687f, 0.10106301f, 0.04571394f, 0.04648596f, 0.01131228f, -0.12504426f, 0.01721846f, 
    0.01376478f, -0.14625457f, -0.19502881f, -0.04685058f, -0.35868427f, 0.18095498f, -0.05394743f, -0.13787362f, 
    0.10718003f, 0.05602873f, 0.02987523f, 0.27441224f, 0.02551293f, -0.05215781f, 0.08129130f, -0.08774136f, 
    0.15463147f, -0.17920408f, 0.02569333f, 0.17831247f, 0.33945158f, -0.09819406f, 0.02543006f, -0.06694926f, 
    0.06884693f, -0.05695442f, -0.04783123f, -0.12373852f, 0.12588914f, 0.05211875f, 0.08161899f, 0.21600042f, 
    0.03377989f, 0.02937849f, 0.02979988f, 0.13989824f, -0.00832766f, 0.11724158f, 0.09335766f, -0.02482643f, 
    0.15804394f, -0.08374013f, 0.13748105f, 0.17151633f, 0.05896759f, -0.01371715f, 0.02061060f, -0.15067962f, 
    0.06266455f, 0.04584112f, -0.05972987f, 0.00530877f, -0.04087866f, 0.06480664f, -0.06128718f, 0.02909119f, 
    -0.00086641f, 0.11045190f, -0.04530177f, -0.12202040f, 0.09177037f, -0.04376503f, 0.21271218f, 0.11429161f, 
    0.00088714f, 0.18470551f, -0.01570394f, 0.17857727f, 0.15326698f, 0.06341923f, 0.09002080f, 0.11530175f, 
    -0.00522167f, -0.07443010f, 0.01270112f, 0.03063715f, 0.23188984f, -0.25159368f, 0.06481364f, 0.07088905f, 
    -0.00456976f, -0.07654275f, 0.04293727f, -0.11653257f, 0.06375960f, -0.08122738f, 0.06086719f, 0.01893637f, 
    0.18584692f, -0.26251554f, 0.05307003f, 0.08114448f, 0.08906056f, -0.05007977f, -0.02208374f, -0.01462431f, 
    0.07160228f, 0.03022683f, -0.02384228f, -0.03306877f, 0.10916532f, 0.28096369f, -0.11498604f, 0.33926940f, 
    -0.07201964f, -0.01533974f, 0.10253212f, -0.10402606f, 0.00487058f, -0.16692503f, 0.03609849f, 0.02492591f, 
    0.06440049f, -0.05488180f, -0.04775075f, 0.08153145f, 0.04625884f, -0.12210259f, 0.05827935f, 0.14763904f, 
    -0.03593034f, -0.08763548f, 0.10597365f, 0.25868380f, -0.31366932f, 0.34652317f, 0.27221376f, -0.29643625f, 
    0.02424710f, 0.13573441f, -0.01301026f, 0.08598082f, 0.03837243f, 0.07616317f, -0.03738822f, 0.08264877f, 
    -0.03648074f, 0.02112601f, -0.03339384f, 0.02178368f, 0.00787333f, -0.02518472f, -0.02625165f, -0.03273906f, 
    0.01502801f, -0.00512881f, -0.01912981f, -0.01357234f, -0.02850505f, -0.01552836f, -0.03580644f, 0.01971820f, 
    0.03581707f, 0.01004830f, 0.00909513f, 0.02197609f, -0.01343460f, -0.02950161f, 0.02364732f, -0.03218964f, 
    -0.01833911f, 0.00836963f, 0.00452508f, -0.03415576f, 0.00667624f, 0.01059532f, 0.01568236f, -0.03946139f, 
    0.00024702f, 0.02641294f, -0.03533812f, 0.02717757f, 0.00983223f, -0.01449561f, -0.03454895f, 0.02053119f, 
    -0.01702995f, 0.02979010f, 0.01410229f, -0.02428014f, 0.00385551f, -0.00304410f, -0.04167259f, 0.02094435f, 
    0.03471290f, 0.00217594f, -0.01231326f, -0.00930463f, -0.01406487f, 0.01154484f, -0.00069500f, -0.02482264f, 
    -0.02191100f, 0.03002359f, 0.00461956f, 0.01280360f, 0.02257859f, 0.00154099f, -0.02733136f, 0.01083324f, 
    0.01579585f, -0.01492091f, 0.00593715f, 0.01401317f, 0.02962493f, -0.03899347f, -0.00985385f, -0.00286484f, 
    0.00658381f, 0.00094781f, 0.02351125f, -0.03670220f, 0.02597482f, 0.00352211f, -0.00688283f, 0.02969270f, 
    -0.01836930f, 0.00138257f, 0.02356959f, -0.04036037f, 0.02434487f, -0.00788382f, -0.03279272f, -0.00274600f, 
    0.03862747f, 0.01390247f, -0.01719195f, -0.03177726f, -0.03053819f, -0.02944085f, 0.02432456f, 0.02779766f, 
    -0.03928868f, -0.03478583f, -0.00842384f, -0.02696295f, -0.03909580f, -0.03906885f, 0.00661035f, -0.03891447f, 
    -0.02989735f, 0.01539871f, -0.01837339f, -0.02238965f, -0.01760282f, 0.02452619f, -0.02471112f, -0.02663074f, 
    -0.01893083f, -0.03859403f, 0.02196307f, 0.02544591f, -0.00725701f, 0.00260025f, 0.02695680f, 0.01063078f, 
    -0.02803012f, -0.00381374f, 0.00107786f, 0.00697491f, 0.00281448f, -0.00557758f, -0.04143790f, 0.02581933f, 
    0.01486672f, 0.01001018f, 0.00488253f, -0.03309108f, -0.01182303f, -0.02204050f, -0.03772261f, 0.02175069f, 
    0.02758976f, 0.00784306f, -0.04002941f, -0.02407335f, 0.04127822f, -0.02791433f, 0.03218466f, -0.02711575f, 
    -0.04117870f, 0.02713408f, 0.02715972f, -0.03027551f, 0.02567862f, -0.02224969f, -0.02696905f, 0.02450708f, 
    0.00372127f, 0.01370564f, 0.00497899f, 0.01936270f, -0.00620494f, 0.01946401f, -0.02094759f, 0.02853829f, 
    -0.00690866f, 0.02377535f, -0.02513895f, -0.01606292f, 0.00648439f, -0.03950455f, -0.03200388f, 0.00096028f, 
    0.02677666f, 0.01053056f, 0.01960430f, -0.02807442f, -0.00144443f, -0.01147276f, -0.02904662f, -0.00559835f, 
    -0.03284751f, 0.03662008f, 0.03735454f, -0.01173768f, -0.01501289f, 0.02785545f, -0.00751847f, -0.03336778f, 
    -0.00950968f, 0.01618706f, 0.01804089f, 0.02862525f, -0.01008490f, -0.03726127f, -0.00802230f, 0.02929069f, 
    0.01620230f, -0.02210309f, -0.02580532f, -0.04114927f, 0.00424145f, 0.00238158f, -0.02777328f, -0.01246155f, 
    0.01972151f, 0.00286727f, 0.00469160f, -0.00514009f, -0.00770609f, 0.01688343f, 0.01631967f, -0.03491345f, 
    -0.03782048f, -0.04012679f, -0.02780605f, -0.03268835f, -0.00737973f, 0.02257313f, -0.00094414f, -0.00678657f, 
    -0.01267374f, -0.01171444f, 0.00597812f, -0.03714751f, 0.02804229f, -0.01147273f, -0.03929947f, -0.03207212f, 
    -0.02773752f, -0.01022236f, 0.00952166f, -0.00475425f, -0.02234624f, -0.00741690f, -0.03090059f, -0.02224468f, 
    -0.03284346f, -0.04158586f, 0.02629207f, 0.02069005f, -0.02266205f, 0.02275275f, -0.02599422f, 0.03379887f, 
    -0.00696612f, 0.00636107f, 0.00498984f, 0.01254552f, 0.03761538f, -0.00722018f, -0.00746204f, 0.00825780f, 
    -0.03748157f, -0.03191124f, 0.01079299f, -0.00371276f, -0.03827251f, 0.01282221f, 0.03441509f, -0.01725010f, 
    0.00256757f, -0.00468449f, 0.02097069f, -0.00877072f, 0.00926071f, 0.02299845f, -0.03593998f, -0.02091912f, 
    -0.00741034f, -0.01144465f, -0.01579938f, -0.02492964f, 0.01587019f, -0.02266646f, 0.02591349f, 0.00472047f, 
    -0.01486162f, -0.02562788f, -0.02849903f, -0.03363421f, 0.00166734f, 0.03918837f, 0.01533213f, -0.02023691f, 
    0.04116458f, 0.02150774f, -0.00009662f, 0.00344733f, 0.00132702f, -0.03036011f, -0.02407738f, 0.02593107f, 
    -0.00416290f, -0.00889822f, 0.00589766f, 0.02853489f, 0.00663113f, 0.00610494f, 0.02918696f, 0.00844156f, 
    -0.03577113f, -0.00979907f, -0.02187294f, 0.00362212f, 0.02081947f, 0.01179226f, -0.00684479f, 0.01478574f, 
    0.02149797f, 0.01440376f, -0.03546907f, -0.02152066f, -0.02012665f, 0.03005234f, 0.02966262f, 0.00869668f, 
    0.01714494f, 0.01774132f, -0.03303749f, -0.03348542f, -0.01605304f, 0.01036495f, -0.00138258f, -0.01621326f, 
    -0.00164885f, 0.00368821f, -0.02825456f, -0.02722247f, -0.02987124f, -0.00049573f, 0.03377464f, 0.01926804f, 
    -0.00164275f, 0.00045496f, 0.01085024f, -0.01064499f, 0.02549701f, 0.03213640f, 0.04046389f, 0.01775357f, 
    0.01465879f, -0.01750531f, -0.02035113f, 0.01889453f, -0.03397015f, -0.00766971f, 0.00808480f, -0.03102937f, 
    0.02380629f, 0.00132684f, -0.02257142f, -0.03183183f, -0.00092276f, -0.01328582f, -0.02682819f, -0.01749764f, 
    0.01278740f, -0.02758610f, -0.00646960f, -0.00963800f, -0.00267163f, -0.01216783f, 0.02441775f, 0.02472002f, 
    -0.03185980f, -0.00120797f, -0.00140553f, -0.02649399f, -0.02382843f, 0.02476928f, -0.00204119f, -0.03806181f, 
    0.01498641f, -0.03160487f, -0.00951847f, 0.02341481f, 0.02011194f, 0.02640008f, -0.00976312f, -0.00899784f, 
    -0.03163657f, 0.00631615f, -0.03853109f, -0.01224158f, 0.01983091f, -0.02057040f, 0.02355959f, -0.03608551f, 
    -0.01530788f, 0.00074114f, -0.03691263f, -0.01837600f, -0.00677562f, -0.02731341f, 0.02899332f, 0.02003901f, 
    -0.03981289f, 0.01982982f, -0.00912711f, -0.00673422f, -0.03869196f, -0.03536662f, -0.00317874f, 0.01341157f, 
    -0.01881370f, 0.02369311f, -0.02443320f, 0.02665559f, 0.01770958f, 0.01300293f, 0.00595436f, 0.02092644f, 
    -0.00174705f, 0.01159747f, -0.02394499f, -0.02803649f, 0.03952830f, -0.02312952f, 0.01638647f, -0.02460049f, 
    -0.01896955f, -0.01581539f, -0.01114943f, -0.03192747f, 0.02066595f, 0.02756258f, -0.03599463f, 0.01845444f, 
    -0.01982828f, 0.00513244f, -0.01164022f, -0.01649825f, -0.00138582f, 0.00642570f, -0.00005100f, 0.03258186f, 
    -0.02350991f, -0.01810505f, 0.01356642f, -0.02298813f, -0.01730785f, 0.02598380f, -0.02296547f, 0.00160608f, 
    -0.01675911f, 0.01410608f, -0.02171590f, -0.01734825f, 0.01114643f, 0.00318136f, 0.00324428f, 0.02525327f, 
    -0.01750446f, -0.02814792f, -0.01612152f, 0.01200566f, -0.03648030f, -0.01327639f, -0.02376675f, 0.01909802f, 
    -0.03953897f, 0.01158026f, 0.02952880f, -0.00464849f, -0.02779094f, -0.03600007f, -0.01005853f, -0.00807023f, 
    0.02532032f, 0.01309376f, -0.02944663f, 0.02604118f, -0.02460347f, 0.02931672f, -0.03874885f, -0.02072309f, 
    0.00347185f, -0.02510344f, 0.01528080f, 0.01901308f, -0.01738940f, 0.02896818f, -0.03351954f, -0.00237447f, 
    -0.03201834f, -0.04169779f, -0.01977425f, 0.01941524f, -0.00149844f, -0.01248069f, -0.01408143f, 0.01644680f, 
    0.02453021f, 0.02470439f, -0.02982548f, -0.00641677f, -0.03012246f, -0.01958765f, 0.01002601f, -0.00616134f, 
    0.01881343f, -0.03044595f, -0.00567855f, -0.00911344f, -0.01331547f, -0.02831614f, -0.01727132f, -0.02330157f, 
    -0.03183028f, -0.00209178f, -0.00812582f, 0.00480332f, 0.03620334f, 0.00902510f, -0.02441291f, 0.03732073f, 
    -0.03656608f, -0.01647911f, 0.00090108f, -0.01728543f, 0.02533491f, 0.01912556f, -0.00486994f, -0.04135419f, 
    0.02827285f, 0.01084623f, -0.01357736f, -0.04011694f, -0.00814672f, -0.00306011f, 0.02495127f, -0.01839186f, 
    -0.02291438f, 0.02103724f, -0.00463352f, 0.02593639f, 0.01002068f, -0.00246949f, -0.03150607f, 0.02518786f, 
    0.00786004f, -0.00269620f, -0.02145657f, -0.03688033f, 0.02205909f, -0.03664693f, -0.00379309f, 0.01077020f, 
    0.00480556f, -0.03351592f, -0.00400608f, 0.00009534f, -0.02414477f, -0.00332955f, -0.03900695f, -0.03903195f, 
    -0.02452705f, -0.03210614f, 0.01049342f, 0.00819469f, -0.03079732f, 0.00763657f, 0.02968090f, 0.02256782f, 
    -0.00869980f, -0.03940184f, 0.03971053f, 0.02216867f, 0.02602251f, -0.02602419f, -0.01615808f, 0.00957982f, 
    0.01629592f, -0.03690388f, -0.02080713f, 0.01067630f, -0.02378268f, -0.03277469f, -0.03146340f, -0.00537059f, 
    0.00874258f, 0.02596024f, 0.00039963f, -0.00781882f, -0.02515902f, 0.02339363f, -0.03883689f, -0.02948240f, 
    -0.01344056f, -0.02433335f, 0.02824606f, -0.02792237f, -0.01500548f, 0.01336150f, 0.01662121f, 0.02444203f, 
    -0.02626315f, -0.00941399f, -0.02062585f, -0.01284500f, 0.00835054f, 0.02789843f, -0.02387779f, -0.03725107f, 
    0.00817493f, 0.01231258f, 0.01626360f, -0.00977237f, -0.01187513f, -0.01557747f, -0.01575696f, 0.00652951f, 
    -0.01850418f, -0.02417668f, -0.03381265f, 0.02325563f, -0.01519444f, 0.02629884f, -0.01113166f, -0.00312561f, 
    -0.02947191f, 0.01752524f, -0.01532868f, 0.00952963f, 0.02468657f, -0.01202256f, -0.02077273f, -0.00758723f, 
    0.00062404f, 0.02499622f, -0.01875702f, -0.00402172f, 0.01262315f, -0.03702291f, -0.03888673f, 0.00628360f, 
    -0.02237951f, -0.01351935f, -0.01208409f, -0.01781199f, -0.03792352f, 0.01105097f, -0.01902066f, 0.01132104f, 
    0.00207015f, 0.03345487f, 0.00724666f, -0.03230825f, -0.02272518f, -0.03003550f, 0.02948067f, 0.00397014f, 
    0.01839393f, -0.00760054f, -0.00148064f, 0.00392052f, 0.00317321f, -0.02229430f, 0.01951613f, 0.00101875f, 
    -0.04174565f, -0.01902598f, 0.01167274f, 0.01930730f, 0.03579647f, -0.01758268f, -0.01544389f, 0.01139633f, 
    -0.00067579f, 0.01974252f, -0.01983169f, 0.01671356f, 0.02126290f, -0.02897222f, 0.01625860f, -0.02199112f, 
    0.01489056f, 0.01292435f, 0.02186017f, -0.00664694f, 0.02042751f, 0.01066826f, -0.02063701f, 0.02816621f, 
    0.01078844f, 0.02438041f, -0.01505360f, -0.03415071f, -0.01589028f, -0.02161285f, 0.01156582f, -0.03241289f, 
    -0.00902474f, -0.00666902f, -0.02489041f, 0.01697608f, 0.03472354f, 0.02709690f, -0.01810547f, -0.01426420f, 
    -0.02554834f, -0.01156504f, 0.02105626f, -0.00216609f, 0.00606845f, -0.02262361f, -0.03290649f, 0.00755433f, 
    -0.02640137f, -0.00148333f, -0.00840635f, -0.00605246f, 0.00331547f, -0.01508978f, -0.00747666f, 0.00734844f, 
    -0.01916563f, -0.03629282f, -0.00502592f, -0.00950588f, 0.02363689f, 0.01566937f, -0.04101294f, -0.00935294f, 
    -0.00290951f, -0.02134659f, 0.01780693f, -0.03411375f, -0.02537994f, -0.01872349f, 0.01182820f, -0.01901499f, 
    0.01596461f, 0.02681320f, -0.00481194f, -0.01879634f, -0.04143080f, -0.02499837f, 0.01305070f, 0.00677257f, 
    -0.03786892f, -0.00062355f, 0.00550272f, 0.00261799f, 0.01804224f, -0.03785056f, 0.01178849f, -0.03971554f, 
    -0.00919643f, 0.01193989f, -0.03884489f, -0.03178894f, -0.01669143f, -0.02827068f, -0.02086908f, -0.04195561f, 
    -0.02523591f, 0.01093726f, -0.01703284f, 0.00538175f, -0.01396347f, 0.00916659f, -0.00922907f, -0.02687932f, 
    0.02663622f, -0.02033094f, -0.02567187f, -0.02100123f, 0.01707140f, 0.00472779f, 0.00736027f, -0.00459595f, 
    -0.00777214f, -0.03470720f, 0.01034452f, 0.02399945f, 0.02498238f, 0.02767132f, -0.03217187f, -0.00693759f, 
    -0.02904696f, -0.03749990f, -0.03804817f, -0.03209558f, -0.04053259f, 0.02588436f, 0.02211970f, 0.00633050f, 
    0.02572159f, 0.00632745f, -0.01475076f, 0.01591787f, 0.00093357f, -0.01306642f, -0.00659437f, -0.03071842f, 
    0.02930070f, -0.03913454f, 0.00467882f, 0.01876257f, -0.01942366f, 0.01419625f, -0.01943423f, -0.01410123f, 
    -0.02340172f, -0.03677735f, -0.00122516f, -0.00812969f, -0.01880157f, 0.02252001f, -0.01537841f, 0.00422188f, 
    0.00489836f, 0.00139610f, -0.03122045f, 0.02436503f, 0.00249768f, -0.02011599f, -0.00092262f, 0.00769700f, 
    -0.03487221f, 0.00177583f, 0.00150759f, -0.00694109f, 0.02929043f, -0.00220356f, 0.00036004f, -0.00884037f, 
    0.02113736f, 0.00067460f, 0.00730269f, -0.03509521f, 0.01876898f, -0.01373129f, 0.02243575f, 0.00541267f, 
    -0.02174284f, -0.02717321f, -0.02128563f, -0.00918070f, -0.00255864f, 0.01846028f, -0.03284744f, 0.02121567f, 
    0.00524802f, 0.00815509f, 0.01151635f, 0.02655011f, -0.02224363f, -0.02944050f, 0.02641662f, 0.01376812f, 
    -0.01295693f, -0.01761927f, -0.01706213f, -0.00195747f, -0.03625929f, -0.04068512f, -0.01317859f, -0.02592468f, 
    -0.00061573f, 0.02997320f, -0.01637696f, -0.01441322f, -0.04002383f, -0.00078309f, 0.00909131f, -0.00642529f, 
    -0.02264087f, -0.02738103f, 0.01560940f, 0.02982969f, -0.03829900f, 0.00007855f, -0.04163226f, 0.00796038f, 
    0.02684791f, -0.03445179f, -0.04153825f, -0.03853966f, -0.04099126f, -0.01687968f, -0.04134518f, -0.01528992f, 
    -0.03945347f, -0.00813461f, -0.02000187f, 0.00019146f, -0.02712413f, 0.01000909f, -0.01055118f, 0.02550838f, 
    -0.01020335f, -0.03991333f, -0.00078362f, -0.02289404f, -0.01214430f, -0.00328259f, -0.03870356f, -0.02701312f, 
    -0.03576555f, 0.01833656f, 0.02085494f, 0.02165884f, -0.00750664f, -0.01419568f, 0.02367429f, -0.03800889f, 
    0.01602230f, -0.03024000f, -0.03407691f, -0.02698646f, -0.02976450f, -0.02845092f, 0.01803335f, 0.01657159f, 
    0.01403267f, 0.02630516f, 0.01121543f, 0.02405171f, 0.02801763f, -0.01882967f, -0.03559421f, -0.03248767f, 
    0.02610304f, -0.03583242f, 0.01359108f, 0.01418299f, 0.01377350f, -0.03238843f, -0.01187765f, -0.02476268f, 
    -0.03082234f, 0.00304593f, 0.01121034f, 0.02242411f, -0.02848864f, 0.01163845f, 0.00185831f, -0.03288928f, 
    0.01340231f, -0.01925688f, 0.01323518f, -0.03411652f, -0.02551786f, -0.02704667f, -0.03687546f, -0.02049094f, 
    0.01090062f, -0.03189602f, -0.01766878f, -0.02293460f, -0.01591494f, 0.01962295f, -0.03253792f, -0.02111117f, 
    -0.03137897f, -0.02984427f, 0.00394129f, -0.01383516f, 0.01359739f, 0.01769463f, 0.02432653f, -0.02427987f, 
    0.00158430f, -0.03927168f, -0.01903702f, -0.03484175f, -0.00805198f, -0.04199353f, -0.03203252f, 0.00568287f, 
    -0.02274183f, 0.00081249f, -0.01184245f, 0.00994310f, 0.00779008f, 0.01716886f, -0.01314592f, 0.00107463f, 
    -0.03793146f, -0.01948977f, -0.00463764f, -0.03413759f, 0.01249627f, 0.02827716f, 0.02923027f, 0.02197744f, 
    -0.00468063f, -0.00042541f, -0.01808366f, 0.00024149f, 0.01750442f, -0.01817702f, 0.00008850f, 0.02584650f, 
    -0.03588574f, 0.00163706f, 0.02179141f, -0.03397236f, 0.02035250f, -0.03714366f, -0.01361578f, 0.01284109f, 
    -0.02147013f, 0.01827799f, -0.02803853f, 0.02295266f, 0.00721774f, -0.01205424f, 0.00285587f, 0.02090056f, 
    -0.00525047f, 0.01293781f, -0.02882407f, -0.01850125f, 0.01179714f, -0.01423466f, -0.03831919f, 0.01539471f, 
    0.00887777f, 0.00776443f, 0.01593344f, 0.00774315f, 0.01817048f, -0.02277393f, -0.03476435f, -0.03467879f, 
    -0.01464044f, -0.01812359f, -0.03643181f, -0.03377818f, -0.02063385f, 0.01905054f, 0.02456806f, -0.01624429f, 
    -0.02050726f, 0.02510924f, -0.00429882f, 0.00335316f, -0.03006384f, 0.00566733f, 0.02476509f, -0.02987714f, 
    0.01426013f, 0.02105535f, -0.00840410f, 0.02829698f, 0.00689223f, -0.03455133f, 0.01394414f, -0.03186858f, 
    -0.01966556f, 0.01155566f, -0.01488712f, -0.01368799f, -0.01830338f, -0.01004285f, -0.01996124f, -0.03781645f, 
    0.01245156f, -0.01476866f, -0.01125138f, -0.02954687f, -0.02574143f, 0.01233259f, -0.02413878f, -0.00354131f, 
    -0.00304043f, -0.00514651f, -0.02376782f, -0.02336844f, -0.00203531f, -0.00899539f, 0.02169832f, -0.01956734f, 
    -0.01430235f, -0.01393559f, -0.03779056f, 0.00582949f, 0.01064600f, -0.00920087f, -0.02668183f, -0.03148543f, 
    -0.01560556f, -0.00451798f, 0.03397311f, 0.00293552f, -0.00171113f, 0.00940156f, -0.00971636f, -0.03774629f, 
    0.01173126f, -0.02628681f, -0.00180027f, 0.01799211f, 0.01135085f, -0.04043293f, -0.01008184f, 0.01741957f, 
    0.00297151f, -0.01782383f, -0.00211206f, -0.02203066f, -0.01953513f, -0.01436887f, -0.00860561f, 0.00633263f, 
    -0.02360291f, 0.01779543f, -0.01969196f, 0.02495975f, -0.00098178f, 0.00350808f, -0.02948167f, -0.03616595f, 
    0.02321174f, -0.01178180f, -0.02912065f, 0.03706722f, -0.00847981f, -0.00703318f, 0.02132688f, 0.00097580f, 
    -0.00668255f, -0.01364323f, 0.00227881f, -0.03573459f, -0.01640548f, -0.02124050f, -0.00379049f, 0.01236477f, 
    0.02358838f, 0.01805793f, 0.02081760f, -0.03293588f, 0.01635753f, 0.02651472f, -0.00997071f, 0.00435758f, 
    -0.02552123f, -0.03302881f, 0.00439348f, 0.01889000f, 0.01980115f, 0.02057732f, -0.02696193f, -0.00439445f, 
    0.00274684f, 0.02764016f, -0.03898059f, 0.01494271f, 0.01900102f, -0.04167661f, -0.02691218f, -0.01758226f, 
    0.02092929f, -0.03925259f, -0.01949814f, 0.02766794f, -0.01541310f, -0.02674491f, -0.03537050f, 0.02873201f, 
    0.01654323f, -0.00539426f, -0.00063643f, -0.02463478f, -0.00380580f, -0.01978341f, -0.04161473f, 0.00915435f, 
    -0.00145803f, 0.00560426f, -0.03250130f, 0.01435198f, -0.02765170f, -0.03001904f, -0.01508934f, 0.00346431f, 
    -0.02203507f, 0.00937889f, 0.02096381f, -0.03602581f, 0.02973534f, 0.00517664f, 0.01474568f, -0.02701855f, 
    -0.04103037f, -0.00648001f, -0.04119660f, -0.02322779f, -0.01809362f, -0.02906694f, 0.01330736f, 0.00901583f, 
    -0.00424584f, -0.02126856f, -0.04173116f, -0.00430714f, 0.01696655f, 0.00523475f, -0.02743228f, -0.00716975f, 
    0.02239437f, -0.00707133f, -0.02855661f, 0.00490939f, 0.00652112f, -0.03200888f, 0.00729664f, -0.02554966f, 
    0.00887435f, -0.01432190f, 0.00148566f, 0.00577605f, -0.00745530f, 0.00436709f, 0.00713442f, 0.02717519f, 
    -0.02867370f, -0.01937095f, 0.01508318f, -0.00129648f, 0.00184531f, -0.03570012f, -0.02196302f, 0.00553790f, 
    0.02831046f, -0.03890880f, 0.02211534f, -0.00784887f, 0.00684505f, 0.02824673f, 0.02534650f, -0.02457395f, 
    0.00237349f, -0.02845493f, -0.03607799f, 0.00216649f, -0.00515186f, 0.00330836f, -0.01872660f, -0.04178805f, 
    0.00689205f, -0.02872260f, 0.00589685f, -0.01706922f, -0.00231763f, -0.01923402f, -0.01944950f, 0.03140938f, 
    0.02803842f, -0.01406857f, 0.02935153f, -0.03015375f, 0.00437448f, -0.02093873f, 0.00194920f, 0.02975108f, 
    0.02236744f, 0.02812719f, 0.01444464f, -0.02849762f, 0.00365425f, -0.02575826f, 0.01424183f, -0.01764171f, 
    0.00917454f, 0.02898208f, -0.03697934f, -0.00988964f, 0.02237737f, -0.01139310f, -0.01145663f, -0.02357657f, 
    0.02574746f, 0.02990947f, -0.01871071f, -0.03147260f, 0.02931320f, -0.00153355f, 0.01245430f, -0.01307536f, 
    0.00858794f, 0.00705442f, 0.01204596f, 0.00545040f, -0.04082227f, -0.02550468f, -0.00511529f, 0.02897514f, 
    0.01337938f, -0.03835447f, 0.02448959f, 0.00433542f, 0.01048867f, -0.02181447f, -0.00076199f, -0.03271779f, 
    -0.01434086f, 0.00774514f, -0.02656960f, -0.02278901f, -0.00851803f, -0.00805583f, -0.01383357f, 0.00667319f, 
    0.02694803f, -0.03543439f, 0.00028148f, -0.00399987f, -0.01044010f, 0.00653255f, -0.03288861f, -0.00386153f, 
    -0.02510627f, 0.02653829f, -0.00565820f, -0.01789211f, 0.01863760f, -0.00022232f, 0.02854945f, 0.01105532f, 
    -0.02081408f, 0.02255470f, 0.01827321f, -0.00901660f, -0.03043157f, -0.02723042f, -0.02808352f, -0.03302697f, 
    0.02284411f, -0.00302413f, -0.00423183f, -0.01542038f, -0.01733284f, -0.02333665f, 0.02386134f, -0.03842994f, 
    0.02326038f, 0.00263713f, 0.00727907f, 0.00370604f, 0.00715402f, 0.00504785f, -0.03869381f, -0.01584903f, 
    -0.03497312f, 0.00169507f, -0.01427536f, 0.02976777f, 0.03486035f, -0.02111875f, 0.02360908f, 0.03566813f, 
    0.00836400f, -0.02815100f, -0.04077858f, -0.00482364f, -0.03213004f, -0.01889780f, 0.00451934f, 0.02101420f, 
    -0.00504374f, -0.03265023f, -0.02925252f, -0.00068646f, -0.02769080f, -0.01593216f, 0.00402987f, 0.00253558f, 
    -0.00712402f, 0.01846093f, 0.00224391f, -0.01727126f, 0.01861125f, -0.02497316f, -0.03321699f, 0.00087144f, 
    0.01071020f, -0.03039685f, 0.00108261f, -0.01608053f, -0.00042811f, 0.01851313f, 0.00803510f, -0.03538158f, 
    -0.02335927f, -0.02948062f, -0.03767698f, 0.00035400f, -0.03940715f, -0.01966685f, 0.00281997f, -0.02311568f, 
    -0.01507883f, -0.01467091f, 0.01798529f, 0.02332759f, -0.00825324f, 0.02421567f, 0.01051894f, 0.02563031f, 
    0.02028829f, -0.00640716f, 0.01930563f, -0.02180708f, 0.00965794f, -0.01433020f, 0.02497623f, 0.00569647f, 
    -0.02840100f, -0.02980912f, 0.00468069f, -0.03069096f, 0.01618667f, 0.02843175f, 0.01506894f, 0.00658729f, 
    0.00307016f, -0.02000138f, 0.00480427f, -0.01543438f, 0.00806705f, -0.03833629f, 0.02866788f, 0.02415946f, 
    0.00964481f, 0.02643575f, 0.02477204f, -0.00206959f, 0.02936405f, 0.01378257f, 0.02892398f, -0.00663882f, 
    -0.02559713f, 0.01871410f, -0.02063142f, 0.02633185f, 0.02091838f, -0.01140269f, 0.02380399f, 0.02334563f, 
    0.01325374f, -0.02657257f, -0.02820612f, 0.00054646f, -0.00916434f, -0.02142317f, -0.04053143f, -0.03350026f, 
    -0.00023531f, -0.02300920f, -0.03989222f, -0.00084567f, 0.00171262f, -0.02107986f, 0.00485569f, 0.00512043f, 
    -0.02011529f, 0.01854007f, 0.01489945f, 0.00774623f, -0.03201517f, -0.03031820f, -0.00738713f, 0.00856347f, 
    -0.00284024f, -0.00307132f, -0.03948219f, 0.01650458f, -0.03765553f, -0.01898336f, 0.00892730f, 0.02270523f, 
    0.01539662f, -0.00848437f, 0.01928816f, -0.02796928f, 0.02280728f, 0.00665738f, -0.01280583f, -0.03183533f, 
    0.04019863f, -0.00626129f, 0.01985565f, -0.01993048f, -0.02485413f, 0.01746560f, 0.01505497f, -0.02715030f, 
    -0.03295502f, -0.03790765f, -0.03939351f, -0.03612576f, -0.03777445f, -0.00076967f, 0.01859758f, -0.01747974f, 
    0.02212602f, 0.01473811f, 0.00796636f, -0.03164244f, -0.01337485f, -0.01353596f, -0.02402233f, 0.01754823f, 
    -0.00280003f, 0.01095159f, -0.00466040f, -0.02673960f, 0.00905335f, 0.02025409f, 0.01934226f, 0.00901656f, 
    0.00502539f, -0.00515266f, -0.01040787f, -0.03653206f, -0.02276294f, -0.01109183f, -0.00632720f, 0.00573081f, 
    0.01525321f, -0.02246056f, 0.00995879f, -0.01503776f, -0.02525298f, -0.03839373f, -0.02677860f, 0.00488966f, 
    -0.00346955f, -0.01002133f, -0.00085518f, -0.00104056f, 0.01123486f, -0.02147133f, 0.00519670f, -0.03707692f, 
    -0.02180967f, -0.10273118f, -0.16571674f, 0.02192591f, -0.03504815f, 0.06929000f, -0.05471987f, -0.01865596f, 
    -0.07340481f, 0.01852693f, 0.02617593f, 0.05474417f, -0.08611723f, 0.10732087f, -0.01519017f, -0.04614270f, 
    -0.11858714f, 0.00996384f, -0.18188839f, 0.14919102f, -0.05581049f, 0.13401191f, -0.02926132f, -0.01291494f, 
    -0.20719902f, -0.02880958f, -0.02879977f, -0.02676525f, 0.04182376f, 0.01167170f, -0.00550332f, -0.06373543f, 
    -0.14004299f, 0.10578670f, 0.00901027f, 0.15318391f, -0.24903657f, -0.11900374f, 0.03317638f, -0.10331660f, 
    0.05101785f, 0.11660204f, 0.01433841f, -0.01139050f, -0.04153423f, 0.03885658f, 0.03438487f, -0.08388841f, 
    0.06568736f, 0.01026911f, -0.00961398f, 0.02073167f, 0.01210352f, -0.03703668f, -0.00495097f, 0.03766883f, 
    0.00170705f, -0.06287451f, 0.01764626f, -0.02869945f, 0.58171731f, 0.20775717f, -0.00515974f, -0.09860593f, 
    -0.13611488f, -0.05269302f, 0.21963857f, -0.12052044f, -0.03795252f, -0.04769863f, -0.01463385f, -0.21786201f, 
    0.04573048f, -0.14056246f, -0.18497711f, -0.12132248f, -0.05079411f, -0.04418068f, 0.20699167f, 0.03728982f, 
    -0.14304122f, 0.16798708f, 0.07903017f, -0.16236551f, 0.53005713f, -0.13417096f, 0.12605105f, 0.05912404f, 
    0.05922117f, -0.03260348f, 0.19708388f, 0.10144959f, 0.06301003f, 0.00296647f, -0.09899370f, 0.06179931f, 
    0.14781027f, -0.17001703f, 0.24636702f, -0.12377924f, 0.16695826f, 0.06365082f, -0.00898589f, -0.02608180f, 
    0.05746668f, -0.04581257f, 0.04569194f, -0.09550066f, 0.32376504f, -0.08971539f, 0.33799616f, -0.02198805f, 
    0.02807783f, -0.03623439f, 0.04019520f, 0.05231186f, 0.03099119f, 0.19694966f, 0.08760356f, -0.09000206f, 
    0.07040600f, -0.01027902f, -0.01325754f, 0.08880927f, 0.03851597f, 0.00808399f, 0.10375253f, 0.01249861f, 
    0.03397175f, 0.17356473f, 0.06505097f, 0.04620469f, 0.07324631f, 0.02720076f, 0.10547411f, -0.07239856f, 
    -0.03324180f, 0.08625936f, 0.11892562f, -0.00516858f, 0.09431389f, 0.18860590f, -0.00940241f, 0.09415793f, 
    -0.00586095f, -0.06855109f, -0.25318015f, 0.07756609f, -0.03639678f, 0.00732282f, 0.01341109f, -0.03562238f, 
    -0.01054765f, 0.12066127f, 0.05730270f, 0.03799331f, -0.06779052f, 0.05247023f, -0.00013395f, 0.01535342f, 
    0.01814182f, 0.06256236f, -0.12608011f, 0.06736303f, 0.06023880f, -0.06428371f, 0.09118777f, -0.18480575f, 
    0.07122660f, 0.01916789f, 0.06382550f, 0.05815932f, -0.07232410f, 0.12790480f, -0.02946937f, -0.07599193f, 
    0.06222169f, 0.02197323f, 0.03101221f, -0.14244358f, 0.13561936f, -0.12995689f, -0.31724909f, 0.11611556f, 
    -0.07764030f, -0.08323047f, 0.03179738f, -0.14326642f, -0.00833100f, 0.04160674f, 0.04351455f, -0.00167052f, 
    0.40252179f, 0.16038013f, 0.04483967f, -0.06180969f, -0.11106043f, 0.00063893f, 0.01792196f, -0.04381569f, 
    -0.09413826f, -0.02563394f, -0.10567062f, -0.02702975f, 0.08119117f, 0.17737569f, 0.04680148f, 0.11041814f, 
    0.02644669f, 0.02358039f, 0.02801315f, -0.02762711f, 0.14999622f, -0.01546407f, 0.02015204f, 0.11600646f, 
    0.33038703f, -0.11469690f, -0.01620753f, 0.08529102f, 0.06775429f, 0.00399378f, 0.08316837f, 0.11005557f, 
    0.05455093f, 0.18983227f, -0.00008014f, 0.05301974f, 0.20409994f, 0.04918930f, 0.05647738f, 0.03522376f, 
    -0.02311932f, 0.00730591f, -0.04863600f, 0.09705256f, 0.00472642f, -0.06364484f, 0.04172543f, -0.11643251f, 
    -0.23788182f, -0.03248087f, -0.22365168f, -0.14211313f, -0.05768250f, -0.07658297f, -0.11008359f, -0.12800804f, 
    -0.09714603f, 0.14436176f, -0.05402141f, -0.08453654f, 0.38715667f, 0.06129228f, -0.01958757f, 0.05076245f, 
    -0.02088344f, 0.00742565f, 0.06443119f, -0.11208392f, -0.05957980f, -0.09411746f, -0.11795782f, 0.00965086f, 
    0.31524631f, 0.22067219f, 0.07865266f, -0.03696045f, 0.02110920f, -0.04361286f, -0.07172051f, 0.08674195f, 
    -0.05289778f, -0.00639058f, -0.09499803f, -0.04735372f, -0.28692070f, 0.01805351f, 0.17720434f, -0.05581485f, 
    -0.04203248f, -0.07745510f, -0.12547931f, 0.01332349f, -0.00968781f, 0.12183554f, 0.01248305f, -0.08929263f, 
    -0.15277021f, -0.25135651f, -0.18604948f, -0.33452147f, -0.10570702f, 0.02501715f, -0.15872625f, 0.07700355f, 
    -0.03277108f, 0.10216127f, 0.07608527f, 0.06890382f, 0.03589228f, -0.24616396f, 0.01508748f, 0.22915512f, 
    -0.06021952f, -0.22584900f, 0.15640020f, 0.03265550f, 0.09031519f, 0.09049686f, 0.03583744f, 0.03163860f, 
    -0.48518106f, 0.06647866f, 0.17584267f, -0.10624411f, -0.07138436f, 0.04877652f, -0.02670397f, 0.05496820f, 
    -0.03701951f, 0.07322152f, -0.11482458f, -0.14043003f, -0.17259794f, 0.09677526f, 0.16491731f, -0.21521467f, 
    -0.01523440f, -0.07409503f, -0.09588999f, -0.06107965f, 0.08762009f, 0.15889698f, 0.24088012f, -0.14526363f, 
    0.38855138f, -0.00567654f, 0.24054293f, 0.02525997f, -0.00941889f, 0.01031362f, 0.13128132f, -0.03901075f, 
    0.04475335f, -0.01492303f, -0.03060237f, 0.14244509f, -0.12650277f, -0.12839444f, -0.11249506f, -0.03062022f, 
    -0.00224306f, -0.16982740f, 0.09362663f, 0.11342943f, -0.08246670f, -0.10237301f, -0.01490096f, -0.01882074f, 
    -0.14912497f, -0.08590142f, 0.11336824f, -0.01848073f, 0.22003289f, 0.11558179f, -0.03796904f, -0.11895526f, 
    0.00184196f, -0.28668076f, -0.22068131f, -0.16989960f, -0.02619947f, -0.16951501f, -0.00718725f, 0.13166046f, 
    0.04805852f, 0.14739507f, 0.07048535f, 0.00384431f, 0.09619316f, 0.02239511f, 0.03686844f, -0.04717082f, 
    0.22345111f, -0.00779073f, -0.12721135f, 0.06869271f, 0.14954199f, 0.10320474f, 0.03351699f, -0.06379964f, 
    -0.14005832f, 0.00014013f, -0.13315956f, -0.21888958f, 0.23312983f, -0.07920140f, 0.20430855f, -0.18820481f, 
    -0.05174715f, 0.13877626f, 0.02983384f, 0.20318724f, -0.07282706f, 0.16074030f, -0.06079784f, -0.00370598f, 
    0.06338122f, -0.06169161f, 0.07726333f, 0.00888168f, -0.00190970f, -0.17743404f, -0.12620558f, -0.13428210f, 
    0.04675788f, -0.16529441f, -0.12669604f, -0.04605816f, 0.19328025f, 0.10132706f, 0.02646245f, -0.01049410f, 
    0.04192899f, 0.02375970f, -0.07779316f, -0.00969866f, -0.07674578f, 0.02626461f, -0.04245400f, -0.12197085f, 
    0.12152356f, -0.00309389f, -0.17340240f, -0.21296544f, -0.03891313f, 0.01348418f, -0.16737403f, 0.08499933f, 
    0.03018879f, -0.00113904f, -0.03378275f, -0.04035629f, -0.12480909f, 0.11857859f, -0.09259908f, 0.01819311f, 
    0.04041676f, -0.07436518f, 0.05793161f, 0.01932888f, 0.03578611f, -0.01065684f, 0.12171289f, 0.02980307f, 
    -0.21304567f, 0.08411466f, -0.37526590f, -0.09217230f, -0.06231450f, -0.02175324f, -0.04798526f, 0.06761380f, 
    -0.12946522f, -0.03071439f, 0.14380077f, 0.16396011f, -0.04089176f, -0.30806622f, -0.33759171f, -0.12020265f, 
    -0.01854284f, 0.00090144f, -0.17603225f, -0.01854778f, -0.00624306f, -0.09477656f, -0.08428121f, 0.05821930f, 
    -0.12716961f, -0.07048440f, 0.14334318f, -0.00955797f, 0.06644206f, 0.04184871f, -0.01517232f, 0.12382621f, 
    0.14931592f, -0.21068877f, -0.10594692f, -0.02338332f, 0.25793666f, -0.18064445f, 0.15333562f, -0.11372350f, 
    -0.12584464f, 0.09815767f, -0.06603189f, 0.05681176f, -0.05492281f, 0.02800781f, 0.06460357f, 0.12528345f, 
    -0.36316833f, -0.11428377f, 0.23109402f, -0.23474035f, -0.17906271f, -0.05337488f, -0.07785591f, -0.18191011f, 
    0.09677249f, 0.06845549f, -0.14586823f, -0.15051532f, 0.15334342f, 0.11758769f, -0.18192640f, 0.19436643f, 
    0.05504596f, 0.04328029f, 0.04096722f, 0.11598613f, 0.09160771f, -0.04867446f, 0.00258979f, 0.03732394f, 
    -0.00562499f, -0.02088834f, 0.04456715f, 0.01602623f, 0.01082663f, 0.10286356f, 0.01026718f, 0.00066946f, 
    0.04791016f, -0.02485269f, 0.08698605f, 0.20226479f, -0.06266879f, -0.15027754f, -0.21904016f, -0.29920724f, 
    0.02748629f, -0.23256633f, -0.20883642f, -0.05057557f, -0.06118456f, -0.03187216f, 0.01465803f, -0.08050802f, 
    0.05399017f, 0.06315049f, 0.21390983f, -0.03091181f, -0.02646244f, 0.10607531f, -0.06140666f, 0.00583000f, 
    -0.06741595f, 0.11266504f, 0.08589423f, -0.00519530f, 0.07834030f, 0.00387538f, -0.12624975f, 0.09930764f, 
    0.09034601f, 0.03625247f, 0.02773281f, 0.02381544f, -0.11141997f, -0.01799588f, -0.04709794f, 0.03452127f, 
    0.13860954f, 0.06336915f, 0.00370926f, 0.21156904f, -0.03434599f, -0.12178288f, 0.01972339f, 0.00592393f, 
    0.14936613f, 0.15007742f, 0.11700825f, 0.05110826f, -0.20861131f, -0.05778407f, -0.19317010f, 0.16494930f, 
    -0.11548088f, 0.00012306f, 0.08294880f, -0.07068356f, 0.04111413f, 0.01136010f, 0.02541845f, -0.11827958f, 
    0.21629760f, 0.13009317f, 0.07413734f, -0.15364555f, -0.02267727f, -0.01338679f, 0.07879388f, 0.07687989f, 
    0.07952130f, 0.20629847f, 0.08416663f, 0.04787187f, 0.07306617f, -0.14170323f, 0.16060780f, -0.05131195f, 
    0.09370373f, 0.02551869f, 0.05914070f, 0.14162268f, 0.07962287f, 0.06743742f, -0.09477908f, 0.10922634f, 
    0.00441015f, 0.02367097f, -0.04175215f, -0.21219485f, 0.05866373f, 0.07658076f, 0.12202021f, -0.05729117f, 
    -0.02915400f, 0.02490515f, 0.10632019f, -0.07105917f, 0.40968701f, -0.04961875f, 0.08303970f, 0.00957773f, 
    0.01570091f, 0.13157542f, 0.11813330f, -0.07480671f, 0.02819634f, 0.00747756f, -0.08355723f, -0.00568576f, 
    -0.05534719f, -0.00335471f, 0.13514018f, -0.35975051f, -0.05773270f, 0.14299503f, 0.01715295f, 0.28127345f, 
    -0.03065840f, 0.12939049f, 0.01387074f, 0.00162701f, 0.05830176f, -0.06792787f, -0.12390546f, -0.20512736f, 
    -0.06731364f, -0.01356488f, 0.02468868f, -0.00900920f, -0.03998992f, -0.05838447f, -0.05252767f, 0.00431369f, 
    -0.20598677f, 0.08247556f, -0.05998377f, -0.09297525f, -0.08616892f, -0.01262276f, -0.05892426f, 0.08767122f, 
    -0.09708982f, 0.06457997f, -0.00055000f, 0.13366137f, -0.07575404f, -0.02656158f, 0.05219634f, -0.00042322f, 
    0.03130175f, 0.02438982f, -0.00287846f, 0.07389483f, 0.18357895f, 0.16892053f, -0.07087903f, 0.13837813f, 
    -0.18985872f, -0.40349272f, -0.15127748f, -0.21018395f, -0.12517993f, -0.14051986f, -0.06767946f, -0.06402095f, 
    -0.05939870f, 0.04580320f, -0.05583086f, -0.02763077f, -0.39069447f, 0.21207391f, -0.07271623f, -0.04630275f, 
    -0.04192024f, -0.11906556f, -0.14043380f, -0.05147769f, -0.01139233f, 0.06301942f, -0.03105364f, 0.00545041f, 
    0.08096530f, 0.21331576f, -0.01437613f, 0.09467295f, 0.09818275f, 0.06024192f, 0.10082408f, -0.07391658f, 
    0.04638552f, 0.01681007f, 0.10186187f, 0.10710311f, 0.07498856f, -0.16215962f, 0.20888993f, -0.34728217f, 
    0.12561284f, 0.04072437f, 0.09285673f, 0.20008802f, 0.08071742f, 0.11076541f, 0.14589272f, 0.03912659f, 
    -0.15384069f, -0.11033828f, -0.08973925f, -0.17723265f, 0.00815137f, -0.01165485f, 0.09902608f, 0.04816035f, 
    -0.08552082f, 0.05569549f, 0.12114646f, -0.06653190f, -0.24941012f, -0.37988633f, -0.42391747f, 0.23327130f, 
    0.06877088f, 0.09969423f, -0.00863751f, -0.09506442f, -0.04666114f, 0.05324330f, 0.12418789f, -0.02360383f, 
    0.33526146f, 0.06318089f, -0.10154215f, -0.21489681f, 0.03761769f, 0.07641349f, -0.11800303f, -0.12860420f, 
    -0.00870538f, -0.11447230f, 0.05702081f, 0.04495255f, 0.00098675f, 0.13351418f, 0.02810775f, 0.06130556f, 
    0.09856662f, 0.02533175f, -0.00973880f, 0.00910224f, 0.02262591f, -0.19020547f, -0.02496123f, -0.10730143f, 
    -0.35452509f, -0.06096965f, -0.05736224f, -0.03553803f, -0.03149613f, 0.07038569f, -0.04622425f, 0.06044092f, 
    -0.01361898f, 0.04234208f, -0.03562531f, 0.02387039f, -0.25154302f, -0.04241598f, 0.04847205f, -0.01813694f, 
    0.00112767f, 0.09284471f, -0.08320956f, 0.11936851f, -0.03313458f, 0.01974275f, 0.02274000f, 0.01428143f, 
    -0.14371736f, -0.19259040f, -0.04056868f, 0.12291206f, 0.05083120f, 0.00151048f, -0.00575084f, 0.07604392f, 
    -0.01028216f, -0.05275055f, 0.13041215f, 0.06647547f, -0.07625162f, -0.05251474f, 0.15387085f, -0.05288147f, 
    -0.11618730f, 0.06083166f, -0.04981217f, -0.00567911f, 0.00687921f, -0.00068456f, -0.00620031f, -0.06713803f, 
    -0.40223879f, 0.08632255f, 0.18194582f, 0.09476557f, 0.03451056f, 0.10792945f, -0.00622861f, 0.11510935f, 
    0.02929408f, -0.11576278f, 0.03998429f, 0.04220407f, 0.37128013f, -0.12563172f, -0.22698036f, -0.07998170f, 
    0.03608854f, 0.07125381f, 0.02134932f, -0.06007763f, 0.06476995f, 0.03961936f, -0.03217510f, -0.03799314f, 
    -0.06373531f, -0.03290682f, -0.04627563f, -0.00843823f, -0.02753163f, 0.10860038f, -0.07764853f, 0.12019905f, 
    0.04039242f, -0.01018011f, -0.00399008f, 0.12000149f, 0.01372831f, -0.37327412f, 0.08851082f, 0.15900347f, 
    0.12854402f, 0.03653040f, 0.05324028f, 0.00263048f, 0.09006447f, -0.09604698f, -0.07630592f, 0.17632684f, 
    0.19516294f, -0.13781345f, -0.00088286f, 0.00446928f, 0.03822418f, -0.02069754f, 0.02122483f, 0.05573926f, 
    0.01300602f, -0.12777285f, 0.08404434f, 0.14530070f, -0.16808985f, -0.09727914f, -0.15925868f, 0.08567599f, 
    0.02481925f, 0.01978252f, 0.00376870f, 0.06061141f, -0.12364696f, -0.06684338f, 0.01058715f, 0.05416913f, 
    0.24624395f, 0.09059875f, 0.11755230f, -0.08789831f, -0.02365625f, 0.14007190f, 0.13027331f, -0.01681687f, 
    -0.08952076f, -0.09553713f, 0.00967047f, 0.10242324f, -0.15464826f, 0.03921558f, 0.03250545f, 0.07125519f, 
    0.04390633f, -0.01817019f, -0.07643303f, -0.02317183f, -0.00599039f, -0.00309606f, -0.02693650f, -0.07660561f, 
    0.05368089f, -0.24268427f, -0.11234455f, -0.08361476f, 0.04115871f, 0.04138910f, -0.11103378f, 0.06199555f, 
    -0.04416648f, -0.07177196f, 0.03763029f, 0.12848303f, 0.21856260f, 0.14723314f, 0.05584523f, -0.26068705f, 
    0.09766644f, 0.08315033f, 0.03563806f, 0.09518315f, -0.01895765f, 0.00614656f, 0.06576604f, -0.02096326f, 
    -0.38349497f, -0.04084789f, 0.05028556f, -0.17754127f, 0.14364962f, 0.00658841f, -0.13636728f, 0.07393380f, 
    -0.00519365f, 0.01178281f, -0.03612337f, 0.03050921f, -0.07468063f, -0.30220461f, 0.00016274f, 0.19117498f, 
    0.05718998f, 0.04888799f, 0.00732990f, 0.06312001f, 0.00686094f, -0.00028259f, -0.09834157f, -0.02307138f, 
    0.21457763f, -0.23773493f, -0.27044317f, -0.13101310f, 0.01349104f, 0.05158762f, 0.04156318f, 0.00327476f, 
    0.03625783f, 0.01222691f, -0.05781728f, 0.04535479f, -0.07692321f, -0.04314232f, 0.00118300f, 0.07266189f, 
    0.01340743f, 0.03246594f, 0.02658451f, 0.01211588f, -0.01182843f, 0.01316482f, 0.01821040f, -0.10895333f, 
    0.06588630f, 0.19383574f, -0.06253986f, -0.14804280f, 0.11422756f, 0.13806249f, 0.01858080f, -0.07077405f, 
    0.13358073f, 0.01667584f, -0.04474986f, -0.06054085f, -0.10164405f, -0.06875197f, -0.21363778f, 0.13350646f, 
    0.08724216f, -0.09170510f, -0.03385618f, -0.00859120f, -0.04858787f, 0.02881910f, -0.00600136f, 0.07359298f, 
    -0.27367091f, -0.29286057f, 0.04011882f, 0.20746490f, 0.06555799f, 0.02680041f, 0.01505357f, 0.01965848f, 
    -0.06670283f, 0.03369347f, -0.01777380f, 0.02204909f, -0.04529124f, -0.15699974f, 0.05484662f, 0.05555085f, 
    0.06267937f, -0.00340248f, 0.08118366f, -0.03785385f, -0.04602098f, 0.06651011f, -0.01582799f, -0.01645145f, 
    0.24665220f, 0.13770236f, 0.03784817f, -0.07417437f, 0.04519049f, -0.00310286f, 0.02430741f, -0.14441450f, 
    -0.04132426f, -0.08183298f, -0.07610530f, -0.04020565f, 0.32928637f, -0.10152914f, -0.22597840f, -0.26274461f, 
    0.04502955f, 0.12298998f, -0.06725919f, -0.09720440f, 0.10274699f, 0.10359033f, -0.10258449f, 0.00980642f, 
    -0.09102788f, -0.03573222f, 0.14688064f, 0.03862058f, 0.05819491f, -0.00465242f, 0.02161142f, 0.04145365f, 
    -0.05758025f, 0.03481759f, 0.00867432f, -0.04442586f, -0.58228946f, -0.19945250f, -0.02020099f, 0.32016888f, 
    0.05126022f, 0.03523735f, 0.00711456f, 0.06552041f, -0.03070163f, 0.04323963f, 0.07687663f, -0.05737527f, 
    0.07836509f, -0.31141359f, -0.09682866f, -0.09829826f, -0.00281812f, 0.02131415f, -0.09696826f, 0.08430882f, 
    0.02241131f, 0.02270685f, 0.05398005f, 0.08659704f, 0.04307267f, 0.12755324f, 0.03985051f, -0.07486686f, 
    0.10649445f, 0.11484353f, -0.00690167f, -0.00742941f, -0.01116790f, 0.03751780f, 0.03622716f, -0.01553569f, 
    0.07363897f, -0.11723484f, 0.01431090f, 0.02203749f, -0.15930422f, -0.07551207f, 0.01831376f, 0.09904901f, 
    0.01953239f, 0.03216922f, 0.05336739f, -0.01007359f, 0.17999120f, 0.06743264f, 0.10394555f, 0.07183298f, 
    0.05358000f, -0.27601811f, 0.11424260f, 0.03694003f, -0.03177960f, 0.07045233f, 0.00905347f, 0.02158993f, 
    0.16866745f, -0.06443799f, -0.09283465f, -0.07558241f, -0.12336452f, -0.09212802f, -0.13838620f, 0.00343718f, 
    -0.00371116f, -0.04253442f, 0.07062896f, 0.02112174f, -0.06193259f, 0.06806275f, 0.06387917f, 0.14061803f, 
    0.09500659f, 0.06217935f, -0.06741224f, -0.00853235f, 0.04513707f, 0.06359911f, 0.06487428f, 0.02935729f, 
    0.23366606f, 0.16541186f, -0.12331913f, -0.09545008f, -0.03260185f, 0.00260354f, -0.06679489f, 0.04274143f, 
    0.01783331f, -0.00229531f, 0.07314278f, -0.01036961f, -0.00740790f, -0.10595252f, -0.07455236f, 0.09578438f, 
    0.06107030f, -0.02074368f, -0.07591683f, 0.01441507f, -0.06016375f, -0.07570179f, 0.06026700f, 0.04038068f, 
    0.27334642f, 0.04125117f, -0.09310069f, -0.13680555f, 0.03251569f, 0.06393080f, 0.10559806f, -0.05908249f, 
    0.07223593f, 0.00607348f, -0.06408267f, -0.02180676f, 0.06300362f, 0.00636853f, -0.05457889f, 0.08947905f, 
    0.00224331f, 0.01958194f, 0.08706000f, 0.03600759f, 0.00799104f, 0.02919321f, -0.04887759f, -0.09079816f, 
    0.38479254f, 0.07485582f, 0.10306280f, -0.06720991f, 0.09420088f, 0.01144635f, -0.03774292f, -0.09314906f, 
    0.05901600f, -0.00180544f, -0.01603292f, 0.02090102f, 0.28883624f, 0.04054511f, -0.10043654f, 0.01191269f, 
    0.10739096f, 0.15382418f, 0.10707157f, 0.00585927f, -0.02887492f, 0.03069302f, 0.03832707f, 0.03301827f, 
    0.01760357f, -0.28281257f, -0.17014949f, 0.21361446f, 0.10463753f, -0.09544232f, -0.03454757f, -0.03892089f, 
    0.08161225f, 0.01043800f, -0.04543847f, 0.04642366f, 0.23012756f, 0.08826260f, -0.04702938f, -0.10305244f, 
    0.05806983f, 0.18558790f, -0.14230922f, 0.02609857f, 0.05456503f, 0.02093518f, -0.06822244f, 0.06012409f, 
    0.13544184f, 0.05188983f, -0.16583070f, -0.00526133f, 0.04353961f, 0.13655788f, -0.00798866f, -0.02406732f, 
    0.13448231f, 0.04264579f, 0.06923242f, 0.07691733f, 0.06813009f, -0.13066037f, 0.02821387f, -0.01579610f, 
    -0.06048188f, -0.01694815f, -0.01155211f, 0.02261045f, 0.03312504f, -0.03761516f, -0.03506385f, -0.17688872f, 
    -0.14072005f, -0.02999511f, 0.03367723f, 0.04952064f, 0.03969477f, 0.03224628f, 0.01975673f, 0.03542143f, 
    -0.10415688f, -0.02173140f, 0.10772932f, -0.07866061f, 0.20259432f, 0.24874571f, 0.00459231f, -0.16462758f, 
    0.07963289f, 0.01631422f, 0.03036502f, -0.10452525f, -0.05169005f, -0.03934718f, 0.01980829f, -0.01530556f, 
    0.03492459f, -0.08517195f, -0.40931070f, 0.11905138f, 0.07673614f, -0.01847165f, -0.03728330f, -0.03137497f, 
    0.03545185f, -0.02315476f, 0.03375707f, 0.06204621f, 0.03106671f, -0.08425024f, -0.05906992f, 0.04916989f, 
    -0.11618789f, 0.01430838f, -0.02557736f, 0.00340242f, -0.05625619f, -0.03285414f, -0.09772649f, -0.07022996f, 
    0.09597645f, -0.30262002f, 0.02129194f, 0.10646251f, 0.00937438f, -0.00325952f, 0.07291268f, 0.01416985f, 
    -0.03097611f, -0.04986503f, -0.02937777f, -0.05381349f, 0.33441347f, 0.17181855f, -0.30172643f, -0.22628850f, 
    0.04242366f, 0.06049292f, 0.07991761f, 0.07006409f, 0.03266592f, 0.02442043f, -0.00569983f, 0.09236313f, 
    -0.06033369f, -0.30982983f, 0.10434040f, 0.16738927f, 0.03406568f, 0.01687949f, 0.00222888f, 0.03983869f, 
    0.02957984f, -0.00349273f, -0.06879116f, 0.00167081f, 0.02064515f, 0.06232754f, -0.22237338f, -0.13762341f, 
    -0.08539739f, 0.08895950f, 0.13834651f, 0.01647320f, -0.01062613f, 0.18783771f, 0.05594005f, 0.00050731f, 
    0.08368182f, 0.13472864f, 0.17587368f, -0.01001005f, -0.10752748f, 0.11677895f, 0.00745288f, 0.25038549f, 
    0.03414732f, 0.03051011f, -0.00187295f, 0.00411690f, 0.24134265f, 0.02167673f, -0.48244584f, -0.09528633f, 
    -0.11011679f, -0.01439646f, 0.03593772f, 0.00944262f, 0.02043607f, 0.07687563f, -0.00965992f, 0.02432346f, 
    0.23760968f, -0.14663462f, -0.12676181f, -0.18592311f, 0.07961174f, -0.02962309f, 0.08918262f, -0.11872232f, 
    -0.13934027f, 0.18243966f, 0.03388339f, -0.02719247f, 0.19087820f, -0.00855525f, -0.06275314f, -0.24799725f, 
    0.12177921f, 0.12493807f, 0.09211764f, 0.03774218f, 0.03633459f, 0.03150621f, 0.04307531f, -0.03324471f, 
    -0.25023571f, -0.14767256f, 0.07588295f, 0.16268477f, 0.07296534f, 0.03843956f, -0.06346826f, 0.04407213f, 
    -0.02547418f, 0.03354632f, 0.09959752f, -0.02601474f, -0.13346243f, -0.05549162f, 0.08614233f, 0.10336775f, 
    0.09362296f, -0.06233044f, 0.01247888f, 0.05291785f, -0.06521145f, -0.06892480f, 0.11667237f, 0.02999962f, 
    0.14922720f, 0.17016163f, -0.15592156f, -0.07264002f, 0.22321880f, 0.10001476f, -0.09547493f, -0.07730756f, 
    0.04319171f, -0.04588245f, -0.03206145f, 0.02322908f, -0.03274312f, -0.19872922f, -0.17949089f, 0.07320589f, 
    0.05505195f, 0.09174994f, 0.03588521f, 0.01762082f, 0.02640823f, 0.05160762f, 0.05665967f, 0.05760833f, 
    -0.13958859f, 0.01611999f, 0.19005527f, -0.07743981f, -0.15194680f, -0.01754373f, 0.14138299f, 0.11340404f, 
    0.03937699f, 0.05108156f, -0.05776466f, 0.06417269f, -0.39772317f, -0.06369919f, 0.24600029f, 0.09561395f, 
    -0.03915505f, 0.08804214f, -0.14001349f, 0.09572858f, 0.21796830f, 0.09455438f, -0.08134568f, -0.09997343f, 
    -0.25108150f, 0.19892646f, 0.04313296f, 0.02580075f, 0.03039449f, 0.10917492f, -0.07995678f, 0.06822741f, 
    0.05216600f, 0.02402567f, 0.08242153f, 0.00981244f, 0.20586744f, 0.24372332f, 0.01711763f, -0.08914427f, 
    -0.14032967f, -0.12818016f, 0.09717949f, 0.07385559f, 0.02471779f, -0.01325393f, -0.03708189f, 0.01997296f, 
    -0.02421134f, -0.02625521f, 0.01975233f, -0.00649598f, 0.03261543f, 0.00517560f, 0.00685933f, -0.01842517f, 
    -0.02236647f, 0.03319433f, 0.01630384f, -0.00165106f, -0.00080268f, 0.01949359f, 0.01340829f, 0.01543195f, 
    0.02462910f, -0.03641048f, 0.02159711f, 0.01960212f, 0.00781613f, 0.00789581f, 0.00366586f, 0.02207719f, 
    -0.03091719f, -0.01807028f, 0.00248265f, 0.00906073f, 0.01981625f, 0.00889213f, -0.00987840f, 0.00851069f, 
    -0.03414405f, 0.00784566f, 0.02003517f, -0.03258784f, -0.03791215f, -0.02510845f, -0.03996547f, 0.00661467f, 
    0.01357886f, 0.01999714f, 0.00864287f, 0.01510948f, 0.00239804f, 0.02405234f, -0.01599394f, -0.00811932f, 
    0.03156300f, -0.02197059f, -0.01394805f, -0.03693554f, 0.02260847f, -0.00817151f, 0.02118979f, 0.00775941f, 
    -0.02576139f, 0.01176033f, -0.03123075f, -0.00914120f, -0.03696829f, -0.00142591f, 0.01929216f, 0.02382587f, 
    0.00094057f, 0.00802662f, -0.01878121f, 0.01926378f, -0.03259831f, -0.03399211f, -0.01876316f, -0.03257506f, 
    -0.03201783f, -0.01399184f, 0.02819168f, -0.00725417f, 0.03005671f, -0.01412176f, 0.03179868f, 0.02508277f, 
    -0.01009029f, -0.01541006f, -0.03311696f, -0.00623891f, 0.00473907f, 0.03686249f, 0.02595722f, 0.01986726f, 
    -0.04035890f, 0.03461998f, 0.02118620f, 0.01412993f, -0.02454141f, 0.00014045f, -0.01843077f, -0.03631780f, 
    0.02014689f, -0.02872583f, -0.03092663f, 0.01313638f, -0.02786650f, -0.02557136f, -0.03894741f, 0.00764619f, 
    -0.02669263f, -0.01125009f, -0.01403115f, -0.03753003f, -0.00575831f, 0.01126910f, -0.01276818f, 0.01220175f, 
    0.02733765f, 0.00357983f, -0.00619611f, -0.03338119f, 0.02056236f, -0.02735276f, 0.02622773f, -0.02351571f, 
    -0.03490400f, -0.03550753f, 0.01227027f, 0.01209463f, 0.02675166f, -0.01421350f, -0.03550829f, -0.03036312f, 
    -0.01117273f, 0.01880199f, -0.00166423f, 0.01648190f, 0.03260142f, -0.00892369f, 0.01806508f, 0.00078127f, 
    0.00984334f, 0.01700880f, -0.01951879f, 0.01743619f, -0.02835153f, -0.00549529f, -0.02359552f, -0.00232454f, 
    -0.03408187f, -0.00899181f, 0.02185565f, -0.02852258f, 0.03785826f, -0.01004890f, 0.00543133f, -0.02734208f, 
    0.02205234f, 0.02507393f, -0.02257153f, 0.00958641f, -0.01499286f, -0.03440504f, -0.03872873f, 0.01274333f, 
    0.00909720f, 0.01273292f, 0.00821098f, -0.00500532f, -0.03570483f, 0.01523309f, -0.02349189f, -0.01566873f, 
    -0.00869440f, 0.02576646f, -0.01456921f, -0.02028724f, -0.02207026f, -0.01728919f, -0.01941515f, 0.01384601f, 
    0.00765780f, 0.00222052f, -0.03555195f, -0.03736610f, 0.01824842f, 0.01563620f, 0.02309319f, -0.00266318f, 
    -0.03034092f, -0.02357248f, 0.01507015f, 0.00190851f, 0.00936460f, 0.02032473f, 0.03621697f, 0.01881751f, 
    0.00910505f, 0.01041749f, 0.02552353f, 0.00063023f, 0.00966175f, 0.01248969f, -0.01237652f, -0.00537690f, 
    -0.01921439f, -0.02630586f, -0.02413158f, 0.01859821f, -0.02288501f, -0.01420447f, -0.03492446f, -0.01374407f, 
    -0.02876281f, 0.01978403f, -0.00043957f, 0.02803306f, 0.01108148f, 0.01342786f, -0.03303324f, -0.03845615f, 
    0.02292287f, -0.03926999f, 0.01073444f, -0.02515476f, -0.03266516f, 0.01904109f, 0.02989481f, -0.03354931f, 
    0.00527659f, -0.01066251f, 0.00167043f, 0.02906827f, -0.00465468f, -0.02494887f, 0.00665840f, -0.02691143f, 
    -0.02455615f, -0.03925283f, 0.01342933f, -0.02373700f, 0.01060336f, -0.00046424f, -0.00565249f, 0.00063860f, 
    -0.01437661f, -0.03715055f, -0.00468369f, 0.01555040f, 0.01825813f, -0.01078579f, -0.02103064f, 0.02372065f, 
    0.02708776f, -0.01189238f, 0.00727619f, -0.01817800f, 0.02360589f, -0.02628865f, -0.02992773f, -0.02626680f, 
    0.01610954f, 0.02146371f, -0.02794340f, 0.02448102f, -0.01799075f, 0.02257624f, -0.02126374f, 0.02887840f, 
    0.01642239f, 0.00605062f, 0.01035172f, -0.00433399f, -0.01887148f, 0.00979294f, 0.02297713f, 0.02364722f, 
    -0.02564446f, 0.00518674f, 0.01319579f, -0.03631677f, -0.03282321f, -0.03263199f, -0.03022865f, -0.00434458f, 
    0.00591067f, 0.02388936f, 0.02372133f, -0.03588282f, 0.02007907f, 0.00695096f, -0.00880948f, -0.03451586f, 
    -0.02765109f, 0.00002086f, -0.03433997f, -0.00809624f, 0.01139788f, -0.03213925f, -0.02501668f, -0.00868589f, 
    -0.01942138f, 0.01341817f, 0.00400883f, 0.01036124f, -0.01252277f, -0.00740171f, -0.00861345f, 0.01445481f, 
    -0.01777369f, 0.01259909f, 0.01652708f, -0.00072868f, -0.02915651f, 0.02477289f, -0.02237837f, 0.01783599f, 
    -0.01807993f, 0.01497343f, 0.02504990f, 0.02819620f, -0.01968837f, -0.01195232f, -0.00069024f, -0.01018832f, 
    -0.03296346f, -0.01350812f, -0.02297098f, -0.00668712f, -0.00582182f, 0.02401948f, 0.03257477f, 0.02615320f, 
    0.02377840f, 0.02238097f, 0.03710510f, -0.00298217f, -0.01997076f, 0.01866542f, -0.01876470f, 0.00096406f, 
    0.00010105f, 0.02539528f, 0.02643842f, -0.03017249f, -0.03151094f, -0.02005612f, 0.02595382f, 0.01820626f, 
    -0.00583754f, 0.00443276f, -0.01445056f, -0.02679382f, 0.00336672f, 0.01129798f, -0.03967890f, -0.03516963f, 
    0.00742001f, -0.03094550f, 0.00476937f, 0.00738228f, -0.02577449f, -0.03612959f, -0.03024838f, -0.02118019f, 
    0.02073318f, -0.01609074f, -0.00123834f, -0.02433971f, -0.03442129f, -0.03966041f, -0.00351796f, 0.01889645f, 
    -0.00093063f, -0.00100605f, -0.02812641f, -0.02901392f, -0.03299185f, 0.02307318f, -0.03918647f, 0.01779307f, 
    -0.02635862f, 0.02129754f, -0.00347277f, 0.02483817f, 0.03072915f, 0.01281241f, -0.00070622f, -0.02199645f, 
    -0.03778097f, 0.01638055f, -0.03078072f, -0.02500715f, 0.02281363f, 0.00120424f, 0.02400543f, -0.03785332f, 
    0.00450517f, -0.01866733f, -0.01782311f, -0.01997669f, -0.00949380f, 0.01151070f, 0.02751415f, 0.00733149f, 
    -0.00283173f, -0.01453278f, 0.00148245f, -0.03823315f, -0.03198926f, 0.00552039f, -0.03460133f, 0.00149369f, 
    0.03622802f, -0.00627769f, -0.01425920f, -0.00101044f, 0.01814371f, -0.01630687f, -0.03337424f, -0.01859995f, 
    -0.01250635f, -0.02575852f, -0.00013805f, 0.02011432f, 0.03123576f, 0.00443833f, -0.02881725f, -0.02473018f, 
    0.02253640f, -0.02640701f, -0.01525304f, -0.02278461f, -0.01646739f, 0.01926263f, -0.01750602f, 0.01855730f, 
    -0.01684459f, 0.02229088f, 0.00556072f, -0.02822481f, -0.03163118f, 0.00651309f, -0.03579354f, 0.01067616f, 
    0.01836650f, 0.01755804f, -0.00542212f, -0.03124150f, -0.01392493f, 0.02547759f, 0.02144296f, -0.02084634f, 
    -0.03585292f, -0.00165031f, -0.00794092f, -0.04101975f, -0.00808958f, -0.01682445f, -0.00446126f, -0.01890792f, 
    0.02197630f, 0.00978505f, -0.02610530f, 0.01895626f, -0.01211733f, -0.02546575f, 0.00400492f, -0.00306182f, 
    -0.01756711f, -0.01732959f, 0.03123365f, 0.03347979f, 0.03091847f, -0.00871226f, 0.01270853f, 0.00572165f, 
    -0.03225859f, 0.02594669f, -0.00082818f, 0.01357549f, 0.01717014f, -0.03917369f, 0.00511591f, -0.03015962f, 
    0.02401849f, -0.02787082f, -0.02229102f, 0.00448365f, 0.02133532f, 0.00826395f, -0.02270077f, 0.02739628f, 
    -0.00765686f, 0.00208566f, -0.01537710f, 0.00546142f, 0.00769940f, 0.01138567f, -0.02695125f, 0.03077395f, 
    -0.00922834f, -0.01481032f, -0.01343293f, -0.02144083f, 0.00854600f, -0.00901271f, -0.03166686f, 0.01293213f, 
    0.02287724f, 0.04111058f, -0.00954638f, 0.01626332f, -0.03061046f, -0.02422868f, 0.00689886f, -0.01057800f, 
    0.00054017f, 0.00110825f, 0.01825586f, -0.02404493f, 0.00614974f, -0.00543110f, -0.00213174f, 0.02241889f, 
    -0.01722408f, -0.01620867f, -0.00825276f, 0.00197616f, -0.00144092f, 0.02731291f, -0.04249027f, -0.03492298f, 
    0.02795494f, 0.02317926f, 0.03571640f, -0.01880801f, 0.02590168f, 0.03146522f, -0.02629188f, -0.02892635f, 
    -0.00067649f, -0.00983795f, -0.01132577f, 0.01399228f, -0.00776878f, 0.00697231f, 0.00376845f, -0.01327547f, 
    -0.01909083f, 0.01992251f, -0.00611090f, 0.01119203f, 0.00478170f, -0.02103088f, 0.03035288f, -0.03247004f, 
    0.00650373f, 0.02549965f, 0.00355786f, 0.02289831f, -0.00541135f, 0.01750448f, 0.00438161f, -0.01832358f, 
    0.01663285f, 0.00386877f, 0.02741138f, -0.00041019f, -0.03194997f, 0.00062066f, 0.01641148f, -0.01810095f, 
    -0.02447095f, -0.03006058f, 0.01036896f, -0.03136415f, -0.00889330f, -0.01192629f, -0.01896907f, 0.00525122f, 
    -0.03678882f, 0.00330115f, -0.00302816f, 0.01264613f, 0.01136417f, -0.00677538f, 0.02938124f, -0.01491655f, 
    -0.03002126f, 0.01026788f, 0.02036358f, 0.00624555f, -0.01848157f, -0.00897278f, -0.00573138f, -0.00336209f, 
    0.00296403f, 0.00876105f, 0.00442389f, -0.01714627f, -0.02222516f, 0.03132651f, -0.00007559f, -0.00586998f, 
    -0.03656961f, -0.02480697f, -0.01640549f, 0.02150706f, -0.00262390f, -0.03291794f, -0.00589455f, 0.00351760f, 
    0.02787083f, 0.00189571f, -0.03175484f, 0.02312590f, -0.00333315f, 0.00613884f, 0.01227116f, -0.02892356f, 
    -0.01140517f, 0.02112910f, 0.00286929f, -0.00116785f, 0.01791573f, -0.02304218f, -0.01821383f, -0.02619233f, 
    -0.01275600f, 0.00879043f, -0.01214872f, -0.02206948f, -0.01756612f, 0.02772291f, 0.00728261f, -0.03785363f, 
    0.00878492f, -0.01432347f, -0.03957338f, -0.01023894f, -0.02264790f, 0.01188496f, -0.03456968f, 0.03151364f, 
    -0.01134413f, 0.02233990f, -0.02454408f, -0.02952574f, -0.01640433f, -0.02836541f, -0.02440015f, -0.00154147f, 
    -0.01386449f, -0.00321456f, 0.01371264f, 0.01761744f, -0.00805188f, 0.02445401f, -0.01428035f, 0.00421088f, 
    0.02561001f, -0.02841920f, -0.01259022f, -0.00601791f, -0.00620536f, -0.00722842f, 0.02313384f, 0.01542518f, 
    -0.03345304f, -0.02642571f, 0.02760649f, 0.01847577f, -0.00015190f, 0.03734117f, -0.01537243f, -0.01174043f, 
    -0.03384404f, 0.01264513f, 0.01971627f, 0.02579122f, 0.03434338f, -0.00072994f, 0.02972444f, -0.03365923f, 
    0.02298857f, -0.00377695f, 0.01696848f, 0.00381998f, 0.02612811f, 0.02726384f, -0.01713496f, 0.01928797f, 
    -0.02704586f, 0.03314251f, 0.01806340f, -0.00913852f, 0.00855444f, -0.00844537f, 0.02997265f, -0.02731090f, 
    0.03107932f, 0.00779389f, 0.00783186f, -0.01038564f, -0.03213815f, -0.01998736f, -0.03650637f, 0.02716944f, 
    0.00077095f, 0.02957574f, -0.03544122f, 0.00075499f, 0.01301216f, -0.03696208f, 0.01858207f, 0.02054192f, 
    -0.02909113f, -0.00168740f, 0.00026858f, 0.01369647f, -0.00319091f, 0.01244773f, 0.02654397f, -0.03982514f, 
    -0.03200384f, 0.00253393f, -0.03236007f, -0.00475388f, 0.02384595f, -0.02446759f, -0.03890893f, -0.00576725f, 
    -0.02908234f, -0.01788633f, 0.01845431f, 0.01645413f, -0.00712024f, -0.01284619f, -0.01338364f, -0.02243638f, 
    0.03126625f, -0.02305449f, 0.00471640f, 0.00682954f, -0.00785117f, 0.01450290f, 0.01153272f, 0.00361710f, 
    -0.01969604f, 0.01955000f, 0.01621570f, -0.02998705f, -0.02876656f, -0.00119352f, 0.00079978f, -0.02342616f, 
    0.02057269f, 0.00829485f, 0.00940466f, -0.00862277f, 0.03505261f, -0.02776499f, 0.02960028f, 0.02205332f, 
    -0.01933812f, 0.03434911f, -0.01786916f, -0.00341213f, 0.03997627f, -0.03694326f, 0.00677534f, 0.03331538f, 
    -0.24022536f, -0.01565589f, 0.05702202f, 0.22646485f, -0.03441218f, -0.08170202f, 0.10522939f, -0.05853553f, 
    0.05193127f, 0.04849743f, 0.06415445f, 0.03931578f, 0.06225707f, -0.10785744f, 0.01607636f, -0.05691033f, 
    -0.07332303f, -0.04941199f, -0.05234504f, 0.17852263f, 0.11409079f, 0.08100643f, 0.07627562f, -0.00695152f, 
    0.38194564f, -0.00777242f, 0.05653764f, 0.05867683f, 0.15349619f, 0.07477017f, 0.04331366f, 0.05283374f, 
    -0.14164495f, 0.01911716f, 0.06604305f, 0.05079686f, 0.27972409f, -0.00040357f, -0.09756958f, -0.07083686f, 
    0.03375415f, -0.05342390f, 0.00742160f, 0.08773531f, -0.11662564f, -0.14656906f, -0.02766761f, -0.06237169f, 
    0.17981823f, 0.10849425f, 0.04970038f, -0.03905890f, -0.09447122f, -0.08381660f, 0.00673104f, -0.01500678f, 
    0.02417351f, 0.01704958f, 0.06022141f, -0.07285901f, 0.13553517f, -0.05641064f, 0.25936005f, -0.01864151f, 
    0.01292659f, -0.13589452f, -0.04958886f, 0.12215706f, -0.03683084f, -0.00797160f, 0.04640198f, -0.07894310f, 
    0.26411018f, -0.16174926f, 0.10635795f, -0.11848044f, -0.03406171f, 0.05920406f, -0.05080020f, 0.11107900f, 
    -0.08689972f, -0.05213773f, -0.04126991f, 0.01091008f, 0.08245267f, -0.13033983f, -0.15159330f, 0.46111801f, 
    0.03596466f, 0.02540356f, 0.05313921f, 0.01844660f, 0.05241525f, 0.01824600f, 0.11984980f, 0.05413144f, 
    0.19449456f, 0.10754904f, 0.12393776f, 0.24606441f, 0.03687416f, 0.10990159f, -0.05780068f, -0.04657704f, 
    0.04049859f, -0.02370988f, -0.04992093f, 0.04737298f, 0.58936930f, -0.05186739f, -0.25324640f, 0.07582519f, 
    -0.08567155f, 0.18348040f, 0.01650651f, -0.00001158f, -0.01317349f, 0.21427146f, 0.01495452f, 0.00893650f, 
    -0.03528157f, 0.13572085f, -0.03940442f, -0.03205000f, 0.01109835f, -0.05380357f, 0.14380099f, -0.16072935f, 
    0.13422857f, 0.14289242f, -0.05745542f, 0.03505355f, 0.15455467f, 0.20438045f, -0.02258931f, -0.18932509f, 
    -0.08466773f, -0.09160668f, -0.06894086f, -0.07082032f, 0.09670942f, 0.12672244f, 0.01513464f, 0.04840182f, 
    -0.13114302f, -0.07902095f, -0.04696106f, 0.17251661f, 0.07053469f, 0.02596680f, -0.02806981f, -0.08532371f, 
    -0.04645156f, -0.03021506f, 0.00332052f, -0.00115643f, 0.12329884f, 0.00932674f, -0.06114461f, -0.03582919f, 
    0.04649286f, -0.04014285f, 0.06326683f, 0.01876437f, -0.01524113f, 0.06269557f, -0.05418576f, 0.02752766f, 
    0.07246731f, -0.01683828f, 0.17257147f, -0.15534416f, 0.00301127f, 0.03630280f, -0.00128468f, -0.00186786f, 
    -0.03609122f, 0.04773225f, -0.05771063f, 0.02508588f, -0.08595990f, -0.01116555f, 0.19753653f, 0.11269949f, 
    0.03829879f, -0.00746791f, -0.00758610f, -0.08959684f, -0.11327906f, -0.08747526f, -0.10328760f, 0.03397831f, 
    0.26830164f, 0.09785423f, 0.39895612f, -0.14444539f, -0.08993787f, -0.18435127f, -0.07229642f, -0.07457189f, 
    -0.05251841f, 0.07914367f, -0.02149590f, 0.05309335f, 0.20154630f, 0.12745455f, -0.04631654f, -0.19864209f, 
    -0.01921462f, 0.00298723f, 0.00403316f, -0.02264525f, -0.01211666f, 0.04758198f, -0.02605889f, 0.16138700f, 
    0.05739094f, -0.11076747f, -0.13777226f, 0.13731769f, 0.07626547f, 0.00658519f, -0.11957759f, 0.00272611f, 
    0.10204241f, -0.03443194f, 0.10391936f, 0.01726639f, 0.03705980f, -0.01007876f, 0.05441812f, -0.00673000f, 
    -0.03140529f, -0.04695053f, 0.04261742f, 0.09335906f, 0.05059165f, -0.06065387f, 0.08320207f, -0.03244465f, 
    -0.12599137f, -0.11991041f, 0.08929805f, 0.16247071f, 0.00720668f, -0.00599071f, 0.14833364f, 0.14701785f, 
    0.00581053f, -0.03353474f, 0.03151771f, -0.00334345f, -0.00569231f, 0.12255409f, 0.00600314f, 0.02794210f, 
    -0.10127404f, -0.09332357f, -0.03954311f, -0.09937329f, -0.01568748f, -0.00353687f, 0.03673875f, 0.07144714f, 
    0.19495034f, 0.03958654f, 0.17520587f, -0.19796805f, -0.06776301f, -0.00873027f, -0.05278395f, 0.04436491f, 
    0.03127477f, 0.02209270f, 0.02337384f, 0.00348556f, 0.05159931f, 0.26749405f, -0.17009561f, -0.39731461f, 
    -0.06536642f, -0.04183825f, -0.01162362f, 0.10075307f, 0.03453239f, 0.08985680f, 0.06681669f, 0.01789335f, 
    -0.11750542f, -0.06059053f, 0.00341033f, 0.11001548f, 0.02304579f, 0.13050419f, 0.03687759f, 0.01560794f, 
    -0.03415003f, -0.07472193f, 0.06548224f, -0.03698611f, -0.19912177f, 0.10405745f, 0.04244201f, 0.20788693f, 
    -0.01555344f, -0.12586063f, 0.18830134f, 0.12209228f, 0.09963277f, 0.17376891f, -0.01778278f, -0.08405742f, 
    0.20371403f, -0.20915824f, -0.31014422f, -0.18836133f, -0.04207642f, 0.10619780f, 0.04295702f, 0.08526209f, 
    -0.02856135f, 0.12794819f, 0.02035629f, -0.05737437f, 0.56407529f, 0.11032953f, -0.15713902f, -0.22105780f, 
    -0.09421270f, 0.03941816f, -0.04651742f, -0.01927945f, -0.03742537f, 0.18479244f, -0.17407247f, 0.09186636f, 
    0.07212725f, 0.12405930f, 0.25733036f, 0.15761372f, -0.15993761f, -0.18060240f, -0.04632144f, 0.03559992f, 
    0.04331765f, 0.00033227f, 0.04872518f, 0.05357839f, -0.03982403f, -0.07627927f, -0.18562263f, 0.11116693f, 
    0.06827506f, -0.01949457f, 0.03320855f, -0.12233551f, -0.00451862f, -0.00901357f, -0.01288910f, -0.04883812f, 
    -0.08717493f, -0.12634990f, 0.05477916f, 0.02641958f, 0.01094644f, -0.07740698f, -0.03126226f, -0.02918291f, 
    -0.02123951f, -0.01087600f, -0.02617890f, -0.08618234f, 0.05516395f, 0.18296944f, -0.27417350f, 0.04221765f, 
    0.07639696f, -0.02383192f, 0.18128976f, -0.04865609f, -0.01381493f, -0.06750108f, 0.03401273f, 0.08701091f, 
    0.05913651f, -0.20197341f, -0.00944251f, 0.04152603f, 0.20200956f, -0.00775418f, -0.05637620f, -0.05875119f, 
    -0.02593955f, 0.12475297f, -0.08292609f, -0.04253753f, 0.26281697f, -0.09805681f, -0.15841644f, 0.17050044f, 
    -0.09118966f, 0.16908213f, -0.06337595f, 0.10099009f, 0.05415233f, 0.07536745f, 0.03869099f, 0.02968679f, 
    -0.12270257f, -0.17399690f, -0.02909470f, 0.15193905f, 0.04445631f, 0.18894908f, 0.00800605f, -0.22057667f, 
    0.05129796f, 0.01531486f, -0.08231740f, -0.05861928f, 0.02945325f, 0.09119756f, 0.09493378f, 0.05539274f, 
    -0.05063413f, -0.01428422f, -0.10606600f, 0.01503005f, 0.02052999f, -0.04193084f, 0.09473904f, -0.02573354f, 
    -0.08083923f, 0.08610807f, 0.01809497f, 0.06341378f, -0.06610470f, 0.06453479f, 0.17205104f, -0.11974689f, 
    0.09942351f, 0.04844792f, 0.00192852f, -0.04188642f, 0.06399859f, 0.10433972f, -0.15058917f, 0.12597461f, 
    -0.01276236f, -0.11213171f, 0.06986546f, 0.07968188f, -0.00891859f, 0.03975954f, -0.04339277f, 0.05441595f, 
    -0.14955768f, -0.15728991f, -0.00562008f, -0.08493213f, -0.03433418f, -0.07357824f, -0.01546243f, 0.00231474f, 
    -0.01625934f, 0.12804124f, 0.02490452f, 0.03941061f, -0.18192038f, 0.15721847f, 0.03970716f, 0.06289138f, 
    -0.05382287f, 0.04009820f, 0.11034584f, -0.05395130f, -0.01944698f, 0.01001470f, -0.12244714f, -0.06998394f, 
    -0.05773915f, 0.05420497f, 0.10599612f, -0.00005942f, -0.14717549f, -0.09898832f, 0.21943781f, -0.11545326f, 
    -0.16928256f, 0.03766543f, -0.09319363f, -0.10635646f, -0.10854524f, -0.08737530f, 0.15198578f, 0.17392573f, 
    -0.02747743f, 0.03965315f, 0.11080247f, -0.08987361f, -0.07482686f, -0.05024000f, 0.05430932f, -0.05041887f, 
    -0.20406361f, -0.15946954f, -0.09195653f, 0.05204921f, -0.02420897f, 0.09068887f, 0.05755104f, -0.05364759f, 
    0.00005153f, -0.06852141f, 0.02272831f, 0.03231801f, 0.01397527f, -0.09594410f, 0.02079812f, -0.03213361f, 
    0.05055537f, 0.08119884f, 0.03152713f, 0.05421504f, 0.00200316f, -0.01945962f, 0.11048360f, -0.04407281f, 
    0.08094586f, 0.05656194f, -0.02246546f, 0.03466876f, -0.05298456f, -0.10448138f, -0.13692585f, -0.09985758f, 
    0.06468593f, 0.17258668f, 0.15258951f, -0.04019916f, -0.07812426f, -0.19648911f, 0.16550325f, 0.16921687f, 
    0.08792156f, 0.06723481f, 0.03040885f, 0.03482809f, -0.04118637f, 0.00106005f, 0.01396430f, -0.05262761f, 
    0.11044151f, 0.15094541f, 0.07497803f, 0.03327613f, 0.02121543f, -0.01915351f, -0.06870454f, -0.06186693f, 
    -0.04947337f, 0.06171429f, -0.03453845f, 0.11709727f, 0.02692348f, 0.02874330f, -0.07938986f, 0.08054188f, 
    0.01318109f, -0.01378200f, 0.13783838f, -0.02495491f, 0.00246736f, 0.06284025f, 0.00450061f, -0.04048610f, 
    0.05758427f, 0.22970256f, 0.06746835f, -0.17912921f, 0.02045631f, 0.04853633f, -0.00420865f, 0.03913715f, 
    -0.00669738f, 0.13917664f, -0.12572087f, -0.04384232f, -0.18437910f, 0.10754321f, -0.15285778f, 0.32983676f, 
    -0.00029400f, -0.09811883f, 0.07689928f, -0.19581345f, -0.04240607f, 0.00142508f, -0.02477830f, 0.02373636f, 
    0.11995876f, -0.03044657f, 0.05573817f, -0.15451913f, -0.08281056f, 0.01816033f, -0.02317133f, 0.02434843f, 
    -0.00070396f, 0.05701850f, 0.10641307f, -0.00893406f, -0.09906328f, -0.13624942f, 0.23633870f, 0.03785457f, 
    -0.00886924f, 0.02966119f, -0.21281457f, 0.03678317f, 0.17635070f, 0.08416186f, 0.18147658f, 0.13945131f, 
    0.20051117f, 0.00405927f, -0.32895747f, 0.23026803f, 0.16045788f, -0.13781604f, -0.04459406f, 0.06344590f, 
    -0.07031105f, -0.00733236f, 0.05462324f, 0.07789670f, -0.21224830f, 0.06941959f, 0.17259455f, 0.11304839f, 
    0.06012249f, -0.10714669f, -0.00046896f, -0.05472855f, -0.03209326f, -0.02457682f, 0.04269352f, 0.15783234f, 
    0.05931706f, 0.35853785f, -0.19645825f, 0.11610539f, -0.12439094f, 0.17981948f, -0.00959900f, -0.12132338f, 
    0.16363218f, 0.01706979f, 0.02107431f, 0.00495059f, -0.05008347f, 0.04918505f, 0.04654947f, 0.22276030f, 
    -0.06729123f, -0.01271068f, -0.05299909f, -0.09384941f, -0.02728076f, -0.07209869f, -0.10157303f, -0.05783627f, 
    0.35536829f, -0.28954479f, -0.10921029f, -0.04727797f, 0.03495714f, 0.13534464f, 0.00481794f, 0.02218612f, 
    -0.01329489f, 0.07991441f, 0.02535205f, 0.02368778f, 0.16740151f, 0.18874149f, -0.07549798f, -0.21595369f, 
    0.00107438f, -0.07171810f, 0.05694620f, -0.00781428f, 0.09037548f, 0.15801504f, -0.01651023f, -0.03200116f, 
    0.01274994f, 0.05179384f, 0.22165507f, 0.19563356f, -0.02328733f, -0.00646726f, 0.09066708f, -0.17214523f, 
    -0.07505805f, -0.00692016f, -0.04419673f, -0.03945403f, -0.03422865f, -0.17362230f, -0.08946254f, 0.00874129f, 
    0.01605782f, -0.00625338f, 0.04448934f, 0.07007040f, 0.04299791f, 0.00047739f, 0.10891639f, -0.06718291f, 
    0.15812339f, -0.15517198f, 0.05915909f, -0.15857998f, 0.04501671f, 0.00224859f, -0.08048608f, 0.11258595f, 
    0.00392922f, 0.10247026f, -0.01642634f, 0.03438593f, 0.29992640f, -0.16708748f, 0.30793917f, -0.10336305f, 
    -0.05703907f, 0.22668865f, -0.03090068f, -0.03356713f, -0.05035326f, 0.08004183f, 0.01496605f, 0.10264321f, 
    0.22190224f, -0.21219955f, -0.17053001f, 0.06102025f, 0.05807781f, 0.08915976f, 0.03725924f, -0.04787806f, 
    0.02906726f, -0.09191932f, -0.01851366f, 0.01768914f, -0.13303606f, 0.00165757f, -0.00122127f, 0.10082789f, 
    0.15485562f, -0.07883126f, 0.02447987f, 0.00665558f, -0.11313347f, -0.05496080f, -0.02915739f, 0.02419678f, 
    -0.15922228f, -0.02855131f, -0.02645196f, 0.16137938f, 0.01270069f, -0.05044540f, 0.06865017f, 0.08176750f, 
    0.16683485f, -0.03069302f, 0.10245931f, 0.27055258f, 0.19967912f, -0.05118138f, -0.00771307f, 0.05288519f, 
    -0.11293223f, -0.04051088f, -0.07781567f, 0.03692211f, 0.02744324f, -0.14937195f, 0.00658583f, -0.06630290f, 
    -0.18508588f, -0.04877292f, 0.15461317f, 0.21258296f, -0.15552545f, -0.14920999f, -0.07369992f, 0.09099606f, 
    -0.00228342f, -0.00109111f, -0.07556275f, -0.06035037f, 0.27567881f, 0.04470155f, 0.06185968f, 0.15949686f, 
    0.01941266f, 0.00575648f, 0.05611028f, 0.17477171f, 0.07848989f, -0.06489353f, 0.05925122f, 0.04687911f, 
    -0.05084814f, -0.07726914f, -0.05355057f, -0.02535751f, 0.02336972f, -0.02403842f, 0.01994023f, -0.17403696f, 
    -0.07410333f, 0.01977408f, -0.01564501f, 0.03694104f, 0.11272681f, -0.13425025f, -0.01736640f, 0.12844913f, 
    0.05629620f, 0.10657423f, 0.07784305f, -0.11632155f, -0.05036189f, -0.03773160f, -0.24306951f, -0.32027280f, 
    0.16353348f, -0.10744650f, -0.19014764f, 0.00873613f, 0.06439023f, 0.03733360f, 0.31049758f, 0.05338838f, 
    0.18206173f, 0.25233424f, 0.23353851f, 0.34314150f, 0.12083637f, 0.42314395f, -0.14021488f, 0.12963441f, 
    -0.00754847f, -0.07169055f, 0.08682559f, -0.09731981f, 0.01343993f, 0.11112965f, 0.00254878f, -0.08920788f, 
    -0.17350909f, 0.23686263f, -0.02029514f, 0.10447468f, 0.15613222f, 0.04282745f, 0.09772985f, 0.01497088f, 
    -0.07342978f, -0.04477771f, -0.00194316f, 0.20694119f, -0.15971197f, 0.08660126f, -0.26497251f, 0.15160105f, 
    0.01520458f, 0.05139838f, -0.03486405f, -0.02236176f, -0.05827346f, -0.00500771f, 0.08705794f, 0.00077086f, 
    -0.05335766f, -0.05217917f, -0.05150204f, -0.17561451f, -0.03954409f, 0.11502718f, 0.06376991f, 0.01336784f, 
    0.13254759f, 0.11743350f, 0.00110436f, 0.18130974f, 0.04946572f, -0.07950179f, -0.11339775f, -0.05365387f, 
    -0.05556822f, -0.09316415f, 0.08474673f, 0.07242458f, 0.13203657f, 0.14795208f, 0.13576125f, 0.22616845f, 
    -0.06191023f, -0.03553609f, 0.07938445f, 0.07365245f, 0.05019152f, 0.02022814f, 0.07086228f, 0.07606024f, 
    0.19285269f, 0.09037072f, 0.07506040f, 0.16376309f, 0.05057520f, 0.02605505f, -0.05570044f, -0.10905083f, 
    -0.04443959f, -0.02227546f, -0.04603098f, -0.07230115f, -0.10012970f, -0.17933542f, -0.08756699f, -0.30777326f, 
    -0.04300116f, 0.01906273f, 0.04231980f, -0.13911493f, 0.04728715f, 0.23010930f, -0.01261922f, -0.18459071f, 
    0.06013022f, -0.16284427f, 0.07516800f, 0.04085415f, -0.05303866f, -0.05243371f, 0.16696329f, 0.05512743f, 
    -0.03775926f, 0.04555601f, 0.09309563f, 0.09501157f, -0.01884210f, 0.09640317f, -0.05195048f, 0.08884276f, 
    0.03954560f, -0.05373338f, -0.05389227f, 0.07452238f, -0.10916513f, 0.13286704f, 0.06370262f, -0.02112569f, 
    -0.02645819f, -0.13247679f, -0.04842464f, -0.17072500f, 0.07699497f, -0.02654335f, -0.02949071f, -0.06060908f, 
    -0.03268879f, -0.08999012f, -0.12199320f, -0.02379015f, 0.05834618f, 0.05967506f, 0.08085864f, -0.01096899f, 
    -0.00006898f, 0.17334864f, -0.17165908f, 0.09298539f, 0.06231788f, -0.01252458f, -0.01561989f, -0.05679905f, 
    0.12006027f, 0.07422968f, 0.11268467f, 0.10282855f, 0.17491201f, 0.01316517f, -0.02624747f, -0.13658202f, 
    0.08413871f, -0.02247984f, -0.22818744f, -0.14229614f, -0.10291839f, -0.06950781f, -0.07056233f, -0.00185216f, 
    0.05816245f, -0.04820252f, 0.18946663f, 0.00872079f, 0.04889252f, -0.12988020f, -0.08354904f, -0.11712088f, 
    0.07974081f, -0.08477056f, -0.06969926f, -0.00140011f, -0.11579417f, -0.09478233f, -0.09756548f, 0.16078597f, 
    0.10690487f, 0.02557138f, 0.08737570f, -0.00490653f, -0.33133546f, -0.15657637f, -0.35084566f, -0.19163133f, 
    -0.04390957f, -0.06727891f, -0.09663136f, -0.09312177f, -0.00851291f, -0.03103134f, -0.09912581f, 0.00186604f, 
    -0.20724010f, -0.19210416f, -0.05712954f, -0.15590893f, 0.22095490f, 0.05519822f, 0.06647100f, -0.19827187f, 
    0.06545015f, -0.11080337f, -0.18092336f, -0.01013763f, 0.08770049f, -0.03769481f, -0.02337745f, -0.17383987f, 
    0.12342582f, 0.12516698f, 0.12250280f, 0.15380333f, -0.03816114f, -0.02870282f, 0.08839094f, -0.05702920f, 
    0.10927211f, -0.00120767f, 0.10690563f, 0.04853377f, -0.18762182f, 0.22876501f, 0.10750070f, -0.00671724f, 
    -0.19789742f, -0.07948427f, 0.00016393f, -0.10243208f, -0.02597331f, -0.05104359f, -0.09031186f, -0.07892132f, 
    0.37242833f, 0.24964021f, 0.30596876f, 0.24977224f, -0.24086230f, -0.10894589f, 0.05166958f, 0.14776748f, 
    0.02183997f, 0.00202288f, -0.04747996f, -0.20594147f, 0.12179275f, 0.02980546f, -0.11430997f, 0.05931480f, 
    0.04455220f, -0.14477642f, -0.01779739f, -0.07543128f, 0.02233113f, -0.01015133f, 0.06428014f, 0.15077448f, 
    0.02724593f, 0.11839789f, 0.11199111f, 0.31363443f, -0.04883721f, 0.03759276f, 0.11899478f, 0.07994463f, 
    -0.14317547f, -0.01099454f, -0.02224596f, -0.12484483f, -0.04132587f, 0.04850848f, 0.10344131f, 0.06976973f, 
    0.00802496f, -0.08736317f, -0.00597016f, 0.02582450f, -0.07955647f, -0.12013040f, -0.02307300f, -0.01706392f, 
    0.07052466f, -0.00152424f, 0.08390370f, 0.08319893f, 0.02936601f, 0.07019360f, -0.15310514f, -0.12466171f, 
    0.12847653f, -0.17040464f, -0.12502305f, 0.01836564f, -0.04685657f, -0.08110580f, 0.22114976f, 0.12307675f, 
    0.03455133f, 0.05765631f, -0.02538455f, 0.09021523f, 0.07531479f, 0.09219358f, 0.11187679f, 0.13320966f, 
    -0.01880335f, -0.02332426f, -0.29081813f, -0.12726516f, 0.04932491f, -0.01481296f, 0.02497875f, 0.00329559f, 
    0.00378040f, -0.01269587f, -0.21426482f, -0.13120912f, 0.01700126f, 0.16397537f, -0.04944865f, -0.17869745f, 
    0.04272947f, -0.01185348f, 0.02892531f, 0.04541825f, 0.08383749f, -0.01567709f, -0.00268408f, -0.05424049f, 
    0.09461334f, 0.02422169f, 0.01389443f, 0.07060920f, 0.09116259f, 0.09234405f, 0.03221327f, 0.00797900f, 
    0.06272137f, -0.05341261f, -0.04813578f, -0.12216549f, -0.09163576f, -0.05600473f, -0.01215075f, -0.02981086f, 
    0.08539693f, 0.14509720f, 0.02280381f, 0.01764684f, -0.08939406f, -0.22123383f, -0.04913529f, -0.13260962f, 
    -0.23470393f, 0.16215415f, 0.25658816f, -0.12785476f, -0.06633934f, 0.10030017f, 0.06960090f, 0.03583103f, 
    -0.11001894f, -0.05173426f, -0.05135189f, -0.00206017f, -0.07996362f, -0.02842341f, 0.10301826f, 0.04519854f, 
    0.07390527f, -0.07560794f, -0.03915756f, -0.07893391f, -0.20217806f, -0.02574691f, -0.13506404f, -0.28423598f, 
    -0.04185254f, -0.07245238f, -0.03993096f, 0.14999016f, -0.01639944f, -0.05834562f, 0.04684822f, 0.04599119f, 
    0.21278661f, 0.15862890f, 0.08979720f, 0.15731978f, -0.25383866f, -0.06398038f, -0.00652614f, 0.06155918f, 
    -0.01737181f, -0.14200930f, 0.06372732f, -0.09020968f, -0.09396096f, -0.20091820f, 0.01131743f, -0.14742839f, 
    0.10380248f, -0.01417550f, 0.02608298f, -0.05540083f, -0.13345277f, -0.12632233f, 0.10945175f, 0.06055075f, 
    -0.05131773f, -0.06421879f, -0.03778726f, -0.02606782f, -0.15584004f, 0.16591881f, 0.05445448f, -0.00081669f, 
    0.06897122f, 0.01237071f, 0.04874090f, 0.09525937f, 0.16841415f, -0.02196957f, 0.04898395f, 0.17490020f, 
    0.20769407f, 0.24071513f, 0.23691300f, 0.11916078f, 0.00391930f, -0.13033114f, -0.07378076f, -0.03805625f, 
    0.20869836f, 0.00201653f, 0.10404854f, 0.12272570f, -0.23377176f, -0.37293652f, -0.00623165f, -0.16233641f, 
    -0.00229708f, 0.01917826f, 0.03574508f, -0.01717288f, 0.08131652f, -0.22562447f, -0.00200904f, 0.00866327f, 
    -0.04414113f, -0.16210589f, -0.18033282f, 0.05536888f, -0.02386195f, -0.04470479f, 0.06856306f, -0.04011892f, 
    0.24794264f, 0.17284003f, 0.14174515f, 0.29606715f, -0.05001480f, 0.03583500f, 0.08878133f, 0.11426960f, 
    0.15424785f, -0.04870298f, -0.01159874f, 0.05082175f, -0.08618438f, -0.17020833f, -0.11268904f, -0.14437278f, 
    -0.09056187f, 0.03529195f, 0.01924939f, -0.05542795f, 0.07404803f, 0.01238091f, -0.00682378f, -0.08880527f, 
    0.14175564f, -0.03918141f, 0.14125240f, 0.05400997f, -0.26368454f, -0.18588650f, 0.07359174f, -0.13484800f, 
    0.01759486f, -0.02940160f, 0.03091515f, -0.12439051f, -0.14765269f, -0.08114563f, -0.17270091f, -0.17011158f, 
    -0.03794717f, -0.04091309f, 0.08295529f, -0.03594214f, -0.14238714f, -0.09151554f, -0.12729695f, 0.04790054f, 
    0.08565722f, 0.11490678f, -0.05678463f, 0.14017311f, -0.30164766f, 0.01732402f, 0.12386289f, 0.14624012f, 
    -0.01957846f, -0.10230546f, 0.13746795f, -0.04521573f, -0.10413458f, -0.01638121f, 0.06412179f, 0.02344375f, 
    0.05043000f, -0.08070052f, -0.05038853f, -0.08517207f, -0.02778069f, -0.02221596f, -0.11118563f, 0.02394770f, 
    0.12473614f, 0.11836328f, 0.13887131f, 0.12974308f, 0.07618464f, 0.06942569f, 0.13915560f, 0.27278879f, 
    -0.02140641f, 0.14071618f, 0.08672705f, 0.08559651f, 0.22451854f, -0.05852540f, 0.24742499f, 0.09895671f, 
    -0.04528759f, 0.01747082f, -0.00649385f, -0.03163743f, 0.09267922f, -0.00512305f, 0.05263932f, 0.01610258f, 
    -0.08384100f, -0.16281462f, -0.14895330f, -0.23027739f, -0.11840870f, 0.16320059f, -0.07525824f, 0.02271497f, 
    0.06384253f, 0.03546038f, 0.08046400f, 0.02716511f, -0.12443948f, -0.05994609f, -0.08454654f, -0.17451966f, 
    -0.01070352f, -0.02652278f, -0.08825751f, -0.00592180f, 0.13385332f, -0.04673823f, 0.15873198f, 0.06522334f, 
    0.11731084f, -0.00528428f, 0.04794396f, -0.02433866f, -0.01625562f, 0.06130535f, -0.05830255f, 0.10504486f, 
    0.11201481f, 0.12697871f, 0.16457102f, -0.02204210f, -0.07204331f, -0.01859432f, -0.16869108f, -0.09725874f, 
    0.22601485f, 0.08817274f, 0.04611648f, 0.24807127f, -0.10007491f, -0.04275243f, -0.04012943f, 0.05683591f, 
    0.07260025f, 0.03680662f, -0.01370435f, 0.06919439f, -0.02606650f, -0.01568079f, 0.01447762f, -0.09272455f, 
    -0.09912568f, -0.00199098f, 0.01005317f, -0.04490457f, 0.06612938f, 0.11827201f, 0.19101653f, 0.24236393f, 
    -0.03920918f, 0.13667515f, 0.00048057f, 0.05750726f, 0.08577621f, -0.06595968f, 0.08594048f, 0.04036747f, 
    -0.13458510f, -0.10975900f, -0.08656745f, -0.04010870f, 0.18636742f, 0.17452879f, 0.42085317f, 0.13286474f, 
    -0.16113602f, -0.13890907f, -0.04807124f, 0.09985240f, 0.25359446f, -0.00762574f, 0.03566661f, 0.16196941f, 
    0.14761211f, -0.15560593f, 0.02673621f, -0.04048601f, 0.17825055f, 0.14363284f, 0.07564109f, -0.00318649f, 
    0.09139680f, 0.12074818f, -0.19130506f, 0.13629948f, 0.07011296f, 0.05116762f, -0.06691598f, 0.13009088f, 
    -0.04776756f, 0.14434607f, 0.08396833f, -0.10221007f, 0.07019889f, 0.02145874f, 0.13702820f, 0.21363775f, 
    0.05495856f, -0.12284028f, -0.12250134f, 0.08249830f, -0.00352725f, 0.01174541f, 0.21509925f, 0.11007704f, 
    0.01233867f, 0.10543772f, 0.18795846f, 0.23862655f, 0.04398499f, 0.03234657f, 0.11668302f, 0.04798663f, 
    0.08105982f, 0.07492925f, -0.06517280f, 0.03795573f, 0.04658792f, 0.22326936f, 0.15563595f, 0.18232217f, 
    -0.32281125f, -0.15526085f, -0.03981248f, 0.15758519f, -0.08764672f, -0.16652067f, 0.18097302f, 0.10809084f, 
    0.01196167f, -0.03681631f, -0.05903219f, 0.10469253f, -0.00582939f, 0.09984380f, -0.13102245f, -0.02774693f, 
    0.00235667f, -0.03646260f, -0.04171160f, 0.03892760f, 0.05330845f, 0.11420105f, -0.03822634f, 0.22110026f, 
    -0.11214592f, -0.17289457f, -0.18691467f, -0.02191667f, -0.00708837f, -0.05007540f, 0.02670916f, 0.02139113f, 
    0.01061027f, 0.03368015f, 0.07164001f, 0.00941884f, 0.10133390f, -0.07777703f, -0.06769059f, -0.04094706f, 
    -0.04942089f, -0.08025067f, 0.02677384f, -0.08769862f, 0.18794510f, 0.02691240f, 0.04660629f, 0.04363686f, 
    0.18801153f, 0.03481681f, 0.02297630f, 0.00116809f, 0.05831579f, 0.03825193f, 0.00506504f, 0.04245796f, 
    0.04092395f, -0.00218557f, -0.06690376f, -0.05013996f, 0.30712384f, 0.02649544f, -0.04405984f, 0.23871560f, 
    0.08433681f, -0.09656225f, 0.06826553f, -0.00114726f, 0.02812840f, 0.01137519f, -0.02732369f, -0.13255088f, 
    0.18774964f, -0.14346585f, -0.15199989f, 0.07370111f, 0.04502078f, -0.11882524f, 0.22500533f, 0.13075270f, 
    0.07223731f, 0.05829190f, 0.16036636f, 0.14193910f, -0.08352606f, 0.29986763f, 0.01847076f, 0.29642135f, 
    0.00365855f, -0.13027745f, 0.21413024f, 0.02988404f, -0.15397747f, -0.01976509f, 0.12917383f, -0.00641871f, 
    -0.13191406f, 0.22055930f, -0.11914983f, 0.00232936f, 0.10577116f, 0.00498045f, -0.03192969f, -0.00111600f, 
    0.12297168f, 0.01837615f, 0.04446137f, -0.01692298f, 0.03540079f, 0.20302558f, -0.22430952f, -0.04073329f, 
    0.14390403f, 0.02450904f, -0.02767402f, 0.10775516f, -0.09051654f, 0.17294860f, 0.24451648f, -0.00894092f, 
    0.17752571f, -0.01447694f, 0.04099436f, -0.00267740f, 0.07247543f, 0.02992219f, 0.05779111f, 0.03287942f, 
    0.11415491f, 0.10716856f, 0.08315373f, -0.13462031f, 0.22040218f, 0.17083155f, 0.08155879f, -0.01219534f, 
    0.02744788f, -0.02512678f, 0.04707235f, 0.04318347f, 0.07520714f, 0.11112977f, 0.08625047f, -0.03286739f, 
    -0.15702288f, -0.07955927f, 0.01421575f, 0.02531369f, 0.07264620f, -0.06417203f, 0.00316687f, 0.01217612f, 
    0.04249847f, -0.00248559f, 0.06134015f, -0.04025865f, 0.09517705f, 0.00942281f, -0.00429034f, -0.13927676f, 
    0.05253453f, 0.06223300f, -0.03252837f, 0.04821648f, 0.07456233f, -0.05064275f, -0.02894241f, -0.09248947f, 
    0.01831620f, 0.01384021f, 0.13875996f, 0.12791167f, 0.02850669f, 0.08825115f, 0.05853026f, -0.13800205f, 
    0.15899447f, 0.13245042f, 0.31089845f, -0.13657837f, -0.12977500f, -0.04320910f, 0.25227547f, 0.21097493f, 
    -0.17031199f, -0.02509790f, 0.08256119f, -0.03902025f, -0.03408227f, 0.07082206f, -0.07632169f, 0.04799108f, 
    0.58244586f, -0.09908564f, -0.02839677f, 0.13322052f, 0.02291172f, -0.02431576f, -0.02071434f, 0.02462968f, 
    -0.03979249f, -0.03049142f, -0.02736639f, -0.10773428f, 0.22410820f, 0.12566379f, 0.02710022f, 0.05027896f, 
    0.08244589f, -0.00842038f, -0.02272250f, -0.05510898f, 0.04514170f, -0.05242712f, 0.06606160f, -0.09661163f, 
    -0.00411564f, 0.16518857f, 0.10333957f, -0.00504520f, -0.00736327f, 0.07447160f, 0.09146226f, -0.04052655f, 
    0.00022428f, 0.03128672f, 0.10263801f, -0.03275189f, 0.12130111f, 0.01000345f, 0.11436898f, -0.08340216f, 
    0.15236473f, -0.00107190f, -0.07013904f, 0.03668103f, 0.02822094f, -0.04301248f, -0.03907617f, 0.06727047f, 
    -0.05975571f, -0.14223418f, 0.03132589f, 0.05371204f, -0.01808551f, -0.11603368f, -0.06273553f, -0.06959991f, 
    0.05919728f, 0.10977268f, 0.01045461f, -0.01971821f, 0.13338795f, 0.11502799f, 0.04506107f, -0.01112292f, 
    0.11476866f, 0.03154432f, 0.05228996f, 0.05053402f, -0.01147985f, -0.02847860f, -0.13998537f, -0.01027403f, 
    0.38665345f, 0.10330444f, 0.07190461f, 0.02348923f, 0.09557858f, 0.00473564f, -0.01052932f, -0.00678283f, 
    0.01260031f, -0.05133938f, -0.11113507f, -0.09915550f, 0.15902756f, 0.09870408f, -0.16068368f, -0.09121951f, 
    0.10109242f, -0.00939382f, -0.12249336f, -0.09173968f, -0.01832366f, 0.11332181f, -0.01279672f, -0.03770422f, 
    -0.07290588f, -0.02390684f, 0.01177418f, 0.02519086f, -0.00518712f, 0.04381848f, -0.00843559f, -0.01820827f, 
    0.03766195f, 0.00982213f, 0.09485690f, 0.04181059f, -0.37191883f, -0.08746216f, 0.15046856f, 0.18797070f, 
    -0.11537036f, 0.01182653f, 0.06856835f, 0.16000725f, -0.07703769f, -0.15605085f, 0.04068109f, -0.00847701f, 
    0.35896432f, -0.10654958f, 0.02782073f, 0.01242233f, -0.00338064f, -0.08902967f, -0.04933988f, -0.10574073f, 
    0.10926389f, 0.05436889f, 0.07845443f, 0.00669687f, 0.19417438f, 0.10850926f, -0.19583239f, -0.04539854f, 
    0.10235257f, -0.03845292f, -0.00521093f, -0.09209830f, 0.01223928f, 0.04656481f, 0.05128595f, 0.10893510f, 
    0.29814661f, 0.21503568f, 0.09255394f, 0.34505460f, 0.03077990f, 0.06828380f, 0.16717602f, 0.23740405f, 
    0.09495264f, 0.03795356f, 0.04515059f, -0.00827403f, -0.10120250f, -0.14258805f, -0.10819424f, -0.08366951f, 
    -0.05747036f, -0.10751836f, 0.03754207f, 0.10274159f, 0.06152685f, 0.00069764f, -0.01510115f, 0.02622945f, 
    0.10974404f, 0.00727390f, 0.07645016f, 0.08304406f, 0.16932596f, -0.03544597f, -0.04352770f, -0.18593767f, 
    0.20611881f, -0.02163835f, 0.01806421f, 0.03618822f, -0.21343356f, -0.00836421f, 0.04821754f, 0.02434257f, 
    0.19013768f, 0.16823529f, 0.01194577f, 0.03772533f, -0.07739359f, -0.02327320f, 0.04675838f, 0.13334386f, 
    -0.02800746f, 0.07451013f, -0.00294590f, 0.02430854f, 0.10187242f, -0.06597704f, -0.04038199f, 0.01927778f, 
    0.09778661f, 0.04862849f, -0.11401612f, -0.08711655f, 0.08837835f, -0.02781105f, 0.02180953f, -0.31434065f, 
    0.06402504f, 0.02125501f, -0.04583110f, 0.08318285f, 0.06837382f, 0.01920217f, 0.11085775f, 0.04148795f, 
    -0.05933570f, -0.11497696f, 0.14371432f, 0.18914868f, 0.07156280f, 0.00749446f, 0.01500011f, -0.07523415f, 
    0.13653390f, -0.10929505f, -0.03834082f, -0.08823177f, 0.08643057f, 0.14115834f, 0.08578455f, 0.01888500f, 
    0.05713674f, 0.06493878f, -0.04242959f, 0.04747506f, 0.05867745f, -0.01453191f, -0.03630762f, -0.08101819f, 
    -0.34074607f, -0.04534047f, 0.32233995f, -0.12590104f, 0.06543680f, -0.19381446f, -0.14756727f, 0.13162591f, 
    -0.15830570f, -0.08660029f, -0.03629093f, 0.05785795f, -0.04413457f, -0.05913687f, 0.11466516f, -0.00170435f, 
    0.10478355f, 0.06671595f, 0.01850854f, -0.03589110f, 0.03096571f, 0.03628007f, 0.07292514f, -0.02506162f, 
    -0.22637479f, -0.18934530f, -0.32967913f, -0.03539996f, -0.06094867f, -0.09169865f, 0.03350263f, 0.08435360f, 
    0.02632309f, 0.10593547f, 0.06162168f, 0.23188344f, -0.26401728f, -0.14090322f, -0.18210392f, -0.01299755f, 
    -0.03412289f, -0.10994346f, -0.04319069f, 0.04735613f, -0.00567753f, -0.02997304f, 0.02824052f, -0.03228723f, 
    0.03840981f, 0.04200603f, -0.04984297f, -0.04141583f, -0.04818953f, 0.00870948f, -0.06894989f, 0.13739482f, 
    -0.08558079f, 0.02713758f, -0.07444864f, 0.10672682f, -0.14383499f, 0.01494808f, -0.02865233f, 0.09260251f, 
    -0.00570154f, -0.14303708f, 0.07053576f, 0.03105891f, -0.08497390f, 0.08186110f, -0.04089685f, 0.07756577f, 
    -0.13827743f, 0.01237122f, 0.14019424f, 0.01413340f, 0.05262199f, -0.04183489f, -0.04992659f, -0.11460612f, 
    0.01878914f, -0.13482425f, 0.12706214f, 0.00882374f, 0.00565133f, -0.13425350f, 0.09401146f, -0.04248476f, 
    0.08975995f, 0.03668461f, 0.04205719f, -0.02666010f, 0.22651009f, -0.13902409f, 0.07927260f, -0.08415246f, 
    0.22021636f, -0.01023441f, -0.04133647f, 0.08059464f, 0.00910671f, 0.00573651f, 0.04714914f, -0.03764045f, 
    0.30160877f, 0.05921032f, -0.06440328f, -0.00459180f, -0.12301131f, -0.08107533f, 0.20476748f, 0.09340771f, 
    0.05203539f, -0.07206766f, 0.00015413f, 0.09215133f, 0.09887829f, -0.01077350f, -0.03745985f, -0.03343509f, 
    0.00007797f, 0.15396686f, 0.21652047f, -0.11301783f, 0.05293759f, 0.12803631f, -0.05577335f, -0.02804602f, 
    0.11654166f, -0.01027038f, 0.10034697f, -0.01479678f, -0.11505051f, -0.07017194f, 0.02379032f, -0.04347759f, 
    -0.03456605f, -0.00842930f, 0.15692006f, 0.07686681f, 0.05423145f, -0.00031896f, -0.04200325f, -0.00133402f, 
    -0.15990488f, -0.15804029f, 0.21818613f, 0.06302748f, 0.04996462f, -0.01940804f, -0.01157689f, -0.04212946f, 
    0.05014690f, -0.00817171f, 0.02345470f, 0.07209565f, -0.42570049f, -0.02007578f, -0.02521495f, 0.21366639f, 
    -0.08317613f, -0.01042563f, 0.05264756f, 0.00327509f, -0.04996847f, 0.06283721f, 0.11139567f, -0.10794263f, 
    0.21530700f, 0.21612078f, 0.05877329f, -0.03140042f, 0.00832925f, 0.00396897f, -0.04219665f, -0.01724778f, 
    0.22374868f, -0.07669128f, 0.09065893f, -0.04881197f, 0.04420738f, 0.15039040f, 0.17002477f, 0.11793396f, 
    0.00784640f, 0.13914125f, 0.02289082f, 0.02156130f, 0.21179236f, -0.00849078f, 0.23041284f, 0.08649058f, 
    0.00120557f, 0.03501292f, 0.06141088f, 0.05414049f, 0.10617809f, -0.07374263f, -0.00739312f, -0.05578150f, 
    -0.00370047f, 0.11534425f, 0.13133004f, -0.12223949f, -0.10069792f, 0.26990280f, 0.19639221f, 0.01068521f, 
    0.08796657f, 0.09981940f, -0.04448064f, 0.23061371f, 0.09602155f, 0.06021562f, 0.05042335f, -0.06888536f, 
    0.23090371f, 0.03997185f, 0.18781276f, -0.02616172f, 0.09273785f, 0.05662523f, -0.08309737f, 0.09480423f, 
    0.17340501f, -0.08045837f, 0.09901808f, -0.08465191f, 0.03735374f, -0.04919348f, 0.03832545f, 0.14738031f, 
    -0.03797074f, -0.03359087f, 0.06043190f, 0.06105296f, 0.03291599f, 0.00829817f, -0.03208375f, -0.04259877f, 
    0.22685853f, -0.07851437f, -0.17177801f, -0.05720503f, 0.00193107f, -0.02890506f, -0.02368272f, -0.07577600f, 
    0.03063742f, 0.00641697f, 0.02205629f, 0.15677170f, 0.15194142f, 0.09117918f, 0.07911868f, 0.00720826f, 
    0.04201301f, 0.03444858f, -0.03649513f, -0.05626583f, 0.06219859f, 0.01751623f, -0.00641062f, 0.21825132f, 
    -0.12060242f, 0.07652861f, 0.11440389f, 0.09066179f, 0.01767560f, -0.09931566f, -0.04122923f, 0.11874249f, 
    -0.06429060f, -0.01587994f, -0.04172974f, 0.00863224f, 0.05286869f, 0.00106223f, 0.00874669f, -0.10396736f, 
    -0.01254495f, -0.03997909f, -0.06292357f, -0.04601764f, 0.10958453f, -0.03541375f, 0.04365603f, 0.12661403f, 
    0.44319662f, -0.23381089f, -0.02097083f, 0.16417477f, 0.20471008f, -0.08933283f, 0.07078466f, -0.06625091f, 
    0.06819021f, 0.14727697f, -0.02158151f, 0.02483997f, 0.15356791f, 0.15446755f, -0.03680085f, -0.00541484f, 
    -0.13233121f, 0.02799097f, 0.23479971f, -0.03955146f, 0.00967341f, 0.00091630f, 0.15372095f, 0.15702708f, 
    0.04010560f, -0.20948449f, -0.22083889f, -0.10128625f, -0.05076482f, -0.14190923f, 0.29786891f, 0.17875718f, 
    -0.04210651f, -0.05194210f, 0.11547238f, 0.08977444f, -0.38931903f, -0.00951936f, 0.27988911f, -0.04214856f, 
    0.12035291f, 0.18195391f, -0.10840021f, -0.04625285f, -0.00160812f, 0.04672865f, 0.11261711f, -0.00771538f, 
    -0.02091872f, 0.02087741f, 0.01668135f, 0.02861657f, 0.00051426f, -0.01078755f, -0.03448540f, 0.02756554f, 
    0.00862327f, -0.01003094f, -0.01947773f, -0.03704754f, 0.03010111f, 0.02602322f, -0.01048688f, -0.00132226f, 
    -0.02192861f, 0.01181747f, -0.03469274f, 0.00180986f, -0.01321941f, -0.01029698f, -0.00451161f, -0.01446957f, 
    0.01985580f, 0.00014999f, -0.00499339f, 0.02878177f, -0.02279865f, -0.02965093f, -0.00999504f, 0.00762435f, 
    0.02326701f, -0.03294826f, 0.01336057f, -0.00022239f, -0.00660467f, 0.00301907f, -0.00497503f, -0.00491989f, 
    -0.03089449f, -0.04208015f, -0.03692016f, -0.02396965f, -0.02563009f, 0.01953278f, 0.00322034f, -0.01775895f, 
    0.01960828f, -0.03496384f, 0.01352881f, -0.01073450f, 0.02222221f, -0.01307833f, 0.00866753f, -0.03559085f, 
    -0.03218694f, -0.01402199f, -0.00020620f, -0.02932951f, 0.02139230f, -0.03046065f, -0.03790615f, 0.00515134f, 
    0.00629824f, 0.02054631f, 0.00824268f, -0.02693586f, 0.02255335f, -0.00071086f, 0.02267724f, -0.01999282f, 
    0.00237294f, -0.02879803f, -0.03092789f, -0.02801428f, -0.00888722f, -0.01779584f, -0.01130181f, 0.01045643f, 
    -0.01146855f, 0.01115728f, -0.03677594f, 0.02433589f, -0.01084680f, -0.02656944f, 0.00683476f, 0.01411386f, 
    -0.00155650f, 0.01621885f, -0.01969345f, 0.01084240f, 0.00304865f, -0.03900621f, -0.02627077f, -0.02888163f, 
    -0.00418186f, 0.01586378f, -0.02103611f, -0.01042681f, -0.03952272f, 0.01115285f, -0.03521577f, 0.00767081f, 
    0.00389995f, 0.01147884f, 0.02465129f, -0.03404539f, -0.03869889f, 0.02740223f, 0.01802328f, -0.01502487f, 
    0.00649017f, -0.01681978f, 0.00201847f, -0.02070603f, 0.00284679f, 0.01741359f, -0.02292840f, -0.00406447f, 
    0.00172952f, 0.02061987f, -0.01755744f, -0.01487187f, 0.01982912f, -0.01814029f, 0.01352084f, -0.04029467f, 
    -0.02418567f, 0.00854151f, 0.02766936f, 0.02895477f, -0.03243271f, 0.00840805f, -0.00679150f, -0.03325157f, 
    -0.01434115f, 0.03540010f, -0.03281351f, 0.00081488f, 0.02760936f, 0.01432378f, -0.00916805f, -0.01561002f, 
    -0.01990397f, 0.01483717f, 0.01218946f, 0.02059812f, -0.03021923f, -0.01962253f, -0.02688517f, 0.03001613f, 
    -0.00799492f, 0.01715667f, -0.01524676f, 0.01198177f, -0.01964539f, -0.01688013f, -0.02320225f, 0.00725049f, 
    -0.01422339f, 0.02105147f, -0.02386688f, -0.02588392f, -0.02514241f, -0.01540772f, 0.00595288f, 0.02594438f, 
    -0.03958600f, -0.03559706f, 0.03360967f, -0.00291914f, -0.02641992f, -0.01993229f, 0.01182575f, 0.01256431f, 
    -0.01085087f, -0.01530257f, 0.01179767f, -0.00125635f, -0.03125625f, 0.01484026f, -0.00354802f, -0.00617023f, 
    -0.01194749f, 0.01741451f, 0.01162836f, 0.00864901f, 0.02902370f, 0.02489043f, 0.00529946f, 0.02524051f, 
    -0.03699530f, -0.02955937f, -0.00540873f, -0.01891803f, -0.02617497f, -0.00982136f, -0.00316849f, 0.00728768f, 
    0.00043009f, -0.01208926f, 0.01208243f, -0.02041786f, -0.04087348f, -0.03250186f, -0.00046712f, 0.01844175f, 
    0.02266358f, 0.01485734f, 0.00177272f, 0.00129020f, -0.03630499f, 0.02163864f, 0.00390689f, -0.00667524f, 
    -0.03339471f, -0.01347020f, -0.01169801f, -0.02678497f, -0.03105365f, 0.00680314f, -0.00329259f, 0.00131542f, 
    -0.04106204f, -0.02445590f, 0.02525491f, -0.02356412f, -0.02360620f, -0.01799580f, 0.01029141f, 0.02863263f, 
    0.00818217f, -0.00096255f, -0.03712164f, 0.01418669f, -0.02482899f, 0.02421182f, 0.01582836f, -0.04129262f, 
    -0.00798151f, -0.03238483f, -0.03242569f, -0.01539462f, 0.02943372f, -0.03426429f, -0.00308936f, -0.02941978f, 
    0.01923413f, -0.02380495f, -0.02426835f, 0.00054530f, -0.01479954f, 0.02377588f, 0.01278409f, -0.03166811f, 
    0.01144859f, -0.01436982f, -0.00547949f, -0.00518909f, -0.03798871f, -0.03326005f, 0.01154344f, -0.04172602f, 
    0.00015372f, 0.00116988f, -0.02555632f, 0.00234843f, -0.01537529f, -0.01677764f, -0.04179109f, -0.02354170f, 
    0.02254652f, 0.00891578f, -0.00844630f, -0.03264170f, 0.02554266f, 0.01271755f, -0.03258574f, 0.01328682f, 
    -0.01622518f, -0.01947908f, 0.00731032f, -0.01972904f, 0.02608592f, -0.00748087f, -0.00761855f, -0.00262249f, 
    0.02605203f, -0.02242960f, -0.02324646f, -0.00930713f, 0.00775274f, -0.03695087f, -0.00776858f, -0.02521379f, 
    -0.01349544f, -0.02733237f, -0.01567038f, -0.03415759f, -0.00062330f, 0.00767224f, 0.00413596f, 0.02416843f, 
    -0.01533050f, -0.03969412f, -0.02566868f, 0.01735936f, 0.01812014f, 0.02522779f, -0.00652349f, -0.01008886f, 
    0.01523057f, 0.01156228f, -0.00335425f, 0.02032737f, -0.04026169f, -0.03723262f, -0.03315471f, -0.00252156f, 
    0.00566502f, -0.04070274f, 0.00829916f, -0.00662467f, -0.00243007f, 0.00093275f, -0.01551828f, 0.01568761f, 
    0.01020430f, 0.03376096f, -0.01635237f, -0.03120115f, 0.00617336f, -0.00738593f, -0.01970737f, -0.03179312f, 
    0.02581063f, -0.02610549f, -0.02292703f, -0.03569600f, 0.00001951f, 0.00482305f, -0.03233892f, 0.02416575f, 
    0.02131720f, -0.03915203f, 0.00186360f, -0.03520780f, 0.01900106f, 0.00375447f, 0.01607697f, 0.00257692f, 
    -0.00641279f, -0.00952024f, -0.00716313f, -0.03508227f, -0.00039656f, 0.01273243f, 0.02975211f, -0.00742572f, 
    -0.01771322f, -0.01445629f, -0.03094473f, -0.00339806f, 0.00407144f, -0.00674732f, 0.01471398f, -0.02528414f, 
    -0.02385742f, 0.01131740f, 0.00913120f, -0.01127764f, 0.01972315f, -0.01896861f, 0.01014763f, -0.00336180f, 
    -0.01907619f, -0.02336210f, -0.00444078f, 0.02602022f, -0.01173455f, 0.01645785f, 0.02406258f, -0.00098848f, 
    -0.04091103f, 0.01967348f, -0.01607647f, -0.03657025f, -0.03475912f, 0.01463978f, 0.00724657f, 0.00848958f, 
    -0.01577950f, -0.02746742f, 0.00853042f, 0.02098676f, -0.00933633f, 0.02346713f, -0.04062242f, 0.00906543f, 
    0.00530288f, -0.01267403f, 0.02943915f, -0.01935273f, -0.02044292f, -0.01289186f, 0.01010761f, -0.03067195f, 
    -0.00011613f, -0.00569133f, 0.00678702f, -0.04076957f, 0.00830617f, 0.01911638f, 0.00578113f, -0.01964215f, 
    -0.01004719f, -0.02908553f, 0.00477299f, -0.03563398f, -0.02906648f, -0.02157510f, -0.01849054f, -0.03457399f, 
    -0.00718641f, -0.03770241f, -0.04199537f, -0.03138687f, 0.00281252f, -0.01301062f, -0.00488379f, -0.04167023f, 
    0.02708699f, -0.03766440f, -0.02585974f, -0.02482880f, 0.00873620f, -0.01193061f, -0.00709603f, 0.00726122f, 
    -0.01661101f, 0.02441853f, 0.02548755f, 0.00119104f, 0.02775234f, 0.02226570f, -0.00714612f, -0.03975663f, 
    -0.02079841f, -0.03326682f, -0.03742228f, -0.00966523f, -0.01560870f, -0.03534554f, -0.02812169f, -0.00903199f, 
    -0.01080259f, 0.01402567f, 0.00041759f, -0.00266367f, -0.00927302f, 0.01567645f, -0.00618555f, -0.03034559f, 
    0.02427033f, -0.02762556f, 0.01636080f, 0.01154411f, 0.02549346f, -0.02893504f, -0.00623311f, -0.04201969f, 
    0.00669714f, -0.03290379f, 0.02670322f, -0.02347133f, -0.03645363f, 0.01319927f, 0.00654231f, 0.02034034f, 
    -0.02840434f, -0.03711378f, -0.02740660f, -0.02365582f, -0.03128479f, -0.02276616f, -0.00387631f, 0.01462098f, 
    -0.02781216f, -0.00235250f, -0.02241832f, -0.03656854f, 0.02074549f, -0.01469245f, -0.04093715f, 0.01827112f, 
    -0.02337079f, -0.00721156f, -0.02580000f, 0.01345985f, -0.01551430f, 0.01705395f, -0.00657520f, -0.03883981f, 
    0.02394603f, -0.02462080f, 0.01342509f, 0.01069767f, 0.00808776f, -0.02805504f, -0.02869564f, 0.01136252f, 
    -0.01557571f, 0.00445153f, -0.02953282f, -0.01600887f, -0.04189979f, 0.02055011f, -0.03659631f, -0.02802936f, 
    0.00683535f, 0.00641297f, -0.02399048f, -0.01186527f, -0.02306432f, -0.00578310f, 0.02683043f, -0.02334508f, 
    0.01708526f, -0.01867781f, -0.01115240f, -0.00099546f, -0.03502686f, -0.03365089f, -0.00346770f, 0.00191795f, 
    -0.00898454f, -0.00548864f, 0.00347425f, 0.02884369f, 0.02300087f, -0.02330436f, -0.02559356f, 0.03015398f, 
    -0.00800417f, 0.00116824f, -0.02200691f, -0.02229866f, 0.01079731f, -0.02194908f, 0.01371662f, 0.01653213f, 
    -0.03899636f, -0.03501842f, 0.01827197f, -0.02680457f, -0.02686244f, -0.02190552f, 0.02140642f, -0.04052967f, 
    -0.02665289f, -0.03688609f, -0.03665441f, 0.01646841f, -0.03919064f, -0.04030318f, -0.02421143f, 0.02274151f, 
    -0.00059011f, -0.03823770f, -0.00396883f, 0.00693373f, 0.00282443f, -0.02069357f, -0.01766172f, -0.00483269f, 
    0.02053108f, 0.01510790f, -0.01427170f, -0.03936945f, 0.01725226f, 0.00536294f, -0.03247673f, -0.01058827f, 
    -0.00416538f, -0.02554904f, -0.02132583f, 0.02416918f, 0.02712268f, 0.00767193f, -0.02580026f, -0.03336813f, 
    0.00686384f, 0.02603785f, 0.01591537f, 0.00370355f, -0.01519353f, -0.01566194f, -0.02097680f, 0.01527547f, 
    0.01765043f, 0.02531730f, -0.00267418f, -0.02128543f, 0.02836276f, -0.02700690f, 0.00595969f, 0.00446242f, 
    0.01333088f, -0.01324604f, -0.01405409f, 0.00618343f, 0.02744938f, 0.02549220f, -0.01207247f, -0.02931171f, 
    -0.01318966f, 0.00834382f, -0.01687412f, -0.00898634f, 0.01108738f, 0.01751825f, -0.02506763f, -0.03545760f, 
    0.02375744f, 0.01745975f, 0.01186201f, -0.00373498f, 0.00682308f, -0.02031233f, -0.04168478f, -0.02301502f, 
    0.00178613f, 0.00051662f, -0.00822405f, -0.00488471f, -0.00720930f, -0.01552924f, 0.00717410f, 0.00349927f, 
    0.02608049f, -0.00288067f, 0.00324632f, 0.02299549f, 0.01928196f, -0.01392191f, 0.01596412f, -0.01131762f, 
    -0.02974002f, -0.02581296f, -0.01066331f, -0.00737370f, -0.02214544f, 0.02530851f, 0.02936411f, 0.01339672f, 
    0.01998262f, -0.01173922f, -0.00213208f, -0.01178812f, -0.02402110f, -0.01856570f, -0.01341849f, -0.03664684f, 
    0.01643608f, -0.03762170f, -0.00070782f, 0.01942110f, -0.01077218f, 0.01452533f, -0.00007530f, -0.01061551f, 
    -0.01487004f, -0.03349104f, -0.00956122f, 0.02594689f, -0.03382815f, 0.01187105f, 0.02536001f, -0.00453936f, 
    0.00914138f, -0.03543926f, -0.02269310f, 0.00368124f, -0.03169375f, -0.01738511f, 0.01948023f, 0.01463766f, 
    -0.02821825f, 0.02409099f, -0.02688779f, 0.02733865f, 0.00411719f, 0.00321966f, -0.03060875f, -0.02809217f, 
    0.02727106f, 0.00348463f, -0.02989075f, 0.00414039f, 0.01052473f, -0.00497987f, -0.00771629f, 0.01339838f, 
    0.01273110f, -0.02320626f, -0.01956425f, -0.02865745f, 0.02895460f, -0.01357381f, -0.00732508f, -0.03413420f, 
    0.03249927f, -0.03459473f, 0.00653516f, -0.03588977f, -0.00334615f, 0.00677565f, 0.00051120f, -0.02890053f, 
    0.00903435f, -0.03846504f, -0.01650192f, -0.02099338f, -0.03046419f, -0.01408893f, -0.00925148f, -0.02790133f, 
    -0.03155531f, 0.01600350f, 0.01243104f, -0.03844300f, -0.03351713f, -0.02215906f, -0.02535207f, -0.03331378f, 
    0.02613112f, -0.01983853f, -0.03254126f, 0.01336323f, 0.02325008f, -0.03700186f, -0.02872023f, 0.00704832f, 
    -0.03057821f, 0.00320345f, -0.00491623f, -0.03969524f, 0.00185933f, 0.01597840f, 0.00981564f, -0.02749477f, 
    -0.03029441f, 0.01932480f, -0.03953030f, -0.00075967f, -0.01694210f, -0.00654207f, -0.03220883f, 0.00958193f, 
    -0.01452000f, 0.01899411f, 0.00865279f, -0.02545643f, -0.00090141f, -0.01536233f, -0.01038551f, 0.01919990f, 
    -0.13257442f, 0.27012357f, 0.19797505f, 0.11248475f, 0.02000083f, -0.01621998f, -0.03190242f, 0.03196429f, 
    -0.11174572f, 0.01674455f, -0.10376833f, -0.10661779f, -0.03859518f, 0.05042112f, -0.08789854f, 0.02702329f, 
    0.05529177f, 0.06453018f, 0.04811364f, -0.11172478f, 0.11858079f, -0.01273399f, -0.08595186f, -0.02334530f, 
    0.12075669f, -0.08310661f, 0.14165628f, 0.04065644f, 0.14486186f, -0.01256687f, 0.14506389f, 0.00982430f, 
    0.05060421f, 0.04827480f, 0.00641067f, 0.04361558f, 0.13836135f, 0.07604184f, -0.06506493f, 0.06255703f, 
    0.13738604f, -0.01872175f, 0.14254092f, 0.09448832f, 0.00220862f, 0.00881101f, -0.00110563f, 0.08521304f, 
    -0.06896994f, -0.15527979f, -0.15142851f, -0.12388326f, -0.04969589f, 0.05738778f, 0.04504689f, -0.04847746f, 
    0.02071037f, 0.10617043f, -0.02754801f, 0.04647745f, -0.38844743f, -0.13643759f, 0.08837616f, 0.15444811f, 
    -0.00382796f, -0.03419170f, -0.12314741f, 0.03663025f, -0.06229317f, 0.10957605f, 0.11990891f, 0.20635858f, 
    0.18514629f, 0.09416665f, 0.02126931f, -0.05370947f, 0.07076164f, -0.09702592f, -0.11275040f, -0.06112252f, 
    -0.04118231f, -0.00936488f, -0.01294188f, 0.08007748f, -0.28531560f, -0.08981325f, 0.21397616f, 0.27709571f, 
    -0.01762303f, 0.03446406f, -0.11294627f, 0.04456772f, -0.05519995f, -0.00435134f, 0.07182632f, -0.08868535f, 
    0.21633221f, -0.02355169f, 0.05886421f, 0.04519606f, 0.06153274f, -0.05848815f, 0.08349872f, 0.05162512f, 
    -0.06083078f, 0.05346473f, -0.01269907f, -0.02240300f, 0.04432403f, -0.16120970f, 0.20321080f, -0.02881322f, 
    -0.02835221f, -0.09649476f, -0.22919491f, 0.02767809f, 0.00763804f, 0.00937814f, -0.08220506f, -0.05479877f, 
    -0.22950102f, 0.11161305f, -0.17338733f, -0.01118644f, -0.03806145f, 0.04867469f, -0.08275379f, 0.09017594f, 
    -0.01165856f, 0.05069114f, 0.01130844f, -0.07606591f, -0.06698795f, -0.15839353f, 0.00367400f, -0.07423225f, 
    -0.04205102f, -0.02626632f, -0.10122603f, -0.05549961f, 0.06597849f, -0.08246823f, 0.02342671f, -0.11115466f, 
    -0.14225215f, 0.06928830f, 0.03536199f, 0.16903606f, -0.04787282f, -0.01252052f, -0.10991985f, 0.01588440f, 
    0.00426599f, 0.02271752f, 0.02254075f, -0.01499272f, -0.00431922f, -0.06922918f, -0.05676813f, -0.04289936f, 
    0.00781684f, -0.04946256f, 0.00912386f, 0.00544031f, 0.00953662f, 0.06152929f, -0.04528306f, 0.17172495f, 
    -0.09720848f, 0.01010461f, -0.17748795f, 0.04165377f, -0.00683112f, 0.02956944f, 0.08331407f, -0.04257625f, 
    0.04527131f, 0.04909612f, 0.00096970f, 0.06068108f, -0.23520519f, 0.06606576f, -0.05868900f, 0.23636986f, 
    -0.03395696f, -0.03168720f, -0.06966246f, -0.02555005f, 0.03383416f, 0.02309231f, 0.04379852f, 0.02095033f, 
    0.00631569f, -0.04580635f, 0.29724842f, 0.03911148f, -0.11297411f, -0.14385757f, 0.04501999f, 0.09877901f, 
    -0.02234177f, -0.01471710f, 0.04590070f, -0.02186780f, -0.32063359f, -0.19729166f, -0.10710972f, -0.00336792f, 
    -0.05019785f, 0.00927467f, -0.00786741f, 0.02197566f, -0.04235099f, 0.06902538f, 0.03584526f, 0.08854633f, 
    -0.15375865f, -0.00265492f, -0.07595436f, 0.28610930f, -0.01630302f, 0.04559187f, -0.04349344f, -0.03793844f, 
    0.04697220f, -0.10312742f, 0.07166494f, -0.03596386f, -0.18178253f, -0.01441388f, -0.24833146f, -0.00384846f, 
    -0.04411696f, -0.02326963f, -0.01779575f, -0.02221994f, -0.03937393f, 0.05449799f, -0.01365781f, 0.22403222f, 
    0.15072271f, 0.10535521f, 0.10794149f, 0.19091925f, 0.01966311f, 0.02501111f, 0.16213170f, -0.04116860f, 
    0.10463501f, -0.01733797f, 0.02824001f, -0.09322272f, -0.16556852f, -0.07660854f, 0.13682829f, -0.07967535f, 
    -0.01756760f, -0.04097652f, -0.07020016f, 0.16019686f, 0.04438923f, 0.08413773f, 0.04129360f, -0.05695327f, 
    -0.08449916f, -0.09058591f, -0.05030726f, -0.09191121f, -0.10866658f, 0.07791284f, -0.00075805f, -0.02321089f, 
    -0.00313372f, 0.03485204f, 0.15122190f, 0.02589087f, -0.03029275f, 0.04375342f, -0.02688057f, 0.05808870f, 
    -0.02764758f, 0.09101338f, 0.03514778f, -0.01727658f, 0.14903748f, -0.00583006f, -0.00945619f, 0.08029313f, 
    -0.11256630f, -0.00770283f, 0.06134745f, 0.18520753f, 0.01108143f, -0.03447553f, 0.06185997f, -0.04369000f, 
    0.01349151f, 0.04267971f, -0.00830373f, -0.00948935f, -0.12286050f, 0.00742464f, -0.00589200f, 0.33779132f, 
    0.09431630f, 0.10088166f, -0.08160277f, -0.09713078f, 0.07556782f, -0.13020208f, 0.08058137f, -0.16989172f, 
    0.00214774f, 0.08190584f, -0.06861641f, 0.12323563f, 0.07761740f, 0.01036309f, 0.12434756f, 0.06460080f, 
    0.06810229f, -0.10607231f, -0.09049870f, 0.03778278f, 0.36417177f, -0.26341376f, 0.16924067f, -0.05563966f, 
    0.02284455f, -0.01742928f, 0.02075589f, -0.00052509f, 0.01722087f, -0.14515616f, 0.06269997f, 0.13856968f, 
    -0.13319650f, -0.00130935f, 0.05538966f, -0.03538726f, 0.02435360f, -0.00279333f, -0.10688329f, -0.00611983f, 
    -0.03859579f, 0.02327038f, -0.00140381f, -0.09501789f, 0.08235809f, 0.32074156f, 0.24639750f, 0.12476360f, 
    0.00938919f, 0.03849328f, -0.01194263f, -0.03575744f, -0.06588974f, -0.00600698f, -0.05777555f, 0.07204019f, 
    0.02387683f, 0.15303344f, 0.07614150f, 0.00870952f, -0.00673131f, -0.02723013f, 0.08605208f, 0.11394151f, 
    -0.00251931f, 0.07396548f, 0.02561856f, 0.03516715f, -0.03779508f, 0.15974185f, -0.07673167f, -0.01008454f, 
    -0.15312392f, 0.01680898f, -0.17063530f, 0.08237692f, 0.01290969f, -0.09393147f, -0.05542261f, 0.06832105f, 
    -0.11471070f, 0.03866391f, 0.06687207f, 0.06648199f, -0.00173708f, 0.06170343f, -0.00143044f, 0.12716201f, 
    0.02503378f, 0.01785507f, 0.08147812f, 0.05193628f, 0.29432169f, -0.04515155f, 0.27256152f, 0.11189743f, 
    -0.04683903f, 0.09435497f, -0.06500859f, 0.09456475f, 0.05032359f, -0.06687125f, 0.01290576f, -0.00938311f, 
    0.01195919f, 0.07823651f, 0.22643277f, 0.14695299f, 0.03584041f, -0.06851810f, 0.04092891f, -0.01990401f, 
    0.00042640f, 0.05905464f, -0.00573110f, 0.08142299f, -0.06554188f, -0.18032135f, -0.08983946f, -0.11054485f, 
    0.01440841f, -0.00916159f, 0.03503061f, -0.01400523f, 0.06818611f, 0.11749221f, -0.02766593f, 0.10770369f, 
    -0.06200382f, 0.10570681f, 0.09526986f, 0.50307876f, 0.02923277f, 0.16101857f, -0.14414683f, 0.03284850f, 
    0.04478989f, -0.02083653f, 0.02490376f, 0.04289398f, -0.06170729f, 0.06149562f, 0.06271396f, -0.00248094f, 
    -0.03534424f, 0.04252577f, -0.02452549f, -0.01858468f, -0.07096976f, -0.00912977f, 0.10809190f, -0.01203065f, 
    -0.30507672f, 0.29783687f, 0.19418219f, 0.07991482f, 0.01379534f, 0.04990678f, 0.12160135f, -0.02999775f, 
    -0.01512706f, -0.02172947f, -0.18490189f, -0.03184856f, 0.12978509f, 0.40680099f, 0.28713840f, 0.09508001f, 
    -0.08999693f, 0.01908902f, -0.08147535f, -0.14877822f, 0.02752712f, 0.01198675f, 0.01356746f, -0.03092476f, 
    -0.00915587f, 0.15852845f, 0.06493127f, -0.10079438f, 0.07220891f, 0.14331552f, -0.00149669f, -0.01505255f, 
    -0.07713809f, 0.08399221f, 0.02368842f, -0.07124317f, -0.06083121f, 0.14611213f, 0.03279436f, 0.21310578f, 
    -0.00800946f, -0.08485173f, 0.17837656f, 0.05795449f, -0.01504080f, 0.05827823f, -0.00103663f, -0.13741021f, 
    0.21683814f, 0.02927447f, -0.00174168f, 0.20266952f, 0.04602516f, 0.02327297f, 0.06222612f, 0.06140285f, 
    -0.04899750f, -0.11025989f, -0.02865381f, -0.10865197f, -0.30353230f, 0.17605765f, -0.15297861f, 0.14253801f, 
    -0.04828080f, 0.01152785f, 0.00531849f, 0.00023033f, -0.03889772f, 0.23135032f, -0.01534877f, 0.12274926f, 
    -0.12940995f, -0.02158168f, -0.01145178f, -0.04467029f, -0.02586061f, 0.03450297f, -0.02484949f, -0.08177487f, 
    0.00953088f, -0.00077912f, -0.08657847f, -0.09208080f, 0.02024013f, 0.04509136f, 0.11491529f, 0.27139452f, 
    -0.08091918f, 0.15742266f, 0.05445483f, 0.19307408f, 0.04629069f, 0.05252530f, -0.03278037f, -0.04110244f, 
    0.06009888f, -0.14668217f, -0.23557970f, -0.08602249f, -0.06182104f, 0.00374534f, 0.04227410f, -0.00922175f, 
    0.01250328f, -0.04944845f, 0.00737069f, 0.02108683f, -0.10385020f, 0.05979254f, 0.02810691f, -0.02467963f, 
    0.02246773f, 0.10533599f, -0.09796327f, -0.01752017f, 0.02905947f, 0.01459998f, 0.12722449f, -0.05422968f, 
    -0.28791294f, -0.02346467f, -0.35552758f, -0.07727334f, 0.01135626f, 0.02909217f, -0.05556260f, 0.00164994f, 
    -0.00110183f, -0.05051976f, -0.04381989f, 0.05478320f, 0.05783046f, 0.27825460f, 0.29870516f, 0.09663463f, 
    0.15006627f, -0.07375942f, -0.06915150f, -0.02242697f, 0.01040213f, -0.07751241f, 0.05296591f, 0.05012841f, 
    -0.20209074f, -0.12707290f, -0.06299476f, -0.03986075f, 0.01544853f, 0.06321783f, -0.04327717f, -0.04905864f, 
    -0.04283805f, -0.08774932f, 0.04066297f, 0.06641756f, 0.11252212f, -0.09448160f, 0.11812039f, 0.09457086f, 
    -0.01052324f, -0.08131804f, -0.14672092f, -0.14802536f, 0.00992393f, -0.02179155f, 0.09393703f, -0.12544855f, 
    0.10340813f, -0.08689465f, 0.17272075f, 0.02072349f, 0.00239436f, -0.02248953f, 0.00626461f, -0.09433419f, 
    -0.00008277f, -0.09740319f, -0.05498120f, 0.00865049f, -0.14184149f, -0.02543432f, 0.16808130f, -0.01277841f, 
    0.06096425f, -0.04323770f, -0.05923308f, 0.06418859f, -0.01021327f, -0.02493349f, 0.10014743f, -0.02181747f, 
    -0.17956951f, -0.02113954f, 0.42464676f, 0.07088542f, 0.01442375f, 0.01436190f, -0.00643370f, 0.09502652f, 
    0.02146656f, 0.11034401f, 0.03229908f, 0.12197372f, -0.07640107f, 0.23394062f, 0.20457035f, 0.18832068f, 
    -0.03337854f, 0.03866602f, -0.10082775f, 0.07416181f, -0.01010333f, 0.03974292f, -0.02865140f, -0.05092118f, 
    -0.06923436f, 0.04724472f, 0.22095507f, -0.06590158f, 0.01904769f, 0.03449919f, 0.20093019f, 0.05946737f, 
    0.02148911f, 0.03111446f, -0.10323232f, -0.02185509f, -0.19608155f, -0.07225611f, -0.22488643f, -0.09333669f, 
    -0.04520156f, -0.01003342f, 0.01687940f, -0.08080702f, -0.03055780f, -0.09486172f, -0.05768906f, -0.01472267f, 
    0.16401322f, -0.00493392f, 0.10566308f, 0.22760835f, -0.05952139f, 0.03755549f, 0.10518195f, 0.10732163f, 
    0.02524764f, -0.03193379f, 0.15972495f, -0.08040603f, -0.03314776f, -0.02241654f, 0.11153296f, 0.15650530f, 
    0.06608109f, 0.02619829f, 0.08912028f, 0.01916277f, 0.04336596f, 0.01820371f, -0.08360256f, -0.06327038f, 
    -0.35502908f, 0.10224079f, -0.02937177f, 0.11267992f, -0.04274125f, -0.04508829f, -0.08834143f, 0.03286808f, 
    -0.08028463f, -0.03835709f, 0.11725106f, -0.08622513f, 0.39196074f, -0.00528988f, 0.02423758f, 0.05059680f, 
    0.04239392f, -0.11415276f, 0.10524500f, -0.12780316f, -0.15174021f, -0.06789294f, -0.03874607f, 0.02066627f, 
    0.29724270f, 0.15311801f, 0.05673778f, 0.11888123f, 0.10728233f, -0.07922107f, -0.04908022f, 0.03948584f, 
    -0.08452339f, -0.01030698f, -0.08451342f, 0.05612219f, -0.13681082f, 0.20705689f, -0.15841135f, 0.00125189f, 
    -0.04127515f, 0.03981367f, -0.11287504f, 0.07865842f, -0.00091052f, 0.03115886f, 0.00648896f, 0.09179732f, 
    -0.02657804f, 0.01483910f, -0.02621354f, -0.04189299f, 0.00358764f, 0.03607333f, -0.01070317f, 0.01100582f, 
    0.01573060f, -0.00801105f, -0.02379198f, -0.03417639f, 0.00864921f, -0.02601398f, -0.03389462f, 0.02238482f, 
    -0.01334754f, 0.00691202f, 0.00751038f, 0.03033536f, 0.00925175f, -0.01694053f, 0.01931013f, 0.01759221f, 
    -0.02222289f, -0.02144388f, -0.00864341f, -0.00756388f, -0.03953076f, 0.02373848f, -0.01007468f, -0.04370746f, 
    0.00646533f, 0.01517289f, -0.03743235f, -0.01536637f, -0.03888324f, 0.00505514f, -0.01910696f, -0.02059054f, 
    0.00566163f, -0.02073297f, -0.01402421f, -0.02060460f, -0.03749659f, -0.00207554f, -0.03683341f, -0.03592834f, 
    -0.00680938f, -0.00549378f, 0.00331447f, 0.00453366f, 0.01125836f, 0.01062424f, 0.02558918f, 0.01449251f, 
    -0.02685832f, -0.01752373f, -0.04316524f, -0.01068760f, -0.01359564f, 0.02680600f, -0.03182643f, 0.02151435f, 
    -0.01129639f, 0.00471311f, -0.00310947f, -0.02750795f, 0.00891685f, 0.00087438f, -0.03370466f, -0.02445858f, 
    -0.00149889f, -0.02054739f, 0.03010596f, -0.00346967f, -0.04044682f, -0.02628040f, -0.02922148f, -0.00843524f, 
    -0.01357587f, 0.00710714f, -0.03384783f, -0.03484918f, -0.01202942f, -0.01325546f, 0.02889488f, -0.02113253f, 
    -0.01833594f, 0.01622918f, 0.02327263f, -0.02890278f, -0.01701375f, 0.02396395f, 0.01971855f, -0.03810177f, 
    0.00041460f, -0.02420136f, 0.02351106f, 0.01814039f, 0.00556126f, 0.00970930f, -0.04023447f, 0.02334411f, 
    0.00926362f, 0.01957657f, -0.02723488f, -0.00309509f, 0.01047994f, -0.02665282f, -0.02134502f, -0.03307638f, 
    -0.00548989f, 0.01137871f, -0.00524840f, -0.00243462f, -0.03821172f, 0.02929429f, -0.03847129f, 0.01314233f, 
    0.00373077f, 0.01262687f, -0.02203959f, -0.00861052f, -0.04171194f, -0.04231309f, -0.00630436f, -0.02927691f, 
    0.02737404f, 0.02393714f, 0.01131817f, 0.01057003f, 0.00164097f, -0.02349673f, -0.02660120f, 0.01578731f, 
    0.02493773f, -0.01715345f, 0.00829847f, -0.04198505f, -0.00674465f, 0.00216406f, 0.00979916f, 0.01902933f, 
    -0.02897630f, 0.01527818f, -0.03429784f, -0.01887937f, 0.01720168f, -0.00668640f, 0.02044223f, 0.01555451f, 
    -0.00145337f, -0.00507983f, -0.04321185f, -0.03764878f, 0.01344786f, -0.02740667f, -0.00668243f, -0.01104030f, 
    -0.02929794f, 0.00553699f, -0.00165419f, -0.03886819f, -0.00512297f, -0.01628238f, -0.03077932f, -0.03852590f, 
    -0.01900345f, -0.03042818f, -0.03248438f, -0.00236796f, -0.02325496f, 0.01315987f, 0.01995651f, -0.00101905f, 
    0.00368459f, -0.03765510f, 0.02373080f, -0.04006214f, -0.03882499f, -0.01221909f, -0.01092574f, 0.00232513f, 
    -0.00508678f, -0.03384874f, 0.03900982f, 0.02825076f, -0.02261131f, -0.00555920f, 0.01988524f, 0.00842272f, 
    0.00924599f, -0.03619128f, -0.02442640f, -0.00651218f, -0.03183499f, -0.01105591f, -0.03285866f, -0.02392486f, 
    -0.03063611f, -0.01055237f, 0.02875497f, -0.01042215f, -0.00778042f, -0.01407121f, -0.00859530f, -0.00466042f, 
    -0.04293581f, 0.02222858f, 0.01304453f, -0.02859418f, -0.01662564f, 0.02480615f, 0.03254649f, 0.00270533f, 
    0.02468694f, 0.01910235f, -0.02027004f, -0.01680316f, -0.00418021f, -0.02896164f, 0.00544708f, 0.00868845f, 
    0.00435818f, -0.01673491f, -0.00535407f, -0.00177624f, -0.03209630f, 0.02353926f, -0.00138396f, 0.02229538f, 
    0.03584642f, -0.01930096f, -0.01070560f, 0.01834266f, -0.02872689f, -0.02839840f, -0.00248801f, 0.00772290f, 
    -0.02346122f, 0.01769551f, -0.03269269f, -0.02024670f, 0.01443078f, 0.02837210f, 0.02599375f, 0.02740581f, 
    0.02986557f, 0.02478095f, 0.00656130f, 0.01751100f, -0.03739888f, 0.01251944f, -0.01928487f, -0.03095951f, 
    0.02413629f, -0.00091215f, -0.01378278f, -0.04028206f, -0.03510065f, -0.02861216f, 0.01242566f, 0.01452468f, 
    -0.02912467f, 0.01919802f, 0.02130612f, -0.00749657f, 0.00680505f, 0.02025599f, 0.01138863f, -0.00429985f, 
    0.00220030f, 0.00895161f, 0.00427969f, 0.02544779f, 0.00636452f, 0.00258760f, 0.02571970f, 0.01911953f, 
    0.02570284f, -0.00869622f, -0.01703153f, 0.00885861f, -0.01420162f, 0.01725083f, -0.02883793f, -0.00832929f, 
    0.02839578f, 0.00500095f, -0.04113262f, 0.01694121f, 0.00478685f, -0.02570736f, -0.01121318f, -0.00230343f, 
    0.02458928f, 0.02560734f, 0.01230504f, -0.03070633f, -0.02171768f, -0.03824566f, 0.00709228f, -0.00683066f, 
    0.01726530f, -0.02218764f, -0.01950312f, -0.01447797f, -0.00858835f, -0.00252126f, 0.03067293f, -0.01263026f, 
    -0.00098101f, 0.00811955f, 0.01837672f, -0.02493587f, 0.00280609f, -0.02108830f, 0.01935090f, -0.02667009f, 
    0.02336387f, -0.03349645f, -0.01778130f, 0.00097308f, -0.00605893f, -0.00507216f, -0.01756462f, -0.03328890f, 
    -0.03485111f, 0.01153889f, -0.02955090f, -0.02782981f, -0.03056059f, 0.02075583f, -0.01102041f, 0.02336933f, 
    -0.00734669f, -0.03978392f, 0.00126047f, -0.01331317f, -0.02691576f, -0.01318932f, 0.01571047f, 0.03932180f, 
    -0.00997129f, 0.01777256f, 0.01440451f, 0.02644563f, -0.00875800f, -0.01202499f, -0.02775482f, 0.02159970f, 
    0.02012440f, 0.01919374f, -0.02813508f, 0.00873929f, -0.04191996f, -0.02926766f, -0.02756345f, -0.01640667f, 
    -0.01072309f, 0.01642235f, 0.00905735f, -0.03560529f, -0.02638625f, 0.02385451f, 0.02450752f, 0.02304300f, 
    -0.03916960f, 0.00271625f, 0.01574069f, 0.00098389f, -0.03254377f, -0.01170554f, -0.02823701f, -0.01105941f, 
    -0.02148638f, -0.01526647f, 0.00658982f, 0.00778246f, 0.02541720f, -0.02524107f, 0.00528903f, -0.00877779f, 
    -0.01408646f, -0.04137658f, -0.01056089f, -0.01107607f, 0.02024556f, -0.03421237f, -0.02040006f, 0.00529253f, 
    -0.00246401f, -0.01964459f, -0.03669851f, 0.00044300f, -0.02639787f, 0.02162441f, -0.02420459f, 0.01325418f, 
    0.00233864f, 0.01845458f, 0.01198595f, 0.01256325f, -0.01390521f, -0.01029512f, -0.03365121f, -0.04014943f, 
    0.00965580f, -0.01262237f, 0.02425245f, 0.02278500f, -0.03743912f, -0.03829336f, -0.02705733f, -0.02319145f, 
    -0.03594704f, -0.00401146f, -0.03957056f, 0.00318009f, 0.00006568f, -0.00455091f, -0.00912430f, -0.02902720f, 
    -0.01172285f, 0.01957437f, -0.00985408f, -0.03400722f, 0.00085664f, 0.00773690f, -0.03505860f, -0.04246979f, 
    0.02742502f, 0.00373942f, -0.01801626f, -0.02632103f, 0.01105055f, -0.02612788f, -0.03686698f, 0.00690862f, 
    -0.03110974f, 0.02388719f, 0.01931310f, 0.01417284f, -0.00617392f, -0.03490297f, -0.03351311f, -0.01903406f, 
    0.01366165f, -0.02868347f, -0.00512868f, -0.03347922f, 0.00627035f, 0.03880665f, -0.03722169f, 0.00482066f, 
    -0.02514355f, -0.03350514f, 0.03489493f, 0.01552789f, -0.02600558f, 0.00023299f, 0.01519146f, 0.01673845f, 
    0.04338181f, 0.02720311f, 0.01602865f, -0.03043032f, 0.02011819f, -0.02581074f, 0.00367253f, 0.01057757f, 
    -0.01468693f, 0.01258788f, 0.03572316f, 0.01221086f, -0.02067698f, 0.03084266f, -0.00806234f, 0.01421061f, 
    -0.01499208f, 0.01214614f, 0.01010310f, -0.00710881f, -0.00626556f, 0.02117779f, 0.00764703f, 0.02717874f, 
    -0.03879716f, 0.02378630f, 0.01233061f, -0.00572083f, -0.01419057f, -0.02294267f, 0.01600964f, -0.02379896f, 
    0.01028823f, 0.01065693f, 0.00657959f, -0.00498934f, 0.02460406f, -0.03969326f, -0.01403135f, -0.03889324f, 
    -0.04114341f, 0.00629458f, -0.00802390f, -0.01346636f, 0.02264496f, -0.03224391f, 0.00216401f, -0.03537708f, 
    0.02742732f, 0.01763381f, 0.02798516f, 0.02420626f, 0.01330769f, 0.00911848f, 0.01669821f, -0.02416359f, 
    -0.02012223f, 0.00541826f, -0.03034088f, -0.00204457f, -0.03135417f, 0.02088011f, -0.00460202f, -0.03818013f, 
    0.01036741f, 0.01227458f, 0.02603907f, -0.01820622f, -0.03094761f, 0.00203061f, 0.01865208f, -0.00455338f, 
    -0.00165367f, 0.02610634f, 0.02665583f, 0.00675006f, -0.02396920f, 0.02265568f, -0.02362623f, -0.03613890f, 
    -0.00975897f, -0.02145738f, -0.03845841f, 0.00365267f, -0.03057159f, 0.00563135f, -0.03187467f, 0.02612082f, 
    0.02343147f, 0.02607339f, 0.01167409f, 0.00551794f, 0.03076499f, -0.01002373f, 0.00621304f, -0.02375465f, 
    -0.01245719f, -0.03375226f, -0.00534086f, -0.02977694f, 0.01944456f, -0.02581171f, -0.00036118f, 0.01072800f, 
    -0.00308004f, -0.03000742f, -0.00466250f, -0.02900747f, -0.02760524f, 0.00559133f, 0.01382902f, 0.03469961f, 
    -0.01544605f, 0.00859482f, 0.02545188f, -0.00551128f, -0.02034207f, 0.01556325f, -0.00915975f, -0.04304019f, 
    0.03012051f, 0.01280930f, -0.01502712f, -0.01514798f, 0.01085056f, -0.00682742f, -0.01686998f, -0.01254823f, 
    0.00860378f, 0.00473013f, 0.01161675f, 0.01422664f, -0.03759269f, -0.03809348f, 0.01832382f, 0.02255642f, 
    -0.01477403f, -0.04022324f, -0.02649111f, 0.00455137f, -0.00326441f, -0.00931277f, 0.03251392f, -0.01991195f, 
    0.01017732f, -0.00820556f, 0.01523049f, 0.00424884f, -0.03568602f, -0.03950090f, -0.02999814f, -0.03563707f, 
    0.02117789f, 0.02477479f, -0.03125490f, -0.04377978f, -0.01451712f, -0.03505398f, 0.00495023f, 0.01094063f, 
    -0.02738308f, -0.03183146f, 0.01690488f, 0.00358785f, -0.00624613f, -0.01793733f, 0.02456352f, 0.02801748f, 
    -0.03035592f, 0.02086403f, -0.04155196f, 0.02165989f, -0.00907861f, -0.01653307f, 0.01488899f, 0.01966158f, 
    0.02607576f, -0.00962099f, -0.03297944f, 0.01880564f, 0.01162584f, 0.00141260f, -0.00975236f, 0.00705355f, 
    -0.02320206f, 0.01083793f, 0.01711735f, 0.01070829f, 0.01649879f, -0.03845380f, -0.02181257f, 0.01596317f, 
    -0.01145813f, 0.00598678f, 0.00776125f, -0.02884010f, -0.03531367f, 0.00504657f, -0.00201887f, 0.00074052f, 
    0.01106601f, 0.01543073f, -0.00655813f, -0.03043515f, 0.00405968f, 0.00318568f, -0.00501573f, -0.02378948f, 
    0.01588873f, 0.01251063f, -0.03202797f, 0.01298750f, 0.00626258f, -0.02919249f, -0.02529261f, -0.02179961f, 
    -0.02950333f, 0.00737741f, 0.01944862f, 0.02183710f, -0.03761885f, -0.03352104f, -0.03118165f, 0.00921639f, 
    -0.01039993f, 0.00323720f, -0.02477577f, -0.02691017f, -0.00880803f, -0.02541011f, 0.01426605f, -0.03020127f, 
    -0.00092434f, -0.00358311f, -0.03563683f, -0.04101498f, -0.02910423f, 0.04071853f, -0.00969544f, -0.02304263f, 
    0.00084658f, 0.03260848f, 0.02006895f, -0.01928506f, 0.00955591f, -0.01464566f, 0.01226146f, -0.00077893f, 
    -0.03629417f, -0.01691630f, -0.00210508f, 0.03249401f, 0.02679006f, 0.01188075f, -0.01803843f, 0.01829033f, 
    0.01300362f, -0.00073258f, 0.01429777f, -0.01724451f, -0.02475996f, 0.01900817f, 0.00327263f, 0.01931293f, 
    -0.03149053f, -0.02462005f, 0.01727062f, -0.01870459f, -0.03037525f, -0.01689686f, 0.01237458f, -0.01748168f, 
    -0.03284300f, -0.02082811f, 0.00814041f, 0.02554539f, -0.03273955f, 0.00952087f, 0.01629888f, -0.00544318f, 
    -0.02995710f, 0.00296782f, -0.04122050f, -0.03036741f, 0.01058891f, -0.02755549f, -0.02920823f, -0.00419166f, 
    0.02626296f, -0.01741339f, 0.00575711f, -0.02859458f, -0.03579948f, -0.02987124f, 0.02091206f, 0.01674967f, 
    -0.03097543f, -0.01675495f, 0.00327464f, 0.02690935f, -0.01133926f, -0.03070594f, 0.01423105f, -0.01557887f, 
    0.05673288f, 0.07231048f, 0.10694332f, -0.05910003f, -0.08162012f, -0.04109855f, -0.10465320f, 0.04746244f, 
    0.01437465f, -0.07270386f, -0.05208116f, -0.14084265f, -0.05992141f, 0.03928255f, 0.02591541f, -0.13704816f, 
    -0.08340867f, -0.00066445f, -0.03497248f, 0.11912621f, -0.03993766f, -0.06252720f, 0.07664004f, -0.01108064f, 
    -0.42759177f, 0.12374180f, -0.14814244f, 0.00395110f, -0.06417693f, -0.12418053f, 0.00312400f, -0.09259602f, 
    -0.01922105f, -0.00843902f, -0.09067480f, 0.10986187f, -0.37357795f, -0.06130772f, -0.03882936f, -0.02044713f, 
    -0.06000662f, -0.14246403f, -0.08240831f, -0.00452901f, -0.00371535f, -0.07710120f, -0.00526353f, 0.00400311f, 
    0.04914411f, 0.04752740f, 0.02936785f, 0.05226138f, -0.06551882f, -0.06127368f, -0.09036873f, -0.02482505f, 
    0.01154804f, -0.11322463f, -0.07003972f, -0.02962088f, -0.03408000f, 0.19437483f, -0.11744307f, -0.00727835f, 
    0.00121336f, -0.03675544f, -0.01744832f, 0.09215868f, -0.01709056f, 0.02140187f, 0.13911143f, 0.00312251f, 
    -0.17794031f, -0.07210438f, -0.32082587f, -0.12324379f, -0.01611742f, -0.11367530f, 0.03152497f, -0.11114572f, 
    -0.03767117f, -0.15281859f, -0.04367690f, -0.07310225f, 0.20554803f, 0.13571163f, 0.13237926f, -0.31983700f, 
    0.00844199f, 0.05092254f, 0.06495165f, 0.11586384f, 0.11569466f, 0.00026345f, -0.01514990f, -0.07284975f, 
    0.00580718f, 0.05132671f, -0.06173977f, -0.25056240f, 0.11014523f, -0.12460592f, 0.05113297f, 0.07368261f, 
    -0.02231410f, -0.03608605f, 0.10878690f, -0.09919229f, -0.02175155f, 0.05240543f, 0.10115217f, 0.00777991f, 
    0.10817488f, -0.03030806f, -0.00391172f, 0.14407316f, 0.05353422f, 0.03256081f, -0.08242147f, -0.01014467f, 
    0.33829430f, -0.00283595f, -0.00921417f, -0.02664844f, 0.01272855f, -0.01216894f, -0.10201093f, 0.14764377f, 
    -0.05298956f, -0.00579043f, 0.06856381f, -0.20329480f, 0.22552855f, -0.05306811f, 0.04574641f, 0.01219272f, 
    0.04697751f, 0.01500077f, 0.06016683f, -0.00625124f, 0.00882934f, -0.02421159f, 0.02619067f, -0.08507051f, 
    0.08565165f, 0.07564151f, 0.17061807f, -0.05226311f, -0.07092110f, 0.02802750f, 0.02763504f, 0.03340309f, 
    0.06446534f, -0.05371606f, 0.04471558f, 0.07185083f, -0.03970815f, 0.07701023f, 0.08713263f, 0.02698409f, 
    0.03835912f, -0.00567491f, -0.01831421f, 0.02786155f, 0.07818957f, 0.00973769f, 0.07213771f, 0.10776062f, 
    0.15159686f, 0.02846065f, -0.07876548f, 0.18434407f, 0.02640574f, -0.11167579f, -0.06017744f, -0.01422405f, 
    -0.04594845f, -0.05802083f, 0.10914663f, 0.03280045f, -0.03500680f, 0.12879612f, 0.14683625f, 0.11514313f, 
    0.02504596f, 0.01908198f, -0.17599879f, -0.10378648f, 0.01982082f, -0.02402328f, 0.04147617f, 0.04002651f, 
    0.12009876f, -0.10340602f, -0.31426695f, 0.17342778f, 0.06534375f, 0.16865771f, 0.02347461f, 0.00491101f, 
    -0.03056502f, -0.03967239f, 0.00187060f, 0.00368532f, 0.04568074f, 0.09744314f, 0.03773966f, 0.18228272f, 
    -0.02003457f, -0.00684316f, 0.02173677f, 0.06369998f, 0.13937224f, -0.08922401f, 0.06472272f, 0.03599610f, 
    0.52853531f, 0.09243267f, 0.20589504f, -0.21785487f, -0.00618742f, 0.02155152f, 0.08154918f, 0.11700312f, 
    0.10884304f, -0.04944042f, 0.02669893f, 0.01286507f, 0.07242632f, -0.01460661f, 0.03725269f, 0.02608102f, 
    0.01239342f, 0.02683652f, -0.05416535f, 0.07788990f, 0.02486516f, 0.00729488f, 0.06491907f, -0.01526544f, 
    -0.06755298f, 0.12310098f, 0.20209539f, 0.06847386f, -0.09048953f, -0.02998007f, -0.10321498f, -0.03740781f, 
    0.06519531f, 0.00994413f, 0.04611180f, -0.02069044f, 0.12356005f, -0.00469011f, -0.02715299f, -0.00572990f, 
    0.01426302f, 0.01110458f, -0.05689331f, -0.04153184f, 0.04659625f, -0.01893135f, -0.04310957f, 0.00474165f, 
    0.02489375f, 0.10048418f, 0.02587321f, 0.08148353f, 0.00626737f, -0.04453991f, 0.02003774f, 0.01032149f, 
    0.00642165f, 0.04078411f, -0.00111634f, -0.00765886f, -0.01708360f, -0.29617298f, 0.22401997f, 0.21953940f, 
    -0.06582981f, -0.11723138f, -0.10074259f, 0.09362577f, 0.10653133f, -0.01706281f, -0.08391669f, 0.18737711f, 
    -0.05730056f, 0.09098587f, 0.19465217f, 0.03660789f, -0.00400950f, 0.10095490f, -0.03935107f, -0.01555032f, 
    0.11807084f, 0.11076432f, 0.03798544f, 0.00919409f, 0.30891979f, 0.05454284f, 0.02683954f, 0.05441868f, 
    -0.05638636f, 0.04296992f, 0.03032027f, 0.08824244f, 0.18947914f, -0.06238085f, 0.09796124f, 0.07329568f, 
    -0.47122002f, -0.01821612f, -0.00674677f, -0.04672168f, -0.15244061f, -0.14770883f, -0.06494779f, 0.01526487f, 
    0.03332677f, -0.05228597f, 0.04560846f, 0.05333789f, -0.23909034f, -0.10344987f, 0.01759390f, 0.05101078f, 
    0.04184430f, 0.00293677f, 0.03265872f, -0.00924290f, 0.16716617f, -0.05883294f, 0.04017050f, 0.00908898f, 
    0.20874918f, 0.09552553f, -0.14781711f, -0.03302140f, 0.18906944f, 0.22532138f, -0.01733383f, 0.05158344f, 
    -0.02879193f, -0.08144754f, 0.04165800f, 0.00737734f, -0.10461769f, 0.15279970f, 0.19124772f, 0.00590594f, 
    -0.04096444f, 0.01032451f, 0.13570319f, 0.23356371f, -0.03569699f, -0.00206248f, 0.01342658f, 0.10147878f, 
    -0.17380802f, -0.09816041f, 0.01982464f, -0.00900017f, 0.07352392f, -0.00021180f, 0.07839178f, 0.00399763f, 
    -0.10543054f, -0.03540494f, -0.02101879f, -0.10954731f, -0.21653070f, -0.34485087f, 0.37404805f, 0.15372868f, 
    -0.05584156f, 0.09677199f, -0.01186414f, 0.05912440f, 0.22101742f, 0.10562713f, -0.01983874f, 0.02010758f, 
    0.12498777f, -0.00948019f, 0.08842047f, -0.06517903f, 0.05917006f, -0.03759259f, 0.07152338f, -0.05555858f, 
    -0.01182352f, -0.03627817f, -0.01435529f, -0.03821959f, 0.03324061f, -0.08708671f, 0.28875089f, -0.10327633f, 
    0.08793885f, 0.00299633f, 0.05263659f, 0.17684898f, 0.13601756f, 0.02543899f, -0.00722837f, 0.06127824f, 
    -0.13380370f, 0.21533374f, 0.18888818f, 0.19319534f, -0.05385721f, -0.10183103f, -0.08738020f, 0.01260151f, 
    -0.20165913f, -0.08504560f, -0.00032125f, 0.00075846f, 0.08829661f, 0.01116099f, -0.04916776f, 0.02893844f, 
    -0.01545970f, -0.00358042f, -0.04460392f, -0.06756501f, 0.09305198f, 0.07248875f, -0.01685596f, -0.03862441f, 
    0.08947316f, 0.16297500f, 0.23246410f, -0.01514745f, 0.11533543f, -0.04069273f, -0.16061187f, 0.10651051f, 
    0.04092191f, -0.06590182f, 0.03931605f, -0.00185011f, 0.12377197f, -0.03965432f, 0.16405435f, -0.01442251f, 
    0.15521608f, 0.08451725f, -0.02880930f, 0.06471322f, 0.08403939f, 0.01325098f, 0.13052693f, 0.10122760f, 
    -0.15071493f, 0.15958534f, 0.02235480f, 0.01231929f, -0.07159090f, -0.00509562f, 0.02177265f, 0.27371949f, 
    0.00362343f, 0.02087030f, -0.04610035f, -0.07153735f, -0.03851231f, 0.00774192f, 0.19346090f, -0.01141423f, 
    -0.00047448f, 0.01455391f, -0.01818875f, -0.00005359f, 0.04107578f, -0.05314994f, 0.05151604f, -0.01985561f, 
    -0.01975431f, -0.09085897f, -0.09919250f, 0.03402384f, -0.03185606f, 0.02435928f, 0.03202838f, 0.06902353f, 
    0.06546418f, 0.06110911f, -0.06134328f, 0.00617916f, 0.05833709f, 0.17134552f, 0.15569483f, -0.04053421f, 
    0.11083006f, 0.04450539f, -0.05630517f, 0.07405631f, 0.03940636f, 0.08302399f, -0.06617668f, 0.00731260f, 
    -0.06462919f, -0.05340601f, 0.08818518f, -0.15692408f, -0.11852717f, -0.03675244f, -0.05026887f, -0.07406630f, 
    -0.07224364f, 0.02505629f, 0.02398604f, -0.04134599f, 0.11204040f, 0.09832289f, -0.09318905f, 0.02443368f, 
    -0.00179296f, 0.02062009f, 0.00934871f, 0.08621633f, 0.01057566f, 0.00523256f, 0.03942457f, 0.00825426f, 
    0.08741775f, 0.00918598f, -0.06101467f, -0.04688039f, 0.03553594f, 0.00758642f, 0.00760149f, 0.02757206f, 
    -0.08836961f, -0.01568532f, -0.15341280f, -0.03491137f, 0.00180494f, 0.08143900f, 0.25105292f, 0.09852934f, 
    -0.02473105f, 0.01412879f, -0.03947260f, -0.00907293f, -0.02796808f, 0.00240341f, 0.06128011f, 0.11062704f, 
    0.13143924f, -0.02878931f, 0.04487347f, -0.02000453f, -0.02491608f, -0.01272553f, 0.04686822f, -0.00207332f, 
    -0.01089048f, 0.04291428f, 0.02664645f, 0.07076976f, 0.13880762f, -0.01428534f, 0.00348157f, -0.07126175f, 
    0.05089691f, 0.09796183f, -0.06548754f, 0.04877060f, 0.03106717f, 0.03203608f, -0.00353552f, 0.05762536f, 
    0.17296346f, -0.02741097f, -0.06145379f, 0.33497980f, -0.04873894f, -0.06750005f, -0.07278031f, 0.02642156f, 
    0.06571765f, -0.14944161f, 0.03638298f, 0.03113383f, 0.10894400f, 0.00398247f, 0.26997641f, -0.05370607f, 
    0.01537783f, 0.03100342f, -0.06640806f, -0.06357086f, -0.05017978f, -0.02380725f, 0.05155932f, 0.01097571f, 
    0.16324791f, 0.06713920f, 0.05194814f, 0.03004352f, 0.02911002f, 0.03839012f, 0.00947863f, -0.02024652f, 
    0.06147167f, -0.05129962f, -0.12238893f, 0.04509728f, 0.20361139f, 0.12899970f, -0.04899200f, -0.06840664f, 
    0.16408522f, 0.08937781f, 0.16230141f, -0.03084457f, -0.16771205f, -0.16007535f, -0.09752960f, -0.14632289f, 
    -0.12265746f, -0.05456901f, 0.17911707f, -0.02743909f, 0.07962011f, 0.14101364f, 0.06569766f, 0.02322458f, 
    -0.00832090f, 0.04954393f, 0.00661745f, -0.04062214f, 0.38090950f, 0.10576051f, -0.15963396f, -0.16555619f, 
    0.03354498f, 0.14609627f, 0.04988066f, 0.00839674f, 0.08997539f, -0.01108912f, 0.07931019f, 0.03982166f, 
    -0.06039693f, -0.15991159f, 0.21469280f, -0.12327835f, -0.09582896f, 0.04281403f, 0.04540009f, 0.18544880f, 
    -0.11492167f, -0.02743216f, 0.02865450f, 0.03460333f, -0.03700894f, 0.06916181f, 0.09293040f, 0.03856442f, 
    0.04498539f, -0.00643740f, 0.07523803f, 0.15484986f, -0.00928574f, -0.00538583f, 0.05733927f, 0.02771190f, 
    -0.54310560f, 0.29818514f, 0.02220124f, -0.13896228f, -0.11972734f, -0.14158402f, -0.06000977f, 0.07731406f, 
    -0.03720940f, -0.06855272f, -0.02388035f, -0.03553456f, -0.01836091f, -0.19367553f, 0.13550310f, 0.15716468f, 
    -0.02198012f, -0.00808495f, -0.09449364f, 0.01621653f, 0.00724068f, 0.02792600f, -0.11953113f, 0.01127572f, 
    -0.06409433f, 0.05911340f, 0.18307905f, -0.04124376f, -0.05771469f, 0.19784503f, -0.06628790f, -0.00909783f, 
    -0.01473953f, -0.00295038f, 0.04318175f, 0.18446377f, -0.23929906f, 0.16906925f, -0.03359926f, -0.22484617f, 
    -0.05768194f, -0.13022904f, -0.16979107f, 0.02880610f, 0.03037499f, 0.07751094f, -0.08545815f, -0.06147739f, 
    -0.00944460f, 0.09778449f, -0.07334717f, 0.21702784f, 0.11822800f, 0.06155950f, 0.08022662f, 0.03189244f, 
    0.04613156f, 0.12835030f, 0.03733572f, 0.06406230f, -0.41373533f, 0.01933204f, -0.18455756f, -0.00892736f, 
    0.26036382f, -0.06442899f, 0.12805974f, 0.05694168f, 0.18587220f, 0.07024886f, -0.03172426f, -0.07535545f, 
    -0.25002250f, 0.13031147f, 0.00027599f, -0.05328337f, -0.03124011f, -0.12132692f, 0.02356834f, 0.11319178f, 
    0.05800718f, -0.17514719f, 0.00092063f, -0.09487288f, -0.21754235f, -0.30513364f, 0.29870877f, 0.00629785f, 
    0.02523944f, 0.02380610f, -0.03462370f, 0.11697747f, 0.13149324f, 0.05471831f, 0.06116135f, 0.07376715f, 
    0.21670574f, -0.02664253f, -0.15589786f, -0.01241179f, 0.17820385f, 0.09257117f, 0.06215845f, 0.01304621f, 
    0.06018183f, -0.07953686f, 0.10284425f, 0.09079834f, 0.04642766f, 0.17505401f, -0.34988949f, 0.16112037f, 
    0.09594756f, -0.04341992f, 0.08049128f, -0.14579602f, 0.17049737f, -0.07535487f, -0.01415416f, -0.00683661f, 
    -0.21342553f, -0.28576139f, -0.17067513f, -0.24477030f, 0.11408393f, 0.00721810f, 0.03704669f, 0.02339217f, 
    0.04646253f, 0.02051960f, -0.04521446f, -0.01070032f, -0.28860176f, -0.21473199f, -0.16476224f, -0.24529657f, 
    0.16875170f, 0.12297752f, -0.00410832f, 0.04465702f, 0.10194344f, 0.00891073f, 0.02272901f, 0.02860004f, 
    0.07875516f, -0.25860947f, -0.07873878f, 0.11072972f, 0.03928562f, 0.05478256f, -0.16207027f, 0.05261635f, 
    0.02246039f, -0.00330289f, 0.07748505f, 0.11563887f, -0.03897737f, -0.05194981f, 0.22696392f, 0.15923080f, 
    0.03000974f, 0.09860875f, 0.07514173f, 0.00887352f, -0.03118381f, 0.03654944f, -0.13921763f, -0.04449562f, 
    -0.21063472f, -0.11974760f, -0.07359561f, 0.03056712f, 0.01338785f, -0.04429660f, 0.15524799f, 0.15169747f, 
    0.03266864f, 0.03301931f, 0.09009589f, 0.13542436f, 0.15923847f, -0.14283031f, -0.07248213f, 0.25599861f, 
    0.00705951f, 0.04635688f, 0.03608123f, -0.03528943f, -0.07666973f, 0.06985613f, -0.06342009f, -0.03600947f, 
    -0.16462335f, 0.03040371f, -0.12321249f, 0.00544937f, 0.01593493f, 0.07787184f, -0.02623371f, 0.07330770f, 
    -0.01343152f, 0.02718731f, -0.04115229f, 0.10684485f, -0.16599509f, -0.35862851f, 0.05001175f, -0.11100779f, 
    0.14295840f, -0.04262270f, 0.05554698f, 0.08482438f, 0.12499878f, -0.11609291f, 0.07608487f, 0.20516849f, 
    0.01986837f, -0.41782519f, 0.00258636f, -0.15129341f, 0.00005738f, -0.07284401f, 0.02917874f, 0.18615413f, 
    0.09222119f, -0.04495138f, 0.03599638f, 0.09266152f, -0.12066877f, -0.13663527f, -0.07504678f, 0.18253829f, 
    -0.05613910f, 0.03050563f, 0.03304150f, 0.06332182f, -0.01632678f, 0.02609848f, -0.00869050f, 0.00773621f, 
    0.21642049f, 0.04565081f, 0.08993206f, -0.02081104f, 0.10321999f, 0.10868762f, 0.06057012f, 0.09510041f, 
    -0.00169767f, -0.03145299f, 0.08233023f, 0.10301945f, -0.22025850f, -0.07910278f, -0.05895923f, -0.07139664f, 
    -0.00399266f, -0.00287642f, -0.04224159f, -0.14840105f, 0.04043312f, -0.05805193f, -0.06332738f, -0.12438585f, 
    -0.09545697f, -0.42895314f, 0.05233608f, 0.00396410f, -0.00015948f, 0.14310692f, -0.01515733f, -0.09131695f, 
    0.02879182f, 0.03399625f, 0.18861316f, 0.04514254f, 0.20074426f, 0.14635335f, 0.13125227f, -0.06327051f, 
    0.08674886f, 0.07176504f, 0.07045597f, 0.16260469f, -0.04498378f, 0.11674363f, 0.11568949f, 0.02398942f, 
    0.02572598f, -0.16171588f, 0.24252978f, 0.08970829f, 0.08066012f, 0.11760826f, -0.02751902f, 0.05832765f, 
    0.02408727f, -0.16218372f, -0.11276751f, -0.03916515f, 0.00191914f, -0.24019147f, 0.18137786f, 0.06669977f, 
    0.06374247f, 0.02764503f, -0.06469970f, -0.01701345f, 0.01756041f, 0.09088087f, 0.00959056f, -0.07404505f, 
    -0.20822722f, -0.34002557f, -0.26935935f, 0.00064274f, -0.06788894f, 0.01722910f, -0.07421380f, -0.01836337f, 
    -0.01253655f, 0.01232982f, -0.01186518f, 0.07088579f, 0.02995458f, -0.12758277f, -0.04650864f, -0.16018644f, 
    0.00142052f, -0.05574970f, -0.15267290f, -0.05101452f, -0.01888101f, 0.05778529f, -0.02532790f, 0.01881876f, 
    0.22380111f, 0.08434825f, -0.12999044f, -0.06976731f, 0.09979825f, 0.08877029f, 0.02337157f, -0.10586268f, 
    0.06390777f, -0.05088060f, 0.01696347f, -0.10064276f, -0.03378476f, -0.09453471f, -0.29242450f, 0.24495052f, 
    0.15292668f, 0.00646412f, 0.08465954f, 0.00278900f, -0.04365297f, -0.03061318f, -0.09072050f, 0.02387418f, 
    -0.04268678f, -0.13888584f, 0.05383132f, 0.10398438f, 0.12239446f, 0.02198444f, -0.05740451f, -0.09129790f, 
    -0.00481366f, -0.09574927f, -0.17786621f, -0.00646411f, 0.19904360f, -0.06016822f, -0.11014988f, -0.12935114f, 
    0.04593114f, 0.03603994f, -0.01031237f, -0.23013458f, -0.08217582f, -0.01712888f, -0.12626539f, -0.07579914f, 
    0.34916580f, 0.15739641f, 0.07145224f, -0.01835570f, 0.08902095f, 0.08557742f, 0.04552387f, -0.01812989f, 
    -0.03817017f, -0.02142481f, -0.01125320f, 0.03227060f, -0.07168267f, -0.28188261f, -0.11759408f, -0.02442719f, 
    -0.11246265f, 0.15264277f, -0.03446860f, 0.02508701f, -0.03539507f, 0.01606771f, 0.00158029f, 0.02061747f, 
    0.20080879f, -0.09354224f, 0.14647692f, -0.10328774f, 0.13314457f, -0.01120649f, -0.07359889f, -0.09287656f, 
    -0.00518504f, 0.02858913f, 0.04623519f, -0.07304724f, -0.35013747f, -0.13873075f, 0.01712514f, 0.12540923f, 
    -0.00546118f, -0.07387261f, 0.02938261f, 0.00754782f, -0.01141629f, -0.00869793f, 0.06766195f, 0.01684937f, 
    0.13280378f, -0.10165342f, 0.07931041f, 0.27623725f, 0.07520434f, 0.10904202f, 0.02807853f, 0.27433246f, 
    -0.02328242f, 0.13408419f, 0.14898357f, 0.01633118f, 0.10031133f, 0.16820128f, -0.07558893f, -0.13297829f, 
    0.06129574f, 0.01822685f, -0.13529640f, -0.06192423f, -0.05263656f, 0.00035765f, 0.07828538f, 0.01323758f, 
    0.28762969f, 0.00578170f, 0.05990071f, 0.00485722f, 0.01078742f, 0.04563533f, 0.06599901f, 0.10109337f, 
    0.13309011f, 0.02854014f, 0.05226192f, 0.01905073f, 0.17844673f, 0.11474674f, 0.17837335f, -0.02020914f, 
    0.16100708f, 0.04849087f, 0.06560897f, -0.06199069f, -0.08255555f, 0.02569524f, 0.02427499f, 0.08300704f, 
    -0.02830551f, -0.13307950f, -0.25650033f, -0.14592902f, -0.05048326f, -0.06628027f, -0.00850573f, 0.05771823f, 
    -0.03389032f, -0.01683837f, 0.02840322f, -0.06989615f, -0.12158310f, 0.11732907f, 0.06988212f, -0.12187255f, 
    0.17774279f, 0.01674049f, -0.07495581f, -0.10371967f, 0.11348298f, -0.04128078f, 0.08770739f, 0.07059097f, 
    0.42335045f, 0.23096101f, 0.09666034f, 0.02920447f, 0.08504082f, -0.00262002f, 0.01443160f, 0.14811172f, 
    0.02867416f, -0.02411555f, 0.08507536f, -0.08638825f, -0.18443167f, -0.13696218f, -0.01944784f, 0.25460896f, 
    0.01298474f, 0.07666515f, -0.03253514f, -0.06569434f, 0.05623239f, -0.04014516f, 0.08015880f, -0.00632910f, 
    0.08524217f, -0.15092367f, 0.03875093f, -0.08056884f, 0.00773100f, 0.03460898f, 0.02851958f, -0.05225368f, 
    -0.03045172f, -0.07445385f, 0.00444939f, 0.03014384f, -0.09851802f, -0.02979135f, -0.07499387f, -0.01232353f, 
    0.01181944f, -0.02952711f, 0.02358578f, -0.03627085f, 0.06489250f, 0.00877791f, 0.01911904f, -0.13266781f, 
    0.18280390f, 0.04107386f, -0.16042994f, -0.07187778f, 0.12541226f, 0.01686316f, 0.03048111f, -0.10160295f, 
    0.10207301f, 0.00567444f, 0.00542511f, 0.05092894f, 0.25620922f, 0.05592401f, -0.14751270f, 0.08514123f, 
    0.08885662f, 0.10845682f, 0.01592559f, 0.03126128f, -0.06165884f, -0.05870347f, 0.06133234f, 0.06735177f, 
    0.22277160f, -0.35465622f, -0.31414405f, 0.22079280f, 0.18216892f, -0.04380574f, -0.08110180f, 0.06714961f, 
    0.03131658f, -0.05166524f, -0.12052257f, -0.02585585f, 0.16819434f, 0.03717491f, -0.15366292f, 0.02142504f, 
    0.10833450f, -0.04826996f, -0.01782777f, 0.17887646f, 0.04008022f, 0.06859300f, -0.01647757f, -0.00677422f, 
    0.13958894f, 0.01757343f, -0.10641545f, 0.04168510f, 0.13832796f, 0.00153244f, -0.06551182f, -0.02343697f, 
    0.18659870f, 0.04117390f, 0.10270265f, 0.11800755f, -0.23202118f, -0.44904333f, 0.04223485f, -0.24731126f, 
    -0.00843784f, -0.21559364f, 0.03084449f, -0.00054667f, 0.16711102f, -0.04108181f, -0.00140621f, -0.14634661f, 
    -0.07196489f, -0.06876623f, 0.01014858f, 0.00148935f, -0.00287298f, -0.01072992f, 0.08005241f, 0.05890531f, 
    0.05592901f, 0.00831048f, -0.03869335f, -0.12509976f, 0.31717780f, 0.24121433f, 0.03980801f, -0.00089401f, 
    0.14868073f, 0.09104170f, 0.07143988f, -0.01415630f, -0.07159727f, -0.04608936f, -0.01458937f, -0.09402402f, 
    -0.11955333f, -0.12352099f, -0.16168103f, 0.20778765f, -0.05611744f, 0.00087388f, -0.04710875f, -0.02348107f, 
    0.11049968f, 0.05426637f, 0.13472565f, 0.05788293f, -0.21830274f, -0.18296973f, -0.08650816f, -0.07169089f, 
    -0.04931756f, -0.05017662f, 0.01303741f, 0.02574028f, 0.03670072f, -0.02681672f, -0.07792968f, -0.10198376f, 
    -0.02009239f, -0.34478092f, 0.15876766f, 0.08192785f, -0.05518917f, -0.03760220f, 0.02279381f, 0.01141070f, 
    0.07663668f, 0.03879322f, 0.04513855f, -0.00586441f, 0.09816204f, 0.16490996f, -0.29375198f, 0.03164537f, 
    0.04079007f, -0.00787338f, 0.03246393f, 0.09546953f, 0.00981635f, -0.01493465f, 0.04784442f, 0.08059201f, 
    -0.08999234f, -0.19325592f, -0.00196642f, 0.02991661f, -0.05861192f, 0.00095666f, -0.01624283f, -0.05433279f, 
    0.11332282f, -0.04544475f, 0.10600326f, 0.03534020f, 0.04825198f, 0.23733920f, -0.03184135f, 0.11986023f, 
    -0.00570100f, 0.08124855f, 0.06486075f, 0.11521395f, 0.03252083f, 0.09988841f, 0.15306965f, 0.02063681f, 
    0.13705112f, 0.21011533f, 0.20795608f, -0.12645836f, -0.08047564f, 0.01616104f, -0.01892011f, 0.14964589f, 
    0.09935459f, -0.01767739f, 0.04989382f, -0.04303278f, 0.04971964f, 0.20716169f, -0.33780465f, 0.05841202f, 
    0.02662993f, 0.02980193f, 0.17219023f, 0.20492432f, -0.04552710f, 0.06995554f, -0.00452128f, -0.16040295f, 
    0.35751876f, -0.24609002f, 0.12625402f, -0.25470319f, 0.22302511f, -0.00609742f, 0.03550592f, -0.00551472f, 
    -0.05384455f, 0.04967622f, 0.11144028f, 0.00399717f, 0.23958652f, 0.09799686f, -0.04284768f, -0.00083253f, 
    0.04646104f, 0.07601187f, 0.08303547f, 0.05620693f, -0.00667683f, 0.10789509f, 0.03590146f, -0.00680062f, 
    -0.06353041f, -0.20817223f, 0.01557494f, -0.11517249f, 0.15666240f, 0.07488381f, -0.08712312f, -0.06076733f, 
    -0.02696238f, 0.00895416f, -0.02060349f, -0.01309628f, -0.01750726f, 0.00770357f, 0.11751189f, 0.08409595f, 
    0.03110368f, 0.01496435f, 0.00216314f, -0.06947921f, -0.05282112f, -0.04529443f, 0.07198979f, 0.14315024f, 
    0.23999597f, 0.19067761f, -0.07368077f, 0.15660840f, 0.21808095f, 0.10253834f, -0.13660310f, 0.09313754f, 
    0.02516516f, -0.08572819f, -0.03514783f, 0.05782214f, -0.06842888f, -0.24893850f, -0.41868773f, -0.10971613f, 
    0.09458014f, -0.02500365f, 0.00622398f, -0.11430779f, 0.15531999f, 0.01139400f, 0.00480301f, 0.01851808f, 
    0.01221681f, -0.14796808f, 0.23109351f, -0.08367360f, -0.00174183f, -0.03474710f, 0.01703471f, 0.02058443f, 
    0.03865491f, 0.02163363f, -0.09381524f, 0.00948412f, -0.21385027f, 0.09754393f, 0.09014172f, 0.01034565f, 
    -0.07863256f, 0.14570746f, 0.06313002f, -0.05735275f, -0.00107203f, 0.06895042f, 0.02739093f, 0.10645741f, 
    -0.10073537f, 0.03239013f, -0.03432706f, -0.01033698f, 0.05377131f, 0.04910509f, 0.13114728f, 0.14717367f, 
    0.03268517f, 0.09010956f, 0.06867652f, 0.02138252f, 0.17963602f, 0.35278329f, -0.01015724f, -0.04770790f, 
    0.01681486f, 0.14355183f, 0.00130947f, 0.02336118f, -0.02853322f, -0.01387095f, 0.02407629f, 0.10372155f, 
    -0.14533232f, 0.01448129f, 0.28366196f, 0.07297118f, -0.10372125f, -0.05129070f, -0.08075871f, -0.05322728f, 
    -0.04844932f, 0.08239042f, 0.06567968f, 0.05317218f, 0.07231421f, -0.16796787f, 0.14965618f, 0.00384273f, 
    0.04697270f, 0.02370432f, 0.00073870f, 0.02587474f, -0.16492377f, -0.11433928f, 0.14417972f, -0.11821424f, 
    -0.12818803f, 0.40380538f, 0.09835772f, 0.24019310f, -0.07986180f, -0.06474702f, 0.04490462f, -0.20437092f, 
    0.00983548f, -0.04568070f, 0.00737681f, 0.00568613f, -0.05637645f, 0.17278302f, 0.12831089f, 0.19095750f, 
    -0.04990148f, -0.06211340f, -0.11916230f, -0.10055302f, 0.07096089f, 0.03642309f, 0.10859887f, 0.17513345f, 
    0.02188709f, -0.03485030f, -0.07080472f, 0.07043926f, -0.00485438f, 0.00520164f, 0.01244348f, -0.01250638f, 
    -0.04917079f, 0.00250895f, 0.02478681f, 0.03253920f, -0.02901551f, -0.04310051f, -0.28016695f, 0.01911963f, 
    -0.00034190f, -0.01651922f, 0.11255365f, -0.02811778f, 0.01256082f, -0.06096529f, -0.06858696f, -0.02610488f, 
    0.19524816f, 0.11316799f, -0.16391848f, -0.09460219f, -0.02066473f, -0.10615746f, -0.02569001f, -0.27915177f, 
    0.15171969f, 0.05387180f, 0.14016165f, 0.22322559f, 0.10113608f, 0.30365816f, 0.19119889f, -0.48262379f, 
    -0.04028430f, 0.03842517f, -0.01576425f, -0.32330680f, 0.07969084f, 0.15437819f, -0.11835935f, 0.06830729f, 
    0.02281215f, 0.11483201f, 0.00371823f, -0.27568063f, 0.06568632f, -0.04006684f, 0.06857818f, -0.14396343f, 
    0.14258735f, 0.05816025f, 0.03544328f, 0.09207034f, -0.10531067f, 0.30357981f, -0.11531416f, -0.15423349f, 
    -0.01095403f, 0.04848535f, 0.10529508f, -0.04870671f, 0.02478431f, 0.04909479f, -0.09774745f, -0.05591745f, 
    0.14574885f, 0.00479634f, 0.08123719f, 0.02689400f, -0.03011895f, 0.03598072f, 0.06614899f, -0.02082216f, 
    0.07955081f, 0.01686933f, 0.07012431f, 0.32009065f, 0.10858691f, -0.01501791f, 0.00931674f, -0.03430700f, 
    0.03356982f, -0.03757859f, 0.03125754f, 0.02114733f, 0.10245930f, 0.07727898f, 0.17923829f, 0.25939912f, 
    -0.06433757f, -0.00875632f, 0.11099081f, 0.03535929f, -0.04161142f, -0.00594657f, 0.04205424f, 0.08410165f, 
    0.07920974f, 0.04699936f, 0.05629155f, 0.08409510f, -0.03587533f, -0.01592313f, -0.02191768f, 0.01539130f, 
    0.11901621f, 0.12121197f, -0.03531056f, 0.10555157f, -0.06305954f, 0.02049995f, -0.05833016f, -0.00768300f, 
    0.12512623f, 0.06489840f, -0.08659776f, 0.03268548f, 0.07450213f, 0.01670226f, 0.04582819f, 0.06790029f, 
    0.10144836f, -0.15262389f, -0.09346573f, 0.00866086f, -0.13948254f, -0.10195336f, 0.11676187f, -0.10522296f, 
    -0.04886037f, -0.01517154f, -0.00384999f, -0.04226900f, 0.04627855f, 0.05086141f, 0.00446955f, 0.02296818f, 
    -0.25874701f, -0.11641967f, -0.30885911f, 0.08487508f, -0.15255459f, 0.17426226f, 0.16286147f, 0.06433218f, 
    -0.02109957f, -0.01792532f, -0.01594462f, -0.02650996f, 0.03020720f, 0.05973127f, -0.09579430f, 0.12348517f, 
    -0.07215331f, -0.04268724f, -0.00862684f, -0.00522916f, 0.03443927f, 0.01995408f, -0.02828353f, 0.00706090f, 
    0.22604944f, 0.26471704f, 0.34947023f, -0.34429884f, 0.08927723f, 0.02274808f, -0.04467084f, -0.20025635f, 
    0.08174937f, 0.11908074f, 0.19711326f, 0.06634878f, 0.24859171f, -0.05930813f, 0.01097200f, 0.05705690f, 
    0.01059201f, -0.00915548f, 0.03852290f, -0.00749102f, -0.08124107f, 0.01530822f, -0.09409198f, -0.16739285f, 
    -0.14397790f, -0.02797067f, 0.26108924f, 0.14618507f, -0.03765909f, -0.14613849f, -0.19069566f, 0.10553549f, 
    0.03116696f, -0.01745023f, -0.06124519f, 0.02356652f, 0.08555066f, -0.03912954f, -0.05299955f, -0.04136301f, 
    -0.00977655f, 0.11747347f, 0.06001389f, 0.04428327f, -0.02679429f, -0.07461296f, -0.07955953f, -0.07654654f, 
    -0.11197409f, -0.12998199f, -0.12957169f, 0.11949257f, -0.00728488f, -0.03218327f, 0.05920354f, 0.03293521f, 
    -0.05086879f, -0.06589518f, 0.00215230f, -0.11474716f, -0.23664005f, -0.21757285f, 0.25336084f, 0.24396634f, 
    0.02418053f, -0.05624203f, -0.04566414f, 0.09302753f, 0.01705342f, -0.08259624f, 0.15095145f, -0.14791791f, 
    -0.15810421f, 0.09300565f, 0.12119229f, 0.03126403f, -0.12777135f, -0.02841324f, 0.01779567f, -0.00989060f, 
    -0.07554255f, 0.04643897f, 0.15412520f, 0.14140692f, 0.26231489f, 0.33106652f, 0.08476463f, -0.29052341f, 
    0.02029605f, -0.14620893f, -0.03836658f, 0.05997726f, -0.16379398f, 0.04804045f, -0.13455157f, -0.05643807f, 
    -0.17355780f, 0.29037425f, 0.18002211f, 0.28792801f, -0.14141494f, -0.07292215f, -0.08380924f, -0.03151313f, 
    -0.00323225f, 0.06000342f, 0.13596913f, 0.10641446f, -0.25613594f, 0.06113531f, -0.09827940f, -0.06351314f, 
    -0.03796853f, 0.04890492f, -0.05728925f, 0.02658010f, 0.09522551f, -0.08546459f, -0.08235460f, -0.15532438f, 
    0.23105401f, 0.25802892f, -0.11233523f, -0.28140986f, -0.01991080f, -0.01471637f, 0.04064912f, 0.01033696f, 
    0.02989938f, 0.02561769f, -0.12457854f, 0.09452834f, 0.04675266f, 0.07545851f, 0.24760324f, 0.05878750f, 
    -0.11672490f, -0.03081440f, 0.09009992f, -0.05608949f, 0.01313616f, 0.00983579f, -0.01154176f, -0.09020181f, 
    -0.12306362f, -0.05609160f, 0.02345991f, 0.04981129f, 0.07400313f, 0.06268119f, -0.05274201f, -0.11832081f, 
    0.05068199f, -0.04312620f, -0.03664966f, 0.04414097f, -0.27505866f, -0.36077258f, 0.16270278f, 0.13853896f, 
    0.05519297f, 0.14822173f, -0.06630038f, 0.10175255f, 0.25127858f, 0.12781918f, 0.06479560f, 0.10961249f, 
    0.11255508f, 0.10756099f, 0.08720620f, -0.07384665f, 0.00643273f, 0.09876112f, 0.05812262f, -0.11084669f, 
    0.07317878f, 0.03758767f, -0.13139060f, 0.00640664f, -0.01513420f, 0.17409231f, 0.15749057f, -0.14782920f, 
    -0.04333740f, -0.06782291f, -0.07201011f, 0.19084466f, 0.00794189f, 0.05646505f, -0.08891556f, -0.06133169f, 
    -0.15915866f, -0.08078335f, 0.04260786f, -0.08163248f, -0.03258068f, 0.08864260f, -0.00211559f, -0.07448827f, 
    -0.01572821f, -0.00123606f, -0.03699030f, -0.03837273f, 0.21187294f, -0.11311811f, -0.02239097f, -0.03540249f, 
    0.01338382f, 0.03264464f, 0.01763408f, 0.01115656f, -0.01176838f, -0.05015069f, -0.05668796f, -0.05553149f, 
    0.05987298f, 0.21354012f, 0.38422590f, -0.04097481f, -0.07377710f, -0.05971889f, 0.06914480f, -0.14421619f, 
    0.02227128f, 0.16520499f, 0.06649943f, -0.07988220f, 0.00219683f, 0.00910098f, 0.02754777f, -0.03375874f, 
    0.19354646f, 0.10548583f, -0.05812069f, 0.14670305f, -0.04554461f, 0.08017685f, -0.10519409f, -0.06010685f, 
    -0.03509335f, 0.02682186f, 0.27305529f, 0.31613290f, -0.08607920f, -0.04605651f, 0.02230036f, 0.03211844f, 
    -0.08825351f, -0.00830298f, 0.11446088f, 0.04984703f, -0.26991951f, 0.00192339f, 0.33737850f, -0.08106989f, 
    -0.06981766f, -0.10420255f, 0.08757618f, 0.06237340f, -0.01272137f, -0.02788498f, 0.01097799f, -0.22216243f, 
    -0.06469896f, -0.12950271f, 0.13337344f, -0.07652702f, -0.13234012f, -0.12813485f, 0.19901855f, -0.06420840f, 
    -0.10757250f, -0.07417604f, 0.14149155f, -0.05589771f, -0.17239910f, 0.06980765f, 0.28903463f, -0.09070878f, 
    -0.18605237f, 0.02056528f, 0.06726856f, -0.17009714f, 0.07067255f, 0.00858489f, 0.07949544f, 0.17831008f, 
    -0.13441707f, 0.02770472f, 0.16684623f, -0.00745353f, -0.14447281f, -0.13784644f, -0.05387540f, -0.04103220f, 
    0.02507169f, 0.14437953f, 0.06337015f, 0.09776957f, 0.18780451f, 0.06571574f, -0.03656989f, 0.06327523f, 
    0.03706738f, 0.06225317f, 0.05998632f, -0.03287123f, 0.07083016f, -0.00867040f, -0.06181489f, 0.22175232f, 
    0.04381702f, 0.04781532f, -0.04094137f, 0.04277514f, -0.01616578f, 0.00843318f, 0.05096716f, -0.01766858f, 
    -0.04095468f, 0.00362001f, 0.21091945f, 0.42912504f, -0.19695945f, -0.03960755f, 0.00566022f, -0.00099933f, 
    -0.11590856f, -0.09879582f, -0.03349067f, 0.07023761f, 0.04672896f, -0.06889255f, -0.00486588f, -0.07188623f, 
    0.15824117f, -0.07923123f, 0.08727897f, -0.06079950f, 0.02922760f, 0.01190780f, -0.00106216f, 0.04281013f, 
    -0.02166991f, -0.05194126f, -0.01695221f, -0.05782234f, 0.13516945f, 0.04960613f, -0.11481736f, -0.08445154f, 
    0.10243059f, -0.02235732f, 0.00068801f, 0.10739624f, -0.00223859f, -0.00372935f, -0.05483810f, -0.04531974f, 
    0.09335087f, -0.08779112f, -0.01649531f, 0.14318696f, 0.02894413f, -0.06342001f, -0.02568082f, 0.02648910f, 
    -0.13634701f, 0.07682607f, -0.02575819f, 0.07053338f, -0.15781142f, 0.05181438f, 0.28424335f, -0.17484330f, 
    -0.01120879f, 0.05397593f, 0.08282883f, -0.10252187f, 0.02673184f, 0.02998712f, -0.02421128f, -0.06875057f, 
    0.27545008f, 0.13143452f, -0.04093308f, 0.01357867f, -0.01552966f, 0.02013008f, 0.02731851f, -0.01927506f, 
    0.02675182f, 0.24318640f, 0.12259750f, 0.13743144f, 0.08926079f, 0.03720394f, 0.02732528f, -0.19583583f, 
    0.03324795f, -0.00168746f, -0.15188299f, 0.01083028f, 0.09174824f, 0.05541031f, -0.08960944f, 0.14960764f, 
    -0.14940746f, 0.06854889f, -0.09148857f, -0.07560869f, 0.03117256f, 0.15322739f, 0.01769947f, 0.10451909f, 
    0.04742182f, -0.03248985f, -0.20870021f, -0.04714461f, 0.22682922f, 0.01362398f, -0.06326757f, -0.08174804f, 
    -0.05040422f, 0.16959815f, -0.01952001f, -0.13365479f, 0.07200482f, 0.12089563f, -0.07920455f, 0.08182546f, 
    -0.28913069f, -0.01438977f, -0.07732534f, 0.03005847f, -0.04577709f, 0.04788118f, 0.05079611f, 0.00538228f, 
    0.01566073f, 0.03425117f, 0.07469500f, 0.02258907f, -0.16944125f, -0.02000338f, 0.07947932f, -0.09936402f, 
    -0.04590372f, -0.06925540f, 0.14231278f, -0.03973137f, 0.01374707f, -0.05008583f, -0.06830656f, 0.04795098f, 
    -0.12238120f, 0.39747259f, 0.10726719f, 0.32052621f, -0.11886232f, -0.11627764f, 0.02588044f, -0.08835872f, 
    0.02395921f, -0.01565312f, 0.09261978f, 0.12161777f, -0.22481146f, -0.08682477f, -0.02795440f, 0.19207940f, 
    -0.02812734f, 0.05730492f, 0.02274565f, 0.09055138f, 0.02586564f, 0.27671748f, 0.15019655f, 0.01852635f, 
    -0.17590019f, -0.04293864f, 0.05528123f, -0.18726751f, -0.11651770f, -0.04999129f, 0.03322252f, 0.02575980f, 
    -0.09310703f, 0.05497284f, -0.06808265f, -0.12266299f, -0.07628753f, 0.27994272f, 0.32761225f, 0.14326993f, 
    -0.09623765f, -0.10230397f, -0.09159572f, -0.05533374f, 0.00603832f, -0.08318354f, 0.07431965f, 0.20030974f, 
    -0.15691365f, 0.17199017f, -0.08884808f, 0.22847763f, 0.07205336f, 0.15511169f, 0.03425395f, -0.02956967f, 
    0.10655904f, 0.09531318f, 0.03597556f, 0.03424633f, -0.02778448f, 0.05001163f, -0.24693960f, 0.07448537f, 
    0.05170015f, -0.00247729f, -0.05889356f, -0.05934642f, 0.16039993f, 0.03660547f, 0.09430154f, 0.18845786f, 
    0.02705321f, 0.10026702f, 0.13831757f, 0.02174656f, -0.06346958f, -0.06204300f, -0.05027758f, -0.09566444f, 
    0.09880655f, 0.14932433f, 0.09591105f, 0.16562939f, -0.07494127f, -0.38998291f, 0.13600054f, 0.34279776f, 
    0.00940533f, 0.00596504f, 0.02272974f, -0.03163306f, 0.01901443f, 0.09594349f, 0.06809397f, 0.04004874f, 
    0.06910497f, 0.08639926f, 0.05366326f, -0.03121487f, 0.03941283f, 0.07718681f, 0.11265583f, 0.02254749f, 
    0.02810554f, 0.03770785f, -0.10444342f, -0.14001484f, -0.20387201f, -0.20935535f, -0.02174750f, -0.08568708f, 
    -0.09386052f, -0.13555776f, -0.04006455f, -0.19183996f, 0.03123586f, 0.17313179f, -0.11212565f, 0.12785256f, 
    0.26548076f, -0.08598664f, -0.03338014f, -0.06419981f, 0.07438000f, 0.12176339f, -0.05847063f, -0.03036300f, 
    0.06835878f, 0.08235894f, 0.12363455f, 0.10991984f, 0.02033338f, -0.02957717f, -0.15710066f, -0.08516500f, 
    0.09976880f, -0.00037959f, -0.02204923f, -0.03738587f, -0.02812988f, 0.10138708f, -0.01926813f, 0.07158550f, 
    0.01830167f, 0.01630829f, 0.07790048f, -0.06126632f, -0.14997320f, -0.17893288f, -0.12631802f, -0.15686558f, 
    -0.06492870f, -0.12047279f, -0.06860553f, -0.07543032f, -0.00308651f, 0.05863981f, 0.15730852f, -0.05387186f, 
    -0.01376539f, -0.03322879f, -0.21015897f, 0.03757066f, 0.00425593f, 0.01960320f, 0.05308601f, 0.19804758f, 
    -0.15706900f, -0.00840273f, 0.21970585f, 0.04372261f, -0.02265302f, -0.00537813f, -0.18776639f, 0.06303206f, 
    -0.16553564f, -0.07383592f, -0.16502395f, -0.20930418f, -0.16177072f, -0.05840972f, 0.07227222f, 0.15122248f, 
    -0.06740239f, 0.05871337f, -0.05202562f, 0.15080582f, 0.12388252f, -0.03744125f, 0.09711111f, 0.13671882f, 
    0.11446127f, -0.13098943f, 0.03261539f, 0.04260190f, -0.04146684f, 0.11663376f, 0.04914623f, 0.19973136f, 
    0.03029159f, 0.13463783f, 0.06611311f, -0.09139934f, 0.38454250f, 0.16408102f, 0.07440998f, 0.14939284f, 
    -0.06549745f, -0.07704140f, 0.06303479f, 0.05424277f, 0.11344258f, 0.04099522f, 0.04231765f, 0.19552283f, 
    -0.12723736f, 0.12920108f, 0.08692743f, 0.14584363f, -0.07733168f, 0.03234863f, -0.07624415f, -0.06285086f, 
    0.00771809f, 0.01277854f, 0.01732146f, -0.09343947f, -0.09850593f, 0.08321436f, 0.11150597f, 0.11265516f, 
    -0.00732608f, 0.08787698f, -0.08022287f, -0.06118644f, -0.02734140f, -0.02206214f, -0.00503493f, -0.15559541f, 
    -0.00792472f, 0.04710616f, -0.01394564f, 0.03855442f, 0.07983080f, 0.01452524f, 0.05621477f, 0.00726959f, 
    -0.04082805f, -0.04291284f, -0.04715563f, -0.12583719f, -0.02985969f, -0.13116881f, -0.13578291f, 0.07591382f, 
    0.09288186f, -0.05754820f, -0.00253737f, -0.07371762f, 0.15475976f, 0.12446474f, 0.05466213f, 0.22637482f, 
    -0.09683146f, -0.07190268f, -0.11223471f, -0.01025694f, -0.13876922f, -0.14569715f, -0.05126426f, -0.10505939f, 
    -0.06001636f, 0.12834339f, -0.05994153f, 0.03350894f, -0.00799430f, 0.09136911f, -0.08799329f, 0.03258702f, 
    0.09956456f, -0.00613401f, -0.00526299f, -0.02537915f, -0.03322173f, -0.09523640f, 0.05590220f, 0.02958372f, 
    0.07428005f, 0.26357499f, 0.31742302f, 0.05567533f, 0.14747144f, -0.12250974f, -0.05803243f, -0.04734832f, 
    -0.02942681f, -0.00433006f, -0.06662954f, 0.07918464f, 0.06812839f, 0.11522403f, 0.17019995f, -0.02834040f, 
    -0.10458324f, -0.06514764f, -0.08830046f, -0.12405450f, -0.01226649f, -0.01788372f, -0.01548673f, 0.19530396f, 
    0.03242882f, 0.10399724f, 0.16971008f, 0.17248115f, -0.03739380f, -0.04310618f, -0.07962419f, 0.15288503f, 
    0.09808192f, 0.13452181f, 0.06309378f, 0.07833911f, -0.27590302f, 0.04806318f, -0.03873301f, 0.05816591f, 
    -0.24276343f, -0.18665847f, 0.00697363f, -0.09249078f, 0.10188121f, 0.03724225f, -0.04315832f, 0.15369509f, 
    -0.10201143f, 0.00706237f, -0.08322520f, 0.04688546f, -0.00720538f, 0.07934033f, 0.19386174f, 0.15790389f, 
    -0.12622669f, 0.01327151f, -0.01291329f, 0.04385009f, -0.09054196f, 0.14815322f, 0.20274313f, -0.14857236f, 
    -0.02235464f, -0.04953350f, -0.09796812f, -0.03077554f, -0.01681056f, -0.09476649f, 0.08053504f, 0.06023593f, 
    0.09680603f, 0.21204782f, 0.39059073f, 0.11355267f, -0.06621630f, -0.08923168f, 0.03732428f, -0.19643430f, 
    0.03813646f, 0.08537974f, -0.00670594f, 0.14184383f, -0.03521078f, 0.15052548f, -0.21243717f, -0.11183974f, 
    -0.16357644f, -0.03972749f, 0.07287154f, -0.08891240f, 0.03535341f, 0.08207340f, -0.01941803f, 0.16083828f, 
    -0.05248421f, -0.09457496f, -0.04928487f, -0.01512335f, 0.10364405f, 0.11989739f, 0.15991162f, 0.08783824f, 
    -0.05232740f, -0.01172254f, -0.05947751f, -0.09492140f, -0.13111258f, -0.14530106f, 0.01655496f, 0.12185773f, 
    0.10175435f, 0.04728996f, 0.02153260f, -0.03377832f, 0.19792357f, 0.11216606f, 0.14905447f, 0.05065691f, 
    -0.13546640f, -0.22424597f, -0.28464535f, -0.15810721f, 0.08796901f, 0.02699077f, -0.00646063f, -0.08229209f, 
    -0.00447975f, 0.00314610f, 0.06255215f, 0.15057410f, 0.20583738f, 0.14211942f, 0.05152668f, 0.18936802f, 
    -0.17863330f, -0.02187591f, -0.10413479f, 0.06056518f, 0.01024116f, 0.06786513f, -0.04001301f, 0.23683177f, 
    -0.22293004f, -0.10088706f, 0.00370034f, 0.01086972f, 0.08411834f, 0.04142669f, 0.11798674f, 0.03765045f, 
    0.02425241f, -0.10792381f, 0.00773679f, 0.08113795f, 0.03116013f, -0.00360774f, -0.03538592f, 0.05259644f, 
    0.21215020f, 0.27377999f, -0.02308447f, 0.05736691f, -0.00034532f, 0.05613956f, 0.05068903f, 0.08097257f, 
    -0.10729882f, -0.02291662f, -0.34552726f, -0.16778438f, 0.10287296f, -0.00620201f, 0.18452150f, 0.23633623f, 
    -0.11939386f, 0.15146902f, 0.09667778f, -0.09529275f, 0.23335361f, 0.52239549f, -0.16636883f, -0.01034393f, 
    0.07187865f, -0.05116192f, 0.13479106f, 0.08049829f, 0.02579409f, -0.02860525f, 0.08308664f, 0.08384831f, 
    -0.31678236f, -0.03013141f, -0.07920334f, -0.10190425f, 0.05437334f, 0.02167878f, -0.10392937f, 0.13196872f, 
    -0.15482934f, -0.04526365f, 0.10823130f, 0.06596391f, 0.30307692f, 0.01314651f, 0.01073419f, 0.42086029f, 
    0.05057386f, 0.11952607f, 0.13899334f, 0.03808369f, -0.05202721f, 0.18398947f, 0.09574521f, 0.20244807f, 
    -0.11685832f, -0.14281528f, -0.08535912f, -0.10480840f, 0.00754351f, 0.05469169f, 0.08508193f, 0.01987100f, 
    -0.05453701f, 0.04987588f, -0.02142524f, 0.03751155f, -0.27055535f, -0.04889973f, -0.01486589f, -0.08824314f, 
    -0.14186502f, -0.26223731f, -0.15084118f, -0.16106623f, 0.08444924f, 0.07919023f, -0.08143236f, 0.04001248f, 
    0.11691426f, -0.11046758f, -0.22549695f, 0.06558531f, 0.17177035f, 0.05917488f, 0.21233168f, -0.04734515f, 
    0.11601547f, 0.04401072f, 0.09784184f, 0.08952710f, 0.04502172f, -0.15286177f, -0.09325328f, 0.00264289f, 
    -0.09518516f, 0.02447288f, -0.11182953f, 0.00226377f, 0.09804755f, -0.01903093f, 0.17225449f, 0.19972344f, 
    0.05569128f, -0.02239107f, 0.19718251f, -0.00844914f, 0.04163512f, 0.04612292f, 0.02724674f, -0.01681480f, 
    0.00456858f, 0.01853319f, -0.06880207f, -0.13699879f, 0.20647171f, 0.17477886f, 0.06137626f, 0.01614187f, 
    0.03687065f, 0.15650120f, 0.10237695f, 0.13734145f, -0.01429540f, 0.05512416f, 0.01597085f, 0.11628897f, 
    -0.18059611f, 0.09203260f, -0.15255250f, -0.02117847f, 0.05801212f, 0.11533092f, -0.16378717f, -0.10752112f, 
    0.11979627f, -0.06523502f, 0.05293917f, -0.12482267f, 0.14256322f, -0.02932554f, -0.02733129f, 0.07997762f, 
    0.03287449f, 0.08951741f, 0.12867360f, 0.01948204f, -0.00971408f, 0.01903275f, 0.08272208f, -0.16289076f, 
    -0.03066301f, -0.09338680f, -0.29678053f, -0.04922665f, 0.02406486f, 0.02698149f, 0.01362390f, 0.15627471f, 
    -0.06296964f, -0.11896111f, 0.03271820f, -0.01247936f, -0.05967614f, 0.24346033f, -0.02757007f, -0.09271392f, 
    -0.05856290f, -0.03989852f, -0.09682961f, -0.12340907f, 0.06038932f, 0.23364513f, 0.05665840f, 0.02402519f, 
    -0.06346904f, -0.04636352f, 0.10511242f, -0.04587138f, -0.02915505f, -0.02087578f, -0.06026322f, -0.07742743f, 
    -0.10068455f, -0.08623631f, -0.00486028f, -0.32628688f, 0.01544179f, -0.07018038f, -0.00975388f, -0.03470317f, 
    0.10656388f, 0.14706738f, 0.10825042f, 0.10896619f, -0.03267333f, 0.02801228f, -0.00786340f, 0.11069691f, 
    0.11413631f, 0.02714407f, -0.02879261f, 0.14658393f, -0.10803617f, -0.14018138f, -0.02597436f, -0.03711966f, 
    0.00456751f, 0.08030970f, 0.00802565f, 0.06234753f, -0.01544376f, -0.00601919f, -0.02380878f, -0.01679850f, 
    -0.04115603f, -0.04063524f, -0.02676491f, -0.02764016f, 0.10467996f, 0.08928607f, 0.11182182f, 0.11793537f, 
    0.05986382f, 0.23280571f, -0.03117406f, -0.05928792f, -0.17445569f, -0.09819497f, -0.07490254f, -0.10962690f, 
    0.12980910f, 0.01974983f, 0.03697020f, 0.03626690f, 0.22492625f, 0.05686526f, -0.02768984f, -0.08257097f, 
    0.09620831f, 0.02457928f, -0.03011772f, 0.09206758f, 0.06406090f, -0.06885266f, -0.03704976f, 0.19688107f, 
    -0.13200296f, 0.07938096f, 0.14404891f, 0.21769752f, -0.00278506f, -0.03140102f, 0.01811774f, -0.09166900f, 
    -0.00433447f, 0.00216012f, 0.03056405f, -0.05051269f, -0.18094933f, -0.21108952f, -0.04602557f, -0.09891752f, 
    -0.02016164f, 0.01336847f, 0.01662357f, 0.04793490f, -0.12722625f, -0.03443837f, -0.09842200f, -0.03984393f, 
    0.13233076f, -0.08144171f, -0.05663851f, 0.10600674f, 0.05744484f, 0.00445817f, -0.07689562f, 0.09035661f, 
    0.00987447f, -0.06231696f, 0.04822962f, 0.19233800f, -0.24160306f, -0.27067515f, 0.19414116f, -0.06195420f, 
    0.05180834f, -0.07694017f, -0.00821092f, 0.11851928f, 0.03305443f, -0.06160775f, -0.02863085f, 0.07342301f, 
    0.11362500f, 0.04219683f, -0.11319931f, 0.15051283f, 0.10175581f, 0.05535891f, -0.00426007f, 0.01222933f, 
    0.06849929f, 0.04598896f, -0.02545032f, 0.03472065f, 0.05102159f, -0.06506533f, 0.03416766f, 0.08995066f, 
    0.02869079f, 0.01930971f, -0.08455329f, 0.06477835f, 0.01914673f, 0.01949130f, 0.06558733f, 0.08195668f, 
    0.07821283f, -0.21723920f, 0.04639802f, -0.09306266f, 0.07030988f, 0.08560981f, 0.02389772f, -0.09002372f, 
    0.01222364f, 0.16553661f, -0.01569127f, -0.00141191f, 0.20546417f, 0.20623018f, -0.07014377f, -0.04211161f, 
    -0.02251789f, -0.04400131f, 0.01039652f, -0.17615116f, -0.01535064f, -0.12190980f, -0.00878691f, -0.08343617f, 
    0.01879152f, -0.04325040f, 0.04339314f, 0.09509441f, 0.02974077f, 0.18818358f, 0.08855073f, -0.03658952f, 
    0.08515683f, -0.01663205f, 0.08984427f, 0.11193092f, -0.01273470f, -0.27528751f, -0.15494601f, -0.10267079f, 
    0.01926957f, 0.03788077f, 0.05902027f, -0.12007727f, -0.14748229f, 0.10964237f, 0.04318760f, -0.13058358f, 
    -0.00221384f, 0.12736367f, 0.00149187f, -0.03178769f, -0.11083002f, -0.04977889f, -0.10898008f, 0.10580765f, 
    -0.03988328f, -0.06621699f, 0.18775398f, -0.07276623f, 0.16229437f, 0.07596094f, 0.18339956f, 0.04157211f, 
    0.20344602f, 0.04446772f, 0.03611228f, 0.18240929f, -0.10271997f, 0.01927209f, 0.04327968f, -0.09989595f, 
    0.11190872f, -0.00238473f, 0.10959321f, 0.01922752f, 0.10509848f, 0.04971547f, -0.10696743f, -0.02605992f, 
    0.02539939f, -0.02564523f, -0.17403580f, -0.02947012f, 0.01526477f, 0.17684649f, -0.07783645f, -0.16567893f, 
    0.00836655f, -0.07837949f, 0.11951166f, 0.08054860f, 0.05622762f, -0.03525420f, -0.05208205f, -0.01410255f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03245393f, -0.03778047f, -0.03840691f, 0.10334424f, -0.01769759f, -0.03205249f, 0.03940810f, -0.01994307f, 
    -0.02750689f, -0.00399907f, -0.03854524f, 0.15058683f, 0.12537324f, 0.02276952f, 0.09040946f, 0.20858760f, 
    0.01904621f, -0.03255102f, -0.01363079f, 0.14084561f, 0.03867715f, 0.02199027f, 0.01075479f, -0.01567679f, 
    0.04649954f, 0.01551509f, -0.04346012f, -0.00553264f, 0.17058389f, -0.00652176f, 0.10942479f, 0.09927677f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05139553f, 0.10610650f, 0.11453837f, -0.12218459f, 0.25442386f, 0.13205072f, 0.26240456f, 0.12880151f, 
    -0.01826465f, -0.14621940f, -0.05467406f, 0.17566171f, -0.07345555f, 0.15505643f, -0.19025660f, -0.07243672f, 
    -0.11600356f, 0.08789905f, -0.05243690f, -0.15971836f, 0.16946152f, -0.09845743f, 0.12491126f, 0.05859160f, 
    -0.34853971f, 0.12496120f, 0.19263966f, -0.06577824f, -0.31912526f, 0.11953945f, 0.13871828f, 0.31390420f, 
    -0.17027712f, -0.00891315f, 0.08993442f, -0.03212017f, -0.09996218f, 0.01303901f, -0.24216868f, -0.13506936f, 
    0.15411165f, 0.05800640f, -0.00564475f, 0.11037358f, -0.15390228f, 0.11460906f, 0.11510007f, -0.09108143f, 
    0.45885381f, 0.03512911f, -0.01841288f, -0.50736135f, 0.17093109f, -0.16401216f, 0.14458282f, 0.35791129f, 
    0.02873817f, 0.15630254f, 0.05686269f, 0.11555529f, 0.10014525f, 0.29419896f, -0.17887306f, 0.03057129f, 
    0.10832993f, -0.13894629f, -0.00858941f, 0.00388918f, 0.07247309f, -0.05752821f, 0.21513236f, -0.12154002f, 
    -0.07358409f, 0.07099473f, -0.08625625f, -0.13059290f, -0.28795472f, 0.00690699f, 0.24351898f, -0.20833634f, 
    0.32099932f, -0.06787597f, 0.16509219f, 0.01701024f, 0.08268772f, -0.14085671f, -0.06411436f, 0.18216601f, 
    0.18170989f, 0.14782840f, -0.08211730f, -0.10799745f, -0.12121576f, 0.41169015f, -0.15215772f, -0.07988546f, 
    0.05904130f, 0.01791249f, -0.13133170f, -0.00298135f, -0.04877542f, -0.13496989f, 0.28825861f, 0.00123441f, 
    -0.06563842f, -0.07819990f, -0.08640439f, -0.15284573f, 0.12985958f, 0.21432894f, -0.07782044f, 0.20543793f, 
    0.04008574f, 0.09525822f, -0.09929573f, -0.03356130f, -0.24334800f, -0.01216322f, 0.21455753f, -0.20007451f, 
    0.00655193f, 0.10265398f, 0.10760462f, 0.10880867f, 0.02450024f, -0.06327169f, -0.10006557f, 0.48781317f, 
    -0.17914011f, 0.14380977f, 0.12825102f, 0.25827858f, 0.04854107f, -0.03069421f, -0.07271882f, 0.10501559f, 
    -0.16596547f, -0.08399639f, 0.01861094f, 0.34843990f, 0.25186375f, 0.09145351f, 0.11600411f, 0.04903196f, 
    -0.10324528f, -0.09951975f, 0.07803909f, 0.20585279f, 0.24489363f, -0.17030577f, -0.26337683f, -0.05936989f, 
    -0.16744018f, 0.07662817f, -0.10959552f, 0.09267514f, 0.45227748f, -0.19383872f, 0.43712288f, -0.01647299f, 
    0.12621461f, -0.06425427f, -0.14950694f, -0.23578766f, 0.03787917f, 0.12465346f, 0.05607970f, -0.05951741f, 
    -0.03744696f, -0.10751490f, 0.05996203f, 0.14952017f, -0.46574667f, 0.30341482f, 0.06657391f, 0.27850351f, 
    0.25728506f, 0.14310837f, -0.07365578f, -0.06379551f, -0.37411919f, 0.16067542f, -0.05908560f, 0.46999401f, 
    -0.02889176f, 0.11019643f, 0.04630186f, 0.04140231f, 0.13182595f, -0.19288424f, 0.32572454f, -0.28880867f, 
    0.05478177f, -0.06626379f, 0.36566874f, 0.13924651f, 0.39167055f, 0.07459891f, -0.06337740f, -0.02170081f, 
    0.12763731f, 0.08294636f, -0.05814358f, -0.00560768f, 0.07783758f, 0.01452312f, -0.19614542f, -0.08040450f, 
    -0.10376191f, -0.16978051f, 0.01197291f, 0.41662708f, 0.22713116f, 0.12552100f, 0.16630568f, 0.16020985f, 
    -0.12593564f, -0.05478906f, 0.03352118f, 0.06248420f, 0.18111864f, 0.22101243f, 0.30280539f, -0.17325062f, 
    -0.17251694f, -0.14877278f, -0.26852569f, -0.30048171f, 0.01821034f, 0.00363240f, -0.23518422f, -0.13280700f, 
    -0.15768191f, 0.01393396f, 0.16702288f, 0.19032362f, -0.01856009f, -0.06917690f, -0.12359000f, -0.11711296f, 
    -0.14075005f, -0.03839504f, 0.01056011f, -0.16143340f, 0.13170773f, -0.18032366f, 0.07024493f, -0.09451860f, 
    -0.06157597f, 0.07892977f, 0.17646506f, 0.08811979f, -0.04642779f, -0.23329888f, -0.01189565f, -0.15657981f, 
    0.16814208f, 0.06234862f, -0.11190315f, 0.07035293f, -0.23185621f, 0.15337618f, 0.26298687f, 0.16877091f, 
    0.00056949f, -0.10409489f, -0.07609890f, 0.05178853f, -0.12269252f, -0.14053608f, -0.10068439f, 0.23131265f, 
    0.10316231f, 0.17376143f, 0.03438121f, 0.00464132f, -0.22471407f, -0.00074600f, -0.08592178f, -0.22265553f, 
    0.05883706f, -0.15102720f, -0.10381698f, -0.13380945f, -0.17631911f, 0.13592489f, -0.01599588f, 0.13072573f, 
    -0.15265517f, 0.06298884f, -0.12848620f, 0.23434751f, -0.04386387f, 0.16052346f, 0.08816784f, 0.00682533f, 
    0.08928850f, -0.16158304f, 0.14356536f, -0.15017503f, -0.03713096f, -0.27195561f, 0.07974713f, 0.22642548f, 
    0.15570886f, 0.09088934f, 0.04251970f, -0.02128279f, 0.07124040f, 0.16924188f, -0.15931848f, -0.22281952f, 
    0.06004988f, 0.12345979f, -0.00559338f, -0.06149149f, 0.23309842f, -0.00058406f, 0.19407147f, 0.05576229f, 
    -0.10038204f, 0.02103710f, -0.04929437f, 0.24113327f, -0.21553913f, -0.01568856f, 0.27302346f, -0.14314298f, 
    0.13588989f, 0.15469539f, 0.16184527f, 0.12333819f, 0.00976608f, 0.33151516f, 0.11475134f, 0.08884493f, 
    -0.07696331f, 0.15665518f, 0.14614192f, -0.13742471f, 0.11531483f, 0.14384134f, -0.14758435f, -0.08007079f, 
    -0.09747373f, -0.07423518f, 0.17249393f, 0.16236728f, 0.15547468f, -0.10648019f, -0.25954267f, 0.18011028f, 
    0.17431283f, 0.01362594f, -0.14663053f, -0.08868882f, -0.25125912f, -0.11546917f, -0.05244524f, 0.04006068f, 
    0.13523775f, 0.10676280f, 0.11747163f, 0.03873439f, -0.21011297f, 0.01255467f, 0.12931411f, 0.27134457f, 
    0.22153647f, -0.05641685f, -0.15066020f, -0.37233746f, -0.10276663f, 0.06274607f, 0.27153039f, 0.42627516f, 
    0.30449411f, -0.16664788f, -0.01120112f, -0.02941620f, 0.08739346f, -0.10910437f, 0.26293153f, 0.10444665f, 
    0.15590674f, 0.11763728f, -0.09380154f, -0.06491246f, -0.07674574f, -0.08251897f, -0.12807582f, -0.05360861f, 
    0.10790145f, -0.06910680f, 0.00669092f, 0.24606518f, -0.09799809f, -0.13778019f, -0.20370664f, -0.31628904f, 
    -0.06385818f, -0.04401052f, -0.05767195f, 0.16643530f, -0.03229253f, -0.05654201f, 0.02287852f, -0.11650668f, 
    -0.02309315f, -0.06593103f, 0.11139295f, -0.12804507f, -0.03443174f, -0.06920028f, 0.09314034f, 0.05552905f, 
    0.14179260f, 0.09160483f, 0.14297231f, 0.21535465f, -0.21744981f, 0.00110170f, 0.09481931f, -0.04504224f, 
    0.13303764f, 0.09455293f, -0.07787760f, -0.08069412f, 0.10025470f, -0.28436944f, 0.20503548f, 0.18711719f, 
    -0.23141107f, 0.11199051f, -0.14073133f, 0.59203500f, 0.15711595f, -0.02812470f, 0.19020766f, -0.12566507f, 
    0.06639885f, -0.07367357f, -0.26638147f, 0.00806351f, 0.26235691f, 0.02150323f, 0.26442471f, 0.17134373f, 
    0.00061070f, 0.05449118f, 0.23102574f, 0.07627286f, 0.08107351f, 0.09293745f, -0.26863226f, 0.12599058f, 
    0.03386194f, -0.14019990f, 0.09002350f, 0.11834805f, 0.21110678f, 0.16411389f, -0.35192937f, -0.15401934f, 
    0.16790979f, 0.00083594f, -0.08876032f, -0.17554036f, 0.20011663f, -0.12445655f, 0.03570674f, 0.08047529f, 
    -0.21367016f, 0.01913630f, 0.21924107f, -0.13894238f, -0.01588102f, 0.29367623f, -0.12691948f, 0.09022409f, 
    0.00264198f, -0.07924157f, -0.02468502f, -0.32665750f, -0.01547565f, 0.10841969f, -0.36126563f, 0.03840345f, 
    0.03427904f, -0.11755367f, -0.04860039f, 0.18318824f, 0.25656781f, -0.13980208f, 0.14736882f, 0.01814939f, 
    0.16503987f, 0.08631308f, 0.08941875f, 0.03515458f, -0.16037394f, -0.13257898f, 0.02203228f, -0.08171631f, 
    0.22389184f, -0.04812337f, 0.03496237f, -0.00625248f, -0.10635787f, 0.05900043f, -0.11757268f, 0.31865367f, 
    -0.00193123f, -0.07428856f, -0.14442010f, 0.19749777f, -0.29653594f, -0.03806850f, -0.09116512f, 0.04241896f, 
    0.14103933f, -0.12987381f, -0.17030330f, -0.01895862f, 0.30154464f, -0.03579248f, 0.12740408f, 0.13703801f, 
    0.19322941f, 0.10922065f, 0.05779135f, -0.39156911f, 0.14639735f, -0.07789536f, -0.36522517f, 0.05726617f, 
    0.05873560f, -0.02846876f, 0.04548101f, 0.06206203f, 0.24628381f, 0.16229016f, -0.00184535f, 0.05123039f, 
    0.09843209f, -0.02728192f, -0.35454232f, 0.24398290f, 0.20243593f, -0.13014710f, 0.46763739f, -0.00569889f, 
    -0.08881190f, 0.15665568f, 0.05671804f, -0.18999590f, -0.08901210f, -0.00392440f, 0.02775406f, -0.01003982f, 
    0.03077054f, -0.08080223f, 0.09444327f, 0.14346431f, -0.57072532f, -0.11527864f, 0.33146599f, 0.04363785f, 
    -0.00982056f, 0.18030787f, 0.32250404f, 0.09339176f, 0.02029032f, -0.25931555f, -0.07949217f, 0.22406481f, 
    -0.02186539f, -0.11218717f, 0.11072023f, -0.21012452f, 0.25004849f, 0.03248192f, -0.19581792f, -0.03827472f, 
    -0.16054222f, 0.10655762f, 0.15417887f, 0.22999847f, -0.17250864f, -0.24369444f, 0.11788488f, 0.07367681f, 
    0.11188158f, -0.08434208f, 0.00755997f, 0.37242249f, -0.29977727f, -0.16622426f, 0.00496855f, 0.30894235f, 
    0.26922032f, 0.08287147f, -0.17283104f, -0.01032529f, 0.15421607f, -0.06248481f, 0.34858495f, -0.11868433f, 
    -0.16407366f, 0.08046774f, 0.35923016f, 0.00264956f, -0.23406699f, -0.04763040f, -0.14881420f, 0.11294378f, 
    -0.01236057f, 0.02122916f, -0.07899834f, -0.03582691f, 0.26286942f, -0.18782420f, 0.18741798f, 0.03043585f, 
    0.19476831f, -0.12309653f, -0.07302270f, -0.15202621f, 0.09419460f, 0.02965705f, 0.39417520f, -0.01009274f, 
    0.24333170f, -0.00848110f, -0.03509242f, 0.04208924f, -0.11536101f, 0.44359523f, -0.39292288f, 0.23403965f, 
    -0.00523001f, 0.14858723f, 0.26713791f, 0.02539643f, -0.24156897f, -0.17440288f, -0.09407130f, 0.16880174f, 
    0.06759167f, 0.00006050f, 0.06407953f, 0.34991965f, -0.17281298f, 0.14574654f, 0.20133302f, 0.30153352f, 
    0.01142738f, -0.09478427f, -0.00810580f, 0.24615014f, 0.16247964f, -0.12120885f, -0.17634167f, -0.03166875f, 
    -0.11152053f, -0.02544004f, -0.38528073f, 0.16415274f, 0.13675439f, 0.29255113f, -0.12664716f, 0.12912986f, 
    0.05277667f, 0.12534568f, 0.26546037f, 0.17092001f, 0.10904133f, -0.15304898f, 0.02725937f, 0.09339026f, 
    -0.01007409f, -0.10578908f, 0.02887110f, 0.01812650f, 0.20098996f, -0.02643071f, -0.16079110f, -0.09905641f, 
    -0.10445458f, 0.17112385f, 0.07126402f, 0.20369798f, -0.17133500f, 0.04014724f, -0.27937692f, -0.13564299f, 
    0.27406266f, 0.08175547f, 0.14010327f, 0.01189516f, 0.35225952f, -0.02506038f, 0.09247719f, -0.19334430f, 
    0.17824093f, -0.07422805f, 0.07923119f, -0.34257185f, 0.01661875f, -0.16195147f, -0.28579286f, -0.13951220f, 
    0.15292421f, -0.16941889f, -0.03539199f, 0.38030052f, 0.09340396f, 0.13179797f, 0.25310987f, -0.01422065f, 
    -0.18886282f, 0.02856006f, 0.15685345f, 0.19528076f, -0.07047246f, -0.14349718f, 0.19595414f, -0.03068780f, 
    0.17189163f, -0.08833922f, -0.36093926f, -0.05770706f, 0.19689651f, 0.09658954f, -0.17884503f, -0.04264105f, 
    -0.11798630f, 0.03243568f, 0.17532104f, -0.05395642f, 0.29074627f, 0.16567247f, 0.01151600f, -0.12805828f, 
    -0.03014661f, -0.14322594f, -0.08241515f, 0.07058324f, -0.18661788f, 0.12543549f, 0.05412775f, -0.11207533f, 
    0.13047265f, 0.05121862f, 0.06931967f, 0.02766275f, 0.09466185f, 0.04064253f, -0.29996318f, -0.02344314f, 
    -0.10777460f, -0.02559373f, 0.16292171f, 0.03750403f, 0.08618717f, 0.16516490f, -0.05347059f, 0.14901435f, 
    -0.17565542f, 0.01819157f, 0.21114229f, -0.05513152f, 0.24705991f, 0.14858873f, -0.04312633f, -0.08617859f, 
    0.15058601f, -0.15311587f, -0.08374526f, -0.37413338f, -0.01802024f, 0.06859182f, -0.07290914f, -0.19937646f, 
    -0.04953954f, 0.01132541f, -0.11092471f, 0.17870116f, -0.17364544f, 0.09369573f, 0.12518376f, -0.00354614f, 
    0.09909404f, -0.05441577f, 0.27715254f, -0.05878401f, 0.07917664f, 0.30991080f, -0.09796412f, 0.07432923f, 
    -0.08540805f, -0.17441209f, 0.08045036f, -0.09738384f, 0.02961336f, 0.05262971f, -0.11377077f, 0.01093785f, 
    0.10227620f, -0.06101464f, -0.12478635f, 0.20520650f, 0.05734384f, -0.13536420f, -0.12534027f, 0.24549985f, 
    0.22849376f, -0.07273836f, 0.12085221f, -0.10086811f, -0.17472562f, -0.15342025f, 0.16367640f, -0.24153674f, 
    -0.06981257f, -0.11593140f, 0.18727522f, -0.13773291f, 0.08508075f, -0.28585535f, 0.16291888f, 0.29556623f, 
    -0.06477509f, -0.11188894f, -0.20133984f, 0.27031788f, 0.03742330f, -0.14308906f, 0.28461635f, -0.10971419f, 
    -0.10445531f, 0.05606174f, 0.14400843f, -0.40029839f, -0.03405034f, -0.08454063f, 0.24629414f, -0.06772048f, 
    0.16504805f, -0.06858957f, -0.13501918f, 0.01294945f, -0.21855007f, 0.15711725f, -0.13327490f, -0.16070294f, 
    0.17868319f, -0.16895176f, 0.06680081f, -0.11985385f, 0.20980328f, -0.02682332f, -0.14010604f, 0.28648478f, 
    -0.14716905f, 0.03238292f, 0.12790999f, 0.07867923f, 0.33205625f, -0.07874129f, 0.17836496f, 0.00471104f, 
    -0.16455574f, 0.16622387f, -0.08664821f, -0.06910153f, 0.08182883f, -0.17190127f, 0.08720896f, 0.10825740f, 
    -0.15241721f, -0.04270059f, -0.10207169f, 0.30350462f, -0.19110113f, 0.01463066f, 0.21464030f, -0.27558726f, 
    0.00061528f, -0.10026202f, 0.06141010f, 0.06807889f, 0.17669812f, -0.00539581f, -0.18502919f, 0.22443523f, 
    0.14689797f, 0.01900617f, -0.06279656f, -0.22458835f, -0.33034599f, -0.14160652f, 0.04545221f, -0.07707155f, 
    -0.07425611f, 0.12055698f, -0.11029480f, 0.14886273f, 0.14615767f, -0.10316932f, -0.08473456f, -0.15325943f, 
    0.00716932f, 0.16579439f, -0.04418015f, -0.14034858f, 0.07738493f, -0.00634588f, -0.07257314f, -0.15545848f, 
    0.09399420f, -0.06442399f, -0.25307447f, -0.16541059f, -0.13765556f, -0.08693910f, 0.09258296f, -0.34018826f, 
    -0.13329768f, 0.04257992f, -0.05030832f, -0.11217815f, 0.27838576f, -0.13426980f, 0.20548673f, -0.11525359f, 
    -0.04060679f, -0.05295084f, -0.09108816f, 0.19900422f, -0.29350185f, -0.08217613f, 0.03771413f, -0.26662633f, 
    0.20184724f, -0.07700523f, 0.15360372f, 0.02946085f, 0.03572778f, -0.04791655f, -0.14637049f, 0.28468323f, 
    0.25792310f, 0.05931691f, -0.00368044f, -0.04035023f, -0.34986031f, 0.02707309f, 0.27091253f, 0.11002954f, 
    0.08666858f, 0.08171489f, 0.17299786f, 0.16522413f, 0.36403942f, -0.04056238f, 0.11113477f, 0.05567259f, 
    0.04866887f, 0.12898082f, 0.13456880f, 0.36270657f, 0.13600312f, 0.20185803f, -0.21291412f, 0.10974732f, 
    0.29431686f, -0.03096448f, -0.00607474f, -0.02326121f, -0.09815664f, 0.13343446f, -0.23063502f, -0.23588908f, 
    -0.25295305f, -0.13057739f, -0.04331554f, 0.03038210f, 0.04841429f, 0.13366637f, 0.07030567f, 0.18647355f, 
    -0.00146218f, 0.10952698f, 0.20814674f, 0.10435954f, 0.09653049f, -0.15316528f, -0.22123088f, -0.00298148f, 
    -0.13476886f, 0.02778268f, -0.07278223f, 0.05357943f, -0.02438631f, -0.26707402f, -0.00374138f, -0.14043318f, 
    0.32544300f, 0.05416527f, -0.11926108f, -0.31353009f, -0.10979715f, -0.01246302f, 0.07103234f, -0.01372588f, 
    0.05364672f, 0.03836756f, 0.11116360f, 0.15526296f, 0.20407845f, 0.22505754f, 0.09404427f, 0.02767346f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.23849443f, 0.04577664f, 0.05529835f, 0.09767185f, 0.12460891f, 0.13403779f, -0.20450015f, -0.05306626f, 
    0.08348104f, 0.02301579f, -0.01919453f, 0.25394249f, -0.08123233f, 0.15147051f, -0.10873391f, 0.09534677f, 
    0.04961864f, -0.06728402f, -0.13320547f, -0.05877124f, 0.05444544f, -0.16494837f, 0.22766337f, -0.23870201f, 
    -0.04050830f, 0.03085726f, 0.10652198f, -0.10174622f, 0.08165341f, -0.06124841f, -0.11584257f, 0.12182187f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.28558427f, 0.08030118f, 0.17829695f, -0.22915427f, -0.02059708f, -0.39345437f, 0.17616779f, 0.11791065f, 
    -0.11619080f, -0.32039371f, 0.12452672f, -0.48870078f, 0.10634980f, -0.23653600f, 0.23864682f, -0.19782025f, 
    0.03743901f, -0.54418409f, -0.42709282f, 0.01417990f, 0.08107408f, -0.13047807f, -0.08433532f, 0.17647581f, 
    0.07579054f, -0.30479294f, -0.23373109f, -0.22186698f, -0.06977876f, 0.08160901f, 0.13087042f, -0.11551220f, 
    0.19871634f, -0.23192891f, -0.69544953f, 0.04637129f, 0.28897926f, -0.35089612f, 0.16095246f, -0.02423494f, 
    -0.11968336f, -0.02088862f, 0.11767436f, -0.22032452f, -0.01672030f, 0.16342911f, 0.17965040f, 0.15093002f, 
    -0.22852249f, -0.23640296f, 0.13314860f, 0.03434941f, 0.13893071f, -0.05767835f, 0.26199648f, -0.07161710f, 
    -0.03408782f, 0.25265819f, -0.17554627f, 0.24273287f, -0.15417401f, -0.37423837f, 0.21028896f, 0.05763428f, 
    0.14901857f, 0.12955733f, -0.21761703f, 0.10756423f, 0.13742037f, 0.24655810f, -0.15694879f, 0.09622451f, 
    -0.15170866f, -0.04387159f, 0.02280961f, 0.26144192f, 0.18878137f, -0.15264922f, -0.22313258f, -0.10052875f, 
    0.04139786f, 0.25695783f, -0.02185198f, -0.37676898f, -0.16004060f, -0.31034115f, -0.45077437f, -0.18479793f, 
    -0.57277149f, 0.23670323f, 0.07060313f, -0.21190621f, -0.05120797f, 0.23655754f, 0.05788902f, -0.06409483f, 
    0.10698862f, 0.20407745f, 0.13028865f, 0.12740014f, -0.58648813f, -0.01953360f, 0.07191410f, -0.27672422f, 
    -0.08769520f, -0.17950605f, -0.15604125f, 0.04544672f, -0.12499996f, -0.37378043f, 0.00747172f, -0.24413639f, 
    -0.52983171f, 0.13163593f, -0.03745821f, 0.04704823f, -0.26776510f, -0.27108005f, -0.30176240f, 0.07300396f, 
    0.12694937f, 0.05957390f, 0.06358997f, 0.14257976f, -0.32954019f, 0.20126410f, 0.06229042f, 0.05149493f, 
    -0.14865588f, 0.21533719f, 0.01432519f, -0.38688931f, 0.01969248f, 0.13606390f, 0.21323596f, -0.10095442f, 
    -0.08820576f, -0.17624326f, -0.10914429f, -0.00654956f, -0.19510753f, -0.25654405f, 0.16692154f, 0.25103369f, 
    0.08660921f, -0.17428282f, 0.14447907f, 0.04980666f, -0.21725018f, 0.24993554f, 0.17277150f, -0.10341269f, 
    0.17141612f, 0.01431966f, -0.24731921f, -0.26390821f, 0.13909629f, -0.09011464f, -0.02804253f, 0.24001624f, 
    -0.20023353f, 0.25877300f, 0.11045328f, -0.03431435f, 0.08055768f, -0.29362008f, -0.13710716f, -0.01129755f, 
    -0.09178007f, 0.07474463f, 0.25657567f, 0.09433321f, -0.38119823f, 0.04880938f, 0.10604787f, -0.18652438f, 
    0.34062737f, -0.19549395f, -0.22578582f, 0.16351359f, 0.15627880f, -0.13920131f, 0.05487304f, -0.06822143f, 
    -0.02767817f, -0.03824193f, 0.15907192f, -0.13177657f, -0.30655426f, -0.28076303f, -0.05552331f, 0.22905564f, 
    -0.42338321f, -0.42758977f, 0.15389417f, -0.30676773f, 0.20872732f, 0.31361645f, 0.17606764f, 0.02250990f, 
    -0.06285749f, -0.10310536f, 0.05695516f, 0.18751310f, -0.13039528f, 0.29153377f, -0.06611505f, -0.61230338f, 
    -0.30576065f, 0.06637102f, 0.18558703f, -0.30940199f, 0.15419726f, -0.01412358f, 0.12877861f, -0.23783411f, 
    -0.23408428f, -0.22775528f, -0.12242922f, -0.09927732f, 0.05291911f, 0.10574857f, -0.51039433f, -0.82919019f, 
    -0.14801641f, 0.34120616f, 0.11784469f, 0.10792589f, -0.28120646f, 0.13823275f, -0.39409268f, 0.00179126f, 
    -0.18677750f, -0.35531104f, -0.20851457f, 0.27538270f, 0.14953856f, -0.05059209f, 0.03984710f, 0.13397250f, 
    0.03635265f, -0.21419959f, 0.14582671f, 0.27450395f, 0.02576516f, -0.24100928f, 0.24875733f, -0.37894613f, 
    -0.05724428f, -0.07518767f, -0.15960266f, -0.20203415f, 0.11499242f, -0.02130286f, -0.53450781f, 0.09382323f, 
    -0.15901394f, -0.25434741f, -0.04103008f, 0.35102132f, -0.36935973f, 0.01459100f, -0.64485162f, -0.22763239f, 
    0.34513307f, 0.04832040f, 0.19286868f, -0.06548793f, 0.13608700f, 0.20798606f, -0.37013134f, -0.01451124f, 
    0.10516668f, 0.28738797f, -0.20651177f, 0.21656497f, 0.17906238f, -0.12566674f, -0.04952941f, -0.52628928f, 
    0.03902856f, 0.10456684f, 0.18832622f, 0.07658812f, -0.42806807f, -0.33734423f, -0.19331294f, -0.36788672f, 
    -0.36515746f, 0.07022535f, 0.04545673f, -0.58564430f, 0.11718132f, 0.30635598f, -0.09919830f, -0.22564371f, 
    0.03577064f, 0.00932966f, -0.38462964f, -0.03521989f, -0.19208321f, -0.18971007f, -0.40457705f, 0.03234472f, 
    0.08964741f, -0.45980835f, 0.31648454f, -0.22794409f, 0.26963201f, 0.05503484f, 0.12693557f, 0.20542577f, 
    -0.45681283f, 0.08711421f, -0.15561944f, -0.28482214f, -0.38710541f, 0.24874264f, 0.20188354f, 0.02127453f, 
    0.02149576f, -0.14671671f, -0.25900963f, 0.31695363f, 0.01647569f, 0.06194665f, -0.16639176f, -0.22231311f, 
    -0.14826992f, -0.09673254f, 0.32169154f, -0.26184180f, -0.00687529f, -0.34288105f, -0.15604860f, -0.41945472f, 
    0.06722721f, 0.35435736f, -0.24481720f, -0.55391127f, -0.38849828f, 0.15870562f, -0.10226960f, 0.19209194f, 
    0.09336111f, -0.08764345f, 0.29339844f, 0.19227284f, -0.18701699f, -0.08834013f, 0.29692838f, -0.21079294f, 
    -0.28948417f, -0.27687016f, 0.16677143f, -0.23954402f, 0.03172150f, -0.30133405f, 0.21091883f, -0.58168977f, 
    -0.15607706f, 0.05729389f, -0.46698838f, -0.12957461f, -0.19641519f, 0.19484271f, -0.19771262f, -0.26597828f, 
    -0.26913157f, 0.20554298f, 0.24293244f, -0.09830515f, -0.47608960f, 0.20540194f, -0.12348345f, -0.19869021f, 
    0.27443725f, -0.06677306f, 0.26885754f, 0.19992328f, -0.40467384f, 0.08414844f, -0.24228635f, 0.19337788f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.08759709f, -0.10980695f, 0.10984253f, -0.05403670f, 0.03745828f, 0.03312843f, 0.08575714f, 0.03855233f, 
    0.21354312f, -0.10654801f, 0.13118577f, 0.15333553f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
