#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.80740035f, 1.12405360f, 0.90528607f, 0.39591569f, 0.05040232f, -0.39846647f, 0.27747586f, -0.46323526f, 
    -0.31755418f, 0.56011719f, 0.33533338f, 0.45539007f, 0.04093546f, 0.02812070f, 0.04857692f, 0.00520391f, 
    0.05548033f, 0.45272866f, -0.05333208f, -0.30576211f, -0.01091924f, 0.16300336f, -0.15342125f, -0.06950032f, 
    0.32404390f, -1.15541518f, 0.14851172f, -0.39527997f, -0.72865880f, -0.23452961f, 0.36542034f, 1.23400068f, 
    0.18171327f, 0.50521439f, 0.54487944f, -0.21740840f, -0.34207839f, -0.10779954f, -0.42709038f, -0.03070760f, 
    0.01698261f, -0.23304151f, 0.02022479f, 0.14770396f, -0.08547498f, 0.12971553f, -0.20102501f, -0.04263137f, 
    0.12556435f, 0.20960601f, 0.91076803f, 0.21701312f, -0.22853218f, -0.80587465f, -0.45620093f, 0.63244432f, 
    0.54561448f, -0.48384607f, -0.19206734f, -0.52696794f, -0.12686960f, 0.27802026f, -0.30618605f, 0.06276464f, 
    0.13456744f, 0.27017546f, 0.19124851f, 0.21045475f, 0.42978033f, 0.11707635f, 0.12557046f, -0.12511005f, 
    -0.14470796f, 0.02038874f, 0.08104084f, -0.21458916f, -0.48615378f, 0.32630071f, 0.62455267f, -0.14400238f, 
    -0.21422894f, 0.61649936f, 0.71061993f, -0.61959529f, 0.67599392f, -0.47304139f, 0.20480897f, 0.10133371f, 
    -0.03195353f, -0.07990809f, -0.46506792f, -0.28754234f, 0.09437680f, 0.25904742f, -0.34320351f, 0.06130610f, 
    -0.08156525f, -0.20045716f, 0.42700604f, -0.12570904f, -0.03068400f, -0.52174962f, -0.62198853f, -0.81455600f, 
    -0.62891322f, 0.21610436f, -0.10254032f, -0.22555195f, -0.15196979f, 0.32710072f, -0.14860001f, -0.18778220f, 
    -0.40350223f, -0.41948199f, -0.68454677f, 0.17175953f, -0.04227599f, 0.60137624f, -0.38948452f, 0.07996548f, 
    0.05552628f, 0.16210696f, -0.31542760f, 0.15202297f, 0.14679599f, -1.08905554f, 1.15146291f, 0.16479914f, 
    -0.68959337f, 0.22314100f, -0.89874697f, 0.09776070f, 0.45711201f, -0.04575259f, -0.46167669f, 0.33872542f, 
    -0.19184253f, 0.05829399f, 0.17776880f, -0.03139026f, -0.01705056f, -0.02297596f, 0.21523115f, 0.03593604f, 
    -0.03568678f, 0.07634626f, 0.03517078f, 0.25401956f, 0.19622351f, 0.24167888f, 0.76270497f, 0.36347976f, 
    -0.22879368f, -0.00562208f, 0.23133251f, -0.79979551f, -0.67024922f, -0.55754334f, -0.02862344f, -0.36120832f, 
    -0.31627259f, -0.17673728f, 0.30495584f, 0.33882514f, -0.15114342f, 0.09287310f, -0.02283908f, -0.08140022f, 
    0.04873179f, -0.00428174f, -0.03518203f, 0.31901193f, 0.33107871f, 0.26824480f, -0.13623746f, -0.90233278f, 
    -1.49997103f, -0.47046494f, 0.19542043f, 0.34468675f, 0.79795098f, 0.71066362f, 0.36541745f, 0.51158905f, 
    0.17898826f, 0.14256176f, 0.51689875f, 0.05243007f, 0.33667389f, 0.11573785f, -0.01682122f, 0.39737523f, 
    0.10099775f, -0.04239276f, 0.13759629f, -0.06079518f, -0.10689995f, 0.02437076f, -0.11104482f, 0.03486115f, 
    -0.35655811f, -1.04910576f, 0.04078878f, 0.71366864f, 0.25754303f, -0.99578005f, 0.14000672f, 0.47428665f, 
    -0.81750846f, -0.04993108f, 0.39686039f, 0.43723384f, -0.07874767f, 0.06831362f, 0.08291365f, 0.27762845f, 
    0.39812750f, 0.03707442f, 0.02697096f, 0.10932352f, 0.23138958f, -0.04642874f, 0.21488886f, 0.01752298f, 
    -0.17262717f, 1.35421395f, 0.58916384f, 0.42446047f, 0.85752106f, 0.88173372f, 0.88191009f, 0.04638008f, 
    -0.23554218f, 0.33682093f, -0.13084275f, -0.17415558f, 0.18846634f, -0.21315394f, 0.05658365f, -0.17653742f, 
    -0.16538952f, -0.08008509f, 0.09385402f, -0.01280554f, -0.34102011f, -0.00756294f, 0.35027340f, 0.13281123f, 
    -0.05971511f, 0.14730233f, -0.08572508f, -0.52423763f, -1.01011550f, -0.50385612f, 0.05790383f, 0.20078211f, 
    -0.37923777f, 0.04012904f, 0.70953101f, -0.30727455f, -0.59722555f, -0.16073182f, 0.41891369f, 0.12996139f, 
    -0.54460078f, -0.13796894f, 0.06128020f, -0.06316886f, -0.34933051f, -0.19986403f, -0.15106249f, -0.19628958f, 
    0.33899423f, 0.04251869f, 0.02014900f, 0.40213436f, -0.29597446f, -0.39636368f, 1.05678785f, 0.55871361f, 
    0.40071103f, 1.02247655f, 0.29956442f, 0.49516112f, -0.13626422f, -0.04026181f, -0.23230025f, -0.47027165f, 
    -0.34679052f, -0.35308394f, -0.27493036f, -0.36883187f, -0.12069928f, -0.20900649f, -0.40448651f, 0.10275666f, 
    -0.11328531f, -0.22221002f, -0.15973042f, -0.09835983f, 0.95583469f, 0.52157223f, 0.72582394f, 0.58194947f, 
    -0.59399748f, -0.53066081f, -1.03279805f, 0.17297155f, -0.00523678f, 0.41803902f, -0.02350002f, 0.15624166f, 
    -0.11549640f, 0.06454895f, 0.15674612f, 0.01335632f, -0.19431987f, 0.06621568f, -0.25398633f, 0.40461755f, 
    0.31164476f, 0.14812844f, -0.03717687f, -0.14635295f, -0.17264287f, 0.53829992f, 0.90144581f, -0.68174571f, 
    -0.89540797f, -0.84273958f, 0.34604660f, -0.36707017f, 0.21176256f, 0.32706779f, -0.27846789f, 0.27252343f, 
    0.09487957f, 0.08364929f, 0.16490024f, -0.13033070f, 0.14364277f, 0.17684181f, -0.28883880f, -0.01979702f, 
    -0.29165310f, -0.36445960f, -0.24688776f, 0.17447175f, -0.13550714f, 0.04151946f, 1.06804013f, -0.06939922f, 
    -0.78926218f, 1.07006574f, 0.52343637f, -0.33735415f, -0.09221960f, -0.37709355f, -0.21247475f, 0.32662675f, 
    -0.02611841f, 0.23891950f, -0.18743919f, 0.25097799f, -0.12136669f, 0.09082013f, -0.21445982f, -0.15945888f, 
    -0.01364324f, -0.07884474f, -0.16435722f, -0.16932732f, -0.21934922f, -0.19923188f, 0.00161373f, -0.66009390f, 
    1.06423533f, 0.05533176f, -0.99820888f, 0.73831111f, 0.39480251f, -0.43656945f, -0.86496741f, -0.71692306f, 
    -0.67535061f, 0.07086175f, 0.20994033f, -0.07478422f, -0.04642137f, -0.02866295f, -0.06649050f, 0.16256447f, 
    -0.30260772f, -0.08967164f, 0.20068423f, 0.17280602f, -0.09398294f, 0.29121301f, -0.06706301f, -0.18609659f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.32003233f, 0.10205798f, 0.18817866f, 0.22611500f, -0.06480425f, 0.31838852f, 0.17197733f, 0.41053757f, 
    0.17157087f, 0.18862069f, 0.19658819f, -0.15436801f, 0.30800995f, 0.01144085f, -0.09052952f, 0.18784463f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.26893130f, 0.14807875f, 0.04013823f, 0.00489709f, 0.04708035f, 0.19799973f, 0.02810553f, -0.04981581f, 
    0.00450395f, -0.07079969f, 0.04886802f, 0.07408255f, 0.45156017f, 0.33405256f, 0.06454352f, -0.12787369f, 
    0.07026332f, -0.09235237f, -0.23539320f, 0.22940047f, 0.17715052f, 0.02285671f, -0.15867883f, -0.12217492f, 
    0.27147821f, 0.14921053f, 0.36333957f, -0.39328218f, 0.13778816f, 0.03893636f, 0.02434822f, 0.03200549f, 
    0.00148777f, 0.01040690f, -0.01419241f, 0.08465195f, 0.04584898f, 0.10875878f, -0.09380431f, 0.20007420f, 
    0.00815773f, 0.09778064f, -0.01872782f, 0.04954166f, -0.01498922f, -0.06670171f, -0.05300166f, -0.30697277f, 
    -0.11179296f, -0.03195512f, 0.25291258f, -0.03363938f, 0.07972273f, 0.04952313f, -0.00251914f, 0.29112056f, 
    0.09677014f, -0.33827561f, -0.13996179f, -0.23195408f, -0.05905307f, -0.02811053f, -0.26041323f, -0.37007222f, 
    0.08979194f, 0.21021980f, 0.01415662f, -0.06209000f, -0.03705581f, -0.05026147f, 0.32336554f, 0.17846380f, 
    -0.04470176f, -0.55511290f, 0.02927397f, -0.19956914f, -0.10122505f, -0.05323697f, 0.23392306f, 0.00922049f, 
    -0.01584833f, -0.15201527f, -0.04758953f, -0.05850295f, 0.52895606f, 0.41826236f, 0.04924175f, 0.01482135f, 
    -0.08267649f, -0.11534286f, -0.08292820f, 0.04348082f, 0.02220977f, -0.13861179f, 0.05981449f, 0.10058726f, 
    0.12318572f, -0.11152709f, -0.17946805f, 0.17804277f, -0.16457793f, 0.02032546f, -0.00767410f, 0.03712549f, 
    0.10871555f, -0.04089991f, 0.15209259f, 0.38951379f, 0.45126435f, -0.09583084f, 0.21072470f, 0.57403159f, 
    0.19925925f, 0.02601238f, -0.02647603f, -0.12068430f, 0.00229818f, -0.02489311f, 0.08481798f, 0.07792097f, 
    -0.24746792f, -0.14731972f, 0.13791175f, -0.12126164f, -0.04930352f, -0.03762978f, 0.01708652f, 0.19770940f, 
    -0.07132301f, -0.30229673f, 0.05963272f, -0.21771815f, 0.13732876f, 0.21459171f, 0.00254854f, 0.35054877f, 
    0.14749706f, 0.06476015f, -0.19301704f, 0.11578470f, 0.02027874f, 0.24506375f, 0.00851657f, -0.20416607f, 
    0.00550362f, -0.13895468f, -0.14608780f, 0.07502142f, 0.05973684f, 0.01305707f, -0.03328456f, -0.10884676f, 
    -0.03441722f, 0.01083145f, -0.07436325f, 0.05515851f, 0.09708697f, 0.12426507f, 0.09413773f, -0.65984589f, 
    -0.23778382f, -0.23616605f, 0.06797345f, 0.24492030f, -0.15416741f, -0.14579299f, -0.14113641f, -0.07970200f, 
    0.06320484f, -0.27664354f, -0.00553342f, 0.15182382f, 0.00036390f, -0.12683621f, -0.25500089f, 0.10865969f, 
    0.09506448f, 0.01210755f, -0.14601794f, -0.02987711f, -0.36712530f, -0.00856262f, -0.07906485f, -0.50235045f, 
    0.03996303f, 0.01069977f, 0.04209242f, -0.17000127f, 0.08717085f, 0.32155973f, 0.02271547f, -0.17298222f, 
    0.09591891f, 0.07936729f, -0.10174707f, -0.12229836f, 0.23955771f, 0.00103014f, -0.03608868f, -0.11192141f, 
    -0.09559673f, 0.01027004f, 0.18045801f, 0.02681233f, 0.22368300f, -0.27420187f, -0.10551888f, -0.47297621f, 
    -0.01885467f, 0.01321079f, 0.05066151f, -0.01674373f, 0.20765553f, 0.03217924f, -0.02908906f, -0.04733660f, 
    0.01722248f, 0.10649711f, -0.31690219f, 0.36766386f, -0.07252546f, 0.08843224f, -0.07108380f, 0.13291672f, 
    0.12001809f, 0.03161710f, 0.14004681f, 0.03023030f, 0.43171519f, -0.15771617f, 0.05871220f, 0.02406172f, 
    -0.06446302f, 0.17967267f, 0.03444768f, -0.16347533f, 0.16466086f, -0.06897800f, 0.00036776f, -0.01772271f, 
    0.13283776f, 0.02947969f, -0.40398788f, -0.33726180f, 0.04781723f, 0.36124322f, 0.13764523f, 0.02013114f, 
    0.08589353f, -0.16738003f, -0.07601390f, -0.14517078f, 0.08833261f, -0.65980691f, 0.45125520f, 0.07859381f, 
    -0.16836238f, 0.08394937f, -0.00749413f, 0.10312916f, 0.18682981f, -0.00561393f, 0.10600237f, -0.08208408f, 
    -0.12840925f, -0.01997108f, 0.26722416f, -0.14923760f, -0.12814617f, 0.05663101f, -0.02588232f, 0.12961510f, 
    -0.09552900f, -0.20805351f, 0.10476115f, 0.24430527f, 0.26955155f, -0.20516416f, -0.08568574f, -0.00490719f, 
    0.12550542f, 0.12708861f, 0.09547789f, -0.00363514f, 0.06917758f, 0.02104416f, 0.06024196f, 0.12712948f, 
    0.07554372f, 0.00202913f, 0.08909050f, -0.16326542f, 0.16051710f, -0.03035525f, 0.15159896f, 0.12121617f, 
    0.26177424f, 0.06899843f, 0.13031326f, 0.11946120f, -0.52093339f, 0.19459103f, 0.04430628f, -0.25698179f, 
    0.05234481f, 0.04250620f, 0.04863496f, -0.05438524f, -0.08962609f, -0.03726011f, 0.07837869f, -0.01824525f, 
    0.05638887f, -0.07430090f, 0.31327921f, -0.22995672f, 0.06273670f, 0.28143200f, -0.03774309f, 0.12776306f, 
    0.04564514f, -0.04981918f, 0.15140207f, -0.02011941f, -0.22059037f, 0.27240628f, 0.22038999f, 0.13543680f, 
    -0.11795352f, -0.11351142f, -0.21974082f, -0.08367708f, -0.00224292f, -0.14993924f, -0.02890438f, -0.17085171f, 
    0.04608851f, 0.49726096f, -0.04799156f, -0.10367841f, 0.32669523f, -0.02016084f, 0.02002807f, 0.01145021f, 
    -0.17230661f, 0.05850103f, -0.00325604f, 0.08076278f, -0.21036078f, 0.12540054f, 0.34713671f, 0.14245161f, 
    0.03699994f, -0.10210421f, -0.10384458f, 0.09161820f, 0.12060715f, -0.18027540f, -0.22987846f, 0.09080423f, 
    -0.46843112f, 0.22224367f, 0.23306125f, -0.20930140f, -0.15134887f, -0.19699226f, -0.13109630f, 0.05325477f, 
    0.06484848f, -0.15433282f, 0.07983569f, 0.08677939f, 0.00032250f, -0.08051568f, -0.01089222f, -0.05780480f, 
    -0.01263383f, -0.11433305f, 0.02857824f, 0.19383915f, 0.11395479f, 0.08538911f, -0.05372177f, 0.12742107f, 
    0.47529152f, 0.36333206f, 0.28692961f, -0.01226932f, -0.05422083f, -0.01920749f, 0.08845150f, 0.03160969f, 
    0.01884035f, 0.10670514f, 0.01835947f, -0.00341894f, -0.21863182f, -0.40533099f, -0.14987679f, 0.10215912f, 
    -0.00626177f, 0.01295627f, -0.12339924f, 0.12118121f, -0.08975739f, 0.01326121f, 0.07228714f, 0.15367790f, 
    0.04291101f, -0.20058218f, -0.01365736f, 0.18895367f, 0.17554431f, 0.02507425f, 0.06031044f, 0.04060213f, 
    -0.11407794f, -0.10744189f, -0.07482233f, -0.14114030f, 0.15347552f, -0.12982027f, 0.12323343f, 0.23921572f, 
    -0.01914058f, 0.19958344f, 0.11370470f, 0.00937513f, 0.09086405f, 0.06783342f, 0.09181333f, 0.29591966f, 
    -0.16610317f, -0.13987477f, -0.11571608f, -0.21788199f, -0.18669032f, -0.05435305f, 0.12969218f, -0.08875564f, 
    0.02524157f, 0.15067060f, 0.13704707f, 0.15022980f, -0.01793806f, -0.08708812f, -0.18369460f, -0.14113238f, 
    -0.03083855f, 0.15545747f, 0.06323000f, 0.00696390f, -0.14285052f, -0.11169238f, -0.04011243f, -0.02532616f, 
    -0.17955878f, 0.23795012f, -0.41447333f, -0.19055519f, 0.15995884f, 0.08219555f, -0.00468097f, -0.12433650f, 
    -0.11633652f, -0.02101571f, -0.20639020f, 0.09585274f, 0.51607215f, -0.32423997f, -0.11304762f, 0.15299790f, 
    0.00058418f, -0.04894041f, 0.01104146f, 0.20631900f, -0.00266016f, 0.05294213f, -0.08063160f, -0.12032022f, 
    0.10957304f, 0.09804145f, -0.16800353f, 0.11207913f, -0.00767668f, 0.01908071f, -0.00562688f, 0.08124036f, 
    -0.16968888f, 0.00555300f, 0.05147059f, -0.26878804f, -0.01513773f, 0.37422845f, 0.10919002f, -0.11549277f, 
    0.09823741f, -0.12266981f, -0.00572954f, 0.15983142f, 0.10241582f, 0.01202753f, 0.05045180f, -0.03490264f, 
    -0.31374502f, -0.24720527f, 0.00696321f, 0.02188383f, 0.09178028f, -0.25841346f, -0.07483762f, 0.04619655f, 
    0.18325113f, 0.13498536f, -0.10764863f, 0.18474996f, 0.07969569f, -0.40811470f, -0.00721923f, -0.05040414f, 
    0.22465980f, 0.01378401f, 0.14469723f, 0.21519880f, -0.01210762f, 0.16678101f, 0.23700976f, 0.23492762f, 
    0.05707318f, 0.25350320f, 0.13113225f, -0.03143053f, -0.05672103f, 0.14266053f, 0.21897440f, -0.03755822f, 
    0.04481445f, -0.09058920f, -0.00872740f, 0.02355528f, 0.03485632f, -0.15140259f, 0.10856397f, 0.22961852f, 
    -0.02331648f, 0.19103026f, 0.09281760f, 0.03847545f, 0.14681253f, 0.11525830f, 0.31039536f, 0.04321773f, 
    0.16146113f, 0.35682869f, 0.04219579f, -0.23649617f, 0.00089412f, 0.10614264f, 0.07337615f, -0.14532784f, 
    0.11892285f, 0.23688643f, 0.09581478f, 0.07910134f, 0.08712756f, -0.22307293f, -0.20167291f, -0.10662333f, 
    0.00001219f, -0.00132178f, -0.02414355f, -0.01296427f, -0.04831462f, -0.02087164f, 0.09956810f, -0.00082434f, 
    0.02770852f, -0.22424179f, -0.02219938f, 0.04052615f, 0.18273611f, 0.01356487f, -0.03122414f, 0.05706518f, 
    0.15181194f, -0.05660935f, -0.01563632f, 0.19894157f, -0.52753961f, -0.05111147f, -0.08965731f, 0.22907546f, 
    0.05359951f, 0.06634875f, 0.13599499f, -0.09094284f, -0.09113793f, -0.04221187f, 0.05123493f, -0.07327732f, 
    0.04101714f, 0.02611206f, -0.11811716f, 0.15613000f, -0.04163276f, -0.05052336f, 0.09736615f, -0.17547360f, 
    0.00569824f, 0.01578132f, 0.11025042f, -0.07688443f, -0.03026992f, 0.09981812f, 0.04648304f, -0.48793611f, 
    0.12435348f, -0.29739007f, 0.05882701f, 0.08565909f, -0.22669655f, -0.06276622f, 0.08282256f, -0.18559569f, 
    0.07063083f, -0.00658438f, -0.03896213f, 0.35468981f, 0.11945357f, -0.11186398f, -0.01177454f, 0.07634888f, 
    0.10393398f, 0.04720347f, -0.05697060f, -0.00355303f, 0.16254571f, 0.11299381f, 0.41035748f, 0.45546079f, 
    -0.14899515f, -0.17874293f, -0.03789309f, -0.13959627f, 0.05255431f, 0.21336481f, -0.09674913f, -0.04015746f, 
    0.13808325f, 0.13515887f, -0.19244750f, 0.38017792f, -0.09789100f, -0.11013072f, -0.07141490f, -0.04418043f, 
    0.16456833f, 0.06271896f, 0.11644053f, 0.01483219f, -0.85767400f, 0.08390398f, 0.13434137f, 0.01964716f, 
    0.05066609f, -0.02164574f, -0.08748174f, -0.24188580f, 0.03262166f, 0.01469795f, -0.00425085f, 0.01894029f, 
    -0.50536281f, 0.05682307f, 0.16127396f, -0.30945298f, -0.03926677f, -0.17591935f, 0.12871902f, -0.09482547f, 
    0.07896470f, 0.13353567f, -0.18086320f, 0.05918647f, 0.07518440f, -0.00577527f, -0.11324918f, 0.11752263f, 
    0.05395323f, 0.18343024f, 0.15293279f, 0.03874047f, 0.08940659f, 0.00805665f, -0.15052134f, 0.15484549f, 
    0.09454863f, -0.08116055f, -0.21512465f, 0.13139446f, 0.00195480f, 0.01852275f, 0.03956072f, -0.08466223f, 
    -0.01080879f, -0.01004476f, 0.21055236f, 0.01590117f, 0.23022468f, 0.13044682f, 0.08730689f, -0.20403534f, 
    -0.06847749f, -0.15277089f, 0.03172257f, -0.17356716f, 0.05500044f, -0.07147820f, -0.03203797f, -0.03524374f, 
    0.19063437f, -0.19311172f, 0.11209084f, -0.03310644f, 0.00230517f, 0.14563780f, 0.01137149f, 0.05560199f, 
    0.16259930f, 0.13699587f, 0.02636874f, -0.01253647f, 0.21716274f, 0.35928422f, -0.31870487f, 0.30221003f, 
    0.13104632f, 0.15047434f, -0.09304609f, -0.15943927f, -0.02149597f, 0.03080885f, -0.03147408f, 0.07185112f, 
    -0.22006325f, 0.25593424f, -0.07927878f, 0.19017535f, 0.24218254f, 0.04102590f, 0.27272633f, 0.04313961f, 
    -0.05666390f, -0.07788136f, 0.09984281f, 0.11047983f, -0.01873156f, 0.08154640f, 0.21291591f, 0.63977605f, 
    -0.02044264f, 0.04283353f, 0.03320497f, 0.04894383f, -0.11799882f, -0.04251530f, 0.01647920f, 0.10224096f, 
    -0.69921857f, 0.02836890f, -0.10838506f, 0.39700624f, -0.02576759f, 0.06849959f, -0.01670026f, -0.03035570f, 
    0.04833611f, 0.00605606f, -0.01541170f, 0.04327616f, 0.26816994f, 0.43654239f, -0.09443218f, -0.14273980f, 
    -0.00395979f, -0.04498511f, 0.06879443f, -0.08279169f, 0.08266015f, 0.04733912f, -0.10150839f, 0.14321807f, 
    0.02941515f, -0.04173754f, 0.13397598f, -0.21715906f, -0.11666479f, 0.16970573f, -0.00392527f, 0.15554430f, 
    0.08020446f, 0.02133087f, 0.12060845f, 0.13502096f, -0.08557604f, 0.04594904f, 0.01508525f, 0.09647375f, 
    0.03948436f, 0.02062387f, -0.06805684f, 0.00165663f, 0.09667385f, 0.04114563f, 0.03071779f, -0.03529753f, 
    -0.30384606f, -0.04915216f, 0.14043084f, -0.04414036f, -0.10764042f, -0.00547401f, -0.11992166f, 0.20544556f, 
    0.02487454f, 0.02530568f, 0.09160999f, 0.08197001f, -0.21274929f, 0.50990373f, 0.21229516f, -0.00901101f, 
    0.07103931f, -0.20165353f, 0.08830690f, 0.01184160f, -0.00136415f, 0.17836954f, 0.05741419f, 0.08903202f, 
    0.05074690f, -0.04239298f, 0.27134171f, -0.19206725f, 0.03234286f, 0.05900481f, -0.03695221f, 0.07338120f, 
    0.09713263f, 0.04071978f, 0.13264157f, -0.00426347f, -0.42779091f, 0.12836997f, -0.14243273f, -0.18541588f, 
    -0.25435990f, -0.05505935f, 0.08933627f, -0.06174039f, 0.05497736f, -0.02341872f, 0.01388748f, 0.07676708f, 
    0.18838492f, -0.13509895f, 0.21323030f, 0.02217888f, 0.06871680f, 0.11305853f, -0.03583305f, -0.04306126f, 
    0.10093654f, 0.01730192f, -0.06568331f, 0.09309839f, 0.28951120f, -0.30468988f, 0.13966000f, 0.29322875f, 
    -0.07864726f, 0.00553589f, -0.01091437f, 0.00665851f, 0.11840747f, 0.01019567f, 0.03103982f, 0.05658643f, 
    -0.08207828f, 0.12331957f, 0.06902629f, -0.16764174f, -0.26305166f, 0.10953280f, 0.16021086f, -0.13043879f, 
    -0.02501385f, 0.05823164f, 0.02063852f, -0.08412801f, 0.17166159f, 0.15474124f, -0.01114564f, 0.11228473f, 
    -0.09212872f, 0.03778265f, 0.00133564f, 0.00885380f, 0.06261408f, 0.03931472f, -0.03678199f, -0.04240373f, 
    -0.04812436f, -0.40366361f, -0.19481927f, 0.38762733f, 0.00839124f, 0.03493492f, -0.09949879f, 0.06595951f, 
    0.03911556f, -0.02207215f, -0.09328118f, -0.00906038f, -0.13466670f, 0.03859953f, -0.38213274f, 0.06910165f, 
    -0.08365861f, 0.07741910f, 0.15499853f, 0.06271429f, 0.04575144f, 0.13531575f, -0.14144871f, 0.06449342f, 
    0.58302009f, -0.26103100f, 0.10288314f, 0.43459517f, -0.05846208f, 0.11811202f, -0.05384220f, 0.01639343f, 
    -0.14611882f, -0.17851578f, 0.09423016f, -0.07748923f, 0.27249789f, 0.31859046f, 0.31779006f, -0.28679255f, 
    0.04020867f, 0.03340213f, 0.16857053f, 0.00265555f, 0.17288792f, -0.05286393f, 0.01021906f, 0.15731147f, 
    0.04820069f, -0.04613568f, -0.03652026f, -0.07626443f, -0.04865270f, 0.05681365f, 0.05841361f, 0.02417734f, 
    0.01925431f, 0.01439993f, 0.03680299f, -0.07876567f, -0.00269234f, 0.01194462f, -0.03240708f, 0.05875233f, 
    -0.04997223f, -0.03744500f, 0.04873615f, 0.00272324f, 0.02839234f, -0.08227722f, 0.02205293f, -0.07046150f, 
    -0.07445405f, -0.06568976f, 0.01046750f, -0.04525885f, -0.04470339f, 0.02620568f, -0.06795917f, 0.05030945f, 
    -0.03976040f, -0.00374862f, -0.04733755f, 0.02661583f, -0.06852435f, 0.01125590f, -0.05601314f, -0.00394071f, 
    0.03549769f, -0.01184445f, -0.06921598f, 0.03845383f, -0.04443773f, -0.03722977f, 0.01904986f, -0.06058618f, 
    -0.01010852f, -0.08300202f, 0.03838105f, 0.01808036f, -0.05254740f, 0.00788746f, 0.01413709f, 0.04185139f, 
    0.05014997f, 0.05316295f, -0.07540961f, -0.05877671f, 0.03421301f, 0.01759766f, 0.05112249f, -0.07849203f, 
    0.04130083f, 0.01533532f, 0.06144314f, 0.03108505f, 0.03034835f, 0.01801855f, -0.01853033f, -0.05136436f, 
    0.00701036f, -0.00762402f, 0.03676762f, -0.08150408f, 0.04540978f, 0.06101842f, 0.02544809f, 0.03161852f, 
    -0.07850003f, 0.00516055f, 0.04602494f, 0.01929288f, 0.01228252f, 0.02446141f, 0.01100595f, -0.02070404f, 
    0.03410702f, 0.01476585f, 0.00903892f, 0.04097181f, 0.03716090f, 0.00801228f, -0.02160724f, -0.02787297f, 
    -0.03052591f, -0.04259254f, -0.02338616f, -0.07082143f, 0.03403337f, -0.04975870f, -0.06639978f, -0.00454377f, 
    -0.07236562f, 0.05524570f, 0.00724403f, -0.01662703f, -0.00118021f, -0.04534701f, -0.00863264f, -0.02333490f, 
    0.05259571f, 0.04234622f, 0.00078832f, -0.02944885f, -0.03817912f, -0.00291134f, 0.03490508f, 0.05911006f, 
    -0.07178496f, 0.02097333f, 0.04257760f, -0.02965798f, 0.03995867f, -0.03739209f, -0.08146387f, -0.05500879f, 
    -0.06027414f, 0.04933020f, 0.03390209f, 0.04835385f, -0.02033223f, 0.06049263f, 0.01153165f, 0.02795174f, 
    -0.06559613f, -0.03556205f, 0.04371144f, 0.03622672f, 0.04371504f, -0.08079880f, -0.02529821f, 0.04657803f, 
    -0.05832144f, -0.00773048f, 0.04754492f, -0.06343661f, 0.04471854f, 0.02465640f, 0.05134360f, -0.05977928f, 
    -0.05430529f, -0.00022148f, -0.01846937f, -0.07586685f, -0.03468006f, 0.00827093f, 0.04867138f, 0.02083698f, 
    -0.02604632f, -0.02522461f, -0.04725186f, 0.02799263f, 0.00509352f, -0.05341550f, 0.06043386f, -0.07961755f, 
    -0.05834936f, -0.04924352f, -0.01844844f, -0.04909439f, -0.02983410f, 0.03917210f, -0.06519526f, -0.01915355f, 
    -0.07391396f, -0.04198575f, -0.03764950f, -0.07646307f, -0.06754243f, 0.03982903f, 0.05095401f, -0.01410440f, 
    -0.03031315f, 0.00522376f, 0.02312747f, -0.07505956f, -0.04876911f, -0.07725563f, -0.02683520f, -0.02529105f, 
    0.16266452f, -0.06397161f, -0.03390538f, 0.19384328f, 0.09865010f, 0.15160309f, 0.09545075f, -0.11032612f, 
    0.10638996f, -0.00624162f, 0.15787423f, 0.08745570f, -0.33200604f, 0.03906482f, -0.21627064f, -0.08898075f, 
    -0.18183504f, 0.02991993f, -0.12997800f, 0.00864901f, 0.14925191f, 0.13441570f, -0.10519086f, -0.25586709f, 
    0.12740920f, -0.38756984f, -0.08010884f, -0.03302848f, 0.06073564f, 0.15440585f, 0.03744265f, -0.02143216f, 
    0.08996945f, -0.05312544f, -0.01071719f, -0.12233461f, 0.09420639f, 0.03691853f, 0.05904559f, 0.13738674f, 
    0.11991643f, 0.00653097f, -0.10677008f, 0.11852574f, -0.00254519f, -0.22649588f, -0.06276375f, -0.29290083f, 
    0.08086304f, 0.12391711f, 0.00581125f, 0.18564916f, -0.03586290f, 0.09683460f, -0.04403764f, 0.00270606f, 
    0.29756644f, -0.28284955f, 0.03715093f, -0.20565781f, -0.17740735f, 0.38657257f, -0.07545254f, -0.19519545f, 
    0.16379993f, 0.36890155f, 0.02971717f, 0.01343412f, 0.21085198f, 0.03453309f, 0.08067323f, 0.22667128f, 
    0.15935677f, -0.01571854f, 0.06436557f, 0.10411243f, 0.07814612f, -0.06590093f, 0.24050671f, 0.06333326f, 
    -0.06923372f, 0.04538873f, 0.07338785f, 0.12009276f, 0.49488649f, 0.20841397f, -0.08166095f, 0.06771196f, 
    -0.05860642f, -0.02623316f, 0.02656174f, 0.01071127f, -0.09112332f, -0.01181118f, 0.08107430f, 0.21338183f, 
    0.04207145f, 0.11991054f, -0.01109966f, -0.11840709f, 0.03366140f, -0.03427870f, 0.16160557f, -0.09236641f, 
    -0.04063860f, -0.07521457f, 0.10158559f, 0.24177292f, -0.21759714f, -0.47567227f, 0.24918592f, -0.00310183f, 
    0.00217654f, 0.08263812f, -0.04368339f, -0.09482118f, 0.06719165f, -0.10007985f, 0.09719115f, 0.11692198f, 
    -0.00545418f, -0.33881587f, 0.11554324f, 0.02550280f, -0.05799216f, 0.02173943f, 0.03526568f, 0.07658070f, 
    -0.03608807f, -0.21087773f, 0.09634306f, -0.08859383f, 0.41782147f, -0.24083647f, -0.00644397f, -0.20273979f, 
    0.08773649f, -0.07034845f, -0.15824986f, -0.02832610f, 0.25736952f, 0.04247748f, -0.24983069f, -0.10707399f, 
    -0.10678775f, 0.16912821f, -0.04492386f, 0.13772564f, 0.09434950f, 0.13258678f, 0.15761185f, 0.09785935f, 
    0.00848631f, -0.07565336f, -0.01719706f, 0.11082178f, -0.03131894f, -0.07477530f, -0.06842369f, 0.05568950f, 
    0.09653543f, -0.01883590f, -0.11350310f, -0.09121823f, -0.06235475f, 0.07574422f, -0.09830782f, -0.06231795f, 
    -0.09628297f, -0.53465480f, -0.04801892f, -0.33284956f, 0.04733729f, -0.05498745f, -0.17832930f, -0.05030416f, 
    0.13460724f, -0.05085245f, -0.22145893f, 0.01345284f, 0.30390474f, -0.01452192f, -0.05946442f, 0.07986545f, 
    0.03726325f, -0.07866018f, -0.02244613f, -0.12311348f, 0.09350927f, 0.33079559f, 0.02326349f, 0.04628570f, 
    0.55282122f, 0.07015937f, -0.02014565f, 0.13038185f, -0.04393765f, -0.02423334f, 0.01468624f, 0.11694957f, 
    0.05416649f, -0.09866133f, 0.10321312f, -0.01331817f, -0.42541733f, -0.21314512f, 0.01027134f, -0.13598102f, 
    -0.00725928f, -0.01853835f, -0.13061547f, 0.23744552f, -0.07913801f, -0.16062480f, -0.04028909f, -0.00436390f, 
    0.27062210f, 0.03954180f, -0.18731871f, 0.06081448f, 0.07334314f, -0.02276034f, 0.01938995f, 0.05779032f, 
    -0.12703243f, -0.04771669f, -0.09779392f, -0.01819855f, 0.19753098f, -0.12124769f, 0.14759117f, 0.05169291f, 
    0.06963516f, 0.11472332f, 0.12396285f, -0.09526912f, 0.03076456f, 0.12982264f, -0.03788208f, 0.22114618f, 
    0.09247283f, 0.06953393f, -0.13161431f, -0.38324693f, -0.16654795f, 0.00090907f, 0.12133980f, 0.09259693f, 
    0.02320652f, 0.02708205f, 0.04008100f, 0.09649538f, -0.24054639f, -0.04888477f, 0.07747967f, -0.21926013f, 
    0.01603434f, 0.06065322f, 0.05295462f, -0.01357805f, -0.14770645f, -0.10818499f, -0.11619509f, -0.00394023f, 
    -0.04411412f, 0.06912021f, -0.34153107f, -0.39721438f, 0.13659512f, 0.13558732f, -0.02105968f, -0.07654813f, 
    0.03947054f, -0.08495037f, -0.07375915f, 0.07794412f, 0.52917928f, -0.32237941f, -0.14128053f, -0.04190046f, 
    0.04359309f, -0.07442749f, 0.02272061f, 0.03699499f, -0.11224879f, -0.09901416f, -0.02418954f, -0.03876541f, 
    -0.21743487f, 0.17681848f, 0.24020851f, 0.04778946f, 0.04250411f, -0.10224162f, 0.05791317f, 0.02621293f, 
    -0.06630664f, 0.08144725f, -0.03443843f, -0.19159859f, -0.14502122f, 0.29107907f, -0.01675720f, -0.00513091f, 
    -0.00721069f, 0.01177205f, -0.00331493f, -0.00485362f, 0.05915434f, -0.09604803f, 0.00818819f, -0.10876324f, 
    -0.07415958f, -0.09884517f, 0.16648914f, -0.06637737f, -0.01788491f, -0.24289639f, -0.11784454f, -0.00587609f, 
    0.03225340f, 0.06149994f, 0.07551654f, 0.23366354f, 0.03734475f, -0.39574373f, -0.01685011f, 0.01559426f, 
    0.05572617f, -0.02860720f, 0.13343029f, 0.10925359f, 0.02425578f, 0.27608922f, 0.24141245f, 0.17274101f, 
    0.38880259f, 0.10288068f, -0.20423557f, -0.08187674f, 0.15372030f, 0.22143385f, 0.13858041f, 0.01627740f, 
    0.04799093f, -0.03840251f, 0.04697330f, -0.03064192f, 0.18641825f, 0.08381039f, 0.08816131f, 0.03177014f, 
    -0.03155361f, 0.14192827f, -0.09991500f, 0.15588526f, 0.12587033f, 0.13138179f, 0.11597188f, 0.02194127f, 
    -0.07220149f, 0.41103753f, 0.14101838f, -0.04325245f, -0.00276791f, 0.01438486f, 0.03519733f, -0.16747522f, 
    0.16238563f, 0.11038873f, 0.13210568f, 0.09503789f, 0.42743707f, -0.26420230f, 0.10031852f, 0.02383898f, 
    0.01009180f, 0.07684563f, -0.05859520f, 0.02928745f, -0.03911459f, 0.05885040f, -0.04859398f, 0.02394396f, 
    0.03068632f, 0.20425773f, -0.19110766f, 0.10815016f, -0.01098481f, 0.10892726f, 0.00137886f, -0.17991012f, 
    0.04771239f, 0.04732382f, 0.06823584f, 0.05244905f, 0.58614385f, 0.09374183f, -0.07873131f, -0.12694436f, 
    -0.12669531f, -0.03747449f, 0.01117914f, 0.04839855f, 0.11995094f, 0.12871687f, -0.17404240f, 0.01466046f, 
    0.08761901f, -0.06244274f, -0.03339501f, -0.20386063f, -0.06628915f, 0.16214600f, 0.00687787f, 0.01262368f, 
    0.11847381f, -0.10183034f, 0.05304426f, 0.04238411f, 0.08286030f, -0.00978605f, -0.16165748f, 0.42018482f, 
    0.11238416f, 0.13594930f, -0.10655402f, -0.05905661f, 0.14774463f, 0.00166929f, 0.02538564f, 0.01200621f, 
    -0.03668595f, 0.07484128f, 0.15757090f, -0.23984860f, -0.02366052f, 0.21442790f, 0.00777898f, -0.04770679f, 
    0.08784226f, -0.05788456f, -0.03103322f, -0.17169482f, -0.08410622f, 0.19588968f, -0.31783846f, -0.38256571f, 
    0.06313028f, 0.25191730f, 0.01493342f, 0.06034059f, 0.06212489f, -0.04947396f, 0.30833209f, 0.18003695f, 
    -0.14385407f, 0.05410891f, 0.30382121f, -0.16034769f, 0.05154874f, 0.05486481f, 0.16519389f, 0.03765747f, 
    0.00393110f, -0.03904122f, -0.04180065f, 0.02273608f, 0.57758266f, -0.08517053f, 0.03506786f, -0.06412215f, 
    -0.08110046f, 0.01665654f, 0.12677200f, 0.26325980f, -0.05786464f, -0.08648199f, -0.00110219f, 0.09438280f, 
    0.35580537f, -0.00396967f, -0.10253814f, 0.11484227f, 0.00394488f, 0.03524942f, 0.04652025f, 0.17729934f, 
    -0.04948376f, -0.09048883f, 0.21690172f, 0.15004086f, -0.04862083f, -0.29926077f, 0.27745059f, 0.02679770f, 
    0.05860136f, -0.19607863f, -0.03895096f, -0.09018119f, 0.06067623f, 0.00748275f, 0.11772849f, -0.06726869f, 
    -0.35780478f, -0.17226325f, 0.20757943f, -0.20689151f, -0.08010701f, 0.11204787f, 0.16110162f, 0.15489182f, 
    -0.07742608f, -0.07686255f, -0.08673922f, -0.03644322f, 0.23270582f, -0.19119041f, -0.12901433f, 0.12235019f, 
    0.00596423f, 0.03320041f, -0.10780682f, 0.12601177f, -0.05677494f, 0.02129858f, -0.13979800f, -0.15883654f, 
    -0.35514811f, 0.08637729f, 0.01867757f, 0.24864550f, 0.03361643f, -0.10508961f, -0.07852820f, -0.05544829f, 
    0.03779443f, 0.01435278f, -0.10182577f, 0.10549590f, -0.13858962f, 0.06338853f, 0.07213326f, -0.31332111f, 
    -0.10069670f, -0.13260813f, -0.07231734f, -0.01265216f, -0.11176604f, -0.09138874f, 0.03470458f, 0.00623980f, 
    0.28570867f, -0.34748539f, 0.12857413f, 0.03645570f, -0.06972396f, -0.17104071f, -0.34153748f, -0.01734610f, 
    -0.01630522f, -0.06377791f, -0.11103741f, -0.00807715f, 0.01997864f, 0.10957052f, -0.12997967f, -0.55079424f, 
    0.13059410f, -0.11566526f, 0.01031867f, -0.14569768f, 0.19456448f, 0.26086402f, -0.06160592f, -0.00187700f, 
    -0.10042263f, 0.22015104f, 0.23333344f, 0.40081078f, -0.24812992f, -0.04452692f, -0.02873276f, 0.01129394f, 
    0.02676717f, -0.18319821f, 0.15292108f, -0.04478640f, -0.46837291f, -0.14360656f, -0.19646475f, 0.01336046f, 
    0.17471541f, 0.14505324f, 0.07023484f, -0.18195499f, 0.10431773f, -0.00990124f, -0.10159376f, 0.06220879f, 
    0.51006448f, 0.10947537f, 0.14807981f, -0.11445168f, 0.17580603f, 0.16742222f, 0.12075692f, 0.08275885f, 
    0.13103402f, 0.09232686f, 0.03990179f, -0.13048388f, 0.06401119f, 0.11064005f, 0.29807457f, 0.10255897f, 
    -0.01773084f, -0.07857674f, -0.12058696f, -0.11035737f, -0.03929942f, -0.10437580f, 0.11652829f, -0.11483968f, 
    -0.00548483f, 0.07336792f, 0.02489835f, 0.11061960f, 0.10027954f, 0.14942308f, 0.03164073f, 0.53319204f, 
    0.11264310f, -0.05155095f, 0.13820338f, 0.11670177f, 0.23677817f, -0.11973087f, 0.17920525f, -0.00906830f, 
    0.08489861f, -0.19766086f, -0.10453139f, -0.07672293f, 0.03575157f, -0.02632472f, -0.16173901f, -0.00113308f, 
    0.25786158f, -0.34583247f, -0.28562823f, 0.05307882f, -0.28887787f, -0.09702624f, -0.05029037f, 0.05483551f, 
    -0.05999352f, -0.00965904f, 0.05870860f, 0.03638485f, -0.29376560f, -0.13000333f, -0.32620341f, 0.04900541f, 
    0.16149320f, 0.16164361f, -0.00229675f, -0.17389378f, -0.01323477f, 0.07110939f, 0.01381200f, 0.14462179f, 
    -0.52221775f, -0.14546481f, 0.15871398f, -0.12740648f, 0.06114482f, -0.15560074f, 0.02882200f, 0.03803487f, 
    0.01741536f, 0.20822521f, -0.09710626f, 0.07819394f, 0.63660741f, 0.48367020f, 0.49885333f, 0.23998368f, 
    -0.25556850f, -0.11849091f, -0.03038455f, 0.09220722f, 0.02833595f, -0.09036471f, -0.02094194f, -0.07118396f, 
    -0.04600028f, -0.27855948f, 0.01446311f, -0.17578045f, 0.10980528f, -0.02365171f, 0.08062959f, 0.04154503f, 
    0.05979300f, -0.17507148f, -0.03294330f, -0.12733915f, 0.74593151f, 0.34788668f, 0.21118857f, 0.34036812f, 
    -0.20249119f, 0.10914861f, 0.04753606f, 0.07903006f, 0.12508398f, 0.15334383f, 0.09854698f, -0.00239887f, 
    0.28763112f, -0.19852157f, 0.10221265f, 0.21517986f, -0.27489167f, -0.01856490f, 0.06821629f, -0.04935284f, 
    0.03611327f, -0.07441943f, 0.04435432f, -0.09826165f, 0.57044691f, 0.23545669f, -0.36499363f, 0.25409922f, 
    -0.10529866f, 0.21336345f, -0.08627449f, 0.21898413f, -0.02513327f, 0.10448410f, 0.02225346f, 0.09749572f, 
    0.53083360f, 0.34225386f, 0.08659606f, 0.09112896f, -0.22069530f, 0.09599506f, -0.04742188f, -0.18247128f, 
    0.09343100f, -0.09664124f, 0.07028532f, 0.05824606f, -0.03440538f, -0.08047445f, 0.18638472f, -0.14656806f, 
    -0.34886664f, -0.05340194f, 0.14602752f, -0.11908148f, 0.02480626f, 0.09661308f, 0.05356968f, 0.12418119f, 
    -0.12318881f, 0.13514702f, -0.28145108f, 0.06578153f, 0.16405964f, -0.02444615f, 0.06802497f, -0.09019534f, 
    -0.04339144f, 0.13570298f, -0.03723234f, -0.13095905f, 0.34519276f, 0.24950662f, 0.03640430f, 0.31077063f, 
    -0.14188904f, -0.08795212f, -0.02052723f, 0.08327938f, -0.07497809f, 0.12809379f, -0.07744525f, 0.01573518f, 
    -0.07599823f, -0.08021759f, -0.32583347f, -0.13533735f, -0.10198181f, 0.04950873f, -0.07476962f, 0.01918358f, 
    -0.02729871f, -0.05888471f, 0.00405976f, -0.11678335f, 0.18662046f, -0.17977977f, -0.07786215f, 0.36055619f, 
    -0.00671190f, -0.00716442f, 0.03394711f, -0.09603132f, 0.33859953f, 0.18538179f, -0.11539785f, 0.34384152f, 
    -0.47691947f, 0.19633996f, 0.14267017f, -0.14118260f, -0.24519466f, -0.16162357f, -0.09060831f, -0.19070756f, 
    -0.07402054f, 0.11524981f, 0.05300439f, -0.06673508f, -0.28720635f, 0.32532454f, -0.04293396f, -0.39370021f, 
    0.23692979f, 0.07942899f, -0.00968513f, -0.11822160f, -0.11948784f, 0.04579118f, 0.05528121f, 0.06563988f, 
    -0.29766127f, 0.14355107f, 0.04823854f, -0.29587033f, 0.20493081f, 0.11702152f, 0.00497079f, 0.08034553f, 
    0.08922879f, 0.11448292f, -0.05884201f, -0.07273576f, 0.45831540f, -0.16999499f, 0.42226717f, 0.02366611f, 
    -0.36172578f, -0.04348394f, 0.06260265f, 0.22607760f, -0.07055637f, 0.01474949f, -0.03376765f, 0.02333896f, 
    0.40081778f, -0.02039859f, 0.05445844f, 0.11741846f, -0.09116704f, 0.09194626f, -0.01349652f, 0.10202231f, 
    -0.06088600f, -0.04165768f, 0.16357847f, -0.06519223f, -0.05187781f, -0.11715654f, 0.10950877f, 0.09844765f, 
    0.07196257f, -0.02050170f, -0.14154188f, 0.05007129f, 0.13899004f, 0.11542851f, 0.12167821f, -0.13783377f, 
    -0.08787953f, 0.40085360f, 0.32657242f, -0.20808364f, -0.11458105f, -0.17530289f, 0.10274956f, -0.04704027f, 
    -0.10144798f, 0.29839492f, -0.03203545f, 0.03333159f, 0.46218222f, -0.49554995f, -0.11395229f, 0.03020037f, 
    0.00630029f, 0.08487202f, 0.12558110f, 0.15090501f, -0.04815911f, 0.04637949f, 0.09043498f, 0.11148465f, 
    -0.42620715f, -0.03258388f, -0.10190815f, 0.03644703f, 0.06993712f, 0.02878309f, -0.03155692f, -0.04675191f, 
    0.10763475f, 0.07187233f, -0.10085829f, 0.06278072f, -0.21091063f, 0.22162020f, -0.27473426f, 0.17090641f, 
    0.03904482f, -0.10241342f, -0.04573834f, 0.00834963f, 0.21243420f, 0.18854800f, 0.13612796f, -0.07911555f, 
    0.40759894f, -0.07707492f, 0.03880262f, 0.37960988f, 0.11100724f, 0.11893886f, -0.20432356f, 0.18198273f, 
    -0.07057209f, 0.01998859f, -0.10821317f, -0.27594900f, 0.13014281f, 0.18782195f, -0.17621070f, -0.06143036f, 
    0.26240158f, 0.09377874f, 0.00320730f, -0.05913960f, 0.17018704f, 0.00128545f, -0.10912310f, -0.13366129f, 
    -0.08192094f, 0.31819284f, 0.24016708f, -0.15383323f, -0.26466796f, 0.09246078f, 0.05994939f, 0.06116179f, 
    0.00054011f, 0.00117800f, -0.07971022f, -0.10737982f, -0.05129086f, -0.00916186f, -0.06886998f, 0.29189077f, 
    0.13354257f, -0.06392732f, -0.04390214f, -0.10548633f, 0.04092651f, 0.00303559f, -0.03462711f, 0.19770013f, 
    0.02767063f, -0.07424562f, -0.00951713f, -0.06865271f, 0.01678575f, -0.14616364f, 0.04927333f, 0.20320874f, 
    -0.00691112f, 0.04880726f, -0.13274065f, -0.11821120f, 0.25612274f, -0.03525382f, 0.06467245f, 0.09951387f, 
    -0.07301718f, 0.00386917f, 0.01130056f, 0.07629533f, 0.16832784f, 0.09824160f, 0.00995343f, 0.22665054f, 
    -0.08184186f, 0.06101174f, 0.15778241f, 0.43162906f, -0.01806561f, -0.08874464f, -0.07321924f, 0.01265941f, 
    -0.12885806f, 0.27559915f, 0.22182325f, 0.03919932f, 0.13397121f, -0.25274658f, -0.27874625f, 0.08165625f, 
    0.23916821f, -0.06405099f, 0.01370757f, -0.05703007f, -0.16744281f, -0.08525717f, -0.14116658f, -0.05691358f, 
    -0.08472871f, 0.09993177f, -0.22200432f, 0.02797406f, 0.01621955f, 0.08006431f, -0.06004240f, -0.10992706f, 
    -0.18054356f, 0.07859003f, -0.05818127f, -0.11869583f, 0.16604568f, -0.11630241f, -0.03057058f, 0.14104553f, 
    0.01567415f, 0.07454097f, 0.02502814f, 0.09046701f, 0.01766423f, 0.04923632f, -0.14678249f, -0.06888238f, 
    0.55893552f, -0.28880081f, -0.05313689f, 0.26676282f, -0.05875373f, 0.11588031f, -0.00608187f, -0.01863304f, 
    -0.15090489f, -0.08930565f, -0.03726514f, -0.26865444f, 0.13432415f, 0.45663950f, 0.09880646f, -0.11237080f, 
    -0.17065465f, 0.00684136f, -0.03279801f, 0.11784394f, -0.15009092f, 0.00537433f, 0.07825352f, -0.05924119f, 
    0.13205113f, 0.30378470f, 0.02173669f, 0.20573686f, 0.24639173f, -0.07844714f, 0.01148140f, -0.09888817f, 
    0.00414858f, -0.03995110f, -0.38655022f, 0.00848681f, 0.13771693f, -0.19009551f, 0.12288454f, 0.02413322f, 
    0.00718163f, 0.17807557f, 0.06347845f, 0.23085144f, 0.00497976f, 0.00344446f, 0.09514312f, 0.21241228f, 
    -0.41421118f, 0.16294818f, -0.04689915f, -0.16909023f, -0.29256544f, 0.07655859f, 0.05900884f, -0.08688837f, 
    -0.08781371f, -0.05631565f, 0.04667020f, -0.06976472f, 0.25162452f, -0.11880551f, -0.19789279f, 0.38453615f, 
    0.00638846f, 0.06817124f, 0.16421941f, 0.18117391f, -0.07395057f, 0.12158896f, 0.20744960f, -0.05715862f, 
    0.39638871f, 0.29159069f, -0.16385946f, -0.28538108f, -0.08646876f, 0.25907001f, -0.04023071f, 0.05675669f, 
    -0.08212174f, 0.09253761f, -0.08098885f, -0.26381284f, -0.17018817f, -0.15098789f, -0.11214352f, 0.07983045f, 
    -0.01852263f, 0.00372878f, 0.08377682f, -0.00448044f, -0.07820731f, -0.00482492f, 0.05160840f, -0.05449079f, 
    -0.71219093f, -0.33453393f, -0.07879342f, -0.22925384f, -0.05198137f, -0.02019652f, -0.12307325f, -0.07196466f, 
    0.08018383f, 0.04008223f, 0.01113819f, -0.06279287f, -0.35472071f, -0.12430810f, 0.21454759f, 0.13551977f, 
    -0.06216135f, 0.00893278f, 0.20683092f, 0.05503577f, -0.05934381f, 0.07535060f, 0.03388079f, 0.11200567f, 
    -0.13650508f, 0.14963534f, 0.19981690f, 0.26690674f, 0.13604480f, 0.14424740f, -0.05101188f, 0.03619330f, 
    -0.03660594f, -0.01206233f, 0.00078840f, -0.11412582f, -0.15877473f, -0.20645662f, 0.32113868f, -0.03476900f, 
    0.06229697f, 0.08815720f, -0.01059899f, -0.11514171f, 0.07228591f, 0.14890209f, 0.11566863f, 0.22379225f, 
    0.00440505f, 0.14618014f, 0.18500994f, 0.24338612f, -0.07076722f, -0.01791037f, 0.09478219f, 0.18904637f, 
    -0.03908933f, 0.10745084f, 0.04477708f, 0.34001771f, 0.25185245f, 0.07578302f, 0.09265520f, -0.24155185f, 
    0.25260204f, -0.03529312f, 0.02839418f, -0.02109927f, 0.03535533f, 0.03904437f, -0.18806893f, -0.06522147f, 
    -0.08140191f, -0.16712247f, 0.16842538f, 0.16503081f, 0.02414786f, 0.22394051f, 0.06173139f, -0.03426738f, 
    -0.05507942f, 0.09127085f, -0.06572463f, -0.00632033f, 0.46582204f, 0.05949045f, -0.10929817f, 0.20192717f, 
    -0.00834808f, -0.21017130f, 0.02870014f, 0.07942576f, -0.03342587f, 0.07820093f, 0.10277738f, -0.02535502f, 
    -0.35706559f, 0.12788087f, 0.49254850f, -0.00368674f, -0.02284726f, -0.06820931f, 0.01985371f, 0.07092085f, 
    -0.13109498f, 0.03728367f, -0.02889837f, -0.06744126f, -0.25936785f, 0.31216925f, -0.39323381f, -0.32789567f, 
    0.05383828f, -0.12699217f, -0.07932183f, 0.11034404f, 0.01919249f, -0.05210089f, -0.06416864f, 0.05915768f, 
    0.31956485f, 0.15095605f, 0.05650406f, 0.18881151f, -0.09018496f, -0.28158417f, -0.22423638f, 0.05146847f, 
    0.04752950f, 0.02302198f, 0.09815267f, 0.07865891f, 0.00374735f, -0.15816854f, -0.50607508f, 0.12552850f, 
    0.00856574f, 0.04543681f, 0.12761691f, -0.04214093f, -0.06713094f, 0.00354764f, 0.29061079f, 0.16350050f, 
    -0.01760689f, -0.54666942f, 0.23203242f, -0.02320302f, 0.10036808f, 0.07107360f, 0.05633314f, -0.30913350f, 
    0.06877628f, 0.06675921f, -0.08103920f, 0.07277011f, 0.04584577f, -0.04128231f, 0.31980854f, 0.06499176f, 
    -0.04615040f, 0.15123016f, 0.03777681f, 0.32970417f, 0.15784082f, 0.13054268f, 0.01081347f, -0.09139673f, 
    -0.31040174f, 0.17814563f, -0.14027810f, 0.05695555f, 0.08727298f, 0.07213697f, 0.07495259f, -0.02777806f, 
    0.22617489f, -0.02035370f, 0.10482533f, -0.01596092f, 0.43387300f, 0.38570973f, -0.03853415f, -0.24238893f, 
    0.11833049f, 0.00143878f, -0.16288096f, 0.12123412f, 0.04376534f, 0.00663784f, -0.09791896f, -0.15798305f, 
    -0.48969147f, -0.09725996f, 0.04191875f, -0.08238155f, -0.14300551f, -0.23280862f, -0.11083929f, -0.00211888f, 
    0.08832401f, 0.12181624f, -0.19002910f, 0.05571961f, 0.06166221f, 0.07512128f, 0.03039765f, -0.10965859f, 
    0.05375797f, 0.01292273f, 0.14852032f, 0.04419173f, -0.13553214f, 0.05667875f, 0.22573051f, 0.27676019f, 
    -0.30203247f, 0.12521057f, 0.25693846f, 0.16817029f, -0.00598107f, 0.09701748f, -0.10822145f, 0.09676716f, 
    0.09922706f, 0.07500540f, 0.05670926f, 0.10109007f, -0.47991830f, -0.02504858f, -0.01961322f, -0.22276531f, 
    -0.02353526f, -0.02856846f, -0.00964535f, 0.04456964f, 0.02537034f, 0.12530811f, 0.07582605f, 0.10357208f, 
    0.13090841f, -0.12234966f, 0.03276967f, 0.03316196f, 0.05959444f, -0.03018377f, 0.07047790f, -0.06153964f, 
    -0.26521444f, 0.26593521f, -0.05551938f, 0.29521585f, -0.02519217f, 0.21888013f, 0.31696501f, 0.27138332f, 
    -0.12995602f, -0.24054395f, 0.13412015f, 0.18845519f, -0.02531463f, 0.18148394f, -0.13410111f, -0.20575711f, 
    0.24898502f, 0.17038515f, 0.31833676f, 0.32460490f, 0.05983700f, 0.17053100f, -0.07561565f, 0.06847002f, 
    0.09847501f, 0.10552815f, 0.02664572f, 0.05312915f, -0.46860254f, 0.10554741f, -0.13231431f, -0.23046090f, 
    0.12709017f, 0.02254936f, -0.07048575f, 0.12074719f, 0.07079577f, 0.24215917f, 0.05290152f, -0.13966100f, 
    -0.34795472f, 0.29625827f, 0.17368765f, 0.09765733f, 0.01570992f, 0.03382485f, -0.11394083f, 0.04685153f, 
    0.00643242f, 0.14500023f, -0.10270884f, -0.16753364f, -0.00270239f, 0.05586214f, -0.42793944f, -0.13728632f, 
    -0.09273668f, -0.02577413f, 0.06948334f, 0.13275415f, 0.01389148f, -0.01267445f, -0.10089494f, 0.02778173f, 
    0.38130748f, 0.13603629f, -0.26236740f, 0.01592283f, -0.02035260f, 0.08528384f, 0.00981759f, -0.04516964f, 
    0.14462648f, 0.30499083f, 0.10276081f, 0.14366981f, -0.46603963f, 0.23782676f, -0.15618971f, -0.01938334f, 
    -0.00786039f, 0.03606630f, 0.08672794f, -0.01408400f, -0.09295946f, -0.03081241f, 0.12389993f, 0.10738569f, 
    0.24989694f, -0.20109126f, 0.02882635f, 0.02456807f, 0.09435704f, 0.00123975f, -0.13840638f, -0.03627469f, 
    0.12786613f, 0.14220262f, 0.01543999f, 0.20209579f, -0.13005677f, -0.20612523f, 0.23924445f, -0.05576642f, 
    -0.01986352f, 0.14644097f, 0.16885349f, -0.00043984f, 0.05082742f, 0.05596193f, 0.00867826f, 0.10778699f, 
    -0.07218660f, 0.12484187f, -0.01749274f, 0.38068634f, -0.00898662f, 0.00981276f, 0.14647503f, 0.10287602f, 
    -0.01619529f, 0.07755747f, 0.15519214f, 0.12660587f, 0.00167027f, 0.28205073f, 0.11654420f, 0.25904715f, 
    -0.00592788f, 0.20287503f, 0.03754907f, 0.07640871f, -0.02129175f, -0.30319139f, 0.12756479f, 0.20209138f, 
    -0.02339876f, -0.07964665f, 0.14994144f, 0.03343492f, -0.10279150f, 0.10241213f, -0.04153202f, -0.00361921f, 
    -0.09369459f, -0.07356610f, 0.10923951f, -0.01789268f, 0.18855476f, 0.23765881f, 0.20308788f, -0.05197518f, 
    0.19012608f, -0.02080744f, -0.03183151f, 0.12159621f, 0.10884732f, -0.07065598f, -0.01332341f, 0.02565164f, 
    -0.18549223f, 0.52502942f, 0.53217906f, -0.37184665f, 0.10199906f, -0.09360407f, -0.15429190f, 0.05624134f, 
    0.00516133f, 0.11071585f, 0.17243135f, 0.15030645f, 0.10864679f, 0.15304363f, -0.06698624f, -0.13118806f, 
    0.07733317f, 0.10677287f, -0.01108904f, 0.04752013f, -0.12888604f, 0.01085336f, -0.01387193f, -0.14945179f, 
    -0.14417805f, -0.31705648f, 0.30447343f, -0.06593273f, 0.26194540f, 0.16581963f, -0.01545129f, 0.28292653f, 
    0.07779954f, -0.12661797f, -0.01469317f, 0.08191622f, 0.24883768f, -0.13303719f, -0.21879677f, 0.10926666f, 
    -0.00731198f, -0.11736761f, 0.03024593f, 0.04846045f, -0.04931055f, 0.05223780f, 0.23341838f, 0.10869112f, 
    -0.11916183f, -0.19450706f, 0.17595154f, 0.09139771f, -0.23096612f, -0.08474427f, -0.03751052f, -0.06028679f, 
    0.11864255f, -0.05472835f, 0.00760693f, -0.10376225f, -0.44642878f, 0.10080569f, -0.05880469f, 0.03821673f, 
    0.16941656f, -0.08566037f, -0.12410800f, -0.14270537f, 0.17415643f, 0.02895235f, 0.09264046f, -0.00553958f, 
    -0.07688547f, -0.33339125f, -0.11071964f, 0.05706602f, -0.00263354f, -0.10060617f, 0.04350702f, -0.02618025f, 
    0.17407753f, 0.07741196f, 0.00243774f, 0.37246117f, 0.38604930f, 0.11962676f, 0.00941995f, 0.39932472f, 
    0.06606953f, 0.09840924f, 0.11483932f, 0.00969030f, -0.14749190f, 0.13377663f, 0.02401558f, 0.01913975f, 
    -0.50017560f, -0.22406924f, -0.09228437f, 0.18331499f, 0.08343377f, 0.21420063f, -0.07722414f, 0.15835924f, 
    -0.03600555f, -0.20973159f, 0.09428351f, 0.01451171f, -0.14135043f, 0.75411659f, -0.05987394f, 0.20579231f, 
    0.05103952f, -0.04674369f, -0.12604995f, -0.09141133f, 0.07504726f, 0.18212302f, 0.02966265f, -0.08538751f, 
    0.19580816f, -0.25601906f, 0.08321704f, 0.13915817f, -0.12572935f, 0.01937761f, 0.01107740f, -0.08112920f, 
    -0.01999644f, 0.06497824f, 0.08337021f, 0.00229566f, -0.11200499f, 0.30133253f, 0.06910289f, -0.59482455f, 
    -0.16613026f, -0.12488190f, 0.10316715f, 0.10005978f, -0.10331134f, -0.08779822f, -0.11319584f, -0.09487294f, 
    -0.29075676f, -0.02039971f, 0.19032918f, 0.14861837f, 0.10734913f, -0.03693980f, 0.19032811f, 0.03525262f, 
    0.01131729f, 0.06115749f, 0.24289617f, 0.12930171f, -0.40459055f, 0.15149882f, 0.11377286f, -0.45708877f, 
    -0.05881545f, 0.01450833f, -0.02053800f, -0.13335167f, 0.03369917f, -0.02591928f, -0.05567049f, -0.06607865f, 
    -0.00682830f, -0.06541798f, -0.04462312f, 0.03123938f, 0.03172266f, -0.06286182f, 0.02661854f, -0.04448966f, 
    0.00750485f, 0.04879850f, -0.01342669f, -0.07176661f, -0.06112582f, 0.00101943f, 0.02828486f, 0.03992805f, 
    0.04261812f, -0.02754058f, -0.02945861f, -0.02974401f, -0.06923146f, 0.03314104f, -0.06975173f, 0.01327556f, 
    -0.03069636f, 0.04259490f, -0.00535487f, 0.01433125f, -0.01293187f, 0.02903824f, 0.06989821f, 0.00338442f, 
    -0.01998585f, -0.06745034f, -0.02617213f, -0.02277445f, 0.02022259f, 0.06575952f, -0.06036032f, 0.04092935f, 
    0.03668686f, -0.05995454f, -0.01043313f, 0.02924197f, -0.02732066f, 0.00214618f, 0.00925152f, -0.02306694f, 
    -0.01637998f, -0.06142585f, -0.04563262f, 0.00325612f, -0.03320693f, 0.04817696f, -0.06846762f, 0.01118516f, 
    -0.04486111f, -0.06458490f, 0.05075610f, 0.03816353f, 0.01509499f, 0.03229709f, 0.02593035f, -0.06980935f, 
    -0.03328460f, -0.06469632f, 0.06875960f, -0.06774480f, 0.04890039f, -0.03709449f, -0.04690550f, -0.00002642f, 
    0.04850721f, -0.01538785f, 0.02838761f, -0.03220091f, -0.01821305f, -0.03144088f, -0.05112068f, -0.05609057f, 
    0.01711084f, -0.05799991f, 0.06992472f, 0.01097874f, 0.06736158f, 0.06473902f, 0.00068204f, 0.06224730f, 
    0.01716743f, 0.00749570f, -0.02578489f, -0.04320363f, -0.00672763f, -0.05448702f, -0.00800312f, 0.06102625f, 
    -0.05280385f, -0.07056532f, -0.01935179f, 0.02482023f, -0.00342357f, -0.06235542f, -0.04381648f, -0.07104722f, 
    -0.04492514f, -0.05322282f, -0.04959542f, -0.05013434f, 0.05823057f, 0.03500080f, -0.05197846f, 0.03071674f, 
    -0.01260392f, 0.06595565f, -0.03635610f, 0.02226716f, -0.01828447f, -0.06596534f, -0.01532545f, -0.04970375f, 
    -0.02101397f, 0.03905870f, -0.03624517f, 0.05816101f, 0.01904638f, -0.06155834f, -0.06984052f, 0.04231787f, 
    -0.00512499f, 0.02176539f, -0.02753053f, 0.02727078f, -0.02396646f, -0.01838472f, -0.02031403f, -0.01732952f, 
    -0.06295750f, -0.04176100f, 0.00279281f, -0.05512167f, -0.06801226f, -0.02429989f, -0.01237585f, 0.06657099f, 
    0.00824453f, 0.05639797f, -0.06087008f, -0.02974433f, -0.06939981f, 0.06639979f, -0.02115257f, -0.06737503f, 
    -0.03231876f, 0.03387637f, -0.00848198f, -0.02425262f, -0.06583909f, -0.01836223f, -0.06309129f, 0.01721165f, 
    -0.06971354f, 0.00888096f, -0.02143641f, 0.04818815f, -0.06313956f, 0.02937168f, 0.01950167f, 0.04320547f, 
    -0.05824929f, 0.05029404f, -0.04970973f, 0.02610715f, -0.04678077f, -0.03493482f, 0.03191130f, 0.04242072f, 
    0.03481573f, 0.04927294f, 0.02099004f, 0.01539238f, 0.05668466f, -0.01290423f, -0.01729132f, -0.02238640f, 
    0.05627430f, -0.06502370f, 0.00375232f, -0.05633003f, 0.05822562f, -0.01387941f, 0.06758533f, -0.03828609f, 
    0.05651793f, -0.01147336f, 0.01038190f, -0.01249118f, -0.02499493f, -0.06733952f, 0.06053691f, -0.00674235f, 
    -0.02153463f, -0.06990424f, -0.02888051f, -0.05332841f, 0.05910904f, 0.02893768f, -0.02743615f, -0.01789177f, 
    -0.07211512f, -0.06486040f, -0.07003424f, 0.00653194f, 0.00571484f, 0.02500082f, 0.02884727f, 0.01094352f, 
    -0.05624147f, -0.02909710f, -0.01830052f, -0.05903309f, -0.07100965f, -0.07377318f, 0.03898315f, 0.03113684f, 
    -0.02398219f, -0.05172946f, -0.04520261f, -0.05232615f, 0.04611427f, -0.07235879f, 0.05020359f, 0.05405720f, 
    -0.05579058f, 0.00113212f, -0.04332997f, 0.06597678f, 0.04286652f, -0.01034889f, 0.02710889f, 0.03602979f, 
    -0.04831383f, -0.05424852f, -0.07267547f, -0.04716389f, -0.01074494f, -0.06421330f, 0.02558260f, -0.06603179f, 
    -0.07185801f, 0.02146451f, 0.00463952f, -0.00264604f, 0.04820251f, -0.05403082f, 0.04076570f, -0.06122143f, 
    0.05073177f, -0.07087617f, -0.06602868f, -0.04847749f, 0.01871909f, 0.05930869f, 0.02790586f, -0.01808852f, 
    0.02395006f, -0.03584655f, 0.00454356f, 0.04698673f, 0.02596575f, -0.02844818f, 0.06209973f, 0.00348049f, 
    0.01520262f, 0.02000969f, -0.06107694f, -0.00473795f, -0.07802897f, -0.07467077f, 0.04035208f, 0.00151454f, 
    -0.07007787f, -0.07742438f, -0.03439653f, 0.01977586f, 0.03294104f, -0.03586651f, 0.05292135f, -0.01979240f, 
    -0.03661019f, 0.03482154f, -0.05799614f, -0.06047795f, 0.00036175f, -0.02029357f, -0.00465039f, -0.02520757f, 
    0.00234832f, -0.01659738f, -0.03211492f, 0.01038884f, 0.00840581f, -0.07263704f, 0.00546636f, -0.00481811f, 
    0.00554084f, -0.01746150f, 0.03755569f, 0.05227339f, 0.04679988f, 0.02630589f, 0.04288991f, -0.01871925f, 
    -0.04341985f, 0.01866091f, 0.02277185f, -0.05049074f, 0.06428102f, -0.04154916f, -0.00718379f, 0.01545829f, 
    -0.03068728f, 0.03888418f, -0.07284698f, 0.06460003f, -0.07174669f, 0.04137789f, 0.00112662f, -0.00581908f, 
    -0.05556674f, 0.00843307f, -0.04898046f, -0.01654078f, -0.03119582f, -0.05689596f, -0.03305903f, 0.05200814f, 
    0.04720379f, -0.00585874f, 0.02101511f, 0.00909910f, 0.03705038f, 0.05620472f, -0.01669641f, -0.01060289f, 
    0.02062218f, 0.04538010f, -0.01440289f, -0.00810053f, 0.01557390f, -0.01541082f, -0.01098714f, -0.01724620f, 
    -0.07681161f, -0.00245504f, -0.03297624f, -0.05372085f, -0.04264252f, -0.04198352f, 0.04967445f, 0.01740270f, 
    -0.00623972f, 0.04464851f, 0.03879198f, -0.07192994f, -0.04781005f, -0.04303103f, -0.03706862f, 0.05866714f, 
    -0.02595641f, -0.04173347f, 0.04479499f, -0.02401495f, 0.00769015f, -0.02594595f, 0.00651811f, -0.07086565f, 
    -0.04741362f, 0.01132946f, 0.03732619f, 0.02517280f, -0.06711077f, -0.06103678f, -0.03378655f, -0.06745477f, 
    -0.07360224f, 0.04087985f, 0.05733147f, 0.00691391f, 0.04788589f, 0.02873363f, 0.00397885f, -0.01188218f, 
    -0.06827907f, -0.03506201f, -0.06234964f, 0.01818959f, -0.06716647f, 0.03195825f, -0.07165174f, 0.04480005f, 
    -0.05747288f, -0.02486964f, -0.01233214f, 0.00926469f, -0.01760395f, 0.04409897f, -0.06465236f, 0.02658065f, 
    -0.06969985f, 0.01358020f, 0.03338514f, 0.05545664f, 0.03466693f, 0.00858634f, -0.06596068f, -0.04925806f, 
    -0.05214284f, -0.03698083f, -0.01604095f, 0.03280479f, -0.04709085f, -0.06485379f, 0.05484078f, -0.03631220f, 
    0.05865892f, -0.04203584f, -0.01050564f, -0.03167823f, -0.06345829f, 0.00957590f, 0.06017536f, -0.03944037f, 
    -0.06368184f, 0.05129710f, -0.03455717f, 0.02709560f, 0.02918627f, 0.05900952f, 0.00683470f, -0.05296903f, 
    0.02499290f, 0.06472195f, -0.00391564f, 0.02149365f, 0.01046724f, -0.02348565f, 0.02111750f, 0.02949885f, 
    -0.03550972f, 0.04924574f, 0.04379120f, -0.02749967f, -0.03252245f, 0.02758745f, 0.01146344f, -0.05253243f, 
    -0.04014077f, -0.04178835f, 0.04317469f, -0.06635041f, -0.00028345f, -0.06152344f, -0.00809900f, -0.01045534f, 
    -0.04102360f, -0.03400494f, -0.05357996f, -0.03990155f, 0.01742282f, 0.00252427f, 0.01895557f, 0.00123415f, 
    -0.06240808f, 0.01927695f, -0.05829710f, 0.00837707f, -0.05239857f, -0.06527367f, -0.05937928f, 0.05808923f, 
    0.01482638f, -0.05423870f, 0.00988007f, 0.04841724f, 0.02626128f, -0.01028464f, 0.02830153f, 0.03645228f, 
    -0.07652140f, -0.01690255f, -0.07005784f, 0.01650619f, 0.02904019f, -0.02115908f, -0.06064223f, 0.06311403f, 
    -0.01420630f, -0.02758268f, -0.06835400f, 0.01957320f, -0.04986039f, -0.04019063f, -0.06689071f, -0.04697873f, 
    0.06677408f, -0.01208628f, -0.04922794f, 0.02504690f, -0.05654866f, -0.04160013f, 0.01437252f, -0.05008786f, 
    0.02998066f, -0.02381279f, -0.05374129f, -0.03757798f, -0.02975523f, 0.03202199f, 0.02493648f, -0.06656808f, 
    -0.07811391f, 0.02230889f, -0.04488104f, 0.06321957f, -0.00668773f, 0.02701125f, 0.02803350f, -0.03078441f, 
    0.05348441f, -0.01473069f, -0.07883814f, -0.01049390f, 0.03223567f, -0.01129298f, 0.02796273f, 0.06384903f, 
    -0.03225282f, -0.00491543f, -0.05494032f, -0.03307146f, -0.02566857f, 0.00855411f, -0.03014801f, -0.06916773f, 
    -0.00019865f, 0.06043784f, -0.05450697f, 0.04437244f, -0.04878068f, 0.04713511f, -0.05565909f, 0.00588911f, 
    -0.06146282f, -0.07732033f, 0.01308269f, -0.07224561f, -0.02408849f, 0.00138064f, -0.02020026f, 0.00855353f, 
    -0.00889408f, 0.06286656f, 0.03139516f, 0.03466059f, 0.02747849f, 0.04679900f, 0.05339440f, -0.04054772f, 
    0.03295388f, -0.04549676f, -0.06487808f, -0.04728755f, 0.01742146f, -0.03073034f, 0.01784861f, -0.01568885f, 
    0.09632269f, -0.39551392f, -0.21565104f, -0.19144794f, -0.16350570f, 0.02170699f, 0.01717094f, 0.01753761f, 
    -0.08703350f, -0.14339149f, -0.13036196f, -0.13817298f, 0.00142675f, 0.38863561f, 0.28284970f, -0.13950011f, 
    0.28850570f, -0.00940533f, -0.06036402f, 0.24366352f, 0.05835768f, -0.09686635f, 0.13209054f, -0.00494504f, 
    -0.23510893f, 0.07593040f, 0.19169043f, -0.03248488f, 0.01329178f, -0.10751015f, -0.16167730f, 0.10284171f, 
    -0.18394656f, 0.11218840f, -0.06127518f, 0.09841137f, -0.17683628f, 0.14500122f, -0.06537540f, -0.13861752f, 
    0.00753322f, 0.00652411f, 0.14877923f, 0.15247618f, -0.10750303f, 0.03483399f, -0.12451545f, -0.00051044f, 
    0.47867098f, -0.01808318f, 0.26239812f, 0.22944702f, 0.23027378f, 0.17032573f, 0.22464173f, -0.07045579f, 
    0.07799066f, 0.01659079f, -0.10213047f, -0.03569641f, -0.03681745f, 0.09241225f, -0.13512264f, -0.06062054f, 
    0.15493706f, 0.10234494f, 0.06462905f, 0.17959398f, -0.01235161f, -0.09647404f, -0.03185016f, 0.01850010f, 
    0.46000391f, 0.13644320f, 0.32232124f, 0.08634826f, 0.14290175f, 0.18049848f, 0.17423365f, 0.11443809f, 
    0.05517587f, -0.00039891f, -0.12558953f, -0.02354489f, 0.30585667f, 0.42124441f, -0.16474181f, -0.01458999f, 
    0.19234523f, -0.09026168f, -0.03279083f, 0.04258203f, 0.05253517f, -0.05391844f, 0.06640224f, -0.18063782f, 
    0.17996427f, 0.11903936f, 0.20802410f, 0.20475584f, 0.07443768f, 0.15478016f, -0.11123893f, -0.03464067f, 
    -0.03816333f, -0.01054112f, 0.01312586f, 0.09562369f, -0.02000604f, -0.37192613f, -0.27408624f, 0.02623776f, 
    0.11579260f, 0.18820913f, -0.01593411f, -0.16031578f, -0.13996223f, -0.05774535f, -0.08449256f, -0.02151624f, 
    0.54207563f, 0.19432358f, -0.06756790f, 0.37255764f, 0.10090007f, 0.11080541f, -0.22365959f, 0.27279797f, 
    0.02853220f, 0.11795249f, 0.10526242f, 0.10525801f, -0.60959762f, 0.21667317f, -0.14015342f, -0.08237845f, 
    0.10261478f, 0.07695846f, 0.01107394f, -0.24876961f, 0.14049414f, 0.21920562f, -0.10775558f, -0.11479258f, 
    0.39174560f, -0.16122594f, -0.24750401f, 0.05545072f, 0.03927581f, 0.00866958f, 0.00901677f, 0.06320342f, 
    -0.10782424f, -0.08506273f, 0.06667704f, 0.06624027f, -0.11387020f, -0.26556650f, 0.36879110f, -0.47793046f, 
    -0.06852155f, -0.19276607f, 0.17803214f, 0.22990301f, -0.07138750f, 0.08176545f, -0.09120882f, -0.22222723f, 
    -0.38197464f, -0.09858530f, 0.04630214f, -0.09955522f, 0.26626912f, 0.06867386f, 0.13772650f, -0.02573723f, 
    0.11177336f, 0.04715360f, 0.10055568f, 0.18101187f, 0.22418503f, 0.16847418f, 0.06169659f, 0.24461052f, 
    -0.07523612f, 0.21026731f, -0.03859477f, -0.02626620f, -0.09459790f, 0.03863914f, 0.05764273f, -0.16292326f, 
    0.13747847f, 0.02598726f, 0.10553392f, -0.19547048f, 0.25873443f, 0.13805141f, 0.00716728f, -0.04702763f, 
    -0.07981941f, -0.03052983f, 0.11225744f, 0.15559667f, 0.21709614f, -0.12929279f, -0.00322687f, 0.19953580f, 
    0.10467985f, 0.06127273f, 0.09071921f, -0.01788006f, 0.14307414f, 0.04933583f, -0.03784984f, -0.05759925f, 
    0.04658639f, 0.17470118f, -0.25298917f, 0.07721595f, 0.06686574f, -0.12963434f, 0.08063185f, -0.24603610f, 
    0.13153850f, -0.11328819f, 0.23461540f, 0.10182994f, 0.53406364f, 0.03747626f, -0.06836881f, -0.21709752f, 
    0.13409762f, -0.02187099f, 0.07361837f, 0.03131929f, -0.02624013f, -0.05179128f, 0.03892865f, -0.27159002f, 
    -0.05921458f, -0.02047199f, -0.20521690f, 0.18208036f, 0.25018218f, 0.07990614f, 0.04355902f, -0.05448085f, 
    0.09943291f, -0.09563114f, -0.00349427f, -0.19638398f, 0.36630654f, -0.38073781f, -0.05753011f, 0.33068892f, 
    -0.16003387f, 0.22931169f, -0.04889434f, -0.14469798f, 0.03277893f, 0.13727592f, 0.13253723f, 0.08388984f, 
    -0.25083834f, -0.02125236f, -0.09351631f, 0.12249471f, -0.02995072f, 0.00932562f, -0.04577181f, -0.13711235f, 
    0.00480315f, 0.04936266f, 0.19680199f, 0.08277437f, -0.15853457f, -0.03689703f, 0.31564656f, 0.20755263f, 
    0.04435958f, -0.04507546f, -0.05313523f, -0.05659814f, 0.10193611f, -0.07954675f, -0.00595607f, 0.05452897f, 
    0.31104249f, -0.12631221f, -0.16012236f, -0.32017162f, 0.05075939f, -0.09378386f, 0.19705316f, 0.01572991f, 
    0.22212133f, 0.05228589f, 0.04588370f, 0.15029357f, -0.38233611f, 0.05014100f, 0.17300048f, -0.05303790f, 
    0.30491522f, 0.06427064f, 0.14407754f, 0.01749406f, 0.02835459f, 0.12406305f, 0.04899993f, 0.14314356f, 
    -0.19598995f, -0.12750836f, 0.12925398f, 0.17334871f, 0.03655544f, 0.19589546f, 0.13046949f, 0.05361058f, 
    -0.02522783f, -0.05792591f, -0.00484087f, 0.01853392f, 0.03042807f, 0.35011682f, 0.23782341f, -0.22516648f, 
    0.11707411f, -0.23664013f, -0.23834445f, -0.08458316f, 0.04209492f, -0.20737450f, -0.17562303f, -0.11559115f, 
    -0.23669674f, 0.25084779f, 0.27013391f, -0.30614343f, 0.15733092f, 0.14463472f, 0.07542390f, 0.02624259f, 
    0.02406857f, 0.19893594f, -0.06492746f, -0.01778898f, -0.02422325f, 0.38213331f, 0.11899149f, 0.21464260f, 
    0.08625688f, -0.02478278f, -0.01766797f, -0.27145815f, 0.00983558f, -0.05581244f, 0.01620336f, 0.18560745f, 
    -0.45547727f, 0.23538099f, -0.12920055f, -0.33756733f, 0.05998733f, -0.14883797f, 0.05046817f, 0.01719676f, 
    -0.01617050f, -0.05099659f, 0.06579506f, 0.09105922f, -0.42991287f, -0.17485635f, -0.10500334f, 0.14586335f, 
    0.10138649f, -0.18171766f, -0.05290836f, 0.09545099f, -0.07758100f, 0.18845198f, 0.01806075f, -0.04867804f, 
    -0.50604397f, -0.47487146f, -0.19090466f, 0.04370100f, 0.24516997f, -0.07813319f, -0.10638314f, -0.00459893f, 
    0.04581764f, -0.00020688f, 0.00970060f, 0.15182766f, -0.22509317f, -0.06146199f, 0.11723577f, 0.25385863f, 
    -0.18114915f, 0.11490278f, 0.13499403f, 0.11367609f, -0.17855211f, 0.03981397f, -0.03424941f, -0.02224769f, 
    -0.15288526f, 0.10298840f, 0.23801169f, 0.00407922f, -0.01584656f, 0.13031152f, -0.02384831f, -0.18222731f, 
    -0.01674337f, -0.06070678f, 0.16108356f, -0.02279162f, -0.06141171f, -0.03094352f, 0.16164492f, -0.09230972f, 
    0.19733712f, -0.18055695f, 0.07109207f, -0.02736775f, 0.05358353f, 0.10112291f, 0.03167386f, -0.01388205f, 
    -0.12489846f, 0.03694550f, 0.14204007f, 0.13637158f, -0.06415922f, -0.00566014f, 0.00299049f, 0.12704334f, 
    0.02245088f, 0.10040940f, 0.01835490f, 0.25153261f, 0.24665955f, 0.50635362f, 0.06251538f, -0.15164043f, 
    0.14951092f, 0.17059547f, 0.11232768f, -0.14146212f, 0.12910306f, 0.06070156f, -0.05465248f, 0.02008269f, 
    -0.10583030f, -0.21547548f, -0.03642895f, 0.14857836f, 0.04719756f, 0.15452023f, 0.06208966f, -0.06130776f, 
    0.18535145f, 0.18706520f, -0.04348711f, 0.04874762f, 0.18645859f, 0.31291726f, 0.18510351f, 0.13217928f, 
    -0.12039327f, -0.24419731f, -0.02171782f, -0.06572603f, -0.02123637f, -0.06577734f, 0.04547362f, 0.02282687f, 
    -0.58888185f, 0.18066387f, 0.13213679f, -0.25764617f, -0.07036953f, -0.00571906f, 0.10976896f, -0.01714917f, 
    -0.07761293f, 0.13942111f, -0.10918962f, 0.14405605f, -0.24165566f, 0.01251696f, -0.16718812f, 0.01032201f, 
    0.22004196f, -0.06134465f, -0.08012241f, 0.01414361f, 0.16399407f, 0.01889030f, -0.12153345f, 0.08832078f, 
    -0.00546407f, -0.03996963f, 0.01351880f, 0.27928180f, -0.11142341f, -0.19202417f, -0.01883710f, 0.08982204f, 
    -0.01771990f, -0.05027858f, 0.17564972f, 0.01921832f, 0.47476193f, -0.12243762f, -0.29048488f, -0.10024567f, 
    -0.05464727f, -0.17942391f, 0.12567763f, -0.18676220f, 0.01021892f, -0.05253305f, 0.13471806f, 0.02182450f, 
    -0.11130060f, -0.50446475f, 0.17669229f, -0.05171207f, 0.18494266f, 0.14890556f, 0.03214429f, -0.21542609f, 
    0.22234438f, 0.12267882f, -0.10250317f, 0.12143663f, -0.09532943f, 0.12125287f, 0.04367732f, -0.03834888f, 
    -0.01583336f, 0.16637506f, -0.03094566f, 0.00810836f, 0.05910518f, 0.12903644f, 0.10291961f, 0.06452144f, 
    -0.44370538f, 0.02806514f, -0.12169790f, 0.11132661f, 0.27963322f, -0.03053063f, 0.08735358f, -0.08576392f, 
    0.10886323f, -0.01424851f, 0.05166445f, 0.02847405f, 0.73985982f, 0.20103993f, -0.08593359f, 0.04815488f, 
    0.17619340f, 0.04400764f, -0.20434307f, 0.14308366f, 0.13696900f, 0.19616130f, -0.01015698f, -0.11871999f, 
    0.16263464f, -0.00991554f, -0.09031460f, 0.04172322f, 0.27992761f, 0.21447413f, -0.00154976f, 0.03243474f, 
    -0.15743840f, -0.03427675f, 0.17107217f, 0.15048368f, -0.26109588f, 0.02098198f, -0.10505367f, 0.12168121f, 
    -0.10726267f, 0.06454340f, 0.04249935f, -0.10112347f, 0.04275232f, 0.05509776f, -0.10861585f, -0.03680587f, 
    0.03921404f, -0.21345606f, -0.59917414f, 0.25673801f, -0.14632356f, -0.06449487f, 0.15263081f, 0.01684384f, 
    0.09120392f, 0.00129836f, 0.01936572f, 0.02004807f, 0.36614951f, -0.15497549f, 0.09446208f, -0.22752921f, 
    0.04353296f, -0.05202777f, 0.01451389f, 0.20720853f, 0.05700391f, -0.04938460f, -0.01688070f, -0.18827213f, 
    0.17692009f, 0.12527920f, -0.28783518f, 0.14308599f, -0.04906416f, 0.04934863f, 0.00145401f, -0.07224546f, 
    0.21761973f, -0.02114392f, 0.01117104f, -0.23355900f, -0.07683492f, -0.07096881f, 0.38548282f, 0.32716709f, 
    0.06722100f, 0.18271753f, -0.05228576f, -0.09590381f, 0.07320119f, 0.09277681f, -0.09921085f, -0.01307350f, 
    0.02284607f, 0.18880333f, -0.15332255f, 0.02215726f, 0.27362618f, 0.04600837f, -0.00627650f, -0.05693861f, 
    0.02254299f, 0.06765664f, 0.05068509f, 0.12618129f, 0.09407354f, -0.07758787f, 0.21836597f, 0.03595910f, 
    -0.18680491f, 0.03119701f, 0.08671428f, -0.01857804f, -0.00524052f, 0.05330712f, -0.01820307f, -0.03465701f, 
    0.43365553f, 0.02297352f, 0.10929359f, -0.20695375f, 0.01938556f, -0.05977147f, 0.18184628f, -0.04248414f, 
    0.05134331f, -0.05294580f, 0.00210800f, -0.08612917f, -0.45615047f, -0.13849841f, 0.09090339f, -0.19092314f, 
    0.08298492f, 0.10904332f, 0.12213401f, -0.04741729f, 0.06767164f, 0.02624191f, 0.04440236f, 0.13945942f, 
    0.30654898f, 0.09578767f, 0.06169922f, 0.31950545f, -0.07349480f, 0.05908956f, 0.19694552f, -0.08783899f, 
    0.02173101f, 0.00942050f, 0.16776660f, -0.01034515f, 0.02143313f, -0.18740191f, 0.09035647f, -0.39463115f, 
    -0.02112421f, -0.11548508f, -0.02496384f, -0.07372873f, 0.09948599f, -0.15460612f, -0.06230491f, 0.01155348f, 
    -0.02202419f, 0.36615553f, -0.19480547f, -0.06789926f, 0.14618258f, 0.03429218f, 0.02326943f, 0.15371691f, 
    -0.11362462f, -0.04617960f, -0.02343675f, -0.02819284f, 0.07302277f, 0.12266416f, -0.03634446f, 0.50132412f, 
    0.28384700f, 0.06076750f, -0.18285210f, -0.07931910f, 0.07717375f, 0.03229364f, -0.14916953f, 0.03538051f, 
    -0.08675195f, 0.03285561f, -0.01010260f, -0.35976791f, 0.09064192f, -0.03732818f, 0.02726547f, 0.01727098f, 
    -0.09018096f, -0.09205190f, -0.09532379f, -0.06930403f, 0.16479163f, -0.20124553f, 0.14433068f, 0.66367507f, 
    0.03887784f, -0.10607126f, -0.11428375f, 0.21514948f, 0.01914505f, 0.05145941f, 0.07844327f, 0.15601765f, 
    -0.00445916f, -0.07378378f, 0.01527709f, -0.05628065f, 0.05288694f, -0.06564982f, -0.01513184f, -0.01254085f, 
    0.03734498f, 0.02370807f, 0.04131808f, 0.05309944f, -0.02846304f, -0.04735405f, 0.03086105f, -0.02193644f, 
    -0.03728078f, 0.06015028f, 0.05591123f, 0.01802116f, -0.03814551f, 0.05577908f, -0.07323706f, -0.00292959f, 
    -0.05010459f, 0.02990407f, -0.05810839f, 0.01697166f, 0.04818485f, -0.01898312f, -0.03409081f, -0.02985116f, 
    0.05561016f, 0.01164819f, 0.04221144f, -0.01426043f, -0.04078110f, -0.02171489f, -0.00590378f, -0.04593900f, 
    -0.02524940f, -0.06247443f, 0.06430616f, 0.05713787f, -0.04623514f, -0.00086045f, -0.04056266f, -0.04755918f, 
    -0.01598528f, -0.03552167f, 0.05332337f, -0.05335855f, 0.00133678f, 0.03508164f, -0.01379634f, 0.05090046f, 
    0.00907922f, -0.01984767f, 0.05825127f, 0.05364431f, -0.04579601f, 0.03241847f, 0.03547729f, -0.01773551f, 
    -0.02397148f, 0.00146524f, 0.04100637f, 0.03768481f, -0.00031401f, -0.07571679f, 0.01620500f, 0.06430203f, 
    -0.01587674f, 0.05363399f, -0.04753644f, 0.01393527f, -0.02117510f, 0.00066857f, -0.05018096f, 0.01082488f, 
    -0.03611147f, -0.00007131f, 0.04099728f, -0.01976781f, -0.06950447f, -0.04070252f, -0.01871239f, -0.02246928f, 
    0.00028948f, 0.02846699f, -0.01281739f, -0.01579874f, 0.06096909f, 0.02213082f, 0.02174286f, -0.01733941f, 
    -0.04106541f, 0.05962706f, 0.05248054f, -0.06147033f, 0.05925056f, -0.04140773f, -0.06618215f, -0.00992624f, 
    0.00224614f, 0.06450367f, -0.02602555f, -0.07187086f, -0.04224614f, 0.02843425f, -0.01275956f, -0.05175932f, 
    0.04193312f, -0.00754769f, 0.04811988f, 0.04427551f, -0.05804485f, -0.03968105f, -0.03493881f, 0.06038130f, 
    0.06782369f, 0.01178371f, -0.07289958f, 0.03863740f, -0.06475889f, 0.02344719f, -0.00295468f, -0.07704231f, 
    -0.04674673f, -0.05397724f, -0.05135065f, -0.03576054f, -0.03397907f, 0.05612995f, -0.03902761f, 0.03445776f, 
    -0.07677272f, 0.02580414f, -0.00721084f, -0.00536622f, 0.04161310f, -0.02507365f, 0.00398566f, 0.01408091f, 
    0.05949707f, 0.05753919f, 0.00031742f, 0.03364345f, -0.07799448f, 0.00440134f, -0.06818696f, 0.01498168f, 
    0.04649643f, -0.00682430f, -0.04532253f, -0.04924325f, 0.04661510f, -0.06936341f, 0.05099523f, -0.07659802f, 
    -0.05419907f, -0.03356104f, 0.02487463f, 0.04834367f, -0.05806885f, 0.02188286f, -0.00861552f, 0.02123100f, 
    -0.02672312f, -0.03732681f, -0.00008102f, 0.01783829f, -0.05896957f, -0.06910400f, 0.04792278f, -0.05522107f, 
    -0.03936697f, -0.02248340f, -0.03914049f, -0.07469772f, -0.07444575f, -0.07035929f, -0.05098330f, 0.01462717f, 
    -0.05324589f, 0.03422861f, 0.01117348f, -0.04476508f, -0.05493772f, -0.00902737f, 0.01229668f, -0.07209282f, 
    0.49092090f, 0.36842164f, 0.09116867f, 0.17257635f, -0.11965499f, -0.10251790f, 0.13720600f, -0.00955889f, 
    0.09316316f, 0.00991951f, 0.01324079f, 0.18105164f, 0.19678645f, 0.08226921f, -0.19293919f, -0.24723856f, 
    -0.03952083f, 0.09516463f, -0.15835527f, 0.02191205f, 0.07697660f, 0.12109091f, -0.03392610f, -0.08978893f, 
    0.15787002f, -0.39882898f, 0.11872550f, -0.11110455f, -0.04074139f, 0.24275298f, 0.15586294f, 0.07804961f, 
    0.19934890f, -0.02793018f, -0.03225546f, -0.05260096f, -0.57190418f, 0.38400206f, -0.12055798f, 0.18575731f, 
    0.00679824f, -0.00384930f, -0.18445277f, 0.21230136f, -0.05816797f, -0.20384465f, 0.00516968f, -0.18783164f, 
    0.22653721f, -0.12617357f, -0.03831570f, -0.01476356f, -0.00368978f, -0.03844491f, 0.07533404f, -0.03680392f, 
    0.12917575f, -0.04688829f, -0.05705643f, -0.10131093f, -0.39737543f, 0.38770050f, 0.10092366f, 0.14323266f, 
    -0.14802536f, 0.10037310f, 0.06767094f, 0.18337318f, 0.24981591f, 0.08349166f, 0.06414758f, 0.12443933f, 
    0.49959892f, 0.16451621f, 0.22974221f, 0.22204727f, -0.01455567f, -0.23912908f, 0.09004790f, 0.11963014f, 
    0.04874147f, -0.06904818f, 0.09491435f, 0.06851947f, -0.44408041f, 0.30596805f, -0.18051261f, -0.26782843f, 
    0.15350564f, 0.15153782f, 0.05446674f, 0.06236579f, 0.05230316f, 0.13141772f, 0.09209226f, 0.14732881f, 
    -0.51545370f, 0.20223908f, -0.43879983f, 0.16016614f, -0.01266424f, 0.06601514f, -0.06992385f, -0.08059416f, 
    0.12359473f, -0.02233815f, 0.12177596f, 0.13907143f, 0.51761520f, -0.46837121f, 0.19282930f, 0.22051704f, 
    -0.06334031f, 0.00627399f, 0.01882757f, -0.05162553f, 0.14440489f, 0.00273064f, 0.04296385f, 0.10376855f, 
    0.05765271f, -0.40909144f, -0.21803030f, -0.33943695f, 0.07282352f, 0.15292530f, 0.27360421f, -0.01144288f, 
    0.16758555f, -0.04570945f, 0.08637545f, -0.08616921f, 0.01312851f, -0.00447424f, 0.11793038f, 0.08397941f, 
    -0.09289388f, 0.20958729f, -0.06700685f, -0.02992633f, 0.10745730f, -0.09095069f, -0.12891604f, -0.10322322f, 
    0.19401802f, 0.37683055f, -0.01617000f, 0.20325419f, 0.09390134f, -0.16695976f, -0.06273502f, 0.23951106f, 
    0.08809001f, -0.04784057f, 0.06667309f, 0.06911045f, 0.02040251f, -0.31008798f, -0.07410619f, -0.07068522f, 
    0.03682186f, 0.06053026f, 0.05182610f, -0.29517752f, -0.13199469f, -0.11094094f, 0.01112360f, -0.03094432f, 
    0.38698140f, -0.52967590f, 0.05338311f, 0.17701767f, -0.02028483f, -0.18041082f, -0.15072915f, 0.06634970f, 
    0.03625264f, 0.06653871f, -0.18584906f, 0.03839533f, -0.38980496f, -0.00725948f, 0.12652521f, 0.24657854f, 
    -0.13022383f, 0.00845679f, 0.19391778f, -0.13971266f, 0.02496922f, 0.07527421f, 0.14607823f, 0.26652548f, 
    0.00768214f, -0.02635029f, 0.02377022f, -0.06038190f, -0.01898501f, -0.06768938f, -0.02571017f, -0.01598897f, 
    -0.05710213f, 0.02743630f, 0.04206172f, -0.04471367f, 0.00591180f, 0.05705493f, 0.04057021f, -0.03520435f, 
    0.01446188f, -0.07971822f, -0.06632147f, 0.01520228f, -0.08394296f, 0.02671630f, -0.05651563f, -0.00584880f, 
    0.00383782f, -0.05413457f, -0.04777237f, -0.02042662f, -0.00407467f, 0.01680039f, 0.01943477f, 0.01205455f, 
    -0.06346402f, 0.02760732f, -0.04798394f, -0.00724821f, -0.06771763f, -0.04238524f, 0.02522291f, -0.05156279f, 
    -0.02755694f, -0.05760334f, -0.04137236f, -0.02025850f, -0.03123929f, -0.06506731f, -0.00762863f, 0.00897235f, 
    -0.00546605f, 0.05085878f, 0.00607298f, -0.05906154f, 0.02243693f, -0.07982355f, -0.03979083f, 0.04219593f, 
    -0.07636044f, -0.03439530f, -0.01840260f, 0.01830976f, -0.05666742f, -0.02330441f, -0.06976360f, 0.04026331f, 
    0.00662713f, 0.00300470f, -0.06734201f, 0.03208406f, -0.05576769f, 0.03711214f, -0.03430706f, -0.04254316f, 
    -0.00729212f, 0.02410179f, -0.02274667f, -0.00557319f, -0.04679037f, -0.00359176f, 0.04235589f, 0.02287623f, 
    0.01508494f, 0.02268498f, -0.06760141f, 0.03406146f, -0.07173201f, -0.03072639f, -0.03906794f, -0.03970701f, 
    0.01925456f, -0.06720012f, -0.00541839f, -0.01960566f, -0.08133531f, -0.05028445f, -0.00604282f, -0.00599593f, 
    0.04692543f, -0.05748403f, 0.03593600f, 0.01860360f, 0.04373925f, 0.03725648f, 0.05026171f, -0.05429140f, 
    -0.02183128f, -0.02597303f, -0.04400420f, 0.01066751f, -0.01426431f, -0.08070535f, 0.04760150f, 0.04786405f, 
    0.00497861f, -0.08121881f, -0.01241670f, -0.00323868f, -0.05024699f, 0.04587100f, -0.02041815f, 0.06111716f, 
    -0.07207680f, 0.03681737f, -0.03737301f, -0.00437986f, 0.00066763f, -0.02759646f, -0.00320769f, 0.04836671f, 
    -0.05148615f, -0.02328645f, -0.04262013f, -0.05207889f, 0.03269882f, -0.08638874f, 0.00115591f, 0.02508758f, 
    -0.01317313f, -0.00011679f, -0.01778023f, 0.02305110f, -0.05296472f, -0.02315329f, 0.05418582f, 0.06112577f, 
    -0.00297857f, -0.03197550f, -0.08500073f, -0.05061372f, 0.03454176f, -0.00368664f, 0.01199679f, -0.02643085f, 
    0.02380102f, 0.06595393f, -0.00267373f, -0.04999278f, 0.04681336f, 0.05463956f, -0.02053860f, 0.01635418f, 
    -0.06727924f, 0.01007256f, -0.05639989f, -0.04599035f, 0.04737945f, 0.05183449f, -0.07538775f, 0.01174635f, 
    0.02103635f, -0.01030593f, -0.04424684f, 0.05005703f, -0.08357435f, 0.05041785f, -0.04026095f, -0.02632927f, 
    -0.03590909f, 0.02989545f, -0.00029667f, 0.06083041f, -0.03822818f, 0.02690371f, -0.07608914f, -0.03956819f, 
    -0.05608971f, -0.07164089f, -0.05427051f, 0.02248187f, -0.01821979f, -0.03949755f, 0.00025431f, 0.00580648f, 
    0.00493448f, -0.01680274f, -0.05848781f, 0.02664079f, -0.03965958f, 0.04243654f, 0.04061186f, -0.01974102f, 
    0.03686612f, 0.00464878f, 0.03767203f, -0.07841761f, 0.05601913f, 0.04822255f, -0.07490943f, -0.06511849f, 
    0.00440136f, -0.07615477f, -0.03317340f, 0.00051972f, 0.02917003f, -0.07624479f, 0.00799708f, -0.00934154f, 
    -0.04600534f, -0.05972142f, 0.00653351f, 0.02931428f, -0.03621924f, -0.00465376f, 0.05911418f, 0.00033368f, 
    0.01148280f, -0.06495599f, -0.03989012f, -0.03537460f, -0.06078670f, 0.00760610f, 0.03939313f, -0.06175411f, 
    -0.04024798f, 0.00804294f, -0.01371501f, -0.03035998f, -0.07159214f, -0.03283666f, 0.04411478f, -0.02687979f, 
    0.05048119f, -0.01280846f, -0.07735052f, -0.04998810f, 0.04573984f, -0.07723311f, 0.05966056f, 0.00381301f, 
    -0.01313486f, -0.01006229f, -0.06115871f, -0.01541205f, -0.04495088f, -0.05334480f, -0.07560606f, 0.00879125f, 
    -0.01647150f, -0.00932711f, -0.00669460f, -0.02626768f, -0.02313668f, 0.02515330f, -0.06378358f, 0.05273564f, 
    -0.01316085f, 0.03128694f, 0.00031183f, -0.06032461f, 0.02269323f, 0.02353243f, -0.07315745f, -0.01005260f, 
    -0.00940678f, -0.01928078f, -0.05892973f, -0.02059439f, 0.01265257f, -0.03899291f, -0.04630480f, -0.06047759f, 
    -0.04708580f, -0.05969208f, -0.02382765f, -0.04382810f, 0.02428011f, 0.04252708f, 0.02498034f, 0.02611619f, 
    0.03846837f, -0.05702121f, 0.02983825f, 0.01681500f, -0.04056316f, -0.01235776f, -0.00446984f, 0.00930595f, 
    -0.07558877f, -0.07493283f, 0.04055405f, 0.02347452f, -0.04795133f, -0.07656895f, -0.07164579f, 0.03774432f, 
    0.04587179f, -0.06351671f, 0.02343740f, 0.00681169f, -0.04683169f, -0.01290169f, 0.04738330f, -0.06080379f, 
    -0.03992407f, -0.00736755f, -0.03957537f, 0.01321810f, -0.02454518f, 0.04325426f, 0.02505640f, -0.04269926f, 
    0.06154579f, 0.04852693f, 0.01830037f, 0.05764891f, -0.07066009f, 0.04045164f, -0.02688972f, 0.04872365f, 
    -0.00158710f, 0.04113049f, 0.01861252f, 0.02528874f, -0.02610618f, -0.07548689f, 0.01524602f, 0.02944450f, 
    0.01758756f, -0.00352203f, -0.06369080f, 0.01183929f, -0.05980398f, 0.01861645f, 0.00174777f, -0.04254937f, 
    -0.05969030f, 0.00147684f, -0.04679021f, -0.07339968f, -0.05948127f, 0.01921434f, -0.05219236f, -0.07494938f, 
    0.04748120f, -0.02413712f, 0.06081940f, -0.02787058f, 0.02027129f, 0.05558468f, -0.04817382f, 0.05846843f, 
    -0.00295238f, -0.04374978f, -0.04528306f, -0.04036614f, 0.04608800f, -0.03748719f, -0.05633340f, 0.06092359f, 
    -0.02833386f, 0.06280687f, -0.01508822f, 0.05073130f, -0.06281231f, -0.05482586f, 0.00438201f, -0.01328362f, 
    -0.05721568f, -0.00030386f, 0.00790135f, 0.03968496f, 0.06318297f, -0.07489461f, -0.02478512f, -0.00691102f, 
    -0.10117690f, 0.26516959f, 0.50574380f, -0.13737306f, -0.06459049f, 0.07527841f, 0.08157194f, -0.04042946f, 
    0.10561685f, 0.13587731f, -0.14351000f, -0.04728216f, 0.09428570f, -0.39178622f, -0.24428770f, 0.05908545f, 
    0.00897696f, -0.05622167f, -0.00584971f, -0.15463273f, -0.01936440f, 0.07929078f, -0.02541237f, 0.14504363f, 
    -0.16768171f, -0.15369868f, 0.56419027f, 0.05618475f, 0.34167305f, 0.11027712f, 0.10217362f, -0.04615328f, 
    0.14350165f, -0.05671038f, 0.02091181f, -0.15891920f, -0.06909744f, 0.04947600f, 0.03983974f, 0.19914584f, 
    0.02091498f, 0.16358332f, -0.07347846f, 0.05574735f, -0.01583622f, 0.06957594f, 0.15747406f, 0.01611238f, 
    -0.08368455f, -0.04208748f, 0.02630276f, 0.23634484f, 0.10470515f, -0.02411518f, 0.03908953f, -0.03319900f, 
    0.04240164f, 0.19619676f, 0.07473371f, 0.10905837f, 0.31477135f, 0.08052845f, -0.49610615f, -0.04061689f, 
    0.04131609f, 0.07583494f, 0.19177991f, 0.01816496f, 0.02289030f, 0.09059523f, -0.03896219f, -0.03366940f, 
    -0.02060528f, -0.06069338f, 0.22681645f, 0.27519733f, 0.08086870f, -0.01562632f, 0.14596957f, 0.01022209f, 
    -0.22969265f, 0.14034069f, -0.01151188f, 0.07147278f, 0.24014930f, 0.15062384f, -0.04795279f, 0.06182246f, 
    0.14418776f, -0.01277907f, 0.09963518f, 0.16055425f, -0.04660096f, 0.11391946f, -0.03427063f, -0.03811628f, 
    -0.03832667f, 0.02445555f, -0.29426309f, 0.03609100f, 0.00426264f, -0.04264563f, -0.07077869f, 0.06298526f, 
    -0.09092948f, -0.08945993f, 0.05866231f, -0.07356587f, -0.15047592f, 0.31684297f, 0.02350323f, -0.37766454f, 
    0.13953860f, -0.10300030f, 0.13714115f, 0.03411424f, 0.05221069f, -0.07276567f, 0.05198244f, 0.18322675f, 
    -0.23001304f, -0.27947730f, -0.12779297f, -0.00613089f, 0.16925156f, -0.05157652f, -0.14196089f, 0.23660482f, 
    0.23858096f, -0.03511157f, -0.18930726f, 0.04927268f, 0.20336851f, -0.02762638f, -0.15214929f, -0.06307966f, 
    0.22675167f, 0.13172668f, -0.01923470f, 0.19413324f, 0.13166811f, -0.27002481f, 0.02642131f, 0.14704905f, 
    -0.46641394f, 0.25443974f, 0.61293954f, -0.00133017f, -0.05957288f, 0.02676396f, 0.07262568f, -0.12650895f, 
    0.05438823f, -0.02704610f, -0.03443669f, 0.12940159f, -0.05947130f, -0.31420261f, 0.26930803f, 0.09437010f, 
    0.01953447f, 0.11336004f, 0.17922279f, -0.10907678f, -0.01311455f, 0.11844286f, 0.11805976f, 0.08020954f, 
    -0.03030093f, -0.01799420f, -0.13186179f, -0.31823438f, -0.04170062f, 0.00247397f, 0.01093007f, 0.08555155f, 
    0.08829507f, 0.13144992f, -0.07907227f, 0.02340889f, -0.22760542f, -0.00083512f, -0.22663765f, -0.39100084f, 
    0.08851561f, -0.04755856f, 0.11055690f, -0.04739747f, -0.18696764f, 0.10921449f, 0.11084948f, 0.05838658f, 
    0.02412671f, -0.08094757f, -0.04594639f, -0.01095959f, -0.04212387f, -0.02122223f, 0.03616155f, -0.07479536f, 
    0.03295335f, -0.07761654f, -0.07979674f, 0.00349385f, -0.05762079f, 0.05473819f, 0.02847349f, -0.04404729f, 
    0.00936994f, -0.01507427f, 0.02788846f, -0.06495488f, -0.02189513f, 0.02418850f, -0.03734608f, -0.02732312f, 
    0.02808516f, -0.05030149f, 0.03955572f, -0.00023907f, -0.03998983f, -0.07739897f, -0.01857688f, -0.06648188f, 
    0.01982933f, 0.01135242f, -0.02123744f, -0.00449705f, 0.04588341f, -0.04385855f, 0.00005202f, -0.00210369f, 
    0.01610398f, 0.01387327f, 0.02472720f, -0.08378374f, -0.04558102f, 0.02057622f, -0.04188393f, -0.07164982f, 
    -0.09445637f, -0.08438956f, -0.06568599f, -0.06469569f, -0.02837146f, -0.06003617f, -0.02829372f, -0.00676562f, 
    -0.06803098f, -0.06544138f, -0.06570239f, -0.08902502f, -0.06795869f, -0.00589862f, 0.05153039f, 0.02216019f, 
    0.01116219f, -0.07938707f, -0.04295523f, -0.04794469f, -0.03892986f, -0.02566183f, 0.02848010f, -0.08633342f, 
    -0.04287608f, 0.01801402f, -0.03863287f, -0.00169135f, -0.02008036f, 0.03652560f, 0.04367846f, -0.06160324f, 
    -0.08138511f, -0.01290252f, 0.01720969f, 0.00972761f, -0.06404480f, -0.08210783f, -0.04493895f, -0.09241486f, 
    -0.09568116f, -0.09348480f, -0.04390036f, -0.00055777f, 0.00002939f, 0.03273733f, -0.02688634f, -0.07048927f, 
    0.00490810f, -0.00413442f, -0.05286357f, -0.03758222f, 0.03291350f, -0.04101747f, 0.00862766f, -0.06510070f, 
    -0.03642709f, -0.08216903f, -0.02616419f, 0.03532853f, 0.02520447f, -0.03707815f, 0.04337027f, 0.04478051f, 
    0.03238176f, -0.09185125f, 0.01208546f, -0.00586710f, -0.06776088f, -0.05582263f, 0.02876786f, -0.05171406f, 
    -0.01620335f, 0.04737478f, 0.03084215f, -0.07435206f, 0.04347335f, -0.00803012f, 0.01495246f, -0.00613741f, 
    0.04395112f, 0.03483731f, -0.06587441f, 0.01764338f, 0.02834417f, -0.05864540f, -0.05333075f, -0.00693813f, 
    -0.07032741f, -0.04733992f, 0.04712586f, -0.05290548f, 0.02169777f, -0.09229708f, -0.05123572f, -0.05655278f, 
    -0.08361627f, -0.05036073f, 0.02039125f, -0.08700791f, 0.00084597f, -0.04875719f, -0.07828322f, -0.08295548f, 
    -0.03554289f, 0.00958747f, -0.03513745f, -0.03278993f, 0.00119505f, -0.05129104f, 0.04314532f, 0.00884003f, 
    -0.08818609f, -0.00755332f, -0.02103586f, -0.08614755f, 0.03490219f, -0.01405086f, -0.09355773f, 0.01906195f, 
    -0.05076894f, -0.02004620f, 0.02771894f, 0.04101271f, 0.01174220f, 0.00645530f, -0.02733914f, -0.05858356f, 
    -0.04853107f, 0.00990975f, -0.06215018f, 0.03743509f, 0.02521846f, -0.03996169f, -0.08624283f, -0.07579351f, 
    -0.07171608f, -0.07367412f, 0.05362307f, -0.03742119f, -0.02328145f, 0.01107942f, -0.06064926f, 0.04618810f, 
    -0.05203739f, 0.05870755f, 0.06301274f, 0.00473481f, -0.05766764f, -0.03117552f, -0.04915557f, -0.04924275f, 
    0.01124047f, -0.03286206f, -0.04073074f, 0.05612170f, 0.05314475f, -0.04885987f, 0.03770834f, -0.05540945f, 
    -0.07890668f, -0.02708396f, -0.01011475f, -0.00453240f, 0.02495130f, -0.03906428f, -0.05821259f, 0.01092392f, 
    -0.02602755f, -0.00779390f, -0.06069900f, -0.03104476f, -0.07557704f, 0.01533510f, -0.04927011f, 0.02587787f, 
    0.05741419f, -0.03108047f, 0.02547039f, -0.01780421f, -0.01685403f, -0.02891365f, 0.01652611f, -0.06002993f, 
    -0.04697740f, -0.01413272f, 0.01417106f, 0.01627789f, 0.05590364f, -0.07604167f, 0.02613285f, -0.04242707f, 
    0.00144113f, 0.03568389f, -0.01189099f, 0.04882084f, 0.06163038f, -0.04042335f, 0.02251189f, -0.00942384f, 
    -0.04860333f, -0.00825134f, 0.00494188f, -0.03968734f, -0.02206215f, -0.05947723f, 0.03136585f, -0.03474494f, 
    -0.00331552f, 0.03400505f, -0.05678064f, -0.02862897f, 0.06538845f, 0.00496256f, -0.06632359f, 0.05596229f, 
    -0.06198785f, -0.05245547f, -0.00028456f, -0.03102677f, -0.04009824f, 0.06010600f, -0.05965530f, 0.03070850f, 
    -0.01156857f, -0.04664452f, 0.03875945f, 0.04680279f, -0.04967719f, -0.05628631f, -0.05874392f, 0.02124410f, 
    0.00801200f, -0.07920977f, 0.02783252f, -0.04355686f, 0.05646228f, -0.03090331f, -0.06035747f, 0.01874684f, 
    -0.01006907f, -0.07471505f, -0.04372481f, 0.00952288f, -0.00830695f, 0.02386550f, -0.00856400f, -0.04755491f, 
    -0.07341967f, -0.06858007f, 0.04278166f, -0.03563938f, -0.02665231f, -0.05789781f, -0.01058868f, -0.03516103f, 
    0.04109922f, 0.02218121f, -0.04262494f, 0.02723164f, -0.07672784f, -0.07103941f, -0.05363975f, -0.07477465f, 
    -0.05286367f, 0.04756496f, -0.05676534f, 0.03613169f, 0.00945502f, 0.01287246f, -0.01749543f, -0.02899421f, 
    0.04450562f, -0.02516591f, -0.01137435f, -0.00836894f, 0.00403475f, -0.04397784f, -0.01121580f, 0.02083210f, 
    -0.04016880f, -0.06528734f, -0.05816194f, 0.05894452f, 0.03724159f, -0.01348331f, -0.06965011f, 0.05639451f, 
    -0.07490539f, -0.05346014f, -0.00113080f, 0.05026644f, -0.06681793f, 0.04466728f, -0.01375642f, 0.04655710f, 
    -0.02449700f, 0.04999177f, -0.06263544f, 0.05607175f, -0.07895689f, -0.04357374f, 0.01741309f, -0.06871548f, 
    0.05661416f, -0.05102259f, -0.03406059f, -0.07380573f, 0.03178902f, -0.05018527f, -0.04642762f, -0.06285077f, 
    0.00048297f, 0.04874420f, -0.05821993f, -0.06010023f, 0.05104291f, -0.05375813f, -0.07082105f, 0.06023242f, 
    0.00672233f, -0.06375558f, -0.05025396f, -0.04147211f, -0.02750883f, 0.05829995f, 0.06324168f, -0.01827812f, 
    -0.05670471f, -0.05237279f, -0.06402459f, 0.04307463f, -0.03545512f, 0.05175073f, -0.07680727f, 0.01230796f, 
    0.10896803f, -0.05925909f, 0.07323569f, -0.15338145f, 0.20836136f, 0.09162229f, -0.23586614f, -0.17478065f, 
    -0.13385621f, 0.19120863f, -0.23640388f, -0.14066195f, 0.81066638f, -0.01972812f, 0.05459234f, 0.20816357f, 
    0.02296961f, -0.02004003f, 0.32098749f, 0.23533925f, -0.13993876f, -0.14220974f, 0.16054614f, 0.17911401f, 
    -0.15969390f, 0.25010902f, -0.18842953f, -0.01027204f, 0.03768586f, -0.23145583f, 0.09923422f, 0.13230777f, 
    0.06074306f, -0.06871323f, 0.02583284f, -0.08048863f, 0.42956531f, -0.25147936f, -0.32993099f, -0.25398371f, 
    0.03336181f, -0.07011512f, 0.18537749f, 0.07344225f, 0.14369455f, 0.12989068f, 0.00455793f, 0.22861217f, 
    0.03662415f, -0.05580503f, 0.13367999f, 0.06583919f, -0.01049769f, 0.01174880f, 0.10811593f, 0.03776765f, 
    -0.20869169f, 0.28521979f, -0.08540807f, 0.07622641f, 0.46609861f, -0.46836287f, 0.03523907f, 0.17738712f, 
    -0.07241789f, -0.07969956f, -0.14883737f, -0.20607661f, -0.22910969f, -0.12087754f, -0.14950188f, -0.09438719f, 
    -0.25627121f, 0.34964305f, -0.20954695f, -0.09417702f, 0.02105040f, 0.19238305f, -0.30114532f, -0.25685132f, 
    -0.16064903f, -0.13124879f, -0.07102077f, 0.07692914f, -0.01576904f, -0.15330593f, 0.35226533f, 0.11213101f, 
    0.12578133f, -0.06031255f, 0.14602120f, 0.26474324f, 0.11372243f, -0.08622535f, -0.17984089f, -0.40488362f, 
    0.69318628f, 0.02049766f, -0.18447834f, 0.01106318f, 0.12856841f, -0.03269935f, 0.02664151f, -0.17544581f, 
    -0.14381646f, -0.01000125f, -0.04450478f, -0.19176178f, -0.06457204f, 0.40441579f, -0.10184985f, -0.26728022f, 
    0.19302861f, 0.01445025f, -0.19022040f, -0.18526362f, -0.04434960f, 0.15209942f, -0.02400506f, -0.08027366f, 
    0.00329822f, 0.37102273f, -0.15062204f, 0.23469408f, 0.12177314f, 0.10463899f, -0.01907099f, 0.19654305f, 
    0.24681488f, 0.31503794f, 0.07802045f, 0.19909893f, -0.44237196f, 0.10301369f, -0.19697355f, -0.13330217f, 
    0.09149206f, -0.22794326f, 0.03139365f, -0.11712951f, -0.08822518f, 0.00650381f, 0.27150366f, 0.21896957f, 
    0.01327712f, 0.19841298f, -0.01119032f, -0.24238330f, 0.07856987f, 0.15425712f, -0.12444904f, -0.36426276f, 
    -0.11312073f, -0.09084354f, 0.01740123f, -0.10835078f, 0.01952395f, 0.13905661f, 0.12044409f, 0.17227311f, 
    0.02182569f, 0.12058430f, 0.17530391f, 0.10602988f, 0.26106566f, 0.17695789f, 0.19509907f, 0.16718639f, 
    0.05499890f, 0.53974342f, -0.03996314f, 0.06971423f, 0.08597315f, 0.12530525f, 0.20525195f, -0.12583651f, 
    0.01684809f, 0.02581577f, 0.19396156f, -0.05358418f, -0.33329093f, -0.05038539f, 0.04699377f, 0.17034416f, 
    0.17500095f, 0.10829928f, -0.34399945f, 0.14013441f, -0.12264369f, -0.27118927f, 0.02758342f, 0.17676973f, 
    -0.00034695f, -0.00934030f, -0.03758475f, -0.07846352f, -0.04056408f, -0.04874619f, 0.03941983f, 0.06583928f, 
    0.01883524f, -0.00234923f, -0.00322402f, 0.05560708f, -0.03093790f, -0.06652339f, 0.00673291f, -0.02375634f, 
    -0.04565627f, -0.00715015f, 0.06394774f, 0.06701128f, -0.07081397f, -0.07529009f, 0.04168647f, 0.04987318f, 
    -0.04418147f, -0.03621979f, 0.02686263f, -0.03027709f, -0.06828711f, 0.04686037f, 0.05898376f, 0.02779531f, 
    0.01220941f, 0.01874754f, -0.02870819f, 0.05504498f, 0.00269720f, -0.03435772f, -0.04639090f, 0.04277252f, 
    -0.03645232f, -0.02058988f, 0.00741889f, 0.00475847f, 0.06143200f, 0.00833472f, -0.05289398f, -0.07081893f, 
    0.02848542f, 0.03476121f, 0.03051437f, -0.07343097f, -0.07415510f, -0.01873402f, 0.03147570f, -0.01790169f, 
    -0.07694910f, -0.05506017f, 0.01736764f, 0.02490650f, -0.06243188f, 0.01011220f, 0.01624949f, 0.06134067f, 
    0.03372643f, -0.04995273f, -0.00750441f, 0.01975436f, 0.04052066f, -0.04085774f, -0.02212492f, -0.03375810f, 
    0.05150576f, 0.05208980f, -0.05434434f, 0.03295909f, -0.03008002f, -0.06232542f, -0.06058878f, -0.07476029f, 
    0.00036513f, 0.00792906f, -0.05939836f, -0.06807325f, 0.02918617f, 0.01060440f, 0.03046183f, 0.05828631f, 
    -0.05601486f, -0.03833499f, -0.03535433f, -0.00252022f, -0.05150035f, 0.04800695f, -0.07404567f, -0.00516764f, 
    0.02039590f, -0.03724232f, -0.00321333f, 0.03664360f, -0.01107845f, -0.01866502f, -0.02441619f, 0.00364908f, 
    0.04553843f, 0.06152977f, -0.05902854f, 0.01274425f, -0.02753600f, -0.03561349f, 0.01439701f, 0.04003647f, 
    -0.07809184f, 0.02791792f, 0.00113575f, -0.06904116f, 0.00577940f, -0.07944591f, -0.01775257f, -0.01327223f, 
    -0.07119776f, 0.03721347f, -0.04978618f, 0.04112184f, 0.00235518f, -0.06020105f, 0.01233763f, 0.03851593f, 
    0.01827442f, -0.05272156f, -0.02970080f, -0.07249007f, -0.04136166f, 0.00733149f, -0.00209990f, 0.03461654f, 
    -0.03329203f, -0.05640623f, 0.05311000f, 0.04485219f, -0.05685435f, 0.04835198f, 0.05947954f, -0.04154001f, 
    0.04612361f, -0.07270263f, 0.02879809f, 0.03508352f, 0.00176167f, 0.01653539f, -0.02097984f, 0.02438964f, 
    -0.04735597f, -0.06558950f, 0.01999961f, 0.02829233f, -0.00658959f, 0.05143142f, -0.05448367f, 0.05983045f, 
    -0.03945187f, -0.00496553f, -0.01227933f, -0.01881320f, 0.00447813f, -0.07222974f, -0.03268112f, 0.02847438f, 
    -0.00963206f, -0.02630103f, 0.04203518f, -0.03170240f, 0.01439141f, -0.04912607f, -0.01867829f, -0.03551485f, 
    -0.04533254f, 0.02585211f, 0.04546743f, -0.04030690f, -0.01040850f, 0.02037864f, -0.06621992f, -0.04490828f, 
    0.03520127f, -0.00068951f, 0.04978672f, -0.02626502f, -0.02276981f, 0.04609864f, -0.02529933f, -0.05887156f, 
    0.96753579f, 0.02647702f, -0.24115926f, -0.13470539f, 0.05812961f, -0.23965278f, -0.05505308f, -0.03346514f, 
    0.07143630f, 0.07870934f, -0.02502918f, 0.00111361f, -0.01720135f, 0.03819736f, 0.16065064f, 0.10253486f, 
    -0.04414114f, 0.10288480f, -0.15300332f, 0.28396642f, 0.00554706f, 0.00538054f, 0.00430061f, -0.00838349f, 
    0.37723169f, 0.21925329f, -0.24173574f, -0.13653079f, -0.16230734f, 0.06838208f, -0.04357112f, -0.09672589f, 
    -0.08000018f, -0.01444965f, -0.01632532f, 0.04186055f, -0.29155880f, 0.05866020f, -0.25416440f, 0.19457218f, 
    -0.07445550f, -0.08893736f, 0.04316182f, 0.03715659f, -0.02114824f, 0.00843933f, -0.01200922f, 0.03485038f, 
    0.24214895f, 0.17077741f, 0.10430712f, -0.10681678f, 0.02292197f, -0.00784292f, 0.09773546f, -0.23381430f, 
    0.03346088f, -0.06770162f, -0.14736906f, -0.16255699f, -0.11972856f, -0.05398176f, 0.16160405f, -0.13062243f, 
    -0.07177047f, 0.16762042f, -0.09881011f, 0.00990201f, -0.03638689f, -0.11962153f, 0.10869396f, 0.20534763f, 
    0.19517766f, 0.11478464f, -0.25242481f, 0.06989143f, -0.19031005f, -0.03945375f, -0.03923755f, 0.10083564f, 
    0.09428439f, -0.01236520f, -0.02246598f, -0.14271012f, -0.06003956f, -0.04996151f, 0.28214294f, 0.01560940f, 
    0.12962672f, 0.06141402f, -0.03356684f, 0.20793653f, 0.00155762f, 0.02547339f, 0.00228353f, -0.06202316f, 
    -0.48497531f, 0.15827663f, -0.14512223f, 0.23505092f, -0.06463910f, -0.04842528f, -0.06533454f, 0.03882361f, 
    0.03708507f, -0.01415645f, 0.09046642f, -0.02116152f, 0.56411052f, -0.20388977f, -0.02806543f, 0.36963770f, 
    0.06603542f, 0.05244995f, -0.04605345f, 0.08937682f, 0.11047296f, -0.01516469f, -0.00698288f, -0.20608209f, 
    0.07848930f, 0.15669484f, 0.06189065f, -0.27984056f, 0.22478393f, -0.11187132f, 0.11984344f, -0.03768370f, 
    -0.11757955f, 0.03442292f, 0.14172158f, -0.04102103f, -0.02986879f, -0.30262619f, 0.03879524f, 0.12869449f, 
    -0.04568052f, -0.04191781f, 0.04877053f, 0.03061698f, -0.03487322f, 0.24096394f, 0.01087171f, -0.02296960f, 
    0.36775261f, 0.16051681f, -0.18099144f, -0.16459262f, 0.20165275f, -0.09600402f, -0.06678644f, 0.01802351f, 
    0.11788709f, 0.01825155f, 0.13073339f, 0.03018992f, 0.31594679f, 0.25548813f, -0.05199684f, -0.41888526f, 
    0.04159969f, -0.15430523f, -0.11150917f, -0.09872548f, 0.04609206f, -0.07213757f, 0.15037359f, -0.08091798f, 
    -0.07808366f, 0.15325274f, -0.14678206f, 0.31316748f, -0.04587390f, -0.17324887f, -0.04531438f, 0.04082728f, 
    -0.02802402f, 0.16964047f, -0.11859015f, 0.12341493f, -0.48234272f, -0.15632160f, -0.13592517f, 0.39480475f, 
    -0.09007235f, 0.04300001f, -0.03267655f, -0.14789408f, 0.06654336f, 0.09231496f, 0.05768941f, -0.04844968f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07835046f, 0.17854623f, 0.06148042f, -0.06177085f, -0.02227317f, 0.03068961f, 0.18540169f, 0.02145968f, 
    0.15951650f, -0.00081945f, -0.08563813f, -0.03726840f, 0.06313445f, -0.04156685f, 0.00486226f, -0.01283695f, 
    0.02700235f, -0.01780946f, 0.02881366f, 0.13441253f, 0.13614695f, 0.02770866f, -0.07525418f, 0.13900229f, 
    0.02685346f, -0.03075391f, 0.20507509f, 0.05324292f, -0.04173549f, -0.10667188f, 0.00642673f, -0.08426924f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.35643056f, -0.06665955f, -0.31084177f, -0.29834497f, 0.39931673f, -0.01540874f, -0.58024591f, -0.50989276f, 
    0.18612799f, -0.01677436f, 0.01521675f, -0.06192596f, -0.61773676f, 0.21591832f, 0.34665927f, 0.16146496f, 
    -0.07012912f, 0.01735982f, 0.09794268f, -0.40203717f, -0.68345326f, -0.62283468f, 0.11870570f, 0.42864954f, 
    0.11104844f, 0.04244088f, -0.14566208f, -0.15335280f, 0.08713418f, 0.14089188f, 0.11010410f, 0.29035923f, 
    0.43933016f, -0.09602624f, 0.08265222f, -0.36976615f, -0.05671529f, 0.13783878f, 0.43906102f, 0.16722232f, 
    0.25970760f, 0.34864888f, -0.06004047f, 0.09658059f, 0.03155131f, -0.37092534f, 0.00752625f, 0.07799274f, 
    -0.11368341f, -0.14643514f, -0.03148271f, -0.33235097f, -0.24335156f, -0.23779427f, -0.15299936f, 0.16206104f, 
    -0.14777994f, 0.03376679f, 0.10853796f, -0.05612690f, 0.02442455f, -0.98872823f, 0.08071825f, 0.09870593f, 
    0.23055637f, -0.56215453f, 0.20072733f, -0.45223472f, -0.01119980f, -0.12238454f, 0.10118821f, -0.24003446f, 
    0.31669515f, -0.42051327f, 0.34374538f, 0.32676795f, -0.50219709f, -0.49294448f, 0.08364031f, -0.14019743f, 
    0.16287944f, 0.03922912f, 0.03299247f, 0.21109210f, -0.21052383f, 0.07914140f, 0.09545986f, -0.36156878f, 
    0.01998461f, -0.10951611f, 0.24652162f, -0.14756480f, 0.08793423f, 0.53747886f, -0.10588614f, -0.33570051f, 
    -0.37377790f, -0.08935422f, -0.19786221f, 0.01767964f, 0.46363717f, -0.07576420f, 0.16197459f, 0.53585780f, 
    -0.17065929f, -0.09487118f, 0.04411176f, -0.30767739f, 0.41252831f, 0.10891321f, -0.16498590f, -0.11739937f, 
    -0.00215686f, -0.10074575f, 0.29340753f, -0.78748453f, 0.38363859f, 0.11453930f, 0.03999231f, -0.36897296f, 
    0.08368637f, -0.02099316f, -0.66720188f, -0.09875388f, -0.08085994f, -0.42597881f, -0.06723954f, -0.59803981f, 
    -0.12631088f, -0.69970900f, -0.08394311f, 0.37494028f, 0.05115988f, -0.09381513f, -0.33444461f, -0.30635992f, 
    -0.30224448f, 0.32078373f, -0.24201517f, 0.09420384f, 0.34085059f, 0.18076155f, 0.21378098f, 0.09388199f, 
    0.12242665f, 0.15833965f, -0.17392246f, -0.17296055f, 0.31301889f, -0.33269596f, 0.01938659f, -0.07410470f, 
    0.04875786f, -0.09590057f, 0.27646115f, -0.05245999f, 0.05978702f, -0.08526204f, -0.01473394f, -0.25132862f, 
    -0.25744137f, 0.34849912f, -0.23850691f, 0.38618189f, -0.03409045f, 0.10260116f, 0.13014825f, -0.26245233f, 
    -0.22500581f, 0.22200863f, -0.77984565f, -0.14435013f, -0.77195954f, -0.09027899f, 0.24429108f, -0.08449172f, 
    0.13647749f, 0.10386773f, -0.12346472f, 0.32904205f, -0.40361595f, 0.30083573f, -0.00469158f, 0.34289205f, 
    -0.13587396f, -0.02254284f, 0.02170827f, 0.03041544f, 0.08619922f, -0.26087201f, -0.06211479f, -0.16883489f, 
    -1.18276477f, 0.30844173f, 0.43017668f, -0.13434617f, -0.02927538f, 0.02274414f, -0.20163727f, 0.35740879f, 
    0.02732865f, 0.18945600f, 0.29593214f, 0.31047994f, -0.05912096f, -0.12842244f, -0.90390778f, -0.02998236f, 
    -0.11068930f, -0.13140483f, -0.72881806f, -0.02140381f, -0.40101886f, 0.32373545f, -0.05041259f, -0.11274804f, 
    -0.18378337f, -0.14115836f, 0.19253302f, 0.12217737f, 0.16250867f, 0.23680121f, -0.04324304f, -0.28351539f, 
    -0.04471841f, 0.10360996f, -0.57016116f, 0.22444519f, -0.26695973f, -0.12162284f, -0.28832614f, -0.41910264f, 
    -0.62499112f, -0.10702538f, 0.07863471f, 0.41672260f, 0.10445973f, 0.01933223f, -0.40466061f, 0.09762677f, 
    0.02773957f, 0.15270197f, 0.25411612f, 0.08436594f, -0.17138201f, 0.53293413f, -0.15723985f, -0.71526271f, 
    -0.11017008f, -0.03208030f, -0.55210757f, -0.13458870f, 0.08088440f, 0.55572736f, -0.05961668f, 0.03244448f, 
    0.34787363f, 0.23455259f, -0.30359781f, 0.19716521f, 0.07933879f, 0.06749372f, 0.06472990f, 0.10181282f, 
    0.24974409f, 0.15240633f, 0.26761925f, -0.41582531f, -0.22683077f, -0.60162884f, 0.28996220f, -0.06187130f, 
    -0.07790390f, -0.14603452f, -0.61355197f, 0.31820750f, 0.37564301f, 0.02211660f, 0.12973769f, -0.39264685f, 
    -0.04213415f, -0.01714888f, -0.62376422f, -0.14022975f, -0.03699490f, -0.14710727f, -0.11713257f, 0.39593112f, 
    -0.02772761f, 0.58503431f, 0.24256276f, -0.34944677f, -0.77985841f, 0.03835376f, -0.55199265f, 0.35501048f, 
    -0.08746387f, -0.19269776f, -0.42577109f, -0.03572424f, 0.39820319f, 0.01486637f, 0.32073733f, 0.02193965f, 
    -0.01279751f, -0.05464173f, 0.17135908f, 0.14415987f, -0.04630128f, -0.27972072f, -0.11106163f, -0.65818489f, 
    -0.04761803f, -0.16992716f, 0.25621140f, 0.13017082f, -0.11084522f, 0.42933479f, -0.15947729f, -0.09347120f, 
    0.07632265f, 0.35686529f, -0.40673178f, -0.24730264f, 0.03229656f, -0.11877009f, 0.50641966f, -0.75702459f, 
    0.39295453f, -0.79609072f, 0.17931345f, -0.32483557f, 0.33574450f, 0.03020357f, -0.72321510f, -0.09572527f, 
    0.07001978f, 0.02483404f, 0.08486713f, 0.00866676f, 0.37927011f, 0.16313247f, 0.01181638f, 0.07727718f, 
    -0.05040624f, 0.11772941f, 0.38658011f, -0.11999372f, -0.02015062f, -0.51007092f, -0.03950775f, -0.53422666f, 
    -0.57051331f, -0.29754788f, 0.24570855f, 0.28510955f, -0.67485148f, 0.12885828f, 0.10512336f, 0.40319583f, 
    -0.30184051f, -0.40088347f, -0.00743426f, -0.20228554f, -0.30923355f, 0.02150299f, -0.91991889f, 0.01290819f, 
    -0.14259097f, -0.16903572f, 0.10218243f, -0.11603127f, 0.02274174f, 0.29096678f, 0.09090216f, 0.35889331f, 
    0.10480803f, 0.04587836f, -0.15378359f, 0.08473481f, -0.06659792f, 0.09030764f, 0.11280418f, 0.71543103f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.03533830f, 0.09902711f, -0.27501586f, -0.00234921f, 0.01854069f, 0.11246905f, 0.08896080f, -0.19603907f, 
    -0.26434454f, -0.05061329f, 0.12368803f, -0.11004993f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
