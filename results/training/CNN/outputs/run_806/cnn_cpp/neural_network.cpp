#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.17161895f, 0.12403453f, 0.22679178f, -0.49312013f, -0.49650931f, -0.54939252f, -0.03790313f, 0.35181022f, 
    -0.25721136f, -0.51743358f, -0.22127320f, -0.11810535f, -0.11190116f, -0.42177877f, -0.58047307f, 0.40470636f, 
    -0.18280201f, 0.06655602f, -0.32924694f, 0.29549015f, -0.05929770f, -0.38428760f, -0.50778824f, -0.06388864f, 
    0.40060329f, 0.16449136f, 0.38928095f, -0.00218928f, -0.45951641f, -0.32629630f, -0.16986084f, 0.72195095f, 
    -0.49368408f, 0.27662510f, 0.21865477f, -0.08217093f, -0.55409461f, 0.65692902f, -0.27020371f, -0.36611050f, 
    0.13981780f, -0.44096550f, 0.08527973f, 0.20522410f, 0.03134677f, 0.52487838f, 0.37105161f, 0.43134582f, 
    -0.70065546f, 0.45758170f, -0.24478270f, 0.07245750f, 0.03121875f, -0.00684571f, 0.32187441f, 0.17026024f, 
    -0.54625583f, -0.02766010f, -0.64226794f, -0.30658442f, 0.20423277f, -0.20367610f, 0.46251428f, -0.35470015f, 
    0.59056050f, -0.55841851f, -0.18407445f, 0.40868661f, 0.13111043f, -0.17613873f, 0.02545047f, 0.08277713f, 
    -0.50850755f, -0.46871603f, -0.25091895f, 0.47558746f, 0.47516173f, -0.03940319f, 0.11780503f, -0.01480414f, 
    -0.24065319f, 0.56701696f, 0.64798510f, 0.23572171f, -0.20570292f, 0.11303793f, -0.31739748f, -0.15533786f, 
    0.22424318f, 0.08118057f, 0.08043962f, -0.56255722f, 0.22393723f, 0.12236322f, -0.03036787f, 0.33923697f, 
    0.13976648f, -0.13206317f, 0.33785102f, -0.47645569f, -0.44973087f, 0.05068053f, -0.40595129f, -0.13069236f, 
    0.62539536f, 0.21723652f, 0.06812564f, 0.40879935f, -0.24272938f, 0.04183615f, -0.36993852f, -0.38098466f, 
    0.10197809f, -0.37787050f, -0.35046044f, -0.33762339f, 0.02080500f, 0.51725626f, -0.05124353f, 0.29774654f, 
    -0.29121438f, -0.56320101f, -0.52751058f, 0.27022579f, 0.20996553f, -0.01332075f, -0.56222373f, -0.30930111f, 
    0.17334759f, -0.43756887f, 0.27104083f, -0.17531216f, 0.10969150f, 0.44222665f, -0.17498237f, 0.32840076f, 
    -0.56275707f, -0.44248646f, -0.52472520f, 0.21092862f, -0.08495127f, -0.39200318f, 0.12836118f, 0.22963428f, 
    0.30556068f, 0.37935272f, -0.56300062f, -0.47873425f, 0.32500520f, -0.38346896f, 0.23428503f, 0.31834254f, 
    0.20198877f, 0.25692311f, 0.45778018f, -0.32123309f, -0.38934252f, -0.69663304f, -0.20224646f, -0.17151015f, 
    -0.30434260f, -0.06330618f, 0.84938270f, 0.22848558f, 0.15951499f, 0.43885076f, 0.21620174f, -0.23303425f, 
    -0.21736850f, 0.50007874f, -0.04290017f, -0.82257354f, 0.42987031f, 0.29301846f, 0.17611441f, 0.55919260f, 
    0.28947264f, -0.38736144f, -0.29906067f, -0.22467043f, -0.93736613f, 0.10330258f, -0.45416796f, 0.01068992f, 
    0.56399357f, 0.46052292f, 0.01006832f, -0.00757110f, 0.44262052f, -0.46815991f, -0.53704584f, -0.36198065f, 
    -0.09582099f, 0.14704631f, -0.26301014f, -0.19558285f, -0.02039700f, -0.01634483f, -0.01308630f, 0.21482059f, 
    0.26375058f, -0.66905469f, -0.35387239f, -0.40601954f, 0.00192851f, -0.41211063f, 0.11478174f, 0.49778616f, 
    0.45412633f, 0.48355904f, -0.09230978f, 0.33506709f, 0.61053157f, -0.23087765f, -0.34993845f, 0.00310482f, 
    0.28981057f, 0.49470565f, 0.45112535f, -0.19260332f, -0.50777704f, 0.50568086f, -0.08725175f, 0.45991039f, 
    0.32155684f, -0.63130623f, -0.47390622f, -0.60009122f, -0.11249388f, -0.47411948f, 0.40036905f, 0.05702949f, 
    0.07957955f, -0.13851859f, -0.41155469f, 0.58401960f, -0.37055877f, 0.62986863f, -0.17762166f, -0.41537717f, 
    -0.22953001f, 0.16877803f, 0.07304911f, -0.19521728f, -0.48883307f, -0.43530276f, 0.55277169f, 0.22019932f, 
    0.43755263f, -0.27993888f, -0.42332500f, 0.09884310f, -0.39245006f, -0.03773621f, 0.50629956f, 0.62376064f, 
    -0.17069854f, 0.03066830f, 0.27790701f, 0.35362688f, 0.48577389f, 0.30802596f, 0.14611235f, 0.65064508f, 
    0.58727974f, 0.00128048f, -0.27703243f, 0.10676643f, -0.11984333f, 0.00704988f, 0.11592850f, -0.25081003f, 
    -0.44972941f, 0.77133822f, 0.45648986f, -0.13791417f, 0.07325622f, -0.04011545f, 0.05443388f, 0.61157346f, 
    -0.58757651f, 0.04468809f, -0.39743903f, -0.42377812f, 0.46258172f, -0.44521418f, -0.19082770f, -0.21469755f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24356447f, 0.10964339f, -0.22497150f, 0.16485895f, -0.09678540f, -0.15767990f, -0.06059257f, -0.06179683f, 
    0.14389847f, -0.05158845f, 0.16635670f, -0.17112802f, -0.17818850f, 0.19236004f, 0.07628736f, 0.10277676f, 
    0.04138940f, 0.18608080f, -0.12302594f, -0.14476120f, 0.04223163f, -0.08712637f, 0.21304034f, -0.08597918f, 
    -0.06186392f, -0.07401060f, -0.37678480f, -0.22443396f, -0.01541981f, 0.32798490f, -0.09486073f, -0.03886111f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.00890015f, -0.03656702f, 0.04691264f, -0.04487554f, 0.01151615f, 0.01129728f, -0.05121605f, -0.02552893f, 
    -0.04894463f, 0.02865778f, 0.02949692f, 0.02297783f, -0.01264763f, -0.06147790f, 0.02178827f, -0.03718242f, 
    0.04265709f, -0.02295167f, -0.06232076f, 0.04852815f, -0.03176412f, 0.03063583f, -0.05182730f, -0.03034434f, 
    -0.01565546f, 0.02689438f, 0.04814871f, -0.02934290f, -0.04453320f, -0.05934167f, -0.03940110f, -0.05217685f, 
    0.00947282f, 0.01670083f, -0.01357546f, -0.01967326f, 0.00048276f, -0.00228320f, 0.02017962f, -0.00359985f, 
    -0.00934005f, -0.05858575f, 0.01862432f, -0.02466408f, -0.00651473f, -0.00785808f, 0.03567953f, -0.05737533f, 
    -0.04538330f, 0.00935405f, 0.02664359f, -0.01784398f, 0.03938288f, 0.02050228f, -0.02914639f, 0.04373473f, 
    0.02250354f, -0.04926273f, 0.04573563f, -0.00632706f, 0.00437847f, 0.03652113f, 0.02592792f, -0.04677692f, 
    -0.05777280f, -0.03701162f, -0.01438032f, -0.01822460f, 0.03021171f, -0.03268294f, -0.02831523f, -0.06483158f, 
    0.03123267f, -0.01624833f, 0.04140934f, -0.01211993f, -0.00751354f, -0.01218817f, 0.04831579f, -0.02800582f, 
    -0.02482849f, 0.01930064f, -0.00099990f, -0.02351444f, 0.03768095f, -0.04594611f, 0.02772208f, 0.04369164f, 
    -0.06359411f, -0.03974969f, -0.02333911f, -0.05890984f, 0.05039901f, 0.05045742f, 0.02305497f, -0.00179702f, 
    0.00880135f, -0.06001966f, 0.01119494f, -0.03514595f, 0.01423209f, -0.00964032f, 0.03188708f, 0.01493321f, 
    -0.03353485f, -0.04085544f, 0.01220386f, -0.00512038f, -0.06003946f, -0.06399553f, -0.02787903f, -0.03475394f, 
    0.05232844f, -0.01896431f, 0.01139240f, 0.02020490f, -0.03660323f, 0.00985877f, 0.04916840f, -0.02207671f, 
    -0.01220049f, -0.00296008f, -0.03725192f, -0.01647141f, 0.01286508f, -0.00506383f, -0.05931281f, -0.04039562f, 
    -0.04796371f, -0.03185527f, -0.05117267f, -0.01870881f, -0.01797157f, -0.05202502f, -0.04862469f, 0.00499394f, 
    -0.01038374f, 0.00175947f, -0.02140382f, 0.02531395f, -0.01637304f, -0.02547973f, 0.00020855f, -0.03109836f, 
    0.02819089f, 0.02578905f, 0.02723088f, 0.02550778f, -0.01134221f, -0.03251188f, 0.01313434f, -0.01688989f, 
    -0.06314974f, 0.01101922f, -0.03013520f, -0.06567626f, -0.04876582f, -0.02435944f, -0.04440253f, -0.05097054f, 
    -0.04782858f, -0.03833668f, 0.03852516f, 0.04869315f, 0.04459041f, -0.01657966f, 0.01149172f, 0.02987236f, 
    0.00441250f, -0.03353423f, 0.02566883f, 0.03020472f, -0.03307687f, 0.00227104f, -0.02522860f, 0.03318982f, 
    -0.01483716f, 0.03232651f, -0.02571595f, -0.01469637f, -0.00310252f, 0.00759152f, 0.04898110f, -0.03600625f, 
    0.04863145f, 0.04844956f, 0.05776657f, 0.05155525f, -0.02498128f, 0.04231986f, -0.03929336f, -0.04078496f, 
    0.00848112f, -0.05013828f, 0.00048310f, 0.01550273f, 0.02747245f, -0.00032053f, -0.02577621f, -0.00741082f, 
    -0.04629931f, -0.02483778f, 0.04018409f, -0.00830647f, 0.02010439f, 0.00925153f, 0.02591388f, -0.05473240f, 
    -0.03056373f, -0.02130087f, -0.05708872f, 0.01049645f, 0.01425811f, 0.05525579f, -0.01545459f, -0.00890342f, 
    -0.05938361f, 0.01948347f, 0.02766076f, 0.01040823f, 0.02261752f, -0.03920675f, 0.00111979f, -0.04214367f, 
    0.02670010f, -0.01398834f, -0.04391580f, 0.04376540f, 0.04641455f, -0.01747698f, -0.05048865f, -0.02176522f, 
    -0.03891209f, -0.00697930f, 0.00869313f, 0.00382757f, -0.01987009f, 0.02506996f, -0.04156178f, 0.02133056f, 
    0.03427180f, -0.03722984f, 0.01622283f, -0.05104997f, -0.01213491f, -0.01455715f, -0.01074285f, -0.04172471f, 
    -0.00275590f, -0.03542243f, -0.03665472f, -0.03635819f, -0.05099227f, -0.05408898f, -0.01398467f, -0.03929280f, 
    -0.03119876f, 0.02497510f, 0.03751057f, 0.04256728f, 0.01708677f, -0.01604035f, -0.03313016f, 0.04081313f, 
    -0.01677288f, 0.01860449f, -0.02159549f, 0.01929583f, -0.02377583f, -0.05217127f, -0.05994380f, 0.04922436f, 
    -0.04884997f, -0.01008369f, -0.00971226f, -0.03098549f, -0.01720058f, 0.04627284f, -0.02885087f, -0.04708786f, 
    0.01112375f, -0.04958614f, -0.02602297f, -0.04247880f, -0.01895927f, -0.04085220f, 0.03523961f, 0.03017130f, 
    -0.00139714f, -0.11201755f, -0.01217506f, 0.04424008f, 0.12144680f, 0.00736453f, -0.01419539f, -0.01890719f, 
    -0.00237743f, -0.22311522f, -0.19553807f, 0.24706532f, 0.00647132f, -0.06128634f, -0.10659327f, -0.00266192f, 
    0.03323004f, -0.03433644f, -0.03509786f, 0.15275510f, -0.11000152f, -0.06168994f, 0.00692708f, -0.07818567f, 
    0.08707663f, -0.00295951f, 0.02975410f, -0.19856966f, 0.09934136f, 0.00667734f, -0.07546370f, 0.09045362f, 
    0.04526345f, 0.02466910f, 0.05437495f, 0.06277902f, -0.24660729f, -0.00793371f, -0.24254024f, 0.02910851f, 
    0.02500075f, -0.05254977f, -0.02008869f, 0.03069448f, 0.00508720f, -0.17621785f, -0.11346196f, -0.18782689f, 
    0.13794740f, 0.05628841f, -0.01440961f, 0.05999431f, -0.09406341f, 0.11113122f, -0.25627020f, 0.15884602f, 
    -0.07584129f, -0.16034964f, -0.00289073f, -0.00495631f, -0.01367882f, 0.02031484f, 0.07090066f, 0.05454596f, 
    0.05842485f, -0.05089187f, 0.08825561f, 0.02666307f, 0.08641233f, 0.07023222f, 0.02687301f, -0.05966995f, 
    -0.29109958f, -0.18778053f, 0.07063682f, 0.01849112f, 0.02822601f, -0.02018236f, -0.06688498f, -0.07707664f, 
    -0.04474248f, 0.04218781f, -0.05111374f, 0.09007106f, 0.14539228f, 0.06095369f, 0.01425299f, -0.01818946f, 
    -0.09471074f, -0.00547016f, 0.09930328f, -0.01534209f, 0.08751490f, 0.04229435f, 0.08180977f, 0.08017953f, 
    -0.00507529f, 0.00054599f, 0.07513730f, 0.02388748f, -0.18243545f, 0.19892028f, -0.06265715f, -0.08011331f, 
    0.00328845f, -0.04763710f, -0.07397447f, 0.11132588f, -0.08052680f, -0.00238144f, -0.24092712f, 0.06845320f, 
    0.04383896f, 0.09002257f, 0.04819122f, 0.02076774f, 0.00981434f, 0.03203570f, -0.12463953f, -0.10680486f, 
    0.00829884f, 0.09336805f, 0.01026387f, -0.05244274f, -0.07488864f, 0.08502586f, -0.10667191f, -0.11652230f, 
    0.00159489f, 0.06513684f, 0.03840629f, 0.06760213f, 0.00533136f, 0.05741928f, 0.04782349f, -0.22518569f, 
    0.35333610f, -0.08681554f, 0.02528360f, 0.01351377f, -0.02442064f, 0.03482523f, 0.06029588f, -0.01374135f, 
    -0.01139317f, 0.17191869f, -0.24170443f, 0.00446636f, 0.06305522f, 0.00479625f, 0.09871726f, -0.01748639f, 
    0.03126263f, -0.13220431f, -0.08193140f, -0.17651099f, 0.06906812f, 0.01106816f, -0.09770158f, 0.01549436f, 
    0.07822267f, -0.04621988f, 0.04835262f, 0.18677525f, 0.14236560f, -0.03140960f, 0.03168096f, -0.08659773f, 
    -0.07206169f, 0.05937060f, -0.01711182f, 0.03933191f, 0.05591381f, -0.05229264f, -0.01850373f, -0.15617277f, 
    -0.01854970f, 0.14170173f, 0.02783841f, 0.04337042f, 0.00404573f, -0.03022102f, 0.18688506f, -0.08696599f, 
    -0.01574483f, 0.08560619f, -0.02157581f, -0.00047745f, 0.02060338f, -0.37583816f, 0.03913351f, 0.19402403f, 
    -0.04651688f, 0.15956095f, 0.00180651f, -0.04063040f, -0.00821637f, 0.02393069f, -0.15931137f, -0.17634626f, 
    -0.06580791f, 0.06310777f, -0.03311516f, -0.02069208f, 0.12970546f, 0.06858286f, 0.00304585f, -0.00635154f, 
    0.02619099f, -0.05335598f, 0.14725296f, 0.08262187f, -0.06807052f, 0.02069571f, 0.11255933f, -0.01246162f, 
    0.13212678f, 0.05369214f, 0.05682659f, 0.10059211f, 0.00840571f, 0.00513131f, 0.06759665f, -0.00479711f, 
    0.00938727f, -0.42357391f, 0.03004042f, 0.19163150f, -0.10170057f, -0.01643294f, -0.18528453f, -0.04714201f, 
    -0.01225722f, -0.01828262f, -0.06581209f, -0.19641313f, -0.45787245f, 0.00560183f, 0.04762940f, -0.18478212f, 
    0.05938883f, -0.08646204f, -0.01591193f, -0.08113491f, 0.03361036f, 0.07868911f, -0.19981435f, -0.07120023f, 
    -0.06004330f, -0.02155901f, 0.07247306f, -0.02796912f, 0.16487543f, 0.05187731f, -0.05219253f, 0.02420528f, 
    -0.08537779f, 0.05761428f, -0.04167648f, 0.02557450f, 0.04098463f, -0.09158353f, 0.15737702f, 0.11363413f, 
    0.02264039f, 0.02855463f, -0.07310462f, 0.03564316f, -0.02598409f, 0.02921162f, -0.12097386f, 0.01754453f, 
    -0.09262134f, -0.16712843f, -0.03188211f, 0.12468848f, -0.08424036f, -0.01135574f, -0.07131037f, 0.00183173f, 
    -0.09600934f, -0.09590546f, -0.00123054f, 0.02419961f, 0.01264029f, 0.07091837f, -0.01124061f, -0.03204321f, 
    0.09967490f, -0.02222371f, -0.14490238f, -0.02265338f, -0.08371904f, 0.02332492f, 0.13627538f, -0.03960137f, 
    -0.09095265f, 0.02472648f, -0.13611270f, -0.06839878f, -0.06126077f, 0.08425099f, -0.02448653f, -0.19819607f, 
    0.00469626f, -0.01873330f, 0.01614085f, -0.10000976f, -0.03113635f, 0.03500106f, 0.16597462f, 0.07800228f, 
    0.07149217f, 0.04384939f, -0.16950309f, 0.04741849f, -0.04176161f, -0.23048694f, 0.12754487f, 0.09663846f, 
    0.06576335f, -0.18152905f, 0.10064476f, 0.02769869f, -0.08457609f, -0.12553990f, -0.22357906f, -0.22752312f, 
    0.11412407f, 0.12086330f, -0.04984223f, -0.20901255f, -0.06879095f, 0.38248894f, 0.09626846f, -0.16255109f, 
    0.03653495f, -0.00590785f, -0.00431680f, 0.15527532f, 0.02361204f, 0.10487267f, 0.07221768f, 0.03734441f, 
    -0.10994270f, 0.04311638f, -0.00714332f, -0.09266110f, -0.04936371f, 0.15241168f, -0.03281508f, -0.18618564f, 
    -0.10326349f, -0.01433998f, -0.02959591f, 0.07375751f, -0.04628066f, -0.12244482f, 0.02179000f, -0.07618543f, 
    -0.07916308f, 0.03158721f, 0.00494039f, 0.03624342f, 0.10402542f, 0.15681589f, -0.01160660f, 0.04728777f, 
    -0.02203306f, 0.28845835f, 0.14993331f, -0.16058007f, -0.02661764f, -0.05367741f, 0.08060185f, 0.10835876f, 
    -0.06032821f, 0.02809779f, -0.09409963f, 0.02923971f, 0.03985689f, 0.09072259f, -0.02839310f, 0.00960251f, 
    -0.00131540f, -0.13702439f, -0.11325242f, -0.09260274f, 0.24528164f, -0.08554156f, -0.00360386f, 0.09324242f, 
    -0.03177587f, 0.06188492f, -0.09733763f, -0.01220234f, -0.02604274f, -0.00209966f, 0.00418315f, -0.08004308f, 
    -0.04579894f, 0.04377092f, -0.02837590f, -0.16743946f, -0.10600600f, 0.25356194f, 0.12058484f, -0.17160700f, 
    0.03898400f, -0.06271110f, -0.00067833f, 0.10238063f, 0.02019283f, -0.07054435f, 0.01305632f, 0.15183434f, 
    -0.07661193f, 0.03744553f, 0.08143775f, -0.07451539f, -0.05973738f, 0.03838692f, 0.04963215f, 0.14668527f, 
    0.01562864f, 0.09035294f, 0.07995667f, -0.14771515f, 0.04539134f, 0.08767702f, 0.12173715f, -0.06023645f, 
    0.15672703f, -0.04266989f, -0.05370263f, -0.04377361f, 0.02140363f, 0.05383343f, -0.11598354f, 0.06298473f, 
    0.07835560f, 0.12400451f, 0.11733574f, -0.01389082f, 0.05752490f, 0.11821486f, -0.00600173f, -0.01419689f, 
    0.04318609f, 0.06810783f, 0.21487302f, 0.06907177f, -0.12152932f, 0.00744071f, -0.01944299f, 0.09282064f, 
    0.09180998f, -0.05895380f, 0.09314895f, -0.46077684f, -0.14317466f, -0.06019534f, -0.02394526f, 0.11444349f, 
    0.04321495f, -0.15558413f, -0.00343996f, -0.00879559f, -0.20992151f, 0.06918351f, 0.01530677f, -0.00640386f, 
    0.09476205f, 0.05261084f, -0.09579452f, -0.02012365f, 0.02493451f, 0.13185851f, 0.11525368f, -0.00645269f, 
    -0.06060122f, 0.02904774f, 0.06089049f, -0.04395525f, -0.12649390f, 0.08012751f, 0.14100361f, 0.03143284f, 
    -0.14209867f, 0.02193326f, 0.02366419f, 0.14442964f, 0.07425100f, -0.01334279f, -0.04063347f, -0.01952173f, 
    -0.04009357f, -0.00544244f, 0.10477204f, -0.08485659f, -0.11624356f, 0.02014618f, -0.04345625f, -0.06383468f, 
    0.11179322f, -0.01071197f, -0.05094816f, 0.05155517f, -0.02902140f, 0.01838102f, 0.11657207f, 0.08359811f, 
    -0.04154350f, -0.08905986f, 0.30299613f, -0.10634197f, 0.10955027f, -0.02488104f, -0.06325869f, -0.12527049f, 
    0.04036957f, 0.09564137f, -0.28279600f, -0.15836453f, 0.10579862f, 0.06369378f, 0.04247853f, -0.03101633f, 
    -0.06408982f, -0.19400223f, 0.00263664f, 0.02472686f, 0.01795802f, 0.09737500f, 0.12477440f, 0.11149336f, 
    0.04082922f, 0.00422667f, -0.11588847f, -0.04328714f, -0.02100772f, -0.08751702f, 0.03017472f, -0.02433294f, 
    0.03827506f, 0.04260179f, 0.02004138f, -0.06519821f, -0.04177261f, 0.20527802f, 0.06352392f, -0.16259755f, 
    0.00996947f, -0.01602531f, -0.04201824f, 0.05685382f, 0.01188580f, 0.04044735f, 0.22748148f, -0.10884439f, 
    0.11643898f, 0.17887679f, 0.04000679f, 0.00066178f, -0.05100536f, -0.05379792f, -0.01812722f, 0.05436587f, 
    0.06989871f, 0.13090646f, 0.08368392f, -0.05498390f, -0.03628284f, -0.00795120f, -0.03382599f, 0.05378051f, 
    0.05949933f, -0.14635406f, -0.00784598f, 0.00341450f, -0.07375090f, 0.09327319f, 0.04168341f, 0.00629074f, 
    0.01533214f, 0.00180220f, 0.07824188f, -0.03013512f, -0.10535504f, -0.07530422f, 0.04073592f, -0.10094736f, 
    0.11284215f, -0.11666330f, -0.05537378f, 0.01796728f, -0.07842473f, 0.00911614f, 0.00389760f, 0.10320610f, 
    -0.10110623f, -0.00094072f, -0.19086051f, 0.14464264f, 0.05582476f, -0.11547395f, 0.09068904f, 0.03841269f, 
    -0.08606127f, -0.02803412f, -0.03227247f, -0.16449270f, -0.08994266f, 0.00466614f, 0.06018987f, -0.02630699f, 
    -0.00036279f, 0.06639500f, -0.13874310f, -0.07906228f, -0.07071317f, -0.17404865f, -0.09002678f, 0.01592097f, 
    0.23449084f, 0.12056281f, 0.07759735f, -0.03049211f, 0.01804967f, 0.13242471f, 0.16110007f, 0.04505033f, 
    0.15399179f, 0.03785993f, -0.01731600f, -0.05103809f, -0.06595375f, 0.08794256f, -0.23182721f, -0.04976530f, 
    -0.02800924f, 0.13205028f, 0.04049787f, 0.03683509f, -0.02622715f, -0.04717365f, -0.06348762f, -0.02607633f, 
    0.18276021f, 0.21233426f, 0.04287624f, 0.09822738f, 0.05337812f, -0.00330504f, 0.01843866f, 0.10965578f, 
    0.05227076f, 0.00879211f, -0.14900422f, 0.03788465f, 0.00645755f, -0.02640093f, 0.00125526f, 0.07862278f, 
    -0.10274442f, -0.00288688f, 0.03929651f, -0.00903076f, 0.04940219f, 0.01804219f, -0.02668731f, -0.07415835f, 
    -0.00359587f, -0.03109619f, 0.02771208f, -0.20830819f, 0.12596503f, 0.02321576f, -0.01489794f, -0.06643104f, 
    -0.01148648f, 0.04588713f, 0.01021079f, -0.03175193f, -0.06475583f, -0.00243291f, 0.04632291f, 0.05510710f, 
    0.09386356f, 0.06241030f, 0.01383248f, -0.04680877f, -0.07290988f, 0.23502372f, -0.19836567f, 0.03725557f, 
    0.04365186f, -0.08634599f, -0.07550997f, -0.08651228f, 0.01948636f, -0.06497157f, -0.00213567f, 0.06826171f, 
    -0.01647693f, -0.00546267f, 0.00798852f, -0.03176313f, -0.00076672f, 0.01115448f, 0.01442607f, 0.12685189f, 
    0.07394069f, -0.01608144f, 0.11853426f, -0.09946790f, 0.03221148f, -0.07537170f, -0.02502229f, -0.13752021f, 
    -0.02439719f, 0.04586566f, 0.04635198f, 0.01460252f, -0.05858942f, 0.05715187f, -0.06346259f, -0.14400832f, 
    -0.15370610f, 0.12954134f, 0.00092153f, 0.16893215f, 0.06920796f, -0.13567540f, -0.01133765f, -0.01199039f, 
    0.04363637f, -0.15505962f, 0.04209947f, -0.11808047f, 0.03547259f, 0.06122226f, -0.02978652f, 0.09909827f, 
    0.09524739f, -0.20114253f, 0.11181594f, -0.25508991f, -0.03392392f, 0.00472908f, 0.22590932f, 0.08772456f, 
    -0.18309183f, -0.21304047f, 0.14319721f, 0.16512866f, -0.06708584f, 0.02410546f, 0.08250625f, -0.02718066f, 
    -0.06258578f, -0.11911757f, 0.03779246f, 0.14111778f, 0.11073611f, 0.20144916f, 0.17248839f, 0.03268643f, 
    0.01476549f, -0.00640327f, -0.04008405f, -0.02273376f, 0.03731447f, 0.05245269f, -0.03289748f, -0.02576503f, 
    -0.01576414f, -0.05978476f, 0.01525805f, 0.03213873f, 0.00272253f, -0.01954194f, -0.00023040f, 0.00678465f, 
    -0.05492896f, -0.18546337f, -0.03912695f, 0.12301376f, -0.03687430f, 0.01775414f, 0.03751158f, 0.08497781f, 
    0.22569552f, -0.14072503f, -0.16006464f, -0.09316715f, 0.02142026f, 0.12543613f, 0.04218400f, 0.02857600f, 
    -0.08741346f, 0.06423526f, 0.19938657f, 0.13735089f, 0.17071047f, -0.12272659f, -0.00587383f, -0.01706305f, 
    0.16247211f, -0.12246790f, 0.00538424f, 0.04032825f, -0.02917462f, -0.16581002f, -0.00203866f, -0.06871746f, 
    0.01582580f, 0.02183520f, -0.03957351f, 0.17541064f, 0.06064308f, 0.03060826f, 0.08117805f, 0.05233804f, 
    -0.10079314f, -0.06662656f, 0.07622794f, 0.07645408f, -0.29978827f, -0.00092127f, -0.01153465f, 0.03294330f, 
    0.11350168f, -0.05429279f, 0.06357603f, -0.05502198f, -0.02910470f, 0.08192751f, -0.10439072f, -0.02335550f, 
    -0.08217821f, 0.02389687f, 0.00312567f, 0.00464006f, -0.07207662f, -0.03915735f, 0.08720539f, -0.02760261f, 
    -0.04098384f, 0.05790640f, -0.04618373f, -0.08584961f, 0.11584911f, -0.06288497f, -0.01053593f, 0.08088994f, 
    0.14214721f, -0.09246023f, -0.10385182f, -0.05305681f, 0.08404693f, -0.02477169f, -0.01818512f, 0.08775651f, 
    0.03702070f, -0.00747232f, 0.03272897f, -0.03523933f, -0.05463253f, 0.03258262f, 0.00657589f, -0.01955099f, 
    -0.03832981f, 0.01695951f, -0.01928713f, -0.02505423f, -0.01970447f, 0.00512343f, 0.00090399f, 0.02706349f, 
    0.01958276f, -0.05754583f, 0.01295467f, -0.03997440f, -0.02755699f, 0.04896114f, 0.00650423f, -0.04051630f, 
    -0.02468438f, 0.02025704f, 0.04792814f, 0.01443748f, 0.02230630f, 0.00136333f, 0.03917041f, 0.05410181f, 
    0.04269778f, 0.00167362f, 0.01424988f, -0.06001949f, 0.01432940f, -0.03405887f, -0.00953373f, -0.04633921f, 
    0.00075473f, -0.01877075f, -0.04908497f, 0.01390444f, 0.02518425f, -0.06784785f, -0.07036360f, 0.00618202f, 
    -0.03306199f, -0.03002113f, 0.02931432f, -0.02619490f, 0.00268572f, -0.05502631f, 0.01042316f, -0.01561964f, 
    -0.03310138f, -0.05644050f, -0.04603278f, 0.04602030f, -0.05909440f, -0.06679797f, -0.02248081f, -0.05042228f, 
    0.03277379f, -0.01818560f, 0.04561340f, 0.02404017f, -0.04854643f, -0.05165765f, -0.05485595f, -0.01547343f, 
    -0.04316377f, -0.03850931f, -0.04955838f, -0.01629986f, 0.01212912f, -0.04530386f, -0.03333402f, -0.02593434f, 
    0.02106276f, 0.02096518f, -0.00912992f, -0.00807456f, -0.03966139f, -0.01931574f, -0.00052440f, -0.05721754f, 
    -0.01842976f, -0.00679500f, 0.03127500f, -0.06005753f, -0.02442498f, -0.03156452f, -0.03894398f, -0.00393621f, 
    0.00663372f, 0.04528296f, -0.00709842f, -0.03278300f, 0.01084003f, 0.04032100f, 0.01982575f, -0.04458115f, 
    -0.01838933f, 0.02294574f, -0.00312862f, 0.03195852f, -0.04562514f, -0.03283247f, 0.03558186f, 0.04096604f, 
    0.04446118f, -0.05796899f, -0.05887803f, 0.01775584f, -0.04858820f, -0.01591474f, -0.04989455f, -0.02283517f, 
    -0.04632746f, 0.04406729f, 0.05086224f, -0.02397456f, -0.05727731f, -0.00791992f, 0.05853862f, 0.02522426f, 
    0.04082744f, 0.02348220f, -0.05131625f, -0.00927068f, 0.03879545f, -0.01847695f, 0.04697222f, 0.03001960f, 
    0.02005128f, 0.04032235f, -0.00523690f, -0.02015913f, 0.00301106f, 0.04207762f, -0.05227632f, 0.02655710f, 
    -0.05924237f, -0.04464887f, -0.03523613f, 0.01021443f, 0.00839630f, 0.04020542f, -0.05858542f, -0.02657878f, 
    0.04924048f, -0.00565162f, -0.02982944f, -0.00622030f, -0.03873020f, -0.04408132f, 0.00835532f, 0.00205854f, 
    -0.04974568f, 0.03560307f, -0.00521411f, 0.03650302f, -0.02259309f, -0.06389839f, -0.05637683f, -0.04879395f, 
    0.01062967f, 0.05158610f, -0.02507170f, -0.03808485f, 0.01461776f, -0.01788838f, -0.01243357f, -0.00752099f, 
    -0.04047814f, 0.01789798f, -0.00340568f, 0.05722053f, -0.05686678f, 0.02900518f, -0.05227294f, 0.01860186f, 
    0.00925515f, -0.00451318f, -0.01020715f, -0.03885378f, -0.00794144f, 0.00587223f, -0.00093830f, -0.05754760f, 
    0.02670597f, 0.04206320f, -0.04765474f, 0.05553188f, -0.05555608f, 0.02831852f, -0.01332972f, -0.02295736f, 
    -0.01195015f, 0.04401112f, 0.00786795f, -0.03391187f, 0.04374361f, 0.03535411f, 0.00120442f, 0.04536456f, 
    0.02343528f, 0.03466583f, -0.01004576f, -0.07746910f, -0.01068952f, -0.04974600f, 0.05428223f, 0.00883290f, 
    -0.04720821f, 0.04460191f, -0.02059146f, -0.03911906f, 0.04267834f, 0.04026677f, 0.01249712f, 0.00776224f, 
    0.04799270f, -0.05772421f, -0.02460677f, 0.00404860f, 0.04377623f, 0.01022004f, 0.03442941f, -0.03660545f, 
    -0.01839894f, 0.01871541f, -0.04771919f, -0.04326366f, -0.02911224f, -0.02659372f, -0.00403838f, 0.01278331f, 
    -0.04833297f, 0.04313518f, -0.05232767f, 0.04757493f, -0.00910415f, -0.01477502f, 0.03245074f, 0.01087122f, 
    0.01675163f, -0.03998623f, 0.00121436f, 0.00480215f, -0.05952213f, -0.05280810f, -0.02129390f, 0.00742273f, 
    -0.05569682f, -0.00301524f, 0.00040484f, 0.05180414f, 0.02334758f, 0.03004805f, -0.06188082f, 0.00516939f, 
    -0.04579948f, -0.03954205f, -0.05434615f, -0.05694265f, 0.01631073f, -0.03302709f, 0.01956240f, -0.01963618f, 
    0.02193729f, 0.04688742f, -0.01347798f, 0.04124916f, -0.03310547f, -0.01522402f, -0.02859475f, -0.04109373f, 
    -0.05446444f, -0.00419701f, -0.03949098f, 0.00406941f, 0.00948819f, -0.00744340f, -0.00260982f, -0.05257590f, 
    -0.16011837f, 0.04048090f, -0.07688943f, -0.01876131f, 0.09879575f, -0.04282066f, -0.04233864f, 0.11145151f, 
    -0.06440894f, 0.00191297f, 0.04189357f, -0.07411736f, 0.07945274f, -0.01812180f, -0.00451607f, 0.02205526f, 
    0.07775246f, 0.06499813f, 0.07952676f, -0.00247917f, -0.19607423f, 0.12525918f, -0.07059889f, -0.01080684f, 
    -0.03135159f, -0.15939207f, 0.07879850f, 0.13682894f, -0.27786717f, -0.09609719f, 0.04690349f, 0.00632539f, 
    0.08842824f, 0.10095397f, -0.12442836f, -0.13645260f, -0.21044391f, -0.11219251f, -0.55596918f, 0.10532228f, 
    -0.02327391f, 0.10180568f, -0.08309302f, -0.03801132f, -0.08034487f, 0.16060406f, 0.07173457f, -0.10959928f, 
    0.05336391f, -0.02733462f, 0.09106632f, -0.13953343f, 0.11842958f, -0.06202850f, -0.11758623f, -0.17621697f, 
    -0.09648874f, -0.05809188f, 0.11631954f, 0.02192476f, 0.03059364f, -0.08870719f, -0.01455678f, 0.07381849f, 
    0.03720909f, -0.12027454f, -0.05205030f, 0.08677287f, -0.00946840f, 0.00668653f, -0.04941765f, 0.11876443f, 
    0.30622485f, 0.03854211f, 0.13323432f, -0.11864074f, 0.08251847f, -0.03492104f, 0.03776217f, 0.04952652f, 
    -0.02598386f, 0.03692825f, 0.01179119f, 0.04027261f, -0.02517576f, -0.05959651f, 0.02487335f, -0.12164529f, 
    -0.01460673f, -0.01939558f, -0.14664717f, 0.17202730f, -0.10693653f, -0.03841471f, -0.03149947f, -0.03948771f, 
    0.10423380f, 0.00228406f, 0.01701177f, 0.24443443f, 0.08203486f, -0.15908842f, -0.12720773f, -0.06512418f, 
    0.07076800f, -0.04715206f, 0.02911584f, 0.02777871f, -0.04105465f, -0.19961365f, -0.33890182f, 0.07604966f, 
    0.15575820f, 0.14121953f, -0.24725333f, -0.00182088f, 0.02382147f, -0.26375163f, 0.12320951f, 0.03241047f, 
    0.01281414f, 0.11699163f, 0.02346852f, -0.00292842f, 0.04935767f, -0.06778804f, 0.09523470f, -0.10130648f, 
    -0.15456948f, 0.05852686f, -0.07496525f, 0.21179499f, -0.03919625f, -0.02944698f, -0.04576978f, 0.21556360f, 
    -0.20277832f, -0.01215176f, 0.02177311f, 0.02182936f, 0.17306523f, -0.00656337f, -0.08481900f, 0.08433662f, 
    0.31956384f, -0.10136458f, 0.00966231f, 0.03549474f, -0.09012049f, 0.03487784f, 0.09725078f, -0.06370370f, 
    -0.03027733f, -0.13987574f, -0.22823584f, -0.07079673f, -0.00206584f, 0.07260747f, 0.00124950f, -0.01562641f, 
    -0.04311645f, -0.02686051f, -0.21312661f, -0.17566252f, 0.07564746f, 0.08283059f, -0.00051065f, 0.04640742f, 
    -0.08373216f, 0.03103508f, 0.02160335f, 0.21557336f, 0.07035301f, -0.11295357f, -0.06149464f, 0.06733149f, 
    0.06271043f, 0.08087959f, 0.05192059f, -0.08794589f, 0.15962823f, 0.20197885f, -0.04596847f, -0.08135802f, 
    0.04262389f, 0.07223237f, -0.04354936f, 0.00212766f, 0.01136604f, 0.02839771f, -0.06997796f, -0.10001977f, 
    -0.05911671f, 0.09093571f, 0.08779052f, 0.08176447f, 0.05978956f, 0.08390118f, 0.01778587f, 0.00243556f, 
    -0.18615824f, 0.06265996f, 0.12331237f, -0.07205772f, -0.09585930f, 0.00057300f, -0.07192335f, -0.18141983f, 
    0.06125026f, -0.04263689f, 0.06786892f, -0.10054071f, 0.05249672f, 0.03986034f, 0.06569006f, 0.12798478f, 
    -0.09940504f, -0.05453582f, -0.13304025f, 0.03204314f, 0.02058483f, 0.06208646f, -0.06751864f, -0.00044037f, 
    0.06368350f, 0.19726403f, 0.11433478f, -0.03264550f, 0.05057108f, 0.02232015f, 0.02291912f, -0.04779725f, 
    0.01668189f, 0.00624746f, -0.14759950f, -0.05761562f, -0.14946273f, 0.06784713f, 0.07310729f, 0.00811125f, 
    -0.13458908f, 0.04923838f, -0.01925753f, 0.00654691f, 0.24564378f, 0.12341326f, -0.01434997f, -0.08827338f, 
    -0.12660785f, 0.11355148f, 0.04468720f, 0.03411756f, 0.05423804f, 0.21769363f, 0.03357575f, -0.19073120f, 
    0.01270512f, -0.05091315f, 0.15424673f, -0.00953286f, -0.01755944f, -0.25603566f, -0.15529285f, 0.04455563f, 
    0.13473724f, 0.05446331f, 0.05546889f, -0.08928940f, 0.06449801f, 0.03442839f, 0.07824665f, -0.15943281f, 
    0.16076145f, -0.11623893f, 0.01339051f, -0.01316801f, 0.10836932f, 0.10510049f, -0.02798861f, -0.34058148f, 
    -0.01579163f, -0.20155910f, 0.03473858f, 0.04219785f, 0.08156760f, 0.03507141f, -0.02691647f, -0.01999442f, 
    -0.04453249f, -0.21850914f, 0.06659330f, -0.07215118f, 0.04106642f, 0.07732838f, 0.05016400f, -0.15754038f, 
    -0.06703062f, -0.06829647f, -0.17168306f, -0.05136400f, -0.04335491f, 0.02223460f, -0.04432197f, 0.10066575f, 
    -0.03529609f, -0.27479699f, 0.11721898f, -0.22132075f, 0.11337222f, -0.13204522f, 0.00613380f, 0.09124143f, 
    0.24206823f, 0.09957838f, 0.13791707f, -0.01147174f, 0.05904093f, -0.16980164f, -0.06807072f, -0.02935994f, 
    -0.02505993f, 0.05785807f, -0.14262202f, -0.05914126f, -0.06871855f, -0.23949410f, -0.02836281f, 0.04556697f, 
    -0.17146553f, 0.07010029f, 0.06899792f, 0.08726583f, 0.04855177f, 0.06330546f, -0.00025726f, 0.00617386f, 
    -0.01839883f, 0.12366747f, 0.12697531f, 0.07514997f, -0.00453407f, 0.15499033f, 0.01913785f, -0.05666878f, 
    0.15944859f, -0.17119823f, -0.18200146f, 0.01921207f, 0.14220098f, -0.01714511f, 0.10000637f, 0.01267748f, 
    -0.11492124f, 0.04185616f, -0.03598194f, -0.12151160f, -0.00168553f, 0.01670774f, 0.01915162f, 0.06727213f, 
    0.07084817f, 0.05816080f, 0.03561629f, -0.05249347f, -0.20909056f, -0.01222408f, 0.02249365f, 0.01657962f, 
    -0.00739100f, -0.05962116f, 0.03097016f, 0.17077519f, 0.07887090f, -0.00753972f, 0.17026009f, -0.03504556f, 
    -0.06943647f, 0.15041469f, -0.11822366f, -0.07146033f, -0.00247871f, 0.03375604f, 0.03941229f, 0.04000971f, 
    0.00918006f, 0.02069092f, -0.02021687f, -0.06826434f, -0.21786852f, 0.00754190f, -0.13446726f, -0.04992238f, 
    0.03252278f, 0.07190665f, 0.04402643f, 0.14878656f, -0.15523563f, -0.12695000f, -0.04656763f, -0.00496652f, 
    -0.01028764f, 0.04413750f, 0.00006667f, 0.02477615f, -0.09620391f, 0.10132470f, -0.17984223f, 0.21034777f, 
    0.01751266f, 0.01303231f, -0.00383486f, 0.08217373f, -0.13016394f, 0.08230127f, -0.01106039f, -0.04172571f, 
    -0.00387393f, -0.17756352f, -0.08997691f, 0.07428109f, 0.04958876f, -0.10379387f, -0.08130929f, -0.07052211f, 
    0.08061524f, -0.10871757f, -0.07345879f, -0.14469482f, 0.02205080f, 0.14591444f, 0.00850932f, -0.06423245f, 
    -0.21663691f, -0.16725522f, 0.03779260f, 0.05165776f, -0.06476570f, -0.06107174f, 0.08734871f, 0.08337503f, 
    -0.03302756f, -0.08246866f, -0.02398555f, 0.03358447f, 0.02555268f, -0.11245368f, -0.05592373f, 0.10170971f, 
    -0.04565565f, 0.10373743f, 0.06177489f, -0.00659395f, 0.03835100f, 0.11544280f, -0.14315952f, 0.07666446f, 
    -0.09802921f, 0.16112427f, -0.01058448f, 0.02912876f, 0.14326400f, 0.10142265f, -0.04682555f, -0.05876049f, 
    0.06808478f, -0.00895966f, -0.14198659f, 0.12884836f, -0.00026166f, 0.03513192f, 0.07858508f, -0.18544158f, 
    -0.15865555f, 0.01375678f, -0.01013362f, -0.10307657f, 0.16054717f, -0.11916688f, -0.07575162f, -0.13464771f, 
    -0.02908820f, 0.07111707f, -0.07298760f, 0.09807983f, -0.10385552f, -0.00562149f, 0.02704093f, 0.00119655f, 
    0.08892636f, 0.03013573f, 0.03515248f, 0.05636309f, -0.07915989f, -0.10822111f, 0.14304912f, 0.06188268f, 
    0.14820440f, 0.08121097f, 0.07445755f, 0.13246281f, 0.07820579f, 0.06707232f, -0.07257917f, -0.04667709f, 
    -0.27387348f, 0.07309057f, 0.05696726f, 0.04328598f, 0.03607583f, 0.19281095f, 0.02913016f, 0.01298589f, 
    0.09135386f, 0.01192449f, -0.19963183f, -0.03622618f, -0.04813586f, -0.05669975f, -0.16595936f, 0.06273307f, 
    -0.01708968f, 0.05958804f, -0.00446440f, -0.25561574f, -0.05157586f, -0.08931853f, 0.08584962f, 0.15057762f, 
    0.19246143f, -0.09657981f, -0.01444616f, 0.17857695f, -0.07477122f, 0.17749453f, -0.02027817f, 0.10240286f, 
    -0.07123598f, 0.12334438f, -0.17434174f, -0.12606739f, -0.05496734f, 0.16852883f, 0.13793319f, 0.09732147f, 
    0.11146998f, 0.14824900f, 0.10433046f, 0.01538079f, -0.04274934f, -0.04646942f, 0.00702728f, -0.07689650f, 
    -0.03082469f, -0.02842227f, 0.11307630f, -0.03853770f, 0.00924776f, -0.03238572f, 0.15443932f, 0.05723431f, 
    0.04965769f, 0.00516614f, -0.08445361f, -0.18266232f, 0.06815482f, -0.04396388f, -0.04210021f, -0.04415604f, 
    -0.15276925f, -0.04720327f, 0.09588493f, -0.05246042f, -0.12604573f, 0.07853825f, 0.01243885f, 0.08412877f, 
    0.22111781f, 0.12721200f, 0.09510621f, -0.08822142f, 0.12304128f, 0.05406436f, -0.08619446f, 0.05723687f, 
    0.20002006f, 0.09186672f, 0.19209878f, 0.03954151f, 0.17014906f, 0.14525048f, -0.07994585f, 0.04147585f, 
    0.08183425f, 0.09482846f, 0.02067115f, -0.03628373f, -0.07407141f, 0.03870001f, 0.05286123f, -0.02812605f, 
    0.08694813f, 0.08081901f, -0.00388831f, -0.30412397f, -0.09592651f, -0.01652057f, 0.10161176f, 0.08269329f, 
    -0.02916126f, 0.05205659f, 0.03873022f, -0.05558691f, -0.34389645f, 0.03689436f, 0.08944729f, -0.06900378f, 
    0.02532552f, -0.06963993f, 0.06938091f, 0.00279732f, -0.21325462f, -0.37625033f, 0.14354651f, 0.15366662f, 
    -0.21799025f, 0.13435195f, 0.21978885f, 0.05218198f, -0.10673203f, 0.06978860f, 0.05341089f, -0.04225949f, 
    0.18789521f, -0.06424265f, -0.02695649f, 0.04287053f, -0.00428014f, 0.00177377f, 0.10475183f, -0.22900821f, 
    -0.12935930f, -0.03038063f, -0.04337905f, 0.04206284f, -0.06841462f, 0.09018867f, -0.08904856f, 0.02045856f, 
    -0.31610328f, 0.06182730f, 0.00739246f, 0.14669266f, -0.01826127f, 0.10275839f, 0.17101015f, -0.05907132f, 
    -0.04321544f, -0.18934198f, 0.21870904f, 0.09804913f, 0.13381508f, 0.01462020f, 0.12117558f, 0.01754889f, 
    -0.04271713f, -0.07251735f, -0.06293539f, -0.06321953f, -0.04654563f, 0.10009698f, 0.02863374f, 0.07945821f, 
    0.11880475f, -0.02345389f, 0.10892019f, -0.20629045f, -0.25141373f, -0.01550809f, 0.16001202f, -0.01966020f, 
    0.01076611f, 0.22190912f, -0.14299686f, 0.02807068f, -0.10589323f, -0.08902734f, 0.01648925f, 0.06275935f, 
    0.00422695f, -0.00391687f, -0.00471724f, 0.00387140f, -0.17312251f, 0.14686479f, 0.12930995f, 0.19209352f, 
    -0.15119575f, -0.02059157f, 0.05481359f, 0.00497467f, -0.00457867f, 0.14273466f, -0.39882895f, -0.07506707f, 
    0.12830207f, 0.08935751f, 0.09819309f, 0.12737638f, 0.07469972f, 0.00163448f, -0.05522668f, 0.07109902f, 
    -0.03534286f, -0.06786608f, -0.19039536f, -0.10842546f, 0.07509561f, -0.03217197f, -0.06532498f, 0.04500627f, 
    -0.03069970f, 0.01064062f, 0.12603153f, -0.10398009f, -0.03534793f, -0.00480026f, 0.14935440f, 0.01837409f, 
    -0.05635184f, 0.01361140f, -0.03795304f, 0.21227677f, -0.01659376f, -0.15679553f, 0.10804585f, 0.00269910f, 
    0.11340229f, 0.07937580f, -0.12119438f, 0.11191022f, 0.02463804f, 0.16479449f, 0.02397924f, 0.10602517f, 
    0.07249626f, 0.04683856f, 0.02147866f, 0.38996831f, 0.02085047f, -0.01496380f, 0.05276019f, -0.00526926f, 
    0.05139274f, -0.01365982f, 0.11588185f, -0.02558025f, -0.16218419f, 0.02563438f, 0.04727875f, 0.02321469f, 
    0.18836027f, 0.15758783f, -0.02108707f, -0.05811195f, 0.10677577f, -0.35658762f, 0.08693529f, 0.25109929f, 
    0.07344879f, 0.11348040f, 0.02792837f, -0.02716262f, 0.00493505f, -0.18422748f, 0.14380236f, 0.16400640f, 
    0.18695444f, 0.09706642f, -0.02843416f, -0.01021152f, 0.05508515f, 0.01384337f, 0.12754810f, -0.11208195f, 
    0.05550114f, 0.04160590f, 0.15745439f, 0.15040320f, 0.08619659f, 0.02701922f, 0.00937852f, -0.01946387f, 
    -0.10418384f, -0.05329544f, 0.03506797f, 0.10439564f, 0.02860913f, 0.10106057f, -0.08669786f, 0.00303722f, 
    -0.01032147f, -0.11640062f, 0.04773438f, -0.04956487f, 0.28769055f, 0.05963435f, 0.07967626f, 0.19433297f, 
    -0.11959881f, -0.05707500f, -0.48474443f, -0.12646116f, -0.05292373f, 0.00025191f, 0.02759055f, -0.01121271f, 
    0.04182594f, -0.01816366f, -0.10735971f, 0.00185504f, 0.05097510f, 0.07324526f, 0.22768712f, 0.01282392f, 
    0.07642275f, 0.05163462f, -0.13294558f, 0.05048708f, -0.12643005f, -0.16748659f, -0.17204669f, -0.01679075f, 
    -0.07490239f, 0.08740726f, 0.05147851f, 0.01705177f, -0.02484961f, 0.08186718f, 0.01979444f, -0.07204840f, 
    0.04864334f, 0.04932135f, 0.17242339f, 0.09145896f, 0.07062970f, 0.01235528f, 0.04837812f, 0.06249086f, 
    0.01130668f, 0.17435206f, 0.08438753f, -0.01271037f, 0.12929246f, -0.00431069f, -0.13606681f, 0.05022805f, 
    0.01192672f, -0.13943280f, -0.02957390f, -0.01312568f, 0.00071061f, -0.01218316f, -0.04235098f, -0.00427432f, 
    0.12113534f, 0.00895293f, -0.17217499f, -0.05788768f, -0.01980909f, 0.13980162f, -0.01510216f, 0.00048745f, 
    -0.01928267f, 0.08363076f, -0.27349919f, -0.14071003f, 0.01625193f, 0.05299919f, 0.03009817f, 0.16789979f, 
    0.11221808f, -0.08287013f, 0.05596446f, -0.08728164f, -0.18922660f, 0.13618471f, -0.07132553f, -0.01717856f, 
    -0.03559516f, 0.04663938f, 0.02522422f, -0.14175068f, -0.15470842f, -0.09138508f, 0.08225137f, 0.07150064f, 
    0.10493039f, -0.03868894f, -0.02629755f, -0.07031102f, 0.05671709f, -0.33989716f, -0.09819202f, 0.01285694f, 
    -0.03299336f, -0.06395487f, 0.12099534f, 0.06256405f, -0.04998353f, -0.01967089f, 0.06938444f, 0.12442271f, 
    0.08154315f, 0.15581416f, -0.04397499f, -0.00766013f, -0.04384059f, 0.08737640f, -0.07946987f, -0.10839735f, 
    0.08087581f, 0.09433747f, 0.02920647f, -0.05640050f, 0.05889526f, -0.07999884f, 0.05974047f, -0.24415952f, 
    -0.20435365f, 0.14540620f, -0.06177940f, 0.03163510f, -0.06546464f, 0.02283405f, -0.05548673f, 0.09835728f, 
    -0.13516782f, -0.13864046f, -0.14021860f, -0.05795973f, -0.05626583f, 0.09211318f, 0.07913148f, 0.04850300f, 
    0.02330215f, 0.11765548f, 0.11032182f, -0.00678538f, 0.11792388f, 0.04071981f, -0.01864080f, -0.06962051f, 
    -0.03319876f, 0.10555703f, -0.11385825f, -0.06362572f, 0.01008500f, -0.01185082f, 0.00469655f, 0.07893506f, 
    0.05242961f, -0.03205452f, 0.05332772f, -0.27444467f, -0.16203649f, -0.09941344f, 0.04088799f, 0.02214927f, 
    -0.00300150f, -0.14231981f, -0.00195597f, -0.00993227f, -0.06965610f, -0.04317039f, -0.00741342f, 0.01770957f, 
    -0.08133754f, -0.00952113f, 0.07145884f, 0.11128730f, -0.06242153f, 0.09210383f, 0.09333540f, -0.08125835f, 
    0.04394371f, -0.05511281f, 0.10511135f, -0.06853583f, -0.03434670f, 0.06400736f, -0.02572114f, -0.20243344f, 
    -0.16666776f, 0.02216306f, 0.08454895f, -0.08565523f, 0.04123886f, -0.01598988f, 0.14621958f, -0.21826652f, 
    -0.06740633f, -0.21196859f, 0.07054812f, 0.02964771f, 0.00457995f, -0.03257415f, 0.05918645f, -0.08452898f, 
    -0.01169863f, 0.02766943f, 0.19273174f, -0.00016589f, -0.11528167f, -0.03432399f, 0.06813572f, -0.00368426f, 
    0.03676569f, -0.00087261f, -0.10347891f, -0.01770848f, 0.20807266f, -0.00318183f, 0.12132322f, 0.01973388f, 
    0.08201796f, -0.04020485f, -0.13427076f, 0.07194741f, 0.14762820f, 0.03632578f, 0.03371868f, 0.00160854f, 
    0.01348942f, -0.10257334f, -0.01059526f, -0.08653833f, -0.05623002f, -0.06891861f, -0.09988359f, 0.09904664f, 
    -0.14897594f, 0.13870262f, -0.01877629f, 0.01248764f, -0.20457700f, -0.14160126f, -0.09061591f, 0.02747801f, 
    0.09622040f, 0.02673802f, 0.05153846f, -0.07296943f, 0.05454077f, -0.24816708f, -0.00851508f, -0.13778099f, 
    0.01313080f, 0.05222347f, 0.02359482f, -0.03969661f, 0.10433364f, -0.01071000f, 0.12138223f, 0.02314375f, 
    -0.09984327f, 0.04139396f, 0.00810317f, 0.06119522f, 0.10381182f, -0.00420558f, 0.12957543f, 0.01456651f, 
    0.00541502f, 0.00305939f, -0.06429852f, -0.04802791f, -0.01411555f, 0.03795432f, 0.11061699f, 0.07634585f, 
    0.14792219f, 0.06102341f, -0.08195183f, 0.01952579f, -0.02244461f, 0.05716597f, -0.09781104f, 0.11587982f, 
    0.12707175f, -0.35481432f, -0.09765077f, -0.08983681f, 0.10955363f, 0.02134068f, 0.02028215f, 0.03634297f, 
    0.14542815f, -0.12715749f, -0.21175572f, -0.20556018f, 0.05600926f, -0.02955362f, 0.07035111f, -0.00879267f, 
    -0.03803288f, -0.08383241f, 0.08941372f, -0.02657783f, 0.01602254f, -0.10500414f, -0.06708071f, -0.02030758f, 
    -0.01301535f, 0.01958298f, 0.02452455f, -0.04305999f, 0.04933907f, -0.20307718f, -0.01104456f, -0.04368377f, 
    0.09108095f, -0.00360405f, -0.05986973f, -0.04590486f, 0.07598310f, 0.01471022f, 0.02827948f, 0.12043520f, 
    -0.05118250f, 0.12291922f, 0.04478359f, 0.02987903f, 0.08554381f, -0.07260645f, -0.27335656f, -0.14145072f, 
    -0.17752828f, -0.01760453f, -0.08551443f, 0.00303418f, 0.02345563f, -0.07743223f, -0.07308374f, -0.07790265f, 
    -0.05113096f, -0.10575586f, 0.02612317f, 0.05980070f, 0.07252181f, -0.09140927f, 0.11717785f, 0.00409681f, 
    -0.12517482f, 0.05099846f, -0.05160676f, 0.02926268f, 0.03589700f, -0.01124666f, -0.07878371f, 0.01882227f, 
    0.06819927f, 0.05007788f, -0.00722569f, 0.05535942f, -0.03706201f, -0.02545581f, 0.00514090f, 0.10667020f, 
    -0.04045736f, 0.02698916f, 0.02164720f, 0.01608611f, -0.01056282f, -0.05292833f, -0.12537220f, -0.06013953f, 
    0.01189441f, 0.11326149f, -0.08127128f, -0.00477352f, 0.15025857f, 0.05150672f, -0.02962624f, -0.09603053f, 
    -0.06349236f, -0.02520742f, 0.06042390f, 0.01835016f, 0.06446777f, 0.12741174f, 0.09460811f, 0.03068395f, 
    -0.12482966f, -0.05861127f, 0.09671108f, 0.02346104f, 0.01955006f, -0.17023401f, 0.07075837f, 0.04757665f, 
    0.02464115f, -0.02466376f, -0.03468790f, -0.04906800f, -0.02349046f, 0.05292598f, 0.12387921f, 0.05768321f, 
    0.11596967f, -0.14583336f, 0.05625400f, -0.04412313f, 0.10280219f, 0.13722508f, -0.02595277f, -0.08386350f, 
    0.11438932f, 0.11723427f, -0.09235676f, 0.08164712f, -0.08460807f, 0.05541059f, -0.05620067f, -0.13627525f, 
    -0.08700942f, -0.04960084f, 0.09664601f, -0.07987962f, -0.05952899f, 0.05212085f, -0.03520986f, -0.02626954f, 
    0.15641686f, -0.15848637f, 0.09109135f, -0.12656049f, 0.21819136f, 0.03247636f, -0.00328585f, -0.00889086f, 
    -0.02736841f, -0.09682804f, 0.18961477f, -0.03440320f, -0.01025280f, 0.02139140f, 0.02646400f, -0.02297109f, 
    0.00671122f, -0.06872381f, -0.05696085f, 0.12644324f, -0.06162662f, -0.07309245f, 0.00938349f, 0.02941251f, 
    -0.06589834f, 0.02775562f, -0.12719984f, -0.08326609f, -0.02686463f, -0.00248329f, 0.04147867f, -0.01940415f, 
    0.01047987f, -0.02969813f, 0.08847973f, 0.04276913f, 0.04312101f, -0.04988211f, -0.08258716f, 0.00587822f, 
    -0.01395161f, -0.00171867f, -0.15747058f, 0.00123083f, -0.01664492f, 0.07685576f, -0.16049092f, 0.03472427f, 
    0.07888398f, 0.02809251f, -0.09633584f, -0.04083879f, 0.01448432f, 0.00318246f, 0.03424540f, -0.03046129f, 
    0.03743300f, 0.18692966f, -0.01182474f, 0.07336086f, -0.04543877f, 0.08112134f, 0.03430054f, 0.11100561f, 
    -0.04434029f, 0.00245637f, 0.07792730f, -0.04551802f, -0.04898457f, -0.12091713f, -0.00175804f, -0.01738644f, 
    -0.00819594f, 0.05611179f, 0.06652762f, -0.05552696f, 0.06127445f, -0.03962670f, 0.01420803f, 0.07121366f, 
    0.15220198f, -0.01026304f, 0.00134162f, -0.06850763f, -0.26761267f, 0.13142727f, 0.02804543f, 0.05305443f, 
    -0.01699204f, 0.02789200f, -0.04577496f, -0.21618919f, 0.06644557f, -0.09749478f, -0.02418686f, -0.08971722f, 
    0.07397878f, 0.07062695f, -0.04263278f, 0.01034077f, -0.15476313f, -0.01476567f, 0.02948413f, 0.00464022f, 
    0.05785225f, 0.08655977f, -0.07488440f, 0.05654939f, -0.00438168f, -0.12757781f, -0.03613550f, 0.11188693f, 
    0.09402785f, -0.12164411f, 0.01357318f, -0.02654208f, -0.02448427f, 0.18105105f, -0.04943407f, 0.04069629f, 
    0.04498868f, 0.08453087f, -0.04212581f, -0.02823611f, 0.03632742f, 0.03379345f, 0.09784415f, 0.02167512f, 
    -0.05380894f, -0.10469175f, 0.00639108f, 0.05676589f, 0.10432312f, 0.13654326f, 0.02009177f, -0.09980727f, 
    0.02898996f, -0.23634584f, -0.13891225f, 0.09072859f, 0.00886992f, 0.04989260f, 0.11305099f, -0.10459646f, 
    -0.02765372f, 0.07278764f, -0.04966533f, 0.09750623f, 0.01819091f, -0.05555877f, -0.06957089f, -0.16936688f, 
    0.08260573f, 0.11137896f, 0.28604499f, -0.04183501f, 0.13044734f, -0.18088287f, -0.05005982f, -0.04223454f, 
    0.00722258f, 0.11290973f, 0.00890509f, -0.01380980f, -0.10984615f, 0.05095877f, 0.04131128f, 0.00261585f, 
    0.17771301f, -0.12434620f, 0.04523103f, -0.01869872f, 0.01604646f, 0.10452865f, -0.07275368f, 0.09211604f, 
    0.03925228f, 0.20455730f, -0.00185284f, -0.15381205f, -0.02771560f, 0.11687836f, -0.10224175f, -0.14157096f, 
    0.08232647f, -0.09691305f, 0.16025274f, -0.01268847f, 0.05593764f, -0.05035609f, 0.00686417f, 0.06291681f, 
    -0.07692589f, -0.02448563f, 0.04000076f, 0.07759181f, -0.04817944f, 0.09272250f, 0.00252440f, -0.05336744f, 
    -0.07577014f, 0.03008375f, -0.05708328f, 0.05008259f, 0.13580121f, 0.13990419f, 0.03169484f, 0.00506141f, 
    0.00210720f, 0.03779669f, -0.04034773f, -0.03572209f, 0.01602872f, -0.05627573f, -0.04332466f, 0.02390116f, 
    0.00101207f, -0.01266282f, -0.03345329f, -0.03263624f, 0.01456708f, 0.01864015f, -0.01114715f, -0.01077336f, 
    -0.01103832f, -0.01243627f, 0.00919110f, -0.05229167f, -0.04339066f, -0.02351827f, -0.01993718f, -0.05809570f, 
    -0.00086138f, -0.02324254f, -0.03321854f, 0.02953894f, 0.01731328f, -0.02706565f, -0.06160815f, 0.03635832f, 
    0.02959651f, 0.00085332f, -0.00073291f, -0.02436422f, 0.01958346f, 0.04914657f, -0.04917276f, 0.03662354f, 
    -0.06322161f, 0.04635531f, 0.00140835f, 0.02398269f, -0.01652459f, -0.03527548f, 0.04407071f, 0.01058952f, 
    -0.05165773f, 0.01027443f, 0.03020736f, 0.03446516f, -0.06418937f, 0.04371741f, 0.01113976f, -0.02261617f, 
    -0.04636388f, 0.01540680f, -0.06094791f, -0.03048811f, -0.01623609f, -0.01372414f, -0.00033411f, -0.03361256f, 
    0.00166899f, -0.04325438f, -0.05962200f, -0.03190215f, 0.02104753f, 0.03043829f, 0.00007821f, 0.01066434f, 
    0.02950305f, -0.05130085f, 0.03628961f, 0.02595668f, -0.06129466f, 0.00758409f, 0.02692350f, -0.05082282f, 
    -0.02380208f, -0.03312105f, 0.02165586f, -0.01418779f, -0.05790042f, -0.03955521f, -0.01899306f, -0.04033664f, 
    0.03579127f, 0.04495001f, -0.02576982f, 0.03938232f, -0.02879041f, 0.00820548f, -0.02791541f, 0.01382858f, 
    -0.04586939f, -0.01345055f, -0.04586500f, 0.01488160f, 0.02219506f, -0.01962174f, 0.01548719f, 0.03219631f, 
    -0.05857155f, -0.03351051f, 0.04737205f, 0.02652082f, -0.04406834f, 0.04082951f, -0.03154306f, 0.03726158f, 
    -0.01002730f, -0.01030218f, 0.05071937f, -0.01700722f, 0.01956951f, -0.01122464f, -0.05695478f, 0.04481544f, 
    -0.00463068f, 0.01934368f, 0.00807494f, 0.04122351f, 0.02446002f, 0.01899569f, -0.00171596f, -0.02702004f, 
    -0.02277672f, -0.04127536f, 0.02755920f, 0.03254694f, -0.05427522f, -0.03384765f, -0.06553476f, -0.05905759f, 
    -0.01740365f, 0.00063436f, 0.04201955f, 0.00166450f, 0.05044118f, -0.02297729f, -0.01161964f, 0.04073999f, 
    -0.00184666f, -0.05353701f, -0.02399522f, -0.04860582f, -0.05552040f, -0.05878955f, -0.01709766f, 0.00346601f, 
    -0.06745327f, -0.01118331f, 0.04103126f, 0.00401379f, -0.05474820f, 0.04965971f, -0.00722389f, 0.04541624f, 
    -0.03803698f, -0.00627372f, -0.04136456f, 0.00897951f, 0.03266299f, 0.02629920f, 0.02746234f, -0.01104116f, 
    -0.01788046f, 0.03161502f, -0.03696633f, -0.02073028f, 0.00389387f, -0.04866395f, -0.05799824f, 0.00162420f, 
    0.02066137f, -0.00926123f, 0.02182326f, 0.01423323f, -0.03104649f, 0.02544920f, -0.00892241f, 0.03631635f, 
    -0.03103971f, -0.03067156f, 0.03136038f, 0.01148553f, -0.02522030f, 0.00965308f, -0.00024148f, 0.01012903f, 
    -0.03548323f, -0.01779191f, -0.01809492f, 0.03866107f, -0.01118804f, 0.01856721f, 0.01730984f, -0.04038874f, 
    -0.05554007f, -0.04177530f, -0.03229537f, 0.03165514f, 0.03740605f, 0.04188021f, -0.02410217f, 0.03618859f, 
    0.02264275f, -0.06430202f, 0.05141084f, 0.02911307f, -0.02479966f, 0.01723774f, 0.02432166f, 0.02955409f, 
    -0.06612869f, -0.04489440f, -0.03903739f, 0.00703110f, -0.04205901f, 0.03435123f, 0.00545958f, -0.03679781f, 
    0.02638442f, -0.04801346f, -0.00952136f, -0.00894856f, 0.00389314f, -0.03826183f, -0.06146921f, -0.04653349f, 
    -0.00943547f, 0.02644597f, -0.01328266f, 0.02340944f, -0.05766841f, 0.00686558f, 0.00310161f, -0.03840627f, 
    0.03325873f, -0.02842215f, -0.03598181f, 0.04036603f, 0.04426051f, 0.04149555f, -0.06298587f, -0.00031503f, 
    0.01953895f, 0.02647535f, -0.01194087f, -0.06246744f, 0.01712470f, 0.03489500f, 0.01274082f, -0.05981031f, 
    -0.01370982f, -0.04384301f, -0.05460446f, -0.03922078f, -0.05453572f, -0.04210296f, -0.02104786f, -0.03796938f, 
    -0.03034238f, 0.00281801f, -0.04987471f, -0.02191650f, -0.05955924f, 0.02248718f, 0.04667804f, 0.02896897f, 
    0.00228006f, 0.04616784f, -0.02926018f, 0.04691190f, -0.00999025f, -0.02291297f, -0.02758643f, -0.02950755f, 
    -0.02527185f, 0.00111533f, 0.00238645f, -0.00333503f, 0.04766198f, -0.02930187f, -0.06538446f, -0.00916689f, 
    -0.05906233f, 0.02214077f, 0.09694833f, 0.04972203f, 0.06526034f, -0.08123304f, 0.05956706f, -0.06695449f, 
    0.07041305f, 0.02473392f, 0.15812296f, 0.01110425f, 0.05336508f, -0.03551895f, -0.00588248f, 0.02194068f, 
    -0.13112983f, -0.00315448f, -0.05261492f, 0.10897364f, 0.05881584f, -0.00143627f, 0.13730893f, 0.09321325f, 
    0.09037935f, -0.00082600f, -0.07969441f, -0.05104195f, 0.01325521f, 0.05652219f, -0.03870425f, 0.09876861f, 
    -0.01411088f, -0.03060406f, 0.00843242f, 0.01916666f, 0.25031850f, 0.10596336f, -0.04171406f, -0.08643374f, 
    -0.00280824f, -0.01629304f, -0.19615872f, 0.02177700f, 0.01963073f, 0.16703570f, -0.02281755f, 0.09642299f, 
    -0.09099682f, 0.03840962f, 0.03727448f, -0.11546421f, -0.05256826f, 0.10025199f, 0.23493724f, 0.00355144f, 
    -0.19197495f, 0.03939795f, -0.05384850f, -0.11904220f, -0.09339149f, 0.04574494f, -0.15511118f, -0.01672388f, 
    0.03598861f, -0.04020542f, -0.04339394f, 0.08197820f, 0.02166930f, 0.02819521f, -0.04731614f, 0.02395061f, 
    -0.05748614f, 0.06706032f, 0.03180708f, 0.02183636f, 0.03725347f, 0.03722970f, -0.04658877f, 0.13213854f, 
    0.05688884f, 0.18879394f, -0.23007876f, -0.07827282f, -0.03928889f, 0.05167831f, 0.06565478f, -0.00210702f, 
    -0.00001540f, 0.07752592f, -0.02249866f, -0.08157233f, -0.14984807f, -0.09513734f, 0.02839777f, 0.02943970f, 
    -0.06657618f, 0.05020858f, -0.11913501f, 0.00436612f, 0.10938078f, 0.01259933f, -0.12411669f, -0.06186815f, 
    -0.08649655f, 0.00535725f, -0.04056175f, 0.08023956f, -0.12703112f, 0.18919952f, -0.11058651f, 0.14180294f, 
    0.07690738f, -0.07056352f, 0.09194414f, -0.15508059f, -0.09564977f, 0.06159810f, -0.11755414f, -0.05848172f, 
    0.00205010f, -0.06989907f, 0.04593191f, 0.14150758f, -0.02452239f, -0.03763410f, -0.07608291f, 0.12829879f, 
    -0.03295262f, -0.02707495f, -0.02889088f, -0.05087562f, 0.01199327f, -0.03400519f, -0.02962589f, -0.06094576f, 
    0.11617546f, -0.13858855f, -0.04622929f, 0.01073949f, -0.08569877f, 0.04034654f, 0.01757072f, -0.08369002f, 
    0.11583070f, 0.03057884f, -0.09990948f, -0.13494104f, 0.04763126f, -0.04291496f, -0.15179984f, 0.03237871f, 
    -0.07007539f, 0.25600442f, 0.14122739f, -0.24951395f, -0.09247726f, 0.01397609f, -0.03450772f, 0.06941714f, 
    0.01013899f, 0.02419870f, -0.13051984f, -0.20340416f, -0.25778550f, 0.08070239f, -0.06992961f, 0.10990014f, 
    0.02907152f, 0.13880646f, -0.08171147f, -0.31447148f, 0.11492014f, -0.02530139f, -0.09446017f, 0.03895126f, 
    -0.00944747f, -0.06011401f, -0.13075000f, 0.12433888f, -0.10265897f, 0.07101629f, 0.03986315f, 0.05446424f, 
    0.07300448f, -0.08645252f, 0.12098747f, -0.08584666f, 0.03893925f, -0.04034894f, 0.10512069f, -0.03055742f, 
    0.04205735f, -0.03558657f, -0.00039127f, 0.03514577f, -0.05378169f, 0.00933413f, 0.04381667f, 0.05409447f, 
    0.02065333f, 0.08545084f, 0.05764091f, -0.03052117f, -0.01929426f, -0.09649666f, 0.08180043f, -0.12962975f, 
    0.03040556f, 0.01432484f, 0.04624557f, -0.00183523f, 0.13824616f, 0.12829216f, 0.06051802f, -0.03880680f, 
    -0.20854872f, -0.21387181f, 0.04574170f, -0.03046562f, 0.05586914f, 0.10938431f, 0.18679711f, 0.05976770f, 
    -0.11247039f, 0.13883312f, 0.07271818f, -0.05977783f, -0.13920057f, 0.08597239f, -0.06026675f, 0.05124726f, 
    -0.03983742f, 0.14740013f, 0.32128403f, -0.08728793f, 0.04517502f, -0.01533824f, -0.13285802f, 0.01429601f, 
    0.05592072f, 0.04576016f, -0.07448720f, -0.00340951f, -0.05511608f, -0.05434747f, 0.07979871f, 0.06569394f, 
    0.14043419f, -0.10828447f, 0.06217105f, -0.00671585f, 0.06828954f, 0.03477415f, -0.03609077f, 0.14535879f, 
    0.08597766f, 0.14733365f, 0.04449761f, -0.01749571f, -0.20644580f, 0.05527040f, -0.30580440f, -0.06287743f, 
    -0.04543680f, -0.07232034f, 0.01787982f, 0.02892011f, 0.11061899f, 0.11604329f, -0.17348818f, -0.00589059f, 
    -0.00059865f, 0.09433889f, -0.03015051f, 0.02294744f, -0.02619996f, -0.01398849f, 0.01057090f, -0.04251490f, 
    0.02012165f, -0.09222577f, -0.15126042f, -0.02883709f, 0.06867349f, 0.03381838f, -0.04351732f, -0.09319380f, 
    0.12736830f, -0.05520645f, 0.08846149f, -0.03284008f, 0.06060207f, 0.00358775f, -0.00099006f, 0.02273215f, 
    0.03077248f, 0.04662003f, 0.03123417f, 0.00453857f, 0.09701362f, 0.04393250f, 0.03297659f, 0.00861832f, 
    0.05002083f, -0.04462988f, -0.15212291f, -0.01516919f, 0.10241081f, 0.05231173f, -0.01737766f, 0.09041499f, 
    0.01966291f, 0.00974295f, -0.09741008f, -0.32981652f, -0.10336501f, -0.04731266f, 0.13908052f, 0.06358152f, 
    0.06101546f, -0.03578616f, 0.06097195f, -0.02257274f, 0.07209968f, -0.27639192f, -0.13107923f, -0.05081365f, 
    0.00968503f, 0.09966147f, 0.10413416f, -0.06683826f, -0.14738485f, -0.13968137f, -0.17780380f, 0.14443359f, 
    0.05296306f, -0.03549945f, 0.08186787f, 0.00785760f, 0.00812056f, 0.09131522f, -0.27992624f, 0.09372132f, 
    0.03811503f, 0.06703525f, 0.06169700f, -0.00750513f, -0.08029722f, -0.06330943f, -0.02128722f, 0.23619182f, 
    -0.49245876f, 0.02428500f, 0.07348277f, 0.04333821f, -0.02519878f, -0.07833876f, 0.08837249f, 0.03852259f, 
    -0.29083073f, -0.15359126f, -0.06375611f, 0.10602623f, 0.08552960f, -0.07087729f, 0.12457997f, 0.02085329f, 
    0.06823764f, -0.09814335f, 0.01241936f, 0.12885834f, -0.05833569f, 0.00628015f, 0.01903346f, -0.12306619f, 
    0.07810675f, 0.07251818f, 0.38203302f, -0.00122188f, -0.11172317f, -0.03013645f, 0.02892810f, -0.03682746f, 
    -0.03892237f, -0.02889252f, -0.06563956f, 0.11777830f, -0.10415838f, -0.15598838f, -0.08151921f, 0.03188926f, 
    0.00501757f, -0.09029970f, 0.01053496f, -0.08108372f, 0.20670034f, -0.05428833f, -0.09116923f, 0.01873830f, 
    -0.04733602f, 0.24554144f, 0.00480316f, -0.05555604f, -0.08647606f, 0.20982872f, 0.04501817f, 0.08581788f, 
    0.06113070f, 0.03863040f, -0.03371029f, -0.03797360f, -0.07188643f, 0.07371261f, -0.21104340f, -0.14814939f, 
    0.12624216f, 0.04870117f, 0.14497834f, -0.03360104f, 0.02205192f, -0.05728622f, -0.02445530f, -0.24538556f, 
    0.15039131f, -0.23417020f, 0.02952459f, 0.01645700f, 0.03411585f, -0.06822599f, 0.08569238f, 0.03465478f, 
    -0.34091809f, 0.13693282f, -0.06145696f, -0.13997769f, -0.03529654f, -0.07251901f, 0.09379536f, -0.02361023f, 
    0.08343911f, -0.10547099f, -0.01209283f, 0.02935762f, -0.01246037f, 0.06863289f, 0.04927792f, -0.04152999f, 
    -0.00830701f, 0.03174260f, -0.07705360f, 0.14247274f, 0.04273224f, -0.09864847f, -0.05683802f, 0.04287012f, 
    -0.11148247f, 0.12386087f, -0.00541359f, 0.21278886f, -0.23479232f, 0.17028898f, -0.01053537f, -0.09202584f, 
    -0.14851406f, -0.03996759f, -0.03620100f, -0.03965460f, 0.27542672f, -0.39854011f, -0.19801310f, 0.05630552f, 
    -0.01301231f, -0.04982373f, -0.08023301f, -0.05086203f, -0.00670481f, 0.01217885f, 0.10906155f, 0.01616461f, 
    0.03714743f, 0.07706802f, 0.08185517f, -0.01722865f, 0.00293421f, -0.10220595f, 0.05371346f, -0.05294899f, 
    0.06666043f, -0.03066706f, -0.04849609f, 0.03689334f, 0.06894974f, 0.06134740f, 0.11808127f, 0.03692871f, 
    -0.08621402f, 0.10163769f, -0.05033853f, -0.06295197f, 0.02111930f, 0.03502349f, 0.11167204f, -0.01099678f, 
    -0.01307104f, -0.00508591f, 0.00395415f, -0.17256267f, 0.01590943f, -0.02208135f, -0.01594553f, 0.06021231f, 
    0.01741420f, -0.02533440f, -0.17360470f, -0.04183936f, -0.03039355f, 0.05836554f, 0.00361960f, -0.07026032f, 
    0.01823968f, -0.05567022f, -0.28492230f, -0.16840766f, 0.07475221f, 0.03532817f, 0.08522996f, 0.07381617f, 
    -0.01360503f, 0.00806728f, -0.01115472f, 0.21331714f, -0.10115429f, -0.08461525f, 0.07058859f, 0.01372017f, 
    0.09118687f, 0.12457760f, -0.10805412f, -0.07926951f, 0.05669041f, 0.11232961f, -0.08891950f, -0.02569936f, 
    -0.16735980f, 0.04119175f, -0.04813698f, 0.09172523f, -0.07250473f, 0.05797697f, 0.06158263f, 0.00936456f, 
    0.07330380f, 0.06481125f, -0.08064089f, 0.07775607f, 0.00696690f, -0.06061889f, -0.22836494f, 0.02809491f, 
    -0.10180691f, 0.19143064f, -0.09630749f, -0.03001931f, -0.02161711f, -0.01532724f, 0.06214024f, 0.32712913f, 
    0.11645237f, -0.07769889f, 0.05523302f, -0.04209312f, 0.00106280f, -0.03980722f, -0.03714604f, 0.03543745f, 
    -0.00233464f, 0.09451972f, 0.00090679f, -0.04433975f, 0.01056684f, -0.05162901f, 0.03988288f, 0.05315713f, 
    0.06687722f, -0.26233092f, -0.25483745f, -0.04487872f, 0.08687136f, 0.04146840f, -0.06543601f, -0.01642032f, 
    0.08557225f, -0.00247574f, -0.25826988f, -0.13038053f, 0.01526917f, -0.13062268f, 0.02197479f, 0.01659800f, 
    -0.06098825f, -0.00359683f, 0.04438950f, -0.11869174f, -0.21984674f, -0.11284377f, 0.10190643f, 0.09135701f, 
    0.04216739f, -0.02567862f, -0.02368872f, -0.06831237f, -0.05318661f, -0.03868276f, -0.19864230f, -0.07528072f, 
    0.00660771f, 0.11773624f, 0.00646895f, 0.11226662f, -0.01906328f, 0.14496844f, 0.03967884f, -0.21074694f, 
    -0.15035814f, -0.07710359f, -0.07190184f, 0.04044261f, -0.01651393f, -0.05458282f, -0.01641637f, -0.06404176f, 
    0.18889377f, -0.05927220f, -0.00978991f, 0.02879141f, -0.15090849f, 0.01909118f, 0.00443348f, 0.26248997f, 
    0.15164338f, -0.14391141f, 0.07030738f, 0.00987139f, -0.03860885f, -0.07308336f, -0.09070467f, -0.09258618f, 
    0.28378424f, 0.18701398f, -0.00556972f, 0.03151555f, 0.13256164f, 0.01971288f, 0.05497474f, -0.12856869f, 
    0.01929505f, 0.08558178f, 0.07243181f, -0.02405451f, -0.15816070f, 0.09671918f, -0.01786603f, -0.11549588f, 
    -0.01561736f, -0.02958020f, -0.04862936f, 0.00513788f, 0.12053224f, 0.11759813f, 0.10965484f, 0.06537540f, 
    0.12767231f, -0.06806488f, -0.13291751f, -0.24396113f, -0.08379988f, -0.10871797f, -0.02588592f, -0.16029544f, 
    -0.12295256f, 0.06555613f, 0.02851078f, -0.00445792f, -0.03606041f, -0.05989832f, 0.04891647f, 0.07920187f, 
    -0.01526820f, 0.00878546f, -0.01535362f, 0.03372104f, -0.14029682f, 0.04234595f, 0.03120863f, 0.08111800f, 
    0.00083639f, 0.08533459f, 0.05355698f, 0.06652911f, -0.04094975f, 0.06950521f, -0.30541748f, -0.08668894f, 
    0.14005293f, 0.02090065f, 0.02793037f, 0.01152398f, -0.03859950f, -0.04556649f, -0.17471892f, -0.18717961f, 
    -0.32986432f, 0.15382707f, -0.09569558f, -0.00119721f, 0.06217876f, -0.09124798f, -0.04692347f, 0.02094223f, 
    -0.08126975f, -0.15601337f, 0.09851056f, 0.12631401f, -0.00439920f, -0.00804736f, -0.10520283f, -0.03675111f, 
    0.03028017f, 0.06143539f, -0.05602568f, 0.18012989f, -0.13569082f, -0.01985883f, 0.02983150f, -0.10573247f, 
    0.07794749f, 0.09385648f, 0.17510846f, -0.02465591f, 0.04441183f, -0.15676029f, 0.00061966f, -0.03823124f, 
    0.03317276f, 0.10991555f, 0.01026233f, 0.22680552f, 0.21204691f, 0.24042639f, 0.00289227f, -0.05188093f, 
    -0.12542069f, 0.01259697f, 0.05856838f, 0.09274103f, 0.44577470f, 0.24468461f, -0.20830250f, 0.12412777f, 
    0.02470873f, 0.04226301f, 0.01646192f, 0.00731433f, -0.09440643f, -0.06564626f, -0.06827510f, 0.09549931f, 
    0.03994470f, -0.07221413f, 0.07241815f, 0.01926246f, 0.05495616f, -0.13424911f, -0.01564521f, -0.01523195f, 
    -0.02536743f, 0.00748812f, 0.05487212f, -0.01900737f, 0.07447878f, 0.10615963f, 0.04848890f, -0.10356704f, 
    0.13743719f, -0.10431356f, -0.10753636f, -0.03120597f, 0.01106674f, 0.14973487f, 0.02400632f, -0.03279268f, 
    -0.09143886f, 0.23860726f, 0.10306539f, -0.07690884f, -0.09459068f, -0.17770155f, -0.05794157f, 0.00551244f, 
    0.07322790f, -0.17478131f, 0.05744606f, -0.27869132f, 0.02789715f, -0.04914561f, 0.04891321f, 0.12058636f, 
    -0.04589717f, 0.01560345f, 0.02527757f, -0.24951203f, -0.09418892f, 0.06456749f, -0.00221450f, -0.07157987f, 
    0.13704206f, 0.04487194f, 0.03701173f, 0.24379404f, 0.15372752f, -0.34484449f, -0.10689394f, 0.05386848f, 
    0.02518416f, 0.03578933f, -0.01873972f, -0.09472114f, -0.41396758f, 0.00192933f, 0.25163722f, 0.01945831f, 
    0.02724798f, -0.04538147f, 0.02004192f, 0.08800113f, 0.10860751f, -0.09466223f, -0.05703164f, 0.22250454f, 
    -0.03821378f, -0.07431860f, 0.00009421f, 0.04624481f, 0.09171592f, 0.16259140f, 0.17897792f, -0.02670070f, 
    -0.25571254f, -0.19350086f, 0.10797929f, 0.00872104f, -0.06243824f, -0.08224626f, -0.12375196f, -0.06199896f, 
    -0.21470214f, 0.06318959f, -0.03034959f, 0.02924418f, -0.14022917f, 0.04432318f, 0.10895126f, 0.03623590f, 
    0.12854508f, 0.07946872f, -0.02445302f, -0.06351293f, 0.02573422f, 0.00172260f, 0.09057424f, 0.00069167f, 
    -0.11354388f, 0.15074310f, -0.04923175f, 0.01502880f, -0.14136438f, 0.01299567f, 0.00418479f, 0.13218196f, 
    0.03544634f, -0.13070437f, 0.10735809f, 0.02700350f, -0.16878167f, -0.01981234f, 0.09239159f, 0.05502453f, 
    0.04893738f, 0.13957627f, -0.07869893f, 0.10404219f, -0.13195552f, 0.00348311f, -0.09552161f, -0.00047141f, 
    0.10744055f, 0.09558299f, 0.05102443f, -0.07218770f, 0.13629663f, -0.23465958f, -0.17216085f, 0.03683715f, 
    0.07313956f, 0.08923985f, -0.11602564f, 0.14669535f, -0.09182589f, 0.34625405f, 0.12722546f, 0.00171717f, 
    -0.14038604f, -0.03187780f, 0.02190634f, -0.00320281f, 0.06397297f, 0.04046890f, -0.10231020f, -0.00270910f, 
    -0.09278153f, 0.06729953f, 0.00271638f, 0.00570149f, 0.04092568f, 0.04689487f, -0.00189618f, -0.01298191f, 
    0.02372886f, -0.14586355f, -0.01323913f, -0.06343550f, -0.12462028f, -0.06819545f, -0.04286515f, 0.05557967f, 
    -0.00858914f, -0.00580298f, 0.00236375f, -0.08671018f, -0.17448889f, -0.01976073f, 0.08010926f, -0.03057190f, 
    0.11457787f, 0.29063961f, 0.21818833f, 0.09392235f, -0.13541390f, 0.00782743f, 0.08233111f, -0.14364101f, 
    0.05473407f, 0.07655723f, -0.15409169f, 0.16692375f, 0.18838485f, 0.00139458f, -0.03110467f, -0.08677213f, 
    0.11075080f, 0.06013190f, 0.13035321f, 0.04050094f, 0.19331677f, -0.09829622f, -0.09372611f, -0.00516933f, 
    -0.08003075f, 0.03734751f, 0.21480197f, -0.09610213f, 0.04870658f, -0.04121805f, 0.32629114f, 0.08224033f, 
    0.09751556f, 0.09110688f, -0.03062164f, 0.04953560f, -0.13637288f, 0.00166774f, 0.19284485f, 0.09323807f, 
    0.06836700f, 0.00594826f, 0.02962200f, 0.08044963f, 0.12229738f, -0.01744854f, 0.05307850f, -0.14209816f, 
    -0.03882324f, -0.10444824f, 0.09910154f, 0.11322957f, 0.00782021f, 0.05189260f, 0.02140117f, -0.08658154f, 
    -0.03378246f, 0.11356571f, 0.00956495f, 0.10400013f, 0.11468090f, 0.04108698f, 0.15288845f, 0.02026874f, 
    0.05671848f, 0.04369200f, 0.13695356f, -0.02148035f, 0.07891390f, -0.05197475f, -0.07059712f, 0.04496395f, 
    0.16452768f, 0.12070690f, 0.04822667f, -0.07425649f, 0.05763585f, -0.03529361f, 0.15499857f, 0.12164392f, 
    0.11832060f, -0.21982987f, 0.02719721f, -0.05590395f, -0.00132210f, -0.15688445f, -0.07074337f, 0.03022727f, 
    -0.06291503f, 0.11404714f, 0.00050708f, -0.07660875f, 0.02960965f, 0.04232219f, 0.00418876f, -0.04953277f, 
    -0.33040315f, 0.13355465f, 0.03374499f, -0.15073228f, 0.15028656f, 0.15967402f, -0.09831453f, -0.06774093f, 
    -0.04688017f, -0.07317226f, 0.07770440f, 0.02470873f, -0.03098216f, -0.04297209f, -0.11448368f, -0.10674954f, 
    0.00817243f, 0.06040163f, 0.06189352f, 0.10393458f, -0.07593537f, -0.04847065f, 0.25793731f, 0.04476685f, 
    -0.06417845f, -0.01102978f, -0.05342052f, 0.14054744f, -0.04614576f, 0.12484050f, 0.02587378f, 0.00013926f, 
    0.17963620f, 0.00403304f, -0.15693139f, -0.16013731f, 0.06683628f, 0.08725303f, 0.16165805f, -0.11346184f, 
    0.23226006f, 0.25619164f, -0.11614899f, 0.17716773f, -0.12814610f, -0.09761432f, -0.03274722f, 0.04847850f, 
    -0.00854006f, 0.01126018f, 0.14379701f, -0.27903625f, 0.04570630f, -0.11745857f, -0.00065725f, 0.01222175f, 
    0.01545183f, 0.07670563f, -0.05462486f, -0.22107077f, -0.13276111f, 0.04385160f, 0.13583772f, -0.12716793f, 
    -0.11230180f, -0.20235248f, -0.01456923f, -0.03214128f, 0.04345175f, -0.19281614f, -0.07601459f, -0.04400589f, 
    -0.12994274f, 0.08613157f, -0.05815767f, -0.05949099f, -0.13663219f, 0.10712890f, 0.31407267f, 0.05104950f, 
    0.08758696f, -0.00293187f, 0.13330545f, 0.13725613f, 0.01826323f, -0.08869671f, 0.11896381f, 0.32520831f, 
    -0.00287493f, 0.03318961f, 0.07998319f, -0.02953079f, -0.02674489f, -0.02543278f, -0.05956272f, -0.26226434f, 
    -0.06151076f, -0.14865366f, 0.07257794f, -0.04566577f, 0.15828544f, -0.05648362f, 0.04980726f, -0.09680301f, 
    0.02874741f, 0.03343157f, 0.25023231f, -0.00325509f, 0.08022013f, -0.10038179f, 0.08955559f, -0.04535213f, 
    -0.03504817f, -0.00372041f, 0.04314291f, -0.01668125f, 0.03713252f, -0.05265149f, -0.00776722f, -0.01407982f, 
    -0.05257750f, -0.05420204f, -0.01743226f, 0.02536200f, 0.03798257f, 0.00664216f, -0.05252859f, -0.01150173f, 
    0.05200117f, 0.02590685f, -0.01379903f, -0.03627063f, 0.02626978f, -0.05369964f, 0.03713645f, 0.02226904f, 
    0.03075426f, 0.02032610f, -0.04055733f, 0.00831130f, -0.01565370f, -0.06246024f, -0.05512375f, 0.02102663f, 
    0.05043883f, 0.00291715f, -0.01680669f, -0.05060412f, 0.00039067f, -0.05631024f, -0.03127801f, -0.04735887f, 
    -0.04646386f, -0.04240863f, -0.03667124f, -0.04092884f, -0.05696365f, 0.01739529f, 0.04639695f, 0.02257323f, 
    0.04646165f, 0.04007196f, 0.00206370f, -0.04272625f, -0.04326793f, -0.00071195f, -0.03877562f, 0.05153343f, 
    -0.04247069f, -0.01687030f, -0.00323989f, 0.02474622f, 0.03432698f, -0.01529909f, -0.00298530f, -0.03101216f, 
    -0.04312759f, -0.06093718f, 0.04693580f, 0.01874955f, -0.00823680f, -0.04657533f, -0.03419717f, 0.01411126f, 
    -0.00278689f, -0.05264157f, 0.00573895f, 0.04875704f, -0.03011005f, -0.05098627f, 0.03563311f, -0.03494390f, 
    -0.01967351f, -0.01568673f, -0.04680652f, 0.04397351f, -0.04299049f, 0.03373195f, -0.03626519f, 0.00839013f, 
    0.00350182f, -0.01830649f, -0.02212175f, -0.02695883f, -0.03553898f, -0.06158285f, 0.01392861f, 0.03950397f, 
    -0.04795291f, -0.02666325f, -0.02076641f, -0.05950484f, -0.01180902f, 0.05502652f, 0.01752585f, 0.03326092f, 
    0.00874797f, -0.04288527f, -0.02538684f, -0.01546897f, 0.02397943f, 0.00274954f, -0.05844759f, 0.02551446f, 
    -0.02200815f, -0.02150800f, 0.04253938f, -0.05785973f, 0.04278509f, -0.03039368f, -0.01926059f, 0.01686808f, 
    -0.05933681f, 0.03325714f, 0.00922061f, 0.01255795f, 0.03682791f, -0.02886453f, -0.03809353f, 0.02665740f, 
    -0.00990877f, 0.02281608f, -0.01769118f, -0.00305163f, 0.04046101f, -0.01176736f, 0.04084730f, -0.04983093f, 
    -0.01479221f, 0.03187400f, -0.05570206f, 0.04176338f, -0.01574659f, -0.06386869f, 0.00690941f, -0.06247466f, 
    0.05162794f, 0.01804354f, -0.01786406f, -0.02004214f, 0.02643001f, 0.02440718f, 0.00805497f, 0.02401863f, 
    -0.01233087f, 0.00355876f, 0.03835965f, -0.02290981f, -0.04192307f, 0.04630974f, -0.02279007f, 0.04637842f, 
    0.01993158f, 0.02262364f, -0.05237728f, -0.03737879f, -0.01035086f, 0.02234897f, 0.00555962f, 0.01315203f, 
    -0.04069192f, -0.03978073f, -0.04901023f, -0.03339868f, -0.00152012f, -0.05341912f, -0.03653034f, 0.02294877f, 
    0.03585267f, 0.00567380f, -0.05467937f, -0.00828332f, -0.02643663f, -0.05018706f, -0.05803357f, -0.06323694f, 
    0.02031151f, -0.03537995f, 0.03411100f, 0.04457199f, 0.02916246f, -0.00544283f, 0.03745644f, 0.00404306f, 
    -0.03535937f, 0.03335563f, 0.01204817f, 0.04280923f, 0.00580660f, 0.00427780f, -0.01808650f, 0.03035379f, 
    0.00495946f, -0.01322937f, -0.06353615f, -0.05806657f, -0.03508583f, 0.01226753f, -0.02392517f, -0.04550989f, 
    -0.04786897f, 0.00896244f, 0.04002677f, 0.04345782f, -0.05139049f, -0.00716957f, -0.00348365f, 0.03875503f, 
    -0.04924496f, 0.02349923f, -0.05384883f, 0.01812440f, -0.00455407f, 0.02842137f, -0.03221304f, -0.04576116f, 
    -0.01491287f, -0.05878512f, -0.01960784f, -0.03634654f, -0.02917542f, -0.04908288f, 0.03293347f, -0.05643042f, 
    -0.03567830f, -0.05462783f, -0.03653459f, -0.02293683f, 0.00321608f, -0.01560092f, -0.00374187f, -0.01805517f, 
    -0.04154341f, -0.03693790f, -0.03831869f, 0.05473077f, -0.03043512f, 0.01119559f, 0.00216411f, -0.03759186f, 
    -0.01933592f, -0.05865648f, -0.01591790f, -0.05604642f, -0.00815720f, -0.02541195f, 0.05009043f, -0.00533426f, 
    -0.00864602f, 0.04553089f, 0.00931834f, -0.02121892f, -0.01968405f, -0.05041511f, -0.02394921f, -0.01368205f, 
    0.00034544f, -0.06204076f, -0.01921861f, -0.03739444f, -0.06279816f, 0.01904585f, 0.01720317f, 0.03584703f, 
    -0.04934030f, -0.05739974f, -0.05161034f, 0.04644364f, 0.05041752f, 0.03375169f, -0.03188824f, 0.00759862f, 
    0.04836606f, -0.00165745f, -0.01907214f, -0.06346050f, 0.02104712f, 0.01709128f, 0.01109403f, -0.00584229f, 
    0.06814487f, -0.01260423f, 0.11043347f, 0.00204557f, -0.04290650f, -0.13056850f, -0.05969431f, -0.06401101f, 
    0.03075586f, 0.04002856f, 0.07935867f, 0.01986329f, 0.14227699f, -0.09903712f, 0.07590315f, 0.05859874f, 
    0.01457760f, 0.04044209f, 0.03177530f, -0.09744253f, -0.00579873f, 0.05693760f, 0.06471901f, -0.24876264f, 
    0.13529609f, 0.10720640f, 0.03882065f, -0.00675446f, 0.20253798f, 0.20332663f, 0.14577247f, -0.10145045f, 
    0.05618707f, 0.06726903f, 0.03278805f, 0.02019415f, 0.18211074f, 0.04314532f, 0.03540184f, 0.13432105f, 
    -0.11158874f, -0.13719603f, 0.00897376f, 0.10230822f, -0.00920402f, -0.09199402f, 0.04081896f, -0.01572509f, 
    0.02530293f, 0.02123727f, -0.06394330f, 0.05809904f, -0.01394241f, -0.12287234f, 0.05514402f, 0.10860189f, 
    -0.05931957f, 0.07975507f, 0.20049842f, -0.22752774f, -0.10365567f, 0.11339406f, 0.05162143f, -0.02984249f, 
    0.01726096f, -0.14695248f, 0.06636485f, -0.09924366f, -0.03211083f, 0.06803204f, -0.05209967f, 0.05287617f, 
    0.10472186f, 0.11613056f, -0.05101067f, 0.02264520f, 0.03894060f, 0.13295229f, 0.05828501f, 0.07641149f, 
    0.01249590f, -0.25670823f, 0.00974835f, 0.00436326f, 0.12849244f, 0.01045587f, -0.03428982f, 0.06527449f, 
    0.00281940f, -0.09543651f, 0.12443151f, -0.07778047f, -0.15132469f, -0.04556300f, -0.07192089f, -0.04349310f, 
    -0.00628693f, -0.04499101f, -0.08082198f, 0.23816708f, -0.08163509f, 0.02680792f, 0.04903154f, -0.03438288f, 
    -0.05452417f, 0.00768371f, -0.06592963f, -0.15232888f, -0.09673259f, -0.02588063f, 0.03379453f, 0.02723779f, 
    0.12536050f, -0.03559447f, -0.19955121f, -0.17697738f, -0.00972648f, 0.03559265f, -0.02065888f, 0.06982079f, 
    -0.07304131f, -0.00063806f, -0.14666963f, -0.05153362f, -0.01615003f, 0.14497244f, 0.10592908f, 0.02756771f, 
    0.08588371f, 0.12883262f, -0.01797109f, -0.02680193f, -0.01348260f, 0.04229221f, 0.04962985f, 0.06073314f, 
    -0.11015744f, 0.06823482f, 0.01292534f, 0.14249486f, 0.01434656f, -0.14993531f, -0.02913782f, -0.01673451f, 
    -0.18480837f, 0.04304010f, -0.01711155f, -0.01218432f, 0.05053740f, 0.04123642f, -0.10704183f, -0.01754388f, 
    0.12267736f, -0.03212406f, 0.08474391f, 0.02570240f, -0.03647354f, 0.21483792f, -0.10099971f, -0.11676446f, 
    0.09871810f, 0.09823004f, -0.39604026f, -0.03945232f, -0.14459904f, 0.14227293f, 0.07339010f, 0.05404291f, 
    0.13773285f, -0.07233039f, -0.06369177f, 0.19401158f, 0.14919659f, -0.06257586f, -0.06451229f, -0.01517602f, 
    0.07501405f, 0.01663215f, -0.07657707f, -0.12367334f, 0.05084322f, -0.07965024f, -0.10972353f, 0.03208786f, 
    0.07499470f, 0.07484306f, 0.00109529f, 0.01260094f, 0.01241853f, 0.06008144f, -0.10882242f, 0.15864773f, 
    0.14260256f, 0.05139931f, 0.05371678f, -0.06240495f, -0.00136460f, 0.12083729f, 0.17309627f, -0.09612260f, 
    -0.03340914f, 0.02256807f, -0.03223053f, -0.16387321f, -0.06193048f, -0.02767822f, -0.00142409f, 0.10344363f, 
    0.04329699f, 0.00544027f, 0.00404159f, 0.02711597f, 0.03151022f, -0.03856258f, 0.07039330f, -0.13178638f, 
    0.05734535f, -0.14633740f, -0.06374988f, -0.04945274f, 0.03587341f, 0.00192718f, 0.03381508f, 0.02452477f, 
    0.02425416f, 0.09538233f, -0.08688942f, 0.06972488f, 0.16577105f, 0.08223648f, 0.00810537f, 0.02377007f, 
    0.03379257f, -0.13153915f, 0.12418353f, 0.02806466f, -0.09153286f, 0.05231715f, -0.01005778f, 0.04086957f, 
    0.01998292f, 0.05994902f, 0.05899188f, 0.03498539f, -0.06682251f, 0.02345311f, -0.09631586f, -0.08730676f, 
    0.02375970f, 0.01177264f, 0.01723848f, 0.03988882f, -0.15238173f, -0.07969844f, -0.08737241f, 0.11732432f, 
    -0.02952811f, -0.01292498f, -0.01848293f, 0.05880314f, -0.00096702f, -0.09789079f, 0.10157694f, -0.15747252f, 
    0.10800706f, -0.04077071f, -0.00448124f, 0.14607033f, -0.03430003f, 0.04652237f, -0.19917436f, 0.17672342f, 
    -0.10081949f, 0.02736668f, -0.00604883f, -0.01333008f, -0.02549812f, 0.04002886f, -0.05053410f, -0.03100779f, 
    -0.02953961f, 0.09595065f, -0.13871576f, 0.12563577f, -0.16733788f, 0.03385400f, 0.00343120f, -0.11697308f, 
    0.04604186f, 0.06604013f, -0.07502417f, 0.07180482f, 0.06041708f, -0.10910610f, 0.07762389f, 0.02382627f, 
    -0.02264323f, -0.19489628f, -0.14151591f, 0.16486992f, -0.00988861f, -0.02841552f, -0.11078326f, 0.04157108f, 
    -0.00024049f, -0.09646343f, -0.01850805f, -0.01584320f, -0.03581471f, -0.01394711f, -0.05099354f, -0.08278632f, 
    0.05142564f, 0.10301598f, -0.03469039f, -0.15132201f, -0.04893175f, -0.11348690f, -0.01121888f, 0.04703144f, 
    0.09627325f, -0.01048649f, -0.08350278f, 0.05047065f, -0.36618662f, -0.22578953f, -0.40368447f, -0.00443008f, 
    0.00074189f, -0.03759469f, -0.06382857f, 0.09284139f, -0.03493968f, 0.03896547f, -0.15837665f, -0.17415603f, 
    0.07938554f, 0.03122339f, -0.02569234f, 0.03880496f, -0.01767345f, 0.01001366f, -0.00409291f, 0.05767753f, 
    -0.00356269f, -0.00738697f, -0.07181942f, -0.07944541f, -0.08720680f, 0.01683410f, -0.02888573f, -0.12799034f, 
    -0.08564559f, -0.11678466f, -0.00280413f, -0.01618116f, 0.02940330f, 0.07511816f, 0.08039691f, -0.03259777f, 
    -0.03057167f, -0.09551419f, 0.17444123f, -0.14164643f, -0.06185781f, 0.03890313f, 0.06032583f, 0.07705534f, 
    0.10962282f, 0.18896036f, 0.02690194f, -0.12874235f, 0.00402079f, 0.01718067f, -0.06305303f, -0.00897065f, 
    -0.06399360f, -0.09682441f, 0.19560665f, 0.01247687f, -0.02440629f, 0.04523601f, -0.02789303f, -0.02719930f, 
    -0.00643085f, -0.05020573f, -0.04633246f, 0.04326445f, -0.13319182f, 0.09224472f, -0.05646164f, -0.05980187f, 
    -0.03000697f, -0.01752834f, -0.00637906f, 0.03888118f, 0.02617326f, 0.02580443f, -0.16570276f, 0.08399036f, 
    -0.00247675f, 0.18404350f, -0.08711413f, 0.07829554f, 0.19613568f, 0.21339133f, -0.08563417f, -0.06619519f, 
    0.03108653f, 0.04480610f, -0.02702544f, 0.12728651f, -0.01177798f, -0.01168516f, -0.20728390f, -0.06324594f, 
    0.09462998f, -0.00120923f, 0.01144383f, -0.08193805f, 0.04513453f, -0.04945012f, 0.00141323f, 0.00155891f, 
    0.11991814f, -0.00803141f, 0.08590783f, 0.04279939f, 0.02035763f, -0.03366484f, -0.03259777f, -0.00251902f, 
    0.02628151f, -0.03791646f, -0.30714029f, 0.02138339f, -0.06444305f, -0.02779483f, -0.10343581f, 0.03607634f, 
    -0.10614983f, -0.06345704f, 0.18626039f, -0.08214027f, 0.03177316f, -0.02404035f, -0.00513251f, 0.06340297f, 
    0.09976659f, 0.07414628f, 0.33488116f, 0.02644252f, -0.21411744f, 0.00477715f, -0.00140879f, 0.03065134f, 
    0.06643850f, 0.00174431f, -0.02287385f, -0.06279128f, -0.11286708f, -0.01040760f, -0.02542862f, 0.01459821f, 
    0.01633439f, -0.04298834f, 0.11793730f, 0.13695624f, 0.11122017f, -0.11298997f, 0.19195101f, -0.11216568f, 
    -0.05557364f, 0.09705547f, 0.00641654f, -0.03775083f, 0.11456903f, 0.01699018f, 0.10449385f, 0.19252862f, 
    -0.00492908f, -0.09530368f, 0.08676974f, -0.04046308f, -0.06167552f, 0.13532147f, -0.08846641f, -0.05180262f, 
    -0.07463617f, 0.01739730f, 0.06447150f, -0.09074873f, 0.08153678f, 0.03793877f, 0.07241409f, 0.01475906f, 
    0.00537226f, 0.12441464f, 0.01174579f, 0.15034133f, -0.01554801f, -0.05617946f, 0.11417992f, -0.07958566f, 
    0.05358146f, -0.02728820f, 0.01352112f, 0.02931508f, -0.04160056f, 0.03892438f, 0.19331494f, -0.04429774f, 
    -0.22368075f, -0.07851858f, 0.03794030f, 0.18315315f, 0.04064988f, -0.01984594f, -0.00877853f, -0.02704054f, 
    0.11839153f, -0.02605302f, -0.28767470f, 0.05543012f, -0.34667891f, -0.12584932f, -0.10367162f, 0.20839351f, 
    -0.00134091f, -0.07052498f, 0.09250055f, 0.16691652f, -0.02110151f, 0.22490185f, -0.05442094f, -0.03236905f, 
    0.00125173f, -0.10907312f, 0.08991998f, 0.12381490f, 0.18766102f, 0.10889534f, -0.12835845f, -0.04436205f, 
    0.05422084f, 0.06740960f, -0.00628488f, -0.05613198f, 0.05357195f, -0.07453447f, 0.16863181f, -0.16619335f, 
    0.05663817f, 0.01933527f, -0.03152267f, 0.10536917f, -0.09471038f, 0.12644178f, -0.02405996f, 0.01403826f, 
    0.07351620f, -0.17393197f, -0.09218884f, 0.04400029f, -0.07245380f, 0.01086213f, 0.13122056f, 0.13419516f, 
    -0.15851298f, 0.12447895f, -0.06382848f, -0.00850240f, -0.03024800f, 0.09170862f, 0.04662262f, -0.01210715f, 
    0.04924900f, -0.08321869f, -0.16697164f, -0.01564270f, 0.03650026f, 0.08677709f, 0.01257126f, -0.12838216f, 
    -0.03254394f, -0.15039755f, -0.05189075f, -0.02566294f, -0.01090797f, 0.09746002f, -0.00906248f, -0.06323405f, 
    0.03968038f, -0.06594804f, -0.11193322f, -0.06012970f, -0.06806520f, 0.02072019f, 0.02219243f, 0.05689358f, 
    0.08215583f, 0.03218199f, -0.20838793f, 0.11142320f, 0.00362657f, -0.23173112f, -0.01559752f, 0.02094366f, 
    -0.05498070f, 0.06039431f, -0.04583475f, 0.03048899f, -0.06230830f, 0.02805647f, -0.17556477f, 0.01699112f, 
    -0.07456587f, 0.08351900f, 0.08959738f, -0.09584454f, -0.04300285f, 0.09408318f, -0.15755515f, 0.00810327f, 
    0.17319587f, 0.02249683f, 0.09890967f, 0.10434240f, 0.02902067f, -0.03220870f, -0.06013703f, 0.02537524f, 
    -0.14389697f, 0.09245890f, 0.12126241f, 0.12357766f, 0.16259883f, -0.09838995f, -0.06117165f, 0.06969903f, 
    0.11918496f, -0.09741852f, 0.01745631f, -0.13861631f, -0.20630608f, -0.04590445f, 0.08035486f, 0.11290297f, 
    -0.13688016f, 0.02050697f, -0.06840021f, -0.00959543f, -0.01056316f, 0.05816631f, 0.04737408f, -0.01857994f, 
    0.01661660f, 0.10075255f, -0.04620563f, 0.07199492f, -0.04805705f, 0.00580180f, 0.02719737f, 0.05864624f, 
    -0.08342994f, 0.11972480f, -0.04905318f, 0.07734963f, 0.12851760f, 0.13201886f, -0.05000101f, 0.03783624f, 
    0.14995025f, -0.04856766f, 0.00209044f, -0.01232956f, 0.11164720f, 0.06775620f, 0.01307459f, -0.06583820f, 
    -0.06049715f, -0.00876239f, -0.07522703f, -0.03714491f, 0.09740423f, 0.15555646f, -0.11906762f, -0.04147321f, 
    0.03305883f, 0.10574931f, 0.01488552f, 0.00282287f, -0.00571787f, 0.04722518f, 0.05372694f, 0.07556485f, 
    0.02165357f, -0.02335707f, 0.04671649f, -0.00723781f, -0.02679382f, 0.02052170f, -0.01711504f, 0.00665787f, 
    -0.01126846f, -0.04704548f, -0.04325682f, 0.07670212f, 0.06785958f, 0.02077089f, -0.03347604f, 0.02284154f, 
    0.04966258f, -0.23614134f, 0.11894087f, -0.08000609f, 0.14390974f, -0.03192924f, 0.01103903f, -0.02051998f, 
    0.13504088f, 0.02774225f, -0.13982028f, -0.01394080f, -0.03971793f, 0.04317186f, 0.00555423f, 0.03695678f, 
    0.11706108f, 0.01446600f, -0.07792383f, -0.10436028f, 0.11787245f, -0.06935851f, 0.13791981f, 0.00118758f, 
    -0.19668157f, -0.01917204f, 0.05951523f, 0.02985848f, 0.06196892f, 0.12748607f, 0.04338837f, -0.09248311f, 
    -0.04854139f, 0.08685571f, 0.07306902f, -0.28580123f, 0.01950430f, 0.02012413f, 0.04433567f, -0.04554730f, 
    -0.23741524f, -0.01540247f, 0.10143214f, -0.03493229f, -0.07796254f, 0.14165162f, 0.05703327f, 0.03783118f, 
    0.02253153f, -0.09450635f, -0.02865740f, -0.11104210f, 0.06208459f, 0.05366271f, 0.19406548f, -0.18173404f, 
    0.00970576f, 0.07819350f, 0.06392553f, -0.00246955f, -0.01953227f, 0.07077165f, -0.06424551f, -0.03907330f, 
    0.04785166f, 0.09155996f, -0.06104183f, 0.02339473f, -0.14156392f, -0.04420510f, 0.13818130f, 0.00730271f, 
    0.10170329f, 0.07802343f, 0.04838638f, -0.14576536f, -0.07137924f, -0.13535315f, 0.06693376f, -0.09389632f, 
    -0.02194671f, 0.00131555f, 0.18353377f, 0.07073914f, -0.05956903f, -0.09897273f, 0.12537964f, -0.03254867f, 
    0.08120196f, -0.10095269f, 0.30809844f, 0.01363402f, 0.09032413f, 0.07992145f, -0.05348018f, 0.01100808f, 
    -0.07154742f, 0.08380115f, -0.33024138f, -0.12421279f, -0.36509863f, 0.05503193f, 0.03262431f, -0.12440260f, 
    0.03854077f, 0.00050967f, 0.04600158f, -0.00557459f, 0.05773115f, -0.05107579f, -0.03950452f, -0.04089090f, 
    -0.03589425f, -0.09989642f, -0.03625674f, -0.01070213f, -0.00499395f, 0.01716469f, 0.12779941f, -0.05254615f, 
    -0.04885698f, -0.09846351f, 0.08152011f, -0.02532552f, -0.00915321f, 0.18637942f, 0.01719848f, 0.14970073f, 
    0.01190665f, 0.05568239f, -0.09680955f, -0.06232031f, 0.04580173f, 0.04033270f, 0.03636374f, -0.09954406f, 
    -0.01768329f, 0.04283199f, -0.00607555f, -0.05150297f, -0.02288944f, -0.05977843f, 0.00593289f, -0.21145751f, 
    0.14454974f, -0.05761755f, 0.07260700f, -0.15013795f, 0.03132520f, 0.05607310f, 0.05815874f, -0.10502958f, 
    0.10166495f, -0.04408223f, -0.16489159f, 0.00277863f, 0.01846496f, 0.06064897f, 0.02405170f, -0.02784117f, 
    0.00220495f, 0.00059282f, -0.19057688f, 0.07429650f, 0.01751148f, 0.00531921f, -0.02245380f, -0.05602150f, 
    0.07318766f, -0.01510984f, 0.05981841f, 0.00681497f, 0.04915607f, 0.00155011f, 0.03157039f, -0.01090559f, 
    0.13442187f, -0.11273003f, -0.02310806f, 0.04981625f, -0.04569323f, -0.10387781f, 0.06294408f, 0.01586480f, 
    0.00950405f, 0.03265832f, 0.02500029f, -0.00142679f, -0.03867783f, -0.19120486f, -0.23580992f, -0.04357745f, 
    0.15233785f, -0.07957449f, 0.10786749f, -0.06877078f, -0.02852789f, 0.09696048f, -0.22454034f, -0.02487295f, 
    -0.01866500f, -0.12581694f, 0.07772905f, 0.11880361f, 0.10748569f, 0.15360834f, -0.09833849f, 0.08283318f, 
    -0.02571241f, 0.18629608f, 0.04389613f, 0.03842040f, -0.00895001f, -0.00719824f, -0.09879015f, 0.07760367f, 
    -0.01020470f, -0.06195590f, -0.00174552f, 0.02592477f, -0.01300627f, 0.00833900f, 0.06463850f, 0.13864742f, 
    -0.06031450f, -0.11414495f, 0.02129672f, 0.01773249f, 0.00802031f, -0.09019648f, -0.04066885f, -0.07012563f, 
    0.00848103f, 0.19418296f, -0.03425780f, -0.04451549f, -0.04270039f, -0.05570893f, 0.01547699f, 0.00698530f, 
    -0.00680667f, 0.01248185f, 0.12393345f, 0.19594221f, 0.08773445f, 0.07153314f, -0.06386685f, 0.12486627f, 
    0.06620154f, -0.00074811f, 0.09875555f, 0.13765667f, 0.07147136f, 0.09426022f, -0.14629675f, -0.04747193f, 
    -0.01337822f, -0.00813853f, -0.02621206f, 0.12488667f, 0.02241852f, -0.04498746f, -0.03776958f, 0.08671822f, 
    -0.10203368f, 0.01765454f, -0.01076705f, -0.07089548f, -0.06877281f, 0.17562371f, 0.01466475f, -0.05578788f, 
    0.12400777f, -0.04442252f, 0.08721120f, 0.00579721f, 0.11125206f, 0.02326143f, -0.06529507f, -0.12494894f, 
    -0.05842141f, 0.06876495f, 0.09180741f, 0.11554047f, 0.12215947f, 0.02832766f, -0.03127616f, 0.01574267f, 
    0.10704218f, -0.08490723f, 0.08468828f, -0.03788069f, -0.00223418f, 0.06564490f, 0.00471428f, -0.07307356f, 
    0.06852491f, 0.09686336f, 0.02123834f, -0.01620609f, -0.00361662f, 0.07059208f, 0.00085495f, 0.08214443f, 
    0.01166799f, -0.06811899f, -0.06839831f, -0.06844196f, 0.12072397f, -0.03189050f, 0.08072160f, -0.02052659f, 
    -0.01801288f, -0.00833469f, 0.27584687f, 0.11693268f, 0.01121873f, 0.06723195f, -0.05150400f, 0.01258716f, 
    -0.05285530f, 0.07387520f, 0.06067684f, -0.06829735f, -0.09100253f, -0.05446283f, -0.04810286f, -0.01531233f, 
    -0.08468874f, -0.01446007f, 0.00604131f, 0.02176536f, 0.01991882f, -0.03313559f, 0.13122424f, -0.16411600f, 
    -0.08355477f, 0.12416273f, 0.05253334f, -0.01070183f, 0.09596899f, -0.01489493f, -0.13000619f, -0.07878746f, 
    0.04211024f, 0.02231687f, 0.02523864f, 0.03275552f, -0.15627703f, 0.01755221f, 0.03139965f, -0.13474125f, 
    -0.17270370f, 0.05973860f, -0.02100960f, 0.01122820f, 0.10306153f, -0.02467316f, 0.10743649f, -0.03217165f, 
    0.03576710f, 0.03334520f, 0.03231540f, -0.02496285f, -0.04676582f, -0.00041329f, 0.11645468f, -0.02277990f, 
    0.12542056f, -0.04069342f, 0.08259804f, 0.06494868f, -0.07667618f, -0.09625347f, 0.10997863f, -0.02034942f, 
    0.16316125f, -0.06252282f, 0.11106980f, 0.04461629f, -0.08094743f, -0.06164581f, -0.08786586f, 0.01089589f, 
    0.10968916f, -0.12006190f, -0.18121916f, -0.11805706f, -0.11882455f, 0.16439916f, 0.06181676f, 0.06667077f, 
    -0.02123274f, -0.02175011f, 0.09117307f, -0.18170051f, 0.02606293f, 0.09291202f, 0.08803175f, -0.07412111f, 
    -0.09468383f, -0.15155125f, -0.01113840f, 0.06506748f, 0.10968842f, 0.12583625f, -0.04695726f, 0.07471716f, 
    0.02400580f, 0.07132586f, 0.04916590f, 0.08639644f, 0.16236070f, 0.09265275f, 0.09268197f, 0.02506054f, 
    0.10959118f, 0.00522003f, 0.03153288f, 0.00203597f, 0.08090529f, 0.13069394f, -0.02607578f, 0.05913641f, 
    0.09347864f, 0.06763624f, -0.17351884f, 0.10828186f, -0.12066217f, -0.09190178f, 0.07522543f, 0.15427315f, 
    0.05698628f, 0.00499476f, 0.25616780f, 0.10238931f, -0.00413486f, 0.05680765f, -0.07800975f, -0.04012532f, 
    0.09967885f, 0.09931190f, -0.08798890f, -0.00234693f, 0.10202899f, 0.11135326f, 0.08006911f, -0.04959139f, 
    0.12938581f, 0.05504569f, 0.01613775f, -0.00360648f, 0.05167710f, 0.01018938f, -0.03563304f, 0.12006716f, 
    0.08071227f, 0.04048736f, -0.10396699f, -0.00165522f, -0.06940066f, -0.03558557f, 0.05141965f, -0.05257068f, 
    -0.12647742f, -0.03274499f, -0.06060411f, -0.03867282f, -0.13111743f, -0.10970240f, 0.07181136f, 0.07653692f, 
    0.05052673f, -0.07129755f, -0.06090469f, -0.01788193f, -0.08453147f, -0.04483259f, -0.04935297f, 0.02220009f, 
    -0.03697016f, -0.10037731f, 0.04558823f, 0.03402944f, -0.03277553f, 0.00326102f, 0.23063919f, 0.20823137f, 
    0.01849455f, 0.04379532f, -0.04789494f, -0.01530063f, -0.03581123f, 0.04211955f, -0.00241011f, -0.16647393f, 
    0.12068672f, 0.00260849f, -0.03659249f, 0.02908459f, 0.01304431f, -0.10761303f, -0.04891810f, -0.19812432f, 
    -0.04782712f, 0.02762472f, 0.01040714f, -0.14247032f, -0.08356068f, -0.08859540f, -0.04352152f, -0.02024709f, 
    -0.01384026f, -0.26069793f, -0.20175387f, -0.00018747f, -0.03226240f, -0.00774975f, 0.03215565f, 0.03284216f, 
    -0.04786189f, 0.18180528f, 0.13786550f, 0.16745301f, 0.04574879f, 0.06544046f, 0.04969140f, -0.06376485f, 
    0.01160965f, 0.00992949f, -0.16202687f, -0.04782495f, -0.01542474f, -0.07510421f, -0.07592810f, 0.00635238f, 
    0.06622594f, -0.05584182f, 0.08883426f, -0.26140442f, -0.14266102f, -0.11601506f, 0.12694961f, 0.03989051f, 
    0.00263981f, -0.03037523f, -0.18219632f, 0.03983814f, -0.12490252f, 0.03960530f, 0.05683046f, -0.01946993f, 
    0.07277003f, 0.02064152f, 0.06387318f, 0.03068988f, -0.18043655f, 0.06463036f, 0.11376372f, -0.01933610f, 
    0.03442837f, 0.03840502f, 0.12280718f, 0.11985799f, -0.04389970f, 0.07984477f, 0.01838211f, -0.05158078f, 
    -0.02523543f, 0.07170410f, -0.00543378f, 0.04121376f, -0.01557810f, -0.03064319f, -0.08131067f, -0.05118957f, 
    -0.07383977f, -0.25456303f, 0.02939664f, 0.07659519f, -0.03089218f, -0.01416015f, 0.06105309f, 0.03996752f, 
    0.02333432f, -0.19255562f, 0.16307545f, -0.03205248f, 0.02207546f, -0.04707037f, 0.03811132f, 0.01029910f, 
    0.03458032f, -0.07001861f, -0.09707262f, -0.00393969f, -0.06424335f, -0.00375746f, 0.04014118f, -0.05719314f, 
    0.07011480f, 0.13654394f, 0.00960831f, -0.03023361f, 0.11497036f, -0.07110361f, 0.12597942f, 0.03503272f, 
    0.04487774f, -0.02985316f, 0.01704282f, -0.08359955f, -0.01828445f, -0.13418756f, 0.08147928f, -0.04082684f, 
    -0.08046946f, -0.03568219f, -0.09997078f, 0.05000918f, -0.08312547f, -0.08363132f, -0.17271681f, 0.08824179f, 
    -0.00353798f, -0.01996349f, 0.08615549f, -0.09831814f, 0.00784245f, 0.00986689f, 0.06709658f, -0.11862939f, 
    0.03639282f, -0.05506374f, 0.04173004f, -0.09398972f, 0.10720136f, -0.07701617f, -0.07055788f, 0.07748862f, 
    0.02842789f, 0.00951469f, 0.01127200f, -0.02042624f, 0.03530524f, -0.03982043f, 0.15171957f, 0.04170836f, 
    0.17509924f, 0.13499734f, 0.13983750f, 0.04158851f, 0.09333556f, -0.04416062f, 0.04060143f, 0.01580326f, 
    0.16525935f, 0.16224055f, 0.15770017f, -0.02485659f, -0.01250711f, 0.05431567f, 0.05359703f, 0.00190005f, 
    0.09569962f, -0.15825033f, -0.07768679f, -0.20182255f, 0.03804902f, 0.05959614f, 0.05947174f, 0.00082230f, 
    0.01007832f, 0.00015735f, -0.11611895f, -0.05434893f, 0.00524351f, -0.01449449f, 0.06912827f, -0.06750692f, 
    0.09657697f, -0.09743918f, 0.08823488f, -0.02309165f, -0.28994435f, -0.21156050f, 0.05363002f, 0.07287865f, 
    0.03576406f, -0.02009902f, -0.03779730f, -0.00795719f, -0.00555061f, -0.09517152f, 0.09487907f, -0.04814257f, 
    0.02231035f, 0.01699000f, 0.02835590f, -0.11749650f, 0.07154788f, 0.11068900f, 0.05692173f, 0.12468275f, 
    0.07769001f, 0.14646268f, 0.02953224f, -0.01677741f, 0.06361937f, 0.01991039f, -0.24551305f, -0.33353561f, 
    -0.16819781f, 0.16535327f, 0.07098299f, -0.05209177f, 0.08981670f, -0.07101531f, -0.12904368f, -0.09226165f, 
    0.04333531f, 0.00487947f, -0.14224325f, 0.05606227f, 0.04295406f, -0.04048817f, -0.01585853f, 0.04762146f, 
    -0.14536801f, -0.02515391f, -0.13714595f, -0.06099049f, -0.03504201f, -0.01615871f, 0.04155292f, -0.04882504f, 
    0.07661905f, -0.06335474f, 0.10105660f, 0.19157189f, 0.01515468f, 0.07077549f, 0.01348259f, 0.00853355f, 
    -0.01753990f, 0.08935372f, -0.22619241f, -0.05852583f, 0.04608435f, -0.01694578f, -0.09864181f, 0.03769272f, 
    -0.02881228f, 0.11238162f, -0.05852053f, 0.04142520f, 0.11521746f, 0.17744595f, 0.06487360f, 0.04014318f, 
    0.05821832f, -0.05850914f, -0.00734187f, 0.00107331f, -0.02544837f, 0.02847510f, 0.11512476f, -0.01681205f, 
    -0.13674782f, 0.03186445f, -0.04422352f, 0.02593423f, 0.02731372f, 0.16619372f, -0.22366285f, -0.08118753f, 
    -0.03528454f, -0.06864806f, 0.05643304f, -0.04993658f, 0.06578700f, 0.02853569f, 0.05527829f, 0.16280451f, 
    0.01053713f, -0.09953033f, -0.02331281f, -0.06774952f, -0.11380517f, 0.05333984f, 0.00359044f, 0.07422295f, 
    0.00086693f, 0.00961413f, 0.05298021f, 0.04253543f, 0.07739466f, 0.06114308f, 0.05810489f, -0.03557661f, 
    0.04297428f, 0.09913696f, 0.15236840f, 0.03294268f, 0.05199319f, -0.03660156f, -0.01389058f, -0.03385216f, 
    0.11964101f, -0.04880105f, -0.01075803f, -0.01185434f, 0.05980511f, -0.08200542f, 0.02642693f, 0.00068444f, 
    0.01614902f, -0.02852354f, 0.15958910f, -0.01843370f, -0.01055050f, 0.04235207f, 0.02556782f, 0.05104911f, 
    0.04107008f, 0.00841318f, -0.02088519f, 0.17086546f, -0.09300445f, 0.01091986f, -0.04651456f, -0.00444038f, 
    -0.09985754f, -0.01777860f, 0.00441640f, -0.10516175f, -0.09346452f, -0.06326807f, 0.10157030f, 0.11507493f, 
    -0.07562247f, -0.00321024f, -0.03066160f, 0.08533953f, -0.04306665f, -0.03057971f, -0.04678421f, -0.15141085f, 
    -0.09406310f, -0.00066340f, -0.12823296f, 0.06121860f, 0.00139262f, -0.02086752f, -0.01069607f, 0.03366103f, 
    0.10713327f, -0.00476226f, 0.06992558f, 0.01101848f, -0.03536496f, -0.02410650f, -0.01983542f, 0.06207982f, 
    -0.01875004f, 0.05190594f, 0.00735353f, -0.01956338f, 0.04041545f, 0.03796216f, 0.03402099f, 0.06414519f, 
    -0.10645064f, 0.01327802f, -0.03968230f, -0.03852560f, -0.06347822f, -0.01210337f, 0.08005843f, -0.05395602f, 
    0.07425974f, 0.06149225f, 0.02213424f, -0.01651195f, -0.08936587f, -0.05531700f, -0.03684332f, -0.01006920f, 
    0.05463213f, 0.05979082f, 0.34099367f, 0.01643972f, -0.15370908f, 0.06099710f, -0.06305008f, 0.08263822f, 
    0.07468762f, 0.09003741f, -0.03236980f, 0.02006071f, 0.14823279f, 0.09069832f, 0.10814697f, -0.01651985f, 
    0.11190597f, 0.03008620f, 0.03527323f, -0.00436929f, 0.11845600f, -0.04219290f, 0.09613553f, 0.01195802f, 
    0.06859163f, 0.08121745f, -0.01830721f, -0.02535779f, 0.02748509f, 0.09045269f, 0.07770125f, 0.30551836f, 
    0.10698189f, -0.03073212f, 0.08324535f, -0.04374009f, -0.05664964f, -0.02757245f, 0.00841134f, -0.14501533f, 
    0.10811231f, -0.03866052f, 0.03073074f, -0.03693337f, 0.02349551f, 0.05576767f, 0.02952225f, 0.10529608f, 
    0.00365320f, -0.12610140f, 0.00993169f, 0.03327554f, 0.06482705f, 0.15160567f, 0.03548737f, -0.09887403f, 
    -0.06742465f, 0.10476630f, -0.23946476f, 0.01520993f, 0.12839819f, -0.03339531f, -0.12292670f, -0.07997081f, 
    -0.07714434f, 0.22286965f, 0.00503125f, 0.28816542f, 0.10861858f, 0.01257036f, -0.01560253f, 0.03264077f, 
    -0.00288449f, 0.07734881f, 0.18017966f, 0.17290156f, 0.09482772f, 0.07724760f, 0.05160201f, -0.02757004f, 
    -0.05459661f, 0.14829700f, -0.06446398f, 0.15141612f, 0.14791578f, 0.07486608f, 0.02658907f, -0.00531880f, 
    0.00507840f, 0.06276344f, 0.01472891f, 0.01045972f, 0.01597030f, -0.06513420f, -0.11502125f, -0.04691667f, 
    0.02700509f, 0.07981084f, -0.07195944f, -0.00870089f, 0.00025217f, 0.22577786f, -0.12543757f, -0.12962328f, 
    -0.02758222f, -0.04072318f, 0.00398792f, -0.01442824f, -0.06323603f, 0.04427479f, 0.06196140f, 0.17339645f, 
    -0.11893049f, -0.01646248f, -0.01194664f, -0.02002097f, 0.04409958f, 0.10071582f, -0.00997532f, 0.12003129f, 
    0.04324889f, 0.07494570f, -0.18033968f, 0.09174439f, 0.00303527f, -0.00968152f, 0.13832186f, -0.03518181f, 
    -0.03089687f, -0.12209859f, -0.00188298f, -0.03329895f, -0.11465315f, -0.01581466f, -0.12355676f, -0.02654307f, 
    0.00811596f, 0.11480583f, 0.08259706f, -0.04657718f, 0.04466370f, -0.06496029f, 0.04460545f, 0.03122808f, 
    -0.01192343f, 0.07939851f, -0.01699583f, -0.16077082f, -0.08611235f, -0.02325061f, 0.00158819f, 0.17245051f, 
    0.10305012f, -0.09513687f, 0.03070450f, 0.02262193f, 0.11366442f, 0.30903652f, 0.08662786f, -0.11090042f, 
    0.01781165f, 0.06893156f, -0.05400892f, -0.07652283f, 0.00860669f, -0.04730349f, 0.01878009f, 0.08419839f, 
    0.02886749f, -0.01748463f, -0.11772408f, -0.01140061f, -0.16344574f, -0.11475769f, -0.20147116f, 0.08005580f, 
    0.05343398f, 0.03750376f, -0.07669730f, -0.01823149f, 0.03302296f, 0.09114557f, -0.17338920f, 0.06792843f, 
    0.01787206f, -0.08931413f, 0.10560004f, -0.00114438f, -0.08518314f, 0.05070397f, -0.01270432f, -0.04602150f, 
    -0.04392929f, 0.02625348f, 0.09675659f, -0.06362293f, -0.06611101f, 0.05471961f, 0.05710186f, -0.02599801f, 
    0.20615971f, 0.21433492f, 0.15644889f, 0.01621689f, 0.09403475f, -0.01598130f, 0.05313286f, 0.05738711f, 
    0.03544803f, -0.33221591f, -0.08608062f, -0.05275145f, -0.00190213f, -0.03994770f, 0.02017282f, -0.01482842f, 
    0.13315573f, 0.02074872f, 0.08619475f, 0.07769962f, 0.02716472f, -0.05945927f, -0.01208475f, -0.03915745f, 
    0.01708929f, 0.07004432f, 0.04820453f, 0.19187514f, -0.18855901f, 0.09962684f, -0.04698942f, -0.13129672f, 
    0.06726554f, -0.00759654f, -0.02198206f, 0.12550169f, 0.04002737f, 0.02017234f, 0.10288141f, -0.12263384f, 
    -0.04186625f, 0.05581927f, -0.14190668f, 0.08035761f, -0.17640622f, 0.00200618f, 0.03931142f, -0.04594908f, 
    -0.04093000f, -0.13300391f, 0.02752195f, -0.06649618f, 0.04034210f, -0.07466753f, 0.06887049f, 0.05255187f, 
    0.14643528f, -0.00919584f, 0.07673965f, -0.04860918f, 0.01100482f, 0.04612350f, -0.00445374f, 0.09908442f, 
    0.10063505f, 0.02065298f, 0.06338299f, 0.02419452f, 0.02516508f, -0.13968031f, 0.00761025f, -0.06537655f, 
    -0.31743121f, -0.01154011f, 0.08920850f, 0.03256236f, 0.00059935f, -0.14785235f, -0.01921392f, -0.07668923f, 
    -0.06399732f, -0.05933829f, -0.02583602f, 0.12455047f, -0.12719670f, 0.01751583f, 0.11518893f, -0.01406851f, 
    0.01877462f, 0.01133944f, -0.17864305f, -0.08917654f, 0.02248892f, 0.07779278f, -0.08249893f, -0.01602388f, 
    0.09246102f, 0.13341925f, 0.03121332f, -0.07893504f, -0.03099555f, -0.03668395f, 0.04620846f, 0.11939523f, 
    -0.05589465f, 0.01795881f, 0.01757992f, 0.10593026f, 0.17626972f, -0.00451602f, 0.01918276f, 0.09879790f, 
    0.00626615f, 0.04110215f, -0.02999530f, 0.11466807f, -0.02203392f, 0.22397737f, 0.08078657f, 0.24435847f, 
    0.05897244f, 0.05079157f, 0.13318224f, -0.09996042f, 0.04662938f, 0.00492170f, 0.05521896f, -0.25590685f, 
    -0.03617045f, -0.12783028f, -0.02402067f, 0.12453087f, -0.10255444f, -0.00060486f, -0.08825784f, -0.08060028f, 
    0.02551334f, 0.11673594f, -0.05676953f, 0.00806762f, 0.00441142f, 0.04639682f, 0.07963611f, 0.06356739f, 
    -0.07889016f, -0.08633126f, -0.02539198f, -0.09636991f, -0.12085855f, -0.06440502f, -0.12276312f, 0.06063199f, 
    0.16311046f, 0.18996952f, 0.06269468f, 0.18432434f, 0.09632988f, 0.11189359f, 0.09533686f, 0.01774010f, 
    0.18686353f, -0.10556079f, 0.06487991f, 0.02936176f, 0.06433053f, 0.01151073f, -0.00699247f, 0.14740698f, 
    -0.03408648f, -0.03018342f, -0.16257721f, 0.27441913f, 0.13975573f, 0.05923756f, 0.15000646f, 0.05602951f, 
    0.02029028f, 0.08703444f, 0.04620584f, -0.01753566f, -0.17824151f, -0.16766837f, -0.04123412f, 0.07530265f, 
    -0.04325032f, -0.02069910f, -0.00724789f, 0.02564213f, 0.08360801f, -0.05861503f, 0.03534487f, -0.13548644f, 
    -0.03017746f, -0.07006683f, -0.02446011f, 0.01111011f, 0.07158934f, -0.04766918f, -0.05038779f, -0.06090960f, 
    0.06058892f, -0.04454900f, 0.07873642f, 0.04277318f, 0.18432885f, 0.12245058f, -0.10241297f, 0.08207971f, 
    0.06496197f, 0.06085121f, -0.08265677f, -0.00456145f, -0.12114210f, -0.03428718f, -0.04873047f, 0.05534552f, 
    -0.00604934f, -0.02950349f, 0.02092474f, 0.01113921f, -0.01500046f, -0.05304065f, 0.01884028f, -0.03850178f, 
    -0.01824142f, -0.03528804f, 0.02701058f, -0.04923177f, 0.00637189f, -0.01257385f, -0.05381903f, 0.02063838f, 
    -0.01770338f, -0.03973972f, 0.04867563f, -0.01371704f, 0.03830864f, -0.00361831f, -0.01543170f, 0.00258475f, 
    0.03754300f, -0.02652089f, -0.04060364f, -0.00471049f, -0.00239761f, -0.02183448f, 0.00194803f, -0.03311652f, 
    0.00270062f, 0.00467534f, -0.00889003f, 0.04144049f, -0.04262905f, -0.01809676f, 0.00727962f, 0.00907835f, 
    0.02570757f, -0.02544246f, -0.00632071f, -0.03093284f, -0.04189888f, 0.01440974f, -0.03275036f, 0.01909988f, 
    -0.00107766f, 0.00189087f, -0.03270538f, 0.04153371f, 0.03565247f, -0.05630052f, 0.05293851f, 0.05859783f, 
    -0.05073015f, 0.04871287f, -0.00951504f, 0.00177919f, -0.00325709f, 0.05866671f, -0.01564020f, -0.05671654f, 
    -0.03414303f, 0.03388264f, -0.03109133f, 0.04355330f, -0.05020318f, -0.05563312f, 0.04888517f, -0.04789696f, 
    0.00486257f, -0.01357684f, 0.05333703f, -0.01012465f, 0.05739457f, 0.01304629f, -0.01046212f, -0.04136693f, 
    -0.01111401f, 0.04064601f, -0.01547728f, -0.02588804f, 0.02562617f, -0.01127209f, -0.04287954f, -0.04461541f, 
    -0.04984657f, 0.04582186f, 0.05087195f, -0.03729549f, -0.05443879f, -0.00077937f, -0.00470879f, -0.00262047f, 
    0.02494479f, 0.04657153f, 0.02513271f, 0.01844319f, -0.02206676f, 0.01815171f, 0.01501420f, -0.04751309f, 
    0.03558004f, -0.01900383f, -0.05767552f, 0.00361638f, -0.04636165f, 0.02960230f, 0.05281062f, -0.00474177f, 
    -0.03556214f, -0.03860820f, 0.03736859f, 0.00156089f, 0.02731581f, 0.02504351f, 0.01379368f, 0.02927977f, 
    -0.05064026f, -0.05852807f, -0.02230475f, -0.05252333f, 0.02932615f, 0.03397815f, 0.04327656f, -0.00764271f, 
    0.00695205f, 0.03958552f, 0.00470639f, 0.01392629f, -0.04531424f, -0.02729847f, 0.00201496f, -0.02243815f, 
    -0.05620650f, 0.05193261f, -0.05789340f, -0.02988353f, -0.04061586f, -0.02106712f, -0.03186636f, 0.00742769f, 
    0.00003274f, -0.05058519f, 0.05372461f, -0.05656046f, -0.04112110f, 0.01813921f, -0.00282166f, -0.01136370f, 
    0.02721999f, -0.02004984f, 0.00106513f, -0.02996469f, 0.03061327f, -0.01702419f, -0.04136267f, -0.03643755f, 
    -0.03225910f, 0.05045691f, -0.03597108f, 0.05638550f, 0.04998503f, -0.03504508f, -0.00317294f, -0.05235800f, 
    0.01209167f, 0.03039907f, -0.05483915f, 0.00052636f, -0.04910254f, -0.05820300f, 0.00185181f, -0.03530740f, 
    0.00985029f, -0.04018710f, -0.05865128f, -0.03754505f, 0.04842912f, -0.01806160f, -0.00500898f, 0.03408775f, 
    0.02051917f, -0.04398581f, -0.01958913f, 0.05409509f, -0.03506749f, -0.05841419f, 0.04814100f, -0.04631366f, 
    0.03687759f, 0.05230675f, 0.00850246f, 0.03962024f, -0.05440173f, 0.01279307f, -0.01159575f, 0.03288182f, 
    0.00091105f, -0.01027013f, 0.01676182f, -0.04562237f, 0.03123173f, -0.01953759f, 0.05436566f, -0.01843193f, 
    0.03948275f, 0.03180151f, -0.01114017f, 0.01641419f, -0.02761381f, -0.01450141f, -0.01872979f, 0.02939222f, 
    -0.02172300f, 0.00548135f, 0.02066237f, -0.02582902f, -0.02265891f, -0.03530693f, -0.04288407f, 0.00474460f, 
    -0.01706731f, -0.03915654f, -0.04182529f, 0.01862209f, -0.02271006f, -0.01543806f, 0.05020802f, 0.04898692f, 
    -0.00000698f, -0.03671172f, -0.03192268f, 0.03440093f, 0.00776221f, -0.00638103f, -0.04362849f, 0.04863001f, 
    0.03820287f, -0.02050273f, -0.02126512f, -0.04551547f, 0.01790786f, 0.01567179f, -0.05519678f, 0.04454050f, 
    -0.04557604f, -0.01044756f, 0.05758650f, -0.01578392f, -0.00601825f, -0.02727993f, -0.03432441f, 0.00105933f, 
    0.02564806f, -0.01513754f, -0.05819777f, -0.03549822f, -0.03512019f, 0.01864555f, -0.03423735f, 0.03215575f, 
    -0.00616434f, 0.05208238f, 0.04660814f, 0.02447303f, 0.04075625f, -0.04600668f, -0.05791275f, -0.01438460f, 
    -0.05044767f, -0.03454925f, -0.05352922f, -0.04158799f, -0.04601990f, -0.01623867f, 0.01839648f, 0.05289040f, 
    -0.03063532f, -0.04812624f, -0.05457223f, -0.03532686f, 0.00421833f, 0.04015259f, 0.02911536f, 0.03346803f, 
    0.07870063f, -0.11256394f, 0.07548731f, -0.03291257f, 0.01430270f, 0.07439944f, 0.01336309f, -0.01337620f, 
    0.00365760f, 0.11608049f, 0.02226898f, -0.02402185f, -0.06430880f, -0.04868044f, 0.01271371f, -0.00278522f, 
    -0.03176598f, 0.07496308f, 0.05348787f, -0.07032200f, -0.00770008f, -0.18193245f, 0.12961058f, -0.03525793f, 
    -0.00635381f, 0.03515277f, -0.05919983f, 0.17337039f, 0.12273476f, -0.06604898f, 0.02871883f, -0.05144779f, 
    0.02974176f, -0.00404120f, 0.05460180f, -0.06065933f, 0.10810011f, -0.03308050f, 0.03098379f, 0.05055229f, 
    0.01549636f, -0.01149471f, -0.08333404f, -0.02585483f, -0.01730726f, -0.39620316f, -0.06087963f, -0.01344793f, 
    0.16350384f, 0.18608198f, 0.06918314f, 0.02804590f, -0.12700605f, 0.05801894f, 0.17351086f, -0.13820878f, 
    -0.05446439f, -0.06330153f, 0.06759989f, -0.01698731f, 0.08610775f, -0.07610814f, 0.06364582f, 0.03061599f, 
    0.02969327f, -0.06511775f, -0.01662137f, -0.01922473f, -0.05439229f, 0.02343187f, 0.07181819f, 0.00375676f, 
    0.22523266f, 0.16082387f, -0.02128972f, -0.03592880f, 0.01906515f, -0.05034128f, 0.00847053f, 0.06476952f, 
    0.06292894f, -0.19770744f, -0.29298025f, -0.02639541f, -0.00554542f, 0.02293235f, 0.02590799f, -0.04615570f, 
    -0.08545276f, 0.03335552f, 0.08741590f, -0.02958918f, 0.06019635f, -0.03950465f, -0.06320446f, 0.01521677f, 
    0.06049846f, 0.09519954f, -0.01466543f, -0.15498626f, 0.05285777f, -0.06465719f, -0.06431152f, -0.16213219f, 
    -0.00965824f, 0.03397085f, 0.03843534f, 0.12396745f, 0.03199758f, 0.01623131f, 0.03418351f, 0.05637724f, 
    0.10131749f, 0.12523262f, -0.01412571f, -0.09977815f, -0.10500445f, 0.08484433f, -0.22681090f, 0.10426717f, 
    -0.09479816f, 0.02564407f, 0.07906324f, 0.06203341f, -0.01407993f, 0.05458813f, 0.03894244f, 0.14522611f, 
    0.00945582f, 0.06310490f, -0.06421378f, -0.01619338f, 0.02749499f, 0.05461864f, 0.02589728f, -0.06404818f, 
    0.17945601f, -0.10871845f, -0.01967487f, -0.11300731f, 0.07896550f, -0.00313071f, -0.06362484f, -0.09338296f, 
    -0.13759199f, -0.08590810f, -0.18106571f, -0.08723590f, -0.01009268f, 0.05494425f, -0.08573242f, -0.03892901f, 
    0.00334813f, 0.16433288f, -0.02772737f, -0.02275919f, 0.02768509f, 0.08151586f, -0.00859915f, 0.08983577f, 
    -0.00500623f, -0.09565444f, -0.13247965f, -0.24860205f, -0.01586465f, 0.04727091f, -0.00439887f, -0.05009898f, 
    -0.01307525f, -0.01644078f, 0.05899236f, -0.08489906f, -0.12242860f, 0.01089878f, 0.05678210f, 0.01746611f, 
    -0.00907931f, -0.02552270f, 0.03838928f, 0.01480439f, 0.00714288f, 0.12517752f, 0.06814317f, -0.04011478f, 
    -0.00745805f, -0.00512936f, 0.01130637f, 0.04446564f, 0.08240252f, 0.10869540f, 0.12130245f, 0.09562682f, 
    0.03776979f, -0.00451045f, -0.01583845f, 0.06417491f, -0.00057679f, -0.00404234f, 0.00078826f, -0.03364453f, 
    0.05495723f, -0.13369764f, 0.03188306f, 0.07788184f, 0.01200048f, -0.06507252f, 0.05100744f, -0.06552805f, 
    -0.06921728f, 0.07469203f, 0.01026215f, -0.03919102f, 0.00033916f, -0.04631198f, 0.13098378f, 0.03429176f, 
    -0.03872064f, -0.23509796f, -0.04797039f, 0.03765350f, -0.02291016f, 0.01493444f, 0.02756642f, -0.01079989f, 
    -0.04799839f, 0.00586442f, 0.15961017f, 0.06158619f, 0.04582174f, -0.00461469f, -0.01766193f, 0.05908900f, 
    0.10854988f, 0.03078694f, 0.34557587f, -0.21769126f, 0.05489786f, -0.22430471f, 0.13939607f, -0.07009642f, 
    0.09811421f, 0.08499225f, 0.09020657f, 0.33981198f, 0.10934222f, -0.15405269f, -0.05133927f, 0.11901330f, 
    0.02764794f, 0.05433654f, 0.07208464f, 0.01941942f, -0.14096448f, 0.00364998f, 0.19612134f, 0.00863876f, 
    0.00146426f, -0.05378877f, 0.04751926f, 0.07323395f, -0.01344107f, -0.12832552f, -0.14368896f, -0.05508185f, 
    0.02012627f, 0.01685863f, 0.10694297f, -0.13606335f, -0.00433391f, -0.01820376f, 0.18459037f, 0.06623799f, 
    -0.19466780f, -0.04523949f, 0.04928547f, 0.07008011f, 0.11830198f, 0.16229846f, 0.04751194f, -0.14140336f, 
    0.05254395f, 0.14120601f, -0.03122359f, 0.04961161f, -0.06029384f, -0.01938628f, -0.03214556f, 0.01032594f, 
    0.29942229f, 0.12583871f, 0.07879233f, 0.19726774f, 0.03324769f, 0.18882869f, -0.02052473f, 0.07423720f, 
    0.02309358f, 0.04560127f, 0.17386562f, -0.09710209f, 0.09182893f, 0.00659434f, 0.07024266f, -0.05123693f, 
    -0.00476498f, 0.00681409f, 0.22950879f, 0.22052993f, -0.07589073f, 0.00932684f, 0.06945015f, -0.19096896f, 
    -0.06589399f, 0.00696304f, 0.01865743f, 0.08449262f, -0.03180098f, -0.00692565f, -0.02701075f, -0.02120327f, 
    0.09625611f, -0.06246682f, 0.07655477f, 0.00657860f, 0.13302462f, -0.05322410f, -0.24568298f, 0.03956921f, 
    -0.06024994f, -0.03969428f, 0.01966288f, 0.04571608f, 0.03376111f, -0.21681255f, -0.12262189f, -0.01048174f, 
    0.02517859f, 0.09024420f, -0.00196224f, -0.04916258f, -0.02254934f, -0.12927875f, 0.05910407f, -0.06766494f, 
    0.11477172f, 0.05629935f, 0.03289714f, -0.11203352f, 0.03181453f, 0.07709406f, 0.00991130f, -0.14919613f, 
    0.03306003f, 0.02718373f, -0.01181134f, -0.05196296f, -0.06312669f, -0.20147628f, 0.05652966f, -0.00218192f, 
    0.07150776f, 0.07621256f, 0.00599085f, -0.04246813f, 0.00354289f, 0.07760409f, 0.00282922f, 0.03240250f, 
    0.06761038f, -0.25831947f, -0.19443007f, 0.00882098f, 0.00944341f, 0.10536763f, -0.10478042f, -0.05732561f, 
    -0.06623612f, -0.04862872f, 0.10510879f, 0.06295178f, 0.16687785f, 0.03535397f, -0.06144889f, 0.02052184f, 
    0.03362459f, 0.04285209f, -0.04807773f, 0.08588169f, 0.14386430f, 0.10687201f, 0.03883106f, -0.07990474f, 
    -0.03900967f, -0.04080343f, 0.16363513f, -0.05655180f, -0.21073371f, -0.12189896f, -0.00349831f, -0.07011279f, 
    0.09683289f, 0.02772691f, -0.03499220f, 0.08181140f, -0.08514767f, 0.19778503f, 0.09567125f, 0.08985382f, 
    0.13659635f, 0.01578243f, 0.07715807f, 0.01099800f, 0.09463011f, -0.05586965f, 0.00544418f, 0.06258681f, 
    0.00675302f, -0.01648749f, -0.02482998f, -0.00337909f, -0.00274903f, 0.03095489f, 0.12616539f, 0.01008167f, 
    -0.04912664f, 0.03651599f, 0.00179620f, 0.06424568f, 0.01727153f, 0.11033340f, -0.04254027f, 0.05535902f, 
    -0.00784553f, -0.08115084f, 0.07115325f, 0.04920728f, 0.03756528f, -0.11247881f, -0.01294318f, 0.03564414f, 
    0.16660307f, 0.09273984f, 0.14052726f, 0.18121488f, 0.13636789f, 0.05686781f, 0.04554259f, -0.05275378f, 
    0.01062773f, 0.00476064f, -0.53306979f, -0.29736295f, -0.15460466f, -0.11013748f, 0.06030763f, -0.09969696f, 
    0.04280878f, -0.04760798f, -0.05482855f, -0.06633326f, 0.02051077f, -0.22819364f, -0.03050970f, -0.04264544f, 
    -0.06592773f, 0.03333871f, -0.11536350f, -0.10734230f, 0.15884793f, 0.03308849f, 0.08148034f, -0.02320555f, 
    -0.04418499f, -0.07590148f, 0.03308429f, 0.00407172f, -0.05313683f, -0.07743842f, -0.15893227f, -0.04188430f, 
    -0.14154096f, -0.05390499f, -0.02965930f, 0.01048523f, 0.06307855f, 0.01958337f, 0.23790091f, 0.14911924f, 
    0.14632089f, 0.18166648f, 0.03207861f, 0.00323446f, -0.03246491f, 0.03476549f, 0.01064236f, -0.25493354f, 
    -0.33280644f, -0.10286821f, 0.01804329f, -0.01348658f, -0.06714188f, -0.01909630f, 0.03874560f, -0.06863144f, 
    -0.20093912f, -0.28348628f, 0.08297931f, 0.07165077f, 0.07401083f, -0.00994095f, 0.05079668f, 0.08040262f, 
    -0.02909426f, -0.07755028f, -0.12437458f, -0.02245099f, -0.08997252f, 0.03694380f, 0.05630550f, -0.04283840f, 
    0.02898439f, 0.01214842f, 0.10877841f, -0.22157702f, -0.29053855f, -0.04857845f, -0.03608422f, -0.01054328f, 
    -0.07862928f, 0.00075913f, 0.07475849f, 0.20443732f, 0.05966020f, 0.00418244f, -0.15360321f, 0.04383277f, 
    -0.02143121f, -0.10155561f, 0.05565689f, -0.12034843f, -0.06341600f, 0.04472537f, -0.15878503f, -0.00944477f, 
    0.01145303f, -0.00129322f, -0.01099398f, 0.05601999f, 0.15131859f, -0.31742710f, -0.20385738f, -0.02433341f, 
    0.09688226f, 0.03501033f, 0.07971452f, -0.00077498f, 0.04245943f, 0.06269345f, 0.10690609f, 0.19830830f, 
    0.01611414f, 0.05077729f, 0.01956449f, -0.04129856f, 0.00169109f, 0.09058052f, 0.07415031f, -0.23505338f, 
    -0.09822702f, 0.13389362f, 0.09343643f, 0.05483690f, -0.05388208f, 0.02811308f, -0.02658974f, -0.05312579f, 
    -0.02633807f, -0.01285541f, -0.01621942f, 0.00557196f, 0.00001368f, -0.02563239f, 0.00136121f, -0.06521960f, 
    0.00324509f, 0.01118628f, -0.02188867f, -0.06449182f, 0.01631835f, -0.03180062f, 0.04467280f, -0.06660488f, 
    0.00229199f, -0.05264404f, -0.05292723f, 0.02943002f, -0.03599956f, -0.04524092f, 0.03304700f, 0.04593289f, 
    0.00682326f, 0.04521003f, 0.04645233f, -0.01470906f, 0.03214770f, 0.04161229f, 0.04988386f, 0.01445691f, 
    0.01631267f, -0.01304178f, 0.04651938f, -0.02670719f, -0.05619896f, 0.03923373f, -0.06261058f, 0.02938692f, 
    -0.06210189f, -0.03297282f, -0.00146326f, -0.03393823f, -0.03551208f, 0.03762300f, -0.03226783f, 0.04905036f, 
    -0.01369529f, -0.01543629f, 0.00886672f, -0.03284182f, 0.04022710f, -0.02129527f, 0.02518599f, -0.06258830f, 
    0.00502538f, -0.05358379f, 0.00870330f, 0.04830974f, -0.03648473f, -0.06699514f, -0.06388214f, 0.00205636f, 
    -0.04536575f, -0.01925429f, -0.02940610f, -0.02777870f, 0.03340175f, 0.01634119f, -0.02090324f, -0.04557921f, 
    0.03993329f, 0.00905775f, 0.01937428f, -0.01924541f, -0.05831828f, 0.03387974f, -0.05706115f, 0.01848583f, 
    -0.03249000f, -0.03993788f, -0.06712830f, 0.01074656f, -0.00430641f, 0.01363079f, 0.00101851f, 0.05270791f, 
    -0.00796701f, 0.04404845f, 0.03694540f, -0.00852847f, -0.04998257f, 0.03188559f, 0.02012022f, -0.05778126f, 
    -0.01247073f, 0.04659700f, -0.03718197f, -0.03278171f, 0.03457035f, 0.03054982f, -0.04491328f, 0.03810473f, 
    -0.03253463f, -0.02314687f, -0.01051433f, 0.02984736f, -0.05162667f, -0.02371195f, -0.01894078f, -0.01717916f, 
    -0.04595316f, 0.00473022f, 0.00150759f, -0.03394917f, 0.03358039f, -0.03026469f, -0.03800770f, -0.04446094f, 
    -0.00989796f, -0.00442381f, 0.00683762f, -0.02885895f, -0.02972920f, -0.04819937f, -0.02069131f, 0.03152670f, 
    0.03437237f, -0.00946515f, -0.06410500f, 0.04839323f, -0.03098491f, -0.04264513f, -0.04079020f, 0.01309745f, 
    0.00876690f, -0.05731080f, -0.04690614f, 0.03608248f, -0.03818731f, -0.01551299f, 0.02570087f, 0.01571714f, 
    0.00199705f, -0.01317808f, -0.02549875f, -0.05207070f, -0.03155959f, -0.00208773f, -0.05400179f, 0.01577636f, 
    0.00975265f, 0.04952666f, -0.05588510f, 0.03494726f, -0.02783697f, 0.01958485f, 0.03283882f, 0.01984865f, 
    -0.02458374f, -0.05090214f, -0.03252229f, 0.00183974f, -0.04290609f, 0.00222840f, 0.03980113f, 0.04247420f, 
    0.01338151f, -0.04287121f, 0.03265630f, -0.03317552f, -0.05385865f, 0.01990284f, -0.00076377f, 0.02633979f, 
    -0.06029417f, -0.01202629f, 0.02784082f, -0.04049825f, 0.04135627f, -0.04505043f, -0.04189015f, 0.01314794f, 
    0.00007747f, -0.03079069f, -0.00399945f, -0.04348272f, 0.02906425f, -0.02209341f, -0.06216136f, -0.04907165f, 
    -0.00306865f, 0.05128867f, -0.04475420f, 0.04980822f, 0.00150874f, 0.01628685f, 0.01742839f, 0.04338275f, 
    0.02751993f, -0.03611578f, -0.06583856f, 0.01244374f, -0.00607749f, -0.01643063f, 0.04939911f, -0.00314990f, 
    -0.03075585f, -0.03653445f, -0.00502882f, 0.04914913f, 0.03800805f, 0.04654875f, -0.05263045f, -0.03661177f, 
    0.03706302f, 0.04429321f, -0.03261961f, 0.00778021f, -0.01457299f, 0.02619070f, 0.01102071f, -0.00229939f, 
    -0.04879552f, 0.00504266f, 0.01939623f, 0.01811276f, -0.05964876f, 0.00982203f, -0.04653251f, -0.04280639f, 
    -0.05504826f, -0.01831569f, 0.00338509f, -0.04723695f, -0.04996129f, -0.01479302f, 0.04635090f, 0.01028080f, 
    0.00394248f, -0.06225090f, 0.01349060f, -0.01456731f, 0.01553803f, 0.02290516f, 0.02283587f, -0.03512396f, 
    0.01886397f, 0.01100911f, -0.02348290f, -0.01070571f, 0.04905356f, -0.02373624f, 0.02073555f, -0.01738119f, 
    0.01350138f, -0.03766264f, -0.05751836f, 0.00747617f, -0.04969772f, 0.03923695f, 0.02196406f, 0.04238174f, 
    -0.03325495f, -0.03945572f, -0.02582104f, 0.01470614f, 0.01595390f, -0.00688758f, -0.01491688f, -0.01742073f, 
    -0.03923182f, 0.03720922f, 0.01983813f, 0.03131962f, -0.02891225f, -0.03598226f, 0.00854820f, -0.00390840f, 
    0.04193163f, -0.05719186f, -0.03102368f, 0.02753807f, 0.00982227f, 0.02271208f, -0.06703512f, 0.03588049f, 
    -0.01630861f, -0.03066294f, 0.00302482f, -0.02753798f, 0.02619203f, -0.01229867f, 0.05082056f, -0.00662563f, 
    -0.02524840f, -0.01459290f, 0.00555725f, -0.02378092f, -0.06195684f, 0.01837316f, -0.04985381f, -0.05896518f, 
    0.02276367f, 0.02841524f, -0.05066953f, -0.00214182f, 0.02309011f, 0.01002511f, 0.01125918f, -0.01543171f, 
    -0.04557247f, 0.00285129f, 0.04305127f, 0.02855727f, -0.04986281f, 0.01701069f, 0.01120894f, 0.03758647f, 
    -0.01949811f, -0.01440379f, -0.04864456f, -0.02607894f, -0.03367944f, 0.02266942f, -0.01667867f, 0.02154858f, 
    0.00881873f, 0.02038116f, 0.03627897f, -0.03439237f, 0.05318784f, -0.06580371f, -0.02518862f, -0.03847888f, 
    0.02134185f, -0.05562593f, -0.05660494f, -0.06938241f, 0.04083592f, 0.03825155f, 0.03769458f, -0.06036046f, 
    0.03892002f, -0.04845476f, 0.02190500f, 0.01577019f, -0.00685323f, 0.02986290f, 0.02171917f, 0.01039465f, 
    -0.05286850f, 0.01186603f, -0.01773862f, -0.06135026f, 0.03286627f, -0.02105419f, -0.03688238f, 0.03674880f, 
    -0.01703167f, -0.00488522f, -0.02156506f, -0.04254445f, -0.00929582f, -0.03911668f, 0.04183098f, -0.04761457f, 
    0.00610262f, -0.04378069f, -0.01510345f, -0.05965464f, -0.05663183f, 0.04888307f, 0.04145351f, 0.02757570f, 
    -0.02193089f, 0.05149904f, 0.03938996f, 0.00321608f, 0.00639718f, 0.02275665f, 0.00445414f, 0.00212065f, 
    0.01343730f, -0.04236650f, -0.00409757f, 0.01550891f, -0.00948674f, -0.02332922f, -0.01948829f, -0.00688958f, 
    -0.00325600f, -0.02527452f, 0.00041801f, 0.03530502f, 0.00347771f, -0.04030772f, -0.03930851f, -0.02806747f, 
    -0.02341061f, 0.00998172f, 0.00182640f, -0.01476701f, 0.03035518f, -0.05006981f, 0.02637840f, 0.05109298f, 
    0.03412954f, -0.00705599f, -0.01951501f, 0.04049983f, 0.03012449f, 0.03239961f, -0.05189345f, -0.00854123f, 
    0.02209643f, 0.02330524f, 0.04859204f, -0.03142479f, 0.01986775f, -0.04102531f, -0.00266136f, 0.03877689f, 
    -0.02403883f, -0.03268576f, -0.05190771f, 0.03653923f, -0.01220204f, -0.02072885f, -0.01435983f, 0.01322894f, 
    -0.00371816f, -0.03015416f, -0.00155498f, 0.04043649f, -0.06038396f, 0.04406828f, -0.02930363f, 0.02318294f, 
    -0.00324459f, 0.00901323f, -0.06527505f, -0.06582474f, 0.02075342f, 0.04199395f, 0.01369003f, -0.06105169f, 
    -0.04189807f, -0.00472002f, -0.04171528f, -0.01748177f, -0.00304774f, 0.02698355f, -0.00430890f, -0.04022485f, 
    0.02491708f, -0.01806723f, 0.02205389f, -0.02974113f, -0.03636883f, 0.02914646f, -0.05891215f, -0.03739070f, 
    0.00979481f, -0.05760329f, 0.03853134f, -0.00313605f, 0.01786332f, 0.02527243f, 0.00814590f, 0.03261614f, 
    0.00087759f, -0.01855569f, -0.05806905f, -0.00438025f, -0.02481995f, 0.02753768f, -0.06457780f, 0.00753920f, 
    -0.02849923f, 0.01301389f, 0.00142918f, 0.03702196f, -0.04896510f, 0.04040428f, -0.00412209f, -0.02168329f, 
    0.01611751f, -0.05490509f, -0.05231758f, 0.02972249f, -0.02765778f, 0.01151005f, -0.01081943f, -0.01716364f, 
    0.00937926f, -0.00256641f, -0.03833421f, 0.03693287f, -0.04958552f, -0.02383073f, -0.00881473f, 0.00557712f, 
    -0.04700861f, -0.05495189f, 0.00539802f, 0.00608299f, 0.02211482f, -0.05677364f, -0.04762175f, -0.01542546f, 
    -0.02981282f, 0.03568371f, 0.04040280f, -0.05381894f, 0.00477505f, 0.03886731f, -0.05683532f, 0.03808291f, 
    -0.01054939f, 0.03950498f, -0.01252763f, 0.01951657f, 0.01038188f, -0.00482902f, -0.01018848f, -0.03646994f, 
    0.00936023f, 0.05327595f, 0.04236055f, -0.06388248f, -0.00571741f, -0.06334033f, 0.01852445f, 0.03387925f, 
    -0.01890338f, -0.00211253f, -0.00373234f, -0.04661139f, 0.01098806f, 0.00041502f, -0.03634976f, -0.04456876f, 
    -0.05386418f, 0.04716295f, -0.04024108f, -0.02032626f, 0.00951251f, -0.05529344f, 0.02847077f, 0.00165580f, 
    -0.06076310f, 0.03736147f, -0.00650452f, -0.00366403f, -0.04167184f, 0.05281664f, 0.06335769f, -0.00450754f, 
    0.03615260f, 0.01327234f, -0.04331549f, 0.02367417f, 0.00482685f, -0.02825935f, -0.06222469f, 0.01144819f, 
    0.03919620f, -0.03378674f, -0.02767544f, 0.03131288f, -0.03955465f, 0.00258000f, -0.02217677f, 0.02032530f, 
    0.01163549f, 0.03291631f, -0.11155187f, 0.01004659f, 0.10146490f, 0.10058054f, -0.05671069f, -0.04786474f, 
    0.03080667f, 0.05982031f, 0.09302337f, -0.12073462f, 0.00813366f, 0.06205684f, 0.03838352f, 0.05228892f, 
    -0.04114654f, -0.01020107f, -0.08734221f, 0.00543565f, -0.07257087f, -0.05528432f, 0.04074217f, 0.06350244f, 
    -0.03800624f, -0.21235375f, -0.16821507f, -0.00535652f, -0.01343141f, -0.05240832f, -0.07542195f, 0.07899603f, 
    0.17196248f, 0.03850919f, -0.09042778f, -0.09772722f, -0.15592569f, -0.03539551f, 0.04891902f, 0.01376862f, 
    0.02690191f, 0.00580325f, -0.05493740f, -0.10770091f, -0.12872528f, 0.18760274f, 0.16830879f, 0.20664148f, 
    0.10931049f, 0.21924840f, 0.00478159f, -0.10652082f, 0.05066283f, 0.06782706f, -0.10749343f, -0.01148459f, 
    -0.12020523f, 0.10121836f, -0.12239947f, 0.05028912f, 0.01919619f, -0.06335279f, -0.08538854f, -0.28603688f, 
    -0.04064262f, 0.24749793f, -0.09679491f, -0.04570420f, 0.03330580f, 0.00692298f, 0.12752382f, -0.05047353f, 
    -0.14641091f, -0.07593992f, -0.10687825f, -0.04708920f, -0.08693395f, 0.03698555f, 0.02379279f, 0.02225527f, 
    -0.12736656f, 0.18857372f, 0.08569398f, 0.09684286f, 0.12896332f, 0.06710005f, 0.06456421f, -0.05746612f, 
    -0.00736447f, 0.09167062f, -0.06160407f, 0.02215355f, 0.14996466f, 0.03013105f, -0.00262969f, -0.00267749f, 
    0.05106758f, -0.05747484f, 0.15339118f, -0.08703250f, 0.15430942f, 0.05847139f, 0.11431930f, 0.06140345f, 
    0.03455714f, -0.02350201f, -0.19911885f, 0.12727229f, -0.07186334f, 0.02900933f, 0.03663698f, -0.01451467f, 
    0.02975920f, 0.14052379f, -0.17084692f, -0.10253686f, -0.16561477f, 0.06310903f, 0.12032883f, -0.00477472f, 
    -0.09944089f, 0.05183403f, 0.19412291f, 0.03804968f, -0.04936143f, -0.05754223f, 0.13125728f, 0.06639101f, 
    -0.08998445f, 0.05167205f, 0.02845964f, 0.01936083f, 0.05669988f, 0.05928874f, -0.01557536f, -0.08085912f, 
    0.06097930f, -0.15479279f, 0.00772678f, -0.04320749f, 0.04260281f, 0.01173825f, -0.01347202f, -0.03492323f, 
    0.02435380f, -0.03242557f, 0.19920495f, -0.02063407f, -0.05971444f, 0.09736336f, 0.01896102f, 0.00110127f, 
    -0.03811174f, 0.16335613f, 0.05936906f, -0.11461736f, 0.01545042f, 0.00330298f, 0.02312899f, -0.07226846f, 
    -0.15253174f, -0.10108057f, -0.01805218f, -0.10010486f, 0.16551679f, 0.08901514f, 0.02078872f, 0.00223143f, 
    -0.04525923f, 0.04196076f, 0.05479495f, -0.31844363f, -0.12473637f, -0.06226587f, 0.00742820f, 0.02477665f, 
    -0.08013106f, -0.12863478f, 0.07421779f, -0.01236672f, -0.28089365f, 0.00790030f, -0.02470483f, 0.01956096f, 
    0.06038483f, 0.07740273f, 0.10407650f, -0.01267453f, 0.03186840f, 0.05529911f, -0.00067309f, -0.21026158f, 
    -0.09504400f, 0.05208602f, 0.01843307f, -0.12844333f, -0.13008325f, -0.11330048f, 0.05350226f, 0.11096336f, 
    0.04052614f, 0.00069702f, 0.11029778f, 0.06907377f, -0.08075076f, -0.04666606f, -0.07471424f, 0.16991852f, 
    -0.03600753f, 0.17935185f, 0.05020198f, 0.07524889f, -0.07266145f, 0.03479077f, 0.05940716f, 0.15992472f, 
    0.19529459f, 0.07212050f, 0.18985768f, -0.02654696f, 0.13890979f, 0.05154156f, 0.14010686f, -0.09662765f, 
    0.16774254f, -0.03339053f, 0.21493529f, -0.44307333f, 0.03578259f, -0.01263729f, -0.02497808f, -0.01565292f, 
    -0.08022770f, -0.17456113f, -0.29786748f, 0.10918331f, 0.03025733f, -0.07439291f, 0.00085830f, -0.05694791f, 
    -0.05710442f, -0.01995957f, -0.13910259f, -0.11904268f, 0.09698088f, 0.01396398f, -0.05430624f, 0.00780728f, 
    -0.06964038f, 0.07168182f, -0.06096435f, -0.00711032f, 0.05215445f, -0.23253453f, 0.08911530f, 0.06386448f, 
    -0.03403646f, 0.06974968f, 0.16155645f, -0.02399226f, 0.03020656f, 0.23779720f, 0.08269512f, 0.03740580f, 
    -0.00490498f, 0.07425155f, 0.20616172f, 0.03349430f, -0.02879761f, -0.02118300f, -0.09056392f, -0.03590101f, 
    0.00096104f, 0.04340161f, -0.04640890f, -0.12401987f, 0.13886295f, 0.04959600f, -0.06340715f, 0.07226600f, 
    0.15049781f, -0.07811245f, -0.03238686f, 0.13949452f, -0.01802204f, -0.06470918f, -0.07340813f, -0.04122483f, 
    0.17133820f, 0.10695539f, 0.07967053f, 0.03412222f, -0.05442120f, 0.01164718f, 0.05385769f, -0.00680945f, 
    -0.04238780f, 0.01041929f, -0.05697981f, 0.22270177f, -0.17819676f, -0.09817522f, -0.00259469f, -0.03624892f, 
    0.03611539f, 0.00987439f, 0.01089263f, 0.20072894f, 0.09123222f, -0.01407785f, -0.21169776f, -0.05623941f, 
    0.01171414f, -0.21511051f, 0.06302095f, 0.10752095f, -0.01714226f, 0.11289617f, -0.04076388f, 0.04321526f, 
    -0.09947116f, 0.05188887f, 0.02100676f, -0.11378780f, 0.07232224f, -0.08089200f, -0.11902980f, -0.01930762f, 
    -0.12754491f, -0.01912725f, -0.02311226f, -0.10814238f, 0.01457615f, 0.06082079f, 0.12153334f, -0.09332058f, 
    0.05041605f, 0.15677151f, 0.14214464f, -0.03157286f, -0.13162175f, -0.13295721f, -0.00759900f, 0.01608075f, 
    0.02750064f, 0.00024678f, -0.06582672f, -0.07980175f, -0.08487985f, 0.04261913f, -0.04395944f, -0.07379702f, 
    0.00741128f, 0.03639748f, -0.06049646f, 0.00669937f, -0.03342393f, -0.00893807f, 0.03997455f, 0.04441979f, 
    0.09544034f, 0.02200685f, 0.19830984f, -0.08980019f, -0.11595421f, -0.11211368f, 0.04116144f, 0.07862627f, 
    0.09171103f, 0.02360825f, -0.00559224f, 0.05821792f, -0.00519414f, 0.06977307f, 0.07928678f, -0.03845124f, 
    -0.02799343f, -0.02783596f, 0.02535759f, -0.03111042f, 0.01363701f, -0.08417336f, -0.02165219f, -0.08335416f, 
    -0.12697493f, 0.02826624f, 0.01428685f, 0.22929123f, 0.02476248f, -0.07455954f, -0.14486521f, -0.00413093f, 
    -0.01648291f, -0.00762786f, -0.04584593f, 0.12742209f, -0.21106745f, -0.08364839f, -0.01800214f, -0.03917172f, 
    0.05463456f, -0.05173415f, -0.00131109f, -0.05537523f, -0.00048674f, 0.07085808f, 0.08403541f, 0.10666677f, 
    0.03306515f, -0.03783129f, 0.05867990f, 0.10221846f, -0.00722419f, -0.00583648f, 0.10311273f, -0.00481927f, 
    -0.03330648f, -0.06170541f, -0.11220591f, -0.11700130f, -0.00317534f, 0.06309875f, -0.00810159f, 0.20138246f, 
    0.00289933f, 0.15841454f, -0.14930016f, -0.01460740f, -0.08739754f, 0.06630444f, -0.06170309f, -0.07041270f, 
    0.13621663f, 0.08675945f, -0.07027271f, -0.04664397f, -0.08650077f, -0.08034288f, -0.04351761f, -0.11760172f, 
    -0.00772044f, -0.01423586f, -0.01703466f, -0.04103091f, -0.01495630f, 0.09658655f, -0.14599685f, -0.09890148f, 
    -0.02098405f, -0.04121742f, -0.02862136f, -0.10673223f, 0.06521636f, 0.13627192f, -0.00071828f, 0.10786235f, 
    -0.03866576f, -0.01090971f, -0.18642680f, 0.21963100f, 0.13993026f, -0.07250094f, 0.00660905f, 0.04687965f, 
    0.18670163f, -0.06289126f, -0.01619485f, -0.06580387f, 0.12209763f, 0.16758300f, 0.03650070f, -0.15647961f, 
    0.05908050f, -0.05196942f, 0.08350271f, -0.05023757f, 0.01914151f, -0.09742112f, 0.01694618f, 0.09394267f, 
    -0.03357363f, -0.06455895f, -0.00678960f, 0.01215741f, -0.02603917f, -0.03311269f, 0.05650274f, 0.02985412f, 
    0.07692436f, -0.01121796f, -0.01619297f, -0.01410000f, -0.03723457f, 0.05143942f, -0.06597306f, -0.23744327f, 
    -0.00426820f, -0.18511650f, 0.09187037f, 0.07575363f, 0.26469150f, -0.19936474f, 0.00721454f, 0.00387905f, 
    -0.17501898f, 0.11931831f, -0.07506592f, -0.02914598f, 0.08753828f, 0.17265424f, -0.07219657f, -0.03062054f, 
    -0.03972284f, -0.02892415f, -0.06843601f, 0.02369757f, -0.13922727f, 0.05762808f, 0.07290184f, 0.01714517f, 
    -0.04708934f, 0.05171726f, 0.12620477f, -0.06388720f, 0.10797150f, -0.04518293f, -0.07112335f, -0.10453954f, 
    -0.11660375f, -0.08676483f, 0.07132242f, -0.00992837f, 0.07849469f, 0.23291709f, -0.10230754f, -0.11025438f, 
    0.01056686f, -0.10626960f, 0.05419710f, -0.00713688f, 0.10582756f, 0.14301550f, 0.07500782f, -0.10753962f, 
    -0.02955767f, 0.06861514f, -0.01547489f, -0.07599398f, -0.13633993f, -0.03862305f, -0.26819327f, -0.01509053f, 
    -0.01450914f, 0.15668856f, 0.07308344f, 0.00364014f, 0.03688467f, -0.09137024f, 0.00093512f, 0.08284888f, 
    0.23463863f, -0.02989842f, 0.04415270f, -0.01101232f, -0.03224585f, -0.04382030f, 0.00628146f, 0.11637842f, 
    0.10364703f, -0.06869715f, -0.08598448f, 0.00946683f, 0.06048812f, -0.14174807f, -0.11127426f, -0.06951115f, 
    0.10745937f, 0.07181883f, 0.10837194f, 0.04318503f, 0.07073723f, -0.15474786f, 0.03212220f, 0.04790990f, 
    -0.01124175f, 0.13363725f, 0.05705804f, -0.01878892f, 0.00105318f, 0.06092899f, -0.04554383f, -0.07184719f, 
    -0.01848084f, -0.01329691f, -0.07091655f, 0.01287502f, 0.05117812f, 0.04616952f, -0.03482627f, -0.06822968f, 
    -0.10603329f, 0.01478000f, -0.04175782f, 0.14137585f, -0.06162560f, 0.01719627f, 0.11007024f, 0.00512988f, 
    0.03745324f, -0.07952239f, -0.00439479f, 0.09745853f, 0.18670928f, 0.14656839f, -0.08781568f, -0.07339214f, 
    0.04639698f, 0.07733040f, -0.02555010f, 0.02987238f, 0.04825899f, -0.10911615f, 0.33480197f, -0.03279600f, 
    -0.14873940f, -0.09349160f, 0.14548764f, -0.04101501f, -0.00247764f, -0.13028629f, -0.06593591f, 0.05274003f, 
    -0.00267641f, -0.02630632f, 0.07608745f, -0.16202076f, -0.01461673f, 0.05069045f, 0.15863004f, 0.00954446f, 
    0.01527059f, -0.12446906f, -0.05195608f, 0.04111920f, 0.04337703f, 0.03900508f, 0.05387868f, 0.09590744f, 
    0.15098676f, -0.22664770f, 0.03033334f, 0.00276552f, -0.06263881f, -0.02253485f, -0.00424096f, 0.11583765f, 
    -0.03905241f, -0.22059880f, 0.23426379f, 0.13455500f, 0.01555701f, 0.00721506f, 0.02415947f, 0.05857481f, 
    0.00406685f, -0.08796810f, 0.22363944f, -0.14124092f, -0.11432848f, -0.08167139f, -0.01073555f, -0.00904405f, 
    -0.02345939f, 0.02114995f, -0.04438304f, 0.18014739f, -0.06489839f, -0.02909226f, -0.13608205f, 0.00804914f, 
    0.01935409f, 0.10444392f, -0.14156567f, -0.09531692f, 0.14198764f, 0.02933788f, -0.04885350f, 0.10954752f, 
    0.00973371f, -0.12606137f, 0.11643881f, -0.00381867f, 0.13208002f, -0.10164957f, -0.02834067f, 0.13181788f, 
    0.05147845f, 0.06679741f, -0.01640486f, -0.09575132f, -0.02149019f, -0.01580863f, 0.10750543f, 0.09623335f, 
    0.01432731f, -0.00600085f, -0.02911139f, -0.11129782f, -0.11055660f, -0.10172188f, 0.06689461f, 0.18620223f, 
    -0.21616662f, 0.07050899f, -0.06551655f, 0.11636640f, -0.14022826f, 0.06689087f, 0.05455675f, 0.04043015f, 
    0.02425246f, 0.05216479f, -0.10526013f, 0.07374389f, -0.05988359f, -0.03530075f, -0.03319168f, 0.09407651f, 
    0.03341118f, -0.10319776f, -0.00303265f, -0.01587872f, 0.02322565f, 0.07779112f, -0.02470208f, 0.01441479f, 
    -0.01462218f, 0.00237466f, -0.17419985f, 0.21051323f, 0.03895328f, -0.07003446f, -0.10262113f, 0.05963432f, 
    0.04055116f, -0.03128533f, -0.02681805f, 0.19078074f, 0.13793297f, -0.18271478f, -0.01625451f, 0.03704146f, 
    0.14440520f, 0.08107208f, 0.15084411f, -0.11776315f, 0.25130615f, -0.11820823f, -0.14756247f, -0.15406080f, 
    -0.10526793f, 0.05059108f, 0.15450215f, -0.01001293f, 0.04114458f, 0.10253286f, -0.17752199f, 0.11023493f, 
    -0.14649795f, -0.00481289f, -0.06919017f, 0.17138918f, -0.06940804f, 0.08614727f, 0.08235474f, -0.01256203f, 
    0.03550062f, 0.14842394f, -0.03613244f, -0.13446298f, -0.04885652f, 0.01057546f, -0.18028764f, -0.36733419f, 
    0.22679803f, 0.07108821f, -0.07145979f, -0.00632716f, 0.12740697f, 0.09127303f, -0.03398826f, -0.11143003f, 
    -0.12145938f, 0.00240993f, 0.07443017f, -0.00039355f, 0.17506811f, -0.06609350f, -0.09748529f, -0.06339575f, 
    -0.10809179f, -0.01929911f, -0.15122138f, 0.14689529f, -0.01100558f, 0.06121340f, 0.10949323f, 0.01359060f, 
    -0.07346522f, 0.09995770f, 0.03613549f, -0.08195326f, 0.11034436f, 0.01886638f, 0.01920080f, 0.02360289f, 
    -0.03851021f, 0.07948349f, 0.00513469f, -0.10896254f, -0.22618154f, 0.08340880f, -0.10616658f, -0.04092738f, 
    0.01320476f, 0.08628570f, -0.01960407f, 0.10707853f, 0.16426292f, -0.06905601f, 0.00070489f, -0.05536664f, 
    0.04416421f, -0.06658407f, -0.04997765f, -0.02160814f, -0.22068049f, -0.14122836f, -0.00313255f, -0.03175115f, 
    -0.02687863f, 0.09431443f, 0.11724436f, 0.09723430f, -0.05148912f, -0.13141169f, 0.07939309f, -0.07188152f, 
    -0.00121293f, -0.03567170f, -0.12089923f, -0.14830846f, -0.22164570f, -0.02396457f, 0.02023350f, 0.10986758f, 
    0.04738821f, -0.05396276f, -0.08351762f, 0.01719511f, 0.12602590f, 0.11886455f, -0.02800295f, -0.12730663f, 
    0.12388631f, 0.13280685f, 0.01862279f, -0.00353519f, -0.00172396f, -0.04061956f, 0.13398877f, 0.07902595f, 
    0.12379427f, 0.00680241f, -0.08552918f, -0.03427606f, 0.09509438f, 0.13155708f, 0.04991611f, 0.07740982f, 
    -0.03243402f, 0.12027647f, 0.04550408f, -0.01725118f, -0.00988633f, 0.02739362f, 0.08147950f, -0.10722304f, 
    0.01523800f, 0.00391871f, -0.13294397f, -0.01925233f, 0.10824282f, -0.07376540f, -0.01646181f, 0.11248973f, 
    -0.05456412f, -0.06761560f, -0.01782127f, 0.10398550f, -0.04115301f, -0.03734148f, 0.03628087f, 0.01533053f, 
    -0.09147430f, -0.09532743f, -0.17811725f, 0.07114298f, 0.05000234f, 0.09257956f, 0.09494641f, 0.08161976f, 
    -0.11643121f, -0.12093494f, -0.02755806f, -0.02759906f, 0.07080739f, -0.05665546f, 0.05719820f, -0.08955640f, 
    -0.05104025f, -0.04736926f, 0.06195940f, 0.02443447f, 0.17201735f, -0.00789359f, 0.08027831f, 0.06888198f, 
    -0.15336300f, 0.17743735f, -0.11024961f, 0.07444628f, 0.03271059f, -0.00809039f, -0.02901494f, 0.03855780f, 
    -0.09843705f, -0.22046958f, -0.11350666f, 0.08798332f, 0.03506497f, 0.06613369f, -0.02536117f, -0.05752525f, 
    0.01301029f, 0.12817451f, 0.18345778f, 0.11231808f, 0.00218621f, -0.05989128f, 0.06006259f, 0.11484204f, 
    0.02673231f, -0.05114340f, 0.11559953f, -0.04872925f, 0.00425379f, 0.07818802f, -0.01571688f, 0.05569083f, 
    0.01384687f, -0.00397622f, -0.02462092f, -0.18015103f, 0.13608286f, -0.12864423f, 0.11748643f, 0.07361621f, 
    0.15511011f, -0.09861365f, -0.09461909f, -0.10704108f, -0.01168780f, -0.08412185f, -0.24401596f, -0.04489142f, 
    -0.05659324f, 0.07276788f, 0.02400429f, 0.10988198f, -0.00781066f, 0.10361929f, 0.12000345f, 0.03012447f, 
    -0.11730004f, -0.09340231f, -0.14874978f, 0.08892007f, 0.06470750f, 0.15857518f, 0.00847411f, -0.04531424f, 
    -0.06088797f, 0.06397267f, 0.04142774f, 0.00682792f, -0.09294744f, -0.02594289f, -0.02557010f, -0.02475380f, 
    0.07886171f, -0.03762303f, 0.03049508f, -0.05797746f, -0.08957180f, 0.13964890f, 0.00763051f, 0.08403981f, 
    -0.10073568f, 0.05682097f, 0.02670163f, -0.06875794f, -0.03482024f, 0.00666815f, 0.10052167f, 0.02108421f, 
    -0.06571382f, 0.10401411f, -0.01368321f, 0.12013401f, -0.06661764f, 0.08457303f, -0.01932807f, 0.14962016f, 
    0.16281414f, 0.23678716f, -0.03177505f, 0.18917176f, -0.06765750f, 0.00292198f, -0.07570450f, 0.06486081f, 
    0.05574284f, 0.07295703f, -0.04060989f, 0.35866204f, -0.11227246f, -0.02446090f, -0.02696439f, 0.10300168f, 
    0.12174754f, 0.00525644f, 0.00868840f, -0.14879872f, 0.13119432f, -0.13391517f, 0.11901031f, 0.12870416f, 
    0.11165293f, 0.02245370f, -0.07818948f, -0.13605715f, -0.09281632f, -0.09412069f, -0.00596942f, -0.19752602f, 
    0.03312923f, -0.05447762f, -0.03112134f, -0.00022068f, -0.05849401f, 0.06550319f, 0.17606217f, -0.03644197f, 
    0.16281988f, 0.09463866f, 0.07707396f, -0.08001595f, 0.05340742f, 0.02169986f, 0.05240155f, 0.06015017f, 
    0.11334673f, 0.29576626f, 0.13721216f, 0.12765692f, 0.18964812f, 0.16977118f, -0.13000180f, -0.10213561f, 
    0.00097259f, 0.17578317f, -0.03476153f, -0.01109244f, 0.14898448f, 0.00549839f, -0.04948645f, -0.10762402f, 
    -0.02502116f, -0.12307319f, -0.08779960f, -0.21152762f, 0.15087184f, 0.01678264f, 0.07000992f, 0.02162671f, 
    0.01974313f, 0.12324505f, -0.02481216f, -0.04047550f, 0.00724524f, -0.01745372f, -0.00681782f, -0.12407946f, 
    0.16229388f, 0.06221825f, 0.06943710f, -0.11950023f, -0.21202034f, -0.10473328f, 0.26272050f, -0.03598491f, 
    0.05708562f, -0.05535880f, -0.10939283f, 0.04217728f, 0.07630509f, -0.24980684f, 0.00606152f, -0.02016140f, 
    0.10485268f, 0.11701711f, 0.01484571f, -0.12663747f, -0.29538167f, 0.10435074f, 0.03144925f, -0.01584894f, 
    -0.04492166f, 0.13195564f, 0.10111813f, 0.07674419f, 0.03957902f, 0.06551208f, -0.19670759f, -0.19994819f, 
    0.14847697f, 0.25098041f, 0.03867017f, 0.03554674f, -0.22773190f, -0.13824446f, -0.08026460f, 0.13376722f, 
    0.02940282f, 0.05783531f, 0.03359599f, -0.00310487f, 0.06204846f, 0.05997906f, 0.08982677f, 0.11145282f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.05571622f, 0.09164000f, -0.04324257f, -0.04196472f, -0.00919955f, 0.05592041f, -0.15165833f, 0.16657162f, 
    0.11588373f, 0.03867183f, -0.03099453f, 0.01580627f, 0.00010351f, 0.07998250f, 0.11292553f, 0.04124874f, 
    0.00956385f, 0.01467158f, -0.04859173f, 0.04118458f, 0.13264023f, -0.01952338f, -0.01059236f, -0.01446906f, 
    0.03575034f, 0.13957691f, -0.02150230f, -0.00835541f, 0.10068960f, -0.03283279f, -0.03848565f, 0.10712134f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.11473370f, -0.15093005f, 0.08768597f, -0.01153840f, -0.00234512f, -0.07260639f, 0.00657436f, 0.19428882f, 
    -0.07568800f, 0.34580439f, -0.04021404f, 0.38971102f, -0.36325601f, -0.22357737f, -0.11936489f, 0.11710296f, 
    0.34442985f, -0.36311263f, 0.16338955f, -0.06109536f, 0.06317212f, -0.10796469f, 0.08018385f, 0.05233142f, 
    0.28948635f, 0.17972974f, 0.05481182f, 0.04161162f, 0.08582936f, -0.07040472f, -0.07164614f, -0.01750729f, 
    -0.02872495f, 0.14034390f, 0.12394909f, -0.16683778f, -0.09541173f, 0.03214695f, 0.05320438f, -0.05091143f, 
    -0.00207548f, -0.19185571f, -0.02854756f, -0.05093244f, -0.15007213f, -0.00863651f, 0.01697375f, 0.05052061f, 
    -0.01578815f, -0.01802923f, -0.14600630f, -0.02360800f, -0.01952657f, -0.03211151f, -0.14585494f, -0.14462446f, 
    -0.01266999f, 0.13329311f, -0.09325045f, -0.06299820f, -0.04305261f, -0.03673104f, 0.01599697f, -0.10451367f, 
    -0.00191549f, -0.21336126f, -0.01453512f, 0.37952819f, -0.13961589f, 0.30782726f, -0.17118427f, 0.20890625f, 
    0.09280360f, -0.10795920f, 0.15033868f, -0.07678054f, 0.29188171f, -0.09629349f, -0.28322080f, -0.02339698f, 
    0.22662695f, -0.20281202f, -0.06796005f, -0.17987704f, -0.12927887f, 0.21523562f, 0.41543984f, -0.08753894f, 
    0.02736548f, -0.21737504f, -0.05614992f, 0.06840539f, -0.03618327f, 0.15398608f, 0.04815030f, -0.11948572f, 
    -0.01935442f, -0.22607894f, -0.46175891f, -0.03676304f, 0.05764922f, -0.09878623f, 0.25053185f, 0.18193603f, 
    -0.14197966f, 0.02319257f, 0.07316168f, 0.25320590f, 0.22424977f, 0.28523955f, -0.06218209f, -0.05157816f, 
    0.18402685f, -0.17933761f, -0.15374084f, -0.10087908f, 0.03130839f, 0.23750658f, 0.26735833f, -0.12171573f, 
    0.32418928f, -0.07767417f, 0.14427494f, -0.02044516f, -0.03221449f, 0.06653095f, 0.31756413f, 0.01153314f, 
    -0.15516497f, 0.16818494f, 0.37074175f, -0.14273816f, -0.00722892f, 0.12055832f, -0.28136447f, -0.03204447f, 
    0.07295710f, -0.23154429f, 0.00057234f, -0.15259586f, 0.02762290f, 0.43146825f, 0.18503398f, 0.00645692f, 
    -0.27711213f, -0.07025813f, 0.19062184f, 0.07110734f, 0.22222091f, 0.11470718f, 0.12722510f, -0.04806096f, 
    0.07923384f, -0.25065154f, 0.05976453f, -0.00210871f, 0.30163598f, -0.28625229f, -0.18908754f, 0.19113381f, 
    -0.04047625f, 0.25389785f, -0.09976606f, 0.03498618f, 0.09631505f, -0.16753227f, 0.15279247f, 0.10280104f, 
    0.25746328f, -0.00298970f, -0.16368972f, -0.22336222f, -0.13359565f, -0.12864530f, 0.18165652f, 0.05740807f, 
    -0.34708267f, -0.10085522f, 0.09990500f, 0.13909914f, 0.00661919f, 0.01306380f, -0.07542931f, 0.07904205f, 
    -0.12768349f, -0.24709615f, -0.06662329f, -0.00124887f, 0.18829194f, -0.02154686f, -0.61611974f, 0.11743644f, 
    -0.12216353f, -0.05016109f, 0.07568111f, 0.22690228f, -0.10948455f, 0.06654632f, 0.02636215f, 0.05083959f, 
    0.34849003f, 0.16967985f, 0.12321194f, -0.13514528f, 0.16180928f, 0.40359217f, 0.00640254f, 0.00190569f, 
    0.01635973f, -0.32643282f, -0.07399376f, -0.20112617f, 0.25718138f, 0.18723693f, 0.33766663f, -0.01158372f, 
    0.08710384f, -0.39459154f, -0.09634890f, -0.07900535f, 0.10667598f, -0.33712023f, -0.15499239f, 0.20906498f, 
    0.04882720f, -0.47690853f, 0.25357863f, 0.20788075f, 0.15927072f, -0.34195450f, 0.19623542f, -0.01208630f, 
    -0.30327186f, 0.18281586f, 0.04146377f, 0.27756935f, 0.06762858f, 0.32858101f, 0.22147030f, -0.16449751f, 
    0.01177865f, 0.11229111f, 0.08873279f, 0.12719949f, -0.19667493f, 0.10131970f, 0.20460461f, 0.05229669f, 
    0.24232268f, -0.09125622f, 0.03999758f, -0.02642155f, -0.08579496f, -0.14916712f, -0.04138607f, 0.13148564f, 
    0.13471404f, -0.14620894f, 0.05292521f, 0.14096940f, -0.12317197f, 0.10298721f, -0.12865104f, -0.15650314f, 
    0.09649887f, 0.02535105f, 0.14587694f, -0.06554571f, -0.08548879f, -0.16271684f, -0.13608484f, 0.09169734f, 
    -0.02742192f, 0.04121914f, -0.08801868f, -0.09059417f, -0.03411165f, 0.02594755f, -0.18770251f, 0.02214499f, 
    0.08839958f, 0.05388032f, -0.11683377f, -0.13561563f, 0.01816458f, 0.13680974f, -0.08144981f, -0.10691671f, 
    -0.00137352f, -0.06305835f, -0.14444958f, -0.31720725f, -0.11990304f, 0.03180179f, 0.20920861f, 0.23752390f, 
    0.21878937f, 0.38612342f, 0.02083378f, 0.09366136f, -0.42761248f, -0.09787138f, -0.04559674f, 0.10100970f, 
    0.29286432f, -0.44419888f, -0.27620158f, -0.03510463f, -0.06193352f, 0.11700145f, -0.14337206f, -0.09459771f, 
    0.09835219f, 0.43478516f, 0.12712345f, -0.17426172f, 0.05459858f, -0.18888710f, 0.08326641f, 0.19913432f, 
    -0.01632566f, -0.12586358f, -0.15125477f, -0.30848363f, 0.01644535f, -0.21866360f, -0.16441512f, 0.31979370f, 
    0.22673593f, 0.17881106f, -0.15528800f, 0.05805023f, 0.27925736f, 0.13228977f, -0.04290088f, -0.11490896f, 
    -0.05760247f, -0.35505220f, -0.04147424f, -0.04012692f, 0.35273522f, 0.20928209f, 0.01797331f, -0.14514577f, 
    -0.29560310f, -0.19187970f, -0.09587894f, -0.09763070f, 0.05507938f, -0.00775585f, -0.06442320f, 0.06317003f, 
    0.14852764f, -0.39336723f, -0.07421321f, -0.27533317f, -0.00308317f, -0.19691333f, 0.09411716f, -0.02419730f, 
    0.02915418f, 0.31960180f, -0.11000976f, 0.29430026f, -0.17028905f, -0.01074470f, 0.00748593f, 0.04765214f, 
    0.03089550f, 0.02434067f, -0.22304609f, -0.00785194f, 0.16487411f, 0.07444623f, -0.01576688f, 0.14485614f, 
    0.02185070f, 0.19455472f, 0.06902482f, 0.09871078f, 0.01372658f, -0.15053974f, 0.33525601f, 0.15111546f, 
    -0.00507615f, 0.21722938f, 0.42057487f, 0.07991992f, -0.00288889f, 0.03031513f, 0.02175716f, -0.17264247f, 
    -0.21395895f, -0.11858357f, 0.06333960f, 0.24241342f, 0.26175815f, 0.05916938f, 0.08327444f, 0.08377719f, 
    -0.18346865f, 0.47887206f, 0.19568928f, 0.10586620f, -0.03995286f, -0.00446578f, -0.05464649f, 0.13236223f, 
    -0.13097568f, -0.25254083f, -0.02131973f, -0.16312535f, -0.08447347f, 0.22036101f, 0.17935185f, 0.30218917f, 
    -0.04406098f, -0.01654099f, -0.05756295f, 0.09281978f, -0.14024770f, 0.02068831f, 0.29007110f, 0.19957511f, 
    -0.48850897f, 0.19779372f, -0.11754975f, 0.30407742f, 0.11429373f, 0.14261900f, -0.14290592f, 0.15743093f, 
    0.01844102f, 0.23387662f, -0.04059098f, -0.16722174f, -0.15068695f, 0.25085226f, 0.03586241f, 0.05331393f, 
    0.12639222f, -0.42381471f, 0.00852995f, 0.00902908f, -0.22859153f, -0.09550269f, 0.37930077f, 0.20897168f, 
    0.15106934f, 0.42432362f, 0.44552618f, 0.27072522f, -0.07399240f, -0.15124239f, -0.12579481f, -0.02404235f, 
    -0.11080562f, 0.05447557f, 0.06253900f, 0.14290613f, -0.26057082f, -0.28167918f, 0.05708526f, 0.04968185f, 
    -0.20873587f, 0.12076583f, 0.18671079f, 0.05442060f, -0.24211365f, 0.10396022f, -0.10409063f, -0.07066802f, 
    -0.04054583f, 0.26351458f, -0.14372469f, 0.16086675f, -0.09281523f, 0.01885828f, -0.37544581f, 0.17579246f, 
    0.15433663f, -0.24054745f, 0.43411452f, -0.07818285f, 0.12289148f, 0.20821875f, -0.30228668f, 0.09596417f, 
    -0.10803314f, -0.01104110f, -0.08568968f, 0.24098915f, -0.07414848f, -0.33809072f, 0.02092887f, 0.02736766f, 
    -0.14823171f, 0.22185181f, -0.22103538f, 0.19503056f, 0.00519838f, 0.06989194f, -0.37680191f, 0.10408451f, 
    -0.31812701f, 0.41540706f, -0.05196572f, -0.12261178f, -0.03181686f, 0.29245436f, 0.36094573f, 0.08535822f, 
    0.03869610f, -0.18418193f, 0.01108098f, -0.11028358f, -0.18456319f, 0.26500860f, 0.21724015f, -0.18930958f, 
    -0.30053210f, 0.34894297f, -0.14830303f, 0.35934719f, -0.28006190f, -0.11081835f, 0.13678461f, 0.01206700f, 
    0.25586131f, 0.16422722f, -0.26681626f, 0.11102643f, -0.26069021f, -0.11769039f, -0.13189787f, 0.05381446f, 
    -0.03993781f, 0.02441001f, 0.17837299f, 0.05575262f, 0.00487366f, 0.43407816f, 0.39623564f, 0.25143179f, 
    -0.17339258f, 0.01968077f, -0.11511524f, -0.12373012f, 0.06491217f, -0.11347552f, -0.09949313f, -0.10215941f, 
    0.04276407f, -0.03240696f, 0.02762028f, -0.06840193f, -0.11792996f, 0.15938933f, -0.13547632f, 0.05433498f, 
    0.01592080f, -0.15604535f, -0.07825369f, 0.06638698f, -0.11670022f, 0.08967324f, 0.10890484f, -0.10880400f, 
    -0.16610759f, -0.13639693f, 0.03659017f, 0.15322034f, -0.05532758f, 0.09167561f, 0.12710615f, -0.04842624f, 
    -0.07672729f, 0.34285197f, 0.34047988f, 0.23911366f, 0.13245121f, 0.24034767f, -0.20477931f, -0.06668984f, 
    0.13565955f, -0.10878013f, -0.14240168f, -0.07240284f, 0.01160678f, -0.24778433f, 0.18229942f, 0.15012248f, 
    -0.16621642f, -0.15647595f, 0.40683514f, 0.14968340f, 0.04747071f, -0.11182907f, 0.13635935f, 0.05323743f, 
    0.23816256f, 0.10315504f, 0.09567027f, -0.12091865f, 0.19845538f, 0.02452274f, -0.16982633f, -0.17466776f, 
    0.09550412f, -0.05658565f, 0.02011360f, -0.13456281f, 0.08768777f, 0.16988949f, -0.18815473f, 0.17263553f, 
    0.19901219f, -0.24864750f, -0.06001884f, -0.19590808f, 0.39240277f, 0.17755939f, 0.03174910f, 0.07495713f, 
    -0.04801958f, 0.13377103f, -0.20218098f, 0.18155985f, 0.25339076f, 0.11964314f, 0.09008756f, -0.11887565f, 
    -0.11155260f, -0.31299180f, -0.00376856f, -0.05379248f, 0.09532641f, -0.06010857f, 0.29913455f, 0.05279477f, 
    -0.10732480f, 0.07352745f, 0.26828262f, 0.28345466f, -0.07561879f, 0.15164889f, -0.10407164f, -0.05364526f, 
    0.25302002f, -0.21089375f, -0.17414242f, -0.00695751f, 0.30332676f, 0.40754399f, 0.21828467f, 0.01126159f, 
    -0.26770246f, 0.16552109f, 0.31226876f, 0.06388039f, 0.23328558f, -0.15288623f, 0.25514397f, -0.08974467f, 
    0.26451653f, -0.31668928f, 0.06634319f, -0.09513833f, -0.11609500f, -0.07718128f, 0.03974275f, -0.00329945f, 
    0.00190432f, -0.24480505f, 0.05584162f, -0.16258679f, -0.06476706f, 0.35037312f, 0.20321678f, 0.02360084f, 
    -0.37633401f, 0.17972766f, 0.09987388f, 0.24573320f, -0.37141958f, 0.04686087f, 0.18183266f, 0.06395733f, 
    0.38541541f, 0.09579676f, -0.11037075f, -0.17230378f, -0.10680658f, -0.04963442f, -0.02584834f, 0.16285048f, 
    0.03018027f, 0.05281856f, -0.08830114f, -0.14225081f, -0.18156274f, 0.28816468f, 0.35905549f, 0.13615867f, 
    0.12194538f, -0.12572879f, -0.15816273f, -0.10093596f, 0.04243945f, -0.23939262f, -0.06242447f, 0.00299861f, 
    -0.28148213f, 0.07878866f, 0.09892256f, 0.00472834f, -0.33366972f, 0.44613564f, 0.04861723f, -0.11924260f, 
    0.23131615f, 0.20490262f, 0.00471557f, -0.17534158f, -0.13718776f, 0.07587935f, 0.05538038f, -0.15963361f, 
    0.13543127f, -0.03432078f, 0.11515614f, 0.08776557f, -0.07320286f, -0.01430154f, 0.03809861f, 0.07198702f, 
    -0.10261362f, 0.39153609f, -0.02135645f, 0.10725892f, 0.08737101f, 0.42070487f, 0.18616338f, 0.02607048f, 
    -0.16942026f, 0.00035723f, -0.05894017f, -0.17889528f, 0.11689658f, -0.20673843f, -0.03252055f, 0.13283654f, 
    0.28985718f, 0.37587610f, 0.32164261f, 0.17595389f, -0.21689504f, 0.17945652f, 0.14923951f, -0.13947074f, 
    0.10815021f, 0.11783694f, 0.10059543f, -0.14462858f, -0.01933550f, 0.32433534f, -0.04680769f, -0.17329694f, 
    0.13921459f, -0.03186990f, -0.18080820f, -0.14011031f, -0.14782007f, 0.09574951f, -0.01877413f, 0.09700251f, 
    0.11485631f, -0.03938713f, -0.00610595f, -0.18081109f, -0.12600145f, -0.11860427f, -0.12171049f, -0.06406029f, 
    0.00306904f, 0.11614279f, -0.02187123f, -0.18412808f, 0.04856183f, 0.00171258f, 0.10215147f, 0.06455464f, 
    0.00446092f, 0.08305866f, 0.15316702f, 0.03012178f, -0.11414787f, -0.11796363f, 0.02546707f, -0.19357954f, 
    0.07153454f, -0.02673321f, 0.28663209f, -0.12362526f, 0.01765962f, -0.30118573f, -0.04753900f, 0.06269995f, 
    -0.28635290f, 0.15906703f, 0.05613045f, -0.07194747f, 0.43557236f, 0.30810460f, 0.04386819f, -0.06998786f, 
    -0.01061033f, 0.57270980f, -0.03711398f, 0.25716558f, -0.23682484f, 0.04684443f, -0.10734887f, -0.12104400f, 
    -0.33729258f, -0.28217793f, -0.03855339f, 0.02191651f, 0.01693529f, 0.08635477f, -0.04815870f, 0.23816586f, 
    0.14474177f, -0.34654734f, 0.22031243f, -0.28935641f, 0.16069525f, 0.13265482f, -0.33302385f, 0.16848761f, 
    0.05181395f, -0.04075776f, -0.12712501f, 0.08913540f, 0.08951769f, 0.17262174f, -0.03675523f, -0.16725321f, 
    -0.05072793f, -0.10587594f, -0.00908265f, 0.05826408f, 0.18335654f, 0.26080731f, -0.07989822f, -0.04801211f, 
    -0.29704663f, -0.19170631f, -0.02588355f, -0.15771389f, 0.12285098f, -0.23642609f, 0.42522055f, 0.30164787f, 
    0.00935364f, 0.08075020f, 0.09201343f, -0.07646506f, 0.15669179f, 0.11378774f, 0.09542099f, -0.09304047f, 
    0.06723715f, -0.14737783f, 0.11750406f, 0.08009174f, -0.06982701f, -0.16786824f, -0.13258827f, -0.13279693f, 
    0.07200719f, -0.14573680f, -0.18604046f, -0.00731591f, -0.01885820f, 0.08050574f, -0.10711920f, 0.06600765f, 
    0.10555610f, -0.21840571f, 0.11955915f, 0.10819060f, 0.06000368f, 0.07628264f, 0.06355193f, -0.17842564f, 
    0.00964255f, 0.25659195f, -0.10567360f, -0.14081952f, -0.00732918f, 0.07684504f, 0.00732773f, 0.24121065f, 
    0.11151691f, 0.09097034f, 0.03165327f, -0.18593475f, -0.20263839f, -0.09342857f, 0.04089088f, -0.10461169f, 
    0.14686094f, -0.05952827f, -0.14887066f, -0.11721275f, 0.02345915f, -0.10553180f, 0.12999891f, -0.02275808f, 
    0.19912912f, -0.10482110f, -0.12301810f, -0.08835901f, 0.00418013f, 0.01127200f, -0.25331223f, -0.01429009f, 
    -0.04463097f, 0.51745939f, -0.00200840f, -0.05659334f, -0.00106112f, 0.31102553f, 0.04779737f, 0.16974336f, 
    0.05869361f, 0.00375105f, -0.07553424f, -0.21594280f, 0.17837757f, -0.29248849f, 0.12868752f, 0.12821123f, 
    -0.00950455f, 0.42779222f, 0.07343908f, 0.29096201f, -0.19862621f, -0.07781465f, 0.01051818f, 0.02063057f, 
    -0.13643324f, 0.07726891f, -0.10260150f, 0.16200711f, -0.17510042f, 0.22877862f, 0.01211719f, -0.12355173f, 
    0.16381671f, 0.01038725f, -0.22909032f, -0.11751051f, -0.15765129f, -0.13961741f, -0.29145956f, 0.23660393f, 
    0.27845773f, 0.02044224f, 0.03925003f, 0.09176029f, -0.03259212f, 0.06475277f, 0.11086763f, 0.13879408f, 
    -0.00336192f, -0.46084279f, 0.15481232f, 0.09353936f, 0.28461093f, 0.03805234f, -0.01607352f, -0.11626665f, 
    -0.25159857f, 0.20088840f, -0.13599135f, 0.00187640f, 0.13148348f, -0.20548639f, -0.06362414f, -0.09442943f, 
    -0.06437775f, 0.01613001f, -0.12230072f, -0.14978375f, 0.02213032f, 0.01055373f, -0.15919103f, -0.14166316f, 
    0.14296141f, 0.07573837f, 0.12403444f, 0.12758243f, -0.08062714f, -0.08729398f, -0.05325842f, -0.13013425f, 
    -0.05413721f, -0.05651969f, 0.02565334f, 0.08503789f, -0.05116917f, -0.14748973f, -0.18419734f, -0.11268760f, 
    0.09932389f, 0.04550128f, 0.08199609f, 0.16810821f, 0.05211145f, 0.02044823f, -0.06273157f, -0.16959763f, 
    -0.04759814f, -0.19006974f, -0.00240827f, 0.12414788f, -0.16341934f, -0.08512351f, 0.17613234f, -0.05502995f, 
    -0.35587430f, 0.29828456f, 0.10872520f, 0.27066800f, 0.18891345f, 0.03120999f, -0.02662856f, 0.13233750f, 
    0.13564911f, 0.29053944f, -0.14529438f, -0.04682879f, -0.26206526f, 0.12502736f, -0.15486588f, 0.07956436f, 
    0.09291737f, 0.08100168f, -0.03563922f, 0.13977815f, -0.00350367f, 0.34005797f, 0.37223279f, 0.05788863f, 
    -0.15065509f, 0.04333201f, 0.00044413f, 0.03023735f, 0.00701776f, 0.03426434f, 0.09491795f, -0.00633076f, 
    0.07655047f, -0.02009258f, -0.07657727f, -0.13859788f, -0.05069507f, -0.19041204f, -0.13948856f, 0.16749911f, 
    -0.05549679f, -0.09367006f, 0.00571462f, -0.17650481f, -0.14073683f, 0.13489470f, -0.01060873f, -0.09517291f, 
    -0.13319823f, 0.05068980f, 0.08262102f, -0.15055338f, -0.07383607f, -0.11580646f, 0.05714089f, 0.02015253f, 
    -0.17382032f, 0.09411830f, -0.06111851f, -0.13494219f, -0.05692970f, -0.33969107f, -0.25173217f, 0.26854277f, 
    0.22367439f, 0.27977955f, 0.02281432f, -0.19451763f, 0.04284683f, -0.38096476f, 0.01875264f, -0.15074235f, 
    -0.16904899f, 0.02018024f, -0.15675630f, 0.03692257f, 0.19024000f, 0.24416260f, -0.14938261f, 0.07371751f, 
    -0.08258198f, 0.02594049f, -0.13983262f, 0.10154491f, 0.24379952f, -0.21256422f, -0.17357001f, 0.13844386f, 
    0.03982053f, 0.22317380f, -0.08451471f, 0.08094440f, -0.02262268f, -0.25401545f, -0.27047351f, 0.00300974f, 
    0.02906259f, 0.15882826f, 0.08681089f, -0.02289514f, 0.70965636f, 0.42749152f, -0.17041884f, 0.03540171f, 
    -0.17505005f, 0.54093230f, 0.18172134f, 0.20635018f, -0.12987012f, 0.23104693f, 0.01585347f, -0.13553682f, 
    0.03619703f, 0.02218985f, -0.04798290f, 0.03164845f, 0.00456657f, -0.35331234f, 0.11997449f, -0.09646692f, 
    -0.14695226f, 0.22618550f, -0.21470249f, 0.04461596f, 0.08799858f, 0.05042020f, -0.13752127f, 0.05569606f, 
    0.37124664f, 0.06640097f, -0.16360755f, 0.13372089f, -0.35630906f, -0.17347552f, 0.27228063f, -0.11917729f, 
    -0.11065617f, -0.13469134f, 0.26226464f, 0.10731184f, 0.28125936f, -0.02763063f, 0.11322616f, 0.06801780f, 
    0.36821157f, 0.51285791f, -0.10960769f, 0.11376707f, 0.20424958f, -0.18543927f, -0.03499747f, -0.14533627f, 
    -0.15928656f, 0.09265515f, 0.15380940f, 0.09004552f, 0.10630467f, 0.00489814f, -0.05475897f, -0.01871634f, 
    0.11435039f, 0.09243029f, -0.04586907f, 0.35870391f, -0.22025824f, -0.29463223f, -0.04610888f, 0.12797327f, 
    -0.14702901f, 0.01706211f, 0.31959790f, -0.01224545f, 0.29192644f, 0.12969242f, -0.20994279f, -0.07096656f, 
    -0.18246819f, -0.04010604f, 0.10707853f, 0.05138582f, 0.29816592f, -0.14733084f, 0.28835648f, 0.21850356f, 
    0.00349938f, 0.10684519f, 0.04922142f, -0.14875506f, 0.05415137f, 0.11141146f, -0.12191064f, -0.17413493f, 
    -0.01556350f, -0.02543915f, -0.13512020f, 0.09885266f, 0.16780229f, -0.07757238f, -0.12878536f, 0.01078131f, 
    -0.02446320f, 0.16000773f, 0.01256474f, -0.14880478f, -0.13026522f, -0.09870039f, 0.08614354f, -0.08237035f, 
    0.12268990f, -0.05555616f, 0.02850910f, -0.07009365f, -0.13885087f, -0.17962076f, -0.16767752f, 0.09616580f, 
    -0.01508353f, -0.27113992f, -0.29833442f, -0.27957827f, -0.09490290f, 0.04074416f, 0.04614804f, 0.12249179f, 
    0.07603038f, 0.11228307f, 0.13960424f, 0.17822637f, -0.45183244f, 0.29340041f, 0.26544073f, -0.16450848f, 
    0.21424633f, -0.42529234f, -0.29942355f, 0.10613054f, 0.13007164f, -0.09560342f, 0.21419427f, 0.02015852f, 
    0.03864270f, 0.24909538f, -0.13611278f, -0.04687305f, 0.17559525f, 0.09850561f, 0.03488789f, -0.14021495f, 
    0.02617740f, 0.06198048f, -0.18513665f, 0.12689260f, -0.12490319f, 0.03560985f, 0.36929330f, -0.08304735f, 
    -0.30097979f, 0.08290621f, 0.01494417f, 0.23499213f, -0.05801242f, -0.13962986f, 0.12425905f, 0.02600358f, 
    0.24462728f, 0.15336704f, 0.10797923f, 0.19616118f, -0.25673246f, 0.19261396f, 0.21125342f, -0.10944550f, 
    0.20775336f, 0.05993053f, -0.00830598f, 0.18141142f, -0.24916252f, 0.25781196f, -0.12974660f, -0.06198319f, 
    -0.09417416f, -0.01123255f, 0.05228104f, -0.16750918f, -0.10674696f, -0.15328166f, 0.10120216f, 0.13435523f, 
    -0.11712462f, -0.15644214f, -0.05090892f, -0.09950878f, -0.23232497f, -0.16526489f, 0.05598054f, -0.15912957f, 
    -0.16685627f, -0.07229970f, 0.04743316f, -0.14241651f, -0.10135505f, -0.08593301f, -0.12186226f, 0.16698545f, 
    0.12173191f, -0.08725307f, 0.04412798f, 0.09419563f, -0.08177900f, -0.10200801f, -0.14947991f, 0.07231075f, 
    -0.07099371f, 0.48525608f, 0.04197604f, -0.03703588f, -0.05995505f, 0.27435276f, -0.29357621f, 0.11801396f, 
    0.21362120f, -0.12324279f, 0.06483784f, -0.34644991f, -0.00404099f, 0.13262549f, 0.01293257f, -0.14382894f, 
    -0.04810478f, 0.17478624f, 0.28737792f, 0.29720527f, -0.12949972f, -0.15674904f, 0.00835345f, -0.02002679f, 
    -0.03755374f, 0.21746075f, -0.15108785f, 0.03849785f, 0.16231774f, 0.04694540f, -0.31712401f, -0.03446423f, 
    -0.12761404f, -0.10421945f, -0.32010373f, 0.02446254f, 0.15769894f, -0.07734640f, 0.16518982f, 0.25451031f, 
    -0.04141789f, 0.25234094f, -0.01484882f, 0.01453850f, -0.00692270f, -0.12458526f, 0.00807939f, -0.16611065f, 
    0.25516504f, -0.39524576f, -0.28662780f, 0.02767710f, 0.03759894f, 0.22019245f, 0.02559074f, 0.09442616f, 
    0.09609580f, -0.17987342f, 0.13411900f, 0.12942241f, 0.06645183f, -0.31679982f, 0.34049109f, 0.21293789f, 
    -0.02007998f, 0.34532681f, 0.14659402f, -0.00386161f, 0.07078719f, 0.32606730f, -0.14688382f, 0.00173860f, 
    0.15693702f, -0.26952645f, 0.10261385f, -0.37129113f, 0.14201601f, 0.56350005f, 0.20657070f, -0.15962538f, 
    0.06407604f, 0.16544473f, -0.13304542f, 0.24524233f, 0.14183585f, -0.08875199f, 0.23756872f, 0.03561310f, 
    0.11331483f, -0.02156444f, -0.03553857f, 0.09742286f, -0.11155430f, -0.23055613f, -0.11696706f, 0.10890672f, 
    0.04585462f, -0.20273812f, 0.23118544f, 0.31143680f, 0.08562623f, 0.18769251f, 0.10567060f, -0.03784834f, 
    -0.17723787f, 0.06856385f, -0.08108254f, 0.27231100f, -0.32218960f, 0.48712945f, 0.18680955f, -0.00819329f, 
    0.22143164f, -0.38794559f, 0.15398587f, -0.06697527f, 0.16626711f, 0.07057775f, 0.24137171f, -0.02379704f, 
    0.13323322f, -0.35705373f, 0.16612777f, 0.15771858f, -0.04994884f, -0.02749260f, -0.16380626f, -0.06125798f, 
    0.08409801f, -0.08749429f, -0.31164071f, 0.31421572f, 0.17450248f, -0.03888597f, 0.16740900f, 0.09949425f, 
    -0.31493568f, 0.10543246f, 0.09037489f, 0.18665110f, -0.18402062f, 0.23727578f, -0.06985732f, 0.02109184f, 
    0.36408740f, 0.03782860f, -0.07399815f, -0.19734021f, -0.27025503f, 0.26344782f, 0.13129522f, 0.12823372f, 
    0.40811253f, -0.11039220f, -0.01919553f, 0.16131882f, -0.31096119f, 0.04182515f, -0.08512850f, 0.04527803f, 
    0.01127741f, 0.33537161f, 0.09240800f, 0.37902242f, 0.06878693f, 0.09213237f, 0.02184438f, 0.09846622f, 
    0.04453059f, 0.13051188f, -0.12154345f, -0.08855171f, 0.22372967f, -0.19271839f, -0.09003969f, 0.06796385f, 
    -0.02593154f, -0.06246513f, 0.17605548f, -0.06760032f, -0.27100465f, 0.00323361f, 0.25941288f, 0.03228860f, 
    0.42521015f, 0.18470205f, 0.08018611f, -0.16097400f, 0.04789891f, -0.02628146f, -0.14313304f, -0.07389377f, 
    0.14536484f, -0.17926851f, -0.08735494f, -0.08432672f, -0.01543624f, 0.00348052f, -0.11452485f, 0.09662265f, 
    -0.02564028f, -0.14619818f, -0.14725320f, -0.13215695f, -0.11065944f, 0.03752872f, 0.04873250f, -0.15096308f, 
    -0.13282871f, -0.08386234f, -0.13066606f, -0.14847611f, -0.08479298f, -0.06703494f, -0.10849218f, 0.06006054f, 
    -0.10306685f, 0.04614080f, 0.10551959f, 0.09673218f, 0.16689566f, -0.04546295f, -0.17870992f, -0.16204630f, 
    -0.12606862f, -0.04364217f, -0.00628206f, -0.11153456f, -0.07554325f, -0.15556401f, -0.12937245f, -0.13141564f, 
    0.03787691f, 0.02250046f, 0.08424042f, -0.07913517f, 0.03026356f, 0.11768718f, 0.14243028f, 0.03043719f, 
    -0.07112482f, -0.08590081f, -0.14451206f, -0.12882039f, -0.17404135f, 0.11271851f, -0.12738362f, -0.09584292f, 
    -0.02909219f, -0.05854501f, 0.17140630f, -0.06135175f, -0.11821515f, -0.06250424f, -0.19934444f, -0.12235293f, 
    0.00944361f, -0.09617943f, 0.37283272f, 0.44358963f, -0.04471470f, -0.41782486f, 0.11899193f, 0.10744451f, 
    0.18922251f, 0.22147967f, -0.04948118f, 0.27629763f, -0.13050525f, -0.34516919f, -0.13865477f, -0.06884785f, 
    0.18370135f, -0.32055938f, 0.34554616f, 0.13479768f, -0.22374961f, 0.05584231f, 0.20118091f, -0.05116971f, 
    0.16050480f, 0.14430077f, 0.15798227f, 0.07221157f, 0.08369673f, 0.00779962f, -0.09425364f, 0.03376579f, 
    -0.16375037f, 0.06620055f, -0.22650073f, -0.31549999f, 0.03240985f, 0.27982959f, -0.15006804f, 0.24101895f, 
    0.09556359f, -0.12299393f, -0.15523146f, -0.16956989f, 0.48492712f, 0.44787008f, -0.07626123f, -0.12608252f, 
    0.04184592f, -0.08102907f, -0.29150319f, 0.14456752f, 0.14920868f, 0.07346592f, 0.18111843f, -0.14052303f, 
    -0.14384130f, -0.21524568f, 0.01819458f, 0.04917972f, -0.15857071f, -0.08933142f, 0.30998072f, 0.15532376f, 
    -0.14725263f, 0.19473115f, 0.15914698f, -0.15833557f, -0.05401830f, 0.39308330f, -0.37806734f, -0.05950096f, 
    0.08949850f, -0.04550215f, -0.12627751f, -0.22112884f, -0.21774347f, -0.01301028f, 0.23727980f, -0.11624026f, 
    -0.13412453f, 0.09424001f, 0.01370407f, 0.21050259f, 0.02996114f, -0.12033345f, 0.01275450f, -0.15274990f, 
    0.01218198f, 0.41710642f, 0.03673869f, 0.02358099f, 0.02269995f, 0.21055174f, -0.17437984f, 0.10180933f, 
    -0.17794250f, 0.48659307f, 0.25935110f, 0.18204513f, -0.14242746f, -0.10336900f, -0.09299081f, 0.17376089f, 
    0.08102270f, -0.18271929f, 0.15457734f, -0.24865620f, 0.34818608f, -0.04874343f, 0.06371060f, -0.13968320f, 
    -0.12062837f, 0.27201712f, 0.27953592f, 0.12907393f, -0.00025272f, 0.22933319f, -0.03706065f, -0.16499281f, 
    -0.30191946f, -0.19906405f, -0.14361332f, -0.01367952f, 0.20971413f, 0.02028050f, -0.21447352f, 0.21849652f, 
    -0.03812999f, 0.43262908f, 0.05619315f, -0.11561923f, -0.02218977f, 0.62915885f, 0.16258055f, 0.04799120f, 
    0.00067950f, -0.21205969f, -0.02291046f, -0.27503762f, 0.08095217f, -0.01052382f, 0.26273760f, 0.13944304f, 
    -0.00855157f, 0.25415772f, 0.14951700f, 0.12431439f, -0.06724776f, -0.10745575f, 0.20703116f, -0.04040172f, 
    0.03618640f, -0.05201922f, 0.06197087f, -0.05301158f, -0.05919398f, 0.24044576f, -0.05252500f, -0.17282741f, 
    0.14816190f, -0.08088400f, 0.08078764f, -0.11287603f, 0.00583778f, -0.01541461f, -0.09757659f, -0.07390010f, 
    -0.11810310f, 0.09819213f, -0.07480134f, -0.14809322f, -0.20761324f, 0.12578653f, -0.18479899f, 0.02011528f, 
    -0.16345708f, 0.11346449f, -0.20766604f, 0.05181869f, 0.03699181f, -0.11915982f, 0.07236123f, -0.02265614f, 
    -0.01760089f, 0.03763781f, -0.07758854f, 0.04374817f, 0.10782849f, 0.11028853f, -0.14499211f, -0.09676022f, 
    0.13665722f, 0.34210920f, 0.30498502f, 0.15527521f, 0.02658290f, 0.31372473f, -0.28918895f, 0.12953243f, 
    0.07331426f, -0.15292908f, 0.00279703f, -0.29416615f, 0.01427221f, 0.06970787f, 0.16311283f, -0.05015728f, 
    -0.25384590f, 0.12011097f, 0.18027003f, 0.27254233f, -0.07531229f, -0.14394614f, 0.08415952f, -0.04122566f, 
    -0.14784639f, 0.17441654f, -0.04545185f, 0.08729886f, 0.20601875f, -0.20090996f, -0.11066209f, -0.09806948f, 
    0.13315205f, 0.00387241f, -0.14265886f, 0.08448381f, -0.06594477f, -0.05751991f, -0.07357048f, -0.12484249f, 
    -0.12029519f, 0.08871581f, -0.11840044f, -0.08868957f, -0.08139127f, 0.04578315f, 0.06112234f, 0.04532754f, 
    -0.10670045f, -0.09882609f, 0.13166529f, -0.07089019f, 0.03354313f, 0.07530388f, -0.08998936f, 0.13868517f, 
    -0.15232566f, 0.10700525f, -0.14405458f, 0.14775255f, 0.05908000f, -0.14455654f, -0.14534637f, -0.10324912f, 
    0.13496788f, 0.53717399f, 0.07754561f, 0.06978852f, 0.11073390f, 0.07024316f, -0.10502319f, 0.04189315f, 
    -0.07889345f, -0.14790328f, -0.07695070f, -0.24874207f, 0.46736559f, 0.48972481f, 0.11621179f, 0.01824390f, 
    0.16876602f, 0.13537112f, -0.09433183f, 0.25290900f, -0.30026624f, -0.01947489f, 0.32918161f, -0.06455285f, 
    -0.07743590f, 0.06878032f, 0.04107856f, -0.03553934f, -0.26567942f, -0.11594978f, -0.24169594f, -0.10016072f, 
    0.00540192f, -0.45213920f, 0.20449539f, 0.11298478f, -0.05889841f, -0.00488525f, -0.35134417f, -0.11584062f, 
    0.50849038f, -0.21368971f, -0.13273649f, -0.07999521f, -0.02744067f, -0.17546397f, 0.18926980f, 0.17722128f, 
    -0.24378093f, -0.37881100f, 0.03260031f, -0.00184370f, 0.31926849f, -0.10067818f, 0.13858068f, -0.03718218f, 
    0.05370602f, 0.31924146f, -0.08409087f, 0.15004714f, 0.38955095f, -0.23801929f, 0.11099315f, 0.17180349f, 
    0.08114780f, -0.54966909f, 0.15727279f, -0.35795066f, 0.03832864f, -0.27601472f, -0.04162510f, 0.16903529f, 
    -0.13843499f, 0.14646167f, 0.10763218f, -0.09803099f, 0.01463061f, -0.02845393f, 0.06082461f, 0.00766460f, 
    0.04131458f, -0.09185458f, -0.28591901f, 0.18845494f, -0.15089719f, 0.00732199f, -0.10296097f, -0.15845333f, 
    -0.26494485f, 0.27568629f, 0.10632056f, 0.11832377f, 0.03502572f, 0.01725012f, 0.30041814f, 0.27139434f, 
    -0.14202607f, 0.01939478f, -0.07378429f, 0.08132444f, 0.14591657f, -0.18895558f, 0.12044047f, -0.09213533f, 
    0.12355193f, 0.00164764f, 0.00659178f, 0.14880885f, -0.04172269f, -0.09940117f, -0.07368304f, 0.14241898f, 
    -0.07884278f, 0.01989069f, -0.10529386f, 0.04388831f, -0.19515747f, -0.04679980f, -0.09374682f, -0.07352859f, 
    -0.18614012f, 0.00202945f, 0.04465369f, -0.01187827f, -0.03055477f, 0.14079191f, -0.16566274f, -0.06960630f, 
    -0.10672294f, 0.15877630f, 0.09741343f, -0.11785425f, 0.14997475f, -0.21738295f, -0.47341073f, 0.12351081f, 
    0.10468613f, 0.28292331f, 0.16027099f, -0.11849509f, 0.07233462f, -0.35119703f, -0.06329867f, -0.04244523f, 
    -0.07683638f, 0.13808985f, -0.27485788f, 0.04321060f, 0.22801414f, 0.16915587f, -0.32102567f, -0.13398586f, 
    -0.19768080f, -0.09428225f, 0.00618461f, 0.05279411f, 0.23184563f, 0.03273858f, -0.01652643f, 0.22790401f, 
    -0.04114635f, -0.34946516f, 0.20212457f, -0.04833341f, -0.06004505f, -0.10877564f, 0.10101523f, 0.18233441f, 
    -0.19253317f, 0.08265221f, 0.09457392f, 0.17322423f, -0.18250436f, -0.24885523f, -0.02305519f, -0.11845120f, 
    0.12992145f, 0.25043052f, -0.15374510f, 0.17744492f, -0.23363234f, -0.08032369f, -0.26046348f, 0.09650911f, 
    -0.22555920f, 0.15918665f, 0.04814081f, -0.09266241f, -0.00661427f, 0.25953442f, 0.20405585f, 0.18337864f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.26686475f, 0.01873131f, -0.20587023f, -0.05627090f, 0.17629948f, 0.02712477f, -0.09608413f, 0.00863605f, 
    -0.08405434f, 0.19700505f, 0.06592161f, 0.07450140f, -0.20843665f, 0.13116252f, 0.06328549f, 0.10103120f, 
    0.05829899f, -0.12113999f, -0.01259708f, 0.15387045f, -0.19246978f, 0.06642939f, 0.07793638f, -0.09675571f, 
    -0.21586460f, -0.11466026f, 0.21756582f, -0.15822229f, 0.12109236f, 0.10138822f, 0.15577926f, 0.03472527f, 
    0.04501348f, 0.00740790f, 0.09286824f, -0.08951233f, 0.29567844f, -0.03926020f, 0.06944241f, 0.05615603f, 
    0.17175230f, -0.17308630f, 0.08877057f, 0.03882631f, -0.10877686f, -0.18638885f, 0.05935976f, 0.12735198f, 
    0.10854856f, -0.17803338f, 0.12276061f, 0.10669363f, 0.28129172f, 0.02336412f, 0.07808010f, 0.03936845f, 
    0.16165982f, -0.13855013f, 0.08989632f, 0.16724661f, 0.29465765f, 0.09277567f, 0.13298748f, 0.20782767f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.15652518f, -0.10990063f, 0.15340461f, -0.13206032f, 0.04051891f, -0.20103338f, 0.08413912f, 0.14707008f, 
    0.00247229f, -0.03093274f, -0.03469729f, 0.04802077f, 0.25197232f, 0.16885778f, 0.31159347f, -0.05736583f, 
    -0.08286541f, 0.03845406f, -0.22176613f, 0.04291813f, 0.11637216f, -0.16719893f, -0.03687445f, 0.11883598f, 
    -0.07416561f, 0.44737607f, 0.14197019f, 0.17475249f, -0.02858736f, -0.07007980f, -0.17712548f, 0.11497092f, 
    0.18148999f, -0.06876510f, -0.11184580f, 0.47356272f, -0.26320413f, -0.10182004f, -0.07985777f, -0.29123807f, 
    0.09789056f, -0.11345840f, -0.09806959f, 0.04597442f, 0.15633669f, 0.08372404f, -0.09326867f, 0.02596102f, 
    0.06544648f, 0.06870302f, 0.18822525f, 0.10736692f, -0.10108210f, 0.16583817f, -0.11458061f, -0.00383698f, 
    0.09318009f, -0.09622137f, 0.32059741f, -0.24185203f, 0.12406351f, 0.09645100f, -0.03568310f, 0.01052230f, 
    -0.12470673f, 0.09800632f, 0.10364691f, 0.17064650f, -0.11883524f, -0.40046182f, 0.13380152f, 0.04176123f, 
    -0.09431596f, -0.00296054f, 0.23389852f, 0.12871766f, 0.20091772f, 0.13905866f, -0.25263196f, 0.32099539f, 
    0.28020737f, -0.02896777f, -0.17357734f, 0.11645625f, -0.06796512f, 0.30094707f, -0.02535150f, -0.08318734f, 
    0.04832251f, 0.29448706f, 0.29157346f, 0.10667222f, -0.11378539f, -0.02742009f, -0.00544438f, 0.00287589f, 
    0.06816206f, 0.06037884f, 0.06224053f, 0.13549186f, -0.16018516f, 0.12081704f, 0.12606853f, -0.03422546f, 
    -0.15556011f, 0.03093495f, -0.15201911f, 0.18807165f, -0.10331022f, -0.06684848f, -0.15297072f, -0.14518952f, 
    -0.10247975f, 0.02693586f, -0.09165952f, 0.35082185f, 0.03404548f, 0.01554462f, 0.00139400f, -0.07965010f, 
    -0.09554391f, -0.01373720f, -0.02506330f, -0.12306038f, 0.21742201f, 0.02377087f, 0.19356172f, 0.21812949f, 
    -0.08728181f, 0.01246033f, 0.09724598f, -0.07688609f, -0.07201122f, 0.04264610f, -0.07017961f, 0.00418301f, 
    -0.06778426f, -0.04194971f, 0.04132856f, 0.10693979f, 0.02708716f, -0.02646403f, 0.08412528f, 0.01847866f, 
    0.02874387f, -0.10928966f, 0.01492722f, -0.06766710f, -0.11581955f, 0.08510125f, 0.07074802f, 0.00775396f, 
    0.12345825f, 0.01874342f, -0.11168595f, 0.03780012f, -0.10280555f, -0.11458969f, 0.11200748f, 0.11418869f, 
    -0.09332852f, -0.07317789f, 0.05087551f, -0.04917799f, -0.06146327f, -0.04828430f, -0.05747229f, 0.08806180f, 
    -0.06916068f, 0.11327726f, 0.03904472f, 0.02310498f, 0.11356131f, -0.11731873f, -0.10822113f, 0.04732478f, 
    -0.05358690f, 0.08175585f, -0.12488443f, -0.02482859f, 0.12368493f, 0.05277199f, -0.09082383f, -0.05051003f, 
    0.04566166f, -0.07828009f, -0.05229563f, -0.11700216f, -0.01872419f, 0.05090822f, -0.00376521f, -0.08105174f, 
    -0.03994378f, -0.05660017f, -0.01564590f, -0.10382102f, -0.07371144f, -0.00653198f, 0.01710338f, -0.13404386f, 
    -0.08167759f, 0.05653467f, -0.10739435f, -0.03334139f, -0.03746635f, -0.04330532f, -0.05260901f, 0.06222265f, 
    -0.03640223f, 0.07667163f, -0.06167478f, -0.04737455f, -0.15869479f, -0.06632908f, 0.05164436f, -0.02117852f, 
    0.03803861f, -0.01131348f, 0.04566927f, 0.01628486f, -0.13749821f, -0.06361409f, -0.12693383f, 0.01265452f, 
    -0.03759477f, 0.07299040f, -0.02727530f, -0.15599389f, 0.02535386f, 0.05714912f, -0.07903724f, -0.14959435f, 
    -0.01681862f, -0.04996479f, -0.01339793f, -0.02205606f, 0.02777289f, -0.00068031f, 0.06559823f, -0.10289112f, 
    0.01633042f, 0.03455748f, -0.09074192f, -0.14821605f, -0.05983204f, 0.08407919f, -0.04693559f, 0.11360409f, 
    -0.07594271f, -0.06733833f, -0.05389090f, -0.06564096f, -0.15413363f, -0.09954382f, 0.09072890f, -0.12121596f, 
    0.13200396f, 0.07945670f, -0.07103465f, -0.07681095f, 0.02131222f, 0.14994128f, 0.04890934f, -0.07341653f, 
    0.01485041f, -0.09079105f, 0.00025370f, 0.03705918f, 0.04742508f, -0.09631648f, 0.03223672f, -0.02085642f, 
    0.08417624f, 0.10387529f, -0.05054042f, -0.15228574f, -0.05279545f, -0.02041560f, -0.07257226f, 0.08414762f, 
    0.01850525f, 0.06748252f, 0.06825846f, -0.11688244f, 0.12184960f, 0.02202172f, -0.01613863f, 0.02503903f, 
    -0.13791390f, 0.00145473f, -0.04695672f, -0.06011112f, -0.14267689f, 0.05002745f, 0.09460114f, -0.06518551f, 
    -0.01163657f, 0.09174074f, 0.04008765f, -0.04988579f, -0.11663145f, -0.11205506f, -0.02615539f, 0.03713964f, 
    -0.03755908f, 0.02918194f, 0.08203959f, -0.00363386f, -0.14820094f, -0.15233515f, -0.15669037f, -0.03282365f, 
    0.02628822f, 0.09764649f, -0.09423770f, -0.02377775f, -0.13225298f, 0.00173466f, 0.06219041f, 0.07537461f, 
    -0.10466787f, -0.00053977f, 0.22651964f, 0.12343817f, 0.16171436f, 0.20270129f, 0.32012501f, 0.21395434f, 
    0.12339522f, -0.15953723f, -0.05286709f, -0.02536605f, 0.10264040f, -0.09126774f, 0.01392026f, -0.21765918f, 
    -0.23002532f, 0.02187368f, 0.23978536f, 0.11991794f, 0.38485581f, 0.02406666f, 0.06615453f, -0.05846031f, 
    0.14632915f, 0.07016954f, 0.09865738f, 0.06889196f, -0.00499394f, -0.27110404f, 0.01704557f, -0.11075330f, 
    -0.17666401f, -0.02905734f, 0.08999193f, 0.11811875f, 0.15799853f, 0.16983032f, -0.09322561f, -0.02686839f, 
    -0.13101858f, 0.03677142f, -0.02006628f, 0.00914652f, 0.16702892f, 0.37891641f, -0.01209317f, 0.13818863f, 
    -0.07676363f, 0.00395175f, 0.22198062f, -0.09858794f, -0.06042790f, 0.13551599f, -0.06681612f, 0.07024752f, 
    0.14923440f, 0.01600250f, -0.04707434f, 0.28025797f, -0.23461111f, 0.01027364f, -0.05588766f, -0.15059550f, 
    -0.02471866f, 0.03055212f, -0.02264822f, -0.13066538f, 0.20473585f, 0.18191542f, 0.18839939f, 0.04128018f, 
    0.03072407f, 0.13062468f, 0.20953412f, 0.03748253f, -0.07054729f, -0.22059870f, 0.23487726f, 0.08040307f, 
    -0.19000281f, 0.11106826f, 0.23382154f, -0.04774549f, 0.02168345f, -0.17692152f, -0.00336519f, -0.15668818f, 
    -0.06879740f, 0.11806652f, 0.17578208f, -0.11939273f, 0.17166612f, 0.06212508f, 0.34210804f, 0.11898670f, 
    -0.21359645f, -0.05445741f, 0.59064877f, -0.02659077f, 0.11905762f, -0.22048473f, 0.04292212f, 0.05307908f, 
    -0.24067844f, 0.00123996f, 0.37218985f, -0.03009594f, 0.25133735f, 0.00944355f, -0.24979797f, -0.04108264f, 
    -0.03859521f, 0.03055110f, 0.15197101f, 0.03453100f, 0.22487566f, 0.29508296f, -0.07979907f, 0.00215321f, 
    0.38418856f, -0.09959170f, 0.03499180f, 0.28610951f, 0.23960015f, -0.04132526f, 0.36682078f, 0.15513207f, 
    0.23636810f, -0.01842177f, 0.50908798f, 0.26770881f, -0.21388943f, 0.05079367f, 0.31846052f, 0.03493623f, 
    0.01915434f, 0.06070270f, -0.05471911f, -0.03942992f, -0.19175528f, 0.35921326f, -0.18943873f, -0.31565517f, 
    0.07685433f, 0.11627771f, -0.19460645f, 0.02888573f, 0.07475645f, 0.10202237f, 0.26400357f, 0.18119501f, 
    0.09489165f, -0.12052671f, 0.05711860f, -0.04723206f, 0.02409785f, -0.25575483f, -0.15631823f, 0.00096937f, 
    0.23781845f, 0.01615967f, -0.26893082f, -0.01354305f, 0.03647638f, -0.34011075f, 0.11339086f, 0.01662260f, 
    0.19356765f, -0.06959324f, -0.15037762f, 0.26769653f, 0.07915558f, 0.29981461f, 0.51070040f, 0.17647783f, 
    0.05548826f, 0.13951807f, 0.13983157f, 0.22953399f, -0.26186234f, -0.12201440f, -0.16616355f, -0.01347892f, 
    -0.20848279f, -0.07028089f, 0.07600407f, -0.11088201f, -0.14089188f, -0.08710007f, -0.25467974f, -0.13324206f, 
    0.17718542f, -0.07412745f, 0.05184938f, 0.16536635f, -0.09523365f, 0.17741150f, -0.14021747f, -0.02276264f, 
    0.03539760f, 0.15986253f, 0.24998084f, 0.27372259f, -0.18092072f, 0.00668889f, -0.33253172f, 0.31279975f, 
    0.28132841f, -0.04235607f, -0.14878753f, 0.21103708f, -0.06046310f, 0.28604847f, 0.14081492f, 0.05894954f, 
    0.01137143f, -0.02856373f, -0.02867385f, 0.01225862f, 0.02184038f, 0.03747883f, 0.04062264f, -0.06227475f, 
    0.09679193f, 0.17605869f, 0.14686921f, -0.09569056f, 0.00597385f, -0.07960668f, 0.06020704f, 0.15372343f, 
    -0.06969386f, -0.00004866f, -0.00842158f, 0.24478944f, -0.09404942f, -0.18822052f, 0.14769429f, -0.20485389f, 
    0.10721241f, -0.00038118f, -0.01334416f, 0.19509399f, 0.12454793f, 0.04119260f, 0.06092757f, -0.09902177f, 
    -0.14274715f, -0.03438906f, -0.04776140f, -0.05930374f, 0.15710087f, -0.03694674f, 0.29885602f, 0.07466239f, 
    -0.02444291f, -0.10703553f, -0.36666542f, -0.23903197f, 0.08046176f, 0.61548418f, 0.00265590f, -0.05594039f, 
    0.07652697f, 0.05527642f, -0.06020178f, -0.26890925f, 0.21128945f, -0.06323326f, 0.54229105f, -0.05024914f, 
    -0.03305237f, -0.02451292f, 0.13475017f, -0.19233210f, -0.19651502f, -0.31589133f, -0.27936706f, 0.16618110f, 
    0.06719694f, 0.32934093f, -0.15240787f, -0.09801506f, 0.01338126f, 0.25553003f, -0.01661761f, -0.02989360f, 
    -0.08388404f, 0.00385590f, 0.24375227f, -0.01988793f, 0.01367426f, 0.24161151f, 0.10266610f, -0.33248982f, 
    0.10774795f, -0.02938928f, 0.13077193f, -0.04270494f, -0.15841217f, -0.07359765f, -0.06235180f, -0.05743728f, 
    0.08440769f, -0.11391936f, 0.15987349f, -0.20610572f, 0.11921106f, 0.27679470f, 0.06952914f, 0.01114522f, 
    0.03150644f, -0.02711091f, 0.05297346f, -0.15206076f, -0.04030770f, -0.09343371f, 0.42867374f, 0.11783021f, 
    0.34255230f, 0.01982819f, 0.16952838f, 0.00777129f, -0.21860482f, -0.40461969f, -0.04603696f, 0.06734316f, 
    0.05544202f, 0.05610800f, -0.18067659f, 0.07390287f, 0.18156150f, 0.36444321f, 0.06513316f, 0.17362578f, 
    0.37491947f, 0.12112689f, 0.03401082f, -0.15840198f, -0.05982675f, 0.39409956f, -0.04061801f, 0.21500900f, 
    0.01672496f, -0.22308457f, 0.00124332f, 0.01047638f, 0.02314775f, -0.01042550f, -0.08287939f, -0.12325004f, 
    0.17138226f, 0.05720412f, -0.05870048f, -0.40396103f, -0.06445920f, 0.23989429f, 0.07632826f, -0.18834114f, 
    0.30942780f, 0.07856981f, -0.24975257f, 0.11958434f, -0.24787284f, 0.11385929f, 0.38835606f, 0.03675431f, 
    0.05813729f, -0.08048381f, 0.20920113f, -0.19212787f, -0.06373949f, 0.05052092f, 0.09323960f, -0.08341844f, 
    -0.09803733f, 0.03335827f, -0.41309556f, -0.26902875f, 0.00441939f, -0.01310066f, 0.01218654f, 0.09402932f, 
    -0.09509055f, 0.03350652f, -0.04820833f, 0.02022460f, -0.08855012f, 0.07610750f, -0.13545419f, -0.04510937f, 
    0.00295564f, 0.03182244f, 0.07602162f, 0.03724486f, 0.11182799f, -0.11072780f, 0.05769129f, -0.01911544f, 
    0.00188602f, -0.01244900f, -0.12990841f, -0.10543038f, -0.05449543f, -0.13909876f, 0.00903888f, 0.06988693f, 
    0.00852463f, -0.10172536f, 0.11570353f, -0.02262086f, -0.12641901f, -0.13941531f, -0.13096866f, 0.07738314f, 
    -0.04034176f, -0.01325268f, 0.03032787f, 0.06248216f, 0.10528349f, 0.04576784f, 0.00499599f, -0.06887822f, 
    0.04889677f, -0.02379881f, -0.12382341f, 0.01157695f, -0.02307141f, 0.00323084f, -0.05450843f, 0.02079121f, 
    0.07130469f, 0.03658012f, -0.00788349f, 0.04630657f, 0.09183179f, -0.06667851f, 0.03199169f, 0.08948492f, 
    0.01010625f, -0.02148587f, -0.06244971f, -0.02793533f, -0.04418248f, 0.06833770f, -0.03525703f, -0.13982311f, 
    0.00314841f, -0.06205392f, 0.00615875f, -0.02464263f, 0.03667739f, 0.04958491f, -0.01889041f, -0.07152729f, 
    0.05570801f, 0.09382060f, -0.11593220f, -0.09658830f, -0.10319832f, 0.02420403f, 0.04105523f, -0.10426244f, 
    -0.07772224f, -0.11077577f, -0.06219794f, -0.05273516f, -0.03571162f, -0.12306330f, 0.05693299f, -0.10869989f, 
    0.01034163f, -0.00744446f, 0.10607910f, 0.02112007f, -0.09302948f, 0.04049481f, -0.03327125f, -0.07519236f, 
    -0.04145515f, -0.04632209f, -0.07590419f, 0.05421108f, -0.07085893f, -0.02645914f, 0.05227266f, -0.11965650f, 
    -0.07044475f, -0.09125002f, -0.11900094f, 0.00488660f, -0.12314384f, 0.05808030f, -0.02503267f, 0.10430135f, 
    -0.00989398f, -0.09925573f, 0.01494287f, 0.07071079f, 0.05245957f, 0.01278973f, 0.03842534f, 0.00281814f, 
    -0.08565420f, -0.01423880f, 0.03859907f, -0.00296493f, -0.03396004f, -0.01952988f, -0.11322336f, -0.03408735f, 
    -0.17013942f, 0.06496418f, 0.21139802f, -0.01719522f, 0.18809369f, -0.02033442f, 0.07501577f, -0.06498498f, 
    0.05049958f, 0.14896110f, 0.34568787f, 0.03890218f, 0.08618721f, 0.20227206f, -0.30007470f, 0.15646310f, 
    0.01283546f, 0.05535464f, -0.00419828f, 0.34176230f, 0.11606715f, 0.09756786f, -0.17434265f, -0.04387420f, 
    -0.10006875f, 0.01282006f, 0.33265415f, -0.13470978f, 0.09068587f, 0.06705149f, 0.18556666f, 0.06045917f, 
    -0.08959567f, 0.02781813f, 0.04668909f, -0.05123411f, -0.02671537f, 0.29286936f, 0.10641048f, -0.10218745f, 
    -0.20178173f, -0.11545444f, -0.06823755f, 0.07380899f, 0.17401411f, -0.08705922f, 0.03622295f, -0.12998167f, 
    -0.10242078f, 0.05345763f, -0.23976323f, 0.45045072f, 0.15858653f, 0.15069620f, 0.18451889f, 0.10886671f, 
    0.16949229f, 0.03845277f, -0.12097608f, -0.08778555f, -0.02078703f, 0.08209250f, 0.13633026f, 0.11470030f, 
    0.02514206f, 0.10266559f, 0.05703066f, -0.01070648f, -0.05543630f, -0.00761905f, -0.04178332f, 0.00794418f, 
    -0.05336826f, -0.03905732f, -0.04109458f, -0.07943311f, -0.05697466f, -0.10482563f, 0.07308378f, -0.02733792f, 
    -0.03380836f, 0.10689858f, -0.07622562f, -0.06462941f, -0.11991922f, 0.05475314f, 0.05991821f, 0.06990810f, 
    -0.04673846f, -0.07219630f, -0.01475847f, -0.00502193f, -0.11766315f, -0.13299470f, -0.03812233f, 0.09140376f, 
    -0.11219302f, -0.10856942f, -0.14936844f, 0.08891511f, 0.02799799f, -0.08061398f, 0.02637531f, 0.07793170f, 
    -0.08781566f, 0.09589434f, -0.06770083f, -0.03526668f, -0.05099124f, 0.07088205f, 0.04054432f, 0.07240925f, 
    -0.01207022f, 0.04999238f, -0.02196773f, 0.04013136f, -0.04579965f, 0.09432713f, 0.04083212f, 0.05196670f, 
    -0.11750290f, 0.10335284f, -0.14887334f, -0.09066483f, 0.01865366f, 0.06424847f, 0.00047194f, 0.01392826f, 
    0.00966216f, -0.06820931f, -0.01065931f, -0.27605441f, 0.17013730f, -0.27252939f, -0.04725594f, -0.14045262f, 
    -0.02468039f, 0.03723507f, -0.10589574f, -0.03580385f, -0.02059484f, -0.11961590f, 0.16292141f, 0.38841403f, 
    0.15049718f, -0.10687473f, -0.04997822f, 0.17593572f, -0.09202012f, 0.15116070f, -0.09284744f, 0.18984756f, 
    -0.02549130f, 0.08067482f, 0.21953928f, 0.02150806f, 0.13403885f, 0.27002251f, 0.12207470f, 0.05453648f, 
    0.03095719f, 0.07144000f, -0.13804495f, -0.49074140f, 0.01510552f, -0.00013612f, -0.06551521f, 0.04936363f, 
    -0.14509864f, -0.06930938f, 0.31761971f, -0.13171376f, 0.23524159f, 0.00004125f, -0.13334839f, -0.05740431f, 
    -0.07531790f, -0.14058177f, -0.03829437f, -0.01880728f, 0.23385748f, 0.14640906f, 0.36347866f, -0.09960864f, 
    0.29531232f, 0.01797244f, 0.19567391f, 0.08720013f, 0.16643934f, -0.02502969f, -0.00889248f, 0.18361004f, 
    0.13921794f, 0.07207698f, 0.57398093f, -0.02733697f, 0.07372389f, 0.27290258f, 0.05598548f, -0.11807787f, 
    0.01189183f, 0.02768650f, 0.11089185f, -0.30142555f, -0.18524109f, -0.04680718f, 0.12610753f, -0.17159989f, 
    -0.34962839f, 0.10038954f, 0.30652544f, -0.00759237f, 0.05092463f, -0.16037382f, 0.01626812f, 0.07548980f, 
    0.06188835f, -0.17193085f, -0.09762887f, -0.12706539f, 0.32727599f, 0.31640828f, 0.21407187f, -0.08296828f, 
    -0.24751444f, -0.10276708f, 0.08405131f, -0.23033196f, 0.08506930f, 0.01270256f, 0.06966618f, 0.07996733f, 
    -0.05733277f, 0.02160889f, 0.28408143f, 0.05094730f, 0.02483267f, 0.17045695f, 0.18130773f, 0.16473877f, 
    0.02850953f, 0.04175705f, 0.15093105f, -0.11078187f, -0.01784736f, 0.20620880f, 0.26583910f, 0.08009660f, 
    0.19945934f, 0.13201243f, 0.30194387f, -0.10791703f, -0.10252204f, 0.02025175f, -0.06363164f, -0.09659886f, 
    -0.09020491f, 0.03862597f, -0.03035669f, -0.13879892f, -0.00630704f, 0.09224925f, -0.07727329f, 0.11328555f, 
    0.04211538f, 0.06716245f, 0.06606396f, 0.07637963f, 0.07236646f, -0.11594744f, -0.14307632f, -0.10555498f, 
    0.04533041f, 0.08815815f, -0.12025846f, -0.07719892f, -0.07364272f, -0.12259714f, -0.06206569f, -0.12772910f, 
    -0.08157721f, -0.04116911f, -0.04018433f, -0.12315468f, 0.02190920f, 0.07109766f, 0.04464846f, -0.02300505f, 
    -0.12450239f, 0.04041768f, 0.02621815f, 0.05320515f, -0.06285312f, 0.09828024f, 0.00939029f, -0.00395181f, 
    -0.01037865f, 0.02231742f, 0.06245301f, -0.06645312f, -0.10153838f, -0.10941922f, 0.08327243f, -0.02892545f, 
    0.03703584f, -0.09747826f, -0.08010055f, 0.07481009f, -0.13877524f, -0.04456857f, 0.04184244f, 0.03156644f, 
    0.09245405f, 0.06666043f, 0.01689593f, -0.00982721f, -0.08594032f, -0.12402162f, 0.10162491f, -0.03681739f, 
    0.00452186f, -0.03402691f, -0.45316544f, 0.02989685f, 0.03980840f, 0.15752384f, 0.07555697f, 0.15531386f, 
    0.11827236f, 0.14806657f, -0.04002945f, 0.00544493f, -0.09492335f, -0.03583384f, 0.09767260f, -0.02085535f, 
    0.24128711f, 0.12220344f, 0.07364840f, -0.09556743f, 0.13443294f, 0.30361792f, 0.34451720f, 0.14806347f, 
    0.03295388f, -0.21115312f, -0.16069958f, -0.12160072f, 0.38766387f, 0.09333366f, 0.10754807f, -0.00050914f, 
    0.03309445f, -0.00403749f, -0.21247873f, -0.18343140f, 0.22179489f, -0.23862226f, 0.08697505f, 0.38999432f, 
    0.24042134f, -0.02676605f, 0.14812751f, -0.01332033f, 0.24402547f, 0.36836016f, 0.31216609f, -0.00017353f, 
    -0.05087660f, -0.09257627f, 0.02063848f, 0.10208270f, 0.20219386f, -0.11549234f, 0.48003000f, 0.04775061f, 
    -0.04632504f, -0.03642256f, 0.20944138f, -0.22546697f, 0.01394482f, -0.00551248f, -0.34268335f, -0.08888543f, 
    -0.06848343f, 0.06909924f, 0.25871262f, -0.01885848f, -0.15720958f, -0.00944135f, -0.18966018f, 0.01669642f, 
    0.09177928f, 0.16155209f, 0.07834564f, 0.03926095f, 0.21510646f, 0.22165477f, -0.19151439f, 0.19133697f, 
    0.14019690f, -0.02652542f, -0.32065922f, -0.00193151f, -0.30571130f, 0.27207640f, 0.01969174f, 0.21636513f, 
    -0.04724468f, 0.28486603f, 0.18282793f, -0.01204690f, -0.02348557f, 0.31984034f, -0.13810354f, -0.08870883f, 
    0.03362004f, 0.06835110f, 0.09223644f, 0.02590984f, -0.18637531f, -0.14178093f, -0.08768421f, -0.09345931f, 
    0.23822765f, -0.19530223f, 0.12154895f, 0.10109191f, -0.06489166f, -0.17555988f, -0.04116913f, -0.21125416f, 
    -0.12008300f, 0.03460417f, -0.13312447f, 0.17800172f, -0.03802050f, 0.13068433f, 0.21455523f, 0.04853218f, 
    0.06690578f, 0.09941038f, 0.36271966f, -0.51657945f, 0.18003926f, -0.02770996f, 0.06400935f, 0.20559435f, 
    -0.03634954f, 0.02778049f, -0.11098784f, 0.07588332f, -0.00778333f, 0.00465493f, 0.10387158f, -0.11828452f, 
    -0.05942589f, -0.08050621f, -0.01236421f, 0.07185306f, -0.03018679f, -0.02121161f, -0.09166034f, 0.00041612f, 
    -0.02997953f, 0.02475882f, 0.06739808f, 0.01957203f, 0.00580751f, -0.05686573f, 0.06188963f, 0.05195519f, 
    0.08817798f, -0.00943072f, -0.11155760f, -0.06433306f, 0.00812354f, 0.08521674f, -0.01992350f, 0.09862036f, 
    -0.09891277f, -0.06905875f, 0.03631788f, -0.10182697f, -0.08974801f, -0.01658986f, 0.07347172f, 0.10301386f, 
    0.03075863f, 0.06969105f, 0.02274239f, -0.04043347f, 0.05293198f, 0.02731193f, -0.03362617f, 0.01128132f, 
    -0.05824247f, 0.07528585f, -0.00121074f, -0.02978363f, 0.10436912f, -0.00640240f, -0.14379591f, 0.09651172f, 
    -0.12910257f, 0.05493404f, -0.11219393f, -0.12504499f, -0.13883777f, -0.09069246f, 0.08322469f, 0.07647904f, 
    -0.19750397f, 0.09618372f, 0.27809417f, 0.01757009f, 0.20854691f, 0.20191522f, 0.15411390f, 0.06412426f, 
    0.09090766f, -0.18887977f, -0.12058506f, -0.27024868f, 0.46815822f, 0.20204403f, 0.07710036f, -0.10047752f, 
    0.15128048f, 0.11406735f, 0.17258893f, 0.13660951f, 0.32101640f, 0.16332577f, 0.03852341f, 0.30754921f, 
    0.11562129f, 0.24515332f, -0.06964763f, -0.04122327f, -0.07081178f, 0.39126313f, -0.16410449f, -0.07344852f, 
    -0.03506976f, 0.03513427f, -0.31081277f, 0.18727224f, -0.04664433f, -0.05172523f, 0.12337822f, -0.22804384f, 
    0.06157450f, -0.09839859f, 0.17556083f, 0.01673269f, 0.26676983f, 0.21259153f, 0.24311717f, 0.10707085f, 
    -0.00691563f, -0.04690315f, 0.05328152f, 0.15672161f, -0.02777028f, 0.11041164f, 0.42245078f, -0.05528681f, 
    0.09399962f, -0.06493796f, 0.50450838f, -0.31081343f, -0.30696228f, 0.08005111f, -0.18270731f, -0.14921005f, 
    -0.10649081f, 0.00075957f, -0.11918521f, 0.03094299f, 0.05091723f, 0.13735731f, 0.00675579f, -0.13073048f, 
    0.01874213f, -0.03957073f, -0.02621219f, -0.05089939f, 0.05962980f, -0.00591667f, 0.05476486f, -0.04108774f, 
    0.05519715f, -0.08256941f, 0.06912119f, -0.08906449f, -0.13002208f, 0.04710922f, -0.01010058f, 0.02578936f, 
    -0.09339286f, 0.04986970f, -0.03671039f, -0.07601986f, -0.07184270f, 0.05820327f, -0.09876265f, -0.01050166f, 
    0.08777785f, 0.01687926f, -0.05855354f, -0.12487210f, -0.10786024f, 0.11570989f, 0.09302257f, -0.09975334f, 
    -0.01708533f, 0.02892785f, -0.11337665f, -0.09689383f, -0.09561322f, -0.06109880f, -0.02311556f, -0.05237354f, 
    0.11691733f, -0.07418898f, -0.11164024f, 0.02197272f, -0.05666194f, 0.03704368f, -0.05203656f, -0.03943960f, 
    -0.03119583f, 0.09206046f, -0.11933462f, 0.00244503f, -0.06409420f, -0.11501539f, 0.02842022f, -0.09415804f, 
    0.03127063f, -0.08198786f, 0.19503970f, -0.14090554f, 0.01334307f, -0.04381774f, 0.12508366f, -0.08724067f, 
    -0.04808465f, 0.13144438f, 0.36340275f, -0.01045453f, 0.14732592f, 0.07617106f, 0.28645286f, 0.34699985f, 
    -0.01816070f, -0.06027132f, -0.05026806f, 0.06879233f, -0.06296682f, -0.12646645f, -0.32309204f, -0.15419833f, 
    -0.11617804f, 0.10938474f, 0.32730719f, 0.08419761f, -0.02277218f, -0.20018089f, 0.05183304f, 0.11198019f, 
    -0.09827013f, -0.01950028f, 0.60114962f, -0.02200631f, -0.08221969f, 0.29272777f, 0.04226638f, -0.18757083f, 
    -0.25273052f, 0.06488460f, -0.00424688f, 0.14274670f, -0.09427574f, -0.28122559f, -0.14095837f, -0.07723486f, 
    -0.06676014f, -0.04031181f, 0.12521142f, 0.00302305f, 0.03893446f, 0.24167299f, -0.46557117f, -0.02359509f, 
    0.03005052f, -0.10903437f, -0.29462665f, 0.21354994f, 0.29050168f, -0.06624360f, 0.66587967f, 0.20306282f, 
    0.16581267f, 0.02371019f, 0.58642340f, 0.26621699f, -0.24983621f, 0.13923916f, 0.10300078f, -0.09500571f, 
    -0.07813372f, 0.22513211f, 0.35874632f, -0.07778112f, -0.32414535f, 0.16181938f, -0.16307895f, -0.03435603f, 
    -0.05208740f, 0.05890131f, -0.24300872f, 0.09460261f, -0.18828315f, -0.04661333f, 0.02671059f, 0.21811187f, 
    0.16120499f, 0.05528478f, 0.09341822f, -0.00539136f, 0.30290633f, 0.21429560f, 0.04065120f, -0.12424287f, 
    0.13662177f, -0.06382772f, 0.16627961f, 0.18818879f, 0.11040524f, -0.18454072f, -0.01864324f, 0.09148227f, 
    0.11817317f, 0.04429698f, -0.12031846f, 0.11381902f, -0.07763306f, -0.11056527f, 0.35479707f, 0.23405120f, 
    -0.01496950f, -0.02063343f, 0.09151548f, 0.30496851f, -0.06328579f, -0.00700481f, -0.08036534f, -0.12668954f, 
    -0.22383761f, -0.09759958f, 0.15767099f, -0.23245865f, -0.10519166f, 0.08999090f, 0.03581120f, -0.00931689f, 
    -0.18104184f, -0.00824031f, 0.38613102f, 0.03164423f, 0.24164599f, 0.11144939f, 0.33168766f, 0.15340772f, 
    -0.02278605f, -0.21120410f, 0.18660378f, -0.14165072f, 0.26219851f, 0.16495661f, 0.04044009f, -0.20002931f, 
    -0.11116804f, -0.11719279f, -0.07142069f, 0.15427728f, 0.10294440f, -0.05647754f, 0.03452060f, 0.14509842f, 
    0.00772969f, 0.29206061f, 0.21368074f, 0.12912664f, 0.03820519f, 0.04460628f, 0.07175937f, -0.02833825f, 
    0.01274209f, -0.01269374f, 0.01122877f, 0.49561378f, -0.12224624f, -0.11007024f, 0.09468980f, -0.22271058f, 
    -0.02571577f, 0.05383501f, 0.10141772f, -0.06152220f, 0.29752079f, 0.04150880f, 0.16558324f, -0.09359796f, 
    0.05262610f, -0.04853012f, -0.14850198f, 0.36983883f, -0.00835289f, 0.24949276f, 0.18996656f, 0.07125239f, 
    0.12962811f, 0.12543020f, 0.51685464f, -0.01075160f, -0.14334355f, 0.03975448f, -0.03982976f, 0.01354535f, 
    0.01013702f, -0.10202138f, -0.26826659f, 0.06345249f, -0.14964345f, -0.35539261f, -0.18938853f, -0.09312057f, 
    -0.01339428f, 0.12702641f, -0.07953336f, 0.26352978f, 0.03035378f, -0.18355986f, -0.13808230f, 0.39718232f, 
    0.09072114f, -0.10640398f, 0.02546019f, 0.10310767f, -0.20109424f, 0.02077284f, -0.26219299f, 0.13975766f, 
    0.05093834f, -0.22964165f, 0.15074061f, 0.05790623f, -0.17778763f, 0.20694819f, 0.21358290f, 0.03670889f, 
    0.16137932f, -0.08777026f, 0.28753683f, 0.00662667f, 0.28499505f, 0.20443566f, 0.11859767f, 0.14260097f, 
    -0.07511085f, 0.01637718f, 0.05198573f, 0.14768593f, 0.01123763f, -0.28865328f, -0.06677850f, 0.04566577f, 
    0.07070623f, 0.02799928f, -0.05547055f, 0.11008121f, 0.20104329f, -0.02724648f, 0.08627846f, -0.01328362f, 
    0.11131026f, 0.09145436f, -0.12392274f, 0.36948374f, 0.00965650f, 0.07294264f, 0.26955861f, -0.00926098f, 
    0.03384984f, 0.02063774f, -0.10888344f, 0.00246083f, 0.08748706f, 0.03945125f, 0.06771949f, -0.05040825f, 
    -0.07896894f, 0.07214290f, -0.08712453f, -0.00520359f, 0.07163586f, -0.14657031f, 0.03263801f, 0.04253059f, 
    -0.06444012f, -0.01719020f, -0.06145255f, 0.08197263f, -0.00626148f, -0.07854190f, -0.04506075f, 0.02608020f, 
    0.03766564f, -0.11359440f, -0.01448594f, -0.02447183f, 0.07436969f, -0.05611225f, -0.01627196f, -0.11614963f, 
    -0.06239791f, 0.09806867f, -0.09760368f, 0.06322002f, -0.14563803f, -0.01510099f, -0.06511071f, 0.07601481f, 
    -0.15010698f, -0.09760176f, -0.04318157f, -0.10326515f, 0.00020762f, -0.14730571f, -0.05135214f, -0.08364768f, 
    0.08698483f, -0.07587068f, 0.04958892f, -0.01503209f, -0.11528874f, 0.00252885f, -0.12564048f, -0.08016255f, 
    0.04117871f, -0.12445474f, 0.02438094f, 0.01523955f, -0.09590448f, -0.09175142f, 0.10391827f, -0.10851481f, 
    -0.09115158f, 0.10744114f, 0.09444046f, -0.10705864f, 0.11237630f, -0.07111968f, -0.07136839f, 0.04655812f, 
    -0.02480825f, -0.11184516f, -0.00375164f, 0.05722910f, -0.11253463f, -0.03448419f, 0.00761566f, 0.03785918f, 
    -0.11435935f, -0.10256900f, -0.10583594f, -0.12626278f, -0.12553687f, -0.02070168f, -0.12458716f, -0.08862238f, 
    -0.01834735f, 0.09817538f, -0.01151939f, 0.04779958f, 0.06741334f, -0.08462475f, 0.01558501f, 0.05638902f, 
    -0.09682717f, -0.00992399f, 0.05259280f, 0.02252317f, -0.07450162f, 0.10934076f, -0.05567374f, 0.01282561f, 
    0.02823693f, -0.09585345f, 0.08246042f, 0.01216235f, 0.08422925f, -0.05320287f, 0.08053543f, -0.07406606f, 
    0.06959017f, 0.02455908f, -0.00094720f, 0.02879757f, 0.02808930f, -0.04411882f, -0.03778878f, 0.07914821f, 
    0.05621594f, -0.05137252f, -0.09160480f, 0.02197803f, -0.11039506f, 0.10937034f, -0.04033522f, 0.01312105f, 
    -0.17015874f, -0.09072752f, -0.14650573f, 0.12275843f, 0.35943261f, -0.02265827f, 0.26082873f, 0.06866882f, 
    -0.13019951f, -0.12714845f, -0.05142955f, -0.02895296f, 0.44084638f, 0.14836782f, -0.07818992f, 0.04325240f, 
    0.00450277f, -0.08268492f, 0.01300716f, 0.25754660f, 0.24007238f, 0.05599318f, -0.05582054f, -0.09020972f, 
    -0.09978840f, 0.27529517f, 0.23168601f, 0.06804775f, -0.24389195f, -0.20774111f, 0.06614470f, -0.06671664f, 
    0.08681040f, 0.05503846f, -0.26085454f, 0.21272661f, -0.07224079f, 0.02980196f, -0.03460060f, -0.13791056f, 
    -0.25207976f, 0.01461930f, -0.09433049f, 0.03335422f, 0.14755367f, 0.29138291f, -0.06494083f, -0.07511930f, 
    0.03405824f, -0.04097114f, -0.06370529f, 0.18417647f, 0.02537568f, 0.15983626f, -0.10838696f, 0.04302364f, 
    0.08995122f, -0.05148454f, 0.17059872f, 0.27336690f, 0.01850947f, -0.04720428f, -0.03933981f, -0.09923153f, 
    -0.00165227f, 0.07089871f, -0.00334177f, 0.09037010f, 0.09094703f, -0.12311770f, 0.02798101f, -0.05587387f, 
    -0.00802833f, -0.11482502f, -0.09515320f, -0.00343398f, -0.01219252f, 0.04674919f, -0.11922244f, -0.09068358f, 
    -0.14308038f, 0.04533716f, 0.03444776f, -0.07603955f, -0.12704383f, -0.11461353f, -0.01796103f, -0.06060350f, 
    0.02743948f, 0.09465420f, -0.05242553f, 0.11488824f, 0.08052186f, 0.08906749f, -0.03608305f, -0.05133551f, 
    -0.12699285f, -0.04187028f, -0.02128834f, -0.13190688f, -0.11876953f, -0.12646587f, -0.07474207f, -0.09829587f, 
    -0.09221344f, -0.11090724f, 0.02871392f, 0.06518508f, -0.06177149f, -0.01932787f, 0.05283074f, 0.00447215f, 
    0.06003042f, -0.10401234f, 0.08148694f, 0.06739154f, -0.02890778f, 0.00197084f, 0.04155153f, -0.09296731f, 
    0.05006324f, -0.09289478f, 0.05904989f, 0.08611680f, 0.05725284f, -0.04219703f, 0.04145119f, -0.00766606f, 
    -0.04837158f, -0.01767075f, -0.31704232f, 0.05067143f, -0.04916347f, -0.13395090f, -0.34525532f, -0.01281229f, 
    0.08555873f, 0.06768575f, -0.32724428f, -0.00817324f, 0.33895892f, 0.12431485f, 0.23704445f, 0.06474060f, 
    0.16166383f, -0.01686628f, 0.12327152f, -0.11802591f, 0.20073996f, 0.15015434f, 0.08875774f, 0.25287080f, 
    0.03895102f, 0.05865240f, -0.18823379f, 0.06411684f, -0.04628028f, 0.40917829f, -0.09081593f, -0.06002140f, 
    0.18126763f, 0.07170822f, -0.15420283f, 0.21375443f, 0.20860994f, -0.00353504f, -0.08989967f, -0.15034296f, 
    0.29438636f, -0.05844462f, 0.20478594f, -0.09579235f, 0.13443750f, -0.15604575f, 0.05551662f, 0.00670736f, 
    0.10121307f, -0.06595415f, -0.15119097f, -0.06689096f, 0.20393389f, -0.01780429f, 0.35085827f, -0.02107608f, 
    0.12528059f, -0.00738885f, 0.15696542f, -0.08086946f, 0.02696118f, 0.05524561f, -0.27119780f, 0.17677052f, 
    0.36142272f, 0.08457901f, 0.03807319f, 0.23716243f, 0.09761230f, 0.10748366f, 0.26209351f, 0.26444060f, 
    0.07361421f, 0.30165887f, 0.32573211f, 0.33002448f, -0.08779269f, 0.18130986f, 0.13735417f, -0.25874561f, 
    -0.08804011f, -0.05548841f, -0.17685892f, -0.03100694f, -0.06988422f, 0.20373823f, 0.32224217f, -0.06922982f, 
    -0.05123378f, -0.09272168f, 0.15398364f, 0.04055253f, 0.23611014f, -0.31503668f, 0.12581645f, 0.06726722f, 
    -0.01942515f, 0.04195950f, 0.04062015f, -0.14240240f, -0.00293085f, -0.01444608f, -0.10415013f, 0.30055654f, 
    0.20229843f, 0.11394424f, -0.16505942f, 0.24035260f, -0.09689958f, 0.26981261f, 0.39039844f, 0.08165344f, 
    0.03420703f, -0.07364716f, 0.13953376f, 0.05214701f, -0.25734124f, 0.07066754f, -0.26638195f, -0.07329924f, 
    -0.24091795f, 0.05451903f, -0.06546225f, -0.10530803f, -0.02697762f, -0.08787729f, 0.12674470f, 0.09977946f, 
    0.04719052f, -0.01904085f, 0.52549976f, 0.20274946f, 0.09738414f, 0.14115329f, 0.42445514f, 0.10215441f, 
    -0.11452740f, 0.06556204f, 0.45775405f, 0.04510322f, -0.00717147f, 0.14266890f, -0.22699311f, -0.16298565f, 
    -0.23362547f, 0.05283591f, -0.15039101f, 0.25297457f, 0.16030541f, -0.25730708f, 0.08741391f, -0.18274088f, 
    0.01988588f, 0.16883147f, 0.05792194f, -0.06554716f, -0.09767921f, -0.27390754f, 0.12114177f, -0.07906593f, 
    -0.02450443f, 0.07841397f, 0.22292824f, 0.47072417f, 0.09490912f, 0.16146243f, -0.06401907f, -0.09919214f, 
    -0.22843030f, 0.09133811f, -0.15276879f, 0.18316935f, 0.11917770f, 0.03462913f, 0.17405213f, 0.19459440f, 
    -0.10452596f, -0.12234070f, 0.12878881f, 0.22241350f, -0.13695848f, 0.06906903f, -0.20514818f, 0.06797828f, 
    0.03849585f, 0.04300100f, -0.01972374f, -0.01541602f, 0.10975283f, 0.04693592f, 0.11835564f, -0.09118200f, 
    0.27824402f, 0.03133191f, -0.39664167f, 0.09273020f, 0.04634918f, 0.26371372f, 0.08252102f, -0.02458349f, 
    -0.02674129f, 0.26053539f, 0.04743953f, 0.27301666f, 0.03089823f, 0.21729328f, -0.13038516f, -0.02431018f, 
    0.25387383f, -0.09839603f, -0.24501267f, 0.08937932f, -0.10384389f, 0.30025083f, 0.23899904f, -0.10714880f, 
    0.08635137f, 0.05090128f, 0.25880775f, 0.02698234f, 0.13888817f, -0.07194237f, 0.06602260f, 0.01560322f, 
    0.04845360f, -0.06525267f, 0.07238958f, -0.30595168f, 0.13968708f, 0.21676092f, 0.08810499f, 0.35260063f, 
    -0.10398881f, 0.05885062f, -0.14788319f, 0.07435622f, -0.04130197f, 0.30017951f, 0.03974377f, -0.20613134f, 
    -0.11777273f, 0.03322553f, 0.01035291f, 0.10739912f, 0.03313050f, -0.04766289f, -0.16958047f, -0.09115501f, 
    -0.08360785f, 0.04281339f, -0.34313822f, 0.02936898f, 0.03439481f, 0.10088862f, -0.00063207f, 0.08360579f, 
    -0.23704275f, -0.08561257f, 0.15858875f, 0.22965038f, 0.10055941f, 0.10703529f, 0.22880308f, -0.00533053f, 
    -0.01840692f, 0.21337892f, 0.36692089f, -0.00415116f, -0.16072683f, 0.17172256f, -0.48442698f, 0.06445026f, 
    -0.05889412f, -0.03023466f, -0.20051646f, 0.27541500f, 0.07326165f, 0.00009144f, 0.20525664f, -0.17303395f, 
    -0.11160187f, 0.05065379f, 0.31720841f, -0.06703368f, 0.05125974f, 0.03435533f, 0.26984388f, 0.00621808f, 
    0.00533433f, 0.01642892f, 0.07239937f, 0.00055637f, 0.02465325f, -0.02637675f, 0.06809443f, 0.37272474f, 
    -0.23173919f, -0.10588069f, -0.03345769f, 0.23675311f, 0.26493916f, 0.10171165f, 0.02051710f, -0.35532445f, 
    -0.04789218f, -0.08232894f, -0.33499715f, 0.47724253f, 0.00717888f, -0.06051474f, 0.18235151f, 0.02948273f, 
    0.02716537f, -0.10470339f, 0.17637394f, 0.05687355f, 0.03301635f, -0.02688277f, 0.12933776f, 0.03683341f, 
    -0.21827899f, 0.11455005f, 0.05893804f, 0.04595217f, -0.02909532f, -0.03574394f, -0.05594467f, 0.00890044f, 
    0.08169597f, -0.14932935f, -0.24422529f, -0.11692607f, 0.11015087f, -0.11874443f, 0.19205271f, 0.12192669f, 
    0.06836747f, 0.12350439f, 0.15623778f, 0.14869775f, 0.21231298f, -0.11588515f, -0.13081563f, 0.37301272f, 
    -0.04560085f, 0.13804233f, -0.00519450f, -0.00836472f, -0.26901987f, 0.32555595f, -0.14904290f, 0.07794368f, 
    0.13086656f, 0.04660334f, -0.18604501f, 0.47075656f, 0.17451194f, -0.27154902f, -0.08360760f, -0.06983768f, 
    0.23798321f, 0.12858061f, 0.26113695f, -0.19668975f, 0.21608001f, -0.19274002f, 0.14329398f, 0.26762837f, 
    -0.03288257f, -0.03428446f, -0.00070832f, 0.01163898f, 0.17355968f, 0.07962412f, 0.22561532f, 0.01165843f, 
    0.13828659f, 0.12612985f, 0.45318469f, -0.06980425f, -0.17075700f, 0.00480650f, -0.15576930f, 0.04055471f, 
    0.39593521f, 0.10219082f, -0.77100539f, 0.05992661f, -0.00109718f, 0.05111853f, -0.17881194f, 0.16887271f, 
    0.04042665f, 0.16604461f, -0.27174008f, 0.01483513f, -0.12377957f, -0.04256931f, 0.40396237f, 0.12903562f, 
    0.05899637f, 0.00179265f, 0.37929720f, -0.21733071f, 0.12686412f, 0.10327177f, 0.12312628f, 0.10447753f, 
    -0.05824895f, -0.06089381f, -0.05444318f, -0.00309266f, -0.03417424f, -0.22005171f, 0.07289241f, 0.07622235f, 
    -0.01977102f, -0.09314008f, 0.09433594f, -0.16725615f, 0.32448244f, 0.19450581f, 0.04435530f, 0.22661471f, 
    0.28856817f, 0.07629165f, 0.10202401f, -0.01172768f, -0.05060011f, 0.18475333f, 0.05803096f, 0.27079657f, 
    0.09190328f, 0.09077750f, 0.25774017f, -0.52317488f, 0.11208027f, -0.08133554f, -0.20200357f, 0.06325847f, 
    0.05252863f, 0.03898330f, -0.24767001f, 0.31463209f, 0.07891198f, 0.04663809f, -0.09989676f, 0.01655841f, 
    0.03095057f, 0.10785353f, 0.03277761f, -0.09466865f, -0.06734747f, -0.00765105f, 0.00942338f, -0.01837734f, 
    0.04526471f, 0.10015294f, 0.03736198f, -0.05537884f, -0.11513792f, -0.13693307f, 0.00036615f, 0.07378091f, 
    -0.13638191f, -0.02851795f, 0.02500077f, 0.03896124f, -0.10814654f, -0.04519391f, 0.05161699f, -0.13234538f, 
    -0.06921023f, 0.06014575f, -0.08252852f, -0.03140984f, -0.01808956f, -0.04368933f, 0.09923701f, -0.01562048f, 
    0.10069849f, -0.11325189f, -0.02027105f, -0.06097509f, 0.01603042f, -0.10663295f, -0.07358152f, 0.09179691f, 
    0.02688693f, 0.02504987f, 0.03648954f, 0.09600874f, -0.01037222f, -0.12799245f, 0.05331221f, 0.00057713f, 
    -0.01615651f, -0.10898663f, -0.10944983f, 0.02042442f, -0.11586126f, -0.04633248f, -0.13784316f, 0.05680855f, 
    0.02590967f, 0.09994826f, -0.10040747f, -0.11182148f, 0.01280735f, 0.10948311f, 0.04160003f, 0.04638086f, 
    0.04224090f, 0.12749963f, 0.00844383f, 0.06918925f, 0.11980039f, -0.11265498f, 0.13670096f, 0.05728320f, 
    -0.04947765f, 0.01006131f, -0.20278241f, -0.03897982f, -0.10062993f, 0.12165257f, 0.04370520f, -0.26810029f, 
    -0.08025276f, -0.11878794f, -0.17944786f, 0.02059994f, 0.13139473f, 0.17844662f, 0.48858991f, -0.05359658f, 
    0.14396399f, 0.13324688f, -0.10344153f, 0.01729279f, -0.12011997f, -0.29542351f, -0.22108668f, -0.03828461f, 
    0.10968022f, 0.01845283f, -0.07409714f, 0.20525980f, -0.15292197f, -0.41639531f, -0.11901132f, 0.07546636f, 
    0.09855619f, -0.02927177f, 0.03730525f, 0.05376734f, 0.13788946f, 0.16663130f, 0.38413036f, -0.05795759f, 
    0.03877507f, -0.11236008f, 0.00830110f, 0.07343585f, -0.00799476f, -0.13745748f, -0.06998807f, 0.01831007f, 
    -0.04849864f, -0.00417876f, 0.36091959f, -0.26371694f, 0.14231120f, -0.03720155f, -0.21450442f, -0.07631529f, 
    0.09784450f, 0.04376341f, 0.29454800f, -0.17617585f, 0.30754721f, 0.18075174f, 0.14106819f, 0.08862955f, 
    0.00310583f, -0.07506948f, -0.06732637f, -0.18966153f, 0.26123187f, -0.05891665f, 0.29408640f, 0.15064552f, 
    -0.13632756f, -0.02293435f, 0.30771121f, 0.16915393f, 0.23461673f, -0.10603116f, -0.20189765f, -0.09344082f, 
    0.11583252f, 0.03564854f, 0.10597152f, -0.07335992f, -0.28758046f, 0.04335177f, 0.01911471f, -0.08329669f, 
    -0.14610015f, -0.08021512f, 0.04776540f, -0.04823627f, -0.07792919f, 0.12863667f, 0.08042165f, -0.29678768f, 
    -0.16681935f, -0.05138104f, 0.19196959f, -0.03219203f, 0.14783317f, 0.09138156f, -0.08638882f, 0.17279923f, 
    0.03201781f, -0.05661714f, 0.05177879f, -0.14861453f, 0.07461280f, 0.31477833f, -0.02198506f, -0.05050454f, 
    0.18228278f, 0.11308751f, -0.17773405f, 0.24909635f, 0.08323627f, -0.01393156f, 0.28262818f, 0.05812528f, 
    0.12153958f, -0.01722661f, 0.14762925f, -0.05822022f, 0.03312983f, 0.44251740f, 0.12710379f, 0.02177175f, 
    0.00145521f, 0.23545942f, 0.10623803f, -0.16115610f, -0.59888190f, -0.26711518f, 0.00940100f, -0.12815814f, 
    -0.23524709f, 0.09393291f, 0.08549473f, 0.10322298f, -0.12778403f, -0.16075405f, -0.11776718f, 0.06436305f, 
    0.14334616f, -0.23840879f, -0.15193062f, 0.00440998f, 0.25311482f, 0.28156137f, 0.26391572f, -0.10932840f, 
    -0.33470824f, -0.06865481f, 0.26866433f, -0.18463403f, 0.27251765f, -0.28359005f, -0.07403290f, 0.11403371f, 
    -0.00952730f, 0.03806670f, 0.38413265f, 0.11506906f, 0.12616727f, -0.16871990f, -0.14133450f, 0.24595118f, 
    0.04873626f, 0.00172504f, 0.09668913f, 0.11383531f, 0.29834670f, 0.13047475f, 0.19305716f, -0.09155507f, 
    0.30544257f, 0.02072823f, 0.17786032f, 0.20455705f, -0.02458569f, 0.03862624f, 0.03137894f, -0.09368625f, 
    0.17538254f, 0.00477126f, 0.12341664f, 0.28141475f, -0.19830383f, 0.11093368f, 0.10579827f, 0.09991750f, 
    0.10591057f, 0.01247221f, -0.07885662f, 0.17830898f, -0.02522949f, 0.20829511f, 0.08568893f, -0.21814010f, 
    0.13049687f, -0.08847356f, -0.32816130f, -0.09993157f, 0.00532810f, 0.11881449f, 0.17287795f, -0.08361346f, 
    -0.06436872f, 0.27708656f, -0.01421191f, -0.09130156f, -0.07864449f, -0.10761224f, -0.06898751f, -0.11596823f, 
    0.35108393f, -0.06618514f, 0.05000350f, 0.28554842f, -0.10811939f, -0.31031227f, -0.10454667f, -0.04540737f, 
    0.22010991f, -0.04331026f, -0.17099367f, 0.17447191f, 0.01678558f, 0.11168120f, 0.44775513f, 0.14360191f, 
    0.01167646f, 0.03001840f, 0.17497195f, 0.10449407f, -0.15531297f, -0.04779561f, -0.21997482f, -0.06350573f, 
    -0.12320677f, -0.04522092f, 0.34524643f, -0.40872213f, 0.19490007f, 0.11732226f, -0.14017364f, 0.12613243f, 
    -0.19095279f, 0.00248164f, 0.19295458f, -0.05996694f, 0.30827710f, -0.32121822f, 0.26017937f, 0.09213877f, 
    -0.07422078f, -0.16631438f, 0.06728376f, -0.00354682f, 0.38429952f, -0.03222016f, 0.06509445f, 0.04392992f, 
    -0.10420854f, -0.02494223f, 0.05495688f, 0.24640360f, 0.18562332f, -0.09478159f, -0.22050016f, -0.05148900f, 
    -0.12652516f, 0.20737834f, 0.22484766f, -0.03405709f, -0.25074667f, -0.06809254f, -0.02172356f, 0.12715089f, 
    -0.06978121f, 0.01087698f, 0.07975484f, 0.31504479f, 0.08534973f, 0.26726699f, 0.04161553f, -0.38230622f, 
    -0.09224652f, -0.02150830f, 0.14726505f, -0.01954124f, 0.08650077f, 0.10770717f, -0.26376230f, -0.06480248f, 
    -0.02489010f, -0.01055346f, 0.13023521f, 0.13424289f, -0.00684679f, 0.26596612f, 0.07606130f, -0.10045736f, 
    0.15986899f, 0.04813419f, 0.14560863f, 0.08811201f, -0.00279064f, 0.09785832f, 0.23081413f, -0.01152905f, 
    0.24012606f, -0.11302501f, -0.14524201f, 0.10886257f, -0.18774661f, 0.25625211f, 0.12444285f, -0.07602881f, 
    -0.08189043f, 0.25854361f, 0.13291106f, 0.05719648f, -0.09699163f, 0.07847203f, -0.19436872f, -0.14407891f, 
    0.20726366f, 0.01663129f, -0.20137285f, -0.02257639f, -0.26536068f, 0.12998539f, 0.24795911f, 0.10023274f, 
    -0.09184591f, -0.04462190f, -0.10930251f, -0.11002500f, 0.57604820f, 0.13901031f, 0.00016621f, 0.04483426f, 
    0.02645734f, 0.03108380f, -0.03717985f, -0.34917295f, 0.09329791f, 0.16687608f, -0.08694547f, 0.26755282f, 
    0.16423537f, 0.11463046f, -0.16304600f, 0.19959949f, -0.17190614f, 0.13041627f, 0.26635292f, 0.10041133f, 
    -0.10582685f, -0.05195478f, 0.13548853f, 0.01788517f, -0.15147437f, 0.08085038f, 0.05837760f, 0.06630831f, 
    -0.33178335f, 0.04928355f, -0.26406735f, -0.24281622f, -0.02499972f, 0.07185125f, 0.02539758f, 0.14965251f, 
    0.06980237f, -0.07175403f, 0.08698745f, -0.10011651f, -0.10123380f, 0.10231376f, 0.07023734f, -0.04384436f, 
    -0.08711049f, 0.00888034f, 0.04154376f, -0.11125658f, 0.02221086f, -0.08452328f, -0.11566810f, -0.11478986f, 
    0.01983070f, 0.02996354f, -0.09785770f, 0.06762262f, 0.06739651f, -0.06232508f, -0.03417820f, 0.04814991f, 
    0.02195670f, 0.08195310f, -0.15834956f, 0.03700785f, 0.03780418f, 0.02851852f, -0.01698770f, -0.03438303f, 
    -0.04518611f, -0.09304152f, -0.08813862f, 0.05173921f, 0.03124778f, 0.03686799f, 0.11028769f, 0.01715748f, 
    0.03332463f, 0.04402621f, -0.13626096f, -0.08804654f, 0.02096431f, 0.00340287f, 0.06729351f, -0.09264349f, 
    0.03807457f, -0.00237432f, -0.07003078f, -0.08719371f, -0.03148937f, -0.02089662f, -0.06943946f, -0.02055408f, 
    -0.07947170f, 0.08813034f, 0.06470349f, 0.07399040f, -0.09792445f, 0.06313908f, -0.10614972f, -0.09624918f, 
    0.19812122f, -0.09219085f, -0.30331761f, -0.11254871f, -0.13449940f, 0.02974995f, -0.17147525f, 0.11644355f, 
    0.10328405f, 0.34577513f, -0.08863574f, 0.22042443f, 0.05494984f, 0.03117892f, 0.31310433f, 0.46266639f, 
    0.31974143f, -0.10209601f, -0.09926000f, -0.12586348f, -0.26259464f, 0.20804335f, -0.18097292f, 0.04341562f, 
    -0.11048566f, 0.10220449f, 0.01730816f, 0.02556499f, 0.00493908f, 0.06995819f, -0.03756265f, -0.09834830f, 
    0.20528276f, 0.00407216f, 0.26592711f, -0.40930903f, -0.03679527f, 0.03157336f, 0.06665500f, 0.19424132f, 
    -0.02415860f, -0.05983763f, -0.02572584f, 0.02839891f, -0.08713353f, -0.02458150f, -0.03189173f, 0.08701082f, 
    -0.09620078f, -0.00300689f, 0.25508446f, -0.07250237f, 0.13265732f, -0.05124690f, -0.12654707f, -0.05696560f, 
    0.12567765f, -0.01288651f, -0.13246961f, 0.15827501f, 0.40202409f, 0.05626992f, 0.28909934f, 0.29339540f, 
    0.21124373f, 0.08637914f, 0.07136200f, 0.04748965f, 0.01744019f, -0.37760475f, -0.01228362f, 0.21517228f, 
    0.04108184f, 0.08787192f, -0.23514703f, 0.07546228f, 0.14688322f, 0.08857714f, 0.47623053f, 0.15360518f, 
    0.17843923f, -0.00469041f, 0.28326669f, -0.29030094f, -0.09458960f, -0.03302430f, -0.04462580f, 0.15387692f, 
    0.10323039f, 0.04419930f, 0.04811808f, -0.06999987f, -0.19763653f, 0.00605641f, -0.17574440f, -0.07251289f, 
    0.29764318f, 0.08171932f, 0.18335128f, 0.10707426f, 0.14466065f, 0.16772641f, -0.05223012f, -0.35699478f, 
    0.26266089f, 0.06446784f, -0.02999096f, 0.04232745f, -0.22832119f, -0.13369699f, 0.15238221f, 0.30778965f, 
    0.05017121f, -0.05086494f, 0.45236975f, -0.32005730f, -0.02858769f, 0.07338510f, -0.06979282f, -0.00775136f, 
    -0.03425810f, -0.08731548f, -0.15830006f, 0.02067780f, -0.05207719f, -0.01292025f, -0.04328779f, 0.15694220f, 
    -0.14979914f, -0.04540274f, -0.05467023f, -0.11930073f, 0.05387791f, -0.08015560f, 0.00222620f, 0.05040796f, 
    -0.01091839f, -0.15262108f, -0.08549236f, -0.10525697f, 0.15464215f, -0.00118404f, 0.10365821f, -0.02684391f, 
    0.00525105f, 0.04529697f, 0.06778038f, 0.09812270f, 0.07626700f, 0.05512964f, 0.04506440f, 0.08501708f, 
    0.03558027f, 0.21544224f, -0.06664006f, -0.01195150f, 0.03014569f, 0.32197267f, -0.06115858f, -0.04203939f, 
    0.02170326f, -0.08106456f, -0.17455252f, 0.36900267f, 0.02584376f, -0.43140224f, -0.00335069f, -0.01769308f, 
    0.14646013f, 0.08010370f, 0.33495089f, -0.01665740f, 0.26804501f, -0.01439667f, -0.01639857f, 0.06434169f, 
    0.05001444f, 0.01402976f, -0.21792109f, 0.21495888f, 0.27874210f, 0.19812660f, 0.32755846f, -0.04820790f, 
    0.28580788f, 0.11516494f, 0.71984369f, -0.19442150f, 0.10759914f, -0.08427545f, -0.37086180f, -0.08668742f, 
    0.27807975f, 0.04893186f, 0.46043345f, 0.09826023f, -0.22861907f, -0.30406961f, 0.00270500f, 0.10695466f, 
    -0.10596908f, 0.10422277f, -0.31614333f, -0.07446210f, -0.28311563f, 0.00131256f, 0.05052295f, 0.03104092f, 
    0.04090985f, -0.07800384f, 0.18547851f, -0.14197981f, -0.14128070f, 0.09284952f, 0.07744806f, 0.31603369f, 
    -0.01400887f, -0.37806204f, -0.12725846f, -0.03628543f, -0.17815432f, -0.03928154f, 0.11772262f, 0.11705620f, 
    0.11392518f, -0.05073674f, -0.18228990f, -0.27597392f, 0.17367211f, -0.26566342f, 0.07080871f, 0.13684273f, 
    0.17401470f, -0.09234039f, 0.07296895f, -0.05106176f, -0.17191589f, 0.17235537f, 0.36513337f, 0.52059126f, 
    -0.06913050f, 0.03429089f, 0.32314929f, -0.10672081f, 0.13436078f, -0.19252127f, 0.00344030f, -0.04600427f, 
    0.04160580f, 0.06596934f, 0.01705952f, 0.01674264f, -0.12182226f, -0.02645675f, -0.38166893f, 0.09694519f, 
    0.08642526f, -0.00109749f, -0.39573386f, 0.10166518f, 0.18681332f, 0.01220133f, 0.16801482f, 0.15895855f, 
    -0.07000879f, 0.25973260f, 0.46348897f, 0.33449507f, -0.20536110f, 0.02838876f, -0.19204463f, -0.12314755f, 
    -0.07626817f, -0.04316983f, -0.36257249f, 0.17290241f, -0.04878755f, 0.04517458f, 0.32023233f, -0.39677423f, 
    -0.02339185f, 0.13090545f, 0.22674896f, 0.01787603f, 0.17129792f, -0.12857489f, 0.32340011f, -0.05761166f, 
    -0.05984794f, 0.12944403f, 0.37005994f, 0.18177302f, 0.08578158f, -0.02032063f, -0.05237409f, 0.24359773f, 
    -0.13068527f, 0.05834261f, -0.05896498f, 0.26119259f, 0.07000066f, -0.03251274f, -0.02348110f, -0.23771593f, 
    -0.02592950f, -0.06686252f, 0.08607057f, 0.18116608f, -0.12183091f, 0.03623235f, -0.43479520f, -0.08557680f, 
    -0.15643995f, -0.10796338f, -0.04283645f, 0.04809645f, 0.34187296f, 0.05685753f, 0.19137602f, -0.02404476f, 
    -0.09994476f, -0.00638635f, -0.00062342f, 0.03787957f, 0.00804920f, -0.03557207f, -0.01991429f, -0.07215222f, 
    -0.07618405f, -0.06304027f, 0.02093970f, 0.09707201f, -0.08356058f, 0.05861223f, 0.05214423f, 0.00864272f, 
    -0.07773303f, -0.06573434f, 0.04406312f, -0.13342522f, -0.01077697f, -0.11582715f, -0.04791306f, -0.09153257f, 
    -0.11823738f, 0.07955513f, -0.03364701f, -0.03671005f, -0.08477198f, -0.03536718f, 0.02756264f, 0.10560371f, 
    -0.05901701f, -0.07993327f, -0.08318768f, -0.10920903f, -0.01990567f, -0.00225493f, 0.09851487f, 0.06734688f, 
    -0.12608097f, -0.11594009f, 0.07304365f, 0.04649881f, -0.11172171f, -0.04740075f, -0.12466666f, -0.05104612f, 
    0.06929085f, 0.09371871f, 0.06438091f, -0.00465987f, -0.04020166f, 0.08762379f, -0.03721247f, -0.08397237f, 
    -0.07869667f, 0.05851613f, -0.11368455f, 0.04178930f, 0.02206757f, 0.05828264f, 0.03188085f, -0.09586314f, 
    -0.02753012f, 0.09376784f, 0.06418628f, -0.10915329f, 0.03733008f, 0.02236164f, -0.14615656f, -0.10165265f, 
    -0.01818927f, -0.06388351f, -0.05521233f, 0.08697343f, -0.03509826f, -0.08245258f, 0.04286455f, 0.04030728f, 
    -0.06463494f, 0.02818239f, -0.09098176f, -0.00380403f, -0.10420940f, 0.05091702f, 0.02108303f, 0.05832007f, 
    -0.09473819f, 0.08370137f, -0.00981650f, 0.08133682f, 0.07431052f, -0.03480952f, -0.11614823f, 0.03796409f, 
    0.07081603f, 0.01850742f, 0.07221358f, 0.00461144f, 0.02120785f, 0.01135647f, 0.09305560f, -0.04493368f, 
    -0.01516620f, -0.03081460f, 0.04720641f, -0.02445550f, 0.02687539f, 0.02406692f, -0.11745253f, 0.00151778f, 
    -0.03074840f, -0.10496785f, -0.00523373f, 0.00703448f, 0.00040405f, -0.11271180f, 0.05859157f, -0.10950125f, 
    -0.01331626f, 0.00169143f, -0.13408540f, -0.08099873f, -0.05784362f, 0.04997530f, -0.13097213f, -0.08014552f, 
    0.08517665f, -0.11016968f, -0.07682304f, -0.14499032f, 0.07699265f, 0.04836897f, -0.01101862f, 0.01881574f, 
    0.08743944f, -0.10224830f, 0.02692430f, -0.11830951f, 0.00021052f, -0.05040995f, -0.05265571f, -0.09750003f, 
    0.02929098f, -0.03677297f, -0.13629097f, -0.07366271f, -0.01504352f, -0.09580020f, -0.09104247f, -0.08339562f, 
    -0.03597020f, 0.00921727f, -0.10643122f, -0.10944804f, -0.02278082f, -0.00836046f, -0.14147286f, -0.02007912f, 
    -0.14773737f, -0.09913487f, -0.06354796f, 0.02494486f, -0.11719634f, 0.01816682f, 0.07803304f, -0.03477535f, 
    -0.05421986f, -0.09377268f, -0.15267166f, 0.01038146f, -0.15166321f, -0.15049753f, -0.00022180f, 0.06190511f, 
    -0.07174858f, 0.01752509f, 0.06310184f, -0.09715962f, 0.01809149f, 0.01411718f, 0.01380135f, 0.04145750f, 
    -0.16656125f, 0.02439110f, 0.02295057f, -0.12695500f, 0.06400878f, -0.08039788f, 0.01154509f, 0.01610078f, 
    0.10056762f, -0.01825326f, 0.05252557f, -0.12937677f, 0.03608216f, 0.02453174f, -0.05778172f, -0.14185351f, 
    0.07554537f, -0.14370243f, -0.09367424f, 0.04705827f, 0.04423160f, 0.03564100f, 0.06041508f, -0.00158397f, 
    0.02067441f, 0.12350303f, -0.02244742f, -0.03850990f, -0.05077626f, 0.04767408f, -0.11341951f, -0.08179507f, 
    -0.04937593f, -0.07062333f, -0.01186182f, 0.03285202f, -0.04579276f, -0.06328814f, -0.04191589f, 0.11988509f, 
    0.05490692f, -0.11262374f, -0.08139206f, 0.01868772f, 0.02037361f, -0.04442205f, 0.00055893f, 0.02455730f, 
    0.09165487f, 0.06907876f, 0.02803986f, -0.15695585f, -0.10615453f, -0.11234485f, -0.09002330f, -0.01854891f, 
    -0.02613197f, 0.05887118f, 0.06328081f, -0.05993629f, 0.00095395f, -0.05391242f, -0.00829182f, 0.02550820f, 
    -0.05360627f, -0.09323154f, -0.11653443f, 0.00979575f, -0.11695717f, -0.06048372f, 0.05814297f, -0.06151891f, 
    0.09992448f, 0.04947692f, -0.22223224f, 0.11152920f, -0.07966571f, -0.29381028f, -0.10775371f, 0.02280142f, 
    0.09493175f, 0.09289670f, 0.05800936f, 0.36696726f, 0.27776694f, 0.25767270f, -0.17395711f, 0.35936749f, 
    0.33665493f, 0.07601272f, -0.26971647f, 0.09975747f, -0.19986023f, 0.26896760f, 0.01455817f, -0.03103426f, 
    0.03056627f, 0.32392561f, 0.25514948f, -0.07168693f, -0.21527013f, -0.00767101f, -0.07360865f, -0.00816117f, 
    0.31099164f, 0.00139866f, 0.03813105f, 0.08446833f, 0.06073612f, 0.20306659f, -0.01180974f, -0.00988293f, 
    0.01629484f, 0.07031036f, -0.20311725f, 0.21093188f, -0.15998286f, -0.16056381f, -0.14403538f, -0.10071156f, 
    -0.08061245f, -0.08847111f, -0.08365183f, 0.03378192f, -0.11304075f, -0.00284444f, -0.16079909f, 0.04352114f, 
    -0.11173143f, 0.08022469f, -0.32917392f, 0.02376542f, 0.34204319f, 0.07611695f, 0.26049829f, 0.16804425f, 
    -0.07351920f, -0.11720064f, 0.41001832f, 0.13946235f, 0.18594083f, -0.05420684f, 0.14127405f, 0.04615021f, 
    0.06851748f, 0.12793519f, 0.12390693f, -0.05269979f, -0.30651718f, -0.00250813f, -0.19991282f, -0.26175895f, 
    -0.24504012f, -0.00761943f, 0.28234187f, -0.02036935f, 0.22512472f, -0.06760054f, 0.06368292f, 0.09315123f, 
    0.05111855f, -0.27950436f, 0.12425043f, 0.07333777f, 0.02549731f, -0.05404878f, 0.28732735f, -0.06266256f, 
    -0.16284914f, 0.06992254f, -0.04580627f, -0.02818595f, 0.20895520f, -0.27445298f, 0.12870131f, 0.28138271f, 
    0.00298981f, -0.02384190f, 0.18410170f, 0.09421062f, 0.15920474f, 0.08305854f, 0.07693379f, 0.09027688f, 
    0.07393104f, -0.00623250f, -0.12124967f, 0.22991242f, 0.14608257f, -0.09054659f, 0.30736825f, -0.08599708f, 
    0.17215967f, 0.05700665f, 0.30196708f, 0.25386968f, -0.02648560f, -0.10049249f, -0.33015117f, -0.02461508f, 
    0.37635317f, 0.12188113f, 0.27213523f, 0.26184914f, -0.03313051f, 0.13107073f, 0.14097904f, -0.02643758f, 
    0.08409084f, 0.44880313f, 0.32406697f, 0.38367799f, -0.31096262f, -0.03071442f, -0.02177088f, -0.01341437f, 
    0.06732268f, 0.00161350f, 0.04963646f, -0.11111504f, -0.22164473f, 0.03144306f, 0.06873500f, -0.15403487f, 
    -0.09879777f, -0.06261752f, 0.17555380f, 0.07522572f, 0.18521804f, -0.04499854f, 0.41293883f, 0.04025397f, 
    0.04376318f, 0.08234639f, 0.30357903f, -0.09694318f, 0.18313882f, 0.20662241f, -0.10816144f, 0.25606713f, 
    -0.02452303f, -0.09296677f, -0.15162402f, 0.34075937f, -0.04338645f, -0.04175957f, 0.16614993f, 0.04001848f, 
    -0.00840130f, 0.01841964f, 0.21296632f, 0.02834005f, -0.02812421f, -0.03376182f, -0.25749260f, -0.09478774f, 
    -0.07128809f, -0.07220420f, -0.15783460f, 0.19465339f, 0.21639465f, 0.03170726f, 0.11009555f, 0.11295710f, 
    -0.00437784f, -0.07948408f, -0.61023742f, 0.06517781f, 0.05946444f, -0.08606995f, -0.18804161f, 0.18532351f, 
    0.02512552f, 0.07961994f, -0.26751450f, 0.00362476f, 0.04984188f, -0.05260931f, -0.02409546f, 0.20122311f, 
    0.42709571f, -0.10133211f, 0.05165402f, -0.01917990f, -0.02978148f, 0.45616987f, 0.10735789f, 0.07401396f, 
    0.06733465f, 0.11126270f, 0.05592496f, 0.07647783f, 0.10506789f, 0.17566594f, -0.27512503f, -0.00985953f, 
    0.21486939f, 0.06119880f, -0.33322966f, -0.26651204f, -0.12083891f, -0.22504888f, 0.02623720f, 0.31866941f, 
    0.19498952f, 0.08687951f, -0.05905762f, -0.02641244f, 0.22118925f, 0.13336138f, 0.03620484f, -0.12232623f, 
    -0.04133441f, 0.04692396f, -0.12562035f, 0.08519897f, 0.16165972f, -0.10984637f, 0.21230660f, 0.00994689f, 
    0.01428716f, 0.05283880f, 0.13473678f, -0.00100135f, 0.24506561f, 0.12909277f, -0.26406366f, 0.24983479f, 
    -0.19529353f, 0.00879652f, 0.47717956f, 0.12801683f, -0.16577187f, 0.19373414f, -0.23607716f, 0.06856252f, 
    -0.08227470f, -0.02969404f, 0.04911000f, -0.11674803f, 0.10847126f, 0.17280100f, -0.00637594f, 0.02956241f, 
    -0.11724856f, -0.06852962f, -0.17683892f, 0.17491676f, -0.01595448f, -0.14540501f, -0.09446386f, 0.21966220f, 
    0.12037409f, 0.31611529f, -0.01061495f, 0.02958330f, 0.06247806f, 0.44256434f, -0.11739432f, -0.11402740f, 
    0.22020879f, -0.00799409f, 0.31870663f, 0.48898327f, -0.20753062f, -0.00208000f, 0.08466483f, -0.48253313f, 
    0.02020708f, 0.05065359f, 0.23907253f, 0.02224621f, 0.11289334f, -0.41938940f, 0.00782047f, 0.16723779f, 
    0.02797154f, 0.03411659f, -0.12069046f, 0.24915618f, -0.11916353f, 0.29716510f, -0.01722399f, 0.11550276f, 
    -0.09679329f, -0.06306344f, 0.25040045f, -0.33781695f, 0.17628537f, -0.04185935f, 0.35714248f, 0.11204614f, 
    0.00644068f, -0.05615192f, -0.41757396f, -0.09767037f, 0.04866842f, -0.20157005f, -0.20982350f, 0.16044347f, 
    -0.06665085f, 0.09434239f, -0.11677008f, 0.11790145f, 0.31932703f, 0.07411945f, 0.19051214f, 0.45345569f, 
    0.20890339f, 0.07047153f, -0.11671237f, -0.00572822f, 0.04751614f, -0.00872966f, -0.08709431f, -0.16963510f, 
    0.05127688f, 0.30673936f, 0.11358913f, 0.10194349f, -0.19217792f, 0.07826967f, -0.04917988f, 0.05711409f, 
    0.22208324f, -0.07585690f, 0.03927903f, 0.01794413f, 0.06826260f, 0.10958291f, -0.07613192f, -0.07386789f, 
    -0.04877852f, -0.00515294f, -0.07577743f, -0.05476598f, -0.23082735f, -0.05382711f, -0.22344664f, 0.00436044f, 
    -0.09178506f, -0.11791015f, 0.19953270f, -0.04485655f, 0.14529166f, 0.12206909f, -0.28959829f, 0.08428465f, 
    0.11985303f, -0.03319946f, -0.30795485f, 0.15833740f, 0.26009682f, 0.04244564f, 0.36339322f, 0.12763043f, 
    0.06706870f, 0.04646264f, 0.06673829f, -0.09168170f, 0.34052426f, -0.12355687f, 0.12286920f, 0.05780432f, 
    -0.01467620f, 0.01629381f, 0.04153483f, -0.03711988f, -0.13500158f, -0.15360068f, -0.07974384f, 0.07436292f, 
    -0.05488831f, 0.05664690f, 0.10571919f, 0.17132106f, 0.18411103f, -0.22184241f, 0.06551954f, -0.11551945f, 
    -0.06295315f, -0.05154438f, 0.00507447f, -0.10472442f, -0.09190516f, -0.08085956f, 0.20010281f, -0.07545212f, 
    -0.12142209f, 0.03423948f, 0.06244934f, 0.02988367f, 0.23552643f, -0.01388602f, -0.11494064f, 0.09619546f, 
    -0.25944743f, 0.08329475f, 0.27761525f, 0.03718401f, 0.24393632f, -0.11605300f, -0.05774286f, 0.03282920f, 
    0.00375587f, 0.08489975f, 0.07688138f, 0.23599502f, 0.13283435f, 0.12716152f, -0.04975591f, -0.08049937f, 
    0.34307197f, -0.07186431f, 0.04506731f, 0.33174258f, 0.06285728f, 0.09588180f, -0.14500064f, -0.09523905f, 
    0.02733231f, 0.06528617f, -0.47465882f, -0.03463724f, 0.17841932f, 0.08110961f, -0.01475540f, 0.11686358f, 
    -0.04940089f, -0.11793036f, -0.26569000f, -0.01523050f, 0.27385014f, -0.12443340f, 0.13267253f, -0.03486964f, 
    0.11812720f, -0.09389669f, 0.19415256f, -0.08263163f, 0.14348762f, 0.13115834f, 0.19666335f, -0.02697657f, 
    -0.00055328f, 0.00211942f, 0.08291138f, -0.06153813f, 0.11073228f, 0.02617389f, -0.01135926f, 0.02304527f, 
    -0.13769929f, 0.10815679f, -0.21108891f, 0.10382470f, 0.08733089f, -0.15730733f, -0.06089137f, 0.12212802f, 
    -0.04171202f, 0.02322687f, 0.21206890f, 0.02903291f, 0.22741345f, 0.17239964f, 0.03664546f, -0.06441472f, 
    0.08191790f, 0.13260858f, -0.11095165f, -0.10753889f, 0.34594640f, 0.09831065f, 0.21597040f, -0.09900905f, 
    0.15200359f, 0.00107441f, 0.16591616f, 0.17962983f, 0.01686341f, 0.12118036f, -0.30215785f, 0.00170162f, 
    -0.15480387f, -0.05724101f, 0.01541580f, -0.22929367f, 0.09821332f, 0.08961260f, -0.00615700f, -0.08747588f, 
    0.00630583f, 0.00434462f, -0.19080049f, -0.05447785f, 0.14412571f, -0.26333243f, 0.13215345f, 0.10727093f, 
    0.02175481f, 0.09126353f, 0.35612541f, 0.16118874f, 0.10449565f, -0.02145648f, -0.41450411f, 0.25379094f, 
    -0.03633736f, -0.09618255f, 0.20329462f, 0.02669041f, 0.12493690f, 0.24771008f, 0.14388734f, -0.07318258f, 
    -0.22881708f, -0.06678648f, 0.02616041f, -0.29767254f, 0.18523677f, 0.24479626f, -0.04409119f, -0.11028834f, 
    -0.17803277f, 0.12056214f, 0.32910037f, 0.02333656f, 0.09600111f, -0.01097511f, -0.38517594f, 0.01423030f, 
    0.02145172f, 0.03505965f, -0.03360288f, 0.06577610f, 0.28362870f, 0.14414604f, 0.39412144f, 0.00609902f, 
    0.20109010f, -0.00857814f, -0.07826839f, 0.33083877f, -0.12052332f, 0.00967912f, 0.18983825f, -0.06629098f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.06934480f, 0.20759675f, -0.06687757f, 0.06316705f, -0.06365543f, 0.00054325f, 0.16126432f, 0.09034055f, 
    0.04332845f, 0.14600544f, 0.21855780f, 0.08553952f, -0.02530174f, -0.02246242f, 0.04980098f, -0.00199964f, 
    -0.03617411f, 0.01971027f, 0.02869051f, -0.00296975f, -0.07907649f, -0.08580154f, 0.10800051f, 0.15356036f, 
    -0.04268295f, -0.02605053f, -0.00172857f, 0.03686083f, 0.08149025f, 0.05665406f, -0.11580985f, -0.03864483f, 
    0.17678934f, 0.01807680f, 0.24759717f, 0.15839097f, 0.08038841f, 0.06905914f, -0.08273196f, -0.03541360f, 
    0.14540078f, 0.17947626f, 0.14280438f, -0.08563086f, 0.10374858f, -0.04662955f, 0.10296810f, 0.04501921f, 
    0.08334956f, 0.03897841f, 0.18280783f, -0.09758178f, 0.08743350f, 0.06873345f, -0.13165891f, 0.15910579f, 
    0.05750021f, 0.28690010f, 0.03282484f, 0.05749300f, 0.10724120f, 0.16224404f, 0.11475088f, 0.11302136f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.24932808f, 0.06512756f, 0.11585177f, 0.10228696f, -0.09267482f, 0.01317128f, -0.04785287f, 0.12806694f, 
    -0.01235492f, -0.41089657f, -0.29800126f, 0.12097173f, -0.00041778f, -0.07264658f, 0.01077683f, -0.08744635f, 
    -0.20711321f, 0.04575086f, 0.29099208f, 0.10772637f, 0.02639153f, 0.13634351f, -0.06572995f, -0.45902100f, 
    0.05915904f, 0.13017359f, -0.43700677f, -0.12367773f, -0.05617176f, 0.07727578f, 0.11199335f, -0.01530143f, 
    0.15893516f, 0.05955973f, 0.14051770f, 0.17086923f, 0.02919272f, -0.12385274f, 0.07745267f, 0.40852588f, 
    -0.36463347f, -0.21825032f, 0.23928192f, -0.11867463f, -0.11375514f, -0.00147901f, -0.15857869f, -0.30765188f, 
    0.26084423f, -0.38475776f, 0.25209489f, -0.01177761f, -0.08108974f, 0.04249408f, 0.02353084f, -0.04785817f, 
    0.03222996f, -0.06953810f, 0.25337398f, -0.07847033f, -0.18128134f, -0.08695254f, 0.14502366f, -0.49819845f, 
    0.09265475f, 0.03828013f, -0.05022294f, -0.01041475f, -0.07103132f, 0.20244409f, -0.01556840f, -0.11279018f, 
    -0.22278562f, -0.45723709f, 0.13675721f, -0.02145812f, -0.02577998f, 0.12387651f, -0.06243164f, 0.04600902f, 
    0.09189368f, -0.08846931f, 0.01415664f, -0.11005398f, -0.06265459f, 0.23272006f, 0.11877631f, -0.24852213f, 
    -0.22789168f, 0.14619097f, 0.03334278f, -0.05683235f, -0.01736246f, 0.24871080f, 0.03668988f, 0.03159737f, 
    -0.27873370f, 0.08394382f, -0.19255462f, 0.10442200f, 0.22466946f, -0.20034133f, 0.01356211f, -0.20446678f, 
    0.13437903f, -0.06535707f, -0.16268805f, 0.21282563f, -0.36173025f, -0.01885090f, -0.52369320f, -0.15572354f, 
    0.26254851f, 0.09927259f, -0.21871905f, 0.10195962f, -0.03892056f, 0.03435504f, 0.07767150f, -0.21289082f, 
    0.21310957f, -0.21281199f, -0.11767088f, -0.00512665f, -0.14549832f, 0.17823015f, 0.14612272f, 0.19409023f, 
    -0.08987448f, 0.18991241f, -0.03052123f, -0.01587416f, -0.06763177f, -0.46756595f, -0.05817048f, -0.33562842f, 
    0.19100027f, -0.15561718f, -0.01201501f, 0.07422327f, 0.03599568f, 0.13122168f, 0.03461014f, 0.26772323f, 
    -0.29680598f, -0.19474557f, 0.06260305f, 0.32907104f, 0.02303775f, 0.12218220f, 0.04547966f, -0.04462952f, 
    -0.40666592f, -0.05343690f, 0.18338686f, -0.05069691f, -0.02580651f, -0.01349468f, 0.02853770f, 0.12754540f, 
    -0.59125257f, -0.60442364f, -0.00713555f, 0.08254234f, 0.16173829f, -0.26604465f, 0.02217168f, 0.05938831f, 
    0.05444209f, -0.18680106f, -0.21367869f, -0.06402799f, -0.28978223f, -0.08269489f, 0.19432139f, -0.29196030f, 
    0.17864522f, -0.30174863f, -0.38092273f, 0.02783916f, 0.05160325f, -0.13140923f, -0.12442846f, 0.18171650f, 
    -0.23051244f, -0.35749921f, 0.40996444f, 0.13393055f, 0.18162985f, -0.09668793f, 0.10378323f, 0.24523312f, 
    -0.30687234f, -0.08875880f, 0.02765089f, -0.09011865f, 0.04212844f, -0.14594468f, -0.37314811f, 0.13833007f, 
    0.14795291f, -0.26743883f, 0.25038937f, 0.10624523f, -0.01474130f, -0.35285947f, 0.12374835f, -0.30848801f, 
    -0.41067800f, -0.03836602f, 0.18474479f, -0.31922388f, 0.05795202f, -0.25998247f, -0.10769480f, -0.46225375f, 
    -0.02583075f, -0.67348772f, 0.22909540f, 0.05064063f, -0.11462672f, -0.25080147f, -0.05989098f, 0.18301380f, 
    0.08403081f, -0.12181874f, 0.26785654f, -0.20550412f, 0.01959931f, 0.27303091f, 0.09311385f, -0.00358237f, 
    -0.41692439f, -0.25652030f, 0.20655699f, -0.64973760f, 0.24659488f, -0.07323322f, 0.22672619f, 0.09341114f, 
    -0.29420498f, 0.14881659f, 0.06189366f, -0.12135549f, 0.11645984f, -0.10373439f, 0.10055827f, 0.24733560f, 
    -0.13890696f, 0.16903512f, 0.08237142f, -0.38784137f, 0.15141425f, -0.19518378f, -0.02325220f, -0.38129178f, 
    -0.01318458f, 0.19729173f, 0.01976094f, 0.01922793f, 0.07084105f, -0.21075597f, -0.04968625f, 0.01462727f, 
    0.14462121f, -0.07955825f, 0.18003818f, -0.03520603f, -0.05052486f, 0.11452892f, -0.13834220f, 0.03599887f, 
    0.11284637f, -0.09509622f, -0.03432004f, 0.30939883f, -0.05875234f, -0.15248290f, 0.00184439f, 0.13468948f, 
    0.34334338f, -0.15436153f, 0.04681040f, -0.06579622f, -0.09529965f, -0.16456923f, 0.09847605f, -0.13873774f, 
    0.08900332f, 0.04002997f, 0.21466537f, 0.06767166f, -0.37350512f, -0.18178959f, -0.11018552f, -0.42305848f, 
    -0.22467151f, -0.06838020f, -0.00767364f, -0.18113936f, 0.40391922f, 0.03822334f, 0.11161400f, -0.11116765f, 
    -0.15164258f, -0.13652208f, 0.18895707f, 0.07072024f, 0.01003391f, 0.05495691f, -0.13478750f, 0.16198319f, 
    -0.11542673f, 0.20334210f, -0.15742540f, 0.16013801f, -0.05475490f, -0.16797552f, -0.28363284f, -0.12062738f, 
    -0.13639033f, -0.13528040f, 0.10130706f, -0.05270314f, -0.14230464f, 0.22146769f, 0.16869792f, 0.30884567f, 
    -0.05630604f, 0.31152359f, -0.24742514f, 0.06817610f, -0.07397304f, 0.03928770f, -0.01315620f, 0.00382167f, 
    0.35362458f, 0.09169833f, 0.02593732f, -0.37015471f, -0.12987936f, -0.08550895f, 0.06152060f, 0.11944495f, 
    0.07310102f, -0.02645148f, -0.09215976f, -0.05428475f, -0.00207153f, 0.04893511f, -0.09937042f, -0.45840824f, 
    0.02677310f, 0.17194691f, 0.07945448f, 0.17439929f, -0.28263003f, -0.05669488f, 0.06673707f, 0.12364979f, 
    0.19938233f, 0.35372004f, -0.14893581f, -0.02797632f, -0.10874454f, 0.07149953f, -0.21318242f, -0.35314268f, 
    -0.03358513f, 0.20718366f, 0.11006831f, -0.07964209f, 0.10585684f, -0.04831769f, 0.00947202f, -0.34435189f, 
    0.20075412f, 0.13975422f, -0.40923113f, -0.23162772f, -0.21803012f, 0.17249775f, 0.00729196f, 0.15036687f, 
    -0.14132093f, 0.15074076f, -0.11151390f, -0.01604806f, -0.01237111f, 0.08661697f, 0.15366384f, -0.58409756f, 
    0.08930530f, -0.40481740f, -0.33863652f, 0.08311962f, 0.07157059f, 0.05980698f, 0.04495911f, -0.01109974f, 
    -0.39199018f, 0.06438311f, -0.25544488f, -0.35563013f, 0.06394926f, -0.57133943f, -0.02915641f, 0.34263650f, 
    -0.28151292f, -0.15174918f, 0.25513551f, 0.08169518f, 0.03336638f, 0.08132602f, 0.07424384f, -0.43821466f, 
    0.09208748f, 0.13888340f, 0.24871963f, 0.12414877f, -0.51432949f, 0.09606739f, 0.01612750f, -0.33717075f, 
    0.08251735f, -0.12975232f, -0.28011182f, 0.12695634f, -0.25337833f, -0.04611028f, 0.07168816f, -0.10637620f, 
    -0.34328738f, -0.41444218f, 0.33178324f, -0.03730129f, 0.00528340f, 0.04847380f, -0.07488251f, 0.24906120f, 
    -0.07404543f, 0.21325354f, -0.16879290f, -0.32265586f, 0.23431283f, 0.13640262f, -0.00937378f, 0.09972346f, 
    -0.03651730f, -0.03953430f, 0.08182251f, 0.06217197f, 0.04824368f, 0.14521153f, -0.51352632f, 0.34371540f, 
    0.01989708f, -0.07225987f, 0.22649333f, -0.07609770f, -0.10615219f, -0.35204661f, -0.05782373f, -0.39916894f, 
    0.07094850f, -0.08172986f, 0.05911929f, -0.06680870f, 0.11529544f, 0.23464654f, 0.01478453f, -0.25723708f, 
    0.19033326f, 0.04262852f, -0.48758268f, 0.05690928f, 0.05305995f, -0.22684076f, -0.11483305f, -0.24153808f, 
    0.22869304f, 0.15283369f, -0.04908978f, -0.19186951f, 0.04285884f, 0.01584788f, 0.00290893f, 0.16677542f, 
    -0.20541678f, -0.34218058f, 0.21190749f, -0.08703791f, 0.10646325f, 0.06743119f, -0.13446890f, 0.15001316f, 
    -0.22555655f, 0.16885918f, -0.46472749f, -0.10972897f, 0.09053928f, 0.04583779f, 0.08504177f, -0.10089120f, 
    0.04015438f, 0.07096104f, -0.14128354f, 0.25731412f, -0.47292611f, -0.38346049f, -0.36624208f, -0.03288620f, 
    0.10817755f, -0.62760216f, -0.02718175f, -0.01399831f, 0.02093637f, 0.16827501f, 0.15903468f, -0.17509001f, 
    -0.53541142f, 0.50205618f, -0.27226216f, -0.03894719f, 0.01338869f, -0.11406895f, -0.11189961f, -0.01737093f, 
    0.25342840f, 0.04158703f, 0.03795870f, -0.19234838f, 0.05158648f, 0.21173556f, 0.03169129f, 0.02833618f, 
    -0.16492626f, 0.11228929f, -0.13010731f, 0.07697947f, -0.03444910f, -0.05773312f, 0.12483934f, 0.26232257f, 
    -0.27294028f, -0.14157940f, -0.58887661f, -0.36911854f, 0.28148738f, 0.10541163f, 0.07330184f, -0.25744689f, 
    0.23271547f, 0.09865591f, -0.41843536f, 0.18790072f, -0.36431485f, 0.02929169f, -0.27725229f, 0.10583546f, 
    0.13706413f, -0.31790331f, -0.42121691f, 0.05439533f, -0.09168914f, -0.09294014f, -0.06942010f, -0.60731745f, 
    -0.12381133f, -0.45696354f, -0.36827081f, 0.21214715f, 0.01258725f, -0.00276703f, 0.15948524f, 0.25470492f, 
    0.33201283f, 0.12089659f, -0.00634116f, 0.09182888f, 0.05988107f, -0.07924795f, 0.09181161f, 0.00483313f, 
    -0.00368882f, 0.23636879f, -0.34750381f, 0.03399201f, 0.04390582f, -0.03809563f, -0.13460751f, -0.13369888f, 
    -0.10824832f, -0.07834225f, -0.49100170f, 0.22426695f, -0.01356915f, -0.04016217f, -0.11371429f, 0.28366035f, 
    0.17958890f, 0.08374075f, -0.02352261f, 0.04761683f, -0.05641388f, 0.01951422f, -0.03337685f, -0.13483515f, 
    -0.13588941f, 0.22711949f, -0.26726928f, -0.04140171f, 0.18306494f, -0.34470168f, 0.10821408f, -0.10740698f, 
    0.10671547f, -0.11539715f, 0.17969081f, 0.13964532f, -0.54092634f, -0.02232885f, -0.03591241f, 0.02957118f, 
    0.13849322f, -0.12808821f, 0.10959861f, 0.10177085f, 0.00118742f, 0.10557836f, 0.06432094f, 0.13419956f, 
    -0.18653783f, -0.02925579f, -0.39292821f, 0.52657908f, 0.18861893f, 0.00571463f, -0.20189327f, -0.17030096f, 
    -0.33518580f, -0.32126039f, -0.08756375f, -0.04020322f, 0.04363643f, -0.19545516f, 0.20506008f, -0.18397489f, 
    0.00427898f, -0.12284965f, -0.14327189f, -0.00886737f, -0.08819912f, -0.32401118f, -0.09371134f, 0.18228894f, 
    0.24499327f, 0.00338682f, 0.23911557f, -0.07843509f, 0.00406694f, -0.23861645f, 0.10422643f, -0.42057410f, 
    -0.09293918f, -0.52242827f, 0.28873739f, -0.03090881f, -0.11428253f, -0.55955094f, 0.00691779f, 0.12823135f, 
    -0.14720911f, -0.29903165f, -0.20909604f, -0.28398582f, 0.27460074f, 0.28983989f, -0.05018923f, -0.02772369f, 
    -0.19491880f, 0.48733586f, -0.06150374f, -0.38197979f, -0.01287609f, -0.06295920f, 0.26626164f, 0.06620239f, 
    0.23487903f, 0.34235007f, -0.16219926f, -0.10240497f, -0.06799791f, -0.11831685f, 0.03305933f, -0.26432726f, 
    0.21561751f, 0.14741580f, 0.20373240f, -0.35502607f, -0.07446782f, 0.14190125f, 0.06929037f, 0.17118809f, 
    0.21860300f, 0.00724906f, 0.00149743f, -0.03360256f, 0.09088358f, 0.12418275f, 0.05199304f, -0.20423171f, 
    -0.25254506f, 0.21511601f, 0.22411142f, 0.10725122f, -0.06480166f, -0.20562732f, 0.00999750f, 0.11009732f, 
    -0.06663290f, -0.04219374f, 0.00597842f, -0.16647935f, -0.08034535f, 0.07170846f, 0.08780989f, 0.20174392f, 
    -0.65963131f, -0.22171214f, -0.26274115f, -0.15154992f, 0.08637198f, 0.07948988f, 0.01057686f, 0.04599642f, 
    -0.03153263f, -0.17824583f, 0.13531595f, -0.46031591f, -0.10382725f, 0.22950366f, -0.07404707f, -0.13192825f, 
    0.26172107f, -0.38253877f, -0.00404185f, 0.06813257f, -0.04394828f, 0.07243814f, 0.29605374f, 0.26370460f, 
    -0.04846890f, -0.06678778f, -0.14767587f, 0.09997614f, -0.02702890f, -0.05546563f, -0.05555709f, 0.03203090f, 
    -0.32245299f, -0.06064453f, 0.16035824f, -0.46291396f, 0.19719143f, -0.07896511f, 0.09135072f, -0.04624147f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.05988543f, -0.07255200f, -0.08373274f, 0.15316406f, 0.15705217f, -0.06221122f, 0.01119603f, -0.04442821f, 
    -0.02142545f, -0.05964309f, 0.03793593f, 0.04611538f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
