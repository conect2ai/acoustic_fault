#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.25539944f, 1.01862359f, 0.59942007f, 0.17829223f, -0.47808883f, -0.70987254f, 0.57509744f, -0.45803192f, 
    -0.12072076f, 0.34352264f, 0.23220097f, 0.06811649f, -0.06265678f, -0.16479284f, -0.01706986f, -0.11268687f, 
    -0.29164714f, -0.01952686f, -0.07584420f, -0.38891545f, 0.22394583f, 0.10793850f, -0.14668640f, 0.15702684f, 
    0.26399690f, -1.11297131f, 0.25563541f, -0.46526510f, -0.04314624f, -0.69117129f, 0.62740207f, 0.63496041f, 
    -0.55098921f, 0.35513622f, 0.29691818f, 0.08575629f, -0.40521559f, -0.23291174f, -0.28384265f, 0.35412461f, 
    0.22724311f, 0.18326606f, -0.22271809f, -0.28596872f, -0.04060291f, -0.08785938f, 0.04750162f, 0.44141889f, 
    0.48813570f, 0.00371141f, -0.89007378f, -0.00776786f, 0.92157525f, 0.59956652f, 0.32498589f, 0.71826077f, 
    0.52190363f, 0.53124619f, -0.12747438f, 0.19883350f, 0.04146566f, -0.28319907f, 0.17815693f, -0.03489134f, 
    -0.26393121f, 0.03302930f, -0.09400899f, -0.03457382f, -0.27837092f, -0.27412039f, -0.11006697f, 0.00659431f, 
    -0.15975790f, -0.05720913f, -0.38841289f, -0.08464804f, -0.40206501f, 0.51306075f, 0.35001662f, -0.54357988f, 
    0.54463005f, 0.07985743f, -0.51887691f, -0.63122004f, -0.10501681f, -0.36115539f, -0.07549615f, -0.25527474f, 
    0.38882035f, 0.41408983f, 0.31824720f, -0.00609918f, -0.20384865f, 0.13007109f, -0.13939336f, -0.40577796f, 
    0.03782384f, 0.27421501f, 0.33975849f, -0.02945814f, 0.16550554f, 0.65083587f, 0.01857704f, -0.05931298f, 
    0.33656287f, 0.46762756f, -0.57956308f, -0.65768856f, -0.65450162f, -0.41623077f, 0.31579274f, -0.18709278f, 
    -0.09173866f, 0.41368124f, -0.47375584f, 0.28686029f, -0.05706072f, -0.33477238f, -0.01530431f, 0.15378220f, 
    -0.18712723f, 0.18133007f, 0.38622671f, -0.24497689f, 0.05129600f, -0.04600672f, 0.36397564f, -0.40295199f, 
    -0.44006929f, -0.61115241f, 0.38348141f, -0.33306509f, -0.49669164f, -0.04494903f, -0.57670432f, 0.42353821f, 
    0.39365822f, 0.39486635f, 0.31559253f, -0.09963664f, -0.16525643f, -0.08646924f, -0.06133079f, -0.08612622f, 
    0.16653517f, 0.27262849f, 0.21169131f, 0.04593361f, 0.22775711f, 0.24363582f, -0.57779068f, 0.60056084f, 
    -0.26012421f, -0.44536251f, -0.19854707f, -0.11355189f, -0.25605932f, -0.17619625f, -0.03426592f, -0.01935122f, 
    0.34625798f, -0.35272714f, 0.14645816f, -0.26388374f, -0.41392088f, -0.54638904f, 0.41773140f, 0.27875561f, 
    -0.33402932f, -0.02556645f, -0.03435445f, 0.43148038f, -0.31262839f, -0.02127002f, -0.29715669f, 0.81179267f, 
    0.50644159f, 0.03485073f, -0.63444066f, -0.46477455f, -0.35977826f, 0.48975381f, -0.27175125f, -0.30091649f, 
    0.23917016f, 0.46098351f, 0.10294140f, 0.08066045f, -0.07803436f, 0.11667489f, -0.11613898f, 0.21323034f, 
    0.16437826f, 0.32940757f, 0.12748164f, 0.11059379f, 0.30814102f, 0.17706835f, -0.00908124f, 0.44964948f, 
    -0.70986992f, -0.31748641f, -0.41687891f, -0.66329062f, -0.20333259f, -0.57609141f, -0.19501740f, 0.24099781f, 
    0.17689583f, -0.56485885f, -0.11843150f, 0.05640833f, 0.14365488f, 0.22540940f, 0.29990044f, 0.22588964f, 
    0.22227138f, -0.00766185f, 0.29651368f, 0.15744232f, -0.02203821f, -0.38494623f, -0.19341795f, -0.31109402f, 
    -0.25596026f, -0.54836023f, 1.20950162f, 0.36694357f, -0.76428652f, 0.31355846f, 0.14391059f, 0.24128586f, 
    -0.22928751f, -0.24535604f, 0.18034200f, 0.06394423f, 0.05652714f, -0.36607406f, -0.25132757f, 0.20909931f, 
    -0.32258278f, 0.13300909f, -0.22399656f, 0.08375930f, -0.04267322f, 0.14314498f, 0.28797144f, 0.42268223f, 
    0.41927537f, 0.01542111f, 0.92195398f, -0.10842665f, -0.22350298f, -0.77676672f, -0.04967679f, 0.44677815f, 
    -0.45064497f, 0.39867711f, -0.11830039f, 0.06353454f, -0.50683200f, -0.02869349f, -0.18169966f, 0.37122771f, 
    0.09872618f, 0.23916715f, 0.16623272f, 0.21648461f, 0.12963772f, 0.15911523f, -0.29948524f, -0.06883294f, 
    -0.06104048f, -0.09354282f, 0.03353678f, 0.19711596f, -0.48731467f, -0.80301887f, -0.67521328f, -0.27546737f, 
    0.73457873f, -0.17709216f, -0.09749313f, 0.01014152f, 0.25565180f, -0.35616836f, -0.47449893f, -0.25150836f, 
    -0.53981245f, -0.22509685f, -0.24774545f, -0.06959060f, -0.15819693f, 0.29318038f, -0.15448827f, 0.13804698f, 
    -0.17201138f, -0.40231881f, 0.02817538f, 0.02893399f, 0.41965660f, 0.55460685f, 0.68177372f, 0.52436268f, 
    0.58553964f, -0.75373465f, -0.32674110f, -0.61566126f, 0.38797039f, -0.20520842f, 0.30569941f, -0.02426871f, 
    0.12487244f, 0.17461154f, -0.32557052f, -0.03863220f, -0.02486139f, 0.17213990f, 0.07619946f, -0.07756128f, 
    0.03045863f, 0.20618927f, 0.17508760f, -0.16375445f, -0.13776670f, -0.68024647f, 0.53136092f, 0.50749326f, 
    -0.00087303f, 0.77212912f, 0.26188779f, 0.65765768f, 0.80238640f, -0.20807309f, 0.27373171f, -0.45449990f, 
    -0.31617332f, -0.06530736f, 0.09075226f, -0.23534383f, -0.20725045f, -0.05489671f, 0.00938173f, 0.33792296f, 
    0.05473267f, 0.26070774f, 0.09425483f, -0.07066084f, -0.03380897f, 0.34889346f, 0.47683322f, -1.02573955f, 
    -0.71115535f, 0.74117965f, 0.35203192f, -0.71977317f, 0.81507671f, 0.28559852f, -0.30716738f, 0.27409887f, 
    0.39901471f, 0.09555677f, -0.44270125f, -0.13917728f, 0.16625881f, -0.24803093f, -0.38013408f, -0.19499388f, 
    -0.09097188f, -0.22131762f, -0.12709732f, 0.09901217f, -0.04967536f, 0.08684147f, -0.21642548f, 0.70391840f, 
    0.37499753f, 0.58232141f, 0.35202348f, 0.52368146f, 0.71310717f, 0.31257778f, -0.45693448f, -0.20792080f, 
    0.36241502f, -0.30553019f, 0.09282633f, 0.08243158f, -0.45038959f, -0.05777629f, -0.47190532f, 0.10559162f, 
    0.05508690f, -0.39167067f, -0.47606590f, -0.16772364f, -0.22556053f, 0.24692705f, -0.11495043f, 0.08146791f, 
    -0.74905992f, -0.03541773f, -0.31569538f, -0.02517547f, 0.11027157f, 0.86243141f, 0.79395151f, -0.35442123f, 
    0.59976429f, 0.12167838f, 0.11887299f, -0.32242402f, 0.26304716f, -0.18512805f, -0.27698475f, -0.33425599f, 
    -0.05537067f, 0.05074462f, -0.29959202f, -0.17012694f, 0.22114871f, -0.04739520f, 0.06445456f, 0.07575271f, 
    0.20614371f, -0.04282707f, 0.52592057f, -0.42836040f, -0.87307751f, -0.69862181f, 0.68607306f, -0.25465766f, 
    -0.27026966f, 0.11375875f, -0.33313668f, 0.10114846f, 0.02646860f, 0.21938428f, 0.10235613f, -0.09035492f, 
    0.36209655f, -0.10790471f, 0.01017177f, 0.03725086f, -0.00891165f, 0.06968604f, -0.39445370f, 0.11469763f, 
    -0.11012648f, 0.26735741f, -0.00329509f, -0.61258107f, -0.08302417f, 0.16466251f, 0.04169432f, 0.69589210f, 
    0.79565400f, 0.49145555f, 0.43524703f, 0.12710671f, 0.02152888f, -0.41295704f, 0.02538595f, -0.10913839f, 
    -0.03316628f, -0.05830489f, -0.02367826f, 0.03851262f, 0.07842819f, -0.16078627f, -0.36471128f, -0.25648645f, 
    -0.06151947f, -0.23336732f, 0.08358253f, -0.43925902f, -0.50280428f, -0.58194965f, -0.35648414f, -0.29126880f, 
    -0.46331167f, 0.25666606f, 0.53092110f, 0.49168938f, -0.07277022f, -0.24364042f, -0.00129734f, 0.16633883f, 
    0.00683311f, -0.44160610f, -0.39182135f, 0.03759745f, 0.04115420f, 0.09720298f, -0.03644784f, 0.24821533f, 
    0.21465680f, 0.05997331f, 0.08498515f, 0.15849414f, 0.12505478f, 0.12724099f, -0.40340802f, -0.60526103f, 
    0.73877501f, 0.01088115f, -0.38844591f, -0.53501844f, -0.05309333f, -0.08939954f, -0.00312841f, -0.37873530f, 
    0.39911780f, 0.07255169f, 0.08746121f, -0.10166656f, -0.41783485f, -0.24909580f, -0.32065248f, -0.23272040f, 
    0.37511724f, -0.39284986f, 0.28270873f, -0.29941159f, -0.26973900f, 0.44190833f, 0.72931522f, 0.66210651f, 
    0.22059394f, -0.51052171f, -0.50987422f, -0.19866742f, 0.36599681f, -0.19725513f, -0.38252258f, 0.17654160f, 
    0.15627390f, -0.47035420f, 0.41584587f, 0.06958357f, 0.06733154f, -0.10360488f, 0.31763294f, 0.04961709f, 
    -0.28147808f, 0.24764146f, 0.40262195f, 0.24410851f, 0.35774043f, -0.01842601f, 0.28398916f, -1.07974815f, 
    -0.69464910f, 0.65707368f, 0.27630609f, -0.77214408f, 0.51245320f, 0.35195574f, -0.32389003f, 0.01572115f, 
    0.38220626f, 0.30688000f, -0.23435102f, -0.25245941f, 0.29454231f, 0.31224468f, 0.44358256f, -0.13295023f, 
    0.05506791f, -0.18690325f, 0.17164986f, 0.17163195f, -0.07909031f, 0.20771563f, 0.25445363f, -0.14244385f, 
    0.71024251f, -0.18872957f, -0.33766013f, -0.64095324f, 0.25202298f, -0.67869586f, -0.41908878f, -0.22071892f, 
    -0.03514511f, 0.35261655f, 0.38884863f, 0.26976219f, 0.25856593f, 0.01681789f, 0.00686299f, 0.05371229f, 
    0.06608516f, 0.10508490f, 0.43187207f, 0.01203414f, 0.19265214f, 0.19691794f, 0.03738237f, 0.18541497f, 
    -0.79215848f, -0.61442840f, 0.29704189f, 0.50761002f, 0.34124476f, -0.50995433f, 0.39882937f, 0.43801406f, 
    -0.12520750f, 0.32269663f, 0.15579794f, -0.06170196f, 0.35698143f, 0.00097916f, 0.20583594f, -0.11170635f, 
    0.25277677f, 0.36018783f, 0.16950260f, -0.41270792f, 0.06625469f, -0.11983079f, -0.02271957f, 0.21119323f, 
    -0.19798589f, -0.63073409f, 0.92224371f, 0.63607728f, -0.07512830f, 0.85019416f, 0.56529295f, 0.06626875f, 
    -0.69001639f, -0.74601060f, -0.50128490f, 0.03960344f, 0.21711534f, 0.33821091f, 0.20433372f, -0.21394418f, 
    -0.21180785f, 0.30086645f, 0.25804067f, -0.18642117f, 0.23756669f, -0.03965272f, -0.09028813f, -0.19518937f, 
    0.09023088f, 0.14549921f, -0.24724717f, -1.02299404f, 0.29003701f, -0.27158058f, -0.42880279f, 0.60500848f, 
    0.04149731f, 0.36788687f, 0.55226356f, 0.32351223f, 0.22143263f, 0.22678636f, -0.23972866f, 0.40510952f, 
    -0.33147362f, 0.07930134f, 0.28500992f, 0.14061640f, -0.06578881f, 0.09925540f, 0.16279413f, 0.05021309f, 
    0.05347777f, 0.20888223f, 0.09330294f, -0.09264092f, -0.24759652f, -0.68461853f, -0.55398816f, -0.38127869f, 
    -0.66102672f, 0.10221332f, 0.49484316f, 0.43545321f, 0.61937296f, 0.36186731f, 0.13985464f, -0.13362885f, 
    -0.39627272f, 0.15137027f, 0.24681744f, 0.36994326f, -0.29532260f, 0.10754977f, -0.03080987f, -0.13925119f, 
    -0.19694039f, 0.35268405f, 0.08012582f, 0.17164847f, 0.75737816f, 0.80507666f, -0.57629460f, -0.34680918f, 
    0.36825016f, 0.36990631f, -0.12579367f, -0.72732288f, 0.06199044f, -0.03704290f, 0.14373264f, -0.03442572f, 
    -0.32871920f, 0.04851615f, -0.44018245f, -0.29871067f, -0.03868413f, -0.10980380f, -0.28587058f, -0.06658773f, 
    -0.02795055f, 0.07799154f, -0.13311388f, 0.17774317f, -0.01795170f, -0.80452996f, -0.29556331f, -0.05615169f, 
    -0.41686326f, 0.25400499f, -0.23375638f, -0.17363699f, -0.38733244f, -0.54227352f, 0.03457650f, 0.18148670f, 
    0.27019039f, -0.05766313f, 0.45979244f, 0.08141403f, 0.37227851f, -0.33854899f, -0.12642777f, 0.04613948f, 
    0.01762624f, 0.04922445f, 0.28389093f, 0.22801444f, 0.21710137f, 0.26609355f, 0.19158266f, 0.32527691f, 
    0.45478383f, 0.49453613f, 0.74272025f, -0.87051719f, -0.35648200f, -0.53864700f, -0.52978450f, -0.20759477f, 
    0.34684339f, 0.15150797f, 0.09645021f, 0.11317475f, 0.21269561f, -0.01867102f, 0.28192607f, -0.05773645f, 
    -0.11604877f, 0.24431844f, 0.30923489f, -0.06879906f, -0.13802457f, 0.28346285f, 0.28278008f, 0.10203473f, 
    0.30741540f, 0.33718470f, -0.21121608f, -0.28178951f, -0.49759403f, -0.20493799f, -0.71549225f, -0.47910199f, 
    -0.40675399f, 0.32728156f, 0.51153392f, -0.03168194f, -0.20558387f, 0.26221415f, 0.14522417f, 0.10198381f, 
    -0.19555445f, 0.33740836f, 0.39485952f, 0.30662829f, -0.27062440f, 0.14806482f, -0.19623110f, -0.45057362f, 
    -0.03675025f, 0.34337720f, 0.29170683f, 0.22092880f, -0.66845059f, -0.21411481f, -0.73913383f, -0.40895787f, 
    -0.19215389f, 0.27053469f, 0.22745354f, -0.31169260f, 0.22942944f, -0.18258819f, 0.20239484f, -0.29740682f, 
    -0.31389785f, -0.30499732f, -0.43010983f, 0.23063520f, -0.13556613f, -0.07951483f, 0.17858958f, 0.39050317f, 
    -0.40865332f, -1.32114327f, 0.40198684f, 0.75596094f, -0.80489111f, -0.51050097f, 0.68657881f, 0.25492129f, 
    -0.13391000f, 0.51744843f, -0.12805985f, -0.04253764f, -0.15739991f, 0.15785775f, 0.20430203f, -0.09257918f, 
    -0.24328575f, -0.17731902f, -0.08035636f, -0.16682129f, -0.23764180f, 0.02206692f, -0.00195445f, 0.03826546f, 
    0.19988939f, -0.00800379f, 0.13452215f, -0.34090173f, -0.31217733f, -0.26122048f, 0.10173799f, 0.14956449f, 
    -0.85998392f, 0.17823143f, 0.04325620f, 0.17220575f, -0.14064912f, -0.27104920f, -0.42732608f, -0.33086646f, 
    -0.63424468f, -0.34459525f, 0.44454512f, 0.29655296f, -0.20338614f, -0.41406566f, -0.21019372f, 0.28356785f, 
    0.14485529f, -0.09273582f, -0.12796432f, -0.13043912f, 0.91788685f, 0.16577663f, 0.08537314f, 0.64200729f, 
    -0.18984877f, 0.60495347f, 0.73527938f, -0.25738239f, 0.31374761f, -0.53356212f, -0.31917131f, 0.18495952f, 
    -0.37356645f, -0.10374448f, 0.40383136f, -0.09445847f, -0.14203492f, -0.44270718f, -0.33427298f, -0.00829475f, 
    -0.26002121f, -0.07468534f, 0.22787964f, -0.01910283f, -0.59142780f, -1.32765222f, -0.58518577f, -0.24752995f, 
    0.28033209f, -0.05274268f, 0.85489517f, 0.40992808f, -0.44737190f, 0.23416038f, -0.10332201f, -0.07415486f, 
    -0.20645823f, 0.04830370f, -0.01059081f, -0.12700056f, -0.16514030f, -0.11438040f, -0.07113044f, -0.07616863f, 
    0.03476710f, 0.01491482f, 0.17113832f, -0.05208284f, -0.03211798f, -0.56604940f, -0.41254798f, -0.63611799f, 
    -0.23631206f, -0.46772861f, 0.08100720f, -0.18441321f, 0.05764387f, 0.32627591f, -0.13052458f, 0.04614691f, 
    0.35255620f, 0.05494570f, 0.34563428f, 0.36194107f, -0.36779419f, 0.35853010f, 0.16929795f, -0.23266183f, 
    -0.01771877f, 0.09100758f, 0.10100590f, -0.35945016f, 0.11066727f, -0.34990034f, -0.33595496f, 0.37798432f, 
    0.78146595f, 0.33628649f, 0.11282848f, -0.21549208f, -0.55098271f, -0.02854893f, -0.05914067f, 0.23039787f, 
    0.57795447f, -0.02461392f, 0.03099057f, 0.13080326f, 0.04472971f, 0.48964936f, 0.18055110f, 0.07517257f, 
    -0.12043839f, 0.11617655f, 0.33352420f, 0.43601245f, -0.38617975f, -0.01744767f, -0.10389265f, 1.06283569f, 
    0.50191605f, -0.82993174f, 0.94488227f, -0.07755435f, 0.05186747f, 0.40462956f, 0.32171521f, 0.74291235f, 
    -0.22248799f, -0.03801469f, -0.27280650f, 0.10585428f, -0.30937046f, -0.02051919f, -0.11383817f, -0.34131396f, 
    -0.01529919f, -0.05743358f, 0.14955226f, 0.13701387f, -0.21606719f, -0.08478857f, -0.11579601f, -0.18156810f, 
    0.64684534f, 0.43014583f, 0.28388789f, 0.69264156f, 0.59416503f, -0.48886839f, -0.70877898f, -0.08678567f, 
    -0.42551678f, -0.04997724f, 0.16582960f, -0.08763113f, 0.05978621f, -0.06378356f, -0.27994588f, -0.16713864f, 
    0.29688588f, 0.07602498f, -0.28210521f, -0.17987871f, -0.26529339f, -0.09922898f, 0.08926992f, -0.04732636f, 
    0.39483750f, 0.96166897f, 0.30575565f, -0.08844171f, 0.84235340f, 0.85385555f, 0.07318110f, -0.11508241f, 
    0.17304134f, 0.18417071f, 0.07621229f, -0.21702412f, -0.28955421f, -0.02193494f, -0.05176180f, 0.26613149f, 
    0.13025670f, 0.05893015f, 0.36542642f, 0.22655153f, 0.12428258f, 0.16493666f, -0.16084985f, 0.06210333f, 
    -0.16109456f, 0.08653996f, 0.72796309f, 0.21668379f, 0.14613160f, -0.14390951f, -0.51893449f, -0.47943050f, 
    0.85619599f, -0.33981556f, -0.31631693f, -0.11492894f, 0.23395285f, 0.30293795f, -0.08109752f, -0.19990672f, 
    0.33928069f, -0.00650162f, 0.08610617f, 0.26793259f, 0.29967660f, -0.06564683f, -0.12439492f, 0.07451317f, 
    -0.06730939f, 0.01271459f, 0.02796939f, -0.15762244f, 0.83358425f, -0.77155036f, 0.79960674f, -0.75155854f, 
    0.16129063f, 0.00276010f, -0.26763582f, 0.14564891f, -0.44650781f, 0.11001924f, 0.00845996f, -0.26446635f, 
    -0.24307266f, 0.09085157f, 0.19997700f, -0.03497097f, 0.14931180f, 0.33911109f, 0.07395556f, -0.08416153f, 
    -0.44434047f, -0.29325208f, -0.12712435f, 0.00536147f, -0.27806589f, 0.57863730f, 0.46214730f, -0.79495949f, 
    0.51015323f, -0.62247968f, -0.28195462f, -0.38769934f, 0.05292873f, -0.47332627f, -0.11450918f, 0.17216426f, 
    0.32500878f, 0.10683832f, -0.07082010f, -0.12704913f, -0.34677288f, 0.14352936f, -0.22301637f, 0.19387129f, 
    0.12381943f, -0.01998585f, -0.29016557f, -0.02447537f, -0.03297033f, 0.03729086f, -0.48812905f, -0.86776954f, 
    -0.41870171f, -0.54845619f, 0.41099775f, 0.08951061f, 0.31992528f, 0.56562483f, 0.04169092f, -0.35589072f, 
    -0.14977759f, -0.26419267f, -0.27930149f, -0.53213453f, 0.17657590f, 0.19639577f, -0.08437646f, -0.30644754f, 
    0.15903227f, 0.01205301f, -0.08540563f, -0.12842003f, -0.19528477f, 0.04799552f, 0.63330257f, 0.24319418f, 
    -0.65442312f, -0.11781895f, 0.57703251f, 0.40426314f, -0.67166376f, -0.66688448f, -0.40939388f, 0.27374759f, 
    0.02776214f, 0.56937420f, -0.03233248f, -0.02681670f, 0.18032233f, 0.36841145f, -0.01839935f, 0.00247435f, 
    -0.12553354f, -0.12560125f, -0.11650568f, 0.14985521f, 0.04787355f, -0.10864966f, 0.31702080f, 0.48815563f, 
    0.44332519f, -0.01213279f, 0.49131319f, -0.01691864f, -0.13091126f, -0.21469270f, -0.53843182f, -0.35919946f, 
    0.16219854f, -0.04368685f, 0.47045538f, 0.29716760f, 0.54530793f, -0.13795397f, -0.38943043f, 0.09842288f, 
    0.04425817f, -0.23178829f, -0.33787289f, 0.54928184f, -0.21280679f, -0.36498618f, -0.00130339f, -0.10826264f, 
    0.86300588f, 0.96971804f, 0.00799583f, -0.20497809f, -0.13665150f, -0.11299504f, 0.00025492f, -0.21013050f, 
    0.29830110f, 0.59436172f, 0.26201770f, 0.31224537f, 0.01315879f, -0.27670398f, -0.13976614f, -0.09702004f, 
    -0.39103439f, 0.07295391f, 0.25564012f, -0.03006365f, -0.45482928f, 0.09253789f, -0.12387206f, 0.02227543f, 
    -0.15363829f, 0.74165839f, 0.11379384f, -0.60408986f, -0.53849053f, 0.35684651f, 0.46700647f, -0.00285445f, 
    0.39402220f, -0.41110852f, 0.02048966f, 0.22818494f, 0.35543177f, 0.18392576f, 0.28163961f, -0.26589739f, 
    0.07504189f, -0.44354132f, 0.04882528f, -0.04763471f, -0.21159923f, 0.17126392f, -0.27710113f, -0.08713288f, 
    0.24986315f, -0.08512086f, 0.82912582f, 0.69569844f, 0.51446640f, 0.60915315f, 0.59374726f, 0.50280994f, 
    -0.10866172f, 0.16514671f, -0.23189583f, -0.08743827f, 0.01600653f, -0.13903952f, -0.14722203f, 0.23661442f, 
    0.19286603f, 0.43752420f, -0.18207660f, -0.23743236f, 0.13051429f, 0.36250702f, 0.13059439f, 0.05937918f, 
    -0.17726150f, -0.22824015f, 0.09911398f, -0.67864865f, 0.92982519f, -0.06270459f, -1.26077843f, -0.12356866f, 
    0.18852615f, 0.24701197f, 0.35572603f, 0.10036204f, -0.09991165f, -0.14313000f, -0.22385013f, -0.45735011f, 
    -0.28942844f, -0.48385084f, 0.10231562f, -0.15415975f, 0.17087255f, 0.16100776f, 0.27901095f, -0.14335336f, 
    -0.25383312f, 0.04386356f, -0.30309248f, 0.23736820f, 0.67085409f, 0.24456222f, 0.51288801f, 0.16751488f, 
    0.49680090f, 0.36229569f, 0.02396231f, 0.25044054f, 0.45270333f, 0.09542288f, -0.58368802f, 0.06350657f, 
    -0.27491888f, 0.03392565f, 0.03297140f, 0.53308886f, 0.16509643f, -0.13072905f, 0.19415566f, 0.33410758f, 
    0.19306979f, -0.20597123f, -0.14913785f, -0.16037060f, -0.02013246f, -0.02790871f, -0.61340797f, 0.11889810f, 
    -0.16457142f, 0.09163320f, 0.64290261f, -0.33146736f, 0.50378090f, 0.61347532f, 0.44496658f, 0.06902905f, 
    -0.15735047f, 0.07559609f, 0.36808679f, 0.49550888f, 0.26139793f, -0.20806281f, -0.21929617f, 0.07001706f, 
    0.40078938f, -0.17149955f, -0.19140601f, -0.24717236f, -0.09764926f, 0.04105355f, -0.66604781f, -0.64084595f, 
    -0.68902463f, -0.47469935f, -0.37886018f, -0.55930150f, -0.15183946f, -0.09179224f, -0.27117917f, 0.54139119f, 
    -0.01704876f, 0.10757132f, 0.05280344f, 0.07457551f, -0.20829144f, -0.20320334f, -0.09637000f, 0.42235905f, 
    -0.30280784f, 0.01301435f, -0.05408492f, 0.05875140f, -0.33068621f, -0.01745579f, 0.12072016f, 0.38906062f, 
    0.62731332f, 0.31951854f, 0.80598247f, 0.31535047f, 0.33117473f, 0.25955865f, -0.36283797f, 0.32480729f, 
    0.37742668f, 0.12446397f, -0.16175723f, 0.27200890f, 0.11259963f, -0.29112947f, 0.05193540f, -0.27045220f, 
    0.03218995f, 0.16106957f, -0.04277100f, 0.32447532f, 0.01832380f, 0.51250988f, 0.42439133f, -0.20418526f, 
    0.53745496f, 0.63245064f, -0.04507724f, -0.01667104f, -0.82490706f, -0.30901799f, -0.58494771f, 0.06731039f, 
    -0.54091561f, -0.15281984f, -0.04673382f, -0.24498351f, -0.28721765f, -0.33209360f, 0.21455991f, -0.22015509f, 
    -0.02489249f, -0.32433590f, -0.23626503f, -0.29343715f, 0.01539172f, 0.06856243f, 0.09282633f, -0.12579395f, 
    -0.06283513f, 0.40135053f, 0.14076573f, 0.53433704f, 0.77889818f, -0.34898889f, 0.03421165f, -0.25562099f, 
    0.23269378f, 0.13552061f, 0.29275697f, -0.39159116f, -0.36320394f, 0.03638551f, 0.02356624f, -0.07281031f, 
    0.30461988f, -0.02603071f, -0.35228905f, 0.19868955f, 0.02004203f, -0.00622255f, 0.05293625f, 0.40796611f, 
    -0.18816358f, -0.04505768f, 1.29079270f, 0.35912344f, -0.24325606f, 0.55714554f, 0.13542974f, -0.11823893f, 
    0.32882211f, -0.42045698f, 0.68181247f, -0.06750556f, -0.17058629f, -0.14141390f, -0.17285569f, 0.26427746f, 
    -0.13387443f, 0.15351751f, -0.11998607f, -0.28041869f, -0.08855887f, 0.15218316f, -0.16313094f, 0.13930048f, 
    0.06552523f, 0.08399951f, 0.15145162f, 0.38618201f, -0.10281222f, -0.00374823f, 1.26129806f, 0.11743474f, 
    -0.14624885f, 0.46082652f, -0.58270746f, 0.33202216f, 0.22555779f, -0.06453051f, -0.33532366f, -0.13693555f, 
    0.02249284f, -0.14829648f, -0.23480520f, 0.20902266f, 0.16345392f, 0.11925803f, -0.20955741f, 0.13490072f, 
    -0.18689051f, -0.14988448f, -0.24144745f, 0.18010986f, -0.56209981f, -1.06401122f, -0.29649147f, 0.61171162f, 
    -0.17286000f, -0.14948042f, 0.63330925f, 0.65435696f, -0.17387824f, -0.28278682f, 0.23972747f, -0.02257150f, 
    -0.01321550f, 0.25619787f, 0.06973118f, 0.01014698f, 0.20790182f, 0.08818381f, -0.48872465f, 0.22525610f, 
    0.00770151f, -0.26978251f, 0.29680470f, -0.08824720f, 0.05504833f, 0.08190493f, -0.91992426f, -0.08269192f, 
    -0.11704849f, 0.06246844f, 0.61119562f, -0.83288795f, 0.61447078f, 0.40598181f, -0.42737654f, 0.01072669f, 
    -0.22606550f, -0.34050572f, 0.40259674f, 0.05228618f, 0.05197226f, 0.12778915f, 0.00066864f, -0.01991270f, 
    0.24881335f, -0.22772720f, 0.09345687f, 0.14187713f, -0.02214622f, -0.10129958f, -0.26412883f, -0.08160631f, 
    0.50248343f, -0.47059461f, -0.46182337f, -0.31765079f, -0.45566306f, -0.28505099f, -0.30149084f, 0.05079108f, 
    -0.11490958f, 0.42036638f, -0.40117684f, -0.04453414f, 0.03248356f, 0.03426065f, -0.39444035f, -0.11830819f, 
    -0.18646486f, 0.48934197f, 0.24246533f, 0.27781361f, -0.17221563f, 0.44576952f, 0.35904726f, 1.09330189f, 
    0.25133866f, -0.77248031f, -0.32981351f, -0.40836096f, -0.52215540f, -0.36670101f, 0.27103367f, 0.02901395f, 
    -0.21841773f, -0.24372309f, -0.13321941f, 0.17473979f, -0.17671400f, 0.18634243f, 0.20249945f, -0.02963594f, 
    -0.16176443f, -0.19190390f, 0.37920019f, 0.31466374f, 0.23717676f, 0.01594824f, -0.37268156f, -0.28435242f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18906245f, -0.07762942f, 0.01562540f, 0.17280664f, 0.18402733f, 0.24327010f, -0.06632275f, 0.12074295f, 
    0.21372975f, 0.07448675f, 0.18204807f, -0.28159773f, 0.17329550f, 0.05153390f, 0.00851203f, 0.13077487f, 
    0.03085429f, 0.25754568f, 0.04080173f, 0.08345714f, 0.28852490f, 0.30197755f, 0.22969101f, 0.35048491f, 
    0.38198113f, 0.17383897f, -0.00086465f, 0.11889723f, 0.07414912f, 0.26931617f, 0.07582784f, 0.00248138f, 
    0.14477956f, 0.06438877f, -0.10067980f, -0.02623021f, 0.17900990f, 0.29570469f, 0.08986327f, 0.24293064f, 
    0.17852639f, 0.13749179f, 0.19914231f, 0.02839358f, 0.31339517f, -0.15831882f, 0.13178422f, 0.01342034f, 
    0.09691403f, -0.05204646f, 0.12401301f, 0.07521533f, 0.13128088f, -0.00647989f, 0.18454476f, -0.01397812f, 
    0.03072421f, 0.02882892f, 0.32482696f, 0.06996194f, 0.22105423f, 0.03922020f, 0.18053955f, 0.01310407f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01800353f, 0.07410532f, 0.00241100f, 0.09505568f, -0.02711425f, 0.01044229f, -0.04978811f, -0.18517470f, 
    -0.08603936f, 0.05355978f, -0.05234475f, -0.09919535f, 0.70006227f, 0.06277350f, 0.04868072f, -0.19374181f, 
    -0.05433031f, 0.07698235f, -0.12150837f, 0.01928451f, 0.11303632f, 0.05825721f, -0.00722811f, 0.03706660f, 
    -0.18889944f, 0.11044098f, 0.08934170f, 0.17280485f, -0.13390748f, -0.01088756f, 0.09145356f, -0.00862841f, 
    -0.01551294f, -0.14603518f, 0.05439516f, -0.17005982f, -0.02792437f, 0.01399085f, -0.05177464f, 0.02652255f, 
    0.08416893f, -0.11814450f, -0.03059856f, 0.01692941f, -0.09144295f, 0.02998593f, 0.05543284f, -0.09025751f, 
    0.00470253f, 0.05363042f, 0.19767949f, -0.30553895f, -0.09631893f, 0.01428174f, -0.01485873f, 0.07148143f, 
    0.02390022f, -0.04724427f, -0.03320152f, -0.10329010f, -0.34039012f, -0.14317141f, 0.04630010f, 0.06843433f, 
    -0.12697539f, 0.05972601f, 0.05283445f, -0.02161838f, -0.02772833f, -0.02874024f, 0.00199046f, 0.07069023f, 
    0.04764270f, -0.01661421f, -0.08748916f, -0.01304096f, 0.03527198f, -0.08357638f, 0.15533637f, -0.01602666f, 
    -0.02067536f, 0.06547245f, 0.01537462f, -0.16103664f, -0.23145853f, 0.15405551f, 0.12098871f, -0.09207425f, 
    0.06013932f, 0.00009112f, 0.06643494f, 0.02777052f, -0.00823046f, -0.08352143f, 0.00523080f, 0.05391547f, 
    -0.17669830f, -0.01584953f, -0.06658627f, 0.00559979f, -0.07810801f, 0.00719079f, -0.01282165f, 0.04342665f, 
    0.04322685f, 0.02461912f, -0.00723364f, -0.03225456f, -0.01952897f, 0.08558887f, 0.11920959f, -0.21991311f, 
    0.12310458f, -0.01420652f, 0.06185652f, -0.13074000f, -0.01266725f, -0.05744512f, -0.06626517f, 0.05814737f, 
    0.36853760f, -0.04447054f, 0.14438508f, -0.40121958f, -0.05040675f, -0.00582900f, -0.03080159f, 0.01097955f, 
    -0.09839467f, -0.08590204f, -0.13867313f, 0.04832185f, 0.10098144f, -0.31784731f, 0.07288075f, -0.33040574f, 
    0.13162327f, -0.06937392f, -0.00750398f, 0.07299704f, -0.12582563f, 0.06727104f, -0.04072944f, 0.11510811f, 
    0.07253151f, 0.07976411f, -0.11072980f, 0.04302422f, -0.10708427f, -0.16533008f, -0.10586404f, 0.00671664f, 
    -0.00915846f, -0.02005344f, -0.04637810f, -0.04901445f, -0.16029930f, 0.10689182f, 0.15548243f, 0.00309083f, 
    0.03730974f, -0.02427857f, -0.01711613f, 0.06579950f, 0.01089934f, -0.06377722f, -0.09419598f, -0.02003345f, 
    -0.12899773f, 0.12542139f, -0.00194447f, 0.23163949f, -0.08649837f, -0.04505347f, -0.03396454f, -0.18572298f, 
    -0.00126133f, 0.03755877f, 0.05151106f, 0.06630126f, 0.06861843f, -0.00051743f, 0.06150614f, 0.08173293f, 
    -0.24515855f, -0.19753678f, 0.04581349f, 0.02264803f, -0.06697095f, 0.10432763f, -0.01765467f, 0.10597283f, 
    0.30647025f, 0.08533908f, 0.10533822f, -0.05422482f, 0.07899974f, 0.01139565f, -0.10128194f, -0.03117718f, 
    -0.04282970f, 0.03389008f, -0.08655556f, 0.03738648f, 0.15161711f, -0.06580886f, -0.05485975f, -0.29113138f, 
    -0.20333701f, -0.00535147f, 0.02013619f, 0.01875621f, -0.09731336f, -0.02567267f, -0.03866058f, 0.05923858f, 
    0.08109255f, 0.11676549f, 0.05456188f, 0.06673031f, 0.07401275f, 0.05733592f, 0.10141818f, -0.06226788f, 
    0.05395744f, -0.04887163f, -0.10671161f, -0.03014606f, -0.12081254f, 0.22255059f, -0.17342165f, -0.14096527f, 
    0.05076302f, 0.03542938f, 0.12114839f, 0.06072228f, 0.05354312f, 0.06586146f, 0.03491786f, 0.07954884f, 
    -0.08705119f, -0.11058827f, 0.17968817f, -0.14465418f, -0.07958078f, 0.01693700f, -0.08618388f, -0.03909405f, 
    0.03063444f, -0.10021104f, 0.00300686f, -0.05455254f, -0.04377762f, 0.18817885f, -0.12724125f, 0.08438620f, 
    -0.12609889f, -0.07786544f, -0.16309978f, -0.07031144f, -0.04932956f, -0.04491251f, -0.00883721f, -0.04998893f, 
    -0.16952899f, -0.00815019f, -0.06837051f, 0.19993609f, 0.08256494f, -0.03083694f, 0.04712659f, -0.06542616f, 
    -0.05981949f, -0.02835359f, 0.06021951f, 0.03551273f, -0.12733346f, 0.03072175f, 0.01617740f, 0.02763393f, 
    -0.02386848f, -0.02868015f, 0.03745240f, 0.00675802f, -0.03699071f, -0.03834707f, -0.09951599f, 0.03962538f, 
    -0.25320476f, 0.05189526f, -0.15755270f, 0.15611739f, 0.00873740f, -0.03364598f, -0.03246102f, -0.01839960f, 
    -0.01237524f, -0.06535076f, -0.08674701f, -0.05370861f, -0.37339765f, 0.05862732f, 0.01352716f, -0.20364220f, 
    0.00548905f, -0.11773002f, 0.08788192f, -0.04852716f, 0.05194248f, -0.08102784f, -0.06268468f, 0.05986398f, 
    0.00428630f, 0.01940262f, -0.12912299f, -0.10087599f, 0.06403912f, 0.07787716f, 0.00452275f, 0.07819236f, 
    -0.00723806f, 0.03310111f, -0.06176429f, -0.02048131f, -0.11672016f, 0.09880801f, -0.10126371f, -0.29194254f, 
    0.01132471f, -0.09528170f, 0.09415733f, -0.07516927f, -0.00833410f, -0.08275604f, 0.07295559f, -0.07752977f, 
    0.01359856f, 0.09737463f, 0.20222001f, -0.07029341f, 0.04217448f, -0.07372303f, 0.06055043f, 0.11525959f, 
    0.11932330f, -0.02144765f, -0.08240384f, -0.09210359f, -0.45677215f, -0.15465112f, 0.02840985f, 0.00686992f, 
    0.01604806f, 0.04605111f, 0.03866678f, 0.03159790f, -0.04635552f, 0.00458064f, 0.01814602f, -0.04459340f, 
    0.19047540f, 0.05338128f, 0.08270721f, 0.09221649f, -0.16405359f, -0.09421327f, 0.01130569f, -0.05873590f, 
    0.00250874f, -0.09396029f, -0.04433415f, -0.00253664f, -0.08738362f, 0.13218684f, 0.12096369f, -0.01055923f, 
    0.05684761f, 0.06262366f, 0.05453761f, 0.09802736f, 0.06794285f, -0.11267256f, 0.04031286f, -0.03982030f, 
    -0.04892230f, -0.03345190f, -0.07272429f, 0.12516433f, -0.05935176f, 0.01284915f, 0.06730062f, 0.01972214f, 
    -0.11049664f, -0.02871508f, 0.09012146f, 0.05882791f, 0.30701277f, -0.09550169f, 0.15453906f, 0.03720015f, 
    -0.03255335f, 0.01721496f, -0.02217661f, -0.01831160f, 0.00339342f, -0.03917663f, 0.02983736f, 0.02048372f, 
    0.04310070f, -0.03955138f, 0.19628003f, -0.14385930f, 0.04732873f, 0.11537927f, 0.11653510f, 0.01525476f, 
    -0.09826835f, 0.10838863f, -0.02344807f, -0.04096726f, -0.04756778f, 0.06801362f, 0.07194305f, 0.01111712f, 
    -0.05230296f, -0.09383021f, -0.00106234f, 0.00091628f, 0.02426922f, 0.03466699f, 0.05863822f, -0.06811244f, 
    -0.38470048f, 0.08439913f, 0.11406472f, -0.23121437f, -0.00867711f, -0.00194835f, -0.05857581f, 0.02956812f, 
    0.00004804f, 0.06734709f, -0.01707006f, 0.05731203f, -0.01511878f, -0.03785586f, -0.17599447f, -0.02056449f, 
    0.03386092f, 0.03799501f, 0.03771486f, 0.03451868f, -0.10791592f, -0.06822479f, -0.07855920f, -0.01554692f, 
    -0.21642376f, 0.05122029f, -0.24167179f, 0.04940660f, -0.06609544f, -0.03478913f, 0.06109006f, -0.16068107f, 
    0.01404001f, -0.00090241f, -0.02752376f, 0.03434362f, -0.08979070f, 0.12462387f, -0.16839972f, 0.14319073f, 
    -0.17903285f, 0.04257756f, -0.03659575f, -0.00089119f, 0.02827946f, 0.07954852f, 0.02376164f, 0.02600968f, 
    0.17351627f, -0.00013613f, 0.07561775f, 0.08899339f, -0.12775466f, -0.03651431f, 0.00823915f, 0.08020742f, 
    -0.03628853f, 0.05578054f, 0.03316936f, -0.07104500f, 0.17443612f, -0.06817526f, 0.00509486f, 0.28031239f, 
    -0.14879930f, 0.06618343f, -0.00963329f, 0.06339692f, -0.05730462f, 0.06007923f, 0.02720761f, 0.00415387f, 
    -0.07931091f, 0.22902831f, 0.05922027f, -0.03926012f, -0.12566669f, 0.00063404f, -0.09519208f, 0.03672684f, 
    0.00018956f, 0.03422162f, -0.02512567f, -0.04333509f, 0.16832611f, 0.12391900f, 0.08310723f, -0.16748320f, 
    -0.16418900f, 0.03825670f, 0.03592796f, -0.02936037f, 0.06877020f, -0.05568599f, 0.08169547f, -0.04649908f, 
    -0.19783099f, 0.02733622f, 0.13505326f, -0.23497052f, -0.11714174f, -0.00653926f, 0.02380312f, 0.02135957f, 
    0.02122140f, -0.12645908f, -0.02831162f, -0.07194648f, 0.16593073f, 0.01319043f, -0.14315727f, -0.29184991f, 
    0.06633513f, 0.07411192f, 0.01837393f, 0.04231491f, -0.05971667f, 0.02557067f, 0.01478001f, 0.10228724f, 
    0.12630674f, -0.22603886f, 0.27410331f, -0.06613739f, -0.08282725f, -0.01287970f, 0.08563466f, 0.00442430f, 
    -0.00913137f, 0.01536382f, 0.11012434f, -0.04656364f, 0.09033445f, 0.09827557f, 0.08607146f, -0.07577658f, 
    -0.08720674f, -0.02929846f, 0.12871401f, -0.04691176f, -0.07988698f, 0.10503766f, -0.02431084f, -0.08423970f, 
    0.08701428f, 0.01895880f, 0.06137481f, -0.26719692f, 0.07512634f, 0.01394661f, 0.02596595f, 0.06205642f, 
    0.05098325f, 0.09159571f, 0.01313197f, -0.00923210f, 0.07409489f, -0.09449738f, 0.06467476f, -0.20488065f, 
    -0.12606522f, -0.05164636f, -0.11269005f, -0.00248957f, -0.00283250f, 0.14207369f, -0.04542540f, 0.03366036f, 
    0.26584849f, -0.07485861f, 0.00622477f, -0.05758242f, -0.11308169f, -0.04999571f, 0.03092974f, 0.08742120f, 
    0.00611630f, 0.02056470f, 0.00315887f, -0.01176756f, 0.12286967f, 0.04867250f, 0.13467535f, -0.40404269f, 
    -0.01724218f, 0.00181208f, 0.03609810f, 0.04514703f, -0.07340948f, -0.00942622f, 0.06932230f, 0.00059722f, 
    0.09218768f, -0.04686364f, -0.04872913f, -0.00118973f, -0.00061135f, -0.07454453f, 0.04108368f, 0.06053947f, 
    0.04813528f, 0.02861103f, 0.01815752f, 0.07669088f, 0.23491456f, -0.11161489f, -0.05157639f, 0.00684227f, 
    -0.03827110f, -0.09208743f, 0.02435613f, -0.05592699f, 0.09533864f, -0.02518620f, 0.01556358f, 0.12164700f, 
    -0.14019896f, -0.24206078f, -0.22378117f, -0.02789584f, 0.00961359f, -0.05399307f, 0.03908330f, 0.01999999f, 
    -0.01947062f, -0.04594674f, -0.04369707f, -0.01013774f, 0.09521724f, 0.03446588f, -0.06796589f, 0.13084263f, 
    -0.07070298f, 0.06300636f, -0.00261598f, -0.00621215f, -0.10763880f, -0.00938033f, 0.03590193f, -0.02184079f, 
    -0.08445941f, 0.11496795f, 0.06125412f, 0.02778870f, -0.07430557f, -0.14379852f, -0.02264380f, -0.00101649f, 
    -0.11702135f, -0.05755285f, -0.02945779f, 0.06269367f, 0.04051908f, -0.03291529f, -0.24430215f, 0.27301887f, 
    -0.00368081f, 0.06251605f, -0.03176272f, 0.04396354f, -0.04330514f, -0.08884174f, 0.03006626f, -0.06147929f, 
    0.08734906f, -0.07301401f, -0.08642946f, 0.13410503f, -0.09355704f, -0.09489095f, -0.12480569f, 0.06809078f, 
    -0.02641027f, -0.01442752f, 0.03597054f, -0.15937169f, -0.02465235f, -0.03097064f, -0.12140028f, 0.38888839f, 
    -0.06306356f, -0.03333498f, 0.01710281f, -0.07531410f, -0.06130847f, -0.03721061f, -0.04073950f, 0.12210506f, 
    -0.27021840f, 0.15061995f, -0.15198068f, 0.10681766f, -0.04801292f, 0.18420283f, -0.13761073f, -0.03219005f, 
    0.04258814f, 0.05240679f, -0.09767437f, -0.09712026f, 0.26885831f, -0.17391410f, 0.09536730f, -0.03052314f, 
    0.03772039f, 0.05254383f, -0.02813918f, -0.01143717f, -0.07314075f, -0.04525420f, 0.03297283f, -0.00300384f, 
    -0.31784728f, -0.09104780f, 0.22045389f, -0.07391838f, -0.00496205f, 0.14225036f, -0.01669418f, 0.04223489f, 
    0.02776866f, 0.05635529f, -0.03301379f, 0.11041412f, -0.16023722f, -0.12484534f, -0.02677692f, -0.16138542f, 
    0.01140010f, 0.10932687f, -0.01631296f, 0.15304451f, -0.09256074f, -0.05664305f, 0.00217749f, 0.11347763f, 
    0.07909214f, 0.10253139f, -0.18695144f, -0.06417713f, -0.11321881f, 0.02648764f, 0.07361394f, 0.09840044f, 
    0.02296390f, -0.12047096f, 0.05529888f, 0.05549731f, -0.45710254f, -0.08218633f, -0.10192986f, -0.17328294f, 
    -0.05252690f, -0.17380285f, 0.02072314f, -0.16878462f, 0.05156667f, -0.03216064f, -0.05205496f, 0.15153250f, 
    -0.06220305f, 0.21102740f, -0.01560873f, 0.12843096f, 0.05803305f, 0.07368103f, -0.09359718f, -0.07121792f, 
    -0.13797078f, 0.04807072f, -0.05358022f, -0.04020783f, -0.14578344f, 0.08172366f, -0.08111797f, 0.07252852f, 
    -0.06885195f, 0.00327517f, 0.14303035f, -0.16630150f, -0.03231484f, -0.08770486f, -0.12067808f, 0.02197114f, 
    0.03393238f, -0.21052060f, 0.03929314f, -0.17798457f, 0.04463191f, 0.02843181f, 0.07316165f, -0.06362709f, 
    -0.13792650f, 0.07779258f, -0.01335900f, 0.04338335f, -0.08636825f, -0.38564748f, -0.02214208f, -0.09765987f, 
    -0.04557881f, 0.07897419f, 0.04583603f, 0.07171778f, 0.07986711f, 0.12888919f, -0.04713001f, -0.11399589f, 
    -0.06006858f, -0.02684925f, -0.10966792f, -0.28998169f, -0.13787563f, -0.00825540f, -0.13077518f, -0.01861577f, 
    -0.04152849f, -0.23493119f, 0.01194467f, -0.13419567f, 0.34251329f, 0.04174972f, -0.13809651f, -0.13642117f, 
    -0.01692447f, -0.07815339f, -0.03318731f, 0.06108496f, 0.05457120f, 0.01430613f, 0.11686733f, -0.00407987f, 
    -0.00980666f, 0.07226034f, 0.10018339f, -0.05589416f, 0.05603813f, 0.00098165f, 0.00885845f, 0.09083853f, 
    -0.14284106f, 0.05105513f, 0.06756204f, -0.02961774f, -0.04887322f, 0.05213042f, -0.03114613f, -0.14637402f, 
    -0.19421931f, -0.03243485f, 0.02032745f, -0.03893948f, 0.04617240f, 0.06574923f, 0.08133212f, -0.03559056f, 
    0.17035477f, -0.09122697f, -0.00996823f, -0.18875581f, 0.11467752f, 0.04748846f, 0.04604414f, 0.01925640f, 
    -0.03300390f, 0.05649282f, 0.06398787f, -0.05006300f, 0.02126854f, 0.03257606f, 0.20012510f, -0.13701053f, 
    0.03992673f, 0.04844619f, -0.11020665f, 0.00739641f, 0.13036788f, -0.03241434f, 0.00598290f, -0.06576879f, 
    0.24729744f, -0.14043301f, 0.04123321f, 0.28134137f, -0.00746517f, -0.02969473f, 0.09669406f, 0.05794286f, 
    0.02883920f, -0.03138537f, -0.03677611f, -0.03891060f, 0.06816597f, 0.17913491f, -0.07319211f, 0.03714901f, 
    -0.04481583f, 0.05876132f, -0.00668227f, 0.06214279f, 0.06634437f, 0.15676506f, -0.06873237f, -0.05954194f, 
    0.21633701f, -0.33081287f, 0.04740191f, 0.03336881f, -0.12659732f, 0.05958692f, -0.02602062f, 0.05917138f, 
    -0.00782527f, 0.00757735f, -0.16434534f, 0.00220259f, 0.20525002f, 0.08804359f, 0.11759944f, 0.02128370f, 
    -0.16276693f, 0.11145654f, -0.02323172f, 0.06298780f, -0.07810809f, -0.15882160f, 0.06623530f, -0.06571435f, 
    -0.24413961f, -0.05102168f, -0.05885267f, 0.06683558f, 0.06765057f, 0.04379527f, -0.00547591f, 0.03687779f, 
    0.04589553f, 0.10176814f, -0.01068787f, -0.01100293f, -0.15209173f, -0.33363256f, 0.16795050f, -0.14236902f, 
    0.02272706f, 0.02879366f, 0.10153287f, 0.15485427f, 0.04429607f, 0.10751821f, 0.05398582f, 0.02469122f, 
    0.03082814f, 0.00456561f, 0.01397972f, -0.01549096f, 0.10788005f, 0.11626075f, -0.10182144f, 0.04148531f, 
    0.01974794f, 0.07054986f, -0.04541798f, 0.03805042f, 0.06052759f, -0.18923090f, -0.06485562f, -0.09496514f, 
    0.07661375f, -0.03870936f, -0.01264429f, 0.10843945f, 0.10199007f, -0.16580679f, -0.05390353f, -0.04769398f, 
    0.03217397f, 0.02952283f, 0.07206334f, -0.15737253f, 0.00590224f, -0.12885453f, -0.08787415f, -0.01765748f, 
    -0.06878166f, -0.00200636f, -0.22193557f, -0.00601709f, -0.14605847f, 0.02525026f, -0.06348010f, 0.12210960f, 
    -0.01371556f, -0.01409131f, 0.06167909f, 0.03764647f, -0.03097940f, 0.04569731f, -0.00789102f, 0.08954290f, 
    0.09937683f, -0.21858270f, -0.00315480f, 0.16530685f, -0.19183493f, 0.07488886f, -0.15229210f, 0.01613262f, 
    0.06871481f, 0.01246176f, -0.00597164f, 0.10580583f, -0.18304594f, -0.22300728f, -0.04447994f, -0.06816147f, 
    0.01981443f, -0.01578675f, 0.06789185f, -0.01564424f, 0.08214439f, 0.17215154f, 0.11030039f, -0.02240210f, 
    0.03935231f, 0.12879662f, -0.06342580f, 0.04493036f, -0.04373332f, 0.01045731f, -0.11848893f, 0.05018945f, 
    -0.00328207f, -0.00413748f, 0.02574192f, 0.08602514f, 0.17147075f, 0.03616995f, 0.02388593f, -0.10257310f, 
    -0.07852066f, 0.09099203f, -0.01090080f, -0.07570286f, -0.02827818f, 0.01708244f, 0.09963505f, -0.07638607f, 
    0.09066233f, -0.01459199f, -0.16082223f, 0.01872055f, -0.01192267f, 0.06495074f, 0.00108905f, 0.08214132f, 
    0.10355959f, -0.16125751f, 0.00802484f, 0.06220460f, 0.18457033f, -0.14148490f, -0.05215614f, -0.17479305f, 
    -0.01453786f, -0.04478076f, -0.12366691f, 0.16580643f, -0.05834074f, -0.03671632f, -0.06014377f, 0.02507627f, 
    0.16251646f, -0.22420530f, -0.06333099f, -0.18256004f, -0.24007438f, 0.00269246f, -0.01673631f, -0.06266049f, 
    -0.12743732f, 0.07004541f, -0.04036667f, -0.03599028f, -0.05767670f, 0.08316199f, -0.05567190f, -0.12143774f, 
    0.14190643f, 0.07905346f, -0.06213033f, 0.05899060f, -0.00515401f, 0.08704256f, -0.16687793f, 0.05821006f, 
    -0.06912755f, -0.10970764f, 0.01539749f, 0.03589786f, 0.07595997f, 0.08391817f, -0.01954029f, 0.04080456f, 
    -0.01025873f, 0.11146963f, 0.05920040f, 0.01628209f, -0.17147732f, -0.13705802f, -0.18514474f, -0.06142844f, 
    -0.01293746f, -0.03644426f, -0.15858938f, -0.02229391f, -0.05456931f, 0.12896213f, 0.09020569f, 0.05298947f, 
    -0.11473662f, -0.05449180f, 0.04028156f, -0.07688162f, -0.00421198f, 0.01767611f, 0.07362527f, 0.00398107f, 
    -0.09486131f, -0.02170167f, 0.00043011f, -0.01444899f, -0.82387185f, 0.01115201f, -0.02263460f, -0.03849551f, 
    -0.01478719f, -0.01628742f, 0.01091669f, 0.07638979f, -0.07113252f, -0.00338444f, -0.10506997f, -0.10157474f, 
    -0.00214941f, -0.03427130f, -0.04957218f, -0.08494661f, -0.00759024f, -0.12340529f, -0.02394320f, -0.02287887f, 
    0.23939119f, -0.18331391f, -0.03009347f, -0.08252126f, 0.21340375f, 0.25511119f, 0.05041913f, 0.08987500f, 
    0.01399745f, 0.12463933f, -0.03851843f, 0.06188409f, 0.01766210f, 0.01154276f, 0.00378449f, 0.02256137f, 
    0.44107509f, -0.02546502f, -0.16553725f, -0.03031086f, -0.01344644f, -0.02458506f, 0.02742044f, 0.05060804f, 
    0.01740283f, -0.04475172f, -0.12791981f, -0.00256185f, 0.00636337f, 0.03442392f, -0.05793604f, -0.04273479f, 
    0.15980801f, -0.04127580f, 0.09064369f, 0.00524874f, 0.03147224f, -0.02913454f, 0.01308133f, 0.05016381f, 
    -0.16886604f, 0.00933333f, 0.05159604f, -0.04795822f, 0.03910566f, -0.06163561f, 0.00374672f, -0.03869469f, 
    -0.07917180f, 0.03279778f, 0.06120916f, 0.06573576f, 0.25622800f, -0.20541452f, 0.04661615f, 0.20490198f, 
    0.01251629f, 0.01228627f, -0.04550840f, 0.10691545f, -0.01124562f, 0.05846034f, -0.17204650f, 0.02368341f, 
    0.06862617f, -0.03589219f, 0.08764287f, 0.15700336f, 0.03292742f, 0.05168933f, 0.00931117f, 0.04590914f, 
    -0.02048917f, -0.02325617f, 0.02236056f, -0.00009153f, 0.19446769f, -0.02679905f, 0.03565712f, 0.22074117f, 
    -0.05689752f, -0.01126620f, -0.12749097f, 0.00868528f, 0.00340176f, 0.04860906f, -0.07476489f, 0.01043845f, 
    0.32944676f, -0.07127485f, -0.07307334f, -0.08014382f, 0.02442338f, 0.00958037f, -0.06828026f, 0.03460682f, 
    0.05690653f, 0.02946130f, -0.01519824f, 0.10340472f, -0.12507847f, -0.24987933f, -0.32605803f, 0.11545181f, 
    0.14042881f, 0.00980587f, -0.05382418f, 0.00991733f, -0.08048934f, 0.05762620f, -0.15949889f, 0.07495539f, 
    -0.18760881f, 0.02681991f, -0.03948378f, -0.17035063f, -0.03376580f, -0.01473163f, 0.02408652f, 0.02164423f, 
    0.00285769f, 0.04395273f, 0.00042315f, 0.11866078f, 0.00349155f, -0.17671967f, 0.00680186f, -0.15186335f, 
    -0.05380426f, -0.01710096f, -0.00725262f, 0.00277030f, 0.09951157f, -0.01971580f, -0.01657287f, -0.04436350f, 
    0.05395569f, -0.19359228f, 0.07107753f, -0.15228315f, 0.04537182f, -0.02716760f, -0.03960162f, -0.02046799f, 
    0.00626320f, -0.07227401f, -0.05348247f, 0.11279747f, -0.04414882f, -0.00623850f, 0.04099991f, -0.00940607f, 
    -0.03370140f, -0.06893624f, -0.22594470f, 0.04212770f, 0.14963184f, -0.19386688f, -0.05794979f, 0.02684761f, 
    0.27164474f, -0.05517339f, 0.09000232f, 0.05849026f, -0.04796995f, -0.12828787f, 0.01264134f, 0.00122493f, 
    -0.04352326f, -0.09191544f, -0.10560738f, 0.06412019f, 0.21845889f, -0.07839333f, 0.11931004f, -0.25267488f, 
    -0.00497936f, -0.06767783f, 0.10275631f, 0.11164088f, -0.07811575f, -0.10549951f, -0.06385631f, 0.02266579f, 
    0.13169523f, 0.02820684f, 0.12771927f, 0.14652961f, -0.14858627f, -0.04182959f, -0.00806609f, 0.00296007f, 
    0.01170048f, 0.03146348f, -0.07006964f, 0.12670703f, -0.24474823f, -0.07623700f, -0.11534243f, -0.30088148f, 
    0.01820767f, 0.10613611f, -0.05525653f, -0.07272127f, 0.06734250f, -0.03616120f, 0.02726113f, 0.05300538f, 
    0.30985859f, -0.00706086f, 0.05908817f, 0.12753831f, 0.02508178f, 0.04658915f, -0.05828479f, -0.02435369f, 
    -0.04507641f, -0.01222230f, -0.06183470f, -0.03990033f, -0.02981758f, 0.09238509f, 0.03400123f, -0.06048041f, 
    0.07242133f, 0.02651642f, -0.03939158f, 0.00075786f, -0.16352779f, 0.09652632f, 0.03456118f, 0.03553987f, 
    0.10432151f, 0.02172743f, 0.05404462f, -0.07697798f, -0.10373975f, -0.07923283f, 0.05155145f, 0.07085909f, 
    0.04275750f, -0.07338331f, -0.01185906f, 0.03543392f, 0.15120989f, 0.03894091f, 0.10169358f, 0.14759102f, 
    -0.13731952f, -0.04076089f, 0.02490206f, -0.00950973f, -0.00392215f, -0.00858910f, 0.04329631f, 0.05776325f, 
    0.05979179f, -0.06411017f, -0.21047884f, -0.00520949f, -0.04430587f, 0.06095711f, 0.05234443f, 0.07565729f, 
    -0.09116879f, 0.00426258f, -0.11289882f, -0.07238678f, 0.07363193f, 0.13125223f, 0.04086848f, 0.22504823f, 
    -0.11116932f, -0.08415388f, 0.03139925f, -0.00560640f, 0.04963118f, -0.10794677f, -0.09917027f, 0.05356617f, 
    0.35376179f, -0.14020400f, 0.01202656f, 0.11571610f, -0.03914174f, -0.06398092f, -0.00354320f, -0.02130841f, 
    -0.13739608f, 0.07995402f, 0.00052888f, 0.07783076f, 0.27494526f, -0.21444248f, -0.15381761f, -0.00892345f, 
    0.00528541f, 0.00802088f, -0.02122750f, -0.00445603f, 0.04068484f, 0.08014605f, 0.08914203f, -0.16322182f, 
    0.03373981f, -0.05611366f, -0.18307996f, 0.18306585f, -0.03912252f, 0.01413889f, 0.01140823f, 0.01602277f, 
    -0.06435412f, -0.02398080f, 0.19747102f, 0.07233490f, -0.03789217f, 0.13898492f, -0.00732855f, -0.05680424f, 
    -0.10229844f, 0.04105929f, -0.08583115f, 0.01585097f, 0.06256124f, 0.10594601f, 0.02676098f, 0.06086231f, 
    -0.31119359f, 0.00500431f, -0.15431198f, -0.17583917f, 0.05040660f, 0.09576896f, -0.08043060f, 0.06471653f, 
    -0.12911622f, 0.03896315f, 0.05154535f, -0.12348175f, 0.14572008f, -0.27175131f, 0.05460136f, -0.20904708f, 
    -0.04615135f, -0.15462354f, -0.01603554f, 0.03520934f, -0.03346100f, 0.04869669f, -0.03415956f, -0.01911841f, 
    0.10353462f, 0.12057661f, -0.02371315f, -0.08509414f, 0.01007893f, 0.07465796f, 0.04058845f, -0.08235721f, 
    0.02318964f, -0.02863713f, 0.02833682f, -0.14328699f, 0.31442094f, -0.04346623f, 0.11685354f, 0.00814138f, 
    0.05280581f, -0.00802902f, -0.12571669f, 0.06736894f, -0.07735246f, -0.00075603f, 0.06204734f, -0.02376462f, 
    0.26665804f, -0.07404303f, 0.00879115f, -0.04193337f, -0.04800485f, 0.00855047f, -0.02473013f, 0.00985145f, 
    0.01118265f, 0.08427853f, -0.01552965f, -0.10888445f, 0.07282063f, -0.10350972f, -0.12426072f, -0.24631006f, 
    -0.10318002f, 0.05304573f, -0.16520062f, 0.08010400f, 0.01341572f, -0.02185667f, -0.04707116f, -0.00317200f, 
    -0.16229224f, 0.03604934f, -0.09747493f, -0.02379057f, 0.14820905f, -0.01894283f, 0.00423713f, -0.03909932f, 
    -0.03699596f, -0.02082405f, -0.06133263f, -0.13763019f, -0.26821426f, 0.06922091f, -0.03464861f, -0.23515317f, 
    0.00316759f, -0.01578843f, -0.06661292f, 0.02578115f, -0.02479926f, -0.03385933f, -0.12626997f, -0.07146100f, 
    -0.07428537f, -0.12697558f, 0.02792415f, -0.17853406f, -0.06377006f, 0.01731953f, -0.01236054f, -0.04447574f, 
    -0.02364727f, 0.09339289f, -0.11589160f, -0.04513030f, -0.06060740f, 0.05507218f, 0.05519889f, -0.16033314f, 
    -0.00464710f, 0.03277908f, 0.02381447f, -0.05070857f, -0.11386490f, -0.02592844f, -0.01472146f, -0.00130383f, 
    0.03297320f, 0.02124532f, -0.21390288f, -0.09339604f, -0.06058793f, -0.04817305f, -0.06598705f, 0.08300200f, 
    -0.02270027f, 0.00801356f, -0.10897914f, -0.00234231f, 0.25541073f, -0.12465008f, -0.09125558f, -0.04928621f, 
    -0.04555491f, 0.04657175f, -0.00679554f, 0.02440299f, -0.00167480f, 0.00462063f, 0.04175451f, 0.02980387f, 
    -0.47297594f, 0.00573860f, -0.04069445f, -0.04121384f, 0.10221884f, -0.10056160f, 0.00685618f, -0.00783361f, 
    -0.09681492f, -0.08401227f, -0.10563148f, 0.06116827f, -0.19852923f, -0.08785000f, 0.04618429f, 0.12166968f, 
    -0.01120617f, 0.00476318f, 0.02917815f, -0.09323405f, -0.01979992f, 0.02841965f, -0.03412221f, 0.09730846f, 
    0.04437386f, 0.10409164f, -0.10450593f, 0.12863182f, 0.04710637f, 0.00426080f, -0.03627751f, -0.08252570f, 
    -0.09085488f, -0.01466065f, -0.04879878f, -0.02744159f, 0.20540614f, -0.02151296f, -0.07124750f, 0.12065581f, 
    0.02258146f, 0.01186979f, 0.02680424f, -0.01050356f, 0.06174711f, 0.00496640f, -0.05281310f, 0.15234169f, 
    0.45866695f, -0.15435208f, 0.01376443f, -0.03679167f, 0.11127054f, 0.07446562f, 0.04789554f, 0.04999328f, 
    0.09795206f, 0.04790165f, 0.09137822f, 0.01952680f, 0.02957603f, -0.10729049f, 0.08333510f, -0.10429168f, 
    0.15049508f, 0.07855976f, -0.00621298f, 0.03652146f, -0.01551817f, 0.11211662f, -0.04659186f, 0.04014694f, 
    0.29531854f, 0.01633996f, 0.15024036f, 0.11473338f, -0.02667154f, -0.06738362f, -0.16115282f, 0.06546195f, 
    -0.03785260f, 0.04643525f, -0.05455175f, 0.06404761f, -0.33512309f, 0.09459862f, -0.10940909f, 0.05150402f, 
    -0.01971661f, -0.12043475f, -0.05344010f, 0.01740535f, -0.09106322f, 0.09993430f, -0.03195294f, -0.07424241f, 
    0.02803376f, 0.11605428f, 0.12861502f, 0.10846628f, -0.04141996f, -0.04549934f, -0.04398826f, 0.16715612f, 
    -0.09327812f, -0.02353263f, -0.03060148f, -0.07621595f, 0.16326176f, 0.09817640f, -0.05004283f, 0.18568899f, 
    -0.13883041f, -0.15736809f, -0.05025813f, -0.08922762f, -0.05287764f, -0.02370916f, 0.00736709f, 0.07940423f, 
    -0.21087749f, -0.11371008f, -0.03299570f, -0.22553456f, 0.06314092f, -0.03331963f, 0.01207869f, -0.07237291f, 
    0.05164522f, -0.00379192f, -0.08499210f, -0.08949015f, -0.21762636f, 0.08268940f, -0.05152575f, -0.10762370f, 
    -0.07219551f, 0.00771398f, -0.00858159f, -0.09111127f, -0.09761976f, -0.02592426f, 0.00910732f, -0.02444093f, 
    0.45340076f, -0.19808602f, 0.04770412f, -0.05503879f, 0.02360737f, -0.02066751f, 0.06552535f, -0.07724224f, 
    0.00544459f, -0.02620022f, 0.06189854f, -0.09231228f, -0.27750215f, 0.09985143f, 0.02394197f, -0.17376897f, 
    0.05716053f, 0.00940375f, 0.00748870f, -0.00699441f, -0.06627774f, -0.08556348f, -0.09524166f, -0.06606480f, 
    0.27163351f, -0.17185149f, -0.01667248f, 0.10006604f, -0.05161893f, 0.02277076f, -0.02843131f, -0.03371945f, 
    0.00044198f, -0.01204267f, -0.04995203f, -0.04003163f, 0.12673742f, -0.03223797f, -0.05123655f, 0.07323126f, 
    0.01492917f, -0.04110708f, 0.00517247f, -0.09194800f, -0.13529032f, -0.02829893f, -0.06587057f, 0.04134220f, 
    0.09698410f, 0.06593060f, 0.16445452f, 0.06643715f, -0.11227330f, -0.05778041f, -0.01393662f, 0.03813772f, 
    -0.01403032f, 0.09735453f, -0.00318943f, -0.06028932f, 0.11970454f, -0.04412423f, 0.21152256f, 0.24378835f, 
    -0.22841363f, -0.03822346f, 0.04948371f, 0.02821319f, -0.02216308f, -0.04885151f, -0.03615478f, 0.00576429f, 
    0.09160441f, -0.32520965f, -0.03155153f, -0.20631374f, 0.07917161f, -0.10283474f, 0.10784604f, -0.15197621f, 
    -0.05900978f, 0.07041319f, 0.05700805f, 0.02280198f, 0.18571261f, -0.11432655f, 0.00308632f, -0.11824645f, 
    -0.04218725f, -0.00183451f, -0.19032042f, -0.05734658f, 0.03882568f, -0.11767606f, 0.06423309f, -0.04926403f, 
    0.23256387f, 0.10863960f, -0.09469208f, 0.10441446f, 0.14481401f, 0.01287402f, -0.02536672f, -0.03159437f, 
    -0.04482628f, -0.01500550f, -0.05910230f, -0.05738049f, -0.06168173f, 0.01945331f, -0.00957071f, -0.16294906f, 
    0.06077239f, 0.08587701f, 0.01470726f, 0.00057620f, -0.04703748f, -0.13184534f, -0.00289364f, -0.15818177f, 
    -0.11246054f, 0.03024676f, 0.02260402f, -0.12450454f, -0.09040164f, 0.10680392f, -0.05055680f, -0.01238039f, 
    -0.05221802f, 0.08070385f, 0.02080051f, 0.00129232f, 0.32403716f, 0.10545646f, -0.14970766f, -0.06871001f, 
    0.02127677f, 0.04267031f, 0.03814087f, -0.01526458f, -0.03842515f, 0.08427058f, -0.03367705f, 0.00223826f, 
    -0.39881977f, -0.12555070f, 0.00806845f, 0.11805525f, 0.01333661f, 0.07469321f, -0.06100605f, -0.10092466f, 
    0.02013334f, 0.09679478f, -0.08433400f, -0.01545047f, 0.07684410f, -0.14082074f, -0.14768784f, -0.10655054f, 
    0.11082279f, -0.00918538f, 0.00881045f, -0.02233072f, 0.05611425f, 0.01279104f, 0.00011930f, -0.05091822f, 
    0.28773457f, -0.04346887f, 0.08971685f, 0.14241183f, -0.13092372f, -0.02507129f, -0.04729629f, 0.04760363f, 
    0.08713628f, -0.07598054f, -0.00522593f, 0.05083988f, 0.08411333f, 0.10330688f, 0.05187706f, 0.01940604f, 
    -0.19063957f, -0.15644822f, -0.00748661f, 0.00275432f, -0.08761719f, -0.09897523f, -0.09869634f, 0.00333977f, 
    0.19999446f, 0.11956399f, -0.00741402f, 0.19957678f, -0.03762887f, 0.03278891f, -0.01115832f, -0.12558192f, 
    -0.01397027f, -0.10019264f, -0.11216823f, 0.05505823f, 0.21689202f, -0.02757557f, -0.12903473f, -0.08476988f, 
    0.01503072f, -0.05396174f, -0.00619664f, 0.06809735f, -0.06729987f, 0.01325794f, 0.08210273f, -0.00865727f, 
    0.04623594f, 0.14241347f, -0.15274476f, 0.06822081f, 0.05116326f, 0.05852055f, 0.03142955f, -0.02716454f, 
    -0.08154006f, 0.05592950f, -0.02833387f, -0.01412575f, -0.00282123f, -0.02017825f, 0.01986589f, -0.07300406f, 
    0.09501983f, -0.02758175f, 0.00951957f, 0.03107867f, 0.00897117f, -0.06223316f, -0.05064914f, -0.04087137f, 
    0.17835133f, 0.07057912f, 0.03560788f, -0.17936772f, -0.05125015f, 0.05873274f, -0.00119314f, 0.03349503f, 
    -0.06763101f, -0.06405254f, 0.00578824f, -0.10711084f, 0.06787378f, -0.14227003f, -0.13331616f, -0.08429225f, 
    0.01280446f, -0.01345311f, 0.01646190f, -0.01871012f, -0.10899726f, -0.04948080f, 0.01784878f, -0.06108087f, 
    -0.06573721f, -0.02604743f, -0.30559281f, -0.06094233f, 0.12392620f, 0.04670973f, 0.03207162f, -0.08684258f, 
    -0.02813066f, -0.02347070f, -0.01757760f, -0.06114813f, -0.05896007f, 0.06119847f, 0.05473375f, 0.20674983f, 
    0.03549475f, -0.08078885f, -0.02511037f, 0.08171406f, -0.00534200f, 0.06067491f, 0.01047056f, -0.00154016f, 
    -0.18505365f, -0.14001727f, 0.00491786f, -0.25840509f, 0.06015570f, -0.01771034f, 0.04014098f, -0.03242769f, 
    -0.05924371f, 0.05895741f, 0.03566429f, -0.09281058f, 0.02004294f, 0.01655859f, -0.02737660f, -0.08846735f, 
    0.06733119f, 0.05876328f, 0.03305422f, -0.01516727f, -0.10562979f, 0.12651953f, -0.11493944f, -0.05835086f, 
    0.10485825f, 0.11543041f, 0.12148376f, -0.02397096f, 0.00259454f, -0.00371661f, 0.08967373f, 0.03594778f, 
    0.00067908f, 0.02359518f, 0.14002669f, -0.13062564f, -0.12296426f, 0.01615962f, 0.02167245f, 0.00241188f, 
    -0.11383984f, -0.04374046f, 0.04107310f, -0.03068454f, -0.12895483f, 0.02468898f, 0.00275107f, -0.04617099f, 
    -0.11764392f, 0.03701263f, 0.06292531f, 0.03431342f, 0.12701562f, 0.00976802f, 0.00417697f, 0.00165756f, 
    0.00742903f, -0.05394549f, 0.00193109f, 0.00973002f, 0.18002446f, -0.02304762f, -0.17355868f, 0.09738962f, 
    0.06828935f, 0.00798937f, -0.07473954f, -0.00588268f, -0.06640811f, 0.09660899f, 0.02322531f, -0.00813735f, 
    -0.10798644f, -0.01707239f, -0.01216820f, 0.04335083f, 0.10714296f, -0.02008371f, 0.00930240f, 0.00257800f, 
    -0.02707416f, -0.06941426f, -0.08947959f, -0.03705379f, -0.02624187f, 0.22116359f, 0.02037424f, 0.09325969f, 
    -0.01919373f, -0.08114395f, -0.03116731f, 0.05273809f, -0.08061160f, -0.04888134f, -0.05104811f, -0.06090353f, 
    0.20859143f, -0.11978511f, -0.11019684f, 0.08427497f, -0.09492628f, -0.09870936f, -0.03815290f, -0.08506089f, 
    0.05925848f, 0.02546830f, 0.02407504f, 0.02577396f, 0.16246432f, 0.02985862f, -0.01419441f, -0.00898610f, 
    0.06367381f, 0.02778667f, 0.00460131f, -0.04490291f, -0.11529750f, 0.12322770f, 0.07812734f, -0.06711792f, 
    -0.31261754f, -0.06067096f, -0.16771162f, -0.26315990f, -0.02149356f, -0.03664188f, 0.03127402f, -0.01379661f, 
    -0.05104129f, 0.00293155f, 0.06887257f, 0.04087755f, -0.22180231f, -0.03446566f, -0.08186053f, -0.02157881f, 
    -0.09581830f, 0.11972789f, -0.11364580f, 0.07212047f, -0.03738614f, 0.03980983f, 0.13866130f, -0.06682816f, 
    0.10152166f, -0.03644209f, 0.00656916f, -0.01296353f, 0.06032020f, -0.08889014f, 0.02627413f, 0.06585675f, 
    -0.09182745f, 0.07401662f, 0.04845800f, -0.12550132f, 0.00480359f, -0.14621960f, -0.02448110f, -0.03765491f, 
    0.05969012f, 0.04959089f, 0.04473895f, -0.01225182f, -0.02209137f, 0.03362554f, -0.06032325f, -0.02054083f, 
    0.32044160f, -0.00507847f, 0.01398204f, -0.07696297f, -0.17222431f, 0.05872252f, -0.09117342f, 0.02088756f, 
    -0.01504327f, -0.04479563f, -0.03093288f, -0.04366980f, -0.42178634f, 0.04021242f, -0.02805206f, 0.13281667f, 
    0.04231696f, 0.01398080f, -0.02186870f, 0.03722437f, 0.03370678f, -0.05030176f, -0.01314431f, -0.06460617f, 
    -0.11728187f, -0.14865419f, 0.11386888f, -0.18973646f, -0.01389386f, -0.03632681f, -0.02254009f, 0.02897361f, 
    0.12905972f, 0.01253808f, -0.01776358f, 0.02826415f, -0.10483041f, -0.12890297f, -0.12981403f, -0.00758084f, 
    -0.10944179f, -0.08113475f, 0.12058166f, 0.02716998f, 0.07735958f, -0.07050404f, -0.05618290f, -0.06337237f, 
    -0.50367653f, 0.07455234f, -0.14477943f, 0.07854049f, -0.04004505f, 0.03090806f, 0.00825959f, -0.07005224f, 
    -0.13458297f, -0.01701846f, 0.06426074f, -0.08133058f, -0.02936501f, 0.18987982f, -0.09027380f, -0.09992182f, 
    0.02275862f, -0.02213077f, -0.04251093f, 0.10056300f, -0.03512340f, -0.12561944f, -0.04087458f, -0.07242568f, 
    -0.35272339f, 0.02162203f, 0.00527946f, -0.04486473f, 0.04084912f, -0.06362090f, 0.01038987f, 0.04915146f, 
    0.08881366f, -0.02387207f, -0.00055100f, -0.04960857f, 0.09988904f, -0.18740012f, 0.00463945f, 0.04425299f, 
    0.01128950f, -0.05437126f, 0.06562836f, 0.00108373f, -0.02044302f, -0.10507409f, 0.00881473f, -0.00017314f, 
    0.40050077f, 0.03683653f, 0.04177537f, 0.12566347f, -0.01270361f, -0.01281747f, -0.14684679f, 0.05906240f, 
    0.05819629f, -0.06520904f, -0.03330569f, -0.08414495f, 0.17361136f, 0.05108147f, 0.06878386f, 0.06975759f, 
    0.09180664f, -0.08203028f, -0.00767310f, -0.02411483f, -0.03999429f, -0.00465981f, -0.03231214f, -0.05324233f, 
    0.14754434f, 0.24211971f, -0.11531600f, 0.04482564f, -0.01172158f, 0.08443636f, -0.04964955f, 0.04768205f, 
    -0.01193232f, 0.11302439f, -0.09227943f, 0.12689938f, -0.31907231f, -0.19276410f, -0.08118331f, -0.01425200f, 
    -0.03947988f, 0.00596740f, -0.03720851f, 0.05437077f, -0.02172950f, 0.03382205f, -0.05999340f, 0.00525916f, 
    -0.17476942f, 0.01013587f, 0.00173304f, 0.07346707f, -0.09214126f, -0.04160933f, 0.08669115f, -0.03811100f, 
    -0.04660973f, -0.01398470f, 0.07231012f, 0.10392479f, 0.16491695f, 0.01540509f, 0.17559737f, -0.15240033f, 
    -0.05020853f, -0.02543978f, -0.08548695f, 0.05650196f, 0.00522354f, -0.03376924f, -0.00257883f, -0.01972170f, 
    -0.13557586f, -0.09371183f, -0.01334046f, 0.15274656f, -0.03551216f, -0.04007857f, 0.04151826f, 0.05589814f, 
    -0.01287362f, 0.03911965f, -0.07573400f, 0.04431324f, -0.06155699f, -0.01748765f, 0.06296874f, -0.04712831f, 
    -0.04982622f, 0.04685371f, 0.08075105f, -0.01379675f, -0.06012450f, -0.02338012f, 0.03206746f, 0.08665735f, 
    -0.08527761f, -0.10557266f, -0.08598830f, 0.15965007f, 0.01290022f, 0.12821089f, 0.10651965f, -0.06301608f, 
    -0.08249015f, -0.00049787f, -0.01868373f, -0.06597327f, -0.51578182f, -0.16486259f, 0.11613467f, -0.12256239f, 
    -0.05729533f, -0.08567166f, 0.06850129f, 0.06344964f, 0.04058477f, -0.13931546f, -0.00511891f, -0.02403681f, 
    -0.06174974f, 0.00332357f, 0.13124050f, 0.04155061f, 0.06118846f, 0.07585432f, 0.07103918f, -0.03947890f, 
    0.04108961f, 0.11590346f, 0.01940746f, -0.02998076f, -0.22815357f, -0.35561824f, -0.08018457f, 0.09379412f, 
    -0.09791709f, 0.00446665f, -0.05365488f, 0.01011460f, 0.13061368f, -0.06981869f, 0.00815653f, 0.09251089f, 
    -0.02039020f, 0.04179541f, -0.08122828f, -0.05489433f, -0.02479318f, -0.03867044f, 0.05448921f, 0.01161545f, 
    0.01077105f, -0.03415037f, -0.09484412f, -0.02262572f, 0.11500060f, 0.02291446f, -0.04402827f, -0.03097375f, 
    -0.02529410f, 0.08746328f, 0.02812169f, -0.01646350f, -0.03118212f, 0.07091375f, -0.11812714f, -0.07692537f, 
    -0.22224382f, -0.19350992f, -0.06927512f, -0.12082461f, 0.01572570f, -0.04204595f, -0.02936807f, -0.04159010f, 
    0.01230386f, -0.04673095f, 0.01471219f, -0.03950225f, 0.00364564f, 0.04754611f, 0.01814083f, 0.02724899f, 
    -0.11859803f, -0.06609225f, 0.04732714f, -0.04626368f, -0.14733383f, 0.05013866f, 0.05998784f, 0.07107143f, 
    0.24931563f, 0.20094267f, 0.16826104f, 0.05093627f, 0.02685035f, 0.01449860f, 0.03249694f, -0.06896182f, 
    0.07672641f, 0.10728909f, 0.03567133f, -0.05605798f, -0.37110186f, -0.32766867f, -0.06922434f, 0.01387776f, 
    -0.07526604f, 0.05632518f, 0.01942166f, 0.00100460f, -0.00213168f, -0.06190072f, -0.02513098f, -0.01637678f, 
    0.05138316f, -0.00694810f, 0.09868629f, 0.09580366f, -0.01726613f, -0.07699700f, -0.01693267f, -0.11848810f, 
    -0.04433402f, -0.01824264f, -0.09235425f, 0.01749644f, 0.17929746f, 0.06460302f, -0.01087628f, 0.12697859f, 
    0.06099224f, 0.06287570f, -0.06291904f, 0.12508181f, 0.02021468f, 0.00185827f, -0.06481195f, -0.08246662f, 
    -0.05036433f, 0.09934317f, 0.07132880f, -0.00285425f, -0.10120484f, -0.07699201f, -0.00719276f, 0.03821488f, 
    -0.07942597f, 0.02852472f, -0.11605088f, -0.05107123f, 0.40986365f, -0.17814237f, 0.18160762f, 0.14340433f, 
    0.04356081f, 0.02656153f, 0.01265492f, 0.11594962f, -0.05246043f, 0.02086613f, -0.15586628f, -0.02834190f, 
    0.12028774f, -0.17100021f, 0.02187616f, -0.27921331f, -0.07614703f, -0.05928451f, -0.10777602f, -0.01810274f, 
    0.04226084f, -0.01733429f, 0.06720740f, -0.02343943f, -0.04359261f, -0.06838503f, -0.11940226f, -0.16368178f, 
    -0.15133092f, 0.04396402f, -0.02634654f, -0.01986985f, -0.00573402f, -0.01300496f, -0.02265102f, 0.04129171f, 
    0.28861654f, 0.08751635f, 0.01681506f, -0.13164477f, 0.02687446f, 0.00751061f, -0.04545897f, -0.00791365f, 
    -0.04128060f, 0.03556285f, 0.01931314f, -0.03210298f, 0.04709781f, 0.17512870f, 0.16362374f, 0.09792222f, 
    -0.01597585f, -0.07789923f, -0.07366856f, -0.03214768f, 0.01859938f, 0.01439372f, 0.09158560f, -0.06119217f, 
    -0.27085233f, -0.10586641f, 0.11631384f, 0.10370769f, 0.02243885f, 0.04719496f, 0.05615757f, -0.05406541f, 
    -0.11125363f, -0.03514026f, -0.08507641f, -0.20193739f, -0.09117310f, 0.14557174f, 0.03393643f, 0.07131552f, 
    0.01190294f, 0.07104146f, 0.01377222f, 0.03886520f, -0.01095846f, -0.09427668f, -0.03005492f, -0.06621580f, 
    0.11587161f, -0.00371109f, -0.11811523f, -0.00701804f, 0.09519688f, 0.03950717f, 0.06326848f, 0.04399490f, 
    -0.02020398f, -0.06532960f, 0.01696101f, 0.00665738f, 0.05920822f, 0.15815417f, 0.18077968f, -0.12925786f, 
    0.05526989f, -0.00935045f, 0.02227494f, 0.00333767f, 0.00218257f, -0.07803503f, -0.01448742f, 0.05502502f, 
    0.08659855f, 0.19316797f, 0.04365281f, 0.04131574f, -0.08231048f, -0.00722698f, -0.00984013f, 0.00602332f, 
    0.04423141f, 0.08810554f, -0.08166974f, 0.08131048f, -0.45201361f, -0.18376867f, 0.08842239f, 0.01244982f, 
    -0.05004826f, -0.04739046f, -0.05578772f, -0.02459218f, 0.02757722f, 0.05138315f, 0.00017856f, 0.04657242f, 
    0.04144372f, -0.01025916f, 0.00551351f, 0.08022211f, -0.02606331f, -0.06118102f, 0.04066282f, 0.02801957f, 
    -0.07647143f, -0.03290009f, 0.01669525f, -0.06642901f, 0.06652852f, -0.06024562f, -0.02593555f, -0.10428325f, 
    -0.13014324f, -0.08832284f, -0.01447381f, 0.11632839f, 0.00774495f, 0.02193938f, 0.00055199f, 0.07832425f, 
    -0.27321482f, -0.10553667f, -0.05819641f, 0.23524058f, 0.02488691f, -0.00610021f, 0.13619913f, 0.05922141f, 
    -0.00025097f, 0.01563835f, 0.05922011f, 0.00252865f, 0.26411563f, -0.37766400f, -0.07454387f, -0.18022467f, 
    -0.00461716f, 0.00258729f, -0.00635839f, -0.03421820f, 0.04357018f, -0.02887538f, 0.07995247f, 0.00506327f, 
    0.13891266f, -0.22620884f, -0.03917134f, 0.22641174f, 0.07910152f, 0.09976123f, 0.02750102f, -0.02571131f, 
    0.01792101f, -0.06870307f, -0.07170860f, -0.07315919f, -0.05716483f, -0.16395159f, -0.03886164f, 0.00969221f, 
    -0.00312688f, 0.13938953f, 0.08573027f, -0.13370930f, 0.11986018f, -0.16087402f, 0.10243328f, 0.02722579f, 
    -0.33223662f, 0.12716520f, -0.05636569f, -0.00781819f, -0.17854641f, 0.02041780f, -0.09741894f, -0.08722144f, 
    -0.03779025f, -0.00791497f, -0.03687887f, 0.05028815f, 0.32585156f, 0.03094969f, -0.11951713f, 0.00246701f, 
    0.06100931f, 0.02868963f, 0.08274683f, 0.07443953f, 0.01028802f, 0.04221261f, 0.10422640f, -0.01092745f, 
    0.17793445f, 0.12133715f, 0.02546017f, 0.02386784f, 0.06409976f, 0.05957735f, 0.11346395f, -0.12107449f, 
    -0.01085917f, 0.09457278f, -0.03792433f, 0.03036647f, -0.07682253f, -0.06914268f, -0.04906366f, -0.04276817f, 
    -0.14764807f, 0.02948114f, 0.02690290f, 0.00467617f, -0.08360936f, 0.08487085f, -0.00273489f, 0.00943647f, 
    0.07715354f, 0.10756449f, -0.07653444f, 0.30078322f, -0.02847581f, -0.07639270f, -0.02896806f, 0.02669311f, 
    -0.02865270f, -0.02670956f, -0.05094859f, -0.01530014f, 0.09107254f, -0.18933360f, -0.04961710f, 0.21513616f, 
    -0.02535011f, 0.02666137f, 0.09013117f, -0.15443252f, 0.08808526f, 0.03972283f, 0.01159362f, 0.09347783f, 
    -0.27215254f, -0.13126412f, -0.23103841f, 0.08524811f, -0.07432651f, 0.11230610f, -0.07133089f, 0.06049222f, 
    -0.04764501f, 0.04185837f, -0.04300542f, 0.03738239f, -0.15159918f, -0.08260881f, -0.03955872f, 0.18315153f, 
    -0.09381272f, 0.04821298f, 0.16737638f, 0.11102206f, 0.00096400f, 0.03745024f, 0.06643863f, 0.04290300f, 
    -0.24447219f, -0.38805437f, -0.16881651f, 0.13965634f, -0.13740210f, 0.03748094f, 0.00310069f, -0.01522419f, 
    -0.03400904f, -0.08364328f, 0.07536554f, -0.01005559f, -0.15909445f, 0.18510456f, 0.12207972f, -0.18351506f, 
    -0.12387443f, 0.02827363f, 0.00084936f, 0.11070781f, -0.00468642f, -0.03435408f, 0.06422996f, 0.10681238f, 
    -0.21874198f, -0.29592878f, -0.20761807f, 0.01381995f, -0.08512650f, -0.17346089f, 0.05643165f, -0.07247500f, 
    -0.01552818f, 0.00725171f, 0.03975067f, -0.02038134f, 0.01285193f, 0.10583340f, -0.09141710f, -0.09094132f, 
    0.02312593f, 0.04600316f, -0.11835418f, -0.19956884f, 0.00873881f, 0.11205532f, 0.08614252f, -0.07280148f, 
    0.08270274f, 0.04200407f, 0.01693811f, -0.06593088f, -0.11436116f, -0.06235640f, -0.11165389f, 0.05100136f, 
    -0.03018897f, -0.01531442f, 0.03485133f, 0.10988391f, -0.12413591f, -0.09156206f, -0.14575052f, -0.13982792f, 
    0.07225858f, -0.03862108f, -0.06406165f, -0.12825003f, 0.10065557f, -0.03469341f, -0.05204641f, 0.01837970f, 
    0.30676323f, -0.32476020f, -0.06129445f, -0.00022685f, -0.00514132f, 0.07932785f, -0.05839402f, 0.11096941f, 
    0.04413403f, 0.05341622f, 0.00400813f, 0.04765109f, -0.03379167f, -0.33327097f, -0.06094256f, 0.11411081f, 
    0.00369395f, -0.00703483f, -0.01630287f, -0.04768752f, -0.13293177f, -0.02501115f, -0.02839760f, 0.08925635f, 
    0.07642098f, -0.28253767f, -0.19437686f, -0.13635360f, -0.02331616f, -0.01305197f, -0.04155659f, 0.00470344f, 
    0.05213425f, -0.09021673f, 0.07902586f, 0.02974116f, 0.01230883f, -0.09796329f, 0.00937363f, 0.04143132f, 
    -0.04248853f, 0.00421323f, 0.11741998f, -0.00776255f, 0.02271797f, 0.02084897f, 0.02037253f, 0.01410543f, 
    0.17866954f, -0.14206287f, 0.02220878f, -0.06281801f, -0.03036695f, -0.14864735f, -0.02325840f, -0.04591042f, 
    -0.10786760f, -0.06688946f, 0.01415564f, -0.07761551f, 0.09016331f, 0.02739430f, -0.00980079f, 0.15334556f, 
    -0.01898951f, 0.07549057f, -0.05052715f, -0.02034490f, -0.03568801f, 0.04461735f, -0.02944103f, 0.01084996f, 
    0.12296718f, 0.11169132f, 0.04603934f, 0.06422962f, 0.11207716f, -0.05825964f, 0.06853805f, -0.00375729f, 
    0.00859275f, -0.07000606f, 0.00571711f, -0.05722099f, 0.27972791f, -0.13012849f, -0.02725195f, 0.03914212f, 
    -0.07833134f, 0.08741863f, -0.00494796f, 0.05286781f, 0.02867151f, 0.04317219f, -0.05187565f, 0.01009922f, 
    -0.50863963f, -0.09055647f, 0.06974529f, -0.01812300f, -0.03881175f, -0.05588693f, 0.04397430f, -0.06745736f, 
    0.09194975f, 0.04094238f, -0.04643459f, -0.04400410f, -0.14847365f, -0.22782704f, -0.05869212f, 0.13163212f, 
    0.04643710f, 0.06394462f, 0.00463919f, 0.07594227f, -0.02192925f, -0.09494745f, -0.09904896f, -0.05731920f, 
    -0.04061648f, 0.15250492f, -0.21455534f, -0.08629186f, 0.05916741f, -0.04457152f, 0.08561601f, 0.13653012f, 
    0.00826772f, 0.15834528f, -0.07031737f, 0.03228392f, -0.15070306f, 0.15470801f, 0.13788535f, -0.33773011f, 
    0.12642561f, -0.03898444f, -0.15865722f, 0.03648395f, 0.10914168f, -0.04543957f, -0.00644989f, 0.08904127f, 
    -0.18804996f, 0.08007201f, 0.16414516f, 0.05726860f, -0.12309650f, -0.02885672f, -0.06342989f, 0.01409052f, 
    -0.03753825f, -0.05158180f, 0.15867093f, -0.00977937f, 0.00631656f, -0.07071393f, -0.07390524f, -0.09472892f, 
    0.13508326f, 0.00946658f, -0.03609947f, -0.00768303f, -0.01709330f, -0.04511803f, 0.04220420f, 0.03714545f, 
    0.16055277f, 0.10157854f, 0.03904260f, 0.00623042f, 0.06726113f, 0.14264348f, 0.13618954f, 0.03182944f, 
    0.06713966f, 0.02395821f, 0.06533463f, 0.08773797f, -0.26296481f, -0.21129279f, 0.08568644f, -0.15289064f, 
    -0.09030160f, 0.16757037f, 0.04587554f, -0.01119098f, 0.07477285f, -0.13019012f, -0.11288985f, -0.17539424f, 
    0.17870183f, 0.06479505f, 0.09171678f, 0.07496296f, 0.00903807f, -0.05994501f, 0.05374225f, 0.07256180f, 
    0.07134244f, -0.10283316f, -0.02028880f, 0.03307469f, 0.21851239f, 0.15323988f, -0.12825131f, 0.10982617f, 
    0.03011354f, -0.13886258f, -0.03013667f, -0.05220484f, -0.05739672f, -0.06689297f, -0.06231158f, -0.02976724f, 
    -0.14042449f, -0.09325843f, -0.04594970f, 0.11971687f, -0.01906903f, 0.03831634f, 0.05502490f, 0.03725396f, 
    0.00757404f, 0.05012638f, 0.12383021f, 0.02424939f, -0.44977373f, -0.15923938f, 0.00774166f, 0.29062781f, 
    0.08236964f, -0.02864288f, 0.13428277f, -0.07884878f, -0.14923401f, -0.00268234f, 0.00496659f, 0.02287414f, 
    -0.20901613f, -0.04627557f, 0.17038015f, 0.16641244f, -0.10627545f, 0.04321206f, 0.02255105f, -0.02332653f, 
    0.09406245f, -0.03967823f, -0.08590359f, -0.01732786f, 0.13791619f, 0.10623293f, -0.24691135f, 0.05100521f, 
    -0.09570596f, -0.01094691f, 0.10105500f, -0.08415509f, -0.11912581f, -0.15883490f, 0.05698825f, -0.02516365f, 
    -0.34300855f, 0.13820030f, -0.09590900f, 0.01351919f, 0.00187728f, -0.00259632f, 0.07455571f, 0.01153625f, 
    -0.07116646f, -0.08225271f, -0.03341385f, 0.12634821f, -0.03506478f, 0.05868766f, -0.10473850f, 0.02368314f, 
    0.04504398f, -0.06615020f, -0.08235551f, 0.11629666f, -0.09548531f, -0.02125577f, 0.00395009f, 0.12335512f, 
    -0.26096496f, 0.13931727f, -0.28908229f, 0.01242377f, 0.02766128f, 0.03125599f, 0.07229307f, -0.06350581f, 
    -0.09797703f, -0.06637761f, 0.05932194f, -0.07212655f, 0.14777711f, 0.02010409f, -0.03546642f, 0.10190593f, 
    -0.01535817f, 0.03590979f, 0.05933022f, -0.01979661f, -0.03949462f, -0.04546367f, -0.05079224f, -0.05977372f, 
    -0.40453774f, -0.05149209f, -0.12417736f, 0.14724380f, -0.05201310f, -0.05773401f, 0.01463276f, 0.05209419f, 
    0.04969243f, 0.02203736f, 0.04907701f, 0.10938424f, -0.07162731f, -0.01495290f, -0.02497931f, 0.05585277f, 
    0.02296436f, 0.08660048f, -0.03984363f, 0.06786622f, -0.07001824f, -0.07252304f, 0.08135827f, -0.10354678f, 
    0.10601401f, -0.08220203f, -0.17570934f, 0.10479537f, -0.03153340f, 0.06694423f, 0.02630368f, 0.05643486f, 
    -0.11173902f, -0.02472463f, 0.03905123f, 0.09131259f, -0.00529928f, -0.15783344f, 0.16892412f, -0.03825649f, 
    0.03615385f, 0.03069375f, 0.19200274f, -0.05323494f, 0.04695262f, -0.00264875f, -0.03722436f, -0.03170632f, 
    -0.28154045f, 0.14551446f, -0.12733616f, -0.13863541f, 0.00760803f, -0.02221087f, -0.05480896f, 0.03437762f, 
    0.00972045f, 0.01723544f, -0.03317649f, -0.09545743f, 0.01789973f, -0.24272545f, 0.01046926f, -0.04096499f, 
    -0.02622310f, 0.02868832f, -0.01536946f, -0.00072634f, 0.01796195f, -0.06058688f, 0.04970275f, -0.00957140f, 
    -0.34132853f, 0.05958648f, 0.05496031f, -0.06677749f, 0.05026913f, 0.03827687f, 0.04301535f, 0.05362468f, 
    0.05790896f, 0.01888928f, -0.03798127f, -0.01541839f, -0.25812075f, 0.25994226f, -0.03250302f, -0.22567259f, 
    -0.08441083f, 0.09371038f, -0.00293075f, -0.02955911f, -0.01583778f, 0.08288687f, -0.06122335f, -0.06494261f, 
    -0.11423634f, 0.12206034f, 0.07836355f, 0.15501225f, 0.06768402f, 0.02273736f, -0.12816747f, 0.02923719f, 
    0.01757274f, -0.00393769f, 0.01600633f, -0.01822994f, 0.02717941f, 0.00668840f, -0.10381523f, 0.28316081f, 
    0.03007632f, 0.02708284f, 0.10569037f, 0.06906859f, -0.05141376f, 0.17405070f, 0.14042008f, -0.01720891f, 
    0.03924909f, -0.14397316f, -0.01722585f, 0.03923063f, -0.00005660f, 0.08088204f, -0.04283477f, 0.13038933f, 
    -0.14398350f, -0.06904048f, -0.05793430f, 0.01036420f, 0.02156041f, 0.16067077f, 0.06652316f, 0.00968345f, 
    -0.02310955f, -0.16386236f, -0.02362966f, 0.06311008f, -0.01223435f, -0.12371191f, -0.00907462f, -0.02817125f, 
    -0.28897801f, -0.03860932f, 0.21175204f, 0.18949583f, -0.11720907f, -0.11059830f, -0.01384804f, -0.08703856f, 
    0.08638703f, 0.00587185f, -0.07841237f, -0.11897271f, -0.04692778f, -0.09634898f, 0.12026461f, 0.04016603f, 
    -0.00783812f, -0.06606518f, 0.08389942f, -0.21261536f, 0.08185292f, -0.03748421f, -0.10141596f, 0.03507910f, 
    -0.04658701f, -0.25999814f, 0.11435100f, -0.11678980f, 0.01655895f, 0.09636647f, -0.12454379f, -0.10708105f, 
    0.05768989f, 0.06068505f, -0.14603764f, 0.02472769f, 0.51996005f, 0.36532241f, -0.12706447f, -0.21967588f, 
    0.08373692f, -0.11935955f, 0.11315867f, -0.01067991f, 0.11699641f, 0.04297471f, -0.17885111f, -0.00681763f, 
    -0.02787897f, -0.15704671f, -0.23329902f, 0.11160383f, -0.04020883f, 0.04783737f, -0.09601676f, -0.06370585f, 
    -0.18579832f, 0.05502782f, 0.05290492f, 0.06649020f, 0.08904252f, 0.11967678f, -0.02630365f, 0.13555998f, 
    -0.11170319f, -0.05008545f, 0.05360371f, 0.07033906f, -0.02142562f, 0.10299645f, -0.13554108f, 0.03958246f, 
    -0.76946974f, 0.07407293f, -0.03271604f, 0.07562645f, 0.10629050f, -0.03157518f, 0.04350060f, 0.02935432f, 
    -0.05970281f, -0.02247000f, 0.06330347f, 0.08139129f, 0.10069700f, 0.11001611f, 0.07191837f, 0.00901056f, 
    -0.00173153f, 0.07021352f, 0.03226910f, 0.04803842f, 0.06477307f, -0.09069189f, 0.02370282f, 0.01231662f, 
    -0.00108874f, -0.05324924f, -0.03870884f, -0.02504510f, -0.12568972f, -0.08294867f, -0.05052121f, -0.03575100f, 
    0.02229249f, -0.03492822f, -0.08333369f, -0.11635961f, 0.32141602f, 0.04738844f, 0.02302518f, 0.00629247f, 
    0.02694372f, 0.05490790f, 0.04039349f, -0.07973048f, 0.01451510f, -0.04566585f, 0.15365954f, -0.03481505f, 
    -0.10112321f, -0.04472481f, 0.12419683f, 0.04357246f, -0.07975627f, 0.02988834f, -0.04208247f, 0.02020635f, 
    0.05785414f, 0.05950975f, -0.09570177f, -0.03390220f, 0.23690847f, -0.08420311f, -0.08683658f, 0.03703706f, 
    0.06882047f, -0.08725309f, 0.08730638f, 0.02582851f, 0.08140531f, 0.03770122f, 0.01079275f, -0.05671771f, 
    -0.31452677f, -0.06656297f, 0.24546039f, -0.18857752f, -0.03324951f, 0.09654115f, -0.07493691f, -0.10877084f, 
    0.10746761f, -0.01720253f, -0.00931994f, -0.09062065f, -0.02652992f, 0.08018852f, -0.00285631f, -0.30137643f, 
    0.11606900f, 0.09139323f, -0.01092198f, 0.01913800f, -0.00714507f, 0.09424077f, -0.02178453f, 0.02070285f, 
    -0.07839137f, 0.04782845f, 0.04256212f, 0.08887606f, 0.01479875f, -0.00449823f, -0.01778511f, -0.08607848f, 
    0.04908897f, -0.09831380f, -0.05579353f, -0.00925076f, -0.41636181f, -0.10135144f, 0.00845472f, 0.26739162f, 
    0.07649383f, -0.08053749f, -0.07017712f, 0.04713687f, 0.02846083f, 0.07816684f, 0.14064078f, 0.01803705f, 
    -0.11087060f, -0.10532474f, -0.03666805f, 0.25351259f, -0.13314816f, -0.05176255f, 0.05632478f, 0.01004116f, 
    -0.00962792f, -0.09118578f, 0.00091448f, 0.02462824f, -0.27660683f, -0.18013252f, 0.18680085f, 0.07767230f, 
    -0.06675259f, 0.11361457f, -0.10428964f, -0.05056072f, 0.02549915f, 0.04552808f, 0.01473244f, 0.08161282f, 
    -0.31793442f, -0.28125125f, -0.09187841f, -0.05992245f, -0.15239838f, -0.03916069f, 0.05866436f, 0.11715849f, 
    0.10444934f, -0.04799250f, 0.03422756f, 0.03476763f, -0.00493761f, -0.01752838f, -0.30186075f, 0.00293917f, 
    -0.00550014f, -0.03794135f, -0.02078159f, -0.10231795f, -0.07025693f, -0.01594707f, -0.00152868f, -0.07771556f, 
    0.08425329f, 0.04457706f, -0.03818784f, 0.07022328f, 0.01327291f, -0.01676578f, 0.01476444f, 0.05653446f, 
    0.04256412f, 0.00735811f, 0.05795057f, -0.09844907f, 0.23218332f, 0.12403215f, -0.01933825f, 0.15508966f, 
    -0.04309348f, -0.10716583f, 0.09201880f, -0.02754737f, -0.06458268f, -0.03259704f, 0.07257221f, 0.17076126f, 
    -0.04844655f, 0.05412173f, -0.09283786f, -0.09622109f, -0.06104699f, -0.12177619f, 0.16273427f, 0.05622571f, 
    0.00062830f, -0.04970105f, -0.07566535f, 0.01165833f, -0.08071751f, -0.08352908f, -0.01758029f, 0.12551746f, 
    0.10066991f, -0.01690144f, 0.01822655f, 0.06884868f, 0.00444301f, -0.09819164f, -0.02864257f, -0.15223736f, 
    0.03336419f, -0.01512973f, 0.13563462f, 0.22904380f, 0.07288919f, 0.04211128f, 0.05078782f, 0.17543578f, 
    0.03666087f, 0.09603264f, 0.12021961f, 0.05969892f, -0.15282983f, 0.08229896f, -0.04418661f, 0.06823493f, 
    -0.09234204f, 0.05583239f, -0.01476463f, 0.08351175f, -0.02586118f, -0.04318601f, 0.04006444f, 0.04733044f, 
    -0.01932366f, -0.15319557f, 0.09066448f, -0.04304068f, 0.03593071f, 0.03922153f, 0.04782579f, -0.16621082f, 
    0.08788747f, 0.12994160f, 0.04323473f, 0.05522242f, -0.09421385f, -0.00422342f, 0.12293438f, -0.17861746f, 
    0.06431537f, 0.09766589f, -0.18110318f, 0.03792424f, -0.03229298f, -0.00346799f, 0.08065796f, 0.01438343f, 
    0.17720906f, 0.23659931f, 0.01678978f, 0.05491129f, -0.06107105f, -0.05707274f, 0.00965563f, 0.02986850f, 
    0.05773535f, -0.02488200f, -0.01676472f, 0.08457819f, -0.01610180f, 0.24676140f, 0.05476430f, -0.06817836f, 
    0.01679026f, 0.09321255f, 0.03051023f, -0.07368986f, 0.05383955f, 0.06750529f, 0.08435909f, -0.05122934f, 
    -0.51001108f, -0.05427859f, -0.11625380f, -0.10903731f, 0.05408328f, -0.04077009f, 0.01217821f, 0.05725502f, 
    -0.12317694f, -0.03211663f, -0.10931949f, 0.02576236f, -0.24430497f, -0.01278166f, -0.25011617f, -0.00231387f, 
    -0.04216672f, -0.03707679f, 0.02979721f, -0.08428418f, 0.05738257f, -0.16004209f, 0.00528812f, -0.01975277f, 
    0.14143705f, -0.07481854f, -0.00025062f, -0.02435786f, -0.02177325f, 0.00279579f, -0.00414723f, -0.02634374f, 
    -0.03331579f, -0.08181907f, 0.09638716f, 0.06614497f, 0.18858486f, -0.03306516f, -0.00662270f, 0.09472480f, 
    -0.12214513f, -0.06715909f, 0.08319420f, -0.16688699f, 0.12859799f, 0.10683231f, -0.02013896f, -0.04279980f, 
    -0.05610578f, -0.03285519f, 0.00192803f, 0.13342105f, -0.04781299f, -0.08576346f, -0.07958511f, 0.02109885f, 
    -0.03478308f, -0.02102122f, 0.04384944f, 0.02107857f, -0.30880827f, 0.10741230f, -0.03430954f, -0.03147212f, 
    -0.00744129f, 0.11794580f, 0.19270821f, -0.00436645f, 0.06577188f, 0.12188401f, -0.12113694f, -0.04885045f, 
    -0.20673159f, -0.06922419f, 0.23816553f, -0.03924880f, 0.10725842f, -0.10421860f, -0.05699011f, -0.05349191f, 
    0.06916088f, -0.04413952f, -0.07514735f, -0.05755374f, -0.09440822f, 0.08029976f, 0.01910768f, 0.10403728f, 
    -0.15020800f, 0.08105072f, 0.06441877f, 0.05303645f, -0.12300796f, 0.14060538f, 0.04933580f, -0.04226394f, 
    -0.15700933f, 0.06207611f, 0.02795420f, 0.31521827f, -0.19458787f, -0.03599741f, 0.12400240f, -0.02903691f, 
    0.03334025f, -0.05216941f, -0.04806000f, 0.19874813f, -0.15916276f, 0.09385610f, 0.00713162f, 0.13620962f, 
    -0.07852154f, 0.01782606f, -0.01772545f, 0.01754854f, -0.04732769f, -0.01813150f, 0.06698842f, 0.08170866f, 
    -0.20794582f, -0.15230560f, -0.00830239f, 0.37407044f, 0.13731560f, -0.07962304f, -0.14808999f, -0.00764602f, 
    0.07333822f, -0.11610078f, -0.12166413f, 0.00647960f, -0.01897267f, 0.04097831f, 0.16031992f, 0.07223536f, 
    -0.04862334f, -0.11380500f, 0.04782134f, 0.00075358f, 0.00780781f, 0.05046802f, 0.02607472f, 0.00076101f, 
    -0.13791494f, -0.40602314f, -0.08167582f, 0.06606071f, 0.15714477f, -0.04265019f, -0.05435928f, -0.08146192f, 
    -0.01638348f, 0.15580052f, 0.05991284f, 0.09885868f, -0.20838141f, -0.13837202f, 0.14990093f, 0.12477601f, 
    0.04272976f, -0.03550742f, 0.17846100f, 0.06265003f, 0.08726931f, 0.12107965f, -0.04180214f, -0.07962931f, 
    -0.09353109f, -0.05485142f, 0.19986297f, -0.05509759f, -0.10859375f, -0.10703119f, -0.04748226f, -0.13088650f, 
    0.12019109f, 0.06636186f, 0.15386477f, 0.04692548f, 0.38167816f, 0.05807179f, -0.16560811f, -0.13167053f, 
    0.06676965f, 0.10560978f, -0.12992273f, 0.11170661f, 0.10318048f, 0.00850869f, 0.08679613f, -0.18784271f, 
    -0.03007238f, 0.02598750f, -0.01077310f, -0.07234976f, 0.03675391f, -0.05661906f, 0.00664988f, -0.02351788f, 
    -0.04166808f, -0.04634021f, 0.05227722f, 0.14220572f, -0.05173081f, 0.17065814f, 0.23471814f, -0.07300840f, 
    0.04965426f, 0.05064443f, -0.00025534f, -0.15110481f, 0.04494953f, 0.06568911f, 0.14232840f, -0.12396436f, 
    -0.48569995f, 0.02669514f, 0.02277283f, -0.32159323f, 0.06968152f, -0.06404882f, -0.03871907f, -0.03024464f, 
    -0.04025712f, -0.15972427f, -0.00235982f, -0.09823284f, 0.05667823f, -0.09888696f, 0.18764636f, 0.07879838f, 
    0.09767231f, -0.03617428f, 0.12166031f, -0.05309162f, 0.07229514f, -0.07706025f, -0.05460723f, -0.23592605f, 
    -0.19802946f, 0.00342278f, 0.01207232f, -0.17024361f, -0.13140786f, -0.03886032f, 0.06511872f, -0.01168589f, 
    0.05556617f, -0.21837269f, 0.03078407f, -0.22642179f, -0.14493176f, 0.03475054f, -0.05304711f, 0.04114535f, 
    0.17529325f, 0.08777217f, -0.17590140f, -0.11704853f, 0.04727635f, 0.01115481f, 0.06711883f, -0.02641367f, 
    -0.02311824f, 0.22250444f, -0.07589849f, -0.08316869f, -0.00671247f, -0.00692504f, -0.07456639f, -0.18596481f, 
    -0.04591673f, -0.09829410f, -0.05815677f, 0.01882359f, -0.09114260f, -0.14918081f, -0.15494154f, -0.02368834f, 
    0.05530750f, 0.09372307f, -0.08098315f, -0.04602984f, 0.04680578f, 0.03264230f, 0.01380192f, -0.08603248f, 
    -0.10471170f, -0.10019632f, -0.09814634f, -0.00211501f, -0.01677271f, 0.02358134f, 0.13216430f, -0.01000279f, 
    0.10977987f, 0.04341381f, 0.04998785f, -0.10115559f, 0.09343570f, 0.15685764f, -0.05865237f, 0.02947521f, 
    -0.11603136f, 0.00582366f, -0.07995556f, 0.11218780f, 0.14701030f, -0.02931186f, 0.10915371f, 0.01618814f, 
    -0.30014214f, 0.13394630f, 0.06728755f, -0.22725548f, 0.11581260f, -0.01245302f, -0.06979701f, 0.04999187f, 
    0.06110632f, -0.04867782f, -0.11793446f, 0.01299972f, -0.07149734f, 0.11426159f, 0.07972632f, 0.13031568f, 
    -0.01663501f, -0.08768270f, -0.04178174f, 0.04291359f, -0.08132508f, 0.00513019f, -0.04164518f, 0.09834577f, 
    -0.03952442f, 0.04936717f, -0.02251527f, -0.25294170f, 0.09008366f, 0.07491878f, 0.04883864f, -0.02262512f, 
    0.00745246f, -0.05585415f, 0.07271228f, -0.08041026f, -0.15694888f, -0.25159633f, 0.25414219f, 0.29399514f, 
    -0.00054597f, -0.04067270f, -0.01107802f, -0.00823626f, -0.06633883f, 0.09670831f, 0.10253646f, 0.06315705f, 
    -0.36136442f, -0.05801877f, -0.10387499f, 0.05455384f, 0.02540952f, -0.20712173f, 0.05353696f, -0.17249943f, 
    0.18096751f, 0.00739726f, -0.03532328f, 0.11233823f, -0.00677879f, -0.19604076f, -0.06284920f, -0.11883511f, 
    0.04905013f, 0.08020527f, -0.00246201f, -0.04623486f, 0.04228039f, 0.00824067f, -0.22842056f, 0.17939733f, 
    -0.03144524f, 0.00469474f, -0.04537641f, 0.09550438f, 0.01633190f, 0.01643619f, 0.01732471f, -0.03927091f, 
    0.00494455f, -0.17827229f, -0.11258193f, -0.05195517f, -0.02581510f, -0.19085689f, 0.06180778f, 0.11678143f, 
    -0.07513932f, 0.02412652f, 0.03651316f, -0.00866094f, -0.11968207f, 0.05392320f, 0.13843162f, 0.09883764f, 
    0.12647717f, 0.05580832f, 0.01488997f, -0.02283764f, -0.09894750f, -0.08137608f, 0.07489926f, -0.02729466f, 
    -0.09603477f, -0.03089851f, 0.08873408f, 0.20872067f, -0.01480766f, 0.00828927f, -0.03857766f, 0.10758790f, 
    -0.01900214f, -0.10455927f, 0.07640651f, 0.02650512f, 0.02212749f, 0.06165298f, 0.07053372f, 0.10889912f, 
    0.03748687f, 0.02197254f, -0.02191749f, 0.18204555f, 0.04460521f, -0.10045207f, 0.06200717f, 0.06059725f, 
    0.03673441f, -0.14261225f, -0.11368246f, -0.11735735f, -0.27009267f, -0.61136669f, 0.05007766f, 0.16032107f, 
    -0.05172317f, -0.06731223f, -0.03110843f, -0.09852231f, -0.00138599f, -0.08472192f, 0.02431187f, -0.08434892f, 
    0.06120513f, -0.09473918f, 0.03734652f, 0.11518280f, 0.14875518f, 0.05049950f, 0.03246695f, 0.09135120f, 
    0.09309249f, -0.20136906f, -0.04033478f, -0.01587403f, -0.04809530f, 0.04255568f, 0.17958777f, -0.06257848f, 
    -0.03557482f, -0.00476411f, 0.10868165f, -0.07598370f, 0.02828632f, -0.16918936f, -0.05835050f, -0.06391537f, 
    -0.45710146f, 0.11262560f, -0.28706461f, -0.30463904f, 0.06887283f, 0.02200318f, 0.03699392f, -0.05182917f, 
    0.00182244f, 0.01575959f, 0.00738825f, -0.08464871f, -0.41221645f, -0.24312745f, -0.10838306f, -0.02128323f, 
    0.03510665f, 0.02280092f, -0.13187104f, 0.06097038f, 0.09363531f, 0.25740096f, 0.02319000f, 0.01736217f, 
    0.04741638f, -0.04677446f, -0.00856367f, 0.17298450f, -0.06215428f, 0.11378798f, -0.02916664f, 0.07568534f, 
    0.16805452f, 0.14729612f, 0.01144662f, 0.04748946f, 0.16692860f, 0.23166360f, 0.09936275f, -0.17272453f, 
    -0.09153397f, -0.09243286f, -0.10392185f, -0.16534065f, -0.13769019f, -0.03460864f, -0.04203165f, -0.08476323f, 
    0.02872868f, 0.00865819f, -0.00291904f, 0.07747925f, -0.12523611f, -0.07349564f, 0.04864336f, -0.08001981f, 
    -0.01488185f, -0.24268658f, 0.00941311f, 0.24193542f, 0.03372898f, 0.05399154f, 0.05577908f, -0.29337236f, 
    0.01076252f, -0.12317654f, -0.13779697f, -0.07684309f, 0.07862771f, 0.02586391f, 0.08190741f, 0.17340699f, 
    -0.05539795f, 0.05776083f, -0.00733916f, 0.13019080f, -0.03680023f, -0.05855383f, 0.09843552f, 0.06368446f, 
    -0.09996076f, 0.02223621f, -0.01515762f, -0.00002058f, 0.05272943f, 0.19093932f, 0.01313061f, -0.08401997f, 
    0.01526296f, 0.05509870f, -0.12137797f, 0.01009419f, 0.06337767f, -0.04148898f, 0.10666666f, -0.03505205f, 
    0.04451447f, 0.03964789f, 0.03596326f, 0.13541164f, -0.00175443f, -0.01803578f, -0.00947318f, 0.01700580f, 
    -0.14109115f, 0.10710958f, 0.09331191f, 0.00899831f, 0.21755278f, 0.04977374f, -0.28342748f, -0.12316269f, 
    0.07901864f, 0.16719726f, -0.03372375f, -0.13727677f, -0.02086328f, 0.00225661f, -0.20531781f, 0.01617505f, 
    -0.11491351f, 0.07162724f, 0.06896687f, -0.05934271f, -0.01998145f, 0.09922777f, 0.00929146f, 0.03732745f, 
    0.02015431f, 0.11841603f, -0.01448787f, 0.02602226f, 0.13030864f, -0.03100780f, 0.01723733f, 0.16064799f, 
    -0.02059838f, -0.01829505f, 0.07719489f, 0.10586062f, -0.22339723f, -0.00930670f, 0.09946874f, -0.02487870f, 
    0.08299703f, -0.13635989f, -0.11157100f, -0.02427670f, 0.04669676f, 0.00225879f, 0.00271465f, -0.01474126f, 
    -0.19978763f, -0.11069068f, 0.05042769f, -0.05817524f, -0.12463681f, 0.15142180f, 0.20023316f, 0.02200893f, 
    0.04487890f, -0.01994094f, -0.07537830f, -0.05937951f, 0.03262142f, -0.14662033f, 0.07279456f, 0.07944971f, 
    0.00650383f, 0.15453500f, 0.08417007f, 0.08610027f, 0.07135887f, 0.09554683f, 0.03267597f, -0.11220711f, 
    0.02051727f, 0.11500353f, -0.05298772f, 0.16136442f, 0.27715537f, -0.07955451f, 0.03811225f, 0.11400536f, 
    -0.00012927f, -0.08877812f, -0.12300529f, 0.00975927f, 0.00531879f, 0.02736583f, 0.01930178f, -0.16404080f, 
    0.07893971f, 0.08280051f, 0.19517671f, -0.00015652f, 0.13520096f, -0.01779764f, -0.07652353f, -0.17193164f, 
    -0.02606269f, 0.06938157f, 0.04869143f, 0.09378642f, -0.23921745f, -0.00083430f, -0.09111767f, -0.02218191f, 
    0.01644550f, 0.14489047f, -0.08828533f, -0.15542239f, 0.11003675f, 0.09058036f, -0.09446705f, 0.00377658f, 
    -0.23143022f, -0.01618157f, -0.24931364f, 0.18408287f, 0.17352016f, 0.15963821f, 0.00296721f, -0.04040039f, 
    -0.00956204f, -0.00470464f, 0.04802941f, -0.06227092f, -0.14274089f, -0.01235623f, 0.04725499f, -0.12256379f, 
    0.06202785f, -0.14642771f, 0.13086262f, 0.05553410f, 0.24988423f, 0.02909960f, -0.07892752f, 0.01406379f, 
    0.04092437f, 0.15915395f, 0.02962031f, 0.10941235f, 0.06572846f, 0.04473143f, 0.00482399f, 0.16245748f, 
    -0.11841692f, 0.00879883f, -0.08947278f, -0.11346889f, 0.09312380f, 0.05609873f, -0.02135871f, -0.11604559f, 
    0.09282388f, -0.11641894f, 0.14174934f, 0.02670015f, -0.02869448f, 0.14946260f, -0.04141623f, 0.03519839f, 
    -0.02658186f, -0.07668854f, -0.04292746f, -0.08144411f, -0.02710279f, 0.05174449f, 0.09450222f, -0.17998634f, 
    0.03849180f, -0.02082755f, -0.01248039f, 0.02242279f, -0.13574520f, 0.07376930f, 0.20491949f, -0.08267031f, 
    0.03000589f, -0.00086108f, -0.10239322f, 0.08856504f, 0.11131056f, -0.11878033f, 0.04594457f, -0.03228971f, 
    -0.44635272f, 0.04464796f, -0.11616898f, -0.18780755f, 0.20929892f, -0.03810146f, 0.00184202f, -0.08066282f, 
    0.07428769f, -0.02464152f, -0.00924730f, 0.11752416f, -0.31425637f, -0.29498017f, -0.07582615f, 0.03778924f, 
    -0.08247244f, -0.05137929f, 0.05238624f, -0.11911078f, 0.03338233f, 0.09263419f, -0.02536950f, -0.02562748f, 
    -0.02743773f, -0.02993164f, -0.09619027f, 0.18976389f, -0.10237277f, -0.08331009f, 0.04169790f, -0.00659393f, 
    -0.06961446f, 0.02535484f, -0.03036577f, -0.01536042f, 0.15165341f, -0.03205761f, 0.02378567f, 0.03912591f, 
    0.09839915f, -0.08203155f, 0.02448473f, -0.00593923f, -0.05867609f, 0.10799825f, -0.08092725f, -0.03139202f, 
    -0.07492559f, 0.04746050f, 0.09929855f, 0.06316605f, 0.12326101f, -0.02275284f, 0.01873348f, -0.00789167f, 
    0.03242415f, 0.04083437f, -0.06433113f, -0.04021889f, 0.24143513f, 0.04557346f, 0.05824578f, 0.09731758f, 
    -0.05914022f, 0.05459593f, -0.08517513f, -0.05443848f, -0.19406092f, 0.07779312f, 0.08879909f, -0.03336544f, 
    0.37065238f, -0.49246132f, -0.12745301f, -0.00926696f, -0.12621191f, 0.01816661f, 0.13307330f, 0.06111426f, 
    0.01381441f, 0.00755322f, 0.09836132f, 0.06187888f, 0.17745383f, 0.01279070f, -0.02726496f, -0.00392994f, 
    0.00500498f, 0.05186182f, -0.02793392f, -0.04583515f, -0.01819421f, 0.02459149f, 0.02998370f, -0.12178603f, 
    -0.00778657f, 0.03152011f, -0.16947362f, -0.04994471f, 0.03306588f, 0.03563846f, -0.06601831f, -0.01888628f, 
    0.01253255f, 0.02373715f, 0.03611826f, -0.10032467f, -0.00937294f, -0.13142480f, -0.13365704f, 0.07925899f, 
    0.02920567f, -0.03387811f, -0.08659067f, -0.01287423f, -0.05632401f, -0.06839585f, -0.16454695f, -0.03173629f, 
    0.02687543f, 0.08406413f, -0.00583852f, 0.01346106f, -0.13999522f, -0.02729925f, 0.07848988f, -0.06194684f, 
    -0.11207139f, 0.16730364f, 0.14601022f, 0.00738115f, -0.15958382f, -0.03287655f, -0.10014907f, 0.12358952f, 
    0.06774492f, -0.06336459f, -0.06801672f, 0.09388743f, -0.00797669f, -0.10157475f, -0.12593040f, -0.10243500f, 
    -0.03434559f, -0.04940575f, -0.10235758f, -0.03655138f, 0.00988167f, -0.00498400f, -0.02640267f, -0.01203235f, 
    -0.00515661f, -0.00007881f, 0.09839091f, -0.00105374f, -0.15255885f, 0.05925978f, -0.06034919f, 0.12973119f, 
    0.08991712f, -0.00088772f, -0.12509321f, 0.06333196f, -0.13931268f, -0.02520170f, 0.01772396f, 0.12466811f, 
    0.04063963f, 0.09582151f, -0.11711401f, 0.18312871f, 0.07620165f, 0.01464093f, 0.02495266f, 0.00051723f, 
    0.07814524f, -0.09838897f, -0.11920268f, -0.00861588f, -0.17358908f, -0.09224273f, -0.35673279f, -0.19422719f, 
    -0.15681519f, -0.07905655f, -0.00632461f, -0.03821861f, -0.08446541f, 0.00117620f, 0.00407255f, 0.04398398f, 
    0.04002098f, 0.26420736f, 0.18287469f, -0.36185187f, 0.03170684f, 0.09157814f, -0.02741591f, 0.00574507f, 
    -0.06906811f, 0.05333136f, 0.01814919f, -0.02510544f, -0.00229231f, -0.20375234f, 0.05117444f, 0.02412184f, 
    -0.04538332f, 0.03375163f, 0.02967618f, 0.06690086f, 0.03264131f, -0.03564689f, -0.19663757f, 0.10800163f, 
    0.50549370f, -0.06845109f, 0.11790495f, -0.15937315f, -0.02750241f, 0.05436071f, 0.06476030f, -0.01886860f, 
    0.05852231f, -0.00764463f, 0.16085242f, 0.08096150f, -0.19815044f, 0.18191740f, -0.02034459f, 0.01486256f, 
    -0.19941993f, 0.03755761f, 0.03173007f, -0.00874358f, -0.06767626f, 0.13080105f, 0.05143294f, 0.20757639f, 
    0.14091362f, -0.25496846f, 0.02003587f, -0.06066640f, -0.10601621f, 0.07317352f, -0.07697647f, 0.00599903f, 
    -0.10866065f, 0.07138361f, 0.01792465f, 0.17874046f, 0.17214240f, -0.08060971f, -0.25542030f, 0.27786055f, 
    -0.01641074f, 0.01954303f, 0.02872473f, -0.05824138f, -0.07845526f, -0.03778425f, -0.07315619f, 0.09069675f, 
    -0.04954566f, -0.50904953f, -0.09876021f, -0.11926134f, -0.04659012f, 0.05926808f, 0.02154896f, 0.04108413f, 
    0.12284633f, 0.01274496f, 0.06225810f, 0.11523867f, -0.13691480f, -0.05281189f, 0.03397268f, -0.11904050f, 
    -0.03940738f, -0.08626786f, 0.14050581f, -0.05364284f, 0.00985416f, 0.06930462f, -0.00779794f, 0.06623949f, 
    -0.09214769f, 0.13231383f, 0.06929987f, -0.08022621f, 0.00133837f, -0.09399141f, -0.05794396f, 0.00899532f, 
    -0.06036028f, -0.01554749f, 0.09537337f, 0.16288447f, -0.16177867f, 0.07672968f, 0.01875248f, -0.01695292f, 
    0.10698643f, -0.11418346f, 0.03775928f, -0.01265586f, -0.06286865f, 0.07977697f, -0.10734291f, 0.06214232f, 
    0.30119145f, -0.04779405f, 0.03463901f, -0.05315374f, -0.00666708f, 0.02624113f, 0.07773063f, 0.02630658f, 
    0.03562642f, 0.00087297f, 0.06889541f, -0.18691345f, 0.06476758f, -0.09086170f, -0.05043624f, 0.20019417f, 
    -0.00834452f, 0.03850792f, -0.02452460f, 0.07542983f, -0.05672105f, -0.16208798f, -0.04370513f, -0.07370420f, 
    0.14511728f, -0.26199320f, 0.05148964f, -0.01976457f, 0.01528840f, -0.05602786f, 0.08995089f, 0.06707697f, 
    0.06714374f, 0.00178237f, -0.12667991f, 0.05030066f, 0.16246834f, -0.07598963f, 0.03352319f, -0.04041004f, 
    -0.02507609f, 0.03416102f, 0.06460623f, 0.09408034f, 0.12810625f, -0.14337331f, -0.11142921f, -0.06337938f, 
    -0.19257227f, -0.12907231f, -0.10366836f, -0.02254564f, -0.06496242f, 0.08565123f, 0.02605166f, -0.15352695f, 
    -0.13579832f, 0.00909719f, -0.06183869f, -0.04763209f, -0.45622778f, -0.04034296f, 0.00057574f, 0.04060334f, 
    0.08748097f, 0.03618515f, -0.03575475f, -0.12570809f, 0.06944026f, -0.03214154f, 0.16878428f, -0.12738638f, 
    -0.14799590f, 0.04677383f, -0.14532180f, 0.15724128f, 0.01615147f, 0.03130575f, -0.01696633f, 0.06969535f, 
    0.07550664f, 0.09880612f, 0.01339713f, 0.12065083f, -0.06364758f, 0.04643612f, -0.08257055f, -0.17801329f, 
    0.06031740f, 0.08381508f, 0.00287160f, -0.18239272f, -0.06249604f, -0.07362676f, -0.09972799f, -0.20635805f, 
    0.08670007f, 0.19482075f, 0.04450854f, -0.23669411f, -0.02924462f, 0.03179384f, 0.02790877f, 0.00358269f, 
    0.00351000f, -0.09621265f, -0.12713403f, -0.03964993f, -0.01619957f, -0.12016198f, 0.12696040f, -0.07301581f, 
    0.17189483f, 0.09499751f, -0.03995204f, 0.11050995f, -0.09582477f, -0.05192621f, -0.03550309f, 0.05513068f, 
    -0.15916555f, 0.05621107f, -0.11706559f, -0.13117751f, 0.01768297f, -0.07043487f, -0.02286942f, 0.09815922f, 
    -0.02862116f, 0.05132473f, -0.04362025f, 0.05558369f, 0.30235645f, -0.19676597f, -0.13180143f, 0.10167050f, 
    -0.10448946f, 0.09440021f, -0.13011593f, 0.04254145f, -0.08189315f, 0.08290327f, -0.00034556f, 0.10090304f, 
    -0.07970297f, -0.07689716f, -0.05947242f, -0.22261135f, -0.02825418f, -0.07389800f, 0.06732505f, 0.02068180f, 
    -0.13183236f, 0.07649998f, -0.00445154f, 0.11735123f, -0.24976924f, 0.03317174f, 0.01866872f, -0.02946965f, 
    0.01933989f, -0.10625416f, 0.05762243f, 0.01466677f, -0.17925709f, -0.00404869f, -0.12020788f, 0.05620527f, 
    0.14477107f, -0.24232017f, -0.05894169f, -0.13747193f, 0.02295961f, 0.04699402f, -0.08281170f, -0.00219047f, 
    0.04872558f, -0.02022649f, 0.08463968f, 0.10908327f, 0.07788271f, -0.04275417f, -0.03561774f, 0.01762537f, 
    -0.03201924f, 0.05589581f, -0.03231494f, 0.01260850f, -0.00319098f, -0.06787384f, 0.03624735f, 0.02550552f, 
    0.18849209f, 0.03401460f, 0.01379474f, -0.18312323f, 0.10724852f, 0.05913051f, 0.05034255f, -0.02870150f, 
    -0.08109235f, -0.05731290f, 0.07936165f, -0.15398170f, -0.33160016f, 0.17255136f, 0.07468180f, 0.10485803f, 
    0.01867416f, 0.03962038f, 0.11866583f, 0.03041217f, -0.03789374f, -0.06098002f, -0.06155254f, 0.01720294f, 
    0.10968117f, 0.16585708f, 0.05618284f, -0.38197508f, 0.00971700f, 0.10902178f, 0.02582162f, 0.02331888f, 
    0.05518035f, 0.11078478f, -0.01222940f, -0.06847584f, 0.01749582f, 0.15053438f, 0.21208112f, -0.27145261f, 
    -0.09336146f, 0.12887216f, 0.10965893f, 0.08356155f, 0.01989567f, -0.00438170f, -0.03340835f, -0.04724882f, 
    -0.05203621f, -0.15760924f, 0.07265434f, 0.08510007f, 0.05664028f, -0.04782744f, -0.01554500f, 0.06567786f, 
    -0.11341383f, -0.02456767f, -0.03388711f, -0.02065947f, 0.15099789f, 0.03115867f, 0.23607430f, 0.42510599f, 
    0.01523682f, -0.05425544f, 0.13480276f, 0.01308071f, 0.17301919f, -0.13841824f, -0.00854132f, -0.02557825f, 
    0.03716188f, 0.07414847f, 0.05756100f, -0.00372061f, 0.08216663f, 0.01452677f, -0.07051612f, -0.03555054f, 
    0.02077603f, -0.06809514f, -0.05411350f, 0.03877690f, -0.16959937f, 0.04480962f, -0.02600271f, -0.09241862f, 
    -0.10880127f, -0.13709144f, -0.01875763f, 0.00886204f, 0.01708363f, 0.01164295f, 0.10309964f, 0.07181519f, 
    0.08883192f, -0.00106826f, -0.27034888f, -0.03449674f, -0.04015594f, -0.00321299f, -0.10248069f, 0.07093453f, 
    -0.01603885f, -0.05409563f, -0.04688066f, -0.06767005f, 0.12339231f, 0.10051591f, 0.05402211f, 0.03012090f, 
    -0.05742443f, 0.06669553f, -0.00905047f, 0.06965303f, 0.00032427f, 0.04923693f, 0.03570590f, -0.04923234f, 
    -0.34135264f, 0.24885124f, 0.06265272f, 0.14721835f, -0.00386966f, 0.01336714f, 0.02959542f, -0.00310817f, 
    0.07171997f, 0.02618471f, -0.06546652f, 0.04743567f, 0.08866966f, -0.07907723f, -0.08860765f, 0.05723587f, 
    -0.02698342f, 0.06069270f, -0.05389551f, 0.11481726f, 0.06557593f, 0.01722088f, -0.03969744f, -0.08031354f, 
    -0.18185292f, 0.10434801f, 0.13850196f, -0.21980728f, -0.17433123f, -0.00936908f, -0.02641496f, 0.11429115f, 
    -0.05764833f, -0.11784796f, 0.01006467f, -0.10006621f, -0.19933002f, -0.17897199f, -0.22177708f, 0.23900205f, 
    -0.03013973f, 0.02419263f, 0.20510255f, -0.15902913f, 0.12297494f, -0.16532852f, -0.08080990f, 0.00587500f, 
    -0.26982531f, 0.08583784f, 0.11360878f, -0.01286181f, -0.10964412f, 0.07843493f, 0.04203195f, 0.09351624f, 
    -0.06874031f, 0.01549608f, 0.02574577f, -0.10616834f, -0.28546199f, -0.27123728f, -0.03572182f, -0.02322188f, 
    -0.00683371f, 0.02223241f, 0.13114859f, 0.08306216f, -0.01901120f, -0.01052723f, 0.01955243f, 0.00432387f, 
    -0.17293622f, 0.00099963f, -0.20178583f, -0.31598711f, -0.10589881f, -0.06856021f, 0.01433526f, -0.05838095f, 
    -0.04578273f, 0.02061507f, 0.00422114f, 0.14181367f, 0.07456513f, 0.02350180f, 0.10459206f, 0.00001450f, 
    -0.04293934f, 0.01210843f, -0.04190139f, -0.05146275f, -0.13650757f, 0.09306273f, 0.04191964f, 0.01928392f, 
    -0.17338400f, 0.00160927f, -0.00014403f, 0.21981463f, 0.06047676f, 0.00837783f, -0.11251762f, 0.09991140f, 
    -0.00548060f, 0.02448522f, 0.04242161f, 0.06349506f, -0.11838232f, 0.09580269f, 0.16063163f, -0.11768446f, 
    -0.00881646f, 0.12761810f, 0.01724908f, 0.07419855f, -0.04599112f, 0.02392827f, -0.06049125f, -0.10940780f, 
    -0.36219016f, 0.19113381f, 0.08313890f, -0.00520762f, 0.03002734f, 0.07372181f, -0.01820346f, 0.01454672f, 
    -0.04509477f, 0.01873378f, 0.07510366f, -0.05208183f, 0.28090361f, 0.10684492f, -0.00052575f, -0.35149148f, 
    -0.02846022f, 0.03116139f, 0.04406504f, 0.00563888f, 0.04033234f, -0.00683747f, -0.08097540f, -0.00996392f, 
    0.01878892f, -0.15596937f, 0.06994046f, -0.10997713f, -0.03872369f, 0.01573524f, 0.07366173f, -0.04490123f, 
    0.03099214f, 0.00752090f, 0.06488429f, -0.08719868f, -0.25648156f, -0.14021237f, -0.05210067f, -0.07681736f, 
    0.04296371f, -0.01051745f, 0.11745182f, -0.10095111f, 0.04469782f, -0.11671403f, -0.12959069f, 0.09332246f, 
    -0.19243269f, -0.01507880f, -0.09236720f, -0.09050883f, 0.03426296f, 0.02222005f, 0.08329978f, -0.08582541f, 
    0.00678046f, -0.05785612f, 0.05760624f, -0.10675500f, -0.25971669f, -0.00519199f, -0.08573305f, 0.08744838f, 
    0.04110026f, 0.04243653f, 0.00364406f, 0.10045619f, 0.01021912f, -0.20276271f, 0.21546873f, 0.05365287f, 
    0.04147857f, -0.24704908f, -0.04093902f, -0.18342200f, 0.08039521f, -0.02209152f, -0.07014214f, -0.04046475f, 
    -0.02171327f, -0.06269183f, -0.06687190f, -0.00620413f, -0.12781048f, 0.11846366f, 0.04771770f, 0.16506702f, 
    0.17410246f, 0.02184615f, -0.00806341f, 0.03873836f, -0.00912409f, 0.04306621f, 0.13297549f, 0.10987916f, 
    -0.03748088f, -0.12481145f, -0.00856143f, -0.05428893f, 0.06555354f, -0.01204172f, -0.01699658f, -0.08439624f, 
    -0.01306395f, 0.01022175f, 0.07404710f, -0.06621760f, 0.07164945f, 0.02268977f, 0.01543968f, 0.19894989f, 
    0.05049140f, -0.05336082f, -0.03699780f, -0.00195880f, 0.02660949f, 0.04326958f, 0.03303077f, -0.01415702f, 
    -0.23957580f, 0.05634112f, -0.02502196f, 0.18752673f, -0.03623122f, -0.10084480f, -0.05489723f, -0.01699906f, 
    -0.03271880f, 0.03223649f, 0.07029833f, 0.01102652f, 0.03205674f, 0.19346650f, -0.01996117f, 0.12947664f, 
    -0.11132238f, -0.10804214f, 0.00675576f, -0.02732040f, -0.07229605f, -0.00664487f, -0.02183011f, 0.02920431f, 
    -0.03012105f, 0.08637417f, -0.01979229f, 0.13007011f, 0.10154752f, -0.01865139f, -0.04465050f, 0.03505982f, 
    -0.00253318f, -0.02020089f, -0.03654175f, -0.10448803f, -0.09079327f, -0.06156273f, -0.05662198f, -0.08401861f, 
    -0.02981105f, -0.04340608f, -0.00766159f, -0.03760896f, 0.00063891f, -0.02463299f, -0.05537993f, -0.03006415f, 
    0.16257690f, 0.06720670f, 0.05902799f, 0.07872629f, 0.09370000f, 0.00463957f, -0.01018701f, -0.00417654f, 
    -0.03682598f, 0.00663134f, -0.06721444f, -0.04956150f, 0.05988140f, -0.03362865f, 0.10309763f, 0.04824860f, 
    0.00447059f, 0.02962740f, -0.09268190f, -0.03275189f, -0.02885491f, -0.06227743f, -0.01308118f, 0.02792110f, 
    0.02107832f, 0.06916130f, -0.11621147f, -0.02460093f, -0.07238276f, -0.00382123f, -0.01085729f, 0.06002367f, 
    -0.11405802f, -0.01765006f, -0.00066919f, 0.00818143f, 0.17524570f, 0.15186268f, 0.02187506f, 0.16854426f, 
    -0.01753171f, 0.05414981f, 0.11118009f, 0.02945905f, -0.09105439f, -0.01768753f, -0.06082090f, -0.04451039f, 
    -0.23036060f, -0.18535788f, -0.12581952f, -0.11778128f, -0.07303318f, -0.00656931f, -0.06597353f, -0.08603197f, 
    -0.05412238f, -0.01989173f, 0.01495645f, -0.03310418f, 0.07259522f, -0.14663719f, -0.04786361f, 0.00194600f, 
    -0.02558140f, -0.03334638f, -0.03629877f, -0.09920958f, -0.02027649f, -0.01128386f, 0.00146368f, 0.03585836f, 
    0.26196560f, 0.02325825f, 0.08192846f, -0.21539576f, -0.16234198f, -0.06229756f, -0.02964635f, -0.04166401f, 
    0.01390078f, 0.05422819f, -0.01792158f, -0.00622175f, -0.17345424f, 0.11786606f, -0.09402667f, -0.09480782f, 
    0.03297151f, -0.02849649f, -0.06707025f, -0.09810873f, -0.12202091f, 0.07460736f, -0.12653269f, -0.02691824f, 
    -0.31481251f, 0.12289167f, 0.07267389f, -0.05657760f, 0.00216110f, -0.02495754f, 0.03570918f, 0.08102347f, 
    -0.02922027f, 0.05429494f, 0.06434916f, -0.04648275f, 0.07477518f, 0.16155258f, -0.03086288f, 0.17900743f, 
    0.00593337f, -0.09560364f, -0.01142675f, 0.05847928f, 0.04080544f, -0.07336773f, -0.04959802f, -0.04551767f, 
    -0.02980912f, 0.04974963f, 0.05698591f, -0.10213246f, -0.09400985f, 0.00860189f, -0.05206139f, -0.05183177f, 
    -0.07594993f, 0.05930523f, 0.03254872f, -0.03160113f, 0.10778266f, 0.12726182f, 0.13742919f, 0.13970849f, 
    0.06372039f, -0.02835679f, 0.08945126f, -0.07745020f, -0.04615868f, 0.06448825f, 0.02714588f, -0.06528126f, 
    -0.14503725f, 0.02506693f, -0.05812425f, 0.13927826f, 0.03594138f, -0.04091104f, -0.03022585f, -0.01902630f, 
    -0.08321732f, -0.12146787f, 0.03071179f, -0.08083793f, 0.11272520f, -0.19146502f, -0.09056295f, -0.04126433f, 
    0.05149184f, -0.02836840f, 0.03980660f, -0.07516087f, 0.00568978f, -0.05724923f, 0.01391482f, -0.06516679f, 
    0.24357836f, 0.01445178f, 0.11923791f, -0.18143974f, -0.07599555f, 0.02042109f, -0.06908643f, 0.00113627f, 
    0.00018037f, 0.05628252f, 0.03583385f, 0.02288781f, 0.04159519f, 0.07383180f, 0.04828809f, 0.08645388f, 
    -0.06685279f, -0.16160148f, -0.03469791f, -0.03459266f, -0.04641159f, -0.02397395f, -0.10339829f, -0.04964401f, 
    0.06158633f, -0.16002451f, 0.07151867f, -0.18120998f, 0.02659367f, 0.00686453f, -0.01666008f, -0.04359939f, 
    -0.03678937f, 0.01839304f, -0.03920453f, -0.04097231f, -0.12547466f, -0.01708301f, 0.05330283f, 0.15351540f, 
    0.02153238f, -0.06097513f, -0.01169641f, -0.03785020f, -0.01761601f, 0.08158676f, -0.01036919f, -0.12852152f, 
    -0.14560220f, 0.16068502f, 0.11187987f, 0.17565309f, 0.13314617f, 0.03915912f, 0.10921776f, -0.00120674f, 
    -0.02548079f, 0.01107964f, -0.00242983f, -0.01904940f, 0.10316177f, 0.13544516f, 0.13814178f, 0.01286026f, 
    0.07370828f, 0.06243027f, 0.03954747f, -0.08180289f, -0.01072034f, 0.02428368f, 0.04423138f, -0.11966242f, 
    -0.17170079f, 0.13573314f, -0.12062734f, 0.03902918f, -0.04222317f, -0.02428700f, -0.04977965f, 0.00669311f, 
    0.02088439f, 0.03215700f, 0.04668741f, 0.01344470f, 0.06106437f, 0.00593160f, 0.08715960f, 0.10222269f, 
    -0.00832350f, -0.04326881f, 0.00982048f, -0.09897985f, -0.00194092f, 0.02737527f, 0.03523773f, 0.01280125f, 
    -0.06280177f, -0.14627789f, -0.13330525f, -0.04754226f, -0.00739766f, -0.09869977f, 0.00563937f, -0.01748389f, 
    -0.01449346f, -0.03094139f, 0.01213952f, -0.00652314f, 0.06333176f, -0.12078969f, -0.04821633f, 0.19178972f, 
    -0.06227402f, -0.07134514f, -0.01141516f, -0.05466562f, 0.04090716f, -0.10568112f, 0.02549011f, -0.06248178f, 
    -0.00691717f, -0.05855964f, -0.06375401f, 0.06823695f, 0.00698726f, 0.00334403f, -0.12025055f, -0.05270786f, 
    -0.02275581f, 0.03098419f, 0.00139981f, -0.04370039f, 0.13380037f, 0.18073194f, -0.02458617f, 0.22869919f, 
    0.15879795f, 0.02870031f, 0.08373487f, 0.04559756f, -0.00742198f, -0.00454937f, 0.01229402f, -0.04543227f, 
    0.12281945f, 0.08973911f, 0.04179288f, 0.08610383f, -0.09057567f, 0.10131245f, -0.00505866f, -0.02494493f, 
    -0.13526063f, 0.09195415f, 0.01926825f, -0.03080157f, 0.10294571f, -0.15860315f, -0.00620585f, 0.05469412f, 
    -0.01952337f, -0.08483504f, -0.01425953f, -0.09291752f, -0.02267449f, 0.00754180f, -0.09639053f, 0.02900699f, 
    0.10696897f, 0.02804779f, 0.21948914f, 0.05927822f, 0.02267068f, 0.12206839f, 0.00937842f, 0.05847047f, 
    -0.04997128f, 0.03200188f, -0.03671566f, 0.01128510f, 0.01988229f, 0.10115299f, 0.05374507f, 0.16597717f, 
    0.02401392f, 0.00501334f, -0.00232072f, -0.05510204f, 0.03324745f, -0.01460917f, -0.01780920f, -0.09021816f, 
    -0.01025403f, -0.12354776f, -0.13905475f, -0.07907693f, -0.01213974f, 0.00684853f, -0.06817172f, -0.07968099f, 
    -0.03591036f, -0.01761652f, -0.06887704f, -0.04864193f, -0.23675449f, 0.15696540f, 0.01227767f, -0.13860624f, 
    -0.06455951f, 0.02295098f, -0.02104628f, -0.08113461f, -0.02429670f, -0.03326744f, 0.00405908f, -0.13897161f, 
    -0.12632743f, -0.00116370f, -0.11609612f, -0.00614561f, 0.00517650f, -0.02428816f, -0.04675882f, -0.02524422f, 
    -0.04110000f, -0.00535639f, 0.01164460f, -0.06686531f, -0.17777172f, 0.09869701f, 0.02589971f, -0.08666211f, 
    -0.06244690f, 0.00211819f, 0.00667959f, -0.13538913f, -0.03613146f, -0.08223669f, -0.00465840f, -0.05175677f, 
    0.06588647f, -0.10215655f, -0.08201557f, 0.01980692f, -0.05629167f, -0.11490075f, -0.03191083f, 0.00729325f, 
    -0.00846070f, -0.02298013f, -0.05321455f, -0.05659020f, -0.11048205f, -0.00592473f, 0.10784608f, 0.12441025f, 
    -0.05041065f, -0.03726171f, 0.06340125f, 0.02532776f, 0.03302829f, -0.01293614f, 0.03600378f, -0.14519376f, 
    0.09670630f, -0.13034897f, 0.06475198f, 0.16852652f, -0.00092515f, -0.05987399f, -0.07053379f, -0.02929431f, 
    -0.03607773f, -0.05125507f, -0.04976481f, -0.08122647f, 0.20476301f, 0.17347474f, 0.05159382f, 0.18036503f, 
    0.06006991f, 0.07772695f, 0.07599824f, 0.01865004f, -0.02589613f, 0.12301365f, -0.00489349f, -0.07057417f, 
    -0.30592299f, 0.07126841f, -0.16169012f, 0.04412158f, -0.08513088f, -0.01236398f, -0.08687142f, 0.00154820f, 
    0.02614263f, 0.04251479f, 0.04904438f, -0.02476706f, -0.18581924f, 0.08537462f, -0.11956370f, -0.07003992f, 
    -0.06350676f, 0.03655687f, 0.10216626f, -0.01339488f, -0.09138902f, 0.06087209f, -0.01605987f, -0.02078099f, 
    -0.35511535f, 0.04083408f, -0.00826948f, -0.09144832f, -0.03469916f, 0.01905773f, -0.05087614f, -0.02477276f, 
    -0.03179600f, 0.01745431f, -0.02023581f, -0.07561193f, -0.19908696f, 0.00964135f, -0.03757822f, 0.05562099f, 
    -0.01553631f, 0.01803404f, -0.07451122f, -0.09665325f, -0.00042092f, 0.02766334f, -0.07960511f, -0.03623312f, 
    -0.18994819f, 0.05938143f, -0.06328387f, -0.11190206f, -0.07492611f, 0.01256295f, 0.02639868f, -0.06478151f, 
    -0.00873740f, -0.03210278f, -0.06096613f, -0.09509293f, 0.00735886f, 0.08999611f, 0.07978117f, 0.14904627f, 
    0.15760276f, -0.05278555f, -0.02744246f, -0.02332833f, 0.01719830f, -0.06285989f, -0.03772290f, -0.12147885f, 
    0.09126350f, 0.02543855f, -0.03695986f, -0.04109235f, -0.04366735f, 0.00503228f, 0.02850280f, -0.06273732f, 
    -0.00823718f, -0.00534007f, 0.03693013f, 0.05869057f, -0.05004831f, -0.00235982f, -0.08398401f, -0.00331494f, 
    -0.10030250f, -0.04609687f, -0.06096828f, -0.10361073f, 0.07839544f, -0.05099908f, -0.00923554f, 0.02028314f, 
    0.10961083f, 0.09915523f, 0.14933209f, 0.13561215f, 0.05829397f, 0.07768270f, -0.00297677f, -0.11151695f, 
    -0.06788441f, -0.00296627f, -0.04780268f, -0.08178957f, -0.27207550f, 0.11285623f, 0.01818389f, -0.12187187f, 
    0.00079529f, 0.01548274f, -0.04902332f, -0.04644245f, 0.01249981f, -0.01711240f, -0.08739986f, -0.04467745f, 
    -0.11891652f, 0.00474776f, -0.04289585f, 0.12481848f, -0.09863660f, -0.08357015f, -0.00739373f, -0.00987117f, 
    -0.02395421f, -0.08983864f, 0.02759452f, -0.00680154f, 0.09870652f, -0.06020660f, -0.11048832f, -0.24441242f, 
    -0.00907858f, -0.01123611f, -0.01875121f, -0.05165527f, 0.04797498f, 0.01433421f, -0.03611235f, -0.01779477f, 
    -0.22461927f, 0.07081168f, -0.15029477f, -0.03709088f, -0.06618097f, 0.03512223f, -0.06197440f, -0.02786727f, 
    -0.07670865f, 0.01360376f, -0.04848848f, -0.00499333f, -0.10184915f, 0.15671068f, -0.02024137f, -0.18751988f, 
    -0.16684334f, -0.01587057f, -0.00235093f, -0.09802438f, -0.12962738f, -0.03455147f, -0.11005302f, -0.11368177f, 
    0.17236792f, -0.13181575f, 0.12114495f, -0.08490296f, -0.04140329f, 0.03923297f, -0.03945533f, 0.01418857f, 
    -0.00947243f, 0.08709818f, -0.05186388f, -0.00912057f, 0.11323386f, 0.19255906f, -0.03446294f, 0.12137090f, 
    0.02433250f, 0.00652553f, -0.04068206f, -0.04946131f, -0.02513309f, -0.06338036f, -0.00262648f, -0.01638599f, 
    0.14258902f, 0.03541917f, 0.05600990f, 0.11199214f, 0.05050801f, 0.02276367f, 0.00619539f, -0.02689322f, 
    -0.02195989f, -0.01496529f, -0.06008893f, -0.05279356f, 0.01369935f, 0.13981107f, -0.00380680f, 0.07922645f, 
    0.01500032f, 0.01469618f, -0.08655524f, 0.01672164f, -0.05335573f, -0.03219157f, -0.03639807f, -0.06554593f, 
    0.13393252f, -0.01518338f, -0.19180985f, -0.01721558f, 0.04420283f, -0.01078394f, 0.01224581f, -0.01197802f, 
    0.06165182f, -0.01185070f, 0.04437666f, 0.01319187f, -0.06664159f, 0.02123656f, -0.04331760f, -0.02448376f, 
    -0.09202403f, -0.13781545f, 0.04996652f, -0.06019401f, -0.03001700f, 0.03017000f, -0.19786270f, 0.05681201f, 
    0.10059197f, -0.14608216f, 0.13870499f, 0.03724764f, 0.00758315f, -0.07564025f, -0.06119084f, -0.05733173f, 
    -0.02160693f, -0.07801383f, -0.03386438f, -0.05106251f, 0.06004324f, -0.16577975f, -0.05695390f, -0.19499373f, 
    -0.05422295f, -0.06935602f, 0.08557568f, -0.06705238f, 0.03813187f, -0.02404482f, -0.05004291f, 0.04575538f, 
    -0.14245723f, 0.02598469f, -0.19066450f, -0.01945999f, 0.05626681f, 0.00493706f, -0.03877495f, -0.05694046f, 
    0.00442671f, 0.01733035f, 0.08161430f, -0.02348949f, 0.12159979f, 0.16510284f, -0.05339587f, -0.19647081f, 
    -0.05254038f, -0.08829725f, 0.08128382f, 0.03080255f, 0.05579408f, 0.03975770f, 0.14691480f, 0.09839901f, 
    -0.04421994f, 0.07499369f, -0.01065207f, -0.19546610f, 0.12596144f, -0.05163557f, -0.04841569f, 0.11531386f, 
    -0.02682492f, -0.03741043f, -0.01295130f, 0.04600604f, 0.11906926f, 0.11120722f, -0.24034536f, 0.01905210f, 
    0.03690036f, 0.08149604f, 0.07051908f, -0.05375554f, 0.03207298f, 0.01354343f, 0.02341058f, 0.09088332f, 
    -0.19622152f, -0.14612482f, 0.03477382f, -0.15326701f, 0.02946622f, 0.00996977f, -0.04229118f, -0.07865242f, 
    0.04187755f, 0.01988740f, -0.00254940f, 0.04311859f, 0.09843650f, 0.09935858f, -0.13791670f, 0.10926176f, 
    0.10762458f, -0.03666465f, 0.05261768f, 0.03983858f, -0.01616135f, -0.09561355f, -0.05520280f, -0.07381552f, 
    -0.15134418f, 0.14205822f, -0.17997617f, -0.14238703f, -0.11599677f, 0.08656721f, -0.16348228f, -0.11233126f, 
    0.06889071f, 0.06270831f, 0.04908936f, 0.03550709f, -0.14546210f, 0.16651261f, -0.02243635f, -0.05906947f, 
    -0.13768864f, 0.02571956f, -0.02813602f, 0.04654447f, 0.06357430f, -0.08205184f, 0.02949090f, -0.11246360f, 
    -0.17371258f, -0.15941793f, -0.04958420f, 0.07997793f, 0.12240563f, 0.07253613f, -0.00929046f, 0.01261641f, 
    0.05926701f, 0.07413151f, 0.09265056f, -0.00175388f, 0.25434190f, 0.06666514f, -0.00015973f, 0.11597247f, 
    0.02883509f, -0.05175082f, -0.14245948f, -0.06165324f, -0.04466799f, -0.06842729f, 0.10863368f, -0.10224730f, 
    -0.15946901f, 0.21654259f, -0.11352988f, -0.08051191f, -0.00582832f, -0.14762525f, -0.01494997f, 0.00108240f, 
    -0.00638012f, -0.01309481f, -0.11157537f, -0.02644105f, 0.13516012f, 0.01368929f, -0.03165912f, 0.04739413f, 
    0.09731905f, -0.02218216f, -0.02045181f, -0.11509850f, 0.11491356f, -0.02257423f, -0.08637350f, -0.12274853f, 
    0.14732599f, -0.08608662f, 0.05759009f, 0.06085414f, -0.03078689f, -0.00812869f, -0.03985647f, -0.00028152f, 
    0.02848724f, -0.06979071f, -0.04006801f, -0.03467070f, 0.02824906f, 0.27890763f, -0.11445408f, -0.16826726f, 
    0.02660530f, -0.09304912f, -0.11680167f, -0.04053983f, 0.01009555f, -0.08143377f, -0.00162711f, 0.04988474f, 
    0.09201163f, 0.05038911f, 0.14098443f, 0.08933089f, -0.06376839f, -0.09380726f, -0.00197210f, -0.18908812f, 
    -0.08572057f, -0.06513104f, -0.02153416f, -0.10704925f, -0.17355652f, 0.01953636f, 0.09020069f, 0.00310141f, 
    -0.07032368f, 0.01832749f, -0.06050572f, 0.08581106f, -0.00448660f, -0.04394889f, 0.03383917f, 0.01460552f, 
    -0.05800903f, -0.01827920f, -0.08297688f, -0.13764551f, 0.05897728f, -0.02914710f, -0.04500864f, -0.04807124f, 
    0.04936525f, 0.12553848f, -0.00417610f, -0.17053843f, 0.06445786f, -0.10980634f, -0.06062008f, -0.00061591f, 
    0.02766022f, 0.00294240f, 0.00575948f, -0.00390843f, 0.05272012f, -0.02886277f, 0.00014639f, 0.04897822f, 
    -0.20866123f, 0.12055754f, -0.07005209f, -0.01635224f, 0.00797722f, -0.05761820f, -0.01608919f, 0.05481496f, 
    0.03065873f, 0.03235328f, -0.08200057f, 0.12483175f, 0.13363372f, 0.15556951f, -0.16900152f, -0.16751492f, 
    0.02328908f, -0.13837737f, 0.02685306f, -0.00577850f, 0.01786430f, 0.04939160f, 0.07293266f, 0.03776626f, 
    0.04995221f, -0.07207996f, 0.12243138f, 0.03657454f, -0.07853466f, 0.00134076f, 0.03471433f, -0.04370540f, 
    0.00565157f, -0.00954861f, 0.03097962f, -0.00332983f, -0.01036735f, -0.04199307f, -0.08459971f, 0.01610048f, 
    0.06658321f, -0.01798603f, -0.06743289f, -0.05368219f, 0.08047456f, -0.03062697f, 0.05118372f, 0.02390519f, 
    0.05586699f, -0.06803252f, 0.16459702f, 0.11182664f, -0.24265310f, -0.01925806f, 0.01450708f, -0.03502249f, 
    -0.07842568f, -0.09767246f, 0.01507915f, 0.09247299f, -0.14793496f, 0.16859972f, 0.04767476f, 0.09642777f, 
    -0.02394667f, -0.07030833f, -0.01400309f, 0.01614242f, -0.00077631f, -0.01117733f, -0.06729259f, 0.14583690f, 
    -0.09150733f, 0.02868508f, -0.00276361f, 0.05562737f, 0.07316503f, -0.00829134f, -0.02711731f, -0.02220251f, 
    0.03806137f, -0.04498336f, 0.05179562f, 0.04929378f, -0.11789536f, -0.02285505f, 0.01516132f, -0.07399412f, 
    -0.00248142f, 0.05189037f, 0.05114086f, -0.08679950f, 0.03634411f, 0.00458889f, 0.12675470f, 0.06330643f, 
    -0.11075416f, -0.11531263f, -0.12161727f, 0.00029633f, 0.03583385f, 0.02175201f, 0.02054875f, 0.05194317f, 
    0.06810061f, 0.04638470f, 0.04832181f, 0.08400773f, 0.19662665f, -0.04404033f, -0.18281370f, -0.17997499f, 
    -0.03610152f, 0.02265454f, 0.02686810f, -0.02063364f, -0.01513639f, 0.10925623f, -0.08937699f, 0.03211924f, 
    0.01008047f, -0.12634657f, -0.12501888f, -0.16369534f, 0.05937263f, -0.15326370f, 0.11690766f, -0.00068122f, 
    0.08762400f, 0.05834372f, -0.00586662f, -0.03857585f, 0.06072275f, -0.12850057f, 0.05649668f, -0.15656324f, 
    -0.00481068f, -0.06741835f, 0.02702962f, 0.04457875f, 0.03832028f, 0.04312618f, 0.05325139f, -0.05087295f, 
    -0.16214766f, 0.05996788f, 0.12628178f, -0.09884334f, 0.02006088f, -0.01323649f, -0.02985780f, 0.02855474f, 
    0.07441358f, -0.19587879f, -0.03232913f, 0.00882475f, 0.21749552f, 0.03540518f, -0.06732605f, 0.08894653f, 
    0.04472612f, -0.01128557f, -0.07692882f, -0.07160953f, -0.08311015f, 0.10811517f, -0.03721874f, -0.08506988f, 
    -0.23883948f, -0.04127763f, 0.16559333f, 0.01519575f, -0.05333770f, -0.05734330f, 0.03084825f, -0.04649345f, 
    0.02459326f, -0.02964792f, -0.04472195f, -0.00735096f, -0.03577828f, 0.00551921f, 0.12961167f, -0.08298176f, 
    -0.01972853f, -0.08582480f, -0.04946682f, -0.01041583f, -0.04929498f, 0.00448178f, 0.03187341f, 0.03971082f, 
    0.05130139f, -0.23412721f, 0.04699409f, -0.02933714f, 0.00571927f, -0.08465738f, 0.01048316f, 0.06183132f, 
    0.05986966f, 0.05117693f, -0.11227587f, 0.02746580f, 0.16328625f, -0.13602641f, -0.02194497f, 0.07251311f, 
    0.03473575f, -0.08293391f, -0.06247172f, -0.01779818f, -0.00606473f, 0.03025267f, 0.01635599f, -0.10383275f, 
    -0.18939207f, -0.12044396f, 0.05335492f, 0.08736828f, 0.08098995f, 0.02284263f, -0.01532235f, -0.03171596f, 
    0.01368148f, -0.06219285f, 0.01436954f, 0.05260861f, -0.03076179f, -0.05817084f, 0.07002195f, 0.14968367f, 
    0.12229382f, -0.00955456f, -0.00936027f, -0.01193967f, -0.00233241f, 0.02312025f, 0.08648871f, -0.01861784f, 
    0.18143994f, 0.07914846f, -0.22686972f, -0.07511427f, -0.04625975f, 0.06380425f, 0.03563873f, -0.12207905f, 
    -0.02479595f, -0.01578046f, -0.00644766f, 0.02735362f, 0.00870754f, -0.13812269f, -0.24579397f, -0.16032343f, 
    -0.01258983f, -0.17184751f, -0.25548303f, -0.15015478f, -0.10602134f, 0.01520242f, 0.04041426f, 0.00807069f, 
    -0.08380688f, -0.13123091f, -0.08556975f, -0.27702317f, -0.02176383f, -0.07636480f, -0.16702195f, 0.04148188f, 
    -0.01583620f, 0.08840761f, 0.09145933f, -0.10087045f, -0.10179285f, 0.01531364f, 0.14047828f, 0.01605400f, 
    -0.10264940f, 0.02833116f, -0.05744184f, -0.05644768f, 0.08529966f, -0.16714095f, -0.06524613f, 0.04702155f, 
    -0.11166271f, 0.12226167f, -0.14726608f, -0.11934806f, 0.00759073f, 0.04449379f, -0.04471730f, 0.01925882f, 
    0.01155928f, -0.05485108f, 0.07744464f, 0.06875877f, 0.14097989f, -0.07651626f, -0.12110912f, -0.03276548f, 
    -0.01254299f, 0.01598357f, -0.01291926f, 0.05607923f, 0.07070690f, -0.03983587f, 0.10825502f, -0.09971669f, 
    0.09972426f, 0.13788964f, -0.16510862f, 0.07256671f, 0.13729706f, 0.00963266f, -0.08036298f, -0.03919243f, 
    -0.16433233f, 0.06180900f, 0.02985042f, 0.07195767f, -0.08191168f, 0.14647411f, -0.15316203f, 0.09926093f, 
    -0.00124558f, 0.00319086f, -0.03730897f, -0.08154648f, 0.06892299f, -0.02040884f, 0.02311762f, 0.11165649f, 
    0.07687357f, 0.12127131f, 0.04816028f, 0.16889228f, 0.09727835f, 0.03563993f, -0.05951720f, -0.04883951f, 
    0.02173912f, 0.13001139f, 0.01560886f, -0.01900021f, 0.01025474f, 0.20195839f, -0.01521055f, -0.05260912f, 
    -0.01338096f, -0.07716597f, -0.07450183f, -0.00977926f, -0.06243817f, 0.03991639f, 0.10722921f, -0.15608594f, 
    0.06277570f, 0.03048451f, 0.06519350f, 0.09790540f, -0.06369489f, 0.04162832f, -0.08187325f, 0.04570664f, 
    -0.04598628f, 0.08622512f, 0.02344225f, 0.03777386f, 0.02778543f, 0.04700901f, 0.12660967f, 0.14470650f, 
    -0.06773120f, 0.02490749f, -0.02579850f, -0.05229705f, -0.14939144f, 0.05495462f, -0.00889577f, -0.03019110f, 
    -0.14508219f, -0.10068828f, 0.14476009f, -0.11843721f, 0.03477745f, -0.04596530f, -0.08646199f, -0.05415241f, 
    0.03351463f, -0.00237498f, -0.04398781f, -0.09102257f, 0.22427152f, -0.13069376f, -0.03276673f, 0.18849048f, 
    0.02501830f, -0.01659288f, 0.03202533f, -0.01665638f, 0.07603482f, -0.04203741f, 0.06607726f, -0.15698977f, 
    -0.05791876f, -0.00861459f, -0.01080373f, -0.21877389f, -0.02112452f, -0.09223894f, -0.00816342f, -0.01926833f, 
    0.11672219f, -0.02758020f, -0.19360772f, -0.00735010f, 0.09249168f, -0.05821610f, 0.04261707f, -0.02208100f, 
    0.04648044f, -0.08437781f, 0.00049810f, -0.01651037f, 0.03596661f, 0.02982257f, -0.05305663f, 0.08444257f, 
    0.01905158f, -0.04485688f, 0.05712909f, 0.14128618f, -0.00763526f, 0.04512505f, 0.01389708f, -0.05364254f, 
    0.01118399f, 0.01671715f, -0.02466526f, -0.01757796f, 0.11431216f, -0.04885421f, -0.03767283f, 0.12566471f, 
    -0.03521613f, -0.07050812f, -0.07630479f, -0.01041346f, 0.00966705f, -0.08179699f, 0.08072107f, 0.07107946f, 
    -0.10461695f, -0.10934032f, 0.15159233f, -0.07242610f, -0.11183207f, -0.09903314f, 0.13081385f, -0.08024053f, 
    -0.02712395f, 0.04789328f, -0.05778551f, 0.04015443f, -0.22244678f, 0.06938525f, 0.12177551f, -0.10092352f, 
    -0.08922476f, -0.01678350f, -0.06134178f, 0.08494440f, -0.07226623f, 0.09057021f, 0.04457253f, 0.00779041f, 
    -0.02800787f, -0.11272181f, -0.08160271f, -0.21661916f, -0.08116747f, -0.03993130f, 0.07072480f, -0.01461207f, 
    0.03487669f, 0.04118450f, -0.10594866f, 0.05208718f, -0.20714626f, 0.08569158f, -0.18521699f, -0.18191144f, 
    -0.00395903f, 0.04158197f, -0.09199967f, 0.06063501f, 0.11089750f, 0.06635935f, -0.02318639f, -0.04596752f, 
    0.19170314f, -0.11548557f, 0.20779279f, -0.06400482f, -0.00635934f, -0.03277441f, 0.01138579f, 0.01032429f, 
    -0.00986711f, 0.01881883f, -0.07523632f, 0.04967857f, -0.12466151f, -0.27235332f, -0.05777983f, 0.02582253f, 
    0.02016507f, -0.08997679f, 0.06450391f, 0.00862253f, 0.03348430f, -0.05286274f, 0.13130321f, -0.04917376f, 
    0.17283282f, 0.13939792f, -0.14535341f, -0.09465691f, -0.02319511f, 0.11165971f, -0.01010237f, -0.09262136f, 
    0.04942643f, 0.01106717f, -0.03958042f, 0.16410065f, 0.07147351f, 0.08785249f, 0.01971812f, -0.17579293f, 
    0.07392409f, -0.06319997f, -0.14954226f, 0.08363926f, 0.02317620f, -0.15780488f, -0.05299682f, -0.04062714f, 
    -0.09191564f, 0.01689179f, 0.00105275f, -0.23617777f, 0.06140116f, 0.05175996f, -0.03701789f, 0.05704933f, 
    0.03327231f, -0.10095571f, -0.14315522f, -0.03239603f, -0.07310794f, 0.16544129f, 0.19683832f, 0.06405821f, 
    0.06928188f, -0.05243690f, -0.02730860f, -0.10805600f, -0.01665916f, -0.07705310f, 0.06056944f, -0.02678938f, 
    -0.01521744f, -0.27457947f, 0.16460708f, -0.16797709f, -0.11615550f, -0.07289575f, 0.08019032f, 0.06957992f, 
    -0.07992335f, 0.05519257f, 0.04301080f, 0.13749620f, 0.20037314f, 0.00457963f, 0.05798335f, 0.11867251f, 
    0.05773519f, 0.04952139f, -0.02123636f, -0.01373512f, -0.09176949f, -0.01555302f, 0.02013168f, 0.00743216f, 
    0.08207234f, -0.21792828f, -0.19746415f, 0.15001965f, -0.04034355f, 0.03635292f, 0.10255702f, -0.04435576f, 
    0.12191740f, -0.18095528f, -0.02615245f, -0.09940662f, 0.14134358f, -0.42674682f, 0.11389619f, -0.13419472f, 
    -0.04650614f, -0.00528037f, -0.07932077f, -0.07874079f, -0.10830900f, -0.11132211f, 0.10154827f, -0.02006990f, 
    0.12655886f, 0.19241418f, -0.03563550f, 0.11981130f, -0.12129974f, -0.01495982f, -0.00132187f, 0.15233913f, 
    0.06777833f, -0.00537186f, -0.12218096f, 0.05963441f, -0.11462082f, 0.22802763f, 0.10878116f, -0.00896454f, 
    0.05585225f, 0.10417474f, 0.06260260f, 0.05249103f, -0.01014060f, 0.09459820f, 0.07714365f, 0.14703850f, 
    -0.18437812f, -0.04363444f, 0.05000244f, -0.34048304f, -0.11928091f, -0.09723940f, 0.00997471f, 0.03486168f, 
    -0.02770928f, 0.01665341f, -0.08110638f, -0.03284767f, 0.16987485f, -0.26939985f, -0.05525370f, -0.08309534f, 
    0.05866185f, 0.00181431f, -0.00096889f, -0.06286202f, -0.16794185f, 0.02553333f, -0.02576585f, 0.09133671f, 
    -0.48439977f, 0.02862811f, -0.09088416f, -0.01605568f, 0.02490842f, 0.03780975f, -0.09245828f, 0.08222105f, 
    -0.00200521f, 0.14041315f, 0.13778763f, 0.07027880f, -0.14663009f, 0.16611554f, -0.05967556f, -0.21687232f, 
    0.08411225f, -0.04338108f, -0.08021208f, 0.09156896f, 0.00614435f, 0.00137608f, 0.04280104f, -0.00140786f, 
    -0.23754323f, -0.05814412f, 0.01859212f, 0.12918447f, 0.11833248f, -0.01869315f, -0.07353248f, -0.04208395f, 
    0.08304866f, 0.08771949f, 0.02949855f, 0.05434337f, -0.26936421f, -0.04134204f, 0.30371961f, -0.09692514f, 
    0.03899842f, -0.06038005f, 0.01917609f, 0.04586322f, 0.08887181f, -0.07060256f, 0.04997278f, 0.02593168f, 
    0.26798654f, -0.03132238f, 0.00624685f, 0.08797210f, 0.16386800f, -0.06653911f, -0.01988732f, 0.00537680f, 
    -0.00091892f, 0.02843326f, 0.04841031f, -0.05065339f, -0.01336257f, -0.16268331f, 0.07947588f, 0.11332822f, 
    -0.00445493f, -0.08958475f, -0.13669835f, 0.03023501f, -0.06711654f, 0.12833780f, -0.05543627f, 0.10158198f, 
    -0.20866942f, 0.01182143f, -0.00075929f, 0.08729304f, -0.01358783f, 0.14567484f, -0.09078196f, 0.02208753f, 
    0.08793920f, -0.08208413f, 0.06850591f, 0.03838293f, 0.21854833f, -0.11443036f, 0.25562981f, -0.02459701f, 
    0.00828872f, 0.11566667f, -0.11114909f, 0.02149079f, -0.11331791f, 0.00418306f, -0.02144249f, -0.09426453f, 
    -0.12052148f, 0.02189886f, -0.15661868f, 0.10562801f, 0.07401833f, 0.05766927f, 0.01484899f, -0.09169901f, 
    0.00149210f, 0.01091800f, 0.01802643f, -0.03030981f, -0.02916404f, 0.05125769f, 0.16402777f, -0.21656141f, 
    0.03849471f, -0.00655248f, -0.09905535f, 0.01146602f, -0.05175250f, -0.06543049f, 0.00207668f, -0.03275080f, 
    0.23648170f, -0.11822078f, -0.00178026f, -0.00503230f, 0.00338080f, 0.03512342f, 0.04884154f, -0.03032683f, 
    -0.05898898f, -0.04933671f, 0.01619586f, -0.00924387f, 0.16158609f, 0.16256338f, -0.20583738f, -0.36879307f, 
    0.00436566f, -0.08332621f, -0.10799730f, 0.14413747f, 0.01876874f, -0.02784089f, -0.06837849f, -0.06777532f, 
    0.36265150f, -0.21944618f, -0.07699224f, -0.12161525f, 0.13178061f, -0.00687156f, 0.04324351f, 0.06569976f, 
    -0.09998349f, 0.04084095f, 0.02812184f, -0.00374886f, -0.06052399f, -0.21622904f, -0.05879069f, 0.07579383f, 
    0.04495158f, -0.03563036f, -0.05638143f, 0.09170391f, -0.04233690f, -0.10477325f, 0.02636585f, -0.15382014f, 
    -0.25203255f, 0.27434567f, 0.15824331f, -0.05806282f, 0.04528783f, -0.03497200f, -0.09239566f, -0.07535364f, 
    -0.05831470f, 0.02177554f, 0.09456376f, 0.00938494f, -0.01832988f, -0.21627323f, -0.24995647f, 0.06266093f, 
    -0.04106492f, -0.08169758f, 0.03936667f, -0.05932932f, 0.05310507f, -0.07795358f, -0.05149252f, -0.00095461f, 
    -0.16792879f, -0.06756669f, -0.14573509f, -0.42742163f, 0.03929570f, -0.05848389f, -0.03332250f, 0.04044061f, 
    0.02643682f, -0.04740841f, 0.06783232f, -0.15926456f, -0.13022697f, 0.10486372f, 0.08500973f, -0.07630284f, 
    -0.06985154f, 0.04196624f, -0.07199681f, 0.02325915f, 0.08430221f, 0.04757439f, 0.08588786f, -0.09313904f, 
    -0.02088606f, 0.31533498f, 0.11834312f, -0.08188573f, -0.02910861f, -0.01059871f, -0.02175349f, -0.03047068f, 
    0.07654372f, -0.07866459f, 0.08999392f, 0.00194243f, -0.30213663f, -0.14790675f, 0.06963843f, -0.08306785f, 
    0.08591245f, -0.10379143f, -0.04579918f, -0.05139646f, 0.01326815f, -0.08604690f, 0.18107744f, 0.08233991f, 
    0.14795008f, 0.20785038f, -0.05033170f, 0.09503938f, -0.05453954f, 0.01004733f, 0.08380798f, 0.01768059f, 
    -0.02186688f, 0.04452054f, 0.08504048f, 0.02818438f, 0.27406368f, -0.32610950f, -0.15858570f, -0.04556120f, 
    0.01205081f, 0.01023758f, -0.00503330f, -0.00579252f, 0.04832109f, 0.03556857f, 0.16412929f, 0.05633667f, 
    0.09591336f, -0.30066824f, -0.08522244f, 0.14659967f, 0.03915936f, 0.00767827f, -0.04675014f, -0.04979271f, 
    0.03748168f, 0.05047301f, 0.01759812f, -0.10464989f, -0.23286518f, -0.23862077f, 0.10010686f, 0.10780905f, 
    0.04756503f, 0.01129384f, -0.00447499f, -0.08544976f, 0.03813051f, 0.00351350f, -0.09859056f, -0.07336975f, 
    0.04009837f, 0.08755849f, 0.18213935f, -0.09586828f, -0.00455071f, 0.02265310f, 0.05690685f, -0.00215244f, 
    -0.06204851f, -0.09828699f, 0.05412287f, -0.02491162f, -0.46295661f, 0.13555218f, 0.07400376f, 0.01049402f, 
    0.08983719f, 0.02007778f, 0.07226114f, -0.02985497f, 0.08001060f, 0.02172478f, 0.05659007f, 0.04104326f, 
    -0.25425026f, -0.02057578f, -0.04447006f, -0.30365324f, -0.00020288f, -0.10886467f, -0.06563007f, -0.02564648f, 
    0.03750432f, 0.03968665f, 0.02265655f, -0.06040115f, -0.24733530f, 0.13631216f, -0.19352134f, 0.02547707f, 
    0.05189440f, 0.01973476f, 0.06486645f, -0.06409444f, -0.10857449f, 0.06422511f, -0.06081972f, -0.05002310f, 
    -0.16584928f, -0.02563402f, -0.08789056f, 0.12952979f, 0.05941790f, -0.02113518f, 0.07824749f, 0.06729444f, 
    0.06097971f, -0.03525130f, 0.02577983f, 0.06462522f, -0.45530331f, -0.01329992f, 0.10830996f, -0.00418059f, 
    -0.04842508f, 0.01940024f, 0.16997887f, 0.02309717f, -0.05735003f, -0.00784429f, 0.00741305f, -0.09652861f, 
    0.05427067f, -0.27931237f, -0.06315863f, -0.17339446f, -0.06251691f, 0.04601248f, 0.05053832f, 0.08058771f, 
    -0.05236004f, 0.03789159f, 0.14392768f, -0.01288069f, -0.05139657f, 0.03059114f, 0.09152624f, 0.07563671f, 
    0.13038935f, 0.03575277f, -0.02748938f, 0.18546402f, -0.00577532f, -0.03392218f, 0.03148533f, 0.05205100f, 
    -0.15776804f, 0.35429722f, 0.08009081f, -0.10636789f, -0.01431397f, 0.08081647f, 0.06956478f, -0.08862201f, 
    -0.05411458f, 0.02149272f, 0.04521760f, -0.15167847f, -0.37476489f, 0.16275288f, 0.01846375f, -0.11171383f, 
    0.18583712f, -0.04902623f, 0.03008186f, -0.05018350f, 0.07071440f, 0.06058912f, -0.12746628f, 0.08251226f, 
    0.15101059f, 0.05761709f, 0.21233639f, 0.04758722f, -0.09507474f, 0.02826859f, 0.03967494f, -0.06780440f, 
    0.01360620f, 0.07210196f, -0.00020767f, -0.10146476f, -0.04504197f, 0.20070928f, 0.12835005f, 0.24625300f, 
    -0.03099474f, 0.06910874f, 0.09305027f, -0.04523711f, 0.11598422f, 0.04829187f, 0.12514041f, -0.00902041f, 
    -0.09173127f, 0.09694531f, -0.08031128f, -0.06106780f, 0.08387660f, 0.06691789f, 0.08787267f, 0.03556862f, 
    -0.00774092f, -0.08612864f, -0.03223453f, -0.08201782f, 0.04333251f, -0.44280645f, 0.04915110f, -0.08187134f, 
    0.01469708f, -0.02646426f, 0.02315459f, 0.20501076f, -0.08247036f, 0.05275366f, 0.02228220f, -0.03006566f, 
    0.06654308f, 0.05014772f, 0.00883885f, 0.02963260f, 0.00855985f, 0.08878808f, 0.04746395f, -0.05756268f, 
    0.08511563f, 0.02667320f, 0.10207760f, -0.03034914f, 0.28924611f, 0.01396290f, -0.02880947f, -0.21578379f, 
    -0.07858730f, -0.18470474f, 0.03679940f, -0.00750122f, 0.09485751f, -0.13051337f, 0.05696211f, 0.02976154f, 
    -0.15776737f, -0.33356595f, 0.03594436f, -0.08031268f, -0.01518514f, 0.07291499f, 0.06157985f, -0.00060214f, 
    -0.11840483f, 0.04121195f, -0.07121789f, -0.02638589f, -0.15679355f, 0.09615893f, 0.00307563f, -0.25462842f, 
    0.11285900f, 0.13885614f, 0.02480313f, -0.10555048f, -0.07001128f, -0.15942174f, -0.16404076f, -0.06553879f, 
    0.10605762f, -0.00595585f, 0.13727759f, -0.06546886f, -0.03687551f, 0.04881273f, 0.07574313f, -0.07706576f, 
    -0.01509469f, 0.01011945f, 0.09188008f, 0.05204429f, 0.07820390f, 0.02863087f, -0.01221711f, -0.06527117f, 
    -0.02789470f, 0.05268970f, 0.07881336f, -0.08704162f, 0.09702727f, -0.03106819f, 0.10171826f, 0.02039812f, 
    -0.36208853f, 0.17534994f, 0.09984767f, -0.19078192f, 0.02751426f, 0.06013340f, -0.04387100f, -0.00702506f, 
    0.08279262f, -0.10014766f, -0.05878476f, 0.06730214f, -0.50044787f, 0.00051889f, 0.05657366f, 0.00517253f, 
    0.02767686f, -0.19131389f, 0.02211575f, 0.03490788f, -0.04533670f, 0.05393430f, -0.14483361f, 0.08869411f, 
    0.23897262f, 0.12638818f, -0.05420205f, 0.25793412f, -0.00387932f, 0.01546856f, -0.00817407f, 0.04561373f, 
    0.02850465f, 0.02914733f, -0.06773969f, -0.11066318f, 0.45577875f, 0.07884711f, -0.01570019f, 0.02342954f, 
    0.01435533f, -0.03869531f, 0.09737706f, 0.10396988f, 0.01060239f, -0.08302489f, 0.05986518f, -0.00116121f, 
    0.17088510f, -0.07481081f, -0.05775084f, -0.11333907f, 0.02280539f, -0.07701356f, 0.00282417f, -0.09209678f, 
    -0.09423856f, -0.09735995f, -0.03674325f, 0.04479821f, -0.12679547f, 0.15352495f, 0.06163291f, 0.05643218f, 
    0.02389134f, 0.15895772f, 0.00661349f, -0.04976289f, -0.03735304f, -0.13198619f, 0.03703498f, 0.07401045f, 
    -0.25832507f, -0.05902587f, 0.01995866f, 0.00158177f, 0.07940046f, 0.07795476f, -0.13010311f, 0.00988075f, 
    0.07489907f, -0.02039944f, -0.06019802f, 0.05721936f, 0.00640713f, 0.04792221f, -0.06958093f, 0.12740202f, 
    0.00551593f, -0.02855019f, 0.00051187f, -0.10091621f, 0.12673229f, 0.04772876f, 0.09979299f, 0.09492312f, 
    -0.08474141f, 0.07248715f, -0.11047298f, -0.06914099f, 0.03686767f, -0.08710227f, -0.06075810f, -0.02345292f, 
    -0.06682327f, -0.20083416f, -0.06567974f, -0.11479069f, -0.13362883f, 0.00079579f, -0.00792451f, 0.22821471f, 
    0.09065108f, 0.03383932f, -0.03259443f, -0.05141112f, 0.02574921f, 0.04410926f, 0.08414899f, -0.01063025f, 
    -0.05319367f, -0.02660211f, -0.03650071f, -0.14734656f, 0.11840528f, 0.02006163f, 0.04749638f, -0.01295305f, 
    0.03170929f, 0.04765324f, 0.01780168f, -0.00919123f, 0.07426032f, 0.01695296f, -0.03852238f, -0.05675329f, 
    0.03253988f, 0.02987274f, 0.05160811f, 0.03785717f, 0.10578404f, 0.07641563f, 0.10717772f, -0.04187986f, 
    -0.08170889f, 0.08915135f, 0.06864776f, 0.03347578f, 0.06025677f, -0.15161280f, 0.01918771f, -0.03051796f, 
    0.00259571f, -0.00271147f, 0.10182175f, -0.09992422f, -0.27521861f, -0.15796456f, 0.09911072f, 0.09247287f, 
    0.06375302f, 0.01200560f, -0.05010992f, 0.02564148f, 0.06383547f, 0.12772410f, 0.06351825f, 0.12885173f, 
    0.24087429f, 0.03128931f, 0.00997160f, -0.18978491f, 0.00572434f, 0.03862717f, 0.02089761f, -0.01190017f, 
    -0.13231355f, 0.01199026f, -0.05641947f, 0.00680931f, -0.49873605f, 0.21556649f, -0.26254454f, -0.02392369f, 
    0.00890600f, 0.03599962f, 0.00889532f, -0.02482494f, 0.15316407f, 0.16960639f, -0.00083680f, 0.04635470f, 
    -0.16700897f, -0.10657578f, 0.06956781f, 0.08778812f, 0.05602593f, 0.10360888f, -0.04400833f, -0.11220615f, 
    0.00396257f, 0.00449270f, 0.06215075f, -0.09478275f, 0.03356085f, -0.01109716f, -0.09471604f, 0.12952758f, 
    0.02371672f, -0.07611593f, -0.08863431f, -0.04738737f, 0.08096742f, -0.08302402f, -0.15109438f, -0.13135456f, 
    0.03267966f, 0.01980443f, 0.12188800f, -0.14175744f, 0.13383240f, -0.10835443f, -0.06966813f, 0.09947419f, 
    0.00494943f, 0.00910022f, 0.04459793f, 0.04161449f, -0.10869055f, 0.14079370f, -0.23277412f, -0.11936703f, 
    0.02004507f, 0.06266458f, -0.08859041f, 0.09128668f, 0.05895182f, 0.17294724f, -0.02258110f, 0.01300538f, 
    0.10603220f, -0.17370486f, -0.13003398f, 0.20664501f, -0.04453226f, -0.06528588f, -0.06694571f, 0.04936115f, 
    -0.06207328f, -0.08938890f, -0.23364089f, 0.01079511f, -0.34300128f, -0.13601208f, -0.10936147f, -0.09432879f, 
    0.08234300f, 0.04511720f, -0.02310094f, -0.08764522f, 0.02714816f, -0.13165304f, 0.08302058f, -0.08017457f, 
    0.25607392f, 0.11695857f, -0.18786003f, 0.02011648f, -0.15366644f, -0.05094001f, 0.00765548f, 0.08968760f, 
    0.06296250f, 0.01625253f, 0.07353875f, 0.02342827f, 0.02847154f, -0.02722203f, -0.02058929f, -0.16464606f, 
    -0.01020246f, -0.01543739f, -0.00117431f, 0.01952720f, -0.00749439f, -0.03455894f, 0.07043608f, 0.02207483f, 
    0.28349781f, 0.08836415f, 0.03907261f, -0.06900100f, -0.16421583f, -0.00409098f, -0.00866524f, -0.05147466f, 
    0.02306741f, -0.02963386f, -0.08025731f, -0.09598434f, 0.16127178f, -0.02039878f, 0.03933671f, -0.07392365f, 
    -0.03380885f, 0.03627429f, -0.00581129f, 0.01525878f, 0.06964716f, 0.07701533f, 0.04520286f, -0.08043155f, 
    0.18085001f, 0.00708591f, -0.01576833f, -0.04060432f, 0.05105685f, -0.06505710f, -0.09607346f, 0.06934863f, 
    -0.01950758f, -0.06937622f, -0.14679600f, -0.03488880f, -0.35903320f, 0.15502749f, -0.01494372f, 0.00303728f, 
    0.02542175f, 0.05866475f, -0.00849855f, -0.04611233f, 0.04133417f, 0.09015297f, 0.03560942f, 0.10903939f, 
    -0.04654229f, -0.13201110f, -0.04791192f, 0.08133914f, 0.02155137f, 0.06174670f, 0.02688316f, 0.06572118f, 
    -0.04759754f, 0.00868674f, 0.02313580f, 0.08452121f, 0.09803668f, 0.09532609f, -0.08034266f, 0.01717497f, 
    0.04156093f, 0.02896742f, 0.08487596f, -0.04375812f, 0.07101059f, 0.11884617f, 0.09407631f, 0.05509755f, 
    -0.01882781f, 0.02077099f, -0.04888721f, 0.08761339f, 0.03483234f, 0.10340624f, -0.04760863f, 0.03277382f, 
    -0.10032755f, 0.03223313f, 0.11766502f, 0.03264129f, -0.17696866f, 0.12699461f, -0.27287984f, -0.17538123f, 
    -0.02782797f, -0.02411095f, -0.09524108f, 0.04343330f, 0.09788740f, 0.00066732f, 0.14787196f, 0.01915095f, 
    0.05964235f, 0.07326689f, 0.08142261f, 0.10029179f, -0.04620894f, -0.02918203f, 0.04908440f, 0.06777485f, 
    0.03679285f, 0.02802382f, 0.09493157f, 0.05100260f, 0.05562836f, 0.06052635f, 0.12859008f, -0.11585358f, 
    -0.01906633f, -0.01714965f, 0.04430012f, -0.10640424f, -0.00618194f, -0.07275899f, -0.02696270f, 0.10369293f, 
    -0.35246190f, -0.25745049f, 0.01204397f, 0.09542036f, 0.04604791f, 0.05577042f, 0.04198889f, 0.00184746f, 
    0.17675728f, -0.04278927f, -0.11962599f, 0.01795643f, 0.25180852f, 0.09651042f, -0.04082169f, -0.06175456f, 
    0.08324219f, 0.11145424f, 0.05347219f, 0.00757596f, 0.03773595f, 0.08847936f, -0.00579581f, 0.06447047f, 
    0.12184339f, 0.14465272f, -0.02384443f, -0.07688288f, -0.00571839f, 0.05040440f, -0.00828828f, 0.13033654f, 
    -0.00106568f, 0.07191076f, 0.10620180f, 0.13419852f, 0.12535809f, 0.05245360f, 0.00222398f, -0.08981624f, 
    0.06166507f, -0.11510487f, -0.05492128f, 0.06541812f, 0.01127200f, 0.06508530f, 0.04968864f, 0.10735404f, 
    -0.00100398f, 0.06261880f, 0.04772351f, 0.17742583f, 0.07804539f, 0.01909098f, 0.05942192f, -0.05304778f, 
    0.01975595f, 0.05232528f, -0.07336105f, 0.05093604f, -0.07635257f, 0.05727045f, -0.16337319f, -0.07597470f, 
    -0.05935007f, -0.04340442f, -0.02723138f, -0.00509611f, -0.03247409f, 0.02084651f, -0.01184410f, -0.16398701f, 
    -0.14322767f, 0.04780718f, 0.07040564f, 0.06532374f, 0.11630915f, -0.12249462f, 0.06344932f, 0.01379159f, 
    -0.02659726f, -0.03638316f, -0.08574260f, -0.04164359f, -0.20989326f, 0.05358031f, -0.20993723f, -0.17472295f, 
    0.03923117f, 0.06338602f, -0.11381640f, -0.02583339f, 0.12234888f, -0.12769520f, -0.06591803f, -0.04203062f, 
    0.28363675f, 0.04457323f, -0.00238845f, -0.03083611f, -0.19290024f, -0.09048026f, -0.00313352f, -0.01140620f, 
    -0.02767692f, 0.01781781f, -0.06533244f, -0.05178005f, 0.15540446f, 0.06603996f, 0.05122007f, -0.10024038f, 
    -0.02949084f, 0.09823167f, 0.02590811f, 0.01741412f, -0.02976568f, 0.14113539f, 0.06149792f, -0.00052548f, 
    -0.20300533f, 0.15312655f, -0.06370407f, -0.10516343f, 0.12007636f, -0.03560505f, -0.04638141f, 0.03760185f, 
    -0.06684452f, 0.02462269f, 0.09870971f, 0.12364393f, -0.45028114f, -0.40214297f, -0.06624475f, -0.08989528f, 
    0.00338750f, 0.00146509f, -0.07580715f, 0.01794782f, 0.02300529f, 0.02627605f, -0.09601879f, 0.07144471f, 
    -0.04243660f, 0.05130392f, 0.00979832f, -0.14749384f, 0.04413038f, 0.00880254f, 0.06738388f, 0.04818600f, 
    0.03297266f, -0.00610514f, 0.01983015f, 0.05514089f, -0.46267366f, -0.36594909f, -0.13806470f, 0.04478143f, 
    -0.02268673f, -0.14192674f, -0.05886310f, 0.04923387f, -0.03246793f, 0.12695789f, -0.04214072f, 0.05120290f, 
    -0.43172446f, -0.27392060f, 0.03139454f, 0.06717954f, 0.03705518f, 0.08728469f, -0.01602240f, 0.05941392f, 
    0.02868195f, 0.04138612f, 0.09831780f, -0.00221667f, -0.27491874f, -0.13741259f, 0.16022561f, 0.09018167f, 
    0.00693053f, -0.05366508f, -0.10047364f, -0.13774195f, 0.03755772f, -0.04541025f, -0.03875794f, 0.08929895f, 
    0.16561832f, 0.02868076f, 0.05584406f, -0.14272170f, 0.07577053f, 0.04428080f, -0.09776961f, 0.12561467f, 
    0.05805885f, 0.08001469f, -0.03273063f, -0.01340640f, 0.08266495f, -0.02038278f, 0.02829818f, -0.06075280f, 
    -0.06813429f, -0.09486610f, -0.00133231f, -0.02125204f, 0.03683810f, -0.21472383f, -0.07235011f, -0.00429394f, 
    0.09660631f, -0.20861247f, -0.00725715f, -0.13431305f, 0.10005298f, 0.04258339f, 0.07541795f, 0.00230973f, 
    0.01995247f, 0.03173131f, 0.10103167f, 0.07908319f, -0.13327976f, -0.12014521f, 0.01221227f, -0.09042700f, 
    0.01930126f, -0.09909030f, -0.08574330f, 0.05559991f, 0.01995922f, -0.05608450f, 0.05987075f, -0.02385307f, 
    -0.38555932f, -0.31823063f, -0.03236585f, 0.02739405f, 0.07318819f, -0.01651272f, -0.07829704f, -0.07850880f, 
    0.04483671f, -0.02795887f, -0.02992531f, -0.00482712f, -0.04129867f, -0.17720647f, 0.00716845f, 0.05977204f, 
    -0.01899410f, -0.07566759f, -0.06347235f, -0.03075833f, 0.10721583f, -0.07578319f, -0.04431932f, 0.03665778f, 
    -0.49149346f, -0.35415560f, -0.15159297f, -0.31505698f, 0.07290794f, -0.06508444f, -0.05349891f, -0.02513885f, 
    0.08194612f, 0.00982517f, -0.08873418f, 0.03938090f, -0.12165643f, -0.02717132f, 0.04116126f, -0.08283632f, 
    0.06918015f, 0.02032520f, -0.03165507f, -0.06243533f, -0.00022300f, 0.02272934f, -0.21630321f, -0.07746691f, 
    -0.28698912f, -0.11202206f, -0.02841685f, -0.12642755f, 0.09077647f, 0.03715753f, -0.09945025f, 0.00550746f, 
    -0.03990271f, -0.10116678f, 0.00367518f, 0.02264996f, 0.03391754f, -0.03929533f, 0.08425396f, 0.02245912f, 
    -0.07063131f, -0.07240573f, 0.13256468f, 0.09518839f, -0.01037348f, 0.02657318f, -0.09380207f, 0.07271284f, 
    0.15758808f, 0.14871740f, -0.03228534f, -0.06222918f, 0.05269723f, 0.01332219f, 0.01132001f, -0.00069534f, 
    -0.02340749f, -0.00222373f, 0.03269059f, -0.07000487f, -0.35662648f, -0.20130052f, -0.15371822f, -0.11801490f, 
    0.04662451f, -0.08545734f, 0.00744322f, 0.07178897f, 0.13394442f, 0.04687255f, 0.07812390f, 0.07037183f, 
    -0.36936700f, 0.13606128f, 0.15500054f, 0.03966007f, 0.11360677f, 0.05413451f, 0.04621595f, -0.12379073f, 
    -0.01902983f, -0.18735105f, -0.11303283f, -0.02306529f, -0.25295416f, -0.27164719f, 0.00302067f, 0.04813658f, 
    -0.01564157f, -0.04608120f, 0.00232684f, -0.12944733f, 0.11104877f, -0.00403559f, -0.04116153f, -0.00348882f, 
    -0.48878965f, -0.39218238f, 0.10167118f, 0.06428705f, 0.06322441f, 0.07471955f, 0.07546505f, -0.01634573f, 
    0.16321568f, 0.08762776f, -0.05116491f, 0.01723925f, -0.11529314f, -0.24285239f, 0.04624358f, 0.10929447f, 
    0.01621663f, -0.01646451f, -0.08641229f, 0.05950535f, -0.04488754f, -0.08097812f, 0.07588083f, 0.03128016f, 
    0.10668418f, 0.02946911f, 0.02096640f, 0.02469418f, 0.01164298f, -0.05788070f, 0.03680251f, 0.06580141f, 
    0.03884973f, 0.03639843f, 0.01011958f, 0.09093831f, 0.05639260f, -0.10206540f, 0.09658291f, -0.07267218f, 
    0.04492644f, 0.02421577f, 0.04261257f, 0.03862562f, -0.00094660f, 0.17968719f, -0.00141079f, 0.01947419f, 
    0.08873523f, 0.14880206f, -0.00603086f, 0.07554801f, 0.03468530f, 0.01711377f, -0.03242751f, 0.04176639f, 
    0.09550713f, 0.07521804f, -0.04084726f, 0.07480654f, -0.27514616f, -0.15853642f, 0.13885525f, 0.05291001f, 
    0.08950523f, 0.01320117f, -0.03015667f, -0.07226460f, -0.04119515f, -0.03496002f, 0.03425166f, 0.05437361f, 
    0.50013465f, 0.08396228f, -0.10800849f, -0.10144493f, -0.01244884f, -0.09447669f, -0.05836714f, 0.04189743f, 
    0.01729451f, 0.10595991f, 0.04921152f, 0.12011092f, 0.02636404f, -0.15617900f, 0.04494216f, 0.10110062f, 
    -0.10491280f, 0.03125506f, -0.09427885f, 0.11760212f, -0.15385263f, 0.04817192f, 0.03142728f, -0.07273681f, 
    -0.36226714f, -0.13128680f, -0.04655420f, -0.22690666f, -0.03694516f, -0.01575592f, -0.02281770f, 0.01784526f, 
    -0.10331800f, 0.13160270f, 0.02870985f, 0.14180365f, 0.05138332f, -0.18610635f, 0.07491763f, 0.13785267f, 
    0.00136621f, 0.02058058f, 0.05484635f, -0.02437741f, 0.08077056f, -0.04797487f, 0.03317192f, 0.03664002f, 
    0.17125764f, -0.18467669f, -0.08276081f, 0.12127374f, 0.03727085f, -0.10610590f, -0.01457883f, -0.00894259f, 
    0.04606137f, 0.00476053f, 0.02987924f, 0.04992337f, 0.13201627f, -0.20868449f, -0.09859625f, 0.01021047f, 
    -0.01859151f, 0.07373351f, -0.03774054f, -0.07401697f, 0.02752822f, -0.03409795f, -0.04087804f, 0.00722483f, 
    -0.00667081f, -0.08932161f, -0.00113789f, 0.09515493f, -0.07534550f, 0.09228338f, -0.17475298f, -0.06863787f, 
    0.12759352f, -0.10513022f, -0.13175279f, 0.07196949f, 0.32262883f, 0.07087760f, -0.04801370f, 0.09816825f, 
    0.04345451f, 0.03017002f, 0.01456036f, -0.06053648f, -0.09399520f, 0.08879225f, -0.01230801f, -0.00131779f, 
    -0.09809719f, 0.12445162f, 0.06494307f, -0.04938084f, -0.14360937f, -0.01337377f, 0.00808669f, -0.06732543f, 
    0.04492522f, 0.03452751f, -0.12744845f, -0.05633681f, 0.00367934f, 0.01557714f, -0.09205513f, 0.17021796f, 
    -0.09561512f, 0.09023441f, -0.16510369f, 0.10636701f, -0.00303745f, 0.00983873f, 0.09916430f, -0.08577658f, 
    -0.00549667f, -0.06383152f, -0.04120397f, 0.05123934f, 0.00005207f, -0.13034663f, -0.00965287f, -0.03580923f, 
    -0.13671719f, -0.05741449f, -0.02715259f, -0.07149678f, 0.11213173f, -0.14602670f, -0.05904497f, 0.10365514f, 
    -0.15102905f, -0.11620406f, 0.01438550f, -0.08364420f, -0.03872158f, -0.04566169f, -0.02238925f, -0.02977233f, 
    0.27807540f, -0.00712794f, -0.23639528f, -0.05962541f, 0.01513339f, 0.07697569f, -0.04072450f, 0.01173607f, 
    0.12268161f, -0.06194054f, 0.04334081f, -0.01324661f, -0.44873637f, -0.11411905f, 0.00889215f, -0.16945912f, 
    -0.00945256f, -0.05025554f, 0.05255387f, 0.07370216f, -0.09685163f, -0.07574408f, 0.03474212f, -0.04794932f, 
    -0.31128693f, 0.11051667f, -0.12097950f, 0.00042406f, 0.13359737f, -0.07199596f, 0.09597223f, -0.00779900f, 
    0.01263941f, -0.03176489f, 0.00111339f, -0.01664392f, 0.26838687f, -0.12104819f, -0.25887132f, -0.03061485f, 
    -0.00290644f, 0.03806010f, 0.09423478f, -0.06835868f, 0.08000544f, 0.11020895f, 0.01720645f, 0.01684548f, 
    0.03854196f, -0.27697352f, 0.13663490f, -0.04154032f, -0.01026144f, 0.07632432f, 0.06036723f, -0.01569000f, 
    -0.04208233f, -0.04387465f, -0.00894340f, 0.03359953f, 0.01285090f, -0.21309313f, -0.17858331f, 0.05873987f, 
    -0.00736868f, -0.00467720f, 0.00174612f, -0.12848210f, -0.00403368f, 0.00498381f, -0.04757843f, 0.05055525f, 
    -0.22525825f, -0.33594212f, 0.03507894f, -0.13812314f, 0.05614281f, -0.04762972f, 0.10997924f, 0.14726919f, 
    -0.09101740f, -0.00580270f, 0.03936236f, -0.13325568f, -0.20372736f, 0.15718815f, -0.03672305f, -0.03567344f, 
    -0.14529912f, -0.03710303f, -0.12084968f, -0.17965455f, 0.05777370f, 0.07510586f, 0.03164428f, -0.08812262f, 
    0.17403248f, -0.10576873f, -0.00442662f, 0.21093059f, 0.03601175f, 0.05096285f, 0.11625814f, 0.00347616f, 
    0.06867866f, 0.11705311f, 0.06848149f, 0.07387223f, 0.40491042f, 0.03210378f, -0.06838990f, -0.14763184f, 
    0.04501476f, 0.03206493f, -0.04573389f, -0.01496678f, 0.03704992f, -0.03694334f, -0.01937526f, -0.08268467f, 
    -0.18846275f, 0.12737352f, -0.00739539f, -0.00686406f, 0.07745178f, -0.08209588f, 0.10498831f, -0.14077604f, 
    -0.06479521f, -0.03001545f, 0.03548548f, -0.09421574f, 0.12131286f, -0.16179954f, -0.03675193f, 0.04010211f, 
    0.02738573f, 0.06136915f, -0.09702444f, 0.02211161f, 0.04540681f, -0.05721718f, -0.00814598f, -0.01004093f, 
    -0.24958073f, 0.11105130f, -0.00753422f, -0.00424900f, -0.07352344f, -0.02970925f, 0.01443490f, -0.03386156f, 
    -0.02644162f, 0.01060820f, -0.00881555f, 0.04622535f, 0.03807903f, -0.01679213f, -0.01275543f, 0.27318457f, 
    0.00431832f, 0.01811144f, -0.01365348f, -0.07510941f, -0.10798752f, -0.08711504f, 0.09286629f, 0.13191590f, 
    -0.17125104f, 0.03755868f, 0.00125804f, -0.23235202f, 0.03704520f, 0.08026913f, -0.05338263f, 0.11799990f, 
    -0.15309937f, 0.01202509f, -0.05003865f, -0.21964364f, -0.07140511f, 0.26974133f, 0.02847714f, -0.07174791f, 
    0.00124767f, -0.02149414f, 0.03483379f, -0.00696754f, -0.05237639f, 0.06196789f, -0.03443446f, -0.12190814f, 
    0.25809008f, 0.02345518f, -0.09121116f, 0.17391206f, -0.01654243f, -0.02814783f, 0.09016446f, -0.05303980f, 
    0.05069360f, 0.06217552f, 0.12195906f, 0.02770544f, -0.01205868f, 0.00475151f, -0.08036418f, 0.05179876f, 
    -0.08914012f, -0.04090200f, 0.05101187f, 0.11692560f, 0.00758493f, -0.07699750f, 0.00471509f, 0.02829012f, 
    0.11051267f, 0.04869365f, -0.20018578f, 0.12712105f, 0.10528219f, 0.01854056f, 0.03558012f, 0.03205410f, 
    -0.01076050f, 0.01420816f, -0.10413735f, -0.07295455f, 0.20717132f, 0.00042908f, -0.08544569f, 0.16811477f, 
    -0.09461134f, 0.02059317f, -0.02122116f, -0.02469175f, -0.00444769f, -0.05454476f, -0.04200199f, -0.23386104f, 
    0.18589218f, -0.03097625f, 0.03384464f, 0.03525013f, 0.00213503f, 0.06358850f, -0.14522232f, 0.10256781f, 
    0.09290098f, -0.00809978f, 0.09783475f, 0.03805819f, -0.32528925f, -0.14226171f, -0.06869678f, 0.12115465f, 
    -0.12733871f, 0.11575080f, -0.10825302f, 0.02433939f, 0.08544619f, 0.02543242f, 0.02946082f, 0.18410531f, 
    0.09978417f, -0.04612887f, -0.04354737f, -0.05203961f, -0.06819090f, -0.10572255f, -0.09458713f, 0.01147326f, 
    -0.08103305f, 0.06545368f, 0.02084552f, -0.03596570f, -0.46119177f, 0.04958085f, -0.09352308f, -0.17645946f, 
    -0.00095598f, -0.00709640f, 0.03063012f, 0.09147233f, -0.01643298f, -0.00217182f, 0.08348577f, -0.02426686f, 
    -0.16059528f, 0.02275638f, -0.04543908f, 0.01366053f, 0.01320335f, -0.00915309f, 0.09948776f, -0.02019491f, 
    0.03531967f, -0.02934782f, 0.08442427f, -0.02540012f, 0.11774035f, 0.04732709f, 0.05395363f, 0.08376165f, 
    -0.01669933f, -0.02517763f, -0.05697641f, -0.18392730f, -0.05341273f, -0.00201181f, 0.05710914f, -0.06950322f, 
    0.13193963f, -0.13123788f, 0.09991226f, -0.10302714f, -0.06594903f, 0.08156050f, -0.00616925f, 0.11477232f, 
    -0.01612946f, -0.06929380f, -0.06158613f, -0.04543795f, -0.32654810f, -0.03813799f, -0.05429654f, -0.14464095f, 
    0.10964100f, 0.02386503f, 0.03205224f, 0.10409740f, 0.11905888f, 0.07600689f, 0.08476990f, -0.00092372f, 
    0.04899547f, 0.14577512f, -0.21391553f, -0.09756134f, 0.07534228f, -0.06824522f, 0.04607917f, 0.09473901f, 
    -0.02305162f, 0.09983595f, 0.01755273f, 0.02362970f, -0.12768364f, 0.01083894f, -0.00012179f, -0.01671391f, 
    0.04769991f, 0.05412018f, 0.01681888f, 0.02950794f, -0.06027912f, -0.11664265f, -0.03485694f, -0.03218102f, 
    0.24137555f, 0.02355766f, -0.04717269f, 0.04766587f, 0.09477458f, -0.07504614f, 0.11650816f, -0.06933767f, 
    -0.03731691f, 0.04304726f, -0.02734641f, 0.02500755f, 0.04201501f, -0.21602100f, -0.06731065f, -0.04288113f, 
    -0.06195378f, -0.01742671f, 0.03582324f, -0.03827903f, -0.07442214f, 0.06592261f, 0.00753881f, 0.05181313f, 
    -0.02104815f, 0.00966888f, -0.04020013f, 0.27502489f, -0.09520539f, -0.00056502f, -0.00353640f, 0.06417607f, 
    0.08060032f, 0.03577885f, -0.01137539f, -0.03244810f, 0.03545568f, -0.07493187f, -0.05336718f, -0.03623183f, 
    -0.05678170f, -0.08419388f, 0.01871866f, -0.12349483f, -0.08535278f, -0.02594647f, 0.02024001f, -0.01735706f, 
    0.14383739f, -0.04855040f, -0.08735022f, 0.13790596f, 0.12948421f, -0.07024665f, 0.05517753f, 0.01113572f, 
    -0.04877888f, 0.05255371f, -0.03538008f, -0.01571944f, 0.27579936f, 0.09106717f, -0.15352498f, -0.03144959f, 
    0.08234243f, 0.02796718f, 0.10942739f, 0.01353764f, 0.03937528f, -0.02436256f, -0.07025426f, 0.07209343f, 
    0.36147603f, 0.07468813f, -0.07926585f, -0.04626396f, 0.05312245f, 0.03146980f, -0.10177593f, 0.05134479f, 
    0.07723302f, 0.07471842f, 0.05198639f, 0.04789547f, 0.02161765f, -0.13680977f, -0.09483904f, 0.10908620f, 
    0.21418890f, 0.00049499f, 0.05633706f, -0.05159271f, -0.03544733f, -0.01347379f, -0.02939518f, 0.02887989f, 
    0.15688109f, -0.21962374f, -0.12508640f, -0.08736815f, 0.05027113f, -0.07314040f, -0.01336310f, -0.01017627f, 
    -0.00915034f, -0.07079443f, -0.00892443f, -0.03081888f, -0.25851512f, -0.02997698f, -0.05006279f, 0.23205426f, 
    -0.06064860f, 0.10296895f, -0.04375832f, -0.03237901f, -0.04567926f, 0.00004957f, 0.03198154f, 0.00924905f, 
    -0.15163209f, -0.01510087f, -0.13717742f, -0.06911447f, -0.03886800f, 0.02675758f, -0.02205346f, 0.09578037f, 
    0.04272987f, -0.01963618f, -0.06859357f, -0.14195749f, -0.09225157f, -0.19384862f, 0.02739859f, 0.05725420f, 
    -0.01044783f, -0.01929259f, -0.01857193f, 0.18481472f, -0.02456188f, -0.18285173f, -0.07547597f, 0.04489641f, 
    0.07265337f, 0.08908129f, -0.08767778f, -0.08121096f, -0.15319864f, -0.04902345f, -0.04110416f, -0.09417173f, 
    0.07328929f, -0.00020633f, -0.03353855f, -0.09539010f, 0.18527287f, -0.20677699f, -0.18947153f, -0.12020363f, 
    0.00155543f, -0.00075537f, -0.10351570f, 0.01438541f, -0.16965607f, -0.03656157f, 0.00174145f, 0.02855845f, 
    0.21503690f, 0.14628869f, -0.00024886f, -0.07875939f, -0.05223659f, -0.02865691f, -0.04783719f, -0.04662424f, 
    0.11091655f, -0.02875040f, 0.08477873f, -0.01940989f, 0.13270713f, 0.14944628f, 0.00151612f, -0.20363168f, 
    0.01797441f, -0.03491540f, -0.05437735f, 0.01016529f, -0.04914371f, -0.07430056f, 0.00172124f, -0.02278996f, 
    0.08835999f, 0.04941559f, 0.05794281f, -0.08751100f, 0.02054252f, -0.00402415f, -0.01399469f, 0.03037190f, 
    -0.01058254f, 0.02966133f, -0.10157374f, -0.08230420f, 0.12852187f, -0.07004437f, -0.01544362f, -0.21617091f, 
    0.10895786f, -0.01770164f, 0.07037270f, -0.03570030f, -0.08358921f, 0.04288443f, -0.13888218f, 0.05218348f, 
    -0.11239773f, 0.15701035f, 0.14817546f, -0.05269783f, -0.00859602f, -0.09407271f, -0.11042855f, -0.07088467f, 
    0.09922802f, -0.01500178f, 0.09197856f, -0.10559347f, 0.17612624f, -0.09194675f, 0.09984700f, -0.01674722f, 
    0.03059392f, -0.04269318f, -0.07892602f, 0.14813659f, -0.06080535f, -0.06026312f, 0.07746013f, -0.06667398f, 
    0.07015125f, 0.01222928f, -0.02442213f, 0.10919379f, -0.15832251f, 0.03756105f, -0.07546367f, 0.01334973f, 
    0.07417265f, -0.06914587f, -0.04152590f, -0.09492250f, -0.17293295f, 0.33226815f, -0.03692118f, -0.00298060f, 
    0.06647446f, -0.02611236f, -0.10210007f, -0.11086004f, 0.03462053f, -0.02634598f, -0.00338770f, 0.03352232f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02663382f, 0.00716548f, -0.03674191f, -0.01339767f, 0.00934019f, -0.02524604f, -0.01936922f, -0.04455914f, 
    -0.05340818f, -0.02401110f, 0.09474085f, -0.00208172f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
