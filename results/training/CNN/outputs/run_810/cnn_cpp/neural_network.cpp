#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.78430712f, 0.33831573f, 0.23346451f, -0.09654026f, 1.26607275f, 1.34962022f, 0.19905601f, -1.12801778f, 
    0.01989476f, -0.63199747f, -0.11993172f, 0.40408465f, -0.20990716f, 0.36793950f, -0.34900171f, -0.38935417f, 
    -0.03236186f, -0.18199317f, -0.14952895f, -0.03422527f, 0.22806245f, -0.30962035f, -0.50110596f, -0.36136153f, 
    -0.14974719f, 0.74063987f, 0.99512470f, -0.92312777f, -0.13296874f, 0.92990607f, 0.06857283f, -0.49739090f, 
    0.53490347f, 0.05318597f, 0.58278078f, -0.34533381f, -0.02545921f, 0.35616520f, -0.58177239f, -0.50659478f, 
    0.02920624f, -0.14864448f, 0.27623478f, -0.23118274f, 0.46215066f, 0.04656131f, 0.35179663f, -0.21154930f, 
    -0.31073639f, -0.28549024f, -0.07838590f, -0.31540990f, 0.63637632f, 0.36913225f, 1.04116082f, -0.03235129f, 
    -0.81102151f, -0.73064846f, -0.73477590f, -0.33214062f, 0.03188689f, 0.18617742f, 0.70674169f, 0.62161946f, 
    -0.04081353f, 0.54827517f, 0.12714042f, 0.36630091f, 0.48198739f, 0.35305718f, 0.02779311f, 0.01857394f, 
    0.01219948f, -0.17316008f, -0.42062008f, -0.53341120f, -0.97960472f, -0.40245077f, 0.57790881f, -0.25202662f, 
    0.75703394f, 1.37775207f, 0.03409664f, 0.55214739f, 0.32323447f, 0.29257530f, -0.28892416f, -0.10946248f, 
    0.03202210f, -0.22386605f, -0.16337392f, -0.06741225f, -0.21710911f, -0.28315970f, -0.23630668f, 0.01878662f, 
    -0.24312542f, 0.10044910f, -0.31284574f, 0.21075052f, -0.15434864f, -0.41889518f, -0.54338074f, 0.13318419f, 
    0.76674581f, -0.03704901f, -0.40957651f, -0.81619000f, -0.03323591f, 0.30037493f, 0.22367226f, -0.34083167f, 
    0.12081139f, -0.23105073f, 0.11581425f, 0.46606562f, 0.22270331f, 0.14412950f, 0.69293720f, 0.09694228f, 
    -0.31785843f, 0.19723816f, -0.08769444f, -0.30425587f, 0.32801232f, 0.60191625f, 0.75085467f, -0.15061104f, 
    -0.07564597f, 0.83197659f, -0.43468761f, 0.27764732f, 0.93237472f, 0.51188290f, -0.12925342f, -0.47876292f, 
    -0.33344996f, -0.01463889f, -0.19291173f, 0.36677644f, -0.03360893f, 0.34725693f, 0.41191411f, 0.57942092f, 
    0.35382226f, 0.46283141f, 0.07685573f, 0.30623117f, 0.31499097f, -0.09727272f, 0.75083995f, 1.40332985f, 
    0.49471158f, 0.19467877f, -0.45301837f, 0.63409108f, -0.08685500f, -0.45358944f, -0.05098053f, -0.35093477f, 
    0.39604723f, 0.05113984f, 0.19646594f, 0.29738960f, -0.16907191f, 0.31319270f, -0.27082977f, 0.04758061f, 
    0.43023384f, -0.38118836f, -0.26259229f, -0.41755748f, -0.37014768f, -0.22426665f, 0.30111551f, 0.08479871f, 
    0.57066089f, 1.04381156f, -0.30175060f, -0.37000865f, -0.23442955f, -0.27432877f, -0.07052483f, 0.35350883f, 
    0.08808357f, 0.37963530f, 0.50501931f, 0.10177994f, 0.17531672f, 0.54588699f, 0.23107870f, 0.28255975f, 
    -0.12635621f, -0.17583440f, 0.69095296f, 0.40613121f, 0.25266212f, 0.06807644f, -0.12091726f, 0.12972723f, 
    0.71020162f, 0.81113100f, 0.35979787f, 0.92507035f, 0.72610426f, 0.83914328f, -0.08277924f, 0.09575175f, 
    -0.30281121f, 0.44473067f, 0.01221319f, -0.55628169f, 0.12538724f, -0.01290297f, -0.04122071f, 0.26515967f, 
    0.10962262f, -0.43924445f, -0.21090329f, -0.42964134f, 0.25664580f, 0.35578933f, 0.23505254f, 0.31041187f, 
    -0.10479449f, -1.37519300f, 0.30535051f, 0.57968390f, -0.46203479f, -0.65169358f, -0.19920154f, 0.59136742f, 
    -0.49173945f, -0.39968392f, -0.70599794f, -0.26023296f, 0.62183499f, -0.25390497f, 0.57114744f, 0.19945301f, 
    -0.33587125f, -0.08578599f, 0.01378179f, -0.37434763f, -0.47514004f, 0.23832963f, 0.03050088f, 0.09342921f, 
    0.33660781f, 0.34657213f, 0.33424088f, -0.07662971f, -0.39068386f, 0.70454460f, -0.66739237f, 0.54585791f, 
    0.18097879f, 0.43513852f, 0.88692600f, 0.46518013f, -0.15596502f, -0.07317514f, 0.49934953f, -0.27306247f, 
    0.04195231f, 0.25553113f, -0.30601022f, 0.09118708f, -0.11792754f, 0.21239299f, 0.11714424f, -0.27369249f, 
    0.35090327f, 0.12091783f, 0.32922882f, 0.96104497f, 0.38770857f, -0.93232739f, -0.38103136f, -0.61076993f, 
    0.58629161f, 0.85833412f, 0.32434818f, 0.76920050f, 0.28842574f, 0.04684393f, -0.30131355f, -0.61853147f, 
    -0.48155108f, -0.31410360f, 0.15462041f, 0.10692432f, -0.06118741f, -0.05898517f, 0.31129885f, -0.16210039f, 
    0.03140481f, -0.47469068f, -0.16576128f, -0.28588644f, 1.24134338f, 0.98788571f, 0.66359305f, 0.41593021f, 
    -0.49048907f, 0.37795711f, 0.28680968f, -0.29535943f, -0.02221085f, -0.34697884f, 0.37332121f, 0.36104915f, 
    -0.49817944f, -0.16628388f, 0.39530456f, 0.29565850f, -0.27176192f, -0.08274709f, 0.16232882f, 0.19757901f, 
    0.39579102f, 0.06202397f, 0.66706127f, 0.08535033f, 0.06631257f, 0.88456732f, 0.61599708f, 0.04728865f, 
    0.57101768f, -0.01177118f, 0.02708087f, 0.38536996f, 0.70868838f, 0.62285525f, 0.49048898f, -0.64171612f, 
    -0.20007448f, 0.04343576f, 0.02865113f, -0.36036241f, -0.58169383f, -0.33946913f, -0.28747222f, -0.26504365f, 
    0.35953376f, 0.14049028f, -0.50364161f, 0.14271741f, 0.13523310f, 0.09811839f, 0.23670086f, 1.01351368f, 
    0.60764754f, 0.33194217f, 0.82134563f, -0.42265981f, -0.93289244f, -0.93258101f, -0.69745910f, -0.43500012f, 
    0.41640928f, -0.17347991f, 0.26008317f, 0.41646063f, -0.35751042f, -0.01930922f, -0.11822991f, 0.07932767f, 
    -0.37637830f, -0.04586784f, -0.10393313f, 0.17852683f, 0.43678984f, -0.22713016f, -0.01541470f, 0.86523616f, 
    -0.48682538f, -0.53446227f, 1.02008379f, 0.96256959f, 0.94295830f, 0.67976981f, 0.37625322f, 0.41900754f, 
    0.40224954f, -0.51717937f, 0.00700666f, -0.26966053f, 0.04715101f, 0.39884669f, 0.06723514f, -0.15561697f, 
    0.00940228f, 0.07675788f, 0.22175355f, 0.34604388f, 0.23121329f, -0.01788993f, -0.11252642f, -0.08575182f, 
    -0.67486078f, -1.40194714f, -0.97655803f, -0.59807098f, -0.12609400f, -0.36763507f, 0.41905442f, 0.71116143f, 
    -0.15080538f, 0.65851742f, 0.21678412f, 0.18244274f, 0.06593130f, -0.22438848f, -0.15416931f, -0.08384854f, 
    0.34773347f, 0.13502994f, 0.16451670f, -0.22142817f, -0.35462600f, -0.42968401f, 0.18995726f, -0.03252637f, 
    0.38188145f, -0.77431369f, -0.73238635f, -0.18639639f, -0.38420594f, -0.42277294f, -1.00788558f, -0.25196335f, 
    -0.45045978f, -0.85116303f, 0.09643072f, 0.02264000f, 0.05070226f, -0.38720897f, -0.06070707f, -0.08729486f, 
    0.16471809f, -0.01329033f, -0.20992976f, -0.31861651f, -0.37000036f, -0.31683585f, -0.35645536f, 0.33068025f, 
    0.18209834f, -0.42164034f, -0.63261384f, -0.99281055f, -0.94787741f, -0.78378415f, -0.03854058f, 0.35399967f, 
    0.75563914f, -0.06481785f, 0.10237642f, 0.60807383f, -0.28569975f, 0.12056372f, 0.18164992f, 0.33867565f, 
    -0.59568119f, 0.15906630f, -0.07372767f, -0.03213735f, -0.00277028f, 0.33352920f, -0.32364845f, 0.24927777f, 
    -0.59892100f, -0.05456228f, -0.22802517f, 0.55336738f, -0.93524528f, 0.42505351f, 0.77359354f, 0.03560980f, 
    -0.18301119f, 0.49182120f, 0.61749977f, -0.35240293f, -0.03674160f, -0.10295216f, 0.35282281f, -0.21614330f, 
    0.76401275f, 0.05935569f, -0.24397007f, -0.33270577f, -0.57282776f, -0.06183647f, -0.20552328f, -0.44326919f, 
    0.00957091f, -0.25964180f, 0.59583795f, -0.12349003f, -0.13570604f, 0.33791825f, -1.03748703f, -0.69784284f, 
    -0.31430641f, -0.00661027f, -0.85683358f, -0.54919571f, -0.68769157f, -0.23795556f, 0.33182621f, -0.33378673f, 
    0.42542517f, 0.09166292f, -0.45636871f, -0.29265687f, -0.18333723f, 0.49970463f, -0.43480715f, 0.25956127f, 
    0.13306597f, 0.08398038f, 0.41104645f, 0.65254313f, -0.14609164f, 1.18747401f, -0.24568030f, 0.44440511f, 
    0.87800193f, 0.51185113f, 0.38655555f, -0.18419167f, -0.55280292f, 0.47964621f, 0.42596543f, 0.03592861f, 
    0.06365535f, -0.40504262f, -0.19050227f, -0.38382828f, -0.43984631f, -0.17813978f, 0.13579199f, -0.07561242f, 
    -0.31086943f, -0.00196231f, 0.27636451f, -0.39695904f, -0.25646806f, 0.15413830f, -0.47014165f, 0.03578583f, 
    -0.51973927f, -0.92510754f, -0.62573552f, 0.99694693f, 0.76629317f, -0.56518042f, 0.30866998f, 0.34877530f, 
    -0.15184577f, -0.41472736f, -0.37071335f, -0.34854525f, 0.55151290f, -0.15485366f, -0.00454984f, -0.18901016f, 
    0.10917049f, -0.04543189f, 0.16542038f, -0.20626457f, 0.18508999f, 0.33735090f, 0.14203525f, 1.29236209f, 
    0.64579749f, 0.40896735f, 1.12640345f, 0.21068358f, 0.22223863f, 0.21424153f, -0.21572357f, -0.56607521f, 
    0.25115415f, -0.34987581f, 0.25152633f, 0.01757159f, 0.14998704f, -0.33932218f, -0.03478009f, 0.18895593f, 
    0.16227372f, 0.26512218f, 0.06559131f, -0.25917226f, -0.26316592f, -0.23981878f, -0.45857269f, 0.27107868f, 
    -1.15466642f, -1.31257629f, -0.33541456f, 0.55054343f, 0.16348602f, 0.57511538f, 0.72325075f, 0.69820362f, 
    -0.05653035f, -0.78921902f, -0.22132728f, 0.17487237f, -0.14970851f, 0.61700916f, 0.33583349f, 0.19919848f, 
    0.17555858f, -0.30583665f, -0.27967331f, 0.11965351f, 0.12936962f, 0.16397448f, 0.15762994f, 0.29123601f, 
    -0.13212588f, 1.12356126f, -0.18460143f, -0.35694581f, -0.35852197f, -1.05373847f, -0.28664988f, -0.48338950f, 
    0.22224227f, 0.47181100f, -0.14003359f, 0.49372378f, 0.52772015f, 0.41447517f, 0.21870337f, 0.18321180f, 
    -0.19605187f, 0.09960640f, -0.20601723f, -0.01566909f, 0.60723895f, -0.11330713f, 0.25490588f, 0.34740534f, 
    -0.06153412f, 0.52318919f, -0.48584437f, 1.52830744f, -0.32235661f, -0.01244157f, 0.42635143f, -0.70303708f, 
    1.02723610f, 0.43068355f, -0.26006553f, 0.39290333f, -0.18285528f, -0.00985251f, -0.08107136f, -0.33153781f, 
    0.38308910f, 0.01308376f, 0.09630692f, -0.06566344f, -0.01393904f, -0.35153949f, 0.31859961f, -0.01028650f, 
    -0.15549134f, 0.19689940f, 0.33976153f, 0.61828977f, 0.84539038f, 1.09517050f, -0.30890304f, 0.82719177f, 
    0.50452244f, -0.32743207f, -0.86516297f, -0.16241375f, -0.43810341f, 0.46043193f, 0.20581977f, -0.15667540f, 
    0.03581961f, -0.07750612f, -0.04076838f, 0.42155609f, -0.32543775f, 0.23927125f, 0.11141395f, 0.12619929f, 
    0.03568382f, 0.26046649f, 0.08095153f, 0.34353769f, 1.20059311f, -0.41566864f, -0.50144410f, -1.51436925f, 
    0.52787423f, -0.04665604f, 0.27004251f, 0.15632653f, -0.27314156f, -0.23996192f, -0.51427609f, 0.09868664f, 
    -0.25184798f, -0.44116113f, -0.47904015f, -0.18676782f, 0.07819865f, -0.32108012f, 0.10939974f, -0.23883550f, 
    -0.30081460f, -0.08055768f, -0.29182985f, -0.18901534f, -0.12880605f, -1.40209401f, 1.25776935f, 1.24816978f, 
    -0.96957695f, 0.84772068f, -0.01942223f, 0.48455393f, 0.32249746f, -0.60148668f, -0.21827023f, -0.28121266f, 
    -0.17858112f, 0.29758361f, 0.02065492f, -0.24946994f, 0.07645103f, -0.26608583f, -0.09343788f, 0.01941773f, 
    -0.08061821f, -0.04941399f, 0.12964034f, 0.14888847f, -0.02148470f, 0.17198201f, 0.60655010f, -1.58808172f, 
    0.46721530f, 0.76794684f, 0.98230672f, -0.96743268f, 0.50967610f, 0.39726308f, -0.51189816f, 0.28279167f, 
    0.42872784f, 0.35978162f, -0.15260653f, -0.18101034f, 0.05866272f, -0.21786156f, 0.30879414f, 0.13561203f, 
    0.09705338f, 0.16472508f, 0.13173449f, 0.23271203f, 0.01750556f, -0.08049572f, 0.05041692f, 0.42588353f, 
    -0.66228938f, -0.27107501f, 0.40642774f, -0.34557676f, 0.05461853f, 0.98665702f, -0.17708692f, 0.53538811f, 
    0.81629014f, -0.50965554f, 0.61485374f, -0.05955054f, 0.59372985f, 0.40824440f, -0.17425299f, -0.32828036f, 
    0.09651381f, -0.17353575f, -0.36835632f, 0.29496595f, 0.42079294f, -0.09003652f, 0.14621803f, 0.14094304f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28728682f, 0.10096134f, 0.26387689f, 0.34603807f, 0.23298065f, 0.19238646f, 0.26879713f, 0.00832560f, 
    0.21843775f, 0.29133204f, -0.00803519f, -0.11737449f, 0.46224344f, 0.11892012f, 0.48426989f, 0.18718706f, 
    0.41384861f, 0.23032953f, 0.06673739f, 0.17414410f, 0.24447152f, -0.00463044f, 0.31907293f, 0.22539598f, 
    0.38080761f, -0.00266570f, 0.08503249f, 0.21449140f, -0.01471969f, 0.16151780f, 0.16487679f, 0.08702159f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.42072302f, -0.26067725f, 0.28684381f, -0.01702345f, -0.01941087f, -0.06130665f, 0.14144517f, -0.20959988f, 
    0.00225184f, 0.01915068f, 0.08328184f, 0.09811061f, 0.04341295f, -0.01789960f, 0.21258062f, -0.30390325f, 
    -0.13592298f, 0.12494296f, 0.08221789f, 0.00688139f, 0.08444454f, 0.17267597f, -0.14069764f, 0.06385912f, 
    0.06899893f, -0.05784049f, 0.11860045f, -0.04658804f, -0.02314728f, 0.03418501f, -0.02270166f, -0.08285653f, 
    0.13540265f, -0.07366569f, -0.11325995f, -0.15498655f, 0.14089034f, 0.27727309f, 0.10246723f, -0.01135881f, 
    0.01144669f, 0.01618110f, -0.05591336f, -0.01147519f, 0.02244652f, 0.02390066f, -0.18224533f, 0.05736456f, 
    0.06405712f, -0.24734069f, 0.23618786f, 0.22810379f, 0.01338501f, -0.00713180f, 0.21969800f, -0.09850700f, 
    0.03729292f, 0.03293189f, -0.03324616f, -0.05218857f, -0.00379525f, 0.19704804f, -0.10665268f, -0.00199192f, 
    -0.24983519f, 0.02179800f, -0.15863800f, -0.01739390f, -0.05462910f, 0.02880485f, 0.09528339f, 0.02155678f, 
    0.04672609f, 0.14518735f, 0.00440745f, -0.23870492f, -0.30413643f, -0.16362771f, 0.10562284f, 0.07466673f, 
    -0.04762564f, 0.05055401f, -0.03660536f, -0.04048903f, -0.04930474f, 0.15265855f, -0.00981410f, 0.08094281f, 
    0.02096373f, 0.15927024f, -0.02105881f, -0.09277524f, 0.13190940f, -0.14626622f, 0.03457217f, 0.16044742f, 
    0.18085277f, -0.13816577f, 0.04864561f, 0.21229269f, -0.17635885f, -0.00479560f, 0.07937036f, 0.01579779f, 
    -0.19070901f, 0.02248512f, -0.00081917f, -0.03822878f, -0.31459031f, 0.16827276f, 0.16553839f, 0.00306505f, 
    0.11026032f, 0.09906879f, 0.03721187f, 0.03341045f, 0.06474943f, 0.06895845f, -0.14930701f, -0.03133821f, 
    0.18252763f, 0.19092289f, -0.46722510f, 0.14751832f, 0.07086346f, 0.04558578f, -0.07625646f, -0.13233957f, 
    -0.02052814f, -0.04951776f, -0.10209188f, -0.03134764f, 0.11380742f, 0.22113633f, -0.09404419f, -0.17273697f, 
    -0.10126058f, 0.01249247f, 0.07061433f, 0.08299202f, -0.16550675f, 0.03636283f, 0.05252611f, 0.12474386f, 
    0.09326299f, 0.04346381f, -0.19342472f, -0.05692993f, -0.22507781f, -0.17047904f, 0.06547143f, 0.03562199f, 
    0.03194163f, -0.07920630f, 0.01311170f, -0.11996665f, 0.00464641f, -0.03171880f, -0.24233478f, 0.23853379f, 
    -0.14414798f, 0.05245621f, -0.11734256f, 0.03331274f, -0.05176634f, -0.03894525f, 0.10915046f, 0.02815727f, 
    0.17257155f, 0.15090911f, 0.12499247f, -0.12885417f, -0.17539307f, -0.12935895f, -0.10049438f, 0.01694066f, 
    0.04546363f, -0.09813609f, -0.05192987f, -0.09372253f, 0.09360199f, 0.09100122f, 0.03562839f, 0.51655906f, 
    0.03748464f, -0.03224849f, -0.14019810f, -0.03395158f, 0.01111437f, -0.03944733f, 0.01853001f, -0.02338721f, 
    -0.26256701f, 0.28672048f, -0.10346855f, -0.43287584f, 0.21262814f, 0.07230929f, -0.07331493f, 0.06131089f, 
    0.02978041f, 0.15031157f, -0.14460552f, -0.03042851f, -0.44474536f, -0.34135470f, -0.04754400f, 0.11287784f, 
    -0.01102319f, -0.01775464f, 0.00096312f, 0.04743953f, -0.03454563f, 0.07943860f, 0.04495839f, -0.01036374f, 
    -0.06116262f, -0.03986689f, 0.03521582f, -0.54816377f, 0.13247274f, -0.01606323f, 0.08043642f, 0.07227794f, 
    0.02465528f, -0.02339094f, -0.02446599f, -0.00944205f, 0.26512024f, 0.08372578f, -0.29126728f, 0.18416965f, 
    -0.15001014f, -0.04821159f, -0.06560258f, -0.07724116f, 0.09832038f, 0.05082766f, 0.12769742f, -0.15232410f, 
    -0.12922081f, -0.17139503f, 0.20526148f, -0.09547424f, -0.22470583f, 0.09294007f, 0.19916491f, 0.03486667f, 
    -0.08569101f, 0.08159883f, -0.03995162f, -0.16820809f, 0.38135925f, -0.28868505f, -0.13146366f, 0.50800031f, 
    -0.05959778f, -0.04890657f, 0.23057526f, 0.01543331f, -0.18059947f, 0.16133530f, -0.11323673f, -0.12733410f, 
    0.55851609f, 0.03455290f, 0.10981953f, -0.53700197f, 0.06835254f, 0.00838038f, 0.00140809f, 0.08724941f, 
    0.05636735f, -0.01478969f, 0.08886126f, 0.18887445f, 0.18417226f, 0.04257117f, -0.06643341f, 0.20220312f, 
    -0.32244879f, -0.07758940f, -0.10126211f, 0.15686312f, 0.00680323f, 0.08251950f, -0.17304493f, 0.10604571f, 
    -0.61881274f, 0.22436073f, -0.06939458f, 0.01862596f, 0.19528884f, 0.12137332f, -0.24079221f, 0.05193951f, 
    0.16939926f, -0.12145509f, 0.09013668f, -0.13689409f, -0.14527315f, -0.54714417f, -0.01065403f, 0.15588868f, 
    -0.01698621f, 0.03987468f, -0.03035617f, 0.00831938f, 0.09782254f, -0.12025321f, 0.00387202f, 0.13224044f, 
    0.21439877f, 0.03866164f, 0.29805472f, -0.32151479f, -0.06233266f, -0.02942018f, 0.01677932f, -0.23113206f, 
    -0.22038397f, -0.04464530f, -0.13199648f, -0.13820449f, -0.10754994f, 0.03931693f, 0.17335084f, -0.42168331f, 
    -0.15095699f, -0.09554493f, -0.02084654f, -0.03119715f, 0.12861006f, -0.04918489f, 0.00128498f, 0.02258639f, 
    0.00018370f, 0.10604145f, 0.15072487f, -0.68539292f, -0.06615667f, 0.00069634f, 0.00324562f, 0.06037429f, 
    -0.20521274f, -0.03954834f, 0.07756266f, -0.05963024f, -0.58173746f, -0.02304427f, 0.25928205f, -0.13618940f, 
    -0.05231169f, -0.01101006f, -0.10323454f, -0.10783063f, 0.06964798f, -0.16323298f, 0.07665481f, 0.06846367f, 
    0.37193048f, -0.09811566f, -0.11369188f, 0.28422946f, -0.27941164f, 0.05635608f, 0.01945665f, -0.01994964f, 
    -0.08767594f, -0.01736715f, -0.17544390f, -0.01724899f, -0.07078350f, -0.13532278f, -0.11973083f, 0.06795429f, 
    -0.06387946f, -0.20811670f, -0.11955589f, 0.01231860f, 0.10420041f, 0.04480095f, 0.10124142f, -0.05246440f, 
    0.00491883f, -0.11780063f, -0.13722359f, -0.01776512f, -0.02816691f, -0.06085560f, -0.17514583f, 0.04598949f, 
    -0.20718427f, -0.00322521f, -0.07978689f, -0.29001436f, 0.18862243f, -0.03698585f, 0.06475393f, -0.00468418f, 
    0.05357359f, -0.07603682f, -0.00402880f, 0.06810150f, 0.14169247f, -0.18381904f, 0.00322992f, 0.04557540f, 
    -0.10857856f, -0.03104003f, -0.04956803f, -0.22177300f, -0.03930542f, -0.06294880f, 0.13735062f, -0.11538212f, 
    0.03254769f, 0.08083507f, 0.07740929f, 0.18539485f, -0.00529884f, -0.09850225f, -0.19315456f, 0.04891697f, 
    0.22370461f, 0.06385424f, -0.02223710f, 0.02201983f, -0.11686055f, 0.18754680f, -0.05384011f, 0.01902147f, 
    0.19228126f, -0.07830852f, -0.09456205f, -0.25459531f, 0.02796861f, -0.05153035f, -0.10984807f, 0.01780751f, 
    -0.05833243f, -0.06317444f, 0.08518377f, -0.05871332f, 0.18637490f, 0.12423335f, 0.04764700f, 0.12736493f, 
    -0.05282479f, -0.15734789f, -0.07985739f, 0.03688056f, 0.19315369f, 0.02220729f, -0.18565638f, 0.07008545f, 
    0.07851691f, -0.03574767f, 0.16647303f, 0.05200396f, -0.11399862f, 0.11316004f, 0.03532615f, 0.08434863f, 
    0.08485410f, -0.00478369f, -0.12293921f, 0.12577833f, -0.59913373f, 0.04716254f, -0.09443408f, -0.12337586f, 
    -0.08728306f, -0.19556645f, 0.07114437f, 0.01337779f, 0.09333676f, 0.07228129f, 0.02237608f, -0.06474355f, 
    0.20880845f, 0.06562223f, 0.19138306f, 0.28404170f, 0.01113321f, 0.01694460f, -0.00807119f, 0.04315222f, 
    -0.04527590f, -0.05370224f, -0.03323630f, 0.13608496f, -0.67406327f, 0.18365976f, -0.47239164f, -0.16700037f, 
    -0.24300082f, 0.04209085f, 0.01377746f, 0.03930419f, 0.05362577f, 0.03419636f, -0.11925120f, -0.06640036f, 
    -0.07991012f, -0.12709899f, 0.02716028f, 0.03312729f, -0.05094474f, -0.07180947f, -0.06580047f, 0.12168563f, 
    0.04879832f, -0.00712865f, 0.16795520f, 0.04366917f, 0.41166165f, -0.56461400f, 0.12708524f, -0.10183926f, 
    0.10018863f, -0.08651169f, -0.14389022f, -0.07453660f, 0.08625461f, -0.04715611f, -0.12284447f, 0.00253091f, 
    0.02886884f, -0.14413179f, 0.22058059f, 0.06345259f, -0.35069716f, -0.05324362f, 0.09011675f, 0.07207485f, 
    -0.13877313f, 0.05003506f, -0.12224592f, 0.18488103f, 0.26407743f, 0.13089456f, 0.18983801f, 0.31810600f, 
    -0.08087370f, 0.03298491f, 0.10691475f, 0.10423923f, -0.07560874f, -0.06018488f, -0.12386414f, -0.14309521f, 
    -0.00767874f, -0.13128918f, 0.14426045f, -0.10664004f, 0.10905624f, -0.05930540f, 0.15102467f, -0.06309837f, 
    -0.05716784f, -0.01789259f, 0.00382388f, 0.07193688f, 0.39000100f, -0.36742905f, 0.01090899f, 0.07299004f, 
    -0.09918319f, 0.03194811f, -0.20842764f, -0.09526643f, 0.12274260f, 0.28649101f, -0.07473927f, 0.06737633f, 
    0.41874647f, -0.19072053f, -0.00341332f, 0.02718640f, -0.13839163f, -0.11928301f, 0.03226085f, 0.06201328f, 
    -0.00376591f, -0.25193635f, 0.12723936f, 0.03460588f, 0.07700534f, 0.17776734f, 0.02637859f, 0.23245455f, 
    -0.25283715f, -0.07620017f, 0.11150794f, -0.01928006f, -0.06388105f, -0.13042803f, -0.15459989f, 0.01403170f, 
    0.07221615f, -0.00979332f, -0.04816418f, -0.16337463f, -0.06888308f, -0.06693777f, -0.03959970f, -0.05718049f, 
    -0.05647663f, 0.14267795f, 0.03076758f, -0.14547725f, -0.18614364f, -0.02452868f, 0.10415818f, 0.13845457f, 
    0.01934000f, 0.01708408f, -0.04081981f, -0.00798305f, 0.09049640f, -0.01430646f, -0.21685803f, -0.05314898f, 
    -0.15497854f, -0.23923609f, -0.15122381f, -0.45511535f, 0.00080295f, -0.05120466f, 0.18006703f, -0.00980831f, 
    0.10216007f, -0.03750575f, 0.13396196f, -0.00746490f, 0.19743155f, -0.04151180f, 0.22626822f, 0.12228135f, 
    -0.25012025f, 0.01648820f, -0.08206911f, 0.03532142f, 0.04300868f, -0.05550957f, 0.03109819f, -0.15082142f, 
    -0.37648210f, -0.21679102f, -0.09760281f, -0.26008186f, -0.01535559f, -0.24217816f, -0.05876064f, -0.06991871f, 
    -0.01265127f, 0.07007940f, -0.20138168f, 0.00997729f, 0.43389651f, 0.05827685f, 0.00390722f, 0.26188502f, 
    -0.00011807f, 0.04434048f, -0.00485322f, -0.02688023f, 0.07527708f, -0.22702864f, 0.03161391f, -0.16054769f, 
    0.17336136f, 0.05140226f, -0.23778199f, 0.11108806f, -0.15984155f, 0.00475615f, -0.04534009f, -0.02047351f, 
    -0.06362125f, 0.12994622f, -0.07540010f, 0.13805619f, 0.33819050f, -0.13786002f, -0.15217270f, -0.17676391f, 
    0.02895758f, 0.10432754f, -0.21820398f, 0.15237743f, -0.31056130f, 0.13939731f, 0.05173168f, -0.00051166f, 
    0.19252551f, 0.19731794f, -0.17936763f, -0.14755005f, 0.04945036f, 0.20864750f, -0.08824580f, 0.05107174f, 
    0.17652220f, 0.05529982f, 0.13615333f, 0.04174285f, -0.01819954f, -0.13940853f, 0.22009049f, 0.18898778f, 
    -0.17877357f, 0.07651319f, 0.06584319f, 0.03017561f, -0.04930859f, 0.07709815f, -0.00290793f, -0.04907360f, 
    0.25839710f, -0.29338682f, 0.23773023f, -0.42427185f, 0.23637925f, 0.03034688f, -0.06239081f, 0.00903756f, 
    0.01356887f, -0.02149487f, -0.09475703f, 0.03872124f, -0.03575979f, 0.10078544f, -0.38268363f, -0.38168070f, 
    -0.08484236f, 0.18841518f, 0.12041262f, -0.11223011f, -0.02428125f, 0.12852348f, -0.04423398f, -0.00676650f, 
    -0.35259834f, -0.37290853f, 0.12395880f, 0.20295787f, -0.04797108f, 0.01702862f, 0.03326128f, 0.12195724f, 
    0.14115544f, 0.03030779f, 0.23251277f, -0.04997709f, 0.59400797f, -0.11612765f, -0.04730873f, -0.06743538f, 
    -0.12464279f, 0.09055174f, 0.04154171f, -0.05788532f, -0.14928190f, -0.12464239f, -0.06727374f, 0.08330600f, 
    0.29307622f, -0.51107538f, 0.07085631f, 0.05747091f, 0.00592412f, -0.06233936f, 0.10836798f, 0.04428278f, 
    -0.01513513f, 0.09655564f, -0.02477770f, 0.08774022f, 0.04762302f, -0.06397134f, 0.07887760f, -0.07689580f, 
    0.08719278f, -0.13789572f, -0.00373493f, -0.13051431f, -0.07401115f, 0.03008468f, -0.15127654f, 0.08518338f, 
    0.17047682f, -0.05494974f, 0.04772661f, 0.00062371f, 0.02241096f, 0.07752988f, -0.10701526f, -0.04023924f, 
    -0.12441484f, -0.22490562f, -0.09228011f, -0.16876999f, 0.37052202f, -0.07911262f, 0.24998182f, -0.01457297f, 
    -0.16220742f, -0.04073035f, -0.02282873f, 0.05724910f, 0.01547277f, 0.11700562f, 0.01640382f, 0.00267077f, 
    0.02023474f, -0.44712439f, 0.14040157f, 0.02708134f, -0.11162073f, -0.08269778f, 0.15518199f, -0.03492497f, 
    -0.11543268f, -0.13505334f, -0.14102992f, 0.04302647f, -0.09100588f, 0.07228609f, -0.24050854f, -0.03261152f, 
    0.08808912f, 0.05730465f, 0.07313588f, 0.06400127f, -0.03049996f, -0.16141945f, 0.11444111f, 0.11756488f, 
    -0.03801394f, -0.10096528f, -0.05317062f, -0.15192868f, 0.10082535f, 0.05841348f, 0.09651776f, -0.10891788f, 
    -0.17908774f, 0.04856310f, -0.15383789f, -0.04501966f, 0.01060930f, 0.08235982f, -0.02476127f, -0.11832942f, 
    -0.08929241f, 0.08900550f, 0.07254462f, 0.03925212f, 0.03653935f, -0.02326638f, -0.11185954f, -0.05130883f, 
    -0.01965984f, 0.00211374f, -0.07106725f, -0.01661921f, 0.17374460f, 0.01626989f, -0.08624079f, -0.13641526f, 
    0.08923725f, 0.09658901f, -0.06758903f, -0.05215852f, 0.48931867f, 0.15056010f, -0.51434785f, -0.60969746f, 
    -0.07368332f, -0.08712327f, -0.10972094f, 0.03317834f, 0.07375021f, -0.02112103f, -0.07486387f, -0.13054653f, 
    0.08728097f, 0.01492967f, 0.00346682f, 0.17273960f, -0.10625564f, 0.04669481f, -0.09117760f, 0.09664740f, 
    -0.11143639f, 0.00054383f, -0.04582619f, -0.00136203f, 0.15435678f, -0.09265921f, 0.20793277f, 0.12735669f, 
    0.02526299f, -0.23967890f, 0.11014561f, 0.22603340f, -0.09213027f, -0.10053480f, 0.07690492f, -0.05093181f, 
    -0.00309253f, -0.07746501f, 0.00740375f, -0.29830539f, -0.02470114f, 0.03746843f, 0.02493560f, -0.06894800f, 
    0.04906571f, -0.14558093f, 0.04065416f, -0.06750062f, 0.14953350f, 0.07968576f, -0.19765384f, -0.03953385f, 
    -0.01291538f, -0.04002928f, 0.07412121f, -0.04071014f, -0.11255473f, 0.08267236f, 0.16031834f, -0.04909167f, 
    -0.10420148f, 0.13006501f, -0.25202447f, -0.03493669f, 0.16578858f, -0.01483638f, 0.03954893f, -0.23572655f, 
    -0.13727602f, 0.09003556f, -0.12043437f, -0.07357605f, -0.12954910f, -0.00693102f, 0.09420026f, -0.04983011f, 
    0.00324564f, -0.06849650f, -0.03722805f, 0.08199189f, 0.01454807f, -0.03758404f, 0.08832357f, -0.06515621f, 
    0.30762517f, -0.06980979f, 0.17861845f, 0.34449306f, -0.25430980f, -0.25943029f, -0.07075705f, -0.00762420f, 
    -0.10308030f, -0.00231394f, -0.01237964f, -0.04729146f, 0.45149305f, -0.28029719f, -0.20949152f, -0.46878669f, 
    -0.01421436f, 0.12771806f, -0.24919301f, -0.00470873f, 0.03128640f, -0.06593354f, 0.01799657f, -0.06358780f, 
    0.44007760f, 0.03922699f, 0.33215752f, 0.11914092f, -0.14412917f, -0.02055939f, -0.02708748f, 0.19567502f, 
    -0.07838699f, -0.01868570f, -0.00334599f, 0.01746087f, 0.11508861f, 0.05967058f, -0.16071984f, -0.15441482f, 
    0.04078380f, 0.04567773f, 0.07901829f, -0.06221162f, 0.09379105f, 0.03057346f, 0.03477646f, -0.13225918f, 
    -0.78814542f, -0.00600882f, -0.14068408f, -0.36343911f, 0.00670587f, 0.05015783f, -0.16365209f, -0.06539560f, 
    -0.02554470f, -0.00102601f, 0.02482117f, -0.13303342f, -0.15544398f, 0.10860156f, -0.01148052f, -0.11955763f, 
    0.08788475f, 0.05300780f, 0.02254051f, -0.03262541f, -0.00247558f, 0.03590441f, 0.01462924f, 0.03931044f, 
    0.28887954f, -0.00696942f, 0.25145480f, 0.18441574f, 0.06179034f, -0.06755233f, 0.07020047f, 0.11167346f, 
    -0.00666984f, -0.00893702f, 0.12564448f, -0.08058159f, -0.09027151f, -0.00542649f, 0.04423344f, -0.29405946f, 
    0.11777108f, 0.07082614f, 0.04470379f, -0.01931691f, -0.12693313f, 0.12070625f, -0.11395720f, -0.06418335f, 
    0.29937857f, -0.13967815f, -0.14294413f, -0.10449737f, -0.28672716f, -0.09608877f, -0.04055764f, -0.03396151f, 
    0.13348800f, -0.21672608f, 0.06370743f, -0.12209241f, -0.20883289f, -0.00213861f, 0.04466965f, -0.14801510f, 
    -0.08124125f, -0.05412463f, 0.20259057f, 0.02836500f, -0.05071309f, -0.04097609f, 0.06802680f, -0.09478506f, 
    0.07964627f, -0.04191088f, -0.22916156f, -0.12039234f, 0.17445400f, -0.05179072f, 0.11483159f, -0.16757157f, 
    -0.11501376f, 0.11529560f, -0.02892932f, -0.00603132f, 0.08855687f, -0.07852068f, -0.03228094f, 0.10249054f, 
    0.06562783f, 0.02608512f, 0.06688044f, -0.13870688f, -0.01140694f, -0.00576172f, 0.02773547f, -0.08136328f, 
    -0.66561621f, -0.04391328f, -0.14906839f, -0.20076826f, 0.00052949f, -0.09498505f, 0.13113546f, 0.05181770f, 
    -0.03568817f, 0.04297133f, -0.11242788f, 0.01669845f, 0.57828331f, 0.01383127f, -0.39322501f, 0.10078350f, 
    0.01529776f, -0.03958860f, 0.03612847f, -0.08413635f, -0.00506387f, 0.06135432f, 0.05159513f, 0.03240332f, 
    0.60016674f, 0.09196885f, -0.06660207f, -0.05618639f, 0.09196756f, 0.03684971f, -0.02607425f, -0.05542355f, 
    -0.15688713f, -0.06455575f, -0.13507418f, -0.03163790f, 0.21053970f, -0.03881012f, 0.18676208f, 0.16477625f, 
    -0.19006751f, 0.11810047f, 0.08610882f, -0.03927930f, -0.08667298f, 0.00440798f, 0.00714285f, -0.08134803f, 
    0.96853411f, -0.02634524f, 0.18667284f, 0.23961391f, 0.14401901f, 0.05946956f, -0.02981107f, 0.01587351f, 
    -0.06980493f, 0.07419524f, 0.00292424f, -0.03270423f, 0.12888217f, -0.02120585f, -0.36507106f, 0.22389053f, 
    -0.15208639f, -0.00384257f, -0.09859122f, -0.02421855f, 0.05630673f, 0.09555386f, -0.14475033f, 0.04798149f, 
    -0.00936752f, -0.18823113f, 0.26967439f, 0.43217945f, 0.21895058f, 0.31788301f, 0.08401668f, -0.15025668f, 
    0.05383198f, 0.06146800f, -0.11985448f, -0.06056889f, -0.00856033f, -0.16279638f, -0.08585560f, -0.12992428f, 
    0.09497278f, -0.00046277f, 0.08074930f, -0.13170834f, 0.01146814f, 0.01226564f, 0.05772898f, -0.17745522f, 
    0.23313242f, 0.14654750f, -0.07278892f, -0.05526402f, -0.13925491f, 0.15194167f, 0.10163277f, -0.02580984f, 
    0.04152318f, -0.06636978f, -0.01261375f, -0.04608539f, -0.35933360f, -0.44332549f, -0.15602630f, -0.16528249f, 
    -0.18963549f, 0.05454189f, 0.19394644f, -0.02774292f, -0.15058120f, -0.21632603f, 0.01280129f, 0.02459888f, 
    0.15185089f, -0.20095305f, -0.31908858f, 0.26291370f, -0.00384985f, 0.00687514f, 0.06875937f, 0.16311206f, 
    -0.05492673f, 0.09068114f, 0.03348925f, -0.02160598f, -0.39970613f, -0.17768309f, -0.04572236f, 0.13840500f, 
    0.08164640f, -0.12996086f, 0.08912081f, 0.06112020f, 0.08278872f, 0.01190125f, -0.03687764f, -0.00272753f, 
    -0.41739061f, -0.32283568f, -0.42500177f, 0.16387829f, -0.14494632f, 0.06088703f, -0.02383686f, 0.04331147f, 
    0.02245509f, -0.17082188f, 0.00248249f, 0.12568910f, 0.09720287f, 0.47439438f, 0.20267640f, -0.06185380f, 
    0.06486379f, -0.04694884f, -0.04872112f, 0.01205718f, -0.00583740f, 0.05289160f, -0.03769282f, 0.12960677f, 
    0.08639197f, 0.07071896f, -0.05126287f, -0.31730106f, 0.04887091f, 0.02744271f, -0.04633946f, -0.17328958f, 
    -0.12829985f, 0.05828366f, 0.00575868f, -0.11114744f, -0.09774098f, -0.22766960f, 0.06652487f, -0.14035216f, 
    -0.14261961f, 0.08067840f, 0.06364162f, -0.01990887f, -0.12426574f, 0.02701103f, 0.05264999f, 0.01056226f, 
    -0.32851395f, -0.34973580f, -0.25038248f, 0.04297011f, -0.03603957f, -0.09432735f, -0.13572712f, 0.04363019f, 
    -0.03248118f, -0.03753097f, 0.01081464f, -0.13846269f, -0.12981458f, -0.44869757f, -0.19314185f, -0.08135033f, 
    -0.11427037f, -0.17975526f, -0.02159497f, -0.01375154f, 0.02513919f, 0.06159087f, -0.01909683f, 0.07408378f, 
    0.18830915f, -0.18725722f, 0.04980182f, 0.18669677f, -0.04554407f, 0.14022839f, -0.02142412f, -0.00853057f, 
    0.04707354f, -0.03365355f, -0.01094552f, -0.24010099f, -0.22818761f, 0.05885926f, -0.39752510f, -0.13321531f, 
    0.07657669f, 0.00550787f, -0.04238246f, -0.18489018f, 0.01223554f, -0.16783668f, 0.18367194f, -0.13913177f, 
    0.15241408f, -0.12897916f, 0.05506865f, -0.19141126f, -0.10118728f, -0.09031598f, -0.04357872f, -0.10327449f, 
    -0.06008805f, -0.01371285f, 0.02826160f, -0.10441327f, 0.07536934f, 0.17960292f, 0.12486788f, 0.09685358f, 
    -0.07971505f, -0.04099935f, -0.17897591f, 0.01130944f, 0.09376511f, 0.15031230f, 0.11655347f, 0.01607248f, 
    -0.17348301f, 0.00067653f, -0.14514992f, 0.00745547f, -0.13415876f, -0.19472675f, 0.20474680f, 0.10630415f, 
    -0.07085303f, -0.11986176f, 0.06111065f, -0.13864453f, -0.05686701f, -0.21637651f, 0.21867381f, 0.00005594f, 
    -0.12817061f, 0.02161399f, 0.03580204f, 0.01250782f, 0.03469164f, -0.05842529f, 0.04363084f, 0.04756693f, 
    0.27012417f, 0.20125787f, 0.04606888f, -0.00340992f, -0.01783790f, -0.02368388f, -0.00877149f, 0.10434179f, 
    0.15219949f, 0.09438575f, 0.03250354f, 0.02848507f, -0.01793928f, -0.26390451f, -0.16792008f, -0.01250543f, 
    -0.01870163f, 0.03274636f, -0.02305613f, -0.16757610f, 0.09478591f, 0.09509090f, -0.09556401f, 0.06998389f, 
    -0.12457380f, 0.00557260f, -0.02986546f, -0.16420491f, -0.06952740f, 0.02499386f, 0.00760025f, 0.01694675f, 
    -0.03318388f, -0.21851678f, 0.15194972f, -0.00918730f, -0.22099073f, -0.74555808f, -0.23319337f, 0.29614973f, 
    -0.08028439f, -0.07911935f, 0.08540022f, 0.04633383f, 0.04537930f, -0.03566076f, -0.02180319f, 0.16157828f, 
    0.09613390f, 0.16541319f, 0.02055142f, 0.11534463f, 0.05342492f, -0.23040023f, 0.00040015f, -0.02697731f, 
    -0.18529502f, -0.08866678f, 0.01577318f, 0.02691292f, 0.20648172f, -0.29723608f, -0.32726252f, -0.07177433f, 
    -0.22545318f, 0.04554095f, 0.08775941f, 0.21389718f, 0.18891196f, -0.04284150f, -0.01809138f, 0.00703805f, 
    -0.85897803f, 0.13561423f, 0.00199282f, -0.05384095f, -0.06721005f, -0.05392568f, 0.11084038f, 0.07523447f, 
    -0.00693788f, 0.02441000f, -0.12434158f, -0.03423760f, 0.26696327f, -0.42579761f, -0.04252070f, 0.07213275f, 
    0.05378200f, -0.13422593f, -0.07259511f, 0.03299947f, 0.00946694f, -0.01786476f, -0.01627899f, -0.20091845f, 
    -0.16145962f, 0.02876647f, 0.16829215f, 0.06338155f, 0.04221156f, -0.06452145f, 0.05732604f, 0.05675597f, 
    -0.06386843f, 0.19903812f, 0.14156295f, 0.11646622f, -0.02189291f, 0.09565998f, 0.19660860f, -0.05579799f, 
    0.12532172f, -0.04646758f, 0.02129192f, 0.15367970f, 0.13730760f, -0.11108304f, -0.03117016f, -0.04836179f, 
    -0.30805749f, 0.03304614f, 0.29884696f, 0.29658875f, -0.03651643f, 0.22232015f, -0.04251945f, -0.08854987f, 
    -0.21355873f, 0.15300506f, -0.01309460f, 0.01011554f, 0.12286045f, -0.13836367f, -0.10528189f, 0.00058659f, 
    0.05727998f, 0.14531416f, -0.07767005f, -0.15855339f, -0.13547674f, -0.04882861f, -0.06592397f, 0.07272689f, 
    -0.02643861f, 0.38329655f, -0.35203856f, -0.45769200f, -0.00243806f, -0.05853263f, 0.12074586f, 0.04665373f, 
    0.05603834f, 0.09692328f, -0.01950539f, 0.05911882f, 0.28440151f, -0.41231802f, -0.37009948f, 0.34741747f, 
    -0.21870883f, 0.07650920f, 0.18546589f, -0.07606244f, -0.13202544f, 0.15529485f, -0.11418665f, -0.15421408f, 
    -0.37663057f, -0.01366806f, 0.19049357f, 0.19339588f, -0.00525021f, -0.03095192f, -0.10060488f, 0.10035007f, 
    0.22666264f, -0.23159195f, -0.10129993f, -0.05025567f, -0.75196666f, 0.08034839f, -0.08046662f, -0.08311255f, 
    -0.03405011f, 0.01225875f, -0.02329424f, 0.09468222f, 0.10506687f, -0.09723100f, 0.08228722f, -0.01719559f, 
    -0.02221600f, 0.00079960f, -0.12285668f, 0.17350361f, -0.12561032f, 0.04686117f, 0.07789513f, 0.00871168f, 
    0.13897508f, 0.00155214f, 0.06746949f, -0.06577086f, 0.49355179f, -0.25553688f, 0.09995209f, 0.05124573f, 
    -0.06585011f, 0.04221436f, 0.05933306f, -0.28976497f, 0.06345866f, -0.06973831f, -0.12587200f, -0.01321521f, 
    -0.12398249f, 0.19986737f, 0.05166935f, -0.16693914f, -0.07684152f, 0.01737169f, 0.04696387f, 0.18416721f, 
    0.01805173f, -0.02139877f, 0.09317736f, -0.15277772f, -0.00320379f, -0.27659753f, -0.20893218f, -0.11173609f, 
    -0.18563047f, -0.26307252f, -0.16348721f, -0.19941816f, -0.11625741f, -0.03707304f, -0.02311083f, -0.12523606f, 
    0.16210088f, 0.01059065f, -0.07286984f, 0.12191900f, -0.12055971f, 0.00267461f, -0.13619123f, 0.10915917f, 
    0.00207699f, 0.07943726f, 0.08469974f, 0.10228471f, 0.17264281f, 0.10862281f, 0.28532246f, -0.39007401f, 
    -0.03623813f, -0.10005285f, -0.01989089f, -0.02961149f, 0.12123796f, -0.04649203f, -0.01340513f, 0.04362287f, 
    -0.14593565f, -0.17392166f, -0.09876058f, 0.25227126f, 0.09364397f, 0.00910926f, -0.09270677f, -0.23378469f, 
    -0.10996893f, 0.02176467f, -0.04046303f, -0.14392419f, -0.40173244f, -0.19663851f, 0.10637254f, 0.16722897f, 
    -0.02013677f, 0.10735229f, 0.01325539f, 0.09352383f, 0.09164790f, 0.06525949f, 0.25798994f, 0.07937369f, 
    -0.13531221f, 0.16783348f, 0.25501505f, -0.08656145f, 0.06086260f, -0.07884007f, -0.05069619f, -0.13212176f, 
    0.11907799f, 0.00744460f, 0.04278293f, -0.16603208f, 0.01200563f, -0.06233859f, 0.13594115f, 0.12633722f, 
    0.13117710f, 0.00554687f, 0.06274222f, -0.01113848f, -0.03381877f, 0.03364744f, 0.11029113f, 0.05042270f, 
    -0.50856519f, -0.02619538f, 0.20037325f, 0.27318490f, -0.25002056f, 0.07030420f, -0.17677777f, -0.06650351f, 
    0.01851999f, 0.03263596f, 0.04459217f, -0.02917939f, 0.02524980f, 0.07981750f, -0.18356001f, 0.07985151f, 
    0.07498837f, 0.04002869f, 0.19933827f, -0.00031160f, -0.12271053f, -0.04464032f, 0.06667636f, 0.02085415f, 
    -0.36257643f, 0.18375899f, -0.01724236f, 0.21546951f, 0.15457496f, 0.04152480f, 0.04514771f, 0.12762038f, 
    -0.13124995f, -0.01828942f, 0.03074024f, 0.08852196f, -0.09349753f, -0.22034055f, 0.28178382f, 0.05776031f, 
    0.01950427f, 0.03834431f, 0.09698116f, 0.12273866f, -0.01315964f, 0.13070557f, -0.05737669f, 0.12596399f, 
    -0.46912724f, 0.37333798f, 0.07728664f, 0.32123935f, 0.10986983f, 0.00104531f, -0.00985432f, 0.12802272f, 
    0.08404209f, -0.03290953f, -0.02027142f, -0.05065041f, -0.51168460f, 0.40651900f, -0.01312316f, -0.06911597f, 
    0.05424309f, -0.16342241f, 0.12075450f, 0.14153537f, -0.21691032f, 0.12926313f, 0.04003440f, 0.10016820f, 
    0.07894319f, -0.02121467f, -0.10316508f, 0.04878477f, 0.09537323f, 0.07952128f, 0.05821276f, -0.02260415f, 
    -0.21406400f, 0.03260505f, -0.03663285f, 0.04870630f, -0.02239664f, 0.10904384f, -0.04490295f, 0.00337584f, 
    0.01290363f, 0.01417503f, 0.07670519f, 0.11059743f, 0.09965020f, 0.00469207f, -0.11421235f, 0.19107823f, 
    -0.08859899f, -0.15247051f, 0.11445144f, 0.22329694f, 0.01466021f, -0.12044312f, 0.09492271f, -0.08731324f, 
    -0.01178704f, -0.05223448f, -0.01746349f, 0.05607162f, -0.04604984f, 0.11856509f, 0.13210404f, -0.00255511f, 
    0.01809772f, 0.07067280f, 0.13961686f, 0.08191995f, -0.01335693f, -0.05437438f, -0.06412707f, -0.02010727f, 
    -0.43346247f, 0.05765983f, -0.20183553f, -0.32170933f, 0.00819716f, -0.05561532f, 0.05527579f, 0.10102099f, 
    -0.02021805f, -0.15954129f, 0.08101100f, 0.04005381f, 0.00519962f, -0.00943733f, -0.19174656f, 0.08295389f, 
    -0.03045253f, 0.10779924f, 0.13470678f, -0.10461657f, 0.13514492f, 0.00854405f, 0.00784364f, -0.03888991f, 
    -0.19546649f, 0.06122077f, 0.08738805f, 0.02451879f, -0.15914497f, -0.19017114f, 0.17170297f, 0.01599541f, 
    0.00612127f, -0.01007399f, -0.14565440f, -0.02070030f, -0.11693276f, -0.06049738f, 0.04315768f, -0.02460258f, 
    0.08297496f, 0.02769822f, -0.09335090f, -0.06224884f, -0.01560716f, -0.10232628f, 0.04131888f, -0.09432796f, 
    -0.09024502f, -0.28846982f, 0.15558778f, -0.02196297f, 0.05610274f, -0.09783725f, -0.05838260f, -0.09882493f, 
    0.08884323f, -0.12909280f, 0.15195414f, -0.04166272f, 0.18722571f, 0.62306094f, -0.25596404f, -0.03887831f, 
    -0.11615866f, -0.03511254f, -0.05031524f, 0.12332324f, -0.18703565f, -0.11232647f, -0.03313038f, -0.08297390f, 
    -0.61796963f, 0.13032873f, -0.04780953f, -0.31547421f, 0.13641934f, -0.06079672f, -0.03220182f, -0.09478330f, 
    0.12327046f, 0.04185048f, -0.03444185f, -0.12138896f, -0.45700961f, 0.38710719f, 0.13879952f, -0.01464033f, 
    0.21305446f, -0.11234055f, -0.04554684f, -0.05897817f, -0.04393479f, 0.04423177f, -0.06129065f, 0.23190549f, 
    -0.25651297f, -0.23105457f, 0.20325540f, -0.10074275f, 0.08993910f, 0.15028532f, -0.03363740f, 0.00763353f, 
    -0.10960520f, -0.02827851f, -0.12077571f, -0.15934061f, -0.06427173f, 0.11578193f, 0.21629070f, -0.21682130f, 
    -0.03861716f, -0.18140087f, -0.09886319f, -0.01811055f, -0.28169361f, -0.10304888f, 0.12112170f, -0.13448305f, 
    0.14330266f, 0.02043386f, -0.13336131f, -0.08035550f, 0.07708042f, 0.03648340f, 0.00602446f, 0.15575768f, 
    -0.07369112f, 0.15061544f, 0.33419862f, 0.35701934f, -0.51980948f, 0.12854350f, -0.08872870f, -0.10339174f, 
    -0.08237033f, 0.13177848f, 0.14756851f, -0.32029229f, 0.03943656f, -0.28300804f, -0.02585756f, -0.13584816f, 
    -0.10152484f, -0.00752155f, -0.22080001f, -0.25328746f, 0.03490333f, 0.00853367f, -0.17002429f, 0.08258210f, 
    -0.05829153f, 0.11520854f, 0.07812685f, 0.16703522f, 0.07254370f, 0.04914895f, 0.29606336f, -0.18617600f, 
    0.04235603f, -0.06584313f, -0.02979998f, -0.12896594f, 0.03485871f, 0.09091009f, 0.16829789f, -0.07535311f, 
    -0.03862394f, 0.07465664f, 0.02914729f, 0.07741504f, 0.10199365f, 0.11037602f, 0.02998044f, -0.20230274f, 
    -0.03399155f, -0.25077224f, 0.14066832f, 0.08777695f, 0.25892785f, 0.31411713f, 0.10857225f, 0.06291726f, 
    -0.01764335f, 0.10779160f, 0.00535672f, 0.01507758f, -0.03096360f, 0.07231712f, -0.02853129f, 0.15000355f, 
    -0.01903674f, 0.16388136f, 0.25668949f, -0.10947706f, -0.02698098f, -0.09245949f, 0.20420994f, 0.00452000f, 
    0.21649687f, -0.01244600f, -0.20047656f, -0.08288679f, -0.22943075f, -0.28858057f, 0.08530873f, 0.38566363f, 
    0.09110477f, -0.05059833f, -0.07723442f, 0.10126665f, 0.01668974f, 0.07593663f, 0.13428630f, 0.07009567f, 
    0.22937578f, 0.15557545f, -0.08660626f, -0.17673898f, -0.01110100f, -0.03660025f, 0.03268412f, -0.04002049f, 
    0.01787779f, -0.00352386f, -0.14257465f, 0.09840934f, 0.34702891f, 0.19461951f, -0.23672271f, -0.03701908f, 
    -0.10094290f, -0.02881926f, -0.27538162f, -0.28453350f, -0.11354015f, 0.01415492f, -0.19486171f, 0.02208425f, 
    0.05709707f, 0.08190373f, 0.08467380f, 0.20164263f, 0.18480140f, 0.09651519f, -0.01501829f, 0.05495202f, 
    -0.05462972f, -0.00642626f, -0.00047306f, 0.00650407f, 0.29159597f, 0.14045504f, 0.12549871f, -0.28904748f, 
    -0.14572541f, -0.04231247f, 0.01624070f, -0.12506008f, -0.05780965f, -0.12516703f, -0.13231272f, -0.20571943f, 
    0.06865157f, -0.02365964f, 0.00683598f, 0.31970790f, -0.34166875f, -0.17334935f, 0.17233531f, 0.07902425f, 
    -0.10048061f, -0.13274093f, 0.04499807f, 0.23544556f, -0.17441219f, 0.28945753f, 0.23555344f, -0.49073789f, 
    0.06168130f, -0.09587763f, -0.20204225f, 0.09919173f, 0.18654092f, 0.05319934f, -0.07956084f, 0.02762836f, 
    -0.48456153f, -0.11803071f, -0.39636859f, -0.21758541f, 0.09417009f, 0.15302239f, 0.04023878f, -0.04956923f, 
    0.11010607f, 0.14588396f, -0.03771721f, 0.13999484f, -0.09334638f, -0.05820738f, 0.04215150f, -0.15365808f, 
    0.16109984f, -0.08962181f, 0.06997370f, -0.02320059f, 0.03944373f, 0.04425058f, 0.00561976f, 0.12623334f, 
    0.02979025f, -0.39546722f, -0.47970480f, -0.12773836f, 0.11095537f, 0.05180045f, -0.16527002f, -0.26904556f, 
    0.05217895f, -0.01157228f, 0.02968641f, -0.05521630f, -0.21456058f, 0.10842882f, 0.07169710f, -0.06554663f, 
    -0.08253837f, 0.13867213f, -0.00921340f, 0.06854982f, -0.30504385f, -0.08342730f, -0.08614858f, -0.06883291f, 
    -0.09096088f, -0.12251343f, 0.01112182f, 0.46021518f, 0.14959005f, 0.04180862f, -0.05669051f, 0.15655425f, 
    0.00385385f, -0.03885876f, -0.05743025f, 0.07683999f, -0.11968280f, -0.27365541f, -0.04621869f, 0.00693153f, 
    0.10003994f, -0.09566755f, -0.08840387f, 0.07393665f, 0.07249553f, -0.09683496f, 0.10476928f, -0.15197016f, 
    -0.28649321f, -0.08083062f, -0.12971631f, -0.07551342f, 0.11231190f, 0.12433399f, 0.12982532f, 0.05776798f, 
    0.16713041f, 0.08593403f, 0.05774811f, -0.24114893f, -0.03833161f, 0.01217246f, 0.21717122f, 0.02066377f, 
    -0.15655480f, -0.11509983f, 0.04910726f, -0.03293245f, -0.10946816f, 0.01757568f, 0.10840352f, 0.18571249f, 
    -0.67901152f, 0.03538553f, 0.02906567f, -0.31087139f, 0.06869044f, 0.03754105f, 0.28360251f, -0.05632633f, 
    0.01463330f, 0.22596647f, -0.10574164f, -0.12692779f, -0.08239362f, 0.21040717f, 0.03687701f, 0.17728721f, 
    -0.20948157f, -0.29823670f, 0.05428866f, -0.20957199f, -0.03456198f, 0.00249952f, -0.14011982f, 0.07362284f, 
    -0.21760814f, -0.02844450f, 0.16418181f, 0.25152060f, -0.17441833f, 0.10177837f, -0.08126570f, 0.04897014f, 
    0.24712874f, -0.16293606f, 0.11245352f, -0.03068964f, -0.08447473f, 0.05340382f, 0.12973292f, 0.18229996f, 
    -0.03855498f, -0.03979720f, 0.04888304f, 0.09272652f, -0.10281393f, 0.10133818f, -0.21077351f, 0.16881759f, 
    0.39553520f, -0.06724236f, 0.19187467f, 0.08399100f, -0.07468051f, 0.02977878f, -0.13900389f, 0.02575385f, 
    0.12781259f, 0.02210620f, -0.11759728f, -0.07184689f, -0.39031056f, -0.12134429f, 0.26716071f, 0.27355900f, 
    0.05490901f, -0.03561751f, -0.03329268f, -0.02895399f, 0.05274515f, 0.02487491f, 0.02338661f, -0.03516374f, 
    -0.43063569f, 0.10879762f, 0.11546574f, -0.39993373f, 0.03352556f, -0.05805347f, 0.02562339f, -0.06154129f, 
    0.09289204f, -0.04659079f, -0.03327706f, 0.00911338f, -0.36133978f, -0.08022638f, -0.10028464f, -0.07962318f, 
    -0.01472794f, -0.03093361f, 0.06853654f, 0.26914397f, 0.15682553f, 0.02100056f, 0.10416510f, -0.13223171f, 
    0.19849496f, -0.41950610f, -0.09461867f, 0.06888966f, 0.02636728f, 0.07112235f, -0.10007697f, 0.07791068f, 
    0.10820701f, -0.04813699f, 0.02253701f, 0.10190614f, -0.38958699f, 0.24507961f, 0.01327890f, -0.05191104f, 
    -0.14102547f, 0.21324250f, 0.02331753f, 0.03122156f, 0.08355913f, -0.00334981f, 0.01726726f, 0.10378721f, 
    0.17456383f, 0.19212414f, 0.21162030f, -0.43587005f, -0.00141395f, 0.01080796f, -0.01973748f, -0.04853596f, 
    -0.07667226f, -0.26670158f, -0.12161388f, -0.37829262f, 0.28477082f, -0.44856471f, -0.00710571f, -0.09175128f, 
    -0.12142922f, -0.08255693f, 0.01866083f, -0.00530028f, 0.00879206f, 0.09082749f, 0.26451498f, 0.22361699f, 
    -0.19749629f, 0.15093756f, -0.14248720f, -0.17923751f, -0.08365152f, 0.08637491f, 0.13557957f, -0.00234893f, 
    -0.10544176f, -0.19284844f, -0.21350797f, -0.07075028f, -0.41813269f, 0.10028353f, 0.14695701f, 0.06518816f, 
    0.09530932f, -0.03811204f, 0.07928686f, 0.06730712f, -0.06347622f, 0.02116576f, -0.16206422f, -0.11469227f, 
    0.06092625f, 0.15351593f, 0.06899748f, 0.30072978f, -0.08201662f, -0.06728454f, 0.01681676f, 0.03526640f, 
    0.08602875f, 0.07466067f, -0.20723338f, -0.00314019f, -0.12423200f, -0.04224699f, 0.10188346f, 0.23063889f, 
    0.16478933f, 0.01929990f, 0.06005486f, 0.00481677f, 0.06704562f, -0.03377647f, -0.08558913f, -0.23236239f, 
    0.02685725f, 0.08691701f, 0.00207727f, -0.13099653f, -0.03239601f, -0.03320393f, 0.11944169f, 0.13672046f, 
    -0.27622920f, 0.09957198f, 0.24172162f, -0.16051550f, 0.15595086f, -0.38792366f, -0.00323080f, -0.16633420f, 
    0.00876662f, 0.03925749f, 0.11906854f, -0.14785124f, -0.16493471f, 0.02815258f, 0.01228839f, -0.08949702f, 
    -0.09810927f, -0.05561249f, 0.34743205f, 0.01856937f, -0.12110091f, 0.00787816f, 0.04609725f, -0.06671124f, 
    0.04228308f, -0.11643238f, 0.04244990f, 0.00691915f, -0.54017693f, -0.15744872f, -0.16263896f, 0.31937703f, 
    0.05513301f, 0.03202436f, 0.04674034f, 0.10077003f, 0.08728914f, -0.05381468f, 0.12776577f, -0.09139568f, 
    -0.31837958f, 0.08056270f, 0.08085765f, 0.07176525f, 0.16461289f, 0.11140283f, 0.02041968f, 0.02238184f, 
    0.07255263f, 0.16799803f, 0.07422391f, 0.00023151f, -0.53794390f, 0.08745156f, 0.15828785f, 0.09802603f, 
    0.07984826f, -0.09156657f, 0.00032285f, 0.13150950f, 0.04098685f, 0.12721011f, 0.03491867f, 0.30793837f, 
    0.12488065f, 0.23319381f, 0.00955391f, -0.29853445f, 0.12845463f, 0.10948848f, -0.03592799f, 0.13073781f, 
    -0.10110030f, 0.02748801f, -0.07202810f, 0.04030973f, -0.08556391f, -0.41058922f, 0.05992921f, -0.36586979f, 
    -0.11727124f, 0.01243434f, 0.05215254f, 0.20706531f, -0.06909544f, -0.17805366f, -0.12248738f, 0.03314016f, 
    -0.33837330f, -0.30653170f, -0.10671070f, -0.31098592f, 0.09552483f, -0.10430165f, -0.04262530f, -0.08907440f, 
    0.02755195f, -0.04089463f, -0.00943423f, 0.06495982f, -0.15705170f, -0.00891754f, -0.49535060f, -0.25265998f, 
    -0.00391587f, 0.10092615f, -0.10751055f, -0.00877327f, -0.03246654f, 0.14678045f, 0.00018927f, 0.09934618f, 
    -0.28589067f, -0.24696624f, -0.19716224f, -0.07147316f, -0.05283552f, 0.07674291f, 0.20371106f, -0.08660129f, 
    0.03378637f, 0.14058568f, -0.08407757f, 0.20905583f, 0.47096908f, -0.06394093f, 0.28260106f, -0.03884766f, 
    0.02833234f, -0.01432017f, 0.09321240f, -0.11908780f, 0.14020082f, -0.05813952f, 0.13020846f, 0.08818522f, 
    0.03607945f, 0.02779833f, -0.24661645f, 0.20137411f, -0.06193240f, -0.05083919f, -0.21350627f, -0.09868009f, 
    -0.08084647f, -0.00028695f, -0.17871779f, 0.04175386f, 0.14389180f, 0.19479720f, 0.06676530f, -0.41752321f, 
    -0.10734423f, -0.02362814f, 0.01863978f, -0.09497939f, -0.05642629f, 0.08960333f, 0.13734840f, 0.07780668f, 
    0.12139118f, 0.06845572f, -0.38220069f, 0.11837832f, -0.02364667f, 0.24988207f, -0.11301783f, -0.03695628f, 
    -0.13272706f, 0.10866205f, 0.04651032f, 0.07112961f, 0.15043166f, 0.27522248f, 0.18088782f, -0.35503998f, 
    -0.26763469f, 0.00915972f, -0.06755188f, 0.08635158f, 0.09233206f, 0.05069216f, -0.07303409f, -0.14501186f, 
    0.13306604f, -0.33459672f, 0.10826068f, -0.07470638f, 0.03230676f, 0.05960342f, -0.00531803f, -0.30646601f, 
    -0.01519720f, 0.02460826f, 0.02819538f, -0.19906662f, -0.15560637f, -0.17412631f, -0.05791559f, 0.12908694f, 
    0.13926511f, -0.05144544f, 0.00911355f, 0.03689605f, 0.01285074f, -0.10526335f, -0.02737335f, -0.19403905f, 
    -0.40872973f, -0.06446253f, 0.11450437f, 0.07805361f, 0.17043966f, 0.01372945f, 0.13211702f, -0.02813056f, 
    -0.18746325f, -0.07418056f, -0.03444902f, -0.01668405f, -0.08400135f, 0.18978903f, -0.03806692f, -0.12014288f, 
    -0.07788896f, -0.06907779f, -0.04703261f, 0.03316583f, 0.10987654f, 0.05934143f, 0.02544870f, -0.03506591f, 
    0.02398487f, -0.00832589f, -0.33974388f, 0.21366832f, -0.05391992f, -0.06587835f, 0.10743277f, -0.00489011f, 
    0.09254072f, -0.01175144f, 0.05767742f, 0.27017033f, 0.05335200f, -0.34558403f, -0.01142013f, 0.17165518f, 
    -0.03091163f, -0.04087906f, -0.01612113f, 0.05590086f, 0.05716012f, -0.14016417f, -0.19028088f, -0.03238083f, 
    0.91907126f, 0.06834954f, 0.26475465f, 0.05503808f, -0.09886149f, -0.00314330f, 0.07916521f, 0.06779781f, 
    -0.05621456f, 0.08165057f, -0.02666909f, -0.04827851f, -0.20733282f, -0.14148299f, 0.21290693f, -0.08110240f, 
    -0.05428530f, 0.08230351f, 0.06002592f, -0.28486902f, -0.32213527f, 0.01257545f, 0.05548943f, -0.01718470f, 
    -0.39397693f, 0.30926579f, -0.11658371f, -0.13013686f, -0.02070414f, 0.00741900f, 0.09854147f, -0.10467268f, 
    -0.02375859f, -0.04104746f, 0.01782029f, 0.03272119f, 0.08450565f, 0.19564381f, 0.01976721f, -0.00521702f, 
    0.04958870f, 0.00472069f, -0.13248923f, 0.02646283f, -0.13889259f, 0.10023949f, -0.11475161f, 0.03800795f, 
    -0.13640723f, -0.01059375f, -0.19374341f, 0.10078537f, -0.14837766f, -0.08889572f, -0.03374610f, 0.00193405f, 
    0.10112196f, 0.03233749f, -0.00420707f, -0.11979251f, -0.23735036f, 0.22009940f, 0.16496839f, 0.00127794f, 
    -0.09833437f, -0.05730359f, -0.09573498f, 0.04894166f, -0.10530443f, 0.11501233f, -0.00693241f, -0.05106660f, 
    -0.37446588f, 0.05480592f, 0.14420353f, -0.10791652f, 0.02285408f, -0.03234691f, -0.08908393f, -0.11915343f, 
    -0.01790940f, -0.03147500f, -0.02831644f, -0.09317516f, 0.00535326f, -0.09218663f, -0.02747407f, -0.15253860f, 
    0.00969099f, 0.02039677f, -0.03703983f, -0.03711541f, -0.08555495f, 0.03124327f, -0.03234756f, 0.08215453f, 
    -0.34592527f, -0.01371589f, -0.06353404f, -0.04979438f, -0.11306300f, -0.05525451f, 0.06631123f, 0.05552652f, 
    -0.10407460f, -0.01915611f, 0.02046847f, -0.07866950f, 0.18003394f, -0.17027710f, -0.03599125f, 0.02144840f, 
    0.11878739f, -0.04192797f, -0.04542931f, -0.07227341f, 0.06825563f, -0.06587006f, -0.00461219f, -0.07688299f, 
    -0.32962304f, 0.11991569f, -0.05386350f, -0.38296083f, 0.01422750f, -0.00210461f, -0.10805382f, -0.02539528f, 
    -0.01893672f, 0.04139339f, -0.03421152f, -0.01047456f, 0.37476423f, -0.08476233f, 0.23019892f, 0.22947043f, 
    0.23568781f, -0.04794199f, 0.04270802f, -0.03462101f, -0.04096361f, -0.04994602f, -0.00240933f, -0.11112961f, 
    -0.00276307f, 0.10372094f, 0.03204154f, -0.06164188f, -0.09017799f, -0.02862898f, 0.06612723f, 0.01313807f, 
    0.06133915f, -0.14058280f, -0.02479729f, -0.06569155f, -0.08512186f, 0.23097062f, -0.06232210f, -0.02783293f, 
    -0.03960283f, -0.03159611f, 0.04883228f, 0.01107120f, 0.10405154f, 0.09545777f, 0.05336183f, -0.01028297f, 
    -0.30861974f, -0.18080264f, -0.22502956f, -0.01819125f, -0.08528651f, -0.11061342f, -0.04358296f, -0.04677239f, 
    0.03747144f, -0.17024291f, 0.05333956f, -0.03481207f, -0.04650307f, -0.08642557f, -0.14777932f, -0.26723960f, 
    0.02581257f, 0.05574067f, 0.05058661f, -0.12052342f, 0.09527493f, 0.03084903f, -0.04489570f, -0.00909373f, 
    -0.32118550f, -0.10156040f, -0.11520268f, 0.13476706f, -0.06934208f, -0.16561092f, -0.12345777f, -0.01464205f, 
    -0.13726203f, 0.05506620f, 0.04092148f, -0.10217783f, -0.21309632f, -0.00250092f, 0.04684692f, -0.09871630f, 
    -0.06132350f, 0.02055794f, -0.03669133f, -0.02323205f, -0.03635099f, 0.04099624f, -0.11971528f, -0.15626489f, 
    0.21313076f, 0.15261732f, 0.24029011f, 0.20464361f, 0.11055244f, 0.07848466f, 0.08801194f, -0.11772348f, 
    -0.04008992f, 0.09548736f, -0.11148404f, -0.11649366f, 0.17256603f, 0.13569061f, 0.25716251f, 0.18626899f, 
    0.09330193f, 0.03635660f, -0.08559196f, -0.02369665f, -0.10515494f, 0.04289706f, -0.08555077f, -0.08568855f, 
    -0.14746453f, 0.20390831f, 0.27276298f, 0.17193542f, 0.26712969f, 0.22563863f, 0.05492628f, -0.07341450f, 
    -0.00890411f, -0.02457281f, -0.12594539f, 0.06957729f, 0.20186962f, -0.19436297f, -0.14591683f, -0.27812055f, 
    -0.14811033f, 0.03341731f, 0.05013983f, -0.00851072f, -0.01151355f, 0.01442593f, -0.07138765f, -0.02316770f, 
    -0.02486633f, 0.22152047f, 0.09752932f, 0.26855257f, 0.09182893f, -0.12924437f, -0.08748219f, -0.00157802f, 
    -0.17602809f, -0.06839686f, -0.08816100f, -0.12951390f, -0.27326846f, 0.16953342f, -0.32249179f, -0.02596880f, 
    0.01497664f, 0.04419443f, -0.03159007f, -0.15578976f, -0.15218568f, -0.08343818f, -0.10471646f, -0.04672968f, 
    -0.01672900f, 0.30279815f, 0.07670273f, 0.29934648f, 0.13599935f, 0.01299067f, 0.00859031f, 0.08083097f, 
    0.10671417f, -0.03351252f, 0.09972116f, -0.00884305f, -0.44066328f, 0.03887297f, 0.11392281f, -0.09874000f, 
    -0.09133160f, -0.01219409f, 0.00631315f, -0.01882596f, -0.11048628f, -0.02568238f, -0.14054260f, -0.20891081f, 
    0.18225206f, -0.26934856f, 0.24149586f, -0.08006652f, 0.05043314f, 0.06149285f, 0.03198542f, 0.00810702f, 
    -0.03160865f, 0.07236343f, 0.00479324f, 0.00063070f, 0.03632782f, 0.27934048f, -0.14291273f, 0.06639312f, 
    -0.11508823f, 0.02291861f, -0.01928930f, -0.09886494f, 0.06156231f, 0.07006037f, -0.00270596f, -0.01899995f, 
    -0.01697327f, -0.23610450f, 0.12103831f, -0.04043592f, 0.03740205f, -0.10414750f, -0.04536603f, -0.00067008f, 
    -0.05661768f, -0.09407485f, -0.03620341f, 0.03109156f, -0.24509971f, 0.15493533f, -0.25352648f, 0.02313559f, 
    0.02306512f, -0.01679088f, 0.04962723f, -0.03317750f, -0.05672858f, -0.04927586f, 0.03451335f, 0.05910112f, 
    0.04627870f, -0.08064070f, 0.01337067f, 0.21977931f, -0.03489949f, 0.00693566f, -0.01009714f, 0.00531463f, 
    0.00525819f, -0.00501062f, -0.00692101f, -0.07882752f, 0.40546659f, -0.47023460f, 0.24233426f, 0.32896376f, 
    -0.03160893f, -0.08962594f, -0.06636811f, -0.09754920f, -0.06355236f, -0.00852919f, -0.15864599f, -0.07918300f, 
    0.34267464f, -0.18946460f, -0.33495668f, 0.01581229f, -0.05867699f, 0.02958165f, 0.02016221f, -0.04704374f, 
    0.02123365f, 0.07825299f, -0.15092905f, 0.04205105f, 0.01724741f, 0.00706912f, 0.07557092f, -0.01192994f, 
    -0.17852867f, 0.10473911f, -0.08423704f, 0.09605621f, 0.05862630f, -0.08192698f, -0.10890348f, -0.10182258f, 
    0.01839828f, -0.12047341f, -0.01258799f, 0.13575484f, -0.12776531f, -0.17090014f, -0.22723517f, -0.04000736f, 
    0.13091382f, 0.01015942f, -0.12717243f, -0.08180627f, -0.01112080f, 0.04513285f, -0.15380269f, 0.03457370f, 
    0.04918609f, -0.14846033f, -0.29542196f, -0.05339073f, 0.10450199f, 0.05519136f, 0.08176284f, -0.29125792f, 
    -0.22026259f, -0.26906380f, -0.17876972f, -0.20009539f, -0.15640783f, -0.20345691f, 0.02256124f, -0.12388931f, 
    0.02214642f, 0.13493559f, 0.09485818f, -0.02796904f, 0.21215275f, -0.32672617f, 0.28581238f, 0.16702786f, 
    -0.19515717f, -0.07891738f, -0.06250060f, -0.08391737f, -0.10169831f, -0.11234910f, -0.18316333f, -0.14069667f, 
    -0.58980411f, 0.06541115f, 0.17210484f, 0.01337519f, -0.18669851f, -0.05136355f, 0.02098533f, 0.05266089f, 
    0.05366380f, -0.03880113f, 0.09002373f, 0.16347516f, 0.08714741f, -0.24665530f, -0.01786691f, -0.00396785f, 
    0.09248721f, 0.03966536f, -0.02529031f, 0.06619087f, -0.02487770f, 0.14724244f, 0.15443394f, -0.08135986f, 
    0.12025741f, 0.07183526f, -0.23253267f, 0.08892069f, 0.06097680f, 0.03160432f, -0.08855996f, -0.07930233f, 
    -0.08733091f, -0.12296663f, 0.17926356f, -0.03576484f, 0.36405313f, -0.27973419f, -0.02234821f, -0.09892378f, 
    0.03640603f, -0.08760149f, 0.00382518f, 0.16130041f, 0.10921051f, 0.07946996f, 0.02324144f, 0.14166322f, 
    -0.02463101f, -0.12606741f, 0.15645036f, 0.25241148f, 0.03843682f, -0.03847538f, -0.08010416f, -0.03355183f, 
    0.13393664f, -0.04652610f, -0.25489542f, 0.00665154f, 0.08309373f, -0.23664449f, -0.22109379f, -0.33709860f, 
    -0.00318969f, 0.15236029f, -0.02764503f, -0.06263887f, 0.03872759f, 0.01803218f, -0.03041154f, 0.03887258f, 
    0.20582674f, -0.14477266f, 0.09370261f, 0.15368962f, 0.06390735f, -0.01814347f, 0.06293874f, -0.08990189f, 
    -0.04585951f, 0.12975171f, 0.11209643f, -0.03131694f, 0.20403485f, 0.40072498f, -0.15789337f, 0.11275976f, 
    -0.16233405f, 0.02208843f, -0.22996789f, -0.01890480f, 0.09501332f, 0.00420597f, -0.14046039f, 0.11496301f, 
    0.15578720f, 0.16137718f, -0.19834179f, 0.09257341f, 0.09717130f, 0.16732188f, 0.06616237f, 0.04842632f, 
    -0.03557896f, -0.10065172f, -0.20431112f, 0.09982305f, 0.22225276f, -0.26986128f, -0.09140566f, 0.03847551f, 
    0.15887159f, 0.00924955f, 0.01190286f, -0.08447678f, -0.06156752f, -0.02894530f, -0.01605938f, -0.00123494f, 
    -0.28049949f, -0.13529600f, -0.32766014f, 0.01602534f, 0.17811266f, 0.13432063f, 0.05607117f, 0.09384858f, 
    0.08803441f, 0.07249547f, 0.12904714f, -0.17154440f, 0.21507064f, 0.15792055f, 0.08057418f, 0.15401915f, 
    -0.09657899f, -0.09828760f, 0.04141437f, 0.06362519f, -0.03210389f, 0.01623169f, 0.04130749f, -0.08243266f, 
    -0.34181103f, 0.05860820f, 0.26617321f, 0.04819680f, -0.23764488f, 0.04922365f, -0.08831649f, -0.32131255f, 
    -0.04900011f, -0.14490290f, -0.05830494f, 0.10391257f, -0.22924341f, -0.14540890f, 0.00995719f, -0.19909444f, 
    0.08976243f, -0.11280249f, 0.24419644f, -0.21897918f, 0.01088781f, -0.04038944f, 0.04442534f, 0.03028306f, 
    -0.22720078f, -0.04147007f, 0.38000891f, 0.11887888f, -0.00438401f, -0.07196649f, -0.17847456f, -0.11778004f, 
    -0.00953848f, -0.15332088f, 0.12131985f, -0.02466531f, 0.08387082f, -0.21912205f, -0.03548566f, 0.05667816f, 
    0.18202107f, -0.00924999f, 0.12709211f, -0.05445756f, 0.07743084f, -0.07128303f, 0.05242511f, -0.17440234f, 
    -0.23672678f, 0.28559718f, -0.11729214f, -0.28636724f, 0.10118505f, -0.34374854f, 0.14455675f, 0.04335776f, 
    0.00273995f, -0.07705814f, 0.09569095f, -0.11101126f, -0.15804669f, -0.10907455f, 0.26722345f, 0.24095492f, 
    0.07690070f, -0.06347242f, -0.08092736f, -0.06526186f, 0.04527992f, -0.09956789f, 0.01811750f, -0.11901660f, 
    0.07454393f, 0.30965665f, -0.19033945f, -0.07014627f, -0.19775298f, 0.06153011f, 0.10446496f, 0.03624901f, 
    -0.21567234f, 0.05723664f, -0.21049030f, -0.15122096f, 0.07186714f, -0.11946674f, -0.09502129f, 0.21028732f, 
    0.15779883f, -0.04252740f, -0.07567914f, -0.11926437f, -0.04288112f, -0.07052296f, 0.15525798f, -0.01365055f, 
    -0.25313348f, -0.20036353f, 0.18279895f, -0.11300424f, -0.08019626f, -0.10695757f, 0.06457537f, -0.12405283f, 
    -0.00689919f, 0.11481801f, -0.16454330f, 0.07580049f, -0.00845978f, 0.17642295f, 0.14516170f, -0.13237077f, 
    0.06277338f, -0.06066447f, -0.01021420f, 0.03900176f, 0.09747981f, 0.17964312f, 0.04477920f, 0.11703879f, 
    0.25050557f, 0.28314739f, -0.15168858f, 0.13276507f, -0.06266546f, 0.09485117f, -0.13881497f, -0.09070746f, 
    -0.06284441f, -0.00679365f, 0.05394659f, -0.07688040f, -0.06049052f, -0.03508115f, -0.17970641f, 0.16264589f, 
    0.14837541f, -0.00641397f, -0.00078297f, -0.01389360f, 0.14108577f, -0.00423357f, -0.00143275f, 0.04870993f, 
    -0.24379151f, 0.16166024f, -0.50181597f, -0.31917262f, -0.16783239f, 0.03569272f, -0.15563153f, -0.05304147f, 
    0.10507424f, 0.04456204f, -0.09008992f, -0.11552069f, 0.18053766f, -0.02515354f, 0.05714715f, 0.06431447f, 
    -0.00720145f, -0.07652016f, -0.14400600f, -0.09458998f, -0.05733877f, -0.00280528f, 0.12638398f, -0.20340072f, 
    -0.12235821f, -0.01870519f, -0.10901023f, 0.05122936f, 0.03350869f, -0.09269350f, -0.08245564f, -0.08636418f, 
    0.12173280f, -0.07285678f, -0.00480701f, 0.20208260f, 0.22542830f, 0.09602498f, 0.05354496f, 0.01374581f, 
    -0.01608129f, 0.06429277f, -0.08001366f, 0.18509339f, 0.13304026f, 0.03506655f, 0.11655948f, -0.28734496f, 
    -0.37461472f, 0.60392940f, -0.16171211f, 0.06476695f, -0.06673177f, -0.13661490f, -0.02191707f, 0.02386744f, 
    -0.02549069f, 0.06157898f, 0.12718843f, 0.08565652f, -0.10615426f, -0.08970498f, 0.05518287f, -0.00224094f, 
    -0.05649246f, 0.19152401f, 0.02918238f, 0.10556965f, -0.08372191f, 0.00529991f, 0.04239621f, 0.06488975f, 
    0.03185743f, 0.33406180f, -0.28732201f, -0.40263531f, 0.05555242f, 0.00944491f, -0.00052708f, 0.04847679f, 
    -0.06724741f, 0.18444248f, -0.23774618f, -0.03204895f, -0.00621424f, 0.03868993f, 0.01881059f, 0.11495607f, 
    0.19387574f, -0.00803801f, 0.00194351f, -0.03430639f, 0.08697890f, 0.16814287f, 0.01849488f, 0.01487278f, 
    -0.04510965f, -0.07621283f, 0.12845427f, 0.04834617f, 0.22542544f, 0.09956470f, -0.13045837f, -0.05716947f, 
    -0.01825993f, 0.15024291f, 0.02005218f, -0.19977227f, 0.06133612f, -0.11784837f, -0.21972628f, 0.21905950f, 
    0.02683566f, 0.01918302f, 0.07720431f, -0.00206869f, -0.18237516f, -0.15343449f, 0.09582320f, -0.24561691f, 
    -0.03172721f, 0.01911594f, 0.21571554f, -0.21881807f, 0.08750607f, -0.03441399f, -0.13581763f, -0.15219364f, 
    0.03597898f, 0.04207185f, -0.04276727f, -0.12313250f, 0.16756488f, -0.12157095f, 0.15293981f, -0.21853659f, 
    0.03553354f, 0.02086105f, 0.02478149f, -0.09897602f, -0.02451531f, -0.05376772f, 0.02297690f, -0.09277539f, 
    -0.14598995f, 0.19928820f, -0.13330050f, -0.29776689f, 0.05150485f, 0.11341079f, -0.01083786f, -0.09630220f, 
    -0.05261901f, -0.18507230f, 0.07785214f, -0.08467177f, -0.02166689f, -0.38628569f, 0.08268806f, 0.16906935f, 
    0.11822084f, -0.01798234f, 0.08532993f, 0.07887045f, -0.07429342f, -0.09349360f, 0.02231860f, 0.11745521f, 
    -0.33030900f, 0.02369139f, 0.01182511f, -0.26371905f, 0.19796552f, -0.04303505f, 0.10830662f, 0.03198035f, 
    0.03065814f, -0.08249304f, -0.06816468f, 0.00175253f, -0.35632482f, 0.44688329f, 0.24025558f, 0.05085090f, 
    0.09514216f, 0.11071720f, 0.08678621f, 0.16351126f, 0.11875325f, 0.01349661f, 0.14985031f, 0.07756036f, 
    -0.01538343f, 0.16712892f, -0.03610962f, -0.05084383f, 0.01551687f, 0.05288548f, -0.07850759f, -0.13029318f, 
    -0.13887031f, -0.03332378f, 0.09384444f, -0.00642418f, -0.25516129f, 0.13196178f, 0.06529009f, 0.03830788f, 
    0.06610291f, 0.08581512f, 0.12202179f, -0.13932976f, 0.14934660f, 0.02629492f, -0.06883027f, 0.07272103f, 
    -0.16539924f, -0.06479675f, -0.01765277f, -0.56191796f, -0.04161875f, 0.08918058f, -0.20944600f, 0.12297434f, 
    -0.01749239f, 0.05548872f, -0.17501409f, -0.04259125f, -0.28067502f, 0.45096892f, -0.28432041f, 0.13384949f, 
    0.17444420f, -0.04248370f, 0.04034357f, -0.16956189f, -0.12471294f, -0.08461425f, 0.02453321f, -0.05706596f, 
    0.16634759f, -0.36552176f, -0.18732983f, 0.01013773f, -0.03597926f, -0.09055003f, 0.04995010f, 0.09961382f, 
    -0.06768902f, 0.10977209f, 0.02490078f, -0.19367331f, -0.11170082f, -0.15303773f, -0.22812320f, 0.14376253f, 
    -0.04313314f, 0.07646084f, -0.07235168f, -0.03432812f, 0.04089090f, -0.12823969f, 0.17290676f, -0.17010516f, 
    -0.00730538f, -0.63083309f, 0.01240970f, -0.03053785f, 0.08755416f, 0.10433159f, -0.13759528f, 0.12586150f, 
    0.04646884f, -0.01818762f, -0.10175282f, 0.16107370f, 0.13159914f, -0.06012499f, -0.22259080f, -0.11108834f, 
    0.07469937f, -0.07192620f, -0.12234726f, 0.11037239f, -0.07609981f, 0.07871438f, 0.06387214f, 0.19641493f, 
    -0.21043237f, -0.19301541f, 0.46593544f, -0.15262456f, 0.01236701f, 0.09238016f, -0.15623292f, -0.06201385f, 
    0.06636546f, -0.10754097f, -0.02094637f, 0.17251609f, -0.11907958f, 0.43275180f, -0.14312454f, -0.26383203f, 
    -0.04358731f, 0.04466531f, 0.01927188f, 0.02241131f, -0.09131274f, 0.00154574f, -0.08310162f, 0.10462785f, 
    -0.53831053f, -0.04136862f, 0.21727525f, 0.01745441f, 0.02163792f, -0.05471930f, -0.05439615f, 0.00177373f, 
    0.08342774f, -0.21161546f, 0.02842868f, 0.10592740f, -0.55370569f, 0.01012204f, -0.20876299f, -0.08944583f, 
    0.07114117f, -0.14658424f, 0.09784767f, 0.00536423f, 0.02625678f, 0.15017384f, -0.00451605f, -0.04852981f, 
    0.46732301f, 0.05134545f, -0.25923204f, 0.47942755f, -0.03235637f, -0.02187010f, -0.13882153f, 0.13428725f, 
    -0.03577058f, -0.15618211f, -0.06040167f, 0.01045977f, 0.15165631f, 0.18096021f, 0.36247668f, -0.02759595f, 
    -0.03456206f, 0.11228527f, 0.06362208f, -0.01676539f, 0.08562930f, -0.24757470f, -0.03705310f, -0.01498249f, 
    0.67168903f, -0.60243917f, -0.07368593f, -0.02724706f, 0.01637629f, -0.21426602f, 0.05299601f, 0.01496028f, 
    -0.08912582f, 0.11471479f, 0.05884964f, 0.09886172f, 0.07693829f, 0.14222565f, -0.07732145f, -0.57166362f, 
    0.05635459f, 0.02572383f, -0.15184215f, 0.05316558f, -0.22369792f, -0.12623942f, 0.10678666f, -0.10515557f, 
    -0.17099613f, 0.41223517f, -0.40663418f, 0.38698113f, -0.02194725f, 0.04835666f, 0.08795603f, 0.09656577f, 
    -0.15525223f, 0.11097623f, 0.07556199f, 0.03999223f, 0.31967220f, -0.60511374f, 0.07092717f, -0.11950187f, 
    0.04249373f, -0.01312315f, -0.01239559f, 0.00488821f, 0.00308343f, -0.08370651f, 0.11696435f, 0.13776334f, 
    -0.05819941f, 0.07153764f, -0.15693825f, -0.26883635f, 0.10314357f, -0.09048441f, 0.06361895f, -0.02329787f, 
    -0.06293479f, -0.08637748f, 0.01669995f, 0.08977380f, -0.35012478f, 0.00559641f, 0.04058429f, -0.00826440f, 
    0.07328205f, 0.10211495f, 0.05459497f, -0.11397796f, 0.28332010f, 0.04501769f, -0.23505232f, 0.02699858f, 
    -0.11764726f, 0.11433754f, -0.04841776f, 0.00201902f, 0.09594536f, -0.03098077f, -0.01937952f, 0.10491068f, 
    0.11887179f, -0.20713264f, -0.10842400f, -0.04724466f, -0.49377909f, -0.42664704f, -0.01328011f, 0.13372110f, 
    0.06267886f, 0.00651970f, -0.09504392f, 0.05115207f, 0.07570071f, -0.19781677f, 0.13403612f, 0.05164183f, 
    0.21012269f, 0.10919616f, -0.09088876f, -0.14953457f, -0.03339101f, -0.25233862f, 0.02704996f, 0.18573616f, 
    0.01038095f, 0.14994991f, 0.23381245f, 0.03825204f, 0.47057706f, 0.21711774f, -0.15835528f, -0.03904909f, 
    -0.24784701f, -0.02085926f, -0.00171820f, 0.24829686f, 0.11134127f, -0.04172003f, -0.13908343f, 0.06238886f, 
    0.24827521f, 0.27667791f, -0.11590337f, 0.20823866f, 0.18540373f, -0.09503476f, 0.04813340f, 0.15539399f, 
    0.01080065f, 0.15823026f, 0.03866448f, 0.18908751f, -0.21496175f, -0.23011385f, 0.02559096f, -0.01642667f, 
    -0.01944501f, 0.00524454f, -0.10773282f, 0.02294005f, 0.07208847f, 0.24682511f, 0.01403670f, -0.08592827f, 
    -0.79151207f, -0.56802189f, -0.03772097f, -0.21644822f, 0.14501698f, 0.00461072f, -0.18057877f, -0.15913506f, 
    0.08147974f, -0.10413409f, 0.06816357f, -0.05157995f, -0.32563782f, 0.22785538f, -0.03215417f, -0.00487732f, 
    0.09517954f, -0.15036246f, -0.05340458f, 0.09046141f, -0.01891830f, 0.07507690f, 0.04229152f, 0.20605868f, 
    -0.33878219f, -0.06420335f, -0.19421759f, -0.32048053f, 0.24420255f, -0.20430098f, -0.01913528f, -0.10265116f, 
    0.10587853f, -0.02418534f, 0.01110840f, 0.19582532f, -0.16067670f, 0.02910461f, -0.15530759f, 0.08120698f, 
    -0.01505065f, 0.18824981f, 0.17197433f, 0.00353052f, 0.10707458f, 0.00525834f, 0.06623533f, -0.16084008f, 
    -0.10973328f, -0.17662667f, 0.00472504f, -0.03054834f, -0.10385805f, 0.11256392f, 0.06171615f, 0.07587165f, 
    0.05417372f, 0.10669778f, 0.03043152f, 0.15428463f, -0.23599692f, -0.21415606f, -0.09453077f, -0.15762657f, 
    -0.06383442f, -0.10211492f, -0.00805910f, -0.26842463f, -0.03894806f, -0.29683831f, -0.21719167f, -0.05934700f, 
    -0.65008110f, -0.11288952f, -0.01749990f, -0.08798595f, 0.08951171f, -0.03666043f, 0.02827936f, 0.08300715f, 
    0.10369314f, 0.10757302f, 0.10470421f, 0.22040305f, -0.09651399f, -0.21969517f, -0.15814626f, -0.29140446f, 
    -0.06617070f, 0.14368384f, 0.05696331f, 0.03113165f, 0.05101532f, -0.09957594f, -0.15996112f, -0.05929144f, 
    0.19784500f, 0.21111724f, 0.05554548f, -0.14717267f, 0.21382970f, -0.04340884f, 0.12619020f, 0.09914242f, 
    0.02760286f, 0.04409207f, 0.08538155f, -0.04117447f, 0.16058826f, -0.12992281f, -0.07343289f, 0.09528638f, 
    -0.06041403f, -0.12158468f, 0.03028517f, 0.13087346f, -0.05216816f, 0.15774262f, 0.01727869f, 0.03334916f, 
    0.13596863f, 0.06558236f, 0.09475693f, -0.07366145f, -0.15799537f, 0.04989906f, 0.02291744f, 0.01981927f, 
    0.07668033f, -0.06976382f, 0.04024575f, 0.07520268f, 0.17393705f, 0.04372916f, -0.07990777f, 0.00659127f, 
    0.09138753f, 0.15215249f, 0.19027224f, -0.11605117f, 0.00902996f, -0.19074449f, -0.12455993f, 0.04386475f, 
    0.36647752f, 0.09292801f, -0.07396408f, 0.05614675f, -0.28791305f, -0.17867787f, -0.09639107f, -0.04112119f, 
    0.07685155f, -0.08481867f, 0.10137527f, -0.06155779f, -0.31129527f, -0.14625831f, -0.05789137f, 0.18097566f, 
    -0.02708255f, -0.10563738f, -0.01517178f, -0.02195197f, 0.06834617f, 0.00154379f, -0.16942708f, -0.07574618f, 
    0.24161585f, 0.11198282f, -0.01205354f, -0.03181444f, 0.08568244f, 0.19802316f, 0.00516579f, -0.11780800f, 
    0.09136086f, 0.13772100f, 0.14249261f, 0.01320717f, -0.45757040f, -0.49253273f, 0.15883641f, -0.05518473f, 
    0.17106314f, -0.00227752f, -0.03332819f, -0.11795363f, -0.02028889f, -0.09181181f, -0.03323457f, -0.03426849f, 
    0.24301973f, 0.03746210f, -0.12470009f, 0.07342511f, -0.11047879f, -0.02368796f, 0.05157405f, -0.00594660f, 
    0.15677203f, 0.12653042f, -0.06060060f, 0.02425186f, -0.69479489f, -0.65677381f, -0.27603668f, -0.26222986f, 
    0.12414894f, 0.07594614f, -0.15166177f, -0.15682636f, 0.07517236f, -0.05468126f, 0.08867581f, -0.08565106f, 
    0.34413296f, -0.09855940f, -0.02318167f, 0.11235730f, -0.04274895f, 0.01104090f, 0.06631961f, 0.04256207f, 
    -0.00291727f, 0.04654174f, -0.02990011f, 0.02889787f, -0.26646742f, -0.12750432f, 0.22909842f, -0.06526504f, 
    0.11450367f, 0.03045736f, -0.02838617f, -0.09368102f, 0.15185374f, 0.13238865f, -0.06678391f, 0.13743708f, 
    -0.29395452f, 0.09815013f, -0.24025752f, 0.06811365f, -0.06721686f, 0.24200812f, -0.36731711f, -0.00881261f, 
    0.13931969f, 0.15317759f, 0.01821203f, 0.07475290f, -0.51539135f, 0.11611838f, -0.14701186f, -0.33094329f, 
    0.16742602f, 0.09513439f, -0.09951734f, 0.01192406f, 0.02734480f, 0.17659605f, 0.03739588f, 0.10884240f, 
    -0.06560235f, -0.13944091f, 0.16077802f, 0.10182554f, 0.01992183f, 0.03086927f, -0.07791193f, 0.02497700f, 
    0.14055870f, -0.29300499f, -0.15011002f, -0.25876892f, -0.51259965f, 0.43913326f, -0.31278232f, -0.31337023f, 
    0.05911521f, 0.21390058f, -0.05548710f, -0.00668569f, 0.15559849f, 0.12242181f, 0.08294164f, 0.05063242f, 
    -0.27180713f, -0.16773449f, -0.08277733f, -0.16310184f, -0.08572360f, 0.04529118f, -0.04049968f, 0.06045604f, 
    -0.03780850f, -0.05198268f, 0.05576342f, 0.04100500f, 0.02712717f, 0.10217165f, -0.14929041f, 0.11789656f, 
    -0.01639338f, 0.01094834f, 0.02477234f, 0.10930531f, 0.06932843f, 0.09102073f, 0.15151726f, -0.06472568f, 
    0.12426581f, -0.01564595f, 0.24794318f, 0.33315143f, -0.17784666f, 0.06015881f, -0.01036166f, 0.00728057f, 
    0.07910698f, 0.13931766f, 0.09189267f, 0.21235649f, -0.15885609f, 0.35596249f, -0.22404447f, 0.12393244f, 
    0.23465760f, 0.03402837f, 0.03762850f, -0.03679854f, 0.15927042f, 0.08798216f, 0.01828958f, 0.13670866f, 
    0.09558922f, -0.05310493f, -0.14219569f, 0.31424725f, -0.02141926f, -0.01163941f, 0.11135456f, 0.09678924f, 
    -0.09083198f, -0.08120716f, -0.16903169f, 0.01847167f, -0.22015455f, -0.11523268f, 0.16959321f, -0.07471574f, 
    0.19924809f, -0.08113039f, 0.04099994f, 0.09840850f, -0.10975565f, -0.08749752f, 0.03751679f, 0.02239581f, 
    0.16418289f, -0.03197911f, 0.02413006f, 0.23141012f, -0.11902814f, -0.09326215f, -0.04605934f, 0.03783203f, 
    0.10400485f, -0.06643929f, -0.11827447f, -0.16861713f, -0.27906638f, 0.38954225f, -0.04650372f, 0.11505435f, 
    0.10589302f, 0.10214707f, 0.06624482f, 0.06676361f, 0.08006629f, -0.12598962f, -0.18778098f, 0.03584939f, 
    0.45130178f, -0.32607564f, -0.17572798f, -0.13859200f, -0.03526831f, -0.14651342f, -0.03784175f, -0.11502482f, 
    0.06900592f, 0.05851417f, -0.04881380f, 0.11354327f, 0.35173294f, 0.05588843f, -0.08268967f, 0.20355739f, 
    -0.20696612f, 0.17893682f, -0.05134455f, 0.13802232f, 0.00470895f, -0.16596840f, -0.10568191f, -0.02256125f, 
    0.24226265f, -0.29671603f, -0.01912243f, -0.37479666f, -0.20097654f, -0.06320033f, -0.09833092f, -0.03327413f, 
    -0.10829352f, 0.10537229f, 0.00195729f, -0.25980574f, 0.03516790f, -0.09415790f, 0.03495201f, 0.19167641f, 
    -0.30976430f, -0.12714429f, -0.03171930f, -0.01083844f, -0.06587017f, 0.06287743f, 0.17751692f, 0.04321161f, 
    -0.36516255f, -0.24526130f, 0.05745270f, -0.10540277f, 0.04204232f, -0.02906953f, -0.03001946f, 0.22770934f, 
    0.12734188f, -0.15642232f, -0.13686550f, -0.09299262f, -0.18729427f, -0.31189364f, -0.03065496f, -0.21630846f, 
    0.03875602f, 0.04782606f, 0.24315892f, 0.01111450f, -0.08042493f, 0.17123282f, 0.11079157f, -0.17997451f, 
    0.65302646f, -0.14472218f, -0.17110650f, -0.06346343f, 0.04569790f, -0.05704250f, 0.00196982f, 0.00015902f, 
    0.04208160f, -0.04827074f, -0.06306983f, 0.01441330f, -0.39600238f, 0.01047967f, -0.12403230f, -0.28921777f, 
    0.09251429f, 0.03244110f, -0.09252181f, 0.10872626f, 0.08880833f, -0.10317798f, 0.04287610f, 0.05553376f, 
    0.41676474f, -0.02823973f, -0.39415565f, 0.08345428f, 0.02231432f, -0.02431174f, 0.11794289f, 0.07971384f, 
    0.13885862f, -0.03585975f, 0.08556560f, -0.00778989f, -0.14760196f, -0.43855080f, 0.15301615f, 0.00139037f, 
    -0.06352757f, 0.09957933f, 0.10548279f, -0.01302540f, -0.09063504f, -0.14652644f, -0.13823444f, 0.04826293f, 
    -0.12788278f, 0.22008006f, -0.07063246f, 0.05120578f, -0.01504610f, -0.07881665f, -0.01600008f, -0.00767129f, 
    0.00433580f, 0.06907171f, -0.03107452f, -0.23334572f, -0.06210669f, 0.09733576f, -0.01158770f, -0.12521976f, 
    0.12143898f, -0.14699008f, -0.01388501f, 0.07390527f, -0.07630691f, -0.02705869f, -0.11900851f, -0.09947528f, 
    0.25074956f, 0.15522730f, -0.14376710f, 0.09948348f, 0.06312423f, 0.07713462f, 0.05545488f, -0.15883586f, 
    -0.02798753f, -0.00089911f, -0.14111632f, -0.01684511f, -0.25120941f, -0.03857932f, -0.01581304f, -0.18929458f, 
    0.02088580f, 0.06617689f, -0.05307693f, -0.00305189f, 0.06113182f, 0.16423132f, -0.01926977f, -0.07018972f, 
    0.15969828f, -0.24778777f, -0.31052673f, 0.09158219f, -0.10963759f, 0.06661281f, -0.02195784f, -0.11562923f, 
    -0.03627256f, -0.06793857f, -0.19737528f, 0.00064247f, 0.20595500f, -0.07331037f, -0.09754384f, -0.48971108f, 
    0.08126988f, 0.06423826f, -0.09518230f, 0.14535059f, 0.02952620f, -0.05715317f, 0.10669461f, 0.25132409f, 
    0.20477161f, -0.32252702f, -0.12456460f, 0.28458652f, -0.10475907f, 0.10139780f, -0.21716587f, -0.02414096f, 
    -0.15335907f, 0.09539722f, 0.01560279f, -0.08359386f, 0.22033305f, -0.04348461f, -0.20771258f, -0.24625741f, 
    0.07136551f, -0.08774833f, -0.02535244f, -0.10572034f, -0.04225994f, 0.10563851f, -0.01813848f, 0.04703606f, 
    -0.02854177f, 0.14812770f, 0.33678511f, -0.13334720f, 0.01022117f, -0.06191475f, -0.14668187f, -0.12066717f, 
    -0.01678729f, -0.00653233f, 0.15022168f, 0.06642213f, -0.19642420f, 0.16289441f, 0.09869955f, -0.10138585f, 
    0.21151789f, -0.01395232f, -0.28425148f, 0.08848333f, -0.12138204f, 0.04411139f, 0.07059046f, -0.16023637f, 
    -0.19628996f, 0.14807290f, -0.13816299f, -0.03179014f, 0.04953159f, -0.09059480f, 0.03662300f, 0.18652835f, 
    -0.21258871f, -0.13970304f, 0.03155716f, -0.10315077f, 0.48151711f, -0.16168429f, -0.31259805f, 0.42308837f, 
    -0.12555502f, 0.02935759f, -0.01755059f, -0.05865752f, 0.06592404f, -0.02123033f, 0.02307413f, -0.10332573f, 
    -0.28172505f, 0.08783495f, -0.34810963f, 0.26541939f, -0.07056886f, -0.07530126f, 0.06488232f, -0.22652312f, 
    -0.05791380f, 0.11945533f, 0.06513160f, 0.02031100f, -0.63190669f, 0.11101636f, 0.25109965f, 0.18121818f, 
    -0.01821471f, 0.04223307f, 0.01274509f, 0.10197396f, -0.04520340f, 0.03918855f, 0.14220066f, 0.05625933f, 
    -0.41242570f, 0.18176016f, -0.42715371f, 0.02376933f, 0.13442677f, 0.00409508f, 0.00834102f, 0.05329067f, 
    -0.03436991f, -0.02971954f, -0.07661964f, -0.09345485f, -0.22187172f, -0.03251797f, 0.02593946f, 0.02335454f, 
    0.04321503f, -0.00132237f, 0.08765187f, 0.06332394f, 0.02417752f, -0.11195669f, -0.12926930f, 0.03279693f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13365196f, 0.07116140f, -0.09683204f, -0.07332262f, -0.00040742f, -0.00871581f, 0.01750300f, -0.08322071f, 
    -0.02564131f, 0.02214514f, 0.12025027f, 0.07435257f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
