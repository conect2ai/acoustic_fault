#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.44305173f, -0.16901384f, 0.23176515f, 0.41590127f, 0.71383858f, 0.64351350f, -0.55874521f, 0.44803533f, 
    -0.74693048f, -0.32034621f, 0.02704795f, 1.12021542f, 0.41621020f, -0.42679298f, 0.09751927f, -0.35722968f, 
    -0.24726932f, -0.25497052f, 0.36015502f, 0.80543691f, 0.72393113f, 0.03168816f, -0.60843831f, 0.05582531f, 
    0.16424289f, -0.53498119f, 0.27458516f, -0.18556294f, -0.04115898f, -1.31741011f, -0.21703945f, -0.03459137f, 
    0.09131014f, -0.36332664f, -0.44389585f, -0.29756397f, 1.02390802f, -0.86559403f, 0.33598864f, -0.52401096f, 
    0.05555268f, 0.39568955f, 0.02513396f, 0.22294056f, 0.16235800f, 0.26362202f, -0.28889439f, 0.19922833f, 
    0.30592862f, -0.09132724f, -0.38274270f, -0.43612894f, -0.76199454f, -0.39128757f, -0.55033565f, -0.78741759f, 
    -0.51493126f, -0.67079252f, -0.36940569f, 0.67866105f, 0.53087950f, -0.05048661f, 0.73739874f, 0.55972850f, 
    -0.19950607f, -0.30584005f, -0.33188379f, -0.07472856f, -0.15007520f, 0.74075168f, 0.72312295f, 0.70058066f, 
    0.16105933f, -0.04963406f, -0.27683416f, -0.10114691f, -0.02041952f, 0.29021296f, 0.83220208f, -0.68947852f, 
    -0.20975313f, -1.07417452f, -0.48739165f, -0.12322763f, 0.97553235f, 0.29343900f, -0.81642735f, 0.04293407f, 
    -0.26981720f, -0.28745818f, 0.40002882f, -0.85880601f, -0.37447220f, -0.95878351f, -0.72040159f, -0.71154517f, 
    0.53818721f, -0.52715868f, -0.14953665f, -0.22148459f, -0.05478317f, -0.11561488f, 1.40442753f, -0.63567144f, 
    0.04227298f, -0.28327900f, 0.01727283f, -0.32667294f, -0.97345740f, -0.95133185f, -0.15657400f, -0.09484580f, 
    0.02279802f, 0.05870446f, -0.09801651f, 0.40315068f, -0.33312580f, -0.78151917f, -0.12007245f, 0.34509933f, 
    -1.04352427f, 1.00921273f, -0.88534647f, -0.17868111f, 0.09020045f, 0.11820397f, -0.92924994f, 1.30144906f, 
    -0.62472266f, -0.01979234f, -0.09127261f, 0.56570005f, 0.02907251f, -0.06098339f, 0.19510537f, 0.83278936f, 
    0.29345086f, 0.45416698f, 0.34155968f, 0.13679662f, 0.51392430f, -0.07337455f, 0.59313077f, -0.18356264f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03498936f, 0.10550319f, 0.17605396f, 0.20754635f, 0.66809988f, 0.35123926f, 0.12161950f, 0.19540833f, 
    0.68693054f, -0.18883789f, 0.05303419f, -0.12162751f, 0.53848088f, 0.23127769f, 0.14532901f, 0.38540646f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.11059239f, 0.03146768f, -0.10894515f, 0.03361931f, 0.00968174f, -0.01577543f, -0.02330775f, 0.23341864f, 
    0.12652177f, -0.40681741f, 0.01554019f, -0.27145290f, -0.01155982f, 0.09533209f, 0.19693995f, 0.06562277f, 
    -0.11553270f, -0.14623868f, 0.11141154f, -0.20468619f, 0.09830266f, -0.13681504f, 0.08783414f, -0.05652477f, 
    -0.10878976f, 0.07112997f, -0.04210060f, 0.01991032f, 0.15803045f, 0.17883770f, -0.09967597f, 0.14293332f, 
    -0.04167477f, 0.11082014f, 0.14154148f, 0.16074274f, 0.37111637f, 0.29042605f, -0.32335562f, 0.11596162f, 
    0.04600769f, 0.21777560f, 0.11554366f, 0.20637545f, 0.00214469f, -0.00579401f, 0.10693395f, -0.27529484f, 
    0.05530148f, 0.06809781f, 0.11608689f, 0.06146509f, 0.25003812f, 0.08590319f, -0.41635945f, 0.49618307f, 
    0.27096817f, -0.27335495f, 0.09999636f, -0.18701304f, -0.02013486f, 0.00593922f, -0.00154975f, 0.00432737f, 
    0.13058728f, -0.25339940f, -0.13147613f, -0.12575716f, -0.10262854f, -0.03354044f, 0.24413718f, -0.23020761f, 
    0.05458216f, 0.29099786f, 0.35719565f, 0.17741351f, -0.07286152f, 0.05606849f, 0.29494798f, 0.25633198f, 
    0.09812170f, -0.49262547f, -0.31503287f, 0.47450832f, -0.15997733f, 0.15234423f, -0.30335581f, -0.11030288f, 
    -0.07153502f, 0.14987268f, -0.48787683f, -0.28967619f, -0.27020264f, 0.10286783f, -0.22702675f, -0.05067566f, 
    0.01718379f, -0.02800373f, 0.03413348f, -0.55279970f, -0.29400361f, 0.17441115f, 0.07364455f, 0.03673136f, 
    -0.13202022f, -0.07577429f, 0.15751234f, -0.07989640f, -0.30361196f, 0.16289052f, 0.62093401f, -0.10313792f, 
    0.24874540f, -0.06279205f, -0.08306163f, 0.02733611f, 0.00381963f, -0.23960575f, -0.70663583f, -0.14355767f, 
    0.04474105f, 0.11422864f, -0.26590592f, -0.10293061f, -0.03886171f, -0.07960248f, 0.03000279f, -0.27182904f, 
    -0.07375045f, 0.14820930f, -0.16408083f, 0.03640595f, 0.18884124f, 0.04405955f, 0.08085261f, 0.17169122f, 
    -0.04649149f, -0.01461345f, -0.07835998f, -0.05986174f, 0.13398178f, 0.06201488f, -0.00310357f, 0.19746047f, 
    -0.34266222f, -0.41590136f, 0.25916126f, -0.01060122f, -0.23713207f, -0.02789388f, 0.03097864f, 0.02142447f, 
    0.07606395f, -0.30306214f, -0.87131780f, -0.61595619f, -0.12371962f, -0.00005377f, 0.06719915f, 0.16047235f, 
    -0.10165759f, -0.14947248f, 0.14861821f, -0.21919222f, -0.04154688f, 0.06303457f, -0.04541375f, -0.04924054f, 
    0.01639317f, -0.23038240f, -0.02774063f, -0.06481520f, 0.22363673f, -0.03044200f, 0.00837852f, 0.25290725f, 
    0.17675586f, 0.11193727f, 0.01973041f, -0.07006461f, -0.28310153f, 0.05851554f, -0.83997530f, -0.11228205f, 
    0.04098300f, 0.31766018f, 0.10272253f, -0.05992381f, 0.15776855f, 0.28546992f, 0.03468901f, 0.08131958f, 
    0.09055291f, -0.03150377f, 0.00458459f, 0.09462714f, -0.06699628f, -0.18556114f, 0.12505046f, 0.22307463f, 
    0.17918672f, -0.20588182f, 0.02416127f, 0.06475403f, 0.03014170f, 0.06459219f, 0.01931820f, 0.14135516f, 
    0.03237197f, -0.16285628f, -0.04897839f, 0.13724975f, 0.00403058f, -0.00694165f, 0.03906803f, -0.07270716f, 
    -0.01088358f, 0.08747017f, -0.28927225f, 0.07183975f, 0.09641070f, 0.09824794f, -0.11005551f, 0.17718862f, 
    0.09149280f, 0.53573728f, 0.09517462f, 0.07418587f, -0.03687626f, -0.11391430f, 0.16569322f, 0.23479563f, 
    0.10633142f, -0.06005310f, 0.29965428f, 0.63653010f, 0.04222083f, -0.00645020f, 0.00633890f, -0.06878161f, 
    -0.02080376f, -0.25292829f, 0.01208477f, -0.20432508f, 0.50410557f, -0.05493303f, -0.26582104f, -0.03933296f, 
    0.06004127f, 0.01893381f, -0.01990002f, 0.14289375f, 0.38152429f, 0.05483141f, 0.23422050f, -0.03582729f, 
    0.04283420f, 0.13828903f, -0.05826999f, 0.08614337f, -0.07423837f, 0.15739417f, -0.09624793f, 0.16643238f, 
    -0.17618524f, -0.00962417f, -0.02399282f, 0.13856097f, 0.13051978f, -0.09654979f, -1.09548652f, -0.05410225f, 
    -0.70866513f, -0.32091820f, -0.19007678f, 0.12448429f, 0.18767084f, 0.16431376f, -0.05802469f, 0.39920247f, 
    0.20011036f, -0.64890343f, 0.02662631f, 0.21527980f, 0.15695405f, 0.23350948f, 0.13436703f, -0.06491718f, 
    0.32104227f, 0.44351417f, 0.15924820f, 0.02822897f, -0.04468099f, -0.07677671f, -0.05928186f, -0.13786453f, 
    -0.01739772f, 0.15963422f, 0.02894622f, -0.13398144f, -0.17907076f, 0.12726358f, 0.15332894f, 0.14630789f, 
    0.01590778f, -0.00234918f, -0.02205152f, 0.14145006f, -0.35689583f, 0.02906038f, 0.08467087f, 0.12333092f, 
    0.04017748f, 0.02771931f, -0.02879033f, -0.11115588f, -0.07710554f, -0.12490325f, 0.02923135f, -0.11110640f, 
    -0.03157839f, -0.10398089f, 0.08423746f, 0.24739486f, -0.17533855f, 0.04407549f, -0.09470257f, 0.21471591f, 
    0.08484853f, 0.04816554f, 0.35217911f, 0.09847344f, -0.09047457f, 0.04698490f, -0.05599809f, 0.04610726f, 
    0.07991188f, 0.05842600f, 0.02637315f, 0.08757228f, 0.05774033f, 0.21779515f, -0.02749852f, 0.26709139f, 
    0.13195758f, -0.03871654f, 0.11000191f, 0.02642780f, -0.08249152f, 0.19593073f, -0.23136452f, 0.12832545f, 
    0.00202250f, 0.10767053f, 0.26945356f, -0.03554601f, 0.08126308f, 0.02376158f, -0.55084622f, -0.73599124f, 
    0.13233909f, -0.14788929f, 0.00732974f, -0.09655993f, 0.07845731f, 0.05540153f, 0.25080296f, 0.20334028f, 
    0.09624109f, -0.34607536f, -0.41971788f, -0.52459592f, -0.35164773f, 0.06633265f, -0.30271614f, 0.03770667f, 
    0.01961713f, 0.09396873f, 0.13968208f, 0.06518298f, -0.10994013f, 0.18926035f, 0.27694115f, -0.07244317f, 
    0.00783428f, -0.06176167f, 0.05804663f, 0.20821469f, -0.31719872f, 0.01230566f, -0.09140646f, 0.04282325f, 
    -0.15247120f, 0.19063053f, -0.06730834f, 0.17970057f, -0.20120306f, 0.28063110f, 0.02894331f, 0.07578956f, 
    -0.02625951f, -0.04188062f, -0.06913115f, 0.00724422f, 0.11448534f, -0.31688744f, 0.08500998f, -0.17462249f, 
    -0.12970698f, 0.09796228f, -0.18167029f, 0.04078793f, 0.00961800f, -0.12528427f, -0.38291401f, 0.20691939f, 
    -0.02173934f, -0.14626984f, -0.18654209f, 0.18472163f, 0.10982987f, -0.11124396f, -0.09990154f, -0.03206141f, 
    -0.22912918f, -0.13145539f, 0.15346010f, 0.09573124f, 0.17026784f, 0.25947094f, -0.09773877f, 0.15859197f, 
    -0.01052566f, -0.16691220f, 0.19517002f, 0.36056340f, 0.36889952f, 0.21254629f, -0.09692281f, -0.09745240f, 
    -0.19863904f, -0.26557770f, -0.26282787f, 0.17947720f, 0.04260878f, -0.05980861f, 0.04253752f, -0.02006161f, 
    -0.12419502f, -0.30034083f, -0.05558932f, -0.45757478f, -0.08977240f, 0.16550697f, 0.18796062f, 0.10270637f, 
    0.03962473f, -0.12511526f, -0.10722735f, 0.05466018f, 0.21364123f, 0.24251117f, 0.08099850f, -0.14711347f, 
    -0.03967807f, 0.06469397f, 0.01959996f, -0.02498578f, -0.14336568f, -0.28022897f, -0.18623462f, -0.01817796f, 
    -0.12255985f, -0.05165421f, -0.21327986f, 0.18460050f, -0.01558707f, 0.11258860f, -0.06332185f, -0.05624186f, 
    0.10429171f, -0.07960419f, 0.13845623f, -0.19446573f, -0.09458671f, -0.57673764f, 0.42420921f, 0.21177962f, 
    0.24193726f, 0.13254514f, -0.20163563f, 0.17488070f, 0.04530680f, 0.07520954f, 0.08271535f, -0.13643590f, 
    0.13999942f, -0.00063625f, -0.08498558f, 0.08915766f, 0.06801666f, 0.02266624f, 0.29524308f, 0.29561037f, 
    0.10378961f, -0.08258266f, -0.23803250f, -0.01818969f, -0.16364744f, -0.19505508f, -0.24632388f, 0.08231727f, 
    -0.05750843f, 0.46232924f, 0.35088474f, 0.00399210f, 0.13258226f, 0.01362104f, 0.00289294f, -0.15715624f, 
    0.09329131f, -0.18339770f, -0.00356412f, 0.28727174f, 0.08431391f, 0.12340701f, 0.05050696f, 0.20070486f, 
    0.05935652f, -0.10597841f, -0.26663601f, 0.12426381f, 0.40076199f, 0.15153252f, 0.00171674f, 0.02351313f, 
    -0.00299252f, -0.18733931f, 0.06876384f, 0.02644663f, 0.23127550f, 0.10406978f, -0.05447005f, 0.01501816f, 
    -0.05095398f, 0.12799996f, 0.00450383f, 0.09624513f, -0.00485216f, 0.26413628f, -0.00451001f, 0.29649681f, 
    0.10692108f, 0.02492594f, -0.04738975f, -0.02075455f, 0.16155791f, -0.04986610f, -0.00299117f, -0.02974050f, 
    0.46304092f, -0.11180610f, 0.01767008f, 0.09601141f, -0.10124356f, 0.15126731f, -0.06291243f, 0.06671419f, 
    -0.02677436f, -0.16650963f, 0.01283033f, 0.12931484f, 0.08615443f, -0.10689546f, -0.02702453f, -0.10945860f, 
    -0.08032955f, -0.17682420f, 0.26485744f, 0.20923302f, -0.14218006f, -0.08852884f, -0.00515560f, -0.05813941f, 
    -0.27379331f, -0.17856017f, -0.16152097f, 0.15400355f, 0.01451010f, -0.05604832f, 0.12863891f, -0.07140655f, 
    -0.19084252f, -0.26694369f, 0.06161757f, -0.09004534f, -0.04195084f, 0.00635534f, 0.01581281f, 0.17044906f, 
    -0.02972811f, 0.21396111f, 0.08824674f, -0.06582161f, 0.06989641f, 0.04998714f, -0.05814645f, -0.05201734f, 
    0.03434476f, -0.01061332f, -0.11929405f, -0.05043562f, 0.42822492f, -0.07445807f, 0.07501229f, 0.13516739f, 
    0.27240467f, 0.09092439f, -0.08813967f, 0.15493721f, 0.00164460f, 0.03921417f, 0.17030640f, -0.15798812f, 
    0.01413752f, 0.03170387f, 0.03943073f, -0.05857219f, 0.03326403f, -0.21086900f, -0.10708937f, -0.23804004f, 
    -0.06384500f, -0.25582266f, 0.08492812f, -0.11835511f, 0.06603886f, 0.01363229f, -0.02780143f, -0.09707212f, 
    -0.44107276f, -0.27354023f, 0.01304627f, 0.00269823f, -0.06184938f, 0.13855849f, 0.15656647f, 0.09882083f, 
    0.23528960f, 0.17735837f, -0.01012463f, 0.10406070f, 0.17074631f, 0.10522816f, 0.18678135f, -0.08397432f, 
    0.15856129f, -0.15168384f, 0.21472107f, 0.34309390f, 0.04893199f, -0.25926444f, -0.06395756f, 0.00179139f, 
    -0.11781602f, 0.07810911f, -0.17441382f, 0.07139666f, -0.18226035f, 0.01552901f, -0.03520168f, -0.02333092f, 
    0.13490123f, 0.19426860f, 0.03740209f, -0.22425997f, 0.06463956f, -0.30245337f, -0.05130885f, 0.01233000f, 
    0.01802715f, 0.02625017f, -0.33331639f, -0.16679257f, -0.24147345f, 0.01672640f, -0.27367762f, -0.01591015f, 
    0.14140195f, -0.01256469f, -0.13679734f, -0.08502146f, 0.15506427f, -0.04869065f, -0.28788218f, 0.35524017f, 
    -0.02421985f, 0.07878172f, 0.09918885f, 0.06037775f, 0.15128832f, 0.18532392f, -0.29392368f, 0.16153191f, 
    0.46484655f, 0.10901690f, 0.02729320f, -0.14879332f, 0.11228755f, 0.04116241f, 0.26138660f, -0.12956996f, 
    -0.03654551f, 0.22796457f, -0.16363142f, -0.22170389f, 0.02551499f, -0.05925152f, -0.05716510f, -0.01544615f, 
    0.11455788f, 0.08968262f, 0.21531765f, -0.04471264f, 0.08718413f, -0.17601810f, 0.06600302f, -0.44543874f, 
    -0.04734526f, -0.04925674f, 0.06110343f, 0.08338638f, -0.00551390f, 0.18724379f, -0.19354670f, 0.01460905f, 
    0.04596827f, 0.05799729f, -0.14258204f, 0.08226665f, 0.13228664f, 0.00813402f, 0.10231044f, 0.24666733f, 
    -0.00685639f, 0.10484276f, 0.00951992f, -0.27732259f, 0.11472180f, -0.62880611f, -0.01561848f, -0.16467512f, 
    0.02509033f, -0.21798949f, -0.01182004f, -0.01151899f, 0.60365069f, -0.17154987f, -0.13029896f, 0.00094998f, 
    -0.02362994f, 0.23679361f, 0.09738163f, 0.08421727f, 0.01270864f, -0.06363756f, -0.09859471f, -0.12339771f, 
    0.03888420f, -0.06922297f, 0.15977971f, -0.00413303f, -0.27332702f, 0.29374030f, 0.57719868f, -0.03792304f, 
    -0.21972758f, 0.09559970f, 0.01980251f, 0.17304361f, 0.03923935f, -0.03014568f, -0.05712694f, -0.05565088f, 
    -0.04018929f, 0.24096538f, 0.13211775f, -0.09688375f, 0.33759192f, 0.01570489f, -0.03598391f, 0.42309773f, 
    0.17996204f, -0.01895032f, 0.07305440f, -0.01317229f, 0.05861631f, -0.08132488f, -0.29460028f, 0.21003906f, 
    -0.09623131f, 0.11148629f, -0.40840387f, -0.16507953f, -0.01855847f, -0.15888153f, -0.37982073f, 0.12726828f, 
    -0.03939614f, -0.08494766f, -0.23030017f, 0.24281216f, -0.06601825f, -0.05598067f, 0.16174872f, 0.16521055f, 
    0.08454920f, 0.27335423f, -0.09086027f, -0.06716300f, -0.34976518f, 0.00271074f, 0.11824868f, -0.21529773f, 
    0.04528947f, 0.16438355f, -0.22369562f, 0.21384481f, 0.23423471f, -0.31415740f, -0.24235722f, -0.00165913f, 
    -0.06622931f, 0.02535569f, 0.01093319f, -0.08361454f, -0.00887932f, 0.09102559f, -0.00792371f, 0.09010226f, 
    -0.04214991f, 0.03062603f, -0.07140786f, 0.01723920f, -0.00310030f, -0.29420131f, 0.35561487f, -0.08697091f, 
    -0.07624535f, -0.03631398f, -0.17627724f, 0.16366741f, 0.52307844f, -0.41464531f, 0.11820713f, 0.11891697f, 
    0.18875012f, 0.32285956f, 0.04271805f, -0.01045615f, 0.18842097f, 0.05872300f, -0.13906376f, 0.08575708f, 
    0.04536480f, 0.00751854f, -0.10743732f, 0.03278293f, -0.00204907f, 0.05659091f, -0.09576855f, -0.00523212f, 
    0.01091828f, 0.06158249f, -0.08742526f, -0.12069841f, -0.07257975f, -0.06352726f, -0.01474171f, 0.04214556f, 
    0.02757495f, -0.10465463f, -0.07864320f, -0.06758051f, 0.02550404f, -0.00180730f, 0.02476398f, 0.02319528f, 
    -0.02517565f, -0.12362068f, 0.01721639f, -0.07781985f, -0.06806959f, -0.01220325f, -0.02916546f, 0.00379181f, 
    0.03439504f, -0.09889987f, -0.06543922f, -0.06183813f, 0.01597603f, -0.03080454f, -0.08901612f, -0.01848402f, 
    0.02543648f, -0.06732906f, 0.01791986f, -0.09459316f, 0.02977547f, 0.00446642f, 0.01916304f, -0.10504475f, 
    0.04353874f, -0.08891094f, -0.04199051f, -0.01702472f, -0.03560059f, 0.03455209f, -0.02906819f, -0.04679735f, 
    -0.07250026f, 0.01143126f, -0.02575928f, -0.05068015f, 0.03326680f, -0.02622908f, 0.03608965f, -0.02887831f, 
    0.05745234f, -0.01184347f, -0.08860905f, -0.14140673f, -0.12646775f, -0.06059270f, -0.01987432f, -0.00948310f, 
    -0.00381398f, -0.08563109f, -0.03653634f, -0.04393678f, -0.00902895f, -0.02295407f, -0.08684061f, -0.05002715f, 
    -0.07156405f, 0.01910564f, 0.04823813f, -0.06149917f, -0.05964915f, 0.03683037f, 0.01690359f, -0.03718856f, 
    -0.05212905f, -0.08777124f, -0.03862064f, -0.05773361f, -0.02432868f, -0.09501214f, -0.08425999f, 0.01095850f, 
    -0.06174548f, -0.05359313f, -0.03444898f, -0.11816031f, -0.01429860f, -0.05561569f, 0.04012201f, 0.00547824f, 
    -0.09368152f, -0.01941987f, -0.06730130f, -0.08433174f, -0.03388926f, 0.06328595f, -0.07082459f, -0.04640548f, 
    -0.01944485f, -0.02941870f, 0.05582141f, 0.03024599f, 0.01720623f, 0.03723897f, 0.04625767f, 0.01437245f, 
    -0.05670564f, -0.13197228f, 0.01193804f, 0.05475048f, -0.05106231f, -0.04483880f, 0.04954750f, 0.04660352f, 
    -0.03393035f, -0.07549160f, -0.00381601f, 0.03972590f, -0.03839851f, -0.11733744f, -0.06231988f, 0.00471756f, 
    -0.00756586f, -0.05073286f, -0.07704371f, -0.06968695f, -0.04490787f, 0.03694747f, -0.00865111f, -0.00425303f, 
    -0.28875884f, -0.37257114f, -0.42643818f, -0.04537608f, 0.06189796f, 0.10376473f, -0.03181500f, 0.20510846f, 
    -0.24755336f, -0.05529751f, -0.50343651f, 0.46238962f, -0.09725496f, -0.06715546f, -0.27107859f, -0.12747245f, 
    -0.08053050f, -0.01577873f, 0.08947230f, -0.32103562f, -0.07255066f, -0.00600594f, 0.14248522f, 0.01429445f, 
    -0.07433111f, -0.03108661f, 0.01220175f, -0.04121674f, 0.15453826f, 0.00824977f, 0.00405465f, 0.12388735f, 
    0.16573191f, -0.20834349f, -0.01776325f, -0.08759622f, 0.74581349f, -0.06883673f, -0.01022654f, 0.31435150f, 
    0.05319533f, 0.06386504f, 0.12343057f, 0.08852234f, 0.08042102f, 0.22324015f, 0.23529130f, 0.23150989f, 
    -0.04721648f, 0.00136165f, -0.00700414f, 0.01534143f, -0.13222550f, -0.30274287f, 0.14649250f, -0.16781721f, 
    0.31995270f, -0.17148344f, -0.13471106f, 0.02356777f, 0.25371820f, 0.03447113f, -0.01186423f, -0.01900477f, 
    -0.00590170f, 0.06300615f, -0.01289011f, 0.07482725f, 0.11210191f, -0.06678420f, 0.24703254f, 0.14308392f, 
    0.25911278f, 0.16106316f, -0.02475889f, 0.06888594f, 0.07204116f, 0.00351814f, 0.24454299f, 0.00192173f, 
    -0.01031240f, -0.94333798f, -0.31922162f, 0.22434178f, -0.22386424f, 0.03124577f, -0.04689655f, 0.26958102f, 
    -0.12227643f, 0.05943573f, 0.09522343f, 0.04071089f, 0.07438411f, -0.01002735f, 0.07958612f, 0.07438683f, 
    -0.11894197f, -0.03685574f, -0.02281974f, -0.41132888f, -0.41243985f, -0.53030628f, -0.07855985f, -0.01450033f, 
    -0.10601997f, 0.10412464f, -0.22786589f, -0.06277282f, 0.07457748f, -0.01764505f, 0.13098532f, 0.06475562f, 
    -0.02453450f, 0.01151264f, 0.00092997f, -0.07874177f, 0.03104289f, -0.23412441f, -0.33668107f, 0.19930686f, 
    -0.04477875f, 0.21215415f, -0.08560396f, 0.09957500f, 0.05994285f, 0.06307534f, 0.21326861f, 0.43049949f, 
    -0.32797298f, 0.00263666f, 0.10669303f, -0.09818000f, 0.03409817f, 0.24770272f, 0.19441026f, -0.22147454f, 
    -0.27404773f, 0.08266798f, -0.11406555f, 0.10474333f, 0.10114041f, -0.04293961f, 0.02048196f, -0.00883770f, 
    0.38310933f, 0.44212425f, -0.15252760f, -0.15511611f, -0.17486651f, -0.07331707f, -0.05741641f, 0.08239314f, 
    0.20995525f, -0.99583352f, -0.07374636f, 0.06428917f, -0.18006724f, 0.13793586f, -0.14190876f, -0.07729714f, 
    0.01020711f, -0.05877022f, -0.20612229f, 0.07662219f, -0.27803269f, 0.05562261f, -0.16349001f, -0.15493278f, 
    -0.06337724f, 0.01118385f, -0.05123242f, -0.09906600f, -0.45063177f, -0.15340580f, 0.04262750f, -0.10052866f, 
    0.09223878f, 0.10970592f, -0.02982656f, 0.08120250f, -0.13593434f, 0.00144181f, -0.01848841f, 0.08002691f, 
    0.08564104f, 0.09493223f, 0.07895546f, 0.11905298f, 0.10767932f, 0.12845454f, 0.14451933f, -0.01491774f, 
    0.07143103f, 0.07421651f, 0.00200880f, 0.12079935f, -0.00938739f, 0.04785166f, -0.22924553f, 0.39808726f, 
    0.35141975f, 0.02611333f, -0.23134016f, -0.18037193f, -0.06152475f, -0.04502894f, 0.02952544f, 0.10856739f, 
    0.11464512f, 0.22157629f, 0.10068899f, -0.16906753f, 0.01951012f, 0.07434101f, 0.11579827f, -0.15788308f, 
    0.15224911f, -0.03379225f, 0.34573147f, 0.03180907f, -0.00888230f, 0.06653942f, 0.01741357f, 0.16038403f, 
    0.06166727f, -0.13271710f, -0.28462318f, -0.22370140f, -0.24276745f, 0.06948750f, -0.45058742f, -0.10959864f, 
    0.04069322f, -0.01444543f, 0.17600963f, -0.08200826f, 0.34378922f, -0.02487262f, -0.16257113f, 0.20054869f, 
    0.02747070f, -0.04857266f, 0.01796233f, -0.46460027f, -0.47240061f, 0.19462535f, -0.15093137f, 0.05599598f, 
    -0.26266122f, -0.00821435f, -0.00418608f, -0.00709219f, 0.04022099f, -0.02219326f, 0.42214346f, 0.12449376f, 
    -0.07523195f, 0.03213947f, 0.24216232f, -0.07720072f, 0.09614039f, -0.46912566f, 0.39452001f, 0.21699753f, 
    -0.02124757f, -0.16764872f, -0.16685250f, 0.03322541f, 0.05958488f, 0.04639343f, -0.80706066f, -0.03822942f, 
    -0.53389531f, 0.02700518f, 0.10331977f, 0.00692263f, -0.01256536f, 0.06080010f, -0.01862545f, -0.13741726f, 
    -0.06602835f, 0.31800702f, -0.18418777f, -0.06901066f, -0.10659594f, 0.15047315f, 0.18158406f, 0.10792968f, 
    0.10723401f, 0.15904802f, 0.42134520f, 0.05220939f, -0.10964990f, -0.09268468f, -0.10692443f, -0.12855762f, 
    0.07994018f, 0.05475232f, 0.03250134f, 0.26587680f, -0.06810632f, 0.08411692f, 0.02630470f, -0.03929989f, 
    -0.22670881f, 0.11241945f, 0.09037851f, 0.15452470f, 0.03896131f, 0.33324742f, 0.04823023f, 0.16019537f, 
    0.05580672f, -0.14713094f, 0.00759078f, 0.05929086f, 0.30495578f, 0.32399619f, -0.28531328f, -0.34678566f, 
    -0.24750577f, 0.10690102f, 0.19164841f, -0.11658441f, -0.28365055f, 0.06407157f, 0.49767181f, 0.21269448f, 
    0.12933928f, -0.03615098f, -0.04669912f, 0.03186679f, -0.16708210f, 0.16549708f, -0.02258890f, 0.05518372f, 
    -0.08620470f, -0.00151496f, -0.25228083f, 0.01657583f, 0.10588151f, 0.00136352f, -0.10335368f, -0.09249601f, 
    0.02525990f, 0.03999242f, -0.05213756f, 0.02430498f, 0.22831827f, -0.17243195f, 0.07491159f, 0.15456529f, 
    0.13727888f, 0.26041237f, 0.06645404f, 0.04823438f, 0.20544441f, 0.10530308f, -0.08038378f, -0.01248121f, 
    0.06624137f, -0.20900360f, 0.11421053f, 0.06530795f, 0.10564262f, -0.13903147f, -0.22197567f, -0.14921167f, 
    -0.21581578f, 0.08506796f, 0.18104872f, 0.13289332f, -0.14716682f, 0.16966043f, -0.20745054f, 0.11126312f, 
    0.02920613f, 0.06240650f, -0.19854011f, -0.11352136f, -0.13692778f, -0.17227313f, -0.43214035f, -0.07678097f, 
    -0.00573328f, 0.08982131f, 0.10326582f, 0.18398985f, 0.12596168f, -0.41994831f, -0.06062766f, 0.10394402f, 
    -0.03487390f, -0.08199649f, -0.10528124f, -0.06046037f, -0.22728840f, -0.07554120f, -0.23587458f, 0.20836058f, 
    0.02065717f, 0.03175974f, -0.04316841f, 0.07997680f, -0.03476938f, -0.45302054f, -0.45916128f, -0.27958474f, 
    -0.15042832f, -0.01071656f, -0.25720882f, 0.10249665f, -0.08189335f, -0.03675434f, -0.59946787f, 0.39986739f, 
    0.05493733f, -0.06673483f, -0.10285716f, -0.02702194f, 0.08088937f, -0.00451625f, -0.27128726f, 0.08111177f, 
    0.06302559f, 0.20421992f, 0.12777981f, -0.01262892f, 0.09884889f, -0.02750879f, -0.11348502f, 0.02031785f, 
    0.01863382f, 0.03282999f, -0.05527313f, -0.04029007f, -0.02022657f, -0.07093786f, -0.05625474f, -0.06968642f, 
    0.05692972f, -0.02583498f, -0.02997411f, -0.03965002f, 0.05578287f, 0.01964725f, -0.01599198f, -0.00899185f, 
    0.01926470f, 0.00316584f, -0.00669293f, 0.04710417f, -0.00836043f, 0.00504488f, -0.08793136f, 0.03755111f, 
    -0.04751206f, -0.00930496f, 0.03428886f, -0.08072429f, -0.05434421f, -0.01299706f, 0.05680993f, -0.00150497f, 
    -0.04561623f, -0.01680421f, 0.07551599f, -0.03617057f, 0.07174204f, -0.03825177f, -0.03696310f, 0.02680500f, 
    -0.05286038f, 0.05696972f, 0.01366092f, -0.07326971f, 0.03958865f, -0.03934845f, -0.06233065f, -0.06092021f, 
    -0.05274908f, -0.00529956f, -0.07169205f, -0.05582502f, 0.00379485f, -0.08295848f, 0.06405248f, -0.07127239f, 
    0.06369399f, -0.01070492f, 0.06319319f, 0.07117561f, 0.04169859f, -0.00289427f, -0.07076562f, 0.02890238f, 
    0.05405399f, 0.01260186f, -0.04858828f, 0.01517279f, -0.06433553f, -0.06194977f, -0.03123827f, -0.06207524f, 
    -0.05828916f, 0.03090649f, 0.02636603f, -0.05774800f, -0.04730126f, -0.00875879f, -0.05598083f, -0.04606006f, 
    -0.07048356f, -0.06078970f, 0.01284455f, -0.03379036f, 0.04188262f, 0.03839216f, -0.01735096f, 0.01350694f, 
    -0.00789789f, 0.02060446f, -0.00126887f, 0.02945328f, 0.08287366f, 0.02406908f, 0.00146454f, 0.05731026f, 
    -0.03978723f, 0.01237462f, -0.02762769f, 0.04187163f, -0.06362475f, -0.05461715f, 0.00954732f, -0.00508143f, 
    0.04726765f, -0.03761517f, 0.04531505f, 0.06461923f, 0.02631122f, 0.06689613f, 0.02425287f, -0.03585051f, 
    0.01674359f, -0.03364408f, -0.04545545f, -0.08048969f, 0.06270096f, -0.05080761f, -0.05643633f, -0.02973294f, 
    -0.06649269f, -0.02945609f, 0.03229197f, -0.04826280f, -0.05086828f, -0.01826495f, -0.05345009f, 0.04174124f, 
    0.00557450f, 0.05197886f, 0.00309350f, -0.05486656f, -0.07465803f, -0.01549676f, 0.07572238f, -0.04379468f, 
    0.04047186f, -0.04017271f, -0.02453410f, -0.02659126f, -0.07627802f, 0.04251526f, -0.08179788f, 0.04056147f, 
    -0.24695329f, -0.06558760f, 0.12825090f, -0.01806038f, 0.03296892f, -0.12146756f, -0.03377187f, 0.03631819f, 
    -0.12517256f, -0.14835416f, 0.02666892f, -0.20768611f, 0.00995279f, -0.12942238f, -0.22691984f, -0.14095727f, 
    0.01074137f, 0.02785294f, -0.88846475f, 0.02003662f, 0.01662757f, 0.11096463f, 0.13722767f, 0.19784944f, 
    0.04647933f, 0.25426522f, -0.01915733f, 0.35179251f, 0.10979190f, 0.00407636f, -0.07559197f, 0.15736696f, 
    -0.19116731f, -0.09022326f, -0.05118629f, -0.05032147f, 0.46023318f, -0.08305914f, -0.12487241f, 0.14063284f, 
    0.17750677f, 0.04396429f, 0.10996232f, 0.00024477f, 0.14245217f, -0.20065649f, 0.05545629f, -0.07294934f, 
    -0.02941690f, -0.13682716f, -0.07673018f, 0.14742464f, -0.01853985f, 0.11552379f, 0.00985201f, 0.01239854f, 
    -0.32537767f, -0.11606961f, 0.14816365f, 0.02192438f, 0.03184845f, 0.01921026f, -0.06271778f, -0.07688788f, 
    -0.05381256f, 0.06366556f, 0.13564731f, -0.03760855f, -0.05824864f, 0.21106634f, 0.05849980f, 0.08717820f, 
    0.12328320f, 0.07335123f, 0.02809015f, 0.05802545f, 0.18447088f, 0.00845694f, -0.06911556f, 0.11427755f, 
    0.26149210f, 0.19327603f, 0.22316138f, -0.00804215f, -0.15388060f, -0.19659767f, 0.32976034f, -0.00361009f, 
    -0.09727893f, -0.34371746f, 0.09145045f, -0.31803018f, -0.49393451f, -0.20973201f, -0.03433790f, 0.09473561f, 
    -0.08773057f, 0.02616585f, 0.22914711f, -0.33135626f, -0.47444603f, -0.16018040f, -0.10875467f, -0.18524897f, 
    -0.22875467f, -0.05453058f, 0.07445021f, 0.17925858f, 0.51500165f, 0.04218061f, -0.18443160f, -0.04805754f, 
    -0.01849901f, -0.04036815f, 0.16281727f, -0.03501869f, -0.12818226f, 0.18706127f, -0.14716397f, -0.01187397f, 
    -0.06772091f, -0.01815964f, 0.03472814f, -0.00015794f, 0.00881579f, 0.00801370f, 0.28971910f, -0.14172536f, 
    -0.00175765f, 0.31824633f, 0.15468669f, -0.25359821f, -0.08741443f, 0.14882484f, 0.29037222f, -0.27822253f, 
    0.15521410f, -0.03472236f, -0.06874493f, 0.05393273f, 0.03874389f, 0.05901257f, -0.04551664f, 0.11154214f, 
    0.07540843f, -0.09675381f, 0.09782460f, -0.21421035f, -0.06784259f, 0.14965039f, -0.07634292f, -0.03615711f, 
    0.00592769f, 0.25028121f, 0.10250051f, 0.21116875f, -0.02783388f, -0.07723349f, -0.23063633f, 0.11413185f, 
    0.13701589f, 0.13013436f, 0.27227476f, -0.01128829f, 0.02685567f, -0.05984202f, -0.03643659f, -0.08877936f, 
    0.07815442f, -0.01034393f, 0.19363849f, -0.04357667f, -0.11797330f, -0.38485765f, 0.09893027f, -0.00151777f, 
    -0.07730745f, 0.05605477f, 0.09353158f, 0.17808449f, 0.43574831f, -0.08851956f, -0.14056008f, -0.02126173f, 
    0.17850120f, 0.21038005f, -0.02872980f, 0.14215261f, 0.04548065f, 0.17581093f, 0.06259205f, -0.10043644f, 
    0.09362906f, -0.06151674f, 0.07658649f, -0.11004283f, 0.10107011f, 0.11202700f, -0.12922516f, 0.26106608f, 
    -0.00941985f, 0.01096602f, 0.04201087f, -0.13814701f, 0.10040248f, 0.00801931f, -0.16380146f, 0.08135212f, 
    -0.22098020f, -0.32033899f, 0.20505518f, -0.05415529f, 0.12309053f, 0.01391514f, -0.12948146f, 0.01504268f, 
    -0.00382473f, 0.27978691f, 0.27432978f, -0.03880419f, 0.18651015f, 0.09234452f, -0.03307228f, 0.29762831f, 
    0.16764611f, -0.61689728f, -0.10138774f, -0.05753331f, -0.09927750f, 0.01065165f, -0.18478362f, -0.03787372f, 
    -0.12525800f, 0.05536367f, -0.61540592f, -0.16632730f, -0.40077668f, -0.07508016f, 0.04007778f, -0.01095897f, 
    -0.01219535f, -0.17584202f, 0.08728829f, -0.04470718f, 0.00476497f, 0.39721379f, -0.14108814f, -0.15596774f, 
    -0.05172396f, 0.15719956f, -0.06067922f, 0.11442465f, -0.50604427f, 0.31343573f, 0.31807533f, 0.20704766f, 
    0.02263737f, -0.00546699f, -0.04352483f, 0.06233833f, 0.08545274f, -1.03915548f, -0.46196339f, 0.00629955f, 
    0.20106140f, 0.04661625f, -0.20147762f, -0.02999106f, -0.05282643f, -0.03116330f, 0.09186064f, -0.33403012f, 
    -0.43952951f, 0.05479805f, 0.02114833f, 0.30557394f, 0.02540241f, -0.00775648f, -0.01166471f, 0.05218790f, 
    0.16258393f, 0.11466958f, -0.13887335f, -0.09797905f, 0.05165602f, 0.09621478f, -0.02822737f, -0.03054723f, 
    0.12097777f, 0.07871509f, 0.00838321f, -0.11127960f, 0.09877042f, 0.19789079f, -0.09895352f, 0.00399537f, 
    0.13994376f, 0.25597534f, 0.45197669f, 0.03099301f, -0.33352479f, -0.27267045f, -0.08728735f, 0.27612957f, 
    0.19522782f, -0.03579741f, 0.05177807f, 0.50526059f, -0.11128264f, -0.12371013f, -0.20695059f, 0.07650996f, 
    0.22560783f, 0.04619959f, -0.22551413f, 0.04571520f, -0.14107209f, 0.03753544f, 0.04821066f, -0.03894337f, 
    0.09356572f, -0.00146045f, 0.13382180f, 0.28046882f, 0.10252228f, 0.02882665f, 0.14080085f, 0.19843532f, 
    0.07033663f, 0.12896776f, 0.19406024f, 0.06858840f, -0.13702238f, 0.09583847f, 0.09351652f, 0.43191919f, 
    -0.21421833f, -0.14069301f, -0.10734288f, 0.11859971f, 0.36889330f, 0.04280849f, 0.37089047f, -0.02885462f, 
    -0.32630396f, 0.01030013f, -0.06782527f, -0.08403544f, -0.07683913f, 0.21245266f, -0.05457474f, -0.10054344f, 
    -0.00567264f, 0.10603902f, -0.09750985f, -0.10826570f, -0.11261377f, 0.00120642f, 0.07201809f, -0.14082080f, 
    0.06773251f, 0.21623033f, 0.30801105f, 0.20018215f, 0.15059629f, -0.09832579f, 0.11289396f, 0.41789967f, 
    -0.16719517f, 0.48416540f, -0.45348141f, 0.23823808f, -0.00981746f, 0.14900222f, -0.13423082f, -0.25472081f, 
    -0.05995202f, 0.14451419f, -0.02357949f, 0.13141060f, 0.13511461f, 0.03185849f, 0.00096134f, -0.10527359f, 
    -0.11400405f, 0.04628866f, 0.08127074f, -0.01181742f, 0.19289799f, 0.74218196f, -0.03810642f, 0.01114842f, 
    0.07036431f, 0.05966571f, 0.13584779f, 0.21552046f, 0.35677537f, -0.12330540f, -0.17279989f, 0.02630153f, 
    -0.04650452f, -0.00317553f, -0.10421860f, 0.00457156f, 0.04781194f, 0.23285335f, -0.35578257f, 0.10078008f, 
    0.13436915f, 0.12003657f, -0.15476187f, 0.23498046f, -0.01445854f, -0.08451684f, 0.29277736f, -0.37833446f, 
    -0.89791840f, -0.00981778f, -0.06047268f, 0.30753058f, -0.00127794f, -0.18679641f, 0.01835756f, 0.10468040f, 
    0.18102738f, -0.02821377f, -0.13920133f, 0.01740482f, -0.05114902f, -0.01025904f, 0.02458465f, -0.07190143f, 
    -0.46258664f, -0.20745660f, -0.26337609f, -0.00924349f, -0.11047950f, 0.12046150f, -0.15636174f, -0.31928438f, 
    0.19764826f, 0.06996521f, 0.05942558f, 0.00230933f, -0.13530968f, -0.05099259f, -0.19330812f, 0.08430579f, 
    -0.00632803f, -0.02388917f, -0.81348288f, 0.04806859f, -0.39281726f, -0.16348748f, -0.08325841f, -0.06005780f, 
    0.16175692f, 0.28045633f, 0.20449585f, 0.38978121f, 0.16037704f, 0.36938092f, 0.04164618f, -0.00404649f, 
    -0.08893326f, 0.11778191f, 0.31007358f, -0.06481688f, -0.18351527f, 0.04878567f, 0.03162076f, 0.03429217f, 
    0.08545975f, -0.01160723f, 0.14171575f, 0.28253230f, 0.05289679f, 0.01724228f, 0.26621497f, 0.30982932f, 
    0.06953518f, 0.17902705f, 0.33157754f, 0.12559584f, -0.21954100f, 0.09285766f, 0.06557658f, -0.18337983f, 
    0.36403206f, -0.08078609f, 0.25846460f, -0.13333957f, 0.03335151f, 0.07877426f, -0.01215969f, 0.09273741f, 
    -0.09967867f, -0.15735891f, -0.00366260f, -0.18513452f, 0.13805610f, -0.02061939f, -0.17161506f, 0.04706452f, 
    -0.26239809f, 0.45916286f, 0.51831526f, 0.26613179f, 0.33342311f, -0.02681547f, 0.29446563f, 0.09724872f, 
    0.25829542f, -0.44618285f, 0.47082928f, 0.01430898f, 0.11830831f, -0.26676068f, -0.01849163f, -0.02170028f, 
    0.00827916f, -0.24957842f, -0.11199521f, 0.01009779f, 0.20178606f, -0.20334995f, 0.06426291f, -0.03277997f, 
    -0.01729412f, -0.09980052f, -0.42095238f, -0.22288102f, 0.07420956f, 0.07372471f, 0.17202693f, 0.23438823f, 
    0.03348787f, -0.04285473f, 0.16120121f, 0.58033127f, 0.00666772f, 0.04725242f, 0.41390815f, 0.18379582f, 
    0.16094033f, 0.11374087f, 0.19943735f, 0.07231082f, 0.06557413f, 0.35395971f, 0.35891834f, -0.00277256f, 
    -0.05657460f, 0.14326862f, -0.01119916f, -0.06239614f, -0.12299937f, 0.00675485f, 0.07285652f, 0.08727054f, 
    -0.38235497f, -0.12486190f, -0.01456319f, 0.16330557f, 0.06479906f, 0.26491910f, -0.03613768f, -0.22314267f, 
    -0.17878294f, -0.15139726f, 0.02933240f, -0.13887054f, -0.13620290f, 0.24574731f, 0.25714591f, 0.48437697f, 
    -0.14318934f, -0.36383519f, -0.15976860f, 0.11239529f, 0.02114200f, -0.16239692f, -0.36978248f, 0.00778945f, 
    0.28718826f, -0.20493536f, 0.20334312f, -0.04975206f, -0.23257478f, 0.25945556f, -0.11436392f, 0.00943599f, 
    -0.02524341f, 0.22366935f, 0.06347828f, 0.42015287f, -0.20996726f, -0.20873249f, -0.19957054f, -0.06054136f, 
    0.12678820f, 0.14365102f, -0.08489031f, 0.04754299f, -0.35578874f, -0.37840408f, 0.01022593f, 0.05578744f, 
    -0.06786442f, -0.00018955f, -0.10457428f, -0.02301199f, 0.27339590f, 0.01003541f, 0.08623731f, 0.02612641f, 
    0.08807794f, 0.44601315f, -0.07693471f, 0.05543233f, 0.06785811f, 0.12563336f, -0.08590852f, 0.33994776f, 
    -0.13279378f, -0.09270362f, 0.04983920f, 0.11405651f, 0.00157018f, 0.22967330f, -0.41508538f, 0.04211958f, 
    -0.18399377f, 0.05623310f, 0.05419750f, 0.01330599f, 0.12289032f, 0.06876975f, 0.02032477f, -0.25129128f, 
    -0.07475912f, -0.03474457f, -0.01250915f, 0.00287217f, 0.06272525f, 0.17466843f, 0.07474887f, -0.06008982f, 
    -0.17758815f, 0.17951185f, 0.46132183f, 0.21320158f, 0.00292906f, -0.05725537f, 0.00935849f, 0.28756207f, 
    0.22687940f, -0.08369136f, -0.11052406f, -0.14186308f, -0.03948814f, -0.09463682f, -0.25316918f, -0.04725298f, 
    0.16225848f, 0.06996356f, 0.11051320f, -0.20974568f, -0.08034694f, -0.36318526f, -0.01458610f, -0.04656367f, 
    0.04899050f, 0.11651519f, -0.01350824f, -0.33809900f, -0.55000573f, 0.35095879f, -0.12530501f, -0.06643137f, 
    -0.11898378f, -0.02178524f, -0.18836327f, -0.18864703f, 0.26139787f, -0.26893947f, -0.33078936f, -0.31142807f, 
    -0.02149880f, 0.16832769f, -0.05028626f, -0.00512795f, -0.06860133f, -0.42308131f, -0.03014720f, 0.63175339f, 
    -0.14359847f, 0.11860943f, -0.05498613f, 0.09899119f, 0.04219411f, -0.12702024f, -0.35104626f, -0.18429914f, 
    -0.89560944f, 0.42051682f, 0.12408186f, 0.35000658f, 0.01420982f, -0.14010942f, -0.15420285f, 0.37451679f, 
    0.22136863f, 0.37386701f, -0.13804953f, -0.14300826f, 0.11957258f, 0.03777612f, -0.02606949f, -0.08787123f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.23257598f, -0.03350845f, 0.12984012f, -0.16635893f, 0.27914220f, -0.00093794f, 0.02506060f, 0.24961808f, 
    0.26908326f, 0.07140844f, -0.06193175f, 0.15615396f, 0.09339843f, 0.04837492f, 0.33147916f, 0.21289822f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.26229450f, 0.53777462f, 0.19988440f, -0.03826525f, -0.33805031f, -0.09049689f, -0.18859038f, -0.34923440f, 
    -0.30492410f, 0.35459217f, -0.24523389f, 0.50552005f, -0.31591296f, 0.15626691f, 0.32062852f, -0.71180373f, 
    -0.18354385f, 0.33903813f, -0.06353132f, 0.18260705f, -0.36895820f, 0.06147560f, 0.24956644f, -0.18466531f, 
    -0.15034910f, 0.01629163f, -0.13468432f, -0.15346801f, 0.16539945f, 0.07503844f, -0.16617431f, 0.03609554f, 
    0.03238000f, 0.05370591f, 0.05468225f, 0.13227506f, 0.70955646f, 0.16276933f, 0.19572282f, 0.21969101f, 
    -0.67080450f, 0.00491248f, 0.23570178f, -0.26827925f, 0.44049615f, -0.20795245f, 0.13843630f, -0.41686797f, 
    -0.28928828f, 0.20024712f, 0.25338644f, 0.29143661f, 0.18717800f, -0.43866873f, 0.15927464f, 0.41828296f, 
    0.31978518f, 0.29758358f, -0.18709448f, -0.10230120f, -0.43357044f, 0.02205766f, 0.35644728f, -0.39614466f, 
    -0.33266893f, -0.13534196f, -0.27654806f, 0.26002365f, 0.34617954f, 0.23772810f, 0.24165531f, 0.34506539f, 
    -0.92454374f, -0.07715919f, -0.00418690f, 0.21615241f, 0.09216011f, 0.07062360f, 0.22305951f, 0.01564127f, 
    -0.18854779f, -0.14605959f, -0.07074675f, 0.03126672f, -0.06047890f, 0.12909482f, -0.07555771f, -0.04886258f, 
    -0.09664461f, -0.02944437f, -0.09856418f, -0.15941869f, -0.21195501f, -0.28063938f, -0.15695906f, -0.12520958f, 
    -0.35000795f, 0.18033254f, -0.06583688f, 0.40398809f, -0.18775032f, 0.17142484f, 0.10700993f, -0.71952021f, 
    -0.40701663f, 0.04809695f, -0.07379061f, 0.15988754f, -0.36603230f, -0.09621087f, 0.46247023f, -0.70260721f, 
    0.29668102f, 0.19997379f, 0.20927648f, -0.37072366f, 0.37253776f, -0.04965425f, 0.13584308f, -0.05339229f, 
    -0.61695296f, -0.43991038f, -0.18435830f, 0.15932849f, 0.26615396f, -0.09266359f, 0.37899342f, -0.39798960f, 
    0.38432106f, -0.55058342f, 0.20647585f, 0.06141905f, -0.14588130f, -0.24468055f, -0.15319408f, -0.01831757f, 
    -0.03801117f, -0.01139587f, 0.14519402f, -0.01616047f, 0.24757123f, 0.16937494f, -0.36582121f, 0.18576418f, 
    0.06182622f, 0.59644085f, 0.02679152f, 0.33563426f, -0.02434337f, 0.13556087f, -0.17898923f, -0.25924322f, 
    -0.07260972f, 0.05888497f, -0.10326265f, -0.04903369f, -0.52509314f, -0.21286222f, 0.00587328f, -0.35400072f, 
    -0.00127418f, -0.50584775f, -0.36105391f, 0.14412107f, 0.24605396f, -0.10804287f, -0.08217549f, -0.22804502f, 
    -0.15612392f, -0.46142587f, -0.22123259f, 0.55334508f, -0.35365748f, 0.18318249f, 0.28754005f, 0.77209014f, 
    0.00321622f, -0.11943828f, -0.29555964f, 0.20074619f, 0.66388893f, -0.17302708f, 0.17687707f, 0.15916580f, 
    0.00911491f, -0.33388680f, 0.05785666f, 0.43208018f, 0.20583017f, -0.45019579f, 0.28995788f, -0.11067732f, 
    0.06857695f, 0.01384193f, 0.05659168f, 0.16046271f, -0.00982123f, -0.24574982f, -0.02413106f, 0.48154232f, 
    1.08805454f, 0.43553466f, -0.03784290f, -0.31028178f, -0.01360445f, 0.08801664f, -0.10832657f, 0.02444865f, 
    0.24523345f, 0.23230211f, 0.14874516f, -0.47134915f, 0.29253757f, 0.01431613f, 0.16350733f, -0.18613839f, 
    0.47594491f, -0.30974624f, 0.12072250f, -0.35701898f, 0.41957915f, -0.06853653f, 0.34136978f, -0.50353396f, 
    -0.28480101f, -0.66239333f, -0.17264012f, 0.43565583f, -0.08913102f, 0.25370851f, -0.12699524f, 0.33356851f, 
    0.45860845f, 0.22083253f, 0.13485198f, 0.26927045f, 0.08617400f, -0.27592358f, -0.08208149f, -0.40803781f, 
    -0.27057567f, 0.00601643f, 0.04777424f, -0.10431023f, 0.20939045f, 0.17773545f, 0.10935199f, -0.21719362f, 
    0.14162120f, -0.16571990f, -0.08377808f, -0.05012389f, -0.07421288f, -0.31734511f, -0.16896373f, 0.02738581f, 
    -0.21341960f, -0.00128279f, 0.00845044f, -0.07743471f, 0.12791301f, -0.04294399f, 0.16343111f, -0.08076113f, 
    -0.00058393f, 0.05722003f, -0.14924726f, 0.18260694f, 0.04403803f, -0.22292547f, -0.26177371f, -0.02032831f, 
    0.39546740f, 0.11934162f, -0.44763932f, 0.20679976f, 0.23191559f, 0.23731855f, 0.16354412f, -0.33741820f, 
    0.02454505f, -0.60897088f, -0.19191521f, 0.07181548f, 0.14252590f, -0.28304255f, 0.09254801f, -0.51792854f, 
    0.30203259f, -0.27572411f, -0.22068562f, 0.02810906f, 0.35640806f, -0.39817259f, -0.02217970f, 0.60889447f, 
    -0.42806509f, -0.14595075f, -0.12938520f, 0.51517290f, 0.03738009f, -0.02692335f, 0.06411868f, 0.44836268f, 
    -0.21719478f, 0.41095477f, -0.00479826f, 0.50347298f, 0.04756406f, -0.01448131f, 0.14023007f, -0.33294159f, 
    0.88836956f, -0.11122119f, 0.19777910f, 0.15646811f, -0.49637654f, 0.22341581f, -0.12969588f, -0.23174554f, 
    -0.20005786f, 0.09155969f, -0.26716623f, -0.23194149f, 0.04714135f, -0.21068028f, 0.14496621f, 0.03434657f, 
    -0.17972824f, -0.17988944f, -0.21211961f, -0.01443553f, 0.00976244f, 0.12092550f, -0.07955397f, -0.02040467f, 
    0.33468491f, 0.02634656f, -0.11859355f, -0.41302353f, 0.14242156f, 0.10547929f, 0.13119341f, 0.20572516f, 
    -0.34077209f, -0.07637206f, -0.19729371f, 0.41625419f, 0.12572987f, -0.12889202f, 0.19073100f, 0.05534007f, 
    0.14729285f, -0.35268924f, -0.18090385f, -0.10963481f, -0.10990757f, 0.02860570f, -0.21743244f, 0.08175159f, 
    0.14005926f, 0.11825313f, -0.09064224f, 0.28874043f, -0.05581741f, -0.16420165f, 0.02513280f, 0.25269517f, 
    0.17154634f, -0.22104140f, 0.11338331f, 0.15234278f, 0.12562855f, -0.21469636f, 0.13273744f, 0.47830856f, 
    0.52745527f, 0.31196770f, -0.24616933f, 0.30308464f, -0.30944481f, 0.02724980f, -0.02195062f, -0.43360078f, 
    -0.21692759f, -0.12953252f, -0.47702804f, 0.22421139f, -0.36329997f, 0.29080707f, 0.07865731f, 0.18595697f, 
    -0.30119529f, -0.84061420f, -0.07940599f, -0.14755583f, -0.03977738f, 0.26348829f, 0.12359115f, 0.75073850f, 
    -0.14387384f, 0.04286297f, 0.17326696f, -0.37491605f, 0.05783015f, 0.31428260f, -0.13944224f, -0.12268331f, 
    -0.22909153f, 0.19905773f, 0.15913612f, -0.14967804f, -0.02330814f, -0.00096339f, -0.14544794f, 0.06601315f, 
    -0.13124481f, -0.13708460f, -0.10114333f, -0.24131250f, 0.13540936f, -0.12574822f, -0.06507835f, 0.23912513f, 
    -0.18211621f, 0.12834397f, 0.16685307f, -0.04205161f, -0.22988725f, -0.05030194f, -0.14395636f, -0.16718489f, 
    -0.33518091f, 0.30425951f, -0.36624774f, 0.23764680f, 0.03507007f, 0.29100928f, -0.18072556f, 0.37367555f, 
    0.88075316f, -0.26601020f, 0.13123715f, -0.52288258f, -0.04540078f, 0.19128537f, -0.02244639f, 0.19124223f, 
    0.78329659f, 0.57547641f, 0.03532871f, -0.17787589f, 0.15743007f, 0.26057932f, -0.18365642f, 0.40533218f, 
    -0.41291192f, -0.30479974f, 0.24937464f, 0.02845743f, 0.48347610f, -0.14342029f, -0.07869754f, 0.02134918f, 
    0.37519383f, -0.53991324f, 0.28844520f, -0.51026249f, 0.01261534f, -0.32581621f, -0.08025292f, -0.20731919f, 
    0.60118812f, -0.27289668f, 0.10044142f, 0.22491841f, -0.00005078f, 0.49197417f, 0.10692621f, 0.00584646f, 
    0.01894277f, 0.03011694f, 0.45027387f, -0.53221178f, -0.45920226f, -0.49723718f, -0.10294955f, 0.06104614f, 
    0.40192086f, -0.01726908f, -0.22793818f, -0.36054879f, 0.04656181f, 0.56233138f, 0.25114051f, -0.32911342f, 
    -0.40837550f, -0.08536450f, 0.39976943f, -0.05612148f, -0.49640247f, -0.78242987f, 0.14278035f, -0.54704112f, 
    0.08441665f, -0.90088999f, -0.23668405f, 0.49447545f, -0.57018512f, 0.18675037f, 0.33386487f, 0.05530443f, 
    0.01072610f, -0.14499021f, -0.11252096f, 0.09742932f, 0.65967464f, 0.05767507f, -0.12854929f, 0.05252350f, 
    -0.09160866f, -0.01472925f, -0.11282185f, 0.11073193f, 0.20692523f, 0.08554792f, 0.02549874f, -0.20389114f, 
    -0.35939378f, 0.28920937f, 0.23039541f, -0.02429899f, -0.16580191f, -0.36271453f, 0.13969077f, 0.13068169f, 
    0.13958943f, 0.41494620f, -0.02991521f, 0.31506935f, -0.03070790f, 0.03813359f, 0.42147148f, -0.45169380f, 
    0.23054498f, 0.39816180f, 0.40041879f, -0.23803876f, -0.33442944f, -0.20691863f, -0.28016660f, -0.02540711f, 
    0.45015734f, 0.13965310f, 0.00987977f, -0.59791434f, 0.28839040f, 0.44214779f, -0.11518664f, -0.44429341f, 
    -0.20528169f, -0.27520865f, -0.06574971f, -0.26041910f, 0.16388728f, 0.18454227f, -0.07877406f, -0.29990941f, 
    -0.61804903f, 0.26830950f, 0.22489542f, -0.29679111f, -0.16878855f, -0.21397400f, -0.38362402f, 0.06506802f, 
    0.38060293f, 0.44503596f, -0.06959908f, 0.39384976f, -0.16126722f, -0.30627444f, -0.06703841f, -0.38969240f, 
    -0.54677093f, -0.10658788f, -0.14378539f, -0.03983311f, -0.16721147f, -0.35331148f, 0.35925275f, -0.53784621f, 
    0.08798662f, -0.15332101f, -0.03353053f, 0.15648232f, -0.00698838f, -0.13687433f, 0.22280818f, 0.03166173f, 
    0.24982837f, 0.11203293f, -0.04578626f, -0.20165750f, -0.24717872f, -0.09515443f, -0.13288435f, -0.02935297f, 
    0.21148697f, -0.32377282f, 0.05521027f, -0.23646489f, 0.23923236f, -0.13781546f, -0.11299685f, 0.24467698f, 
    0.27770680f, -0.12344822f, -0.00307742f, 0.21629338f, -0.11381557f, -0.08088592f, 0.32603836f, -0.08663631f, 
    -0.16496593f, -0.18487692f, -0.02606573f, -0.34172395f, 0.13576047f, -0.36631882f, 0.11264184f, 0.21897504f, 
    0.17455329f, 0.12103830f, -0.06873709f, -0.06058764f, 0.09107053f, 0.27681699f, -0.14992720f, 0.77411598f, 
    0.28726980f, -0.21707781f, -0.57753175f, -0.23217624f, 0.00744863f, 0.28945106f, 0.03977200f, 0.33014518f, 
    -0.22883064f, -0.22927959f, -0.10580155f, -0.09641416f, 0.03832948f, 0.18393449f, 0.33243850f, 0.02451195f, 
    0.10523769f, 0.06822454f, -0.20454909f, -0.05309867f, -0.00997499f, -0.08647480f, -0.13398328f, 0.17985472f, 
    -0.13763145f, -0.06885444f, 0.15252453f, 0.09703919f, -0.03237488f, -0.22238699f, -0.08140710f, -0.11383723f, 
    -0.22662434f, -0.06633871f, -0.38902226f, 0.05332619f, -0.00201474f, -0.22845542f, -0.25818589f, -0.05677183f, 
    -0.41687781f, 0.22840188f, 0.06051171f, -0.41644719f, 0.13881764f, 0.32856703f, 0.00480039f, 0.58525300f, 
    -0.14543124f, 0.52092212f, -0.06910945f, 0.26761124f, 0.63224488f, -0.01576621f, -0.07916175f, 0.24008237f, 
    0.50395495f, -0.02691300f, -0.10783187f, 0.32498857f, -0.61183381f, -0.20832463f, -0.18935947f, 0.28960791f, 
    -0.36060280f, -0.41641015f, -0.26280469f, 0.40108842f, 0.49601534f, 0.01517199f, -0.02734368f, 0.05488540f, 
    -0.16697811f, -0.33864036f, -0.21745105f, 0.27509618f, -0.09081485f, 0.16885923f, 0.02762326f, 0.32642394f, 
    0.33837190f, 0.44274253f, 0.07590491f, -0.15839067f, -0.31921497f, 0.29634720f, 0.26380891f, -0.45526356f, 
    -0.29766104f, -0.42824313f, 0.20202969f, 0.00857576f, 0.17708941f, 0.28500396f, 0.00333847f, 0.11375596f, 
    0.32625312f, -0.10416035f, 0.35938862f, -0.25065404f, -0.51616949f, -0.60572243f, -0.10473470f, -0.05856030f, 
    0.23755811f, -0.35516816f, -0.10366300f, -0.05553105f, 0.18800867f, 0.30890170f, 0.14373615f, 0.11676378f, 
    -0.01097974f, -0.02904692f, -0.06789815f, 0.08371297f, 0.10060984f, -0.19424236f, 0.18046409f, -0.20806283f, 
    -0.17664534f, -0.12054342f, -0.18187550f, -0.09364000f, 0.19890913f, -0.18202013f, -0.19106022f, 0.19684845f, 
    0.13256751f, 0.38153687f, -0.07284456f, 0.43173206f, -0.30764446f, 0.02797329f, 0.06952290f, 0.12972130f, 
    -0.59614360f, -0.33873355f, 0.21746515f, -0.06575321f, -0.05714026f, 0.40666211f, -0.16989900f, 0.33084834f, 
    -0.43915156f, 0.29244146f, -0.15638499f, 0.42897421f, 0.16105729f, 0.02907570f, 0.21863067f, -0.13454472f, 
    0.38450834f, -0.18516378f, 0.12865900f, 0.23496436f, -0.19365411f, -0.09501164f, 0.16416799f, 0.96551681f, 
    -0.29855192f, -0.19255741f, 0.35440034f, 0.12607247f, 0.11948732f, -0.02195191f, 0.04750345f, -0.01152430f, 
    -0.01757225f, 0.06976954f, -0.16097310f, -0.30516669f, -0.15944408f, 0.28274325f, 0.25656548f, -0.51722014f, 
    0.29118738f, -0.14864565f, -0.28382286f, -0.23906256f, -0.02045399f, 0.18752371f, 0.12166692f, 0.49728248f, 
    0.71609807f, -0.40363094f, 0.03921947f, -0.78166246f, -0.03986277f, -0.00676439f, 0.26269519f, -0.37052172f, 
    0.33441547f, -0.09273463f, -0.19287138f, -0.29850042f, -0.12736528f, 0.15176468f, 0.25228938f, -0.27410641f, 
    -0.27525476f, -0.09072558f, 0.18662784f, 0.23491178f, 0.07093994f, 0.27079844f, 0.18491641f, 0.43622920f, 
    0.20711878f, -0.21040417f, 0.07831946f, -0.30804670f, 0.01903594f, -0.25419161f, 0.05307357f, -0.02047346f, 
    1.04289639f, 0.38528261f, 0.14847001f, -0.19546066f, 0.09877985f, -0.09693687f, 0.35623050f, -0.09870156f, 
    0.38735744f, 0.38629949f, 0.10486089f, 0.13063550f, 0.44701025f, -0.18746082f, -0.27096337f, 0.31921694f, 
    0.45896283f, -0.00414172f, -0.06130503f, -0.03133371f, 0.43150669f, -0.31631672f, -0.19275776f, 0.22122526f, 
    0.07824416f, -0.02464467f, 0.12696597f, -0.43825197f, -0.31356788f, -0.06638516f, -0.07396809f, -0.11329521f, 
    0.44287819f, -0.16343352f, 0.04136875f, -0.58117861f, 0.24755442f, 0.35657534f, -0.14190085f, 0.67264611f, 
    -0.24873349f, 0.49744028f, 0.25210908f, 0.12300476f, -0.30028388f, -1.14974201f, 0.19119230f, -0.93067837f, 
    0.18034443f, -0.15053585f, 0.19416156f, 0.27117682f, 0.47080761f, -0.08225156f, 0.12992062f, 0.41886935f, 
    0.42021522f, 0.16658176f, -0.16646275f, 0.22746484f, -0.38979456f, 0.23806150f, -0.16725971f, -0.32261080f, 
    -0.65143299f, -1.22237802f, -0.24428509f, 0.49679646f, 0.42064428f, 0.29042479f, -0.08298533f, 0.06676940f, 
    -0.22290446f, 0.06686675f, -0.11551000f, 0.18246132f, 0.35925755f, -0.53332394f, -0.07240329f, 0.47348055f, 
    0.07949159f, 0.23850650f, 0.09696853f, 0.41141224f, -0.28551006f, 0.05106918f, 0.22683920f, 0.01081493f, 
    -0.41677448f, -0.15821801f, 0.43240708f, 0.15192695f, -0.08236267f, -0.52280045f, -0.08199251f, 0.29147276f, 
    0.67979628f, 0.15144634f, 0.23944017f, 0.46784866f, -0.57688290f, 0.24762306f, 0.25474131f, -0.28087941f, 
    -0.18093625f, 0.21645316f, -0.26079985f, -0.21755800f, -0.00956550f, 0.25086978f, -0.11822020f, 0.12480675f, 
    -0.44544700f, 0.08491977f, -0.16625351f, -0.03167083f, 0.23161641f, 0.18540509f, -0.10005229f, 0.70435739f, 
    -0.22397183f, -0.11221741f, -0.06937117f, 0.10099588f, 0.51122665f, -0.37985343f, -0.19076988f, -0.07448961f, 
    0.34242809f, 0.09962361f, 0.19537786f, 0.11050889f, 0.19883507f, -0.26737344f, 0.13067824f, 0.74414986f, 
    -0.19462748f, -0.01083375f, -0.08950997f, -0.02352738f, 0.90244144f, 0.04061431f, 0.20567042f, 0.26489681f, 
    0.23694254f, -0.29212293f, 0.12217413f, 0.53515750f, -0.34258172f, -0.08424249f, 0.21706341f, -0.11028985f, 
    0.31537515f, -0.15422826f, -0.00349279f, 0.25906736f, -0.11832800f, -0.22834016f, -0.04344928f, -0.00859464f, 
    -0.21622533f, -0.34832305f, 0.11412936f, 0.18909757f, 0.17633422f, 0.13472280f, -0.13291162f, -0.38203251f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.26725310f, -0.04953380f, 0.38527462f, 0.26068929f, -0.17060213f, 0.03914936f, 0.17607126f, 0.01096426f, 
    -0.19661182f, -0.05876214f, 0.36369669f, 0.27074078f, 0.24921770f, 0.32042283f, -0.46242103f, -0.14874467f, 
    0.07818954f, -0.05784133f, 0.36550748f, -0.28905404f, -0.23078845f, -0.09977432f, -0.01974300f, 0.46435484f, 
    0.00980534f, 0.50956434f, 0.21921891f, -0.07788425f, 0.47986662f, 0.51652491f, 0.14432025f, -0.07182635f, 
    -0.07182463f, 0.18630944f, -0.00686852f, 0.27554128f, -0.30057740f, -0.03793234f, 0.23067483f, 0.40883887f, 
    0.36016181f, -0.26535156f, -0.44716182f, -0.14117262f, 0.17706718f, -0.14790255f, 0.46562225f, -0.13530713f, 
    0.04393310f, 0.06592596f, 0.08859802f, 0.27079549f, 0.13297658f, 0.22350818f, 0.00855460f, 0.01747748f, 
    -0.46002385f, -0.04744782f, 0.67319286f, 0.11451092f, 0.05759316f, -0.31795385f, 0.47213846f, 0.10196687f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.31826207f, 0.26365855f, -0.10686572f, -0.00400215f, -0.17110993f, -0.00176788f, 0.27521983f, 0.07389799f, 
    -0.44956353f, 0.28734356f, -0.43750161f, -0.04547378f, -0.34062588f, -0.10563609f, 0.10483290f, 0.01724759f, 
    -0.03108470f, 0.12682745f, -0.54856992f, 0.30771923f, -0.09473554f, -0.08690167f, -0.35037652f, -0.24306056f, 
    -0.44275075f, 0.08023079f, 0.03328045f, -0.19987941f, 0.02729423f, 0.62586975f, -0.29807729f, 0.28657797f, 
    -0.19035049f, 0.03021118f, 0.00850278f, 0.07100076f, 0.21919139f, -0.11239168f, -0.35503399f, -0.34071112f, 
    -0.79703581f, 0.10327846f, -0.04120795f, 0.26424566f, -0.18183257f, 0.26987016f, -0.21927354f, -0.11589229f, 
    0.09490722f, 0.21718493f, 0.01966362f, -1.07263172f, -0.38651100f, -0.72322011f, 0.04938299f, -0.78469098f, 
    0.57946014f, 0.49518991f, -0.18622382f, -0.09521724f, -0.21230662f, 0.11845849f, -0.01554104f, 0.02767553f, 
    0.12092479f, 0.06412898f, 0.18186556f, -0.14458072f, 0.12969147f, -0.07790051f, 0.51161999f, 0.16326667f, 
    0.14230216f, 0.41368002f, 0.10931262f, 0.13297585f, -0.32740599f, 0.21831973f, -0.31928265f, -0.06423090f, 
    -0.06856689f, 0.81164271f, -0.02827424f, -0.05643348f, -0.13664936f, 0.16935419f, 0.09878973f, -0.25665489f, 
    0.03345123f, 0.04671973f, -0.00446205f, -0.19101000f, 0.25524437f, -0.68953693f, -0.66278136f, -0.73105252f, 
    0.02532505f, -0.07821513f, -0.31226906f, 0.00855860f, 0.48701367f, 0.00510856f, 0.09752356f, 0.48753023f, 
    0.14369619f, 0.00207228f, -0.11294185f, 0.15901040f, -0.08074611f, -0.04597841f, -0.64900059f, 0.00137521f, 
    -0.15528141f, 0.28357172f, -0.12184261f, 0.01781018f, 0.10310561f, 0.02020014f, 0.11634330f, 0.08709285f, 
    -1.27247643f, -0.04250215f, -0.13542411f, -0.38476831f, 0.08789409f, 0.35226113f, 0.11332069f, -0.42120725f, 
    0.01982507f, 0.07447467f, 0.13057406f, -0.01541430f, -0.05467037f, 0.08759719f, -0.52562571f, 0.56206340f, 
    -0.02185149f, -0.39150074f, -0.03852420f, 0.36069423f, -0.13672121f, 0.17940415f, 0.30887488f, -0.11212070f, 
    0.01435834f, 0.44230404f, 0.33080438f, -1.28398645f, 0.05343199f, 0.03944599f, -0.40928549f, 0.25463986f, 
    -0.60501873f, 0.00870015f, -0.00584938f, -0.58838415f, 0.10110455f, 0.22549663f, 0.19562446f, -1.44321144f, 
    0.00773867f, 0.07552352f, -0.01723152f, -0.06352202f, 0.33900616f, -0.03327811f, 0.22986680f, -0.99941403f, 
    0.03616399f, 0.03057180f, -0.58416229f, -1.16978288f, -0.31875136f, -0.13613515f, 0.34768382f, -0.10767381f, 
    -0.11919992f, -0.88951451f, 0.17699912f, -0.03041111f, -0.13186964f, -0.10044561f, -0.04367512f, -1.25063038f, 
    -0.23953620f, 0.35132530f, 0.19986723f, -0.00624432f, -0.31631711f, -0.81231809f, 0.28456083f, 0.14633246f, 
    0.20538297f, -0.26677540f, -0.28376824f, 0.10735203f, 0.08246398f, 0.00493373f, 0.31666294f, 0.02968042f, 
    -0.14545961f, -0.15100326f, 0.32807031f, -0.11698987f, -0.23745126f, -0.30919760f, 0.75719601f, 0.03459689f, 
    0.09190438f, -0.73015821f, -0.10701446f, 0.03736304f, -0.08222795f, -0.17744611f, -0.04632268f, 0.03410303f, 
    0.13441946f, -1.67175877f, 0.02407207f, -0.21610963f, -0.95421666f, 0.32975116f, 0.32422885f, 0.62576717f, 
    -0.13926205f, 0.22197422f, -0.22009039f, -0.09219033f, -0.00201713f, 0.05686184f, 0.07673375f, 0.30256346f, 
    -0.06866697f, 0.09527078f, -0.04509769f, -0.23036145f, 0.20234223f, -0.21696126f, 0.24042650f, -0.10189474f, 
    -0.08224569f, 0.04426513f, 0.18822540f, -0.33474144f, 0.06411631f, 0.02530369f, -0.93499511f, -0.56709617f, 
    0.05889567f, -0.05958349f, 0.06369422f, 0.25511172f, 0.06984232f, -0.04076435f, 0.05011763f, -0.29669279f, 
    -0.01048644f, -0.14297184f, -0.20725991f, 0.25757539f, -0.34453911f, 0.06251918f, -0.21772905f, -0.23687339f, 
    -0.34857610f, 0.20039150f, -1.12434936f, -0.10504190f, 0.47388238f, 0.02707174f, -0.10225635f, -0.17278479f, 
    -0.01823693f, -0.61994892f, -0.49978328f, 0.16701539f, 0.05098945f, -0.64484507f, -0.05117145f, 0.00266407f, 
    -0.05268026f, -0.14867516f, 0.09727548f, 0.28811154f, -0.06321139f, -0.86060917f, 0.24949563f, -0.38938534f, 
    -0.17259260f, 0.10182470f, 0.18556599f, 0.33377090f, -0.07130350f, -0.13057972f, -0.06351551f, -0.33605850f, 
    -0.21740426f, -0.08196749f, -0.07207939f, 0.11108924f, -0.49028519f, -0.14687590f, 0.15224007f, 0.04398063f, 
    0.12248798f, 0.07621129f, 0.05408323f, 0.10684345f, -0.30306327f, 0.17859165f, 0.16334455f, -0.19439140f, 
    -0.26977575f, -0.24363348f, -0.07075298f, 0.07095721f, 0.06236744f, -0.33671212f, -0.11018439f, -0.07324304f, 
    -0.04588991f, -0.12701505f, 0.15387501f, 0.16835281f, 0.14611880f, 0.01859825f, -0.27660343f, 0.08639143f, 
    0.27796698f, 0.05284012f, -0.14146999f, 0.27684438f, 0.09489689f, -0.17300883f, -0.40860495f, -0.16900307f, 
    -0.09712944f, -0.50872141f, 0.42611378f, -0.10621602f, 0.10109267f, -0.00112631f, -0.31364343f, 0.10811649f, 
    -0.19964081f, -0.05910592f, 0.03302772f, 0.01586577f, 0.07632712f, -0.54003012f, -0.22224206f, -0.50790083f, 
    0.01079387f, 0.08166927f, 0.00414029f, -0.13174172f, -0.06975697f, -0.00298086f, 0.07689747f, -0.26123127f, 
    0.13057828f, -0.01687229f, 0.58877242f, 0.16680388f, 0.17890313f, -0.33080158f, -0.56422520f, -0.10632402f, 
    0.08845981f, -0.04349237f, 0.14234257f, 0.05191129f, -0.34912008f, -0.09581494f, 0.05168123f, -0.29278573f, 
    0.16393889f, -0.47499734f, 0.23665233f, 0.01626931f, 0.13336933f, 0.10082260f, 0.20922314f, 0.23369031f, 
    -0.66823184f, -0.04978651f, 0.01667066f, -0.90401137f, -0.44370288f, -0.09559984f, -0.40526736f, 0.35257214f, 
    0.37879783f, -0.29915479f, -0.18393895f, -0.22138128f, -0.02155975f, 0.36070451f, -0.06623243f, -0.17507382f, 
    0.09667822f, -0.32648560f, 0.13615456f, -1.22576165f, -0.00835341f, 0.21819404f, -0.08952478f, -0.11316104f, 
    -0.14179642f, -0.34052274f, 0.02670783f, -0.29599851f, 0.20952386f, 0.49543798f, 0.20089290f, -1.08370042f, 
    0.02480503f, -0.66656172f, 0.34903666f, 0.29112861f, -0.71365595f, 0.10357342f, 0.24755248f, -0.49393585f, 
    0.14132002f, 0.08622426f, -0.94101548f, -0.98942643f, -0.33080810f, 0.27391970f, 0.38126266f, -0.01131727f, 
    -0.07086730f, -1.26341999f, -0.24690993f, 0.25993186f, 0.14009893f, 0.41187647f, 0.12197652f, 0.07283749f, 
    -0.39781433f, 0.49665999f, -1.31929004f, -1.18011475f, -0.15730040f, -0.31943396f, -0.80902863f, 0.03619289f, 
    -0.19663732f, 0.18313161f, 0.00169451f, -1.06426907f, 0.31713447f, -0.11262042f, -0.25032467f, -0.02146505f, 
    -0.50155276f, -0.92966652f, -0.00058949f, -0.59910041f, -0.43867365f, 0.04644173f, 0.14733778f, -0.06769369f, 
    -0.01778309f, 0.44495070f, -0.55202866f, 0.14107847f, 0.07931431f, 0.03285413f, -0.20387727f, -0.70934337f, 
    0.72612464f, -0.12907188f, 0.07165757f, 0.64426059f, 0.07297289f, -0.38409424f, -0.02755147f, -0.58163482f, 
    0.09300417f, -1.00520861f, 0.00458647f, -0.12401912f, -0.28417820f, 0.00637028f, -0.22159430f, -0.64539045f, 
    0.31587657f, -0.02120081f, -0.17259243f, -0.44111833f, 0.18151493f, 0.35878244f, -0.29574487f, 0.05727953f, 
    0.35901210f, 0.42232370f, -0.07580413f, 0.33797032f, 0.15097021f, -1.00685441f, -0.15193592f, 0.17346050f, 
    -0.42822936f, 0.57772291f, -1.41757774f, -0.59228355f, 0.25073373f, -0.75550622f, -0.27095267f, -0.45961297f, 
    -0.86125690f, -0.19433618f, 0.06898740f, -0.13274930f, 0.23569934f, -0.00924541f, -0.85727710f, -0.31564528f, 
    -0.03122799f, -1.16414821f, 0.41830188f, 0.21531594f, -0.07882644f, -1.11749518f, -0.03468086f, -0.19022356f, 
    0.08405999f, -0.52120781f, 0.42781910f, 0.22063430f, 0.04795948f, 0.06792254f, 0.12419870f, 0.11884369f, 
    0.50473583f, 0.12310543f, -0.11403117f, -0.14516492f, 0.20732737f, -0.18803141f, -1.19683576f, -0.38672608f, 
    0.16190821f, -0.79106086f, -0.32993409f, -0.74041408f, -0.81558442f, -0.12405906f, -0.07414906f, -0.02381462f, 
    -0.03483691f, -0.14904422f, -0.14855349f, 0.09865143f, 0.39736447f, -0.04044475f, -0.40332830f, 0.11235201f, 
    0.36934623f, 0.15060113f, -0.05705772f, -0.25565982f, 0.00033001f, -0.40745938f, 0.01431241f, -0.19413655f, 
    -0.68483138f, 0.51772094f, 0.19673315f, 0.14038408f, 0.07517467f, -0.23379019f, 0.18086791f, -0.06634933f, 
    -0.35297486f, -0.81911755f, -0.05223774f, 0.07999689f, -0.53398061f, -0.12532777f, -0.74056572f, -0.29330426f, 
    -0.87105978f, -0.68502438f, -0.46179706f, -0.50955313f, 0.31083277f, 0.35482004f, -0.24647851f, -0.00411039f, 
    0.03715085f, -0.73339295f, -0.77202964f, 0.09975283f, 0.10986774f, -0.08991349f, -0.34081471f, 0.08436699f, 
    -0.74222076f, 0.06075955f, -0.12093303f, -0.05300628f, 0.00634759f, 0.46029589f, 0.48810264f, -0.13592026f, 
    0.02897372f, 0.02910232f, 0.41800630f, -1.36306989f, -0.43977207f, 0.03300028f, -0.06886982f, -0.04699345f, 
    -0.00724577f, -0.04839909f, -0.10736816f, -0.18800271f, -0.71402603f, 0.14000513f, 0.22051594f, 0.10345717f, 
    -0.33096948f, -0.36373293f, 0.15335204f, 0.15823764f, 0.05345133f, 0.55399972f, -0.07289129f, 0.19337760f, 
    0.27443829f, -0.76551396f, -0.20041180f, 0.19784480f, -0.01590736f, -0.65455914f, -0.12355955f, -0.33779418f, 
    -0.39735270f, 0.05170977f, -0.11006337f, 0.01956188f, -0.12919973f, -0.10319557f, -0.11345284f, -0.87349796f, 
    -0.66103417f, -0.30151358f, 0.13724957f, 0.21883540f, 0.46448076f, -0.15849210f, -0.24127392f, 0.07105428f, 
    -0.01128236f, 0.17795451f, 0.03992713f, 0.28360927f, -0.07602453f, -0.27866676f, -0.33003691f, 0.24312541f, 
    -0.07843415f, -0.72348648f, 0.04060638f, 0.29343924f, -0.59003276f, 0.16110872f, -0.44926605f, -0.45687699f, 
    0.11206912f, -0.10887379f, -0.49808091f, -0.05529891f, -1.21862769f, 0.06683704f, 0.09794240f, -0.20658517f, 
    -0.23740788f, -0.00060961f, -0.70143342f, 0.19819561f, 0.37092242f, -0.75368315f, -0.26857150f, -0.04828392f, 
    -0.55689222f, 0.36836269f, -0.03095969f, 0.17034459f, -0.39561707f, 0.48829687f, 0.24537313f, -0.21024992f, 
    -0.49652034f, -0.76920336f, 0.15896267f, 0.16675702f, -0.55816746f, 0.49922827f, 0.14648180f, -0.12910149f, 
    0.34045050f, -0.71474981f, -0.61605769f, -0.17043273f, -0.14887719f, -0.08750250f, 0.15641910f, -0.28596157f, 
    0.15384895f, 0.42845798f, 0.32622150f, -0.64535105f, 0.13283259f, -0.49240309f, 0.33819532f, -0.22221774f, 
    0.02237055f, 0.50302202f, 0.33816943f, -0.51925045f, -0.02250789f, -0.01939952f, 0.05577030f, 0.12510540f, 
    0.32292914f, -0.55938381f, -0.11241767f, -0.13718359f, -0.01047748f, 0.08825709f, 0.09475356f, -0.42107132f, 
    -0.16018444f, 0.19515634f, -0.20505029f, -1.12730849f, 0.04726880f, 0.00284599f, -0.08009114f, 0.54892540f, 
    0.07469463f, 0.05657163f, 0.39084083f, -0.48621708f, -0.03702871f, 0.02171595f, 0.45470172f, 0.06816611f, 
    0.12207990f, 0.13699110f, -0.43682817f, -0.33074498f, 0.17783055f, 0.09134631f, 0.02333123f, 0.31432706f, 
    -0.30693907f, 0.02845882f, 0.09539860f, -0.03982933f, 0.06660960f, 0.32553837f, -0.55382288f, 0.12952702f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.31790116f, 0.25055936f, 0.08013501f, -0.04264336f, -0.00754093f, -0.07010116f, 0.00430648f, -0.24118766f, 
    0.10750497f, 0.26247424f, 0.01744675f, -0.11813962f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
