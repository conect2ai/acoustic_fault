#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.61354953f, -0.53246576f, 0.27317733f, 0.04005941f, -0.40214860f, 0.26962972f, 0.08951091f, 0.06494207f, 
    0.05482889f, -0.68939477f, 0.59324723f, -0.26871663f, 0.00300573f, 0.40242350f, -0.15160061f, 0.09132272f, 
    0.03466418f, -0.11109409f, -0.58946389f, -0.29581603f, -0.09322596f, 0.12360047f, 0.68394250f, 0.03547754f, 
    0.16831362f, -0.10165885f, 0.12293232f, -0.11461483f, -0.25288323f, -0.17059417f, 0.43650782f, 0.61853713f, 
    -0.04433326f, -0.19754158f, 0.12157150f, -0.29745510f, 0.48899260f, 0.51791239f, 0.62547696f, -0.42192307f, 
    0.21658856f, -0.32967582f, 0.15251929f, -0.03872553f, -0.11606477f, 0.36638480f, -0.32106707f, 0.09155300f, 
    -0.24923238f, -0.66483933f, -0.35075870f, 0.23057659f, 0.02452097f, 0.32941490f, -0.03384205f, 0.48140091f, 
    -0.02796387f, 0.41313189f, 0.48113233f, -0.45636365f, 0.20089525f, 0.21534218f, -0.19437607f, 0.48723522f, 
    0.41770145f, 0.48914388f, 0.25910684f, 0.08327269f, 0.25763771f, 0.07444426f, 0.36173150f, 0.12696041f, 
    0.07526331f, -0.43794167f, 0.31992429f, 0.43480173f, 0.41816372f, 0.63305157f, -0.15538566f, 0.05343059f, 
    0.18286717f, -0.48276263f, -0.37854677f, -0.40868574f, -0.16326728f, -0.45322371f, -0.21281014f, -0.19049302f, 
    0.04967054f, 0.14828248f, 0.19929378f, 0.21332414f, 0.14381321f, 0.27132559f, -0.20247662f, 0.55806804f, 
    0.17907588f, -0.23004641f, -0.04451643f, -0.59069008f, -0.58948153f, -0.63981187f, 0.05880122f, -0.00012661f, 
    0.43317002f, 0.05867986f, -0.06675182f, 0.09326839f, 0.24942511f, 0.17740883f, -0.18518594f, 0.04790692f, 
    -0.55921847f, 0.57788473f, -0.05185523f, 0.28483230f, -0.07950404f, 0.68606406f, 0.42242363f, -0.07667076f, 
    -0.48207778f, -0.07738810f, -0.37001532f, 0.02635026f, 0.14264293f, 0.19689707f, 0.27644935f, 0.18724434f, 
    0.42133164f, 0.05214836f, -0.52103090f, -0.18380044f, -0.31044424f, -0.09129325f, -0.21599971f, -0.17504683f, 
    -0.13253765f, -0.04201217f, 0.51806659f, -0.15072651f, -0.18241541f, -0.36159512f, -0.28600267f, -0.45011279f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.19630131f, 0.11871231f, -0.18115489f, 0.04054645f, -0.32292172f, -0.31431520f, 0.05276092f, 0.35162675f, 
    0.16038169f, 0.00992317f, 0.06696209f, 0.07366421f, -0.26382163f, -0.08150599f, 0.19183473f, -0.24016339f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.32012370f, 0.05746229f, -0.05192064f, -0.09745041f, 0.14366680f, 0.03401017f, -0.04104824f, -0.20449951f, 
    0.03053031f, 0.41571754f, -0.00292526f, -0.12567672f, -0.00411551f, 0.05700126f, 0.00612688f, -0.14017594f, 
    -0.08885504f, -0.04858752f, 0.31814721f, 0.21934053f, 0.04801982f, -0.21113923f, -0.04269033f, -0.16941720f, 
    -0.13097128f, -0.02848742f, -0.07936233f, 0.05191427f, 0.10360248f, -0.07622334f, -0.01965034f, -0.08892705f, 
    -0.07101438f, 0.20581768f, 0.11122778f, 0.15266970f, 0.20036724f, 0.13607845f, -0.31879711f, -0.11015010f, 
    -0.09241354f, -0.07178694f, 0.17233092f, 0.00962634f, -0.17700085f, -0.06866647f, 0.00233320f, -0.10150190f, 
    0.18755966f, 0.09011866f, -0.00907824f, 0.07374953f, 0.17491034f, 0.03953728f, -0.11402648f, 0.06034885f, 
    0.10777958f, -0.31760052f, 0.09322692f, -0.04911454f, -0.03478247f, -0.00736864f, 0.20090027f, 0.06596707f, 
    0.09487566f, -0.01116918f, 0.01151700f, -0.02983637f, 0.00688353f, -0.09539844f, -0.02271756f, -0.19658336f, 
    0.17217840f, 0.20179862f, -0.07439449f, -0.03936607f, 0.08031090f, 0.11966150f, 0.09820173f, 0.02296779f, 
    0.01911338f, -0.39513695f, -0.06248973f, -0.16499051f, 0.15015307f, 0.10911376f, -0.09694725f, 0.20078018f, 
    0.02111433f, -0.07283054f, -0.09432594f, -0.04194400f, -0.05792752f, 0.05808130f, 0.13526671f, 0.09866433f, 
    -0.00424106f, -0.05334555f, -0.09858592f, 0.19854730f, -0.00132137f, -0.35011515f, -0.01795943f, 0.08383350f, 
    0.24792884f, 0.01992480f, -0.13864237f, -0.09279977f, -0.15202171f, -0.26775855f, -0.00553439f, -0.00860659f, 
    -0.02797309f, -0.03142203f, -0.14343593f, 0.07342324f, 0.13570653f, 0.33553123f, 0.03452432f, -0.08540244f, 
    0.17209329f, 0.01496602f, 0.06450778f, -0.19455029f, -0.01474300f, -0.00132197f, 0.02859737f, 0.12070960f, 
    0.05794124f, -0.07179318f, 0.03036598f, -0.10528289f, 0.18824989f, 0.10116426f, 0.04156274f, -0.01450923f, 
    -0.26289758f, -0.08715916f, -0.02188291f, 0.00224193f, 0.11382353f, -0.07932260f, 0.02190372f, 0.01087723f, 
    0.01665658f, -0.00482679f, 0.03671943f, 0.06661816f, -0.08693159f, 0.02666120f, -0.05478799f, -0.00793515f, 
    -0.06160656f, 0.01749950f, -0.01357748f, 0.04663843f, -0.01186228f, -0.02004703f, -0.06902748f, -0.02467244f, 
    -0.08667950f, -0.04175439f, 0.06326753f, -0.04459266f, 0.01000508f, -0.07426637f, -0.07207201f, 0.00432474f, 
    -0.06170661f, 0.06938385f, -0.07787570f, 0.03965262f, 0.01857122f, 0.05304176f, -0.08133415f, -0.06207287f, 
    -0.04162807f, -0.04917315f, -0.04996010f, -0.00796796f, 0.01094607f, 0.01197069f, 0.01423276f, 0.00038782f, 
    -0.01867670f, -0.03624909f, -0.04473786f, 0.07517614f, 0.04159053f, -0.04789085f, -0.05065396f, 0.01861201f, 
    -0.05479512f, -0.07174101f, -0.06690909f, 0.07013133f, 0.05004549f, -0.01680923f, 0.00474157f, -0.02571236f, 
    0.01642083f, 0.02794635f, -0.07276955f, -0.05284443f, -0.04954357f, 0.05053645f, -0.04915495f, 0.03144090f, 
    -0.02736321f, -0.07724100f, 0.04478887f, 0.07230354f, -0.04919051f, -0.07120278f, -0.03088697f, 0.00577497f, 
    -0.04937011f, -0.07727454f, 0.03702620f, 0.01966833f, 0.01194751f, -0.04122875f, -0.08346014f, 0.01622483f, 
    0.05817230f, 0.03592021f, -0.07615211f, -0.06481513f, 0.06253181f, -0.01890179f, -0.06170047f, 0.04643375f, 
    -0.03004931f, -0.01856251f, -0.06996629f, -0.08728107f, -0.00656719f, 0.03959255f, -0.00715453f, -0.05949824f, 
    0.04530344f, 0.07066911f, 0.03360630f, -0.06726334f, -0.06458788f, -0.02662734f, 0.06756722f, 0.03301881f, 
    -0.06916647f, 0.04046003f, 0.01266089f, -0.07980288f, -0.04979246f, 0.02759298f, -0.04399998f, 0.03672864f, 
    0.00343468f, -0.03578727f, -0.00585134f, -0.03838828f, 0.00369597f, 0.00239088f, 0.05929278f, 0.01850880f, 
    -0.03290348f, -0.06256355f, -0.03204718f, 0.02355028f, -0.02217565f, -0.01203757f, 0.05340376f, -0.04298659f, 
    -0.06332111f, 0.05862827f, 0.01635580f, 0.02391735f, -0.01716848f, -0.02531790f, 0.01852398f, -0.08310843f, 
    0.04236798f, 0.04670019f, 0.05129438f, -0.05205907f, 0.04539425f, -0.01421002f, 0.04570332f, -0.04038514f, 
    -0.02283364f, -0.12851723f, 0.20115060f, -0.07071967f, -0.05334822f, -0.12905525f, -0.04165191f, 0.05688150f, 
    0.05713405f, -0.30824551f, 0.21354374f, -0.09149891f, -0.03218896f, -0.10929309f, 0.04396446f, 0.08272687f, 
    -0.05782199f, 0.02616129f, -0.12554546f, -0.12759405f, 0.24269018f, -0.17294732f, -0.12050157f, 0.10791913f, 
    0.07163667f, -0.05234785f, -0.01277973f, 0.21462385f, -0.11363507f, 0.05785669f, -0.07322945f, -0.08052282f, 
    -0.07634697f, -0.01370812f, -0.06056174f, -0.03354835f, -0.21395269f, -0.01291017f, -0.25448242f, 0.12453423f, 
    0.14616285f, -0.00419672f, -0.06610575f, 0.01823532f, 0.11136075f, 0.11634737f, 0.06387267f, -0.39723516f, 
    0.11019541f, 0.03728968f, 0.04160002f, 0.10055729f, 0.05110024f, -0.00497278f, 0.22221771f, -0.04951268f, 
    -0.24772805f, 0.00547216f, -0.17774460f, -0.03702428f, 0.03416267f, 0.02111496f, 0.00525686f, 0.15549366f, 
    0.31735748f, 0.05904456f, 0.09852292f, -0.01942692f, -0.12770601f, 0.05081192f, 0.02734824f, -0.09188269f, 
    0.13641994f, 0.09131994f, 0.10560165f, 0.09497157f, 0.01565092f, -0.09152871f, -0.05945111f, 0.18793659f, 
    0.05726715f, -0.30785233f, -0.18504816f, 0.19758035f, 0.14794303f, 0.01029630f, -0.02991241f, -0.01562528f, 
    0.05359393f, 0.02548108f, -0.14496374f, 0.13758554f, -0.06834455f, -0.10431027f, 0.15121679f, -0.06490316f, 
    -0.25654513f, 0.09401318f, 0.09564283f, -0.20556711f, -0.00847507f, 0.52165419f, -0.02545797f, -0.00221032f, 
    0.01113362f, -0.06447282f, 0.04140103f, 0.11287045f, -0.19963878f, -0.26167232f, -0.35574955f, 0.07436073f, 
    0.18754977f, 0.01799790f, 0.01188986f, 0.05870675f, -0.09557370f, 0.11302634f, -0.01476780f, -0.15980402f, 
    0.14130984f, 0.00468613f, -0.01735750f, -0.03490745f, -0.04368211f, -0.16604294f, 0.02290692f, -0.00576048f, 
    -0.21020034f, 0.12982963f, 0.01368897f, 0.13187177f, 0.07879638f, 0.05029561f, 0.05786857f, -0.00233832f, 
    -0.29123670f, -0.15433824f, -0.16608874f, -0.08672917f, -0.19332679f, -0.02890384f, 0.11668576f, 0.05240824f, 
    0.07409977f, -0.10464124f, 0.13621958f, -0.00736781f, 0.09499426f, -0.04527631f, 0.01720822f, -0.07873669f, 
    -0.04706088f, 0.37782115f, 0.07146294f, -0.02301008f, 0.00373696f, -0.07709917f, 0.02383528f, 0.08489151f, 
    0.04158333f, 0.00700021f, 0.12426154f, 0.28376433f, 0.23507991f, -0.09770502f, -0.07782619f, -0.10912636f, 
    0.13531345f, 0.02399689f, 0.04607642f, -0.18782566f, 0.08297118f, -0.04495706f, 0.07162999f, -0.10434739f, 
    -0.00798492f, -0.10602812f, 0.05061075f, 0.05403329f, -0.33733305f, 0.27090746f, 0.18366277f, -0.09879725f, 
    -0.05952058f, -0.03640361f, -0.10822640f, 0.06630906f, -0.01113514f, 0.08236960f, -0.08274449f, -0.12601168f, 
    -0.15011644f, 0.06932460f, -0.09909603f, 0.02546148f, 0.02086878f, -0.14842214f, 0.28464735f, 0.06679042f, 
    -0.01004171f, -0.06472837f, -0.06789934f, -0.08154298f, -0.18844591f, -0.06936381f, -0.09569637f, 0.06601787f, 
    -0.09407073f, -0.00966812f, -0.04669651f, 0.03130521f, 0.22956760f, 0.13493384f, 0.11051177f, -0.09451101f, 
    -0.04681325f, 0.00092131f, -0.20888676f, 0.01890969f, 0.04590910f, 0.04965537f, -0.09307802f, 0.08738992f, 
    -0.05548126f, 0.04023565f, -0.12058732f, -0.08558267f, 0.07292215f, -0.06697721f, -0.17652757f, 0.07270744f, 
    0.14433259f, -0.05100287f, -0.09038869f, -0.14882022f, -0.33196050f, -0.02204501f, 0.02862054f, 0.23659199f, 
    -0.04642140f, -0.00773090f, -0.13799401f, 0.17350420f, 0.04782808f, 0.20646024f, -0.07223492f, 0.04086399f, 
    -0.02479929f, -0.06052680f, 0.00043181f, 0.04300852f, 0.14326538f, 0.05046570f, -0.15465750f, -0.03540103f, 
    -0.02789319f, 0.05953781f, 0.19801918f, -0.05598777f, -0.07411496f, 0.01827015f, -0.08165366f, -0.08714239f, 
    0.00060587f, -0.02581189f, -0.23156074f, 0.08520868f, -0.14221281f, 0.02086588f, 0.02804912f, -0.28840306f, 
    -0.07463367f, 0.09107842f, 0.02315985f, -0.00465331f, 0.08312344f, 0.04292228f, 0.08433651f, 0.40322751f, 
    -0.07352620f, 0.37273407f, -0.09722355f, 0.13419326f, 0.08360321f, -0.04646645f, -0.17631610f, 0.01845285f, 
    -0.21586245f, 0.18332554f, -0.11957178f, 0.06602762f, 0.06057684f, 0.13969792f, -0.00587593f, 0.05772490f, 
    -0.00948541f, -0.07501605f, -0.00036292f, 0.02622291f, -0.13251889f, 0.03619434f, 0.10401177f, -0.16638450f, 
    -0.02391819f, -0.02699123f, -0.08387191f, -0.07272094f, 0.02450360f, 0.09853964f, -0.10743811f, 0.11158662f, 
    -0.07329225f, 0.17237361f, 0.09236558f, -0.18937938f, -0.24388023f, -0.02164313f, -0.10085535f, -0.08093846f, 
    -0.00836040f, -0.17562447f, -0.07267857f, -0.05649861f, 0.51617604f, -0.00936709f, -0.08119024f, -0.14636590f, 
    -0.00352442f, -0.00396581f, 0.01181633f, -0.04910315f, -0.02456669f, 0.07433331f, -0.20892772f, -0.18724380f, 
    0.16780964f, -0.19421801f, -0.01196894f, 0.10804791f, 0.06644609f, -0.10321516f, 0.12908453f, -0.10300204f, 
    -0.16810915f, 0.08213386f, 0.04809824f, -0.03633241f, -0.06590062f, 0.04461766f, 0.01478554f, 0.30280283f, 
    0.00038547f, 0.00886426f, 0.08345070f, -0.00453252f, -0.00378499f, 0.00178616f, 0.06275559f, -0.00521098f, 
    -0.56480068f, -0.02036545f, 0.00302328f, 0.03698523f, 0.07472952f, 0.04003659f, 0.04007116f, -0.14050002f, 
    0.05997042f, 0.26574808f, 0.12925717f, -0.32789844f, -0.07315248f, -0.00826576f, -0.01058682f, -0.03322649f, 
    0.14842580f, -0.03251508f, 0.04968827f, -0.30232698f, -0.11876954f, 0.06339955f, 0.11554312f, 0.04599649f, 
    0.04527571f, 0.12788297f, -0.03925080f, -0.09820826f, 0.04049393f, 0.00743854f, -0.09668227f, -0.05705534f, 
    -0.04069730f, 0.00011591f, -0.07295302f, 0.04033794f, 0.15965171f, 0.14741988f, -0.01974824f, 0.21397093f, 
    0.03894289f, -0.08046833f, 0.05449410f, -0.07528382f, 0.02314884f, 0.21771827f, 0.33156145f, 0.03552997f, 
    0.18860196f, -0.03590408f, 0.08612695f, 0.24571869f, -0.01323764f, -0.15233549f, 0.08379368f, 0.00140709f, 
    -0.04579392f, 0.13619681f, -0.01303280f, -0.07328452f, 0.05246826f, 0.09052362f, 0.12797992f, -0.29917482f, 
    -0.20400271f, 0.00932325f, -0.10056510f, 0.00305137f, 0.12185220f, -0.17469682f, 0.01885385f, -0.01803808f, 
    -0.07549066f, -0.01550818f, -0.07589754f, -0.04064192f, 0.05340466f, 0.00139902f, 0.01882123f, -0.07470617f, 
    0.04010481f, -0.01217476f, 0.05043339f, -0.03627761f, -0.05968320f, -0.00013767f, -0.10346327f, -0.02978033f, 
    0.01952699f, -0.00087640f, -0.07496772f, 0.00230675f, -0.06261864f, 0.00641909f, -0.10165951f, 0.05060300f, 
    -0.07295290f, -0.04981166f, 0.02278929f, -0.03673919f, -0.09590704f, -0.00978349f, -0.09136131f, -0.07326861f, 
    -0.07244959f, 0.03748533f, -0.00536753f, 0.00303468f, -0.04125781f, 0.06133446f, -0.06624255f, 0.01674891f, 
    0.00333633f, -0.03451330f, 0.00141937f, -0.01799159f, 0.07641951f, 0.01925249f, 0.03938864f, -0.06964211f, 
    -0.09252991f, -0.04753318f, 0.03038179f, -0.01802145f, 0.00266792f, 0.04095726f, 0.04842374f, -0.02163613f, 
    -0.07978980f, -0.10099497f, -0.03156455f, -0.06227316f, 0.01971840f, 0.02085111f, -0.03164632f, -0.05632025f, 
    -0.04356280f, -0.05918285f, -0.06769639f, -0.00422254f, 0.00831133f, -0.02210079f, 0.07148117f, -0.02336880f, 
    0.05328169f, 0.03048728f, -0.08145973f, -0.03467270f, -0.03191428f, -0.05068814f, -0.02414084f, -0.08884511f, 
    -0.04933878f, -0.00955715f, -0.00535522f, -0.06680290f, -0.00244083f, 0.01206975f, -0.02120356f, -0.01581660f, 
    -0.05489712f, -0.03207646f, -0.02369374f, -0.03372616f, 0.03831778f, 0.03982861f, -0.03977187f, -0.04286456f, 
    -0.08470669f, -0.06672970f, -0.05105752f, 0.02162326f, -0.01999007f, 0.03840917f, -0.05499503f, 0.04563110f, 
    -0.07581841f, -0.06336574f, 0.03760412f, -0.09319300f, -0.09858895f, -0.07088868f, -0.00976892f, -0.09645566f, 
    -0.05225863f, -0.02088356f, 0.00761266f, 0.00753665f, 0.03153714f, -0.07910415f, 0.05420158f, 0.02105405f, 
    -0.04923678f, -0.07055913f, -0.02902398f, -0.06989953f, 0.01742993f, 0.01486898f, -0.10247632f, -0.09860682f, 
    -0.07829066f, -0.09154496f, 0.03251332f, -0.05237553f, -0.07307593f, -0.06117361f, -0.02070647f, -0.05645623f, 
    0.00467115f, -0.01550986f, 0.06960128f, -0.06574935f, -0.03524914f, -0.04964268f, -0.08726442f, 0.02980584f, 
    -0.13832262f, 0.10652947f, -0.07971736f, -0.08500182f, -0.18212894f, -0.13356906f, -0.09078524f, 0.15677841f, 
    0.08046983f, 0.17017183f, 0.02134796f, -0.01980115f, 0.01327936f, -0.03490887f, -0.05109683f, 0.02150803f, 
    -0.00735206f, 0.04740134f, -0.07036902f, 0.20287342f, 0.13958924f, -0.02493856f, -0.05440904f, -0.16144884f, 
    -0.04942494f, 0.21488149f, -0.02775011f, 0.02775336f, -0.09253154f, -0.17268389f, -0.03496546f, 0.10195295f, 
    -0.26626778f, 0.04636116f, 0.05074121f, -0.05735626f, 0.00269502f, -0.48622480f, 0.29675046f, 0.12004235f, 
    0.18236782f, 0.21363583f, -0.05648388f, -0.03161085f, -0.07880063f, 0.30998671f, 0.20401245f, 0.21339716f, 
    0.00642162f, -0.02910261f, 0.06353943f, 0.01863110f, 0.05163602f, 0.02727462f, -0.01133656f, -0.15187478f, 
    -0.09209092f, -0.18654738f, 0.00484883f, 0.06678765f, 0.04477033f, 0.10014042f, 0.00751369f, -0.46795407f, 
    -0.24432185f, -0.07166032f, -0.04009284f, -0.04380007f, 0.16066553f, -0.05003330f, 0.01113604f, 0.10141081f, 
    0.06410352f, 0.13608861f, 0.08833258f, 0.15774314f, -0.09677767f, 0.00199249f, 0.12155039f, 0.19500776f, 
    0.03432027f, -0.03257892f, -0.00517052f, 0.10300554f, -0.15325187f, 0.03497394f, 0.01007180f, 0.01947008f, 
    -0.02894383f, -0.02729248f, -0.22080557f, -0.17547220f, 0.13458443f, 0.08289079f, 0.16697626f, 0.09668206f, 
    -0.03753430f, -0.01895672f, -0.01475585f, 0.18388999f, 0.17644170f, -0.05529555f, -0.01931593f, -0.01232270f, 
    0.02055886f, -0.04863515f, 0.10881836f, 0.03024383f, -0.13734746f, -0.31327990f, 0.04909325f, 0.00627111f, 
    -0.19498017f, -0.04107071f, -0.04069370f, 0.05720578f, 0.04397592f, 0.20606500f, -0.25168145f, -0.09237935f, 
    0.09307800f, 0.10306172f, -0.04441806f, 0.05955294f, 0.06444491f, 0.07591501f, -0.33970785f, -0.12574643f, 
    0.14780478f, 0.12594461f, 0.04014979f, 0.05436082f, 0.03031348f, 0.00234613f, -0.15362802f, -0.08040567f, 
    0.02995794f, -0.20195127f, -0.04862601f, -0.05829059f, 0.01589280f, -0.09801828f, 0.04419549f, -0.09390882f, 
    -0.18015526f, -0.39447978f, -0.22309248f, 0.06434035f, -0.07931598f, 0.00099466f, -0.12322964f, -0.05994379f, 
    -0.07290182f, 0.14383267f, -0.01098115f, -0.08871146f, 0.02833790f, -0.01979535f, -0.13055950f, -0.02537070f, 
    -0.01519963f, -0.05345192f, -0.09097432f, -0.30361485f, -0.28152618f, 0.11919437f, 0.05362791f, 0.03597829f, 
    0.10335090f, -0.04756429f, -0.08101163f, -0.14762141f, -0.14307112f, -0.03705405f, 0.25576442f, 0.02545710f, 
    0.11153003f, -0.03420262f, 0.01076548f, -0.02770822f, 0.00982540f, 0.36936459f, 0.32669801f, -0.01222123f, 
    -0.01819874f, -0.11118658f, 0.03958275f, 0.10513348f, -0.03846934f, -0.03901888f, -0.06812721f, -0.17001203f, 
    -0.16652305f, 0.02194643f, -0.02238379f, 0.04057932f, 0.06240678f, 0.06333748f, -0.13057461f, 0.02904997f, 
    -0.14073102f, -0.01225733f, 0.00133733f, -0.12340157f, -0.04423614f, 0.01684930f, -0.05219165f, -0.05873326f, 
    0.02112815f, 0.31876147f, -0.05667366f, 0.05622224f, 0.05450266f, -0.00199680f, 0.00817619f, -0.02195912f, 
    -0.00264177f, -0.16165867f, -0.08227706f, 0.03283649f, 0.15332901f, 0.00777610f, -0.05576273f, -0.07938127f, 
    0.08271322f, -0.09692421f, -0.01145648f, -0.06906734f, 0.15660140f, -0.00276138f, -0.03607646f, -0.04224027f, 
    0.03307867f, 0.03935410f, -0.13065277f, -0.08667822f, 0.06782407f, -0.06325860f, 0.02585172f, 0.19492245f, 
    0.08599950f, 0.09965714f, -0.06180564f, -0.15076050f, -0.07271357f, -0.15204152f, -0.04822979f, 0.12819736f, 
    0.04370272f, 0.01863674f, -0.03501950f, -0.01855509f, -0.32099706f, -0.01509553f, 0.09653969f, -0.08317092f, 
    -0.01942341f, -0.02257400f, 0.17262761f, -0.01018743f, 0.00904223f, 0.25423348f, 0.23568642f, 0.23615192f, 
    0.06499704f, 0.00255488f, -0.07659371f, -0.02095289f, -0.06429293f, 0.09172042f, 0.15470293f, 0.19295275f, 
    0.26126817f, 0.04532792f, 0.15682681f, -0.03731512f, 0.16535081f, 0.03217955f, 0.10632089f, -0.11124789f, 
    -0.00995052f, -0.33709446f, -0.09510388f, 0.03999312f, 0.01565942f, 0.16226313f, -0.13836809f, 0.04243920f, 
    -0.19214445f, 0.20104578f, -0.00443259f, -0.09316716f, 0.00153923f, -0.00579667f, 0.10385535f, 0.22648536f, 
    -0.02308730f, -0.21277949f, 0.04713587f, 0.18550257f, -0.03607580f, 0.00474544f, -0.07294808f, -0.14830559f, 
    -0.01725532f, -0.15451938f, 0.05327981f, 0.29991299f, -0.02293659f, 0.18234693f, 0.15095553f, -0.16235927f, 
    -0.06987287f, -0.05138556f, -0.06685800f, 0.29735026f, -0.01551362f, 0.07050176f, -0.02614098f, 0.10730428f, 
    -0.05667469f, 0.07941739f, 0.05611818f, -0.01119400f, -0.09107120f, -0.34922099f, -0.01389556f, 0.05139787f, 
    -0.07787669f, 0.21043926f, -0.06570522f, 0.04435381f, 0.13001353f, 0.20236236f, -0.40471545f, -0.09317032f, 
    -0.07473781f, -0.13364470f, 0.07087276f, 0.07575233f, -0.10961999f, -0.19287816f, 0.05315956f, 0.03849054f, 
    -0.18421233f, -0.13366181f, -0.02611706f, -0.01497228f, 0.10911038f, -0.16213377f, 0.09314349f, 0.09909369f, 
    0.05724507f, -0.00720772f, 0.11781323f, -0.03857156f, -0.17698044f, 0.18021271f, 0.04396239f, 0.18995070f, 
    -0.22825338f, -0.18648995f, 0.04137013f, -0.06183814f, 0.16728808f, -0.10641967f, 0.04276437f, -0.01403523f, 
    0.04886175f, 0.15626150f, 0.12431614f, 0.00713431f, 0.05813433f, 0.05157659f, 0.18087393f, -0.09478841f, 
    -0.01763252f, -0.28017935f, 0.03275282f, -0.06535832f, 0.02132292f, -0.01737251f, 0.02087743f, -0.16924557f, 
    0.11138682f, 0.05619520f, 0.14247961f, 0.17693278f, 0.25440460f, 0.09812450f, 0.09244020f, 0.05424669f, 
    -0.07705798f, 0.18163289f, 0.12722749f, 0.01870564f, 0.19180851f, -0.09052006f, -0.16297235f, 0.12503773f, 
    -0.06178055f, 0.08176279f, 0.10200918f, -0.10954534f, -0.08072386f, 0.01261736f, -0.12399104f, 0.08456527f, 
    0.09336157f, -0.05764623f, 0.05806131f, 0.03868803f, -0.14332259f, -0.07591507f, 0.00300102f, 0.11910567f, 
    -0.17134848f, -0.21741813f, -0.03252162f, 0.12765250f, -0.16352347f, -0.17796279f, -0.02815752f, -0.04247586f, 
    0.07396664f, -0.10832462f, 0.08265805f, 0.07440185f, 0.03646332f, -0.33172074f, 0.08744802f, -0.18163469f, 
    0.19886819f, -0.19229619f, -0.01005264f, 0.05441546f, -0.24663016f, -0.18214801f, 0.04058589f, 0.09474321f, 
    0.00457864f, -0.10817353f, 0.11922089f, -0.03318468f, 0.17401284f, 0.09767355f, 0.01216521f, 0.04846315f, 
    0.02165653f, 0.02124170f, 0.21096490f, 0.10004012f, 0.11252557f, -0.01794734f, -0.16451629f, -0.00192694f, 
    -0.05030456f, -0.04751101f, -0.01037405f, 0.07524768f, 0.00189145f, -0.12192342f, 0.08027755f, 0.05793047f, 
    0.07612310f, 0.16909187f, 0.18828951f, -0.03227525f, -0.18067205f, 0.17219104f, -0.12633632f, -0.05125830f, 
    0.07618782f, -0.14083211f, -0.07068557f, -0.25877661f, -0.01493512f, 0.01952472f, 0.19304352f, -0.01236777f, 
    -0.06019261f, 0.01904876f, -0.11410961f, -0.26614350f, 0.12378013f, -0.02046849f, -0.33989516f, -0.03542144f, 
    -0.28115124f, 0.04192355f, 0.03526032f, -0.00354071f, 0.03723374f, 0.03562642f, -0.01204104f, -0.50106120f, 
    -0.26108220f, -0.08896809f, 0.05266330f, -0.05400518f, 0.10526616f, 0.11009102f, 0.06249414f, 0.05248760f, 
    0.04725540f, -0.10749256f, 0.01599701f, 0.12170397f, 0.07291264f, 0.04406419f, 0.03585113f, 0.19896424f, 
    -0.08791392f, 0.32250869f, 0.18305881f, 0.10974007f, 0.01573780f, -0.09330840f, 0.08175339f, 0.10242637f, 
    -0.02971483f, 0.01123771f, 0.00714367f, 0.01482026f, -0.12304997f, 0.07196641f, 0.12795831f, -0.20193253f, 
    -0.12350324f, 0.09698424f, 0.08440062f, 0.10078742f, -0.00301664f, -0.02355908f, 0.05010051f, 0.15165153f, 
    0.06533432f, -0.17594491f, 0.12692553f, -0.06351488f, -0.00260082f, -0.18840377f, 0.05336994f, 0.12012633f, 
    0.00340657f, -0.17423178f, -0.12996440f, -0.00230644f, 0.06530892f, -0.46934238f, -0.30971798f, 0.08365659f, 
    0.17727727f, -0.10160235f, 0.01181293f, -0.00122273f, 0.13780682f, 0.21115190f, -0.03514957f, -0.07092135f, 
    0.26129422f, 0.13311081f, -0.09647218f, 0.07311784f, -0.03879176f, -0.14344372f, 0.06701276f, 0.11001323f, 
    -0.04011787f, 0.10038445f, 0.15013744f, 0.08957502f, 0.12014079f, -0.04885815f, -0.12744549f, -0.16044386f, 
    -0.01111009f, -0.06198126f, -0.06454903f, -0.01415935f, -0.04354373f, -0.02568793f, 0.05750151f, -0.02474310f, 
    0.00395539f, 0.05881145f, -0.07851658f, -0.02644059f, -0.06468479f, 0.04601890f, 0.06149068f, -0.05294509f, 
    -0.02540755f, -0.08109632f, -0.04992401f, -0.02900935f, 0.03000347f, 0.06538007f, -0.00612788f, 0.04793715f, 
    0.04260771f, -0.09147216f, -0.00809054f, 0.04813485f, 0.03817854f, -0.03744616f, -0.09021536f, 0.02167795f, 
    -0.06447759f, 0.02763589f, 0.01999342f, -0.00275816f, -0.08372240f, -0.05583163f, 0.01443855f, 0.04409477f, 
    -0.01611535f, -0.05103950f, -0.06389325f, 0.02819447f, -0.01483088f, 0.01108642f, -0.07074855f, -0.07108586f, 
    0.02189134f, -0.02527816f, -0.04987407f, -0.00673743f, -0.07882438f, -0.08916437f, 0.03283285f, -0.06657778f, 
    0.04703217f, -0.04440970f, 0.03181564f, -0.04951430f, -0.01232098f, -0.08325661f, -0.09508882f, -0.04744220f, 
    -0.05963571f, -0.01948934f, -0.06425121f, 0.03365080f, 0.05414874f, -0.06842162f, 0.06502854f, -0.07117668f, 
    -0.05051928f, -0.01639519f, -0.04612607f, -0.04925507f, -0.08337216f, -0.01928923f, -0.03149349f, -0.00776003f, 
    -0.00284973f, -0.02559744f, 0.06531685f, -0.08916625f, 0.04942025f, -0.06215521f, 0.05235987f, -0.00825458f, 
    0.03497454f, -0.02634799f, 0.06618664f, -0.07061611f, -0.01840785f, 0.06021131f, -0.06846962f, -0.09340961f, 
    0.04986313f, -0.03222843f, 0.00093253f, 0.03113619f, -0.09264858f, 0.03605097f, -0.06420951f, -0.09675872f, 
    0.01083103f, 0.01580331f, 0.02411511f, -0.01893506f, -0.01810773f, -0.04434741f, -0.03553820f, -0.02819549f, 
    -0.02728345f, -0.03957622f, -0.02608884f, -0.05367587f, 0.03606115f, 0.01872453f, -0.06638572f, -0.02603439f, 
    0.02865102f, 0.00590267f, 0.02526505f, -0.08218265f, 0.02369604f, 0.00640894f, -0.08882500f, 0.00330310f, 
    -0.02419649f, 0.05381839f, -0.03677217f, -0.00923392f, 0.02856448f, 0.01934800f, 0.01992079f, -0.08287580f, 
    -0.04865313f, 0.03908344f, 0.04612016f, -0.09504072f, -0.03152403f, -0.09199047f, 0.01767241f, -0.04206421f, 
    -0.07509410f, -0.06163908f, -0.00823456f, -0.07620608f, -0.04404930f, -0.08939296f, -0.03765654f, -0.03843694f, 
    0.05182066f, 0.04104111f, 0.00139408f, 0.05377357f, -0.07980131f, 0.02814577f, -0.03977634f, -0.09110986f, 
    -0.05983419f, -0.04305619f, 0.04485063f, -0.02637336f, 0.01538094f, -0.00349426f, -0.03711643f, -0.01398386f, 
    -0.06770380f, -0.03495013f, 0.02415884f, 0.04352025f, 0.01058035f, -0.01265103f, -0.05492066f, -0.05346003f, 
    0.03294370f, -0.09285544f, -0.04466535f, -0.00190702f, 0.00364074f, -0.05910328f, 0.01254710f, 0.01409133f, 
    -0.07684458f, 0.02561864f, -0.02140815f, -0.05092989f, 0.00591604f, -0.04293711f, -0.04883996f, -0.08169451f, 
    -0.08613535f, -0.01476106f, -0.04025649f, 0.04864736f, -0.04637676f, 0.06769367f, 0.04348050f, -0.03168448f, 
    -0.00576398f, 0.00033343f, -0.04466506f, -0.05287525f, -0.08237052f, -0.07877203f, 0.07264797f, 0.01155650f, 
    0.07211543f, -0.06672631f, -0.00041263f, -0.05287605f, -0.06024821f, -0.06843843f, -0.03543944f, -0.07443489f, 
    0.04915180f, -0.08008277f, -0.02600498f, -0.04915972f, 0.00429203f, 0.03764398f, -0.05355403f, -0.02844979f, 
    -0.05886138f, 0.03401682f, -0.03447579f, 0.06111727f, 0.01105197f, -0.06138195f, -0.01579306f, -0.08166471f, 
    0.02517977f, 0.04132196f, 0.04846609f, -0.05275094f, 0.04707070f, 0.02829705f, -0.03973731f, -0.04577994f, 
    0.00243658f, -0.05146467f, 0.07358626f, 0.03156174f, 0.04829041f, -0.03819702f, 0.00521994f, -0.04916722f, 
    -0.03343949f, 0.03113103f, -0.06408742f, -0.06740410f, 0.04252179f, 0.02750486f, -0.03751031f, 0.02342464f, 
    0.02877295f, 0.01132788f, -0.01187961f, -0.07940600f, -0.06372909f, -0.05580904f, 0.06463131f, 0.02317450f, 
    0.03318266f, 0.07824546f, 0.02060731f, 0.04123584f, -0.00796040f, -0.01478572f, 0.04671369f, 0.04451378f, 
    0.06315784f, -0.05274219f, -0.03147995f, -0.03856924f, 0.02356331f, 0.04280180f, 0.04588610f, -0.09908357f, 
    -0.10216146f, -0.03837299f, 0.04363491f, -0.05847131f, -0.07765535f, -0.01740289f, 0.00871544f, -0.03915067f, 
    0.06492058f, -0.19023664f, -0.18532708f, -0.00723088f, 0.11492273f, -0.00952357f, 0.22263773f, -0.00574705f, 
    -0.14039639f, -0.17746553f, 0.15140884f, 0.11598568f, -0.16809808f, -0.04302077f, -0.02792842f, -0.11864059f, 
    -0.08839388f, 0.11887036f, -0.16554745f, 0.19998856f, 0.25150314f, 0.13010649f, -0.03767044f, 0.08027088f, 
    -0.12544782f, 0.08248476f, -0.11008596f, -0.07755955f, 0.23914957f, 0.19896279f, 0.05957243f, -0.00851780f, 
    -0.00664999f, 0.05220382f, 0.06358839f, -0.01373309f, 0.03073920f, 0.00108185f, -0.04212838f, 0.00749500f, 
    0.00438344f, 0.08106808f, 0.10189626f, 0.00534252f, 0.09840038f, 0.09246646f, 0.15451108f, -0.24173549f, 
    -0.08150440f, -0.11303744f, -0.09540910f, 0.12171303f, 0.04783342f, -0.06006971f, -0.00766779f, 0.04369999f, 
    -0.04322999f, 0.17981692f, -0.03784345f, 0.01744940f, 0.08496449f, 0.06073788f, -0.08856399f, -0.12652019f, 
    0.00225485f, 0.08205155f, 0.01114654f, 0.10162897f, 0.08426065f, -0.04343574f, -0.00773623f, -0.10779510f, 
    0.04586000f, -0.13668545f, -0.17721586f, 0.04362310f, 0.05071136f, 0.04911604f, 0.03955473f, 0.00057588f, 
    0.00062521f, -0.09880915f, 0.15793376f, 0.27165216f, 0.04324387f, -0.06771935f, -0.01822580f, 0.04746078f, 
    -0.04792129f, 0.02133824f, -0.15182236f, -0.07512539f, -0.15933819f, 0.09545781f, -0.06134460f, 0.04651953f, 
    -0.00282250f, -0.07202940f, -0.15603663f, -0.11635157f, -0.09139578f, 0.26933464f, 0.22612786f, 0.09392269f, 
    0.10482401f, -0.16870752f, -0.08633473f, 0.29169607f, 0.22256638f, 0.00969654f, 0.01037096f, 0.03294097f, 
    0.00866542f, 0.00105836f, -0.11513710f, -0.08072625f, -0.23815863f, 0.14306986f, -0.08154409f, -0.11437051f, 
    -0.03411093f, 0.00780414f, -0.18478151f, 0.07504086f, -0.06847782f, 0.01630792f, 0.12134805f, -0.18181619f, 
    -0.29233742f, -0.13587594f, 0.02872184f, 0.02197707f, -0.04111883f, 0.06272003f, -0.03883786f, 0.30525792f, 
    0.06451241f, 0.14618237f, 0.05908177f, -0.04151012f, 0.17946734f, -0.07755313f, 0.10255169f, 0.03364052f, 
    0.04765531f, -0.06228533f, -0.01616271f, -0.09818312f, 0.04331672f, -0.01866490f, -0.05728032f, -0.01685308f, 
    0.04011445f, 0.00214886f, -0.08078524f, 0.02373033f, -0.01358111f, 0.03359138f, -0.10215564f, 0.02776631f, 
    -0.02632757f, -0.00827252f, 0.06937141f, 0.04216627f, -0.09785593f, -0.08272893f, 0.00570717f, -0.08055709f, 
    -0.03125572f, 0.01683893f, 0.01279591f, -0.02246342f, 0.00509842f, -0.09217449f, -0.07950842f, 0.02882881f, 
    -0.02047993f, -0.00718858f, -0.09989048f, 0.01986862f, 0.06718015f, 0.01911048f, -0.02690671f, 0.08412804f, 
    0.03363387f, 0.01341156f, -0.05270232f, -0.04673088f, -0.07738791f, -0.03561008f, -0.00598981f, -0.07461476f, 
    -0.07226866f, 0.03242518f, -0.01946265f, 0.04744133f, 0.05202092f, -0.13421695f, -0.04144979f, -0.04689156f, 
    -0.02829355f, -0.07321109f, -0.08807431f, 0.05936979f, 0.03893976f, -0.06495853f, -0.03858114f, 0.08008558f, 
    0.00520118f, -0.07792278f, 0.06147824f, -0.03651821f, 0.06304511f, 0.04120378f, 0.01976135f, 0.01565338f, 
    -0.03081952f, -0.01619647f, 0.04283605f, -0.01891707f, -0.01827344f, -0.06685404f, -0.09971208f, -0.05058967f, 
    -0.09352235f, -0.03286821f, -0.08083406f, -0.02401008f, 0.00222872f, -0.04263533f, -0.04705313f, 0.05167264f, 
    0.01844896f, -0.10436351f, -0.07306832f, 0.01627881f, -0.06981157f, 0.00422380f, 0.04304504f, -0.02733659f, 
    0.01560969f, -0.11201887f, 0.04680504f, 0.02292555f, -0.05138535f, -0.00121399f, -0.09663191f, -0.06910562f, 
    -0.09479471f, -0.02434681f, -0.08203338f, -0.05314623f, -0.07739677f, -0.08740971f, -0.02883131f, -0.08357030f, 
    0.06622748f, 0.03933282f, 0.02735183f, -0.02802422f, -0.02468541f, -0.05391140f, 0.01417109f, -0.10392174f, 
    -0.03209325f, -0.03980696f, -0.07031769f, -0.09697253f, 0.03941754f, -0.05173795f, -0.00525751f, 0.02589584f, 
    -0.13510314f, 0.04129339f, -0.01306992f, -0.06566415f, -0.12687850f, 0.02388617f, -0.05685578f, 0.00040836f, 
    0.02240795f, -0.11366516f, -0.09035489f, -0.01719126f, -0.08175946f, -0.00305957f, -0.06450551f, 0.07444677f, 
    -0.07184896f, -0.03271269f, 0.12685941f, -0.07810507f, -0.13563912f, -0.11945163f, -0.08619895f, -0.03279143f, 
    -0.01309115f, 0.18376094f, 0.07965907f, -0.22756131f, 0.06256195f, -0.05581676f, -0.03848624f, 0.04761362f, 
    0.12729555f, 0.05398680f, 0.37368134f, 0.20330898f, -0.04306098f, 0.09869968f, -0.11433697f, 0.11743068f, 
    0.12477682f, -0.06119831f, 0.06114792f, 0.29524210f, 0.00474148f, 0.11203025f, -0.04415858f, -0.00385594f, 
    -0.08199778f, 0.07362773f, 0.11609806f, -0.14772122f, -0.35780731f, 0.15817598f, -0.13546003f, 0.18902624f, 
    0.03655291f, 0.06501067f, -0.09498357f, 0.05061385f, -0.00446336f, -0.35297233f, -0.12013890f, -0.26888770f, 
    0.05248023f, 0.10144021f, -0.00858280f, -0.07284836f, -0.06923892f, 0.07571901f, -0.00712585f, -0.47445789f, 
    0.00624740f, -0.02881267f, 0.04374817f, -0.00902414f, 0.03222160f, 0.01259660f, -0.03604542f, -0.25978404f, 
    0.10336209f, -0.04913567f, -0.04609725f, 0.13520288f, -0.05470315f, -0.04266921f, 0.00966129f, 0.17551775f, 
    -0.05183263f, 0.39288518f, 0.00015912f, -0.09446676f, -0.04828687f, -0.07397197f, -0.01404484f, 0.03262753f, 
    -0.01838944f, -0.06052742f, -0.29018152f, -0.10102396f, -0.05810775f, -0.05391891f, 0.09404273f, 0.02221598f, 
    0.06714257f, -0.03399063f, -0.07684776f, 0.07106069f, -0.16582984f, 0.11264673f, 0.01357413f, 0.09711682f, 
    -0.04779467f, -0.12070823f, -0.01683257f, 0.36849672f, 0.06641719f, 0.14232992f, 0.12318739f, -0.03348581f, 
    -0.10934389f, 0.06003012f, -0.11161596f, 0.11203542f, -0.19767627f, -0.08015572f, -0.17550524f, 0.10646667f, 
    -0.06963058f, 0.16730969f, -0.02826725f, 0.00530756f, -0.02905896f, 0.13191469f, -0.09377493f, 0.05791862f, 
    -0.03628637f, -0.03438710f, 0.12101281f, -0.05410988f, -0.07305412f, 0.03887750f, -0.32957461f, -0.09091592f, 
    -0.04420596f, -0.04046598f, 0.09568458f, 0.04957005f, -0.11705414f, -0.03275110f, 0.01056320f, -0.00008587f, 
    0.00561813f, 0.05841887f, 0.08419832f, 0.20845199f, -0.12367338f, 0.09435852f, -0.03193002f, -0.07790402f, 
    -0.27104238f, 0.04964555f, -0.29635456f, -0.14802398f, -0.04721808f, -0.04973512f, 0.19972140f, -0.00878419f, 
    0.07785404f, -0.23809990f, -0.54978424f, -0.07853865f, 0.02566039f, 0.11783275f, -0.11856149f, 0.11501732f, 
    -0.04169839f, 0.11707812f, -0.13876507f, -0.23731600f, -0.28971842f, -0.05392482f, 0.15957113f, 0.03019127f, 
    0.00081313f, 0.03364654f, -0.21639669f, -0.14260349f, -0.14798446f, -0.25126860f, 0.08063011f, 0.00433245f, 
    -0.17171039f, 0.06507198f, -0.01246162f, -0.09327989f, 0.11797430f, 0.04703707f, -0.02470604f, -0.05203940f, 
    0.04761882f, 0.08367299f, -0.13625115f, 0.03018084f, 0.03699082f, -0.15541384f, 0.07623405f, -0.00963016f, 
    0.04941415f, 0.13879524f, 0.15239596f, 0.04862002f, 0.11302021f, 0.02769307f, -0.13745214f, 0.01824540f, 
    0.20724361f, 0.10508762f, -0.02060127f, -0.20975284f, -0.11260556f, -0.02912050f, -0.01233363f, 0.14674509f, 
    0.22336583f, 0.16662286f, -0.05087692f, 0.13936746f, 0.07407724f, 0.16888045f, 0.12871890f, 0.08287789f, 
    0.18235028f, -0.00839673f, 0.00594972f, -0.01232013f, -0.02010086f, -0.09948704f, 0.02969339f, -0.00941427f, 
    0.22541961f, -0.22267276f, -0.11201655f, 0.04805789f, 0.23250993f, 0.11869453f, 0.04064557f, -0.15919092f, 
    0.16876140f, -0.01785427f, 0.08125929f, 0.00159924f, 0.09926037f, -0.07372523f, 0.04613294f, 0.02064557f, 
    -0.01334719f, 0.04439559f, 0.05904420f, -0.08003058f, 0.02856117f, -0.19868825f, 0.07606281f, -0.00854406f, 
    -0.02405877f, 0.00720995f, -0.17888300f, -0.15285890f, -0.08803282f, 0.23382825f, 0.23573999f, 0.07816820f, 
    -0.02345174f, -0.11230256f, -0.21094990f, 0.08082596f, 0.07418393f, 0.11709055f, 0.09337122f, -0.24460089f, 
    0.03511684f, -0.00788318f, 0.16991867f, -0.12393092f, -0.02431412f, 0.05361051f, 0.11585038f, 0.27370432f, 
    0.03098594f, 0.03337634f, -0.08712041f, -0.04212296f, 0.06724567f, -0.05857372f, -0.04950367f, -0.00843126f, 
    0.12234148f, 0.08377397f, 0.12684928f, 0.03081194f, 0.05923501f, 0.11683906f, 0.19157620f, -0.19066727f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.18527842f, 0.05047125f, 0.06006009f, -0.01809181f, 0.12650184f, -0.04193073f, 0.06854366f, 0.04143586f, 
    -0.05102078f, 0.09525692f, -0.08197670f, -0.00648159f, -0.15111415f, -0.07074526f, -0.08311486f, 0.08573929f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16947813f, -0.02776770f, -0.24399367f, 0.17502876f, -0.24905865f, 0.10480301f, -0.03919572f, -0.30039203f, 
    -0.27773675f, 0.36519936f, 0.01062924f, 0.24170145f, 0.07251747f, 0.15213257f, 0.17304628f, 0.13863255f, 
    -0.37672895f, 0.02598867f, 0.26795331f, -0.75036979f, 0.13764289f, -0.15974444f, 0.32352465f, 0.18365124f, 
    0.08259447f, -0.29929048f, -0.01748265f, -0.13500194f, 0.17449522f, 0.23097326f, 0.32742941f, 0.03298349f, 
    0.07018030f, 0.09783952f, 0.21229768f, -0.00565675f, -0.17502767f, 0.24368098f, 0.12618743f, -0.25457272f, 
    0.22084902f, -0.18370157f, -0.03715743f, 0.14723577f, -0.06381883f, -0.24692248f, 0.13697615f, 0.19195257f, 
    -0.15975025f, 0.23444200f, -0.15712139f, -0.14812517f, 0.02050898f, -0.20808035f, -0.20594534f, 0.06700672f, 
    -0.16456114f, -0.14454958f, -0.04778334f, 0.05627069f, -0.16718589f, 0.13367033f, 0.01964416f, -0.00137559f, 
    0.00044131f, 0.11934987f, -0.06143085f, -0.26435110f, 0.23288207f, 0.23488072f, 0.10061229f, -0.08709644f, 
    -0.07872803f, 0.13769948f, 0.07333709f, 0.25157043f, -0.18721105f, -0.15408592f, -0.18823840f, 0.52689368f, 
    0.16444159f, -0.15660825f, 0.09797380f, -0.21912472f, -0.09056116f, -0.19553360f, -0.47343037f, 0.13373417f, 
    0.24474201f, 0.40962693f, 0.15942338f, 0.06317582f, -0.27943653f, -0.04009139f, -0.00109502f, 0.14510444f, 
    0.06738959f, -0.08071741f, -0.05959628f, 0.28251520f, 0.27249777f, -0.14400576f, 0.28747758f, -0.36309892f, 
    0.22675610f, 0.13442096f, 0.16473225f, 0.05079754f, 0.00714208f, -0.09313587f, -0.40381321f, -0.17170447f, 
    -0.02698731f, -0.13131028f, 0.22648989f, 0.29652771f, 0.03414175f, 0.01871787f, 0.08643220f, 0.19116393f, 
    -0.23164836f, 0.08273216f, -0.20016773f, 0.18543819f, 0.32042477f, -0.14133498f, -0.14623351f, -0.24851741f, 
    -0.00219080f, -0.02052253f, 0.14941178f, -0.20001656f, 0.08592284f, -0.01194620f, 0.06623211f, -0.10842976f, 
    0.21984716f, -0.08981504f, -0.19933735f, -0.11695670f, -0.40046358f, -0.10633513f, 0.40740821f, 0.36067480f, 
    -0.13406199f, 0.05527188f, -0.14164835f, -0.05560092f, -0.18136935f, 0.02930108f, -0.07249394f, 0.27271792f, 
    0.23093177f, 0.39999077f, 0.16506226f, 0.10881857f, -0.50757772f, 0.19940932f, 0.06751084f, 0.42313939f, 
    0.07241141f, 0.10293574f, 0.31304151f, -0.01867982f, -0.25652993f, 0.24321724f, 0.11608024f, -0.03315619f, 
    -0.32439941f, 0.10370705f, 0.05497472f, 0.23116063f, 0.15672402f, 0.13324349f, -0.07736460f, 0.05016555f, 
    0.21111730f, -0.18603680f, 0.54833311f, -0.19102062f, -0.37445739f, -0.21845743f, -0.35481867f, -0.12243781f, 
    0.19007185f, -0.28141728f, -0.00058085f, 0.26322612f, 0.28780398f, -0.21800980f, -0.34011114f, 0.12629212f, 
    0.09521127f, -0.19231313f, -0.16989209f, 0.14617565f, 0.19218852f, 0.16496874f, 0.28046313f, -0.10254903f, 
    -0.28752163f, 0.31783682f, -0.20391044f, -0.19138996f, 0.12263838f, -0.04315316f, -0.30625317f, 0.01200304f, 
    -0.35787898f, -0.02923024f, -0.05027433f, 0.15456411f, -0.09107850f, 0.06398013f, -0.12551251f, 0.04436474f, 
    0.21262492f, -0.04664617f, -0.24684435f, 0.03513060f, 0.36847377f, 0.12640570f, 0.19373026f, 0.13796629f, 
    -0.24435061f, -0.23837897f, -0.27961469f, 0.13243940f, -0.34557873f, -0.04890973f, 0.06291942f, 0.16572258f, 
    0.14707287f, 0.25383964f, 0.09724656f, 0.14672466f, -0.25428188f, -0.21469545f, 0.22208136f, 0.28608575f, 
    -0.03863268f, 0.07779840f, -0.11285355f, 0.03239253f, 0.25597304f, 0.07731773f, -0.07673988f, -0.29111877f, 
    0.15248986f, 0.34453845f, 0.20479473f, 0.18998531f, 0.21914347f, -0.15611012f, 0.35366204f, -0.39318687f, 
    -0.06058654f, -0.23251587f, 0.48989224f, 0.37468570f, -0.04157643f, 0.13783608f, 0.23424722f, -0.22582033f, 
    0.08914867f, -0.43965501f, 0.17364652f, 0.12292989f, -0.10394514f, 0.22656724f, -0.25030065f, 0.11558071f, 
    -0.23776358f, 0.04189739f, -0.02926153f, -0.16089514f, 0.07377318f, 0.05313933f, -0.15858603f, 0.06179348f, 
    -0.01325217f, -0.03246400f, -0.24545071f, -0.23344955f, -0.21396691f, 0.20181736f, -0.01368314f, -0.23979199f, 
    0.38607985f, -0.01602513f, 0.07914732f, 0.13268256f, 0.15794678f, -0.01998563f, -0.42875403f, 0.21149810f, 
    -0.38119519f, 0.35350826f, 0.22744578f, -0.23013699f, -0.13452370f, 0.09903017f, 0.06430765f, -0.05779379f, 
    0.20470469f, -0.06351977f, -0.23966771f, 0.23346719f, -0.55085009f, -0.08607472f, -0.33688357f, 0.09036817f, 
    -0.09262826f, -0.11978290f, 0.25603396f, -0.06098730f, 0.29857174f, -0.23090500f, 0.30275127f, 0.14389545f, 
    -0.23490593f, -0.18377134f, -0.52568424f, 0.04052401f, -0.23118237f, -0.13013387f, -0.05388256f, -0.57011127f, 
    0.29487967f, 0.26443994f, -0.10529204f, -0.02221041f, 0.27308831f, -0.11170471f, -0.04726600f, -0.28828183f, 
    -0.09965211f, 0.07443273f, -0.22856924f, -0.13935152f, -0.06615201f, -0.09358791f, -0.03870198f, -0.01699358f, 
    0.11928782f, 0.07301730f, -0.14971873f, 0.15287578f, -0.10974994f, -0.17601234f, -0.08551034f, -0.21192247f, 
    0.21283190f, -0.07738209f, -0.02669636f, -0.43022904f, 0.38215774f, 0.05539732f, 0.15779871f, 0.17335919f, 
    -0.01766093f, -0.15413688f, -0.01874566f, -0.13533494f, 0.04023897f, 0.10332374f, 0.10028587f, -0.24148308f, 
    -0.43190584f, 0.13007590f, -0.17297226f, 0.07135191f, -0.25744182f, 0.09943909f, 0.33930516f, 0.45749488f, 
    0.27825734f, -0.12184479f, -0.06481319f, -0.24190101f, 0.08947149f, -0.05672613f, 0.17941983f, 0.08070170f, 
    -0.13373281f, 0.17019191f, 0.46481133f, 0.07397261f, -0.18443446f, -0.17021304f, 0.04553574f, -0.11174986f, 
    0.33995655f, 0.07979386f, -0.21038538f, -0.11300006f, 0.18587184f, -0.08579604f, -0.18901847f, 0.00393920f, 
    -0.03429044f, 0.07825120f, 0.31830955f, -0.19756812f, 0.26541430f, 0.08515193f, 0.35228312f, -0.24492399f, 
    0.17250307f, -0.10791562f, 0.14018521f, 0.13513875f, -0.01217030f, 0.10351646f, 0.12069260f, -0.02843369f, 
    0.06764937f, 0.01872137f, 0.35121951f, 0.01039944f, 0.11645962f, 0.18650068f, -0.06507930f, 0.13978364f, 
    0.22409478f, -0.07288761f, 0.06316318f, -0.06656427f, -0.25205010f, -0.23936065f, -0.04699399f, 0.13068871f, 
    0.01547564f, 0.12487276f, 0.06092752f, 0.36599624f, -0.19919692f, 0.08675276f, 0.03634265f, -0.08181087f, 
    0.40372482f, 0.23094967f, 0.02026732f, 0.08730654f, 0.06176922f, 0.25809696f, 0.06695030f, -0.37683457f, 
    0.22742409f, 0.17019713f, 0.14558503f, 0.09227169f, -0.04565700f, -0.03377403f, 0.15240782f, 0.20943290f, 
    -0.39744511f, 0.14295368f, 0.18578281f, 0.04248518f, -0.29681695f, 0.13386047f, 0.16668932f, -0.00803182f, 
    0.23162076f, 0.21492088f, 0.34310687f, -0.00113345f, 0.29846972f, 0.22098686f, -0.19578676f, -0.11393885f, 
    0.29137251f, -0.35340187f, 0.05969811f, 0.09976482f, -0.15682913f, -0.18742083f, -0.40890411f, 0.11315303f, 
    0.11385490f, 0.12726328f, -0.18955910f, -0.06989230f, -0.08182903f, 0.08287655f, 0.28279093f, -0.21914251f, 
    -0.24642640f, 0.31930459f, 0.06150194f, -0.16032813f, -0.17868480f, -0.21984389f, 0.20968854f, 0.22675383f, 
    0.10303549f, -0.17380482f, -0.00907311f, 0.37117690f, 0.31168029f, 0.01762344f, -0.17872225f, -0.29223010f, 
    -0.00096673f, 0.06643716f, 0.07634921f, -0.11615363f, 0.03796892f, 0.23317270f, 0.28290221f, -0.16992635f, 
    0.10573390f, -0.14267418f, -0.44898477f, -0.01435513f, 0.36638799f, -0.15662156f, 0.10349075f, -0.15124269f, 
    0.33377042f, -0.33228609f, -0.11914391f, -0.10623410f, 0.13212341f, -0.06157638f, 0.13488351f, 0.02808970f, 
    -0.23632061f, -0.22749215f, -0.18187152f, 0.35280418f, -0.25288439f, -0.01537669f, 0.07459211f, 0.38668016f, 
    -0.07025672f, 0.31222281f, -0.20220551f, -0.07381249f, 0.20764150f, -0.15658928f, 0.17574370f, -0.11722868f, 
    -0.10915716f, -0.07678072f, -0.05789883f, 0.21488781f, -0.34326568f, -0.11641409f, -0.16379559f, 0.32311752f, 
    -0.17422926f, 0.30353689f, -0.23390476f, 0.15197723f, 0.30385488f, -0.22206494f, -0.12854762f, -0.28500965f, 
    -0.05968478f, -0.12257218f, 0.06019302f, 0.49138883f, -0.13901986f, -0.13430071f, 0.12708263f, -0.03969833f, 
    0.11733019f, 0.31168643f, 0.17023082f, 0.11467383f, 0.16052745f, -0.19069932f, -0.02633251f, 0.06681742f, 
    -0.07891475f, 0.09990624f, -0.15072043f, -0.01068287f, 0.07848976f, 0.13809699f, -0.05617600f, -0.25402927f, 
    0.11660320f, 0.20114678f, 0.16000707f, -0.23650184f, -0.30654797f, 0.01922989f, 0.24864912f, 0.27155334f, 
    -0.15178782f, 0.04542533f, -0.13958642f, 0.07724772f, -0.15075223f, 0.14234298f, -0.08296108f, 0.17439789f, 
    -0.14921497f, 0.01878955f, -0.23038608f, -0.14255163f, -0.11447400f, -0.04148406f, -0.15699065f, -0.25921160f, 
    0.31871319f, 0.07435650f, -0.02022333f, -0.02263311f, -0.36831090f, -0.06260160f, 0.43384418f, -0.34020746f, 
    -0.00108394f, 0.40383795f, 0.14874971f, 0.16072753f, -0.07154427f, -0.02618589f, 0.14386410f, -0.16290331f, 
    -0.09943005f, 0.21092111f, 0.36937135f, -0.18225348f, 0.27222002f, -0.16262910f, -0.34518170f, 0.27389452f, 
    -0.13353905f, 0.12535134f, -0.23465416f, 0.01687229f, 0.33548614f, -0.03012133f, -0.71424526f, 0.24026987f, 
    0.15631525f, -0.00000489f, -0.19052917f, 0.34521335f, 0.14725932f, -0.24105509f, 0.30192378f, 0.35339710f, 
    -0.29184765f, -0.14661053f, -0.18950722f, -0.05086033f, 0.02557779f, 0.00084208f, -0.21735285f, -0.28379571f, 
    0.19102928f, 0.04930946f, 0.47155547f, -0.08996961f, -0.18956462f, 0.24292870f, 0.14799443f, 0.11487892f, 
    -0.20254710f, -0.26214707f, -0.20327470f, -0.00468552f, 0.20769787f, 0.13387601f, -0.42390060f, -0.04979237f, 
    0.06710618f, 0.20565045f, -0.05610937f, -0.10908703f, -0.02348825f, -0.08815674f, -0.49298191f, -0.35152158f, 
    -0.12361157f, -0.23373047f, 0.07906267f, 0.00351274f, 0.27994987f, -0.03034810f, 0.66789860f, 0.21833199f, 
    0.25688884f, -0.09786948f, 0.41647607f, -0.07449528f, -0.38287601f, 0.23124871f, -0.12480662f, -0.00266495f, 
    0.35486159f, -0.12603071f, -0.23359787f, -0.17286649f, -0.07568055f, -0.26118821f, 0.09759168f, -0.05379416f, 
    -0.28689986f, 0.06388208f, -0.06042946f, 0.34556046f, -0.44332024f, 0.15740469f, -0.20273289f, -0.03290296f, 
    0.05496217f, 0.20136511f, -0.20863104f, -0.17737803f, 0.11552713f, -0.01581153f, 0.41110969f, 0.08788649f, 
    0.19098139f, -0.10010521f, 0.27106544f, -0.08674780f, -0.15626611f, 0.00585153f, -0.39679003f, 0.24848300f, 
    -0.17914984f, -0.14167261f, 0.14064823f, -0.02906705f, 0.18525958f, 0.12425508f, 0.30590209f, 0.21992026f, 
    0.23968628f, -0.18639463f, -0.43301022f, 0.28906623f, -0.11492706f, -0.07457479f, 0.28239906f, -0.33591279f, 
    -0.27785411f, 0.28329822f, -0.18613523f, -0.09944189f, -0.00691419f, -0.06362454f, 0.06414957f, 0.25944871f, 
    0.02188876f, 0.20202701f, -0.21134312f, -0.52033168f, 0.21874349f, -0.14364684f, 0.16836019f, 0.21931215f, 
    0.02655678f, 0.09637375f, -0.18392430f, -0.06681425f, 0.30117610f, 0.13687278f, -0.28421801f, -0.30029136f, 
    -0.09704325f, -0.16688818f, 0.32781491f, -0.25954223f, 0.00789189f, -0.05359959f, 0.18323663f, -0.15157834f, 
    0.37234369f, -0.11391398f, 0.11641326f, 0.00304635f, 0.20155418f, 0.10085577f, 0.12055766f, -0.10778183f, 
    0.13636422f, -0.09304187f, 0.14291894f, -0.06259774f, 0.03457213f, 0.04374474f, 0.24401414f, 0.01074996f, 
    0.39712352f, -0.51979136f, -0.06560954f, -0.21144146f, -0.19759223f, -0.15253210f, 0.32928577f, -0.43610820f, 
    -0.20425381f, 0.19663846f, -0.11238223f, 0.14045739f, 0.10554841f, 0.17373055f, 0.08812883f, 0.24380045f, 
    0.09653968f, 0.29345796f, -0.19555564f, -0.16790690f, 0.27842873f, -0.24636687f, -0.39826313f, -0.25143245f, 
    -0.09073722f, -0.24476668f, -0.05113759f, 0.52007210f, -0.18801340f, -0.21170485f, 0.16568117f, -0.31606811f, 
    -0.14894965f, -0.19183835f, -0.18411189f, 0.08205551f, -0.06282864f, -0.17996779f, 0.17422360f, 0.31846553f, 
    0.38879105f, 0.05340499f, 0.02167735f, 0.48001838f, -0.16897348f, 0.20226043f, -0.14148420f, -0.13701858f, 
    -0.21482116f, -0.10007572f, 0.06615974f, 0.11348635f, 0.05076266f, -0.04997515f, 0.17333145f, -0.25688341f, 
    0.14509259f, -0.10596713f, -0.06368771f, -0.23908566f, -0.22842547f, 0.14758827f, 0.04944736f, -0.17803673f, 
    -0.14176586f, 0.12067515f, 0.15015881f, 0.10587631f, -0.46389088f, -0.04655748f, -0.01887649f, 0.21778943f, 
    -0.16133605f, -0.09013954f, 0.15970044f, 0.43958047f, -0.28172415f, 0.18957891f, -0.13904856f, -0.08528373f, 
    0.05355696f, 0.38067320f, 0.14634939f, -0.08487548f, 0.10552227f, -0.13945815f, 0.24314539f, -0.38063523f, 
    0.10793329f, -0.18070436f, 0.35885608f, 0.18818097f, -0.21276960f, -0.19801496f, 0.08632120f, -0.16857381f, 
    0.07970369f, 0.28975645f, -0.14801413f, 0.10515624f, 0.11606184f, 0.15002517f, -0.24850135f, -0.41976830f, 
    0.06066336f, 0.15735087f, -0.36746120f, 0.19180650f, 0.48206940f, 0.14310218f, -0.38527483f, 0.10286530f, 
    0.02136534f, 0.19203436f, -0.03042354f, -0.18089752f, -0.13539913f, 0.00050037f, -0.11306199f, 0.09994227f, 
    -0.04452299f, 0.07364796f, 0.27838814f, -0.14038335f, 0.10495987f, -0.19315672f, -0.11052854f, 0.28612426f, 
    0.14249285f, -0.24265507f, -0.09682000f, -0.09925156f, -0.10433106f, 0.12116575f, 0.41035625f, 0.11760543f, 
    0.10178832f, -0.03892404f, -0.18736938f, -0.21941990f, 0.54019463f, -0.14856911f, -0.21484131f, -0.26473960f, 
    0.32011354f, 0.20437564f, -0.12226778f, -0.19543794f, 0.02252400f, -0.08756731f, -0.16435097f, -0.25576282f, 
    0.25896600f, -0.21586660f, -0.01241454f, 0.31411073f, -0.00833675f, -0.00864769f, -0.12228327f, 0.35534105f, 
    -0.05960871f, -0.03543283f, 0.05133062f, -0.03960525f, 0.24500547f, 0.10063425f, -0.15175882f, -0.38456333f, 
    -0.12203708f, 0.10282034f, 0.27972913f, -0.03358928f, 0.06608752f, -0.04365775f, -0.37930703f, -0.16962540f, 
    0.28627646f, 0.30721986f, 0.05771659f, -0.06885205f, 0.07222837f, 0.10687412f, -0.12634042f, 0.31761169f, 
    -0.03490212f, -0.06966507f, -0.19877565f, 0.35577971f, 0.63058627f, -0.13346176f, -0.07204590f, 0.16489927f, 
    -0.29753512f, 0.09854554f, -0.18561433f, -0.11179601f, -0.13652533f, -0.14875080f, -0.04119039f, -0.20522501f, 
    0.29241806f, -0.15356877f, 0.27710781f, -0.09892291f, 0.22373016f, 0.08551802f, 0.29009715f, -0.20726292f, 
    0.00372906f, -0.16662635f, 0.06013181f, -0.24100786f, 0.13717839f, 0.19025913f, 0.14065440f, -0.38469657f, 
    -0.21779911f, -0.02998552f, 0.11767008f, -0.55584717f, -0.01926576f, -0.22772150f, 0.06413594f, -0.24263085f, 
    0.40071997f, 0.28361011f, -0.24428758f, 0.03212214f, -0.15157756f, 0.06536102f, 0.05470693f, -0.20855184f, 
    -0.09498546f, -0.24070765f, 0.15196337f, -0.01556139f, 0.23632136f, 0.18320604f, 0.33337951f, -0.15189189f, 
    0.08405068f, 0.18145154f, -0.02192972f, 0.12337333f, 0.38110286f, -0.15319934f, -0.20823428f, -0.26115996f, 
    0.29474908f, 0.16877738f, -0.64054728f, 0.18397117f, 0.43063343f, 0.00323356f, -0.08192425f, -0.01873771f, 
    0.19508512f, -0.04885555f, 0.21437927f, 0.16093864f, 0.04768610f, 0.10703984f, -0.27665722f, 0.11895951f, 
    0.01998034f, 0.23132095f, -0.22524746f, 0.19435565f, -0.09516901f, 0.07349998f, -0.18247078f, -0.19756582f, 
    0.06471633f, -0.00458725f, -0.19388399f, -0.10755345f, -0.24129184f, -0.22388014f, -0.18013930f, -0.14244214f, 
    0.20884314f, 0.14322715f, 0.04000596f, -0.35290232f, 0.35554591f, -0.13172065f, -0.02582472f, 0.04586262f, 
    0.19411169f, 0.00737279f, -0.06473579f, 0.08881749f, 0.20074691f, -0.20987178f, -0.36386475f, -0.15589125f, 
    0.20718095f, 0.02972149f, 0.11584366f, -0.39078286f, 0.48785678f, 0.03917753f, -0.17373769f, 0.03144472f, 
    -0.21330677f, 0.06602822f, 0.08157876f, -0.19293536f, -0.11225685f, -0.24591187f, 0.22276440f, 0.05878616f, 
    0.03299790f, -0.16606101f, -0.34086654f, -0.06292907f, 0.01267216f, -0.05742795f, 0.30751583f, 0.25148889f, 
    0.29774812f, -0.10961276f, -0.05663283f, -0.21525730f, 0.13205399f, -0.23191120f, 0.00313485f, -0.07032471f, 
    -0.31238776f, 0.07323360f, -0.23932563f, 0.06977926f, -0.31330547f, 0.11125255f, 0.25331578f, 0.17157581f, 
    0.37714034f, -0.36367282f, 0.17495070f, 0.03073706f, -0.13926956f, 0.02944352f, 0.02982858f, 0.13210735f, 
    -0.16767474f, 0.22644848f, -0.26986796f, -0.07812398f, -0.20840335f, 0.15621305f, -0.24347924f, 0.17499243f, 
    0.33582261f, 0.35149062f, -0.18405685f, -0.06581497f, -0.21475664f, -0.19355491f, 0.49393427f, -0.31485656f, 
    0.33959991f, 0.23562588f, -0.16332537f, -0.27863103f, -0.24869107f, 0.08749078f, -0.31734145f, 0.24918030f, 
    -0.06870751f, -0.19450414f, 0.08297979f, -0.13240805f, 0.27188659f, -0.04841231f, -0.14957660f, 0.27857345f, 
    0.24837893f, 0.06233606f, 0.39357358f, 0.28946760f, 0.05552601f, 0.02276431f, 0.13326974f, -0.25379837f, 
    0.25555494f, -0.17294157f, -0.08574206f, 0.20744936f, 0.37826410f, -0.04602152f, -0.15500872f, -0.31581846f, 
    0.10354132f, 0.03050938f, -0.02216705f, 0.18443950f, -0.14500013f, 0.16232698f, 0.45748746f, 0.09360652f, 
    -0.38932747f, -0.04061649f, -0.21342671f, -0.09439941f, -0.38695377f, 0.02545309f, 0.58793151f, 0.03116944f, 
    0.24985301f, 0.20507570f, -0.22196488f, -0.31188446f, 0.04170884f, -0.02572975f, 0.02047209f, -0.08346225f, 
    0.28215441f, -0.06643922f, 0.12935543f, -0.02256603f, -0.10536677f, -0.12820663f, -0.00457152f, 0.32096392f, 
    -0.23091958f, 0.18829405f, 0.42800283f, 0.40036657f, 0.00090836f, 0.03796557f, -0.43316552f, -0.10822128f, 
    -0.10052999f, 0.27418512f, -0.16958798f, -0.07762471f, 0.07411725f, -0.07127598f, 0.29960516f, -0.23745315f, 
    -0.12524800f, 0.15049496f, 0.15876752f, 0.44806665f, 0.46620733f, -0.14855048f, 0.05053588f, 0.14462133f, 
    -0.15048273f, -0.32483599f, -0.01364446f, -0.21362287f, 0.41950977f, 0.02856443f, 0.16857287f, -0.03397688f, 
    0.03085148f, 0.22592568f, -0.25950208f, 0.14812717f, 0.06057665f, -0.06518227f, -0.13900390f, 0.01703182f, 
    0.08481531f, 0.27047011f, -0.18283407f, 0.14918295f, 0.20011184f, -0.00569400f, -0.24726720f, -0.29469484f, 
    0.25025132f, -0.13293858f, -0.38197216f, -0.09273975f, 0.05620183f, -0.15036593f, -0.43465048f, 0.08806569f, 
    -0.17425051f, 0.00674438f, 0.21401593f, 0.12982230f, 0.29373264f, -0.23775482f, -0.19939999f, 0.43215367f, 
    0.03462516f, 0.10343355f, 0.15513641f, 0.24666196f, -0.08144762f, -0.19098836f, -0.26933879f, 0.30558160f, 
    -0.16704121f, 0.28970644f, -0.13912462f, -0.22313388f, 0.38917795f, -0.07270938f, -0.47306466f, -0.11190764f, 
    -0.24718571f, -0.15360716f, -0.18948239f, 0.08888617f, -0.05316356f, 0.18268222f, -0.11757371f, -0.12692198f, 
    -0.00263178f, -0.03093991f, -0.01632118f, -0.00949430f, -0.01362520f, -0.04989153f, -0.21776956f, 0.05460620f, 
    0.20831434f, -0.15964080f, -0.28554237f, 0.44669041f, -0.16505463f, 0.18246867f, 0.26353359f, -0.11873717f, 
    -0.24986105f, -0.31078893f, 0.03715685f, 0.16491085f, 0.07066905f, 0.11869408f, 0.28020355f, -0.06205364f, 
    -0.34330785f, -0.21256024f, -0.23334917f, -0.16391049f, 0.23202308f, -0.20317809f, 0.29835024f, 0.21249090f, 
    0.31486714f, -0.26885217f, -0.06359053f, -0.22350752f, -0.28470555f, -0.22037542f, 0.33566529f, -0.22363283f, 
    0.24061927f, 0.12230350f, 0.44461554f, -0.11521733f, -0.17666061f, 0.09196391f, 0.08480138f, 0.31361246f, 
    -0.13954887f, -0.24292979f, -0.13418257f, -0.06532941f, -0.01362030f, 0.13427657f, 0.06377096f, -0.27302486f, 
    0.04620914f, -0.09091914f, -0.25466555f, -0.05405283f, -0.26050714f, -0.11597422f, -0.27404770f, 0.02424247f, 
    0.36712381f, 0.12668623f, 0.08999442f, -0.05522722f, 0.39785758f, 0.01642904f, -0.12248096f, 0.13031301f, 
    0.32692841f, 0.13238254f, -0.13699065f, -0.06583989f, -0.02736901f, -0.19237828f, -0.15483019f, 0.33419371f, 
    0.35653457f, -0.26825184f, -0.24665307f, -0.17030123f, 0.22970320f, 0.13619778f, -0.19148466f, -0.10674073f, 
    -0.12018669f, -0.07093552f, 0.15083566f, -0.22880785f, 0.22739626f, 0.10181763f, 0.08433981f, -0.22912253f, 
    0.39400798f, 0.11880812f, 0.21233462f, -0.21636136f, -0.43865108f, -0.03808848f, 0.27104476f, -0.03671357f, 
    0.23712204f, 0.06510293f, 0.14455526f, 0.24976632f, -0.56594783f, 0.16920169f, -0.40010461f, -0.07659514f, 
    0.05466764f, 0.20896448f, -0.04786702f, -0.20152628f, 0.12212581f, -0.21376418f, -0.11873095f, 0.24962987f, 
    -0.16542159f, 0.19250256f, -0.01535312f, -0.10620873f, 0.27787364f, -0.21116029f, 0.26501545f, 0.24227820f, 
    -0.03306352f, 0.04755519f, 0.18162350f, -0.09440898f, 0.14414303f, 0.18387018f, -0.18497130f, -0.51282322f, 
    -0.20196488f, -0.03768814f, -0.32956788f, -0.20419830f, 0.09238837f, -0.21019526f, 0.10535988f, 0.24150372f, 
    -0.31764585f, 0.41231990f, -0.21289513f, -0.14792910f, -0.06384648f, 0.11727328f, 0.25101846f, 0.30974054f, 
    0.14027235f, -0.10117273f, -0.07060868f, -0.32246593f, 0.19367357f, 0.20039392f, -0.05562282f, -0.07124216f, 
    0.15295653f, -0.02116515f, -0.07943311f, -0.21980917f, 0.15227695f, -0.13096559f, -0.37199527f, 0.33683908f, 
    0.27730107f, 0.10869369f, 0.00319265f, 0.02792979f, -0.24070980f, -0.05316239f, 0.08136166f, -0.23061080f, 
    0.47304514f, 0.13748713f, 0.18835656f, 0.06907671f, 0.24353723f, -0.21887591f, 0.03798477f, -0.27491298f, 
    -0.23242921f, 0.18162775f, 0.12342860f, -0.18576685f, 0.05003145f, 0.09342843f, -0.23735891f, -0.14864275f, 
    -0.09392321f, 0.16665229f, 0.06597963f, -0.16025186f, -0.21550998f, 0.01013318f, 0.04793511f, -0.08810882f, 
    -0.23000690f, -0.04247558f, 0.11393628f, 0.00891754f, 0.09598583f, 0.24741775f, -0.21664172f, 0.06977683f, 
    -0.14726710f, -0.08893949f, 0.04358378f, -0.06609076f, -0.08829966f, -0.06325960f, -0.21610937f, -0.24839750f, 
    -0.24191868f, -0.23035982f, 0.29889384f, 0.13853094f, 0.47465423f, 0.22838564f, 0.09369214f, -0.21598679f, 
    -0.02296519f, -0.22741969f, -0.12703045f, -0.22918926f, 0.15997063f, -0.00884291f, 0.22217017f, 0.25454530f, 
    0.20370278f, -0.00899345f, 0.08221446f, -0.02609000f, -0.31399384f, -0.10313770f, -0.00080198f, 0.00260490f, 
    -0.16240044f, 0.50424838f, 0.18872754f, -0.08744129f, -0.14258672f, 0.06551911f, -0.03830845f, -0.22953202f, 
    -0.19860145f, -0.07107446f, 0.34888625f, 0.42019320f, -0.33652687f, -0.12235571f, 0.12244049f, -0.15112346f, 
    0.19252943f, 0.07337310f, 0.24379227f, 0.03796387f, -0.05326542f, -0.16564180f, 0.27862531f, -0.10103481f, 
    -0.03806166f, -0.07990673f, -0.33380148f, -0.13665491f, 0.23694158f, 0.05385411f, -0.16411965f, 0.33041680f, 
    0.27948919f, -0.08044704f, 0.00228612f, -0.19986989f, -0.08230115f, -0.15810066f, -0.12576942f, 0.18910123f, 
    -0.07713562f, 0.23644516f, 0.02153744f, 0.19760196f, 0.16179284f, -0.20680675f, 0.25828636f, -0.09211119f, 
    0.20048787f, 0.07330799f, -0.01196347f, -0.18579224f, -0.17825170f, -0.15243794f, 0.26751155f, 0.07084675f, 
    0.27787167f, -0.24697123f, -0.16991210f, -0.08472399f, -0.28905228f, 0.08268101f, -0.39298761f, -0.28958964f, 
    0.24534006f, -0.00730221f, -0.02064826f, 0.12822419f, -0.05492611f, 0.12253425f, 0.44956097f, 0.34776124f, 
    -0.17073230f, 0.04231504f, 0.11137886f, 0.32769316f, -0.30578366f, -0.11789686f, -0.02909781f, 0.06787429f, 
    -0.05148222f, 0.20844583f, 0.11726945f, -0.02708831f, -0.16891564f, 0.13184601f, -0.48011610f, 0.42460206f, 
    0.37755078f, -0.12846182f, -0.35156509f, -0.19479029f, -0.20257673f, -0.12730439f, -0.11143944f, -0.05845403f, 
    0.16043200f, 0.37195507f, -0.21200295f, 0.04207705f, -0.39663005f, -0.22937973f, -0.08222003f, 0.25789729f, 
    -0.27538094f, -0.00695723f, -0.08553752f, 0.26713395f, -0.18613674f, -0.19035445f, -0.27835903f, 0.25813526f, 
    0.15646541f, 0.25636172f, 0.07966381f, 0.01079760f, -0.30640954f, 0.14185496f, 0.12236714f, -0.22461154f, 
    0.05346225f, 0.05624440f, 0.36954933f, 0.19026437f, -0.45732617f, -0.17370874f, -0.14379042f, 0.07303851f, 
    -0.20566246f, 0.04534302f, -0.13731074f, 0.05160905f, 0.35636893f, -0.02939467f, 0.09287308f, -0.27039507f, 
    0.16993622f, -0.04328844f, -0.26499912f, 0.03431913f, -0.13178763f, -0.12067786f, -0.12168568f, 0.41839209f, 
    -0.15071619f, 0.04704444f, 0.02042374f, -0.01972594f, 0.12525605f, -0.18286961f, -0.19219148f, 0.40237662f, 
    -0.18431434f, 0.15412071f, 0.17754339f, -0.03675504f, 0.30805883f, 0.24409653f, 0.18485835f, 0.18998334f, 
    0.09694553f, -0.12855157f, -0.04390885f, -0.23556851f, -0.10142579f, -0.24089384f, -0.23782875f, 0.38466996f, 
    0.41695431f, -0.00289205f, -0.00328991f, -0.18370992f, -0.21276699f, 0.11667969f, -0.31395566f, -0.09868153f, 
    0.23845907f, -0.08527938f, -0.23111014f, -0.14980017f, 0.30946022f, 0.13236175f, -0.27924728f, 0.36535415f, 
    -0.14265363f, -0.24428406f, 0.21696635f, -0.44000039f, 0.16691568f, 0.17892799f, 0.29855698f, -0.03942168f, 
    -0.16782133f, -0.22805032f, 0.13121715f, -0.14335626f, -0.37299237f, -0.09724392f, 0.27485314f, 0.38282382f, 
    0.01050939f, -0.01194157f, -0.20427620f, -0.25753033f, 0.16508909f, 0.22075814f, -0.14218304f, 0.24079527f, 
    0.17050751f, 0.22562376f, -0.02921234f, 0.14404251f, -0.33787340f, 0.03105522f, -0.07277383f, 0.36118233f, 
    0.23358421f, -0.22493462f, -0.08110127f, -0.02633628f, 0.04097580f, -0.06108471f, 0.13072212f, 0.16986680f, 
    -0.13989726f, -0.20500152f, 0.04978047f, -0.21389620f, 0.21992829f, -0.16883856f, -0.06942615f, -0.30571923f, 
    -0.01880812f, 0.06090528f, -0.27428946f, 0.07541147f, 0.44676137f, -0.12816988f, 0.41315436f, 0.17818579f, 
    0.39019686f, -0.17839447f, 0.21588533f, -0.11712955f, 0.18172359f, -0.01531474f, -0.41741538f, -0.14414273f, 
    -0.27153447f, -0.24931657f, -0.08141580f, -0.50928503f, 0.36040151f, 0.16218582f, 0.25865126f, -0.18127608f, 
    -0.24030794f, 0.46398327f, 0.22616982f, -0.22920939f, -0.17738724f, -0.01233796f, -0.00988286f, -0.03219423f, 
    -0.14344674f, -0.13642308f, 0.40772638f, 0.23470142f, -0.08897628f, -0.02751361f, -0.15012322f, 0.21341439f, 
    0.48991621f, -0.18065265f, -0.06467414f, 0.10266925f, -0.42553401f, -0.23548001f, -0.01299655f, 0.07708769f, 
    -0.00616675f, -0.24037515f, -0.01181063f, -0.24384281f, 0.17337300f, -0.17635226f, 0.19471647f, 0.18028457f, 
    0.03183388f, 0.03185028f, -0.21493809f, 0.18352687f, -0.33105305f, -0.18375540f, -0.40995318f, 0.29970613f, 
    0.24500969f, 0.08890344f, 0.20127532f, -0.41654056f, 0.42969745f, -0.22056049f, -0.31074375f, -0.41468230f, 
    0.24633721f, -0.26594904f, 0.09178769f, 0.20344697f, 0.13988723f, -0.09838264f, 0.20505828f, 0.07409955f, 
    0.09101596f, 0.03080939f, 0.45006326f, 0.27364045f, 0.09628683f, -0.09615883f, 0.12517504f, -0.35641891f, 
    -0.01958424f, -0.33790845f, 0.07382468f, 0.07278302f, 0.03961118f, 0.10716993f, -0.05404695f, -0.05278303f, 
    0.24806169f, 0.20358275f, -0.31817296f, -0.21395981f, 0.38908944f, 0.22060467f, -0.13466239f, 0.32296956f, 
    0.29444000f, -0.16854799f, 0.12505920f, 0.23995423f, -0.14632669f, 0.13183416f, 0.14848965f, 0.11511950f, 
    -0.00365313f, 0.20658463f, -0.15514320f, -0.14175183f, 0.29516634f, 0.20933475f, -0.15389611f, -0.32684907f, 
    0.24517174f, 0.13209698f, 0.23733093f, 0.05408650f, -0.18833812f, -0.01315902f, 0.35381633f, 0.04035271f, 
    -0.06372648f, 0.18700969f, -0.34159935f, 0.30879289f, -0.45659569f, 0.13334143f, -0.30256674f, 0.15550086f, 
    0.19077501f, 0.12083899f, -0.23104049f, 0.06045459f, 0.35718957f, 0.00138133f, 0.29332045f, 0.13930149f, 
    0.00256632f, 0.05034268f, 0.20852958f, 0.15792257f, -0.14537737f, 0.07165945f, 0.22489558f, -0.13651329f, 
    0.45455310f, 0.14243950f, -0.24732196f, 0.08539946f, -0.07656520f, -0.10582487f, 0.10965466f, -0.35941234f, 
    0.20006779f, 0.10636541f, -0.50274616f, 0.06564905f, 0.34841397f, -0.21509095f, 0.00313765f, -0.18823490f, 
    0.33240882f, 0.14993294f, -0.07637034f, -0.15527231f, 0.16999876f, -0.08311776f, -0.29869509f, -0.30819747f, 
    -0.33035100f, 0.24850047f, -0.00575035f, 0.08084531f, 0.28509966f, -0.18200302f, 0.37250173f, 0.29925695f, 
    0.00760753f, 0.13981444f, -0.17683898f, -0.15563731f, 0.01979556f, -0.08923573f, -0.29355487f, -0.24098742f, 
    0.41374537f, -0.08170426f, 0.05214608f, 0.54070300f, -0.09894414f, 0.10725671f, -0.43520162f, -0.18100235f, 
    -0.18474521f, -0.20241152f, 0.02741447f, 0.07063999f, 0.19792515f, 0.20358713f, 0.50234479f, -0.00315242f, 
    0.13541664f, -0.22827563f, -0.27161857f, 0.29498738f, -0.03994468f, 0.11897724f, 0.16994770f, -0.39767563f, 
    0.09131695f, 0.35788751f, 0.18780549f, 0.02784183f, 0.01225392f, 0.21277829f, -0.29026514f, -0.14506131f, 
    -0.09148805f, -0.14902258f, 0.37655056f, -0.30550718f, 0.41037503f, 0.15486063f, 0.20790884f, -0.25801840f, 
    0.28758812f, 0.07769771f, -0.10964741f, 0.00669601f, -0.23929562f, -0.11416172f, 0.19603619f, -0.19539474f, 
    -0.15346821f, -0.11020154f, 0.32403114f, 0.06566652f, -0.17412215f, 0.05025656f, -0.17189388f, 0.25187352f, 
    0.02320905f, 0.04197603f, -0.13213004f, 0.14490423f, -0.08658147f, -0.05335193f, -0.54446429f, 0.34196123f, 
    -0.20278649f, -0.16765831f, 0.47214806f, 0.28389227f, 0.41150087f, -0.01744696f, 0.09969065f, 0.01074825f, 
    -0.10441997f, -0.06464576f, 0.23226838f, -0.19866993f, 0.06573575f, -0.24657324f, -0.30272084f, -0.15079923f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.41211665f, -0.26862350f, 0.10659943f, -0.08133490f, 0.00854067f, 0.08982884f, -0.50406003f, 0.12132735f, 
    -0.36566880f, -0.12512040f, 0.08855636f, -0.15163819f, 0.40364882f, -0.15907665f, 0.13464585f, 0.29258993f, 
    0.38778532f, -0.15611994f, -0.03788035f, -0.04284906f, -0.00772240f, -0.19589296f, 0.37870774f, -0.38606825f, 
    -0.08925229f, 0.08212654f, 0.46497771f, -0.07005115f, 0.17201367f, 0.40592650f, 0.49423936f, 0.27627224f, 
    -0.18557407f, -0.40273777f, 0.21744213f, -0.44562963f, 0.33111927f, -0.13558283f, -0.14409021f, 0.21607818f, 
    0.23088415f, 0.21628328f, 0.35766989f, 0.09641933f, -0.57491380f, 0.36117679f, 0.17287372f, -0.05143095f, 
    -0.06863246f, 0.02882636f, 0.36798859f, 0.02321069f, 0.19966902f, 0.01127200f, 0.26679206f, 0.35054740f, 
    0.49397001f, -0.40896490f, 0.05953947f, -0.22858985f, -0.14006732f, 0.51177627f, 0.34647724f, 0.44224721f, 
    -0.08061279f, -0.06233905f, -0.06694871f, 0.45944214f, 0.08366721f, -0.45059198f, -0.57394123f, 0.03674344f, 
    0.39036509f, 0.08040825f, -0.00010405f, 0.12100928f, 0.11945673f, -0.20142131f, 0.34748963f, 0.29209381f, 
    -0.03742649f, -0.13736707f, 0.19547020f, -0.25048426f, 0.23377915f, -0.01538013f, -0.05650992f, 0.16853510f, 
    -0.00688730f, 0.36801979f, -0.28959978f, -0.03386143f, -0.37706646f, -0.18391046f, -0.10992593f, -0.03847197f, 
    0.32809186f, -0.24266635f, 0.02582605f, -0.35507801f, 0.28840896f, 0.30272448f, 0.28963852f, 0.48217532f, 
    0.23752141f, 0.05185034f, 0.09056225f, 0.03743346f, 0.29403263f, 0.03440034f, 0.33904865f, -0.10470040f, 
    0.18076995f, -0.29574645f, -0.07092927f, 0.43045616f, 0.29261318f, 0.17039330f, 0.51082391f, -0.37457547f, 
    0.18458459f, 0.19995695f, 0.35167119f, -0.18187809f, -0.14367725f, -0.16941178f, 0.44632745f, 0.37526408f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.02486096f, -0.05941708f, 0.05512659f, 0.01877368f, -0.01798785f, -0.07449247f, 0.08104572f, -0.00106573f, 
    -0.02953689f, -0.08476702f, -0.00729295f, -0.05218645f, 0.01595549f, 0.03180102f, -0.09292266f, -0.07776435f, 
    -0.06058013f, 0.04862933f, -0.06734719f, 0.00741072f, -0.05128568f, -0.06301388f, -0.02988686f, 0.06935836f, 
    0.00107657f, -0.01081467f, -0.00398263f, 0.08119754f, -0.10337896f, 0.06668747f, -0.02821600f, -0.08902898f, 
    -0.03430586f, 0.05198582f, 0.02293736f, -0.06095213f, -0.07254595f, -0.03605648f, -0.06864238f, -0.01034111f, 
    0.07095075f, 0.03299642f, 0.00581122f, -0.04612157f, 0.02345328f, -0.02908186f, -0.06463164f, -0.08148427f, 
    -0.08587871f, -0.00495610f, 0.06753551f, -0.00310239f, -0.09283010f, 0.05394317f, 0.02520172f, -0.02806676f, 
    0.01495821f, 0.04810809f, 0.06289828f, -0.08899262f, 0.02341258f, 0.06478319f, -0.08311327f, -0.07058521f, 
    -0.05181496f, 0.00833234f, 0.01788536f, -0.05680552f, -0.00595842f, -0.02788737f, 0.02358644f, -0.05379771f, 
    -0.06577193f, -0.03183365f, -0.01190268f, -0.06611337f, 0.01476269f, -0.06338058f, -0.04295111f, -0.08490390f, 
    0.07058948f, 0.03115502f, -0.06418362f, 0.07184477f, 0.03628697f, -0.04370581f, -0.00446896f, -0.08249995f, 
    -0.01457444f, -0.02655698f, 0.01026547f, 0.07131823f, -0.04253073f, 0.04333228f, 0.06905866f, -0.04257857f, 
    -0.10748737f, 0.01608450f, 0.05826915f, 0.08505411f, 0.04084445f, 0.07493755f, -0.02413862f, -0.04105847f, 
    0.06243706f, -0.08276252f, 0.01979015f, -0.01178230f, 0.05560457f, 0.01624210f, 0.06624874f, -0.04081796f, 
    0.02211704f, -0.00229101f, -0.06496447f, -0.00403664f, 0.03757913f, -0.00014822f, -0.07335539f, -0.08281275f, 
    0.06363048f, 0.01129835f, 0.01177032f, 0.01618814f, 0.05719606f, 0.06785655f, -0.07022578f, -0.00515431f, 
    -0.06278099f, 0.01767787f, -0.00251934f, 0.05886045f, -0.00117437f, 0.03720899f, -0.07994431f, -0.12280228f, 
    -0.09305211f, -0.00753346f, 0.04400488f, -0.03197208f, -0.06240401f, 0.03902377f, -0.01354493f, -0.08979316f, 
    0.03878727f, 0.04744749f, -0.04416711f, 0.02774195f, -0.02882222f, -0.04651354f, -0.08606438f, -0.05067265f, 
    -0.05903535f, -0.03567478f, 0.03242471f, 0.05291120f, -0.03531311f, 0.05005108f, 0.00893506f, 0.03900232f, 
    -0.08031084f, -0.11248285f, 0.08067360f, -0.09307916f, -0.03617020f, 0.07092590f, 0.03722410f, 0.03437525f, 
    -0.01235306f, -0.09850156f, -0.05982877f, -0.07556211f, 0.00437509f, -0.03161199f, 0.04895953f, -0.07463137f, 
    -0.07922513f, 0.00762573f, -0.09544373f, 0.00035394f, -0.04937764f, 0.02439420f, -0.04623830f, -0.07559166f, 
    -0.01396624f, 0.00558595f, 0.02664097f, -0.04613532f, -0.03241252f, -0.00526504f, -0.00911656f, 0.02632093f, 
    0.02809582f, 0.03466120f, 0.00978202f, -0.03414140f, -0.06244009f, -0.11500116f, 0.05711323f, 0.02814597f, 
    0.05678423f, 0.02326347f, 0.01357124f, -0.00040617f, -0.04023347f, -0.06186252f, 0.05355083f, -0.05981192f, 
    0.06708545f, 0.03979894f, -0.10510693f, -0.05830753f, -0.06311655f, 0.06252207f, -0.09008919f, 0.04254197f, 
    0.04260946f, -0.00548118f, -0.13373460f, -0.04276626f, -0.13361920f, 0.07153133f, -0.00629300f, -0.10080874f, 
    -0.03456313f, 0.02108708f, -0.05216528f, -0.09924581f, 0.00022743f, -0.09444708f, -0.05268147f, -0.05425071f, 
    0.02043742f, -0.01159704f, 0.01983889f, -0.02281905f, 0.01461081f, -0.07438163f, 0.04654389f, 0.02054280f, 
    0.01740503f, -0.06775955f, -0.03357400f, -0.07720874f, -0.01505858f, -0.04151428f, -0.09123079f, 0.01446260f, 
    -0.02699460f, -0.06973738f, 0.02925118f, 0.04417761f, -0.01864360f, 0.02510181f, 0.02923337f, 0.00949283f, 
    -0.01965114f, 0.04405814f, -0.05592748f, -0.08076049f, -0.06615099f, -0.01953824f, 0.08633446f, -0.10819800f, 
    0.04005746f, -0.05952379f, -0.08791270f, 0.00304947f, 0.01960145f, 0.08626280f, -0.08037356f, -0.07152116f, 
    -0.03852183f, -0.01197058f, -0.07567067f, -0.05889669f, 0.01031014f, -0.08191703f, -0.04754445f, 0.00311179f, 
    -0.01512178f, -0.02927205f, -0.02627879f, -0.01765057f, -0.06521092f, -0.10669839f, -0.06264963f, -0.06262182f, 
    -0.02696329f, -0.05290592f, -0.07381113f, -0.07620190f, -0.02448267f, 0.03305127f, -0.00627921f, -0.04720234f, 
    -0.04879525f, -0.00966142f, 0.06379536f, 0.01483212f, 0.00788320f, -0.04690775f, -0.05065414f, -0.00315294f, 
    -0.08818375f, -0.05223510f, -0.04115674f, -0.08715206f, 0.08771910f, -0.07017986f, 0.06514654f, -0.00721181f, 
    0.01784292f, -0.01399265f, 0.02862578f, -0.03866368f, -0.11303629f, -0.08316099f, -0.08536896f, 0.06158018f, 
    0.01405369f, -0.05852159f, -0.07337034f, -0.06743032f, 0.04828862f, -0.11600358f, -0.07421429f, 0.05511984f, 
    -0.03305916f, -0.01316952f, -0.03942806f, 0.03068493f, 0.06250221f, 0.05528406f, -0.09427427f, 0.00123781f, 
    -0.08241510f, 0.04107526f, 0.02248023f, 0.05948856f, -0.01398048f, -0.04742950f, 0.03542761f, -0.09739521f, 
    -0.06089129f, -0.01953490f, -0.04797941f, -0.08310731f, -0.04048379f, 0.02660800f, 0.06862401f, -0.01373268f, 
    -0.04066631f, -0.01802098f, 0.04281729f, -0.07385043f, 0.00340168f, 0.04235024f, -0.05907450f, -0.09652742f, 
    0.05962486f, 0.03398678f, -0.02417810f, -0.06243460f, 0.05601303f, -0.05155187f, 0.02277853f, 0.04304302f, 
    -0.02557667f, -0.10440093f, -0.05082490f, -0.07411052f, 0.05321224f, -0.05227882f, -0.06413890f, -0.06681903f, 
    -0.00134532f, 0.02361288f, -0.01057514f, -0.05015389f, -0.07561981f, 0.04503961f, -0.05294439f, -0.08700979f, 
    -0.05927984f, -0.01945152f, -0.08715537f, 0.00796469f, -0.14059941f, -0.03166795f, -0.05100974f, -0.04202948f, 
    -0.00948832f, 0.04335089f, 0.00817870f, 0.07170393f, -0.04772437f, -0.09537704f, -0.10903234f, 0.05921831f, 
    -0.05007723f, -0.03600578f, -0.01734880f, -0.00967035f, -0.04850404f, -0.06498708f, -0.09499879f, -0.08678450f, 
    -0.05347896f, -0.11605627f, 0.00967440f, -0.04288225f, 0.00391500f, 0.03471659f, -0.03295666f, 0.00070313f, 
    -0.09434343f, 0.00713908f, -0.03320426f, -0.10982066f, -0.05562103f, 0.00754085f, 0.02634652f, 0.00083757f, 
    -0.02577510f, 0.04667247f, 0.04933088f, -0.02635502f, -0.04984863f, 0.02365487f, -0.05060827f, -0.01202523f, 
    -0.05413819f, 0.07181603f, 0.02464405f, 0.03930370f, 0.03390907f, 0.03974009f, -0.10349235f, 0.00605433f, 
    -0.07066786f, 0.02020459f, -0.03879299f, 0.03249833f, -0.04463184f, -0.00879690f, 0.01213609f, -0.02948134f, 
    -0.07458715f, -0.08294636f, -0.06867491f, -0.12736017f, -0.09436663f, -0.06984201f, -0.02493134f, 0.02714795f, 
    0.02751224f, 0.01386191f, -0.06822816f, -0.01757062f, 0.03901889f, -0.06754348f, -0.02443890f, -0.06170765f, 
    0.00202858f, 0.08380582f, -0.06959404f, 0.05852336f, 0.00748834f, -0.09067114f, -0.07725227f, -0.12611106f, 
    0.01359388f, -0.12531477f, -0.00038375f, 0.01169765f, 0.01242745f, -0.04999034f, 0.01371665f, -0.11005261f, 
    0.03708164f, -0.06704784f, -0.01038557f, -0.11188873f, 0.02517545f, -0.10637715f, -0.10337851f, -0.00809212f, 
    -0.00923581f, -0.09037501f, -0.08063918f, -0.05172944f, -0.09624361f, -0.10970259f, 0.04488184f, 0.01954785f, 
    0.03084690f, -0.04645744f, 0.02712200f, -0.09577984f, -0.09730677f, -0.08890425f, -0.13096990f, -0.08063943f, 
    0.02333764f, 0.00844793f, -0.10441295f, 0.02536971f, -0.01790987f, 0.00700559f, -0.03383393f, -0.05223012f, 
    -0.12250451f, -0.07367663f, 0.00537994f, -0.04001068f, -0.30063069f, -0.14518419f, -0.08966564f, 0.28156808f, 
    -0.20350760f, -0.07367954f, 0.01359516f, -0.09342303f, -0.03387505f, 0.39253837f, 0.08300126f, 0.20499636f, 
    -0.00113408f, 0.06671988f, 0.00390153f, -0.06034887f, 0.59568691f, -0.07594338f, -0.13910426f, 0.20742612f, 
    0.20712598f, -0.02780664f, -0.11561712f, 0.21502192f, -0.24686798f, -0.27608952f, -0.17816243f, -0.01196938f, 
    -0.08281773f, 0.24689999f, 0.16772911f, 0.16869625f, -0.15939549f, -0.01860896f, -0.08754615f, 0.24813265f, 
    -0.31720206f, 0.03421248f, 0.07573044f, -0.13115010f, 0.56382042f, -0.07675304f, -0.11234619f, 0.15218784f, 
    0.10565118f, -0.26600194f, 0.15651800f, 0.30013257f, -0.13347659f, 0.02206530f, 0.32030547f, 0.08698510f, 
    -0.15768816f, 0.01903484f, -0.16584557f, 0.12108307f, 0.23296554f, -0.25467601f, -0.15455920f, -0.10712666f, 
    0.04505164f, -0.30322990f, 0.07144760f, -0.04313131f, -0.18344025f, 0.11342311f, -0.26056737f, 0.34033215f, 
    -0.16011614f, 0.08877168f, -0.16240068f, -0.27757126f, 0.21854943f, 0.33699173f, 0.09193856f, -0.14659716f, 
    0.25071031f, -0.07541213f, -0.09941956f, -0.13998379f, -0.14983027f, 0.19864413f, -0.02050311f, -0.23596048f, 
    -0.08264999f, 0.09954286f, -0.09067404f, -0.06028626f, 0.21382214f, -0.07727203f, -0.02839690f, 0.17865579f, 
    -0.11988443f, 0.21329902f, 0.03396160f, 0.11623979f, -0.04564239f, 0.01484688f, -0.32033849f, -0.01988355f, 
    0.13046476f, -0.26675901f, 0.04422005f, -0.05502866f, -0.49195248f, -0.18386862f, -0.03944641f, -0.00807048f, 
    -0.19759433f, 0.05799911f, -0.20152837f, 0.05075990f, 0.03936229f, -0.13401446f, -0.09304401f, 0.18170492f, 
    0.17417645f, -0.20207855f, 0.15145725f, 0.16470221f, -0.12788866f, -0.21114038f, -0.04733083f, 0.07124981f, 
    -0.00082695f, -0.70065874f, -0.19509569f, 0.08000758f, 0.15941787f, 0.33504072f, -0.01003799f, -0.09458739f, 
    -0.01463493f, 0.22351576f, -0.02881253f, 0.12217791f, -0.07092860f, 0.43136972f, 0.04680578f, -0.95333630f, 
    -0.28364322f, 0.02589814f, 0.33201724f, 0.09233623f, -0.22347824f, -0.00267536f, -0.04435460f, -0.24856953f, 
    -0.02581867f, -0.33093795f, 0.23190454f, -0.71344125f, 0.16549459f, 0.17526539f, -0.03044469f, -0.44278723f, 
    -0.28685012f, -0.06880506f, -0.26873207f, 0.21086246f, 0.08892398f, -0.07315852f, -0.30714875f, 0.43530235f, 
    0.01130148f, 0.01814050f, -0.42788860f, 0.03028295f, 0.40209162f, 0.21588108f, 0.04351898f, -0.68756133f, 
    -0.28617036f, -0.34584266f, -0.16220775f, -0.29096791f, -0.42482978f, 0.22180665f, -0.63768411f, -0.28214550f, 
    0.21979704f, 0.18841428f, -0.35422125f, 0.13447189f, 0.35566431f, 0.01241923f, -0.31248504f, -0.49317861f, 
    -0.23295426f, 0.12599936f, 0.08485060f, 0.07236668f, 0.21248955f, -0.24379408f, -0.82997674f, -0.54669404f, 
    0.23116757f, -0.20846309f, -0.20858039f, 0.04363828f, -0.35316825f, 0.08894521f, -0.14549440f, 0.34279656f, 
    0.20364022f, -0.04740899f, -0.16004398f, -0.70740128f, 0.07420395f, 0.05177254f, 0.16347763f, -0.43827528f, 
    0.06547507f, -0.46477023f, 0.15709488f, 0.15923011f, -0.53686714f, 0.02252499f, -0.04206300f, -0.13339548f, 
    -0.00183257f, -0.12274359f, 0.18903480f, 0.14900360f, 0.00084761f, 0.22398947f, 0.15654948f, -0.41941878f, 
    -0.05739689f, 0.29780406f, 0.09534946f, 0.29020169f, -0.24523108f, 0.25987616f, 0.00580918f, -0.44014692f, 
    -0.61610103f, 0.07561165f, 0.17791289f, -0.01875259f, -0.42127565f, 0.08663505f, -0.14720561f, 0.13642015f, 
    -0.68005639f, -0.11767101f, -0.20991722f, -0.22725596f, -0.31459504f, -0.63523048f, 0.29198739f, -0.17817633f, 
    0.03496500f, -0.17825779f, 0.18465766f, 0.02803434f, 0.12253345f, 0.24505395f, 0.12278342f, -0.17072588f, 
    0.28648987f, 0.22507039f, 0.05342249f, 0.05134673f, 0.06276921f, -0.32427913f, 0.17624792f, 0.22764660f, 
    0.11206904f, 0.02599682f, 0.08505661f, 0.00036705f, -0.41827461f, 0.07476460f, -0.04482072f, -0.20058431f, 
    0.03390805f, 0.07893302f, 0.08408109f, 0.08575045f, 0.06564802f, 0.26520550f, 0.16735364f, 0.30587062f, 
    -0.05199696f, -0.10574747f, -0.13375802f, -0.02023635f, 0.24205363f, 0.05841071f, 0.38343418f, -0.28813833f, 
    -0.00123750f, -0.19070211f, -0.23763366f, 0.15546727f, -0.36600721f, -0.10410040f, 0.10814272f, -0.40334189f, 
    -0.01083069f, -0.00358621f, -0.10021035f, 0.09580720f, 0.18553400f, 0.58994853f, 0.01943823f, 0.03793755f, 
    0.15586610f, 0.09689149f, 0.61040354f, -0.05732924f, 0.15409468f, 0.11127757f, 0.20360225f, 0.17905842f, 
    0.03121972f, 0.20654079f, -0.04956271f, -0.06648538f, 0.07952674f, -0.04519183f, 0.13359715f, -0.40234163f, 
    -0.18408051f, 0.08256692f, 0.37627324f, -0.02394276f, 0.20162511f, -0.11914580f, -0.01491424f, -0.32346776f, 
    -0.38668913f, -0.08424108f, 0.02031000f, 0.19286881f, -0.02885669f, -0.32939056f, -0.23037592f, 0.26994330f, 
    -0.08902427f, -0.08375747f, 0.16871716f, 0.06301074f, 0.07329246f, -0.07026336f, -0.04059417f, 0.25377512f, 
    0.21144873f, -0.04782011f, -0.04801833f, 0.18066584f, -0.00977366f, -0.02391966f, 0.28098884f, -0.32341760f, 
    0.12992322f, -0.15634030f, 0.01739052f, -0.10331383f, 0.07600575f, 0.06358758f, -0.19094829f, 0.09378652f, 
    0.11620577f, 0.15844673f, 0.09969766f, -0.04796965f, 0.20110810f, -0.00830602f, 0.12146810f, -0.25167537f, 
    0.17286828f, 0.18945763f, 0.03966720f, 0.14497891f, 0.08054188f, 0.36077794f, -0.09143537f, 0.19713964f, 
    -0.06089544f, 0.04780610f, -0.03572651f, -0.01127586f, 0.04079818f, -0.04500165f, -0.09765337f, -0.06194467f, 
    0.03836757f, -0.00429977f, -0.06444335f, -0.04227787f, -0.01888388f, -0.13474306f, -0.02525161f, -0.08500618f, 
    -0.10106803f, -0.04123485f, 0.07259270f, 0.00057756f, 0.01425936f, -0.00134590f, -0.06485426f, -0.10636836f, 
    -0.06060611f, -0.00093881f, -0.09529701f, 0.08468631f, 0.06462285f, 0.06449210f, 0.01732633f, 0.07070460f, 
    -0.08161928f, -0.05088129f, -0.11048540f, -0.05214401f, -0.08009058f, -0.06621104f, 0.04016758f, 0.04289177f, 
    -0.01123683f, 0.07310072f, -0.06272238f, -0.04539838f, -0.07806751f, 0.00243597f, -0.08108217f, -0.07126479f, 
    -0.13085237f, -0.02630109f, -0.07284993f, -0.01998300f, -0.00942698f, 0.07280184f, -0.00788147f, 0.01830877f, 
    -0.02738736f, 0.05477190f, -0.12734289f, 0.03591207f, -0.07567696f, -0.01975995f, 0.01698616f, 0.03882268f, 
    -0.13521793f, 0.01742737f, 0.08159540f, 0.06466258f, -0.00100428f, -0.14913601f, -0.01879294f, -0.10988480f, 
    0.01082837f, 0.06750152f, -0.02877712f, 0.04654822f, 0.00282179f, -0.10214081f, -0.01711993f, 0.03711722f, 
    -0.00008315f, 0.04287214f, -0.10260625f, -0.05520922f, -0.00741654f, -0.00298518f, -0.08711888f, -0.06853894f, 
    -0.01121405f, -0.04794897f, -0.11106948f, 0.04791777f, -0.03580802f, -0.08661459f, 0.04983286f, -0.10225122f, 
    -0.01595615f, -0.01326737f, -0.11048304f, 0.00946286f, -0.04194147f, 0.01129606f, -0.08444101f, -0.02506462f, 
    -0.00262129f, -0.03220041f, -0.02509731f, -0.02433716f, 0.03908314f, 0.05834222f, -0.04258605f, -0.06258204f, 
    0.02651553f, -0.05618878f, 0.05611626f, 0.03535162f, 0.02721730f, -0.05838523f, -0.10274570f, -0.15615508f, 
    0.04240201f, -0.14809081f, -0.11752316f, -0.03604627f, 0.07278362f, -0.07325024f, 0.00593787f, 0.00030275f, 
    0.06880901f, -0.32276428f, 0.12489898f, 0.03649199f, -0.02597239f, 0.01884149f, 0.16550246f, -0.18298604f, 
    -0.04127747f, -0.12934887f, 0.05082076f, 0.15251102f, -0.08489642f, -0.41397566f, -0.22898242f, 0.37624198f, 
    -0.00433811f, -0.03101366f, -0.00327253f, 0.08322989f, 0.07833699f, -0.07663327f, -0.04381753f, -0.39754167f, 
    -0.00367190f, 0.05749207f, 0.01004043f, 0.32622901f, -0.05176039f, 0.19824606f, 0.10326746f, 0.39355204f, 
    0.06379919f, -0.28595942f, -0.09667866f, 0.10490341f, -0.01011469f, 0.04969342f, 0.33876783f, -0.21537915f, 
    -0.10836376f, -0.01379243f, 0.18318959f, 0.10847116f, -0.10380398f, 0.06318879f, 0.10390990f, -0.04389201f, 
    -0.14141476f, -0.17176923f, -0.11745644f, 0.08306920f, 0.26738042f, -0.22337678f, 0.17583442f, 0.04358085f, 
    0.07089522f, 0.01135973f, 0.05709222f, 0.10827343f, 0.07998363f, 0.02401315f, -0.04193999f, 0.36745539f, 
    0.04534065f, 0.22236446f, 0.10567306f, -0.00050235f, 0.03897990f, -0.11331630f, 0.31081370f, -0.04867644f, 
    0.01513427f, 0.11666021f, -0.08001848f, 0.10813434f, 0.17285720f, -0.06116666f, 0.04546135f, 0.16972360f, 
    -0.05797074f, -0.02329887f, 0.13778912f, 0.09627721f, -0.01699736f, 0.07896725f, -0.00829655f, 0.19344169f, 
    0.32317260f, -0.00339330f, -0.02731504f, 0.07761335f, 0.47043774f, 0.06744365f, -0.00043432f, 0.03397040f, 
    -0.03688760f, 0.06527921f, -0.05558172f, -0.06463096f, 0.31223395f, -0.06916637f, 0.18323424f, -0.21995071f, 
    -0.03643201f, -0.07211490f, -0.05321631f, 0.21678291f, 0.04137707f, -0.03251730f, 0.09293011f, -0.02735062f, 
    0.21285105f, 0.09001469f, -0.13088520f, 0.21128961f, 0.04699945f, -0.00277032f, 0.15550132f, -0.16922583f, 
    0.30935904f, 0.06603579f, -0.23686695f, 0.48821855f, 0.41261381f, 0.00942204f, 0.01524249f, -0.06405772f, 
    0.14747499f, 0.23229428f, -0.03696228f, 0.07432140f, -0.09842801f, -0.28362256f, 0.34982902f, -0.06354730f, 
    -0.13976884f, -0.14698753f, -0.04308067f, 0.11032009f, 0.22445139f, 0.06540821f, 0.08278455f, -0.07095365f, 
    0.18778026f, 0.00387785f, -0.22070746f, 0.07098926f, 0.50006795f, 0.04607667f, -0.00845737f, 0.15106270f, 
    -0.15987529f, -0.01246247f, -0.16210163f, -0.04309507f, -0.08885265f, 0.09973463f, 0.01567340f, 0.03018293f, 
    0.05551758f, 0.15071318f, 0.20051534f, 0.05557128f, 0.00623826f, -0.11427728f, -0.11041595f, -0.13553584f, 
    0.06535795f, 0.06990238f, 0.08349120f, -0.24955159f, -0.14148736f, 0.01195994f, 0.24000984f, 0.33025384f, 
    -0.10897299f, -0.31077251f, 0.12719436f, 0.06392596f, 0.14969113f, -0.25767696f, -0.01002684f, -0.04343613f, 
    0.04076291f, -0.02100133f, -0.07838755f, 0.08220843f, -0.15094718f, 0.04121657f, 0.06363431f, -0.60653210f, 
    -0.13174845f, 0.24726652f, -0.08015343f, -0.08300511f, -0.05094226f, 0.23244724f, -0.22504352f, -0.02709655f, 
    0.19248861f, 0.00488035f, -0.08390120f, 0.03772278f, -0.40383351f, 0.01962963f, 0.22892182f, 0.21249227f, 
    0.13283266f, 0.06317938f, 0.24679655f, -0.14626734f, -0.12517551f, 0.16402887f, 0.15888815f, -0.02913792f, 
    -0.03251014f, 0.05187278f, -0.10053504f, 0.01637770f, -0.01322600f, -0.00666980f, 0.01663425f, 0.04989025f, 
    -0.06996970f, 0.01449472f, 0.11490283f, -0.02489004f, 0.06927944f, 0.02299113f, -0.05671329f, 0.04480893f, 
    -0.23410748f, 0.04227354f, -0.11487421f, 0.10486473f, -0.04901710f, -0.06014137f, 0.08402929f, 0.23014958f, 
    -0.31390691f, -0.19179384f, -0.07613162f, -0.08383305f, 0.23114549f, 0.06867073f, -0.05910034f, 0.23465857f, 
    -0.20393701f, 0.25318184f, 0.01823781f, 0.00478371f, 0.23607631f, -0.26747891f, 0.09104118f, 0.07669699f, 
    0.04557425f, -0.04084843f, 0.02805373f, -0.04471653f, 0.06925991f, -0.06387445f, 0.05227781f, 0.06103219f, 
    0.01365737f, 0.07123055f, -0.01543699f, 0.02691549f, -0.04166067f, -0.10485927f, -0.09890824f, -0.01776755f, 
    -0.00115406f, 0.06856781f, -0.03490362f, 0.03727553f, -0.07747977f, 0.07349856f, -0.06851095f, 0.04086847f, 
    -0.08171152f, 0.04220209f, -0.07120490f, -0.09643234f, 0.05319213f, -0.00395640f, 0.02875772f, 0.01615041f, 
    -0.03343488f, 0.06684101f, -0.08444458f, 0.02887589f, -0.08067580f, 0.05829236f, 0.08107771f, 0.00762878f, 
    0.02596033f, -0.00744835f, -0.04045878f, 0.05087925f, 0.07357508f, -0.00434969f, 0.01219775f, -0.05076112f, 
    -0.10137249f, -0.02935316f, 0.04547134f, 0.01379790f, -0.01861773f, 0.07597024f, 0.03124729f, 0.01167906f, 
    -0.06559727f, -0.08028835f, 0.02015544f, -0.06745991f, -0.07253762f, 0.00055630f, -0.03045156f, 0.03543659f, 
    -0.08611548f, 0.00577238f, -0.07854165f, -0.08501367f, -0.06865273f, -0.05201390f, -0.04613009f, -0.06000161f, 
    -0.05665309f, -0.05683945f, 0.02327973f, -0.04831913f, -0.05833319f, -0.07693937f, 0.05352127f, -0.03227598f, 
    -0.10278968f, -0.03178862f, 0.03077154f, -0.01361979f, -0.03430844f, -0.09744581f, -0.10913032f, 0.05923827f, 
    -0.00816493f, -0.02624159f, -0.08781835f, 0.05620205f, -0.04340872f, -0.04882741f, 0.02341886f, 0.00249332f, 
    -0.05155534f, 0.00305515f, -0.10246080f, -0.06471626f, -0.05077779f, -0.00777208f, -0.05984348f, 0.01210910f, 
    -0.01918021f, 0.00337637f, -0.03623334f, -0.00975970f, -0.02605793f, -0.06034801f, 0.05953700f, -0.08834244f, 
    -0.06133442f, -0.04192263f, -0.09230150f, -0.03783209f, 0.00891224f, -0.03557367f, -0.05093507f, 0.00497573f, 
    0.03164085f, 0.05569820f, 0.01442492f, -0.08717954f, 0.02715631f, 0.01109403f, -0.03414044f, -0.06548355f, 
    0.11507680f, -0.27230281f, -0.01010536f, -0.08296953f, -0.11615346f, -0.24450651f, -0.18377669f, 0.22582775f, 
    -0.49564320f, -0.27076185f, 0.12235490f, 0.26538524f, 0.18071850f, -0.13071318f, -0.00842000f, 0.19816761f, 
    -0.04053762f, 0.00841014f, 0.15286452f, 0.04901780f, -0.42777574f, -0.01951273f, -0.00551412f, 0.04207666f, 
    -0.00694469f, 0.08387099f, -0.02071302f, -0.03934818f, 0.23101342f, 0.01447066f, 0.13483384f, 0.10746808f, 
    -0.31373203f, -0.08228613f, 0.10153145f, -0.06037148f, -0.04855590f, 0.10232760f, -0.00767849f, 0.28546098f, 
    0.17500220f, 0.13238731f, 0.11472308f, -0.15422083f, -0.12816295f, 0.13373169f, 0.02702328f, 0.04558147f, 
    0.13573077f, -0.49276847f, 0.17551249f, 0.05435552f, -0.07537052f, 0.09681823f, -0.02035449f, 0.02567201f, 
    0.02332980f, -0.30678862f, -0.08800869f, 0.08734754f, -0.07902450f, 0.36427718f, 0.16504514f, -0.09800708f, 
    0.10794732f, -0.26866460f, 0.07805917f, 0.09526157f, 0.01462958f, -0.08493589f, -0.23222107f, 0.04190450f, 
    -0.05561336f, 0.07239611f, 0.19610421f, -0.18156205f, 0.12980267f, 0.34449506f, -0.05180299f, -0.06319012f, 
    0.09826565f, -0.07952730f, -0.06553512f, -0.29881850f, 0.14699987f, -0.14368209f, -0.24005209f, -0.21300459f, 
    -0.09749198f, 0.18255639f, 0.05162759f, -0.02612790f, -0.06855775f, 0.05088556f, -0.04578095f, 0.10439536f, 
    0.06278288f, -0.09782426f, -0.11859403f, 0.01645228f, -0.19193122f, 0.06929806f, -0.19056605f, 0.20652527f, 
    0.20920038f, -0.01160235f, 0.12529930f, -0.21006577f, -0.06496577f, -0.15433489f, 0.14062566f, -0.00534839f, 
    -0.44238195f, -0.55340964f, -0.02027828f, 0.07929056f, 0.14583810f, 0.01758894f, -0.01106858f, -0.23820342f, 
    -0.02398096f, -0.14031942f, 0.32334372f, -0.11401130f, -0.03792334f, -0.05740639f, 0.09569585f, 0.25354904f, 
    0.19270562f, -0.74358106f, -0.01516126f, 0.04651197f, -0.27332091f, -0.07537241f, -0.17064050f, 0.20643087f, 
    -0.47313133f, -0.08579429f, 0.03848449f, 0.43059680f, 0.06098623f, -0.04933411f, -0.02598660f, 0.06425882f, 
    0.13205911f, -0.00405658f, -0.01389915f, 0.18890280f, 0.43910986f, -0.08077826f, 0.03806426f, -0.42631936f, 
    -0.00628783f, -0.24752665f, 0.00309774f, 0.00798914f, 0.05081730f, -0.06158864f, 0.07802645f, 0.03547077f, 
    -0.38238084f, 0.16977879f, 0.16665824f, -0.00212744f, 0.00353296f, -0.03669111f, -0.22270653f, 0.00919002f, 
    0.08624396f, 0.46153831f, 0.27457991f, -0.09687592f, 0.01602599f, 0.16391248f, 0.07537521f, 0.20362344f, 
    -0.21096712f, -0.49976209f, 0.15585750f, 0.61383617f, 0.07382077f, 0.18456468f, 0.26212123f, 0.05851871f, 
    0.01253970f, -0.08155246f, 0.06310575f, 0.16149904f, -0.11944763f, 0.19846083f, -0.00133856f, -0.12933445f, 
    -0.09170654f, -0.16576302f, 0.06629489f, -0.13257140f, -0.15943186f, 0.00362466f, 0.10487578f, 0.15374874f, 
    0.14954279f, 0.10085497f, 0.46261021f, -0.35626110f, 0.32147107f, 0.04471986f, 0.13515948f, 0.15604651f, 
    0.17349865f, 0.08344600f, 0.30004433f, -0.06320324f, 0.03821196f, 0.07256019f, 0.05539633f, -0.19808608f, 
    0.22780803f, 0.18975437f, -0.15548488f, -0.19371469f, -0.20220001f, -0.00890408f, 0.05435053f, -0.06528281f, 
    0.04767261f, -0.04422614f, -0.32423306f, -0.09517051f, -0.06983393f, 0.18422714f, -0.09646264f, 0.67183715f, 
    0.37272209f, -0.03429021f, -0.17323092f, 0.01671507f, 0.07621832f, -0.23482274f, -0.01432483f, -0.26365694f, 
    -0.06025473f, 0.17571644f, -0.50744784f, -0.06356306f, 0.06526143f, -0.21388538f, 0.06383242f, 0.11031218f, 
    -0.02872893f, -0.11281620f, 0.18092321f, 0.29423630f, -0.01624066f, -0.33756116f, 0.16634469f, 0.19487347f, 
    0.33920237f, -0.06891112f, 0.07020377f, 0.06187623f, -0.09674014f, -0.12771893f, -0.32540900f, 0.10392611f, 
    -0.02270103f, 0.09756940f, 0.01976126f, -0.19132346f, 0.21816598f, -0.11688620f, 0.14328070f, 0.11433892f, 
    -0.01642208f, 0.07794725f, -0.16510384f, 0.12539051f, -0.21400242f, 0.08475906f, 0.03560502f, -0.30426937f, 
    -0.20205468f, -0.13484155f, -0.02737822f, -0.08994354f, 0.09385514f, -0.37697795f, 0.32119033f, 0.23189254f, 
    -0.14389847f, -0.09125598f, 0.02851950f, -0.01158825f, 0.22119310f, 0.01217354f, -0.09577662f, -0.24664865f, 
    0.14270529f, 0.01847271f, 0.39845809f, 0.00185014f, -0.44261768f, 0.06399622f, 0.35417241f, 0.28632599f, 
    -0.19979574f, 0.29703972f, 0.07385365f, 0.58771980f, 0.23512204f, 0.24624950f, 0.22016229f, 0.03484582f, 
    0.24294834f, -0.19889967f, -0.15531960f, -0.07126543f, -0.09724408f, 0.22985356f, 0.15880981f, 0.26269990f, 
    -0.10503189f, -0.04615176f, 0.01558303f, -0.07461482f, -0.08825325f, -0.16029164f, -0.00878603f, 0.04041729f, 
    0.12113269f, 0.00266876f, 0.26024806f, 0.07726004f, 0.12306695f, -0.14098369f, 0.15612967f, 0.26564625f, 
    -0.06467962f, 0.06711293f, 0.31560251f, 0.24379258f, -0.00647165f, -0.00205096f, -0.17421705f, 0.14403318f, 
    0.16775160f, 0.08524090f, -0.01585868f, -0.03961671f, -0.21243010f, 0.05514348f, 0.07765657f, -0.15569523f, 
    0.05836108f, -0.34595102f, -0.11320309f, -0.17161204f, 0.16559571f, 0.18619700f, 0.18912615f, 0.42765835f, 
    0.14822036f, 0.05830078f, -0.17829065f, -0.05180218f, -0.01978903f, -0.07250149f, 0.10783259f, -0.19879387f, 
    0.00523091f, 0.06831792f, -0.31855762f, -0.04680267f, -0.00422760f, -0.08243163f, 0.21091487f, -0.03125134f, 
    -0.01868501f, 0.02725227f, -0.00318091f, -0.06808762f, -0.14282686f, -0.01294296f, 0.06570113f, -0.08018151f, 
    0.07132322f, -0.35776627f, -0.00146528f, 0.08254384f, -0.50999433f, -0.59919471f, 0.06203744f, 0.25081810f, 
    -0.14965264f, -0.47106519f, 0.04823479f, 0.12655342f, 0.15053840f, -0.04533450f, -0.04339886f, 0.06879463f, 
    -0.16063520f, 0.07233639f, -0.14287259f, -0.06464082f, -0.12116282f, -0.06634326f, 0.21864840f, -0.29971948f, 
    -0.23495845f, 0.07048239f, -0.12083516f, -0.04947087f, 0.01793021f, -0.07640281f, -0.06604522f, 0.07386053f, 
    0.46408135f, -0.01539088f, 0.13645950f, -0.13858804f, -0.17899664f, -0.00512574f, 0.21432285f, -0.13877700f, 
    0.43953353f, 0.63763356f, 0.20718463f, -0.26851156f, -0.20515786f, -0.16576760f, 0.14049935f, 0.34413040f, 
    -0.06158802f, 0.39394465f, 0.13934882f, -0.05403554f, 0.28425851f, -0.10560149f, -0.13936768f, 0.10910837f, 
    -0.19650149f, -0.30677068f, 0.00019724f, 0.19213125f, -0.84368324f, 0.12504321f, 0.40779516f, -0.38203076f, 
    0.12431967f, 0.13770252f, -0.12108388f, 0.17775242f, -0.11479910f, 0.19258711f, 0.23711415f, -0.05051744f, 
    0.15671808f, 0.21317978f, 0.23736091f, -0.11875385f, -0.60405350f, 0.11607685f, 0.12945049f, -0.03290090f, 
    -0.03158333f, 0.07308732f, 0.32928333f, 0.39366886f, 0.00098871f, -0.00528283f, 0.14029737f, -0.01187845f, 
    -0.26531458f, 0.31228995f, -0.32510829f, 0.02495032f, 0.19878854f, -0.05292412f, 0.06467411f, -0.02671207f, 
    0.03638715f, -0.28865901f, -0.06730690f, -0.11431398f, -0.26905331f, -0.60387081f, -0.16531992f, 0.02643726f, 
    0.20868570f, -0.31926581f, -0.40106475f, -0.10438174f, -0.26077268f, -0.31761447f, 0.36929041f, 0.37974653f, 
    0.07724573f, -0.65073770f, -0.38191599f, 0.05886986f, 0.07072026f, -0.08708239f, -0.02330614f, 0.06273950f, 
    0.11495128f, 0.26867780f, 0.07600021f, -0.09922205f, -0.00704656f, 0.02976861f, -0.31805137f, 0.14381817f, 
    -0.01234672f, 0.03413307f, -0.10426667f, 0.02291986f, -0.04129634f, -0.11948121f, -0.09167026f, 0.03421754f, 
    0.02047065f, -0.07775225f, -0.10309651f, -0.05966048f, -0.09308580f, -0.07740825f, -0.09676065f, -0.01455157f, 
    0.04202130f, 0.01074095f, 0.00650712f, -0.00443267f, 0.00077898f, -0.05640431f, -0.09633421f, 0.03289345f, 
    -0.00209750f, 0.03168099f, -0.11867628f, -0.09963462f, -0.08480012f, 0.02694879f, 0.00555142f, 0.05410131f, 
    -0.06511919f, -0.09052319f, -0.07333912f, 0.05390354f, -0.09410951f, 0.00854125f, 0.02566388f, -0.02636288f, 
    -0.01728887f, 0.00382482f, 0.06213764f, -0.00920726f, 0.02395069f, -0.02027738f, -0.03732150f, -0.02032669f, 
    -0.11857887f, -0.01575338f, 0.02332825f, -0.06486698f, 0.00121402f, -0.05899538f, 0.03975271f, -0.03336101f, 
    -0.01142488f, -0.00931407f, 0.02924825f, -0.07387000f, -0.07209537f, 0.04472234f, -0.08925976f, 0.03404092f, 
    -0.05041411f, -0.04136815f, -0.02868357f, -0.07872967f, -0.02456713f, -0.00574747f, -0.06907777f, -0.09129866f, 
    -0.09922510f, -0.00986756f, -0.06976073f, -0.00141525f, -0.13986918f, 0.02376329f, 0.05571613f, -0.07657252f, 
    0.04994742f, 0.07831394f, 0.00038261f, -0.05018609f, 0.00312690f, -0.04692645f, -0.05552792f, -0.01406179f, 
    -0.09251333f, -0.11046665f, -0.00717474f, -0.05027128f, 0.01621843f, 0.04430962f, -0.04746553f, -0.04694853f, 
    0.01271224f, 0.01160280f, -0.01537632f, -0.07143934f, -0.01617526f, -0.00957529f, -0.06907953f, -0.02717290f, 
    -0.07697605f, -0.00753206f, -0.05437818f, -0.04158182f, -0.13976875f, 0.02724710f, -0.01448714f, 0.10307067f, 
    0.05880693f, -0.08455088f, -0.13564067f, -0.11221471f, -0.12219409f, -0.13361885f, -0.01263181f, -0.07401151f, 
    -0.00911657f, -0.09225863f, -0.00273988f, -0.01773605f, 0.00812823f, 0.01185460f, -0.02867143f, -0.01834843f, 
    0.12945847f, 0.22672634f, -0.06153080f, 0.09453785f, 0.06412194f, 0.08936168f, -0.20629236f, -0.02706176f, 
    0.04455003f, -0.05147374f, 0.04330726f, -0.49800047f, 0.09372608f, 0.22339077f, -0.03978631f, 0.26930580f, 
    -0.38851154f, -0.03696266f, 0.22687636f, -0.01121360f, -0.00642876f, 0.00292293f, 0.14561899f, -0.26046944f, 
    -0.27718145f, -0.06369509f, 0.05713597f, -0.30965343f, 0.10300004f, -0.10758773f, 0.09100678f, 0.34160385f, 
    0.28989884f, -0.28726047f, -0.19754256f, -0.22556974f, 0.26617494f, -0.01163174f, -0.10315955f, -0.45356217f, 
    0.11942217f, -0.30054298f, 0.40078187f, 0.00085812f, -0.44953319f, 0.15165356f, 0.25490445f, -0.04247327f, 
    -0.03937760f, 0.32437408f, 0.00270429f, 0.06923757f, 0.09023709f, 0.53906530f, -0.28586078f, 0.09954432f, 
    0.21807876f, 0.09333297f, 0.42874682f, 0.14689402f, 0.05847825f, 0.24067034f, 0.04746490f, 0.07375560f, 
    0.10649541f, 0.31410462f, 0.01859193f, 0.08432505f, 0.17981975f, -0.00882925f, 0.12552741f, -0.58091116f, 
    0.14923649f, 0.00753687f, 0.03193294f, 0.11904249f, 0.17456971f, 0.26995111f, -0.05949752f, 0.21339732f, 
    -0.12053996f, -0.04544531f, 0.17614916f, 0.20851023f, 0.07699613f, 0.00621299f, 0.23818910f, -0.00182321f, 
    0.01611692f, 0.06832567f, 0.05195575f, 0.03170284f, -0.10184758f, -0.01188185f, -0.05196999f, 0.10882054f, 
    0.14717494f, -0.64954758f, 0.29665864f, 0.01606378f, 0.14604591f, -0.14895979f, 0.17698690f, -0.37575758f, 
    -0.11453933f, 0.08485642f, 0.07746831f, 0.05155529f, -0.05692237f, 0.12329222f, 0.14683999f, 0.11994975f, 
    -0.18600236f, -0.06189183f, -0.11719090f, 0.22990482f, -0.03108602f, 0.27698120f, 0.19461332f, -0.01588330f, 
    -0.21114616f, 0.23861906f, -0.09146221f, 0.12389280f, 0.05234268f, 0.00390485f, -0.19677415f, -0.23322751f, 
    0.04316067f, -0.19954981f, -0.22904001f, -0.08409551f, -0.39927039f, 0.02793100f, -0.28257173f, 0.20008609f, 
    0.00396428f, 0.01715249f, -0.13906752f, 0.08608834f, 0.04859960f, 0.18353575f, 0.11384417f, 0.19134480f, 
    -0.37387556f, 0.07284412f, 0.10089936f, -0.02608655f, 0.43981627f, -0.04282603f, -0.10999180f, 0.20179078f, 
    0.12227964f, -0.31516930f, -0.13542698f, 0.32782021f, -0.14136454f, -0.25308499f, -0.27283189f, 0.19797683f, 
    -0.27552441f, 0.30931571f, 0.25482935f, 0.22706059f, 0.13032463f, 0.06193703f, -0.23639306f, 0.08738687f, 
    -0.15750496f, -0.21192914f, -0.12859938f, -0.15349990f, 0.64254439f, -0.09747174f, -0.07396413f, 0.01023521f, 
    -0.14828186f, -0.23399316f, 0.16755623f, 0.28182653f, -0.04847411f, 0.08690353f, 0.25779188f, 0.08786803f, 
    0.16435790f, 0.06835545f, 0.10288406f, 0.14825980f, 0.08872371f, 0.04741894f, -0.19779360f, 0.19736226f, 
    0.03219393f, -0.05449502f, -0.06260134f, -0.02439858f, -0.11959992f, 0.02716440f, -0.25854263f, 0.56075364f, 
    -0.34398893f, -0.03116727f, 0.08349615f, -0.47572002f, 0.49977615f, 0.15408510f, 0.21930981f, -0.12693782f, 
    0.18438660f, 0.05919592f, -0.13207908f, -0.16341998f, -0.30029777f, 0.20550255f, -0.12358575f, 0.27561614f, 
    -0.00549669f, 0.01824410f, -0.07537939f, -0.42431194f, 0.07708245f, -0.01257800f, -0.07133050f, -0.22505662f, 
    0.11646301f, 0.20632870f, 0.11900412f, 0.05676517f, -0.10365672f, -0.03722568f, -0.19129826f, 0.52641994f, 
    0.03528937f, -0.19350976f, -0.17205240f, -0.15580590f, -0.25195253f, 0.00135656f, -0.10881545f, -0.21996807f, 
    -0.30976555f, 0.22488573f, -0.26161990f, 0.01754651f, -0.08087222f, -0.10016459f, 0.14623564f, 0.33883768f, 
    0.08768891f, 0.07283025f, 0.08371598f, 0.15214200f, -0.09325313f, -0.01501407f, -0.19843245f, 0.04200445f, 
    0.23818491f, -0.07660084f, 0.06660268f, -0.05053455f, 0.43922892f, -0.20057921f, 0.11730707f, 0.07949907f, 
    0.08410248f, -0.29484019f, 0.13235894f, -0.21917537f, 0.02545820f, 0.32511440f, -0.07570799f, 0.17223608f, 
    -0.00693111f, 0.08085790f, -0.11463726f, 0.11971809f, 0.52200902f, -0.01669191f, -0.27008194f, -0.20790735f, 
    0.17498958f, -0.02152258f, -0.46880007f, 0.16224799f, -0.33025324f, -0.83589870f, 0.07312854f, 0.11326589f, 
    -0.02298983f, 0.10705557f, 0.19270028f, 0.17123508f, -0.02500421f, 0.10627455f, 0.16763858f, -0.66964138f, 
    -0.58222812f, -0.23299555f, 0.47027451f, -0.00027499f, 0.57571894f, -0.14450486f, 0.25103006f, -0.05998431f, 
    0.09423935f, -0.59362835f, 0.09499720f, -0.16843714f, 0.02668924f, 0.22246252f, 0.28277472f, 0.02865197f, 
    -0.25049654f, -0.09131862f, 0.01719230f, 0.04301903f, 0.13728908f, -0.29830712f, -0.10214876f, 0.14549744f, 
    0.23202653f, -0.17913528f, 0.00273910f, -0.03625391f, -0.09840541f, -0.08971347f, -0.88418019f, 0.31895411f, 
    -0.25595117f, 0.04282442f, -0.42135429f, -0.15569709f, 0.37831184f, 0.07407425f, 0.12991770f, -0.29097891f, 
    0.16028343f, 0.07143798f, 0.01407644f, -0.79432321f, -0.42638958f, 0.28418630f, -0.24942695f, -0.13623686f, 
    0.17958018f, -0.14481051f, 0.09473210f, -0.25658879f, 0.28649881f, 0.00526323f, -0.01767250f, 0.18016239f, 
    0.23932557f, 0.19941519f, -0.53885937f, 0.14690898f, 0.26604941f, -0.28713140f, 0.04116995f, -0.19405404f, 
    0.30101505f, -0.58654886f, -0.24658546f, -0.04733834f, 0.45015478f, -0.45826742f, -0.02773112f, -0.33659917f, 
    0.38968849f, -0.28204060f, -0.17456394f, -0.13677180f, 0.11217505f, -0.46521208f, 0.02738606f, 0.37436113f, 
    -0.01149796f, 0.09693983f, -0.16249542f, 0.35488272f, 0.29356831f, 0.16569741f, -0.80696964f, -0.13105656f, 
    0.08380651f, 0.26871830f, -0.00953672f, 0.04008744f, -0.25855637f, -0.30140638f, 0.26455203f, 0.07596356f, 
    0.13129574f, -0.07971393f, -0.08111697f, -0.07025731f, 0.04963471f, -0.07901178f, -0.06845877f, 0.12558976f, 
    0.15835153f, -0.02763678f, -0.18561903f, 0.02077087f, 0.26876542f, 0.04188855f, 0.15070894f, -0.08070391f, 
    -0.04101947f, 0.03475914f, -0.05836648f, -0.04771300f, -0.03704286f, -0.08464921f, 0.12096635f, 0.36249939f, 
    0.33436921f, -0.09832191f, 0.03914151f, -0.03475589f, 0.05549946f, -0.01942199f, 0.16500036f, -0.43864447f, 
    0.37337345f, 0.03504843f, 0.33262780f, -0.03304257f, -0.20217277f, -0.11811209f, 0.15033095f, 0.43417317f, 
    -0.07391507f, -0.00231721f, -0.02403073f, 0.35236984f, 0.46043169f, 0.06197739f, 0.02612293f, 0.10067443f, 
    -0.03403670f, -0.08441018f, 0.22800046f, 0.09530288f, -0.27423939f, 0.10225321f, 0.10664988f, -0.66669983f, 
    0.12502269f, 0.17968976f, -0.02242346f, -0.07477502f, -0.13197681f, 0.16213095f, 0.11526943f, -0.16189337f, 
    -0.02696784f, 0.18140234f, 0.27029833f, 0.02015330f, 0.30911434f, 0.01841391f, 0.02713355f, 0.02875352f, 
    -0.10728324f, -0.01678122f, 0.29619056f, 0.26425731f, 0.08586600f, -0.05564971f, 0.11956701f, 0.17837155f, 
    -0.05169922f, 0.17570427f, -0.03513933f, -0.09541060f, 0.07342944f, -0.03731008f, 0.03969727f, -0.00306634f, 
    -0.00530479f, -0.02619761f, -0.01028012f, 0.10308316f, -0.05123242f, -0.31886795f, 0.01576660f, 0.07665063f, 
    0.01772994f, -0.02656776f, -0.15271570f, -0.09069224f, 0.25507882f, -0.11087093f, 0.12700360f, 0.34850785f, 
    -0.32615322f, 0.16383147f, -0.06139738f, -0.07751853f, 0.18172245f, -0.07054516f, 0.06079835f, -0.18340716f, 
    0.03371468f, 0.28549951f, 0.13977750f, 0.25531629f, 0.08438994f, -0.01561944f, -0.22491142f, 0.08161975f, 
    0.15343152f, 0.09087065f, -0.04627830f, 0.06023275f, 0.04565480f, 0.10886688f, -0.02834223f, 0.17857391f, 
    -0.28193605f, 0.04229292f, 0.09894790f, 0.43526843f, 0.09349585f, 0.19662839f, 0.05449072f, -0.15742391f, 
    0.34449112f, -0.08097109f, 0.10510673f, 0.20075797f, 0.14499253f, -0.05272175f, 0.01996604f, 0.20087859f, 
    0.07168853f, -0.07303564f, -0.04110752f, 0.04274475f, -0.00910800f, 0.27197081f, -0.00673976f, -0.25008297f, 
    -0.09492514f, 0.26233014f, 0.23473200f, 0.09980781f, 0.00688559f, -0.00177134f, -0.15991208f, 0.32252747f, 
    0.04990072f, 0.38302416f, -0.09340219f, 0.00967743f, 0.07097319f, 0.08323728f, -0.00173352f, 0.25246671f, 
    -0.08318973f, -0.16561770f, 0.23782003f, -0.00619739f, 0.01139566f, -0.49030983f, 0.18900011f, 0.00938401f, 
    0.01026915f, -0.08259090f, -0.51036018f, -0.05046768f, 0.06714875f, -0.16880408f, 0.00691171f, -0.14597727f, 
    0.03383657f, 0.02413565f, 0.00114117f, 0.04349571f, -0.03137973f, -0.00916291f, -0.34447625f, 0.65296614f, 
    0.21237217f, 0.06638636f, -0.29449517f, 0.03012851f, -0.26704165f, -0.10415840f, 0.16101652f, 0.11931643f, 
    0.27413377f, 0.05528546f, 0.08583945f, -0.21810012f, 0.01479121f, 0.36407936f, 0.05053645f, -0.26907867f, 
    0.19872563f, -0.02634544f, -0.17197907f, 0.05463491f, 0.00559996f, 0.07041820f, 0.08290169f, -0.00794231f, 
    -0.05882603f, 0.04213135f, 0.09424986f, -0.04739300f, 0.08801916f, 0.43146896f, -0.07698148f, 0.48847407f, 
    0.10151812f, 0.08906800f, 0.09212978f, 0.26406801f, -0.06531461f, -0.04052827f, 0.14636815f, -0.13394615f, 
    0.21205458f, -0.17966488f, 0.15167472f, 0.01163450f, 0.17031680f, -0.12091827f, -0.04184813f, 0.13496825f, 
    -0.04590131f, 0.07581674f, 0.12788777f, 0.14389428f, 0.09189974f, -0.34369102f, 0.22587585f, 0.13035986f, 
    0.09486242f, 0.03104734f, 0.00633352f, 0.05767784f, -0.13688686f, 0.32916349f, 0.00982181f, -0.22752093f, 
    0.01548844f, 0.12587810f, 0.05853548f, -0.06798348f, 0.02536100f, -0.10601607f, 0.05405781f, -0.02725896f, 
    -0.20472907f, -0.06681042f, 0.25072074f, 0.17798047f, -0.25447536f, 0.05329760f, 0.09485879f, 0.01085635f, 
    -0.23921292f, -0.03551058f, 0.10197409f, -0.23115239f, 0.06685907f, 0.08218523f, 0.00995796f, 0.02668004f, 
    -0.02875971f, 0.06108309f, 0.14621550f, -0.19110529f, 0.02914938f, -0.00517993f, 0.23106164f, -0.13628949f, 
    0.14980710f, -0.11596581f, -0.01252278f, 0.26245162f, -0.33690119f, 0.09858459f, 0.04723571f, -0.07565915f, 
    -0.05969880f, 0.24560018f, -0.16604896f, -0.25320229f, 0.21891691f, 0.00208780f, -0.08122317f, 0.08134489f, 
    0.13472086f, 0.07940884f, 0.23245616f, 0.12506285f, -0.23849751f, 0.12399349f, 0.07967889f, 0.59657001f, 
    -0.20862094f, 0.13360263f, -0.06929825f, -0.03922363f, 0.18107888f, -0.09298681f, 0.09734516f, -0.10430895f, 
    0.10313026f, -0.03408299f, 0.10122433f, -0.01487538f, -0.11372026f, -0.09515385f, 0.02648917f, -0.04374239f, 
    -0.00888476f, 0.06355318f, 0.08491491f, -0.06006689f, 0.18734287f, 0.08490398f, 0.11268615f, 0.13530886f, 
    0.04082322f, -0.18300939f, 0.05698747f, -0.12759061f, -0.16932535f, 0.04850866f, -0.02323096f, -0.21510600f, 
    0.22742914f, 0.00964758f, -0.02137792f, 0.01040476f, 0.16508801f, -0.04640347f, 0.27392814f, -0.27097479f, 
    0.12569450f, 0.11776796f, -0.14846878f, -0.16167131f, -0.14439410f, 0.07262619f, 0.14607690f, -0.08644498f, 
    0.24853578f, -0.04399300f, -0.01146648f, -0.03243465f, -0.10868079f, 0.04632453f, 0.15156649f, 0.04810562f, 
    -0.06156197f, 0.21553506f, -0.21564317f, 0.11448424f, 0.27264073f, -0.05389129f, -0.04278183f, -0.24662863f, 
    0.00354265f, 0.04590838f, -0.03886024f, -0.00326848f, 0.03379540f, -0.01340838f, 0.00102140f, -0.02543646f, 
    -0.09821111f, -0.00099831f, -0.07933936f, -0.06860893f, 0.03568919f, -0.02369601f, -0.06693794f, -0.08800008f, 
    -0.03954270f, -0.00459891f, -0.03644662f, -0.05878803f, -0.03869044f, -0.08654229f, -0.03344369f, -0.04913715f, 
    -0.01632428f, -0.09391384f, -0.01988097f, -0.04494078f, -0.08058275f, 0.00840448f, -0.07762981f, -0.04758083f, 
    -0.11448077f, 0.00207504f, 0.01912636f, 0.00280328f, -0.09267870f, 0.00590550f, 0.07415316f, 0.04424860f, 
    -0.10794171f, -0.07641401f, -0.04847374f, -0.08075050f, -0.08700907f, -0.07806174f, 0.00822646f, -0.08528566f, 
    0.00489111f, 0.03444777f, -0.10278413f, 0.00649471f, 0.01635291f, -0.01983429f, -0.04233794f, 0.03420899f, 
    -0.05240388f, 0.04936824f, 0.05029126f, 0.04588440f, -0.05234204f, 0.05740706f, -0.01856782f, -0.02890141f, 
    -0.10124125f, 0.07083204f, -0.07969465f, -0.01068124f, -0.06247944f, -0.05519641f, -0.04185364f, -0.08334780f, 
    -0.11248523f, -0.04884437f, -0.03347692f, -0.08572695f, -0.04426624f, 0.01213337f, -0.08663637f, -0.07234647f, 
    0.05170602f, -0.01626722f, -0.03093588f, 0.01739985f, -0.01909569f, 0.08325565f, -0.06603196f, 0.03024342f, 
    0.02717619f, -0.10954208f, -0.07904752f, -0.01098340f, -0.05005115f, 0.06094307f, 0.01173594f, -0.02110082f, 
    0.00827088f, -0.05115213f, -0.00917130f, 0.04623105f, -0.00744469f, -0.06295076f, 0.01400424f, -0.06003220f, 
    -0.00758671f, -0.07089291f, -0.05848419f, -0.02720887f, -0.01112756f, 0.03743524f, -0.06653561f, -0.03387238f, 
    -0.00444118f, 0.04069470f, 0.04680927f, 0.00344537f, -0.03289154f, 0.00040007f, 0.02223354f, 0.03254341f, 
    -0.08182397f, 0.01333890f, -0.07753465f, 0.07426214f, -0.03069018f, -0.11720119f, -0.01291857f, 0.01744954f, 
    -0.02788587f, -0.01342412f, -0.01388801f, 0.08027393f, -0.09474967f, 0.06258029f, -0.09019461f, -0.06437653f, 
    -0.06510137f, -0.00313849f, 0.05818655f, -0.07543561f, -0.04451272f, 0.05442988f, 0.03863945f, -0.05626176f, 
    0.06237318f, -0.03333712f, 0.05516423f, -0.03146112f, -0.00763994f, -0.03197465f, -0.07247053f, 0.05631946f, 
    -0.01705499f, -0.01002343f, -0.06680800f, -0.04418746f, 0.04782753f, -0.02941461f, 0.07766111f, 0.03802342f, 
    0.03604750f, 0.00193939f, -0.05867697f, -0.08112011f, 0.04564551f, -0.02847406f, -0.09095752f, 0.08216979f, 
    0.03078504f, -0.04469675f, 0.01663940f, -0.06595285f, 0.03372088f, -0.07022792f, -0.02709179f, 0.03460512f, 
    -0.05552807f, -0.04480108f, -0.02798315f, -0.05712707f, 0.07342590f, -0.08145614f, 0.04017963f, -0.08051573f, 
    0.04718114f, -0.06191886f, -0.06345673f, 0.04390206f, -0.05824934f, 0.04734758f, -0.02686952f, -0.01156907f, 
    -0.05588611f, -0.00021290f, -0.03806154f, 0.02779404f, -0.00719767f, -0.03096217f, 0.04131008f, 0.03178919f, 
    -0.07672272f, 0.03487523f, -0.07126056f, -0.07804744f, 0.02762956f, 0.04901606f, -0.03411930f, -0.08364534f, 
    0.04510463f, 0.08799652f, -0.02559284f, -0.01786518f, -0.03864546f, -0.06214855f, -0.03829344f, -0.05891362f, 
    0.04421604f, -0.01362365f, -0.10448049f, -0.04008651f, -0.04960218f, -0.01534514f, -0.04211581f, 0.02003900f, 
    -0.03935655f, 0.00058775f, 0.00588892f, 0.00463414f, -0.08648247f, -0.03735365f, 0.04672313f, -0.07409413f, 
    -0.03846682f, -0.03594454f, -0.01716815f, -0.06333853f, 0.00321821f, -0.07083693f, -0.05611751f, -0.00068665f, 
    0.03232521f, -0.04873373f, -0.00783307f, 0.06877448f, -0.03567965f, -0.07035677f, 0.05335608f, 0.06045355f, 
    -0.03507159f, 0.05111639f, 0.06715659f, -0.08391584f, 0.05018212f, -0.05696149f, 0.07538549f, -0.07746718f, 
    0.04395455f, -0.14134529f, -0.04747546f, -0.05762359f, 0.21066262f, 0.11675603f, -0.18718822f, 0.05320813f, 
    0.09683982f, 0.18760645f, 0.12348378f, -0.30041182f, 0.10078356f, -0.06069873f, 0.07161191f, 0.12639464f, 
    0.00857679f, -0.08556065f, 0.15563414f, -0.23259406f, 0.09099503f, 0.01435135f, 0.15576513f, -0.14599183f, 
    0.00942530f, 0.08834814f, 0.17856726f, 0.06696509f, 0.18542182f, 0.21784227f, 0.28614989f, -0.16002545f, 
    -0.31416342f, 0.16229719f, 0.08699589f, -0.04032945f, 0.06787177f, -0.04546311f, 0.09496275f, 0.76208526f, 
    -0.09274289f, -0.00123777f, -0.49411982f, -0.02735072f, 0.15370873f, 0.05161785f, 0.05006830f, -0.02709690f, 
    -0.08399682f, -0.00381217f, 0.09716966f, -0.11114251f, -0.55132639f, 0.17465706f, 0.12769569f, 0.03377857f, 
    0.11464491f, 0.00613527f, 0.10146035f, -0.36330548f, 0.12408249f, 0.25561684f, -0.14981419f, 0.86199588f, 
    0.00764801f, -0.17241824f, -0.04278428f, 0.07470018f, 0.16601612f, -0.10901456f, -0.55041164f, 0.47639370f, 
    -0.16948983f, -0.11829411f, 0.11733092f, -0.14824337f, 0.29517817f, -0.06215134f, 0.10477661f, -0.03865994f, 
    0.03569345f, -0.03953436f, -0.07582612f, 0.22905587f, -0.01081997f, -0.16250451f, -0.40737158f, 0.29617596f, 
    -0.01382619f, -0.09860602f, 0.36991712f, -0.13031153f, -0.18186435f, -0.10492171f, 0.07474580f, 0.09807989f, 
    0.12846021f, 0.16176797f, 0.00560311f, 0.06904212f, -0.15040477f, 0.21451466f, -0.03476681f, 0.30171961f, 
    -0.10059056f, 0.11690912f, 0.18022212f, -0.26872075f, 0.25419632f, 0.24257122f, -0.14376441f, -0.37875405f, 
    0.34578425f, -0.09794001f, 0.02669139f, -0.09014463f, -0.09419401f, -0.02420340f, -0.03653309f, -0.20737456f, 
    0.16212547f, -0.02935972f, 0.05997854f, -0.47138152f, -0.01072213f, 0.30808303f, 0.15367950f, 0.09911361f, 
    -0.06858598f, 0.18164700f, 0.13488919f, -0.06087679f, -0.11278134f, -0.12520684f, -0.00622744f, 0.17845987f, 
    0.01783416f, 0.04053885f, 0.13436916f, -0.00167923f, 0.26280719f, -0.29449195f, 0.05670469f, 0.30635518f, 
    0.14029229f, -0.07863534f, -0.13469030f, -0.07999706f, -0.29994041f, -0.07454710f, 0.13035494f, -0.05998615f, 
    0.08794460f, 0.07857265f, -0.02338716f, 0.20007719f, 0.15792516f, -0.21629478f, 0.22622475f, 0.09296996f, 
    -0.04107042f, -0.17956400f, 0.11201608f, -0.00064296f, -0.05780441f, 0.05448604f, 0.25176260f, 0.07660994f, 
    0.21923701f, 0.13824008f, -0.18735984f, 0.03868993f, -0.54576850f, -0.13868113f, -0.06988513f, 0.42642918f, 
    0.11418029f, 0.43657804f, 0.21647106f, 0.26081237f, -0.03422067f, 0.04416505f, 0.23023298f, 0.26365277f, 
    -0.10446190f, -0.11314801f, 0.03103500f, 0.01426401f, -0.26539221f, 0.05140969f, 0.15016443f, 0.02502569f, 
    0.25733507f, -0.14169192f, -0.02110307f, 0.07319077f, 0.05981695f, 0.17103840f, 0.03115170f, 0.29542947f, 
    -0.10782317f, 0.04744310f, 0.32114747f, -0.07672513f, 0.13732140f, -0.10758857f, 0.19750844f, -0.14534949f, 
    0.02638081f, 0.01450193f, 0.04088324f, 0.42897069f, 0.18646243f, -0.30051252f, -0.15498702f, 0.20285121f, 
    -0.20654222f, 0.37349430f, -0.00627309f, -0.04420374f, 0.07173435f, 0.10786757f, -0.06326900f, -0.18766345f, 
    0.22391719f, -0.11888605f, -0.16270366f, 0.10126917f, -0.01097453f, -0.30886713f, 0.02471782f, 0.40107918f, 
    0.19488378f, -0.09983692f, -0.01906330f, -0.09303264f, 0.09044971f, -0.10415825f, 0.13669908f, 0.06621044f, 
    0.09448127f, 0.20665151f, -0.25322425f, -0.17035872f, 0.00948539f, -0.04961428f, 0.00069856f, -0.39226469f, 
    0.41098094f, 0.16390048f, 0.33431667f, -0.33122796f, 0.03986724f, 0.18291050f, -0.09861862f, 0.17298995f, 
    0.06746741f, -0.24094892f, 0.01678454f, 0.04205513f, 0.06858735f, -0.13186021f, -0.21782675f, -0.08446372f, 
    0.11005913f, 0.07435383f, -0.03518463f, -0.17257898f, -0.02959660f, 0.06919310f, 0.07053643f, 0.10389508f, 
    0.08943697f, -0.07652985f, -0.00523458f, -0.02529732f, -0.09190279f, 0.03885373f, -0.01618346f, -0.02305430f, 
    -0.09741176f, 0.10774606f, 0.13138218f, -0.13819067f, -0.03049408f, 0.18048494f, 0.13919903f, 0.13926670f, 
    -0.06604399f, -0.05445886f, 0.03223056f, 0.02587536f, 0.23791856f, -0.03928803f, -0.23717235f, -0.08860836f, 
    -0.05599269f, -0.05198269f, -0.12248500f, 0.06588307f, -0.09359221f, 0.09677340f, 0.08955988f, -0.17601210f, 
    -0.06580230f, -0.17998213f, -0.00446226f, 0.32309166f, -0.15488021f, 0.07575904f, -0.00858841f, -0.06450014f, 
    0.39557680f, -0.04929437f, 0.12670110f, -0.16117118f, 0.12831010f, 0.33401522f, 0.10563916f, 0.36456186f, 
    -0.08647451f, -0.00343421f, -0.05460670f, 0.08871400f, -0.00534578f, -0.10936336f, 0.13968788f, 0.14104730f, 
    -0.10140555f, -0.08496831f, 0.21165454f, -0.00891604f, 0.39766961f, 0.12656452f, 0.03123945f, 0.10526209f, 
    -0.19039160f, -0.04146754f, 0.07851325f, -0.17965862f, 0.07468050f, 0.22955385f, -0.04671466f, 0.15942630f, 
    -0.21097140f, -0.00763297f, 0.05533716f, -0.14666790f, -0.27617678f, -0.11138956f, 0.05759189f, 0.21923906f, 
    -0.04155353f, -0.14184824f, 0.08000892f, 0.04036260f, 0.11109450f, -0.04296950f, -0.06507730f, 0.32747939f, 
    -0.00553272f, 0.00798048f, 0.22401097f, -0.10093477f, 0.15156263f, 0.11964659f, -0.12410158f, -0.03826361f, 
    -0.02705543f, 0.06005812f, -0.10651741f, 0.10815496f, 0.12589450f, 0.18064742f, 0.20377189f, 0.06383943f, 
    -0.13518123f, -0.18337858f, 0.17689788f, -0.22609653f, -0.20770897f, 0.15928802f, -0.04777285f, 0.14900959f, 
    -0.01902191f, 0.09235985f, -0.13618863f, -0.08306917f, -0.30646646f, 0.32529899f, -0.05524823f, -0.12127785f, 
    -0.09209019f, 0.25681555f, -0.12053908f, -0.15382169f, -0.07091699f, 0.13152172f, 0.12734841f, -0.14845465f, 
    0.09777145f, 0.05584512f, 0.07765301f, 0.22993560f, -0.12277986f, -0.03224430f, 0.05612861f, 0.17501898f, 
    -0.07711578f, -0.33871904f, -0.17996919f, 0.17273365f, 0.09889511f, -0.60374677f, -0.07998949f, -0.18016693f, 
    0.06629797f, 0.38899925f, 0.20792270f, -0.00369774f, -0.03378682f, 0.00410785f, -0.23615418f, -0.25196019f, 
    -0.02816946f, -0.41866872f, 0.07370903f, 0.01652488f, 0.25708461f, 0.05943723f, -0.13952102f, 0.24033952f, 
    -0.03644582f, -0.20041327f, 0.08426583f, -0.17796262f, 0.04258554f, -0.02669494f, 0.13049445f, 0.01651077f, 
    0.09242819f, 0.10480501f, -0.23493579f, 0.27788791f, -0.25115237f, -0.14174162f, -0.07452212f, -0.63012385f, 
    -0.25364494f, 0.00315406f, -0.01041115f, -0.05529782f, -0.08162209f, 0.27333617f, -0.37985510f, 0.53638905f, 
    -0.12006283f, -0.05866804f, 0.05797485f, -0.04089585f, -0.19614755f, -0.01526668f, 0.14845611f, -0.02238003f, 
    0.23532107f, 0.07024429f, 0.03831803f, -0.30626360f, 0.00894281f, 0.32683262f, 0.24612467f, -0.27384874f, 
    0.05737859f, -0.01406898f, 0.20318377f, -0.30403194f, 0.03496297f, -0.05320458f, -0.08815605f, -0.44092196f, 
    0.11050088f, 0.03471826f, 0.14462428f, 0.10546865f, 0.17224610f, -0.10451122f, 0.15781567f, 0.55702168f, 
    -0.06496087f, -0.02853600f, -0.14786002f, -0.05952036f, -0.36475244f, 0.09362399f, 0.10491209f, -0.07112606f, 
    -0.22844072f, 0.04658537f, -0.06908573f, -0.33724806f, -0.10782513f, 0.01964406f, -0.01752866f, 0.46550113f, 
    0.05509039f, 0.18220547f, -0.04140112f, 0.03374069f, -0.13624547f, -0.25908437f, -0.17170955f, -0.15127167f, 
    -0.04555941f, 0.12472475f, 0.02205874f, -0.08699403f, 0.02944752f, 0.05354434f, -0.31272164f, -0.01583351f, 
    0.03306983f, -0.16170752f, 0.09289283f, -0.12024362f, -0.13924834f, -0.00568263f, -0.16063155f, 0.22377326f, 
    -0.14270075f, -0.04181422f, -0.00268376f, -0.00245130f, -0.17427966f, -0.01686861f, 0.11604477f, -0.22233167f, 
    -0.02484468f, 0.05627377f, 0.24515311f, -0.11445294f, 0.09610585f, -0.04161337f, -0.20307879f, 0.16527851f, 
    0.03601079f, -0.41952702f, -0.20070150f, -0.22224012f, 0.07427486f, -0.05747538f, -0.20168018f, -0.00654313f, 
    -0.06731723f, -0.12838081f, 0.24642235f, 0.13517901f, -0.32929510f, 0.23237351f, -0.13069558f, -0.03592972f, 
    0.14438836f, 0.43517905f, -0.07284348f, -0.33722767f, 0.09470873f, 0.53060639f, -0.13763566f, 0.03576629f, 
    0.18609634f, 0.28394273f, 0.32003063f, -0.05857260f, 0.22367871f, 0.08959085f, 0.22788537f, 0.21141550f, 
    -0.01613057f, 0.06147886f, -0.05716750f, 0.18342595f, 0.18549439f, -0.19108211f, 0.12061500f, -0.07312781f, 
    0.15499446f, 0.09391110f, -0.15413569f, 0.09097960f, 0.13964324f, 0.14790611f, 0.09464959f, 0.03606705f, 
    -0.12054320f, 0.05382829f, -0.12810341f, 0.10780759f, 0.23216406f, 0.18512599f, 0.19832432f, 0.12463237f, 
    0.06337298f, 0.11454423f, -0.07727131f, 0.14062220f, -0.01873321f, 0.02203849f, -0.04469404f, 0.03065380f, 
    -0.01235191f, -0.66310483f, 0.08362755f, -0.07365609f, 0.04824095f, -0.15001060f, -0.08510034f, -0.17660804f, 
    0.05703547f, 0.03087947f, 0.18897235f, 0.08966774f, 0.10620841f, -0.00828337f, 0.13616134f, -0.06662389f, 
    0.13962069f, 0.17082995f, 0.10906311f, 0.32537481f, -0.01078700f, 0.16475475f, 0.09117347f, -0.15307400f, 
    0.00239107f, 0.06696144f, 0.09230266f, 0.01520330f, -0.08736644f, 0.10585756f, -0.00598789f, 0.03777194f, 
    -0.08467208f, 0.09348663f, -0.05339802f, -0.07136280f, 0.03370603f, -0.08961231f, 0.02797340f, -0.07469266f, 
    -0.02963961f, -0.09160195f, 0.04972645f, -0.01006857f, 0.01795525f, -0.01581684f, 0.02932894f, -0.02581029f, 
    0.06387881f, -0.05832455f, -0.07156798f, -0.11810007f, -0.06966291f, 0.04235844f, -0.03470039f, -0.07546824f, 
    -0.03513115f, 0.09992671f, 0.04704254f, -0.08414824f, -0.09437998f, 0.06139708f, -0.04455235f, -0.01346618f, 
    -0.01293955f, -0.10297819f, -0.14858130f, -0.01316704f, 0.02987489f, 0.03403752f, -0.02518175f, 0.05514565f, 
    -0.01823342f, -0.00808029f, 0.02261376f, 0.01110628f, -0.07277332f, -0.04893643f, -0.06003557f, -0.11493255f, 
    -0.04342095f, 0.02124703f, -0.06401226f, 0.06380124f, -0.01016952f, 0.03152957f, 0.04517336f, 0.02447224f, 
    -0.10654698f, 0.00424577f, 0.00433219f, -0.11625420f, -0.04158836f, -0.03868051f, 0.00115150f, 0.08828276f, 
    -0.03242474f, -0.12376184f, -0.00016956f, -0.05670837f, -0.00991755f, -0.11083774f, 0.03637784f, -0.03684819f, 
    -0.08231543f, 0.02639872f, -0.08550783f, -0.11685521f, 0.09792045f, -0.05318058f, -0.12278736f, -0.02519671f, 
    -0.09543175f, -0.05942160f, -0.14547832f, -0.02986284f, 0.00192402f, -0.11446665f, -0.14047377f, -0.08188314f, 
    -0.08023432f, 0.02284718f, 0.04833258f, 0.05259299f, -0.05355322f, 0.03758174f, -0.04015749f, -0.02374151f, 
    -0.04585174f, 0.02492842f, -0.00485395f, -0.08665213f, -0.06007894f, -0.04781405f, -0.11576584f, -0.12529558f, 
    0.04768721f, 0.03503111f, 0.04214900f, 0.07158116f, 0.01441253f, 0.00511640f, -0.07866251f, 0.01837291f, 
    0.06163294f, 0.03404221f, 0.06549175f, 0.06671383f, -0.00462903f, -0.11430582f, -0.11801947f, -0.05007024f, 
    -0.09473404f, -0.12570430f, -0.07321506f, 0.06115906f, 0.00832749f, 0.06538647f, -0.07129723f, -0.05806119f, 
    0.04693908f, 0.12278029f, 0.24423365f, -0.02152620f, -0.00714426f, -0.68623739f, -0.01398975f, 0.03909702f, 
    0.34716943f, -0.18762390f, 0.04285155f, -0.00221323f, -0.00519318f, 0.17803474f, -0.09228534f, 0.30351329f, 
    0.31552544f, 0.08829954f, -0.54862636f, -0.15147342f, 0.41292438f, -0.01726443f, 0.00497502f, -0.01354362f, 
    0.29576904f, 0.27001795f, -0.08532850f, 0.22711371f, -0.27663901f, 0.08871612f, -0.15712145f, 0.15246113f, 
    0.18682668f, -0.00598623f, 0.02982763f, 0.08413628f, 0.09576217f, 0.00577621f, 0.14065324f, -0.04738509f, 
    -0.29774019f, 0.39233601f, 0.00557738f, 0.13006157f, 0.57139492f, -0.23624642f, -0.18926333f, 0.14865907f, 
    0.24716094f, 0.60950249f, 0.04186974f, 0.10147801f, 0.23249266f, -0.31938773f, 0.15581568f, 0.25770721f, 
    -0.25487718f, 0.08285738f, 0.40114042f, -0.02154538f, 0.01214714f, -0.36233044f, 0.25539306f, 0.03008242f, 
    0.31909406f, 0.03343641f, 0.02140140f, 0.13860969f, -0.06877690f, 0.11247401f, 0.07560243f, 0.01654298f, 
    -0.15505935f, 0.29812035f, -0.21465877f, -0.00852982f, -0.17550972f, 0.15564875f, 0.08018147f, -0.38367587f, 
    0.05378987f, -0.00850639f, 0.00301278f, 0.21474084f, -0.15994392f, 0.07157738f, 0.04466160f, 0.15672621f, 
    -0.02607667f, 0.14016122f, -0.44571540f, -0.10183588f, 0.27715364f, 0.10980828f, 0.04084995f, 0.30083996f, 
    -0.00030296f, 0.30071789f, -0.23323716f, 0.05726323f, 0.13409397f, -0.26737550f, -0.11138465f, -0.35828087f, 
    0.12633285f, -0.57388186f, -0.10709547f, -0.07434109f, 0.37214455f, -0.30959198f, -0.00132283f, 0.27588260f, 
    0.21882229f, -0.08790881f, -0.05435294f, 0.23322190f, 0.32632458f, -0.11032361f, 0.05545156f, 0.05640368f, 
    0.22949184f, 0.25930035f, -0.01988987f, 0.11401868f, -0.06948456f, 0.37876821f, -0.19086419f, 0.14451815f, 
    0.18207939f, 0.34164923f, -0.03893145f, 0.08115336f, 0.07634790f, -0.14829195f, 0.06480626f, 0.13626601f, 
    -0.09504419f, 0.03934929f, 0.05181109f, -0.24572065f, 0.40954673f, -0.30389965f, -0.01074640f, 0.15867126f, 
    -0.19527906f, -0.07966761f, 0.15004405f, -0.29754871f, -0.13922666f, 0.05624642f, 0.05843107f, -0.22348037f, 
    -0.03156073f, 0.16923092f, 0.01908270f, -0.02513415f, 0.14256361f, -0.16376698f, 0.29737490f, 0.28797835f, 
    -0.10038503f, 0.00298730f, -0.07727902f, 0.15581878f, 0.13885072f, 0.00426369f, 0.13027070f, 0.08123437f, 
    0.19765893f, -0.20010258f, -0.06954198f, -0.37516403f, -0.39531639f, -0.15151724f, 0.30192685f, -0.01917716f, 
    0.08921722f, -0.66021335f, 0.06725255f, 0.22262840f, 0.06023346f, 0.44386017f, 0.02964749f, 0.07631759f, 
    0.22774534f, -0.19862662f, 0.33428770f, -0.10200788f, -0.09760362f, 0.61778492f, 0.15125604f, 0.03765397f, 
    0.21555871f, 0.10220111f, 0.00379520f, 0.02499421f, 0.04226407f, 0.00104006f, 0.17111102f, -0.28569177f, 
    -0.27008238f, -0.03277307f, 0.17054093f, -0.11879760f, 0.18436396f, 0.26177776f, 0.14648838f, -0.01202344f, 
    0.05032101f, -0.03728340f, -0.00321458f, -0.12195616f, -0.14869390f, -0.36617583f, -0.25141838f, 0.03869230f, 
    -0.24983898f, 0.09012140f, 0.30118424f, 0.04716813f, -0.12709272f, 0.03943437f, -0.04404960f, 0.23738638f, 
    0.27528509f, -0.00737995f, -0.06515611f, 0.14075425f, -0.22378407f, 0.11978202f, 0.00236660f, -0.02718845f, 
    -0.04368062f, -0.13953736f, 0.04951731f, -0.33735064f, -0.09125146f, -0.03560314f, 0.00945082f, 0.16723382f, 
    -0.04705204f, -0.64784640f, 0.10590744f, -0.15280592f, 0.06113414f, -0.00669228f, 0.03194989f, -0.40744117f, 
    0.02028747f, 0.07040501f, 0.33876756f, -0.04961050f, 0.17765298f, 0.12995362f, 0.00046293f, 0.19830020f, 
    -0.36974823f, -0.11782756f, -0.00144570f, -0.09527235f, -0.12956122f, -0.32271054f, -0.03306233f, 0.07778875f, 
    -0.00395675f, -0.46099269f, -0.18211524f, 0.15643312f, -0.24301948f, 0.19491513f, -0.36994186f, -0.04251926f, 
    0.34011212f, -0.01292296f, -0.21099173f, -0.11670798f, 0.28928906f, 0.02161827f, 0.16132985f, -0.25775993f, 
    0.03220792f, 0.13256520f, 0.13114859f, 0.04554976f, -0.05482643f, 0.20270495f, -0.36425710f, 0.08351745f, 
    0.18970928f, -0.06289242f, -0.21681216f, -0.15917426f, -0.19409682f, -0.00580251f, -0.23362143f, -0.10344946f, 
    0.18190224f, -0.01967971f, 0.20300101f, 0.10576809f, 0.04665019f, 0.09834513f, -0.31554598f, -0.09015342f, 
    0.14465149f, 0.38740459f, 0.07025132f, -0.26643062f, -0.23406546f, 0.25370941f, -0.19785631f, -0.13177961f, 
    0.00797833f, 0.27267432f, 0.00768829f, 0.05065676f, 0.00192945f, 0.19918832f, 0.22591011f, -0.16701104f, 
    0.01062237f, -0.01024968f, 0.00588170f, 0.02821334f, 0.10115505f, -0.03048123f, 0.06761111f, -0.18972009f, 
    0.00114613f, 0.19059008f, 0.01191425f, -0.00276846f, -0.09756504f, 0.40642384f, -0.14366244f, -0.01248220f, 
    -0.23279476f, 0.00415067f, 0.01841792f, -0.29444826f, 0.20379876f, 0.04898794f, 0.09847447f, 0.00339033f, 
    -0.43588549f, 0.11535901f, -0.44257525f, -0.01580608f, -0.02684706f, 0.05664900f, -0.06268764f, 0.43533310f, 
    -0.56609213f, -0.11506305f, -0.09462543f, 0.03381423f, -0.05463314f, -0.22837536f, -0.39086145f, -0.45245579f, 
    0.01560860f, -0.15314393f, 0.11834367f, -0.02324778f, 0.22640175f, -0.08613669f, 0.16905376f, 0.38241205f, 
    0.13393776f, 0.25062889f, -0.03892851f, 0.20088691f, 0.11273046f, 0.14027093f, 0.03465063f, -0.01497080f, 
    0.08730321f, -0.08495469f, 0.18691970f, -0.02032259f, -0.13543953f, 0.15444896f, -0.06802865f, 0.35476464f, 
    -0.01382368f, -0.06540762f, 0.02528517f, -0.04804940f, 0.04205638f, -0.07753865f, -0.02634422f, 0.02875860f, 
    -0.03571121f, 0.07383785f, -0.03186028f, -0.07056265f, -0.08793229f, -0.01047845f, -0.02068117f, 0.03700489f, 
    -0.02590179f, -0.05007963f, 0.01611723f, -0.08628138f, 0.07357462f, 0.01625695f, -0.04721197f, 0.08340652f, 
    -0.04476706f, -0.00140812f, 0.04123057f, -0.00100498f, 0.03078201f, -0.06635461f, -0.08331539f, -0.03532625f, 
    0.00311527f, -0.07794020f, -0.06782246f, -0.08167993f, 0.04508611f, 0.01603121f, -0.05994135f, -0.02319302f, 
    0.04606803f, 0.05698068f, -0.02246660f, 0.02651654f, -0.06895243f, -0.00829697f, -0.05242108f, 0.04204667f, 
    -0.03661822f, -0.03490819f, -0.01696267f, 0.08317789f, 0.06592117f, -0.04349088f, -0.02553373f, -0.06026696f, 
    -0.04364233f, -0.03529783f, -0.00668495f, -0.03800869f, -0.04430958f, 0.01804576f, 0.03948290f, 0.02055718f, 
    -0.00694745f, -0.05008818f, 0.03287449f, -0.04780048f, -0.02367083f, -0.05765385f, -0.08550131f, 0.02653901f, 
    0.00688145f, -0.00537709f, 0.05606315f, -0.09765665f, -0.02013328f, -0.08365855f, 0.01073000f, -0.04651887f, 
    -0.04647803f, 0.05870919f, 0.06506651f, -0.04183511f, -0.00285604f, 0.06480608f, -0.05418904f, -0.00246778f, 
    0.06943784f, -0.06093231f, -0.08620764f, 0.01661002f, 0.07435487f, 0.08348256f, 0.08528567f, -0.10024290f, 
    -0.02117411f, 0.00207894f, -0.02525718f, 0.03201736f, 0.07096530f, -0.05395380f, -0.09587029f, -0.01126042f, 
    0.04482756f, -0.02492735f, -0.02053905f, 0.03855773f, -0.09044157f, 0.07390086f, -0.01900046f, 0.00959659f, 
    0.02553234f, -0.00424018f, -0.03089208f, -0.07603518f, -0.03774628f, -0.03499835f, -0.00663774f, -0.05584282f, 
    -0.08000238f, -0.04167429f, -0.03150780f, 0.07107100f, 0.03180573f, -0.06557871f, 0.05771170f, 0.05437801f, 
    0.13376805f, 0.02179145f, 0.05230490f, -0.07315517f, -0.03721173f, 0.17851488f, -0.28183705f, -0.00246817f, 
    0.07289601f, 0.08275770f, 0.13814615f, -0.08050203f, -0.12387359f, 0.04177091f, -0.07833914f, 0.20555891f, 
    -0.37160170f, -0.08617879f, 0.21190113f, -0.01477465f, -0.41368750f, 0.05346310f, 0.07963984f, -0.03327860f, 
    0.02242715f, 0.01290670f, 0.19366114f, -0.03371684f, 0.08090759f, -0.01749503f, -0.02917299f, 0.10845003f, 
    0.07968654f, -0.08204990f, 0.07128658f, -0.13393497f, 0.07035084f, -0.06727853f, -0.04965580f, -0.28035623f, 
    -0.16815661f, 0.00645467f, 0.02471263f, 0.12516643f, 0.02065937f, 0.24556047f, -0.12192104f, -0.04371665f, 
    0.09497662f, 0.28668335f, -0.08430563f, 0.13544218f, 0.06041003f, 0.35271999f, 0.12333833f, 0.11745600f, 
    0.11551790f, 0.09116901f, 0.15274489f, -0.00082924f, -0.05063139f, -0.10307313f, 0.20355752f, 0.35209918f, 
    0.04601831f, -0.08679666f, -0.05702399f, -0.01894188f, 0.13443169f, -0.06284562f, 0.17276680f, 0.13971660f, 
    0.05751020f, 0.04610694f, 0.08988629f, -0.03024815f, 0.18305545f, -0.05053578f, -0.10693043f, 0.04040926f, 
    0.00782359f, -0.03278203f, 0.07239324f, 0.15820187f, 0.21209791f, 0.07431567f, -0.02562797f, -0.00599733f, 
    0.10778783f, -0.00119286f, -0.02866270f, -0.03565612f, 0.06855562f, -0.09099703f, 0.06690969f, -0.06629972f, 
    0.27701107f, -0.00760612f, -0.03632877f, -0.05105103f, 0.12068400f, -0.08047873f, -0.01815747f, 0.13303673f, 
    0.22232270f, -0.01254087f, -0.08249818f, 0.12347819f, 0.07699533f, 0.03154020f, -0.00219254f, -0.08830392f, 
    0.23536403f, 0.23465846f, -0.02432473f, 0.20780542f, -0.12228049f, 0.11708561f, 0.19081165f, 0.11593182f, 
    -0.04361844f, -0.09766058f, -0.04692159f, -0.08413776f, -0.29329538f, 0.19647478f, -0.05020449f, 0.00232855f, 
    0.02436987f, 0.40597171f, 0.10871375f, -0.10795965f, 0.07981482f, 0.07010997f, 0.26805088f, -0.32449049f, 
    -0.09987228f, -0.15533492f, -0.03224241f, 0.62416035f, -0.19093309f, -0.13790201f, -0.30353701f, -0.10379808f, 
    0.18931724f, -0.02663667f, -0.05227418f, 0.09865198f, -0.06424479f, -0.07709546f, -0.14542837f, -0.51939636f, 
    0.14319731f, 0.06096308f, 0.06453783f, 0.06148434f, -0.22780329f, 0.34816271f, -0.08679047f, 0.00933967f, 
    -0.43931344f, -1.23583877f, -0.30224460f, -0.42749518f, 0.04305141f, 0.01699162f, 0.09023353f, 0.28556287f, 
    -0.39234132f, 0.13889261f, 0.45932809f, 0.03361373f, -0.93647659f, 0.21538936f, -0.18772060f, -0.39737868f, 
    0.20961030f, 0.37203157f, -0.04187986f, -0.32508323f, -0.14728373f, -0.26615855f, -0.27626064f, -0.18498954f, 
    -0.01359045f, -0.07326207f, -0.59073007f, -0.40603158f, 0.26738626f, -0.31018671f, 0.01972174f, 0.98459202f, 
    -0.05538527f, -0.13358705f, 0.08120055f, 0.05820424f, 0.02600270f, -0.69976211f, 0.83546418f, -0.28458792f, 
    0.20749858f, -0.03633464f, -0.33473882f, -0.01417733f, -0.64412999f, -0.07737540f, -0.05041668f, 0.15040193f, 
    -0.15302400f, 0.04867662f, -0.27776507f, 0.16854630f, -0.02012959f, 0.23384854f, -0.08296079f, 0.22782032f, 
    0.19234984f, 0.08602493f, -0.34589240f, 0.11294337f, 0.22838685f, 0.01537603f, 0.04641532f, 0.27991128f, 
    -0.27802289f, -0.11918698f, -0.13049774f, -0.32659611f, 0.28018069f, 0.41545397f, -0.12115136f, 0.29374197f, 
    0.06279343f, -0.04891311f, 0.05794795f, 0.25307426f, 0.36182117f, 0.02374898f, -0.12084340f, -0.37796348f, 
    0.52694285f, 0.09484521f, -0.04657454f, 0.34789407f, 0.17762880f, -0.14247136f, 0.16584837f, -0.48970872f, 
    0.15925154f, -0.34639233f, -0.05970654f, 0.18643305f, 0.24742937f, 0.10281292f, 0.25056437f, 0.07467193f, 
    -0.05070068f, 0.07440948f, -0.07877298f, -0.06353848f, -0.05681436f, 0.01144795f, 0.04122172f, -0.08608495f, 
    0.05440243f, -0.06202978f, -0.01364700f, 0.02302262f, -0.08658660f, 0.05355533f, -0.01815714f, 0.02758656f, 
    -0.03839009f, -0.07543956f, -0.06694616f, -0.03286880f, 0.02843028f, 0.06240493f, -0.04346692f, -0.07842732f, 
    -0.06883760f, 0.03213241f, -0.07020495f, -0.02490233f, -0.09114610f, 0.04205441f, -0.09760752f, -0.06509949f, 
    0.00188769f, -0.06039198f, 0.02966941f, -0.06996907f, -0.00932260f, -0.08421445f, 0.02958076f, -0.05112747f, 
    0.04889041f, -0.06501398f, -0.02316227f, -0.02267931f, 0.05752768f, 0.01355979f, -0.01497449f, 0.01424124f, 
    -0.05867414f, -0.03790828f, 0.07196355f, -0.02374493f, 0.08153816f, -0.06473441f, -0.01284204f, -0.01609406f, 
    0.03290926f, -0.05043819f, -0.02422637f, -0.05519131f, 0.08588987f, -0.07760847f, -0.08667640f, 0.02733135f, 
    0.04380998f, -0.00395135f, -0.02255544f, -0.00983095f, 0.00573351f, 0.04183034f, -0.01067066f, 0.07482640f, 
    -0.09528643f, -0.00686967f, 0.06771395f, -0.03227378f, -0.05737006f, -0.07779419f, -0.09136423f, 0.03969584f, 
    -0.02321026f, 0.04474683f, -0.06430878f, -0.08320702f, -0.00311108f, 0.03487401f, -0.08205864f, -0.03204452f, 
    0.02426416f, -0.00482065f, 0.01763330f, 0.06259894f, -0.05937990f, -0.05981329f, -0.08676572f, -0.00298250f, 
    0.01463301f, -0.00292756f, -0.06472902f, 0.06842852f, -0.01527798f, -0.01088434f, 0.04878750f, -0.04100417f, 
    0.05608284f, 0.00794838f, 0.06357988f, 0.06122433f, 0.03976463f, -0.00136305f, -0.03148919f, 0.01175603f, 
    -0.01875952f, -0.06320976f, -0.02968701f, 0.05997617f, -0.06013600f, 0.00650107f, -0.01697124f, -0.06988218f, 
    0.06373010f, -0.07492603f, 0.01813149f, 0.06411586f, -0.04601844f, -0.02913877f, 0.05822369f, 0.06151151f, 
    -0.08664518f, -0.07245381f, -0.08164967f, 0.07650759f, -0.09091365f, 0.05163954f, -0.06616101f, -0.06839336f, 
    0.04034450f, 0.06455135f, 0.00433447f, -0.08078415f, -0.00140515f, -0.07213879f, 0.02376353f, -0.06446053f, 
    0.04121499f, -0.08335569f, 0.01272918f, -0.11877993f, 0.03057019f, -0.07489422f, -0.07822477f, -0.01889787f, 
    -0.03257987f, -0.07507127f, -0.09069880f, 0.02057957f, -0.06294835f, 0.06397640f, -0.08330078f, -0.03225764f, 
    -0.08050875f, -0.08553313f, 0.06331644f, -0.00679042f, 0.00818344f, -0.00191813f, -0.05102404f, -0.07934404f, 
    0.02769124f, -0.08587980f, 0.05038039f, 0.05347205f, -0.02822749f, -0.03599833f, -0.07261806f, -0.03298464f, 
    -0.04296231f, 0.01886757f, -0.07358412f, -0.04415364f, -0.02944976f, -0.03617119f, 0.06048721f, -0.08180755f, 
    -0.07520099f, -0.08462642f, 0.08501519f, -0.02252945f, 0.00830899f, 0.01148739f, 0.00136079f, -0.01326704f, 
    -0.04459360f, -0.01777787f, 0.07506012f, -0.01923989f, 0.05881744f, -0.01403491f, 0.01778598f, 0.03233578f, 
    -0.01090013f, -0.06347492f, 0.05277231f, -0.04278072f, 0.05187052f, -0.00153939f, -0.01373758f, -0.04332219f, 
    -0.02421852f, -0.05005861f, -0.06598490f, -0.11296226f, 0.03403558f, -0.03289732f, 0.03421801f, -0.07490008f, 
    0.05533189f, -0.01140301f, -0.08468938f, -0.02866342f, 0.04294017f, -0.00048962f, -0.00058761f, -0.01821359f, 
    -0.07186539f, 0.06910115f, -0.02718763f, 0.04798298f, 0.03130212f, -0.03843544f, 0.01810474f, -0.01775666f, 
    -0.09840985f, -0.02472267f, 0.01760334f, 0.00245441f, -0.11128578f, -0.02498564f, -0.07265288f, -0.04517805f, 
    -0.07036366f, 0.03862672f, -0.00499936f, 0.01674684f, 0.00218218f, -0.02668457f, -0.01736027f, 0.02749234f, 
    0.03713278f, 0.02377070f, 0.03341772f, 0.00999062f, -0.04742000f, 0.00036005f, -0.08682643f, -0.04537758f, 
    -0.06319993f, -0.22483669f, 0.11581459f, -0.05700276f, -0.15457992f, 0.06324428f, 0.20740622f, 0.20854521f, 
    0.02331406f, -0.07600868f, 0.13484773f, -0.43826210f, -0.03570670f, -0.03453435f, -0.01040492f, -0.00605594f, 
    0.03029623f, -0.04812113f, -0.26024237f, 0.00660505f, 0.30085891f, -0.01610194f, -0.12560844f, 0.07234225f, 
    0.33809221f, 0.05875584f, 0.07075617f, 0.27840805f, 0.08283473f, -0.28616571f, -0.13096617f, -0.11088742f, 
    -0.01905299f, -0.01892879f, 0.09807920f, 0.24257901f, -0.04536841f, 0.05710739f, 0.05463255f, 0.42736968f, 
    0.11439912f, 0.53473991f, -0.25001550f, 0.01991848f, 0.07306123f, -0.09526688f, -0.03896762f, 0.09464473f, 
    0.11805476f, -0.03218766f, 0.19951260f, 0.21150506f, 0.07204079f, -0.10404583f, 0.12420119f, 0.01240731f, 
    -0.49204203f, -0.04948777f, -0.06232387f, 0.24779241f, -0.03296104f, -0.31053773f, -0.00792838f, -0.16107151f, 
    0.20104924f, -0.27548417f, -0.09013121f, -0.00938204f, -0.28081146f, 0.17962019f, -0.14955081f, 0.02176446f, 
    -0.06876119f, 0.15880436f, 0.12946497f, -0.18827482f, -0.25711793f, 0.01983790f, 0.10148069f, -0.71183449f, 
    0.10142162f, -0.02939828f, 0.02010656f, -0.03310942f, 0.07125645f, -0.24018990f, 0.14172190f, -0.11897972f, 
    -0.04546851f, 0.17712022f, -0.33060092f, -0.05833963f, 0.10226427f, -0.03803930f, -0.01769420f, 0.05726209f, 
    -0.02786883f, 0.29123932f, -0.08785643f, 0.18265198f, -0.14038180f, 0.10032766f, -0.11047474f, 0.01826204f, 
    0.11808930f, -0.23553416f, 0.04226272f, -0.09234232f, -0.20104888f, -0.06512371f, -0.03840902f, 0.36138290f, 
    -0.45814005f, 0.28132823f, 0.17857864f, -0.46177089f, -0.12269561f, -0.19958624f, -0.10769774f, -0.17519039f, 
    0.23687296f, 0.06525265f, 0.28297320f, -0.07614293f, 0.06691376f, -0.10081353f, 0.23472083f, 0.09467281f, 
    -0.05561538f, 0.29791418f, 0.16427453f, -0.01003015f, 0.10439077f, -0.01698088f, -0.50044358f, 0.22010536f, 
    0.16809988f, -0.13232958f, 0.23576702f, 0.42687821f, 0.01990064f, -0.15691839f, -0.43942213f, 0.16762164f, 
    0.26469192f, -0.08644608f, 0.12455020f, -0.18270360f, 0.02790167f, -0.02938207f, 0.03258516f, -0.15070280f, 
    0.15803882f, 0.20097563f, -0.01114063f, -0.11651670f, 0.22732338f, 0.31838197f, 0.08497076f, 0.02486697f, 
    -0.24308835f, -0.29434133f, 0.15198117f, -0.07924613f, -0.16869152f, -0.05569140f, -0.00699905f, 0.09536000f, 
    -0.11124976f, 0.44430146f, -0.87034929f, 0.21437494f, -0.24258274f, -0.02856245f, 0.06318805f, 0.40284899f, 
    0.24059810f, -0.26273111f, -0.00886487f, -0.05962569f, 0.35607338f, 0.23767065f, 0.08777823f, 0.34863418f, 
    -0.34443206f, -0.10167195f, 0.22502376f, 0.11746254f, -0.04493621f, -0.43492579f, 0.31059727f, 0.29040369f, 
    0.36463618f, -0.15815635f, -0.00432123f, 0.06801868f, 0.03682990f, -0.07440849f, -0.22116329f, 0.11902739f, 
    0.00752716f, 0.34813607f, 0.23301455f, 0.07525868f, 0.33919853f, -0.10269960f, 0.19369657f, -0.27056438f, 
    0.11080582f, -0.03499109f, 0.07163364f, -0.25994733f, 0.16328843f, -0.07042219f, 0.05824805f, -0.07173897f, 
    0.09284732f, 0.01741476f, 0.05517307f, -0.00494856f, 0.13840039f, -0.06321972f, 0.06111859f, 0.00102157f, 
    0.38724250f, -0.60497934f, -0.26407433f, -0.09882183f, -0.22870423f, -0.03873926f, -0.09754125f, 0.02317871f, 
    0.36416453f, -0.08234038f, -0.01714650f, 0.04372993f, -0.03669762f, -0.03075614f, 0.12164252f, -0.18942745f, 
    0.15009734f, -0.17949468f, -0.02284954f, -0.03816894f, 0.37536982f, -0.17735830f, -0.35968971f, -0.33354729f, 
    0.00650970f, 0.06570353f, -0.00947454f, 0.16122881f, -0.33503678f, 0.23199485f, 0.11476281f, 0.20175487f, 
    -0.05846168f, -0.04618702f, -0.02208318f, -0.02130334f, -0.04057415f, -0.11738615f, -0.08511990f, 0.04526296f, 
    0.05906432f, -0.06915294f, 0.00902832f, -0.06837500f, -0.05850717f, -0.08033450f, -0.09073965f, 0.00982536f, 
    -0.06590044f, -0.07755595f, 0.01581042f, 0.06195100f, -0.08538797f, 0.01624579f, -0.09511179f, -0.08568121f, 
    -0.08144639f, 0.05370031f, -0.11641415f, 0.01224687f, -0.07903644f, 0.02207808f, -0.08887784f, -0.06616178f, 
    0.02445053f, 0.03274579f, -0.06126923f, 0.04247783f, -0.01299088f, -0.03667818f, 0.06029245f, -0.07449704f, 
    -0.00007072f, -0.11072762f, -0.08091106f, 0.02416105f, -0.01579186f, -0.08774486f, -0.06422477f, 0.04726171f, 
    -0.00164564f, -0.08566641f, -0.10001066f, -0.05701565f, 0.07200491f, 0.07377440f, -0.03297354f, 0.00554412f, 
    -0.01468639f, 0.01601384f, -0.05020820f, -0.09229399f, 0.03118175f, -0.02814673f, 0.04159640f, -0.02356916f, 
    -0.01044110f, -0.04210635f, 0.01027195f, 0.00138531f, 0.04364417f, -0.07388287f, 0.00778859f, 0.06764949f, 
    0.03228819f, -0.02612950f, -0.00476410f, 0.03535987f, 0.06592564f, 0.03761759f, -0.06611506f, 0.02318611f, 
    0.04037702f, 0.05239131f, -0.08575866f, -0.05680854f, -0.11032322f, -0.00911028f, -0.06263144f, -0.04238947f, 
    0.01522133f, -0.04579179f, -0.09773371f, 0.04170637f, -0.04406976f, -0.03557823f, -0.07195704f, -0.08508644f, 
    -0.07596227f, -0.03104866f, -0.03460205f, -0.08540153f, -0.06017850f, -0.01836102f, -0.00302501f, 0.08421259f, 
    0.01047610f, -0.04729954f, -0.00512409f, 0.02780956f, -0.05361724f, -0.03465664f, -0.04945205f, 0.01634320f, 
    0.00245263f, 0.01159193f, 0.04436328f, -0.08619744f, -0.08333658f, 0.01981311f, 0.03609355f, -0.07343668f, 
    0.06586215f, 0.04450651f, 0.05179797f, -0.07190897f, -0.03005919f, 0.03763438f, -0.05858438f, -0.07148757f, 
    -0.12443214f, -0.00728065f, 0.04111296f, 0.08455016f, 0.08437365f, 0.11809536f, -0.00567532f, 0.02352388f, 
    -0.11702258f, 0.14464004f, -0.08911476f, 0.24195243f, -0.08292099f, 0.05553887f, -0.00316929f, -0.35579997f, 
    0.08738744f, -0.01749834f, -0.02169440f, -0.04499502f, 0.08202662f, -0.03132439f, 0.10730112f, -0.00561287f, 
    -0.00117591f, 0.10670675f, 0.25663844f, -0.05455635f, 0.12546512f, 0.17920586f, -0.07407400f, -0.16872656f, 
    0.07390542f, 0.01060079f, -0.03738352f, 0.04503432f, -0.11305182f, 0.06679926f, -0.04142138f, 0.27360904f, 
    0.11999262f, 0.21645521f, -0.69063228f, 0.16458483f, -0.15435399f, 0.05508432f, -0.21542150f, -0.60647058f, 
    0.06943806f, 0.31405765f, 0.11214842f, -0.26730824f, -0.20247751f, -0.16808508f, -0.40870482f, 0.10342348f, 
    0.05082182f, 0.10122865f, -0.21117090f, 0.16031854f, -0.03320296f, -0.03424162f, 0.20053639f, -0.22630809f, 
    -0.02930100f, -0.08063785f, 0.02876415f, 0.12177405f, 0.04865406f, 0.04072693f, 0.20002300f, -0.14943364f, 
    0.10950445f, 0.13379385f, -0.25484991f, 0.13249297f, -0.41296700f, 0.08272535f, -0.00705702f, -0.01326784f, 
    -0.02174706f, -0.01461898f, -0.11002234f, -0.21027586f, 0.24737848f, -0.07212348f, 0.31152368f, -0.28539515f, 
    -0.08945692f, -0.12661071f, -0.14944008f, -0.11176176f, -0.05844099f, -0.07921662f, 0.04214966f, 0.02019318f, 
    -0.13067180f, -0.07494704f, 0.13987012f, 0.13497943f, -0.21398166f, 0.18766011f, 0.13459189f, -0.18441157f, 
    -0.16986512f, 0.08163649f, 0.23467045f, 0.06076340f, 0.01663979f, 0.08845986f, 0.08126879f, 0.23649822f, 
    -0.65340286f, -0.02488307f, 0.19718888f, 0.12362813f, 0.09820592f, 0.09291992f, 0.00496966f, 0.06322651f, 
    0.13995102f, -0.08693099f, 0.12222252f, -0.39616361f, -0.02461253f, -0.25127488f, 0.19856012f, 0.38912305f, 
    -0.05440961f, 0.01555207f, 0.13368702f, -0.01328021f, -0.12477830f, 0.21488750f, -0.17471476f, 0.16804810f, 
    0.08582000f, -0.12490467f, 0.12590024f, 0.05340332f, -0.09864705f, -0.04358535f, -0.11673169f, -0.13726059f, 
    -0.17630707f, 0.02666704f, 0.31489602f, 0.26209664f, -0.28157043f, 0.07507715f, 0.08359741f, -0.24259491f, 
    0.03381445f, 0.08575512f, 0.28919572f, -0.10011248f, 0.20199837f, 0.02710305f, -0.16681617f, 0.05606215f, 
    0.10708576f, -0.22378658f, -0.08585855f, -0.09444162f, -0.02477373f, 0.06595331f, -0.00330497f, -0.23388395f, 
    0.02959842f, 0.01052824f, 0.18160982f, 0.43302342f, -0.14918451f, 0.36787930f, -0.18105057f, -0.29118130f, 
    0.16480434f, 0.54361248f, -0.14928800f, -0.15852882f, 0.24347842f, 0.38749680f, -0.14799045f, 0.12549570f, 
    -0.06774575f, 0.38347563f, 0.27922249f, 0.21341163f, 0.06872853f, -0.07157037f, 0.16740172f, 0.29499510f, 
    0.00273165f, 0.19493817f, 0.01659104f, 0.08957243f, 0.15189709f, -0.02055009f, -0.08319176f, -0.49118257f, 
    0.22542883f, 0.17879120f, 0.12323339f, -0.03147557f, 0.06555360f, 0.20271999f, -0.22555657f, 0.13406745f, 
    0.22776604f, -0.00278353f, 0.10757849f, -0.11755123f, 0.33981204f, 0.11339154f, 0.32005468f, -0.03286021f, 
    0.25298634f, -0.12773079f, -0.05601029f, -0.03805695f, 0.10995562f, -0.07557722f, 0.04893659f, 0.08439815f, 
    0.06034351f, -0.22060643f, 0.06135540f, -0.04611387f, 0.22589821f, -0.08383247f, -0.12837918f, -0.57353956f, 
    0.21302778f, 0.09664222f, -0.04293838f, 0.21072213f, -0.18573268f, -0.02646879f, 0.03311811f, -0.02083787f, 
    -0.11533948f, 0.09429637f, -0.00292911f, 0.18850499f, -0.00254031f, 0.25177848f, -0.00408308f, 0.14859530f, 
    -0.00648724f, -0.01118373f, -0.21462828f, 0.45578483f, 0.00297863f, 0.10141990f, 0.11243983f, -0.04588942f, 
    0.00665069f, 0.04060591f, -0.03363678f, 0.05117147f, -0.07912517f, -0.07595902f, -0.05177692f, 0.05323782f, 
    0.04149930f, -0.01803062f, -0.00456266f, -0.03891095f, 0.03229076f, -0.08434938f, -0.08754645f, -0.02924633f, 
    0.04032886f, -0.02438444f, 0.02447972f, -0.00975142f, -0.01232609f, -0.06963784f, -0.08048131f, -0.08169819f, 
    -0.08369696f, 0.07160606f, -0.06805069f, -0.06651588f, 0.06053497f, -0.06427985f, -0.06325113f, 0.04852691f, 
    0.07022125f, 0.08647185f, -0.06239954f, -0.06766546f, -0.05612406f, 0.06369726f, 0.00458197f, 0.02668616f, 
    0.04941981f, -0.05917507f, 0.06736471f, -0.01168295f, 0.04444793f, -0.02034936f, -0.05161977f, -0.02297237f, 
    0.00281595f, 0.02363816f, -0.08352893f, 0.06331388f, 0.07384694f, -0.00978989f, 0.03693883f, -0.00440922f, 
    0.02202078f, 0.05626940f, -0.04575490f, -0.04652843f, -0.02623874f, -0.07530066f, 0.06295146f, 0.07709221f, 
    -0.02105842f, 0.01982393f, 0.08165667f, 0.04708213f, -0.06830230f, -0.06904534f, -0.05733552f, -0.07667387f, 
    0.01609993f, -0.06554095f, -0.03367590f, 0.00156037f, -0.04348839f, 0.00003490f, 0.03951811f, -0.05987722f, 
    0.04441867f, -0.04290634f, -0.08772554f, -0.04787430f, -0.00658293f, -0.01118623f, 0.07399309f, 0.06062390f, 
    -0.05681631f, -0.05494396f, -0.04744235f, -0.06652912f, -0.06992391f, 0.01574266f, -0.00401121f, -0.00957949f, 
    0.08201972f, -0.03710263f, -0.05563499f, 0.08511095f, 0.00501457f, 0.05710541f, -0.05461719f, 0.04844423f, 
    -0.06151607f, -0.06568542f, -0.08187731f, -0.07112863f, 0.02563127f, -0.03688908f, -0.07532836f, -0.04561940f, 
    -0.01253429f, 0.08412790f, 0.01438462f, -0.05493482f, 0.02159780f, -0.01775175f, 0.02136892f, -0.07941737f, 
    0.05706490f, 0.00145213f, 0.00695951f, -0.00381771f, 0.05855107f, -0.05923662f, 0.03680882f, -0.03047792f, 
    0.22071134f, 0.35706234f, 0.05551356f, 0.05589966f, 0.07887695f, 0.09843950f, 0.21700974f, -0.27277952f, 
    0.25441414f, 0.09144005f, 0.08557949f, -0.38056386f, -0.03345905f, -0.23778333f, 0.02259599f, 0.12200990f, 
    0.00403958f, -0.01836875f, 0.04693308f, 0.12295672f, -0.02878813f, 0.00126954f, 0.00025002f, -0.35175925f, 
    -0.13707207f, -0.00159223f, -0.08298995f, 0.00786959f, 0.04742872f, 0.04209919f, 0.13554710f, 0.17257264f, 
    0.21026285f, -0.24342896f, -0.11594988f, -0.22855808f, 0.10916281f, -0.03502112f, 0.40099525f, -0.27979887f, 
    -0.09043144f, -0.26691425f, 0.32606637f, -0.17091703f, 0.18192399f, 0.03917809f, 0.09348461f, -0.10182735f, 
    0.06286225f, 0.48703453f, -0.28542402f, -0.04241369f, 0.12415845f, 0.00106168f, 0.02945120f, -0.06112677f, 
    0.13707770f, 0.16757815f, 0.04639487f, -0.01584684f, 0.06190528f, -0.04730479f, 0.10768236f, -0.46049225f, 
    -0.02211431f, 0.25227630f, -0.07895597f, -0.02037673f, 0.06641113f, -0.04384850f, 0.06493374f, 0.03168765f, 
    0.23934077f, 0.03114768f, 0.09041864f, 0.28235501f, -0.06118989f, -0.23888293f, -0.08828104f, 0.19852522f, 
    -0.15405959f, -0.03133824f, 0.19446333f, 0.12704192f, -0.10089851f, 0.07699296f, 0.06388064f, -0.01337615f, 
    0.06804325f, -0.10481938f, -0.03730829f, 0.17111857f, 0.35596207f, 0.05735559f, 0.05170836f, -0.18004803f, 
    0.13604708f, -0.16665432f, 0.07160585f, 0.02748785f, 0.33798969f, -0.23974465f, 0.24153115f, 0.00353985f, 
    -0.28063950f, 0.07863706f, -0.13084577f, 0.15655562f, 0.29242009f, 0.05611490f, 0.09725561f, -0.08440555f, 
    -0.45957270f, 0.02427457f, -0.00537746f, 0.05568164f, -0.16927595f, 0.05908203f, 0.21203311f, 0.07975574f, 
    0.01576624f, 0.10776168f, -0.42313790f, 0.05594810f, 0.20346501f, -0.04684362f, -0.14210935f, -0.43737221f, 
    -0.02012448f, -0.08002400f, -0.02669442f, 0.03575275f, -0.04270330f, 0.04719096f, 0.00741786f, 0.01615681f, 
    -0.03038048f, -0.05677145f, 0.06259677f, -0.11737922f, -0.11150076f, 0.01165400f, 0.01962581f, -0.00504609f, 
    0.03430949f, -0.01094036f, -0.09416528f, -0.05276165f, 0.01546166f, 0.06763142f, 0.00822064f, -0.08775414f, 
    -0.09424577f, 0.01713468f, -0.03189725f, -0.08038365f, -0.08971415f, -0.08870073f, -0.09956893f, 0.00193094f, 
    0.00858778f, -0.03217997f, -0.09267478f, -0.05792809f, 0.01162588f, 0.04832839f, -0.07364576f, -0.06232459f, 
    -0.01451897f, -0.10793894f, 0.04490633f, 0.04192263f, -0.04274008f, -0.01713246f, -0.08377112f, -0.10511874f, 
    -0.08234908f, -0.08335219f, -0.00726043f, 0.06548362f, -0.01053756f, -0.07557730f, 0.05029550f, -0.05390184f, 
    0.01306659f, -0.07913626f, -0.01477343f, -0.01950268f, -0.03495894f, -0.10945509f, -0.00540289f, 0.02136116f, 
    -0.01894217f, -0.02796131f, 0.07516465f, -0.10343311f, -0.08359551f, -0.00683185f, -0.04496077f, -0.03553514f, 
    0.00979644f, -0.03230445f, -0.02474833f, -0.05087934f, 0.01868019f, 0.05525677f, -0.08089793f, -0.06648788f, 
    -0.06139398f, -0.08543020f, 0.04145915f, 0.08329567f, -0.06955686f, -0.09628959f, -0.03298275f, 0.03528480f, 
    -0.09894289f, -0.10396873f, 0.07932851f, -0.02085645f, -0.03594388f, -0.06627477f, -0.05527958f, -0.03916847f, 
    0.00442811f, 0.03650695f, -0.11315457f, -0.09792151f, -0.07044643f, -0.01268767f, -0.00381313f, -0.00123417f, 
    0.05878777f, 0.01538523f, -0.07299005f, -0.07705206f, -0.03545247f, 0.01573202f, -0.01167170f, -0.07420754f, 
    -0.03411371f, -0.00425001f, 0.06948053f, -0.04535908f, -0.05320724f, -0.11815351f, 0.02881823f, -0.03616679f, 
    0.01026042f, -0.05140483f, -0.10099909f, -0.02555025f, -0.08000566f, -0.07825307f, -0.04640570f, 0.01347676f, 
    -0.03253127f, -0.00175932f, -0.12011627f, 0.08181408f, 0.05020919f, -0.11884368f, -0.01293633f, 0.04446290f, 
    -0.01221205f, -0.10221885f, -0.07676633f, -0.07502263f, -0.01585613f, 0.05937858f, -0.09995364f, 0.05917447f, 
    0.02160143f, -0.05828715f, 0.02605934f, -0.05483489f, -0.02912755f, 0.02117962f, -0.09432486f, -0.05563601f, 
    -0.05856399f, -0.01158938f, 0.04563120f, -0.08831102f, -0.01194528f, -0.10857566f, -0.02524673f, -0.07362217f, 
    0.08318800f, -0.08286496f, -0.05852677f, -0.11565440f, -0.05858212f, -0.07494298f, -0.08502521f, -0.10846749f, 
    0.00132183f, 0.04269178f, -0.11653957f, -0.07103535f, -0.01643408f, 0.01238212f, -0.01012114f, 0.00080065f, 
    0.04822841f, -0.01074959f, -0.09207921f, -0.10583451f, -0.02505687f, -0.00837877f, -0.02854136f, -0.07009587f, 
    -0.05767504f, -0.09976730f, 0.07641172f, 0.02428166f, 0.02467209f, 0.07704245f, -0.05872631f, 0.04105693f, 
    0.00865293f, -0.07142613f, -0.02180655f, -0.07639088f, 0.02013409f, 0.04701918f, -0.00915639f, -0.08314645f, 
    0.04760701f, -0.06151900f, -0.06147175f, -0.09352601f, 0.06183487f, -0.04619355f, -0.03850829f, -0.06606887f, 
    -0.10979997f, 0.00511135f, -0.00769472f, -0.04752216f, -0.01585449f, -0.09739424f, -0.11264148f, -0.00635521f, 
    0.00061002f, -0.01602843f, 0.02596546f, 0.01181077f, 0.03063948f, -0.00747313f, 0.07817049f, 0.00291010f, 
    -0.03080579f, -0.04931550f, -0.01779424f, -0.00035643f, -0.06795765f, -0.07771953f, 0.04458718f, 0.04873843f, 
    -0.02149806f, -0.07462376f, -0.00555018f, -0.12534738f, -0.10324907f, -0.04203930f, 0.03859448f, -0.07774312f, 
    0.06000874f, -0.10721467f, -0.06802087f, -0.02686121f, -0.06096484f, -0.11497403f, 0.04259690f, 0.05682722f, 
    0.00321426f, -0.08074939f, 0.05203623f, -0.06246524f, 0.05086464f, -0.05806336f, 0.03645122f, -0.06658375f, 
    -0.03817824f, 0.01387247f, -0.08822884f, -0.06498533f, -0.02873250f, -0.06077516f, -0.02576556f, 0.05561832f, 
    -0.04221941f, -0.06432587f, -0.07577221f, -0.10705417f, 0.00654643f, 0.03379394f, 0.06468234f, -0.11327108f, 
    0.00810278f, 0.08289959f, -0.03247815f, -0.03934051f, -0.03666599f, -0.08697137f, 0.01982663f, 0.05164061f, 
    -0.09667059f, 0.05087950f, -0.09853739f, -0.08140491f, -0.00939318f, -0.03733629f, -0.09835473f, -0.00537215f, 
    0.05622886f, 0.04677944f, 0.05484539f, -0.02655136f, -0.05858660f, 0.01145016f, 0.06330003f, 0.05532055f, 
    0.05492460f, -0.04100250f, -0.07909632f, -0.09029756f, -0.05181615f, -0.01680074f, -0.10882954f, -0.02336806f, 
    -0.03816926f, -0.05034313f, 0.05139450f, -0.07001428f, -0.06055720f, -0.07106715f, -0.03978383f, -0.10816015f, 
    -0.06671146f, -0.03063867f, 0.04579571f, 0.04174888f, -0.00308516f, -0.00897214f, -0.10783147f, -0.00393023f, 
    -0.08965711f, 0.00365174f, -0.06553493f, 0.05526355f, -0.08775809f, -0.01777351f, -0.01343927f, -0.04976692f, 
    0.06104122f, 0.01780874f, -0.04417822f, 0.00932937f, 0.02976777f, 0.08181243f, 0.07412894f, -0.06239508f, 
    0.05895698f, -0.00157029f, -0.00408970f, 0.11510582f, -0.02387686f, 0.07687311f, 0.04239233f, 0.01248352f, 
    -0.08859722f, -0.05179500f, -0.05890328f, -0.03545370f, 0.06491891f, -0.03555522f, 0.02477358f, 0.01469580f, 
    0.02334365f, -0.04365752f, -0.06520247f, -0.04315099f, -0.10828703f, -0.09331270f, -0.05748588f, -0.07786107f, 
    -0.04602937f, -0.03171255f, -0.07110900f, -0.02229953f, -0.03394455f, 0.02694227f, -0.01487607f, -0.04672286f, 
    -0.09505729f, -0.09421062f, -0.01782769f, -0.00419469f, -0.08401597f, 0.02771246f, 0.00825747f, -0.01013626f, 
    -0.08410243f, -0.07041615f, -0.03674041f, 0.05964826f, -0.04663550f, -0.06299911f, 0.00424367f, -0.01596239f, 
    0.08352850f, -0.19108649f, 0.08506813f, 0.01971429f, 0.03709843f, 0.01828833f, -0.01892328f, -0.04545318f, 
    0.06105863f, -0.08799423f, 0.06147085f, 0.29461560f, -0.01439097f, -0.34879619f, 0.03266954f, 0.13399333f, 
    0.11158456f, 0.00908693f, 0.19600692f, 0.02053552f, -0.22377670f, -0.07184439f, -0.01547054f, -0.04850443f, 
    -0.03475685f, 0.04333286f, 0.08029880f, 0.02848325f, 0.19351816f, 0.18389155f, 0.07001026f, 0.22994499f, 
    -0.13244329f, -0.17525390f, 0.04105024f, -0.04566392f, 0.11746357f, -0.03703773f, 0.35850859f, -0.05799191f, 
    0.18147552f, -0.06086050f, -0.03113024f, -0.06127004f, -0.45761618f, -0.00067144f, 0.15532194f, 0.01732120f, 
    -0.07248306f, -0.06197919f, 0.03171461f, -0.19709824f, 0.25714180f, -0.05887244f, -0.03150833f, -0.02647029f, 
    -0.01570112f, 0.01119639f, 0.22717029f, -0.04465210f, -0.01894316f, 0.31436998f, 0.15103590f, 0.06216672f, 
    -0.02704511f, 0.05880594f, -0.01084601f, 0.03008715f, 0.08850329f, -0.10094845f, 0.23052171f, -0.13408630f, 
    -0.02046327f, 0.05010315f, 0.27840987f, -0.13843013f, -0.02823643f, 0.00907212f, 0.09213841f, -0.06216223f, 
    -0.15571071f, -0.03996869f, -0.00880873f, 0.09685405f, 0.11086007f, -0.29727593f, -0.16388935f, 0.09637122f, 
    0.09594664f, 0.04211472f, 0.14381589f, -0.05624418f, 0.02382528f, -0.00855602f, -0.04610465f, 0.04900808f, 
    0.05309589f, -0.17432667f, -0.07197563f, -0.06367727f, 0.06227234f, -0.09188055f, 0.07004061f, -0.21268116f, 
    0.11445832f, -0.07213636f, 0.05235091f, -0.17594148f, 0.13770203f, 0.00593462f, 0.11601550f, 0.00093129f, 
    0.34662741f, -0.20253767f, 0.01424048f, 0.10316442f, 0.05724490f, -0.00654546f, 0.22829413f, -0.20566525f, 
    0.06654832f, -0.03009055f, 0.10194611f, 0.13789622f, 0.11496270f, -0.01118336f, -0.04717008f, 0.12027767f, 
    -0.02809994f, 0.30790132f, 0.20648812f, 0.02736093f, -0.02791878f, -0.13684908f, 0.37003878f, 0.11039415f, 
    0.19857799f, -0.04038485f, 0.14041156f, -0.05821811f, 0.18599288f, -0.03357904f, 0.09852641f, -0.11842489f, 
    0.36749181f, 0.01692802f, -0.17330284f, -0.03878308f, 0.08458284f, -0.05061416f, -0.12357313f, 0.08924471f, 
    0.25664487f, 0.07433196f, -0.08205357f, 0.11187366f, 0.03482945f, 0.10326820f, 0.14163604f, 0.06202799f, 
    -0.04428058f, 0.16029444f, 0.13399127f, 0.17026645f, 0.12473010f, -0.02349019f, 0.16544923f, -0.18882473f, 
    -0.07043184f, -0.00981167f, 0.09531468f, 0.06456320f, -0.13850267f, -0.07710832f, 0.07441917f, 0.07865926f, 
    0.21538225f, 0.13441086f, 0.08040354f, 0.12634049f, 0.20685677f, 0.01485672f, 0.18603770f, 0.27438617f, 
    -0.36365157f, 0.08332553f, -0.25627154f, -0.00302012f, 0.21191069f, -0.23525141f, -0.05966876f, -0.04503185f, 
    0.24035174f, -0.17123647f, -0.06075042f, 0.03958064f, -0.17363480f, 0.08030884f, -0.15797572f, -0.02072347f, 
    -0.25736028f, 0.16079010f, 0.16612440f, -0.06847602f, 0.19564910f, -0.19131599f, -0.09738237f, -0.23542772f, 
    0.03997816f, -0.07213917f, 0.08517146f, 0.11416852f, 0.02960924f, -0.27720311f, -0.30460322f, 0.18814352f, 
    0.18149874f, 0.02330439f, 0.14722942f, -0.01805673f, 0.04926858f, -0.03092469f, 0.06231072f, -0.01232489f, 
    0.19980374f, 0.33355474f, -0.34942028f, 0.10184123f, -0.11553088f, 0.12233132f, -0.06921683f, -0.02477152f, 
    0.14768942f, -0.17488627f, -0.09595111f, 0.04817346f, 0.17286259f, -0.17951556f, 0.00745948f, -0.21828072f, 
    0.20545322f, -0.00470521f, -0.05862802f, -0.03733376f, 0.28795680f, -0.27539355f, 0.10930131f, -0.30642074f, 
    0.32346889f, 0.12208451f, 0.12512322f, 0.04320683f, 0.39927459f, 0.18971479f, 0.05769438f, 0.18335481f, 
    -0.02397762f, 0.21833026f, 0.01875445f, 0.03661731f, 0.07736469f, -0.22097138f, -0.14022295f, -0.04949487f, 
    0.24649487f, -0.16535179f, -0.09616464f, -0.25301695f, -0.03114867f, 0.12024321f, -0.03069083f, 0.24545939f, 
    -0.20422427f, -0.01825612f, -0.28717631f, -0.26043755f, 0.65223014f, 0.07943305f, 0.16375567f, -0.15979378f, 
    0.06347610f, 0.07075077f, 0.00395524f, 0.12343827f, -0.23146251f, 0.03619855f, 0.00184657f, 0.24233286f, 
    0.14884725f, -0.29284304f, -0.14917381f, -0.21953489f, 0.00370344f, -0.01773245f, 0.00008222f, -0.16115816f, 
    -0.23519783f, -0.36185431f, 0.34220019f, -0.16577062f, 0.03162562f, 0.03208794f, -0.12414879f, 0.12517451f, 
    0.17424391f, 0.10683465f, -0.01824616f, -0.26931211f, -0.12811641f, -0.09808026f, 0.08943776f, 0.05916221f, 
    0.17812340f, 0.08054698f, 0.06044230f, -0.18600070f, 0.07575019f, 0.22986780f, 0.01459418f, 0.33839288f, 
    0.05504550f, -0.02405885f, 0.10977156f, 0.11886810f, 0.05328288f, 0.06638931f, 0.08067168f, 0.02877268f, 
    0.02769089f, 0.02879751f, 0.01457820f, 0.02765251f, 0.41059923f, 0.03466839f, 0.10806360f, 0.04695286f, 
    -0.15242131f, -0.02110174f, -0.13471223f, 0.00913525f, -0.08071751f, 0.22953413f, -0.14445627f, 0.32043889f, 
    -0.20782086f, 0.16752893f, 0.00965300f, 0.06065648f, 0.08025560f, 0.04684538f, 0.01082979f, 0.38661861f, 
    -0.15491737f, 0.01182332f, 0.14564052f, 0.06218906f, 0.18461396f, -0.25933594f, -0.20195723f, -0.03795147f, 
    -0.04091230f, -0.14307074f, 0.15420334f, -0.11121102f, 0.49346995f, 0.03228478f, 0.03487299f, 0.16136035f, 
    0.26076865f, 0.10774139f, -0.04029072f, 0.28408027f, -0.01880757f, 0.04276975f, 0.05770233f, -0.12034228f, 
    0.12208351f, -0.00878683f, 0.02222612f, 0.07444742f, -0.09528676f, 0.14565116f, -0.17444921f, 0.11294851f, 
    0.16121569f, 0.06708433f, -0.11365049f, 0.00061663f, 0.11522800f, 0.10011682f, -0.34980056f, 0.29224578f, 
    -0.14511520f, 0.01305655f, 0.13503966f, 0.05566317f, 0.27742949f, 0.24304879f, 0.05896975f, -0.36779618f, 
    -0.09141611f, -0.04661398f, 0.04895892f, 0.09992759f, 0.16182896f, 0.02043174f, 0.10734253f, 0.02543665f, 
    0.10812159f, -0.08518128f, -0.05211458f, -0.01551926f, 0.01399956f, -0.12252126f, 0.09213179f, -0.41299674f, 
    -0.07987805f, 0.03025589f, 0.26210254f, 0.15955655f, -0.06322204f, 0.01459414f, -0.24052528f, 0.39227682f, 
    0.07648376f, 0.13268067f, -0.13098282f, -0.01598517f, -0.28959543f, 0.15693085f, -0.03056948f, 0.17795469f, 
    0.00788921f, -0.03736581f, 0.24183777f, -0.18712080f, -0.32799259f, 0.04282731f, -0.07617798f, 0.10078816f, 
    0.16264260f, -0.04589690f, -0.36075917f, 0.04362795f, 0.05407184f, -0.10198953f, -0.12783007f, -0.16477095f, 
    0.06966412f, 0.01647683f, 0.05187874f, 0.16803603f, 0.13146852f, 0.03567666f, -0.45908749f, 0.27507851f, 
    0.27002615f, -0.13048844f, -0.28350592f, 0.12237642f, -0.30517015f, 0.01739562f, 0.22172707f, 0.26917997f, 
    0.36180937f, 0.05658373f, -0.01066798f, -0.35378364f, 0.01084092f, 0.25417426f, 0.08498561f, -0.36693275f, 
    0.12040932f, 0.01915140f, -0.15702473f, 0.24213311f, -0.09205172f, 0.00611314f, -0.04782935f, -0.05683693f, 
    -0.06135540f, -0.03069886f, 0.11661813f, 0.02518474f, -0.08590312f, 0.16175555f, 0.08174652f, 0.35539716f, 
    -0.02668686f, 0.25085419f, 0.06330338f, 0.27049953f, -0.11333130f, 0.10684050f, 0.11322604f, 0.00548767f, 
    -0.53349239f, -0.37838668f, 0.01656108f, -0.11161187f, -0.19342196f, 0.13132232f, -0.04288974f, 0.16501015f, 
    -0.05117863f, -0.03496530f, 0.15744321f, -0.20478813f, -0.26152992f, -0.46378946f, 0.20105909f, -0.07918242f, 
    -0.04448750f, -0.06576807f, 0.05898064f, -0.02404111f, -0.00766865f, -0.04880322f, 0.00011866f, -0.11310262f, 
    0.02089949f, -0.07750029f, 0.07097147f, -0.05555414f, 0.05324109f, 0.05395903f, -0.07421687f, -0.06221208f, 
    0.01761254f, 0.06115161f, 0.03761131f, 0.02835336f, -0.09443381f, -0.01688134f, -0.08423355f, 0.00710216f, 
    -0.04900458f, 0.05877528f, 0.02385762f, -0.07082638f, -0.03824041f, 0.06634526f, -0.03924321f, -0.00071767f, 
    -0.08288963f, -0.00488403f, -0.02320467f, -0.08806144f, 0.03767937f, -0.02263796f, 0.00390268f, 0.01114381f, 
    -0.08946444f, -0.02698774f, 0.06805648f, -0.04863878f, -0.07463814f, -0.09194148f, -0.05164259f, 0.06675430f, 
    0.07361782f, -0.05637873f, 0.04402057f, -0.02850929f, 0.01372832f, 0.09158663f, -0.01827608f, -0.03660464f, 
    -0.02762183f, 0.03187364f, -0.02957861f, -0.01036478f, -0.03919886f, -0.00348913f, 0.02933047f, 0.01235872f, 
    -0.06193136f, 0.04347701f, 0.08782595f, -0.07933649f, -0.01888105f, 0.07630082f, 0.07840548f, 0.01350445f, 
    -0.08102474f, 0.00974793f, 0.01332502f, -0.05345462f, 0.05103351f, -0.04320789f, 0.05040297f, 0.03886461f, 
    0.01877974f, 0.08672253f, 0.05663813f, -0.02225548f, 0.05639983f, 0.04048410f, -0.01230229f, -0.05683514f, 
    -0.06111107f, 0.00319388f, -0.08111489f, -0.00299393f, 0.05782393f, 0.08727575f, 0.02351245f, -0.10691179f, 
    -0.01329556f, -0.00776605f, 0.06385250f, 0.03802888f, -0.01647746f, 0.02764358f, -0.06958950f, 0.03179105f, 
    0.05916859f, 0.01653340f, -0.02031286f, -0.01721433f, -0.06614352f, -0.05421985f, 0.06072501f, -0.03882271f, 
    0.08254644f, 0.01539759f, -0.07071900f, 0.06862529f, -0.06643266f, -0.06766976f, -0.08214790f, 0.04516017f, 
    -0.00872207f, -0.04471768f, 0.05728271f, -0.01603093f, -0.06546746f, -0.05335524f, 0.07341174f, 0.00512826f, 
    -0.02019215f, -0.51601785f, -0.09337479f, -0.04515138f, -0.06872112f, -0.05638748f, 0.14769022f, 0.20428258f, 
    -0.12896451f, -0.07040644f, 0.09133647f, 0.33219334f, 0.19129330f, 0.00887045f, -0.02180087f, -0.13839720f, 
    0.00328145f, -0.03473365f, 0.14503011f, -0.06824755f, 0.25424206f, 0.05080571f, -0.02453690f, 0.06734072f, 
    0.07378837f, -0.00908219f, 0.01150057f, 0.03483880f, -0.00140585f, -0.24857169f, -0.00737852f, -0.18670024f, 
    -0.28857341f, 0.16854766f, 0.04718022f, 0.06389603f, -0.04056744f, -0.01125045f, 0.01360670f, 0.33332369f, 
    0.26488438f, 0.43089351f, 0.04478739f, 0.00787361f, -0.25360367f, -0.00752585f, 0.03666162f, 0.30186841f, 
    -0.04652438f, -0.82843059f, 0.23371105f, 0.31804952f, 0.07430752f, 0.16923545f, 0.08047610f, 0.04097675f, 
    -0.18658280f, -0.00395864f, -0.23086663f, 0.01776572f, -0.10287669f, 0.09395564f, -0.08698352f, -0.12893863f, 
    0.18996252f, -0.13645300f, 0.00677113f, 0.12629440f, -0.06284732f, 0.06081979f, -0.39849818f, -0.22528118f, 
    0.14046839f, 0.11684775f, -0.06193499f, -0.17666779f, -0.03657029f, 0.12701805f, -0.01029164f, 0.11236248f, 
    0.25435710f, -0.04134218f, 0.02584366f, -0.60658956f, 0.11894559f, -0.07584525f, -0.07855164f, -0.27180216f, 
    -0.00194456f, 0.22086906f, -0.07169755f, 0.11139282f, 0.09197029f, -0.04624031f, -0.00333735f, -0.02728789f, 
    0.05915176f, 0.17064990f, -0.20483555f, -0.04236086f, -0.32692274f, 0.17437281f, -0.25474578f, 0.08292143f, 
    0.20596150f, -0.04091137f, 0.04895316f, 0.10946961f, -0.07405701f, -0.08693574f, 0.10797115f, 0.13261719f, 
    0.09159606f, -0.35255125f, 0.16566718f, -0.12431280f, 0.04429382f, -0.12725468f, -0.11943018f, -0.17482939f, 
    -0.04327197f, -0.07088652f, 0.26952091f, 0.04932161f, 0.18024985f, -0.20526206f, 0.20583981f, 0.14405659f, 
    -0.19052742f, -0.17241764f, -0.51226395f, -0.06843453f, 0.00252015f, 0.15101223f, 0.13137703f, -0.03180439f, 
    -0.16899492f, -0.03695570f, 0.00268938f, -0.22943918f, 0.01519365f, 0.04436695f, -0.17708242f, 0.13004267f, 
    -0.21641646f, 0.07184477f, 0.10435056f, -0.36323866f, 0.48071113f, 0.01947201f, 0.14418064f, -0.18237241f, 
    -0.22406918f, -0.14578788f, -0.03381103f, -0.17638503f, -0.11946475f, 0.05718531f, -0.19938107f, 0.02795236f, 
    0.04165423f, -0.21907827f, 0.14526480f, -0.19240369f, -0.11570667f, -0.05321137f, -0.29212534f, 0.13109979f, 
    0.33626440f, 0.11047736f, -0.68312770f, -0.14299810f, 0.22430357f, -0.10564120f, -0.07675728f, 0.07325692f, 
    -0.21982153f, -0.26334831f, 0.16282499f, -0.25980255f, -0.30637661f, 0.00768285f, -0.02994536f, 0.17843714f, 
    0.15857342f, -0.15725017f, 0.56304812f, 0.16436070f, -0.06182347f, 0.25048363f, -0.04851143f, -0.22550169f, 
    0.11757248f, 0.30959296f, 0.00686221f, 0.19766776f, 0.13272150f, 0.00752855f, -0.13030341f, -0.12242337f, 
    0.13939014f, -0.08248942f, -0.34415418f, 0.02547511f, 0.04588834f, 0.07425922f, 0.15510148f, 0.24128610f, 
    0.08091878f, 0.04960622f, -0.21098112f, -0.16864049f, -0.03025163f, 0.05119248f, 0.20323706f, -0.06834176f, 
    -0.32895517f, 0.12284016f, -0.08161583f, 0.06408236f, -0.12607862f, 0.03355921f, -0.03147137f, -0.09174157f, 
    0.11484366f, 0.12077176f, 0.25706458f, -0.30019906f, -0.38221902f, -0.34322190f, 0.11337972f, -0.26297840f, 
    -0.21899323f, 0.08536066f, -0.02117014f, 0.02261727f, -0.27649179f, 0.09104256f, 0.18016998f, 0.38928342f, 
    -0.20746535f, -0.51960522f, 0.17511536f, 0.07039195f, -0.07373562f, 0.12908734f, -0.01643542f, -0.33849403f, 
    -0.04869602f, 0.28206632f, 0.26367080f, -0.56578904f, -0.01158485f, 0.08575788f, -0.03440762f, 0.11601932f, 
    0.04565577f, 0.04051622f, 0.10293655f, 0.08523347f, 0.08832879f, 0.02203010f, -0.21165852f, -0.16773868f, 
    -0.02815687f, 0.05829582f, 0.06934050f, 0.14828014f, 0.00140323f, -0.16073123f, -0.08635842f, 0.18773600f, 
    0.13978635f, 0.03964940f, -0.16172251f, -0.01561986f, -0.21206126f, -0.01744170f, 0.07083821f, -0.00068999f, 
    -0.01327099f, 0.15744039f, 0.18242192f, 0.00668028f, -0.00412876f, 0.15329660f, 0.17391752f, 0.07136683f, 
    0.00434592f, -0.20254181f, -0.03081050f, -0.22524059f, 0.11524541f, -0.02492402f, 0.22086549f, 0.01136384f, 
    -0.09493750f, 0.04361578f, 0.31070450f, 0.20714840f, -0.33463153f, 0.05648264f, 0.00489271f, 0.12877177f, 
    0.19546838f, 0.26862681f, -0.05982821f, 0.13259502f, 0.06711346f, -0.20289463f, 0.10200541f, 0.04717738f, 
    0.00008832f, -0.11584942f, -0.12198391f, -0.20847271f, -0.21492365f, -0.08693192f, 0.19101636f, 0.10384183f, 
    0.06497455f, -0.23166202f, 0.04974071f, -0.02357768f, 0.10128885f, -0.02981826f, 0.09306803f, 0.16065302f, 
    -0.01310962f, 0.20486474f, 0.12966670f, 0.20872062f, -0.21707669f, -0.23513170f, -0.04859772f, -0.05884089f, 
    -0.27985954f, -0.00778730f, 0.05870282f, 0.14737605f, 0.20578031f, 0.01901785f, 0.06167619f, 0.02190661f, 
    -0.03158706f, 0.09852450f, -0.29122797f, -0.07534108f, 0.08348759f, 0.02760892f, 0.01228419f, -0.03664589f, 
    0.16957049f, -0.12441361f, -0.09971688f, -0.07720191f, 0.29686701f, -0.10316040f, 0.10826189f, 0.23417287f, 
    0.04705958f, -0.18008661f, -0.11551753f, 0.04364324f, 0.19962156f, 0.05497368f, 0.05860329f, -0.01756261f, 
    0.09497969f, 0.07772617f, 0.00013076f, 0.13781364f, 0.10277915f, 0.04681765f, 0.27317291f, -0.13813870f, 
    0.19260575f, -0.09911301f, 0.01421919f, -0.19770779f, -0.21938199f, 0.10038016f, 0.07879835f, 0.01578128f, 
    0.15244222f, -0.20496278f, -0.00800903f, 0.08862176f, 0.05556834f, 0.14989606f, -0.16364761f, -0.04072211f, 
    -0.08212289f, -0.02915818f, -0.00985630f, -0.32660475f, 0.19451034f, 0.23145525f, -0.01492603f, 0.07678349f, 
    0.07818429f, -0.07114159f, -0.04575552f, -0.18277988f, -0.11793020f, -0.05656134f, 0.08384372f, -0.20901765f, 
    -0.06727641f, -0.00477589f, 0.05608379f, -0.05900890f, 0.02826491f, 0.17649366f, 0.28630874f, -0.11751316f, 
    -0.19562225f, -0.13740359f, -0.01309636f, -0.15599522f, 0.11564321f, -0.03883871f, -0.26969141f, 0.27353036f, 
    0.01761349f, -0.09055488f, -0.35386434f, 0.09624855f, -0.00273802f, -0.08361804f, 0.03492599f, 0.01441745f, 
    -0.00068443f, -0.57489854f, 0.13210650f, 0.39348084f, -0.43994412f, 0.25402504f, 0.16524649f, -0.01918674f, 
    0.23058437f, -0.34870526f, 0.12630829f, -0.16211773f, 0.01776177f, 0.33594629f, 0.17450725f, -0.06427053f, 
    -0.10763314f, 0.03909990f, 0.00852427f, 0.13153669f, 0.04014543f, 0.02470445f, -0.31540701f, 0.10311903f, 
    -0.00708012f, -0.06960090f, 0.03447323f, 0.18799089f, 0.43468699f, -0.08380183f, 0.16080259f, -0.01459720f, 
    0.01842173f, -0.08446344f, 0.04770468f, -0.10453434f, 0.08432933f, 0.00151709f, 0.03371470f, 0.07304399f, 
    -0.32618842f, -0.05794696f, -0.07636641f, 0.04678104f, -0.10110408f, 0.01865590f, -0.07719726f, -0.02229069f, 
    0.03657982f, 0.03125754f, 0.04658686f, -0.03241041f, -0.12313079f, -0.07874426f, 0.20662165f, 0.36996421f, 
    -0.11220548f, -0.03773164f, 0.15179361f, -0.11064498f, 0.21671209f, 0.12621582f, -0.01874574f, -0.00208862f, 
    -0.64124572f, -0.02233169f, 0.14780402f, 0.05100068f, -0.00925286f, 0.15076540f, 0.06784321f, -0.01580926f, 
    0.08067413f, 0.08634143f, 0.15651938f, -0.91733825f, -0.48547456f, 0.01860363f, 0.13251542f, 0.21965346f, 
    -0.04086730f, -0.06617849f, 0.04104237f, 0.03598873f, 0.02492891f, -0.10013840f, 0.05600820f, 0.05476958f, 
    0.01301004f, -0.08568969f, 0.06479200f, -0.06646800f, -0.07277700f, -0.00907665f, 0.00600669f, -0.08793345f, 
    0.00399648f, -0.01574847f, -0.08853295f, -0.08384012f, 0.00907740f, -0.08690216f, -0.07534435f, -0.06795279f, 
    -0.04471011f, 0.05197171f, 0.00136363f, -0.05844759f, -0.04103180f, 0.07605115f, 0.06109676f, 0.04055980f, 
    -0.05920051f, -0.08273923f, -0.02260844f, -0.05261703f, -0.04538975f, -0.00879978f, 0.03523792f, -0.01659083f, 
    0.05237727f, 0.06776670f, -0.08366931f, -0.06463670f, 0.06571875f, -0.10416868f, -0.05361458f, 0.06819367f, 
    -0.06424013f, -0.02509225f, -0.01501164f, -0.07361329f, -0.02550800f, -0.00254110f, -0.00587577f, 0.06755188f, 
    -0.00680332f, -0.02750016f, -0.04611172f, -0.07048683f, 0.04067405f, -0.11265842f, 0.00432807f, 0.00693327f, 
    0.04094810f, -0.05143159f, -0.01926440f, -0.10166246f, -0.01473520f, 0.05857363f, -0.03902724f, 0.00716428f, 
    -0.01917957f, -0.00237245f, -0.08934871f, 0.00696830f, 0.05825456f, -0.09952692f, -0.07025054f, -0.10739193f, 
    0.03456892f, 0.02041999f, -0.03539595f, 0.01913889f, -0.11195546f, -0.00960705f, -0.05431987f, -0.05766014f, 
    0.05915082f, -0.10367206f, 0.05701114f, 0.01827916f, -0.04764317f, -0.00159802f, 0.01993972f, -0.00709459f, 
    -0.08292169f, 0.05830685f, -0.07791337f, -0.10619000f, -0.06937984f, -0.00707428f, -0.04005267f, 0.05087524f, 
    -0.02660924f, -0.11376666f, 0.05648112f, -0.03322734f, 0.03825619f, -0.01988852f, -0.00662737f, -0.07519285f, 
    -0.02881352f, -0.04834255f, 0.00457050f, -0.02131856f, 0.02498739f, -0.10813431f, -0.05424563f, -0.09048121f, 
    -0.00492904f, 0.06760611f, -0.02681016f, 0.03844023f, -0.09061496f, -0.05046721f, -0.10931640f, 0.00666524f, 
    -0.05134802f, -0.08665851f, -0.05498306f, 0.05945769f, 0.01293978f, -0.04183552f, -0.09037630f, -0.00193649f, 
    -0.01905496f, -0.00745889f, -0.00705701f, -0.08842064f, 0.00578554f, -0.12754409f, 0.02077489f, 0.02363733f, 
    -0.00079496f, -0.00330732f, 0.06457411f, -0.12553102f, -0.01681126f, -0.05375907f, -0.00088846f, -0.01008695f, 
    -0.01265035f, 0.04638320f, -0.09244914f, -0.10034792f, -0.07408815f, -0.02282704f, -0.03970809f, 0.05042580f, 
    -0.09420131f, -0.04169774f, -0.07127486f, -0.05155364f, -0.02438098f, 0.06880969f, 0.03121307f, 0.03082188f, 
    0.04565522f, 0.05660134f, 0.00237827f, 0.00040365f, -0.08817779f, -0.11249817f, -0.08297101f, 0.05161237f, 
    0.00447033f, -0.00831675f, -0.11569028f, -0.07022063f, 0.08463492f, 0.06208122f, -0.04504667f, -0.07902754f, 
    -0.09630404f, -0.01328289f, -0.01088843f, 0.07206783f, -0.08204548f, 0.04630644f, 0.00843703f, -0.00072044f, 
    0.03119810f, -0.08002986f, -0.01322750f, -0.08084264f, -0.01731507f, -0.04585231f, -0.09289327f, -0.03131163f, 
    -0.08339001f, -0.00456778f, -0.03075944f, -0.00825357f, -0.05251586f, 0.01811153f, -0.12930012f, -0.10058604f, 
    0.00391632f, -0.02426448f, 0.01690892f, 0.04106297f, -0.04326474f, -0.15997139f, -0.11009552f, 0.01079735f, 
    -0.01433543f, 0.00321487f, 0.01035651f, -0.04083898f, 0.04902623f, 0.08044718f, 0.08509633f, -0.01360701f, 
    -0.06275239f, 0.05628819f, -0.09783316f, -0.07062278f, -0.03944386f, 0.00665732f, -0.00838125f, -0.04847158f, 
    0.00826319f, -0.09362226f, -0.09477475f, -0.02891685f, -0.04539229f, 0.03662817f, -0.09929899f, -0.05595951f, 
    -0.09294558f, 0.00550383f, -0.01033661f, -0.07412933f, 0.01092288f, -0.06053715f, -0.06350428f, 0.00576849f, 
    -0.00893253f, -0.11028712f, -0.01818617f, -0.00089620f, 0.00662396f, -0.03183010f, 0.02966502f, 0.02447713f, 
    -0.24404784f, -0.18703824f, 0.10865312f, 0.04486552f, -0.08717798f, -0.06381797f, 0.29197466f, -0.19123864f, 
    -0.18460824f, -0.58644223f, -0.18258739f, 0.52071327f, -0.24498829f, -0.02147087f, -0.37439796f, 0.24590693f, 
    0.23073953f, -0.04081904f, -0.07127801f, -0.03878485f, 0.50432521f, -0.00103617f, 0.01716788f, -0.13794707f, 
    0.09671275f, 0.23180929f, 0.04735029f, 0.26170710f, -0.24386717f, 0.40783134f, -0.42750260f, 0.22865880f, 
    -0.02081223f, -0.12430074f, -0.25199333f, 0.08125278f, -0.19546537f, 0.03336335f, -0.04513181f, 0.17731416f, 
    -0.00289698f, 0.09575198f, -0.00257200f, 0.05559999f, 0.26613766f, 0.08461957f, -0.23322730f, -0.47818473f, 
    0.15147659f, 0.09292696f, 0.00440918f, -0.31117374f, -0.07192812f, 0.14684111f, -0.23267700f, -0.13071552f, 
    -0.02220967f, 0.08610667f, -0.02621591f, 0.17221509f, 0.12918997f, -0.03716609f, 0.22547543f, -0.32941392f, 
    0.03864540f, 0.14256269f, -0.11160208f, 0.05500505f, 0.02035430f, 0.04221685f, -0.19356517f, -0.08502376f, 
    0.01446148f, 0.31630224f, -0.39756659f, 0.08596136f, -0.32415181f, 0.16655958f, -0.02586233f, 0.08962880f, 
    -0.09637138f, 0.08804111f, -0.10187405f, -0.54500973f, 0.08468071f, 0.17383792f, 0.13521954f, -0.06914534f, 
    -0.02024830f, -0.16917567f, -0.63069528f, 0.03983385f, 0.47647256f, 0.03482205f, 0.06432345f, 0.33321723f, 
    -0.48542342f, 0.29057017f, -0.19507995f, 0.07586146f, 0.05454761f, -0.05614950f, -0.13808608f, -0.53572083f, 
    -0.09329244f, -0.21433344f, 0.06834690f, 0.22260988f, 0.02220537f, -0.07292647f, 0.01638534f, 0.43458062f, 
    0.27364725f, 0.24624750f, -0.08427434f, 0.23250507f, 0.28174904f, 0.03429394f, 0.03051752f, 0.06627856f, 
    0.27491218f, 0.28313288f, -0.12652339f, 0.21482179f, 0.51210892f, -0.04919496f, 0.03391998f, 0.22770952f, 
    0.01880822f, 0.03797532f, 0.06211064f, -0.00581036f, -0.03519888f, -0.10731789f, -0.02274335f, -0.08561569f, 
    -0.06063140f, 0.00635412f, -0.03563459f, -0.10284384f, 0.06158519f, -0.00449969f, -0.03319829f, 0.02514984f, 
    0.04712430f, 0.05665186f, -0.07997715f, 0.01579791f, -0.00726160f, -0.00522348f, -0.02783936f, -0.06993274f, 
    0.02635908f, -0.08899888f, 0.03734324f, 0.03268394f, -0.09658779f, -0.05259128f, -0.11026260f, 0.06057164f, 
    0.00303919f, 0.02290200f, 0.01199023f, -0.00256708f, 0.00852765f, 0.04809001f, 0.04790216f, -0.08659281f, 
    0.05537474f, 0.03896551f, -0.03837181f, 0.03423656f, -0.04796037f, -0.00175629f, -0.05376773f, -0.09002994f, 
    -0.09563085f, 0.08069202f, -0.09254552f, 0.01227072f, -0.00565618f, 0.03582680f, -0.03246679f, 0.04711752f, 
    -0.05888982f, 0.04129700f, -0.03368652f, -0.03046065f, 0.03081709f, 0.00200139f, 0.00736775f, 0.04914939f, 
    -0.03094953f, -0.00750688f, 0.03998010f, -0.06402128f, 0.00712201f, -0.09673445f, -0.05975313f, -0.05572989f, 
    -0.01880234f, 0.03849567f, -0.00600423f, -0.02316316f, 0.04779660f, -0.09179240f, -0.06627139f, -0.06331928f, 
    0.04781510f, -0.01705972f, -0.11487910f, 0.08216953f, -0.05395357f, 0.03531755f, 0.05090978f, -0.05966537f, 
    -0.05059113f, 0.04511448f, 0.03588986f, -0.07886794f, -0.06754682f, 0.02038984f, 0.01317776f, 0.02433914f, 
    -0.06719897f, -0.03839638f, -0.02078909f, 0.05427122f, -0.05754390f, 0.00543339f, 0.00044078f, -0.01832634f, 
    0.04905662f, 0.01024844f, -0.01364819f, -0.10331934f, 0.04516975f, -0.00274253f, -0.10199088f, -0.04550401f, 
    0.01958079f, -0.00689363f, 0.04878329f, -0.06519932f, -0.03203960f, -0.07127254f, -0.09845624f, -0.04080231f, 
    -0.08525044f, -0.01819869f, -0.03194284f, -0.06027958f, -0.08790877f, -0.06232579f, 0.06037746f, -0.03296714f, 
    0.00159542f, 0.03595849f, -0.07590415f, 0.05574023f, -0.08919296f, -0.06958116f, -0.01672385f, 0.05269045f, 
    -0.10341981f, 0.02695620f, -0.05750734f, 0.05735272f, 0.02208153f, -0.04105208f, -0.04052595f, -0.03673460f, 
    0.00889897f, 0.08445973f, -0.03064559f, 0.01148772f, -0.01472235f, -0.08348040f, 0.04235870f, 0.00141025f, 
    -0.04203412f, -0.03225774f, -0.09051026f, -0.06518995f, -0.04705476f, 0.01994202f, -0.01388655f, 0.03288528f, 
    -0.00908574f, 0.02417348f, -0.01707998f, 0.07048742f, -0.05665517f, 0.00146315f, 0.03262493f, 0.04034475f, 
    -0.00096545f, -0.02707134f, -0.03293322f, -0.10833707f, 0.07070980f, 0.02050065f, -0.10348581f, 0.06991166f, 
    0.04238322f, 0.06181448f, 0.00558441f, -0.08487537f, -0.00975040f, 0.06967175f, -0.06269965f, -0.09667104f, 
    0.02560336f, -0.02211407f, -0.01472087f, -0.10548551f, 0.00135016f, 0.06292059f, 0.03140643f, -0.00194626f, 
    -0.05500545f, -0.01621098f, 0.03989264f, -0.10662828f, 0.03338800f, 0.02782155f, 0.04027923f, 0.04409476f, 
    -0.00313150f, -0.00680410f, -0.03212863f, -0.03731767f, 0.07928155f, 0.03715178f, 0.04498903f, -0.02407601f, 
    -0.03511351f, 0.03924399f, 0.01074042f, -0.09805451f, 0.02962200f, -0.04393741f, 0.05385085f, -0.03917028f, 
    0.00151731f, 0.01946171f, 0.03801243f, -0.09628908f, 0.01336325f, 0.05082098f, -0.08714451f, -0.10028466f, 
    0.01144663f, -0.07498458f, -0.07188402f, -0.06030136f, 0.03388317f, -0.12648046f, -0.08353427f, 0.04775032f, 
    -0.03469141f, 0.02052637f, -0.09999862f, 0.03178251f, -0.09627068f, -0.10338677f, -0.08977437f, -0.07501388f, 
    0.05501090f, 0.02060147f, -0.07172985f, -0.03814579f, -0.07509258f, 0.03710007f, -0.07386389f, 0.06113870f, 
    -0.03451773f, -0.05755297f, -0.04831981f, -0.03663164f, -0.06703471f, 0.01245655f, 0.02049804f, -0.03976462f, 
    0.29076138f, -0.31113684f, 0.13514164f, 0.07557590f, 0.05905841f, 0.32680485f, 0.13706453f, -0.14341958f, 
    0.16281693f, 0.39438885f, 0.18049230f, -0.10499468f, 0.16803467f, -0.43332765f, 0.19694009f, 0.15668975f, 
    -0.14707097f, 0.02075294f, 0.10759877f, 0.12106289f, -0.23264302f, -0.05821847f, -0.15373990f, -0.25788054f, 
    0.09041383f, -0.16776310f, -0.01481225f, 0.35487482f, -0.01236719f, 0.04484799f, 0.30152982f, 0.01167654f, 
    -0.22050491f, -0.09566904f, 0.12114606f, 0.09821981f, 0.05738393f, -0.01304914f, 0.55220741f, -0.04395865f, 
    -0.06848861f, -0.03265239f, -0.20176847f, 0.13390374f, -0.07833020f, -0.02409535f, 0.17501621f, -0.31378278f, 
    -0.02303525f, 0.23845378f, 0.00776279f, -0.25386250f, 0.20879851f, -0.00314204f, 0.35925585f, 0.16696692f, 
    0.03939405f, -0.10694220f, 0.14777887f, -0.13361727f, 0.04464095f, -0.12014230f, -0.19720912f, 0.47332442f, 
    0.04223894f, 0.03332775f, 0.07576841f, -0.01447812f, 0.00591990f, -0.12215418f, 0.00331881f, 0.24386328f, 
    0.00251393f, -0.07446725f, 0.07590026f, 0.02680210f, 0.08412796f, -0.72376299f, 0.07190653f, 0.05589854f, 
    -0.10951544f, 0.07106024f, 0.05363308f, 0.16840249f, -0.04631238f, 0.06349580f, -0.14851539f, 0.15863757f, 
    0.33787456f, -0.04597252f, 0.08671720f, -0.01503965f, 0.28437951f, 0.04106530f, 0.07024397f, -0.66487634f, 
    0.31942058f, 0.18101127f, -0.10876069f, 0.07760045f, 0.21115495f, 0.19780667f, 0.47277457f, 0.13509074f, 
    0.04577610f, 0.06747296f, -0.18398361f, 0.07981057f, 0.06830472f, 0.03632617f, 0.03736130f, -0.48223850f, 
    0.13524383f, 0.11644509f, -0.00334902f, -0.17640358f, -0.16945916f, -0.06798451f, 0.04531533f, -0.15171811f, 
    0.37168860f, 0.27797234f, -0.09191471f, 0.01477121f, 0.40607938f, 0.03850187f, 0.05318404f, -0.44178799f, 
    -0.09273531f, 0.02457376f, 0.00736493f, 0.05863574f, -0.11443242f, -0.01858514f, -0.04614814f, -0.08102120f, 
    0.02981313f, 0.06784933f, -0.03028166f, -0.01339279f, -0.09793152f, -0.04564004f, 0.00178269f, -0.13114518f, 
    -0.07962320f, 0.05506370f, 0.04328838f, 0.03379267f, -0.05611840f, 0.02079465f, -0.05060457f, 0.03286303f, 
    -0.07708554f, -0.06279139f, -0.08632927f, 0.01150479f, -0.06031573f, -0.15259892f, -0.04851973f, 0.00947417f, 
    0.02213676f, 0.03830120f, 0.04495769f, 0.01036543f, 0.03900767f, 0.04274272f, -0.08605275f, -0.03550939f, 
    -0.05288125f, -0.09405906f, 0.05157212f, -0.10132485f, -0.06062116f, -0.06789685f, -0.01675438f, -0.09276582f, 
    -0.05782975f, -0.07756094f, -0.09972045f, 0.03130016f, 0.07465785f, -0.01414660f, -0.08374760f, -0.06241316f, 
    -0.05480700f, -0.03932048f, 0.02673282f, 0.06670615f, 0.01896561f, 0.03405989f, 0.03261920f, -0.10619636f, 
    -0.02317735f, -0.05231293f, 0.04240194f, 0.00810366f, -0.07212365f, -0.02940280f, 0.01106530f, -0.03328747f, 
    -0.05982171f, -0.11262767f, 0.02662493f, -0.08067909f, 0.05193845f, -0.03188981f, -0.12504275f, 0.01626899f, 
    -0.09462494f, -0.08530301f, -0.03893301f, 0.03414715f, -0.08003674f, -0.01546565f, -0.00521686f, 0.05135567f, 
    -0.04596775f, -0.11594153f, -0.02263379f, -0.05721040f, -0.11178225f, -0.05255419f, 0.05348481f, -0.06345759f, 
    0.06475169f, 0.08662916f, -0.08954199f, 0.06801158f, 0.07429746f, 0.03091169f, 0.03114110f, 0.08404396f, 
    0.01614962f, 0.07275312f, 0.02231712f, -0.10356592f, -0.04864960f, -0.09922969f, 0.07078690f, 0.02132318f, 
    0.02614316f, -0.03805746f, -0.09254905f, -0.09819855f, -0.10468073f, 0.01014129f, 0.03189068f, 0.05874117f, 
    -0.10869099f, 0.04544549f, -0.02402120f, -0.04786026f, -0.06259587f, -0.01553420f, -0.01120208f, -0.05887522f, 
    0.01102513f, -0.02153359f, 0.04102175f, -0.08059517f, -0.06038290f, -0.09624585f, -0.09764860f, -0.11325102f, 
    0.03871335f, -0.03977407f, -0.07495961f, 0.04594217f, -0.02977107f, -0.01298165f, -0.04578495f, -0.02265508f, 
    -0.10509165f, 0.02070455f, -0.09602603f, 0.04355316f, -0.09798077f, 0.00802896f, -0.00661354f, 0.03570442f, 
    -0.01764439f, -0.11108010f, -0.10228746f, -0.05112424f, 0.03323304f, -0.04237406f, -0.05629274f, 0.02862680f, 
    -0.07473378f, -0.03067334f, -0.03680884f, -0.03779248f, 0.07431401f, 0.02378414f, 0.04510487f, -0.03840465f, 
    -0.06397105f, -0.09550383f, -0.03445747f, -0.03681901f, -0.10434995f, -0.12051902f, 0.05172545f, -0.03066167f, 
    -0.04726785f, -0.04885897f, -0.06029202f, -0.00228176f, 0.07576443f, 0.01206990f, -0.01320021f, 0.01300306f, 
    0.07123527f, -0.03834159f, 0.02428836f, -0.10849775f, -0.12599124f, -0.08182614f, 0.04129090f, -0.04303874f, 
    -0.09884765f, 0.05308158f, -0.07352850f, -0.03072714f, -0.04957591f, -0.05496588f, -0.03449855f, 0.04040173f, 
    -0.02581779f, -0.09841815f, -0.04307005f, -0.00145254f, 0.02964338f, -0.05280629f, -0.01621738f, 0.00553663f, 
    0.02621706f, -0.03481406f, 0.02817088f, 0.01996993f, 0.02271508f, 0.02256387f, 0.07355665f, -0.06329810f, 
    0.01407014f, -0.11039134f, -0.07479601f, -0.05103872f, 0.00618549f, 0.03463603f, 0.02993865f, -0.09581862f, 
    -0.01210638f, 0.03757510f, -0.08824813f, -0.05696438f, -0.03218070f, -0.00196006f, -0.03010415f, -0.03384167f, 
    -0.05063097f, -0.06561672f, -0.11739107f, 0.02560112f, -0.06909915f, -0.04612928f, -0.02601532f, 0.01357716f, 
    0.02318406f, -0.03465468f, -0.10489140f, -0.04157073f, -0.03196846f, 0.02202678f, -0.06289247f, -0.01301561f, 
    -0.03473828f, 0.06901487f, 0.00629117f, -0.02094532f, -0.00457016f, -0.11432137f, -0.09849421f, -0.01061526f, 
    -0.04746508f, -0.03116626f, 0.03692157f, 0.00453573f, -0.08383261f, -0.06855677f, 0.04330873f, 0.06441349f, 
    -0.09859078f, -0.07126128f, -0.01530623f, -0.06598387f, 0.05065272f, -0.00330962f, -0.00533642f, 0.01868059f, 
    -0.09376158f, -0.05294123f, 0.04169920f, -0.09940477f, -0.07829192f, -0.06808467f, 0.01946926f, -0.03172233f, 
    -0.01491714f, -0.06306694f, -0.05181822f, -0.08055777f, 0.05918568f, -0.08790266f, 0.00474882f, 0.04986866f, 
    -0.07524682f, -0.10412584f, -0.03359162f, -0.07802573f, -0.06373145f, -0.02175200f, -0.04251755f, -0.06207027f, 
    0.04999718f, -0.08533264f, -0.04050493f, -0.00986603f, 0.05392971f, -0.04722896f, 0.04612420f, -0.05359342f, 
    -0.01112108f, -0.03999721f, 0.06510056f, 0.01252473f, 0.05357173f, -0.07609113f, -0.10617666f, -0.02131027f, 
    -0.06166369f, -0.05862648f, -0.05631888f, -0.01835869f, 0.00818099f, -0.00526668f, -0.09944297f, -0.00210629f, 
    0.06083879f, -0.01114713f, -0.00624855f, -0.04007858f, -0.06709323f, -0.07168035f, -0.07152122f, 0.02319495f, 
    -0.08010072f, 0.00100195f, 0.06315481f, -0.03658024f, -0.02476442f, -0.08781641f, 0.05321965f, 0.04827077f, 
    0.00786047f, -0.08365034f, -0.03650592f, -0.01763190f, -0.04931552f, -0.01403326f, 0.00471753f, 0.05181237f, 
    0.03373206f, -0.05943718f, 0.00042295f, -0.05249801f, -0.03243865f, 0.03253673f, -0.06816411f, -0.00958504f, 
    -0.05853382f, -0.02090738f, -0.00367780f, -0.03570319f, -0.05700501f, -0.06433052f, -0.08773524f, -0.05916803f, 
    -0.04739620f, 0.08625861f, -0.09652603f, -0.06310808f, -0.08493800f, 0.01984118f, -0.07879188f, 0.06038776f, 
    0.03086365f, 0.01569706f, 0.02199820f, -0.04119082f, -0.00929782f, -0.00999581f, -0.07474598f, -0.06015196f, 
    -0.00001382f, 0.03442454f, -0.08463410f, -0.07507630f, 0.04627851f, 0.02909375f, -0.05975972f, -0.09448066f, 
    0.13833255f, -0.80048513f, -0.14411439f, 0.08461910f, -0.11759245f, 0.07682727f, -0.26124918f, 0.21439838f, 
    -0.18389273f, -0.16795981f, 0.13473052f, -0.15194772f, -0.04022519f, -0.20141697f, -0.09984090f, 0.12056924f, 
    -0.19587885f, 0.08720426f, 0.34484786f, 0.14020847f, -0.21228430f, 0.01418475f, 0.19379513f, -0.51685959f, 
    -0.25540373f, 0.00250887f, 0.06477793f, -0.37342060f, 0.07150014f, -0.09832122f, -0.04893006f, 0.20666580f, 
    0.09651076f, -0.20834917f, 0.11489818f, -0.25270715f, -0.02440672f, -0.01479543f, -0.15949702f, -0.05135456f, 
    0.30573794f, 0.04624163f, 0.69065756f, 0.14059773f, -0.29835412f, 0.18114950f, 0.12586917f, 0.11780246f, 
    -0.07820919f, -0.01160930f, -0.10730578f, 0.09950919f, 0.22637223f, 0.46986818f, -0.12271830f, 0.02528417f, 
    0.21117668f, 0.00292931f, 0.16360286f, 0.19062024f, -0.15992384f, 0.41051885f, 0.08764762f, 0.12500359f, 
    -0.06162932f, 0.17933710f, 0.01853758f, 0.13905610f, 0.24473958f, -0.21219410f, -0.07274425f, -0.41205737f, 
    0.25062203f, 0.00416022f, 0.11368179f, 0.08095211f, 0.27081060f, 0.15013608f, -0.04827471f, 0.19154519f, 
    0.13709620f, -0.00787496f, 0.14982082f, 0.18673760f, 0.14150646f, -0.08054624f, 0.09162630f, 0.06523018f, 
    -0.04233907f, 0.12231123f, -0.15451737f, -0.06604058f, -0.02114062f, 0.07196157f, 0.04087298f, -0.12739445f, 
    0.27097046f, -0.62281561f, -0.12826246f, -0.20995960f, 0.18206453f, -0.15435527f, 0.11462155f, -0.39536995f, 
    0.38381159f, 0.00993768f, -0.19512416f, 0.16506381f, -0.36455572f, -0.13241009f, 0.15997384f, 0.14930828f, 
    0.06321053f, -0.25889191f, -0.06456524f, 0.11903441f, -0.05680213f, 0.16159248f, 0.09409497f, -0.06052370f, 
    -0.06589341f, 0.19223681f, -0.06380103f, 0.25880396f, -0.06913769f, -0.13914679f, -0.00254407f, -0.04679763f, 
    0.06616487f, 0.46369731f, -0.12012008f, 0.03295765f, -0.03476816f, 0.31884885f, -0.17221673f, -0.06669251f, 
    -0.23069671f, 0.08438101f, -0.06480927f, -0.13535780f, 0.10572942f, -0.04384866f, 0.17908370f, -0.14181866f, 
    -0.11775190f, 0.03032386f, 0.23258574f, 0.06959176f, -0.02269327f, 0.02503962f, 0.14892590f, -0.15928040f, 
    -0.21726027f, -0.23249061f, 0.14158900f, -0.36434644f, 0.13205102f, 0.16301693f, 0.13053389f, 0.10326813f, 
    0.07332496f, 0.00953731f, -0.06364641f, -0.13793802f, 0.15141270f, 0.07376567f, -0.06930871f, -0.01887992f, 
    0.17228691f, -0.03004109f, -0.09292975f, 0.02168110f, -0.24487540f, 0.25306368f, 0.07507772f, -0.38444367f, 
    -0.12598936f, 0.11488107f, 0.01752361f, -0.36651385f, 0.19443557f, 0.05992445f, -0.25086951f, -0.01811141f, 
    0.32392627f, -0.02204273f, 0.18080892f, 0.09726856f, -0.12831627f, 0.19096632f, 0.02460308f, -0.27697900f, 
    -0.28930011f, 0.43440622f, 0.04513007f, 0.10109212f, 0.18293512f, 0.05957196f, 0.23183298f, -0.29325405f, 
    0.42697302f, -0.13255595f, -0.16684572f, 0.27397975f, -0.14156534f, -0.04267935f, -0.09674391f, 0.40100732f, 
    -0.00552561f, -0.07005763f, 0.13529336f, 0.13145302f, 0.21376435f, 0.10860702f, 0.21994804f, -0.18851259f, 
    0.08667570f, -0.28909937f, 0.08535219f, 0.08202571f, -0.16238448f, 0.05115773f, 0.03552068f, -0.27620414f, 
    0.02555826f, -0.16512299f, 0.28013372f, -0.13253756f, 0.34375823f, -0.09150743f, 0.32620147f, -0.44254220f, 
    -0.01766893f, 0.36267272f, -0.08181070f, 0.19411571f, -0.30124274f, 0.12679099f, 0.05640366f, -0.10531336f, 
    -0.73371112f, -0.21448441f, 0.01766754f, 0.25381058f, -0.11785426f, 0.29681262f, 0.06749585f, 0.14847602f, 
    -0.17667833f, 0.14049664f, -0.29247314f, -0.02462186f, 0.24318534f, -0.57325572f, -0.10263310f, -0.23301700f, 
    0.00616847f, 0.16688828f, -0.06363504f, -0.07114761f, -0.02118981f, -0.09426665f, 0.00018326f, 0.25545579f, 
    -0.00726981f, -0.12312237f, 0.10164341f, -0.15647435f, 0.15404652f, -0.15201850f, -0.08234732f, 0.14966875f, 
    -0.00132513f, 0.07644786f, -0.05999768f, -0.26896209f, -0.15529865f, 0.07959987f, 0.00849618f, -0.08861735f, 
    0.03991952f, 0.22133702f, 0.03175838f, 0.05439122f, 0.10554811f, -0.35575035f, 0.24239674f, 0.02462558f, 
    -0.06312343f, -0.12208455f, 0.10876513f, -0.06885687f, 0.03830830f, 0.01107755f, -0.05111857f, 0.25424761f, 
    0.08192040f, 0.09266771f, -0.03521381f, -0.19071221f, -0.48940405f, -0.06450219f, 0.12303587f, 0.32848436f, 
    0.15982540f, -0.73523831f, 0.28529024f, 0.39835173f, -0.18230696f, 0.27301279f, 0.20978233f, 0.07709214f, 
    0.10327648f, -0.18707590f, 0.13663846f, 0.01264010f, -0.13120739f, 0.36937711f, 0.15019232f, -0.19733453f, 
    0.17831936f, -0.14417940f, 0.00607266f, 0.11623883f, -0.00060179f, 0.02932776f, -0.09847408f, -0.00912752f, 
    -0.15552376f, -0.02439857f, -0.03073884f, 0.03480578f, 0.30013776f, -0.04271669f, 0.26635674f, -0.16626474f, 
    0.05855656f, -0.08149267f, -0.07482644f, -0.20183682f, -0.03834802f, -0.10497202f, -0.17007490f, 0.04735247f, 
    -0.32848927f, 0.23007065f, -0.02693514f, 0.00731988f, -0.13999467f, -0.04582005f, 0.07544795f, 0.12111620f, 
    0.23376642f, -0.21572952f, -0.01184173f, 0.06676619f, -0.33766520f, 0.02732847f, -0.04418090f, 0.62050736f, 
    0.23319305f, -0.10053483f, 0.22980002f, -0.22218589f, 0.17211604f, 0.03821506f, 0.03855283f, 0.29142508f, 
    -0.19200017f, -0.21423560f, 0.04568107f, -0.12909369f, 0.06679290f, -0.06316814f, 0.06393141f, -0.28217536f, 
    0.07397769f, 0.20375058f, 0.45356309f, -0.38069195f, -0.05331717f, 0.12015623f, 0.06343898f, 0.32518336f, 
    0.10252978f, -0.19070628f, 0.02482465f, -0.05034385f, 0.16554333f, 0.12375401f, -0.30142742f, -0.05783653f, 
    0.04463078f, 0.02104152f, -0.00080293f, -0.43088478f, 0.00818899f, 0.21314222f, -0.01558075f, 0.24031132f, 
    -0.10433206f, -0.04173171f, -0.08625334f, -0.05274422f, -0.11384077f, -0.03135561f, 0.03143522f, -0.19593009f, 
    -0.05311224f, 0.07223440f, 0.14899968f, -0.09420589f, 0.01367022f, -0.01988141f, 0.15006210f, 0.09659401f, 
    0.03044681f, -0.17048927f, -0.04795207f, 0.05214087f, 0.10610450f, 0.00703848f, -0.17621781f, 0.10452548f, 
    -0.25745377f, -0.38860077f, -0.01362444f, -0.00133022f, 0.13867672f, 0.03380915f, 0.07546856f, -0.19506852f, 
    0.07771917f, 0.02861248f, -0.02953994f, 0.17210449f, -0.39845034f, 0.21156511f, 0.00033083f, 0.02761869f, 
    0.36336994f, -0.14709507f, 0.12782766f, -0.18150212f, 0.04107242f, 0.20490120f, 0.11567993f, 0.45636874f, 
    -0.03688938f, 0.06341153f, 0.10009386f, 0.06818622f, 0.03056683f, -0.04913988f, 0.18371470f, 0.13269480f, 
    -0.05118131f, -0.10793125f, 0.01969849f, 0.25977230f, 0.15746450f, 0.06617060f, 0.04752413f, 0.18356188f, 
    -0.11751137f, -0.07637404f, -0.03182638f, -0.11873791f, -0.02830603f, 0.17432262f, -0.00688443f, 0.16275761f, 
    -0.16345182f, 0.07974797f, -0.01871376f, 0.06199377f, -0.06898585f, -0.08139309f, 0.06242783f, 0.12056962f, 
    0.01661001f, -0.02169590f, 0.26044044f, -0.00189281f, 0.14853215f, -0.05760109f, 0.22718033f, 0.17027815f, 
    -0.17967975f, -0.03856504f, 0.05252446f, -0.00347893f, 0.17164160f, 0.10962052f, -0.01375943f, -0.04274954f, 
    -0.00696572f, 0.00082226f, 0.00096050f, 0.20746560f, -0.07266369f, 0.14642520f, 0.22976890f, 0.00517658f, 
    -0.05140334f, -0.08177479f, 0.09676795f, -0.51859170f, -0.16024354f, 0.07969157f, -0.02647850f, 0.10516606f, 
    0.31769145f, -0.58072352f, -0.03972568f, -0.08088158f, -0.09863926f, -0.04677991f, 0.15577239f, 0.19183902f, 
    -0.03714196f, -0.21633288f, 0.13010894f, -0.00605288f, 0.21769346f, -0.49016666f, -0.14837947f, 0.44031391f, 
    -0.12401559f, 0.02966007f, 0.25004008f, -0.03087638f, -0.26835331f, -0.01979106f, 0.06053222f, -0.58231920f, 
    0.06179391f, -0.00787464f, 0.07890107f, 0.06387415f, -0.00670790f, -0.01216543f, 0.19643219f, 0.32421827f, 
    -0.02893817f, -0.11003957f, 0.01368136f, 0.12069864f, 0.16523854f, 0.04933638f, 0.16401213f, -0.20962398f, 
    0.05576721f, -0.10412001f, 0.15422735f, 0.06384110f, -0.41633350f, -0.01722327f, 0.18450052f, 0.09692948f, 
    -0.08334614f, -0.73206061f, 0.05651949f, -0.10469291f, 0.27684718f, 0.07435609f, 0.30523232f, 0.10299644f, 
    0.05147209f, -0.15169783f, 0.40392283f, 0.00487185f, 0.18063252f, 0.30180544f, 0.04991534f, 0.16482963f, 
    0.21082217f, 0.18184498f, 0.08621103f, 0.14586774f, 0.18157326f, -0.25101233f, -0.53393018f, -0.27729839f, 
    0.00392634f, 0.16846253f, 0.01868828f, -0.12470789f, 0.71897888f, 0.06882029f, 0.07565496f, 0.07191802f, 
    0.04341865f, 0.03267328f, -0.09508190f, -0.95841593f, -0.03229160f, 0.01380503f, 0.00801322f, 0.17989849f, 
    0.21244636f, 0.05295011f, 0.05439167f, -0.05215922f, 0.06432785f, 0.01280396f, 0.04888076f, 0.10677124f, 
    0.28897384f, -0.03751598f, -0.24532969f, -0.06004643f, 0.10422214f, -0.20102343f, 0.12791693f, 0.10401481f, 
    0.32252946f, -0.06497409f, -0.10979664f, 0.02938705f, -0.21727410f, -0.10657013f, -0.07297956f, -0.19118804f, 
    0.32618734f, -0.07198535f, -0.35495141f, 0.08270621f, 0.13754180f, 0.02754499f, 0.16314101f, -0.25007838f, 
    0.15516330f, 0.23833470f, 0.00239924f, 0.37633222f, 0.34660134f, 0.16487460f, -0.03644445f, 0.13149068f, 
    0.08973087f, -0.34594673f, 0.18489705f, -0.09940938f, 0.16181771f, -0.40117615f, 0.20516327f, 0.14483173f, 
    0.14870015f, -0.27537513f, -0.01840656f, 0.00447293f, 0.18101922f, -0.28734785f, -0.09639440f, 0.08711301f, 
    0.56078923f, 0.06866769f, -0.11574318f, -0.02672114f, 0.30184907f, -0.06087756f, 0.13617603f, -0.06591995f, 
    0.03597410f, 0.23391259f, 0.12367231f, 0.06687557f, 0.01317009f, 0.03737852f, 0.20511295f, 0.27942875f, 
    -0.22152416f, -0.22434656f, -0.17674786f, 0.10817521f, 0.10764635f, 0.06413548f, -0.04888443f, 0.01635514f, 
    0.29414192f, -0.01274317f, -0.11145176f, -0.11953872f, -0.20807414f, 0.02945871f, 0.27884197f, -0.50666946f, 
    0.03323147f, -0.43864143f, 0.01529489f, 0.12733938f, -0.18517610f, -0.28844905f, 0.10421859f, -0.07249843f, 
    0.00429953f, -0.00139444f, -0.32211459f, -0.07862752f, 0.00282128f, 0.28015733f, 0.14872549f, -0.36122641f, 
    0.07041596f, -0.02786152f, 0.00033187f, 0.03692663f, 0.07555854f, -0.09503716f, -0.21496376f, -0.16048050f, 
    -0.07517697f, 0.08558357f, 0.29173002f, 0.04824168f, 0.12867890f, 0.30077505f, -0.05987354f, -0.17247550f, 
    -0.26872772f, -0.08597876f, 0.16577795f, -0.48139200f, -0.07533140f, -0.37752312f, -0.17904246f, 0.27073565f, 
    -0.15322617f, 0.05403249f, -0.18420447f, -0.14094634f, -0.06525294f, 0.03293470f, -0.08467671f, 0.49514243f, 
    -0.11577235f, 0.15008034f, -0.22527505f, 0.23024367f, -0.02102968f, -0.07857820f, -0.08691945f, -0.16360295f, 
    0.09390370f, -0.03104988f, 0.20747918f, -0.09012102f, 0.45687762f, -0.01493684f, 0.05910090f, 0.03287704f, 
    -0.53778261f, -0.04358119f, 0.11015455f, 0.04511603f, 0.28139278f, -0.06642407f, 0.21338537f, -0.44152370f, 
    0.17245853f, -0.17208931f, 0.19762149f, 0.04906898f, 0.27840903f, -0.01425900f, 0.05727705f, 0.42921358f, 
    0.00389055f, -0.21929869f, 0.02649094f, -0.01748863f, -0.14323743f, -0.20595677f, -0.08972828f, 0.19826104f, 
    0.22966594f, -0.01471284f, 0.09175038f, -0.11504027f, -0.02922118f, -0.21887879f, 0.01191245f, -0.01933780f, 
    -0.39435875f, 0.01425080f, 0.16612008f, 0.13991357f, -0.54352462f, -0.02693696f, 0.19027680f, 0.01199510f, 
    -0.21999921f, 0.06260389f, -0.08210523f, -0.12523971f, 0.26528764f, -0.61815566f, 0.10504854f, 0.11217684f, 
    0.15010354f, -0.03046522f, -0.00770627f, -0.03457155f, 0.00402974f, -0.07941896f, 0.23505317f, -0.51910388f, 
    0.23414552f, -0.16398442f, 0.19544493f, -0.02051403f, -0.72893816f, 0.18878764f, 0.17755301f, 0.30490208f, 
    0.05007289f, 0.16984896f, -0.17307772f, 0.26501146f, 0.21666907f, -0.12792204f, -0.19013733f, -0.33013284f, 
    0.01409724f, 0.28295559f, -0.00701771f, 0.15335828f, -0.44970736f, 0.26308802f, 0.11018525f, 0.15346408f, 
    -0.05066575f, -0.07076284f, -0.03724437f, -0.28555179f, 0.12182033f, 0.10399003f, -0.35125256f, -0.50739509f, 
    -0.03189985f, -0.11281984f, 0.52393228f, -0.04595026f, -0.19090226f, 0.35808012f, -0.42391708f, -0.07064555f, 
    -0.13315001f, 0.00682224f, 0.22850901f, -0.14395456f, 0.15566140f, -0.56492937f, -0.05271419f, 0.01488543f, 
    -0.14152066f, 0.22834897f, 0.19011430f, -0.38026521f, -0.08926640f, -0.02461297f, -0.06129775f, 0.24594265f, 
    -0.11592732f, 0.04800751f, 0.06146571f, 0.20335326f, -0.08286266f, -0.20223890f, -0.42169678f, -0.62141192f, 
    0.04971826f, 0.11340459f, -0.05184593f, -0.32995158f, 0.03464948f, -0.07304140f, 0.03621008f, 0.02292880f, 
    0.07272992f, -0.19435981f, -0.21421707f, -0.16127670f, -0.07298177f, 0.17487438f, 0.01305076f, -0.40628582f, 
    -0.07146389f, -0.39671132f, -0.02798550f, 0.42013082f, -0.13135827f, 0.14479646f, -0.35795522f, -0.09821054f, 
    -0.08006776f, -0.01132473f, 0.04288632f, -0.06485615f, 0.03729136f, -0.07540330f, 0.07519098f, -0.03198239f, 
    -0.01647424f, -0.01077063f, -0.05767754f, -0.07276679f, 0.03697175f, 0.04306016f, 0.03104125f, -0.03333154f, 
    0.01145454f, 0.02179734f, 0.03921285f, -0.00618734f, 0.15812808f, 0.06995967f, -0.01429279f, -0.02300833f, 
    -0.07440045f, 0.02581482f, -0.13949907f, 0.00047986f, -0.09790634f, -0.04400190f, 0.00339018f, 0.01090320f, 
    -0.01696105f, 0.00787189f, -0.06760596f, 0.02842275f, -0.08979329f, 0.07555318f, 0.03368966f, -0.01441059f, 
    -0.14726982f, 0.04187055f, 0.12024307f, -0.12226467f, -0.00741516f, -0.05188453f, -0.01406403f, 0.06640486f, 
    -0.07048314f, -0.05551873f, 0.05511964f, -0.03223915f, 0.00305020f, 0.01662882f, -0.04029979f, -0.06020434f, 
    -0.00971819f, -0.00881473f, 0.01726402f, -0.05920317f, 0.05941084f, -0.03226062f, -0.12701534f, 0.12033304f, 
    -0.04071319f, -0.05983317f, -0.04385614f, -0.03696774f, -0.08104584f, -0.06802957f, -0.03033805f, -0.00334997f, 
    -0.09985922f, -0.03968695f, -0.00408491f, -0.02151044f, 0.01773885f, -0.10558147f, -0.05436352f, -0.02294400f, 
    -0.05290611f, -0.04361678f, 0.03134693f, 0.04134888f, 0.00031629f, -0.03462921f, -0.05051461f, 0.00120935f, 
    -0.09813154f, 0.05428321f, 0.05531452f, -0.08526114f, -0.04789119f, 0.04777789f, 0.07474449f, -0.12454480f, 
    -0.04729472f, 0.00609887f, -0.06538618f, -0.08155908f, -0.08067358f, 0.06221998f, 0.04512500f, 0.03568118f, 
    0.02624305f, 0.04420711f, -0.05326019f, -0.10474559f, 0.03973651f, 0.00176161f, -0.10368694f, -0.00793961f, 
    0.10999907f, -0.07170062f, -0.03222425f, -0.09036636f, -0.08132402f, -0.02460267f, -0.00774977f, -0.03821109f, 
    0.05705991f, -0.10766773f, 0.05074791f, -0.10185622f, -0.02803303f, 0.01705635f, -0.11470962f, -0.12974325f, 
    -0.01760929f, -0.05858192f, -0.04339361f, -0.00997833f, -0.06306749f, -0.00450692f, 0.06045955f, -0.04649571f, 
    -0.02732571f, -0.09492680f, 0.04455940f, -0.02474847f, -0.02413395f, -0.03286159f, -0.02850095f, 0.03356636f, 
    0.03149385f, 0.00468945f, 0.03041453f, -0.10226623f, -0.07804312f, 0.02159630f, -0.10063293f, 0.07077129f, 
    -0.07380035f, -0.03222505f, -0.03579087f, -0.02745050f, 0.03502782f, -0.06958657f, -0.06984229f, -0.04273784f, 
    0.02990536f, -0.07681191f, -0.03062771f, -0.03846211f, -0.04203461f, 0.06350239f, -0.02113337f, -0.05393252f, 
    -0.02957902f, -0.09551436f, -0.02914708f, 0.04156809f, 0.00941425f, -0.08538165f, 0.06061440f, -0.11407150f, 
    -0.05614224f, -0.05219620f, -0.10512805f, -0.06738823f, -0.08445577f, -0.05076572f, -0.07667574f, -0.01743309f, 
    0.01619000f, 0.06664741f, -0.01671875f, -0.04626278f, -0.08779941f, -0.02357868f, -0.03554022f, 0.01685338f, 
    0.02088826f, -0.05611809f, 0.04293065f, -0.04337142f, 0.06067246f, -0.00289856f, 0.07123001f, -0.07872087f, 
    -0.06071384f, 0.03239214f, -0.00232198f, -0.09498040f, -0.06539983f, -0.09233065f, -0.03886079f, -0.05415776f, 
    -0.06171122f, 0.08371381f, -0.02287517f, 0.04495468f, 0.02299026f, -0.00251244f, -0.06002988f, -0.08041190f, 
    -0.04174003f, -0.02847784f, -0.01156086f, -0.06198797f, 0.04929749f, 0.01651567f, 0.06443103f, 0.01166618f, 
    -0.03249589f, 0.01172231f, -0.00738448f, 0.02401511f, 0.06644043f, 0.04708629f, 0.06175102f, 0.03425586f, 
    0.04116571f, -0.03894314f, 0.05860265f, -0.04572591f, 0.02695764f, -0.00909857f, 0.04970969f, -0.08873570f, 
    0.02147026f, 0.01266636f, -0.01611603f, -0.08694675f, -0.05972232f, 0.03867061f, -0.05409344f, -0.02982159f, 
    -0.08674252f, 0.06478743f, -0.04535580f, -0.06195331f, -0.01758508f, -0.01703737f, -0.08451517f, -0.10478081f, 
    0.05151661f, -0.31314915f, 0.00839905f, -0.06527033f, -0.55907190f, -0.19330657f, 0.23263001f, -0.02771897f, 
    0.26058239f, -0.00228312f, -0.12025017f, -0.16847268f, -0.22106032f, 0.27770561f, 0.04475728f, 0.16843092f, 
    -0.07382289f, -0.02881544f, -0.23283464f, 0.04682216f, 0.28159630f, 0.01321125f, -0.30413371f, -0.04294811f, 
    0.11118775f, -0.16394150f, -0.33368531f, 0.20624401f, -0.35485283f, 0.04863031f, -0.28927147f, 0.10178003f, 
    0.30627522f, 0.20684421f, 0.11466885f, 0.17974380f, 0.06308507f, 0.05325704f, -0.01642819f, -0.26886752f, 
    -0.41674453f, -0.20600313f, 0.15861218f, -0.10212544f, 0.58157068f, -0.25664645f, 0.02893444f, -0.20459352f, 
    -0.04196295f, 0.12118589f, -0.00676841f, 0.20235023f, 0.05220483f, -0.20023844f, 0.29516378f, -0.14816916f, 
    -0.25574934f, 0.04083480f, 0.04268379f, 0.22501144f, -0.04714908f, -0.42408332f, -0.24951792f, -0.27715704f, 
    -0.09581602f, 0.09153330f, 0.00164728f, -0.37258220f, -0.14569981f, 0.04609907f, 0.14270073f, 0.43803674f, 
    -0.24223156f, -0.02615129f, -0.09211520f, -0.15133443f, 0.08632331f, 0.19125891f, 0.04917426f, -0.06341692f, 
    0.01993141f, -0.05546430f, 0.06727651f, 0.20195460f, -0.34556136f, 0.16755943f, -0.06119629f, 0.06105363f, 
    -0.08119052f, -0.12274458f, -0.11649174f, -0.31988227f, 0.17874691f, -0.07085437f, -0.06822424f, 0.17809352f, 
    -0.23139492f, 0.37259743f, -0.11468024f, 0.16732064f, 0.19332796f, -0.40440151f, -0.23508774f, 0.05393734f, 
    -0.10376842f, -0.44209090f, -0.30515575f, 0.07991665f, -0.49604043f, -0.17556717f, -0.05050334f, 0.07146787f, 
    -0.12814881f, 0.20403887f, -0.38520312f, -0.13934708f, -0.09779362f, -0.15038109f, 0.03269817f, 0.44442761f, 
    0.17843300f, 0.02573519f, -0.24330322f, 0.35902822f, 0.14488038f, -0.07788493f, -0.55204797f, -0.33600810f, 
    0.01863719f, 0.03698257f, -0.03088353f, -0.00310201f, -0.06906163f, -0.09720667f, -0.07283278f, 0.04497293f, 
    -0.03280696f, -0.09563673f, 0.01772972f, 0.01079427f, 0.00262977f, -0.00937449f, 0.01438015f, 0.03272203f, 
    0.05797349f, -0.07487766f, 0.00210733f, -0.00230973f, 0.01907938f, -0.04841284f, 0.06262696f, 0.03674958f, 
    -0.03324148f, -0.09981560f, -0.01763838f, -0.04458378f, -0.04691647f, -0.03505470f, -0.10109935f, 0.06842232f, 
    -0.10025803f, -0.11147229f, 0.00504946f, 0.02971404f, 0.01104775f, 0.06716845f, -0.06234147f, -0.01104479f, 
    0.00673355f, -0.06981212f, -0.01627059f, -0.02098331f, -0.07945318f, -0.00421210f, -0.08016432f, 0.03723601f, 
    -0.06618254f, -0.04255425f, -0.09420849f, -0.07953931f, 0.08334125f, 0.02990801f, -0.11284513f, -0.01964200f, 
    -0.05037681f, 0.00624275f, -0.07359698f, -0.07177106f, -0.05206897f, -0.01588033f, 0.00957606f, 0.04189948f, 
    -0.05867459f, -0.08805414f, 0.04973557f, -0.02450557f, 0.02716253f, 0.03539818f, -0.04810710f, 0.01148789f, 
    -0.09278907f, -0.00294794f, -0.08864503f, 0.05114995f, -0.00565221f, -0.06808542f, 0.06206572f, 0.04339295f, 
    -0.12164471f, 0.03977131f, -0.07366288f, 0.02327105f, -0.02212393f, 0.04908637f, -0.05473560f, -0.00298951f, 
    0.04280502f, 0.02358495f, -0.01630392f, 0.00712440f, 0.05885089f, 0.01412028f, -0.01384031f, -0.10066239f, 
    -0.02883388f, -0.09023736f, 0.02907437f, -0.01335134f, -0.03663480f, 0.00729597f, 0.05908689f, -0.00835835f, 
    -0.08371094f, -0.05362367f, -0.09740589f, -0.01410275f, 0.02499374f, 0.01912947f, 0.03901782f, -0.05483356f, 
    0.03228613f, -0.03865174f, 0.05381099f, -0.08215974f, -0.08206090f, -0.06079502f, -0.00105742f, -0.11546373f, 
    0.00720360f, -0.07095192f, -0.00831597f, -0.07649940f, -0.02686987f, -0.00037744f, -0.05286691f, -0.01355137f, 
    0.09536950f, -0.57572383f, -0.07171112f, 0.09930352f, -0.34912235f, -0.19468166f, -0.05252626f, 0.24084760f, 
    -0.40621346f, -0.25700817f, 0.10259346f, 0.38446417f, 0.20936094f, -0.11221372f, 0.06910498f, -0.04419038f, 
    -0.05385886f, 0.00547189f, 0.15531407f, 0.20780246f, -0.12712981f, -0.07164359f, 0.06301166f, -0.07664413f, 
    -0.12930243f, -0.07585419f, -0.06934125f, 0.02140626f, 0.17919773f, -0.27254215f, -0.02608001f, 0.13340950f, 
    -0.29321238f, 0.06238584f, 0.32339495f, -0.08749573f, -0.00271090f, 0.00986963f, -0.06603415f, 0.24386372f, 
    0.32316238f, 0.43171063f, 0.39037615f, 0.01319194f, -0.38250092f, 0.13517143f, 0.07945565f, 0.18635149f, 
    -0.15380713f, -0.79339379f, 0.16636619f, 0.46946654f, 0.15135224f, 0.14698091f, 0.21668094f, 0.07366104f, 
    0.12421062f, -0.15422235f, -0.18549345f, 0.17773369f, -0.30192986f, 0.45771247f, -0.10049377f, -0.39377081f, 
    -0.09406825f, -0.11075599f, -0.01972567f, 0.07358974f, -0.01539416f, -0.00258378f, -0.04849671f, 0.00387574f, 
    0.07310766f, -0.02486976f, 0.34108067f, -0.26144749f, 0.16534859f, 0.21760544f, 0.16523212f, 0.17481522f, 
    0.29745251f, -0.03495128f, 0.06099116f, -0.17565188f, 0.14537545f, -0.07315113f, 0.04731843f, -0.16064326f, 
    0.03792450f, 0.24829045f, -0.24254273f, -0.06774502f, -0.12640317f, 0.07296511f, 0.02069437f, -0.03784281f, 
    0.04190599f, -0.11194300f, -0.26478571f, -0.08141052f, -0.03697132f, 0.08044191f, -0.12629785f, 0.61925167f, 
    0.40744546f, 0.09454920f, -0.06206297f, -0.00748969f, -0.09130944f, -0.22334613f, 0.01733955f, -0.03293605f, 
    0.05020078f, -0.33538154f, -0.28042528f, -0.04210086f, 0.02330178f, -0.12404090f, -0.04681607f, 0.05402417f, 
    0.01502543f, 0.01524235f, 0.18517426f, 0.16500397f, -0.02529985f, -0.39832821f, 0.15186894f, 0.10592520f, 
    0.05507410f, 0.21236956f, 0.11354230f, -0.05572021f, -0.25346115f, -0.07299004f, 0.36055341f, -0.03200393f, 
    -0.12844166f, 0.15949175f, 0.04540923f, 0.36577153f, 0.04175109f, -0.17266841f, 0.17689718f, -0.11700334f, 
    0.60985857f, -0.03915870f, -0.12397791f, 0.16547547f, 0.28304297f, 0.03629374f, -0.18126801f, 0.15911378f, 
    0.17075101f, -0.12108924f, -0.15260257f, 0.34114459f, 0.01267752f, 0.20317374f, -0.12183200f, 0.09442582f, 
    0.24271220f, 0.28006712f, 0.26015785f, 0.22711889f, -0.05148165f, -0.02656552f, 0.11404153f, -0.50250131f, 
    0.01752485f, 0.12808032f, -0.14662401f, 0.14305384f, 0.14600852f, -0.14839441f, 0.19032227f, 0.04439959f, 
    -0.01893084f, -0.03284403f, 0.16303800f, 0.26975980f, 0.24800293f, -0.35349551f, 0.14446902f, 0.20975751f, 
    -0.10234100f, 0.02652979f, -0.30127525f, 0.28181905f, -0.11884859f, -0.32755357f, -0.01656039f, -0.31865388f, 
    0.04747280f, 0.20418555f, 0.03248905f, 0.04184019f, -0.30094698f, 0.23935440f, -0.30253291f, 0.36588997f, 
    -0.11642396f, 0.21558698f, -0.00044545f, -0.07565884f, -0.06208118f, -0.13134071f, 0.17139569f, -0.12152874f, 
    0.20591049f, 0.03469450f, 0.30098510f, -0.12867607f, -0.05034224f, 0.26473257f, 0.12254030f, -0.20113569f, 
    0.36854994f, -0.07560819f, -0.00512331f, -0.17106263f, 0.36421430f, 0.02675897f, -0.04039863f, -0.32708520f, 
    0.11648289f, 0.27015305f, -0.11033978f, 0.09045313f, 0.18960457f, 0.20309396f, 0.18944265f, -0.00836953f, 
    -0.10083310f, 0.02075432f, -0.21859002f, 0.00270279f, -0.26274586f, -0.03248638f, -0.05197972f, 0.09655676f, 
    0.00006944f, 0.13376553f, -0.06784918f, -0.09026273f, 0.19066088f, -0.12266379f, -0.08825556f, 0.26752231f, 
    0.13442935f, 0.49594781f, -0.11103649f, 0.29120442f, 0.52154899f, -0.25843769f, -0.11650841f, -0.10301984f, 
    0.21803801f, -0.51677573f, 0.00408134f, 0.04561082f, -0.32112452f, -0.14091994f, -0.09964063f, 0.33653876f, 
    -0.20857698f, -0.18900768f, 0.16600479f, 0.60729116f, 0.11824965f, -0.24847053f, -0.03181873f, -0.05400370f, 
    0.09903769f, -0.02976387f, 0.08817801f, 0.19581251f, -0.39097562f, 0.03711767f, 0.02129681f, -0.12621322f, 
    -0.04400630f, -0.05118797f, 0.09094681f, 0.03091714f, 0.25722438f, -0.12435469f, 0.20230725f, 0.15877053f, 
    -0.27423033f, -0.03939461f, 0.25436848f, -0.01670181f, -0.06856354f, -0.03002004f, -0.00558479f, 0.03308443f, 
    0.24035653f, 0.48398244f, 0.47202998f, 0.05746565f, -0.44288886f, 0.23657121f, 0.21941127f, 0.23602425f, 
    -0.12697563f, -0.60204023f, 0.14211172f, 0.51961672f, 0.26400462f, 0.30634469f, 0.00537459f, 0.17985792f, 
    -0.04736445f, -0.24361426f, -0.33569494f, 0.09207647f, -0.17666295f, 0.24561301f, 0.11216760f, -0.27401370f, 
    0.03591199f, -0.22674994f, -0.00791340f, -0.07747635f, -0.06951977f, -0.06663665f, -0.15147166f, -0.12134553f, 
    0.00087791f, 0.13842069f, 0.30425066f, -0.23608302f, -0.03683285f, 0.22860588f, 0.01911418f, -0.04980335f, 
    0.18342048f, 0.02063156f, 0.09439551f, -0.39388606f, 0.08608223f, -0.11830214f, -0.06601344f, -0.17675710f, 
    0.12783986f, 0.30097020f, -0.11603772f, -0.04896776f, -0.11857611f, -0.05074698f, 0.00037933f, 0.02188982f, 
    0.20067792f, -0.26898420f, -0.39624956f, -0.17343698f, 0.03288775f, 0.24463668f, -0.24223898f, 0.45273596f, 
    0.37275150f, -0.06161617f, -0.13115196f, -0.04078097f, -0.17836434f, -0.22847566f, 0.04656202f, -0.03805217f, 
    -0.07315755f, -0.24637507f, -0.32154062f, 0.01307927f, 0.12821467f, -0.18460962f, 0.03414633f, -0.20042753f, 
    -0.06625775f, -0.20492968f, 0.25014034f, 0.17375432f, -0.10455900f, -0.37154865f, 0.11737367f, 0.26209494f, 
    0.19930395f, 0.14018138f, -0.03709785f, 0.07429034f, -0.12555470f, 0.18698500f, 0.06107333f, -0.06617513f, 
    0.19601715f, 0.10794928f, -0.07378470f, 0.00236318f, -0.01486042f, -0.27522734f, 0.14202873f, 0.07142923f, 
    -0.27242938f, 0.05365443f, 0.28965819f, 0.16311155f, -0.43464470f, 0.06678251f, 0.08907955f, -0.05755955f, 
    -0.10131770f, -0.10478927f, -0.00002961f, -0.11580335f, 0.08143175f, -0.13836102f, 0.08648640f, 0.06944285f, 
    0.07399059f, 0.12052455f, 0.05654667f, 0.00596913f, 0.08046678f, -0.00575150f, 0.39489773f, -0.14895104f, 
    0.16259959f, -0.18121935f, 0.11722232f, 0.07539036f, -0.59305978f, 0.11706848f, 0.05870119f, 0.16516602f, 
    -0.06013246f, 0.46536478f, -0.14842345f, -0.02786219f, 0.21639261f, 0.07427932f, -0.06754446f, -0.11243522f, 
    0.08238119f, 0.19156557f, 0.09111185f, 0.03295645f, -0.18157224f, 0.22869892f, 0.08038338f, 0.79123664f, 
    -0.06538916f, 0.06763711f, 0.04027062f, -0.17116128f, 0.13633902f, -0.04113281f, 0.07555888f, -0.27636385f, 
    -0.10468870f, -0.18465525f, 0.36683041f, -0.03290812f, -0.23771055f, -0.07138941f, 0.01287925f, 0.01566567f, 
    -0.11784691f, -0.00226298f, 0.19414181f, 0.27090895f, 0.06221496f, -0.21577471f, -0.11720952f, 0.14942853f, 
    0.17889841f, 0.04172169f, 0.24542108f, -0.13697028f, 0.06343812f, 0.05677549f, -0.05016256f, -0.07092419f, 
    0.21149857f, -0.04732563f, -0.06537489f, 0.09808056f, 0.11828604f, -0.11859559f, 0.07582650f, -0.46985066f, 
    0.16040154f, -0.02665967f, -0.13761504f, -0.06525029f, -0.09957689f, 0.05622139f, 0.06437480f, -0.17433456f, 
    0.91417849f, -0.12163955f, -0.12900877f, -0.10641305f, -0.18406259f, 0.01744412f, 0.09509081f, -0.23806421f, 
    -0.04365845f, 0.12187254f, -0.13957745f, 0.28782615f, 0.31526661f, 0.07908836f, -0.21680622f, -0.35156694f, 
    -0.02005243f, 0.31102508f, 0.14871138f, 0.02961822f, 0.18349144f, 0.04307827f, -0.25065127f, -0.05857816f, 
    -0.05357600f, -0.35706109f, -0.01664112f, 0.59722269f, -0.09658889f, -0.37559047f, -0.42544165f, -0.12026419f, 
    0.19506034f, -0.04775741f, 0.05409840f, 0.06065537f, -0.25550812f, -0.08018535f, 0.09729137f, -0.34448484f, 
    -0.03473052f, 0.12946951f, 0.12834467f, -0.34718689f, 0.00696888f, 0.33493343f, 0.04229517f, -0.01284040f, 
    -0.15352395f, -0.85861570f, -0.13905284f, -0.46575037f, 0.00014739f, -0.08230065f, -0.01680350f, 0.28983557f, 
    0.00565109f, 0.48200035f, 0.05491928f, 0.12504444f, -0.66988790f, 0.17238402f, -0.04585294f, -0.01044681f, 
    0.09357263f, 0.65549320f, -0.07931613f, -0.25230432f, 0.14898117f, -0.10461396f, -0.36659053f, -0.03327956f, 
    0.07436071f, 0.13619585f, -0.35156789f, -0.17334718f, -0.02571427f, 0.11040149f, 0.28418627f, 0.59160888f, 
    0.04487608f, -0.17709965f, -0.06124041f, 0.17269517f, 0.17669164f, -0.24287252f, 0.92274362f, -0.15242569f, 
    0.16599117f, 0.00677046f, 0.02925437f, 0.05999122f, -0.41384462f, 0.04055818f, -0.34822878f, 0.16898857f, 
    0.06916144f, -0.06659517f, -0.09379300f, 0.31918114f, 0.17422710f, 0.12641558f, -0.05027144f, 0.14377533f, 
    0.11209020f, 0.36504135f, -0.47960463f, 0.15677486f, -0.09751922f, -0.00454338f, 0.06421567f, 0.21318565f, 
    -0.03418200f, -0.56239700f, -0.13934381f, -0.22607969f, 0.04661139f, 0.10038521f, -0.04690323f, 0.02400476f, 
    0.19333172f, 0.13010111f, 0.03107481f, 0.24947536f, 0.35480183f, 0.01712133f, 0.13937135f, -0.12923262f, 
    0.83370411f, 0.02460977f, 0.02390441f, 0.32714882f, 0.13590604f, -0.01218363f, 0.13940005f, -0.41922069f, 
    -0.18196601f, -0.31474760f, 0.09292125f, 0.17341818f, -0.34667504f, -0.01940766f, 0.16871193f, 0.13143684f, 
    -0.01271138f, 0.24698016f, -0.01982941f, -0.03462069f, -0.07505381f, 0.13514268f, -0.38029295f, 0.11453751f, 
    0.07007056f, -0.00628596f, 0.22853366f, -0.13771188f, 0.04738888f, -0.01283697f, -0.09418026f, 0.10884698f, 
    -0.42973474f, -0.07047566f, 0.19468580f, -0.03957756f, -0.42449507f, -0.06823816f, 0.11332444f, -0.07940996f, 
    0.08291098f, 0.11463046f, 0.14589150f, -0.19147496f, 0.12919791f, 0.01121008f, -0.09115814f, 0.01207082f, 
    0.02075809f, -0.03827665f, 0.06823477f, -0.19590048f, -0.04564308f, 0.05290537f, -0.19321549f, 0.04518681f, 
    0.10606159f, 0.09959716f, 0.43510264f, 0.15458785f, -0.16757073f, 0.29835069f, -0.08117121f, 0.22117238f, 
    0.10886449f, 0.31018999f, 0.09812406f, -0.19109412f, -0.08109618f, 0.59573424f, 0.00995399f, 0.26316065f, 
    0.03684501f, 0.22205046f, 0.27198038f, 0.13674146f, 0.00720086f, 0.07288531f, 0.18114929f, 0.04889812f, 
    0.19657503f, 0.09604043f, -0.05764664f, 0.19426666f, 0.23989336f, -0.04743620f, 0.11826551f, -0.17071219f, 
    0.18841322f, -0.03290037f, -0.18278025f, -0.02133130f, 0.17457294f, 0.08201709f, 0.01484681f, 0.10623211f, 
    0.12952954f, -0.08542410f, -0.14917873f, 0.09985369f, 0.17520311f, 0.03024122f, 0.18790737f, -0.08596900f, 
    -0.01406508f, 0.23316383f, 0.01299207f, 0.16785459f, 0.10330404f, 0.05698365f, -0.00382633f, -0.01665722f, 
    0.28964984f, -0.37026641f, 0.06491481f, -0.11112163f, -0.03279829f, -0.27723426f, 0.06065898f, 0.08502359f, 
    0.28516054f, -0.00334686f, 0.00565978f, 0.16334419f, -0.16737044f, 0.04543978f, 0.14794220f, 0.02709762f, 
    -0.09282031f, -0.06675409f, 0.07299859f, 0.28378183f, -0.13507316f, 0.11571660f, 0.09049667f, 0.05659512f, 
    -0.04121032f, 0.04344326f, 0.14623721f, -0.03024315f, -0.10218362f, 0.07987008f, -0.02814394f, 0.02921627f, 
    0.18775052f, -0.36676371f, -0.06371411f, 0.01150823f, -0.10230005f, 0.21348675f, -0.38992736f, 0.08449803f, 
    -0.41349024f, -0.11329911f, 0.02573459f, 0.02014535f, 0.04761378f, -0.03266681f, 0.10186148f, -0.08369073f, 
    -0.12290432f, -0.05916469f, 0.17893155f, 0.03119370f, -0.37897635f, 0.00862432f, 0.06488940f, 0.23906188f, 
    -0.18457429f, -0.05789950f, 0.17374709f, -0.18122141f, 0.05582168f, -0.02227814f, -0.03088257f, 0.01904063f, 
    -0.05563879f, 0.09072741f, 0.25010231f, -0.07872558f, 0.05066784f, -0.06591091f, -0.49884850f, 0.09945388f, 
    0.20981649f, -0.06612606f, 0.02961275f, 0.05364436f, -0.21595825f, 0.24924591f, -0.00671102f, -0.20645751f, 
    -0.24285905f, -0.35927129f, 0.07494635f, -0.05275247f, 0.13909242f, -0.18936749f, 0.06827609f, -0.09625955f, 
    0.37052441f, 0.02787275f, 0.00607978f, 0.12409826f, 0.01721683f, 0.43011069f, -0.09937900f, 0.00840237f, 
    -0.17957340f, 0.21260455f, -0.04141268f, 0.12251467f, 0.02974387f, -0.10801566f, -0.22047316f, 0.17225371f, 
    0.16510716f, -0.14209607f, -0.26562205f, -0.07131173f, 0.11219905f, 0.11473706f, 0.12792659f, 0.29296565f, 
    0.34950772f, -0.05162742f, 0.02822501f, -0.39505896f, 0.16457017f, 0.16597995f, 0.19959418f, 0.11811813f, 
    0.01783861f, -0.01509840f, -0.04930948f, 0.03763931f, -0.19020024f, 0.01563379f, 0.06614789f, -0.03712334f, 
    0.08562503f, -0.00930628f, 0.14841434f, -0.11372665f, 0.12119699f, 0.09691425f, 0.03815773f, 0.35669413f, 
    0.11276168f, 0.20189078f, 0.01889263f, 0.14963961f, -0.29931575f, 0.02390353f, 0.05844511f, 0.00720612f, 
    -0.09969228f, -0.19923811f, -0.13505934f, 0.15394989f, -0.10325702f, 0.12579466f, 0.15740232f, 0.13994111f, 
    -0.16047977f, 0.09407289f, 0.00790792f, -0.01422204f, -0.15397003f, -0.28568333f, 0.19399460f, 0.01914012f, 
    -0.00142525f, -0.02505818f, -0.02100067f, 0.03476850f, -0.06754751f, -0.08906346f, -0.02907624f, -0.01706748f, 
    0.04299091f, -0.09062351f, -0.01719643f, -0.00878820f, -0.03883677f, 0.00887632f, -0.06305891f, -0.05471749f, 
    -0.08768288f, -0.04250528f, -0.03599868f, -0.05889713f, -0.04627777f, 0.08211669f, -0.02862899f, -0.01491946f, 
    -0.01157925f, -0.07489053f, -0.03396503f, -0.08299032f, -0.08629310f, -0.07776900f, 0.03464799f, -0.03916857f, 
    -0.04385732f, -0.01134719f, 0.05971514f, -0.03938317f, -0.04395764f, 0.02761437f, -0.10257745f, -0.03009271f, 
    0.06481218f, -0.05000713f, 0.04329142f, -0.07167172f, -0.09738395f, 0.01732802f, -0.10094651f, -0.02422025f, 
    -0.10852484f, -0.02503350f, -0.07763241f, -0.02928172f, 0.04100623f, 0.02689925f, -0.08195902f, -0.02429264f, 
    -0.02821952f, -0.00755516f, 0.00735484f, -0.02030380f, -0.01998568f, 0.05757060f, -0.02707975f, 0.00935137f, 
    -0.11695242f, -0.06558824f, 0.08597959f, 0.04377517f, 0.04668547f, -0.03959278f, 0.07545482f, -0.06371110f, 
    -0.00583351f, -0.06057337f, 0.03254899f, -0.05585303f, -0.04977923f, 0.05648967f, 0.06022921f, -0.09067005f, 
    0.00696949f, 0.01077187f, 0.00557003f, 0.08483876f, 0.03196138f, -0.08883655f, 0.03344964f, 0.04790783f, 
    0.00246488f, 0.01550489f, -0.04357230f, -0.03428046f, 0.02877325f, -0.01461810f, -0.00806386f, -0.05108194f, 
    -0.04446747f, -0.06832681f, -0.06753132f, 0.02248931f, -0.01806634f, -0.01020718f, -0.05139329f, 0.02768924f, 
    0.04035281f, 0.05383858f, 0.04521681f, -0.06922764f, 0.05264701f, -0.06868068f, -0.07689996f, 0.05762659f, 
    -0.07425664f, 0.05546382f, -0.03928970f, 0.05378095f, 0.06564981f, 0.03078953f, -0.09963179f, 0.02030012f, 
    -0.08318657f, 0.03075379f, 0.00303038f, -0.05204613f, 0.04388000f, -0.04943602f, 0.01713766f, 0.05875330f, 
    -0.07060982f, 0.08485071f, 0.21185945f, 0.02885037f, -0.31576991f, -0.25801587f, 0.09021752f, 0.15326077f, 
    0.30952805f, 0.09724852f, -0.09327868f, -0.06549955f, 0.04347137f, 0.16745950f, 0.11632466f, 0.19969966f, 
    0.18654744f, -0.06217252f, -0.26088625f, -0.05708274f, 0.41598579f, -0.03678161f, 0.05183318f, 0.07178286f, 
    0.19269636f, 0.21736763f, 0.09836629f, 0.30124593f, -0.09756336f, -0.10105109f, -0.17078254f, 0.16408232f, 
    -0.06580640f, -0.01135651f, -0.04586614f, 0.11970886f, 0.08683407f, 0.01031886f, 0.29283151f, -0.22130926f, 
    -0.15540883f, 0.24740689f, -0.05573601f, 0.19453299f, 0.23803245f, -0.13289256f, -0.02994109f, 0.07532039f, 
    0.21639971f, 0.50662273f, 0.11124630f, 0.22640237f, 0.28641978f, 0.00743718f, 0.16591169f, 0.32052425f, 
    -0.44834077f, 0.06755128f, 0.07178380f, 0.13809545f, -0.27887997f, -0.35856760f, 0.15117420f, 0.01090209f, 
    0.14430074f, -0.25615308f, -0.10877040f, -0.07507745f, -0.12187207f, 0.25358865f, 0.07938737f, 0.20752494f, 
    -0.37771764f, 0.29557401f, 0.11864807f, 0.00842597f, -0.06953768f, 0.03571510f, 0.18189538f, -0.67142171f, 
    0.05771695f, -0.01685205f, 0.17670730f, 0.19772862f, 0.06739239f, 0.00497506f, 0.10822337f, 0.35762817f, 
    -0.08048540f, 0.01888772f, -0.25289798f, -0.40246123f, 0.32510576f, -0.03566828f, -0.05869868f, 0.10406926f, 
    0.18525194f, 0.26601335f, -0.21722779f, 0.14884561f, 0.09507433f, -0.42535001f, 0.18528959f, -0.11112839f, 
    0.08303212f, -0.44387752f, -0.07727975f, -0.33865395f, 0.08888935f, -0.17842670f, 0.07347602f, -0.01490686f, 
    -0.07673026f, 0.14976771f, -0.03034148f, -0.19549277f, 0.16597159f, 0.01280555f, -0.01572408f, -0.07625746f, 
    0.42316079f, 0.14728270f, 0.15614824f, 0.18116142f, -0.02917589f, 0.30918968f, -0.36883822f, 0.18088244f, 
    0.08339823f, 0.23726557f, 0.06319040f, 0.01408562f, 0.01492907f, -0.07852381f, 0.09017117f, 0.05338379f, 
    -0.07926969f, -0.00948357f, -0.02478234f, -0.22216366f, 0.34372929f, -0.23988828f, 0.06884514f, 0.12284318f, 
    0.03984645f, 0.03557272f, 0.00936634f, -0.06124637f, -0.40131965f, 0.01769823f, 0.04310020f, -0.07417400f, 
    -0.13280243f, 0.08003532f, 0.03997489f, 0.09236202f, 0.08008675f, -0.03037265f, 0.26701880f, 0.10538018f, 
    0.17032656f, 0.01542426f, 0.00088598f, -0.01028546f, 0.13851875f, 0.04390292f, 0.14855962f, -0.05514488f, 
    0.25625166f, -0.14829215f, -0.11423421f, 0.04979347f, -0.51405585f, -0.08646260f, 0.27803910f, 0.38475510f, 
    0.04631242f, -0.14408381f, 0.12504511f, 0.48690820f, 0.01455962f, 0.05420995f, -0.01844494f, 0.01971629f, 
    0.27068904f, -0.16053690f, 0.23037495f, 0.09796453f, -0.11492126f, 0.50258845f, 0.12423817f, -0.36818630f, 
    0.09353530f, 0.26068038f, 0.04060959f, 0.07900997f, 0.05726223f, 0.23472236f, 0.05116403f, -0.09964254f, 
    0.01703796f, 0.05282266f, 0.05651628f, 0.21233211f, -0.11196813f, -0.10759261f, 0.09058136f, 0.13198774f, 
    0.03986640f, -0.05518381f, 0.15994531f, 0.09226771f, 0.00140674f, -0.22287969f, 0.02028933f, 0.19059862f, 
    -0.22151035f, 0.22026300f, 0.10086068f, 0.14929625f, 0.01536142f, 0.02514410f, -0.02824965f, -0.08640472f, 
    0.15004329f, -0.05254263f, 0.03894133f, 0.13084297f, 0.07418197f, -0.22746117f, 0.26090834f, 0.20839611f, 
    -0.14657535f, -0.04786078f, -0.01126983f, -0.11352316f, -0.04837250f, -0.01332581f, 0.06856849f, 0.28109092f, 
    -0.50903291f, -0.26576966f, -0.00083105f, -0.02942081f, 0.09969404f, 0.10143982f, 0.09597891f, -0.34966120f, 
    -0.01940552f, 0.25723913f, 0.24607128f, -0.27842671f, 0.04006776f, 0.16373566f, -0.06376269f, -0.00441122f, 
    -0.07222100f, -0.23573281f, 0.20160523f, 0.00095837f, 0.18360959f, 0.01538069f, -0.15853412f, 0.06701408f, 
    -0.06539708f, -0.24669263f, 0.09088629f, 0.55653453f, -0.20156108f, -0.11515549f, -0.16222602f, -0.16721922f, 
    0.25196984f, 0.06910951f, 0.01742429f, 0.17440875f, -0.07974508f, 0.05231115f, -0.06986552f, 0.04312642f, 
    0.25043356f, 0.14190818f, 0.25668874f, 0.09887412f, 0.13624991f, 0.29843181f, -0.00160079f, 0.00562873f, 
    -0.29225147f, -0.07462708f, -0.00660320f, 0.07097193f, -0.05277234f, -0.02452975f, -0.13874415f, 0.23742354f, 
    -0.10528719f, 0.37862059f, -0.10736257f, 0.20657234f, 0.16029122f, 0.25906837f, -0.14749008f, -0.30271411f, 
    0.13110110f, -0.06435490f, -0.07133155f, 0.09556079f, 0.19999829f, -0.58275628f, 0.12393860f, -0.05961730f, 
    -0.23956010f, 0.14181314f, -0.49537152f, 0.02760221f, 0.10015061f, -0.27708685f, 0.12530094f, 0.04420050f, 
    -0.03021706f, -0.12877098f, 0.03762887f, 0.03817185f, -0.05951176f, -0.24765131f, -0.12378734f, 0.19334576f, 
    0.20585880f, 0.25921124f, -0.06726898f, -0.00785428f, 0.07374143f, -0.00109605f, -0.16528375f, -0.08413944f, 
    0.15028842f, 0.07666968f, -0.08380233f, -0.44411427f, 0.20583652f, 0.17556629f, 0.05927231f, -0.11344671f, 
    0.36350188f, -0.10087306f, -0.26804140f, 0.10408292f, 0.07461337f, 0.04191571f, -0.05255012f, 0.21630946f, 
    -0.03402190f, 0.00872444f, -0.09565448f, -0.00683416f, 0.05065213f, 0.33503160f, -0.27629724f, 0.01547482f, 
    0.37039301f, 0.06390803f, 0.15724476f, 0.25813183f, 0.23766752f, 0.03620246f, 0.04199762f, -0.20327780f, 
    0.17542021f, 0.26307133f, 0.05708207f, 0.08389156f, 0.21849711f, -0.03717993f, -0.02515963f, 0.02264695f, 
    0.08518582f, -0.38027221f, 0.00634401f, 0.17958727f, 0.00674601f, 0.01950215f, 0.33575967f, 0.26379523f, 
    -0.12424030f, -0.03892697f, -0.05095359f, 0.02301204f, 0.02521786f, 0.02691584f, -0.09997421f, -0.10381476f, 
    -0.13519974f, -0.01315715f, -0.04089850f, 0.00633432f, 0.00241242f, -0.06640576f, 0.00966665f, -0.06232356f, 
    0.00395419f, -0.03210469f, -0.00258166f, -0.02500577f, -0.09622088f, -0.00286338f, -0.10552675f, 0.06770438f, 
    -0.00207957f, -0.03567267f, -0.01792425f, -0.01409914f, -0.02976684f, -0.01474972f, 0.00095731f, -0.05107048f, 
    0.02786516f, -0.00421898f, 0.01150594f, -0.05501102f, -0.04789628f, -0.01976447f, -0.13532971f, 0.01662316f, 
    -0.11933506f, -0.07874078f, -0.08099425f, -0.10595742f, 0.00310904f, 0.02120745f, -0.07089576f, 0.02982087f, 
    0.00876059f, -0.07383903f, -0.08189837f, -0.03009633f, -0.04192733f, -0.02227378f, -0.17065936f, -0.08658520f, 
    0.01984197f, 0.05426903f, -0.09556583f, -0.03436631f, -0.03774403f, -0.06203366f, -0.06428391f, -0.00122063f, 
    -0.05159152f, -0.03217862f, -0.05563035f, 0.00601296f, -0.08264795f, -0.03553721f, 0.03869803f, -0.03693560f, 
    0.05863604f, -0.15251914f, -0.12780493f, -0.07231057f, 0.02814324f, 0.00731340f, 0.00759195f, -0.09727547f, 
    -0.08036516f, 0.05413354f, -0.14271067f, 0.03340461f, -0.02038667f, -0.01113896f, -0.02520431f, -0.06391468f, 
    -0.09637500f, -0.11490361f, 0.00570700f, 0.02573778f, -0.01974038f, 0.04807952f, 0.06213450f, -0.08351883f, 
    -0.13729256f, -0.08673738f, -0.07222881f, -0.13791512f, -0.13380630f, -0.05922137f, -0.12891750f, -0.07369135f, 
    0.03215538f, -0.05557899f, -0.09416258f, -0.08990517f, 0.00267722f, 0.03739278f, -0.06940418f, -0.00078754f, 
    0.04152477f, -0.03834312f, 0.01677966f, 0.01393517f, 0.00047181f, -0.03871958f, -0.05998582f, -0.01034156f, 
    -0.06949737f, -0.01559289f, -0.01428951f, -0.11109324f, -0.05104832f, -0.15499704f, -0.10040192f, -0.05814891f, 
    0.09959871f, -0.22346207f, 0.03847788f, -0.02599735f, 0.11969778f, 0.27204102f, -0.26806754f, -0.14386275f, 
    0.08660880f, 0.20816210f, 0.12568355f, 0.00260678f, -0.01973926f, -0.07213093f, 0.10730620f, 0.03396118f, 
    0.12285943f, 0.05171449f, 0.03167552f, 0.07441836f, -0.10551861f, 0.01886205f, -0.03223652f, -0.10303080f, 
    0.01559753f, 0.00491397f, 0.19317536f, -0.00985984f, 0.00104774f, 0.18509161f, 0.12663975f, 0.14450786f, 
    -0.24583225f, -0.07130413f, -0.05396701f, -0.02620489f, 0.20376147f, -0.05750035f, 0.00993644f, -0.13232300f, 
    -0.21859449f, 0.10210795f, -0.13633078f, 0.18396974f, 0.23519465f, 0.14307630f, 0.11870366f, -0.18310754f, 
    -0.01934652f, 0.35196909f, -0.12162553f, 0.10018735f, 0.00088598f, 0.06603371f, 0.20174910f, 0.01793143f, 
    0.12254259f, 0.14744677f, 0.10158337f, -0.14831069f, -0.03442064f, 0.07446294f, -0.01536508f, 0.69772285f, 
    -0.21433432f, -0.17592578f, -0.05422585f, -0.01132978f, 0.14683682f, -0.19268259f, -0.00350764f, 0.29562128f, 
    0.01535394f, -0.11346976f, 0.26249379f, -0.03888689f, 0.15277217f, -0.10610782f, -0.01216204f, -0.12740722f, 
    -0.07256789f, 0.01983202f, 0.03791216f, 0.12591378f, -0.00110015f, 0.00161177f, -0.08584142f, 0.17335111f, 
    0.15001094f, -0.12287930f, -0.08362131f, -0.17043832f, -0.08272115f, -0.08620636f, 0.07021540f, 0.00825095f, 
    0.17566611f, 0.02329662f, -0.01508748f, -0.04858758f, 0.16472246f, 0.19188051f, -0.04174747f, 0.36883149f, 
    -0.07594702f, -0.04818888f, -0.00584794f, -0.13068126f, 0.24270281f, 0.10087253f, -0.20430481f, -0.29845148f, 
    0.60249209f, 0.42506048f, -0.08003200f, 0.11670379f, -0.01698187f, 0.06668954f, 0.14521877f, -0.04850481f, 
    0.02582993f, -0.12977229f, -0.05950424f, 0.04582092f, -0.08103888f, 0.16431731f, 0.14229043f, 0.04558573f, 
    -0.05443243f, 0.02149161f, -0.03715289f, -0.02969076f, -0.07736285f, 0.00724529f, -0.08386831f, -0.06275688f, 
    -0.10294215f, -0.00236144f, -0.01487945f, 0.06272779f, -0.10282119f, -0.08759949f, -0.10828262f, 0.06499407f, 
    0.02819941f, 0.05023130f, -0.03126080f, -0.06840938f, -0.04563726f, 0.07896453f, -0.00600662f, 0.04667170f, 
    0.02210739f, -0.09891225f, -0.01867029f, 0.00121706f, -0.08843052f, -0.07899012f, 0.03440347f, -0.08567394f, 
    -0.10592230f, -0.07119890f, 0.03459076f, -0.04872424f, -0.06689718f, 0.06144395f, -0.04049197f, 0.06129450f, 
    -0.04216623f, 0.03497084f, 0.00342966f, 0.04864956f, -0.03030023f, -0.06479846f, -0.10190544f, -0.01822441f, 
    -0.05525031f, -0.10569415f, -0.12974350f, 0.03318324f, -0.06820089f, 0.04087003f, -0.07410178f, -0.07751641f, 
    0.00292704f, -0.03037322f, 0.07907379f, 0.01413787f, 0.01610935f, 0.01280654f, 0.07399075f, 0.00667131f, 
    -0.09361141f, 0.05641593f, 0.02877179f, -0.08786497f, 0.00424426f, 0.01253401f, -0.10638504f, -0.00712304f, 
    0.00736090f, -0.02011787f, 0.01973132f, -0.06928706f, -0.06109209f, -0.12550403f, 0.04135025f, 0.02270246f, 
    0.04993967f, 0.05232817f, 0.02889785f, 0.05333989f, -0.14270575f, -0.05720529f, -0.12083105f, 0.02681626f, 
    -0.00378404f, 0.05027270f, -0.13399678f, 0.04111997f, 0.03789500f, -0.07239349f, -0.05658405f, -0.05599615f, 
    0.04493679f, 0.05631819f, -0.00970781f, -0.03879849f, 0.04592027f, 0.00561466f, -0.04452728f, 0.04111454f, 
    -0.09808418f, -0.00011505f, -0.05643528f, 0.01449116f, -0.00466475f, 0.01086117f, 0.01498147f, 0.02555696f, 
    -0.07431521f, -0.02458880f, 0.00890436f, 0.05796712f, -0.08928310f, -0.12358132f, -0.01243045f, -0.09078988f, 
    0.02775585f, 0.03378373f, -0.00467759f, -0.04628547f, -0.06698933f, -0.03256926f, -0.08574998f, -0.01159345f, 
    0.17473131f, -0.53639203f, -0.08464254f, -0.05626269f, 0.02400986f, 0.21806429f, -0.54720759f, 0.18437749f, 
    -0.52936924f, 0.13689865f, 0.05544202f, 0.23305766f, 0.20901939f, 0.04418570f, 0.11689122f, -0.10363723f, 
    0.16512844f, -0.01686149f, 0.15397489f, 0.16028100f, -0.46931946f, 0.01637801f, 0.10541994f, 0.13083737f, 
    -0.08425509f, -0.03867348f, 0.14175230f, -0.09768217f, 0.17064025f, 0.02574292f, 0.10001390f, -0.29031280f, 
    -0.28989151f, 0.07339853f, 0.23479994f, -0.12206040f, 0.10329046f, -0.08671731f, -0.40117368f, 0.33578756f, 
    0.05344881f, 0.27173936f, -0.06582621f, -0.03076944f, -0.00570126f, 0.14926054f, 0.00897432f, -0.10748974f, 
    -0.12688795f, -0.52243453f, 0.14637497f, 0.17642841f, -0.05950810f, -0.24850707f, 0.26160502f, 0.04030329f, 
    0.27008373f, -0.37489143f, -0.57871801f, 0.04433845f, -0.04570556f, 0.14826888f, -0.02552009f, -0.01349873f, 
    -0.11302786f, -0.04412571f, -0.07919477f, 0.12052754f, 0.01119217f, -0.19575095f, -0.49741983f, 0.43544114f, 
    0.34722456f, 0.00151034f, -0.24007627f, -0.05819927f, -0.00502426f, -0.13508467f, 0.04636044f, 0.28986219f, 
    0.26518628f, 0.08350921f, 0.10320221f, -0.43581450f, 0.09735333f, 0.08524073f, 0.00405167f, -0.17246015f, 
    0.27683198f, -0.03759449f, -0.09937145f, 0.04623513f, -0.33275661f, 0.00774391f, 0.05635938f, -0.17718378f, 
    0.28000641f, 0.03602799f, 0.09384764f, -0.10964829f, 0.16376123f, 0.38621753f, 0.19811627f, 0.64963228f, 
    0.20578541f, 0.28290004f, -0.00479574f, 0.27805626f, -0.14533797f, 0.02280585f, 0.11524681f, -0.31905019f, 
    -0.48757970f, -0.37408358f, 0.14153132f, 0.14767060f, 0.07777836f, 0.00662122f, 0.15598927f, 0.14313293f, 
    -0.09102619f, -0.34083924f, 0.04837528f, -0.11196359f, -0.28230184f, -0.52397603f, 0.28775242f, 0.01843334f, 
    0.09970148f, -0.12384514f, -0.04170790f, -0.00944570f, 0.27125210f, 0.14753161f, -0.13993171f, 0.11990471f, 
    -0.12373094f, 0.04147732f, 0.10491201f, 0.18750261f, 0.09497160f, 0.36400014f, 0.01278986f, -0.20983508f, 
    -0.03230512f, -0.05397018f, 0.14441834f, -0.01341405f, 0.33090442f, -0.00496231f, 0.07809628f, -0.05340857f, 
    0.26371256f, 0.03722403f, 0.15614232f, 0.09598470f, 0.00602580f, 0.10747392f, 0.11669207f, -0.31943518f, 
    -0.34512016f, 0.13019437f, -0.02872510f, 0.26797074f, -0.04534518f, 0.05078259f, -0.24027416f, 0.43018556f, 
    0.02024437f, 0.16779332f, -0.33524632f, -0.04197126f, 0.68014222f, 0.02031111f, -0.16832095f, -0.17001730f, 
    0.02861140f, -0.21652886f, 0.18787761f, -0.13732387f, -0.44102842f, -0.04681240f, 0.01813288f, 0.09630977f, 
    0.01252892f, 0.03239732f, -0.22528315f, -0.02331412f, 0.24894655f, -0.16427593f, -0.13267720f, 0.29519844f, 
    -0.00879858f, -0.05343425f, -0.00228894f, 0.11065388f, 0.08024124f, -0.04593711f, -0.49688062f, 0.46843356f, 
    0.16792409f, 0.03466872f, -0.35714576f, 0.11960264f, -0.15054134f, -0.08179621f, 0.06244325f, 0.06237170f, 
    0.34332156f, -0.05965906f, -0.17171641f, -0.36039191f, -0.04807745f, 0.42504856f, 0.10898034f, -0.31915033f, 
    0.03819609f, -0.06399880f, 0.14372358f, 0.02893172f, -0.01425531f, -0.01986640f, 0.01136707f, 0.12600803f, 
    -0.09070310f, 0.18812683f, 0.16373573f, 0.00278389f, -0.05647105f, 0.35327777f, -0.05966629f, 0.06913716f, 
    -0.01064817f, 0.23863274f, 0.11240854f, 0.23233281f, 0.18083365f, 0.18261380f, 0.03593455f, -0.37834448f, 
    -0.03686054f, -0.17625289f, 0.11415023f, -0.00929371f, -0.07617167f, 0.07804552f, -0.03227096f, 0.37207085f, 
    0.00102677f, -0.10833830f, 0.03541288f, -0.27027345f, -0.13446356f, -0.27378100f, 0.19440152f, 0.10571402f, 
    0.01912722f, -0.08286217f, 0.04143514f, 0.06690874f, -0.05818068f, 0.00511355f, 0.06238158f, -0.01877733f, 
    0.04047988f, -0.04826760f, -0.10312510f, -0.03626386f, -0.03643163f, 0.03924516f, 0.05160156f, -0.03817320f, 
    -0.00907773f, -0.01030309f, 0.04652987f, -0.07038595f, 0.02881860f, 0.01410005f, -0.04088190f, -0.01778958f, 
    0.04555383f, 0.02651107f, -0.01194381f, -0.06398371f, 0.00678417f, 0.05850554f, 0.01200432f, 0.03464177f, 
    -0.06016835f, -0.06647032f, 0.05669819f, -0.06383187f, -0.09817330f, -0.00153387f, -0.00507392f, 0.00075766f, 
    0.02025161f, 0.03811438f, 0.05744066f, 0.03293002f, 0.04864243f, -0.09145091f, 0.03170068f, 0.05258968f, 
    0.01135167f, 0.02186702f, 0.01382516f, 0.02359939f, -0.02066098f, -0.03158033f, 0.08707681f, -0.05085132f, 
    0.04170130f, 0.05975235f, -0.05082987f, -0.00191246f, -0.01864964f, -0.05094018f, 0.00075700f, -0.00122260f, 
    -0.00400873f, 0.05360686f, 0.00187631f, -0.07690797f, 0.06243417f, -0.03343244f, -0.04774934f, 0.03061213f, 
    -0.11308751f, -0.08281757f, -0.04950558f, 0.01861147f, 0.00681196f, -0.05893414f, -0.03867188f, 0.04235429f, 
    -0.04725105f, 0.03884235f, -0.01283184f, -0.06451222f, 0.03468402f, 0.03342987f, -0.05504089f, 0.01304843f, 
    0.03229862f, -0.05262848f, -0.09152819f, -0.04479010f, 0.03480700f, 0.06841620f, -0.04059651f, -0.02921829f, 
    0.03941178f, -0.08661298f, 0.05839806f, -0.06213452f, 0.03025198f, 0.05336674f, -0.00317428f, 0.03489975f, 
    -0.00681337f, 0.00820806f, -0.05381007f, 0.01875250f, 0.06778046f, -0.05895965f, -0.03901270f, -0.07565058f, 
    -0.00155406f, -0.01950506f, -0.05965624f, -0.05032429f, -0.05631441f, 0.02117903f, -0.00351861f, -0.09123789f, 
    -0.05773453f, -0.03717504f, -0.04548079f, -0.04682108f, -0.07594194f, 0.01457259f, -0.05851114f, -0.04223407f, 
    -0.03760526f, 0.01872334f, 0.03234559f, 0.04886132f, -0.00138429f, -0.04066262f, 0.05302824f, -0.06728248f, 
    -0.09667715f, -0.02973439f, -0.04897271f, -0.10675156f, 0.03575262f, -0.00442990f, -0.04875335f, -0.10621900f, 
    -0.05566233f, 0.01350635f, 0.06193526f, -0.02616010f, -0.00863427f, -0.03669326f, 0.06439481f, -0.05191667f, 
    -0.04470509f, 0.05868284f, -0.00280836f, 0.01493312f, 0.02324616f, -0.03850964f, 0.01979606f, -0.07307763f, 
    -0.01849982f, 0.00596453f, -0.08714510f, -0.04819320f, -0.06562042f, -0.06488518f, -0.00308106f, 0.02869173f, 
    -0.04650681f, -0.06334107f, -0.06759515f, -0.00741925f, 0.00724804f, 0.01131895f, 0.00523678f, -0.06931647f, 
    0.02438433f, -0.00269061f, 0.02576334f, 0.06813731f, 0.07620181f, 0.03856423f, -0.03217668f, -0.04562688f, 
    -0.05738728f, -0.09300181f, -0.09451342f, -0.08747979f, -0.01247255f, -0.06892431f, 0.03077886f, -0.00390533f, 
    0.03747442f, 0.07000233f, 0.08098733f, -0.10082914f, -0.08629780f, 0.00194376f, -0.06073504f, -0.02763449f, 
    -0.04961884f, 0.01101689f, 0.04656960f, 0.02741589f, 0.07834826f, -0.12946491f, -0.04381761f, -0.00860743f, 
    -0.02104427f, -0.08406408f, 0.02039084f, -0.03071890f, -0.11298123f, -0.03544847f, -0.08756845f, -0.06878370f, 
    -0.08178905f, -0.07443667f, -0.04220811f, 0.01898856f, 0.04737815f, 0.01391929f, 0.02671610f, -0.01182843f, 
    -0.08913171f, -0.10093094f, -0.07625204f, 0.05224721f, -0.09910892f, 0.02825726f, -0.09176790f, 0.00813801f, 
    -0.05015758f, -0.02968803f, -0.07134779f, 0.00993398f, -0.04291233f, -0.06720937f, -0.00293872f, 0.00631940f, 
    -0.06873463f, 0.00728064f, 0.04631439f, 0.03181947f, 0.01591916f, 0.02601232f, -0.04265744f, -0.11364019f, 
    -0.02486928f, 0.01061356f, 0.02501800f, -0.07072738f, -0.07726443f, -0.14187063f, -0.06677758f, -0.10966633f, 
    0.19976082f, -0.06220262f, -0.04808695f, -0.07339019f, 0.10720190f, -0.08977114f, -0.29229760f, 0.03989761f, 
    -0.35574782f, -0.11464557f, 0.00639232f, 0.01380380f, 0.32968462f, 0.09379430f, 0.06432405f, -0.00988771f, 
    0.09491764f, -0.06043387f, 0.06323126f, -0.01580589f, -0.10760409f, 0.08281038f, 0.15844181f, -0.06238203f, 
    -0.15760943f, -0.06291617f, 0.02282302f, -0.06642757f, -0.01319957f, 0.09999349f, 0.16627672f, -0.00738338f, 
    0.16287130f, -0.01373030f, 0.06571440f, -0.04807475f, 0.10391917f, -0.05879400f, -0.23313315f, 0.10007890f, 
    0.10961116f, -0.01089508f, -0.13887230f, -0.01748516f, -0.21133436f, 0.03288670f, 0.33421811f, -0.02650690f, 
    -0.07898973f, -0.15964107f, 0.15374799f, 0.24294102f, -0.17033704f, -0.19895943f, -0.02618691f, 0.08116099f, 
    0.26374865f, -0.34112504f, -0.06302440f, 0.06842480f, -0.03687912f, 0.36491719f, 0.22811155f, -0.35298243f, 
    0.01568071f, 0.31366441f, -0.02631814f, 0.19184053f, 0.03853464f, 0.11685050f, -0.23294115f, -0.02774851f, 
    0.22505660f, -0.04337316f, -0.20625228f, 0.22077885f, -0.01823397f, -0.03539233f, 0.15827803f, 0.41161039f, 
    0.08274151f, 0.07725035f, 0.18816523f, -0.14799908f, -0.01758119f, 0.08215857f, 0.17120126f, -0.18881184f, 
    -0.10899530f, 0.09098692f, -0.12138430f, 0.08831046f, -0.01342643f, 0.05800636f, -0.03036423f, -0.06984577f, 
    -0.02906055f, -0.10483497f, 0.20095891f, -0.03308923f, 0.27912390f, 0.15108587f, 0.33603317f, 0.24801247f, 
    -0.30381125f, 0.25752217f, 0.04705913f, 0.12389553f, -0.20620945f, 0.07967386f, 0.13128486f, 0.09188880f, 
    -1.00910258f, -0.34145993f, -0.05132532f, 0.10491413f, -0.03264209f, 0.18068524f, 0.11961120f, 0.02079651f, 
    -0.04725751f, 0.20988867f, 0.00909575f, -0.41114789f, -0.19320664f, -0.26788840f, 0.13517009f, -0.08073174f, 
    -0.09369899f, 0.09711259f, 0.08028933f, 0.06163704f, 0.20059332f, 0.10140964f, 0.07016138f, -0.01410911f, 
    -0.12850045f, -0.09293035f, 0.04460479f, 0.27255282f, 0.04442668f, 0.24935310f, -0.00106418f, -0.22905111f, 
    0.11801719f, -0.03638786f, -0.04331854f, 0.16450454f, 0.03364547f, -0.08459622f, 0.08120065f, 0.23448232f, 
    0.12750913f, -0.07470424f, -0.00847793f, 0.19978605f, -0.09324590f, 0.09111089f, -0.17009220f, -0.16189975f, 
    0.20471773f, 0.26693115f, -0.04652416f, 0.13975264f, -0.01454462f, 0.04811183f, -0.11859668f, 0.31243023f, 
    -0.03696898f, 0.25087678f, -0.18769696f, 0.10595376f, 0.64983433f, 0.12593450f, -0.15064304f, -0.12510744f, 
    0.06201117f, -0.01429588f, -0.01508688f, -0.09228050f, -0.14006726f, -0.27914840f, -0.10649018f, -0.02301963f, 
    0.00619053f, 0.00688138f, -0.31093568f, 0.17873895f, 0.02281182f, -0.37148783f, 0.01402941f, -0.30914488f, 
    0.00803638f, 0.08906550f, 0.06667648f, 0.07194274f, -0.03185951f, 0.18466581f, -0.05784271f, 0.26137611f, 
    0.07146341f, 0.02039042f, -0.28929403f, 0.12409458f, -0.34895742f, 0.09509229f, 0.06803163f, 0.15417704f, 
    0.20322590f, -0.06714873f, 0.00120605f, -0.42088917f, -0.01713138f, 0.42127725f, 0.33379227f, -0.39870796f, 
    0.09574144f, -0.10949241f, 0.00864091f, 0.09932452f, 0.14199898f, 0.00859941f, -0.05936582f, 0.02581792f, 
    -0.14382128f, 0.24373235f, 0.08468904f, -0.03554942f, 0.01094754f, 0.17053746f, 0.09598968f, -0.01814546f, 
    -0.08447739f, 0.17752743f, 0.03082643f, 0.28103521f, 0.01498558f, 0.00729813f, 0.07063515f, 0.00259584f, 
    0.17160471f, -0.03011232f, 0.07830558f, 0.08182722f, -0.00693671f, 0.06427274f, -0.00302354f, 0.46625388f, 
    -0.02102802f, 0.08882828f, -0.11128645f, 0.00217246f, -0.03655393f, -0.35191876f, 0.11866762f, 0.00951860f, 
    -0.16382384f, 0.21159093f, -0.30442649f, 0.04407830f, -0.21577483f, -0.01087043f, 0.03407763f, 0.24416247f, 
    -0.19561730f, -0.14607701f, 0.02896561f, -0.59856445f, 0.14943120f, -0.06746797f, -0.00894387f, 0.13641460f, 
    -0.17303807f, 0.04623437f, 0.00133909f, -0.17573979f, 0.07204028f, -0.03251079f, 0.24851418f, -0.05007759f, 
    -0.06390241f, -0.06542696f, -0.10352093f, 0.07075598f, 0.00296381f, -0.32240725f, -0.12372153f, -0.00651235f, 
    0.04996208f, 0.11830460f, 0.18362918f, -0.12703989f, -0.24127664f, -0.06507695f, -0.13331334f, 0.03209018f, 
    0.23822276f, -0.07014444f, 0.09395950f, -0.06272060f, -0.26872745f, -0.06987742f, -0.01636804f, 0.48174343f, 
    -0.01866535f, 0.09573640f, 0.20556174f, -0.10785622f, -0.15889180f, 0.14136912f, 0.13661380f, 0.07650573f, 
    0.15008777f, 0.03706453f, 0.07691395f, 0.16030794f, -0.24564429f, 0.42246008f, 0.08595309f, -0.46395063f, 
    0.14564472f, 0.15420239f, 0.00296062f, 0.16130863f, 0.06094303f, 0.09752585f, -0.15609786f, 0.13094500f, 
    0.09736669f, -0.05775879f, -0.02557548f, -0.20103107f, 0.23953280f, 0.22304949f, 0.12678732f, 0.14378706f, 
    0.03321080f, -0.08267128f, -0.00580684f, 0.12795064f, 0.03785946f, -0.07940910f, 0.11516337f, 0.03721321f, 
    -0.41022697f, 0.30003318f, -0.05108408f, 0.10251961f, -0.09061133f, -0.02952781f, -0.03209161f, -0.10981222f, 
    -0.08211041f, -0.07225708f, 0.15527411f, -0.01264386f, -0.48717543f, -0.20885931f, -0.03155695f, 0.40212494f, 
    0.05619493f, -0.02509671f, -0.04442656f, -0.14598902f, -0.10214897f, 0.02558047f, 0.13973010f, 0.29872170f, 
    -0.52891833f, -0.01537150f, 0.00804664f, -0.22899953f, -0.11055846f, 0.11508997f, -0.04538319f, -0.09373891f, 
    0.09995438f, 0.21481700f, 0.39745164f, -0.36513567f, -0.23668227f, 0.05883567f, 0.08847496f, 0.04610090f, 
    0.11442987f, 0.00015561f, -0.00073118f, 0.01119166f, 0.04926471f, 0.10853548f, -0.19356039f, -0.11571717f, 
    -0.17367718f, 0.01973964f, 0.05763937f, 0.14915165f, 0.18531024f, 0.35232806f, 0.09985452f, -0.09322603f, 
    0.02425063f, 0.02073071f, 0.13388507f, 0.14784642f, -0.25519374f, 0.02788791f, 0.03771322f, 0.04730714f, 
    0.01245013f, -0.08671019f, 0.02705838f, -0.03264569f, 0.03074351f, -0.00604754f, -0.09233950f, -0.27433714f, 
    0.29698828f, 0.11900077f, 0.13892686f, -0.04255979f, 0.03390399f, -0.10935024f, -0.18037620f, 0.29043385f, 
    0.07056477f, 0.06879316f, 0.16276424f, -0.02205935f, 0.18349703f, 0.16144305f, 0.00428155f, 0.03409133f, 
    -0.12300012f, 0.05415051f, 0.10465366f, 0.10662623f, 0.02989355f, 0.02074523f, 0.08428100f, -0.00470146f, 
    0.20190942f, -0.21042651f, -0.22305506f, 0.05331509f, 0.01291261f, -0.04127835f, -0.06772342f, -0.39183223f, 
    -0.02999019f, 0.29582217f, 0.00024165f, 0.10607483f, -0.07046608f, 0.12776119f, 0.20574117f, 0.22666134f, 
    0.38195434f, -0.05960157f, -0.45381820f, 0.18301331f, -0.34992111f, -0.29876477f, 0.20534797f, 0.34958363f, 
    0.32122567f, 0.08730078f, 0.11824664f, 0.14250802f, 0.11996305f, 0.38864577f, 0.38352159f, -0.20157954f, 
    0.18565792f, -0.08658601f, -0.03531471f, 0.09824027f, 0.07935156f, 0.06585962f, -0.07972550f, -0.31642434f, 
    0.13722251f, 0.06616600f, 0.13136728f, -0.15481457f, 0.28824782f, 0.17575085f, 0.27156815f, 0.29999861f, 
    -0.12764357f, 0.19629075f, -0.00085047f, 0.47847664f, -0.25305355f, 0.01700144f, 0.08904301f, 0.02860799f, 
    -0.17368916f, -0.21686263f, 0.03660003f, 0.03508154f, -0.13994361f, 0.14887606f, -0.05093339f, 0.36592349f, 
    -0.08862171f, 0.13219677f, -0.09977259f, 0.00428517f, -0.12592858f, -0.49790516f, 0.14159016f, -0.16819029f, 
    -0.05189494f, -0.05707877f, 0.03892897f, -0.05059055f, -0.00295032f, 0.06819762f, -0.02873551f, 0.06408589f, 
    -0.06210890f, -0.00565271f, -0.07282154f, -0.05893749f, -0.01782020f, -0.03699171f, 0.01255982f, -0.00634567f, 
    0.03412001f, 0.05507129f, 0.00269804f, 0.04430377f, -0.02762887f, -0.02552441f, 0.02564726f, 0.06141791f, 
    -0.03802666f, -0.05936791f, 0.00298918f, 0.05279687f, 0.03530880f, -0.01255239f, -0.10074196f, -0.10450505f, 
    0.03755752f, 0.02465359f, -0.05925782f, -0.10707243f, -0.09023193f, -0.06917428f, 0.03042001f, -0.08259492f, 
    -0.08738237f, 0.02739643f, -0.06101474f, -0.10426824f, -0.03342808f, 0.07499759f, -0.09653185f, 0.04870337f, 
    -0.07910237f, 0.00685227f, 0.00372203f, -0.02823700f, 0.03331268f, -0.07828449f, -0.00376395f, -0.04810128f, 
    0.04432107f, -0.07935035f, 0.02670092f, -0.00269601f, 0.02114603f, -0.02342225f, 0.03003667f, -0.07774486f, 
    -0.01718002f, -0.06051607f, 0.08650121f, 0.01508192f, -0.10666642f, -0.06542488f, -0.01192920f, -0.08588958f, 
    -0.02510386f, -0.05396368f, -0.03401754f, -0.05841048f, -0.08727778f, 0.05684103f, 0.02320563f, -0.03442938f, 
    -0.03733236f, -0.06366193f, -0.06141484f, 0.05598019f, -0.09722344f, 0.05402998f, 0.05384133f, 0.02455520f, 
    0.06042372f, -0.06066094f, -0.04418825f, 0.02667913f, -0.04092090f, -0.03697143f, 0.08609108f, 0.04583118f, 
    0.00961444f, 0.02299690f, 0.05147343f, 0.03031718f, -0.04699077f, -0.09527096f, 0.00230750f, -0.07179309f, 
    0.05496897f, -0.05249504f, 0.02293555f, -0.08598630f, -0.00412046f, -0.05765272f, -0.00382866f, -0.07383370f, 
    -0.06129984f, -0.02967088f, -0.09782851f, 0.05928447f, -0.07813982f, -0.06506255f, -0.07547438f, -0.07777944f, 
    -0.06146840f, -0.08491259f, 0.05194240f, -0.04445237f, -0.00492897f, 0.02049163f, -0.08522633f, 0.04881674f, 
    -0.05613749f, -0.08145714f, -0.07758333f, 0.02645590f, -0.08254768f, 0.00053430f, -0.05975799f, -0.05327910f, 
    -0.09493381f, 0.06130774f, -0.09831856f, -0.07586297f, -0.01560151f, -0.02281119f, 0.00330423f, -0.04334751f, 
    0.02098893f, 0.04949762f, -0.10323504f, -0.05024483f, -0.04005915f, 0.04736238f, 0.02426718f, -0.07143641f, 
    -0.10791942f, -0.06533837f, 0.00451444f, -0.07736070f, -0.04769659f, -0.01156902f, 0.00369986f, 0.05280155f, 
    0.01632418f, -0.01153988f, 0.06345792f, 0.00862825f, -0.10253751f, 0.03550832f, -0.06076147f, 0.02911173f, 
    0.03151506f, 0.06208549f, 0.01699181f, -0.04108459f, 0.01922302f, -0.06050363f, 0.06290650f, 0.05626410f, 
    0.02721617f, 0.00877760f, -0.06271290f, -0.00557526f, 0.05289427f, -0.01014464f, 0.01679103f, -0.09205942f, 
    0.05644529f, -0.05733410f, -0.08292761f, 0.04713809f, 0.05117121f, -0.02876450f, -0.01369400f, -0.01967012f, 
    -0.08523017f, 0.00213383f, -0.08334190f, 0.00185387f, -0.02834858f, -0.01270607f, -0.06338261f, 0.01697572f, 
    -0.08109441f, 0.02027199f, -0.10372816f, -0.03642439f, 0.06665601f, 0.04548490f, -0.10535678f, -0.11099023f, 
    -0.02413027f, -0.02697020f, -0.08819955f, -0.05518033f, 0.00066438f, 0.01990511f, -0.02986938f, -0.05827259f, 
    -0.01374920f, -0.03756125f, -0.02313279f, -0.02937268f, -0.07388979f, 0.03705549f, -0.05816941f, -0.04770572f, 
    -0.08421253f, -0.00846258f, 0.02500134f, -0.02251166f, -0.04386112f, -0.00240597f, -0.04591037f, -0.02326379f, 
    -0.05508021f, -0.00450718f, 0.03965729f, -0.10767245f, 0.00410310f, -0.07955733f, -0.10280072f, 0.02520984f, 
    0.07457019f, -0.00403510f, 0.02093176f, -0.05190774f, -0.08337292f, -0.11051458f, 0.02104812f, -0.08129629f, 
    0.04658444f, 0.04115202f, 0.01061843f, -0.02311477f, 0.06247979f, -0.06392574f, 0.00256171f, 0.03946409f, 
    -0.08556281f, -0.00205500f, 0.06025366f, 0.03810882f, -0.24524780f, 0.07267512f, 0.10530639f, 0.03137878f, 
    -0.09536858f, 0.14519013f, 0.02571266f, 0.08085699f, -0.14925997f, 0.26647550f, 0.12286495f, -0.10095397f, 
    -0.00405214f, -0.01205143f, -0.23497693f, -0.12556139f, 0.34375075f, 0.03922570f, -0.03270000f, 0.28374189f, 
    0.22575839f, -0.17390320f, 0.03434277f, 0.21462227f, -0.15284510f, -0.05448025f, -0.35960031f, -0.14240681f, 
    0.28676343f, 0.18019927f, 0.10560394f, 0.10634921f, -0.12777825f, 0.11536112f, -0.01505393f, -0.00992778f, 
    -0.05802956f, 0.48794618f, -0.57978868f, 0.21112747f, 0.54915953f, -0.05843787f, -0.25834233f, 0.03267606f, 
    0.13439144f, 0.12218898f, 0.07031597f, 0.18887362f, 0.12671143f, -0.17368138f, 0.10880827f, 0.01194196f, 
    -0.16762476f, 0.09878481f, -0.06586771f, 0.36446542f, -0.04488252f, -0.33120072f, -0.02259581f, -0.22868313f, 
    -0.09941989f, 0.09231791f, -0.08982264f, 0.05950740f, -0.40570801f, 0.22364783f, 0.03932266f, 0.29031634f, 
    -0.20850168f, 0.18175821f, -0.02981133f, -0.01449424f, -0.23788196f, 0.05822565f, 0.09380389f, -0.39229327f, 
    0.13090704f, 0.02570603f, 0.01558421f, -0.21689105f, 0.06185506f, 0.38280943f, 0.41901243f, -0.13244461f, 
    -0.12661266f, -0.09604501f, -0.20909341f, 0.00708007f, 0.25863931f, -0.06469162f, -0.08480579f, -0.10138410f, 
    -0.00093151f, 0.26555657f, 0.21387720f, 0.16789530f, -0.12453330f, 0.12518726f, -0.11305729f, 0.35326925f, 
    -0.14231098f, 0.01498161f, 0.08168627f, 0.02629061f, -0.36372915f, -0.02102996f, -0.03725094f, 0.32917374f, 
    -0.14597221f, 0.66453588f, 0.06095470f, -0.25507328f, -0.16478969f, 0.04432456f, -0.13748007f, 0.24400628f, 
    0.19991237f, 0.13669738f, 0.09269492f, -0.12707509f, 0.10279641f, -0.46795443f, 0.13785110f, -0.15457296f, 
    0.02618149f, 0.27313739f, 0.00492773f, 0.02154282f, -0.26678038f, -0.26642466f, 0.05732920f, 0.04685933f, 
    -0.11359760f, -0.06751640f, -0.20491545f, -0.30601174f, 0.04657033f, 0.16342525f, 0.06721768f, 0.05164990f, 
    0.14157744f, -0.03946232f, 0.01028504f, 0.00179340f, 0.55564040f, -0.04243398f, 0.06562601f, 0.05430280f, 
    0.08492625f, 0.09705932f, -0.09950918f, 0.25172600f, -0.06219952f, -0.17611997f, -0.12192101f, 0.19313824f, 
    0.20754258f, 0.00064024f, 0.03565599f, 0.18677580f, 0.00879388f, 0.00012696f, -0.12235985f, -0.45921010f, 
    -0.10708480f, -0.39602596f, 0.11395845f, -0.04320413f, 0.21670789f, -0.05567195f, -0.02274275f, 0.03633310f, 
    0.16325296f, -0.16292426f, 0.03313691f, 0.06195823f, -0.27951211f, 0.12125886f, 0.24277084f, 0.03320273f, 
    0.09287325f, 0.05064985f, 0.03209893f, 0.16990672f, 0.17751411f, 0.08485845f, 0.10716747f, -0.29892802f, 
    -0.01487753f, -0.02822977f, -0.00349584f, 0.04345275f, -0.02739709f, 0.18195842f, -0.28171965f, 0.34614354f, 
    -0.08541026f, 0.12145972f, -0.23772074f, -0.05212995f, 0.68095231f, 0.18635388f, 0.08641654f, 0.00068345f, 
    0.17059851f, 0.03882289f, -0.08872645f, -0.10269060f, -0.16067401f, 0.14064440f, 0.05653394f, 0.14626348f, 
    -0.22646032f, -0.00444968f, -0.06139865f, -0.11612678f, 0.20757647f, 0.06293914f, -0.00415276f, 0.12915514f, 
    -0.06030208f, 0.13179523f, 0.06443648f, 0.16221030f, 0.06935305f, -0.17466699f, -0.17570579f, 0.23282127f, 
    -0.05262510f, 0.00636337f, -0.00553085f, -0.08329021f, -0.16661647f, -0.07474902f, -0.11922497f, 0.06897420f, 
    -0.61741126f, -0.08011629f, -0.29981375f, 0.19354245f, -0.02050219f, 0.11733820f, 0.08814000f, 0.03694804f, 
    0.12380376f, -0.04798284f, 0.11989298f, 0.04666889f, 0.10823656f, -0.08429414f, -0.19253042f, 0.13604124f, 
    -0.27214405f, 0.05692283f, 0.03253995f, -0.05027295f, -0.24333341f, 0.02962100f, 0.24281088f, 0.08749092f, 
    0.20390703f, -0.05440508f, -0.06482176f, 0.10174115f, -0.07338327f, -0.16210666f, -0.03952516f, 0.41514978f, 
    0.26206470f, 0.08057416f, -0.17563672f, -0.39606792f, 0.26390865f, 0.02531841f, 0.16915436f, -0.24726075f, 
    0.12036387f, 0.30601290f, -0.00582524f, 0.32182470f, -0.00852434f, 0.20662551f, -0.13912287f, 0.21199463f, 
    -0.13457546f, -0.21607368f, -0.20132747f, -0.13234471f, -0.04318263f, 0.09602379f, 0.12051738f, -0.04016438f, 
    -0.05581059f, 0.25997424f, -0.86064380f, 0.21638353f, -0.50201738f, -0.17764872f, -0.22567993f, 0.10107601f, 
    0.14763184f, 0.29270515f, 0.05447974f, 0.02684963f, 0.01154393f, 0.12116481f, 0.30957037f, 0.17454199f, 
    -0.05536033f, 0.18929499f, 0.58259201f, 0.13807739f, -0.05330710f, 0.00590269f, 0.31499293f, 0.52587998f, 
    0.22431047f, -0.04586154f, 0.07365655f, 0.09015794f, -0.02497383f, -0.03543289f, -0.16969799f, 0.31389204f, 
    -0.25921038f, 0.31157854f, 0.14286648f, -0.10616104f, 0.41049692f, -0.10427921f, 0.18639936f, -0.56427264f, 
    -0.27300343f, -0.06813029f, -0.15622738f, 0.51127243f, 0.16633496f, -0.13181679f, 0.14919513f, 0.37475201f, 
    -0.28959134f, 0.06797811f, -0.40083548f, -0.13958749f, 0.29147118f, -0.00892719f, 0.04347507f, 0.16261891f, 
    -0.03645745f, 0.03848832f, -0.13413127f, 0.12383805f, -0.46145049f, -0.51542503f, 0.04405124f, 0.35916224f, 
    -0.04524176f, -0.46657512f, -0.07848153f, -0.22964574f, 0.27030754f, -0.09238449f, 0.07407383f, -0.01058371f, 
    -0.15217482f, 0.33972368f, -0.09646702f, 0.01234601f, 0.19877794f, -0.03609466f, 0.12269343f, -0.34022474f, 
    0.54056239f, 0.27359384f, 0.14113414f, -0.33023936f, -0.04656555f, 0.63275689f, -0.12069936f, 0.33495766f, 
    0.21945280f, -0.15741259f, 0.10463567f, -0.01497699f, -0.07123594f, 0.40690559f, 0.10685465f, -0.24406394f, 
    0.19286570f, 0.13414928f, 0.14214374f, -0.07234685f, -0.06837025f, -0.28982338f, 0.14263333f, 0.11365095f, 
    -0.19466726f, 0.02941224f, 0.17796333f, 0.13581948f, -0.01345496f, 0.08570053f, 0.02976538f, -0.20297319f, 
    -0.13849768f, -0.09280104f, -0.06084862f, 0.08347061f, 0.14374031f, -0.05656524f, 0.28219476f, -0.01588474f, 
    -0.19685830f, -0.21212749f, -0.05489165f, -0.09039652f, 0.09957327f, 0.06252736f, 0.48181871f, -0.21040565f, 
    -0.26865807f, -0.15707077f, -0.24784134f, 0.20735645f, 0.00535209f, 0.07693854f, 0.13129945f, -0.06869356f, 
    -0.01226802f, 0.58006924f, -0.23449202f, -0.24235542f, -0.05016878f, -0.07668739f, 0.06896745f, 0.04872116f, 
    -0.01005408f, 0.05282734f, 0.24830942f, -0.26511592f, -0.03955287f, -0.16508028f, 0.06281301f, 0.75768900f, 
    -0.13780442f, -0.00529065f, 0.04912635f, -0.08259835f, 0.00901099f, -0.20940515f, 0.06224862f, 0.14763254f, 
    0.17552306f, -0.13340643f, 0.18776470f, 0.04773216f, 0.01762375f, -0.55323100f, -0.19564381f, 0.02834246f, 
    -0.14124478f, -0.05982910f, -0.04271569f, 0.29471523f, 0.01056838f, -0.00998636f, -0.18587798f, 0.30497086f, 
    0.38656920f, 0.07219600f, 0.11814445f, -0.03757117f, 0.09154993f, 0.02786966f, 0.06651837f, -0.43319505f, 
    0.34942895f, 0.00622874f, -0.13980457f, 0.09198866f, 0.24414150f, 0.01368993f, 0.37135515f, -0.02922384f, 
    0.07715596f, -0.02222859f, -0.18608847f, 0.04349473f, 0.07820079f, 0.07082430f, -0.07265007f, -0.48678422f, 
    0.45836464f, 0.16514127f, -0.05408730f, 0.01630953f, -0.15230651f, 0.05359269f, 0.15668543f, -0.16894445f, 
    0.12972350f, 0.12284048f, -0.22266576f, 0.14506270f, 0.17000879f, 0.10831710f, -0.19073285f, -0.57200456f, 
    0.22503553f, 0.35637063f, 0.08374891f, -0.07865935f, 0.08528399f, -0.21078061f, -0.23450750f, -0.36919063f, 
    -0.01066761f, -0.09387194f, -0.29047620f, -0.13548829f, 0.01669631f, 0.28948766f, 0.00239991f, -0.02397734f, 
    0.19653617f, -0.06545233f, -0.15862919f, -0.07407814f, 0.48477009f, -0.05199443f, 0.09165142f, 0.00515431f, 
    -0.09597570f, -0.04431412f, 0.09555544f, -0.18919134f, -0.15147886f, 0.09128910f, 0.07124858f, 0.31067166f, 
    0.33493021f, -0.16984236f, -0.43212882f, -0.50700563f, 0.10947203f, -0.06807498f, -0.04446593f, 0.13398297f, 
    -0.32500038f, -0.06672001f, 0.49090457f, -0.10081091f, 0.15902252f, 0.07650878f, 0.15324365f, -0.36879066f, 
    0.11456276f, 0.34117100f, -0.32326090f, 0.22945422f, 0.02629811f, -0.22528647f, -0.22496642f, -0.67344731f, 
    0.09889251f, -0.10892473f, -0.61326116f, -0.54096818f, -0.04614023f, 0.18604754f, 0.11141945f, -0.31085187f, 
    -0.30386087f, -0.04141286f, 0.07977762f, -0.03217939f, 0.07982780f, -0.09241639f, 0.31993884f, 0.19348164f, 
    0.17919357f, -0.02458968f, -0.00706978f, 0.13477276f, -0.22699581f, -0.06977367f, -0.32206324f, 0.17194533f, 
    -0.16229846f, -0.06390953f, 0.27398655f, 0.22223759f, -0.01504184f, 0.13945250f, -0.00025417f, 0.15933703f, 
    -0.15596630f, -0.18973504f, -0.07263695f, 0.01732374f, -0.01256436f, 0.05548434f, -0.08060607f, 0.12556176f, 
    0.03484264f, -0.00920950f, 0.01431931f, -0.19346839f, 0.37738976f, -0.01359877f, 0.09619053f, 0.06172341f, 
    -0.41435695f, 0.05828715f, 0.10379983f, 0.13600372f, 0.26320952f, -0.06080601f, 0.04803622f, 0.02693065f, 
    -0.70297176f, 0.14871132f, 0.16386655f, 0.29461104f, -0.02394750f, -0.01748001f, 0.30243570f, 0.05169077f, 
    -0.25851363f, -0.49202687f, -0.24516764f, 0.06023120f, -0.17914021f, -0.22664525f, 0.00719448f, 0.01034266f, 
    0.01860802f, 0.16643964f, 0.16662353f, 0.04729417f, 0.25043374f, -0.01495875f, 0.08668974f, -0.07507673f, 
    0.46524814f, 0.26089078f, -0.01380844f, -0.21769124f, -0.19093575f, 0.01560463f, 0.13890511f, -0.31123772f, 
    -0.08804142f, -0.05709375f, 0.02929738f, 0.23619500f, -0.35072887f, -0.01114120f, -0.07440863f, 0.21695103f, 
    -0.21762012f, -0.02574720f, 0.06206053f, -0.16230832f, 0.25679469f, -0.23490302f, 0.11177420f, 0.03922028f, 
    -0.05821624f, 0.17228276f, -0.03381936f, 0.11570884f, 0.06335101f, 0.08410551f, 0.04783116f, -0.46925321f, 
    0.11211139f, -0.17684747f, 0.58253092f, -0.02864733f, -0.07336240f, 0.12078433f, 0.22808334f, 0.00374357f, 
    -0.08258676f, 0.15999697f, -0.35535884f, 0.21817742f, 0.43587318f, 0.45876968f, -0.10120524f, -0.66379857f, 
    -0.09099649f, 0.33017281f, -0.23604104f, 0.05853587f, -0.10128440f, -0.03676395f, -0.20490335f, -0.70852447f, 
    -0.37601042f, -0.01602059f, -0.01951869f, -0.31914216f, -0.03838820f, 0.23285745f, 0.35085973f, -0.28281206f, 
    -0.06948709f, -0.42086884f, 0.52532202f, 0.04403472f, -0.07012713f, 0.28988549f, -0.29762107f, -0.04565853f, 
    -0.32665592f, 0.06309254f, 0.34884340f, 0.53290153f, 0.06901248f, -0.30944732f, -0.10683075f, -0.06298327f, 
    0.08573070f, 0.10520407f, 0.29511401f, -0.06566346f, -0.36626062f, 0.02620868f, 0.07679592f, 0.18307753f, 
    -0.34305283f, -0.07535753f, 0.10391445f, 0.27772936f, 0.12658839f, 0.26593184f, -0.11000683f, -0.14381365f, 
    -0.15272439f, 0.24371538f, 0.15388574f, -0.09099279f, 0.36460590f, 0.20070423f, 0.01296636f, 0.17499109f, 
    0.22722743f, 0.15989441f, 0.13092691f, -0.30552310f, -0.28581822f, 0.14244057f, -0.12182378f, 0.32371944f, 
    -0.33474585f, -0.45226064f, -0.09837002f, 0.61125749f, -0.27702045f, 0.13690428f, 0.06496619f, -0.28979933f, 
    0.10730848f, 0.05415341f, -0.08028644f, -0.03195599f, 0.01107747f, 0.13088514f, 0.08610641f, 0.11549292f, 
    -0.21788979f, 0.08983728f, 0.06822503f, -0.22968709f, 0.20135793f, -0.07261186f, 0.13515915f, -0.05939675f, 
    0.08565345f, 0.00860013f, -0.08076482f, 0.10247117f, -0.10467481f, 0.07127842f, 0.13482954f, -0.09445481f, 
    -0.04772190f, -0.06133236f, 0.09620950f, -0.01705513f, -0.03309000f, -0.12924491f, -0.04578390f, -0.10859778f, 
    0.03111397f, 0.12769254f, 0.08390408f, -0.08458573f, -0.01196708f, 0.01538519f, -0.07240393f, -0.00813073f, 
    0.30090120f, 0.04894354f, 0.18149635f, -0.03977126f, -0.41416875f, 0.03026297f, 0.18984717f, 0.17855394f, 
    -0.05595052f, -0.02624723f, 0.15205951f, 0.00607151f, 0.14834610f, 0.04085176f, -0.06038133f, 0.19070810f, 
    0.17112814f, -0.08939841f, 0.03213126f, 0.14981611f, -0.12068237f, 0.18306668f, -0.04185427f, -0.43177524f, 
    0.03307405f, 0.30053493f, -0.09057105f, 0.05804149f, -0.06088096f, 0.15451141f, -0.04455720f, -0.15392013f, 
    0.15557240f, -0.02911632f, -0.14192818f, 0.15514967f, -0.22337845f, -0.10655096f, 0.15344764f, 0.27590656f, 
    0.22849828f, -0.06337091f, 0.18597104f, -0.13349764f, 0.17337762f, -0.13789245f, 0.18610713f, -0.09076612f, 
    -0.06569953f, 0.18055089f, -0.20469080f, 0.19829550f, -0.10822564f, -0.01178207f, -0.00531770f, -0.21006256f, 
    0.05218945f, -0.11355159f, 0.14210844f, -0.01887835f, -0.01496625f, 0.09199913f, 0.22206654f, 0.23853433f, 
    -0.05345917f, 0.16458234f, -0.05537514f, 0.07646907f, -0.09709013f, 0.04494956f, 0.16015905f, 0.31274688f, 
    -0.46620509f, -0.15597844f, -0.03164179f, -0.06586579f, -0.10534830f, -0.02444959f, -0.07330301f, 0.02289234f, 
    -0.04544712f, 0.11547173f, 0.15087992f, -0.35717407f, 0.05994720f, -0.05542795f, -0.01034655f, 0.05120317f, 
    0.00249171f, -0.04903369f, 0.03205625f, 0.02900256f, 0.04723188f, -0.02253677f, -0.03319801f, 0.00125468f, 
    -0.07497638f, 0.01809705f, 0.05252505f, 0.01696302f, -0.02329906f, -0.08895017f, -0.04545550f, -0.04399696f, 
    0.02437047f, 0.08294398f, -0.09819010f, 0.00684678f, 0.03919046f, -0.02021438f, -0.06522342f, 0.03804274f, 
    0.00965082f, 0.03836225f, 0.01120208f, -0.04465939f, -0.09767941f, 0.06074836f, 0.00772398f, 0.00251176f, 
    0.04574585f, -0.06384051f, 0.02765116f, -0.07771838f, -0.04893421f, 0.05202496f, -0.06325896f, 0.04478912f, 
    -0.02530066f, 0.03124936f, 0.05919967f, 0.01779819f, 0.06976409f, -0.05873866f, 0.06472321f, -0.10188302f, 
    -0.00652508f, 0.08211435f, -0.00718892f, 0.03024377f, -0.03964638f, -0.04284472f, -0.02754895f, -0.06462031f, 
    -0.05120304f, -0.08136076f, 0.09207378f, 0.01651195f, 0.05859313f, -0.01328146f, -0.06650808f, 0.02002191f, 
    0.06253101f, 0.02677889f, 0.06714345f, 0.00791094f, 0.04213563f, -0.03527354f, -0.04061241f, 0.03984552f, 
    -0.03561831f, -0.03112457f, -0.05967422f, -0.06254713f, -0.00917045f, -0.06695966f, -0.10325002f, 0.03953234f, 
    -0.01367785f, -0.06778983f, -0.01508566f, 0.02173773f, -0.00163891f, -0.03682862f, -0.02048301f, 0.06773343f, 
    -0.02562115f, -0.00071480f, -0.06567699f, -0.07792938f, -0.06010979f, -0.08274721f, -0.07244202f, -0.02601170f, 
    -0.03543150f, -0.09230033f, 0.05109020f, 0.03682885f, 0.00971467f, 0.07420063f, 0.00860369f, 0.06552703f, 
    -0.09315724f, 0.03052297f, 0.06977618f, -0.06721031f, -0.06146229f, -0.08399927f, -0.03075282f, 0.01351765f, 
    -0.05129810f, -0.02587334f, -0.04365557f, -0.09132525f, 0.03148726f, 0.01061277f, -0.03802539f, -0.09015097f, 
    0.03769966f, -0.06829208f, 0.06295303f, -0.03822528f, -0.04436557f, -0.12047597f, -0.10005297f, 0.06379367f, 
    0.12918320f, -0.27594048f, 0.22879608f, -0.02601434f, 0.19115345f, 0.27398697f, -0.28881061f, -0.36060923f, 
    0.34854797f, 0.35954341f, -0.03777155f, -0.25883451f, -0.05868836f, -0.02083571f, 0.23542807f, -0.29234013f, 
    -0.10363393f, -0.02156412f, 0.07935628f, 0.15498647f, 0.27522743f, -0.02098909f, 0.16439450f, -0.17236279f, 
    -0.09882384f, -0.00963118f, 0.10654134f, -0.09004204f, 0.22192961f, 0.11887236f, 0.16435350f, -0.04009955f, 
    0.04091507f, -0.18565643f, -0.26060849f, -0.10226674f, 0.28279632f, 0.00860801f, 0.15154304f, -0.25668141f, 
    -0.11996611f, -0.19310443f, 0.68139267f, 0.18425326f, 0.30893609f, 0.16775545f, 0.28669205f, -0.55611020f, 
    -0.12632073f, 0.60463148f, -0.36826050f, -0.03648815f, -0.08566783f, 0.13483202f, -0.08946357f, -0.30668053f, 
    0.35621876f, 0.19787315f, -0.20439819f, -0.24434587f, 0.01956651f, -0.00725253f, 0.08846726f, -0.01246133f, 
    -0.54063326f, 0.04761257f, 0.08275300f, 0.01716200f, 0.20918819f, -0.03728599f, -0.24987257f, 0.14479473f, 
    0.13794689f, -0.39930969f, 0.35620135f, 0.31516153f, 0.11743627f, -0.10489181f, -0.28560823f, 0.09508906f, 
    -0.25136465f, 0.05519520f, 0.07689285f, -0.10967400f, 0.00932297f, -0.12720531f, 0.01115428f, 0.22394092f, 
    0.06860112f, -0.30335465f, 0.00757237f, 0.01740391f, -0.19962482f, 0.05412338f, -0.02260514f, 0.00512967f, 
    0.15602146f, -0.08816668f, 0.19818395f, -0.00092202f, 0.50253820f, 0.14995570f, 0.39034849f, 0.20060608f, 
    -0.24513960f, 0.14735383f, 0.08192241f, 0.13185617f, 0.13635328f, 0.20212065f, 0.03333039f, -0.30375832f, 
    -0.49282926f, 0.24756758f, 0.20478570f, 0.05123145f, -0.19551474f, 0.19764788f, 0.17892529f, 0.12077201f, 
    -0.09047664f, -0.12210742f, -0.50754684f, 0.00125118f, -0.10508845f, -0.04586145f, 0.05449815f, -0.46383852f, 
    0.15559119f, -0.10904334f, 0.28725421f, -0.03904749f, 0.08894539f, -0.36910281f, 0.05312001f, 0.02567402f, 
    0.33355954f, 0.08605166f, 0.03316385f, -0.51261580f, 0.02836731f, -0.07137366f, 0.21210855f, 0.03368041f, 
    0.61245269f, -0.01681460f, -0.42146185f, -0.14999777f, 0.42694837f, -0.08282516f, -0.05270290f, -0.02722988f, 
    0.27706042f, 0.29423541f, 0.00953447f, 0.23305215f, 0.06395932f, 0.09222779f, 0.24024150f, 0.14440091f, 
    -0.01714007f, 0.05701393f, -0.04525452f, 0.11335320f, 0.12336545f, 0.04757048f, 0.32468873f, -0.24767658f, 
    -0.15813677f, -0.50336927f, 0.21398096f, 0.11453166f, -0.08385471f, -0.12861025f, 0.13433652f, -0.16017476f, 
    0.19010621f, -0.21421634f, 0.03460838f, -0.10441550f, -0.18018484f, -0.21065289f, 0.26293579f, 0.21308041f, 
    -0.11346695f, -0.08959896f, -0.34155643f, -0.19213806f, 0.16686414f, -0.21467566f, 0.08500426f, -0.14167477f, 
    0.13857378f, -0.23077758f, 0.03264532f, 0.06073767f, -0.14373842f, 0.07150642f, -0.50957501f, 0.08767479f, 
    -0.37093651f, 0.07862866f, 0.26093769f, 0.09528716f, 0.14973032f, -0.05114805f, 0.08128929f, -0.48768339f, 
    -0.22485025f, -0.07254792f, 0.09186562f, -0.25120750f, -0.05813485f, -0.17283165f, -0.19696604f, 0.28244632f, 
    -0.02931797f, 0.10029218f, 0.04250560f, -0.28665799f, 0.00130290f, -0.10443172f, 0.08689927f, 0.23308922f, 
    -0.02927912f, 0.34346467f, -0.07402809f, 0.29215941f, 0.15594086f, 0.06590747f, 0.00402456f, -0.35603133f, 
    0.01681688f, -0.17993048f, 0.06151642f, -0.43842432f, 0.38562521f, 0.07418961f, -0.11785349f, -0.10198405f, 
    -0.52050179f, -0.36634403f, 0.07035276f, 0.04506486f, 0.25346395f, -0.03301955f, 0.04044648f, -0.18580925f, 
    0.36478660f, 0.07474675f, 0.00149923f, -0.10594873f, 0.41295612f, -0.04869162f, -0.10172778f, 0.24919517f, 
    -0.12452181f, 0.26955026f, 0.02545617f, -0.03487817f, 0.09720109f, -0.03230866f, 0.00909535f, -0.09201208f, 
    0.29080841f, -0.07168128f, -0.16748303f, -0.26900482f, -0.02403306f, 0.27473244f, -0.01345684f, 0.03887174f, 
    0.04861105f, 0.05088810f, -0.16541061f, -0.07267360f, 0.39932099f, 0.05636558f, -0.03455913f, -0.15446597f, 
    0.00481148f, 0.08238477f, 0.03787159f, 0.20750062f, -0.25149769f, 0.21498679f, -0.15430470f, 0.11724610f, 
    0.17038433f, -0.11866514f, -0.20998217f, 0.02528958f, 0.09527801f, -0.04347410f, -0.20870110f, 0.10285021f, 
    -0.42180592f, -0.30936527f, -0.01805592f, -0.08779496f, 0.61075932f, -0.02163672f, 0.07097160f, -0.11520989f, 
    0.06775724f, -0.15588631f, 0.03827524f, 0.04543543f, -0.39077806f, 0.23806040f, -0.01148300f, -0.16837406f, 
    0.13289098f, 0.10142253f, 0.23931302f, -0.18981594f, 0.12561196f, 0.00369741f, -0.01316393f, -0.03365799f, 
    -0.07071566f, 0.18279637f, 0.12755315f, 0.03993768f, 0.03347446f, 0.00210281f, 0.06730240f, 0.21586305f, 
    0.02941608f, 0.08833928f, -0.00544210f, 0.12593783f, 0.17572182f, 0.00063950f, 0.06577916f, 0.10416026f, 
    -0.05779207f, -0.04691749f, -0.21242608f, -0.04140553f, -0.24427022f, 0.34813148f, 0.04459190f, -0.00084983f, 
    -0.08562611f, -0.04999072f, -0.06181084f, 0.05787347f, 0.21005870f, 0.05561044f, 0.04642490f, 0.28932652f, 
    -0.21252878f, 0.08132761f, 0.24952605f, 0.12660085f, 0.13422020f, -0.15779740f, -0.05646608f, 0.07265362f, 
    -0.37452945f, -0.09031035f, 0.10351644f, -0.02027647f, 0.44468918f, 0.13702081f, -0.22851206f, 0.09833828f, 
    0.00248620f, 0.37051210f, -0.06175265f, 0.07094043f, -0.10389458f, 0.19271345f, 0.08156034f, 0.21271333f, 
    -0.05055550f, 0.05083602f, -0.12069717f, -0.23076437f, -0.09753101f, -0.02110214f, -0.00222115f, 0.12928535f, 
    0.07560164f, 0.33910292f, -0.04584808f, 0.02750606f, 0.15118505f, 0.07539999f, 0.30259761f, 0.00783581f, 
    0.09150716f, 0.04369887f, 0.06672528f, -0.00926246f, 0.27409366f, -0.23489520f, 0.04488200f, -0.01274896f, 
    -0.12856174f, -0.08577512f, 0.14613117f, -0.13282889f, -0.10578350f, 0.07276619f, 0.05664342f, -0.06294533f, 
    -0.08232216f, -0.10830591f, -0.07548565f, -0.05310072f, 0.02925021f, -0.07322977f, 0.22184992f, -0.02320797f, 
    0.04236429f, -0.05895553f, -0.15438528f, -0.03249013f, -0.09382698f, -0.10986440f, 0.21016416f, 0.18966493f, 
    0.19139446f, 0.02426366f, -0.05715241f, 0.06552599f, -0.33402669f, -0.08257527f, 0.12982546f, 0.46608189f, 
    -0.07527694f, -0.06865504f, -0.01232450f, -0.03966980f, -0.09116168f, 0.48659232f, -0.02661993f, 0.08927988f, 
    0.01732016f, -0.03574077f, 0.35253683f, 0.04382813f, -0.05513877f, 0.04968647f, -0.00105568f, -0.23671922f, 
    0.22819810f, 0.30290312f, -0.05909995f, 0.16447957f, 0.06594471f, 0.22543146f, -0.15165949f, -0.33120257f, 
    0.12807322f, -0.12022551f, -0.02258154f, 0.20986886f, -0.27436185f, -0.28929225f, 0.11531588f, 0.25250313f, 
    0.08351034f, -0.07247611f, 0.03360696f, 0.29814592f, -0.06193944f, -0.06196996f, 0.00674821f, -0.00844006f, 
    0.02909996f, 0.02252995f, 0.07689308f, 0.20118101f, 0.17040788f, 0.03261643f, 0.05316227f, -0.29757023f, 
    0.02855000f, 0.02032441f, 0.08288009f, 0.00287329f, -0.01991585f, -0.11366404f, 0.30012548f, -0.16838953f, 
    -0.12097888f, -0.01156016f, -0.12931250f, 0.12212043f, -0.15847573f, 0.07294617f, 0.05825065f, -0.08415835f, 
    -0.09552746f, -0.23118852f, -0.02853569f, -0.07421032f, -0.14526504f, 0.11774808f, -0.02396613f, -0.18017368f, 
    0.08452664f, 0.36099115f, 0.02601274f, -0.17460367f, 0.25836653f, 0.08950738f, -0.05673510f, -0.23263203f, 
    -0.15846513f, -0.11340139f, 0.13383080f, -0.00348953f, 0.14600524f, -0.29207358f, 0.34368840f, 0.07108027f, 
    0.16982369f, -0.02694825f, -0.14974290f, -0.23945087f, 0.05644532f, -0.09488106f, 0.04304638f, -0.09429009f, 
    0.28436118f, 0.04428067f, -0.06921501f, -0.19429715f, 0.52108163f, -0.04618375f, 0.08861797f, -0.03281200f, 
    0.08744288f, 0.19627889f, 0.15028378f, -0.13691621f, 0.01378245f, -0.18476242f, -0.02692739f, 0.04974260f, 
    0.30330721f, -0.21242106f, -0.30714041f, 0.10400302f, 0.09667597f, -0.07499574f, -0.08755144f, -0.18919560f, 
    0.23731492f, -0.15782209f, 0.04592882f, -0.12154961f, -0.28590789f, -0.05199135f, 0.09657560f, -0.11949724f, 
    0.07221576f, -0.00342048f, 0.13124822f, -0.03925617f, -0.21096735f, -0.08629843f, -0.47130093f, -0.12552303f, 
    0.04863803f, 0.15976934f, -0.03451375f, -0.04063267f, 0.12443098f, 0.41561267f, 0.08264645f, -0.51120836f, 
    0.00539557f, 0.09667413f, 0.05283917f, -0.01477728f, 0.08091922f, 0.18249160f, 0.17726180f, -0.55455190f, 
    0.02789074f, 0.07536067f, 0.05525796f, 0.06829988f, -0.04734961f, 0.29217261f, -0.06130293f, -0.12291833f, 
    -0.10654163f, 0.00290466f, -0.04857393f, -0.17694858f, -0.03132477f, -0.30770689f, -0.04592699f, 0.15421854f, 
    -0.39171171f, 0.16508216f, -0.02367149f, -0.04042403f, -0.05616568f, -0.03985965f, -0.07524024f, 0.30229071f, 
    -0.36911115f, 0.13301536f, 0.07243819f, 0.19213821f, -0.10137708f, -0.08552711f, -0.19054177f, -0.67027479f, 
    -0.07750893f, -0.05192632f, 0.17610702f, -0.17383921f, 0.05923057f, -0.06607269f, 0.07358271f, 0.65285605f, 
    -0.56810081f, -0.11050899f, 0.14421725f, 0.04941290f, 0.12770863f, 0.17409201f, 0.05660248f, -0.31854966f, 
    0.00365766f, -0.07690077f, 0.25458750f, -0.15385902f, 0.16681783f, 0.09517152f, -0.00699525f, 0.24517891f, 
    -0.22807138f, -0.02486993f, 0.14028864f, 0.04184290f, -0.16194518f, 0.01483724f, 0.02073665f, 0.03388580f, 
    0.27165896f, -0.04290067f, -0.01273725f, -0.21745262f, -0.29188585f, 0.35542339f, 0.03677735f, 0.01047570f, 
    -0.28558123f, -0.03175284f, -0.26082551f, 0.26970592f, 0.16871341f, -0.06460617f, -0.14041317f, 0.17669798f, 
    0.22468165f, 0.02805663f, -0.08483573f, 0.11919726f, -0.18956223f, -0.36305177f, -0.28604880f, -0.14571971f, 
    0.25757244f, 0.24631257f, 0.06174028f, 0.19542851f, -0.03459390f, -0.01723612f, -0.15851738f, 0.15167052f, 
    -0.43974864f, -0.18660238f, 0.53232670f, 0.17950290f, 0.59292918f, 0.26678264f, -0.37451664f, -0.13534886f, 
    0.12857367f, 0.00904859f, -0.05293742f, -0.36652949f, -0.12439998f, -0.01610302f, 0.02452601f, -0.09885947f, 
    -0.52502638f, 0.38238397f, 0.06796746f, 0.03199168f, 0.30884239f, -1.06660986f, -0.24636790f, -0.17459176f, 
    0.06858622f, -0.18584706f, -0.00670711f, -0.18083403f, 0.10985498f, 0.11135711f, 0.04225195f, -0.02509788f, 
    0.01756933f, -0.07473173f, -0.23843701f, -0.03044737f, 0.12244157f, 0.15586841f, -0.00714638f, -0.22139904f, 
    0.19846329f, -0.04547324f, -0.12002812f, 0.05503420f, 0.01691654f, 0.34897441f, 0.36611077f, -0.12669779f, 
    0.06451093f, -0.28894323f, 0.02445401f, -0.04260164f, 0.14877015f, -0.08646788f, -0.04239486f, 0.23289320f, 
    -0.27191648f, 0.29307693f, 0.02133080f, 0.02745440f, 0.20222045f, -0.13060817f, -0.21650913f, -0.36886671f, 
    0.05903810f, -0.05753039f, 0.06991512f, 0.13461177f, -0.07148183f, -0.03783926f, -0.18262838f, 0.17236844f, 
    0.37552533f, 0.20133232f, -0.00198659f, 0.13137116f, -0.27172783f, 0.03653537f, -0.01346438f, 0.45672917f, 
    0.06694002f, -0.17387486f, -0.13942224f, 0.27665153f, -0.19984427f, -0.04271192f, 0.08566756f, -0.20659773f, 
    -0.06112232f, 0.00964264f, 0.02447072f, 0.08599302f, 0.02350189f, -0.02522837f, 0.04277716f, -0.08681748f, 
    -0.07308918f, 0.03078706f, -0.00673864f, 0.02551335f, -0.11093053f, 0.00299984f, 0.04295072f, 0.01825749f, 
    -0.11202793f, -0.06993978f, -0.13247105f, 0.04292275f, -0.08706976f, 0.06943240f, -0.06372307f, -0.01731729f, 
    -0.11568613f, 0.00159015f, -0.03151158f, -0.01146413f, -0.08182181f, 0.03419764f, -0.08062240f, 0.02375325f, 
    -0.07507569f, -0.03128476f, -0.03800388f, -0.00913395f, -0.00087790f, -0.07348738f, -0.09423045f, 0.09087490f, 
    -0.03687649f, 0.03524952f, -0.01043532f, -0.03295250f, -0.04546174f, -0.10410985f, -0.07337852f, 0.02633983f, 
    -0.06286973f, 0.00240568f, 0.03497005f, 0.03190177f, -0.07730591f, 0.02032615f, -0.01351364f, -0.08599824f, 
    0.03644677f, -0.09228209f, 0.00854802f, -0.02987582f, -0.04908104f, -0.02925462f, 0.04130439f, -0.03285420f, 
    -0.03460561f, 0.06458801f, 0.04359622f, -0.06517215f, 0.01458265f, -0.08244691f, 0.04029897f, -0.06287012f, 
    -0.00652888f, -0.12335820f, -0.11686126f, 0.04811782f, 0.01353822f, 0.01962851f, -0.09886466f, -0.01157897f, 
    -0.05820749f, -0.05656761f, -0.10365065f, 0.00822454f, -0.09397074f, 0.02261300f, -0.06197137f, -0.07192032f, 
    -0.02910883f, -0.01555941f, 0.06394006f, -0.00924633f, -0.12463498f, -0.00710037f, -0.02810061f, -0.03947072f, 
    -0.08832599f, -0.01503112f, -0.01952404f, -0.03213110f, -0.08083736f, 0.04369214f, 0.02477514f, -0.04059789f, 
    -0.09585073f, 0.05364035f, 0.01890608f, -0.02957332f, -0.01561771f, 0.03969532f, -0.11085851f, 0.07202670f, 
    -0.02151902f, -0.05253875f, -0.09248558f, -0.04488963f, -0.02895557f, -0.06038237f, -0.02883561f, -0.02007029f, 
    0.00232904f, -0.05297900f, -0.01763085f, -0.07519209f, 0.00924534f, 0.04412967f, -0.00307502f, -0.06307708f, 
    0.35792845f, 0.00883788f, 0.10521456f, 0.04902617f, 0.27695093f, 0.24384694f, 0.01032276f, -0.27952912f, 
    0.10924762f, 0.26272362f, 0.10003013f, -0.59027517f, 0.16174860f, -0.25991869f, 0.20219232f, 0.10188820f, 
    -0.00675113f, -0.08797953f, -0.01802358f, 0.13814183f, -0.28389809f, -0.02749808f, -0.04738894f, -0.33742982f, 
    -0.05212148f, -0.04378059f, 0.13760914f, 0.09942868f, 0.07702221f, -0.09522380f, 0.43828458f, -0.11720121f, 
    -0.11714964f, -0.09538057f, -0.11073724f, 0.11521137f, 0.29513952f, -0.04419160f, 0.39922029f, 0.07117891f, 
    -0.19953883f, -0.41817108f, 0.02980382f, 0.05089460f, 0.03637448f, -0.04965904f, 0.36344948f, -0.40205321f, 
    -0.09324207f, 0.16858384f, -0.11314926f, 0.03331136f, -0.27505475f, -0.15620196f, 0.09341867f, -0.02101423f, 
    0.16396785f, 0.00151723f, 0.00294927f, -0.25544932f, -0.02082792f, 0.09821940f, 0.01312461f, 0.43161929f, 
    -0.10380634f, 0.16159317f, 0.11466847f, -0.09237088f, -0.05636642f, -0.10755941f, -0.12061103f, 0.12150284f, 
    0.00044797f, -0.21455532f, -0.01877972f, 0.24919693f, -0.18559277f, -0.50095177f, -0.07366821f, 0.01666614f, 
    -0.05637949f, 0.07413174f, 0.12256522f, 0.03400011f, -0.01543813f, 0.09513821f, -0.09225114f, 0.19910914f, 
    0.17959234f, -0.36295494f, 0.11349155f, -0.03497520f, 0.07814824f, 0.00263563f, 0.07159900f, -0.10585959f, 
    0.24656725f, -0.09123030f, 0.11864541f, -0.00250345f, 0.47859147f, 0.36151958f, 0.48605487f, -0.05972207f, 
    -0.34929740f, 0.15440130f, 0.06206517f, -0.05660621f, 0.29408085f, 0.21492344f, -0.14944871f, -0.38502499f, 
    0.06994531f, -0.00561630f, 0.10585758f, -0.10731836f, -0.27951905f, 0.12206558f, 0.23111553f, 0.14620979f, 
    0.17231284f, 0.07269426f, -0.28702673f, -0.24402325f, 0.23151307f, 0.13740316f, 0.09108043f, -0.32690722f, 
    0.10122828f, -0.11813690f, 0.13312918f, 0.06126014f, -0.00819260f, 0.23501077f, -0.29863763f, -0.33584228f, 
    0.20680583f, 0.22242621f, 0.13903317f, 0.11340954f, -0.18373536f, -0.08968433f, 0.09361915f, 0.30890280f, 
    -0.27208501f, -0.05971888f, 0.00094626f, 0.19479032f, -0.25724480f, -0.02660082f, 0.01960963f, -0.27228296f, 
    -0.08123417f, -0.04247453f, 0.12599061f, 0.14383425f, 0.03852561f, 0.03378660f, 0.14268862f, 0.14030765f, 
    -0.09655365f, -0.28935790f, -0.01339712f, -0.15259857f, 0.22830774f, -0.07200536f, 0.31409845f, -0.10758601f, 
    -0.29156801f, 0.10067516f, 0.15228975f, 0.23716119f, 0.19191298f, -0.00080431f, -0.12504853f, -0.22533627f, 
    0.14085928f, 0.51985574f, -0.17316268f, 0.02743113f, -0.04263213f, -0.08132556f, 0.07491150f, 0.05562300f, 
    0.04898775f, -0.01646355f, 0.19558941f, -0.31613526f, -0.15093268f, -0.15331718f, 0.10784353f, 0.24114709f, 
    -0.19880202f, 0.00126711f, 0.03685976f, -0.04282065f, 0.06437800f, -0.16509722f, 0.34478042f, 0.19721429f, 
    0.21242230f, -0.04754277f, -0.11627758f, 0.07749767f, -0.08681663f, -0.42030737f, 0.10617802f, 0.03828775f, 
    -0.28858918f, 0.06161663f, -0.09866041f, 0.26052049f, 0.02551880f, 0.08605815f, 0.06453539f, 0.20299438f, 
    0.14887694f, -0.06546862f, -0.01764854f, 0.05133566f, 0.18028030f, -0.10606924f, -0.02442404f, -0.30415159f, 
    0.25449610f, -0.10796584f, -0.01580430f, -0.03834519f, 0.36805561f, -0.18111405f, 0.26093990f, 0.25365266f, 
    0.11818755f, -0.14318757f, -0.20406763f, 0.12762265f, 0.05507524f, 0.02457836f, 0.01711144f, -0.16903219f, 
    0.06643685f, 0.08884726f, -0.04219127f, 0.26375386f, -0.03845619f, 0.00768322f, 0.23756754f, 0.11291257f, 
    0.26978683f, 0.20349623f, -0.23435502f, -0.03729166f, 0.08443457f, -0.08862168f, -0.08941946f, -0.54374796f, 
    -0.33994123f, 0.29174024f, 0.08476148f, -0.01472372f, -0.17075585f, -0.13900439f, -0.16199958f, -0.01531897f, 
    0.22431377f, 0.12673433f, 0.02607320f, 0.08196028f, -0.31363198f, 0.07153744f, 0.00981830f, -0.25550443f, 
    0.17390500f, 0.01939404f, -0.06188320f, -0.09618553f, 0.10760051f, 0.02040785f, -0.10456566f, 0.08889470f, 
    0.10503799f, 0.20160811f, 0.16154364f, -0.13686110f, 0.04782329f, 0.16526024f, -0.34495479f, 0.20659433f, 
    0.23084864f, -0.08117581f, -0.16730294f, -0.20525119f, 0.01346665f, -0.00632455f, -0.43164057f, -0.05548666f, 
    -0.17008646f, 0.02827864f, 0.14071187f, 0.19157250f, -0.07366794f, 0.01132563f, -0.30926013f, -0.03428682f, 
    0.01850254f, 0.41946173f, -0.28013510f, 0.32832184f, 0.07010119f, -0.04137107f, 0.11953223f, 0.12711921f, 
    -0.15486695f, 0.16294342f, 0.18522131f, -0.12397118f, 0.01054711f, -0.15431353f, 0.09626152f, 0.35712603f, 
    -0.19159059f, -0.19721776f, -0.08469765f, -0.12805657f, -0.01041618f, -0.01206857f, -0.02401398f, 0.15841031f, 
    -0.22247493f, 0.10734549f, 0.15170284f, -0.20332889f, 0.62801635f, 0.14004835f, -0.39191037f, -0.22826456f, 
    -0.12669028f, -0.00219314f, -0.03047572f, 0.31688318f, 0.17211623f, -0.18252061f, -0.09220949f, 0.39041972f, 
    0.01402751f, 0.03859971f, -0.06767495f, -0.22331424f, -0.35847846f, 0.02427412f, 0.00561402f, 0.27677611f, 
    0.12066217f, 0.06999036f, -0.05814479f, 0.04335959f, -0.08256939f, -0.14521079f, -0.33234513f, 0.24649213f, 
    0.20293258f, -0.24314190f, 0.10843381f, -0.17090261f, 0.22376901f, 0.01476216f, -0.09302871f, -0.14195915f, 
    0.40782556f, 0.46605593f, -0.09976564f, 0.09430099f, 0.13477346f, -0.15747906f, -0.05913018f, 0.03147357f, 
    -0.02246398f, -0.21879669f, 0.03498587f, 0.18258618f, -0.75124145f, 0.49838376f, 0.04499532f, 0.26655388f, 
    -0.51288158f, 0.14473070f, 0.00291963f, -0.03011778f, 0.17118548f, -0.12635580f, 0.08464901f, 0.03618808f, 
    0.12960111f, 0.12159627f, 0.23250134f, 0.22979188f, -0.03193779f, -0.39759129f, -0.34780827f, -0.01976254f, 
    0.27496436f, -0.00433811f, -0.19203705f, -0.22397502f, 0.42985830f, 0.05780902f, 0.02021235f, -0.13114187f, 
    0.12784226f, 0.11430300f, 0.10450826f, -0.15619244f, 0.10183139f, 0.27412003f, -0.22192897f, -0.26260218f, 
    0.15747446f, -0.23038758f, -0.18121473f, -0.29515818f, -0.31464368f, -0.06352186f, -0.15799300f, 0.08605863f, 
    0.29085582f, 0.53102171f, -0.69274467f, 0.17676970f, -0.17072530f, 0.01434506f, -0.37686741f, 0.33595356f, 
    0.11304203f, 0.41292682f, -0.12175212f, -0.00902471f, -0.02489178f, 0.21911016f, -0.29431880f, 0.21895494f, 
    -0.27598682f, 0.19566216f, 0.17525037f, 0.02673483f, -0.19515829f, -0.31300473f, 0.28910598f, 0.04113358f, 
    0.22080557f, 0.18406563f, 0.00053322f, -0.00421466f, 0.09896339f, 0.18467773f, 0.06667264f, -0.17947093f, 
    -0.05281776f, 0.15919216f, 0.18548959f, 0.00288562f, 0.03870327f, 0.09966603f, 0.04497549f, -0.21076401f, 
    -0.15458979f, -0.00436400f, 0.03488141f, 0.02713549f, 0.24574235f, -0.23706795f, 0.15408136f, -0.11018902f, 
    -0.18064682f, 0.17767103f, -0.19062996f, 0.15164499f, -0.02372893f, -0.06568290f, -0.06270254f, 0.09818572f, 
    -0.05385687f, -0.27288434f, 0.11330246f, -0.09009432f, -0.34202090f, 0.02178438f, -0.10909653f, -0.45788980f, 
    0.13517612f, 0.04320229f, 0.10263103f, -0.00728087f, 0.22292309f, 0.01251970f, 0.15092734f, 0.21412647f, 
    0.31436694f, 0.04980134f, 0.23633003f, 0.00841266f, 0.23568532f, 0.01182828f, -0.31103924f, -0.45321348f, 
    0.06201499f, 0.26407620f, -0.04311510f, -0.23481357f, -0.15108667f, 0.13987580f, 0.00372838f, 0.10809793f, 
    0.28468758f, -0.87785470f, 0.08102003f, 0.07638640f, -0.24320559f, -0.01097042f, 0.04369878f, 0.08596449f, 
    0.11128937f, -0.25680825f, 0.11373055f, 0.06503513f, -0.02339138f, -0.57682401f, -0.20881855f, 0.36837098f, 
    0.11751504f, -0.06470153f, 0.09893800f, 0.10316426f, 0.17076074f, 0.01112353f, -0.05900218f, -1.00829995f, 
    0.03981321f, -0.09112358f, 0.00353010f, 0.14779145f, 0.02686049f, -0.00413588f, 0.09683048f, 0.35795298f, 
    -0.10311693f, -0.19237539f, 0.07902483f, 0.13600318f, 0.01767634f, -0.09706518f, 0.27588335f, -0.40616456f, 
    0.13187389f, 0.06219113f, 0.47786355f, 0.04945496f, -0.26452240f, 0.07671881f, 0.15314035f, 0.13935232f, 
    -0.05020384f, -0.42783839f, -0.14114171f, 0.20332453f, 0.42929682f, -0.10090354f, 0.28354925f, 0.23722917f, 
    0.06607621f, -0.02305955f, 0.34540826f, 0.19550706f, 0.10758201f, 0.22759067f, 0.09595205f, 0.48991024f, 
    -0.02289948f, 0.15232430f, 0.00185476f, -0.06094805f, 0.12629884f, -0.28755173f, -0.54415721f, -0.38099530f, 
    0.13290405f, 0.18538940f, 0.23599045f, -0.04381339f, 0.59005570f, 0.01084950f, 0.03104630f, 0.13209225f, 
    -0.01032237f, 0.02755339f, 0.18412666f, -0.68966633f, -0.01512393f, 0.00454014f, -0.01341513f, 0.22290617f, 
    0.35867119f, 0.15087983f, -0.16679329f, 0.00880744f, 0.16724148f, 0.11001763f, -0.05723094f, 0.00391408f, 
    0.27758825f, -0.00485858f, -0.26200867f, -0.15987875f, 0.32833332f, 0.08198447f, 0.06570181f, 0.11045082f, 
    0.26666686f, -0.09194336f, -0.19835553f, 0.21425749f, 0.02678504f, -0.18136092f, 0.11157528f, -0.24957679f, 
    0.39067376f, 0.19254220f, -0.37316477f, 0.11849533f, 0.24270085f, -0.10160957f, 0.13509628f, -0.17268527f, 
    0.16687168f, 0.16767211f, -0.15552172f, 0.74065948f, 0.35270280f, 0.28841549f, 0.02868171f, 0.03871404f, 
    0.17913780f, -0.47074771f, -0.16621032f, 0.02857017f, -0.05650379f, 0.15402123f, 0.07782761f, 0.29750061f, 
    -0.50933290f, -0.00937976f, 0.06878989f, 0.28090087f, 0.23861286f, 0.02141994f, 0.07342086f, -0.24884303f, 
    0.09409582f, 0.08282080f, 0.10559161f, 0.20811260f, -0.01717962f, -0.02678801f, 0.05069356f, 0.18672504f, 
    0.01549908f, -0.22166035f, 0.15623097f, -0.03319361f, 0.07236151f, 0.03959897f, -0.00754887f, -0.28325409f, 
    -0.10644497f, 0.37536746f, 0.35358498f, 0.08251341f, -0.11433949f, 0.10373638f, -0.28971937f, 0.46074876f, 
    0.42924806f, 0.41474867f, -0.25441980f, 0.08156615f, -0.29627481f, 0.21459588f, 0.15019931f, -0.05205541f, 
    -0.23989150f, -0.49182472f, 0.28818804f, 0.03628881f, 0.05952758f, -0.33593607f, 0.09268222f, 0.18631066f, 
    0.09723279f, -0.18374000f, -0.37863889f, 0.23819712f, -0.22473013f, 0.20738171f, -0.05441421f, -0.58548170f, 
    -0.05802052f, 0.13690604f, -0.01369155f, 0.04779826f, 0.00854440f, 0.00928989f, -0.80139583f, 0.26276249f, 
    0.29782948f, -0.08860146f, -0.24212770f, 0.02332444f, -0.35608655f, 0.08765834f, 0.27425665f, 0.32737163f, 
    0.51789659f, 0.05770269f, 0.21236913f, -0.47341502f, 0.04903127f, 0.14820385f, 0.17772458f, -0.23145975f, 
    0.07113007f, 0.11230255f, -0.12859094f, 0.00281018f, -0.21176256f, -0.03135696f, 0.08644581f, -0.12453940f, 
    0.22243792f, 0.07543547f, -0.00562528f, -0.17895484f, -0.06347118f, 0.33880144f, 0.10401738f, 0.38963473f, 
    0.16982253f, 0.21712694f, -0.00745396f, 0.15262839f, -0.28119481f, 0.07222528f, 0.23403691f, 0.01329148f, 
    -0.15182164f, -0.30803484f, 0.13659360f, -0.08679823f, -0.03989475f, 0.04255160f, -0.09106276f, 0.16831619f, 
    -0.02875780f, 0.07636867f, 0.23610516f, -0.07669780f, 0.10593858f, -0.57994151f, 0.34208420f, 0.04584136f, 
    0.04578091f, 0.15871798f, 0.03055503f, 0.08699121f, -0.16165157f, 0.06057998f, -0.13807760f, 0.05215997f, 
    -0.19914632f, -0.15228613f, 0.15320361f, 0.28517747f, -0.15222667f, 0.20113228f, -0.05313014f, -0.14271797f, 
    -0.22090828f, 0.02080742f, 0.30294892f, 0.29151252f, -0.10962599f, -0.02093358f, 0.09728012f, 0.35290825f, 
    0.03537248f, -0.08230917f, 0.04530472f, -0.08331294f, 0.12459623f, 0.00525319f, -0.05743102f, -0.02705224f, 
    0.15644048f, 0.15963711f, 0.23375104f, 0.01741875f, -0.13370296f, 0.05892913f, -0.12552486f, -0.10458347f, 
    0.03090411f, 0.36899176f, 0.24453874f, 0.22421600f, -0.10139403f, 0.36234081f, -0.10771375f, 0.12533008f, 
    0.05675302f, 0.29058373f, 0.03651028f, -0.28689286f, 0.22952715f, -0.14103989f, -0.07214226f, 0.03809901f, 
    -0.02347113f, 0.26700071f, -0.16041416f, 0.31830323f, -0.08751102f, -0.11326640f, 0.07535279f, 0.20130970f, 
    -0.13346346f, 0.01392719f, 0.09894663f, 0.11249822f, 0.12454864f, 0.11228454f, 0.00786942f, 0.21749876f, 
    0.32438526f, 0.09009624f, -0.06900978f, -0.03338057f, 0.07851946f, 0.24262792f, -0.11956917f, 0.06715243f, 
    0.31329349f, -0.01255389f, 0.09940317f, -0.14459653f, 0.23653872f, 0.28204834f, 0.36953536f, -0.20465228f, 
    0.17858838f, -0.05668725f, 0.06276799f, -0.06189802f, 0.15196985f, 0.03951766f, -0.08586519f, 0.04277046f, 
    -0.00584995f, -0.12055571f, 0.00310941f, -0.06921520f, 0.11250881f, 0.02320713f, -0.12909222f, 0.01222846f, 
    0.24812084f, 0.15775381f, -0.06443196f, 0.30222392f, -0.17148091f, -0.03537973f, 0.12258870f, -0.12022934f, 
    0.12242243f, -0.03898913f, -0.09605502f, 0.10536000f, 0.10881677f, 0.09231488f, -0.00902444f, 0.41948634f, 
    -0.14840557f, -0.12623075f, -0.15949677f, 0.49429089f, -0.12341992f, -0.23737404f, 0.12988341f, -0.09628383f, 
    0.22062884f, -0.43822959f, -0.05758520f, -0.06599505f, -0.18367295f, -0.02694130f, 0.37571302f, 0.10882476f, 
    -0.18334359f, 0.10998899f, 0.01082828f, 0.23683558f, 0.00477632f, -0.27669793f, 0.17373309f, 0.15775602f, 
    0.41596383f, -0.03814919f, 0.02386867f, 0.16214353f, 0.28441647f, -0.00607453f, -0.15542060f, -0.21050857f, 
    0.02703577f, -0.14982517f, -0.12697048f, 0.21530925f, -0.01377336f, -0.01071197f, -0.03046324f, 0.03444426f, 
    0.02728504f, 0.13272834f, 0.16408847f, 0.17234342f, -0.01532143f, 0.03790975f, 0.08811801f, -0.27247071f, 
    0.14484638f, 0.00404919f, -0.07649073f, 0.04938008f, -0.14648765f, -0.15127283f, 0.11008076f, -0.06110974f, 
    -0.10789976f, -0.06740113f, 0.18250614f, -0.14407313f, 0.17342220f, -0.38382465f, 0.32407477f, 0.32115474f, 
    -0.01317518f, -0.13954818f, -0.11959434f, 0.23262499f, -0.20799555f, 0.05909156f, 0.03998498f, 0.24387376f, 
    -0.03450226f, 0.01269562f, 0.01858165f, -0.00831848f, -0.13095832f, 0.01625151f, -0.64684784f, 0.19595793f, 
    -0.14229248f, 0.05081696f, 0.08873986f, -0.16138470f, 0.39591986f, -0.21398082f, 0.25168812f, -0.05600644f, 
    0.04385429f, 0.04165446f, 0.23668417f, -0.43998578f, -0.07766913f, 0.12806153f, 0.07499471f, 0.12112855f, 
    0.15627974f, 0.02840625f, 0.00513759f, -0.36239576f, 0.08411708f, 0.06651139f, 0.04140745f, -0.15091319f, 
    0.19576043f, 0.10137702f, 0.02938635f, -0.02030040f, 0.02528835f, 0.10583137f, 0.22457890f, 0.24323571f, 
    0.03143444f, -0.01965827f, -0.26177707f, -0.29266599f, -0.28605285f, 0.00577491f, 0.03473912f, -0.06345511f, 
    0.22064123f, 0.28317100f, -0.19803323f, -0.21882659f, 0.05969447f, -0.10254380f, -0.00539418f, 0.15011264f, 
    0.24823464f, 0.27546301f, 0.01094203f, 0.10548643f, 0.29880047f, 0.12893213f, -0.03307400f, 0.02970760f, 
    -0.01884794f, 0.04439588f, 0.00703725f, -0.07152376f, 0.28663325f, 0.22265437f, 0.16185279f, -0.09886248f, 
    -0.03629798f, 0.13269717f, 0.03722388f, -0.09823117f, 0.13625747f, -0.15130277f, 0.15436037f, -0.55138522f, 
    0.28979781f, 0.01260260f, -0.48758736f, -0.21682544f, -0.72365737f, -0.06758756f, 0.00675203f, 0.15157321f, 
    0.05957201f, -0.01209778f, 0.08268490f, -0.09208968f, 0.03250787f, -0.06388506f, 0.15625057f, -0.26217902f, 
    0.02639482f, 0.17116940f, -0.04721631f, 0.03239186f, 0.09957436f, 0.00253830f, 0.11451004f, -0.07251400f, 
    0.17546058f, -0.17423078f, -0.08736603f, -0.58201414f, -0.07696926f, -0.26341128f, 0.03356581f, -0.06130958f, 
    -0.10758521f, -0.06196698f, 0.12019865f, 0.12982534f, -1.07715285f, -0.09239926f, -0.26995561f, -0.19490623f, 
    0.04169641f, -0.04559594f, -0.68994021f, -0.15705743f, 0.21448024f, -0.07623354f, -0.45172852f, -0.77587932f, 
    -0.05976490f, 0.03104883f, -0.07536777f, -0.18176955f, -0.11351904f, 0.13440110f, 0.06250852f, -0.25084201f, 
    -0.27306089f, -0.32387751f, 0.03678248f, 0.08085276f, -0.83250588f, 0.00218659f, -0.12215031f, -0.30547839f, 
    -0.28497830f, -0.01851218f, 0.05580088f, 0.14594646f, -0.03612242f, -0.39202636f, -0.02139750f, 0.06725266f, 
    -0.08528345f, 0.12722872f, 0.26516929f, 0.13691348f, -0.39098257f, 0.06376490f, -0.05082534f, -0.06748240f, 
    -0.05315862f, -0.05954544f, 0.08835185f, 0.01951590f, -0.09018658f, 0.25490010f, 0.16680266f, -0.32797053f, 
    -0.61810029f, 0.16948934f, 0.21873915f, -0.27934882f, 0.22482464f, 0.17518084f, -0.07582701f, 0.21059468f, 
    0.16928418f, -0.18479329f, 0.37296000f, -0.02114436f, -0.16591255f, 0.01235395f, -0.03020224f, -0.04835956f, 
    -0.04696254f, 0.01044682f, 0.30843514f, -0.80763292f, 0.29309988f, -0.14388885f, 0.32084256f, -0.03380530f, 
    -0.02445447f, -0.06763808f, 0.02396444f, 0.03681799f, -0.09193911f, 0.04559002f, -0.04064726f, -0.07948799f, 
    -0.08964287f, -0.00005104f, -0.00618075f, -0.03656787f, 0.05654106f, -0.01184930f, -0.03017737f, 0.02700156f, 
    0.06523141f, -0.00859314f, -0.08618923f, -0.10170731f, -0.01629571f, 0.03507049f, 0.00454701f, 0.04706548f, 
    -0.05719407f, 0.00297279f, 0.05634579f, 0.06993154f, 0.01074714f, -0.02984512f, -0.05952927f, -0.08684646f, 
    0.03300185f, -0.07119291f, -0.00989677f, -0.08641142f, -0.06634636f, 0.00632075f, -0.08235106f, 0.06249730f, 
    0.05288268f, 0.02266715f, -0.07934932f, -0.08629755f, 0.08361740f, -0.06680167f, 0.01062826f, -0.04657607f, 
    -0.04244110f, 0.03075124f, -0.02951009f, -0.02091510f, 0.01274842f, -0.01635220f, 0.00914970f, -0.09437623f, 
    0.03825097f, -0.05019284f, 0.08024184f, -0.08679835f, -0.12727620f, -0.07746361f, 0.06948313f, -0.01197477f, 
    -0.00998733f, -0.05559233f, -0.06585678f, -0.09223972f, -0.05556026f, -0.02534622f, -0.03373984f, -0.07766357f, 
    0.03129129f, -0.01814870f, 0.01730071f, -0.00768492f, 0.03475482f, -0.05989785f, -0.09180012f, 0.02143127f, 
    0.06103883f, -0.00825466f, 0.06481215f, -0.02291777f, -0.08754437f, -0.02235386f, -0.09063779f, -0.07720313f, 
    -0.09037589f, -0.06796633f, -0.10002622f, -0.00053953f, 0.04418325f, -0.05233566f, -0.04479535f, 0.01950243f, 
    0.06845796f, -0.00193845f, 0.01279527f, -0.05548944f, -0.02827998f, 0.01544728f, 0.05254171f, -0.07181627f, 
    -0.00674191f, 0.05358267f, 0.05625216f, 0.02217934f, 0.03135878f, 0.05710573f, -0.05568601f, 0.01877475f, 
    0.07175123f, -0.07818033f, -0.01667761f, 0.02080812f, 0.05401508f, -0.00329204f, 0.02576093f, -0.04434662f, 
    0.05749278f, 0.02636794f, 0.04474320f, 0.08008187f, 0.05878026f, -0.05468760f, -0.04220637f, -0.04242950f, 
    -0.01210848f, -0.78794229f, 0.06124518f, 0.02197431f, -0.36874169f, -0.14822918f, 0.36120415f, 0.22203526f, 
    -0.10633116f, -0.48375422f, -0.00806531f, 0.36893201f, -0.08854605f, -0.21226270f, -0.18314083f, 0.20241375f, 
    0.20262706f, -0.07471175f, 0.18040928f, 0.36258405f, 0.40808830f, -0.07979896f, 0.00797466f, -0.41882989f, 
    -0.02742876f, -0.00401506f, -0.01946336f, 0.25389948f, -0.01386838f, 0.03985736f, -0.17909104f, 0.17880009f, 
    0.11440000f, 0.07432961f, -0.00096331f, 0.06461514f, -0.15862988f, 0.02830765f, 0.16686042f, -0.31018284f, 
    0.26355606f, 0.28350806f, 0.31217062f, 0.13351756f, 0.07253420f, 0.12799422f, 0.12009227f, -0.19551955f, 
    -0.05350430f, -0.29179165f, -0.04412957f, -0.10542202f, 0.50495374f, -0.43469790f, 0.24325515f, -0.01034670f, 
    -0.16510330f, 0.22477920f, 0.15296726f, 0.36178187f, -0.23584011f, 0.03865496f, 0.16900988f, -0.33139125f, 
    -0.00406116f, 0.17442502f, 0.05471204f, -0.05610331f, -0.07222924f, 0.08482209f, -0.23116150f, -0.08875915f, 
    0.12064841f, 0.30712557f, 0.21891990f, -0.10487958f, 0.06214822f, 0.22919573f, -0.09041342f, 0.06615913f, 
    -0.03227801f, -0.03258513f, 0.19471276f, -0.59604818f, 0.16215712f, 0.11242981f, 0.23830430f, 0.02612560f, 
    0.32779592f, -0.00636715f, -0.30669507f, -0.11989717f, 0.29756868f, -0.00604064f, -0.07864338f, 0.12013503f, 
    -0.09966170f, 0.30572933f, -0.24317420f, -0.02330181f, 0.13870375f, -0.14790721f, -0.08560228f, -0.16022162f, 
    0.36259237f, -0.03386815f, -0.41172239f, 0.10785628f, -0.26147327f, -0.19322972f, 0.11634929f, 0.14948128f, 
    -0.07542081f, 0.10585982f, -0.44604516f, 0.06055487f, 0.29741973f, -0.04540491f, -0.04449873f, 0.08382572f, 
    0.12305121f, 0.12506722f, -0.25436181f, 0.62341964f, 0.33925426f, 0.03597913f, 0.00638673f, 0.13597898f, 
    0.06250639f, -0.00160059f, 0.13437374f, 0.04246422f, 0.16831781f, 0.02668619f, -0.13350455f, -0.09213075f, 
    0.04446058f, 0.06370323f, 0.09660903f, 0.11717022f, 0.10524163f, -0.03315498f, 0.10530343f, 0.14170814f, 
    0.19116005f, 0.04530455f, -0.05471257f, -0.13017574f, 0.16171648f, -0.00152133f, 0.18190946f, -0.09335675f, 
    0.13606684f, 0.20530970f, 0.24780074f, 0.15883973f, 0.08792125f, 0.24954444f, 0.24382226f, -0.08342983f, 
    -0.18334331f, -0.19765776f, -0.17621687f, -0.08597665f, 0.07568662f, 0.01077557f, 0.15656894f, 0.26699898f, 
    -0.18557426f, 0.06488214f, -0.32160267f, 0.03988266f, 0.27033451f, -0.00083690f, -0.05842050f, -0.42958277f, 
    0.04655528f, -0.06331628f, -0.09939227f, -0.16414568f, -0.24210615f, -0.10777418f, -0.01385504f, 0.00863575f, 
    0.09295736f, -0.07536914f, -0.04133265f, -0.19737436f, 0.28905180f, 0.02408714f, 0.18611726f, 0.28216061f, 
    0.06974255f, -0.12767822f, -0.05281308f, 0.01010178f, 0.15483029f, -0.06861317f, -0.34174070f, 0.29260832f, 
    0.01355417f, 0.07243147f, 0.06233014f, 0.07819773f, 0.11066420f, -0.21947694f, -0.13845541f, 0.00442334f, 
    -0.14477736f, 0.01261150f, -0.12770379f, -0.15254311f, 0.05427122f, -0.04581506f, -0.16727933f, 0.10647511f, 
    0.04044277f, -0.07112440f, 0.07462800f, 0.02046705f, 0.02207586f, 0.05631080f, 0.07527468f, 0.09835696f, 
    0.13363974f, 0.06678271f, 0.01510754f, 0.15037775f, 0.18887326f, 0.12111405f, 0.18394205f, -0.24633209f, 
    -0.13208722f, 0.05975586f, 0.12077883f, -0.04395711f, 0.38235217f, 0.18980089f, 0.00307275f, -0.46152806f, 
    -0.08041327f, -0.06044912f, 0.06964324f, 0.15143074f, 0.14741296f, 0.05602622f, 0.15027703f, -0.04189923f, 
    0.22222503f, -0.08874320f, -0.15026464f, -0.34821579f, -0.05317867f, 0.14854300f, 0.09230761f, 0.01403003f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01405577f, 0.07528733f, -0.10129161f, -0.06094721f, -0.07114609f, -0.06147593f, -0.08235928f, -0.03852207f, 
    -0.00225593f, 0.05188261f, -0.05227109f, 0.22303660f, 0.21165954f, 0.25701129f, 0.15404269f, 0.02628722f, 
    0.07372430f, -0.17576353f, -0.31742996f, 0.02463125f, 0.09927752f, 0.15654589f, 0.01831687f, -0.02883521f, 
    0.16732910f, 0.11059397f, 0.30161610f, -0.20377910f, 0.16370934f, -0.08708692f, 0.01208070f, 0.13754103f, 
    0.02793224f, -0.07686390f, 0.10156826f, 0.20170513f, -0.04587333f, -0.06549954f, -0.06927016f, -0.15578175f, 
    0.06207935f, 0.13199325f, 0.03604361f, 0.01459267f, 0.08111917f, -0.03120511f, 0.05043396f, -0.08969793f, 
    0.11201260f, -0.08824904f, 0.05864570f, 0.09951416f, 0.02864064f, -0.06028457f, -0.00232860f, 0.25608259f, 
    0.34150329f, -0.05508858f, 0.00695925f, -0.07101362f, -0.00600499f, -0.10191854f, 0.08714352f, 0.01258521f, 
    -0.04864379f, 0.08054367f, 0.09374680f, 0.14719340f, 0.25928128f, 0.26848245f, 0.01944334f, 0.10618611f, 
    -0.05447538f, 0.04954942f, 0.04632685f, -0.39904916f, -0.08391311f, 0.23137245f, -0.22742867f, 0.21161684f, 
    -0.08091837f, 0.09316510f, 0.05938533f, 0.30837759f, 0.00186140f, -0.11792091f, 0.27706853f, 0.00309234f, 
    -0.06708337f, 0.17499191f, -0.10440210f, 0.34699303f, 0.12739483f, -0.09451386f, 0.00909222f, 0.37451938f, 
    0.02028940f, -0.03481250f, 0.12501886f, -0.04367091f, -0.09762063f, -0.14550665f, -0.09673739f, 0.03556243f, 
    -0.02866452f, 0.20584910f, -0.16923943f, 0.09365314f, 0.02689388f, 0.13070585f, 0.25312483f, 0.02792798f, 
    -0.12163272f, 0.02199367f, -0.31776294f, -0.05119517f, 0.23722687f, 0.16982001f, 0.00414753f, -0.01980505f, 
    0.14896739f, 0.24738567f, -0.05749381f, 0.01301608f, -0.02012527f, -0.01113972f, -0.01628898f, 0.24390222f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.07155814f, 0.00014509f, 0.02409062f, 0.00415951f, -0.70056605f, -0.38794830f, 0.12878360f, -0.18032746f, 
    0.14037840f, 0.15081222f, -0.05878541f, -0.18571067f, -0.09965304f, -0.04656599f, 0.19920960f, -0.02434923f, 
    -0.07456275f, -0.73090011f, -0.82726836f, 0.10583311f, 0.07671162f, 0.13627090f, -0.07684955f, 0.00431219f, 
    0.03059201f, -0.03146592f, -0.17050923f, 0.20207344f, -0.13464671f, -0.05522149f, -0.30853814f, -0.05492054f, 
    -0.05057877f, 0.03802388f, 0.06603488f, -0.30639997f, -0.01093610f, -0.01878718f, -0.40654007f, -0.03711630f, 
    0.04084217f, -0.32428870f, 0.07447647f, 0.03641763f, 0.12613367f, 0.05284761f, 0.04248350f, -0.14999917f, 
    0.05612649f, 0.21528231f, -0.32708538f, 0.00395768f, -0.04999738f, 0.10857783f, -0.05766063f, -0.06850816f, 
    -0.29803935f, 0.04290200f, -0.03817780f, 0.16944227f, 0.02829449f, -0.09053148f, 0.19782853f, -0.05537636f, 
    0.07061534f, 0.05715169f, 0.02969795f, 0.10818915f, -0.18587033f, -0.18417567f, 0.20103541f, -0.31809044f, 
    -0.28907937f, -0.06201324f, -0.06250194f, -0.67034012f, 0.05200196f, 0.01747747f, 0.17977712f, 0.02514092f, 
    0.23709230f, -0.26366261f, 0.09833400f, 0.03247409f, 0.04692905f, -0.28155041f, 0.09946927f, -0.14239027f, 
    0.03521774f, -0.04839370f, -0.02281159f, -0.02484390f, -0.07248749f, -0.03276272f, 0.00061179f, -0.09541062f, 
    0.09934814f, -0.03493974f, 0.12335689f, -0.04620502f, 0.06390634f, -0.41421980f, -0.26187602f, -0.09590282f, 
    0.15773928f, -0.38418505f, 0.04776692f, 0.05712621f, -0.07142135f, -0.24114439f, -0.20196494f, -0.44560766f, 
    0.17485182f, -0.59706157f, 0.12759496f, -0.01059647f, 0.08768190f, 0.06790852f, 0.47252247f, 0.02132614f, 
    0.21389121f, 0.13603742f, 0.17417975f, 0.15730985f, 0.13911283f, 0.08394665f, 0.24751920f, -0.21499167f, 
    -0.02973148f, -0.03028640f, 0.05473364f, 0.02310540f, 0.32914242f, 0.28271699f, -0.07165243f, -0.04396948f, 
    -0.04476723f, -0.23705846f, -0.03355981f, -0.09496620f, -0.11060384f, 0.18569630f, 0.54392785f, 0.07484592f, 
    0.21570288f, 0.02680027f, -0.66100776f, -0.24704248f, -0.10692333f, 0.01489682f, 0.00335585f, 0.00001280f, 
    0.00831584f, 0.12813967f, -0.04597896f, -0.27757204f, 0.13039809f, -0.12442994f, 0.44903859f, -0.25426596f, 
    -0.06054379f, -0.00327291f, 0.10487314f, -0.13706395f, -0.04064771f, -0.05523977f, 0.30845490f, 0.35665169f, 
    -0.07334174f, -0.01406795f, 0.09676474f, -0.03331025f, 0.24807999f, 0.04250233f, 0.03440455f, 0.00672178f, 
    -0.06639860f, -0.09112613f, 0.02047964f, 0.01303288f, -0.00182928f, -0.04086559f, -0.21663569f, 0.10734603f, 
    -0.06004354f, -0.01892861f, -0.03581392f, -0.34823713f, -0.00693648f, -0.04665764f, 0.27502275f, -0.05394020f, 
    0.01255594f, -0.00788571f, 0.06033592f, 0.11751070f, -0.09869471f, 0.09974054f, -0.16454181f, -0.49278787f, 
    -0.09829121f, -0.01877475f, 0.03081054f, 0.67419469f, -0.05910421f, -0.24554050f, -0.21280360f, 0.06045188f, 
    0.03122610f, 0.06011650f, 0.10271956f, -0.15300976f, -0.01747951f, 0.27457637f, -0.09768607f, -0.14093371f, 
    0.01592783f, 0.15076357f, -0.04489975f, 0.00261180f, 0.06931221f, -0.08168370f, 0.06326039f, 0.01579683f, 
    0.06487731f, -0.24648993f, 0.04373053f, 0.01595190f, 0.01339289f, 0.14238140f, -0.20188591f, 0.02195539f, 
    0.30999708f, 0.14397390f, -0.15222315f, -0.02459799f, 0.07011691f, 0.26881662f, -0.42847884f, 0.16235170f, 
    -0.02356775f, -0.25304925f, 0.25403449f, -0.00445756f, 0.34410375f, 0.37766075f, 0.07880949f, 0.38565415f, 
    -0.10311533f, -0.19316109f, -0.05704334f, -0.35526896f, -0.29224938f, 0.04254976f, -0.44457966f, 0.03185223f, 
    -0.08440893f, -0.01925742f, -0.06888811f, -0.10760947f, -0.87212896f, -0.55254465f, 0.14336137f, -0.05341047f, 
    -0.00900841f, -0.16997197f, -0.05239033f, 0.10915349f, 0.13173902f, 0.15755951f, 0.32932386f, -0.10311829f, 
    0.20765807f, -0.62779492f, -0.08672313f, 0.11186863f, -0.48645613f, 0.10614461f, 0.05904473f, -0.01823109f, 
    -0.73447627f, -0.49889934f, 0.08103719f, -0.49839440f, 0.15611883f, -0.05903682f, -0.60658514f, 0.00960778f, 
    0.19627021f, -0.02839097f, 0.12035961f, 0.11951740f, 0.00157951f, -0.06693273f, -0.10586101f, -0.21994948f, 
    0.07834276f, 0.05201786f, 0.23073170f, 0.08650400f, -0.03030987f, 0.01208818f, 0.03937657f, -0.06425819f, 
    0.12354424f, -0.73815453f, 0.18369938f, -0.47630075f, 0.02953100f, -0.01409171f, -0.07582240f, 0.01201314f, 
    -0.48848286f, -0.05872879f, 0.00123095f, 0.01492405f, 0.01708968f, -0.07987115f, -0.12733413f, 0.01750206f, 
    -0.02108559f, -0.09529248f, 0.26981723f, 0.06344818f, -0.36345643f, -0.00944530f, 0.13515958f, -0.03322949f, 
    0.49325609f, -0.01916152f, -0.03328713f, -0.43877542f, -0.03443158f, 0.11425594f, -0.78293043f, 0.19952288f, 
    0.18697834f, 0.19295505f, 0.10351602f, 0.09485776f, -0.10507488f, -0.98765248f, -0.19362676f, -0.06663445f, 
    -0.01803702f, 0.09137005f, 0.05593207f, -0.22604512f, -0.51582253f, -0.01673176f, -0.05558787f, -0.31658614f, 
    -0.29797977f, 0.08338815f, -0.30340961f, -0.04765363f, -0.04430802f, 0.02922484f, -0.43182504f, -0.26474938f, 
    0.17976604f, 0.00913150f, 0.27508983f, -0.14456992f, -0.00147972f, 0.12184872f, -0.58040464f, 0.10435330f, 
    -0.48670223f, 0.19502723f, -0.07294529f, 0.02514087f, -0.24114813f, 0.11683363f, -0.00271466f, 0.17641175f, 
    0.24710476f, -0.27643016f, 0.15849532f, -0.12044961f, 0.34829551f, 0.08022632f, 0.18478996f, -0.28188989f, 
    -0.07360850f, 0.05871830f, 0.02533183f, -0.08690506f, 0.03358114f, -0.54022455f, 0.10542331f, -0.09010646f, 
    -0.01076413f, 0.06290810f, -0.01840167f, 0.06298704f, 0.20696692f, 0.18471012f, 0.23547870f, 0.00997893f, 
    -0.68885648f, -0.10063561f, -0.17544620f, 0.18970285f, -0.09399881f, -0.07949885f, 0.02689280f, 0.05399963f, 
    -0.10097398f, 0.17196527f, -0.21504742f, -0.03031705f, -0.64665407f, -0.11776736f, -0.09118695f, 0.24488334f, 
    -0.11563706f, -0.06544871f, -0.38847071f, -0.31444383f, -0.06294698f, 0.04119381f, 0.21336196f, -0.08814286f, 
    0.06436735f, -0.07781933f, -0.83863044f, -0.04478068f, -0.01613440f, -0.03930554f, 0.03302373f, -0.00173542f, 
    0.05715660f, 0.17730398f, -0.08355550f, -0.17507319f, 0.03332711f, 0.13297831f, 0.05975547f, -0.02046171f, 
    -0.06451526f, -0.04366967f, -0.07991419f, -0.05046117f, -0.00712321f, -0.07739466f, 0.06177821f, -0.05579245f, 
    -0.02610233f, 0.01630981f, -0.37199312f, -0.51861495f, 0.22380243f, -0.32260633f, 0.02585135f, 0.17048696f, 
    -0.83612669f, 0.01159053f, -0.03933645f, -0.36784932f, -0.07033744f, 0.26938039f, 0.09946560f, 0.22456804f, 
    -0.00677315f, -0.36446241f, -0.30680990f, -0.32982010f, -0.01322399f, 0.11470182f, 0.17832080f, -0.47395360f, 
    -0.04653645f, -0.37809679f, -0.05130824f, -0.21963878f, -0.32000616f, -0.10101499f, -0.06111916f, -0.01975950f, 
    -0.22452295f, 0.20368992f, -0.35428140f, -0.06341856f, -0.06362527f, -0.24199551f, 0.02205596f, 0.10942172f, 
    -0.16207592f, -0.08801622f, 0.29723728f, 0.11290377f, 0.04925966f, 0.64338309f, 0.16884801f, -0.23235419f, 
    0.13618632f, 0.14128479f, -0.40059534f, -0.02791934f, 0.01850824f, -0.25030333f, 0.02144745f, 0.04294868f, 
    0.05926405f, 0.02849532f, -0.56894749f, 0.07515545f, 0.56262797f, 0.00005621f, 0.12518944f, -0.16636018f, 
    -0.07418559f, -0.05406389f, -0.08339713f, -0.03371237f, 0.12779130f, -0.56802166f, -0.27161449f, -0.11360487f, 
    0.02735064f, 0.11621883f, -0.03411884f, 0.10857613f, 0.29552531f, 0.31052014f, -0.13059528f, -0.03979593f, 
    -0.15009484f, 0.31332368f, -0.61928773f, 0.01591722f, 0.15818341f, -0.16362686f, 0.03255196f, 0.05670461f, 
    0.06299134f, 0.09701991f, 0.13303564f, 0.20417921f, -0.07413769f, -0.11306073f, -0.57256109f, 0.09850823f, 
    -0.29610276f, -0.05660324f, 0.04981097f, 0.14471762f, -0.00975799f, 0.01000919f, 0.00301873f, -0.02039498f, 
    -0.03109897f, -0.22632019f, -0.17941158f, 0.01033134f, -0.12848686f, -0.07336504f, 0.07321806f, -0.04846958f, 
    -0.02933853f, 0.01438926f, 0.05319287f, 0.08073117f, -0.05532980f, 0.15802626f, 0.00576891f, 0.18389650f, 
    0.20201118f, -0.05669121f, -0.01913322f, -0.25764701f, -0.03481385f, -0.11968988f, -0.32776102f, 0.01502363f, 
    0.05879567f, -0.01573193f, 0.03386933f, -0.21936904f, 0.31054732f, 0.11471742f, 0.09390479f, 0.03526886f, 
    -0.45205849f, 0.05670886f, -0.00061082f, -0.71110696f, 0.00403538f, 0.22503234f, -0.04979721f, 0.25898799f, 
    -0.18971543f, 0.18873101f, 0.02365741f, 0.09427729f, 0.03393605f, -0.19129808f, 0.09899939f, 0.10846064f, 
    -0.07491343f, 0.15789552f, -0.02454492f, 0.17588580f, -0.00059737f, 0.00688269f, 0.07637201f, 0.14284998f, 
    0.02644155f, 0.21301396f, 0.11317392f, 0.00124409f, -0.06244276f, 0.28979579f, 0.21962725f, -0.09256944f, 
    -0.56820697f, 0.53309768f, -0.01514293f, 0.04958057f, 0.03797341f, -0.13001455f, -0.26446149f, 0.21847108f, 
    -0.01208825f, -0.21777683f, -0.66891718f, 0.04812437f, -0.41448823f, -0.33149594f, 0.05002191f, -0.15222766f, 
    0.13861652f, 0.12592162f, 0.01949039f, -0.06184618f, -0.18748592f, 0.03928224f, -0.04899226f, -0.17167653f, 
    0.05139684f, 0.03739798f, 0.00569621f, -0.14600803f, -0.02806439f, 0.27345607f, -0.30447364f, -0.11704727f, 
    -0.19773172f, 0.13021332f, -0.10868550f, -0.15429227f, -0.39133683f, 0.02693379f, 0.37521255f, 0.07197367f, 
    -0.13261993f, 0.02481258f, 0.28130093f, 0.25415498f, 0.13859041f, 0.05092080f, -0.01029413f, 0.04282333f, 
    0.04133053f, -0.03046488f, -0.00583513f, 0.26986095f, -0.15765885f, -0.03002331f, 0.28310814f, -0.76448417f, 
    0.28625321f, 0.06501201f, -0.01118595f, 0.32707939f, -0.00201672f, -0.04070811f, -0.07114573f, -1.18752992f, 
    -0.03930847f, 0.15081331f, -0.04706695f, -0.08121064f, 0.06555017f, 0.00037024f, 0.01288456f, -0.08089958f, 
    -0.09052281f, -0.14837670f, 0.15193905f, 0.11352279f, -0.05843666f, -0.27520198f, -0.31642586f, 0.11393449f, 
    0.09464090f, -0.00274024f, -0.04869756f, 0.18367612f, 0.03274135f, -0.01661723f, -0.07192527f, 0.01498276f, 
    -0.06071953f, -0.05502523f, -0.21021046f, 0.17752451f, -0.50542313f, 0.05007080f, -0.53365624f, 0.10656029f, 
    -0.39430723f, -0.09811032f, -0.05536147f, -0.11775234f, 0.05175586f, -0.35905516f, 0.18503287f, -0.63641810f, 
    -0.07891185f, 0.16162328f, -0.11396846f, 0.14602619f, 0.02254601f, 0.22404066f, -0.00185438f, 0.01841723f, 
    0.00815164f, 0.04120912f, -0.00452802f, 0.28264412f, 0.11754365f, -0.05725402f, -0.02169669f, 0.21650769f, 
    0.18713990f, -0.31923968f, 0.12537855f, -0.03448346f, -0.05741375f, -0.04479813f, 0.14535010f, 0.00377893f, 
    -0.05072082f, 0.27910879f, -0.46122909f, 0.09458179f, 0.02488262f, 0.14950046f, 0.13671452f, 0.06160008f, 
    -0.06897730f, -0.02246638f, 0.04612618f, -0.06414226f, 0.25845477f, 0.01743852f, 0.23529463f, -0.43829110f, 
    -0.45102516f, 0.26049650f, 0.06116193f, 0.25775102f, -0.05597397f, -0.00837352f, -0.29628599f, 0.08030885f, 
    -0.02772311f, -0.03915840f, -0.05415674f, 0.03150255f, -0.15194875f, 0.33220747f, 0.12535954f, -0.06221215f, 
    -0.66810179f, 0.04220110f, -0.11166705f, -0.04108748f, -0.42745015f, -0.02318438f, -0.48667437f, 0.06991085f, 
    0.14903265f, -0.79392689f, 0.04144344f, -0.15408213f, -0.02254316f, 0.11213483f, -0.05010726f, -0.02144228f, 
    0.06767303f, -0.41817126f, 0.08447095f, -0.02531854f, 0.03254454f, -0.08577768f, 0.37934881f, 0.08557910f, 
    -0.36344942f, 0.03052663f, 0.05059725f, -0.78133595f, 0.01779077f, 0.00462630f, -0.44294319f, 0.51044822f, 
    0.00800144f, 0.11359058f, 0.12639537f, 0.04384886f, -0.40652898f, 0.07724319f, 0.07884154f, 0.06928670f, 
    -0.10604785f, -0.04821610f, -0.44567356f, 0.20582736f, 0.04521035f, 0.01342122f, 0.41462210f, -0.12693480f, 
    0.28323290f, 0.01274853f, -0.11542778f, -0.27274013f, -0.02751035f, 0.01213758f, -0.49695677f, 0.01753075f, 
    -0.01322821f, 0.05493830f, 0.18048397f, 0.21682292f, -0.07240210f, 0.11093182f, -0.35942191f, -0.09769084f, 
    -0.08024951f, -0.00623848f, 0.03561612f, -0.19902723f, 0.01748649f, -0.04757221f, -0.56741989f, -0.19715519f, 
    -0.08568782f, -0.17887953f, 0.16800919f, 0.22265682f, 0.04889017f, 0.13523807f, 0.10289715f, -0.16815037f, 
    0.03338255f, -0.01716895f, -0.06388830f, 0.13681498f, 0.13749953f, -0.02898090f, -0.04743896f, 0.20146152f, 
    0.12079816f, 0.06530889f, 0.15682614f, -0.01802885f, -0.05477332f, -0.42150474f, -0.09368274f, 0.21526210f, 
    -0.40700483f, -0.44846249f, -0.04372178f, 0.19019005f, 0.05801073f, 0.03920469f, 0.44505018f, -0.23450913f, 
    0.08526465f, 0.05199637f, 0.13694291f, -0.08222014f, -0.13891827f, -0.40004843f, -0.67259455f, -0.08732936f, 
    -0.65476948f, 0.22660495f, 0.09659693f, -0.39158359f, -0.02630308f, -0.04052415f, -0.40053421f, -0.03484800f, 
    -0.04158680f, -0.06763783f, -0.00181700f, 0.00718797f, 0.18760706f, 0.23363659f, -0.21780385f, -0.05177260f, 
    0.08530489f, 0.07514150f, -0.10974701f, -0.44865462f, 0.16329275f, -0.57477152f, 0.03202326f, -0.09561069f, 
    -0.61993164f, 0.16351238f, 0.40588629f, 0.03578177f, 0.06846311f, -0.45976031f, -0.06094426f, -0.02339612f, 
    0.09916452f, -0.07717780f, -0.29639348f, 0.02832485f, -0.23773019f, -0.13284136f, 0.17346048f, -0.25389725f, 
    -0.14312217f, -0.05722999f, -0.24399844f, -0.39782116f, 0.00875468f, 0.05004808f, 0.12470121f, -0.16124202f, 
    -0.03310863f, -0.38208887f, 0.18850748f, 0.04377069f, -0.07757513f, 0.04932852f, 0.03550493f, 0.02720538f, 
    -0.32878968f, 0.13109970f, 0.00998157f, -0.08548197f, -0.04344938f, 0.09062701f, -0.11366419f, -0.52689546f, 
    -0.47577515f, 0.03485780f, -0.03138531f, 0.13047569f, 0.03583804f, -0.02832328f, -0.08794950f, 0.00730522f, 
    0.01430111f, -0.03705389f, -0.05010954f, -0.42986414f, -0.21885806f, -0.38036293f, 0.00599231f, 0.02239892f, 
    -0.17489393f, 0.05227142f, 0.06927607f, 0.24817102f, 0.00432576f, -0.16885865f, 0.14775600f, -0.35923442f, 
    -0.30181462f, -0.43170053f, -0.56241316f, -0.16296467f, 0.02939608f, 0.14789481f, -0.21896055f, 0.33142251f, 
    -0.11597335f, -0.11712551f, -0.07562460f, -0.44434014f, 0.13426463f, 0.01723975f, 0.01443395f, -0.39244649f, 
    0.12285966f, -0.15448672f, -0.10908644f, -0.05101297f, -0.04329741f, 0.12470943f, 0.07115999f, -0.06407055f, 
    -0.15676327f, -0.42088488f, 0.18283561f, -0.21228452f, -0.04497932f, 0.12980026f, 0.01565680f, 0.07346920f, 
    0.05208334f, -0.41257459f, 0.19665202f, 0.02538685f, -0.64071643f, -0.48562825f, -0.07239655f, -0.46581528f, 
    0.14223561f, -0.01852999f, -0.06373538f, 0.03076491f, 0.02623026f, 0.02808369f, 0.22734523f, -0.06379002f, 
    0.02042002f, -0.04634656f, 0.02893413f, 0.05996601f, 0.19634126f, -0.22300886f, 0.13612092f, 0.04867919f, 
    -0.05385692f, -0.22721297f, -0.07711551f, 0.00215089f, -0.16084485f, -0.25254640f, -0.02957525f, -0.05143804f, 
    -0.37818760f, 0.22109579f, -0.94485277f, -0.24358006f, 0.02837261f, -0.24915250f, 0.02861288f, -0.03782151f, 
    0.12365682f, -0.34078678f, 0.17963845f, 0.15719567f, 0.13944620f, 0.07045726f, -0.11009378f, -0.11041972f, 
    0.26530805f, 0.03048344f, 0.04812078f, 0.23765625f, 0.05268618f, 0.07467245f, -0.16605850f, 0.17066020f, 
    -0.03757206f, 0.15006298f, -0.01918977f, -0.08662845f, -0.42495570f, 0.00146614f, 0.04341082f, 0.00708586f, 
    0.09876332f, -0.15106668f, 0.00126476f, -0.25277287f, -0.05115010f, -0.37790141f, 0.15392038f, 0.11921804f, 
    0.23382422f, 0.03464125f, -0.02771775f, 0.25221705f, -0.02295812f, -0.01786547f, -0.00550339f, 0.00541828f, 
    0.02343651f, -0.07572860f, -0.73999381f, -0.50109071f, 0.06191558f, 0.10958972f, -0.16186874f, 0.19652899f, 
    -0.47750938f, 0.05070565f, -0.03219611f, -0.28562590f, -0.02158814f, -0.50347066f, 0.13909790f, -0.21078631f, 
    -0.28716037f, 0.20029749f, -0.03420567f, -0.36695796f, 0.07334848f, -0.05252074f, -0.33880225f, 0.28694186f, 
    -0.03263262f, 0.17183089f, -0.06582472f, -0.54198039f, 0.28321093f, 0.01248747f, -0.08313974f, -0.33715394f, 
    0.20997810f, -0.77182722f, -0.20977974f, -0.04913218f, -0.05002372f, 0.20513630f, -0.06396491f, 0.22456063f, 
    -0.17837006f, -0.15584157f, 0.13862479f, -0.38983339f, 0.03197754f, -0.03548013f, -0.09137644f, 0.16027938f, 
    -0.28080231f, -0.17748269f, 0.03927815f, 0.07142393f, 0.05843764f, 0.04228003f, -0.01285850f, 0.33234698f, 
    -0.21440183f, -0.60937530f, -0.03680174f, 0.12422385f, -0.13654542f, 0.07685739f, -0.11841650f, 0.22253779f, 
    -0.04072633f, -0.09263749f, 0.07393531f, 0.03511282f, 0.18542223f, 0.06732161f, -0.15413135f, -0.00111139f, 
    -0.03198533f, -0.11699107f, 0.00310171f, 0.23547687f, -0.14009754f, -0.34394041f, -0.63844800f, -0.02333700f, 
    -0.05221839f, 0.16672027f, 0.25104207f, -0.36528945f, 0.16773488f, -0.08239623f, 0.05296949f, -0.08314148f, 
    0.03370761f, -0.10500535f, -0.12833814f, 0.20982748f, 0.09246425f, -0.05387429f, -0.37612012f, 0.25084791f, 
    0.13127060f, -0.04764376f, -0.00361680f, 0.34604698f, -0.08297521f, -0.07762260f, -0.04707023f, -0.12285483f, 
    -0.05227762f, 0.21674697f, 0.07897310f, -0.04116149f, -0.19084540f, 0.01649503f, -0.06993186f, -0.03400213f, 
    0.08474767f, 0.08115610f, -0.20514031f, 0.16164440f, -0.06593692f, 0.23193751f, -0.28469998f, -0.00682541f, 
    -0.10910887f, -0.00476890f, -0.01522587f, 0.31640208f, -0.03757524f, -0.02225287f, 0.06814532f, -0.08210906f, 
    0.00545250f, -0.02931326f, 0.00701603f, 0.04628780f, 0.05219768f, -0.08173367f, -0.00689177f, 0.16787970f, 
    0.30569690f, -0.05702804f, 0.03519635f, -0.25290480f, 0.06354512f, 0.09193181f, 0.06635653f, 0.15439542f, 
    -0.01335127f, 0.24438193f, 0.12718095f, 0.08040230f, 0.04308663f, -0.27742103f, -0.11359294f, 0.23692647f, 
    0.05410140f, -0.14091995f, 0.05675756f, 0.14224738f, 0.18458146f, 0.04187763f, -0.08208949f, -0.02485420f, 
    0.20670889f, -0.03555819f, 0.06052488f, -0.04304390f, 0.06364623f, 0.21002664f, 0.09888248f, -0.95076048f, 
    0.26277718f, -0.48511204f, -1.15976620f, -0.03655577f, -0.02799342f, -0.74079454f, 0.19731387f, -0.33505401f, 
    -0.11860128f, 0.24457604f, 0.35249192f, 0.01591126f, -0.30609944f, 0.41672021f, -0.73668134f, -0.08106776f, 
    -0.18023449f, 0.19656548f, 0.14339438f, -0.10718393f, -0.19621839f, 0.03216400f, -0.01602674f, 0.00900404f, 
    -0.08038151f, -0.05255532f, 0.07420033f, -0.03936425f, -0.05284530f, 0.06552988f, 0.19427191f, -0.00848950f, 
    0.15602461f, -0.23807749f, -0.07068744f, 0.06910572f, -0.15516722f, 0.10792886f, -0.41986477f, -0.06561233f, 
    -0.04058893f, -0.11174047f, -0.12307380f, 0.03244783f, -0.17806911f, 0.05676686f, -0.04826263f, 0.00194543f, 
    0.38264838f, 0.19328941f, 0.13299520f, -0.45487204f, -0.11734335f, -0.06014824f, -0.03056276f, 0.20072705f, 
    -0.40173918f, 0.02636524f, -0.05368231f, 0.07167120f, 0.05892366f, -0.12502736f, -0.10472888f, 0.03341569f, 
    -0.07461519f, -0.27739963f, -0.39726534f, -0.00649462f, 0.06866120f, 0.01224222f, 0.04980025f, -0.07797851f, 
    0.13463967f, 0.06953136f, 0.19131714f, -0.08764052f, -0.07728928f, -0.34698525f, -0.11618342f, 0.08232481f, 
    0.04219644f, -0.02137156f, -0.01071815f, -0.31990978f, 0.03269934f, -0.02684269f, 0.22939566f, -0.05587792f, 
    0.03979776f, -0.00059264f, -0.76276368f, -0.18434539f, 0.03728355f, 0.07170923f, 0.14480700f, 0.09027746f, 
    0.54538763f, 0.03903756f, -0.06238274f, -0.14712037f, -0.07444148f, -0.45670643f, -0.09472187f, -0.29251671f, 
    0.28110754f, -0.79638648f, -0.28026342f, -0.63051075f, 0.02675389f, 0.00264837f, 0.12035336f, -0.18519680f, 
    -0.08152411f, 0.05979770f, 0.07876682f, -0.90847278f, -0.00602554f, -0.05046506f, -0.00151238f, -0.03149889f, 
    -0.48753843f, -0.06951886f, -0.59122342f, 0.02838519f, 0.05730993f, -0.54301649f, 0.03554910f, 0.25378805f, 
    0.35240972f, -0.24806504f, 0.37031779f, -0.23864356f, 0.03673216f, -0.26781988f, 0.16564773f, 0.08257104f, 
    0.09561194f, -0.10900903f, -0.82198882f, -0.06323965f, 0.21286671f, 0.06905454f, -0.15191385f, -0.51978487f, 
    0.11183660f, -0.37002406f, -0.57115936f, 0.11971678f, -0.25261849f, 0.01416211f, -0.29242936f, 0.24473977f, 
    -0.06422501f, 0.05094107f, 0.01325301f, -0.06980833f, -0.27565730f, -0.13256703f, 0.08371202f, -0.03759286f, 
    0.04859542f, 0.11488803f, -0.03032678f, 0.12993805f, -0.47206607f, -0.13392369f, -0.08759818f, -0.01739936f, 
    0.12191854f, -0.13565150f, 0.45257494f, 0.14572579f, -0.40360597f, -0.11126910f, -0.09566811f, -0.07652419f, 
    -0.47534108f, 0.01688594f, 0.05294241f, -0.20900014f, 0.05191387f, -0.07662009f, 0.09323779f, 0.12188204f, 
    0.23813890f, -0.10027446f, -0.04594456f, -0.33051351f, -0.03765262f, 0.00552724f, -0.17673185f, -0.04882128f, 
    0.06527245f, 0.08026251f, -0.06551757f, -0.03045332f, 0.17384335f, -0.05822427f, -0.01297349f, -0.00857479f, 
    0.02205258f, -0.02397731f, 0.17316969f, -0.29857957f, -0.07280689f, -0.24131756f, 0.34604955f, 0.02925710f, 
    0.07183660f, -0.07537436f, 0.03473186f, 0.13429381f, -0.05641621f, 0.05434088f, -0.16930355f, -0.04123516f, 
    -0.10239950f, -0.06635638f, 0.04363552f, 0.23648666f, 0.07756643f, 0.06503874f, 0.19676115f, 0.11850903f, 
    -0.29121447f, 0.00776005f, 0.07107230f, 0.27651817f, 0.05335563f, -0.21169606f, -0.18763123f, -0.10829191f, 
    -0.32537219f, -0.29596028f, 0.05326956f, 0.15101305f, 0.05136567f, 0.00641235f, 0.20389143f, -0.26188999f, 
    -0.00721712f, -0.27859464f, 0.05080191f, -0.15741953f, -0.25289381f, 0.03699483f, -0.04047105f, 0.19424661f, 
    -0.05249543f, 0.13743907f, 0.07050204f, 0.06672528f, 0.08413799f, 0.00846535f, 0.16045801f, 0.06419170f, 
    -0.40512514f, 0.17842339f, -0.08271042f, 0.06233040f, -0.07106455f, 0.01354883f, -0.08504932f, 0.09817958f, 
    0.05392728f, 0.25414801f, 0.16007620f, -0.10712297f, 0.03419843f, -0.19617029f, 0.15958275f, 0.10748615f, 
    0.01800928f, -0.26006058f, -0.21060185f, -0.24929613f, -0.02719397f, -0.00222230f, -0.00960505f, 0.08340182f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.19262822f, 0.04134170f, -0.15059821f, -0.07755085f, 0.14178686f, 0.08986015f, -0.01030402f, -0.26433691f, 
    -0.16951492f, 0.07253432f, 0.05783222f, 0.10403880f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
