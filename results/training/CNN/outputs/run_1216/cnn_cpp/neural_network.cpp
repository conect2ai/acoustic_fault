#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.04426542f, 0.42919064f, -0.22374119f, -0.53863305f, -0.26356465f, -0.30346891f, -0.29464331f, -0.26592863f, 
    0.19756824f, -0.12811299f, -0.15121016f, -0.15483469f, -0.23389180f, -0.15366915f, 0.19059388f, 0.03039555f, 
    -0.01919942f, 0.10721840f, -0.35833699f, -0.20863874f, 0.32360795f, 0.36265323f, 0.15998940f, 0.35677406f, 
    0.45574743f, 0.62692589f, -0.33051267f, -0.68662101f, -0.11667024f, 0.13670640f, 0.87754232f, 0.63113350f, 
    -0.44329447f, -0.59238482f, 0.18699105f, 0.18317991f, -0.20270155f, -0.31111863f, -0.23382443f, 0.16642684f, 
    -0.16213661f, 0.17286853f, 0.25775883f, 0.08493321f, -0.16774994f, 0.26595420f, -0.06457347f, -0.31946018f, 
    -0.11460773f, -0.01281872f, 0.40242994f, -0.01617857f, 0.14622726f, 0.44438756f, 0.39980841f, 0.25823644f, 
    0.08099104f, 0.17121013f, -0.02107450f, 0.11810845f, -0.05567996f, -0.09613609f, -0.05769392f, 0.00831835f, 
    0.20333765f, 0.06768122f, 0.15900466f, -0.00198515f, 0.08472713f, -0.03060109f, -0.19303820f, -0.20431867f, 
    -0.28172332f, -0.31521940f, -0.15070249f, -0.11241442f, -0.66051471f, -0.60565692f, -0.18406552f, -0.26912716f, 
    -0.41969860f, -0.32461306f, -0.35171825f, 0.01045631f, -0.02263531f, 0.01631948f, 0.15438944f, 0.07953440f, 
    0.18961458f, -0.40212935f, -0.25666484f, -0.01152073f, 0.15225616f, 0.13418923f, 0.19169888f, -0.22470039f, 
    -0.38059461f, 0.04976619f, -0.42950532f, -0.38226378f, 0.20185441f, 0.74608904f, 0.07863379f, -0.63788062f, 
    0.68395478f, 0.02219987f, 0.15622512f, -0.03359789f, -0.51853955f, -0.66173363f, -0.24288671f, -0.13462871f, 
    0.18532670f, -0.20921457f, -0.07390135f, 0.00241919f, 0.07328808f, -0.01655457f, 0.02757782f, 0.10387279f, 
    0.07767519f, -0.02212304f, 0.04171146f, 0.01451271f, -0.29434127f, -0.55175900f, -0.24975027f, -0.46935797f, 
    -0.89192247f, -0.74758548f, 0.32551330f, 0.06622010f, 0.22435006f, 0.57748544f, 0.36911264f, 0.17814790f, 
    0.10489660f, -0.01687430f, 0.21378870f, -0.13171072f, -0.14419876f, 0.06838053f, -0.11912739f, -0.11849641f, 
    -0.02644133f, -0.15644349f, -0.06853446f, -0.03148259f, -0.04903052f, -0.30399570f, -0.47219166f, 0.10891423f, 
    0.37630472f, 0.17081092f, 0.18221293f, -0.44210115f, -0.05374938f, 0.23348144f, -0.27717373f, 0.32909399f, 
    -0.17929344f, 0.04179141f, -0.13268739f, 0.54442787f, -0.26845086f, -0.07653666f, 0.10256970f, -0.33897975f, 
    -0.20473117f, 0.36624047f, 0.23923859f, -0.21243995f, -0.23616154f, 0.08329540f, 0.00898715f, -0.03309947f, 
    -0.27085128f, 0.35891369f, -0.02788788f, -0.21611455f, 0.38463286f, 0.69951618f, -0.58454752f, -0.04654079f, 
    -0.79499948f, 0.42812109f, -0.24382010f, -0.30235258f, 0.05754044f, -0.35678294f, -0.00870711f, 0.09084962f, 
    0.04729617f, 0.12227341f, -0.04929327f, -0.31521553f, 0.04056333f, -0.01265076f, 0.05765434f, 0.28815940f, 
    0.00534879f, 0.12949641f, -0.09020364f, 0.02497804f, -0.24985820f, -0.42630786f, -0.09330199f, 0.54675764f, 
    0.34151140f, -0.31347966f, -0.04939917f, -0.05571555f, 0.02755221f, 0.12697229f, 0.19556819f, -0.06730806f, 
    -0.14835055f, -0.34955162f, -0.09788925f, 0.03963424f, -0.09834772f, -0.29651055f, 0.25471878f, 0.25569472f, 
    0.29336828f, -0.27555776f, -0.21997055f, -0.16526492f, -0.13288526f, 0.20432344f, 0.80547434f, -0.27566129f, 
    0.00172406f, 0.56490982f, 0.31627622f, 0.13254790f, 0.32374609f, -0.12763555f, -0.18967728f, -0.03870963f, 
    -0.27833268f, 0.16525252f, -0.01434343f, -0.07103930f, -0.00861191f, 0.19567063f, -0.01860336f, -0.12310894f, 
    0.30402395f, 0.01218177f, -0.98646671f, -0.77282226f, 0.03193435f, 0.81000561f, 0.72104651f, 0.41770908f, 
    0.36311764f, -0.22683796f, -0.16770157f, 0.01612226f, -0.19557476f, 0.18149857f, 0.03245476f, -0.03807784f, 
    -0.37044340f, 0.05616784f, 0.02528459f, -0.18256655f, 0.07821564f, 0.26665172f, -0.02217990f, -0.10820325f, 
    0.03673649f, -0.01511859f, -0.23137207f, 0.15650511f, 0.32812557f, 0.25631452f, 0.33085760f, 0.25674108f, 
    -0.07057887f, -0.26407689f, 0.12633583f, 0.30740789f, 0.09660121f, 0.30563730f, -0.04348036f, -0.38951203f, 
    -0.18804453f, 0.45676470f, -0.31064928f, 0.23725307f, -0.03910928f, -0.16018821f, 0.07557566f, -0.01961779f, 
    0.07144345f, 0.26190168f, -0.02806342f, 0.03324990f, 0.83000278f, 0.39765671f, -0.07019725f, 0.12707348f, 
    -1.00683045f, -0.18195558f, -0.19663039f, 0.00116571f, 0.10059544f, 0.16477299f, 0.20182966f, -0.23397513f, 
    -0.13233094f, 0.42645004f, -0.33054033f, -0.18562515f, -0.15521173f, -0.04880895f, 0.34809521f, -0.10852049f, 
    0.18231475f, -0.00591104f, -0.11925818f, 0.14382967f, -0.00666028f, -0.42888907f, -0.43046847f, -0.45437422f, 
    0.02160313f, -0.29188827f, -0.39325857f, -0.40462020f, -0.52193952f, -0.56194228f, -0.74667603f, 0.53111327f, 
    -0.33100244f, 0.11086021f, 0.05872180f, 0.40324599f, -0.12297732f, 0.10202083f, -0.12614669f, -0.23045568f, 
    -0.33973229f, -0.09079629f, -0.23947254f, 0.19087766f, 0.18078414f, 0.14440091f, 0.68245417f, 0.94324636f, 
    -0.34603286f, 0.16231224f, -0.73551381f, -0.33096173f, 0.17394219f, -0.07205933f, -0.06502528f, 0.22293745f, 
    0.20847897f, 0.02166422f, 0.07590234f, -0.40952802f, -0.15086913f, -0.08954984f, 0.13554484f, 0.18267284f, 
    0.03510451f, -0.42830113f, -0.00396716f, -0.03600889f, -0.11048840f, -0.21487804f, -0.30206168f, -1.15453851f, 
    0.33106837f, 0.28540927f, -0.44015378f, 0.12756352f, -0.33444467f, -0.22008443f, 0.11774126f, 0.29057717f, 
    -0.03919780f, -0.52711314f, -0.46990827f, -0.18744074f, -0.35093766f, 0.25281149f, -0.03764115f, 0.24125719f, 
    -0.04872601f, 0.16781479f, 0.15873723f, -0.12673876f, 0.17542361f, -0.17864795f, -0.23409115f, -0.26617822f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.04810309f, 0.34419271f, -0.16170321f, -0.11743712f, -0.00539281f, 0.22704053f, 0.23992093f, 0.31754735f, 
    0.25444716f, -0.09319837f, 0.10211280f, -0.04381204f, 0.26425529f, 0.11582410f, 0.11629123f, -0.06195484f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.11920865f, 0.16877064f, 0.30676296f, 0.25568348f, 0.19296452f, 0.15231588f, -0.22339720f, -0.08354836f, 
    -0.08846010f, 0.14242186f, 0.04019006f, 0.10106798f, -0.12941727f, 0.04580703f, -0.10138245f, -0.23689640f, 
    -0.08411581f, -0.04461989f, -0.03153116f, 0.04601741f, 0.01304192f, -0.19813199f, -0.04983717f, -0.00668189f, 
    -0.06965448f, -0.08600280f, -0.11762644f, -0.04595573f, 0.05574259f, 0.01283076f, -0.00975579f, 0.01223742f, 
    -0.18453556f, -0.20056327f, -0.12904380f, -0.13816912f, 0.31535023f, 0.03023080f, -0.05913316f, 0.00842526f, 
    0.05802598f, 0.08417691f, 0.02686177f, 0.03176212f, 0.03731487f, -0.23712541f, -0.07175218f, 0.04943233f, 
    0.07990883f, 0.20286745f, -0.10660116f, 0.18503824f, -0.01321060f, -0.06629632f, -0.12889661f, -0.10781618f, 
    -0.10029668f, 0.06584006f, 0.04221629f, -0.04044415f, -0.16300444f, -0.16665851f, -0.13842578f, 0.13500139f, 
    0.14652012f, 0.22768249f, 0.09399520f, 0.15130298f, 0.01788021f, 0.01616086f, 0.01998988f, -0.09635695f, 
    0.02424845f, -0.15202551f, -0.14050570f, 0.05777863f, 0.08138719f, -0.10386978f, 0.06620100f, 0.10366040f, 
    0.07884713f, -0.04369756f, 0.07554123f, 0.07108968f, 0.34164101f, 0.22206028f, -0.35759902f, -0.09076196f, 
    0.01249172f, -0.23648998f, 0.07062607f, -0.08229395f, 0.11125374f, 0.04252200f, 0.02367169f, 0.05602911f, 
    -0.10883049f, -0.20215143f, 0.07852396f, 0.07423701f, 0.08780760f, 0.10159107f, 0.01581485f, 0.07094193f, 
    0.05465668f, 0.02083232f, -0.06140285f, 0.09452590f, -0.12664695f, -0.06270672f, -0.27020308f, -0.12025117f, 
    -0.04046523f, -0.12389884f, -0.01707079f, 0.00159081f, 0.06852978f, 0.06321319f, 0.03006916f, -0.07965947f, 
    0.09521268f, 0.04161945f, -0.18585439f, -0.24518307f, -0.11011686f, -0.00685095f, 0.05572871f, 0.11294997f, 
    0.09573874f, 0.00045224f, -0.01913465f, -0.00426193f, -0.15684590f, -0.02262754f, 0.02155454f, -0.07838494f, 
    0.16578592f, 0.02425822f, -0.12631838f, 0.04108723f, 0.10545795f, 0.02933480f, 0.04588441f, 0.11792741f, 
    -0.21053322f, -0.11594532f, 0.11924455f, 0.10307506f, 0.11908828f, -0.02308133f, -0.17642409f, -0.04906183f, 
    -0.00309227f, -0.07125098f, 0.16884427f, -0.02343453f, 0.26089370f, 0.14244531f, 0.01393471f, -0.22390077f, 
    0.13326594f, 0.17832319f, 0.07295467f, -0.01541369f, 0.15575364f, 0.06084949f, 0.03496404f, 0.09786805f, 
    -0.14119191f, -0.24438542f, -0.05158377f, -0.00598275f, -0.00889981f, 0.10355788f, -0.12998140f, -0.08313472f, 
    0.00381651f, -0.06443870f, 0.04495730f, -0.08801410f, 0.04488592f, 0.27822170f, 0.19121337f, -0.00610042f, 
    0.05202048f, -0.07180104f, -0.14617692f, 0.12841199f, 0.03549560f, 0.09699895f, 0.06562695f, -0.16267578f, 
    0.08741023f, -0.07147454f, -0.17630954f, -0.14394377f, -0.00192432f, -0.02705208f, 0.03605491f, -0.12910099f, 
    0.06887099f, -0.05818182f, 0.06117805f, 0.09481017f, -0.14987791f, 0.10699644f, 0.21709055f, -0.14596687f, 
    -0.01438880f, -0.12615536f, 0.10981397f, 0.02584827f, 0.05055470f, 0.08041425f, -0.08211371f, -0.08625419f, 
    -0.04991767f, -0.05990317f, 0.00019143f, -0.01336881f, -0.09648621f, -0.04495017f, -0.04855795f, -0.03159237f, 
    -0.13860458f, -0.06821974f, -0.00795993f, -0.02222543f, 0.19501995f, -0.03134894f, -0.03624195f, -0.14501603f, 
    0.15526967f, 0.09853927f, 0.00552691f, 0.07153484f, -0.02595163f, 0.11021694f, -0.09185440f, -0.00098590f, 
    -0.59918499f, 0.11490154f, -0.03744541f, 0.12921652f, 0.04180941f, 0.32766768f, 0.04918350f, 0.02707838f, 
    -0.05819440f, -0.07552535f, 0.01578535f, -0.07190092f, -0.11043797f, -0.15610415f, -0.14984195f, -0.11327984f, 
    0.09855308f, -0.06141429f, -0.00435610f, 0.16133402f, 0.00347766f, 0.03927521f, 0.11282690f, -0.03580697f, 
    -0.10908776f, -0.36355013f, 0.19844261f, 0.12410245f, 0.01072256f, 0.02214786f, -0.04198654f, 0.09942234f, 
    -0.13142982f, 0.05295269f, -0.10355028f, -0.05261802f, 0.19347551f, 0.12124346f, 0.14330548f, 0.05565495f, 
    0.09927134f, 0.09531617f, -0.02585909f, -0.09861557f, -0.01366305f, 0.08599661f, 0.00950274f, 0.07196467f, 
    0.03343773f, 0.11946672f, 0.00531159f, 0.06932054f, 0.02921426f, -0.11910456f, -0.12879665f, 0.03216136f, 
    0.03523119f, -0.04619958f, 0.02365750f, 0.02566594f, 0.03788140f, -0.02873221f, 0.03321699f, -0.03408771f, 
    -0.04120806f, 0.04316874f, -0.11133038f, -0.10451066f, 0.30087164f, 0.05363536f, 0.20563439f, -0.01999356f, 
    -0.08824117f, 0.02510639f, 0.22206578f, -0.03727271f, 0.09915863f, -0.09249253f, -0.12968612f, -0.01389289f, 
    0.09452550f, -0.02854122f, 0.04898874f, 0.02981694f, -0.07525382f, -0.17067078f, -0.05290350f, 0.00685231f, 
    0.06615520f, -0.10398397f, -0.04954525f, 0.02242995f, 0.05720538f, -0.05988334f, 0.09369636f, -0.11358073f, 
    0.42606309f, -0.03032137f, -0.39306563f, 0.23712422f, -0.01321138f, -0.00415502f, 0.08940122f, -0.07473028f, 
    -0.03532972f, 0.15566784f, -0.08383211f, 0.00747741f, 0.16441524f, 0.14297150f, -0.15121031f, 0.06603578f, 
    0.03714661f, 0.15270574f, -0.10630607f, -0.07481317f, 0.03278869f, 0.04948819f, 0.05604381f, 0.00436763f, 
    0.36435628f, -0.12937535f, -0.41198662f, 0.06062845f, -0.01541939f, 0.06146703f, 0.19941360f, 0.06801280f, 
    0.03329372f, 0.09003326f, -0.17039712f, -0.12853041f, -0.08132581f, 0.03876222f, 0.11228053f, 0.07990916f, 
    -0.18828741f, 0.01625041f, 0.18414596f, 0.12525603f, -0.05958379f, -0.03433414f, 0.00102346f, -0.01366033f, 
    -0.14820845f, 0.19277947f, 0.08597296f, 0.18333964f, 0.13106969f, 0.19049039f, 0.04042820f, 0.06573941f, 
    -0.05280640f, 0.04727560f, 0.06416913f, 0.11367078f, 0.13818388f, -0.18496986f, 0.09083062f, 0.19728772f, 
    -0.10394664f, 0.10437712f, -0.02089393f, -0.10168900f, 0.07228103f, -0.08224033f, 0.08053458f, 0.15271750f, 
    -0.22993462f, -0.05339434f, -0.08083810f, -0.12531225f, -0.07092677f, -0.04358779f, -0.07629699f, -0.07659411f, 
    0.06290894f, -0.09730396f, 0.11364682f, 0.18084125f, 0.03778714f, 0.26396027f, -0.00210018f, 0.17568439f, 
    0.12031983f, 0.13537365f, 0.15466110f, -0.05618142f, 0.01532943f, -0.13668850f, 0.08630461f, 0.04189382f, 
    0.25134286f, -0.33222947f, -0.31907991f, -0.05356540f, 0.01003650f, -0.08494490f, 0.09847959f, -0.11051922f, 
    -0.01149347f, -0.04656598f, 0.13147490f, 0.00983871f, 0.15878493f, 0.23931018f, 0.00138284f, 0.07149243f, 
    0.11606809f, 0.08251954f, 0.04918065f, 0.09318116f, 0.08413090f, 0.01106630f, 0.02347613f, -0.01007321f, 
    -0.18502550f, 0.15157947f, -0.01944217f, -0.07995777f, -0.01973794f, 0.11393414f, -0.15539114f, 0.04476073f, 
    0.11200832f, -0.00647436f, 0.01264378f, 0.01140570f, 0.25037485f, 0.10555488f, 0.09787549f, -0.00277301f, 
    0.15359615f, 0.08522046f, -0.03101576f, 0.18046999f, 0.06352123f, -0.06191550f, 0.00133081f, 0.00662170f, 
    -0.09750059f, -0.08762429f, 0.07961014f, 0.11554643f, 0.04433403f, 0.15149927f, -0.04339544f, -0.00266925f, 
    0.02424051f, 0.02510829f, 0.00428892f, 0.15425685f, -0.06271821f, 0.20048630f, -0.15132302f, 0.05615905f, 
    -0.12442970f, -0.19775613f, -0.10264561f, 0.04270195f, -0.12733608f, 0.04732107f, 0.02939779f, -0.10110777f, 
    0.33490220f, -0.36096027f, 0.15060984f, -0.07741357f, -0.21771093f, -0.09223311f, 0.03173435f, -0.10153137f, 
    -0.00116766f, 0.11679299f, 0.12813991f, 0.12108670f, -0.11260500f, -0.02834493f, -0.24699770f, -0.21398394f, 
    0.08793238f, -0.04507856f, 0.00285322f, -0.05314907f, -0.09199560f, 0.05636334f, -0.03024747f, 0.14946213f, 
    -0.41528818f, -0.05560468f, 0.21096392f, -0.13333295f, 0.11235446f, 0.10260069f, -0.26167902f, 0.15871850f, 
    0.05545653f, 0.04563057f, -0.00157636f, -0.05369850f, 0.11567836f, 0.17584687f, 0.16370963f, 0.13940215f, 
    -0.07621904f, -0.08451991f, 0.13001788f, 0.02817166f, -0.05978124f, 0.03321079f, -0.01464033f, 0.11711529f, 
    -0.45089820f, -0.12681656f, 0.14806908f, -0.15146783f, -0.00351062f, -0.00887047f, 0.10768094f, -0.22096145f, 
    -0.13589716f, -0.06789910f, 0.00982144f, 0.05091240f, -0.01552669f, 0.05906136f, -0.05013666f, 0.21306503f, 
    0.17522524f, -0.06820537f, 0.04658225f, -0.13637835f, 0.04774437f, 0.02046290f, -0.17586774f, 0.00704632f, 
    -0.03462134f, 0.00481601f, 0.03137529f, -0.10174362f, 0.12764217f, 0.22262013f, 0.07183088f, 0.03927503f, 
    -0.03232045f, 0.03790822f, -0.01370693f, 0.01243090f, 0.19960202f, 0.13613170f, -0.06768411f, 0.19495198f, 
    -0.04610410f, 0.00114069f, 0.02518394f, 0.07904387f, 0.02254882f, 0.03478283f, 0.00908086f, 0.05972368f, 
    -0.04703346f, 0.06574520f, -0.08819882f, 0.03853545f, -0.02238692f, -0.03844085f, -0.06059168f, -0.15647559f, 
    -0.01905831f, -0.23309664f, -0.13136552f, -0.17863217f, 0.29653296f, 0.32562000f, 0.00988416f, -0.08051880f, 
    0.11345759f, -0.03033178f, 0.06755010f, -0.05324381f, 0.00834092f, -0.15945987f, 0.07894985f, -0.04795655f, 
    0.24495828f, -0.05643115f, -0.35129738f, 0.04721444f, 0.00199233f, -0.08810081f, 0.15185285f, -0.00419757f, 
    -0.16585532f, -0.00223686f, -0.13244019f, -0.00559300f, -0.12196391f, -0.03655891f, -0.17529625f, -0.22326632f, 
    0.05063845f, 0.07059685f, 0.07053508f, -0.04187353f, 0.05380048f, 0.03473201f, 0.02475510f, -0.09986165f, 
    0.12702465f, 0.08281932f, 0.15205361f, 0.07084517f, 0.04747831f, -0.11794994f, 0.04408256f, 0.00756997f, 
    0.11370856f, -0.02834467f, 0.15784477f, 0.05081512f, 0.27700928f, -0.01178449f, -0.15806957f, -0.05984881f, 
    -0.06135906f, -0.02928622f, 0.16124345f, 0.01777706f, 0.05209106f, -0.00545510f, 0.00940004f, 0.09625658f, 
    0.17338333f, -0.33930719f, 0.23456939f, 0.13920844f, -0.05788658f, 0.16542545f, 0.07255869f, 0.01811994f, 
    0.01616211f, 0.10235684f, 0.00434493f, 0.18623151f, -0.23954694f, -0.01889672f, -0.11565989f, 0.13344249f, 
    -0.11553571f, -0.03625751f, -0.00425061f, -0.05596263f, 0.05283879f, 0.15645310f, 0.04037452f, 0.05168378f, 
    0.26861733f, -0.02285373f, -0.09587174f, 0.03255376f, 0.00049842f, -0.10986815f, 0.02019546f, -0.04056988f, 
    0.13128735f, 0.11466060f, 0.00997985f, 0.00867331f, 0.12831879f, 0.19018391f, 0.07803954f, 0.04541993f, 
    0.00412202f, -0.01749132f, -0.13224638f, -0.14649075f, -0.04761542f, 0.03150788f, -0.15803888f, -0.03240936f, 
    0.20156828f, -0.05841500f, 0.50339437f, 0.00539398f, 0.02701937f, 0.02995361f, -0.01328466f, 0.03844565f, 
    0.07432631f, -0.01257741f, 0.09777293f, -0.07715914f, 0.10452280f, 0.13161854f, 0.14308012f, -0.21897961f, 
    0.00350515f, 0.09687288f, 0.06397448f, -0.13233569f, -0.03148779f, -0.01705166f, 0.01428855f, 0.08953039f, 
    0.04219058f, -0.13426276f, 0.31324849f, 0.20573549f, 0.08455296f, -0.01725569f, 0.04121533f, -0.01858264f, 
    -0.20642218f, -0.22136308f, -0.05783751f, 0.04719861f, -0.15956660f, 0.18006366f, 0.15525936f, -0.03193153f, 
    0.06794062f, 0.07702668f, -0.10979006f, 0.09313127f, 0.03970275f, 0.09524072f, -0.04980800f, -0.09088939f, 
    -0.20822567f, -0.16557319f, 0.00067407f, 0.10795817f, 0.13316642f, 0.08973745f, -0.04998092f, 0.10753302f, 
    -0.02143793f, 0.03522499f, -0.04000659f, 0.13763604f, 0.04681011f, 0.04132130f, 0.25070286f, -0.21187668f, 
    -0.08357733f, -0.04112009f, -0.10105836f, 0.21371281f, 0.08912943f, 0.02582372f, 0.06485079f, 0.02607492f, 
    0.00583420f, 0.02706916f, -0.02987548f, -0.08034808f, -0.17357688f, -0.23640780f, -0.15012363f, -0.15499914f, 
    -0.11247035f, -0.13435324f, -0.07829135f, -0.07357809f, 0.01727801f, 0.00369945f, 0.09540088f, -0.01613184f, 
    0.02446489f, 0.12495505f, 0.05918749f, 0.00605547f, 0.00984130f, -0.18697007f, 0.06744743f, -0.01955303f, 
    -0.13684584f, 0.30252627f, -0.17090078f, -0.06745744f, 0.00757429f, -0.02166999f, -0.02922076f, 0.00133698f, 
    -0.09344165f, 0.06287938f, 0.00147894f, -0.09372244f, -0.07417629f, -0.00327560f, -0.07729995f, 0.10468830f, 
    -0.13684832f, 0.09470730f, 0.11506271f, 0.06628826f, 0.14470042f, -0.04174916f, 0.05831988f, 0.08347391f, 
    0.20339075f, 0.05352838f, -0.14184369f, 0.13249366f, -0.13923895f, -0.16581476f, -0.01967460f, 0.04070808f, 
    -0.05081467f, -0.05955170f, -0.01685057f, 0.02952476f, 0.06649972f, 0.15473416f, -0.15351431f, -0.16494094f, 
    -0.02714740f, -0.00911083f, 0.15551174f, 0.13713993f, 0.10305779f, 0.09160650f, 0.06728210f, 0.14673255f, 
    0.03179937f, 0.10755762f, -0.12447987f, 0.27034473f, 0.01341699f, 0.02271293f, 0.01585360f, -0.11692362f, 
    0.04819442f, 0.07757454f, -0.03439081f, 0.05130925f, -0.13156478f, -0.04017605f, -0.15734050f, -0.32618085f, 
    -0.16110179f, -0.01086136f, -0.02671168f, 0.04741905f, 0.22931509f, -0.11885089f, 0.18742828f, 0.08704383f, 
    0.47556508f, 0.00800521f, 0.02405680f, -0.05693818f, -0.00651616f, -0.14907281f, 0.16640608f, 0.09832451f, 
    0.11719822f, -0.04856048f, 0.05855186f, -0.06630740f, 0.02133859f, 0.02800406f, 0.22685206f, -0.01708403f, 
    -0.01768629f, -0.12955722f, -0.07132060f, -0.05397105f, 0.17406961f, 0.01872234f, -0.05766477f, 0.02344726f, 
    0.06167882f, 0.16644514f, 0.22588201f, -0.14600869f, 0.01237472f, -0.04603839f, -0.28828669f, 0.07661864f, 
    0.01676762f, 0.06561364f, 0.14379220f, 0.04153507f, -0.23511729f, -0.00768989f, 0.01969217f, -0.18568659f, 
    0.10493075f, 0.06283847f, -0.00051526f, -0.11160685f, 0.08143046f, -0.06330197f, 0.04137651f, 0.09176296f, 
    0.19110040f, -0.12257595f, 0.19358279f, -0.03129351f, 0.11560037f, -0.00064650f, -0.22760256f, -0.00250079f, 
    0.07683866f, -0.04506670f, 0.01366767f, 0.07180502f, -0.31209007f, 0.14029926f, 0.01237637f, 0.13703792f, 
    0.09779397f, -0.01865216f, -0.13029104f, 0.16124825f, -0.07200757f, -0.03799799f, -0.00208332f, -0.01850412f, 
    -0.06792578f, -0.13820185f, -0.12638871f, 0.11066825f, 0.11307932f, -0.03170083f, 0.02563572f, 0.04698340f, 
    0.01178181f, -0.07534743f, -0.12539826f, -0.02109876f, -0.28152144f, 0.06847750f, -0.10358074f, 0.07707534f, 
    -0.14059784f, -0.04895235f, 0.12574914f, -0.09357707f, -0.08970956f, 0.19805735f, 0.16680574f, 0.05310181f, 
    -0.12334109f, -0.08450985f, -0.09319474f, -0.18968612f, 0.03816534f, -0.04933810f, 0.03749975f, -0.05651051f, 
    -0.00897235f, -0.02320398f, 0.03046755f, 0.17057031f, -0.08688687f, -0.22740376f, -0.11401679f, 0.09062171f, 
    0.08670946f, -0.16099072f, 0.10202022f, 0.05649193f, 0.02680769f, 0.05986114f, 0.10579530f, 0.11810593f, 
    0.04898070f, 0.13147280f, 0.50713241f, 0.03847892f, -0.20898774f, 0.08563150f, 0.11074552f, 0.14773302f, 
    -0.00491611f, 0.06994809f, 0.02817192f, 0.03032915f, -0.01110149f, -0.12324704f, -0.00047757f, 0.10866738f, 
    -0.05726089f, -0.06769551f, 0.03730898f, -0.02452142f, -0.05814857f, 0.11474951f, -0.02126795f, 0.11879805f, 
    0.04462703f, 0.14168601f, 0.02774676f, -0.16235857f, 0.02075518f, 0.10200716f, -0.04147146f, -0.07647943f, 
    -0.01589493f, 0.06373592f, -0.20117614f, -0.13730913f, -0.23484421f, 0.10727522f, 0.25275585f, 0.23622036f, 
    -0.03436782f, 0.25547495f, -0.05661046f, 0.03922166f, 0.01493303f, -0.11797788f, 0.10824838f, -0.07917634f, 
    0.01188925f, 0.01961538f, -0.01676370f, -0.13725783f, 0.02648041f, 0.05129950f, -0.09215579f, -0.04690542f, 
    0.06119656f, -0.10607336f, 0.04044778f, -0.00696249f, -0.00201971f, -0.08991216f, -0.07747189f, -0.08315503f, 
    0.00883834f, 0.00018301f, 0.08246948f, -0.03487496f, -0.05628780f, -0.01224104f, 0.05880394f, 0.05375392f, 
    0.05938676f, 0.04301596f, -0.27257854f, -0.09745470f, -0.02301420f, 0.08655482f, -0.12245975f, -0.15777294f, 
    -0.01492088f, 0.04858691f, -0.04673653f, 0.13929814f, 0.13265958f, -0.01921182f, -0.04557738f, -0.25943762f, 
    -0.14905673f, -0.03496990f, 0.06672950f, -0.02067961f, -0.00097098f, -0.00494510f, 0.03586318f, -0.03768095f, 
    -0.51943302f, 0.03449937f, 0.14133666f, 0.21654606f, -0.04805268f, 0.00091393f, -0.00615358f, 0.01712563f, 
    0.03649740f, -0.07444622f, -0.01370341f, 0.03570612f, 0.06355413f, -0.15435752f, -0.13415542f, 0.20634037f, 
    -0.06791388f, -0.01655699f, 0.00961361f, 0.20387170f, -0.00727698f, 0.01966765f, -0.09282073f, -0.02741401f, 
    -0.39478758f, 0.32596526f, 0.17868993f, 0.08151694f, -0.14168663f, -0.11925087f, -0.04588497f, 0.01802811f, 
    -0.04194911f, 0.01008133f, 0.05481815f, 0.02925813f, 0.36252245f, -0.06772251f, -0.03367454f, -0.01037843f, 
    0.11999150f, 0.03426732f, 0.09632324f, 0.11784200f, -0.03439330f, -0.01349630f, -0.06206746f, 0.24965176f, 
    -0.07298061f, 0.12134705f, -0.19111040f, 0.28084213f, 0.01945708f, 0.06434527f, 0.09477723f, 0.09128990f, 
    -0.24996239f, -0.24014650f, -0.20091516f, -0.23432179f, -0.08012045f, 0.08074119f, 0.21334223f, 0.03967585f, 
    -0.13054894f, -0.12228218f, -0.16088113f, -0.01130790f, 0.04519297f, 0.09279504f, 0.01623360f, 0.21178521f, 
    0.10103394f, -0.19528271f, -0.02083472f, -0.12730385f, -0.03520063f, 0.02693225f, -0.00832633f, -0.14434119f, 
    0.01066775f, 0.27281210f, 0.24528734f, 0.20909530f, -0.08173905f, -0.15066794f, 0.13020961f, 0.05756509f, 
    0.09449940f, 0.00184765f, -0.00662095f, 0.00506997f, 0.15367259f, 0.14951813f, 0.16563660f, 0.08051241f, 
    0.14662258f, 0.29629549f, 0.39957726f, 0.26170287f, 0.21554777f, 0.12311089f, -0.05640095f, 0.21497439f, 
    -0.02398140f, -0.06699855f, -0.02704499f, -0.10708646f, 0.35180193f, -0.15137735f, 0.09834450f, 0.04414301f, 
    -0.02926820f, -0.20038378f, -0.03159230f, -0.13848138f, 0.20547198f, 0.00324616f, 0.04686876f, 0.27032194f, 
    -0.15483207f, 0.16595446f, -0.13040808f, -0.12344316f, 0.08469260f, 0.01394769f, -0.18452393f, -0.06570423f, 
    -0.10265996f, 0.12136382f, -0.34120449f, -0.11411779f, -0.08092122f, 0.01110305f, 0.21714373f, 0.16067462f, 
    -0.15807940f, 0.05561996f, -0.04343336f, 0.08728435f, 0.06814956f, -0.15812090f, -0.05759045f, -0.16131383f, 
    -0.22722895f, 0.11143189f, -0.20510523f, -0.21472113f, -0.02067054f, -0.15290309f, -0.09921733f, -0.09649315f, 
    -0.17076181f, 0.07922646f, -0.17523497f, -0.28467479f, 0.36208811f, 0.03469145f, 0.16292949f, -0.39573780f, 
    -0.40147007f, 0.13682978f, -0.20838457f, -0.34081960f, 0.10017631f, 0.02128054f, -0.23126841f, -0.20223318f, 
    0.17156999f, 0.27741408f, 0.24137864f, -0.00441693f, 0.08822952f, 0.22380887f, -0.25070849f, -0.02091963f, 
    0.07199564f, 0.15219782f, 0.01697367f, -0.03175796f, -0.10075989f, -0.30897689f, -0.03655287f, -0.25376874f, 
    -0.15222426f, 0.08296337f, -0.07994309f, -0.40509042f, -0.14129543f, 0.09470877f, -0.17180587f, -0.18375373f, 
    -0.09686755f, -0.05453928f, -0.09397329f, 0.12549390f, -0.02225340f, 0.07386798f, -0.03398395f, -0.11282796f, 
    -0.28273645f, 0.02631911f, -0.15454097f, -0.04687588f, 0.26685253f, 0.05864704f, 0.12080282f, 0.38899586f, 
    0.04185989f, 0.07824039f, 0.09404442f, 0.07527803f, 0.06899289f, -0.10276472f, -0.10141736f, 0.10414135f, 
    -0.02654072f, 0.09819648f, -0.05079481f, 0.22396198f, -0.00622706f, 0.09985138f, 0.19806546f, 0.06339216f, 
    0.16430894f, -0.02215070f, 0.13766409f, 0.23970915f, 0.10004492f, -0.20651528f, 0.02118931f, 0.10546292f, 
    0.13896111f, 0.03867279f, 0.11933073f, -0.01621629f, 0.16335016f, 0.01312102f, -0.01955196f, 0.18205959f, 
    -0.12393715f, -0.09100766f, -0.10863919f, 0.00920677f, 0.05738015f, 0.14590356f, 0.08441951f, -0.03030952f, 
    -0.03189562f, 0.03104652f, 0.11920237f, 0.13712671f, 0.16935576f, -0.03270946f, -0.04712227f, 0.14055334f, 
    -0.05434886f, -0.07366685f, 0.09846128f, -0.10185406f, 0.07730922f, -0.03339966f, -0.14403786f, 0.01755203f, 
    -0.12712269f, -0.11512177f, -0.07341978f, -0.03616077f, -0.05765631f, -0.02482525f, -0.20723240f, -0.22724701f, 
    -0.06362953f, -0.16393046f, -0.20390512f, -0.26433581f, 0.24345097f, 0.18548837f, -0.12171116f, -0.22247644f, 
    0.07296082f, -0.12042340f, -0.08365063f, 0.06405521f, -0.08489641f, -0.14273825f, -0.11031778f, -0.19295254f, 
    -0.02065849f, -0.16898566f, -0.19853510f, -0.07764594f, -0.13130380f, 0.03274799f, 0.13106647f, 0.04463941f, 
    -0.19680379f, -0.10517671f, -0.05166298f, -0.07987089f, -0.23603113f, 0.00389854f, -0.20731951f, -0.19297071f, 
    -0.00351437f, 0.07578424f, -0.02591607f, 0.01053871f, -0.05516903f, 0.02713625f, -0.08099822f, -0.05119371f, 
    -0.05348513f, -0.03052728f, 0.20177765f, 0.03716231f, 0.07291406f, 0.01253105f, 0.03690739f, 0.12891982f, 
    0.13036217f, -0.07343432f, 0.05223581f, -0.14522414f, 0.21987090f, 0.10821993f, -0.15329030f, -0.07179141f, 
    -0.01429619f, 0.08756258f, 0.04937527f, 0.17022520f, 0.12550178f, 0.00399358f, -0.05441852f, 0.05904210f, 
    0.02060501f, -0.12671310f, 0.10714263f, 0.08731598f, -0.01638062f, 0.08131141f, 0.03745177f, -0.05889145f, 
    0.20606676f, 0.09641849f, -0.02262571f, 0.12041203f, -0.18720159f, -0.01346636f, -0.05477899f, 0.06029754f, 
    -0.27544752f, -0.08382179f, -0.19593355f, -0.16340858f, 0.12492159f, -0.01298839f, 0.21122791f, 0.15764081f, 
    -0.00754899f, -0.15395662f, -0.03704471f, 0.06670371f, -0.08005387f, -0.14959334f, -0.11211007f, -0.03482064f, 
    0.06557928f, -0.07770943f, -0.10502554f, -0.08787421f, -0.13315718f, 0.03360518f, -0.01385328f, -0.10801046f, 
    -0.04288523f, -0.11416575f, -0.13909706f, -0.15134171f, -0.04156594f, -0.01727636f, -0.09907952f, 0.21651931f, 
    -0.30367914f, 0.04561580f, 0.13132028f, 0.11375039f, -0.00782732f, 0.11376787f, -0.14528462f, 0.01365006f, 
    0.04288841f, -0.07453554f, 0.01772559f, -0.03943651f, 0.11244816f, 0.05839839f, -0.04837945f, -0.16998674f, 
    0.00789234f, 0.12256642f, 0.15676874f, 0.01219563f, -0.03964229f, 0.00995050f, -0.04819537f, 0.08335637f, 
    -0.39314038f, 0.11028291f, 0.08137650f, 0.11265455f, -0.10690338f, 0.00169786f, -0.10564768f, -0.13363442f, 
    -0.16151285f, -0.22414456f, -0.16021252f, -0.03258387f, -0.20419951f, 0.26999906f, 0.07813798f, -0.13417378f, 
    -0.00148881f, -0.03715831f, -0.03664979f, 0.24794699f, -0.05031374f, 0.11364495f, -0.15307638f, -0.22806248f, 
    -0.04615620f, -0.02007757f, 0.02632882f, -0.07339447f, 0.00951120f, -0.04484858f, -0.02910742f, 0.06762003f, 
    0.02797229f, 0.02579165f, -0.06647990f, 0.02758284f, -0.02170902f, 0.01202100f, -0.01066996f, 0.02077175f, 
    -0.01592042f, -0.05776316f, 0.05663223f, -0.03316059f, 0.06406179f, -0.04992317f, 0.01736620f, -0.05568317f, 
    0.02288438f, 0.04984471f, -0.00108127f, -0.06517921f, -0.06653618f, 0.00208621f, 0.06803492f, 0.02528602f, 
    0.00153879f, -0.04264429f, -0.01699527f, -0.04301807f, -0.01949030f, 0.04640883f, 0.05789994f, 0.04369820f, 
    -0.05556584f, -0.02637639f, 0.02323329f, 0.02791480f, -0.01217666f, -0.01326143f, -0.01484924f, -0.05262572f, 
    -0.03513925f, -0.01883984f, 0.00738147f, -0.06451713f, 0.05177432f, -0.05355706f, -0.04786399f, -0.01197027f, 
    -0.06678338f, 0.00659634f, 0.02069364f, -0.01792879f, 0.02828744f, 0.06134941f, 0.01399789f, -0.05666006f, 
    0.03018822f, -0.05778105f, -0.07292908f, -0.06744102f, -0.00198458f, -0.07096499f, 0.01572447f, -0.02391160f, 
    0.04381719f, 0.01191485f, -0.01507116f, -0.00075683f, -0.05505103f, 0.04009649f, 0.01336082f, -0.06323285f, 
    -0.06216152f, -0.02033091f, -0.01235108f, -0.06304279f, -0.07022579f, -0.02682983f, 0.00252068f, 0.02005398f, 
    0.01034265f, -0.01269798f, 0.01686936f, 0.00588527f, -0.05208064f, 0.02620606f, -0.05843192f, -0.00367699f, 
    -0.04738218f, -0.05042493f, 0.00535820f, 0.03987102f, 0.03999593f, -0.05456665f, -0.00956956f, 0.05223948f, 
    -0.06472335f, 0.03646075f, 0.04368890f, -0.06148895f, -0.04186087f, 0.04658242f, -0.07450272f, -0.01186845f, 
    0.04682498f, -0.01296182f, -0.02585583f, 0.03597039f, -0.03031109f, -0.02553998f, -0.01920449f, -0.06727560f, 
    -0.05380728f, 0.02502029f, 0.00779084f, -0.02541463f, -0.02543416f, -0.02616229f, 0.06201017f, -0.02018925f, 
    -0.00615938f, 0.02405171f, 0.04482721f, 0.02938505f, -0.00213790f, 0.01113302f, 0.03525630f, -0.03858395f, 
    -0.03515850f, -0.06538967f, -0.05972668f, 0.06632107f, -0.04811503f, 0.02543789f, -0.05181701f, -0.07294210f, 
    0.00422396f, -0.03864115f, -0.07415323f, -0.07296786f, -0.03880016f, 0.00463278f, 0.03230394f, 0.00491356f, 
    0.06159008f, -0.03728384f, -0.05867089f, -0.07644098f, -0.06961373f, -0.03181877f, 0.03856034f, -0.07499821f, 
    -0.07449277f, -0.07560857f, -0.01653790f, -0.02701738f, -0.00864494f, 0.00987726f, -0.02736653f, 0.05920926f, 
    -0.04787837f, -0.03634057f, 0.02239992f, -0.05986704f, 0.06074117f, -0.01369073f, -0.01196667f, -0.05862997f, 
    -0.03620041f, 0.02592189f, 0.02660622f, 0.04465633f, 0.03070701f, -0.03088368f, 0.04085157f, 0.01565401f, 
    0.06979076f, -0.02811773f, 0.05688762f, 0.04461265f, 0.00326199f, 0.06525332f, -0.06676257f, -0.01422744f, 
    -0.08671235f, 0.04098260f, -0.05259282f, 0.04793623f, -0.08309678f, -0.00849061f, -0.05231509f, -0.06548940f, 
    0.02836624f, -0.06111866f, -0.06753705f, 0.02876932f, -0.03988853f, 0.03563095f, -0.03194869f, 0.03839963f, 
    -0.08733243f, -0.01444961f, -0.04662277f, 0.03009518f, -0.04808238f, -0.05893616f, -0.07110924f, 0.04859469f, 
    0.01646897f, -0.02578866f, -0.02863631f, -0.04089997f, -0.06605859f, -0.03348413f, 0.03545775f, 0.01554484f, 
    0.03976317f, 0.01531854f, 0.03439652f, 0.00598811f, -0.00751650f, -0.00907727f, -0.07647191f, 0.02474885f, 
    0.04197837f, 0.00419238f, 0.00660611f, -0.00150841f, -0.03987326f, 0.05655336f, 0.02769250f, 0.05808860f, 
    0.01793106f, 0.06424920f, 0.01623462f, 0.00190695f, -0.03331880f, 0.05533562f, -0.02481515f, 0.00242539f, 
    -0.02779999f, -0.00543266f, -0.03767098f, 0.03244263f, -0.03758496f, -0.01751572f, 0.02294134f, -0.06969133f, 
    -0.04622149f, -0.04039730f, 0.06247675f, 0.05589338f, -0.01269241f, 0.01367443f, 0.04653344f, 0.04315394f, 
    -0.07704569f, 0.04852154f, -0.01054909f, -0.02027862f, 0.00517904f, -0.03665156f, -0.02793072f, -0.07525594f, 
    -0.04099545f, -0.06306816f, 0.03615158f, 0.00736678f, -0.08087674f, -0.03002801f, 0.01756053f, -0.02689261f, 
    -0.06059778f, -0.05192211f, 0.01512471f, -0.04096900f, 0.00755959f, 0.04211134f, -0.03148167f, -0.05046610f, 
    -0.02356809f, -0.04420435f, 0.02735783f, -0.01468325f, -0.00992168f, 0.01115740f, -0.09441923f, -0.02736051f, 
    -0.05415855f, -0.01022219f, -0.05903830f, -0.07486489f, -0.05076726f, 0.02462722f, -0.08408480f, 0.02797785f, 
    -0.06633048f, 0.04649064f, 0.02056335f, -0.07637364f, 0.01419520f, -0.01083769f, -0.04989567f, -0.01700954f, 
    -0.05735771f, -0.03636361f, -0.00139517f, -0.00518695f, -0.04293736f, -0.05992408f, 0.06045178f, -0.03754358f, 
    -0.02832532f, -0.06553213f, 0.05035368f, -0.07324361f, -0.08860955f, -0.05026509f, -0.07308423f, 0.02795149f, 
    -0.00731919f, -0.03088553f, 0.02293707f, -0.01626097f, 0.04778161f, -0.08424188f, 0.03515068f, -0.00138998f, 
    -0.01721694f, -0.01695868f, -0.03509722f, -0.02610014f, -0.02120856f, -0.04614615f, -0.01097671f, 0.00213561f, 
    0.05060013f, -0.07785282f, -0.08087011f, -0.02367780f, -0.07120410f, 0.02377188f, -0.03273097f, -0.03776316f, 
    -0.03520888f, -0.02912485f, -0.03546477f, 0.00989484f, 0.02311832f, -0.04283539f, -0.02277375f, 0.03445350f, 
    0.03282333f, 0.03043769f, 0.02902159f, 0.03896333f, 0.01391137f, 0.00677940f, -0.06773716f, -0.01358580f, 
    0.01514751f, -0.05645614f, -0.09050722f, -0.08636899f, -0.04470122f, -0.02140262f, -0.04548565f, -0.03657861f, 
    0.00156845f, 0.01723301f, 0.02230292f, -0.04534646f, -0.00472142f, 0.04451154f, 0.02880510f, -0.05381615f, 
    0.22895454f, -0.03512270f, 0.00153359f, -0.07926821f, 0.12966409f, 0.03771241f, -0.07056241f, -0.01915287f, 
    -0.10978786f, -0.12513101f, -0.15207295f, -0.02249181f, -0.05515980f, 0.06440476f, -0.18187176f, -0.27266204f, 
    -0.01216040f, -0.02701935f, -0.09898376f, 0.08247031f, 0.16514055f, -0.02616504f, 0.08545441f, 0.05607123f, 
    -0.06588949f, -0.24270606f, -0.22028141f, 0.05074671f, 0.08276356f, 0.00079917f, -0.04229925f, -0.09733704f, 
    0.08723353f, -0.02134428f, 0.02495713f, 0.02041716f, 0.26198757f, 0.11311049f, 0.24395078f, 0.02168531f, 
    0.05643594f, 0.03328978f, -0.03239291f, 0.12437547f, 0.08147972f, 0.10082509f, 0.20679466f, 0.13575056f, 
    0.20543283f, 0.36744273f, 0.05428079f, -0.25085124f, 0.02473197f, -0.04822250f, -0.00824754f, 0.36200598f, 
    0.01934610f, -0.01399291f, 0.00762890f, -0.15702230f, 0.01689221f, 0.01207581f, 0.04824384f, 0.10716764f, 
    -0.00591447f, -0.03371602f, 0.01214031f, -0.11037552f, -0.04870360f, -0.14050041f, 0.04295363f, 0.14452729f, 
    0.00441050f, -0.32340300f, -0.03631803f, 0.10951347f, 0.04982943f, -0.09678968f, 0.01893458f, -0.01216189f, 
    -0.06869582f, 0.09298606f, -0.11404970f, 0.06162734f, -0.00340778f, 0.13106543f, -0.20223416f, -0.11126611f, 
    -0.00116484f, 0.14981145f, 0.19473216f, 0.07866492f, 0.03024833f, 0.10855147f, 0.02208095f, -0.02610220f, 
    -0.04645471f, -0.31939963f, -0.30896053f, 0.09112281f, -0.00773990f, -0.17511792f, -0.02825598f, -0.20404230f, 
    -0.04160815f, 0.01174997f, -0.13514808f, -0.15371290f, -0.20128161f, -0.18212037f, -0.20088686f, -0.13279021f, 
    0.01244608f, 0.02816112f, -0.19186397f, -0.06599893f, 0.06134893f, -0.07370696f, 0.00903885f, 0.13743956f, 
    -0.18635897f, -0.01623189f, -0.02218407f, 0.22831708f, 0.08295198f, -0.07411484f, 0.01145138f, 0.14655282f, 
    0.04743858f, 0.02757391f, -0.07115378f, 0.14149605f, -0.26940581f, -0.21904215f, 0.02775231f, 0.18612307f, 
    0.02287227f, 0.01503794f, -0.19619678f, -0.04134800f, 0.08101493f, 0.06747063f, -0.23140064f, 0.00413852f, 
    -0.30380118f, 0.08125894f, -0.08894657f, 0.14851592f, -0.05651608f, 0.05140248f, 0.01150755f, -0.11099853f, 
    0.05080165f, 0.05491582f, 0.02592085f, 0.01905213f, 0.28617918f, 0.16254570f, 0.25894180f, 0.01948860f, 
    0.04535667f, 0.11501510f, 0.09793354f, 0.11040810f, 0.02430969f, 0.01163207f, -0.04979691f, -0.01153640f, 
    -0.08625180f, -0.04042294f, -0.15397461f, 0.14542711f, 0.09492926f, 0.10300747f, -0.23718522f, -0.03792889f, 
    0.13052142f, 0.05145897f, 0.09496555f, 0.07276517f, -0.05989457f, 0.21804675f, 0.32310048f, 0.17343248f, 
    -0.02797476f, -0.10890734f, 0.07246859f, 0.13198939f, -0.00829719f, 0.12826689f, -0.07723343f, 0.10618103f, 
    0.02391892f, -0.10444053f, 0.01490525f, 0.01315349f, 0.02368080f, 0.02888625f, -0.06769395f, 0.03798662f, 
    0.07142762f, 0.10480568f, 0.05058907f, 0.12249223f, -0.19971311f, 0.50495499f, 0.07516861f, -0.08238410f, 
    0.01227615f, -0.03654327f, 0.14490634f, 0.02182515f, 0.01867217f, 0.01888370f, 0.03042045f, -0.07722070f, 
    -0.23555006f, -0.06125458f, -0.20267156f, -0.07683922f, -0.08500013f, -0.14684553f, -0.17515321f, -0.17833410f, 
    -0.17793439f, -0.03847732f, -0.14237343f, -0.20065294f, -0.03697337f, -0.13856567f, 0.01178974f, 0.03261686f, 
    -0.11043915f, -0.03993067f, -0.02365701f, 0.08290875f, -0.19342494f, -0.10989962f, -0.05435305f, -0.18063946f, 
    -0.10611822f, 0.18262349f, 0.32839018f, -0.14279091f, 0.04676186f, -0.00117633f, -0.05617718f, -0.02324622f, 
    -0.14077669f, 0.08596055f, 0.01276674f, 0.02908801f, -0.07345749f, -0.06659982f, 0.00286039f, -0.02815959f, 
    0.05211024f, -0.01987434f, -0.06148310f, 0.16292427f, 0.02754991f, 0.04349087f, 0.03725487f, -0.06554593f, 
    0.35783750f, 0.01356206f, 0.03348443f, 0.01951246f, -0.04129877f, -0.12731175f, 0.01013045f, 0.10452901f, 
    -0.00916247f, 0.04785423f, 0.06016428f, -0.02152412f, -0.00828396f, 0.29377627f, -0.05366242f, 0.17855461f, 
    -0.01743722f, 0.04837099f, 0.12340764f, -0.06130178f, 0.19480205f, 0.04130318f, 0.14906213f, 0.20562564f, 
    0.20328949f, 0.09748954f, -0.05040253f, 0.11111413f, -0.04979880f, 0.03790975f, 0.01427494f, -0.08480152f, 
    0.14266115f, 0.18516633f, -0.01099362f, 0.02644659f, -0.28969541f, -0.38113007f, -0.17670949f, -0.09810343f, 
    0.05305330f, 0.04939158f, -0.10441381f, 0.00237891f, 0.18800023f, 0.03392525f, 0.19234689f, 0.26800260f, 
    -0.25662261f, 0.35090658f, -0.26356494f, -0.07054482f, 0.02883220f, -0.03864221f, 0.03300293f, 0.02354841f, 
    0.08438137f, -0.07990628f, 0.13512310f, -0.00494103f, -0.03465049f, 0.04042732f, 0.07769110f, -0.05363336f, 
    -0.14479277f, -0.12866178f, -0.11068217f, 0.08767854f, 0.00101350f, 0.08125772f, -0.11917188f, 0.06798189f, 
    0.31572473f, 0.22709379f, 0.28413391f, 0.11857200f, -0.03924030f, -0.14132644f, 0.08025936f, -0.11810580f, 
    0.01578420f, 0.12088010f, 0.18997349f, 0.05285957f, -0.17563622f, -0.11338503f, -0.05183210f, -0.00295740f, 
    0.02953988f, 0.09270928f, 0.05488859f, -0.01988789f, 0.07661438f, -0.04010073f, -0.07736067f, -0.02790658f, 
    0.10832189f, 0.01500615f, 0.14962317f, -0.08580763f, 0.04299168f, -0.06629702f, -0.18047604f, 0.14273506f, 
    -0.02633013f, -0.00098743f, -0.07240713f, -0.16519754f, 0.14708881f, 0.06550919f, 0.11572273f, -0.02227821f, 
    0.12128604f, -0.10491528f, -0.01794334f, 0.25921151f, -0.12026646f, 0.16831416f, 0.10821470f, -0.03389967f, 
    -0.10623665f, 0.12640627f, -0.09515524f, -0.05809681f, 0.07663076f, -0.24407804f, 0.19490804f, 0.02937011f, 
    0.00908623f, 0.06829156f, 0.04455909f, 0.03093608f, 0.22590020f, -0.15322101f, 0.31840640f, 0.14157891f, 
    -0.00847574f, 0.05248845f, 0.00170720f, -0.03510094f, 0.01284180f, 0.00484911f, 0.21643896f, 0.03854623f, 
    -0.03894776f, -0.07703707f, 0.01541479f, -0.14886509f, -0.07568116f, -0.08656718f, 0.00343439f, -0.11542891f, 
    -0.03074984f, -0.17363453f, 0.02195580f, -0.22689217f, -0.10470661f, 0.02334137f, -0.00130510f, 0.04035425f, 
    -0.04818019f, 0.09849466f, -0.03659838f, 0.02291191f, 0.07414683f, 0.00520307f, -0.13528496f, -0.06312776f, 
    -0.24114147f, -0.18782945f, 0.10477050f, -0.16098420f, -0.03060186f, 0.04383584f, -0.03517497f, -0.13291964f, 
    -0.10638999f, 0.04031743f, -0.05542808f, 0.13043964f, -0.01415711f, -0.00495799f, 0.02537626f, -0.17262962f, 
    0.03043521f, -0.07016534f, -0.08607254f, 0.07118699f, -0.03240838f, 0.01629140f, 0.09513079f, -0.21901201f, 
    0.06245223f, 0.05583157f, 0.06190724f, 0.04149400f, 0.00714041f, 0.03324338f, -0.04567761f, -0.06941782f, 
    0.11919418f, 0.10188893f, 0.13410681f, -0.08613636f, 0.01810288f, 0.01932473f, 0.20907019f, 0.15860739f, 
    0.14848754f, 0.03612152f, 0.05473816f, 0.09554295f, 0.11674412f, 0.06396516f, 0.13006498f, 0.08183125f, 
    0.17633611f, 0.29369295f, 0.06918610f, -0.00134028f, -0.02113601f, 0.00970445f, 0.00157496f, 0.00200995f, 
    0.19009282f, 0.04529849f, 0.25308076f, 0.21155572f, -0.11297280f, -0.13493578f, -0.01849053f, -0.14940320f, 
    -0.00613423f, -0.11616267f, -0.06115471f, -0.06494053f, 0.06385372f, 0.02600045f, 0.16844778f, 0.04747801f, 
    -0.11641113f, -0.10705566f, 0.03285342f, 0.14058436f, -0.03583665f, 0.04346528f, -0.05994754f, -0.01287508f, 
    0.12553088f, -0.01848247f, 0.06406327f, 0.12360750f, 0.05510570f, 0.00265760f, -0.08302048f, -0.11650596f, 
    -0.04844024f, -0.12236094f, -0.02047879f, -0.09199066f, -0.02938573f, -0.06170846f, 0.00917533f, -0.04327353f, 
    0.58896369f, 0.28294075f, 0.14817318f, -0.03496762f, -0.03437871f, -0.17904760f, 0.11738312f, -0.07178088f, 
    0.02002286f, 0.10157302f, -0.04865921f, -0.05385678f, -0.22421971f, -0.10487493f, 0.04887162f, 0.04669446f, 
    -0.08033526f, -0.13267170f, 0.07958710f, 0.06043089f, 0.01638802f, 0.10097540f, -0.02317988f, -0.02676854f, 
    0.12371121f, 0.23947242f, 0.15701671f, -0.17908221f, -0.15993245f, -0.09561373f, 0.12658730f, 0.06314721f, 
    -0.00312378f, 0.04799742f, -0.03133125f, 0.00306480f, -0.13142705f, 0.07040168f, -0.18391499f, 0.00323801f, 
    0.31107280f, -0.07295512f, 0.06537934f, 0.05515676f, 0.04683634f, 0.01769567f, 0.04522042f, 0.08442129f, 
    -0.05397472f, 0.04179022f, 0.05332872f, -0.03007742f, -0.02200991f, 0.00512558f, -0.03557417f, -0.04520200f, 
    -0.00307315f, 0.01352699f, 0.05235057f, 0.04658454f, 0.01230129f, 0.05104377f, -0.02032139f, 0.00816047f, 
    0.01044018f, -0.04261079f, -0.04206398f, -0.06849870f, 0.02365629f, 0.02467507f, 0.04919595f, -0.01860963f, 
    -0.03279876f, -0.05564304f, -0.04276762f, 0.02860668f, 0.05786194f, 0.01529471f, -0.07773909f, -0.01868879f, 
    -0.02579574f, 0.06525311f, -0.00373451f, 0.04572746f, 0.00921303f, -0.02343784f, 0.04520355f, 0.02158261f, 
    0.05154979f, 0.03044597f, 0.00455757f, -0.04326783f, -0.06764877f, -0.05972309f, 0.06020068f, 0.01432766f, 
    -0.02122643f, 0.04387258f, 0.01561554f, -0.01016184f, 0.03931651f, 0.02862177f, 0.04122214f, -0.05446597f, 
    -0.02260721f, 0.00632467f, -0.01618321f, 0.04971915f, -0.04291194f, 0.00742083f, -0.05031946f, 0.00358667f, 
    -0.07326719f, -0.04953758f, -0.00315214f, -0.05895153f, -0.00599851f, -0.05515385f, -0.02897647f, -0.03359881f, 
    0.02686216f, 0.00307681f, 0.01305959f, 0.05632769f, -0.07198688f, -0.07124434f, -0.03354846f, 0.05397372f, 
    0.00388831f, -0.02416304f, -0.00885863f, -0.02681647f, -0.01113897f, 0.01516175f, -0.01724299f, -0.07629388f, 
    -0.06988346f, -0.07219815f, -0.01522434f, -0.01338562f, -0.01788487f, -0.04575063f, 0.04354401f, -0.05646135f, 
    0.05307770f, 0.01740570f, -0.03562126f, -0.02846497f, -0.01333840f, -0.04335402f, -0.02006307f, 0.02832525f, 
    -0.04348949f, -0.03756857f, 0.02514423f, 0.02006678f, -0.06767732f, -0.03605672f, 0.01392606f, -0.04482662f, 
    0.01955628f, 0.06254833f, -0.06664019f, -0.01713386f, 0.05474889f, -0.00785988f, 0.04297969f, 0.05463175f, 
    -0.07495201f, -0.00162124f, 0.06076807f, -0.03765107f, -0.06117870f, 0.02618467f, -0.04586870f, -0.01283442f, 
    -0.07438914f, -0.03447822f, -0.07636745f, -0.07027673f, -0.04550510f, 0.04801781f, 0.02506276f, -0.04865909f, 
    0.03783008f, -0.06583432f, -0.04363608f, -0.02752859f, -0.02081522f, 0.02382367f, -0.05875564f, 0.06230769f, 
    0.02763538f, -0.05753601f, 0.05844327f, 0.01920936f, 0.03451753f, -0.03388392f, 0.02951817f, -0.01636335f, 
    -0.02558249f, -0.00585518f, -0.04120477f, -0.03935000f, -0.04612602f, 0.02542820f, -0.06634416f, -0.05459515f, 
    -0.04779202f, -0.00922043f, -0.04271126f, 0.03043626f, 0.05247166f, -0.05084438f, -0.06811227f, -0.04327661f, 
    0.00576376f, -0.00170069f, -0.01517632f, -0.05033577f, -0.01650091f, 0.05627909f, -0.03763716f, -0.00604816f, 
    0.03477564f, -0.07950137f, -0.00764053f, -0.04911036f, 0.05870569f, 0.04438478f, 0.05847645f, -0.00512522f, 
    0.04915483f, -0.02301967f, -0.00047700f, 0.03031914f, -0.03469074f, 0.01974455f, 0.04409112f, -0.07511466f, 
    -0.20738548f, -0.06962132f, -0.02161312f, 0.07975131f, 0.19052982f, 0.06451291f, 0.02754776f, 0.23237883f, 
    -0.06857185f, -0.00616735f, -0.06910159f, -0.05316835f, 0.17849886f, -0.42260534f, -0.06885991f, 0.12303400f, 
    -0.09165708f, -0.01018879f, -0.19175802f, -0.10466296f, 0.22446725f, 0.09860270f, 0.03895737f, 0.12463689f, 
    0.06536147f, -0.04620190f, -0.02463948f, -0.02626332f, 0.01946789f, -0.05400192f, 0.02391841f, -0.08910429f, 
    0.18395121f, -0.10472909f, -0.08384612f, 0.07082782f, -0.00782181f, 0.07830828f, 0.15980883f, 0.05335928f, 
    -0.03491493f, 0.04606587f, 0.16263540f, -0.06334329f, 0.00037904f, -0.19317709f, 0.07644478f, 0.06806350f, 
    0.00380941f, -0.02926801f, -0.14216441f, -0.02650016f, -0.07806061f, -0.21345001f, -0.02771912f, -0.14373928f, 
    -0.06210057f, 0.10056326f, 0.03488060f, 0.03140026f, 0.04614953f, 0.17171529f, 0.08732282f, 0.10048975f, 
    -0.08419888f, 0.01329875f, -0.00353575f, -0.00194823f, -0.03850033f, 0.05346797f, -0.04546636f, 0.07935817f, 
    0.07590813f, 0.24872071f, -0.18394065f, 0.00944819f, 0.04191726f, -0.00813431f, 0.08910444f, -0.13156019f, 
    0.09740031f, 0.04570804f, 0.01287079f, 0.05504103f, 0.00205197f, -0.21769084f, -0.26037019f, -0.20287038f, 
    -0.02671683f, 0.11392727f, 0.13414015f, 0.16399018f, 0.11889105f, -0.05100536f, 0.11711741f, -0.02424251f, 
    0.02795990f, -0.02035604f, -0.10876929f, 0.02414196f, -0.10075126f, 0.20305316f, 0.20418541f, -0.11873663f, 
    0.09182641f, -0.02403984f, 0.10967441f, -0.05840927f, 0.09763435f, 0.02504368f, 0.00387758f, -0.03250282f, 
    0.03695280f, -0.04329016f, 0.03570716f, 0.11903542f, -0.12652165f, -0.07360048f, -0.01180483f, 0.04537373f, 
    0.53620523f, -0.21320418f, -0.23852761f, 0.19927630f, -0.05888453f, 0.12775522f, 0.01432727f, -0.16425118f, 
    0.17846350f, -0.02328597f, 0.01697718f, -0.05352869f, 0.03589130f, 0.06575154f, 0.05635935f, -0.09258962f, 
    0.03834881f, 0.08584344f, 0.09431566f, 0.01289205f, 0.08161206f, 0.01563477f, -0.03940215f, 0.09341022f, 
    -0.28163692f, 0.12198582f, 0.28022221f, -0.24927209f, 0.02792690f, 0.02542933f, -0.13111991f, -0.01438299f, 
    -0.04733213f, -0.20103538f, 0.25231525f, -0.12117804f, -0.17540704f, -0.03090119f, 0.21842672f, -0.23704594f, 
    0.04117260f, -0.05858089f, 0.09134880f, 0.07543372f, 0.06097339f, -0.03190593f, -0.07739844f, 0.11000908f, 
    -0.41624963f, 0.10130429f, 0.29756048f, -0.15831494f, -0.08983377f, 0.00646130f, -0.31361020f, 0.03144832f, 
    0.04272044f, -0.07687405f, 0.03710200f, 0.16168252f, -0.30817702f, 0.19212914f, -0.16020118f, 0.07173601f, 
    0.30071473f, -0.05292888f, -0.23360041f, 0.01236600f, 0.16345866f, -0.02742570f, -0.00696599f, 0.02998265f, 
    -0.21778600f, -0.17088586f, -0.19883260f, -0.12343896f, 0.00168199f, -0.13890009f, 0.07783674f, 0.15931739f, 
    0.17371690f, -0.02795104f, -0.07222385f, 0.00713410f, -0.19257414f, -0.01322902f, 0.26883271f, -0.22481866f, 
    0.14103940f, 0.02606568f, 0.13485560f, -0.00989736f, 0.00965017f, 0.22423887f, 0.02132326f, -0.08568802f, 
    0.15217806f, 0.01150453f, 0.05265089f, -0.05170280f, 0.04782058f, -0.05736526f, 0.00771587f, 0.02439586f, 
    -0.03785319f, -0.00627583f, 0.05302935f, 0.09355382f, -0.15853384f, -0.21553908f, 0.12050038f, 0.13502152f, 
    -0.12921207f, -0.07808276f, 0.01159668f, 0.03182094f, -0.08745536f, 0.30937329f, 0.13809207f, 0.03334619f, 
    -0.09976936f, 0.17805293f, 0.27924931f, -0.22176319f, 0.20323078f, 0.16985586f, 0.11420894f, 0.16985777f, 
    0.05567728f, -0.00902388f, 0.05795239f, -0.06266645f, 0.07599268f, 0.10780214f, 0.11922333f, 0.11232038f, 
    -0.11197156f, -0.09393414f, 0.08912437f, -0.03091806f, 0.04284951f, 0.02281063f, 0.14240359f, 0.17511861f, 
    0.18475881f, -0.11478481f, -0.05785882f, 0.08862763f, -0.03448764f, 0.12688464f, -0.16119073f, 0.01343483f, 
    -0.10138677f, 0.09856366f, -0.13282560f, -0.00059268f, -0.37753743f, 0.14785226f, 0.23670763f, 0.11024572f, 
    0.07079747f, 0.14728571f, 0.01793975f, -0.00427180f, -0.12943541f, -0.02561451f, 0.00998718f, 0.00597213f, 
    0.03990774f, 0.25280571f, -0.18809809f, 0.08481791f, 0.04415676f, -0.08491138f, -0.12385577f, 0.05680436f, 
    -0.02066391f, -0.07535834f, -0.14524840f, 0.00518412f, 0.08100037f, -0.13337278f, 0.16080345f, -0.02866204f, 
    0.04251906f, 0.08557536f, -0.07514185f, -0.02195469f, 0.12987596f, -0.03033707f, -0.02005313f, 0.09957173f, 
    -0.06053501f, -0.02900463f, 0.15907934f, 0.10681461f, 0.17033857f, 0.01809113f, -0.14107856f, -0.00939442f, 
    -0.01010827f, 0.05016659f, 0.01214013f, 0.00646830f, 0.06508753f, -0.10595716f, 0.00092392f, 0.00296093f, 
    -0.00511356f, 0.09272145f, -0.07488959f, -0.02295883f, 0.04436836f, 0.02491954f, 0.05567378f, -0.10156465f, 
    0.10163812f, 0.09834417f, 0.04692980f, 0.11391853f, -0.06963153f, -0.00627118f, 0.19081609f, 0.00954544f, 
    0.07696210f, 0.12386983f, -0.01140846f, 0.14005809f, -0.20862034f, -0.11326768f, 0.12241692f, 0.17615516f, 
    -0.09029369f, -0.10488547f, -0.05638028f, 0.12927061f, -0.01067404f, -0.06528674f, 0.07112012f, -0.05935794f, 
    0.36943522f, 0.18478677f, 0.03744108f, -0.05831979f, 0.05245242f, -0.06882238f, 0.10176336f, 0.00890015f, 
    0.17364945f, 0.02456349f, 0.04827096f, -0.06546697f, -0.05609644f, -0.15404053f, -0.14548150f, 0.13618922f, 
    0.04449476f, -0.02841248f, 0.07600902f, -0.03374654f, -0.01811044f, -0.02959974f, -0.05586727f, 0.23572989f, 
    -0.06480063f, -0.04501301f, -0.06624567f, -0.00175745f, -0.05542853f, -0.08404680f, 0.04798054f, -0.03408565f, 
    -0.08752441f, 0.05846951f, -0.05579537f, 0.00860046f, 0.01303491f, -0.07892954f, -0.00078795f, -0.01300583f, 
    0.03744001f, 0.01151150f, 0.00016404f, -0.00874316f, -0.04854212f, 0.00811418f, 0.01099506f, -0.02387014f, 
    0.04712566f, -0.03689218f, -0.00278939f, 0.04299061f, -0.02141165f, -0.05030040f, -0.01948741f, -0.02140095f, 
    0.00038000f, -0.07546509f, -0.07381164f, -0.04472166f, -0.05233810f, -0.05263738f, -0.01063138f, -0.01434253f, 
    -0.05204622f, 0.04454459f, 0.04003014f, 0.04404214f, 0.02698025f, -0.06062309f, -0.06629118f, 0.02316128f, 
    -0.06023433f, 0.04116094f, -0.02134866f, 0.02155201f, -0.08191617f, 0.02145328f, 0.02923534f, 0.03433816f, 
    -0.04239835f, -0.07516942f, -0.01707079f, -0.04178645f, -0.04216081f, -0.00034839f, 0.04250430f, -0.03182590f, 
    -0.07405667f, -0.00157082f, -0.08506458f, 0.03363930f, -0.03590343f, -0.05155171f, -0.01012437f, 0.02408903f, 
    -0.07517117f, 0.03703796f, -0.06922665f, -0.01317709f, -0.03254117f, -0.06787678f, 0.01840760f, -0.02423019f, 
    0.00897153f, -0.05339486f, 0.05149776f, 0.00822969f, -0.01903678f, -0.07442548f, 0.01697401f, -0.04542238f, 
    0.03372980f, -0.05810727f, 0.02276795f, -0.01318266f, 0.03217601f, -0.02932153f, -0.04816787f, 0.06655736f, 
    -0.01592341f, -0.05651204f, 0.06260594f, 0.01261788f, 0.05682139f, 0.03333299f, 0.03072844f, 0.04626452f, 
    0.01389061f, -0.02360073f, -0.05371848f, -0.02654332f, -0.07876163f, -0.05200754f, -0.07009245f, -0.04550007f, 
    0.05276156f, -0.02685812f, -0.03643550f, 0.01047843f, 0.03429225f, -0.04654916f, 0.03234864f, 0.01201206f, 
    -0.00805766f, -0.01296694f, -0.02892811f, 0.04514146f, -0.01789780f, 0.01871523f, -0.02294136f, -0.07000405f, 
    0.02311011f, -0.05105091f, -0.02678919f, 0.03804910f, -0.07044957f, -0.05745287f, 0.00564233f, -0.02284720f, 
    -0.07054542f, -0.01939089f, -0.05922923f, -0.06717935f, -0.04962106f, 0.02132179f, -0.06824253f, 0.03052848f, 
    0.00112050f, 0.05889925f, -0.05887223f, 0.04720481f, -0.07720648f, -0.07652204f, -0.04326362f, -0.06840436f, 
    0.04132383f, 0.00563458f, -0.01881241f, 0.06606610f, -0.02206498f, -0.02224938f, -0.04574941f, -0.04571566f, 
    -0.03245750f, -0.03236974f, 0.04996485f, -0.02068993f, 0.04403573f, -0.02161523f, -0.01901000f, 0.01975084f, 
    -0.05661811f, 0.02288272f, -0.00209854f, -0.08846728f, 0.01139192f, -0.08694796f, 0.05752525f, 0.00161061f, 
    0.01541034f, 0.03778046f, 0.01233765f, -0.08155104f, -0.07236942f, -0.01087668f, 0.06749947f, -0.01886486f, 
    -0.03439556f, 0.04854293f, -0.02832392f, 0.00688365f, 0.03010115f, 0.00037459f, 0.02285074f, 0.05957237f, 
    0.01736849f, -0.09889754f, 0.14044057f, 0.33358669f, 0.16205163f, -0.00095068f, 0.13183029f, 0.02328729f, 
    0.10082974f, 0.03823753f, 0.14232711f, 0.20976914f, -0.17657918f, 0.40843707f, 0.20527077f, 0.05351837f, 
    -0.00088797f, -0.10601760f, 0.14202859f, 0.02015335f, -0.03094124f, -0.05282668f, 0.05335996f, -0.00214132f, 
    -0.18177952f, -0.06943713f, -0.17030123f, -0.19408131f, -0.14741501f, -0.10316113f, -0.03361101f, -0.11327802f, 
    -0.07102969f, -0.00976251f, -0.02348809f, -0.19074190f, -0.14490755f, -0.14468497f, -0.17221723f, 0.13496856f, 
    -0.00191673f, -0.11800890f, -0.09804166f, 0.07350263f, 0.04175323f, -0.00626831f, 0.01065645f, -0.09234288f, 
    0.07191036f, 0.26019335f, 0.49047461f, 0.18640159f, -0.11507974f, 0.11402635f, -0.03442989f, 0.00386914f, 
    0.03842687f, -0.06050901f, 0.06750368f, 0.06240354f, -0.08896143f, -0.17084534f, -0.01964701f, 0.08770231f, 
    0.11029131f, 0.12588535f, 0.06808843f, 0.23462538f, -0.03582056f, 0.04661050f, -0.06552725f, -0.03896329f, 
    0.21894443f, 0.15126380f, 0.15514380f, -0.20694046f, -0.18597747f, -0.06239057f, 0.00885201f, 0.01908367f, 
    -0.04727727f, 0.08616973f, 0.00947342f, -0.21226487f, -0.06535670f, 0.41329840f, 0.17442435f, 0.35767043f, 
    0.06324723f, -0.10760484f, -0.00110419f, 0.07858279f, 0.05319113f, 0.09410406f, 0.06340068f, 0.11484285f, 
    0.01454822f, 0.34597251f, 0.03821415f, -0.11646285f, 0.06812168f, -0.01074750f, -0.02484624f, 0.07380242f, 
    0.09681178f, 0.14842451f, 0.20063931f, 0.10744783f, -0.09933623f, -0.18458977f, -0.07730788f, -0.17810500f, 
    -0.07048930f, 0.01074538f, -0.01451541f, -0.08564369f, 0.15507902f, 0.00243341f, 0.09917895f, 0.04063402f, 
    -0.14982530f, 0.40766245f, -0.08962108f, -0.36817539f, 0.01738585f, 0.10011246f, 0.04599835f, 0.15058325f, 
    -0.09597193f, -0.09371585f, -0.10001156f, 0.01097883f, -0.14397371f, -0.05013638f, 0.10228345f, -0.41952622f, 
    -0.18102209f, -0.19396134f, -0.15256448f, -0.02273566f, -0.05681116f, -0.00314041f, -0.03400981f, -0.01842940f, 
    -0.18054241f, 0.21461295f, 0.01962484f, 0.29500765f, -0.18704903f, 0.05978892f, -0.02595840f, -0.07870720f, 
    0.09718797f, 0.21602009f, 0.09670465f, 0.04537719f, -0.04301712f, -0.11079806f, -0.18698633f, 0.31602904f, 
    0.07802049f, 0.07686795f, 0.11282385f, 0.01794774f, 0.09708086f, 0.06135699f, 0.04242862f, 0.13416207f, 
    -0.34240749f, 0.14684598f, 0.01663253f, 0.19534981f, 0.03161051f, -0.06795170f, -0.05322935f, 0.09454399f, 
    -0.00025137f, 0.02096504f, -0.06475241f, -0.04466856f, 0.36466649f, -0.07302517f, -0.06725236f, -0.01912915f, 
    0.18993966f, -0.07504061f, 0.02048337f, 0.13143751f, -0.06565960f, 0.16437085f, 0.16552658f, -0.02813763f, 
    -0.20590460f, -0.05014458f, 0.06950022f, 0.00546357f, 0.03320923f, -0.11255323f, -0.20861429f, -0.01904106f, 
    0.01438380f, -0.19058397f, -0.10315408f, -0.08520440f, -0.16443400f, -0.08927160f, 0.05671927f, -0.03955457f, 
    -0.00805225f, 0.11110590f, -0.11299349f, -0.02569782f, 0.04933959f, 0.11700778f, 0.13608673f, 0.06159742f, 
    -0.06355546f, -0.07222884f, -0.14764607f, -0.08568819f, -0.07844526f, -0.08778551f, -0.03398732f, 0.00452220f, 
    0.12110696f, 0.06996439f, 0.11370710f, 0.05990107f, -0.26586831f, -0.10671614f, 0.13967495f, 0.07846074f, 
    -0.08820775f, -0.02731020f, 0.08473109f, -0.03636810f, 0.11476551f, 0.06614000f, 0.01753601f, 0.09246365f, 
    0.09507676f, 0.22139846f, 0.34986895f, -0.45284969f, 0.08569270f, 0.06613431f, -0.03646711f, 0.00994033f, 
    -0.07660256f, 0.04120792f, 0.03176690f, -0.13061482f, 0.06107375f, 0.48849082f, 0.16098478f, 0.16456906f, 
    -0.07066499f, -0.16779916f, 0.09696628f, 0.02600785f, 0.16775401f, 0.05594065f, 0.10837997f, 0.16420643f, 
    0.14195363f, -0.30313185f, -0.07062609f, 0.13956024f, 0.07856567f, 0.15264328f, -0.14193137f, -0.01884909f, 
    0.07699733f, 0.03703929f, 0.06763107f, -0.04103333f, -0.17090398f, 0.06064172f, 0.22085232f, 0.04786329f, 
    0.23173344f, 0.11459967f, -0.03060983f, -0.01435940f, 0.01442063f, -0.03655681f, -0.02799019f, -0.08020531f, 
    0.07836792f, 0.20030828f, -0.14799680f, 0.05499664f, 0.00308117f, -0.08385293f, -0.05165257f, 0.02403200f, 
    -0.11991107f, -0.07644968f, -0.03126014f, -0.01217219f, -0.16423690f, -0.11342753f, -0.16502298f, 0.12613162f, 
    0.11052527f, -0.14196692f, -0.02071887f, 0.09893516f, -0.12007381f, -0.12971424f, -0.11415447f, 0.02741405f, 
    -0.02447698f, -0.34452757f, 0.10590388f, 0.26002741f, -0.03896127f, -0.01494705f, -0.12633893f, -0.00854433f, 
    0.15366231f, 0.14723702f, 0.08427790f, 0.04094216f, -0.04135787f, -0.07851797f, -0.23265816f, 0.09085493f, 
    0.03679108f, 0.17372641f, 0.03960543f, 0.03750190f, 0.01643265f, -0.06727296f, -0.09199762f, -0.03616618f, 
    -0.01354418f, 0.26918438f, 0.15555556f, 0.01445334f, 0.02329993f, -0.02085923f, 0.00911335f, 0.06462550f, 
    -0.15071394f, -0.04378609f, -0.00301594f, 0.00245567f, -0.22565205f, -0.10074040f, 0.15486149f, 0.13677469f, 
    -0.11098019f, -0.16646513f, -0.01248539f, 0.11143813f, -0.07483058f, -0.04289043f, -0.05172689f, -0.11621902f, 
    0.16514497f, -0.08820945f, -0.07934323f, -0.31573325f, 0.06953729f, -0.11512095f, 0.02460479f, 0.02571321f, 
    0.19553886f, 0.07711760f, 0.03498301f, 0.12144926f, -0.18817964f, -0.27609318f, -0.11489256f, 0.15558580f, 
    0.15244004f, -0.07854598f, 0.07192948f, -0.00277449f, 0.09126861f, -0.00413699f, -0.02763578f, 0.16234857f, 
    0.03556155f, 0.11656755f, -0.08287724f, 0.00887426f, -0.03288581f, -0.10265197f, 0.06566878f, -0.19930802f, 
    -0.17930397f, -0.20256491f, -0.19613732f, -0.18400016f, 0.42201036f, -0.08892702f, 0.29387847f, -0.03254322f, 
    0.00552385f, 0.04612993f, 0.06820308f, -0.17768875f, -0.01354494f, 0.01157949f, 0.15083265f, 0.01616314f, 
    0.07408842f, 0.00413690f, 0.16943957f, 0.11144289f, -0.07258556f, 0.04723061f, -0.01592949f, -0.03607749f, 
    0.38446394f, 0.23763229f, 0.15867777f, 0.20748982f, -0.27450556f, -0.22768493f, -0.00273689f, -0.35032424f, 
    -0.18340711f, 0.13868482f, 0.01156455f, 0.10589510f, 0.10895405f, 0.18601593f, 0.05446393f, 0.06352402f, 
    -0.01884154f, 0.07208905f, 0.05334418f, 0.17703222f, -0.01786795f, 0.01363464f, 0.20910989f, -0.10510647f, 
    -0.03261585f, -0.07119864f, 0.10034446f, 0.13857040f, -0.02584248f, -0.08806211f, 0.02565159f, -0.49431261f, 
    -0.25985751f, -0.10528495f, -0.17708261f, -0.01298153f, 0.02234093f, -0.14228019f, 0.12779357f, 0.01114454f, 
    -0.03218711f, 0.11601581f, 0.03446665f, 0.06118644f, -0.01345334f, 0.02675230f, 0.12686799f, -0.16145346f, 
    -0.01591872f, -0.04910328f, 0.06687499f, 0.13412865f, -0.06996892f, -0.41361681f, 0.05679196f, -0.03497511f, 
    -0.02700537f, -0.04758004f, 0.01733991f, -0.01440639f, -0.01173717f, 0.06273064f, -0.01361954f, -0.15838462f, 
    0.00050069f, 0.12584527f, 0.06561591f, -0.00419582f, -0.15134802f, -0.16022621f, 0.05307738f, -0.05302816f, 
    -0.18722501f, 0.01178229f, 0.07497473f, -0.09531178f, 0.08941118f, 0.18317211f, 0.18925488f, 0.09874386f, 
    -0.06223591f, 0.04576131f, -0.02822000f, -0.04464156f, -0.04369470f, 0.06102499f, -0.15216488f, -0.02542936f, 
    0.01952530f, 0.18949552f, 0.17674935f, 0.16361620f, 0.04536626f, 0.46626887f, -0.04766211f, 0.02666778f, 
    0.11023090f, -0.01214544f, 0.08267842f, 0.12901945f, 0.00606339f, -0.00290076f, 0.01136433f, 0.04388234f, 
    -0.02278694f, 0.02125548f, -0.05659044f, -0.01281392f, -0.03029469f, -0.08535890f, 0.04678863f, -0.03358542f, 
    0.47349516f, 0.18482918f, -0.17794745f, -0.01566449f, -0.12765966f, -0.02696772f, 0.18187469f, -0.00058696f, 
    -0.17549936f, -0.09435757f, -0.08422589f, -0.13087484f, -0.12635027f, -0.23234259f, -0.46428916f, -0.32547072f, 
    0.12103777f, -0.08837178f, 0.05948769f, 0.26426846f, -0.11431756f, 0.03111697f, 0.04270758f, -0.08381481f, 
    0.11982800f, 0.06914606f, -0.18926576f, -0.19853371f, -0.05984747f, 0.02810822f, 0.10274968f, -0.03843477f, 
    0.30857566f, 0.29133931f, 0.06440239f, 0.07970726f, -0.30861837f, -0.00734391f, -0.21542509f, -0.10252110f, 
    0.23481864f, -0.12844539f, 0.00128300f, 0.09692947f, -0.14210349f, -0.04899025f, 0.08952413f, 0.18846259f, 
    0.10277707f, -0.08766303f, -0.07075911f, 0.07792699f, 0.08644448f, 0.22364461f, -0.00186471f, 0.07889704f, 
    -0.02401648f, -0.00431492f, 0.07337563f, 0.14796124f, 0.05499621f, 0.16412489f, -0.01801378f, -0.01732183f, 
    -0.04853240f, 0.01903535f, 0.04226109f, 0.07652047f, 0.11781850f, 0.01968573f, -0.14622140f, -0.07570935f, 
    0.01378992f, -0.03607874f, 0.03600340f, 0.00741716f, -0.11889010f, -0.02142992f, -0.06885882f, -0.07918472f, 
    0.03795007f, -0.04912340f, -0.13801433f, -0.16807000f, 0.25916305f, 0.21931405f, -0.08051008f, -0.05804421f, 
    0.24901499f, -0.17885579f, -0.13284495f, -0.00376228f, -0.12993988f, -0.16916870f, -0.00638032f, -0.14539824f, 
    0.11084855f, 0.19072938f, -0.14840470f, -0.08795661f, 0.07568579f, 0.11006361f, 0.02297787f, 0.11455388f, 
    -0.05670708f, -0.09930460f, -0.08130741f, -0.20454933f, -0.09466421f, 0.10020253f, -0.22588311f, -0.07515491f, 
    -0.02226089f, -0.13118836f, -0.06792264f, 0.03128553f, 0.06990857f, -0.04569091f, -0.06883709f, -0.04309523f, 
    -0.00062332f, -0.02824594f, 0.24972565f, 0.11977696f, 0.00663506f, -0.07993387f, 0.00895274f, 0.21216169f, 
    0.02837854f, 0.01750426f, 0.02822769f, 0.02067243f, 0.19111119f, 0.28663224f, -0.05098548f, 0.15400892f, 
    0.10973754f, 0.01382505f, 0.09138247f, 0.05370796f, -0.01958692f, 0.06307570f, -0.16261446f, 0.04550893f, 
    0.07839670f, -0.07710526f, 0.02758705f, 0.09083905f, -0.01223580f, -0.04694095f, -0.00657376f, -0.01792907f, 
    0.08185168f, 0.11919963f, -0.01858302f, 0.15586127f, -0.05427436f, 0.18744765f, -0.07831455f, 0.07364333f, 
    -0.20409530f, -0.06097236f, -0.15610680f, -0.04910050f, 0.17796540f, -0.01219636f, 0.07201149f, 0.16878986f, 
    -0.00860112f, -0.11304993f, 0.10963003f, 0.10833553f, -0.09234178f, -0.16358982f, -0.05209437f, -0.06601632f, 
    -0.15744022f, -0.00038430f, -0.12199499f, -0.03005201f, -0.11393799f, 0.09352171f, 0.07205495f, 0.06389855f, 
    0.01203928f, -0.09547707f, -0.07174712f, -0.00712231f, -0.01099453f, -0.02188674f, -0.06897102f, 0.17918225f, 
    0.02924184f, 0.13880338f, -0.00209249f, 0.25647891f, -0.03444213f, 0.07593257f, 0.00508266f, -0.04697612f, 
    0.08693678f, 0.15617639f, -0.07907011f, -0.09374154f, 0.18698063f, 0.29989281f, 0.04696337f, 0.13280775f, 
    0.13826312f, 0.11076564f, 0.15408273f, 0.06164466f, 0.09440870f, 0.08636548f, 0.03544987f, 0.04975134f, 
    0.02878378f, 0.06466616f, -0.07126517f, 0.15005958f, 0.13403860f, 0.06745576f, 0.03524215f, 0.02449552f, 
    0.09303099f, -0.15127382f, -0.06901237f, 0.02239093f, -0.19328664f, 0.10350675f, 0.05133807f, 0.03651562f, 
    0.02290989f, -0.06349050f, 0.16852853f, 0.20544818f, -0.05302168f, 0.09892400f, -0.16850856f, -0.20262493f, 
    0.05870469f, 0.14630987f, 0.06909769f, 0.13665071f, 0.09011005f, 0.00652967f, -0.02809042f, 0.13861801f, 
    -0.02187488f, -0.11663458f, -0.18570574f, -0.26523075f, -0.02777731f, -0.10249006f, -0.15230067f, -0.10286344f, 
    -0.05490842f, 0.05399428f, -0.12735911f, 0.02219230f, 0.03647613f, 0.00562561f, 0.01223229f, 0.08186249f, 
    -0.08663788f, -0.28064001f, -0.21439229f, 0.09073394f, 0.05870739f, 0.08004836f, 0.07639774f, -0.08760796f, 
    0.19923195f, 0.14991492f, 0.06198004f, 0.04658829f, -0.06676943f, -0.00186047f, 0.18100511f, 0.17655818f, 
    0.02972288f, -0.18632115f, 0.02834853f, 0.14624269f, 0.02807767f, 0.15117982f, 0.10876980f, 0.12748630f, 
    0.52778363f, 0.31409568f, 0.32797447f, -0.01347260f, 0.10839408f, 0.17894793f, -0.09213869f, 0.28339848f, 
    0.11343063f, 0.03119533f, -0.06388891f, -0.15043905f, -0.00325534f, 0.02893551f, 0.19072624f, 0.05813010f, 
    -0.02383099f, -0.14208128f, 0.00524865f, -0.04983309f, 0.00774075f, -0.05059487f, 0.10318483f, 0.27418134f, 
    -0.09517355f, -0.39046097f, -0.08743402f, 0.05686967f, 0.09436403f, 0.06338686f, -0.09707332f, -0.20728521f, 
    0.04101029f, -0.01134636f, -0.15654281f, -0.12267917f, -0.15436450f, 0.02237052f, -0.08449759f, 0.19488455f, 
    0.06943201f, 0.12609519f, 0.11395297f, 0.10985306f, 0.04224158f, -0.05766978f, -0.09943806f, -0.06528448f, 
    -0.03705601f, -0.10141516f, -0.19426204f, -0.21688397f, 0.00646549f, -0.20798448f, -0.10653673f, -0.01348810f, 
    -0.08624630f, 0.05831310f, -0.17661925f, -0.12288304f, -0.14069545f, -0.12701757f, -0.18117481f, -0.03673325f, 
    -0.02475446f, 0.11049721f, -0.13159911f, -0.15388866f, -0.02546010f, -0.13798356f, -0.20279959f, -0.06697749f, 
    -0.32142529f, -0.17101872f, 0.11107698f, 0.33645195f, 0.08539942f, 0.05326638f, -0.09079801f, -0.03940059f, 
    0.06886168f, 0.06483471f, -0.10353424f, -0.02909033f, -0.08050094f, -0.23915473f, -0.19926788f, 0.08733766f, 
    -0.02454564f, 0.14722350f, -0.12693492f, -0.14427073f, -0.15944843f, -0.06962225f, -0.17392562f, -0.08425070f, 
    -0.06749240f, 0.10007844f, 0.01633755f, 0.22794911f, -0.01326035f, 0.06349152f, 0.08116692f, 0.00336614f, 
    -0.18122821f, 0.02013499f, -0.04892316f, 0.06976358f, 0.24076349f, 0.12216052f, 0.15908250f, 0.13946299f, 
    0.10310590f, 0.05491213f, 0.12564939f, 0.22561836f, 0.07192816f, -0.05232072f, -0.02726817f, 0.05878161f, 
    -0.05959768f, 0.11789405f, -0.27724493f, 0.10225511f, 0.03226736f, 0.05687447f, -0.18938513f, 0.13254146f, 
    0.18336289f, 0.06687040f, 0.22270554f, 0.30250016f, 0.01892496f, -0.08156379f, 0.02367269f, 0.18262070f, 
    0.12342268f, -0.08913981f, 0.00214435f, 0.04169193f, 0.17286316f, 0.04825103f, 0.00618610f, 0.17922047f, 
    0.03214371f, 0.06014126f, -0.06599874f, 0.02234097f, 0.01219351f, -0.06691495f, 0.01014363f, 0.01065222f, 
    0.06966542f, -0.02003160f, 0.05591521f, 0.03740606f, -0.04225025f, 0.06207402f, 0.00983283f, 0.04007630f, 
    0.00067179f, -0.00628885f, -0.06516837f, -0.05079424f, 0.02008136f, 0.07191740f, -0.06928481f, 0.01422882f, 
    0.02306633f, -0.06358124f, -0.03781536f, -0.04671244f, -0.00308817f, 0.01486914f, -0.00428384f, -0.04276851f, 
    0.05459060f, 0.02434015f, 0.00097927f, 0.00639138f, -0.02359462f, 0.04783689f, -0.07031056f, -0.03835690f, 
    0.00906333f, 0.04136422f, 0.05552173f, 0.00332677f, -0.06990384f, -0.04319526f, 0.02109838f, -0.05469656f, 
    -0.02566087f, -0.01909783f, 0.02697650f, 0.04724909f, -0.03737187f, -0.03334859f, 0.03560688f, -0.02444275f, 
    0.03854726f, -0.01108999f, -0.02794637f, -0.02060183f, -0.04483337f, 0.00659505f, -0.05331415f, 0.03822867f, 
    -0.06866510f, 0.00581973f, -0.04642394f, -0.01573621f, -0.01336103f, 0.06745445f, 0.05557553f, -0.04745527f, 
    -0.01426159f, -0.07046845f, 0.03493147f, -0.04760893f, -0.02755834f, 0.00597183f, -0.06983001f, 0.00420582f, 
    -0.06974049f, -0.04024073f, -0.01658956f, -0.06856968f, -0.03460667f, 0.02919288f, -0.06789568f, 0.07132620f, 
    0.06607763f, -0.01130543f, 0.00641267f, -0.04728214f, -0.03689320f, 0.00656428f, 0.03107083f, 0.00478630f, 
    -0.03891291f, 0.04321845f, -0.04265607f, -0.04540473f, -0.05438904f, -0.01091592f, -0.05241707f, -0.04338236f, 
    0.03504028f, -0.01091401f, -0.05675744f, -0.04971701f, -0.05688354f, 0.02752217f, -0.03122824f, 0.02454448f, 
    0.06600286f, 0.02972824f, -0.04543753f, -0.05797881f, -0.04624145f, -0.04599703f, -0.00877633f, -0.06205611f, 
    -0.04019480f, 0.06588447f, -0.06891934f, 0.03998767f, 0.05561775f, -0.05968795f, 0.05922233f, 0.03356318f, 
    -0.06711520f, -0.05100033f, 0.02014675f, -0.07172032f, -0.02620028f, -0.01883208f, 0.02013249f, 0.01447153f, 
    0.01970137f, 0.01693001f, -0.00870553f, -0.02465922f, -0.04132018f, 0.00730679f, -0.04063226f, 0.07076393f, 
    0.01103832f, 0.04406539f, -0.01022184f, 0.01552334f, 0.02060552f, -0.00244628f, -0.05597148f, -0.03693553f, 
    -0.06149530f, 0.01954650f, -0.01966994f, 0.05358560f, -0.03368960f, 0.05509828f, 0.00275738f, -0.06437689f, 
    0.04270112f, 0.00089711f, -0.05362727f, 0.06863756f, -0.03963827f, 0.04821429f, 0.02027667f, 0.05401046f, 
    -0.04477083f, 0.00575522f, 0.00637050f, -0.03281702f, -0.04709202f, 0.04854918f, 0.00211162f, -0.05557322f, 
    0.02694596f, -0.07184383f, 0.06574896f, -0.01641981f, -0.01790575f, 0.05108026f, -0.04339143f, 0.05410930f, 
    -0.05235633f, -0.04396808f, 0.05530495f, 0.06882510f, -0.04572083f, -0.01292267f, -0.06365576f, -0.03830244f, 
    -0.06573369f, -0.34667578f, -0.05325962f, -0.16033304f, 0.15296096f, 0.07962737f, -0.03107272f, 0.24655798f, 
    0.00043672f, -0.01151067f, 0.01383830f, 0.04608245f, -0.24518266f, 0.30868053f, 0.04544808f, 0.11022224f, 
    0.03089127f, -0.11402827f, 0.22523484f, 0.27290860f, 0.01678691f, 0.07159182f, 0.04578957f, -0.03411502f, 
    -0.28153524f, -0.00804562f, -0.23778205f, -0.21158579f, -0.06797709f, -0.18802744f, 0.00346388f, -0.06273025f, 
    -0.05940194f, -0.02865255f, -0.04740133f, -0.13056745f, -0.11702868f, -0.22712900f, -0.28028387f, -0.04549905f, 
    -0.14154218f, -0.00721319f, 0.07777533f, 0.06517684f, -0.09797446f, -0.06715937f, -0.05512501f, -0.09017693f, 
    -0.25495979f, 0.04379200f, 0.23925282f, 0.00572635f, -0.03493765f, 0.09626932f, -0.08444495f, -0.05966863f, 
    -0.05703726f, 0.09956501f, -0.11181605f, -0.11503396f, -0.10107315f, 0.12287413f, 0.06405425f, 0.20487632f, 
    -0.07442150f, 0.06257678f, -0.04048177f, 0.21980847f, 0.01240281f, 0.05920548f, 0.09342574f, 0.03546057f, 
    0.36441803f, -0.04627941f, 0.13976222f, 0.07318463f, -0.03939106f, -0.13103642f, 0.07083770f, 0.12253406f, 
    -0.09859270f, 0.00458735f, 0.06006501f, 0.04357607f, -0.13114464f, 0.31140113f, 0.17711851f, 0.13133216f, 
    0.12859917f, -0.03586470f, -0.05544007f, -0.11949617f, 0.04148087f, 0.02197674f, 0.08134544f, 0.01705640f, 
    0.18477705f, 0.06213656f, 0.09416048f, 0.03950406f, 0.08387568f, 0.17802714f, 0.08108043f, -0.00369444f, 
    0.15366803f, 0.06122694f, -0.04526568f, -0.02430590f, -0.25537568f, -0.12415721f, -0.13866225f, -0.11739968f, 
    0.04260214f, 0.08566200f, -0.00427899f, 0.25371093f, 0.00631062f, 0.02708279f, 0.16784339f, 0.10928134f, 
    0.05497232f, 0.31452134f, -0.28997964f, -0.20474210f, 0.15210828f, -0.09557874f, 0.13569126f, 0.03331568f, 
    -0.01016049f, 0.10532632f, 0.24432272f, 0.02556092f, -0.09226631f, 0.10552201f, 0.02468432f, -0.07898609f, 
    -0.19543903f, -0.14027417f, -0.14567432f, 0.00968859f, -0.05192891f, -0.02479164f, -0.01078464f, 0.00264431f, 
    0.08597755f, 0.25433770f, 0.26941368f, 0.24809319f, 0.11741378f, -0.03234977f, 0.03326189f, -0.02459588f, 
    0.07666807f, -0.01448082f, 0.13152191f, 0.09750669f, -0.44403905f, -0.33579761f, -0.34894007f, -0.17421788f, 
    0.04927053f, 0.08646446f, -0.05945140f, -0.13476636f, 0.02307269f, 0.01159942f, -0.02087644f, -0.00509160f, 
    0.19929817f, -0.07393058f, 0.04088221f, 0.06716172f, 0.06257173f, -0.03221329f, -0.07582385f, 0.11861113f, 
    -0.00652182f, 0.12563668f, 0.04710133f, 0.01595314f, 0.33341852f, -0.14151701f, -0.03895561f, -0.14972588f, 
    0.03272918f, 0.12493651f, 0.01940917f, 0.04710605f, -0.18652168f, 0.01925603f, 0.01836651f, 0.04548141f, 
    -0.02383676f, -0.20346524f, -0.15419476f, -0.31325066f, -0.15810764f, 0.03034690f, 0.28302440f, 0.11300383f, 
    0.11955650f, 0.03432410f, 0.00594881f, -0.06615660f, 0.02381664f, 0.17178114f, 0.16398641f, 0.18684524f, 
    0.12590149f, -0.06748094f, 0.03338754f, 0.14098230f, 0.03860255f, 0.00366453f, 0.13799630f, 0.04302404f, 
    0.03914787f, 0.04901083f, 0.08211127f, -0.07082913f, -0.08257589f, -0.06768398f, -0.00745348f, 0.00544300f, 
    0.03773508f, -0.01891988f, 0.09938338f, -0.02215150f, -0.34289253f, -0.21635406f, -0.14105190f, 0.10457038f, 
    -0.09542627f, 0.42790303f, 0.22336441f, 0.07154873f, -0.09814826f, -0.07790005f, -0.07676864f, 0.14806470f, 
    -0.22028634f, -0.05302947f, -0.21741030f, 0.24061669f, -0.00993621f, 0.08449430f, -0.01573945f, -0.07752442f, 
    0.04736472f, 0.08243053f, 0.04576717f, 0.11136739f, 0.07267150f, -0.25332415f, -0.21751668f, -0.32663685f, 
    -0.13059442f, -0.11363915f, -0.01132277f, -0.01283808f, 0.07768920f, 0.07015164f, 0.03044412f, -0.02330922f, 
    -0.01348373f, 0.00059819f, -0.01207089f, -0.05837579f, -0.09717371f, -0.04630155f, -0.08901949f, 0.03372287f, 
    -0.04012705f, -0.01626017f, -0.18459581f, 0.06402001f, -0.09362561f, -0.18897393f, 0.13784111f, 0.03169532f, 
    0.00492099f, -0.04321826f, 0.09906838f, -0.09037710f, -0.12510125f, -0.07664914f, 0.08990563f, 0.15787449f, 
    0.03881063f, 0.19021280f, 0.08207326f, 0.07186143f, -0.03519680f, 0.00145086f, -0.07969422f, -0.01684218f, 
    -0.02841388f, -0.09838054f, -0.05719012f, 0.09802309f, 0.16124941f, -0.03077329f, 0.05202029f, -0.16955887f, 
    0.04687963f, -0.12032079f, -0.05028866f, -0.11205886f, 0.07854684f, 0.02012366f, 0.04106700f, -0.13773327f, 
    0.12129091f, 0.14397372f, 0.23801346f, -0.18764880f, 0.01575017f, -0.04507807f, -0.06137036f, -0.01078934f, 
    -0.09147639f, 0.20125768f, -0.12003691f, 0.02015425f, 0.10692209f, 0.01794346f, 0.06662251f, 0.10924914f, 
    0.00265236f, -0.05238320f, -0.07298554f, -0.07159826f, -0.04234052f, -0.07203381f, -0.00490718f, -0.20631947f, 
    0.56494921f, -0.06767729f, -0.10182650f, -0.11682875f, -0.08284911f, -0.11473492f, 0.01026979f, -0.08300245f, 
    0.00656327f, 0.13814503f, 0.04029246f, -0.02308734f, -0.33585486f, 0.00065452f, -0.01543898f, 0.37275362f, 
    0.10895683f, 0.14202744f, 0.05326916f, -0.19820063f, -0.04253523f, 0.00461646f, -0.04216829f, -0.07734870f, 
    0.40942675f, 0.02914446f, 0.03574017f, 0.01476464f, 0.00849710f, -0.01643022f, 0.08374271f, 0.05360245f, 
    -0.07526965f, 0.30359316f, 0.19112805f, -0.09593094f, -0.04932978f, -0.37524977f, 0.11823963f, 0.14497709f, 
    -0.21707536f, 0.13612656f, -0.11485646f, -0.16538046f, -0.15881445f, -0.08394048f, -0.11233387f, 0.07018973f, 
    -0.26546231f, 0.07104764f, 0.08259451f, 0.05447143f, 0.09646922f, 0.15165786f, 0.11132864f, -0.00732902f, 
    -0.10604911f, 0.06518569f, -0.14342451f, -0.06836459f, 0.49844024f, -0.37709630f, 0.18803827f, -0.05674387f, 
    -0.18114273f, 0.13202068f, -0.17107721f, 0.04116679f, 0.11108769f, -0.00257985f, 0.07039284f, 0.12645447f, 
    -0.07554355f, -0.14767326f, -0.14406863f, -0.11491278f, -0.10903212f, -0.11186225f, -0.22619605f, -0.11964089f, 
    0.11338517f, 0.00836555f, 0.01782670f, 0.03044937f, -0.13029039f, 0.09071048f, 0.22058429f, 0.10538352f, 
    0.01391221f, -0.02037952f, 0.06568065f, 0.05135651f, 0.06270726f, -0.12495620f, 0.13632238f, -0.03083264f, 
    0.23546866f, -0.04346284f, -0.20764388f, -0.37899697f, 0.06646445f, -0.39722577f, 0.05354023f, 0.02678308f, 
    -0.06997363f, 0.01788016f, -0.03287712f, -0.01225174f, 0.28996161f, 0.41301861f, 0.22965609f, 0.13646787f, 
    -0.13038875f, 0.06313202f, 0.11310262f, -0.15592639f, 0.05722677f, 0.12958013f, 0.01273671f, 0.13146535f, 
    -0.18608746f, 0.03208826f, -0.51569396f, 0.02608453f, 0.12833959f, 0.13741063f, -0.04273024f, -0.01358389f, 
    0.11014299f, 0.02706633f, 0.05323670f, 0.06806250f, -0.03454590f, -0.08361421f, -0.12181339f, -0.15375355f, 
    0.10940114f, 0.22679532f, -0.06989003f, 0.20888309f, 0.13454382f, -0.14032239f, 0.03686342f, -0.01908988f, 
    -0.09765615f, -0.03796810f, -0.09296215f, 0.11996269f, 0.14190039f, 0.01084308f, 0.12763377f, -0.14211100f, 
    -0.11992905f, -0.05131206f, -0.04497602f, 0.16779633f, -0.07187000f, -0.09082025f, -0.10987550f, -0.10125019f, 
    -0.05775398f, -0.15801449f, -0.11239508f, 0.07851978f, -0.12177003f, -0.01993647f, -0.07001430f, 0.07537182f, 
    -0.07456791f, -0.16804688f, 0.19835964f, 0.29702160f, -0.08795647f, -0.22741933f, 0.05930188f, 0.06933712f, 
    0.14025018f, 0.02152651f, 0.10387372f, 0.07126610f, -0.27390262f, -0.18425639f, -0.35024121f, 0.01061236f, 
    0.05371746f, 0.10370561f, 0.16008793f, -0.12406392f, 0.05089692f, 0.08106826f, -0.26351899f, -0.04386555f, 
    -0.16622491f, 0.03102992f, 0.19982706f, -0.41176829f, 0.21487720f, 0.03910011f, -0.10385421f, 0.18685226f, 
    -0.14022306f, -0.07154953f, 0.10713057f, -0.03393093f, -0.16082482f, 0.03182213f, 0.41684502f, -0.01163528f, 
    -0.03491212f, -0.04704209f, 0.22141211f, 0.09718740f, -0.03353603f, 0.04416008f, 0.05860130f, 0.01852719f, 
    -0.18961641f, 0.16919076f, 0.31808713f, -0.36416537f, 0.02972559f, -0.09537096f, -0.33360189f, -0.10926142f, 
    0.08891907f, -0.02126006f, 0.11255974f, 0.23363811f, -0.44874120f, 0.13845029f, -0.14469744f, 0.31230134f, 
    0.17063902f, -0.23051962f, -0.14167100f, -0.03952453f, 0.06116924f, -0.11814015f, -0.14589866f, 0.06847406f, 
    0.21130903f, 0.16398029f, 0.15321800f, 0.16544296f, 0.07371685f, -0.08071127f, -0.10713452f, 0.03236056f, 
    0.11176404f, -0.02382147f, 0.05101999f, 0.01848725f, -0.32844737f, 0.06260064f, -0.24793491f, 0.05196517f, 
    0.06412981f, 0.07968758f, -0.07531176f, -0.10084161f, -0.03953471f, 0.04952290f, -0.02391565f, 0.12769425f, 
    -0.18337309f, -0.26003286f, -0.12675640f, -0.08169051f, 0.11122818f, 0.09495462f, 0.01649438f, 0.00337387f, 
    0.15826879f, 0.16784048f, 0.25283742f, 0.14867069f, -0.02335911f, -0.04054153f, 0.13241456f, 0.05881342f, 
    0.13371940f, -0.14559871f, 0.03026630f, -0.10479228f, -0.07068632f, 0.09203054f, -0.04883203f, 0.06460489f, 
    0.26283425f, 0.41305643f, 0.60176903f, 0.07011565f, 0.09388047f, 0.26065168f, -0.07931793f, 0.17860784f, 
    0.13758512f, -0.07625864f, 0.00380930f, -0.06567238f, -0.14459130f, 0.00483777f, 0.09384276f, 0.13885038f, 
    0.11873756f, -0.07838159f, 0.04568768f, 0.09237793f, -0.04286063f, -0.12291070f, 0.03492489f, 0.02707619f, 
    -0.21635860f, -0.29679754f, 0.23282330f, -0.06565865f, -0.10100828f, 0.00791798f, 0.00835713f, 0.02946205f, 
    0.06790803f, 0.01398474f, 0.02873548f, -0.09399651f, 0.02122558f, 0.24373420f, 0.26814008f, 0.30086884f, 
    0.27249578f, 0.02689263f, 0.01374741f, 0.02617596f, 0.00707778f, 0.02354833f, -0.04876379f, -0.05700765f, 
    -0.16103818f, -0.07150783f, 0.00750343f, -0.10425572f, 0.02639054f, -0.16982897f, -0.16617262f, 0.07577356f, 
    -0.02409426f, -0.04177834f, 0.15152986f, 0.07256406f, 0.09219968f, 0.03032589f, -0.16051745f, 0.15551768f, 
    -0.03455669f, 0.07917577f, 0.05896642f, 0.08104998f, -0.03917933f, -0.12795985f, -0.09181989f, 0.05389601f, 
    -0.17330259f, -0.25429428f, 0.04042165f, -0.14503913f, -0.08507072f, 0.03654133f, -0.05934909f, 0.05473707f, 
    -0.15436324f, -0.01387543f, -0.10771167f, 0.16180883f, -0.16769038f, -0.10914984f, -0.19361967f, -0.23697139f, 
    0.00106102f, -0.03618334f, 0.06688050f, 0.10467314f, -0.03700240f, -0.04058845f, -0.02965979f, 0.05834761f, 
    -0.33329320f, -0.01400126f, -0.20046605f, 0.55741078f, -0.11228719f, 0.04211352f, -0.02453369f, 0.01137871f, 
    0.09351460f, -0.00024655f, -0.02932979f, -0.01402521f, 0.18557754f, 0.08749864f, -0.03625384f, 0.29063016f, 
    0.00724511f, -0.05806171f, 0.07518003f, 0.21781175f, -0.08079488f, 0.02462959f, -0.03844316f, -0.00336902f, 
    -0.23204504f, 0.01279212f, -0.39560553f, 0.15441847f, 0.07176614f, -0.04595211f, 0.09077254f, -0.12066344f, 
    0.13857818f, 0.03614510f, 0.09833413f, 0.06526147f, 0.17560264f, -0.15283525f, 0.03874831f, -0.04479867f, 
    -0.20353876f, -0.06303639f, 0.18238673f, -0.04112058f, -0.06719940f, -0.06556029f, 0.01827126f, 0.04547860f, 
    0.06304896f, -0.10054497f, -0.03604442f, 0.16835040f, 0.15156879f, 0.19809158f, 0.08531117f, -0.28972781f, 
    0.04137770f, -0.02766165f, 0.03326010f, 0.08901094f, 0.22902797f, -0.01805881f, 0.30464587f, 0.08692937f, 
    0.03269837f, -0.00147286f, 0.00051094f, 0.05125449f, -0.28528437f, 0.03954719f, -0.09505438f, -0.12087440f, 
    0.00669111f, -0.05294198f, 0.10854571f, 0.04819974f, 0.05682969f, 0.04221228f, -0.02074420f, -0.00278756f, 
    0.12231045f, 0.13812843f, 0.01970741f, 0.05898028f, -0.14255112f, 0.09775623f, 0.08106415f, -0.07440569f, 
    -0.28377771f, -0.50559747f, -0.24759017f, -0.02053056f, -0.28671485f, -0.27112707f, -0.17349605f, -0.11393533f, 
    0.23381338f, 0.21174224f, 0.19365750f, 0.19671552f, -0.23486708f, -0.06724741f, 0.00848801f, -0.12644440f, 
    0.01144459f, 0.02703105f, 0.01923130f, -0.01127580f, 0.15818094f, 0.10605553f, -0.01528568f, -0.15422033f, 
    -0.10202052f, -0.10699730f, 0.02084092f, 0.15214561f, -0.20639274f, -0.10076663f, 0.02051419f, 0.07745100f, 
    -0.10268285f, 0.31077084f, 0.03861745f, 0.06653153f, -0.03588040f, -0.11069186f, -0.05929276f, -0.14251828f, 
    0.15153572f, -0.01582590f, 0.03364209f, 0.06528036f, -0.09965778f, -0.19701706f, -0.14363992f, -0.08963494f, 
    -0.23000845f, -0.20289606f, 0.01830168f, 0.13736862f, -0.00758047f, -0.02960496f, -0.00138781f, -0.14595923f, 
    -0.03458242f, 0.08374641f, 0.03406563f, 0.05713319f, 0.04967877f, 0.01336750f, -0.07043760f, -0.08669282f, 
    0.09554609f, -0.14994940f, -0.02204349f, -0.01177061f, 0.13818711f, 0.14737180f, 0.04614961f, -0.04490802f, 
    0.03021968f, -0.04591679f, 0.00450086f, 0.11763767f, -0.06880831f, 0.09351961f, -0.05284603f, 0.06719840f, 
    0.16620512f, 0.10349222f, 0.17488886f, 0.04131227f, -0.03343500f, 0.11754536f, -0.06219567f, 0.07517029f, 
    -0.23856220f, -0.15773688f, -0.03776797f, -0.05126148f, 0.10077725f, 0.06863215f, 0.09862747f, 0.07913770f, 
    -0.00185598f, 0.00142056f, 0.02206340f, 0.01111097f, 0.01177769f, -0.00380421f, -0.08355646f, -0.00422535f, 
    -0.03325805f, 0.08638300f, 0.05084957f, 0.08253395f, -0.14968309f, 0.00252797f, -0.01766479f, -0.06554246f, 
    0.05290969f, 0.12288488f, -0.12434220f, 0.02765927f, 0.05182783f, -0.12875172f, -0.05532374f, -0.07648684f, 
    0.25752479f, 0.13101864f, -0.00175100f, 0.10075623f, -0.24634488f, -0.09502911f, -0.07509157f, -0.08099757f, 
    -0.35678542f, 0.06567154f, 0.06515998f, -0.10020068f, -0.08450114f, 0.06491416f, -0.07723530f, -0.18335807f, 
    0.21995318f, 0.20532714f, -0.08807259f, 0.16753384f, 0.22156368f, 0.16078758f, 0.04951647f, 0.33196184f, 
    -0.10083023f, -0.45487598f, -0.18404822f, 0.01822910f, -0.25326461f, -0.07361585f, -0.26033059f, -0.33145946f, 
    0.12096889f, -0.07736621f, 0.02890555f, -0.01516869f, -0.14416705f, -0.18961702f, -0.18894643f, 0.15945916f, 
    0.01138581f, -0.07559532f, -0.13144377f, -0.24573967f, -0.17847392f, -0.03243710f, -0.48853073f, 0.18766962f, 
    0.04049233f, 0.12066631f, 0.10381123f, 0.02750962f, -0.18153921f, 0.07112493f, 0.08538207f, 0.09646028f, 
    -0.00579712f, -0.04622188f, -0.04544979f, -0.01958261f, 0.11952610f, 0.00838979f, 0.01105307f, 0.08580333f, 
    0.06277293f, 0.01023741f, 0.23601879f, 0.23152012f, -0.06751537f, -0.22492108f, 0.03896029f, 0.24521576f, 
    0.00460916f, 0.16815120f, 0.13432018f, 0.02732492f, 0.08532271f, 0.10464783f, 0.12385270f, 0.27025035f, 
    0.20760414f, 0.02175404f, 0.41378176f, 0.21981385f, 0.02676589f, -0.06358848f, -0.11650360f, 0.01837367f, 
    0.04958720f, 0.04327522f, 0.04983175f, -0.03437096f, 0.03819647f, 0.01871539f, 0.24701637f, 0.15670145f, 
    0.03767028f, -0.07850523f, -0.02009519f, 0.01742206f, 0.01121211f, 0.05682228f, 0.10401099f, 0.18239813f, 
    0.03311915f, -0.18472604f, -0.10496935f, -0.14950424f, 0.09876726f, 0.11164512f, -0.10222670f, -0.09778602f, 
    -0.02447360f, -0.18089344f, -0.17768210f, 0.02315556f, -0.30942073f, -0.30352205f, 0.03940579f, 0.15769535f, 
    0.15303563f, 0.12310962f, -0.03876224f, -0.07544947f, -0.06261330f, -0.15415311f, 0.01880303f, -0.04551382f, 
    0.15891053f, -0.15131792f, 0.09382331f, -0.05845053f, 0.10347924f, -0.12587102f, -0.08504423f, 0.04759049f, 
    0.03844821f, -0.01752809f, -0.11008588f, -0.03743363f, -0.05927119f, -0.06844553f, -0.15779808f, -0.05368470f, 
    0.03658121f, -0.00847836f, 0.06582732f, -0.07347877f, -0.09613888f, 0.01656334f, -0.14867212f, -0.04845578f, 
    -0.03408587f, -0.05384595f, 0.00945857f, 0.01327991f, -0.05820246f, 0.08609701f, -0.05169538f, -0.05813112f, 
    0.04547859f, 0.18517992f, 0.13606209f, 0.20027891f, 0.24500391f, 0.11618551f, -0.07683867f, 0.14006260f, 
    -0.05912114f, 0.07331745f, -0.01938304f, 0.02473840f, -0.07586448f, -0.11775259f, -0.17750223f, -0.21883452f, 
    -0.07851622f, -0.01014557f, 0.10454226f, 0.25107178f, 0.04192156f, -0.12726222f, 0.08154698f, -0.01329663f, 
    -0.10345848f, -0.09365274f, 0.05182763f, 0.08714238f, 0.09762884f, -0.11795114f, 0.16840236f, 0.00545061f, 
    -0.02675259f, -0.05571600f, 0.08030090f, 0.24566144f, -0.11343937f, -0.11185188f, -0.02280859f, -0.09590895f, 
    -0.07774612f, 0.02597194f, 0.07054303f, 0.17391801f, -0.07361212f, -0.09557194f, -0.06615123f, 0.03098206f, 
    -0.10100354f, 0.18115102f, 0.03251827f, 0.04271391f, 0.26149547f, -0.05605933f, 0.04271309f, 0.03035994f, 
    0.01144615f, 0.20459519f, 0.05472120f, -0.05629899f, 0.08872771f, 0.00401152f, 0.05144610f, 0.16003470f, 
    0.04810137f, 0.16880742f, 0.07498584f, 0.06245790f, 0.06829771f, 0.20477679f, 0.05574593f, 0.06979617f, 
    -0.12742400f, -0.00923699f, -0.02516194f, -0.01637163f, 0.29158160f, -0.31468442f, 0.20362480f, -0.01867943f, 
    -0.04062538f, -0.06094302f, -0.13960619f, -0.01713804f, 0.21268092f, -0.02904715f, 0.02968550f, 0.12201861f, 
    0.09061209f, -0.10223406f, 0.09836575f, 0.04106929f, -0.06925286f, 0.02588828f, 0.04819935f, 0.01416368f, 
    0.08093542f, 0.08155774f, -0.16349755f, -0.08844041f, 0.18007299f, 0.19794638f, 0.14006986f, -0.16430297f, 
    0.01035392f, 0.03052055f, 0.17758624f, 0.03402960f, 0.02307085f, -0.20744543f, 0.02078642f, -0.10505299f, 
    -0.13314112f, 0.08803079f, -0.42842776f, 0.04595492f, 0.01491929f, -0.18233167f, 0.00385904f, 0.01140597f, 
    -0.15964420f, 0.01579198f, -0.01079208f, -0.04352429f, 0.04325100f, -0.01288948f, -0.02558447f, -0.11505511f, 
    0.04107966f, 0.04857545f, 0.01172588f, -0.04453540f, 0.00885575f, 0.02558075f, 0.05939631f, -0.03442686f, 
    -0.10766261f, 0.13954043f, -0.04480251f, 0.16818494f, -0.00953539f, -0.00760184f, 0.06533827f, 0.03392364f, 
    0.04986354f, -0.00478924f, 0.07443253f, -0.03185660f, 0.26137495f, -0.13731489f, -0.26426503f, -0.33857810f, 
    -0.19326256f, -0.00839602f, 0.17960039f, 0.15252978f, 0.18781139f, 0.08518509f, -0.01974923f, -0.01948231f, 
    -0.04196393f, -0.05089881f, -0.01329124f, 0.14080553f, -0.02300026f, 0.06472063f, 0.11089045f, -0.21919088f, 
    0.05453115f, 0.05413357f, -0.05831473f, -0.08241255f, 0.02964030f, -0.01431195f, 0.03213631f, 0.01115020f, 
    0.00255805f, -0.03158852f, -0.11513124f, 0.04773291f, -0.07784690f, -0.01497408f, 0.00082823f, -0.14711373f, 
    0.35855731f, -0.11099803f, -0.03716086f, 0.12986688f, -0.02014257f, 0.06047459f, 0.05768851f, -0.09800387f, 
    0.09841907f, -0.00189359f, 0.14319701f, -0.02991333f, -0.13045433f, -0.14614281f, -0.04642424f, 0.02248465f, 
    -0.06546438f, -0.00552584f, 0.07690874f, -0.03827292f, 0.03683272f, 0.11196208f, -0.06840500f, 0.09977129f, 
    -0.08718727f, -0.02897727f, 0.04277759f, -0.25666800f, 0.04943231f, 0.05029568f, -0.07452551f, 0.00629929f, 
    -0.00146642f, -0.05479478f, 0.02377303f, -0.09588898f, 0.12074775f, 0.06190425f, 0.06284101f, -0.27161601f, 
    0.11982312f, -0.04265827f, 0.06096114f, 0.02244358f, 0.00507214f, 0.06279683f, -0.03086363f, 0.00897991f, 
    -0.10646398f, 0.07321714f, 0.09102022f, -0.10040955f, 0.01918027f, 0.08449817f, -0.12755708f, 0.07230008f, 
    0.07651880f, -0.10860591f, 0.05984189f, 0.22845894f, -0.26163426f, 0.21744777f, 0.02604557f, 0.03442998f, 
    0.04353053f, -0.07951048f, -0.09654424f, 0.07882892f, 0.14991704f, -0.03827008f, -0.10338623f, -0.02629384f, 
    -0.16570129f, -0.30097216f, -0.10830691f, -0.06800004f, 0.17321295f, -0.05109829f, 0.26985011f, 0.22517613f, 
    0.06960532f, -0.01257489f, 0.08255545f, -0.01481147f, -0.15874909f, -0.17875691f, 0.19911101f, -0.03601258f, 
    0.09912905f, -0.13104178f, 0.17177273f, 0.02008180f, 0.11503919f, 0.11011900f, 0.15438482f, -0.03895006f, 
    0.05466295f, 0.03642479f, 0.02289169f, -0.06781676f, -0.03283619f, -0.02207220f, 0.08715515f, -0.05431603f, 
    -0.17810817f, -0.02784284f, 0.13185330f, 0.00663640f, -0.04263023f, -0.34190026f, -0.04508269f, -0.09252334f, 
    -0.10740077f, 0.04524766f, 0.05439815f, 0.12168022f, -0.03622686f, -0.12533729f, -0.08234598f, 0.12554640f, 
    -0.68931347f, 0.10885577f, 0.12000766f, 0.10240442f, 0.09409918f, 0.15094250f, 0.05788007f, -0.03260846f, 
    -0.03536349f, -0.03410794f, 0.02351007f, -0.04409445f, 0.02216781f, -0.15038943f, 0.13126950f, 0.11571311f, 
    0.03296124f, -0.04837177f, 0.02167797f, -0.00103168f, -0.05097693f, 0.14648452f, 0.12977509f, 0.20162168f, 
    0.19694921f, -0.01786002f, -0.19705629f, 0.05041369f, -0.02688930f, -0.06511874f, -0.04664873f, 0.06356854f, 
    -0.04667816f, 0.00600578f, -0.10424159f, -0.00849280f, -0.30937284f, 0.00777721f, 0.01269326f, -0.02725325f, 
    0.13336433f, 0.17133266f, -0.00418831f, 0.15877339f, -0.02056139f, -0.08621184f, 0.13235496f, -0.08142943f, 
    0.02264101f, 0.13143131f, -0.01091146f, -0.07376233f, 0.21275775f, -0.04031456f, -0.03954370f, -0.05135150f, 
    0.09921669f, -0.04324258f, 0.11953676f, 0.06713810f, 0.12901162f, -0.03244671f, 0.15679847f, -0.17549650f, 
    0.15915765f, 0.06854785f, 0.07385281f, 0.07870556f, 0.13112538f, 0.13111928f, 0.24860533f, 0.09028657f, 
    0.31607503f, 0.03720608f, -0.03885667f, -0.08936885f, 0.05301839f, -0.08628124f, -0.03721226f, -0.06663841f, 
    -0.02017258f, -0.04552378f, 0.27895951f, 0.00033315f, 0.04523913f, -0.02831214f, 0.03239449f, -0.14359508f, 
    0.07801233f, 0.06817266f, 0.01588623f, 0.08237905f, 0.09719630f, -0.02689299f, 0.10131510f, -0.06044017f, 
    -0.25205052f, -0.05119476f, 0.05650265f, 0.14593524f, 0.00353536f, 0.03702698f, 0.03492439f, -0.08706063f, 
    -0.04627714f, -0.06606210f, 0.04212949f, 0.18671840f, 0.01268060f, -0.21425098f, -0.23982386f, -0.26108047f, 
    0.04688774f, -0.07052802f, -0.06364415f, 0.06078554f, -0.01171189f, -0.03764598f, -0.02599862f, -0.01283019f, 
    -0.16234209f, 0.18225808f, 0.04594753f, -0.12064083f, -0.08941384f, 0.00981108f, -0.13892297f, 0.05161278f, 
    -0.05188696f, -0.09962571f, -0.02424539f, 0.03738280f, 0.10166223f, -0.05724018f, -0.18190269f, 0.10875259f, 
    0.15564494f, 0.22407967f, 0.02808449f, 0.05196354f, -0.01050287f, -0.11010396f, 0.03728987f, 0.15762812f, 
    -0.09181911f, 0.00254327f, 0.06131772f, -0.05186861f, 0.14712891f, 0.06869034f, -0.05093303f, 0.03827801f, 
    -0.26714146f, -0.04957750f, -0.07120688f, -0.04321056f, 0.09679403f, 0.15288475f, -0.19256653f, -0.36274946f, 
    -0.01302807f, 0.08555419f, 0.00037186f, -0.03591743f, 0.11308919f, 0.01724336f, 0.01168661f, -0.08239172f, 
    -0.11716846f, 0.05152985f, 0.04254390f, 0.06743517f, -0.06255133f, -0.01062653f, -0.03857224f, -0.02365175f, 
    0.15882584f, 0.28212914f, -0.01923604f, 0.01041406f, 0.05092135f, -0.09099109f, -0.11947328f, -0.11855260f, 
    -0.15225215f, -0.16467437f, -0.17690365f, -0.05160862f, -0.07575011f, -0.11911392f, -0.21347350f, -0.19586687f, 
    -0.10393859f, 0.15950814f, 0.28319556f, 0.14526393f, 0.02239190f, -0.12377299f, -0.01924451f, -0.12368999f, 
    -0.01906592f, 0.00909500f, -0.09586260f, -0.09059187f, -0.35270780f, -0.16724622f, -0.20442767f, -0.03243636f, 
    -0.09361108f, 0.06630932f, 0.02345906f, 0.09544528f, 0.01619062f, 0.16657473f, 0.15348095f, -0.08585578f, 
    0.03767347f, -0.06177864f, 0.12726708f, 0.18021260f, 0.02280243f, -0.01547299f, 0.10564304f, -0.08811171f, 
    0.19102469f, -0.06627965f, 0.16269310f, 0.01776405f, 0.08168997f, 0.20509489f, 0.02644497f, 0.08187403f, 
    0.35561636f, 0.01575724f, -0.11322918f, -0.10146166f, 0.04692314f, 0.10054404f, -0.05412351f, 0.01593577f, 
    0.16160989f, -0.10266140f, 0.06869423f, 0.02613469f, -0.04546296f, 0.04202307f, -0.06159469f, 0.09884267f, 
    0.14553908f, -0.05453057f, -0.06707980f, 0.13204062f, -0.04923341f, 0.10943837f, -0.03745482f, -0.08831614f, 
    0.05880386f, 0.02402011f, 0.11496751f, 0.13004388f, 0.20318285f, 0.05450424f, 0.27628252f, 0.11915061f, 
    -0.01479748f, 0.14939256f, 0.03987247f, -0.26923859f, -0.21526046f, 0.11943666f, 0.14950918f, 0.07145265f, 
    0.07486393f, -0.01120022f, 0.18532267f, 0.03622153f, 0.06449659f, 0.18936554f, 0.18865207f, 0.10951643f, 
    0.08085515f, 0.03259028f, 0.06091861f, 0.06521674f, 0.04972937f, -0.01111010f, 0.04008223f, 0.14425868f, 
    0.39425680f, 0.20443304f, 0.01469095f, 0.09471648f, 0.02127649f, -0.13286246f, 0.00305243f, 0.04769053f, 
    0.04007011f, -0.09193491f, 0.00525500f, -0.08332039f, -0.03173243f, -0.04201370f, 0.08265517f, -0.11947543f, 
    -0.12878868f, -0.07176425f, 0.08204322f, -0.03937144f, -0.04823775f, -0.04169184f, -0.00053106f, -0.15381166f, 
    0.22146107f, -0.26441520f, -0.20791505f, 0.13947877f, 0.02218893f, -0.01083647f, -0.06839162f, -0.01743339f, 
    0.28529814f, 0.24235305f, -0.14058736f, -0.12530579f, -0.04273929f, 0.08042046f, -0.02964726f, -0.15486830f, 
    0.13341148f, -0.25066701f, 0.19657111f, 0.08159895f, -0.20066366f, -0.05523977f, 0.03132765f, -0.11209800f, 
    0.16999893f, 0.06256346f, 0.00015579f, 0.20511493f, 0.00836742f, 0.11602809f, 0.05938846f, -0.06221302f, 
    -0.01660104f, 0.01548713f, 0.01790893f, 0.15172388f, -0.14534365f, 0.42608580f, 0.02984848f, 0.09936991f, 
    -0.11791871f, 0.01198962f, 0.17972024f, 0.01669220f, 0.00511567f, -0.00376835f, -0.07600591f, -0.05932889f, 
    -0.10811040f, -0.09302153f, -0.08015040f, -0.05105441f, -0.06098439f, -0.06469833f, -0.03226423f, -0.09275092f, 
    -0.11327510f, 0.05657648f, -0.16714893f, -0.22779469f, 0.26460382f, 0.00704340f, -0.23691215f, 0.00941918f, 
    0.18377152f, -0.01873918f, -0.12097897f, 0.15652306f, -0.00313565f, 0.00090846f, -0.00537579f, -0.08519852f, 
    -0.00731829f, 0.07003115f, 0.15652901f, 0.26491189f, -0.15851986f, 0.09395420f, -0.03302514f, -0.11332127f, 
    -0.06640626f, -0.00652743f, 0.02168727f, 0.03181817f, -0.09433817f, -0.42723173f, -0.18216984f, -0.06491872f, 
    0.04335846f, 0.07240488f, 0.01463401f, 0.04067733f, -0.06702346f, -0.02063514f, 0.00990175f, -0.17029940f, 
    -0.00074353f, 0.00363057f, 0.18352589f, -0.05884878f, -0.03563627f, -0.12765907f, 0.07037134f, 0.05882710f, 
    0.01405858f, 0.03774480f, 0.04497564f, -0.01037384f, 0.22487760f, 0.26836693f, 0.00187450f, 0.24165490f, 
    -0.06332409f, -0.06156127f, -0.02119203f, 0.01093759f, 0.07116694f, -0.01325789f, -0.03121258f, 0.01252106f, 
    0.18322551f, -0.06439873f, 0.06127707f, -0.04305084f, 0.12200991f, -0.02890565f, -0.04889482f, 0.03994452f, 
    0.12713328f, 0.10034561f, 0.14190386f, 0.04329520f, -0.06790207f, 0.05971972f, -0.03438574f, -0.00316455f, 
    -0.09468200f, -0.01816838f, -0.00946175f, -0.12150347f, 0.26328421f, 0.08596826f, 0.27704108f, 0.20008634f, 
    -0.19611013f, 0.24563450f, -0.19149885f, -0.21083297f, 0.04408950f, -0.05848674f, 0.02071166f, -0.05850461f, 
    -0.16021508f, -0.08570923f, -0.15546365f, 0.02698065f, -0.01844122f, 0.10238726f, 0.13590741f, -0.05693769f, 
    -0.04353101f, -0.11561017f, -0.09512533f, -0.12493096f, -0.01389049f, 0.08107221f, 0.00695344f, 0.06278771f, 
    -0.01915452f, -0.03319389f, 0.13596365f, 0.29728064f, -0.02764118f, -0.05022748f, -0.11415650f, -0.02580008f, 
    0.00123542f, 0.00862316f, 0.02434294f, -0.04590311f, 0.21644881f, 0.02092173f, -0.15003313f, 0.04019375f, 
    0.14984830f, 0.22983992f, 0.02630855f, 0.09109094f, 0.17478025f, 0.05912561f, -0.04188119f, 0.09168820f, 
    -0.17417294f, -0.01743885f, 0.00479010f, 0.20088498f, 0.01970582f, -0.01282820f, 0.03812078f, 0.01065567f, 
    -0.10932618f, -0.06192708f, 0.04149998f, -0.13430600f, 0.36437917f, 0.16952816f, 0.29669175f, -0.14457914f, 
    0.13069589f, 0.03335169f, 0.09457877f, 0.25192299f, -0.11755405f, 0.07444473f, 0.05550495f, -0.09807616f, 
    0.24747485f, -0.01469791f, 0.07982501f, 0.12438989f, 0.09268730f, 0.09795527f, -0.02782012f, -0.17412165f, 
    0.06443948f, -0.02061400f, 0.03487921f, 0.09172560f, -0.44502559f, 0.59630716f, -0.12155373f, -0.01400911f, 
    -0.04293093f, -0.13951384f, 0.19369452f, 0.17103069f, 0.00006354f, -0.00870481f, -0.02636084f, -0.11441869f, 
    -0.14298379f, 0.04065658f, -0.10605164f, -0.07146975f, -0.07389140f, -0.01246344f, -0.11566485f, -0.02620783f, 
    -0.10193708f, 0.06088357f, -0.08318859f, -0.19396320f, 0.17034827f, 0.01265028f, -0.27393678f, -0.05028686f, 
    0.04790772f, -0.10017004f, -0.04083538f, 0.06797360f, -0.03390855f, 0.08543305f, 0.04815672f, -0.00404283f, 
    0.20630258f, 0.25523561f, 0.26389048f, 0.13022026f, -0.14778429f, 0.15719849f, 0.05610079f, 0.20880783f, 
    0.01288230f, -0.04884835f, 0.03634146f, -0.03446902f, -0.10355700f, -0.30319771f, -0.18786678f, -0.00046425f, 
    0.05673902f, 0.10319828f, 0.16250290f, 0.03442520f, 0.07670265f, 0.04511940f, 0.04741081f, -0.11994708f, 
    0.15776503f, 0.05323253f, 0.26268363f, -0.13527797f, 0.00324721f, -0.11993581f, 0.13765228f, 0.14207794f, 
    -0.04575678f, 0.09075020f, 0.06967961f, -0.08547952f, 0.10778517f, 0.49123228f, 0.05673976f, 0.27557397f, 
    0.00710100f, 0.02660269f, -0.02252916f, -0.12218357f, -0.09859407f, 0.08461883f, 0.01919949f, 0.03492467f, 
    0.09263089f, -0.04081650f, 0.11658627f, -0.10419999f, 0.12819660f, 0.09819981f, -0.08547942f, -0.00709588f, 
    -0.07171310f, 0.12309147f, 0.00070816f, 0.01566762f, -0.13880683f, 0.01687028f, -0.17885046f, -0.04708338f, 
    -0.16027108f, 0.16068524f, 0.04717774f, 0.08941780f, 0.11473221f, 0.01677093f, 0.10471226f, -0.04395219f, 
    -0.13099229f, 0.20881465f, -0.15903212f, -0.23404303f, 0.10051724f, 0.04436121f, 0.12727535f, 0.07294243f, 
    -0.18826106f, -0.04708511f, 0.00220413f, 0.06012876f, -0.05215596f, 0.14568369f, 0.17412169f, -0.09556756f, 
    -0.10115141f, -0.11800327f, -0.10345124f, -0.03658279f, -0.07292581f, -0.01854081f, 0.00370259f, 0.00124072f, 
    -0.03889209f, -0.11104449f, 0.33988589f, 0.45408723f, -0.05100875f, -0.05556549f, -0.09461220f, 0.06532946f, 
    -0.00659989f, 0.00812095f, 0.00280796f, -0.01944670f, 0.10256895f, 0.09615426f, -0.13310221f, 0.18497534f, 
    0.03463625f, 0.26255837f, -0.01163374f, -0.07798177f, 0.14577229f, -0.00372229f, 0.07977669f, 0.09167098f, 
    0.00242508f, -0.05279197f, 0.10110053f, 0.27710679f, 0.03859268f, -0.00671589f, -0.03500768f, 0.06758010f, 
    -0.07393050f, -0.03849579f, 0.21410111f, -0.02798925f, 0.36497381f, -0.00383438f, 0.25088540f, -0.12896696f, 
    0.06302298f, 0.07859443f, 0.15156518f, 0.15853848f, -0.11466473f, 0.08171592f, -0.00057792f, -0.06136031f, 
    0.03268800f, 0.23087324f, -0.05666366f, -0.10369040f, -0.18716583f, 0.03992528f, 0.26481181f, -0.12080614f, 
    0.01747487f, -0.00853400f, -0.07734938f, -0.12405823f, 0.50556797f, -0.30595884f, 0.26425347f, 0.04351076f, 
    -0.07878167f, 0.10753687f, -0.03912748f, -0.09674951f, -0.04034564f, 0.01053950f, 0.06682797f, 0.14544633f, 
    0.00797716f, -0.09981269f, 0.04505289f, -0.11457207f, -0.06985962f, 0.08470289f, -0.09784844f, -0.02334982f, 
    0.09197909f, 0.01933304f, 0.06833101f, 0.02152012f, 0.02099680f, 0.28180099f, 0.04063148f, 0.02081489f, 
    0.14095549f, -0.11485109f, -0.06465922f, 0.05339096f, 0.08572942f, -0.08755604f, 0.11621241f, 0.02909628f, 
    0.13748759f, -0.53285784f, -0.31391025f, -0.03486873f, -0.08600888f, -0.17659517f, 0.21427765f, 0.04601498f, 
    -0.01089312f, -0.01352049f, -0.02336711f, 0.07695499f, 0.21418422f, 0.10068170f, 0.13939004f, -0.08890095f, 
    -0.00718806f, -0.09073739f, 0.02283714f, -0.21522975f, 0.02582422f, 0.10953831f, 0.03227242f, 0.00532932f, 
    -0.34850067f, 0.22530411f, -0.05987530f, -0.07349458f, 0.23597860f, 0.06521571f, 0.01234089f, -0.07802932f, 
    0.15445544f, 0.03757153f, -0.04619091f, -0.07524113f, 0.09855708f, -0.20245329f, 0.16413668f, -0.09511741f, 
    -0.10076442f, 0.18924418f, 0.00668697f, 0.26330051f, -0.04808885f, -0.02689337f, -0.08826263f, -0.03816395f, 
    -0.06228341f, -0.03777904f, 0.00898820f, -0.02346245f, 0.14195451f, -0.10450919f, 0.08493695f, -0.09750322f, 
    0.02621865f, -0.04456044f, 0.10518117f, 0.07986309f, -0.06323987f, 0.08384307f, 0.22725812f, 0.09560545f, 
    0.08341239f, 0.02595176f, -0.06826945f, -0.23333943f, -0.09769204f, 0.11875043f, 0.07268996f, -0.09505834f, 
    -0.14556193f, -0.15359853f, 0.13074411f, 0.15882798f, -0.04875738f, 0.01900981f, -0.14603692f, 0.08301324f, 
    0.16000192f, 0.04368867f, -0.06908465f, 0.02671152f, -0.15278263f, -0.27566049f, -0.16327187f, -0.19305901f, 
    0.00695179f, 0.05579646f, 0.22677888f, -0.18829733f, 0.01798887f, 0.02494061f, -0.04347823f, -0.02808828f, 
    -0.31461811f, 0.09230884f, -0.15413183f, -0.25403726f, 0.13117608f, 0.11912635f, 0.08493450f, 0.04253482f, 
    0.05276800f, 0.00265387f, -0.04087222f, -0.00377490f, 0.08514111f, 0.20159605f, 0.12498580f, 0.07705701f, 
    0.04215337f, -0.08419664f, 0.20637660f, 0.28819439f, 0.01924578f, -0.05393963f, 0.07729917f, 0.05053373f, 
    -0.54807174f, 0.18589662f, 0.17504488f, -0.14462519f, -0.26750904f, 0.12831630f, 0.05399898f, -0.02873808f, 
    0.02048053f, -0.00344518f, -0.02109203f, 0.20548762f, -0.07628112f, 0.10618752f, -0.04141687f, 0.08247958f, 
    0.00134998f, -0.02889601f, -0.00790506f, 0.00399738f, -0.00884653f, -0.00734296f, -0.17485604f, 0.05029329f, 
    -0.15676779f, -0.27200872f, -0.11748017f, -0.24898003f, 0.06714857f, 0.03168778f, 0.16563959f, 0.10972368f, 
    -0.00081899f, 0.01503709f, -0.02325411f, 0.06416963f, 0.07938079f, -0.19511589f, 0.25798142f, 0.00531712f, 
    -0.03661292f, -0.04658341f, 0.10519263f, 0.07223457f, 0.11967073f, 0.09166893f, -0.00287889f, 0.20612663f, 
    -0.18013281f, -0.10263288f, -0.04782667f, 0.02173277f, 0.00054686f, -0.03771621f, -0.04853202f, -0.08307464f, 
    -0.08783245f, 0.16455647f, 0.07303108f, 0.08497578f, -0.02292408f, -0.09643912f, 0.01386354f, -0.12736294f, 
    -0.02218103f, -0.02215088f, 0.05377740f, 0.15837429f, 0.04312284f, 0.11985040f, 0.01185831f, 0.03342622f, 
    -0.54318225f, -0.23782067f, 0.09724770f, -0.20709580f, 0.03528055f, 0.12795980f, 0.12958564f, -0.11448810f, 
    -0.07359923f, -0.10446870f, 0.02211460f, 0.02366586f, 0.08409838f, 0.18647489f, 0.14358485f, 0.19491386f, 
    -0.13715248f, -0.06342623f, -0.04363630f, -0.06308576f, 0.01376404f, 0.14011408f, 0.20141736f, 0.20858119f, 
    0.23926079f, -0.09379064f, -0.00596779f, 0.13692643f, 0.01425059f, 0.05869569f, 0.13227201f, 0.08338052f, 
    -0.10604309f, -0.00021642f, 0.03159128f, -0.06835572f, -0.12165676f, 0.03311532f, 0.12911154f, 0.10432744f, 
    0.26726922f, 0.27775201f, -0.00626673f, 0.14409135f, 0.09066187f, -0.03399393f, 0.09481108f, 0.02954424f, 
    0.14169443f, 0.15527089f, 0.04778073f, 0.05099472f, 0.13450728f, -0.06863859f, -0.02520333f, 0.09152536f, 
    0.03787303f, -0.00132516f, 0.19234346f, 0.10926114f, -0.14355265f, -0.06157072f, 0.13899043f, 0.08068258f, 
    0.05918579f, -0.06263559f, -0.10351549f, 0.03129598f, 0.07890501f, 0.06506700f, 0.18537354f, 0.20578244f, 
    -0.19316758f, 0.14438376f, -0.02476709f, 0.16103262f, 0.05052247f, -0.05435087f, -0.06313054f, 0.08681721f, 
    0.18744554f, 0.11171685f, 0.32357395f, 0.06905133f, -0.10676876f, -0.12359609f, -0.19399251f, -0.10297537f, 
    -0.02291610f, 0.07401181f, 0.00526214f, -0.01335887f, -0.06532995f, -0.03662059f, 0.03982967f, -0.06365551f, 
    0.13753809f, 0.29463708f, -0.06682484f, -0.06575506f, 0.02553544f, 0.06857134f, 0.19847859f, -0.13434474f, 
    0.00153704f, -0.07626112f, 0.04787421f, 0.14828831f, -0.12030987f, -0.21171620f, -0.21767384f, -0.36461294f, 
    0.10559576f, 0.10648736f, -0.07759340f, 0.00298886f, 0.06442508f, -0.02084289f, -0.04196474f, 0.03294135f, 
    0.08440334f, 0.09771334f, -0.07410102f, -0.00260088f, 0.07189313f, -0.06087286f, 0.04280122f, -0.00417009f, 
    -0.14400713f, 0.06737301f, -0.05837918f, 0.13831444f, -0.12434216f, 0.03897845f, 0.00598969f, -0.10614610f, 
    0.06556216f, 0.20265336f, 0.13612579f, 0.09625191f, 0.09302512f, 0.02996710f, 0.11111202f, 0.25838211f, 
    -0.02643071f, 0.06432212f, -0.08280145f, -0.16988480f, -0.07274033f, 0.01330850f, 0.29431149f, -0.06103086f, 
    -0.07697427f, -0.07957888f, -0.03448787f, -0.04613265f, 0.38236719f, -0.40466192f, 0.30336776f, -0.05104458f, 
    0.01455250f, 0.10198388f, -0.01448856f, -0.02418471f, 0.15939493f, 0.10231245f, 0.05199443f, 0.10349347f, 
    0.10653229f, -0.05209051f, 0.13115202f, 0.14158316f, 0.01249301f, -0.07496405f, 0.02547839f, -0.05888899f, 
    0.16338722f, 0.11278557f, 0.08694315f, 0.02887060f, -0.05468844f, 0.13221441f, 0.19169205f, -0.17869706f, 
    0.04295341f, 0.08299910f, 0.02354312f, 0.09336790f, 0.07139725f, 0.06073093f, 0.06486157f, -0.05393556f, 
    -0.10720780f, -0.20977423f, -0.27432373f, -0.09505246f, 0.16602898f, -0.00907169f, 0.13471504f, 0.11196426f, 
    -0.09283659f, 0.02047682f, 0.00987861f, 0.02878832f, 0.23665939f, 0.26381946f, 0.07758492f, -0.02586589f, 
    -0.04428845f, -0.05545647f, -0.01231498f, -0.07623155f, 0.07331562f, 0.04608361f, 0.16264051f, 0.09470980f, 
    -0.11147663f, -0.03497494f, -0.06437342f, 0.16116022f, 0.06129480f, 0.08493283f, 0.07294134f, -0.05390507f, 
    0.12014979f, 0.12654348f, 0.06242377f, 0.15007256f, 0.11599525f, -0.17953986f, 0.06833979f, -0.21356520f, 
    -0.00880699f, 0.04400365f, 0.08812989f, 0.23828842f, 0.01872514f, 0.08854114f, -0.06149134f, 0.07124136f, 
    -0.03122210f, 0.13640454f, -0.02378012f, 0.21256532f, -0.11701869f, -0.13223808f, 0.06865416f, -0.06529298f, 
    0.02254393f, 0.02068990f, 0.04506413f, 0.06434018f, -0.03480368f, -0.02312388f, 0.16093589f, 0.08493938f, 
    0.07483340f, -0.03180676f, -0.11676824f, -0.09828437f, 0.01299158f, 0.00065812f, 0.10876302f, 0.01305902f, 
    -0.02007146f, -0.17298324f, 0.28457868f, 0.31209061f, 0.05117871f, 0.05800783f, -0.06762635f, 0.08994205f, 
    0.28210741f, -0.02520349f, 0.16074640f, -0.06408063f, -0.15673050f, -0.26013398f, -0.13337094f, 0.05311444f, 
    -0.02427110f, 0.03352180f, 0.02991208f, -0.02031796f, 0.03749716f, -0.00838681f, -0.04259795f, 0.02556760f, 
    0.40717444f, 0.22955087f, -0.20010243f, -0.48448601f, -0.07158349f, 0.07690764f, 0.10821657f, -0.04241722f, 
    -0.00885989f, 0.06680348f, -0.14182839f, 0.02491499f, -0.10595978f, -0.00952175f, 0.11209875f, -0.17260012f, 
    0.18738605f, 0.08651141f, 0.04070302f, -0.00128897f, -0.07580155f, -0.05248685f, -0.02054674f, -0.03570030f, 
    0.19050850f, -0.01161704f, -0.06873295f, -0.31838062f, -0.01160986f, 0.01474145f, 0.02313956f, -0.02088718f, 
    0.16186747f, 0.01968708f, -0.00007216f, 0.10215950f, -0.45644593f, 0.04480046f, -0.09697931f, 0.20203014f, 
    0.06171063f, -0.01069221f, -0.04052711f, -0.02821826f, 0.02873305f, -0.01743919f, 0.05450352f, 0.02530153f, 
    -0.03391723f, -0.15548676f, -0.01225073f, 0.23149323f, 0.17636329f, 0.20813015f, 0.00290094f, 0.05945364f, 
    -0.09769951f, 0.03964878f, 0.00199066f, 0.18509980f, -0.03861539f, 0.17691882f, 0.10471440f, 0.17831764f, 
    0.08065284f, -0.12884939f, 0.12826294f, 0.13059130f, -0.01502234f, -0.01085706f, -0.09500301f, -0.00659599f, 
    -0.16282599f, -0.09811869f, -0.04961149f, 0.00943968f, -0.13622549f, -0.14581282f, -0.15969227f, -0.16545747f, 
    -0.04538915f, -0.00693925f, -0.07434615f, -0.07109423f, 0.19689745f, 0.12370028f, -0.23716220f, -0.02557117f, 
    0.24414769f, 0.02880792f, 0.06843691f, 0.03589359f, -0.06278516f, -0.09354744f, -0.05272854f, -0.19129190f, 
    -0.11813385f, -0.02473862f, -0.16426367f, -0.00519257f, -0.01435617f, -0.12940168f, 0.16930835f, -0.00533061f, 
    0.01589366f, -0.01644586f, -0.00953253f, -0.19455303f, 0.07248643f, 0.25499806f, -0.11661050f, 0.27711889f, 
    0.00444806f, 0.12625296f, -0.02198341f, 0.11166959f, 0.13706551f, -0.01279443f, -0.03098902f, 0.13496704f, 
    0.09047857f, 0.12670077f, 0.14940915f, -0.01072371f, -0.18632099f, -0.00289753f, 0.02621653f, 0.18887153f, 
    -0.02975529f, -0.02623096f, 0.05808304f, -0.06009674f, 0.29963347f, 0.35182834f, 0.03212427f, -0.00801122f, 
    0.06368015f, -0.01143408f, -0.00813362f, 0.09372145f, 0.01820415f, 0.12913078f, 0.08472845f, 0.02932537f, 
    0.00290831f, -0.04194795f, 0.12301622f, 0.08495525f, -0.06322490f, 0.15367210f, 0.13109827f, 0.00220856f, 
    0.01073385f, 0.08504503f, 0.00297794f, -0.02796936f, -0.09985738f, 0.27514243f, -0.15222184f, 0.01544453f, 
    -0.16966192f, -0.10882323f, -0.17536440f, 0.08246096f, 0.13887121f, -0.09826452f, 0.16489741f, 0.06523940f, 
    0.26739299f, 0.03931243f, -0.05537293f, -0.17003603f, -0.11760534f, -0.20019212f, 0.18668835f, 0.02668026f, 
    -0.01622296f, -0.05454643f, -0.08710035f, -0.01812544f, -0.11201481f, -0.01753404f, 0.05623951f, -0.23704396f, 
    -0.15906313f, -0.24124157f, -0.05223362f, -0.11251047f, 0.04672444f, 0.08110140f, -0.04674303f, 0.11699593f, 
    -0.58233660f, 0.06114468f, 0.09520627f, 0.15335888f, 0.05608457f, 0.17634416f, -0.18675064f, 0.02079558f, 
    0.10230606f, 0.12300377f, 0.06879949f, 0.00240432f, -0.01352755f, 0.08666418f, -0.23118463f, -0.02788713f, 
    0.05189210f, 0.16537419f, 0.02684584f, -0.13224930f, 0.11548757f, 0.14091569f, 0.03789266f, 0.09774666f, 
    -0.32189876f, -0.21742207f, 0.05155673f, 0.18850884f, 0.08196154f, 0.03689394f, -0.11384217f, -0.02057046f, 
    0.01243052f, -0.11425303f, 0.00039911f, 0.03873761f, 0.01917519f, 0.07837269f, 0.05100960f, -0.07196112f, 
    -0.02293304f, -0.00123837f, -0.06129455f, 0.10076009f, -0.10283671f, 0.09884287f, -0.09564039f, -0.13940163f, 
    -0.16365902f, -0.09790788f, -0.13939887f, 0.07949397f, -0.00262353f, 0.11457482f, 0.00346346f, 0.04597480f, 
    -0.36441547f, -0.37705871f, -0.35150504f, -0.46774399f, -0.09204698f, 0.02211635f, 0.10561422f, 0.02850267f, 
    0.07121915f, -0.12001047f, -0.09713352f, 0.11306549f, 0.20238212f, 0.10717017f, 0.04872168f, 0.17072242f, 
    0.06318191f, -0.16125771f, -0.16078779f, -0.14293574f, -0.00148757f, -0.09704616f, 0.04574651f, -0.12367994f, 
    0.03874855f, 0.23454806f, 0.19037892f, 0.41276529f, -0.03798306f, -0.15196258f, 0.09299700f, 0.20948739f, 
    0.16730477f, 0.11221361f, 0.21168351f, 0.01267003f, 0.10188375f, 0.25723663f, 0.21349537f, 0.23133239f, 
    0.12397780f, 0.26453546f, 0.40865552f, 0.38476709f, 0.24317299f, -0.02936780f, -0.10659338f, 0.04262523f, 
    -0.03469678f, -0.02578532f, 0.08498441f, -0.07022705f, 0.43085054f, 0.05760996f, 0.30410054f, 0.44221112f, 
    -0.13094230f, 0.01866845f, -0.15546232f, -0.05987773f, 0.13668200f, 0.02947389f, 0.06242946f, 0.33458215f, 
    -0.00124629f, 0.16391410f, -0.33555770f, -0.12870117f, -0.07816975f, -0.02370595f, -0.20642427f, -0.13820854f, 
    -0.15728216f, -0.03226143f, -0.20067288f, 0.00285512f, -0.15427488f, -0.06719381f, 0.08946615f, -0.01655741f, 
    -0.02717898f, 0.05979966f, 0.03961270f, 0.06307875f, -0.06727135f, -0.19646643f, 0.04059194f, -0.23176734f, 
    -0.24642619f, 0.10028531f, -0.23276402f, -0.18007079f, -0.02928290f, -0.09912165f, -0.11941712f, -0.02443582f, 
    -0.32461166f, 0.01593801f, -0.20492648f, -0.28097963f, 0.39006755f, 0.06479462f, 0.08368403f, -0.30880648f, 
    -0.20148860f, 0.02936176f, -0.01273275f, -0.05300318f, 0.02256905f, 0.10451151f, -0.25899035f, -0.09811688f, 
    0.31348091f, 0.40205023f, 0.02012794f, -0.23161368f, -0.04539134f, 0.11164687f, 0.02674079f, -0.02641925f, 
    0.05732610f, 0.17362432f, 0.16092445f, 0.00906283f, -0.01790616f, -0.34229046f, 0.03868711f, -0.20385514f, 
    -0.03351611f, 0.11953172f, 0.02081711f, -0.28704721f, -0.14973384f, -0.30293003f, -0.26153868f, -0.31357640f, 
    -0.27325732f, -0.08156257f, -0.15898502f, 0.06679717f, 0.06971055f, 0.26962724f, 0.08483691f, -0.08146075f, 
    -0.24909496f, -0.20080574f, -0.05104255f, -0.05182151f, 0.12483492f, -0.05455088f, 0.00008920f, 0.06097268f, 
    -0.07601993f, 0.01521775f, -0.00900630f, 0.01404170f, 0.01615450f, -0.18345523f, -0.08766232f, -0.10464918f, 
    -0.02150864f, -0.09865998f, -0.00699911f, 0.10490479f, 0.04050057f, 0.18452032f, 0.05064324f, 0.04118755f, 
    0.26631272f, 0.12625903f, 0.11426266f, 0.23303202f, 0.29155806f, -0.14383432f, 0.03438176f, 0.06862605f, 
    0.06820446f, 0.20151785f, 0.00736778f, -0.07813031f, 0.16367102f, 0.03019936f, 0.10238402f, 0.17151408f, 
    0.06435692f, -0.34969795f, 0.08226812f, -0.15393226f, 0.00993716f, -0.04675664f, 0.04274249f, 0.05273419f, 
    -0.05947728f, -0.05675831f, -0.15248416f, -0.24106801f, 0.12019250f, 0.21259309f, -0.01951683f, -0.05172088f, 
    0.20357716f, -0.12136116f, -0.11513872f, 0.11835708f, 0.11512829f, 0.05159976f, -0.04933505f, 0.06374614f, 
    -0.11673106f, 0.07018584f, -0.15692654f, -0.04625769f, -0.13912059f, -0.18465684f, -0.17468840f, -0.05677840f, 
    -0.05415329f, -0.05002813f, -0.00399511f, 0.04568528f, -0.05591645f, -0.02886832f, -0.11497999f, 0.10097874f, 
    -0.01822053f, 0.21588315f, 0.09999938f, 0.02920600f, 0.09062219f, -0.02906034f, 0.04020462f, 0.12666495f, 
    0.05767915f, -0.26678807f, 0.04525604f, 0.26790041f, -0.01059229f, -0.02235359f, 0.01291265f, -0.05170842f, 
    -0.13520397f, 0.04695710f, 0.03665134f, 0.00974135f, 0.22003867f, 0.33206469f, 0.19865450f, 0.37969181f, 
    -0.00366328f, 0.03990703f, -0.00979827f, 0.18026035f, 0.08729574f, 0.10954802f, 0.03225507f, 0.11534745f, 
    0.30082753f, -0.14167635f, -0.19536157f, 0.01293992f, -0.09987739f, -0.00346141f, 0.12230533f, 0.09393988f, 
    0.02901042f, 0.02233034f, 0.13269024f, 0.05429434f, -0.08751430f, -0.05682468f, -0.09137569f, 0.01249866f, 
    0.12791082f, -0.00970091f, 0.08500265f, -0.06100135f, -0.06667094f, -0.02161505f, 0.06955811f, 0.18806878f, 
    0.05138585f, 0.02335600f, 0.03002493f, -0.00700389f, -0.11619008f, 0.13665095f, -0.07567970f, -0.00156037f, 
    -0.11896256f, 0.04523189f, -0.08152922f, -0.19192176f, -0.19035083f, -0.07400851f, -0.19074298f, 0.06048013f, 
    -0.02390518f, -0.18745439f, 0.01337848f, 0.05353031f, 0.05434389f, -0.00336393f, -0.01994004f, 0.17304507f, 
    -0.08892447f, 0.20232253f, 0.05697854f, -0.16313487f, -0.00000473f, -0.11366975f, 0.15954293f, -0.01657541f, 
    -0.00306660f, 0.12271320f, 0.05897564f, 0.11131477f, -0.27175561f, -0.19608970f, -0.02610621f, 0.11560168f, 
    -0.00733838f, -0.18242259f, -0.17842351f, -0.21919267f, -0.09815900f, -0.14378175f, -0.16492090f, -0.02060315f, 
    0.07995033f, 0.10291300f, -0.09672383f, -0.27917096f, 0.12452497f, -0.02655101f, 0.08377920f, -0.07620805f, 
    0.04681504f, -0.07375607f, 0.21611771f, -0.08732444f, -0.28527683f, -0.21085741f, -0.11789863f, -0.11601517f, 
    0.11318987f, 0.09788931f, -0.00756451f, -0.17618413f, 0.03763038f, 0.02534161f, 0.06302240f, 0.00506355f, 
    0.16775630f, -0.27706459f, 0.01069491f, -0.13139336f, 0.04811409f, -0.07158502f, -0.12039896f, 0.03512228f, 
    0.07724912f, 0.08086225f, -0.09103767f, 0.04731712f, 0.17851222f, 0.03015650f, 0.12863441f, -0.13241920f, 
    0.16302067f, 0.10748617f, -0.05820249f, -0.02106860f, -0.06473209f, 0.12973076f, 0.15060151f, 0.03097150f, 
    0.41023251f, 0.23561746f, 0.00327822f, 0.05228967f, -0.06088310f, 0.10580438f, 0.07711526f, -0.02889071f, 
    0.09945779f, -0.08266153f, -0.00309199f, 0.01543713f, -0.16733460f, 0.03070005f, -0.24931131f, -0.08071636f, 
    0.05864982f, 0.07866240f, -0.04334551f, -0.07553724f, -0.11272366f, -0.03158629f, 0.06921008f, 0.05346756f, 
    -0.13957478f, -0.30514678f, -0.08840104f, 0.01661072f, 0.06570176f, 0.02540045f, -0.03350855f, 0.03684400f, 
    0.10236335f, 0.15621036f, 0.03879454f, 0.10014117f, 0.26033637f, 0.04328982f, 0.19476452f, 0.12874034f, 
    0.05834559f, -0.16279177f, -0.00359611f, 0.20704572f, -0.01173112f, 0.14837919f, -0.03904215f, 0.21107689f, 
    0.21565367f, 0.23337217f, -0.13187484f, 0.11584136f, 0.15694109f, 0.29207250f, -0.02473373f, 0.30603904f, 
    -0.00296795f, -0.16163847f, -0.15429185f, -0.14905053f, -0.03518086f, -0.18741898f, 0.12278848f, -0.10670352f, 
    0.07520456f, -0.02011735f, -0.01758032f, -0.05631848f, 0.01916957f, -0.14619920f, 0.11228369f, 0.15680389f, 
    -0.34445262f, -0.23328705f, 0.16348687f, 0.01837549f, -0.00605978f, 0.05543375f, -0.07694753f, 0.08337629f, 
    0.07856944f, 0.10629509f, -0.08044378f, -0.10907597f, 0.25903067f, 0.07138936f, 0.04975978f, 0.11923439f, 
    0.11987346f, 0.10311354f, 0.11934976f, -0.01775990f, -0.09903620f, -0.07306188f, -0.13328595f, -0.01981857f, 
    -0.04096159f, -0.13852011f, 0.05049463f, -0.16150029f, 0.09550892f, -0.09853248f, -0.03331608f, 0.04406264f, 
    0.04432064f, 0.08133621f, -0.00344440f, -0.10655846f, -0.03100428f, -0.07882750f, -0.04880607f, 0.07961208f, 
    0.01133068f, 0.16264077f, -0.03181789f, -0.14410545f, 0.16501604f, 0.05965574f, -0.05777725f, -0.04665991f, 
    -0.34943524f, -0.28971913f, 0.19562019f, 0.06670290f, 0.08697540f, 0.10963888f, 0.02154392f, -0.11292937f, 
    0.02985212f, 0.08199374f, -0.07510054f, 0.07345191f, -0.24769005f, -0.25554475f, -0.17485890f, 0.07698929f, 
    0.12993260f, -0.03390884f, 0.01244363f, 0.09617306f, 0.06860722f, 0.08073826f, 0.07664948f, -0.10702702f, 
    0.13169353f, -0.16675700f, -0.32186896f, 0.34084615f, -0.13958481f, -0.00820593f, 0.09595019f, 0.04173336f, 
    -0.04527340f, 0.15795401f, -0.16574182f, 0.04887093f, 0.42056668f, 0.40187377f, 0.20092431f, 0.31004187f, 
    0.09479111f, 0.06743481f, 0.08331134f, 0.11355429f, -0.03557690f, -0.06753137f, 0.01540627f, -0.01321891f, 
    0.02904119f, -0.18215491f, -0.45016876f, 0.21337378f, -0.04896055f, -0.00146897f, 0.14364807f, 0.05661023f, 
    0.17088495f, -0.03887509f, 0.07651246f, 0.12096068f, -0.08315827f, -0.03882021f, 0.27181771f, 0.08251266f, 
    -0.04857849f, -0.02591261f, 0.14595875f, 0.14101483f, 0.03204690f, 0.04139825f, 0.02979668f, 0.01094749f, 
    -0.08351906f, -0.06625858f, 0.00805247f, -0.31720945f, -0.05628031f, -0.35272613f, 0.05927810f, 0.15693070f, 
    0.02626782f, -0.02665064f, -0.05200155f, -0.15489273f, 0.17425945f, 0.11789791f, -0.13956156f, 0.29671657f, 
    0.03173291f, 0.11958051f, -0.04147644f, -0.12683250f, 0.02737034f, -0.08799075f, 0.09207535f, 0.07243939f, 
    -0.09829063f, 0.10814814f, -0.03293617f, 0.03208214f, -0.07727463f, -0.03158791f, -0.10102268f, -0.00477058f, 
    -0.02425805f, 0.02068441f, -0.07534631f, -0.15147999f, -0.23375440f, 0.02233202f, -0.04833875f, 0.11594417f, 
    -0.13758591f, 0.15057817f, 0.04776503f, 0.04687071f, 0.14948133f, 0.28953668f, -0.02770161f, 0.09543411f, 
    0.19589934f, -0.29555064f, 0.20035478f, -0.02434402f, 0.01244582f, 0.05924603f, -0.13966268f, -0.22637989f, 
    -0.04479335f, 0.01778940f, -0.05698710f, 0.07023846f, 0.11945773f, 0.21000135f, 0.03892989f, -0.09534342f, 
    0.01691839f, -0.04549144f, -0.03381974f, 0.00800081f, 0.04330390f, 0.04341562f, -0.12872128f, -0.06215229f, 
    0.02517119f, -0.05244368f, 0.18757699f, -0.01422298f, -0.04409133f, 0.04636880f, -0.07227851f, -0.06672131f, 
    -0.07096086f, 0.02138093f, 0.23546781f, -0.14631245f, -0.04581405f, -0.00049959f, 0.24338304f, 0.19036552f, 
    0.24848191f, 0.00550190f, 0.02400891f, -0.19179076f, -0.02450425f, -0.06914530f, -0.00603047f, 0.09399366f, 
    0.16967884f, 0.01940573f, -0.03456937f, -0.09977221f, -0.11061788f, 0.05369459f, 0.03240316f, 0.18460917f, 
    -0.12108050f, -0.08969016f, 0.09599417f, -0.04281493f, -0.16476013f, 0.07126758f, 0.02239228f, 0.13335861f, 
    -0.04162749f, -0.15745264f, 0.03738605f, -0.14846651f, -0.06885819f, 0.04463451f, 0.01756690f, 0.11887019f, 
    -0.38512236f, 0.01623104f, 0.09403992f, 0.25246754f, -0.07603463f, 0.04009840f, -0.06226846f, 0.01588771f, 
    -0.01101125f, 0.16731584f, -0.00962258f, 0.08151620f, -0.03410589f, 0.04182245f, -0.20437150f, 0.15203539f, 
    -0.06348811f, -0.04566371f, -0.10008691f, -0.08625865f, -0.11587043f, -0.03603910f, -0.03505177f, -0.15432023f, 
    0.55441612f, 0.22132440f, -0.12019186f, 0.01737087f, 0.01616742f, -0.10408500f, 0.25523195f, -0.01623665f, 
    -0.08100512f, -0.03232181f, 0.02157572f, -0.04716342f, -0.29117593f, -0.09883966f, -0.15245140f, 0.16722035f, 
    -0.13261937f, -0.00832710f, -0.00048412f, -0.08414322f, -0.02546025f, 0.10516302f, 0.12545142f, 0.02615937f, 
    0.35008201f, -0.05888354f, 0.06101105f, -0.00426119f, -0.06964009f, -0.12170755f, 0.19775227f, 0.06751527f, 
    -0.12737961f, 0.11224823f, -0.05482548f, -0.20835060f, 0.01645082f, -0.23118988f, -0.12389293f, -0.15231737f, 
    -0.06876820f, 0.12005064f, 0.06414462f, -0.16556408f, -0.01670222f, 0.12560962f, 0.12746297f, 0.01382146f, 
    -0.01804849f, -0.03505074f, 0.03869464f, 0.04924442f, 0.02813343f, -0.00489635f, 0.01800057f, 0.02638288f, 
    -0.03578901f, -0.05750035f, -0.05183066f, -0.05901224f, -0.01380736f, -0.04692093f, -0.00486528f, -0.02388797f, 
    -0.03512564f, -0.03761948f, -0.00902883f, -0.05731844f, -0.00230526f, -0.00274525f, -0.05205713f, -0.07247068f, 
    -0.02725078f, -0.00489120f, -0.04240932f, -0.02958965f, -0.08515784f, -0.00389596f, -0.00260852f, -0.00600925f, 
    -0.03008944f, -0.02121687f, 0.04159735f, -0.03233067f, 0.01484879f, -0.07894927f, -0.03597006f, 0.06221574f, 
    0.04041749f, -0.06006263f, 0.03567576f, 0.01823818f, 0.01883819f, 0.04783897f, -0.03014071f, -0.06633850f, 
    0.01206505f, 0.06066940f, 0.01259640f, 0.01380089f, 0.02679739f, -0.05200072f, -0.05963122f, 0.05353542f, 
    -0.05040811f, 0.02346179f, -0.00607827f, -0.05506068f, -0.03256490f, 0.04362880f, -0.08644827f, 0.01826694f, 
    -0.05054372f, 0.04399331f, -0.04790229f, -0.00804881f, 0.00826394f, 0.01874095f, -0.01352772f, 0.01049582f, 
    -0.01214766f, -0.01067221f, 0.06879039f, -0.07833762f, -0.02036764f, -0.01757854f, -0.05154718f, 0.05224792f, 
    0.05342562f, 0.00709479f, 0.03096072f, -0.03459761f, 0.01119378f, -0.04687794f, 0.02147986f, -0.07757406f, 
    0.00725675f, 0.03862680f, -0.05479753f, 0.03576506f, 0.02266043f, 0.01811445f, 0.03395358f, -0.08044063f, 
    -0.00002331f, 0.02074217f, 0.02888261f, -0.00268904f, -0.05509930f, -0.01707608f, 0.05179473f, 0.03366119f, 
    0.02732342f, 0.01203439f, 0.03068500f, 0.05626863f, -0.05971906f, 0.05020824f, -0.02326027f, 0.05104887f, 
    0.02113338f, 0.01943554f, -0.06098031f, -0.07138381f, 0.03666180f, -0.00735019f, -0.03660471f, -0.00817286f, 
    -0.00807949f, -0.04140131f, 0.01324525f, 0.01163470f, 0.05134201f, 0.05568676f, -0.00162490f, 0.00705554f, 
    -0.07244309f, 0.05470316f, 0.03095317f, 0.05290701f, -0.03679852f, -0.06506681f, 0.04479586f, -0.03531686f, 
    -0.01702797f, -0.00812447f, -0.04269395f, -0.01775262f, -0.00935051f, 0.02288229f, 0.00720713f, 0.03794022f, 
    -0.05272802f, 0.05880423f, -0.05164776f, -0.06250200f, -0.02401545f, -0.04508753f, -0.01945219f, -0.07079612f, 
    0.00521598f, 0.00117791f, -0.02086228f, -0.08261431f, 0.04787354f, -0.06916523f, -0.04795167f, 0.01296972f, 
    -0.06082148f, -0.02739955f, -0.07314789f, 0.04579204f, -0.01723141f, 0.01252768f, -0.07621463f, -0.02367332f, 
    0.03530413f, -0.04942613f, 0.06206590f, -0.05720904f, -0.03708979f, -0.05548673f, 0.05296846f, -0.05328456f, 
    0.05938416f, -0.05036698f, 0.02487272f, -0.05061554f, 0.02031042f, -0.06907952f, -0.07217414f, -0.03607474f, 
    0.04286930f, 0.03629971f, 0.03106650f, -0.06449477f, -0.04476650f, 0.05650805f, -0.05907293f, -0.06087385f, 
    0.01746327f, -0.03552198f, -0.16681647f, -0.02963736f, -0.08636711f, 0.07173879f, 0.13355428f, -0.06650188f, 
    0.06401424f, -0.02719460f, 0.02580396f, 0.03492260f, 0.17234695f, -0.36056805f, 0.26775864f, 0.03918404f, 
    0.05140615f, 0.00439874f, -0.06404096f, 0.05597517f, -0.09280284f, 0.20275007f, 0.01752133f, 0.06255503f, 
    0.05150811f, 0.06796870f, 0.10421866f, 0.04615989f, 0.08870903f, 0.04945970f, -0.03546802f, 0.08688675f, 
    -0.01744863f, -0.13008147f, 0.10498608f, 0.13883355f, -0.11173835f, 0.00151223f, 0.14249097f, 0.04446445f, 
    0.09609824f, 0.04623370f, 0.11852030f, -0.02219467f, -0.13824272f, 0.00028297f, 0.00775670f, 0.03982552f, 
    -0.14079471f, -0.14567032f, -0.11719119f, -0.00371335f, 0.13384455f, 0.03378391f, 0.28684986f, 0.29409468f, 
    0.08223769f, 0.03500417f, -0.00741085f, -0.05553868f, 0.21123168f, 0.34206313f, 0.19056062f, 0.17644499f, 
    -0.01067466f, -0.04703447f, 0.04081303f, -0.06472751f, 0.08045665f, -0.16393317f, 0.07736788f, 0.03140841f, 
    -0.08425178f, 0.00472821f, -0.08029845f, 0.01208340f, 0.01080420f, 0.08151091f, -0.11162746f, 0.08107967f, 
    0.04114969f, 0.10966430f, -0.31004176f, 0.08579173f, -0.00214749f, -0.23713419f, 0.14189108f, -0.10415757f, 
    0.03792010f, 0.21055280f, -0.14014931f, 0.16228308f, -0.10663141f, -0.04472483f, 0.05499029f, -0.05374059f, 
    -0.18482539f, 0.19411597f, -0.01777816f, -0.06700606f, 0.02051581f, -0.08365726f, -0.10962892f, -0.03897110f, 
    0.02065373f, -0.05173541f, -0.12213004f, -0.10904947f, 0.26160881f, 0.00635181f, 0.06624593f, -0.00047017f, 
    0.04977439f, 0.02062177f, -0.13457313f, 0.00023058f, -0.02387394f, -0.18966909f, -0.08134007f, -0.04627160f, 
    0.28492096f, -0.27683079f, 0.32787785f, 0.12419450f, 0.12532781f, -0.00422043f, -0.19463456f, -0.01229699f, 
    0.08450635f, 0.03113344f, -0.03134701f, 0.00150187f, 0.00394862f, -0.12017014f, -0.08576692f, -0.07522240f, 
    0.00465117f, 0.05593751f, 0.11993659f, 0.08055876f, 0.01363048f, 0.00253830f, 0.02806806f, 0.00579161f, 
    -0.23991691f, 0.13418064f, -0.35177410f, -0.05241631f, 0.04679620f, 0.03261395f, -0.01769355f, 0.00985133f, 
    -0.02011352f, 0.20985419f, -0.16931696f, 0.10159077f, -0.05047717f, 0.06540442f, 0.00304025f, 0.05518525f, 
    0.05505350f, -0.10642808f, -0.00841800f, 0.14901082f, -0.06210997f, -0.02910497f, -0.08841723f, -0.05236246f, 
    -0.04689021f, 0.08229479f, -0.10787131f, -0.07215914f, 0.11172116f, 0.00497080f, 0.11019173f, -0.05149458f, 
    0.10926491f, -0.00087171f, -0.09562720f, 0.08757899f, -0.14865530f, -0.08907840f, -0.09760773f, 0.21243542f, 
    -0.17410317f, 0.00647299f, -0.02245642f, -0.09907296f, -0.06489540f, -0.14265746f, -0.12132510f, 0.16418442f, 
    -0.31337389f, 0.08616193f, 0.02725090f, 0.06662226f, 0.19729534f, 0.03797017f, -0.03270081f, 0.10483286f, 
    -0.08607933f, -0.00672552f, -0.08156683f, 0.02948247f, 0.17503065f, -0.25510496f, 0.05836164f, 0.09411678f, 
    0.03163135f, -0.03631217f, -0.04169203f, -0.01437219f, 0.12002116f, 0.02325596f, 0.04943401f, 0.05660889f, 
    -0.16514066f, -0.04731197f, -0.10698258f, -0.10431600f, -0.03104671f, -0.05258085f, -0.10450331f, -0.08463895f, 
    0.04822161f, -0.11129595f, 0.03629928f, -0.02062230f, 0.00732879f, 0.09232999f, 0.13332738f, 0.05249749f, 
    0.02644031f, 0.08334228f, 0.06104407f, -0.07560334f, 0.14489882f, -0.11010125f, -0.03921942f, -0.04575250f, 
    -0.06773663f, -0.09932569f, -0.12574458f, -0.18330091f, -0.00123276f, -0.11154629f, -0.04532114f, -0.30226573f, 
    -0.09411541f, -0.01784772f, 0.03225856f, -0.00424028f, -0.07413229f, 0.37953073f, -0.01805307f, 0.05976580f, 
    -0.01004722f, 0.01171379f, 0.06242260f, 0.14050224f, 0.10081889f, 0.07073739f, -0.03860098f, -0.02097296f, 
    0.03834195f, -0.09858465f, -0.01520927f, 0.03352286f, -0.09402733f, 0.05611283f, -0.10180105f, -0.07996903f, 
    0.17554353f, -0.06659898f, 0.23893535f, -0.09428820f, 0.17015967f, 0.03831656f, 0.05838361f, -0.00984240f, 
    0.18634556f, -0.15226471f, -0.06854168f, 0.15031071f, 0.11006083f, -0.10771769f, 0.02803059f, 0.01137683f, 
    0.15319265f, 0.11200724f, 0.07124858f, 0.02664163f, -0.00705491f, 0.09876169f, 0.11404438f, 0.04181430f, 
    0.03924531f, -0.04608232f, -0.01167595f, 0.18261176f, -0.15449251f, 0.09404422f, -0.17188783f, -0.01047366f, 
    -0.08677415f, -0.17715527f, -0.03953647f, -0.10295449f, -0.00400232f, -0.03569141f, 0.15818836f, 0.14419335f, 
    0.29741234f, -0.33001029f, 0.03805061f, 0.15082552f, -0.15980116f, -0.07506686f, 0.07734098f, -0.01490523f, 
    0.17313224f, 0.01071776f, -0.00711472f, 0.04690260f, -0.08522775f, 0.01502155f, -0.08370226f, -0.03825035f, 
    0.03669231f, -0.04694053f, -0.08543541f, -0.14944620f, -0.01457541f, -0.02346530f, -0.01921430f, 0.06649657f, 
    0.19092366f, 0.21117416f, 0.16591620f, -0.17414650f, 0.06830904f, -0.12965432f, -0.03211967f, 0.06131452f, 
    0.01809245f, -0.04342005f, 0.07279952f, -0.13430132f, -0.17048313f, 0.08537472f, 0.18388951f, -0.03493556f, 
    0.04077201f, -0.07553499f, 0.13294435f, -0.03214221f, 0.03325010f, -0.00271702f, 0.05607635f, 0.10925414f, 
    0.04895123f, -0.18742767f, 0.20443380f, -0.08529380f, 0.00102493f, -0.09049198f, -0.01160580f, -0.12883911f, 
    -0.09373964f, -0.04222476f, -0.17453097f, -0.01762638f, -0.27418450f, -0.02172357f, -0.18554850f, 0.08137064f, 
    0.15300749f, 0.01520041f, -0.04102303f, -0.02393198f, 0.05911142f, 0.07482202f, -0.00444111f, -0.03442085f, 
    0.01380766f, 0.05692153f, 0.02495549f, 0.05908272f, -0.04017373f, 0.04948230f, 0.06337377f, -0.06850761f, 
    0.02065119f, 0.02451689f, -0.01511744f, 0.05106211f, -0.03006298f, -0.07971338f, -0.07005976f, 0.01646958f, 
    -0.04644290f, -0.04350135f, 0.05948092f, -0.07168235f, -0.01582872f, 0.06138654f, -0.00377851f, -0.05241816f, 
    -0.06004397f, 0.05268842f, 0.03422724f, -0.01628199f, -0.07108717f, -0.01523202f, -0.04538003f, -0.04903171f, 
    0.02669860f, 0.05166955f, 0.05648770f, -0.00764055f, -0.00193139f, 0.00428458f, -0.00880016f, -0.01867451f, 
    0.05860515f, -0.05129781f, -0.02463327f, 0.00168122f, -0.04099284f, -0.06409719f, -0.03477700f, 0.00923457f, 
    -0.03967177f, 0.03245666f, -0.06742046f, -0.03584619f, 0.05057712f, -0.06973185f, 0.01158690f, -0.04779924f, 
    0.05530459f, 0.00509762f, 0.04000442f, -0.00012556f, -0.07025742f, -0.02790762f, 0.02388807f, -0.04631089f, 
    -0.00595162f, -0.07599671f, -0.06674405f, -0.02005794f, -0.00096858f, -0.07048129f, 0.04735821f, -0.05166244f, 
    -0.06149857f, 0.05834650f, 0.04769657f, 0.04562852f, 0.01972306f, 0.02542040f, 0.03561492f, 0.01975184f, 
    -0.04942589f, -0.05358262f, -0.06461298f, -0.03920451f, 0.03357598f, -0.01195129f, -0.00086613f, -0.04374703f, 
    -0.01382416f, -0.01704726f, -0.02506007f, -0.06512216f, -0.06735498f, 0.03289220f, 0.02328260f, 0.04037168f, 
    -0.00949063f, -0.02445933f, 0.03232169f, 0.05588201f, 0.00901946f, -0.06054316f, -0.07437680f, -0.02618060f, 
    0.02136519f, 0.02313764f, -0.05385683f, 0.02320247f, -0.06184973f, -0.04364049f, 0.05510564f, -0.00025535f, 
    -0.07997745f, 0.01540003f, -0.01730655f, 0.02240116f, 0.06182116f, -0.05664045f, -0.03188902f, 0.01508996f, 
    -0.07383232f, -0.05796164f, -0.02435526f, -0.05798721f, -0.06710852f, 0.00053557f, -0.06519802f, -0.03516487f, 
    0.04902548f, -0.07325366f, 0.02349499f, 0.05585552f, -0.07008618f, 0.06436154f, -0.02299974f, -0.07156722f, 
    -0.07813013f, -0.05780031f, 0.06397916f, -0.06016227f, 0.05346965f, 0.02772411f, 0.00058119f, -0.05644120f, 
    -0.03924653f, -0.05259806f, -0.07291214f, -0.03376688f, -0.03205447f, -0.03386898f, 0.00006016f, -0.02488427f, 
    0.02681573f, 0.03278064f, -0.02903770f, 0.03263534f, -0.04518795f, -0.02313152f, 0.04904840f, -0.02640760f, 
    -0.00683611f, -0.01441389f, 0.05168865f, 0.01135792f, 0.05762186f, -0.05540325f, -0.05592962f, 0.05534940f, 
    -0.01991880f, -0.00729586f, 0.01041186f, 0.03583625f, -0.06022565f, -0.07243536f, 0.02173868f, -0.05547300f, 
    0.04262344f, -0.04034230f, -0.05549182f, -0.06210741f, 0.03794071f, 0.01653336f, -0.07318357f, -0.03774396f, 
    0.05117954f, -0.03685277f, -0.02373676f, 0.05025123f, 0.02707256f, -0.08001279f, 0.01421044f, 0.04400707f, 
    0.03640019f, -0.00125909f, -0.04481279f, -0.09672799f, -0.04383218f, -0.00484173f, 0.10483231f, -0.14673677f, 
    -0.11478770f, -0.04910309f, 0.04525195f, 0.01135029f, 0.07816698f, -0.12930882f, -0.03632036f, 0.36483034f, 
    -0.06562975f, 0.00455618f, 0.06492910f, -0.06154607f, -0.09662533f, 0.06077438f, 0.10989582f, 0.22190277f, 
    -0.12040837f, -0.07596299f, -0.06924299f, -0.13728912f, -0.09931227f, 0.07408363f, 0.01714254f, -0.00894100f, 
    0.04496542f, 0.09297007f, 0.01844430f, 0.04962914f, 0.10426352f, 0.10245541f, -0.15287991f, 0.00327252f, 
    0.16621138f, -0.04471650f, 0.09580605f, -0.01597668f, -0.00531055f, 0.05283305f, 0.08648598f, -0.00056210f, 
    0.05663605f, -0.30081642f, 0.07130271f, 0.00669507f, -0.16025783f, -0.04393411f, 0.10843614f, -0.05413964f, 
    -0.05211833f, -0.07045694f, -0.09831479f, -0.02793619f, -0.06694136f, 0.05431473f, -0.13077824f, -0.16789676f, 
    0.02979713f, -0.07751483f, 0.07711603f, -0.02121024f, -0.03272483f, 0.05376826f, 0.08988927f, -0.06566489f, 
    -0.18585822f, 0.16704650f, 0.17686126f, -0.13635148f, 0.06756226f, 0.03904584f, 0.07954157f, 0.02770909f, 
    0.08484841f, 0.02540047f, -0.06558384f, -0.02950105f, 0.25843894f, 0.00303990f, 0.21831349f, 0.21485136f, 
    0.11552241f, 0.08621430f, -0.12624551f, 0.10969681f, -0.05445829f, -0.05701625f, -0.07815970f, -0.11230015f, 
    0.05626156f, -0.00044488f, 0.11111523f, -0.14055018f, 0.02362335f, -0.03658750f, -0.01180213f, 0.03149828f, 
    0.11313638f, -0.09496744f, 0.23216391f, 0.12592195f, -0.05642181f, 0.13797460f, 0.06622527f, 0.04984662f, 
    -0.13192153f, 0.00575734f, -0.03571710f, 0.01587397f, 0.02274762f, 0.13410822f, 0.14335154f, -0.02039721f, 
    -0.10999052f, -0.03733314f, -0.06447463f, -0.15472861f, -0.17002334f, -0.08708995f, -0.05759708f, -0.02481425f, 
    0.02827837f, -0.00411230f, -0.00562443f, 0.08116690f, 0.01361079f, 0.06901066f, -0.13793765f, -0.21895362f, 
    -0.02890822f, -0.05258898f, 0.09822406f, -0.07744894f, -0.08626676f, -0.05212152f, 0.05336586f, 0.03707239f, 
    -0.44308344f, -0.00110264f, 0.06132910f, 0.23898217f, 0.04923892f, 0.06551620f, -0.04677396f, 0.03134197f, 
    0.03943926f, -0.06144479f, -0.01358540f, 0.00483450f, 0.16264965f, 0.13968216f, -0.13841350f, 0.00007854f, 
    0.04186937f, -0.04842395f, -0.09020775f, 0.01072788f, 0.06880315f, 0.00418066f, 0.06049838f, 0.01508746f, 
    -0.55855691f, -0.01612630f, 0.02513036f, 0.11294910f, -0.10681994f, -0.07864747f, 0.06712957f, -0.14508168f, 
    -0.29815948f, 0.04019272f, 0.07205224f, 0.02209693f, 0.19927554f, 0.08966789f, 0.06879829f, -0.04861804f, 
    0.02402315f, 0.06749930f, 0.15197355f, 0.05337388f, 0.07346471f, 0.09551970f, -0.06232974f, 0.15468022f, 
    -0.00648147f, -0.00411395f, 0.08767747f, -0.00802588f, -0.02390938f, 0.05465378f, 0.07478035f, 0.05521685f, 
    0.02190610f, -0.01613568f, 0.08160245f, 0.14232914f, -0.03143373f, 0.45192498f, 0.18331884f, -0.15398641f, 
    0.06353558f, -0.10313198f, 0.03002859f, -0.02081119f, -0.05756259f, -0.05949780f, 0.02383198f, -0.10073633f, 
    0.04606039f, -0.07527623f, -0.01869525f, 0.04858309f, -0.06883486f, -0.14671665f, -0.11599749f, -0.09904214f, 
    -0.12882546f, 0.03455786f, -0.07055579f, -0.20269340f, -0.07332548f, -0.14910109f, -0.00610102f, 0.07081477f, 
    -0.02026065f, -0.02846109f, -0.11269099f, 0.07679698f, -0.02055225f, -0.00466617f, -0.04483052f, -0.03524809f, 
    -0.02672919f, 0.21635655f, 0.26744744f, 0.04657742f, 0.01830341f, 0.07495312f, -0.17109001f, -0.00646732f, 
    -0.03976722f, -0.01360006f, -0.02014810f, 0.04144803f, -0.04187588f, -0.22869477f, -0.17148952f, -0.00818343f, 
    -0.05868346f, -0.02939439f, -0.07235813f, 0.11725517f, 0.01753864f, 0.00698579f, -0.06990770f, -0.00513012f, 
    0.16095960f, -0.03230858f, 0.07120327f, 0.08337599f, -0.09545474f, -0.01970307f, 0.03618965f, 0.00345728f, 
    -0.09791065f, -0.04438119f, 0.09732182f, -0.09192344f, -0.01981060f, 0.23907912f, 0.03480966f, 0.06573495f, 
    0.02870527f, -0.14991812f, 0.06849659f, -0.02789743f, -0.01466121f, 0.02346961f, -0.02542185f, 0.09941178f, 
    0.02965985f, 0.14102346f, -0.02601136f, -0.02264256f, -0.01263701f, 0.00041367f, -0.10602822f, -0.00307961f, 
    0.08792251f, 0.00780026f, 0.02577102f, -0.07155246f, 0.03047892f, -0.00331114f, 0.00905907f, -0.11122648f, 
    0.03702627f, -0.09769818f, -0.10961286f, -0.01287398f, 0.16959564f, 0.01419533f, 0.08942930f, 0.14071268f, 
    -0.21520062f, 0.24713531f, 0.01188478f, -0.17025891f, 0.02381332f, -0.06232173f, -0.02552691f, -0.02780120f, 
    -0.04535159f, 0.01977112f, -0.05502355f, -0.16596653f, -0.01723153f, -0.10968976f, 0.15319362f, 0.08072189f, 
    0.02733684f, -0.16336606f, -0.05948706f, 0.03349638f, -0.03178563f, 0.07166936f, 0.01989050f, -0.02621645f, 
    0.44100684f, 0.16752461f, -0.20376350f, 0.11368915f, -0.05321647f, -0.17446826f, -0.04987972f, -0.09579562f, 
    0.05298902f, 0.09253137f, -0.05151664f, 0.06291694f, -0.01976458f, 0.07693629f, 0.03048229f, 0.17349266f, 
    0.05027385f, 0.06684574f, 0.09195625f, 0.04231297f, 0.01031788f, 0.01959227f, 0.03407035f, 0.09715366f, 
    0.27256843f, -0.15879272f, -0.16394150f, 0.02239284f, 0.05818482f, -0.05445438f, -0.03722034f, 0.05947967f, 
    0.16074033f, -0.02511526f, -0.06172748f, -0.15322599f, 0.08221372f, -0.10169148f, 0.12255175f, 0.04446713f, 
    0.01452075f, -0.06133001f, -0.03748657f, 0.12149723f, -0.12480010f, 0.03906778f, 0.08550470f, -0.03269596f, 
    0.03443678f, -0.06595825f, -0.05910140f, -0.06757285f, 0.04427345f, 0.01119254f, -0.07821126f, 0.01460814f, 
    -0.06619830f, 0.03438942f, -0.06489667f, 0.01106307f, 0.00539055f, -0.01507572f, -0.05165781f, -0.07503498f, 
    -0.02611826f, -0.04769818f, -0.03781470f, 0.04597742f, -0.03933397f, 0.04474738f, -0.05355310f, -0.07443749f, 
    -0.01092844f, 0.00103833f, 0.00596982f, -0.03521103f, 0.01525029f, -0.01993381f, 0.05953595f, -0.00323497f, 
    -0.07937852f, -0.03067039f, -0.01142786f, -0.03439634f, 0.03313190f, 0.03120113f, -0.04869637f, 0.06194299f, 
    -0.06663464f, 0.01434932f, -0.05363957f, 0.06215314f, 0.00136756f, 0.06410360f, 0.05011353f, -0.06064694f, 
    -0.06275245f, -0.06348974f, -0.06501657f, -0.00749761f, 0.01195494f, -0.05496505f, 0.01220589f, 0.03838840f, 
    -0.07503727f, 0.01078812f, 0.04341979f, -0.06720014f, -0.02801214f, 0.01556150f, -0.01880266f, -0.05187144f, 
    -0.06480741f, 0.02341290f, -0.00497390f, 0.03011124f, -0.03942865f, 0.04346694f, -0.02985869f, -0.01964702f, 
    -0.01120142f, -0.06409403f, -0.04613221f, 0.06124361f, -0.01181491f, -0.05210826f, 0.04440010f, -0.01014504f, 
    0.05451734f, -0.02369307f, -0.00420008f, 0.06070279f, 0.01822603f, -0.03628945f, 0.03290909f, -0.01213797f, 
    0.06151775f, 0.00481803f, -0.03001028f, -0.06446654f, 0.04296879f, -0.05448218f, -0.02617311f, 0.04592250f, 
    -0.08033105f, -0.04320580f, 0.01608650f, -0.00619581f, 0.04393696f, -0.04739313f, -0.02481355f, -0.00346475f, 
    -0.03064718f, 0.02974177f, -0.01897246f, -0.08461463f, -0.06119900f, 0.05376662f, 0.05234567f, -0.05869839f, 
    0.04300389f, -0.06897391f, -0.00345465f, 0.02995797f, -0.03615011f, 0.05273186f, 0.04624998f, -0.03894595f, 
    -0.07136106f, -0.00795472f, -0.01285587f, 0.05305134f, 0.05808914f, 0.00091642f, -0.02367740f, 0.00217946f, 
    -0.00439672f, 0.03536920f, -0.02111105f, -0.01894369f, -0.00124561f, 0.00437067f, 0.01273604f, -0.02347381f, 
    -0.06253897f, 0.02267388f, 0.04379736f, -0.07933985f, -0.00046489f, -0.06977689f, -0.01903203f, -0.02323951f, 
    0.02015768f, 0.02942686f, 0.03715324f, 0.01595283f, 0.03441780f, 0.04767467f, -0.07600047f, -0.06130369f, 
    0.02275823f, -0.06881838f, 0.05925404f, -0.07219894f, 0.03518016f, 0.04620393f, 0.02132519f, -0.00612221f, 
    -0.00926509f, -0.01592166f, -0.02169916f, -0.02860355f, 0.03591311f, -0.05144680f, -0.01075347f, 0.00208646f, 
    -0.03818867f, 0.02831350f, -0.03110740f, -0.01614825f, -0.03696814f, -0.06666166f, 0.00849007f, -0.05355266f, 
    0.04452555f, -0.04933987f, -0.01332820f, -0.03189901f, 0.03227128f, 0.04098188f, -0.02815838f, 0.04102127f, 
    -0.05569542f, 0.03570553f, -0.02258173f, 0.05382803f, -0.00759077f, -0.04941727f, -0.04681884f, 0.05574150f, 
    0.04842430f, 0.05840160f, 0.03634461f, -0.14306509f, -0.20255429f, -0.04165509f, -0.02123088f, -0.17785537f, 
    -0.07409780f, -0.15688658f, -0.00352916f, 0.09463519f, -0.08089854f, -0.04590986f, 0.13332726f, 0.08151531f, 
    -0.00070912f, -0.08137424f, 0.04578083f, 0.08355779f, 0.00540114f, 0.06288861f, -0.02877281f, -0.02173772f, 
    -0.11677767f, -0.02761617f, -0.04695054f, -0.00725552f, -0.02164812f, 0.04202273f, -0.06529139f, 0.07298356f, 
    -0.06179237f, 0.06047204f, -0.10932294f, -0.11452295f, -0.19716181f, -0.04791598f, -0.29308060f, -0.21467085f, 
    0.28401330f, 0.01052080f, 0.06654570f, 0.07337315f, -0.05773185f, 0.03807644f, -0.19844775f, -0.28499618f, 
    -0.10783365f, -0.39639184f, -0.16728719f, 0.00102254f, -0.00734442f, 0.07076508f, 0.06630135f, -0.00556318f, 
    -0.01681185f, -0.02693986f, -0.01500163f, 0.07256074f, -0.03277588f, 0.23566766f, -0.03616278f, 0.07400000f, 
    0.12824561f, -0.05405676f, -0.02963144f, 0.05798576f, -0.02912071f, 0.01000732f, -0.00138980f, -0.08370470f, 
    -0.06970241f, 0.05414646f, 0.34869975f, 0.02410456f, 0.00344939f, 0.03470896f, 0.16589962f, 0.18032129f, 
    0.07201988f, 0.09525088f, -0.00377608f, -0.06213898f, 0.29266745f, 0.13405405f, 0.36852893f, 0.11213671f, 
    0.07875911f, -0.07642236f, -0.15961447f, 0.03821771f, -0.10549079f, 0.13852648f, 0.06222044f, 0.13501474f, 
    0.05259495f, 0.12149731f, -0.01462267f, -0.17667222f, -0.04287186f, -0.02616822f, -0.06408025f, 0.05674734f, 
    0.11425178f, 0.05241620f, -0.03479916f, 0.14569964f, -0.17800178f, 0.00652644f, -0.05742433f, 0.14976402f, 
    -0.00473206f, -0.03060988f, -0.09709693f, 0.00156376f, -0.00419933f, -0.04890211f, 0.10304230f, -0.04706645f, 
    -0.39492995f, 0.02034443f, -0.06244979f, -0.02323248f, -0.01303496f, 0.07623324f, -0.02156023f, 0.03251819f, 
    0.22483383f, -0.10284624f, 0.00996829f, -0.00197633f, -0.11118174f, -0.07406349f, -0.14875148f, -0.20321870f, 
    -0.04062077f, -0.04770603f, 0.12178807f, 0.07457520f, -0.00179707f, 0.06575502f, 0.05545460f, 0.04814542f, 
    0.16598107f, 0.04605369f, -0.32386830f, -0.07627243f, 0.06162069f, 0.13543570f, -0.00283897f, 0.09487919f, 
    -0.05451145f, 0.08886001f, -0.05864189f, 0.03868144f, -0.06023179f, -0.02302953f, -0.17373165f, 0.09377664f, 
    -0.07040862f, -0.03804277f, -0.14344427f, -0.18664700f, 0.07401305f, -0.01396401f, 0.00071454f, 0.02369620f, 
    0.08809459f, -0.18307748f, -0.17595020f, -0.05083657f, 0.03421560f, -0.06625041f, 0.22415510f, -0.00829995f, 
    -0.14095496f, -0.09165847f, 0.02970652f, -0.11373267f, -0.01092969f, -0.19890784f, -0.07415698f, -0.18468623f, 
    -0.06961823f, 0.13050766f, 0.26059878f, 0.15106653f, -0.03671253f, 0.00837316f, 0.04891353f, -0.18328394f, 
    0.04816936f, -0.06425159f, -0.09957832f, -0.10783889f, -0.02271553f, -0.06306992f, -0.12267127f, 0.04704953f, 
    -0.04101921f, -0.06433839f, 0.00431425f, 0.08068518f, -0.56720883f, 0.28207403f, -0.25506464f, -0.00333640f, 
    -0.01758607f, -0.06445133f, 0.17560908f, 0.06735834f, -0.04345755f, 0.11845341f, -0.02452642f, -0.06617949f, 
    -0.12828983f, -0.10246126f, -0.06831130f, -0.08898780f, 0.01506667f, 0.03108220f, -0.03479815f, -0.01141377f, 
    -0.11149917f, 0.02283369f, -0.11336914f, -0.03493938f, 0.24825130f, -0.11993042f, -0.09771506f, -0.07797252f, 
    0.18025333f, -0.10074963f, -0.01856866f, 0.06363082f, -0.03450785f, 0.14204516f, -0.08652921f, 0.00173559f, 
    -0.36395168f, 0.08722618f, 0.26631841f, 0.07547867f, 0.04600607f, 0.38688919f, 0.01444209f, 0.05799404f, 
    -0.04865205f, -0.07331336f, -0.07924019f, -0.04058415f, -0.27703768f, -0.28663334f, -0.21654828f, -0.17513365f, 
    0.05635213f, -0.03535900f, 0.00251105f, 0.05671727f, 0.06033892f, 0.10350648f, 0.17385848f, 0.04469372f, 
    -0.00033238f, -0.15410060f, 0.33437338f, 0.03651430f, -0.06852121f, 0.04153164f, 0.08477934f, 0.11019549f, 
    -0.10754966f, 0.02756933f, -0.03021351f, -0.12225020f, 0.12366484f, 0.33299637f, 0.20877928f, 0.36230570f, 
    0.20269762f, 0.08330560f, 0.01333111f, -0.16614132f, -0.00380357f, 0.14656705f, -0.07161360f, 0.06126536f, 
    0.19497649f, -0.02509100f, 0.04051916f, -0.12037023f, 0.02451446f, -0.06685678f, -0.05580711f, 0.11083155f, 
    0.02254698f, -0.00389048f, -0.02199063f, 0.08688197f, -0.22083485f, -0.06218679f, -0.06982428f, 0.05927848f, 
    -0.05272425f, 0.00665525f, 0.02153117f, -0.05273494f, 0.27079031f, 0.07216302f, 0.09400937f, -0.01666449f, 
    -0.10658100f, -0.07540329f, -0.12505397f, -0.13494422f, 0.03935681f, 0.01317900f, 0.05763824f, 0.00171918f, 
    0.05359028f, 0.01141218f, 0.01249617f, 0.08083937f, -0.04112283f, 0.20621510f, 0.00482133f, 0.04291066f, 
    0.02747710f, -0.00353424f, 0.02522605f, 0.06056838f, -0.07063933f, -0.04005684f, 0.12248918f, -0.06932379f, 
    0.31300208f, -0.05798432f, 0.04636458f, 0.45376539f, 0.02512572f, 0.03297665f, 0.09531986f, 0.08056429f, 
    -0.03419105f, 0.12493494f, -0.06136245f, 0.05594199f, 0.13566338f, 0.10539179f, -0.16312420f, 0.13628899f, 
    -0.09161694f, 0.03947578f, -0.17511722f, -0.12443221f, 0.14451420f, -0.01433457f, 0.05643601f, 0.02486876f, 
    0.30835080f, -0.07858523f, -0.16169511f, 0.25600109f, 0.14684296f, -0.05370430f, 0.28226084f, 0.07726850f, 
    -0.19278766f, -0.00488579f, 0.07170105f, -0.19729987f, 0.17441809f, 0.00241176f, 0.18199871f, -0.21803847f, 
    -0.18357725f, 0.07816283f, 0.32219914f, 0.20075266f, 0.02704021f, 0.10770459f, 0.05724479f, 0.06001826f, 
    -0.03599396f, -0.07772216f, -0.01822891f, 0.06366801f, -0.05646690f, -0.11237956f, 0.08451738f, 0.01836319f, 
    -0.08829992f, -0.01374393f, -0.06586201f, -0.09808222f, 0.12495613f, 0.10924064f, 0.11717773f, 0.23135078f, 
    0.17260672f, 0.02371526f, 0.01173272f, 0.01052464f, 0.05383730f, 0.10158384f, 0.14002331f, -0.16323011f, 
    0.01720122f, 0.10809715f, 0.00396767f, -0.01425431f, -0.01394786f, -0.04444230f, 0.02464700f, -0.07682271f, 
    0.20913036f, -0.10576275f, 0.00518350f, 0.00527975f, -0.36255959f, -0.10754572f, -0.22364917f, 0.27303064f, 
    -0.17534523f, 0.34542453f, 0.10800122f, 0.00747573f, -0.06763717f, -0.10119462f, -0.08000537f, -0.03125590f, 
    0.17662129f, 0.00128465f, -0.09456786f, 0.19364257f, -0.07087614f, -0.02185092f, -0.03782021f, -0.09637346f, 
    -0.00026320f, 0.09244281f, 0.03138599f, 0.13835435f, 0.04951164f, -0.12184913f, -0.13080452f, -0.09076399f, 
    -0.05703526f, 0.02913787f, -0.07210839f, 0.06547605f, 0.11922262f, 0.00891223f, -0.03637768f, 0.13198370f, 
    0.15317257f, 0.25670069f, 0.02256742f, -0.07448208f, -0.11761290f, 0.04453501f, 0.04152370f, -0.16288896f, 
    -0.02242690f, -0.04734309f, 0.02705591f, 0.15530092f, 0.07653663f, -0.11590475f, 0.08879918f, -0.05444464f, 
    0.01359422f, -0.10992701f, -0.02775922f, -0.09003733f, 0.03914348f, -0.03840492f, 0.06392681f, -0.05507198f, 
    0.20314549f, 0.12261546f, -0.07316957f, -0.05454929f, -0.14673939f, 0.10058530f, 0.09362897f, 0.04128970f, 
    0.00240454f, 0.02934023f, -0.00852996f, -0.02268266f, 0.12271821f, 0.16296679f, -0.02882974f, -0.14213853f, 
    0.10616977f, -0.01609096f, 0.06776610f, 0.03008933f, 0.03988857f, -0.03549182f, 0.02326233f, 0.01813644f, 
    0.32912070f, 0.04894402f, 0.06847768f, -0.08817757f, -0.04821257f, 0.06909384f, 0.13806492f, 0.00992728f, 
    0.06339929f, 0.05073736f, -0.11796146f, 0.00686461f, 0.12349635f, 0.08844938f, 0.05009994f, 0.00466539f, 
    -0.05010430f, -0.08577125f, -0.03641770f, 0.00866846f, -0.00254764f, -0.01605736f, 0.00143265f, -0.13367616f, 
    0.44828734f, 0.15558918f, 0.01252371f, -0.11158772f, -0.06050004f, -0.12561646f, 0.01631832f, 0.02660958f, 
    0.14609563f, 0.13429268f, 0.14518589f, -0.14548670f, -0.42158702f, -0.17069767f, -0.16872920f, 0.22562021f, 
    -0.19930027f, -0.07323067f, 0.06004304f, -0.20755868f, -0.06998839f, 0.08299992f, -0.00326452f, -0.03842332f, 
    0.24142404f, -0.16642706f, 0.13292353f, -0.05154229f, 0.01280338f, -0.13621840f, 0.09694798f, -0.09296078f, 
    0.04037282f, 0.20698023f, 0.04613799f, -0.09731555f, 0.10444031f, -0.08650949f, -0.12660226f, -0.01382950f, 
    0.00972663f, 0.13938947f, -0.09001984f, -0.01213669f, -0.08112438f, -0.02169934f, 0.00780372f, 0.09025747f, 
    0.01503825f, 0.05989047f, -0.03084749f, -0.10199718f, -0.02413492f, -0.10817391f, -0.01601608f, -0.08827630f, 
    -0.08788500f, -0.09614544f, -0.05447383f, 0.00673033f, 0.16262557f, 0.04053375f, -0.07284272f, -0.03378962f, 
    -0.07553039f, 0.16976307f, 0.01049939f, -0.16176897f, 0.02858919f, 0.15801939f, 0.02732816f, 0.10857555f, 
    0.18556438f, 0.02656950f, 0.13936201f, -0.00755173f, 0.08696923f, 0.04220393f, 0.05940389f, 0.03447453f, 
    0.08089341f, -0.07744952f, -0.03483150f, 0.05259509f, -0.08986037f, -0.12856692f, 0.00733709f, -0.17768523f, 
    -0.04029178f, 0.02834942f, 0.14033572f, -0.01734956f, 0.02644945f, 0.02921627f, -0.03186709f, 0.08509716f, 
    0.30662686f, 0.23787466f, 0.20377931f, 0.25194168f, 0.08214319f, 0.26447451f, 0.12679709f, -0.02246616f, 
    0.08173550f, -0.12919846f, 0.07602267f, 0.08814344f, -0.13821171f, -0.57788473f, -0.08632524f, -0.42862600f, 
    -0.06491929f, -0.06373903f, -0.00239999f, 0.08775210f, 0.02338030f, -0.01355984f, 0.11464778f, -0.00534366f, 
    -0.00271045f, 0.17439210f, 0.02727871f, 0.05277454f, 0.08634453f, -0.05694483f, -0.06605393f, -0.25588834f, 
    -0.07616385f, -0.00687762f, -0.08021463f, -0.02764679f, -0.08211927f, -0.07229318f, -0.03484239f, 0.06858084f, 
    0.11053322f, 0.00326835f, 0.01852002f, 0.01248177f, 0.08580095f, -0.12438161f, -0.10294134f, 0.04358118f, 
    -0.09901414f, 0.02440057f, 0.02108314f, 0.09738946f, -0.06609105f, -0.14578955f, -0.11198540f, 0.06868425f, 
    -0.11830528f, -0.03421482f, 0.11415403f, 0.06135045f, 0.13548508f, 0.02495726f, 0.08999047f, -0.08530408f, 
    -0.11575403f, 0.08405215f, -0.06009873f, -0.12977771f, -0.09065669f, -0.02211635f, -0.08530965f, -0.03019454f, 
    0.07186914f, 0.04019305f, 0.07655376f, 0.14529344f, -0.03689862f, 0.32198319f, -0.07021791f, 0.03613360f, 
    0.04164121f, 0.17802073f, 0.08133341f, 0.08137832f, 0.22818103f, 0.06609017f, 0.11394032f, 0.08334494f, 
    0.04451711f, 0.09446888f, -0.05015475f, -0.09786444f, -0.12501885f, -0.06662972f, -0.06874750f, -0.06300133f, 
    0.50784141f, 0.08697390f, 0.05037500f, 0.35422590f, -0.06358010f, -0.05756651f, 0.06164659f, -0.00618750f, 
    -0.14877005f, -0.18549883f, -0.19123507f, -0.10826422f, 0.28239569f, 0.16116218f, -0.09254394f, -0.05146863f, 
    0.09462482f, -0.03010210f, 0.06980760f, 0.30572873f, -0.11485308f, -0.06991175f, -0.01873370f, -0.01004264f, 
    0.24505138f, 0.14837395f, -0.02959426f, 0.17330202f, 0.02191418f, 0.00288214f, 0.14013161f, -0.01635765f, 
    0.12937865f, 0.07211632f, 0.12139791f, -0.03894615f, -0.07911424f, -0.06773130f, -0.17243110f, -0.15561004f, 
    0.09594626f, 0.03271935f, 0.16272290f, -0.05313826f, 0.00390656f, -0.09446404f, 0.01920418f, 0.09816132f, 
    -0.14883380f, -0.18463641f, 0.21213752f, -0.11533720f, -0.00091121f, 0.15176891f, -0.01909756f, 0.05733344f, 
    -0.08586679f, -0.09135139f, -0.11020951f, 0.01547357f, 0.09080008f, 0.30550596f, -0.07382295f, 0.27487981f, 
    -0.01923895f, 0.14525121f, 0.05637194f, 0.15972924f, 0.01056721f, -0.02383816f, 0.06423542f, 0.12963623f, 
    -0.05901717f, 0.14741711f, -0.23126653f, -0.05317665f, -0.13620202f, -0.12156438f, -0.20621707f, -0.10441496f, 
    0.07371321f, -0.11384270f, -0.16031319f, -0.17181329f, -0.07276897f, 0.16940269f, -0.13027300f, 0.03327112f, 
    -0.06930684f, -0.02453701f, 0.08163225f, -0.10799510f, -0.02346267f, -0.02257255f, 0.08610611f, -0.11240341f, 
    0.51805890f, -0.08744386f, 0.06496553f, -0.40669945f, -0.18484695f, -0.11538755f, -0.01812543f, -0.02341181f, 
    -0.08434132f, 0.00865940f, -0.00117928f, -0.00514476f, 0.02137271f, 0.46695417f, -0.01338267f, 0.08102506f, 
    -0.11976081f, -0.04931028f, 0.04844687f, -0.06172789f, 0.17942007f, 0.11814506f, 0.00551687f, -0.01690830f, 
    0.23441063f, 0.13761452f, 0.26352620f, -0.07987071f, 0.13696973f, 0.08050697f, 0.00846987f, 0.10029842f, 
    0.21273288f, -0.02589778f, 0.20506909f, 0.13667226f, 0.02931442f, 0.15647821f, 0.17004278f, 0.04977231f, 
    0.05128128f, 0.05163724f, 0.08924831f, 0.06445371f, 0.00509770f, 0.05613460f, 0.00698670f, 0.08602243f, 
    0.18792482f, -0.14367232f, 0.09688077f, 0.02295385f, -0.07719702f, 0.25658968f, 0.07856181f, -0.06815179f, 
    0.02259138f, 0.07597084f, -0.02595396f, 0.12515104f, -0.32050595f, -0.10314005f, -0.18398418f, 0.22628760f, 
    -0.03121608f, -0.10565026f, 0.11949179f, 0.09429017f, -0.04469858f, -0.04734287f, -0.06123042f, 0.02134693f, 
    -0.07521236f, -0.07432584f, -0.13564433f, 0.09661949f, -0.11668251f, -0.07326663f, 0.17693798f, 0.03793258f, 
    0.00238581f, 0.01183463f, 0.06648195f, 0.12879060f, 0.07977117f, 0.29340225f, -0.02266647f, 0.05958011f, 
    -0.11210311f, -0.06596600f, -0.01396895f, -0.01009663f, -0.07943987f, -0.00697135f, -0.18062802f, 0.01834714f, 
    -0.02451664f, 0.17637268f, 0.62615138f, -0.09127016f, 0.11440144f, -0.08743248f, -0.05664983f, 0.21915109f, 
    -0.00372811f, -0.10832994f, 0.07988272f, -0.03651436f, -0.54030490f, -0.02275821f, 0.04508672f, -0.02153212f, 
    -0.19879034f, 0.02807696f, 0.02013214f, -0.17570284f, -0.01560942f, -0.01953969f, -0.04253054f, 0.07240546f, 
    0.13677931f, -0.01289208f, 0.48553920f, -0.06784414f, 0.04241018f, -0.11012698f, -0.13106188f, -0.07016693f, 
    -0.20909266f, -0.13696468f, 0.04114822f, -0.07703402f, -0.05891712f, 0.06260337f, -0.09780515f, 0.00265674f, 
    0.04055573f, -0.00414488f, 0.04520546f, 0.12005087f, -0.01258538f, 0.09295300f, -0.16942453f, -0.07005605f, 
    -0.03714685f, 0.12068512f, -0.03186846f, -0.07311199f, 0.18310659f, -0.00400482f, -0.01631738f, 0.04862213f, 
    0.04947190f, 0.08823165f, 0.07821316f, -0.09584878f, 0.14817320f, -0.60427201f, -0.06890727f, -0.14174180f, 
    -0.07922623f, 0.06717605f, 0.18191189f, 0.07318575f, 0.00526587f, 0.01897899f, 0.04224191f, 0.20043670f, 
    -0.16289134f, -0.30836043f, -0.12713949f, -0.14343654f, 0.06565836f, -0.04422365f, 0.10037932f, 0.02330041f, 
    -0.12644373f, -0.22338577f, -0.11784317f, 0.03493226f, 0.23585683f, 0.19800416f, 0.39069501f, 0.11674463f, 
    0.02014521f, 0.14961137f, 0.11686551f, 0.07358748f, 0.06090998f, 0.05291411f, -0.02094756f, 0.09750087f, 
    -0.23949817f, 0.13988651f, -0.41477561f, 0.07213928f, 0.11513378f, 0.01389068f, -0.03312976f, 0.05266331f, 
    0.01345927f, -0.00618918f, -0.06389672f, 0.02316131f, 0.05359493f, -0.21361862f, 0.05729324f, -0.15971093f, 
    0.03035248f, 0.12039170f, 0.02950821f, 0.03865188f, 0.04671821f, 0.05399413f, 0.03520055f, 0.04082799f, 
    -0.28819016f, -0.25577527f, -0.15687917f, 0.08206813f, -0.00364656f, -0.00656912f, -0.19356754f, -0.08185568f, 
    0.02204370f, -0.13965324f, -0.02513406f, -0.07612639f, 0.18078616f, -0.20674291f, -0.09170543f, -0.05979219f, 
    0.07258663f, 0.06805498f, 0.03686508f, 0.11295422f, 0.04860883f, -0.05826316f, -0.01937090f, 0.04964209f, 
    -0.09422191f, -0.07246053f, 0.02504333f, 0.05829246f, 0.13051453f, 0.06507568f, -0.14638451f, 0.09032283f, 
    0.06268773f, -0.01838042f, 0.04473199f, 0.22047287f, 0.16718720f, -0.32884407f, -0.09954514f, -0.30088788f, 
    -0.06477675f, 0.03841168f, -0.02402609f, -0.05296610f, -0.07154065f, 0.12190363f, -0.05480693f, -0.01200127f, 
    0.34875226f, -0.46970075f, 0.17672220f, 0.15614581f, 0.03674539f, -0.06953207f, 0.04317392f, -0.04640198f, 
    0.00142637f, -0.03918837f, 0.11173061f, 0.05962635f, -0.05965556f, -0.11390364f, -0.26061252f, -0.09929060f, 
    0.13847649f, 0.19603418f, 0.02496966f, 0.02880769f, -0.06748546f, -0.05260509f, -0.00395588f, -0.08503167f, 
    0.27069625f, -0.27780685f, 0.09317151f, -0.05469731f, 0.09919690f, -0.03136258f, -0.02127819f, 0.08166555f, 
    -0.05323348f, -0.03992182f, 0.03929536f, -0.00731581f, 0.22058414f, 0.22275111f, 0.37347010f, -0.12168547f, 
    -0.08709265f, -0.17375667f, 0.09616105f, 0.10928827f, -0.02309128f, -0.02355222f, -0.02037287f, 0.05807355f, 
    -0.09826943f, -0.10611312f, -0.22949749f, 0.03935091f, -0.02267485f, -0.08518275f, 0.04319680f, -0.07341970f, 
    0.09748524f, 0.02134073f, -0.03219519f, -0.00217757f, -0.23201483f, 0.19849971f, 0.12513277f, 0.26609850f, 
    0.01739567f, -0.00816779f, 0.00671119f, -0.01235667f, 0.12259822f, -0.19768143f, -0.03800435f, 0.19118266f, 
    0.16794281f, 0.25726551f, 0.15567774f, 0.14715168f, 0.09742638f, 0.21212457f, 0.10456881f, -0.07980923f, 
    -0.08376655f, -0.03991321f, -0.05936682f, -0.21131530f, 0.16271180f, -0.03080041f, -0.08314203f, -0.00651774f, 
    -0.05981003f, 0.07386778f, -0.08632316f, -0.06171500f, 0.05477027f, -0.08183691f, 0.10035823f, 0.15034313f, 
    -0.11467758f, -0.31683668f, -0.19063993f, -0.08192223f, -0.04599994f, -0.03561374f, -0.11653710f, -0.16968140f, 
    0.09398337f, -0.08468449f, -0.08760808f, 0.13069984f, 0.10235763f, 0.23453526f, 0.36166224f, 0.03356719f, 
    0.11012839f, 0.00522943f, 0.08619729f, -0.01795314f, 0.06845139f, 0.02186470f, 0.19830760f, 0.05824082f, 
    0.34221637f, 0.14245977f, -0.41271368f, -0.20200714f, 0.08333217f, 0.06939434f, 0.07762547f, 0.19231507f, 
    -0.07379290f, -0.07149620f, -0.04863744f, -0.05117689f, 0.19374749f, 0.19510360f, 0.14290050f, -0.03368845f, 
    0.08216932f, 0.06572871f, 0.09338161f, -0.12754531f, 0.11039782f, -0.06509646f, 0.11955651f, 0.10154352f, 
    -0.42623413f, -0.24677497f, -0.21067777f, -0.01903993f, 0.21021454f, 0.09819409f, -0.09373249f, 0.04737966f, 
    0.14264186f, -0.02127845f, 0.03978584f, 0.13112277f, 0.17548604f, 0.15885748f, 0.04463340f, -0.16048843f, 
    -0.01636363f, -0.04380562f, 0.12973404f, 0.26722094f, 0.03633172f, 0.00721977f, -0.09921066f, -0.12278714f, 
    -0.07922447f, -0.19360247f, -0.17574337f, 0.11833634f, 0.11372704f, -0.03632495f, 0.03441003f, -0.06279205f, 
    -0.01531423f, -0.01005382f, -0.05175381f, 0.00405530f, -0.10725453f, 0.04848900f, -0.07977226f, -0.00210334f, 
    0.10007965f, 0.06281181f, -0.06650285f, 0.00569452f, 0.00227586f, 0.08486724f, -0.06287736f, -0.02021121f, 
    -0.06286582f, -0.28102639f, 0.22153161f, 0.18956108f, -0.11900975f, -0.06474893f, -0.03611585f, 0.05857892f, 
    0.13597584f, 0.12877718f, -0.01827571f, -0.01578560f, -0.55308574f, -0.34627557f, -0.17534222f, 0.01518763f, 
    0.19233792f, 0.12333223f, 0.07228376f, 0.10104516f, -0.04031274f, -0.04520922f, -0.11291102f, -0.07117507f, 
    -0.32198516f, -0.23115306f, -0.15518822f, -0.10305730f, 0.02809349f, 0.11772791f, -0.03538349f, 0.00554825f, 
    -0.07743509f, 0.09620513f, 0.00133089f, 0.06640496f, 0.26643950f, 0.36406568f, 0.47854060f, 0.21020980f, 
    0.03549612f, -0.03315728f, 0.08721573f, 0.23128894f, 0.08589610f, -0.02667080f, -0.04181446f, -0.10153936f, 
    -0.13104868f, -0.17220509f, -0.25115308f, -0.14551297f, 0.04991519f, 0.03395989f, -0.05761337f, -0.07916129f, 
    0.17846294f, -0.02435514f, -0.03142751f, 0.17231643f, -0.17977282f, 0.12451074f, 0.05814027f, 0.29539552f, 
    0.00915212f, 0.02396398f, 0.02076556f, 0.03603258f, 0.09742087f, -0.09142290f, -0.04699863f, 0.03770661f, 
    0.36936960f, 0.15108773f, 0.30701360f, 0.19705915f, -0.06997250f, 0.13619217f, -0.05431139f, 0.00031229f, 
    -0.12018451f, -0.03270521f, -0.03552674f, -0.08746983f, 0.07270715f, 0.25923973f, -0.28211594f, -0.01139246f, 
    0.04175153f, 0.05948094f, -0.04120824f, 0.07820782f, 0.16695096f, -0.11004274f, -0.03084086f, 0.13359615f, 
    -0.03768294f, 0.05369933f, -0.08314746f, -0.01949449f, 0.04059292f, 0.00541700f, 0.00769118f, 0.03936989f, 
    0.09121230f, 0.12512471f, -0.04262453f, 0.10995834f, -0.05593689f, 0.21836114f, -0.14488149f, 0.27463698f, 
    0.07602675f, 0.00873258f, -0.04867056f, -0.05700432f, 0.07005208f, 0.02056663f, 0.06982544f, 0.05685022f, 
    0.62201679f, -0.08504003f, -0.10398710f, -0.12167476f, -0.08082651f, -0.16185075f, 0.11868651f, -0.00230006f, 
    0.00588277f, -0.06291508f, 0.04021041f, -0.00136759f, 0.26464564f, 0.25573704f, 0.03702842f, 0.15438809f, 
    0.00192740f, 0.04155244f, 0.05730946f, -0.10726717f, 0.22627126f, -0.01929715f, -0.16895823f, 0.04846465f, 
    -0.12773569f, 0.18229012f, -0.03197511f, -0.12748939f, 0.06456653f, -0.03307226f, 0.13734408f, 0.03933232f, 
    -0.00583618f, 0.04125641f, 0.04704422f, 0.11066996f, 0.07281493f, 0.05907993f, -0.02618166f, -0.03904311f, 
    -0.08288259f, -0.13466510f, -0.02215594f, -0.09261567f, -0.04860208f, -0.05974350f, -0.11584178f, -0.10164028f, 
    0.03056594f, -0.07065199f, 0.02152152f, -0.05979988f, -0.20628653f, 0.07141414f, 0.04091313f, -0.07879649f, 
    0.00875283f, 0.09583189f, -0.18490821f, -0.25180653f, -0.20499507f, 0.06153557f, -0.11590313f, 0.22962768f, 
    -0.00713765f, 0.06575482f, 0.12255588f, 0.11331647f, -0.09539600f, -0.00876567f, -0.16417877f, -0.00927832f, 
    -0.21658638f, 0.15366255f, -0.13055962f, 0.03673344f, -0.05654243f, 0.12647302f, 0.24744567f, -0.05875800f, 
    0.05710471f, 0.15319368f, -0.11526986f, 0.07304085f, -0.11264420f, -0.00349637f, 0.03203216f, -0.02907797f, 
    0.00045894f, 0.04479276f, 0.11972462f, 0.06502680f, 0.03119795f, 0.00967300f, 0.00055420f, 0.04451267f, 
    -0.17333771f, -0.15282500f, -0.07665893f, -0.20883024f, 0.01470940f, 0.08214132f, -0.07379924f, 0.11557713f, 
    -0.04439841f, -0.05123677f, 0.05744869f, -0.17367686f, -0.00545748f, 0.08661193f, 0.05972302f, 0.25638974f, 
    0.02790313f, 0.15466177f, 0.10404198f, 0.03960559f, 0.00455709f, -0.00913960f, -0.06490438f, -0.07656923f, 
    -0.05829084f, -0.33352166f, 0.15400471f, -0.10338806f, 0.05528172f, 0.02917683f, -0.01930534f, -0.07997710f, 
    0.04826389f, -0.07662953f, 0.09991344f, 0.04598817f, 0.39129230f, 0.04675092f, 0.17359853f, 0.07383129f, 
    -0.05205886f, 0.04933881f, -0.17247538f, -0.00081027f, -0.07880524f, -0.03900418f, -0.04730634f, -0.18964323f, 
    -0.26538095f, -0.16133584f, 0.06739564f, 0.05057861f, 0.06568357f, 0.07439709f, -0.04924558f, 0.09715327f, 
    -0.03825304f, -0.02066652f, -0.05119820f, -0.08691739f, 0.29707870f, -0.09131058f, 0.21288192f, 0.08601124f, 
    -0.01464599f, 0.02680625f, -0.06815229f, 0.08225557f, 0.20180669f, 0.11306516f, 0.00448259f, -0.04842712f, 
    -0.05353200f, 0.01237339f, -0.03536331f, -0.10480061f, 0.00978014f, -0.06554228f, 0.02349470f, -0.05738963f, 
    -0.02404707f, 0.01174098f, -0.09761196f, -0.08897683f, 0.07442382f, 0.05471820f, 0.01807995f, 0.05190931f, 
    -0.01569185f, 0.01980806f, 0.19856960f, 0.03365804f, 0.02366596f, -0.23541673f, 0.04782923f, -0.12073739f, 
    0.06198549f, 0.10666634f, -0.15609577f, -0.03268817f, -0.18106113f, -0.34431714f, 0.05499469f, -0.19625656f, 
    -0.08525262f, 0.05285886f, -0.04404591f, -0.00346166f, 0.02456878f, 0.12270135f, -0.01327328f, 0.01828558f, 
    -0.01996997f, 0.20693353f, 0.15235545f, 0.04347875f, -0.04585512f, 0.11755580f, 0.01417445f, 0.04061617f, 
    0.27357161f, 0.22162673f, -0.10437766f, 0.05440707f, 0.09512482f, -0.11745477f, 0.10610819f, -0.10993412f, 
    0.09335322f, -0.07358690f, 0.04185547f, 0.08730815f, 0.06809615f, -0.01243099f, -0.15779206f, -0.22022580f, 
    -0.13040556f, -0.08198172f, 0.17119652f, 0.13893652f, 0.18145582f, 0.07821356f, 0.04709995f, 0.01949221f, 
    0.15015015f, -0.01129766f, -0.00548673f, 0.13959359f, 0.00206763f, 0.22542459f, 0.16357477f, -0.18476079f, 
    0.01903517f, 0.03598062f, 0.04005540f, 0.19804147f, -0.14853203f, -0.01456779f, -0.01718996f, -0.00409177f, 
    -0.05369146f, 0.00817840f, -0.06830106f, 0.16456249f, -0.07716881f, 0.09460924f, 0.04967851f, -0.05053527f, 
    0.48196250f, -0.01255447f, -0.34716374f, 0.08302489f, 0.00738481f, -0.02285258f, 0.03413346f, -0.04543900f, 
    0.16044156f, 0.04622508f, 0.00225857f, -0.18910734f, 0.16008161f, 0.07787345f, 0.15566562f, -0.04706799f, 
    -0.12352344f, -0.00149620f, -0.01616229f, -0.13573273f, 0.07802332f, 0.09651795f, -0.12872113f, 0.00536153f, 
    -0.04816661f, 0.19437195f, 0.49701449f, -0.24053288f, 0.03078056f, 0.01067883f, -0.05152478f, 0.13857871f, 
    -0.02896604f, -0.09302989f, 0.17860471f, 0.03410387f, -0.27495930f, -0.12654814f, 0.09773502f, -0.25252974f, 
    0.02131564f, -0.11087457f, -0.00918243f, -0.02356992f, 0.03764004f, -0.01198637f, 0.01241896f, 0.00082060f, 
    -0.15707096f, 0.04642186f, 0.50579971f, -0.15426807f, -0.03683449f, 0.02757598f, -0.11884104f, -0.02615262f, 
    -0.05834606f, -0.03927805f, 0.16917613f, 0.11307073f, -0.22284609f, 0.18385419f, 0.04407196f, 0.15919578f, 
    0.17253539f, 0.01248805f, -0.25495189f, -0.01155653f, 0.08465313f, -0.04085910f, -0.08279030f, 0.09680558f, 
    -0.20733459f, 0.02956597f, -0.17593637f, -0.11951621f, 0.07781442f, -0.08539288f, 0.06752741f, 0.09644128f, 
    -0.08678126f, -0.05252178f, 0.09041197f, 0.04360177f, 0.18208228f, -0.26791808f, 0.17760137f, 0.00273180f, 
    0.03324375f, -0.02580157f, 0.10216878f, -0.01820394f, -0.00901664f, 0.22653110f, 0.12988155f, 0.03701202f, 
    0.06077996f, 0.01863699f, 0.06007395f, 0.08259183f, 0.03215779f, -0.06374779f, 0.01592533f, -0.01169821f, 
    -0.06496118f, -0.14743626f, -0.11444027f, -0.11187714f, 0.13660219f, 0.16276748f, 0.11098929f, -0.05112926f, 
    0.04440466f, 0.14118624f, 0.01846060f, -0.00529490f, 0.01969378f, 0.04894534f, -0.11174744f, -0.00186249f, 
    -0.48794353f, -0.18737549f, -0.35960051f, 0.02405885f, -0.02926727f, 0.08111486f, -0.03167278f, -0.11238955f, 
    -0.09052884f, 0.00834622f, 0.00116196f, 0.12135688f, -0.13755666f, -0.03727389f, 0.03393741f, -0.20484653f, 
    -0.04930765f, 0.02129893f, 0.00541226f, -0.08093061f, -0.03051681f, 0.09256115f, 0.14854877f, -0.04394484f, 
    0.11236011f, -0.00685915f, 0.04586954f, 0.17542979f, 0.00715774f, -0.01925314f, -0.03349332f, 0.04765591f, 
    0.08459297f, -0.05956250f, 0.08005259f, -0.02544093f, 0.25011382f, -0.17428970f, -0.08713924f, -0.09175493f, 
    0.10957265f, 0.04168837f, 0.09129685f, 0.13909432f, 0.05056290f, 0.09938974f, 0.01840625f, 0.14378306f, 
    0.07982120f, -0.01439675f, 0.17716901f, 0.14050917f, 0.09283669f, -0.04959270f, 0.11500074f, 0.00363701f, 
    0.17187396f, -0.02949321f, 0.11860179f, 0.21075651f, -0.09333663f, -0.17046095f, -0.08463400f, -0.13014479f, 
    -0.02750320f, -0.14267215f, 0.01031387f, -0.16100153f, 0.23093325f, 0.16081627f, 0.23522681f, 0.00608523f, 
    0.19937381f, -0.12931167f, -0.00218771f, 0.10144787f, 0.05413758f, -0.10914760f, -0.00321776f, -0.06281543f, 
    0.25104100f, -0.09995015f, 0.18332955f, 0.05770012f, 0.09218132f, 0.05271981f, -0.10439997f, -0.03859565f, 
    0.00298200f, 0.02411092f, -0.08182842f, -0.11154886f, -0.06195910f, -0.14245041f, 0.05288459f, -0.14607742f, 
    0.69787484f, 0.00050420f, 0.14139961f, -0.05250798f, -0.05222471f, -0.18331543f, 0.09163383f, 0.01399305f, 
    0.09472371f, -0.11104261f, 0.09793316f, -0.02054619f, 0.06450377f, -0.00197826f, -0.00836479f, -0.21928671f, 
    -0.04582128f, -0.07782003f, -0.12563385f, -0.08211688f, 0.04821566f, -0.06392248f, 0.01147441f, -0.07051852f, 
    0.25913927f, -0.00383458f, 0.00714946f, 0.01797815f, -0.03837144f, -0.09626751f, 0.12101532f, 0.07511646f, 
    -0.10394303f, 0.10664891f, -0.16427806f, -0.11560831f, -0.30887136f, 0.20141365f, 0.03380927f, -0.03208260f, 
    0.08458756f, 0.12882212f, -0.02681928f, 0.05985296f, 0.16683392f, 0.02200793f, -0.00426529f, 0.13240087f, 
    -0.03357124f, 0.01651677f, -0.06863601f, 0.18668683f, -0.04881692f, -0.04412066f, 0.07127063f, -0.07430172f, 
    0.07460913f, -0.05272420f, -0.05373511f, -0.12447975f, -0.10756645f, -0.02292382f, 0.27566677f, 0.12567759f, 
    0.03211002f, -0.09776713f, 0.09667297f, -0.02698338f, 0.04760980f, 0.10489710f, 0.19591993f, 0.15511233f, 
    -0.19533424f, -0.21099600f, -0.10370882f, -0.25810200f, -0.11236956f, -0.17712677f, 0.11087000f, -0.02144735f, 
    0.17637473f, 0.26273176f, 0.22370477f, 0.20999274f, -0.30953121f, -0.26642421f, -0.06216199f, 0.04660640f, 
    -0.00837775f, -0.08569510f, 0.05518097f, 0.03203623f, 0.01963421f, 0.15470713f, -0.03406213f, 0.13638128f, 
    0.01520563f, 0.20444220f, 0.60347492f, 0.08897486f, -0.04186441f, -0.05220920f, -0.02104625f, 0.02465118f, 
    0.11683416f, -0.00142510f, 0.06125126f, 0.04112632f, 0.15370911f, 0.16091171f, 0.28634980f, 0.28622910f, 
    0.02468222f, -0.14203948f, 0.01245363f, 0.01615739f, 0.09077280f, 0.08720624f, 0.05906201f, 0.11580297f, 
    -0.01331423f, 0.10611254f, -0.14109193f, -0.13533668f, -0.01879105f, -0.00136413f, -0.04687825f, -0.09853657f, 
    -0.16135171f, -0.04141033f, -0.13324618f, 0.00655813f, -0.27505141f, 0.12819134f, 0.36209118f, 0.24878159f, 
    0.01659719f, 0.04112179f, -0.11493788f, 0.10088218f, -0.11235917f, -0.13350454f, 0.00034083f, -0.15615606f, 
    -0.12546635f, 0.44239810f, -0.18310142f, -0.15409485f, 0.10085885f, -0.17013051f, -0.17359185f, -0.00553704f, 
    -0.10083673f, -0.06480520f, 0.09544340f, 0.01826837f, 0.23747057f, 0.05510059f, 0.16817713f, -0.16200817f, 
    0.09134176f, -0.12721767f, 0.07478668f, -0.02247637f, -0.10304969f, 0.00176153f, -0.10227311f, -0.07460573f, 
    -0.19629420f, 0.28345093f, -0.03009690f, -0.14549515f, -0.03519350f, 0.18341850f, -0.14575413f, 0.04291281f, 
    -0.00680762f, 0.11257525f, 0.00740354f, 0.07196116f, -0.03351987f, -0.18055566f, -0.12980445f, -0.25152874f, 
    -0.17788005f, 0.00384743f, 0.04176174f, -0.06023708f, -0.09591127f, -0.10466101f, -0.04425334f, -0.10329321f, 
    -0.35040659f, 0.21564190f, -0.21689121f, 0.11036690f, 0.06498484f, 0.16181025f, -0.00830269f, -0.11431878f, 
    -0.11968779f, -0.00480564f, 0.05037683f, 0.11548706f, -0.09822956f, -0.17736183f, -0.10542227f, 0.18211721f, 
    0.00073430f, -0.05588982f, -0.00981921f, 0.13607158f, 0.10544621f, -0.05467316f, -0.01734612f, 0.00985901f, 
    -0.25326574f, 0.26885191f, -0.18245450f, -0.09732770f, -0.12709723f, 0.10901739f, 0.04463464f, 0.01669407f, 
    0.18878053f, 0.24795660f, 0.19580172f, 0.12258015f, 0.28533295f, -0.24934120f, -0.15341493f, 0.07933778f, 
    -0.00736581f, 0.00500632f, 0.15448453f, -0.10158736f, 0.05333724f, -0.06575370f, 0.18515837f, 0.09554645f, 
    0.07435895f, -0.00072983f, -0.22140673f, -0.18153802f, -0.01098087f, -0.05138756f, -0.03297136f, 0.06533139f, 
    -0.06656083f, -0.11752217f, 0.00795402f, -0.00711879f, -0.09526615f, -0.18537220f, -0.04243486f, -0.30801731f, 
    -0.02163977f, -0.02377138f, -0.02869614f, 0.03315465f, 0.04016555f, 0.10502566f, -0.08273093f, 0.03429706f, 
    -0.00678960f, -0.28415146f, 0.06430740f, 0.21663593f, 0.04695460f, 0.03362758f, 0.03856333f, -0.01714940f, 
    0.01400490f, 0.12775822f, 0.04830788f, 0.11897947f, 0.20090558f, 0.04606452f, 0.30580619f, -0.10028186f, 
    0.10051019f, -0.03041462f, 0.02896451f, 0.12231959f, 0.06212192f, 0.09173165f, 0.07056227f, 0.08590700f, 
    -0.30837807f, 0.19884939f, -0.20402843f, -0.07294217f, 0.26906025f, 0.34869269f, 0.14709577f, 0.21560347f, 
    0.03477834f, -0.06707906f, -0.14267273f, -0.20303005f, -0.20473224f, -0.12085740f, -0.02486560f, -0.10706840f, 
    -0.03003309f, -0.07075702f, -0.06139113f, 0.06262235f, 0.04342840f, -0.05129643f, 0.16569872f, 0.15754157f, 
    -0.18771720f, -0.38870236f, 0.19709367f, 0.36978462f, 0.14198609f, -0.03064685f, -0.06396977f, 0.08193752f, 
    -0.07185819f, -0.03453515f, -0.11329060f, 0.02300274f, 0.17090577f, -0.06077154f, -0.07887851f, -0.02955622f, 
    0.15529810f, 0.14554679f, 0.12491211f, 0.01087592f, -0.00706522f, 0.05025284f, -0.05369755f, 0.01076476f, 
    -0.09809300f, -0.12415314f, -0.02129940f, 0.16455612f, -0.10722432f, -0.25760996f, -0.19805112f, -0.06997650f, 
    0.00265789f, -0.04265774f, -0.03542861f, -0.06952993f, 0.05226090f, 0.03073680f, 0.08999690f, 0.11431251f, 
    -0.03241683f, 0.08110002f, -0.34553662f, -0.13678639f, 0.27462196f, 0.08235282f, 0.07241435f, 0.01662708f, 
    0.01112813f, -0.25560048f, 0.26598981f, 0.30066422f, 0.05289001f, -0.04456348f, -0.08998887f, 0.02866548f, 
    0.17589240f, 0.04555343f, 0.13663581f, -0.05374117f, -0.32342947f, -0.26450160f, -0.15235755f, 0.35950795f, 
    0.21222202f, 0.13550004f, -0.04099919f, 0.01340762f, -0.04368627f, -0.05465462f, 0.06733555f, -0.11086823f, 
    0.27231613f, -0.01418480f, -0.19153990f, 0.16245498f, 0.11237413f, 0.04598703f, 0.12873812f, -0.12247808f, 
    -0.10110912f, 0.09220743f, -0.16895084f, 0.00381840f, 0.22452097f, 0.27302441f, 0.02949766f, -0.16005820f, 
    0.05960695f, 0.14468588f, -0.03987182f, 0.05725304f, 0.00414314f, -0.03103043f, -0.06368178f, -0.02423760f, 
    0.28746819f, -0.06159711f, -0.41557926f, 0.04757986f, 0.20604050f, 0.05783201f, 0.11063942f, 0.13955610f, 
    0.20492853f, -0.09019450f, 0.00007057f, 0.07518931f, -0.30718958f, 0.07426116f, 0.17027001f, 0.02232806f, 
    -0.21305667f, -0.02294385f, 0.15170097f, 0.08651942f, 0.08486319f, -0.01787877f, -0.00129352f, 0.13329582f, 
    0.03938650f, -0.01738844f, 0.05852369f, -0.01865979f, -0.08208955f, 0.01174738f, 0.01948018f, -0.00133320f, 
    0.02554797f, -0.02884418f, -0.04518018f, 0.04953760f, -0.01022515f, 0.02624328f, -0.00938499f, -0.04680644f, 
    -0.01778699f, -0.03568681f, 0.03204250f, -0.06733031f, 0.05212383f, -0.01528177f, -0.00328968f, 0.01351306f, 
    -0.04493700f, -0.03656909f, -0.04507729f, 0.04913248f, -0.02104439f, -0.04795892f, -0.07967702f, -0.07744835f, 
    0.02639237f, 0.04786655f, 0.03389652f, 0.05631878f, -0.04434895f, 0.02587398f, 0.03488513f, -0.04139480f, 
    0.03967512f, -0.05605594f, -0.00906868f, -0.06764494f, 0.02617880f, -0.00079262f, 0.03544782f, -0.04632189f, 
    0.05226012f, 0.04900303f, -0.07388952f, 0.02979218f, -0.02193031f, -0.05219568f, -0.02837224f, 0.00149765f, 
    -0.03354346f, 0.06552665f, -0.06200125f, -0.00292256f, -0.01754233f, 0.05502223f, -0.02776516f, -0.05121364f, 
    0.05405204f, -0.03060009f, -0.06294095f, -0.05835195f, 0.02750213f, -0.03169699f, -0.07599970f, 0.04964238f, 
    0.04843217f, 0.00886730f, 0.03487464f, -0.02015464f, 0.02149858f, 0.01709996f, 0.05358420f, -0.05831232f, 
    0.03258887f, -0.04389943f, -0.01757653f, -0.01069787f, -0.01830220f, -0.07717860f, 0.05161662f, -0.03396873f, 
    0.04756580f, -0.01912106f, -0.07833539f, -0.04745623f, -0.04646661f, 0.04739147f, -0.06578771f, 0.01118193f, 
    -0.03561594f, 0.01087943f, -0.04180248f, -0.06883827f, -0.05527763f, 0.00904523f, -0.05687420f, -0.01126630f, 
    -0.06574413f, 0.00952495f, 0.03487721f, -0.01539832f, -0.00798042f, 0.05288229f, 0.04033177f, -0.08371342f, 
    -0.04774952f, 0.04794551f, -0.02294335f, -0.07287087f, 0.01080808f, -0.05499491f, -0.02216472f, -0.04274464f, 
    0.02940159f, -0.06563473f, -0.06280251f, 0.00794388f, -0.05439911f, -0.03631349f, 0.02756094f, -0.04280914f, 
    0.03204497f, 0.05131000f, -0.07623155f, -0.02228489f, 0.00424821f, -0.05254243f, -0.00038614f, 0.04806263f, 
    -0.04520145f, 0.02050380f, 0.02310892f, -0.02916653f, 0.02000457f, -0.02878591f, -0.06907423f, 0.00792897f, 
    -0.06871232f, -0.01476016f, -0.01261163f, 0.00632287f, -0.00172601f, -0.07032746f, 0.05803691f, 0.03017574f, 
    0.05350425f, 0.05282613f, -0.04467582f, -0.05635272f, -0.00799918f, -0.04683617f, 0.04055260f, -0.05361721f, 
    -0.01401492f, -0.07827134f, 0.04687389f, -0.04125829f, -0.01283097f, 0.04493761f, 0.02896548f, -0.07100945f, 
    0.01783043f, 0.00092401f, -0.07324174f, -0.04018924f, -0.04872484f, -0.02540259f, 0.02137268f, -0.04856456f, 
    0.05046273f, 0.01403636f, -0.04560773f, -0.02245675f, -0.00052671f, -0.04526379f, -0.02186891f, -0.04724011f, 
    -0.02480993f, -0.08209564f, -0.05311443f, 0.01863388f, -0.06372853f, 0.05658446f, -0.07369977f, -0.04208242f, 
    -0.01453299f, 0.00574872f, -0.01769315f, -0.04191520f, 0.02350410f, 0.02546098f, 0.04387874f, -0.05305217f, 
    -0.02129268f, -0.01345089f, 0.02943063f, -0.00723342f, -0.00655921f, -0.01856238f, 0.00143643f, -0.00343809f, 
    0.03748995f, -0.04844203f, 0.04878109f, 0.04455478f, 0.00042328f, -0.06684827f, -0.03809825f, -0.01484930f, 
    0.02224324f, 0.05214557f, -0.05756195f, 0.04352481f, -0.07818540f, -0.01504371f, -0.03025562f, 0.01462544f, 
    0.03729954f, 0.02144024f, 0.03283513f, -0.02061424f, 0.03867591f, 0.00739820f, -0.00510588f, -0.06694358f, 
    -0.04978535f, 0.03092500f, 0.00934890f, -0.04457936f, -0.01855955f, -0.00310408f, -0.05736705f, -0.01781262f, 
    -0.01025181f, 0.03008639f, 0.05993271f, 0.04152265f, 0.00182412f, -0.03284608f, -0.07166116f, 0.02758453f, 
    0.05991087f, -0.02617733f, 0.06335057f, 0.04395241f, -0.02114929f, -0.02272985f, -0.03220007f, 0.01485409f, 
    0.04340372f, -0.02904638f, -0.04570244f, -0.07107071f, 0.03878668f, -0.00573886f, 0.02513219f, -0.04497831f, 
    -0.06895286f, -0.02125431f, -0.07813090f, -0.05576121f, 0.04213733f, 0.06347982f, -0.03342349f, 0.04313199f, 
    -0.03620093f, -0.06546018f, -0.04458085f, -0.03733111f, 0.02867972f, -0.03964659f, 0.05154876f, -0.02195024f, 
    -0.01556522f, -0.00354712f, 0.05330761f, -0.03126062f, -0.02991099f, 0.02584452f, -0.01044874f, -0.01327050f, 
    0.04585287f, -0.05729001f, 0.01509629f, -0.02964546f, 0.04735314f, -0.06584290f, 0.05128254f, -0.01387650f, 
    -0.05483059f, 0.05211595f, -0.05396524f, -0.05605596f, 0.04900548f, 0.00482127f, -0.04079869f, -0.07699549f, 
    0.05156231f, -0.00429876f, -0.00366856f, -0.03747520f, 0.04770058f, 0.03154077f, -0.07226571f, -0.02202529f, 
    -0.01133116f, 0.06088476f, -0.00804958f, 0.01386582f, 0.01994125f, 0.02605072f, -0.03044687f, -0.06554294f, 
    0.04460227f, -0.05673971f, -0.02881466f, -0.04963280f, -0.04152950f, -0.05120014f, -0.02850573f, -0.00313394f, 
    0.02945392f, -0.05939073f, 0.05725750f, 0.03160656f, 0.05947982f, -0.02424597f, -0.01688029f, -0.02145656f, 
    0.00538283f, -0.07263638f, 0.00504942f, -0.07185259f, -0.02434922f, -0.02662322f, -0.03681470f, -0.07767137f, 
    -0.07722019f, 0.01938484f, 0.06094543f, 0.04310805f, -0.04417237f, 0.06015184f, 0.01278601f, -0.03752160f, 
    -0.02167479f, 0.01058281f, -0.02751276f, 0.01430308f, -0.02660342f, -0.07346824f, 0.01994706f, -0.04522254f, 
    -0.00460392f, 0.02468200f, -0.04857259f, 0.07150041f, 0.04044272f, -0.02394352f, 0.06201174f, -0.04390420f, 
    -0.03037174f, 0.04901465f, -0.05910301f, 0.04397362f, 0.05371367f, -0.01310170f, 0.01903244f, 0.03276598f, 
    -0.05427919f, -0.00856853f, -0.02598267f, 0.00927569f, -0.02446774f, -0.02410555f, 0.06402854f, 0.03340028f, 
    0.10149851f, 0.28666684f, 0.12775140f, 0.15879165f, 0.17008975f, -0.02936199f, 0.03069264f, -0.03774573f, 
    0.07264507f, 0.14020380f, 0.07411552f, 0.00091060f, 0.08326883f, -0.19384581f, -0.03705663f, -0.27446100f, 
    0.02975244f, -0.02754573f, 0.01765230f, 0.01884594f, 0.06223232f, -0.02601722f, 0.08011784f, 0.01001454f, 
    -0.06676278f, -0.14554232f, -0.03719909f, -0.03141361f, -0.00367570f, -0.04706798f, -0.01816916f, -0.03415599f, 
    -0.01703830f, -0.11277531f, 0.06196387f, 0.15898155f, 0.10487589f, 0.16514137f, 0.28024358f, 0.24106959f, 
    -0.08660646f, 0.11968839f, -0.00217624f, -0.08476007f, -0.05380600f, -0.04907510f, -0.09919567f, -0.03854429f, 
    0.02874035f, 0.38206521f, -0.12771778f, 0.00326320f, 0.02805531f, -0.04874786f, -0.15626262f, -0.00183307f, 
    0.09453912f, 0.06671743f, -0.02819420f, -0.02020301f, 0.01519591f, -0.15767366f, 0.04823086f, 0.07173146f, 
    0.04300238f, 0.08219392f, -0.01697530f, 0.04580163f, 0.02975220f, 0.00897170f, 0.02331945f, 0.01237506f, 
    -0.25488991f, -0.21122378f, -0.22723979f, -0.02885609f, 0.04310800f, -0.09199617f, -0.08799678f, 0.03176568f, 
    -0.02048144f, -0.04668297f, 0.01346497f, 0.01532823f, 0.11869676f, -0.02391712f, -0.24218310f, -0.04173923f, 
    0.04530315f, -0.11744834f, 0.06780741f, 0.11632358f, 0.03500576f, -0.09084765f, -0.01948245f, 0.03491373f, 
    -0.17545222f, -0.11669613f, 0.01402828f, 0.08294054f, -0.00386291f, 0.03255877f, -0.00315042f, 0.02962370f, 
    -0.01061918f, -0.11331594f, -0.03232611f, 0.24600849f, -0.02902520f, -0.16324379f, -0.11638582f, -0.13432580f, 
    0.01231563f, 0.04781534f, 0.09093342f, 0.02124467f, 0.03890273f, 0.19140901f, 0.05061783f, 0.00710701f, 
    -0.01740089f, -0.12332465f, 0.03253685f, -0.06624707f, -0.05954085f, -0.01334093f, 0.02178650f, -0.00436754f, 
    -0.16482137f, -0.04833260f, 0.06519726f, -0.04488904f, -0.09616280f, -0.18938735f, -0.05286912f, -0.05339692f, 
    0.03033533f, -0.02996661f, 0.00828648f, 0.03343266f, 0.05919035f, 0.02298366f, -0.06399877f, -0.01665745f, 
    0.13266467f, -0.41729906f, -0.09583188f, -0.01839115f, 0.01807200f, -0.04667741f, -0.01557616f, -0.00314600f, 
    0.05685966f, -0.02508097f, 0.09662718f, 0.01951658f, 0.31647539f, 0.15169966f, 0.47863361f, 0.16720319f, 
    0.05221365f, 0.02043958f, 0.05832813f, 0.12898754f, 0.07456344f, 0.02521772f, -0.04467105f, -0.05340873f, 
    -0.03793488f, -0.18010111f, -0.27455682f, -0.19427389f, -0.07840336f, 0.04782836f, -0.18333724f, -0.02287186f, 
    0.11462405f, 0.11387818f, -0.14255930f, 0.03502528f, -0.07339704f, 0.21558963f, 0.21382895f, 0.25672698f, 
    -0.12743081f, -0.05626414f, -0.06818227f, 0.01936006f, -0.06565864f, -0.07517657f, 0.00935829f, 0.06363469f, 
    -0.02833719f, -0.01935651f, -0.04031123f, 0.02629040f, 0.05672184f, -0.05604166f, -0.03479548f, 0.05277168f, 
    0.01310466f, -0.00462421f, -0.06971756f, -0.02055779f, -0.06885555f, 0.04193672f, 0.03467515f, -0.01564291f, 
    0.04180261f, -0.05671163f, 0.03477521f, 0.01158768f, -0.05215179f, -0.05774030f, -0.08343372f, -0.06167255f, 
    -0.02400357f, 0.00500826f, -0.04605861f, -0.08273506f, 0.00203900f, 0.02256224f, -0.08379290f, -0.00767835f, 
    0.02520321f, 0.03505641f, -0.00845897f, -0.05145549f, -0.00654411f, 0.05043280f, 0.02681264f, 0.07416257f, 
    0.07106634f, -0.05516654f, -0.02347547f, -0.00500964f, 0.08327448f, 0.02437479f, 0.02272809f, 0.05918455f, 
    0.01964128f, -0.01769399f, -0.05293878f, -0.06882139f, 0.04389128f, -0.00090572f, -0.01659749f, -0.00796849f, 
    0.06294795f, 0.06734484f, 0.01963340f, -0.00698867f, 0.00350469f, -0.04576812f, 0.00952638f, -0.05606883f, 
    -0.01444802f, -0.02762317f, 0.00208204f, -0.05813116f, -0.03102639f, -0.05740491f, -0.02499815f, 0.06216759f, 
    -0.09172527f, -0.02484994f, -0.04368081f, 0.00316059f, -0.05447276f, 0.04973655f, -0.06307906f, 0.02623774f, 
    0.04300845f, -0.03730930f, -0.02516463f, -0.04031178f, -0.04742902f, -0.06113577f, 0.05976358f, -0.04173299f, 
    -0.02647638f, 0.00335058f, -0.07554477f, 0.00151800f, -0.02563226f, 0.03379440f, -0.05423870f, -0.05634917f, 
    0.01843429f, -0.02795870f, -0.05996146f, -0.01118552f, 0.00587128f, -0.06297033f, 0.01954532f, -0.02381689f, 
    -0.07054361f, 0.03264584f, -0.01055920f, -0.08239114f, -0.06358697f, 0.07261185f, 0.03188201f, -0.05045200f, 
    -0.09272353f, -0.02289177f, 0.04834402f, -0.03871685f, -0.02301915f, 0.03248721f, 0.04483324f, 0.00505419f, 
    0.07026427f, -0.04615048f, 0.07100163f, -0.05823478f, -0.08149230f, -0.03402136f, -0.01135048f, 0.04773205f, 
    -0.02516339f, 0.04087007f, -0.07807162f, 0.00422945f, 0.00391420f, -0.04649241f, -0.04664344f, -0.07184491f, 
    0.04205995f, 0.07066599f, -0.04402117f, 0.03607261f, -0.08042131f, -0.07393734f, -0.02396570f, -0.07751718f, 
    -0.03274339f, -0.01367306f, -0.02586431f, -0.06951776f, 0.00311221f, -0.06172937f, -0.04081131f, 0.03830569f, 
    0.04083248f, -0.05803515f, -0.04378116f, 0.05427050f, 0.06256534f, -0.05164829f, 0.02836761f, 0.08145341f, 
    0.01573914f, -0.06872264f, 0.01675086f, -0.07055853f, 0.06262893f, -0.02948563f, -0.04145794f, -0.06435683f, 
    -0.00840520f, -0.04891747f, -0.05048298f, -0.04559832f, 0.01092631f, -0.01980108f, 0.07037747f, -0.05193829f, 
    0.04495033f, 0.02060776f, 0.00468234f, -0.06965382f, 0.05455375f, -0.05378663f, -0.02816002f, 0.02299445f, 
    -0.06560593f, 0.03930607f, 0.03321764f, -0.03451225f, -0.04918535f, -0.02172568f, 0.05320106f, 0.01118215f, 
    0.23370974f, -0.22032951f, -0.12371990f, -0.04495276f, 0.03904813f, 0.01490579f, -0.13329858f, 0.08406258f, 
    -0.05187242f, -0.19512206f, -0.11858273f, 0.01039184f, -0.22320724f, 0.23656657f, -0.10969483f, -0.05483658f, 
    0.01686321f, -0.02219532f, 0.04185778f, 0.13459474f, 0.16572645f, 0.21611756f, 0.04591937f, 0.08258813f, 
    -0.50804609f, -0.41727176f, -0.39548934f, -0.07485770f, -0.05093972f, -0.20204532f, 0.09982422f, -0.10115485f, 
    0.15199864f, 0.17668606f, 0.06474013f, 0.19482669f, 0.13276741f, -0.08516000f, -0.04045546f, -0.03531262f, 
    0.14420749f, 0.03610269f, 0.11086810f, 0.12069770f, -0.11786486f, 0.13789390f, 0.14759578f, 0.16368546f, 
    0.09178579f, 0.53270549f, 0.51553112f, 0.16662598f, -0.25707760f, 0.05308661f, -0.05862489f, 0.16706696f, 
    0.02714556f, -0.05939686f, 0.03642463f, -0.17386669f, -0.07582016f, -0.05026627f, 0.03488126f, 0.39892626f, 
    0.02544058f, 0.02438793f, 0.07195231f, 0.10863960f, 0.00124424f, -0.00779096f, 0.04391285f, 0.12749512f, 
    0.36105546f, -0.15942208f, 0.00409483f, 0.04659662f, -0.06458195f, -0.09419330f, 0.00981331f, 0.11221881f, 
    -0.11668225f, -0.12481121f, -0.10292690f, 0.03920688f, -0.16272102f, 0.25005370f, -0.04394585f, -0.00837804f, 
    -0.03651514f, 0.04559975f, 0.03189850f, 0.05250539f, 0.01288750f, 0.06864999f, -0.02678120f, -0.07833900f, 
    -0.08191455f, -0.07711821f, -0.08861476f, 0.07749584f, 0.05291682f, -0.12316111f, -0.06582928f, -0.05862052f, 
    0.07331625f, 0.09430746f, -0.05515612f, -0.03980255f, -0.08608802f, -0.16620448f, -0.12812956f, -0.10218926f, 
    -0.04351638f, 0.13605984f, -0.06430221f, 0.15209298f, 0.13189925f, -0.02558966f, -0.02407036f, 0.06740216f, 
    -0.12934242f, 0.38850713f, -0.10051755f, -0.03172829f, 0.01277878f, 0.09803327f, -0.01529738f, 0.14426821f, 
    -0.12120332f, 0.01878262f, 0.12938155f, 0.14138523f, -0.23034051f, -0.15716991f, 0.10672817f, 0.04449479f, 
    -0.37335193f, 0.02793325f, -0.48292032f, -0.15117858f, -0.01612742f, -0.15113483f, -0.09743094f, -0.05303126f, 
    -0.30302206f, 0.34577987f, -0.02875573f, 0.28329656f, -0.07325694f, 0.14619191f, 0.01579836f, -0.21204199f, 
    0.13979413f, -0.09730027f, 0.13247849f, 0.05918112f, 0.12853010f, -0.06552117f, -0.07601056f, -0.11854955f, 
    0.05747864f, 0.14402220f, -0.06026217f, 0.02771660f, 0.04483147f, -0.01378891f, -0.05001844f, -0.12944937f, 
    -0.13493726f, 0.16208720f, -0.36456656f, 0.25617340f, 0.03932521f, 0.21651083f, -0.28290272f, -0.10295273f, 
    0.19006868f, 0.18100812f, -0.03595672f, -0.03225385f, 0.33176100f, 0.02019610f, 0.13122483f, 0.07037768f, 
    -0.23927391f, 0.13718036f, 0.01301799f, 0.06812964f, 0.01666094f, 0.11093932f, 0.12288379f, 0.11633608f, 
    -0.23975271f, -0.01634461f, -0.27084097f, -0.10725500f, -0.04613722f, -0.09634814f, 0.19262715f, 0.10955393f, 
    0.06986117f, 0.01681191f, 0.07763550f, -0.05855578f, 0.35416710f, -0.56767070f, 0.26540577f, -0.04097665f, 
    0.08846917f, 0.01934058f, -0.14734760f, -0.10136687f, 0.02973578f, 0.16591348f, 0.11645618f, 0.18172474f, 
    -0.00318518f, -0.03851208f, 0.13715845f, 0.03354083f, 0.01481618f, 0.00507669f, 0.05559577f, -0.02016263f, 
    0.09031812f, -0.06740758f, 0.13196492f, 0.07403883f, -0.23122765f, 0.02577303f, 0.10926443f, 0.05389808f, 
    0.08671942f, 0.08341740f, 0.00902838f, 0.01588908f, 0.04733034f, 0.11156587f, -0.02050176f, 0.06090986f, 
    -0.21300922f, -0.36799255f, -0.10408609f, -0.20826624f, 0.18879139f, 0.00804912f, 0.15818684f, -0.01569080f, 
    0.02648604f, -0.03863158f, -0.00671945f, 0.06175287f, 0.13660444f, 0.44282532f, 0.27821466f, 0.10687319f, 
    -0.07272496f, -0.07370764f, -0.08221174f, 0.00845301f, 0.09486082f, -0.03799783f, 0.07521379f, 0.17007481f, 
    -0.10332634f, 0.01836838f, -0.10768291f, 0.12616803f, -0.09292764f, 0.12258542f, -0.06819030f, -0.05220203f, 
    0.13592958f, 0.06532585f, -0.08007466f, 0.11911304f, -0.11234406f, -0.28696060f, 0.23452124f, -0.13793474f, 
    0.07794964f, 0.06215188f, -0.03678802f, 0.19627458f, 0.03220192f, 0.03754099f, 0.04204872f, -0.05283843f, 
    -0.06019904f, 0.22949623f, -0.11196925f, -0.04247835f, -0.01681183f, -0.08439102f, 0.03037902f, 0.03726629f, 
    0.04082483f, -0.06516129f, 0.06712607f, -0.11751726f, 0.13672762f, 0.06988943f, 0.07359440f, 0.09999585f, 
    0.04030194f, -0.19588578f, -0.10864281f, -0.11110429f, -0.08576123f, -0.06034032f, 0.03958644f, 0.09141780f, 
    0.11198925f, -0.29750553f, 0.34886047f, 0.24959463f, -0.08322573f, 0.01174622f, -0.01130007f, 0.02428347f, 
    0.22547691f, -0.04113953f, 0.13755678f, 0.07856762f, -0.05575003f, -0.12592845f, -0.27291420f, 0.02750725f, 
    -0.03351167f, 0.06011095f, 0.14045016f, 0.03836972f, -0.00335185f, -0.06942862f, 0.07186101f, 0.05170505f, 
    0.01479231f, 0.37011144f, -0.30397016f, -0.25072235f, 0.05445799f, -0.00215532f, 0.05319708f, 0.09142163f, 
    0.05952431f, 0.05078793f, -0.03534156f, 0.04780930f, -0.17070794f, -0.00885922f, 0.00787371f, 0.03969262f, 
    0.02459883f, -0.02988653f, -0.05407290f, 0.08339139f, -0.09981368f, -0.01639240f, 0.05106936f, -0.05945937f, 
    0.19583695f, -0.08404985f, 0.01246767f, -0.25858846f, -0.00668269f, -0.13961560f, 0.16570207f, -0.05290655f, 
    0.06072309f, 0.10575839f, -0.25099254f, 0.00701382f, -0.26248631f, -0.08977670f, -0.24660279f, 0.16223766f, 
    -0.03604592f, -0.05976075f, -0.00230264f, -0.09638730f, 0.10192862f, 0.02197875f, 0.00465994f, 0.17815760f, 
    0.01834976f, -0.11431995f, -0.10496892f, -0.26138955f, 0.08242987f, 0.02143395f, 0.05757543f, 0.14139371f, 
    0.12464209f, 0.02056134f, -0.00640817f, -0.07899249f, 0.10671967f, -0.23896603f, -0.17174540f, -0.26200700f, 
    0.01448492f, 0.13297416f, -0.06734692f, -0.03010182f, 0.00744074f, 0.08979467f, 0.04698209f, 0.13034318f, 
    -0.01229582f, -0.16744500f, 0.00861496f, -0.00128397f, 0.04783934f, 0.03390509f, 0.09771520f, 0.02895931f, 
    0.19074076f, 0.10548703f, 0.07591801f, 0.02647970f, -0.04598841f, -0.10970175f, 0.19522129f, -0.15587282f, 
    0.14851142f, -0.21643747f, -0.15152547f, 0.12472901f, 0.04145478f, 0.01214237f, 0.13283753f, 0.09738106f, 
    0.05300333f, 0.06872788f, 0.29976100f, -0.19549674f, -0.01611068f, 0.01330494f, -0.01645490f, 0.26563168f, 
    0.01887470f, -0.12748142f, -0.08345077f, -0.09118140f, -0.01212416f, 0.14402713f, 0.12635161f, 0.19471718f, 
    0.07836848f, -0.12513970f, 0.01439328f, 0.00490624f, -0.03065770f, -0.00299930f, 0.26415533f, 0.14627875f, 
    -0.06390970f, -0.20055713f, -0.06984563f, 0.18400750f, 0.02188282f, -0.00632618f, 0.06400213f, 0.12837982f, 
    0.06003199f, 0.00622091f, -0.14141437f, 0.02281718f, -0.21109356f, -0.01124273f, -0.29510233f, -0.02118289f, 
    0.11052112f, 0.32559040f, 0.13173924f, 0.16109338f, 0.19041486f, -0.01133412f, 0.12770920f, -0.12643309f, 
    -0.06872136f, -0.12634447f, -0.15465525f, 0.08243594f, 0.02176041f, -0.16270791f, -0.10323589f, 0.05669528f, 
    0.06121150f, 0.00279341f, 0.10768561f, -0.05907233f, -0.00779716f, -0.20540540f, 0.00545234f, 0.00143225f, 
    0.10367907f, -0.06079910f, -0.17651385f, -0.12850060f, -0.00565679f, 0.08212185f, 0.03635854f, 0.24118498f, 
    -0.25150061f, -0.05044584f, 0.13533995f, 0.10623495f, 0.00174457f, -0.03595863f, -0.06378698f, 0.07221103f, 
    0.09408341f, -0.04413196f, 0.00736280f, 0.15040952f, -0.21320641f, -0.11425473f, -0.13223489f, 0.12106647f, 
    0.00498835f, -0.02433876f, 0.00972895f, -0.03815211f, 0.00288329f, -0.07603735f, -0.20123512f, 0.11879498f, 
    -0.30870685f, 0.28199905f, -0.11246892f, 0.11977289f, 0.14768085f, 0.08949124f, 0.09287730f, -0.08751171f, 
    -0.00379835f, -0.01195282f, -0.03654993f, -0.01374769f, 0.09971143f, -0.07508908f, 0.03140747f, -0.20634063f, 
    0.09142221f, 0.01346827f, 0.15711035f, 0.19093329f, 0.12879826f, -0.00125243f, 0.02515134f, -0.08101312f, 
    -0.26696169f, 0.09408076f, -0.21171570f, -0.07037873f, 0.02629773f, -0.02414900f, -0.25721243f, 0.00659765f, 
    0.15860209f, -0.01898354f, -0.06624684f, 0.00546249f, -0.02351334f, -0.06392608f, 0.01973281f, -0.02166132f, 
    0.11454386f, -0.24362062f, 0.06216569f, 0.17415293f, 0.14809251f, 0.12877962f, 0.11099030f, 0.08863885f, 
    0.02601534f, 0.03592715f, -0.10657430f, 0.12192618f, -0.01435930f, 0.23727183f, -0.02610854f, -0.04470091f, 
    -0.06825347f, 0.11208607f, 0.04870624f, 0.10852629f, 0.13574007f, 0.03533019f, 0.12752287f, -0.06749179f, 
    -0.25758237f, 0.00980624f, 0.06355239f, -0.14286487f, 0.09813569f, 0.04758210f, -0.10930388f, 0.09575035f, 
    0.14683953f, -0.09135962f, 0.13815346f, 0.04170483f, -0.06271914f, -0.00731882f, 0.01147315f, -0.19933644f, 
    0.02588192f, 0.03628983f, -0.02474683f, -0.04958271f, 0.21247520f, 0.08724181f, -0.02358362f, -0.21824276f, 
    0.18038595f, -0.13696474f, -0.05485975f, 0.08430805f, -0.07724185f, -0.11913651f, 0.07348359f, -0.00759419f, 
    0.03843851f, 0.27075487f, -0.02718264f, 0.05312975f, -0.12596752f, 0.00222312f, 0.00745751f, 0.21498245f, 
    0.04495277f, -0.02876765f, -0.01426442f, -0.04346157f, -0.08116560f, -0.48347580f, -0.19478504f, -0.35874611f, 
    -0.07924209f, -0.08222008f, -0.07813374f, -0.05628543f, -0.00600456f, -0.03763164f, 0.09597620f, -0.04489405f, 
    0.07905542f, 0.09269449f, 0.03120307f, -0.04584433f, 0.01320350f, -0.08919077f, 0.08335204f, -0.04053490f, 
    -0.03525966f, 0.10293950f, -0.01037472f, -0.01500072f, 0.11817018f, 0.14989990f, -0.08500586f, 0.02163243f, 
    -0.03931225f, 0.08469187f, 0.02177807f, 0.17639987f, 0.08731794f, -0.02519536f, -0.04060675f, -0.01936852f, 
    -0.02551255f, 0.08517846f, 0.01807787f, 0.03338005f, 0.16571601f, -0.01422980f, 0.06287934f, -0.15801905f, 
    0.08595932f, -0.01516303f, 0.09765343f, 0.01688459f, 0.26461673f, 0.00668568f, 0.21566772f, -0.12659155f, 
    -0.16055696f, 0.08060666f, -0.06615954f, -0.03038016f, -0.01751906f, 0.07288219f, 0.00504935f, -0.01371850f, 
    0.18484081f, 0.17071979f, -0.09822449f, 0.02064453f, 0.07141686f, -0.03662260f, -0.11137082f, -0.16798161f, 
    -0.07754105f, -0.02432055f, 0.05143785f, 0.03137958f, 0.10549053f, 0.06948592f, 0.18526499f, -0.12880079f, 
    0.01448057f, -0.01569805f, -0.06463100f, -0.13719927f, 0.01628150f, 0.13213383f, 0.00623313f, -0.02038105f, 
    -0.16610077f, -0.05503061f, 0.22982456f, 0.25571913f, -0.07982834f, 0.04473707f, -0.02726882f, -0.04574487f, 
    -0.11885514f, -0.00765574f, 0.03918432f, 0.06989446f, 0.29890212f, 0.16632494f, 0.00222301f, -0.16961090f, 
    0.14908139f, 0.14465155f, 0.10618679f, 0.27692977f, 0.05656157f, -0.00210851f, -0.04045416f, 0.09688900f, 
    -0.31963727f, 0.50746024f, 0.11448552f, 0.03883217f, 0.02739692f, 0.05236843f, -0.17681949f, 0.00348867f, 
    -0.02005444f, -0.29534605f, 0.08725253f, 0.12384869f, -0.02424276f, 0.26708126f, 0.07099369f, 0.01664689f, 
    0.07604676f, -0.01833084f, 0.10936984f, 0.22730987f, -0.09290870f, -0.06786752f, -0.06312807f, 0.03669953f, 
    -0.14908227f, 0.02842820f, 0.14516100f, 0.19416679f, 0.06774314f, 0.24549048f, 0.23248455f, 0.10717294f, 
    -0.06123160f, 0.08941567f, 0.06165966f, -0.05073521f, 0.43775764f, -0.04156606f, 0.22490239f, 0.11075307f, 
    0.01063907f, 0.02835281f, -0.27077603f, -0.01734308f, 0.11953776f, -0.04990728f, 0.00226595f, -0.07346205f, 
    0.16356777f, 0.10539442f, 0.08123314f, 0.07690942f, -0.04075349f, -0.05466127f, -0.06770462f, -0.13506781f, 
    0.16492045f, 0.09868231f, 0.05350037f, -0.08578628f, -0.29544038f, 0.12194983f, -0.01871749f, 0.17289481f, 
    -0.01856736f, 0.07689550f, 0.01873843f, -0.05859722f, -0.12995578f, -0.26130748f, -0.05268483f, -0.08955438f, 
    0.53350085f, 0.14800505f, -0.19408849f, 0.03643661f, -0.05342153f, -0.36138386f, -0.01777607f, 0.05147553f, 
    0.04447266f, -0.04074060f, 0.04865635f, -0.00458891f, 0.31068856f, 0.04787896f, -0.18721701f, -0.07686993f, 
    -0.07465108f, 0.01060897f, -0.06696482f, -0.08650111f, 0.06602201f, -0.03102462f, -0.05999646f, -0.04367545f, 
    0.07500273f, 0.35918134f, -0.18216111f, -0.05452665f, -0.15525155f, 0.00680811f, 0.02232365f, -0.09341305f, 
    0.02389805f, 0.02877717f, 0.06314155f, 0.01918332f, -0.06580593f, -0.01052737f, 0.00979980f, -0.08679108f, 
    -0.07495265f, -0.06660298f, 0.10978287f, 0.15159918f, 0.08075240f, -0.01051706f, -0.03857225f, -0.08539736f, 
    0.02080367f, 0.10696796f, -0.10388605f, -0.02193060f, -0.16552638f, 0.12154207f, 0.25195369f, -0.18716033f, 
    0.05398395f, 0.05940221f, 0.04443764f, -0.05550288f, 0.15079519f, 0.16977490f, 0.06326193f, -0.06760729f, 
    0.06049886f, -0.03990183f, -0.05570154f, 0.05152816f, -0.20324840f, -0.15435904f, -0.19376321f, 0.01227574f, 
    0.29805985f, 0.09285875f, -0.05436424f, -0.10017629f, -0.05025161f, 0.01213818f, 0.05623760f, 0.03846372f, 
    -0.05629802f, 0.08296434f, -0.20093778f, -0.00124443f, 0.04583172f, 0.01871761f, 0.13961363f, 0.03569629f, 
    -0.04811075f, -0.10076733f, 0.09984267f, -0.07551865f, 0.04107650f, 0.16493846f, -0.06764147f, -0.00687024f, 
    -0.14068510f, 0.08268238f, 0.09369100f, -0.31670627f, -0.06247098f, 0.02446542f, -0.06179454f, -0.04057875f, 
    -0.00395379f, -0.11338118f, 0.20221286f, -0.04805538f, -0.08113873f, 0.00899450f, 0.25381657f, 0.14313905f, 
    0.06425437f, -0.03807845f, 0.26369265f, 0.20192896f, -0.11981469f, -0.03732279f, -0.06595151f, 0.06007205f, 
    -0.07930169f, 0.05531619f, 0.23259616f, -0.16092829f, -0.03756060f, -0.03134583f, -0.19426851f, -0.02917145f, 
    0.14579859f, -0.13472089f, 0.18503469f, 0.25728938f, -0.14337662f, -0.09726124f, -0.10809826f, 0.22668123f, 
    0.09459668f, -0.09464097f, -0.21901672f, -0.03409562f, -0.02939507f, -0.04216914f, -0.16011542f, -0.08033060f, 
    -0.04928735f, 0.08788543f, -0.12278471f, -0.17503902f, 0.04419924f, -0.03010041f, -0.08005873f, 0.16924177f, 
    0.04376426f, -0.04405765f, 0.09676027f, 0.07162414f, -0.29458272f, 0.03206690f, 0.10590905f, -0.00955273f, 
    0.06902154f, -0.02340320f, -0.02699011f, 0.19913875f, 0.02286059f, 0.02841984f, 0.06376113f, 0.03149006f, 
    -0.22719809f, -0.17127933f, -0.06983244f, -0.16371751f, -0.17670436f, -0.09175318f, -0.19580582f, -0.12469285f, 
    0.01441459f, -0.05572427f, -0.05069023f, -0.17288180f, 0.06981824f, -0.02891242f, 0.10843754f, -0.03040802f, 
    0.05836779f, 0.04942287f, 0.01965954f, 0.00674717f, 0.03993986f, 0.03148719f, -0.18065728f, -0.11606085f, 
    -0.51087952f, 0.04445404f, -0.08653070f, -0.01092908f, 0.06080889f, 0.31792468f, 0.02496482f, -0.07882099f, 
    -0.19976377f, -0.01392490f, -0.14323647f, -0.08161081f, -0.18459564f, 0.08964064f, -0.04068357f, -0.13239056f, 
    0.05668550f, -0.17436051f, -0.10100637f, 0.19341035f, 0.05833983f, -0.02881984f, 0.05786990f, -0.04188457f, 
    0.06217004f, -0.30222344f, 0.23607919f, 0.30322880f, -0.13546839f, -0.04943784f, -0.01573355f, 0.04286022f, 
    -0.00255710f, 0.15373951f, 0.10330416f, -0.00760978f, 0.15581994f, 0.23267531f, 0.34829792f, 0.15228555f, 
    0.15714023f, -0.03469569f, 0.15212804f, -0.20063423f, -0.04535685f, 0.17064442f, -0.04575314f, 0.15976377f, 
    0.20853236f, 0.08423775f, -0.03133869f, 0.02567812f, 0.02521932f, -0.02342707f, 0.00718203f, 0.07190020f, 
    0.18881601f, -0.02931986f, 0.14094102f, 0.01852504f, -0.11051004f, -0.06539577f, -0.09897563f, 0.00188511f, 
    -0.12141019f, -0.21991991f, -0.19163959f, -0.22646014f, 0.29242483f, -0.03332218f, 0.12265141f, 0.17456999f, 
    0.00763625f, -0.23142670f, 0.15420291f, 0.04923332f, 0.03152377f, -0.01623410f, -0.10757989f, -0.08890135f, 
    0.02394459f, -0.03261510f, 0.03323782f, -0.03144469f, -0.15098365f, -0.01047690f, -0.11878256f, 0.05486405f, 
    0.03931529f, -0.02727825f, -0.15139820f, 0.05343119f, 0.13331760f, 0.01721050f, 0.20510022f, 0.03755998f, 
    0.69605726f, 0.12521344f, -0.16972436f, 0.15412052f, -0.08799963f, -0.05258186f, 0.07592792f, -0.00812946f, 
    0.03453746f, 0.15424566f, 0.02386957f, -0.03738260f, -0.02070677f, 0.19493243f, -0.04064969f, 0.14144170f, 
    -0.05567279f, 0.03269276f, -0.07821430f, -0.13925393f, -0.04660559f, -0.01865001f, -0.07292639f, -0.01358916f, 
    0.68826580f, -0.27424601f, -0.41884711f, 0.10941007f, 0.05435380f, -0.22390531f, 0.30412000f, 0.09381587f, 
    0.11613918f, -0.05117333f, 0.05518975f, -0.05330171f, -0.23517920f, -0.00901964f, -0.04900981f, 0.07625807f, 
    0.04576832f, 0.02437620f, 0.16720167f, 0.13129744f, 0.06141707f, -0.02525951f, 0.05400542f, -0.13354321f, 
    -0.05211985f, -0.06337491f, 0.05051425f, 0.00645014f, -0.00909072f, 0.02299506f, -0.05380781f, 0.04883959f, 
    -0.00227662f, -0.04607014f, -0.03310581f, -0.02379645f, 0.00600563f, -0.04614053f, 0.00984637f, 0.06118932f, 
    -0.01463812f, -0.07303239f, 0.02337589f, -0.06347404f, 0.02575536f, -0.06347069f, 0.03807147f, -0.05351566f, 
    0.00246777f, -0.00342919f, -0.06542630f, 0.06084814f, -0.02527143f, -0.01108380f, -0.05806571f, 0.04197172f, 
    0.06418845f, -0.00583262f, -0.04264820f, 0.04466527f, -0.06089001f, -0.01388031f, -0.03343154f, -0.05393156f, 
    0.01472424f, 0.06074596f, -0.06188919f, -0.03882774f, 0.03200171f, 0.01365862f, 0.03786742f, -0.04850863f, 
    -0.07639351f, 0.04902093f, 0.05424678f, -0.04196658f, -0.03654619f, -0.06966547f, 0.01833800f, -0.03623612f, 
    0.04773128f, -0.00961463f, 0.04345826f, 0.04171164f, 0.05637747f, 0.02730878f, 0.01009934f, -0.00495439f, 
    -0.07079799f, -0.00094155f, -0.02159728f, -0.05003716f, 0.01422564f, -0.04775636f, 0.05471686f, 0.00064326f, 
    -0.00319114f, 0.03850644f, 0.04286795f, 0.05087141f, 0.01364876f, -0.01936242f, -0.07832911f, -0.08045683f, 
    0.01209138f, -0.03474294f, 0.04517221f, 0.05013946f, 0.05427653f, 0.04452556f, 0.02337453f, -0.03576045f, 
    -0.08147959f, -0.05777581f, 0.01881965f, -0.07874454f, -0.04225554f, -0.06854365f, 0.04899632f, -0.03579701f, 
    -0.06089279f, 0.03899268f, -0.00881680f, 0.01867730f, 0.05718878f, 0.04152054f, 0.05882037f, -0.03920956f, 
    0.04041426f, -0.03144815f, 0.00334442f, -0.07066718f, 0.00353997f, -0.00605520f, -0.07455217f, -0.02133253f, 
    -0.04714144f, -0.05779454f, 0.02636642f, -0.01434834f, -0.03240639f, -0.03422550f, -0.01088749f, -0.04361201f, 
    -0.05106062f, -0.07440019f, 0.02567224f, -0.01077627f, -0.07116301f, 0.03128450f, -0.02261400f, -0.07032885f, 
    0.02670534f, -0.04282333f, -0.07928692f, -0.07173914f, 0.04082294f, -0.03722186f, -0.05196800f, 0.04060788f, 
    -0.06863087f, -0.05476188f, -0.00072024f, 0.04648548f, -0.07134289f, 0.04462161f, 0.02541349f, -0.01986610f, 
    0.03714641f, -0.03588732f, 0.05084505f, 0.05897053f, -0.00556341f, -0.00724443f, -0.02455981f, -0.01834091f, 
    0.00262412f, -0.06998041f, -0.00274619f, 0.04546904f, -0.03031510f, 0.03499785f, 0.05204771f, 0.01728548f, 
    -0.03444180f, -0.00668806f, 0.02405171f, -0.03879017f, 0.00996223f, 0.03944545f, 0.02557879f, -0.06359544f, 
    -0.01622974f, -0.03095242f, 0.01306888f, 0.05495180f, -0.03816389f, -0.06193573f, 0.03284992f, -0.01186862f, 
    -0.05149928f, -0.01224352f, -0.04465104f, 0.02606680f, 0.03785137f, -0.04153501f, 0.04543034f, 0.04499524f, 
    0.04509086f, -0.04240716f, 0.05894160f, -0.02341782f, -0.06721997f, -0.03241251f, -0.05626744f, 0.03757328f, 
    -0.02996926f, 0.03464991f, 0.02477315f, 0.01420248f, 0.06402832f, -0.01918477f, -0.07628161f, 0.02630561f, 
    0.02872708f, -0.01189155f, -0.06874976f, -0.06054000f, -0.06828447f, 0.00563942f, 0.05064842f, -0.04277755f, 
    -0.03334646f, -0.06428342f, 0.02073991f, -0.05256292f, -0.05348334f, -0.04420232f, 0.00450419f, -0.04071627f, 
    0.00110956f, 0.01965858f, -0.07175359f, -0.05880326f, 0.02227433f, 0.03617905f, -0.02975080f, 0.00210343f, 
    0.01142238f, -0.03899594f, 0.03715704f, 0.05647918f, -0.02632258f, 0.05170020f, 0.04075284f, 0.01748585f, 
    0.05443509f, -0.05789724f, -0.03238637f, 0.05435264f, -0.07324005f, 0.01640750f, -0.03996228f, -0.01149685f, 
    0.00812371f, 0.02294167f, -0.04025149f, -0.06059429f, -0.05033776f, 0.04666690f, -0.06665097f, 0.01783259f, 
    0.03548476f, 0.01892764f, -0.00855372f, 0.04208220f, -0.01762037f, 0.04493934f, 0.05453887f, -0.07774971f, 
    -0.04404110f, -0.02679765f, -0.06522959f, -0.07334702f, 0.02363659f, -0.02695519f, 0.03111408f, 0.03681374f, 
    -0.02362704f, -0.02717620f, -0.01714576f, 0.00063002f, 0.03837502f, 0.02617336f, 0.00182319f, 0.00590151f, 
    0.03942034f, -0.07077380f, 0.03446190f, 0.02552646f, 0.02055143f, -0.02595773f, 0.02009996f, -0.04513578f, 
    -0.02246403f, -0.00500803f, 0.00010859f, -0.06165927f, 0.00382986f, -0.05301281f, -0.00614545f, 0.05401018f, 
    0.01551385f, -0.03208920f, 0.05359548f, -0.06268512f, 0.05484483f, -0.05883486f, 0.02111220f, -0.06865804f, 
    -0.05615392f, -0.02109830f, -0.05927902f, 0.03341226f, -0.04280793f, -0.01171948f, -0.00295599f, 0.00492822f, 
    -0.02890575f, -0.03829826f, -0.03320954f, -0.05169482f, -0.03185819f, -0.05516467f, 0.00208002f, -0.05029995f, 
    0.05239216f, -0.05930758f, -0.05633121f, -0.00469701f, -0.00229231f, -0.01049062f, -0.06084248f, 0.03467713f, 
    -0.06184602f, -0.07203712f, 0.01159302f, -0.04348681f, -0.05541603f, -0.06445638f, -0.00586675f, -0.04906130f, 
    -0.00755033f, -0.06828287f, 0.04907706f, 0.02615124f, -0.02902642f, -0.06467285f, -0.01283953f, -0.02671327f, 
    0.00907337f, -0.04345141f, 0.04698680f, 0.00637598f, 0.00658325f, 0.00888086f, 0.04696174f, 0.05712955f, 
    0.01439020f, -0.07331827f, 0.02861083f, 0.00563151f, 0.05420560f, 0.01023675f, 0.05973684f, -0.07420111f, 
    0.02691053f, -0.06490120f, -0.02944055f, 0.01653680f, -0.03534228f, 0.02761625f, 0.05945208f, -0.06317431f, 
    0.06194741f, -0.04127628f, -0.05848790f, 0.01014556f, 0.04176059f, 0.05831115f, -0.02960404f, 0.05066564f, 
    -0.06289036f, -0.06004835f, -0.04312050f, -0.02475579f, -0.02604528f, -0.05457175f, -0.02619054f, 0.02340910f, 
    0.06159981f, 0.03963065f, 0.01239830f, -0.00526082f, -0.04565898f, 0.03540071f, 0.02536721f, -0.08041417f, 
    0.07632347f, 0.14255016f, -0.00861281f, 0.02572049f, -0.06445497f, 0.01678082f, 0.19561115f, 0.09445790f, 
    -0.05506772f, -0.06509387f, 0.07086266f, -0.05442348f, 0.20176110f, -0.12072890f, 0.06027266f, 0.24013658f, 
    0.14029332f, 0.08625355f, -0.16080911f, 0.03017373f, 0.00044302f, -0.02126068f, 0.03959587f, 0.01783444f, 
    -0.04003680f, 0.05671621f, 0.01738572f, -0.00700329f, -0.02588244f, -0.05274249f, -0.02267219f, 0.02069291f, 
    0.05473955f, -0.00498049f, 0.11558966f, 0.03919766f, -0.21608119f, 0.13044223f, -0.08151163f, 0.17582126f, 
    0.14586215f, 0.15665154f, 0.07084805f, 0.03182306f, -0.05797993f, -0.00431761f, -0.07029445f, 0.10320004f, 
    0.24294916f, -0.38484213f, -0.19513611f, 0.12155797f, 0.06468923f, -0.05987556f, 0.16114931f, -0.08205164f, 
    -0.00059078f, -0.02547643f, 0.05648255f, 0.04177649f, 0.23941538f, 0.35860142f, 0.02070399f, 0.06018084f, 
    -0.00185475f, -0.03369864f, 0.01208914f, 0.06956583f, 0.09714355f, -0.06152011f, -0.08481853f, 0.04951664f, 
    -0.22026013f, 0.18781769f, 0.00608009f, -0.11101198f, -0.09754045f, 0.05001425f, -0.02508198f, 0.04539159f, 
    0.11193231f, -0.02500191f, -0.07018358f, 0.02877731f, 0.18804149f, -0.20881587f, 0.25560156f, -0.01070995f, 
    0.09054185f, -0.04906850f, -0.09549227f, 0.03862235f, -0.09796234f, -0.06421150f, -0.05483650f, -0.02908520f, 
    -0.15539917f, 0.10570240f, 0.01422336f, -0.02578874f, -0.12051357f, -0.00007031f, 0.09990291f, -0.00798697f, 
    0.03541444f, 0.03194041f, -0.19044088f, -0.07260372f, 0.07312295f, 0.20093054f, 0.01655504f, 0.05294399f, 
    0.00574315f, -0.04367492f, 0.01838262f, -0.05094157f, -0.12586313f, -0.09919337f, -0.14383152f, -0.07847730f, 
    0.18240614f, -0.21259962f, 0.13385914f, 0.01583649f, -0.15519713f, 0.05019313f, 0.05182005f, -0.08210186f, 
    -0.00787833f, 0.07081988f, -0.01291016f, 0.00844415f, 0.00190174f, -0.09745741f, -0.09147040f, -0.05265740f, 
    -0.07563466f, -0.13325649f, 0.07971753f, 0.02480712f, 0.08763004f, 0.05704447f, 0.04052344f, -0.00842527f, 
    0.01106102f, 0.12144502f, -0.36671576f, -0.25823268f, -0.08828035f, 0.00695061f, -0.11995541f, 0.12963107f, 
    0.07113304f, 0.06939988f, -0.11171503f, -0.14237365f, 0.01147056f, 0.03823990f, -0.00103011f, 0.23053557f, 
    0.05575800f, -0.00565149f, 0.04981311f, 0.01664991f, -0.13268007f, -0.08119825f, -0.00334236f, 0.07278600f, 
    0.09217279f, -0.10528265f, 0.00046885f, -0.13127926f, 0.01024799f, -0.11016195f, 0.05338782f, -0.05910720f, 
    0.04420663f, 0.08543757f, 0.07145023f, 0.07720924f, 0.02972084f, -0.13089626f, -0.12698942f, 0.13288061f, 
    -0.11151314f, 0.05869186f, 0.03709495f, -0.15514891f, -0.06806959f, -0.13853911f, -0.15611961f, -0.00825101f, 
    -0.07042712f, -0.04957153f, 0.21555424f, 0.13841598f, -0.05573731f, -0.02642056f, 0.07968282f, 0.06665597f, 
    0.01214198f, 0.09535407f, -0.02873046f, -0.01437011f, 0.28603247f, 0.19821820f, 0.04290069f, 0.38827270f, 
    0.16968442f, 0.04470968f, -0.11133651f, 0.00831344f, -0.01515407f, 0.02467921f, 0.06008544f, 0.08765378f, 
    -0.08091474f, 0.26805589f, -0.09512153f, -0.09663141f, -0.12183300f, -0.07428858f, -0.04516671f, 0.01481888f, 
    -0.02535977f, 0.00232540f, 0.05589341f, 0.08075827f, -0.28066859f, -0.05477072f, -0.08794772f, 0.26891208f, 
    -0.01726257f, 0.07758025f, 0.07754076f, -0.05848996f, 0.06203026f, 0.01544520f, 0.04733901f, 0.08022023f, 
    0.57720840f, -0.14059439f, 0.20466644f, 0.19503656f, -0.10605893f, -0.20807014f, -0.06040707f, -0.13246182f, 
    0.10068473f, 0.08673782f, 0.06047096f, 0.12460985f, 0.28082106f, 0.27408800f, 0.13866693f, 0.26392993f, 
    -0.01824238f, 0.00381730f, 0.01793861f, 0.02948805f, 0.05431253f, 0.08280005f, -0.10952033f, 0.00175266f, 
    0.11194520f, 0.32574052f, -0.23345146f, -0.40394825f, -0.09401949f, -0.03106209f, 0.05096841f, -0.06226536f, 
    0.09773020f, 0.04642181f, 0.05493063f, -0.00236410f, -0.08589437f, -0.00515192f, 0.25102285f, 0.09137238f, 
    0.03745345f, -0.04819299f, -0.10316476f, 0.05228742f, -0.07831522f, -0.04899120f, 0.08893465f, -0.04044907f, 
    0.07129008f, 0.08151098f, 0.06561762f, -0.19672540f, 0.01139739f, 0.12166397f, 0.10718829f, 0.10893313f, 
    -0.02529951f, -0.09379954f, 0.06744615f, 0.04951487f, -0.08350312f, 0.11263197f, -0.07877414f, -0.01726468f, 
    0.14296325f, -0.14072594f, 0.15702391f, 0.01907763f, -0.22706015f, -0.00388482f, -0.09216205f, 0.01747436f, 
    -0.02418163f, 0.23266424f, -0.14596131f, -0.23971343f, -0.08397215f, 0.04279081f, 0.05867218f, -0.06921110f, 
    -0.00740836f, 0.15555462f, -0.02164537f, 0.14663994f, 0.18265405f, 0.09315096f, -0.10577764f, -0.18836591f, 
    -0.09981696f, -0.10018252f, 0.09250122f, -0.13046414f, -0.16336134f, -0.05034828f, -0.08258110f, -0.02767547f, 
    -0.19549014f, 0.12402276f, 0.18291546f, -0.14208858f, 0.03392088f, 0.04754089f, -0.13337895f, 0.15524092f, 
    -0.04132784f, 0.02947276f, 0.09990143f, -0.10013998f, -0.10656080f, -0.12375258f, 0.07246661f, 0.14392889f, 
    -0.05610579f, -0.07358705f, 0.04455601f, 0.05443639f, -0.07013124f, 0.05366312f, 0.07105781f, -0.01627425f, 
    -0.23265371f, 0.04366823f, 0.43147078f, -0.10456421f, -0.16681597f, -0.08163746f, -0.00127344f, -0.11043530f, 
    -0.09349941f, 0.03277282f, 0.15141143f, 0.13949524f, 0.32379287f, -0.12768283f, -0.02628594f, 0.02396129f, 
    0.10547480f, 0.05648930f, -0.07632434f, -0.04856047f, -0.08655265f, -0.03089303f, 0.04072919f, 0.07078894f, 
    -0.06697322f, -0.03078814f, -0.00020453f, -0.03002044f, -0.01945360f, -0.06431925f, -0.05677624f, -0.01415724f, 
    0.00842615f, -0.04545290f, 0.00533543f, 0.02444847f, -0.04069333f, -0.06581268f, -0.03328642f, 0.04371883f, 
    -0.01842136f, 0.02556101f, 0.04015321f, -0.05948496f, -0.04515170f, -0.02662460f, -0.01535801f, 0.05581961f, 
    -0.06052742f, -0.02030434f, 0.03703915f, -0.06751907f, -0.00574602f, 0.03600916f, -0.03516391f, 0.01983066f, 
    -0.05718059f, -0.04029029f, -0.00149706f, -0.02200220f, 0.06142496f, 0.05962878f, 0.00502536f, -0.04059060f, 
    -0.07721397f, -0.00561252f, 0.01214625f, -0.07179262f, -0.01003620f, -0.07721102f, -0.03948715f, -0.02357861f, 
    0.05183962f, 0.06484919f, -0.05347535f, -0.01055802f, -0.07571414f, 0.00022073f, 0.00671414f, 0.00035260f, 
    -0.01440471f, -0.03299014f, 0.03014787f, -0.00338014f, 0.03908638f, 0.00896910f, 0.00040461f, 0.06008922f, 
    -0.01961428f, -0.04419889f, 0.04251184f, -0.01146001f, -0.04907633f, 0.03762099f, -0.02362358f, 0.04448747f, 
    0.05663832f, -0.06408006f, 0.06506966f, 0.01014402f, -0.01195115f, -0.05123640f, -0.05986567f, -0.07562741f, 
    -0.06319553f, -0.01959327f, -0.04627175f, 0.05733103f, 0.01807987f, 0.03713567f, 0.00654003f, 0.00335174f, 
    0.04683311f, -0.06443773f, 0.06612865f, 0.00042211f, -0.04090136f, -0.07775913f, -0.03569120f, -0.02437199f, 
    -0.02097634f, 0.06217521f, 0.00613789f, 0.01109781f, -0.01146393f, -0.00565239f, 0.06409907f, -0.07624082f, 
    0.04919256f, 0.02836476f, -0.04111085f, 0.06009242f, -0.03278740f, -0.06818056f, 0.01196573f, 0.03884993f, 
    0.00415160f, -0.05251581f, -0.06501074f, 0.02945815f, 0.03108711f, 0.06408766f, 0.01576224f, -0.03776886f, 
    0.00529270f, 0.00534097f, -0.07807833f, -0.02033114f, 0.00102914f, 0.00994488f, 0.02907106f, -0.06226676f, 
    -0.06389903f, -0.03865913f, -0.04538293f, -0.03317691f, -0.00067422f, 0.02762866f, 0.05739319f, -0.01554331f, 
    -0.05762660f, 0.00454414f, -0.01244023f, -0.01459826f, -0.05225231f, 0.04205678f, -0.06355540f, 0.02035286f, 
    0.00039576f, 0.03014310f, -0.03919473f, 0.05561528f, 0.03019487f, 0.02188380f, -0.03807482f, -0.00088245f, 
    -0.05227760f, 0.01269876f, -0.05388921f, 0.05649850f, -0.02853864f, -0.01703565f, 0.05404780f, -0.06027249f, 
    -0.00537164f, 0.05671503f, -0.05388740f, -0.07254091f, 0.00234353f, 0.06150405f, -0.00265950f, 0.03219225f, 
    0.03306977f, -0.03290728f, -0.04913166f, -0.05259944f, -0.03740951f, -0.05162242f, 0.02091600f, -0.00789444f, 
    0.02344165f, 0.02997155f, 0.05561626f, 0.02855498f, -0.02776600f, -0.05400046f, 0.03452240f, -0.05687717f, 
    0.04855516f, 0.06576753f, -0.06656449f, -0.06967716f, -0.07770299f, -0.05669466f, 0.04796014f, -0.01485781f, 
    -0.05410123f, 0.05226218f, -0.00347222f, -0.23886105f, -0.00499397f, 0.04433632f, -0.06911382f, -0.02692547f, 
    -0.20656703f, -0.12431533f, -0.19485565f, -0.12007148f, 0.05960147f, 0.07320376f, -0.16026242f, 0.29148218f, 
    0.04192811f, 0.08903385f, 0.22700040f, -0.06668039f, 0.03020214f, 0.09650733f, 0.11386321f, 0.07344235f, 
    -0.02580534f, 0.11572445f, -0.04174550f, -0.08159893f, -0.04765004f, -0.04261369f, -0.03894463f, -0.08174054f, 
    0.01324867f, -0.00432799f, -0.07028141f, 0.06511264f, 0.25563312f, 0.16543336f, -0.01008611f, 0.00669979f, 
    0.03173140f, 0.13628910f, 0.24043392f, 0.05607950f, -0.01885897f, -0.03990735f, 0.01383900f, -0.04777588f, 
    0.01138034f, -0.05662550f, -0.33778694f, 0.31851235f, -0.10088535f, -0.12186568f, 0.07983170f, -0.05628810f, 
    -0.18036713f, -0.01045747f, -0.05537256f, 0.15620448f, -0.04776999f, -0.10016911f, 0.00156867f, -0.14058100f, 
    -0.00617318f, 0.09966918f, 0.05768418f, 0.07841886f, 0.00835147f, 0.09494895f, 0.00499837f, 0.07419219f, 
    0.17732337f, 0.09651906f, 0.07219005f, -0.07432891f, 0.01719672f, -0.03619250f, -0.06658383f, -0.10661653f, 
    0.05037599f, -0.12115498f, 0.14392480f, 0.05628263f, 0.24301374f, -0.15652516f, -0.17854527f, -0.04077791f, 
    -0.01566494f, -0.01827599f, -0.00854161f, -0.00276845f, -0.06102397f, 0.06245420f, 0.08801586f, 0.05564239f, 
    0.16332676f, -0.28225628f, 0.22197506f, -0.00333542f, 0.04775506f, 0.10190096f, 0.00490518f, 0.12680724f, 
    -0.00615978f, -0.11164705f, 0.05445147f, 0.04942294f, -0.15373306f, 0.02170771f, -0.10017067f, 0.20300449f, 
    -0.14333625f, 0.08363887f, 0.16117662f, 0.04345354f, -0.02020749f, 0.11538706f, 0.10865878f, 0.02102106f, 
    0.49107036f, -0.09785733f, -0.25758609f, 0.01086067f, 0.01079107f, -0.06632634f, 0.15317611f, -0.05373937f, 
    0.17824452f, 0.16238509f, 0.16614188f, 0.12288663f, 0.26879930f, 0.30005321f, 0.09330720f, 0.15189645f, 
    0.05832393f, -0.01819447f, -0.10026956f, -0.13882774f, -0.08876541f, -0.19219735f, -0.00729075f, -0.11383913f, 
    0.18776478f, -0.25915715f, 0.51725894f, -0.04722063f, 0.15246801f, -0.13292170f, 0.00343745f, 0.02896794f, 
    0.04157479f, -0.19973066f, 0.12073914f, 0.03598420f, 0.08573417f, 0.11629380f, -0.01539813f, -0.29925510f, 
    -0.02258424f, -0.07287379f, -0.12613487f, -0.19707921f, -0.08025707f, -0.10690526f, -0.04077554f, -0.12827985f, 
    0.03554580f, -0.17670496f, 0.31822744f, 0.07806770f, -0.07768995f, -0.06387658f, 0.09683777f, 0.01545367f, 
    -0.19373430f, 0.06778731f, 0.10888876f, 0.04965399f, -0.06486361f, 0.27856761f, 0.17634636f, -0.11678705f, 
    -0.02867329f, 0.29810971f, 0.04094665f, -0.04341976f, 0.05197633f, -0.02615710f, -0.11538742f, 0.07200893f, 
    0.07175503f, -0.04991547f, 0.00600676f, 0.03593006f, -0.01535776f, 0.20013741f, 0.00355519f, -0.07380461f, 
    -0.12830347f, -0.03900329f, -0.11095131f, -0.09227340f, -0.14778896f, 0.14482431f, -0.04632634f, 0.23624459f, 
    -0.04462577f, -0.03843763f, 0.00272700f, -0.05882985f, -0.03966306f, 0.02874613f, 0.11491803f, 0.08566821f, 
    0.07261896f, 0.01401064f, -0.09956417f, -0.03998885f, 0.05378526f, 0.01391022f, 0.02038531f, -0.05010826f, 
    -0.14847106f, -0.07658823f, 0.04445389f, 0.03722795f, 0.14543746f, 0.18855268f, -0.06755697f, 0.00501389f, 
    0.12119493f, -0.04362321f, 0.17771386f, -0.09949747f, -0.07039583f, -0.09582280f, -0.00129551f, -0.03409310f, 
    0.13794693f, -0.05228027f, -0.22415452f, 0.16285826f, -0.06680141f, 0.10308129f, 0.17278181f, 0.14733018f, 
    -0.02704790f, -0.02010730f, -0.05258022f, -0.08481871f, 0.15109606f, 0.07184662f, 0.03566983f, -0.04833758f, 
    -0.02259434f, 0.01425932f, -0.07399338f, -0.13814637f, 0.20357744f, 0.07800272f, -0.09253467f, 0.00385234f, 
    0.11022639f, 0.13589834f, 0.09141284f, -0.17081872f, -0.04046861f, 0.04939626f, -0.06501947f, 0.09071445f, 
    -0.02428862f, -0.05152547f, -0.09963863f, -0.06978867f, 0.17501941f, 0.15006842f, 0.08778013f, 0.13572466f, 
    -0.13775745f, 0.04897510f, -0.06427131f, -0.04034599f, -0.18420222f, -0.19168353f, -0.12581086f, -0.09858684f, 
    -0.02753126f, -0.06132802f, 0.04413106f, 0.00141545f, 0.15484323f, 0.16147572f, -0.09331043f, -0.01578882f, 
    0.03682869f, -0.05591016f, -0.06525058f, 0.01664566f, 0.02848643f, 0.00293005f, 0.07064895f, 0.06273440f, 
    -0.07976469f, 0.07087069f, 0.09403136f, 0.05356572f, -0.08105503f, -0.09367812f, 0.00457283f, -0.05716864f, 
    0.41039741f, -0.08576764f, -0.08782160f, -0.08517375f, -0.06747326f, -0.04908199f, -0.04113245f, -0.18556389f, 
    -0.00801749f, 0.08998381f, -0.03493728f, 0.11852024f, 0.09349775f, 0.11753117f, 0.02454170f, -0.08491945f, 
    0.04295307f, 0.06314874f, 0.07379836f, 0.07891656f, -0.01679343f, 0.08961651f, 0.01229831f, 0.00770585f, 
    -0.41209653f, -0.12480240f, 0.34246644f, 0.16633941f, 0.01957737f, 0.20080817f, -0.16229114f, 0.19959877f, 
    0.00457964f, 0.07594689f, -0.06687929f, -0.00412130f, 0.16620651f, 0.09671866f, -0.00102300f, 0.15009388f, 
    0.03954484f, -0.03050842f, -0.11546224f, -0.00548543f, -0.02772500f, -0.06316178f, -0.16453142f, -0.10322698f, 
    -0.22557470f, 0.06559033f, 0.14016172f, 0.05257373f, 0.02030915f, 0.00204400f, 0.01235512f, -0.02434050f, 
    -0.18694656f, -0.07624668f, 0.09406452f, 0.07503805f, 0.19650775f, 0.05419049f, -0.05029302f, 0.04683178f, 
    0.00973889f, 0.08115035f, 0.06896032f, 0.06846987f, -0.04185640f, -0.11664834f, -0.15020192f, -0.08460311f, 
    -0.06709149f, 0.01570230f, -0.05655815f, 0.05732718f, 0.03712076f, -0.04557798f, -0.07935865f, -0.00811663f, 
    0.02546163f, -0.00241243f, -0.04548061f, 0.06214461f, -0.05313467f, -0.05143666f, 0.04275349f, -0.06987993f, 
    -0.07605986f, -0.05371089f, -0.00382583f, 0.02877505f, -0.02429295f, -0.01115822f, -0.04030536f, 0.04958795f, 
    0.06000056f, 0.02304291f, 0.01466629f, -0.05970746f, 0.00057889f, 0.00272804f, -0.06478930f, 0.01099196f, 
    0.03423527f, 0.02539889f, -0.03216072f, -0.05770069f, -0.07922045f, -0.04044983f, -0.01251672f, -0.06960120f, 
    -0.00842942f, 0.03836763f, 0.01227047f, -0.06469604f, -0.02958208f, 0.00879483f, 0.05825514f, -0.07390469f, 
    -0.04686037f, 0.06162396f, -0.06046191f, -0.04256545f, -0.06213031f, -0.07544975f, 0.05070578f, -0.05275561f, 
    -0.00354934f, -0.05706967f, 0.04810077f, 0.02912778f, 0.01189754f, -0.00231510f, 0.06214301f, -0.01743055f, 
    0.00598791f, -0.00716572f, 0.01319191f, -0.02868381f, -0.06540857f, -0.06088536f, 0.00273459f, -0.01267347f, 
    0.05856069f, 0.04723254f, -0.02733087f, -0.06543552f, 0.04692503f, 0.00232379f, -0.03006339f, -0.07457885f, 
    0.05159396f, -0.04843391f, 0.02443866f, -0.03082814f, -0.04314116f, 0.03798252f, -0.03705123f, 0.03851965f, 
    -0.02059055f, 0.01815379f, -0.03016480f, 0.00180907f, -0.07076529f, -0.05298974f, 0.02483371f, -0.06420451f, 
    0.06279011f, -0.04527330f, -0.01946568f, 0.05634316f, -0.06325039f, -0.00440998f, 0.05081467f, -0.01191155f, 
    0.02339762f, 0.01305351f, -0.02462434f, 0.04926658f, -0.04263765f, 0.02300746f, 0.02283270f, -0.03885764f, 
    0.04420748f, -0.01555654f, 0.00766757f, -0.05143180f, 0.00538100f, 0.04856833f, -0.00968853f, 0.02226028f, 
    0.02920735f, -0.03210072f, -0.02319488f, 0.00841686f, -0.04838035f, -0.00060048f, 0.02716474f, 0.03494506f, 
    -0.02713527f, -0.01297609f, -0.00958022f, 0.00118805f, -0.01178521f, 0.00348491f, -0.03533799f, -0.06397169f, 
    0.01010799f, 0.00118253f, -0.07460459f, -0.04799072f, -0.05126539f, 0.02668888f, -0.02767378f, 0.06219174f, 
    -0.03253821f, -0.03965010f, 0.00897944f, -0.00347407f, -0.03766926f, -0.04551904f, -0.05381713f, 0.03301324f, 
    -0.07114394f, 0.05610023f, -0.05058198f, 0.00791830f, -0.05853475f, -0.06634671f, -0.00160735f, 0.06526233f, 
    -0.04561196f, -0.08050124f, 0.04756581f, 0.02748262f, -0.07664520f, -0.03986901f, 0.02564807f, -0.06189773f, 
    -0.03352877f, -0.07032377f, -0.03245842f, 0.00021119f, -0.07218567f, -0.01948033f, 0.02979989f, 0.00325629f, 
    0.05805960f, 0.05881939f, -0.03115147f, 0.02784199f, 0.04026773f, -0.00414595f, -0.03227491f, 0.03886147f, 
    -0.06863613f, -0.03776482f, -0.00661769f, 0.00357173f, 0.04245794f, -0.06181110f, 0.02815598f, 0.04406607f, 
    -0.21619973f, -0.14241396f, -0.00550727f, 0.29648295f, 0.25385287f, 0.05878620f, 0.06176534f, -0.04166715f, 
    0.00138864f, 0.01349731f, -0.03247482f, 0.04425948f, 0.00382103f, -0.12146969f, 0.36554050f, -0.27221411f, 
    -0.01654341f, -0.02301007f, -0.00780168f, 0.07329075f, 0.00733571f, -0.00242775f, 0.12240463f, -0.12235449f, 
    -0.03748399f, -0.01048589f, -0.00496187f, -0.18216455f, -0.06262355f, -0.09385698f, 0.00186087f, -0.11196514f, 
    0.10481999f, -0.00596554f, 0.17668922f, -0.00235381f, -0.31401187f, -0.26791549f, -0.00792493f, 0.11870854f, 
    -0.01233984f, -0.11758904f, -0.07538851f, 0.00589160f, -0.04386193f, -0.13389860f, 0.01827753f, -0.10513351f, 
    -0.08436332f, 0.29762915f, 0.40797618f, -0.10720997f, -0.06295201f, -0.12527435f, 0.02421661f, -0.02698321f, 
    0.01267264f, 0.08250355f, 0.01588586f, 0.07580534f, 0.04627925f, 0.09374326f, 0.13882540f, 0.20786354f, 
    -0.00930410f, 0.04787762f, 0.08903539f, 0.09132958f, 0.05195657f, 0.06403157f, 0.07633418f, 0.13717480f, 
    0.23185082f, 0.07395758f, -0.30674547f, 0.03306562f, -0.01880923f, -0.02389522f, -0.00129117f, -0.05122279f, 
    0.03052613f, -0.10272592f, -0.01752178f, 0.02937140f, -0.21458103f, 0.10053180f, 0.06656315f, 0.10236505f, 
    0.09345391f, -0.07439753f, 0.03778575f, 0.19124348f, 0.04618927f, 0.02783961f, 0.20185651f, -0.03547509f, 
    0.03930099f, 0.41114622f, -0.09111761f, 0.07390806f, -0.02544239f, -0.05162698f, -0.01061944f, -0.07454654f, 
    0.10106780f, 0.09190611f, 0.10608873f, 0.09912358f, 0.12908261f, -0.15894330f, -0.03798318f, -0.26280609f, 
    -0.00394834f, -0.03035718f, -0.07979143f, 0.03682524f, 0.05875995f, -0.09407478f, 0.07346778f, 0.16134538f, 
    0.08987969f, 0.09426765f, -0.01237849f, -0.04628790f, -0.13604462f, 0.02344435f, -0.01145926f, 0.15897964f, 
    0.14862904f, -0.04314626f, 0.16018078f, -0.05562354f, 0.08583215f, -0.00155214f, 0.05478298f, -0.16958708f, 
    -0.12414393f, -0.08583455f, -0.04015761f, 0.00333661f, -0.01266673f, -0.03262522f, -0.11607808f, 0.00788431f, 
    -0.20802455f, 0.37205794f, 0.12944670f, -0.05795308f, 0.00597330f, -0.05391984f, -0.12670271f, -0.07650022f, 
    -0.04364645f, 0.10080715f, 0.16186409f, 0.11410026f, -0.20750883f, -0.25683671f, 0.07553814f, 0.02596324f, 
    -0.01286326f, 0.04960152f, 0.06013386f, 0.05058403f, 0.05753760f, -0.04325237f, -0.06186361f, -0.03265648f, 
    -0.19973372f, 0.25912514f, 0.07498217f, -0.21848261f, -0.05830394f, -0.00103576f, -0.14456198f, -0.01640227f, 
    0.23831801f, 0.12094348f, -0.08039829f, 0.09653310f, -0.00804379f, -0.10951731f, -0.20656015f, 0.09642959f, 
    0.16995870f, -0.10518613f, -0.00504954f, 0.06065750f, -0.06728068f, -0.05735052f, 0.08297192f, 0.05328939f, 
    0.26703006f, 0.11700018f, 0.08483995f, -0.08761076f, -0.10997106f, 0.04870892f, 0.24026957f, -0.01115926f, 
    -0.12408295f, 0.00655866f, -0.06155536f, -0.16325541f, 0.30777568f, 0.07581530f, -0.22954670f, 0.09795661f, 
    -0.02163173f, -0.05844234f, -0.01761562f, -0.10433295f, 0.02863175f, -0.12853555f, 0.00035206f, 0.15620853f, 
    -0.14161821f, -0.06034132f, -0.00339488f, 0.01677432f, -0.00989812f, 0.02929963f, -0.00495008f, -0.06420876f, 
    -0.04344906f, 0.04463744f, -0.02813209f, -0.09070082f, 0.10983402f, 0.22823501f, -0.09137930f, 0.00693001f, 
    0.04154773f, 0.05920300f, -0.10539105f, 0.04584919f, -0.05815654f, -0.09834204f, 0.10297571f, 0.09326813f, 
    0.37211761f, -0.35432500f, -0.18503018f, 0.22519936f, -0.04058355f, -0.02570822f, 0.01693619f, 0.07205681f, 
    -0.10737232f, -0.12548932f, -0.01172326f, 0.03563971f, 0.13063452f, -0.06440032f, -0.01200907f, 0.00108731f, 
    0.01186320f, 0.01416385f, -0.01413309f, -0.08607963f, 0.00955753f, -0.00450195f, 0.00240665f, 0.02472120f, 
    -0.26110795f, 0.02704998f, -0.05780966f, -0.23170258f, 0.06447253f, -0.08298959f, 0.03132128f, -0.00593522f, 
    0.11379626f, 0.04727594f, 0.01960585f, 0.04036616f, 0.16244964f, -0.09825736f, -0.06286217f, 0.02795660f, 
    -0.07739509f, 0.16682413f, 0.08377976f, 0.10144377f, -0.06527392f, 0.02109816f, -0.02771458f, 0.01133656f, 
    -0.00345751f, -0.15788876f, 0.02204823f, -0.02909351f, 0.00213581f, 0.02956207f, -0.03897580f, 0.00107638f, 
    -0.05443922f, -0.04398452f, 0.07225858f, -0.13396437f, -0.09659912f, -0.07160584f, -0.01748230f, 0.03456192f, 
    -0.01039204f, -0.03353513f, -0.07168780f, -0.05780764f, -0.01257337f, 0.19340762f, -0.00959728f, 0.11544923f, 
    -0.21949780f, 0.09726388f, 0.01911298f, -0.14677592f, 0.02610559f, 0.05473487f, -0.08337891f, -0.09613884f, 
    -0.03909620f, -0.01606871f, -0.07145704f, 0.10573694f, -0.21298151f, -0.18055166f, -0.10087249f, 0.01068531f, 
    -0.11413032f, -0.08756050f, -0.04652685f, -0.08213079f, -0.01457678f, 0.07059534f, -0.08576714f, 0.00418633f, 
    -0.23113644f, -0.06082915f, -0.15067238f, -0.17123124f, 0.05908021f, -0.10188245f, 0.02944898f, -0.05645024f, 
    -0.05076861f, 0.02351164f, -0.02149165f, -0.07785044f, 0.26912999f, 0.14164260f, 0.11683561f, 0.01698139f, 
    0.21334071f, 0.15347631f, 0.20085615f, 0.10240936f, -0.08746392f, -0.04439335f, 0.03235956f, 0.00619374f, 
    -0.40893224f, -0.00865013f, -0.04418074f, -0.07008649f, -0.11681023f, -0.02863549f, -0.10029653f, 0.02744064f, 
    -0.18154547f, 0.04326244f, -0.01987857f, 0.03553120f, 0.21553808f, 0.15014377f, 0.19868112f, -0.07530536f, 
    0.05398218f, -0.00937033f, -0.12388157f, 0.03872819f, 0.00183811f, 0.03939208f, -0.05467515f, -0.06129381f, 
    -0.02594174f, -0.06559980f, -0.02016866f, -0.05814804f, -0.09190161f, 0.03043832f, -0.02564380f, -0.02461334f, 
    0.04105235f, -0.07127715f, -0.04536319f, -0.03961048f, -0.05309610f, -0.07507540f, -0.09047868f, 0.06299972f, 
    0.03262236f, 0.02839187f, -0.03115217f, -0.05684848f, -0.12905306f, 0.07275955f, -0.09707662f, 0.01588359f, 
    -0.02048883f, 0.04949793f, -0.05285180f, 0.00256826f, 0.04778719f, 0.04935425f, -0.00081652f, -0.01420828f, 
    0.02189323f, 0.09256924f, 0.01118416f, 0.04392533f, -0.10621947f, 0.02524224f, -0.04175298f, -0.03079860f, 
    -0.00645791f, -0.05303155f, -0.06506412f, -0.00449013f, -0.01487701f, -0.05231434f, -0.10575948f, -0.12295743f, 
    0.06375831f, -0.04252236f, -0.06392982f, -0.05634432f, -0.10098486f, -0.10707240f, 0.00581549f, -0.04629784f, 
    -0.08851600f, 0.01928400f, 0.01282354f, 0.04214163f, -0.01906845f, 0.04745074f, -0.09387422f, -0.08616144f, 
    0.02676008f, -0.03041738f, 0.00421193f, 0.05115189f, 0.00195279f, -0.11995975f, -0.05038024f, -0.11137913f, 
    -0.06670451f, 0.00008825f, -0.06864196f, -0.07657813f, -0.06586103f, -0.08251644f, 0.04549981f, -0.03006440f, 
    0.04470353f, -0.02396392f, -0.01196976f, -0.06308077f, 0.00149288f, 0.02674146f, 0.04354303f, -0.06435365f, 
    -0.01875631f, -0.07847317f, -0.03680365f, -0.06793694f, -0.05016862f, 0.00538026f, 0.01026453f, -0.06737705f, 
    -0.03563554f, -0.04047986f, 0.01844375f, 0.01676132f, -0.01909088f, -0.00161890f, -0.08808083f, -0.07261760f, 
    0.00765763f, -0.02994920f, -0.00404843f, -0.02330588f, 0.03938708f, 0.07827858f, 0.05698676f, -0.01919521f, 
    0.06765602f, 0.05445710f, -0.03680721f, 0.07471649f, 0.04561027f, 0.07338186f, 0.01587081f, 0.06659113f, 
    -0.02353887f, -0.02623091f, -0.04742409f, -0.02175284f, -0.01764471f, 0.03626721f, 0.02610627f, -0.00806482f, 
    0.01264384f, 0.02020864f, -0.02841136f, -0.07894619f, -0.00147861f, 0.07901570f, 0.01128660f, -0.02027091f, 
    0.06988469f, 0.06412484f, 0.04740794f, -0.01846676f, -0.03935593f, 0.00600799f, 0.04409170f, -0.04708099f, 
    -0.05650562f, -0.02564485f, 0.05492659f, 0.08342668f, 0.00335337f, -0.05784569f, 0.03735545f, -0.04275305f, 
    -0.07522158f, -0.08338492f, -0.00443960f, 0.04639292f, 0.04223442f, -0.01521526f, 0.07086245f, 0.08348809f, 
    -0.03901628f, -0.09691989f, -0.06940476f, -0.05357699f, -0.11502113f, -0.08156831f, 0.01116902f, -0.04522559f, 
    0.03573609f, -0.01416922f, -0.08730654f, -0.06295658f, -0.10405371f, -0.09402604f, -0.07435820f, -0.03563131f, 
    -0.02882582f, -0.04225162f, -0.05852199f, -0.08612529f, 0.00508646f, -0.00757058f, -0.01237592f, 0.00749877f, 
    -0.01353133f, 0.04867506f, -0.00391769f, -0.05848404f, -0.00100684f, -0.07900853f, -0.00681096f, 0.04904668f, 
    -0.07963135f, 0.01672180f, -0.24144906f, -0.20984551f, -0.02717871f, -0.11383730f, -0.20060699f, 0.01870736f, 
    -0.09947558f, -0.19878443f, -0.16447042f, -0.33854762f, -0.05894606f, -0.09719964f, 0.00820080f, -0.06233665f, 
    0.05901949f, -0.03551299f, -0.04251603f, 0.10486192f, 0.05130211f, 0.23016371f, -0.06204368f, 0.31928465f, 
    -0.20824143f, -0.23125826f, -0.18240653f, -0.04427904f, -0.03036029f, -0.16088274f, 0.10679377f, -0.02786773f, 
    0.16725695f, 0.22342852f, 0.07113613f, 0.24582145f, -0.03426475f, -0.04065419f, 0.15259522f, -0.08456830f, 
    0.11860898f, 0.03651587f, 0.14447758f, 0.00457690f, 0.21497935f, 0.36319354f, 0.06786926f, 0.15553053f, 
    -0.16893335f, 0.03445327f, 0.19573358f, 0.11548336f, -0.02914926f, 0.01883457f, 0.01655800f, -0.00354837f, 
    -0.05601322f, -0.10339470f, -0.12999165f, -0.15831198f, 0.10461284f, 0.25759459f, 0.29154858f, 0.36748531f, 
    0.00768802f, -0.21191539f, 0.01755409f, 0.07997864f, -0.01525362f, 0.02296424f, 0.08686448f, 0.20398594f, 
    0.07624611f, -0.36756095f, -0.00970159f, 0.12053595f, 0.15375954f, 0.13035823f, -0.02969999f, 0.03821998f, 
    -0.13103166f, -0.04720835f, 0.03752550f, 0.07754109f, -0.06874195f, -0.12921174f, 0.01965058f, 0.07127927f, 
    0.11092564f, 0.10737432f, -0.07723484f, -0.03393176f, -0.03796333f, -0.01801220f, -0.01430343f, -0.09302395f, 
    0.04369302f, 0.03682412f, 0.05527923f, -0.05445037f, 0.00487230f, -0.25673741f, -0.09222495f, 0.08378812f, 
    -0.06463797f, -0.05273478f, 0.14766943f, -0.17415231f, 0.10118546f, 0.04356080f, 0.10106156f, 0.28127044f, 
    0.06129121f, -0.21848559f, -0.13073073f, -0.13900341f, 0.02446258f, 0.09810745f, -0.10108632f, 0.09004820f, 
    -0.14403540f, -0.18503082f, 0.23129301f, 0.25935528f, 0.16300690f, -0.00426178f, -0.26876110f, -0.02761099f, 
    0.12592100f, 0.10867850f, 0.23960993f, 0.08248337f, -0.15429524f, -0.21887849f, -0.26367858f, 0.20238078f, 
    0.06425684f, 0.20345743f, -0.05033521f, -0.15667111f, -0.18545890f, -0.25555110f, -0.00923795f, -0.08035370f, 
    0.08200797f, 0.17427818f, -0.19881755f, 0.08673912f, 0.15573856f, 0.18655711f, 0.30755380f, -0.11461522f, 
    -0.04925179f, -0.19966969f, 0.02609756f, 0.05800261f, 0.17134878f, -0.03720646f, -0.05371327f, -0.27351561f, 
    -0.00807277f, 0.00032971f, -0.06235274f, 0.03571501f, 0.06389365f, -0.11788291f, -0.02234894f, -0.05188547f, 
    0.11056817f, -0.05354982f, -0.40759665f, -0.01851461f, -0.00759106f, 0.06236875f, 0.01362570f, -0.01949075f, 
    0.12821975f, 0.18086553f, 0.05605553f, 0.23720217f, -0.03682870f, -0.12585223f, 0.00323453f, -0.09591556f, 
    -0.03990624f, 0.13516614f, 0.16895956f, -0.07826582f, 0.21695445f, 0.08660091f, 0.12385820f, 0.13813299f, 
    0.22612806f, 0.09813347f, 0.11658039f, -0.01315668f, 0.01746096f, 0.02282954f, 0.13379167f, -0.15324287f, 
    -0.02602313f, -0.04441350f, 0.02140787f, 0.15202063f, 0.29331124f, 0.24492194f, 0.24907313f, -0.01071862f, 
    -0.09113984f, 0.10368592f, 0.07614572f, 0.13202621f, -0.10624654f, -0.08258320f, 0.06332794f, -0.10719021f, 
    -0.03891003f, -0.05239337f, -0.02884338f, -0.13338685f, -0.12315770f, -0.00340457f, -0.06875951f, -0.06517906f, 
    -0.06689958f, -0.14875835f, -0.13074231f, -0.16611077f, 0.12514266f, 0.18645766f, 0.14601831f, 0.00510354f, 
    -0.07362113f, 0.11366328f, -0.14365211f, 0.09543306f, -0.20329891f, -0.33302322f, -0.17076865f, -0.16114040f, 
    -0.26711684f, -0.16884412f, -0.12969732f, -0.21020989f, -0.07135258f, -0.22703812f, -0.06965462f, -0.09290975f, 
    -0.08343284f, -0.18977760f, -0.05759498f, 0.12564784f, 0.22805488f, -0.00614581f, 0.07733624f, -0.19875364f, 
    -0.03833602f, 0.14072992f, -0.00091088f, 0.00691100f, 0.00512497f, 0.07362826f, 0.08292352f, 0.04537565f, 
    -0.20083779f, 0.20101163f, -0.13472879f, -0.02754512f, -0.04872863f, -0.06417035f, 0.12343742f, -0.17926103f, 
    0.20630296f, 0.04919239f, 0.12105267f, 0.05930587f, 0.04309489f, -0.03503610f, -0.06654675f, -0.07898808f, 
    -0.06241885f, -0.16206491f, -0.00648984f, 0.15013695f, 0.18619716f, 0.07923458f, 0.21052213f, 0.04009305f, 
    0.09450924f, 0.21026629f, -0.06573302f, 0.10790972f, 0.14606772f, -0.05624165f, 0.00257080f, -0.04740108f, 
    0.24482380f, 0.06434701f, -0.10211241f, 0.05375026f, -0.17136192f, -0.34069642f, -0.03662739f, -0.19863781f, 
    0.16834173f, 0.01466337f, 0.00560349f, 0.07509957f, -0.01532039f, 0.15191047f, 0.13873816f, 0.09118591f, 
    -0.62032670f, 0.27526155f, -0.00386349f, 0.16235910f, -0.00609729f, -0.02376243f, -0.04482692f, 0.12843429f, 
    0.12108936f, -0.13410841f, -0.17998746f, -0.01801294f, -0.07581097f, -0.15428764f, 0.03815516f, -0.07054576f, 
    -0.23096369f, -0.10740879f, 0.02524436f, 0.02882523f, 0.08430450f, 0.13386442f, 0.01572489f, -0.13608162f, 
    0.07943843f, -0.00076153f, -0.01849208f, -0.35429341f, -0.12778175f, -0.34391412f, -0.00661143f, -0.00680018f, 
    0.06755583f, 0.19061010f, -0.08929716f, 0.02747789f, 0.04919851f, 0.10415740f, 0.12534842f, 0.04146225f, 
    0.07411569f, 0.12031683f, 0.05713513f, -0.08299853f, -0.18848093f, -0.23945871f, -0.14104731f, -0.05578665f, 
    -0.12696902f, -0.28823161f, 0.18794696f, -0.40302110f, -0.11343703f, -0.26841345f, -0.03798885f, 0.04570757f, 
    -0.02270315f, 0.13284107f, -0.05837400f, -0.19497553f, 0.18352158f, 0.18118580f, 0.26990575f, 0.25563577f, 
    0.12039693f, -0.04911374f, -0.11313166f, 0.11717162f, -0.20130885f, -0.10352331f, -0.16840853f, -0.06537751f, 
    -0.01154597f, 0.02961818f, -0.03232390f, -0.02980902f, -0.00404640f, -0.01430719f, 0.01215057f, 0.01674208f, 
    -0.04189906f, 0.03622338f, -0.04767485f, -0.03432000f, -0.00746756f, 0.05852253f, -0.06905922f, -0.00834597f, 
    -0.00500103f, -0.01447429f, 0.04635383f, 0.05294161f, -0.03324295f, -0.03031534f, -0.04615442f, -0.06253283f, 
    0.03628632f, -0.05841954f, -0.06519893f, -0.05439460f, 0.04102481f, 0.04966400f, 0.01254952f, -0.04697587f, 
    -0.02227842f, -0.00522365f, -0.01965812f, -0.00883661f, 0.03621116f, 0.05949351f, 0.00937702f, -0.06679050f, 
    0.06117975f, -0.01375622f, -0.01250573f, -0.03374526f, 0.00520783f, 0.03707752f, -0.03797569f, 0.04161062f, 
    -0.01815878f, 0.03074575f, -0.04945488f, 0.00333173f, -0.04765895f, -0.04844504f, -0.07380056f, 0.03245564f, 
    0.06260638f, -0.03144374f, 0.04513874f, -0.00543242f, -0.06509201f, 0.04118868f, 0.01822933f, 0.00266412f, 
    0.00675917f, 0.01476248f, -0.01210605f, -0.03176672f, -0.02028724f, 0.00963810f, 0.02301805f, -0.00999108f, 
    0.06502119f, -0.06603880f, -0.07748385f, 0.01955363f, -0.06761042f, 0.03019141f, 0.01128057f, 0.03943631f, 
    0.02925013f, -0.01414083f, 0.04461160f, 0.04363174f, 0.04369910f, -0.06909470f, -0.01701505f, -0.05448745f, 
    -0.03793685f, -0.07831980f, -0.04056950f, 0.06312229f, 0.00617306f, 0.02581642f, 0.01224603f, -0.03915085f, 
    -0.06496301f, 0.06753210f, -0.02876044f, -0.01158209f, 0.06504840f, -0.00379084f, 0.00825731f, -0.02405032f, 
    0.00452215f, -0.05848687f, -0.00440468f, -0.07484318f, -0.00604803f, 0.01633180f, 0.01163883f, 0.00052503f, 
    -0.02739366f, -0.01613687f, -0.00979815f, -0.03021555f, 0.00772075f, 0.05590741f, -0.05273979f, -0.05442417f, 
    -0.06070572f, 0.05214390f, -0.04429105f, 0.01545984f, 0.06188897f, -0.04534832f, 0.01933244f, -0.05481518f, 
    0.04739089f, -0.07412732f, -0.02712387f, 0.03379076f, 0.06183762f, -0.03483775f, 0.01586144f, 0.04655311f, 
    -0.05352560f, 0.04294841f, -0.05861027f, -0.00175031f, -0.07269975f, -0.03963096f, 0.04483723f, 0.02818225f, 
    0.05589531f, 0.02285977f, 0.04402916f, 0.06418549f, 0.00350599f, -0.04126197f, 0.05647731f, 0.01514249f, 
    -0.01676892f, 0.04239094f, -0.01483096f, -0.03125145f, 0.01164085f, -0.04348115f, 0.05859169f, -0.06444256f, 
    -0.04475042f, -0.03645671f, 0.04153492f, -0.00524374f, -0.07473694f, -0.02727208f, -0.02973880f, 0.02712381f, 
    -0.02579748f, -0.02926812f, -0.04311541f, -0.01241066f, 0.02417300f, 0.00526684f, 0.04896431f, -0.02821383f, 
    0.00903830f, -0.06291550f, -0.05463798f, 0.06058248f, -0.07700431f, -0.01998893f, -0.01357041f, -0.03326895f, 
    -0.02565549f, 0.04005165f, -0.05020842f, 0.04863525f, 0.01363668f, -0.00334262f, -0.06808663f, 0.00058139f, 
    -0.18081613f, -0.03687508f, -0.01940545f, -0.02064259f, 0.06884627f, -0.07842895f, -0.12056413f, -0.08456923f, 
    -0.14718795f, -0.16526635f, -0.22201504f, -0.10450808f, -0.08228760f, -0.07980087f, 0.02173315f, 0.06144135f, 
    -0.04018798f, 0.19040425f, -0.00285010f, 0.08697768f, 0.07373112f, 0.17994863f, 0.18804370f, 0.08234981f, 
    -0.01098439f, 0.08288159f, -0.03793575f, -0.07553063f, -0.03252426f, 0.03367873f, 0.02627007f, 0.02637961f, 
    0.10664817f, 0.02900195f, 0.06237951f, 0.18940321f, -0.26188049f, -0.05935957f, 0.04950418f, 0.05125523f, 
    -0.09696312f, -0.02519467f, 0.19266996f, 0.08575379f, 0.08286197f, 0.15047428f, 0.11327852f, 0.02263958f, 
    0.32038024f, 0.25300670f, 0.34657222f, -0.19192646f, -0.06821924f, -0.11282729f, 0.02781116f, 0.02210494f, 
    -0.04775182f, 0.10399106f, 0.06030194f, 0.09839376f, 0.01145914f, 0.31323057f, 0.12088554f, 0.12630826f, 
    -0.14360464f, -0.08164508f, 0.04169824f, -0.07994330f, 0.03922801f, 0.13812070f, 0.01529783f, 0.02224699f, 
    0.16665201f, -0.00104841f, -0.16237308f, -0.09832752f, 0.12108193f, -0.03826676f, -0.10489734f, -0.22590326f, 
    -0.02670137f, -0.17580515f, -0.04354172f, 0.08823019f, -0.34111831f, -0.12792036f, 0.16499466f, 0.08524249f, 
    0.01433578f, 0.07808807f, -0.00926566f, 0.00485877f, 0.03131483f, -0.09383395f, 0.10489655f, -0.07459289f, 
    0.12466297f, 0.15178780f, -0.01890511f, -0.04438929f, 0.00974965f, 0.01941693f, 0.00904161f, 0.07369880f, 
    -0.10784730f, -0.02948071f, -0.11031222f, 0.12949227f, -0.03551323f, -0.03501378f, 0.09363272f, -0.03305584f, 
    0.01209734f, -0.11799302f, 0.02046690f, -0.08029907f, -0.16011012f, -0.12184865f, -0.13817982f, -0.20276769f, 
    0.09669493f, -0.09669344f, -0.00093301f, 0.17955981f, -0.04228183f, 0.06186497f, 0.01821951f, 0.01824652f, 
    0.22013190f, 0.20022339f, 0.28506169f, 0.09721718f, 0.16338183f, 0.16013637f, -0.10365235f, -0.05904026f, 
    -0.14868894f, 0.08975188f, -0.06171100f, -0.11030833f, -0.11609593f, -0.20147689f, -0.17947081f, -0.16262777f, 
    -0.03939211f, 0.16431035f, 0.49651474f, -0.00411608f, 0.16152975f, 0.05822031f, -0.02617681f, 0.13298865f, 
    -0.20405819f, -0.19400473f, 0.02255795f, 0.16906035f, -0.18073635f, -0.09430774f, 0.19179019f, 0.07325044f, 
    -0.16957249f, -0.12642798f, 0.04501841f, 0.08479594f, -0.08329012f, -0.07530714f, 0.06084196f, -0.15502778f, 
    0.02568153f, 0.22150886f, 0.20206180f, -0.16344066f, -0.11776955f, -0.00318980f, -0.06714714f, -0.11737702f, 
    0.12161458f, 0.07632750f, 0.20262532f, 0.13613006f, -0.10367288f, -0.13453145f, -0.25749725f, 0.06812944f, 
    0.18365258f, -0.00409313f, 0.17549926f, -0.15314338f, 0.04736988f, -0.12727951f, -0.00661403f, 0.32032138f, 
    0.10646141f, -0.02921613f, -0.08011596f, -0.03379238f, 0.06216130f, 0.11551316f, 0.02754290f, 0.06322364f, 
    -0.11924693f, -0.37707201f, -0.29022491f, -0.28419450f, -0.42796421f, 0.38453758f, -0.09749006f, 0.15531336f, 
    -0.15770823f, -0.09142844f, 0.00974952f, 0.17250685f, -0.02889726f, 0.10014256f, 0.03088323f, 0.28074569f, 
    0.03879483f, -0.19034401f, -0.18641222f, 0.02031570f, -0.16950847f, -0.10545938f, -0.21718372f, 0.00252090f, 
    0.13580571f, 0.33121213f, 0.01460256f, 0.17622706f, 0.16052340f, -0.05301742f, 0.01039761f, -0.01158912f, 
    0.07835700f, -0.09817077f, 0.17056534f, 0.02902786f, 0.11750974f, 0.23502658f, 0.15901488f, 0.12255692f, 
    0.13039328f, 0.42114091f, 0.32339039f, -0.01573201f, -0.01261838f, -0.06227792f, -0.04109869f, 0.05952854f, 
    -0.03857296f, 0.01850107f, -0.13666253f, -0.27798766f, 0.04940513f, -0.12161917f, -0.03886151f, 0.11721741f, 
    -0.11154693f, -0.10153361f, 0.06258746f, -0.15048294f, 0.04905749f, 0.02899442f, 0.16577151f, 0.20233749f, 
    0.07584031f, -0.02520541f, 0.06984872f, -0.02154272f, 0.06147922f, -0.05937805f, -0.13542557f, 0.14792472f, 
    -0.10590193f, -0.02029377f, -0.26977879f, 0.01039904f, -0.04694495f, 0.22788875f, 0.04935635f, 0.04321312f, 
    -0.08052105f, 0.13939202f, 0.14150810f, 0.01538052f, -0.06691357f, -0.08133540f, -0.02149470f, -0.12055463f, 
    0.03009714f, -0.17646599f, -0.11887865f, -0.07918461f, 0.03515152f, -0.21128950f, -0.12576245f, 0.01629676f, 
    -0.18681413f, 0.07636288f, -0.33377397f, -0.12815617f, 0.03629685f, -0.15610737f, -0.01006389f, -0.06535355f, 
    -0.24760976f, 0.31635749f, -0.00475709f, 0.03163240f, 0.02902890f, -0.09122577f, -0.13293476f, -0.07984316f, 
    0.03292853f, 0.10716155f, -0.19808292f, 0.08287534f, 0.08904472f, -0.02989068f, 0.06072665f, -0.10252470f, 
    0.00750124f, 0.06092785f, 0.12019184f, 0.02717215f, 0.18418461f, -0.01526899f, 0.10550421f, -0.07310586f, 
    -0.20110442f, 0.05773173f, -0.29653549f, -0.16042066f, 0.11610699f, -0.06082305f, -0.28553170f, -0.13360977f, 
    -0.23108450f, 0.07769065f, 0.23419493f, 0.26775113f, 0.10354519f, 0.15801995f, 0.06363975f, -0.11724481f, 
    -0.09781852f, -0.11910925f, -0.00742018f, 0.07114440f, 0.06049949f, 0.00003393f, -0.01511052f, 0.03447783f, 
    0.00853819f, 0.04971168f, -0.11390692f, -0.04962086f, 0.06538081f, -0.19026802f, -0.02687156f, 0.00850067f, 
    0.14826699f, 0.11476646f, 0.03900838f, 0.26216513f, 0.05680418f, 0.09977260f, -0.07466950f, -0.00713193f, 
    0.17953935f, -0.06452389f, 0.17700878f, 0.24188428f, 0.17548406f, 0.08096332f, 0.14581782f, -0.05125778f, 
    -0.07797113f, 0.08010963f, 0.13335377f, 0.03602749f, 0.13521832f, 0.01793533f, 0.05487769f, 0.15079659f, 
    -0.07858031f, -0.17262661f, 0.03956399f, -0.02239072f, 0.13456881f, 0.18284038f, 0.04886362f, 0.13164973f, 
    -0.02854836f, 0.10827608f, -0.06793067f, 0.21876089f, 0.00485243f, 0.36403278f, 0.09097335f, 0.12112903f, 
    -0.06043315f, -0.09816132f, 0.04278507f, 0.08015331f, 0.02157641f, 0.01168937f, 0.06468379f, -0.03500055f, 
    -0.07566782f, 0.02996590f, -0.14389944f, -0.07815086f, -0.19432162f, -0.20656592f, -0.28443137f, -0.25033399f, 
    -0.09834738f, -0.15258460f, -0.03525054f, -0.28115231f, -0.06358287f, 0.05870593f, -0.19365035f, 0.06917229f, 
    -0.05220601f, -0.03553808f, 0.04770920f, 0.05445192f, -0.09717160f, -0.15628590f, -0.06327841f, -0.13929355f, 
    -0.10673410f, 0.01084493f, -0.01386586f, -0.22914928f, -0.07257247f, -0.04474039f, -0.03447173f, -0.14567018f, 
    -0.12112399f, 0.08489103f, -0.03821671f, -0.07325985f, -0.03070397f, 0.12679105f, -0.18321757f, -0.01456287f, 
    0.02684963f, 0.00701939f, 0.07949115f, 0.07522897f, 0.04959923f, -0.01064274f, 0.00342550f, -0.07327560f, 
    0.24031015f, 0.19047816f, 0.12145805f, 0.08128307f, -0.10466628f, -0.08729556f, 0.09890866f, 0.15270987f, 
    0.04144146f, 0.02343359f, 0.13684830f, 0.05215315f, 0.16030602f, 0.26970544f, 0.03490946f, 0.04657972f, 
    -0.02869267f, -0.04709169f, 0.11982372f, 0.01250829f, 0.08458924f, 0.02160789f, 0.09742262f, 0.21215491f, 
    0.21252503f, 0.10641283f, 0.02047217f, 0.12234153f, -0.07139200f, 0.26156849f, 0.05077055f, -0.01304043f, 
    0.21095428f, 0.10053165f, 0.05043142f, 0.10233928f, -0.28598595f, -0.19914693f, -0.27454185f, 0.02981810f, 
    -0.13622205f, -0.19227900f, -0.05431143f, 0.12333389f, 0.17726710f, -0.08318704f, 0.21801564f, 0.22238891f, 
    -0.07929287f, 0.18300064f, -0.18610679f, -0.12778345f, -0.02394678f, -0.09824281f, 0.17978424f, 0.09608652f, 
    0.01233867f, -0.08265083f, 0.03840146f, -0.08430877f, 0.04240157f, 0.10747985f, 0.06401207f, -0.02880114f, 
    -0.10986236f, -0.22421297f, -0.06984372f, 0.04593663f, 0.08861054f, 0.13785000f, -0.06179889f, 0.02690192f, 
    0.29736972f, 0.25290987f, 0.31905341f, -0.04583225f, -0.11149061f, -0.05864531f, -0.11297453f, -0.00361252f, 
    0.04008018f, 0.11375502f, 0.14524007f, -0.03815817f, -0.34070602f, -0.05910137f, 0.02288678f, 0.04996086f, 
    0.03759880f, 0.15491775f, 0.02789499f, -0.07614195f, 0.01721665f, 0.01382755f, -0.00473486f, 0.04942265f, 
    0.12766258f, -0.12508659f, 0.21793857f, -0.09600789f, 0.09020024f, -0.10592896f, -0.07310093f, -0.05706731f, 
    -0.03156348f, -0.10671747f, -0.00984697f, -0.14508063f, -0.01832526f, 0.01488586f, 0.03216296f, -0.00232501f, 
    0.13544472f, -0.07739351f, -0.01220119f, 0.19085827f, -0.10495896f, 0.13898848f, -0.01840162f, -0.21077329f, 
    0.20423558f, 0.14911814f, 0.17760232f, 0.34127158f, 0.10296547f, 0.07343379f, -0.04707380f, -0.13212444f, 
    0.08926012f, 0.04259619f, 0.08171114f, 0.05104959f, 0.02318011f, 0.12269355f, 0.17822126f, -0.13672958f, 
    -0.05057831f, -0.11203482f, 0.00412520f, 0.03374518f, 0.11812267f, -0.15191199f, -0.04784015f, -0.09863108f, 
    0.00814569f, -0.08359952f, 0.01451852f, 0.03739917f, 0.01851891f, -0.04458649f, 0.00406484f, -0.03632908f, 
    -0.06832185f, -0.08992845f, -0.02718519f, -0.08880371f, 0.15663807f, -0.07619168f, -0.04974679f, -0.04242638f, 
    0.13113612f, 0.17550567f, 0.01404765f, 0.03514219f, -0.15198074f, -0.21042374f, -0.09109973f, 0.05294818f, 
    0.00660220f, 0.30233747f, -0.01683654f, 0.49183121f, -0.11624917f, -0.05326348f, -0.09118502f, -0.00456895f, 
    0.04629926f, 0.07041995f, 0.14071803f, -0.02979255f, -0.07375015f, -0.39580703f, -0.14682770f, 0.01112899f, 
    0.15277296f, 0.19808187f, 0.01941383f, 0.19258270f, -0.03764806f, 0.00673657f, 0.03549684f, -0.09216299f, 
    -0.01554266f, -0.09397779f, 0.00209850f, 0.01571773f, -0.07355335f, -0.15989143f, 0.10173529f, 0.06357466f, 
    0.00532396f, 0.01744506f, -0.07098725f, -0.02284359f, 0.26762646f, 0.25757244f, -0.30656582f, -0.00780543f, 
    -0.05121488f, -0.11334840f, -0.07571515f, 0.06851427f, 0.11246336f, -0.01841594f, 0.05989625f, 0.02870299f, 
    -0.02369209f, 0.04122255f, 0.11936907f, 0.09129035f, 0.10888448f, 0.01912655f, -0.08821780f, -0.02855445f, 
    -0.04628386f, -0.04000865f, 0.05959487f, 0.08887308f, 0.29041710f, 0.05848807f, -0.08365103f, -0.27651569f, 
    -0.05103481f, -0.01410891f, 0.03960024f, -0.06206358f, 0.15803593f, 0.04020425f, 0.10151059f, -0.00114983f, 
    0.35457096f, 0.16999754f, -0.00086798f, -0.34413311f, -0.08991015f, -0.04926785f, 0.01511363f, 0.09271953f, 
    -0.06512482f, -0.06673498f, -0.11784070f, 0.02184881f, -0.00882945f, -0.06941617f, 0.31938770f, -0.07821424f, 
    0.04851114f, -0.16331154f, -0.06849835f, 0.00644667f, 0.02842362f, 0.05750856f, 0.04165642f, 0.06898022f, 
    -0.21095058f, -0.29258189f, 0.07551824f, 0.19935054f, 0.09656938f, -0.05724598f, -0.17130886f, -0.01363607f, 
    -0.04613272f, 0.02164899f, 0.09479966f, -0.00852146f, 0.34972984f, 0.14007223f, -0.01041072f, 0.05488543f, 
    0.30376032f, 0.26186016f, 0.08380099f, 0.03394083f, 0.06358270f, 0.03430140f, -0.03992649f, -0.00092572f, 
    -0.30462438f, -0.02553957f, -0.12054732f, 0.17239960f, 0.05543670f, 0.13308083f, -0.25337377f, -0.06639974f, 
    0.02056528f, 0.09630737f, -0.00517047f, 0.19564313f, 0.24651532f, 0.21175525f, 0.26135799f, 0.05868722f, 
    -0.01299054f, -0.02246242f, -0.03678598f, 0.20859736f, -0.18424593f, -0.00874964f, -0.01790438f, -0.17807779f, 
    -0.02075535f, 0.00998026f, -0.09141904f, 0.04783103f, 0.05255895f, -0.09758179f, -0.13934082f, 0.02498245f, 
    0.04822812f, -0.04731152f, -0.01055256f, 0.09542821f, -0.53789335f, -0.00508479f, 0.09367872f, -0.08693381f, 
    0.11833829f, -0.21823461f, -0.02521539f, 0.17151712f, 0.10358246f, 0.14523831f, 0.03783727f, -0.03421516f, 
    -0.37372163f, -0.48242822f, -0.34990761f, 0.01853996f, -0.14605239f, -0.15260123f, -0.10066961f, 0.13924685f, 
    0.20474763f, 0.05343821f, 0.00172356f, 0.16578260f, 0.13993385f, -0.01719958f, 0.09881541f, -0.06643301f, 
    0.12768012f, 0.10073686f, 0.07346342f, 0.09540021f, 0.05114583f, 0.03890534f, -0.13805935f, -0.06744448f, 
    -0.14928623f, 0.42556950f, 0.11149587f, -0.28725737f, 0.04737171f, 0.20445138f, 0.06485298f, 0.11138216f, 
    -0.06006728f, -0.08131696f, -0.07009126f, -0.35902238f, -0.15480335f, 0.16893518f, 0.01911839f, 0.07669301f, 
    0.06121692f, -0.17952518f, 0.02161880f, 0.18763624f, 0.04795490f, -0.16850127f, 0.08571136f, 0.11357059f, 
    0.25309429f, -0.56686759f, 0.23998690f, 0.28906393f, -0.12061656f, -0.06485511f, -0.05566752f, 0.07042910f, 
    -0.14067245f, 0.05210851f, -0.09197993f, -0.00548785f, -0.01791772f, 0.26560178f, 0.05184242f, 0.10116513f, 
    0.13075158f, -0.00859748f, 0.14785552f, -0.13501869f, -0.05601691f, 0.14913335f, -0.17266013f, -0.02066350f, 
    0.06256679f, 0.01719304f, -0.14266856f, 0.12301391f, -0.17322388f, -0.05381668f, -0.08039002f, -0.01782039f, 
    -0.04728879f, 0.10995506f, -0.12123217f, 0.09394823f, -0.12589145f, 0.12866883f, -0.24615553f, 0.20927484f, 
    -0.13562521f, -0.09627198f, -0.22641769f, -0.00163728f, 0.18978927f, -0.15302347f, 0.00943981f, 0.07761395f, 
    0.23115584f, -0.42466915f, 0.34354141f, 0.11708347f, -0.10469636f, -0.08852993f, -0.07318394f, -0.03242798f, 
    -0.00441313f, 0.00930464f, -0.03312613f, 0.01161857f, -0.32286820f, -0.20603955f, -0.06946719f, 0.06227186f, 
    0.01243276f, -0.00413474f, -0.26447129f, 0.14555052f, 0.04761061f, 0.03045375f, 0.07121436f, 0.06373207f, 
    0.31508049f, 0.30182171f, -0.16047835f, 0.36930984f, -0.15328668f, 0.13307168f, -0.03858997f, -0.02836216f, 
    0.05037862f, 0.06097853f, 0.01778381f, -0.03371227f, 0.04400938f, 0.10846959f, 0.08282610f, 0.08345262f, 
    -0.07439997f, 0.01563636f, 0.03419355f, -0.05256128f, 0.01455479f, 0.00431791f, -0.07158246f, -0.01141811f, 
    0.69837624f, -0.26387134f, -0.69719392f, 0.17531800f, 0.18241242f, -0.01732588f, 0.23461625f, 0.18354179f, 
    0.19426924f, -0.08074270f, 0.06336221f, -0.02463233f, -0.21493956f, -0.00221847f, 0.03021941f, 0.07441704f, 
    -0.03079387f, -0.06004142f, 0.07220443f, 0.06324417f, 0.10242029f, 0.02394540f, 0.11587818f, -0.10063293f, 
    0.04280874f, 0.05421823f, -0.01173970f, -0.05141683f, 0.04407713f, -0.05302904f, -0.06056583f, 0.01899980f, 
    -0.02501508f, -0.06275427f, -0.00353008f, 0.05943079f, -0.03669242f, -0.02011643f, -0.01318272f, 0.05476087f, 
    -0.00675074f, -0.05699321f, 0.03574031f, -0.05267312f, -0.06420089f, -0.04912116f, 0.03767520f, -0.04372469f, 
    0.04515946f, 0.05484228f, 0.04982692f, -0.06666550f, -0.07788142f, -0.05994115f, -0.07982689f, -0.07130213f, 
    -0.01707624f, -0.07060365f, -0.05771514f, 0.01429739f, 0.01042383f, 0.00554246f, -0.02392914f, 0.02211407f, 
    -0.05392668f, 0.06385390f, -0.01382608f, 0.05770538f, 0.06060620f, 0.00459945f, 0.02268862f, -0.00799959f, 
    -0.03219783f, -0.01718007f, 0.04779934f, -0.03410427f, 0.02395117f, -0.05902563f, 0.01629655f, -0.03407522f, 
    -0.03594549f, 0.05357296f, -0.06913111f, 0.00030974f, -0.02133557f, 0.03610881f, 0.01893496f, -0.01157278f, 
    0.04969006f, -0.05559519f, 0.03859247f, -0.06541535f, 0.04092887f, 0.00276287f, 0.00725160f, -0.03442517f, 
    -0.07470400f, 0.01255631f, 0.02501815f, 0.00760353f, 0.00513192f, -0.04894897f, -0.07355281f, -0.06624008f, 
    -0.07122386f, 0.00799405f, -0.06680349f, 0.04099343f, -0.03882293f, 0.02384500f, -0.06177241f, -0.07551453f, 
    -0.03325702f, 0.01494749f, 0.03585718f, -0.06425530f, -0.03074915f, -0.02800851f, -0.01048845f, 0.05315379f, 
    0.04175458f, -0.02165198f, 0.01669455f, -0.04390846f, 0.05339440f, -0.02213990f, 0.01339883f, 0.06168775f, 
    -0.05058657f, -0.05101093f, -0.05652020f, 0.04353194f, -0.05675143f, 0.04795290f, 0.04120293f, -0.07918766f, 
    -0.00225210f, 0.00507147f, 0.05187258f, -0.02350988f, -0.00256692f, -0.06775343f, -0.04945000f, -0.04773682f, 
    0.06009902f, -0.01295547f, -0.00367758f, 0.05647744f, -0.03142670f, -0.01366230f, 0.02705543f, -0.07356988f, 
    0.06253743f, -0.00632057f, -0.04924798f, -0.02774997f, -0.06378762f, 0.04321183f, 0.06708327f, -0.04264984f, 
    0.05204628f, 0.00961205f, -0.00477570f, -0.01711372f, 0.05713642f, -0.03325257f, -0.00433323f, 0.03770246f, 
    -0.04187674f, 0.04439020f, 0.00816964f, -0.08049180f, -0.04979420f, -0.03931144f, -0.00814476f, -0.04872258f, 
    -0.06011790f, -0.05392021f, -0.04886987f, -0.00053163f, 0.02665360f, -0.01655065f, 0.03248656f, 0.03728219f, 
    -0.04352560f, 0.04289763f, -0.04448269f, -0.06417660f, -0.06582414f, 0.00114799f, 0.03613498f, -0.06157729f, 
    0.01009265f, -0.05494052f, -0.06410815f, 0.05992175f, 0.03971667f, 0.04533400f, 0.04318018f, -0.05767676f, 
    -0.03132828f, 0.03904095f, -0.05043135f, -0.06072034f, -0.06195695f, -0.05729728f, 0.01958240f, 0.02229527f, 
    0.01452863f, 0.04538065f, -0.01054471f, 0.03985048f, -0.02505285f, 0.06093733f, -0.00777331f, -0.02037589f, 
    0.17184123f, 0.01575110f, -0.04900019f, -0.08906393f, -0.10206268f, -0.06812695f, -0.08497819f, 0.11830258f, 
    -0.00056396f, 0.02694673f, 0.05892892f, 0.15653260f, -0.29034233f, 0.40203756f, -0.12393239f, 0.17384177f, 
    -0.22318844f, -0.04720961f, 0.20776546f, 0.05096368f, -0.03397932f, 0.08959513f, -0.00309902f, -0.05969248f, 
    -0.16009657f, -0.10211536f, -0.09658487f, -0.06803206f, -0.01249843f, -0.06385276f, 0.04369946f, 0.07205626f, 
    -0.04894863f, 0.09677080f, -0.09064316f, -0.09314723f, 0.10791256f, 0.00283692f, -0.13245693f, -0.02653936f, 
    0.17706671f, -0.27997431f, -0.09352698f, 0.08607195f, -0.21989572f, 0.03941178f, 0.01853012f, -0.09538089f, 
    -0.08267982f, 0.13384879f, 0.38913223f, -0.21533358f, -0.07863776f, 0.21848620f, -0.08038606f, 0.06781062f, 
    -0.03151811f, -0.07057633f, -0.11894751f, -0.06004167f, -0.09789302f, -0.22500871f, -0.01412015f, -0.14388120f, 
    -0.02018665f, -0.26417747f, -0.15097931f, 0.00449283f, -0.00645037f, -0.02483649f, 0.09457018f, -0.14133780f, 
    0.00908278f, -0.05023513f, 0.43124548f, -0.03072645f, 0.16205597f, -0.04138142f, 0.08562122f, 0.10999367f, 
    -0.02029854f, 0.12871885f, 0.02363044f, -0.03240062f, -0.07391381f, 0.34540957f, 0.31964469f, 0.32581326f, 
    0.15381393f, 0.09585822f, -0.03549439f, -0.05232648f, 0.00392253f, 0.10898042f, -0.09091038f, 0.07069363f, 
    0.16749482f, -0.12510911f, 0.05375181f, -0.14800796f, 0.06648862f, 0.00097258f, -0.00487230f, -0.03113883f, 
    0.02802494f, 0.13177118f, 0.18337306f, 0.10898768f, -0.22962099f, -0.07881664f, 0.11594495f, 0.21631478f, 
    -0.09302399f, 0.04062705f, 0.03157165f, -0.06751703f, 0.13019410f, 0.01441870f, 0.10104007f, 0.05030569f, 
    -0.54694414f, 0.10193653f, -0.27644655f, 0.09477331f, 0.07558876f, 0.12785666f, -0.14491965f, -0.06158802f, 
    -0.01564595f, -0.06920881f, -0.09511647f, 0.08650303f, 0.03752311f, 0.11808905f, -0.08810701f, -0.11188509f, 
    -0.07387903f, 0.01925203f, 0.02422983f, -0.02875765f, -0.04641509f, 0.11043196f, 0.09739912f, 0.05259235f, 
    0.12590267f, 0.12964764f, 0.28604367f, 0.28260171f, -0.06330553f, -0.02783222f, 0.13898653f, 0.05082638f, 
    -0.03946993f, 0.07321683f, -0.04942174f, 0.14811152f, 0.05812016f, 0.02865204f, -0.09239300f, 0.24770881f, 
    -0.09722766f, 0.01427942f, -0.00869084f, 0.13887474f, 0.06629650f, -0.05864812f, 0.05051342f, 0.00780395f, 
    -0.07247826f, 0.23571455f, 0.02546663f, 0.16710848f, 0.03830125f, -0.04884524f, 0.11757410f, 0.00574187f, 
    -0.24479274f, -0.23400784f, 0.01495477f, -0.19044286f, 0.29852349f, -0.07859580f, 0.13489567f, -0.14738803f, 
    -0.06677648f, -0.04208095f, 0.25340566f, 0.24922703f, -0.12003622f, 0.13518906f, 0.12745079f, 0.01297827f, 
    0.17716858f, 0.06590234f, 0.08746582f, 0.01893098f, 0.06870026f, 0.16805156f, 0.26130185f, 0.14075293f, 
    0.01585724f, 0.15077965f, -0.04725216f, -0.37837234f, 0.14091904f, 0.11729172f, -0.42581284f, 0.34757704f, 
    0.11209277f, 0.02019446f, -0.18548326f, -0.13697676f, 0.09686981f, -0.08426505f, -0.04696424f, 0.07850303f, 
    -0.25857887f, 0.09825721f, -0.07689282f, -0.17740852f, -0.04150213f, 0.11607892f, 0.03768941f, -0.06810948f, 
    -0.04174524f, 0.14645162f, 0.03193988f, -0.00045090f, 0.13397752f, -0.00063297f, -0.10125980f, 0.18818595f, 
    0.11619233f, 0.00214140f, 0.14357772f, 0.06454037f, -0.04434094f, 0.01433437f, 0.05820728f, 0.23129183f, 
    0.45773053f, -0.07798572f, 0.02881948f, 0.50386643f, 0.05281646f, 0.07841998f, -0.05464653f, 0.06717852f, 
    0.23217078f, 0.02817851f, 0.00594293f, 0.13065690f, 0.18704213f, -0.09329526f, 0.14350137f, 0.25168362f, 
    0.03537970f, 0.10336202f, -0.14489150f, -0.14501165f, -0.03466576f, 0.13977040f, -0.02511429f, 0.19421275f, 
    -0.33813360f, 0.25583991f, -0.12983702f, -0.51099294f, -0.05835748f, -0.03600669f, 0.09449742f, -0.13562377f, 
    -0.06348055f, -0.12245808f, -0.06908975f, -0.08806832f, 0.06563689f, -0.20980524f, 0.06388845f, 0.17286128f, 
    0.05485026f, 0.11204866f, -0.00326019f, 0.12508529f, -0.04971537f, -0.22377230f, 0.04075805f, -0.09747126f, 
    -0.28153682f, -0.21756940f, 0.03569042f, -0.33274910f, 0.06939028f, 0.07357395f, -0.08689183f, 0.03124253f, 
    -0.07713610f, -0.14198577f, 0.21221045f, -0.16627015f, 0.12178317f, 0.11748090f, -0.10100195f, -0.20740555f, 
    0.19175787f, 0.08898204f, 0.12162653f, -0.17467356f, -0.33969876f, 0.23801768f, -0.12989426f, 0.04356442f, 
    -0.16338593f, 0.22598517f, -0.13995102f, -0.36721238f, -0.09997831f, 0.23257382f, 0.09946415f, -0.13505244f, 
    -0.11021157f, 0.06150402f, -0.09225402f, 0.09063552f, -0.29549772f, -0.28229335f, 0.03450622f, -0.25251019f, 
    -0.04665476f, 0.04540798f, 0.05382812f, -0.27893591f, -0.24190125f, -0.06533712f, -0.14891905f, -0.11897504f, 
    -0.53216308f, -0.42666319f, -0.18994440f, 0.04362201f, 0.07946852f, 0.12323346f, -0.19693302f, -0.02054081f, 
    0.01248447f, 0.02550261f, -0.04338538f, -0.03846600f, 0.28637993f, 0.08725969f, -0.00944718f, 0.17141604f, 
    0.25845346f, 0.13992307f, 0.09649132f, 0.29651207f, 0.01552882f, 0.08899339f, 0.14760545f, 0.03118553f, 
    -0.57643658f, -0.01014925f, 0.02327249f, 0.29679283f, -0.12648995f, -0.00073596f, -0.21195482f, -0.13106707f, 
    -0.03757994f, 0.01365656f, -0.05395645f, 0.17807001f, 0.46336520f, 0.01854087f, 0.05695114f, -0.09431697f, 
    0.05625376f, 0.13049479f, -0.00637590f, 0.03462026f, -0.01763185f, -0.06819389f, -0.05105737f, 0.07664793f, 
    -0.10383191f, -0.24442293f, -0.21690620f, -0.19639097f, 0.14412078f, -0.08256859f, -0.16188657f, -0.05284113f, 
    0.01410590f, 0.03004496f, 0.05005284f, 0.01922782f, -0.27714768f, 0.17158140f, -0.40442175f, 0.12121575f, 
    -0.04258288f, 0.03069120f, 0.08774229f, 0.12139373f, -0.04633548f, 0.03488483f, 0.04316249f, 0.07026591f, 
    0.00852956f, 0.08095384f, -0.03899108f, -0.06597031f, 0.06515331f, 0.01944336f, -0.03847545f, -0.01752726f, 
    -0.02455677f, -0.07371257f, 0.01403369f, 0.06622280f, 0.17324576f, -0.27626321f, -0.20468928f, -0.01229244f, 
    -0.11965414f, 0.00095836f, 0.06505270f, -0.03608650f, 0.10674291f, 0.01746787f, 0.14181495f, 0.02167061f, 
    -0.02394165f, 0.22396423f, 0.28543007f, 0.27909866f, -0.11202437f, 0.13795008f, -0.02086650f, -0.03753450f, 
    -0.05908348f, 0.05126067f, 0.07885713f, 0.04393206f, -0.48470905f, -0.43540484f, -0.19730741f, -0.21904367f, 
    -0.05488702f, 0.08920133f, 0.13744989f, 0.17539521f, 0.01543496f, 0.12738866f, 0.03954513f, 0.06172555f, 
    0.09945676f, -0.04577344f, 0.12987788f, 0.02795345f, 0.05830184f, 0.02976255f, -0.02994074f, -0.07204019f, 
    0.02584254f, -0.03485104f, -0.01337675f, -0.05786622f, -0.16630010f, -0.00850845f, -0.11943649f, 0.21314982f, 
    0.22102652f, 0.13877739f, 0.04908732f, -0.09733805f, 0.11245480f, -0.11252959f, 0.05292697f, 0.07797483f, 
    0.14382824f, -0.05821265f, 0.11005736f, -0.08643458f, 0.03557353f, -0.04922267f, -0.01167210f, 0.07442793f, 
    0.02347846f, 0.01659267f, -0.01514266f, 0.05355969f, 0.05481113f, 0.08304145f, -0.15476988f, -0.04100631f, 
    -0.04407641f, -0.08733315f, 0.08122870f, 0.00911593f, 0.21713632f, 0.08104946f, -0.00015551f, 0.06191512f, 
    0.19631459f, 0.00702641f, 0.03811631f, -0.08721441f, -0.05479540f, -0.01927472f, 0.01395866f, -0.11895802f, 
    0.20356913f, 0.12565571f, 0.08770736f, 0.10677499f, 0.14497456f, 0.31315532f, 0.23213147f, 0.16708393f, 
    0.09397356f, -0.10352021f, -0.09008128f, -0.02309474f, 0.01392888f, -0.01461578f, -0.08875097f, -0.12904410f, 
    0.34491524f, 0.04838803f, 0.40532520f, 0.47780702f, 0.10176495f, -0.08900084f, -0.02912714f, 0.01529162f, 
    -0.07230271f, -0.01516115f, 0.04320807f, 0.05128004f, 0.22392282f, -0.06447547f, -0.04905885f, -0.18070766f, 
    -0.12126036f, -0.08215351f, 0.01469356f, -0.05128178f, 0.06362660f, -0.09674563f, 0.06717704f, -0.01129832f, 
    0.17351660f, -0.14028661f, -0.00068761f, 0.35034603f, -0.04787407f, -0.04891701f, 0.09247534f, 0.07145154f, 
    -0.12075401f, 0.20570488f, 0.07198554f, -0.13299337f, 0.02499801f, 0.04508087f, -0.04635607f, -0.32797620f, 
    0.18204537f, 0.16117720f, 0.19704656f, 0.01009406f, 0.02097709f, 0.08727664f, 0.02671899f, 0.14067823f, 
    -0.16142070f, 0.08413289f, -0.06741054f, 0.09951502f, 0.09530658f, 0.24030665f, 0.18504526f, 0.11088853f, 
    0.03436807f, 0.14101954f, 0.10071638f, 0.00540666f, 0.30968699f, -0.18404135f, 0.23733258f, -0.02613965f, 
    0.00133812f, 0.01224183f, -0.04832933f, -0.01356893f, 0.06839874f, 0.03956152f, -0.06674704f, 0.05346415f, 
    0.10281199f, 0.04528607f, 0.00220109f, 0.02865557f, -0.03131470f, -0.09328518f, -0.08293407f, -0.11140508f, 
    -0.02246817f, -0.18650156f, -0.13709320f, -0.19999418f, 0.11893616f, 0.25918254f, 0.04131034f, -0.06323078f, 
    0.02605552f, -0.03103356f, 0.03699757f, -0.09010946f, -0.08160809f, -0.26151571f, -0.02027893f, -0.13935046f, 
    0.02013875f, 0.15643413f, -0.39392233f, 0.01195691f, -0.02031661f, -0.05443859f, 0.06382563f, 0.07831017f, 
    0.00936515f, -0.07271942f, -0.09733831f, -0.05084486f, -0.07934694f, -0.16001065f, -0.22472589f, -0.30025226f, 
    -0.10633560f, 0.01225458f, 0.06104287f, 0.02061691f, 0.05211392f, -0.01332106f, 0.00302830f, -0.11286367f, 
    -0.00329326f, 0.13863835f, 0.06938059f, 0.17971420f, -0.02514538f, -0.06198528f, 0.04206495f, -0.02975828f, 
    0.09948080f, 0.10226940f, -0.03767405f, 0.00826854f, 0.36882779f, 0.14014359f, -0.00226560f, -0.02293831f, 
    -0.00837632f, 0.06466489f, 0.14949201f, 0.14281346f, 0.09536501f, 0.11207729f, -0.06538802f, -0.00647180f, 
    0.06504776f, -0.00791346f, 0.07765986f, 0.13182160f, 0.00075866f, 0.16257337f, 0.18802372f, -0.09304855f, 
    0.15493621f, 0.09824006f, 0.03134111f, 0.09497155f, 0.09375947f, 0.04622262f, 0.04018005f, -0.14049162f, 
    -0.22757657f, -0.02822473f, -0.08822636f, -0.11453148f, 0.13647382f, 0.01834459f, 0.08530292f, -0.07575066f, 
    0.53175926f, -0.24332443f, 0.03482690f, 0.03825339f, -0.09497123f, -0.03009192f, -0.00192491f, -0.02702388f, 
    0.07712407f, -0.00807653f, -0.03138172f, -0.10305441f, 0.08957641f, -0.03411085f, 0.15058830f, -0.00718343f, 
    0.02555162f, -0.15002571f, 0.05149752f, -0.09790401f, 0.04178767f, 0.13857649f, 0.05207495f, 0.02959185f, 
    0.21829189f, 0.09892050f, 0.14675523f, 0.05302393f, -0.11274245f, -0.03768393f, -0.17002168f, 0.03608128f, 
    0.03646016f, -0.02630666f, 0.05059527f, -0.08748116f, 0.11218146f, 0.26375777f, 0.15002355f, -0.00520168f, 
    0.02710506f, 0.06377932f, 0.08907484f, -0.02284795f, 0.03837910f, 0.02048991f, -0.02947757f, 0.09901797f, 
    -0.01242771f, 0.13091455f, 0.17665957f, 0.08269007f, 0.00660783f, 0.04703595f, -0.05252700f, 0.04937828f, 
    0.03616092f, -0.31646082f, 0.01704211f, 0.13996398f, -0.32581559f, 0.13496464f, -0.03804304f, 0.11235464f, 
    0.12317523f, -0.07855891f, -0.11823335f, 0.13088199f, -0.02486659f, 0.01580610f, -0.04782465f, -0.03743057f, 
    0.03738751f, -0.05402691f, -0.07671224f, 0.02929104f, 0.02580228f, -0.06291150f, 0.03710681f, 0.04965759f, 
    0.04894055f, 0.01363529f, 0.03723824f, -0.01609610f, -0.05937266f, -0.06120194f, -0.00146654f, -0.00774048f, 
    -0.07921743f, -0.08099720f, -0.07993057f, 0.02893808f, 0.01852495f, -0.04831436f, -0.04533594f, 0.03721756f, 
    -0.05066976f, -0.04766288f, 0.04367297f, -0.02643633f, -0.00952397f, -0.04873597f, -0.00263324f, 0.05236815f, 
    -0.01782766f, 0.05510135f, -0.00878092f, 0.00013515f, -0.05729590f, 0.03577865f, 0.00056952f, 0.00014393f, 
    0.04590221f, 0.05850375f, -0.04946953f, -0.00083136f, -0.02730772f, 0.04812495f, 0.00716365f, 0.04058959f, 
    -0.07325412f, 0.00111733f, -0.02726672f, 0.04604325f, -0.04270305f, -0.02303831f, 0.00900308f, -0.04138412f, 
    0.04087223f, -0.07405819f, -0.03686967f, -0.00277969f, -0.05187142f, -0.04474629f, 0.05289598f, -0.04358077f, 
    -0.01982659f, -0.07754872f, -0.00788577f, -0.07432467f, -0.05033766f, 0.01642077f, -0.04049116f, 0.03842133f, 
    -0.07004874f, -0.04259679f, -0.06344541f, 0.05840484f, 0.04251862f, 0.04273296f, 0.04602942f, 0.00658775f, 
    -0.07358563f, -0.07671337f, -0.07326103f, 0.01967542f, 0.05824412f, 0.01648951f, -0.03960921f, 0.03029110f, 
    -0.02024187f, 0.02419413f, -0.06012448f, -0.01569846f, -0.02319220f, -0.07983654f, -0.01797318f, 0.05672557f, 
    -0.02428576f, 0.01775318f, -0.00849636f, 0.05226851f, 0.04027032f, -0.01769876f, -0.03849648f, -0.03958689f, 
    0.04509596f, 0.00214811f, -0.00621379f, 0.06167056f, -0.01922899f, 0.04291390f, -0.04546571f, 0.01731572f, 
    -0.04523309f, -0.06722748f, -0.01359156f, -0.04355649f, -0.02026156f, -0.07066436f, -0.03435769f, -0.01161310f, 
    0.03642047f, 0.02509185f, -0.00498319f, 0.03628019f, -0.00754065f, -0.01793778f, 0.05108791f, 0.05752319f, 
    0.04597636f, -0.02043078f, -0.06642734f, -0.07213426f, -0.06544468f, 0.03237962f, 0.03904300f, -0.02517452f, 
    -0.06987027f, 0.05625996f, 0.03889792f, 0.05848252f, -0.00185141f, -0.01829109f, -0.08022597f, -0.01362329f, 
    0.00495011f, 0.03222891f, -0.06248267f, 0.04199015f, 0.03432831f, -0.06882962f, 0.00901271f, 0.03108444f, 
    -0.02063204f, 0.05571412f, 0.04432312f, 0.04412254f, 0.04603148f, -0.06421763f, -0.05974054f, -0.05456265f, 
    -0.06182230f, -0.06454952f, -0.01593652f, -0.01927906f, -0.02753371f, 0.04027771f, -0.06101765f, -0.05538655f, 
    -0.02305269f, -0.06217960f, -0.05535428f, 0.04432792f, -0.02104568f, -0.04830001f, 0.02986225f, 0.01612951f, 
    0.04375951f, 0.04872065f, -0.06879824f, 0.01080591f, 0.05472486f, 0.00622653f, -0.00793506f, -0.01536706f, 
    -0.04191900f, -0.03454552f, 0.04541707f, -0.04782669f, -0.01642371f, 0.00697464f, -0.07267929f, 0.05935613f, 
    0.06448217f, 0.00975998f, -0.00739287f, -0.06373442f, -0.04457117f, -0.02454887f, 0.00199475f, -0.05290265f, 
    -0.03854464f, -0.00862138f, 0.04825334f, -0.01276161f, 0.03015856f, 0.04316937f, -0.05537382f, -0.02518651f, 
    0.06487904f, 0.05934176f, 0.05304995f, 0.06289541f, -0.03811003f, 0.01195452f, -0.01409880f, -0.05838314f, 
    0.01540763f, 0.04479533f, -0.01498287f, 0.04782124f, 0.04685221f, 0.00452781f, -0.05181919f, -0.06732282f, 
    -0.03105689f, 0.00089668f, 0.01771566f, -0.04385105f, -0.05409479f, 0.03465320f, 0.04009604f, 0.03377141f, 
    0.03147227f, 0.02567465f, -0.05434906f, 0.02408824f, -0.03501067f, -0.02914143f, -0.05814319f, 0.02214648f, 
    -0.02927448f, -0.02891386f, -0.07071704f, -0.05560363f, -0.05723486f, 0.02648500f, 0.05994652f, -0.00238027f, 
    -0.04109422f, -0.04342994f, 0.02143746f, -0.04154133f, -0.05492323f, 0.00223851f, -0.06259249f, -0.01122961f, 
    -0.06279781f, 0.04732540f, 0.04881277f, -0.02466374f, -0.04630972f, 0.04907152f, -0.04595752f, -0.00450951f, 
    0.00854372f, -0.02758687f, 0.01203097f, -0.06998233f, 0.01722119f, 0.00576181f, 0.02032823f, -0.04728571f, 
    -0.04830845f, 0.01684131f, -0.04757614f, 0.01093390f, -0.06652460f, -0.04706924f, -0.06211326f, -0.06728441f, 
    0.04909234f, -0.01823129f, 0.02219213f, -0.05802486f, -0.03998760f, -0.00669116f, 0.05390544f, 0.02182003f, 
    -0.04356125f, 0.03174152f, 0.04041129f, -0.00333912f, 0.03433735f, -0.02495088f, -0.03276537f, 0.05979122f, 
    0.01164544f, -0.03644893f, 0.00775858f, -0.04173622f, 0.04356208f, -0.01178745f, -0.05061133f, -0.04805012f, 
    -0.06079551f, -0.01174734f, 0.00075211f, 0.02028744f, -0.01222351f, -0.07016688f, -0.03033056f, 0.04148714f, 
    0.03962375f, -0.05621349f, 0.03465785f, 0.01809705f, -0.02139699f, -0.02179182f, -0.06731430f, -0.03305212f, 
    0.06043636f, 0.06042274f, 0.00185168f, 0.01975445f, 0.00969996f, -0.06370929f, 0.06391361f, -0.06244234f, 
    0.00048003f, -0.04578733f, 0.03333558f, -0.06069591f, 0.03532477f, 0.02641923f, -0.00869967f, -0.05664178f, 
    -0.04474020f, -0.04107353f, 0.06573359f, 0.05413191f, 0.03387772f, 0.05155990f, 0.04417530f, 0.02077996f, 
    -0.00245583f, -0.01246202f, 0.00227148f, -0.06185301f, -0.06128867f, -0.02696738f, 0.06529777f, -0.00564757f, 
    -0.03299376f, -0.01713181f, -0.02008224f, 0.03177086f, -0.06724843f, -0.05465680f, -0.04124114f, -0.07044389f, 
    0.02429941f, -0.05974238f, 0.06583992f, -0.04358720f, -0.01588277f, -0.04457247f, 0.05409878f, -0.04896200f, 
    0.01877129f, -0.01860241f, -0.02648927f, -0.06573362f, -0.00122154f, -0.00310077f, 0.04567906f, 0.03231297f, 
    0.00069118f, 0.05845952f, -0.04430876f, 0.01555703f, -0.06987843f, -0.00373002f, 0.02302264f, 0.06733391f, 
    -0.07011668f, -0.00034835f, -0.14035000f, -0.20893958f, 0.05074314f, -0.21059284f, -0.03934730f, -0.10829913f, 
    0.04705496f, 0.01307355f, -0.06489675f, -0.05477922f, -0.03167525f, 0.06651092f, 0.11702897f, -0.21501829f, 
    -0.02508612f, -0.02796896f, 0.08363567f, 0.03207128f, 0.03305748f, 0.08216327f, 0.05357321f, 0.01347552f, 
    -0.01178013f, -0.08876774f, -0.04756431f, 0.03173427f, -0.11372513f, -0.02409949f, -0.01546943f, -0.05408203f, 
    -0.04041018f, -0.05471675f, -0.08558881f, -0.06606506f, -0.00242896f, -0.07303990f, 0.22925898f, -0.06737646f, 
    -0.14385374f, 0.07697701f, 0.03366438f, 0.09705553f, 0.08138867f, 0.09136337f, -0.01723767f, -0.05711930f, 
    -0.25555217f, 0.11826035f, 0.05690365f, -0.32793391f, 0.05305690f, 0.10009176f, -0.14379407f, -0.15462354f, 
    -0.02750123f, -0.05416481f, -0.04611952f, -0.00180898f, -0.20405537f, 0.01053919f, -0.04376563f, -0.15213957f, 
    -0.05884549f, -0.03983971f, -0.05607445f, 0.12908877f, -0.00583750f, 0.05891811f, 0.15107980f, -0.02318757f, 
    0.04451602f, -0.19021463f, 0.03042758f, 0.14366387f, 0.07802978f, -0.11111190f, -0.04752000f, -0.00765601f, 
    0.07296206f, -0.09485089f, 0.16208212f, -0.04092341f, 0.05376266f, -0.06806647f, -0.03601050f, 0.03076600f, 
    0.14306729f, -0.04879287f, 0.15650313f, -0.11002273f, 0.19276930f, 0.14454778f, -0.02919477f, 0.10388285f, 
    0.21981235f, 0.11796018f, -0.05730671f, 0.14494222f, -0.07827918f, -0.12161218f, -0.01843558f, 0.03354402f, 
    0.09466693f, -0.08446831f, -0.05424011f, 0.05982174f, -0.15530920f, -0.14123347f, -0.06640626f, 0.02013743f, 
    -0.05176700f, -0.13196333f, -0.03603481f, -0.11817366f, 0.17906065f, 0.04802193f, 0.11717329f, 0.14447942f, 
    -0.28333598f, -0.16215523f, 0.10379855f, 0.24228691f, 0.00897825f, -0.01941786f, -0.08533322f, 0.03131858f, 
    0.10536321f, 0.04456778f, 0.07375631f, -0.10045465f, -0.07507900f, -0.00090077f, 0.01470386f, 0.21442398f, 
    0.03524516f, -0.00510465f, -0.21017441f, -0.07407659f, -0.12021805f, -0.07400396f, -0.06569980f, -0.04080081f, 
    0.80219227f, 0.08712044f, 0.11686568f, -0.02109211f, 0.03648781f, -0.13862166f, 0.05973895f, -0.06833376f, 
    -0.07268797f, -0.02992035f, -0.00422451f, -0.07756667f, -0.07088861f, 0.04252009f, 0.21744156f, -0.10824947f, 
    0.00841292f, -0.07632024f, 0.08042806f, -0.10586490f, -0.00369323f, -0.11073991f, -0.04312633f, -0.00629025f, 
    0.53635556f, -0.21038723f, -0.11303212f, -0.06552899f, -0.01222675f, -0.06332941f, 0.04710175f, 0.10209560f, 
    0.14032668f, 0.00407311f, 0.02208440f, -0.16096051f, -0.30561012f, 0.04611319f, -0.02179917f, 0.04947102f, 
    0.04241681f, -0.14541578f, 0.05402362f, 0.02331546f, 0.00167273f, 0.04874719f, 0.11881259f, -0.00781647f, 
    -0.14980263f, -0.00290135f, 0.12346202f, 0.03793096f, -0.01327481f, 0.11206350f, -0.13062595f, -0.22048782f, 
    -0.03356887f, -0.06345227f, -0.08041477f, 0.02115267f, -0.11535406f, 0.31919536f, -0.01463787f, -0.15605934f, 
    -0.04773530f, 0.09100179f, -0.04267725f, 0.00144445f, 0.03861669f, -0.09096947f, -0.03807124f, -0.04609725f, 
    0.12416915f, 0.09377725f, 0.01313322f, 0.05009418f, 0.03329860f, -0.01781365f, 0.06817708f, 0.05277756f, 
    0.05242717f, 0.17561363f, -0.17723472f, -0.04175090f, 0.10703799f, 0.02644580f, 0.13333850f, -0.35538363f, 
    -0.11301735f, -0.06363450f, 0.00555781f, -0.04856812f, 0.11935785f, 0.01864841f, 0.03896634f, 0.02153637f, 
    0.50321627f, 0.51147568f, -0.04525452f, 0.12080024f, -0.01939021f, 0.07526468f, -0.09061693f, -0.01133631f, 
    0.00635615f, 0.00991100f, 0.00728976f, -0.01543570f, -0.25135908f, -0.38456976f, -0.11183602f, -0.00962783f, 
    -0.09776664f, 0.02025964f, 0.13856679f, 0.03804734f, 0.13893674f, 0.03737320f, 0.11063389f, 0.03152201f, 
    0.10894772f, 0.08392514f, 0.03466937f, 0.21696562f, 0.09177811f, -0.02192584f, 0.07484449f, -0.09584037f, 
    0.06519184f, 0.04872922f, 0.18203874f, -0.01901020f, 0.02395009f, 0.10436545f, -0.02815158f, -0.03688357f, 
    -0.00490044f, -0.26205057f, 0.15364780f, -0.12743361f, 0.04918021f, 0.01336212f, -0.08272847f, -0.00259941f, 
    0.17494211f, -0.00342883f, 0.15107769f, 0.04561884f, -0.11202493f, 0.05005896f, 0.14829959f, -0.06155253f, 
    -0.17518945f, 0.04710737f, -0.15498619f, -0.07674858f, -0.10775082f, 0.03987065f, 0.02946148f, 0.08250857f, 
    0.00679317f, 0.05185484f, -0.02052701f, 0.01251515f, -0.09785607f, -0.07842131f, -0.04960737f, -0.22742519f, 
    0.18253370f, -0.01302115f, -0.05940795f, 0.00581679f, -0.00477205f, 0.07820588f, 0.07129511f, 0.10619276f, 
    0.08069238f, 0.12408856f, -0.02502998f, -0.18812625f, 0.06172501f, 0.06675643f, 0.14715843f, 0.22005528f, 
    -0.00790732f, 0.07405118f, -0.07230864f, -0.04620159f, -0.05980000f, -0.07826901f, -0.11830023f, 0.01113282f, 
    0.27021256f, 0.05821826f, 0.31334692f, -0.00939245f, 0.05441578f, 0.02083482f, 0.01259762f, -0.01997185f, 
    -0.05054978f, -0.10140082f, 0.00222131f, -0.02764498f, -0.31932414f, -0.16674848f, -0.09915899f, -0.06040446f, 
    0.09828098f, 0.11641917f, 0.00768481f, -0.06934049f, 0.12597278f, -0.00029639f, 0.06333964f, -0.08678007f, 
    0.22815596f, -0.06582516f, 0.16167989f, 0.07496440f, 0.04764428f, 0.08039649f, -0.02735713f, 0.10140401f, 
    0.18007673f, 0.06896714f, 0.07399580f, 0.06949154f, -0.40225625f, -0.26857826f, -0.30906624f, -0.30550188f, 
    0.03402219f, -0.13886921f, -0.04077489f, -0.08237293f, -0.04046130f, -0.04703156f, 0.01946474f, -0.00641286f, 
    -0.04219128f, -0.02752815f, -0.00867864f, 0.02603099f, 0.04226621f, 0.06637145f, 0.05985742f, 0.01440781f, 
    0.05597463f, -0.06077046f, 0.01238585f, -0.00832633f, -0.00122977f, 0.02953209f, -0.06029602f, -0.06503728f, 
    0.02563682f, 0.01016687f, 0.00250032f, -0.01860400f, -0.00758030f, -0.05528103f, -0.03913445f, 0.00301730f, 
    -0.01809686f, 0.04578028f, 0.02461340f, 0.01000076f, -0.07158456f, -0.00834257f, -0.00116518f, 0.03325028f, 
    -0.03847397f, -0.01759350f, 0.02607797f, 0.06645212f, 0.04150439f, -0.05393738f, -0.04921400f, 0.02980991f, 
    -0.03627188f, -0.06416071f, 0.04231848f, 0.02554923f, -0.00566657f, -0.07777058f, 0.02380423f, -0.08141316f, 
    -0.01097335f, -0.02953154f, -0.02912149f, 0.01700209f, -0.07123795f, 0.03166237f, -0.00767162f, -0.01838846f, 
    0.05661212f, -0.01529011f, -0.02433577f, -0.01078248f, -0.02494350f, -0.02112652f, -0.09017375f, 0.03090523f, 
    0.01993328f, -0.00988923f, 0.04425079f, -0.01559719f, 0.01144899f, -0.05503542f, 0.01021936f, -0.01855469f, 
    -0.00788889f, 0.03283269f, -0.07173350f, 0.05438141f, -0.02877366f, -0.07216818f, -0.02785739f, -0.01397691f, 
    0.05255010f, 0.04754323f, -0.05784335f, 0.03510153f, -0.08267080f, -0.02209774f, -0.01502185f, -0.05759839f, 
    0.00494010f, 0.01289883f, -0.02640397f, 0.03241310f, -0.03322974f, -0.04725869f, -0.03270225f, -0.00192952f, 
    0.02604060f, -0.02266367f, -0.04978843f, -0.07888552f, -0.04552692f, 0.02456142f, -0.06561107f, 0.04874792f, 
    -0.03212149f, -0.05718533f, 0.03825805f, -0.00731659f, 0.06158154f, 0.02212308f, -0.03284123f, -0.04874559f, 
    -0.02504522f, -0.03300435f, 0.04694196f, -0.04497180f, 0.01771552f, -0.04403552f, 0.00985935f, 0.01872078f, 
    0.05084470f, -0.09072565f, 0.04252472f, -0.08295562f, -0.03702390f, -0.00790927f, 0.02716379f, -0.05067316f, 
    0.05878403f, -0.06141800f, -0.04763016f, -0.01296358f, -0.00084809f, -0.05944788f, 0.01036765f, -0.00431321f, 
    -0.00510716f, -0.07232440f, -0.06004006f, -0.08103233f, -0.00532072f, -0.04221053f, -0.06099514f, 0.02041306f, 
    -0.03113718f, -0.08060982f, -0.00736536f, 0.01483427f, -0.02362417f, -0.01513151f, 0.05537015f, -0.04120042f, 
    -0.04274762f, 0.01234357f, -0.03720164f, 0.05224716f, -0.00918975f, -0.06516495f, -0.07039925f, 0.04339727f, 
    -0.04837795f, 0.01615773f, 0.03870408f, -0.04603682f, -0.01190637f, -0.07511804f, 0.02699332f, 0.05341411f, 
    0.02705252f, 0.03993722f, -0.02204677f, 0.03024546f, 0.00334115f, -0.02589780f, -0.05871992f, -0.07927750f, 
    0.02014050f, 0.04243572f, 0.01720392f, 0.04010073f, -0.07710402f, -0.00884454f, -0.03128142f, 0.04325965f, 
    0.00513263f, -0.07101066f, -0.08214803f, -0.05400711f, -0.01754362f, 0.03929302f, -0.07010693f, -0.06382680f, 
    0.08786237f, 0.13337953f, -0.14938870f, -0.37570515f, -0.06263532f, -0.08465234f, -0.10637452f, -0.00214578f, 
    0.01641225f, -0.12568991f, -0.00871858f, -0.03369204f, -0.00577088f, -0.17120492f, -0.17078494f, -0.11031705f, 
    -0.05481860f, 0.05224563f, -0.05405053f, 0.00584956f, -0.00556359f, 0.02793861f, -0.04066778f, 0.06767972f, 
    -0.01036544f, -0.11192701f, -0.02825120f, 0.10734302f, 0.05502244f, 0.01515891f, 0.05149029f, -0.04272494f, 
    0.16145787f, 0.18468979f, 0.11184637f, 0.14302780f, 0.30131337f, 0.01091264f, 0.29016674f, -0.16204627f, 
    0.03990692f, 0.05310955f, -0.00827611f, 0.09422306f, 0.08541737f, 0.13985577f, 0.09136119f, 0.06917138f, 
    -0.07060409f, 0.09679653f, -0.08977540f, 0.04701624f, 0.11435509f, 0.16930354f, -0.02664296f, 0.05504778f, 
    0.00109243f, -0.05174907f, -0.01323278f, -0.01635513f, -0.08624021f, -0.24289846f, -0.03584782f, -0.25518167f, 
    -0.04911178f, -0.10530762f, -0.03362742f, -0.07689577f, -0.01216136f, -0.07215728f, 0.13147786f, 0.08035348f, 
    -0.10682726f, -0.26953718f, 0.11127393f, 0.24366422f, 0.10454420f, 0.06372923f, -0.00642494f, -0.05935793f, 
    -0.07510035f, -0.09751092f, 0.02843604f, -0.02679339f, 0.05787910f, -0.27749658f, -0.25140914f, -0.06147428f, 
    0.17190459f, 0.22091699f, 0.14260857f, -0.08505014f, 0.10897096f, -0.03110517f, -0.07940573f, 0.01478346f, 
    0.15015332f, -0.29840520f, 0.16231543f, 0.09571039f, 0.03986938f, -0.13665120f, -0.10334723f, 0.10505193f, 
    -0.01508589f, -0.04541750f, -0.02651673f, 0.00399593f, -0.05828668f, -0.03750958f, 0.04212527f, 0.11347787f, 
    0.04390502f, -0.01282077f, -0.09467382f, -0.07148144f, 0.01214489f, 0.19691943f, 0.04937466f, 0.09898948f, 
    -0.12864876f, -0.23239742f, 0.20376593f, 0.25040194f, 0.13232671f, 0.01568911f, -0.16083711f, -0.00826961f, 
    0.07539876f, 0.01453868f, 0.04151742f, 0.15387154f, -0.03351271f, -0.03587367f, -0.09837203f, 0.20724306f, 
    0.09449024f, 0.06025494f, -0.04531223f, -0.06812107f, -0.04593064f, -0.04694772f, -0.07743899f, -0.07510842f, 
    0.44211721f, -0.06143359f, 0.00486585f, 0.19074190f, 0.13823619f, -0.11940324f, 0.24800433f, -0.08867653f, 
    -0.08271341f, -0.14540075f, -0.14241433f, 0.03375760f, 0.26456800f, 0.23628706f, 0.13177203f, -0.27670538f, 
    -0.00201016f, -0.00429513f, 0.02486998f, 0.07409143f, -0.11358006f, -0.06198549f, -0.06879288f, -0.02175421f, 
    0.14436848f, -0.00686199f, -0.18735448f, 0.07414205f, -0.03033458f, 0.00037768f, 0.07749116f, -0.00060827f, 
    -0.02329945f, 0.12495814f, -0.01941361f, 0.08901848f, -0.25716919f, 0.16953689f, 0.15460965f, -0.09723091f, 
    -0.15355816f, 0.03255540f, 0.17168559f, -0.05366991f, 0.16007872f, -0.02307158f, 0.07085092f, 0.12668733f, 
    0.04485940f, -0.04751306f, 0.04171665f, 0.05708352f, 0.00286169f, 0.02248810f, -0.01798553f, -0.00528954f, 
    -0.03823428f, -0.03643606f, -0.02975314f, -0.01545774f, 0.00477313f, -0.05118025f, -0.04992407f, -0.03742567f, 
    -0.02384095f, -0.06022898f, 0.02751584f, -0.00265136f, 0.03758391f, 0.02686361f, -0.03987760f, -0.04770019f, 
    0.05316732f, -0.01913667f, 0.01282991f, -0.04908701f, -0.01352334f, 0.03158778f, 0.00378271f, 0.02765100f, 
    -0.00332536f, 0.00700339f, -0.07084445f, 0.04408356f, -0.00076459f, -0.07999729f, 0.01079739f, 0.03303830f, 
    0.05214375f, 0.06220490f, 0.06203931f, 0.05722859f, 0.00057290f, -0.01467232f, 0.06140780f, -0.08176377f, 
    -0.05251512f, -0.05245390f, -0.00921724f, 0.00837473f, 0.02090595f, -0.05282852f, 0.03169640f, 0.01680156f, 
    -0.02888757f, 0.02352595f, 0.05159813f, -0.05441302f, 0.06526297f, -0.02702217f, -0.03345618f, -0.04807557f, 
    0.04451957f, -0.05436890f, -0.07564495f, -0.00592625f, 0.01743731f, 0.05093268f, -0.06904005f, -0.04234166f, 
    0.01791115f, 0.01970800f, 0.06867471f, 0.02456168f, 0.01264588f, 0.01930326f, 0.02278772f, -0.03135545f, 
    -0.05783514f, 0.04051863f, -0.06906340f, -0.06732377f, 0.05735586f, -0.06617352f, -0.03990654f, -0.05854172f, 
    -0.07159275f, -0.01387992f, -0.02413123f, 0.05004787f, -0.07290215f, -0.04066190f, -0.05797394f, 0.06072878f, 
    -0.03139827f, 0.02191183f, -0.02238713f, -0.03245421f, 0.04877551f, -0.03425185f, -0.07731961f, -0.05550767f, 
    0.04402113f, 0.00915375f, -0.07065942f, -0.03564636f, 0.01016809f, 0.03545571f, -0.02334952f, -0.04709725f, 
    0.02535977f, 0.05635094f, 0.03268517f, -0.04697813f, 0.06718536f, -0.04199937f, 0.00066190f, -0.02118374f, 
    0.03749885f, -0.01651465f, -0.05482594f, -0.04596693f, -0.06655345f, 0.06261770f, -0.01120069f, 0.01272339f, 
    -0.07049985f, 0.03738749f, -0.06605099f, 0.05317924f, -0.06727596f, 0.04646832f, 0.00165169f, 0.02815784f, 
    -0.02307390f, -0.01524965f, -0.00785908f, -0.06531978f, 0.04759603f, -0.05108216f, 0.00728645f, -0.06131235f, 
    0.02629779f, -0.03318053f, -0.03946411f, 0.05252924f, 0.01857217f, -0.00945798f, 0.01023516f, -0.07523378f, 
    0.05390114f, 0.04276824f, -0.06924345f, -0.00031107f, -0.03966926f, 0.00395408f, 0.02919343f, 0.01375546f, 
    -0.00594147f, -0.04171007f, 0.03223819f, -0.02468122f, -0.03497244f, 0.00173080f, -0.01582999f, -0.02681886f, 
    -0.05699492f, -0.00054897f, -0.06711465f, -0.07049137f, 0.03323770f, -0.02319414f, 0.03779182f, 0.01705805f, 
    0.05611489f, -0.02888307f, -0.01657233f, -0.01076746f, 0.06996281f, 0.03324706f, -0.00344721f, -0.03146143f, 
    -0.02273844f, -0.07431828f, -0.05182632f, 0.03197717f, 0.05345131f, -0.02989823f, 0.03735716f, -0.05432554f, 
    -0.03332841f, 0.14923421f, 0.04811021f, 0.15158626f, -0.08034855f, 0.16346678f, 0.19895957f, -0.07153138f, 
    -0.09792553f, -0.09993271f, 0.03028532f, -0.05740860f, 0.45475957f, -0.21836421f, 0.15438345f, 0.08185448f, 
    -0.26282671f, 0.06319599f, -0.06278791f, -0.16938126f, 0.14704645f, -0.00699131f, 0.04422201f, 0.13359788f, 
    0.24771625f, -0.01852456f, 0.14707385f, 0.01582864f, -0.08415009f, 0.04509430f, -0.05723306f, -0.02777119f, 
    0.01391044f, 0.02442811f, 0.07404412f, 0.08771043f, -0.14514466f, 0.15108037f, 0.10574769f, 0.12614384f, 
    0.19402727f, -0.11764032f, -0.05085642f, 0.04230905f, 0.06552010f, 0.00205262f, 0.16079333f, 0.10018375f, 
    0.49467891f, -0.03155753f, 0.12061791f, 0.12569691f, -0.05629673f, 0.00479316f, 0.09782576f, 0.17547679f, 
    0.11447802f, -0.08593750f, -0.04648311f, 0.08527289f, 0.26872581f, -0.03166113f, 0.02448118f, -0.10233667f, 
    0.01337771f, -0.08234881f, -0.01156959f, -0.20334055f, 0.13635291f, 0.09905916f, 0.03435006f, 0.02293396f, 
    -0.27346960f, 0.23102108f, -0.19174613f, -0.10946349f, 0.25151458f, 0.11561736f, 0.03414258f, -0.12999664f, 
    0.01204911f, 0.00547187f, -0.01350290f, 0.08580342f, -0.04600228f, -0.08911137f, 0.04906029f, 0.03707689f, 
    -0.08825592f, 0.01532634f, -0.00961326f, 0.32132530f, 0.06823951f, -0.02783817f, -0.07886431f, -0.19048980f, 
    -0.21070878f, 0.04241708f, -0.01524472f, -0.16189353f, 0.03947997f, -0.06316156f, 0.00435913f, -0.13644621f, 
    -0.07255379f, -0.05827865f, 0.01757048f, -0.02644825f, 0.26141381f, 0.12139114f, 0.26226512f, -0.12862019f, 
    -0.03940394f, 0.00899219f, -0.12543568f, -0.29795781f, -0.09798251f, 0.08118353f, -0.12769452f, -0.10569727f, 
    -0.00646895f, 0.18764833f, 0.06458066f, -0.00935665f, -0.09470676f, 0.12692823f, -0.16458586f, 0.04998417f, 
    0.05466177f, 0.02718409f, -0.07612659f, 0.04365178f, -0.04891128f, -0.25081804f, -0.03486256f, -0.17464134f, 
    -0.06779083f, 0.04205765f, 0.11530589f, -0.24387597f, -0.14950089f, 0.03201788f, -0.13301197f, 0.01268662f, 
    -0.42593324f, 0.04600304f, -0.10881597f, -0.09545314f, -0.07745394f, 0.08216426f, 0.00691062f, 0.03677867f, 
    -0.20241106f, -0.09130756f, -0.07447581f, 0.03096970f, 0.21104674f, 0.04278897f, 0.13786486f, 0.16226645f, 
    0.17586538f, 0.03469298f, 0.16561036f, 0.26258177f, 0.01606137f, 0.01322071f, 0.05769537f, 0.03669731f, 
    -0.57162422f, 0.35838622f, 0.13055380f, 0.03541648f, -0.20610273f, 0.12110762f, -0.13030021f, -0.11451607f, 
    -0.05895659f, -0.07377212f, 0.07024816f, 0.13514468f, 0.24758652f, 0.03280236f, -0.03612615f, 0.16696924f, 
    0.06105625f, 0.02339063f, -0.03018873f, -0.07587332f, 0.07115543f, -0.00521914f, -0.08402893f, 0.08554848f, 
    -0.11788738f, -0.08220995f, -0.22715275f, 0.19265543f, -0.01911916f, 0.19490290f, 0.13921754f, 0.03988395f, 
    0.02300147f, 0.10340554f, -0.14920625f, 0.23548217f, 0.20795248f, -0.02593945f, 0.17227730f, -0.08207947f, 
    -0.30735084f, -0.07784233f, 0.05636092f, -0.04690390f, -0.01376896f, -0.13822009f, -0.00257509f, -0.14911351f, 
    0.11882948f, -0.12098028f, 0.21768895f, 0.05280897f, 0.01799508f, -0.10201855f, -0.15397094f, -0.39352012f, 
    -0.02834233f, 0.12575608f, 0.14039019f, 0.02385687f, 0.28429222f, -0.16647452f, -0.14284568f, -0.39230496f, 
    0.00255216f, -0.08793268f, 0.04965936f, 0.13749993f, 0.14304166f, 0.01686624f, 0.14013790f, -0.07961261f, 
    -0.59145164f, 0.15252501f, -0.01559694f, 0.17615682f, 0.21013589f, 0.03739652f, 0.06369053f, 0.37602976f, 
    0.08668214f, -0.16646051f, -0.03136810f, -0.03716407f, 0.32589585f, -0.41177812f, -0.12291449f, -0.32760823f, 
    -0.18389377f, -0.03663829f, -0.21913891f, -0.02348296f, 0.04503367f, 0.10426994f, 0.04011881f, 0.08692700f, 
    -0.09547237f, 0.10761008f, -0.00886012f, 0.10548346f, -0.05276718f, 0.05416742f, 0.11383405f, -0.04048118f, 
    -0.05788680f, 0.18310009f, -0.21347769f, -0.12110762f, -0.03090118f, 0.08211013f, -0.08863346f, -0.06832781f, 
    -0.07139669f, 0.06928486f, -0.00677976f, 0.30640516f, -0.04509923f, -0.10903502f, -0.04996501f, 0.00604079f, 
    -0.04316434f, 0.30176297f, -0.06498589f, -0.01939487f, 0.12514010f, -0.20474282f, 0.01958719f, -0.04004624f, 
    0.10623918f, -0.03033140f, -0.08372469f, 0.14962882f, 0.32071230f, -0.03864154f, 0.25299829f, -0.37749377f, 
    -0.09054761f, 0.18080896f, -0.23569548f, -0.20627265f, 0.14868633f, 0.07986600f, 0.17994167f, 0.10273569f, 
    0.27033156f, 0.33527243f, 0.13088344f, 0.16766511f, -0.09137599f, 0.04534133f, -0.22645751f, -0.19114819f, 
    0.14122476f, 0.06024477f, 0.00704110f, -0.13602632f, -0.15447460f, -0.15055037f, 0.11852811f, -0.15825517f, 
    -0.01181696f, -0.00250357f, 0.00509789f, -0.25995386f, 0.05205677f, 0.27215704f, 0.04871338f, -0.00466792f, 
    -0.12788273f, -0.05834771f, -0.03565700f, 0.07308012f, 0.01985855f, 0.00147800f, 0.00625852f, -0.08243182f, 
    -0.23246232f, -0.00035947f, -0.01868510f, -0.02191877f, 0.19983861f, -0.00818425f, -0.14126083f, -0.16046402f, 
    0.16977412f, 0.12228133f, 0.11575048f, 0.23377560f, 0.23480177f, -0.00394317f, 0.00314696f, 0.05313014f, 
    -0.18994893f, 0.20302303f, 0.07000649f, 0.16001737f, -0.07888233f, -0.02883961f, -0.18648505f, 0.07935190f, 
    -0.07253807f, -0.02449416f, 0.12336624f, 0.02677304f, -0.18334973f, 0.13422598f, -0.13555980f, 0.09563597f, 
    0.15491435f, -0.00823839f, 0.01720247f, 0.11456890f, 0.21058606f, 0.09977330f, -0.04097327f, 0.13169791f, 
    -0.08555122f, -0.07992126f, -0.07347792f, 0.11572637f, 0.04952968f, 0.11810895f, -0.05704183f, 0.07751707f, 
    -0.02633178f, -0.00525230f, -0.10969976f, -0.05487338f, -0.38283730f, 0.29176375f, 0.06284454f, 0.00109484f, 
    0.04853696f, -0.04512294f, 0.01823201f, 0.05558276f, 0.05262365f, -0.00432844f, 0.09329645f, -0.01841989f, 
    0.03819294f, 0.00709838f, -0.12661491f, -0.08258750f, -0.00209149f, -0.11580417f, 0.00448174f, -0.00256631f, 
    0.05969724f, 0.11221492f, 0.10928290f, -0.04258237f, -0.25505453f, -0.18917841f, 0.01844185f, 0.17447789f, 
    -0.00931858f, -0.11648757f, 0.09716195f, 0.00330799f, 0.00933099f, 0.06271046f, 0.11422788f, 0.07543896f, 
    0.21875645f, 0.38966706f, 0.43872261f, -0.29495740f, 0.00006015f, -0.01248582f, -0.07823087f, 0.12045600f, 
    -0.00137891f, -0.04327503f, 0.03051406f, -0.13314778f, 0.18443280f, 0.10121589f, -0.01133630f, 0.16714038f, 
    -0.05239251f, -0.17329729f, 0.04964481f, 0.08265934f, 0.22672532f, -0.09197240f, 0.06474169f, 0.16082512f, 
    0.10187479f, -0.01609530f, -0.06522088f, -0.08050672f, 0.03070806f, -0.03654908f, -0.00704904f, 0.03248721f, 
    -0.06933489f, 0.01659164f, -0.03999989f, 0.02049854f, -0.30806506f, 0.38669673f, 0.20908514f, 0.11897068f, 
    0.06343952f, -0.02750236f, 0.01077400f, -0.14420885f, -0.06992927f, -0.07300029f, 0.06026756f, -0.00602617f, 
    -0.00048301f, 0.10435027f, -0.14323820f, -0.10749392f, -0.10527405f, 0.00214741f, 0.01568393f, -0.12465184f, 
    -0.09423579f, 0.14558540f, -0.14949961f, 0.02402636f, 0.04911814f, -0.08933484f, -0.11214795f, -0.13545913f, 
    -0.03491411f, 0.03819072f, -0.02644364f, 0.12545648f, 0.01798002f, -0.11956087f, -0.06245089f, -0.12602982f, 
    -0.12536113f, 0.20056155f, -0.09685316f, 0.02886849f, 0.04608045f, 0.10000176f, 0.09736060f, 0.08837398f, 
    0.05790629f, 0.16956954f, -0.01338953f, -0.04469551f, 0.07833711f, -0.04253221f, 0.07358049f, -0.03897460f, 
    -0.09934551f, -0.00021276f, 0.02635038f, -0.00374693f, 0.02855569f, 0.01686513f, -0.05277481f, -0.04687256f, 
    -0.19297807f, 0.00384843f, 0.18424605f, 0.10473780f, -0.13163477f, 0.08012848f, -0.02029402f, -0.00553347f, 
    -0.00636155f, 0.07226250f, 0.02749220f, 0.10041965f, -0.28524247f, -0.05498874f, 0.03003959f, 0.34430686f, 
    -0.09900989f, -0.05991097f, -0.00767841f, -0.01574895f, 0.05521106f, 0.01087787f, 0.00123925f, -0.01064805f, 
    0.11308403f, -0.00255182f, 0.13382190f, -0.07329781f, 0.05311051f, -0.09222162f, -0.07848994f, 0.09429643f, 
    0.16186041f, -0.07540709f, 0.10136609f, -0.06078583f, 0.14435071f, -0.18436249f, -0.12176108f, 0.16305509f, 
    0.16363648f, -0.01001213f, 0.01737186f, 0.07319925f, 0.02599801f, 0.01277074f, -0.00089502f, 0.07392053f, 
    0.02408559f, 0.01542958f, -0.18701525f, -0.07794826f, -0.03181231f, -0.25943974f, 0.06780551f, -0.17142367f, 
    -0.16064285f, -0.15431648f, 0.00299599f, -0.03170841f, 0.41328889f, -0.00157237f, 0.27334476f, -0.00232672f, 
    -0.00560865f, 0.04554765f, 0.11835825f, -0.09082668f, 0.05116460f, 0.19300048f, 0.13745333f, 0.05840840f, 
    0.11940271f, 0.06071031f, 0.13489726f, 0.07412255f, -0.06598575f, 0.03316303f, -0.08683755f, -0.11868231f, 
    0.34109420f, 0.04677397f, 0.07028690f, 0.09263780f, -0.47196999f, -0.10634912f, 0.19062053f, -0.21763687f, 
    -0.13755845f, 0.08847682f, 0.01009474f, 0.01979660f, 0.06847049f, 0.04102549f, -0.03886880f, -0.03599197f, 
    0.27724028f, 0.13865902f, 0.18086442f, 0.34424698f, -0.07506095f, -0.00144861f, 0.12999673f, -0.04183134f, 
    -0.03108725f, -0.06275927f, -0.03449428f, 0.01234597f, -0.20260482f, -0.41291827f, -0.09190961f, -0.53307617f, 
    -0.06769294f, -0.00159495f, -0.06169889f, 0.10789681f, 0.01471707f, -0.18732612f, 0.14585303f, 0.06897770f, 
    -0.06986789f, 0.21460883f, 0.11367773f, 0.10534456f, 0.03401663f, -0.04331318f, 0.00131380f, -0.08632714f, 
    0.01812454f, -0.13415073f, 0.05923862f, 0.03436552f, 0.10412402f, -0.15832065f, 0.01714462f, -0.00817795f, 
    -0.09954157f, 0.00439421f, 0.11112812f, 0.16725181f, 0.03406706f, 0.10790535f, -0.09252217f, -0.10960187f, 
    -0.08687451f, 0.06976318f, 0.11398354f, 0.04212153f, -0.12442321f, -0.15438046f, -0.00642331f, 0.02217943f, 
    -0.08257066f, -0.00323207f, 0.13032578f, 0.09655076f, 0.22884737f, 0.13828841f, 0.12158585f, 0.01552293f, 
    -0.01684167f, -0.07389619f, -0.08073766f, -0.09101088f, 0.11616006f, 0.07055667f, 0.03671818f, 0.03459037f, 
    0.02698747f, 0.12151199f, 0.21109354f, 0.23686355f, -0.00170965f, 0.30385464f, -0.08357183f, -0.05436948f, 
    0.07515295f, -0.12157981f, 0.03720128f, 0.16601133f, 0.12184316f, 0.10274463f, 0.04302014f, 0.03642852f, 
    -0.02228568f, -0.00964248f, -0.11231213f, 0.00033066f, -0.13755968f, -0.09572962f, -0.04483597f, -0.10773505f, 
    0.52019799f, 0.37585381f, -0.16279638f, 0.09359510f, -0.05509844f, -0.05944169f, 0.09275315f, 0.08440021f, 
    0.02353694f, -0.05963448f, -0.07008243f, -0.03945629f, -0.09489762f, -0.22272977f, -0.36877039f, -0.21334878f, 
    0.14699669f, -0.11284105f, 0.01515662f, 0.25343320f, -0.00914182f, 0.02343026f, -0.03236702f, -0.09999027f, 
    0.15246227f, 0.19752032f, -0.08364402f, 0.06442615f, -0.15659055f, 0.05986266f, 0.22820798f, -0.08525028f, 
    0.23568174f, 0.20118447f, 0.04150702f, 0.04315464f, -0.48262876f, -0.13174807f, -0.18579364f, -0.06214803f, 
    0.05709523f, -0.01864608f, 0.05434217f, 0.01430975f, -0.12271529f, -0.14203283f, 0.14452145f, 0.07237934f, 
    0.29895747f, 0.14385965f, 0.13667822f, -0.00856842f, -0.04831580f, -0.09909914f, 0.11777665f, -0.00730180f, 
    -0.09391449f, 0.08503582f, -0.08531020f, -0.16037956f, 0.01063005f, -0.04935556f, -0.34260812f, -0.23064706f, 
    0.04379771f, 0.00579001f, 0.00964734f, -0.00281588f, 0.12351608f, 0.02846814f, 0.06651886f, 0.03884644f, 
    -0.15867004f, -0.28650001f, -0.14633441f, -0.24150373f, 0.17011291f, 0.03857621f, 0.06546822f, -0.16460855f, 
    -0.02411905f, 0.07817142f, -0.10460718f, 0.17430057f, 0.29555541f, 0.08933637f, 0.23810180f, 0.16940655f, 
    -0.04631353f, 0.12268904f, -0.00413354f, 0.18155950f, -0.06590723f, -0.02839075f, -0.03177416f, 0.13757871f, 
    0.05308916f, 0.25224870f, -0.09800955f, 0.10782181f, 0.08052996f, 0.06229826f, -0.05203982f, 0.20156065f, 
    -0.08988211f, -0.03734829f, -0.03406902f, -0.00451402f, -0.00111084f, -0.31915873f, 0.05136805f, 0.02948669f, 
    0.12747164f, 0.07446314f, -0.06365719f, 0.02626081f, 0.01241211f, 0.08220608f, -0.00689671f, 0.17512210f, 
    -0.10439134f, -0.16084120f, -0.29721859f, -0.12166542f, -0.01398850f, -0.06674755f, 0.10890207f, -0.03604567f, 
    -0.12465417f, -0.03771564f, -0.01682087f, -0.00160092f, -0.03835620f, -0.07008615f, -0.28160214f, -0.08555785f, 
    -0.10371090f, 0.05949653f, 0.15579453f, 0.08970879f, 0.08178726f, 0.02721437f, 0.03508333f, 0.09763989f, 
    -0.11081874f, -0.15710345f, -0.14394082f, 0.03888043f, 0.05169350f, -0.03209335f, 0.05927254f, 0.00096625f, 
    0.01835879f, 0.07402986f, -0.02477745f, 0.02782294f, -0.17697847f, -0.44776973f, -0.12867776f, -0.28947794f, 
    0.10949440f, 0.28641531f, 0.07977884f, -0.09268557f, 0.17752087f, 0.21793728f, -0.00751407f, 0.19176641f, 
    -0.29097846f, 0.07965613f, -0.15414017f, -0.01505991f, 0.15281054f, 0.14148119f, 0.23891269f, 0.02575182f, 
    0.06047201f, -0.04021821f, 0.00780445f, 0.03478372f, -0.46987063f, -0.39836448f, 0.01241519f, 0.02058707f, 
    -0.06874216f, 0.01673403f, -0.17624867f, 0.03247889f, 0.13240334f, 0.00107508f, -0.09691148f, -0.22327448f, 
    0.23362039f, -0.24747695f, 0.06394460f, -0.07570419f, -0.07653935f, -0.18381456f, 0.06223793f, 0.04253490f, 
    0.04337020f, -0.04757328f, 0.19773170f, -0.05068192f, 0.33254322f, 0.15754887f, 0.16483851f, 0.00754438f, 
    0.04840691f, -0.01989545f, 0.05816089f, 0.06070466f, -0.05040076f, -0.15536427f, -0.00798111f, -0.07771927f, 
    0.03453318f, -0.21041179f, -0.21751323f, 0.12508672f, -0.23280808f, -0.09433863f, -0.24059436f, 0.16071698f, 
    0.02560762f, 0.16265061f, 0.08219518f, -0.04349888f, 0.18067618f, 0.35606596f, 0.30668917f, 0.06104264f, 
    0.04251418f, 0.18679048f, -0.03410690f, 0.10935547f, -0.05157463f, -0.03338657f, -0.01450312f, 0.17572132f, 
    -0.08819633f, 0.14694898f, -0.11073055f, -0.08107972f, -0.05937752f, -0.03272510f, 0.03828373f, -0.11789147f, 
    -0.18467200f, -0.11788166f, 0.02850322f, 0.03176321f, 0.18127270f, -0.16960421f, -0.05180029f, -0.01839697f, 
    -0.14145084f, 0.09153424f, -0.09500269f, -0.02666486f, -0.06853926f, -0.09029534f, 0.03066080f, 0.02146243f, 
    -0.09495477f, -0.07235993f, -0.02349940f, 0.00425070f, -0.06259909f, 0.00734781f, -0.11922965f, -0.05727455f, 
    0.12346026f, 0.05162833f, -0.03768658f, -0.07892820f, 0.08487032f, 0.13758619f, 0.10934879f, -0.09109048f, 
    0.08695238f, -0.03678524f, -0.05227889f, -0.02946052f, -0.02870755f, -0.00728738f, -0.08946022f, -0.13253231f, 
    0.03084401f, -0.10051413f, -0.22535886f, -0.15041372f, -0.12254509f, -0.08978540f, -0.01292770f, -0.12915303f, 
    -0.11264245f, -0.08698731f, -0.14754874f, -0.13754867f, -0.10975338f, 0.12170871f, -0.17570879f, -0.29284585f, 
    -0.05577108f, -0.02308202f, 0.04780680f, -0.08312001f, 0.07439715f, -0.11289924f, -0.02257955f, -0.17668486f, 
    -0.05835804f, -0.03170201f, 0.20755020f, 0.16332626f, -0.03597343f, 0.02644133f, -0.00078741f, 0.00760933f, 
    0.12887785f, -0.11445543f, 0.05271341f, -0.09829546f, 0.19575065f, -0.05936756f, 0.16077764f, -0.01755395f, 
    0.07350242f, 0.07226847f, 0.00616410f, -0.01366218f, -0.00824009f, -0.00018790f, -0.03259141f, 0.00278734f, 
    0.00807248f, -0.12230545f, 0.00960614f, -0.01514195f, -0.14397028f, -0.05088516f, 0.05378287f, -0.07231588f, 
    -0.09913245f, -0.10875863f, 0.00770574f, 0.02725655f, -0.16337307f, 0.07495365f, -0.04366926f, 0.16105641f, 
    -0.08568692f, -0.02803110f, -0.15386297f, -0.01996507f, 0.01960635f, -0.10155427f, -0.04874705f, -0.02888389f, 
    0.01795718f, -0.28714523f, 0.10477105f, 0.18502009f, -0.14343734f, -0.01115714f, 0.00940232f, -0.06408796f, 
    0.04009317f, -0.06689128f, -0.07195793f, 0.02680505f, 0.06472926f, 0.02004712f, -0.05619985f, 0.04420049f, 
    -0.02099837f, -0.01113041f, 0.00736745f, -0.09871140f, -0.12514435f, -0.00092857f, 0.01128516f, 0.09236749f, 
    0.37340805f, 0.00521598f, 0.15438227f, -0.02038263f, 0.04222402f, -0.14208418f, 0.02183705f, 0.00722588f, 
    -0.03614497f, -0.04030441f, -0.12658669f, -0.00962292f, 0.12909538f, 0.18156266f, 0.11552639f, -0.03923397f, 
    -0.13938053f, -0.07193045f, -0.04878730f, -0.11133479f, -0.04277799f, -0.04879283f, -0.06485131f, 0.04157112f, 
    0.09171559f, -0.12140758f, -0.00012010f, -0.00890112f, 0.02462999f, -0.01249742f, 0.13035890f, -0.11729552f, 
    -0.02992496f, -0.10071943f, 0.00633888f, 0.01092741f, -0.28590900f, -0.01096610f, -0.04638022f, -0.08779670f, 
    -0.00973885f, 0.01957754f, -0.03634851f, -0.05162570f, -0.05459987f, -0.04155091f, -0.04878975f, -0.03647998f, 
    0.05786355f, -0.06287044f, -0.00273238f, -0.00306330f, -0.02749532f, 0.06211450f, -0.01792223f, 0.05217284f, 
    0.02655060f, 0.01820310f, -0.06272451f, -0.05114162f, -0.02719842f, 0.01544933f, -0.00529210f, -0.02383771f, 
    -0.00530043f, 0.01325874f, 0.05864708f, 0.05659737f, -0.07196607f, -0.02669653f, 0.04420260f, 0.05104325f, 
    0.02710291f, 0.05007892f, -0.07868604f, -0.00019260f, 0.03928682f, -0.04234261f, 0.03907413f, -0.03794174f, 
    -0.04880009f, -0.04260315f, -0.06800107f, 0.02393746f, -0.00207507f, -0.03787466f, -0.05014424f, -0.02114742f, 
    0.05073802f, -0.06240932f, 0.05476985f, -0.03162765f, 0.04807516f, 0.04719964f, -0.03384014f, -0.03907332f, 
    -0.02029946f, -0.05783215f, 0.01896621f, 0.01415921f, 0.01300010f, 0.02956266f, -0.01144028f, -0.06838873f, 
    -0.02038846f, -0.04561058f, 0.06008283f, 0.02643580f, -0.00726121f, 0.00882312f, -0.00679534f, 0.05166765f, 
    -0.05241169f, -0.04950044f, 0.05980470f, 0.01239311f, -0.05149192f, -0.05572785f, 0.02223038f, -0.03993674f, 
    0.00337567f, 0.00291712f, -0.00017314f, 0.03919844f, 0.02970946f, -0.04364653f, -0.01691125f, 0.04657384f, 
    -0.04535592f, -0.01974740f, -0.02703636f, -0.07271086f, 0.02517959f, -0.07478364f, -0.06739295f, -0.07402327f, 
    -0.02424752f, -0.07221752f, -0.04759572f, -0.07770389f, 0.03368833f, -0.03754886f, -0.04413733f, -0.04309864f, 
    -0.06480674f, -0.04003007f, -0.01298781f, -0.05731392f, 0.05670125f, 0.05651769f, -0.00313799f, 0.04346745f, 
    -0.05251089f, -0.04418902f, 0.05266771f, -0.07635912f, -0.01452839f, -0.01159702f, 0.01664137f, 0.03961235f, 
    -0.01326172f, -0.01350238f, -0.01695615f, -0.03421482f, -0.02460511f, 0.05250103f, 0.02189879f, -0.06184839f, 
    0.04358844f, -0.06318986f, -0.05623567f, -0.00317884f, 0.04174163f, 0.00370611f, -0.05620612f, 0.01164370f, 
    0.05275766f, -0.00164148f, 0.03554379f, 0.01442291f, 0.05583780f, 0.05301679f, -0.06064407f, 0.05311505f, 
    0.00479444f, -0.05407906f, -0.04334103f, 0.05577759f, -0.03394037f, -0.07558931f, -0.03424129f, -0.00726606f, 
    -0.01647146f, 0.04601043f, 0.03138009f, -0.07309047f, -0.03440607f, 0.01569949f, 0.01711875f, -0.05615082f, 
    0.01282177f, -0.00041085f, 0.05633926f, -0.03203489f, 0.06819023f, -0.01732557f, -0.03584021f, -0.05330640f, 
    -0.06031362f, -0.01763105f, 0.03759684f, 0.05572783f, 0.00774231f, -0.06758203f, -0.05136541f, 0.00106583f, 
    -0.01708623f, 0.00345511f, -0.03682141f, -0.01175736f, 0.04798724f, 0.02695622f, -0.04493997f, 0.06562004f, 
    -0.06580591f, -0.07688173f, -0.06344146f, -0.00384638f, -0.05537525f, -0.05269751f, -0.00740183f, 0.02243272f, 
    -0.05903663f, -0.06750966f, -0.02912392f, -0.04706900f, -0.02871918f, -0.05833944f, -0.05135392f, -0.00965595f, 
    0.00419161f, -0.12396677f, 0.05211845f, 0.07087820f, -0.03290050f, -0.16522622f, -0.04357494f, -0.19379014f, 
    -0.02184671f, -0.12120707f, -0.18801406f, -0.19356261f, 0.15481730f, -0.02853177f, 0.11873032f, 0.15311073f, 
    -0.09542696f, 0.11496098f, 0.06459454f, -0.03852842f, -0.02070851f, 0.12024200f, 0.15101013f, 0.15327641f, 
    -0.19140659f, -0.05880566f, -0.15046996f, -0.20108750f, 0.05269695f, -0.03591875f, 0.20187134f, 0.08431629f, 
    0.03166476f, 0.16649869f, 0.14219733f, 0.23407970f, -0.27380106f, -0.08866654f, -0.12532163f, 0.06710271f, 
    0.09606487f, -0.08590031f, 0.04632593f, -0.02373480f, 0.00069353f, 0.08282136f, 0.00638962f, 0.04894197f, 
    0.24419814f, 0.01260855f, 0.53278774f, 0.19041030f, -0.23996876f, -0.15772644f, 0.11286018f, -0.10881418f, 
    0.16306637f, 0.00674144f, 0.08430344f, 0.21085887f, 0.19905716f, 0.14065741f, 0.28420362f, 0.28356275f, 
    -0.04704275f, 0.00229826f, 0.06984492f, 0.04858650f, -0.09872262f, 0.08793080f, 0.00010138f, 0.07827775f, 
    0.03277417f, 0.13603139f, -0.19943923f, -0.22520743f, 0.12778185f, 0.02921218f, 0.00252153f, -0.10040648f, 
    0.05919921f, -0.02532985f, -0.09426602f, 0.09094337f, -0.23346725f, -0.07603392f, 0.16404082f, 0.20150609f, 
    -0.06205874f, -0.03836587f, -0.10632976f, 0.16374035f, -0.05278022f, -0.17070279f, -0.01745304f, -0.13459940f, 
    -0.06238172f, 0.19775568f, -0.03004735f, -0.06055496f, 0.21057257f, -0.02494580f, -0.08593274f, 0.01258635f, 
    0.00939274f, -0.12892215f, 0.13507673f, -0.02978101f, 0.16019091f, 0.03363555f, 0.11545510f, -0.08846028f, 
    0.18289478f, 0.04046454f, 0.20292254f, -0.03741290f, -0.31332394f, 0.07415570f, -0.04677679f, -0.05839735f, 
    -0.06144112f, 0.23784348f, -0.12433986f, -0.08385997f, 0.04920775f, 0.16846235f, -0.11444515f, 0.00018046f, 
    0.04986196f, 0.14987843f, 0.11561016f, 0.19128579f, 0.19779299f, -0.06899343f, -0.14146076f, -0.18644245f, 
    -0.12690407f, 0.08404800f, 0.00628935f, -0.27646941f, -0.13747983f, -0.17735288f, -0.06056509f, -0.12344579f, 
    -0.38541758f, 0.15184446f, 0.19225298f, 0.01777788f, 0.15976878f, 0.13832738f, 0.06865498f, -0.09519618f, 
    -0.06332985f, -0.11156792f, 0.05340043f, 0.13544615f, -0.03926748f, -0.29576895f, -0.13549718f, -0.04332775f, 
    0.05501601f, -0.03280555f, 0.06338685f, 0.17947905f, 0.06399503f, 0.04865569f, 0.01272878f, -0.05422305f, 
    -0.63355422f, 0.23237136f, 0.13530549f, -0.05960029f, -0.15834144f, 0.14532885f, -0.14923173f, 0.01191618f, 
    -0.05736104f, 0.18890755f, 0.07897242f, 0.23624995f, 0.34770459f, -0.05097408f, -0.12010603f, -0.00618594f, 
    0.11688071f, 0.09164169f, 0.05558328f, -0.01986221f, 0.03567622f, -0.00264760f, 0.13308953f, 0.28110650f, 
    -0.02216319f, -0.00348480f, 0.03481900f, -0.04458028f, 0.02616070f, -0.00377529f, 0.01330323f, -0.00405391f, 
    -0.03885312f, 0.02874311f, 0.00546360f, 0.03824946f, -0.07254946f, 0.04022264f, -0.00017521f, 0.06002335f, 
    -0.01919291f, 0.03823536f, -0.00294484f, 0.02132329f, -0.03997852f, 0.06168046f, -0.02185571f, -0.04509556f, 
    -0.00299880f, 0.00066210f, -0.01631027f, -0.07490765f, 0.01460915f, -0.00553594f, -0.03193456f, 0.05436967f, 
    0.02132526f, -0.01870293f, 0.00642902f, -0.07258021f, 0.06128349f, -0.03646444f, 0.00250794f, -0.07474165f, 
    -0.00889900f, -0.04256223f, -0.05993399f, 0.02910590f, 0.01929904f, -0.04574328f, -0.03136300f, -0.02285194f, 
    -0.02441211f, -0.05901529f, -0.07254530f, 0.00219986f, -0.06706192f, 0.02883167f, -0.01301286f, 0.00358152f, 
    0.04875298f, -0.03062144f, -0.07145218f, 0.05743016f, -0.01678021f, -0.04090960f, -0.01526588f, 0.04790720f, 
    -0.02409500f, 0.06288713f, -0.05015838f, -0.00348961f, 0.01727173f, -0.08001596f, 0.03351181f, 0.02250681f, 
    -0.04992958f, -0.00219385f, 0.04414770f, -0.02877662f, 0.03203015f, -0.07257818f, -0.03616605f, -0.04995817f, 
    0.02390799f, -0.02975974f, 0.00008690f, -0.07462303f, -0.03294533f, -0.00087288f, 0.04839745f, -0.04896764f, 
    0.01225330f, -0.04694560f, -0.05243746f, 0.01020035f, -0.05028147f, -0.06677370f, -0.07425042f, -0.06935553f, 
    -0.05807701f, 0.03226871f, -0.00443877f, -0.01811375f, -0.04615983f, 0.02442609f, 0.06374140f, -0.06125925f, 
    0.03770313f, -0.05441604f, 0.02995000f, 0.00214040f, 0.03855804f, -0.03607178f, 0.06009864f, -0.04755216f, 
    -0.00251141f, -0.00482672f, -0.06560908f, 0.00296769f, -0.07926449f, 0.00330238f, -0.00813769f, -0.06304254f, 
    0.00381035f, 0.04017819f, -0.04925347f, -0.05072514f, 0.06098430f, 0.03923242f, -0.05310973f, 0.03521804f, 
    0.05574505f, -0.00010146f, 0.03700560f, -0.05425956f, 0.01792691f, -0.07459962f, -0.05298063f, -0.01828125f, 
    -0.04787066f, 0.04911393f, 0.04031004f, -0.07002068f, -0.07002019f, 0.06115932f, -0.03337356f, -0.04533557f, 
    0.02672397f, -0.01761630f, -0.03248888f, -0.03823034f, -0.00370234f, -0.07661963f, -0.05149322f, -0.06677908f, 
    -0.00998733f, -0.06518430f, -0.05387976f, -0.04049341f, 0.05607605f, -0.07073817f, -0.04950346f, -0.02301581f, 
    0.02542080f, 0.04224984f, 0.00212887f, 0.01295478f, 0.00024934f, 0.00491749f, 0.01803181f, -0.00471220f, 
    -0.03174968f, -0.04944888f, 0.03059877f, 0.05033896f, 0.06253634f, -0.02220751f, 0.02878957f, -0.05528195f, 
    0.03154353f, 0.02112664f, 0.02756568f, 0.01117497f, -0.07872377f, 0.00915732f, -0.06300644f, -0.07817290f, 
    -0.00966591f, -0.07169189f, 0.02035438f, -0.06264397f, -0.00962181f, -0.04143924f, -0.02329713f, -0.06110818f, 
    0.03318711f, 0.03866163f, -0.00231318f, -0.04252708f, -0.00123343f, 0.05280774f, 0.02122983f, -0.01916791f, 
    -0.00412105f, -0.06201140f, 0.04965777f, 0.05490122f, -0.03820539f, -0.05976153f, -0.00508706f, 0.02899233f, 
    0.00379838f, -0.01480802f, 0.05421890f, -0.05457677f, 0.05369292f, -0.07669410f, -0.07882503f, 0.04823252f, 
    0.04952032f, -0.06653946f, 0.00940982f, -0.00464269f, 0.04251616f, -0.03717159f, -0.07406341f, 0.05271881f, 
    -0.08159094f, 0.01792173f, -0.04540101f, -0.02256111f, -0.06302202f, 0.04346048f, -0.04501589f, -0.04717280f, 
    -0.04066674f, 0.02667221f, -0.04221222f, -0.02437394f, -0.01716680f, -0.03103640f, -0.04518937f, -0.04171204f, 
    0.03878063f, -0.03353789f, -0.06952433f, 0.06031284f, -0.03079631f, -0.05012964f, -0.02331041f, 0.03670447f, 
    -0.05103026f, -0.00433741f, -0.05297745f, 0.01743543f, 0.05377609f, -0.06894763f, -0.00795197f, -0.02158712f, 
    0.00237589f, 0.07793971f, -0.02111212f, 0.01371110f, 0.02671942f, 0.04794018f, -0.05027258f, -0.02251970f, 
    0.04952316f, 0.01607143f, 0.04828997f, -0.05482540f, -0.07461143f, -0.01490170f, 0.00819150f, -0.03545820f, 
    0.03725096f, -0.05181281f, 0.03800655f, -0.08262214f, -0.03790522f, 0.01061702f, -0.07022054f, -0.07065216f, 
    -0.06069686f, -0.06209001f, -0.06103330f, -0.06912019f, -0.03865064f, -0.02475053f, -0.02359442f, 0.01337375f, 
    0.04921870f, 0.06088110f, 0.04935483f, 0.03590494f, 0.01519342f, -0.07800706f, -0.06339882f, -0.00336272f, 
    -0.02482417f, 0.02866256f, 0.04506383f, -0.06751762f, -0.07495092f, -0.02679432f, -0.05530891f, -0.06456746f, 
    -0.08116320f, -0.01395221f, -0.04262112f, -0.02915574f, 0.02722878f, 0.02945203f, 0.04447800f, -0.05705304f, 
    -0.05871805f, 0.07215895f, -0.06503861f, -0.02195975f, 0.07690260f, -0.02390186f, -0.03176437f, -0.04534231f, 
    -0.06767418f, -0.04496524f, -0.00877687f, 0.01611776f, 0.01596854f, -0.02874297f, -0.01342580f, -0.03585325f, 
    -0.06519950f, 0.02131606f, -0.02912318f, 0.04751258f, 0.05657633f, 0.05943704f, -0.02701565f, 0.03428256f, 
    -0.00162198f, -0.05357156f, 0.01061879f, 0.04260259f, -0.01249172f, -0.07900202f, -0.06837752f, -0.00572799f, 
    0.01533653f, -0.00910966f, -0.05914566f, -0.04742666f, 0.01826426f, -0.04067644f, 0.04458302f, 0.04716600f, 
    0.04328330f, 0.02017126f, -0.05225534f, -0.06885052f, -0.05202123f, 0.02987797f, 0.07025658f, -0.03116098f, 
    0.00937540f, 0.05242965f, 0.05181645f, -0.07433551f, 0.02503869f, -0.03140037f, -0.02701203f, -0.01661852f, 
    0.02532316f, -0.05539354f, 0.06997121f, 0.03029449f, -0.00358857f, -0.01623088f, -0.03546060f, 0.02342536f, 
    -0.05448445f, -0.03971538f, -0.05235820f, 0.04161082f, -0.00445383f, -0.05480325f, 0.06684047f, 0.03685357f, 
    0.05700781f, 0.03504328f, -0.02244248f, -0.00206117f, -0.03103975f, 0.01093637f, 0.03861670f, -0.06598632f, 
    -0.06371158f, 0.04957229f, -0.00096577f, -0.05968442f, 0.04393625f, -0.04043282f, -0.03668639f, -0.03576403f, 
    -0.02226597f, 0.01140254f, -0.06322182f, 0.00951707f, -0.03050130f, -0.00778198f, 0.04107160f, 0.02928244f, 
    0.05050034f, -0.02554878f, -0.05271275f, 0.04082507f, -0.03546805f, 0.05223238f, -0.05941672f, -0.01353160f, 
    -0.07170823f, -0.04229870f, -0.00356110f, 0.01134042f, -0.05235153f, -0.04502726f, 0.04929348f, -0.04907363f, 
    -0.01247703f, -0.06739784f, -0.00551830f, -0.03389239f, -0.02899797f, -0.05204098f, 0.01994869f, -0.06075406f, 
    0.00100917f, -0.05527142f, 0.03142908f, -0.05132382f, -0.07066415f, -0.07459173f, 0.01550251f, -0.02432599f, 
    -0.03309375f, 0.00976130f, -0.01338485f, 0.03366824f, -0.02588313f, 0.01193193f, 0.00187819f, -0.07709774f, 
    -0.00373667f, 0.01716501f, -0.05539246f, 0.00631414f, -0.00460766f, 0.00306980f, 0.04390594f, -0.06519587f, 
    -0.05545553f, -0.01943580f, -0.05778990f, 0.05004356f, -0.07469030f, 0.01353769f, -0.02753318f, -0.04132073f, 
    -0.04880884f, 0.06509478f, 0.05486467f, -0.05795273f, -0.00730402f, -0.05258734f, 0.04602319f, -0.07781881f, 
    0.03648623f, 0.05997537f, 0.05072315f, -0.05205594f, -0.04037261f, -0.03347709f, 0.00387977f, -0.04541431f, 
    0.00911099f, -0.02863498f, -0.05212983f, -0.04752196f, 0.05888770f, -0.03753170f, 0.01314955f, -0.03969685f, 
    0.04398472f, 0.06227472f, 0.05707233f, 0.00171437f, 0.05797273f, -0.06113873f, -0.03106670f, 0.03064232f, 
    0.00826749f, 0.03955685f, 0.04096526f, -0.06242007f, -0.02786520f, 0.03644574f, -0.02489560f, -0.05564282f, 
    0.00932889f, 0.00453126f, 0.05216439f, -0.02599793f, -0.00873748f, 0.02702595f, 0.04133640f, -0.02638077f, 
    0.00373646f, 0.05386143f, 0.00129116f, -0.04111189f, -0.03653406f, 0.05522411f, -0.00606771f, -0.07788976f, 
    -0.04639553f, 0.02476877f, 0.00773549f, 0.03017293f, 0.05994108f, -0.04823339f, 0.02142019f, 0.03355757f, 
    -0.04362619f, -0.03685168f, 0.00119422f, -0.04994386f, 0.00718164f, -0.00512578f, -0.06876548f, -0.02992756f, 
    -0.02580321f, 0.03965158f, -0.06718829f, -0.03421777f, 0.01482573f, -0.04507810f, -0.03805659f, 0.03787259f, 
    -0.06739599f, -0.03860737f, -0.05530298f, -0.00055797f, 0.03605000f, -0.06312803f, -0.03729063f, -0.00716397f, 
    -0.00320581f, 0.00171407f, -0.05150004f, -0.01872616f, -0.01251050f, -0.03271213f, -0.02935513f, -0.05299385f, 
    -0.03765112f, 0.04855389f, 0.02310307f, 0.05679160f, -0.05278977f, 0.00771993f, 0.02563712f, -0.04228330f, 
    0.04565973f, 0.00997685f, -0.05085423f, -0.06451620f, 0.00351623f, -0.06972824f, 0.01072527f, -0.06833559f, 
    0.16230509f, 0.02132038f, 0.10144807f, -0.06478900f, -0.18345243f, -0.13577890f, -0.12878376f, 0.06141990f, 
    -0.04915588f, 0.01727259f, -0.05493417f, -0.14563468f, -0.13649215f, 0.11098986f, -0.34727666f, 0.23454468f, 
    0.10226067f, 0.03758069f, 0.17455098f, -0.01086641f, 0.03980625f, 0.03566871f, 0.10101871f, 0.18441330f, 
    -0.04894982f, 0.01446943f, -0.16729255f, -0.05299899f, 0.04049290f, 0.00720361f, -0.04049073f, -0.02908703f, 
    -0.04483107f, 0.05903380f, 0.10348295f, 0.08239473f, 0.07979617f, 0.10338492f, -0.08808570f, 0.08831690f, 
    -0.01215634f, 0.22169614f, 0.16224374f, 0.05963496f, 0.01659394f, -0.05029500f, -0.00733059f, 0.12389022f, 
    0.04395058f, -0.24473782f, 0.06347414f, 0.26112667f, -0.12256566f, -0.08587153f, -0.05630518f, -0.06059080f, 
    -0.11868332f, 0.07702121f, -0.00984669f, 0.16684432f, 0.06554970f, -0.11874820f, 0.10630316f, 0.08417726f, 
    0.02742369f, 0.13906547f, -0.06843863f, -0.03626979f, -0.13332777f, 0.07600521f, 0.07754961f, 0.20031929f, 
    0.14381360f, -0.07192359f, 0.02896737f, -0.17659600f, 0.02687155f, -0.06012923f, 0.02345883f, -0.10631694f, 
    -0.03459504f, -0.12706235f, 0.03231231f, 0.09009932f, -0.00582117f, -0.28122163f, -0.11644241f, 0.02104749f, 
    -0.04794477f, 0.02106572f, 0.01218248f, 0.01158684f, -0.06266057f, -0.03517716f, -0.06930038f, 0.03241667f, 
    0.18174471f, -0.22880141f, 0.20793755f, -0.05358118f, -0.05099216f, -0.00225326f, 0.01851434f, 0.06957764f, 
    -0.08990110f, -0.10018067f, -0.04845471f, 0.07081462f, -0.13515437f, -0.03252568f, -0.04378897f, 0.00182551f, 
    0.02015248f, -0.07974429f, 0.10302795f, 0.08305805f, -0.14394028f, -0.02014287f, -0.00849269f, -0.03309562f, 
    0.11315822f, 0.08357360f, -0.28144950f, -0.01881388f, -0.02262103f, 0.03635761f, 0.04984771f, -0.08317941f, 
    -0.01628706f, 0.06288092f, 0.13690360f, -0.02726335f, 0.18090819f, 0.17305006f, 0.04512759f, 0.06336137f, 
    -0.12966110f, -0.06343672f, -0.07643557f, -0.06865291f, -0.10630593f, -0.11268637f, -0.10518712f, -0.19356985f, 
    0.03290658f, -0.12564684f, 0.26458284f, 0.01594681f, 0.01894417f, -0.15496482f, 0.05827966f, -0.06821297f, 
    -0.09151889f, -0.17943597f, 0.10879021f, -0.06161026f, -0.00966588f, -0.06544302f, -0.15843727f, -0.23530802f, 
    -0.07757668f, 0.01971147f, -0.02276913f, -0.09714624f, -0.06908839f, -0.16191848f, -0.01129239f, -0.07272641f, 
    -0.02002966f, -0.18526854f, 0.21264441f, 0.00965976f, -0.07911339f, -0.04517941f, -0.00958846f, -0.01214319f, 
    -0.24700990f, 0.21368572f, 0.11215762f, 0.12691176f, 0.29249877f, 0.09258455f, 0.08412809f, -0.17393799f, 
    0.11048816f, 0.31337494f, -0.01316338f, -0.06666773f, 0.00096192f, -0.02520140f, -0.03517625f, 0.09111920f, 
    -0.03425713f, -0.20317119f, -0.05330355f, -0.02435186f, 0.07534702f, -0.07647691f, -0.06447043f, 0.02637675f, 
    -0.05279468f, -0.02253021f, -0.14124347f, -0.08469490f, -0.34740219f, 0.10969186f, -0.03775319f, -0.13952951f, 
    0.03288027f, -0.15125297f, 0.16584015f, 0.04043318f, 0.08955088f, 0.14116600f, 0.04811919f, -0.08397022f, 
    -0.13431616f, -0.07120925f, -0.16155101f, -0.06661817f, -0.06573202f, -0.03276000f, 0.06943803f, 0.02928822f, 
    -0.15987031f, 0.10246263f, 0.00157591f, 0.04068853f, -0.00456098f, -0.11952517f, -0.13480094f, 0.07499948f, 
    0.03999425f, 0.03947106f, 0.10647736f, 0.07562168f, -0.09350052f, -0.01404510f, 0.03329771f, 0.08485114f, 
    -0.23339021f, 0.20406857f, 0.38881668f, 0.17673981f, 0.12124503f, 0.01151350f, -0.05550589f, 0.08182308f, 
    -0.02787741f, -0.04911935f, 0.01553932f, -0.02851102f, -0.08793066f, -0.05588128f, 0.10693329f, 0.17665622f, 
    0.04715758f, -0.00534215f, 0.04286128f, -0.09791897f, 0.00309628f, 0.10706133f, 0.09892948f, 0.08468292f, 
    0.17608918f, 0.05692365f, -0.17219555f, -0.12251321f, 0.07886380f, -0.06217364f, 0.00548673f, 0.04517942f, 
    -0.04697733f, -0.09658128f, -0.01494086f, -0.03876455f, -0.21712345f, 0.12846953f, -0.04769194f, 0.10685854f, 
    0.04160628f, 0.01934609f, 0.00162639f, 0.05869735f, -0.04791318f, -0.01972672f, 0.11739825f, -0.00932273f, 
    0.15618962f, 0.02550684f, -0.13400653f, -0.10222483f, 0.10802460f, -0.07496078f, -0.05399110f, -0.06260963f, 
    0.02407302f, -0.02601509f, 0.03610592f, 0.06699018f, -0.12138392f, -0.10325308f, -0.00461065f, -0.09724616f, 
    0.08634315f, 0.06313460f, 0.09554584f, 0.00064247f, 0.13592467f, 0.09204323f, 0.12818265f, 0.11929610f, 
    -0.14274612f, 0.36445561f, -0.38025048f, -0.14181225f, 0.12687953f, -0.02761405f, 0.02481086f, 0.09060262f, 
    0.04381587f, 0.02199800f, 0.14330396f, 0.00788895f, 0.01407320f, -0.02049575f, -0.00483297f, -0.06368594f, 
    -0.00387531f, -0.01132058f, -0.02312522f, -0.05352775f, 0.02108389f, -0.06899157f, -0.08289943f, 0.03253679f, 
    -0.17352010f, -0.02324327f, 0.16139551f, 0.06521184f, -0.03808486f, 0.07762529f, 0.02364463f, -0.04309052f, 
    -0.01112839f, -0.01033142f, 0.12518223f, 0.05755352f, -0.00619265f, -0.23087777f, -0.15512513f, -0.18362629f, 
    -0.05416361f, 0.09602414f, -0.03222437f, -0.06539103f, 0.05219626f, -0.04275081f, -0.03189566f, -0.07624557f, 
    -0.17299858f, 0.00663748f, 0.14230427f, -0.01615113f, 0.03701258f, 0.04598382f, -0.04454624f, 0.04853383f, 
    -0.08114042f, 0.02261400f, 0.02331065f, 0.02433652f, 0.23848021f, -0.04098134f, 0.00006951f, -0.04875745f, 
    0.10789505f, 0.16025853f, -0.06294239f, 0.15272005f, 0.00610935f, 0.00981146f, 0.08715979f, 0.16452046f, 
    0.05677987f, -0.20584153f, 0.12354384f, -0.12486835f, -0.22339384f, -0.10283358f, -0.01038954f, -0.05498514f, 
    -0.03416066f, -0.07957485f, -0.21222283f, -0.31760836f, 0.24998297f, 0.36899769f, -0.01436411f, 0.19930524f, 
    0.16508965f, -0.00579555f, 0.05760183f, 0.04352526f, 0.13010380f, 0.14948387f, 0.18782693f, 0.08580955f, 
    -0.03378907f, 0.28196052f, -0.01234187f, -0.06984866f, 0.04839288f, -0.00728863f, -0.02764711f, 0.04420219f, 
    -0.01550084f, 0.08842214f, 0.11360890f, 0.09873357f, -0.20406023f, -0.11511035f, -0.26204818f, 0.18438941f, 
    -0.03040479f, 0.07836460f, 0.20963740f, 0.19459906f, 0.04385214f, 0.10494466f, 0.09475802f, 0.09993204f, 
    0.26388735f, -0.33332711f, 0.24992168f, 0.05385376f, -0.08263853f, -0.23573531f, -0.03218688f, -0.14645006f, 
    -0.07918156f, 0.09949611f, 0.02227940f, 0.22893250f, 0.36631048f, 0.15214078f, 0.09109985f, 0.04489091f, 
    -0.14928134f, -0.07434146f, 0.02520912f, 0.05156993f, -0.19969434f, 0.10281928f, 0.03630670f, 0.25528067f, 
    0.07502208f, 0.08949757f, -0.14430095f, -0.31252873f, 0.15346164f, 0.03364201f, 0.05011083f, -0.13473870f, 
    -0.00792275f, -0.10357199f, -0.02321339f, 0.14755723f, -0.28202483f, -0.22324048f, 0.03736375f, 0.11467928f, 
    -0.06284907f, -0.05523344f, 0.13174681f, -0.01813322f, -0.04209090f, -0.03250305f, -0.06324631f, 0.16541006f, 
    0.07138578f, -0.03808139f, 0.01032061f, -0.06694832f, -0.07482257f, 0.03315581f, 0.04850412f, 0.05834325f, 
    -0.12126295f, -0.08018094f, 0.05145697f, -0.00448610f, -0.01688788f, 0.01385531f, -0.01549988f, 0.12972414f, 
    0.18177201f, -0.16083479f, 0.01580806f, -0.06574544f, -0.23528147f, 0.06507143f, -0.01066431f, -0.01201604f, 
    -0.19794363f, 0.40197232f, -0.18744162f, 0.06387423f, 0.20957841f, 0.15859005f, -0.02851248f, 0.10159560f, 
    -0.04860396f, 0.03724930f, 0.10632798f, 0.08188534f, 0.23426262f, 0.05464628f, -0.21946271f, 0.24173997f, 
    -0.25996205f, -0.00716789f, -0.05640226f, -0.17270891f, -0.10581937f, -0.19965412f, -0.07598226f, -0.22376846f, 
    0.21885000f, 0.16151793f, 0.14414875f, -0.29336244f, -0.12514439f, -0.13818975f, 0.24179937f, -0.08543699f, 
    0.02296969f, -0.02027010f, 0.04142910f, -0.02408985f, -0.15575650f, -0.29346710f, -0.19788022f, -0.07232068f, 
    -0.03775968f, 0.11561961f, -0.03118288f, 0.09399907f, -0.15162969f, -0.12347952f, 0.06513990f, -0.17549361f, 
    0.03281339f, -0.14022917f, 0.21848324f, -0.21187542f, -0.16898693f, 0.09237660f, -0.04497281f, 0.01334253f, 
    -0.09311437f, 0.29772738f, 0.02769807f, 0.12958264f, 0.34145504f, -0.03103271f, 0.07582700f, -0.03170618f, 
    0.08842128f, 0.15213177f, -0.03699139f, -0.10671855f, 0.01798934f, 0.03590644f, 0.06694677f, 0.19057021f, 
    -0.02113672f, 0.03672800f, 0.04580978f, -0.04196428f, -0.12065684f, -0.10254227f, 0.27883404f, 0.07948515f, 
    0.08137637f, 0.03173209f, -0.00758707f, 0.07024840f, -0.10408132f, 0.36361015f, 0.10729124f, 0.27875915f, 
    0.06929357f, -0.12850009f, 0.15217006f, 0.05024909f, -0.02473311f, -0.12886661f, 0.15018353f, 0.03189345f, 
    -0.01760032f, 0.03349385f, 0.02837458f, -0.11101120f, -0.11575723f, -0.07749581f, -0.09293696f, -0.05356612f, 
    -0.08803300f, -0.04579609f, -0.15104146f, -0.29144049f, -0.08286761f, 0.01212281f, -0.22548285f, -0.01607411f, 
    -0.11483606f, 0.05191877f, 0.12698795f, 0.03950128f, -0.01690811f, -0.03870155f, -0.18912147f, -0.18354574f, 
    -0.00221301f, -0.00236513f, 0.08148656f, -0.03462839f, -0.13756680f, -0.04973860f, -0.05939547f, -0.07957349f, 
    -0.04733586f, -0.06139657f, -0.02897057f, 0.08149325f, 0.01835322f, -0.15877229f, -0.15269136f, -0.28887346f, 
    -0.00359200f, -0.07822854f, -0.08970954f, 0.09982988f, 0.11206684f, 0.11272148f, -0.07507809f, -0.17367810f, 
    0.15700616f, 0.20688415f, 0.20624386f, -0.15200974f, 0.02765494f, 0.00712158f, 0.10164829f, -0.09922139f, 
    -0.00067569f, 0.16201957f, 0.09197973f, -0.10921387f, 0.03796889f, 0.16323330f, 0.28591752f, 0.19946162f, 
    0.01517430f, 0.00101352f, 0.16307215f, -0.14056867f, -0.00728959f, -0.00770511f, 0.03602862f, 0.04440448f, 
    0.25922447f, 0.20778471f, -0.02191953f, -0.02229504f, 0.04995765f, 0.11288693f, 0.18985137f, -0.06328625f, 
    -0.00281054f, 0.08938049f, 0.07975429f, 0.08329017f, -0.00084933f, 0.07291079f, 0.01343441f, 0.02273778f, 
    0.01335325f, 0.08939378f, -0.05511891f, -0.03134892f, -0.15305541f, -0.01371398f, -0.00952903f, -0.18881975f, 
    -0.12018407f, 0.26763070f, -0.21524028f, -0.10091399f, 0.07862599f, 0.16992451f, -0.05341572f, -0.03002706f, 
    -0.04965669f, 0.10705966f, -0.06397659f, -0.04775607f, 0.09528498f, 0.03334682f, 0.02390376f, -0.06519496f, 
    -0.14788076f, -0.08505413f, -0.06782127f, -0.09651775f, -0.09139956f, 0.01172221f, 0.09354492f, -0.09284019f, 
    0.49134508f, -0.14532408f, 0.15108123f, 0.10641321f, -0.18213002f, -0.03034589f, 0.08115455f, -0.03937413f, 
    -0.04162455f, 0.05029872f, 0.09255090f, -0.03816179f, -0.14338331f, 0.01633116f, 0.01904966f, 0.24939297f, 
    -0.13411160f, -0.02452447f, -0.09641850f, -0.08583384f, -0.04514236f, 0.03261320f, 0.03698329f, 0.04900568f, 
    0.20865753f, 0.05257390f, 0.13849714f, -0.02759654f, -0.11542224f, -0.14671703f, 0.09655759f, 0.07372899f, 
    -0.19531824f, -0.09502114f, 0.17660265f, -0.12400955f, 0.24578090f, -0.06743677f, -0.07074466f, 0.01136111f, 
    0.09426253f, 0.06511274f, 0.14300460f, 0.07398488f, -0.02940801f, -0.04023796f, 0.02010377f, -0.05845987f, 
    -0.09429674f, -0.12861104f, 0.12232256f, -0.06768874f, -0.00081262f, -0.12621783f, 0.03357801f, 0.02791103f, 
    -0.03656248f, -0.10875120f, -0.14683655f, -0.06480236f, -0.02673079f, 0.33084521f, 0.02633157f, 0.25754213f, 
    0.03250037f, -0.01913419f, 0.07338934f, -0.00933732f, 0.07948526f, -0.06397234f, 0.14715335f, 0.10394671f, 
    -0.29323441f, 0.06522255f, -0.23311101f, -0.23384641f, -0.11713584f, -0.11389371f, -0.06323132f, 0.05451963f, 
    0.01951499f, 0.07191382f, 0.15595123f, -0.08511128f, -0.30790156f, -0.16605732f, -0.12127413f, 0.19331960f, 
    -0.09232152f, -0.08013806f, -0.09435970f, -0.00443265f, -0.01227964f, 0.02272175f, -0.07107655f, 0.02090733f, 
    0.31589878f, -0.17740956f, 0.40220156f, -0.11356717f, -0.10533819f, -0.15361485f, -0.15723135f, -0.17752470f, 
    -0.00880416f, -0.00363128f, 0.02198515f, 0.10602123f, 0.05443034f, 0.31419405f, 0.19013344f, 0.17527197f, 
    -0.03086598f, -0.08503608f, 0.00174639f, 0.06179578f, 0.09389526f, 0.04977468f, -0.01897795f, 0.03055400f, 
    0.21239465f, 0.15026912f, 0.08821508f, -0.19849750f, -0.00522231f, 0.09370726f, 0.03046964f, -0.00673603f, 
    0.07946880f, -0.00824178f, 0.13902600f, -0.00351227f, -0.10539514f, 0.03065862f, 0.30231208f, 0.32662043f, 
    0.16125438f, 0.03973393f, -0.06792614f, -0.08862173f, 0.09699292f, -0.09678745f, 0.11018123f, 0.00554046f, 
    0.18734215f, 0.04846271f, 0.04000552f, -0.21339856f, -0.00621401f, 0.13006574f, -0.06997238f, 0.06142135f, 
    -0.00301539f, 0.06089612f, 0.19518739f, 0.10469247f, -0.17184538f, -0.07670421f, -0.05426406f, 0.16617572f, 
    0.19745301f, -0.01023252f, 0.20394190f, 0.09148696f, -0.11353157f, 0.10121783f, -0.02750157f, 0.09160101f, 
    -0.51295739f, 0.06847931f, -0.00219176f, -0.03604271f, -0.06569381f, 0.06077330f, -0.00766307f, 0.03219105f, 
    0.01507925f, 0.04974888f, -0.05239899f, 0.14739236f, 0.03312886f, 0.06982467f, -0.10265274f, 0.05316530f, 
    -0.06853696f, -0.06450276f, 0.07945594f, -0.07788515f, -0.03967413f, -0.00969161f, -0.03408064f, 0.01708638f, 
    0.06397647f, 0.15341629f, 0.20674530f, 0.05678838f, 0.03324090f, -0.01446246f, 0.09795681f, 0.11835644f, 
    -0.00399109f, 0.01565101f, 0.17966568f, -0.03941155f, -0.23995887f, -0.17796671f, 0.00500210f, 0.20609897f, 
    -0.08490931f, 0.07735293f, 0.07118765f, -0.01365539f, 0.00540207f, -0.01010439f, 0.00086345f, -0.04057819f, 
    -0.00316432f, 0.05524372f, 0.09074446f, -0.21922988f, -0.16440925f, -0.05575995f, 0.02098768f, 0.00516897f, 
    -0.10178073f, 0.12832643f, 0.07381692f, 0.02028819f, 0.23785803f, -0.10937093f, -0.10858253f, -0.14551924f, 
    0.08639488f, 0.01124094f, 0.13509540f, 0.01269800f, -0.24607967f, 0.02546681f, 0.05425075f, 0.03687708f, 
    0.22293651f, 0.21966714f, -0.06586784f, -0.12756646f, -0.06715648f, 0.13385740f, -0.10258482f, -0.17747466f, 
    -0.13188526f, -0.11796788f, 0.06158589f, -0.01755543f, 0.14528078f, -0.15893123f, -0.20220843f, -0.07820540f, 
    -0.03985279f, 0.05236996f, -0.10805905f, 0.02846820f, -0.06009477f, 0.11328331f, -0.14092368f, 0.04689633f, 
    -0.00927807f, -0.07112212f, 0.03510645f, 0.12522042f, 0.02614425f, 0.11375397f, 0.01103132f, 0.00489397f, 
    -0.03121321f, 0.11513782f, -0.06887633f, 0.09143427f, 0.22809774f, 0.17118229f, 0.05652269f, -0.13210489f, 
    0.04688741f, -0.09589916f, -0.01095269f, 0.06565923f, 0.01362883f, -0.00459057f, 0.07047297f, -0.03337481f, 
    0.05122675f, 0.03898401f, -0.23310764f, -0.13220944f, 0.11053509f, 0.05344411f, 0.12708598f, 0.16257161f, 
    0.01090220f, 0.01791900f, -0.07160122f, -0.07606088f, -0.12746438f, 0.17838031f, 0.01908810f, 0.07679271f, 
    0.08446027f, 0.06507664f, 0.08499504f, -0.02128273f, 0.02086059f, -0.03232612f, 0.02839694f, -0.04659321f, 
    -0.33729193f, -0.14202984f, 0.15403336f, 0.14450784f, 0.11541244f, 0.05176487f, 0.07730791f, 0.08464933f, 
    0.07226865f, -0.10658845f, 0.02712876f, 0.10797399f, 0.18572156f, -0.15084611f, -0.06484238f, -0.23125924f, 
    -0.04208052f, 0.07481530f, -0.07255822f, -0.05085351f, 0.08705813f, 0.06252581f, -0.00688431f, -0.01396052f, 
    -0.03091732f, -0.29200432f, 0.09016535f, 0.07623500f, -0.07847189f, -0.07270376f, -0.05754216f, 0.02278186f, 
    -0.04564674f, -0.01506154f, -0.12700717f, -0.03386283f, -0.17338480f, 0.08634224f, -0.08794420f, 0.17396487f, 
    -0.12037902f, -0.03712600f, -0.02144278f, 0.09164298f, 0.00229472f, -0.11203595f, -0.06413083f, -0.07014344f, 
    -0.07522734f, -0.21346670f, 0.21250384f, 0.25343603f, -0.00763039f, -0.02519495f, 0.07440325f, 0.06365725f, 
    0.16528715f, -0.02250253f, 0.01895349f, -0.04160369f, -0.02010292f, 0.05314023f, -0.01997395f, 0.08620765f, 
    0.08540810f, -0.01765764f, 0.12498377f, 0.02781748f, -0.03936552f, 0.04014685f, 0.02085894f, 0.04873942f, 
    -0.01331333f, 0.01859998f, 0.06325050f, -0.10706286f, 0.16621740f, 0.06794790f, -0.01241187f, 0.05434669f, 
    -0.03282714f, -0.04954620f, -0.12762822f, 0.07220597f, 0.19362693f, 0.26871035f, 0.06191481f, -0.20503137f, 
    -0.03315006f, -0.00119732f, 0.04838574f, -0.03238289f, 0.06326346f, -0.08825821f, 0.01256497f, 0.06871997f, 
    0.06880981f, -0.26123714f, -0.16818854f, 0.02029059f, 0.17934057f, 0.12362679f, 0.03019224f, 0.00412327f, 
    0.03080943f, -0.16252351f, 0.06996358f, 0.04529027f, -0.18121850f, 0.14612409f, 0.11313649f, -0.01919737f, 
    -0.12956937f, -0.07849248f, 0.03830633f, -0.04629196f, 0.08883057f, 0.03397247f, 0.05157739f, -0.13706832f, 
    -0.21349356f, -0.00757849f, -0.09303682f, -0.04910203f, -0.14959870f, -0.09664304f, 0.18357380f, 0.09789372f, 
    0.03939224f, 0.03243356f, 0.07760054f, -0.01414455f, 0.05872107f, 0.02192583f, 0.40934685f, 0.07725137f, 
    0.01364688f, -0.03514726f, -0.02759461f, -0.05001989f, -0.00574677f, 0.07294039f, 0.14326955f, -0.08936760f, 
    0.04944659f, 0.05476451f, 0.10083552f, 0.04379642f, 0.00969230f, -0.05351933f, -0.04861577f, 0.03553693f, 
    0.09992339f, -0.06718986f, -0.01358716f, -0.09394613f, -0.15946220f, 0.02539096f, 0.10454393f, -0.03574942f, 
    -0.02803274f, 0.11132119f, 0.06786728f, 0.09686533f, 0.01933646f, 0.21500511f, -0.03776011f, -0.01742161f, 
    -0.10661285f, 0.06233399f, -0.07454154f, -0.30133858f, 0.11910978f, 0.05423401f, -0.10262195f, 0.04083866f, 
    0.11114541f, 0.00757968f, -0.07516214f, 0.04875331f, 0.06453745f, 0.11264049f, 0.02512220f, -0.21031293f, 
    -0.07641926f, -0.12752125f, -0.01284037f, 0.02738740f, 0.14139593f, -0.03428299f, 0.05958570f, -0.01032734f, 
    0.02699426f, -0.07029450f, 0.08235214f, 0.11254520f, -0.05754019f, -0.01021483f, 0.01655326f, 0.01580853f, 
    -0.01454014f, 0.12261944f, 0.09471313f, 0.02723337f, -0.05924876f, 0.09182595f, 0.34635571f, 0.05850901f, 
    0.12807548f, 0.00655052f, 0.08282129f, -0.09377990f, 0.00357037f, 0.10591155f, -0.02649120f, 0.11477648f, 
    0.15980656f, 0.25110376f, -0.10581671f, 0.07983369f, 0.01431961f, 0.04555664f, 0.09383331f, 0.00635536f, 
    0.01086827f, -0.02082759f, 0.03256776f, 0.09147352f, 0.06955643f, 0.06207068f, 0.18043602f, -0.05927065f, 
    -0.01083436f, -0.10260700f, -0.05563252f, 0.00645630f, -0.07960445f, -0.13750029f, 0.04493687f, -0.16205515f, 
    -0.01630715f, -0.19806519f, 0.14745526f, 0.27214959f, 0.04353039f, -0.05087760f, -0.11991327f, 0.08113722f, 
    0.05547709f, 0.10774902f, 0.02129197f, -0.02093274f, 0.06363077f, -0.04461983f, -0.04025472f, 0.12326742f, 
    -0.11617067f, -0.01472188f, -0.06235960f, -0.09317854f, -0.08629718f, -0.05623263f, 0.10810637f, -0.03837643f, 
    0.76067150f, 0.09641058f, 0.07443175f, -0.18215756f, -0.10593599f, -0.13380319f, 0.12112483f, -0.06600957f, 
    0.00693762f, 0.06897216f, -0.03064806f, 0.07839224f, -0.15667810f, 0.02656934f, 0.12561013f, 0.09693207f, 
    -0.04814568f, -0.05257302f, -0.02769539f, -0.04919930f, -0.04603874f, 0.12233916f, 0.10173737f, -0.08797228f, 
    0.58596611f, 0.13642420f, 0.04094553f, -0.12280078f, -0.01511912f, -0.10468036f, 0.11335988f, 0.05538212f, 
    0.16891629f, -0.00033881f, 0.08702693f, -0.03580164f, -0.19052868f, -0.13040014f, -0.10992743f, 0.18642475f, 
    0.01909473f, -0.10627261f, 0.03428334f, -0.09656848f, 0.04416928f, -0.00929270f, 0.03637848f, 0.08097542f, 
    -0.07861017f, 0.03494864f, 0.17149386f, -0.14519279f, -0.06885803f, -0.04279833f, 0.00462341f, -0.04822405f, 
    -0.08452448f, -0.07785154f, -0.14653189f, -0.11235951f, 0.11877843f, 0.18002620f, -0.13587305f, 0.14857027f, 
    -0.02985365f, 0.17337881f, 0.03174127f, 0.07734551f, 0.00267682f, -0.06445505f, 0.12056069f, 0.11803449f, 
    -0.00255438f, 0.17796111f, -0.16620947f, 0.01316573f, -0.07488567f, -0.06531610f, -0.03943460f, -0.01438200f, 
    0.19553420f, 0.11261296f, 0.08525617f, 0.01008101f, -0.25402579f, 0.08430973f, -0.02470659f, 0.14087978f, 
    -0.11648628f, -0.00019284f, 0.02272383f, -0.04861854f, 0.00396538f, 0.03096977f, 0.01960068f, -0.14484347f, 
    0.47743252f, 0.02390677f, 0.06107813f, -0.42275321f, -0.16326497f, -0.09113356f, -0.08237280f, -0.04079387f, 
    -0.05002790f, 0.03479221f, -0.02907702f, -0.02642284f, 0.02651698f, 0.45440629f, 0.07261290f, -0.08693077f, 
    -0.10809725f, -0.14642614f, 0.03799070f, 0.01295278f, 0.19060220f, -0.01590791f, 0.00337190f, -0.09741456f, 
    0.07362685f, -0.04822987f, 0.14176939f, 0.04739023f, 0.07330033f, 0.09143833f, -0.13635449f, 0.00000311f, 
    0.16747861f, 0.05390787f, 0.09129881f, 0.11850099f, 0.03109097f, -0.08308323f, 0.14841351f, 0.02736518f, 
    0.10661898f, 0.08305267f, -0.01966458f, -0.16965321f, 0.01992630f, -0.01157883f, 0.01549838f, -0.05607850f, 
    0.25318038f, -0.09542815f, 0.09115860f, 0.01970680f, -0.08214504f, 0.16108322f, 0.06775378f, 0.06276800f, 
    -0.17595011f, -0.02431912f, -0.16751936f, 0.12316357f, -0.08588861f, -0.02523039f, -0.03323218f, 0.24874163f, 
    0.02170150f, -0.06402066f, 0.09452287f, 0.06213555f, -0.09571644f, -0.03898599f, -0.11810082f, -0.03595505f, 
    -0.16990219f, -0.22906135f, 0.13021442f, 0.32672060f, -0.09165241f, 0.05188216f, -0.04880290f, 0.04662774f, 
    0.14299317f, 0.10025518f, -0.06257770f, 0.04064761f, 0.04313286f, 0.13500147f, -0.01623156f, 0.17735147f, 
    0.07147534f, 0.02471886f, -0.01448357f, -0.07253437f, -0.05907009f, -0.02188145f, -0.12058789f, 0.05798087f, 
    0.36231571f, 0.19353347f, 0.28602409f, -0.03259411f, 0.01887317f, -0.10477462f, 0.06268790f, 0.15666667f, 
    -0.07693175f, -0.00621320f, 0.06465330f, -0.01206981f, -0.21231295f, 0.05922611f, 0.23157203f, 0.16150670f, 
    -0.09127872f, -0.07964183f, 0.10686471f, -0.05795977f, -0.10014674f, -0.11638666f, -0.04289305f, -0.05836195f, 
    0.39995611f, -0.17838547f, 0.24846058f, -0.12220875f, 0.01750569f, -0.12671220f, 0.03768917f, -0.11021772f, 
    -0.00732869f, 0.00561553f, 0.09746254f, 0.00644335f, -0.20347053f, -0.11530616f, -0.12917946f, 0.00959595f, 
    0.08757764f, -0.09326743f, -0.07945746f, -0.12899204f, -0.09899246f, 0.00677687f, -0.14267687f, -0.00688833f, 
    -0.07937562f, -0.01846773f, -0.03711286f, -0.16030531f, 0.06440692f, 0.03804614f, 0.09856161f, -0.04607192f, 
    -0.06544916f, -0.08793163f, -0.04009328f, -0.12368987f, 0.30012429f, -0.01406423f, -0.00965923f, -0.00527891f, 
    0.16277479f, -0.03125924f, -0.05424514f, -0.00107802f, -0.00057222f, 0.02866995f, 0.02542205f, 0.10730332f, 
    0.06843665f, 0.08426871f, -0.03216292f, 0.12729079f, -0.07943972f, -0.01430679f, -0.00367434f, 0.04797808f, 
    0.01844773f, -0.00605383f, 0.14893745f, -0.01740805f, -0.30503163f, 0.02329831f, 0.10620198f, 0.22478540f, 
    -0.02174423f, 0.23907526f, 0.09406012f, 0.01599063f, 0.09580851f, 0.06958266f, 0.01383774f, 0.05165737f, 
    0.21618180f, -0.15577815f, 0.00847548f, -0.09632002f, 0.13059841f, 0.04868333f, 0.09698427f, -0.08023646f, 
    -0.02914714f, 0.04475789f, 0.06455567f, 0.06844113f, 0.17391947f, 0.43538842f, 0.13721997f, 0.07951893f, 
    -0.09571023f, -0.05344942f, 0.00819513f, -0.07734114f, 0.13538799f, -0.00644653f, -0.00253207f, 0.17293760f, 
    -0.07313792f, -0.00934492f, 0.08337220f, 0.08940477f, 0.03088097f, 0.11602540f, -0.03805536f, 0.07747761f, 
    0.13347994f, -0.02503563f, 0.11583488f, 0.06261992f, 0.01147602f, -0.16405474f, 0.26271018f, -0.07017560f, 
    0.30102897f, -0.07874037f, 0.00994597f, -0.10745729f, -0.11319531f, 0.03910331f, -0.09046028f, 0.03290989f, 
    0.11129420f, 0.08820163f, -0.00187669f, 0.08714274f, -0.22464341f, -0.06187589f, -0.05904758f, 0.05805105f, 
    -0.13961411f, 0.04213463f, -0.12897657f, -0.08497005f, -0.06598584f, 0.09886066f, -0.03252082f, 0.15385577f, 
    -0.02437785f, -0.16150449f, 0.01787471f, 0.00942506f, 0.06143867f, -0.15207313f, -0.11751366f, 0.02059867f, 
    -0.08646553f, -0.08105554f, 0.13819204f, 0.17514481f, -0.10543852f, 0.07392338f, 0.07145398f, 0.13313502f, 
    0.15710603f, 0.12799624f, 0.03941043f, 0.09107831f, -0.04874820f, 0.03875868f, -0.09556124f, 0.19309293f, 
    0.04808973f, -0.03736746f, 0.05616650f, -0.06968480f, 0.01721997f, -0.10249859f, -0.06993850f, -0.02272420f, 
    0.51250619f, 0.20366320f, -0.17119297f, -0.24498892f, 0.04076271f, 0.01804368f, 0.02656646f, -0.00891264f, 
    -0.06443358f, -0.00393465f, 0.03209518f, 0.01387364f, -0.23030308f, -0.00104613f, 0.08540908f, 0.26222751f, 
    0.00186875f, 0.01216234f, 0.05569531f, -0.15968347f, -0.15968734f, -0.03303821f, 0.08524225f, 0.04440076f, 
    0.48416215f, -0.25083834f, -0.04564188f, -0.04931342f, -0.01267627f, -0.05956323f, 0.09007920f, -0.05478156f, 
    0.08626629f, 0.13650829f, 0.00067156f, 0.07794680f, -0.19656321f, -0.19070424f, -0.08376318f, 0.07376441f, 
    -0.00470658f, 0.04331220f, 0.03007340f, -0.18134123f, 0.02383008f, -0.02796090f, 0.00081904f, -0.04531324f, 
    -0.20466620f, -0.00462643f, -0.11886129f, 0.08876248f, 0.09408846f, 0.10922445f, 0.17025670f, 0.13022217f, 
    -0.01979859f, 0.15084513f, 0.10005193f, 0.13975978f, 0.38744709f, -0.39462698f, 0.44852450f, -0.06768312f, 
    -0.05580166f, 0.01897942f, -0.14213102f, -0.05410623f, 0.07270888f, 0.00645736f, 0.01534181f, 0.05969030f, 
    -0.09017042f, -0.12884490f, 0.00700561f, -0.11099572f, -0.11565120f, -0.12884468f, -0.16682601f, -0.05083925f, 
    0.15042441f, -0.16151500f, 0.10554177f, -0.11416909f, -0.10368295f, 0.06060225f, 0.12339783f, -0.11064814f, 
    0.08876406f, -0.04001416f, -0.00342810f, -0.03290868f, 0.08998176f, -0.08532479f, 0.01289939f, -0.02451229f, 
    -0.26956484f, -0.15901580f, -0.10983109f, -0.11295246f, 0.14924465f, -0.09472881f, 0.19316840f, -0.09933922f, 
    -0.13451964f, -0.11030252f, -0.06541973f, 0.02033060f, 0.04147251f, 0.36517242f, 0.06465373f, -0.03729250f, 
    -0.01561810f, -0.15640350f, -0.05284546f, 0.05759050f, 0.06177551f, -0.00642694f, -0.00485553f, -0.06398399f, 
    -0.03404295f, 0.01690143f, -0.09233670f, 0.12831511f, -0.07972191f, 0.00661083f, 0.03122712f, 0.05258753f, 
    0.04743347f, 0.04019197f, 0.00000845f, -0.01758900f, 0.06012822f, 0.13400038f, 0.17964022f, 0.00163651f, 
    0.08308242f, 0.08338014f, 0.05925381f, 0.22540697f, 0.10515454f, 0.07648630f, 0.03879453f, -0.01615097f, 
    -0.04535342f, 0.35164523f, -0.03266219f, 0.09282288f, -0.03152263f, 0.03079534f, 0.11334796f, -0.04110127f, 
    0.07658415f, 0.08754148f, 0.17021586f, 0.09587048f, 0.15508319f, 0.08504484f, 0.00248485f, -0.02258186f, 
    -0.01798113f, -0.21558467f, -0.20691410f, -0.17941719f, 0.13429779f, 0.00753212f, 0.17120984f, 0.10154647f, 
    0.17546353f, -0.12487123f, 0.32465440f, 0.14121453f, -0.10883876f, 0.00932043f, -0.18192166f, 0.00299528f, 
    0.15990946f, 0.02029321f, 0.02038544f, -0.06675249f, -0.26417419f, -0.25654724f, -0.11114366f, -0.24304590f, 
    -0.04224977f, -0.11768519f, -0.03130738f, 0.03020829f, -0.00673145f, -0.00656898f, 0.05619669f, 0.06386126f, 
    0.06491739f, 0.36952645f, -0.18053050f, -0.18027686f, -0.01028258f, 0.03756896f, -0.14641659f, -0.04206534f, 
    -0.03381068f, 0.08202133f, -0.05916441f, -0.03424403f, -0.22821449f, 0.09606653f, 0.05049448f, 0.09472597f, 
    0.07160649f, -0.09757219f, 0.19569978f, 0.12368277f, 0.01657229f, 0.10897709f, 0.10110018f, 0.07737195f, 
    -0.04132896f, 0.07976110f, -0.04836353f, -0.13679451f, 0.02482177f, 0.00990429f, -0.01325863f, 0.03193596f, 
    0.08389854f, -0.06783555f, -0.14677259f, -0.04876123f, -0.32631454f, -0.05802038f, -0.24376915f, 0.21501473f, 
    0.16571753f, -0.25033209f, -0.05441507f, 0.01180094f, 0.08385987f, 0.10196797f, 0.05414088f, -0.02635538f, 
    -0.06804761f, -0.02004068f, 0.05477803f, -0.04465482f, 0.05201964f, -0.00181874f, -0.02527815f, -0.01821040f, 
    -0.00800533f, 0.01171120f, 0.03698236f, -0.03949882f, -0.01380469f, -0.04180892f, -0.05640246f, 0.02018629f, 
    -0.00159534f, -0.02493385f, -0.01844224f, -0.03110386f, 0.06322297f, -0.05101661f, 0.03083146f, -0.06799754f, 
    -0.05427048f, -0.04861714f, -0.04225079f, 0.00130093f, -0.00506142f, -0.06486357f, -0.04530515f, 0.04276583f, 
    0.01135434f, 0.03524118f, -0.00600449f, -0.03306363f, 0.04475607f, 0.05966561f, -0.01342815f, -0.00419027f, 
    -0.03525584f, -0.05271687f, 0.02214260f, 0.02319941f, 0.04442704f, -0.06453910f, -0.06407645f, 0.06428998f, 
    0.03666306f, -0.02356960f, -0.07535148f, -0.01646912f, -0.03071636f, -0.05487324f, -0.03665709f, 0.01489094f, 
    0.01812426f, -0.01416621f, -0.03343429f, -0.05069268f, -0.06602801f, 0.01481886f, -0.07431363f, 0.01167902f, 
    0.03979189f, -0.02447819f, 0.05066312f, -0.01218350f, 0.05283000f, 0.04717023f, -0.06843159f, 0.04364984f, 
    -0.01922270f, 0.02953773f, -0.05369426f, -0.02089614f, 0.01985756f, -0.01476425f, -0.02999040f, 0.00937534f, 
    0.04468781f, -0.07386429f, -0.05372249f, -0.07240959f, -0.05084513f, -0.00311078f, 0.06114234f, -0.04419149f, 
    -0.01009123f, 0.04627719f, 0.01029625f, 0.03542496f, -0.00001964f, -0.00054029f, -0.01261871f, -0.05745927f, 
    0.03803136f, -0.05137655f, 0.00536360f, 0.00859219f, -0.01360144f, -0.03196916f, -0.00805350f, -0.01736492f, 
    0.02679728f, 0.05906470f, 0.03250135f, -0.04410555f, -0.00653364f, -0.07005845f, -0.02726130f, -0.05232132f, 
    -0.05341646f, 0.00368505f, 0.03725165f, -0.02231923f, 0.00249898f, -0.00767109f, -0.00187093f, -0.07252354f, 
    -0.00987221f, 0.01454988f, 0.06188896f, -0.03448762f, 0.03467491f, 0.06241120f, -0.02402196f, -0.03496232f, 
    -0.07620774f, -0.07416728f, -0.03868080f, -0.03809726f, 0.01713593f, -0.07176322f, 0.01010551f, -0.07286865f, 
    -0.00844088f, 0.02800349f, -0.00468917f, 0.00132141f, -0.03904504f, 0.03097363f, -0.03132996f, -0.01958222f, 
    -0.02028846f, -0.01913835f, 0.04208139f, -0.05444809f, -0.06050298f, -0.02485660f, 0.06503115f, -0.02215600f, 
    0.06547675f, -0.02091005f, -0.04839485f, -0.01115986f, -0.03440200f, -0.01939107f, -0.04946701f, 0.01559721f, 
    0.04083091f, 0.04431711f, -0.03288420f, -0.07652386f, -0.03198847f, -0.01476509f, -0.00000577f, -0.03091618f, 
    0.01124684f, -0.02473426f, -0.02831669f, -0.06298158f, -0.01238590f, -0.06188647f, -0.01150685f, 0.02190064f, 
    -0.06279457f, -0.05552244f, -0.03155651f, -0.05827307f, 0.06499590f, -0.04971149f, 0.05375974f, -0.00140347f, 
    -0.02250588f, -0.06808957f, -0.05020009f, -0.07191833f, -0.06555372f, 0.03151677f, 0.05475154f, 0.01829552f, 
    -0.02266814f, -0.16605790f, -0.02451196f, -0.16154109f, 0.04908574f, 0.05074074f, 0.07395006f, 0.08172049f, 
    -0.00016002f, 0.05728275f, 0.04690304f, 0.15519065f, 0.11062792f, 0.13311782f, -0.10935640f, 0.06219115f, 
    -0.00329029f, 0.02979733f, 0.03718730f, 0.07219771f, 0.06292654f, 0.01128826f, -0.03358426f, 0.06899840f, 
    0.04410668f, 0.00816513f, 0.06420035f, 0.00728835f, -0.02357370f, -0.08912625f, -0.10416283f, -0.10204932f, 
    -0.16673133f, -0.19943811f, -0.19981228f, -0.12266553f, 0.33177069f, 0.09153610f, -0.02774283f, -0.09177575f, 
    0.05001837f, 0.06971247f, -0.02378356f, 0.02454562f, -0.05386955f, -0.12575348f, 0.02549646f, -0.12121421f, 
    -0.23153557f, -0.11330227f, -0.29647884f, 0.12347945f, -0.05584416f, -0.04508483f, 0.07046854f, -0.08218383f, 
    -0.08745211f, 0.00068760f, -0.03745285f, -0.10080416f, -0.10458131f, -0.21085840f, -0.22595936f, -0.16539712f, 
    0.05090323f, 0.08218896f, -0.01187200f, 0.00797542f, -0.07224172f, 0.10171290f, 0.00153445f, -0.10378135f, 
    0.17450017f, 0.06403781f, 0.18366030f, 0.09599208f, 0.05770139f, 0.01092145f, 0.07224397f, 0.16577968f, 
    0.05969213f, -0.03402065f, 0.08932155f, 0.06841893f, 0.12136724f, 0.01983198f, -0.27501512f, -0.12099263f, 
    0.03336953f, 0.03028538f, 0.12706839f, -0.00552970f, 0.11896826f, 0.04138597f, 0.03692959f, 0.14129300f, 
    0.18238957f, -0.09154212f, 0.20388663f, 0.16957635f, -0.03328144f, 0.10352078f, 0.05510438f, 0.04253835f, 
    0.05492164f, 0.14149015f, -0.07786072f, 0.10962527f, -0.20446481f, -0.05429397f, -0.14060712f, -0.04897976f, 
    -0.16893974f, -0.11360142f, -0.06192516f, -0.03201507f, 0.19796354f, 0.09962213f, 0.28428319f, 0.22370413f, 
    0.03454299f, 0.07005408f, -0.09206159f, -0.01464653f, 0.01625279f, -0.16175412f, 0.10228863f, 0.02932525f, 
    0.09282529f, -0.12179276f, 0.00343000f, 0.12262855f, -0.07869729f, 0.13910614f, 0.14599735f, 0.05611527f, 
    -0.02612756f, -0.17465499f, -0.12884222f, -0.04408782f, 0.07158969f, 0.00336137f, -0.04933298f, 0.02116363f, 
    0.30634603f, -0.07493587f, 0.19110498f, -0.02828940f, 0.00245134f, -0.18753916f, -0.01286196f, -0.08002391f, 
    0.08989845f, -0.11492111f, 0.04507629f, -0.02892013f, 0.06245752f, 0.05137871f, -0.06665614f, -0.30908725f, 
    0.12302511f, 0.18660858f, -0.01082821f, -0.08467731f, 0.00493098f, 0.01243449f, 0.02196401f, 0.03248567f, 
    0.09720832f, -0.10088915f, 0.13713491f, 0.16100785f, 0.05703713f, 0.04990980f, -0.07364070f, -0.09139711f, 
    -0.05522463f, -0.10866696f, -0.14633358f, -0.08119790f, 0.03999749f, 0.33156848f, 0.21845159f, -0.08111251f, 
    0.02575032f, 0.06602841f, -0.04126573f, 0.19211371f, -0.06150913f, 0.10214951f, -0.05762426f, -0.16708606f, 
    0.01811475f, -0.02894744f, -0.05179231f, -0.01792445f, -0.05944449f, -0.08665311f, 0.12955077f, 0.00998368f, 
    0.15399492f, -0.00040695f, 0.01203574f, 0.06043165f, -0.10954710f, 0.03359111f, 0.17061092f, -0.09248163f, 
    -0.01948678f, 0.01482178f, -0.02766367f, -0.11538456f, -0.02204904f, 0.03996043f, 0.08396459f, -0.12373664f, 
    -0.01059829f, -0.11958466f, -0.05851662f, -0.11696550f, -0.10545482f, -0.02245706f, -0.09017182f, -0.01437579f, 
    -0.06837008f, 0.11371077f, 0.06797144f, -0.07771204f, -0.24099500f, -0.21021649f, -0.05306569f, 0.03088141f, 
    0.03310298f, -0.15723245f, 0.04692762f, 0.10382761f, -0.09388461f, 0.06485246f, -0.03493591f, 0.05580334f, 
    -0.14814340f, 0.16302638f, 0.40015867f, -0.24904887f, 0.07952464f, 0.17879844f, -0.06162495f, 0.08594115f, 
    -0.00983286f, -0.07921907f, -0.05685205f, 0.00900258f, 0.05814010f, 0.05996632f, 0.11394583f, 0.01565560f, 
    -0.14131185f, -0.17249793f, 0.00489248f, -0.00500030f, 0.08203208f, -0.07951950f, 0.14258765f, 0.09626137f, 
    -0.02510322f, -0.02815337f, -0.02153642f, 0.01574678f, 0.01494616f, -0.12640128f, -0.09808627f, -0.02448672f, 
    -0.07235184f, 0.10284885f, -0.10123765f, -0.03994834f, -0.28568557f, 0.10369410f, 0.26773638f, 0.14873934f, 
    -0.01901864f, 0.11443225f, -0.00411742f, 0.05801410f, -0.05871971f, 0.03246947f, -0.03585530f, -0.08886050f, 
    -0.09413853f, 0.11641070f, -0.21115106f, -0.09106966f, -0.04129519f, -0.10965444f, -0.12350474f, -0.11423417f, 
    -0.08584826f, 0.00566487f, -0.02636654f, 0.02178320f, 0.09296250f, -0.17933980f, 0.07452796f, -0.19172221f, 
    -0.03848851f, -0.06766349f, -0.13382183f, -0.05292509f, -0.06951300f, -0.10239323f, 0.00804814f, -0.12356252f, 
    -0.28597379f, 0.14308357f, 0.10313978f, -0.01011858f, 0.04657082f, 0.01049104f, -0.18865110f, -0.00625034f, 
    -0.01041941f, -0.13369539f, -0.04495125f, 0.06558689f, -0.03361486f, -0.17946869f, -0.05607078f, -0.18935567f, 
    -0.15980610f, -0.10949120f, -0.11176942f, 0.04289725f, -0.10021517f, 0.01496038f, -0.02329856f, -0.12151179f, 
    0.09002200f, 0.08770218f, -0.17656429f, -0.03970830f, -0.18929805f, -0.04690786f, -0.01233977f, -0.11305928f, 
    -0.00758258f, 0.07576559f, -0.08630449f, 0.04271368f, -0.18857421f, -0.05144882f, -0.02545359f, 0.24111140f, 
    -0.12951501f, -0.05994267f, -0.02616207f, 0.18581653f, -0.03161958f, 0.00868567f, 0.04187623f, -0.06735153f, 
    0.07281971f, 0.16731870f, -0.09883717f, -0.10330812f, -0.02157438f, -0.02944411f, -0.03349020f, 0.03491015f, 
    0.14891690f, -0.01362896f, -0.00671273f, -0.09763284f, 0.02274081f, -0.17991659f, -0.10354932f, 0.11498019f, 
    -0.04877677f, -0.14883769f, 0.08562250f, -0.01410041f, -0.05016438f, 0.01608006f, -0.00219943f, 0.20993470f, 
    0.12839478f, -0.00786328f, 0.09326563f, 0.08133799f, 0.10824759f, 0.25882837f, 0.19614652f, 0.11310198f, 
    -0.10951333f, 0.14102972f, 0.18123165f, 0.18044694f, 0.19648963f, 0.25161842f, 0.04443805f, 0.07881808f, 
    0.08866717f, -0.01929745f, 0.06753670f, 0.02271422f, 0.00790236f, -0.10579498f, -0.08365786f, 0.01104190f, 
    -0.11522272f, -0.05483990f, -0.01929818f, 0.01684070f, -0.08625271f, -0.07571685f, -0.23822841f, -0.19504109f, 
    -0.16456574f, -0.12581745f, -0.16168039f, -0.21341771f, 0.18753356f, 0.19134489f, -0.14408082f, -0.05843284f, 
    0.15302901f, 0.17352739f, 0.02193934f, 0.01678963f, -0.09276348f, -0.18490572f, -0.14082640f, -0.21507917f, 
    0.01213565f, -0.14513715f, -0.24084659f, 0.33723736f, 0.05867586f, -0.01342716f, 0.03311258f, -0.13866644f, 
    -0.16435346f, -0.07959969f, -0.06029986f, 0.03815705f, 0.06361556f, -0.11035064f, -0.20264994f, -0.08884453f, 
    0.01085613f, 0.10194501f, -0.03187608f, 0.06066165f, -0.05107334f, 0.10598243f, -0.10107948f, 0.01539455f, 
    0.02703229f, 0.27681592f, 0.16003528f, 0.05339057f, -0.12140512f, -0.06119642f, 0.09232555f, 0.02715957f, 
    0.06801046f, 0.01414480f, 0.13494140f, -0.03021567f, 0.29059854f, 0.21820721f, -0.16303402f, 0.00038600f, 
    0.00707977f, 0.02021389f, 0.02555738f, 0.20760493f, 0.07594482f, 0.09891732f, 0.09055921f, 0.18350969f, 
    0.09155548f, -0.08103969f, 0.07921560f, 0.02139224f, -0.03011461f, 0.13640061f, 0.12363886f, -0.10805091f, 
    0.21382922f, 0.11163497f, 0.04862368f, 0.09197465f, -0.09869304f, 0.02069834f, -0.12542090f, -0.07609434f, 
    -0.15256160f, -0.06633519f, -0.12714493f, -0.01572766f, 0.17928918f, 0.17738922f, 0.20898218f, 0.18335932f, 
    0.12340156f, 0.38033047f, 0.03770297f, -0.17714024f, -0.12398683f, -0.01707201f, 0.02421351f, -0.03186582f, 
    0.08170614f, -0.04919950f, -0.04252609f, -0.05078607f, -0.20959459f, -0.09568604f, 0.24954498f, -0.08514738f, 
    -0.08603536f, -0.30035710f, -0.03389825f, -0.12162039f, 0.06937341f, 0.17411587f, -0.10645121f, 0.15320195f, 
    -0.00674956f, -0.07788149f, -0.05605470f, 0.07053011f, -0.09108708f, -0.05609985f, -0.05386946f, 0.06819844f, 
    0.16818869f, 0.16006339f, 0.04929142f, -0.09452621f, 0.09095420f, 0.09001140f, -0.04082128f, -0.02489703f, 
    0.10474390f, 0.20106232f, 0.11465649f, -0.08845594f, 0.08395670f, -0.03291985f, 0.02281191f, 0.01809857f, 
    -0.14646304f, -0.05516432f, 0.08020932f, 0.21017383f, -0.05326610f, -0.02070669f, -0.11572488f, 0.01867721f, 
    -0.16653225f, -0.09769838f, -0.18792383f, -0.11887926f, 0.18933058f, 0.17187731f, 0.20266101f, -0.07879104f, 
    0.05854632f, 0.03267883f, -0.11118851f, 0.24578378f, -0.13602217f, 0.07755688f, -0.01950429f, -0.22171678f, 
    0.01849542f, 0.11928329f, -0.06347596f, 0.01225957f, -0.05574707f, -0.34312558f, -0.12097950f, 0.06700376f, 
    0.09440500f, -0.11637522f, 0.03980793f, 0.05361215f, -0.43407282f, 0.04637895f, 0.18631899f, -0.05428027f, 
    -0.05094513f, 0.05723863f, 0.07898994f, 0.04218637f, -0.02096315f, 0.16445915f, 0.11186638f, 0.02389340f, 
    -0.12095162f, -0.19514908f, -0.14043309f, -0.09000053f, -0.05162101f, -0.04841005f, 0.05354918f, 0.07130234f, 
    0.06544081f, 0.12586574f, 0.01940213f, 0.07004718f, -0.11483095f, -0.12373989f, 0.12700757f, 0.01784521f, 
    -0.02014069f, -0.05512150f, 0.14936396f, 0.12468500f, -0.03795124f, 0.26556516f, -0.02476288f, 0.05094068f, 
    -0.27091166f, 0.26224336f, 0.18461287f, -0.34983590f, 0.18053544f, 0.40366268f, 0.01426128f, 0.08208778f, 
    0.00041672f, -0.15758060f, -0.10395233f, -0.02684473f, -0.10898063f, 0.10545935f, 0.03827858f, -0.03313123f, 
    0.00675389f, -0.19530711f, -0.01267004f, 0.08545646f, 0.00976256f, -0.02538461f, 0.05257119f, 0.01313968f, 
    -0.11656917f, -0.34709746f, 0.14876269f, 0.23142898f, -0.01371731f, 0.11540800f, -0.10034215f, 0.08376200f, 
    0.01553039f, 0.10762423f, 0.01086817f, -0.09076911f, -0.00973878f, 0.12340579f, 0.39954209f, 0.22695823f, 
    0.21217811f, 0.06792111f, -0.10118183f, -0.11953501f, -0.06944065f, 0.09756429f, -0.02742416f, -0.01597933f, 
    0.07677503f, 0.21231659f, -0.05954772f, -0.06873886f, 0.06372713f, -0.22511944f, -0.03791339f, 0.17557359f, 
    0.06504805f, -0.01735468f, 0.01939455f, 0.04255999f, -0.12724705f, -0.02783018f, 0.09856956f, 0.14074315f, 
    0.05183962f, -0.05246415f, 0.00628577f, -0.10074348f, 0.02400219f, -0.06434780f, 0.03916998f, -0.00482756f, 
    -0.26642162f, -0.43423864f, 0.16937457f, 0.14601898f, 0.10434072f, -0.00781740f, -0.17247023f, 0.03639016f, 
    0.11474832f, 0.02754034f, -0.06044127f, 0.00349491f, -0.09172998f, -0.13452341f, -0.37563625f, -0.12753692f, 
    0.00110641f, 0.05686628f, -0.04716021f, 0.05386112f, 0.05093629f, -0.10715356f, 0.13319677f, -0.09228149f, 
    0.40991384f, 0.11850702f, -0.14807959f, 0.29105628f, -0.14532270f, 0.01016010f, 0.23732501f, 0.01692004f, 
    0.01916704f, 0.08374193f, -0.19467893f, 0.10284117f, -0.00257820f, 0.04108023f, -0.03811711f, 0.19539617f, 
    -0.14310177f, -0.06384094f, -0.12576383f, 0.08039230f, 0.00874459f, -0.05066978f, -0.07255707f, -0.01203042f, 
    0.46346813f, 0.07244822f, -0.46898499f, 0.00291865f, -0.01203401f, -0.01750007f, 0.30306259f, 0.10734659f, 
    0.05658012f, 0.00741582f, 0.08523712f, 0.03486818f, -0.17151354f, -0.22877425f, -0.10724165f, 0.01556681f, 
    -0.12845853f, -0.01585439f, 0.17778993f, 0.03575554f, 0.13849241f, -0.07541168f, 0.05485984f, 0.07331594f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02749496f, 0.02575053f, 0.06598692f, 0.04284848f, 0.14651126f, -0.12176262f, -0.04865650f, 0.18328245f, 
    0.03284861f, -0.04583910f, 0.12489522f, 0.21615866f, 0.04977948f, 0.02173451f, 0.02561444f, -0.03967536f, 
    0.01257201f, 0.13223296f, 0.13537002f, 0.01168635f, 0.14353774f, -0.02570682f, -0.06180191f, 0.12797883f, 
    -0.07024894f, 0.18447261f, -0.01864016f, 0.06134880f, -0.07925311f, 0.08437624f, -0.00128526f, 0.18963842f, 
    0.02519667f, -0.04307966f, 0.00121584f, 0.16559550f, 0.16471645f, 0.17352125f, -0.03094099f, 0.13614087f, 
    -0.06393804f, 0.12081430f, -0.03403605f, -0.08361772f, 0.16488244f, -0.07765771f, -0.04822955f, 0.08945142f, 
    -0.03894708f, 0.11533644f, -0.07379404f, 0.03184077f, -0.04682631f, 0.21322466f, -0.03291416f, 0.03657044f, 
    0.01938196f, 0.19282515f, 0.12073869f, 0.00791107f, 0.02168894f, 0.02315962f, -0.05609707f, -0.06841040f, 
    -0.07436633f, 0.10234547f, 0.09237662f, 0.11076654f, -0.08511459f, 0.02801514f, 0.12354165f, -0.07944749f, 
    -0.06464708f, -0.06358004f, -0.03473870f, -0.07457881f, 0.02303416f, -0.07615014f, 0.00059207f, 0.16205585f, 
    -0.05629044f, -0.02223426f, 0.04806169f, 0.00880620f, -0.06414232f, -0.01440516f, -0.03908023f, 0.13374743f, 
    -0.01843139f, 0.06722327f, -0.00795992f, 0.04401163f, -0.18868527f, -0.05043481f, 0.13181359f, -0.02883107f, 
    -0.06660098f, 0.10074870f, 0.04779551f, -0.05712874f, -0.00668481f, 0.06639340f, -0.00054756f, -0.08280490f, 
    0.03267473f, 0.09404859f, 0.06742056f, 0.03059001f, 0.01346336f, 0.05383899f, 0.02992832f, 0.03742121f, 
    0.00379891f, -0.02916447f, 0.00809629f, -0.00262692f, -0.00095239f, 0.11823100f, -0.01204304f, 0.02645972f, 
    0.19460241f, 0.19076881f, 0.14873855f, -0.06455633f, 0.02970421f, -0.00528600f, 0.09315532f, 0.00640090f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.17639157f, 0.02815167f, 0.09993720f, 0.22657895f, -0.18073697f, -0.11456463f, 0.02090551f, 0.11302064f, 
    0.03321073f, -0.09116422f, 0.06322007f, -0.39210621f, -0.34960145f, -0.07023813f, 0.07255264f, -0.37409621f, 
    0.04381714f, -0.46866229f, -0.50818843f, -0.19142561f, 0.05596718f, -0.02421627f, -0.03245674f, -0.40330133f, 
    -0.22338131f, -0.15712459f, -0.03074214f, -0.16609366f, 0.04217660f, 0.19706115f, -0.06740987f, -0.47870597f, 
    0.07918609f, 0.00459601f, 0.15437782f, -0.17571683f, -0.02647044f, 0.06851260f, 0.13421197f, 0.00525509f, 
    0.10750543f, -0.38510618f, -0.08051688f, 0.04257624f, -0.19151159f, -0.08266581f, 0.16945964f, -0.25429937f, 
    -0.07861738f, 0.10411096f, -0.00919850f, -0.08301231f, -0.19770819f, -0.29943150f, 0.16668279f, 0.07956981f, 
    0.14649999f, 0.10734165f, 0.05767206f, -0.32237518f, 0.20259635f, -0.08845203f, -0.00524601f, 0.07144678f, 
    -0.02505613f, 0.15455322f, -0.13021566f, -0.02042462f, 0.16280232f, -0.10444809f, -0.16836612f, 0.02577403f, 
    0.06629321f, 0.09028459f, -0.09624746f, -0.06945564f, 0.43896228f, 0.14698553f, -0.01969952f, -0.60421693f, 
    0.14847697f, -0.02976881f, 0.12951365f, -0.19355707f, 0.00132408f, -0.47677600f, 0.22324406f, -0.35382426f, 
    0.12325925f, -0.10796278f, 0.00691014f, -0.23472607f, 0.12540604f, -0.22157751f, 0.03582742f, 0.03847940f, 
    -0.00544403f, -0.25130278f, -0.00199895f, -0.06958457f, 0.19287814f, -0.07073402f, 0.09284854f, 0.35807297f, 
    -0.46379790f, -0.23976438f, 0.15586111f, 0.06655393f, -0.00473068f, -0.10677414f, -0.02624370f, 0.06715602f, 
    0.03024609f, 0.20261249f, 0.03323824f, -0.09922288f, -0.22326200f, -0.44237965f, 0.19567749f, -0.29275391f, 
    -0.32428405f, -0.12490717f, -0.31992275f, -0.02982756f, 0.21317354f, -0.39191157f, 0.14612243f, -0.33079013f, 
    0.13536437f, -0.15772021f, 0.14155404f, 0.21497719f, 0.15635946f, -0.22319034f, -0.46366429f, 0.10908253f, 
    -0.01346177f, -0.02202735f, -0.03583536f, 0.00320868f, 0.06764568f, 0.06985044f, 0.10216835f, -0.12700759f, 
    0.01183031f, -0.21372731f, -0.08454363f, 0.38514161f, 0.06519142f, -0.12384776f, -0.01826477f, -0.25544506f, 
    0.02447456f, 0.43579715f, -0.29236248f, 0.04546656f, -0.06592902f, 0.11735451f, -0.16621022f, 0.12227585f, 
    -0.01907109f, -0.05711043f, 0.26607955f, -0.15902717f, 0.12070660f, -0.02673864f, -0.50596637f, 0.04186502f, 
    -0.11059967f, 0.01157016f, 0.05278378f, -0.10236392f, 0.14714958f, -0.05029127f, -0.05222605f, -0.00691122f, 
    0.00659155f, -0.08338729f, -0.20521078f, 0.10212545f, 0.21309210f, 0.18303706f, 0.15044998f, 0.14179474f, 
    0.12821142f, 0.16869707f, 0.10275013f, -0.38172090f, -0.14652567f, -0.06339235f, 0.06948181f, 0.12202225f, 
    0.00139387f, -0.53917509f, -0.05004651f, -0.08803882f, 0.03458942f, 0.25404614f, -0.06147670f, -0.02190527f, 
    -0.07467884f, 0.03445811f, 0.09015883f, -0.05857377f, 0.17714086f, -0.05728741f, -0.00697841f, -0.04457677f, 
    0.07262672f, -0.05787893f, -0.44476449f, 0.26379529f, -0.06170621f, -0.04303600f, -0.59831047f, 0.15558052f, 
    0.01631881f, -0.41532424f, -0.01651320f, -0.20544453f, -0.02253375f, 0.02530723f, 0.19102600f, 0.07230397f, 
    0.02954039f, 0.09576032f, 0.10241354f, -0.03023518f, -0.00522863f, -0.04474975f, 0.07620509f, -0.16475479f, 
    -0.09499841f, 0.33042693f, 0.08596570f, 0.11898868f, -0.07296602f, -0.27741128f, 0.01468422f, -0.00642596f, 
    -0.04181997f, 0.05590312f, -0.13716112f, 0.17999920f, 0.04095818f, -0.03680179f, 0.02959472f, 0.00256184f, 
    0.19571719f, 0.10271709f, 0.08819594f, -0.04093285f, 0.15933102f, -0.19929866f, 0.17139223f, -0.34607479f, 
    -0.02405556f, -0.26073611f, 0.00966495f, -0.09256640f, 0.24004647f, -0.08057058f, -0.08535213f, 0.00596499f, 
    0.06151123f, -0.00995903f, 0.07667324f, 0.09815443f, -0.13471708f, -0.05479357f, 0.10573120f, 0.07374538f, 
    0.05417454f, -0.03091902f, 0.22050469f, -0.39050665f, 0.00155737f, 0.00609379f, -0.04720607f, 0.23564544f, 
    -0.27426106f, 0.40415692f, -0.23918308f, 0.05104504f, -0.01831980f, 0.10120746f, 0.00333336f, -0.10681690f, 
    -0.19714382f, -0.13215218f, -0.05704379f, 0.08340621f, 0.14946496f, 0.25978166f, 0.13103925f, 0.31172910f, 
    -0.40432620f, -0.07839022f, 0.06126552f, 0.17742978f, 0.07624729f, 0.04215766f, -0.06499822f, -0.12478165f, 
    -0.03352038f, 0.00071795f, -0.32372874f, 0.01662883f, -0.65861416f, 0.39400846f, -0.63010764f, -0.04598466f, 
    0.07943776f, 0.22475992f, -0.12329399f, 0.08167796f, -0.25891161f, 0.03767445f, -0.04415714f, -0.30418685f, 
    0.02482350f, 0.35086218f, 0.15748610f, 0.12402249f, -0.41686785f, 0.06682342f, -0.27361739f, 0.04176138f, 
    0.01251819f, 0.07715044f, 0.12124935f, -0.08120672f, -0.27974477f, 0.14401790f, 0.01546214f, 0.21593660f, 
    -0.10259102f, -0.16677544f, 0.09578696f, -0.17319551f, 0.05939190f, 0.15857396f, 0.22390085f, 0.22574626f, 
    -0.22455364f, 0.20142230f, 0.00087635f, -0.30621234f, -0.67591691f, -0.38489923f, -0.16686805f, 0.05709703f, 
    0.07297935f, -0.04049408f, 0.00443187f, -0.08692678f, -0.29082468f, -0.03710496f, -0.07181502f, -0.41847622f, 
    0.15463926f, -0.63423705f, -0.34508246f, -0.01107278f, 0.01232271f, 0.11198088f, -0.09380354f, 0.06843826f, 
    0.00714322f, -0.14156789f, 0.09533292f, 0.10390797f, -0.15660387f, 0.09945720f, 0.07728710f, -0.04487725f, 
    0.23257545f, 0.17217368f, 0.19879064f, 0.07763396f, -0.06198300f, -0.03475932f, -0.08659446f, -0.25546476f, 
    0.04605422f, -0.17485474f, -0.06447463f, -0.23325275f, -0.28208604f, 0.21423125f, 0.12046696f, -0.10954134f, 
    -0.03130623f, -0.06345526f, 0.05431381f, 0.15415014f, -0.13400671f, -0.08418845f, -0.26040736f, -0.02853214f, 
    -0.00546183f, 0.30607739f, -0.22409388f, -0.30762479f, -0.03598396f, 0.06863105f, -0.03354282f, 0.18321870f, 
    -0.05443478f, -0.19579189f, 0.07988530f, 0.41530502f, 0.16585535f, -0.38413271f, 0.16253881f, -0.08069478f, 
    0.19033778f, 0.15737359f, -0.04956494f, 0.05553193f, -0.40861952f, -0.05202840f, 0.18938310f, 0.19089583f, 
    0.00502214f, 0.07744389f, 0.00072300f, -0.17859301f, -0.41940111f, 0.06546158f, 0.01733252f, 0.12009515f, 
    0.02960108f, -0.32018125f, -0.08402017f, -0.06174845f, -0.03559605f, -0.29283491f, -0.27065775f, -0.04689238f, 
    0.13086970f, -0.24274236f, -0.44423333f, 0.24093129f, -0.26055118f, 0.04397132f, 0.08194358f, 0.05565604f, 
    0.01188260f, 0.26316190f, -0.46172398f, 0.13859834f, 0.03658013f, 0.06469196f, -0.44434467f, 0.01766277f, 
    0.01459355f, -0.06770788f, 0.27759323f, -0.03042768f, -0.30309203f, -0.03830151f, 0.03820621f, 0.08561132f, 
    0.12667620f, 0.00659106f, -0.01638019f, 0.19649826f, 0.05223247f, -0.15207630f, 0.01882821f, -0.08468100f, 
    0.15614520f, -0.39765853f, 0.05712784f, 0.07106959f, 0.26675171f, -0.07403708f, -0.35511121f, 0.00176569f, 
    -0.05453256f, -0.31346601f, -0.49758765f, -0.05250530f, -0.13161953f, 0.04533065f, 0.18757693f, 0.11257750f, 
    0.09708043f, -0.38028881f, 0.15080255f, -0.38200459f, -0.00415250f, 0.32546046f, 0.04793854f, -0.06648440f, 
    0.07876454f, 0.11220887f, 0.25968176f, 0.37138611f, 0.07979577f, 0.22483762f, -0.27005202f, -0.25240543f, 
    -0.26660612f, -0.14528063f, -0.27165028f, -0.01871227f, -0.11169565f, 0.07051084f, 0.08352080f, -0.27841768f, 
    -0.03130211f, -0.04392803f, 0.15443414f, -0.18483841f, -0.12514567f, -0.05213683f, 0.21337180f, -0.11218815f, 
    -0.09794851f, -0.00544392f, 0.03092881f, -0.36615005f, -0.12922607f, -0.07337303f, -0.05225180f, 0.08311504f, 
    -0.01124037f, -0.12164295f, 0.18568690f, -0.38947910f, 0.05422806f, 0.17682943f, 0.05037212f, -0.80327320f, 
    0.12681240f, 0.15020308f, 0.22567974f, 0.07853119f, 0.09869561f, -0.10932668f, -0.15522754f, 0.06972159f, 
    -0.11088412f, -0.03630226f, 0.02272776f, -0.54014683f, -0.05671823f, -0.04896947f, 0.17682931f, -0.09169204f, 
    0.17634355f, 0.02093159f, 0.06464527f, 0.12726013f, 0.06004856f, 0.06956179f, -0.00995008f, -0.07216271f, 
    0.04904034f, -0.17806298f, -0.06052555f, 0.07941116f, 0.17110784f, -0.22016209f, 0.14479719f, 0.20068489f, 
    0.00322572f, -0.29303020f, -0.22581206f, 0.11208968f, 0.11101364f, 0.06796549f, 0.03049025f, 0.12583610f, 
    0.05781015f, -0.05022505f, 0.00896543f, 0.08433953f, -0.10660361f, 0.04645257f, 0.00923770f, -0.06431358f, 
    -0.06870215f, 0.09007281f, 0.04761375f, 0.08067160f, -0.20317712f, -0.01810035f, 0.06348918f, -0.03366473f, 
    -0.06461041f, 0.02084664f, 0.11571648f, -0.40290570f, 0.06653000f, 0.09474923f, 0.06281750f, -0.33504531f, 
    0.00038670f, 0.34640747f, -0.08185250f, -0.19474882f, 0.04274978f, 0.16637369f, -0.01574819f, 0.02551729f, 
    -0.06636673f, -0.03939211f, 0.01496718f, 0.05060882f, 0.05736541f, 0.00615098f, 0.09331382f, -0.51160812f, 
    0.09791101f, 0.07396272f, -0.02695491f, 0.04047511f, 0.01846192f, -0.03593882f, 0.06962419f, -0.03771547f, 
    0.03606063f, -0.14536452f, -0.22744812f, -0.51365960f, -0.12763388f, -0.05404818f, 0.04364897f, 0.01494683f, 
    0.06527836f, 0.14732359f, 0.07278302f, -0.04335886f, -0.44056785f, -0.03648380f, -0.21433093f, 0.20860781f, 
    0.16284868f, 0.28202355f, -0.10826479f, 0.05471474f, 0.13356318f, -0.28231516f, -0.00305409f, 0.07929605f, 
    0.02563199f, 0.02261708f, 0.13576208f, 0.23202546f, 0.02513903f, -0.06002712f, -0.20589086f, -0.02261288f, 
    -0.00245613f, 0.04027072f, -0.07530134f, -0.41688973f, 0.15086915f, -0.00353352f, 0.04459604f, 0.06373917f, 
    0.03744768f, -0.18529694f, -0.05617804f, -0.32093084f, -0.20766461f, 0.00910855f, -0.00662790f, 0.16198057f, 
    0.13029154f, 0.14592399f, -0.25208148f, 0.06808974f, 0.02530041f, -0.01325284f, -0.27313724f, -0.01599227f, 
    0.10207812f, -0.09397752f, -0.07042716f, -0.10350833f, -0.04167391f, -0.00664406f, -0.14867294f, 0.14721815f, 
    -0.02197985f, 0.01205306f, 0.21641521f, -0.25562450f, 0.00576138f, -0.21736191f, 0.02693154f, 0.06145706f, 
    -0.06134736f, -0.12795708f, 0.06306025f, -0.28571177f, 0.34597403f, -0.09249818f, -0.02222651f, 0.11369699f, 
    -0.05179434f, 0.07986862f, -0.14820178f, 0.08147869f, 0.12547362f, -0.21196383f, 0.35753098f, 0.05169817f, 
    -0.03351395f, -0.15526271f, -0.49471825f, 0.06295661f, -0.23673853f, -0.14317575f, -0.08702142f, -0.06387504f, 
    -0.04825779f, -0.07327083f, -0.07529102f, 0.04818704f, 0.04638301f, -0.39427629f, -0.05741865f, 0.13115607f, 
    0.15981233f, 0.44549817f, 0.02282786f, 0.03978359f, -0.44959423f, 0.03051839f, 0.10857332f, 0.05599605f, 
    -0.06945679f, 0.21213958f, 0.10689941f, -0.08016517f, 0.13084064f, -0.03706652f, -0.25467485f, 0.32833049f, 
    -0.00592298f, -0.44692233f, 0.14810389f, 0.05640991f, -0.04054971f, -0.65597832f, -0.08088089f, -0.03872034f, 
    -0.04870345f, -0.30370793f, 0.06270596f, -0.65256405f, 0.01883893f, -0.22342035f, 0.05862155f, 0.01687448f, 
    -0.13914859f, -0.03394482f, 0.06037678f, 0.05415267f, 0.15429714f, -0.03035678f, 0.14461619f, 0.16036135f, 
    -0.25888243f, 0.16969314f, -0.42116433f, -0.33651257f, -0.08845065f, -0.16547924f, -0.16643880f, -0.40101150f, 
    -0.06572461f, -0.06427988f, -0.65570253f, 0.01904012f, 0.15252331f, -0.05616726f, -0.14305848f, 0.15424095f, 
    0.05527198f, -0.20548093f, 0.16809596f, 0.12490753f, -0.45733646f, -0.23026423f, 0.03670550f, 0.20503491f, 
    0.16613601f, -0.40809619f, -0.31956384f, -0.31790587f, 0.08850729f, -0.14727524f, 0.13273901f, 0.10641180f, 
    -0.24775775f, -0.36665773f, -0.61468852f, 0.22534619f, 0.17173846f, -0.36661229f, 0.08573376f, 0.34247118f, 
    -0.23298483f, 0.28920445f, -0.06724042f, 0.03202618f, 0.09735212f, -0.06295875f, -0.09821035f, 0.02282893f, 
    0.05078588f, 0.08794482f, 0.05640365f, 0.26287562f, -0.03295326f, -0.15732285f, -0.13581988f, -0.72758162f, 
    -0.19979091f, -0.10512086f, 0.22686093f, 0.13082829f, -0.02619431f, 0.01722394f, 0.08620667f, -0.06757389f, 
    0.02201315f, -0.23259668f, 0.23102219f, -0.16552767f, -0.67040050f, -0.33976585f, 0.49456671f, 0.01060610f, 
    0.02590898f, 0.08967694f, 0.10638497f, 0.02276539f, 0.12340856f, -0.25409010f, 0.01857760f, 0.04547742f, 
    -0.22398067f, -0.07263240f, 0.28209546f, -0.07026184f, -0.06831214f, 0.07289734f, -0.24299787f, -0.06294445f, 
    -0.26067355f, 0.31902114f, -0.06714320f, -0.22545412f, -0.57010096f, -0.04818466f, -0.28320745f, -0.03390469f, 
    -0.03074848f, 0.21178707f, -0.08275910f, -0.03605939f, 0.08899597f, 0.05859654f, -0.57742387f, -0.34370977f, 
    -0.08313036f, 0.02465560f, -0.55753511f, 0.01764497f, -0.02116179f, 0.07911675f, 0.04718952f, 0.01197450f, 
    -0.05356890f, 0.10418396f, 0.05256740f, 0.23860706f, 0.06003717f, 0.21686481f, -0.10404325f, 0.16859843f, 
    0.07261638f, 0.25251180f, 0.04262194f, -0.00285592f, -0.13776332f, 0.00126306f, -0.26785433f, 0.24768795f, 
    -0.27308998f, -0.06693864f, -0.29965290f, -0.10966205f, 0.19211718f, 0.15548991f, 0.41305867f, -0.22493784f, 
    0.04931231f, 0.03079855f, -0.35640231f, 0.02119107f, 0.07180715f, 0.01225100f, 0.14096202f, 0.14389251f, 
    -0.06222756f, 0.14102840f, -0.13693856f, 0.04641465f, -0.14689630f, -0.23074675f, 0.04725191f, -0.01649153f, 
    0.13187216f, -0.39937925f, -0.20900293f, 0.04373631f, -0.07155036f, 0.10816439f, 0.14575565f, -0.17718947f, 
    -0.05739821f, -0.05284999f, -0.25189516f, -0.16763566f, 0.01430453f, -0.09609478f, 0.37106025f, -0.41092059f, 
    -0.13549297f, -0.43749025f, 0.05795358f, 0.12146214f, -0.16763215f, -0.08889917f, -0.10580570f, -0.01644903f, 
    -0.05757438f, -0.17010191f, -0.16287613f, 0.14293802f, 0.05342163f, -0.28324074f, 0.10824960f, -0.29976729f, 
    -0.11840706f, 0.13482320f, -0.00746179f, 0.16860375f, -0.35174674f, 0.07658726f, 0.03980729f, -0.02507363f, 
    0.03734602f, 0.09046432f, -0.06016114f, -0.42117769f, 0.20602675f, 0.29014581f, -0.23269756f, -0.08041146f, 
    0.04770166f, 0.05755244f, 0.07433396f, 0.05504081f, -0.07068672f, 0.12444516f, 0.00049296f, 0.20742060f, 
    -0.29545340f, -0.07362752f, -0.42010367f, -0.04617632f, -0.08548598f, 0.06885033f, 0.19768426f, -0.02263732f, 
    0.08097669f, -0.28751549f, 0.07631131f, -0.19755019f, 0.17205122f, -0.06844115f, 0.18593752f, 0.05188612f, 
    0.06465783f, -0.13779706f, 0.02549733f, -0.03433570f, -0.33748001f, -0.05646896f, 0.20214069f, 0.36094445f, 
    0.19566260f, 0.03773857f, -0.20465907f, -0.17625284f, -0.04858480f, 0.03242351f, -0.01493707f, -0.00521908f, 
    0.01566843f, -0.07520589f, 0.05926422f, -0.09194747f, 0.11049031f, -0.29584840f, -0.17774329f, 0.05365117f, 
    -0.31564534f, -0.20119505f, 0.07985130f, -0.01955818f, -0.17831574f, 0.13485083f, -0.03278781f, -0.15223993f, 
    0.16029505f, -0.05880723f, 0.22154400f, 0.07594221f, 0.13924445f, 0.26012260f, -0.68251866f, 0.25081357f, 
    -0.06028562f, 0.06702735f, -0.40607601f, 0.20847267f, 0.12209723f, -0.05791620f, 0.16449274f, -0.15764637f, 
    -0.03475733f, 0.31138074f, -0.13919885f, -0.26538169f, 0.09500933f, -0.75447005f, -0.00739378f, 0.26424807f, 
    -0.41892788f, -0.32742682f, 0.09001274f, -0.00968243f, -0.03097930f, -0.04059589f, 0.16061360f, 0.26037452f, 
    0.17215197f, 0.10917148f, -0.65715033f, 0.14435543f, -0.34325072f, 0.27083719f, -0.36155564f, -0.20012808f, 
    -0.67813671f, -0.19144072f, 0.06561495f, -0.19332157f, 0.19640109f, 0.05344168f, 0.26897523f, -0.08090180f, 
    -0.05992511f, -0.05076970f, 0.18636374f, -0.04933008f, -0.04139607f, 0.01872517f, 0.22974434f, -0.60412431f, 
    -0.22076413f, 0.13855818f, 0.13007444f, 0.01465741f, -0.47175804f, -0.00340125f, 0.00834977f, -0.25722158f, 
    0.00218679f, 0.13941436f, -0.06962816f, 0.03599063f, 0.16394804f, -0.16136096f, -0.09894008f, -0.06512012f, 
    -0.01301231f, -0.16440752f, 0.05795984f, 0.06743703f, 0.18605562f, 0.08440454f, 0.00737432f, 0.19235976f, 
    -0.20586888f, 0.04638377f, -0.34150136f, -0.29315189f, 0.02442866f, -0.00360982f, -0.24148932f, 0.18307918f, 
    0.08961831f, -0.30686349f, 0.01107413f, 0.02888075f, -0.22767082f, 0.12540641f, 0.08080251f, 0.00930171f, 
    0.02013206f, -0.15218779f, -0.14524475f, 0.08230714f, -0.29544559f, -0.00747107f, -0.30279356f, 0.08887161f, 
    -0.09928032f, -0.03519700f, -0.44034046f, -0.00802383f, 0.00328383f, 0.16599193f, -0.00052807f, -0.07786072f, 
    -0.04694336f, 0.05467514f, 0.16863695f, -0.42796323f, -0.00167797f, 0.01072974f, -0.16364588f, -0.18046109f, 
    -0.36932337f, -0.47553971f, 0.13831598f, -0.05822933f, 0.21278687f, -0.14172535f, 0.16232207f, -0.19291371f, 
    -0.24707863f, -0.05600731f, -0.18730998f, -0.32883018f, -0.20260507f, 0.01597375f, 0.14674827f, -0.14229092f, 
    0.00203927f, 0.00492171f, 0.00286864f, -0.22269094f, 0.10864446f, -0.01275318f, 0.11885486f, 0.11856443f, 
    -0.01997626f, -0.34363887f, 0.14062028f, 0.21483663f, -0.16895053f, 0.16561286f, 0.00411188f, -0.37209791f, 
    -0.19056779f, 0.24079299f, -0.05981391f, 0.25872436f, 0.05222571f, 0.11525446f, 0.07970704f, -0.14707696f, 
    -0.27376544f, -0.54561979f, 0.44093674f, 0.19101107f, 0.25423166f, -0.50819486f, 0.01171822f, -0.32469136f, 
    -0.00076080f, 0.03450249f, -0.00723919f, 0.17355004f, -0.07362770f, -0.09663437f, 0.06657828f, -0.25623152f, 
    0.03958762f, -0.15497726f, -0.26432106f, -0.30501169f, 0.11954779f, -0.26584741f, 0.42063275f, -0.00109530f, 
    -0.41144198f, -0.03835049f, 0.06742465f, 0.17341726f, 0.13519585f, 0.07841932f, -0.05841183f, 0.00073509f, 
    -0.04407964f, 0.02553649f, 0.26644611f, 0.33710518f, 0.16145390f, -0.12496332f, -0.18687308f, -0.01006585f, 
    0.00638537f, -0.11484819f, -0.12804182f, -0.03136220f, -0.27479649f, -0.27363437f, 0.03822918f, 0.11268970f, 
    -0.03164515f, -0.02748716f, 0.24001698f, -0.14948432f, -0.07064824f, 0.15049203f, -0.02019523f, -0.46470842f, 
    -0.37188619f, -0.19682321f, 0.03118020f, 0.00618134f, -0.41728297f, -0.24607737f, -0.08024965f, -0.02228301f, 
    0.03366801f, 0.06662861f, -0.15592985f, 0.01778047f, 0.22333263f, -0.07110115f, 0.33761388f, 0.15347505f, 
    -0.10900024f, 0.17850552f, 0.15790789f, 0.01481737f, 0.01980478f, 0.28017429f, 0.06028350f, 0.00493670f, 
    0.08016144f, -0.26403552f, -0.01743937f, -0.04125753f, -0.14916655f, -0.05689953f, 0.02499107f, 0.07425034f, 
    -0.08702907f, -0.04369041f, 0.22025914f, -0.05908948f, -0.39039716f, 0.11725070f, -0.48522371f, 0.12781937f, 
    -0.17371540f, 0.25587565f, 0.11895592f, 0.00235700f, -0.41158068f, 0.01983988f, -0.10713854f, 0.20501669f, 
    0.04825164f, 0.00050932f, -0.27338037f, 0.00848523f, 0.10780603f, 0.02795124f, -0.49746573f, -0.09511511f, 
    -0.08242862f, 0.30992344f, -0.12905908f, -0.05279847f, 0.21649823f, -0.31486326f, 0.03785557f, -0.01178228f, 
    0.02688230f, -0.52234894f, 0.11381923f, -0.09335992f, -0.59217250f, -0.22759755f, -0.31756860f, -0.14510083f, 
    0.26494879f, 0.26655671f, 0.32884437f, -0.03058105f, 0.00401188f, 0.18751729f, -0.55186367f, -0.21251804f, 
    0.10428278f, 0.21941276f, 0.03839739f, 0.08547434f, -0.05539551f, 0.07699624f, 0.33379716f, 0.10096172f, 
    -0.03372093f, 0.41404283f, 0.27194408f, 0.06740986f, -0.29191852f, 0.18204759f, -0.77798128f, -0.10278086f, 
    0.06440775f, -0.32072616f, -0.10541890f, 0.15764977f, -0.22324948f, -0.04766605f, 0.04921531f, -0.42223886f, 
    -0.03522461f, -0.43353331f, -0.02250572f, -0.21696553f, -0.01160693f, -0.02985016f, 0.29044113f, -0.04238626f, 
    0.06402718f, 0.25532332f, 0.18087569f, -0.00356937f, -0.42562762f, 0.16602889f, 0.05066264f, -0.17271976f, 
    0.11226600f, -0.09823722f, -0.39203689f, 0.08394053f, -0.06700226f, -0.42067826f, -0.30977902f, 0.16149940f, 
    -0.08088203f, -0.04432459f, -0.01417831f, 0.42639545f, 0.05256223f, -0.46784219f, 0.11719167f, -0.05461710f, 
    -0.01211632f, -0.20471047f, -0.54577529f, -0.05995127f, -0.33675310f, -0.09911786f, 0.14995743f, -0.33752048f, 
    0.05013733f, 0.03381320f, -0.46938550f, 0.21085398f, -0.05411863f, -0.05429363f, -0.05493739f, -0.02239243f, 
    -0.00097143f, -0.55134708f, -0.19921547f, -0.12955539f, 0.29054511f, 0.23334920f, -0.08657509f, 0.12925772f, 
    0.06627605f, 0.06012807f, 0.26540145f, 0.00693303f, -0.07170554f, 0.12778093f, 0.23188227f, 0.27387094f, 
    -0.25610805f, -0.20732053f, -0.31195095f, 0.17664340f, -0.18139045f, 0.20723084f, -0.16059220f, -0.14009504f, 
    0.05647938f, -0.06320137f, -0.00915662f, 0.16612726f, -0.00728345f, -0.03202248f, -0.13016632f, 0.13758112f, 
    -0.06852813f, -0.14207439f, 0.16282371f, -0.17756695f, -0.02579489f, 0.13621248f, -0.07096157f, 0.22223079f, 
    -0.05213922f, -0.45437348f, 0.00139131f, -0.34357899f, 0.27561057f, -0.24272513f, -0.05072388f, 0.08972586f, 
    0.04566168f, 0.26081055f, -0.46886992f, -0.00057517f, -0.31094873f, -0.24506824f, -0.25059441f, -0.32332501f, 
    0.13934356f, 0.20758836f, 0.01406164f, -0.37354732f, -0.20764601f, 0.05063761f, 0.01784804f, -0.12030217f, 
    -0.02563000f, 0.00048479f, 0.35815811f, -0.04433345f, 0.10290447f, 0.38196939f, -0.22844538f, -0.15070234f, 
    0.13953792f, 0.01732716f, 0.00070624f, -0.14674404f, -0.17822473f, 0.01120971f, -0.00437515f, -0.19702789f, 
    0.06090192f, 0.06093081f, -0.33036491f, -0.17163025f, -0.02433532f, -0.38404152f, 0.05951123f, -0.08386983f, 
    -0.01965266f, -0.25206450f, 0.03856432f, -0.02185358f, 0.32251623f, 0.12352140f, 0.06682684f, -0.19480132f, 
    -0.17380226f, -0.01504583f, -0.10505400f, -0.05350748f, -0.02772618f, 0.20398858f, 0.43751404f, 0.05249486f, 
    -0.52594650f, -0.03342761f, 0.00276150f, 0.38005364f, -0.35470414f, 0.18346854f, -0.21334678f, 0.02843919f, 
    0.04827023f, 0.11879667f, 0.07520909f, -0.08343051f, 0.13927135f, -0.02734218f, -0.45707566f, -0.48696661f, 
    0.20022775f, -0.21128695f, 0.11098630f, 0.10335896f, -0.01029844f, 0.01770907f, 0.03399166f, -0.05673293f, 
    -0.00016635f, 0.22113770f, 0.18013456f, 0.18497168f, 0.20162807f, 0.24627322f, 0.03267168f, 0.07157879f, 
    0.34059247f, -0.06362468f, -0.57304597f, 0.04172158f, 0.03243206f, 0.01720057f, -0.34400228f, 0.20258555f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12994412f, 0.03747761f, 0.13780726f, 0.01280058f, 0.00749443f, 0.09762600f, -0.04531187f, -0.03791628f, 
    0.00155199f, 0.05152188f, 0.07380724f, -0.02849210f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
