#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.74047357f, 0.65917468f, 0.49672383f, 0.34879690f, 0.84547341f, 0.74669778f, -0.38596940f, 0.08467124f, 
    0.36153993f, 0.88480055f, -0.02977596f, 0.66979963f, 0.38526961f, 0.20087425f, 0.51013333f, -0.37703660f, 
    -0.44083783f, -0.03388303f, -0.29856151f, 0.65657353f, -0.04160852f, 0.42680156f, -0.77912009f, -0.44312814f, 
    -0.04226752f, -0.24350843f, 0.63779634f, 0.38246414f, 0.28591195f, 0.31198627f, -0.37216035f, -0.88607848f, 
    0.61018258f, -0.20883918f, 0.00216715f, -0.23189959f, 0.69414788f, 0.71379757f, -0.72355759f, -0.58145565f, 
    0.55622274f, -0.55217105f, 0.36711869f, 0.07746200f, 0.11792222f, 0.54912132f, 0.19701706f, 0.68888170f, 
    -0.96102875f, -0.01272314f, -0.73999482f, 0.06276076f, -0.24174674f, -0.19453508f, -0.71871608f, -0.00544414f, 
    -0.49187121f, 0.30487156f, 0.96715659f, -0.13466170f, 0.00219919f, -0.13630117f, -0.26977462f, -0.90969843f, 
    0.13976330f, -0.09212743f, 0.68132091f, -0.12158407f, -0.72642761f, 0.32743230f, 0.06714782f, -0.25427619f, 
    -0.48312461f, -0.40039402f, -0.80514973f, 0.54579991f, -0.21076101f, -0.18827513f, -0.41484711f, 0.57150275f, 
    0.28462386f, -0.67824942f, -0.16451417f, 0.47990429f, 0.75110179f, 0.71630460f, 0.00493767f, 0.59318161f, 
    0.40704995f, 0.20649295f, -0.77780974f, -0.93432307f, -0.48331928f, 0.57866460f, -0.27182749f, 0.35860494f, 
    0.18570235f, -0.40709350f, 0.27881822f, -0.09798466f, -0.22184944f, -0.81625390f, 0.37955680f, -0.63674271f, 
    0.21279474f, -0.51912975f, -0.45274147f, -0.32350871f, -0.07244359f, -0.31859660f, 0.45418778f, 0.95286453f, 
    -0.92707026f, 0.30362707f, -0.11556480f, 0.02400544f, -0.22970350f, 0.55542511f, -1.11418569f, -0.37275898f, 
    -0.62201315f, -0.57690024f, 0.32396656f, -0.14844359f, 0.07924849f, 0.15122972f, 0.51118934f, 0.52610618f, 
    0.27849010f, -0.56704408f, 0.58226967f, 0.65242553f, -0.21129565f, 0.40569508f, 0.10034057f, 0.93884224f, 
    0.83528244f, 0.60464931f, 0.10631227f, -0.05658680f, -0.15080059f, 0.10082729f, 0.46879077f, 0.14998679f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10760942f, 0.07270625f, -0.42603141f, 0.38889962f, 0.29474342f, 0.35293004f, -0.09341477f, -0.10100505f, 
    0.13367856f, 0.22227092f, -0.20745070f, -0.06903205f, -0.31975916f, -0.08557104f, -0.17137310f, -0.06367216f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.34885523f, 0.28729752f, 0.00959462f, 0.01383849f, 0.21400619f, 0.00746789f, 0.20477681f, 0.03320754f, 
    0.03675150f, 0.04355367f, 0.12815249f, 0.14630288f, -0.07483205f, -0.05833168f, 0.05216603f, 0.16685165f, 
    0.09310865f, -0.06806291f, 0.07558721f, -0.32470709f, -0.09045413f, -0.13338591f, 0.08265828f, -0.07139230f, 
    0.15171489f, -0.00515334f, 0.18218905f, 0.00168614f, 0.21662176f, 0.06537945f, -0.02108319f, -0.04910701f, 
    0.10729722f, 0.00105352f, -0.07210079f, 0.19065097f, 0.26428273f, -0.30092165f, 0.17164207f, -0.11059077f, 
    0.09873382f, -0.13504614f, -0.02304716f, -0.01955689f, 0.03193500f, 0.37188905f, 0.12309311f, 0.00368872f, 
    0.01153141f, -0.02015605f, 0.17611502f, 0.03291913f, -0.05580897f, -0.00983066f, -0.08469327f, -0.33837762f, 
    -0.28257507f, -0.03055188f, 0.03522243f, -0.11119572f, -0.07172931f, -0.11616158f, -0.22622409f, -0.41461018f, 
    -0.07864846f, -0.13847513f, 0.15108962f, -0.06433801f, -0.08384807f, 0.14952055f, -0.02193883f, -0.08091302f, 
    -0.16962026f, -0.27462026f, -0.37306100f, -0.13641357f, 0.22465670f, -0.08757138f, 0.11501296f, 0.02630253f, 
    0.16789855f, -0.20413287f, -0.16985922f, 0.34651905f, -0.13886096f, 0.12642367f, -0.10099886f, 0.09036382f, 
    -0.21997210f, 0.02146115f, -0.14047676f, 0.29398614f, -0.48741636f, 0.06362016f, -0.12955292f, 0.17934094f, 
    0.12943280f, 0.02856372f, -0.02051556f, -0.29011178f, 0.19414915f, -0.32255653f, -0.19251822f, -0.00101063f, 
    -0.14086980f, -0.09440554f, 0.07941236f, -0.19934571f, -0.37960476f, 0.19490296f, 0.24322088f, 0.16871168f, 
    0.18639426f, -0.11962844f, -0.04530747f, 0.00662737f, -0.20928931f, -0.28619093f, -0.02002053f, 0.03141905f, 
    -0.08261643f, 0.05121482f, -0.01128485f, -0.08909668f, -0.06956369f, 0.08896484f, 0.31342098f, 0.11879405f, 
    -0.23074049f, 0.09140100f, 0.00539070f, 0.09839012f, -0.02072811f, 0.08322922f, 0.06870735f, 0.40469298f, 
    0.28899363f, 0.07955298f, 0.02685346f, -0.01113734f, -0.01795788f, -0.07483806f, -0.01058090f, 0.12740272f, 
    0.31135285f, 0.01312381f, -0.04972812f, -0.19515374f, -0.12653837f, 0.20039959f, -0.03418492f, -0.00096110f, 
    0.07926501f, -0.49973267f, 0.13573913f, -0.17668281f, 0.02710561f, 0.02337798f, 0.16587691f, -0.16905068f, 
    -0.02884195f, 0.14079997f, 0.03874494f, 0.18939444f, 0.02363386f, 0.02379991f, 0.27610874f, 0.07730668f, 
    0.17961009f, 0.19896708f, -0.17039725f, -0.57303947f, -0.09721136f, -0.36979190f, -0.11775375f, 0.10655773f, 
    -0.03619522f, -0.15403882f, 0.03562701f, 0.05758909f, 0.16060193f, 0.11297724f, -0.36903217f, -0.08580182f, 
    0.01492415f, 0.12359123f, -0.16051649f, -0.04875509f, -0.05099422f, 0.22304879f, 0.23831411f, -0.04831480f, 
    0.16880135f, 0.07675154f, -0.01338731f, 0.01920755f, -0.09000318f, 0.00931108f, 0.58859378f, 0.10088726f, 
    0.10649126f, 0.10226978f, -0.32792974f, -0.12768437f, 0.18905404f, 0.03674313f, 0.09655032f, 0.44388098f, 
    0.00022569f, 0.08506273f, -0.05399865f, 0.12826526f, -0.14902133f, -0.21259686f, -0.06010854f, 0.04537563f, 
    -0.08449751f, -0.20432007f, 0.10393958f, -0.35831940f, -0.00595156f, 0.10155800f, 0.20004879f, -0.02665059f, 
    0.03944088f, 0.37186792f, 0.29206744f, 0.13251144f, 0.05978390f, -0.08469708f, -0.02462841f, 0.13191929f, 
    -0.02656846f, -0.07784473f, 0.07635624f, 0.07884326f, 0.18374228f, -0.03783595f, 0.09027530f, -0.09633736f, 
    0.02990343f, -0.04505529f, -0.05681447f, -0.12035803f, -0.05335196f, 0.27285472f, 0.04751774f, 0.10807440f, 
    0.17677024f, -0.18059975f, -0.09513953f, 0.21551162f, -0.10094004f, -0.02900609f, 0.06977116f, -0.22168836f, 
    0.06137465f, 0.02112938f, -0.05382114f, -0.13821743f, -0.11318727f, 0.44019505f, -0.20551933f, -0.32037696f, 
    0.01177199f, 0.03928025f, -0.21730167f, -0.08504480f, -0.02434429f, -0.12334657f, -0.19310196f, 0.19197835f, 
    -0.21597050f, 0.00848097f, -0.05117682f, 0.16285314f, -0.05043652f, 0.25533277f, 0.01259684f, -0.17651394f, 
    0.03675157f, 0.09592041f, -0.16037326f, 0.05211806f, 0.19227622f, -0.03724043f, 0.16890220f, -0.21834880f, 
    -0.12326186f, -0.03070339f, 0.29263154f, -0.01623507f, -0.21216206f, 0.01546967f, 0.02834012f, -0.06623353f, 
    -0.06235179f, -0.07943849f, -0.02021979f, -0.37322488f, -0.08847582f, -0.03835886f, 0.33131367f, 0.09688400f, 
    0.22217631f, -0.23046130f, 0.47765324f, 0.00678776f, -0.15029643f, 0.06257179f, -0.26412636f, 0.16078722f, 
    -0.07218558f, 0.08373356f, 0.02409088f, 0.06249373f, -0.35890591f, -0.20933595f, -0.05561590f, 0.22207448f, 
    -0.08507656f, 0.06052895f, 0.04913135f, -0.16635872f, 0.12236761f, -0.01014336f, -0.20027937f, -0.24838942f, 
    -0.07206177f, -0.07581768f, -0.03161344f, 0.00072651f, -0.08038425f, -0.31793410f, -0.04277125f, 0.24657170f, 
    -0.13322951f, -0.01175932f, -0.07805225f, 0.13949670f, -0.07531500f, 0.10620113f, -0.31102511f, 0.43592137f, 
    0.13336575f, 0.02386949f, -0.07761859f, -0.00838414f, 0.06450745f, 0.13743249f, 0.23758014f, 0.46676981f, 
    0.25161353f, 0.12587745f, 0.08831374f, 0.13171282f, -0.04365654f, 0.05177720f, 0.07097910f, -0.07988122f, 
    -0.21801147f, -0.05192217f, 0.05568713f, -0.11766633f, 0.01808085f, 0.08428037f, 0.09291763f, 0.08555092f, 
    -0.07675445f, -0.14627972f, -0.01737203f, -0.03016559f, 0.17257169f, 0.04185251f, 0.12758893f, 0.00340359f, 
    0.07444502f, -0.00713120f, 0.20595814f, -0.02231174f, -0.21099354f, -0.11927886f, 0.01036297f, -0.01819412f, 
    0.01959339f, 0.01303363f, -0.08517765f, 0.23826762f, 0.22068487f, 0.28030112f, 0.01962960f, -0.01518646f, 
    0.13327990f, 0.06948926f, 0.01817811f, 0.13988759f, 0.13021924f, 0.09295148f, -0.11313341f, -0.11710405f, 
    0.15214208f, -0.15361644f, 0.02851378f, -0.00530173f, -0.19384749f, -0.06865393f, 0.13109572f, 0.08432390f, 
    -0.19358991f, -0.14636236f, -0.05982082f, 0.10415842f, 0.01680072f, 0.05729955f, 0.00372111f, -0.15851155f, 
    -0.02493122f, 0.09149322f, 0.14998987f, 0.07948673f, 0.05327332f, 0.11167935f, -0.14006968f, -0.34750143f, 
    -0.33409294f, 0.00222928f, 0.04053316f, 0.04879938f, 0.00592914f, -0.19236967f, 0.00747466f, 0.10050591f, 
    -0.31638291f, 0.11661731f, -0.16235903f, 0.05722370f, -0.14766656f, -0.06337841f, 0.18573597f, -0.02535531f, 
    0.15625770f, -0.51791275f, -0.47216755f, -0.27241454f, -0.08678913f, 0.02141640f, 0.03033996f, -0.03645051f, 
    0.07224805f, 0.12020118f, 0.31386921f, -0.02890853f, -0.42292497f, 0.13785535f, -0.03836041f, -0.01779374f, 
    -0.11778652f, 0.12032969f, -0.21449739f, -0.00445066f, -0.23797382f, -0.01634206f, 0.06434544f, -0.05925736f, 
    -0.03310171f, -0.04804153f, -0.01214067f, 0.00786216f, -0.40437755f, -0.44961181f, -0.03624958f, -0.09679073f, 
    0.01956429f, -0.05653339f, -0.09631379f, -0.10910355f, 0.01225128f, -0.33967662f, 0.17486522f, 0.14763695f, 
    0.16246818f, 0.12888977f, 0.13386299f, -0.19365315f, -0.06477013f, -0.07178549f, 0.39928234f, 0.35282266f, 
    -0.01985851f, 0.09518883f, 0.08986332f, -0.04403000f, 0.08759661f, 0.06964877f, -0.18462500f, 0.24499524f, 
    0.11194658f, -0.12483693f, -0.01598711f, -0.12916908f, 0.12093562f, -0.08605032f, -0.06547614f, -0.01291903f, 
    0.12057310f, 0.23036022f, 0.18569295f, 0.01691664f, 0.00745762f, 0.29439449f, 0.19201483f, 0.19396482f, 
    0.19566528f, 0.01717629f, -0.09450176f, 0.12517954f, -0.04304860f, -0.07640256f, 0.06670514f, 0.07126319f, 
    0.06962576f, 0.23186898f, 0.33760348f, 0.37650728f, 0.02937536f, -0.10751034f, -0.01359430f, 0.23217261f, 
    -0.06958587f, 0.04358970f, -0.06763659f, 0.15663747f, 0.09881680f, 0.02144321f, -0.02190143f, 0.03320802f, 
    0.03770198f, 0.06337323f, -0.14205109f, -0.13493851f, -0.25044456f, -0.12034867f, -0.08890747f, 0.21225828f, 
    -0.00679684f, 0.14686695f, 0.06153414f, 0.14790303f, -0.04034797f, -0.15100917f, 0.09567355f, 0.12427912f, 
    -0.03822777f, -0.04089922f, -0.18177292f, -0.19263057f, 0.14079104f, 0.10204679f, -0.37363929f, 0.09232525f, 
    -0.21511753f, 0.14541408f, -0.00973711f, -0.31485590f, -0.03959635f, 0.02758904f, 0.16835977f, -1.04272532f, 
    -0.31327674f, -0.25502712f, 0.12313526f, 0.00224049f, 0.04927200f, 0.15690696f, -0.01757503f, 0.03477230f, 
    -0.21105069f, 0.02245147f, -0.07105955f, 0.46258786f, 0.19519696f, 0.29270971f, 0.10861946f, -0.04622715f, 
    -0.23363033f, -0.07759271f, 0.22496809f, -0.09752531f, 0.10237571f, 0.06802493f, 0.24553023f, -0.18038850f, 
    0.18874151f, -0.02601344f, -0.14915560f, -0.10874598f, 0.26799628f, -0.29392636f, -0.14333905f, -0.17360847f, 
    -0.17026645f, 0.01283649f, -0.13514003f, 0.02842144f, -0.14553842f, 0.10167042f, -0.02706521f, 0.06311985f, 
    -0.00168724f, 0.00703782f, 0.02421998f, -0.11722073f, -0.23935823f, 0.13228422f, -0.02314627f, 0.08293734f, 
    -0.03243158f, -0.00258638f, 0.01318575f, 0.16770698f, 0.01863274f, 0.16294998f, 0.20727317f, 0.17119220f, 
    0.31458235f, 0.07280525f, 0.06020959f, -0.16648796f, 0.02848545f, -0.13623281f, 0.04062644f, -0.07631622f, 
    0.17896919f, 0.01270794f, -0.10297660f, -0.29094720f, 0.07762292f, 0.44285452f, 0.29379594f, 0.24448630f, 
    -0.11341107f, -0.18544720f, -0.14257303f, -0.23051791f, 0.12890495f, -0.13645531f, 0.07742970f, -0.17841120f, 
    0.16404822f, -0.13401824f, 0.12644164f, -0.03187561f, 0.06571274f, 0.17850530f, 0.01890037f, -0.04174614f, 
    0.27196974f, 0.01193159f, -0.03017306f, -0.23063518f, -0.10383847f, -0.08479395f, -0.17111729f, -0.09126978f, 
    -0.05615529f, -0.07153393f, 0.24172452f, -0.48768204f, 0.23377378f, 0.13946292f, -0.11196822f, -0.04306352f, 
    -0.16870759f, -0.06879013f, -0.08957567f, -0.34095740f, -0.08521401f, 0.16975719f, 0.19552940f, 0.17990212f, 
    0.28524336f, -0.23470606f, -0.02758711f, -0.04465465f, 0.04607834f, -0.00194694f, -0.05384976f, 0.13623600f, 
    -0.02498567f, 0.16399944f, -0.17289369f, -0.11063512f, -0.11935423f, 0.21346466f, -0.30206442f, 0.21906340f, 
    -0.09371696f, 0.20148405f, -0.40886006f, 0.01229582f, 0.19733641f, -0.00978896f, -0.34648263f, 0.19087738f, 
    0.05151419f, -0.08566279f, 0.11578370f, 0.13074723f, 0.00461778f, 0.04498367f, -0.15668413f, -0.47853988f, 
    -0.10964875f, 0.34246847f, -0.01971296f, 0.15001884f, 0.28798121f, 0.01426482f, -0.06770539f, -0.13577247f, 
    0.32868934f, -0.34621692f, 0.04396553f, 0.14892976f, 0.04690690f, 0.20794365f, 0.14316703f, 0.06992840f, 
    -0.00986818f, 0.16369399f, 0.29359517f, 0.01321646f, 0.16013047f, 0.23725225f, 0.10092118f, 0.06632170f, 
    -0.01057873f, -0.17424691f, 0.14030550f, -0.31357458f, 0.03328060f, 0.00176322f, 0.01680449f, -0.13136595f, 
    -0.02471097f, -0.05255130f, 0.01735559f, -0.22735316f, 0.08148880f, 0.25430229f, -0.02620980f, 0.41625211f, 
    -0.09875885f, 0.03310824f, 0.13685125f, 0.06410837f, -0.25553772f, 0.33546931f, 0.41299281f, 0.06165109f, 
    0.02997974f, -0.08218944f, -0.15990865f, 0.15919758f, 0.03045596f, 0.26676142f, 0.24093820f, 0.23771009f, 
    -0.13540825f, 0.11160121f, -0.00227170f, -0.02569838f, -0.01761026f, -0.01713519f, 0.04907002f, -0.34668776f, 
    0.04313850f, -0.10093842f, 0.05100448f, 0.10266852f, -0.01396958f, -0.11584482f, 0.02612824f, -0.09921750f, 
    -0.11273671f, -0.23503466f, 0.01072640f, -0.02026123f, -0.06943966f, 0.24576646f, 0.11914857f, 0.02001982f, 
    -0.23946071f, -0.18562602f, 0.12132041f, 0.15301679f, 0.08479971f, -0.04558479f, -0.03807395f, 0.09737192f, 
    -0.10108210f, -0.00674856f, -0.42191747f, -0.10195132f, 0.23179005f, 0.05128784f, -0.00958503f, -0.08591505f, 
    -0.25954098f, -0.08829633f, -0.39705980f, -0.25630170f, -0.55423719f, 0.19277403f, -0.03141757f, -0.04747459f, 
    -0.07893211f, -0.11177138f, 0.06188183f, -0.09463190f, -0.27084947f, 0.27373248f, -0.15454294f, 0.02166419f, 
    0.03304592f, 0.10737319f, -0.11445783f, 0.14313377f, -0.13550551f, -0.19897118f, -0.57718313f, -0.02719679f, 
    -0.04104723f, 0.33846366f, 0.10716116f, -0.12374396f, -0.19475289f, 0.19473059f, 0.09377671f, -0.57243794f, 
    -0.22460499f, 0.11013860f, -0.12912346f, 0.17358494f, 0.05300109f, 0.07803222f, -0.30253047f, 0.25336015f, 
    0.16857183f, 0.11569484f, -0.04454422f, 0.05620938f, -0.23489925f, 0.03566376f, -0.21071483f, -0.50254107f, 
    0.29090655f, -0.04944819f, 0.04421342f, 0.14990017f, -0.13512459f, -0.14837165f, 0.09301711f, -0.17259303f, 
    0.03034959f, -0.03093445f, -0.05307136f, 0.04911770f, 0.06740262f, 0.01534676f, 0.05474209f, 0.06594593f, 
    -0.04214600f, -0.00527329f, 0.05258662f, -0.06712610f, -0.01408566f, -0.08520381f, -0.03848583f, 0.02978086f, 
    0.04551563f, -0.00543534f, -0.03788986f, 0.02513939f, -0.07323331f, -0.03415645f, 0.00276167f, -0.09465009f, 
    -0.00088038f, 0.03484908f, 0.03981812f, 0.01126019f, -0.01680335f, -0.04064487f, -0.02067542f, -0.00074849f, 
    -0.04661219f, -0.01233222f, 0.05359609f, -0.09141417f, 0.03056446f, 0.05978631f, -0.05672232f, -0.07124799f, 
    0.02460486f, 0.04299771f, 0.04078941f, -0.06757756f, 0.03481310f, -0.05302979f, 0.03086543f, 0.00091209f, 
    0.06402960f, -0.01009219f, -0.03908616f, -0.09955946f, -0.06844160f, 0.05477815f, -0.04720812f, -0.03417099f, 
    0.06012167f, 0.04012175f, -0.06139689f, -0.03801678f, 0.04222483f, -0.08637113f, 0.04096598f, -0.07482824f, 
    0.05290991f, -0.03075096f, -0.05473531f, -0.02599122f, 0.05367543f, 0.04063696f, -0.04880720f, -0.03505712f, 
    -0.05494255f, 0.01914848f, 0.02852854f, 0.06283572f, -0.07358663f, -0.05092073f, -0.04529354f, -0.08178116f, 
    0.00245908f, 0.00342206f, 0.04463798f, -0.08565198f, 0.01531324f, -0.01606256f, -0.06450032f, 0.01699151f, 
    -0.07138510f, -0.06943823f, 0.02814535f, -0.04049780f, -0.07337078f, 0.06210653f, 0.05023700f, 0.04080217f, 
    0.02655921f, -0.07161681f, 0.00620001f, 0.04750453f, 0.03063223f, -0.07388893f, -0.08568779f, -0.04008954f, 
    -0.09406818f, -0.05625167f, -0.04874351f, -0.08777604f, -0.05622442f, -0.01941567f, 0.00022990f, -0.06956594f, 
    -0.04844935f, -0.08539393f, -0.03480271f, 0.03841117f, 0.03846826f, 0.05087132f, -0.01721293f, -0.00065113f, 
    -0.03907198f, 0.05686427f, 0.00879955f, -0.06757478f, 0.03876915f, -0.07706265f, -0.06531455f, -0.02663513f, 
    0.04066778f, 0.03335643f, -0.01955493f, -0.03613977f, 0.05790695f, -0.01002828f, 0.04776889f, -0.08504084f, 
    -0.06674077f, 0.04008750f, -0.07292327f, -0.04457042f, -0.06015521f, -0.06575764f, -0.08870949f, -0.06499818f, 
    -0.01041217f, -0.06549419f, -0.01883795f, -0.03339963f, -0.01271084f, 0.02102228f, -0.06053959f, -0.11499155f, 
    -0.08125643f, -0.10186913f, -0.10631090f, -0.11234336f, 0.01560299f, -0.04846862f, -0.05406410f, -0.07832155f, 
    0.04622448f, -0.10928746f, -0.05995926f, -0.08230911f, -0.03250914f, -0.00396200f, 0.06408495f, 0.02080704f, 
    0.03498029f, 0.01262653f, 0.05849940f, 0.02358329f, -0.05336687f, -0.02805264f, 0.01204241f, -0.04752725f, 
    -0.07964912f, -0.00440086f, -0.00897248f, 0.03216545f, -0.00357843f, 0.04557677f, -0.11113262f, -0.08747312f, 
    -0.10858884f, -0.04498886f, 0.04000435f, 0.00656184f, -0.03094569f, -0.03105601f, -0.04922457f, 0.01658354f, 
    -0.01191453f, -0.01500759f, 0.02044978f, 0.03095221f, -0.05153512f, -0.03635548f, -0.00243517f, -0.00867516f, 
    0.04304896f, -0.05777231f, -0.02439742f, -0.05091929f, -0.00406153f, -0.00761694f, 0.00062018f, -0.01567246f, 
    -0.08816408f, 0.01799296f, 0.04408722f, -0.08385084f, -0.01010304f, -0.06964323f, 0.01284116f, -0.09547263f, 
    -0.07523939f, 0.02206221f, -0.02989100f, -0.05578575f, -0.00211100f, -0.09355907f, 0.03886199f, -0.08392393f, 
    -0.01378313f, -0.05865398f, -0.10568003f, 0.03222885f, 0.02699842f, -0.00990503f, -0.01841867f, -0.08898006f, 
    0.03985310f, -0.02768657f, -0.08122878f, -0.01415657f, -0.08831950f, -0.03655514f, -0.05557385f, 0.02934130f, 
    -0.00302905f, 0.05257886f, 0.03867723f, 0.01485400f, 0.04590451f, -0.04540340f, -0.09027009f, -0.04862847f, 
    0.01209154f, 0.00503692f, -0.06870726f, -0.02894211f, -0.05644082f, 0.04044605f, 0.05027305f, 0.01702522f, 
    -0.01053098f, 0.00833382f, -0.01665474f, -0.02869792f, -0.00655494f, -0.02962920f, -0.05317842f, -0.07627494f, 
    -0.07482345f, 0.02702009f, -0.05628170f, -0.09070766f, -0.01680259f, -0.07722200f, -0.03139397f, 0.02759865f, 
    -0.04603635f, -0.06902125f, -0.04428361f, 0.00047538f, -0.08387256f, -0.00167387f, -0.03605150f, 0.00132297f, 
    -0.04288303f, 0.01824367f, -0.08117112f, 0.00917268f, -0.02176128f, -0.10224184f, -0.03169208f, -0.07793721f, 
    0.10341000f, -0.02769240f, 0.08958891f, -0.17635110f, -0.23000000f, -0.11314313f, -0.10375854f, 0.17376159f, 
    0.16615491f, 0.09263197f, -0.02695468f, 0.12492862f, 0.04804465f, 0.15152179f, -0.00229601f, 0.24659610f, 
    0.09558287f, -0.08564288f, -0.13362801f, -0.07465522f, -0.61066669f, 0.07626107f, -0.00645816f, 0.01027332f, 
    0.30552101f, 0.02191024f, 0.15561531f, 0.02639531f, 0.20724860f, 0.11307474f, 0.05642987f, 0.00497202f, 
    0.18890433f, 0.17003301f, 0.28915328f, 0.13635464f, 0.57090116f, -0.08930516f, -0.86461794f, 0.17583309f, 
    0.18934937f, 0.22121203f, -0.03484970f, -0.06139185f, 0.01570769f, 0.02045510f, -0.26205429f, -0.13575609f, 
    0.25216165f, 0.14959344f, 0.30202332f, 0.04048180f, -0.08545879f, 0.02139773f, -0.21863484f, -0.37910324f, 
    -0.40024975f, -0.29731882f, -0.07713621f, -0.10917687f, -0.00840268f, -0.11267712f, -0.29707083f, -0.54442996f, 
    -0.50886452f, 0.20636414f, -0.05434598f, -0.25723854f, -0.27754414f, -0.11792228f, -0.18840601f, 0.10705832f, 
    -0.22750998f, 0.00001600f, 0.07153399f, 0.03198195f, -0.29235065f, 0.05751846f, -0.19067279f, -0.19714445f, 
    -0.12504210f, -0.05115126f, -0.13766102f, 0.19623977f, -0.10551654f, -0.12321949f, 0.10265458f, 0.12242931f, 
    -0.08146830f, -0.09270781f, 0.50000155f, 0.15091708f, 0.42667574f, -0.17362283f, -0.43414447f, 0.08695506f, 
    0.00050445f, 0.08521552f, 0.22866756f, -0.22846584f, 0.07130240f, 0.09467121f, 0.27998376f, -0.25002390f, 
    0.02885233f, -0.00056550f, 0.13642874f, -0.08130123f, 0.14612584f, -0.06231024f, -0.34100473f, 0.17053425f, 
    0.11040647f, -0.05794754f, 0.10319729f, 0.00735461f, 0.12658179f, 0.30139330f, -0.08756240f, 0.05546282f, 
    0.08771937f, 0.23118071f, 0.10187591f, -0.03007296f, 0.17909452f, -0.21821381f, 0.21095859f, 0.02856398f, 
    0.27122143f, -0.05183786f, 0.09277087f, -0.21369141f, 0.03049763f, 0.12173592f, -0.13602360f, 0.41082159f, 
    0.22370055f, -0.25633955f, 0.00996124f, -0.04610888f, -0.12366462f, 0.16786475f, 0.03107992f, -0.17374091f, 
    0.38755617f, 0.18553440f, 0.24324800f, -0.00243315f, -0.07291771f, -0.03788603f, 0.02790812f, 0.07026371f, 
    0.12172794f, 0.12175866f, -0.19056252f, -0.09996617f, -0.26479843f, 0.11081389f, -0.03397954f, 0.15961649f, 
    0.16286446f, -0.09238157f, -0.37771687f, -0.04840539f, -0.03196343f, -0.12228052f, -0.11179208f, -0.20843327f, 
    0.03947570f, 0.06556918f, -0.22971477f, -0.00505144f, -0.09829135f, -0.03239306f, -0.15725301f, 0.01995131f, 
    0.03691253f, 0.01180775f, 0.18875696f, 0.11354633f, -0.25958341f, -0.02846049f, 0.12406545f, -0.13498551f, 
    -0.00390834f, -0.09454641f, -0.12726569f, -0.03507467f, 0.01056099f, 0.20417915f, -0.29012489f, -0.04122760f, 
    -0.06744531f, -0.02644822f, -0.11432077f, 0.08882900f, -0.22179821f, 0.15794989f, 0.57085180f, 0.42664120f, 
    -0.21439308f, 0.23024213f, -0.21738170f, -0.05423848f, 0.02630303f, -0.06694622f, 0.08879068f, -0.03946456f, 
    -0.29230300f, 0.04367910f, -0.05771685f, 0.09631327f, -0.01554965f, -0.02080383f, 0.06184324f, -0.05894171f, 
    -0.06751496f, -0.32197163f, -0.17579208f, 0.08095952f, 0.03626605f, 0.05853297f, 0.12646632f, 0.01082055f, 
    0.04010743f, 0.03215947f, 0.48077458f, 0.39133289f, -0.00246795f, 0.12252340f, 0.01287570f, 0.03582570f, 
    -0.09843280f, 0.03556791f, -0.33061743f, 0.11470004f, -0.17924985f, 0.06069973f, 0.24211119f, 0.04474936f, 
    0.11284728f, -0.06305595f, -0.09226546f, 0.27793744f, 0.14168389f, -0.03731987f, 0.04253429f, 0.14816962f, 
    0.04443869f, -0.12635072f, 0.17908014f, -0.00945191f, 0.36706907f, 0.11405776f, 0.01171641f, -0.08267011f, 
    0.02570619f, 0.06639194f, -0.06123089f, -0.03734419f, 0.00795957f, -0.12335949f, -0.48568687f, 0.08107125f, 
    -0.05429012f, -0.00125062f, -0.05513438f, 0.00864613f, -0.03341080f, 0.08902910f, -0.36859787f, -0.16987512f, 
    -0.56443131f, -0.10883936f, 0.03005944f, -0.25679293f, 0.05230772f, 0.01193906f, -0.02529435f, 0.28754592f, 
    0.18735829f, -0.10866793f, -0.48997092f, -0.16242529f, -0.06294218f, -0.04935370f, 0.09828516f, 0.02318256f, 
    0.07475720f, 0.24697237f, 0.15676783f, -0.07521894f, 0.01058886f, -0.01481059f, 0.06749292f, 0.35612097f, 
    0.01315421f, 0.05164335f, -0.05776729f, -0.29478398f, 0.13200356f, 0.19820768f, 0.13329546f, 0.06173919f, 
    -0.13633542f, -0.04569792f, 0.04180533f, -0.15248935f, -0.22143251f, 0.07291987f, -0.24516715f, -0.16245872f, 
    -0.02302793f, -0.08004678f, -0.15608819f, -0.29112089f, -0.38576809f, -0.51794219f, 0.08997282f, 0.11764754f, 
    -0.09202135f, 0.08600274f, 0.23605451f, 0.16572233f, 0.00069659f, 0.17519274f, -0.02457620f, 0.28689480f, 
    -0.18983573f, -0.17157249f, 0.01509123f, 0.05219588f, -0.16871440f, 0.03135056f, -0.13319518f, -0.30513832f, 
    0.07183914f, 0.36663708f, 0.19129622f, -0.07807934f, 0.07889032f, 0.06848078f, 0.14375100f, -0.01581126f, 
    0.11640049f, -0.26185033f, -0.18682486f, 0.06879388f, -0.08161040f, 0.13557425f, -0.03878655f, -0.40283021f, 
    -0.26677930f, 0.00422212f, -0.12674282f, -0.16288149f, -0.22377910f, 0.00672223f, 0.07970303f, 0.13847446f, 
    -0.15451778f, -0.34624144f, 0.26991618f, 0.11940453f, 0.02360022f, 0.15478443f, -0.04773141f, -0.08511946f, 
    -0.10567505f, 0.41010562f, 0.08204291f, 0.03174099f, -0.01602888f, -0.08460500f, 0.29563272f, -0.00794493f, 
    -0.03280511f, 0.14660756f, -0.03658751f, -0.14858149f, 0.53440738f, -0.08779091f, -0.02378231f, -0.39302433f, 
    -0.06536586f, -0.20431598f, -0.10388505f, 0.24202771f, -0.21380477f, 0.18612038f, -0.15547113f, 0.22734015f, 
    0.07748941f, -0.00057150f, 0.01989442f, -0.24347161f, 0.27753845f, 0.09988769f, -0.28403887f, 0.11850556f, 
    0.00095789f, 0.18447119f, 0.16000704f, -0.23909862f, -0.03296326f, 0.17881192f, 0.22940114f, -0.01605943f, 
    -0.12502243f, -0.04974772f, -0.05251416f, 0.10803706f, 0.02819259f, 0.03754247f, -0.29906088f, -0.06604002f, 
    -0.09518437f, 0.36060846f, 0.07612456f, 0.02543821f, 0.03505230f, -0.23361360f, 0.07378183f, 0.29445830f, 
    -0.09503888f, 0.10604154f, 0.17036232f, -0.02078974f, -0.04415054f, 0.12573855f, -0.07588442f, 0.08979244f, 
    -0.18262058f, -0.29750878f, 0.02550677f, -0.13072914f, 0.07102653f, -0.10203720f, -0.14782928f, -0.04822698f, 
    0.17834052f, -0.23996685f, -0.14885409f, -0.28817347f, -0.01856061f, 0.17739604f, 0.06814332f, 0.00651351f, 
    0.02163703f, 0.01796139f, -0.05876249f, -0.13384309f, 0.03636910f, 0.04347573f, -0.00298697f, -0.05075114f, 
    0.15736467f, -0.05070393f, -0.14780946f, 0.02651970f, -0.14180197f, -0.17808576f, -0.04280211f, -0.18859167f, 
    -0.06568897f, -0.08331228f, -0.07884249f, 0.05537018f, -0.18569225f, 0.04567783f, -0.08780190f, -0.00576773f, 
    0.07153499f, -0.04096046f, -0.09611559f, -0.18762678f, -0.19713624f, 0.10800956f, -0.07811901f, -0.13800429f, 
    -0.19674905f, 0.01247582f, 0.04509957f, -0.03805992f, 0.05386335f, -0.06116571f, -0.03733747f, 0.27007377f, 
    -0.08405337f, 0.20715320f, 0.05753246f, -0.12839383f, -0.17248830f, -0.01907457f, 0.04586486f, -0.19681598f, 
    0.05731478f, -0.03566946f, -0.12580535f, -0.01458881f, 0.04204326f, -0.18358710f, 0.02050477f, 0.00488930f, 
    0.18088645f, 0.05055744f, 0.13410939f, -0.02854814f, 0.19503239f, 0.13414924f, 0.14113171f, -0.01061225f, 
    0.07344891f, 0.26594096f, 0.00828106f, 0.08009205f, 0.02615924f, 0.21920939f, -0.02764924f, 0.21771200f, 
    0.04056452f, 0.13791174f, 0.01787094f, 0.19330794f, 0.18230386f, 0.13195622f, 0.11718713f, 0.10396177f, 
    0.20518519f, 0.32493228f, 0.02824031f, 0.78725463f, 0.18814944f, 0.15997565f, 0.05918673f, -0.10322744f, 
    -0.04662465f, -0.22016603f, 0.03021157f, 0.23620468f, 0.38783759f, -0.21568464f, -0.09663732f, 0.05010785f, 
    -0.12325062f, -0.01298629f, -0.11966116f, -0.23270121f, 0.20428783f, 0.21252017f, 0.20764862f, -0.22448047f, 
    -0.21848211f, -0.11874879f, -0.04468953f, -0.02425983f, 0.03582091f, -0.05773083f, -0.07776419f, 0.05555718f, 
    -0.09143871f, 0.07365103f, -0.05065410f, 0.02278229f, -0.00018689f, -0.02709145f, 0.01748099f, 0.41249809f, 
    0.04841253f, -0.07315419f, -0.02914896f, -0.19529465f, 0.02148476f, 0.17113601f, -0.05670749f, 0.22277264f, 
    -0.02030612f, -0.04693159f, -0.02975719f, -0.02807955f, -0.07706510f, -0.01133893f, -0.02279427f, 0.03761948f, 
    -0.06654461f, -0.06925924f, -0.00852181f, -0.00021952f, -0.01022360f, 0.02419117f, 0.07693768f, -0.07485178f, 
    -0.06468301f, -0.06299444f, -0.00506435f, -0.05728891f, 0.06700124f, -0.00040990f, 0.01248840f, 0.02776804f, 
    -0.05719812f, -0.06130842f, -0.04110953f, 0.01576458f, 0.06345203f, -0.06229761f, -0.05019537f, -0.07446358f, 
    -0.05164719f, -0.04364778f, -0.06166552f, 0.01403839f, 0.01860384f, 0.00182203f, -0.05743400f, 0.05757267f, 
    -0.09089992f, -0.04790574f, 0.06184176f, -0.03907002f, 0.06838134f, -0.01429037f, 0.05548352f, -0.00753809f, 
    -0.05690790f, -0.05205846f, 0.06585784f, -0.05501232f, -0.04413034f, -0.02601692f, -0.04921662f, -0.01388475f, 
    0.04018978f, 0.02586520f, 0.06360467f, -0.05663738f, 0.05941341f, -0.06572177f, 0.04325889f, -0.02139642f, 
    0.06662026f, -0.09800206f, -0.08010628f, -0.01126470f, 0.04459731f, -0.05580894f, -0.00317138f, 0.05572222f, 
    0.06763932f, -0.06862014f, -0.00048442f, 0.02713440f, -0.02403612f, 0.03846813f, -0.09039952f, 0.02753722f, 
    0.06428957f, -0.07223042f, -0.08580343f, -0.01728017f, 0.03387464f, -0.03032729f, -0.00247238f, -0.08673708f, 
    0.00045823f, -0.04936927f, -0.08743513f, 0.02431606f, -0.07643344f, -0.06741353f, -0.03003201f, 0.04494901f, 
    0.05008486f, 0.04094815f, 0.00959225f, 0.04766562f, 0.06085945f, 0.05297583f, -0.03410654f, 0.02299919f, 
    -0.01606565f, -0.02694824f, -0.08683448f, -0.01533930f, -0.07279196f, -0.02088952f, 0.06309726f, 0.06944584f, 
    0.04692380f, 0.06281994f, -0.04780890f, -0.06972980f, 0.01774579f, -0.00651607f, 0.04606025f, 0.01644854f, 
    0.06007735f, -0.07528039f, -0.02122476f, 0.08047831f, -0.08800614f, -0.08080447f, 0.04950126f, -0.05742194f, 
    0.07514374f, 0.01187340f, -0.02400360f, 0.02726133f, -0.01870170f, 0.01588575f, -0.04932705f, -0.02207518f, 
    0.05435750f, -0.05932657f, 0.08282826f, -0.04716719f, -0.07763410f, 0.00172918f, 0.01928884f, 0.02395299f, 
    0.50091392f, 0.03942876f, 0.13939860f, -0.18479007f, 0.17265129f, -0.08507930f, 0.11041419f, 0.07427422f, 
    0.10331558f, 0.20756269f, -0.00014895f, 0.22120820f, 0.19304310f, 0.13584761f, -0.16134669f, 0.09767469f, 
    0.24846403f, 0.16017628f, -0.37325215f, 0.11109797f, -0.19999465f, -0.01609226f, 0.04613266f, 0.15310487f, 
    0.05705739f, 0.00838455f, -0.11712356f, 0.07427450f, -0.02012861f, 0.26883367f, 0.03013474f, -0.25467369f, 
    -0.08727004f, 0.06930912f, 0.23658869f, 0.30781564f, -0.18130074f, 0.09871473f, -0.03977149f, 0.00728795f, 
    -0.12999661f, 0.06160329f, 0.00409278f, -0.09004784f, -0.04252616f, -0.10351132f, 0.20818584f, 0.15829805f, 
    -0.00438443f, 0.12198935f, 0.14075251f, -0.09422951f, -0.00170049f, 0.18091702f, -0.15740168f, -0.16464002f, 
    -0.12628673f, 0.17675437f, 0.15385495f, -0.16798696f, -0.04513136f, -0.00332482f, 0.10695953f, -0.54591608f, 
    0.08776634f, 0.24976192f, 0.18286689f, 0.18946238f, -0.13325134f, -0.06536938f, -0.24655254f, 0.04152776f, 
    -0.49057150f, -0.00188661f, 0.19026780f, 0.21170120f, 0.01223037f, 0.08177900f, 0.01569789f, 0.00224709f, 
    -0.12350817f, -0.18060753f, -0.37827760f, -0.13234982f, 0.00412201f, -0.01754583f, 0.17874162f, 0.18823232f, 
    0.11678618f, 0.08194008f, 0.03505043f, -0.00148282f, 0.17334522f, 0.22173713f, -0.04091939f, 0.19618788f, 
    -0.05929540f, 0.10333668f, -0.09661371f, -0.03221202f, 0.11778548f, 0.00008123f, 0.08594360f, 0.04695982f, 
    -0.08625168f, 0.01877306f, 0.03217919f, 0.15393752f, 0.01984640f, -0.23617135f, 0.07588469f, -0.03758045f, 
    -0.15543176f, 0.06155429f, -0.37900341f, 0.00152683f, -0.02559257f, -0.28095308f, -0.21799509f, -0.20582239f, 
    0.11816423f, 0.19916074f, -0.00000446f, -0.21477491f, -0.13599871f, 0.03449626f, -0.18546808f, -0.30357969f, 
    0.10596364f, -0.06997254f, -0.07785340f, -0.06196754f, 0.10664233f, -0.02087254f, 0.18703762f, 0.06015475f, 
    0.03182743f, 0.32603425f, 0.02540800f, -0.05407165f, 0.03524028f, -0.08286408f, 0.06552630f, -0.03673602f, 
    -0.03136816f, -0.11727859f, -0.27333364f, 0.02391216f, 0.04918625f, 0.16246958f, -0.10482925f, -0.02615793f, 
    -0.09287088f, -0.43307227f, -0.32120594f, 0.02611649f, 0.22643983f, 0.21470913f, -0.05184634f, 0.08419468f, 
    -0.03816034f, -0.07725538f, 0.34113166f, -0.61155677f, -0.22738908f, 0.10406868f, -0.10747770f, -0.18897974f, 
    0.10161830f, -0.25090563f, -0.10683778f, -0.14172286f, 0.10288203f, 0.15650608f, 0.10970492f, -0.20451584f, 
    0.01700247f, -0.00523988f, 0.11709681f, 0.11785979f, -0.29893503f, -0.06346787f, -0.02876039f, 0.26895216f, 
    0.01813592f, -0.11028367f, 0.00831294f, -0.07412862f, 0.15751973f, 0.69026566f, 0.27058470f, 0.17735961f, 
    0.07699091f, 0.07807637f, 0.21516237f, -0.00007499f, 0.06078169f, 0.03655814f, 0.28354335f, -0.30797699f, 
    0.13418104f, -0.08949398f, 0.14551964f, -0.07325709f, -0.21084736f, 0.07613481f, -0.00099732f, -0.10402205f, 
    -0.22132757f, -0.14966270f, -0.13696808f, -0.28373057f, -0.07898792f, -0.12523313f, -0.06486313f, 0.13316402f, 
    0.11555493f, 0.05956301f, -0.20947123f, -0.08653159f, -0.18155679f, -0.14265300f, 0.12063785f, 0.08193409f, 
    0.10582972f, 0.16916491f, -0.00636776f, -0.07145539f, 0.08622972f, 0.08521338f, 0.26273796f, 0.00594188f, 
    0.12139256f, -0.01755596f, 0.09448364f, 0.32800025f, -0.27734318f, -0.08064332f, 0.10316078f, -0.04006827f, 
    0.10601906f, 0.01910845f, 0.20367926f, -0.00757101f, -0.10527966f, -0.12382884f, 0.01940813f, 0.13601965f, 
    -0.16225283f, -0.08723516f, -0.20220222f, 0.00801788f, -0.62550944f, 0.05114374f, 0.07255300f, -0.04854339f, 
    -0.03545116f, 0.27446201f, -0.01168157f, -0.08920863f, 0.02112832f, 0.15194188f, 0.10940893f, -0.05817083f, 
    0.09211762f, -0.11270297f, 0.11772076f, 0.14444956f, 0.10764530f, 0.04113735f, -0.46416184f, -0.13785392f, 
    -0.18660821f, 0.05778008f, -0.15763077f, 0.09415455f, -0.04345366f, -0.13716437f, 0.04544573f, -0.42495430f, 
    -0.36184841f, 0.02544438f, 0.25647205f, 0.03590647f, 0.00336581f, -0.02253386f, 0.13186176f, 0.02963551f, 
    0.04216931f, 0.03651950f, 0.04788941f, -0.04566933f, 0.01057616f, 0.03477763f, 0.03630485f, -0.06881849f, 
    -0.08394399f, -0.03566591f, 0.06211951f, 0.00124277f, 0.03640426f, -0.05269415f, 0.04772181f, 0.05049371f, 
    0.04964241f, 0.06632011f, 0.02385196f, 0.00405812f, 0.00261762f, -0.04223711f, -0.06915832f, 0.01688731f, 
    0.00927995f, -0.02692576f, 0.05529902f, -0.00163446f, -0.00034033f, -0.00532858f, 0.05078251f, -0.05394921f, 
    -0.02481820f, -0.05842176f, 0.05345996f, -0.06205773f, -0.06649433f, -0.00478496f, 0.02338007f, 0.04091862f, 
    -0.05085603f, 0.03910497f, -0.00821778f, -0.04031958f, 0.04141313f, 0.05731130f, -0.02743683f, -0.01129787f, 
    -0.02632490f, -0.04857478f, -0.08199658f, -0.06278648f, -0.00326633f, 0.02489802f, -0.02289948f, -0.05337196f, 
    -0.04829269f, -0.06588219f, -0.08927605f, -0.01154436f, -0.01359100f, -0.02300498f, 0.00302815f, -0.00654812f, 
    -0.06578323f, -0.05613054f, -0.05116425f, 0.04647885f, 0.05677157f, -0.07179505f, 0.04618221f, 0.02254678f, 
    -0.07455689f, -0.06989308f, -0.00156294f, 0.03386321f, 0.05881809f, -0.09417377f, -0.07867728f, -0.00449831f, 
    -0.06242666f, -0.08080202f, 0.03690835f, -0.02012569f, 0.01669463f, -0.04812801f, -0.07226916f, -0.09094762f, 
    -0.04410230f, 0.01362233f, -0.01252991f, 0.06029391f, -0.05906737f, 0.00060288f, 0.01354737f, -0.04448511f, 
    -0.06841283f, -0.02255461f, -0.06565890f, -0.00234887f, -0.03624566f, -0.05701867f, 0.02005437f, -0.02605795f, 
    -0.03577967f, -0.00514485f, 0.01618120f, 0.01755074f, 0.05666320f, 0.03553083f, -0.07767398f, -0.04595912f, 
    0.00211392f, -0.00122005f, -0.02056073f, -0.00785979f, 0.01366887f, 0.06190579f, -0.02137731f, -0.08795320f, 
    0.04210762f, -0.04534169f, -0.04431671f, -0.08290286f, 0.04306842f, -0.04768756f, 0.04636718f, -0.01959503f, 
    -0.00178053f, -0.04094925f, 0.04604402f, 0.02802586f, -0.04531509f, -0.06496798f, -0.07880645f, -0.03845663f, 
    -0.03644675f, -0.01052557f, -0.02447262f, -0.05139900f, -0.00366301f, -0.03476302f, -0.00401039f, 0.02353156f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.00217474f, -0.27448192f, 0.03289805f, 0.03968162f, 0.12695974f, 0.35104492f, -0.04034923f, -0.01660786f, 
    0.20370796f, 0.03508756f, -0.01059237f, -0.42425042f, -0.02510125f, 0.24087904f, 0.19936079f, -0.06433935f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.14505497f, 0.03567346f, -0.94589692f, 0.37324521f, 0.02352638f, 0.03876358f, 0.05603269f, 0.09362214f, 
    0.64318508f, -0.22991133f, -0.22561184f, 0.10615605f, -0.02868048f, 0.11767393f, -0.25907713f, 0.14559245f, 
    0.14377792f, -0.09875281f, -0.63279170f, 0.25821421f, -0.19368099f, -0.00733861f, -0.10771266f, -0.22242798f, 
    0.24052767f, -0.63214600f, 0.60954505f, -0.00088179f, 0.17307620f, 0.12980631f, 0.46255946f, -0.07966182f, 
    0.77715731f, 0.25741768f, -0.24973953f, 0.36481422f, 0.18494748f, 0.14687170f, 0.17992735f, 0.09552328f, 
    -0.25179535f, 0.09656521f, -0.49635562f, 0.26690844f, -0.11631326f, -0.09067847f, 0.09953402f, 0.13541220f, 
    0.28313777f, 0.46469191f, 0.10902399f, 0.30560911f, 0.23520425f, -0.30563104f, 0.17896755f, 0.09299692f, 
    0.14673494f, -0.33885753f, -0.14818764f, -0.72953731f, 0.23058389f, 0.19101448f, 0.56927770f, -0.08445310f, 
    -0.50478894f, 0.52872521f, -0.08771832f, 0.11084189f, 0.58026946f, -0.02578990f, 0.16509239f, 0.15198480f, 
    0.24395081f, 1.00253880f, 0.25496024f, 0.31463826f, -0.14323786f, -0.27632612f, -0.26622614f, 0.20229888f, 
    0.36686137f, 0.14553317f, -0.32263234f, -0.44061679f, -0.26107889f, -0.20656984f, -0.15396032f, 0.08393396f, 
    0.15185988f, -0.23961073f, 0.31439731f, 0.18743412f, -0.01745153f, 0.10779699f, 0.44777778f, 0.01432547f, 
    -0.69218928f, 0.20195581f, 0.32537919f, 0.12299898f, -0.01868020f, 0.38219410f, 0.15997761f, -0.14358643f, 
    -0.42253384f, 0.04998695f, -0.33171076f, -0.30929005f, 0.10552547f, 0.35155755f, 0.21897736f, 0.07699183f, 
    0.04355113f, 0.09694328f, 0.07640754f, -0.10803829f, -0.19150069f, 0.22310048f, 0.16714671f, -0.14859785f, 
    0.55189008f, 0.58653784f, -0.19754657f, -0.11716380f, 0.21306594f, 0.13944733f, -0.20622197f, -0.19198756f, 
    -0.27159879f, 0.16637824f, 0.47427723f, -0.32395607f, -0.08694968f, 0.77597904f, -0.24031964f, 0.14424139f, 
    0.26283792f, 0.45097879f, 0.00156057f, 0.61423743f, -0.12105408f, -0.49361423f, 0.01874833f, -0.18512060f, 
    -0.38566604f, -0.29686511f, 0.28243893f, 0.42370084f, -0.03984641f, 0.44462439f, -0.02779504f, -0.14979425f, 
    0.12809457f, -0.47636122f, 0.42527983f, -0.54376864f, 0.23197979f, 0.15663730f, 0.17532006f, -0.11520413f, 
    -0.03509616f, 0.54040295f, 0.12565567f, -0.18695873f, -0.22803645f, 0.54689854f, 0.02541493f, -0.09993887f, 
    -0.09896014f, 0.03840000f, -0.12316342f, -0.17872611f, -0.24023446f, 0.30739921f, -0.49468035f, -0.12116988f, 
    -0.24569242f, 0.05625883f, 0.60191315f, 0.44498128f, 0.71180016f, 0.31313986f, -0.08026473f, -0.07187342f, 
    -0.14409028f, -0.01374597f, -0.04976968f, -0.30223757f, -0.10611071f, -0.12847655f, 0.14236630f, -0.17437929f, 
    0.32247174f, -0.09245932f, 0.09251095f, 0.11703968f, -0.00064221f, 0.04965472f, -0.16691944f, -0.14085597f, 
    0.07645923f, 0.25988120f, -0.17444628f, -0.16849874f, 0.16429707f, -0.19134742f, -0.14449255f, -0.14167789f, 
    0.03074754f, -0.45429483f, 0.19703728f, -0.16578950f, -0.06950734f, 0.78313851f, -0.09005505f, 0.23112391f, 
    -0.21714568f, 0.36532047f, -0.20883735f, 0.57572818f, -0.02669506f, 0.54210764f, -0.49182659f, -0.09484607f, 
    0.37787202f, 0.18742087f, 0.71442670f, -0.18931998f, 0.34433821f, -0.23108916f, -0.10283706f, -0.06705838f, 
    0.36143330f, 0.31230617f, -0.60992742f, -0.23649208f, -0.16098879f, -0.01833801f, -0.11411727f, 0.20619994f, 
    0.38916025f, 0.02710438f, -0.21835540f, -0.49375671f, -0.29033819f, 0.12358733f, 0.14354190f, -0.05693998f, 
    0.33670601f, -0.23325241f, -0.06459784f, 0.46823439f, -0.02860734f, 0.10882938f, 0.25920400f, -0.01908162f, 
    -0.07197607f, -0.25421396f, -0.02785631f, 0.09535112f, -0.19835779f, 0.12047362f, -0.19352469f, -0.03642026f, 
    -0.08896095f, -0.18305801f, 0.03035572f, 0.01473768f, -0.23567095f, -0.26376694f, 0.19676089f, 0.07712185f, 
    0.25835705f, -0.04265344f, -0.37449667f, -0.89489388f, 0.39347735f, 0.12703659f, 0.13798477f, 0.13470852f, 
    0.22180444f, -0.22890747f, -0.06244079f, 0.39046806f, -0.00540394f, -0.08777572f, 0.15336299f, -0.06104538f, 
    0.54027492f, -0.36659366f, -0.00930184f, 0.04104910f, 0.03396209f, 0.25012451f, 0.06375971f, -0.07987698f, 
    0.32714039f, -0.81610042f, 0.15065488f, 0.10164783f, -0.23593332f, 0.09139231f, 0.75405318f, 0.13344170f, 
    -0.08950749f, 0.27317122f, 0.29544091f, 0.74025792f, 0.15432721f, -0.10984049f, 0.11181069f, 0.19754833f, 
    -0.56503320f, 0.09154895f, 0.11414304f, 0.67446011f, -0.00376310f, -0.12126064f, -0.10682988f, 0.23113520f, 
    0.26242366f, 0.43773505f, -0.46069074f, -0.04133974f, 0.17043808f, 0.91515064f, -0.18765040f, 0.18127853f, 
    0.17963022f, -0.10802077f, -0.42353904f, -0.26901025f, -0.13513483f, -0.04550054f, -0.00138166f, -0.12870514f, 
    -0.28890979f, 0.30395186f, 0.38340288f, -0.48681006f, 0.53357261f, 0.43059477f, 0.00465428f, -0.13585413f, 
    -0.37469342f, 0.02301160f, 0.30644330f, 0.24331099f, -0.24149592f, -0.18498939f, 0.42905384f, 0.07011992f, 
    -0.21008722f, -0.53176033f, -0.11664451f, 0.11539681f, -0.07501337f, 0.08383521f, 0.06403010f, 0.20818865f, 
    0.40040040f, 0.42423096f, 0.31919819f, -0.36993292f, 0.03293879f, 0.60763949f, 0.07114030f, -0.24475573f, 
    0.46395549f, -0.48464948f, 0.30304277f, 0.04140424f, -0.06111114f, 0.04439420f, -0.15564862f, -0.16627173f, 
    -0.21346779f, 0.43902421f, 0.19376230f, 0.12403321f, 0.24545129f, 0.15715171f, 0.23709069f, -0.01970701f, 
    -0.12802841f, 0.33654228f, 0.16321348f, -0.06139694f, -0.11800585f, -0.47475576f, -0.08282311f, -0.09362174f, 
    0.36681786f, 0.65551746f, 0.61144024f, 0.61713749f, -0.16307190f, 0.08438684f, -0.37642249f, -0.06196877f, 
    0.05773513f, 0.57963151f, -0.06698944f, 0.68523329f, 0.32085323f, -0.47996044f, 0.06550565f, -0.10973736f, 
    0.40571404f, -0.94263154f, 0.10580343f, 0.67159051f, 0.00245645f, -0.44129142f, 0.41133612f, -0.21880384f, 
    0.60296237f, 0.43698201f, -0.20877087f, 0.22438070f, -0.26308933f, -0.03999512f, 0.17078707f, 0.07652485f, 
    0.28895238f, 0.15303013f, -0.29616702f, 0.09586502f, 0.08429888f, 0.02433258f, 0.05257614f, 0.02836153f, 
    0.27212015f, 0.01835572f, -0.35359171f, 0.87535673f, -0.01463926f, -0.28775835f, 0.02862291f, 0.13461119f, 
    0.13771310f, 0.39058322f, 0.14767335f, -0.39909425f, 0.14684628f, 0.22116224f, -0.17532830f, 0.03618654f, 
    0.12932345f, -0.18022755f, -0.12388191f, 0.00864895f, 0.06202043f, 0.12952282f, -0.10368335f, -0.20909566f, 
    0.27084967f, 0.07547964f, -0.30472088f, -0.33661795f, -0.22470832f, 0.43374875f, 0.51832891f, 0.04258438f, 
    -0.21429048f, -0.20030209f, 0.45627487f, 0.30471298f, 0.74771851f, 0.24404006f, 0.03092496f, 0.16244546f, 
    -0.20480432f, -0.39561689f, -0.02286530f, 0.11725158f, -0.25357637f, 0.04736667f, 0.21474105f, -0.05073495f, 
    -0.34066132f, -0.48894891f, -0.46159351f, 0.45957389f, -0.07001180f, 0.20367135f, 0.10366342f, -0.16147245f, 
    0.23767862f, 0.09748477f, 0.37974674f, 0.57706159f, -0.02326404f, 0.59359413f, -0.53599089f, 0.17908704f, 
    0.36094645f, -0.26731396f, -0.46723095f, 0.46811345f, 0.11777272f, 0.43422449f, -0.22096635f, 0.10285123f, 
    -0.35822606f, 0.39222977f, -0.31996310f, 0.51720369f, -0.14629030f, 0.20361283f, -0.50157684f, 0.16568086f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00642995f, 0.42966959f, -0.05662144f, 0.36089998f, 0.28365907f, 0.58761299f, 0.16346860f, 0.06805480f, 
    0.32090423f, 0.21728988f, 0.20026869f, 0.31215569f, -0.21216033f, 0.50240415f, -0.00981004f, -0.00807698f, 
    -0.29168785f, 0.35320863f, 0.20387812f, -0.40608457f, -0.02451275f, 0.56358790f, 0.35636818f, 0.03550749f, 
    0.06499972f, -0.29124743f, 0.02005427f, 0.14758593f, 0.80404049f, 0.50514060f, -0.01157830f, 0.02700301f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.43392164f, -0.72762513f, -0.00233060f, -0.03231349f, 0.54656190f, -0.12352957f, 0.02000408f, 0.27903065f, 
    0.23162849f, -0.28317428f, -0.04301228f, 0.00166008f, 0.18180014f, 0.10097204f, 0.22278431f, -0.49465272f, 
    0.07616469f, -0.23658036f, -0.85405642f, -0.30156180f, -0.55604959f, 0.09707186f, 0.27770630f, 0.18514690f, 
    0.35083482f, -0.76477867f, 0.00607925f, 0.27345240f, 0.11363532f, -0.24371302f, -0.11674967f, 0.22909392f, 
    0.72638088f, -0.18868370f, 0.25436115f, 0.09002199f, -0.05196036f, -0.13726313f, -1.30350566f, 0.36834437f, 
    -0.46481839f, -0.69655651f, -0.16524296f, -0.09557110f, 0.07686190f, 0.00823003f, 0.41439548f, 0.15736620f, 
    -0.15601827f, 0.21687448f, -0.06110470f, -0.26217875f, 0.07956883f, -0.64823443f, -0.01757829f, -0.07121905f, 
    -0.17637488f, 0.19217649f, 0.33424929f, 0.33110210f, 0.25605264f, -0.20564821f, 0.15460469f, 0.41229248f, 
    0.18026039f, -0.01238337f, 0.17626165f, 0.17093153f, 0.38190225f, 0.18284622f, 0.11095291f, 0.14619832f, 
    0.28593132f, -0.53620422f, 0.60761392f, -0.23059988f, 0.00951581f, -0.70766985f, -0.02231951f, 0.09310216f, 
    -0.01447905f, 0.05200006f, -0.36019334f, -0.73241216f, 0.61838633f, -0.02431612f, -0.41482174f, -0.65983027f, 
    0.22876282f, 0.21748202f, 0.56597912f, -0.02517890f, -0.08350311f, -0.66819113f, -0.56142372f, -0.81251585f, 
    -1.11074686f, -0.12467469f, 0.01968078f, 0.45988312f, 0.10235994f, -0.44579133f, -0.14792787f, -0.79686660f, 
    0.20169052f, 0.24694793f, -0.50465369f, 0.48426130f, -0.15698621f, -0.58407366f, 0.53202069f, -0.90507454f, 
    -0.05360506f, -0.93560964f, 0.24691281f, 0.18617882f, -0.34743589f, 0.20677045f, -0.44929904f, 0.14825653f, 
    -0.25900954f, 0.14618024f, -0.29911238f, -0.13307576f, -0.02378473f, 0.33513746f, -1.17372644f, -0.45058250f, 
    -0.37151238f, 0.18931039f, -0.26163614f, -0.16003841f, 0.11662833f, -0.18082641f, 0.42670342f, -0.30591959f, 
    -0.06791250f, 0.38090295f, 0.33728164f, 0.22533339f, -0.47463343f, 0.21428876f, -0.19891556f, -0.33617201f, 
    0.11741231f, 0.03243300f, -0.20913662f, -0.10599393f, -0.07631032f, 0.32670575f, 0.12095103f, -0.20854779f, 
    0.06540361f, -0.46409735f, -0.72106719f, -0.28233302f, -0.01424650f, 0.22380315f, 0.26343271f, 0.01751076f, 
    0.22836126f, 0.08152231f, 0.18792510f, -0.45707375f, -0.35020924f, 0.17322920f, -0.46508041f, -0.12185632f, 
    -0.20179209f, -0.50198120f, 0.18726964f, -0.11806231f, -0.34505025f, 0.56532842f, -0.27514952f, 0.23596363f, 
    0.03653822f, -0.17066675f, 0.01975867f, 0.61847776f, 0.21754897f, -0.21572506f, -0.06233227f, 0.27224720f, 
    -0.30704251f, -0.41363505f, 0.16157641f, 0.17821196f, 0.17735168f, -0.20081730f, 0.12277973f, 0.52246803f, 
    -0.58742434f, -0.14566372f, 0.28787097f, 0.26500177f, -0.83305013f, 0.03059523f, 0.03381760f, 0.08548058f, 
    0.08264178f, 0.08891584f, 0.32314223f, 0.06248973f, -0.29120257f, 0.35837668f, 0.26468724f, 0.15231314f, 
    0.07250427f, 0.14504550f, 0.19126488f, -0.72025347f, 0.28292388f, 0.15098342f, 0.00860124f, 0.13999104f, 
    -0.90337825f, -0.02153589f, 0.23774739f, -0.28969133f, 0.27093256f, -0.13654867f, -0.56320375f, 0.03809951f, 
    -0.82942694f, -0.56917417f, 0.35856128f, -0.69950539f, 0.16420446f, -0.62957692f, -0.35710794f, 0.01750585f, 
    0.33669227f, -0.32165340f, 0.09478287f, 0.22958249f, -0.48743084f, -0.09290309f, -0.20977043f, -0.17479229f, 
    -0.03526778f, -0.18178898f, -0.56241959f, 0.50375760f, 0.30572268f, -0.01180601f, -0.69405586f, 0.11263488f, 
    0.40312678f, 0.34209847f, -0.04521472f, -0.09611753f, -1.04933417f, 0.07290647f, -0.03287927f, 0.29347807f, 
    0.24720027f, 0.42153212f, -0.72366011f, -0.17500134f, -0.59527481f, 0.35632443f, 0.26513723f, 0.10736441f, 
    -0.94844192f, 0.18345968f, -0.06890313f, -0.96337730f, 0.11467412f, -0.19374099f, -0.21875779f, 0.29708555f, 
    -0.09313102f, -0.26088029f, 0.38777575f, -0.09543812f, -1.05710101f, -0.78663707f, 0.33844736f, 0.24128579f, 
    0.54339421f, -0.00947613f, 0.27679077f, 0.22155552f, 0.07162736f, -0.82952386f, 0.34885541f, -0.58375704f, 
    0.10775358f, 0.03785396f, -0.73853731f, -0.57276767f, 0.09698365f, -0.20238951f, 0.53731048f, 0.06743012f, 
    0.16364846f, 0.47566110f, 0.03993516f, 0.00783969f, -0.31429419f, 0.31333494f, -0.41317168f, -0.15711859f, 
    -0.10582824f, 0.21790852f, -0.05450145f, 0.29960266f, 0.13247034f, -0.06690962f, 0.29033181f, -0.07151850f, 
    0.07424471f, -1.08723629f, -0.40450943f, -0.11038056f, 0.07216758f, -0.09291401f, 0.56928134f, -0.02772690f, 
    0.11181882f, 0.54799449f, 0.17572756f, 0.60919356f, -0.21144304f, -0.02232468f, -0.06427262f, -0.59405714f, 
    -0.55204135f, 0.38821280f, -0.63874394f, 0.15885662f, -0.31953895f, -1.38107765f, -0.62180442f, -0.57666641f, 
    -0.12337470f, -0.54766136f, 0.22204298f, 0.09437273f, -0.04785758f, -0.20441799f, -0.07894959f, -0.02589835f, 
    -0.41013238f, 0.26615009f, -0.05525113f, 0.62854195f, 0.09868249f, 0.03699671f, -0.26347309f, -0.29205203f, 
    -0.33394155f, 0.11259317f, 0.11684479f, -0.17705376f, 0.14970124f, 0.31228808f, -0.43484163f, -0.44241819f, 
    0.34580871f, -0.51498699f, -0.98145515f, -0.09084085f, -0.24609615f, -0.16655011f, -0.19522783f, 0.49915916f, 
    0.04810204f, 0.77270335f, 0.17849591f, -0.11940795f, -0.42250437f, 0.47907257f, -0.18091507f, 0.06105725f, 
    0.09092875f, 0.28527740f, -0.13229555f, -0.84575862f, 0.03461510f, -0.02207398f, -0.37687993f, -0.27427036f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.33356872f, -0.05144404f, -0.08778667f, -0.22471593f, 0.10202972f, 0.34655866f, -0.13761164f, -0.44397256f, 
    -0.18170707f, -0.08486781f, 0.24888930f, 0.30769825f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
