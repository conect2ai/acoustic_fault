#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.35284472f, -1.24927199f, -1.41281617f, -0.27900234f, 0.54500628f, 0.69798863f, -0.14218417f, -0.36738732f, 
    -0.63067937f, 0.20974137f, -0.30954465f, 0.66991591f, 0.30269504f, 0.01722084f, -0.18990237f, -0.62432802f, 
    -0.87936199f, -0.43935856f, 0.89634144f, -0.19498429f, 0.88892949f, -0.44503880f, -0.05862999f, -0.35010907f, 
    -0.06370246f, -0.33793160f, 0.93666375f, -0.71349519f, -1.09098649f, -0.13860193f, -0.48228478f, -0.64196050f, 
    -0.33631551f, -0.33677384f, 0.08456825f, 0.81260610f, -0.04474692f, 0.63418585f, 1.06935596f, -1.27410114f, 
    -0.61455476f, 0.14348947f, 0.34045309f, 0.47367769f, 0.83839130f, -1.37178159f, 1.91931272f, -1.30803573f, 
    -0.28198010f, -0.07769820f, -0.50298721f, 0.22560342f, -0.11443385f, -0.05041441f, -0.07907918f, 0.11990379f, 
    0.26419917f, 1.09346342f, 0.32182947f, 0.80285704f, -0.13426022f, -0.01344309f, -0.05220965f, 1.45053172f, 
    -1.08143234f, -1.00258040f, 0.45692807f, -0.11246274f, 0.20879461f, -0.18933822f, -0.16801764f, 0.92366689f, 
    -1.22952044f, -0.30316982f, -0.68955302f, -0.33673215f, -0.58348727f, -0.52856910f, 0.13790613f, -0.62618268f, 
    -0.44500706f, -1.22735918f, 0.41630954f, 0.19667296f, -0.87891167f, -1.20419276f, -0.96989429f, 0.64224374f, 
    0.30510163f, 0.09708007f, -1.07156277f, 0.94984478f, -0.02384550f, 0.54439718f, 0.04196893f, 0.05031414f, 
    0.29598475f, 0.47788313f, 0.49286762f, 0.33297384f, 0.25112838f, 0.10643652f, 0.29995084f, 0.10888661f, 
    -0.12332492f, 0.64663929f, -0.43602127f, 0.31932700f, 0.60191953f, 0.66011304f, -0.01064280f, -0.63998324f, 
    0.04991828f, 0.46094215f, 0.81662560f, -0.48078427f, -1.01648438f, 0.52777761f, 0.18229516f, -0.13916253f, 
    -0.59188038f, -1.08272576f, -1.65811610f, -0.34380880f, -0.36398447f, 0.09500331f, -0.05547406f, -0.03495903f, 
    -0.50155848f, -0.53076345f, -0.30235305f, -0.35715130f, -0.48256218f, -0.37534109f, -0.43467200f, 0.13669422f, 
    0.46323311f, 0.56610286f, -0.23630594f, -0.43054861f, -0.54296190f, -0.06963439f, -0.51535666f, -0.62237519f, 
    0.07866412f, 0.42280385f, -0.62909353f, 0.17285837f, -0.42395011f, 0.42697075f, -0.57526612f, -0.71383184f, 
    -0.65588444f, -1.71309268f, -0.95522916f, 0.68084145f, 0.61709338f, 0.68823230f, 0.34884202f, 0.20830339f, 
    -0.29343700f, -0.11348596f, 0.19349915f, -0.12087172f, -0.43936270f, 0.95593685f, -0.29938236f, 0.59899265f, 
    -0.59532660f, 0.82125384f, -0.51371717f, 0.02060688f, -0.35871854f, -0.65895355f, -0.52856469f, 0.23981108f, 
    -0.15074575f, 0.65292126f, 0.29545850f, 0.64905912f, -0.13177226f, 0.30489683f, -0.35086754f, -0.41197401f, 
    0.42122445f, -0.39143381f, 0.79724485f, 0.00220168f, 0.44467854f, 0.95466113f, -0.94235444f, -0.81998312f, 
    -0.14447126f, 0.20507719f, 0.67904878f, 0.66491836f, -0.37979063f, -0.40225127f, -0.21932688f, -0.88261449f, 
    -1.27177882f, 0.14437081f, 1.34391987f, -0.53388876f, 0.23729272f, -0.03231918f, 0.21995087f, -0.10684509f, 
    0.30381536f, 0.11715025f, -0.37893480f, -0.31415415f, 0.74026740f, -0.10795848f, 0.63057613f, -0.47808662f, 
    0.45600572f, 0.51947498f, 0.38697785f, 0.38502491f, -0.42096397f, 0.26705703f, 0.27236870f, 0.13184500f, 
    0.13489965f, -0.45453769f, 0.06945157f, 0.62645406f, 0.50079089f, 0.66004241f, -0.00304694f, -0.51606876f, 
    -0.44691840f, -0.55320615f, -0.16152407f, -0.02753805f, 0.27197745f, -0.23861505f, 0.31174171f, 0.18574731f, 
    0.39472276f, 0.33236766f, -0.61245334f, -0.37292820f, 0.65424341f, 0.05001194f, 0.37612906f, 0.54340285f, 
    0.47458956f, -0.26489028f, 0.62006170f, 0.01030254f, 0.79428464f, 1.48127723f, -0.95338267f, -0.64026129f, 
    -0.30860078f, -0.12000357f, 0.16051684f, 0.26148033f, 0.04838862f, 0.94844699f, -1.62311125f, 0.15200976f, 
    0.66541797f, -1.01865983f, -0.90781999f, -0.36866051f, -0.15409498f, -0.25160459f, 0.53031451f, 0.44756287f, 
    0.34473765f, 0.02368424f, 0.21484761f, -0.36460680f, -0.89814717f, 0.62892002f, -0.74806136f, 0.49841496f, 
    0.52451748f, 0.34124538f, 0.75010771f, 0.36659253f, 0.01877452f, 0.35364282f, 0.32353541f, -0.23347801f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11103251f, -0.13667931f, 0.32836518f, -0.42947248f, 0.30733663f, -0.04396335f, 0.09147722f, 0.18448173f, 
    -0.27849469f, 0.23336044f, -0.02078670f, 0.79737300f, -0.10601129f, 0.12543067f, 0.47783417f, -0.00615375f, 
    0.36714843f, 0.12045548f, -0.05931083f, 0.23918885f, -0.01705497f, 0.28363401f, 0.01022782f, 0.60330617f, 
    -0.15162627f, 0.19653070f, 0.77421874f, 0.72489303f, 0.24384658f, 0.59041339f, 0.00308319f, -0.18338719f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.82599711f, -0.46736896f, -0.81730235f, 0.07837708f, -0.04992105f, 0.26952666f, -0.04266587f, -0.04733718f, 
    0.12068822f, -0.02686918f, -0.04941859f, 0.12927511f, -0.08240078f, 0.05214800f, -0.03017546f, -0.12298018f, 
    0.04438861f, 0.11354018f, 0.32088488f, 0.17045093f, 0.12210732f, 0.07179609f, -0.02773945f, -0.06611080f, 
    0.10532027f, -0.09946330f, 0.10002520f, 0.43873519f, 0.39898616f, 0.03986850f, -0.10125483f, 0.03952908f, 
    -0.02508943f, -0.00332873f, -0.08986163f, -0.20860979f, 0.19978961f, 0.12813467f, -0.08017403f, 0.08796313f, 
    0.01036995f, 0.12077902f, 0.07082599f, 0.06069029f, -0.08050191f, 0.29409000f, -0.84369701f, -0.69750643f, 
    0.00931751f, -0.25386101f, 0.08181113f, 0.17235832f, 0.21579407f, -0.06321907f, -0.08426548f, -0.02720647f, 
    0.02503608f, -0.21040872f, 0.06805275f, 0.09109566f, 0.13787986f, 0.03160158f, -0.00770726f, -0.23361738f, 
    -0.14657374f, 0.32506585f, 0.11377864f, 0.08124582f, -0.21262778f, 0.12320738f, 0.08753774f, 0.03554966f, 
    0.60768151f, 0.08985119f, -0.42748901f, -0.02399385f, -0.06548407f, -0.05489151f, 0.11976758f, 0.26240718f, 
    -0.11356332f, 0.23593704f, -0.65500486f, 0.23733421f, -0.22291742f, -0.19238105f, -0.09055994f, 0.22323254f, 
    0.00980609f, 0.00822727f, 0.04731641f, -0.08659492f, -0.21584620f, -0.08741987f, -0.03157806f, 0.00425686f, 
    0.30920288f, 0.03601594f, 0.05180319f, -0.05838587f, 0.08143576f, 0.10565539f, 0.06168278f, 0.15304168f, 
    -0.31852573f, 0.01184836f, 0.17533027f, 0.08933473f, -0.26491430f, 0.11134522f, 0.39169705f, -0.12871566f, 
    -0.07486802f, -0.09318624f, -0.22602887f, -0.05868486f, -0.02274930f, -0.21109167f, -0.37481657f, 0.34080288f, 
    -0.18031251f, 0.01778127f, 0.06922845f, -0.01138113f, 0.05905074f, -0.00588359f, -0.16721074f, -0.25314525f, 
    0.05440053f, -0.06978878f, -0.09189887f, -0.02466844f, 0.18597090f, 0.10825504f, 0.07689561f, -0.05433062f, 
    0.14829306f, 0.20309176f, -0.06360513f, 0.01428094f, 0.11607923f, 0.05178187f, 0.07438014f, -0.10433352f, 
    -0.09268086f, -0.03949199f, 0.31302586f, -0.11280176f, -0.08678387f, -0.09988865f, -0.02064551f, 0.08392201f, 
    0.20151255f, 0.51914805f, -0.14729080f, -0.62789530f, 0.05248882f, 0.09327099f, -0.26450014f, 0.29194182f, 
    0.01914225f, 0.13087264f, -0.16565132f, -0.02244971f, 0.27537099f, -0.10222368f, 0.15190171f, 0.30642956f, 
    0.26357377f, 0.09308490f, 0.01625913f, -0.03870713f, -0.38327679f, 0.08757762f, 0.21738289f, 0.09493939f, 
    0.09800430f, 0.06255449f, -0.03764765f, -0.04954282f, 0.14783993f, -0.11128864f, 0.04519060f, 0.08105980f, 
    -0.05842441f, -0.08998131f, 0.00074089f, 0.02505642f, -0.03035296f, -0.19351287f, -0.49582702f, 0.14002289f, 
    0.14689007f, 0.18429430f, 0.21856524f, 0.00445255f, 0.05361921f, 0.10165520f, 0.27345103f, -0.84963471f, 
    -0.33639821f, 0.03721101f, 0.03348454f, 0.27663445f, -0.03105507f, -0.18066446f, -0.05418198f, 0.09500577f, 
    -0.02940453f, 0.05116620f, 0.13125753f, -0.08455748f, -0.10665565f, -0.25311413f, 0.00940919f, 0.06520297f, 
    0.04153185f, 0.25894579f, 0.05106946f, -0.00754326f, -0.01564432f, 0.00285956f, 0.05992417f, 0.01304691f, 
    0.02315416f, -0.07559706f, -0.08109629f, -0.14314754f, -0.03679144f, 0.12293196f, -0.22500499f, -0.08717132f, 
    -0.06082665f, 0.22098990f, 0.08675815f, -0.01094955f, -0.11999284f, -0.01411797f, -0.04887480f, 0.01013863f, 
    0.03920162f, -0.06569689f, 0.17485353f, 0.11064995f, 0.09312156f, -0.26504210f, -0.18135251f, -0.14992648f, 
    -0.09685723f, 0.17912193f, 0.10104150f, -0.02973703f, -0.26691431f, -0.11224411f, 0.16172230f, -0.06093035f, 
    -0.29898831f, 0.00064859f, -0.12060461f, 0.23930918f, 0.06927421f, -0.05759497f, -0.11664869f, -0.05112887f, 
    -0.08049522f, -0.15393665f, 0.08554994f, 0.17274480f, 0.27106601f, -0.19190007f, -0.06291734f, 0.11529781f, 
    0.09703308f, -0.05644860f, -0.04719595f, 0.03070534f, -0.28960958f, -0.01112275f, -0.08482344f, -0.08608712f, 
    0.25314653f, 0.09134799f, -0.19832143f, 0.13797989f, 0.05333477f, -0.03283130f, 0.00338543f, 0.23493361f, 
    -0.26527148f, 0.32599893f, 0.09260664f, -0.08948976f, 0.04624902f, -0.10795135f, 0.09232579f, 0.03200134f, 
    -0.02893973f, -0.01814131f, -0.06137009f, -0.06041985f, 0.00486335f, 0.08764248f, 0.05305218f, 0.25699189f, 
    0.07074524f, -0.06249863f, -0.45495191f, 0.26448563f, -0.03028962f, 0.18328956f, 0.16747104f, -0.14864874f, 
    -0.28488940f, -0.12114847f, -0.11986712f, 0.37769064f, 0.45493525f, -0.11585899f, -0.15406196f, 0.02608574f, 
    -0.11045402f, -0.06050742f, -0.08336253f, -0.05595586f, -0.48851159f, 0.05287365f, -0.01492619f, 0.19461948f, 
    0.11928633f, -0.20494805f, -0.12854412f, -0.05109559f, -0.18690707f, 0.19715032f, -0.24001378f, 0.35366988f, 
    -0.17388511f, -0.02917161f, -0.06239359f, -0.16126387f, -0.04252809f, 0.09173901f, 0.22910641f, 0.05742260f, 
    0.18223231f, -0.60802251f, -0.18869264f, -0.13052420f, 0.17505273f, 0.01394724f, 0.12284279f, -0.32893339f, 
    0.19431333f, 0.14750375f, -0.22532010f, 0.04471445f, -0.01815478f, -0.04668337f, 0.28173652f, 0.23067783f, 
    0.17013697f, -0.06326012f, 0.09506741f, -0.01375173f, -0.17793426f, 0.03844301f, -0.12357481f, -0.06765824f, 
    0.00973743f, 0.41374463f, 0.17722072f, 0.15686752f, 0.06198418f, -0.03777422f, -0.17341690f, -0.12168307f, 
    -0.17035006f, -0.08777915f, 0.24782531f, 0.08917791f, -0.05735218f, -0.09976441f, 0.05503581f, 0.02821984f, 
    -0.13283499f, 0.04586529f, -0.11640651f, -0.02838074f, 0.08334291f, -0.01362212f, 0.09438361f, -0.16890129f, 
    -0.11136385f, 0.04109971f, 0.12188102f, 0.03415211f, 0.04481560f, -0.04933719f, 0.26394823f, 0.15794061f, 
    0.12810645f, 0.10804525f, 0.05126456f, -0.18851501f, 0.22750013f, 0.04202083f, 0.35304028f, 0.36471835f, 
    0.06711322f, 0.02675604f, -0.05901401f, -0.11785666f, -0.08706515f, -0.09975991f, 0.03402976f, 0.00436013f, 
    -0.01148556f, -0.02141906f, -0.10227415f, -0.03930593f, -0.07388224f, 0.01190699f, 0.10477751f, 0.15377803f, 
    0.11826566f, 0.16514529f, 0.15942062f, -0.03179326f, -0.03468703f, 0.15029524f, -0.23871620f, 0.13769116f, 
    -0.07798473f, -0.06308507f, -0.03466156f, 0.07487968f, 0.03251019f, 0.01384747f, 0.26238313f, 0.19581701f, 
    0.20764658f, -0.09045510f, 0.26124978f, 0.21517617f, -0.25450867f, 0.16837233f, -0.38209540f, 0.09764587f, 
    0.08082347f, 0.10604762f, -0.10216618f, 0.15161252f, 0.25902283f, -0.31122878f, -0.09196080f, -0.19056441f, 
    -0.16251148f, -0.00568916f, 0.18843371f, 0.21785620f, 0.11168189f, 0.03176323f, -0.33998069f, -0.09469903f, 
    -0.00121905f, 0.09341013f, 0.03172314f, -0.16018181f, 0.25074089f, 0.05337446f, 0.05418249f, -0.26377720f, 
    -0.13911639f, -0.02932774f, -0.07837027f, -0.00192267f, -0.17834666f, -0.08090618f, 0.23809254f, -0.27442634f, 
    -0.11818773f, -0.09556718f, 0.21670696f, 0.07589340f, -0.07849666f, 0.02044391f, -0.30465251f, 0.45190829f, 
    0.96100920f, -0.10104640f, -0.22128156f, -0.08116411f, 0.05942477f, 0.28225395f, 0.17840905f, -0.21466680f, 
    0.06266136f, -0.17619778f, -0.03583433f, 0.01118801f, -0.06896106f, -0.16710383f, 0.34698513f, -0.08026376f, 
    -0.06096164f, 0.12656803f, 0.08801629f, 0.13774899f, -0.14954497f, -0.02380617f, 0.14643906f, 0.03325716f, 
    0.08269124f, -0.05246166f, 0.04823976f, -0.02904985f, -0.08763108f, -0.03360597f, -0.16142371f, 0.18080924f, 
    0.15304570f, 0.07362418f, -0.01868884f, -0.06271353f, -0.16288950f, -0.24052671f, 0.04834707f, -0.22000986f, 
    0.04035358f, -0.02812863f, -0.13313358f, 0.02672074f, 0.09533411f, -0.00096579f, -0.69153184f, 0.08788267f, 
    0.01475766f, -0.08172388f, 0.09650581f, -0.04068058f, -0.42116097f, -0.20533912f, -0.07550533f, 0.16166373f, 
    0.17031348f, 0.05086409f, 0.12311703f, -0.05982632f, -0.15243813f, -0.06169587f, 0.14521085f, -0.13868444f, 
    -0.12389066f, -0.17373885f, -0.04903452f, -0.05503827f, 0.11650726f, 0.08473805f, 0.09719653f, 0.07425647f, 
    0.07294520f, 0.10519442f, -0.12410213f, 0.01066947f, 0.25111830f, 0.19713426f, -0.10735934f, 0.11622922f, 
    0.08664059f, 0.09882633f, 0.11760969f, -0.16042386f, -0.00427634f, 0.29601097f, 0.06911120f, 0.08966433f, 
    -0.21252462f, 0.17632264f, 0.17946783f, 0.18996447f, -0.16281827f, -0.07384620f, 0.23007108f, 0.07335166f, 
    -0.13347800f, -0.10599688f, -0.18526717f, -0.03652351f, 0.05541086f, -0.05243494f, 0.05649058f, 0.11353973f, 
    -0.05832467f, 0.35178170f, -0.34843445f, -0.12201623f, -0.27117696f, 0.14544915f, 0.11641530f, 0.26795617f, 
    -0.03000846f, -0.22653688f, -0.29412985f, -0.06025854f, 0.34875700f, -0.29725397f, -0.35753196f, -0.18151090f, 
    -0.05606455f, 0.01538600f, 0.07570623f, -0.01790521f, -0.20909874f, -0.29450643f, -0.38625649f, 0.03400739f, 
    0.04873576f, 0.01813591f, -0.00433881f, -0.19275241f, -0.23806068f, -0.69968188f, -0.95194370f, -0.13076003f, 
    0.04161969f, 0.64437866f, 0.03686878f, -0.06135088f, -0.14615402f, -0.02891908f, 0.17447709f, 0.17362086f, 
    0.14488137f, -0.13291639f, -0.06515376f, -0.15632531f, 0.22661543f, 0.19385085f, 0.19705421f, 0.39561951f, 
    0.06749965f, -0.17814843f, -0.26090842f, -0.50739980f, 0.28253359f, 0.13961831f, -0.02830949f, 0.03146244f, 
    0.04969213f, 0.03387609f, -0.09310161f, 0.01145130f, -0.09109713f, 0.02811272f, 0.13120143f, 0.03254718f, 
    -0.02520912f, 0.09127776f, -0.17344370f, -0.03416299f, -0.27309197f, -0.02576835f, -0.29982862f, 0.09448448f, 
    -0.17382734f, 0.07589763f, -0.08208936f, 0.07360197f, -0.03692013f, -0.05028854f, 0.13743880f, 0.01819593f, 
    0.25112951f, 0.08709898f, -0.00129506f, 0.06101254f, -0.09635773f, 0.10440495f, 0.10156108f, 0.01563874f, 
    0.08961263f, 0.00465901f, -0.02059261f, -0.03065164f, -0.08637663f, -0.46754399f, -0.33457920f, 0.08847203f, 
    0.09786582f, -0.07732350f, 0.17994891f, 0.23278940f, 0.29642949f, 0.37310815f, 0.05144448f, -0.02857252f, 
    -0.02744093f, -0.08623274f, -0.05014792f, 0.13920654f, -0.13848019f, 0.07106106f, 0.12058605f, -0.00088459f, 
    -0.01947238f, 0.13366781f, 0.08818900f, -0.06242326f, -0.01396143f, -0.01818559f, 0.14350027f, 0.14097263f, 
    -0.49554259f, -0.11869875f, 0.20162293f, 0.01658698f, -0.24975252f, 0.16663346f, 0.07507601f, 0.28897500f, 
    -0.06686503f, -0.15012388f, 0.01496239f, 0.02550803f, 0.08885494f, -0.09509274f, 0.06221704f, 0.11530267f, 
    0.26993227f, -0.40211156f, 0.43819401f, 0.31878224f, -0.11633135f, 0.08701672f, -0.14981031f, 0.10317479f, 
    0.00748965f, 0.17155297f, -0.02419572f, 0.26521948f, 0.32272071f, -0.12130888f, -0.07464238f, -0.28446603f, 
    0.26185557f, 0.19248988f, -0.15186301f, 0.39776787f, 0.36332634f, 0.05392130f, 0.01063784f, -0.42813340f, 
    -0.26373202f, 0.03898710f, 0.05769580f, -0.03885863f, 0.14616439f, 0.14756981f, 0.08198420f, 0.07495567f, 
    0.19866012f, -0.13916126f, -0.07840135f, -0.17932273f, -0.00994854f, -0.14333957f, -0.10465442f, 0.23751786f, 
    0.00741257f, -0.30966479f, -0.03284025f, 0.17121808f, 0.00630173f, -0.13796924f, 0.03178944f, 0.39369130f, 
    0.02918913f, 0.03254291f, -0.47526410f, -0.40493202f, 0.07721426f, 0.03154846f, 0.01397207f, -0.06725454f, 
    0.09836692f, -0.08488686f, -0.02404110f, 0.08484232f, 0.03961650f, 0.18144588f, 0.32656875f, -0.03004294f, 
    -0.00838504f, -0.07616756f, 0.08881545f, 0.04431322f, 0.02731448f, 0.11079857f, 0.07185832f, -0.14842328f, 
    -0.25975767f, -0.11417206f, 0.21587944f, 0.01495461f, 0.05094190f, -0.03186759f, -0.06499559f, -0.05603744f, 
    -0.06673390f, 0.35788336f, -0.17273168f, 0.01698101f, 0.14478426f, 0.02926095f, -0.03470051f, -0.11044957f, 
    0.06119927f, 0.26120034f, 0.04646765f, -0.01552811f, 0.14852159f, 0.14816907f, -0.14121486f, 0.10284705f, 
    0.00923966f, 0.28559893f, 0.12362535f, -0.02340585f, 0.16636132f, -0.55612689f, -0.27350765f, -0.03969757f, 
    0.13824235f, 0.23276278f, 0.04496662f, -0.01892904f, -0.20472440f, -0.23339888f, -0.45048863f, -0.39698508f, 
    -0.28258535f, 0.04468676f, 0.30163571f, 0.03180397f, -0.08658686f, -0.20285694f, -0.02585711f, 0.15263335f, 
    -0.01814546f, 0.00783861f, 0.04128463f, -0.24145702f, 0.16284764f, 0.10265301f, 0.14764093f, -0.00193573f, 
    -0.09530858f, -0.05268356f, 0.00080057f, -0.06667662f, 0.00069845f, 0.20560753f, 0.17032358f, -0.06466296f, 
    -0.05272150f, -0.04949943f, -0.04390236f, 0.00829058f, -0.04460469f, 0.03365952f, 0.02501048f, -0.04144689f, 
    0.01054970f, -0.00551656f, 0.04494228f, 0.02814379f, -0.00398422f, 0.03560888f, -0.02188323f, -0.01323900f, 
    0.02022020f, -0.01799668f, 0.00191439f, -0.03880835f, 0.02855531f, -0.00116843f, -0.02853652f, -0.01572322f, 
    0.04976269f, 0.01510546f, -0.00355121f, -0.00838119f, -0.04920651f, 0.00825156f, -0.05236309f, 0.00927424f, 
    0.00834360f, 0.02340687f, -0.06404151f, 0.04102832f, 0.04098349f, -0.05379106f, -0.03450043f, 0.03892709f, 
    -0.04689417f, 0.04603169f, -0.04444747f, 0.01688644f, -0.02866391f, -0.04747588f, 0.03072962f, 0.03395610f, 
    0.06701972f, -0.05861920f, 0.02373896f, -0.00383027f, -0.01061467f, -0.05723739f, 0.01643179f, -0.01655377f, 
    0.02396031f, 0.00470456f, -0.00012438f, -0.03284362f, -0.05418868f, -0.04789382f, 0.04807435f, -0.05478861f, 
    0.02755167f, -0.04272841f, -0.02103665f, 0.01159294f, 0.03712052f, -0.02394465f, -0.04843672f, 0.03553198f, 
    0.02400715f, -0.06179171f, -0.00608617f, -0.02901305f, 0.05688446f, 0.02100885f, 0.03145184f, -0.00853776f, 
    -0.00820738f, -0.01998436f, 0.00497511f, 0.04938217f, -0.00251807f, -0.04491130f, -0.00548830f, -0.04031260f, 
    0.04955891f, -0.04886602f, -0.04077985f, -0.03218567f, 0.04653918f, -0.05561724f, -0.00219224f, -0.00304132f, 
    -0.03315932f, -0.02494745f, 0.01557701f, -0.00372891f, -0.06674328f, -0.06656403f, 0.04730483f, -0.06273464f, 
    -0.01601969f, 0.02378860f, -0.05610297f, -0.04881507f, -0.04136648f, -0.04319539f, 0.00211367f, 0.04336038f, 
    -0.03575431f, 0.00984376f, -0.06087722f, 0.02908057f, -0.02595336f, -0.06456985f, 0.05431275f, -0.05498695f, 
    -0.05118182f, -0.03119391f, 0.03032540f, -0.02049100f, 0.05291631f, -0.02254378f, 0.00867923f, -0.01418754f, 
    0.02664495f, -0.05001939f, -0.02948450f, -0.03429323f, 0.04620098f, -0.03897110f, 0.00883595f, 0.02439464f, 
    -0.02511438f, -0.01679282f, -0.03545782f, 0.01796873f, 0.03926318f, -0.05648123f, -0.02707572f, 0.01216355f, 
    -0.01962539f, -0.02401148f, 0.01767533f, -0.00455942f, -0.00751229f, -0.02441160f, -0.00590158f, 0.04099848f, 
    0.02234281f, -0.01513383f, -0.02804612f, 0.03552929f, 0.04446667f, -0.03005707f, 0.03087836f, 0.03345452f, 
    0.03715641f, 0.02086470f, 0.03777649f, 0.00326292f, -0.05556433f, 0.01956808f, 0.04338630f, 0.03154854f, 
    0.04422643f, 0.00119612f, 0.03154774f, -0.02493164f, -0.02167516f, -0.01383230f, 0.03417012f, 0.01787900f, 
    -0.05506305f, 0.02542128f, 0.04110016f, 0.00696257f, 0.00564738f, -0.00225593f, 0.02254650f, -0.04525158f, 
    -0.02568795f, 0.00747240f, -0.02810511f, 0.01031203f, 0.00850970f, 0.02634717f, -0.04729190f, -0.04474648f, 
    0.01315991f, 0.02563399f, -0.02326276f, -0.01952369f, 0.00083808f, 0.04436710f, 0.01083983f, -0.06338228f, 
    0.02338760f, 0.00844435f, 0.03378902f, -0.05405925f, 0.06224936f, 0.00707046f, 0.03286936f, 0.01711684f, 
    -0.04461356f, -0.02905119f, 0.04112514f, -0.00291377f, 0.03196628f, -0.06103310f, -0.00579263f, 0.03979971f, 
    -0.05349912f, -0.03369335f, 0.01271380f, 0.03152800f, 0.02883876f, -0.03179608f, -0.02156380f, 0.04753965f, 
    0.00005943f, 0.01329426f, 0.03868327f, -0.03952203f, 0.01334403f, -0.01741034f, 0.01580669f, -0.05941728f, 
    0.04148638f, 0.04540160f, -0.01807610f, -0.05978285f, -0.00814614f, -0.02543321f, 0.02471498f, -0.01640403f, 
    0.00856771f, 0.02264280f, -0.02190683f, -0.04631877f, 0.00761750f, -0.06589526f, -0.06504793f, -0.06755181f, 
    -0.00218642f, -0.05978719f, -0.06828966f, -0.03085498f, -0.04321934f, -0.04139262f, -0.04443301f, -0.03061636f, 
    0.01185449f, 0.02650464f, 0.04373745f, -0.00844223f, 0.00616762f, -0.05062237f, -0.03461838f, -0.03263941f, 
    -0.00032196f, -0.03432585f, -0.06249475f, -0.02296269f, 0.00659529f, -0.01795207f, -0.00337206f, -0.03599045f, 
    -0.04011212f, -0.03345858f, -0.05091374f, 0.03015663f, 0.04586996f, 0.02059380f, -0.06409425f, 0.00972209f, 
    -0.06638491f, 0.04421055f, -0.00985102f, -0.02505869f, -0.01427009f, 0.01232512f, 0.01300783f, 0.04740403f, 
    -0.01504881f, 0.02956193f, 0.02901116f, -0.05498930f, -0.00799665f, 0.03582159f, 0.01017984f, -0.04311239f, 
    0.03023013f, 0.01455926f, 0.04604891f, 0.00360314f, 0.00393890f, 0.01374452f, -0.06498372f, -0.02841241f, 
    0.02834894f, -0.01914308f, 0.03347105f, -0.01100265f, 0.02629156f, 0.03916402f, -0.05600049f, -0.00292661f, 
    -0.03655690f, 0.02507428f, -0.03800534f, 0.03402689f, 0.04601426f, 0.01449215f, -0.00734808f, -0.02666244f, 
    0.00626782f, -0.05260597f, -0.03742937f, -0.02218710f, 0.00874158f, -0.03331628f, -0.00511736f, 0.03657450f, 
    -0.03614898f, -0.01026947f, -0.04697552f, 0.03326155f, -0.00597673f, -0.00626000f, 0.03810545f, 0.00909607f, 
    0.01184779f, -0.02509942f, 0.03470422f, 0.01340368f, 0.03643839f, -0.01297354f, 0.03399837f, -0.05611865f, 
    -0.00097800f, -0.05333196f, 0.01278286f, -0.04545336f, -0.03730608f, 0.02225627f, -0.03942799f, 0.01383370f, 
    -0.05134814f, -0.02177602f, 0.00439554f, -0.03171762f, -0.03630275f, 0.01693068f, 0.05101845f, 0.01144502f, 
    -0.02017804f, 0.02893782f, 0.00119592f, 0.02674987f, -0.00576879f, 0.02128728f, -0.04841409f, 0.03078950f, 
    0.03074251f, 0.02460680f, 0.00231644f, 0.00495416f, 0.04300732f, -0.06617820f, 0.03806252f, -0.05143131f, 
    -0.03700148f, -0.03861104f, -0.03459207f, -0.03102050f, 0.03969971f, -0.02104204f, 0.00976869f, -0.04690381f, 
    -0.00900525f, 0.04298966f, 0.00652253f, 0.00317045f, -0.02272354f, 0.02865165f, -0.04690758f, -0.01953428f, 
    0.03323255f, -0.02202658f, 0.01431454f, -0.03468884f, 0.00515825f, -0.06030182f, -0.03584113f, -0.00880950f, 
    -0.01278534f, -0.04949135f, 0.02692986f, -0.02983690f, -0.02573356f, -0.01966311f, -0.01957578f, -0.06106429f, 
    0.02151317f, 0.00774934f, -0.04770447f, 0.02950632f, -0.04691779f, -0.00457230f, 0.03084417f, -0.02887332f, 
    0.01260152f, -0.00982030f, 0.04662864f, -0.03199915f, 0.02963757f, -0.00001074f, 0.05043461f, -0.01014110f, 
    -0.04855769f, -0.00396985f, 0.00608443f, -0.06529351f, -0.05757134f, -0.04314817f, -0.02034950f, -0.06244840f, 
    -0.01520281f, -0.00810716f, -0.03964420f, 0.01433473f, 0.01358309f, -0.03783135f, 0.00862065f, -0.04198519f, 
    0.03749928f, 0.04418316f, -0.02200188f, 0.03069663f, 0.00844228f, -0.06377485f, -0.06732768f, 0.01072821f, 
    -0.02293929f, -0.05594332f, 0.04616240f, -0.00639446f, 0.00394432f, 0.02910550f, 0.02876933f, 0.01090210f, 
    -0.01853104f, 0.02200136f, 0.04611357f, -0.06439905f, -0.05766865f, -0.05674938f, -0.01785292f, -0.00016134f, 
    0.02025054f, -0.05093759f, 0.03802573f, 0.02868476f, 0.01273670f, 0.01998962f, -0.00688252f, -0.05157553f, 
    -0.01095365f, -0.02290053f, -0.01701273f, -0.02818926f, -0.01361602f, 0.02928231f, -0.02195905f, 0.04466327f, 
    0.01134550f, -0.06163648f, -0.03263807f, -0.01749201f, -0.01810765f, 0.04223096f, -0.00023480f, 0.04455762f, 
    0.02294458f, 0.04398396f, -0.02194793f, 0.02344507f, -0.06287652f, -0.01178262f, -0.04915991f, 0.01166570f, 
    0.03663756f, -0.02947109f, 0.01035284f, 0.03091166f, 0.00241169f, 0.03742478f, 0.03173895f, 0.02677634f, 
    -0.03619912f, 0.01259313f, 0.03312628f, 0.03300997f, 0.03098743f, -0.05584220f, -0.00696052f, -0.01375340f, 
    -0.05063178f, 0.00318679f, 0.03407377f, 0.02180170f, -0.02833228f, -0.06324914f, 0.01898634f, -0.04985330f, 
    -0.00912862f, 0.00053817f, 0.02900931f, -0.06454708f, -0.04154415f, -0.06262910f, -0.06680597f, -0.00049422f, 
    0.03928191f, 0.01967536f, -0.06259441f, -0.02217865f, -0.03168292f, -0.02511454f, -0.00910334f, -0.00394107f, 
    0.04459057f, -0.01619243f, 0.00263368f, -0.01788699f, -0.05690947f, -0.05076269f, 0.04572214f, -0.03873778f, 
    -0.06233358f, 0.02819666f, -0.04501635f, -0.02137964f, 0.00970742f, -0.02594479f, 0.03320461f, 0.04582537f, 
    -0.00733263f, -0.03392292f, -0.01353895f, 0.04251405f, 0.03196045f, -0.01107686f, -0.01081906f, 0.01054789f, 
    0.01263070f, -0.06551345f, 0.01379169f, -0.02922030f, -0.05745606f, -0.04768698f, 0.03342165f, 0.00000540f, 
    0.02837862f, 0.00931363f, 0.04854142f, 0.02945965f, 0.02846056f, -0.01491687f, -0.05404348f, -0.02826286f, 
    0.39662811f, 0.12553078f, 0.17057495f, 0.16312796f, 0.08387197f, 0.27360454f, 0.03616429f, 0.14541870f, 
    0.00705316f, 0.09436409f, -0.09428573f, 0.02675325f, -0.14429468f, -0.10582098f, 0.06768968f, 0.06432149f, 
    -0.08830266f, -0.25055894f, 0.01597630f, -0.29036883f, -0.11304121f, 0.10998081f, 0.05512396f, -0.25107455f, 
    0.15768278f, 0.29929212f, -0.45378146f, 0.44930258f, 0.70610142f, 0.03742392f, -0.13636719f, 0.06253167f, 
    0.08320185f, 0.15699428f, -0.15687494f, -0.11219721f, 0.27823111f, -0.20643805f, 0.17888607f, -0.04265432f, 
    0.18364754f, -0.10179288f, 0.04823174f, 0.10484191f, -0.12332137f, 0.10310340f, -0.10013787f, -0.26037276f, 
    -0.13037957f, -0.35551605f, -0.10493009f, -0.00104270f, 0.12225399f, 0.09488802f, 0.22036001f, 0.28849548f, 
    0.18094000f, -0.34700397f, -0.32065997f, -0.27231085f, 0.14762494f, 0.10585196f, -0.11902375f, 0.17087093f, 
    0.55510551f, -0.22716545f, 0.18876685f, 0.11724499f, -0.10279734f, 0.04767388f, 0.08708513f, -0.18563624f, 
    0.49372530f, 0.51539910f, 0.13656969f, 0.04507609f, 0.06005993f, 0.06512590f, -0.10781042f, 0.02953877f, 
    -0.03372115f, 0.21392426f, 0.26558203f, 0.22110051f, -0.37738255f, -0.05786565f, -0.32286102f, 0.00590288f, 
    0.05863915f, 0.05081388f, -0.04707085f, -0.12517041f, -0.19965640f, 0.09774864f, -0.32447711f, -0.10637012f, 
    0.01162932f, 0.10040043f, -0.00729435f, -0.03423343f, 0.14986196f, -0.02369436f, -0.07910622f, 0.07117061f, 
    -0.08019041f, -0.01255509f, -0.00207499f, -0.18538518f, -0.47453743f, -0.03572169f, 0.09863839f, -0.03779347f, 
    0.03735180f, -0.07619592f, -0.08487277f, -0.02050819f, 0.18233995f, -0.05443346f, 0.06037723f, 0.04338628f, 
    -0.17738323f, -0.08638368f, -0.16101173f, -0.01678008f, 0.05671480f, 0.18839233f, 0.00843248f, 0.19489940f, 
    0.11558490f, 0.03959911f, 0.00613422f, 0.06195218f, -0.18157554f, -0.19350526f, 0.06259779f, -0.24273895f, 
    -0.01197377f, -0.08797018f, -0.07802343f, -0.07435616f, -0.19987589f, 0.06272981f, -0.12709673f, 0.19105786f, 
    -0.06774046f, 0.09861971f, 0.15800343f, -0.01967554f, 0.02345136f, -0.04801297f, 0.00751836f, -0.10064014f, 
    -0.02488235f, 0.76814765f, -0.15631446f, 0.02315378f, 0.05661211f, -0.04610941f, 0.14687984f, -0.05358140f, 
    0.15250076f, 0.10662059f, 0.14735943f, -0.09632546f, -0.21140949f, -0.22138010f, 0.17205849f, 0.29160663f, 
    -0.08842763f, 0.05665343f, -0.12884352f, 0.13126488f, 0.26624578f, -0.30826649f, -0.05956842f, -0.12357061f, 
    0.12227625f, 0.05046510f, 0.02987920f, -0.04760490f, -0.02059927f, 0.08873957f, -0.04564815f, 0.09877533f, 
    0.03629412f, -0.01379963f, -0.01822195f, -0.06875010f, -0.10413200f, 0.35248378f, -0.03128147f, -0.41563430f, 
    -0.13871467f, 0.05470421f, 0.10578532f, 0.18223077f, -0.02969509f, -0.06104623f, 0.59664810f, -0.12377895f, 
    -0.61035162f, 0.37394476f, -0.16507408f, 0.38816455f, 0.19126886f, 0.08718455f, -0.26778901f, -0.11709207f, 
    -0.22578320f, -0.07715029f, -0.13683254f, 0.06152572f, -0.09861224f, -0.02491320f, 0.00887124f, -0.03344635f, 
    0.00673084f, 0.27543136f, 0.09064697f, -0.06312043f, -0.02864862f, 0.01599759f, -0.00791045f, 0.00945330f, 
    -0.03539501f, 0.08580960f, -0.20098951f, 0.03389877f, -0.39074260f, -0.08220848f, -0.18349838f, 0.16380088f, 
    -0.10803652f, 0.01805145f, -0.33197692f, -0.31929797f, 0.14736770f, -0.07089500f, -0.02462754f, -0.26592466f, 
    -0.05985261f, -0.25054699f, 0.19318162f, 0.15530318f, 0.11261442f, -0.22478126f, -0.20872203f, -0.09471368f, 
    -0.21756352f, -0.00313566f, -0.06860553f, -0.14202006f, -0.34938502f, -0.10701922f, -0.58059889f, -0.02754107f, 
    -0.07606419f, 0.06196882f, -0.12348130f, 0.02604861f, -0.14378142f, -0.14189170f, -0.27146319f, -0.16295935f, 
    -0.17740349f, 0.03979284f, 0.03262276f, 0.09395796f, -0.08064989f, 0.09382601f, -0.27694350f, -0.18881109f, 
    -0.28464562f, 0.01174817f, -0.07943472f, -0.10532665f, 0.10360179f, -0.39803076f, 0.13329020f, -0.04617223f, 
    0.20618503f, 0.11484049f, -0.07218978f, 0.02770741f, -0.02652404f, 0.01790188f, -0.05415795f, 0.00324190f, 
    -0.27090934f, 0.36165521f, 0.86485660f, 0.04030304f, 0.06479724f, 0.20418759f, 0.03814143f, 0.08145522f, 
    -0.00676486f, 0.04870482f, 0.14916955f, -0.04434390f, -0.06475792f, -0.11712516f, -0.22176716f, 0.48524654f, 
    0.46729648f, 0.40049881f, 0.32977054f, -0.14931387f, -0.25415275f, 0.06641506f, 0.04112647f, 0.10930333f, 
    0.00866570f, -0.25356597f, 0.02158041f, -0.54602188f, -0.26248854f, 0.10807696f, 0.07306696f, 0.09346899f, 
    -0.10230990f, -0.05697514f, 0.01982378f, -0.02822576f, 0.24075910f, -0.09203953f, -0.44376418f, 0.05288159f, 
    0.07875510f, 0.06468900f, 0.02301286f, -0.27617657f, -0.12077492f, 0.35174876f, -0.68563187f, -0.77431667f, 
    0.27893943f, -0.09509849f, -0.44063216f, -0.03973730f, -0.06979237f, 0.08880083f, 0.04266936f, -0.10140618f, 
    -0.02803852f, -0.10160473f, -0.14199176f, -0.03470205f, -0.01077937f, 0.06539699f, 0.28824830f, -0.05403514f, 
    0.28735912f, -0.02833092f, 0.11349814f, 0.23362377f, -0.08243519f, 0.17597939f, 0.17609008f, -0.07405629f, 
    -0.32745120f, -0.11925406f, 0.23288204f, 0.13067608f, 0.00499486f, 0.04291947f, -0.03830598f, -0.17549749f, 
    0.02360369f, 0.09057183f, -0.38574705f, -0.38663626f, 0.12422124f, 0.15058862f, -0.08748907f, -0.03061849f, 
    -0.05271594f, -0.00856391f, 0.02829484f, -0.28416735f, -0.15981352f, -0.06171797f, 0.06412399f, -0.01334088f, 
    0.01021880f, -0.03348719f, -0.02086060f, 0.11265034f, 0.15295044f, -0.10049303f, 0.17437886f, -0.04150176f, 
    0.20773852f, 0.11192644f, 0.09821232f, 0.14943205f, -0.04264852f, -0.12569122f, -0.17360760f, 0.19285494f, 
    0.09853809f, -0.23342519f, -0.22357969f, 0.22216934f, -0.03150595f, -0.13622768f, -0.02735838f, 0.37281439f, 
    0.13834600f, 0.11723665f, 0.03847007f, -0.18091527f, -0.00303514f, -0.26138222f, -0.05534648f, -0.06322069f, 
    0.19378674f, 0.11642195f, 0.20753512f, 0.14960712f, 0.00615376f, 0.09295180f, 0.35985550f, 0.00067757f, 
    0.17211623f, 0.23528260f, 0.22001120f, 0.12369432f, -0.04268967f, -0.02503969f, 0.14906946f, 0.13220705f, 
    0.09224477f, -0.04354145f, 0.00086047f, 0.19365893f, 0.08045267f, 0.06006862f, 0.43049160f, 0.28150234f, 
    0.45851371f, -0.13084960f, 0.10823502f, 0.10336809f, 0.16643420f, -0.08937295f, 0.16050892f, 0.12879357f, 
    0.15282688f, 0.02316500f, 0.19737658f, -0.08466820f, -0.03587423f, -0.24116321f, -0.05136419f, 0.05351753f, 
    0.09756324f, 0.13164721f, 0.24991034f, 0.05712366f, 0.08186075f, 0.05264553f, -0.01104482f, 0.02207255f, 
    0.09162069f, 0.13613249f, 0.01846519f, 0.09343117f, 0.24704306f, -0.12068757f, -0.32296199f, 0.07732724f, 
    -0.17285502f, 0.04986435f, 0.07818434f, -0.17996228f, 0.11308228f, -0.47410986f, 0.49777231f, 0.28342405f, 
    0.15946482f, 0.10049380f, 0.04864183f, 0.24209118f, 0.09353781f, 0.09959660f, -0.63819283f, -0.18269442f, 
    0.06065612f, 0.03417834f, 0.06080498f, -0.02877058f, 0.14101602f, -0.01938159f, -0.00417504f, 0.07457349f, 
    0.00236509f, -0.15636148f, 0.17736603f, 0.05300952f, -0.03676644f, -0.04412418f, 0.06100021f, 0.03649234f, 
    -0.12031581f, -0.04344866f, -0.05803582f, 0.13253511f, -0.15244652f, -0.16155259f, -0.10192761f, -0.09613523f, 
    0.14373310f, 0.13805942f, 0.08870945f, 0.00366031f, -0.15391687f, -0.16790682f, -0.06974558f, 0.09265982f, 
    0.36765295f, 0.43377590f, 0.20235550f, -0.03666222f, -0.07013386f, 0.02101061f, 0.17475884f, 0.05817516f, 
    0.14178409f, 0.23465319f, -0.07847682f, 0.16068399f, -0.11021265f, -0.03689469f, -0.20513135f, -0.03610084f, 
    -0.20082211f, 0.07264198f, -0.04325892f, -0.04729808f, 0.11227211f, 0.16906475f, 0.08167845f, 0.08292919f, 
    -0.11862533f, -0.17806618f, 0.14658551f, -0.06140988f, -0.20171691f, -0.47110465f, 0.16231026f, 0.10601945f, 
    -0.02077598f, 0.15438806f, -0.27260745f, 0.13560793f, 0.27586165f, 0.20846085f, -0.07907170f, 0.06413698f, 
    -0.07992067f, 0.04568790f, -0.07561479f, -0.08676852f, 0.02842290f, 0.22800066f, 0.53408802f, -0.04528470f, 
    -0.06879308f, -0.09063105f, 0.08366828f, 0.05576306f, 0.05842298f, 0.02666805f, -0.17609587f, 0.17453763f, 
    -0.23035480f, 0.05589868f, -0.04078076f, 0.10066576f, 0.01098042f, 0.01169196f, 0.09770848f, -0.04281072f, 
    0.14996099f, -0.12860714f, 0.16697417f, -0.08950168f, 0.00983918f, -0.05568530f, -0.03279420f, 0.02838713f, 
    0.03106848f, -0.03674551f, 0.67369998f, 0.08837600f, -0.23566669f, 0.03227571f, -0.02704410f, 0.00602341f, 
    0.18822588f, 0.02979178f, -0.09700027f, 0.20428178f, 0.33593109f, 0.23692840f, 0.20444115f, 0.13573296f, 
    -0.01235767f, 0.12696521f, -0.07137832f, -0.07652878f, 0.64341545f, -0.19923982f, -0.44159299f, 0.06824584f, 
    0.10801595f, 0.01079842f, -0.08796579f, 0.05420082f, -0.00499170f, -1.13123536f, -0.38555902f, -0.64407188f, 
    0.16966245f, -0.00099970f, -0.26967725f, 0.20632954f, 0.03182142f, -0.10262568f, -0.37130561f, -0.06137181f, 
    -0.07398328f, 0.12836502f, 0.18104438f, 0.05630837f, 0.12695186f, 0.15167353f, 0.20119026f, -0.12769637f, 
    0.66241682f, -0.14175364f, -0.09171437f, -0.39331183f, -0.17948635f, -0.10796877f, 0.01785223f, -0.34986639f, 
    -0.01418018f, 0.08510369f, -0.49551100f, 0.06697062f, 0.06910733f, -0.16167805f, -0.11124036f, 0.07937808f, 
    0.03174124f, -0.83816904f, -0.52391309f, -0.42869893f, 0.00110727f, -0.03639325f, -0.05780666f, -0.02258786f, 
    0.15095840f, -0.04206438f, -0.52903163f, -0.06273629f, 0.18485929f, -0.04561676f, -0.00332326f, -0.06801233f, 
    0.20042457f, 0.08694011f, -0.06665746f, 0.05099306f, 0.09815808f, 0.25146610f, 0.11911367f, 0.05223808f, 
    0.27463838f, -0.13616271f, -0.09318366f, 0.16502929f, 0.10104086f, 0.11928584f, 0.03446100f, -0.06027894f, 
    -0.16695073f, -0.12689532f, 0.09095911f, 0.22942249f, 0.10975697f, -0.14157757f, -0.09439593f, -1.06936622f, 
    -0.03947291f, 0.07480485f, 0.21560970f, 0.21781921f, -0.05652354f, -0.00343425f, 0.40361646f, -0.15216415f, 
    -0.53244871f, 0.06539661f, 0.07276914f, 0.08141211f, 0.01999625f, -0.15135695f, 0.12317517f, 0.00981038f, 
    -0.07773332f, -0.09729560f, 0.04538385f, 0.03618624f, 0.09732145f, 0.15115732f, 0.01526061f, 0.06751302f, 
    0.16490927f, 0.01768943f, 0.06048970f, -0.05009612f, -0.21023811f, -0.21659413f, 0.00096055f, -0.07961602f, 
    0.38459349f, -0.66762018f, -0.09635008f, 0.31088877f, 0.23401470f, -0.05512074f, 0.19428368f, -0.00501936f, 
    0.03039181f, 0.08121993f, -0.12159387f, -0.05104561f, 0.09505137f, 0.28813297f, -0.03533372f, 0.13300994f, 
    0.00230655f, 0.14466864f, 0.13146538f, 0.09272949f, 0.28955019f, -0.15404306f, -0.12583290f, 0.06113834f, 
    -0.07997666f, 0.07230633f, -0.06910390f, -0.13391769f, -0.03001614f, -0.02325339f, 0.03172005f, -0.02199955f, 
    -0.07174550f, -0.00325009f, 0.01534094f, -0.06956111f, -0.19319463f, -0.28520411f, 0.50735414f, -0.12201565f, 
    -0.18551244f, 0.05592311f, -0.00891143f, 0.13407519f, -0.00903300f, 0.36681110f, -0.79918790f, 0.42669040f, 
    0.55738318f, 0.14041318f, 0.19688712f, -0.04282995f, 0.07870322f, -0.20713590f, -0.11057124f, 0.44512817f, 
    0.02950994f, -0.02140619f, 0.07165769f, -0.06512155f, 0.17995767f, 0.12055619f, -0.03669019f, 0.20657155f, 
    0.34641877f, 0.08350798f, 0.22792096f, -0.08356594f, 0.07193258f, -0.02776978f, -0.18207654f, -0.11149967f, 
    -0.00526678f, -0.07172798f, 0.02491624f, 0.01070034f, -0.02323791f, -0.05398472f, -0.02478011f, 0.10629159f, 
    -0.08656034f, 0.21125074f, 0.17766371f, 0.20500006f, 0.03578389f, 0.09790806f, -0.02600514f, 0.17024367f, 
    0.02494082f, -0.08116922f, 0.28380632f, -0.20905115f, 0.01060372f, 0.17897268f, 0.09767631f, 0.12680556f, 
    0.08790645f, 0.13329741f, 0.12192821f, 0.14349526f, 0.75412786f, -0.24122198f, -0.11542630f, 0.09762068f, 
    -0.17888565f, 0.22227809f, 0.30469117f, 0.09163106f, 0.02005348f, 0.18379821f, -0.41122326f, -0.54046774f, 
    0.31024835f, 0.07797555f, 0.17830095f, 0.16498052f, -0.10979743f, -0.06257968f, -0.14223380f, -0.02775059f, 
    0.10236847f, 0.04842662f, 0.08161385f, -0.11738894f, -0.08340342f, 0.00304825f, -0.03934567f, 0.04755539f, 
    0.01191332f, 0.16296826f, -0.02314824f, -0.05962548f, -0.13554665f, -0.22061080f, -0.12608035f, 0.18873937f, 
    -0.12828375f, 0.34426972f, 0.15128803f, -0.03536491f, -0.31352901f, -0.08091878f, 0.04507174f, -0.05319249f, 
    -0.09847482f, -0.25999799f, -0.08907188f, 0.13147797f, -0.00228811f, 0.00163361f, 0.11893062f, 0.07978648f, 
    -0.32653123f, -0.28757429f, -0.27181986f, -0.07504810f, -0.07104225f, 0.01126731f, 0.25587368f, 0.08146106f, 
    0.05452081f, -0.07485235f, 0.18462926f, -0.16483270f, 0.40706223f, 0.32129717f, -0.15496105f, 0.16840310f, 
    0.12239076f, 0.13720131f, 0.05312438f, 0.04958754f, -0.17587245f, 0.17297496f, 0.02552532f, 0.25596541f, 
    -0.10371260f, -0.00984588f, 0.04167751f, 0.24757329f, 0.30277735f, 0.37518248f, 0.22008942f, 0.26552323f, 
    0.18414772f, 0.17079891f, -0.08052576f, -0.02617696f, 0.09676930f, -0.33899149f, -0.02563778f, 0.05508661f, 
    0.04422339f, 0.25456491f, 0.10055735f, 0.02507880f, -0.06999551f, -0.08084320f, -0.05331828f, -0.40850732f, 
    -0.07759385f, 0.21370602f, -0.06077663f, 0.16028766f, -0.01370752f, 0.00988178f, -0.14995463f, 0.40204924f, 
    0.04362634f, 0.15921135f, 0.36008185f, -0.00541576f, 0.03737346f, -0.05384555f, 0.15035807f, 0.11923534f, 
    -0.09728324f, 0.28253922f, 0.37260559f, 0.80097085f, 0.12628075f, 0.08335361f, -0.01725763f, 0.01964524f, 
    0.08602835f, 0.08338498f, -0.12914476f, -0.02538786f, -0.02043721f, 0.04738176f, -0.13919440f, -0.06128755f, 
    0.11760576f, 0.07350353f, 0.05966427f, -0.13598391f, -0.08078170f, -0.01790715f, 0.07153575f, 0.12560901f, 
    -0.04911715f, 0.05283070f, 0.00439745f, 0.18415414f, -0.01097710f, -0.05773187f, 0.10650297f, -0.15924419f, 
    0.03176375f, 0.03668778f, -0.00646647f, -0.12282648f, -0.12134448f, 0.21883021f, 0.07037407f, 0.10274057f, 
    -0.03104715f, 0.23792154f, 0.01327218f, 0.11577634f, 0.04441962f, 0.02075520f, 0.20798208f, 0.12306708f, 
    -0.07867982f, 0.06121706f, 0.05837082f, 0.19812122f, 0.13267064f, 0.05569329f, -0.08926913f, -0.24078856f, 
    -0.58209437f, -0.01659494f, -0.02005761f, 0.07093227f, -0.02043432f, 0.04316265f, 0.05871122f, 0.03557539f, 
    0.03512994f, -0.00312234f, -0.11000600f, 0.00720029f, -0.11268106f, -0.01337115f, -0.06348766f, -0.20566773f, 
    -0.25704730f, -0.19244161f, 0.12859909f, 0.17701507f, -0.14837883f, -0.28250176f, -0.17059989f, -0.05702606f, 
    0.04348234f, 0.00175602f, 0.07458930f, 0.00574921f, 0.01164461f, 0.11810602f, -0.06913273f, -0.35379341f, 
    0.02609891f, -0.20717616f, -0.13773888f, -0.15706043f, 0.12338544f, 0.18790618f, 0.09059771f, -0.02120840f, 
    0.22595969f, 0.05350187f, 0.01955243f, 0.24808490f, 0.09477622f, 0.10814843f, 0.10668462f, 0.09640249f, 
    0.18561596f, 0.12282366f, 0.14804849f, 0.00202507f, 0.14643575f, -0.29235873f, -0.13704698f, 0.07702325f, 
    -0.15538315f, -0.24303541f, 0.23458268f, -0.21206766f, -0.26805273f, -0.21578507f, -0.14190094f, 0.32057777f, 
    0.57188851f, -0.33828306f, -0.16479088f, -0.18513252f, -0.07313988f, -0.05287299f, -0.00554909f, 0.03618022f, 
    0.06856830f, -0.02255285f, -0.03719941f, 0.15631528f, 0.01868623f, -0.15916668f, 0.02563073f, -0.03350298f, 
    -0.11237147f, -0.09004653f, -0.08453363f, 0.04016707f, 0.07535882f, -0.04927850f, 0.22579232f, -0.07299739f, 
    0.03947015f, -0.27971017f, 0.01469476f, 0.04231615f, 0.10702585f, -0.08967606f, -0.03794356f, 0.01089015f, 
    -0.05170999f, -0.18841749f, -0.01202535f, -0.03332993f, 0.08708474f, 0.06632371f, 0.18315223f, 0.05239038f, 
    0.00246158f, 0.18272731f, -0.11119982f, -0.08482728f, 0.01935296f, -0.04675807f, -0.08238719f, 0.05517939f, 
    0.01595007f, 0.15754029f, 0.00595292f, 0.04790044f, -0.28253317f, -0.45050651f, -0.01656702f, 0.01774803f, 
    0.06738317f, 0.15512334f, -0.08233315f, 0.16942325f, 0.27319461f, -0.01096016f, 0.17304549f, -0.02685649f, 
    0.18051031f, 0.06839392f, 0.02488748f, -0.09260426f, -0.11295006f, -0.13845815f, -0.30305421f, -0.29172409f, 
    -0.03632228f, -0.01356394f, -0.07718337f, -0.04685534f, 0.35607019f, -0.31222150f, -0.22341634f, -0.02521253f, 
    -0.09262691f, -0.04609748f, 0.12943731f, -0.05051228f, -0.01420586f, 0.01582372f, -0.10212705f, -0.03219124f, 
    -0.04468339f, -0.04564353f, -0.03242116f, 0.03182464f, -0.03030749f, 0.00243287f, 0.00291043f, 0.03680719f, 
    -0.01550490f, -0.03849229f, -0.02483872f, 0.04306124f, -0.06646720f, 0.02551180f, 0.00773101f, -0.02821630f, 
    0.01914509f, 0.01959467f, 0.02508858f, -0.03841681f, -0.00207981f, 0.01890819f, 0.01035213f, -0.03489147f, 
    0.01788184f, -0.00492196f, 0.02837745f, -0.02951154f, -0.06486968f, 0.02475673f, -0.05602672f, -0.01806852f, 
    -0.05455493f, 0.00776160f, -0.04299093f, -0.04582693f, 0.04385686f, -0.04285677f, -0.03868074f, -0.05482120f, 
    0.04208580f, 0.00196196f, -0.01200279f, -0.01223869f, -0.00031773f, -0.04051061f, -0.05612523f, -0.03249285f, 
    -0.05471696f, -0.02507027f, -0.03950847f, -0.00042816f, -0.01243762f, -0.02661267f, 0.00043593f, -0.06127458f, 
    0.00123317f, 0.00174021f, -0.00769317f, 0.04227946f, 0.03114234f, -0.05853071f, 0.03050678f, -0.01118373f, 
    -0.05546556f, 0.01940152f, -0.05182441f, 0.01022905f, -0.05175395f, 0.00311442f, 0.00936291f, -0.01956207f, 
    -0.06260364f, -0.04759084f, 0.00386437f, 0.01807321f, -0.01200142f, -0.02809428f, 0.04259099f, -0.03081330f, 
    -0.04525674f, 0.02555557f, 0.01915138f, -0.01135191f, -0.06524688f, 0.04195191f, 0.03590823f, -0.01360195f, 
    -0.05843297f, 0.03231456f, -0.06754263f, -0.03736836f, 0.04567103f, 0.03640958f, 0.00756483f, -0.06552833f, 
    0.00227666f, 0.01275567f, -0.06261577f, -0.04614551f, -0.05967726f, 0.02247911f, -0.05897453f, 0.01925894f, 
    -0.03018405f, -0.06076570f, 0.02242440f, -0.05985605f, -0.03419744f, 0.00656885f, -0.02171708f, -0.01835570f, 
    0.01722195f, 0.05147312f, 0.00140082f, -0.03065095f, 0.03891130f, -0.01319594f, -0.01925651f, -0.04979653f, 
    -0.05111710f, -0.00758618f, -0.01580031f, -0.00444141f, 0.04749464f, 0.04152498f, 0.03384898f, -0.02542540f, 
    0.01599995f, -0.04838364f, -0.01189952f, 0.01322192f, -0.06219946f, -0.03057495f, 0.03519436f, 0.02049303f, 
    -0.01823390f, 0.03739537f, 0.01339881f, 0.01209853f, -0.05794649f, -0.03826414f, -0.02294288f, -0.01774239f, 
    -0.06305114f, -0.06671730f, -0.02528123f, 0.00336357f, -0.04748704f, 0.02405749f, -0.02334054f, 0.03543435f, 
    0.02882169f, 0.04272238f, -0.06226646f, 0.02338710f, 0.03135721f, -0.05371232f, -0.03625865f, 0.04468457f, 
    0.04496069f, 0.02417244f, -0.02524824f, -0.00620236f, -0.04887501f, -0.00016163f, 0.03576142f, 0.01877620f, 
    -0.06448140f, -0.02589520f, -0.03720308f, 0.03499334f, -0.04230893f, 0.04289381f, -0.04345000f, 0.00299082f, 
    0.01160532f, 0.04292095f, 0.03802654f, 0.01699846f, 0.00442362f, -0.01460548f, 0.04224533f, 0.00739502f, 
    -0.02492982f, -0.01934659f, -0.00603642f, 0.01134321f, 0.01648464f, -0.01332144f, -0.05849469f, 0.02893952f, 
    -0.01616206f, 0.02595500f, 0.01579970f, -0.04101520f, 0.02459296f, -0.03839631f, -0.04963814f, 0.02525625f, 
    -0.00816654f, -0.01292523f, -0.03908588f, -0.04431876f, 0.01058142f, -0.05405316f, -0.01653311f, 0.03267984f, 
    -0.02926649f, -0.06759959f, -0.04478190f, -0.02006737f, -0.01005157f, 0.04721098f, -0.04149503f, -0.01865410f, 
    -0.06396157f, 0.04347479f, -0.04621559f, -0.04291096f, 0.03963095f, 0.04966094f, -0.00254354f, -0.05387512f, 
    0.01617172f, 0.01336213f, -0.06614828f, -0.04622687f, 0.04600838f, -0.04129313f, 0.02629513f, -0.03700707f, 
    0.01600193f, -0.01233524f, -0.00068433f, 0.01940705f, -0.05171092f, -0.00103250f, -0.01131369f, -0.05145115f, 
    -0.00407911f, -0.04155064f, -0.02145378f, 0.04886860f, -0.04770874f, 0.03891277f, -0.00321425f, -0.02471421f, 
    0.04614560f, -0.03303847f, -0.01566977f, -0.02789368f, -0.05677271f, 0.02835033f, 0.01045261f, 0.00629326f, 
    0.02372014f, -0.04971692f, 0.02089904f, -0.02365189f, -0.05378036f, 0.01609526f, -0.03774842f, 0.00694350f, 
    -0.04835851f, -0.03229997f, 0.01533633f, 0.01572085f, -0.00600050f, 0.02693589f, -0.02587185f, 0.04417005f, 
    -0.04080975f, 0.00090018f, -0.00454651f, -0.00893103f, -0.05063927f, 0.00277243f, -0.05065621f, -0.06242777f, 
    -0.03121443f, -0.05728198f, 0.03760904f, -0.02385948f, -0.02266429f, 0.02756490f, 0.02477906f, 0.01197033f, 
    -0.00187268f, 0.13653488f, 0.27856693f, -0.05257798f, -0.40000737f, -0.29215351f, -0.07245788f, 0.05874675f, 
    0.03186530f, 0.07784165f, -0.34533790f, 0.10503155f, -0.06744467f, 0.02573335f, 0.02001311f, 0.06499101f, 
    -0.09977841f, -0.19138682f, -0.07005510f, -0.01766491f, -0.13403700f, 0.09992720f, -0.04783123f, 0.15001751f, 
    0.22323866f, 0.08419163f, 0.18198758f, -0.55911940f, 0.10626607f, 0.12607688f, -0.09387844f, -0.12725462f, 
    -0.10267296f, 0.07913647f, 0.13796264f, -0.00343246f, 0.02828821f, 0.25284922f, -0.13889742f, -0.00099396f, 
    -0.05066658f, 0.05419432f, 0.18384865f, 0.21082063f, 0.08989799f, -1.04252756f, -0.09989911f, -0.11206271f, 
    -0.03532261f, 0.04465359f, -0.31355006f, 0.12279557f, 0.28838205f, -0.02466040f, 0.10497262f, 0.08664330f, 
    0.10228226f, 0.01307431f, -0.01053949f, 0.01430157f, 0.00792530f, 0.09430513f, 0.08691585f, 0.06479205f, 
    -0.37591952f, 0.27192229f, -0.31021854f, 0.04115951f, 0.14288667f, 0.28289843f, -0.12067293f, 0.14087638f, 
    -0.13405254f, 0.51892620f, 0.35520238f, -0.00706850f, -0.12920281f, -0.14854780f, 0.06000901f, 0.04760885f, 
    -0.02548948f, 0.24835956f, 0.29420200f, -0.09836017f, 0.09922910f, -0.01616315f, 0.01360869f, -0.02342414f, 
    0.16366409f, 0.03986540f, 0.00050370f, -0.01648274f, 0.00939668f, 0.08271863f, -0.14935161f, -0.07633019f, 
    -0.14093781f, 0.07535423f, 0.16458878f, 0.12391996f, 0.06521891f, 0.27563921f, 0.05109347f, 0.11352508f, 
    0.16397223f, 0.04671383f, -0.04444174f, 0.03509342f, -0.17629963f, -0.01410335f, 0.08071111f, -0.02803564f, 
    0.02720258f, -0.03557451f, -0.16806601f, -0.01766763f, 0.11547025f, 0.24581023f, -0.09930883f, -0.70469284f, 
    -0.03098617f, -0.01251989f, -0.00630925f, -0.02295377f, 0.05483918f, -0.12753053f, 0.22669235f, 0.01642241f, 
    -0.07797997f, 0.06070278f, 0.04748990f, 0.05616211f, -0.05672581f, 0.11365430f, -0.03275855f, -0.14238375f, 
    -0.39521423f, 0.02882015f, -0.02231910f, 0.01974774f, 0.13450186f, -0.12679182f, -0.02713953f, -0.11776479f, 
    0.14294912f, -0.36689419f, -0.31577197f, 0.05865577f, 0.09279801f, 0.04108616f, 0.21626884f, -0.09256041f, 
    -0.12409337f, -0.13991360f, -0.16401669f, 0.02447134f, 0.03978042f, -0.13002405f, -0.07629246f, 0.07410310f, 
    -0.18951109f, -0.12491668f, 0.43392929f, 0.10437574f, -0.08202708f, -0.11256982f, -0.12039739f, -0.05232642f, 
    -0.19794156f, -0.19974501f, 0.04158666f, -0.11827594f, -0.11590230f, 0.11760949f, 0.15419514f, 0.02653598f, 
    0.18946424f, 0.11925481f, 0.14748494f, 0.05026436f, 0.05594834f, -0.13579577f, -0.02915144f, 0.15452999f, 
    0.04645455f, 0.10748935f, 0.06253245f, 0.26271433f, 0.06180468f, 0.00580070f, -0.47049329f, 0.09061904f, 
    -0.02730697f, -0.28028700f, 0.08981055f, -0.16683006f, 0.06583800f, -0.07326332f, 0.25218055f, -0.52854764f, 
    -0.22939657f, 0.23964588f, -0.08727564f, -0.35026947f, -0.16070662f, -0.12782390f, -0.05725662f, -0.15250240f, 
    0.17175591f, 0.21144482f, 0.24326551f, 0.13156137f, 0.15244351f, 0.25130442f, -0.00585457f, 0.43037096f, 
    -0.03293856f, 0.05159017f, 0.04182993f, 0.06913366f, 0.03023926f, 0.08530894f, 0.08236057f, 0.08987685f, 
    -0.00538225f, 0.09270978f, -0.02523727f, 0.18669274f, -0.08506361f, 0.04788204f, 0.01430592f, 0.18641831f, 
    -0.04657762f, -0.19266205f, -0.08981871f, 0.17754278f, 0.21265998f, 0.26690874f, 0.07798813f, 0.19400436f, 
    0.23045863f, 0.36266840f, 0.29505810f, 0.11736928f, 0.25190613f, 0.21439375f, 0.12347627f, -0.01191915f, 
    0.07759957f, -0.01710479f, 0.04857881f, 0.13961458f, -0.37611359f, 0.12527901f, -0.01373918f, 0.00080078f, 
    0.01165739f, -0.12507743f, 0.04412422f, 0.01804295f, 0.07851679f, 0.17490503f, -0.35832492f, -0.11923939f, 
    -0.02800324f, -0.03557248f, 0.06257544f, -0.12446325f, 0.14015926f, 0.08031099f, 0.09946036f, -0.10616202f, 
    0.13738509f, 0.04612385f, -0.01465880f, 0.04498860f, -0.03379850f, 0.00230967f, -0.06244271f, 0.00800938f, 
    0.06786104f, 0.19578880f, -0.04017959f, -0.00379135f, -0.04498160f, -0.15072343f, 0.07523844f, 0.06388643f, 
    -0.18820976f, 0.30949557f, 0.25072765f, -0.08201960f, -0.04819724f, -0.27074468f, 0.13912666f, 0.07024580f, 
    0.12261642f, -0.07851915f, -0.06035403f, -0.03560987f, -0.05586560f, -0.07807747f, -0.15551570f, -0.01195558f, 
    -0.45271245f, -0.17459129f, 0.07775041f, -0.00658459f, -0.06343224f, -0.12789463f, -0.04766478f, -0.07658665f, 
    0.09948437f, -0.03626524f, 0.27115238f, -0.23995800f, 0.21358186f, -0.10008188f, -0.42591456f, 0.04259853f, 
    0.01971534f, -0.00276810f, -0.06234657f, -0.38849634f, -0.03610246f, -0.27352145f, -0.02948850f, 0.10345529f, 
    0.11693632f, 0.19874910f, -0.00685556f, 0.13754742f, 0.20007284f, 0.28622490f, 0.05167041f, -0.14658375f, 
    0.21368866f, -0.11963727f, 0.15225458f, -0.11608438f, -0.14757831f, -0.11713990f, -0.02423570f, 0.03234185f, 
    -0.06614230f, -0.08691833f, -0.53588140f, -0.56433290f, -0.01230118f, 0.00323848f, 0.08636505f, 0.42999065f, 
    0.11060970f, 0.12009021f, -0.12324984f, 0.20046902f, 0.25921556f, 0.16443884f, 0.09143724f, 0.20493819f, 
    -0.09059770f, 0.24271396f, -0.15052153f, -0.13003777f, 0.01199898f, -0.28092030f, 0.04638680f, 0.01120904f, 
    -0.32856634f, -0.50015247f, -0.36850041f, -0.07702858f, 0.04129155f, -0.04307799f, 0.09225565f, -0.13954285f, 
    0.02086940f, 0.10409378f, 0.24336664f, 0.03896671f, -0.02431998f, 0.02135246f, 0.10680851f, -0.01675908f, 
    -0.03623101f, 0.06345388f, -0.01423909f, 0.10130684f, 0.15020576f, 0.14373378f, 0.06342242f, -0.07131013f, 
    0.13307568f, -0.09432116f, -0.01100763f, 0.17814474f, 0.15507168f, 0.03261982f, 0.13949491f, 0.10721867f, 
    0.03863161f, -0.14661698f, -0.00965997f, 0.11148497f, -0.03952833f, -0.34700888f, -0.23925580f, -0.15994123f, 
    0.04307860f, 0.00763504f, -0.03447936f, 0.01334403f, -0.04513019f, 0.13356447f, 0.07304254f, 0.03671515f, 
    -0.22838964f, 0.12019965f, 0.10802639f, -0.06154367f, 0.01020352f, -0.05789721f, -0.12604117f, -0.09472290f, 
    -0.31150103f, 0.05022376f, 0.08699289f, -0.03489540f, 0.06980336f, 0.17194091f, 0.03387597f, -0.11996284f, 
    -0.09737115f, 0.03978400f, -0.06096762f, 0.15447439f, 0.07795700f, -0.00010149f, 0.04586557f, -0.02816737f, 
    -0.00452786f, -0.05390482f, -0.07217272f, 0.06277645f, -0.22710378f, -0.11266302f, -0.07556953f, 0.16360360f, 
    0.04156199f, 0.04483508f, 0.09611171f, -0.09336252f, -0.03244081f, 0.00207467f, -0.42971358f, 0.23770173f, 
    -0.23690300f, -0.03769192f, -0.02211996f, -0.21470995f, -0.08546896f, -0.36644676f, 0.00811838f, 0.00176213f, 
    0.20896494f, 0.04129246f, -0.06399221f, -0.19284315f, 0.04625518f, -0.21464074f, -0.01878927f, 0.13138179f, 
    -0.08822608f, 0.37146378f, -0.10570081f, -0.10956595f, -0.06205172f, 0.23755077f, 0.08281276f, -0.12521322f, 
    -0.13742574f, 0.13695203f, 0.14790405f, -0.06455357f, 0.08625866f, 0.08931049f, -0.35838085f, -0.30622083f, 
    0.34170046f, -0.20051943f, 0.13293914f, 0.14095454f, 0.10394064f, 0.05934644f, -0.02999806f, 0.36818394f, 
    0.01511545f, 0.22440432f, 0.04880319f, 0.25930199f, 0.16403534f, 0.09961816f, 0.27718961f, -0.16358821f, 
    -0.10494538f, 0.06879722f, 0.11830217f, 0.07966270f, -0.18830736f, -0.14568119f, -0.14015684f, 0.00069610f, 
    0.04566812f, -0.13388062f, 0.01394467f, 0.05840103f, 0.07852621f, 0.08897620f, -0.26094106f, 0.21670383f, 
    -0.23645350f, 0.11475764f, 0.11257923f, 0.15070508f, 0.27679530f, 0.07656614f, 0.25170907f, 0.21325153f, 
    0.00602354f, 0.22120167f, -0.01900149f, 0.18336706f, 0.10919282f, -0.00150218f, -0.05898888f, -0.08160761f, 
    -0.33425286f, 0.02386763f, 0.06099990f, -0.00712673f, -0.05854361f, -0.42805928f, 0.15046689f, 0.19223605f, 
    -0.06273668f, 0.05714535f, -0.13649058f, 0.16598836f, 0.14258267f, 0.02735678f, 0.19422001f, -0.12133922f, 
    0.14381297f, 0.03204382f, 0.19651812f, -0.02680549f, 0.03178751f, -0.19073938f, 0.31122634f, -0.10043809f, 
    0.12507409f, -0.01311397f, -0.04730107f, -0.06722576f, -0.17641045f, 0.45945948f, -0.11521763f, 0.11208339f, 
    0.15077063f, 0.17681523f, -0.06666790f, -0.11091783f, -0.32757849f, -0.16244730f, -0.11977118f, 0.03688175f, 
    -0.26613823f, -0.47687969f, -0.04433531f, -0.07003552f, 0.06413730f, 0.12179662f, -0.01575692f, 0.16419370f, 
    0.29369932f, 0.28360668f, 0.10106571f, 0.26943287f, 0.08222268f, 0.06896110f, 0.20330118f, 0.00739292f, 
    0.17200568f, 0.00065787f, 0.17440630f, 0.07058922f, 0.07241981f, 0.01400666f, -0.07232077f, 0.09861883f, 
    0.07468813f, -0.20913234f, -0.34620789f, 0.47027749f, -0.08072349f, 0.22207253f, 0.42570084f, -0.22479159f, 
    -0.10184444f, 0.04336839f, 0.08565006f, -0.13775459f, 0.01742615f, 0.28165817f, -0.06604649f, 0.11885689f, 
    -0.07035219f, -0.03234461f, -0.07451676f, -0.05597661f, -0.43624270f, 0.14752097f, 0.37697485f, 0.29530656f, 
    0.05780738f, 0.24198151f, -0.04362340f, 0.09572600f, -0.05254012f, 0.27668941f, 0.13344945f, 0.10320929f, 
    -0.11217762f, 0.07918525f, 0.03610297f, 0.03356370f, 0.21957088f, 0.01476673f, 0.07746022f, -0.46584803f, 
    0.01991984f, 0.20870864f, -0.00043763f, -0.22907805f, -0.19071315f, -0.12746637f, -0.08264755f, -0.23771691f, 
    -0.09546962f, -0.20731620f, 0.27517313f, 0.12645619f, 0.00335615f, -0.10495467f, 0.00644379f, -0.08825607f, 
    0.18196018f, 0.23949690f, 0.09196882f, 0.01611160f, 0.23269816f, -0.13350466f, -0.10273873f, -0.02532924f, 
    -0.02185638f, -0.29128116f, -0.07755677f, 0.03313314f, -0.04926156f, 0.05886948f, 0.07492990f, 0.14503637f, 
    0.22599478f, -0.00490417f, -0.18926090f, 0.01074221f, 0.04371109f, -0.07910696f, 0.06470204f, -0.05586806f, 
    -0.08127938f, 0.05294472f, 0.00894385f, -0.21989729f, 0.01083752f, 0.22162732f, -0.03366975f, 0.03013813f, 
    -0.00354110f, -0.06455172f, 0.24629824f, 0.08879646f, 0.10378204f, 0.33051658f, 0.46436206f, 0.49209225f, 
    0.16838427f, -0.09059375f, -0.15665542f, 0.10185651f, 0.00241876f, 0.04483844f, -0.02175193f, -0.11306971f, 
    0.19273096f, 0.05317724f, 0.02307930f, -0.06538712f, -0.03654312f, 0.15700017f, 0.04063503f, 0.41318497f, 
    0.47926277f, 0.54153031f, 0.01250018f, 0.12827127f, 0.20063235f, 0.06049994f, 0.16991705f, 0.13564266f, 
    0.04878243f, -0.16906568f, -0.12316686f, 0.04416542f, 0.04853570f, 0.05030413f, -0.03446923f, 0.11225769f, 
    0.18117185f, -0.17794856f, -0.21369363f, -0.01567413f, -0.01931807f, -0.00238305f, -0.04260787f, 0.05331312f, 
    -0.18916531f, 0.03094039f, 0.00984189f, 0.03817789f, -0.09248092f, 0.03510626f, -0.24222250f, 0.15998699f, 
    0.02699629f, -0.07393071f, 0.22748205f, 0.06858839f, 0.06120282f, 0.28975204f, 0.13179246f, -0.09161775f, 
    -0.28104383f, 0.12088955f, -0.31379014f, -0.32733515f, 0.05979527f, 0.08463265f, 0.08909314f, 0.17235416f, 
    -0.14976014f, -0.19196784f, 0.09503029f, -0.24862833f, -0.55268574f, -0.40670747f, -0.21367903f, 0.00998060f, 
    -0.00372794f, -0.04613550f, 0.34724283f, 0.04970720f, 0.22314228f, 0.28582171f, 0.12354076f, 0.04480735f, 
    0.38752434f, -0.24610019f, -0.17604098f, -0.22141975f, -0.10170134f, 0.20986179f, 0.38328165f, 0.11153691f, 
    0.09980176f, -0.47088602f, -0.19707869f, -0.06255785f, -0.05437745f, -0.08462572f, -0.09484667f, 0.06993616f, 
    0.14290282f, 0.14293830f, 0.02244477f, 0.03447507f, 0.05438517f, 0.10975917f, -0.00320756f, 0.09451884f, 
    -0.16058132f, -0.22189946f, -0.17574236f, -0.53176969f, 0.12403425f, 0.03209026f, 0.06139031f, 0.05972288f, 
    0.09200883f, 0.03333779f, -0.07098307f, 0.12108219f, -0.21611823f, -0.09092499f, -0.05751554f, -0.12578034f, 
    -0.05894067f, -0.28445694f, 0.02638673f, 0.04530209f, -0.03496340f, -0.22993055f, -0.01179122f, 0.10573130f, 
    0.14056922f, -0.03022711f, -0.01727959f, 0.07754757f, 0.18730870f, 0.52552187f, -0.06109339f, 0.23198855f, 
    0.14200385f, -0.17746127f, 0.08231783f, 0.16224501f, -0.12367377f, 0.01917384f, 0.46029627f, 0.40700954f, 
    -0.20999554f, -0.22116272f, -0.22868799f, 0.08077232f, -0.09912620f, -0.10881466f, 0.01845719f, 0.05801914f, 
    0.34344137f, 0.17361994f, -0.18905717f, 0.13997516f, 0.01562604f, 0.19381128f, 0.15204617f, 0.02142612f, 
    0.16905303f, -0.03895247f, 0.08303444f, 0.01033515f, 0.13232674f, -0.04027711f, 0.09337549f, 0.21679054f, 
    -0.01098089f, -0.02775129f, -0.01206105f, 0.00565111f, 0.01519457f, 0.03147188f, 0.04521605f, 0.01666227f, 
    0.04472663f, -0.04257986f, -0.02423938f, -0.06138022f, -0.02576437f, -0.05193046f, 0.02463853f, 0.01751698f, 
    0.03503320f, -0.05057541f, 0.02243662f, -0.05368549f, -0.00626285f, 0.03315083f, 0.01642621f, 0.01998184f, 
    0.00472105f, 0.02570920f, -0.00700625f, -0.04337509f, -0.03527441f, -0.04494594f, 0.02594696f, -0.04392448f, 
    -0.04118992f, 0.04076915f, 0.02818810f, -0.02057494f, -0.04223947f, -0.04496898f, -0.01034183f, -0.04872769f, 
    -0.04606874f, -0.03418028f, 0.00121834f, 0.00977099f, -0.03569218f, -0.06774829f, -0.05739206f, -0.05147611f, 
    -0.06574319f, -0.04584930f, 0.01676334f, -0.03496944f, -0.02623099f, 0.00870666f, -0.04424683f, 0.01763379f, 
    -0.02961390f, -0.02363948f, -0.03803365f, 0.02423311f, 0.01682689f, -0.03699118f, -0.02033841f, -0.03286032f, 
    -0.01510237f, 0.05115527f, -0.02304228f, 0.04852902f, 0.02084584f, 0.04305409f, -0.01220632f, -0.05061034f, 
    0.00233295f, -0.05839263f, -0.03021213f, -0.05793543f, -0.04283489f, -0.05667086f, 0.02481801f, 0.03102811f, 
    -0.03046862f, -0.06823003f, -0.03103527f, -0.03201976f, -0.03639587f, 0.00737020f, -0.01956682f, 0.05314993f, 
    0.04679270f, 0.03293787f, -0.05029394f, -0.04048709f, 0.01024780f, 0.03236968f, 0.01400736f, 0.05082570f, 
    0.04599413f, 0.03242747f, 0.00822795f, -0.05306303f, 0.00214961f, -0.01688173f, -0.02961403f, -0.04479583f, 
    -0.04667351f, -0.02034386f, 0.00031268f, -0.06471561f, -0.02454093f, -0.00890652f, 0.01103190f, 0.04145525f, 
    0.01363506f, -0.01042936f, -0.04806705f, 0.02107082f, 0.02940427f, -0.00712402f, -0.03697645f, 0.01439662f, 
    0.03734278f, 0.03401515f, -0.03906532f, -0.04858955f, -0.03208392f, -0.00059606f, -0.06110081f, 0.03966570f, 
    -0.04802756f, 0.03720095f, -0.02042228f, 0.02138998f, 0.02800135f, 0.01333655f, -0.05542470f, -0.01609947f, 
    -0.05658012f, -0.02952949f, -0.05558353f, -0.01260192f, -0.04839673f, -0.01111219f, 0.04210048f, 0.00997771f, 
    -0.03673954f, -0.05361402f, -0.04874470f, 0.00043997f, -0.04650852f, -0.04515873f, -0.05260577f, 0.00139969f, 
    0.03119886f, -0.06334643f, 0.01723930f, 0.04323000f, -0.05987911f, 0.01233308f, -0.01848042f, 0.01765379f, 
    0.03355113f, -0.05945225f, -0.03578609f, -0.06127476f, 0.01156636f, -0.03135621f, -0.04113670f, -0.01225757f, 
    0.03704595f, -0.06262906f, 0.01303770f, 0.02926804f, 0.03925176f, -0.03110300f, -0.03084991f, 0.01389548f, 
    -0.04964936f, 0.04679739f, 0.01579573f, 0.00996770f, -0.00109465f, -0.03232817f, -0.02676377f, -0.04033105f, 
    -0.03468996f, -0.04127060f, -0.02492721f, -0.01172164f, 0.03641578f, 0.01776915f, -0.01660467f, -0.02453670f, 
    -0.04932601f, -0.04203115f, -0.03382510f, -0.03799146f, -0.06675626f, 0.01057267f, -0.03153884f, 0.01134560f, 
    -0.06815040f, 0.01045031f, -0.05592994f, -0.00059638f, -0.05748130f, -0.04036888f, 0.03058791f, 0.01347255f, 
    -0.04876810f, 0.02479982f, -0.00184555f, 0.02553684f, 0.02944026f, -0.00389377f, -0.01491194f, 0.03959881f, 
    0.01632131f, -0.00560995f, -0.05714559f, 0.02111828f, -0.05534385f, -0.06534753f, 0.02809484f, 0.04152587f, 
    0.02929921f, 0.04231241f, -0.03799704f, -0.06125769f, 0.04481620f, -0.04771059f, -0.05872224f, 0.03090372f, 
    0.02863109f, 0.00316777f, -0.03819407f, -0.01506756f, -0.06141597f, -0.03890850f, -0.03268024f, 0.04416749f, 
    -0.01393519f, -0.00686964f, -0.00565580f, 0.01212578f, 0.01001924f, -0.02099957f, -0.00504092f, 0.04411938f, 
    -0.01103307f, -0.04597744f, 0.04085245f, 0.01089042f, -0.04303072f, -0.05988833f, -0.05815713f, -0.04546895f, 
    -0.05602457f, -0.04789146f, -0.05068530f, 0.04726779f, 0.02833204f, 0.01432029f, -0.03256110f, 0.00831221f, 
    -0.05043383f, -0.03527311f, 0.03888178f, -0.03597460f, 0.03354169f, 0.02094323f, 0.03483125f, -0.01719094f, 
    -0.05059367f, -0.00722021f, 0.02824988f, -0.04214763f, 0.01031914f, -0.03024718f, 0.02571059f, -0.04785736f, 
    -0.04368718f, 0.02095264f, -0.03910776f, 0.02743510f, -0.04520528f, -0.05089633f, 0.01489739f, -0.03428300f, 
    0.15405886f, 0.22224838f, 0.09399883f, 0.06684007f, 0.11403896f, -0.09082658f, 0.13697097f, -0.08413080f, 
    -0.00495670f, -0.04118956f, -0.00158283f, -0.01367413f, 0.05715477f, -0.01090065f, -0.02672543f, 0.38707638f, 
    -0.27252021f, -0.31379011f, -0.42477399f, -0.21395181f, -0.10353781f, -0.03509616f, 0.09127263f, -0.07952378f, 
    0.25067499f, 0.13937944f, -0.04464329f, -0.13574184f, -0.23738141f, 0.14890738f, 0.06608295f, 0.02527812f, 
    -0.02717505f, 0.16252512f, -0.03855081f, 0.01748784f, -0.63230097f, -0.21730849f, 0.15315354f, -0.07848403f, 
    0.11852825f, -0.11369525f, 0.02679382f, 0.06342543f, 0.03651886f, 0.02284332f, -0.02380224f, 0.12374859f, 
    -0.20221499f, -0.05992571f, 0.31829837f, -0.06427774f, -0.33520052f, 0.09368167f, -0.12984286f, -0.13700865f, 
    -0.06083338f, -0.23919645f, -0.39440745f, -0.73806947f, -0.07051682f, 0.10176241f, -0.02895843f, 0.74993926f, 
    0.05619725f, -0.23175666f, -0.09987159f, 0.06841469f, -0.48252431f, 0.12021887f, -0.02968525f, 0.26057824f, 
    0.19105983f, 0.12616745f, 0.21848090f, 0.00265420f, 0.16467002f, 0.18019018f, -0.01880560f, 0.09530652f, 
    -0.18049537f, 0.20435454f, -0.20382494f, 0.10499251f, 0.13437881f, -0.06125499f, 0.27658743f, -0.00662119f, 
    0.07612437f, -0.12751359f, 0.09532446f, 0.04658596f, 0.14992185f, -0.19382460f, -0.17970288f, -0.06706773f, 
    0.05677599f, 0.14017750f, 0.04892387f, -0.12891898f, -0.07285447f, -0.05157510f, -0.10590979f, -0.00718697f, 
    0.16537821f, 0.19772676f, 0.32045394f, 0.31322119f, -0.13617910f, -0.03920406f, 0.13557220f, -0.01444193f, 
    -0.31613183f, 0.06960294f, -0.11335550f, -0.08062134f, 0.14591466f, -0.70138401f, 0.32443058f, -0.15759788f, 
    -0.10098027f, -0.02374390f, -0.17323026f, 0.07226773f, 0.14364468f, -0.11647040f, 0.05786036f, 0.06923147f, 
    0.27423587f, 0.17042880f, 0.12021995f, -0.02232783f, 0.06702960f, 0.02439852f, -0.19489822f, -0.28545591f, 
    0.17201275f, -0.13453798f, -0.05881168f, -0.12906913f, -0.00929896f, 0.07228054f, 0.14586052f, 0.42150581f, 
    0.10002243f, -0.07582502f, 0.17392370f, 0.04621796f, 0.01885827f, 0.03144097f, 0.14792939f, -0.01307820f, 
    -0.20490846f, 0.28108391f, 0.48240805f, 0.03043533f, 0.18270974f, -0.19934599f, -0.26401785f, -0.02724721f, 
    0.07221434f, -0.00145321f, -0.03873723f, -0.30821693f, 0.05509748f, -0.11386912f, 0.00134904f, -0.15725374f, 
    -0.00799279f, 0.32725361f, 0.10141900f, -0.24656160f, -0.11634021f, 0.12532791f, 0.21223618f, 0.16397338f, 
    0.05284839f, 0.05892331f, 0.21810105f, 0.09318984f, -0.25262222f, -0.25294247f, 0.01966464f, -0.04344747f, 
    0.30886275f, 0.11204183f, -0.04866679f, 0.26864183f, 0.17020929f, 0.48009768f, -0.07494157f, 0.09813473f, 
    -0.00115804f, -0.20778060f, -0.19112487f, 0.02287718f, 0.07800291f, -0.02633346f, 0.50203556f, 0.56877095f, 
    -0.30435741f, -0.05952865f, 0.03453272f, -0.13407490f, 0.09870782f, -0.06023082f, 0.18759000f, -0.16562587f, 
    -0.18196099f, 0.20078044f, 0.10294209f, -0.03758663f, -0.01440771f, 0.19750701f, 0.17272577f, 0.15438239f, 
    -0.28022474f, -0.12163601f, -0.05637645f, -0.07429899f, -0.29191160f, 0.02607066f, 0.06650731f, 0.02419700f, 
    -0.06230124f, 0.07863314f, 0.12796414f, -0.06425872f, 0.14612721f, -0.05711479f, -0.00123779f, 0.11419912f, 
    -0.27829468f, -0.17884706f, -0.07438223f, 0.03837477f, 0.05558423f, 0.14643398f, 0.10469528f, 0.07177895f, 
    0.15277690f, 0.27039048f, 0.25988013f, -0.02104769f, -0.15354683f, 0.01337591f, -0.13284972f, 0.02112387f, 
    -0.16078775f, 0.03936993f, 0.16923003f, 0.15459453f, -0.84281182f, -0.15028858f, -0.11268540f, -0.08611663f, 
    -0.11986408f, 0.02341237f, -0.12063495f, 0.01375744f, 0.11997253f, 0.36042050f, 0.02930232f, -0.10632081f, 
    -0.03271890f, 0.10339333f, -0.21655969f, 0.06025212f, 0.05103628f, 0.04033841f, -0.11290003f, 0.02441967f, 
    0.06079429f, -0.03561297f, 0.05391493f, 0.01997718f, -0.12554175f, 0.01160057f, 0.04207581f, -0.10792470f, 
    -0.11889335f, -0.03247457f, -0.19926977f, -0.18993685f, -0.09561794f, -0.02192090f, -0.02331621f, 0.03285991f, 
    -0.03877628f, 0.00943064f, 0.02623242f, -0.01182094f, -0.02352952f, 0.04933993f, 0.04026186f, -0.01768692f, 
    -0.00595134f, 0.00905995f, 0.01942547f, -0.04767571f, 0.02265882f, 0.00068830f, 0.00358778f, -0.02791461f, 
    0.02513004f, -0.06114092f, -0.03667932f, -0.01011397f, -0.03121733f, -0.01061970f, 0.01780751f, -0.00263334f, 
    -0.04604069f, -0.02837005f, -0.04554128f, 0.00470674f, 0.02431362f, 0.01389657f, -0.01202322f, -0.05045449f, 
    0.00564431f, -0.05274992f, -0.00796050f, -0.03615193f, -0.03358002f, 0.04430736f, 0.00886075f, -0.04397159f, 
    -0.00629682f, 0.04896666f, -0.03542591f, -0.05734015f, 0.02657937f, 0.00385385f, 0.03511104f, 0.01296837f, 
    -0.02817000f, 0.01493674f, 0.00605822f, 0.05242455f, -0.03583265f, -0.01661607f, 0.04415455f, 0.02534039f, 
    0.02781101f, 0.02646746f, -0.01640465f, -0.03595772f, -0.04209710f, -0.03492931f, -0.05974210f, 0.04927303f, 
    0.05137698f, 0.02516986f, -0.02414061f, -0.03368084f, 0.03575468f, -0.01063639f, 0.05171078f, 0.00554462f, 
    -0.02262431f, -0.05712234f, -0.03651284f, 0.05268808f, -0.01423453f, 0.02250767f, -0.01862390f, -0.02737366f, 
    0.03087562f, -0.04321697f, 0.02182227f, 0.03142639f, 0.00266976f, -0.02543791f, -0.02719412f, 0.02054813f, 
    -0.00183026f, 0.05199966f, -0.00579035f, -0.02314406f, -0.01584321f, 0.01276407f, -0.02519359f, 0.00986167f, 
    0.04901312f, -0.01728867f, -0.02096513f, -0.01080658f, -0.05309220f, 0.02116615f, -0.02188089f, -0.02505852f, 
    -0.00837333f, 0.01479369f, 0.00725771f, 0.03893103f, -0.02154974f, -0.06657989f, -0.04203320f, 0.00123613f, 
    0.01797708f, -0.04182059f, -0.02841796f, -0.02065911f, -0.00108810f, -0.05034664f, -0.00325702f, -0.04661999f, 
    -0.00183082f, -0.05940837f, 0.03222184f, 0.00806948f, -0.03099620f, 0.03684943f, 0.04032840f, 0.03020176f, 
    -0.06225194f, -0.05882962f, 0.05435579f, 0.04346849f, -0.01842383f, 0.03003992f, -0.02547863f, 0.04597935f, 
    -0.04654361f, 0.02100992f, -0.02957372f, 0.03611186f, -0.01015821f, 0.05257971f, -0.00767083f, 0.02130531f, 
    -0.02386064f, -0.02506109f, 0.04668852f, 0.02158179f, 0.04791737f, -0.04486222f, 0.00954288f, -0.03654285f, 
    -0.03723713f, -0.01058242f, 0.05238911f, -0.01843580f, -0.05688940f, 0.01369352f, -0.06074795f, -0.06115698f, 
    -0.02837301f, 0.00659007f, 0.02647697f, -0.04738901f, -0.00647159f, -0.02289432f, -0.02900720f, 0.02672442f, 
    -0.05147447f, 0.01580694f, 0.00322058f, -0.02542895f, 0.02928356f, -0.03575740f, 0.04989177f, -0.06297844f, 
    -0.02850989f, -0.02585660f, -0.01156085f, 0.04911617f, -0.01836432f, 0.02316738f, -0.02690761f, -0.03183286f, 
    -0.02008841f, 0.00387300f, 0.01623442f, -0.00577573f, -0.05439210f, 0.05259639f, -0.00839818f, -0.00005090f, 
    0.03367949f, 0.05297533f, -0.04711857f, -0.02210435f, 0.04474992f, -0.04182553f, -0.04520787f, 0.02543969f, 
    -0.03611549f, -0.04214683f, -0.01897665f, -0.05008766f, -0.04031285f, -0.03622270f, 0.03985894f, -0.00071340f, 
    0.00544769f, 0.04602900f, -0.04961943f, -0.04775273f, -0.04571647f, -0.01313167f, 0.04736321f, -0.02999851f, 
    -0.01668205f, 0.03711978f, -0.05899128f, 0.00368444f, 0.02892173f, -0.02028165f, -0.06003918f, -0.02499674f, 
    0.02716010f, 0.00508856f, 0.03323940f, 0.04390856f, 0.01298231f, 0.00819934f, 0.02704157f, 0.00211868f, 
    0.04259694f, 0.02680807f, 0.01141591f, -0.05878597f, -0.01198837f, -0.04269694f, -0.04270695f, -0.04814966f, 
    0.01776814f, -0.01016455f, -0.00226839f, -0.01935089f, -0.04444002f, -0.01863143f, 0.02209948f, 0.02223173f, 
    -0.00660310f, -0.00626701f, 0.03679042f, -0.02612350f, -0.00759476f, -0.04552035f, -0.02032261f, 0.03360000f, 
    -0.03982566f, 0.04675801f, 0.04297080f, 0.04806180f, -0.01691502f, -0.05845546f, -0.02871337f, -0.03389952f, 
    -0.06227229f, 0.03041903f, -0.05569039f, -0.04729759f, -0.05138972f, -0.03594427f, 0.02554314f, -0.05941028f, 
    -0.04755419f, -0.05723184f, -0.03948126f, 0.02066383f, 0.02729895f, 0.00619507f, -0.06476484f, 0.03633180f, 
    -0.00614110f, 0.01345777f, 0.04455270f, 0.03446028f, 0.05178340f, -0.06528050f, 0.00062549f, -0.05785035f, 
    0.20661618f, 0.32903886f, -0.08815590f, -0.33940092f, -0.17432894f, -0.05433113f, -0.04182807f, 0.02883008f, 
    -0.10661188f, -0.01774563f, -0.04636343f, -0.04571880f, -0.15154585f, -0.06784359f, -0.08918907f, -0.17417815f, 
    0.08684350f, 0.01732045f, 0.22742707f, 0.04880947f, -0.04474172f, -0.11793195f, 0.07076664f, -0.04992516f, 
    0.02508465f, 0.15884626f, 0.02175424f, -0.02324310f, 0.54390603f, -0.08473703f, -0.24486220f, -0.34162855f, 
    -0.42934403f, -0.11756019f, -0.25377932f, 0.08768574f, 0.16238695f, 0.02883011f, 0.09501377f, -0.08609124f, 
    0.18951108f, -0.02571233f, 0.22200234f, 0.05468586f, -0.11105921f, -0.52500391f, -0.28317085f, -0.71236837f, 
    -0.20555027f, 0.13630663f, 0.00327326f, -0.27808172f, -0.12894361f, 0.26025939f, 0.35198343f, 0.16267633f, 
    0.13468605f, -0.09612175f, -0.12214425f, -0.11130837f, -0.19432946f, -0.08183433f, -0.14795691f, 0.70349240f, 
    -0.20489432f, -0.49097753f, 0.06729560f, -0.22918601f, 0.08926281f, 0.16103882f, 0.08311826f, 0.21989959f, 
    -0.07669277f, -0.03529370f, -0.06682823f, -0.15398563f, -0.52181965f, -0.05294093f, 0.00912696f, -0.05368135f, 
    0.03479657f, -0.29208860f, 0.22553647f, 0.22240460f, -0.06040144f, 0.22237931f, -0.16794765f, -0.27073437f, 
    -0.22346419f, 0.05679529f, 0.00086440f, -0.04619836f, -0.20382215f, -0.01606433f, -0.12989245f, -0.18624963f, 
    0.13222219f, -0.07534686f, 0.01905698f, 0.19382446f, 0.04677656f, -0.06680821f, 0.20374282f, 0.14744282f, 
    0.00744408f, 0.05303323f, -0.01750374f, 0.02465919f, 0.12352804f, -0.10959794f, 0.08421297f, 0.33160993f, 
    -0.09518648f, -0.19216038f, 0.04226852f, 0.18445486f, -0.03401414f, 0.05967963f, -0.37001586f, -0.08101698f, 
    -0.00471401f, -0.00837733f, -0.03434655f, 0.12385229f, -0.06686459f, -0.10086641f, -0.00420757f, -0.38470542f, 
    -0.37527445f, 0.18777674f, -0.29258037f, -0.04713262f, 0.08014179f, 0.05310867f, -0.05595969f, 0.20988923f, 
    0.11397509f, 0.14697833f, 0.01544149f, 0.09800483f, -0.05192725f, -0.11190001f, -0.02131860f, 0.05700568f, 
    0.13134919f, -0.14130476f, -0.08658767f, 0.11919830f, 0.14097805f, 0.08198375f, 0.15747775f, 0.11985484f, 
    0.09550232f, 0.31085464f, -0.03506159f, -0.04963556f, -0.39150608f, -0.20669317f, 0.23521098f, 0.03871516f, 
    -0.12074284f, -0.27629495f, 0.40310287f, 0.09494682f, -0.10964500f, -0.00917229f, -0.08505102f, 0.06026066f, 
    -0.08996438f, -0.03227768f, 0.10881831f, 0.03161147f, 0.02164537f, -0.09404738f, 0.00202345f, -0.01854058f, 
    -0.01647304f, 0.03177178f, -0.09617139f, -0.01800109f, 0.06042743f, 0.06739730f, -0.10063349f, -0.00288632f, 
    0.07475705f, 0.06114119f, 0.09611481f, 0.01823983f, 0.00425652f, 0.49807477f, -0.19560552f, -0.09188676f, 
    0.17790578f, 0.06279670f, 0.16749527f, 0.08061522f, -0.17679431f, -0.04443138f, 0.09139147f, -0.19773965f, 
    -0.37311280f, -0.21245587f, -0.27376205f, -0.26889330f, -0.16859205f, -0.04582456f, -0.07273139f, -0.13940941f, 
    0.04391574f, 0.30866680f, 0.14717664f, 0.10100719f, 0.06594314f, 0.27844241f, 0.08823236f, -0.03773523f, 
    0.17802395f, 0.06588319f, -0.10666954f, 0.02319818f, -0.03911404f, -0.13618276f, 0.05246162f, 0.00954359f, 
    -0.08293821f, 0.04679438f, 0.04634206f, 0.28390461f, -0.04047116f, -0.02509247f, 0.05688810f, 0.00539642f, 
    -0.04619094f, 0.06280147f, 0.12420993f, -0.03346548f, 0.19776230f, 0.24167164f, 0.14779834f, 0.20438053f, 
    0.14613226f, 0.17130239f, -0.03078171f, 0.18455103f, -0.03253892f, 0.02937968f, 0.01553173f, -0.06550821f, 
    -0.03719791f, 0.07934693f, -0.06309942f, -0.01470531f, 0.36209220f, 0.26392153f, 0.07977334f, 0.05175671f, 
    0.08796545f, 0.04034366f, 0.20026204f, 0.08495799f, -0.02956273f, -0.50195956f, -0.28100720f, -0.71614116f, 
    0.18567227f, -0.22256024f, 0.02893147f, 0.06755523f, -0.19960155f, 0.07180580f, 0.14233129f, 0.15880582f, 
    0.17893159f, 0.06593874f, 0.01679212f, -0.04924868f, -0.09113758f, -0.13088511f, -0.00189169f, 0.22795828f, 
    -0.05077477f, -0.10230935f, 0.13738784f, -0.16335087f, -0.17577007f, 0.10782431f, -0.17917144f, -0.12801206f, 
    -0.74117219f, -0.77589214f, -0.84893715f, -0.18898299f, -0.17574720f, 0.28507030f, 0.01028902f, -0.12200205f, 
    -0.02745793f, -0.06366170f, 0.10820720f, -0.17385863f, 0.00854230f, -0.09958099f, -0.10267872f, 0.10719834f, 
    0.00943937f, 0.25586933f, 0.16537698f, -0.20238145f, -0.00299695f, 0.02232711f, -0.00013705f, -0.31805882f, 
    0.09334087f, 0.01818349f, -0.07665898f, -0.00725670f, -0.89692134f, -0.50998104f, -0.00410867f, 0.28066364f, 
    -0.06848115f, -0.06410889f, -0.13835879f, -0.10070336f, 0.13124806f, -0.30451110f, -0.21379116f, 0.11682230f, 
    0.03050544f, 0.10586730f, 0.10474134f, -0.10820603f, 0.10002374f, -0.42938551f, -0.98110026f, -0.83294016f, 
    0.05476415f, 0.26928613f, -0.06444536f, 0.01275783f, -0.10184763f, -0.04911165f, 0.04559980f, 0.20459992f, 
    -0.03947450f, -0.10440851f, -0.09634949f, -0.03348447f, 0.01201737f, -0.07401795f, -0.08775210f, -0.11292505f, 
    -0.29959622f, -0.18931898f, 0.19048488f, 0.16421157f, 0.15708385f, 0.15474321f, 0.06779644f, 0.05953841f, 
    0.35824353f, -1.18980169f, -0.68505079f, -0.32325271f, -0.02739237f, -0.12715103f, -0.02721598f, -0.12814043f, 
    -0.01454841f, -0.41595045f, -0.14584415f, -0.07393665f, -0.06230495f, 0.17776409f, -0.14074387f, 0.04219924f, 
    -0.06826185f, 0.10306305f, -0.02024694f, -0.07928126f, -0.23443674f, 0.01860674f, 0.05729452f, 0.02982530f, 
    0.14935263f, -0.00672165f, 0.16912164f, 0.17125893f, 0.13074525f, -0.00003113f, -0.03594227f, 0.05238164f, 
    0.02769074f, 0.23578398f, 0.04690046f, -0.07706809f, 0.28355074f, 0.28402829f, -0.13337260f, 0.01046303f, 
    -0.12459416f, -0.08190107f, 0.01539723f, 0.13424788f, 0.07289129f, -0.54392463f, 0.20484143f, 0.05238008f, 
    0.15609436f, 0.10358860f, -0.30696249f, 0.06437248f, -0.01043914f, 0.06866391f, 0.11056872f, 0.02021680f, 
    0.01506479f, 0.07882774f, -0.01984796f, -0.01938552f, 0.12593687f, 0.03938536f, 0.17035048f, 0.40422791f, 
    0.26601419f, -0.31571046f, -0.17079806f, -0.08693892f, -0.27682579f, 0.09654561f, 0.13626319f, 0.24983017f, 
    -0.13193662f, 0.16572022f, 0.27272564f, -0.02516248f, 0.05307960f, 0.06733568f, 0.01199303f, 0.13557574f, 
    0.22137219f, -0.35192853f, -0.71666455f, -0.69083464f, -0.17634435f, -0.12562850f, 0.06661402f, 0.02573754f, 
    -0.01289939f, -0.09499765f, -0.15445833f, -0.04278202f, 0.03901982f, -0.00817416f, 0.14575534f, 0.01856358f, 
    0.07885291f, 0.20356582f, -0.01796792f, -0.35053846f, 0.02566677f, -0.02712602f, 0.20585197f, 0.04009461f, 
    -0.05099459f, 0.16781342f, 0.05224273f, -0.07317720f, -0.08551116f, -0.05913374f, 0.01484330f, 0.08468528f, 
    0.01103791f, -0.02945808f, 0.09985897f, 0.08635690f, 0.05950658f, -0.15660989f, 0.12789863f, -0.32502744f, 
    -0.04549427f, 0.15591547f, 0.04987327f, 0.02751757f, -0.03794682f, 0.11931320f, -1.48338962f, -0.13909288f, 
    0.08259377f, -0.12048274f, 0.04135457f, -0.03862992f, -0.20219120f, -0.01105297f, -0.13540262f, 0.29557055f, 
    0.18872088f, 0.04402838f, 0.10463966f, 0.11267181f, 0.08442463f, 0.19549933f, 0.02143845f, 0.13032788f, 
    0.15106115f, 0.18250437f, 0.00361096f, -0.18778881f, -0.16565207f, -0.07840408f, 0.04255258f, -0.10815933f, 
    -0.06323119f, 0.21567845f, 0.09618305f, 0.15878616f, 0.04829254f, -0.07310478f, -0.01725143f, -0.12561664f, 
    -0.17457402f, 0.35509241f, 0.18433283f, 0.04764561f, 0.00202880f, 0.00893062f, 0.09519403f, 0.27373755f, 
    0.09198204f, 0.15781142f, 0.17491744f, 0.17738207f, 0.24589615f, 0.03410051f, -0.03465383f, -0.04801627f, 
    0.04554176f, 0.07312515f, -0.10449418f, 0.07192340f, 0.23364383f, -0.03431759f, -0.18399005f, -0.03614378f, 
    0.08733100f, 0.20955718f, -0.00721367f, -0.04219397f, 0.08583634f, -0.50529665f, -0.07108764f, -0.12171447f, 
    0.10567531f, 0.22676954f, 0.00705666f, 0.03461017f, 0.12763894f, 0.11226007f, -0.01489489f, 0.28912720f, 
    -0.00700805f, 0.07181301f, 0.08632063f, -0.23276415f, -0.02403297f, 0.09937866f, 0.11864455f, 0.15979564f, 
    0.28373486f, 0.02905359f, -0.12957869f, -0.12002207f, -0.08314747f, 0.11949328f, 0.09888830f, -0.08751723f, 
    -0.04650408f, 0.01706591f, -0.01393067f, 0.00749061f, 0.01972248f, -0.01628322f, 0.02691932f, -0.04393638f, 
    0.01884795f, -0.00175580f, 0.00751513f, -0.01069138f, 0.04699593f, 0.00742957f, 0.05078817f, 0.03930303f, 
    0.03324016f, -0.01057423f, 0.03737868f, 0.02200380f, 0.01783519f, -0.04011785f, 0.00167424f, -0.06070717f, 
    0.03125293f, 0.00528851f, -0.02703094f, -0.05596573f, -0.00503893f, -0.01926970f, -0.03370649f, -0.00387452f, 
    0.02106807f, -0.06502505f, -0.03083172f, -0.05253444f, -0.04455381f, 0.03432652f, 0.03398101f, -0.04769431f, 
    0.00009497f, -0.02933815f, 0.01887699f, 0.03468693f, -0.04809536f, 0.02624470f, 0.04766006f, -0.00241278f, 
    0.00615811f, -0.00112852f, -0.05447315f, -0.05525738f, 0.02406606f, -0.01430767f, -0.01072833f, -0.05581660f, 
    0.03830221f, 0.01937469f, -0.03348564f, 0.05480458f, 0.03951013f, -0.03165762f, 0.01454688f, -0.03527332f, 
    -0.01323340f, 0.00736371f, 0.04430061f, -0.03787243f, -0.05731525f, -0.04401023f, 0.01675797f, -0.00752341f, 
    0.03401650f, -0.00134305f, 0.01857696f, 0.04457918f, -0.04298993f, -0.04416256f, -0.03423965f, 0.00203665f, 
    0.00525800f, -0.04910738f, 0.02648602f, -0.06090334f, -0.02290232f, -0.02861221f, -0.00141658f, -0.01536261f, 
    -0.04277442f, 0.00205439f, 0.00984156f, 0.00587994f, -0.01146651f, 0.01606042f, 0.05081508f, -0.06183889f, 
    0.02389765f, 0.02795216f, -0.06064078f, -0.05658917f, -0.04212901f, -0.03771437f, -0.03408398f, -0.02473539f, 
    -0.03703088f, -0.03163071f, -0.01367591f, -0.00803519f, -0.01076843f, 0.04287315f, -0.00124593f, -0.00852319f, 
    0.04423486f, -0.00964535f, -0.03401711f, 0.00441578f, 0.00033303f, 0.01195446f, -0.00183445f, 0.00767211f, 
    0.00661353f, -0.05155901f, 0.03260905f, 0.04916120f, -0.04032313f, -0.04984429f, -0.04687996f, 0.04972810f, 
    0.02661831f, -0.04800471f, -0.02012228f, 0.00816793f, -0.04930892f, 0.01777743f, 0.02810155f, 0.01825065f, 
    -0.00593287f, -0.01357642f, 0.02538845f, 0.00428473f, -0.02510434f, -0.03466774f, -0.02524052f, -0.06127992f, 
    -0.06245943f, 0.01307550f, 0.04756767f, 0.03844630f, -0.00349640f, -0.04075322f, 0.00339838f, -0.05659921f, 
    -0.02763524f, -0.04244355f, -0.03690065f, 0.00527087f, -0.04482909f, 0.00257858f, 0.03164482f, -0.01556766f, 
    -0.06720064f, -0.02999114f, 0.05218089f, -0.01474307f, 0.04670296f, 0.04588286f, 0.03193287f, -0.02335205f, 
    -0.03616431f, -0.05307880f, -0.00831285f, 0.04074918f, -0.01680528f, -0.00878774f, 0.00143426f, -0.06022374f, 
    -0.04404217f, -0.04096112f, 0.01591308f, -0.04404900f, -0.00847377f, -0.00267592f, 0.05293437f, 0.05134089f, 
    -0.00327591f, -0.02729275f, -0.03917515f, -0.03583713f, -0.01412536f, 0.04299130f, -0.06457232f, -0.04055351f, 
    0.01467447f, 0.04462855f, 0.03914319f, -0.02484412f, -0.04782329f, -0.03269750f, -0.02312209f, 0.00465720f, 
    -0.01533825f, -0.00686441f, -0.01471969f, 0.03935603f, 0.02965478f, -0.04451922f, -0.01386273f, -0.04246050f, 
    -0.00061767f, -0.02065788f, -0.01137096f, -0.04406662f, 0.02221126f, 0.02834515f, -0.06356066f, -0.01710884f, 
    0.05326664f, -0.00259412f, 0.01014959f, -0.03726586f, 0.04412002f, 0.05028260f, -0.01119944f, -0.04805527f, 
    -0.01093403f, -0.06063731f, 0.04167857f, 0.03303139f, -0.03528301f, -0.02049422f, -0.05284926f, -0.01734090f, 
    -0.04617625f, -0.00761329f, -0.06267102f, -0.04010976f, 0.00747659f, -0.01518863f, -0.05884963f, -0.01961872f, 
    -0.03413505f, 0.04475348f, -0.06035887f, 0.02829547f, -0.00364039f, 0.02156494f, 0.03321611f, 0.01480111f, 
    0.03567990f, -0.02938131f, 0.02970018f, -0.04860628f, 0.03156925f, -0.00124305f, -0.03886439f, -0.04264834f, 
    0.01041505f, -0.04716308f, -0.01251452f, -0.01701786f, 0.03178130f, -0.01780514f, 0.00894923f, -0.04693774f, 
    -0.06038155f, 0.00337123f, 0.01488548f, -0.01242959f, -0.06240501f, -0.01453030f, -0.02246834f, -0.05593969f, 
    0.02180329f, -0.01296378f, -0.04906129f, -0.01543522f, -0.06040118f, 0.00627137f, -0.03640268f, -0.02990196f, 
    -0.00643467f, -0.01980954f, 0.03061799f, 0.01954277f, -0.02327301f, 0.00960281f, 0.00414271f, 0.03513817f, 
    0.05579298f, -0.04023277f, -0.13174464f, 0.25529423f, 0.00179695f, 0.20488000f, 0.18320163f, -0.08191933f, 
    -0.09552959f, 0.14690354f, -0.33331832f, -0.29500246f, 0.03274534f, -0.06751288f, 0.11039221f, 0.35612762f, 
    -0.09353598f, 0.03206515f, -0.04870084f, -0.42780438f, -0.32017457f, -0.27871215f, 0.29812402f, 0.05988864f, 
    -0.05810108f, -0.19919661f, -0.03906548f, 0.36476910f, 0.18315330f, 0.57552290f, -0.31058878f, -0.12669562f, 
    -0.06813789f, -0.01200865f, 0.09049536f, 0.13526690f, -0.10728436f, -0.45932457f, -0.18160519f, 0.04004136f, 
    -0.03563718f, -0.02498766f, -0.06234517f, 0.03766019f, 0.10853258f, -0.22725810f, 0.18406495f, -0.11648151f, 
    0.02533707f, -0.31065547f, 0.10872199f, 0.10557068f, 0.25490764f, -0.09627037f, 0.22514150f, -0.14016508f, 
    -1.05621850f, -0.34404379f, -0.15950494f, -0.18874767f, 0.07117920f, 0.06652822f, 0.35407299f, 0.48530951f, 
    -0.04827768f, -0.19272043f, -0.36262113f, 0.23135969f, 0.05233408f, -0.03592877f, -0.01933881f, 0.06206687f, 
    0.09818704f, 0.28527075f, 0.32284373f, -0.02537623f, -0.14492625f, -0.01021518f, 0.16398579f, 0.00373776f, 
    0.19411333f, -0.19711581f, 0.14062038f, 0.55206823f, -0.23117138f, -0.09324748f, -0.10752985f, -0.00580366f, 
    0.05916850f, -0.01079139f, -0.37319627f, 0.03626834f, -0.37627739f, 0.19462425f, -0.08496172f, 0.07036494f, 
    0.39544317f, 0.02752431f, 0.14190027f, -0.06113589f, -0.26658994f, -0.11740430f, 0.05586548f, -0.01289739f, 
    0.03934964f, 0.16417450f, -0.01483213f, 0.16064781f, 0.06999955f, -0.35046607f, -0.27734864f, 0.19907041f, 
    -0.19699489f, 0.03836925f, 0.00609896f, 0.11705571f, 0.13975731f, 0.24683751f, 0.20010376f, 0.22745629f, 
    -0.18218574f, 0.16251487f, -0.07217389f, -0.07304100f, -0.11284437f, 0.12298901f, 0.22928300f, 0.28082940f, 
    0.39033353f, 0.15289114f, -0.12112046f, 0.15278859f, 0.02349745f, -0.00068316f, 0.04854038f, 0.14448129f, 
    -0.17850661f, -0.15137866f, 0.07604813f, 0.11995530f, 0.11866992f, 0.04526098f, 0.09553602f, -0.07730988f, 
    0.23760936f, 0.20071384f, 0.00494932f, 0.01807507f, -0.02548091f, 0.12360364f, 0.05500195f, 0.05662216f, 
    -0.04515399f, -0.31625986f, -0.30341431f, -0.34020159f, -0.11187267f, -0.04440963f, 0.19269349f, 0.19634588f, 
    0.18504174f, 0.13324873f, 0.02573175f, -0.68009531f, -0.65769851f, -0.20868522f, -0.10493263f, -0.10180874f, 
    0.14917061f, -0.06901896f, 0.25573838f, 0.25479060f, 0.05129343f, 0.25812590f, -0.08857831f, -0.08949714f, 
    0.09447326f, -0.17981648f, 0.01584350f, 0.12684667f, 0.02343111f, 0.03847000f, 0.02299212f, -0.15159899f, 
    -0.28096145f, 0.08709671f, 0.41186312f, -0.02262895f, 0.04641409f, 0.38747296f, -0.62796026f, -0.37537640f, 
    -0.12296443f, -0.09635247f, 0.00988424f, 0.00817152f, 0.09645095f, -0.17461675f, -0.24227470f, -0.61506772f, 
    -0.21466371f, 0.16414617f, 0.21790858f, 0.12348831f, 0.01655286f, 0.21992651f, -0.04643858f, -0.18627626f, 
    -0.43812296f, -0.00611910f, -0.13539976f, -0.13928860f, 0.14731660f, -0.03408042f, 0.24953504f, 0.09938654f, 
    0.20056269f, -0.26344290f, 0.18284741f, 0.08976059f, 0.22901344f, -0.00134489f, 0.09910486f, 0.08040245f, 
    0.26180449f, -0.56478256f, -0.22554201f, -0.01362844f, 0.00052427f, -0.12264845f, -0.09002383f, 0.24878825f, 
    -0.02978113f, 0.08296704f, -0.21717364f, -0.13015662f, 0.11230813f, 0.02934868f, -0.09692241f, -0.16098852f, 
    0.14045389f, 0.07752056f, -0.06080001f, -0.34249592f, -0.38660967f, -0.60808969f, 0.14948899f, 0.09300503f, 
    0.19359225f, 0.10609336f, -0.00923631f, 0.22412603f, 0.66011465f, -0.85634303f, -1.50155926f, -0.00187446f, 
    -0.13225323f, -0.00028461f, -0.06870084f, 0.09838566f, 0.11098031f, 0.68343854f, 0.03591402f, 0.19080348f, 
    -0.28963190f, 0.07823535f, -0.05625420f, 0.03224563f, -0.08815559f, 0.06697765f, 0.29676470f, -0.67846841f, 
    -0.21908523f, 0.40140098f, -0.10863810f, -0.02232488f, 0.06393637f, 0.10668651f, -0.14031118f, 0.07350327f, 
    -0.26070324f, -0.15386957f, 0.23645468f, 0.03452030f, -0.04167508f, 0.24945605f, -0.09721147f, 0.22213280f, 
    0.00300451f, -0.02997367f, 0.03933113f, 0.02988305f, -0.01636823f, -0.02735830f, -0.04193247f, -0.00462021f, 
    -0.02043734f, -0.05762056f, 0.03548839f, 0.01037882f, -0.00803875f, -0.01424578f, 0.00714898f, -0.05409925f, 
    0.00760052f, 0.01169386f, 0.01012746f, -0.03684742f, -0.00714886f, 0.02608492f, -0.05101001f, -0.02947235f, 
    -0.05312031f, 0.02816644f, 0.02099536f, 0.03454168f, 0.00307732f, -0.02902187f, -0.00365922f, -0.02906128f, 
    0.03160665f, -0.03971174f, 0.05028170f, 0.05888651f, -0.01010152f, 0.00905262f, 0.03860837f, 0.00904044f, 
    0.03878171f, -0.01530778f, -0.00360415f, -0.02030245f, 0.00421265f, 0.01104977f, 0.02524950f, 0.02848074f, 
    -0.02322578f, -0.02684869f, 0.02551640f, -0.05153428f, 0.02342902f, -0.02885368f, -0.00266354f, -0.02235191f, 
    -0.05260155f, -0.04290441f, 0.04068381f, -0.05880726f, 0.00646143f, -0.05790513f, -0.05132225f, -0.04807042f, 
    0.02575584f, 0.01898988f, 0.01602621f, 0.01668487f, 0.00946700f, -0.02931604f, 0.01415587f, -0.02499035f, 
    0.03209213f, -0.00861022f, 0.02400484f, 0.01170876f, 0.04456907f, -0.06405434f, -0.04401466f, -0.02436679f, 
    0.00768057f, -0.04163178f, 0.01895436f, -0.03413313f, 0.04856332f, 0.02377826f, -0.01469520f, -0.05818487f, 
    -0.04525579f, -0.03288915f, -0.04073453f, 0.01645518f, -0.02300413f, 0.01452161f, -0.04943237f, 0.04273719f, 
    -0.04698014f, 0.01038004f, -0.05025062f, -0.00589030f, -0.03992766f, -0.05803487f, 0.00079419f, -0.02359476f, 
    -0.05185575f, -0.03391184f, -0.05229999f, 0.03441976f, -0.02425553f, -0.04168247f, -0.01566923f, -0.05299811f, 
    0.03115331f, 0.02047881f, 0.01661260f, -0.03084937f, 0.02430156f, 0.00137000f, 0.03133973f, -0.05062919f, 
    0.02726100f, -0.02968767f, 0.01450321f, -0.00876980f, -0.03890114f, 0.04193444f, -0.06113134f, -0.04195130f, 
    0.00271626f, -0.05915597f, 0.03234147f, 0.02574131f, 0.02458079f, -0.05078443f, -0.05505354f, -0.04881384f, 
    -0.02167182f, -0.04060823f, 0.04979723f, 0.02370933f, 0.02332770f, -0.03532014f, 0.01053498f, -0.06381700f, 
    0.00161223f, -0.03738534f, -0.01519322f, -0.02689889f, -0.03047391f, 0.04315333f, 0.00297713f, -0.04099148f, 
    0.03524606f, 0.00217578f, -0.04577663f, 0.03060011f, -0.05213503f, -0.02165863f, 0.01488843f, 0.01682844f, 
    0.00528528f, 0.02474595f, -0.00448106f, -0.05032209f, 0.01234630f, 0.01401576f, -0.03945396f, -0.05116668f, 
    -0.02338967f, 0.00358667f, -0.01140033f, 0.00672047f, 0.01585066f, 0.05244575f, -0.01957213f, -0.04145369f, 
    -0.05053248f, -0.05821945f, 0.00311636f, -0.02437563f, 0.00269226f, 0.01721800f, 0.04822052f, -0.00496601f, 
    -0.04173433f, 0.03892881f, -0.04574915f, -0.00747371f, -0.05937203f, 0.03268700f, 0.04121789f, 0.03825585f, 
    0.02970216f, 0.03597815f, 0.04818526f, -0.05392107f, -0.04686368f, 0.02603920f, -0.05825597f, -0.03799921f, 
    0.00122155f, 0.03632320f, 0.02718923f, -0.00875176f, -0.06298871f, 0.03755857f, 0.01174542f, -0.06331120f, 
    -0.02485407f, -0.01067091f, 0.04654305f, -0.02861402f, 0.03227220f, -0.03566725f, -0.05871995f, 0.03118256f, 
    0.02888621f, -0.02956721f, -0.00276954f, -0.05841098f, 0.00686386f, -0.02552018f, -0.04902013f, 0.02448430f, 
    0.00740082f, 0.00893584f, 0.03353238f, -0.02670785f, 0.01277268f, 0.02196132f, -0.06133202f, -0.01996715f, 
    0.01717151f, -0.04944217f, 0.00674199f, 0.00122241f, -0.00776658f, -0.01576182f, 0.03091890f, -0.04857149f, 
    0.00784504f, 0.03852298f, 0.02619627f, -0.05774058f, -0.02597325f, 0.01097074f, -0.05674810f, -0.02479875f, 
    -0.00509170f, -0.06100816f, -0.05548722f, -0.05405717f, -0.01638859f, 0.05138979f, 0.02497123f, -0.01978608f, 
    0.00792973f, -0.02810846f, 0.01960806f, -0.02216455f, -0.04431328f, 0.00639869f, 0.05120154f, -0.02733251f, 
    -0.01469058f, 0.04639566f, 0.03620693f, -0.05628313f, -0.01035736f, -0.03153753f, -0.01796138f, -0.05183508f, 
    -0.01529315f, 0.01867597f, 0.00796504f, 0.01682038f, 0.03690377f, -0.02901642f, 0.01355556f, 0.03037171f, 
    -0.04271700f, -0.03221462f, -0.02528005f, -0.04203296f, -0.03130150f, -0.03726513f, -0.04637804f, -0.02849750f, 
    0.20386671f, -0.18258509f, -0.27973357f, -0.01094426f, 0.04852622f, -0.08358234f, -0.00112837f, -0.11778159f, 
    0.07714071f, 0.03916335f, -0.11656661f, -0.04763369f, 0.14734001f, 0.07169662f, 0.13975580f, -0.87552679f, 
    -0.10057343f, -0.66790915f, 0.03282661f, -0.12166688f, -0.07251325f, 0.06522402f, 0.07732482f, 0.01665548f, 
    0.13207704f, -0.05226781f, -0.06807321f, 0.27079287f, 0.27851000f, -0.20493992f, 0.04134969f, -0.12096152f, 
    -0.07411727f, 0.09979950f, 0.13561286f, 0.18619795f, -0.21369399f, 0.15735687f, 0.11807642f, 0.00973133f, 
    0.20300554f, -0.22637609f, -0.08399549f, 0.07221022f, -0.10380381f, -0.40923697f, 0.59551352f, 0.20018749f, 
    0.05101781f, 0.00381075f, 0.26284724f, 0.17661162f, 0.21183230f, -0.05059098f, 0.12809084f, 0.17952619f, 
    0.09302676f, 0.23266114f, 0.09204172f, -0.09937099f, -0.06053261f, -0.22858268f, -0.21533614f, -0.09666709f, 
    0.12489383f, -0.26986164f, -0.14578159f, -0.15105145f, 0.11153892f, 0.15958856f, -0.17957112f, -0.07998462f, 
    0.38361537f, 0.48809141f, 0.04888985f, 0.13123867f, -0.03577712f, 0.12810996f, 0.08801951f, 0.08144534f, 
    0.01952662f, 0.03986631f, 0.50760549f, 0.42665151f, -0.02329221f, 0.11814030f, -0.08158850f, 0.07293328f, 
    0.08769751f, -0.04564641f, -0.05715870f, 0.11393841f, -0.11677105f, 0.26226667f, -0.20580770f, 0.01640567f, 
    0.11683158f, 0.31593841f, 0.05053577f, 0.01960354f, -0.06404039f, -0.06689487f, -0.05805689f, 0.04823402f, 
    -0.02729657f, -0.01936793f, 0.01777644f, 0.06123880f, 0.03355786f, -0.07483342f, 0.00747979f, 0.05109284f, 
    0.06688044f, 0.04272291f, -0.19230661f, 0.15233956f, 0.01114942f, 0.42753208f, 0.12774619f, -0.01110111f, 
    0.01428964f, 0.04609909f, 0.12004683f, 0.01548505f, -0.26465365f, -0.59746242f, 0.11601482f, 0.13485527f, 
    0.10220505f, 0.01554056f, -0.06967351f, 0.02004188f, 0.13751380f, -0.09284586f, -0.28068945f, 0.01575860f, 
    -0.42760739f, -0.04765401f, -0.01661328f, 0.03855129f, 0.03530188f, -0.30879918f, -0.22421452f, -0.51749194f, 
    0.08565262f, 0.05663039f, -0.02705620f, 0.01669041f, 0.11426876f, 0.03283596f, -0.60114443f, -0.28392932f, 
    -0.19996864f, 0.07965010f, -0.03119226f, -0.00496868f, 0.21485783f, 0.01019952f, 0.01128393f, -0.05182721f, 
    -0.04318757f, -0.09610418f, 0.15775599f, 0.17763916f, -0.15356591f, 0.31596631f, 0.19984101f, -0.04911545f, 
    -0.12600614f, -0.13068706f, -0.23032755f, 0.15476272f, 0.26938742f, 0.16968083f, -0.05824504f, -0.04593388f, 
    -0.19601220f, 0.13009468f, 0.14772244f, 0.11716515f, 0.04477926f, 0.24848357f, 0.15567032f, -0.09037194f, 
    0.08656923f, -0.21011704f, 0.13316032f, 0.28577805f, 0.06433583f, 0.07614245f, -0.45047927f, 0.20376258f, 
    -0.10656457f, -0.32273868f, -0.05776251f, -0.19415113f, -0.06556490f, 0.07958885f, 0.59257072f, 0.22746626f, 
    -0.41982222f, 0.06724953f, -0.04292142f, -0.05454044f, 0.17372331f, -0.00994126f, 0.13606566f, -0.14240517f, 
    -0.03721493f, 0.10179687f, -0.13813208f, -0.13316832f, -0.30929011f, -0.27672124f, 0.18922979f, -0.14642617f, 
    0.21556370f, 0.08413841f, -0.05269891f, 0.04237882f, 0.19174325f, -0.02600051f, 0.13660236f, -0.00695310f, 
    -0.21483056f, -0.06159849f, -0.02467377f, 0.05965355f, 0.02884927f, 0.21991095f, 0.30329072f, -0.10327154f, 
    -0.58951491f, -0.69773084f, -0.16943301f, -0.19763526f, 0.23757613f, -0.11070368f, -0.20526613f, -0.06878650f, 
    -0.18437046f, 0.05138854f, -0.00144239f, 0.02601576f, 0.00366526f, -0.12536481f, 0.14718953f, 0.09024683f, 
    0.05972299f, 0.03605566f, -0.04458419f, -0.11820782f, 0.16406029f, 0.04809627f, -0.62438178f, 0.00325408f, 
    0.07478943f, 0.15039018f, -0.08108450f, -0.06085571f, -0.05518522f, 0.23968288f, -0.00006848f, 0.03087898f, 
    0.03794831f, 0.01799273f, 0.31354988f, -0.08671894f, -0.05790441f, -0.23783818f, -0.04084403f, -0.14744517f, 
    -0.02947294f, 0.23258080f, 0.16709097f, 0.07757647f, 0.00329580f, 0.16759118f, -0.13812488f, 0.15918356f, 
    0.04362903f, -0.02511456f, 0.11848981f, 0.04273726f, -0.00821316f, 0.06018281f, -0.01865502f, -0.14480266f, 
    0.01968556f, 0.00250943f, -0.01657337f, -0.01396915f, -0.01841173f, 0.03430563f, 0.02576243f, -0.01923929f, 
    -0.04467843f, 0.03095572f, 0.00168400f, -0.06575114f, -0.01133368f, 0.02059252f, -0.05438019f, 0.00043152f, 
    0.00606407f, -0.05469502f, 0.05199185f, -0.06560911f, 0.02232263f, -0.00524798f, -0.05385944f, 0.05538464f, 
    -0.03595692f, -0.06238768f, -0.03024854f, -0.02105608f, 0.01728868f, -0.01418018f, 0.03390946f, -0.00323593f, 
    0.00995127f, 0.00335046f, 0.04238164f, -0.02800586f, -0.01771265f, -0.06273715f, -0.00333306f, 0.04158907f, 
    -0.01424515f, 0.02820359f, 0.02931497f, 0.05300393f, -0.04976255f, 0.06124975f, -0.05740443f, -0.00438389f, 
    -0.04780613f, -0.03432873f, 0.04562385f, 0.02689395f, 0.03881671f, 0.01930778f, -0.02208741f, 0.01571617f, 
    -0.03094992f, 0.01844982f, 0.03141788f, -0.01716562f, -0.05596227f, 0.03040346f, 0.02554269f, -0.01659597f, 
    -0.06112877f, -0.05606346f, -0.01557814f, 0.01237973f, -0.00901131f, -0.00796174f, -0.03107527f, 0.00970834f, 
    -0.04817184f, 0.00755263f, -0.02760801f, 0.02137671f, -0.04980250f, -0.04762767f, -0.05821201f, 0.04754732f, 
    -0.00824061f, -0.05566964f, 0.02495230f, 0.00925698f, 0.02676770f, -0.02002755f, -0.06119691f, -0.04075640f, 
    -0.05525061f, -0.02609835f, 0.00820474f, 0.04460254f, -0.03847996f, 0.00670132f, 0.02761022f, -0.01164072f, 
    0.01920389f, -0.01758562f, 0.02860003f, 0.04795767f, 0.00352526f, -0.05722259f, -0.01320552f, -0.02659568f, 
    0.04813644f, -0.00889491f, 0.05178626f, -0.02888554f, 0.01682953f, 0.02795118f, -0.03913232f, -0.00259921f, 
    0.00343910f, -0.04016808f, -0.03150944f, -0.06362115f, 0.02843530f, -0.01542860f, 0.00656330f, -0.02576510f, 
    -0.03891233f, 0.01067546f, -0.05026814f, 0.00800777f, 0.04770200f, -0.05046684f, -0.06132346f, -0.01186510f, 
    0.04372563f, 0.03960469f, -0.00481035f, 0.02527286f, 0.01856189f, 0.01365773f, -0.02461405f, -0.00808656f, 
    -0.00961407f, -0.06066820f, -0.00693287f, -0.00497703f, -0.06731609f, -0.06122522f, -0.03728484f, -0.02933724f, 
    0.01676249f, 0.01277519f, 0.00218717f, -0.00555056f, -0.02113519f, -0.04691607f, 0.00919490f, 0.00505269f, 
    -0.06269586f, -0.00038093f, -0.00483862f, 0.05127272f, 0.04471096f, -0.02324165f, -0.04482934f, -0.03461538f, 
    0.02757138f, 0.02296198f, -0.04842284f, 0.01073775f, -0.04579739f, 0.02051776f, -0.02606245f, -0.00981342f, 
    0.00219991f, -0.01493260f, -0.04393340f, -0.03572062f, 0.01714790f, -0.01927066f, 0.03694388f, 0.01218282f, 
    -0.04124695f, -0.00164251f, -0.03910793f, 0.01620696f, 0.00685919f, -0.05315983f, 0.02605932f, -0.04583679f, 
    -0.06583119f, -0.02547142f, 0.05455117f, -0.00059497f, -0.00224970f, 0.00920351f, 0.01648332f, -0.05986622f, 
    -0.05284666f, 0.01807609f, 0.04258230f, -0.02221536f, 0.00416294f, 0.03583268f, 0.00418634f, -0.02997296f, 
    0.00377674f, -0.01309892f, 0.02042920f, 0.00256994f, 0.00676882f, -0.06034359f, -0.00781565f, 0.03644319f, 
    -0.01462767f, -0.01955362f, -0.05059734f, 0.04152725f, -0.04984815f, -0.06000521f, 0.01284865f, -0.02025406f, 
    -0.00501478f, -0.02466426f, -0.03199511f, 0.03391800f, 0.01264736f, -0.00968790f, -0.01259851f, 0.01861294f, 
    0.03381013f, 0.03261258f, -0.01211926f, 0.04235839f, 0.00138772f, 0.02789798f, -0.05932641f, 0.02240390f, 
    -0.02791784f, -0.03746565f, -0.05381358f, -0.03164699f, 0.00206320f, 0.02335206f, -0.01181396f, 0.03820737f, 
    -0.03164528f, 0.00893534f, 0.02308382f, -0.00171276f, 0.02849552f, 0.04611093f, 0.02876864f, -0.00502976f, 
    -0.03859446f, -0.00965006f, 0.00008588f, -0.04083325f, -0.05107509f, -0.05101927f, -0.00843162f, -0.05457620f, 
    -0.06332270f, -0.03422144f, -0.06210447f, -0.04988443f, -0.02063379f, 0.03449846f, -0.03385079f, 0.03811764f, 
    -0.06630334f, -0.00676172f, 0.05065110f, -0.04763664f, -0.01707619f, -0.01777435f, -0.03368538f, 0.04213950f, 
    0.04115076f, 0.00699908f, 0.05172400f, 0.02610337f, 0.03922829f, 0.03172941f, 0.01887212f, 0.04458131f, 
    -0.00781312f, -0.03000588f, -0.05057202f, -0.02652973f, -0.05129352f, 0.03684869f, -0.00023684f, 0.01449378f, 
    -0.24638693f, 0.03195950f, 0.30101305f, -0.03416475f, 0.00703137f, -0.03118251f, -0.15582274f, -0.13678177f, 
    0.04225190f, -0.28667021f, -0.11807338f, -0.20746180f, -0.10057391f, -0.02297153f, -0.09468203f, 0.08203536f, 
    -0.13160557f, -0.33887380f, 0.38973033f, -0.00893630f, 0.30282316f, -0.01290571f, 0.09631102f, 0.07788137f, 
    0.05668121f, 0.25497097f, 0.24796239f, 0.11852725f, -0.69792414f, -0.46650681f, 0.12421967f, -0.01125744f, 
    -0.07731954f, 0.16860460f, -0.08665373f, 0.11371842f, 0.21178095f, -0.22189099f, -0.12889519f, 0.00748562f, 
    0.02342331f, -0.00585471f, 0.09634341f, 0.42653158f, 0.25923154f, 0.32399121f, -0.49629545f, 0.18711062f, 
    0.08144011f, -0.34272432f, 0.45889875f, -0.01515835f, 0.03440944f, 0.03424738f, -0.33118567f, -0.31412646f, 
    -0.32196054f, 0.13280606f, 0.10199999f, 0.02320748f, 0.00272315f, -0.12023761f, 0.02727539f, -0.33041871f, 
    0.44922829f, -0.02594686f, 0.10554343f, 0.02797972f, -0.04725292f, 0.04908689f, -0.26249683f, 0.06904311f, 
    -0.37926164f, -0.29063448f, -0.01125025f, -0.08928291f, -0.05633858f, 0.13653070f, -0.13333814f, -0.06461487f, 
    0.21069273f, -0.41777983f, -0.59164202f, -0.46822369f, 0.15845796f, -0.04249427f, -0.12983164f, 0.09528834f, 
    0.19997090f, 0.07485459f, -0.08328184f, -0.00277878f, -0.11840881f, 0.25937644f, -0.00802157f, 0.05757746f, 
    0.20604165f, 0.32753855f, 0.10261279f, 0.01307385f, 0.10399129f, 0.17411382f, 0.07997023f, -0.01378169f, 
    0.12262823f, 0.27868345f, 0.17218788f, 0.22201483f, 0.19217576f, 0.03288634f, -0.19897659f, -0.04195342f, 
    -0.09753542f, -0.24151005f, -0.19401486f, -0.21328700f, 0.02826645f, -0.45325989f, -0.17944819f, -0.13863993f, 
    0.06985601f, 0.14090109f, -0.00108519f, 0.26900533f, 0.10377353f, 0.08700265f, 0.08173702f, 0.04474669f, 
    0.22225156f, 0.15706860f, 0.20487633f, 0.11315882f, 0.15753184f, -0.00967679f, 0.12473954f, -0.08192269f, 
    0.03437370f, -0.00459872f, -0.02236378f, -0.03831755f, -0.03956701f, -0.02566091f, -0.17723951f, -0.08014056f, 
    -0.10818306f, 0.01055265f, 0.14041337f, -0.08837865f, -0.08329184f, -0.12568200f, -0.02115931f, -0.12163478f, 
    0.12049156f, -0.23940565f, 0.02756819f, 0.03932749f, 0.25851861f, 0.20378576f, -0.09971060f, -0.30229089f, 
    0.06209992f, 0.12201376f, -0.30535883f, -0.15139274f, 0.37517086f, 0.12246869f, 0.15086892f, 0.20951968f, 
    -0.00443551f, -0.20269965f, 0.43156260f, 0.01543331f, -0.08804660f, -0.00982125f, -0.24598582f, -0.02330193f, 
    -0.14896576f, 0.23001467f, 0.13802090f, 0.10230115f, -0.01292420f, -0.18674442f, -0.02573984f, -0.15994814f, 
    -0.08490591f, -0.11312990f, 0.24838625f, 0.39907357f, 0.15569432f, 0.19580758f, 0.40195739f, 0.24395347f, 
    0.12526406f, 0.26342812f, 0.00838758f, 0.04709095f, 0.15629573f, 0.18321022f, -0.43935385f, 0.18555249f, 
    0.67109203f, -0.13330327f, -0.08862445f, -0.11928771f, 0.02940925f, -0.05638257f, -0.03462294f, 0.29597482f, 
    -0.09714910f, 0.05888752f, 0.11592160f, -0.00408653f, 0.15455443f, 0.07711178f, 0.18988758f, 0.37322286f, 
    -0.07409959f, 0.01745449f, -0.04966060f, -0.12620220f, -0.30892661f, -0.09057280f, -0.02237465f, 0.07753864f, 
    -0.23402764f, -0.10620490f, -0.23911235f, -0.24204361f, 0.03699974f, -0.00988927f, -0.12510125f, -0.25332788f, 
    -0.43736956f, -0.22565559f, 0.38843811f, 0.18862520f, 0.01654514f, 0.08982367f, 0.13220087f, 0.16879162f, 
    0.13023953f, 0.23778121f, 0.45384157f, -0.01586308f, -0.08114609f, -0.08675867f, 0.33980778f, 0.15862007f, 
    0.24752977f, 0.05579353f, 0.23567538f, 0.31380913f, 0.50214946f, -0.18448602f, -0.15348577f, 0.11404908f, 
    0.11955021f, 0.15023118f, 0.10199416f, 0.17207192f, 0.09282032f, 0.03995360f, 0.38183668f, 0.08789572f, 
    0.07976501f, 0.08017102f, 0.06502774f, 0.15776549f, -0.12632392f, 0.42206052f, -0.15857784f, -0.17711918f, 
    0.09970357f, -0.06068246f, -0.06914079f, -0.04634980f, -0.19810170f, -0.20427372f, 0.04295624f, -0.13058038f, 
    0.01436898f, -0.05045016f, 0.00940364f, -0.14619204f, -0.06099081f, 0.04000565f, 0.02448590f, 0.02583765f, 
    -0.04818396f, 0.03312538f, 0.05593413f, -0.01686573f, 0.05452689f, -0.05512698f, 0.00453815f, -0.05072205f, 
    -0.05386897f, -0.00779121f, 0.04947985f, 0.02069243f, -0.00914178f, 0.00976042f, 0.01471716f, 0.01969091f, 
    0.00112787f, 0.00702814f, -0.02073220f, -0.04592669f, -0.01319032f, 0.03534776f, -0.02640769f, 0.00256864f, 
    0.02048045f, -0.03713348f, 0.01141988f, -0.01520232f, 0.02837323f, 0.04790409f, -0.04505089f, 0.04736061f, 
    0.02554031f, -0.03729000f, 0.02324331f, 0.03779883f, -0.02563886f, -0.03344050f, 0.02922953f, -0.02993532f, 
    -0.05760208f, -0.04022412f, 0.04367242f, -0.01464712f, 0.03119055f, -0.04366783f, 0.00927895f, -0.03766992f, 
    -0.05274728f, -0.01747268f, 0.05071697f, -0.00684480f, -0.03146625f, 0.00766481f, 0.01432674f, -0.03674697f, 
    -0.02316811f, 0.03339270f, 0.02379230f, 0.05331647f, 0.04463305f, 0.05073304f, -0.06301267f, -0.04094853f, 
    -0.00120433f, -0.03770275f, -0.00245532f, 0.05246520f, -0.05437333f, 0.00862652f, 0.00446593f, -0.01314047f, 
    0.04576093f, -0.03941359f, -0.05785109f, 0.03542182f, -0.01586164f, 0.03464450f, 0.01348260f, -0.06257392f, 
    -0.03217404f, 0.02736376f, 0.00609468f, -0.01943203f, 0.04948043f, -0.05383661f, 0.02412190f, 0.00360561f, 
    -0.06092289f, -0.04723488f, 0.02492281f, -0.04820096f, -0.02668764f, -0.05319517f, -0.02657850f, -0.02392844f, 
    -0.04396551f, -0.03599272f, 0.01611338f, 0.04084938f, -0.02757582f, -0.03083261f, -0.04055338f, -0.04041527f, 
    0.00016905f, 0.01214782f, -0.04904180f, 0.02765648f, -0.04899804f, -0.01645570f, 0.02753093f, 0.03011378f, 
    0.00810874f, -0.03870266f, -0.00818280f, 0.05295597f, 0.02127883f, 0.00152834f, -0.03436207f, -0.01683618f, 
    0.04527910f, -0.03057432f, -0.04155301f, -0.03565347f, -0.00252994f, -0.01367921f, 0.00271671f, 0.02896255f, 
    -0.05322793f, -0.05616665f, 0.04540784f, 0.00833225f, -0.01035781f, 0.04845952f, 0.03198719f, 0.04986427f, 
    -0.05397261f, -0.01694086f, 0.03810581f, -0.02535622f, 0.02381924f, -0.03466786f, -0.04605284f, 0.02616804f, 
    -0.03862286f, -0.03266324f, 0.04754262f, -0.01797902f, -0.03346242f, 0.01988845f, -0.03204584f, -0.05438328f, 
    -0.00190580f, -0.03702330f, -0.06088068f, 0.03695985f, 0.01772053f, -0.02800239f, -0.02845997f, -0.04260299f, 
    0.02536989f, -0.02406355f, 0.04356810f, -0.01534093f, -0.02704231f, 0.03464859f, -0.01716328f, 0.03901167f, 
    -0.02923702f, 0.02388405f, 0.02724099f, 0.04401635f, 0.02246222f, 0.02948967f, 0.02611640f, -0.02242892f, 
    0.03614711f, 0.04256244f, 0.04417116f, 0.00246234f, -0.02226232f, -0.05931890f, -0.00711069f, -0.05141301f, 
    -0.04865825f, 0.02446837f, 0.03918957f, -0.02211335f, 0.01142114f, 0.01082673f, -0.01604024f, -0.03537417f, 
    -0.03675432f, 0.05946366f, 0.02230249f, -0.03921090f, -0.03647406f, 0.02416995f, -0.04838462f, -0.04685853f, 
    -0.02698701f, -0.04002111f, 0.05431522f, -0.04270705f, -0.02873966f, 0.01331678f, -0.01470460f, -0.05207096f, 
    0.02566656f, -0.05696222f, 0.04195301f, -0.05579102f, 0.00706576f, -0.01055861f, -0.01063733f, -0.01868343f, 
    0.02653371f, 0.01235000f, 0.05015370f, 0.02537767f, 0.04338350f, -0.02506389f, -0.02706319f, -0.02143698f, 
    -0.00727206f, -0.03317629f, -0.00334661f, -0.04640872f, -0.05430181f, 0.02033908f, 0.04920332f, -0.04612169f, 
    -0.01347582f, 0.01375527f, 0.01048449f, -0.04032300f, -0.05083990f, -0.04720992f, -0.00516287f, -0.03920099f, 
    -0.01075370f, 0.02491693f, -0.03018926f, 0.04199746f, -0.04859630f, -0.02397164f, 0.02305315f, -0.04113763f, 
    0.03688005f, -0.05258388f, -0.03468400f, 0.04573282f, 0.00473155f, -0.03504782f, 0.04556476f, -0.00590475f, 
    -0.04166828f, -0.00471553f, 0.02035500f, -0.06297979f, -0.02188525f, 0.03277921f, 0.01731086f, -0.03248518f, 
    0.00302240f, 0.05430130f, 0.05327765f, -0.05357085f, 0.02898066f, -0.05712002f, -0.04333374f, -0.01647130f, 
    0.01545379f, 0.02950216f, 0.01953805f, -0.00066668f, -0.01095914f, -0.04246567f, 0.04704440f, -0.01854813f, 
    -0.04095284f, 0.00163911f, 0.04512152f, 0.04222325f, -0.04013860f, -0.02025195f, -0.03007307f, -0.05793995f, 
    -0.05035399f, 0.01165463f, 0.00590458f, -0.02253473f, 0.01835773f, -0.04441378f, 0.05214229f, -0.04311749f, 
    -0.03709441f, 0.03946250f, -0.03407645f, -0.03467387f, -0.04148496f, -0.05929736f, -0.04809012f, 0.04196544f, 
    0.02181450f, 0.02899625f, 0.05319557f, -0.00751827f, -0.00303658f, -0.00793182f, -0.03222720f, -0.03689643f, 
    0.02998959f, 0.00064849f, -0.03076607f, 0.04060340f, -0.04319726f, -0.02649759f, -0.02226745f, -0.04961427f, 
    0.02822507f, -0.00226711f, 0.01810918f, -0.04924498f, 0.00585534f, 0.00304719f, 0.01741892f, -0.04814376f, 
    -0.03642560f, -0.00105564f, 0.03143438f, -0.05238401f, 0.02098672f, 0.01763292f, -0.00473482f, 0.00015392f, 
    -0.00447786f, 0.00715454f, 0.00498562f, -0.04144290f, -0.05401940f, -0.03476695f, 0.02787618f, -0.02479985f, 
    -0.02696089f, 0.04115862f, -0.03708608f, -0.00563963f, 0.04590197f, -0.05029792f, 0.04815420f, 0.01196246f, 
    -0.04695514f, -0.03278147f, 0.01567280f, 0.05172081f, -0.05822917f, 0.04906616f, 0.04009897f, -0.00696789f, 
    -0.03885620f, -0.01649125f, -0.00647169f, -0.03939594f, 0.03655699f, 0.03854525f, 0.03090396f, 0.04007783f, 
    0.00411399f, 0.01540503f, 0.04188009f, -0.03603969f, -0.06304681f, 0.01701316f, 0.00677964f, 0.00839410f, 
    0.01099665f, 0.00069491f, -0.01983011f, 0.00461300f, 0.02569305f, 0.00836529f, -0.05221874f, 0.01221973f, 
    -0.02561440f, -0.00424789f, 0.02414260f, 0.02732429f, 0.05659858f, 0.00265474f, -0.02778541f, 0.05051051f, 
    0.01080234f, 0.04141419f, 0.01502416f, 0.04059941f, -0.02243972f, -0.02583871f, 0.04701081f, -0.02598460f, 
    -0.01154868f, 0.02930199f, 0.03557010f, -0.04128807f, -0.03731770f, -0.00030230f, -0.04383678f, -0.03361269f, 
    -0.01255308f, -0.04267551f, -0.03047490f, -0.01837728f, -0.04428335f, -0.00981757f, 0.02855811f, -0.04908964f, 
    0.02314418f, 0.04401502f, 0.04980693f, -0.04167762f, 0.00955050f, -0.04549481f, 0.02091360f, 0.02397911f, 
    -0.02002340f, 0.03396263f, -0.04802120f, -0.06086576f, -0.05484140f, -0.01473729f, 0.01798165f, -0.04656668f, 
    0.03747932f, -0.04614085f, -0.00202729f, -0.00305419f, -0.01361177f, -0.04839836f, 0.04143294f, -0.04565411f, 
    0.03969935f, 0.02836886f, -0.02950147f, 0.04712001f, 0.04507034f, 0.03558299f, -0.05655077f, -0.02972827f, 
    -0.02891951f, -0.04049129f, -0.05046899f, 0.01489646f, -0.01693325f, 0.04385773f, -0.04455210f, -0.05823473f, 
    -0.04949354f, -0.02540016f, -0.03265186f, -0.05889259f, 0.05042769f, -0.05918366f, 0.02989125f, 0.03107937f, 
    -0.01611865f, 0.03199554f, -0.00892066f, 0.04563535f, 0.02902656f, -0.06491385f, 0.01574437f, -0.03367523f, 
    -0.06619149f, 0.03568060f, -0.01606552f, -0.01072236f, -0.05825037f, 0.02269668f, 0.00106818f, -0.00257263f, 
    0.04074183f, -0.06573817f, 0.00520224f, -0.01792138f, 0.00660930f, 0.04715895f, -0.00446489f, 0.03986749f, 
    0.04292915f, 0.03719474f, -0.06569573f, 0.03568914f, -0.01507609f, -0.00323732f, 0.02732048f, 0.03389027f, 
    0.00515751f, -0.02519313f, 0.03690532f, 0.00177125f, -0.05934104f, -0.06267227f, 0.00721357f, 0.04932587f, 
    -0.00435379f, 0.02386232f, -0.02205636f, 0.01186503f, -0.02425232f, 0.02906181f, 0.00570545f, 0.03567846f, 
    0.03735888f, -0.04174362f, 0.01237303f, -0.02520117f, -0.06458236f, -0.00742571f, 0.02170104f, -0.05646238f, 
    -0.03895738f, -0.04419796f, -0.01539321f, -0.00376667f, -0.04231135f, -0.05222080f, -0.00112551f, 0.04786006f, 
    0.00625079f, -0.00058801f, -0.03432873f, 0.00968018f, -0.04277159f, 0.03118952f, 0.01876954f, -0.05216385f, 
    -0.04589019f, -0.03356221f, -0.02031971f, -0.01215278f, -0.00424708f, -0.06237183f, -0.03088359f, 0.00984086f, 
    -0.04877421f, -0.02785454f, 0.01259161f, -0.01539502f, -0.04549428f, -0.04196070f, -0.03527707f, -0.03337870f, 
    0.03279707f, -0.05805134f, 0.01783781f, 0.01235257f, 0.00141206f, 0.03859858f, -0.00157063f, -0.03552051f, 
    -0.06030938f, -0.02392960f, 0.00887905f, 0.02448178f, -0.02687509f, -0.05390740f, -0.06632696f, -0.00365777f, 
    0.03043409f, 0.04554322f, -0.00239538f, -0.02732618f, -0.01057133f, 0.05182632f, 0.01449179f, -0.04720079f, 
    -0.04955273f, -0.02082446f, 0.03710436f, -0.00283407f, -0.05311117f, 0.04523989f, 0.01372045f, -0.04243236f, 
    0.00309843f, 0.04293676f, -0.03240736f, -0.03460212f, -0.03745278f, 0.00876797f, 0.03561090f, 0.00712043f, 
    -0.02303406f, 0.00099048f, -0.04378347f, -0.05836312f, 0.06295322f, -0.00380371f, -0.06330325f, -0.06299368f, 
    -0.00858683f, -0.06311213f, 0.00899960f, 0.01355356f, 0.02664906f, 0.02621504f, -0.00770775f, 0.05572132f, 
    -0.05930309f, -0.01790518f, -0.02218522f, 0.04627143f, -0.00628261f, -0.02347368f, -0.03160242f, -0.04497574f, 
    0.00182212f, -0.00067116f, 0.02013514f, 0.00963766f, -0.04442276f, 0.01252989f, 0.05659522f, 0.03329323f, 
    -0.03578073f, -0.04680352f, -0.00059951f, 0.01319410f, 0.02780057f, -0.01114673f, 0.04779313f, -0.03507557f, 
    -0.04363446f, -0.04732506f, -0.00815161f, 0.04730643f, 0.02477673f, 0.01525151f, 0.01778172f, -0.05473476f, 
    0.04622986f, -0.03019230f, -0.01256352f, -0.01285950f, 0.04949116f, 0.03667828f, -0.05435794f, 0.01805199f, 
    -0.05572642f, -0.01508182f, 0.00881867f, -0.00782351f, -0.04569570f, -0.05339019f, -0.01711340f, -0.01689840f, 
    0.02294420f, -0.01812004f, 0.04436836f, 0.02678195f, 0.03189663f, -0.04995759f, 0.02683023f, -0.00673359f, 
    -0.05431563f, -0.02727305f, -0.02509737f, 0.03627024f, 0.02760554f, -0.05269945f, -0.00196447f, 0.01236932f, 
    -0.03326551f, -0.05825538f, -0.04254093f, 0.02235703f, 0.01335451f, -0.02147934f, 0.01068533f, -0.03805978f, 
    0.01858551f, 0.01843647f, -0.05264949f, 0.03220521f, 0.03314503f, 0.04396949f, -0.03696447f, 0.01953780f, 
    0.03948212f, 0.03630184f, 0.02709419f, -0.01612196f, 0.02410997f, -0.00198913f, -0.03421234f, -0.04068263f, 
    0.04216185f, -0.02155021f, 0.04265790f, -0.00598783f, 0.03570075f, 0.03150238f, -0.04942681f, -0.05583039f, 
    -0.05894241f, 0.01110274f, -0.01651952f, 0.03905611f, -0.06006289f, -0.06262844f, 0.02249224f, 0.02715595f, 
    0.05147889f, 0.04807290f, -0.01802391f, -0.01074957f, -0.05787456f, -0.06128437f, -0.05899218f, 0.00067592f, 
    -0.06404812f, -0.02513934f, 0.00316481f, -0.01196564f, -0.04371436f, -0.05017671f, 0.01346510f, 0.04714835f, 
    0.04341928f, -0.02240035f, 0.01469546f, 0.05274466f, -0.01906772f, -0.00427874f, -0.03255331f, -0.02306212f, 
    -0.02067716f, -0.04187345f, 0.03020834f, 0.00376101f, 0.03964328f, -0.00256151f, 0.03030994f, 0.01197331f, 
    -0.05058248f, 0.00731433f, -0.01355906f, 0.00489371f, 0.03113930f, 0.04069120f, -0.04959745f, 0.01370133f, 
    0.00143490f, 0.04592654f, 0.03769482f, -0.05262341f, -0.05640272f, -0.06454922f, 0.03426448f, 0.00155528f, 
    -0.03076043f, -0.05186639f, -0.00225642f, -0.04518832f, -0.02997467f, -0.06245017f, 0.00177647f, 0.02832353f, 
    0.02553856f, -0.05771144f, -0.04919366f, -0.01176339f, -0.01104385f, -0.06008918f, 0.05423278f, -0.03723733f, 
    0.03976080f, 0.02177197f, -0.02106029f, 0.04505554f, 0.02758818f, 0.05139060f, 0.02303229f, -0.01568747f, 
    -0.00419499f, 0.03924326f, 0.01999564f, -0.04118355f, 0.00435158f, -0.00610251f, -0.03765000f, -0.02513668f, 
    -0.01750816f, -0.01157540f, -0.01667278f, -0.04845338f, -0.03671738f, -0.03257627f, 0.03505844f, -0.03657944f, 
    0.02493948f, -0.02101869f, 0.03367876f, 0.01668611f, 0.04985338f, 0.02929573f, -0.03504241f, 0.04028926f, 
    -0.01287090f, 0.03826361f, -0.01025731f, -0.02513246f, -0.00181618f, 0.02751613f, 0.00155632f, -0.05749176f, 
    -0.00209698f, -0.02460788f, -0.03751760f, -0.04127975f, -0.03042385f, -0.05229820f, -0.03383515f, 0.03714609f, 
    -0.05002435f, 0.01835375f, -0.03222357f, -0.04516764f, 0.06433154f, 0.03068213f, 0.03061880f, 0.04051890f, 
    0.02131049f, -0.06072590f, 0.03007129f, 0.01671120f, 0.04388308f, -0.00260988f, -0.04231796f, -0.04312627f, 
    0.02911863f, -0.01067940f, -0.00904563f, 0.00940926f, -0.06173259f, -0.02187494f, -0.00731278f, -0.05783279f, 
    0.01864892f, -0.02088987f, -0.01351518f, -0.03346698f, 0.03944773f, 0.05650674f, 0.05344968f, 0.01716666f, 
    0.05828381f, -0.00872527f, -0.04705548f, -0.02046086f, 0.01860890f, -0.01062527f, -0.04013314f, -0.02261403f, 
    0.26371726f, -0.11892583f, -0.12834163f, 0.16962019f, -0.06511202f, -0.21094762f, -0.01729834f, 0.09166365f, 
    -0.01366717f, -0.18186159f, 0.12885888f, -0.27635747f, -0.07283781f, 0.21442422f, 0.04315121f, 0.01414693f, 
    -0.06512356f, -0.20041147f, -0.44516677f, 0.26727146f, 0.05482166f, -0.06750526f, 0.06413089f, 0.03698834f, 
    0.24247985f, 0.26126334f, 0.28131980f, 0.73373830f, 0.16747123f, -0.44388762f, 0.02855038f, 0.03313772f, 
    -0.22034809f, 0.03654583f, 0.00449326f, 0.04062726f, -0.29630464f, 0.32036963f, 0.00990146f, -0.10709662f, 
    0.09279115f, -0.02990675f, -0.00879449f, 0.38524076f, 0.07071614f, 0.64823353f, 0.07868776f, 0.37697643f, 
    -0.22152683f, 0.53161818f, -0.06066814f, -0.01721051f, -0.01634463f, 0.10678352f, -0.09724395f, 0.05838327f, 
    0.29681605f, -0.13798279f, -0.10758670f, -0.23698196f, -0.10875057f, -0.12284366f, -0.11293261f, 0.11360212f, 
    -0.11918046f, 0.16364206f, 0.15149540f, -0.07396275f, 0.12753482f, -0.12711890f, 0.13725391f, -0.14608741f, 
    0.62107074f, -0.06436136f, -0.14026621f, 0.12156955f, 0.01352509f, -0.01307964f, 0.13150001f, -0.12969197f, 
    -0.13051127f, 0.57264644f, 0.10828926f, -0.11655935f, -0.21266116f, 0.21520461f, 0.02982787f, -0.00900273f, 
    0.12163383f, 0.14315835f, 0.06370885f, 0.14576386f, 0.06877249f, -0.11486259f, 0.31685957f, -0.19039720f, 
    0.10882888f, 0.05295841f, 0.15000005f, -0.37739366f, -0.07673350f, 0.17389725f, -0.13192080f, -0.06797496f, 
    -0.22061896f, 0.00077583f, -0.01849521f, 0.07152665f, -0.38935384f, -0.12650156f, 0.20940156f, -0.05776358f, 
    0.05695206f, -0.29264531f, 0.19574432f, -0.06750713f, -0.09172067f, -0.14516880f, -0.06872165f, 0.04980763f, 
    -0.24605335f, -0.09096263f, -0.10164500f, 0.07317648f, 0.10773814f, -0.06518131f, 0.17514512f, -0.07687077f, 
    0.14600529f, 0.01212536f, -0.09531388f, -0.15863587f, 0.02834609f, -0.13229090f, -0.20649020f, -0.19212984f, 
    -0.12589544f, -0.25375435f, -0.13875476f, -0.07471655f, 0.05387477f, -0.06324469f, 0.01470656f, -0.11755771f, 
    0.02060037f, 0.00037829f, 0.00855835f, 0.06008225f, 0.03046218f, -0.09139994f, 0.00700055f, -0.19609933f, 
    -0.13376443f, 0.53022426f, -0.20291428f, -0.23751356f, 0.12128619f, 0.15307678f, -0.04491083f, 0.07049039f, 
    -0.17140768f, 0.05557224f, -0.18323290f, 0.19537185f, 0.39844668f, -0.03186874f, 0.16518399f, -0.27307302f, 
    -0.22489259f, 0.04453025f, 0.25702226f, 0.04158283f, -0.14925003f, 0.06072650f, 0.07868046f, -0.04375094f, 
    0.12622213f, 0.09675100f, 0.07837258f, 0.10625649f, -0.19039011f, 0.19061370f, 0.25301185f, 0.04671585f, 
    -0.09068391f, 0.08619826f, 0.11745726f, 0.13882345f, 0.30019724f, -0.00738611f, -0.14854486f, 0.11578528f, 
    0.06880525f, -0.20092474f, 0.06416666f, -0.02742981f, 0.07437203f, -0.10398312f, 0.23349871f, -0.08904319f, 
    -0.00084230f, 0.07440248f, -0.11740142f, -0.28692865f, 0.08123762f, -0.01484385f, 0.16790320f, -0.07659636f, 
    0.07659649f, -0.17305018f, 0.11795487f, -0.09574821f, -0.10081935f, -0.06370305f, 0.01369033f, 0.00357094f, 
    -0.22316185f, 0.05432954f, 0.25844523f, -0.08071707f, -0.00832417f, -0.10276358f, -0.02736129f, 0.01843451f, 
    -0.03442959f, 0.08659546f, 0.16722551f, -0.05848752f, 0.00210781f, 0.00291850f, -0.04481564f, -0.09958834f, 
    -0.23376338f, -0.03852091f, -0.18541884f, 0.08420272f, -0.11851189f, 0.06841404f, -0.11138014f, 0.00246698f, 
    -0.23705494f, 0.02957933f, 0.12369050f, -0.14182745f, 0.00554510f, 0.05545138f, -0.01999843f, -0.09369650f, 
    -0.25803450f, -0.18677869f, 0.00783245f, -0.01734704f, -0.43323886f, 0.06972488f, 0.53025723f, -0.06552431f, 
    0.16669506f, -0.19440639f, -0.03469255f, 0.22058934f, -0.00274498f, 0.18465485f, -0.26632923f, -0.11499296f, 
    -0.34068036f, -0.07976925f, 0.12581451f, -0.00999794f, -0.13449875f, -0.28220046f, -0.41622695f, 0.15860955f, 
    0.07275368f, -0.12127446f, -0.07672781f, 0.10886438f, -0.19449994f, 0.02925146f, 0.06549773f, -0.17621620f, 
    0.00949654f, 0.15098003f, 0.05236864f, -0.00871602f, 0.02443654f, -0.04656059f, -0.01439513f, -0.06246564f, 
    -0.13555856f, -0.10863075f, -0.58899122f, -0.19069684f, -0.03590233f, 0.09550527f, -0.00140854f, -0.11694048f, 
    0.06288471f, 0.03770647f, -0.11608198f, -0.15943889f, 0.16664986f, -0.07351714f, -0.08239613f, 0.20438273f, 
    0.12457608f, -0.14590408f, -0.14533852f, -0.04455199f, 0.03334232f, 0.05873099f, -0.05536007f, -0.04172694f, 
    0.20421632f, 0.09761117f, 0.05320486f, 0.05916578f, 0.11602668f, 0.26293322f, -0.03460098f, -0.25342000f, 
    -0.11470135f, 0.02803745f, -0.09215823f, 0.10315038f, -0.18153286f, -0.29396376f, 0.44606230f, -0.04421933f, 
    -0.01899583f, 0.02356475f, 0.10797495f, 0.01190720f, 0.23782253f, -0.03638676f, 0.35615289f, -0.33138052f, 
    -0.00342100f, 0.47097504f, 0.06086969f, -0.20613906f, -0.02728764f, 0.13614354f, 0.16191646f, 0.24343155f, 
    0.20753027f, -0.06886134f, -0.14873865f, -0.39110199f, -0.00891943f, -0.08607179f, -0.16041794f, -0.17025691f, 
    -0.12274717f, -0.22643687f, 0.08300228f, 0.01861272f, 0.00128900f, 0.00588778f, 0.13027653f, -0.17929870f, 
    0.00956677f, 0.26674843f, 0.07749345f, -0.25535503f, -0.03931970f, 0.08157903f, 0.01019747f, -0.25994042f, 
    -0.08328944f, -0.15408108f, -0.03509284f, 0.79334396f, -0.00818313f, 0.08600491f, 0.02444872f, 0.04616758f, 
    -0.12003624f, -0.10625054f, 0.19932009f, -0.05074546f, -0.17889243f, -0.24888812f, -0.19567969f, -0.03862287f, 
    0.21671182f, 0.10613290f, 0.17537014f, 0.06111707f, -0.03896521f, -0.01481415f, 0.07354372f, -0.11114156f, 
    -0.18509009f, 0.00965818f, -0.03774540f, -0.04828719f, -0.06629744f, 0.02767625f, 0.06320410f, 0.13974923f, 
    -0.06663293f, -0.10563557f, 0.18521585f, -0.23236082f, 0.10078739f, -0.09980240f, 0.60668331f, 0.22241437f, 
    0.00356458f, -0.02734805f, -0.23177488f, 0.11879160f, -0.00912467f, 0.00588724f, -0.03923275f, 0.11815135f, 
    0.03191281f, -0.02039440f, 0.05023054f, -0.05287315f, 0.26569697f, -0.08734749f, 0.19588515f, -0.25533500f, 
    -0.14658599f, -0.04613145f, 0.10400829f, -0.05634518f, -0.09707182f, 0.01961385f, 0.06593587f, 0.12349460f, 
    0.06830397f, -0.05636285f, -0.04729802f, 0.17156848f, 0.10150770f, 0.04022720f, -0.11991148f, 0.14544241f, 
    -0.12044673f, 0.15094383f, -0.17956650f, -0.43579882f, -0.16848817f, -0.01893367f, 0.21011309f, 0.16656235f, 
    -0.06564555f, 0.01256786f, -0.07276481f, 0.22494338f, -0.12692532f, 0.22157098f, 0.22501484f, -0.34091592f, 
    -0.15810391f, 0.02801795f, -0.27010429f, -0.09676433f, -0.15098003f, -0.02492960f, 0.08078185f, -0.27004924f, 
    0.08375122f, -0.04538831f, 0.04891587f, 0.06143094f, 0.00944849f, 0.06700913f, -0.10798561f, 0.04208300f, 
    -0.15679631f, -0.19504599f, 0.00202672f, 0.06062820f, 0.16202268f, 0.21294975f, -0.26563081f, -0.50682455f, 
    -0.12685148f, 0.15782189f, -0.29268613f, 0.15071644f, -0.13375877f, -0.02408572f, -0.37445381f, 0.33012319f, 
    -0.34081551f, -0.12469813f, -0.03095787f, -0.16391127f, -0.01087189f, 0.05104104f, 0.17014275f, 0.03144665f, 
    0.06433665f, 0.13125409f, -0.14560454f, -0.02149352f, 0.08172172f, -0.07059512f, 0.11287867f, 0.09131999f, 
    0.04600511f, 0.16730648f, 0.19985647f, -0.03286334f, -0.20472199f, -0.10108227f, 0.00578070f, -0.04059656f, 
    -0.05330207f, -0.06970539f, 0.04515138f, 0.05127284f, 0.01305641f, 0.02407876f, 0.14061107f, -0.07540073f, 
    -0.19224624f, -0.38343143f, 0.11830129f, 0.08575460f, 0.23043175f, 0.02049698f, -0.04330270f, 0.01654093f, 
    0.01973611f, -0.00503136f, 0.13140272f, 0.15599068f, 0.12886852f, 0.14661394f, -0.07408401f, 0.04117355f, 
    -0.11452834f, 0.08950152f, 0.07529894f, 0.19224332f, 0.45151171f, -0.11457016f, -0.54325897f, 0.30100057f, 
    0.01290821f, -0.18976170f, 0.09739959f, 0.10680488f, 0.16105954f, 0.41113549f, 0.54379416f, -0.57022601f, 
    0.01993443f, 0.14078529f, -0.00800359f, 0.16264778f, -0.09047622f, 0.04146963f, -0.13152298f, 0.14722086f, 
    0.24351391f, -0.09932113f, -0.03960012f, 0.00807927f, -0.08648164f, -0.17850539f, 0.18211852f, 0.04065613f, 
    0.23102634f, 0.03571732f, -0.07374773f, -0.22890446f, -0.21193810f, -0.00353479f, -0.07316834f, 0.17900023f, 
    0.10576072f, 0.15546854f, -0.41430339f, -0.01647598f, -0.21951410f, -0.11617450f, 0.11934446f, -0.07880440f, 
    0.01330573f, -0.44232142f, -0.31511590f, -0.01065275f, -0.02116977f, 0.08067239f, -0.05154550f, -0.04309398f, 
    -0.17819792f, -0.02635345f, 0.18284261f, 0.46541372f, -0.23125203f, -0.04878675f, 0.03741726f, 0.05138530f, 
    0.06442364f, 0.11543109f, 0.07380089f, 0.25970775f, 0.80616087f, 0.56655216f, -0.18048561f, -0.17239240f, 
    -0.24793264f, 0.12374398f, 0.23868629f, 0.08834450f, -0.32136139f, 0.18658167f, -0.07502091f, 0.23368780f, 
    0.01167455f, -0.11091836f, 0.05216207f, -0.03933525f, -0.01174807f, -1.03447938f, -0.63507712f, -0.05304828f, 
    -0.04448573f, 0.36192209f, 0.28679207f, 0.05805753f, 0.09957322f, -0.00644507f, -0.05787152f, -0.37642738f, 
    0.23123458f, 0.04216784f, -0.03602124f, -0.22785689f, 0.10299178f, -0.05199692f, -0.04534172f, 0.27609706f, 
    -0.08159336f, -0.43465918f, -0.10050345f, -0.06405031f, 0.35750383f, -0.03912087f, 0.09635314f, -0.34518775f, 
    0.53573895f, 0.30251977f, -0.18686940f, -0.20162836f, 0.26177689f, -0.16317160f, 0.08863775f, 0.14977866f, 
    -0.06904065f, -0.60159004f, -0.16355774f, 0.46284512f, -0.19812727f, 0.02591561f, -0.08446769f, -0.02610322f, 
    0.04207492f, 0.04905983f, -0.23773026f, -0.16182451f, -0.13433203f, 0.07049055f, 0.08957767f, 0.13541482f, 
    0.01452921f, 0.11315922f, -0.07356597f, 0.12408986f, 0.16111898f, 0.15534082f, 0.06872537f, 0.06827733f, 
    -0.04508219f, -0.04119487f, 0.05719544f, 0.10261541f, 0.05715013f, 0.31627527f, 0.56335485f, -0.02944652f, 
    -0.31867981f, -0.14080708f, -0.09999087f, 0.18562153f, -0.09497081f, -0.12094861f, -0.29479423f, 0.11552092f, 
    -0.19626074f, -0.16771393f, -0.37680426f, 0.01658709f, 0.01940133f, 0.14195411f, 0.27821532f, 0.15411846f, 
    -0.23797891f, -0.00224240f, 0.29062599f, -0.02611425f, 0.09982389f, -0.06926607f, -0.06969912f, -0.27048814f, 
    -0.09502112f, -0.46635500f, -0.17921504f, -0.10358090f, -0.14031783f, 0.05836681f, -0.03348500f, -0.02877047f, 
    0.06444018f, 0.20311151f, -0.23821688f, 0.09536590f, 0.07629786f, -0.02185911f, 0.07270219f, -0.30387273f, 
    0.13513415f, -0.29264277f, -0.46433559f, -0.25543723f, -0.05686283f, 0.15938918f, -0.11854397f, -0.10841324f, 
    -0.08763948f, 0.04335016f, 0.19907892f, -0.06717510f, 0.24230467f, -0.01941598f, -0.14375381f, -0.27816829f, 
    -0.20446539f, 0.10516512f, 0.07243097f, -0.36275822f, -0.23156618f, 0.04754562f, 0.21950568f, 0.15865155f, 
    0.06084323f, -0.01569517f, 0.02501433f, 0.17909651f, -0.29106691f, -0.06690788f, 0.12396877f, 0.08268771f, 
    0.35440931f, 0.14611366f, 0.00637933f, -0.12889747f, 0.29398736f, -0.12554251f, -0.21949431f, 0.46755919f, 
    0.01581839f, 0.00496216f, 0.13358226f, -0.15870553f, 0.01940509f, 0.12137692f, 0.07432891f, -0.28062072f, 
    0.63079697f, 0.12079377f, -0.21942970f, -0.17279400f, 0.03026353f, -0.06321595f, -0.24379689f, -0.13565159f, 
    0.39314294f, 0.20533539f, 0.00796832f, -0.21738227f, 0.09244726f, 0.15289830f, 0.07886055f, -0.07532185f, 
    0.29886797f, -0.02301953f, 0.14561163f, 0.02972884f, -0.03236293f, -0.14948274f, 0.13708271f, 0.14451244f, 
    -0.08032988f, -0.39416209f, -0.17764437f, -0.05872723f, 0.10474678f, 0.07732999f, -0.21402103f, 0.10978759f, 
    0.05072367f, 0.11368170f, -0.02452479f, 0.21482822f, 0.13229245f, 0.00322997f, -0.05568025f, 0.15722913f, 
    0.04182879f, 0.26768520f, 0.09827067f, -0.14403774f, -0.11773791f, -0.11929183f, 0.08782233f, -0.09846176f, 
    0.02688123f, -0.03626993f, -0.11628695f, -0.16148196f, -0.20803761f, 0.01267573f, 0.22209625f, 0.09548578f, 
    -0.01419119f, -0.07236093f, 0.00752107f, -0.05088878f, 0.14808348f, 0.06956887f, -0.09157223f, 0.48647982f, 
    -0.15084016f, 0.03548181f, 0.22194223f, 0.18165715f, 0.00054893f, -0.02744905f, 0.30172652f, 0.12399130f, 
    0.43712905f, 0.00130206f, -0.13361660f, -0.29261339f, 0.10819333f, 0.01115785f, 0.12638964f, 0.38593304f, 
    0.07122637f, 0.20535365f, 0.11862502f, -0.21921761f, -0.23287679f, 0.02679115f, 0.01136383f, -0.10752787f, 
    -0.09917039f, -0.22704031f, 0.17378879f, -0.01374690f, 0.01718090f, 0.09542106f, -0.01332897f, 0.12060281f, 
    0.15410963f, -0.05369037f, 0.17228448f, -0.01626447f, -0.08873481f, -0.03687878f, -0.05168249f, 0.11351110f, 
    -0.38324103f, 0.11702276f, 0.02534175f, -0.54549575f, -0.06331243f, 0.10198556f, 0.16635567f, -0.03864428f, 
    -0.05999777f, -0.17808044f, -0.16472507f, -0.24103639f, -0.33510190f, -0.00949542f, -0.07462419f, -0.03369521f, 
    -0.20780967f, -0.07715564f, -0.11254333f, -0.04729354f, 0.15536502f, -0.12280665f, -0.78188407f, -0.09079401f, 
    0.01310485f, -0.05649330f, 0.19820207f, 0.14310937f, -0.08921472f, -0.37315664f, 0.10855822f, -0.73191750f, 
    -0.08088213f, 0.09982998f, 0.36182946f, 0.03487512f, 0.10978261f, 0.10049295f, -0.10125071f, 0.12971041f, 
    -0.03567265f, -0.19187666f, -0.19213310f, 0.11699638f, -0.07628955f, 0.14008825f, 0.16526294f, -0.10115872f, 
    -0.03185145f, 0.01065615f, 0.13902898f, -0.47847936f, 0.08542517f, 0.04901120f, -0.04466805f, -0.06070377f, 
    -0.34737185f, -0.27656668f, -0.04012446f, -0.10671441f, -0.03328418f, 0.03629022f, 0.00828406f, -0.00421418f, 
    0.14895576f, -0.18043496f, -0.00656742f, -0.32355431f, -0.23616943f, -0.08256567f, -0.06852932f, 0.07273698f, 
    0.10626591f, 0.08257388f, -0.23718703f, 0.00399098f, -0.18913586f, -0.22373325f, 0.17184483f, -0.15194124f, 
    0.17783819f, 0.02098670f, -0.04667182f, 0.07178906f, -0.10793728f, 0.06019842f, 0.03155646f, -0.13677278f, 
    0.19044253f, 0.04788292f, 0.00443211f, -0.03557083f, -0.11455957f, -0.23288469f, -0.44351280f, -0.12902498f, 
    0.12237111f, -0.05386137f, 0.19950111f, -0.05897091f, 0.32540855f, 0.30667225f, -0.08185742f, -0.06670246f, 
    0.09280983f, 0.05655491f, -0.07762002f, 0.11335209f, 0.03728245f, -0.13091719f, -0.19709384f, -0.17226848f, 
    0.03211001f, 0.08233727f, 0.07123966f, 0.10468683f, 0.07524062f, 0.15932907f, -0.01572404f, -0.17914303f, 
    0.00197663f, 0.12442548f, 0.11671995f, 0.04649678f, -0.03956789f, 0.00204798f, -0.20071100f, 0.14873019f, 
    0.14075974f, 0.01895691f, -0.08759490f, -0.05512417f, -0.01374973f, 0.19081540f, 0.43105027f, 0.19889289f, 
    0.02049651f, -0.27573568f, 0.30488569f, 0.21395253f, -0.29751420f, -0.20732918f, -0.16036627f, -0.04246961f, 
    0.06295604f, 0.11341325f, -0.05497539f, 0.04894222f, 0.15932699f, -0.02995193f, -0.05634340f, -0.09896885f, 
    -0.03387729f, 0.08893573f, 0.12207223f, -0.05632019f, 0.24130404f, 0.12426612f, 0.14737216f, -0.07892117f, 
    0.02067552f, 0.05009823f, 0.02381642f, -0.20659226f, -0.06275331f, 0.07384863f, -0.14486335f, 0.12253923f, 
    -0.20778415f, 0.33716217f, 0.00189680f, 0.16206576f, -0.23801102f, -0.03841578f, -0.03934952f, 0.46086824f, 
    0.40375903f, -0.00036161f, 0.10776865f, 0.29487470f, 0.10359138f, 0.13636775f, -0.49952266f, -0.45478889f, 
    0.39725298f, 0.01924485f, 0.19650008f, -0.09263209f, -0.13155992f, 0.17441168f, 0.15008803f, -0.06988354f, 
    -0.06610811f, -0.12063962f, -0.08484403f, 0.28044796f, -0.14536032f, 0.37750337f, -0.08637550f, 0.34558812f, 
    -0.06875881f, -0.17742464f, -0.14545368f, -0.15805568f, -0.15014914f, -0.14516971f, -0.06818373f, 0.07476756f, 
    0.14579840f, 0.07859244f, 0.19580789f, 0.06419247f, -0.36123616f, -0.37761506f, -0.07226232f, 0.05340871f, 
    0.03058319f, 0.09335880f, 0.14358547f, 0.24037725f, 0.21570635f, 0.07907674f, 0.32268557f, -0.06845021f, 
    0.29686788f, -0.03944744f, 0.34807172f, -0.00593233f, 0.31193382f, 0.07979068f, 0.02014979f, 0.25549898f, 
    0.00273595f, 0.24763164f, 0.13995634f, 0.04281491f, 0.67875385f, 0.11831686f, -0.49366885f, -0.06450837f, 
    0.13840957f, 0.19150506f, 0.22407000f, 0.39314508f, -0.23966868f, -0.04864258f, -0.41315237f, 0.27707347f, 
    -0.08558141f, 0.03630970f, -0.01492090f, 0.12725846f, 0.03246034f, 0.00200837f, -0.28319749f, -0.14282282f, 
    0.03944484f, -0.00973196f, -0.05774597f, -0.13714746f, 0.02426865f, -0.32135671f, 0.16676509f, -0.14996688f, 
    -0.17802182f, -0.09229098f, -0.26417965f, -0.19759096f, -0.31356740f, 0.06324738f, 0.10786493f, 0.18263493f, 
    -0.06039588f, -0.03181759f, -0.00322565f, -0.07658439f, 0.01138573f, -0.08917751f, -0.04769482f, -0.00462579f, 
    -0.02350594f, -0.03814165f, -0.03480151f, -0.03551886f, -0.05664378f, 0.04684405f, 0.03177055f, -0.06304251f, 
    -0.04840069f, 0.01205472f, 0.00353437f, 0.02971371f, -0.05202150f, -0.02734518f, -0.00291855f, -0.04491211f, 
    0.03736395f, 0.03375275f, -0.05898043f, -0.03407018f, -0.05092682f, -0.08588269f, -0.00936730f, -0.05318640f, 
    0.02737147f, 0.00447694f, -0.05649925f, 0.04060818f, 0.03029209f, 0.00143963f, -0.06455715f, 0.00391757f, 
    -0.07297454f, -0.03324032f, 0.02125300f, -0.00101501f, -0.05899013f, -0.02605811f, 0.00547942f, -0.03183819f, 
    -0.03477861f, 0.01931818f, -0.07155993f, -0.04028421f, -0.03679175f, -0.05496704f, 0.02518377f, -0.03357974f, 
    0.02457342f, 0.00095401f, -0.00132518f, 0.04482180f, -0.00990314f, 0.00653924f, -0.00722586f, 0.00638384f, 
    -0.03718792f, -0.06650204f, 0.00748635f, 0.04253670f, 0.02193062f, -0.00038003f, -0.05015133f, 0.04035083f, 
    -0.01417238f, -0.05305211f, -0.10141703f, 0.06358031f, 0.04235591f, 0.04825234f, -0.03096533f, -0.05597901f, 
    -0.01261883f, -0.02849646f, 0.00781487f, -0.02638577f, -0.02511608f, -0.04661040f, -0.04713989f, 0.02795791f, 
    0.00109856f, 0.03742716f, 0.02051741f, 0.03085247f, 0.03372849f, -0.01406529f, -0.01124642f, 0.04876064f, 
    0.02100819f, -0.03853037f, -0.05877117f, -0.06076743f, -0.06107921f, -0.03348863f, -0.04539471f, -0.01961903f, 
    -0.01765496f, -0.01271123f, -0.03737925f, -0.05386309f, 0.04838700f, -0.03210608f, -0.08095258f, -0.01732790f, 
    -0.06585638f, -0.02385650f, 0.01919083f, 0.01651134f, -0.04178841f, -0.06511956f, -0.02285018f, -0.01767186f, 
    -0.07278185f, -0.06790637f, -0.06989952f, -0.02185764f, 0.03682736f, 0.04018893f, 0.03943510f, -0.07442732f, 
    -0.08184355f, 0.03514607f, -0.01662326f, -0.02653286f, 0.01493219f, -0.03122324f, -0.07367350f, 0.04050809f, 
    -0.04317871f, -0.04216268f, -0.08592363f, -0.07767180f, -0.02570375f, -0.00883791f, -0.04071939f, -0.03723945f, 
    -0.00380121f, -0.04137750f, -0.05465994f, -0.05525817f, -0.01275685f, -0.01119868f, -0.04951822f, -0.04997629f, 
    -0.02268643f, 0.02210622f, -0.03690587f, -0.01946882f, -0.01356026f, -0.05718018f, -0.00237276f, 0.00231123f, 
    -0.00013153f, -0.04607757f, -0.02025374f, 0.00225265f, -0.03248190f, -0.02499964f, 0.03573262f, 0.03289476f, 
    -0.03997532f, -0.04736793f, -0.09000479f, -0.07728893f, 0.00925237f, 0.02410529f, -0.04421944f, -0.00133800f, 
    0.03844492f, -0.01854032f, 0.00507680f, -0.00650599f, 0.01435313f, -0.01249456f, -0.03592533f, -0.00868439f, 
    0.03549776f, 0.01807193f, 0.05587912f, -0.05735583f, -0.05102285f, -0.07371546f, -0.07997269f, -0.03514621f, 
    -0.05374619f, 0.01072452f, -0.00249194f, -0.07895133f, 0.01571760f, -0.09174588f, -0.04301380f, -0.00402004f, 
    0.02706999f, 0.02839595f, -0.05353986f, 0.00267385f, -0.02632806f, -0.09524080f, 0.08973289f, -0.05653218f, 
    -0.02366714f, -0.08946519f, -0.05600505f, 0.01030307f, -0.08179227f, -0.05810151f, -0.01476218f, -0.00155574f, 
    0.07597050f, -0.00834942f, 0.06257078f, -0.06695294f, -0.04238200f, 0.02142258f, -0.04994103f, 0.02646059f, 
    -0.00077853f, 0.02699196f, 0.02389968f, -0.04153106f, -0.06833035f, -0.01665266f, 0.04581767f, 0.02331403f, 
    -0.06399025f, -0.01008475f, -0.02479356f, 0.02253405f, -0.09418184f, -0.02353690f, -0.00276194f, 0.01185397f, 
    0.01032232f, -0.08317277f, -0.06535063f, 0.04650818f, -0.02453986f, -0.06710818f, 0.01989255f, -0.06717111f, 
    -0.03688610f, -0.00831744f, -0.03599941f, -0.01489402f, 0.01366768f, 0.02930750f, -0.01506161f, -0.03419802f, 
    -0.01732496f, -0.08473209f, -0.03502904f, -0.06612803f, 0.03762636f, -0.01661186f, -0.05149314f, -0.00529443f, 
    -0.05926711f, -0.02534581f, 0.00922985f, -0.00595189f, 0.00068833f, 0.01396173f, 0.04510402f, -0.00106617f, 
    0.02971565f, 0.03257930f, 0.00895400f, -0.00659737f, -0.02324258f, 0.01322144f, 0.01702370f, 0.01496469f, 
    0.03855314f, -0.04527644f, 0.00562763f, -0.00174825f, 0.01938547f, 0.01800880f, -0.02594304f, -0.04913017f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.07801384f, -0.11634354f, 0.14563248f, 0.00867564f, 0.04772694f, -0.12774681f, 0.21064128f, 0.23499438f, 
    0.06462541f, 0.02702645f, 0.37060407f, 0.25003266f, -0.18706253f, -0.04459788f, 0.25473839f, -0.04464000f, 
    0.29171786f, 0.27148509f, -0.00469918f, 0.06943506f, -0.04910862f, -0.06087941f, -0.04317950f, 0.27386335f, 
    -0.00528324f, -0.03154459f, -0.03899060f, -0.20046324f, 0.01210591f, 0.11983546f, 0.28665191f, -0.08863014f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.09306706f, 0.10129564f, 0.39619938f, 0.08391059f, 0.02570000f, 0.89316899f, -0.35483536f, -0.04385255f, 
    -0.37630531f, -0.04750495f, -0.01305549f, 0.11434897f, -0.16182858f, 0.14465494f, 0.09921186f, 0.11514854f, 
    -0.36190295f, -0.18850793f, -0.03977928f, 0.15630530f, 0.11989407f, 0.23551683f, 0.01767375f, -0.53837931f, 
    0.06760438f, 0.11795340f, -0.17401244f, 0.24599046f, 0.05115703f, -0.29374743f, -0.74312639f, 0.02528057f, 
    -0.28713930f, -0.28286284f, -0.14977065f, -0.10649600f, -0.06807237f, 0.11314287f, -0.15228200f, 0.08022165f, 
    0.17540309f, -0.02972477f, 0.22864166f, 0.37299401f, -0.47415277f, -0.09359815f, 0.36874363f, -0.00485015f, 
    0.38531873f, 0.26467082f, -0.10979545f, 0.27356517f, 0.11913671f, 0.00027283f, 0.04011774f, -0.11739562f, 
    0.00693858f, 0.05672728f, -0.11785784f, -0.11608147f, -0.05611945f, 0.31359139f, -0.40554151f, -0.05243478f, 
    -0.46295291f, 0.34322000f, -0.07976484f, 0.03015905f, 0.02242852f, -0.58962816f, 0.32307851f, -0.08998283f, 
    -0.26917610f, 0.08442487f, 0.03699123f, 0.23880403f, -0.04551292f, 0.07151991f, 0.38336480f, 0.04100654f, 
    -0.29249445f, -0.46506548f, 0.02507537f, -0.50118935f, -0.00660518f, -0.52600831f, -0.16834839f, 0.36290070f, 
    0.02586876f, -0.12753731f, -0.11903692f, -0.23641905f, -0.19573052f, -0.65749627f, -0.08627439f, -0.07586633f, 
    0.53249055f, -0.07273602f, -0.20002832f, 0.09226149f, 0.10745928f, -0.01000579f, 0.27266553f, -0.98764265f, 
    0.00144475f, 0.11194624f, -0.25268328f, -0.73267448f, 0.49702096f, -0.07356521f, 0.30923581f, -0.15013669f, 
    0.53612310f, -0.50058252f, 0.13040917f, -0.38916990f, 0.03150339f, -0.01535473f, 0.12280358f, -0.03186305f, 
    -0.06220828f, -0.17469145f, 0.01643639f, 0.45622575f, -0.92221993f, -0.48052967f, -0.46284813f, -0.10400134f, 
    -0.11652601f, 0.53896236f, 0.35200906f, -0.13438867f, -0.09015591f, -0.20129004f, -0.16017476f, -0.06606349f, 
    0.44295582f, -0.13120712f, -0.35514715f, 0.02195782f, 0.19205338f, -0.12593362f, -0.27323505f, -0.15687531f, 
    0.30770165f, -0.17421186f, -0.18112592f, 0.44420180f, -0.10354640f, 0.07613695f, 0.16812371f, -0.40978682f, 
    -0.05355260f, -0.05710931f, 0.14928947f, -0.43481576f, -0.11504448f, -0.04643152f, -0.15487969f, -0.13374145f, 
    -0.39340410f, -0.14403236f, -0.28803343f, -0.13753846f, 0.12571874f, -0.42479357f, -0.28640649f, -0.24917600f, 
    -0.12542500f, -0.16069698f, 0.24452853f, -0.18251415f, 0.14222994f, -0.00544958f, 0.13203368f, 0.04902050f, 
    0.19560367f, -0.20483108f, -0.10831636f, 0.46390733f, -0.13959117f, 0.33154264f, -0.15905926f, 0.13606566f, 
    0.08133950f, 0.09162223f, -0.15397272f, -0.05290455f, 0.58243358f, -0.17369327f, 0.14755245f, -0.01075219f, 
    -0.51267582f, -0.20808592f, 0.43499973f, -0.04075032f, 0.13498041f, -0.34755448f, -0.00275137f, 0.71379608f, 
    -0.78237987f, -0.13885759f, -0.41183466f, 0.09002986f, 0.16171800f, 0.04169574f, -0.31328401f, -0.02197705f, 
    -0.18119135f, 0.06466293f, -0.15076099f, -0.80926293f, -0.11218622f, -0.37006825f, 0.12163913f, 0.17079221f, 
    -0.09172383f, 0.01477312f, 0.06231866f, -0.15911393f, -0.21205398f, -0.41330996f, 0.39961550f, 0.11060885f, 
    0.50572753f, 0.07812785f, -0.25841251f, 0.16253509f, 0.16530532f, 0.37336719f, -0.10355951f, -0.23603874f, 
    -0.15712330f, 0.13757175f, -0.27067405f, 0.28156689f, -0.03378024f, -0.06476920f, -0.61653954f, -0.11775994f, 
    -0.13388316f, 0.32633090f, 0.06839592f, -0.53021681f, 0.02413207f, -0.03654698f, 0.00529155f, -0.16877432f, 
    0.11509591f, 0.04088492f, -0.06465406f, 0.41198343f, 0.38761523f, 0.14237864f, -0.20618151f, -0.14519338f, 
    0.52461231f, -0.57754302f, -0.28145599f, -0.16658191f, 0.02922680f, -0.22750525f, -0.32104737f, 0.10760543f, 
    0.34798101f, 0.13837023f, 0.00580804f, -0.13840346f, -0.48237914f, 0.03062335f, 0.11339374f, -0.03288969f, 
    -0.48024359f, 0.70277375f, 0.04117199f, -0.72320837f, 0.02487196f, 0.18001105f, -0.03233204f, 0.38000610f, 
    0.16666536f, -0.06120262f, 0.10024075f, 0.03036555f, -0.06134177f, -0.44911736f, -0.12229974f, -0.11459513f, 
    0.06608170f, -0.36095092f, 0.49828893f, 0.05125887f, 0.01433477f, 0.30321389f, 0.27107736f, -0.23871715f, 
    0.04346203f, 0.06745929f, 0.45352903f, -0.05695358f, 0.32240140f, 0.11496469f, -0.46571594f, -0.04396420f, 
    0.16181099f, -0.47235736f, -0.17193334f, -0.29219288f, 0.12114127f, -0.35729468f, -0.15680946f, -0.46400127f, 
    -0.01407520f, 0.14386024f, 0.04785015f, -0.54396242f, -0.30602050f, -0.45956662f, 0.68099338f, -0.05127641f, 
    -0.57433474f, -0.10348427f, 0.32262817f, -0.00799261f, -0.07781110f, -0.94777697f, -0.41499406f, -0.49202225f, 
    0.37550789f, -0.04060790f, -0.02737558f, 0.07686793f, -0.33360821f, -0.07506606f, 0.20855710f, 0.11198853f, 
    -0.11576334f, -0.35484484f, -0.02547676f, -0.66992396f, 0.09527995f, -0.07193512f, -0.18068045f, 0.14869943f, 
    -0.14456940f, -0.14478911f, -0.16990308f, 0.59186721f, -0.01966854f, 0.79699326f, 0.27493957f, -0.02813529f, 
    0.35500249f, 0.09484544f, -0.58680218f, -0.15328805f, -0.10734753f, -0.31457385f, -0.02774569f, 0.22198866f, 
    -0.23637180f, 0.04002233f, -0.09140277f, -0.19025807f, 0.11743754f, -0.16775759f, -0.66289866f, -0.04459321f, 
    -0.32865250f, -0.18569286f, -0.03863877f, -0.22299978f, 0.13077603f, -0.29651704f, -0.08923216f, 0.32762849f, 
    -0.15270245f, 0.16434444f, -0.00972157f, -0.42487016f, -0.69599682f, 1.22636533f, -0.11096879f, 0.14776893f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.24097963f, 0.16907160f, 0.35616377f, 0.19045140f, -0.16843727f, 0.09360048f, -0.18062995f, -0.36542639f, 
    -0.02026564f, 0.23204073f, -0.00641481f, 0.07197262f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
