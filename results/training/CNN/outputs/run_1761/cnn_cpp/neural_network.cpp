#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.46910113f, 0.53264099f, 0.25530800f, -0.85269296f, -0.77359974f, 0.38024703f, 0.17279202f, -0.11347425f, 
    -0.42111236f, 0.15285295f, 0.15961097f, 0.13620862f, 0.12241767f, -0.00009393f, -0.07612462f, -0.24798697f, 
    0.26765317f, 0.19556132f, 0.01506974f, -0.42252311f, 0.16296802f, -0.19851658f, -0.09571198f, -0.23023301f, 
    -0.12236850f, -1.12408125f, 0.18792200f, 0.05636831f, -0.63018805f, -0.47161674f, 0.00104051f, 0.50198704f, 
    -0.29670936f, -0.02014056f, 0.07965524f, -0.15471700f, -0.01931226f, -0.19457518f, -0.48721763f, -0.14122346f, 
    0.18923460f, 0.01494691f, 0.21508908f, 0.31313121f, 0.01105000f, -0.01523398f, 0.12772456f, 0.04396834f, 
    0.01253015f, -0.03429056f, -0.05456002f, 1.09625256f, 0.64894563f, -0.69794059f, 0.24851415f, -0.77668703f, 
    -0.26713958f, -0.10805257f, 0.46889126f, -0.22450747f, 0.00084572f, -0.00353228f, 0.01801833f, 0.08228812f, 
    -0.19655791f, 0.04979322f, -0.09083699f, 0.00284383f, 0.15357348f, -0.10186785f, -0.11519537f, 0.16378878f, 
    -0.07948046f, -0.00114251f, -0.05230359f, 0.55738693f, 0.42299271f, 0.39486450f, 0.06999685f, -0.33098131f, 
    -0.23277248f, 0.36111999f, 0.11424705f, -0.48322296f, 0.15549324f, 0.22941656f, -0.00597288f, -0.05963708f, 
    0.20376050f, -0.08229151f, -0.04302796f, -0.14094071f, -0.25232717f, -0.17506287f, 0.16650505f, -0.01416954f, 
    0.14905590f, -0.04056842f, 0.00667158f, 0.21842806f, -0.37865311f, -0.33016104f, 0.05065860f, -0.11132548f, 
    -0.27906898f, -0.43254349f, 0.12471692f, -0.47217685f, -0.25993547f, 0.20814373f, -0.19217405f, 0.01574953f, 
    -0.23389721f, -0.34481993f, -0.21188077f, 0.11690174f, -0.02464980f, 0.03022032f, 0.20544188f, 0.02458511f, 
    -0.04681856f, -0.32808247f, -0.08823082f, -0.27962220f, 0.16255760f, 0.39601618f, -0.16123371f, 0.25285965f, 
    0.28285989f, 0.69220465f, -0.21416141f, 0.01400371f, -0.49264669f, -0.46355578f, -0.35937646f, -0.21558568f, 
    0.23806426f, 0.30193725f, -0.08237241f, -0.08228283f, -0.35275921f, -0.08596767f, 0.12067726f, 0.13807084f, 
    0.21855931f, 0.20945889f, -0.04365736f, -0.14353803f, 0.33650830f, -0.13434322f, 0.48937386f, 0.30226162f, 
    0.20703922f, -0.04149873f, -0.32852468f, 0.09299695f, 0.13369408f, 0.03608471f, 0.09346521f, -0.13870591f, 
    0.10669696f, 0.06744937f, 0.15567391f, 0.17163394f, 0.03247710f, 0.46520919f, 0.09098840f, -0.45365843f, 
    -0.04366013f, 0.02244418f, 0.21905464f, 0.31001619f, 0.01621661f, 0.00435434f, 0.38383710f, -1.17076302f, 
    -0.15210783f, -0.17103319f, 0.55600411f, 0.52467060f, 0.35953829f, 0.54508752f, 0.15541670f, 0.19360276f, 
    -0.39082050f, -0.12793149f, 0.35649380f, -0.26066032f, 0.55547607f, -0.49934161f, 0.01445523f, -0.07234111f, 
    -0.07639825f, -0.14209174f, 0.10627088f, -0.06989993f, 0.01288966f, -0.07829157f, 0.20391138f, -0.10450422f, 
    0.42587662f, -0.10384235f, -0.63470030f, -0.40839472f, -0.17962350f, -0.02959939f, -0.03798657f, -0.03902562f, 
    -0.03462054f, -0.34371436f, -0.09672975f, -0.14635225f, 0.38187510f, -0.22675608f, -0.31869376f, -0.20661393f, 
    0.08685127f, 0.15167744f, -0.42013985f, -0.40240741f, 0.09324158f, 0.37916088f, 0.22568762f, 0.24098945f, 
    0.50748575f, 0.51346660f, -0.32615921f, 0.20220335f, 0.08011574f, 0.04177759f, -0.17184265f, -0.15156379f, 
    0.11708002f, 0.01878915f, 0.05618850f, 0.54269993f, -0.46390083f, -0.24480283f, -0.18579201f, 0.49906728f, 
    -0.35320807f, 0.09696607f, 0.11081192f, 0.26066154f, 0.11431106f, 0.00595439f, -0.06879509f, 0.20601684f, 
    -0.26298296f, 0.27171764f, -0.47069022f, -0.36958909f, -0.27974385f, -0.01646456f, 0.15744101f, -0.46688321f, 
    -0.65174389f, -0.67645174f, -0.13577917f, 0.02602167f, 0.21910721f, 0.37735897f, 0.32127553f, -0.16473761f, 
    0.13822931f, -0.13858902f, 0.06635002f, -0.18055490f, -0.34411243f, -0.13869599f, 0.14400166f, -0.08510344f, 
    -0.09798798f, -0.07900755f, -0.13093999f, 0.41621923f, 0.13738331f, -0.09110615f, 0.09429967f, -0.08709279f, 
    0.11129631f, -0.12846440f, 0.02874902f, 0.51266491f, 0.02082334f, 0.31353512f, -0.35650399f, -0.11188811f, 
    -0.10755371f, -0.38804504f, -0.26167354f, 0.12387401f, 0.30222020f, -0.08856956f, 0.21126471f, 0.05503205f, 
    -0.24189381f, -0.40762052f, -0.02064354f, 0.36358750f, -0.25054827f, 0.02110490f, 0.23040739f, -0.00429497f, 
    -0.11797120f, 0.64676219f, 0.03657052f, -0.28950882f, -0.19064517f, 0.53213996f, 0.13833113f, 0.18922672f, 
    -0.25367120f, -0.15167002f, 0.02734281f, -0.12908633f, -0.37781215f, -0.01812420f, 0.29667154f, -0.27019799f, 
    -0.02992677f, 0.35798270f, -0.23297936f, 0.25377423f, 0.11781558f, -0.30036780f, -0.66869134f, -0.51547855f, 
    -0.60829163f, -0.32126451f, 0.23915996f, 0.18041256f, 0.08139857f, 0.42235097f, 0.20143567f, -0.13157292f, 
    0.18405995f, -0.02437378f, 0.06793717f, -0.18869179f, -0.31298786f, -0.44454691f, -0.03684663f, 0.24634339f, 
    -0.12621062f, -0.16219324f, 0.04022159f, -0.28971276f, 0.09860060f, 0.22972479f, -0.83502740f, -0.88516921f, 
    0.27901199f, 0.63298965f, 0.72634959f, 0.14577790f, 0.00176079f, -0.57019436f, -0.05729467f, 0.47030160f, 
    -0.07783973f, 0.14558864f, -0.31476346f, -0.00442353f, -0.05000621f, 0.07516549f, -0.04901768f, 0.07319341f, 
    -0.00794835f, 0.16202883f, -0.08416265f, -0.12861806f, -0.01906315f, -0.04018430f, 0.03886895f, 0.30042982f, 
    0.45224205f, 0.18236332f, 0.27143875f, 0.00110888f, -0.11909486f, 0.19154537f, -0.27785584f, -0.06350373f, 
    -0.33677733f, -0.14374249f, -0.33889654f, -0.12239864f, 0.07858511f, 0.00225571f, 0.07636002f, 0.12471176f, 
    -0.12847759f, -0.01172067f, -0.17528698f, -0.27576101f, -0.15077819f, -0.25837848f, -0.32904878f, -0.34309441f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06375433f, -0.10678701f, 0.15976027f, 0.19017434f, 0.02312061f, 0.04559825f, -0.12726058f, 0.14097416f, 
    0.00418864f, -0.00037516f, 0.03533113f, -0.03088453f, 0.30173206f, 0.28886163f, 0.22071485f, -0.11093134f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.40701297f, 0.10628086f, 0.14470664f, -0.08728917f, -0.05661553f, 0.22016943f, -0.06315275f, 0.12028597f, 
    0.02504361f, 0.09448313f, -0.06038070f, -0.02357574f, -0.07962457f, 0.27842775f, -0.21640733f, -0.08694761f, 
    -0.00633172f, 0.18950351f, 0.05374788f, 0.18046646f, 0.05159105f, 0.03627332f, -0.02424805f, 0.01969693f, 
    -0.22801620f, 0.11194582f, 0.25733405f, 0.27261823f, 0.28326881f, -0.13472441f, 0.01533803f, 0.06671060f, 
    0.05116702f, -0.02762914f, -0.01529170f, 0.11808188f, -0.24156675f, 0.30197123f, -0.09004807f, -0.07290863f, 
    0.04919554f, 0.00321507f, -0.03862082f, -0.05808251f, 0.03509507f, -0.03354613f, 0.01457006f, 0.00567199f, 
    0.17920086f, 0.08690010f, 0.04011102f, -0.22392669f, 0.08737496f, -0.06845289f, -0.16825068f, 0.09449378f, 
    0.02874874f, -0.02901087f, 0.01267609f, -0.00725342f, 0.32715622f, 0.30317688f, -0.04419190f, -0.12140444f, 
    -0.10439345f, -0.02874721f, 0.02809943f, -0.03205366f, -0.02598390f, 0.11373650f, -0.05850007f, -0.02675885f, 
    -0.50186729f, 0.07867452f, -0.11124123f, -0.03828609f, -0.12247914f, -0.20031349f, -0.31145856f, 0.00152732f, 
    -0.03296368f, -0.10728408f, -0.00688356f, 0.01497734f, 0.19479854f, -0.05790485f, -0.40520316f, 0.20765030f, 
    -0.13827607f, 0.01701676f, -0.03800673f, 0.00140796f, 0.23584631f, -0.10702214f, -0.02472509f, 0.09323553f, 
    0.01620496f, -0.08337297f, -0.02625791f, 0.02483429f, 0.07368491f, -0.00525049f, 0.09962182f, 0.03367209f, 
    0.02757384f, 0.05011244f, -0.07394963f, 0.29182237f, 0.09548928f, -0.12889718f, 0.10936445f, -0.48304588f, 
    -0.02468216f, 0.04273869f, -0.23044042f, -0.00919023f, -0.02406735f, -0.02322960f, -0.02268169f, 0.11057223f, 
    0.23389502f, -0.13616437f, -0.12290923f, -0.20093149f, -0.03585060f, -0.03284841f, 0.06891281f, 0.09783924f, 
    0.12678672f, 0.00717730f, 0.01060946f, 0.02978416f, 0.00912370f, -0.10758624f, 0.22878279f, -0.13561368f, 
    0.03914953f, -0.05174107f, -0.05079925f, -0.10697312f, 0.03357207f, 0.17796203f, 0.06965207f, -0.07033024f, 
    0.16450925f, -0.27666572f, 0.14579368f, 0.05764457f, 0.00533851f, 0.07374272f, -0.03950092f, 0.05685125f, 
    -0.01805795f, 0.14172670f, 0.05042531f, 0.12802827f, 0.10099526f, -0.07724241f, -0.13868934f, -0.11902136f, 
    0.16536775f, 0.06400800f, 0.11759704f, 0.04471282f, 0.14833277f, -0.16173124f, 0.10382761f, 0.00964490f, 
    0.30241051f, 0.24358861f, 0.22788511f, -0.22672664f, 0.21526949f, 0.01478340f, 0.05996972f, -0.07689195f, 
    0.28096581f, 0.02805765f, 0.09112697f, 0.19379517f, -0.16440487f, -0.07633410f, 0.05692597f, -0.09481091f, 
    0.06482907f, 0.04793850f, 0.08918212f, 0.13337161f, -0.00074435f, -0.15583402f, 0.03798352f, -0.11815561f, 
    0.15495723f, -0.27658641f, -0.09639186f, 0.05630272f, -0.04268435f, -0.10570688f, -0.04431365f, -0.06756676f, 
    0.09862100f, 0.03250202f, -0.03195987f, 0.00276900f, -0.01163163f, 0.18285577f, -0.07791547f, -0.28858635f, 
    0.06791040f, 0.03412781f, 0.15400580f, 0.07008453f, -0.09990351f, 0.03922183f, 0.13928553f, -0.00158058f, 
    -0.37066552f, 0.27669528f, 0.10136554f, 0.31238502f, -0.03158366f, 0.00954407f, -0.00466128f, -0.07158649f, 
    0.14357536f, -0.10321051f, -0.02816099f, 0.07868196f, 0.09680539f, 0.11321401f, -0.01038637f, 0.36499622f, 
    -0.11671001f, -0.16800985f, -0.15480344f, -0.13541040f, 0.00563454f, 0.15589301f, -0.06288239f, 0.10006820f, 
    0.08766147f, 0.13738397f, -0.14152281f, -0.19482468f, 0.22641031f, 0.08834281f, -0.04010832f, 0.11978552f, 
    -0.10890023f, 0.08907238f, 0.01409310f, -0.05344956f, -0.18296631f, 0.24608016f, -0.03760435f, -0.11085138f, 
    -0.03858789f, -0.14164458f, 0.13089843f, 0.12447173f, -0.03243893f, -0.03023449f, -0.00610407f, -0.28515136f, 
    -0.07604990f, -0.13415867f, -0.10223373f, 0.11608817f, -0.24410391f, -0.03472576f, 0.02982182f, 0.03483626f, 
    -0.06289358f, -0.16804081f, -0.07398042f, 0.10232940f, 0.56027055f, 0.24451686f, -0.03937186f, 0.08124027f, 
    -0.44430721f, -0.01547282f, -0.01027180f, -0.35298026f, 0.08338907f, -0.05007479f, 0.03347670f, -0.10875273f, 
    0.06231125f, -0.12282169f, -0.21447375f, -0.10192275f, 0.06275134f, 0.14247267f, 0.13159622f, 0.11156154f, 
    -0.10409008f, -0.25893012f, -0.13160308f, 0.09714641f, 0.03558665f, -0.25981972f, 0.12930602f, -0.27769661f, 
    -0.09284364f, -0.29513258f, 0.05245656f, 0.11297489f, 0.11491555f, 0.27456278f, -0.19039029f, 0.00372843f, 
    0.16263291f, 0.22597250f, 0.04611799f, -0.23075458f, 0.17070116f, 0.26022899f, 0.00305420f, 0.12455873f, 
    0.06132556f, -0.03209972f, -0.02574574f, 0.03705037f, 0.05899550f, 0.18240111f, 0.05271518f, 0.11448344f, 
    -0.03281539f, 0.02981099f, -0.02344833f, -0.01101882f, 0.06437235f, 0.03293570f, -0.01807019f, -0.03048385f, 
    0.22820477f, -0.06319354f, 0.14524193f, 0.06562711f, -0.19609527f, 0.00810559f, -0.10970324f, 0.05263942f, 
    0.12442136f, -0.04734440f, 0.13779652f, 0.00023806f, 0.06472957f, 0.10255284f, -0.18009283f, -0.17481768f, 
    0.01341997f, -0.02894711f, -0.05608308f, -0.11864527f, 0.09974270f, -0.05255759f, 0.03217407f, -0.07288171f, 
    0.42927724f, 0.24882546f, 0.30481991f, -0.11310901f, 0.00745502f, 0.05195396f, 0.05148743f, 0.00675379f, 
    0.03438292f, -0.02887449f, 0.04917612f, -0.08560354f, 0.25241917f, 0.01497036f, 0.15758093f, 0.05495027f, 
    -0.16694504f, 0.02033286f, -0.03444670f, 0.03006540f, -0.11424319f, -0.11746943f, -0.08893510f, 0.05804651f, 
    0.07908607f, -0.12802373f, -0.11787519f, 0.38931379f, 0.00467542f, -0.12167226f, -0.03008382f, -0.10766751f, 
    0.16894639f, 0.06778595f, 0.18288521f, 0.24741849f, 0.12823905f, 0.11869910f, 0.02990320f, -0.05272751f, 
    0.22465524f, 0.02662470f, 0.08975071f, -0.02609257f, 0.04835101f, -0.10053555f, 0.05291737f, 0.03563734f, 
    0.19021064f, 0.14764361f, -0.04564203f, 0.19953340f, -0.02010475f, 0.11644465f, 0.03947068f, 0.02525604f, 
    -0.01771891f, -0.26348001f, 0.06573649f, -0.14517123f, -0.25050300f, -0.23806019f, -0.09876163f, 0.31455505f, 
    0.01086775f, 0.07386096f, -0.20056699f, -0.04436066f, -0.09718086f, -0.07555966f, -0.14671221f, -0.19852108f, 
    0.15809469f, 0.24812914f, -0.07373685f, -0.03338576f, 0.08155245f, -0.01129173f, 0.10924003f, 0.13288966f, 
    0.02318608f, 0.08654773f, 0.08965489f, 0.04238183f, -0.03480200f, 0.05220555f, -0.09527609f, -0.18258259f, 
    0.08368310f, 0.05894061f, 0.12467535f, -0.03823870f, -0.23394218f, -0.11042506f, -0.30857104f, -0.19734533f, 
    -0.24786212f, -0.17291482f, -0.14252093f, 0.18899457f, 0.15957622f, 0.05731981f, 0.02941767f, 0.17563564f, 
    -0.13226396f, -0.18988124f, -0.04879551f, -0.40547094f, 0.49699065f, -0.29868278f, -0.02674499f, -0.27122521f, 
    -0.23578562f, 0.07636322f, 0.01129439f, -0.03019941f, 0.08558074f, 0.08268718f, 0.15069342f, -0.01775025f, 
    0.14570285f, -0.02435053f, -0.04176456f, 0.02403360f, 0.23268558f, 0.03996722f, -0.07765809f, 0.29764807f, 
    -0.18917026f, -0.16273524f, -0.05165257f, -0.23042503f, -0.28746805f, -0.32213438f, -0.17816496f, -0.23591585f, 
    0.02022841f, -0.14414230f, -0.12886356f, 0.05338122f, 0.07130288f, -0.25189179f, -0.38826168f, -0.33257404f, 
    0.32491723f, 0.31448272f, 0.10461004f, -0.04822440f, 0.04298504f, 0.04239237f, -0.10047690f, -0.03993570f, 
    -0.00240164f, 0.01055383f, 0.08985841f, 0.17873539f, -0.14517663f, -0.36106631f, 0.02412604f, -0.04694302f, 
    -0.17285721f, 0.03404668f, -0.08151513f, 0.18301864f, 0.05587419f, 0.11446480f, -0.01380272f, -0.10555102f, 
    -0.08140289f, 0.15205657f, -0.33665919f, 0.12785073f, -0.05456864f, -0.13150916f, 0.03556976f, -0.11161415f, 
    -0.08868081f, -0.10137216f, -0.12215407f, -0.14376558f, 0.10998204f, 0.05494910f, 0.09069493f, 0.15321141f, 
    -0.02638950f, -0.20225996f, -0.05236055f, -0.07025468f, 0.07801278f, 0.02483171f, 0.00852513f, -0.09628107f, 
    0.48086125f, 0.16176686f, 0.09628243f, -0.16257325f, 0.00150056f, -0.00133035f, 0.07025990f, -0.24772783f, 
    0.01226676f, 0.06655076f, 0.07132364f, -0.00857865f, 0.24606204f, 0.18921396f, 0.08766109f, 0.24557318f, 
    -0.10533011f, -0.06863011f, 0.03817380f, 0.16510086f, 0.07637786f, -0.03501403f, -0.12667999f, 0.29699144f, 
    0.26312077f, 0.39174739f, 0.03473925f, -0.33872294f, 0.13103902f, 0.01042487f, -0.05949686f, -0.16403869f, 
    0.06328382f, 0.12650959f, 0.17006731f, 0.16433646f, -0.37978289f, -0.06031950f, 0.00890868f, -0.00048581f, 
    -0.06449170f, -0.19423747f, 0.13089028f, -0.12244499f, 0.05119590f, -0.06489192f, 0.04236979f, -0.06134207f, 
    0.09532121f, -0.09545726f, -0.34568214f, 0.05500129f, 0.07896847f, 0.12894072f, 0.10743488f, -0.03806664f, 
    -0.01425994f, -0.03203904f, -0.04469759f, -0.06526949f, 0.19642757f, -0.22763176f, 0.07645423f, 0.12624000f, 
    0.00841897f, -0.00517457f, 0.02831066f, 0.09285703f, -0.04522369f, -0.00991046f, -0.07945024f, -0.07129511f, 
    -0.27009287f, -0.16675463f, 0.10417478f, 0.09833708f, -0.17894059f, 0.01982123f, 0.09345742f, 0.05724453f, 
    0.06149755f, 0.11508787f, 0.22249942f, 0.06462663f, 0.34299919f, -0.18052201f, 0.06189082f, 0.02453306f, 
    0.18479890f, 0.27367520f, 0.07284845f, 0.19004932f, 0.04750877f, -0.04982765f, -0.10158595f, 0.02331420f, 
    0.13891271f, -0.09944067f, -0.07548796f, 0.03315827f, 0.17947610f, -0.05124107f, 0.03268107f, 0.07789504f, 
    0.04885351f, -0.04498166f, -0.13880336f, -0.15647009f, -0.32790369f, -0.42059591f, 0.40911996f, 0.43287343f, 
    0.11218886f, -0.15459053f, -0.11016628f, 0.14549233f, 0.05329239f, 0.15537898f, 0.14202671f, 0.12024420f, 
    0.15331385f, 0.11480345f, 0.18721075f, -0.21601875f, -0.09943940f, -0.26714307f, -0.14285327f, 0.09503563f, 
    -0.02056095f, -0.04256557f, -0.08188458f, -0.27049905f, 0.04262905f, -0.04205627f, -0.06476841f, 0.14021859f, 
    0.11843994f, -0.04957186f, -0.03338661f, 0.10012653f, 0.08336062f, -0.07181234f, -0.10479745f, 0.04108298f, 
    -0.03934274f, -0.09112519f, 0.26495141f, 0.00626064f, -0.16857803f, -0.29398710f, -0.05640217f, -0.16505699f, 
    0.05794192f, 0.08778743f, 0.03275626f, 0.07010665f, 0.13825424f, -0.31616697f, -0.05384702f, 0.07600139f, 
    0.09293585f, -0.10764164f, 0.11437364f, 0.09971485f, -0.06854941f, 0.20575304f, -0.08446792f, 0.19958828f, 
    -0.10076830f, 0.01670582f, -0.08601713f, 0.08467494f, 0.17358607f, -0.07677436f, -0.12083649f, -0.06069345f, 
    -0.06956068f, 0.12182838f, -0.14620212f, 0.03122629f, 0.04585792f, 0.00436478f, 0.18047664f, 0.14411999f, 
    0.09428392f, -0.11067481f, -0.10569752f, 0.02692320f, -0.14218441f, 0.08160814f, -0.05792182f, 0.18940388f, 
    -0.20823748f, -0.42251974f, 0.16411760f, 0.32573596f, -0.09759533f, 0.07019246f, 0.06067755f, 0.23556368f, 
    -0.13473201f, 0.11658480f, 0.08050205f, 0.02483619f, 0.13035227f, 0.09087379f, -0.08479211f, 0.17144080f, 
    0.06254233f, 0.05293124f, 0.13735044f, 0.10595901f, 0.09509540f, 0.02305179f, 0.00260072f, 0.01240865f, 
    -0.07892261f, 0.36855361f, 0.23649806f, -0.29938087f, -0.00634657f, 0.03544299f, 0.04910006f, 0.05979714f, 
    0.08324474f, 0.06517466f, 0.00218500f, -0.04751686f, -0.38438928f, 0.05561854f, 0.02230470f, -0.05273492f, 
    -0.04348023f, 0.10055827f, 0.11972550f, 0.29342368f, -0.07475221f, -0.06004429f, -0.06074976f, 0.05949996f, 
    -0.54514503f, 0.10546754f, -0.33686900f, 0.14233339f, -0.00099340f, -0.17820901f, 0.04834441f, 0.02972703f, 
    -0.05366782f, -0.06078604f, -0.07185344f, 0.04434703f, -0.15682046f, -0.10956058f, -0.19271596f, 0.05055716f, 
    0.07719790f, -0.03404251f, -0.02459399f, -0.13252194f, 0.08273882f, 0.05908529f, -0.06075509f, 0.08480833f, 
    0.02931069f, 0.03029918f, 0.25286302f, -0.02899625f, 0.08519353f, 0.10426434f, -0.06844480f, 0.13960551f, 
    0.00093776f, -0.01675822f, 0.06295339f, 0.06919356f, 0.26774567f, -0.28984675f, -0.13096473f, -0.39007431f, 
    -0.07605483f, -0.09803282f, -0.11033414f, 0.06218631f, 0.02093516f, 0.04153588f, -0.14838202f, -0.08056029f, 
    -0.42906666f, -0.19254652f, -0.10305020f, -0.05856715f, -0.01525330f, -0.10076441f, -0.00094989f, 0.01802969f, 
    0.08147102f, 0.12508138f, -0.00054862f, 0.13109495f, -0.21019103f, 0.13065010f, -0.01014758f, 0.43281543f, 
    0.06978528f, -0.02630208f, -0.30907890f, -0.10640126f, 0.13766919f, -0.03805763f, 0.05709248f, 0.10492270f, 
    0.10976717f, 0.05459641f, 0.06940416f, -0.07223116f, -0.12158278f, 0.12068576f, 0.03177114f, 0.17156424f, 
    0.01487766f, 0.02997962f, 0.06974314f, 0.04455337f, 0.13753983f, -0.25311065f, -0.23801453f, -0.29750621f, 
    0.06582268f, 0.03704314f, -0.09901128f, 0.03994743f, 0.03199869f, 0.07406032f, -0.08750493f, 0.19197954f, 
    -0.07326375f, -0.20076582f, 0.01434421f, 0.03725635f, 0.05597190f, 0.00614186f, 0.14066204f, 0.07400578f, 
    -0.09026078f, 0.14288238f, 0.06250261f, 0.00808315f, -0.09405864f, -0.29672495f, -0.15807959f, -0.06143408f, 
    -0.03446028f, -0.07529625f, 0.03018720f, -0.23453972f, 0.09552000f, 0.02886917f, 0.09280325f, 0.02910520f, 
    -0.02442013f, -0.18596371f, 0.22335126f, 0.01913900f, 0.00654937f, 0.02318766f, -0.10878973f, 0.04808623f, 
    0.26612779f, 0.18388067f, 0.04169721f, 0.10660923f, 0.18388714f, 0.03183050f, 0.17960063f, -0.02502885f, 
    0.09401229f, 0.08927450f, -0.06393847f, -0.00389026f, 0.00269444f, -0.01541895f, -0.00083318f, 0.10169882f, 
    0.06852865f, -0.11814813f, 0.10006420f, 0.18473092f, 0.00567973f, 0.15102279f, -0.00677369f, 0.20210232f, 
    0.09265479f, -0.02700572f, 0.03030235f, 0.01003841f, -0.10370648f, -0.20618452f, -0.17972142f, -0.01681282f, 
    0.09525492f, 0.04738433f, 0.03954777f, 0.06637901f, 0.03184449f, -0.23684141f, 0.01311106f, -0.16528632f, 
    -0.33293262f, 0.11876589f, 0.15245438f, 0.01718135f, -0.10788907f, 0.05058485f, 0.02640011f, 0.11522053f, 
    0.02421675f, 0.00470105f, -0.17632179f, -0.13313103f, 0.05487681f, -0.09534291f, -0.07159781f, -0.06423323f, 
    -0.00449934f, 0.12504147f, 0.00921040f, 0.13543916f, 0.02824048f, 0.10951792f, 0.01287430f, 0.09097818f, 
    0.05553997f, 0.41645440f, 0.17799097f, 0.03606289f, -0.00241881f, -0.18471524f, -0.00671798f, 0.01192519f, 
    -0.00672631f, -0.09721016f, -0.00697181f, -0.02180278f, 0.11726674f, 0.22383656f, 0.05105730f, -0.10032666f, 
    -0.04214003f, -0.10171933f, 0.03951885f, -0.02362518f, 0.08023988f, -0.07573535f, -0.06886841f, 0.00100447f, 
    -0.00076056f, -0.04049829f, -0.07580502f, -0.11818624f, 0.09800857f, 0.01642444f, -0.08266992f, 0.01438779f, 
    -0.00410485f, -0.03734102f, 0.00826099f, 0.01185075f, 0.26905906f, -0.07156454f, 0.08528559f, 0.04304815f, 
    -0.01588721f, 0.00198435f, 0.06380512f, -0.05418150f, -0.12527825f, 0.00739238f, 0.02570975f, -0.01593659f, 
    -0.10135853f, 0.06988899f, -0.04802027f, 0.02397156f, -0.03566070f, 0.00880398f, -0.12364357f, -0.05589158f, 
    0.11323493f, -0.00541540f, 0.02299714f, 0.10969111f, 0.19632360f, 0.47821888f, -0.43165010f, 0.13457115f, 
    -0.04673616f, 0.13894773f, -0.05319158f, -0.27232230f, 0.04020779f, -0.09993920f, -0.04311277f, 0.12393995f, 
    0.08455466f, -0.02022198f, -0.03488199f, 0.13964570f, 0.07419311f, 0.07664506f, 0.18144467f, 0.09114888f, 
    0.04483811f, 0.13719089f, 0.01346448f, 0.23956949f, 0.16431327f, 0.02554888f, 0.11543390f, -0.35408986f, 
    0.01152098f, 0.07093721f, -0.01017758f, -0.14245936f, -0.08100943f, 0.16682416f, -0.05991141f, -0.04248077f, 
    -0.00625162f, -0.15096734f, -0.10258114f, 0.00633385f, 0.04482943f, 0.18237904f, 0.21325260f, 0.23175579f, 
    -0.04465028f, -0.04873679f, -0.07218439f, 0.02678316f, -0.04929198f, 0.09288888f, 0.20785297f, 0.00432640f, 
    -0.02569984f, -0.03952302f, -0.08166615f, -0.27383038f, 0.01936216f, 0.15978324f, 0.15416326f, 0.02820514f, 
    0.20119232f, -0.12888709f, 0.18708499f, 0.21544349f, -0.18869431f, 0.08387686f, -0.03460281f, -0.00207559f, 
    0.17949484f, 0.08160024f, 0.03980747f, 0.06798337f, -0.04528271f, -0.28039622f, -0.16165687f, -0.12907715f, 
    0.08483443f, 0.03558666f, 0.08779138f, -0.00922782f, 0.07414382f, 0.02500948f, 0.05689219f, 0.01582064f, 
    -0.02659271f, 0.32896766f, -0.08209965f, -0.04686359f, 0.15588108f, 0.13036953f, -0.05523263f, -0.12494704f, 
    0.05557647f, 0.08509047f, 0.11444497f, 0.16194342f, 0.06204103f, -0.08448920f, 0.02835925f, 0.00194968f, 
    -0.07191110f, 0.02251854f, 0.15670210f, 0.03474280f, -0.03161933f, -0.15881351f, 0.05204197f, -0.22076482f, 
    -0.05077196f, 0.00970950f, -0.01906151f, 0.01504220f, -0.00032737f, -0.06873706f, 0.05879810f, 0.01875937f, 
    -0.05088508f, 0.03022217f, -0.01588162f, -0.03225031f, 0.03935814f, 0.05165501f, 0.01276709f, -0.01049769f, 
    -0.02634490f, -0.03377342f, 0.03838111f, -0.05909137f, 0.00893924f, -0.06003176f, -0.05053249f, -0.00275134f, 
    -0.06522088f, 0.00143077f, -0.04002873f, -0.01672287f, 0.04078066f, -0.06221991f, -0.02170351f, -0.06990258f, 
    0.02003745f, -0.01947753f, 0.05103077f, 0.06229290f, -0.06080857f, 0.02277904f, -0.00655644f, -0.07669700f, 
    0.00829678f, 0.06039552f, -0.04503787f, -0.07243908f, -0.00200232f, -0.02774813f, -0.02774400f, 0.01161653f, 
    -0.06620710f, 0.01091480f, -0.07858492f, -0.08034150f, -0.04386313f, -0.04975584f, -0.07265711f, -0.05565275f, 
    -0.02769121f, 0.01087294f, -0.06428380f, 0.04003404f, -0.05460783f, -0.05996674f, -0.06253389f, -0.05804906f, 
    0.05138062f, 0.00841188f, -0.01834750f, -0.04051125f, 0.02991702f, 0.04870135f, -0.05698079f, -0.01466456f, 
    0.02652598f, -0.06010298f, 0.03377913f, 0.03495681f, -0.05024195f, -0.05315565f, -0.05315314f, 0.06170998f, 
    -0.02387297f, -0.07071909f, -0.02916254f, -0.07130039f, -0.05932169f, -0.02173389f, -0.07799356f, -0.06257447f, 
    0.03398112f, -0.04536584f, 0.05172275f, -0.04347880f, -0.07655950f, -0.07369138f, 0.04863154f, 0.00206089f, 
    0.04407949f, -0.02818265f, 0.00943238f, -0.06871209f, -0.06346405f, 0.00218753f, 0.01881840f, 0.03322569f, 
    -0.02778234f, -0.07705712f, -0.03693313f, 0.01106542f, -0.02675146f, -0.04059990f, 0.00839816f, -0.03998483f, 
    0.04936944f, 0.01757191f, -0.01334471f, -0.00111680f, -0.06283582f, 0.04912229f, -0.00161901f, 0.05791849f, 
    -0.06245507f, 0.04032492f, -0.05047864f, -0.01737266f, 0.01347918f, 0.05602969f, -0.05135838f, -0.01360695f, 
    -0.01529865f, -0.03270755f, -0.06529722f, -0.02305188f, -0.00983403f, 0.03647473f, 0.01672277f, -0.04056663f, 
    0.02485683f, -0.07320391f, -0.04536387f, 0.05725488f, 0.01005861f, -0.07151379f, -0.05571880f, -0.01736650f, 
    -0.02641749f, -0.00519317f, -0.03657137f, -0.04930294f, 0.02510889f, 0.01857440f, -0.05620523f, 0.06088887f, 
    -0.01559486f, 0.05418643f, 0.02082974f, -0.04635996f, 0.02502595f, -0.05702426f, -0.01557079f, -0.02463404f, 
    0.03129466f, 0.03621898f, 0.02988518f, 0.05133008f, -0.03095128f, 0.03352292f, -0.06069171f, -0.02744732f, 
    -0.00615210f, 0.02005785f, 0.01033550f, 0.03198296f, 0.05569124f, 0.04622037f, -0.00935074f, 0.04268765f, 
    -0.00635403f, 0.04743588f, 0.05002873f, -0.02132891f, -0.06637798f, 0.02627848f, 0.04182335f, -0.07449043f, 
    0.04471803f, 0.00503011f, 0.06225487f, 0.02289444f, 0.01107427f, -0.07903591f, 0.04424434f, 0.00801192f, 
    -0.31081134f, -0.04558210f, 0.06496599f, 0.35488328f, -0.11418830f, -0.10515670f, 0.24300016f, 0.14699666f, 
    -0.15315334f, -0.15276957f, 0.08235189f, -0.08994152f, 0.21213178f, -0.28434917f, 0.09373377f, 0.16679551f, 
    0.12476876f, 0.00700102f, -0.01886009f, -0.04234245f, -0.00186382f, 0.00709644f, 0.04811175f, 0.05453212f, 
    0.38832116f, 0.16073690f, 0.29863077f, -0.15631540f, -0.13511717f, 0.05457400f, 0.10009522f, -0.00732714f, 
    -0.24040668f, 0.13218895f, -0.12845048f, 0.04856816f, 0.02298599f, 0.18195209f, 0.15776388f, -0.18940078f, 
    -0.17296104f, -0.05695713f, 0.07788622f, -0.08428145f, -0.04567974f, -0.11366507f, 0.03221281f, 0.00286468f, 
    -0.00624256f, -0.17703331f, -0.10927559f, 0.07525163f, -0.01559510f, 0.11610509f, 0.12773712f, -0.09584511f, 
    -0.03210960f, 0.05353666f, 0.04847172f, 0.10085217f, -0.05515024f, -0.09320929f, 0.01754338f, 0.17191598f, 
    -0.11861901f, 0.19646136f, -0.15201987f, -0.08031314f, -0.04935782f, -0.05489648f, 0.04724906f, 0.07094765f, 
    -0.06551857f, 0.01662721f, -0.02207274f, -0.11672798f, -0.17100392f, 0.01188257f, -0.17368063f, -0.11618149f, 
    -0.16458865f, 0.04548048f, 0.11760853f, -0.03813449f, -0.33105117f, 0.35282952f, 0.11865503f, -0.18223575f, 
    0.12291398f, 0.15333611f, -0.07211870f, -0.09272003f, 0.07878503f, -0.01704524f, 0.15268654f, 0.08504387f, 
    -0.18781687f, -0.12301736f, -0.05153003f, 0.09762242f, -0.01813986f, 0.04340268f, -0.09115011f, 0.12060707f, 
    0.13984747f, 0.11896515f, 0.18681067f, 0.22625661f, -0.05179890f, 0.23434629f, 0.01238204f, 0.27917016f, 
    -0.10690090f, 0.00142956f, -0.00613460f, -0.06043291f, -0.10222619f, -0.00064967f, 0.01300535f, 0.07793880f, 
    -0.16618802f, -0.14917010f, -0.20520526f, -0.16049233f, 0.09580407f, -0.03767127f, 0.09069352f, -0.01071139f, 
    -0.05484723f, 0.11622601f, 0.00191768f, -0.04399948f, -0.15065055f, 0.01084248f, -0.13524467f, 0.23264076f, 
    -0.16282812f, -0.05558526f, -0.16559722f, -0.06234638f, -0.02785683f, -0.03929900f, 0.13406734f, 0.09996478f, 
    -0.17633149f, 0.38851923f, -0.04638784f, 0.13815705f, -0.10650024f, -0.08021897f, 0.07810184f, -0.07407016f, 
    0.05203895f, 0.16397218f, 0.04784488f, 0.14604729f, -0.13628303f, -0.16853546f, -0.01409598f, -0.01413482f, 
    0.07589711f, 0.00064948f, -0.03296877f, 0.16898401f, 0.06116855f, 0.03812259f, 0.06492415f, -0.00249248f, 
    -0.40958309f, 0.26476115f, -0.23206182f, 0.11980569f, 0.17358005f, 0.06544039f, 0.03964664f, 0.01875611f, 
    0.02075212f, 0.02660761f, 0.16969836f, -0.00060664f, -0.00197924f, -0.02261318f, 0.11798879f, -0.04377416f, 
    -0.09531429f, 0.08963244f, 0.02051162f, -0.02244716f, 0.07462546f, -0.00625762f, 0.03477620f, -0.06174015f, 
    0.01322565f, -0.02832342f, -0.04054698f, -0.08543233f, 0.02933516f, -0.06879505f, 0.01976668f, -0.00697359f, 
    -0.00612810f, 0.04151689f, -0.07326513f, -0.05530475f, 0.00950589f, 0.05436631f, -0.05850645f, 0.03047432f, 
    -0.03345729f, -0.02688506f, -0.02550920f, 0.03237496f, -0.05946862f, -0.02956381f, -0.06075141f, 0.00499834f, 
    -0.03309728f, 0.00730171f, 0.01042591f, -0.08402243f, 0.02785120f, -0.08186030f, -0.04399063f, 0.05533807f, 
    0.04655173f, 0.01638218f, 0.02738134f, 0.01111209f, -0.05108367f, 0.02638930f, -0.03213013f, -0.05520554f, 
    -0.01663402f, -0.04071411f, -0.04194047f, 0.03853957f, -0.06224153f, 0.00903584f, -0.00822788f, 0.03276301f, 
    -0.06992844f, -0.02768565f, -0.05670305f, -0.04660156f, -0.00781846f, -0.04509753f, 0.01175548f, -0.03742522f, 
    0.01821851f, 0.02157726f, -0.01033649f, 0.02720507f, 0.04200492f, 0.03068455f, -0.06866299f, -0.07715984f, 
    0.00859916f, -0.08018951f, -0.07450510f, 0.02071760f, -0.08054642f, 0.01552251f, -0.07580812f, 0.00006177f, 
    0.01058900f, -0.06152908f, -0.09368677f, 0.02777876f, -0.00376830f, -0.05833016f, -0.06597598f, -0.04585927f, 
    0.00875808f, -0.04367447f, 0.04395295f, 0.00306419f, -0.03654134f, 0.03954497f, 0.00005636f, 0.02772301f, 
    -0.05113386f, 0.04740652f, -0.08560698f, 0.01897604f, -0.08801051f, -0.06625821f, -0.06646927f, 0.01117490f, 
    0.02325535f, -0.06396352f, -0.02542158f, -0.01870028f, -0.00335846f, -0.00464187f, -0.05894199f, -0.01924240f, 
    -0.06698836f, -0.04238165f, -0.05992835f, 0.04008375f, 0.02656142f, -0.00554833f, -0.05141602f, 0.05129081f, 
    0.03689151f, 0.01640295f, -0.01450687f, -0.04365755f, -0.04198009f, 0.03073660f, -0.09588386f, -0.06625221f, 
    -0.06967860f, -0.03663001f, -0.04654937f, -0.05593381f, 0.03131441f, 0.03660268f, -0.03823471f, -0.01678754f, 
    0.00816556f, -0.07897522f, 0.03831749f, -0.06441824f, 0.03519058f, 0.00312831f, -0.02570378f, -0.03188039f, 
    0.02196007f, 0.00134589f, 0.00127216f, -0.08473751f, -0.01540686f, -0.03258726f, 0.02692750f, -0.03739845f, 
    0.03149853f, -0.05050023f, -0.04091161f, -0.01476592f, 0.04410084f, -0.03983676f, -0.01177621f, 0.01411136f, 
    0.00339942f, -0.01025639f, 0.04000556f, -0.07471181f, -0.05719676f, 0.01354557f, -0.01071224f, -0.04556769f, 
    -0.01478342f, 0.05616031f, -0.05078232f, -0.05873486f, -0.02738497f, -0.02548991f, -0.07970538f, -0.04696341f, 
    0.01049227f, 0.01250149f, -0.07121609f, 0.04343900f, 0.02239744f, 0.04699933f, -0.07236722f, 0.02211825f, 
    0.05064533f, 0.01208446f, 0.01639111f, -0.01867068f, -0.00574686f, -0.02695146f, 0.00216618f, 0.05432295f, 
    -0.05179045f, -0.02206444f, -0.04483562f, -0.04478275f, -0.06171111f, -0.07678623f, -0.02644923f, -0.04099225f, 
    -0.03734512f, -0.05714883f, 0.02373498f, -0.07034802f, -0.04145082f, 0.06382596f, -0.02722310f, -0.02779985f, 
    -0.01090827f, 0.03544766f, 0.04656505f, -0.04626425f, 0.04199137f, 0.04123845f, -0.04652231f, -0.03362022f, 
    0.00362880f, -0.01925173f, 0.00446938f, -0.06326786f, 0.03580488f, -0.03573291f, 0.05008941f, 0.03784205f, 
    -0.07644496f, 0.04634548f, -0.04676017f, 0.07014156f, -0.01685175f, -0.07681756f, 0.05431242f, -0.05891532f, 
    0.06251950f, 0.01658960f, 0.01505672f, 0.04828569f, 0.00027383f, 0.05588582f, 0.03728170f, 0.04754299f, 
    0.03028041f, -0.06424918f, 0.04406362f, 0.02277485f, -0.01968290f, -0.03669858f, -0.07247264f, -0.06990005f, 
    -0.07887141f, -0.00809417f, 0.01893682f, -0.06638028f, 0.01482874f, -0.03104379f, 0.02123112f, -0.03625214f, 
    0.04387362f, -0.01367550f, 0.06379329f, 0.04073597f, -0.04364254f, -0.00944613f, -0.02298976f, 0.02661381f, 
    -0.04832152f, 0.01940500f, 0.01752146f, 0.02397314f, 0.00807581f, 0.04268083f, 0.02801310f, -0.02679849f, 
    -0.04311901f, -0.06120232f, -0.01185372f, 0.02907231f, 0.00720337f, -0.03091319f, 0.01807738f, -0.02265719f, 
    0.03245137f, -0.04183500f, -0.02611933f, -0.02766568f, -0.03582009f, -0.01542132f, -0.01267589f, -0.05006109f, 
    -0.07009310f, -0.05250668f, 0.03422622f, 0.01940982f, -0.04130467f, 0.00333657f, 0.04843877f, 0.05416436f, 
    -0.06024018f, -0.03973575f, -0.07258538f, 0.01798663f, -0.07410996f, -0.02178684f, -0.05234884f, -0.07836080f, 
    0.04421960f, 0.00675388f, -0.03222360f, -0.06939486f, 0.05190079f, 0.06208710f, 0.00340392f, -0.02292710f, 
    0.03452259f, -0.03161846f, -0.00708963f, 0.04706476f, -0.05069043f, 0.05022601f, -0.06601468f, 0.05531223f, 
    -0.05133766f, -0.02064231f, -0.05165514f, -0.00777709f, -0.04378371f, -0.02678953f, 0.03343349f, -0.02241931f, 
    -0.06256323f, 0.00130420f, -0.02764953f, -0.02219870f, -0.01273979f, 0.01744298f, -0.01931850f, -0.06973084f, 
    -0.03058064f, -0.00413465f, 0.00340125f, 0.05464511f, -0.07608333f, -0.06977752f, 0.04955382f, -0.07912040f, 
    0.03612201f, -0.00484865f, -0.04163660f, -0.02506505f, 0.05112608f, -0.03886011f, -0.00289609f, -0.03587042f, 
    -0.02884472f, -0.05809974f, 0.03842860f, -0.07146665f, 0.03594052f, 0.00481548f, 0.00197089f, 0.04782952f, 
    -0.02925465f, -0.04246930f, -0.07848789f, -0.06951962f, 0.00161920f, -0.01585271f, 0.02021943f, 0.05020826f, 
    0.03950094f, -0.00130254f, 0.04791890f, -0.04626369f, 0.01318299f, -0.01414950f, 0.04259263f, 0.04445179f, 
    0.02827630f, -0.02450851f, -0.00289965f, 0.01024769f, 0.01465740f, -0.07295087f, -0.00590272f, -0.00824050f, 
    0.04332341f, -0.02075882f, -0.05761847f, -0.02530377f, -0.05900858f, 0.04813618f, -0.06034122f, -0.05998758f, 
    0.08156917f, -0.33218920f, -0.19984497f, 0.14349119f, -0.06414405f, 0.08577478f, -0.09865806f, 0.07049838f, 
    0.03195877f, 0.02251003f, 0.12885542f, 0.17309129f, 0.45176971f, 0.50764638f, -0.00505192f, -0.06770729f, 
    0.01964388f, 0.15555853f, 0.05254630f, -0.07477179f, 0.00395355f, 0.01919751f, -0.06116658f, -0.02397820f, 
    -0.31486362f, -0.49969083f, -0.05618406f, -0.27930009f, 0.09755390f, -0.01302397f, -0.16723864f, 0.02403537f, 
    0.07590043f, 0.11069714f, 0.08739591f, 0.05988805f, -0.34033015f, -0.39589822f, -0.15596253f, -0.02900188f, 
    0.02623184f, 0.11115410f, 0.03802837f, -0.02226761f, -0.03644466f, -0.00133939f, 0.11372868f, 0.09552194f, 
    0.28262872f, 0.34788290f, 0.09856565f, 0.00662150f, 0.08643918f, -0.03347782f, 0.03590341f, -0.06092880f, 
    -0.09346808f, -0.04836116f, -0.10689931f, -0.09623200f, -0.01160235f, 0.13992450f, -0.11692831f, 0.14254226f, 
    0.01741264f, -0.10726091f, 0.08264244f, -0.16711849f, 0.06241074f, 0.09427176f, 0.02354681f, 0.05384816f, 
    0.03626177f, 0.00606743f, 0.05341633f, 0.13305588f, -0.06074529f, 0.04183137f, 0.12019231f, -0.04715195f, 
    -0.04237676f, 0.02938427f, 0.04217561f, -0.05701697f, -0.25857890f, -0.42367652f, -0.04249358f, -0.12076117f, 
    0.12664112f, 0.04350072f, 0.22035450f, 0.00360835f, -0.18898171f, -0.06560874f, -0.02781953f, -0.03714073f, 
    0.24736702f, 0.23591843f, 0.02802597f, -0.04611988f, 0.12188185f, -0.09348783f, -0.15313397f, -0.10238986f, 
    -0.08795974f, 0.02395112f, -0.07788492f, -0.04232870f, -0.10138033f, -0.15330924f, -0.12944068f, -0.10684653f, 
    -0.09592914f, 0.01850563f, 0.01029631f, -0.12200126f, 0.05519761f, -0.15798211f, 0.08788008f, -0.00560475f, 
    0.16632664f, 0.26203442f, -0.05471009f, 0.01234830f, -0.00985596f, 0.19855681f, 0.00148691f, 0.10209660f, 
    0.16303095f, -0.03746795f, -0.04623626f, -0.11835132f, -0.06472310f, -0.34075871f, -0.08754998f, -0.17162453f, 
    0.00771154f, 0.02030609f, 0.10599737f, 0.02182091f, -0.00716705f, -0.04155834f, -0.01347267f, 0.04020692f, 
    -0.15398654f, -0.28853187f, -0.20177491f, -0.12033314f, -0.20559584f, -0.08968430f, 0.15224670f, -0.06482937f, 
    -0.07503966f, -0.19765882f, -0.02210953f, 0.05405251f, 0.15979311f, 0.04213033f, -0.09331252f, -0.03894384f, 
    0.19311975f, 0.08565101f, 0.03632276f, 0.00175633f, -0.03048093f, -0.03934023f, 0.05383507f, 0.12699156f, 
    0.15468027f, 0.23942655f, 0.06108041f, -0.27004641f, -0.11122467f, -0.05618081f, 0.11835708f, -0.11325405f, 
    0.09388150f, 0.05899089f, -0.16474161f, -0.08599596f, -0.05877318f, -0.09615904f, 0.07360377f, -0.28031418f, 
    -0.03582706f, -0.03934234f, -0.11356287f, 0.02222463f, -0.04773534f, 0.16851161f, 0.23039357f, 0.19558150f, 
    -0.15775728f, 0.35189480f, 0.40912786f, 0.23661384f, -0.02543207f, 0.11775066f, 0.08885904f, -0.03769555f, 
    0.09407266f, 0.20289387f, 0.14011350f, 0.14397041f, 0.22007181f, -0.36671248f, -0.01254536f, 0.08795408f, 
    0.08686481f, -0.03980279f, 0.00584323f, 0.03083536f, -0.02121934f, -0.04654643f, 0.05955190f, 0.09617666f, 
    0.19088596f, -0.12257222f, 0.14738064f, -0.08777832f, -0.22874705f, 0.01949366f, -0.17329381f, -0.08376084f, 
    0.04636700f, -0.04139592f, 0.07543595f, -0.16868487f, -0.05675080f, 0.07926312f, -0.00703222f, -0.13316116f, 
    0.05402763f, -0.10309346f, 0.00299196f, -0.00652217f, 0.12000306f, -0.07477839f, 0.00983552f, -0.06786676f, 
    -0.14122951f, -0.29396328f, -0.07469621f, 0.14252371f, -0.06985200f, -0.01679443f, 0.12347963f, 0.15046144f, 
    -0.07521401f, 0.07184723f, 0.08626647f, 0.06449682f, -0.22684212f, 0.10379659f, 0.27692920f, -0.09704114f, 
    0.12988055f, -0.02947257f, 0.09480878f, -0.03757358f, -0.04194777f, -0.04848518f, -0.16663612f, -0.15165287f, 
    -0.06913014f, 0.02412491f, 0.00383897f, -0.10222779f, -0.06035890f, -0.05067689f, 0.13321371f, 0.03195404f, 
    -0.05995443f, -0.11931193f, 0.01463140f, -0.37737659f, 0.07840325f, 0.48630497f, -0.28679079f, -0.09611207f, 
    0.22823475f, 0.13033383f, -0.01733334f, 0.07567877f, -0.09346265f, 0.04677897f, -0.04934555f, 0.08489855f, 
    -0.09212478f, 0.08273406f, 0.17915806f, 0.24803999f, -0.00052366f, -0.05677970f, -0.02773085f, 0.12317500f, 
    -0.07694820f, 0.05334720f, -0.19753860f, -0.10380400f, -0.00646716f, -0.07353776f, 0.04291255f, -0.15475738f, 
    -0.04517571f, 0.25628042f, -0.11264203f, -0.29554868f, 0.05839080f, -0.01337563f, -0.12890005f, -0.01005003f, 
    0.04195483f, -0.23116836f, -0.03540009f, 0.19934042f, 0.01413073f, -0.15022570f, -0.03827371f, 0.02422900f, 
    0.12131931f, 0.07999445f, 0.01017599f, 0.00567048f, -0.02977652f, -0.14864533f, 0.04656539f, -0.30459774f, 
    -0.14229330f, 0.02700174f, -0.11147077f, -0.00097546f, 0.10672574f, 0.23605983f, -0.04337132f, -0.05479025f, 
    0.11904561f, 0.07785311f, 0.09876374f, -0.13496378f, 0.14223076f, 0.02135786f, -0.22721504f, -0.14376923f, 
    0.00508212f, -0.09603247f, -0.05762957f, -0.09821544f, -0.01540805f, 0.07678830f, 0.27120861f, 0.16069791f, 
    -0.05395362f, -0.11224381f, -0.08477022f, 0.06057264f, -0.06449416f, 0.08818282f, -0.11414530f, 0.01413345f, 
    -0.36645979f, 0.13937116f, -0.11323445f, 0.17571934f, 0.10241939f, 0.09396445f, -0.23785922f, 0.02737198f, 
    -0.12641869f, 0.22402050f, 0.03643357f, 0.12511037f, 0.05349782f, 0.15058264f, -0.04906229f, 0.10249898f, 
    0.01746185f, -0.02843091f, 0.10668325f, 0.07643637f, 0.24351658f, 0.16902408f, 0.14345397f, 0.16625455f, 
    0.10321952f, 0.25680080f, -0.18926995f, 0.02766931f, 0.11800893f, -0.10332537f, 0.16050620f, 0.08399930f, 
    0.00132357f, -0.08011255f, -0.10173420f, -0.11553235f, -0.21137750f, -0.27137610f, 0.22519712f, 0.04515515f, 
    -0.02340576f, -0.15699716f, 0.04000620f, 0.08498541f, -0.07697444f, -0.09608033f, 0.11740818f, 0.06311180f, 
    -0.21412380f, 0.32020810f, -0.50025576f, 0.06262708f, -0.13390866f, 0.18930840f, 0.08803226f, -0.08037462f, 
    -0.04845563f, 0.00299961f, 0.02484918f, -0.02132178f, -0.06199123f, -0.24551882f, -0.21144406f, 0.10976786f, 
    0.06203546f, 0.10023347f, 0.09756834f, 0.05354230f, -0.07410598f, -0.03955663f, 0.02488989f, 0.02471208f, 
    -0.18011518f, -0.17066517f, 0.09461825f, 0.28476068f, -0.06898665f, -0.01012093f, 0.11610309f, -0.00612156f, 
    -0.00470817f, -0.02547408f, 0.10045853f, 0.10320038f, -0.28531894f, -0.40229186f, 0.18868575f, -0.07170464f, 
    0.20184185f, 0.27295291f, 0.04321674f, 0.16371220f, -0.07127260f, -0.01941636f, -0.07671583f, 0.02493521f, 
    0.00137435f, -0.06116356f, -0.11113214f, -0.05291050f, 0.04308831f, -0.01085390f, 0.11715208f, -0.00428128f, 
    0.02515843f, 0.07705688f, 0.00423403f, -0.08377752f, -0.06558193f, 0.40130082f, 0.26589832f, 0.09385931f, 
    -0.04114189f, -0.09269310f, -0.14393346f, 0.04515250f, 0.01152246f, 0.06339069f, 0.12197879f, -0.02302315f, 
    -0.05392981f, 0.14962463f, 0.13655710f, 0.08586089f, -0.01900654f, -0.04078449f, -0.07783272f, -0.03792897f, 
    0.06683657f, -0.11688572f, 0.14946400f, 0.01948990f, -0.10149127f, -0.05584202f, -0.02814638f, 0.04352996f, 
    0.07518436f, -0.08889959f, 0.07119630f, 0.15194127f, 0.00294591f, 0.02592317f, 0.00980648f, 0.05858935f, 
    -0.06957624f, 0.00688767f, 0.25966102f, 0.07596814f, -0.01491202f, -0.06106995f, 0.02923537f, -0.08552013f, 
    -0.05019656f, 0.03831682f, 0.00878709f, 0.03439576f, -0.07830806f, -0.06350316f, -0.41768616f, -0.06736379f, 
    0.04746462f, 0.06716704f, 0.11093558f, -0.07094987f, 0.09154079f, 0.11834131f, 0.08172646f, 0.08448779f, 
    0.00063887f, 0.04856476f, 0.17470855f, 0.05376583f, 0.08764114f, 0.01019589f, -0.00331300f, -0.16491669f, 
    0.24808598f, 0.09084652f, 0.03616737f, 0.00861270f, -0.01212237f, 0.09045602f, 0.25647253f, 0.06804409f, 
    0.00788165f, -0.03130783f, -0.12223960f, -0.02614996f, 0.01250771f, -0.01541876f, -0.06253111f, -0.01232642f, 
    -0.18560533f, -0.30592081f, 0.17053235f, 0.23516355f, 0.00773825f, 0.03618425f, -0.07485675f, 0.14015692f, 
    -0.13890460f, -0.00819820f, -0.01176711f, 0.07560439f, -0.02494967f, -0.07468993f, -0.09730770f, 0.16210143f, 
    0.00298702f, 0.09578571f, 0.01179374f, -0.02295408f, -0.00998021f, 0.06660127f, 0.00242490f, 0.04389035f, 
    0.03655815f, 0.00632808f, 0.05694766f, 0.04878708f, 0.01745790f, -0.06427457f, -0.04054800f, 0.05453965f, 
    0.03420210f, 0.03930587f, 0.01998857f, 0.00583784f, 0.02472569f, 0.01720129f, -0.02230597f, -0.00494954f, 
    0.01314909f, 0.00156702f, 0.01967186f, -0.04120088f, -0.02867687f, -0.01916233f, -0.04517462f, -0.02178272f, 
    -0.00473451f, 0.03420857f, -0.03024820f, -0.03926318f, 0.02696619f, -0.03333410f, 0.04589336f, -0.00627516f, 
    0.00218257f, 0.01789306f, 0.02758345f, 0.01235492f, -0.02836174f, -0.07135265f, -0.01690803f, 0.02896034f, 
    -0.05590624f, 0.04067179f, -0.00009476f, 0.03422369f, 0.03390643f, -0.07367335f, 0.04726432f, -0.03173181f, 
    -0.03602594f, 0.02067510f, -0.02981142f, 0.05184890f, -0.00082984f, 0.00244117f, -0.05050497f, -0.04662032f, 
    -0.05843655f, -0.00077543f, -0.06703269f, -0.02829259f, -0.06201958f, 0.03805042f, -0.00198766f, 0.01795021f, 
    -0.01098310f, -0.00844238f, 0.04109025f, 0.02391914f, 0.02112420f, 0.06397019f, -0.05311257f, -0.07406643f, 
    0.03907015f, 0.05563239f, 0.01053473f, 0.02466395f, -0.06876900f, -0.06878725f, -0.00618866f, -0.00196414f, 
    -0.02361659f, -0.03059860f, -0.00472533f, 0.01741527f, -0.00482983f, 0.02318033f, 0.03047898f, -0.02857209f, 
    -0.00985248f, -0.04034626f, -0.02470965f, -0.03659753f, -0.05790455f, -0.04883634f, -0.01549949f, 0.01815240f, 
    -0.02248026f, -0.06806584f, 0.04533865f, -0.00769760f, -0.05706887f, -0.01261566f, -0.00692231f, 0.06267117f, 
    0.02929230f, 0.00484442f, -0.03987441f, -0.03681980f, -0.03737878f, 0.05845347f, 0.02352229f, -0.05637159f, 
    -0.06358078f, 0.00597657f, -0.04910120f, -0.03482147f, -0.02091288f, 0.06062213f, -0.06697713f, 0.00983779f, 
    0.02577808f, -0.05912784f, -0.02625414f, 0.06107241f, -0.00008886f, 0.03736981f, -0.00117879f, 0.04636738f, 
    0.01325811f, -0.07350335f, -0.03861644f, 0.03626867f, 0.06583795f, 0.06489445f, -0.06315918f, 0.05364866f, 
    -0.00093828f, -0.02913219f, -0.04313930f, -0.05442353f, 0.01016304f, -0.06620563f, -0.03520832f, 0.03618288f, 
    0.05014380f, -0.00485761f, 0.01300949f, -0.07107547f, -0.03292558f, 0.05203132f, -0.07787601f, 0.05931127f, 
    -0.03268942f, 0.05488466f, -0.05946276f, -0.00596891f, 0.06056177f, -0.07461274f, 0.02796609f, -0.03357990f, 
    -0.07238384f, -0.07674753f, 0.01910055f, 0.05750873f, -0.00048208f, 0.04260422f, -0.06735913f, -0.03920744f, 
    -0.01084520f, -0.05965751f, 0.06530060f, -0.06059133f, 0.03042556f, -0.04547058f, -0.07530856f, -0.07596371f, 
    -0.05952368f, -0.06348550f, 0.01888049f, 0.02609278f, -0.03782560f, -0.01821585f, -0.04985277f, -0.05360529f, 
    0.06216167f, 0.06159546f, 0.00165873f, -0.00744863f, -0.05256017f, -0.06180932f, -0.07404450f, -0.07208148f, 
    0.38015333f, -0.15018733f, 0.41817886f, -0.31072503f, 0.08393420f, -0.07990021f, -0.22595243f, -0.11741613f, 
    0.02718282f, 0.13608760f, 0.18517186f, 0.26110551f, 0.17044154f, -0.32759997f, -0.02796481f, 0.24365249f, 
    0.02594636f, 0.12698634f, -0.12758125f, -0.10731549f, -0.00208149f, 0.07605932f, -0.08955100f, 0.11270888f, 
    0.36011541f, -0.49464792f, 0.51067233f, -0.33810970f, -0.02284582f, 0.02876486f, 0.10438141f, 0.09037255f, 
    -0.11347230f, -0.02005624f, 0.01145071f, -0.02900269f, 0.15184280f, 0.14584720f, 0.12754396f, -0.22536372f, 
    -0.10227242f, -0.06825033f, 0.05654795f, 0.11630782f, -0.00672920f, -0.07042711f, -0.04577609f, -0.03644532f, 
    -0.06231306f, -0.16278189f, 0.02285227f, 0.07973199f, -0.12072438f, 0.22369365f, 0.14070398f, 0.01315332f, 
    0.04425369f, 0.05269063f, 0.08259127f, 0.08218814f, -0.28302091f, 0.13739972f, -0.12435839f, 0.04715627f, 
    0.11121001f, 0.01615447f, -0.16812816f, -0.17512661f, -0.10678406f, -0.06071354f, -0.02562158f, 0.14891736f, 
    0.13905782f, -0.10349051f, 0.05955196f, -0.06807897f, -0.08064859f, -0.03922283f, 0.04896481f, 0.10320570f, 
    -0.07288597f, -0.05585424f, -0.01549049f, -0.18148406f, -0.16203615f, -0.28903905f, 0.26514319f, 0.08448816f, 
    0.07202513f, -0.13261394f, 0.11460314f, 0.07013936f, 0.07028119f, 0.05598758f, 0.07772804f, 0.15046856f, 
    -0.24287876f, -0.05687092f, 0.02158367f, -0.24872023f, -0.00848366f, -0.07390040f, 0.08643134f, 0.07861408f, 
    -0.04649900f, 0.09536252f, -0.10189092f, -0.08826663f, -0.06317178f, 0.24034321f, -0.15941609f, 0.23841791f, 
    0.12908821f, 0.16339664f, 0.03017543f, -0.15610209f, 0.00963555f, -0.04090350f, -0.00387111f, 0.10574633f, 
    -0.30067518f, -0.51191181f, -0.45243236f, 0.07905971f, -0.14465886f, -0.06996115f, -0.03182440f, -0.04450236f, 
    -0.07839994f, -0.06694894f, 0.02146912f, 0.08971571f, -0.10415587f, 0.23105116f, 0.01392761f, 0.02728421f, 
    0.03418688f, 0.01132490f, 0.08218357f, 0.03136519f, 0.06727164f, -0.01434258f, 0.02905336f, 0.15677759f, 
    -0.09987267f, 0.18556456f, -0.02133502f, 0.07364386f, 0.13802119f, -0.09416653f, -0.08191556f, 0.16450250f, 
    -0.00669461f, -0.10670223f, 0.25275537f, -0.00641687f, 0.04314922f, 0.39238057f, 0.32982805f, 0.51473230f, 
    -0.11972076f, -0.08511744f, 0.04466164f, 0.01685125f, -0.02992523f, 0.11463408f, -0.05298104f, 0.05919236f, 
    -0.11087741f, 0.03084310f, -0.28729844f, 0.27546802f, 0.02817049f, 0.10470098f, 0.12608849f, 0.22861788f, 
    0.09796901f, 0.12941292f, 0.18684898f, 0.01105128f, -0.26160029f, 0.14404602f, 0.20506801f, 0.01321007f, 
    0.01038047f, -0.00714038f, -0.10426265f, 0.03931011f, -0.12477978f, 0.01844731f, -0.19643733f, 0.07686497f, 
    -0.04197588f, -0.05082185f, -0.00241195f, 0.03820512f, 0.06647108f, 0.01657352f, 0.05314264f, 0.01976299f, 
    0.02085196f, -0.01795321f, -0.01958098f, 0.01207369f, -0.02817032f, -0.07611696f, 0.04055047f, -0.03278462f, 
    0.00089087f, 0.02664888f, 0.06424177f, -0.00921836f, 0.01878462f, 0.02731152f, -0.07639149f, 0.06206897f, 
    -0.05541912f, 0.01521909f, 0.05494561f, -0.06798200f, -0.06310600f, -0.02283021f, -0.04387865f, 0.02896573f, 
    -0.06886445f, -0.07232083f, 0.05138743f, 0.02277162f, 0.01230816f, 0.03624842f, -0.07252541f, 0.02959011f, 
    -0.07838542f, -0.00326934f, 0.00854404f, -0.02699487f, -0.01067375f, 0.02140184f, -0.01482938f, 0.02664400f, 
    -0.00082366f, -0.00307747f, 0.00476370f, -0.03169008f, 0.00386739f, -0.06497242f, 0.04315372f, 0.00153050f, 
    -0.06185510f, -0.02845492f, 0.05289069f, -0.01641493f, -0.05733663f, -0.03860807f, -0.03167617f, 0.00521091f, 
    -0.00371900f, -0.02478004f, -0.03995650f, 0.04349935f, -0.08414456f, 0.02601327f, -0.05219068f, -0.04206160f, 
    0.05194202f, -0.06170747f, -0.05235392f, -0.05093292f, -0.01296659f, 0.03402298f, -0.06302211f, 0.01066480f, 
    -0.01375106f, 0.03116579f, -0.02872989f, 0.01864438f, 0.05254687f, 0.01803340f, -0.02333108f, -0.05947251f, 
    -0.05595862f, 0.02426404f, -0.04390291f, 0.05251128f, -0.04077959f, -0.05243952f, 0.06625178f, -0.02166529f, 
    -0.01877831f, 0.00901939f, -0.02546062f, 0.02136791f, -0.03487403f, -0.04206831f, 0.01451087f, -0.07631179f, 
    0.02472611f, -0.04984361f, -0.05042176f, -0.00092542f, -0.03707799f, 0.04080607f, 0.02797534f, -0.01725533f, 
    0.01498597f, -0.03658061f, 0.03403781f, -0.00513488f, 0.03153867f, -0.01932485f, 0.04693327f, 0.04115797f, 
    0.04507917f, -0.03080804f, 0.00433734f, -0.04514540f, -0.00194069f, -0.06702910f, 0.04382987f, 0.05128451f, 
    -0.01328815f, 0.03963425f, 0.03940534f, 0.01352324f, -0.02993572f, -0.03871461f, 0.02719115f, 0.00332604f, 
    -0.06109790f, -0.00919260f, 0.03130133f, -0.05777496f, 0.05452942f, -0.02510373f, 0.02640396f, -0.06789436f, 
    -0.01515464f, -0.02668161f, -0.00302968f, -0.03626821f, 0.05677573f, 0.01169176f, -0.03812335f, -0.02592380f, 
    -0.06525637f, -0.08119901f, -0.07381484f, 0.05733478f, -0.06649917f, -0.04287925f, 0.05004199f, -0.03385172f, 
    -0.05522157f, 0.03330908f, 0.04252107f, -0.03736480f, -0.05248540f, -0.02957115f, -0.03884980f, 0.05043301f, 
    0.07253086f, -0.01906877f, 0.06473836f, 0.03957368f, -0.02433712f, -0.01127790f, 0.03659363f, 0.01724904f, 
    0.05845337f, 0.01447765f, -0.04700502f, 0.05307129f, -0.04101894f, -0.04854188f, -0.05169328f, -0.07142024f, 
    -0.04438441f, -0.01783274f, 0.00794721f, 0.07223761f, -0.05740251f, 0.00223856f, 0.00211937f, -0.01950457f, 
    0.02289587f, 0.03844084f, -0.03983951f, -0.05336431f, 0.02035999f, 0.03253093f, 0.03688454f, 0.04438769f, 
    -0.05262645f, 0.04898861f, -0.07775761f, 0.01321645f, 0.00142026f, 0.02970030f, -0.01745889f, -0.04744779f, 
    -0.04647487f, 0.05022965f, 0.05525618f, -0.07666476f, -0.07480678f, 0.05426581f, 0.06019393f, -0.07940593f, 
    -0.06974171f, 0.00413353f, -0.00139370f, -0.04956364f, -0.03521458f, 0.02880502f, 0.03510704f, 0.03356871f, 
    -0.00040925f, -0.04453009f, -0.07749729f, -0.06605923f, -0.05802504f, -0.03133605f, -0.00301618f, -0.03713753f, 
    -0.04644496f, -0.04368034f, 0.03896246f, -0.05033614f, -0.00232438f, -0.02596467f, 0.04280989f, 0.03922604f, 
    -0.04711578f, 0.05973514f, -0.06943619f, -0.00469069f, 0.02600740f, -0.00012601f, -0.03662754f, -0.03962869f, 
    -0.04601608f, 0.00270644f, -0.01963071f, 0.00610393f, 0.01185009f, -0.02837370f, -0.03500745f, -0.00234904f, 
    0.00954203f, -0.07390422f, -0.00058849f, -0.02621694f, -0.06304402f, 0.03396028f, -0.03429051f, 0.04314851f, 
    -0.05679042f, -0.06746779f, 0.04778634f, -0.00659533f, -0.01143392f, -0.03073624f, -0.04329478f, -0.03372922f, 
    0.00341394f, 0.01205014f, 0.01474074f, 0.02436782f, -0.07295360f, -0.05248312f, 0.02925588f, -0.01706395f, 
    -0.00420230f, -0.06903678f, 0.00487680f, 0.05843168f, -0.04756808f, 0.05370969f, -0.00266797f, -0.02262527f, 
    0.06056875f, -0.02471225f, 0.01498648f, 0.05865786f, -0.01025177f, -0.03500981f, -0.02066123f, -0.00644112f, 
    -0.01549422f, -0.07985121f, 0.05328316f, 0.04095193f, -0.07901935f, 0.05525824f, 0.05083170f, -0.02263326f, 
    -0.04087016f, 0.05810767f, -0.05287249f, 0.02833517f, -0.03926926f, -0.03339214f, 0.06167300f, -0.07914796f, 
    0.04396671f, 0.05270779f, -0.04041324f, -0.04154869f, 0.04736509f, -0.05721357f, -0.00141343f, 0.02777870f, 
    -0.04972030f, -0.07909448f, 0.01363241f, -0.06462257f, 0.02116881f, 0.01231270f, 0.00341931f, 0.04052683f, 
    -0.00390349f, 0.05210197f, -0.05675147f, 0.05570878f, -0.04656130f, -0.08165096f, 0.01262716f, 0.02218127f, 
    -0.08217362f, 0.04815340f, 0.01747485f, 0.00201614f, -0.01198721f, 0.00464368f, -0.03929234f, -0.00506044f, 
    0.04460729f, 0.02316399f, 0.05229437f, -0.08288387f, -0.00607071f, 0.04250213f, -0.01938287f, -0.03059944f, 
    0.01660534f, -0.03910360f, 0.00904337f, 0.06358290f, 0.04816415f, -0.04828484f, 0.02804604f, 0.02888107f, 
    -0.05553355f, -0.01052945f, -0.03694677f, -0.03706331f, -0.05933749f, 0.02035617f, -0.02606934f, -0.05253404f, 
    -0.00279872f, -0.05099465f, -0.01074030f, -0.03439666f, -0.08113109f, -0.03938654f, 0.00289065f, 0.05562983f, 
    -0.02744283f, 0.01644468f, -0.06378427f, -0.00966619f, -0.07664676f, -0.01793794f, -0.07609414f, -0.06721392f, 
    0.22296512f, 0.19952768f, -0.24690753f, 0.12956712f, 0.24345413f, 0.01136321f, -0.18208425f, -0.03683609f, 
    0.04131867f, -0.08272272f, -0.10952962f, 0.05280155f, -0.27581018f, 0.02632161f, 0.35054746f, 0.22181320f, 
    -0.03929542f, -0.17926216f, 0.02809508f, 0.25426716f, -0.09420302f, -0.03676632f, 0.09505366f, -0.06534637f, 
    -0.42702705f, 0.09607340f, -0.15659001f, 0.23454228f, -0.05177229f, -0.01965533f, -0.20808706f, -0.09957353f, 
    -0.06001917f, 0.03602008f, -0.02443802f, 0.00322314f, -0.32748011f, -0.23148018f, -0.16919617f, 0.11685453f, 
    0.01380219f, -0.11678939f, -0.10444263f, -0.05322706f, -0.10076188f, -0.06402278f, -0.04307459f, -0.04294709f, 
    -0.07845689f, -0.04425512f, 0.21094620f, 0.21161488f, 0.08895683f, 0.22177050f, 0.02177760f, 0.07669092f, 
    0.05430806f, -0.00249409f, 0.01571932f, -0.01091245f, -0.36920631f, -0.26292324f, 0.00151680f, 0.03978571f, 
    0.08864260f, 0.10010155f, -0.10041362f, 0.12477310f, 0.05255145f, -0.00588710f, 0.01281918f, -0.00906303f, 
    -0.09607043f, -0.10969423f, -0.14280674f, -0.05569199f, 0.01839011f, -0.06559826f, -0.17956144f, -0.12415227f, 
    -0.12107804f, -0.07658618f, -0.05469916f, -0.04951901f, -0.01089650f, 0.21076174f, 0.27217090f, -0.01520551f, 
    -0.13952850f, -0.15355612f, -0.07237368f, 0.04084462f, 0.01580741f, 0.15800148f, 0.11439200f, -0.08738738f, 
    -0.04822760f, 0.11899703f, 0.07385125f, 0.13630557f, 0.10132859f, 0.11200131f, 0.02004384f, 0.00505694f, 
    0.05693739f, -0.06386172f, 0.10825460f, 0.06808116f, -0.29406872f, -0.13406603f, -0.14580417f, -0.00609613f, 
    0.09825547f, -0.05252663f, -0.00060448f, 0.04079000f, 0.01447357f, 0.11378293f, -0.10425205f, 0.04996118f, 
    -0.00229309f, -0.01024859f, 0.26454958f, 0.06812691f, 0.11466731f, 0.08480575f, -0.01937174f, -0.05047458f, 
    -0.03004298f, 0.05693526f, 0.01268115f, 0.10041688f, -0.03089300f, 0.08547415f, -0.25041711f, -0.00702618f, 
    -0.01103426f, 0.00610838f, 0.02080396f, 0.03767975f, 0.30202353f, -0.01207134f, -0.01938820f, 0.16220954f, 
    0.01620089f, 0.17106530f, 0.06285052f, -0.15714806f, 0.13063227f, -0.13754685f, -0.02280487f, 0.10334826f, 
    0.23288137f, 0.13298987f, 0.01585824f, 0.02903072f, -0.00251557f, 0.38304022f, 0.13788137f, 0.23972510f, 
    -0.04136813f, 0.20742050f, -0.02343424f, -0.09787211f, 0.13776432f, -0.06271632f, 0.00150984f, -0.00466415f, 
    0.06549280f, -0.13499840f, 0.41434285f, 0.00635749f, -0.04860311f, -0.12826712f, 0.02628950f, 0.22612362f, 
    -0.02266676f, -0.12449252f, -0.08181988f, 0.05458643f, -0.12805040f, 0.09702284f, 0.02458885f, 0.09070870f, 
    -0.00951209f, 0.04487376f, -0.16975328f, -0.11760743f, 0.08164700f, -0.04511778f, -0.04928435f, -0.11060849f, 
    0.06222228f, -0.03160506f, 0.01197517f, 0.05704282f, 0.01345569f, -0.05669029f, 0.06540262f, -0.07612392f, 
    0.06748486f, -0.02011214f, 0.06892040f, 0.04490108f, 0.00549080f, 0.00919345f, 0.03911413f, -0.05090902f, 
    -0.04310001f, -0.04525292f, -0.01875635f, 0.03053902f, -0.04277476f, -0.03442942f, -0.04406017f, -0.07006212f, 
    0.03986169f, 0.01939642f, -0.05049070f, -0.07665513f, -0.03776041f, 0.03820023f, -0.07834025f, -0.05216863f, 
    0.04963069f, 0.01228758f, -0.00977116f, -0.04644480f, -0.07213196f, 0.04802264f, -0.03960447f, -0.03937253f, 
    0.05550040f, 0.01477349f, 0.01863506f, -0.00181357f, 0.04222430f, -0.00857776f, -0.01986568f, -0.03560106f, 
    0.06245609f, 0.05036793f, 0.01949053f, -0.04854018f, 0.02799809f, 0.03852031f, 0.01876504f, 0.05049749f, 
    0.05769573f, -0.03460952f, -0.00679252f, 0.02317222f, 0.01490661f, 0.01185192f, 0.00726794f, -0.03704325f, 
    -0.00712015f, -0.00380756f, -0.07721361f, -0.01001385f, -0.03283465f, -0.03495281f, 0.04342493f, -0.02933858f, 
    -0.07308081f, -0.07031507f, -0.04781616f, 0.05747123f, 0.00220949f, 0.04183143f, -0.04836786f, -0.05446215f, 
    0.06742237f, -0.07026073f, 0.05893856f, -0.05676996f, -0.07383713f, -0.02946557f, -0.01901227f, -0.07180822f, 
    -0.03945907f, -0.05070253f, -0.04017670f, 0.01975044f, -0.01283280f, -0.04901696f, -0.05257379f, -0.06957911f, 
    -0.07645703f, -0.07718100f, 0.06056872f, 0.03270030f, -0.07727731f, -0.03788261f, 0.02515273f, -0.07083794f, 
    0.04620151f, -0.06613163f, 0.03330410f, -0.06074753f, 0.04356056f, 0.05495526f, 0.06347854f, -0.06764613f, 
    0.02065787f, 0.02205926f, -0.05773748f, 0.02305579f, -0.04202453f, 0.01692329f, -0.02640479f, -0.06203092f, 
    0.04752785f, 0.00670644f, -0.07392344f, -0.06078083f, -0.01547244f, 0.06080922f, -0.05743677f, -0.04111760f, 
    -0.03229394f, -0.00207429f, 0.01711115f, -0.04023221f, -0.05001684f, 0.00273068f, -0.05497283f, 0.00278694f, 
    -0.00158528f, -0.04208331f, -0.07192827f, -0.03451358f, -0.03040248f, -0.07850817f, 0.02486878f, -0.03028643f, 
    0.02290929f, -0.06644795f, 0.03992531f, -0.05733283f, -0.05127720f, -0.04816004f, -0.07615990f, 0.01384716f, 
    -0.01631661f, 0.00302789f, 0.04078008f, -0.05083967f, -0.01064774f, -0.04658714f, 0.00582524f, 0.01393496f, 
    0.02460551f, 0.01177450f, -0.06394260f, 0.04817484f, -0.00148594f, 0.04400709f, 0.00124439f, 0.03170654f, 
    -0.06126141f, -0.02628992f, 0.03063668f, -0.07709176f, -0.04037346f, -0.03151998f, -0.04723481f, 0.03718070f, 
    0.01161271f, 0.05608773f, -0.00261712f, -0.02466457f, -0.03239971f, -0.04092130f, -0.02584621f, 0.03079694f, 
    0.05419243f, 0.02119914f, -0.06981539f, -0.02499386f, 0.05316641f, 0.02180326f, 0.03008164f, 0.01478525f, 
    0.11415889f, 0.05356658f, -0.17123409f, -0.21342529f, 0.07657190f, -0.13367990f, 0.02875091f, 0.21315573f, 
    -0.04802278f, -0.13240942f, -0.01416696f, 0.02155300f, -0.36956578f, 0.23065691f, 0.11405156f, -0.11983480f, 
    0.06348688f, 0.08127474f, 0.21628323f, 0.30881065f, -0.00448935f, -0.13789220f, 0.00315986f, -0.07150580f, 
    -0.57228607f, 0.03122053f, -0.46242458f, 0.21051505f, 0.09710449f, 0.04047779f, 0.01807577f, -0.05969164f, 
    -0.08419261f, 0.04418797f, -0.11843248f, -0.01432969f, -0.12409827f, -0.27521655f, -0.28220394f, 0.10427261f, 
    0.09420986f, 0.04600794f, 0.02394198f, -0.08708060f, -0.03414966f, 0.03073511f, -0.09512645f, 0.11731431f, 
    0.11015452f, 0.21652508f, 0.12444221f, 0.00864711f, 0.20142660f, 0.09292543f, -0.05328643f, 0.13103150f, 
    -0.06441518f, 0.02418841f, 0.01512963f, -0.00364835f, 0.00790905f, -0.31545272f, -0.18527597f, -0.29041606f, 
    0.07028851f, 0.01324889f, -0.11312360f, 0.16586195f, 0.05438586f, -0.02194194f, 0.00327630f, -0.07500150f, 
    -0.21089841f, -0.25929770f, -0.21064635f, -0.11052660f, 0.06417774f, -0.07736547f, 0.06942866f, 0.01771396f, 
    0.12323991f, 0.04307225f, 0.00648183f, 0.26599467f, -0.15795895f, 0.02991886f, 0.22375661f, 0.29871213f, 
    0.03874486f, -0.14866821f, -0.07455960f, -0.13784337f, 0.15797189f, 0.03312518f, 0.23368670f, 0.01773239f, 
    0.23791079f, 0.18157281f, 0.02723433f, -0.00713339f, 0.05212969f, 0.18377912f, 0.14495385f, 0.10368475f, 
    0.02746605f, -0.02590608f, 0.18553564f, 0.11388915f, -0.15465933f, -0.29652774f, -0.31673133f, -0.19198523f, 
    -0.00449268f, 0.00538622f, 0.13795304f, 0.11325642f, 0.03511593f, 0.06291305f, -0.06078405f, 0.02109148f, 
    0.12076903f, 0.23106584f, 0.22062507f, 0.03527465f, 0.02945128f, -0.06246801f, 0.08472852f, 0.06357552f, 
    -0.02653064f, 0.05156534f, -0.02782706f, 0.01316315f, 0.06269840f, -0.15949790f, -0.27103126f, -0.05462532f, 
    -0.06400274f, -0.02825708f, 0.02356945f, -0.13113105f, 0.14729752f, -0.02863818f, -0.00150100f, 0.10185711f, 
    -0.09554017f, -0.21779446f, 0.14558031f, -0.11143050f, -0.01824769f, 0.15011233f, -0.13088150f, 0.07299937f, 
    0.23300974f, 0.11870083f, 0.01565449f, 0.11135227f, 0.23506741f, 0.03508732f, 0.07476932f, -0.10986575f, 
    0.02853847f, 0.15132554f, -0.08849376f, -0.10385214f, 0.03526128f, -0.03547699f, -0.03807194f, 0.03159837f, 
    0.05123299f, -0.19035371f, 0.30196449f, -0.00325990f, 0.06389090f, 0.10633937f, 0.19305307f, 0.18130150f, 
    0.10877262f, -0.11899462f, 0.02793130f, -0.06414611f, 0.02504702f, -0.16498823f, -0.02324047f, -0.03182393f, 
    0.00119262f, -0.01303279f, 0.01362156f, 0.05682407f, -0.10411315f, -0.22388192f, -0.14702576f, -0.14505810f, 
    -0.00564825f, 0.02934432f, -0.05878494f, -0.07351813f, -0.02813259f, -0.02479505f, -0.02264471f, -0.00790613f, 
    -0.03022533f, 0.05599821f, 0.00369276f, -0.06187490f, 0.04253957f, -0.01907690f, -0.01741161f, -0.03345527f, 
    0.04292670f, -0.06115400f, 0.03018083f, -0.02525057f, -0.03296505f, -0.05761606f, -0.01369626f, 0.01704290f, 
    0.05571937f, 0.00456536f, 0.00937888f, 0.03753987f, 0.01702114f, 0.06070255f, -0.07402699f, 0.02524428f, 
    0.00802766f, -0.06880488f, 0.00430720f, -0.05600483f, -0.04153734f, -0.02659919f, -0.06752134f, 0.05724008f, 
    -0.00488365f, 0.01150153f, 0.02455521f, 0.00163516f, -0.02167171f, -0.05151201f, 0.05785118f, 0.03074115f, 
    -0.02136295f, 0.03004717f, -0.05235018f, -0.00519302f, -0.07344868f, 0.05609190f, 0.00074593f, -0.03629170f, 
    -0.05390602f, -0.06956947f, 0.01859343f, 0.02464692f, 0.00730225f, 0.04640523f, 0.05948459f, -0.02835044f, 
    0.01413559f, 0.00663503f, 0.05254043f, 0.02355508f, -0.06607755f, 0.01706919f, 0.06081484f, -0.01956477f, 
    0.03448821f, -0.04914924f, -0.06060161f, -0.06480409f, 0.00150154f, -0.05488409f, 0.02183736f, -0.02005840f, 
    -0.00276382f, 0.05861272f, -0.07418279f, 0.00067738f, -0.07312139f, 0.03193467f, -0.01371469f, -0.04393280f, 
    -0.03853310f, -0.01577042f, 0.02092923f, 0.02361396f, 0.01701494f, 0.06337285f, -0.07294916f, -0.03143677f, 
    0.05490189f, -0.00970806f, -0.00613014f, 0.04932525f, -0.05729345f, -0.00484950f, 0.02720967f, 0.03013478f, 
    -0.04925167f, 0.01896332f, -0.02141198f, -0.00044595f, -0.05833149f, -0.04766250f, -0.04166041f, 0.03923053f, 
    -0.04489582f, -0.03842993f, -0.00095446f, 0.03192623f, -0.03533712f, 0.03762134f, -0.05732240f, -0.03814507f, 
    -0.04372624f, -0.00014199f, -0.05521500f, 0.00050827f, -0.05462038f, -0.06351453f, 0.01654628f, -0.06876311f, 
    -0.01786674f, -0.05875972f, -0.07216854f, -0.07308640f, 0.01597336f, 0.02893062f, -0.05799822f, 0.05391734f, 
    -0.00440372f, 0.02382851f, -0.05385657f, -0.01472548f, 0.04808848f, -0.04149188f, 0.02784995f, -0.06951514f, 
    -0.01741552f, 0.03654665f, -0.02435493f, -0.04298478f, -0.05683013f, -0.07563424f, -0.04244669f, -0.01789567f, 
    0.00798440f, 0.05192733f, -0.03729669f, -0.07277974f, -0.03877556f, 0.03635810f, -0.01008987f, -0.04155612f, 
    0.06294821f, 0.02839235f, -0.05542760f, 0.05164156f, 0.05935971f, -0.06642991f, 0.01637056f, -0.03315205f, 
    0.04376368f, -0.04940516f, -0.05458596f, -0.02224682f, -0.06749733f, 0.02597870f, -0.05762701f, 0.01640120f, 
    0.03170877f, -0.02246168f, 0.06820276f, -0.06196229f, -0.03148365f, -0.02767076f, 0.04839589f, 0.06146409f, 
    0.02500023f, -0.02479063f, 0.02256795f, 0.05046416f, -0.03061460f, 0.01302404f, -0.04337024f, -0.00369637f, 
    0.02703573f, 0.00947022f, 0.03984645f, 0.01183215f, -0.01175108f, 0.01211345f, -0.05077073f, 0.06233019f, 
    -0.01390327f, 0.05143885f, -0.00531404f, 0.05664892f, -0.00344719f, -0.04559563f, -0.07300926f, -0.05778152f, 
    0.00633719f, -0.07068121f, -0.02609122f, 0.02718882f, 0.00502055f, -0.02479921f, 0.05092153f, -0.07124332f, 
    -0.05393220f, 0.00464552f, -0.01119035f, 0.01375101f, -0.02377619f, -0.03547283f, 0.00061482f, -0.04630594f, 
    -0.03358287f, -0.03248599f, -0.03232208f, -0.07134257f, -0.06604289f, -0.00929241f, -0.04001855f, -0.00988018f, 
    -0.06568123f, 0.03099400f, -0.01455879f, 0.03567227f, -0.03134452f, -0.07943653f, 0.02795652f, -0.06199357f, 
    -0.00055568f, -0.03574463f, -0.02134864f, 0.03828618f, 0.03575631f, -0.01133141f, -0.06176681f, -0.04703783f, 
    0.04107609f, 0.04385631f, -0.01575503f, 0.00514279f, 0.01702840f, 0.03520009f, -0.00302299f, 0.03325925f, 
    0.06012590f, -0.05433678f, -0.06006416f, -0.06536864f, -0.00378335f, 0.02244398f, -0.01280564f, -0.04252440f, 
    -0.03123173f, 0.03504504f, 0.02210337f, -0.00828997f, -0.04605605f, -0.03717414f, 0.03984806f, -0.00913723f, 
    -0.01511538f, -0.01000810f, 0.00843242f, -0.05214659f, 0.01754660f, 0.04876620f, 0.01848909f, 0.05424538f, 
    -0.07543139f, 0.05451754f, -0.00567422f, 0.06245329f, -0.06034783f, -0.06841303f, 0.02102881f, 0.03530100f, 
    0.00002689f, -0.00595707f, -0.00056522f, 0.03843934f, -0.03796522f, 0.02229920f, 0.03296532f, 0.02453271f, 
    -0.06291337f, 0.01746060f, -0.03281078f, -0.07480354f, -0.05386950f, 0.01199628f, 0.06077353f, 0.01645348f, 
    -0.02954470f, -0.02795947f, -0.00209146f, 0.03023572f, 0.04804769f, 0.00044316f, -0.07099821f, 0.05770392f, 
    -0.05516871f, -0.03599217f, 0.05436004f, -0.06414074f, -0.02413242f, 0.06375826f, 0.00940754f, -0.05381659f, 
    0.03101802f, -0.03241697f, -0.00248797f, 0.02189912f, 0.02198223f, -0.01423751f, -0.07237288f, -0.03454197f, 
    0.05027876f, -0.00181400f, -0.04600634f, -0.04597778f, -0.03414975f, -0.02966777f, -0.04414304f, -0.02061740f, 
    0.04270022f, 0.03284616f, 0.02126255f, 0.02792712f, -0.02353696f, -0.05835754f, -0.07348506f, 0.05335535f, 
    0.00421705f, -0.00441158f, -0.06584395f, -0.07293802f, 0.00431710f, -0.03910965f, 0.06417374f, -0.03235857f, 
    -0.06525910f, 0.05284419f, 0.04890978f, -0.00990484f, -0.00122436f, -0.02322568f, -0.07569402f, -0.02524668f, 
    0.02008651f, -0.05485144f, -0.03792547f, -0.00103727f, -0.02332995f, -0.00735725f, -0.06949870f, -0.02189003f, 
    -0.05449591f, -0.04028796f, 0.04698312f, 0.01505402f, -0.00536606f, -0.05658836f, -0.03876675f, -0.02311524f, 
    0.00948558f, 0.05369825f, -0.00431656f, 0.01559028f, -0.02212488f, -0.05885765f, 0.06036472f, 0.06369571f, 
    0.01287575f, -0.03945864f, 0.02392298f, 0.01174136f, -0.00916643f, 0.02378504f, -0.05263221f, -0.04962524f, 
    -0.05918364f, 0.05447263f, 0.05625223f, 0.01523951f, 0.00387302f, -0.05099934f, -0.02142305f, 0.00704941f, 
    -0.01104106f, -0.00667290f, -0.06761117f, -0.06213049f, -0.00749570f, -0.02922807f, 0.03384304f, -0.06162224f, 
    -0.01284297f, -0.00434803f, 0.01152215f, 0.05189762f, 0.00806178f, -0.03618706f, 0.05602866f, -0.02520292f, 
    -0.06861059f, 0.01228260f, -0.03360852f, -0.04513077f, 0.01065351f, 0.00355912f, -0.00035876f, -0.00828110f, 
    -0.00913628f, 0.01090173f, -0.00168208f, -0.02032307f, -0.02451967f, -0.07454139f, -0.06398304f, 0.02250935f, 
    0.01146700f, 0.01006751f, 0.01273640f, 0.05533203f, -0.07918213f, -0.04360335f, -0.07408848f, 0.05743845f, 
    -0.00170054f, 0.06038078f, 0.00914086f, 0.00173800f, -0.05515844f, -0.02539101f, -0.03645680f, -0.02679497f, 
    0.04611318f, -0.02241967f, -0.03563369f, -0.06046812f, 0.03250516f, -0.07919751f, -0.01033206f, 0.01359394f, 
    0.00971831f, 0.01869108f, -0.05835750f, -0.07498170f, -0.06116467f, 0.01206902f, 0.00860293f, 0.01263812f, 
    -0.01873594f, -0.07305197f, -0.04910052f, 0.00344866f, -0.07254886f, 0.07596342f, 0.02098057f, -0.04726810f, 
    -0.03858553f, 0.04827776f, 0.03511438f, -0.07191581f, -0.04136043f, -0.07284981f, -0.03466574f, 0.05037183f, 
    0.05944347f, -0.01554447f, -0.06280411f, 0.00613062f, -0.02428351f, 0.01935643f, -0.00351189f, -0.03804355f, 
    0.00217106f, 0.03749776f, 0.00904818f, 0.02109517f, 0.02237915f, -0.01756711f, 0.01400634f, -0.07408997f, 
    -0.05675071f, 0.01426064f, 0.05342854f, -0.07858527f, 0.00663479f, 0.03660078f, -0.00652221f, 0.03126635f, 
    -0.02511954f, -0.06015256f, 0.07266501f, -0.03140677f, -0.02783404f, -0.07109927f, -0.03964836f, -0.02004604f, 
    0.03956561f, 0.02629292f, 0.02771425f, 0.04950590f, 0.00388882f, -0.06221932f, 0.01823418f, -0.06117014f, 
    0.00164397f, 0.00644186f, 0.01226642f, -0.02184881f, -0.00943392f, -0.04475641f, -0.04871778f, 0.00321577f, 
    0.04829794f, -0.01224226f, 0.02330734f, -0.04276499f, 0.05753206f, 0.06581562f, 0.04820450f, 0.04780772f, 
    0.01254831f, 0.01275268f, -0.04294939f, 0.05239272f, -0.02365660f, -0.07038350f, 0.01930300f, -0.04881144f, 
    0.02533318f, 0.01782789f, 0.00294086f, 0.00797372f, -0.05564909f, -0.01751310f, -0.06979429f, 0.05799608f, 
    0.01287129f, -0.02803131f, -0.00836657f, -0.03548886f, -0.07942587f, -0.05772130f, 0.01760405f, 0.04377235f, 
    0.05978159f, -0.00038447f, 0.04323324f, -0.02865571f, -0.00332685f, 0.02810948f, -0.05842147f, -0.05964315f, 
    0.05180775f, -0.01090215f, -0.01244900f, -0.06452945f, -0.05216833f, 0.02232504f, -0.02507129f, -0.05497520f, 
    -0.07005002f, -0.29764041f, -0.31657949f, -0.06000319f, 0.08832200f, 0.16308004f, -0.15869646f, 0.14426531f, 
    0.07497510f, -0.12497569f, -0.04642135f, -0.04068751f, -0.18609448f, 0.31891823f, -0.02597021f, -0.08129463f, 
    0.06504282f, 0.13520029f, 0.18975976f, 0.17202376f, -0.01413643f, -0.15401840f, -0.08501070f, -0.05823921f, 
    -0.49769256f, 0.03806295f, 0.08087597f, 0.13483012f, 0.05287078f, -0.09200954f, -0.04665208f, 0.04047029f, 
    -0.08731932f, -0.01064423f, 0.05303377f, -0.00766468f, -0.17669968f, 0.03900370f, -0.18660429f, 0.14760676f, 
    -0.04149163f, -0.10205460f, -0.01041437f, -0.15446043f, -0.03892275f, -0.05321540f, 0.07505040f, 0.23338850f, 
    0.21179265f, 0.11787728f, 0.05789245f, -0.04118856f, 0.23648764f, 0.19468547f, 0.04125521f, 0.01678179f, 
    -0.05872585f, -0.16551690f, -0.06067327f, -0.05387148f, -0.04233332f, 0.07113402f, -0.11221178f, 0.00842749f, 
    -0.06121740f, -0.00355485f, -0.11335907f, -0.09000639f, 0.03452104f, 0.06065000f, 0.05268882f, -0.03619961f, 
    -0.15268525f, -0.02305104f, -0.16180956f, -0.09387803f, -0.16034117f, -0.09644497f, -0.09669911f, -0.05705558f, 
    0.01509508f, -0.02344931f, -0.03792388f, 0.19050431f, 0.15665305f, -0.11569061f, -0.13260294f, -0.01253948f, 
    -0.16401653f, -0.13668749f, 0.08323272f, -0.03504978f, -0.02875777f, 0.03373886f, 0.00162570f, -0.10181048f, 
    0.05673736f, -0.09099329f, -0.15757844f, -0.16036360f, 0.17269573f, 0.04058629f, 0.07479531f, 0.10429228f, 
    0.05558326f, 0.06550124f, 0.09589645f, 0.16641167f, 0.02792979f, -0.13144721f, -0.04186466f, 0.00966471f, 
    0.00304140f, -0.02608861f, 0.03542235f, 0.03509329f, 0.19922915f, -0.00527258f, 0.01259510f, 0.10501939f, 
    0.13759135f, 0.14816868f, -0.05438492f, -0.29053763f, 0.20213762f, 0.16238149f, 0.08663840f, 0.10094105f, 
    0.00737669f, -0.06841297f, -0.09915797f, -0.02322459f, -0.04185919f, -0.16986738f, -0.11202723f, 0.05628403f, 
    0.06614716f, -0.05424719f, 0.06406316f, -0.06140058f, 0.09964092f, 0.07547793f, 0.18874240f, 0.22734995f, 
    -0.09680425f, -0.15166248f, 0.05992918f, -0.08102437f, -0.08974240f, -0.05938322f, 0.09400500f, 0.11856937f, 
    0.19384545f, 0.05957936f, 0.16108082f, 0.15694699f, 0.03066405f, -0.12847437f, -0.21689719f, -0.11295170f, 
    0.12003725f, 0.25251937f, 0.10190172f, -0.08460300f, 0.02961244f, -0.02585314f, 0.00852483f, -0.05354930f, 
    0.22189572f, 0.13074628f, 0.29050371f, -0.27400714f, 0.15388627f, -0.01695978f, 0.18838754f, 0.23346731f, 
    0.25464132f, -0.05734761f, -0.00452817f, -0.06421540f, 0.00560471f, -0.14112774f, -0.02023965f, -0.18463834f, 
    -0.03301201f, 0.11366262f, -0.03962296f, -0.05084230f, -0.05421265f, -0.17242998f, -0.15036227f, -0.29813048f, 
    0.24417679f, -0.02608339f, -0.12482893f, -0.05876181f, -0.09890201f, -0.12843788f, 0.25414732f, 0.09651989f, 
    -0.03562345f, 0.07517451f, -0.06568240f, 0.03020834f, -0.16795512f, -0.29586899f, 0.09528109f, -0.22216025f, 
    -0.04012684f, 0.00116876f, 0.04386545f, -0.05024349f, 0.08521229f, -0.03453167f, 0.03412428f, -0.01123404f, 
    -0.17645131f, 0.41314685f, -0.49944666f, -0.17611520f, 0.06848127f, 0.07010524f, 0.21330918f, 0.07859196f, 
    0.08537669f, 0.08388133f, -0.19539756f, 0.12454146f, 0.37129658f, -0.27666748f, 0.10453272f, 0.07361580f, 
    0.00399437f, 0.02924389f, 0.10723794f, 0.02124747f, 0.03248158f, 0.04442939f, -0.08346409f, 0.00305274f, 
    -0.09252254f, 0.02794583f, -0.16488765f, -0.06067824f, -0.02566211f, 0.10396089f, 0.05844386f, -0.11967040f, 
    -0.11271563f, -0.10999075f, 0.06287987f, 0.01796442f, -0.02607358f, -0.54551768f, -0.14821240f, 0.21473807f, 
    0.16678043f, 0.23775938f, -0.12835731f, 0.03187809f, 0.06675004f, -0.01424032f, 0.13414927f, 0.03271464f, 
    0.13371094f, -0.01724156f, -0.08367460f, -0.00000161f, 0.11974929f, 0.03679280f, 0.12117539f, 0.01079669f, 
    0.17668766f, 0.16286339f, -0.04217823f, -0.08278701f, -0.08620985f, 0.08677392f, 0.54355371f, 0.36011031f, 
    0.02706739f, -0.06567063f, -0.11826897f, -0.09345723f, -0.10905875f, -0.02071572f, 0.02155037f, 0.06532073f, 
    0.18977284f, 0.02056812f, -0.13610603f, -0.01868335f, -0.16007303f, 0.00115259f, 0.01835444f, 0.05078295f, 
    0.13719660f, 0.01990603f, 0.02695155f, 0.07389553f, -0.04266800f, -0.00836845f, -0.09545844f, -0.02877848f, 
    0.00030110f, -0.02181832f, 0.03004518f, 0.17637271f, -0.01413764f, -0.02486254f, 0.10017066f, 0.01472505f, 
    0.02107870f, 0.43873391f, 0.04491061f, -0.14342070f, 0.04778073f, 0.02454066f, 0.08109419f, 0.02784634f, 
    -0.24750766f, -0.02012222f, 0.07759033f, -0.04218695f, 0.03987845f, 0.05480679f, 0.01910048f, 0.30221474f, 
    0.02408056f, -0.05333611f, 0.12286220f, -0.07146994f, 0.06125311f, 0.06650972f, 0.01357187f, -0.02004909f, 
    0.03908926f, -0.12932073f, 0.10909160f, 0.18972835f, 0.00559426f, 0.12855336f, 0.04102783f, -0.12851621f, 
    -0.02511578f, 0.11959593f, -0.28316841f, 0.03560103f, 0.12183110f, -0.05753808f, 0.18739779f, -0.03380002f, 
    0.13615865f, -0.10525289f, -0.17439154f, -0.09393233f, -0.09710027f, -0.02004251f, 0.00808339f, 0.09051929f, 
    -0.04627671f, -0.21410345f, -0.18648277f, 0.17996719f, -0.16578303f, 0.14125277f, 0.17325014f, -0.17677085f, 
    -0.15206967f, -0.05049576f, -0.03969024f, -0.00286295f, 0.01483959f, -0.05359906f, 0.08818658f, 0.03605011f, 
    -0.00917277f, 0.08410421f, 0.11429978f, -0.01535627f, -0.09210700f, -0.24043418f, -0.09852554f, -0.08402137f, 
    -0.17344363f, -0.09311716f, 0.33775389f, -0.24780993f, -0.02387011f, 0.01075384f, 0.03371042f, -0.11567657f, 
    0.11994358f, 0.02669698f, 0.16183892f, 0.13283581f, 0.16776958f, 0.01429278f, 0.10852718f, 0.13732579f, 
    -0.07382447f, 0.03969421f, -0.05232040f, -0.12910005f, 0.04831664f, -0.03881375f, -0.17202316f, 0.01503177f, 
    0.58471620f, -0.29209024f, 0.37515447f, 0.08722813f, -0.06532092f, -0.13502984f, 0.00818724f, -0.02594336f, 
    -0.08115581f, -0.03563741f, -0.01503354f, 0.05363276f, 0.38866612f, 0.07028228f, 0.23799148f, 0.09757756f, 
    -0.12745592f, -0.02220185f, 0.01615538f, -0.00026979f, 0.00857197f, 0.02544271f, -0.02070585f, -0.00180954f, 
    0.03349461f, 0.07804739f, 0.04207402f, -0.00287758f, 0.03840481f, 0.06039604f, -0.14785236f, -0.06085126f, 
    -0.02607779f, -0.06948996f, -0.07728941f, 0.04988227f, 0.41384932f, 0.42351028f, 0.06519805f, -0.05569174f, 
    -0.15371932f, -0.22225492f, -0.05534209f, -0.00647483f, -0.14254400f, -0.04125868f, 0.03867212f, -0.03695272f, 
    0.16369069f, 0.04073488f, 0.16635112f, -0.04794692f, 0.00202149f, 0.21696459f, -0.08658799f, -0.01412973f, 
    0.02154570f, 0.04302229f, -0.10054032f, -0.05592174f, -0.27393231f, -0.47522464f, 0.14726129f, 0.12609108f, 
    0.00169651f, 0.07930823f, 0.03257655f, -0.00732518f, -0.07927044f, -0.01525441f, -0.12792867f, 0.10194277f, 
    0.09724937f, 0.13132399f, 0.29707223f, 0.06017356f, -0.08432519f, 0.11115542f, 0.08698606f, -0.01138884f, 
    -0.09317300f, 0.02247411f, -0.04661423f, -0.08347365f, 0.08230510f, 0.17671053f, 0.04388260f, 0.08261716f, 
    -0.02524906f, 0.00783089f, 0.03037227f, -0.19644755f, -0.05023949f, 0.06502550f, -0.08802835f, -0.12048825f, 
    -0.18085183f, 0.05968717f, 0.05447656f, 0.38526723f, -0.10441073f, -0.12930281f, -0.02449713f, 0.06856164f, 
    0.06382611f, 0.08002273f, -0.02305767f, 0.01766127f, 0.17529662f, 0.00781445f, 0.15379640f, 0.18322200f, 
    -0.05195946f, -0.03916830f, -0.11499818f, 0.07386880f, 0.12741466f, -0.04631964f, 0.01283186f, -0.01300976f, 
    0.14129810f, 0.36771512f, -0.17939898f, 0.18300860f, -0.12882334f, 0.08481393f, 0.15420219f, 0.05595563f, 
    -0.32513341f, 0.01853770f, -0.01016308f, 0.02274219f, 0.07815003f, 0.05376055f, -0.14925022f, -0.08954468f, 
    -0.17676653f, -0.07467698f, 0.03508760f, -0.03113689f, 0.01354122f, 0.00557470f, -0.04876693f, -0.02931606f, 
    -0.36712530f, 0.15135878f, -0.14900114f, 0.33169705f, -0.08905538f, 0.15372090f, -0.00859372f, -0.12711079f, 
    0.06400495f, 0.08155072f, -0.04510948f, 0.02110418f, 0.18582003f, 0.21990539f, -0.01673119f, 0.06533705f, 
    0.02024985f, -0.02457344f, -0.08874575f, 0.00732082f, 0.08478867f, 0.09606281f, 0.05357206f, 0.19583452f, 
    0.47985888f, -0.03958040f, -0.16803865f, 0.04634510f, 0.00670851f, -0.23859601f, 0.04460903f, 0.16606911f, 
    0.09579837f, -0.07418916f, -0.19551501f, -0.06661073f, -0.25342911f, -0.07221569f, 0.33639011f, 0.00364539f, 
    -0.03765170f, -0.03831569f, 0.09115557f, 0.22750063f, 0.00631045f, 0.00794461f, -0.09881013f, -0.04936424f, 
    -0.28618428f, 0.25670674f, -0.17334642f, -0.01979904f, -0.03675718f, -0.07973715f, 0.06830037f, -0.10434800f, 
    -0.00846589f, 0.24554186f, -0.11840989f, 0.05768799f, 0.07857797f, -0.31435531f, 0.00330008f, -0.08096657f, 
    -0.21669330f, -0.22770005f, -0.08950755f, -0.03793295f, 0.01175035f, 0.04241723f, -0.00868174f, 0.08166446f, 
    -0.12961063f, -0.09548273f, 0.01018830f, 0.11528136f, 0.08929498f, 0.21758822f, -0.00001266f, -0.07081761f, 
    0.01633052f, -0.07867993f, 0.05407998f, 0.07630651f, -0.32750368f, -0.40881756f, -0.19648474f, -0.01961972f, 
    -0.00308341f, 0.13309938f, -0.15194112f, -0.05376552f, 0.05643242f, 0.02987101f, 0.02063807f, -0.03341313f, 
    0.08370585f, -0.29030728f, -0.24043828f, -0.16882455f, -0.10695142f, -0.16766462f, -0.00030559f, -0.15966702f, 
    0.03821195f, 0.07780564f, -0.06192052f, 0.05773992f, -0.01133095f, 0.20011781f, 0.41647443f, 0.24473175f, 
    -0.10191378f, -0.06464075f, -0.14685379f, -0.09925969f, 0.20084077f, 0.03058936f, 0.08210348f, 0.04247842f, 
    0.02011698f, 0.01931097f, -0.00451139f, 0.04225714f, -0.01363501f, 0.24836023f, 0.17256568f, 0.02941212f, 
    -0.01940342f, -0.06273686f, 0.17106313f, 0.08375646f, -0.15128902f, 0.08912493f, -0.10123110f, 0.09971932f, 
    0.06724624f, -0.04450317f, 0.09791840f, 0.17480789f, -0.05285517f, 0.20348337f, 0.06068841f, -0.02119275f, 
    -0.28358036f, -0.04413468f, -0.04302799f, -0.02867058f, 0.11397364f, 0.09343668f, -0.07437666f, 0.10180800f, 
    -0.14710085f, 0.07660687f, -0.06757362f, 0.13251628f, 0.00612135f, 0.33996016f, -0.27845868f, 0.09998423f, 
    -0.00918174f, -0.03834261f, -0.07406863f, -0.17591447f, 0.24905315f, -0.01289601f, 0.03510403f, 0.16926642f, 
    0.06493582f, 0.09925440f, 0.14792819f, 0.00601006f, -0.00789226f, 0.08770829f, 0.08346228f, 0.06159817f, 
    0.26955932f, 0.12408414f, 0.02423527f, 0.13461581f, -0.01573153f, 0.19312961f, 0.07051704f, 0.06997176f, 
    -0.09465478f, 0.16145398f, -0.07927232f, -0.09442574f, 0.09885114f, -0.03376267f, 0.15602967f, -0.02649844f, 
    -0.01005431f, -0.10476770f, 0.19929592f, 0.17908348f, 0.04523839f, 0.02914272f, 0.12117434f, 0.19036746f, 
    0.07150214f, -0.03229249f, -0.04765109f, -0.05834553f, -0.09821496f, -0.11776351f, 0.07625929f, -0.15009221f, 
    0.01411985f, 0.11451450f, 0.03155330f, -0.13906667f, -0.18579207f, -0.24640524f, -0.18361560f, -0.19044244f, 
    -0.23578872f, 0.15962917f, 0.04636584f, 0.06393791f, 0.14840476f, -0.08096363f, 0.00196377f, -0.20979869f, 
    0.10333543f, 0.06991124f, 0.09307299f, 0.18128857f, -0.04316102f, 0.20911735f, 0.15784302f, 0.09030063f, 
    0.03412656f, -0.08435457f, 0.01537611f, 0.11435832f, 0.07256891f, -0.00304826f, 0.05766901f, 0.03704858f, 
    -0.04433793f, -0.02473368f, -0.34640107f, 0.35329559f, -0.02631653f, 0.10221759f, 0.06023797f, -0.17933179f, 
    0.04232993f, -0.22539949f, 0.19292802f, 0.00411983f, -0.10037526f, -0.08393836f, -0.01119620f, 0.18278079f, 
    0.09314674f, 0.11647907f, 0.03981418f, -0.03607132f, -0.00464950f, 0.07739024f, -0.03431842f, 0.06658143f, 
    -0.01598272f, 0.15164432f, 0.10863096f, 0.10770547f, -0.03125064f, -0.05600899f, 0.01123786f, 0.12446820f, 
    0.11232010f, 0.14810821f, 0.01572607f, 0.04305814f, 0.44222870f, 0.36373308f, 0.17989290f, -0.25905198f, 
    0.18953712f, -0.04463995f, 0.07237707f, 0.10179976f, -0.04592747f, -0.01733600f, -0.14314276f, -0.11676454f, 
    -0.08943883f, -0.17237696f, 0.04797644f, 0.18741550f, 0.16217832f, 0.21860991f, 0.16169555f, 0.04615705f, 
    -0.06567848f, 0.01137093f, -0.14927635f, -0.23939329f, -0.00220342f, -0.34660417f, -0.08391905f, -0.01324412f, 
    -0.13962106f, -0.03067378f, -0.10483464f, 0.09025052f, 0.06416374f, 0.12656055f, -0.02570057f, -0.03642893f, 
    0.17367306f, 0.17440431f, 0.26095033f, 0.21156263f, 0.05144371f, 0.02815388f, -0.02211769f, 0.13242076f, 
    -0.17580889f, -0.12752481f, -0.11426844f, -0.32386082f, -0.15689646f, -0.25722203f, -0.02223129f, -0.33909303f, 
    0.06696660f, -0.16674781f, -0.03935130f, -0.03485150f, -0.10347743f, -0.01617662f, -0.38947439f, -0.08179418f, 
    0.23586418f, 0.30196229f, 0.31118754f, 0.29062358f, 0.13566309f, 0.03511916f, -0.02131365f, 0.08316773f, 
    0.06089113f, 0.20462961f, 0.03128548f, 0.01954921f, 0.06608336f, -0.34489387f, -0.05220995f, -0.16055238f, 
    -0.05393042f, 0.10695459f, -0.06528894f, 0.13458523f, 0.10459766f, 0.09786411f, 0.02971148f, -0.02673603f, 
    0.12037204f, 0.08534219f, -0.18647991f, -0.00446393f, 0.00756053f, -0.10799203f, -0.16955043f, -0.21030910f, 
    -0.07845844f, -0.00390291f, -0.12903912f, -0.09405997f, 0.21624179f, 0.01053885f, 0.01480521f, -0.02412385f, 
    -0.02621038f, -0.02282689f, -0.00075410f, -0.02865162f, 0.00179544f, 0.01573383f, 0.01237837f, -0.08716229f, 
    -0.05486973f, -0.21949491f, 0.16696642f, 0.14706606f, -0.08537785f, -0.00233485f, -0.12122685f, -0.28933361f, 
    -0.04598373f, 0.06505728f, -0.04296606f, -0.05910016f, 0.19166248f, 0.16746292f, -0.12301514f, 0.15795982f, 
    0.17898269f, 0.11721700f, -0.00283151f, 0.09784622f, 0.14834230f, 0.11318301f, 0.08230704f, 0.18569842f, 
    0.15095010f, 0.08361395f, -0.19735195f, -0.20639209f, -0.10395181f, 0.16200222f, 0.16630273f, 0.19991986f, 
    -0.08839709f, 0.13490832f, 0.05060877f, 0.04663632f, -0.61129713f, 0.06188430f, -0.06675588f, -0.15496092f, 
    0.06947739f, 0.00880743f, 0.21340197f, -0.07335909f, 0.06413445f, -0.04195541f, -0.00338310f, 0.05888012f, 
    -0.11968105f, 0.20454367f, -0.35257578f, 0.20057993f, 0.25325650f, -0.00651186f, 0.14875284f, -0.02738404f, 
    -0.02154655f, -0.06528313f, -0.02907142f, -0.01432180f, 0.25172058f, -0.18879876f, -0.04302236f, 0.15675575f, 
    0.01374452f, -0.01125805f, 0.02118638f, 0.00456616f, -0.03990912f, -0.07853598f, 0.02268746f, 0.04002345f, 
    0.01601542f, 0.05721037f, -0.03928253f, -0.07600458f, 0.04751647f, 0.03513601f, 0.24500172f, -0.00060532f, 
    0.00532823f, -0.03653109f, 0.10468943f, -0.02046361f, 0.34956530f, -0.47354135f, -0.14943923f, 0.07013655f, 
    0.06867648f, 0.19867250f, -0.06480382f, 0.08557932f, 0.03840451f, -0.08867141f, -0.10039420f, 0.04205792f, 
    -0.03444236f, 0.00200931f, -0.02721547f, -0.02087285f, 0.01938904f, -0.20633818f, -0.08119404f, -0.07775123f, 
    0.08880581f, -0.07539261f, -0.01986351f, 0.00454526f, -0.33332357f, -0.14815983f, 0.16722809f, 0.26017120f, 
    0.00641620f, -0.16396298f, -0.08442417f, 0.02786097f, 0.11239763f, 0.02347822f, 0.20949847f, 0.20845726f, 
    0.17633665f, -0.05872818f, -0.13508847f, -0.24175715f, 0.14965329f, -0.10717254f, -0.15925463f, 0.06688154f, 
    0.07966731f, 0.12945440f, 0.02372733f, 0.05104738f, 0.18942542f, -0.12271940f, -0.01107805f, 0.02289520f, 
    0.05062815f, -0.12927094f, -0.05311477f, 0.06029282f, -0.02210899f, -0.19270906f, 0.07848746f, 0.05697660f, 
    -0.01789605f, 0.00681189f, 0.17524597f, -0.24767885f, -0.05188325f, -0.12984498f, 0.11767858f, -0.01792623f, 
    0.03746287f, 0.06396663f, -0.05488753f, -0.09008830f, 0.13825585f, -0.20163895f, 0.06417358f, 0.11153542f, 
    0.07340649f, -0.10764688f, 0.06755421f, 0.01238766f, -0.15390722f, 0.23063622f, -0.03004467f, 0.16798930f, 
    -0.25895622f, -0.14292386f, 0.07137908f, 0.04397301f, -0.01926999f, -0.07110467f, -0.09185804f, -0.02592738f, 
    0.00680819f, 0.08799152f, -0.17139548f, 0.04946564f, 0.00139908f, -0.18983781f, 0.09450781f, -0.04042459f, 
    0.07470416f, 0.01957966f, -0.01038082f, -0.13198735f, -0.03136161f, 0.07533261f, 0.09442834f, 0.10236647f, 
    -0.03071695f, -0.21320392f, 0.24905999f, 0.05501765f, 0.09441648f, -0.14547919f, 0.24844109f, 0.16944677f, 
    0.00312405f, 0.06365829f, 0.12369189f, 0.08575482f, 0.13105997f, -0.08770967f, 0.06799736f, 0.12734115f, 
    0.10793260f, 0.12379173f, -0.00905242f, 0.15295170f, 0.01103436f, -0.13866019f, 0.18047713f, 0.00702099f, 
    0.12141440f, 0.13726705f, 0.11719717f, -0.20806012f, -0.01260847f, -0.04783218f, 0.21470344f, -0.09042054f, 
    0.14086998f, 0.02286076f, 0.01086724f, 0.09552473f, -0.26314721f, -0.12498581f, -0.02478068f, -0.07538486f, 
    -0.08577077f, -0.11153524f, 0.04371493f, -0.04057461f, 0.00047172f, -0.01424929f, 0.07367547f, 0.02482240f, 
    0.11578575f, 0.05677404f, -0.22600526f, 0.18719777f, -0.01664800f, 0.00174276f, 0.07756352f, -0.10139309f, 
    -0.06403074f, -0.02300647f, -0.00362016f, -0.01321278f, 0.30212760f, -0.12355676f, 0.20208314f, 0.03343454f, 
    -0.09155988f, -0.03808919f, -0.02777223f, 0.05333249f, -0.04829222f, 0.04281429f, -0.11768425f, -0.07383193f, 
    -0.26126206f, -0.02809701f, 0.03492846f, -0.05206237f, 0.04742794f, 0.06299791f, -0.09784303f, -0.01445296f, 
    0.13130106f, 0.18231262f, 0.18551178f, 0.05327409f, 0.25856772f, 0.02867763f, -0.02669376f, -0.12641177f, 
    0.08243284f, -0.09905025f, -0.04435974f, 0.16561976f, -0.07913024f, -0.13157836f, -0.09520002f, -0.02951619f, 
    0.15518230f, -0.05107998f, -0.00733280f, 0.09168903f, 0.15721461f, 0.15484551f, 0.05971798f, -0.04837333f, 
    -0.03174121f, 0.01773899f, -0.01264245f, -0.18030085f, 0.06062691f, -0.06430506f, 0.41081351f, 0.56486547f, 
    0.01271265f, 0.03301129f, -0.22747695f, -0.11851494f, 0.10168159f, 0.06593577f, 0.04945489f, 0.06192043f, 
    0.23829851f, 0.16519250f, 0.13231559f, 0.11202472f, -0.07850092f, 0.10881967f, -0.02575217f, 0.00064637f, 
    -0.25512075f, -0.16770898f, -0.11344522f, -0.24641420f, 0.07481606f, -0.05522360f, 0.04471358f, -0.00407276f, 
    0.00698568f, -0.00910992f, 0.04654283f, -0.10231473f, 0.01176351f, 0.00017199f, -0.22760311f, -0.18511878f, 
    -0.10752395f, 0.23622611f, 0.13111502f, 0.23640515f, 0.02319183f, -0.06023207f, -0.13070063f, -0.02263860f, 
    0.04347347f, 0.11413355f, 0.06540354f, 0.04710382f, 0.17961165f, 0.19829811f, -0.01795235f, 0.13251325f, 
    -0.18138915f, 0.00192391f, 0.04064421f, -0.05296224f, 0.11242541f, 0.12087719f, -0.04046906f, -0.03989895f, 
    0.22744755f, 0.10192101f, 0.09131635f, 0.01131208f, -0.11678957f, 0.03227934f, -0.08912069f, -0.02454043f, 
    -0.12159749f, 0.01697991f, -0.22316630f, -0.09745364f, 0.18193427f, 0.10280013f, 0.13350008f, -0.15510640f, 
    -0.09011301f, -0.18455642f, -0.10313983f, -0.17329091f, -0.04175412f, 0.06424295f, 0.00952406f, -0.01903148f, 
    -0.11404999f, -0.12235600f, -0.02001913f, 0.29946616f, -0.04062743f, 0.06791075f, 0.02312513f, -0.15606213f, 
    0.01142626f, 0.09527910f, -0.11722665f, -0.06226464f, 0.26398420f, 0.10356379f, -0.02035205f, 0.16967930f, 
    0.01580915f, 0.02167467f, 0.12204066f, -0.00770063f, -0.01249647f, 0.04448668f, 0.17100322f, 0.25546536f, 
    0.29750252f, -0.27028930f, 0.11529504f, 0.07146992f, 0.14946805f, 0.00964101f, -0.00676424f, 0.07205938f, 
    0.06300068f, 0.15514736f, 0.09774182f, 0.15845264f, 0.18524864f, -0.36677051f, 0.03256483f, 0.06094152f, 
    0.04303462f, 0.07098006f, -0.13021863f, -0.18398039f, -0.23719834f, -0.17752895f, -0.10660736f, -0.12587176f, 
    0.49048692f, -0.07560042f, 0.50570363f, -0.12289821f, -0.07719274f, -0.02630388f, 0.01476139f, -0.05818932f, 
    -0.06833715f, 0.07337213f, 0.00747182f, 0.05934138f, 0.30615413f, 0.20215058f, 0.22304478f, -0.06873447f, 
    -0.18096675f, -0.11426482f, -0.05559529f, 0.02531299f, -0.05400309f, -0.09597019f, 0.07747421f, 0.03052950f, 
    0.05631248f, -0.22117577f, -0.17850944f, -0.02098809f, -0.13690223f, 0.09002825f, 0.25554642f, -0.08034804f, 
    0.03998847f, -0.09378845f, 0.03341874f, -0.06830455f, -0.16333157f, 0.21295451f, -0.06162477f, 0.25942889f, 
    0.06863128f, -0.01754515f, -0.05652736f, -0.15716340f, -0.12251447f, -0.07383397f, -0.02616022f, 0.08798338f, 
    0.19862713f, 0.11690612f, 0.11137763f, 0.02440817f, -0.09416115f, 0.00026124f, -0.10814005f, -0.14341679f, 
    -0.12798043f, -0.11249208f, -0.09252486f, -0.23138098f, 0.00873267f, 0.04932741f, 0.35894200f, -0.15972100f, 
    0.02155546f, 0.06077750f, 0.16016473f, 0.10033812f, 0.00239336f, 0.11944976f, 0.10616469f, 0.24134451f, 
    -0.21371311f, -0.01342026f, -0.18949866f, -0.09590387f, 0.02071185f, -0.12014935f, 0.01094226f, -0.16476500f, 
    -0.17240214f, 0.02837505f, -0.17735410f, -0.10406175f, 0.07837564f, 0.23662880f, 0.00271972f, 0.22596660f, 
    -0.02398497f, 0.09620629f, 0.19776222f, -0.06312586f, -0.00610447f, -0.19212824f, 0.07879842f, -0.04852735f, 
    -0.34504724f, -0.33620122f, -0.49504733f, 0.01173354f, -0.07097577f, 0.04345741f, -0.17175499f, 0.02660504f, 
    0.03844909f, -0.03388897f, -0.01761463f, -0.00399832f, -0.05370798f, 0.26075950f, 0.04727282f, -0.04489319f, 
    -0.14546941f, -0.05668324f, 0.05654198f, 0.05091818f, 0.23707634f, 0.19843686f, 0.08108284f, 0.13171270f, 
    0.00434542f, 0.26684913f, 0.00927849f, 0.16760884f, -0.00558455f, -0.00345975f, 0.11984780f, 0.17494859f, 
    -0.13235287f, 0.04326514f, 0.15939893f, 0.03376435f, -0.22409809f, 0.24029751f, 0.07671127f, 0.34011790f, 
    0.01230471f, -0.03784894f, 0.25940850f, 0.02597252f, 0.07515617f, 0.20340820f, -0.06065333f, 0.02611789f, 
    0.15029849f, 0.18544547f, -0.05841533f, 0.03813655f, 0.13824661f, 0.21936849f, 0.16095589f, 0.30305037f, 
    -0.04058496f, 0.06579095f, 0.14675900f, -0.01479611f, -0.32859007f, -0.00400898f, 0.13923827f, -0.08468391f, 
    -0.28102952f, -0.05361565f, 0.00201450f, -0.15839991f, 0.01246174f, 0.14847878f, 0.02746973f, 0.23334515f, 
    0.03276330f, -0.06336685f, -0.04526837f, 0.02555884f, -0.06653831f, -0.00930565f, -0.02456462f, 0.05044134f, 
    -0.06838777f, 0.06366768f, -0.03396938f, -0.06208542f, 0.03909089f, 0.03700555f, -0.04451293f, -0.03819831f, 
    -0.05827222f, -0.05080210f, 0.00421266f, -0.02120898f, -0.05609110f, 0.05508379f, -0.05608086f, -0.04766926f, 
    -0.04021616f, -0.07829890f, 0.00840495f, -0.00857860f, 0.04387436f, 0.03413583f, -0.02382198f, 0.02092078f, 
    -0.05843670f, 0.01338699f, -0.07414249f, -0.02373346f, -0.03516157f, -0.00085933f, -0.00135873f, 0.05282125f, 
    0.02499441f, 0.05775328f, 0.03808365f, -0.00028696f, -0.02961472f, 0.02610090f, 0.02502826f, 0.05822118f, 
    -0.05688859f, 0.00101872f, -0.00717142f, -0.04925075f, -0.02070651f, -0.07810194f, -0.05464926f, 0.03488416f, 
    -0.07992882f, -0.06551109f, 0.03366427f, -0.00948610f, 0.02066710f, 0.02754337f, 0.00814987f, -0.06852832f, 
    -0.01927191f, 0.01474775f, -0.02811163f, -0.01777908f, 0.03939194f, 0.00691131f, 0.05996788f, -0.05082558f, 
    -0.01640466f, -0.04551103f, -0.00863999f, 0.05287940f, -0.07773922f, 0.00245788f, -0.02795305f, -0.01203874f, 
    -0.02371923f, -0.04681250f, -0.04673064f, -0.03332692f, -0.01812474f, -0.02003847f, 0.01131904f, 0.05661280f, 
    -0.07126796f, 0.01543820f, -0.02357655f, 0.01285391f, -0.04108150f, -0.03119070f, -0.02141410f, 0.00816254f, 
    -0.00343759f, 0.02026458f, -0.07552454f, 0.00300471f, -0.04400855f, -0.06081276f, -0.00994563f, -0.00263489f, 
    0.05769457f, -0.06460737f, -0.06963367f, 0.04936678f, 0.06522436f, 0.05988738f, -0.05157459f, -0.03173157f, 
    0.01924411f, 0.05519560f, 0.05286723f, -0.06364229f, 0.00888005f, 0.05429412f, -0.04615786f, 0.03128014f, 
    -0.00998425f, -0.04210434f, -0.04254171f, -0.04315401f, -0.03538588f, -0.06032225f, 0.00208203f, -0.05736105f, 
    -0.06272446f, 0.01534064f, -0.01540260f, 0.01305990f, 0.04433543f, -0.05082025f, 0.01097675f, 0.01714694f, 
    0.01937541f, -0.04050504f, 0.04061953f, -0.06590577f, 0.04665679f, 0.02214146f, 0.01015748f, -0.01777650f, 
    0.00012801f, -0.06629776f, -0.01676922f, -0.07301258f, 0.01528785f, -0.00071445f, -0.06959352f, -0.04130401f, 
    0.06042816f, -0.06184907f, 0.02371025f, -0.07747679f, 0.00479205f, 0.04871547f, -0.03211536f, -0.02986498f, 
    -0.08058611f, -0.04839052f, 0.06121026f, -0.05385469f, -0.03211788f, -0.01384008f, 0.02429912f, 0.01840458f, 
    -0.03649226f, -0.02153763f, 0.03801985f, 0.05473492f, -0.02801434f, 0.03977758f, 0.03560192f, 0.03165356f, 
    -0.01699511f, -0.00083024f, -0.06341663f, -0.01416724f, 0.05979296f, -0.00685336f, -0.03694218f, -0.03588300f, 
    0.00666816f, -0.01139736f, -0.07382587f, 0.05260215f, -0.06413969f, -0.05310543f, -0.06912613f, -0.05025762f, 
    -0.01107255f, -0.06393068f, 0.02968966f, -0.05247740f, 0.03314291f, 0.00980795f, -0.00039245f, -0.02472925f, 
    -0.05305845f, -0.00005850f, -0.06412728f, -0.06160717f, 0.02155769f, 0.04518338f, -0.05675404f, 0.04399814f, 
    -0.00788781f, -0.04853662f, -0.08134925f, 0.01991570f, 0.01950564f, -0.03280999f, -0.07565157f, -0.06453587f, 
    -0.01535691f, 0.01661155f, -0.06604805f, -0.03866333f, 0.04055162f, -0.08578295f, 0.03308909f, 0.00525699f, 
    -0.00631119f, -0.03421478f, -0.00649617f, -0.01576760f, 0.05515211f, 0.01398570f, -0.00921615f, -0.00004404f, 
    0.01910255f, 0.01637067f, -0.01659473f, -0.06392352f, -0.04460070f, 0.02003343f, 0.04073400f, -0.02746723f, 
    -0.08240081f, 0.01718228f, -0.06288031f, -0.06429363f, -0.09778663f, -0.02922020f, 0.02135981f, -0.07465394f, 
    -0.09572291f, -0.07522912f, -0.02434835f, -0.02216121f, -0.01372552f, 0.00371204f, 0.00827394f, -0.03016848f, 
    -0.03216892f, -0.09067164f, -0.00619370f, -0.00817830f, -0.03352225f, -0.02856056f, 0.05117542f, 0.05142736f, 
    -0.05565484f, -0.00277762f, -0.02940512f, 0.00405926f, -0.00638412f, -0.06996102f, -0.06528806f, 0.00247654f, 
    -0.06232506f, 0.04746739f, 0.01362651f, -0.01994981f, -0.01000728f, 0.02655319f, -0.08042109f, 0.02164049f, 
    -0.02622635f, -0.02314669f, 0.03055066f, -0.01871971f, -0.00099603f, -0.01368777f, -0.00901151f, -0.07945926f, 
    0.03595084f, -0.03954569f, -0.02764892f, -0.01948769f, -0.05698157f, -0.06447491f, -0.01878548f, -0.06893513f, 
    0.02640362f, -0.07398114f, -0.00930343f, -0.05118217f, -0.05641025f, -0.01937529f, -0.02835702f, -0.07260982f, 
    -0.02713086f, 0.00286463f, -0.03771508f, -0.08037408f, -0.02210059f, -0.04891379f, 0.00223295f, 0.00602276f, 
    -0.05297885f, -0.07178251f, -0.04222280f, -0.04642520f, 0.01659539f, 0.04372867f, 0.02826368f, 0.05698103f, 
    -0.01540852f, 0.01775897f, 0.01936480f, 0.05641344f, -0.02560967f, -0.04577220f, 0.05701797f, -0.04826604f, 
    -0.05808881f, -0.02802296f, -0.05248261f, -0.02013935f, 0.00487127f, -0.06084871f, -0.02969542f, 0.01089672f, 
    0.05332575f, 0.02061367f, -0.03220764f, -0.01208335f, -0.03930695f, -0.06827006f, -0.05952030f, 0.04653013f, 
    -0.09146427f, 0.00399756f, 0.00269669f, 0.00489203f, 0.01349834f, 0.01578448f, 0.00864296f, -0.03362801f, 
    0.04949641f, 0.03990837f, 0.00592960f, -0.07620807f, -0.00606768f, -0.02533426f, -0.06377035f, 0.03142875f, 
    -0.04599594f, -0.08678774f, 0.00553759f, -0.08203758f, 0.00717573f, -0.06534377f, 0.03217423f, 0.05733041f, 
    -0.08079617f, 0.03388092f, -0.07154132f, -0.03133928f, -0.01712655f, -0.04622475f, -0.03984052f, -0.05734878f, 
    0.01592203f, 0.05288561f, -0.04271066f, -0.03717749f, 0.09854483f, 0.01970443f, 0.02236892f, 0.02236263f, 
    -0.07551003f, 0.08022610f, -0.13804194f, -0.05168017f, -0.08973025f, 0.26280937f, 0.05897083f, 0.13373329f, 
    -0.02652606f, -0.02559616f, -0.01842324f, -0.01094977f, -0.57120126f, -0.04346764f, -0.17403917f, 0.03752760f, 
    0.06859582f, 0.01709496f, 0.09726684f, 0.07088248f, -0.04269686f, -0.02935494f, 0.05549529f, -0.08252046f, 
    0.09034584f, 0.13961180f, -0.09113594f, 0.00953864f, 0.12439778f, 0.13486144f, -0.00582086f, 0.10068016f, 
    -0.11727969f, -0.14082159f, 0.08928039f, 0.04085267f, 0.16770029f, 0.22361103f, -0.08396915f, 0.11918176f, 
    0.07710002f, -0.01314324f, 0.00210600f, -0.13120782f, -0.01667315f, -0.03995829f, 0.12202174f, 0.03766185f, 
    0.03793260f, -0.14717536f, -0.00810038f, 0.05746358f, 0.04472154f, 0.04318594f, 0.18174389f, 0.02273040f, 
    -0.02880456f, 0.01739226f, -0.03052853f, 0.03347057f, 0.23194566f, -0.03394880f, 0.07097225f, 0.03219270f, 
    -0.03210311f, 0.22728579f, -0.05356590f, -0.11918099f, -0.03161035f, -0.01235330f, -0.09488561f, 0.04348022f, 
    -0.05546588f, 0.07402711f, -0.05157274f, -0.09816629f, 0.15342680f, -0.07659754f, -0.07451757f, -0.07153075f, 
    0.01319862f, 0.08538226f, 0.05730292f, 0.07869268f, -0.09626333f, -0.10863012f, -0.13750911f, 0.01105803f, 
    -0.05827247f, -0.08625183f, -0.05010274f, -0.11441080f, 0.19571519f, 0.18840799f, 0.09545919f, 0.13335423f, 
    -0.11301401f, -0.06820972f, -0.01669466f, -0.22802973f, 0.07692834f, -0.08659524f, -0.14626864f, 0.09138730f, 
    0.07952493f, 0.06232022f, -0.01683793f, 0.05185114f, 0.15396379f, -0.11903455f, 0.04727899f, 0.07093223f, 
    0.10237420f, 0.03122765f, -0.06543317f, 0.19346352f, 0.19881521f, -0.13034177f, 0.08909672f, 0.17335035f, 
    0.07454766f, -0.17066731f, 0.10538717f, -0.30361897f, 0.09975339f, -0.14487329f, 0.16774873f, -0.09823080f, 
    0.07376121f, -0.02726518f, -0.03336845f, -0.02221108f, 0.02949851f, -0.17932636f, -0.00347722f, 0.08566032f, 
    0.01615222f, -0.09109820f, 0.01631653f, -0.06383325f, -0.10074585f, 0.19999141f, 0.07028564f, 0.23237196f, 
    -0.17592032f, -0.03952162f, 0.07443186f, 0.08066808f, 0.01529693f, -0.23685700f, -0.03802150f, 0.06088867f, 
    0.22574720f, 0.14144963f, 0.14450654f, 0.08558235f, -0.09586041f, -0.28100812f, -0.07619800f, 0.03979994f, 
    0.03074682f, 0.01508653f, -0.02048883f, -0.01289781f, -0.03896739f, 0.06601369f, 0.01531070f, 0.15734854f, 
    0.09408666f, -0.12741034f, 0.25670567f, -0.03845705f, 0.14153789f, 0.03512482f, 0.04827351f, 0.27643862f, 
    0.10708409f, 0.10912121f, 0.21274866f, 0.10256943f, 0.13814448f, -0.10489272f, 0.00016119f, 0.04760244f, 
    -0.03610205f, 0.03077686f, 0.10121121f, 0.03761019f, 0.03904227f, 0.03793127f, 0.07913537f, -0.21860087f, 
    -0.52607143f, 0.12375441f, -0.06359927f, 0.33898464f, -0.08009828f, 0.04146178f, -0.05307503f, 0.03870386f, 
    0.01398757f, -0.02135582f, 0.14863703f, 0.00376466f, 0.60996848f, -0.01895854f, 0.06571435f, 0.29599661f, 
    0.11274099f, 0.17939135f, 0.09783807f, -0.03183766f, 0.00521030f, -0.02984252f, -0.00700074f, 0.07410844f, 
    0.39265966f, -0.19416164f, 0.49614117f, -0.09213509f, -0.00186912f, 0.01877358f, -0.05767985f, 0.18873087f, 
    -0.11255533f, -0.14789665f, -0.07868957f, -0.07139418f, -0.04104965f, 0.22742969f, 0.15993366f, 0.08511505f, 
    0.07315475f, -0.05722506f, 0.06378791f, -0.08259605f, -0.03690856f, -0.07736672f, 0.12015570f, 0.07662193f, 
    0.18969600f, 0.05490397f, 0.00698213f, 0.16057076f, 0.03564482f, 0.02142117f, 0.13390239f, 0.09422155f, 
    -0.08844055f, -0.09060598f, -0.01959530f, -0.07496332f, 0.14275323f, 0.41120920f, 0.18057710f, 0.10915465f, 
    -0.19246313f, 0.09622650f, 0.17058255f, 0.02987798f, 0.03955136f, 0.06710856f, -0.08689408f, -0.06756039f, 
    -0.04218908f, -0.08292936f, 0.01127523f, -0.08479745f, -0.04671602f, 0.11357072f, -0.00929577f, 0.06713580f, 
    0.06086618f, 0.08593948f, 0.13555874f, 0.01141603f, -0.19919214f, 0.01773543f, -0.17476921f, -0.33000088f, 
    0.18085796f, 0.04877570f, 0.06733792f, -0.03919836f, 0.02369980f, -0.06477857f, 0.07787709f, 0.13325042f, 
    -0.13545643f, -0.06943959f, 0.08973277f, 0.20717187f, -0.04340720f, 0.09693730f, -0.08810678f, 0.06373355f, 
    -0.02412934f, -0.03661523f, 0.07618670f, -0.05593472f, -0.10367919f, 0.13701712f, 0.02153171f, 0.20592806f, 
    0.07448860f, -0.06853098f, -0.06076270f, 0.01895572f, 0.14327212f, 0.08212280f, -0.00202465f, 0.03785324f, 
    0.04854858f, -0.14444955f, -0.15195517f, 0.03530775f, 0.19411199f, 0.02839473f, 0.14489141f, 0.08116364f, 
    -0.13198942f, 0.04363182f, -0.05199774f, 0.03186237f, 0.01289512f, -0.14523922f, 0.02469119f, 0.07398855f, 
    -0.05536040f, -0.02577043f, -0.19394588f, 0.00277247f, -0.14559163f, -0.17617208f, -0.03350979f, 0.04445730f, 
    -0.26137841f, 0.32931772f, -0.26589602f, 0.00737846f, 0.02937451f, -0.07704635f, 0.02606300f, -0.04342147f, 
    0.01406166f, -0.05849551f, 0.06482282f, 0.22248569f, -0.12032910f, -0.33113503f, -0.10348544f, 0.05042543f, 
    0.18307233f, 0.17317614f, 0.02760869f, 0.13655321f, 0.01079944f, -0.07395764f, 0.04901022f, -0.07273410f, 
    -0.40051681f, 0.52737182f, -0.24154663f, 0.01737959f, 0.14802371f, -0.11727403f, 0.07241350f, -0.11144959f, 
    0.00612434f, -0.03010104f, 0.22125338f, 0.09862201f, 0.03793919f, 0.11042329f, 0.05600948f, 0.01950638f, 
    -0.16711167f, -0.13020520f, -0.17072135f, 0.07669017f, -0.06027030f, -0.06707647f, -0.13671890f, -0.13280667f, 
    -0.09487928f, -0.08229081f, 0.27034953f, 0.05684004f, -0.07555971f, 0.06780667f, -0.06572613f, -0.09045820f, 
    0.07884399f, 0.06677455f, 0.11923112f, 0.20748423f, 0.50323141f, 0.19975623f, -0.07575991f, 0.18699713f, 
    0.00425521f, 0.17029074f, -0.07286917f, -0.01612239f, -0.06288378f, 0.09166227f, -0.09612000f, 0.01629407f, 
    0.28721663f, -0.38784018f, 0.65161788f, -0.10330171f, 0.06900556f, -0.01618747f, -0.20141521f, 0.21475658f, 
    0.01727846f, -0.15034357f, 0.12845822f, 0.01744668f, -0.15470679f, 0.34380245f, 0.08091221f, -0.19597007f, 
    -0.04466958f, 0.00575842f, -0.06149828f, -0.02159833f, 0.03075769f, -0.07450017f, 0.10352247f, -0.08335926f, 
    0.13692026f, 0.05495997f, -0.05769587f, -0.04708683f, 0.00150818f, 0.06283394f, -0.09385570f, 0.11638248f, 
    0.01172888f, -0.04995226f, -0.12341145f, -0.11604125f, 0.08453800f, 0.49806297f, -0.13196270f, 0.23252429f, 
    -0.05485326f, -0.10876199f, 0.06417671f, -0.15503083f, 0.01725312f, -0.01976075f, -0.05760416f, 0.00900110f, 
    -0.09717477f, -0.03980229f, 0.07256457f, -0.15234186f, -0.03430976f, -0.06060398f, -0.20792918f, -0.13214733f, 
    -0.02028768f, -0.00515247f, -0.01946224f, -0.13848066f, 0.15132973f, -0.20836489f, -0.16455424f, -0.22658223f, 
    -0.06227217f, 0.01419286f, 0.08182797f, 0.00157072f, 0.09305478f, -0.00257362f, -0.16299982f, 0.12707466f, 
    -0.11726339f, -0.02478664f, 0.11055899f, 0.15168799f, 0.15928333f, 0.09031574f, 0.16873297f, 0.02949526f, 
    0.01119432f, 0.14104877f, -0.07234081f, 0.09118660f, -0.22221766f, 0.06085695f, 0.01694592f, -0.10041002f, 
    -0.02402586f, 0.16748366f, -0.13573545f, -0.15712678f, 0.14103484f, -0.05120671f, 0.08591054f, -0.03368677f, 
    0.10722636f, -0.20587255f, -0.33385366f, 0.04258147f, -0.03452591f, 0.08803196f, -0.04975946f, 0.02915436f, 
    -0.02902388f, -0.03404067f, -0.12319381f, 0.13727669f, -0.05444018f, 0.05183495f, 0.15029459f, -0.13270113f, 
    -0.03822346f, 0.09858037f, -0.11587582f, 0.02362189f, 0.08588251f, 0.01982885f, -0.01533848f, 0.00895628f, 
    0.09981774f, 0.00117894f, -0.07393319f, 0.09067411f, 0.05927466f, -0.11743839f, 0.06845741f, 0.18320142f, 
    -0.13863260f, -0.00878653f, 0.18146116f, 0.03898454f, -0.00818706f, 0.15063140f, 0.02698882f, 0.22616290f, 
    0.02595304f, -0.03076483f, 0.06518248f, 0.21740039f, -0.03058026f, -0.01291478f, 0.08285072f, -0.01512733f, 
    0.19037268f, 0.41207758f, -0.07784005f, -0.09611209f, 0.12989581f, -0.09239981f, -0.02082843f, -0.00496780f, 
    0.11138749f, 0.13359927f, 0.04505901f, 0.11271501f, -0.11697064f, 0.08160868f, 0.04535519f, -0.04913657f, 
    -0.04140805f, -0.15065584f, -0.07099092f, -0.00710252f, -0.16887313f, -0.08580039f, -0.02505370f, 0.01405137f, 
    0.11296064f, -0.13273038f, 0.06729604f, -0.28729656f, 0.10110440f, -0.00389217f, -0.03530264f, 0.08370712f, 
    0.00869339f, -0.14461102f, 0.22053637f, 0.11909569f, -0.05804896f, 0.24615650f, 0.12853250f, 0.08221333f, 
    -0.06314153f, 0.04123922f, 0.07042596f, 0.01605848f, 0.12068874f, 0.08777411f, -0.13894068f, 0.04138001f, 
    0.37364453f, -0.48191255f, 0.38646072f, -0.02357854f, 0.12284447f, -0.11228873f, 0.11069093f, 0.03436963f, 
    0.03533891f, 0.01936389f, -0.15612590f, -0.04703394f, 0.17238878f, 0.02966558f, 0.19018017f, 0.04513432f, 
    -0.12203067f, -0.01109625f, -0.03967150f, -0.05911506f, -0.02014764f, 0.02599595f, -0.03443072f, -0.00818758f, 
    -0.02638981f, 0.08545934f, 0.12290075f, -0.00245534f, -0.01674107f, 0.01036404f, -0.10334454f, 0.05756280f, 
    0.03042956f, 0.01063915f, 0.10414335f, 0.14252177f, 0.45537919f, 0.12736322f, -0.14742410f, -0.00887279f, 
    -0.21930976f, 0.00833348f, -0.17226197f, -0.12288929f, -0.03336893f, 0.00787422f, -0.07006322f, 0.07013508f, 
    0.20444828f, -0.13913952f, 0.07670965f, 0.01835406f, 0.03840071f, 0.05005095f, -0.18385033f, -0.09499963f, 
    0.04733093f, 0.04215631f, 0.00556138f, 0.09154729f, -0.39399728f, -0.64575541f, 0.16869937f, 0.11381240f, 
    0.16145268f, -0.18991475f, -0.05719102f, 0.03027810f, 0.02620472f, -0.01603916f, 0.06903526f, -0.07407352f, 
    0.09159835f, 0.04577234f, 0.11344398f, -0.19799194f, -0.06216617f, 0.14545049f, 0.01819380f, -0.00444138f, 
    0.03302935f, 0.06738901f, 0.03918821f, 0.01386262f, -0.07157396f, 0.23454607f, -0.20416215f, 0.18951426f, 
    -0.01666302f, -0.08055779f, -0.06993618f, 0.03354624f, -0.09541116f, 0.09553274f, 0.07427938f, -0.07651747f, 
    -0.29972857f, -0.15653835f, -0.01386501f, 0.16108145f, -0.11400587f, -0.19514881f, 0.08793899f, 0.02560122f, 
    0.16528836f, 0.08360296f, 0.04697619f, 0.00401903f, 0.07406022f, 0.03885092f, 0.09546039f, 0.24433124f, 
    -0.04925536f, -0.04910697f, -0.12277342f, -0.00432073f, -0.10290416f, -0.32881331f, 0.00811496f, 0.05738634f, 
    -0.22475113f, 0.33223698f, -0.13297637f, 0.01056398f, -0.05800326f, 0.10368927f, 0.11359978f, 0.10789087f, 
    -0.09406991f, -0.02343151f, 0.06034427f, 0.25149900f, 0.07598645f, -0.02101067f, -0.23631808f, -0.03530190f, 
    0.01670875f, 0.19939403f, 0.13348261f, -0.00448044f, -0.04822869f, -0.06035190f, 0.10012706f, 0.00169872f, 
    -0.22246607f, -0.05842400f, -0.19547731f, 0.19907491f, -0.02950813f, -0.20898466f, 0.15136518f, 0.12459999f, 
    0.13467839f, -0.22324730f, -0.00727582f, 0.04616600f, 0.11740287f, 0.11752529f, -0.07273499f, -0.07320268f, 
    0.15574761f, 0.06248192f, -0.03191482f, -0.11559805f, -0.04592708f, -0.04342494f, -0.03570485f, -0.01964414f, 
    -0.56726283f, 0.39567164f, 0.12583783f, 0.35745382f, -0.00091212f, 0.00720904f, -0.07429864f, 0.07899468f, 
    -0.11569688f, -0.13512157f, -0.03959245f, -0.11619876f, 0.16740292f, -0.16680770f, 0.23157373f, 0.18106072f, 
    0.14447223f, -0.09767511f, 0.09754366f, 0.12952456f, -0.02497298f, -0.04218663f, 0.15928982f, -0.00766439f, 
    0.23104151f, 0.36224732f, 0.14463401f, 0.04069284f, -0.07212178f, 0.08653769f, 0.12113577f, -0.07206944f, 
    -0.09944419f, -0.05999626f, -0.00957739f, -0.13687748f, -0.07077024f, 0.04950394f, -0.01470869f, -0.01172089f, 
    0.06373257f, -0.03224573f, 0.06629236f, -0.03224342f, -0.10303146f, 0.07040027f, 0.06887864f, 0.00464096f, 
    -0.11889634f, -0.05919148f, 0.10243338f, 0.17378652f, 0.09575257f, -0.04333907f, 0.03214084f, -0.00569791f, 
    -0.04338630f, 0.04403621f, -0.03696666f, -0.06964163f, 0.02630208f, 0.24239503f, 0.40011102f, -0.15833463f, 
    -0.03297508f, 0.18150844f, 0.11912978f, 0.15740483f, -0.11878619f, 0.03781247f, -0.11414715f, -0.03701992f, 
    -0.14960583f, 0.04914226f, -0.02069508f, -0.08283135f, 0.13394201f, 0.09556399f, 0.08631512f, 0.02464944f, 
    0.14368296f, 0.10192813f, 0.23279794f, 0.06895109f, -0.15623423f, 0.54451042f, -0.12821399f, -0.04217090f, 
    0.13321178f, 0.16210859f, -0.10953184f, -0.10597696f, 0.23883127f, -0.05686942f, 0.11986074f, 0.18569890f, 
    -0.03410824f, 0.01539390f, 0.04125727f, 0.35176471f, -0.11242951f, 0.12049519f, -0.07511353f, 0.09830914f, 
    0.08322072f, 0.00211087f, -0.01125097f, -0.02143998f, 0.00891139f, 0.19775912f, 0.06349386f, 0.12415751f, 
    0.10246030f, -0.04099250f, 0.08225282f, 0.16650684f, -0.03855898f, 0.24331066f, -0.08533967f, 0.07217747f, 
    0.03082879f, -0.03493553f, 0.29177839f, 0.08110435f, 0.10267273f, -0.04514888f, -0.01025579f, -0.13190781f, 
    -0.07391278f, 0.18728594f, -0.01613446f, -0.18583460f, -0.06265827f, -0.19651122f, -0.19599538f, -0.00285482f, 
    -0.07868049f, -0.07159334f, -0.17372596f, -0.19446981f, -0.06912628f, 0.06651142f, 0.07307766f, 0.07204850f, 
    -0.20599186f, 0.25089100f, -0.18538131f, -0.05633119f, 0.06395014f, -0.10338774f, 0.02564321f, -0.14396279f, 
    0.23280078f, 0.22939166f, 0.01604398f, 0.09924085f, -0.07313816f, -0.24356750f, -0.05352335f, -0.04873293f, 
    0.12530784f, 0.02923523f, -0.16633928f, 0.00299740f, 0.09769624f, 0.05215776f, -0.00230690f, -0.12296249f, 
    -0.49588236f, 0.20905888f, -0.21926360f, 0.04138711f, 0.11350732f, 0.13910986f, 0.04411895f, 0.01792977f, 
    -0.04536405f, 0.03137970f, 0.10726760f, 0.13535258f, 0.06840022f, 0.02953772f, 0.05115573f, 0.14209878f, 
    -0.07341388f, -0.01344952f, -0.06163945f, 0.05806455f, -0.12483064f, -0.10600351f, -0.10002881f, -0.30602258f, 
    0.00989722f, 0.09337760f, 0.36518633f, -0.25418240f, 0.16100240f, 0.16581176f, -0.09671329f, -0.22360305f, 
    0.27710739f, 0.11731405f, 0.12011459f, 0.10964263f, -0.01454720f, 0.07558124f, -0.05792722f, 0.14448088f, 
    -0.04520687f, -0.06370219f, -0.10599446f, 0.13416219f, 0.02927814f, -0.00319412f, -0.14064844f, -0.10154244f, 
    0.23641041f, -0.33434686f, 0.52920216f, 0.04021662f, 0.09433483f, -0.14396560f, -0.12358880f, -0.06685242f, 
    -0.02113791f, -0.03755574f, -0.04233443f, -0.00802799f, 0.12650494f, 0.28469273f, 0.21745124f, -0.02874265f, 
    -0.10289488f, -0.08025472f, -0.14041051f, -0.03799667f, 0.13642438f, -0.17374507f, -0.16702701f, 0.00627874f, 
    0.00746182f, -0.09852586f, 0.05277862f, 0.03277376f, 0.00272576f, -0.01875405f, -0.17261998f, 0.15444744f, 
    -0.02808128f, -0.01966379f, 0.00849265f, -0.05154180f, 0.22294055f, 0.41155052f, 0.17980784f, 0.01060222f, 
    -0.07265345f, -0.03979954f, 0.05326261f, 0.05384699f, -0.11731057f, -0.20633112f, -0.07653499f, -0.00041792f, 
    0.15048875f, -0.01795224f, -0.03112530f, -0.08901598f, 0.01753279f, -0.03903567f, -0.12779300f, -0.01184603f, 
    0.05978761f, -0.06159027f, -0.17025608f, -0.02011666f, -0.02180042f, -0.20639053f, -0.14509311f, 0.12614687f, 
    -0.02531676f, -0.04957798f, -0.08175575f, -0.02840712f, -0.04856867f, -0.05448180f, -0.02410372f, 0.07525469f, 
    -0.06180924f, -0.00127537f, 0.12343294f, 0.01288158f, 0.06443296f, 0.12705156f, 0.10208567f, -0.08862798f, 
    -0.08819453f, 0.04010844f, -0.07424188f, -0.06601410f, -0.03110124f, -0.02452179f, 0.01080730f, 0.01876458f, 
    -0.00080972f, 0.17896304f, -0.06218329f, -0.09135225f, 0.07804535f, 0.14240721f, -0.05085771f, -0.09864882f, 
    -0.03145000f, -0.35023528f, -0.13387293f, 0.16863078f, 0.04192241f, -0.19633716f, -0.17850883f, -0.03921600f, 
    -0.02058486f, -0.12575123f, -0.09413121f, -0.11444241f, 0.02691950f, 0.24056375f, 0.26257464f, -0.16822219f, 
    -0.09841614f, 0.07597896f, -0.09418552f, -0.01074266f, 0.16255771f, 0.04649059f, -0.04370166f, 0.16398922f, 
    0.19844641f, 0.10978702f, 0.15829968f, -0.09504838f, 0.12720844f, 0.06651614f, -0.08849656f, 0.18897207f, 
    -0.00845596f, -0.10492720f, 0.17291975f, 0.14385164f, -0.17720278f, 0.07605688f, 0.02933360f, 0.14216261f, 
    -0.06082758f, 0.12536637f, 0.04973938f, 0.02216560f, 0.03783296f, 0.09904518f, 0.00461333f, -0.01251602f, 
    0.07789609f, 0.13112627f, -0.00679733f, 0.11911183f, -0.08250861f, -0.05438855f, -0.07520328f, 0.25230438f, 
    -0.01585051f, -0.03438572f, -0.01038446f, 0.03134991f, -0.05634452f, 0.13791035f, -0.06348849f, -0.03515660f, 
    0.10413446f, -0.14131185f, -0.02778237f, -0.18415722f, 0.11721370f, -0.09568048f, -0.00510161f, -0.05754325f, 
    -0.50569326f, 0.37850282f, 0.00009185f, 0.46847981f, -0.19981761f, 0.11738970f, 0.23262343f, 0.20993774f, 
    -0.11548189f, -0.00728602f, -0.05006831f, -0.12895375f, 0.14166631f, -0.34143957f, 0.06068137f, 0.02053558f, 
    0.12639757f, 0.08860521f, 0.19080764f, 0.02927944f, 0.02433737f, -0.04624707f, -0.00449244f, 0.01936288f, 
    0.24936147f, 0.58174151f, -0.08615197f, -0.02784658f, -0.19673994f, 0.02810863f, 0.01947824f, -0.07545721f, 
    -0.01629962f, -0.01168127f, -0.10630683f, -0.10439251f, 0.07897150f, 0.14238012f, 0.06316964f, 0.04680247f, 
    -0.08848919f, -0.04927594f, 0.01642045f, -0.04150545f, 0.07814241f, -0.01836137f, -0.07160665f, 0.03440873f, 
    -0.13361606f, -0.20855539f, -0.01209375f, 0.19011407f, 0.01780898f, -0.08620072f, 0.19589785f, 0.02967284f, 
    -0.07241876f, -0.02078051f, 0.00984900f, -0.02013207f, 0.03858178f, -0.13213292f, 0.44193190f, 0.17341563f, 
    0.02915503f, 0.18096446f, 0.07980198f, 0.10566884f, 0.00558097f, -0.08367323f, -0.13398451f, 0.00123461f, 
    -0.22927481f, 0.02589410f, -0.07003386f, 0.02004431f, 0.07912720f, -0.02005098f, 0.06258411f, 0.00890672f, 
    0.12620620f, 0.16199967f, 0.08209775f, -0.07629736f, 0.05337585f, 0.87498075f, -0.27966589f, -0.14287876f, 
    0.24625267f, 0.14262916f, -0.07695282f, -0.21436696f, -0.10796817f, 0.02673287f, 0.05755284f, 0.09291060f, 
    0.01415190f, 0.01034272f, -0.02935425f, 0.27886999f, 0.04356838f, 0.00352547f, -0.07601883f, 0.06701006f, 
    0.21452209f, 0.12554210f, 0.01499910f, 0.11004960f, 0.20685185f, -0.09778395f, 0.05749137f, -0.07496072f, 
    -0.02606519f, -0.03439249f, -0.11301113f, 0.07817092f, 0.07119021f, 0.09508800f, 0.06654698f, 0.09962180f, 
    0.09552465f, -0.04332559f, 0.01698371f, -0.08589930f, 0.24406381f, 0.09176639f, 0.12986113f, -0.05570846f, 
    0.03823993f, 0.11293022f, -0.00945990f, -0.16863699f, 0.05816970f, -0.25393811f, -0.02428684f, 0.13433623f, 
    -0.07498512f, -0.14821300f, -0.06214124f, -0.24596284f, -0.05357299f, 0.15861130f, 0.11258069f, 0.09064940f, 
    -0.12989362f, 0.11342949f, -0.02934054f, 0.01273926f, 0.10219842f, -0.04915272f, -0.00469872f, -0.21015397f, 
    0.15825494f, 0.15053765f, -0.11959551f, -0.00283112f, -0.22056255f, -0.40853068f, -0.03364712f, -0.16743851f, 
    0.19046292f, 0.00617340f, -0.02432518f, 0.08732385f, 0.13561676f, 0.00423389f, 0.04456345f, 0.06770838f, 
    -0.44007328f, 0.18501924f, -0.11082199f, 0.04570641f, 0.23373187f, 0.03220196f, -0.04657781f, -0.09581117f, 
    -0.09528250f, 0.05934482f, 0.14583467f, 0.12495745f, 0.11821428f, 0.01178823f, -0.00022241f, 0.24234323f, 
    -0.05248324f, 0.03448947f, 0.09792619f, 0.04213840f, 0.09304053f, 0.01380171f, 0.15126523f, -0.07931423f, 
    -0.23744075f, -0.25202924f, -0.25071126f, 0.07808392f, 0.05419724f, 0.17564456f, 0.02480159f, 0.06240248f, 
    0.10582592f, -0.04148163f, -0.04252388f, -0.24964753f, -0.21102841f, 0.01454896f, -0.42757052f, 0.06351644f, 
    0.00571952f, -0.07619800f, -0.10139316f, 0.11535534f, -0.05739808f, -0.07051447f, 0.00930684f, 0.00492147f, 
    0.08802980f, 0.25507548f, 0.15534413f, 0.36935267f, -0.01103381f, -0.02020110f, -0.20204611f, -0.08415593f, 
    0.03064022f, 0.07697154f, 0.01100806f, 0.02884970f, 0.28864416f, 0.22094715f, -0.03022783f, 0.24844322f, 
    -0.07846536f, -0.07249241f, -0.03334028f, 0.00761859f, -0.00708171f, 0.00097506f, 0.03980530f, 0.05279554f, 
    0.10754152f, 0.04324107f, -0.05209206f, 0.07490093f, 0.11797351f, -0.05488703f, -0.14291359f, 0.05801211f, 
    -0.02272942f, -0.05913390f, -0.09119187f, 0.15054134f, -0.01930893f, 0.16447449f, 0.15276769f, 0.24147500f, 
    -0.01794457f, -0.15992098f, -0.05007458f, -0.14180432f, -0.09764595f, 0.03496075f, 0.10871988f, 0.02948624f, 
    0.06838697f, 0.18082893f, -0.00833183f, 0.13125387f, 0.12431198f, 0.10860559f, -0.07097302f, -0.09813811f, 
    0.08784727f, -0.03105492f, -0.04819063f, 0.04834529f, 0.51004636f, 0.06705734f, -0.17676194f, -0.18911999f, 
    -0.27424178f, 0.10342782f, 0.02986017f, -0.05715432f, -0.24021503f, -0.05538021f, -0.27271524f, -0.24977665f, 
    -0.09195752f, -0.09280274f, -0.26092216f, 0.12060715f, 0.24784113f, 0.15436615f, 0.20815049f, -0.15573557f, 
    0.04970755f, 0.02367088f, 0.14155695f, 0.07917222f, 0.14409788f, 0.04277913f, 0.21925943f, 0.10380536f, 
    0.02946092f, -0.03838623f, -0.03992544f, -0.04060011f, 0.01426478f, 0.06480922f, -0.06598642f, -0.02632894f, 
    0.12925252f, 0.24684533f, 0.30867696f, -0.03650717f, 0.07771407f, 0.18010819f, 0.10117674f, 0.25538951f, 
    -0.08750859f, -0.15900667f, 0.04621027f, 0.00849661f, -0.01141377f, 0.18668872f, 0.14321539f, 0.04784997f, 
    0.05219687f, 0.12834056f, -0.10458402f, 0.01930360f, 0.29100290f, 0.04214071f, 0.14788604f, 0.04917083f, 
    0.26322728f, 0.04453602f, 0.19188051f, 0.00086541f, -0.11358669f, 0.05792548f, 0.13563111f, 0.00543743f, 
    0.07389699f, 0.19319458f, 0.11106814f, -0.15782666f, -0.16999917f, -0.45763892f, -0.50871986f, -0.17016985f, 
    -0.20882845f, 0.02971206f, -0.01378858f, 0.05250195f, 0.14958455f, -0.23456547f, 0.01866443f, -0.16377002f, 
    0.56242180f, 0.04542280f, 0.28531954f, -0.20452459f, -0.14414278f, -0.06934628f, -0.01592440f, 0.11800830f, 
    -0.19791012f, -0.06679922f, -0.37949923f, -0.03106729f, -0.01087498f, -0.14030023f, 0.02118661f, 0.13350779f, 
    -0.07346243f, -0.07996441f, 0.02286831f, -0.02820618f, 0.03443760f, -0.01824122f, 0.09723764f, -0.13006052f, 
    0.04475699f, -0.02676375f, 0.36970925f, 0.06168771f, -0.00432569f, -0.07616393f, 0.08132172f, 0.00028846f, 
    -0.01221667f, -0.06470058f, -0.02016910f, 0.09359010f, 0.31349182f, -0.36457849f, 0.19870433f, 0.14085107f, 
    -0.08228335f, -0.04693762f, -0.18749847f, 0.00769955f, -0.07246096f, -0.01271253f, -0.11598554f, 0.01446757f, 
    0.50901645f, -0.07482577f, 0.32344398f, -0.36496162f, -0.13924126f, -0.08344030f, 0.07191911f, -0.11044469f, 
    -0.09293504f, 0.07224611f, -0.01881830f, 0.03051426f, -0.01371372f, 0.04902029f, 0.26913643f, -0.42258400f, 
    -0.22183247f, -0.10350777f, -0.03179553f, -0.04740405f, 0.02989813f, 0.01995490f, 0.05750924f, -0.08267565f, 
    -0.05746065f, -0.16987535f, -0.03697008f, 0.11006472f, 0.00590491f, 0.05422425f, -0.05968618f, -0.01275750f, 
    -0.00323356f, 0.00334436f, -0.12457013f, -0.03642402f, -0.30716336f, 0.02155737f, 0.04952943f, 0.11473584f, 
    -0.02612332f, -0.07010132f, -0.05314974f, -0.15148154f, -0.11116824f, -0.09339118f, 0.04716624f, -0.05483608f, 
    0.03388257f, 0.04477029f, 0.13198337f, -0.17601892f, -0.05030676f, 0.05097745f, -0.02290643f, -0.01572117f, 
    -0.14848381f, -0.11663011f, 0.09504600f, -0.05907027f, -0.02517932f, 0.38589963f, 0.14376789f, -0.06841470f, 
    0.05743533f, 0.22752117f, 0.09684309f, -0.02883824f, -0.03219659f, 0.04609258f, -0.08821530f, 0.02699858f, 
    -0.06528848f, 0.07142216f, 0.19758782f, 0.30101219f, -0.02237737f, 0.10049883f, 0.19350438f, 0.09091603f, 
    -0.00846178f, 0.07440620f, -0.04976630f, 0.07358468f, -0.10992707f, 0.28758305f, 0.03292999f, 0.08790638f, 
    -0.01541696f, 0.14757605f, 0.08370882f, -0.11879288f, -0.15464315f, 0.15348585f, -0.04608927f, -0.08697784f, 
    -0.25719553f, -0.10464481f, -0.17738704f, 0.23170488f, 0.03132027f, 0.03880397f, -0.08774075f, 0.02363891f, 
    0.00093649f, 0.05399657f, -0.01214942f, 0.02565284f, -0.09645171f, 0.34734774f, 0.11036396f, -0.01404677f, 
    -0.13329935f, -0.05199930f, -0.04960742f, -0.05173295f, 0.20169523f, 0.03240863f, -0.02297430f, -0.06514173f, 
    0.12994637f, 0.39622143f, 0.06259844f, 0.09870640f, -0.06076040f, -0.01562047f, 0.13392060f, -0.06437697f, 
    -0.17342155f, 0.11096852f, 0.08749320f, 0.01107651f, -0.00660638f, 0.26470089f, 0.17032906f, 0.30070901f, 
    -0.09368502f, -0.11584178f, 0.12115062f, 0.02236379f, 0.12446800f, 0.06850076f, -0.05021135f, -0.02635433f, 
    -0.26210561f, 0.19651653f, -0.41667476f, 0.14034408f, 0.16538544f, 0.18514621f, -0.02942478f, -0.11735536f, 
    0.02802875f, 0.14083800f, 0.03402721f, -0.01823335f, -0.10759817f, 0.17435613f, -0.00067920f, -0.05497697f, 
    -0.03371600f, -0.05244770f, -0.10963661f, -0.08112432f, -0.09669466f, -0.00411841f, -0.12495776f, 0.11067544f, 
    -0.06741387f, -0.02235678f, -0.06861295f, 0.04702029f, 0.05361480f, -0.04818581f, 0.05386779f, -0.06868388f, 
    0.04051437f, 0.03687568f, 0.05242071f, -0.00245352f, -0.05422072f, 0.05779290f, -0.07241160f, -0.07895920f, 
    0.02236718f, -0.07830219f, -0.07634676f, 0.01346855f, -0.04103185f, 0.02227627f, -0.07444601f, -0.05603747f, 
    0.04263723f, -0.07106012f, -0.07579677f, 0.02728956f, 0.05530666f, -0.00703535f, -0.03922334f, -0.03935559f, 
    0.01505756f, -0.02360355f, -0.01538203f, -0.03552872f, 0.01360914f, 0.07282726f, -0.02494915f, 0.00283610f, 
    -0.00778614f, -0.03027725f, -0.06216031f, -0.02860329f, -0.05453510f, 0.05323552f, 0.05358414f, -0.02188875f, 
    -0.07712957f, -0.01946628f, -0.01097359f, 0.04461319f, 0.00690547f, 0.02828613f, -0.03506903f, -0.02042504f, 
    -0.07188830f, 0.04076484f, -0.06122667f, 0.01875496f, -0.05265769f, -0.02921215f, -0.05937708f, -0.01828228f, 
    -0.05561721f, 0.05201034f, -0.00011170f, 0.00467114f, -0.00778497f, -0.01460827f, 0.05005306f, 0.04944923f, 
    -0.04126757f, -0.02090973f, 0.03072512f, 0.01691844f, -0.03411318f, -0.03391049f, -0.00636004f, -0.02243961f, 
    0.02499616f, 0.03771649f, 0.01124888f, -0.04498000f, -0.03753266f, -0.03740869f, -0.05891684f, -0.02431407f, 
    -0.07575148f, 0.03423214f, -0.03854119f, -0.04575900f, -0.04098400f, -0.02369972f, 0.06301649f, 0.02262889f, 
    -0.01183344f, 0.06377549f, -0.04211543f, 0.00463051f, -0.03271146f, 0.01198514f, -0.04949426f, 0.04885719f, 
    -0.05229557f, 0.04744479f, -0.04279149f, -0.05799143f, -0.00364457f, 0.01272540f, -0.05929384f, 0.01362246f, 
    0.01266379f, -0.05237674f, -0.02236902f, -0.05675812f, -0.05827417f, 0.06321371f, -0.02816391f, -0.03068302f, 
    0.02138321f, -0.04153679f, -0.07516692f, -0.00397791f, -0.03092658f, -0.04445179f, -0.03317118f, -0.04277354f, 
    -0.00389698f, 0.02976809f, -0.02864382f, 0.02392835f, -0.06240719f, -0.03939205f, -0.07523905f, -0.04692522f, 
    0.07099995f, 0.04471745f, 0.00815974f, 0.02542592f, 0.05421725f, -0.00442665f, 0.06190110f, -0.07261506f, 
    0.03727379f, 0.03458358f, 0.00020760f, 0.01103964f, -0.00456171f, -0.03842779f, 0.06164515f, 0.03896207f, 
    -0.05190530f, 0.03142427f, 0.04071015f, 0.02469614f, 0.06465715f, 0.00089688f, 0.03014035f, -0.07538871f, 
    -0.07436299f, -0.02714731f, -0.01860236f, 0.02798577f, 0.05171937f, 0.00134735f, -0.03637622f, 0.00350848f, 
    0.02470550f, 0.03753327f, 0.00868810f, -0.02763178f, 0.01506393f, -0.05048140f, 0.03596886f, -0.06913157f, 
    -0.03521391f, 0.03325194f, 0.02366697f, -0.07408462f, -0.03747743f, 0.05728244f, -0.01315621f, -0.06764866f, 
    -0.01018698f, 0.03038847f, 0.01084425f, -0.06019331f, 0.02452409f, 0.03975887f, -0.03339064f, -0.06509959f, 
    -0.32339886f, 0.39707491f, 0.10187592f, 0.35607526f, 0.00974758f, -0.02352006f, 0.08799131f, -0.11657252f, 
    0.07948276f, 0.20465423f, -0.09739113f, 0.09083753f, 0.39979565f, -0.25221622f, 0.08624331f, 0.11553399f, 
    0.06651773f, 0.01062526f, 0.01614919f, 0.13274035f, -0.04804210f, 0.04795526f, 0.17441919f, 0.11356954f, 
    -0.31379095f, 0.23683964f, -0.14569844f, 0.01413987f, -0.13828515f, 0.11745988f, -0.19017260f, -0.01413088f, 
    0.06797045f, -0.10798337f, 0.15982530f, -0.01427551f, -0.42878231f, 0.05140267f, -0.02672758f, -0.01928037f, 
    0.12947243f, -0.00933129f, -0.03944011f, 0.01391814f, 0.05431026f, 0.01799380f, 0.03981384f, -0.03355741f, 
    -0.13309027f, -0.14536113f, 0.04618528f, 0.02976443f, 0.07610265f, 0.04358549f, -0.08971208f, 0.08584844f, 
    -0.05498723f, -0.01173659f, 0.06992537f, -0.05002426f, -0.41757917f, -0.04785965f, 0.26694763f, -0.04822738f, 
    0.24677137f, 0.06511770f, 0.24960709f, 0.16335288f, 0.07816440f, 0.10292964f, -0.03096180f, -0.06437165f, 
    -0.30815804f, 0.15200698f, -0.07040960f, -0.03928704f, -0.00479910f, 0.06417392f, 0.08022119f, -0.00007928f, 
    0.04057724f, 0.04847938f, -0.05636575f, -0.08798850f, 0.34017891f, 0.62232858f, -0.25946254f, -0.17554854f, 
    0.02665629f, 0.21766640f, -0.02582433f, 0.11706231f, -0.13166347f, 0.09786040f, -0.04029518f, 0.07430257f, 
    -0.02258263f, 0.06134807f, 0.09937098f, 0.27620503f, -0.01827916f, 0.01966954f, -0.10868102f, -0.05718261f, 
    0.00147382f, 0.02599018f, -0.04548671f, 0.15355594f, -0.04663251f, -0.21204105f, 0.10939033f, -0.28894612f, 
    0.01141513f, 0.08538204f, -0.03038647f, -0.07507534f, 0.08437136f, 0.02015636f, -0.19943334f, 0.25908175f, 
    0.25323075f, -0.14522240f, 0.02231547f, 0.05244252f, 0.21248506f, 0.13634726f, 0.02192797f, 0.08921006f, 
    -0.17683727f, 0.01800638f, -0.09015238f, -0.04849141f, -0.05881607f, -0.05907470f, -0.17059694f, -0.26179841f, 
    -0.03898480f, 0.02275483f, 0.04952102f, 0.11371018f, 0.18659683f, 0.16004281f, 0.02431768f, -0.01537339f, 
    0.19920518f, -0.14555103f, 0.16227841f, -0.05988870f, 0.23762889f, 0.02587618f, -0.21954982f, 0.01010687f, 
    -0.02517436f, 0.08205825f, 0.03866938f, -0.09717084f, 0.10710010f, 0.15768053f, 0.33020878f, 0.22149742f, 
    -0.05286745f, -0.17779186f, 0.07489078f, 0.16232945f, -0.05420084f, 0.03721277f, -0.00638732f, 0.01337428f, 
    -0.04447852f, 0.16195041f, 0.06139510f, -0.02702330f, 0.04773709f, 0.05502011f, -0.26492223f, 0.00210939f, 
    -0.16138816f, 0.16444834f, -0.04195725f, -0.01024159f, -0.17948756f, -0.04132245f, -0.02799109f, 0.06621574f, 
    -0.08364999f, -0.04565197f, 0.00147612f, 0.06406235f, 0.11262526f, 0.03314054f, 0.07601923f, -0.06602611f, 
    0.00546654f, -0.04457465f, -0.05319102f, 0.02336083f, 0.03994411f, 0.02461851f, 0.00208119f, -0.05072334f, 
    0.06510855f, -0.01497047f, -0.06116650f, -0.03311631f, -0.07185183f, 0.07035808f, -0.03136674f, -0.06300369f, 
    -0.04376376f, -0.07524740f, -0.07451747f, -0.00870022f, 0.00484897f, 0.00201637f, -0.07762732f, -0.07994504f, 
    -0.03026912f, 0.02971770f, -0.04140649f, 0.01253237f, 0.06225397f, 0.04357724f, -0.04914701f, -0.00628576f, 
    -0.00825850f, 0.03822985f, -0.06970339f, -0.07894796f, 0.06079018f, -0.02608023f, 0.01010450f, 0.03340158f, 
    -0.02024362f, 0.05365625f, -0.02590573f, -0.01115152f, -0.07320676f, -0.00058404f, 0.03792921f, 0.05844485f, 
    0.01620623f, -0.07580213f, 0.01465357f, 0.06615013f, -0.05520424f, -0.05282335f, -0.05329186f, 0.03695849f, 
    -0.02303356f, -0.01420040f, -0.06760335f, 0.01246489f, 0.01133077f, -0.03154935f, -0.07488699f, 0.00260926f, 
    -0.02042429f, -0.05414582f, 0.00355435f, 0.00056056f, -0.00028493f, -0.08081033f, -0.06895672f, 0.01869578f, 
    0.00428526f, 0.03998349f, -0.03611245f, 0.01910347f, 0.01526537f, 0.03046167f, -0.05243839f, -0.01910326f, 
    0.02161584f, -0.03193111f, -0.05153302f, 0.00716073f, -0.03524312f, -0.01770520f, 0.02943448f, 0.01516700f, 
    -0.00326308f, -0.02729659f, 0.01176296f, 0.04597895f, -0.07404415f, -0.04871074f, -0.04052039f, 0.02827495f, 
    0.03784744f, 0.03182516f, 0.05834341f, -0.03735246f, -0.05209656f, 0.00047900f, -0.00474111f, 0.02690878f, 
    -0.06905939f, 0.05371090f, -0.00127717f, 0.02858117f, -0.00466776f, 0.04346373f, -0.06336295f, 0.02337380f, 
    -0.05131484f, -0.03175338f, -0.07176297f, -0.04978213f, -0.04469968f, -0.05590687f, -0.07138916f, -0.06197852f, 
    -0.07726944f, 0.04960714f, -0.00744197f, -0.07699273f, 0.03871582f, -0.01501373f, -0.00913813f, -0.02732743f, 
    -0.02313519f, -0.02996343f, -0.06850027f, 0.01085145f, -0.08026008f, -0.02211543f, 0.03490442f, -0.01902245f, 
    0.05178215f, 0.02186257f, -0.04053978f, 0.02967685f, -0.05715916f, -0.06048937f, -0.00045711f, -0.00724189f, 
    -0.02022492f, 0.01346680f, 0.02555703f, -0.00560510f, -0.06651744f, -0.08060952f, -0.02674034f, -0.02829099f, 
    0.05681337f, -0.04941988f, -0.01987576f, -0.02597244f, 0.03017346f, 0.04666607f, -0.07484686f, 0.05316714f, 
    -0.02407639f, 0.05577016f, 0.02912919f, -0.02850116f, 0.03133854f, -0.04081215f, 0.02485458f, 0.02256441f, 
    -0.01971013f, 0.00503474f, -0.06994993f, 0.06089055f, 0.06489343f, 0.01705653f, -0.04406041f, 0.04923059f, 
    -0.04363996f, -0.05141316f, -0.06866911f, -0.07673889f, -0.07171874f, -0.00372271f, 0.05368320f, 0.04613088f, 
    -0.01432525f, -0.03924936f, 0.02305688f, -0.04604146f, 0.03361242f, -0.05608475f, -0.04512951f, -0.02828843f, 
    0.16468875f, -0.04159300f, -0.16619530f, 0.04449673f, 0.02284806f, 0.04896810f, -0.01784669f, 0.26370370f, 
    0.07527743f, 0.09524884f, -0.09675019f, -0.13241982f, -0.56192356f, -0.09669106f, -0.38389704f, -0.35814548f, 
    -0.03502832f, 0.01615968f, -0.04209115f, 0.04500569f, -0.04812184f, -0.00951818f, 0.01694176f, 0.03940747f, 
    -0.34136522f, 0.40559268f, -0.37558672f, 0.08412879f, -0.00431330f, -0.07384411f, -0.05007980f, -0.10394278f, 
    0.07191826f, -0.01874420f, 0.02308163f, 0.04997877f, 0.23492669f, -0.03743339f, -0.10961327f, 0.07818814f, 
    0.03726029f, -0.09978785f, -0.02097983f, -0.00662376f, -0.01289400f, -0.09387849f, -0.06773059f, 0.03947365f, 
    -0.22227405f, -0.11526353f, -0.30916399f, 0.02362778f, 0.07486410f, 0.00332959f, -0.04101637f, 0.00713159f, 
    0.02377382f, -0.02806488f, -0.08950507f, 0.04981488f, -0.02635802f, -0.31585497f, 0.17941082f, 0.02432786f, 
    0.20127642f, -0.04505975f, 0.10308792f, 0.04599807f, -0.03135930f, -0.01385983f, 0.00286886f, -0.00888646f, 
    0.04042568f, 0.08874243f, -0.11733071f, 0.13322742f, 0.06894655f, -0.04510782f, 0.02673015f, -0.10274471f, 
    -0.00609440f, 0.01204200f, 0.03434051f, 0.07303741f, 0.35272878f, 0.28418663f, -0.15586607f, 0.02426708f, 
    -0.19083899f, 0.03007903f, -0.02621078f, -0.11836595f, -0.11312398f, 0.19477546f, -0.00461030f, 0.01290511f, 
    0.15577169f, -0.08378679f, -0.14198683f, 0.14625205f, 0.07415640f, -0.04682254f, 0.18318865f, 0.04610183f, 
    0.03921480f, -0.06942175f, 0.02866413f, 0.10027935f, 0.18339385f, -0.26046363f, 0.16020647f, -0.27771091f, 
    0.05526160f, 0.02310985f, 0.09545411f, -0.07219259f, 0.04159211f, 0.09088021f, -0.03672939f, 0.06025556f, 
    0.24355601f, 0.05143662f, 0.47179765f, 0.04584236f, 0.04524579f, 0.20619127f, 0.11774477f, 0.20119095f, 
    0.11117239f, -0.15604457f, -0.03822030f, -0.00016288f, 0.08294915f, 0.11135819f, 0.19689538f, -0.07201649f, 
    0.05612717f, -0.03746870f, -0.04225729f, -0.09028606f, 0.14634407f, 0.35567135f, 0.12069477f, 0.09273472f, 
    0.21885453f, -0.22170529f, 0.23602836f, -0.04738198f, -0.00093911f, 0.07094278f, -0.08808728f, -0.13283417f, 
    0.08247818f, 0.03268041f, 0.02347802f, -0.09134550f, 0.06771296f, -0.22829832f, -0.17569517f, -0.37732607f, 
    0.03131374f, 0.01470680f, -0.06678888f, -0.14207312f, 0.09598821f, 0.08661573f, 0.03667840f, 0.05793576f, 
    0.28469807f, -0.40324414f, 0.27003425f, -0.06093521f, 0.07627057f, 0.20322368f, 0.01272968f, -0.02541095f, 
    0.07483012f, 0.21864097f, -0.06627249f, 0.06385098f, 0.20505381f, -0.13104987f, -0.06002827f, 0.14458072f, 
    -0.08038396f, -0.09425009f, 0.14128588f, 0.13475654f, 0.08349493f, 0.04761120f, 0.09260570f, -0.08918434f, 
    -0.30478269f, 0.43322635f, 0.12835297f, -0.16232680f, 0.01992439f, 0.08511823f, 0.07749522f, 0.09727831f, 
    0.02211677f, 0.09239068f, -0.08370095f, 0.03052534f, -0.34620935f, 0.08035751f, 0.00000813f, 0.05620847f, 
    0.04749000f, 0.03615728f, 0.12804240f, 0.20554143f, -0.02729411f, 0.00062000f, 0.05767728f, 0.08794722f, 
    -0.13493831f, 0.32073000f, -0.34385771f, 0.15064123f, 0.07405189f, -0.17486799f, 0.17229399f, -0.01751868f, 
    -0.08586315f, -0.07960706f, 0.00168270f, -0.01049912f, -0.01045388f, 0.17407236f, -0.01134848f, 0.00271766f, 
    0.02352992f, -0.02254743f, -0.07411138f, -0.11549281f, 0.10900838f, 0.12500301f, -0.08342842f, 0.18191606f, 
    -0.06940293f, -0.06500077f, 0.16930635f, 0.01566746f, 0.01978293f, 0.12076189f, -0.04212061f, 0.14510097f, 
    -0.06244392f, -0.01265742f, 0.02916765f, 0.10102613f, 0.52960932f, -0.18290062f, 0.19073747f, -0.37221012f, 
    -0.10151206f, 0.02920288f, -0.07229827f, 0.02449454f, -0.19914500f, 0.02635524f, -0.11467570f, 0.00227257f, 
    -0.35703090f, -0.00986266f, -0.12475553f, -0.03480547f, 0.17275925f, -0.03815465f, -0.16772366f, 0.01518645f, 
    0.18924691f, 0.16069597f, -0.04485889f, 0.11128259f, -0.27983555f, -0.02197887f, -0.13094892f, 0.49152279f, 
    -0.06348799f, -0.08387176f, -0.18867075f, -0.07562996f, 0.33208668f, 0.03674113f, 0.11191697f, 0.08359090f, 
    0.04378672f, 0.01232194f, 0.06331563f, -0.06615235f, -0.09059307f, -0.01443395f, -0.07170685f, 0.07779019f, 
    0.07051931f, -0.02728223f, 0.02840426f, 0.01402542f, 0.26181239f, -0.09149724f, -0.01615205f, -0.36976498f, 
    0.15589072f, 0.00018881f, -0.08569933f, -0.16125880f, -0.04634191f, -0.03284993f, -0.13527326f, 0.03449015f, 
    -0.05431900f, -0.09423112f, 0.18423030f, 0.02082308f, -0.03176428f, -0.06775092f, 0.05583524f, -0.03827674f, 
    -0.06010590f, 0.05483082f, -0.02221752f, -0.05288687f, 0.04202705f, -0.21369937f, -0.00108138f, -0.15643874f, 
    -0.03294842f, -0.13094835f, 0.09226193f, -0.27430078f, 0.09763666f, 0.13847543f, 0.05483974f, -0.03090189f, 
    -0.08218919f, -0.16591915f, 0.05104440f, -0.02387970f, 0.04298608f, 0.10056156f, -0.11749535f, -0.05302637f, 
    0.21051736f, 0.21546133f, 0.03785144f, 0.02390973f, 0.13889395f, -0.18840180f, 0.07523916f, 0.01712765f, 
    0.07175121f, -0.06093036f, -0.10585044f, -0.05224626f, 0.05691236f, -0.05393051f, 0.09920601f, 0.16474813f, 
    -0.10425598f, -0.21318601f, 0.13343860f, 0.24292591f, -0.02981084f, 0.09935846f, -0.11722690f, 0.14520867f, 
    0.00832785f, 0.04084163f, 0.08747542f, 0.08885147f, -0.00167209f, -0.02424847f, -0.14950314f, 0.01014794f, 
    0.11314924f, 0.11174987f, 0.20719299f, 0.09367929f, 0.05271561f, -0.12680531f, -0.01862171f, -0.14957026f, 
    -0.01270717f, 0.02673460f, -0.18726826f, 0.01185634f, 0.04554674f, 0.10340574f, -0.05949190f, -0.02553746f, 
    0.00512689f, -0.05198167f, 0.02547228f, -0.04241080f, -0.08000428f, 0.49171862f, 0.07747322f, -0.05393525f, 
    0.08651227f, 0.10334776f, 0.29375580f, 0.18631962f, -0.07145674f, 0.01417197f, 0.04852681f, -0.03243012f, 
    -0.50283629f, 0.01537251f, -0.36609644f, 0.16488448f, 0.10864803f, 0.00607276f, -0.18930377f, -0.08161501f, 
    0.09362571f, 0.03584101f, 0.04787943f, -0.06667294f, -0.27913976f, -0.26462960f, -0.27023897f, 0.26158297f, 
    0.06316795f, 0.03099285f, -0.03401875f, -0.06416576f, 0.01041324f, -0.01494139f, 0.04527891f, 0.22771430f, 
    0.09626716f, 0.27612546f, 0.18529566f, 0.04935283f, 0.10039331f, 0.05975102f, -0.04126697f, 0.05645918f, 
    -0.00889566f, 0.04345616f, 0.00596098f, -0.09016079f, 0.19213280f, -0.11589395f, 0.02866221f, -0.09421881f, 
    0.02359427f, -0.08297497f, -0.06917807f, 0.27192825f, -0.01761158f, 0.02946291f, 0.04500088f, -0.01405020f, 
    -0.14023060f, -0.16929568f, -0.08641525f, 0.02241119f, -0.00774322f, -0.01436443f, 0.06012388f, 0.01148318f, 
    0.06413075f, 0.10487343f, -0.01052270f, 0.18856575f, 0.00415334f, 0.06191717f, -0.00489734f, 0.04147989f, 
    0.05396099f, -0.08465101f, -0.08957360f, 0.03613906f, -0.06459685f, -0.07426933f, 0.08951497f, 0.04031498f, 
    0.34730905f, 0.20077422f, 0.06320748f, 0.06438083f, 0.06579921f, 0.10790192f, -0.06948543f, -0.04250607f, 
    0.03505630f, -0.06195626f, 0.06139258f, 0.00374668f, -0.11354164f, -0.28027195f, -0.03764300f, -0.06434850f, 
    -0.02771178f, -0.06688407f, -0.05702538f, 0.10711972f, 0.07924310f, 0.07037827f, -0.15683922f, 0.09348739f, 
    0.25858638f, 0.35428491f, 0.22117524f, -0.00042933f, 0.15412879f, 0.07948827f, 0.04292332f, 0.13997808f, 
    0.10128865f, -0.00159700f, 0.05848353f, 0.04138844f, -0.02952230f, -0.36572909f, -0.15159334f, -0.08084286f, 
    0.00047580f, 0.09217395f, 0.04608238f, -0.03284706f, 0.03698581f, 0.07476743f, 0.06112695f, 0.07607096f, 
    -0.09895994f, -0.18854132f, -0.04173304f, -0.11554754f, -0.05661312f, 0.00020576f, 0.04573771f, 0.00922733f, 
    0.12387955f, 0.06980056f, 0.00002527f, 0.09220392f, 0.17823894f, -0.01803702f, -0.11976798f, -0.08486274f, 
    0.08589400f, 0.15087387f, 0.02766158f, 0.02627595f, -0.05197153f, -0.09267219f, -0.01652030f, 0.12381515f, 
    0.11211371f, 0.04577327f, 0.34029698f, -0.13198993f, -0.04375453f, -0.08542615f, 0.09898218f, 0.13530146f, 
    -0.04270355f, -0.11212511f, -0.04969017f, 0.01633643f, -0.02464157f, -0.07066044f, -0.07381672f, -0.02212735f, 
    0.02061434f, -0.02733584f, 0.05234592f, 0.02250751f, 0.10118828f, -0.01006964f, 0.01585773f, -0.00725715f, 
    -0.04236579f, -0.04026945f, -0.01811421f, -0.05710940f, -0.04726231f, -0.01429703f, -0.02409133f, -0.05250746f, 
    -0.00799937f, 0.03006456f, 0.01686571f, -0.00786228f, -0.05798715f, -0.04804823f, 0.03303058f, -0.02854563f, 
    0.04213320f, 0.06138491f, -0.03983128f, -0.02197219f, 0.01834725f, -0.03784443f, -0.05489403f, -0.01656640f, 
    -0.01252627f, 0.05672795f, -0.03069554f, -0.04228313f, 0.01754501f, -0.03769569f, 0.04780657f, 0.03315967f, 
    -0.07456396f, 0.03379484f, -0.02069652f, -0.06712869f, -0.06007328f, 0.03501128f, 0.03956812f, -0.06382231f, 
    0.03344197f, -0.01972234f, -0.03706639f, -0.01051769f, 0.00484513f, 0.00527132f, -0.01632201f, 0.00020024f, 
    -0.02455113f, -0.03299675f, 0.03310319f, 0.00050525f, -0.00724655f, -0.02657894f, -0.00936893f, 0.02879947f, 
    -0.05260179f, 0.00634375f, -0.07635505f, 0.05070999f, -0.07479267f, 0.05986922f, 0.02703043f, 0.06063663f, 
    -0.04789997f, 0.04791735f, 0.01239230f, 0.04067888f, 0.03414868f, 0.04263531f, -0.06146656f, -0.03580042f, 
    0.06423073f, -0.01551944f, 0.03171504f, -0.03341679f, -0.06965150f, 0.00298529f, 0.05060081f, -0.06564240f, 
    0.01447381f, 0.06511539f, -0.07243005f, 0.05898830f, 0.00561507f, 0.05171463f, -0.07460416f, -0.02231983f, 
    0.02721951f, -0.04171905f, -0.04149078f, -0.00196959f, -0.02352571f, -0.01149681f, 0.02223142f, -0.00831067f, 
    0.04357038f, 0.05042168f, -0.06050838f, 0.00502625f, 0.06306972f, 0.00341063f, -0.02511265f, 0.02946311f, 
    0.00572646f, -0.04757459f, -0.01697908f, 0.04545723f, -0.01503953f, 0.02487300f, -0.00023099f, -0.03557945f, 
    -0.05994279f, -0.06200714f, 0.02019962f, -0.07201989f, -0.06521724f, -0.00677038f, 0.02633124f, 0.01460539f, 
    0.02317434f, 0.06310382f, -0.01254188f, -0.05246795f, 0.06444151f, -0.02421659f, 0.00107618f, -0.04969807f, 
    0.01952533f, -0.03359915f, -0.00621559f, -0.01501805f, 0.00024642f, 0.04287170f, 0.05178945f, 0.04564016f, 
    -0.06718229f, -0.05884504f, -0.03670818f, 0.02434221f, 0.00684844f, 0.02176970f, -0.02683894f, -0.06717686f, 
    -0.00969248f, -0.06525284f, -0.05169956f, 0.00197607f, 0.01504995f, -0.00560715f, -0.05945529f, 0.06417502f, 
    -0.05268874f, 0.05657500f, 0.06526798f, -0.04104917f, 0.00360449f, -0.05949593f, 0.00786504f, 0.04123915f, 
    0.04988430f, -0.01927315f, -0.01339203f, -0.06544475f, -0.07368193f, -0.07045126f, -0.07577285f, -0.07486582f, 
    -0.01632485f, 0.01587421f, -0.06370553f, 0.06153421f, 0.06265432f, -0.01723784f, -0.01726789f, -0.01221607f, 
    -0.04977317f, 0.00490970f, -0.07562266f, -0.04429114f, 0.05552747f, 0.01253775f, -0.03547175f, -0.06014894f, 
    0.03902092f, -0.01289360f, 0.01961552f, 0.00954142f, -0.04703758f, 0.01804719f, 0.03256989f, -0.04053649f, 
    0.01410485f, -0.03724563f, -0.08869699f, 0.07409449f, -0.06453215f, -0.06906203f, -0.03207275f, -0.00972545f, 
    -0.00586744f, -0.07040124f, 0.02594698f, 0.11402166f, 0.00453770f, -0.05214422f, 0.03087081f, -0.05761476f, 
    -0.07551499f, -0.05118223f, -0.03951469f, -0.00421881f, -0.07880383f, -0.01743338f, 0.04212268f, 0.00614550f, 
    0.02274717f, 0.06590100f, -0.09768027f, -0.00097608f, 0.01100274f, 0.02091810f, -0.06504228f, 0.00069605f, 
    -0.07791619f, -0.03335638f, -0.05754697f, -0.07198569f, -0.04050806f, -0.02083503f, -0.05067763f, -0.07495353f, 
    0.06122700f, -0.06643213f, -0.03847317f, 0.02842292f, -0.10343394f, -0.00532065f, -0.08613952f, 0.00453300f, 
    -0.06181485f, -0.01835819f, -0.05315145f, -0.01990663f, 0.02038190f, -0.07371772f, -0.06042064f, 0.07926209f, 
    0.04784956f, -0.03178340f, 0.03859037f, 0.04696960f, -0.00224039f, -0.11604708f, -0.06382098f, 0.01956888f, 
    -0.03129993f, 0.03524301f, 0.06943347f, 0.01180659f, -0.07565370f, -0.05548304f, 0.00164250f, 0.06576385f, 
    -0.01129060f, -0.01694398f, -0.02595654f, -0.08510271f, -0.07761147f, -0.02131214f, -0.00607065f, -0.09698530f, 
    -0.08862145f, -0.06981011f, -0.05375371f, -0.06358188f, -0.01031204f, 0.04303142f, 0.00097431f, 0.03096079f, 
    0.02642344f, -0.08668973f, -0.06178128f, -0.00908331f, 0.02854601f, -0.08851288f, -0.07581174f, -0.00423307f, 
    0.00879792f, -0.01034021f, 0.05709140f, -0.10622319f, -0.08072913f, -0.08406423f, 0.04311753f, -0.01101286f, 
    -0.03986636f, -0.01504769f, 0.02311692f, 0.04805765f, 0.04359247f, -0.11523093f, -0.00407140f, -0.13046390f, 
    0.01615508f, 0.05531536f, -0.07942070f, -0.07437456f, -0.08674853f, -0.07920018f, -0.03806165f, -0.04948181f, 
    0.03014733f, 0.01447456f, 0.01352491f, -0.07920820f, -0.01684203f, -0.00598734f, 0.01780644f, 0.01250953f, 
    -0.07943927f, -0.04388070f, -0.08034413f, 0.04020309f, -0.04520503f, 0.01142187f, -0.07868364f, -0.07787900f, 
    -0.05964180f, 0.02451685f, -0.02076176f, 0.00437410f, 0.04927010f, -0.02653978f, -0.05887649f, 0.02090582f, 
    -0.07758341f, -0.07516894f, -0.02607897f, -0.08981606f, -0.07717041f, 0.01509231f, 0.03451753f, -0.01274216f, 
    -0.00248183f, -0.01878867f, 0.02330097f, 0.00586643f, 0.05181253f, 0.03964226f, -0.01643421f, -0.05593726f, 
    0.04235375f, -0.10190213f, 0.01049495f, 0.03627574f, 0.02399262f, -0.04489209f, 0.04871561f, 0.05971181f, 
    -0.04940817f, -0.07810067f, 0.07895497f, 0.00793315f, 0.02074940f, -0.01313553f, -0.08828559f, -0.05791682f, 
    -0.03061914f, 0.08313836f, 0.02844922f, 0.02353293f, -0.03061805f, -0.11181200f, -0.10991075f, -0.00095124f, 
    -0.02231789f, -0.02580291f, -0.03200715f, 0.04989934f, -0.05346562f, 0.00920176f, -0.05159196f, -0.00917711f, 
    0.02588066f, 0.23885161f, 0.38907999f, -0.04479161f, -0.11405651f, 0.01253911f, 0.11867788f, -0.08377323f, 
    0.01525464f, 0.21185407f, 0.15315737f, 0.19518161f, 0.07900686f, -0.27354074f, -0.19402754f, 0.02866822f, 
    0.07962015f, -0.02924781f, -0.06781982f, 0.08107025f, -0.00910286f, -0.14797258f, -0.00519015f, 0.00826818f, 
    0.07987747f, 0.16738230f, -0.02160519f, -0.20964561f, -0.09327735f, -0.03337162f, -0.05613185f, -0.01769686f, 
    0.02102201f, 0.04823629f, 0.01896708f, -0.17824112f, 0.14067926f, 0.05573568f, -0.01663777f, -0.27461895f, 
    0.06879845f, -0.03160111f, 0.00482053f, 0.05720915f, -0.08662718f, -0.20352617f, -0.10405093f, -0.15622938f, 
    -0.08044863f, -0.30853823f, -0.13757163f, 0.24257231f, 0.10159404f, 0.06302764f, 0.13424334f, 0.10042971f, 
    0.11505529f, 0.08475707f, 0.12716544f, 0.15259430f, -0.06676240f, -0.09728838f, 0.13784783f, -0.04734517f, 
    0.19330728f, 0.00542235f, 0.12236703f, 0.08782783f, -0.06046103f, -0.12256855f, -0.01003067f, 0.00513658f, 
    -0.03527592f, -0.03787798f, -0.12628706f, -0.03866175f, 0.00475664f, -0.15214938f, 0.05679578f, -0.02041703f, 
    -0.04554252f, -0.17835012f, -0.20902786f, -0.19762121f, 0.12439909f, 0.28850108f, -0.03849310f, 0.00436331f, 
    0.10624408f, 0.06937473f, -0.14828594f, 0.03785682f, 0.07578139f, 0.12812951f, -0.04149486f, 0.12699854f, 
    -0.23888072f, -0.04411653f, 0.08896048f, 0.04366016f, 0.02932355f, -0.13080306f, 0.03839190f, 0.16011758f, 
    -0.15325275f, -0.03950442f, -0.24374838f, -0.14945728f, 0.24646193f, -0.03700966f, -0.01400814f, -0.14708585f, 
    0.03965761f, 0.13234527f, 0.06179516f, -0.13922216f, 0.03850522f, -0.15684389f, -0.01133568f, 0.03154809f, 
    -0.07377266f, -0.14631358f, 0.08975101f, 0.16253579f, 0.03797122f, -0.05339683f, -0.06166579f, 0.06489954f, 
    0.14187981f, 0.04889975f, 0.02547466f, -0.11719491f, 0.13468170f, -0.00424119f, 0.15289120f, -0.27856833f, 
    -0.11516906f, -0.12431787f, 0.08000275f, 0.00473935f, 0.15783940f, 0.30159292f, 0.04003720f, 0.02615969f, 
    0.20772919f, -0.16958094f, 0.15687664f, 0.02874018f, 0.10266028f, 0.11627027f, -0.15049440f, -0.00891795f, 
    -0.02744172f, -0.04355357f, -0.04118770f, -0.16000903f, 0.04444040f, -0.01140996f, 0.19321106f, 0.14143409f, 
    0.02755819f, -0.12545402f, 0.04492306f, 0.06948114f, 0.05574060f, 0.14831638f, -0.05610658f, 0.16402306f, 
    0.00639817f, -0.17144625f, -0.04210763f, 0.14511323f, 0.05636264f, 0.18797728f, -0.16561028f, 0.02827999f, 
    0.03293302f, 0.17685409f, 0.15956138f, 0.00444835f, 0.05890317f, 0.03397899f, -0.06923346f, 0.00092142f, 
    0.00632040f, -0.08545545f, 0.17837988f, 0.02495830f, 0.09491372f, 0.13916838f, 0.09487061f, 0.13164355f, 
    0.43132067f, -0.32007200f, -0.02267308f, 0.11815564f, 0.13897432f, -0.25115636f, -0.11965536f, -0.10173713f, 
    0.18552013f, 0.03823490f, 0.07625494f, 0.08117124f, 0.38602415f, 0.09827863f, 0.16842550f, 0.11986847f, 
    0.02514062f, -0.02222867f, -0.04396899f, 0.04102013f, 0.01298277f, 0.11792590f, -0.06953282f, -0.00369449f, 
    0.02185502f, -0.25046548f, 0.26843154f, -0.01784202f, -0.03237092f, 0.04040810f, -0.07199621f, 0.05820246f, 
    0.04625814f, 0.22693229f, -0.20337638f, -0.01987197f, 0.03562264f, -0.19312771f, -0.10456893f, -0.09718706f, 
    -0.14666410f, -0.02227766f, -0.01791310f, 0.06826482f, -0.04600554f, -0.06710370f, -0.11074684f, -0.14998187f, 
    0.06149186f, 0.13926658f, -0.01031213f, 0.05089168f, 0.11914496f, 0.14469619f, -0.03780041f, 0.04674191f, 
    0.02173756f, 0.03247075f, -0.00157301f, -0.02585451f, -0.22333175f, 0.18808438f, -0.17664066f, 0.13965650f, 
    0.13655393f, -0.06712145f, 0.03961732f, 0.08242163f, -0.07044467f, -0.02585160f, 0.06915723f, -0.09536559f, 
    0.36446095f, -0.38393289f, -0.16525333f, -0.24477196f, -0.05787613f, 0.10542484f, 0.10550137f, -0.17578870f, 
    -0.08718935f, -0.15776393f, 0.02150889f, 0.01335863f, 0.16756605f, 0.01654113f, 0.21358950f, -0.19983253f, 
    -0.10893803f, 0.10659132f, 0.13564755f, 0.10032535f, -0.06564058f, 0.12021653f, 0.06844889f, -0.02204204f, 
    0.10098746f, 0.14249083f, 0.08527616f, 0.22571300f, 0.04243565f, 0.23500127f, 0.24731964f, 0.05138271f, 
    -0.10432573f, -0.08968401f, 0.01162970f, 0.02533531f, -0.58327669f, -0.10485699f, -0.11134391f, -0.02533304f, 
    -0.03730631f, 0.09616096f, 0.04321587f, -0.03515783f, 0.05350336f, 0.29172364f, -0.08443789f, -0.20433472f, 
    -0.12897593f, 0.21424051f, -0.01817335f, 0.22169682f, 0.04233203f, 0.09255809f, -0.21218163f, 0.16636823f, 
    0.10241085f, -0.02869450f, 0.04809105f, 0.22570693f, 0.02014840f, 0.44512123f, -0.04939086f, 0.01618020f, 
    -0.14109220f, 0.20467786f, -0.28679246f, 0.00571224f, 0.24512149f, -0.05634640f, -0.01005198f, -0.01519758f, 
    0.14303996f, 0.20180850f, -0.03144236f, -0.01097189f, -0.13367000f, -0.09673221f, 0.08230586f, 0.10129570f, 
    -0.14256236f, -0.13276212f, 0.11620128f, 0.05450394f, 0.05178721f, 0.29691991f, -0.03182419f, 0.11626004f, 
    -0.15289953f, 0.14657943f, 0.09267387f, -0.06309590f, 0.02522353f, 0.01888232f, 0.04337512f, -0.04137377f, 
    0.10635614f, 0.17004243f, 0.13435827f, 0.03232448f, -0.03531618f, 0.04116271f, 0.17837691f, -0.02577712f, 
    0.10221348f, 0.05219205f, -0.06631152f, 0.01420319f, 0.06057793f, 0.06586238f, 0.09456824f, 0.10749924f, 
    -0.16052410f, -0.02329169f, -0.14383455f, -0.10957799f, -0.15201357f, -0.01031907f, -0.23814233f, 0.16280307f, 
    0.26716113f, -0.11199468f, 0.28738663f, -0.46846375f, 0.05281858f, -0.05530751f, -0.11298975f, -0.07481325f, 
    0.10500436f, 0.00482428f, -0.01957372f, 0.08205051f, -0.09507871f, 0.30568966f, -0.10414731f, -0.14429636f, 
    -0.18996181f, 0.17532738f, -0.09145431f, 0.16864991f, 0.00419385f, 0.00466494f, -0.19372284f, 0.08216247f, 
    -0.18585534f, -0.26700866f, 0.03640120f, 0.03167948f, 0.15363821f, -0.06055614f, 0.02792759f, 0.11741240f, 
    -0.00362857f, -0.14111207f, 0.04381458f, 0.01197889f, -0.01080681f, -0.09254718f, -0.04803212f, -0.14379509f, 
    -0.05808765f, 0.01159449f, -0.06913814f, 0.02762533f, -0.02875804f, 0.08599307f, 0.00935120f, -0.03101071f, 
    0.14120005f, 0.28015077f, 0.08674653f, -0.31953642f, 0.07558567f, 0.14588803f, -0.22922428f, 0.00289516f, 
    0.15673099f, 0.04794881f, 0.09239426f, -0.02457079f, 0.35650158f, 0.10005588f, -0.32833371f, -0.34657162f, 
    0.02968749f, -0.23011149f, 0.05943225f, 0.05505905f, -0.10277840f, -0.03187393f, 0.06310174f, -0.06346369f, 
    -0.10327815f, -0.01907012f, 0.03472839f, 0.07044218f, 0.07592242f, 0.01913027f, 0.02861527f, 0.08549619f, 
    0.05274152f, 0.09606487f, 0.09208806f, 0.25144243f, -0.04547352f, -0.57607675f, 0.13267805f, 0.48314825f, 
    -0.20570014f, -0.04140252f, 0.01177982f, 0.05937991f, 0.24125122f, -0.03487588f, -0.01322618f, 0.01696546f, 
    0.04639572f, -0.08459480f, -0.00493683f, -0.25894248f, -0.02580350f, 0.19182965f, 0.26983002f, 0.02826153f, 
    -0.08926331f, -0.01672888f, -0.09813699f, 0.03754023f, 0.03480373f, 0.03585930f, -0.06122593f, -0.17594923f, 
    0.03749236f, 0.14867252f, 0.12635702f, -0.05891621f, -0.03618380f, 0.14200500f, 0.05877348f, 0.02646557f, 
    -0.03709724f, -0.04503394f, -0.23689301f, 0.03255129f, -0.14360557f, 0.00449999f, 0.05945016f, 0.10214610f, 
    -0.03265793f, -0.00540199f, -0.06012870f, 0.20614398f, -0.10682093f, 0.18299899f, 0.12582797f, -0.10067627f, 
    0.03925882f, 0.06002327f, 0.01568777f, 0.00152543f, 0.11066176f, -0.05712432f, -0.06433870f, -0.22464277f, 
    0.25219426f, -0.18067695f, 0.04975976f, 0.11245230f, -0.10016926f, 0.21856864f, -0.08205645f, 0.13253325f, 
    -0.07298776f, -0.02776305f, 0.23017427f, 0.18583931f, 0.36237368f, 0.45296848f, 0.02559817f, -0.02476818f, 
    0.03639701f, 0.08223630f, 0.11125248f, -0.08060703f, 0.12764172f, 0.02737591f, 0.18802291f, 0.04832995f, 
    0.51421875f, -0.10022038f, 0.02510498f, 0.07211024f, 0.01404108f, 0.15102342f, -0.01479229f, -0.01072232f, 
    0.24790035f, 0.03643379f, 0.05991833f, 0.02077360f, -0.20311728f, 0.03218990f, 0.02116079f, -0.16869274f, 
    0.08375233f, -0.06721137f, -0.02034725f, 0.06139452f, -0.26983145f, -0.18257999f, -0.22717331f, 0.06684733f, 
    -0.23942025f, 0.59878671f, 0.11085499f, 0.00728537f, 0.18564172f, 0.22120602f, -0.16638605f, -0.12923691f, 
    0.25549793f, 0.06296558f, 0.15434229f, 0.10869906f, -0.14042935f, 0.03999207f, -0.07825781f, 0.13242421f, 
    0.12442145f, -0.03232351f, 0.12264542f, 0.08899578f, -0.17352475f, -0.24290526f, 0.17743574f, 0.13324809f, 
    -0.20794356f, -0.20730160f, 0.15724941f, 0.08096144f, -0.05670862f, 0.03766610f, -0.23647375f, 0.03427820f, 
    0.05362720f, -0.16537027f, 0.13304976f, -0.05771350f, -0.25395051f, 0.23349556f, -0.11573783f, 0.12214830f, 
    0.37648523f, -0.16156755f, -0.09306911f, -0.00879940f, -0.05300745f, -0.17975557f, -0.09626231f, 0.03734915f, 
    -0.17048925f, -0.09952131f, 0.12670697f, 0.30358315f, -0.06752963f, 0.02851792f, 0.12004536f, 0.34444705f, 
    -0.02552777f, 0.02432000f, 0.06532010f, 0.19303939f, -0.06620441f, 0.20935710f, 0.41037044f, -0.08754625f, 
    0.09876642f, 0.05125254f, 0.12295422f, 0.16540684f, -0.10135944f, -0.03895348f, -0.14064460f, -0.09787951f, 
    -0.14592537f, -0.00288347f, -0.20049670f, 0.03502345f, 0.14804137f, -0.15865807f, -0.12475318f, -0.03685009f, 
    -0.02262794f, -0.05271506f, -0.21707729f, -0.22573012f, -0.05750580f, 0.15640211f, -0.42034024f, -0.04938576f, 
    0.20536526f, -0.01263675f, -0.00922732f, 0.14868471f, -0.00499396f, -0.02864844f, -0.04760460f, 0.11988561f, 
    -0.05869967f, 0.00134430f, 0.17469105f, 0.08732654f, -0.01015060f, -0.00407238f, -0.01848141f, -0.16425845f, 
    -0.01309228f, -0.12514140f, -0.08798163f, -0.17197329f, -0.08864924f, -0.18928882f, 0.04288146f, 0.01153715f, 
    0.16673516f, 0.00724283f, -0.18294869f, -0.06535129f, 0.19845779f, 0.13402854f, -0.19383304f, 0.17130117f, 
    0.17904839f, -0.27880362f, 0.24934071f, 0.23924917f, 0.07054127f, -0.14522408f, 0.09103584f, -0.08161248f, 
    0.05732091f, 0.04637307f, -0.09888911f, 0.00974623f, 0.04980874f, -0.35180959f, -0.09025259f, -0.23785402f, 
    -0.06114726f, 0.07012103f, 0.04601421f, 0.15304756f, 0.10576828f, 0.13972038f, -0.01867504f, 0.24725968f, 
    0.01889851f, 0.01976379f, 0.13625228f, -0.21803305f, 0.26794717f, -0.16426910f, -0.26499128f, -0.01290612f, 
    0.23600429f, -0.00367947f, 0.01074946f, 0.05364436f, -0.11332116f, -0.02323480f, 0.18596052f, 0.18105793f, 
    0.06742638f, 0.08332659f, -0.09408298f, 0.13174160f, -0.12441579f, 0.09814359f, -0.05227033f, 0.08827148f, 
    -0.24998945f, -0.10612984f, 0.22532555f, 0.06648288f, -0.04144565f, -0.05073891f, -0.17890009f, 0.27880758f, 
    -0.01931249f, 0.00684592f, -0.00731154f, 0.05832249f, -0.05300128f, 0.06046291f, -0.03284902f, 0.20910361f, 
    0.05528027f, 0.01296110f, 0.07567462f, 0.09732126f, 0.26060131f, 0.20979701f, 0.16239028f, -0.13503309f, 
    -0.17679429f, -0.15429838f, -0.16128090f, 0.21415688f, -0.06663677f, -0.06940186f, -0.05055701f, -0.02623269f, 
    0.07469401f, -0.06464941f, -0.15347503f, -0.03612729f, 0.41848347f, 0.21653378f, 0.06106420f, 0.01273400f, 
    0.04707606f, 0.18512763f, 0.05543067f, 0.19774716f, -0.03773348f, -0.02235468f, 0.01763093f, 0.04658066f, 
    -0.41147229f, -0.08172219f, 0.36580732f, -0.02533871f, 0.15224966f, 0.00132610f, -0.23021519f, 0.06822021f, 
    0.06620743f, 0.17906623f, 0.04022012f, -0.00258753f, -0.49476162f, 0.08081697f, -0.01331202f, -0.12231646f, 
    0.03848185f, -0.04079663f, -0.07716706f, -0.06874348f, -0.02293016f, 0.06355256f, 0.09783198f, 0.04972220f, 
    0.16504964f, 0.16493617f, 0.07804240f, -0.09038393f, 0.13085733f, 0.03878209f, -0.15941229f, -0.04824126f, 
    -0.09429436f, 0.01212972f, 0.05153301f, 0.00795889f, -0.21828863f, 0.24575324f, -0.04100984f, 0.12619787f, 
    -0.09347650f, -0.11797485f, 0.07215487f, 0.04478847f, 0.04377638f, 0.03917992f, 0.12850331f, 0.02785892f, 
    -0.14185219f, -0.04623955f, -0.03943544f, -0.08830275f, -0.16598436f, 0.05307921f, 0.01643071f, 0.01015017f, 
    -0.04395428f, 0.03876306f, 0.14322597f, 0.18852285f, 0.19780186f, 0.16366583f, -0.22634198f, -0.28891379f, 
    0.02954795f, 0.05252189f, 0.07383037f, 0.04705388f, -0.03786661f, -0.09992272f, 0.01773166f, -0.07762732f, 
    -0.02682319f, 0.07483952f, -0.15004824f, 0.07007787f, 0.07849633f, 0.25371382f, -0.04161036f, -0.20871209f, 
    0.08034897f, 0.03322160f, 0.15813462f, 0.16915542f, -0.16938880f, 0.03778836f, 0.02279677f, -0.09275429f, 
    -0.03569552f, 0.12818053f, -0.11694165f, 0.07035780f, 0.08961572f, 0.14583521f, 0.00242797f, -0.01581933f, 
    0.06220243f, 0.01993937f, -0.18263981f, -0.07215701f, 0.19662407f, 0.28234717f, 0.01195272f, 0.13434656f, 
    -0.00183193f, -0.02023387f, 0.01864294f, 0.00623927f, -0.15127082f, 0.23396493f, -0.12705240f, -0.05472730f, 
    0.02218790f, 0.03301176f, -0.06148339f, 0.05128079f, 0.08795493f, -0.14902149f, 0.06630097f, -0.05247054f, 
    0.04981957f, 0.03173526f, 0.10357364f, -0.14397861f, 0.02610664f, 0.05464745f, 0.02439308f, 0.15155755f, 
    0.11234897f, -0.00460514f, 0.19438541f, 0.09240311f, 0.00596015f, 0.17300913f, -0.01915805f, -0.01432488f, 
    0.06534155f, 0.21417131f, 0.09349617f, 0.07874244f, 0.11967632f, -0.05717202f, 0.09218851f, -0.11971090f, 
    -0.00965952f, 0.42189801f, -0.02696019f, -0.24040909f, 0.02297810f, -0.19589730f, -0.07166042f, 0.00345107f, 
    -0.05411184f, -0.18152621f, -0.09384900f, 0.01572687f, -0.27563962f, 0.05472256f, 0.13594422f, -0.06028078f, 
    -0.10647846f, -0.05867408f, -0.05674614f, -0.06134477f, -0.06189778f, -0.00715776f, 0.00283443f, -0.07571720f, 
    -0.04648024f, 0.09887987f, 0.06355496f, 0.09037936f, 0.04097122f, -0.05893265f, -0.04270775f, -0.28949046f, 
    0.07915983f, 0.09631409f, 0.04169527f, 0.20659035f, -0.03334031f, 0.10103381f, -0.06286504f, 0.06660741f, 
    -0.01880432f, -0.05586230f, -0.01917527f, 0.01963633f, 0.04150125f, -0.08989057f, 0.17124537f, 0.04407923f, 
    -0.18762884f, 0.06832270f, -0.30733213f, 0.29605183f, -0.05580074f, 0.12799771f, -0.01239453f, -0.16912836f, 
    0.08003731f, -0.20920745f, 0.12830132f, -0.02841978f, -0.21458398f, -0.03743361f, -0.04468084f, 0.19295146f, 
    0.09359016f, 0.18594363f, -0.04787242f, -0.13391609f, 0.01779634f, 0.00958831f, -0.04708169f, -0.02223736f, 
    -0.09601123f, 0.06143979f, 0.05701007f, -0.07439514f, -0.01923781f, 0.09306093f, 0.01028732f, 0.13306990f, 
    0.01639032f, 0.12143923f, 0.02283476f, 0.05151675f, -0.01503501f, 0.09455359f, 0.02204804f, -0.24625754f, 
    0.22827175f, 0.00528780f, 0.05388266f, 0.16283694f, -0.04748384f, -0.02359587f, -0.17996691f, -0.14385636f, 
    -0.21178719f, -0.15106963f, 0.03674842f, 0.21949197f, 0.08309282f, 0.03455530f, 0.12266125f, 0.11527857f, 
    -0.18079364f, -0.15792339f, -0.19139788f, -0.28527683f, 0.40936580f, 0.05607137f, -0.07157717f, 0.17758793f, 
    -0.37148252f, -0.00657052f, -0.06944533f, 0.00241872f, 0.11004367f, 0.07747858f, 0.00719785f, -0.07562036f, 
    0.00915530f, 0.06825927f, 0.11681110f, 0.22839047f, 0.07139118f, -0.00468538f, -0.01197022f, 0.07874529f, 
    -0.30139875f, -0.26639444f, -0.17289783f, -0.22386599f, -0.13222334f, -0.35614687f, 0.02328962f, -0.34850985f, 
    0.08944393f, -0.02780540f, -0.08634494f, 0.05306782f, 0.11694118f, 0.00415737f, -0.46074900f, -0.00785236f, 
    0.34752890f, 0.28021768f, 0.08684538f, 0.01104108f, -0.01029106f, -0.02632276f, -0.02244688f, 0.08830554f, 
    0.01295145f, 0.05080382f, 0.04875930f, 0.05239529f, 0.06944117f, -0.21723740f, -0.12156297f, -0.14317964f, 
    -0.00357123f, 0.07172786f, 0.14296405f, 0.11586691f, 0.00107281f, 0.06830934f, -0.04579135f, -0.06422547f, 
    0.20934220f, 0.00967958f, 0.01653785f, 0.07470051f, 0.00029096f, -0.05037424f, -0.12616368f, -0.06131811f, 
    -0.08447210f, 0.00541196f, -0.06831767f, -0.05549784f, 0.24258964f, 0.25449717f, 0.21263582f, 0.13010512f, 
    -0.10141811f, -0.18135133f, -0.18202808f, -0.05772986f, 0.01004765f, 0.00264150f, 0.02707205f, -0.03049120f, 
    0.28324804f, 0.01610439f, 0.12508032f, 0.04597329f, -0.11641746f, 0.08890427f, -0.11980250f, -0.20316766f, 
    -0.03705302f, 0.13349037f, -0.12480744f, -0.01060987f, -0.01941535f, 0.01999924f, -0.06862967f, 0.12859540f, 
    0.08081861f, 0.03972875f, -0.00346972f, 0.00487808f, 0.04729484f, 0.11554731f, 0.11728357f, 0.38738152f, 
    -0.14633486f, -0.17115806f, 0.15721653f, 0.07016417f, -0.00269521f, 0.15721251f, -0.03818778f, 0.03787015f, 
    0.11098706f, -0.04253497f, 0.12264939f, 0.08412647f, 0.31997392f, 0.20893075f, -0.15895233f, -0.06153470f, 
    0.18477088f, 0.15791570f, 0.11265669f, 0.07228935f, 0.03842562f, 0.02812354f, -0.02293438f, 0.08842565f, 
    0.16079521f, -0.19855611f, 0.52754295f, 0.02513845f, 0.09435685f, -0.03123862f, -0.14869182f, 0.16067722f, 
    0.04173324f, -0.14237557f, 0.09491596f, 0.01674710f, 0.14901082f, 0.13874897f, 0.04604220f, 0.10994411f, 
    -0.08123500f, -0.16413446f, -0.04214251f, -0.11502038f, 0.02938383f, -0.18128160f, -0.08030647f, 0.01966789f, 
    0.14266892f, 0.06675316f, -0.08079926f, -0.08343029f, 0.14001575f, -0.06566907f, -0.07574765f, 0.01084039f, 
    -0.10044466f, -0.00120498f, -0.11760444f, -0.02852725f, 0.20217678f, 0.43968728f, 0.07300640f, 0.05808058f, 
    -0.08822966f, -0.07814553f, 0.11141147f, 0.06103629f, -0.12741473f, 0.03433874f, 0.07307033f, -0.03269477f, 
    0.08866392f, -0.09029201f, -0.06194890f, -0.03864056f, -0.06752557f, 0.07150199f, 0.00199486f, 0.02448746f, 
    0.04217152f, 0.00320942f, 0.06631207f, -0.01232308f, 0.04942410f, 0.13632642f, -0.41275597f, -0.08678724f, 
    0.11479168f, 0.08061991f, -0.01753830f, -0.07229652f, -0.19197728f, -0.07758716f, -0.00556203f, 0.08841480f, 
    0.20755149f, 0.13389599f, -0.00482020f, 0.12574224f, 0.07935955f, -0.00545792f, 0.13823363f, 0.11937414f, 
    -0.10834838f, 0.08940466f, -0.03332835f, -0.00835176f, 0.06116666f, -0.15310325f, 0.14803721f, -0.09464004f, 
    -0.08708882f, 0.11995981f, -0.07611819f, -0.22805880f, 0.12453152f, 0.04086016f, -0.11846607f, -0.10140260f, 
    0.07950526f, 0.00333406f, 0.03687156f, 0.09856000f, 0.11289377f, 0.17194997f, 0.11518696f, 0.18614501f, 
    0.05203721f, -0.16264240f, -0.10361593f, -0.02689664f, 0.12419957f, -0.11127742f, 0.24274346f, 0.07413702f, 
    -0.25048250f, -0.00324712f, -0.18772292f, -0.09205417f, -0.01209664f, -0.00904726f, 0.03460801f, 0.07383227f, 
    0.08091412f, 0.01532220f, -0.01250118f, -0.07887495f, -0.03131600f, 0.09895994f, 0.03134983f, 0.06911149f, 
    0.07336440f, -0.14376284f, 0.14246759f, 0.00089054f, -0.14758155f, -0.27074921f, -0.30724794f, -0.19547446f, 
    0.15102676f, 0.12632713f, 0.00345175f, -0.04129262f, 0.07017639f, -0.01337576f, -0.14700301f, -0.00448604f, 
    -0.14893447f, 0.50061780f, 0.01964117f, -0.19601846f, 0.05988514f, 0.05311594f, 0.05619638f, -0.01359448f, 
    0.03395098f, 0.01009297f, 0.03011538f, -0.00606018f, 0.15235183f, 0.01156800f, 0.12096731f, 0.07278184f, 
    -0.03965478f, -0.01022885f, 0.02111790f, 0.14886723f, -0.08440937f, -0.11986835f, -0.02208798f, -0.10575133f, 
    0.25000694f, -0.12205627f, -0.02743566f, -0.08262651f, -0.01120732f, 0.18913977f, -0.07554585f, 0.15924042f, 
    -0.03928297f, 0.00474854f, -0.05148119f, -0.07689777f, -0.28174767f, -0.35278395f, -0.14108585f, -0.05021397f, 
    0.08927719f, 0.03372578f, 0.04325240f, -0.03896455f, -0.13924403f, -0.01806240f, -0.01313051f, 0.05547963f, 
    0.19959964f, 0.01489491f, 0.33810082f, 0.05834791f, 0.14418897f, 0.10671952f, 0.00282475f, 0.02153819f, 
    -0.22351564f, -0.03631313f, -0.00910949f, -0.04137330f, 0.22407326f, 0.12460599f, 0.06562515f, -0.00018400f, 
    0.00103642f, -0.04355827f, 0.00262263f, -0.03483970f, -0.04019621f, -0.12730186f, 0.00312380f, 0.10987226f, 
    -0.07122637f, -0.24598183f, -0.17965980f, -0.05186155f, -0.03415201f, 0.16606404f, 0.24945208f, -0.13145956f, 
    0.07555535f, 0.07105617f, 0.11393891f, -0.05784529f, -0.12193669f, -0.24844056f, -0.12290453f, 0.23271333f, 
    0.00480831f, 0.13399807f, -0.15753649f, -0.20752518f, -0.07890223f, -0.11858744f, -0.00439541f, 0.09291501f, 
    -0.06725889f, 0.01770083f, -0.07638969f, -0.07470994f, -0.05728398f, -0.16120335f, -0.06705295f, -0.08912387f, 
    -0.09784675f, -0.04858015f, 0.15492220f, 0.00100406f, -0.27523461f, 0.22133625f, 0.17032231f, -0.07742819f, 
    -0.07625159f, -0.17164096f, 0.07842404f, 0.00043780f, 0.14658478f, 0.03429972f, 0.27262494f, 0.08510103f, 
    -0.27857590f, -0.14605053f, -0.13267183f, -0.12447429f, 0.01994090f, -0.03456515f, -0.01618880f, 0.14972755f, 
    0.06197520f, 0.18202993f, 0.00531476f, 0.08243525f, 0.11406048f, 0.07292925f, -0.06344432f, 0.07145949f, 
    0.13705006f, 0.05885350f, 0.09006092f, -0.06603856f, -0.00713800f, -0.08885760f, 0.11075208f, 0.19653644f, 
    -0.30282918f, -0.31089723f, -0.30147958f, -0.34040907f, -0.00434752f, -0.01847038f, 0.14050148f, -0.05412162f, 
    -0.00291445f, -0.04339807f, -0.03041858f, 0.06419014f, -0.02438722f, 0.22304837f, 0.03695652f, 0.06883201f, 
    -0.00891160f, -0.10212351f, -0.05015438f, -0.12298808f, 0.00687167f, 0.08280017f, 0.16602840f, 0.20981550f, 
    -0.11878935f, 0.23199545f, 0.17904253f, 0.21352372f, -0.03994051f, -0.10501147f, 0.06493504f, 0.04089770f, 
    0.30873042f, 0.12410596f, 0.24025311f, 0.04579369f, -0.29292214f, -0.13047825f, 0.07842088f, 0.12100186f, 
    -0.00023735f, 0.12254360f, 0.10412007f, -0.06567480f, 0.17038697f, 0.12569056f, -0.07158867f, -0.01212349f, 
    -0.06011033f, 0.17501751f, 0.14213727f, -0.03816791f, 0.23551145f, 0.00474934f, 0.28694832f, 0.33649397f, 
    0.10968120f, 0.01041611f, 0.25315478f, -0.00379212f, -0.10731462f, 0.03719983f, 0.15422563f, -0.01603489f, 
    0.07377527f, 0.12019347f, 0.05268050f, 0.02717215f, -0.05369982f, -0.09483494f, -0.10386001f, -0.19773012f, 
    0.02113975f, 0.24963434f, 0.43859270f, -0.05698466f, 0.11387638f, 0.15247348f, 0.00485710f, -0.18261921f, 
    0.10864089f, 0.13461350f, 0.19613443f, 0.24452040f, -0.08283062f, -0.20562430f, -0.11181148f, 0.11968984f, 
    0.02456189f, -0.14135821f, -0.06260879f, 0.04151078f, -0.12892281f, -0.14254126f, -0.01950220f, -0.06547980f, 
    0.09448025f, -0.06468997f, 0.13380602f, -0.15558785f, -0.00688389f, 0.07751387f, -0.06152732f, 0.00038315f, 
    -0.02750820f, -0.05594414f, 0.05753326f, -0.11123728f, -0.03201349f, 0.20280103f, 0.07026445f, -0.09748790f, 
    0.08099715f, 0.00254653f, -0.03366227f, 0.02349014f, -0.08685292f, -0.13266888f, -0.07732502f, -0.12461700f, 
    -0.19741921f, -0.26526895f, -0.04793150f, 0.10365032f, 0.04456203f, 0.08459182f, 0.11263753f, 0.25002524f, 
    -0.02749863f, 0.06568222f, 0.00653900f, 0.17559911f, -0.16612431f, 0.05523525f, 0.24144104f, -0.03586574f, 
    0.17539790f, 0.05916226f, 0.21382247f, 0.04035810f, -0.07373232f, -0.12472283f, -0.20503986f, -0.07473182f, 
    -0.10467116f, 0.11351288f, 0.00916180f, -0.11615387f, 0.07782548f, -0.12392483f, 0.00438368f, 0.06798675f, 
    -0.17252766f, -0.19430543f, -0.18840997f, -0.39535856f, 0.20445751f, 0.22583742f, -0.07008186f, 0.05374253f, 
    -0.00101985f, -0.04886965f, -0.03905221f, 0.17339562f, 0.11571798f, 0.10911102f, -0.04161857f, 0.10086504f, 
    -0.19770658f, -0.04561659f, 0.21510613f, 0.01044684f, -0.04226286f, -0.02985860f, -0.07637119f, 0.01669507f, 
    -0.22987151f, -0.17996173f, -0.18149778f, -0.15505877f, -0.05634591f, -0.06365554f, 0.09001006f, 0.02095551f, 
    0.04231271f, 0.25033519f, -0.14590353f, 0.01669740f, 0.17364216f, -0.05291108f, -0.15940188f, 0.11512471f, 
    0.02614863f, -0.32618460f, 0.06869357f, 0.25524157f, -0.02227830f, -0.12307987f, -0.17088579f, -0.09350096f, 
    0.15101980f, 0.05630272f, -0.05147840f, -0.02716795f, 0.02112161f, 0.05450660f, 0.04128619f, -0.25699237f, 
    -0.08289057f, -0.04517072f, 0.03998510f, 0.10270089f, 0.23388276f, 0.23422655f, 0.05253147f, 0.08441666f, 
    0.09901273f, 0.04663122f, 0.16591628f, -0.05758699f, 0.17642175f, -0.02916252f, -0.08452566f, 0.06102656f, 
    0.03616457f, -0.06997561f, -0.03658408f, -0.03272137f, -0.00648913f, 0.14227542f, 0.29505652f, 0.33068830f, 
    -0.10713753f, -0.09368446f, -0.11093981f, 0.07432996f, -0.04088502f, 0.03454694f, 0.01284019f, -0.00827936f, 
    -0.02459474f, -0.02391312f, 0.04055041f, 0.16336566f, -0.01296680f, 0.08400141f, -0.12735800f, 0.17027672f, 
    -0.02766365f, 0.14792536f, -0.00583507f, 0.13348778f, -0.14941517f, 0.01640883f, -0.04184017f, 0.05786568f, 
    0.06728218f, -0.15544800f, 0.06869823f, -0.00946486f, 0.25952744f, 0.21802357f, 0.21016467f, 0.27776256f, 
    -0.08262315f, -0.06851925f, 0.03845714f, 0.02155175f, 0.01453232f, -0.06836900f, 0.04807308f, 0.01665632f, 
    0.01007480f, 0.04359453f, 0.02939708f, 0.04510774f, -0.01441619f, -0.06492238f, -0.00034600f, -0.08388327f, 
    0.00207428f, 0.05892592f, -0.04216671f, -0.05612451f, -0.03863844f, 0.03498601f, 0.01011210f, -0.00636888f, 
    0.05760465f, -0.03252986f, 0.01914002f, -0.05207558f, -0.05335646f, 0.04816120f, 0.03000944f, -0.01478944f, 
    -0.03879965f, -0.04300411f, -0.00105447f, -0.02215831f, -0.03837952f, -0.04421277f, 0.01815720f, -0.04105435f, 
    0.01311392f, 0.05110164f, -0.00199585f, -0.00681570f, 0.03631618f, -0.07826222f, -0.09567055f, 0.01099916f, 
    -0.06610277f, -0.04453702f, 0.02552286f, -0.01835374f, -0.06707156f, -0.03107798f, 0.05643482f, -0.03514881f, 
    -0.08681064f, 0.03951015f, -0.00778664f, 0.04493282f, 0.07916745f, -0.02788126f, 0.00035737f, 0.04126190f, 
    0.01435096f, -0.06298834f, -0.04797399f, -0.06070340f, -0.00027519f, -0.06310781f, 0.01239120f, 0.04137609f, 
    -0.06811981f, -0.06844185f, -0.04455898f, -0.00069696f, 0.04598796f, -0.03609333f, 0.04387742f, 0.05605521f, 
    0.01344986f, -0.03958649f, -0.06877194f, -0.05143642f, 0.06809566f, 0.07165909f, -0.08061219f, 0.01626562f, 
    -0.00644058f, -0.08335441f, -0.07443051f, -0.04426795f, -0.03503527f, 0.00381761f, 0.04842792f, -0.04636375f, 
    0.05622125f, -0.01621362f, -0.06326190f, -0.05454744f, 0.05091802f, 0.03916057f, -0.03094825f, 0.03349978f, 
    -0.06381612f, -0.04430646f, -0.02194056f, -0.06883906f, 0.05198982f, 0.01227228f, -0.07535106f, 0.04281929f, 
    -0.05947130f, 0.04498275f, 0.06148977f, -0.06982244f, -0.07609348f, 0.03697199f, -0.06677661f, 0.03145983f, 
    -0.05071991f, 0.06714611f, -0.03594849f, -0.01913624f, 0.03805087f, 0.00419528f, 0.00422726f, -0.04163766f, 
    -0.02243720f, 0.03558218f, 0.01180288f, -0.06234488f, -0.04389697f, 0.02140174f, -0.03828436f, -0.04701174f, 
    0.01405474f, -0.05289989f, -0.01461696f, 0.01029482f, -0.02231059f, -0.07283615f, -0.06177174f, -0.04643782f, 
    0.01365709f, -0.08913907f, -0.04334409f, -0.05116471f, -0.01398179f, 0.01868303f, -0.02242679f, -0.00129058f, 
    -0.02209761f, -0.03210827f, -0.06552607f, -0.07134975f, 0.05194117f, -0.07408684f, -0.04013569f, -0.05303187f, 
    -0.04771873f, -0.03233542f, -0.00959164f, -0.03810964f, -0.07320542f, 0.06674130f, -0.02596079f, 0.04272564f, 
    -0.01078399f, 0.01847556f, 0.00905549f, -0.07540400f, 0.07036130f, 0.03007601f, -0.01530774f, 0.02272260f, 
    -0.06943567f, 0.03237708f, -0.06063733f, -0.04668380f, -0.05737850f, 0.01940679f, 0.03602270f, 0.02602720f, 
    0.04462333f, -0.02591499f, 0.06124373f, -0.05385845f, 0.00643639f, -0.05346078f, -0.01951281f, -0.06096945f, 
    -0.01595667f, 0.03435670f, -0.04610066f, -0.06097571f, -0.03592072f, 0.04891346f, -0.00504916f, -0.04234672f, 
    -0.07654749f, 0.04623951f, 0.05976090f, 0.00634233f, -0.05060657f, 0.00037083f, -0.05238062f, -0.01828410f, 
    -0.06835209f, -0.00100098f, 0.02705281f, -0.01543047f, 0.01147756f, -0.07549657f, 0.06540201f, -0.05989370f, 
    -0.01450139f, 0.03055721f, -0.02943921f, -0.03491060f, 0.06502985f, 0.04573338f, 0.03107028f, -0.04749684f, 
    -0.03818806f, -0.04616997f, 0.00327332f, -0.02349706f, -0.02940715f, 0.00336882f, 0.04464510f, -0.07125711f, 
    -0.04591078f, 0.06542836f, 0.06103560f, -0.00524839f, -0.04854862f, -0.01626608f, -0.05842986f, 0.04072378f, 
    -0.06803648f, 0.00923346f, 0.05917090f, -0.05724829f, -0.06590778f, 0.03613931f, -0.04235786f, -0.05678734f, 
    -0.07594734f, -0.02584850f, 0.02106576f, 0.06177323f, -0.02949406f, -0.05839688f, -0.06238497f, 0.02041434f, 
    -0.06662244f, 0.04669303f, -0.05372942f, -0.01965646f, 0.04095802f, -0.07130087f, 0.04058227f, -0.05589201f, 
    -0.05474076f, -0.02490368f, -0.05855972f, 0.02513423f, 0.05622489f, -0.04367144f, -0.03512861f, -0.07214981f, 
    0.01685607f, -0.01740336f, -0.03017686f, 0.00436771f, -0.06431460f, 0.03674892f, 0.02467456f, -0.02543321f, 
    0.05073734f, -0.04503502f, 0.01438218f, 0.05487438f, -0.04834791f, -0.04715005f, -0.00183901f, 0.03117388f, 
    -0.02371015f, -0.02781143f, 0.03831972f, 0.05183921f, 0.04700276f, 0.00493507f, 0.00082267f, -0.04312365f, 
    -0.02147277f, -0.03021051f, -0.06671869f, 0.06022134f, -0.05663368f, -0.04509175f, -0.05329610f, -0.02895178f, 
    -0.01194553f, -0.01978289f, 0.04622164f, 0.02591669f, -0.02420405f, -0.07203627f, 0.03501608f, 0.01083746f, 
    -0.03019316f, -0.04468765f, 0.03171839f, 0.01539939f, -0.05273221f, -0.04509454f, 0.03915107f, -0.06993802f, 
    0.04846426f, 0.04596603f, -0.06617063f, 0.04351098f, 0.02303862f, -0.07804277f, -0.05977501f, 0.05699508f, 
    0.04841372f, -0.03278425f, 0.06162592f, 0.01817155f, -0.03421285f, 0.01542474f, -0.05826049f, -0.02478059f, 
    0.03782518f, 0.06415004f, 0.03010982f, 0.02130703f, 0.04321162f, 0.02794252f, -0.03865059f, 0.01307657f, 
    0.01851021f, 0.04231865f, -0.00029576f, -0.07765462f, 0.02730855f, -0.03083786f, 0.06324598f, -0.06112739f, 
    0.04325959f, 0.04261295f, -0.02653039f, -0.02780237f, -0.03061987f, -0.07230359f, -0.01987948f, -0.05763154f, 
    0.01946268f, -0.06092258f, -0.03468554f, -0.04867529f, -0.07644194f, 0.06531560f, -0.04603013f, 0.02388452f, 
    -0.04848845f, 0.02205935f, 0.01748385f, 0.01391424f, -0.06553090f, 0.01242199f, 0.02008990f, -0.04854148f, 
    0.03498250f, 0.00125035f, 0.01666497f, -0.03839293f, -0.02977662f, -0.06212607f, -0.03747818f, -0.06352039f, 
    -0.06010011f, -0.06802403f, -0.07367170f, -0.05053669f, -0.05346304f, -0.03381465f, 0.04340707f, -0.07645954f, 
    0.04892464f, 0.04979066f, 0.00117563f, -0.04784216f, -0.08072516f, 0.00052294f, -0.06946158f, 0.02252975f, 
    0.02602469f, -0.05569797f, -0.06894402f, -0.03139413f, -0.02493972f, -0.07068910f, -0.06489847f, -0.02750658f, 
    0.00275852f, 0.04985573f, 0.05657597f, -0.02182680f, -0.06506863f, 0.06063251f, 0.02935534f, 0.00153180f, 
    0.05416909f, 0.04219829f, -0.05250309f, 0.04488745f, 0.05259329f, -0.05510360f, -0.03263405f, -0.04915674f, 
    0.01856698f, -0.01668330f, -0.05412110f, 0.03186637f, -0.03863406f, -0.03354446f, -0.07148442f, 0.01111183f, 
    0.03659604f, -0.02782991f, -0.07653110f, 0.06284548f, 0.01150988f, 0.00842417f, 0.06251480f, -0.03204317f, 
    0.00022574f, 0.03000733f, -0.00080825f, -0.00212924f, 0.00629074f, 0.00943450f, -0.00144381f, 0.06234295f, 
    -0.07407834f, 0.04903954f, 0.04261758f, 0.02449720f, -0.04986028f, 0.02069912f, 0.06586882f, -0.03804774f, 
    0.02086956f, -0.03506682f, -0.07453470f, 0.05913125f, 0.04979000f, 0.02422714f, -0.02547655f, -0.05870306f, 
    -0.05030027f, -0.06585125f, 0.03610523f, 0.01696961f, 0.01271898f, -0.01550240f, 0.05403472f, -0.01614937f, 
    -0.03940064f, 0.01536178f, -0.03623250f, 0.04494651f, -0.00105773f, -0.03887208f, 0.04433635f, 0.00881422f, 
    0.03426047f, -0.01177172f, 0.01279718f, 0.01880108f, -0.05200417f, 0.03795584f, -0.01096519f, -0.01088570f, 
    -0.01047359f, -0.02249037f, -0.01595238f, 0.00981781f, -0.04993730f, -0.00731403f, 0.01504350f, 0.00653906f, 
    -0.06244159f, 0.04150983f, -0.06038620f, -0.01249350f, -0.07753935f, -0.04754201f, 0.05665492f, 0.06385559f, 
    -0.04140278f, -0.00455171f, -0.06031452f, 0.02427960f, -0.02153474f, 0.03377745f, -0.02055872f, -0.05192430f, 
    -0.03738065f, 0.05711339f, 0.01466122f, 0.03154547f, -0.00063876f, 0.05330809f, -0.07352180f, 0.03446085f, 
    0.05300691f, 0.06453027f, 0.02025673f, 0.01912939f, 0.05861806f, 0.03313480f, 0.01349237f, -0.02860029f, 
    0.03561264f, -0.00903438f, 0.03185531f, -0.06075853f, -0.07728357f, 0.04426095f, 0.03222898f, -0.03698813f, 
    -0.01382217f, -0.04251796f, -0.02111316f, 0.00585032f, -0.02796374f, 0.00125443f, -0.00771596f, 0.05189239f, 
    0.03152524f, -0.03868704f, -0.07775008f, -0.06642607f, 0.04832489f, -0.03137701f, -0.03073686f, -0.06847260f, 
    -0.04168198f, -0.03273562f, 0.01514551f, 0.01570072f, -0.03674123f, 0.05594567f, 0.03291387f, -0.01796529f, 
    -0.04824003f, -0.00987506f, -0.01407361f, 0.02058368f, -0.05765928f, 0.04913755f, -0.07472213f, 0.02363228f, 
    -0.02505699f, -0.07053884f, -0.00753423f, 0.04010416f, -0.04800148f, 0.01140460f, -0.00006350f, 0.00312218f, 
    0.15435019f, 0.06464324f, -0.02135134f, 0.00526824f, 0.00033443f, -0.18093777f, -0.05053326f, -0.11515580f, 
    -0.06534049f, -0.01779496f, 0.18567199f, 0.06749313f, 0.13523167f, 0.21299241f, 0.25688383f, 0.11324858f, 
    -0.10144706f, -0.05206650f, 0.01470881f, -0.00366035f, 0.04431606f, -0.04968781f, -0.05366549f, 0.05086458f, 
    0.28933844f, -0.24676494f, -0.09986169f, 0.13328142f, -0.00235511f, 0.10518362f, 0.05354672f, -0.00328319f, 
    -0.01302825f, 0.00399746f, -0.04821136f, -0.00478436f, -0.07443900f, -0.21681118f, 0.06982924f, 0.04392354f, 
    0.03153843f, 0.07131495f, -0.00257285f, 0.08301134f, 0.01608713f, 0.03658941f, 0.00418190f, 0.05511376f, 
    -0.05668738f, 0.03260591f, 0.16653174f, 0.04571850f, -0.05756402f, 0.02020946f, 0.00773022f, -0.02731407f, 
    0.02317954f, 0.10856137f, 0.03336843f, -0.02672855f, 0.32968888f, 0.01418783f, 0.01516580f, -0.02417692f, 
    -0.02787369f, 0.13156508f, 0.08919980f, 0.18975879f, 0.03608975f, -0.07430057f, -0.09277215f, 0.01823850f, 
    0.03362959f, -0.21536340f, -0.05109891f, -0.03764808f, 0.09615024f, 0.14293672f, 0.06131516f, 0.00044890f, 
    -0.07119697f, 0.09524851f, -0.02353745f, 0.01791692f, -0.34716901f, -0.41511714f, 0.42526886f, 0.19049825f, 
    0.11546060f, 0.02379216f, -0.00451836f, 0.09286471f, 0.03506420f, 0.05349101f, 0.12593716f, 0.10716140f, 
    0.15777051f, 0.18306077f, 0.23120156f, 0.00117990f, -0.13208926f, 0.01327683f, 0.02005537f, 0.06264727f, 
    -0.06069998f, -0.13360518f, 0.08219359f, -0.20903882f, -0.28361875f, 0.02810901f, -0.24312459f, 0.21670829f, 
    0.00595664f, -0.07795630f, 0.11936904f, 0.01795745f, 0.02608031f, 0.07499981f, -0.07286188f, -0.10782560f, 
    -0.02179182f, 0.18497089f, 0.20655334f, 0.27243847f, -0.03830333f, -0.02602004f, -0.04058763f, -0.08589984f, 
    0.16006848f, 0.13997690f, 0.03883578f, 0.04281721f, 0.05271562f, -0.04923698f, -0.18157375f, 0.17604014f, 
    -0.06396884f, 0.04882091f, -0.00778225f, 0.00455109f, 0.05587209f, -0.18787336f, 0.01098752f, 0.01129307f, 
    -0.20109253f, 0.28413174f, -0.29891610f, 0.01047258f, 0.11067634f, -0.00902360f, -0.01305602f, -0.07424013f, 
    -0.09413884f, 0.05831113f, -0.05852674f, 0.13606310f, 0.18923384f, 0.12122300f, -0.01861964f, 0.07766148f, 
    0.08027103f, 0.19969054f, 0.08251889f, 0.18855083f, 0.02394845f, 0.13840774f, -0.00284031f, -0.03346209f, 
    -0.18223017f, -0.12155253f, 0.00616926f, 0.30219951f, 0.08470949f, -0.05763745f, 0.17384581f, -0.09855500f, 
    -0.06394365f, -0.03342698f, 0.03877543f, 0.01211660f, 0.11113405f, 0.05711299f, -0.06424368f, 0.10634856f, 
    0.12776461f, -0.01145158f, -0.07513747f, -0.00868423f, -0.05222017f, 0.14640258f, -0.03992468f, 0.05612132f, 
    -0.06784374f, -0.05139857f, 0.00004450f, -0.01636211f, -0.06585989f, -0.05379997f, 0.00225992f, 0.03046635f, 
    -0.00144085f, -0.03792393f, -0.01014559f, -0.07201023f, -0.00231604f, -0.06193901f, -0.03859500f, 0.05555237f, 
    -0.04388267f, -0.02452444f, 0.01113780f, -0.07085721f, 0.01878372f, 0.00582445f, 0.02486767f, -0.03011555f, 
    -0.02331826f, -0.01189868f, -0.05394639f, 0.00973244f, -0.04988632f, -0.04785261f, 0.04408008f, -0.01904974f, 
    -0.06675071f, -0.03700202f, 0.00744042f, 0.00916523f, -0.07150073f, -0.02511351f, -0.05371802f, 0.06086991f, 
    0.01112990f, -0.03454170f, -0.02017108f, -0.00981795f, -0.00437743f, -0.01738949f, 0.01547157f, -0.05647954f, 
    0.06579084f, 0.00661765f, 0.04324574f, 0.03210081f, 0.05409708f, -0.02738055f, 0.02264880f, 0.01223016f, 
    0.05636896f, -0.07088810f, 0.02391194f, -0.05219712f, -0.01337389f, -0.02471845f, 0.00562621f, 0.00898311f, 
    0.00212226f, -0.00865431f, -0.00514841f, -0.03734389f, -0.01077503f, 0.05573002f, -0.03422989f, -0.01464963f, 
    0.00452720f, -0.02913540f, 0.04377821f, -0.01089299f, 0.01566854f, -0.04547553f, 0.02462197f, -0.04418339f, 
    -0.04251002f, 0.02830598f, 0.04944159f, 0.04506981f, -0.01870945f, -0.05821665f, -0.03013465f, 0.06031016f, 
    0.02770938f, 0.04853150f, 0.04890060f, -0.06960535f, -0.06752869f, 0.03129163f, 0.06067006f, 0.04076901f, 
    -0.02753870f, 0.05441028f, -0.07490222f, -0.06951481f, -0.03489802f, -0.05386867f, -0.00954787f, -0.03771475f, 
    -0.06070966f, -0.02759326f, 0.04437688f, 0.04951061f, 0.03223092f, 0.04625811f, 0.02726308f, 0.01116427f, 
    0.00733223f, -0.01156196f, 0.02262609f, -0.02700947f, 0.01299862f, 0.01638773f, 0.00103991f, 0.01874604f, 
    0.00586161f, 0.05795408f, 0.01746706f, 0.03626280f, 0.05150235f, 0.01905453f, 0.00444512f, -0.06480024f, 
    -0.00591634f, 0.03372320f, -0.00821874f, 0.00117308f, -0.03788370f, 0.02856958f, 0.02716791f, 0.02112582f, 
    -0.06234730f, 0.04152785f, -0.05619514f, -0.05127871f, -0.05281183f, -0.03299346f, -0.01946774f, -0.01974098f, 
    -0.00073367f, -0.00419575f, 0.02414738f, -0.03069688f, -0.01824461f, -0.07162292f, 0.04634501f, -0.01519287f, 
    0.06269430f, -0.07716549f, 0.01774989f, -0.01002807f, -0.04333803f, -0.00635453f, -0.03716481f, 0.05022071f, 
    -0.07535633f, 0.00224018f, -0.07132033f, 0.04707998f, 0.00778687f, -0.07871000f, 0.00337617f, -0.00837017f, 
    -0.02551568f, -0.06447724f, -0.03546013f, -0.03017230f, 0.01708500f, -0.03443894f, 0.04061186f, -0.03253074f, 
    -0.04924484f, -0.06285056f, 0.04008720f, 0.05578969f, 0.02971300f, -0.06089557f, -0.01349340f, -0.05235519f, 
    0.03560769f, 0.03280890f, -0.02799827f, -0.05187049f, -0.03451867f, 0.00867320f, -0.01300609f, -0.05899766f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.11038364f, -0.00170455f, -0.16841108f, 0.14680059f, 0.30505645f, 0.00756358f, 0.04449197f, 0.03454628f, 
    -0.02727785f, -0.02082716f, -0.14668046f, -0.09421334f, 0.12485580f, 0.01251261f, 0.22675653f, -0.05061838f, 
    -0.01948667f, 0.13748553f, -0.04459102f, 0.17694379f, -0.03549902f, -0.05476264f, 0.01334849f, 0.06922095f, 
    0.06557894f, 0.06683451f, 0.23704639f, -0.09479514f, 0.09637962f, 0.01305734f, 0.16725387f, 0.01983164f, 
    -0.03170656f, 0.11994727f, 0.04648853f, 0.00234334f, 0.14552179f, 0.10042951f, 0.20524985f, -0.05981873f, 
    0.02260588f, 0.06160871f, -0.05778860f, 0.02447307f, -0.04491426f, 0.01880913f, 0.20542467f, 0.05380747f, 
    -0.03473998f, 0.02662420f, 0.00922545f, -0.04124419f, 0.24179964f, 0.10844665f, -0.01753407f, -0.12031443f, 
    -0.12294313f, 0.22369860f, 0.01364319f, -0.04685101f, -0.00751183f, 0.00192139f, 0.12659632f, 0.04235136f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.05818782f, 0.04775901f, -0.19382793f, 0.17428122f, 0.17991441f, -0.03084766f, -0.00985379f, -0.04974010f, 
    -0.04323500f, 0.10908611f, -0.26564541f, -0.11122108f, 0.35525739f, -0.04045999f, 0.04238898f, 0.08210385f, 
    -0.10145745f, 0.05425149f, -0.12744866f, 0.25759098f, 0.04453621f, -0.00281180f, -0.06515635f, 0.13558470f, 
    0.21785256f, -0.33941069f, 0.10704447f, -0.05040222f, 0.31776571f, 0.12320881f, -0.15613151f, -0.08352303f, 
    0.08743865f, 0.07104915f, -0.24211870f, -0.40509009f, -0.03139567f, 0.07994803f, -0.13585187f, 0.17488164f, 
    -0.05031662f, -0.22648764f, 0.04944811f, 0.08509226f, -0.02220240f, 0.24333674f, 0.24507412f, 0.06209180f, 
    -0.00373965f, 0.12260763f, 0.10577409f, 0.04847138f, -0.04426406f, 0.17251793f, -0.14514717f, -0.15306911f, 
    -0.15504853f, 0.14528613f, -0.02807125f, 0.02932776f, -0.02932884f, 0.01365794f, -0.16285402f, -0.08298756f, 
    0.17184871f, -0.24437360f, -0.11107294f, 0.20454186f, -0.01228487f, 0.15762280f, 0.09847419f, -0.16196761f, 
    -0.01921664f, 0.10281353f, 0.05376655f, -0.20208313f, 0.04127577f, 0.03754456f, -0.08217678f, 0.03540796f, 
    0.05560625f, -0.08458961f, -0.07884404f, 0.04975727f, 0.11550960f, -0.00307828f, 0.00994558f, -0.01336537f, 
    -0.06832533f, -0.06160339f, -0.33930245f, -0.19739331f, 0.13363531f, -0.11617233f, -0.17346224f, 0.12098322f, 
    -0.02165253f, -0.03858960f, -0.07910513f, 0.08265302f, 0.03102390f, 0.16106932f, -0.00647046f, -0.05114489f, 
    0.18341516f, -0.04069081f, 0.02862865f, -0.28577688f, -0.00761967f, -0.03909316f, 0.11037657f, -0.07557519f, 
    0.07133348f, 0.05055806f, -0.04983443f, -0.27837202f, -0.18560226f, 0.02058115f, -0.05965045f, -0.03122126f, 
    0.16468590f, 0.03828361f, 0.00526451f, 0.07347591f, -0.07348341f, 0.05537253f, 0.11888856f, -0.03592630f, 
    0.13040170f, 0.22289114f, 0.33862475f, -0.12641294f, 0.00800690f, 0.13794175f, -0.00105160f, 0.16088831f, 
    -0.06986400f, 0.08781563f, 0.12176061f, 0.04444158f, 0.12977315f, 0.12153638f, -0.44858798f, -0.01654975f, 
    0.12162572f, 0.09665539f, 0.04978080f, -0.02299090f, -0.05224076f, 0.03685107f, -0.08999028f, 0.06609456f, 
    -0.37447980f, -0.13812873f, -0.27369103f, 0.15259844f, -0.05883544f, -0.20169093f, -0.06273016f, 0.10651476f, 
    0.02600410f, 0.19213183f, 0.33459654f, 0.18987289f, -0.35973173f, 0.14416008f, -0.09228829f, 0.29921931f, 
    -0.01451005f, -0.16079912f, 0.00926968f, 0.19140071f, -0.06661612f, 0.18358637f, -0.03914603f, 0.16157350f, 
    -0.11805226f, 0.04209024f, -0.02589697f, -0.06052037f, -0.51241565f, 0.26331085f, 0.11477462f, 0.09752892f, 
    0.27497810f, 0.00358072f, -0.05064967f, 0.08010844f, -0.02696846f, -0.01933551f, -0.04635717f, 0.03869294f, 
    0.05646889f, -0.26178998f, -0.08366930f, 0.03492402f, 0.02442973f, 0.13727073f, 0.10160848f, -0.01757958f, 
    -0.10295093f, -0.10370298f, -0.09804244f, -0.09771960f, -0.04819248f, -0.05165157f, -0.05583009f, -0.05796434f, 
    0.04037184f, 0.09942529f, -0.08525532f, -0.04157538f, 0.05357109f, 0.00677036f, 0.01804921f, -0.13563080f, 
    -0.12045220f, 0.05076702f, 0.00756088f, -0.05764902f, 0.14071357f, -0.16514744f, -0.14190535f, 0.08263923f, 
    -0.08581679f, 0.13850474f, 0.06801973f, -0.04751464f, 0.05257022f, -0.18810216f, 0.05340705f, 0.05530496f, 
    0.06057166f, -0.01301026f, 0.04240669f, -0.21006368f, 0.00348487f, -0.12147071f, -0.16267885f, -0.17828572f, 
    -0.09710744f, -0.03572655f, -0.09214532f, -0.06983670f, -0.21863849f, 0.13728864f, 0.07106458f, 0.04553285f, 
    0.03170067f, -0.07734276f, -0.08128154f, -0.09518877f, 0.04246680f, 0.04142280f, -0.09273890f, 0.03806938f, 
    -0.09340692f, 0.20035405f, -0.13587147f, 0.06004160f, -0.20417179f, -0.11314203f, -0.03702234f, -0.29998097f, 
    0.11402927f, 0.01221235f, 0.00642283f, -0.18088701f, 0.25846091f, 0.02297977f, 0.06074174f, 0.05623952f, 
    0.00054599f, -0.33438221f, 0.07801636f, -0.36038974f, -0.04839803f, 0.10184693f, -0.07351085f, -0.06625494f, 
    0.08088939f, -0.21851628f, -0.10452145f, -0.19863130f, -0.13780181f, -0.18339425f, -0.00862538f, -0.07572518f, 
    0.01723019f, 0.02885058f, 0.20288424f, 0.02182776f, -0.10190129f, 0.25130576f, -0.30051661f, 0.14699468f, 
    -0.15862131f, 0.06900641f, -0.04412757f, 0.27048954f, -0.07945119f, 0.00328884f, -0.26743126f, -0.01352589f, 
    -0.05889942f, -0.05514844f, -0.09999964f, -0.16858701f, 0.13363753f, -0.30349931f, 0.02846314f, -0.15200320f, 
    -0.39206725f, -0.23052129f, -0.10099524f, 0.10949690f, -0.09974818f, 0.03922981f, 0.12486150f, 0.05209675f, 
    0.11374182f, 0.30921298f, 0.22517903f, -0.02688605f, 0.26890779f, 0.01659058f, -0.08419496f, -0.09716979f, 
    -0.04147753f, 0.00562948f, 0.05484074f, -0.24703841f, 0.06640371f, 0.04263562f, 0.18012230f, 0.06333470f, 
    0.02421733f, 0.17400631f, -0.05622499f, 0.34877637f, -0.00887045f, 0.04501329f, 0.04541373f, 0.26610965f, 
    0.02916045f, -0.12752956f, 0.25443190f, -0.00757122f, 0.25981832f, -0.07311070f, -0.04830429f, -0.11064228f, 
    0.03528548f, -0.02326351f, -0.16236074f, 0.16478100f, 0.16318531f, -0.06634197f, 0.01845676f, -0.23935013f, 
    -0.01686963f, -0.28838560f, -0.07729765f, -0.01256974f, -0.10538866f, -0.00564493f, -0.02264749f, 0.15786079f, 
    0.07792167f, 0.08074035f, -0.19439755f, 0.20937277f, 0.31101564f, 0.04232066f, 0.22789057f, 0.15372506f, 
    -0.00353315f, 0.07760386f, -0.22243527f, -0.05931110f, -0.04754454f, -0.06611540f, 0.04186920f, -0.06939912f, 
    0.03204422f, -0.14911981f, 0.06500778f, 0.33795378f, 0.18421872f, -0.09599777f, -0.01133107f, -0.12479751f, 
    -0.02972017f, -0.01994077f, -0.29785389f, 0.18011013f, 0.29719350f, 0.10841116f, -0.07709868f, 0.08996976f, 
    0.06206894f, 0.20881297f, -0.12096472f, 0.01814918f, -0.09630844f, -0.03041184f, 0.00325323f, -0.03740662f, 
    0.00647786f, -0.04658823f, 0.18017587f, 0.09624957f, 0.05648685f, 0.10554491f, -0.11567017f, -0.01412270f, 
    -0.07186048f, 0.15534911f, -0.19710182f, -0.01548548f, 0.07040355f, -0.09679226f, 0.13115954f, -0.05792108f, 
    -0.42776194f, -0.00518506f, -0.01650781f, 0.14434291f, 0.04373884f, 0.21625884f, 0.28469071f, 0.02614440f, 
    0.12355924f, 0.13780463f, 0.03147806f, -0.07904469f, -0.20685670f, 0.25898850f, -0.17349090f, 0.20662582f, 
    -0.16163255f, 0.05128485f, 0.44169185f, 0.13049790f, -0.05552855f, -0.07460874f, -0.01431135f, 0.02660311f, 
    -0.05879773f, -0.03896739f, 0.24018890f, 0.12611249f, -0.11655300f, -0.08785997f, 0.07227132f, -0.10030103f, 
    0.07054393f, -0.07924815f, -0.12082940f, 0.47092167f, 0.26239717f, -0.04460368f, 0.13867059f, -0.03501947f, 
    0.05988239f, 0.16634870f, -0.10820169f, -0.09718108f, -0.11704728f, -0.09012263f, 0.11659218f, -0.28964451f, 
    -0.30705956f, -0.03302253f, -0.10104425f, 0.10938556f, -0.17893970f, 0.16000743f, 0.06356588f, -0.10472225f, 
    -0.09539191f, -0.01149709f, -0.04912631f, 0.09507772f, -0.35190582f, 0.04972169f, 0.05937029f, 0.21605192f, 
    -0.31428024f, 0.16452469f, -0.11628433f, 0.22516541f, -0.00378289f, -0.10214521f, -0.06325608f, -0.12896544f, 
    -0.08911432f, -0.01788684f, 0.27181226f, 0.16561572f, -0.31093556f, 0.21845183f, -0.14853975f, 0.33574390f, 
    0.14657682f, -0.05389646f, 0.44692874f, -0.02345473f, -0.07405160f, -0.02647346f, 0.03846472f, 0.05618955f, 
    -0.12968306f, -0.04433702f, -0.08276813f, -0.05873541f, -0.10802834f, 0.02226682f, -0.04670675f, 0.20365441f, 
    -0.03819759f, 0.10485647f, 0.10497754f, -0.17137034f, -0.12826985f, 0.03435126f, 0.13729165f, 0.06539008f, 
    0.05578010f, -0.14491534f, -0.00372868f, -0.25651485f, -0.06355181f, -0.11904824f, 0.12388465f, 0.00097296f, 
    0.19045912f, -0.16398534f, 0.32660672f, -0.26172790f, -0.01360234f, 0.08025733f, -0.35838887f, -0.10440911f, 
    0.11453092f, -0.10483130f, -0.16723032f, -0.17099594f, 0.12412176f, -0.28510743f, 0.02063841f, 0.02454885f, 
    -0.11663967f, 0.00553516f, 0.11525905f, -0.29451084f, 0.09532449f, -0.19681920f, -0.01048141f, -0.08912283f, 
    0.03384209f, 0.09687827f, -0.13579111f, -0.16793740f, 0.23148264f, -0.32190561f, 0.05090623f, -0.13640171f, 
    -0.05180653f, -0.04534787f, -0.13212806f, -0.09131458f, -0.07722025f, 0.05612415f, 0.15691106f, 0.12352258f, 
    0.24958794f, 0.35700306f, 0.07252768f, -0.35739535f, -0.13771810f, 0.20994498f, -0.02010599f, -0.05335844f, 
    -0.09240859f, -0.00862517f, 0.23647618f, -0.07838845f, -0.01642868f, 0.06028450f, -0.16953112f, -0.08870827f, 
    0.10568934f, 0.10686543f, -0.07131743f, 0.02215587f, -0.06266585f, 0.00705372f, 0.07031311f, 0.38329929f, 
    -0.14082232f, -0.21516159f, -0.00276806f, -0.12173706f, -0.14761217f, -0.35806733f, 0.06912176f, -0.09483406f, 
    0.02650496f, 0.04971124f, 0.18959855f, 0.32320765f, -0.19447964f, 0.00279235f, 0.00883784f, 0.18378945f, 
    0.30210763f, -0.03096834f, 0.07221010f, 0.12143622f, -0.05279274f, 0.19028495f, -0.11437194f, 0.06438342f, 
    0.06979204f, 0.03067152f, 0.05582086f, 0.11545471f, -0.02993700f, 0.02859906f, 0.32604894f, -0.05350500f, 
    0.14344935f, 0.10106940f, -0.01199203f, -0.07165933f, -0.05250651f, 0.07152751f, -0.20111920f, 0.08311380f, 
    -0.09581695f, -0.55943143f, 0.03691063f, -0.07460736f, -0.16321652f, -0.11486363f, 0.02962886f, -0.03222311f, 
    0.01300956f, 0.00494419f, 0.35589027f, -0.17612733f, -0.12639587f, 0.06566209f, 0.03383966f, -0.07662237f, 
    -0.06448896f, 0.02936292f, -0.06022999f, -0.04671510f, 0.02549377f, -0.12293115f, -0.04373273f, -0.01712181f, 
    0.11749836f, 0.15269871f, -0.19630682f, -0.02587526f, -0.11758661f, -0.37841034f, -0.13092965f, 0.02758480f, 
    0.14982851f, 0.06895834f, 0.12972675f, -0.10962586f, 0.13067791f, -0.08196219f, -0.14722459f, 0.15630375f, 
    0.03582924f, -0.01451079f, 0.06244425f, 0.07947245f, -0.03421333f, 0.10556314f, -0.39151254f, 0.25201574f, 
    0.06595653f, 0.03829915f, -0.38740608f, -0.05895879f, 0.23660444f, -0.23831806f, 0.13880648f, -0.13716753f, 
    -0.04793768f, -0.16665651f, -0.24709092f, -0.03743766f, 0.01895496f, -0.09888366f, 0.19412072f, 0.06617124f, 
    -0.13148350f, 0.00339162f, 0.02305766f, -0.00877749f, -0.02913526f, -0.06355710f, -0.05357037f, -0.13168749f, 
    0.05888841f, -0.00873879f, -0.08569106f, 0.05432896f, 0.04740676f, 0.10352370f, -0.09860317f, 0.09789504f, 
    0.06673270f, -0.00397877f, -0.09698083f, -0.09520668f, 0.00899912f, -0.07594654f, -0.09319513f, -0.03484428f, 
    0.02105326f, -0.18156333f, -0.05324501f, 0.06694460f, 0.00705216f, 0.01401260f, -0.00570749f, -0.12279865f, 
    -0.07549848f, -0.09883915f, -0.14448012f, -0.05351901f, -0.06185197f, -0.14667872f, -0.13009927f, -0.02945346f, 
    0.00531459f, -0.02226412f, -0.08701131f, -0.05853380f, 0.12224168f, -0.05918874f, -0.06410190f, -0.00347478f, 
    0.09399149f, -0.00426002f, 0.05241505f, 0.05663599f, -0.14624926f, 0.00157185f, -0.15744132f, -0.09846388f, 
    -0.04723629f, -0.08680835f, -0.11907248f, 0.04225102f, 0.09247714f, -0.06470941f, -0.03468736f, -0.06246150f, 
    -0.18751153f, -0.14437045f, -0.24242888f, 0.30152845f, -0.03776589f, -0.10319377f, 0.00388823f, 0.26099578f, 
    0.08563787f, -0.01041639f, -0.13347962f, -0.12007907f, 0.14536533f, 0.07685277f, 0.27756813f, 0.10346265f, 
    -0.02923746f, 0.14527455f, 0.03196929f, -0.08088383f, 0.04997136f, -0.05650012f, -0.11982036f, -0.04628558f, 
    -0.03303190f, 0.28459230f, 0.14012615f, 0.05858041f, 0.06777168f, 0.04925685f, 0.09671524f, -0.04523309f, 
    -0.06122588f, 0.01132888f, 0.29523027f, -0.03914396f, 0.30692270f, 0.18476140f, 0.15031388f, -0.04786433f, 
    -0.00200382f, 0.10728817f, 0.03827529f, -0.17251942f, 0.08778878f, -0.22000434f, 0.11001320f, -0.04155611f, 
    -0.11908876f, 0.03711589f, -0.08124073f, 0.18304451f, -0.24645349f, 0.18111148f, 0.02397102f, -0.26282614f, 
    0.02800897f, 0.16995192f, 0.08786204f, -0.10729419f, -0.00739139f, 0.09688254f, 0.25798509f, 0.12112337f, 
    0.27253443f, -0.03066564f, -0.50619018f, -0.02671987f, -0.04133508f, -0.10390101f, 0.04812255f, -0.01431071f, 
    0.10582259f, -0.10759253f, -0.51283926f, -0.01049146f, -0.00515156f, 0.06394975f, 0.24956317f, 0.03128250f, 
    0.11212789f, 0.26639813f, 0.05207352f, -0.08550432f, -0.05935273f, 0.02137109f, 0.08301790f, 0.30184633f, 
    -0.17032188f, -0.31367999f, 0.09681479f, -0.43062329f, -0.13257055f, -0.18466897f, 0.23012258f, 0.08494632f, 
    -0.10090104f, 0.17286454f, -0.18016787f, 0.31134617f, -0.09913560f, 0.01148075f, 0.11150123f, -0.15618068f, 
    -0.12486835f, 0.04448558f, 0.05077744f, 0.24092977f, 0.00042470f, -0.06967402f, -0.09570669f, -0.12558472f, 
    -0.03646403f, -0.00689937f, 0.13374287f, -0.02417753f, -0.04464861f, 0.23788448f, 0.14654364f, 0.02730244f, 
    -0.48280999f, 0.19168913f, 0.26982376f, -0.11061271f, -0.03996067f, 0.07615790f, -0.04722303f, 0.09325839f, 
    0.19463311f, -0.23009677f, -0.01528309f, 0.20802660f, 0.30516952f, -0.02083587f, 0.02408526f, -0.23904303f, 
    0.10550623f, 0.01321298f, 0.07370643f, 0.10080747f, -0.04648469f, 0.00320642f, -0.19147825f, -0.04383934f, 
    0.13032152f, 0.01678784f, -0.09606912f, 0.09151623f, -0.08259811f, 0.05832429f, 0.05375621f, -0.03332803f, 
    -0.02769580f, 0.10841389f, -0.15008512f, 0.29430246f, 0.06117011f, 0.00496692f, -0.22039677f, -0.09179191f, 
    -0.09665412f, -0.05776972f, -0.07734247f, 0.10261026f, 0.17062536f, -0.06949330f, 0.02630659f, -0.09583610f, 
    -0.34451845f, -0.13998470f, -0.10796820f, 0.00608192f, -0.09609477f, -0.07510446f, 0.33528247f, 0.15545361f, 
    0.04818219f, -0.03650808f, 0.04732143f, -0.02530149f, 0.37470505f, 0.22532481f, -0.14570378f, 0.07692217f, 
    -0.05471108f, -0.13529241f, 0.02732112f, -0.07519351f, -0.04713266f, 0.09920257f, 0.20034979f, -0.02619448f, 
    -0.25089762f, 0.37680626f, 0.05800356f, 0.20311540f, -0.17204121f, 0.15418351f, -0.11810519f, -0.00890506f, 
    -0.08460562f, -0.08146916f, -0.04072906f, -0.17395683f, -0.14393269f, -0.06999478f, 0.09250697f, -0.00893131f, 
    -0.05315062f, -0.11662008f, -0.04056251f, -0.08504896f, 0.11192518f, 0.00056467f, 0.06556549f, 0.00724080f, 
    0.02452968f, -0.11397615f, -0.01045666f, -0.09613814f, 0.05439529f, 0.27805978f, 0.05839338f, -0.03890445f, 
    0.03697984f, 0.02216261f, -0.21720903f, -0.29542586f, -0.05500435f, -0.18260385f, 0.20906347f, 0.09204033f, 
    0.06802959f, 0.09546110f, -0.09010503f, 0.02407876f, 0.08455856f, 0.30105171f, -0.10749081f, 0.03871730f, 
    -0.04918802f, 0.00079945f, 0.21625084f, 0.10977708f, 0.00965717f, 0.03445947f, -0.11330375f, -0.04673541f, 
    0.22264433f, 0.15114887f, -0.07386613f, -0.03289076f, -0.05455211f, 0.07018452f, 0.00327929f, -0.04497292f, 
    0.00048171f, -0.32638639f, 0.03954917f, 0.11074296f, -0.19517070f, -0.02289464f, 0.02763621f, 0.26595202f, 
    0.00358575f, 0.09887265f, -0.18686122f, 0.13872503f, 0.03909140f, -0.11093824f, -0.02160440f, -0.08770836f, 
    -0.00719303f, -0.10300531f, -0.11333622f, -0.16498172f, 0.01088451f, -0.08340042f, -0.06379921f, -0.18326388f, 
    0.12840365f, 0.16436753f, -0.09787627f, -0.17982568f, 0.21956824f, 0.08429650f, 0.17189521f, -0.09805395f, 
    -0.02057430f, 0.08368669f, 0.20282938f, -0.08072415f, 0.08082928f, 0.19810298f, -0.00116506f, 0.21706079f, 
    -0.34808668f, 0.20807773f, -0.00987524f, -0.12287167f, 0.01345275f, 0.04634426f, 0.03138726f, -0.36624920f, 
    -0.03642476f, 0.05105570f, 0.23085372f, -0.14958549f, -0.16252643f, -0.16611189f, -0.34816498f, -0.35844520f, 
    0.07526129f, 0.06967154f, 0.12573530f, -0.00639918f, -0.10459553f, -0.10981195f, 0.15477470f, 0.04221762f, 
    -0.01502138f, 0.02695400f, -0.07456250f, -0.11658426f, -0.06541577f, 0.08341552f, 0.02468691f, -0.27447557f, 
    -0.07744449f, -0.07390098f, -0.18374982f, 0.02340244f, -0.13130701f, -0.09523433f, -0.19931662f, 0.10598338f, 
    -0.08458769f, -0.10710519f, -0.12177826f, 0.03456401f, -0.07146105f, -0.05680522f, -0.11995869f, -0.11019813f, 
    0.03967396f, -0.08983788f, -0.12347283f, -0.13213210f, -0.18950389f, -0.05436799f, -0.12400916f, 0.05176526f, 
    -0.01451160f, -0.03734174f, -0.22301398f, -0.04974438f, 0.08333852f, 0.11141726f, -0.00223570f, 0.07324258f, 
    0.17518912f, -0.10706337f, -0.09809275f, 0.01355168f, 0.00364929f, -0.00760698f, 0.01313454f, -0.08095319f, 
    0.04778144f, -0.00839015f, 0.08078409f, -0.01708295f, -0.04950364f, -0.03984232f, -0.01252764f, -0.10814998f, 
    0.05480657f, -0.09969120f, -0.02473171f, -0.04487086f, -0.07588783f, 0.03934326f, 0.07287228f, 0.07034777f, 
    0.13810933f, -0.22490545f, -0.15488721f, -0.15825751f, 0.10378898f, 0.21848528f, -0.05254268f, 0.20524202f, 
    0.03233485f, 0.09673255f, 0.03940472f, -0.02720091f, -0.14058974f, 0.02101513f, -0.10577247f, -0.05003624f, 
    0.10065624f, -0.07137015f, -0.01937616f, 0.05173936f, 0.12880135f, 0.00404403f, 0.09373054f, 0.13708813f, 
    -0.11747228f, 0.39140460f, 0.04998109f, 0.06043872f, 0.05105064f, 0.15466665f, 0.10582405f, -0.08213061f, 
    -0.07185766f, -0.07255526f, 0.05665309f, 0.07546895f, -0.11269241f, 0.22891873f, -0.11428116f, 0.22203924f, 
    -0.00216932f, 0.34021938f, 0.06206748f, -0.02705917f, -0.11152261f, -0.00890864f, 0.07117813f, 0.03133265f, 
    -0.08170024f, 0.05454571f, -0.12323980f, 0.21835618f, 0.06523160f, -0.39683545f, -0.14110839f, -0.31318641f, 
    0.18034002f, 0.06517468f, -0.34931073f, -0.00988852f, 0.05651358f, 0.08271212f, 0.08077827f, -0.09347840f, 
    -0.22973025f, 0.02922802f, -0.11912502f, 0.21906671f, -0.11769801f, 0.01090579f, 0.01355420f, 0.00308001f, 
    -0.02994933f, 0.04486836f, 0.00516674f, -0.02261160f, 0.06639796f, 0.05466210f, 0.23334773f, -0.03243363f, 
    0.11316659f, 0.14189686f, -0.10882606f, 0.09177449f, -0.09707693f, 0.05552182f, -0.01507866f, -0.22255607f, 
    0.19333003f, 0.29917005f, 0.10803739f, -0.09182724f, -0.09071238f, 0.39966732f, 0.37487078f, 0.10230427f, 
    0.00306655f, -0.02943862f, -0.13059381f, 0.05842584f, -0.03641930f, 0.00107104f, 0.04019561f, -0.15109323f, 
    -0.21006212f, 0.27205580f, -0.11467675f, -0.09972188f, 0.06439823f, -0.26521352f, -0.19394332f, -0.00443259f, 
    0.07773919f, -0.05982154f, 0.13592397f, 0.32989421f, 0.28936994f, -0.22640845f, -0.08151086f, -0.19299145f, 
    -0.18068279f, 0.10985573f, 0.00862453f, -0.10097649f, -0.03526818f, -0.11065849f, 0.24789599f, -0.02143529f, 
    -0.01058405f, -0.60533226f, -0.14112577f, 0.00321292f, -0.09867886f, -0.08306059f, -0.08281038f, 0.07778607f, 
    -0.07024922f, 0.09203079f, 0.05599311f, 0.04835863f, 0.16660108f, -0.05376896f, -0.04662680f, 0.05576237f, 
    -0.04788024f, 0.06052833f, 0.08496456f, 0.15824018f, -0.05669848f, 0.05473128f, 0.04511001f, 0.04103627f, 
    -0.22404957f, 0.05144741f, 0.18040837f, 0.16503596f, -0.23818712f, 0.06777695f, -0.18811971f, -0.02176759f, 
    -0.01161444f, -0.27782446f, 0.07541589f, 0.09998045f, 0.09938361f, 0.18918984f, -0.06593356f, 0.00141748f, 
    -0.19770114f, 0.18772724f, 0.08558779f, 0.10802935f, 0.02715818f, -0.06290860f, -0.04597130f, 0.08963203f, 
    -0.08346802f, -0.06354246f, -0.07853760f, 0.19601655f, 0.01942687f, -0.10116598f, 0.11721171f, 0.04842895f, 
    -0.00056609f, -0.12193987f, -0.30971897f, -0.13083181f, -0.05852411f, 0.06524378f, 0.20824507f, -0.03969027f, 
    -0.05944262f, 0.16855966f, 0.68625218f, 0.05952491f, -0.07215697f, 0.04441946f, -0.09487224f, 0.06811217f, 
    0.02529742f, 0.06116282f, 0.09980666f, 0.15625092f, 0.30035260f, 0.05471376f, -0.39817578f, 0.06285344f, 
    0.13054965f, 0.00908662f, 0.01259915f, 0.15115854f, 0.03159492f, 0.04655099f, 0.00163217f, 0.10175946f, 
    0.18474123f, -0.18866408f, -0.09401033f, 0.23123132f, -0.00953424f, 0.10044782f, -0.26720324f, 0.06754313f, 
    -0.08395346f, -0.13941701f, 0.14232087f, -0.11672279f, -0.31865728f, 0.05513067f, -0.22847183f, 0.26648235f, 
    0.02131867f, -0.02238278f, -0.06248767f, 0.18375315f, 0.01869409f, 0.10753411f, -0.10891940f, 0.25209761f, 
    -0.02328552f, 0.09145077f, 0.13050626f, 0.11249994f, -0.31942409f, -0.09810476f, -0.08672670f, 0.49015594f, 
    0.02636691f, -0.17619041f, 0.03292903f, -0.06295346f, -0.11203676f, 0.09254994f, 0.19854525f, -0.10945673f, 
    -0.14362332f, 0.31708610f, 0.38459826f, 0.25901669f, -0.37299028f, -0.16532388f, -0.01820302f, -0.05345616f, 
    0.07709415f, 0.04450559f, 0.29047418f, 0.15560067f, 0.01397979f, -0.00381428f, 0.05002650f, -0.01711866f, 
    -0.08468141f, 0.03614020f, -0.07473227f, 0.17329666f, -0.08341210f, -0.07526977f, -0.05333561f, -0.06053625f, 
    -0.12932515f, 0.14593254f, -0.05626928f, 0.20826210f, -0.00992198f, 0.34749439f, 0.05149790f, 0.06902672f, 
    0.02798191f, 0.00346997f, 0.24593188f, -0.02637495f, 0.08041229f, 0.05549781f, 0.04235185f, 0.15498109f, 
    -0.06999300f, -0.03907344f, 0.07965931f, -0.10773887f, 0.09072325f, -0.23660067f, -0.40268469f, 0.15506792f, 
    0.11849721f, -0.09878185f, -0.13799639f, 0.35852185f, -0.28455251f, 0.25746864f, 0.16473594f, 0.25877133f, 
    0.32102796f, -0.02101292f, -0.08245061f, -0.04797291f, -0.06748015f, -0.01684871f, 0.19150904f, 0.06048439f, 
    0.32473087f, -0.20459147f, -0.19907390f, -0.20624961f, -0.00497176f, 0.08044884f, 0.05661456f, 0.08725899f, 
    -0.06205686f, -0.05216464f, 0.14505342f, 0.08337776f, -0.32848886f, 0.06458588f, 0.26369032f, -0.04927751f, 
    -0.11700957f, -0.08895490f, -0.03558317f, -0.05370399f, 0.05943075f, -0.10174294f, -0.05596852f, 0.14611000f, 
    -0.15086162f, 0.19059041f, -0.01817224f, -0.06847364f, -0.10359582f, -0.00897791f, 0.16308869f, 0.06520975f, 
    -0.06337922f, 0.16195244f, 0.40903932f, 0.40273985f, 0.14977512f, 0.22189927f, 0.16535963f, 0.08249775f, 
    -0.12022412f, 0.06428578f, 0.04411313f, -0.05243698f, 0.07581639f, -0.36358294f, 0.05497675f, 0.07887430f, 
    -0.11115527f, -0.21036798f, -0.13422310f, 0.06285390f, 0.17867495f, -0.13208281f, 0.18979602f, -0.23754118f, 
    0.26292148f, 0.02524461f, -0.12865816f, 0.01797927f, 0.05909812f, 0.01807164f, -0.06440795f, 0.08582544f, 
    0.03205732f, 0.07043160f, -0.23438613f, -0.14135550f, 0.26623508f, 0.28507128f, -0.02793161f, -0.02279288f, 
    0.07916088f, 0.08404455f, -0.44264966f, 0.00371423f, 0.23992115f, 0.04362989f, -0.20349595f, 0.00363889f, 
    0.03707991f, 0.10732643f, 0.02222401f, 0.25140885f, -0.07484811f, 0.00256532f, 0.09770729f, -0.17153484f, 
    0.10090550f, 0.18153495f, 0.42674679f, 0.06960468f, -0.22265071f, 0.24997386f, -0.12187013f, 0.10962903f, 
    0.09209263f, -0.15736869f, -0.27940652f, -0.14447738f, -0.16913021f, 0.06996857f, 0.13538758f, 0.14095418f, 
    0.08880977f, 0.24247904f, 0.04924988f, 0.01320373f, -0.02290506f, 0.19715784f, 0.24769618f, 0.10642530f, 
    -0.00829563f, 0.07887504f, 0.15682931f, 0.18711951f, 0.27280024f, -0.12283221f, -0.04742818f, -0.06708936f, 
    -0.04188738f, -0.09116098f, -0.03495146f, 0.07188049f, -0.06913494f, 0.03791692f, 0.01875166f, 0.02411895f, 
    0.19268417f, -0.13770777f, 0.30447516f, 0.29310092f, 0.11779752f, -0.06150579f, 0.06213558f, -0.17373160f, 
    -0.06759076f, 0.09640766f, -0.19910544f, -0.08737626f, 0.16492844f, -0.06628279f, -0.02449705f, -0.02807763f, 
    0.06978467f, 0.18445951f, 0.05437116f, 0.10131887f, 0.00531565f, -0.05372299f, 0.01364973f, 0.00266974f, 
    0.15745708f, -0.13651919f, -0.11960883f, 0.15688752f, 0.31961629f, 0.11392333f, -0.06964661f, 0.09673813f, 
    0.08134238f, 0.14493527f, -0.22909555f, -0.23263794f, -0.16835336f, 0.09216812f, -0.10089611f, 0.13592333f, 
    -0.20352972f, -0.21899189f, 0.11205296f, 0.08118867f, 0.07136704f, 0.10105347f, 0.20690720f, 0.08687888f, 
    -0.09558009f, 0.08849920f, 0.04533765f, -0.25591677f, 0.12627274f, -0.01539414f, -0.13596404f, 0.31648481f, 
    -0.32714531f, 0.02054418f, 0.11510810f, 0.06228863f, -0.06428145f, 0.01228754f, -0.02332825f, 0.11757004f, 
    0.17639725f, -0.18564127f, -0.24171393f, 0.02101362f, -0.03904998f, 0.01165936f, -0.07749044f, 0.10627009f, 
    -0.00188370f, -0.04396400f, -0.00904274f, -0.03342837f, -0.10634524f, -0.12185420f, 0.25255197f, -0.01059186f, 
    -0.05802637f, -0.02426459f, -0.10568424f, -0.20471863f, 0.01923141f, 0.09180687f, 0.09019352f, -0.08549783f, 
    -0.14245176f, 0.24188791f, -0.11304076f, 0.05354969f, -0.18273240f, -0.02456873f, 0.30768237f, -0.05296094f, 
    0.09023441f, -0.05005626f, 0.30972323f, 0.39205855f, -0.01596818f, -0.02453918f, 0.23025051f, -0.12653553f, 
    -0.00625258f, 0.20373054f, 0.02339677f, 0.06695056f, 0.01163703f, -0.34897512f, -0.03128444f, -0.03260586f, 
    -0.09017560f, 0.06539660f, -0.10505158f, 0.07818305f, 0.21656843f, 0.08935196f, 0.08489369f, -0.06584030f, 
    -0.05431909f, 0.05649726f, 0.14581455f, 0.03501843f, -0.02642195f, -0.06122841f, 0.11563828f, -0.04019620f, 
    -0.02072491f, 0.03989381f, 0.08441716f, -0.07658333f, 0.02928484f, 0.06162833f, -0.04516755f, 0.01732609f, 
    -0.10462242f, -0.00423567f, -0.02634014f, -0.08146675f, -0.10210763f, -0.01496905f, 0.04764308f, 0.05181780f, 
    0.11730506f, 0.07483019f, -0.11868177f, -0.11309349f, -0.11745784f, 0.06063031f, -0.04641226f, -0.02180633f, 
    -0.00532109f, -0.02576266f, -0.03031078f, -0.09195898f, -0.05848938f, 0.08685030f, -0.12396532f, -0.08328384f, 
    0.04998881f, 0.08386904f, -0.14219831f, 0.06205916f, -0.10738396f, -0.10200354f, -0.11864471f, -0.05967803f, 
    -0.06972229f, -0.11811314f, -0.07229707f, -0.06409754f, 0.04219189f, 0.02580042f, -0.11451778f, -0.01670593f, 
    0.09933706f, 0.03390766f, -0.11651516f, -0.08790520f, -0.06254397f, -0.06825096f, -0.11880007f, 0.08555573f, 
    0.05717464f, -0.11702745f, -0.03365377f, -0.09029025f, -0.09282504f, 0.09255011f, 0.02533665f, 0.05822033f, 
    0.02424270f, -0.03080440f, 0.10988631f, -0.12332614f, 0.05483452f, -0.04287288f, -0.07083988f, -0.00819296f, 
    -0.00388958f, 0.09628193f, 0.03245655f, 0.06998837f, -0.07006399f, 0.07133415f, 0.00653852f, -0.04578152f, 
    0.04729509f, -0.06341215f, -0.07643378f, -0.10872944f, 0.00891097f, 0.01307152f, -0.07638183f, -0.08975169f, 
    -0.05725636f, -0.00607028f, -0.05648255f, -0.10394660f, -0.12065481f, 0.05395926f, -0.07051195f, 0.00109401f, 
    -0.08768374f, -0.11976407f, -0.08691684f, 0.08448072f, -0.05986354f, 0.08198776f, 0.01416084f, 0.03369293f, 
    -0.10639016f, -0.00595706f, -0.06723207f, -0.10427836f, -0.01350088f, -0.06557666f, -0.05848471f, 0.03245182f, 
    -0.03258687f, -0.09102784f, 0.02722809f, -0.04213787f, 0.00277446f, 0.01462603f, 0.02341170f, 0.00160092f, 
    -0.12096709f, -0.05525719f, 0.08803879f, -0.01855673f, 0.11553895f, -0.07125486f, -0.08408116f, -0.06597850f, 
    -0.08166238f, -0.11305542f, 0.18800737f, 0.12433378f, -0.09552623f, -0.14609124f, -0.01879419f, -0.06340389f, 
    -0.07610504f, -0.06284040f, 0.49520919f, -0.02647875f, -0.14340915f, -0.02738415f, 0.02988903f, -0.00804877f, 
    0.07885987f, -0.04545495f, -0.02978300f, 0.15488037f, -0.09785271f, 0.06441300f, -0.12338405f, 0.19979411f, 
    -0.11416816f, 0.16399747f, -0.08393823f, 0.17528923f, 0.08612775f, -0.04103427f, -0.07803162f, -0.02615639f, 
    -0.11298227f, 0.11031844f, 0.05963076f, 0.22325179f, -0.04179429f, -0.10412865f, 0.16126631f, -0.11486639f, 
    0.18533470f, -0.20284082f, -0.08366932f, -0.04003831f, 0.03232703f, 0.21178550f, -0.11708435f, 0.22206721f, 
    0.12722988f, 0.06813137f, 0.01548356f, 0.17613025f, -0.06041005f, 0.21919338f, -0.11937316f, 0.16663423f, 
    0.33861074f, -0.03358291f, 0.23107316f, 0.07407910f, 0.02844108f, 0.02485505f, 0.04955627f, 0.01594600f, 
    0.16607994f, -0.19223589f, -0.03431595f, 0.11199809f, 0.25352478f, -0.09617369f, 0.07236525f, -0.39008564f, 
    -0.08921643f, 0.01177841f, 0.11734325f, 0.01111810f, 0.16872695f, 0.01689942f, -0.02450988f, 0.06754377f, 
    -0.11820222f, 0.13869797f, 0.03670856f, 0.30975518f, -0.09463640f, 0.02215368f, 0.05522054f, -0.09811463f, 
    -0.33099163f, 0.25364196f, -0.05225574f, 0.22870551f, 0.04001102f, 0.12722848f, -0.17337385f, -0.07472628f, 
    0.11533491f, -0.13357994f, -0.01533603f, 0.01111919f, 0.15160480f, -0.11148120f, 0.22406809f, -0.22492243f, 
    -0.33757097f, -0.16581763f, -0.08929587f, 0.16017608f, -0.00466360f, -0.11603703f, 0.21267569f, 0.18422161f, 
    -0.00385697f, 0.08724657f, -0.02185868f, 0.09834041f, 0.42757249f, 0.28590775f, -0.11558874f, 0.15983547f, 
    0.06401327f, -0.25616270f, 0.03083952f, 0.06356034f, 0.00681209f, -0.12358594f, 0.25770399f, 0.11755805f, 
    -0.03392541f, -0.13861099f, -0.14044778f, 0.24956368f, 0.15192066f, -0.01239077f, -0.09275760f, 0.24065065f, 
    -0.07778494f, -0.04639042f, -0.34741017f, 0.08685678f, 0.16906409f, -0.00601541f, 0.02593194f, 0.08385285f, 
    -0.11536653f, 0.02080507f, -0.01485294f, 0.11527944f, 0.09748389f, -0.10108177f, -0.03464476f, 0.11228495f, 
    -0.00599759f, -0.12767002f, 0.13462137f, -0.03441234f, 0.20247081f, -0.02661845f, -0.28093159f, 0.11355695f, 
    -0.11667316f, 0.12396029f, 0.10332727f, -0.18695951f, -0.02444114f, 0.21209547f, -0.06261168f, 0.24453628f, 
    -0.04992148f, -0.03353021f, -0.02770029f, 0.05582455f, -0.05196802f, 0.12824579f, 0.22852604f, 0.00619752f, 
    0.08204073f, -0.02743597f, 0.06794408f, -0.06200359f, -0.11946347f, 0.26757538f, 0.00324250f, -0.02727965f, 
    -0.06205245f, 0.15745939f, 0.02416934f, 0.05199587f, -0.07185826f, -0.09998919f, 0.07158480f, 0.10737606f, 
    -0.08034900f, -0.36784926f, -0.23963471f, 0.20130236f, 0.12645809f, -0.03009156f, 0.01437882f, -0.01215238f, 
    -0.02475672f, 0.12650949f, -0.05448954f, 0.28345165f, -0.00488450f, -0.01086500f, 0.15459028f, 0.09803501f, 
    -0.06668442f, 0.03907084f, 0.07200299f, 0.05825270f, -0.02907587f, 0.08253666f, -0.04277128f, -0.04506644f, 
    -0.24378316f, 0.13194063f, -0.08323463f, 0.12851793f, -0.09853657f, -0.05026908f, 0.09010101f, -0.04970273f, 
    -0.05020280f, 0.03093585f, 0.12390926f, 0.21540792f, 0.10258888f, 0.12779938f, 0.25291276f, 0.06250454f, 
    -0.20951581f, 0.12039102f, -0.00624114f, 0.04769932f, -0.06358235f, -0.05375348f, 0.07619585f, -0.14215334f, 
    -0.05505899f, -0.05428537f, 0.09545750f, -0.05044248f, -0.21713921f, 0.33832613f, -0.03057206f, -0.14649278f, 
    0.17288816f, -0.01039306f, 0.19101249f, 0.14073645f, 0.01130458f, 0.02791785f, -0.09544153f, -0.03616592f, 
    0.05493709f, -0.15121329f, 0.18936118f, -0.09885059f, -0.02767731f, -0.00683148f, -0.06233418f, -0.08189987f, 
    0.05396235f, 0.01945186f, 0.36554179f, -0.10791977f, 0.13122980f, -0.00242823f, -0.22726503f, 0.07231317f, 
    -0.01374039f, 0.17613558f, 0.04338240f, 0.24508403f, 0.06831062f, 0.03939364f, -0.07502460f, 0.26124537f, 
    -0.04476709f, 0.17343560f, 0.19862631f, 0.35050535f, -0.09366810f, 0.09448493f, -0.15000613f, -0.01764975f, 
    -0.06000152f, -0.06174878f, 0.23485045f, -0.03371570f, 0.06253819f, 0.34984294f, -0.14131485f, 0.13802348f, 
    -0.08407006f, 0.11491811f, -0.09355640f, -0.02356215f, 0.01879654f, -0.24027514f, -0.16887254f, 0.25844675f, 
    0.00454288f, 0.03858235f, -0.18653257f, 0.36365366f, -0.17927413f, -0.01720455f, 0.08620936f, -0.01030873f, 
    0.40062436f, -0.09692792f, -0.37637898f, -0.13407309f, -0.10941333f, 0.05413032f, 0.17603394f, -0.07295746f, 
    -0.10799389f, 0.08318781f, -0.00858697f, -0.06474343f, -0.03245573f, -0.07070273f, -0.10912691f, -0.06831518f, 
    0.01809217f, 0.00891097f, -0.04024418f, -0.14021432f, 0.07836240f, -0.02366073f, 0.03842000f, -0.09200527f, 
    -0.03808126f, -0.08829864f, -0.06683187f, -0.09708424f, -0.11155516f, -0.04899877f, 0.07816744f, 0.08601010f, 
    -0.10262250f, -0.08605009f, 0.06956106f, 0.06528384f, -0.12941836f, 0.00535642f, 0.01715025f, 0.08124304f, 
    -0.10617383f, -0.07623787f, -0.10974685f, -0.11936744f, -0.06491166f, -0.07471126f, -0.00436773f, -0.03674738f, 
    -0.02946945f, 0.06293066f, -0.04761665f, -0.02548328f, 0.10954362f, 0.01657375f, -0.05330463f, 0.09846383f, 
    0.03394356f, -0.04914087f, -0.03474484f, -0.12809595f, -0.04039454f, 0.10173087f, -0.09105811f, 0.01962505f, 
    -0.00938235f, -0.12605670f, 0.01474901f, 0.11360109f, 0.10831141f, -0.05447856f, 0.10395054f, 0.00762710f, 
    0.18325666f, 0.31490311f, -0.04400019f, -0.09254856f, 0.26628268f, 0.28409296f, 0.04169832f, -0.15597709f, 
    0.02789976f, 0.03383988f, 0.21889152f, -0.00694434f, -0.05476943f, -0.05569840f, -0.32083425f, -0.10222257f, 
    -0.03536176f, -0.02548634f, 0.10695481f, 0.12856652f, -0.01778140f, 0.05226506f, 0.07214165f, 0.26980191f, 
    -0.13672222f, 0.03645189f, 0.01978728f, 0.07452133f, 0.01999223f, 0.11754892f, -0.31442598f, -0.00748955f, 
    -0.10204188f, 0.12160403f, -0.04643052f, 0.01559158f, -0.23928836f, 0.08123364f, 0.16456480f, 0.09978027f, 
    0.13296632f, -0.25487453f, 0.02144598f, 0.08889128f, -0.06705187f, 0.45873505f, 0.09723049f, 0.18562998f, 
    -0.08437443f, -0.09773874f, 0.17438495f, 0.04154139f, 0.00562161f, 0.04974797f, 0.03740244f, 0.21923369f, 
    0.24263062f, -0.09715345f, -0.02302605f, 0.11789451f, -0.01288582f, -0.06169781f, -0.09339797f, -0.00449934f, 
    -0.19400717f, 0.05742349f, 0.15014215f, 0.12975946f, -0.30413762f, 0.18718480f, 0.01593692f, 0.09404711f, 
    0.00916001f, -0.00893964f, -0.22520903f, -0.05389408f, -0.01456635f, 0.08918831f, 0.12067936f, -0.09027205f, 
    0.02681072f, -0.07887414f, 0.03370818f, -0.18729520f, -0.07343698f, 0.03746927f, 0.03299958f, -0.05159195f, 
    0.01997947f, -0.03483297f, 0.15631306f, -0.46920210f, 0.17909525f, 0.14013062f, 0.35035071f, -0.06397325f, 
    -0.10585210f, 0.20361105f, -0.13008314f, -0.12578242f, -0.22594757f, -0.02733937f, 0.01616708f, 0.13141608f, 
    0.07084136f, -0.09014198f, -0.05304495f, -0.20424940f, -0.08371213f, 0.23313123f, -0.22108656f, -0.33124551f, 
    -0.12674354f, 0.05537302f, 0.23736200f, 0.11714607f, -0.18022981f, -0.20262976f, -0.35376859f, -0.30010411f, 
    0.05685030f, 0.25165233f, 0.04578203f, -0.01842817f, -0.10651878f, 0.01686084f, -0.06016788f, -0.01561305f, 
    0.05925696f, -0.08615357f, -0.12795940f, -0.02572224f, 0.08769494f, 0.17275146f, 0.06789570f, -0.02639692f, 
    0.10121777f, 0.06463290f, -0.29751563f, -0.01871366f, 0.20804501f, 0.00714297f, -0.06257405f, 0.08563035f, 
    0.10185383f, 0.06372774f, -0.03496943f, 0.02649238f, 0.11606223f, -0.09429841f, 0.08407270f, -0.29556298f, 
    0.23029253f, -0.01623054f, 0.11480563f, -0.01590921f, -0.00328582f, 0.08338521f, -0.04937185f, -0.04269216f, 
    -0.01808601f, -0.03393645f, -0.15098195f, -0.31775108f, 0.04853421f, 0.01253080f, -0.19146201f, 0.04852686f, 
    0.16951472f, 0.00138973f, -0.04052680f, 0.03482638f, -0.07967286f, 0.07036175f, 0.08082139f, 0.09304672f, 
    0.08674256f, -0.02384955f, -0.01682500f, -0.25139555f, 0.10730647f, -0.17247169f, 0.08083149f, 0.03551950f, 
    -0.19026624f, -0.15468489f, -0.06985390f, -0.04308065f, -0.03608171f, -0.01930339f, 0.11702839f, -0.05707410f, 
    0.38388434f, 0.23508452f, 0.01041657f, -0.19531623f, 0.10730416f, 0.22523080f, 0.06409690f, -0.12201230f, 
    -0.09493199f, 0.00740470f, -0.08171001f, 0.03023748f, 0.01189693f, 0.08720298f, -0.17070502f, 0.10325576f, 
    -0.00751959f, -0.04791616f, -0.06601742f, 0.05040292f, 0.02516359f, -0.08144358f, 0.06245884f, 0.07557923f, 
    -0.21771167f, -0.16551314f, 0.03485527f, -0.06374663f, 0.07281809f, -0.05032095f, 0.00630419f, -0.10724480f, 
    0.09655972f, 0.02026570f, -0.15151508f, 0.04806844f, -0.30886990f, 0.06931737f, 0.17059468f, 0.05672253f, 
    0.04361753f, -0.01509525f, 0.01546976f, 0.09338699f, 0.07205552f, 0.11661921f, 0.30160993f, -0.09778167f, 
    0.00372401f, 0.03417198f, 0.08973512f, -0.17916344f, 0.34502977f, 0.01866997f, 0.01333153f, 0.03481795f, 
    -0.06373867f, -0.11737186f, -0.06594180f, 0.00248444f, -0.02302270f, -0.03280784f, -0.24242802f, 0.01847088f, 
    0.10368335f, -0.43360719f, -0.35493419f, 0.01521449f, 0.25620615f, 0.17645203f, -0.00205659f, -0.04010084f, 
    -0.08219527f, -0.10230767f, -0.13296655f, 0.08421130f, 0.11107641f, -0.09901343f, 0.11252845f, -0.03323223f, 
    -0.08814223f, 0.12376864f, -0.05139290f, 0.08440613f, -0.00483841f, -0.06330280f, 0.11209359f, 0.00578301f, 
    -0.08893102f, 0.12028913f, 0.34880435f, -0.16877265f, -0.17105392f, 0.08785851f, 0.34914792f, 0.08922618f, 
    -0.00996874f, -0.21603473f, -0.11118263f, -0.01712879f, 0.10659909f, -0.06467406f, 0.22531699f, -0.05468673f, 
    -0.09862782f, 0.41309404f, -0.02625313f, 0.03903486f, -0.01339643f, 0.15860736f, 0.06180688f, -0.09342066f, 
    -0.00529719f, -0.04683824f, 0.13004956f, 0.11576355f, 0.26779106f, -0.15631007f, -0.02888461f, -0.13716282f, 
    -0.08392732f, 0.22145036f, 0.20616964f, 0.12711179f, -0.05040451f, -0.05119365f, 0.11235925f, -0.02248253f, 
    0.04067968f, 0.30676800f, 0.19316365f, -0.09128501f, 0.00279049f, 0.02299020f, 0.04978770f, 0.11282932f, 
    -0.10536978f, 0.02407487f, -0.13522764f, -0.02731739f, 0.10189940f, 0.03854477f, -0.13508816f, 0.09504972f, 
    0.00416525f, 0.18341765f, 0.05416770f, 0.21188004f, -0.10287993f, 0.07521506f, -0.07848857f, 0.19284619f, 
    0.08113143f, -0.05953519f, 0.12256755f, -0.06791714f, -0.15696150f, -0.10623031f, -0.01692090f, -0.03252519f, 
    -0.07249642f, -0.10499658f, 0.26631689f, 0.08333027f, -0.31150723f, 0.08321010f, -0.12402231f, 0.15846956f, 
    -0.17709936f, 0.08144795f, -0.06335312f, 0.24548982f, -0.00855573f, -0.07578901f, -0.01876667f, 0.12735850f, 
    0.09264891f, 0.02131498f, -0.16505888f, 0.10070429f, 0.13145046f, -0.18881918f, 0.16167863f, 0.34060794f, 
    -0.12834339f, -0.01625266f, -0.07830631f, -0.15574870f, -0.11239493f, -0.10473621f, 0.07796934f, -0.00793807f, 
    0.04093657f, -0.17532437f, -0.28143853f, 0.39143723f, 0.29559526f, 0.11801764f, -0.11781178f, 0.04194194f, 
    -0.06071644f, 0.05835671f, -0.08975684f, -0.13781764f, 0.18485811f, -0.09708173f, 0.02348641f, 0.02703031f, 
    0.03409540f, -0.01212265f, -0.02600803f, 0.21271947f, -0.00709043f, 0.04907577f, -0.03062277f, 0.03624755f, 
    -0.10337768f, 0.03312761f, 0.15813145f, 0.02375446f, 0.33495942f, 0.10594312f, -0.07694447f, -0.10271573f, 
    0.00900944f, 0.31088942f, 0.17258890f, -0.05795825f, 0.11658181f, 0.17554952f, 0.18791622f, 0.10447221f, 
    -0.09676354f, -0.22183289f, 0.06352477f, -0.16026090f, 0.00871735f, 0.01772506f, 0.36702994f, 0.16403234f, 
    -0.07353559f, 0.15225899f, -0.05844827f, -0.13238518f, 0.01198389f, 0.05781535f, -0.17940949f, -0.07474393f, 
    -0.04623641f, 0.19597496f, -0.10309460f, 0.06579782f, -0.05188543f, 0.10226633f, 0.18512349f, 0.04087394f, 
    0.04596092f, -0.20569812f, -0.52755272f, 0.15598680f, -0.18357433f, -0.11286035f, -0.02414632f, -0.11613458f, 
    0.06122150f, 0.07194459f, -0.27697366f, -0.03067980f, -0.15308414f, 0.06343623f, 0.18088661f, -0.00671405f, 
    0.11011095f, -0.06957204f, -0.05351501f, -0.15428397f, 0.02634674f, -0.01738099f, 0.00102337f, -0.12420208f, 
    0.12626600f, 0.14590871f, -0.13104898f, -0.19624746f, 0.10464781f, 0.07940101f, 0.35726345f, 0.00181808f, 
    -0.11473595f, 0.18654081f, 0.01403828f, 0.25722480f, -0.08327213f, 0.11453874f, 0.28277150f, 0.14736263f, 
    -0.01040798f, 0.17536899f, 0.00194779f, 0.03339748f, 0.08619573f, -0.13523963f, 0.18495631f, -0.17415266f, 
    -0.02050813f, -0.00686577f, 0.21142192f, -0.07270476f, 0.32356167f, -0.04629993f, -0.12559821f, -0.09925268f, 
    -0.15675317f, 0.08962926f, 0.23903839f, 0.02033490f, 0.06741671f, 0.08050035f, 0.03227104f, 0.05330628f, 
    -0.08145770f, 0.60244912f, 0.16794720f, -0.18162875f, -0.03022618f, -0.03389734f, -0.10966927f, 0.00914325f, 
    -0.09931622f, 0.04003063f, -0.16592111f, -0.06763531f, 0.14477460f, -0.07196261f, -0.20169616f, -0.03825477f, 
    -0.10581523f, 0.20287628f, 0.01200435f, 0.26847592f, -0.03215554f, 0.08874036f, -0.10236084f, 0.36959305f, 
    -0.13245450f, -0.04279893f, 0.37015074f, 0.07863933f, -0.23779052f, 0.09955214f, -0.13878515f, -0.12074135f, 
    -0.00733079f, 0.06226984f, 0.15622009f, -0.11337157f, 0.00169760f, 0.20838034f, 0.07895797f, -0.09326552f, 
    0.15694545f, -0.02965374f, 0.04716966f, 0.17460299f, 0.06789865f, 0.15933219f, -0.03594844f, 0.29134592f, 
    0.12290916f, -0.00754179f, -0.18747681f, 0.32520902f, 0.01633288f, 0.09944056f, 0.18620878f, 0.24168208f, 
    0.10717827f, 0.08818895f, -0.01053514f, 0.03812087f, -0.03819994f, 0.05430963f, 0.13208725f, 0.11197251f, 
    0.17110409f, 0.53923523f, 0.23745601f, 0.18476461f, 0.25968188f, -0.01949147f, -0.04913786f, -0.24074309f, 
    -0.12691222f, 0.02334340f, 0.01750578f, 0.19193053f, 0.27374122f, -0.01458792f, 0.00050079f, -0.10648721f, 
    0.01535016f, 0.08574419f, -0.04804453f, 0.19269730f, -0.12237570f, 0.13058797f, 0.05919208f, 0.23348825f, 
    -0.05659320f, -0.21317415f, 0.23899014f, 0.01200499f, 0.06425161f, 0.16774838f, -0.02748748f, -0.06600279f, 
    0.07487857f, 0.05455682f, -0.32348248f, -0.07501175f, -0.36811513f, -0.01847776f, 0.26376367f, -0.21529604f, 
    -0.16293323f, -0.14332160f, 0.08421727f, -0.00044768f, 0.00396416f, 0.38741684f, 0.03995400f, 0.09571606f, 
    -0.08870697f, -0.08799539f, 0.19379222f, 0.10061107f, 0.27433303f, 0.19387321f, 0.02672576f, 0.16762124f, 
    0.04365109f, -0.04252508f, 0.32734066f, -0.04270282f, 0.02210957f, 0.00547488f, -0.11624697f, -0.10765536f, 
    -0.06372671f, -0.00026381f, 0.10398375f, -0.04000018f, 0.04673347f, -0.00325842f, 0.01113337f, 0.01306660f, 
    -0.10957478f, 0.00546999f, 0.01640282f, 0.01331121f, -0.09760167f, -0.06807454f, -0.08982824f, 0.11775088f, 
    -0.04793487f, -0.11388515f, 0.04260290f, 0.05670143f, -0.05610025f, 0.00912517f, 0.10986745f, -0.13334359f, 
    -0.03011275f, 0.06177822f, -0.07871454f, -0.05354189f, -0.05727680f, -0.01339860f, -0.11955656f, -0.01887767f, 
    -0.00736915f, -0.05990627f, -0.04231259f, -0.02741810f, -0.12077328f, -0.07746170f, -0.03150086f, -0.05359786f, 
    -0.09318954f, -0.05983149f, 0.01926932f, 0.07288035f, -0.03656620f, 0.02920812f, -0.04321571f, -0.05532694f, 
    -0.12209838f, 0.07919612f, 0.04995894f, 0.04253018f, 0.00974006f, -0.08136060f, 0.03531557f, -0.12655295f, 
    0.05673653f, -0.08656812f, 0.11729801f, -0.12070263f, 0.08822332f, 0.08924805f, -0.01349422f, 0.06227906f, 
    -0.03703280f, -0.39506045f, 0.02105533f, 0.05680521f, 0.06675133f, 0.20563257f, 0.01315480f, 0.25092751f, 
    -0.09494364f, -0.04338299f, -0.16387032f, 0.46168777f, 0.15013491f, -0.10373010f, 0.36360496f, 0.03738749f, 
    0.07765777f, -0.07942755f, 0.00452227f, -0.08332486f, -0.01040012f, 0.01873280f, 0.07129940f, -0.34297425f, 
    -0.09825511f, -0.05981775f, -0.02147624f, -0.06960215f, -0.12173317f, -0.02603941f, 0.28727180f, 0.01242485f, 
    -0.07391854f, -0.14755557f, 0.11682527f, 0.15131302f, -0.24778746f, -0.01271357f, -0.02287168f, 0.14386147f, 
    -0.31907117f, 0.44937974f, 0.03180993f, 0.31845534f, -0.08703105f, -0.29375538f, 0.01732258f, -0.11173520f, 
    -0.00392328f, -0.07763916f, 0.37968022f, 0.01344138f, -0.11332880f, 0.16043785f, 0.02744529f, 0.12397993f, 
    -0.07963926f, 0.11659783f, 0.32987785f, 0.01277172f, -0.07133174f, -0.03019941f, -0.03730917f, -0.01016217f, 
    -0.28479344f, -0.19837518f, 0.13396999f, -0.17854035f, -0.18712752f, 0.12261649f, -0.00594703f, 0.03849343f, 
    -0.02952705f, 0.09895497f, -0.39755514f, 0.14007953f, 0.16943930f, -0.01523642f, 0.07441084f, 0.11383335f, 
    -0.07064771f, -0.21122652f, -0.07111990f, -0.14765844f, -0.01833762f, -0.01647616f, 0.08237785f, -0.22055891f, 
    0.16539535f, -0.11124054f, -0.20993036f, -0.02130024f, 0.09254309f, -0.21559538f, -0.07408284f, 0.01243909f, 
    -0.07439142f, 0.00219854f, -0.19454803f, -0.18300058f, -0.00949708f, -0.12177248f, 0.03550693f, 0.13404077f, 
    0.26106638f, 0.08171449f, 0.04565578f, -0.05852314f, 0.06795199f, 0.20806046f, -0.27213538f, -0.25861210f, 
    -0.09665974f, -0.03957220f, -0.04657147f, -0.03501557f, -0.24734339f, -0.04907370f, 0.08325735f, 0.03162861f, 
    0.10848836f, 0.02160143f, -0.07565126f, -0.04443465f, -0.11056712f, 0.09174777f, -0.11361460f, -0.00843119f, 
    0.35447657f, -0.07455637f, -0.45310137f, 0.11691941f, 0.23709594f, 0.23425202f, -0.09644995f, 0.19540402f, 
    -0.07347022f, 0.00151208f, 0.09681732f, -0.07629517f, -0.03503753f, -0.05860053f, 0.00332316f, -0.00162613f, 
    0.01402219f, -0.04097050f, 0.02844382f, 0.09057669f, -0.04127189f, 0.00381702f, 0.12084927f, 0.22034633f, 
    0.03394328f, -0.11483211f, 0.10511882f, -0.20231783f, 0.33895114f, 0.12177705f, -0.06639940f, 0.05074773f, 
    -0.02787782f, 0.20077358f, 0.02045006f, 0.09123295f, 0.00421425f, 0.03250215f, 0.07011878f, 0.15888955f, 
    -0.11258271f, 0.02595015f, 0.06559677f, -0.09781351f, 0.04090478f, 0.17376518f, 0.41823271f, -0.08391231f, 
    -0.03328285f, -0.00611895f, 0.00122429f, -0.00270170f, 0.18819022f, 0.10020227f, -0.11937106f, -0.24320833f, 
    0.14900590f, 0.22670464f, -0.16035794f, 0.02895442f, -0.04270589f, 0.12483567f, -0.12847482f, 0.03692916f, 
    0.10960161f, -0.13192128f, 0.01996806f, 0.17553578f, -0.07923552f, 0.18095993f, -0.08419447f, 0.03672851f, 
    0.02537355f, -0.07361840f, 0.09459864f, 0.10570376f, -0.36988175f, 0.10161389f, -0.17102356f, -0.09982307f, 
    -0.06235126f, -0.48693877f, 0.03485711f, -0.25351065f, -0.03762133f, -0.07223526f, -0.09795804f, -0.14829428f, 
    -0.06044324f, 0.45981488f, -0.36671433f, 0.08631098f, 0.30600435f, 0.25799978f, 0.07348198f, 0.08764813f, 
    0.07958235f, 0.17650592f, 0.28188810f, 0.03220196f, 0.03832615f, -0.01516014f, 0.05394762f, 0.26400283f, 
    -0.08474239f, -0.09647531f, 0.12054137f, -0.10025097f, -0.03209200f, 0.05410508f, 0.17356588f, -0.16740778f, 
    0.12567909f, -0.03171928f, 0.17473769f, -0.11395624f, -0.16915639f, -0.09775240f, -0.39438704f, -0.10465313f, 
    0.30987200f, 0.07429421f, 0.05975046f, 0.05498208f, -0.01973543f, -0.09385648f, 0.12019455f, -0.11216506f, 
    0.12737155f, 0.14241685f, 0.32604173f, 0.18369742f, 0.17143846f, 0.04621605f, 0.01802651f, -0.30673841f, 
    -0.06849013f, 0.07746556f, 0.12096952f, -0.06819378f, -0.03354262f, 0.05735968f, -0.15742654f, -0.11348208f, 
    0.00355181f, 0.09774099f, 0.06679680f, 0.25271210f, 0.04802758f, 0.08308158f, -0.11965206f, -0.04506020f, 
    0.05945140f, 0.26346937f, 0.11449002f, 0.25816360f, -0.10853417f, 0.21653406f, -0.18156174f, 0.02282147f, 
    0.01863088f, -0.24749127f, 0.06008244f, -0.02387818f, -0.00320033f, 0.13508089f, 0.14533603f, -0.09039099f, 
    -0.22838962f, -0.00884053f, 0.00106077f, 0.17841820f, 0.03549853f, -0.09027153f, 0.12405073f, 0.04148316f, 
    0.07159536f, -0.04231487f, -0.04440973f, 0.13317123f, 0.33730149f, 0.17079800f, 0.07337767f, 0.37462321f, 
    -0.14099200f, -0.27305320f, 0.00684226f, 0.02431187f, -0.07454863f, -0.09089527f, 0.23870113f, 0.10340109f, 
    0.18289694f, 0.21184747f, 0.51362407f, 0.14793240f, 0.06431284f, 0.02976962f, 0.00263435f, -0.27255517f, 
    0.04552069f, -0.02486290f, -0.01722870f, 0.24932785f, 0.01180510f, -0.08239985f, -0.05616060f, 0.05773002f, 
    -0.10046996f, -0.07917102f, 0.10127141f, -0.15266293f, -0.07924761f, 0.00838943f, -0.07181143f, -0.21970211f, 
    -0.16505620f, -0.06891283f, -0.22193968f, 0.41066030f, -0.15713653f, 0.28352612f, -0.17360806f, 0.11821465f, 
    0.00170708f, -0.08030452f, -0.21247834f, 0.07315230f, -0.57502478f, 0.09835355f, -0.09341028f, -0.04098710f, 
    -0.01535986f, -0.00974436f, -0.05496451f, 0.34385544f, 0.07328875f, -0.00671890f, 0.12469862f, 0.04176567f, 
    -0.11348388f, 0.08619108f, 0.21269983f, 0.06446966f, 0.03812926f, 0.26637271f, -0.11579877f, 0.49440524f, 
    0.10982594f, -0.16010971f, 0.33748272f, 0.01801772f, -0.03829472f, 0.06827999f, -0.11684861f, 0.01598370f, 
    0.11709972f, 0.16973169f, 0.26897722f, 0.05113422f, 0.05141962f, 0.26518244f, 0.10415325f, 0.06861594f, 
    -0.10469674f, -0.00545458f, -0.02526295f, 0.12377391f, -0.07165962f, -0.11723346f, -0.21705155f, -0.05951878f, 
    0.11213209f, -0.23283903f, 0.07647734f, -0.07334195f, 0.06874483f, 0.08518027f, -0.01458744f, -0.23426217f, 
    0.17704521f, 0.21142280f, -0.04419331f, 0.08478022f, 0.08882675f, 0.20452954f, 0.05680190f, -0.01568522f, 
    -0.12329946f, 0.10194669f, -0.25319460f, -0.21608050f, -0.13003458f, 0.19306986f, -0.11795320f, 0.27535379f, 
    0.00443027f, -0.04081407f, 0.06599012f, 0.16217759f, 0.03309359f, 0.37522960f, 0.23066211f, 0.07466744f, 
    -0.02744970f, 0.09508025f, 0.25471070f, -0.19666561f, -0.04993522f, -0.13651042f, -0.12683722f, 0.05374698f, 
    -0.04919843f, -0.02393247f, 0.00777003f, 0.12230802f, 0.05981853f, 0.03382945f, -0.21789655f, 0.03421703f, 
    0.14609715f, 0.11548373f, 0.01022635f, 0.05889552f, 0.05341780f, -0.00927181f, -0.03539671f, 0.22676365f, 
    -0.09748488f, -0.12804654f, -0.11403958f, -0.15672924f, 0.20806617f, 0.12115850f, -0.19805859f, -0.11477758f, 
    0.02611269f, 0.05465629f, -0.03466390f, 0.00882975f, -0.03252326f, 0.07595847f, 0.07582252f, -0.09221516f, 
    -0.04164469f, -0.06512726f, 0.21308166f, 0.03328263f, 0.03447078f, 0.05935990f, -0.23419283f, -0.05483476f, 
    0.00156280f, 0.06056617f, 0.08855391f, -0.25349334f, 0.04704329f, 0.29663375f, -0.06352997f, 0.18280981f, 
    0.14108738f, 0.07452017f, -0.09706684f, 0.04562190f, 0.04221945f, 0.07454692f, 0.27308097f, 0.10322426f, 
    -0.01902006f, 0.02331066f, -0.20995200f, -0.13570581f, -0.26685470f, -0.05717341f, 0.16668659f, -0.09391093f, 
    -0.06580846f, 0.05143022f, -0.17613485f, -0.04671863f, 0.10045741f, 0.04524876f, -0.00767772f, 0.10596191f, 
    0.15344375f, 0.45681557f, 0.20949948f, -0.20467575f, -0.25470200f, 0.20291305f, 0.07400426f, 0.07034952f, 
    -0.05022490f, -0.07364235f, -0.38309738f, -0.18778300f, -0.29234746f, 0.03760910f, -0.10848029f, 0.11768076f, 
    -0.04518858f, -0.25947106f, -0.01147471f, -0.06941665f, 0.07469912f, 0.10609156f, 0.09927068f, 0.05707400f, 
    -0.02697282f, 0.27088672f, 0.10528985f, 0.00462319f, -0.14647502f, 0.17490508f, 0.05280712f, 0.10434559f, 
    0.06007957f, 0.17160331f, 0.04922292f, -0.10236371f, 0.02749420f, -0.03768314f, 0.13627556f, 0.15338615f, 
    0.30125186f, -0.09703217f, -0.06957915f, -0.18386979f, 0.07107385f, 0.35334525f, 0.09759279f, -0.10067166f, 
    0.04275106f, 0.06870064f, 0.01869540f, -0.08036436f, -0.02614188f, -0.14464550f, 0.02677589f, 0.09553144f, 
    0.16260779f, 0.13016492f, -0.23704727f, -0.08729191f, 0.06031216f, 0.05731955f, -0.32675734f, -0.06569563f, 
    0.16985032f, -0.25189108f, -0.45483699f, -0.12323406f, 0.15150736f, 0.24303690f, -0.00721414f, 0.17317340f, 
    -0.12196340f, -0.06803969f, -0.11694299f, 0.25731036f, -0.07771823f, 0.11749369f, 0.09281638f, 0.01735070f, 
    0.06289189f, 0.04704985f, -0.01158425f, 0.11316507f, -0.07184169f, 0.03160955f, 0.03555093f, -0.09023691f, 
    -0.34962311f, 0.21751672f, 0.06108800f, -0.09093447f, -0.12021246f, -0.07977836f, -0.13593093f, 0.03900615f, 
    0.09156476f, -0.05185151f, 0.17797527f, 0.08887118f, 0.12761422f, 0.08468487f, 0.14415528f, 0.17298599f, 
    -0.29492536f, 0.09328842f, -0.07829475f, 0.08427276f, -0.06889882f, -0.04306312f, 0.23896755f, -0.07875091f, 
    -0.10418577f, -0.02987699f, 0.15088263f, -0.07270059f, -0.08225394f, 0.19227779f, 0.16731136f, -0.21931370f, 
    0.30978844f, 0.07766941f, 0.15147132f, 0.10564461f, 0.09340927f, 0.06982113f, -0.05970157f, -0.09131716f, 
    0.29253423f, 0.14472629f, 0.00424761f, -0.12831973f, -0.05365321f, 0.12649454f, 0.00838484f, 0.10866252f, 
    -0.00085079f, 0.07168075f, 0.00019809f, 0.09898519f, -0.20537823f, 0.01524339f, -0.10187732f, -0.12002860f, 
    0.06944187f, 0.03266841f, -0.00897061f, -0.25476426f, -0.09824251f, -0.02628550f, -0.03650099f, 0.03167762f, 
    -0.39446372f, 0.07735857f, -0.32086194f, 0.05791808f, -0.11833929f, -0.00950329f, -0.10154174f, 0.06842691f, 
    0.00186356f, -0.05362345f, 0.43292594f, 0.32291469f, 0.16088128f, 0.19985741f, 0.24135679f, 0.23797052f, 
    0.09215222f, -0.04786368f, 0.11661856f, 0.03697071f, -0.05232185f, -0.07744210f, -0.02047390f, 0.04199309f, 
    -0.01216516f, -0.01669435f, 0.14275931f, -0.01030616f, -0.11129546f, 0.31146449f, 0.03938419f, -0.10354123f, 
    0.30994853f, -0.12808558f, 0.22802982f, -0.00804260f, 0.06252029f, -0.08401429f, 0.04014628f, -0.00129154f, 
    -0.16641738f, -0.00595610f, -0.11708847f, -0.32464972f, -0.02961774f, 0.04927823f, -0.11024122f, 0.07171647f, 
    -0.06558256f, 0.06653921f, 0.20471062f, 0.06556986f, 0.04158872f, -0.03120844f, 0.19415718f, 0.00343773f, 
    0.06219411f, 0.07931668f, -0.12639461f, -0.06475271f, -0.07457854f, -0.02655799f, 0.07996620f, 0.08356426f, 
    -0.13685140f, -0.17441207f, 0.34198698f, -0.18527979f, -0.11200304f, -0.02375893f, 0.42097110f, 0.06402349f, 
    0.12297694f, -0.12698238f, 0.03131332f, 0.21530455f, -0.10532569f, 0.01650351f, 0.09843022f, 0.06227585f, 
    0.02000130f, 0.28359821f, 0.10444415f, 0.19627963f, -0.01842193f, 0.14392717f, -0.29616416f, -0.09938651f, 
    0.04185037f, -0.10760193f, -0.05882855f, 0.31645384f, -0.14338601f, -0.12384354f, 0.26896548f, -0.12674952f, 
    0.11530855f, 0.17938206f, -0.01825773f, 0.05791623f, 0.06158747f, 0.05727794f, -0.01515774f, -0.05254701f, 
    -0.09868062f, -0.21576570f, -0.22525597f, 0.03276396f, 0.22655301f, 0.20076184f, 0.12668532f, 0.16462226f, 
    0.02119237f, -0.05895065f, -0.25365251f, 0.24908923f, 0.29347628f, 0.06800008f, -0.02216371f, -0.03114160f, 
    0.07010717f, 0.14157052f, -0.07654571f, 0.03752375f, 0.00196438f, -0.09007750f, -0.01155308f, 0.02183976f, 
    0.13995621f, -0.23344980f, 0.20513096f, -0.16888446f, 0.02493751f, -0.04863634f, -0.09053451f, -0.05067820f, 
    0.06799056f, 0.09981473f, 0.14456259f, -0.17226236f, -0.22852693f, 0.25938618f, -0.12286087f, 0.34860784f, 
    -0.35622573f, 0.06330967f, -0.02175733f, 0.20229873f, 0.03322078f, 0.11718447f, 0.13604608f, -0.00720277f, 
    0.09529657f, 0.01462245f, 0.18551770f, -0.08701549f, -0.18065579f, 0.25785547f, -0.04239228f, -0.11012960f, 
    -0.08618097f, 0.05080256f, 0.09483449f, -0.10794429f, 0.09271789f, -0.09910807f, -0.05254673f, 0.03758129f, 
    -0.21929780f, -0.22268458f, 0.19574875f, 0.14581844f, -0.12234750f, 0.01829705f, -0.09805517f, -0.03342203f, 
    -0.01688570f, 0.01690742f, -0.11653370f, 0.14733645f, 0.14745848f, -0.07309754f, 0.05497342f, -0.01814409f, 
    0.05516981f, 0.11594056f, 0.10256389f, -0.21285756f, 0.00554730f, -0.03920290f, -0.03940008f, -0.28952450f, 
    -0.03305030f, 0.19350478f, -0.06917997f, 0.15903814f, -0.09640711f, 0.11098505f, 0.44091514f, 0.08127221f, 
    -0.07488135f, 0.05636142f, 0.02921877f, 0.01886559f, -0.07592593f, 0.09108094f, 0.19345225f, 0.05278686f, 
    0.11715927f, 0.18491828f, 0.04878796f, -0.05197544f, -0.05268869f, 0.28725061f, 0.04389236f, -0.13313936f, 
    0.01562923f, 0.07066531f, 0.36329076f, 0.14520253f, 0.00196113f, 0.18815626f, -0.20653506f, 0.12640595f, 
    -0.05050834f, 0.03341772f, 0.32190409f, -0.00638774f, -0.04789320f, -0.10130657f, -0.06569654f, 0.09125706f, 
    0.22500323f, 0.15732157f, -0.17250215f, -0.27362156f, 0.16824457f, 0.02362986f, 0.08454687f, 0.03414892f, 
    0.04332580f, 0.07669205f, 0.04252080f, -0.17169560f, -0.11898902f, -0.05858023f, 0.12544881f, 0.07067766f, 
    0.10009892f, 0.13544013f, 0.05616665f, 0.18436480f, 0.08495980f, -0.01827261f, 0.04357776f, 0.06998573f, 
    -0.23458435f, -0.03082058f, 0.11222939f, 0.02876155f, -0.09849022f, -0.06737858f, 0.27313653f, -0.00555780f, 
    -0.07333186f, 0.05498444f, -0.05962492f, 0.30445132f, -0.05932638f, 0.03535488f, -0.01845828f, -0.15825048f, 
    0.05503362f, 0.21932770f, 0.10610581f, -0.12536876f, -0.11434292f, 0.04248624f, 0.13779289f, -0.02496753f, 
    0.07824218f, 0.08465943f, -0.13317187f, 0.15436980f, 0.40634570f, -0.23437929f, 0.06440892f, -0.17981598f, 
    -0.07274717f, 0.05104770f, -0.26492855f, -0.11313679f, 0.03155271f, 0.09247640f, -0.14027026f, 0.08506855f, 
    0.15731120f, 0.05580294f, 0.00170198f, 0.17426129f, 0.18329819f, 0.03375444f, -0.12326349f, -0.12431529f, 
    0.12872787f, 0.08280569f, -0.05892004f, -0.19175601f, -0.17468385f, 0.01298687f, 0.19843690f, 0.02747743f, 
    0.08308941f, 0.08348417f, 0.08019165f, 0.16739716f, 0.08109419f, -0.05444960f, -0.07672689f, 0.23350394f, 
    -0.00395416f, -0.03272659f, 0.22134686f, -0.17524563f, 0.19054018f, 0.10555650f, 0.15545462f, 0.10497218f, 
    -0.10367945f, 0.00061361f, -0.20634215f, 0.07127806f, 0.01713233f, -0.21045177f, -0.01768703f, -0.03640883f, 
    -0.01470796f, -0.08742595f, -0.01397010f, -0.00405522f, -0.05313176f, -0.14740178f, 0.03947494f, 0.12438375f, 
    0.05197223f, 0.13108397f, -0.12801957f, -0.01621334f, 0.32442349f, 0.03678198f, -0.02098874f, 0.00957593f, 
    -0.02981996f, 0.18187886f, -0.00645328f, 0.03778651f, 0.08386375f, -0.05682753f, -0.06400362f, 0.08060973f, 
    0.29842815f, 0.21353641f, -0.02565309f, -0.29877111f, 0.16620159f, 0.34153777f, -0.09946525f, 0.13981746f, 
    -0.04199065f, -0.05225457f, 0.09181350f, 0.00574589f, -0.05808099f, -0.08324008f, -0.31062195f, -0.06202612f, 
    -0.02843168f, 0.07478023f, 0.12209760f, 0.16730100f, -0.01875110f, -0.11632492f, -0.00538945f, 0.23007216f, 
    -0.17713323f, -0.19479923f, 0.10009243f, -0.18872693f, 0.01551437f, -0.24484205f, -0.22565240f, -0.11358510f, 
    -0.08227434f, 0.18500574f, 0.11266220f, 0.04280712f, -0.22006142f, 0.12177116f, -0.03349302f, 0.17315884f, 
    0.13363300f, 0.14291310f, 0.08677268f, 0.02075415f, -0.06477153f, 0.30559647f, 0.29919475f, 0.11697219f, 
    -0.02763709f, -0.07095101f, -0.05659229f, -0.02504550f, -0.18301640f, 0.09870379f, 0.17210966f, -0.22938909f, 
    0.21980458f, 0.12021416f, -0.16379300f, 0.07534737f, -0.11201327f, -0.06809956f, -0.16529006f, -0.05059099f, 
    0.15497114f, -0.20716606f, -0.09733325f, -0.24580088f, 0.01858183f, 0.20042896f, 0.07849412f, 0.21239458f, 
    -0.11198768f, 0.10818784f, -0.08127601f, 0.30104777f, -0.07457229f, 0.10732119f, 0.32664996f, -0.07694335f, 
    -0.06227116f, -0.15959787f, -0.04322977f, -0.13100329f, -0.00104760f, 0.03059346f, 0.09800816f, -0.21394382f, 
    -0.33962333f, 0.03457283f, -0.18687837f, -0.13246033f, -0.30841240f, -0.03244545f, 0.13196652f, 0.07584379f, 
    -0.05738195f, -0.13395037f, 0.07525064f, 0.29420698f, -0.23380262f, 0.07216500f, 0.19724746f, 0.26128849f, 
    -0.28988665f, 0.34333661f, 0.09314718f, 0.25681579f, -0.11243710f, -0.12987110f, -0.02994947f, -0.19456109f, 
    0.05347332f, -0.01637365f, 0.26513696f, 0.03732504f, -0.15700319f, 0.19168496f, 0.17357349f, -0.15617448f, 
    0.01239799f, 0.21783109f, 0.25973085f, -0.07152238f, -0.12123242f, -0.04599414f, -0.13441868f, 0.03720128f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.15588653f, 0.08241767f, -0.01735115f, -0.09228186f, 0.01171008f, 0.16126443f, 0.22663651f, -0.01478321f, 
    -0.06255564f, -0.16242716f, -0.06488779f, -0.01978454f, 0.12383375f, 0.16121727f, 0.08519602f, 0.09928152f, 
    0.05406342f, 0.07690314f, 0.06644251f, 0.21474215f, 0.02558252f, -0.01843891f, -0.03403548f, 0.04179550f, 
    0.11030064f, 0.02078969f, 0.24630059f, -0.13360609f, -0.02394155f, -0.06816121f, 0.13262235f, 0.05235879f, 
    0.13749288f, -0.07065262f, -0.10105634f, 0.07486243f, 0.08840216f, 0.06853192f, -0.14207704f, 0.28585231f, 
    -0.00668298f, 0.22930998f, 0.27959517f, 0.10581934f, 0.07543772f, -0.05197156f, 0.15771943f, 0.11660523f, 
    0.21069948f, -0.03406353f, 0.06420103f, -0.20128819f, 0.14968058f, 0.07728257f, -0.05150796f, 0.03382395f, 
    0.05434001f, 0.08174425f, 0.10588297f, -0.05684827f, 0.21914022f, 0.20731501f, -0.02595067f, 0.00245110f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.08363371f, -0.17185828f, 0.21093400f, -0.02320757f, -0.21698034f, 0.21550004f, -0.42311585f, -0.10483325f, 
    0.13495682f, 0.22422163f, 0.15612853f, -0.07860103f, -0.27133775f, 0.18252891f, -0.10718405f, 0.04463225f, 
    -0.08826537f, -0.09154221f, 0.01080555f, 0.00012529f, -0.04436072f, 0.22936524f, 0.20320067f, -0.05936161f, 
    -0.16815224f, -0.03628356f, -0.10666023f, -0.02699082f, 0.02733165f, 0.14508471f, 0.00094423f, -0.39565334f, 
    -0.51742101f, 0.12889254f, 0.01997803f, 0.17072712f, -0.08974899f, -0.00575988f, 0.03265517f, -0.37751648f, 
    0.18510111f, -0.37771118f, 0.01095462f, 0.20800716f, 0.20988455f, -0.06603090f, -0.51678687f, -0.24001221f, 
    -0.33839649f, -0.27523029f, 0.12990780f, 0.17618732f, -0.43039027f, -0.06120088f, -0.25122002f, -0.58474082f, 
    0.03029865f, 0.09018666f, -0.56313646f, -0.45944574f, 0.00345658f, 0.06254847f, 0.00734364f, -0.54021245f, 
    -0.18315645f, -0.05264439f, -0.65490341f, -0.02665451f, -0.21235892f, 0.17733805f, -0.49290010f, -0.59523785f, 
    -0.10632601f, 0.05305897f, -0.11840086f, 0.02887350f, 0.05204582f, -0.41456431f, 0.19185638f, 0.19557603f, 
    0.02386930f, -0.11987501f, 0.21824752f, 0.16826671f, 0.19706386f, -0.30430895f, 0.06328406f, 0.06027759f, 
    0.07700308f, -0.45470324f, 0.11863953f, 0.06005004f, -0.01397720f, 0.12007085f, 0.26661405f, -0.20348009f, 
    0.00847723f, 0.11159673f, 0.06746744f, 0.03160022f, 0.30002826f, -0.12752628f, -0.15843193f, 0.13269579f, 
    -0.03673998f, 0.07149018f, 0.05403702f, 0.09324221f, -0.01717290f, -0.06721214f, -0.36407188f, 0.07267443f, 
    0.05125583f, 0.15559402f, 0.06372987f, -0.71185988f, 0.20351477f, -0.11888804f, 0.21361154f, 0.00962472f, 
    -0.01666475f, 0.14416263f, -0.32432425f, 0.13558669f, 0.22619624f, 0.12813336f, -0.04395064f, -0.23456727f, 
    -0.06176166f, -0.06008829f, -0.48172385f, 0.00643927f, 0.05806422f, 0.16280049f, 0.14645453f, 0.08293291f, 
    0.01788809f, -0.14836775f, 0.08390046f, -0.09780106f, 0.06464073f, 0.37747806f, 0.12146638f, 0.01950596f, 
    -0.28528911f, -0.15254571f, -0.35903060f, 0.20666894f, -0.45203835f, -0.37984064f, 0.01002310f, 0.07413726f, 
    0.13730438f, -0.13328649f, 0.30988762f, 0.00923154f, -0.05793223f, -0.07488414f, 0.11566186f, -0.07032393f, 
    0.10141034f, -0.62089884f, -0.01809549f, -0.19210827f, -0.50263906f, -0.04284927f, 0.16974680f, 0.17321506f, 
    0.02976241f, -0.11108791f, 0.19296022f, 0.02853438f, 0.20545754f, 0.04377324f, 0.20725706f, -0.41343090f, 
    -0.07314708f, -0.39239150f, 0.14735973f, 0.14083464f, -0.41653377f, -0.20284860f, -0.21539623f, 0.14591286f, 
    0.05381707f, -0.04975539f, 0.05048282f, -0.10729933f, 0.11114109f, 0.21344422f, -0.28195700f, 0.13985151f, 
    -0.43709764f, -0.29710349f, 0.26937637f, -0.18482117f, -0.27465141f, -0.12117106f, -0.14185783f, 0.20715839f, 
    -0.69761968f, 0.18571918f, 0.26739749f, -0.11214655f, -0.08292473f, -0.22682850f, -0.16322221f, -0.16708964f, 
    -0.18997668f, -0.20921241f, -0.01758003f, -0.08699466f, 0.07484116f, 0.12245957f, 0.13734622f, 0.08925014f, 
    -0.21998824f, -0.52410579f, 0.09588416f, -0.02978456f, -0.11411439f, 0.11422525f, -0.10738674f, -0.10355522f, 
    0.08903380f, 0.11924268f, 0.10523022f, -0.01326610f, -0.20370081f, -0.44831452f, -0.28094774f, -0.14394915f, 
    0.06601033f, -0.30957028f, -0.45024842f, 0.05973235f, -0.19971929f, -0.03399792f, 0.30535555f, -0.45849216f, 
    -0.20313925f, -0.28087434f, -0.11985905f, 0.10568912f, -0.21751384f, -0.11481957f, -0.27839264f, 0.13227513f, 
    0.21697490f, 0.22299121f, 0.10103796f, 0.25760114f, -0.32563102f, -0.15730366f, 0.06342873f, 0.23060383f, 
    -0.22185113f, 0.08249654f, -0.00348073f, 0.01244553f, 0.45006627f, 0.05747215f, 0.17051476f, 0.15997830f, 
    -0.52888143f, -0.08328640f, 0.10636074f, 0.03979170f, 0.08975647f, -0.12000731f, 0.14318319f, -0.08437504f, 
    -0.09426919f, 0.07259247f, -0.12986644f, -0.03285966f, 0.11665726f, 0.17044066f, 0.16635928f, -0.19019155f, 
    -0.02025767f, 0.21260789f, -0.02529035f, -0.15549633f, -0.09655212f, 0.11859457f, 0.15067492f, -0.04100844f, 
    -0.01375723f, 0.12675957f, 0.06275554f, -0.10039160f, 0.03614493f, 0.20778446f, -0.19638273f, -0.16434883f, 
    0.01974933f, 0.01882194f, 0.07634027f, 0.12041998f, -0.01519282f, 0.13018711f, -0.03820782f, 0.20655039f, 
    -0.37128645f, -0.05468290f, 0.18139915f, 0.13642393f, -0.05098644f, 0.02561796f, 0.25137180f, -0.30273423f, 
    0.04134513f, -0.23264760f, -0.16676345f, 0.31355390f, -0.30491027f, -0.12361564f, -0.41841891f, -0.39595321f, 
    0.31940895f, 0.15149261f, 0.08126289f, 0.01643752f, -0.29682225f, 0.14912492f, 0.11071935f, -0.32206881f, 
    -0.12635617f, 0.02661382f, -0.26540655f, 0.07294589f, 0.12656386f, -0.09283068f, 0.05922987f, 0.10422431f, 
    -0.31591371f, -0.12124261f, -0.03588539f, -0.18090388f, -0.02859978f, 0.03141512f, 0.05748405f, -0.12916242f, 
    0.05763413f, 0.01894952f, -0.25974235f, 0.06396370f, 0.00522037f, 0.05757774f, 0.07231625f, 0.24680755f, 
    0.04492283f, 0.07466337f, 0.04898227f, 0.19661701f, -0.05609218f, -0.06143600f, -0.12852110f, -0.11005796f, 
    -0.01714082f, 0.25850159f, -0.19862457f, 0.18685649f, 0.10883933f, -0.04770152f, -0.50384623f, 0.10859179f, 
    0.15561521f, -0.04881377f, -0.02834051f, -0.22810151f, -0.21790811f, 0.12960200f, 0.01931680f, 0.06914304f, 
    0.04498348f, -0.17890267f, 0.22125132f, -0.38680291f, -0.13133946f, 0.10083551f, 0.17940809f, -0.35978508f, 
    0.30406567f, -0.04837055f, -0.36021462f, -0.19989841f, -0.18876235f, 0.07610407f, 0.20470600f, 0.09399626f, 
    0.04304059f, -0.19497660f, -0.06059592f, 0.06649088f, 0.05806702f, 0.43268684f, -0.43127716f, 0.13150519f, 
    0.20167556f, -0.10375334f, -0.32104918f, 0.18993390f, -0.35473740f, -0.21090604f, -0.13366778f, -0.48514354f, 
    -0.23630367f, 0.18512973f, -0.08585243f, -0.05979455f, 0.03210159f, -0.02853400f, -0.48371425f, 0.07875022f, 
    0.04751312f, -0.29589149f, -0.04033925f, -0.62891954f, 0.28961226f, 0.00475812f, -0.10147827f, 0.15632305f, 
    -0.52563787f, 0.10134953f, 0.26704389f, -0.34712270f, 0.14367574f, -0.03353494f, 0.18322298f, -0.12581107f, 
    0.10751688f, -0.18525246f, -0.45431075f, -0.22897074f, -0.17145245f, -0.24991158f, -0.32707211f, -0.21095611f, 
    -0.56388032f, 0.19093525f, 0.17606048f, 0.15711151f, -0.05933219f, 0.24004583f, -0.51415032f, 0.04001669f, 
    0.05152079f, -0.02007521f, 0.15004985f, -0.01965886f, -0.03946068f, -0.44097576f, 0.06903449f, 0.15348835f, 
    -0.09685557f, 0.16101553f, 0.16762044f, -0.05004513f, -0.39992225f, 0.04871995f, -0.22521968f, 0.13071214f, 
    -0.09266346f, 0.16863573f, -0.03024719f, -0.28025654f, -0.19169408f, 0.13978358f, -0.29625991f, -0.33910426f, 
    0.20776254f, -0.18484017f, -0.33898118f, 0.01442640f, 0.11054319f, 0.06904238f, -0.55712491f, -0.08862583f, 
    0.06438556f, -0.40573701f, 0.10567123f, 0.34195843f, -0.01163799f, 0.18226328f, 0.32883874f, 0.02402421f, 
    -0.25105825f, -0.44359913f, 0.04794112f, 0.01110012f, 0.24865623f, -0.05805169f, 0.02796197f, 0.19120906f, 
    -0.02784725f, -0.05909438f, -0.39140630f, 0.30548534f, 0.20687366f, -0.03851040f, 0.06391492f, 0.15902813f, 
    0.08663767f, -0.05132998f, -0.05697043f, 0.06892448f, -0.07526173f, -0.28165296f, 0.21218538f, 0.09913168f, 
    -0.03692246f, 0.04999212f, 0.23922814f, -0.24858446f, -0.01013748f, 0.00703080f, -0.10747533f, -0.37522936f, 
    -0.01514942f, 0.30826604f, -0.11411229f, 0.04204290f, -0.14203194f, 0.26331434f, 0.04798416f, -0.27724621f, 
    -0.13503696f, -0.34883380f, 0.17783287f, -0.35789692f, -0.40460530f, -0.50184810f, -0.54183871f, 0.27612820f, 
    -0.21670374f, 0.11551514f, 0.20558749f, 0.10087325f, 0.02396537f, -0.13764861f, -0.27334133f, 0.06827874f, 
    -0.05443146f, -0.25933751f, -0.09522378f, 0.01341271f, -0.24643604f, -0.04855548f, 0.28522059f, 0.00570711f, 
    0.13548326f, 0.10555676f, 0.20341274f, -0.11907576f, -0.50013298f, -0.10074037f, 0.07987841f, -0.55041635f, 
    0.21111441f, -0.09758887f, -0.57527006f, -0.14987804f, 0.08654775f, 0.11536718f, 0.02633865f, 0.13422497f, 
    0.16171031f, -0.07249176f, -0.00164126f, -0.21351336f, 0.27309111f, 0.09439228f, 0.30770671f, 0.09252302f, 
    0.26929724f, -0.21005958f, -0.40608484f, -0.13958883f, 0.20731561f, 0.07887086f, 0.17388111f, 0.03402032f, 
    0.03296228f, -0.61315078f, -0.08624709f, 0.14449520f, -0.30091482f, -0.33006293f, 0.40259165f, 0.08949276f, 
    0.02606515f, -0.19576553f, -0.03464320f, 0.02199958f, -0.48790333f, 0.20235600f, -0.18192777f, -0.38047314f, 
    0.18729219f, 0.28864393f, -0.37810355f, -0.05317473f, 0.08717848f, -0.06879418f, 0.08805447f, 0.08604975f, 
    -0.05197648f, -0.38780895f, -0.07842613f, 0.00446522f, -0.19449446f, 0.18766956f, 0.08587632f, 0.04040014f, 
    -0.08914266f, 0.16422158f, 0.10419506f, -0.31845066f, 0.21088402f, -0.05987075f, 0.09865373f, -0.41320658f, 
    0.11795062f, 0.07956870f, 0.18154523f, 0.30298439f, 0.27319726f, -0.07710727f, 0.01374358f, -0.03017463f, 
    -0.31877002f, -0.68024296f, 0.15040287f, -0.01922569f, -0.17773736f, 0.14541468f, -0.41919360f, -0.09657730f, 
    0.21846876f, -0.16672049f, -0.23001310f, -0.05723030f, -0.34088379f, -0.07383017f, -0.09988172f, 0.01497020f, 
    -0.42481580f, -0.03199423f, -0.34991860f, -0.07543287f, 0.17112561f, -0.11909603f, -0.62989146f, -0.26712093f, 
    0.19543040f, -0.20140710f, 0.36457756f, 0.19043116f, 0.22870789f, 0.10414075f, -0.00522682f, -0.08468965f, 
    0.33110577f, -0.09819976f, -0.15312375f, -0.07126083f, 0.02574265f, -0.69121361f, -0.31575593f, 0.21211497f, 
    -0.13793147f, 0.16925684f, -0.09312980f, -0.43122843f, -0.00752115f, 0.16136916f, -0.20284657f, 0.22071955f, 
    0.21334738f, -0.01577366f, -0.18693326f, 0.15378100f, -0.38110220f, 0.07328178f, 0.25072780f, -0.42905447f, 
    -0.01442227f, -0.44845238f, -0.10860107f, -0.40354368f, -0.23695718f, 0.29737759f, -0.45567915f, 0.13470279f, 
    -0.16600598f, 0.35405898f, 0.31645018f, -0.27103347f, 0.06852711f, -0.11532789f, 0.08445290f, 0.01522095f, 
    -0.17971624f, -0.31353864f, -0.05941673f, -0.28544226f, 0.07650030f, -0.48054281f, -0.24846704f, -0.13689220f, 
    -0.43820107f, -0.25553712f, -0.25883818f, 0.08015334f, 0.27792802f, -0.23940191f, 0.11201955f, -0.04186817f, 
    0.42044911f, -0.04067333f, 0.18599387f, 0.09829955f, 0.12243616f, -0.41316891f, 0.16089214f, 0.27281636f, 
    -0.46000087f, -0.09475543f, 0.25616729f, 0.04997906f, -0.05158548f, 0.01195686f, -0.00807393f, 0.04628824f, 
    0.16947746f, 0.10334857f, -0.11347261f, -0.41636485f, 0.03732200f, -0.25279766f, -0.39002365f, -0.06359027f, 
    -0.32097605f, 0.09306691f, 0.19516395f, -0.43690476f, -0.71344507f, -0.11198153f, 0.10804465f, 0.04407718f, 
    0.12657213f, 0.40830648f, -0.06609292f, -0.17600811f, -0.05672701f, -0.10060222f, -0.20781820f, 0.30082351f, 
    0.24456249f, -0.27454659f, -0.02689114f, -0.01210999f, -0.12576480f, -0.12251268f, -0.22571665f, 0.02314679f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.11054295f, 0.10100006f, 0.11441298f, -0.23536026f, 0.08284985f, 0.15538165f, 0.10926187f, -0.05338249f, 
    0.16994488f, 0.01983627f, 0.05875479f, -0.09081528f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
