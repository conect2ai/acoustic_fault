#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.81068885f, -1.05738688f, 1.04890788f, 0.74482787f, 0.32858634f, 0.85021329f, 0.05669834f, 0.12821917f, 
    0.19297910f, -0.24588110f, -0.73990065f, 0.12773371f, -0.32289669f, -1.05426705f, -0.58274865f, 0.59320432f, 
    0.72593343f, 0.02302119f, -1.28195286f, 0.47424778f, 0.90552229f, 0.37287194f, -0.34421563f, -0.60752219f, 
    0.01034850f, -0.27645454f, -0.28513858f, -0.25915426f, -1.11042452f, -0.53068274f, -0.07535585f, -0.17451583f, 
    0.76242733f, -0.46711671f, -0.25814873f, -0.16103312f, -0.64310783f, 0.55032068f, 1.04036725f, -1.28857946f, 
    0.72112751f, 0.45032936f, -0.04703943f, 0.34563652f, 0.14152549f, -0.54423261f, 0.08889478f, -0.42597830f, 
    -0.83606005f, -0.50843728f, -1.03027058f, -0.15152837f, -0.36745366f, 0.16163853f, 0.99184537f, -0.04617986f, 
    0.96980405f, 0.91214228f, 0.50420660f, -0.54334921f, 0.32892653f, 0.07793409f, -0.19165863f, -0.73195422f, 
    0.92837185f, -0.82871699f, 0.94529235f, -0.41598785f, -0.60005516f, 0.33107406f, -0.13055453f, -0.33309099f, 
    -1.09153724f, -0.29302666f, -0.57082623f, 0.37873241f, -0.33947110f, -0.34764418f, -0.27954146f, 0.29769894f, 
    -0.03053416f, 0.00639723f, -0.35692230f, -0.81603539f, 0.74799085f, -0.98500758f, 0.29232502f, -0.27915817f, 
    0.12521093f, 0.64435363f, 0.97128707f, 0.24801944f, 0.17266244f, 0.72018445f, 0.83344537f, 0.63008893f, 
    -0.63788074f, -0.14275016f, -0.21157905f, -0.67160904f, -1.05247247f, -0.53240705f, 0.90581578f, 0.97990650f, 
    0.35950020f, -0.35109824f, -0.39610687f, -0.02541213f, -0.86456746f, 1.23589373f, -0.15375708f, -0.35977089f, 
    0.68163657f, -0.62027586f, 0.11701626f, -0.12400272f, 0.71188366f, 0.94491172f, 0.69521117f, 1.23225796f, 
    -0.89095753f, -0.66888928f, -0.54638046f, 0.07961378f, -0.06738830f, -0.35434547f, -0.03449518f, -1.35882008f, 
    -0.81997716f, 0.37828395f, 0.55732048f, -0.32390440f, -0.40400195f, 0.75713152f, -0.15011029f, 0.90802997f, 
    -0.83186209f, -1.00610626f, -0.83836544f, -0.41592231f, -0.51512837f, -0.09225133f, -0.03099115f, 0.42386132f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.40670574f, 0.17095374f, -0.13074189f, -0.01145267f, 0.29018700f, 0.34493145f, 0.13447067f, 0.08779819f, 
    0.01106975f, -0.03396017f, 0.06340570f, 0.12854782f, 0.18447495f, 0.00507953f, 0.40281966f, 0.43339854f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00046908f, -0.00916051f, -0.04213348f, -0.01775060f, -0.03992072f, 0.01200281f, 0.00511287f, 0.03925944f, 
    -0.02754631f, 0.03582884f, 0.01943843f, -0.04970679f, 0.02164067f, 0.03472141f, -0.04297855f, 0.00355314f, 
    0.02071738f, 0.03857667f, -0.04154896f, -0.00591491f, -0.00732998f, -0.04573308f, -0.04442142f, -0.01746873f, 
    0.03563968f, -0.06059666f, -0.00986720f, 0.01226445f, -0.01977206f, 0.02820091f, 0.03737105f, 0.01239557f, 
    0.04939244f, 0.01994941f, -0.00499182f, -0.02542006f, -0.05107392f, 0.00340190f, -0.00096579f, -0.00875190f, 
    0.04234013f, -0.02005541f, -0.00935760f, -0.03615302f, -0.02444456f, -0.03805547f, -0.02320757f, 0.00800200f, 
    0.02609559f, 0.02491700f, -0.01206037f, -0.04578966f, 0.04783569f, -0.02762852f, -0.06220397f, -0.05139576f, 
    -0.02851418f, 0.00332937f, 0.03170481f, 0.03678107f, -0.02359547f, -0.01019015f, 0.00831923f, 0.03172494f, 
    -0.04822177f, -0.01455103f, -0.01687902f, 0.02535197f, -0.03237597f, 0.01672008f, -0.05930022f, 0.01897674f, 
    -0.04678872f, -0.04840665f, -0.00718145f, -0.02957113f, -0.01664354f, 0.01706909f, 0.00475616f, 0.03123805f, 
    0.01467681f, -0.02813762f, -0.00182080f, 0.04724749f, 0.02090452f, -0.01139747f, -0.00139013f, 0.01843684f, 
    -0.01121742f, -0.05607173f, -0.00158781f, 0.01332756f, 0.02402018f, 0.03614704f, -0.03439111f, -0.02787998f, 
    -0.00033395f, 0.04143047f, 0.03912184f, 0.04295100f, -0.04873338f, -0.05823846f, -0.04468362f, -0.00767154f, 
    -0.00225328f, 0.00206683f, -0.04167827f, 0.00018406f, -0.05600707f, -0.05208755f, -0.01521580f, 0.02919241f, 
    -0.05558804f, -0.05961237f, -0.04520132f, -0.03099790f, -0.03890428f, -0.01486058f, -0.03705553f, -0.00365292f, 
    0.01474674f, 0.02015422f, 0.04316813f, 0.04401129f, 0.01707006f, -0.00474202f, 0.01164488f, -0.00386976f, 
    0.04275527f, -0.04078118f, -0.02360222f, 0.01917517f, 0.03531208f, 0.00222131f, 0.03818788f, 0.03357785f, 
    0.03881939f, -0.01061625f, -0.04736359f, 0.03857113f, -0.00764979f, 0.00293485f, -0.03543524f, 0.01388884f, 
    -0.01925242f, -0.04862616f, -0.02479568f, -0.02624100f, 0.05399184f, 0.04204786f, 0.03770750f, 0.01233247f, 
    0.00594269f, 0.04594402f, 0.02893463f, -0.03813344f, -0.00335661f, 0.02251665f, -0.04443049f, -0.05271644f, 
    0.01481727f, 0.00409318f, 0.00945597f, -0.03631004f, -0.03571559f, 0.01222160f, -0.00913959f, -0.03971425f, 
    0.02528161f, -0.03143572f, -0.06353689f, 0.02618108f, 0.04321089f, -0.03822812f, 0.02426801f, -0.05769470f, 
    -0.04347707f, -0.06047525f, -0.01431730f, 0.00400236f, -0.00004845f, -0.04605039f, -0.04442457f, 0.02687739f, 
    -0.06294055f, -0.05041590f, -0.00767113f, -0.04453869f, 0.04452500f, 0.03653262f, 0.02625009f, 0.00864573f, 
    0.00215754f, -0.01520324f, -0.01540321f, 0.00925973f, -0.05170210f, -0.03647109f, -0.00783775f, -0.05634636f, 
    -0.00647191f, -0.04908527f, -0.04217480f, 0.01968143f, -0.02554088f, -0.03789487f, -0.03426172f, 0.01704718f, 
    0.02153585f, -0.01721123f, -0.04267502f, 0.02140087f, 0.04059723f, -0.05547944f, 0.01626195f, -0.00351087f, 
    -0.01616957f, 0.04314093f, -0.02817038f, -0.01871343f, -0.02549546f, 0.01388943f, -0.01395102f, -0.01913488f, 
    -0.02265675f, -0.04480775f, 0.02997441f, 0.02096560f, 0.03085044f, 0.01939742f, -0.00545414f, -0.02007503f, 
    0.02531755f, 0.00644013f, -0.02834454f, -0.04116195f, -0.05574247f, 0.02480117f, -0.00900070f, -0.02584160f, 
    0.02692318f, -0.04877510f, 0.02946439f, -0.00084541f, 0.03794979f, -0.03928897f, -0.03714905f, 0.01163464f, 
    -0.05662780f, -0.00883243f, 0.00200932f, 0.02247774f, 0.00638423f, 0.00471946f, -0.02156498f, 0.04483160f, 
    0.04165052f, 0.01865313f, 0.04308822f, 0.00610273f, 0.00044530f, 0.05083483f, 0.00161340f, 0.03168051f, 
    -0.06136285f, -0.00143961f, 0.02170757f, 0.00457238f, 0.03409233f, -0.02691413f, 0.00335917f, 0.04570137f, 
    -0.05214171f, 0.01265653f, -0.00246156f, 0.02247178f, 0.00318737f, -0.02132405f, 0.03626443f, 0.04662895f, 
    -0.00900721f, 0.00698711f, 0.00576827f, -0.05745256f, 0.00911246f, -0.03938811f, -0.03878826f, -0.00393854f, 
    -0.05499863f, -0.00089222f, 0.01361628f, 0.02566783f, -0.01081721f, -0.01719046f, -0.01188716f, -0.00826243f, 
    0.05252462f, 0.01116819f, -0.01119758f, 0.03705741f, 0.00419988f, 0.03858405f, 0.00550592f, -0.00327831f, 
    -0.02725138f, -0.06032161f, 0.02075225f, -0.05319444f, -0.05374159f, -0.05890319f, -0.05873517f, 0.02883572f, 
    -0.05148664f, -0.04696850f, -0.00327745f, 0.01899712f, -0.03761076f, -0.04951246f, -0.00268271f, -0.02878769f, 
    0.30116838f, -0.26818344f, -0.14432347f, 0.11923623f, 0.04715233f, 0.01672634f, -0.03093261f, -0.06176065f, 
    -0.06109484f, 0.10338041f, 0.01776818f, 0.10577451f, 0.09962265f, 0.07681794f, 0.10291284f, -0.02412138f, 
    0.02251416f, 0.10765585f, -0.04769806f, -0.01787556f, 0.30656081f, 0.49909666f, -0.16535857f, -0.23495868f, 
    -0.02109267f, 0.07181463f, -0.02390249f, 0.11911014f, 0.04983173f, 0.01127782f, -0.10989451f, 0.04418549f, 
    -0.04413665f, 0.03925064f, -0.04157263f, 0.13795386f, -0.01516536f, -0.03172243f, -0.06727198f, 0.12806445f, 
    -0.08253025f, -0.31629828f, -0.07019837f, 0.13611403f, 0.15209796f, 0.25325221f, 0.07627800f, -0.03870787f, 
    0.16991910f, -0.04453655f, 0.00203478f, -0.05113840f, 0.09788996f, -0.18670048f, 0.05157251f, -0.04580387f, 
    -0.02162265f, -0.02451301f, 0.08913194f, 0.04021836f, 0.04606701f, -0.10783634f, 0.04061849f, -0.36425731f, 
    0.11627764f, -0.01321511f, 0.00249423f, 0.17574535f, -0.11499496f, -0.04467765f, -0.05958445f, 0.03115036f, 
    -0.09288943f, 0.00056319f, 0.06555887f, -0.05469713f, 0.00858533f, 0.04178352f, -0.03889727f, 0.08779597f, 
    0.34686804f, -0.07013521f, 0.15295318f, -0.12690075f, -0.18944237f, 0.16648753f, 0.08190683f, -0.05291316f, 
    -0.03861546f, -0.03072783f, 0.03978945f, 0.11089138f, -0.01538025f, 0.02664272f, 0.02831670f, 0.09547848f, 
    -0.00072488f, 0.11171250f, -0.09399848f, 0.12243058f, 0.12785766f, 0.34144339f, -0.14162554f, -0.18112196f, 
    0.10179146f, 0.10454061f, 0.03672084f, 0.11526289f, 0.09195478f, 0.05932536f, -0.06885851f, -0.04070396f, 
    -0.00665058f, -0.10920319f, 0.07221871f, 0.03585901f, 0.01491998f, 0.02755038f, -0.00296559f, 0.06051814f, 
    -0.07899175f, -0.14581430f, -0.00415480f, 0.19296610f, 0.02955643f, 0.05418284f, 0.00208217f, -0.01815745f, 
    -0.11724893f, -0.09536815f, -0.12807779f, -0.07037586f, 0.17566033f, -0.07424539f, 0.05792533f, 0.04714373f, 
    0.28090981f, 0.01036244f, 0.10192754f, -0.01647855f, -0.34997028f, 0.16751422f, -0.05712595f, 0.04021727f, 
    0.15939008f, 0.12429337f, 0.10938164f, -0.15435776f, 0.05450970f, -0.01190558f, -0.02052248f, 0.13373624f, 
    -0.04032630f, -0.02896169f, 0.07649364f, 0.03491187f, -0.05556243f, 0.05427098f, 0.00347690f, 0.02940104f, 
    -0.31859475f, 0.17304061f, -0.18247512f, 0.16126667f, 0.11293148f, -0.04918905f, 0.07822844f, 0.13138527f, 
    -0.07292319f, -0.03433718f, -0.02408898f, 0.20473678f, 0.09266794f, 0.15544727f, 0.05115860f, 0.08695882f, 
    0.03364107f, -0.06746826f, -0.04920424f, 0.04631377f, -0.26917267f, 0.31331229f, 0.11820061f, -0.15574123f, 
    -0.06942739f, 0.01935531f, -0.05923953f, -0.02821819f, -0.05525540f, 0.00102052f, 0.08267891f, -0.07642300f, 
    0.14250611f, 0.05337880f, -0.11718853f, -0.06625165f, 0.04302356f, -0.16883482f, 0.14767759f, 0.04500050f, 
    -0.06798496f, -0.09273753f, -0.04370250f, 0.02456270f, -0.05756435f, -0.13576099f, 0.05648708f, 0.04450476f, 
    0.00117051f, -0.03348355f, 0.02498046f, -0.04135911f, -0.00729606f, 0.02871466f, 0.01650932f, -0.06530940f, 
    -0.06720794f, 0.12336088f, 0.11148715f, -0.05696082f, 0.46540302f, -0.18172313f, -0.17837602f, -0.14554146f, 
    -0.03340579f, -0.07814426f, -0.03593485f, -0.03755074f, -0.09753701f, -0.03732463f, 0.00463514f, 0.17219776f, 
    0.09081835f, -0.06045605f, 0.00325942f, 0.07944704f, -0.04724629f, -0.08514829f, -0.11166982f, -0.03019293f, 
    0.03702786f, -0.05620647f, -0.18322173f, 0.17522632f, 0.04844221f, 0.03619491f, -0.02430713f, -0.06575084f, 
    0.21052659f, 0.00437595f, -0.06184698f, 0.04025755f, 0.06811666f, -0.08529462f, -0.04506820f, 0.11658388f, 
    0.09592141f, -0.03298678f, 0.18798381f, 0.08308990f, -0.28397605f, 0.10318944f, 0.06702823f, -0.07856137f, 
    -0.15996012f, 0.11214662f, 0.14913683f, -0.00620963f, 0.00621743f, -0.02840132f, -0.03441284f, -0.10712680f, 
    -0.00490312f, -0.05558740f, -0.01953922f, -0.04063749f, -0.01877661f, -0.06040745f, 0.00284884f, -0.14705458f, 
    0.16577606f, -0.22683617f, -0.23004189f, -0.09270007f, 0.10226875f, -0.01011871f, 0.21005844f, 0.05398949f, 
    0.02402976f, -0.02715064f, 0.06918938f, -0.02720295f, -0.06972568f, 0.10793933f, 0.00144940f, 0.09074030f, 
    0.04845533f, -0.07303219f, 0.06210589f, -0.01132983f, -0.19079480f, 0.10572527f, -0.03656378f, -0.35273826f, 
    0.21023920f, 0.03498845f, 0.02736442f, -0.04929986f, -0.00230745f, 0.04945525f, 0.09720116f, 0.05914559f, 
    -0.05058847f, 0.05399623f, -0.02540665f, 0.06681961f, 0.00368364f, -0.05472352f, -0.09236618f, 0.10089934f, 
    0.02644676f, 0.04170343f, -0.01228689f, -0.17050326f, 0.20818706f, -0.12302066f, -0.07813460f, 0.02235452f, 
    0.03424662f, 0.00950866f, 0.09939729f, -0.11723010f, -0.02613505f, -0.06286280f, 0.02017512f, -0.01078327f, 
    -0.12405499f, -0.01896596f, 0.09553552f, -0.00444134f, -0.00489589f, -0.03470369f, 0.04352395f, 0.02261527f, 
    0.02488564f, 0.06117627f, 0.03013694f, -0.02950479f, -0.00154902f, 0.08789048f, 0.01866036f, -0.11154137f, 
    0.01049208f, -0.01411107f, -0.03290779f, -0.11999014f, -0.07812459f, 0.11059825f, 0.01124724f, -0.05712384f, 
    0.60029370f, 0.19392678f, -0.19620258f, -0.16197126f, -0.05989156f, 0.05857175f, 0.08476841f, -0.00981065f, 
    -0.00631811f, -0.00148565f, -0.03197208f, 0.17150436f, -0.10163725f, -0.09441401f, 0.02724096f, -0.00189360f, 
    0.00709340f, 0.02796626f, 0.01478508f, 0.06737448f, -0.08223197f, -0.17319299f, 0.22365056f, 0.27836242f, 
    0.31349039f, -0.01555964f, -0.04324821f, 0.02278733f, 0.10966729f, 0.13420460f, 0.05987393f, 0.09026236f, 
    0.00126556f, -0.07360921f, -0.14592439f, -0.15589075f, -0.06672858f, -0.08906736f, 0.04638089f, -0.09612232f, 
    0.12897852f, 0.16006161f, -0.29462782f, -0.07264398f, -0.06155726f, -0.01901422f, 0.01170675f, 0.07403679f, 
    -0.15775371f, -0.00715701f, -0.04767887f, -0.10628786f, -0.10287192f, -0.07124408f, -0.05195945f, 0.05108392f, 
    -0.00177997f, -0.14528313f, 0.05364475f, -0.09777788f, -0.03872387f, 0.00784647f, -0.01401075f, 0.07483847f, 
    -0.00399307f, 0.08892448f, 0.08671655f, -0.08389759f, 0.01968570f, -0.11367667f, -0.04920486f, -0.04559281f, 
    -0.02997249f, -0.00069877f, 0.03812324f, -0.05758730f, -0.03462302f, -0.02861002f, -0.02006054f, -0.06632378f, 
    -0.39157259f, 0.09235620f, 0.00092038f, -0.13283432f, 0.04346259f, -0.05316959f, -0.00701543f, -0.06257117f, 
    0.01332013f, 0.05164046f, -0.00653329f, -0.02960625f, 0.01927461f, -0.03613544f, 0.08979633f, 0.03698368f, 
    -0.08499052f, 0.02078868f, -0.11210869f, 0.00145207f, 0.21434036f, 0.27783781f, -0.02332242f, 0.12454607f, 
    -0.11113714f, 0.09954734f, -0.13794312f, 0.12347950f, -0.05296104f, 0.00563982f, -0.09008799f, 0.00956040f, 
    0.03244884f, -0.03671949f, -0.04367962f, 0.00900394f, -0.05098512f, 0.11689398f, -0.01949745f, 0.04899940f, 
    0.19564298f, 0.18008016f, 0.28614640f, -0.24010383f, 0.14137056f, 0.03621527f, -0.08406740f, -0.01174268f, 
    0.17805077f, 0.02326913f, -0.05341139f, -0.02226991f, 0.02793696f, -0.00543044f, 0.00080875f, -0.13861398f, 
    0.11438628f, -0.01452262f, 0.07953167f, 0.03089244f, 0.04728783f, 0.24746697f, -0.00046393f, 0.19039926f, 
    0.04434042f, -0.10635138f, -0.15965113f, 0.02161303f, 0.05011197f, 0.12785552f, -0.05375165f, -0.06670160f, 
    -0.21081446f, -0.18356313f, 0.08748487f, -0.01676064f, -0.04863432f, 0.14226367f, 0.02358353f, -0.13324384f, 
    -0.12825689f, -0.06445275f, 0.17327221f, -0.09480970f, -0.14796878f, -0.03489427f, -0.07562678f, 0.00202864f, 
    0.12987030f, 0.08788164f, -0.03603347f, -0.05784537f, 0.05107145f, -0.01706335f, 0.01718919f, -0.16671295f, 
    -0.05216156f, -0.09059174f, -0.03047696f, 0.00880580f, -0.16454220f, 0.01632519f, 0.14101402f, 0.15515624f, 
    0.24316131f, -0.11002804f, -0.01427428f, 0.02088583f, 0.07206946f, -0.02336354f, 0.16819394f, 0.02651206f, 
    0.06152650f, 0.12891260f, 0.02457042f, -0.06233173f, -0.01150390f, 0.06140749f, 0.13865274f, 0.08638328f, 
    -0.15159985f, 0.09100720f, 0.09292398f, -0.01341914f, -0.20680396f, 0.18650486f, -0.06711934f, -0.03909016f, 
    -0.05538419f, 0.01882046f, 0.01910765f, 0.16982055f, 0.00386907f, -0.01242942f, -0.02373960f, -0.05246599f, 
    0.02131564f, 0.01643316f, -0.14398871f, -0.03532054f, -0.26122075f, -0.09400844f, -0.14380881f, 0.15484032f, 
    0.13976315f, 0.22272883f, 0.10515760f, -0.00506494f, -0.05952891f, -0.08355411f, 0.00023632f, 0.14404482f, 
    0.03544764f, -0.03291334f, 0.07196178f, 0.19460520f, -0.01627004f, -0.00679042f, -0.04752337f, 0.06239969f, 
    0.11340880f, 0.01841605f, 0.38865399f, -0.05191554f, 0.11210261f, -0.05840730f, -0.03787636f, -0.05221006f, 
    0.10823754f, 0.00027084f, -0.01877602f, -0.07101283f, -0.00617132f, 0.02345354f, 0.00453125f, -0.01888095f, 
    -0.02386557f, 0.05798708f, 0.10527094f, -0.05862177f, 0.28906661f, 0.13079837f, -0.09173326f, 0.07312297f, 
    -0.13502827f, -0.03304716f, 0.03485632f, 0.05121721f, 0.01670166f, -0.07696433f, 0.01556008f, -0.01710054f, 
    -0.00303286f, -0.06698110f, -0.02195571f, 0.05465425f, 0.03453400f, 0.07958534f, 0.14681248f, 0.04520253f, 
    0.04377474f, 0.14157748f, 0.01323237f, -0.19004586f, 0.04221420f, -0.02262259f, -0.01928276f, -0.08275719f, 
    0.03229614f, -0.02680117f, -0.06908489f, 0.02184434f, 0.07376935f, -0.07080892f, -0.02543265f, -0.06562895f, 
    -0.02597904f, -0.07975727f, -0.01413990f, -0.00689931f, 0.22393265f, 0.12922421f, 0.08079332f, 0.05613832f, 
    0.08164956f, 0.06843676f, 0.01618179f, -0.03759281f, -0.04308382f, 0.06878958f, -0.05410900f, 0.04796135f, 
    -0.02875098f, -0.05610761f, -0.05218039f, -0.09853119f, -0.00182792f, -0.09950716f, 0.11207743f, -0.02128705f, 
    0.11167682f, 0.41930309f, -0.11859517f, 0.08881009f, 0.09151740f, 0.10262793f, 0.09396280f, -0.02205768f, 
    0.06267995f, -0.04130979f, -0.04363961f, 0.10033205f, 0.02524024f, 0.09276082f, 0.05007287f, 0.01219984f, 
    0.02918904f, -0.08167353f, 0.04177633f, -0.06263353f, 0.27762827f, -0.01429987f, 0.14801963f, 0.34916389f, 
    0.05681778f, 0.02971503f, 0.02592574f, 0.02734045f, 0.12563418f, 0.01932336f, 0.12988877f, 0.14336848f, 
    -0.01421796f, 0.02010983f, -0.03714646f, 0.07668527f, -0.00585697f, -0.02852727f, -0.11274321f, 0.08628604f, 
    -0.24912322f, 0.15346405f, -0.01583223f, 0.01851484f, 0.10457239f, -0.04915876f, 0.06265738f, -0.02715946f, 
    -0.02115654f, 0.06807000f, -0.08477051f, -0.05775743f, -0.02026563f, -0.00650955f, 0.10543605f, -0.02179821f, 
    0.05266663f, -0.14204939f, -0.02667001f, -0.00587739f, 0.22043116f, 0.04899040f, 0.10807034f, 0.13111161f, 
    0.17332998f, 0.14366528f, 0.05887640f, -0.01413427f, 0.03801705f, -0.14204726f, 0.05215968f, 0.10819966f, 
    0.04377494f, -0.01029755f, -0.06195197f, 0.06042260f, 0.01522478f, 0.00459870f, 0.01297956f, 0.05517899f, 
    -0.37597764f, -0.09538522f, -0.36649954f, -0.23067284f, -0.18997625f, -0.02810351f, -0.13185908f, -0.00556200f, 
    0.00281875f, -0.10037106f, 0.04484932f, -0.05497243f, -0.10592715f, 0.07843421f, -0.05966909f, -0.06390351f, 
    -0.15277794f, 0.04562144f, -0.01310226f, -0.04266751f, 0.16138308f, 0.12070302f, -0.04446729f, 0.10141337f, 
    0.06449871f, 0.06834807f, -0.03404383f, 0.00550611f, 0.00737745f, -0.02234257f, -0.03743025f, -0.07797123f, 
    -0.04095088f, -0.07983623f, -0.13883726f, 0.01215436f, -0.03144278f, 0.03031659f, 0.02715638f, -0.01222320f, 
    0.25592032f, 0.16510002f, 0.13962145f, 0.10915048f, 0.07030565f, 0.10243402f, -0.01572409f, -0.04381348f, 
    0.18785864f, 0.13683793f, -0.11002663f, -0.06972922f, 0.07755642f, -0.14635020f, 0.00189413f, -0.01445892f, 
    -0.02191057f, 0.02184777f, 0.08309519f, -0.01912604f, 0.26724473f, 0.20417318f, -0.04416854f, 0.25642720f, 
    0.21110947f, 0.06543110f, 0.01380531f, 0.06908028f, 0.09249137f, -0.04759687f, -0.03139329f, -0.03547335f, 
    -0.01262890f, -0.04130018f, 0.06586992f, 0.08638027f, 0.02998160f, 0.10575135f, -0.18014625f, -0.02740735f, 
    -0.36609778f, -0.18764338f, -0.21033706f, -0.20473143f, -0.41576183f, -0.08364995f, 0.02480839f, 0.06376923f, 
    -0.09393262f, 0.00762512f, -0.10141842f, -0.02595613f, -0.09276985f, -0.14281337f, -0.01524091f, -0.03114146f, 
    0.02140864f, 0.04474361f, -0.02183623f, 0.05610185f, -0.17856528f, 0.02917470f, 0.13348018f, 0.14408793f, 
    0.02562567f, 0.03352781f, -0.01322696f, 0.06597187f, 0.10876378f, 0.12113214f, -0.11148056f, 0.02197364f, 
    0.03164269f, -0.04738067f, -0.02876888f, -0.10028906f, -0.11704251f, 0.09441919f, 0.06576786f, 0.02888326f, 
    -0.00971715f, -0.09367706f, 0.00906992f, -0.02542670f, -0.15759256f, 0.07899711f, -0.05793498f, -0.03511872f, 
    0.09354696f, 0.07404640f, -0.01865211f, 0.08516212f, 0.00425297f, -0.05630031f, -0.00061083f, -0.00922805f, 
    -0.08285398f, -0.04949924f, -0.14194399f, -0.04542171f, 0.06949161f, -0.40243119f, -0.22526303f, -0.02839393f, 
    0.16328540f, 0.01998021f, -0.07956442f, -0.03656699f, -0.02496415f, -0.09196632f, -0.01117230f, 0.05100440f, 
    -0.00836638f, 0.02728151f, -0.10623439f, 0.03248694f, 0.01253066f, 0.04718775f, 0.07471216f, 0.03398911f, 
    0.01273172f, 0.11575414f, 0.19119261f, 0.21636683f, 0.09628194f, 0.02037857f, -0.09956101f, 0.00787183f, 
    0.09007532f, 0.01185639f, -0.03093968f, 0.03657447f, -0.04442550f, 0.04857973f, -0.01464952f, -0.00798625f, 
    -0.11035269f, 0.02401397f, 0.03766105f, 0.01300553f, 0.12437657f, 0.29963964f, 0.12981451f, 0.12716605f, 
    0.11771113f, 0.09134949f, 0.08748198f, -0.06199200f, -0.00987451f, -0.04987757f, 0.05653264f, 0.04335986f, 
    -0.03077140f, -0.04274207f, 0.01971480f, 0.01267613f, 0.08208813f, 0.14342125f, -0.04155508f, 0.05556056f, 
    0.39239240f, 0.01912221f, 0.11648247f, -0.01293987f, -0.08744373f, -0.03820498f, -0.02941222f, 0.01107230f, 
    0.01051420f, -0.09698968f, 0.07138298f, 0.05628376f, -0.06826200f, 0.00083187f, 0.00195719f, 0.00435380f, 
    -0.01929574f, -0.12605803f, 0.04484322f, 0.01183654f, 0.04877540f, 0.11167006f, 0.03209053f, 0.06985417f, 
    -0.20471941f, 0.01960862f, 0.12437377f, -0.11525026f, -0.13268568f, -0.00161395f, 0.00838575f, 0.00993647f, 
    -0.01829932f, -0.09783097f, -0.07581905f, -0.05396353f, 0.03634893f, -0.00041398f, 0.10018323f, -0.08677707f, 
    0.33108804f, 0.19142653f, -0.17699134f, 0.10080177f, 0.01218897f, 0.10265885f, -0.04520664f, -0.03890229f, 
    0.07798799f, 0.02131223f, -0.04565645f, 0.11849709f, 0.07984006f, 0.04646027f, -0.21800204f, 0.00306868f, 
    0.00914914f, -0.08079509f, 0.02780103f, -0.12354792f, 0.29759333f, -0.11721995f, 0.14809379f, 0.16677254f, 
    -0.14416757f, -0.02739288f, 0.01430716f, -0.07068913f, 0.06484035f, 0.07262430f, 0.07941356f, 0.05491303f, 
    0.01292623f, 0.05010563f, -0.00494707f, 0.02657707f, -0.00973191f, 0.04750136f, 0.04174368f, -0.01805383f, 
    -0.20929807f, 0.19454004f, -0.07140316f, 0.07469747f, 0.08906139f, -0.00240670f, 0.07627054f, 0.10647829f, 
    -0.07374838f, 0.02198756f, -0.07534186f, -0.04773832f, -0.02336936f, -0.03377960f, -0.00926430f, 0.07110250f, 
    0.10844200f, -0.13992906f, -0.02629605f, -0.05973632f, 0.00788580f, -0.03062372f, -0.03866274f, 0.09868339f, 
    0.00961320f, 0.12728314f, 0.01027862f, -0.00729014f, 0.02876884f, 0.03269343f, -0.06698866f, 0.02349987f, 
    0.04680564f, -0.00065530f, -0.04046060f, -0.00545949f, -0.02165888f, 0.00413634f, 0.07360218f, -0.01689028f, 
    -0.48799253f, -0.16780660f, -0.01759523f, -0.05913256f, -0.13302016f, -0.12612928f, 0.02353228f, -0.00401937f, 
    0.06782071f, -0.12542556f, 0.07902199f, -0.02696142f, 0.03871936f, 0.07912648f, -0.01090448f, -0.01125519f, 
    -0.02301612f, 0.10555402f, -0.06609756f, 0.10679040f, 0.29820922f, 0.19340101f, -0.07174954f, 0.03219472f, 
    0.18186609f, 0.06442071f, -0.03253496f, 0.11925390f, 0.04255839f, 0.00030375f, 0.03293626f, 0.04831774f, 
    -0.02005286f, 0.02999638f, 0.03647264f, -0.01933646f, 0.00311281f, 0.16174343f, 0.07066252f, 0.03272497f, 
    0.13701479f, 0.17937811f, 0.01178894f, 0.00578692f, 0.11879354f, -0.00987349f, -0.27208644f, -0.10345255f, 
    0.13609192f, 0.03166204f, -0.10029578f, -0.09817239f, 0.00466620f, -0.00058324f, 0.00673292f, -0.01990499f, 
    -0.03559830f, 0.05147752f, 0.13976885f, 0.12219936f, 0.15458463f, 0.24639231f, -0.02526788f, 0.22305809f, 
    -0.05541063f, -0.08024164f, -0.12078600f, -0.02035389f, -0.03100573f, 0.01170856f, -0.05631484f, -0.00121310f, 
    -0.10781090f, -0.06055594f, 0.10708256f, 0.11768080f, 0.11720783f, 0.17472309f, 0.05191704f, -0.02430053f, 
    -0.21696694f, -0.07036321f, -0.10281328f, -0.12367506f, -0.11161684f, -0.02982531f, -0.10038473f, -0.00674681f, 
    0.10691305f, -0.06325590f, -0.07351729f, 0.06563002f, 0.13795325f, -0.06237029f, -0.06743569f, 0.02444042f, 
    0.00247537f, 0.03810773f, -0.03501953f, 0.10210379f, 0.15938057f, 0.02868573f, 0.11772007f, 0.15313442f, 
    -0.06000163f, 0.00944086f, -0.16702136f, -0.00027758f, -0.00317705f, 0.07499050f, -0.03503902f, 0.09966679f, 
    -0.02498228f, -0.05513031f, 0.02656296f, 0.06272512f, -0.00458950f, 0.13249287f, 0.05676547f, -0.03557735f, 
    0.16152567f, 0.12064637f, -0.02078213f, -0.21011248f, -0.01237161f, 0.07645889f, 0.01203850f, 0.05586127f, 
    0.08676285f, -0.04816694f, -0.09377754f, 0.07637405f, -0.04570516f, -0.03331966f, -0.03091979f, 0.01531636f, 
    0.01200505f, 0.14440605f, -0.05852871f, 0.05023227f, -0.35407659f, -0.22240800f, -0.29672250f, 0.17657965f, 
    0.26922742f, 0.10603524f, 0.07118899f, 0.14564273f, -0.00802643f, -0.00549354f, -0.00960889f, 0.12683016f, 
    -0.12414358f, -0.10879528f, -0.13726027f, 0.04684567f, 0.06015436f, 0.04765676f, 0.01233627f, -0.07675479f, 
    0.16569254f, 0.05941232f, 0.11529697f, 0.00220948f, -0.11221458f, -0.08046652f, -0.10404091f, -0.06318746f, 
    0.00221179f, 0.04055848f, -0.05359675f, 0.02905301f, 0.04790044f, 0.09241565f, 0.08352649f, -0.02036044f, 
    -0.11329792f, 0.08196968f, -0.02094642f, 0.04972712f, 0.17361933f, -0.02441241f, 0.14360444f, -0.04360386f, 
    -0.10117646f, 0.01754569f, 0.02068796f, 0.06774197f, -0.00107854f, 0.08413333f, 0.03309321f, 0.00454685f, 
    -0.07963349f, 0.01230323f, -0.00770539f, 0.01977777f, -0.04678068f, 0.09645043f, 0.04079230f, -0.01554741f, 
    -0.06219130f, 0.18002516f, -0.07577160f, -0.08066029f, -0.04235148f, -0.10126324f, 0.04551418f, 0.00070364f, 
    0.05253882f, 0.03643948f, 0.05555156f, -0.06240128f, 0.02806528f, 0.00941419f, -0.03586056f, 0.10600401f, 
    -0.05690974f, 0.07662600f, -0.03556800f, 0.04273564f, -0.26720724f, 0.08502764f, 0.10460885f, 0.05099785f, 
    0.04275104f, 0.00735159f, 0.00842120f, -0.09178284f, 0.22605839f, 0.04116347f, 0.04766212f, 0.03455551f, 
    0.05954957f, 0.13908979f, 0.06997917f, 0.04098085f, -0.01634331f, -0.04308177f, -0.06526967f, 0.03555695f, 
    0.31739548f, -0.10818135f, -0.14911683f, -0.17647387f, -0.34622994f, 0.04526978f, 0.21220210f, -0.03294472f, 
    -0.02884072f, -0.09469736f, 0.00111479f, 0.01776084f, -0.16524287f, -0.08508293f, 0.12400457f, -0.08233497f, 
    0.03099203f, 0.11113696f, 0.11879685f, 0.02292492f, -0.23425984f, -0.09810906f, 0.01738783f, 0.08868530f, 
    0.04149742f, -0.04723473f, -0.05083003f, -0.03580350f, -0.10342032f, 0.07376209f, 0.07914781f, 0.07310657f, 
    0.01709013f, -0.02703361f, -0.00485551f, -0.07393766f, 0.05739048f, -0.07137021f, 0.04232095f, -0.10069537f, 
    -0.02443319f, 0.43072945f, -0.30508333f, -0.09501775f, -0.10516167f, -0.05352592f, 0.04724845f, -0.06150994f, 
    -0.02546479f, -0.10527553f, -0.02845700f, 0.01182938f, -0.07155394f, 0.06195013f, -0.11303458f, 0.01238270f, 
    -0.15371746f, 0.02029836f, -0.13680507f, 0.03989274f, -0.00440580f, 0.08139709f, -0.01075583f, -0.01625038f, 
    -0.12246627f, -0.04464069f, -0.00148095f, 0.07746924f, -0.00123800f, -0.07543211f, 0.11030411f, 0.00493492f, 
    0.12015931f, 0.10407247f, 0.21097945f, -0.08175852f, 0.01500742f, 0.01089392f, -0.11622969f, 0.04881249f, 
    0.12221856f, -0.06799319f, 0.08353624f, -0.01605413f, 0.26558632f, 0.19193876f, 0.12449676f, -0.01102665f, 
    0.08416755f, -0.05108302f, -0.06416070f, -0.09922082f, 0.05719166f, -0.16063534f, 0.12392656f, -0.09649551f, 
    0.11680202f, -0.11954620f, 0.10581622f, 0.02700100f, -0.00008524f, 0.15844287f, -0.22000141f, -0.11109059f, 
    -0.04908078f, 0.18939893f, -0.00928385f, -0.13508883f, -0.05525911f, 0.10009940f, -0.11724641f, -0.09975761f, 
    -0.00719289f, -0.06596795f, -0.11378417f, 0.03766812f, 0.02010022f, -0.11035392f, 0.02110534f, 0.05069394f, 
    -0.02947019f, 0.16296455f, -0.03722477f, -0.23506632f, -0.06755036f, 0.00100983f, 0.04993762f, -0.11028922f, 
    0.01691807f, 0.00159085f, 0.08326522f, 0.06034152f, 0.12772380f, -0.00213187f, 0.04813601f, -0.05025752f, 
    0.08979230f, -0.07106113f, -0.05537345f, 0.08492817f, -0.42211029f, 0.36479115f, 0.11372639f, 0.04510229f, 
    0.05137377f, 0.08401667f, -0.12986949f, -0.00954605f, 0.04410417f, 0.14655648f, 0.13936390f, 0.02078126f, 
    0.09332220f, -0.06649202f, -0.09236942f, 0.01709873f, 0.00140445f, -0.08144549f, 0.15805133f, 0.05490936f, 
    0.38792422f, 0.08115093f, 0.24862719f, 0.04658603f, -0.03165898f, -0.00144087f, -0.09033301f, -0.01666028f, 
    0.08131161f, 0.17172857f, 0.05922747f, 0.04418427f, 0.04598503f, 0.08022818f, 0.01760816f, -0.03835261f, 
    -0.07254861f, 0.02857701f, 0.04531089f, -0.06405471f, -0.09090533f, 0.05656430f, -0.16712579f, 0.10492337f, 
    0.04025494f, -0.09033711f, 0.05379165f, 0.06764182f, -0.05188926f, 0.05512355f, 0.08263382f, 0.05245922f, 
    0.01811963f, -0.12788220f, 0.17669325f, 0.05809636f, -0.00226887f, -0.01625351f, 0.09001094f, -0.05442405f, 
    -0.39893612f, 0.28481093f, -0.00617651f, -0.01357369f, -0.06993603f, 0.10469960f, 0.06750356f, -0.06213860f, 
    -0.11773407f, 0.12273518f, 0.02908706f, -0.03621578f, 0.09244221f, 0.02550932f, -0.04023728f, 0.10965379f, 
    0.05840350f, -0.22606736f, 0.04395013f, 0.00554679f, -0.09850691f, -0.15830675f, -0.25683191f, 0.35019940f, 
    0.43974060f, 0.07547119f, 0.12096996f, 0.01292000f, -0.02874622f, -0.05631923f, 0.11323536f, -0.02129513f, 
    0.12838644f, 0.03768181f, 0.06493551f, 0.00095624f, 0.03973858f, -0.04593110f, -0.10235094f, 0.01310012f, 
    0.16043214f, -0.02083773f, -0.02061306f, 0.15494063f, -0.08872729f, 0.01476159f, 0.05399325f, -0.02940559f, 
    -0.03561580f, 0.02395824f, -0.00606683f, -0.05266256f, -0.02890731f, -0.00077660f, 0.00930144f, 0.02637731f, 
    0.07601193f, -0.01432072f, 0.07171567f, -0.04327641f, 0.21405004f, -0.06190936f, -0.20989613f, -0.02722147f, 
    -0.08891014f, -0.01185398f, -0.12113525f, 0.00333678f, 0.07239015f, -0.06140706f, 0.04720344f, 0.01298708f, 
    -0.04382661f, -0.03178905f, 0.08730826f, -0.00509702f, 0.03753828f, 0.08050455f, -0.01270981f, 0.04726722f, 
    0.25601730f, 0.23728241f, 0.17652348f, -0.16365997f, 0.06915943f, 0.01586366f, -0.02237887f, -0.07989591f, 
    -0.06771400f, -0.00937442f, 0.05494219f, 0.02506732f, 0.05312698f, -0.00742197f, -0.01540438f, 0.06425967f, 
    -0.07441966f, -0.32217649f, 0.04649110f, -0.02260168f, 0.10299978f, 0.08804879f, 0.01209116f, -0.07100183f, 
    -0.11293161f, 0.01436866f, 0.06397039f, 0.03744093f, -0.04839304f, 0.13598284f, -0.06738050f, -0.00005486f, 
    -0.01776233f, -0.34625316f, 0.01607489f, 0.08006880f, 0.05808132f, -0.10394493f, 0.19824564f, -0.05501560f, 
    -0.16160071f, 0.01508431f, 0.01461800f, 0.22704920f, 0.07240009f, -0.10346704f, 0.05046910f, -0.07398916f, 
    0.03337211f, 0.02510569f, 0.07493210f, -0.02436685f, 0.08055716f, 0.10894573f, 0.05609458f, 0.17766769f, 
    0.10052219f, -0.11494873f, 0.07128738f, -0.03459777f, 0.62701619f, 0.22791430f, -0.36102727f, 0.35111162f, 
    -0.24570206f, -0.00723495f, 0.01897234f, 0.10960760f, 0.07069007f, 0.06515552f, -0.02935114f, -0.00718449f, 
    0.12889650f, 0.01539122f, 0.12474319f, 0.15041439f, 0.11350985f, 0.23293875f, -0.00177002f, 0.21938162f, 
    0.08024346f, 0.06198358f, 0.03289748f, 0.14936563f, 0.05331948f, -0.06239804f, 0.10014970f, -0.07800820f, 
    0.04187125f, -0.00868821f, 0.05175282f, 0.03483020f, 0.05322605f, -0.04903137f, 0.05627414f, 0.06511589f, 
    0.06081631f, -0.34307998f, 0.11077845f, 0.10876773f, -0.06086098f, -0.14730388f, 0.04575640f, 0.06525809f, 
    -0.10315002f, -0.08731457f, 0.08439042f, 0.06656774f, 0.01666349f, -0.06234350f, 0.04627451f, 0.08720303f, 
    0.01668229f, 0.07802692f, -0.06853070f, 0.06043505f, 0.11525739f, 0.19420214f, 0.09708466f, 0.07420181f, 
    0.29674244f, -0.20081238f, -0.18907528f, -0.17808534f, -0.26121768f, 0.07843730f, 0.06747725f, -0.08150881f, 
    0.00175436f, -0.05269242f, -0.00545661f, 0.02840721f, 0.00904952f, 0.17559718f, -0.07953896f, 0.12624362f, 
    -0.05047925f, -0.05425835f, -0.14064635f, -0.10554051f, 0.02683638f, -0.07618320f, 0.12848549f, -0.26978505f, 
    0.13978434f, 0.02180687f, -0.02027295f, 0.03359177f, -0.04352193f, 0.01518502f, -0.09000556f, -0.06305511f, 
    -0.09698243f, 0.01214011f, -0.05738845f, 0.12904212f, 0.04582023f, 0.14934388f, -0.06054985f, 0.01188129f, 
    0.24365397f, -0.15089726f, -0.15152763f, 0.19966502f, -0.05626037f, 0.00623215f, -0.05395691f, 0.07688399f, 
    -0.02420865f, 0.05814322f, -0.14061983f, -0.01110490f, 0.00844246f, -0.03974161f, -0.04007031f, 0.03329026f, 
    -0.07727084f, 0.20630538f, 0.11569036f, 0.06973020f, 0.06177100f, 0.23169245f, -0.07919598f, 0.22821927f, 
    -0.06425698f, 0.11301287f, 0.10106907f, -0.05477317f, 0.10374141f, -0.07534135f, -0.12570663f, 0.03392483f, 
    -0.03592383f, 0.09812953f, 0.10936555f, 0.17603567f, 0.01575121f, 0.04782163f, -0.19616786f, 0.04399280f, 
    -0.27560303f, 0.09316395f, -0.22696573f, -0.21029638f, -0.25575846f, 0.08687512f, 0.01216035f, 0.16327672f, 
    -0.14773385f, 0.01849547f, 0.00500035f, 0.09159830f, 0.05418929f, 0.04953735f, 0.00162105f, 0.05425710f, 
    0.02752526f, -0.10522716f, -0.24077125f, 0.06279442f, 0.17503990f, 0.11716254f, 0.12349656f, 0.07553635f, 
    0.00654853f, 0.10787677f, -0.03122405f, 0.04334383f, 0.00472621f, 0.12249478f, -0.12967007f, -0.12141797f, 
    -0.01386411f, 0.03008928f, 0.01788949f, -0.09434178f, -0.09231982f, 0.01075118f, 0.04651945f, -0.04457306f, 
    0.37987593f, -0.09158695f, -0.15090029f, -0.23250689f, 0.05389295f, -0.10318346f, 0.05846868f, -0.03104285f, 
    0.04356175f, 0.04200417f, 0.00890428f, 0.00396447f, -0.17833185f, 0.01357108f, 0.01926212f, -0.00120893f, 
    -0.14645427f, 0.07756442f, -0.03089798f, 0.08318847f, 0.27974793f, -0.33008519f, -0.30162454f, -0.19804655f, 
    0.12714548f, -0.08497155f, 0.17305408f, -0.11597948f, -0.04050877f, -0.07533057f, -0.09357689f, 0.00156392f, 
    0.07030430f, 0.00126806f, -0.07164004f, -0.09554941f, 0.17288478f, 0.01304972f, 0.01844873f, -0.03506634f, 
    -0.03997546f, 0.12317928f, -0.10136786f, 0.17550649f, -0.02786256f, 0.02705964f, -0.10070797f, 0.08676017f, 
    -0.02216632f, 0.07043540f, 0.04531345f, 0.05562212f, 0.04489318f, 0.07716430f, 0.02696780f, 0.09938023f, 
    -0.08117948f, 0.10365953f, 0.01329260f, -0.03798097f, -0.09273319f, 0.22186187f, 0.10418613f, 0.06009490f, 
    -0.14109886f, 0.06811858f, 0.08413256f, -0.06153170f, 0.04168190f, 0.01913199f, -0.04270333f, -0.01666396f, 
    -0.04997039f, -0.07837650f, 0.14586878f, 0.02827577f, 0.04643893f, 0.16837631f, -0.03551230f, 0.07581633f, 
    -0.00743611f, 0.28262487f, -0.10355971f, -0.01917683f, -0.12698179f, -0.07215371f, 0.09003425f, 0.00271769f, 
    0.08040455f, 0.15396929f, 0.00728425f, 0.00032106f, -0.03052933f, 0.02002881f, 0.10898357f, 0.06344015f, 
    0.08326814f, -0.07147295f, -0.03255539f, -0.01880699f, -0.07127261f, -0.20950739f, 0.11526724f, -0.00491540f, 
    -0.26817000f, 0.13411915f, 0.09376548f, 0.06923672f, 0.07858741f, -0.03004575f, -0.00443240f, -0.01361707f, 
    0.00182877f, -0.16275446f, -0.09562995f, 0.02793152f, -0.00199899f, -0.00113690f, 0.16319251f, 0.06552359f, 
    0.10187368f, 0.14565273f, -0.20868565f, -0.04016093f, 0.19702363f, -0.03495419f, 0.06515539f, 0.08035170f, 
    -0.08587896f, 0.05107141f, -0.05214752f, 0.01536678f, -0.05649288f, 0.02044924f, -0.17434639f, 0.16702530f, 
    -0.06450953f, -0.08027320f, -0.00192956f, -0.01865368f, 0.11661629f, -0.05719655f, -0.06550130f, 0.21156920f, 
    -0.23230618f, -0.05614835f, -0.14815186f, -0.08498316f, 0.11219095f, 0.07476172f, 0.21368043f, -0.05605609f, 
    0.06933814f, 0.06386848f, -0.01093079f, -0.05685819f, 0.02883464f, -0.23954381f, -0.00115775f, -0.01213289f, 
    -0.27987099f, 0.28194514f, -0.32110476f, 0.01068267f, 0.24674602f, -0.08178540f, 0.05125876f, 0.02984196f, 
    0.03329622f, 0.07520778f, 0.01881268f, -0.01189486f, -0.02439024f, -0.00853508f, -0.01860944f, 0.03479355f, 
    -0.05667498f, -0.05071132f, -0.06320441f, 0.04208792f, 0.05311726f, -0.21151440f, 0.01994265f, -0.00162834f, 
    -0.01580631f, -0.04402125f, 0.05677127f, 0.12530012f, 0.09219392f, -0.03677714f, -0.01986587f, -0.01728266f, 
    0.00194726f, 0.02874750f, -0.06197564f, -0.07120896f, 0.03538902f, -0.03068546f, 0.04326397f, -0.02508136f, 
    0.01833508f, -0.17138544f, 0.17464477f, -0.31068990f, -0.02206477f, -0.00463276f, -0.01779143f, 0.04923093f, 
    0.10450986f, 0.00441735f, 0.11786283f, -0.04202263f, 0.05170849f, 0.04024861f, -0.01130574f, 0.08483195f, 
    0.08156360f, 0.00955444f, -0.02050297f, 0.10107273f, 0.14561157f, -0.33922389f, -0.03440579f, -0.17710826f, 
    0.24131037f, 0.10171673f, -0.01828378f, 0.11176719f, -0.01661372f, 0.04097348f, 0.10677887f, -0.00341909f, 
    -0.04981705f, 0.01272813f, 0.03541512f, 0.09434929f, -0.04800941f, 0.05157639f, 0.03183230f, 0.01086454f, 
    0.39818338f, -0.00939219f, -0.05117296f, -0.08030718f, -0.18009351f, -0.01074322f, -0.23007056f, -0.01949199f, 
    0.09595952f, 0.10147082f, 0.10171951f, -0.16685122f, -0.10302391f, 0.05953068f, -0.14575602f, 0.04366390f, 
    -0.00771528f, -0.01066939f, -0.09565570f, 0.06303820f, -0.09630191f, -0.20257506f, 0.07103162f, -0.08564107f, 
    0.16117170f, 0.02523753f, -0.07817501f, 0.24381034f, -0.08365489f, -0.02191435f, 0.00109680f, -0.04559292f, 
    -0.09378468f, -0.06707434f, 0.03530500f, 0.01931557f, -0.01136425f, 0.13449630f, -0.05224397f, -0.05016381f, 
    0.10387999f, -0.04584948f, 0.05006578f, 0.01843124f, 0.04810657f, 0.16646661f, -0.00469708f, -0.12311374f, 
    0.07207978f, 0.02210998f, 0.02551934f, -0.01835805f, 0.02373390f, 0.05482834f, 0.01404675f, -0.06997865f, 
    0.05629398f, -0.04848627f, -0.05940702f, 0.04372334f, 0.40073195f, 0.17650653f, -0.02345197f, 0.13444076f, 
    -0.15257449f, -0.03634850f, -0.07604875f, -0.04740984f, 0.01581214f, 0.06325853f, 0.08286382f, -0.04753890f, 
    -0.02967943f, 0.21370836f, -0.02760969f, -0.01302835f, -0.09734990f, -0.01529397f, -0.03759169f, -0.08508561f, 
    0.05302233f, 0.08493868f, -0.18834190f, -0.27768123f, 0.32345071f, 0.00465697f, 0.16820642f, 0.02422425f, 
    -0.07617074f, 0.09378066f, 0.06242473f, -0.00862751f, 0.01198189f, -0.06354032f, 0.24307528f, 0.02051192f, 
    0.01049511f, 0.18481949f, -0.09162301f, -0.07558794f, 0.06702441f, 0.08665565f, -0.05444379f, 0.03661297f, 
    -0.02092959f, 0.03135340f, -0.09352288f, -0.04340429f, -0.00898941f, -0.05174974f, 0.09282602f, 0.03512315f, 
    -0.10236976f, -0.05855190f, -0.03611581f, 0.11079510f, -0.02014780f, -0.07309087f, -0.00662417f, 0.07490660f, 
    0.47531149f, -0.11337787f, 0.11438408f, -0.06600512f, -0.21840130f, -0.00619329f, -0.01039110f, 0.04120709f, 
    0.03636994f, 0.21403991f, 0.02121481f, -0.05573053f, 0.08990841f, 0.03672998f, 0.00356563f, 0.15266390f, 
    0.06166416f, 0.02548347f, -0.11595888f, 0.16126101f, 0.11246298f, -0.41833463f, -0.01379877f, -0.02338822f, 
    -0.16094014f, 0.07437348f, 0.06564069f, 0.18724713f, 0.05773295f, 0.04811659f, 0.01159666f, 0.19681726f, 
    -0.09682587f, -0.02910905f, 0.01920631f, 0.03494136f, -0.03347921f, 0.07658945f, 0.13118197f, -0.13867426f, 
    -0.09026206f, -0.14387469f, 0.06160766f, -0.02191142f, 0.05219416f, 0.08836313f, 0.19747174f, 0.02743240f, 
    0.16110620f, 0.05264552f, -0.06816142f, 0.02319667f, 0.04451878f, 0.06893676f, 0.07605781f, 0.04687624f, 
    0.07559437f, -0.11069944f, -0.10315222f, -0.10908315f, -0.04194168f, -0.20912758f, -0.10353895f, -0.13241935f, 
    -0.03669196f, 0.04543034f, -0.00772853f, -0.07499706f, -0.22855961f, -0.04465832f, 0.00781589f, -0.02867559f, 
    -0.09472828f, -0.16998020f, -0.00517073f, -0.03063701f, -0.12440348f, 0.20653859f, 0.10872161f, 0.04483108f, 
    0.21643096f, 0.03935074f, 0.22067980f, -0.18595807f, 0.25190914f, -0.15341212f, 0.04887640f, 0.08831576f, 
    0.03403678f, 0.06367830f, -0.21877763f, 0.04480235f, 0.03884276f, 0.18359387f, 0.05362083f, 0.11747776f, 
    -0.04726661f, -0.10017903f, 0.00519936f, -0.02748493f, -0.17759895f, -0.09396779f, -0.25560176f, -0.17123121f, 
    0.08542971f, 0.14781985f, -0.04490262f, -0.09131555f, 0.09469153f, -0.02449277f, 0.01008079f, -0.11389288f, 
    0.08032782f, -0.00029689f, -0.06409977f, 0.11556327f, 0.02183606f, -0.06874758f, 0.03918452f, 0.00566529f, 
    -0.03077918f, 0.06142000f, 0.10348877f, 0.03795419f, 0.30117512f, 0.07010039f, 0.04675370f, 0.04139855f, 
    0.03092887f, 0.10099157f, 0.00988635f, 0.11237430f, 0.03760089f, -0.05962447f, 0.14636026f, 0.11465141f, 
    0.08256087f, -0.14650510f, 0.05440461f, -0.16211775f, -0.04410348f, -0.18998335f, -0.05161997f, -0.04855614f, 
    0.04523043f, -0.16332285f, 0.10931151f, -0.14220199f, -0.02734217f, 0.01797300f, 0.02410512f, 0.00952304f, 
    -0.15671384f, -0.03634701f, -0.04251716f, 0.16654611f, 0.11327323f, -0.00777624f, 0.24407753f, 0.10506833f, 
    0.34682477f, 0.27872291f, 0.04852922f, -0.11790881f, -0.14035459f, 0.13423730f, -0.02206264f, 0.16713785f, 
    -0.01372938f, 0.12058598f, -0.01362017f, 0.02804265f, 0.09949396f, -0.03359536f, -0.00320292f, 0.11014885f, 
    -0.09108512f, -0.02117792f, -0.38558346f, -0.12161605f, 0.43153736f, -0.25615790f, 0.23142844f, 0.06854969f, 
    -0.07567388f, -0.04400815f, 0.09198216f, -0.00672658f, 0.09852302f, -0.00449609f, -0.04525030f, 0.07815318f, 
    0.05371876f, 0.07146317f, 0.18846279f, 0.09483992f, 0.05130737f, 0.08957542f, -0.04433189f, -0.02703055f, 
    0.32422209f, -0.30589530f, 0.04892664f, -0.11881226f, 0.05028218f, -0.14708544f, -0.06403095f, -0.05925821f, 
    0.02741243f, -0.06811273f, 0.05293301f, -0.12044332f, -0.21716064f, 0.06236414f, 0.01639341f, 0.15361571f, 
    -0.08904716f, 0.08163295f, 0.05033243f, 0.08086734f, 0.27144650f, -0.30997831f, -0.28516385f, -0.13698557f, 
    0.13729721f, -0.03392578f, 0.04457362f, 0.01966186f, 0.00310430f, -0.04177463f, 0.14834692f, -0.03156515f, 
    -0.13716200f, 0.07495587f, 0.08783698f, -0.07723397f, -0.07294725f, 0.11064789f, -0.18598919f, -0.13576658f, 
    -0.07750758f, 0.00037248f, -0.24785750f, -0.03930947f, 0.09544275f, 0.05772904f, 0.11931783f, 0.04739700f, 
    -0.04263235f, 0.09337945f, -0.12543130f, -0.11755202f, 0.03221031f, 0.11775687f, 0.02808206f, 0.07939480f, 
    0.21299796f, -0.24715434f, -0.57269979f, -0.08305598f, -0.15439157f, -0.24839914f, -0.05142667f, -0.24012244f, 
    0.10255536f, 0.11003196f, 0.11540484f, -0.04553488f, 0.12118840f, 0.13768333f, -0.10038233f, -0.16675094f, 
    -0.04085140f, 0.21588716f, -0.03881372f, -0.03040719f, 0.11178815f, -0.00296247f, -0.19805455f, 0.06489643f, 
    0.27814785f, 0.06694562f, 0.01195899f, 0.04976143f, 0.16453229f, 0.04896261f, 0.10981672f, -0.01828339f, 
    -0.01471808f, -0.05701575f, -0.05558201f, 0.11398922f, -0.18505204f, -0.00765012f, -0.02472216f, -0.02967259f, 
    0.05717499f, -0.00250359f, 0.05993526f, -0.02120140f, 0.43346384f, 0.32355121f, 0.25271183f, -0.01077129f, 
    -0.22629835f, 0.02824743f, 0.00093535f, -0.19711369f, -0.13037246f, -0.03568341f, 0.02158222f, -0.08140270f, 
    -0.04901667f, -0.03175646f, 0.08771273f, 0.23608971f, 0.06190846f, -0.05781580f, 0.07345697f, 0.11241996f, 
    -0.10032479f, 0.10530253f, 0.07134841f, -0.10960721f, 0.06538237f, 0.08746910f, -0.04349393f, -0.00678148f, 
    0.06867743f, -0.10240665f, 0.03115148f, 0.02490279f, -0.11882694f, -0.09731205f, 0.07882652f, -0.04803744f, 
    -0.00757584f, 0.00582594f, -0.03057569f, 0.13942389f, -0.17357190f, 0.06231550f, -0.11890641f, 0.16632989f, 
    -0.02571829f, -0.02465214f, -0.06617552f, 0.06160978f, -0.04685418f, -0.02521208f, -0.06169700f, -0.08567569f, 
    -0.05205065f, 0.09665264f, -0.13726483f, 0.12157225f, 0.09697749f, 0.11676072f, 0.16854256f, 0.08908637f, 
    0.29068238f, -0.09871125f, 0.11542112f, 0.16052747f, 0.10923272f, -0.01212595f, -0.00379079f, 0.02749487f, 
    -0.00717706f, 0.04889054f, -0.01618368f, 0.05603747f, -0.01429629f, 0.08524323f, 0.09446418f, -0.05276647f, 
    0.10827949f, 0.01188138f, -0.00477442f, 0.02033149f, 0.18322128f, -0.07736412f, 0.13818683f, -0.19946854f, 
    -0.20081212f, -0.01103636f, 0.05031827f, 0.06693129f, -0.14829667f, -0.17738520f, 0.01159772f, 0.01046536f, 
    0.04368117f, -0.02690830f, -0.20017697f, 0.07094179f, -0.06484811f, 0.01966055f, 0.02949857f, 0.16928542f, 
    -0.20104931f, -0.06414996f, -0.01709373f, -0.18338583f, 0.34448984f, 0.05811915f, -0.21146773f, 0.06139004f, 
    0.03312291f, 0.10725027f, 0.07678778f, -0.04222770f, 0.10815103f, 0.02607797f, -0.05103680f, 0.07646669f, 
    -0.08631296f, -0.01429089f, -0.03152228f, 0.02479245f, 0.06258696f, -0.05728293f, -0.03641400f, -0.24653947f, 
    -0.05660450f, 0.03013466f, -0.06915382f, -0.04118406f, -0.01707028f, -0.05065722f, 0.09641846f, -0.07730073f, 
    0.07450165f, 0.11151253f, 0.08881029f, 0.12602110f, 0.07828344f, 0.00561559f, -0.00045952f, 0.13631192f, 
    0.15842991f, -0.30867025f, 0.31430104f, 0.03909633f, 0.17432112f, 0.14117561f, 0.07480606f, 0.02476313f, 
    0.01312159f, 0.00293795f, 0.01591299f, 0.01754394f, 0.01787158f, -0.03580414f, 0.03871538f, 0.03071095f, 
    0.04425878f, -0.01358363f, 0.00825010f, -0.08279318f, -0.06851462f, -0.15888345f, -0.04154337f, -0.20011690f, 
    0.00728405f, 0.04867280f, -0.01081810f, 0.00018088f, 0.12963586f, 0.14044736f, -0.04197315f, 0.02341125f, 
    -0.01333707f, -0.07662696f, -0.00345962f, 0.03652200f, 0.01796533f, -0.04749058f, 0.09080189f, 0.04512101f, 
    0.12309232f, 0.09075155f, 0.01485305f, -0.04187761f, -0.09093088f, 0.00594811f, -0.02066446f, -0.02802584f, 
    -0.05969643f, 0.07278746f, 0.07225943f, 0.01932586f, 0.06687887f, 0.04854558f, -0.03204834f, 0.08589418f, 
    -0.06449805f, 0.07500787f, -0.03530220f, 0.00181920f, -0.14073755f, -0.33157432f, 0.18911313f, -0.12272219f, 
    0.01056483f, -0.06339729f, 0.10075474f, 0.00644528f, 0.01122619f, -0.04244586f, 0.13209377f, 0.08016030f, 
    0.05866837f, 0.10711534f, 0.19621880f, 0.01443253f, -0.04062428f, 0.08828516f, 0.04733669f, 0.03665258f, 
    0.00712895f, -0.20705390f, 0.02002376f, 0.12742545f, -0.07944658f, -0.04958637f, -0.03586919f, 0.01927802f, 
    -0.04313340f, 0.07086708f, 0.10258420f, -0.01982432f, -0.04072618f, 0.08623923f, -0.07957525f, 0.14521763f, 
    -0.04854463f, 0.04750803f, 0.04330384f, 0.02368754f, -0.08058997f, -0.29847753f, 0.12165006f, -0.03691513f, 
    -0.04118211f, -0.02328111f, 0.10829372f, 0.03610234f, -0.15472560f, -0.17347771f, 0.12260016f, -0.13868035f, 
    0.04723594f, 0.08370013f, 0.13174072f, 0.08368923f, 0.02751043f, 0.02835811f, 0.05299055f, 0.04504080f, 
    -0.01189302f, 0.18080433f, -0.13835528f, 0.17108123f, 0.37116221f, -0.00843514f, 0.06389283f, -0.00603917f, 
    0.01844964f, -0.07292785f, -0.06052162f, -0.03317638f, 0.04533204f, -0.02773327f, -0.03263083f, -0.00009092f, 
    0.10573550f, 0.04851536f, -0.01210500f, 0.00794452f, 0.26698446f, -0.03059074f, 0.19076343f, -0.10972388f, 
    0.12339574f, 0.07217895f, -0.03385780f, -0.07634956f, -0.03431932f, 0.09299403f, -0.03044214f, -0.00909375f, 
    -0.00198782f, 0.11425641f, -0.07352982f, -0.04629229f, -0.05207595f, 0.05241663f, -0.12330954f, 0.00342201f, 
    0.35249701f, -0.13483982f, -0.14322135f, -0.08688358f, 0.24464272f, -0.02781547f, 0.02631350f, 0.00105499f, 
    0.07340568f, -0.07936390f, -0.00485476f, 0.02951994f, 0.01346304f, -0.02464619f, 0.11715516f, -0.07343578f, 
    0.01737880f, 0.17039989f, -0.03543348f, 0.03568786f, -0.07119829f, 0.09599814f, 0.17426716f, -0.34107339f, 
    -0.39835513f, 0.06847370f, -0.09626330f, -0.09582969f, 0.07349934f, 0.09558702f, 0.05569957f, 0.02743431f, 
    -0.03139360f, -0.02967026f, -0.08080976f, 0.06047342f, 0.06916827f, 0.01886425f, 0.06566876f, -0.00317409f, 
    0.04350957f, 0.02564853f, 0.03402137f, -0.11177007f, -0.01624913f, -0.03394168f, 0.00500711f, 0.01285219f, 
    0.04981642f, 0.02427685f, 0.04518596f, 0.05315566f, -0.04793707f, 0.02028291f, 0.05767513f, 0.08940838f, 
    -0.06687568f, 0.06627409f, 0.02075971f, 0.15496451f, -0.28137508f, 0.01395020f, -0.03255511f, -0.13013096f, 
    -0.19693665f, 0.01953924f, 0.04645978f, 0.03200669f, -0.01799898f, 0.09604947f, -0.11565018f, 0.03495784f, 
    -0.00988554f, 0.01135574f, 0.00296873f, 0.04201952f, -0.03210203f, -0.05252185f, 0.04260996f, -0.03896489f, 
    0.03868782f, 0.03571542f, -0.01941128f, -0.00720369f, 0.00961129f, -0.04368187f, -0.01297105f, 0.03876891f, 
    -0.03171379f, -0.02776359f, -0.04411308f, 0.04514988f, -0.00657481f, 0.03674756f, 0.01961439f, -0.01725166f, 
    0.02366130f, -0.03819432f, 0.00560217f, -0.02689149f, -0.00263608f, -0.02178492f, -0.04638902f, 0.03878530f, 
    -0.05010193f, 0.01657015f, -0.03309695f, 0.03526741f, 0.00783455f, 0.02670710f, 0.02731608f, 0.02923173f, 
    -0.04225738f, 0.02065269f, -0.00333247f, 0.01512394f, 0.00036049f, -0.04604595f, 0.00991211f, -0.01323371f, 
    -0.00776630f, 0.00757493f, -0.02965416f, -0.00242069f, 0.00360406f, -0.05238875f, 0.01025390f, -0.00915660f, 
    0.00121015f, -0.00314429f, -0.00998205f, 0.00346254f, -0.01119910f, -0.05843743f, 0.03962874f, -0.00772718f, 
    0.04339068f, -0.04091408f, 0.03706795f, -0.01643302f, -0.02332268f, -0.00350495f, -0.03092160f, 0.01121739f, 
    -0.05582288f, 0.02730514f, -0.01134249f, -0.05647526f, -0.04818522f, 0.00319615f, 0.02905765f, -0.06054332f, 
    0.01880207f, 0.00996783f, 0.04658630f, -0.00688105f, 0.03506622f, -0.00219669f, -0.05811625f, -0.04233576f, 
    -0.06117726f, -0.05667279f, -0.04974860f, 0.04225207f, -0.06176497f, 0.01071483f, 0.02018598f, 0.02985656f, 
    0.02509597f, -0.03961104f, 0.01516555f, -0.05352726f, -0.02536136f, -0.03989477f, -0.04203189f, -0.02138304f, 
    0.00714553f, 0.01680699f, 0.00134950f, -0.00275922f, -0.02740922f, -0.02964934f, -0.02914958f, -0.03261774f, 
    -0.01240856f, -0.04828545f, 0.03623542f, 0.03301212f, 0.00579719f, -0.01851606f, 0.01850190f, -0.05689758f, 
    -0.00528493f, -0.01150163f, 0.04766310f, -0.02020621f, 0.03737681f, -0.00403365f, -0.04537335f, -0.02019725f, 
    0.05016095f, -0.01370207f, -0.02949898f, -0.04761302f, 0.04197256f, -0.04625534f, -0.04210842f, -0.01312117f, 
    -0.00344067f, 0.04299218f, -0.01284363f, -0.02253322f, -0.04531587f, -0.03179063f, -0.05037011f, -0.00451121f, 
    0.02249500f, 0.03679163f, -0.00336417f, -0.03049886f, 0.04472058f, -0.00296372f, -0.03045104f, -0.01790006f, 
    0.00284502f, 0.00929994f, -0.02538105f, -0.05570513f, 0.05054528f, 0.04785575f, -0.01558944f, -0.01017085f, 
    0.00545477f, -0.04583679f, -0.03556904f, 0.04264938f, 0.00509359f, 0.02815571f, 0.03661260f, -0.05972759f, 
    -0.03603347f, -0.00374091f, -0.01906547f, -0.05796921f, -0.03056600f, 0.00898614f, -0.05188520f, -0.00393373f, 
    0.02504098f, -0.03226412f, 0.02394484f, -0.00515224f, 0.00365589f, -0.00445565f, -0.05614746f, 0.02685882f, 
    0.04713199f, -0.01700057f, -0.04003773f, -0.00756301f, 0.04438164f, 0.01920263f, -0.04802285f, 0.00320378f, 
    0.00279819f, 0.02872507f, 0.03431939f, 0.01857925f, 0.04655642f, -0.02086824f, 0.04644946f, -0.04306424f, 
    -0.01466098f, -0.01284151f, -0.06425440f, -0.05374144f, -0.00246052f, -0.00539341f, 0.01214220f, -0.01765418f, 
    -0.05724169f, 0.03028406f, 0.02081222f, -0.00108032f, 0.01386706f, -0.03223617f, -0.01335343f, 0.02308412f, 
    0.00759607f, -0.01881343f, -0.01871456f, 0.03910005f, -0.02333572f, 0.03169996f, -0.03434021f, -0.00442904f, 
    0.01374187f, -0.01937510f, 0.00030355f, -0.03072711f, -0.00169045f, -0.04908856f, 0.05162551f, -0.02912085f, 
    -0.01588082f, -0.05312240f, -0.01452049f, 0.03331458f, 0.00572880f, 0.03910245f, 0.00966011f, -0.01107007f, 
    -0.05453961f, 0.03362521f, 0.02299664f, -0.04376576f, -0.04889959f, 0.00865570f, -0.03651511f, -0.01893440f, 
    0.04393072f, -0.04345950f, -0.01652106f, -0.01064651f, -0.06173394f, 0.00970255f, -0.02224610f, 0.02999355f, 
    -0.03486715f, -0.04582518f, 0.00815642f, -0.00145210f, -0.04373793f, -0.02289572f, -0.05966381f, 0.03099739f, 
    0.03833843f, -0.03107831f, -0.00855931f, -0.05154524f, -0.04838431f, 0.00026536f, -0.02034681f, -0.03907441f, 
    0.02711319f, 0.02828245f, 0.00277973f, -0.01573952f, 0.05011141f, 0.01428584f, -0.00876438f, -0.00939172f, 
    0.02938058f, 0.03536575f, 0.03877581f, -0.00464147f, 0.03249837f, 0.04460886f, -0.04122213f, -0.02853112f, 
    0.02267340f, 0.03430698f, 0.03668849f, 0.04071428f, 0.03554425f, -0.03723260f, -0.00296476f, -0.04987439f, 
    -0.03354906f, 0.00839440f, -0.00734950f, 0.00862672f, 0.04175047f, 0.00773788f, 0.02864509f, -0.02843974f, 
    -0.02440284f, 0.03777883f, 0.04628948f, -0.03821725f, 0.01585685f, -0.02463338f, 0.03697059f, -0.00712405f, 
    0.01821924f, -0.03431945f, -0.00931654f, 0.00466449f, 0.02740551f, -0.00231544f, 0.03335350f, -0.02674574f, 
    -0.05457230f, 0.02292181f, -0.02197054f, -0.05277987f, -0.05222746f, -0.05616274f, -0.00195731f, 0.03270397f, 
    -0.02118182f, 0.00272772f, 0.03671836f, -0.01320258f, 0.02616761f, -0.04398919f, 0.02921067f, 0.00483214f, 
    0.03571818f, -0.00320018f, -0.00990435f, -0.03514780f, -0.05552824f, -0.05566123f, -0.02915103f, 0.03010822f, 
    -0.03994090f, -0.02707997f, 0.02047061f, 0.02179775f, 0.04060284f, -0.06278385f, 0.01248439f, 0.02972806f, 
    0.00185707f, 0.03662449f, -0.00345449f, -0.04716808f, -0.02783562f, -0.00073039f, -0.04503749f, -0.00580888f, 
    -0.05133335f, -0.05205743f, 0.03204553f, 0.02578334f, 0.00395440f, 0.04166930f, -0.01502057f, -0.03321142f, 
    0.03419767f, -0.04122173f, 0.03044693f, 0.02465708f, -0.00075469f, 0.04245846f, 0.01271299f, 0.02140629f, 
    -0.04817038f, 0.02447976f, -0.02835717f, -0.03896996f, 0.03256646f, -0.00804705f, 0.03162827f, 0.01641301f, 
    0.02328298f, -0.05940125f, -0.02143285f, -0.05639420f, -0.00833547f, -0.05154781f, 0.01252209f, -0.00892890f, 
    -0.05447738f, 0.04111943f, -0.03898173f, 0.04430990f, -0.05683289f, -0.02054620f, -0.01452409f, 0.02490123f, 
    0.03210462f, -0.03213222f, -0.00227521f, 0.02683463f, 0.02532501f, -0.05619041f, -0.03427108f, -0.02932531f, 
    -0.04699249f, -0.05617636f, -0.01668603f, -0.03694657f, -0.05418265f, -0.02336033f, 0.05014895f, -0.01659870f, 
    -0.02712474f, -0.00014901f, -0.03948244f, 0.02239267f, -0.06253618f, -0.02953919f, -0.04595968f, -0.04304404f, 
    -0.04963457f, -0.05591427f, -0.04317343f, -0.06130138f, -0.04886669f, 0.00104016f, -0.01978567f, -0.00675506f, 
    -0.02631586f, 0.02079448f, -0.05502221f, 0.03320300f, -0.04205516f, 0.00268859f, -0.00986189f, -0.03727056f, 
    0.00504440f, 0.01625823f, -0.05639294f, -0.00027087f, 0.05175928f, 0.03050635f, -0.04587513f, 0.02829805f, 
    0.03691375f, -0.01182952f, -0.01885231f, 0.03689760f, 0.05171105f, -0.04398447f, -0.01800231f, 0.01331147f, 
    0.03863777f, -0.00520567f, -0.03679786f, 0.04961029f, -0.05936961f, -0.02710933f, -0.03273069f, 0.02287735f, 
    -0.04222893f, -0.00065880f, -0.00647973f, -0.04032917f, 0.01584440f, -0.01905015f, -0.04104055f, 0.00038668f, 
    -0.03878540f, 0.02760237f, 0.01386691f, -0.04922478f, 0.04206701f, 0.03204297f, -0.04929937f, 0.01163935f, 
    -0.05329810f, 0.04332803f, -0.03697215f, -0.03085808f, -0.05085301f, -0.02127270f, -0.04769689f, 0.04580506f, 
    -0.00320721f, -0.04733348f, 0.01615702f, -0.00934007f, -0.03788713f, -0.05547590f, 0.04428112f, 0.01706310f, 
    0.04647405f, -0.06289096f, -0.05409348f, -0.06091853f, -0.03862628f, -0.06359549f, 0.02159615f, 0.04352714f, 
    -0.01706952f, -0.00728355f, 0.00295089f, 0.02418493f, -0.05918926f, -0.03472244f, -0.00370414f, -0.02244583f, 
    -0.02860894f, 0.02282209f, -0.04810010f, -0.01121699f, -0.02210763f, 0.04881545f, 0.04464576f, 0.01479874f, 
    -0.02768879f, -0.06325268f, -0.01217134f, -0.05589389f, -0.03048492f, -0.00418050f, 0.04642207f, -0.03038867f, 
    0.01420446f, 0.02822994f, -0.01447844f, -0.00128091f, 0.02345494f, 0.04207880f, 0.02069928f, -0.02051673f, 
    -0.00995656f, -0.06423158f, -0.04952380f, 0.05116972f, -0.01734453f, 0.01301649f, 0.00455034f, 0.01030366f, 
    -0.04785002f, 0.00614034f, -0.03165935f, -0.03512148f, 0.01518243f, -0.02292256f, -0.00506997f, 0.01462015f, 
    -0.05952649f, -0.01200292f, 0.03986337f, -0.02441990f, -0.02082566f, 0.01828932f, -0.01941789f, -0.02284611f, 
    0.01217294f, -0.01276538f, 0.02725286f, 0.04851944f, -0.03530095f, 0.04656169f, -0.05350718f, 0.02175071f, 
    0.04395631f, -0.03341876f, -0.00611973f, -0.02041576f, -0.01066738f, 0.04031935f, -0.03994912f, -0.00410686f, 
    0.00279459f, -0.01630417f, -0.01584685f, 0.00935656f, 0.04163514f, -0.05603164f, 0.00674113f, -0.02486307f, 
    0.03042107f, 0.03803568f, 0.03969283f, 0.00408206f, 0.00254140f, 0.02932581f, 0.04636658f, -0.00262748f, 
    0.04098442f, 0.01152002f, 0.02033337f, 0.02786107f, -0.03775517f, 0.01360633f, 0.02471533f, -0.02196181f, 
    -0.05832250f, 0.00583867f, -0.01331493f, -0.04994452f, -0.03194769f, 0.01949361f, -0.02435285f, -0.03550007f, 
    -0.03675583f, 0.01599382f, 0.02522737f, 0.04482532f, -0.01356694f, 0.00976898f, 0.02848466f, -0.04642848f, 
    -0.00260706f, -0.04960623f, -0.03489199f, -0.03170140f, -0.02239083f, -0.05966007f, 0.03540812f, -0.02948124f, 
    0.04957906f, -0.02234889f, 0.03481893f, 0.00216800f, 0.02510458f, -0.00656845f, 0.03962139f, 0.03111414f, 
    -0.04040506f, -0.00211284f, -0.04168428f, -0.03890092f, 0.04478738f, -0.05550507f, -0.02467734f, 0.03367453f, 
    -0.02765580f, 0.01532051f, 0.02067498f, -0.00548266f, -0.01992745f, 0.03543972f, 0.00167181f, 0.03893242f, 
    -0.23104046f, 0.12212109f, 0.00968773f, -0.10747167f, 0.14324227f, 0.09785309f, -0.04337920f, -0.05514828f, 
    0.12002391f, -0.09665558f, 0.06519433f, -0.09359325f, 0.08164194f, 0.05765834f, -0.07435855f, 0.09917100f, 
    -0.14377551f, -0.11419383f, -0.05415780f, -0.11725038f, 0.05538893f, -0.05744203f, -0.21170963f, 0.02482609f, 
    0.25564492f, 0.04130522f, -0.14675859f, -0.02318792f, -0.06518883f, 0.05646776f, 0.17802168f, -0.04986022f, 
    -0.02122498f, 0.01989964f, 0.19784489f, -0.00652532f, -0.03901927f, 0.12401145f, 0.00402530f, -0.01113266f, 
    0.02538778f, 0.02292561f, 0.14109854f, 0.05630329f, -0.09137928f, -0.17513554f, 0.12485295f, 0.00106635f, 
    -0.00832540f, -0.15706117f, 0.05248139f, -0.01543866f, -0.07218882f, 0.12811109f, 0.19035257f, -0.08086465f, 
    0.14661278f, -0.03417223f, 0.04291214f, 0.03258760f, -0.07391384f, 0.30223933f, -0.14676943f, 0.06158598f, 
    0.15062194f, 0.13523911f, 0.02949492f, 0.09863710f, 0.04066863f, -0.03946585f, -0.12152383f, 0.02171415f, 
    0.00707000f, -0.01528202f, -0.07530949f, 0.00053975f, 0.01447492f, 0.05967099f, -0.01915287f, 0.05239921f, 
    0.41269928f, -0.07235866f, -0.08792778f, 0.13932973f, -0.12744965f, -0.09071402f, -0.07097676f, 0.02068412f, 
    0.10409635f, 0.03045387f, 0.03784717f, 0.08327121f, 0.10145939f, -0.02825393f, 0.09698860f, -0.03390412f, 
    0.01957147f, -0.06088479f, 0.16924733f, -0.03325617f, -0.08973520f, -0.04058788f, 0.03083931f, 0.07777490f, 
    0.03520084f, -0.03089067f, -0.01528104f, -0.05318630f, 0.01908719f, 0.01670313f, 0.07863624f, 0.10830581f, 
    -0.12861851f, 0.00804278f, 0.04194320f, 0.01474763f, 0.02843085f, 0.06707506f, -0.00592917f, 0.08800729f, 
    0.17322232f, 0.23764743f, -0.00546361f, 0.15562277f, 0.06095151f, 0.23149851f, 0.09917253f, 0.11687757f, 
    -0.01159931f, 0.03414869f, 0.03310528f, 0.04624371f, -0.02350661f, 0.02278829f, -0.00332459f, 0.12279448f, 
    -0.03312127f, -0.18443762f, 0.00362414f, -0.16928431f, 0.06738522f, 0.15407981f, 0.24085632f, 0.13606235f, 
    -0.28405738f, -0.01301833f, 0.10214108f, -0.01728839f, 0.04948385f, -0.09772903f, -0.05919584f, -0.02983319f, 
    0.04136120f, 0.01351912f, -0.06987075f, 0.06294873f, 0.03957762f, -0.04747304f, -0.01279022f, -0.00856065f, 
    0.08309462f, -0.16812138f, 0.15567370f, -0.07822263f, -0.00407708f, -0.07454166f, 0.27021998f, 0.07505948f, 
    -0.00001411f, -0.07035511f, -0.05082276f, 0.09385157f, -0.04984739f, 0.00056228f, 0.18974896f, 0.00864371f, 
    0.04276022f, -0.07499994f, 0.15221880f, -0.05606591f, 0.22529151f, 0.06456902f, -0.27921230f, -0.07117349f, 
    -0.17540938f, 0.14141732f, 0.15131873f, -0.03246848f, 0.09271522f, 0.09834537f, -0.02942821f, 0.12499813f, 
    0.04356274f, 0.03522846f, 0.00824340f, 0.06589903f, -0.10752897f, 0.03226019f, -0.10087519f, -0.00906871f, 
    -0.12922938f, 0.01826864f, 0.01342930f, -0.08776414f, -0.28803730f, 0.11116616f, 0.09758244f, 0.13797431f, 
    -0.02355996f, 0.09549759f, -0.01302313f, -0.06334887f, -0.09668814f, -0.06312308f, 0.03164057f, 0.00781311f, 
    0.08373244f, -0.07863763f, -0.00006041f, -0.09800211f, -0.39754131f, 0.05613423f, 0.12950963f, -0.17253271f, 
    0.18364334f, -0.04959466f, 0.13643286f, 0.07307363f, 0.10588910f, -0.04739873f, 0.03700097f, -0.08710670f, 
    -0.02694492f, 0.08773556f, 0.03657278f, -0.11411866f, -0.01408633f, -0.02201721f, -0.04782630f, -0.00272066f, 
    -0.06462028f, -0.07649602f, 0.27101630f, 0.26073599f, -0.44873762f, 0.05526339f, 0.04473263f, 0.07304721f, 
    0.03142496f, -0.08414225f, 0.07592291f, 0.05314786f, -0.07959171f, 0.01677708f, -0.09924079f, 0.02107913f, 
    0.02401108f, -0.13820861f, 0.06115071f, -0.03184562f, 0.32374594f, -0.05468477f, 0.14013296f, -0.13587777f, 
    0.07321762f, -0.12274329f, 0.14207721f, -0.00649378f, -0.01424886f, -0.12306443f, 0.01700897f, -0.05968731f, 
    0.01884011f, 0.08676399f, 0.13931356f, -0.02283519f, 0.02399227f, -0.03513654f, -0.08118235f, 0.02241227f, 
    -0.52060813f, 0.19655967f, -0.01496889f, 0.16695671f, 0.22119641f, 0.03616372f, 0.03047880f, -0.03337911f, 
    -0.08077783f, -0.08409683f, 0.11513556f, 0.12736116f, -0.04881696f, -0.04346492f, -0.06047246f, -0.08524603f, 
    -0.04380583f, 0.02334626f, 0.03940707f, -0.19424430f, -0.05967648f, 0.28796345f, -0.22839917f, 0.16161506f, 
    0.12395930f, 0.06151116f, -0.15970781f, -0.06416602f, -0.05934443f, -0.04066681f, 0.10281246f, -0.08398191f, 
    0.01961556f, 0.02821838f, -0.03041827f, 0.03631923f, 0.06353559f, 0.00298659f, 0.01863438f, 0.04598627f, 
    -0.04448993f, -0.00872187f, 0.00531562f, 0.02793154f, -0.01375250f, -0.04365310f, 0.01194920f, 0.04351759f, 
    -0.02684713f, 0.01037298f, -0.01270372f, 0.00728541f, 0.05092045f, -0.03549590f, -0.05105891f, -0.01471506f, 
    0.02376146f, 0.02318663f, -0.01056299f, -0.05610701f, 0.00058905f, 0.01431137f, 0.01320914f, -0.02662562f, 
    0.02584578f, 0.03020347f, -0.03121612f, 0.02016763f, -0.00755961f, 0.00858839f, 0.02666865f, 0.04475340f, 
    -0.00052497f, -0.01841802f, -0.04757974f, 0.02358966f, -0.04800201f, -0.01559781f, 0.03120125f, 0.00099945f, 
    -0.04262693f, -0.04007924f, 0.04795046f, -0.03668644f, 0.03457871f, -0.02698107f, -0.01834038f, -0.01637271f, 
    0.03236784f, -0.02294342f, 0.00933594f, 0.00434884f, 0.00058200f, 0.04110127f, 0.01470698f, -0.03916300f, 
    -0.02633281f, -0.00645654f, -0.02938201f, -0.01159983f, -0.01326861f, -0.05738146f, 0.01318968f, -0.06284034f, 
    0.00483876f, -0.04457879f, 0.00597579f, -0.00169187f, 0.02902874f, 0.03250013f, 0.01690242f, 0.00582520f, 
    -0.02633512f, 0.02051833f, 0.02960829f, 0.04372760f, -0.00913169f, 0.00616790f, -0.00129963f, -0.04709652f, 
    -0.00073859f, -0.04996651f, -0.04537878f, -0.06531514f, 0.03419938f, 0.02428765f, 0.00140541f, 0.01722523f, 
    -0.02498505f, -0.04081570f, 0.01201223f, 0.01595633f, -0.04362393f, -0.03238042f, -0.04628958f, -0.02498695f, 
    0.02619709f, -0.04295661f, -0.03419768f, -0.00905624f, -0.06259147f, 0.02894496f, 0.00705612f, -0.05202311f, 
    0.00190247f, -0.01190115f, -0.01388822f, 0.02971265f, -0.00263280f, -0.01815437f, -0.00536604f, -0.05906028f, 
    0.04105784f, -0.04319857f, -0.03249523f, -0.05603547f, 0.04657515f, -0.04788281f, 0.02786456f, 0.02011842f, 
    0.02657924f, 0.05532350f, -0.04866596f, 0.04639924f, -0.05659061f, -0.06331825f, 0.00942613f, -0.03494409f, 
    -0.01057668f, -0.02031982f, -0.04930466f, 0.00914054f, 0.00784744f, -0.03739095f, -0.03792320f, -0.05279346f, 
    -0.00064723f, -0.03138447f, 0.00566716f, 0.05107810f, 0.04081101f, 0.02805899f, -0.02464664f, 0.00213852f, 
    -0.02567329f, -0.04348361f, 0.04082073f, -0.01141282f, 0.05215827f, -0.00689896f, 0.05050391f, -0.02790223f, 
    0.02082705f, -0.02783062f, -0.02063188f, 0.03318772f, -0.05456864f, -0.05188101f, 0.00372218f, 0.04206924f, 
    -0.05850852f, -0.02410288f, 0.00885787f, 0.04391396f, 0.03990267f, -0.00759568f, -0.01881735f, -0.03879422f, 
    -0.05341426f, 0.02315430f, -0.05262454f, -0.06115845f, -0.06467880f, 0.01741745f, -0.01121828f, -0.00631561f, 
    0.00522479f, -0.02913579f, -0.03715748f, -0.00496011f, -0.03928053f, 0.04230792f, -0.00934446f, -0.02739376f, 
    -0.02587060f, -0.02523860f, 0.05223722f, 0.01906022f, 0.02334141f, 0.00441938f, 0.02954903f, 0.00477259f, 
    0.02369085f, 0.00765335f, -0.03884772f, -0.03191724f, 0.00344525f, -0.01315016f, -0.02588851f, 0.02523454f, 
    -0.02654321f, 0.02907819f, 0.03893160f, 0.01254570f, -0.02820351f, -0.00566253f, -0.04248291f, -0.03583603f, 
    0.00148907f, 0.01791716f, -0.05147834f, 0.01122574f, 0.04638445f, 0.02221422f, -0.02033762f, -0.05271373f, 
    -0.05582138f, -0.01573023f, -0.04028025f, -0.04222138f, 0.02872754f, 0.01614917f, 0.03985182f, 0.04557515f, 
    -0.03967620f, 0.03141536f, 0.01314717f, 0.00871874f, 0.04636243f, 0.03781468f, 0.05052086f, -0.04130967f, 
    0.01410631f, -0.00704357f, -0.01107460f, 0.02629846f, -0.03408362f, 0.04123672f, -0.00646251f, 0.03200698f, 
    0.04058620f, 0.01461998f, 0.00881754f, -0.00254320f, -0.03900760f, -0.01835006f, -0.03551038f, 0.00222195f, 
    0.02936073f, 0.04447535f, -0.00075996f, -0.05960828f, -0.01489075f, 0.01475823f, -0.01167245f, -0.01861172f, 
    0.02812824f, 0.03646093f, -0.04969262f, 0.04348297f, -0.00605971f, -0.02610304f, -0.04899153f, -0.02808188f, 
    0.00810272f, 0.03300663f, 0.00508613f, -0.02085162f, 0.04103190f, -0.03827878f, -0.02825061f, 0.02150412f, 
    0.03694667f, 0.03912960f, 0.00391068f, -0.02785865f, -0.03343334f, -0.00953486f, 0.02386700f, 0.02495993f, 
    -0.05535486f, 0.01047379f, -0.00572526f, 0.00348271f, -0.00471598f, -0.04517415f, 0.03549992f, 0.02798472f, 
    0.04722241f, -0.01758973f, -0.04893478f, -0.06060421f, -0.05012427f, 0.03500393f, 0.04868633f, -0.01299018f, 
    -0.05022433f, -0.02448713f, 0.04353790f, -0.02990473f, -0.00759358f, -0.01181648f, -0.04555176f, 0.03633030f, 
    -0.04990837f, -0.02344262f, -0.01363390f, 0.04924249f, -0.02171419f, 0.03839979f, -0.04576363f, 0.00040280f, 
    -0.06340022f, -0.04674871f, -0.03742580f, 0.04347825f, -0.00394337f, -0.00375403f, -0.03788887f, -0.05835032f, 
    0.44596732f, -0.10598884f, -0.33227220f, -0.07824184f, 0.20366465f, 0.04748821f, 0.01660301f, 0.00436879f, 
    0.05769990f, -0.00758034f, 0.00248179f, 0.11868012f, 0.01265631f, 0.13205357f, 0.11596764f, -0.05384901f, 
    0.08765707f, 0.00735780f, 0.03210510f, 0.01064998f, 0.36396131f, 0.09999963f, -0.00148698f, -0.09507206f, 
    0.11501365f, 0.15094464f, 0.07219020f, -0.04235011f, -0.03775179f, 0.05255906f, 0.03317477f, -0.07889672f, 
    -0.04412777f, -0.06555776f, -0.11839707f, -0.13323110f, 0.00487295f, 0.10864078f, 0.02226725f, 0.05372967f, 
    0.13802297f, 0.34222186f, -0.18270278f, -0.20086414f, 0.23541062f, 0.00758870f, -0.11027739f, -0.10499190f, 
    0.09733777f, 0.03893812f, -0.01713937f, -0.05699715f, 0.06733587f, 0.01445042f, -0.04806078f, 0.04283234f, 
    -0.00841341f, -0.00992996f, -0.10831415f, 0.05206576f, 0.00173731f, -0.09589351f, -0.05994199f, -0.03141715f, 
    0.32100618f, 0.10087469f, -0.01840165f, 0.00731070f, 0.00918684f, 0.03450504f, -0.10382809f, -0.05683866f, 
    -0.00156289f, 0.05034994f, 0.02413473f, -0.03048008f, -0.05145504f, -0.05303907f, 0.01215675f, 0.02375392f, 
    0.06178054f, -0.20415971f, 0.17252617f, -0.02654024f, -0.09182808f, 0.09029067f, 0.08575860f, 0.16322394f, 
    -0.06635576f, 0.01651677f, 0.02279512f, -0.04781564f, 0.04245282f, -0.04735847f, 0.03058274f, 0.01206904f, 
    0.04449502f, 0.02540749f, -0.12518969f, -0.03005533f, 0.19294292f, -0.05580162f, 0.10724131f, 0.04712587f, 
    0.06048980f, -0.00043127f, 0.21305586f, -0.01425608f, 0.09733035f, 0.03073935f, 0.02340137f, -0.03689446f, 
    -0.00559118f, -0.05393251f, 0.06559120f, 0.10133017f, 0.16317868f, 0.02927460f, 0.08713329f, -0.03045493f, 
    -0.42032269f, 0.25469798f, -0.06770643f, -0.29132730f, -0.06242224f, 0.12764467f, -0.00973799f, -0.04965400f, 
    0.04316094f, 0.00025154f, 0.05400755f, 0.00052337f, 0.03891457f, 0.04636650f, 0.06459413f, 0.03602161f, 
    0.01203347f, -0.01291618f, -0.02473810f, 0.17284156f, -0.25678802f, -0.06385450f, 0.01693995f, -0.01754398f, 
    0.09580240f, -0.04248364f, 0.05645661f, 0.00299586f, 0.08116854f, 0.08140764f, -0.05967082f, -0.04231521f, 
    0.18400694f, -0.05795492f, 0.04335883f, -0.04849646f, 0.05395612f, 0.11998813f, 0.00508744f, 0.13294491f, 
    0.07519016f, 0.01788533f, -0.02027107f, 0.18552338f, 0.14858356f, -0.07821841f, 0.06414846f, 0.05218458f, 
    0.14476566f, -0.04966474f, 0.11156559f, 0.04807066f, 0.10531748f, 0.00996052f, -0.02185161f, 0.12609746f, 
    -0.04133179f, 0.00503244f, 0.03705939f, -0.01098226f, -0.12476327f, -0.12096588f, -0.05725589f, -0.03006392f, 
    0.11270853f, 0.01860263f, -0.00185242f, -0.04450606f, -0.09028990f, -0.09241318f, 0.02642876f, -0.18210852f, 
    -0.11124694f, -0.01915587f, -0.02295351f, -0.07392079f, -0.01002924f, 0.06287146f, 0.20092194f, 0.05542718f, 
    -0.45751518f, -0.08622444f, -0.06560212f, 0.26109248f, 0.03856132f, -0.04501099f, 0.04538224f, -0.00408893f, 
    0.04375974f, -0.08330230f, -0.10537352f, -0.17625254f, 0.07970462f, 0.07293669f, 0.09765860f, 0.06772313f, 
    0.04995157f, 0.06825319f, -0.04671588f, -0.04609311f, 0.00658521f, -0.20500962f, -0.17939071f, 0.11032850f, 
    0.24084252f, 0.01167202f, -0.13431676f, 0.05209947f, -0.05167475f, 0.17154662f, -0.08139852f, 0.00105629f, 
    0.02596481f, 0.12993056f, -0.05909256f, -0.04884489f, 0.01982236f, 0.10057021f, -0.07059539f, -0.00539686f, 
    0.01999390f, -0.20636316f, 0.07301524f, 0.08335554f, 0.05038762f, -0.00173705f, 0.11776067f, 0.08215079f, 
    0.03562362f, -0.09026012f, 0.04102754f, 0.02633455f, -0.02732755f, 0.05989973f, 0.05145403f, 0.00620689f, 
    0.07323326f, 0.08596764f, -0.04362511f, 0.02266872f, -0.42911506f, 0.00106515f, 0.41534868f, -0.18148541f, 
    -0.68078065f, 0.04285687f, 0.01421438f, 0.07051822f, -0.04066700f, 0.06965462f, 0.01641178f, 0.11734574f, 
    -0.00612935f, -0.00377994f, -0.01889251f, -0.01365969f, -0.07563441f, -0.11695388f, 0.08839295f, 0.07623239f, 
    -0.09266320f, 0.15060353f, 0.08307260f, 0.01437577f, 0.06124902f, 0.08086800f, 0.01977467f, 0.03502136f, 
    0.01748512f, -0.03388934f, 0.01659520f, 0.05771067f, -0.07040161f, -0.04921471f, -0.01340345f, 0.04513007f, 
    -0.03259562f, 0.00529529f, 0.14703768f, -0.02422466f, -0.16680956f, -0.09606069f, -0.16411668f, 0.08570487f, 
    -0.00976833f, 0.04068348f, 0.13130961f, 0.00381606f, -0.02123724f, 0.03192888f, -0.07648102f, 0.07965599f, 
    0.02920357f, 0.04701395f, -0.00721489f, 0.08768588f, 0.14117742f, 0.04534884f, 0.03011773f, -0.02588633f, 
    -0.03178848f, -0.03137216f, 0.00979855f, 0.00160504f, -0.01873133f, -0.05259581f, -0.01687551f, -0.03615215f, 
    -0.06244957f, -0.00723308f, -0.03832698f, 0.03322552f, -0.02388968f, 0.04398567f, 0.01786989f, -0.05778928f, 
    -0.04164166f, -0.01922059f, -0.05920403f, 0.03323666f, 0.01690861f, -0.05020798f, 0.01944461f, 0.03304579f, 
    -0.04914799f, -0.04277887f, 0.02165771f, -0.02094622f, -0.03143844f, 0.03711371f, -0.06233850f, -0.01805773f, 
    -0.01092053f, -0.01679999f, -0.02926681f, -0.06260011f, -0.06396861f, -0.00295202f, -0.02987201f, 0.04180940f, 
    0.04125676f, 0.01323205f, -0.03900569f, -0.05860748f, -0.06540763f, -0.01762441f, 0.03827168f, 0.01690357f, 
    -0.06185288f, -0.00231225f, -0.04939058f, 0.03212203f, -0.02555863f, 0.03986548f, 0.02035999f, 0.01434497f, 
    0.02216331f, -0.01985271f, -0.04897643f, -0.02271151f, -0.01136735f, 0.00562155f, -0.00272362f, -0.00075851f, 
    -0.04061237f, -0.01796815f, -0.03557272f, -0.04548054f, -0.00176291f, -0.02662537f, -0.01647994f, -0.02903645f, 
    -0.05816972f, 0.02624988f, -0.02441726f, -0.04458396f, -0.03016034f, -0.02906520f, -0.01479284f, -0.02924346f, 
    -0.02451556f, 0.04111970f, -0.03762838f, 0.04742805f, 0.00909611f, -0.06307842f, 0.04260760f, 0.02783708f, 
    -0.00563040f, -0.02213142f, 0.01720772f, 0.00959767f, 0.02255232f, 0.01703922f, 0.03966973f, -0.03706584f, 
    -0.05716727f, -0.04221496f, -0.06366073f, -0.02085661f, -0.05114111f, -0.05771941f, -0.04679653f, 0.01857548f, 
    0.00066003f, -0.00354372f, -0.04645790f, 0.00430837f, 0.03144480f, -0.01390870f, -0.00774565f, -0.02982941f, 
    -0.02947716f, -0.04606740f, 0.01371947f, 0.02957665f, -0.05718600f, 0.01583606f, -0.04022494f, 0.02117930f, 
    -0.01330948f, 0.02536442f, -0.03929118f, -0.05643027f, 0.04013927f, -0.01430894f, 0.04288629f, 0.03383417f, 
    0.02295609f, 0.03730104f, 0.02256821f, 0.00355038f, 0.03153477f, -0.00830298f, -0.00046174f, 0.01741436f, 
    0.02731344f, -0.04422386f, -0.03929663f, -0.00837911f, -0.02954258f, -0.00083342f, -0.00225173f, -0.00212688f, 
    -0.01040611f, 0.01977850f, -0.01233321f, -0.03104782f, 0.03548529f, 0.00795759f, -0.02569437f, -0.01381586f, 
    -0.06200650f, 0.04170344f, 0.03654787f, 0.02542549f, -0.03773081f, -0.00390848f, -0.02311636f, -0.00818329f, 
    0.01491807f, -0.02218687f, -0.06345267f, 0.03347382f, 0.00695544f, -0.04382532f, -0.01386890f, -0.05848771f, 
    -0.05452919f, 0.02711628f, -0.06129988f, 0.00506152f, 0.04351208f, -0.01056010f, -0.06071425f, 0.00907370f, 
    0.03560031f, 0.00973950f, -0.05145983f, -0.02398031f, 0.00852066f, 0.03136997f, 0.00666680f, -0.03933437f, 
    -0.00992477f, -0.00912735f, -0.05123079f, 0.04317657f, -0.06511562f, -0.00935236f, -0.00275524f, 0.01617889f, 
    -0.05950902f, -0.04265707f, 0.03463670f, -0.00532887f, -0.03231469f, 0.00040279f, -0.02225602f, -0.05483511f, 
    0.02908637f, -0.04698542f, -0.06168055f, 0.02151213f, 0.02579887f, -0.01741841f, 0.01434650f, 0.04154260f, 
    -0.04752183f, 0.00953013f, -0.06090117f, 0.03146907f, -0.03287157f, 0.03810277f, -0.04376794f, 0.02162119f, 
    0.04274593f, -0.00573562f, 0.03948407f, -0.04793694f, -0.02470165f, 0.01621708f, -0.05765028f, -0.04674624f, 
    0.03927644f, 0.03178158f, 0.00304482f, -0.02174604f, -0.00655758f, -0.03572701f, -0.00802982f, 0.00936158f, 
    -0.03313453f, -0.05586207f, 0.01806802f, 0.01142660f, -0.00873841f, 0.01630134f, 0.03237231f, -0.01053484f, 
    -0.06722561f, -0.02816728f, -0.05731014f, -0.01721850f, 0.01948469f, -0.02059817f, 0.03753775f, 0.04086597f, 
    -0.00539470f, 0.00387551f, -0.05827817f, 0.02934230f, -0.00047090f, 0.02086407f, -0.02552475f, -0.03636079f, 
    0.02075450f, 0.03135249f, 0.03136483f, -0.03088522f, 0.02948339f, 0.02390232f, 0.00665779f, -0.04695914f, 
    0.02636477f, -0.04317975f, 0.03416650f, 0.00309277f, 0.02825509f, -0.05101252f, -0.04116583f, -0.02574122f, 
    0.01852256f, -0.06245091f, -0.05476235f, 0.03824401f, -0.04390612f, -0.02803935f, -0.06254953f, -0.05764812f, 
    -0.03340788f, 0.02986335f, -0.01253271f, 0.04249451f, -0.04303791f, 0.01632092f, -0.05806975f, 0.00740116f, 
    -0.01854690f, 0.00764216f, 0.00597964f, -0.04782470f, 0.01229262f, 0.04248676f, 0.02025737f, 0.00505337f, 
    0.01601893f, -0.02297956f, -0.03896897f, -0.01561315f, -0.04375251f, -0.06559410f, 0.00094488f, -0.00665682f, 
    -0.03332077f, 0.00581817f, 0.03849750f, -0.02124800f, -0.03210426f, 0.02716282f, 0.02764417f, 0.03665871f, 
    0.04234435f, 0.02424879f, -0.03687322f, -0.01942674f, 0.02943840f, -0.02305428f, -0.04481716f, -0.02845436f, 
    0.06336544f, 0.05801833f, -0.11453796f, -0.07941705f, 0.13640463f, 0.03434663f, -0.03892749f, -0.02427071f, 
    0.00204728f, -0.04060069f, -0.05585412f, 0.01632139f, 0.10211488f, 0.00049181f, -0.01616622f, 0.03675154f, 
    -0.09947749f, -0.05691341f, 0.01158836f, -0.10760707f, 0.06328554f, 0.18106177f, -0.10962820f, 0.04708169f, 
    0.27558804f, 0.06376040f, -0.06882598f, -0.02328262f, 0.09833987f, 0.18097059f, 0.15496314f, -0.00998039f, 
    -0.03465258f, 0.11608757f, 0.19820282f, 0.00564875f, -0.05111777f, 0.12628046f, -0.04311064f, -0.06476060f, 
    0.13331321f, 0.00116029f, -0.01300832f, 0.00780795f, -0.15410282f, -0.07814573f, 0.23707022f, 0.01131642f, 
    0.06805212f, -0.09087609f, -0.01165682f, -0.07794444f, -0.12607820f, -0.03490171f, 0.13866527f, -0.14761658f, 
    0.14621495f, 0.07041141f, 0.01932911f, -0.02905693f, -0.06634352f, 0.10655055f, -0.27053037f, 0.01380898f, 
    0.24935675f, -0.00844285f, -0.07210839f, 0.02956488f, -0.12378033f, -0.04753103f, -0.17103197f, 0.09105270f, 
    -0.02761655f, -0.11640455f, 0.02995929f, -0.04135690f, -0.07682036f, -0.00262558f, -0.05189480f, 0.03067268f, 
    0.27692646f, 0.08567522f, -0.06398249f, 0.02483927f, -0.22401126f, -0.13883393f, -0.02719654f, 0.06105032f, 
    0.05363119f, -0.05605556f, 0.00634943f, 0.07500057f, -0.02202869f, 0.07663132f, 0.07441769f, -0.00277411f, 
    0.01464737f, -0.00527647f, 0.03783210f, 0.02857593f, 0.05662037f, 0.12034293f, -0.01810841f, 0.03050431f, 
    -0.00563573f, -0.04891656f, 0.08394814f, 0.07755640f, -0.03916378f, -0.04131246f, 0.07886677f, 0.05210595f, 
    -0.03387544f, -0.01547884f, 0.08112953f, 0.01212062f, 0.07019885f, 0.10202181f, -0.02053140f, 0.05307619f, 
    -0.04132193f, 0.07009143f, -0.07841907f, 0.06792307f, 0.07208061f, 0.21339001f, 0.15608454f, 0.02167651f, 
    0.09043979f, 0.09342217f, -0.06879707f, 0.02009010f, -0.03119460f, -0.04285750f, 0.06025615f, 0.05838026f, 
    0.05421920f, -0.06522510f, 0.03290976f, -0.00747745f, -0.06492823f, 0.16565143f, 0.00726411f, 0.06174065f, 
    -0.18363294f, 0.03208488f, 0.05339641f, -0.01470832f, 0.03126617f, 0.05443254f, -0.14430380f, -0.14389603f, 
    0.05454059f, -0.03653248f, -0.15385231f, -0.01226505f, 0.05039332f, -0.00063954f, -0.01355666f, 0.07767406f, 
    -0.21103571f, -0.06392612f, -0.07079305f, -0.18035127f, 0.04521330f, -0.06793042f, 0.23744056f, -0.03187642f, 
    0.05328182f, -0.06666302f, -0.05506442f, 0.21180744f, 0.09037387f, -0.01528069f, 0.03855970f, 0.04418275f, 
    0.05203969f, -0.00613158f, 0.06137180f, -0.09046312f, -0.24827361f, 0.19219899f, -0.12522346f, -0.11654487f, 
    -0.09537426f, 0.13051645f, 0.03873060f, -0.16393808f, 0.05264279f, 0.09433924f, 0.03059188f, 0.06446893f, 
    0.06328399f, -0.04395948f, -0.04213631f, 0.00016630f, -0.03776718f, -0.12762997f, 0.12459905f, 0.08374470f, 
    -0.25874522f, -0.04386645f, 0.13760795f, 0.01937122f, -0.23562741f, 0.08818792f, 0.01487616f, 0.14272702f, 
    -0.00091367f, 0.11093681f, -0.05615722f, -0.09335148f, 0.01937954f, 0.10986456f, 0.10439008f, -0.07363567f, 
    -0.10296375f, 0.06049363f, 0.07450557f, -0.06986168f, -0.24985258f, -0.02094126f, -0.21184292f, -0.02636645f, 
    0.20057027f, 0.01597088f, -0.06968056f, 0.06812590f, -0.02098924f, 0.05093302f, -0.01592515f, -0.03723583f, 
    -0.01519896f, -0.01240164f, 0.12519576f, -0.01836465f, -0.07013337f, -0.02671943f, 0.01369482f, 0.09357142f, 
    -0.25659087f, -0.00790407f, 0.14952435f, 0.19633941f, -0.27592206f, -0.02356194f, 0.00028904f, 0.05598973f, 
    -0.01681502f, -0.06125898f, 0.04804684f, 0.04031946f, -0.05056661f, -0.00911769f, -0.08402256f, 0.00264658f, 
    0.09043609f, -0.17718713f, 0.07181524f, 0.03520875f, -0.01333770f, 0.01137349f, 0.11517818f, 0.04120254f, 
    0.00700175f, 0.08137212f, 0.30973464f, 0.06295110f, 0.01114583f, -0.05476048f, 0.06860879f, 0.01233638f, 
    0.03201564f, -0.00833939f, 0.04800689f, -0.01033255f, -0.00009600f, -0.01234689f, 0.07223625f, 0.03347492f, 
    -0.39348516f, 0.20031686f, -0.05396159f, 0.09979351f, 0.13874725f, 0.12123244f, 0.01012957f, -0.09983391f, 
    -0.07592747f, -0.08693208f, 0.08391166f, 0.01358290f, 0.00486390f, -0.02334658f, 0.01305239f, 0.03691982f, 
    -0.07913922f, -0.06242002f, 0.07312346f, -0.14908087f, -0.04301915f, 0.19019221f, -0.23951475f, 0.09204580f, 
    0.04658170f, 0.10607784f, -0.07427131f, -0.04250392f, -0.07841989f, 0.01464944f, 0.17766893f, 0.03537788f, 
    0.08812715f, 0.00810252f, 0.02183045f, 0.04619409f, 0.13931224f, 0.05836926f, -0.00491745f, 0.15215693f, 
    0.07755286f, -0.24837047f, -0.10548189f, 0.00800954f, 0.03897423f, 0.05642328f, 0.04931927f, 0.03677557f, 
    0.03217299f, 0.04142518f, 0.05559168f, 0.11015236f, 0.05753596f, 0.04397694f, 0.04153654f, -0.07950263f, 
    -0.02409637f, -0.03207984f, 0.03174154f, -0.12480594f, -0.07131203f, -0.08161083f, -0.17982908f, 0.15767339f, 
    0.07507206f, -0.03715333f, 0.08407424f, -0.06966455f, -0.22457458f, 0.06895375f, -0.09782349f, -0.04117835f, 
    0.04904503f, -0.17635483f, 0.03664367f, -0.04467490f, -0.17787176f, 0.02518127f, 0.11402038f, -0.06583332f, 
    0.49553761f, -0.11667785f, 0.04563273f, 0.05789625f, 0.18500473f, -0.05733987f, 0.07990301f, 0.16740297f, 
    0.01359368f, 0.06808329f, -0.02316935f, -0.07995551f, -0.08675041f, 0.08087184f, -0.17195463f, 0.14671895f, 
    0.02774741f, -0.02882278f, -0.03960645f, 0.05129028f, 0.25984877f, -0.05294982f, -0.00162886f, 0.05614174f, 
    0.21568570f, 0.01235281f, 0.01992866f, -0.03252637f, -0.01954203f, -0.06149797f, -0.03193156f, -0.00781406f, 
    0.08917955f, 0.17238581f, 0.02775115f, 0.04784439f, -0.00060206f, 0.07134949f, -0.01198227f, 0.13110209f, 
    0.56811875f, -0.24031439f, 0.04489250f, -0.01260920f, -0.19578417f, 0.03979824f, 0.02636532f, 0.04626958f, 
    -0.05921990f, 0.05583165f, 0.00654808f, -0.02509384f, 0.07511233f, 0.01847661f, -0.01032574f, -0.09094573f, 
    0.04675843f, -0.08282495f, -0.07119626f, -0.17630024f, -0.18514246f, -0.12948869f, -0.10572526f, -0.10600989f, 
    0.08012467f, 0.00238572f, -0.01101352f, -0.07839418f, 0.05053872f, 0.07230569f, -0.09462819f, -0.03864529f, 
    -0.09626940f, -0.00927948f, -0.05390768f, 0.17517431f, 0.03331449f, 0.17747872f, 0.20163751f, 0.04025444f, 
    0.25631320f, 0.02251057f, 0.14405076f, -0.05518975f, 0.12158615f, 0.00425234f, -0.01889961f, 0.09361558f, 
    0.11442819f, -0.04503804f, 0.00429147f, -0.01842615f, 0.06232884f, -0.00238244f, -0.00245314f, 0.17085704f, 
    -0.10149483f, -0.06556929f, -0.08680159f, 0.03762691f, -0.14575182f, 0.07416053f, 0.04172893f, 0.23428130f, 
    0.26852438f, -0.08422002f, 0.06787235f, 0.02875095f, -0.05133085f, 0.02811813f, -0.08716805f, 0.06756733f, 
    0.03011610f, 0.09320539f, -0.10134668f, 0.13722858f, -0.00345563f, 0.21820305f, -0.04516532f, -0.02725485f, 
    0.12037341f, 0.17109944f, 0.02937243f, 0.17247851f, 0.21805784f, 0.04319980f, -0.00548925f, -0.05182828f, 
    -0.02688528f, 0.01779989f, 0.04619616f, 0.06904499f, 0.05228180f, 0.14218265f, -0.04390763f, 0.15899321f, 
    -0.00164837f, 0.04967383f, 0.04794670f, 0.05000548f, 0.13103728f, 0.06508785f, 0.01508902f, 0.02078756f, 
    0.02337860f, -0.06103219f, 0.01127355f, -0.24413612f, 0.10354726f, 0.03415286f, -0.21082641f, -0.01269642f, 
    -0.07660861f, 0.11748827f, -0.01991572f, -0.09409620f, -0.06595626f, 0.06366184f, 0.06913652f, -0.14249347f, 
    -0.30871683f, -0.25086209f, 0.21356541f, -0.00805232f, -0.06427784f, 0.08594617f, -0.02464207f, 0.15161854f, 
    0.07443891f, 0.12201788f, -0.11361147f, -0.02702359f, 0.01539729f, 0.16265352f, -0.00650840f, 0.04713009f, 
    -0.11067677f, -0.06401197f, -0.22567979f, 0.02605006f, 0.07618764f, -0.20622435f, 0.05010016f, -0.03077645f, 
    0.16909599f, 0.06566571f, 0.04345237f, -0.09833657f, -0.00575626f, 0.04188275f, -0.05417070f, 0.05727959f, 
    0.09528009f, 0.21449669f, -0.01426621f, -0.05132584f, 0.00429445f, -0.04181070f, -0.01933186f, 0.09589785f, 
    0.30685210f, -0.17998590f, 0.15482980f, -0.00064312f, -0.08693577f, 0.01708834f, 0.01648983f, 0.10380162f, 
    0.07336618f, -0.12051164f, -0.11436062f, 0.01701426f, -0.10301043f, 0.04858325f, -0.13292709f, -0.03244985f, 
    -0.13954516f, 0.17302693f, -0.03648153f, -0.00397945f, 0.24805073f, 0.30813286f, -0.16382106f, -0.15819393f, 
    -0.21700841f, 0.04825912f, 0.05517973f, 0.20420769f, 0.04631395f, -0.08816488f, -0.00354553f, 0.01504625f, 
    -0.07274473f, -0.18734334f, -0.05407997f, 0.04190478f, 0.04077575f, -0.12003157f, 0.16572829f, 0.13450339f, 
    0.10155945f, -0.31258988f, 0.16064218f, -0.13772866f, 0.25637209f, -0.01519227f, 0.08373183f, -0.10597208f, 
    -0.04295732f, -0.00227337f, 0.06600048f, 0.03127741f, -0.09548945f, -0.03982401f, 0.07831378f, -0.03388435f, 
    -0.10925565f, 0.05794383f, 0.00006142f, 0.00667551f, 0.11355384f, -0.03157448f, -0.06472499f, -0.08270480f, 
    0.10041770f, 0.06192018f, -0.04122237f, -0.08066002f, -0.12518834f, 0.02173305f, -0.11335026f, 0.05772489f, 
    -0.01210530f, -0.09221469f, -0.07674154f, 0.03251496f, 0.03869152f, 0.17157751f, 0.08392271f, 0.03840613f, 
    0.04842063f, -0.03623604f, 0.00975986f, 0.00549845f, -0.06047603f, 0.02542977f, -0.05585346f, -0.04366390f, 
    -0.01140689f, -0.02755322f, 0.01074764f, -0.02075687f, -0.03858051f, 0.01286665f, -0.03180302f, 0.04817308f, 
    0.03181393f, -0.04083829f, 0.04957406f, -0.03874560f, -0.03668292f, 0.04711486f, -0.00038473f, -0.00481424f, 
    0.03094051f, -0.05821487f, 0.02605976f, -0.01891091f, -0.01270963f, -0.03860229f, -0.00076234f, 0.05071617f, 
    0.00534123f, 0.04885898f, -0.04052635f, -0.03232108f, 0.02197932f, -0.03384312f, -0.05296999f, 0.01146757f, 
    -0.02646773f, 0.03862531f, -0.04861427f, 0.00274946f, 0.03245329f, 0.02425263f, -0.00488201f, -0.03380105f, 
    0.05725901f, 0.04193674f, 0.05368098f, -0.02590861f, -0.04700632f, -0.01574600f, 0.04371301f, -0.04664690f, 
    0.01841577f, -0.04819431f, -0.02767255f, -0.03773329f, 0.00319990f, -0.01562407f, -0.05122080f, -0.04368597f, 
    -0.05015955f, 0.00182089f, 0.04281248f, -0.03746608f, -0.03091772f, 0.01841811f, 0.00828285f, 0.04785097f, 
    0.01348001f, -0.01335888f, -0.01535311f, -0.03630628f, 0.01003095f, -0.01487083f, 0.01997188f, 0.01207491f, 
    0.02810727f, -0.03049018f, -0.02771769f, 0.01133408f, -0.04701942f, 0.02573309f, 0.00042243f, 0.03685348f, 
    0.04516386f, -0.05866552f, -0.03746420f, -0.03019145f, 0.01885756f, -0.03468457f, -0.04483043f, -0.04681391f, 
    0.01170662f, -0.04203623f, -0.01786045f, -0.03159009f, 0.00753961f, -0.03840108f, 0.04827906f, 0.03204723f, 
    -0.00128587f, 0.01473103f, 0.02284566f, 0.00586238f, 0.04275793f, 0.01744219f, -0.02956801f, -0.04818156f, 
    -0.01752586f, -0.03996849f, 0.01652307f, -0.03218682f, -0.02574975f, 0.03555258f, -0.04773716f, -0.04869818f, 
    -0.05843860f, -0.02698325f, -0.04972131f, -0.01280476f, -0.00687362f, -0.01399999f, 0.00932966f, -0.05259903f, 
    0.02908601f, -0.02381632f, 0.04008411f, -0.05085468f, -0.05015464f, -0.02283636f, 0.01793441f, -0.05491966f, 
    -0.00219547f, 0.03908756f, -0.05927413f, 0.01529357f, -0.04325732f, 0.01835309f, -0.03395985f, -0.05887178f, 
    -0.02729205f, 0.02800876f, 0.04106867f, -0.05124210f, -0.02193076f, 0.03765389f, -0.01226272f, 0.02720222f, 
    -0.04417257f, -0.00467892f, 0.02676406f, -0.00445195f, -0.05091031f, 0.01123302f, -0.02722258f, -0.03621460f, 
    -0.03390837f, 0.03747390f, 0.05113780f, -0.00454467f, -0.04709631f, -0.04531344f, 0.03769517f, -0.00600572f, 
    -0.04772811f, -0.02121213f, -0.04594665f, 0.02800070f, -0.02397768f, 0.02014634f, 0.02257494f, -0.02760779f, 
    0.03819827f, -0.03706917f, -0.01156124f, 0.02310382f, -0.02627103f, -0.05349706f, -0.00121673f, 0.02308736f, 
    0.02106655f, 0.04902790f, -0.01593992f, -0.05704653f, -0.03563337f, -0.05804308f, 0.03621136f, 0.05629243f, 
    0.00412732f, 0.01355761f, -0.03562648f, -0.02556274f, -0.03518072f, -0.03045180f, -0.02157849f, 0.04833717f, 
    -0.03943865f, -0.04476087f, -0.05259277f, -0.02882326f, 0.02543815f, 0.02501003f, 0.00835555f, 0.03994899f, 
    0.03183841f, 0.02470452f, -0.01166011f, 0.03562704f, -0.03428051f, 0.04873144f, 0.00478316f, 0.03706673f, 
    0.00114780f, -0.02718130f, 0.01075489f, 0.00571418f, -0.01016009f, -0.02592234f, 0.03233867f, -0.02417043f, 
    0.03162558f, -0.00604166f, -0.01184835f, -0.03290874f, -0.05445352f, -0.04787466f, -0.03254708f, -0.05147788f, 
    0.01110920f, -0.00563856f, -0.01273428f, -0.05389242f, -0.03659236f, -0.04626963f, 0.02068663f, -0.02894001f, 
    -0.03733641f, -0.01908182f, -0.03718789f, -0.05272123f, -0.02558301f, 0.01178325f, -0.03488297f, 0.02921762f, 
    -0.01815151f, 0.04550885f, -0.01387446f, 0.05241092f, -0.04159441f, -0.02481660f, 0.02065511f, 0.04754348f, 
    0.03084686f, -0.00800297f, -0.04322196f, -0.05456136f, 0.03854265f, 0.02257827f, 0.02773077f, -0.02855910f, 
    0.01862366f, -0.03544947f, -0.00783824f, 0.02734097f, 0.00222907f, 0.00898621f, 0.03921600f, -0.04457759f, 
    -0.01616554f, 0.00035095f, 0.04290798f, 0.00715708f, 0.01903316f, 0.02328175f, -0.05183632f, -0.02154761f, 
    0.04360168f, -0.02050851f, 0.03706176f, 0.02561807f, -0.02944084f, 0.02801027f, -0.01603316f, 0.00135662f, 
    0.05231753f, -0.04938884f, 0.04684810f, -0.01044787f, -0.03998117f, -0.04164996f, 0.04051283f, -0.02401426f, 
    -0.00560591f, -0.05096119f, 0.04579209f, -0.01795754f, 0.00862011f, -0.00968894f, 0.01536663f, 0.04591585f, 
    -0.00853958f, -0.05113109f, 0.04527077f, -0.01522960f, -0.01765038f, 0.01960792f, -0.01095070f, 0.03954484f, 
    0.03817411f, 0.03216485f, -0.03319186f, 0.00418654f, -0.04139523f, -0.01079759f, 0.02106400f, -0.00457951f, 
    0.03743389f, -0.04393592f, 0.03940464f, -0.04169860f, -0.00250409f, 0.03507716f, -0.01802543f, -0.01837933f, 
    -0.02631516f, -0.00417616f, 0.02526803f, 0.00176130f, -0.04605062f, 0.03001950f, 0.01473230f, -0.05412402f, 
    0.04049040f, -0.02407551f, 0.02131419f, 0.01171536f, 0.04973470f, 0.04432371f, 0.00614914f, 0.04393126f, 
    -0.00422306f, -0.02385025f, 0.01119342f, 0.02128355f, -0.01423787f, -0.00737885f, -0.00179282f, -0.05230420f, 
    -0.02318344f, -0.04649233f, -0.03428959f, -0.03612597f, -0.02691147f, 0.03987784f, -0.00692308f, -0.00990218f, 
    -0.03223974f, 0.01351906f, -0.03688481f, 0.01797337f, -0.00177969f, -0.01410553f, 0.01615566f, -0.05602926f, 
    -0.02987182f, 0.02020994f, -0.00133560f, -0.04039637f, -0.05457019f, -0.05705320f, 0.00286999f, -0.01510643f, 
    -0.02810207f, 0.02529183f, 0.02613733f, 0.03090029f, -0.03419514f, -0.05014214f, -0.02130801f, 0.01441431f, 
    -0.05164609f, -0.04026747f, -0.04980262f, 0.05296475f, 0.02650511f, 0.01854023f, 0.03413311f, -0.02780161f, 
    0.02193907f, -0.00039780f, -0.01201939f, -0.03779159f, 0.04174893f, 0.01820846f, 0.01574880f, -0.05274791f, 
    -0.06851330f, -0.00922711f, 0.01452153f, -0.01393693f, 0.00056383f, 0.01441640f, -0.05511074f, -0.00665105f, 
    -0.06057361f, 0.01016367f, 0.03071233f, -0.05121129f, -0.02982911f, 0.01923527f, 0.01995721f, -0.01619880f, 
    -0.03923211f, 0.02699136f, 0.03016395f, 0.00222862f, -0.01439922f, 0.02337769f, 0.02985951f, -0.01193176f, 
    0.01191419f, -0.00140099f, 0.01133489f, -0.02072569f, 0.02820011f, -0.06194150f, 0.00874115f, 0.02969762f, 
    -0.05517920f, -0.00643449f, -0.02494837f, -0.02964299f, 0.04446769f, -0.05518123f, 0.00840513f, -0.05490891f, 
    0.03490214f, -0.00433910f, -0.01059120f, -0.02579563f, 0.03834851f, 0.01202427f, 0.03311240f, 0.03914458f, 
    0.03644165f, -0.06389485f, 0.02550665f, -0.00607876f, 0.02597744f, -0.02996978f, 0.01924639f, -0.00763083f, 
    0.02493702f, -0.00184003f, -0.04656950f, 0.01039265f, -0.00076242f, 0.03943130f, -0.05570355f, 0.00495883f, 
    -0.01305020f, -0.02306314f, 0.02398058f, -0.05432205f, 0.04126227f, -0.03413237f, -0.00035468f, -0.00119497f, 
    0.01064763f, -0.04317839f, 0.04199703f, 0.02658061f, 0.04904970f, -0.05419579f, 0.04017994f, -0.05996302f, 
    -0.03398044f, 0.01922189f, -0.06743886f, -0.01133742f, 0.00991765f, -0.02575266f, -0.01613605f, -0.04693732f, 
    -0.02823981f, -0.01190166f, -0.04262831f, -0.02829418f, 0.00697059f, -0.05768480f, -0.01292958f, 0.05004901f, 
    -0.00831780f, -0.03862289f, 0.01676161f, -0.01646975f, 0.04083288f, -0.04115476f, 0.02119548f, -0.02383824f, 
    -0.06135152f, 0.02120765f, -0.05034716f, -0.02811389f, 0.00201844f, -0.01315719f, 0.03273499f, 0.03260073f, 
    -0.02767085f, 0.00412730f, -0.00409753f, -0.03178557f, 0.00783839f, -0.03336645f, -0.03637328f, -0.03496479f, 
    -0.03818408f, -0.00860572f, 0.02979049f, 0.03871090f, 0.02220310f, -0.01120410f, 0.02054086f, -0.04328061f, 
    -0.00118460f, 0.02658541f, 0.03957016f, -0.05493596f, -0.06044439f, 0.02869552f, -0.02679783f, 0.02267615f, 
    -0.05964117f, -0.02830608f, 0.03072723f, -0.03370665f, -0.02236219f, 0.00352305f, 0.02552125f, -0.05196816f, 
    -0.06836389f, 0.02866402f, -0.01691271f, 0.04372897f, 0.02802427f, 0.04803794f, 0.02938243f, -0.00966602f, 
    0.04851046f, 0.00947080f, 0.02301522f, -0.04011989f, 0.03255819f, -0.05702098f, 0.00471864f, -0.03706951f, 
    -0.05093320f, 0.02802024f, 0.03896862f, -0.06617612f, -0.05665525f, -0.02258761f, 0.00591667f, 0.00628614f, 
    -0.02689216f, -0.04813293f, -0.00252431f, -0.01211501f, 0.04441850f, -0.01775120f, -0.01483541f, 0.00013274f, 
    0.00034454f, 0.00848868f, 0.00408154f, -0.01428548f, -0.03925909f, -0.04911431f, 0.01725796f, 0.02595464f, 
    0.04555506f, -0.00261055f, -0.04996348f, -0.01943072f, 0.00640970f, -0.02504547f, 0.03826392f, 0.04700631f, 
    -0.04626285f, 0.01926278f, 0.03932887f, -0.03848311f, -0.01673357f, -0.01146929f, -0.03297057f, -0.00223792f, 
    -0.05522768f, -0.00958335f, -0.05055846f, -0.00672164f, 0.02558693f, -0.02621698f, -0.05044478f, 0.00954918f, 
    0.00133945f, -0.04570189f, 0.04232579f, 0.00859768f, -0.03711110f, -0.00315198f, -0.00207263f, 0.01387663f, 
    0.01093057f, -0.05057422f, -0.05927165f, -0.00471959f, 0.02158230f, -0.02572383f, 0.03826761f, 0.02472749f, 
    -0.01301215f, 0.01436904f, -0.04074778f, -0.04937119f, 0.00948272f, -0.01485691f, 0.04254797f, -0.03916644f, 
    -0.04118394f, 0.01020302f, -0.00931256f, -0.00796690f, -0.00853027f, 0.03914661f, -0.01851850f, -0.01942683f, 
    0.03058884f, -0.15216580f, 0.00931681f, 0.00468569f, -0.07158948f, 0.19005501f, 0.00586362f, -0.04465095f, 
    -0.06158542f, -0.08589619f, 0.01014419f, -0.03627683f, 0.03067457f, 0.09515885f, 0.13253918f, 0.08435670f, 
    0.02892586f, -0.26053920f, -0.08145515f, -0.11176518f, 0.07403433f, -0.28517243f, -0.24631228f, 0.12136728f, 
    0.03221671f, 0.10223518f, -0.01933939f, -0.09828937f, -0.17191666f, -0.01858697f, 0.10659658f, 0.03982970f, 
    -0.15618372f, -0.25255337f, -0.04855326f, -0.12490557f, -0.00427363f, 0.05022280f, 0.06904913f, 0.05809955f, 
    0.05863498f, 0.42489234f, 0.30413175f, -0.10804302f, 0.14550123f, -0.10596190f, -0.06134581f, -0.07723337f, 
    0.09525459f, 0.12526205f, -0.13941064f, 0.02340716f, 0.10374988f, 0.16830595f, 0.01161897f, 0.09988590f, 
    -0.02458313f, -0.03280172f, -0.01991762f, -0.09157527f, 0.05816879f, -0.01804019f, -0.18858175f, -0.10422590f, 
    0.05848892f, 0.23717491f, 0.21978731f, 0.06401221f, 0.16523084f, -0.07383379f, -0.12342422f, -0.09672159f, 
    0.07325015f, 0.01755018f, 0.11077046f, 0.17688656f, -0.02179485f, 0.10824232f, 0.03432192f, 0.07220588f, 
    -0.05192011f, -0.38572621f, 0.41088524f, 0.09351889f, -0.03205809f, 0.00094002f, -0.03871823f, -0.00374279f, 
    0.02427793f, -0.00489513f, -0.02094281f, -0.04173867f, 0.00682332f, -0.12911794f, 0.10976501f, 0.10446477f, 
    0.03016865f, -0.12702101f, 0.09459513f, -0.12294310f, 0.19393526f, -0.10931303f, 0.30212006f, 0.23453763f, 
    0.17719449f, 0.08380847f, 0.12717833f, -0.07265098f, 0.07437529f, 0.16486396f, -0.01578611f, 0.08707809f, 
    -0.04689818f, 0.04658403f, 0.03457558f, 0.06608148f, 0.01606129f, 0.10566130f, 0.14488226f, 0.03848081f, 
    -0.17027497f, 0.30676389f, -0.12053089f, 0.02215165f, -0.10111839f, -0.06597243f, -0.17432207f, -0.09790817f, 
    -0.16119760f, -0.02724368f, 0.10479601f, 0.09151085f, -0.12979777f, 0.08704321f, 0.01197255f, 0.12231892f, 
    -0.05318037f, -0.02557830f, -0.40398362f, -0.15281494f, 0.23224364f, 0.03369153f, 0.30444092f, 0.04471326f, 
    -0.15862900f, -0.02612347f, 0.06539675f, 0.06048890f, 0.02436360f, 0.09293906f, -0.09801217f, 0.02007928f, 
    0.20893286f, 0.01013431f, 0.13086045f, 0.01798651f, 0.01997518f, 0.02791208f, 0.01788235f, 0.03652640f, 
    0.12401030f, -0.23369884f, 0.12183215f, 0.12742899f, 0.13324279f, 0.14372078f, 0.12031866f, 0.08293989f, 
    0.11593562f, 0.13886063f, -0.09753371f, 0.02352591f, -0.04350805f, 0.08474417f, 0.15763894f, 0.16477154f, 
    -0.01189876f, -0.02513072f, 0.20032479f, 0.12395383f, 0.40076140f, -0.32409886f, -0.39258328f, -0.04305064f, 
    -0.09647244f, 0.10111699f, 0.16900468f, -0.01475701f, 0.03940716f, -0.03452310f, -0.03918845f, 0.06709257f, 
    -0.06244160f, 0.07697448f, 0.09416040f, 0.05084864f, -0.08462509f, 0.10395577f, -0.12237084f, 0.07610142f, 
    -0.25433829f, 0.13404860f, -0.24166115f, 0.00127521f, -0.04407432f, -0.09165990f, 0.01382254f, -0.00471709f, 
    -0.10130733f, -0.18013743f, -0.02797222f, -0.03441074f, -0.06774624f, 0.01273821f, 0.02742570f, 0.27570343f, 
    0.29078639f, -0.03683224f, -0.28064284f, -0.02584825f, -0.31388313f, -0.12136080f, -0.06747444f, -0.27214181f, 
    -0.10757597f, 0.16113177f, 0.11349846f, 0.08112995f, 0.13299672f, 0.06079582f, -0.04640947f, 0.00061876f, 
    0.02197922f, 0.21251705f, -0.07280172f, 0.07141730f, 0.11734752f, -0.00346381f, -0.06503498f, -0.09819128f, 
    0.22568028f, -0.19122335f, 0.34849086f, 0.04336638f, 0.02365267f, -0.01190980f, -0.06478355f, -0.00740456f, 
    0.09885254f, -0.07369266f, 0.02190290f, 0.06690874f, -0.27594200f, -0.04715651f, -0.12143934f, -0.11105219f, 
    0.03098556f, -0.01953273f, -0.05430960f, 0.06737410f, 0.10530929f, 0.01085543f, 0.39525956f, 0.05803845f, 
    -0.19324738f, -0.18694878f, 0.03825418f, -0.01211682f, -0.12911741f, -0.00293295f, -0.05253278f, 0.00416026f, 
    -0.08553065f, 0.10592437f, 0.04518973f, 0.16937794f, 0.07199682f, -0.01852586f, 0.11738544f, -0.05470432f, 
    -0.56612420f, 0.28454399f, -0.10794743f, -0.00663517f, 0.05672333f, 0.14015694f, -0.08914361f, 0.02517479f, 
    0.03625163f, 0.00025554f, 0.09501286f, 0.29399303f, 0.01476045f, -0.06314957f, 0.12633680f, -0.12176350f, 
    -0.02683946f, -0.00111731f, 0.10342038f, -0.02520537f, 0.01421791f, 0.09499139f, 0.03034414f, 0.27301779f, 
    0.06037655f, 0.00019445f, 0.07148160f, 0.09980325f, -0.06139075f, 0.07946274f, -0.12672286f, -0.05431338f, 
    -0.03642079f, 0.08149274f, 0.08647124f, 0.05499860f, 0.07826833f, -0.01143750f, 0.12264160f, 0.08766396f, 
    0.39143479f, -0.13315374f, -0.21656018f, -0.03970231f, 0.06451774f, 0.08668557f, -0.01536863f, 0.02803917f, 
    -0.08130742f, 0.14208183f, -0.02925352f, 0.02867231f, 0.01923521f, 0.11485125f, -0.01653076f, 0.02679193f, 
    0.07276298f, 0.02231207f, 0.04464646f, -0.00675027f, 0.13059169f, 0.02879324f, -0.18529108f, -0.20349304f, 
    -0.03879687f, -0.07819618f, 0.01450169f, -0.06031182f, -0.01704973f, -0.04386545f, 0.00413921f, -0.00902531f, 
    -0.00194042f, 0.02483618f, -0.11211720f, -0.04428240f, 0.01854754f, -0.03407887f, -0.03548163f, 0.06811878f, 
    0.19773829f, -0.13939175f, -0.25440094f, 0.01509737f, -0.03590861f, 0.05617060f, 0.04914377f, -0.00193739f, 
    0.04904217f, 0.00748004f, -0.01086076f, -0.07575342f, -0.03049682f, -0.08284125f, 0.10094990f, 0.01767656f, 
    0.16934569f, 0.10075136f, -0.01641914f, -0.04617857f, -0.22308490f, -0.14586501f, -0.16985567f, -0.06867683f, 
    0.30660662f, 0.04043939f, 0.13494332f, 0.00251624f, -0.01288061f, 0.05110608f, -0.19396953f, 0.00923999f, 
    -0.13459387f, 0.02824928f, 0.10596828f, 0.03139635f, -0.00395303f, 0.06844059f, -0.09700628f, 0.03329299f, 
    0.48641914f, -0.15084343f, 0.14008154f, 0.00076178f, -0.24518590f, -0.02345740f, 0.12097734f, 0.07094580f, 
    -0.04212136f, 0.01319189f, 0.01374801f, 0.05266688f, 0.03428746f, -0.02531746f, -0.03179220f, 0.03224315f, 
    0.13592866f, 0.03430151f, -0.01949614f, 0.08673993f, 0.01419900f, 0.08499871f, -0.05398447f, 0.07179134f, 
    0.04674201f, 0.07206963f, 0.02929700f, 0.05260071f, 0.05411617f, 0.02197356f, 0.00219241f, 0.10750485f, 
    0.05306469f, -0.03343106f, 0.01497738f, 0.01471250f, 0.17041484f, 0.07973675f, 0.07877737f, 0.09001710f, 
    0.02448033f, 0.22430080f, 0.24428330f, 0.05340861f, 0.08644805f, 0.23134512f, 0.15322438f, 0.02985833f, 
    -0.07212735f, -0.13872413f, -0.09102801f, -0.10040411f, 0.09741867f, -0.04627758f, 0.03562854f, 0.11400910f, 
    0.05558071f, 0.01563174f, 0.10769501f, -0.00973277f, -0.38599959f, 0.00532124f, 0.09329493f, 0.01214286f, 
    -0.18427514f, 0.09306084f, 0.05535337f, 0.07609640f, 0.01198411f, 0.01326805f, -0.09814322f, 0.01731534f, 
    0.06937715f, -0.07446609f, -0.08606713f, 0.04232121f, 0.06961857f, 0.08848926f, 0.03901086f, 0.07127495f, 
    -0.45927852f, -0.47311780f, -0.14916638f, 0.26524904f, 0.09547434f, 0.10210513f, 0.15209703f, 0.09501541f, 
    0.02232231f, -0.05367610f, -0.03670290f, 0.20485558f, 0.15181442f, 0.02099224f, -0.02501723f, -0.02888502f, 
    0.05033416f, -0.02244606f, 0.12716918f, -0.06088006f, -0.60155571f, 0.01513720f, 0.04554868f, -0.18629819f, 
    -0.18561314f, 0.02332222f, -0.09254842f, -0.16507863f, -0.01344320f, 0.08351367f, 0.02088818f, -0.11527742f, 
    0.05497135f, -0.11559378f, -0.05822793f, -0.02382515f, 0.06179982f, -0.07826398f, 0.14784795f, 0.11593405f, 
    -0.04098659f, 0.25821194f, 0.19176058f, 0.14793210f, 0.05862229f, 0.04835381f, -0.04149467f, 0.15208323f, 
    -0.06125510f, -0.18004459f, 0.01190234f, -0.03643688f, -0.12217562f, 0.04258241f, 0.03017777f, 0.02238399f, 
    -0.02899848f, 0.10672683f, 0.05735825f, -0.17430781f, -0.19053812f, -0.18387233f, -0.19963761f, -0.06202530f, 
    0.23412019f, 0.04639509f, -0.04102445f, -0.09270737f, 0.06722704f, 0.13230868f, 0.03319341f, 0.05104605f, 
    0.00493068f, -0.02484344f, -0.01504534f, 0.06966034f, -0.10412322f, -0.09275655f, -0.05661703f, -0.00079367f, 
    0.03304876f, -0.01789216f, 0.03822081f, 0.08366752f, -0.11135685f, -0.00054737f, 0.01979629f, 0.13638869f, 
    0.03419146f, 0.05957059f, 0.10741358f, 0.03434145f, 0.00937321f, -0.06606314f, -0.03925323f, 0.06463876f, 
    -0.01328693f, 0.01912554f, -0.04052231f, 0.05339354f, -0.25453228f, 0.07620520f, 0.39157525f, 0.16314347f, 
    -0.09088433f, -0.00473277f, 0.14784853f, -0.03171858f, -0.01389991f, -0.09151570f, -0.01371936f, 0.03590020f, 
    0.03821913f, -0.01056932f, 0.00761986f, 0.06760810f, 0.10417036f, -0.07586572f, -0.04337941f, -0.04826566f, 
    -0.42115876f, -0.26627752f, -0.06101910f, 0.07802851f, 0.13032004f, 0.08267283f, 0.14694947f, 0.03087064f, 
    0.03732022f, 0.01231283f, 0.17427973f, 0.01577563f, -0.12872589f, 0.05020895f, -0.01430838f, -0.00159336f, 
    0.04486359f, 0.00350660f, 0.08935705f, -0.04845501f, -0.23333429f, -0.02641669f, -0.25240943f, -0.12712348f, 
    -0.07588542f, 0.02621747f, -0.00672311f, 0.01021349f, -0.02743842f, 0.06569444f, 0.06407560f, -0.08518498f, 
    -0.02622424f, 0.03788081f, -0.02868251f, 0.07669933f, -0.02768289f, 0.11811592f, 0.04280864f, 0.19069341f, 
    0.01640637f, 0.22913845f, 0.17702746f, 0.13580745f, -0.09284645f, 0.06878115f, -0.05629010f, 0.00972464f, 
    -0.02434990f, -0.02170005f, 0.09472934f, 0.00738679f, 0.01102097f, 0.00262895f, -0.00997719f, 0.02524633f, 
    0.02167371f, 0.08411662f, 0.07363573f, 0.09547921f, 0.22338641f, -0.00120868f, 0.01133116f, 0.04474764f, 
    0.03524694f, -0.01209173f, -0.18160291f, -0.00419265f, 0.08075508f, -0.04351714f, 0.06032712f, 0.13950600f, 
    0.09149915f, 0.04458191f, 0.03139723f, 0.04739449f, 0.26463082f, -0.11250313f, -0.07913943f, 0.07016682f, 
    -0.47906837f, 0.07513516f, 0.21104452f, 0.26543739f, -0.05835048f, 0.03981573f, -0.19912516f, -0.08111572f, 
    -0.08561519f, -0.04050161f, 0.02466259f, 0.02531241f, 0.09901524f, 0.06956968f, 0.07954604f, -0.12957534f, 
    -0.07924994f, 0.10010859f, 0.05379946f, -0.14058949f, 0.14123964f, 0.20102704f, -0.01727488f, 0.01800266f, 
    -0.10613158f, -0.00726548f, 0.24442008f, 0.05180388f, 0.10941400f, 0.00376609f, -0.03366732f, 0.10717244f, 
    -0.07415720f, -0.09852225f, 0.03771202f, 0.03097795f, 0.04976969f, 0.06655400f, -0.09392031f, 0.03829946f, 
    -0.07135396f, -0.17499861f, 0.11138223f, 0.14243501f, -0.05734468f, 0.02729877f, -0.05443288f, -0.14246784f, 
    0.11300221f, 0.05061941f, 0.06020140f, 0.05511284f, 0.06828588f, 0.02197047f, 0.04792650f, -0.00981109f, 
    0.01609728f, 0.12486508f, 0.12185931f, 0.17495883f, 0.21046223f, 0.07584709f, 0.22073945f, 0.15859571f, 
    0.05248796f, 0.13654500f, -0.14630194f, 0.04176852f, 0.06998555f, 0.11272574f, -0.00689691f, 0.07698838f, 
    0.07925134f, 0.00664457f, -0.03735380f, -0.06594695f, -0.03564912f, -0.03145435f, -0.17865051f, -0.01905008f, 
    -0.08264533f, -0.06596161f, 0.04003256f, 0.17174777f, -0.15296698f, -0.01490311f, 0.10874943f, -0.03559407f, 
    -0.15604188f, 0.00949078f, 0.01030312f, 0.10033473f, -0.05229157f, 0.09342131f, 0.00708381f, -0.07041576f, 
    0.04992772f, 0.12053218f, 0.13427541f, 0.06118042f, -0.15793613f, 0.00450776f, 0.18212608f, -0.11898902f, 
    -0.09399392f, 0.02916154f, -0.06109548f, 0.10342252f, -0.01840720f, 0.06840666f, 0.08883484f, 0.06103444f, 
    -0.02401523f, 0.03507128f, 0.06047957f, -0.07959564f, -0.05814744f, -0.08963684f, 0.07047977f, -0.02418857f, 
    -0.17354405f, -0.03340344f, -0.07357873f, 0.33587143f, -0.10451546f, 0.17440869f, -0.02625963f, 0.09817223f, 
    -0.07243450f, 0.05846358f, -0.02220647f, 0.05292690f, 0.04583905f, -0.17458718f, 0.02658820f, -0.01524470f, 
    -0.03166324f, 0.02707208f, 0.05145694f, -0.06856129f, -0.00874880f, -0.09990216f, 0.04407739f, -0.02169235f, 
    -0.12057593f, 0.07056966f, 0.10592919f, 0.06353052f, 0.02930835f, -0.02227632f, 0.04499903f, 0.01660331f, 
    0.07187232f, -0.05561629f, 0.08962552f, 0.16132250f, 0.01964495f, -0.07512569f, -0.11559049f, 0.10939961f, 
    0.18398795f, 0.26858130f, -0.07355342f, -0.05529944f, 0.15468937f, -0.06297705f, -0.02579139f, -0.00789261f, 
    -0.10507141f, -0.22714913f, 0.11297363f, 0.07422080f, 0.02087174f, -0.03533076f, 0.00769822f, 0.08088496f, 
    0.07095983f, 0.12716565f, 0.26685509f, 0.12446624f, 0.10353334f, 0.31644690f, 0.01939086f, 0.00932105f, 
    -0.21613589f, 0.02270173f, 0.02606659f, 0.06339256f, 0.03024274f, -0.07516105f, 0.01960587f, 0.01145502f, 
    -0.04712763f, -0.24617545f, 0.01849836f, 0.09398490f, -0.01836156f, 0.07981846f, 0.09220523f, -0.09709584f, 
    0.05387044f, -0.09562215f, 0.01250286f, 0.00103661f, 0.07799142f, -0.13548136f, -0.14180221f, -0.09641648f, 
    0.05962668f, 0.13199389f, 0.02056699f, -0.01765064f, 0.10477853f, 0.00751772f, 0.12587601f, 0.04412607f, 
    -0.04861019f, 0.02194198f, -0.02894784f, 0.00063842f, -0.08345541f, -0.19517885f, 0.08510949f, -0.08693717f, 
    0.05387881f, -0.13577923f, -0.09726745f, -0.11466984f, 0.01496264f, 0.08388236f, -0.18834756f, -0.09794058f, 
    0.00037482f, 0.07203175f, 0.09284832f, -0.10220764f, 0.05318711f, 0.03014629f, -0.02680668f, -0.14316039f, 
    -0.17132345f, 0.03861189f, -0.19010930f, -0.00982182f, -0.12772837f, 0.01199120f, 0.03715742f, 0.12082892f, 
    0.01175970f, 0.05292581f, 0.13260467f, 0.00127190f, 0.13937521f, -0.01324333f, 0.01939579f, -0.07086548f, 
    0.11765499f, -0.01957661f, -0.00682128f, -0.00963038f, -0.11349946f, -0.06037182f, 0.26267219f, 0.08164397f, 
    0.08051006f, 0.02184416f, 0.12404597f, 0.06144290f, 0.07324035f, 0.05955510f, -0.01217090f, -0.06798439f, 
    0.03646015f, 0.08402331f, 0.05547474f, -0.02907546f, -0.10251212f, -0.21162340f, -0.13857903f, -0.02361064f, 
    -0.15938881f, -0.34709978f, 0.03898596f, 0.11318436f, 0.09435193f, -0.00653950f, 0.03310158f, -0.03888147f, 
    0.09299452f, 0.03164278f, 0.06409065f, -0.05489965f, 0.05464461f, 0.00032372f, 0.03656628f, -0.07128989f, 
    0.01934447f, 0.22182190f, 0.03327910f, -0.00547250f, 0.32715565f, 0.33320400f, -0.12782618f, -0.04476178f, 
    0.12802939f, -0.00486780f, -0.06148918f, 0.05869987f, 0.05543888f, -0.04668169f, -0.03665259f, -0.00412284f, 
    0.05165929f, -0.01268561f, 0.08725788f, 0.06790107f, 0.10727390f, 0.22356990f, -0.03388301f, -0.00004787f, 
    0.12149139f, -0.16927174f, 0.05138645f, 0.31914523f, 0.14893882f, 0.10751904f, 0.12394765f, -0.01943385f, 
    0.01555598f, -0.08689485f, 0.05566485f, 0.05134682f, 0.04517661f, -0.03039620f, 0.07731147f, -0.11476931f, 
    0.10199773f, 0.00503158f, 0.00755647f, 0.09812360f, 0.00697329f, 0.08321983f, 0.03988766f, -0.27886319f, 
    0.19833304f, -0.00332684f, -0.03281021f, 0.14248815f, 0.03225558f, -0.06788024f, -0.13846651f, 0.04287320f, 
    -0.01294310f, 0.01668967f, -0.06741112f, -0.06538632f, -0.11036262f, 0.07390870f, -0.01161129f, 0.00013140f, 
    0.30823854f, -0.02543576f, -0.12192965f, -0.09897475f, -0.16354375f, 0.02128354f, 0.05370129f, 0.09458993f, 
    0.00073225f, 0.05024196f, 0.00844895f, 0.10653940f, 0.04397189f, 0.05589844f, -0.06875297f, -0.01140936f, 
    0.09159280f, 0.09154215f, 0.02259279f, 0.05950613f, 0.07269432f, 0.28825980f, -0.10866585f, -0.04152273f, 
    0.20253246f, 0.07936836f, -0.10693768f, -0.09314730f, -0.07514565f, 0.09033140f, -0.09951650f, 0.00395073f, 
    -0.07740976f, -0.05645208f, 0.03129812f, 0.02853086f, -0.07948092f, -0.11378704f, -0.02650761f, 0.11694504f, 
    -0.33949071f, -0.17913231f, -0.08961576f, 0.20013802f, 0.02659085f, -0.05001630f, 0.02287303f, 0.10366641f, 
    0.00787753f, -0.02533015f, 0.04122237f, 0.11222365f, 0.02477396f, -0.00295270f, 0.08325037f, 0.07768311f, 
    -0.03950417f, -0.01213319f, -0.04355347f, -0.02418693f, 0.03356894f, 0.31686530f, 0.01394391f, 0.36510351f, 
    -0.00455262f, 0.02379314f, 0.01576645f, 0.03450999f, 0.08842722f, -0.07527902f, 0.03550517f, 0.09566449f, 
    0.03679148f, 0.12109409f, -0.04862041f, 0.09738358f, -0.04447819f, 0.04104920f, -0.02544243f, 0.03430379f, 
    0.10269950f, 0.15539728f, 0.06290676f, -0.06189935f, 0.15543225f, -0.15096129f, 0.19734794f, 0.08345884f, 
    -0.12092302f, -0.09636583f, -0.09221166f, 0.14872572f, 0.01657942f, 0.06032547f, 0.02486520f, -0.06455987f, 
    0.12614276f, -0.04010128f, -0.04983776f, -0.00487322f, 0.25310481f, 0.09409027f, -0.09471597f, -0.22974107f, 
    -0.01544320f, 0.01978866f, 0.06143797f, -0.04703998f, 0.09997126f, 0.08718598f, -0.19288740f, 0.13506809f, 
    0.03816271f, -0.02964112f, -0.12279934f, -0.00788556f, 0.04949433f, -0.03957074f, 0.08851154f, -0.12608764f, 
    -0.32759565f, -0.21517228f, 0.07078929f, -0.16033718f, -0.15061297f, -0.06421869f, -0.00983609f, 0.07550538f, 
    -0.09011061f, 0.00248075f, -0.02971098f, -0.17678814f, -0.04522921f, 0.02905616f, 0.02336638f, -0.08708053f, 
    -0.06856965f, 0.05767018f, -0.03414096f, 0.01177282f, 0.29354569f, -0.05600261f, 0.07723578f, -0.17574117f, 
    0.14699322f, -0.17738844f, 0.08696976f, -0.03013863f, 0.05181347f, -0.12563589f, 0.00737630f, 0.00963832f, 
    0.08964179f, -0.11977940f, -0.09343424f, 0.02662110f, 0.01458415f, -0.05248848f, -0.03426525f, 0.10165690f, 
    -0.03119417f, 0.09696361f, -0.02924842f, 0.38641626f, -0.11509288f, 0.04783746f, -0.04804636f, -0.12915613f, 
    0.12198676f, -0.03276227f, -0.07541580f, 0.03891764f, -0.00445730f, 0.06560708f, -0.04886706f, -0.00277618f, 
    0.02368117f, 0.05037687f, 0.07058283f, 0.03049756f, -0.08519856f, 0.41081738f, -0.05038502f, -0.09754141f, 
    -0.05651648f, 0.18601847f, 0.00320294f, 0.04559236f, -0.00667970f, -0.03681472f, -0.06321833f, -0.01792705f, 
    -0.01207504f, 0.14078362f, 0.06567957f, -0.00251561f, -0.10033830f, -0.04764311f, -0.03503441f, -0.06881342f, 
    -0.02233905f, -0.23531330f, -0.03496122f, -0.29538140f, 0.28124323f, -0.09158424f, 0.03485278f, 0.09696430f, 
    0.00753240f, -0.13959409f, 0.11489691f, -0.00419168f, -0.02691389f, -0.15593177f, -0.00196714f, -0.06567137f, 
    0.09103326f, 0.01807648f, 0.00390432f, -0.10945483f, 0.09996593f, 0.01918018f, 0.09438970f, -0.10067619f, 
    0.27987170f, 0.00357193f, 0.02344660f, 0.03888255f, -0.02994960f, -0.04326007f, 0.19515027f, -0.05871801f, 
    -0.02133520f, 0.03807231f, -0.14259984f, -0.00185385f, 0.11160651f, -0.00245257f, 0.00876444f, 0.04997319f, 
    -0.43914157f, 0.23927037f, 0.20877555f, 0.16524708f, -0.09221270f, 0.07750659f, 0.02887966f, 0.02985640f, 
    -0.01555883f, 0.04735376f, 0.08625612f, -0.00602696f, -0.04638060f, 0.03549999f, -0.00548803f, 0.06107813f, 
    0.07371766f, 0.15907276f, -0.04474452f, 0.02534758f, 0.04972792f, 0.06505571f, -0.01570204f, -0.03908980f, 
    0.13444255f, -0.01088663f, -0.11773590f, 0.11854202f, 0.12954381f, 0.02709933f, 0.05391114f, 0.12671278f, 
    0.08413608f, 0.18136400f, 0.12784487f, 0.19193403f, 0.10746615f, -0.06915621f, -0.04489297f, 0.10420296f, 
    -0.62973946f, -0.10813483f, 0.23095998f, 0.23509781f, -0.08944745f, 0.05322644f, -0.01512860f, 0.01644393f, 
    -0.13428406f, -0.09491871f, 0.05219101f, -0.02098531f, 0.00121994f, 0.00721694f, 0.11111350f, -0.03844174f, 
    -0.10226917f, 0.06008068f, 0.09084803f, 0.03336617f, -0.01210839f, 0.27166671f, 0.02631059f, -0.16357227f, 
    -0.24037360f, 0.06249281f, 0.10256035f, 0.05125020f, -0.02378841f, -0.06397998f, 0.09751455f, 0.07519104f, 
    -0.09185430f, 0.02127359f, -0.09901784f, -0.01959355f, 0.03108840f, -0.04450738f, 0.04092203f, 0.04846981f, 
    -0.20215262f, 0.08601875f, -0.01625412f, 0.04726012f, 0.20028909f, -0.01500741f, -0.03851765f, -0.14239630f, 
    0.13126627f, 0.10761072f, 0.07329299f, 0.09126246f, 0.05787183f, 0.02018277f, 0.04435663f, -0.05122659f, 
    -0.05156126f, 0.18834202f, 0.00746012f, 0.15815738f, 0.16862702f, 0.05800765f, 0.06387758f, 0.03403543f, 
    0.07098089f, 0.03922611f, -0.13864303f, 0.05922009f, -0.00490466f, 0.09254003f, 0.06529963f, 0.06406938f, 
    0.07943709f, 0.04628867f, -0.00932469f, 0.00750668f, -0.06860790f, -0.10249089f, -0.05540707f, 0.06084682f, 
    0.34925452f, -0.15177259f, 0.02583569f, 0.17328791f, -0.08658598f, -0.03592961f, 0.04977605f, -0.04805182f, 
    -0.11355644f, 0.03391980f, 0.03531473f, 0.10259080f, 0.02369808f, 0.06981532f, -0.04347330f, -0.01084671f, 
    0.10148391f, 0.03524416f, 0.14292321f, -0.06546918f, -0.24122542f, -0.14684966f, 0.09710734f, -0.03640071f, 
    -0.04368240f, 0.04537258f, 0.01570309f, 0.01946110f, -0.05914887f, -0.01461753f, 0.15866911f, 0.10087487f, 
    -0.07670554f, 0.00357747f, 0.06517611f, 0.11335556f, -0.01108654f, -0.16505861f, -0.02479405f, -0.05670504f, 
    -0.10369093f, 0.07504547f, -0.09208312f, 0.20691115f, -0.18669724f, 0.07841428f, 0.13393377f, 0.08716624f, 
    -0.18080504f, 0.03492800f, -0.04601408f, -0.01864625f, 0.01112998f, -0.05861497f, -0.03439169f, -0.01929593f, 
    0.03212763f, -0.05257355f, -0.01682225f, 0.00129084f, 0.18460320f, -0.07951218f, 0.14611362f, -0.06966057f, 
    0.03089970f, 0.11512788f, 0.08788966f, 0.23229258f, 0.07260937f, 0.01987083f, 0.05103614f, 0.07346722f, 
    0.13223895f, 0.06461831f, -0.04491543f, 0.01580445f, -0.00363396f, -0.10969054f, -0.08581277f, 0.01513547f, 
    0.34916145f, 0.09681436f, -0.06103774f, -0.05570502f, 0.01700462f, -0.02756308f, 0.02345658f, 0.00474563f, 
    -0.07172460f, 0.01183015f, 0.19347551f, 0.01586479f, -0.07096498f, 0.02584766f, 0.06455818f, 0.06138321f, 
    0.07851384f, 0.07342427f, 0.20252471f, 0.07452012f, 0.13576794f, 0.27498555f, 0.08786842f, -0.08721302f, 
    -0.31421584f, 0.04965672f, 0.09864302f, 0.02791644f, -0.01212291f, -0.13405149f, 0.04904743f, 0.04191130f, 
    0.07480876f, -0.17149946f, -0.03619156f, 0.06622028f, -0.00625550f, -0.03691888f, 0.00140831f, -0.01456865f, 
    -0.10387339f, -0.07561521f, -0.10752217f, 0.16823208f, 0.12488639f, -0.12053686f, -0.05590446f, -0.09777731f, 
    -0.00904344f, 0.10099027f, 0.01895105f, -0.00580706f, 0.17173111f, 0.02996938f, 0.15240282f, 0.07480425f, 
    0.02581727f, -0.07852858f, 0.05325075f, -0.03847453f, 0.43333727f, -0.00048175f, 0.02619230f, -0.10639291f, 
    0.13658266f, -0.18152685f, -0.07781614f, -0.11865754f, 0.04332108f, 0.04086538f, -0.01601208f, -0.09566367f, 
    0.08837705f, 0.26506272f, 0.12763973f, -0.01591134f, -0.05974128f, -0.05198286f, -0.00928054f, -0.03856662f, 
    0.10137632f, -0.03213877f, -0.20138712f, 0.07596461f, -0.08658139f, 0.08389124f, 0.05127840f, 0.07069141f, 
    -0.02673215f, 0.01727014f, 0.06920306f, 0.05962842f, 0.13758644f, -0.04098510f, 0.00198297f, -0.01663499f, 
    0.08743487f, 0.01969113f, 0.01324643f, 0.01194380f, -0.09424323f, 0.03790465f, 0.22277243f, 0.01141832f, 
    0.31181142f, 0.05595874f, 0.05034331f, 0.00098651f, 0.10619660f, 0.05027216f, -0.00936631f, 0.02836720f, 
    0.01544986f, 0.05158670f, 0.07307877f, -0.06531528f, 0.00454364f, -0.17202801f, -0.08196414f, -0.05878358f, 
    0.09366017f, 0.01393967f, 0.03830437f, -0.10501072f, 0.39750150f, -0.16958451f, 0.02040798f, -0.01415611f, 
    0.15819010f, 0.00890864f, 0.09656460f, -0.05634354f, 0.13197297f, -0.08656241f, 0.03635752f, 0.01990278f, 
    -0.06273126f, 0.05953192f, -0.01386599f, -0.02065191f, 0.37453553f, 0.33600417f, 0.07589383f, -0.19974385f, 
    0.04495776f, 0.05044756f, -0.01264164f, -0.03136999f, -0.01584131f, 0.06387393f, 0.12178649f, -0.07018401f, 
    0.03351149f, 0.06522878f, 0.03266897f, -0.01486296f, 0.11496676f, 0.08500268f, -0.03462293f, 0.12600629f, 
    0.27205673f, 0.04777148f, -0.17492026f, -0.07186640f, -0.06789543f, 0.03447848f, 0.14349845f, -0.08083141f, 
    0.08570679f, -0.07707006f, 0.12921433f, 0.02862069f, 0.02106965f, 0.01261837f, 0.15097445f, -0.10362698f, 
    0.07774390f, -0.02658727f, -0.01176751f, 0.05229787f, -0.15390238f, -0.02949671f, 0.09884011f, 0.10513359f, 
    0.24110205f, 0.04477198f, -0.10929964f, 0.11422013f, 0.04498256f, 0.03876527f, -0.15580934f, 0.04820305f, 
    -0.04260030f, -0.06112268f, 0.05874619f, -0.12077947f, 0.00567716f, -0.08881626f, -0.07378374f, -0.06072366f, 
    0.25592318f, 0.02914187f, -0.15891168f, 0.04990802f, 0.00637386f, -0.04350305f, 0.07615733f, 0.03360368f, 
    0.03726278f, -0.03867112f, -0.04253446f, 0.17062514f, -0.04268896f, -0.01290938f, 0.08546187f, 0.11537668f, 
    0.09330379f, -0.03838281f, 0.11077718f, 0.05538868f, -0.11367133f, 0.18972179f, -0.05908772f, -0.07333315f, 
    -0.08466689f, -0.03335860f, 0.11744826f, -0.07799610f, 0.00867418f, -0.03635069f, 0.11337192f, 0.08638527f, 
    -0.03969685f, 0.00845946f, 0.09356620f, -0.01068788f, 0.00619203f, -0.03862031f, -0.05333723f, 0.10795064f, 
    -0.20540103f, 0.00747766f, -0.18585666f, -0.07705078f, -0.03510234f, 0.32654274f, 0.19862677f, 0.04326388f, 
    -0.11415258f, 0.06570841f, 0.09316204f, -0.01406062f, 0.05999606f, -0.01083416f, 0.00286203f, 0.05107657f, 
    0.00126354f, -0.02128675f, 0.03697132f, -0.09756115f, -0.03271171f, 0.13190416f, -0.00165302f, 0.09202039f, 
    -0.25282961f, 0.00623694f, -0.00244524f, 0.03089610f, 0.01621847f, 0.01273264f, -0.06435872f, -0.02845830f, 
    0.03682299f, 0.03744991f, -0.00599564f, -0.01977048f, 0.09283665f, 0.01359496f, 0.03658142f, 0.08113293f, 
    0.14045496f, -0.15915805f, 0.15770118f, -0.23389596f, -0.04849901f, -0.12623385f, 0.10551685f, -0.06009013f, 
    0.01477975f, -0.17212074f, -0.09440821f, -0.00207869f, -0.02142369f, -0.01944673f, 0.02856171f, -0.08643988f, 
    -0.01663245f, -0.11121626f, 0.09198422f, 0.10532880f, -0.09642362f, 0.28050685f, -0.04866559f, -0.05408254f, 
    -0.12452548f, 0.14735521f, 0.01942854f, -0.07134229f, 0.07047398f, 0.08405147f, 0.04177144f, 0.02068451f, 
    -0.01993547f, -0.06150633f, -0.01506989f, -0.07043491f, 0.03255232f, -0.07771160f, 0.06846457f, 0.10404518f, 
    -0.30281904f, -0.10618839f, -0.04631039f, -0.10930636f, -0.21246396f, 0.12982503f, 0.01690661f, 0.08979865f, 
    -0.06281099f, 0.09076285f, 0.04408242f, -0.14365612f, 0.08693516f, -0.05779839f, 0.08904749f, -0.20026411f, 
    -0.12637718f, 0.03624167f, 0.07087457f, -0.16675083f, 0.01558534f, -0.07984008f, 0.23642316f, 0.09945608f, 
    0.44437748f, -0.18779004f, -0.14164843f, 0.14511499f, 0.08838328f, 0.08825027f, 0.05648793f, -0.08844382f, 
    0.00844391f, -0.08182234f, -0.02203824f, -0.10751489f, -0.10848854f, 0.04252758f, -0.01140340f, 0.02141868f, 
    -0.14644364f, 0.12947729f, -0.16125104f, 0.13510057f, -0.25769866f, 0.12307766f, 0.16953532f, -0.13022186f, 
    -0.02578885f, -0.03601633f, 0.06915104f, 0.12329926f, 0.10599575f, 0.04029150f, -0.02897518f, 0.00718371f, 
    0.09718631f, -0.15297964f, 0.11221600f, 0.03741673f, -0.36019933f, -0.07993368f, 0.01180781f, -0.08754404f, 
    -0.04216429f, 0.21900710f, 0.24680464f, -0.11815014f, -0.06396390f, -0.17183560f, 0.13905513f, 0.12898393f, 
    0.06044906f, 0.04395464f, 0.03462704f, 0.00164663f, -0.01140835f, 0.06870710f, -0.16512728f, -0.08876671f, 
    -0.08337934f, 0.21093735f, 0.21069339f, -0.02764944f, 0.08723885f, -0.13018396f, -0.05477652f, 0.06854755f, 
    0.04064655f, -0.09977137f, 0.03588536f, -0.08948961f, -0.06703867f, -0.05494426f, 0.03333591f, 0.07907878f, 
    0.03270011f, -0.13617282f, 0.16176452f, -0.08771915f, -0.08580771f, 0.43470669f, -0.19020596f, -0.02057972f, 
    -0.18870211f, 0.01086510f, 0.01985935f, -0.09376273f, 0.01884536f, -0.07458551f, 0.17300665f, 0.04998764f, 
    0.04313620f, 0.01585985f, -0.03788574f, 0.09049940f, 0.24121945f, 0.10032526f, 0.03736446f, 0.19974750f, 
    0.01221954f, 0.01863152f, 0.04360456f, -0.00442735f, 0.02415313f, 0.02250395f, -0.04084894f, 0.00572045f, 
    -0.01931570f, 0.02721337f, -0.03606219f, 0.03437667f, -0.02954633f, 0.01493729f, 0.02202588f, 0.04248602f, 
    -0.02061283f, 0.01896454f, 0.04226020f, -0.05846819f, -0.03630355f, 0.02854858f, 0.02583377f, -0.01111263f, 
    -0.01852945f, -0.05461381f, 0.01663428f, -0.06294480f, -0.00035503f, -0.01227701f, -0.06436853f, -0.04174286f, 
    0.00795066f, 0.01454144f, -0.02654770f, 0.01692793f, -0.03089233f, -0.02927496f, -0.05195258f, -0.01900981f, 
    -0.05762453f, -0.02533048f, 0.02701823f, -0.00423431f, -0.00170437f, 0.04361764f, -0.03415393f, -0.03081623f, 
    0.02726759f, -0.03096328f, -0.02895570f, 0.02966707f, -0.02241889f, 0.03397731f, 0.03041340f, 0.02330251f, 
    -0.02031721f, -0.05474804f, -0.00473929f, -0.01092103f, 0.04859551f, 0.00520092f, -0.00352057f, 0.02509448f, 
    -0.03511188f, 0.00901803f, -0.04279104f, 0.00807238f, 0.02037506f, -0.01797394f, 0.04133304f, -0.00361263f, 
    0.01630871f, 0.01003425f, -0.05289665f, 0.02162900f, 0.01274629f, 0.01833875f, -0.05909092f, -0.03808672f, 
    0.02312473f, 0.01798227f, -0.00865511f, -0.03727837f, -0.01051151f, -0.04443486f, 0.04431500f, 0.03740006f, 
    0.01862630f, -0.00295329f, -0.03644645f, -0.03235203f, -0.04750667f, 0.03752708f, -0.02856239f, -0.01914612f, 
    0.01915902f, 0.00381223f, -0.04337424f, 0.02171236f, 0.04530793f, 0.00475986f, -0.00892831f, 0.01180531f, 
    -0.04554567f, -0.04318417f, 0.03494877f, -0.05480656f, 0.00846648f, -0.04823616f, 0.03791320f, -0.03395426f, 
    0.02637401f, -0.01838146f, -0.01369176f, 0.01771185f, -0.05441278f, 0.02064072f, -0.05069844f, -0.05731071f, 
    0.00942089f, -0.02456970f, -0.04593692f, 0.00798324f, -0.05787776f, -0.00819404f, 0.01112700f, -0.02990624f, 
    0.01126594f, -0.04045603f, 0.04045492f, 0.04135045f, 0.02741173f, -0.04992667f, -0.04559195f, 0.00623064f, 
    -0.04424785f, -0.03581157f, -0.01760472f, 0.02954166f, 0.05706811f, -0.04274201f, -0.01742114f, 0.00544124f, 
    -0.02558371f, -0.01533930f, 0.04654094f, -0.00514812f, -0.00719403f, 0.00441558f, -0.04891372f, 0.03738817f, 
    0.03884320f, -0.04541340f, 0.01391344f, -0.00336283f, -0.04825483f, -0.03993769f, -0.02980723f, 0.05226332f, 
    -0.03791173f, -0.02210157f, -0.04837872f, 0.04856064f, 0.03849085f, -0.05836770f, 0.02117261f, 0.03806856f, 
    -0.02433488f, -0.03214343f, 0.03102951f, 0.00374965f, 0.04937024f, 0.00392385f, -0.05469409f, -0.02829435f, 
    -0.00022500f, 0.00661754f, 0.03366732f, 0.00343862f, 0.04594523f, 0.01963041f, -0.04375727f, -0.03777292f, 
    0.00985407f, 0.04588639f, -0.02195249f, -0.05412642f, 0.00122400f, 0.00982566f, 0.03893549f, -0.02174204f, 
    0.00165455f, 0.01791568f, 0.02113077f, -0.02737719f, 0.02908450f, -0.01788565f, 0.00350599f, -0.04592257f, 
    -0.01072102f, -0.00669087f, 0.01430146f, 0.03445733f, 0.04652565f, -0.01806309f, 0.02430180f, -0.01526011f, 
    -0.02942090f, -0.04002288f, -0.03023093f, -0.01361792f, -0.03671924f, -0.03524530f, -0.02623189f, -0.03480111f, 
    -0.03235497f, -0.05318752f, -0.06319428f, -0.01600450f, -0.05434021f, -0.02189557f, -0.04283778f, -0.04621899f, 
    -0.00853497f, -0.05809640f, 0.00780679f, -0.00636433f, -0.03831626f, -0.02856248f, -0.06124897f, 0.04105681f, 
    -0.01223774f, 0.01515457f, 0.01968929f, -0.01830776f, 0.03238546f, -0.04301617f, -0.06181850f, -0.04075311f, 
    -0.06150784f, -0.04930317f, -0.03024733f, 0.04655188f, 0.01594455f, -0.04922260f, 0.04185470f, 0.01157182f, 
    -0.04122021f, -0.02827908f, 0.03273939f, 0.04536934f, 0.04578729f, -0.02043200f, -0.00941121f, 0.04137668f, 
    -0.00289733f, 0.03222337f, 0.02282102f, 0.03530878f, 0.04005907f, 0.00127040f, -0.00827960f, -0.02243533f, 
    0.03206648f, 0.00794790f, 0.01404721f, 0.02083995f, 0.01373808f, 0.01449211f, 0.01745788f, -0.04011403f, 
    0.03286737f, 0.02360888f, -0.03186768f, -0.04721186f, -0.02342555f, 0.03045877f, 0.00034207f, 0.03379133f, 
    -0.05299174f, -0.01138386f, 0.03397714f, -0.06156116f, -0.05842291f, 0.04433469f, -0.00465781f, 0.02644089f, 
    0.03045319f, -0.01472093f, -0.01147860f, -0.04605502f, -0.03820199f, 0.04531560f, -0.01961178f, -0.00881692f, 
    0.02124794f, -0.03525891f, 0.02106174f, -0.02416766f, -0.00433450f, -0.00198441f, -0.03713220f, 0.03173304f, 
    0.01078198f, 0.04333245f, -0.01593028f, -0.02923204f, -0.03183038f, 0.03082116f, -0.01309529f, -0.05693134f, 
    -0.05316437f, 0.02808075f, 0.03027278f, 0.01481334f, -0.06336445f, 0.04706527f, -0.04930141f, -0.05822498f, 
    -0.19509369f, -0.12469493f, 0.01529453f, 0.11638009f, -0.22371757f, 0.07000243f, 0.15003541f, 0.06751973f, 
    0.09568996f, 0.10046960f, 0.06129507f, 0.10003322f, -0.05534442f, 0.03506364f, 0.02815119f, -0.02841389f, 
    0.03034168f, 0.03030124f, -0.03512236f, -0.02394534f, -0.27877012f, -0.18170944f, -0.14935915f, 0.08008102f, 
    -0.02953674f, 0.01937124f, 0.04491871f, 0.08955411f, -0.01451414f, -0.00336089f, -0.08010762f, -0.04864345f, 
    0.02908160f, -0.14267896f, 0.04764492f, -0.00025135f, -0.17162260f, 0.07967840f, 0.16039592f, -0.04857755f, 
    0.04428836f, -0.31057850f, 0.19918373f, 0.24966417f, 0.22442260f, -0.00073679f, 0.10994764f, 0.12490126f, 
    -0.01607362f, 0.05266182f, -0.07323217f, -0.06441187f, -0.04820565f, 0.01345479f, -0.14153029f, 0.20468353f, 
    -0.03009546f, -0.00963975f, 0.07099776f, 0.07797775f, 0.26324067f, -0.00957251f, -0.15101258f, -0.16007508f, 
    -0.16935551f, -0.01251663f, -0.09239658f, -0.03365478f, -0.06200567f, -0.01795966f, 0.06161662f, -0.01909355f, 
    0.11751810f, 0.13012537f, -0.07668506f, 0.12064423f, -0.08764505f, -0.02018364f, 0.07102129f, 0.08038221f, 
    0.05880960f, 0.17350742f, 0.03064897f, -0.00418339f, 0.03534005f, 0.04965987f, 0.03611403f, -0.01233059f, 
    0.02816654f, 0.01873922f, 0.06166357f, -0.08397978f, 0.12030777f, 0.04220657f, -0.03795471f, -0.03115925f, 
    0.01006752f, 0.06874040f, -0.04022139f, -0.08552749f, -0.08716364f, -0.13518266f, -0.14489511f, -0.06631569f, 
    0.05295819f, -0.09621052f, -0.02601626f, 0.02671652f, 0.03620607f, 0.05626408f, -0.08865811f, -0.08430054f, 
    -0.02491083f, 0.03385400f, -0.08531188f, 0.08577328f, -0.01740907f, 0.14469713f, 0.18804161f, 0.05507443f, 
    0.39270639f, -0.23883513f, 0.10301998f, 0.06147978f, 0.00651307f, -0.14245258f, -0.16495678f, 0.15403384f, 
    0.15185736f, -0.03382678f, -0.04701935f, 0.07868958f, 0.02949941f, -0.06014989f, -0.00824093f, 0.05263391f, 
    -0.03357671f, 0.06242600f, -0.16473761f, 0.06727248f, 0.17402165f, -0.22705737f, 0.02203915f, 0.15409137f, 
    0.38089612f, -0.01040916f, 0.03516930f, 0.09240983f, -0.05144110f, -0.06871435f, 0.02746590f, 0.04265863f, 
    -0.02754817f, 0.09923547f, -0.04613379f, 0.16761099f, -0.08047872f, 0.21679252f, 0.05234594f, -0.05409098f, 
    0.19486906f, 0.14884964f, -0.11429969f, 0.11453750f, 0.13151091f, -0.04433446f, -0.04941051f, -0.02156142f, 
    -0.06126370f, 0.05867022f, 0.04676438f, -0.04049754f, 0.03531111f, 0.16418725f, 0.00385991f, 0.10956995f, 
    -0.02564870f, 0.17259832f, -0.01885828f, -0.01567277f, 0.37115794f, -0.16511306f, -0.01083771f, -0.09461487f, 
    0.08717868f, -0.03963429f, -0.00619616f, 0.05432620f, 0.05401289f, -0.02931117f, -0.12521586f, 0.02513138f, 
    -0.06787058f, 0.10958485f, -0.03499256f, -0.09889150f, -0.02234047f, 0.11618595f, -0.04552698f, -0.16999811f, 
    -0.13206086f, -0.22360013f, 0.11516540f, -0.08561610f, 0.03570764f, 0.05081067f, 0.03023932f, 0.11468398f, 
    0.12027871f, 0.10970793f, -0.06419716f, 0.03809182f, -0.02088560f, 0.19085908f, -0.03745075f, 0.08443268f, 
    0.01215473f, -0.08782551f, -0.13163561f, 0.03944087f, 0.29382139f, -0.07954463f, -0.11273689f, -0.12870869f, 
    -0.26722780f, 0.05023156f, 0.13264117f, -0.08807425f, -0.02311596f, -0.05854476f, 0.06946862f, 0.14783628f, 
    0.09761783f, 0.15795209f, -0.03886785f, 0.01071757f, 0.02140745f, -0.06338166f, -0.12609556f, 0.12278065f, 
    0.22522821f, -0.02643804f, 0.16827430f, 0.02616946f, 0.18847883f, -0.09429699f, 0.03446820f, 0.12883492f, 
    0.12361972f, -0.00852230f, -0.07770593f, 0.01124563f, -0.09069777f, 0.06523985f, 0.08253343f, -0.03330624f, 
    -0.12088215f, 0.20911697f, 0.02818276f, 0.00128553f, 0.57047379f, 0.48938021f, -0.21031357f, -0.11068853f, 
    -0.03528472f, -0.03874093f, -0.03674891f, 0.08836514f, 0.10955030f, 0.03210975f, -0.00127324f, -0.06351574f, 
    -0.05905332f, 0.00932950f, -0.03933559f, 0.04730916f, -0.05047488f, -0.06248107f, 0.10522640f, 0.14067169f, 
    0.37678027f, -0.39958385f, -0.13249664f, -0.17380537f, -0.02705896f, 0.06956115f, -0.01563129f, 0.05988843f, 
    -0.07914573f, 0.04170420f, -0.07523154f, 0.06435044f, 0.08984042f, 0.00778328f, 0.08121090f, 0.03531547f, 
    -0.00609981f, 0.11554560f, -0.05625910f, 0.05640666f, 0.06977908f, -0.27963158f, 0.07916236f, -0.08163535f, 
    0.23256731f, 0.06074703f, -0.05024815f, 0.02315936f, -0.05058463f, 0.09211752f, -0.07787798f, 0.04694758f, 
    -0.05851636f, -0.07050077f, -0.04320735f, 0.05343975f, -0.05958118f, 0.05258593f, 0.07594863f, -0.00348555f, 
    0.26949844f, 0.28851321f, -0.07064223f, -0.15341221f, -0.07207264f, 0.07100295f, -0.07549044f, -0.03751546f, 
    -0.10708569f, 0.02790470f, 0.01824656f, 0.00855759f, 0.07734302f, -0.00127548f, 0.00543539f, -0.03100595f, 
    -0.02511434f, -0.12949920f, 0.05159127f, 0.02837728f, 0.05215865f, -0.05065704f, -0.01348180f, 0.15174003f, 
    0.04428880f, -0.04048103f, -0.04337302f, -0.09622415f, -0.02208294f, 0.09336530f, 0.16945639f, 0.05106802f, 
    0.09756283f, -0.08125082f, -0.00251002f, -0.01842139f, 0.15354028f, -0.06282293f, 0.06691906f, -0.03948095f, 
    -0.07919382f, 0.14273082f, -0.11893930f, 0.07071411f, -0.12686028f, -0.04446923f, -0.01921084f, -0.03995948f, 
    -0.02918942f, -0.02680709f, -0.03157286f, 0.01019962f, 0.02936388f, 0.05685188f, 0.03528791f, 0.04135422f, 
    0.07200965f, 0.02930512f, 0.12959622f, -0.03058114f, 0.33210564f, 0.19202949f, -0.23452635f, 0.31514224f, 
    0.07422414f, -0.02812185f, 0.18568945f, 0.03156079f, -0.04787895f, 0.00096152f, -0.05495791f, 0.05957196f, 
    0.00345107f, 0.06521212f, 0.13972171f, 0.09601055f, -0.03274800f, 0.03525301f, -0.10158613f, 0.00535722f, 
    0.32151681f, -0.16790988f, -0.04191416f, 0.02574393f, -0.22141694f, -0.00835176f, 0.09626349f, -0.03712555f, 
    0.02820153f, -0.00753023f, 0.01793508f, 0.01117461f, -0.00946642f, -0.07405344f, -0.01344721f, -0.03109170f, 
    0.04065051f, -0.06135964f, 0.11829484f, -0.02683916f, 0.03890204f, -0.05143366f, 0.08796782f, 0.17348321f, 
    0.00211707f, 0.05332409f, 0.05517543f, -0.02908045f, 0.06648475f, -0.03630129f, 0.07043399f, 0.04019943f, 
    0.09157955f, -0.01496312f, -0.03391319f, 0.03919683f, 0.06419474f, 0.12451605f, -0.08350433f, 0.00468165f, 
    -0.03950082f, 0.06693038f, 0.06331060f, -0.16478293f, -0.10340608f, 0.11107952f, 0.09189883f, 0.11750245f, 
    0.08906855f, -0.08519512f, -0.03781849f, -0.04968694f, 0.05017349f, 0.05722744f, -0.06124912f, 0.04629751f, 
    0.02528534f, 0.01291605f, 0.10636345f, 0.03664191f, -0.40308586f, -0.14092849f, 0.18076444f, -0.18005060f, 
    0.08968104f, 0.05117013f, -0.02730106f, 0.12493840f, -0.02318085f, 0.16875798f, -0.11205836f, -0.05027550f, 
    0.04207020f, -0.12583926f, -0.09759603f, -0.00387951f, -0.00494960f, 0.04420999f, -0.08619834f, 0.12590289f, 
    -0.07808026f, -0.20064732f, -0.07620784f, 0.36927661f, 0.04694104f, 0.15828729f, 0.00755818f, 0.08523987f, 
    0.05709496f, 0.09537980f, 0.00553841f, 0.13917713f, 0.09337103f, -0.07550302f, 0.01360265f, 0.06409986f, 
    -0.01371195f, 0.13647868f, 0.17448737f, -0.07983720f, -0.33280593f, 0.02335851f, 0.10685845f, 0.12375297f, 
    -0.08256672f, -0.01005086f, 0.05303114f, -0.13928367f, 0.01123596f, 0.07617690f, -0.09639377f, -0.07440013f, 
    -0.10557181f, -0.07251875f, 0.03493402f, 0.11591600f, -0.00774974f, 0.02246884f, -0.06138101f, 0.10866267f, 
    -0.22370614f, 0.13557896f, 0.14361289f, 0.00328840f, -0.04171610f, 0.13713150f, 0.04314466f, 0.12052549f, 
    0.05463980f, -0.09453797f, 0.06642707f, 0.02421339f, 0.00075576f, 0.10411493f, -0.02469474f, 0.06709707f, 
    0.00908225f, 0.07748318f, 0.09211774f, 0.03668438f, -0.14401354f, 0.24226162f, -0.03664449f, 0.11452059f, 
    0.04175247f, 0.16717982f, -0.08772187f, 0.01457075f, 0.03350966f, 0.05425642f, 0.01682182f, -0.01927878f, 
    0.01010239f, 0.00261575f, 0.04672673f, -0.08008680f, -0.04903412f, -0.08435805f, 0.11415145f, -0.13759258f, 
    0.13310358f, -0.16254176f, 0.10876326f, -0.11447201f, -0.02884220f, -0.09782095f, -0.01323155f, 0.14431621f, 
    -0.01279395f, 0.02228840f, 0.01194146f, -0.09955937f, 0.06130113f, -0.04464121f, -0.01600184f, -0.03518520f, 
    -0.07051665f, 0.03058657f, -0.09870905f, 0.05767303f, -0.15502617f, -0.16474561f, 0.09601172f, -0.24014096f, 
    -0.21984339f, -0.13540119f, 0.09193613f, 0.09687553f, -0.04395379f, -0.00640025f, -0.12517829f, -0.03925930f, 
    0.01074816f, -0.04594759f, 0.01053322f, -0.19744329f, 0.01005540f, -0.07890428f, -0.00007577f, 0.00653196f, 
    -0.25852570f, -0.02570494f, 0.04209138f, 0.21893850f, 0.09095140f, 0.07315758f, 0.02847094f, -0.06203687f, 
    0.03465986f, 0.13609642f, 0.05885072f, 0.03714686f, -0.04636145f, 0.01095808f, 0.02006141f, 0.05072377f, 
    -0.07536586f, 0.04717885f, 0.04154706f, -0.10872020f, 0.04171301f, -0.18074802f, 0.05847460f, 0.12109893f, 
    -0.09892670f, 0.11806937f, 0.03512146f, -0.11314596f, 0.00058741f, 0.09382214f, -0.02600566f, -0.01643440f, 
    -0.05790726f, 0.02325986f, 0.13190857f, -0.05530182f, -0.00974441f, 0.04210704f, -0.07380561f, 0.03997948f, 
    0.22957431f, 0.13045213f, -0.07572056f, -0.11830922f, 0.04779373f, 0.06480362f, 0.06475038f, 0.04189834f, 
    0.03618132f, -0.03608067f, -0.01882255f, 0.06251547f, 0.09283188f, 0.02911842f, 0.01111884f, 0.06552975f, 
    0.03791793f, -0.01807410f, -0.05841279f, -0.03950793f, 0.15866080f, 0.15138657f, 0.05085111f, -0.03581548f, 
    0.16879675f, 0.01355731f, 0.06128725f, -0.02911013f, 0.01132028f, 0.19807166f, 0.19464947f, -0.02785879f, 
    -0.02822859f, 0.03413992f, 0.04143698f, 0.03152393f, 0.10128360f, -0.11226806f, 0.05644197f, 0.05739988f, 
    -0.34563369f, 0.17829151f, 0.01374462f, -0.12311856f, 0.00425676f, -0.08530961f, 0.04512326f, -0.02025584f, 
    0.07532209f, -0.03776787f, -0.02627823f, -0.01158771f, 0.03109178f, 0.11387763f, 0.12786685f, -0.03949766f, 
    0.04592534f, -0.01888553f, -0.00618848f, -0.11179350f, 0.01618513f, -0.01371563f, -0.20058446f, 0.03546816f, 
    -0.13683173f, -0.05775135f, -0.11494559f, -0.01337234f, -0.06194178f, -0.03102610f, -0.07764220f, 0.03353787f, 
    0.08461516f, -0.09408563f, 0.01681586f, 0.01339785f, 0.01471858f, -0.05415267f, -0.08504376f, 0.08075079f, 
    -0.32360867f, 0.22164412f, 0.10413817f, 0.10281842f, 0.08868913f, -0.10679119f, 0.08613990f, 0.03548063f, 
    0.18761808f, -0.01055470f, -0.03832779f, 0.08777113f, 0.05001141f, -0.02302796f, 0.13668461f, 0.14818406f, 
    -0.07736097f, 0.02909841f, 0.07162171f, 0.05642753f, 0.14382975f, -0.05899772f, 0.15557849f, 0.09157811f, 
    -0.14004616f, -0.16886967f, 0.17877860f, 0.14555503f, -0.01190881f, 0.02882269f, 0.13185796f, 0.02555269f, 
    0.03341823f, -0.00337206f, 0.06467294f, 0.02439115f, 0.04662700f, 0.17168568f, 0.09432688f, 0.08509254f, 
    -0.07543469f, 0.08689366f, -0.22700378f, 0.00923563f, -0.18379270f, 0.19482902f, 0.08067731f, -0.00516184f, 
    0.10877687f, 0.07855021f, 0.06522714f, -0.00745619f, 0.05171617f, -0.02537720f, 0.04702587f, 0.07789558f, 
    0.07051615f, 0.04523458f, 0.05861187f, 0.07745167f, 0.29034901f, -0.05228731f, 0.08724943f, -0.11855941f, 
    -0.02574139f, -0.08204143f, 0.08313140f, 0.01862536f, -0.01788631f, 0.03291154f, -0.03565733f, -0.15009671f, 
    -0.00905733f, 0.03547202f, 0.05974043f, -0.05602087f, 0.02513921f, 0.01175186f, -0.02399482f, 0.01628264f, 
    0.01116060f, -0.22319490f, -0.16680843f, -0.01756378f, -0.09190291f, -0.25895825f, -0.02889802f, -0.03179152f, 
    0.10187451f, 0.01412115f, -0.01645239f, -0.02475088f, 0.00851498f, 0.03085284f, 0.00270069f, 0.07727583f, 
    -0.05031909f, 0.08450413f, 0.08557880f, -0.05765255f, -0.12036516f, -0.01644797f, -0.22700253f, 0.10797104f, 
    -0.08482069f, 0.07332319f, -0.01748697f, 0.08372725f, 0.03832752f, -0.01193900f, 0.12178922f, 0.01499080f, 
    0.02452843f, 0.05688804f, 0.01521170f, -0.01599590f, 0.00361719f, -0.10104565f, -0.03020236f, 0.15923312f, 
    -0.25791022f, -0.03303432f, -0.24499084f, 0.15798207f, -0.20042843f, 0.14292765f, 0.15453969f, 0.04238558f, 
    0.07207203f, 0.05231016f, -0.02319074f, -0.03924657f, 0.04133109f, -0.04125284f, 0.01362119f, 0.03391854f, 
    0.12107938f, 0.03454743f, 0.06006830f, 0.12038112f, -0.20387568f, -0.07407883f, -0.21867751f, 0.08689481f, 
    -0.10577410f, 0.07709903f, -0.14209785f, 0.12518738f, -0.02076969f, 0.08541786f, -0.06171536f, -0.10791875f, 
    0.01329092f, 0.04522346f, 0.01452716f, -0.04478835f, -0.04970744f, 0.07358623f, 0.00838621f, -0.02634654f, 
    0.09638780f, -0.00077725f, 0.08085348f, 0.04116807f, -0.00936552f, -0.13710326f, 0.09748947f, 0.12314019f, 
    -0.00326652f, -0.08592614f, 0.13889199f, 0.04464267f, 0.02437172f, 0.07526217f, 0.07255800f, 0.03633647f, 
    0.08204337f, -0.02891757f, 0.05684594f, 0.01112922f, -0.03177531f, -0.18144563f, 0.20356940f, -0.04272956f, 
    -0.04600336f, -0.00277009f, 0.19539081f, 0.07244109f, 0.04439617f, 0.08431557f, 0.10091672f, -0.01000252f, 
    0.04705706f, 0.01848315f, 0.01322475f, -0.03335766f, 0.05207326f, 0.07972652f, 0.07526967f, 0.04499482f, 
    -0.36072859f, 0.29178694f, -0.20802699f, 0.21707086f, -0.23227720f, 0.07470086f, -0.07152269f, 0.03382223f, 
    -0.08501824f, 0.02347434f, 0.04095512f, 0.04091529f, 0.09830676f, 0.05605032f, 0.01095855f, 0.10609462f, 
    -0.05671184f, 0.01632898f, 0.04912724f, -0.04769449f, -0.23679997f, 0.03757325f, -0.03643551f, 0.08835251f, 
    -0.11721408f, 0.08073638f, -0.01873631f, -0.00726341f, 0.00162657f, 0.00131792f, 0.15749110f, 0.07705352f, 
    0.14371544f, 0.10307097f, 0.11912046f, -0.02715747f, 0.10010737f, -0.04136794f, 0.01840985f, 0.01422293f, 
    0.01468787f, -0.01163609f, -0.05686906f, -0.03897841f, -0.00193255f, 0.00416757f, -0.02686522f, -0.02352915f, 
    0.02301467f, 0.00840469f, -0.04303069f, 0.00698535f, -0.00488492f, 0.03097906f, -0.06324837f, -0.06279944f, 
    0.03165437f, 0.01541636f, 0.01462623f, -0.03747478f, 0.00119427f, -0.03993931f, 0.03105630f, -0.03888827f, 
    -0.00247775f, 0.02330036f, 0.02577074f, -0.02701123f, 0.03400727f, -0.01045015f, -0.01965043f, 0.01687266f, 
    0.02723461f, -0.01778174f, -0.03471049f, 0.00395325f, 0.03642750f, 0.04522302f, 0.02866765f, -0.02885241f, 
    -0.00932082f, -0.02376091f, 0.03678364f, -0.04843975f, 0.02968567f, -0.04863338f, 0.04534030f, -0.01455739f, 
    0.01716255f, -0.05635786f, -0.01229133f, -0.01826963f, 0.03596854f, 0.02635696f, 0.04953831f, -0.05387834f, 
    -0.00786292f, 0.02166217f, -0.01474977f, -0.00775592f, 0.02880284f, -0.04111084f, 0.01911847f, -0.01146726f, 
    -0.00043705f, -0.06046439f, 0.03344356f, -0.03526277f, -0.02067168f, -0.05018922f, -0.00670357f, -0.04730797f, 
    -0.03107872f, 0.00508532f, 0.01254553f, -0.00392783f, -0.03299367f, 0.01046406f, -0.00530705f, 0.06070603f, 
    0.02857331f, 0.00677727f, -0.02004292f, -0.05926351f, 0.01968037f, 0.05294282f, 0.01475205f, -0.01293235f, 
    0.02268695f, 0.03458879f, 0.01248773f, -0.04769624f, -0.04961672f, 0.01311269f, 0.02901438f, 0.01069422f, 
    0.01630153f, -0.04821006f, 0.02168371f, 0.02619143f, 0.00659422f, -0.01493161f, -0.03985623f, -0.04671630f, 
    -0.00683398f, -0.04007496f, 0.01490478f, -0.05459209f, 0.02797045f, -0.04856683f, -0.03395955f, 0.00224670f, 
    0.03650852f, 0.03422014f, -0.05799129f, 0.03560134f, 0.00977325f, 0.00547153f, 0.01080198f, -0.01721907f, 
    0.03083267f, -0.03571954f, 0.00905609f, -0.03578549f, -0.02172459f, -0.04138941f, 0.03159773f, -0.04162869f, 
    0.04128514f, 0.00237307f, -0.05502411f, -0.02442265f, -0.05227173f, 0.04110608f, 0.03865461f, -0.00823479f, 
    0.02887798f, -0.05580161f, -0.04052581f, -0.01998978f, 0.00164850f, 0.01659016f, 0.04333423f, 0.01928586f, 
    0.03107047f, -0.02411519f, 0.03891530f, -0.05710009f, -0.03983411f, -0.05347417f, 0.03437281f, -0.02593573f, 
    0.02825593f, -0.03370103f, -0.04238549f, 0.02124960f, -0.00844397f, 0.00634950f, 0.03275453f, -0.04430359f, 
    0.02635869f, 0.00639167f, -0.04547632f, -0.05398186f, 0.01980852f, -0.02745647f, -0.01054277f, 0.03054542f, 
    -0.01104055f, 0.03344723f, 0.00580845f, -0.00070134f, 0.04210272f, 0.00468704f, -0.05165482f, -0.01017733f, 
    -0.02287077f, -0.04354567f, -0.02683896f, 0.03977649f, -0.04720660f, -0.03062639f, -0.00219465f, 0.04783536f, 
    0.00212560f, 0.02783268f, -0.03019945f, -0.00712878f, -0.06028355f, -0.00498772f, -0.05003624f, 0.01436033f, 
    -0.02991040f, 0.01497631f, 0.00892285f, 0.04173049f, 0.04590075f, -0.05230091f, -0.03739208f, -0.03220008f, 
    -0.05259307f, 0.01437638f, -0.01722860f, 0.03430169f, -0.04636044f, -0.02808286f, -0.05711448f, 0.01055294f, 
    -0.04575258f, 0.00740850f, -0.02784777f, 0.03079238f, -0.05379186f, 0.00093557f, -0.05881244f, 0.00526054f, 
    0.00084519f, 0.00760664f, -0.05415706f, 0.02129173f, -0.05151632f, 0.05033189f, -0.00970975f, -0.05268735f, 
    0.00326289f, 0.00378556f, 0.04402379f, 0.01108692f, -0.05727030f, -0.02711888f, 0.01531578f, -0.00085867f, 
    -0.02538275f, -0.01432367f, -0.04946567f, 0.01765565f, -0.01986057f, -0.00601036f, -0.00892881f, -0.03371553f, 
    -0.03735013f, -0.05454333f, -0.02059273f, -0.01872268f, 0.01040379f, -0.06205912f, 0.03759121f, -0.01005015f, 
    -0.00691531f, -0.04563586f, 0.03817062f, 0.03810571f, -0.02329017f, 0.02612835f, 0.01525446f, -0.05153486f, 
    0.02962238f, 0.04892191f, 0.03326708f, -0.03967229f, 0.04921363f, -0.02373538f, -0.01864455f, 0.00730809f, 
    -0.02281500f, -0.05731501f, 0.01150512f, -0.05668037f, 0.00857570f, -0.02099713f, 0.04492658f, -0.01567034f, 
    -0.03231858f, -0.04561553f, 0.04610128f, 0.02903354f, 0.02664784f, -0.00263637f, -0.01004362f, 0.05577268f, 
    0.02065039f, -0.04244202f, 0.03078481f, -0.05630338f, 0.02644526f, -0.05196970f, -0.03042633f, 0.01546944f, 
    -0.04335693f, 0.02412723f, -0.02990753f, -0.03541224f, -0.00609937f, 0.02685822f, -0.02068982f, -0.03542272f, 
    0.01525270f, -0.04613134f, -0.05035242f, -0.00608506f, -0.02684628f, -0.04683021f, -0.01687678f, -0.00482169f, 
    -0.04828597f, -0.03429492f, 0.00645297f, -0.05790168f, 0.03142718f, 0.00170935f, -0.01842155f, -0.04299229f, 
    -0.00789451f, 0.03604239f, 0.02365758f, 0.04102587f, -0.04262914f, 0.01527592f, -0.06294677f, 0.00007403f, 
    0.00747968f, -0.03262464f, -0.01085734f, 0.00653322f, -0.06293062f, -0.02400214f, -0.04090907f, -0.04315759f, 
    -0.03210412f, -0.01397545f, -0.05572313f, -0.02512094f, -0.05196097f, 0.03877424f, -0.01631834f, 0.02769418f, 
    -0.02628008f, -0.03886672f, -0.05346348f, -0.05026476f, 0.00338438f, 0.02997939f, 0.02468178f, -0.01380672f, 
    0.02038817f, -0.07974322f, -0.06092232f, 0.02462290f, -0.05105586f, -0.04951233f, 0.00204962f, -0.02631046f, 
    0.01925470f, -0.06121486f, 0.03414269f, 0.04855120f, -0.06357788f, 0.00740475f, -0.00554925f, 0.04369962f, 
    -0.02639838f, 0.02061555f, -0.00941868f, 0.01173280f, 0.00141178f, 0.02538529f, 0.02204098f, 0.00610756f, 
    -0.00114453f, 0.00637969f, -0.01235300f, -0.02761320f, -0.00312014f, -0.01681377f, 0.03444337f, 0.04986656f, 
    0.00963022f, 0.00734099f, -0.02500889f, -0.05421376f, 0.04475036f, 0.01860886f, -0.02134219f, -0.00125571f, 
    0.04089688f, 0.03610934f, 0.01643582f, 0.02859409f, -0.06100841f, 0.03533158f, -0.02339391f, 0.01339129f, 
    -0.01594335f, 0.03216386f, -0.04769638f, 0.02746634f, -0.04836670f, 0.05326743f, -0.03277846f, 0.02884975f, 
    -0.01338007f, -0.00103800f, 0.00069680f, -0.03103390f, 0.03768031f, 0.05450616f, 0.03954246f, -0.04832619f, 
    0.01905420f, 0.03992708f, -0.01091017f, 0.01041363f, 0.00176822f, -0.01566624f, -0.01901643f, 0.05068390f, 
    -0.05797355f, -0.02977130f, -0.05488234f, -0.01900478f, -0.06041155f, 0.02108152f, -0.02248725f, 0.03894953f, 
    -0.05100647f, -0.02773578f, -0.01930292f, -0.01915460f, 0.04960042f, 0.03173696f, -0.00625897f, -0.02042308f, 
    -0.05263294f, -0.04696983f, 0.02538061f, 0.04121123f, -0.05234804f, 0.04216037f, -0.04091664f, 0.01986619f, 
    -0.04365694f, -0.00125924f, -0.03478872f, 0.00127944f, 0.01666806f, 0.06267164f, 0.00939657f, -0.04808098f, 
    -0.03841606f, -0.03308214f, -0.00770584f, 0.05065637f, 0.00156803f, 0.02769540f, -0.02384569f, -0.03798334f, 
    -0.04486269f, 0.03093028f, 0.02600858f, -0.04935091f, 0.03270311f, -0.00142197f, -0.04847592f, 0.04838859f, 
    -0.04517302f, 0.03643042f, 0.02999931f, -0.02734857f, 0.01367374f, -0.02118161f, -0.00122830f, 0.01821889f, 
    -0.06998216f, -0.04358200f, -0.01642877f, -0.04666824f, 0.03333625f, -0.06903976f, 0.02569061f, 0.00481679f, 
    -0.04642747f, -0.00271072f, 0.05432157f, 0.01906214f, 0.02340734f, -0.03647023f, -0.05106293f, 0.03632290f, 
    0.03938616f, -0.03966571f, -0.00307417f, -0.05387929f, -0.00011169f, -0.04007152f, -0.06543153f, 0.02065140f, 
    -0.04059299f, 0.02457118f, -0.00188209f, 0.03975501f, -0.00660803f, 0.01977728f, 0.00368499f, -0.01556739f, 
    0.03087221f, -0.04412309f, 0.01297289f, -0.02578670f, -0.03820584f, -0.01101921f, 0.01184888f, -0.05489128f, 
    -0.04622481f, -0.04683435f, 0.02579854f, 0.01819917f, 0.02198925f, 0.04181114f, 0.01952050f, 0.02087144f, 
    -0.05090013f, -0.01615691f, -0.03651070f, -0.04707284f, -0.03517109f, -0.04445803f, -0.05412943f, -0.02673659f, 
    -0.02094447f, 0.02624658f, 0.03760273f, -0.04318664f, 0.03448675f, 0.03187057f, 0.02376333f, -0.04856629f, 
    0.00280753f, -0.04679956f, -0.03434877f, 0.02574072f, 0.00090645f, 0.00964317f, 0.03498014f, 0.08034411f, 
    0.03440369f, 0.04134418f, -0.01430980f, -0.01263071f, 0.01218157f, -0.05218079f, -0.06874861f, 0.03767760f, 
    0.04717221f, 0.01366240f, -0.05177532f, -0.04784004f, 0.03018627f, 0.04567209f, -0.03890822f, 0.04045129f, 
    0.02957074f, 0.03464114f, 0.00796039f, 0.04813628f, 0.02721411f, 0.02705718f, -0.02060488f, 0.00859921f, 
    0.03452686f, -0.03893890f, -0.05420756f, -0.03840785f, -0.02574868f, 0.02664591f, 0.02198719f, -0.00203739f, 
    -0.04821073f, 0.04831819f, 0.04457435f, 0.02440752f, -0.05703196f, -0.06841733f, -0.00340437f, 0.03809797f, 
    -0.01573414f, -0.05115200f, -0.06108990f, -0.03378440f, -0.04725853f, -0.00275438f, -0.05228682f, 0.01556109f, 
    -0.07043764f, 0.02139702f, -0.02632690f, -0.01637333f, 0.04395168f, 0.06324886f, 0.01214538f, -0.05928294f, 
    0.00221030f, 0.05415091f, 0.05506546f, -0.01743417f, -0.03007682f, -0.01263825f, -0.01626202f, 0.02341348f, 
    -0.00757037f, -0.02393927f, -0.04756958f, -0.05551731f, -0.05640279f, -0.00412021f, -0.01057597f, 0.00630966f, 
    0.01026238f, 0.00843528f, -0.05451920f, -0.03177810f, -0.02448235f, -0.02249343f, -0.00768337f, -0.06531519f, 
    -0.01880088f, 0.02770099f, -0.01240528f, 0.01638992f, -0.04509488f, 0.05035663f, -0.01664550f, -0.00119352f, 
    0.02524585f, -0.03655984f, -0.02919839f, -0.03772111f, -0.00863329f, -0.01863376f, -0.05569026f, 0.01155176f, 
    0.00828766f, -0.01110540f, -0.05768279f, -0.01567626f, -0.00754336f, -0.02260068f, -0.04530296f, 0.01428634f, 
    0.03811204f, -0.00030542f, -0.01239972f, 0.01549530f, -0.01891681f, 0.01036354f, 0.02894893f, -0.01683273f, 
    0.02037197f, -0.02185046f, -0.05910189f, -0.05204359f, -0.03094560f, -0.04488372f, -0.00742395f, -0.02884439f, 
    -0.00407422f, -0.03462689f, 0.03353705f, -0.00768392f, 0.02484518f, -0.00562529f, -0.00651017f, -0.03582058f, 
    0.01206174f, -0.01761032f, 0.02137425f, -0.01912620f, 0.02890627f, 0.00433750f, 0.00790056f, 0.00901655f, 
    0.04327232f, -0.03671185f, -0.04096343f, -0.02930000f, -0.05788643f, -0.04547964f, 0.03900736f, 0.03054673f, 
    -0.02561835f, -0.03482870f, -0.00206689f, -0.00221166f, -0.02601690f, -0.01942735f, -0.00169993f, 0.01406363f, 
    0.04866865f, -0.00658294f, -0.05085680f, 0.03869065f, 0.03438837f, 0.04533954f, 0.01129801f, -0.01367460f, 
    -0.05200405f, -0.01553284f, -0.01310549f, 0.01202224f, -0.04715251f, -0.02842015f, -0.05691090f, 0.03631540f, 
    -0.04923692f, -0.03468658f, -0.03601396f, -0.03287106f, -0.04735322f, -0.03670751f, -0.01659363f, -0.04343941f, 
    -0.03828621f, -0.01543971f, -0.05996428f, 0.01777481f, 0.00715086f, -0.04514348f, 0.04686950f, -0.01369391f, 
    -0.00598999f, 0.04611366f, 0.04482292f, 0.01654790f, -0.01911299f, -0.00531635f, -0.04077974f, 0.00168567f, 
    -0.03590861f, 0.04305696f, 0.00311771f, -0.03587997f, -0.04261329f, 0.00596674f, 0.01844306f, 0.01888434f, 
    0.01881295f, 0.00691168f, -0.04424042f, 0.00362881f, -0.00297288f, -0.01005514f, -0.01057749f, -0.06060700f, 
    -0.00231711f, 0.04911074f, 0.03093246f, -0.03568029f, -0.04697526f, -0.02617063f, -0.01430965f, -0.04447153f, 
    0.01092022f, -0.03716470f, -0.04326186f, -0.00542792f, -0.04722697f, -0.00089322f, 0.00273058f, -0.02358143f, 
    -0.02719191f, -0.03676386f, -0.02379149f, -0.04146006f, -0.02255624f, 0.03097023f, -0.05386336f, -0.02615025f, 
    -0.03012703f, 0.02973343f, -0.03609100f, 0.04724090f, -0.03090103f, -0.00104091f, -0.03157018f, 0.00029019f, 
    -0.04262362f, -0.01805845f, 0.04271725f, -0.02321785f, -0.05797938f, 0.04231698f, -0.05562652f, 0.02868357f, 
    0.04074142f, -0.03573384f, -0.03058440f, 0.01656076f, -0.02214941f, 0.03895608f, -0.02981979f, -0.02706821f, 
    -0.00134872f, 0.04244702f, -0.05712892f, -0.00398499f, 0.01973598f, 0.02459539f, -0.01630834f, -0.01818553f, 
    0.01555805f, -0.00753573f, -0.06046618f, 0.04495245f, -0.02142175f, 0.01771126f, -0.06013972f, -0.02679963f, 
    -0.00559168f, 0.01574016f, 0.01572098f, 0.03300649f, 0.04858458f, 0.04284474f, -0.04483468f, -0.00812746f, 
    -0.06032884f, -0.05933220f, 0.04340873f, -0.04135144f, -0.01805563f, -0.00104454f, 0.00327259f, -0.05463605f, 
    -0.01932778f, 0.03641477f, 0.01670663f, 0.02892197f, -0.03070712f, -0.04885379f, 0.03230345f, 0.02537453f, 
    0.02806595f, -0.02053748f, -0.03783179f, 0.00216076f, -0.01175091f, -0.02264959f, 0.04560404f, 0.04470262f, 
    -0.00967348f, 0.02412724f, -0.03661591f, -0.03814333f, -0.04454233f, -0.00252356f, -0.03943361f, 0.02414699f, 
    0.04978589f, -0.02776882f, -0.00267607f, -0.01392327f, -0.04800422f, -0.04963315f, -0.04112951f, 0.04481166f, 
    -0.01694683f, -0.01769247f, -0.00344168f, -0.03301499f, 0.04848675f, 0.00773645f, 0.01381350f, 0.03862351f, 
    -0.01744085f, 0.01715710f, -0.02623467f, -0.03941365f, -0.01365258f, 0.00847751f, 0.02991063f, 0.04214749f, 
    0.01631602f, -0.03712669f, 0.01190303f, -0.03446732f, 0.03461306f, 0.04270566f, -0.01919977f, -0.03238875f, 
    -0.00046885f, 0.03471270f, -0.01499389f, 0.01391026f, -0.00942713f, 0.00567983f, 0.03824612f, -0.01168388f, 
    0.01974767f, 0.02543433f, -0.00259879f, 0.02497699f, -0.02938544f, 0.04883024f, -0.01957840f, 0.00563014f, 
    0.00485924f, 0.04112675f, 0.02621835f, -0.01756127f, 0.01299212f, -0.01961530f, 0.03404375f, -0.00207951f, 
    0.03994143f, -0.00149407f, -0.01459248f, -0.02951235f, 0.04039221f, 0.02463226f, 0.02821699f, -0.00058155f, 
    -0.04616918f, -0.05470813f, 0.01542449f, -0.00412596f, 0.04757157f, -0.03447615f, -0.04820525f, -0.05327015f, 
    -0.02705402f, 0.00326076f, -0.03012120f, -0.06173476f, 0.03897240f, -0.05198688f, -0.01549457f, -0.05059962f, 
    0.04051961f, -0.02258234f, 0.03875803f, -0.01039908f, -0.01685299f, -0.02125332f, 0.04262722f, -0.03627575f, 
    -0.05938017f, 0.02868824f, 0.01621597f, -0.01985548f, -0.03328883f, -0.02985569f, -0.00690861f, -0.00342296f, 
    -0.05172428f, -0.00774402f, 0.03907232f, -0.04352323f, -0.00940535f, 0.01810115f, -0.05114408f, -0.05969469f, 
    0.09328313f, 0.32923526f, -0.11496246f, -0.08632340f, -0.03695174f, 0.07609905f, 0.04695578f, 0.06141479f, 
    -0.09085166f, 0.06561392f, -0.00732122f, 0.04298978f, 0.02697994f, 0.04744731f, -0.04399010f, 0.14035481f, 
    0.07553592f, -0.01194790f, 0.01956613f, 0.01062010f, -0.14396262f, -0.03866544f, 0.09115450f, -0.05491443f, 
    0.08474149f, 0.06218204f, -0.01026097f, -0.07057842f, 0.10113368f, 0.04410041f, 0.14830481f, 0.03016499f, 
    0.01634239f, 0.17234285f, -0.01655065f, -0.08380079f, 0.12671523f, -0.14350076f, -0.13060531f, 0.00279007f, 
    -0.14804173f, 0.25284979f, -0.07802856f, -0.22630213f, -0.21979712f, 0.03646495f, 0.03692035f, -0.13294038f, 
    0.02614266f, 0.01495967f, -0.02930848f, 0.03456510f, -0.00057766f, -0.04399703f, 0.11245702f, -0.06971186f, 
    -0.02191193f, 0.05558188f, 0.01896472f, -0.06435432f, -0.30114239f, 0.02720833f, -0.02380029f, 0.06753015f, 
    0.04871146f, 0.03300982f, 0.11319755f, -0.13207296f, -0.01758378f, 0.16820763f, 0.07427672f, 0.00605477f, 
    0.03396512f, -0.08096190f, 0.03985573f, -0.03491727f, -0.00035849f, -0.09050032f, 0.04528145f, -0.01611657f, 
    -0.17881708f, 0.03547089f, 0.11723117f, -0.04093706f, 0.04387290f, -0.05010769f, -0.01063322f, 0.00254715f, 
    0.00946051f, -0.02039459f, -0.05014699f, -0.05831804f, -0.02312306f, -0.02602681f, 0.08837418f, 0.01928837f, 
    -0.11479796f, 0.07563400f, -0.03931696f, 0.02100104f, 0.06086557f, -0.09576704f, 0.14886342f, 0.06826292f, 
    -0.12615915f, -0.03834662f, 0.09835286f, 0.04851348f, 0.07486657f, -0.03961010f, 0.11043865f, 0.07693973f, 
    0.07110544f, 0.03443475f, 0.11417075f, -0.03965142f, 0.08927517f, 0.03815652f, -0.10170776f, -0.06028867f, 
    -0.02245389f, 0.31886819f, 0.19140200f, -0.08729476f, 0.10186047f, 0.08216336f, 0.07906067f, -0.08322398f, 
    -0.05985063f, 0.01922713f, -0.05072565f, -0.05223913f, -0.03121120f, 0.02837878f, 0.09481003f, -0.12639277f, 
    0.12741056f, -0.05930402f, 0.11270218f, 0.08927507f, -0.22310863f, -0.09533966f, 0.03848004f, -0.27162507f, 
    -0.08409934f, 0.08732314f, -0.01335721f, -0.07668038f, -0.06056212f, 0.17501195f, -0.01199436f, -0.04447367f, 
    0.00823252f, -0.13452139f, -0.01766765f, -0.08966433f, 0.12518449f, -0.18623312f, 0.00493207f, 0.13903309f, 
    -0.24830604f, -0.06256402f, -0.00344261f, 0.03404887f, -0.02419312f, 0.13125740f, 0.00065115f, 0.02672419f, 
    0.12562719f, 0.11753406f, 0.07489982f, -0.02795046f, 0.04880744f, -0.01783128f, -0.00545832f, -0.00598697f, 
    0.00255281f, 0.02493208f, 0.08638450f, 0.03712466f, -0.36168459f, -0.05877129f, 0.07060932f, 0.00716742f, 
    0.00796251f, -0.01293922f, -0.02871152f, 0.07828991f, -0.01104000f, -0.05439169f, 0.18727393f, -0.09550849f, 
    0.09270219f, -0.07928162f, 0.01914757f, 0.05957706f, -0.00473681f, -0.11343222f, 0.12267166f, 0.20297058f, 
    0.37321326f, 0.35299528f, 0.11462676f, 0.17428662f, 0.12855995f, 0.00038912f, -0.00731533f, -0.10673603f, 
    0.00760437f, -0.10301625f, 0.05038052f, 0.04705477f, -0.02817574f, 0.01035983f, 0.03046622f, 0.06729570f, 
    0.08804239f, 0.05632451f, 0.11463840f, -0.04029155f, -0.38738027f, 0.10738499f, -0.26801929f, 0.13951977f, 
    0.01704223f, 0.09549990f, 0.01241263f, 0.03904076f, -0.08133019f, 0.06608341f, -0.02409979f, -0.00890890f, 
    -0.03342147f, -0.09787813f, 0.10662692f, 0.07933486f, 0.06690169f, 0.12684166f, 0.04941855f, -0.00190185f, 
    -0.26405928f, 0.00681682f, 0.03071559f, -0.01716310f, 0.08461810f, -0.00967007f, 0.02641517f, 0.12566417f, 
    -0.09333782f, 0.01589923f, 0.05194878f, -0.01647317f, 0.07960313f, -0.01792210f, 0.06137894f, 0.01681645f, 
    0.04622635f, -0.18265301f, 0.01486606f, 0.06270450f, -0.12959740f, -0.28029889f, 0.27679765f, 0.16126618f, 
    -0.04875977f, -0.15934171f, 0.02827483f, 0.00998183f, -0.00756640f, 0.11061470f, -0.00329306f, 0.00063860f, 
    0.08965977f, 0.03823691f, 0.08716749f, -0.07058515f, 0.10097989f, -0.06492583f, -0.01861982f, 0.01006180f, 
    -0.19355327f, 0.25512463f, -0.03931876f, 0.24967264f, -0.08433712f, 0.16126564f, 0.00605952f, -0.06565883f, 
    0.01308610f, 0.16240586f, -0.02294888f, 0.05036704f, 0.01605242f, 0.06037134f, 0.00762080f, 0.13880423f, 
    0.00419575f, 0.01357461f, 0.06735018f, 0.06848409f, -0.05472932f, -0.07419885f, -0.12544343f, 0.17837203f, 
    -0.14422362f, 0.06037030f, -0.01479718f, 0.00536164f, 0.09617595f, -0.06251837f, -0.06522041f, 0.03981152f, 
    0.03235994f, 0.08639669f, 0.22604968f, -0.01203435f, -0.04943750f, 0.02064474f, -0.03621471f, -0.01815611f, 
    0.00999150f, -0.00377964f, 0.02691096f, 0.02695706f, -0.05743458f, 0.01033555f, 0.02041853f, -0.03531216f, 
    0.00812309f, 0.03958717f, -0.01747913f, 0.03134473f, 0.03981038f, -0.06240067f, 0.04549813f, -0.01318991f, 
    -0.01170695f, -0.04888473f, 0.01559651f, 0.02452666f, -0.03261656f, 0.04952475f, -0.05369427f, 0.01802164f, 
    -0.03583964f, -0.02514907f, -0.02591680f, -0.05275606f, 0.01837376f, 0.00334481f, -0.03338419f, 0.00288981f, 
    0.01790563f, 0.03256574f, -0.00802621f, -0.00283839f, 0.03845764f, -0.02583411f, 0.04865114f, 0.00933294f, 
    -0.00643783f, 0.03826570f, -0.03797977f, -0.01545428f, -0.00301502f, -0.02943157f, 0.02857917f, -0.05040009f, 
    -0.04245121f, 0.01198894f, 0.00326370f, -0.02454689f, 0.01498150f, 0.01567535f, 0.04050139f, 0.04041908f, 
    0.03326855f, 0.03678213f, 0.00651162f, -0.04672539f, -0.03757118f, -0.00139422f, 0.02112094f, -0.00093879f, 
    0.00488888f, 0.01475717f, 0.04589325f, 0.00532188f, -0.03316232f, -0.01686562f, -0.00349516f, -0.02708382f, 
    -0.01664980f, 0.04901871f, -0.01362290f, -0.03685434f, 0.04443332f, -0.01745907f, -0.03769054f, 0.01056431f, 
    -0.02885012f, 0.01822729f, -0.00657962f, -0.05629249f, 0.03084178f, -0.05396616f, -0.05677878f, -0.05433497f, 
    0.02921663f, 0.03415829f, 0.04520647f, 0.00204073f, -0.01105563f, 0.01876152f, -0.04728397f, 0.00827586f, 
    -0.02324358f, -0.05344786f, 0.00038414f, 0.03060155f, -0.02855391f, -0.02880217f, -0.03830906f, -0.04995413f, 
    -0.05616015f, 0.02086285f, 0.01364284f, -0.04115871f, 0.01241916f, 0.02623927f, -0.03436698f, -0.04370604f, 
    0.00755274f, -0.01763919f, 0.01487713f, 0.03295318f, -0.02282562f, -0.05970377f, 0.03919280f, 0.01304551f, 
    0.04372042f, -0.06259294f, -0.02249928f, -0.01335066f, -0.04750396f, -0.02384442f, -0.01905200f, -0.02203101f, 
    -0.04654716f, -0.03034239f, -0.05054858f, 0.00737354f, 0.01658336f, 0.03836771f, 0.01611884f, 0.02740260f, 
    -0.05282930f, 0.01090257f, 0.03108533f, 0.00149766f, 0.03805907f, -0.02000269f, -0.02821656f, -0.04269928f, 
    -0.04120405f, 0.00291833f, -0.00668676f, -0.01921851f, -0.05793374f, 0.03440979f, -0.00217224f, 0.01003918f, 
    0.02906395f, 0.03112915f, 0.01726732f, -0.04462330f, -0.03865919f, -0.03488925f, -0.02973069f, -0.03066670f, 
    -0.04549430f, -0.05506567f, -0.02699670f, -0.01032901f, 0.03221314f, -0.05944534f, -0.00581388f, -0.03471502f, 
    0.04437245f, -0.04490107f, -0.04341451f, -0.05688357f, 0.03021472f, 0.03584774f, -0.00618197f, 0.03550585f, 
    0.02072614f, 0.00662598f, 0.03189219f, -0.02986506f, -0.03285657f, -0.04849795f, 0.00000828f, 0.01441036f, 
    0.02131316f, -0.03747498f, -0.02789035f, -0.04137958f, -0.03695381f, 0.04038518f, 0.04300402f, -0.04524570f, 
    0.00350177f, -0.01362982f, 0.03528499f, -0.01924403f, 0.05197805f, -0.05952617f, -0.00556980f, 0.01789648f, 
    -0.06350888f, 0.02884037f, -0.05535752f, -0.05021034f, -0.00841854f, 0.03477829f, -0.04345445f, -0.01734034f, 
    -0.04907389f, -0.03325991f, 0.04286813f, -0.03769324f, -0.04566339f, 0.01458691f, 0.01121855f, 0.03700006f, 
    0.04209682f, -0.06316775f, 0.00832694f, -0.05138713f, -0.06102124f, -0.00590997f, -0.03129145f, -0.01747975f, 
    0.03172192f, 0.02821244f, 0.01020614f, 0.04482710f, 0.00706763f, 0.01718342f, -0.01269905f, 0.00352594f, 
    -0.03535120f, -0.03733400f, 0.02188429f, -0.03276190f, -0.01800902f, -0.00684880f, -0.01016445f, -0.01438509f, 
    -0.06346180f, -0.04919855f, 0.00664611f, 0.02842589f, 0.04545967f, -0.02114978f, 0.01364096f, -0.01632352f, 
    0.02908352f, 0.04655250f, -0.05142952f, -0.03344259f, 0.03930591f, -0.03289739f, -0.02697936f, -0.02783233f, 
    -0.00586928f, -0.01377823f, -0.00512742f, -0.03877533f, 0.03429621f, -0.01582327f, 0.04590517f, 0.02179014f, 
    -0.04896067f, -0.04583725f, -0.02675165f, 0.00908847f, -0.05159582f, -0.02954306f, -0.00030433f, -0.05294564f, 
    -0.05743158f, 0.01039343f, -0.06218027f, -0.05371268f, 0.02883078f, -0.02847865f, -0.05209149f, 0.03040443f, 
    0.02451554f, 0.03620977f, 0.01405611f, -0.05807763f, 0.03024170f, -0.04142835f, -0.03841439f, -0.05060515f, 
    -0.05145458f, -0.01518132f, 0.03493933f, -0.06327946f, -0.04421678f, 0.01478659f, 0.02037648f, -0.01072371f, 
    -0.00273495f, -0.01123455f, 0.01467139f, 0.03335149f, 0.00683718f, 0.01916181f, 0.04990966f, -0.05565521f, 
    -0.03108183f, -0.01466227f, 0.00772378f, -0.01747779f, -0.02869180f, -0.01368887f, -0.05697814f, 0.02165014f, 
    0.03557988f, 0.00714695f, -0.05442242f, 0.00174492f, 0.02791419f, 0.04849901f, -0.06054511f, -0.00727200f, 
    0.11948495f, -0.24158518f, 0.15772220f, 0.09519121f, -0.19523233f, -0.00048858f, -0.05575226f, -0.01192956f, 
    -0.01285456f, -0.00690585f, 0.05697085f, -0.00902788f, -0.06295147f, -0.04508715f, 0.11344341f, -0.03556585f, 
    0.05880966f, 0.04328652f, 0.08856912f, 0.10021523f, -0.06315537f, 0.07769350f, 0.13643767f, 0.08265713f, 
    -0.24173780f, -0.01254544f, 0.10443887f, 0.02136136f, -0.00951509f, -0.12733930f, -0.09324288f, 0.02386606f, 
    0.08705546f, 0.05320902f, -0.11393892f, 0.07821355f, -0.00993371f, 0.08156710f, -0.09350299f, -0.04853589f, 
    0.45653868f, -0.27878311f, 0.00190537f, 0.03294610f, -0.04310461f, 0.08346406f, -0.12702073f, -0.00010699f, 
    0.11785343f, 0.14065622f, -0.00351389f, 0.04728338f, -0.03971300f, -0.01085628f, -0.10127215f, -0.09015671f, 
    0.02539473f, 0.04672061f, 0.02522350f, -0.00768978f, -0.08442345f, -0.17562069f, 0.03785981f, -0.21863699f, 
    -0.08357872f, 0.00251900f, -0.00834453f, 0.03357724f, -0.04033802f, -0.01838187f, -0.01383254f, -0.06561553f, 
    0.03146654f, 0.05346543f, -0.02440716f, -0.00471985f, 0.06511201f, 0.06873275f, 0.10593763f, -0.02796819f, 
    0.01967789f, 0.25048757f, -0.08951811f, 0.05754643f, -0.01096984f, 0.12995654f, 0.07455923f, 0.11358485f, 
    -0.09367595f, -0.08810880f, 0.02770051f, -0.10292406f, 0.02459673f, 0.04308357f, -0.12173458f, 0.01666963f, 
    -0.00555388f, -0.07124744f, 0.05980411f, -0.02869859f, -0.05462296f, 0.20087555f, -0.06160312f, -0.11404037f, 
    -0.00954820f, 0.03543464f, -0.00626527f, 0.07017937f, -0.10295840f, 0.05209392f, -0.10336093f, -0.05824545f, 
    0.01540840f, 0.02982880f, 0.03101004f, 0.03068768f, -0.03342880f, 0.02506598f, 0.03532364f, -0.01029212f, 
    -0.08668683f, -0.14825240f, 0.20790948f, 0.24492988f, 0.25411129f, -0.18124261f, 0.05472442f, 0.02907578f, 
    -0.00152778f, -0.04254542f, -0.02951652f, -0.01131977f, 0.13816398f, -0.06335316f, 0.02452797f, -0.02836223f, 
    0.02645242f, 0.04127999f, -0.05150666f, 0.04839745f, 0.38075438f, 0.23093821f, -0.12740730f, 0.06207969f, 
    0.02701662f, 0.12757118f, 0.01349867f, -0.03739703f, 0.05568834f, -0.05075452f, 0.01365614f, 0.13031314f, 
    -0.06141725f, 0.12306866f, 0.10018095f, -0.02201520f, 0.00005153f, -0.01760551f, 0.09754566f, 0.01134577f, 
    -0.09353276f, 0.06180843f, 0.02024072f, -0.25556874f, 0.12179424f, -0.04167242f, -0.11136106f, -0.06594563f, 
    -0.04936342f, -0.01766038f, 0.01034915f, -0.05316343f, -0.03377740f, 0.04838858f, 0.05483240f, -0.00493638f, 
    0.06110470f, 0.00126384f, -0.10335577f, 0.08413825f, -0.19735846f, 0.09870897f, 0.12620074f, -0.02615676f, 
    -0.09217133f, -0.14224620f, -0.09253321f, -0.04111065f, -0.08082310f, 0.14133677f, -0.05254164f, 0.06693701f, 
    0.09943859f, -0.03312817f, 0.04132751f, -0.00770221f, 0.05778631f, -0.02671936f, 0.18383698f, 0.00691670f, 
    0.25978202f, 0.05901816f, 0.19090730f, -0.04528840f, 0.31084421f, -0.10248408f, -0.00481999f, -0.05580489f, 
    0.16256511f, 0.01176034f, -0.03627175f, 0.00822167f, 0.10773391f, 0.09307741f, -0.03580713f, 0.02539357f, 
    -0.11033948f, -0.04989506f, -0.03669784f, 0.05784708f, 0.40210214f, -0.10682093f, -0.01109666f, -0.22222422f, 
    -0.01693304f, -0.08801081f, -0.02367707f, -0.11070188f, -0.01922856f, -0.04703500f, 0.08982476f, 0.11978791f, 
    -0.03380470f, 0.00411207f, 0.05493223f, 0.09297343f, 0.06751238f, -0.04328264f, -0.02683210f, -0.00036619f, 
    0.10985768f, 0.38136131f, -0.10461312f, -0.05469677f, 0.07365996f, 0.14617723f, -0.00432369f, 0.01227594f, 
    0.10400387f, 0.04704684f, -0.01767650f, -0.02954440f, -0.07212345f, -0.00152122f, -0.11539406f, 0.08865004f, 
    0.06995720f, -0.01813163f, 0.01082493f, -0.00956871f, -0.41603607f, 0.30518505f, -0.17296714f, 0.34551871f, 
    0.23865211f, 0.14856087f, 0.08471087f, 0.03179269f, -0.00211860f, 0.00613233f, -0.07658426f, -0.04110485f, 
    -0.00472661f, -0.07412527f, 0.00669897f, 0.13017718f, 0.08020840f, -0.01924045f, -0.03067162f, -0.09887615f, 
    0.23260234f, -0.14838210f, -0.03154660f, -0.22969352f, 0.04772941f, -0.09135521f, -0.00634563f, -0.00763795f, 
    0.07625481f, -0.00575086f, 0.04248302f, -0.04987834f, -0.00165162f, 0.08034416f, 0.09442535f, 0.01576896f, 
    0.02890041f, -0.07606231f, -0.06810188f, 0.09186355f, 0.13537689f, -0.14615750f, 0.08045759f, -0.12656547f, 
    -0.13022557f, -0.07683378f, 0.05871615f, 0.06753004f, -0.00464886f, 0.10066735f, 0.02617400f, -0.05573325f, 
    0.04148681f, -0.05481948f, -0.00737184f, 0.05451101f, -0.02752920f, 0.02557504f, 0.01814911f, 0.03411437f, 
    -0.00742048f, -0.04087231f, -0.02680059f, -0.04836957f, -0.05160393f, 0.04578411f, -0.03794132f, 0.00088645f, 
    0.01417182f, 0.00500354f, 0.01178730f, -0.04034974f, 0.01310961f, -0.05446172f, 0.00058795f, -0.00995559f, 
    -0.03368590f, -0.03881583f, -0.03827065f, -0.01751903f, -0.01089957f, -0.06419073f, 0.00426554f, 0.01564107f, 
    -0.02191382f, 0.03952155f, 0.00072544f, -0.06399043f, -0.05062286f, -0.00040950f, -0.04440471f, 0.05007176f, 
    0.03958990f, 0.00372287f, -0.02826090f, -0.00056123f, -0.04938560f, 0.01824054f, 0.04683704f, -0.03161421f, 
    0.00672181f, 0.00676530f, 0.03078683f, 0.01122495f, -0.05337798f, -0.02532629f, -0.00198104f, 0.00224863f, 
    -0.05892766f, -0.05105761f, 0.00041682f, 0.02786732f, -0.00339329f, -0.04610666f, 0.03950716f, 0.05187900f, 
    -0.03198294f, 0.01605763f, 0.04035650f, -0.04972857f, -0.04993015f, -0.03179829f, -0.01552498f, -0.01290016f, 
    -0.01605877f, -0.06320897f, -0.03228101f, 0.00998263f, 0.02709106f, -0.00148697f, 0.03858493f, -0.04371405f, 
    0.03073242f, -0.02808419f, 0.04911456f, -0.02197657f, -0.02217264f, 0.00660662f, 0.02522461f, -0.01604400f, 
    -0.05151827f, 0.02029954f, 0.02014074f, -0.04037756f, -0.01910588f, -0.03603745f, -0.05568772f, -0.03699575f, 
    0.00695520f, -0.05200170f, 0.02056309f, -0.02668209f, -0.06015455f, -0.05528357f, 0.03046196f, 0.04344221f, 
    0.00442044f, -0.01190140f, 0.00985030f, 0.03159286f, 0.00215077f, -0.03253995f, -0.02244917f, 0.01614536f, 
    -0.03908276f, 0.00980654f, 0.01682563f, 0.03989356f, -0.01444558f, 0.01511358f, -0.05240088f, 0.02195522f, 
    0.01845720f, 0.03249640f, 0.04065344f, -0.01336025f, -0.01125669f, -0.00888152f, 0.01590168f, 0.03217421f, 
    -0.01067573f, -0.02934996f, 0.04073270f, -0.02693427f, -0.03267340f, -0.04230141f, 0.01675077f, -0.05456345f, 
    -0.02368174f, -0.04954260f, -0.00218352f, -0.05429967f, 0.01744342f, 0.01941821f, -0.03526906f, -0.05726849f, 
    -0.03577844f, -0.04819183f, 0.02373348f, -0.04510038f, -0.00116940f, 0.03022697f, -0.02275445f, 0.03015629f, 
    0.02954928f, 0.04244545f, 0.02720486f, -0.05516705f, 0.02148286f, -0.06506392f, -0.03687881f, -0.03531338f, 
    0.01701908f, -0.03705034f, -0.02482622f, 0.01517385f, 0.01310683f, 0.04956296f, 0.01571289f, 0.00035153f, 
    0.03222245f, -0.04860006f, 0.01837469f, -0.03540108f, 0.02992317f, -0.00778456f, -0.00431380f, 0.00942789f, 
    -0.04810928f, 0.01424967f, -0.00396927f, -0.01475014f, -0.02583324f, 0.03654001f, -0.02760215f, 0.02579264f, 
    0.04069909f, -0.05593445f, 0.02787875f, -0.05692546f, 0.04424750f, 0.04017996f, -0.00763082f, -0.03160766f, 
    0.00412479f, 0.03204444f, -0.02883003f, 0.04165469f, 0.01474847f, 0.00777801f, 0.03409063f, 0.04774617f, 
    0.01082416f, -0.05732230f, -0.03471347f, -0.00185102f, -0.04690390f, 0.00899497f, -0.00148235f, 0.02202407f, 
    -0.00153075f, -0.00196197f, 0.01220321f, 0.04481077f, 0.04689547f, -0.00106825f, -0.05936157f, 0.03284096f, 
    -0.01692014f, 0.03309848f, 0.04527978f, -0.05307309f, -0.05312140f, -0.04706344f, 0.00123455f, 0.00027842f, 
    -0.05114671f, 0.00739927f, -0.05948058f, 0.01199879f, 0.01145527f, -0.01989217f, -0.03991855f, 0.02830256f, 
    0.00579496f, -0.05698671f, 0.00282577f, 0.01590398f, 0.04036690f, -0.02925718f, -0.00913228f, 0.01133685f, 
    0.00290192f, -0.05919654f, 0.02136030f, -0.02599906f, 0.04695174f, -0.04053094f, 0.01005216f, -0.01256112f, 
    0.02686007f, -0.01810652f, 0.01861289f, -0.04277318f, 0.01277332f, 0.02298523f, 0.04011650f, -0.01797507f, 
    0.03951145f, -0.04010513f, 0.02004058f, -0.03121133f, 0.02790447f, -0.05561052f, -0.03183524f, -0.03406155f, 
    0.04747503f, -0.05360710f, -0.03788410f, 0.04934299f, 0.03595841f, 0.04334733f, 0.01975496f, 0.00432928f, 
    -0.04896836f, -0.00090463f, 0.03120419f, 0.03094508f, 0.04224107f, 0.00511476f, -0.04553068f, -0.01744365f, 
    -0.05909579f, -0.05782406f, -0.01046282f, 0.04181736f, -0.01329813f, 0.00486763f, 0.04833308f, 0.00730490f, 
    0.00695356f, -0.04291679f, 0.04120548f, -0.00142161f, 0.01783343f, -0.05753470f, 0.02378039f, -0.03347735f, 
    0.00921101f, -0.06359418f, 0.04833033f, 0.00645758f, 0.03036908f, -0.05572931f, -0.01212108f, 0.00582079f, 
    0.00662167f, -0.00868046f, 0.00678504f, 0.00944066f, -0.02780539f, -0.03791982f, 0.02618613f, -0.03954824f, 
    -0.04062083f, -0.06509539f, -0.03912171f, -0.05371476f, -0.01486812f, -0.00793799f, 0.04302777f, -0.01326674f, 
    0.04114816f, -0.04245294f, -0.02490836f, 0.04142596f, 0.00546191f, 0.01687501f, 0.04193483f, 0.03619025f, 
    -0.05323771f, -0.00339414f, -0.01392295f, -0.05283263f, 0.03612525f, -0.00173174f, 0.03024728f, 0.01381437f, 
    0.02342340f, -0.02342016f, -0.05074330f, -0.04854019f, -0.00851354f, 0.04352289f, 0.02904843f, -0.03394153f, 
    -0.01176171f, -0.00785643f, -0.00309613f, -0.01738723f, -0.01667686f, 0.03146618f, -0.05640471f, 0.01032134f, 
    0.01830896f, -0.01516239f, 0.00650031f, 0.02980770f, 0.02523939f, -0.02482999f, -0.03774179f, 0.03144436f, 
    -0.00057558f, -0.04548178f, -0.03710962f, -0.04163896f, 0.00534023f, -0.02013662f, -0.00400320f, 0.01220027f, 
    -0.01688286f, 0.03436475f, 0.00030191f, -0.03009023f, -0.00965829f, 0.03831820f, 0.02569295f, 0.04874360f, 
    0.04229216f, 0.02264207f, -0.00191996f, 0.03903544f, -0.00627869f, 0.04100905f, -0.01610032f, -0.01138679f, 
    0.00763074f, -0.03030020f, -0.04959577f, 0.02937976f, -0.00780696f, -0.00653363f, -0.01565229f, 0.04359541f, 
    0.04469918f, -0.03551510f, -0.04592014f, -0.04904464f, -0.03968020f, -0.04315175f, -0.00814407f, 0.03617246f, 
    0.02007963f, 0.00116467f, 0.02847279f, -0.04170486f, 0.02087971f, -0.05741205f, -0.00073401f, 0.01107331f, 
    0.02727394f, -0.02082178f, -0.04071929f, 0.03460196f, 0.01281414f, 0.00988293f, 0.03287752f, -0.01389614f, 
    -0.01533046f, 0.04527083f, -0.04845437f, -0.02591428f, -0.03839650f, -0.02654300f, 0.03563761f, 0.00940013f, 
    0.04295237f, -0.04751897f, -0.06107350f, -0.02194187f, 0.04334032f, 0.01348008f, 0.03750645f, -0.04362575f, 
    -0.01094231f, -0.05411748f, -0.04982414f, -0.04935420f, 0.00829834f, -0.01129001f, -0.04603425f, -0.04928187f, 
    0.04755707f, 0.04150992f, 0.04328571f, -0.01336600f, -0.04112454f, -0.02577469f, -0.05782259f, 0.03135803f, 
    0.04968205f, -0.05104392f, -0.05539759f, -0.04809692f, -0.00994506f, 0.04547236f, 0.01615599f, 0.00942827f, 
    -0.00649519f, -0.01790080f, -0.01405132f, 0.03188134f, 0.04825891f, 0.02989038f, -0.04507143f, -0.02381685f, 
    -0.03216439f, 0.00476220f, -0.02973631f, 0.04019744f, 0.04824883f, -0.05845263f, -0.00509101f, -0.03441413f, 
    -0.01923900f, -0.04921760f, 0.02733711f, -0.03667636f, -0.04999882f, -0.00633250f, -0.01615675f, 0.03180773f, 
    -0.05629500f, -0.03322722f, -0.03722927f, 0.03483288f, 0.01153972f, -0.05109832f, 0.00543088f, -0.01088001f, 
    -0.01407398f, -0.03294664f, -0.01792547f, -0.02914836f, -0.00300469f, -0.04248080f, 0.00945591f, -0.04522445f, 
    0.01657367f, 0.00216714f, -0.04805964f, 0.04206761f, -0.02785135f, 0.03232801f, -0.01116697f, 0.00447856f, 
    -0.05569683f, 0.00183458f, -0.02604766f, -0.00884346f, -0.02077677f, 0.01002615f, -0.04515033f, 0.02170115f, 
    0.04801216f, -0.01702549f, -0.03888806f, 0.01011493f, 0.03554727f, 0.02451194f, -0.00670723f, -0.02734520f, 
    0.04627437f, -0.05653682f, 0.00147477f, -0.04948588f, -0.00894135f, -0.05768083f, 0.03749001f, 0.04658792f, 
    -0.04736903f, -0.04288578f, 0.03611716f, -0.03698911f, -0.02424149f, -0.02275146f, 0.00376557f, -0.04919420f, 
    -0.05122691f, 0.00754244f, -0.04991387f, -0.00531560f, 0.00619702f, 0.01859637f, -0.02067642f, 0.04468168f, 
    -0.01271649f, 0.01150109f, -0.05788725f, 0.03022395f, -0.00020349f, 0.03821677f, -0.01711934f, -0.03911214f, 
    0.02193027f, 0.04331464f, -0.02690749f, -0.01408122f, 0.00801559f, 0.03412609f, -0.03633470f, 0.00517021f, 
    -0.05107015f, 0.04416472f, -0.05652530f, 0.02660106f, -0.05731510f, 0.01354211f, 0.00015061f, -0.04075419f, 
    -0.03737011f, 0.03257145f, 0.00410349f, 0.00282991f, -0.02452324f, -0.03924366f, 0.02827362f, -0.04811710f, 
    -0.00252466f, 0.03560624f, -0.05249132f, -0.05263955f, -0.00316266f, 0.03938831f, 0.00981971f, -0.02881493f, 
    0.00924448f, -0.03623465f, 0.02783191f, -0.01658030f, -0.03194229f, 0.04301709f, 0.02684415f, -0.03639928f, 
    0.02643572f, -0.04388001f, -0.04778648f, 0.01029993f, 0.03036783f, -0.00142354f, -0.02355332f, 0.02539602f, 
    -0.04161555f, 0.02575932f, 0.03899313f, -0.03683621f, -0.02649118f, -0.02143340f, -0.01173165f, -0.03898583f, 
    -0.01803508f, 0.01232629f, -0.01684131f, -0.05539781f, -0.01639974f, -0.01828537f, 0.01082157f, 0.00542336f, 
    -0.01956843f, -0.00005028f, 0.03150874f, 0.04160689f, 0.04278528f, 0.03868044f, 0.01404848f, -0.04341744f, 
    -0.05536922f, 0.01048910f, -0.02311283f, 0.03310011f, -0.04440455f, -0.01989515f, -0.04752481f, -0.03486598f, 
    -0.02482983f, 0.03591927f, -0.00694621f, -0.00179426f, -0.01880436f, -0.02685224f, 0.03661081f, -0.04990466f, 
    -0.00325846f, -0.00740114f, -0.01498373f, -0.05458935f, 0.02009205f, -0.04348549f, 0.00541194f, -0.03417838f, 
    -0.15080790f, -0.31632605f, -0.01219991f, 0.16831440f, 0.12589376f, -0.07296947f, 0.09523620f, -0.01014671f, 
    0.13825347f, 0.05465273f, 0.01844144f, 0.02229005f, 0.07390404f, 0.08714860f, 0.13492464f, -0.04819795f, 
    0.01201415f, 0.13121350f, -0.05857244f, 0.00808907f, 0.30218554f, 0.18412216f, -0.07949799f, -0.22500356f, 
    -0.02760093f, 0.16017337f, 0.05042000f, 0.16223279f, 0.00888678f, -0.05493765f, 0.03821638f, -0.04668672f, 
    0.01705260f, 0.03130065f, -0.02238769f, 0.06803646f, -0.07809521f, 0.15394565f, -0.03425109f, 0.02088758f, 
    -0.10825026f, -0.08616813f, 0.05739089f, -0.10792609f, 0.33529821f, -0.00918391f, -0.02611413f, 0.04893856f, 
    0.11626277f, 0.03507807f, 0.06857283f, -0.05816150f, 0.12455003f, -0.01064624f, 0.02054690f, 0.02796338f, 
    -0.02159055f, -0.00576677f, -0.02539736f, 0.08858342f, -0.16444823f, -0.18006864f, -0.07979364f, -0.30664763f, 
    0.09059219f, 0.09498730f, -0.16083694f, 0.04036513f, -0.09637671f, -0.08025951f, -0.04493425f, -0.04516783f, 
    0.03321022f, 0.05683677f, -0.02571935f, -0.07334142f, -0.01555130f, -0.08339689f, -0.01607564f, -0.01327757f, 
    -0.16102143f, -0.10080562f, 0.19210455f, -0.02449404f, 0.15488151f, 0.03286763f, -0.02293787f, 0.11556134f, 
    0.04605092f, 0.12329410f, 0.06475003f, 0.08552191f, 0.00858823f, 0.02887357f, 0.10529605f, 0.09384072f, 
    0.04269329f, 0.08630064f, -0.05048051f, -0.04935060f, 0.13490526f, 0.10338704f, -0.08727410f, -0.10060998f, 
    0.02130929f, -0.02214554f, 0.07475284f, 0.03624905f, 0.02974305f, 0.13521236f, -0.01249582f, -0.01640601f, 
    -0.08703760f, -0.08747145f, -0.02302963f, 0.06575873f, 0.03567908f, -0.05459116f, 0.07398359f, 0.07741759f, 
    -0.05901114f, -0.02071858f, -0.18093081f, 0.15824755f, -0.11389562f, -0.05457053f, -0.04734440f, 0.02087284f, 
    0.01489239f, 0.11647318f, 0.03453713f, 0.07413952f, 0.05424045f, 0.04039459f, 0.10941416f, 0.10579749f, 
    -0.00713183f, 0.07656964f, -0.04938143f, 0.02792050f, 0.10176473f, -0.09720919f, -0.04653215f, 0.13200617f, 
    -0.00471334f, -0.18379670f, 0.11077289f, -0.08536560f, 0.08444027f, -0.04982424f, 0.13145024f, 0.11439706f, 
    0.00724200f, 0.12968811f, 0.15267453f, 0.06914338f, -0.01017334f, 0.00333170f, 0.00883145f, 0.03409535f, 
    0.13632180f, -0.07707056f, -0.03390085f, -0.11189493f, 0.03615128f, -0.25906166f, 0.09103116f, -0.05222771f, 
    -0.18093225f, -0.11212967f, 0.05708520f, -0.02033576f, -0.13043511f, 0.16422571f, -0.04788961f, 0.07102895f, 
    0.06164768f, -0.03036445f, -0.10470091f, 0.05542904f, 0.18205729f, -0.22851340f, -0.11410314f, -0.22750734f, 
    0.03164825f, 0.01557935f, 0.05792926f, 0.11740511f, -0.05162861f, 0.00156764f, 0.05880509f, -0.03825698f, 
    0.06094403f, 0.13302867f, 0.02026727f, -0.10929076f, 0.04386558f, -0.01796951f, -0.00140988f, -0.10205939f, 
    -0.32769373f, -0.22573023f, -0.19162941f, 0.05208886f, 0.04616877f, 0.01516857f, 0.09713219f, 0.08474798f, 
    0.04257583f, 0.06951316f, -0.11683878f, -0.19001408f, 0.08062250f, -0.03499507f, -0.04926662f, -0.11784425f, 
    0.04409229f, 0.02422281f, 0.00455524f, -0.06504847f, 0.22661863f, -0.27053183f, -0.00861581f, -0.14869942f, 
    0.06751768f, -0.09307388f, -0.01878097f, 0.05492178f, 0.04879771f, -0.08984849f, -0.00101851f, 0.04876581f, 
    0.00334795f, 0.13662925f, -0.10582931f, 0.02219896f, 0.05481760f, 0.07549103f, -0.11908597f, 0.06783701f, 
    0.01467271f, -0.06381961f, -0.07065295f, 0.25555825f, 0.17684186f, 0.00654431f, 0.02939340f, -0.07080726f, 
    0.08069518f, -0.10999908f, 0.00278304f, 0.05985235f, -0.05923468f, 0.03384124f, 0.08020839f, 0.04733752f, 
    0.11622173f, 0.10819133f, 0.09462143f, -0.02734953f, 0.01833395f, 0.36339056f, 0.18000908f, -0.19008897f, 
    -0.34866109f, 0.10205672f, -0.07427280f, -0.01134350f, 0.04663279f, 0.01238815f, 0.11965831f, 0.05650738f, 
    0.03838917f, 0.05886065f, 0.07566278f, 0.05092639f, -0.04110693f, 0.06434575f, 0.02010735f, 0.01299669f, 
    0.04637578f, 0.02777719f, -0.12873784f, -0.19311990f, -0.03810545f, -0.05385838f, -0.07255016f, 0.04422167f, 
    0.02049478f, -0.18282799f, -0.00292214f, 0.07276800f, -0.02443769f, -0.11381470f, -0.01375387f, 0.04733999f, 
    0.00873847f, -0.03908245f, 0.08224352f, 0.03159840f, -0.22053473f, 0.11355966f, -0.07315210f, -0.03370602f, 
    0.02485256f, 0.00216682f, 0.00831386f, 0.01213973f, -0.01894767f, 0.01388649f, 0.14233288f, 0.07721107f, 
    0.03850213f, 0.06076514f, -0.16521974f, 0.08289854f, 0.16436182f, -0.09027936f, 0.07999557f, -0.03032305f, 
    -0.18469246f, -0.00416380f, 0.17176186f, 0.00691656f, 0.09047299f, 0.04806145f, -0.01438976f, -0.04483758f, 
    0.04911425f, -0.08037849f, -0.01878714f, -0.09607955f, 0.05085004f, -0.02724288f, -0.00555287f, 0.04319142f, 
    -0.04503774f, -0.08456311f, -0.00722307f, 0.01093966f, -0.16645357f, -0.16308446f, -0.05294057f, 0.19474052f, 
    0.16921721f, -0.02935112f, 0.02103693f, -0.08667790f, -0.13773596f, 0.00892234f, 0.12427627f, -0.04267780f, 
    0.00707467f, 0.01582209f, 0.14948890f, -0.11165825f, -0.01557565f, 0.22421536f, -0.13273679f, -0.10716269f, 
    0.35090825f, 0.29858497f, 0.18874486f, -0.04231228f, -0.12244033f, -0.04080694f, -0.02565961f, 0.05501017f, 
    0.00839481f, -0.02111462f, 0.07684039f, 0.14889807f, -0.01726728f, 0.00985811f, 0.07386534f, -0.14324227f, 
    0.09861316f, 0.03111234f, -0.04009500f, -0.04747042f, -0.18005694f, 0.07034231f, 0.08248910f, 0.03817641f, 
    0.20388053f, 0.14418836f, 0.15510805f, 0.03738647f, 0.14295511f, -0.06258054f, -0.16281797f, 0.05026518f, 
    -0.06830617f, -0.07307740f, -0.06333070f, -0.05922467f, 0.01130961f, 0.13652267f, -0.01698705f, 0.03532258f, 
    -0.08243829f, -0.11777371f, 0.01356424f, 0.20005026f, 0.02515140f, -0.00574949f, -0.18332641f, 0.09078760f, 
    -0.01653215f, 0.02403008f, -0.00145461f, 0.05888742f, 0.04046309f, 0.01657345f, 0.06048451f, -0.12758517f, 
    0.03234361f, -0.03183635f, 0.20694576f, -0.10798160f, -0.04046345f, 0.03894447f, 0.06081628f, 0.17009458f, 
    0.05433793f, 0.12432021f, 0.04505866f, -0.15123412f, -0.09410752f, 0.05430164f, 0.07770772f, 0.06563223f, 
    -0.03257796f, -0.10071117f, -0.08689193f, 0.02628036f, -0.04719026f, -0.04207029f, 0.04788581f, 0.03298778f, 
    -0.28644323f, 0.21059728f, 0.07640104f, 0.20542590f, 0.10389326f, -0.15371007f, 0.03951275f, -0.02355341f, 
    0.05133812f, -0.00605637f, 0.01029495f, 0.13167985f, -0.07954349f, 0.07162514f, 0.01833957f, -0.01770206f, 
    -0.20515925f, 0.06617230f, -0.11334462f, -0.07967473f, 0.60087204f, 0.37879243f, 0.14531976f, 0.17941821f, 
    -0.31529954f, -0.12324157f, -0.04347693f, 0.11650166f, 0.05456774f, -0.02238590f, -0.03891358f, -0.01280619f, 
    0.13740295f, 0.06373408f, 0.00960493f, -0.10583496f, -0.00318520f, 0.05722514f, -0.03532268f, -0.05067361f, 
    -0.05872854f, -0.01926099f, 0.25709057f, -0.29273298f, 0.00003440f, 0.04900371f, 0.10398035f, -0.11098521f, 
    0.07490985f, 0.04193421f, -0.01399430f, -0.00574068f, -0.06419287f, 0.02349317f, 0.22352572f, -0.05997467f, 
    0.02216702f, -0.00699333f, 0.05080250f, -0.07322459f, 0.35494405f, -0.01235446f, -0.23466244f, 0.11795359f, 
    -0.19768268f, 0.06709760f, 0.10776225f, -0.07537358f, 0.09386534f, 0.01330432f, -0.07391782f, 0.18095805f, 
    -0.00519638f, -0.00660551f, -0.01896970f, 0.01781660f, -0.07279380f, 0.11657651f, -0.08632687f, -0.11389813f, 
    0.07377241f, 0.14871082f, 0.06205998f, -0.04601018f, -0.03066596f, -0.14450873f, 0.00484378f, 0.00062073f, 
    0.01415714f, -0.01841914f, -0.02237291f, 0.05084873f, 0.02835122f, -0.09451391f, -0.03397416f, 0.01796890f, 
    -0.04016493f, -0.04633217f, -0.03761962f, 0.08053653f, -0.50927401f, 0.06401597f, 0.15965249f, -0.03937061f, 
    0.13863841f, -0.09510847f, 0.13527687f, -0.01043807f, 0.14164262f, -0.13226193f, 0.05925313f, -0.05198686f, 
    -0.00459879f, 0.03778246f, 0.01821323f, -0.03897676f, 0.11171026f, 0.06144735f, 0.11511826f, 0.11733606f, 
    -0.11918414f, 0.19377413f, 0.22705969f, 0.18665268f, -0.23590703f, 0.15181461f, -0.02876634f, 0.08002331f, 
    0.01640667f, -0.04220646f, 0.00836191f, 0.08570717f, -0.09491944f, 0.08260138f, -0.04909150f, -0.06691418f, 
    -0.04192967f, -0.02005590f, 0.05044070f, 0.00996729f, 0.03481860f, -0.05405485f, 0.08269609f, 0.29830879f, 
    0.26533386f, -0.04259822f, 0.02608092f, -0.03806824f, 0.00454949f, -0.03673365f, 0.05224465f, 0.05688829f, 
    0.03428702f, -0.05538407f, 0.07483977f, 0.01305792f, 0.02152047f, 0.20271313f, 0.14604837f, 0.03261426f, 
    -0.53504884f, 0.26421911f, 0.06734091f, -0.06322697f, 0.19382142f, -0.06510850f, -0.16051847f, -0.03142487f, 
    0.05307561f, -0.09593969f, 0.09131885f, 0.16460098f, -0.06738777f, 0.02599150f, 0.09218033f, -0.15417291f, 
    -0.06815679f, -0.01396431f, -0.04170690f, -0.11493825f, 0.00999437f, 0.29308689f, 0.05683706f, 0.26539415f, 
    -0.06515973f, -0.09695943f, -0.05258956f, -0.00841955f, -0.03335940f, -0.09705053f, 0.06722518f, -0.07568119f, 
    0.02249581f, -0.01588715f, -0.19384289f, 0.04938239f, 0.08808867f, -0.01009803f, 0.07414118f, 0.07892764f, 
    -0.20659897f, 0.00941233f, -0.18861979f, -0.07450269f, 0.08213589f, -0.06966433f, 0.16952550f, 0.08243814f, 
    0.11436284f, 0.08693153f, -0.01979235f, 0.05540669f, -0.06040958f, 0.08540926f, -0.00582169f, 0.05572269f, 
    0.07971666f, 0.09884057f, -0.06347743f, -0.00037686f, -0.06354561f, -0.03628970f, -0.01429320f, -0.07295155f, 
    0.06634371f, 0.12471583f, -0.01312064f, 0.06858119f, 0.12039815f, 0.04828261f, -0.04853094f, 0.02853077f, 
    0.03634857f, 0.05441352f, 0.04201769f, -0.00772065f, -0.07239579f, 0.05706745f, 0.00999410f, 0.16035613f, 
    0.05007287f, 0.05308945f, -0.16967709f, -0.04649470f, 0.02517042f, 0.08777612f, 0.13747932f, 0.05157968f, 
    -0.13774532f, -0.03527677f, -0.01294116f, -0.00965888f, 0.02179044f, -0.08523010f, -0.07837583f, 0.09261935f, 
    -0.08055750f, 0.04125622f, -0.02780667f, 0.21882658f, -0.08056554f, -0.05965781f, 0.23858555f, 0.01544985f, 
    0.17238398f, -0.07457059f, -0.09931579f, -0.05967870f, -0.00201876f, 0.06925308f, 0.18047772f, 0.04014382f, 
    0.02187543f, 0.09369978f, -0.03473534f, -0.09500615f, -0.04631724f, -0.26306352f, 0.05847551f, -0.13094229f, 
    -0.16378258f, 0.02699117f, -0.01718562f, -0.23020887f, 0.11662993f, -0.02069113f, 0.01880472f, -0.08225917f, 
    -0.07070137f, 0.04752266f, 0.03341341f, 0.01862155f, -0.04774310f, -0.01891788f, -0.07572348f, -0.04794675f, 
    0.00990239f, 0.06999145f, -0.19963531f, -0.04086481f, -0.00341804f, -0.09318037f, -0.04168009f, -0.01901270f, 
    0.16175334f, -0.05194122f, 0.05741572f, -0.01179418f, 0.03299008f, -0.05703546f, -0.03637623f, -0.07207350f, 
    0.07117289f, 0.03861068f, 0.06170696f, -0.04159979f, -0.00709146f, -0.05108387f, 0.03193472f, 0.03370841f, 
    0.15261540f, 0.03025180f, 0.05264884f, -0.23531948f, 0.08887199f, -0.02379447f, -0.00735932f, 0.01385762f, 
    -0.08569990f, 0.02856160f, 0.08077682f, -0.06881804f, 0.03233491f, -0.02161648f, -0.00225272f, -0.05452126f, 
    0.15367503f, -0.02927050f, -0.02572052f, 0.04713286f, -0.44147122f, -0.18273728f, -0.12681584f, 0.01531455f, 
    0.11316757f, 0.04650351f, 0.01401118f, -0.01371678f, -0.01111818f, -0.01473946f, 0.05100439f, 0.09572542f, 
    0.05835985f, -0.05127341f, -0.05857938f, 0.10289036f, -0.02655880f, -0.06776850f, -0.02457333f, 0.06079057f, 
    0.15015732f, 0.28114566f, 0.03804714f, 0.05762876f, 0.02288015f, 0.08440059f, 0.10861415f, 0.15058053f, 
    0.08061963f, -0.00336517f, 0.15878111f, -0.05472389f, 0.04645087f, 0.03380018f, -0.11525045f, 0.00289799f, 
    0.09775131f, 0.04710531f, 0.00702472f, 0.01933946f, 0.16859311f, 0.04570107f, 0.12313077f, -0.15731606f, 
    0.35331252f, -0.06994124f, -0.08322829f, 0.18430398f, -0.00845177f, -0.02915597f, 0.04655015f, -0.12480924f, 
    -0.02844494f, -0.00137236f, -0.06525665f, -0.15312713f, 0.00812270f, 0.04471461f, 0.07796425f, -0.07823973f, 
    0.12582777f, -0.13974848f, 0.14927422f, 0.06193502f, -0.04781865f, 0.02853816f, 0.02620215f, -0.10743307f, 
    0.01193125f, 0.08262948f, 0.13061312f, -0.04760207f, -0.07527581f, 0.04700097f, -0.04439555f, 0.00878533f, 
    0.05900680f, 0.03651812f, -0.00270200f, -0.15952751f, 0.04018298f, -0.04984462f, -0.04161049f, 0.06220058f, 
    -0.07639325f, 0.02992379f, 0.10712443f, 0.05008585f, -0.05793384f, -0.02533469f, 0.07274058f, 0.10421277f, 
    0.11507431f, 0.07394558f, -0.05074638f, 0.08218174f, 0.07226763f, 0.06359275f, -0.05566833f, -0.02304469f, 
    -0.35332742f, -0.08567066f, 0.00602738f, 0.00132171f, 0.09706114f, 0.02952929f, -0.02475278f, 0.00351168f, 
    -0.09265105f, 0.05567249f, -0.03860853f, 0.04070187f, 0.02929699f, -0.05943987f, 0.08733524f, 0.05112083f, 
    0.11788523f, -0.01692219f, -0.09497822f, -0.06322093f, 0.18725307f, 0.18323742f, -0.01381275f, 0.02001622f, 
    -0.10395932f, 0.05998957f, -0.18103822f, -0.02782449f, -0.10035886f, -0.01579069f, 0.06738217f, 0.02431510f, 
    0.07083002f, 0.13107154f, 0.01226638f, 0.05470274f, -0.08569229f, -0.23459759f, -0.07355505f, 0.07053974f, 
    0.47840750f, -0.16087492f, 0.14443313f, 0.03032208f, 0.04668373f, 0.13483305f, 0.13323353f, 0.03132391f, 
    0.02970647f, 0.11162473f, -0.14592519f, 0.01209195f, -0.07107376f, 0.02355587f, -0.11705083f, 0.06374688f, 
    0.08082337f, 0.00027769f, 0.08670333f, 0.09399483f, 0.14568700f, -0.15161267f, -0.18662594f, -0.03110554f, 
    0.28469524f, 0.07235566f, -0.01164012f, 0.03937001f, 0.12053391f, -0.03843440f, -0.13756311f, 0.13846809f, 
    -0.02477777f, -0.03611547f, 0.08240633f, -0.00609913f, 0.07633468f, 0.02334503f, 0.06091126f, -0.02447362f, 
    -0.21459375f, -0.11001574f, -0.11500459f, 0.02938603f, -0.08291947f, 0.12835799f, 0.02971920f, 0.05545603f, 
    0.10682756f, 0.03767828f, -0.08645466f, -0.04128528f, -0.03826750f, 0.06098023f, 0.06700943f, 0.05723303f, 
    -0.01736856f, -0.02377623f, 0.01032119f, -0.04686594f, -0.17999338f, 0.00485809f, -0.10044371f, 0.17260110f, 
    0.25988886f, 0.12964427f, 0.03582680f, -0.04318766f, 0.05919242f, 0.04228193f, 0.12064312f, -0.06347437f, 
    -0.08299916f, 0.19430363f, 0.12006933f, -0.06212564f, -0.06793510f, 0.17376222f, -0.20892066f, -0.09929541f, 
    0.28971934f, 0.11208246f, 0.14660549f, -0.19149506f, -0.16870737f, -0.08916026f, 0.09308609f, -0.00863521f, 
    0.00194280f, -0.04650536f, -0.03160362f, 0.05722370f, -0.07118525f, -0.01176486f, 0.05430420f, -0.13873826f, 
    0.11414821f, 0.12426864f, -0.07823696f, 0.09950460f, -0.48244050f, -0.02767802f, -0.08082337f, -0.21021590f, 
    0.15342310f, 0.10603595f, -0.00381132f, -0.02708743f, -0.07816594f, 0.09199120f, -0.13048230f, 0.02233755f, 
    -0.01093860f, -0.02799291f, -0.05118560f, -0.03874685f, -0.00137495f, -0.02183896f, 0.14048029f, 0.02332865f, 
    -0.16487505f, 0.06682522f, 0.09391224f, -0.06470384f, -0.08826273f, -0.01307002f, -0.14401880f, 0.16620702f, 
    0.00160414f, -0.02471147f, 0.02918492f, -0.04588320f, -0.02199088f, -0.00726274f, 0.00708005f, -0.09625340f, 
    -0.02753362f, 0.01873972f, 0.01709798f, -0.03816864f, 0.16599795f, 0.03675221f, 0.03917137f, 0.08994478f, 
    0.03354450f, -0.02960323f, 0.14460139f, 0.04113749f, -0.00191817f, 0.08077899f, 0.00376599f, -0.10252482f, 
    -0.00075661f, -0.00582238f, 0.12915128f, 0.08514893f, 0.06696586f, -0.01378071f, 0.07952460f, -0.01584144f, 
    -0.10567911f, 0.17583936f, 0.07455412f, 0.16628137f, 0.34327999f, -0.09099202f, -0.02951522f, -0.00035983f, 
    0.11429608f, 0.05751551f, -0.05809991f, 0.02023717f, -0.03444717f, -0.19468763f, 0.08074453f, -0.14121486f, 
    0.04376514f, -0.18101488f, -0.00818670f, 0.04880437f, 0.38600174f, 0.15317333f, -0.06176849f, 0.12997518f, 
    -0.14667477f, -0.04281193f, 0.11107846f, -0.10282244f, 0.09518342f, 0.00355520f, -0.03732923f, -0.01007558f, 
    0.02142852f, 0.00697750f, 0.03191314f, -0.11009026f, 0.05883895f, -0.00200694f, -0.04645726f, 0.06999199f, 
    -0.12541403f, 0.05125225f, 0.00838496f, -0.37393004f, 0.10057119f, -0.02967539f, 0.20236880f, -0.10813119f, 
    0.05961661f, -0.07241636f, 0.08113470f, 0.03701225f, 0.08428134f, 0.08618798f, 0.11990763f, 0.04620387f, 
    0.04486826f, -0.00837039f, -0.07878436f, 0.03050575f, -0.03170378f, -0.12555058f, -0.30332014f, -0.08078575f, 
    -0.05671160f, 0.06121440f, 0.02129364f, -0.00207238f, 0.03110075f, 0.13088889f, 0.07099388f, 0.06225152f, 
    0.05060973f, -0.01968116f, -0.13517416f, -0.11235724f, -0.02703698f, -0.05763213f, 0.08214863f, 0.05929036f, 
    0.18492664f, -0.10221066f, 0.21608889f, 0.14722896f, 0.02945799f, -0.02456963f, -0.01043043f, -0.11745261f, 
    0.03690274f, 0.13300207f, 0.02514026f, 0.03704400f, 0.05371968f, 0.10894607f, 0.05858894f, 0.05642145f, 
    -0.07199211f, -0.05848451f, 0.00651135f, 0.02244396f, -0.50686175f, -0.14547062f, -0.25502750f, -0.08524508f, 
    -0.02125012f, 0.05305718f, 0.09400422f, 0.03889570f, 0.00351648f, 0.04885734f, -0.00494334f, 0.11228743f, 
    0.10930911f, 0.05178253f, 0.09007348f, 0.02619511f, 0.05432438f, 0.01340044f, 0.04690680f, 0.09588998f, 
    -0.29823950f, 0.20351268f, 0.30793142f, 0.23398174f, -0.07022826f, 0.10881018f, 0.02840179f, 0.18371814f, 
    -0.00750659f, -0.04111111f, 0.04310789f, 0.03394769f, -0.08494075f, 0.02937147f, -0.14598605f, -0.02011696f, 
    0.11597461f, -0.18805155f, 0.10081266f, -0.04506038f, 0.04670307f, 0.14171904f, 0.20497985f, 0.40015602f, 
    0.05571920f, -0.02279660f, 0.01257777f, 0.03480439f, 0.04419030f, 0.06601186f, 0.01461844f, -0.04166748f, 
    0.05632052f, -0.00903153f, 0.14042540f, 0.04428619f, -0.03793297f, 0.05127031f, 0.07630914f, 0.15080094f, 
    -0.33370984f, 0.07564852f, -0.18455796f, 0.01652530f, 0.09042941f, 0.14748637f, 0.04097176f, -0.11528617f, 
    -0.00994206f, -0.06122459f, -0.00457405f, 0.05932359f, -0.01378271f, -0.01425575f, 0.04890656f, -0.08836539f, 
    0.05050266f, 0.02209571f, -0.01272152f, 0.01708973f, 0.10482368f, -0.00985841f, -0.18523102f, 0.10350885f, 
    0.11884327f, -0.00220598f, -0.05325196f, 0.02582317f, -0.02476960f, -0.02157961f, 0.06498329f, -0.07562463f, 
    0.11184212f, 0.02581869f, -0.03324147f, 0.07399124f, 0.09478689f, 0.04961433f, 0.03657754f, 0.01210279f, 
    -0.05399565f, -0.06593531f, 0.02700533f, -0.04837738f, -0.03206609f, -0.06144320f, 0.00209636f, -0.05504589f, 
    -0.03030232f, -0.04278896f, -0.05933447f, -0.03679872f, -0.05821498f, -0.03790979f, -0.05497484f, -0.04148844f, 
    -0.00411199f, -0.04757719f, -0.05070089f, -0.03127248f, 0.04360980f, 0.03518114f, 0.04123596f, -0.00608283f, 
    -0.05210030f, 0.00157911f, 0.05234440f, -0.03566418f, 0.03276633f, 0.01323236f, -0.00374031f, -0.01753775f, 
    0.01703448f, 0.00618143f, 0.00540873f, 0.01900431f, -0.02458237f, -0.00207196f, 0.02995013f, 0.01659311f, 
    -0.02881785f, -0.03618591f, -0.04963508f, -0.05414205f, -0.03354441f, -0.02613135f, 0.02335380f, -0.00087395f, 
    0.03255131f, 0.00094503f, -0.04685675f, -0.01144953f, 0.03453669f, 0.01994942f, 0.03129930f, -0.03121595f, 
    0.04747383f, 0.02740146f, 0.02129338f, -0.04397544f, 0.01128598f, 0.05185096f, -0.04116653f, -0.03382308f, 
    0.01205939f, 0.04825489f, -0.03901934f, 0.02375284f, -0.04411364f, 0.00726804f, 0.05154631f, 0.03103334f, 
    -0.00725894f, 0.03247412f, -0.00667437f, -0.00823806f, -0.05767321f, -0.01904556f, -0.02819933f, 0.02729057f, 
    -0.02197679f, 0.00654509f, 0.00631506f, 0.06002421f, -0.01921948f, -0.06060031f, -0.01594466f, -0.01372977f, 
    -0.01985778f, 0.03739588f, -0.03555800f, -0.05908774f, 0.03653196f, -0.05533941f, 0.00686916f, 0.04402664f, 
    -0.05061188f, -0.06167443f, -0.02014250f, 0.05104709f, -0.02909056f, -0.02540206f, -0.01382090f, 0.03046612f, 
    -0.03937246f, 0.03874896f, 0.04913846f, -0.01284330f, -0.02514317f, -0.05262407f, 0.02533782f, 0.00958227f, 
    0.00356744f, -0.03786574f, 0.03842415f, 0.01016291f, 0.02206647f, 0.01260497f, 0.01437795f, 0.00421450f, 
    0.04174354f, 0.00184223f, -0.03799875f, 0.01427668f, 0.00112049f, -0.05648717f, -0.05754377f, -0.01674270f, 
    -0.04990052f, -0.03743580f, -0.04754087f, 0.05858958f, -0.01004907f, -0.04717207f, -0.02436898f, 0.02625283f, 
    0.01188397f, -0.00796633f, 0.01889356f, 0.04097079f, 0.00532617f, -0.04617998f, -0.02049368f, -0.05597568f, 
    0.03307830f, 0.02865601f, 0.00621512f, -0.03430969f, -0.03160432f, -0.03647789f, -0.04444997f, 0.05302574f, 
    0.04774075f, 0.02758900f, 0.00251913f, 0.03471745f, 0.02663356f, 0.04522766f, -0.00145362f, 0.04057548f, 
    -0.01390592f, 0.01623581f, -0.03836996f, 0.01214206f, 0.03871343f, -0.05684673f, 0.03803655f, 0.00970052f, 
    0.05167812f, -0.00311938f, 0.00839919f, -0.04852740f, 0.00715256f, -0.05031914f, -0.05334312f, -0.00676278f, 
    0.02053259f, 0.00209239f, -0.05234607f, 0.03365327f, -0.03840536f, 0.03848999f, 0.03269872f, 0.02270430f, 
    -0.00686042f, 0.05068212f, 0.00581707f, 0.00093021f, 0.00117287f, 0.04527845f, -0.03567377f, -0.04082086f, 
    -0.04897599f, -0.04530074f, -0.04636301f, -0.04013484f, 0.02310851f, -0.01673787f, 0.01248777f, -0.02432415f, 
    0.02010254f, -0.05846168f, 0.04819776f, -0.01345342f, 0.00501938f, -0.03995982f, -0.02782172f, -0.03456461f, 
    0.01422802f, -0.03378753f, -0.04641523f, -0.05420793f, -0.02678670f, 0.02610843f, -0.05021774f, 0.03030560f, 
    -0.05627080f, -0.01074125f, 0.03978322f, 0.00139724f, -0.02572292f, -0.04017655f, 0.02642997f, -0.00767196f, 
    0.00009340f, -0.00186870f, -0.03463937f, 0.02040732f, -0.02356492f, -0.04150008f, 0.05605276f, -0.00584832f, 
    -0.00179724f, 0.01427207f, -0.04033856f, 0.01467745f, -0.04013851f, -0.01653080f, -0.02492070f, -0.04138830f, 
    -0.00215107f, -0.00071700f, 0.04974106f, 0.04528075f, 0.01088419f, 0.01412685f, -0.00977198f, 0.04122861f, 
    -0.02064866f, -0.03938011f, 0.03119198f, 0.04067264f, -0.04181973f, 0.04713832f, 0.00810288f, -0.00852565f, 
    -0.05189219f, -0.05296862f, -0.01463747f, 0.02539552f, -0.03499430f, -0.02261942f, 0.04951931f, 0.01433933f, 
    -0.03439042f, 0.04048961f, -0.04538838f, 0.04060390f, -0.05555721f, -0.02121917f, 0.01004231f, 0.02824503f, 
    -0.00965092f, -0.01070134f, 0.00326975f, 0.01284650f, -0.04417375f, 0.02050688f, 0.03895611f, -0.01159659f, 
    -0.01850218f, -0.01193428f, 0.03042019f, 0.04841918f, 0.02687942f, -0.02600001f, -0.04725308f, 0.04698696f, 
    0.01090709f, 0.00015130f, 0.04961774f, -0.00018806f, -0.01709400f, -0.04714129f, 0.02675944f, 0.00315051f, 
    0.01198820f, 0.02702118f, 0.00728780f, 0.04019214f, -0.02317117f, -0.00098693f, 0.03401735f, 0.01838718f, 
    -0.03116166f, -0.02583642f, 0.03997225f, 0.04780396f, -0.01222645f, 0.04270232f, 0.01639295f, 0.03346113f, 
    -0.01923599f, -0.01481030f, -0.04138871f, -0.05012237f, 0.00703379f, 0.03126310f, 0.04257054f, -0.03453418f, 
    -0.19038968f, 0.00573324f, -0.11401147f, -0.03027549f, -0.01527523f, 0.04647979f, 0.05345095f, 0.02400998f, 
    0.02738995f, 0.02061376f, -0.11400289f, -0.03921988f, 0.04366919f, 0.09830415f, -0.03177902f, -0.02317768f, 
    0.03570941f, -0.07856406f, -0.15178861f, -0.00500591f, -0.39887947f, -0.09772978f, -0.12793416f, 0.17302920f, 
    0.14371511f, 0.13041389f, 0.09407724f, 0.05977817f, 0.04172695f, 0.06831262f, -0.01383168f, -0.04278637f, 
    -0.15601753f, 0.00513940f, 0.05273736f, -0.10142853f, -0.13383387f, 0.03547503f, -0.02842478f, -0.01355771f, 
    0.12826194f, 0.18053564f, 0.11479810f, -0.12755094f, -0.01078472f, -0.08098723f, 0.07762980f, 0.00500649f, 
    0.00953719f, 0.00521192f, -0.07413751f, -0.04171376f, -0.04516582f, -0.02733174f, -0.03746629f, 0.04637158f, 
    0.04855428f, -0.03548240f, 0.00032143f, 0.11475340f, -0.19039549f, -0.14381242f, 0.05525027f, 0.04489905f, 
    0.01236687f, 0.05923853f, -0.03462218f, -0.02299337f, -0.02668343f, 0.06238675f, 0.03348729f, -0.05611725f, 
    0.13030873f, -0.00245919f, -0.02149997f, 0.07852647f, 0.00810239f, -0.00566472f, 0.05617977f, -0.07025864f, 
    -0.49547675f, 0.23169573f, 0.20423847f, -0.01126140f, 0.20899160f, -0.03226993f, -0.11214180f, 0.06302921f, 
    -0.07704391f, 0.01298200f, -0.02378869f, -0.07649148f, -0.02393445f, 0.00290254f, 0.00890812f, -0.04825352f, 
    0.00566195f, -0.04639062f, -0.06339335f, -0.03133406f, -0.06182500f, -0.08124835f, 0.05284192f, 0.04042183f, 
    -0.00527785f, -0.07958765f, 0.07073264f, 0.05870634f, -0.00083068f, -0.01353300f, 0.05389185f, -0.10556696f, 
    0.00583095f, -0.02610828f, 0.05637507f, 0.04573971f, 0.05982269f, 0.08532155f, 0.15201670f, 0.08063193f, 
    0.09129947f, 0.22381978f, -0.08411959f, 0.01201910f, 0.14745374f, -0.09606873f, -0.15679486f, -0.02683362f, 
    0.03004992f, 0.00444265f, -0.01846762f, -0.04766688f, -0.05228661f, -0.06182953f, -0.04486546f, -0.03621412f, 
    0.07912049f, -0.14522107f, -0.04470038f, -0.00864602f, 0.29469976f, 0.07132186f, -0.16064765f, 0.09569503f, 
    0.06927733f, 0.01679015f, 0.03145752f, -0.07504287f, 0.08376402f, -0.00412617f, 0.02424210f, -0.06767485f, 
    0.03757489f, -0.05735670f, 0.01275470f, -0.01735993f, 0.04985109f, -0.00047471f, 0.04957777f, -0.09949017f, 
    0.07989379f, 0.24810335f, -0.00389446f, -0.07508588f, 0.03286231f, -0.03429103f, -0.02032256f, -0.08928283f, 
    0.14118391f, 0.01934239f, 0.15689185f, -0.05597243f, -0.02916363f, 0.07388549f, 0.06645045f, 0.08626285f, 
    0.02358622f, 0.09965058f, -0.00322322f, 0.05422191f, 0.39683080f, 0.02493789f, -0.22285505f, 0.12212072f, 
    0.14375925f, -0.03511157f, -0.00303529f, 0.09674488f, 0.00086100f, -0.01074740f, 0.08068688f, 0.03102087f, 
    -0.01074343f, 0.07356312f, -0.02474587f, -0.05179464f, -0.09302536f, 0.11921432f, 0.01959332f, -0.10489691f, 
    0.00719640f, -0.16432872f, 0.03676030f, -0.01342916f, -0.18097199f, 0.00671378f, 0.07953269f, -0.03429746f, 
    0.01102937f, 0.17632520f, -0.08842814f, 0.07891639f, -0.04989298f, 0.03041185f, -0.09490070f, 0.12143549f, 
    0.07965434f, -0.12027495f, -0.09579451f, 0.06662659f, -0.34473380f, -0.18694930f, -0.22851688f, 0.02481165f, 
    -0.16952775f, 0.05294991f, 0.07837249f, 0.07534755f, 0.01723825f, 0.03701618f, -0.06459008f, 0.13613686f, 
    0.11560574f, 0.16256273f, 0.02281286f, -0.06976823f, 0.10232209f, 0.11185552f, -0.03505652f, 0.07416255f, 
    -0.11636773f, 0.03449046f, 0.29811507f, -0.00873256f, 0.09472925f, 0.01498836f, 0.00242635f, 0.15486038f, 
    0.03302007f, -0.01840872f, -0.07776194f, 0.04309059f, -0.07531866f, 0.03410294f, 0.01668142f, 0.02400035f, 
    0.00240110f, 0.01507260f, -0.02202191f, 0.01330876f, 0.34947184f, -0.11202087f, -0.14213972f, 0.28692764f, 
    0.26368064f, -0.06871440f, -0.02166873f, 0.11696956f, 0.06328438f, 0.10734671f, 0.13072395f, 0.02706313f, 
    0.02859830f, -0.02186627f, -0.01388715f, 0.11349575f, -0.04688532f, 0.01637656f, 0.10984645f, 0.16948152f, 
    0.11627159f, 0.20211424f, -0.02339776f, 0.19776183f, -0.07264376f, 0.17148317f, 0.04288062f, -0.09833438f, 
    -0.02932730f, 0.01194787f, -0.12043174f, 0.12353920f, 0.02640423f, 0.07918890f, -0.03485979f, -0.02594440f, 
    -0.06426572f, 0.09217190f, -0.09164869f, 0.08638109f, 0.11952805f, 0.17543916f, -0.01769423f, 0.09373135f, 
    0.20450354f, 0.00861981f, -0.10512879f, 0.04919829f, -0.02880311f, -0.07116073f, -0.07156938f, 0.10003702f, 
    0.02039935f, 0.02563854f, 0.04531910f, 0.04850909f, 0.07668304f, 0.15793552f, 0.13086773f, 0.05209691f, 
    0.47655544f, -0.28483009f, -0.09123091f, -0.05136213f, 0.23327048f, -0.00822846f, 0.00853932f, -0.00864210f, 
    0.02302098f, 0.00268772f, -0.02271206f, 0.07159249f, 0.12957814f, 0.08366565f, 0.13734011f, -0.11106214f, 
    -0.01633072f, -0.02146024f, -0.02166310f, -0.02497683f, 0.28367016f, 0.28149095f, 0.13226245f, -0.10153525f, 
    -0.05979082f, 0.13056949f, 0.16189919f, 0.00821416f, -0.14145958f, 0.04179753f, -0.16221988f, -0.03097787f, 
    -0.03133968f, -0.18574725f, -0.16055386f, -0.10974026f, -0.16129105f, -0.01086614f, 0.13534397f, 0.02190117f, 
    0.29932007f, 0.14979532f, -0.22747225f, -0.12264892f, 0.27064660f, 0.08579966f, -0.05384207f, 0.07460828f, 
    0.16653791f, 0.10783546f, 0.00031644f, -0.04650698f, 0.11413366f, 0.07951199f, -0.10155603f, 0.11174086f, 
    0.06809968f, -0.06214735f, -0.05168797f, 0.13667712f, 0.25147814f, -0.31010589f, 0.21019983f, 0.07156442f, 
    0.04859450f, 0.03016510f, -0.18321982f, -0.01191892f, 0.00486016f, 0.01876688f, 0.01899490f, -0.06645044f, 
    0.08814600f, -0.03148464f, 0.06107712f, -0.00264523f, -0.06664010f, -0.03263025f, -0.03592321f, 0.04596493f, 
    -0.18394695f, -0.00778868f, 0.17841548f, -0.05094397f, 0.12125173f, 0.04671843f, -0.00893039f, 0.08705474f, 
    -0.03097168f, 0.03746810f, -0.08492144f, -0.05317171f, -0.00369543f, -0.00433201f, -0.01870080f, 0.14050587f, 
    0.04696947f, -0.09686312f, -0.05323122f, -0.10504322f, -0.06674928f, 0.10070062f, -0.03635252f, -0.08428637f, 
    -0.01876433f, -0.11570635f, 0.11610917f, -0.00409703f, 0.01983956f, -0.03615819f, -0.05397904f, -0.04193697f, 
    -0.03733671f, -0.13578078f, 0.04255268f, 0.05092679f, 0.07390246f, 0.18080182f, 0.24834128f, 0.03417789f, 
    -0.36663628f, -0.06634078f, -0.29286152f, -0.19719161f, -0.22032394f, 0.07552066f, -0.06553777f, -0.05137694f, 
    -0.01928992f, -0.00218756f, 0.00979042f, 0.00245786f, 0.05298785f, 0.01645899f, 0.03982948f, 0.14311226f, 
    0.00288290f, 0.07537041f, -0.06178391f, -0.06122335f, 0.00898429f, -0.02284287f, -0.13406548f, 0.13923265f, 
    0.12352274f, -0.04216514f, 0.09225718f, -0.07582430f, 0.10532752f, 0.00028557f, -0.06986988f, 0.00859654f, 
    0.03881768f, 0.06552244f, 0.12763743f, -0.02065426f, -0.02816980f, 0.22516564f, 0.03290346f, -0.00127342f, 
    0.20339455f, 0.11491051f, 0.10996029f, 0.05074203f, 0.21500525f, -0.16334225f, -0.06817032f, 0.02555123f, 
    0.07271016f, -0.01790406f, -0.05530615f, -0.05482983f, 0.04124196f, 0.10810018f, 0.00253062f, 0.12796229f, 
    -0.01016330f, 0.08970674f, 0.11550581f, 0.06875153f, 0.25984216f, 0.16448134f, -0.07002073f, 0.12158740f, 
    0.08578330f, -0.03634499f, -0.03622766f, 0.03144789f, -0.05560935f, -0.08696375f, 0.00507554f, -0.18723701f, 
    -0.10409749f, 0.07477652f, 0.10399561f, -0.03586653f, -0.00235875f, 0.08171760f, 0.08978356f, -0.04321279f, 
    -0.50107586f, -0.33291045f, -0.18019842f, 0.00352062f, -0.26701838f, 0.04922391f, 0.00328320f, 0.10080130f, 
    0.02629806f, 0.01849519f, -0.18621582f, -0.09975648f, 0.05991687f, -0.01150457f, -0.05099696f, -0.06679751f, 
    -0.06099250f, -0.00328887f, -0.09735001f, -0.04457124f, 0.14183512f, -0.29039988f, 0.12307573f, 0.15473135f, 
    0.20852372f, -0.01917568f, -0.10647979f, 0.02907550f, -0.00257814f, 0.19504805f, -0.13559221f, -0.01667326f, 
    -0.00457264f, 0.09985848f, -0.07561874f, -0.13345966f, -0.12894839f, 0.15451649f, -0.02962913f, -0.04830695f, 
    0.16057956f, -0.03260177f, -0.07581599f, -0.09514017f, 0.07448209f, 0.14476052f, 0.12650700f, -0.02592251f, 
    0.17048657f, -0.10473498f, -0.06976531f, 0.11386099f, -0.07516637f, 0.00399595f, -0.10169487f, 0.03393006f, 
    -0.03297554f, 0.11066671f, 0.08260293f, 0.05959236f, -0.29118314f, -0.17140789f, -0.18218032f, -0.21689287f, 
    -0.18039314f, 0.25978035f, 0.11204097f, 0.09885703f, -0.02685657f, 0.01665970f, 0.18206614f, 0.02641208f, 
    -0.02817240f, -0.15768661f, -0.20691159f, 0.13797647f, 0.13757814f, 0.08125570f, 0.03037455f, 0.01873892f, 
    0.22913028f, 0.14090167f, 0.18907306f, 0.03478109f, -0.01723442f, -0.03742001f, -0.06225381f, 0.01288256f, 
    0.08495571f, 0.02905643f, -0.08498158f, -0.00760406f, 0.02769835f, 0.08285706f, 0.03755591f, 0.08200832f, 
    -0.10590012f, 0.09355058f, 0.03456691f, 0.05540041f, 0.00469595f, 0.31004959f, -0.09513558f, -0.07212888f, 
    -0.05848004f, 0.04867996f, -0.00488127f, 0.00577120f, -0.02419646f, -0.02744502f, 0.13410121f, 0.14833915f, 
    -0.05320681f, -0.03987441f, -0.09119917f, 0.12262330f, 0.06253870f, 0.18419681f, 0.16372117f, 0.13838567f, 
    0.42967597f, 0.19053099f, 0.04861670f, -0.12577347f, 0.25175053f, 0.01470310f, -0.12884058f, -0.04190948f, 
    -0.00418710f, -0.11549494f, -0.00220219f, -0.01438641f, 0.07050946f, -0.00321166f, 0.05826354f, 0.05005154f, 
    0.03167757f, -0.07556362f, 0.05741861f, 0.02555134f, -0.08984023f, 0.06281023f, 0.17409007f, -0.06312371f, 
    -0.18895274f, -0.00257658f, 0.12644108f, -0.01869175f, -0.06850395f, 0.03409838f, -0.00109833f, 0.07185922f, 
    -0.09346821f, 0.05007034f, -0.15246680f, -0.13251671f, -0.00778189f, -0.09611875f, 0.05826778f, -0.02237541f, 
    0.26868260f, 0.26828757f, -0.26970372f, -0.30579472f, -0.10128570f, 0.01201124f, -0.02404078f, -0.01906362f, 
    0.05649947f, 0.04882548f, 0.08508949f, 0.08315428f, 0.07817844f, -0.02129935f, 0.01902113f, 0.03517299f, 
    -0.01748390f, -0.02006960f, 0.02610429f, -0.10527188f, -0.08945423f, -0.06038290f, 0.24114077f, 0.26875320f, 
    0.02896131f, -0.00294147f, -0.01796186f, -0.07828975f, 0.07406055f, 0.06740199f, 0.09593414f, 0.02044960f, 
    -0.00876973f, -0.01278479f, 0.11641375f, -0.00811758f, 0.06029642f, -0.01478755f, 0.03379832f, -0.09565835f, 
    -0.19136475f, -0.01069931f, 0.09302748f, 0.14890677f, 0.09422632f, -0.05593932f, 0.00567461f, 0.01799696f, 
    -0.03338553f, -0.03924961f, -0.06466966f, 0.02491879f, -0.15345170f, -0.01602572f, 0.03748970f, 0.03469175f, 
    0.01544022f, -0.12649089f, 0.03473739f, -0.02777221f, -0.19188975f, -0.07764586f, 0.07734780f, -0.10083718f, 
    -0.20124535f, 0.01931030f, 0.07358002f, 0.02294253f, 0.01987831f, -0.09952830f, 0.14918086f, 0.09557302f, 
    0.05368445f, 0.01357429f, 0.05151673f, -0.15484801f, 0.01711131f, 0.01168228f, 0.01248944f, 0.00192548f, 
    -0.07080337f, 0.27409321f, -0.01179212f, -0.08113027f, 0.11712813f, 0.16620377f, 0.06245492f, -0.11100086f, 
    -0.02761822f, -0.00823504f, 0.02807431f, -0.08387333f, -0.04149560f, 0.06776518f, -0.01757020f, 0.05571688f, 
    0.08572336f, 0.04094082f, -0.00433878f, -0.00720194f, 0.09969969f, 0.12665400f, -0.01653361f, -0.16479482f, 
    -0.12662847f, 0.00829602f, -0.05728917f, -0.03388580f, -0.00862482f, 0.04648153f, 0.06125459f, -0.08172281f, 
    0.06707929f, -0.04118977f, 0.08582940f, -0.09150325f, 0.11251137f, 0.05504861f, 0.06017930f, 0.06516404f, 
    0.02610260f, -0.12190232f, 0.22638355f, -0.20396398f, -0.08966345f, 0.10802694f, -0.08639516f, -0.02844097f, 
    0.23685551f, 0.01136766f, -0.01953271f, -0.00970902f, -0.02908861f, -0.03241099f, 0.01959096f, -0.07980720f, 
    -0.02419205f, -0.03474056f, 0.10381494f, 0.12181510f, -0.23789492f, 0.22446530f, 0.00129225f, 0.21794662f, 
    -0.12288799f, 0.03504384f, -0.00387440f, 0.02207999f, 0.00443200f, -0.08098065f, 0.18129312f, -0.01920118f, 
    -0.01799151f, 0.00128904f, 0.14855240f, 0.09248468f, 0.01541675f, 0.10507541f, 0.06398585f, 0.04961400f, 
    0.10096701f, 0.21929267f, -0.05435498f, 0.11437114f, 0.07486627f, -0.01468601f, -0.08841068f, -0.06852304f, 
    0.05185809f, -0.06227079f, -0.03461923f, -0.00340850f, 0.01073030f, -0.16914488f, -0.06022713f, -0.00843222f, 
    0.01440132f, -0.05103151f, -0.01849714f, -0.00919297f, -0.25918067f, -0.04487816f, 0.19283931f, 0.25368044f, 
    0.20722826f, 0.01042996f, -0.12830405f, 0.04014284f, 0.04236424f, 0.14618334f, -0.01659303f, -0.02438125f, 
    -0.03898716f, 0.04329315f, 0.06602818f, -0.05731289f, 0.02196492f, 0.05852299f, 0.02549340f, -0.05733630f, 
    -0.03450789f, 0.15120025f, -0.04612870f, -0.25675625f, -0.08061983f, 0.12910748f, 0.15709312f, 0.01962283f, 
    -0.05685147f, -0.09219635f, 0.00718026f, 0.04901335f, 0.03722908f, 0.03455259f, -0.04683360f, -0.03433959f, 
    0.05851360f, -0.09369421f, -0.01695811f, 0.05048274f, -0.31629980f, -0.48078161f, -0.06674679f, 0.20638494f, 
    0.22147891f, 0.10621176f, 0.04207797f, 0.01221904f, -0.10187748f, -0.10355253f, 0.08361425f, 0.13401017f, 
    0.03723185f, -0.15438092f, -0.07363807f, -0.05952065f, 0.14184776f, 0.10668548f, -0.03944340f, 0.02282067f, 
    -0.06755485f, 0.30377057f, 0.24188563f, 0.21233100f, -0.16545449f, -0.02687074f, -0.00510609f, 0.00037731f, 
    -0.00340012f, 0.08041421f, -0.06764762f, 0.02472156f, 0.02900551f, 0.13468406f, 0.00084303f, 0.02473651f, 
    -0.10047798f, -0.07145902f, 0.00811233f, 0.06827445f, 0.05857025f, 0.24162474f, -0.13009737f, -0.05022564f, 
    -0.37038794f, -0.10200507f, 0.01645446f, 0.00621575f, 0.06449626f, -0.10641975f, -0.02938060f, 0.06807709f, 
    0.04832670f, -0.02382096f, 0.00322049f, -0.01512497f, 0.05383884f, 0.09508631f, 0.09155863f, 0.07192568f, 
    0.03554248f, -0.06354511f, 0.01169678f, -0.05949849f, 0.00906132f, 0.01099310f, -0.02913226f, 0.01453066f, 
    -0.04415574f, 0.02501834f, -0.05247279f, 0.00573403f, -0.04933668f, -0.03852676f, -0.02451812f, -0.01269534f, 
    -0.05688629f, 0.01391661f, -0.06744714f, -0.05304451f, -0.01077305f, -0.00562419f, 0.01736105f, 0.00860941f, 
    0.02824234f, 0.02764583f, -0.04131376f, -0.01415880f, -0.02004460f, -0.04415545f, -0.05280028f, 0.02575149f, 
    -0.03141422f, 0.03928692f, 0.00790622f, 0.02390676f, -0.01305151f, -0.05197909f, 0.02918427f, -0.01466162f, 
    -0.02952617f, 0.02067077f, 0.00404160f, -0.05808585f, -0.04616632f, -0.01899721f, -0.06918652f, 0.01018422f, 
    -0.04640459f, -0.00952577f, -0.03621534f, 0.02213601f, 0.03006306f, -0.03371182f, -0.00316642f, 0.03177302f, 
    -0.04081922f, 0.02173954f, 0.04275833f, 0.00361743f, 0.00215052f, 0.03015913f, -0.04943256f, -0.02258475f, 
    -0.01094098f, 0.00788554f, -0.05946866f, -0.05266030f, 0.00509095f, 0.04118928f, 0.02651117f, -0.03655596f, 
    0.02076848f, -0.01794834f, 0.01247136f, -0.03008510f, -0.05970881f, 0.01625375f, -0.04346953f, -0.01892946f, 
    -0.00737870f, -0.04621711f, -0.02347186f, 0.00132348f, -0.01354462f, -0.03377627f, 0.03669414f, 0.00753331f, 
    -0.06594550f, 0.03006114f, -0.05838766f, 0.02208454f, -0.02347653f, -0.06303192f, 0.02742155f, 0.01466781f, 
    -0.00034894f, -0.02009906f, -0.00572605f, -0.02092427f, -0.04781618f, -0.03067323f, -0.02146968f, 0.03015752f, 
    -0.05856593f, 0.02671325f, -0.01553036f, -0.06199720f, 0.01922169f, -0.04809345f, 0.00756335f, -0.01053052f, 
    -0.03089050f, -0.01641805f, 0.03425955f, 0.01645807f, 0.03612007f, -0.00560207f, 0.00637951f, -0.02273003f, 
    -0.01125117f, 0.04801149f, -0.04091574f, -0.02816104f, -0.05529911f, -0.03558343f, -0.02693549f, -0.04453944f, 
    -0.01666880f, -0.06549837f, 0.00883215f, 0.01544371f, -0.00694575f, -0.05446103f, 0.02620693f, 0.01979143f, 
    0.00660990f, -0.02770510f, 0.03204648f, -0.05700023f, -0.03140268f, -0.04609940f, -0.00777078f, 0.01194641f, 
    -0.04351217f, -0.04970332f, -0.03040595f, 0.03722969f, 0.03377327f, 0.01713176f, -0.00893379f, -0.02928493f, 
    -0.02268814f, -0.00568641f, -0.05765452f, 0.01109326f, 0.02220255f, 0.00071915f, 0.01769307f, 0.00802892f, 
    -0.05396290f, -0.02233076f, -0.04132109f, 0.04242137f, -0.04597670f, -0.00255653f, -0.02155663f, -0.02457500f, 
    0.02637817f, 0.04141357f, 0.02808737f, -0.00418214f, -0.04040226f, -0.03863115f, -0.07040811f, -0.00235868f, 
    0.04143448f, 0.03386906f, 0.04798916f, 0.04259037f, 0.01507995f, -0.03724985f, -0.03160248f, -0.03853120f, 
    0.00016452f, -0.04155916f, -0.03381133f, -0.02794490f, 0.01443807f, 0.00589490f, -0.01694367f, -0.06538973f, 
    -0.01279547f, -0.03523982f, -0.07480223f, 0.00745702f, -0.05613269f, 0.04150283f, -0.00598578f, -0.05315072f, 
    0.00134355f, -0.02360896f, 0.01623056f, 0.03076162f, 0.01893729f, -0.01847098f, -0.02078948f, -0.01489148f, 
    0.03732704f, -0.03479661f, 0.00860358f, -0.01672370f, -0.00825681f, 0.02680333f, 0.04538254f, -0.01237645f, 
    0.02718796f, -0.00882690f, -0.06628785f, -0.01273197f, 0.03500830f, -0.06947917f, -0.04891015f, -0.01621159f, 
    0.01352516f, -0.03610217f, 0.02411769f, 0.02097122f, 0.04172233f, 0.06299534f, -0.04541798f, 0.03991899f, 
    -0.05101783f, -0.05897816f, 0.02034208f, -0.02932077f, 0.02163828f, -0.01089163f, -0.03436860f, 0.03880871f, 
    0.00600176f, -0.06215640f, -0.04743459f, -0.03391113f, -0.04593831f, -0.06982853f, 0.02991556f, -0.03135010f, 
    0.02236896f, -0.00703517f, -0.01874976f, 0.01039586f, -0.02297455f, 0.00302311f, 0.00242320f, 0.00275564f, 
    -0.00176782f, 0.01773236f, -0.00008024f, 0.04270753f, -0.05668927f, -0.00302997f, 0.03729687f, -0.06897423f, 
    -0.02352695f, 0.02560677f, -0.05207289f, -0.00596639f, -0.02522062f, 0.00289715f, -0.05106477f, -0.03636117f, 
    0.01721597f, -0.01019923f, -0.04684088f, 0.02396980f, -0.01927754f, 0.02637284f, 0.04014175f, -0.04109114f, 
    -0.05309336f, -0.05406227f, -0.04012875f, 0.00890934f, -0.04161127f, 0.03899030f, 0.02905995f, -0.04027764f, 
    0.02619747f, -0.04426924f, 0.04727312f, -0.04782889f, -0.02031695f, -0.03344585f, -0.06149791f, -0.03056077f, 
    0.02955385f, -0.03733910f, -0.03318425f, -0.02105894f, -0.00981544f, 0.00967822f, 0.03320191f, 0.02362022f, 
    -0.03230381f, -0.06717496f, 0.02284203f, -0.00574666f, 0.03837502f, 0.02010201f, 0.04318531f, 0.00205442f, 
    -0.06161228f, 0.02023100f, 0.02347062f, -0.04606738f, 0.04987859f, 0.04228978f, 0.00186660f, 0.02445741f, 
    -0.00304765f, -0.04769651f, 0.00528215f, -0.02545596f, 0.03440091f, 0.02459412f, -0.01107799f, -0.03301913f, 
    -0.05051835f, -0.04454226f, 0.00291238f, 0.03722781f, -0.03034696f, 0.03157366f, 0.04607360f, 0.04493662f, 
    -0.06363019f, -0.04462279f, -0.04828144f, 0.03426045f, -0.02298397f, -0.01719486f, -0.01290238f, 0.03438912f, 
    -0.04119964f, -0.03307835f, 0.00902311f, 0.04394852f, -0.00835117f, 0.04867263f, 0.01957210f, 0.03025396f, 
    0.03152598f, -0.04198789f, 0.03815154f, 0.03090807f, 0.04383812f, 0.04222493f, -0.02633386f, -0.01575999f, 
    -0.04612197f, -0.02548475f, -0.02585010f, 0.06030126f, -0.05043355f, -0.00076259f, -0.01194028f, -0.02966747f, 
    0.00645259f, 0.02558702f, 0.03603295f, 0.02900185f, -0.03463988f, -0.05449791f, 0.01804157f, 0.02611700f, 
    -0.06113831f, 0.00618624f, -0.02682895f, -0.02261375f, -0.00901901f, -0.05092830f, 0.05064227f, -0.03190282f, 
    0.01916366f, -0.00881586f, -0.04040142f, -0.03023317f, -0.04888312f, 0.04740056f, -0.00489070f, 0.02916839f, 
    0.01771342f, -0.02947366f, -0.05252767f, -0.00060158f, -0.06052945f, -0.01102532f, 0.03480972f, 0.03511366f, 
    0.02536386f, 0.00951576f, -0.02160403f, 0.01178712f, -0.05968231f, 0.01490740f, 0.02938123f, 0.00460341f, 
    -0.06290088f, -0.03449287f, 0.00191138f, 0.01808226f, 0.01292526f, 0.01611694f, -0.01856466f, -0.02456375f, 
    -0.01066922f, 0.00908106f, -0.02027060f, -0.03527420f, 0.00249558f, -0.04436469f, 0.00354815f, -0.05562560f, 
    0.01654947f, -0.01163763f, -0.05373163f, 0.01829058f, -0.03832446f, -0.04435337f, 0.04146098f, -0.01079377f, 
    -0.04581082f, -0.03576786f, -0.05257954f, 0.01390054f, -0.03151678f, -0.00449380f, -0.06056106f, 0.00216682f, 
    -0.02706814f, 0.03458648f, -0.02991302f, -0.01027742f, 0.01370848f, -0.04491718f, 0.04466139f, -0.04154972f, 
    -0.06197154f, 0.00864397f, 0.01050833f, -0.05330982f, 0.02989438f, 0.01519351f, -0.05349918f, -0.04838648f, 
    0.03625742f, -0.00649233f, 0.03767734f, -0.03269262f, -0.02880051f, -0.04129836f, 0.00075218f, -0.00224847f, 
    -0.01388948f, 0.01226846f, -0.04053153f, -0.02846497f, -0.01810245f, 0.02670554f, -0.04631643f, -0.00835608f, 
    0.02256546f, 0.00202408f, -0.02119214f, 0.00804302f, 0.02410284f, 0.02438467f, 0.03001948f, -0.01876348f, 
    0.02043383f, 0.03997317f, 0.01112938f, -0.02675474f, -0.03787620f, 0.01436395f, -0.05945306f, -0.01121256f, 
    -0.01848439f, 0.03261587f, -0.02962943f, -0.00413035f, -0.04489256f, -0.06332563f, 0.04613146f, 0.01182984f, 
    0.02280675f, 0.02053059f, -0.04047993f, 0.03098928f, 0.00469092f, -0.04250709f, -0.02453370f, 0.01136794f, 
    -0.03637271f, -0.04810090f, -0.05055607f, 0.03882189f, -0.04157096f, -0.05783192f, -0.01007725f, 0.03417277f, 
    -0.06136315f, 0.00256491f, 0.01337846f, -0.01334557f, -0.02466870f, 0.01955678f, -0.03510566f, 0.04071730f, 
    0.03246558f, -0.01218213f, 0.02217308f, -0.01930282f, -0.00239060f, -0.01036628f, -0.01194968f, 0.03787876f, 
    0.02635527f, -0.06228544f, 0.03340373f, -0.00365408f, -0.00230362f, -0.05828633f, 0.00194819f, -0.05038247f, 
    -0.03942450f, -0.01554859f, 0.04546543f, 0.01050791f, 0.03070070f, 0.03568955f, 0.00276882f, -0.04513444f, 
    -0.00588171f, 0.01292494f, -0.04745912f, 0.01144157f, -0.04323861f, 0.01894383f, 0.00412710f, 0.02648981f, 
    -0.06311923f, 0.03724555f, -0.03242905f, 0.02325745f, -0.06243204f, -0.00765446f, 0.03365670f, 0.01735590f, 
    0.03227809f, 0.02663064f, 0.03209930f, 0.01174138f, -0.03562992f, 0.00240783f, -0.05608173f, -0.00233318f, 
    -0.00881244f, -0.03695253f, 0.04264606f, -0.01843347f, -0.03483490f, 0.01450133f, -0.01348188f, -0.02152584f, 
    0.00277865f, -0.01311480f, 0.04512258f, -0.00685547f, -0.03572001f, -0.03498057f, 0.00090737f, -0.00587572f, 
    -0.04179084f, -0.02911789f, -0.02933866f, -0.05389428f, -0.00494855f, 0.04491837f, -0.02248705f, -0.04849505f, 
    -0.02173046f, -0.04748608f, -0.01269534f, -0.00121946f, -0.04018900f, 0.04209603f, 0.04339969f, -0.05473790f, 
    -0.03431183f, -0.04052466f, -0.00483449f, 0.00997887f, 0.02777554f, -0.06120641f, 0.00806291f, 0.03151117f, 
    0.03479659f, -0.06129603f, 0.04699342f, -0.01435666f, -0.03351386f, 0.03071181f, -0.01265222f, 0.04344437f, 
    -0.01791136f, 0.04018146f, 0.01014406f, -0.00627623f, 0.03732112f, -0.02129684f, 0.04997680f, 0.05279275f, 
    -0.00192075f, -0.04184537f, 0.04525223f, -0.02618590f, 0.04630528f, -0.05494326f, -0.01750084f, 0.04620767f, 
    -0.06154868f, -0.06518655f, 0.04871953f, -0.01173952f, -0.02387335f, 0.00800779f, -0.05438835f, 0.00433988f, 
    -0.16293906f, 0.17123775f, 0.05612461f, 0.18242645f, -0.38769573f, 0.07843445f, -0.05233573f, 0.12611100f, 
    -0.09501093f, 0.07264485f, -0.07047812f, -0.00043931f, -0.11401819f, -0.02384453f, 0.02427416f, 0.11436278f, 
    0.05772367f, 0.10446661f, 0.00675041f, 0.11323627f, -0.37818015f, -0.25040025f, 0.02400875f, 0.11163709f, 
    -0.03551225f, -0.02159732f, -0.08325133f, 0.06703861f, 0.13835923f, -0.06797845f, 0.07506068f, 0.04646568f, 
    -0.02755333f, 0.16970941f, 0.00418645f, 0.11098307f, 0.13032445f, -0.04638008f, -0.10837283f, -0.02017411f, 
    -0.23532435f, -0.05839091f, 0.25668550f, 0.00739022f, -0.25196376f, 0.02294821f, -0.07256447f, 0.00023248f, 
    -0.05124502f, 0.08296228f, -0.08680309f, 0.06862836f, 0.02153632f, 0.01002672f, 0.03644506f, -0.09308432f, 
    -0.07490589f, 0.05561372f, 0.03872693f, -0.01328106f, -0.13400549f, 0.06704817f, -0.16626348f, -0.10676302f, 
    -0.20078686f, -0.04170395f, 0.19735198f, -0.00317372f, -0.00616594f, 0.04236445f, 0.02409530f, -0.02520244f, 
    -0.01865418f, -0.01332967f, 0.04341887f, -0.01759877f, 0.08788546f, 0.05064301f, 0.11095075f, -0.02818619f, 
    -0.08540394f, 0.04800140f, -0.00410593f, 0.13189341f, -0.00460944f, 0.02278955f, -0.02214785f, -0.05183221f, 
    0.02773618f, 0.00515076f, 0.08365386f, -0.02602209f, 0.11282486f, 0.03229552f, -0.05126023f, -0.15351871f, 
    -0.04426659f, 0.12656413f, -0.02330338f, 0.04316352f, 0.19346322f, 0.05169102f, 0.19781233f, 0.15750909f, 
    -0.03171132f, 0.15782695f, -0.05311878f, 0.02080044f, -0.03739631f, 0.09257812f, -0.05990313f, 0.05517939f, 
    0.04442728f, 0.15657508f, -0.00084006f, 0.00553922f, 0.06388228f, 0.02408161f, -0.12617990f, -0.03403371f, 
    0.15580060f, 0.06493389f, 0.33553487f, 0.21816473f, 0.18751213f, -0.17481145f, 0.05232389f, 0.03151358f, 
    0.03093456f, -0.03340437f, -0.13356662f, -0.00186654f, 0.06371440f, 0.01114006f, 0.02294636f, -0.08894228f, 
    0.08870453f, 0.07591490f, 0.04923836f, 0.09171023f, 0.02772470f, -0.00791927f, 0.10321921f, -0.15553546f, 
    0.01321106f, 0.05502454f, -0.06548141f, 0.04373546f, -0.04957566f, 0.06620461f, 0.04250344f, 0.10641195f, 
    0.01869050f, -0.03528035f, 0.05726187f, -0.02055970f, -0.02227560f, -0.10180659f, 0.01420031f, 0.06620223f, 
    -0.21821302f, -0.03795092f, -0.11132209f, 0.00720795f, -0.08751105f, 0.25639448f, 0.05266280f, -0.05969026f, 
    -0.09544697f, 0.13503899f, 0.13544971f, 0.00537344f, 0.04579753f, -0.06034102f, 0.07339106f, -0.00661474f, 
    0.00592402f, -0.01927396f, -0.04034231f, -0.04572333f, -0.26954621f, -0.21396020f, 0.07929417f, -0.06566645f, 
    -0.10433857f, -0.06135848f, 0.04656925f, 0.09650110f, 0.00289233f, 0.08757558f, 0.03780209f, 0.04288225f, 
    0.07067807f, -0.00646537f, -0.02207282f, 0.12488475f, 0.04547307f, -0.14367034f, 0.01404063f, 0.12245327f, 
    0.52630490f, 0.41168573f, 0.19837922f, 0.04328684f, 0.30604643f, -0.07699627f, -0.08161043f, -0.11141385f, 
    0.05180461f, -0.11597995f, 0.07061700f, 0.16505910f, -0.02087452f, 0.03800186f, 0.02811959f, 0.17885406f, 
    0.01412240f, 0.07171088f, 0.06588421f, 0.03149926f, -0.15006684f, 0.28137326f, -0.19563337f, -0.08035652f, 
    -0.27759060f, 0.11671065f, 0.07779754f, 0.02829271f, 0.01283036f, -0.02578134f, 0.04470228f, 0.08150626f, 
    -0.04324518f, -0.12486995f, 0.07166032f, 0.14101666f, 0.14404164f, -0.01329446f, -0.01306931f, 0.04843266f, 
    0.01515948f, 0.23008528f, 0.07737714f, -0.04768428f, 0.18645553f, -0.14521617f, -0.04014302f, 0.09825444f, 
    -0.04455121f, 0.22900409f, 0.04978233f, -0.08596940f, -0.00623157f, 0.00354030f, 0.09491584f, -0.03937381f, 
    -0.07527340f, -0.14014511f, -0.04891926f, 0.06348551f, 0.08046035f, 0.08203825f, 0.13160077f, 0.29392248f, 
    0.18083839f, -0.25886577f, -0.05417151f, 0.00268063f, 0.04280496f, 0.10167141f, -0.16713730f, -0.11850917f, 
    0.05885476f, 0.05612122f, 0.20252010f, 0.04470957f, 0.11600222f, -0.00111421f, -0.04473922f, -0.05100935f, 
    -0.15520373f, -0.05690808f, -0.23166135f, 0.03000031f, -0.15564077f, 0.17540526f, 0.01957256f, 0.01901164f, 
    0.06572991f, 0.15537499f, 0.03981765f, 0.04047972f, 0.08358271f, 0.04937385f, 0.09453343f, -0.04726964f, 
    0.10709478f, -0.01688300f, -0.02536546f, 0.07127421f, 0.07878368f, -0.35324010f, 0.22663954f, 0.11693646f, 
    0.01982773f, -0.02575216f, -0.02030597f, 0.05168159f, 0.06160593f, 0.03808574f, -0.14085078f, -0.09229810f, 
    0.02900014f, 0.07700519f, 0.16509829f, -0.07343397f, -0.20565140f, -0.18594228f, -0.01997903f, -0.08195004f, 
    0.11039243f, -0.08717091f, 0.22466440f, 0.09750789f, 0.15815328f, -0.02601796f, -0.07907370f, 0.02569914f, 
    -0.02434552f, -0.09181354f, 0.03698075f, -0.05271433f, 0.02790887f, 0.03879087f, -0.10022981f, 0.01062877f, 
    -0.11282360f, -0.01031611f, 0.04654272f, -0.02920024f, -0.11159878f, -0.23680130f, 0.04039549f, 0.00070647f, 
    -0.12897977f, -0.18875757f, -0.05121146f, -0.01447762f, -0.12253631f, 0.06217052f, 0.00286089f, 0.05606854f, 
    -0.04981117f, -0.06239213f, -0.01852840f, 0.04043306f, -0.16094141f, -0.08363706f, 0.07331395f, 0.05976349f, 
    0.02295472f, -0.24081649f, 0.06932624f, 0.12540856f, -0.05608665f, -0.01835894f, 0.09097556f, 0.07592006f, 
    -0.01520032f, 0.04474381f, 0.10811657f, -0.00255882f, 0.10834148f, 0.02754219f, 0.00348922f, 0.12130108f, 
    -0.01770131f, 0.00255608f, -0.04126031f, 0.07290639f, 0.25742251f, 0.20526212f, 0.17385834f, 0.15462786f, 
    0.02865204f, 0.01268216f, 0.09641477f, 0.05454371f, 0.00020969f, -0.09790203f, -0.01899251f, 0.06909689f, 
    0.04652648f, 0.06816903f, 0.09061863f, 0.09216009f, 0.01840324f, 0.19185328f, -0.11540949f, 0.13690403f, 
    0.53033072f, -0.27883899f, 0.08307709f, 0.09192319f, -0.06748715f, -0.00337681f, 0.00122898f, -0.01135924f, 
    0.04086411f, -0.05145197f, 0.01238765f, 0.08116512f, 0.00206471f, -0.00222766f, 0.01438462f, -0.06568205f, 
    0.09777525f, -0.17342223f, 0.11136665f, 0.00033741f, -0.38208565f, -0.12869410f, -0.11828139f, -0.16404043f, 
    -0.06069083f, -0.05956308f, -0.04557859f, -0.06406730f, 0.07150574f, 0.01755897f, 0.05672509f, 0.07195195f, 
    -0.01939228f, -0.05679906f, -0.08648966f, -0.03322195f, 0.03154866f, 0.05746894f, 0.02386086f, 0.07250589f, 
    0.55888373f, 0.03831315f, 0.00380983f, 0.04842876f, 0.02913054f, 0.05317773f, -0.03390250f, 0.02265931f, 
    -0.02626460f, -0.08092346f, -0.01399346f, 0.00431136f, -0.03600763f, 0.18738109f, -0.14374548f, 0.08751776f, 
    -0.11990824f, -0.04611736f, -0.02075071f, -0.15017840f, -0.22998467f, 0.05227697f, 0.16320340f, -0.06351139f, 
    -0.02435457f, -0.07561543f, -0.05605721f, -0.03973445f, 0.01578632f, -0.03153492f, -0.02593774f, 0.05119266f, 
    0.03827308f, 0.04773707f, -0.01645039f, -0.01529079f, 0.01842820f, 0.05947743f, -0.02318535f, -0.02529305f, 
    -0.06380769f, -0.13487202f, 0.18354313f, 0.16507284f, 0.03317438f, 0.12177782f, 0.07162249f, 0.02661438f, 
    -0.13036831f, 0.03397874f, -0.01240514f, 0.04704809f, -0.03162433f, 0.07305195f, -0.06091011f, -0.01100709f, 
    -0.03987880f, 0.00856487f, 0.05426218f, 0.06255042f, 0.01383005f, 0.17557754f, 0.19915983f, 0.07266523f, 
    -0.11723763f, 0.04489117f, 0.14921524f, -0.13551389f, 0.12369741f, 0.03867188f, -0.04420396f, 0.09224760f, 
    0.09933188f, 0.14007555f, 0.11698289f, 0.02770098f, -0.06301930f, 0.09886067f, -0.17256029f, -0.15237992f, 
    0.05133365f, 0.03428670f, -0.08215240f, -0.03007039f, 0.03195702f, 0.06730493f, -0.00637962f, 0.15482540f, 
    0.06964239f, 0.03502944f, -0.06008389f, 0.11294794f, -0.07244570f, 0.00710495f, -0.03782672f, -0.05642354f, 
    -0.01747024f, -0.04780534f, -0.01607772f, -0.04044030f, -0.02673906f, 0.00300333f, 0.40442428f, 0.00016349f, 
    0.26349145f, 0.09336448f, 0.06315665f, 0.05047806f, 0.04019038f, 0.09822439f, 0.01074344f, -0.11860360f, 
    0.03495468f, 0.01566860f, 0.00800777f, -0.08760073f, 0.03667200f, -0.00572844f, 0.08035859f, 0.01643387f, 
    0.32679552f, -0.11066589f, -0.01603502f, -0.02235113f, -0.12685207f, -0.00672522f, 0.03383239f, -0.03570760f, 
    0.01865102f, -0.03875668f, -0.03045192f, 0.00459961f, 0.03588535f, -0.01460918f, -0.01132332f, -0.04204294f, 
    -0.15241720f, 0.09232917f, 0.04330793f, 0.09891167f, 0.27098107f, -0.22487788f, -0.18660101f, -0.28404421f, 
    0.10864131f, -0.04879418f, 0.01230985f, 0.02153104f, 0.03159317f, -0.01819919f, 0.03831632f, 0.03582576f, 
    0.04336990f, -0.09724399f, -0.01736468f, -0.06628610f, 0.04218410f, 0.07212274f, 0.05120728f, -0.00601243f, 
    -0.09962551f, -0.06759602f, 0.20040245f, -0.08967236f, 0.14691536f, -0.06669036f, 0.04135776f, 0.09744927f, 
    -0.08206802f, 0.00168233f, 0.08217657f, 0.04774832f, 0.04544775f, -0.01117398f, 0.06063893f, -0.04682558f, 
    -0.00665194f, -0.01330052f, 0.00524489f, -0.04495636f, -0.01529854f, 0.33950776f, 0.09183645f, -0.15008505f, 
    -0.10461511f, 0.01129555f, -0.05650227f, -0.07000151f, -0.03694640f, -0.03418808f, -0.01685268f, -0.00997843f, 
    -0.09862034f, -0.00491991f, 0.02576737f, -0.02202859f, -0.01480124f, 0.02946533f, -0.02608881f, -0.00590634f, 
    -0.03620482f, -0.00152758f, 0.02545952f, -0.03850038f, -0.02706900f, 0.01384541f, -0.06303593f, -0.03251817f, 
    0.02860236f, -0.01012270f, 0.02244111f, 0.04022611f, 0.02556324f, -0.02115984f, -0.02774077f, -0.04436585f, 
    -0.02011261f, -0.01461322f, -0.02351476f, -0.04052585f, 0.03207942f, 0.03640992f, -0.05304181f, 0.01592535f, 
    0.02279866f, -0.00991297f, -0.02509176f, 0.03136623f, -0.00206439f, 0.01021675f, -0.04270565f, 0.00505689f, 
    -0.04066740f, -0.00958439f, 0.03175130f, 0.01279321f, -0.00284130f, 0.04579944f, -0.00434744f, 0.01751667f, 
    -0.01965259f, 0.05084747f, -0.02187112f, -0.02861746f, 0.00024620f, -0.03893008f, -0.04285368f, 0.03977811f, 
    -0.00464467f, -0.02624738f, -0.05257686f, -0.03813120f, 0.03398659f, 0.02463069f, -0.04328902f, -0.00689965f, 
    -0.05252940f, 0.04605125f, -0.01933792f, 0.03490923f, 0.00130067f, 0.02815746f, -0.00592780f, 0.03490858f, 
    0.02088252f, 0.03544533f, 0.04652207f, 0.02645669f, 0.03821979f, 0.02994298f, 0.04166779f, 0.00427934f, 
    -0.00014470f, -0.02619268f, 0.01379565f, 0.01509088f, -0.01342764f, -0.00411635f, 0.04126554f, 0.01273220f, 
    0.02947333f, 0.03281652f, -0.05020224f, 0.00564290f, -0.04312703f, 0.01875195f, -0.04538017f, 0.01538878f, 
    -0.00895711f, 0.03795305f, -0.04349978f, -0.04606470f, -0.00144713f, 0.05213037f, -0.01891195f, -0.01311875f, 
    0.02937716f, -0.04219436f, 0.03365564f, -0.04605523f, 0.05603524f, 0.05682379f, 0.04937190f, 0.03902394f, 
    0.04282584f, 0.00587879f, 0.00588463f, 0.00195458f, -0.00622460f, -0.00420462f, -0.04702127f, 0.02534890f, 
    -0.03865868f, 0.02860527f, -0.01240716f, 0.04194251f, -0.02932627f, -0.06057935f, -0.02808844f, -0.02904981f, 
    -0.03152373f, -0.02927775f, 0.02342312f, 0.01477319f, -0.02510880f, -0.01271840f, 0.03090684f, -0.02131505f, 
    0.04105042f, -0.02539624f, -0.00391662f, 0.04096005f, -0.01486324f, 0.02077973f, -0.03281220f, -0.04805486f, 
    0.04157658f, 0.00329734f, -0.01878191f, 0.02993981f, -0.05180229f, 0.00087217f, -0.00619231f, -0.04169072f, 
    0.04090850f, -0.01753563f, -0.06102845f, -0.05836359f, -0.05139694f, 0.00362343f, 0.03617620f, -0.05813367f, 
    -0.03265276f, 0.01127188f, -0.01035483f, -0.01364097f, -0.00108736f, -0.04046379f, -0.04486246f, -0.00416607f, 
    0.03570371f, -0.02285804f, 0.00358746f, 0.04335582f, -0.00550363f, 0.02149971f, 0.01726090f, 0.02265874f, 
    0.02527347f, 0.02510293f, -0.00829916f, -0.05629882f, -0.04642237f, 0.01454234f, 0.03240996f, -0.04354832f, 
    0.00741225f, -0.04542632f, -0.05013492f, 0.03229886f, 0.02045906f, 0.01825585f, -0.03255606f, -0.02551009f, 
    -0.01818125f, 0.01538752f, 0.02587807f, -0.03664220f, -0.03470013f, -0.00475526f, -0.01645984f, 0.00244694f, 
    -0.02946392f, -0.03966667f, 0.02209045f, 0.01300167f, -0.06119020f, 0.05036588f, 0.01149635f, 0.02465800f, 
    -0.01363886f, 0.04628256f, -0.04311004f, 0.02633910f, -0.02285088f, -0.02786131f, -0.00032581f, -0.04680376f, 
    -0.05905645f, -0.04844338f, -0.05515233f, -0.00438621f, -0.00179087f, -0.01683467f, -0.04903692f, 0.01995473f, 
    -0.00047135f, -0.02704987f, 0.03565624f, -0.04149140f, 0.03520955f, -0.03118458f, -0.05138763f, 0.00391057f, 
    0.03647310f, -0.03095068f, -0.04028744f, -0.02708829f, -0.06220846f, 0.02432712f, 0.00399895f, 0.01722305f, 
    -0.03110594f, -0.04095826f, -0.01810885f, 0.01291621f, 0.04319897f, -0.01514458f, 0.03106963f, -0.00777798f, 
    -0.01360097f, -0.01809553f, -0.02241044f, 0.02777945f, -0.05047861f, 0.03032494f, -0.03676390f, 0.03834824f, 
    -0.03546430f, 0.00068977f, -0.03668479f, -0.01406904f, -0.01466236f, -0.00233758f, 0.00374493f, 0.02468021f, 
    0.01922378f, -0.05517162f, -0.06031748f, -0.00049108f, 0.00013539f, 0.00647611f, 0.02565236f, -0.03816994f, 
    -0.04105266f, 0.02320923f, 0.03229968f, -0.04458645f, 0.00530436f, -0.03891458f, -0.01825956f, 0.03760896f, 
    -0.02903408f, -0.01700379f, 0.01595883f, -0.05006616f, 0.00658374f, -0.06363398f, -0.01961859f, -0.03623078f, 
    -0.06134006f, -0.02937859f, 0.01192313f, 0.00384449f, -0.01828504f, -0.05470904f, -0.06406699f, -0.00126171f, 
    0.02226339f, 0.01527654f, -0.01284166f, -0.00873997f, 0.04202954f, -0.03625378f, 0.02216755f, 0.02260030f, 
    0.01306546f, -0.05046514f, -0.01356658f, -0.03959658f, 0.02943209f, 0.05611822f, 0.02956685f, 0.03531095f, 
    0.01735522f, -0.03937393f, 0.00278114f, -0.00320842f, -0.01206169f, 0.02072621f, -0.02513675f, -0.02919970f, 
    -0.03670514f, -0.05562207f, 0.01707438f, -0.03927127f, -0.03419700f, 0.03068067f, -0.02494986f, -0.01116124f, 
    0.00462932f, -0.10503134f, -0.04659344f, 0.07915924f, 0.16074142f, 0.00781137f, -0.03149034f, -0.01545461f, 
    0.01936806f, -0.00617597f, -0.08110285f, -0.02946021f, 0.03998880f, 0.04729608f, 0.07353532f, -0.00203158f, 
    -0.02530187f, -0.00050841f, -0.00431619f, -0.06165141f, 0.09769958f, 0.37041560f, 0.12059779f, -0.00931925f, 
    0.17350908f, 0.08225109f, -0.10624642f, -0.05488850f, 0.08440252f, -0.07732847f, -0.05824074f, 0.01683931f, 
    0.02492417f, 0.10852326f, -0.14278890f, 0.01609022f, 0.01354614f, -0.01447173f, 0.02133105f, -0.01813539f, 
    -0.24641438f, 0.00501527f, 0.02903669f, 0.00374959f, 0.12296245f, 0.09174306f, -0.03297340f, -0.11175054f, 
    0.01780771f, 0.03528789f, -0.10495491f, 0.02651266f, -0.05218964f, 0.07905643f, 0.06682457f, 0.04119829f, 
    -0.09171769f, 0.02048526f, 0.00094000f, -0.01996119f, 0.05683354f, 0.06770915f, 0.37632096f, 0.15737715f, 
    0.02725213f, -0.16765659f, -0.01668888f, 0.13252836f, 0.01688942f, 0.08071121f, 0.03864680f, 0.01257468f, 
    0.01488184f, -0.06442784f, -0.00147863f, -0.12694018f, -0.08800429f, -0.10195034f, 0.01336348f, -0.09250678f, 
    -0.40845606f, -0.14727576f, 0.14189838f, -0.14297417f, 0.03995567f, -0.01317701f, 0.00237998f, -0.05630218f, 
    -0.04227292f, -0.11140976f, -0.05624035f, 0.03156561f, -0.15645464f, 0.09529417f, -0.12294953f, 0.16624433f, 
    -0.07986557f, -0.02859381f, -0.05201197f, 0.12487007f, 0.12448829f, 0.29160082f, 0.20092265f, 0.09689741f, 
    0.08459483f, -0.04571328f, -0.07534553f, -0.00491669f, -0.05439760f, 0.02778338f, -0.04416157f, -0.09599800f, 
    0.13571313f, 0.00877131f, 0.09328199f, 0.10407008f, -0.05050649f, 0.12956068f, -0.07147092f, -0.03068749f, 
    -0.19835594f, 0.06510265f, -0.48694223f, -0.01128047f, -0.10378318f, 0.02814766f, -0.00173444f, -0.12656330f, 
    -0.04662944f, 0.05513696f, -0.01738542f, -0.04947323f, 0.02133232f, -0.10856483f, 0.09018716f, -0.12529767f, 
    0.09995064f, -0.02761808f, 0.05688755f, -0.11185925f, -0.18800774f, 0.43753669f, -0.08575989f, 0.19536114f, 
    -0.00123997f, 0.08042594f, -0.00616548f, 0.00679897f, 0.15464836f, 0.22227322f, -0.06000915f, 0.06390013f, 
    0.12482166f, -0.11945465f, 0.19442882f, -0.21609975f, -0.10042656f, -0.11889693f, 0.03481964f, -0.05357533f, 
    -0.09329514f, 0.45902842f, 0.20955504f, 0.13489267f, 0.16923119f, -0.14429808f, -0.02447801f, -0.00194951f, 
    0.09789013f, 0.06970283f, -0.11779981f, -0.05581320f, 0.03174093f, 0.02349353f, 0.01264033f, -0.03296923f, 
    0.03148558f, 0.04070316f, -0.02859237f, -0.04807010f, 0.28370371f, 0.45222229f, 0.00126896f, 0.13549072f, 
    0.11344241f, -0.05996471f, -0.05948282f, 0.20547998f, 0.02164334f, 0.18114080f, 0.06968420f, -0.00846917f, 
    -0.02803518f, -0.01843012f, 0.05145177f, -0.09207370f, 0.00314164f, 0.11957000f, 0.02667067f, -0.02961857f, 
    -0.02989199f, -0.27947637f, -0.23081554f, -0.02120956f, -0.26123402f, -0.10417651f, 0.04960525f, -0.02908241f, 
    0.03286642f, -0.07213739f, 0.08352484f, -0.03796442f, 0.04040959f, -0.08362522f, 0.05595758f, -0.07393791f, 
    -0.01907414f, -0.02639533f, 0.08446066f, 0.02001847f, 0.10891835f, 0.14662643f, 0.00535938f, 0.27557716f, 
    -0.13259332f, -0.09880534f, -0.03256485f, 0.12819685f, 0.05700583f, -0.07902945f, -0.11109266f, 0.03731303f, 
    0.11451266f, -0.23720549f, 0.03729929f, 0.03797745f, -0.01487355f, 0.01324936f, -0.04212028f, -0.11908673f, 
    -0.35652256f, -0.02174314f, -0.01885476f, 0.18247375f, 0.00054542f, 0.07467058f, -0.13634379f, -0.13688868f, 
    0.08990391f, 0.05098636f, -0.03503413f, 0.11320985f, 0.03866826f, 0.08542192f, -0.09934488f, 0.17925826f, 
    0.05778404f, -0.09337489f, 0.04310952f, 0.07396472f, -0.33431554f, -0.43086645f, -0.06007370f, 0.19154868f, 
    0.03692911f, 0.06394589f, -0.10797183f, -0.04722344f, -0.11234961f, 0.08435142f, 0.06172657f, 0.04435803f, 
    0.02101873f, 0.03967926f, -0.01986058f, 0.16824335f, 0.02123824f, -0.05773869f, -0.10710943f, -0.12677026f, 
    0.44494995f, 0.42201158f, 0.02128182f, 0.23538825f, -0.01153692f, 0.04250765f, 0.07669235f, -0.06898502f, 
    -0.01939426f, 0.09522264f, -0.13158737f, 0.00743267f, -0.01058441f, -0.05117768f, -0.10848660f, 0.03814618f, 
    0.14832111f, 0.08740065f, 0.04376944f, 0.04092566f, 0.21933056f, 0.23878062f, 0.15823211f, 0.03380699f, 
    0.14887868f, -0.05595658f, 0.00986567f, -0.05799606f, -0.01564460f, -0.00110645f, 0.01219983f, 0.12537013f, 
    0.03809557f, -0.05123790f, 0.07954674f, 0.08245288f, -0.01831422f, -0.01055671f, -0.00093018f, 0.01324796f, 
    0.13848224f, 0.07024561f, -0.04487717f, 0.04525637f, -0.11911287f, 0.09474158f, -0.01299679f, -0.00873530f, 
    -0.00591264f, 0.09471443f, 0.02521868f, -0.01984658f, 0.01701654f, -0.05536125f, -0.06070981f, -0.05886630f, 
    0.02266193f, -0.00723356f, 0.05074121f, 0.07939290f, 0.29554835f, 0.16678706f, -0.05772424f, 0.08178774f, 
    0.07550061f, -0.00044910f, -0.08859178f, -0.05521161f, 0.04724271f, -0.03900029f, 0.02207141f, 0.06956131f, 
    0.09729871f, -0.08906014f, 0.00994195f, 0.09821645f, 0.24076305f, -0.05069609f, 0.02470163f, 0.07809932f, 
    -0.09860103f, -0.01129710f, 0.03517695f, 0.40946764f, -0.01414705f, 0.09578165f, 0.02080744f, -0.02140868f, 
    -0.05429267f, -0.04197287f, -0.07617899f, 0.05058152f, -0.04920193f, 0.05911171f, 0.04782298f, -0.03756134f, 
    0.05729564f, -0.03129131f, 0.10431570f, -0.11594489f, 0.33004445f, 0.13373373f, -0.22022177f, 0.10921276f, 
    -0.05517424f, -0.04137433f, 0.11384940f, 0.03065902f, 0.05635905f, 0.01230594f, -0.08940799f, 0.13974196f, 
    -0.11029645f, 0.01468717f, 0.01532401f, -0.02304839f, -0.10456858f, 0.04048638f, -0.00890046f, 0.04856078f, 
    0.35303372f, -0.07185655f, -0.14342241f, -0.02691499f, -0.28086320f, 0.04765268f, 0.12889500f, 0.02136382f, 
    0.03590368f, 0.06185645f, 0.09457842f, 0.04153039f, 0.02689635f, 0.06402876f, 0.01751272f, -0.05175674f, 
    0.05288120f, 0.10296252f, 0.08052238f, 0.03075702f, 0.18279479f, 0.12957379f, 0.07729347f, 0.20982204f, 
    0.16910098f, 0.11670081f, -0.03099468f, -0.03392935f, -0.05135050f, 0.00951702f, -0.08518243f, 0.07190850f, 
    0.01628952f, 0.06165344f, -0.02737844f, 0.07538117f, -0.02342528f, -0.00871077f, -0.06105873f, -0.03671588f, 
    -0.32960519f, -0.31047356f, 0.09494366f, 0.08421053f, -0.07024425f, -0.01371472f, 0.09474394f, 0.02854438f, 
    0.02192730f, -0.13749087f, -0.03116200f, 0.06494635f, 0.05098090f, 0.02315420f, -0.02169264f, 0.00939635f, 
    0.01365546f, 0.11610255f, 0.05643466f, 0.08353858f, -0.10993421f, 0.20105961f, 0.12124471f, -0.07327750f, 
    0.15147345f, 0.11666363f, -0.06415171f, 0.12272595f, 0.04846200f, 0.02046928f, -0.03958484f, 0.02820197f, 
    0.03835308f, 0.00571378f, -0.07622831f, -0.01424357f, -0.09566295f, 0.02641262f, 0.00945511f, 0.05505707f, 
    -0.00500289f, 0.12584552f, -0.09880158f, 0.21016309f, 0.09209620f, 0.07114004f, -0.03113812f, 0.05717482f, 
    -0.04304101f, 0.03538564f, -0.16964233f, 0.10343069f, 0.08022857f, -0.08537052f, 0.07670677f, 0.03751406f, 
    0.02024719f, 0.07137868f, 0.06379089f, -0.07229801f, -0.11728316f, 0.03239477f, 0.08544489f, -0.09111837f, 
    0.00977596f, 0.03668033f, -0.06038769f, -0.05433189f, 0.05180584f, 0.05688075f, -0.20665187f, 0.02060302f, 
    0.03247658f, -0.02612201f, 0.01514134f, 0.03209504f, -0.00207501f, -0.00840684f, 0.01607536f, 0.08618579f, 
    -0.24124508f, 0.03597959f, 0.15400952f, -0.07997780f, -0.09693211f, 0.03084796f, 0.02295447f, 0.08817763f, 
    -0.05191081f, -0.18414715f, 0.08109242f, -0.00978613f, 0.07480218f, 0.03561751f, 0.04476533f, 0.04053301f, 
    -0.07270241f, 0.04201803f, 0.05012260f, 0.09475076f, 0.24626739f, 0.22320598f, -0.16000974f, -0.00902619f, 
    -0.03188598f, 0.08093658f, -0.04093662f, 0.02083938f, 0.04843219f, -0.08360412f, 0.07236806f, 0.01587414f, 
    -0.01042032f, -0.18265808f, -0.01390912f, 0.04947571f, 0.00472818f, -0.06885852f, 0.07529689f, -0.01762336f, 
    0.11102416f, -0.09996448f, 0.05217176f, 0.06451268f, -0.07270496f, -0.15550697f, -0.05750674f, 0.01873218f, 
    0.06743450f, 0.12101308f, 0.03032896f, 0.02065045f, 0.07266761f, -0.02338010f, -0.03054215f, 0.03541993f, 
    -0.01794976f, 0.06730282f, -0.03779309f, 0.09683550f, -0.34095305f, -0.02485714f, -0.00340117f, -0.07030476f, 
    -0.00246109f, -0.08266004f, 0.05423035f, 0.09522285f, 0.04135320f, 0.00099858f, -0.28111726f, -0.03119741f, 
    -0.07536765f, 0.11089340f, -0.00576590f, -0.07971626f, -0.00624395f, -0.05744089f, -0.06846185f, -0.04152485f, 
    -0.10184300f, -0.13918555f, -0.13871485f, -0.04961616f, 0.13973057f, -0.02305556f, 0.00237897f, -0.02532694f, 
    0.03899321f, 0.03248919f, 0.07253780f, -0.05608668f, 0.05730621f, -0.06619732f, -0.01996774f, 0.00062401f, 
    0.02183415f, 0.10177800f, -0.00325849f, -0.10109819f, 0.11528307f, -0.27072182f, 0.21664758f, 0.08052831f, 
    0.12170403f, 0.07951832f, 0.04197576f, -0.00641239f, 0.00050966f, 0.12204389f, -0.00716481f, -0.10473710f, 
    0.00902247f, 0.01492094f, 0.06638483f, -0.01943342f, -0.07485626f, -0.03135944f, -0.08160136f, -0.07110438f, 
    -0.04001640f, -0.04365842f, 0.01742237f, -0.05904004f, 0.02263078f, -0.00509947f, -0.02718441f, 0.02411698f, 
    -0.04456888f, -0.01590796f, -0.06065106f, 0.02168514f, 0.01560416f, -0.02483709f, -0.02308598f, 0.03496235f, 
    -0.00329875f, -0.05583948f, 0.02598119f, -0.05167060f, 0.02832147f, -0.04599262f, 0.03103489f, 0.01747911f, 
    0.03593169f, 0.00604878f, -0.01641740f, 0.01413687f, 0.00994757f, 0.04841954f, -0.00787623f, -0.00858476f, 
    -0.04158037f, -0.03925272f, -0.00835079f, -0.04581619f, 0.02262978f, 0.02590446f, -0.03703866f, -0.06091147f, 
    0.02340004f, -0.02802787f, -0.02541689f, -0.02909108f, 0.05164710f, 0.04197450f, -0.05462543f, 0.03193512f, 
    0.01353665f, 0.02959268f, 0.00602860f, -0.04736561f, -0.02562313f, -0.02408387f, 0.00174479f, -0.02778151f, 
    0.00629879f, -0.00554176f, 0.00874602f, 0.03325083f, 0.00663150f, 0.01075601f, 0.02709878f, -0.03809498f, 
    -0.05470800f, 0.01892361f, 0.02516935f, 0.05067726f, 0.01747156f, -0.00698021f, 0.05231370f, 0.00048276f, 
    0.03934417f, -0.01276732f, -0.01032029f, -0.02283731f, -0.00935708f, 0.04024164f, 0.03823677f, -0.02543015f, 
    -0.03901652f, 0.01114478f, -0.01264793f, -0.06069961f, -0.04918086f, -0.02775274f, -0.00682837f, 0.02119930f, 
    -0.00126224f, -0.00644459f, -0.04747285f, -0.03440390f, 0.02430444f, -0.01596102f, -0.00593184f, -0.02463467f, 
    -0.01647129f, 0.00315920f, 0.00266459f, -0.02841416f, 0.04375389f, 0.02338873f, -0.00344402f, -0.03584761f, 
    0.01270250f, 0.02924826f, 0.02923652f, -0.00788113f, -0.00364626f, 0.02902943f, -0.01764136f, 0.03224387f, 
    -0.01282646f, -0.03188299f, -0.06296233f, -0.00507353f, -0.06283832f, 0.00221230f, 0.02686954f, -0.03478267f, 
    0.00739486f, 0.02543794f, 0.02541406f, 0.03339610f, 0.02496243f, -0.01166579f, 0.02364615f, 0.03134494f, 
    0.01424978f, 0.02464577f, 0.00899927f, -0.05199356f, -0.02719493f, 0.00744374f, -0.03322058f, -0.01385318f, 
    0.02693414f, -0.02243090f, -0.05978830f, -0.02357188f, 0.04759571f, 0.00514899f, -0.04422736f, -0.02918196f, 
    0.01864670f, -0.01747815f, -0.00385170f, 0.04881396f, -0.04036212f, -0.04944076f, 0.00361453f, -0.00996369f, 
    -0.02132761f, 0.00239967f, 0.03320893f, 0.02621369f, 0.00559809f, -0.03862810f, 0.00743562f, -0.03021639f, 
    -0.05527593f, 0.04350231f, -0.03800926f, -0.05556775f, -0.04531121f, 0.04389788f, -0.02159048f, 0.04553749f, 
    -0.03988298f, -0.04885893f, 0.02345811f, 0.00416383f, 0.03837833f, 0.05052394f, -0.00962592f, -0.03915151f, 
    -0.03455970f, -0.04378464f, -0.00354512f, 0.02838240f, -0.03138434f, 0.01909976f, 0.04545435f, -0.01542688f, 
    0.04588177f, -0.03782823f, -0.04015107f, -0.01649347f, 0.01801296f, -0.03631605f, 0.05195317f, 0.04929286f, 
    -0.06227124f, 0.04146121f, -0.02935614f, -0.05327070f, 0.00213692f, 0.00368334f, -0.00209113f, -0.04588353f, 
    0.01052584f, -0.04152242f, 0.00309770f, 0.01899910f, 0.00732108f, 0.01848936f, -0.03774361f, -0.00569470f, 
    -0.04178292f, -0.05959783f, -0.05353268f, 0.05191552f, -0.05717349f, -0.03346468f, 0.01734828f, -0.05328287f, 
    0.04617776f, 0.03744476f, -0.05377647f, 0.02749552f, -0.00149389f, 0.00666347f, -0.01274665f, -0.03675825f, 
    -0.03516035f, -0.00374637f, 0.03735049f, -0.00733994f, 0.02311780f, 0.04796916f, 0.00606661f, 0.00487710f, 
    0.01033426f, 0.02344869f, -0.01657039f, 0.02668123f, 0.01814644f, -0.03007966f, -0.04311376f, 0.03333765f, 
    -0.03218910f, 0.01785144f, -0.00289846f, -0.03162532f, 0.03642907f, -0.01457211f, -0.04880157f, 0.00342176f, 
    -0.05445178f, -0.03394186f, 0.04796228f, -0.00028815f, 0.01150355f, 0.04055558f, -0.00192034f, -0.00217865f, 
    -0.01868592f, 0.00257688f, -0.03389458f, 0.03610170f, 0.02120271f, -0.00035288f, 0.02374519f, -0.03179879f, 
    0.03719167f, 0.01989171f, -0.00473471f, -0.04743292f, 0.02314988f, 0.02355874f, -0.05250692f, 0.02490351f, 
    0.03845471f, -0.00707525f, 0.03159095f, -0.03928337f, 0.02246694f, -0.03628397f, 0.03382973f, -0.00529914f, 
    -0.00760270f, 0.03070244f, -0.03417462f, -0.04489249f, 0.02153108f, -0.00802524f, -0.04223653f, 0.01581452f, 
    -0.00052757f, -0.04683566f, 0.02059299f, 0.00744771f, 0.01691310f, -0.02017149f, -0.01841489f, 0.00701627f, 
    0.03462989f, -0.00048486f, -0.03248084f, -0.01398149f, -0.00558250f, -0.00777996f, -0.00028681f, -0.02546837f, 
    -0.04954081f, -0.05177766f, 0.00528555f, 0.02392584f, 0.02727528f, 0.02889794f, -0.03557330f, -0.05674396f, 
    -0.00648432f, 0.01653655f, 0.03634002f, -0.00260243f, 0.04140588f, -0.05261432f, 0.02366753f, -0.05373956f, 
    -0.45044708f, 0.32054061f, 0.11180729f, 0.07553799f, -0.06776883f, -0.11410935f, 0.08285236f, 0.09510987f, 
    0.12225565f, 0.09280678f, 0.08229972f, -0.03723255f, -0.07410940f, -0.05061506f, -0.07355279f, 0.10338131f, 
    -0.00838323f, 0.17717664f, 0.03138218f, 0.03623509f, -0.18597011f, -0.12770663f, 0.07972675f, -0.04855124f, 
    -0.03057138f, -0.01772039f, -0.10922427f, 0.02393006f, 0.26319271f, -0.05200509f, -0.00422480f, 0.06747538f, 
    0.16276038f, 0.18628590f, 0.15751559f, 0.12976925f, 0.04141818f, 0.02084499f, -0.01820712f, 0.00758455f, 
    -0.21559480f, -0.16552296f, 0.09783574f, 0.12823442f, -0.17406097f, -0.03283703f, 0.21389796f, 0.13754621f, 
    -0.16062960f, -0.11413436f, 0.00675232f, 0.02948998f, -0.05471521f, 0.05023191f, 0.10975830f, -0.03190776f, 
    -0.06542360f, 0.06109966f, 0.13936567f, 0.02586967f, -0.09252248f, 0.16333491f, -0.14574064f, 0.09125934f, 
    -0.12771356f, -0.09584153f, -0.07116791f, -0.06569257f, 0.00775409f, 0.00892561f, 0.18394424f, 0.02945123f, 
    -0.05251698f, 0.02008334f, -0.10959917f, -0.06431317f, 0.02700337f, -0.08585332f, -0.03908017f, -0.03796009f, 
    0.14164320f, 0.35263801f, -0.39233619f, -0.06429645f, 0.04823610f, -0.04293858f, -0.00480136f, -0.08075046f, 
    0.00872034f, 0.08936387f, 0.04350809f, 0.05621294f, 0.01722971f, 0.02287991f, -0.08703694f, -0.00480240f, 
    0.00770093f, 0.16061540f, -0.03394808f, 0.06644884f, -0.05672908f, -0.12665756f, -0.12717989f, -0.06956336f, 
    -0.06747621f, 0.00015019f, -0.15088668f, -0.01103807f, 0.06114429f, 0.00780286f, 0.06604575f, 0.00807576f, 
    0.00534952f, 0.15347397f, 0.01313869f, -0.04121571f, 0.00494594f, -0.12862183f, -0.05145259f, 0.01912279f, 
    0.51740903f, -0.24937005f, 0.29433575f, 0.15260072f, 0.06276019f, 0.03042148f, -0.00774052f, 0.09558106f, 
    0.05934602f, -0.01992910f, -0.02061091f, -0.03100641f, 0.05175847f, -0.03844412f, 0.02033832f, 0.03787453f, 
    0.02348135f, 0.00655171f, 0.04728368f, -0.03106376f, -0.15603516f, -0.21557058f, 0.01721226f, -0.09997463f, 
    -0.00712518f, 0.11634267f, -0.08176883f, 0.05715270f, -0.10324771f, -0.04327707f, 0.09312547f, 0.03734799f, 
    -0.06819944f, -0.03820068f, -0.09021571f, 0.18218540f, 0.01978106f, -0.06056115f, 0.02805849f, -0.05880046f, 
    0.13747174f, -0.04005635f, -0.09077851f, -0.19574831f, -0.20556444f, 0.08236060f, 0.04076210f, 0.07204891f, 
    -0.16633503f, 0.00521738f, 0.08239002f, -0.08080862f, -0.04046925f, -0.09379871f, 0.00832762f, -0.10483227f, 
    0.07744462f, -0.03430661f, -0.04161585f, 0.05977537f, -0.08929408f, -0.07493287f, 0.20436694f, -0.14322612f, 
    0.11836221f, 0.04357735f, 0.00175631f, 0.24005851f, 0.05875584f, 0.15990989f, 0.07182376f, 0.10558169f, 
    0.05487707f, -0.03777609f, -0.01095084f, 0.00193110f, 0.02116036f, -0.11340374f, -0.03892349f, -0.01517125f, 
    0.48957840f, 0.16355078f, 0.26580760f, -0.02612009f, 0.11940158f, 0.03373946f, 0.01940783f, 0.03260415f, 
    -0.02929950f, 0.09962139f, 0.11772396f, 0.10275567f, -0.06536938f, -0.01707270f, 0.00262895f, -0.02662651f, 
    -0.01936547f, -0.00035989f, 0.04144802f, -0.01884334f, 0.16485682f, 0.25611424f, 0.12636398f, -0.02270289f, 
    -0.02645975f, -0.03501071f, 0.11779262f, -0.06682026f, 0.08541548f, -0.17497781f, 0.19652642f, -0.05802511f, 
    0.00377477f, -0.02752568f, 0.08571142f, 0.09653085f, 0.02879012f, -0.12077428f, 0.02390178f, -0.03622606f, 
    -0.17132714f, 0.13205357f, -0.11719403f, 0.04613876f, 0.03919573f, -0.06322836f, -0.03613650f, -0.07003375f, 
    -0.12584129f, 0.10819669f, 0.10367644f, -0.05809608f, 0.19791894f, 0.01011971f, 0.17519838f, -0.05652357f, 
    -0.02697675f, 0.01667283f, -0.01253996f, -0.13438430f, 0.53684121f, 0.24952541f, -0.10485107f, -0.05893939f, 
    0.19490047f, -0.00514667f, -0.08964417f, -0.09860565f, -0.05188509f, -0.01926808f, -0.04639131f, -0.12470634f, 
    0.07387851f, 0.13594548f, 0.20200953f, 0.03653147f, 0.03088492f, -0.01054268f, -0.10774852f, -0.00445214f, 
    0.30555212f, -0.22496830f, 0.05921925f, -0.09285274f, -0.01190168f, -0.07711425f, -0.01663675f, 0.07244830f, 
    0.02024395f, 0.04199206f, 0.02062271f, -0.10262566f, 0.12090867f, 0.01462225f, -0.01187380f, -0.04958641f, 
    0.17018516f, 0.02254124f, -0.01490906f, -0.00307773f, 0.01396686f, -0.28827056f, 0.01332840f, -0.06297156f, 
    0.05924309f, 0.02867030f, -0.05518045f, 0.02375408f, 0.10636635f, 0.05037365f, 0.06273925f, 0.08060280f, 
    -0.05358857f, 0.05861303f, 0.06899847f, -0.07757872f, -0.08294810f, -0.06706853f, -0.04583449f, -0.12404024f, 
    0.10441215f, -0.13930580f, 0.14351302f, 0.10838930f, -0.26190037f, -0.07394494f, -0.00964218f, -0.02768336f, 
    0.00854685f, -0.03609568f, 0.00165398f, -0.05753070f, 0.02223249f, -0.02943932f, 0.15886170f, -0.01832374f, 
    0.03694204f, -0.05443965f, 0.05565561f, 0.05212535f, -0.10469744f, -0.02097203f, -0.06217499f, -0.00539717f, 
    -0.28597879f, -0.00890186f, 0.15842882f, 0.04918215f, -0.07023793f, -0.07228358f, 0.03290904f, 0.00124965f, 
    -0.00431664f, -0.07316209f, -0.16895138f, -0.13125840f, -0.09349421f, 0.09343483f, -0.02254721f, 0.01053589f, 
    0.46456283f, -0.07182772f, 0.05103892f, -0.09123301f, 0.14882289f, -0.00545704f, -0.09128341f, 0.02050868f, 
    0.15407978f, 0.09818771f, 0.00165409f, 0.05012040f, 0.06724730f, 0.03149946f, -0.05136328f, 0.02310828f, 
    -0.02285113f, -0.01889705f, -0.00140727f, -0.04011097f, 0.06483943f, -0.12567604f, -0.12365022f, -0.24139512f, 
    -0.12479386f, -0.06739270f, 0.01779077f, 0.01679010f, 0.03660243f, -0.01824008f, 0.04952136f, -0.03576460f, 
    0.03625091f, 0.10893572f, 0.08236182f, 0.01565365f, 0.03202891f, 0.01918424f, 0.06528132f, -0.00740788f, 
    -0.15747668f, 0.20826168f, -0.06711593f, 0.08639490f, 0.06164329f, 0.01242933f, 0.01511151f, 0.04452382f, 
    -0.07607394f, -0.07519639f, -0.08234502f, -0.03887511f, -0.00248884f, 0.00705370f, -0.03993728f, -0.05185757f, 
    -0.07584181f, -0.08171950f, 0.04528676f, -0.06884142f, 0.04971429f, 0.03318351f, -0.07708793f, -0.12733793f, 
    0.06901523f, 0.08370463f, 0.06182051f, 0.07062971f, -0.01483089f, 0.09489976f, -0.04592219f, -0.05823145f, 
    -0.00630407f, 0.03174509f, -0.09555902f, -0.10157564f, 0.03777077f, 0.01128069f, 0.04854997f, -0.10703683f, 
    -0.07001476f, -0.15142618f, 0.20620683f, 0.05916898f, 0.13062611f, -0.20325118f, -0.11228596f, -0.01991525f, 
    0.10349406f, -0.00288424f, -0.12073535f, -0.05758541f, -0.01836865f, -0.09452903f, -0.00599167f, -0.01447021f, 
    -0.03624393f, 0.00948248f, -0.20248495f, 0.01586390f, 0.50678009f, 0.15351233f, -0.07798741f, -0.01454511f, 
    0.18332335f, -0.00833564f, 0.03654863f, -0.07680808f, 0.14908066f, -0.00339252f, 0.09542124f, 0.08855864f, 
    -0.05649864f, 0.14054041f, 0.11923110f, 0.00301224f, 0.01670954f, 0.07759888f, -0.04355049f, -0.01252764f, 
    0.15348415f, 0.14598316f, -0.04703332f, -0.26267788f, -0.00876003f, 0.06621992f, -0.09791092f, -0.08731508f, 
    0.04566136f, 0.01320139f, 0.15155880f, -0.05599930f, -0.07428931f, 0.09526747f, 0.07639376f, 0.00124972f, 
    -0.10366249f, 0.01323960f, -0.18931128f, 0.13515922f, 0.14473517f, -0.04197575f, -0.06586635f, -0.00565079f, 
    -0.03435782f, -0.06415125f, -0.04940684f, 0.07076947f, -0.09502272f, 0.01910415f, -0.04822220f, 0.03933163f, 
    -0.12298146f, -0.01835327f, -0.06278972f, -0.04562249f, 0.01690994f, 0.02927214f, -0.06454514f, -0.03974866f, 
    0.17504004f, 0.08629890f, 0.09480336f, -0.10471601f, 0.22573353f, -0.06135939f, -0.09825155f, -0.00627206f, 
    0.01777241f, 0.11792208f, -0.09012622f, -0.00986975f, 0.09020081f, 0.10053527f, -0.00003095f, 0.05648617f, 
    -0.01946890f, -0.14310117f, -0.19817570f, 0.03154195f, 0.36418882f, 0.02660803f, 0.00565923f, -0.24700306f, 
    -0.21966261f, -0.14071839f, -0.03039560f, -0.04390708f, 0.05248995f, 0.00033484f, 0.01642697f, 0.12766905f, 
    0.06590565f, 0.06700114f, 0.09790909f, 0.10356493f, 0.09445862f, -0.06789099f, -0.07647719f, 0.10856480f, 
    0.17522794f, 0.27354991f, 0.00273293f, -0.16860221f, 0.20320752f, 0.01950379f, 0.06285638f, 0.05928174f, 
    -0.01293616f, -0.09951191f, -0.06849079f, 0.07977832f, -0.06158863f, -0.02113608f, -0.02537972f, -0.04421956f, 
    -0.01887612f, 0.07840288f, -0.00680344f, -0.01673464f, -0.19404325f, 0.37191397f, -0.12427631f, 0.26591876f, 
    0.17665952f, 0.16786055f, 0.03807497f, 0.05409142f, 0.09084111f, 0.08135561f, -0.00792169f, 0.01038992f, 
    -0.10364027f, -0.12596302f, 0.07672168f, 0.02405049f, -0.05702437f, 0.00806978f, -0.00303630f, -0.01531035f, 
    0.25132865f, -0.06147019f, 0.00458807f, -0.30860358f, -0.12336316f, -0.10710249f, 0.00952394f, -0.00024014f, 
    0.07806377f, 0.02340891f, 0.11523455f, -0.05167631f, 0.00557824f, 0.06265262f, 0.06541373f, -0.02166237f, 
    -0.00658459f, 0.05493046f, -0.08137406f, 0.16984817f, 0.29312190f, -0.24549977f, 0.14496127f, -0.13960941f, 
    -0.11420824f, -0.10421751f, 0.13883705f, 0.19699876f, -0.01128217f, 0.03809569f, -0.00597873f, 0.03992670f, 
    -0.06137602f, 0.01540370f, -0.08966239f, 0.01444547f, -0.08422294f, 0.03489899f, 0.13655750f, -0.00399605f, 
    0.03877288f, -0.00384873f, -0.02944139f, -0.00963170f, -0.03490052f, 0.03419126f, -0.01230467f, -0.02162161f, 
    0.01615907f, 0.04394241f, -0.04392673f, 0.01810603f, -0.05685811f, -0.03462796f, 0.05263347f, 0.00830153f, 
    0.02499072f, -0.03087503f, -0.03298366f, -0.05286878f, 0.02123662f, -0.04497620f, 0.02657693f, 0.04298653f, 
    -0.05016305f, -0.04334363f, 0.01791970f, 0.02058481f, 0.00257665f, -0.03606401f, 0.00381225f, -0.06216654f, 
    0.00887676f, 0.01245844f, -0.05755386f, 0.03393945f, 0.04360049f, -0.03326565f, 0.04575829f, -0.04960832f, 
    -0.00369845f, -0.03343805f, 0.02686782f, -0.03302614f, -0.01552404f, 0.03341845f, -0.04662202f, -0.01544105f, 
    -0.01129537f, -0.01286901f, -0.01885366f, -0.06053271f, 0.02815011f, -0.00021442f, -0.01933482f, 0.00050965f, 
    0.02391172f, -0.04095708f, 0.03837069f, 0.04141799f, -0.04577038f, -0.04239745f, 0.00646532f, -0.02298899f, 
    0.02843039f, -0.00342428f, -0.04619421f, -0.03283462f, -0.04354112f, 0.04449603f, -0.03090966f, 0.04170585f, 
    -0.01312679f, -0.03877287f, 0.04886210f, -0.00093357f, -0.02531766f, 0.04409677f, -0.04865149f, -0.03973313f, 
    -0.00377943f, -0.00730329f, -0.01341627f, 0.00595721f, -0.03050637f, -0.00882368f, -0.03852176f, -0.00853509f, 
    -0.03781332f, -0.04563022f, -0.05040207f, 0.00866762f, -0.05869966f, -0.00731178f, 0.00282385f, -0.01403329f, 
    -0.04435987f, -0.06047615f, 0.01320479f, 0.00790050f, -0.03034766f, 0.00450248f, -0.02197025f, -0.04101666f, 
    -0.01412565f, -0.04648554f, -0.05250850f, 0.04951679f, 0.00061435f, 0.04297568f, 0.00129955f, -0.04372147f, 
    0.00576266f, -0.01734523f, 0.00216915f, -0.05105006f, 0.02156545f, -0.03823120f, 0.02881660f, 0.01190230f, 
    -0.06627741f, 0.04237717f, 0.00895618f, -0.03877993f, 0.03321914f, 0.02835434f, 0.01465557f, -0.01223615f, 
    0.02235190f, -0.02152892f, -0.00551740f, -0.05415508f, 0.00012761f, -0.02989692f, -0.01094877f, 0.02619120f, 
    -0.04671983f, 0.04011750f, -0.06802686f, -0.00149319f, -0.04350867f, -0.04505829f, 0.00701345f, 0.03512808f, 
    0.04585389f, -0.04698555f, 0.01283977f, 0.03989938f, -0.06318369f, 0.03487767f, -0.05928836f, -0.00365529f, 
    0.03825696f, -0.01337358f, 0.02609984f, -0.04353606f, 0.01339530f, 0.04053578f, -0.03137301f, 0.02727466f, 
    -0.03110885f, -0.04544907f, -0.03080986f, 0.02677175f, 0.02044694f, -0.00915424f, -0.03635127f, -0.05132117f, 
    0.02620176f, 0.00463959f, -0.03244572f, 0.04121681f, 0.01911528f, -0.03237806f, 0.04080427f, -0.00680187f, 
    0.05054976f, -0.00779261f, 0.00038178f, -0.00620528f, -0.00288217f, -0.01346591f, 0.02974375f, 0.03788604f, 
    -0.03951567f, -0.03540047f, -0.03646864f, 0.01373673f, 0.01973229f, 0.01599559f, 0.03345180f, -0.02327482f, 
    -0.02726967f, 0.03066532f, 0.00853829f, -0.04579620f, -0.00450841f, -0.02162274f, -0.05671398f, -0.03986772f, 
    0.04416853f, 0.01510192f, 0.00871528f, 0.03249220f, -0.04590896f, 0.04307757f, -0.04708016f, -0.01028669f, 
    -0.03001812f, 0.03588885f, -0.00387038f, 0.02199752f, -0.02710451f, -0.00966283f, -0.05245119f, -0.03519366f, 
    -0.01001131f, 0.05459260f, -0.02327251f, 0.03357141f, -0.02111937f, 0.02496703f, -0.00860879f, 0.04952982f, 
    0.01469639f, 0.00005614f, -0.04248173f, -0.03796507f, 0.05565825f, 0.03945589f, 0.01699230f, 0.00186713f, 
    0.03528904f, -0.01099360f, 0.04205468f, -0.01811310f, 0.04750267f, -0.03418457f, 0.04616802f, -0.01075785f, 
    0.04581133f, 0.01113585f, -0.05508984f, 0.03380598f, 0.04124551f, 0.01059192f, 0.03189919f, -0.02162158f, 
    -0.02009980f, -0.04349502f, -0.02738614f, -0.01271109f, 0.00654469f, 0.04271771f, 0.03579430f, -0.05664027f, 
    -0.05345753f, -0.04935112f, 0.00295743f, 0.00155132f, -0.02392785f, -0.05685794f, -0.01493032f, 0.00618683f, 
    -0.00282046f, 0.01861661f, -0.00560999f, 0.03848945f, -0.04532494f, 0.01415393f, -0.03347380f, -0.00844882f, 
    -0.00877827f, -0.02425024f, -0.05467869f, 0.02390281f, 0.01878507f, -0.06335937f, 0.01150586f, 0.05914944f, 
    0.00391603f, 0.01966066f, 0.04350405f, -0.04659731f, 0.01467181f, 0.02695505f, -0.03177901f, -0.02543147f, 
    0.00507259f, -0.05386855f, -0.05098170f, 0.02769942f, 0.05164443f, -0.00829501f, -0.01934141f, -0.03985119f, 
    0.02377541f, 0.04617967f, -0.03520861f, -0.00673071f, 0.02489454f, 0.03503228f, 0.04414489f, 0.00672872f, 
    -0.00135641f, -0.01790929f, 0.01175134f, -0.01044460f, -0.03197151f, 0.00860635f, -0.03257490f, -0.00410159f, 
    0.00908211f, 0.00047940f, -0.00993802f, 0.01297897f, -0.04280809f, -0.02192928f, 0.04456253f, -0.05441340f, 
    -0.01898354f, -0.05441103f, -0.03407718f, -0.03516414f, -0.05091475f, 0.04175427f, -0.00158129f, -0.04965169f, 
    -0.01154051f, -0.04661607f, -0.02043786f, -0.04768533f, -0.04844819f, -0.03152376f, 0.05542057f, -0.02339682f, 
    0.00132892f, -0.02165313f, -0.03665408f, -0.00861824f, 0.04822503f, 0.05211451f, 0.03929228f, 0.05090664f, 
    -0.01340023f, -0.01464520f, 0.00418686f, -0.01969098f, 0.00746767f, 0.03340091f, 0.01801053f, 0.02160313f, 
    -0.01629722f, -0.01035663f, 0.04909711f, -0.05375670f, 0.00454079f, -0.04245556f, -0.02930705f, -0.04536177f, 
    0.03423239f, -0.01955725f, 0.03463548f, -0.04075681f, -0.04517515f, -0.01992325f, 0.03553865f, 0.02715929f, 
    -0.02406549f, -0.03669351f, -0.04708354f, 0.03418256f, -0.00416449f, 0.05444718f, -0.05291459f, 0.02232707f, 
    0.05284903f, -0.04726560f, 0.03906703f, -0.01300203f, 0.05442095f, -0.00441270f, 0.01238518f, -0.04783515f, 
    -0.03388378f, -0.04252961f, 0.02771075f, 0.04392025f, 0.04459039f, -0.02017333f, -0.00798403f, 0.00518429f, 
    0.05461315f, 0.02682301f, 0.04874606f, -0.05183716f, 0.01821474f, 0.01569315f, -0.04482622f, 0.02676347f, 
    -0.00352002f, 0.02111990f, -0.03728116f, -0.04567228f, 0.03255106f, -0.04402685f, -0.05010226f, 0.02091482f, 
    -0.02034001f, 0.00827658f, -0.03667820f, -0.04220710f, -0.00642681f, -0.01829313f, -0.00338545f, 0.01162467f, 
    0.02617852f, -0.01048545f, -0.03654919f, 0.02872955f, 0.03805977f, -0.04810607f, 0.01559160f, -0.02984299f, 
    0.01678278f, -0.05202066f, 0.03779339f, -0.03660294f, -0.02656029f, 0.03719772f, -0.02973606f, -0.04934869f, 
    0.03369291f, 0.01024910f, -0.02705008f, 0.01710383f, -0.00067509f, -0.04620797f, 0.01572226f, 0.01553427f, 
    -0.04214456f, -0.03191929f, 0.01825262f, -0.00452745f, 0.01531054f, 0.00746749f, -0.03875924f, 0.04833888f, 
    0.01694069f, 0.00644202f, 0.00947131f, -0.04372441f, -0.00739040f, 0.01524674f, -0.05456616f, 0.02940352f, 
    -0.01012562f, 0.00219930f, 0.01958778f, -0.02967080f, 0.00099152f, 0.00275503f, 0.00602078f, 0.01434587f, 
    -0.00998699f, 0.03161321f, -0.01622566f, -0.04099995f, 0.04221390f, -0.04488685f, -0.03883801f, -0.01268698f, 
    0.01521252f, 0.04284889f, -0.02579465f, -0.00591022f, 0.03906320f, -0.02355611f, -0.04577565f, -0.05127168f, 
    0.03102519f, 0.02413922f, 0.01688523f, -0.03078431f, -0.00051915f, 0.02661548f, 0.04190351f, -0.02381987f, 
    0.01727190f, 0.04210412f, 0.04193150f, 0.02266327f, 0.03997695f, 0.05367829f, -0.01725594f, -0.04220511f, 
    -0.00733717f, -0.04036758f, 0.03331831f, 0.01566329f, 0.03229079f, -0.03339330f, 0.03783113f, 0.03944189f, 
    -0.01284371f, -0.01024651f, -0.03224510f, 0.00244492f, 0.03342208f, -0.02620753f, 0.05120116f, -0.01261771f, 
    -0.01173224f, -0.03822737f, -0.00794588f, 0.03798365f, 0.02326794f, 0.04650501f, 0.04714037f, -0.04629043f, 
    -0.04037688f, -0.00258376f, 0.05374264f, -0.04628351f, 0.01482155f, 0.02546020f, 0.02212656f, -0.03032499f, 
    0.00452065f, 0.02831526f, -0.03528251f, -0.05354656f, 0.01192468f, 0.02160546f, -0.04937939f, -0.03189747f, 
    -0.01027833f, -0.01988806f, -0.02236775f, -0.01719834f, -0.02649784f, 0.04779345f, -0.05025414f, -0.02863738f, 
    -0.02630807f, 0.02358106f, -0.00276046f, -0.01537181f, 0.03520476f, 0.01120503f, -0.00088183f, -0.03754535f, 
    -0.05172320f, 0.01361355f, 0.01839575f, -0.05448565f, 0.00822302f, 0.02045788f, -0.04481803f, 0.02297270f, 
    0.01907373f, 0.01654351f, 0.01823878f, 0.01375270f, -0.02682013f, -0.04577234f, 0.03875371f, 0.00376872f, 
    -0.01278921f, -0.04558456f, 0.04953309f, 0.01910936f, 0.03311928f, -0.04270792f, -0.03211066f, -0.04335665f, 
    0.00587438f, 0.00204176f, 0.00851851f, 0.02191678f, -0.03097279f, 0.00520392f, -0.01819593f, 0.00126953f, 
    -0.02459673f, 0.00609495f, -0.00415822f, 0.04360989f, -0.01315095f, -0.03414200f, 0.03566001f, -0.05004016f, 
    -0.04490353f, -0.05050365f, -0.00689348f, 0.05159439f, -0.00853545f, 0.03301466f, -0.01830605f, 0.01131675f, 
    -0.02009081f, -0.05062746f, -0.02162239f, 0.04393697f, -0.05578169f, -0.01276469f, -0.00177190f, -0.02389724f, 
    0.02794138f, 0.00547660f, -0.03517546f, -0.05578451f, 0.02223388f, 0.01838969f, 0.03914041f, 0.03348217f, 
    -0.05291345f, -0.05148267f, 0.00764356f, -0.00352099f, -0.04475824f, -0.03206208f, -0.01175518f, 0.00079234f, 
    -0.00283805f, -0.00009734f, -0.00044443f, -0.05214788f, -0.04645728f, -0.04269068f, -0.02260916f, -0.04929890f, 
    0.00447017f, 0.05181524f, 0.02354725f, 0.03586007f, -0.03552946f, 0.05246525f, -0.00438224f, -0.03096886f, 
    0.02816784f, -0.05463667f, -0.05439319f, -0.01190073f, -0.04172426f, 0.00218058f, -0.02106898f, -0.05884708f, 
    0.03346344f, 0.03649995f, -0.03562242f, 0.01078207f, 0.04780398f, -0.05005123f, 0.04456480f, -0.05784023f, 
    0.00168416f, 0.02451081f, -0.03189913f, -0.04280791f, 0.03062513f, 0.01699019f, -0.04425684f, -0.03809196f, 
    -0.05857127f, -0.00506786f, 0.03984981f, -0.00022725f, -0.05418830f, 0.00657580f, 0.02896685f, -0.01603260f, 
    -0.05587209f, 0.04959738f, -0.03929914f, -0.03846618f, 0.04560852f, -0.04241694f, -0.03575854f, -0.04434331f, 
    0.03544350f, 0.04063635f, -0.02597038f, -0.00556072f, -0.03954690f, 0.03461934f, 0.03780665f, -0.05936367f, 
    -0.02203416f, -0.02248746f, -0.05099336f, -0.03882393f, -0.02077620f, -0.00345191f, -0.03064665f, 0.02638127f, 
    0.01680456f, -0.02386494f, 0.04243068f, -0.04973593f, 0.02201604f, -0.06283050f, -0.01032144f, -0.01854431f, 
    -0.00143766f, 0.02767501f, -0.03741294f, -0.01744193f, -0.03324703f, -0.00910235f, 0.00883696f, 0.02060675f, 
    -0.03402213f, -0.05545698f, 0.03388400f, 0.00644441f, 0.02762728f, 0.01147319f, 0.00697749f, -0.05114143f, 
    0.02870515f, -0.01456378f, 0.03518727f, 0.01942474f, 0.00778628f, 0.03471932f, 0.00837182f, -0.06284823f, 
    -0.04528857f, -0.02790702f, -0.02459678f, 0.04719289f, 0.03965455f, -0.04327612f, -0.05308620f, 0.03596227f, 
    -0.03701238f, -0.02074348f, -0.01894573f, 0.04097015f, -0.03763112f, -0.01072497f, 0.01758523f, -0.00264306f, 
    -0.05073876f, 0.00222076f, -0.00126574f, 0.03135950f, -0.02233094f, -0.05539287f, 0.00888154f, 0.01129558f, 
    0.03940383f, -0.00574111f, 0.04451380f, -0.01205955f, 0.03954219f, 0.04142400f, -0.05089459f, 0.01090430f, 
    -0.04827608f, -0.05108650f, -0.00677408f, -0.02217726f, -0.02341786f, -0.00588056f, -0.05120053f, -0.05900087f, 
    0.02817825f, -0.02750472f, -0.03673692f, 0.04855129f, 0.02906780f, -0.05910833f, -0.04177150f, 0.02895337f, 
    -0.01331426f, 0.02422106f, -0.03330333f, -0.00930431f, 0.01400200f, 0.02728182f, -0.06231078f, -0.01807751f, 
    -0.04454192f, 0.01935648f, -0.04030822f, -0.05388797f, -0.00555366f, 0.00443631f, -0.01815755f, 0.01636478f, 
    -0.00457797f, -0.01382623f, -0.05052574f, -0.02624099f, 0.03471420f, 0.03914296f, -0.04283333f, 0.02176459f, 
    -0.01805475f, -0.05313883f, -0.03526893f, 0.01007029f, 0.04404318f, 0.04094350f, -0.04096652f, 0.01654233f, 
    -0.03103841f, 0.01075330f, 0.03994386f, 0.03760773f, 0.03780886f, -0.03101741f, -0.02241329f, -0.01543167f, 
    -0.04890155f, -0.00286789f, 0.04581400f, 0.02501478f, -0.05504952f, 0.03970671f, 0.04492823f, -0.01359136f, 
    -0.03187187f, -0.01969381f, -0.05116602f, -0.04765445f, -0.03931558f, -0.05798626f, 0.00852142f, -0.03935153f, 
    0.03806981f, -0.03193090f, -0.02708179f, 0.00156304f, -0.02924693f, -0.03011663f, 0.03746565f, -0.04054148f, 
    0.01629291f, 0.01027710f, -0.02824937f, -0.03815318f, 0.03279239f, 0.01026274f, -0.06066427f, 0.02259219f, 
    -0.05766797f, -0.05486063f, 0.02815970f, 0.01925311f, 0.01416247f, 0.04450485f, 0.04718277f, 0.03105046f, 
    0.01063608f, -0.01219019f, -0.02593181f, -0.02925184f, -0.02536343f, 0.03512939f, -0.01253275f, 0.02410859f, 
    0.03880981f, -0.00586882f, -0.00059106f, -0.02092125f, 0.02214049f, -0.01798728f, -0.02238460f, 0.02059019f, 
    0.02758595f, -0.05048116f, -0.03778399f, 0.00270360f, 0.04584346f, -0.03949003f, -0.01213855f, 0.00824806f, 
    -0.01171409f, -0.05648781f, -0.05283587f, 0.04190030f, -0.04544389f, 0.03184976f, 0.00230813f, 0.04355896f, 
    0.02637581f, 0.00767579f, 0.02992235f, -0.01359737f, -0.01438321f, -0.02205705f, -0.04300155f, -0.02883656f, 
    -0.01431104f, -0.04288393f, 0.03842111f, 0.01303457f, 0.01002890f, -0.04993736f, -0.04778646f, -0.06270509f, 
    0.02505293f, 0.03331548f, 0.02747935f, -0.02923039f, -0.03331701f, -0.04093610f, 0.02623216f, -0.00480765f, 
    -0.06010510f, -0.00976521f, 0.02218796f, 0.03372008f, -0.05396912f, -0.04483034f, -0.02899317f, 0.01295316f, 
    0.03579498f, -0.00523490f, 0.01292305f, 0.00013140f, 0.02668385f, 0.01522916f, -0.04112467f, -0.03334848f, 
    0.03119430f, -0.06417470f, -0.02387158f, 0.02459222f, -0.04045891f, 0.03535436f, -0.00881909f, 0.01216006f, 
    0.02806090f, -0.06292624f, -0.04667569f, -0.00205382f, 0.01423910f, -0.01447465f, -0.01980292f, -0.04784116f, 
    -0.01317687f, -0.00693968f, 0.03227114f, 0.02288938f, -0.02970455f, -0.01730360f, -0.01656684f, -0.04669954f, 
    0.01309997f, -0.02823507f, -0.05676699f, -0.05324395f, 0.03062054f, 0.03161076f, -0.03108192f, -0.04783998f, 
    0.15135449f, 0.24922305f, -0.05301740f, 0.04332991f, -0.07724874f, 0.05286421f, 0.00286992f, 0.10030735f, 
    -0.04640971f, 0.10667877f, -0.05028689f, 0.05029676f, -0.01535243f, 0.09187403f, 0.08769836f, 0.06412791f, 
    0.14214844f, 0.05352262f, 0.08887058f, 0.01098833f, -0.12221017f, -0.25911942f, 0.05545190f, 0.02763893f, 
    -0.11248201f, -0.05971815f, -0.07761097f, -0.08018319f, 0.14516142f, 0.01009468f, 0.11663381f, -0.00378409f, 
    0.07517617f, 0.04332253f, -0.07978357f, 0.03336209f, 0.08983502f, -0.10281597f, 0.02667505f, 0.13107026f, 
    -0.06110068f, 0.12215843f, -0.10468309f, -0.27675352f, -0.24076019f, -0.00487223f, 0.02022967f, -0.08102185f, 
    -0.09767190f, 0.05682639f, -0.11069828f, 0.03761803f, -0.02022698f, -0.02617396f, -0.03899160f, 0.06571296f, 
    -0.13684441f, 0.05339452f, 0.04864159f, -0.00224294f, -0.15498355f, -0.01433788f, -0.18281174f, 0.10200074f, 
    0.02456045f, -0.01656597f, 0.06760489f, -0.07894562f, 0.01624612f, 0.15852286f, 0.04895826f, -0.05960160f, 
    0.02521758f, 0.02814845f, 0.05479484f, 0.03597670f, 0.02477783f, -0.15812677f, -0.03146437f, 0.00209052f, 
    0.17414023f, 0.00872358f, -0.06706163f, -0.09550227f, -0.01174219f, -0.01688608f, 0.06696517f, -0.05478952f, 
    -0.10256598f, -0.02844504f, 0.01555248f, -0.01788337f, 0.07277235f, -0.01905160f, 0.05587510f, -0.08215857f, 
    -0.08345898f, 0.11081202f, -0.10653775f, 0.00387225f, 0.13632390f, -0.15570296f, 0.12142172f, 0.02171138f, 
    -0.08515609f, 0.03922100f, -0.02061146f, 0.03030018f, 0.01381037f, 0.04774262f, -0.01348929f, 0.01050366f, 
    0.09635758f, 0.17332792f, 0.12952642f, -0.07516073f, 0.15290451f, -0.00176615f, -0.21882235f, -0.07344096f, 
    0.19637242f, 0.11727309f, 0.42883700f, -0.19623162f, 0.05159293f, 0.09987144f, 0.08600148f, 0.01198139f, 
    0.06211098f, -0.04120097f, -0.02722723f, -0.05392694f, 0.12468977f, -0.02234073f, 0.10643017f, -0.01308371f, 
    0.09443703f, -0.02332045f, 0.11636146f, 0.16596730f, -0.44138753f, -0.23321754f, 0.10736587f, -0.25706452f, 
    0.00586982f, 0.10581277f, -0.03750239f, 0.02735068f, -0.12078189f, 0.11998459f, 0.00612450f, 0.08080869f, 
    0.04429431f, -0.04174332f, 0.02904986f, 0.00372677f, -0.02124227f, -0.11910141f, -0.02708641f, 0.06424178f, 
    -0.06054307f, -0.10497160f, -0.08638180f, 0.11549330f, -0.04493865f, 0.25274059f, 0.02558491f, -0.00800172f, 
    0.03398361f, 0.13320105f, 0.12878984f, 0.00857892f, 0.06464989f, -0.04028158f, -0.03471217f, 0.05568894f, 
    0.01028602f, -0.04811437f, 0.11100205f, -0.05359826f, -0.50707608f, -0.27445874f, 0.22617985f, -0.01486971f, 
    0.02517853f, -0.05845438f, -0.03554891f, 0.10011482f, -0.07010368f, 0.00516099f, 0.11349846f, -0.15870127f, 
    0.03337001f, -0.10427869f, 0.03344988f, 0.01368742f, -0.02328963f, -0.09312980f, 0.04062993f, 0.20386806f, 
    0.40899464f, 0.40995213f, 0.20042185f, 0.07515740f, 0.24399601f, -0.02922763f, 0.00991735f, -0.02719023f, 
    0.08483454f, -0.01978268f, 0.07079972f, 0.14938171f, -0.05271976f, 0.10859472f, -0.00406925f, 0.05710223f, 
    0.02163100f, 0.03621137f, 0.08716168f, -0.07031935f, -0.05279611f, 0.09987685f, -0.12270518f, 0.06203775f, 
    -0.03650499f, 0.05323439f, -0.03312859f, 0.00501345f, -0.05684524f, 0.10475670f, 0.06198294f, 0.03781467f, 
    0.00819315f, -0.00344720f, 0.02769252f, 0.07878841f, -0.00620277f, 0.02759711f, -0.03368016f, -0.08051258f, 
    -0.03848648f, 0.00008741f, -0.02790056f, -0.17451102f, 0.17865428f, -0.11748718f, 0.05981921f, 0.14656137f, 
    -0.23143193f, 0.06891096f, 0.04313974f, -0.14198154f, 0.10154086f, -0.05615346f, 0.15947539f, -0.02166756f, 
    -0.03460116f, -0.07749949f, -0.06277353f, -0.04267925f, -0.04581998f, -0.01308984f, 0.35136127f, 0.01340756f, 
    -0.12536111f, -0.12098879f, 0.01125713f, 0.00262844f, 0.01819919f, 0.07012527f, -0.02980924f, 0.02742711f, 
    0.01406786f, 0.03839996f, 0.10751603f, -0.03225432f, 0.09752526f, -0.03903636f, -0.02210323f, 0.01064426f, 
    0.10677378f, -0.09439845f, 0.00697093f, 0.10809242f, -0.07388972f, 0.06149132f, 0.09984745f, 0.03498161f, 
    0.07622334f, 0.15954807f, 0.01957315f, 0.03440258f, 0.02825304f, 0.06776712f, -0.01071198f, 0.12397286f, 
    0.14565994f, 0.00303823f, 0.06831680f, 0.05570024f, 0.02278347f, -0.35917249f, -0.04025532f, 0.10996265f, 
    -0.05655475f, 0.07028639f, -0.00138722f, -0.01024149f, 0.13556509f, 0.05464578f, -0.09638503f, 0.01106396f, 
    -0.04378270f, 0.04659948f, 0.19973622f, -0.03402939f, -0.02872482f, -0.03075742f, -0.05277472f, -0.08367951f, 
    0.09814063f, -0.23925401f, -0.06893795f, 0.11414705f, 0.17563269f, -0.00467185f, 0.05623457f, -0.06684411f, 
    -0.01393479f, 0.05436469f, -0.00199410f, 0.08084274f, 0.03040540f, 0.12816916f, -0.07196166f, 0.02698940f, 
    -0.05286926f, -0.02484805f, -0.02763114f, 0.00631054f, -0.03395269f, 0.11732210f, -0.15930089f, -0.12127502f, 
    0.09108217f, -0.09859779f, -0.03091731f, 0.09812872f, -0.04499019f, 0.00224368f, -0.05731313f, 0.02895148f, 
    -0.05649102f, -0.07857633f, 0.03980894f, 0.06914030f, -0.13350053f, -0.05661582f, 0.09644109f, 0.01668989f, 
    -0.08724491f, -0.39725223f, 0.11993611f, 0.16736840f, 0.22603150f, 0.04411766f, 0.06405246f, 0.07769650f, 
    0.05016247f, 0.02340058f, 0.06518446f, -0.07575282f, 0.01114900f, -0.01211740f, 0.12489707f, 0.12007067f, 
    0.04718449f, -0.04430901f, -0.04100322f, 0.05265228f, 0.34511170f, 0.08159432f, 0.17591535f, -0.18619047f, 
    0.06456234f, 0.02276138f, -0.00746317f, 0.14892115f, -0.18290564f, -0.14106205f, 0.04740450f, -0.04065255f, 
    -0.02398630f, 0.02938667f, -0.02020195f, 0.04983936f, -0.00280597f, 0.12469180f, 0.02296608f, 0.05270354f, 
    0.50570977f, -0.22091247f, 0.29784065f, -0.01996085f, -0.09842049f, 0.05856817f, 0.09197155f, -0.05393286f, 
    0.02383309f, 0.04468491f, 0.02455822f, 0.08519804f, 0.04160701f, 0.13248257f, -0.01489794f, 0.03318860f, 
    0.12685744f, -0.04591412f, 0.01607207f, 0.02678773f, -0.21898410f, 0.02946413f, -0.16025351f, -0.21429300f, 
    0.07460134f, -0.10639616f, -0.07014608f, 0.01766825f, 0.07651927f, -0.00094919f, -0.01237008f, -0.07214856f, 
    -0.04087608f, -0.05069364f, -0.01505135f, 0.08327674f, 0.03789596f, 0.16752099f, 0.10448807f, 0.10407972f, 
    0.50895327f, -0.02146490f, -0.12241924f, 0.12405679f, 0.08720400f, 0.00701214f, -0.00407189f, 0.05258882f, 
    -0.05883397f, -0.05249552f, -0.05312899f, 0.04586729f, -0.00729847f, 0.05084486f, 0.01358102f, 0.14181289f, 
    0.10649907f, -0.14966792f, -0.03233008f, -0.13263388f, -0.42575970f, 0.06086114f, 0.05115584f, 0.07999580f, 
    0.14540780f, -0.07775825f, 0.07103066f, -0.15571392f, 0.06695683f, 0.05574990f, 0.00211160f, 0.09335338f, 
    0.01027688f, 0.03735181f, 0.02795464f, 0.02540659f, -0.02315508f, 0.07298315f, -0.02245711f, -0.06666267f, 
    -0.07447505f, 0.10945237f, 0.02711993f, 0.34534487f, 0.07608161f, -0.10188528f, 0.08187453f, 0.14298484f, 
    -0.13879788f, -0.06304407f, -0.00093985f, 0.07497188f, -0.00482129f, 0.11523056f, -0.05628946f, 0.08664354f, 
    0.02547062f, 0.13439073f, -0.03375183f, 0.01232335f, 0.19133107f, 0.29617685f, 0.14844020f, 0.00335870f, 
    -0.03190824f, 0.03339374f, 0.03233173f, -0.13221109f, 0.09689777f, -0.04619514f, 0.12326270f, -0.06717505f, 
    0.04105755f, 0.16553293f, -0.03138448f, -0.15261357f, 0.00176684f, 0.04399616f, 0.00288008f, -0.05903285f, 
    -0.20928572f, -0.10387922f, -0.10729726f, -0.03537496f, -0.10868789f, 0.11174633f, 0.13413285f, 0.11571094f, 
    -0.04986255f, 0.10877939f, -0.02834842f, -0.01127311f, -0.09810173f, 0.04487183f, -0.03924758f, 0.07389668f, 
    -0.04614186f, -0.03282293f, -0.13962127f, -0.10114501f, 0.32949749f, -0.18633398f, 0.16711964f, -0.11549547f, 
    0.12753846f, 0.01611285f, 0.08320849f, -0.06777617f, -0.05710058f, 0.06839442f, -0.06826477f, -0.02607996f, 
    0.02559607f, 0.00065971f, -0.09554895f, 0.00781422f, -0.00178376f, -0.09823664f, -0.02840061f, 0.01751242f, 
    0.25622374f, -0.18175682f, -0.03213886f, 0.11915790f, -0.00918637f, -0.06970485f, -0.03512052f, -0.09469055f, 
    0.20022880f, -0.05841823f, -0.06528913f, 0.00650216f, -0.10159830f, -0.01529896f, -0.08194354f, 0.11056062f, 
    -0.09735225f, 0.10276381f, 0.13605070f, 0.00177443f, 0.32144803f, -0.01263364f, -0.16138469f, -0.27631459f, 
    -0.04506472f, 0.08700042f, 0.08895404f, 0.02864322f, 0.10661498f, -0.03712906f, 0.06652264f, -0.06806760f, 
    0.06431776f, 0.03898507f, -0.15534651f, -0.06904531f, -0.00346497f, -0.05556476f, 0.02950736f, -0.04162361f, 
    0.23149972f, -0.19039351f, -0.10513783f, 0.01717187f, 0.18159962f, -0.01653624f, 0.11975375f, 0.02467165f, 
    -0.12613000f, -0.03320068f, 0.03331289f, 0.04129698f, -0.08807761f, -0.00230708f, -0.04742167f, -0.01308836f, 
    -0.01863869f, 0.03391590f, 0.02454565f, -0.00695924f, -0.21989197f, 0.32047489f, 0.00855219f, -0.23148958f, 
    0.26186070f, 0.04464194f, -0.03858458f, -0.09789252f, -0.10516618f, 0.00481285f, -0.02700690f, -0.03508258f, 
    0.01510402f, 0.03687484f, 0.00105591f, 0.05767552f, 0.04577751f, 0.12978496f, -0.04104631f, 0.08718452f, 
    0.21100542f, 0.08438382f, 0.00006410f, 0.01703026f, 0.09487059f, -0.10274076f, -0.01808795f, 0.08376984f, 
    0.05366229f, 0.09436790f, 0.07381517f, 0.09379879f, -0.04980537f, 0.05458177f, 0.11548997f, -0.00796073f, 
    0.06024316f, 0.02414154f, 0.07796211f, 0.02705531f, -0.05447229f, -0.09515791f, 0.10522442f, -0.20468032f, 
    -0.16533107f, -0.02619214f, -0.05051868f, -0.00972706f, -0.02220793f, -0.11854580f, -0.06715593f, -0.02025859f, 
    0.11090822f, 0.03425203f, -0.08202191f, 0.13503963f, -0.08300878f, 0.08312855f, -0.07643910f, 0.09418458f, 
    0.26775908f, -0.18043172f, -0.10529390f, -0.15597972f, -0.08585341f, 0.07385916f, -0.00959740f, 0.02585592f, 
    -0.10111394f, 0.12174217f, 0.03007679f, -0.00493914f, 0.03594844f, -0.02179371f, 0.01380104f, 0.09609114f, 
    -0.01224855f, 0.05163215f, -0.03035842f, 0.06432906f, -0.14843854f, -0.06369872f, -0.01186733f, -0.05417382f, 
    0.14750321f, -0.00825795f, -0.14528929f, -0.01579584f, 0.10535026f, 0.04253160f, 0.06789277f, -0.04370382f, 
    0.06774673f, 0.12801386f, 0.08544472f, -0.04902415f, 0.08573205f, -0.08372798f, -0.01490319f, -0.00430206f, 
    0.49123052f, -0.05197599f, -0.05541971f, -0.05929859f, -0.02154416f, 0.06032949f, 0.07210963f, -0.02869705f, 
    -0.02673010f, 0.06660868f, 0.01875736f, 0.06049513f, 0.03217009f, 0.03382220f, -0.06890613f, -0.08044507f, 
    0.00319980f, 0.00333363f, -0.10438883f, -0.06556093f, -0.21510161f, -0.17987677f, -0.12750441f, -0.34248254f, 
    -0.20435745f, -0.02278840f, -0.02428428f, 0.04111340f, 0.01420362f, -0.00326033f, -0.03251291f, 0.10479351f, 
    0.09099477f, 0.11545334f, 0.09692498f, -0.05339189f, 0.05136013f, -0.03137182f, -0.00827460f, -0.13632940f, 
    0.32434624f, 0.04306729f, 0.27822098f, 0.00515592f, 0.25919777f, 0.17656119f, 0.11142314f, 0.04816993f, 
    0.02304095f, 0.01818025f, 0.01744482f, -0.03489346f, 0.09726768f, -0.09404974f, -0.00238285f, 0.11021309f, 
    0.00737084f, -0.04417097f, 0.02605700f, 0.08596504f, -0.30317605f, -0.13233474f, 0.08598110f, -0.16359927f, 
    -0.09552225f, 0.13211712f, 0.06780013f, -0.01460741f, -0.10213429f, 0.04596449f, 0.13133039f, 0.08608381f, 
    0.02787458f, 0.07149705f, -0.04949212f, 0.08548445f, 0.00249843f, -0.04233718f, 0.02035881f, 0.11734648f, 
    -0.06514756f, -0.10091821f, 0.05013434f, -0.11984316f, 0.02660311f, 0.10458113f, 0.03057834f, -0.06432196f, 
    -0.03513939f, 0.02447352f, 0.09691036f, 0.02734615f, 0.06600206f, 0.08470619f, -0.10543466f, 0.05391736f, 
    0.11698369f, -0.10626594f, 0.01781783f, 0.06593335f, -0.43962473f, -0.03399126f, 0.27011982f, -0.16607094f, 
    -0.03825926f, -0.13741143f, -0.16854948f, -0.05377126f, -0.06394993f, 0.11150087f, 0.10793999f, -0.06818658f, 
    0.04373462f, 0.06358682f, 0.05698317f, -0.00589249f, 0.09004758f, -0.12210862f, 0.12119941f, 0.02780783f, 
    0.39371783f, 0.16752367f, 0.25157404f, 0.16791332f, 0.35965744f, 0.08138960f, 0.00225046f, -0.05556168f, 
    0.12109443f, 0.01707518f, 0.06869569f, -0.01971075f, 0.02125608f, 0.12558438f, -0.00232239f, -0.10297437f, 
    -0.05131048f, -0.03434335f, 0.04254582f, -0.05599932f, 0.24639052f, 0.06320594f, 0.09228108f, -0.05730999f, 
    0.32999268f, -0.14820735f, -0.09633627f, -0.13739376f, -0.00969082f, 0.11852796f, 0.05912307f, 0.00862602f, 
    -0.08515847f, 0.01828261f, 0.04477939f, 0.07448677f, 0.01888575f, -0.04215414f, -0.08458910f, 0.01923421f, 
    0.06270047f, 0.06088785f, -0.18825214f, -0.05257812f, 0.02054485f, 0.11811562f, 0.08348650f, -0.02246005f, 
    -0.17540289f, 0.04684609f, 0.06661081f, -0.02139644f, 0.06837814f, 0.00533464f, -0.00365690f, -0.06637082f, 
    0.00922702f, 0.06054228f, -0.03925586f, -0.01825029f, -0.18163548f, 0.24979335f, 0.15581551f, -0.07072769f, 
    -0.10814789f, 0.19423996f, 0.00272695f, 0.01094125f, -0.04132287f, -0.07670287f, 0.10434946f, -0.00339569f, 
    0.01191773f, -0.13786906f, 0.04887281f, 0.07470195f, 0.04856257f, -0.07303943f, -0.08719792f, -0.07743003f, 
    0.23192033f, -0.15583631f, 0.19165726f, -0.15047528f, 0.09520100f, -0.06884782f, 0.04859092f, 0.02989822f, 
    0.08362237f, 0.01667199f, 0.06004791f, -0.11057761f, -0.04602308f, -0.01369909f, 0.06294173f, 0.08324108f, 
    0.01799070f, -0.04451466f, 0.07692751f, 0.10650644f, -0.02856917f, -0.17074142f, -0.19052111f, -0.19941680f, 
    -0.28978780f, -0.00328086f, 0.04390812f, -0.00233607f, 0.05158240f, 0.03571528f, -0.05127170f, 0.03441482f, 
    -0.03158924f, 0.06759427f, 0.06582002f, 0.00069320f, -0.01082023f, 0.06952393f, -0.00925018f, 0.07587828f, 
    -0.00260280f, -0.03164534f, 0.03409485f, 0.01127526f, -0.03519411f, -0.00543837f, -0.02920422f, 0.02135790f, 
    -0.04593151f, 0.02739943f, -0.04585839f, -0.04344089f, -0.04731874f, 0.01428297f, -0.05398786f, -0.04558713f, 
    0.00314628f, -0.03172914f, -0.00015477f, 0.03712305f, -0.05579803f, 0.03730433f, 0.00197611f, 0.00428307f, 
    -0.05052440f, -0.02377290f, 0.01595392f, -0.02877462f, -0.02884502f, -0.05845794f, -0.02543247f, -0.00521971f, 
    -0.04445599f, 0.02405884f, -0.01646872f, -0.02861901f, 0.04375473f, 0.03791246f, 0.03979854f, 0.00133622f, 
    -0.00236546f, 0.03681151f, -0.05303510f, -0.03541370f, -0.01183787f, -0.01452908f, 0.02068508f, -0.03908909f, 
    -0.05013130f, 0.02311378f, 0.04528360f, -0.01451718f, 0.01589406f, 0.03318094f, -0.03068067f, -0.01362250f, 
    0.04258097f, -0.05869677f, -0.04421258f, 0.02973381f, 0.02296016f, -0.06337959f, -0.00466647f, 0.03853451f, 
    -0.01819624f, 0.05500957f, 0.02483826f, 0.03755976f, -0.04682012f, -0.02068644f, 0.05007917f, -0.00492554f, 
    -0.04343477f, -0.01632706f, 0.05342781f, -0.03979580f, 0.02738994f, 0.02331778f, -0.01140723f, -0.04640713f, 
    -0.00167172f, 0.05704379f, 0.04522893f, -0.05075637f, 0.01191569f, -0.05457471f, -0.05264563f, -0.02257623f, 
    -0.00151857f, 0.04185137f, -0.04185680f, 0.03432296f, -0.04805194f, 0.03580621f, -0.04899847f, 0.00369715f, 
    -0.02663155f, 0.02393503f, -0.04683934f, -0.05738546f, 0.01286898f, -0.04469933f, -0.01036109f, 0.03884931f, 
    0.04780665f, 0.00538673f, -0.01855338f, -0.04882447f, -0.00986516f, 0.03675029f, -0.02050875f, -0.00762632f, 
    -0.04957612f, -0.01098550f, 0.00473797f, -0.04919219f, -0.01642734f, 0.04664017f, -0.02051633f, -0.04421946f, 
    0.00772438f, -0.05638536f, 0.03229625f, -0.01121131f, 0.03514767f, -0.04588614f, -0.00517229f, -0.02586279f, 
    0.02652596f, -0.02141240f, 0.04589113f, -0.02364979f, -0.01666900f, -0.05051031f, 0.03047043f, 0.00272083f, 
    -0.05734101f, 0.03538086f, -0.01001640f, -0.06298074f, 0.03867148f, -0.05528510f, 0.04993293f, -0.00687636f, 
    0.01657118f, 0.03267527f, -0.03717825f, 0.05157178f, 0.01319199f, 0.02994550f, -0.03579769f, -0.01927269f, 
    -0.01453462f, 0.02559106f, -0.05168455f, 0.00083093f, -0.00629383f, 0.00382129f, -0.03577516f, -0.05822964f, 
    0.00786060f, -0.01796608f, -0.04450449f, 0.01024397f, -0.04659977f, 0.01867012f, -0.05653393f, -0.03170884f, 
    -0.00774468f, 0.01286252f, -0.00075430f, 0.03970098f, 0.04420599f, -0.00940177f, -0.03296101f, -0.02334017f, 
    -0.03459239f, -0.03637594f, 0.02038109f, -0.02237960f, 0.01991128f, -0.06420077f, -0.05495753f, -0.02633780f, 
    -0.05154373f, -0.02048449f, -0.03753930f, -0.00991357f, -0.05448935f, -0.02572745f, 0.00203311f, 0.01160349f, 
    -0.00818582f, -0.00404242f, -0.02637896f, 0.03899331f, -0.05789784f, 0.03943843f, -0.04104717f, 0.02269644f, 
    -0.04177748f, 0.04237498f, -0.04482204f, -0.00033065f, 0.03485838f, 0.03676796f, 0.00559751f, 0.02229067f, 
    -0.00293304f, 0.01731843f, -0.00807323f, -0.01749252f, -0.04550789f, -0.04549234f, -0.01937232f, -0.01594789f, 
    0.00983470f, 0.02157716f, -0.03417087f, 0.01596747f, 0.00820528f, -0.06161847f, 0.03388867f, -0.04710970f, 
    0.01957667f, 0.02828987f, 0.00094782f, -0.01187424f, -0.00514481f, 0.03508094f, 0.02701226f, -0.01167175f, 
    0.01055718f, -0.04192577f, 0.05123718f, 0.05368009f, 0.00018821f, 0.03186754f, -0.02657276f, -0.03839511f, 
    0.04673245f, -0.02180772f, 0.00471346f, -0.03865725f, -0.05518144f, -0.01586611f, -0.04170050f, -0.00745494f, 
    -0.04298854f, -0.00162713f, 0.03643579f, 0.04899737f, -0.03569140f, -0.05044108f, -0.01082129f, -0.00224046f, 
    -0.00389123f, 0.00348483f, 0.00271580f, 0.02117372f, 0.02107033f, 0.01587585f, 0.04278103f, 0.04200147f, 
    0.00108821f, -0.01581118f, -0.06096128f, 0.02844718f, 0.01582514f, -0.01037117f, 0.03761042f, -0.05345890f, 
    0.00699399f, 0.03965946f, -0.04023146f, -0.01231375f, -0.01833183f, 0.01873156f, -0.04687985f, 0.01368433f, 
    -0.01246552f, -0.03559382f, -0.00508841f, 0.04545432f, -0.05998450f, -0.00961816f, 0.02869012f, -0.03017211f, 
    0.03543562f, 0.02522480f, 0.03249086f, -0.02351744f, 0.03306170f, -0.04139871f, -0.00336916f, 0.03022736f, 
    -0.01651692f, 0.03054708f, 0.00722500f, -0.01608364f, 0.03413669f, -0.04357647f, -0.02548616f, 0.04618130f, 
    0.04215164f, -0.02731202f, 0.04515126f, 0.00268464f, 0.01905373f, -0.01077822f, -0.01495920f, -0.01045376f, 
    0.01864928f, -0.00854891f, 0.02712820f, -0.02164453f, -0.01234221f, -0.03752988f, -0.04698454f, -0.01074990f, 
    -0.27261379f, 0.33104110f, 0.05638696f, -0.03181925f, -0.09732702f, -0.03231388f, 0.06634203f, 0.02829817f, 
    0.18271908f, 0.03218070f, 0.02399516f, -0.02969889f, 0.03048826f, -0.06462003f, 0.05538081f, 0.02095949f, 
    0.06215272f, 0.09473901f, -0.04544807f, 0.00993866f, 0.10175376f, 0.11086744f, 0.11017561f, -0.02161831f, 
    0.00743533f, 0.07965516f, 0.03130021f, -0.03946381f, 0.20889702f, 0.06949915f, 0.08166049f, -0.01746824f, 
    0.06577884f, 0.06049784f, 0.14697632f, 0.14447105f, 0.09492292f, 0.03119485f, -0.02231910f, 0.02876803f, 
    -0.02179536f, 0.06678930f, -0.02602585f, 0.02571321f, -0.19783667f, -0.08499625f, 0.08778042f, -0.00646297f, 
    -0.01539217f, -0.12283049f, -0.03187286f, 0.10006029f, -0.14635080f, 0.05969615f, -0.03246962f, -0.10744938f, 
    0.00777865f, 0.11608260f, 0.05072814f, 0.00389008f, -0.19874234f, -0.09264362f, -0.24130635f, 0.07233955f, 
    -0.26175708f, -0.09250102f, -0.08779778f, -0.12961608f, -0.02514200f, 0.08105605f, 0.10429030f, 0.03479358f, 
    0.08371913f, -0.03074968f, -0.08467758f, -0.06085593f, -0.07763182f, -0.12211409f, 0.01753517f, -0.07671514f, 
    -0.51728874f, 0.64751351f, -0.39727637f, -0.06925283f, 0.21821225f, -0.08205226f, 0.01831482f, 0.05580705f, 
    0.12471490f, -0.03161832f, 0.04724585f, -0.02162588f, 0.03767899f, -0.04924860f, -0.02638266f, 0.04084708f, 
    -0.05774862f, 0.06731103f, -0.05605887f, 0.07069702f, 0.19201821f, -0.00557899f, 0.05820376f, 0.08657980f, 
    -0.09052585f, -0.12391099f, 0.03111937f, 0.12222074f, -0.11613423f, -0.00065827f, 0.08211790f, -0.00855959f, 
    0.03083390f, 0.12550181f, -0.01460072f, -0.05617941f, 0.02340659f, -0.08777694f, -0.03647811f, -0.01810868f, 
    -0.16194054f, -0.20997764f, -0.00068751f, 0.04423445f, -0.05529134f, 0.09658653f, 0.06013186f, 0.07146753f, 
    0.08989511f, 0.14545780f, 0.10075319f, -0.01560407f, 0.01538404f, -0.12327684f, 0.01977501f, -0.11174327f, 
    -0.04902780f, 0.05434059f, 0.01926361f, 0.07973433f, 0.47307393f, -0.11261175f, -0.05307256f, -0.02918406f, 
    -0.09135856f, 0.04886144f, 0.00058235f, 0.07197554f, -0.05483133f, -0.03709362f, 0.03587966f, -0.05910977f, 
    -0.10721536f, 0.01459943f, -0.05460491f, 0.07394339f, 0.07671453f, -0.08569141f, 0.03708881f, 0.02314414f, 
    0.25465870f, 0.05267079f, -0.06739790f, -0.37774733f, -0.19597627f, -0.19485170f, -0.04997632f, -0.04788548f, 
    0.03954988f, -0.03365191f, 0.03926279f, -0.08110727f, -0.02499569f, 0.03628692f, 0.06172518f, -0.09572308f, 
    0.03422022f, -0.05494713f, -0.02722668f, -0.00793264f, 0.07034682f, -0.07709335f, -0.10290778f, -0.05554901f, 
    0.05363218f, 0.01300097f, -0.08358452f, 0.21937543f, -0.00245653f, 0.12987377f, 0.06567512f, 0.11638050f, 
    -0.03936577f, -0.05644377f, 0.01313326f, 0.03287278f, 0.00657916f, 0.02916818f, -0.03175684f, 0.08392610f, 
    0.01474459f, -0.09874655f, 0.09236985f, -0.05791533f, -0.09873112f, 0.07232348f, 0.02097325f, -0.03266570f, 
    0.09611443f, 0.13652064f, 0.03683383f, 0.01153834f, 0.07999793f, 0.03268418f, 0.04950904f, -0.09271602f, 
    0.08261713f, -0.01797610f, 0.03743295f, -0.02833763f, 0.03619580f, 0.07921512f, -0.16079764f, 0.06161484f, 
    -0.13914406f, -0.05709103f, -0.04198736f, 0.02564387f, 0.09968682f, -0.11755434f, 0.09704120f, -0.03109945f, 
    0.03173332f, -0.09070978f, 0.12225312f, 0.01803016f, 0.02447241f, 0.06615246f, -0.01680658f, -0.01883271f, 
    -0.20952500f, 0.27932698f, -0.02826092f, 0.07106705f, 0.01173594f, 0.02074057f, 0.05975129f, 0.07960083f, 
    -0.08810658f, 0.05251995f, 0.10767249f, 0.02825783f, 0.12110410f, 0.04143412f, 0.12468709f, 0.02566343f, 
    0.08882696f, -0.09103456f, 0.05102874f, -0.06771189f, 0.10101756f, 0.13043098f, -0.08171924f, 0.16084072f, 
    0.35229144f, 0.10388254f, 0.06390385f, 0.01070927f, -0.06152050f, 0.04293682f, 0.06409841f, 0.05909336f, 
    0.08517917f, 0.04400823f, 0.14870100f, 0.07245141f, 0.05849119f, 0.06180937f, -0.09895893f, 0.06534948f, 
    0.16222563f, 0.08007412f, -0.13433927f, 0.04277091f, -0.20097657f, 0.03509415f, -0.13161966f, -0.03641878f, 
    -0.03125998f, -0.03743734f, 0.02133341f, -0.03327025f, 0.18353501f, 0.04655795f, -0.01000254f, 0.02970615f, 
    0.07620736f, 0.03332242f, -0.02270797f, -0.01779038f, 0.13148102f, -0.18446128f, 0.01078405f, 0.10770071f, 
    -0.08955462f, 0.09539713f, -0.01350419f, 0.03831756f, 0.06962906f, 0.00859799f, 0.10938168f, 0.03586962f, 
    0.11206210f, 0.06258864f, 0.01830831f, -0.03346779f, 0.05224100f, -0.00120402f, 0.02702283f, -0.01732277f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04368063f, 0.08747412f, -0.03506726f, -0.02466852f, -0.06558570f, 0.01903182f, -0.03271300f, 0.05783616f, 
    -0.00130411f, 0.00990260f, 0.03207609f, 0.04565894f, 0.00434300f, -0.04396816f, 0.04024586f, -0.03881925f, 
    0.08078279f, -0.02121730f, -0.01284862f, 0.01233235f, -0.02078308f, 0.07473782f, -0.03245800f, -0.04088379f, 
    0.03112605f, 0.05890733f, -0.03720514f, -0.03051715f, -0.01227822f, 0.14017007f, 0.01238040f, -0.02463987f, 
    -0.05833417f, 0.09035861f, -0.00472876f, 0.00439665f, 0.00107082f, 0.03331459f, 0.05473631f, -0.10552358f, 
    0.00360457f, 0.01454791f, 0.00424870f, -0.02970222f, -0.04408075f, 0.02319854f, -0.03715236f, -0.05437823f, 
    -0.01578196f, -0.02224419f, -0.02932276f, 0.01280066f, 0.02011883f, -0.04936291f, 0.09476883f, -0.01522576f, 
    -0.04885859f, -0.05450794f, 0.03820462f, 0.03744023f, -0.01435926f, 0.04321422f, -0.00457741f, 0.12889373f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.09393763f, -0.58092934f, -0.25054029f, 0.02682555f, 0.04943946f, -0.42513183f, 0.18520552f, 0.25272840f, 
    0.27432206f, 0.16977981f, 0.05025916f, -0.07287668f, -0.14347281f, -0.00037675f, -0.39731297f, 0.00028284f, 
    -0.56180662f, -0.04561074f, -0.04240342f, 0.01561942f, 0.27573153f, -0.52335489f, 0.25528616f, -0.27609423f, 
    0.24022996f, -0.63534009f, 0.04339720f, 0.21639624f, -0.11159153f, -0.01202952f, -0.02310932f, 0.04424486f, 
    0.01923839f, -0.09380560f, -0.00483457f, 0.05657575f, -0.11085574f, -0.06571954f, -0.08471598f, 0.21218404f, 
    -0.15615110f, -0.09192927f, 0.06072890f, 0.03937187f, -0.34686247f, -0.14381979f, -0.06739942f, 0.03785064f, 
    0.29670075f, 0.10432063f, -0.08560798f, -0.60333991f, -0.00402371f, 0.11569670f, 0.22720754f, 0.30898941f, 
    0.05914056f, -0.06121880f, -0.03449979f, 0.05025212f, -0.24543773f, -0.11802369f, 0.04226349f, 0.08777159f, 
    -0.06901097f, 0.08551297f, -0.08250548f, -0.13987938f, -0.05684199f, 0.38813320f, -0.40089968f, 0.32397419f, 
    -0.33232099f, -0.09225453f, -0.09637648f, -0.00741928f, -0.61367214f, -0.10914726f, -0.15307137f, 0.07501020f, 
    -0.23026884f, -0.04798030f, 0.02692360f, 0.01773676f, -0.66049820f, 0.01782756f, -0.00527820f, -0.29642057f, 
    0.12902887f, -0.36013645f, -0.06008085f, 0.09545030f, -0.06476071f, -0.09298062f, -0.06296276f, 0.06486902f, 
    0.09480196f, 0.20443748f, 0.07613983f, 0.16134529f, 0.08877651f, 0.00910723f, -0.26621661f, -0.47098851f, 
    0.36948106f, 0.04270045f, 0.02668504f, 0.10051928f, -0.16911583f, -0.05048138f, 0.08033722f, -0.07257179f, 
    0.26039565f, -0.22047392f, -0.06697222f, 0.29726693f, -0.02913059f, -0.00835582f, 0.28486317f, 0.20955455f, 
    -0.04909800f, -0.01945725f, -0.05296781f, 0.27037424f, -0.06292374f, 0.15086927f, -0.09151150f, 0.11436433f, 
    -0.10725388f, -0.13026421f, 0.43190771f, -0.02303657f, 0.18251812f, 0.20173913f, 0.27579445f, 0.27220315f, 
    -0.07356961f, -0.06899931f, 0.03288795f, -0.07798609f, -0.00747860f, 0.05749280f, -0.11586778f, -0.09525475f, 
    0.05241784f, 0.27477121f, 0.03861327f, 0.00649303f, -0.38916466f, 0.09607159f, -0.25247791f, 0.07842912f, 
    -0.45068187f, 0.29158947f, 0.08016616f, -0.05389393f, 0.17980205f, -0.13621210f, -0.04268197f, -0.09139567f, 
    -0.09651169f, -0.22727320f, 0.05632768f, 0.27204710f, 0.09594036f, -0.12493801f, -0.32321274f, -0.08911148f, 
    -0.22295535f, -0.32820350f, -0.02310912f, -0.52353734f, 0.09993516f, 0.14322090f, 0.00457793f, -0.03102445f, 
    -0.18224287f, 0.21924175f, -0.08192165f, -0.58939356f, 0.17499264f, 0.01006753f, 0.18013798f, 0.16913860f, 
    0.05256472f, 0.00178812f, -0.06413105f, 0.04367282f, -0.14075688f, 0.31335920f, -0.03658681f, 0.06293212f, 
    0.00207085f, 0.07999089f, 0.03338318f, 0.18754822f, 0.38647342f, 0.18471232f, 0.26959518f, -0.11773462f, 
    -0.34430712f, -0.42103645f, 0.00096143f, -0.03044594f, -0.24155961f, -0.07824168f, -0.20724495f, -0.09365153f, 
    0.06786694f, -0.11824100f, 0.08077535f, 0.08853641f, -0.04358870f, -0.42619026f, -0.05729058f, -0.01835445f, 
    -0.20921695f, -0.00109353f, 0.07927578f, -0.03258282f, -0.22411057f, 0.26049811f, 0.01778706f, -0.06679835f, 
    -0.06194522f, -0.17332137f, 0.04312317f, 0.40728557f, -0.03305846f, -0.06129938f, -0.14922145f, 0.17328988f, 
    -0.40602323f, 0.13569710f, 0.01517986f, 0.24592544f, 0.29077670f, 0.20835049f, 0.10161750f, 0.07279960f, 
    -0.04409943f, -0.20874552f, 0.09989227f, 0.24097562f, 0.06430530f, 0.08959646f, -0.59873748f, 0.41323939f, 
    0.10975510f, 0.11821657f, 0.06349206f, -0.52573377f, -0.07845043f, -0.72226697f, -0.03550193f, 0.19445951f, 
    -0.04676845f, -0.50672579f, 0.26277161f, 0.16029751f, -0.07116324f, 0.17755924f, -0.19814785f, -0.00084379f, 
    0.16824830f, -0.13737851f, -0.12026706f, 0.00132101f, 0.21700060f, 0.10154554f, 0.20351309f, -0.12603801f, 
    0.14544921f, -0.11896222f, -0.07919098f, -0.02418019f, 0.25439593f, -0.01972291f, -0.15363756f, -0.36769679f, 
    -0.23878275f, 0.12419578f, 0.05891161f, -0.29897797f, -0.00749519f, 0.21180527f, -0.02493620f, -0.02090083f, 
    0.08018234f, 0.31176150f, 0.04930571f, -0.29189146f, -0.06132348f, 0.06789045f, -0.13169192f, 0.33268663f, 
    0.02573068f, 0.33194578f, -0.03586887f, 0.24418867f, 0.01745628f, 0.34136665f, -0.09132129f, 0.06780971f, 
    -0.01178645f, -0.19233806f, -0.06078075f, 0.04263121f, -0.27131417f, -0.08120404f, -0.22664127f, -0.28177416f, 
    0.00616467f, -0.07036267f, -0.02822898f, 0.06244418f, -0.46750253f, -0.11037922f, 0.03842894f, 0.13914505f, 
    0.11597843f, 0.09137696f, -0.28762653f, -0.25876948f, -0.41793630f, 0.11750957f, -0.35220432f, -0.45349991f, 
    -0.28096643f, -0.27740765f, -0.05096411f, -0.01296457f, 0.34081382f, 0.06491853f, -0.15800123f, 0.00577621f, 
    0.24555509f, -0.05690571f, -0.12723775f, 0.04378313f, 0.02880413f, 0.25265241f, 0.22455321f, 0.20494305f, 
    0.21830793f, -0.06017508f, -0.00655062f, -0.08710369f, 0.13161284f, 0.05980305f, -0.10369903f, 0.05099194f, 
    -0.09310284f, 0.09624213f, 0.03825688f, -0.05058858f, -0.04215382f, 0.08985037f, -0.14206389f, 0.21000287f, 
    -0.17505327f, 0.28442267f, -0.04032826f, -0.14521675f, -0.84453249f, -0.45179367f, -0.00412864f, -0.05060165f, 
    0.25772163f, -0.05848061f, 0.03906826f, -0.11245978f, 0.27238944f, 0.09041559f, 0.14432488f, -0.28138372f, 
    -0.09511950f, 0.06760544f, -0.10339952f, 0.06054983f, -0.02129812f, -0.09256265f, 0.08297775f, 0.03156019f, 
    -0.00202394f, 0.24884252f, -0.06149771f, -0.50422812f, -0.14118640f, -0.37160876f, -0.51094669f, -0.10978977f, 
    0.39374661f, 0.21861514f, -0.11574874f, -0.10630809f, -0.12804638f, 0.04215719f, 0.27710408f, 0.09146307f, 
    -0.03359057f, 0.30820850f, -0.07901303f, -0.03000275f, 0.17366983f, 0.11409324f, -0.28438208f, 0.29237086f, 
    -0.25969988f, -0.02588749f, -0.01205998f, 0.15974131f, -0.36635125f, -0.06405467f, 0.08329047f, -0.08094611f, 
    0.09829597f, -0.24115585f, 0.07249263f, 0.25431663f, 0.00443722f, -0.01076560f, 0.35767773f, 0.02800153f, 
    0.05285947f, 0.21816970f, 0.07460472f, 0.02983445f, 0.18336961f, -0.25476333f, 0.13701332f, 0.08856753f, 
    -0.09837296f, -0.09426610f, -0.09770628f, -0.18989818f, -0.12369101f, -0.10013073f, -0.29075453f, 0.34949511f, 
    -0.06271583f, 0.01281352f, -0.06985768f, -0.11920474f, 0.21813083f, 0.08955607f, -0.05055840f, -0.24388352f, 
    -0.03005041f, 0.05396726f, 0.30560261f, 0.28754947f, 0.15785167f, -0.10084619f, 0.05089313f, -0.42966729f, 
    -0.54830480f, -0.25777751f, 0.09289199f, -0.05670004f, 0.18249223f, 0.04394301f, -0.03372065f, 0.01774836f, 
    -0.11689192f, 0.25999123f, -0.00102445f, -0.08519720f, 0.12375093f, -0.06863273f, 0.03762635f, 0.25284609f, 
    -0.04866641f, 0.10022371f, -0.00128901f, -0.11420917f, 0.05417373f, -0.46986395f, 0.01412825f, 0.08039849f, 
    0.08095147f, -0.29133978f, 0.04469540f, -0.23579781f, -0.06303179f, -0.07852545f, -0.43226022f, 0.20936495f, 
    0.19368757f, -0.18378328f, 0.01414825f, 0.03480995f, 0.10949079f, 0.04790198f, -0.03379948f, 0.03278720f, 
    -0.29572624f, 0.29618004f, 0.00746101f, 0.24128315f, 0.16291183f, 0.03138465f, -0.14995153f, -0.30298668f, 
    0.01086518f, 0.10626292f, 0.06277522f, -0.28954071f, 0.28947470f, -0.09312648f, -0.11358972f, -0.56020540f, 
    0.00122557f, 0.17908692f, -0.15188158f, -0.22121193f, -0.25705165f, 0.14288135f, -0.18264452f, -0.34946766f, 
    -0.18518136f, 0.24035650f, 0.03733860f, 0.11050618f, -0.05027920f, -0.05174426f, -0.40925160f, -0.10462026f, 
    -0.11981557f, -0.49051961f, -0.02407153f, -0.03664122f, -0.20487948f, 0.18662724f, 0.20045274f, -0.12522212f, 
    0.20400654f, 0.33529294f, -0.05910087f, -0.59507686f, -0.49136341f, -0.01296011f, -0.02666380f, 0.05236220f, 
    -0.12455199f, 0.14517631f, 0.05899607f, 0.16058256f, 0.03238531f, -0.00864976f, 0.02125248f, 0.09109092f, 
    -0.24313045f, -0.15995824f, 0.01787267f, -0.36875620f, -0.06087312f, 0.38220245f, 0.01058805f, -0.11667183f, 
    0.08837672f, 0.36555192f, -0.03298366f, 0.03391736f, -0.42948598f, 0.03982148f, 0.12691922f, -0.15577695f, 
    -0.04322565f, 0.08232175f, 0.10165016f, 0.03126488f, 0.20660861f, 0.26389509f, -0.04250051f, -0.22793731f, 
    0.05987262f, 0.14509456f, -0.54660249f, 0.05457362f, -0.07897688f, -0.53220850f, 0.46263334f, -0.06803402f, 
    -0.02581020f, 0.29150724f, 0.06775796f, -0.11979777f, -0.04461780f, -0.09767719f, 0.33292744f, -0.09317736f, 
    -0.00696341f, 0.15534571f, 0.01158977f, -0.10469531f, 0.24419257f, 0.25781304f, 0.15956707f, -0.37310466f, 
    -0.07255490f, -0.10828874f, -0.01519477f, -0.04561497f, 0.40575236f, 0.23371972f, 0.05594488f, -0.00698381f, 
    -0.02604431f, 0.12259047f, 0.10545416f, -0.42898425f, 0.05174005f, 0.08213250f, -0.09135830f, -0.33428627f, 
    -0.17651491f, -0.26975623f, -0.06956878f, -0.18052007f, 0.14175008f, 0.04087060f, 0.05841799f, -0.09541195f, 
    -0.03220017f, 0.23015381f, -0.01178665f, -0.30169672f, 0.14526862f, 0.04109563f, -0.37377533f, -0.52208543f, 
    0.03211887f, 0.06233399f, -0.01633879f, 0.13769755f, 0.32802692f, -0.02418025f, 0.08055951f, -0.46508622f, 
    0.05187904f, 0.19780828f, -0.01212355f, 0.12869193f, 0.09702411f, -0.24220085f, -0.15712313f, 0.26020479f, 
    -0.45879337f, 0.11839435f, 0.11084961f, -0.11324015f, -0.37307942f, -0.12492891f, 0.33821329f, 0.09529893f, 
    -0.13499181f, -0.48407525f, 0.01392564f, 0.01563739f, -0.16024658f, -0.38685906f, 0.26336151f, 0.24918287f, 
    0.17908326f, 0.26247570f, 0.10672642f, -0.23818249f, -0.05826710f, 0.20750284f, 0.03377337f, -0.04526208f, 
    -0.03613133f, -0.03928334f, 0.11183759f, -0.16328607f, 0.00906620f, 0.10979557f, 0.31706271f, -0.31532910f, 
    0.13172114f, -0.34131595f, -0.11387739f, -0.31353062f, 0.16199805f, -0.14679745f, 0.06835469f, 0.07433154f, 
    -0.16998442f, -0.67364103f, -0.02904541f, 0.28190309f, 0.26666671f, 0.04587348f, 0.01102606f, -0.21339926f, 
    0.10288741f, 0.05842355f, -0.10687469f, -0.04498684f, -0.33911824f, -0.15103163f, -0.13135596f, 0.30161834f, 
    -0.01092076f, -0.11125606f, -0.17315044f, 0.08997253f, -0.28000283f, 0.01597328f, 0.28844774f, 0.07100520f, 
    0.24560690f, -0.18479818f, -0.04298482f, -0.06303803f, 0.31789061f, -0.10560273f, -0.29120484f, -0.02876694f, 
    0.12547275f, 0.15037994f, -0.12611966f, 0.05661969f, -0.22448336f, -0.78225100f, -0.24910821f, 0.10143649f, 
    0.23643959f, 0.13060041f, -0.03306120f, 0.27232283f, -0.31256333f, 0.16863869f, 0.03391715f, -0.01470145f, 
    -0.09839258f, -0.32512885f, -0.06698873f, -0.47215864f, -0.02794465f, 0.10944443f, 0.20592144f, -0.09311207f, 
    0.20525464f, -0.02563284f, -0.06779946f, 0.24707332f, 0.09135154f, -0.27435467f, 0.02059791f, -0.03167068f, 
    -0.32776350f, 0.17241047f, 0.08245987f, -0.09242757f, -0.25662905f, 0.08919004f, 0.35695603f, -0.43255678f, 
    0.00028376f, -0.11254013f, -0.12114234f, -0.31639287f, 0.38453579f, -0.26536438f, 0.08986224f, 0.23352340f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05487561f, 0.05324386f, -0.03636824f, 0.07533743f, -0.04199579f, -0.05780477f, -0.01059998f, -0.04720262f, 
    0.02269218f, -0.00441368f, 0.06948164f, 0.11694830f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
