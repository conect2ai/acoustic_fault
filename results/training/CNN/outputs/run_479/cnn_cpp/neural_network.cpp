#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.45949900f, 0.27052274f, -0.37945467f, 0.36776003f, 0.55007643f, 0.03285199f, -0.36990723f, 0.26318103f, 
    0.25247160f, 0.52361679f, -0.62116408f, 0.45370889f, -0.22245665f, -0.37656015f, -0.46472034f, -0.33130312f, 
    -0.06931308f, -0.42754680f, 0.17353195f, 0.68059808f, 0.81966865f, 0.09220964f, -0.04712980f, 0.20230284f, 
    -0.21678317f, 0.11667956f, -0.10552502f, 0.83186632f, 0.58309966f, 0.25190824f, -0.33075812f, 0.46946201f, 
    -0.26881933f, 0.36053985f, -0.13520913f, 0.00858174f, 0.67772114f, 0.49012411f, 0.35306254f, -0.35106504f, 
    -0.42446545f, -0.32927036f, 0.16817960f, 0.42597294f, -0.32546908f, -0.52083850f, 0.12648821f, -0.41241422f, 
    -0.21814907f, 0.85711026f, -0.36652941f, -0.09559816f, -0.04633516f, -0.13509525f, 0.34793136f, -0.55197102f, 
    0.44347504f, 0.72583419f, 0.25377801f, 0.67387438f, 0.06809714f, -0.54774594f, -0.16486703f, 0.14028783f, 
    -0.16573216f, 0.63061780f, -0.74216104f, -0.28869206f, -0.23751749f, 0.09977280f, 0.05141987f, 0.25941786f, 
    -0.29209429f, 0.27487355f, 0.53144681f, -0.95495045f, -0.00034893f, -0.67189884f, 0.33205646f, 0.47045690f, 
    -0.10978097f, -0.65702599f, -0.10786697f, 0.45295036f, 0.55903006f, 0.49762774f, 0.39257351f, 0.44437811f, 
    0.40464815f, 0.04262670f, -0.32409120f, 0.25328320f, -0.44967422f, 0.64587271f, -0.75683945f, 0.28498337f, 
    -0.07263717f, -0.07106587f, -0.05398453f, -0.42161858f, -0.43814012f, 0.02268125f, 0.53871155f, 0.80816895f, 
    -0.39430884f, -0.04637916f, 0.10763956f, -0.18386185f, 0.50359184f, 0.24277389f, 0.60606098f, 0.73063451f, 
    0.29298750f, -0.37282658f, 0.32703498f, 0.55160737f, 0.15497614f, 0.07697643f, 0.38115525f, 0.25742769f, 
    0.12836109f, 0.29107183f, 0.71901578f, 0.09114636f, -0.38041633f, -0.28335035f, -0.50329334f, -0.37712380f, 
    -0.32433051f, 0.54733700f, 0.80526859f, 0.22038050f, 0.02294095f, -0.55394226f, 0.13826981f, 0.16924864f, 
    -0.67273462f, -0.57697922f, -0.30614153f, -0.52175057f, -0.01366871f, -0.40477836f, 0.18551026f, 0.24039805f, 
    -0.23852792f, 0.83349186f, -0.36614281f, -0.48091486f, -0.29556337f, -0.44755936f, -0.12391823f, 0.12033015f, 
    0.07485767f, 0.55477470f, 0.18379079f, 0.65489674f, 0.23484294f, 0.27656409f, -0.37053645f, -0.37358752f, 
    -0.02611377f, -0.13616225f, -0.77389115f, 0.71309900f, -0.42794502f, -0.50686556f, 0.35707262f, 0.38832960f, 
    -0.01214086f, 0.04405385f, -0.16128278f, -0.40256327f, 0.08465403f, -0.20245197f, 0.06014585f, 0.59821934f, 
    0.65953213f, -0.25636300f, 0.48466668f, 0.19701174f, 0.72774613f, 0.10402486f, 0.39174357f, 0.10991029f, 
    -0.67904645f, 0.58273929f, -0.25858730f, 0.27948171f, 0.40502155f, 0.36514121f, 0.25126606f, 0.40796337f, 
    -0.01609162f, 0.01340168f, -0.31430683f, 0.04340589f, -0.47080380f, 0.36174351f, -0.63654256f, 0.36087936f, 
    0.18384047f, -0.03474301f, -0.57150978f, 0.06516430f, -0.43186378f, -0.12852715f, -0.41926578f, 0.13752359f, 
    -0.40898159f, -0.61160105f, -0.73336029f, -0.12241521f, -0.22705860f, 0.16705950f, 0.42522678f, 0.37252262f, 
    -0.59360552f, -0.63503432f, -0.70771897f, 0.43922177f, 0.05974475f, 0.30552629f, -0.17331937f, -0.39298835f, 
    -0.28806299f, -0.73460084f, -0.75389767f, -0.35079357f, -0.27819532f, -0.14054704f, -0.27856115f, 0.15686931f, 
    0.06876536f, -0.15114987f, 0.37650579f, 0.25692746f, -0.91646254f, -0.12379165f, 0.11887715f, 0.62103677f, 
    0.71924418f, -0.33761817f, -0.21945085f, -0.35234180f, 0.57219094f, 0.47957376f, 0.75411493f, 0.27801186f, 
    0.15895408f, -0.28190240f, -0.14288035f, -0.19771104f, 0.63712239f, 0.01338389f, -0.07784944f, -0.57964879f, 
    -0.69756562f, 0.32458535f, 0.12287465f, -0.38713565f, -0.18692371f, 0.89504200f, 0.17430276f, -0.68082023f, 
    -0.10103761f, 0.20537695f, -0.30288926f, 0.05619998f, -0.29468831f, 0.08605834f, -0.62073612f, -0.62827235f, 
    -0.52207905f, 0.06722212f, 0.25117078f, 0.56991744f, -0.24850436f, -0.16706541f, 0.19380638f, 0.51558107f, 
    0.09217863f, 0.60854745f, 0.35518435f, -0.81775504f, -0.01991538f, 0.34859082f, -0.16306512f, -0.06236028f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.00884713f, 0.19444484f, 0.21498711f, -0.13790536f, -0.00939315f, -0.18779124f, -0.14295948f, 0.21506979f, 
    -0.15822497f, -0.00910909f, -0.32636213f, -0.09807633f, 0.22076085f, 0.05947632f, -0.35547361f, 0.14186788f, 
    0.19622438f, 0.31941608f, 0.15370473f, -0.08353060f, 0.09094571f, -0.06314483f, 0.03016224f, -0.15649663f, 
    -0.02845712f, 0.10374306f, -0.47032756f, 0.11380510f, 0.11220057f, 0.02404166f, 0.06467894f, -0.07577289f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.12858930f, 0.06059645f, -0.13271664f, -0.05980604f, -0.10486679f, 0.00828732f, 0.19038846f, -0.05204719f, 
    0.03963036f, -0.03408071f, -0.09389106f, 0.10731176f, -0.11277547f, 0.09144867f, 0.05091564f, -0.09757840f, 
    0.02522336f, 0.07918009f, -0.40813926f, 0.04743621f, -0.35611549f, 0.06147259f, -0.02014845f, -0.02520119f, 
    -0.14933352f, -0.03907924f, 0.08706203f, -0.26725596f, -0.47099590f, -0.03373422f, 0.06515276f, -0.01233783f, 
    -0.14247109f, 0.01375064f, 0.01565503f, 0.03923425f, -0.11866298f, -0.15713553f, 0.02248944f, -0.11745215f, 
    -0.11318544f, 0.03161493f, -0.05471246f, -0.06485933f, 0.00964828f, 0.09226716f, 0.00410090f, 0.03558185f, 
    0.13512035f, 0.07345400f, 0.08464286f, 0.04387863f, 0.08268299f, -0.17028378f, 0.00476811f, -0.08178151f, 
    -0.14148280f, 0.17500481f, 0.12938684f, -0.13967697f, 0.02467680f, 0.05582353f, 0.05405331f, 0.10804332f, 
    0.16189304f, -0.02555761f, 0.00803800f, 0.00661854f, -0.00517992f, -0.03677498f, -0.02402353f, 0.14378650f, 
    0.00210421f, 0.13470460f, -0.03596244f, 0.04148228f, -0.14828783f, 0.05996722f, -0.34031957f, 0.07578930f, 
    0.09846217f, 0.02250035f, -0.02833178f, 0.06971996f, 0.05957755f, 0.08760450f, -0.28169119f, 0.22766288f, 
    0.03343285f, 0.21181698f, 0.15960069f, 0.02105857f, -0.08086085f, 0.17976208f, 0.15984549f, 0.06394272f, 
    0.21802951f, -0.00888521f, -0.10726631f, 0.35585910f, 0.17275248f, -0.12006033f, -0.03794965f, 0.06196298f, 
    0.05194379f, -0.04807147f, 0.12131047f, 0.14825788f, -0.19254470f, -0.09085809f, -0.27998745f, 0.03019227f, 
    -0.07985207f, -0.00107648f, 0.13968466f, 0.17746753f, 0.18035755f, -0.03192140f, -0.11952123f, -0.13778771f, 
    0.01194360f, 0.20095137f, -0.19332834f, -0.15925653f, 0.03142143f, -0.13361922f, 0.37513274f, 0.17240559f, 
    0.03077641f, -0.00296889f, -0.07756811f, -0.09154858f, 0.00792978f, 0.03212442f, -0.00147447f, 0.17166568f, 
    0.20766963f, -0.00323054f, 0.08682491f, 0.06508856f, -0.04217777f, -0.01271235f, 0.00366601f, 0.05935763f, 
    -0.01190386f, 0.00014879f, 0.05127897f, 0.01013019f, 0.01901633f, 0.09832554f, -0.08569560f, -0.01063110f, 
    -0.07300804f, -0.22960317f, -0.23960917f, 0.04813821f, 0.04118604f, 0.02244716f, 0.05941899f, -0.06964476f, 
    0.02092966f, 0.12679367f, -0.20117263f, 0.02198684f, -0.03615672f, 0.07056902f, 0.06397691f, -0.09582732f, 
    0.01158972f, -0.02123343f, 0.15302455f, 0.05665982f, 0.04252155f, 0.00627285f, 0.01981440f, 0.04142392f, 
    -0.13796514f, 0.08465617f, 0.09742244f, -0.00529911f, -0.26550451f, -0.29236239f, 0.09958556f, 0.04287162f, 
    -0.07633127f, 0.03392301f, -0.00299405f, -0.00792579f, 0.16669862f, -0.22292759f, 0.01749147f, 0.06214878f, 
    0.05292534f, -0.04329709f, 0.02387525f, 0.06108167f, 0.14026591f, -0.12570256f, -0.14941141f, -0.07348463f, 
    0.05371224f, -0.01818907f, 0.13523471f, 0.00379888f, -0.05186573f, 0.05134352f, -0.10868959f, -0.07442486f, 
    0.05266580f, 0.05817856f, 0.05819428f, -0.09001933f, 0.07097647f, -0.06425707f, -0.04744857f, -0.06088247f, 
    0.29366553f, 0.11873216f, 0.10158177f, 0.01566927f, -0.08929062f, 0.09728186f, 0.00518192f, 0.07422193f, 
    -0.11620959f, 0.13721772f, 0.11162647f, 0.10159099f, -0.01152793f, 0.00146900f, 0.03047151f, -0.06018795f, 
    0.04157056f, -0.04546932f, -0.10800386f, -0.12597370f, -0.13931111f, -0.11579061f, -0.09164967f, -0.08423286f, 
    -0.09963305f, 0.11345516f, 0.00946406f, -0.26551950f, 0.09826723f, -0.17474821f, 0.14334938f, 0.09432065f, 
    0.01656732f, 0.03456254f, 0.04447778f, -0.06777321f, -0.08633257f, -0.02228550f, -0.09502079f, 0.10624558f, 
    -0.07894553f, 0.04898104f, -0.03517401f, -0.05926488f, 0.01645688f, -0.21749407f, -0.15740959f, 0.19405496f, 
    0.02539650f, 0.04416035f, 0.04997382f, -0.01834460f, -0.07642662f, -0.13364324f, 0.13359092f, 0.09921277f, 
    0.12992021f, 0.02599968f, 0.04291207f, 0.06483590f, -0.05641181f, 0.06562494f, -0.06542229f, -0.13508587f, 
    -0.18841165f, -0.02074544f, 0.07187594f, -0.02298899f, 0.14424224f, -0.10017674f, 0.02369544f, -0.00716186f, 
    -0.00080240f, 0.01771073f, -0.03666814f, 0.02626965f, 0.04806517f, -0.05935931f, -0.01470666f, -0.00534504f, 
    -0.00484034f, -0.00256585f, 0.02366978f, -0.02237143f, -0.01218420f, 0.03554622f, -0.05182344f, 0.01237789f, 
    0.00384310f, -0.03934907f, 0.00373850f, 0.04237174f, -0.00362632f, 0.03603052f, -0.05409574f, -0.03919445f, 
    -0.06364033f, 0.02876036f, -0.04686372f, -0.06237179f, 0.00982181f, -0.04377069f, 0.03786680f, -0.02463480f, 
    -0.02755950f, 0.04380973f, 0.04312957f, -0.01649830f, -0.06811222f, 0.03684426f, -0.01031915f, -0.04997390f, 
    0.01572938f, -0.03114339f, -0.04312595f, -0.00019756f, -0.01878042f, 0.00100317f, -0.05729849f, -0.06151846f, 
    -0.02715570f, 0.05422367f, 0.02815525f, 0.01768249f, -0.06702385f, -0.00582566f, -0.06003070f, 0.05101915f, 
    -0.02322643f, -0.04015277f, 0.01588478f, -0.02585332f, -0.05068801f, 0.03697556f, -0.02862792f, 0.02575596f, 
    -0.02970802f, 0.04317720f, -0.02021107f, -0.04054815f, -0.05515337f, -0.03430073f, 0.01276370f, -0.02130627f, 
    0.02831260f, -0.00523934f, -0.01413557f, -0.06347570f, -0.02385956f, 0.03527656f, 0.01279440f, 0.02597395f, 
    0.02523218f, -0.04920409f, 0.01149398f, -0.06770232f, 0.01142481f, -0.05610327f, -0.01429430f, 0.01873004f, 
    0.00578876f, -0.00498009f, -0.01035099f, -0.03246344f, -0.06482472f, -0.04694803f, 0.02155255f, -0.01097367f, 
    0.02172828f, 0.02875244f, -0.00818804f, 0.04079768f, -0.01228543f, -0.06432547f, 0.01312065f, -0.02285885f, 
    -0.01507790f, -0.06493441f, -0.06188223f, -0.01522049f, -0.05591384f, -0.04979820f, -0.04554365f, -0.03631888f, 
    -0.02861212f, 0.01172854f, 0.02154294f, -0.05752455f, -0.06234894f, 0.00503626f, 0.04982218f, -0.02532036f, 
    0.04868189f, 0.02753350f, 0.03587195f, 0.04434832f, -0.01420133f, -0.04573070f, 0.01275857f, -0.02895065f, 
    0.00418194f, -0.04406518f, 0.03229108f, -0.04185678f, 0.02516482f, -0.05985074f, -0.02259363f, 0.03570442f, 
    -0.04417351f, -0.01250231f, 0.05295065f, 0.02630387f, 0.00621041f, 0.01204043f, -0.02627611f, -0.01375436f, 
    -0.05306934f, -0.03210444f, -0.02935825f, -0.03929349f, 0.01464871f, 0.01551323f, 0.03604437f, 0.01078491f, 
    -0.00200092f, -0.02116547f, -0.03762194f, 0.01492408f, -0.00195327f, 0.01190505f, -0.06224735f, -0.00491875f, 
    -0.01433167f, 0.00825163f, -0.00248391f, -0.02698384f, -0.04213955f, -0.06592413f, -0.04929801f, -0.00459405f, 
    -0.00515241f, 0.00455450f, 0.01926727f, -0.05535501f, -0.01867254f, -0.04149837f, 0.03353286f, -0.04797329f, 
    -0.00499906f, -0.05484237f, 0.02946487f, -0.03267930f, -0.06224741f, -0.02923581f, -0.04900622f, 0.01561988f, 
    -0.00082525f, -0.03374704f, 0.01208319f, 0.04867593f, -0.02790702f, -0.04728927f, -0.00369393f, 0.02928624f, 
    -0.04292466f, 0.04621899f, 0.04084696f, 0.03374765f, -0.00750193f, 0.03501341f, -0.04557189f, 0.00111016f, 
    -0.00480456f, -0.02357735f, -0.05905883f, -0.01268600f, -0.03935914f, -0.06451542f, 0.03529740f, 0.01747719f, 
    -0.00734223f, 0.01072545f, -0.03344564f, -0.05158320f, 0.05237547f, -0.04981634f, -0.05864876f, -0.03617187f, 
    -0.05515099f, 0.04127030f, 0.03136552f, -0.05020670f, 0.00225942f, 0.04325417f, 0.00477853f, 0.01555569f, 
    0.03972432f, 0.04195274f, -0.00975903f, -0.02169557f, -0.06253682f, 0.02902522f, -0.05479936f, 0.03410575f, 
    -0.00723562f, 0.02960689f, -0.01366273f, -0.05827817f, 0.05179459f, -0.00823347f, -0.05654455f, -0.00948270f, 
    0.00354287f, 0.00001335f, -0.05423189f, -0.06201420f, -0.04631118f, 0.00531377f, -0.04166942f, -0.03798918f, 
    -0.06233119f, 0.03440428f, 0.02722524f, 0.03474173f, -0.04710408f, 0.00116648f, 0.04936802f, 0.00823194f, 
    0.04218764f, -0.03886348f, 0.03552082f, 0.04912872f, -0.03232438f, 0.01070593f, 0.02427802f, 0.00275628f, 
    0.01920420f, 0.04705642f, 0.03628682f, 0.04603243f, -0.01818262f, -0.05088352f, 0.03940649f, 0.01912851f, 
    0.03206593f, -0.00925119f, -0.03281888f, -0.04080867f, 0.04363360f, 0.04467902f, -0.02692004f, -0.03997564f, 
    -0.03665956f, -0.03915185f, -0.00214199f, 0.02277398f, 0.04509180f, -0.05469651f, -0.02275630f, 0.02657556f, 
    0.07341719f, 0.12957925f, 0.05233204f, 0.05176190f, 0.07194405f, 0.14971972f, -0.01428443f, -0.06334608f, 
    -0.33063558f, 0.26777661f, -0.02308486f, -0.10066059f, 0.10209814f, -0.09214416f, -0.11348891f, 0.00218550f, 
    -0.13763553f, 0.10759134f, 0.11971827f, 0.21957386f, -0.10439243f, 0.00764120f, 0.10173011f, 0.03480499f, 
    0.04130114f, -0.00307579f, -0.06398885f, -0.04797558f, 0.17256629f, 0.08078050f, -0.05577109f, -0.12933303f, 
    -0.10004625f, -0.02982697f, -0.02137713f, 0.00220904f, 0.05339141f, 0.22055373f, -0.05596510f, 0.09832125f, 
    -0.06325200f, -0.03775600f, -0.00412415f, 0.15458128f, -0.18780166f, -0.18892474f, 0.03550055f, 0.08799390f, 
    -0.09999806f, -0.14803645f, 0.09080602f, 0.03077516f, -0.03511589f, 0.32221079f, 0.08068791f, -0.19160841f, 
    0.06929977f, 0.04929624f, 0.08059684f, 0.11502344f, -0.13086151f, -0.05605814f, -0.03060578f, -0.08877753f, 
    0.08128902f, -0.07202658f, 0.11437525f, 0.06323525f, -0.14882880f, 0.03416387f, 0.10599981f, 0.00550561f, 
    -0.02954369f, 0.40650481f, -0.16041772f, 0.00849428f, -0.06069896f, -0.10005857f, -0.07531828f, 0.12554237f, 
    0.09968030f, 0.04233561f, -0.03006576f, -0.02126678f, 0.03119629f, 0.03609092f, 0.06763807f, 0.01029584f, 
    0.01642097f, -0.03812403f, -0.21974894f, 0.00443575f, 0.09128192f, -0.08224550f, 0.09040304f, 0.05498127f, 
    -0.07700209f, -0.04444896f, 0.06108838f, -0.39208150f, -0.16355357f, 0.07710071f, 0.06541408f, -0.12021720f, 
    -0.09389764f, -0.11605341f, 0.02353377f, -0.06081804f, -0.02057946f, -0.17296776f, -0.21772936f, -0.02120799f, 
    -0.01301758f, 0.04513422f, -0.01278024f, -0.01953497f, -0.04734438f, -0.18381633f, 0.01801918f, 0.01797697f, 
    0.07350594f, 0.07727794f, 0.12469113f, -0.02373867f, 0.05025478f, 0.02176129f, -0.09517425f, -0.47215801f, 
    0.10952035f, -0.02171071f, -0.04209563f, 0.05131424f, -0.06050489f, 0.05170402f, -0.02343257f, 0.13194507f, 
    -0.11353905f, 0.06978212f, -0.04793091f, -0.08525701f, 0.07290486f, 0.13228109f, -0.00896160f, -0.03177291f, 
    0.12241153f, 0.16699684f, -0.07084100f, -0.01694496f, 0.06451187f, 0.02918145f, 0.08035284f, -0.02356407f, 
    0.01374845f, 0.23162177f, 0.07928612f, -0.35714808f, -0.03556989f, -0.01259644f, 0.13207711f, -0.01398327f, 
    -0.04011105f, -0.02434914f, -0.10369856f, 0.08113842f, -0.07043514f, -0.06952041f, 0.09236430f, 0.01820380f, 
    0.02180880f, 0.15893133f, 0.00993974f, -0.19137490f, 0.14903891f, 0.20447275f, -0.06040429f, -0.01996082f, 
    0.04677406f, -0.00170580f, -0.04570104f, -0.04741139f, -0.05167374f, 0.10927762f, -0.06114629f, 0.00411964f, 
    0.11300988f, 0.04365428f, -0.02013617f, 0.09923843f, -0.15661158f, 0.17287084f, 0.09451917f, -0.14182146f, 
    0.18407148f, -0.19668050f, 0.00426140f, 0.06038013f, 0.02978703f, -0.20743379f, 0.00358092f, 0.11767014f, 
    -0.01290919f, -0.12854397f, 0.08166533f, 0.07737707f, -0.11500176f, -0.02979562f, -0.11218264f, 0.09887329f, 
    -0.29378217f, -0.00855186f, 0.06743088f, 0.15094689f, -0.03636371f, 0.12096054f, 0.03346323f, -0.08206984f, 
    -0.30722189f, -0.30614600f, 0.35212699f, -0.02500275f, 0.08420916f, -0.02508460f, -0.23817329f, 0.02973000f, 
    0.08871372f, -0.00361957f, -0.13577728f, 0.15771650f, -0.00369279f, 0.01514329f, -0.08133523f, -0.06968836f, 
    0.03356639f, 0.13048615f, -0.08116722f, 0.10245155f, 0.03220038f, -0.04675747f, 0.26513967f, 0.20172955f, 
    -0.16944966f, 0.11120626f, -0.02354401f, 0.04135451f, -0.17868643f, -0.31146622f, 0.03752488f, 0.06193713f, 
    0.12399308f, -0.03153258f, -0.11793876f, 0.01012054f, 0.03038870f, 0.24634102f, 0.02983505f, 0.04183390f, 
    0.13514525f, 0.05766042f, -0.03061327f, 0.08995475f, -0.30333704f, 0.17687543f, 0.19831525f, 0.10017604f, 
    0.05059420f, 0.09371337f, 0.06200524f, 0.08676098f, 0.03778336f, 0.11165035f, -0.01998586f, -0.15370096f, 
    0.33304349f, 0.02572430f, 0.06454556f, -0.07263537f, -0.09216779f, -0.16359614f, -0.05273969f, 0.16522993f, 
    0.04591194f, -0.17440720f, -0.08240484f, 0.12947324f, -0.09900604f, -0.00570324f, -0.00303995f, -0.11309534f, 
    0.27373144f, -0.07837579f, -0.04247780f, 0.09584358f, -0.17709339f, -0.12376074f, -0.09215844f, 0.05293706f, 
    -0.02479273f, -0.01492123f, 0.08311034f, 0.00716501f, 0.14392425f, 0.03355154f, -0.00383544f, -0.14275573f, 
    0.04555149f, 0.12386111f, 0.01765436f, 0.07199743f, 0.28309661f, 0.03901404f, 0.05451059f, 0.05585076f, 
    -0.01843968f, -0.06887242f, -0.01120448f, -0.25888842f, -0.10526233f, 0.00905354f, -0.02884685f, 0.06148784f, 
    0.04407672f, 0.21534827f, -0.00432886f, 0.01570689f, -0.04693362f, -0.06156939f, 0.20156452f, 0.08768766f, 
    0.02226815f, 0.01872130f, -0.00551843f, -0.09415374f, -0.01802237f, -0.34231013f, -0.16176762f, -0.26539749f, 
    -0.03272769f, 0.20222636f, -0.05420060f, -0.07356573f, -0.12704208f, -0.02333247f, 0.09127324f, 0.16818380f, 
    0.16421497f, 0.00731959f, 0.04968743f, -0.07622089f, 0.10386447f, 0.02185319f, -0.16600385f, -0.18370922f, 
    -0.09624132f, -0.06997089f, 0.05696138f, 0.02858915f, 0.00017628f, 0.00964530f, -0.00871767f, 0.16640276f, 
    -0.13795711f, -0.34693879f, -0.08065636f, 0.01988682f, 0.10526969f, -0.08334813f, 0.07898577f, -0.03966326f, 
    -0.18260515f, 0.09210162f, -0.12089940f, 0.08367039f, 0.00348999f, -0.12187693f, -0.03289515f, -0.03538699f, 
    -0.12564743f, 0.08929166f, -0.32094678f, -0.13262910f, -0.10143534f, -0.13412090f, -0.06192486f, 0.01769233f, 
    0.09168636f, -0.08507915f, 0.10701715f, -0.27176127f, -0.18336196f, 0.04423825f, 0.00536087f, -0.08197913f, 
    -0.03722395f, 0.08133887f, 0.00858655f, 0.04493917f, 0.08846772f, 0.09577110f, -0.04669254f, -0.07501118f, 
    -0.19225162f, -0.10729860f, -0.10028998f, -0.01662588f, 0.16044235f, 0.14788488f, -0.01308509f, 0.34598163f, 
    0.14693223f, 0.02374429f, 0.03328274f, -0.04168497f, 0.10042734f, 0.10362577f, 0.16262157f, -0.04737169f, 
    0.19542308f, -0.08591564f, -0.02933619f, -0.06154510f, -0.05563495f, 0.07770670f, -0.00836430f, -0.11900394f, 
    0.33987018f, 0.11495217f, 0.01797763f, -0.02466817f, 0.05342127f, -0.00414374f, 0.11748994f, 0.10245284f, 
    -0.06250199f, -0.16941588f, -0.66777736f, 0.05515372f, -0.04188621f, -0.06991178f, 0.04752083f, 0.09909113f, 
    -0.10916917f, -0.01590087f, -0.02705660f, 0.07877766f, -0.03556347f, -0.04804075f, 0.03997296f, -0.05454469f, 
    0.05006374f, 0.07162125f, 0.14263347f, -0.06014504f, -0.28911269f, -0.09923366f, -0.00293510f, 0.04874662f, 
    -0.00322659f, -0.00805545f, -0.05378187f, 0.18012466f, -0.00631356f, 0.16347075f, 0.06113034f, 0.11188409f, 
    -0.07345704f, -0.02279624f, 0.10441902f, -0.12101088f, 0.09166383f, -0.05472779f, 0.03775048f, 0.02114058f, 
    0.21692890f, 0.10210341f, -0.00435337f, -0.05543447f, -0.02110643f, -0.10756773f, -0.00284430f, 0.06765628f, 
    0.07716326f, 0.07997230f, -0.09092937f, -0.00098515f, -0.10710332f, 0.03704473f, 0.01334630f, -0.28686458f, 
    0.05825775f, 0.20697686f, 0.00451907f, -0.02870253f, 0.21159856f, 0.00177772f, 0.04493173f, -0.49076548f, 
    0.10188922f, -0.09177279f, -0.02596622f, -0.17846459f, 0.04608036f, -0.03895374f, 0.07273371f, 0.02258999f, 
    0.14042461f, 0.02766618f, 0.26710021f, -0.19479065f, -0.01671764f, -0.10562734f, 0.12028311f, -0.04112748f, 
    0.00120454f, -0.01279587f, 0.04194761f, 0.57478511f, 0.19427447f, -0.00718086f, -0.15132123f, 0.07894091f, 
    0.01391273f, 0.16391760f, -0.29485565f, 0.12510005f, -0.23802541f, -0.13019611f, -0.06357310f, -0.04649300f, 
    -0.05585745f, -0.22574611f, 0.08636598f, 0.17075044f, -0.09497114f, 0.16683237f, 0.19583105f, -0.06153451f, 
    0.03466845f, 0.15599982f, 0.13446833f, -0.03979012f, -0.25663874f, -0.01664428f, -0.08549966f, -0.08249280f, 
    -0.05791023f, -0.00669361f, -0.11760126f, -0.01162506f, 0.02834808f, -0.21544327f, 0.16462167f, -0.32597244f, 
    0.09343572f, -0.06526315f, -0.09733074f, -0.07257080f, -0.14324886f, 0.04443591f, 0.13804859f, 0.05540663f, 
    0.22155155f, -0.17565134f, -0.12031545f, -0.00894114f, 0.00420914f, 0.21407738f, 0.05997528f, 0.08595472f, 
    0.15221587f, 0.08541698f, 0.03438573f, 0.06148255f, -0.07276899f, 0.01829776f, -0.09924906f, -0.05888546f, 
    0.10039141f, 0.11533268f, -0.01931434f, -0.10911065f, 0.06241027f, -0.03581712f, 0.01653346f, 0.05892314f, 
    0.17781515f, -0.29997680f, 0.09444844f, 0.08334068f, 0.17883509f, 0.02907291f, 0.07145189f, -0.02364867f, 
    -0.03153943f, 0.00461952f, -0.01203684f, 0.04650461f, -0.11352886f, 0.00667630f, -0.11145537f, 0.02291028f, 
    -0.05544351f, 0.06159116f, 0.18585141f, 0.02098375f, -0.07428337f, 0.07827465f, 0.22461796f, -0.09329393f, 
    0.14650139f, -0.16059257f, 0.02026890f, 0.13416579f, -0.09319998f, -0.09127280f, -0.03148925f, -0.04983157f, 
    -0.06594667f, 0.05201489f, 0.05484420f, 0.00889138f, 0.02690764f, 0.03875936f, -0.13449033f, -0.10033497f, 
    -0.07842514f, 0.05096577f, 0.11627507f, 0.09854285f, -0.23799984f, -0.30405843f, -0.30553940f, 0.12252262f, 
    0.27026752f, 0.07474525f, -0.00274887f, -0.28905630f, 0.09735000f, 0.13504966f, -0.04078116f, -0.04928314f, 
    -0.12557167f, -0.27835435f, -0.01877404f, -0.10286087f, 0.10560234f, -0.05537159f, -0.01584396f, -0.09578530f, 
    0.01989575f, 0.00253436f, -0.17206080f, -0.23394954f, 0.01783352f, 0.12419312f, 0.02258898f, -0.02323612f, 
    0.00658910f, -0.07777791f, 0.03064967f, 0.12734152f, -0.04932988f, 0.04685335f, -0.21310890f, 0.10926702f, 
    0.08719384f, 0.07758576f, 0.15897052f, 0.10116322f, -0.15119180f, -0.03422910f, 0.02873871f, -0.00423553f, 
    0.03413420f, -0.04895958f, -0.25067955f, -0.03112158f, 0.06152657f, 0.00207251f, -0.19809896f, 0.02549753f, 
    0.04734263f, 0.09141086f, -0.00671807f, -0.03126076f, -0.02241683f, 0.02495404f, 0.12224890f, 0.02650541f, 
    0.19284482f, -0.22747165f, 0.11017239f, -0.10340647f, 0.21268326f, 0.24153489f, 0.24616078f, -0.07328777f, 
    -0.01650180f, -0.00525710f, -0.28661284f, 0.00368785f, 0.18027058f, 0.04147648f, 0.11100139f, 0.20357722f, 
    0.01169072f, 0.05714176f, -0.05238614f, -0.14445284f, 0.05816549f, -0.01450027f, -0.19537030f, -0.16899927f, 
    0.09866484f, -0.04406220f, 0.19122790f, 0.16809052f, 0.01939976f, -0.03170619f, -0.05249638f, -0.03630165f, 
    0.02715336f, -0.27884319f, -0.22980592f, -0.03099521f, -0.08140397f, 0.10995348f, -0.05956150f, -0.04242394f, 
    -0.04513035f, -0.03942301f, -0.01064880f, -0.06394633f, 0.01128181f, 0.05415923f, 0.13504139f, -0.11953352f, 
    -0.10650710f, 0.12743627f, 0.15916280f, 0.15334421f, -0.07456624f, 0.01780770f, 0.02532380f, 0.06949639f, 
    0.07356598f, 0.06076672f, 0.08000342f, 0.01519005f, 0.27001750f, 0.15496862f, -0.04385114f, -0.02918738f, 
    -0.03492653f, 0.00122040f, -0.07414131f, 0.14575683f, -0.04319112f, -0.13237119f, -0.04941413f, -0.02280814f, 
    -0.00097591f, -0.14367609f, -0.02714081f, -0.13417245f, 0.25635123f, -0.01739740f, 0.08113217f, 0.22446030f, 
    0.02856877f, 0.01019931f, -0.05861820f, -0.11868060f, 0.04228027f, 0.06354425f, 0.02453733f, 0.06370406f, 
    0.03131286f, -0.00732437f, -0.09885472f, -0.00869313f, -0.02690261f, -0.06385289f, 0.04820773f, 0.02324665f, 
    0.00063617f, 0.06853708f, 0.04101076f, -0.16165949f, 0.03497396f, -0.01711009f, -0.05132075f, -0.05028340f, 
    0.12254073f, 0.15647262f, 0.10605372f, 0.08376383f, 0.05025421f, -0.10659008f, 0.05389840f, 0.11063068f, 
    -0.07377849f, 0.02154406f, 0.17968149f, 0.08559243f, 0.13706674f, 0.03492744f, -0.03209567f, -0.10070210f, 
    0.14895129f, 0.10637347f, 0.25729620f, -0.14351085f, -0.28898346f, -0.01175458f, 0.08447105f, -0.04395386f, 
    0.12072468f, 0.03184287f, -0.00770905f, 0.16807045f, -0.06980205f, 0.01275083f, 0.01430080f, -0.12478451f, 
    -0.06905621f, 0.00996653f, 0.20285259f, 0.17538255f, -0.27576411f, -0.07670917f, -0.24537329f, 0.15449828f, 
    -0.13017118f, 0.10788647f, -0.04874982f, 0.04172899f, -0.12760112f, 0.00868424f, -0.21428992f, -0.10762392f, 
    0.06439746f, -0.00329428f, 0.06653522f, -0.00261287f, -0.04095795f, -0.06766561f, -0.00764150f, 0.19212618f, 
    -0.03655309f, -0.01721240f, 0.04294198f, -0.21276867f, 0.00349457f, -0.04221456f, 0.11560405f, -0.32754555f, 
    -0.01340555f, 0.19409978f, 0.10655109f, -0.01105995f, -0.05326185f, -0.06165997f, -0.02354059f, 0.07680848f, 
    -0.06229724f, 0.03303859f, 0.01683652f, 0.03270733f, -0.03171992f, 0.02339643f, 0.04281703f, 0.02274777f, 
    -0.03033784f, 0.03126425f, -0.04200610f, -0.03065897f, -0.06254976f, -0.05610196f, 0.03310374f, 0.03914748f, 
    -0.03068149f, -0.00263795f, -0.02430095f, -0.04047167f, 0.02904718f, -0.01002997f, -0.03827063f, 0.02017184f, 
    0.04838435f, 0.00845363f, -0.06021657f, 0.00751020f, -0.01040599f, 0.03727236f, 0.04111427f, 0.00760957f, 
    0.01071778f, -0.03284086f, -0.04588534f, -0.01152451f, 0.02673985f, 0.03603302f, 0.00677896f, -0.03981117f, 
    -0.02786488f, 0.04709927f, -0.01715182f, -0.01206957f, -0.04915881f, 0.03463593f, -0.00580414f, -0.00731938f, 
    -0.03590501f, -0.03700147f, -0.01844881f, -0.04346119f, -0.00781493f, -0.04127324f, -0.02860690f, -0.01332525f, 
    -0.00113810f, -0.03901644f, -0.02139785f, -0.03096246f, -0.00511337f, 0.04842170f, 0.04359355f, -0.05667495f, 
    -0.06414858f, 0.01723585f, -0.05578198f, 0.03251234f, 0.03817109f, -0.01683869f, -0.02218639f, -0.02810600f, 
    -0.02289428f, -0.06389830f, 0.01798481f, -0.02230511f, 0.02423832f, 0.00081146f, -0.02099460f, 0.01075593f, 
    -0.04060973f, 0.04316647f, -0.04073660f, 0.03780477f, 0.04423562f, 0.02733653f, 0.01785473f, 0.01627500f, 
    -0.02680736f, -0.03992648f, 0.02063914f, -0.00342223f, -0.00463076f, 0.02900080f, 0.01472262f, -0.05871043f, 
    0.03934208f, -0.00949619f, -0.04030135f, 0.04516870f, 0.04939979f, -0.02069907f, -0.05495336f, -0.00865435f, 
    -0.04077620f, -0.06308229f, 0.00069681f, 0.00550310f, -0.03826980f, -0.01131672f, -0.05914171f, 0.01830137f, 
    -0.02161684f, 0.03338231f, 0.00592918f, 0.03470116f, -0.01119892f, -0.00423252f, -0.00119904f, 0.03440750f, 
    -0.06523974f, -0.04617806f, -0.02422929f, -0.00563852f, 0.02713139f, 0.04008290f, 0.03878587f, -0.02493634f, 
    0.03558153f, -0.04678828f, -0.06014253f, -0.06004806f, 0.00274855f, 0.00147264f, -0.03036002f, -0.01907150f, 
    -0.05308875f, -0.06286772f, 0.04018622f, 0.00462760f, -0.06652459f, -0.03424071f, 0.04848648f, 0.00179737f, 
    -0.05654045f, 0.03448660f, 0.00104319f, 0.04069051f, 0.03165973f, -0.05135880f, 0.00475388f, 0.01371756f, 
    -0.03200376f, -0.05265700f, -0.01502957f, 0.04234129f, -0.03283242f, -0.06548361f, 0.04931181f, 0.00645856f, 
    -0.03904349f, 0.00551304f, -0.04674611f, 0.03074975f, 0.03426018f, 0.03384979f, -0.03378725f, 0.04062444f, 
    0.00943748f, -0.06225578f, -0.06574827f, -0.04579132f, 0.02933778f, 0.04087903f, 0.02379170f, -0.05102403f, 
    0.02627674f, 0.00974441f, 0.02587234f, 0.01044686f, 0.04314197f, 0.03519696f, 0.01377937f, -0.02125257f, 
    0.00096461f, -0.04824067f, 0.02589709f, -0.03074933f, -0.06187658f, -0.00946132f, -0.00399429f, 0.04845786f, 
    0.02507486f, 0.04605063f, 0.02322446f, -0.05961130f, 0.02645080f, 0.01252734f, -0.01786097f, -0.06697189f, 
    -0.00882542f, -0.02566428f, -0.04654171f, 0.02182230f, 0.01880806f, 0.01761045f, 0.04433574f, -0.05862164f, 
    0.02017086f, -0.04080040f, 0.04503157f, 0.02052819f, 0.02585121f, 0.02205374f, -0.03384345f, 0.02802120f, 
    -0.02650824f, -0.01654985f, -0.06623124f, -0.03744905f, -0.04201147f, 0.02304394f, 0.03774154f, -0.00794730f, 
    0.04897939f, 0.00721738f, 0.03276546f, -0.00700310f, -0.01122282f, 0.01716644f, -0.05234794f, 0.01752910f, 
    -0.05890775f, -0.06409239f, -0.06047211f, 0.02843715f, 0.01014698f, -0.03076248f, -0.01815358f, 0.05048189f, 
    -0.03076186f, -0.01311773f, -0.05280930f, -0.05728843f, 0.01799321f, -0.04821194f, 0.05193069f, -0.01380391f, 
    -0.00192774f, -0.03243057f, -0.01013034f, -0.04405424f, 0.04309482f, -0.05809708f, -0.03711000f, -0.03181552f, 
    -0.03522390f, 0.03496281f, -0.00297792f, 0.01385598f, -0.04663809f, -0.02963917f, -0.00501897f, 0.02191821f, 
    -0.02458344f, 0.01896800f, 0.04325119f, -0.02821485f, -0.00380647f, -0.01897828f, 0.03376664f, -0.03985447f, 
    0.02155051f, -0.01700980f, 0.00262981f, -0.05064279f, 0.04562116f, -0.04723907f, 0.01361286f, -0.01206896f, 
    -0.00819333f, -0.04979974f, 0.02288006f, 0.00459852f, 0.01041631f, 0.02564367f, -0.05553578f, -0.01334892f, 
    -0.04353297f, 0.28931129f, 0.19121042f, -0.11431674f, -0.05300058f, 0.06073729f, 0.00258809f, 0.06632347f, 
    0.02465218f, -0.01390713f, -0.06282372f, -0.15790981f, -0.05384502f, 0.07867227f, 0.30929270f, -0.06800876f, 
    0.00083394f, -0.06545155f, -0.06364499f, -0.02250021f, 0.15441565f, -0.00928157f, 0.05492062f, 0.05944854f, 
    -0.03120820f, -0.00364453f, -0.03106245f, 0.00393964f, 0.02877953f, 0.11134878f, 0.08079074f, 0.01106159f, 
    -0.00314197f, -0.13564122f, -0.03902700f, 0.03281508f, 0.12237832f, 0.07343961f, -0.05755836f, -0.01949321f, 
    0.04015039f, 0.11093771f, -0.20195077f, 0.02773411f, -0.00326891f, -0.42003646f, -0.41177371f, -0.31704560f, 
    0.04233092f, 0.04608586f, 0.07172219f, 0.08423974f, -0.14964393f, -0.05627184f, 0.25093421f, 0.20367427f, 
    -0.02248862f, -0.21656509f, -0.06004985f, -0.00853046f, 0.09283084f, -0.01501526f, -0.02028503f, 0.09624508f, 
    0.09533487f, -0.07631585f, 0.08042362f, 0.19198535f, 0.21935596f, -0.02277687f, 0.00717651f, 0.06975424f, 
    0.18324997f, -0.12249000f, -0.28064218f, -0.02617504f, 0.01839679f, 0.05817645f, 0.11283445f, -0.00556163f, 
    -0.01314481f, -0.23778152f, -0.18925160f, -0.16553365f, -0.13181348f, -0.03821144f, -0.12785295f, 0.14390619f, 
    0.00703946f, -0.02401800f, -0.15541644f, -0.07218639f, 0.01514582f, 0.02843468f, -0.04863954f, -0.06352910f, 
    -0.07049152f, 0.07639556f, -0.03303977f, -0.25511098f, -0.40269187f, -0.30343485f, 0.00204345f, 0.03889012f, 
    0.04132847f, -0.01814731f, -0.04746411f, -0.02055712f, 0.19607663f, 0.14115717f, 0.22918676f, 0.18414733f, 
    0.02321179f, 0.02251957f, 0.11545989f, 0.03371622f, 0.11691907f, 0.20055421f, 0.16652496f, 0.03426151f, 
    0.10274474f, -0.05081190f, 0.06920075f, 0.14430036f, 0.07052748f, -0.03492291f, -0.28058487f, 0.05335090f, 
    -0.27611145f, -0.16626006f, 0.02214225f, -0.19933291f, -0.18725263f, -0.05349599f, -0.10538557f, -0.22980353f, 
    -0.08225332f, -0.04357154f, 0.05829892f, 0.02319132f, -0.08023912f, -0.04807962f, 0.02193870f, -0.03281222f, 
    0.30768594f, -0.33034712f, -0.17756808f, 0.08331405f, 0.03625042f, 0.15070464f, -0.08289649f, -0.06917980f, 
    0.07879754f, 0.00464019f, -0.00282603f, 0.16367896f, 0.13382240f, 0.12357027f, 0.08393645f, 0.11999901f, 
    0.04294534f, -0.10393514f, -0.08180001f, -0.22432637f, -0.20043766f, 0.13456044f, 0.04074747f, -0.02095082f, 
    0.21452269f, 0.13056411f, 0.14448886f, -0.06602241f, -0.04635666f, -0.12955710f, -0.09509818f, 0.03148014f, 
    -0.04913760f, 0.14003348f, -0.06076649f, 0.02391309f, 0.11220275f, 0.20429309f, 0.13931404f, 0.01959228f, 
    -0.01542212f, 0.03058248f, 0.02353229f, -0.05083289f, 0.21234521f, -0.00745117f, -0.11349729f, 0.02400753f, 
    0.03445706f, -0.01686445f, -0.07965529f, -0.11271006f, -0.06280222f, 0.23606803f, -0.14116707f, -0.10517428f, 
    0.12332736f, 0.08296341f, 0.03218540f, -0.08858912f, 0.10504238f, 0.13583730f, 0.12920281f, -0.22253285f, 
    -0.03037984f, -0.20722935f, 0.07793777f, -0.11031511f, 0.04102699f, -0.01195045f, -0.26446733f, -0.00893549f, 
    -0.11878477f, 0.32348162f, -0.21106629f, -0.08223718f, -0.05642740f, -0.12349340f, 0.02877329f, 0.18830942f, 
    -0.15545069f, -0.11023305f, 0.05371717f, 0.01383339f, -0.13295303f, 0.13949715f, 0.09740835f, 0.10897179f, 
    0.01526998f, -0.16532454f, -0.04572289f, -0.12279926f, 0.03669066f, -0.06088220f, -0.16843094f, 0.12768202f, 
    -0.10169613f, -0.04388054f, 0.09210834f, -0.03673892f, 0.02935156f, 0.16784547f, 0.12859514f, 0.07643475f, 
    -0.04147798f, 0.05139287f, -0.16041225f, -0.11299391f, -0.13137552f, 0.20697095f, 0.02888175f, 0.09031558f, 
    0.03478772f, 0.22182526f, 0.07731321f, 0.08129207f, 0.01051352f, -0.24871375f, -0.02726843f, -0.00192305f, 
    0.21745630f, -0.03527943f, -0.02144282f, 0.01102931f, -0.05048083f, -0.05827972f, -0.01656334f, 0.06639763f, 
    -0.22244427f, 0.00493835f, 0.00879988f, 0.00903313f, -0.11880367f, 0.14973781f, -0.15763834f, -0.01545654f, 
    0.11003567f, 0.12182371f, 0.03396167f, -0.15920086f, 0.14868696f, 0.07171249f, -0.04003159f, 0.16402614f, 
    0.00692569f, 0.00577517f, 0.03698011f, -0.03554347f, -0.03943923f, -0.00097973f, -0.04743301f, 0.04062006f, 
    0.00385133f, 0.02567485f, 0.03202533f, -0.05040756f, -0.00916795f, 0.01330851f, -0.03149204f, -0.03685569f, 
    0.02906576f, -0.03168667f, 0.03704881f, 0.00153162f, -0.04310230f, -0.01881532f, -0.03350271f, -0.00602612f, 
    -0.05360135f, -0.04087156f, -0.00668793f, 0.02391259f, 0.05672545f, -0.05722865f, 0.02150482f, 0.00033847f, 
    -0.03795025f, 0.03735996f, 0.00679911f, -0.01591483f, -0.03520170f, -0.00896585f, -0.02099859f, -0.01560850f, 
    -0.05099983f, -0.02938336f, 0.01468426f, -0.03036995f, -0.05959833f, -0.03274509f, -0.02230800f, -0.04425926f, 
    -0.05333200f, -0.00799901f, 0.01005542f, 0.03510480f, -0.04686309f, 0.05041804f, -0.04514446f, 0.02418375f, 
    0.03729962f, 0.01658633f, 0.05252228f, -0.01920513f, -0.03684428f, 0.04722389f, 0.04072709f, -0.04694393f, 
    0.01155988f, -0.05357336f, 0.04349542f, 0.03674154f, -0.00827863f, -0.04581575f, 0.04077417f, 0.02471435f, 
    0.00307997f, -0.02444006f, 0.02251053f, 0.05397826f, 0.02264836f, -0.05263575f, 0.00535794f, -0.03637351f, 
    0.04243873f, -0.00985215f, 0.02385697f, -0.02269800f, 0.03353016f, -0.04259960f, 0.01444212f, 0.01572217f, 
    0.01694641f, 0.02391750f, -0.00905668f, 0.02753041f, 0.03128213f, 0.00712379f, 0.00542341f, -0.05953164f, 
    0.01952594f, 0.04327001f, -0.02489100f, 0.01688479f, 0.00833804f, -0.00466241f, 0.01564116f, -0.02702874f, 
    -0.02047007f, 0.02294611f, -0.05017370f, 0.04966799f, 0.01430643f, -0.01277978f, -0.03748782f, -0.02175833f, 
    0.04658130f, -0.01665677f, 0.02471587f, -0.01711343f, -0.01449557f, 0.01789392f, -0.04380080f, 0.01881021f, 
    -0.00154357f, -0.01674740f, -0.03446874f, 0.01649030f, -0.03585853f, -0.04205710f, -0.04161078f, -0.00765043f, 
    0.04518261f, -0.03601837f, -0.05308940f, 0.04476056f, -0.04302080f, -0.05135055f, 0.04666488f, 0.04894024f, 
    0.03527702f, -0.01833129f, 0.00298169f, 0.02427204f, -0.00834136f, -0.01482909f, 0.05284958f, 0.05185740f, 
    -0.01769495f, 0.00399427f, -0.04009864f, 0.04419421f, 0.00870146f, -0.01498324f, 0.00924478f, 0.01095642f, 
    -0.02127498f, -0.04283202f, -0.00832784f, -0.04631240f, -0.05700601f, -0.03745404f, 0.00275553f, 0.02258252f, 
    0.02638925f, -0.00290386f, 0.04057192f, 0.03826546f, -0.05820077f, -0.04877095f, 0.02307164f, 0.00011987f, 
    0.03692767f, 0.02095212f, 0.02586745f, 0.04179243f, -0.05464319f, -0.02243206f, 0.03097301f, -0.02728394f, 
    0.02531455f, -0.03652447f, 0.02723529f, -0.04367119f, -0.03209623f, -0.00505305f, -0.00193246f, 0.01528697f, 
    0.01161776f, -0.03736397f, -0.05638505f, -0.02530041f, -0.02812553f, -0.05003340f, 0.04385367f, 0.04602020f, 
    0.03325468f, -0.04314785f, 0.03220447f, -0.06332246f, 0.03792373f, -0.04631830f, -0.02853977f, 0.02291508f, 
    0.04417875f, -0.05746537f, 0.03872138f, 0.01416650f, -0.02447112f, -0.04988530f, 0.04997195f, 0.01475132f, 
    -0.06433675f, 0.02139016f, -0.00166650f, -0.05893744f, -0.00070313f, -0.03413208f, -0.03093312f, -0.03818627f, 
    -0.04610575f, -0.04979579f, 0.02179011f, -0.05655902f, -0.04948728f, -0.03717564f, 0.01969077f, -0.04592207f, 
    -0.01520267f, -0.01414613f, 0.03421324f, 0.04987618f, -0.03727416f, 0.03649778f, 0.03597295f, -0.03977142f, 
    -0.01898444f, -0.00874852f, -0.05430664f, 0.02926882f, 0.03070749f, 0.01554976f, 0.03825054f, -0.01863873f, 
    0.03325740f, -0.03944597f, 0.04830763f, -0.00961052f, -0.00989504f, 0.00797250f, 0.04036224f, 0.00186866f, 
    0.00758432f, -0.05117966f, 0.01486808f, -0.02282639f, -0.01806296f, -0.02920460f, -0.01418256f, 0.03099816f, 
    -0.00260113f, -0.01610159f, -0.03838668f, 0.03867384f, -0.00305530f, 0.03534144f, 0.04223643f, 0.00691564f, 
    -0.00240365f, -0.01275053f, -0.04719398f, -0.01121086f, -0.06678970f, 0.00347444f, 0.01145014f, 0.01922766f, 
    -0.04724842f, 0.02463680f, -0.02984732f, 0.04401157f, -0.06693383f, -0.04633451f, -0.03424943f, -0.02675966f, 
    -0.04506500f, -0.01653577f, -0.02044566f, -0.00907740f, -0.04516590f, 0.03723637f, -0.03325240f, -0.05720316f, 
    -0.00849130f, 0.03422628f, 0.03488483f, -0.05456958f, 0.01877500f, 0.02926079f, -0.00818746f, 0.00493320f, 
    -0.00692460f, 0.05048866f, -0.05592915f, 0.01004382f, 0.03339035f, -0.04516637f, 0.02952648f, 0.02893101f, 
    0.03991684f, -0.04341385f, -0.02349577f, -0.05897577f, 0.04668890f, -0.05509662f, 0.03619328f, 0.03180966f, 
    0.00655466f, 0.03205377f, -0.03310399f, -0.04063109f, 0.02847204f, -0.00683552f, 0.01747932f, 0.00722140f, 
    -0.05596082f, 0.00407697f, 0.03746556f, -0.03138448f, -0.06382941f, -0.01455538f, 0.00287137f, -0.00401200f, 
    0.00988410f, -0.05068303f, 0.02563749f, -0.01952719f, 0.02372845f, -0.02105343f, -0.05567997f, -0.04843536f, 
    -0.00180674f, -0.04005364f, 0.05180117f, -0.00346657f, 0.01083542f, -0.04274691f, 0.04637147f, 0.03283900f, 
    -0.02107298f, -0.00564739f, -0.03779631f, 0.04063548f, -0.00231376f, 0.04808921f, 0.01079448f, 0.00599921f, 
    0.03481728f, 0.01418039f, 0.00899211f, -0.05030030f, 0.03533314f, -0.04955788f, -0.04797420f, 0.00325827f, 
    -0.03928867f, -0.04541536f, 0.02816677f, 0.00756991f, -0.03104346f, -0.03101849f, -0.02912755f, -0.02290224f, 
    -0.02416329f, 0.02965165f, 0.01168397f, 0.00260983f, -0.04280156f, -0.03113410f, 0.02868676f, 0.03349955f, 
    0.04471066f, 0.04472897f, 0.03541020f, -0.03150021f, -0.05754476f, 0.00962879f, -0.05781306f, -0.04395653f, 
    -0.05285698f, -0.04353031f, -0.01537567f, -0.01788880f, -0.01265551f, -0.05168552f, -0.02339951f, -0.03955511f, 
    -0.02013225f, 0.02036225f, -0.03165404f, -0.01502380f, 0.03249750f, -0.06334377f, 0.03520996f, 0.03537449f, 
    -0.06505799f, -0.05039559f, -0.02319588f, -0.05736558f, -0.01500348f, -0.03429452f, 0.04129872f, -0.01221518f, 
    0.03385282f, 0.05061540f, -0.06502756f, 0.04783831f, 0.02304131f, -0.01273275f, 0.01154823f, -0.03912725f, 
    -0.00096022f, -0.04043276f, -0.05487784f, -0.06057085f, -0.01964368f, 0.02040070f, 0.05137181f, -0.01711729f, 
    0.04467322f, -0.06467830f, -0.00271711f, -0.00675393f, 0.02641466f, -0.05845048f, -0.05829943f, 0.03045147f, 
    0.03315676f, 0.04931707f, 0.00994063f, 0.00063519f, 0.01305242f, -0.00277836f, 0.04134749f, 0.04495407f, 
    0.01349438f, 0.03092105f, 0.03345547f, -0.04553284f, 0.00295196f, -0.06318291f, -0.05123699f, -0.02874386f, 
    -0.06071015f, 0.00775976f, -0.01109782f, 0.01471260f, -0.02401307f, -0.05720544f, -0.00909265f, -0.01851932f, 
    -0.04301815f, 0.00749893f, -0.06359199f, 0.03568557f, -0.00968727f, 0.05372665f, -0.03263373f, -0.05120017f, 
    -0.03855502f, -0.06688864f, -0.02495304f, 0.04704549f, 0.04488226f, 0.04985629f, 0.00301390f, 0.01481111f, 
    -0.02842219f, -0.05908336f, -0.05281178f, -0.03239699f, -0.03537123f, 0.04000220f, 0.04692088f, -0.02344475f, 
    0.04678866f, 0.00661986f, 0.00766705f, 0.01290260f, 0.05191975f, -0.03517958f, 0.00433706f, 0.02032741f, 
    -0.00682677f, 0.00802466f, -0.02027358f, 0.00250653f, 0.00586436f, -0.03926199f, -0.03716444f, 0.01302269f, 
    0.00076371f, -0.02845889f, -0.03852423f, -0.04371227f, 0.04363931f, 0.00175702f, 0.03669791f, 0.02155885f, 
    -0.03568009f, 0.02274072f, 0.02593262f, -0.01021024f, -0.02050157f, 0.04861771f, -0.03547032f, -0.01915705f, 
    -0.06635036f, 0.00534415f, -0.04741503f, -0.00052355f, 0.04695421f, 0.03972207f, -0.06810393f, 0.00202239f, 
    0.01873549f, -0.00554322f, 0.01967323f, 0.00931547f, 0.00641583f, -0.02209327f, 0.01051375f, 0.03288922f, 
    -0.02345101f, -0.05496027f, 0.00951153f, -0.01562617f, -0.05663354f, 0.04645059f, -0.06061724f, 0.02422633f, 
    0.01146218f, -0.03329239f, -0.02495479f, -0.01001230f, -0.03724398f, -0.04107361f, 0.05010382f, 0.02053289f, 
    0.04185167f, 0.00321114f, 0.04596650f, -0.05474980f, 0.02376848f, 0.00468523f, -0.06517611f, 0.02667273f, 
    0.00209361f, -0.04585548f, -0.02228526f, 0.03876146f, -0.05744023f, 0.04946246f, 0.02205106f, 0.02907438f, 
    -0.04164600f, 0.01238424f, -0.01028765f, 0.04770535f, 0.01405199f, -0.02116853f, 0.00042737f, -0.03361043f, 
    -0.03797748f, -0.00755571f, 0.05050974f, 0.05327659f, -0.06012711f, 0.01075933f, -0.03488293f, 0.02288879f, 
    0.05521808f, -0.02188441f, -0.04154852f, -0.02906068f, -0.05339646f, -0.00423580f, -0.00124613f, -0.05827491f, 
    -0.03006744f, 0.02712674f, 0.02901682f, 0.03951745f, 0.02305550f, 0.03809172f, -0.02475243f, -0.04301270f, 
    -0.02763783f, 0.02306886f, 0.03792878f, -0.02931882f, -0.04404402f, -0.03514362f, 0.00347134f, -0.01188348f, 
    -0.04418623f, 0.05296654f, -0.02949131f, 0.04139496f, -0.01026429f, -0.06437910f, 0.02987050f, -0.02223193f, 
    0.01097691f, 0.04873241f, 0.05459481f, -0.03126788f, -0.00449505f, 0.03247717f, -0.02370650f, -0.04955206f, 
    0.02890528f, -0.04806817f, -0.05273280f, 0.04892004f, -0.00388932f, -0.03783093f, 0.01769521f, -0.03995138f, 
    -0.04839855f, 0.04189641f, 0.02257684f, -0.05736368f, 0.03371158f, -0.00412713f, -0.01847805f, 0.01349224f, 
    0.02462803f, 0.02302383f, -0.02641088f, 0.03692946f, 0.00964947f, 0.01138075f, -0.01638528f, 0.04210484f, 
    -0.05902196f, 0.03915017f, 0.01071933f, 0.03678351f, -0.04446625f, -0.02642280f, 0.05014736f, -0.04349125f, 
    -0.00415397f, 0.00563446f, -0.04026312f, 0.04154427f, -0.06069153f, 0.01505988f, -0.00196295f, -0.06005913f, 
    0.00248938f, -0.02118842f, -0.00420198f, -0.05730790f, -0.01642485f, -0.00426494f, -0.04589099f, -0.05006345f, 
    -0.03170962f, -0.00976801f, 0.02691028f, -0.03360641f, -0.07098345f, 0.02645614f, 0.04253615f, -0.05662125f, 
    -0.00606078f, -0.02268796f, 0.00159745f, 0.02030655f, 0.01640267f, -0.04103254f, -0.02895293f, 0.03322401f, 
    0.00876011f, -0.02068835f, 0.00364583f, -0.03433011f, -0.00563017f, 0.02582777f, 0.03005864f, -0.03650667f, 
    -0.05991107f, -0.06152549f, 0.04201414f, -0.03481745f, -0.03240576f, -0.02803139f, -0.00194085f, -0.01539355f, 
    0.00463599f, -0.01793120f, -0.04306159f, -0.04150770f, -0.02430928f, 0.04147517f, -0.03820215f, 0.03485912f, 
    0.01331966f, -0.02748129f, 0.00308928f, -0.05893958f, 0.02376757f, -0.04496800f, 0.00879880f, -0.03702063f, 
    -0.00643179f, 0.04184794f, -0.01896789f, -0.01997893f, -0.03908958f, -0.04313611f, -0.02287043f, -0.00457252f, 
    -0.01019931f, 0.03244914f, -0.05480902f, -0.02561170f, 0.02854242f, -0.05575361f, 0.00329598f, 0.00006283f, 
    0.01703835f, -0.04637272f, -0.02501653f, 0.02577886f, 0.04784258f, -0.05017938f, -0.06004540f, -0.01077995f, 
    0.04485616f, 0.02223451f, -0.00608844f, 0.00681259f, 0.05143575f, -0.02344219f, 0.02848879f, 0.01472736f, 
    -0.00578200f, 0.01783130f, 0.03692310f, -0.03532605f, 0.03360805f, 0.02969791f, 0.01686898f, 0.01355998f, 
    0.02576046f, -0.00060347f, 0.03680595f, -0.04589404f, -0.05554616f, -0.06180831f, -0.01592982f, 0.00998265f, 
    0.02535105f, 0.03719917f, 0.03943558f, -0.05853919f, -0.02743408f, -0.04880432f, 0.03077722f, 0.03746363f, 
    -0.00659666f, -0.00448260f, 0.02857747f, -0.03143971f, 0.01567931f, -0.05647714f, 0.03177154f, -0.04124994f, 
    -0.04074873f, -0.05015708f, 0.04111900f, -0.01832476f, 0.00882761f, 0.01639860f, -0.04488381f, 0.01780535f, 
    -0.01372165f, -0.03020062f, -0.05010563f, -0.00960049f, -0.04842868f, -0.00273379f, -0.00623482f, 0.05189186f, 
    0.00669121f, 0.03162538f, -0.04330801f, -0.06622102f, 0.00419214f, -0.04284493f, 0.02953207f, 0.04512141f, 
    -0.02894686f, 0.03693454f, 0.00872608f, 0.02668042f, -0.03202184f, -0.03088588f, 0.04604098f, -0.02924210f, 
    -0.02125378f, -0.00669962f, 0.02352006f, 0.01077886f, 0.02833956f, -0.01256821f, 0.02959207f, 0.04379825f, 
    -0.03183906f, -0.06518507f, -0.05384120f, -0.05152248f, -0.04485003f, -0.04230509f, -0.01505823f, 0.00257311f, 
    -0.05871948f, 0.03807288f, 0.00127014f, -0.01686010f, 0.03096576f, -0.03192004f, -0.05043706f, -0.01074450f, 
    -0.04619290f, 0.02745344f, 0.02171043f, -0.01038744f, -0.00887608f, 0.00672546f, 0.01721121f, 0.04205914f, 
    0.03814558f, 0.01407940f, 0.00891890f, -0.03349316f, -0.00801078f, -0.01165710f, 0.00103697f, 0.03893450f, 
    -0.00370138f, -0.01572542f, -0.04713551f, 0.03094659f, -0.02602711f, -0.03720230f, -0.03715774f, -0.04404776f, 
    0.00213686f, -0.02108848f, -0.00211712f, -0.01232131f, 0.03103186f, 0.00960226f, -0.02213161f, 0.00013178f, 
    -0.02976030f, 0.02586611f, 0.00094295f, -0.04210826f, -0.06903747f, -0.01675029f, 0.00712855f, 0.04020758f, 
    0.02031233f, 0.03368488f, 0.01815877f, 0.02654208f, -0.04565531f, 0.01748764f, 0.03964478f, -0.00581072f, 
    -0.05598273f, -0.05794443f, 0.00228035f, 0.04162582f, -0.06564884f, -0.00876472f, 0.00971463f, -0.04453418f, 
    -0.03238735f, 0.02662348f, 0.04905204f, 0.00087370f, -0.05235888f, 0.03646346f, -0.03831767f, -0.06105050f, 
    0.00569236f, -0.05648514f, -0.02644991f, 0.03454420f, -0.00078433f, -0.04828850f, -0.03648327f, -0.00042549f, 
    0.00955122f, -0.03271251f, 0.04318566f, -0.06203349f, -0.00378536f, -0.04881584f, -0.04951394f, 0.01944684f, 
    0.00031106f, 0.03798126f, 0.01220323f, -0.02681594f, -0.03798522f, 0.00476617f, -0.02765291f, -0.02540747f, 
    -0.04681345f, -0.03924240f, -0.04173065f, -0.04286547f, -0.04467477f, 0.01765741f, 0.02597468f, 0.00428168f, 
    0.00907343f, 0.00449126f, 0.02906694f, 0.01132603f, -0.03876223f, -0.02691486f, 0.03672058f, -0.00094282f, 
    0.01621471f, 0.02078955f, 0.01352081f, -0.01620225f, -0.05687863f, -0.03899561f, -0.06032931f, -0.00848629f, 
    0.03096468f, 0.01596686f, 0.00339355f, 0.03912538f, -0.02467173f, -0.01161614f, 0.04814172f, -0.03942807f, 
    -0.04340296f, -0.04849493f, 0.03553482f, -0.02644041f, 0.02270249f, -0.02314213f, -0.01840047f, -0.06321216f, 
    -0.04330212f, 0.03203103f, 0.00177539f, -0.00006808f, -0.00680030f, -0.00773042f, 0.03355729f, -0.01121663f, 
    0.02400136f, -0.00301094f, 0.03296330f, 0.04597104f, 0.01984378f, 0.04104954f, 0.03430723f, -0.04913242f, 
    0.01732168f, -0.04873919f, -0.01960546f, -0.00852324f, -0.05338423f, -0.00536620f, 0.02013654f, -0.04502685f, 
    0.04208159f, -0.01730632f, 0.01917232f, -0.06408731f, -0.03137814f, -0.00840817f, 0.00714324f, -0.01581834f, 
    -0.02716196f, -0.05145377f, 0.02395682f, -0.01282388f, -0.00488679f, 0.04380589f, 0.03950442f, -0.00431569f, 
    -0.01817606f, 0.01604064f, 0.01555492f, 0.04968599f, 0.04187658f, 0.03969692f, -0.02742592f, 0.04016186f, 
    -0.05832735f, 0.03764976f, 0.00355380f, -0.00405042f, -0.02332446f, 0.03324461f, -0.04836353f, -0.04149103f, 
    0.01963498f, -0.07032353f, -0.01237250f, -0.04656531f, -0.03484042f, -0.04161424f, -0.00405907f, -0.03963060f, 
    0.04867037f, 0.04654230f, 0.02086359f, -0.01021649f, 0.02642048f, -0.01786571f, -0.05235859f, 0.01042208f, 
    -0.02836588f, -0.03355493f, -0.00515132f, -0.04762668f, 0.05120292f, -0.02813900f, -0.03114863f, 0.01156941f, 
    -0.00662138f, -0.02155528f, -0.04999781f, -0.05222625f, 0.00699665f, 0.04087465f, 0.04193031f, -0.03101719f, 
    -0.03126914f, 0.02488608f, 0.03902932f, 0.01589894f, 0.00753858f, -0.03366689f, 0.01311925f, -0.01929150f, 
    0.04540018f, -0.02038437f, 0.03343786f, 0.03346967f, -0.00361472f, 0.00122998f, -0.06294484f, 0.04284544f, 
    -0.01172396f, -0.04168931f, -0.02837361f, 0.01957651f, 0.03023250f, -0.03957561f, 0.04819701f, 0.05255535f, 
    -0.04033221f, -0.01751685f, -0.01110165f, -0.06545044f, 0.04292194f, -0.03817160f, -0.03242218f, -0.03429911f, 
    -0.03960188f, 0.04512965f, 0.02898089f, -0.05514868f, -0.00924188f, 0.02085510f, -0.03807765f, 0.04033057f, 
    -0.06418649f, -0.02542942f, -0.02950630f, 0.05261551f, -0.04857815f, -0.05425393f, -0.05560923f, -0.05030493f, 
    0.03352455f, -0.05190090f, -0.03020895f, -0.04351531f, 0.00741963f, -0.02730274f, 0.02716053f, 0.01387961f, 
    0.01378356f, -0.01274385f, 0.02705310f, 0.02359588f, -0.04405827f, -0.02609429f, 0.02891035f, 0.04490694f, 
    0.03208700f, -0.06151397f, -0.01976155f, 0.00925138f, 0.00521144f, -0.03644148f, -0.04429636f, 0.02260882f, 
    0.04598829f, -0.05617060f, -0.05666371f, -0.06764515f, 0.04250508f, -0.06120728f, -0.04889799f, -0.05053299f, 
    0.03176330f, -0.03783419f, -0.01715976f, -0.04461582f, -0.05342903f, -0.03242157f, 0.02546051f, -0.03170970f, 
    -0.03003918f, -0.03427712f, 0.01933441f, 0.01866477f, -0.01437041f, 0.00749403f, -0.02210425f, -0.05287793f, 
    -0.01305070f, -0.05085400f, 0.03452281f, -0.04434778f, 0.02500929f, 0.04708041f, 0.04156845f, -0.02998509f, 
    0.15819129f, -0.00247437f, -0.41060770f, -0.18916850f, 0.12352458f, 0.10365465f, 0.14022741f, 0.14720401f, 
    0.08419374f, -0.11755850f, 0.07170915f, 0.07247936f, 0.23973159f, 0.09293707f, -0.14002050f, 0.03114712f, 
    0.05158976f, 0.07212725f, 0.12912974f, 0.05725650f, 0.13330807f, -0.05806084f, -0.06531946f, -0.24141669f, 
    -0.10203014f, -0.06264139f, -0.05543798f, 0.07404249f, -0.00445897f, -0.19855078f, -0.20008764f, 0.08580407f, 
    0.05484048f, -0.01279966f, 0.13061978f, -0.00077715f, 0.15113409f, 0.10373657f, 0.01488118f, -0.14814149f, 
    -0.10960320f, -0.07955965f, -0.00423178f, -0.06178928f, -0.00741100f, 0.04774325f, -0.08693237f, -0.16124478f, 
    0.13535322f, 0.13846686f, 0.21614325f, -0.11786525f, -0.28143516f, 0.06100666f, 0.27805910f, -0.06740912f, 
    0.09813914f, 0.11476916f, -0.00592851f, -0.11093655f, -0.01654676f, -0.05415457f, 0.00513035f, -0.10139402f, 
    -0.09628150f, 0.07118361f, -0.04877152f, 0.03660060f, -0.10027149f, -0.04060513f, 0.01963524f, 0.30071980f, 
    -0.22940721f, -0.16523550f, -0.06191807f, -0.07718437f, -0.22896273f, -0.05711601f, 0.04508711f, 0.04982021f, 
    -0.07679491f, -0.18361980f, 0.30567849f, 0.07838008f, 0.25977913f, 0.09544107f, 0.02672959f, 0.02363025f, 
    -0.01218329f, -0.02667689f, -0.48264924f, -0.10335282f, -0.61134261f, 0.14700095f, 0.08796535f, 0.02300230f, 
    0.04354441f, -0.12919536f, 0.06349996f, -0.09603121f, -0.03598354f, -0.06806448f, 0.07425299f, 0.21743637f, 
    0.07790846f, -0.01467450f, 0.00851082f, 0.01326991f, 0.02899728f, 0.18844140f, -0.08682989f, 0.01535115f, 
    0.05970755f, 0.07691679f, 0.15721877f, 0.04818820f, 0.12590055f, 0.01243526f, 0.07509062f, -0.03410980f, 
    -0.17373084f, -0.05792299f, -0.05969340f, 0.19626574f, 0.17518519f, 0.03574754f, 0.20071834f, -0.07442177f, 
    -0.22834459f, 0.17972293f, 0.01920501f, -0.00205597f, 0.03408965f, -0.05377633f, 0.02706051f, -0.43413815f, 
    -0.03338150f, 0.00246320f, -0.07430182f, 0.02402925f, 0.06106111f, -0.08453155f, 0.02477269f, -0.13166818f, 
    -0.17451538f, 0.13295084f, -0.11209919f, 0.07884614f, -0.05940722f, 0.04177226f, -0.15795025f, 0.00184890f, 
    0.05363541f, 0.07512381f, 0.07412214f, 0.14990066f, 0.02446665f, -0.13134925f, 0.12625259f, 0.18795380f, 
    0.07976779f, 0.16435735f, 0.20292355f, 0.05081877f, -0.28422043f, 0.11511090f, 0.11530717f, 0.22318682f, 
    -0.13353930f, 0.06266183f, 0.07796491f, 0.27778187f, -0.14715481f, -0.31803986f, 0.16581602f, 0.02445482f, 
    -0.14826068f, -0.07916325f, 0.15597858f, -0.12619972f, 0.00847027f, -0.02194888f, -0.15833020f, -0.19226187f, 
    -0.07512987f, -0.06689752f, -0.05183508f, -0.05772439f, -0.08393681f, -0.01082605f, 0.06561261f, 0.16966105f, 
    -0.09959685f, -0.18913592f, -0.09730789f, 0.13013811f, -0.02302858f, -0.03733240f, -0.13445902f, 0.05227253f, 
    0.18841933f, 0.10872258f, 0.03278296f, -0.06426728f, 0.13201043f, 0.13900955f, -0.04976302f, -0.41632557f, 
    -0.08125820f, -0.02552937f, -0.00841038f, 0.09065088f, -0.00114780f, -0.02700299f, -0.17150815f, 0.08254985f, 
    0.39297271f, -0.10387644f, -0.15237284f, 0.15423712f, 0.06181432f, 0.00395663f, 0.09094480f, 0.08612958f, 
    -0.00554218f, -0.06958703f, -0.02545189f, 0.10513537f, -0.11472937f, -0.00658371f, 0.08100239f, 0.19798653f, 
    0.08902805f, -0.08740219f, -0.12534392f, -0.18625902f, -0.16010663f, -0.02168326f, 0.09909360f, -0.20710883f, 
    0.03815213f, -0.03208978f, 0.02382165f, -0.11676400f, 0.23551720f, 0.21015912f, 0.04274401f, -0.18583019f, 
    -0.20653585f, 0.12159508f, 0.07598353f, 0.15929604f, -0.23425500f, -0.15707317f, 0.07541345f, -0.12196941f, 
    0.01163665f, -0.05858934f, 0.09450887f, 0.21356761f, 0.08590085f, -0.45179540f, 0.14814670f, -0.04054354f, 
    -0.12349615f, 0.11842951f, 0.17232013f, -0.22198254f, -0.01100641f, 0.12430131f, 0.35433650f, -0.27305803f, 
    -0.23300928f, 0.09995998f, -0.03687689f, 0.09517275f, 0.04150017f, 0.09660357f, 0.13747717f, 0.04864290f, 
    0.08940407f, 0.03202493f, 0.10744914f, -0.10833832f, -0.03748531f, -0.03057383f, 0.10610189f, 0.02177647f, 
    -0.05796148f, -0.01793718f, -0.06611919f, -0.02836760f, -0.00473678f, -0.04755508f, -0.03931284f, -0.01342612f, 
    -0.02303157f, -0.04636891f, -0.03696283f, 0.01353473f, -0.06598566f, -0.01350896f, 0.00920835f, -0.01306259f, 
    -0.08664909f, -0.07091150f, 0.00126559f, -0.04723024f, -0.08637430f, -0.03330232f, -0.02982796f, 0.01717608f, 
    -0.00980690f, -0.05390254f, -0.01283926f, 0.01710997f, -0.05538615f, -0.07143772f, -0.07265060f, 0.01034659f, 
    0.01357827f, -0.07901018f, -0.08731309f, 0.00955961f, -0.03499554f, -0.08884954f, -0.03256730f, -0.04272719f, 
    0.01912830f, -0.00155081f, -0.07246588f, -0.03854450f, -0.01783521f, 0.01142787f, 0.01558175f, -0.03988056f, 
    -0.07695374f, 0.02731138f, 0.00584854f, -0.04143278f, -0.00554620f, -0.04666640f, -0.00040910f, -0.03127900f, 
    -0.03673718f, -0.06741655f, 0.01964487f, -0.05975267f, 0.00511053f, -0.04884020f, -0.00358346f, -0.08538169f, 
    -0.07860681f, 0.00577275f, -0.00255805f, -0.07289726f, -0.01335911f, -0.03978399f, -0.01736397f, 0.00414988f, 
    -0.08478961f, -0.03032805f, 0.01546908f, 0.02669155f, 0.01724228f, -0.05600128f, 0.01048647f, -0.05092198f, 
    -0.04445715f, -0.02993141f, -0.07511371f, -0.08657353f, -0.06889940f, -0.07406036f, -0.00152665f, 0.00344568f, 
    -0.06663226f, -0.04989656f, -0.05151548f, -0.07014146f, -0.08530924f, 0.02310206f, 0.00793002f, -0.00224276f, 
    -0.00142596f, -0.06930815f, -0.07109723f, -0.08902487f, -0.02320305f, 0.00327250f, 0.01199377f, -0.07613487f, 
    0.02316078f, -0.05180533f, -0.01539586f, 0.00816918f, -0.04458500f, 0.02272887f, 0.00905969f, -0.05044431f, 
    0.02127584f, 0.04645095f, -0.02232864f, -0.05287655f, -0.02669282f, -0.07726744f, -0.01121598f, -0.02214936f, 
    -0.08652423f, -0.05442568f, -0.05269806f, -0.01226403f, -0.06243690f, -0.01373743f, 0.02346329f, -0.05867096f, 
    -0.06707551f, -0.00551001f, -0.05997365f, -0.04290995f, 0.02371886f, -0.04715402f, -0.01498865f, -0.05026420f, 
    -0.08532005f, -0.01331547f, -0.02097835f, -0.06845982f, -0.01628741f, -0.00579524f, -0.01450105f, -0.02380498f, 
    -0.04661702f, -0.04425651f, -0.03807992f, -0.02387033f, -0.07293247f, -0.05634761f, 0.02640867f, 0.00793997f, 
    0.00677115f, 0.00302258f, -0.06759173f, -0.07023074f, -0.06715871f, -0.08903022f, -0.01504733f, -0.08177702f, 
    -0.02058403f, -0.06629170f, -0.04547612f, -0.02203705f, -0.04123506f, -0.08896495f, -0.04322333f, 0.02273033f, 
    -0.08468782f, -0.01859362f, -0.07619028f, -0.04329615f, -0.07467508f, -0.08404754f, -0.00629096f, -0.01125087f, 
    -0.04521916f, -0.03968214f, -0.04748393f, 0.01592446f, -0.01535507f, -0.06845178f, 0.01642056f, -0.02523088f, 
    -0.05163451f, -0.05207685f, -0.02498985f, -0.05981499f, -0.04508511f, 0.00844000f, -0.03653605f, -0.08723366f, 
    -0.01598403f, 0.00015887f, -0.02603017f, 0.02712190f, -0.01057846f, -0.01982226f, -0.07102704f, -0.07056676f, 
    -0.00721455f, -0.07599747f, -0.04022846f, -0.05736656f, -0.05564682f, -0.02157970f, -0.02116935f, 0.00710163f, 
    -0.07274149f, -0.00561380f, -0.05386959f, 0.02159448f, -0.03982538f, -0.01835243f, -0.01316698f, -0.01453301f, 
    0.00268405f, -0.07650692f, 0.01181827f, -0.08117742f, -0.03820561f, -0.05392960f, -0.01002474f, -0.08547670f, 
    -0.04576610f, -0.04525194f, -0.03016359f, -0.07768346f, -0.03882239f, -0.06845531f, 0.02314735f, -0.08599320f, 
    -0.04629416f, -0.05947686f, -0.04394038f, 0.02484273f, -0.02512266f, 0.01082167f, -0.01278809f, -0.05267788f, 
    -0.04063170f, -0.01065688f, -0.02999207f, -0.07422940f, 0.01757102f, 0.00871131f, -0.04653123f, -0.00459101f, 
    -0.02493669f, -0.05040893f, -0.04492505f, -0.00762421f, 0.00437586f, -0.05932146f, 0.01796307f, -0.02222414f, 
    -0.05757292f, -0.04051546f, -0.08585653f, -0.06760665f, -0.00385653f, -0.00461967f, -0.03976751f, 0.00160956f, 
    -0.07177401f, -0.05976126f, -0.01470821f, -0.06099750f, -0.01850811f, -0.02210142f, -0.05513572f, -0.00211601f, 
    0.01525884f, -0.02193286f, -0.07953108f, -0.08829741f, -0.07426918f, 0.00764740f, -0.06694726f, -0.06437458f, 
    0.02407481f, -0.02651057f, -0.05806743f, -0.07208514f, -0.08307195f, -0.06952400f, -0.03782459f, -0.03632561f, 
    -0.18570910f, -0.22986375f, -0.07204014f, 0.14103831f, -0.02889400f, -0.10593954f, 0.00092247f, 0.15201314f, 
    -0.34821120f, -0.10468159f, 0.03793649f, 0.15838182f, -0.19041497f, 0.07008985f, -0.20665187f, 0.18042766f, 
    -0.02793265f, 0.27092716f, 0.08135273f, 0.04127047f, 0.02871428f, 0.03406576f, 0.11181230f, 0.08206308f, 
    0.12003452f, -0.01019629f, 0.09275836f, 0.22406273f, 0.19172481f, 0.12219289f, 0.06604183f, 0.14099012f, 
    0.04892174f, 0.07252172f, 0.00254837f, 0.03216171f, 0.13509820f, -0.09742247f, -0.04687048f, -0.08403088f, 
    0.08716816f, -0.01802799f, 0.15625209f, 0.07658950f, 0.18481195f, 0.12400664f, 0.21716952f, 0.12594841f, 
    -0.21870817f, -0.04797307f, 0.05771408f, -0.29293701f, -0.16949713f, 0.02351667f, -0.38696247f, 0.01061003f, 
    -0.25821751f, -0.06299058f, 0.00037942f, 0.21937329f, 0.02071523f, -0.01321323f, -0.20281795f, 0.02011584f, 
    0.03529605f, 0.10244159f, -0.08665258f, -0.07030692f, -0.16777278f, -0.12601516f, -0.16090828f, 0.08689187f, 
    -0.08054440f, -0.01969984f, 0.12909481f, -0.13976108f, -0.17662126f, -0.17560288f, -0.03836256f, -0.04723477f, 
    0.08775155f, 0.20818201f, 0.12548886f, -0.00979201f, 0.17071803f, 0.23378910f, 0.17218983f, -0.09906986f, 
    0.03480777f, -0.06851254f, 0.28100187f, 0.04058864f, 0.00375101f, -0.11058801f, 0.07238979f, -0.10050599f, 
    -0.03686286f, 0.09976144f, -0.08451443f, -0.31111291f, 0.18805294f, 0.17987080f, 0.13453998f, -0.03457885f, 
    -0.00067524f, 0.05783348f, 0.08149839f, 0.10299622f, -0.02164578f, -0.10934366f, -0.04726039f, 0.08029962f, 
    0.01957171f, 0.03320654f, -0.03360237f, 0.05199446f, -0.21009728f, -0.24013874f, -0.10726894f, -0.11379981f, 
    -0.05682615f, 0.00055941f, 0.21527044f, 0.14386161f, 0.02787923f, -0.13870795f, -0.26376635f, 0.13100007f, 
    0.20341150f, 0.17099449f, -0.00235916f, 0.17663808f, -0.05141567f, 0.03236063f, 0.22540849f, 0.17777029f, 
    -0.05268401f, 0.00006844f, -0.05748157f, 0.11803775f, -0.07621326f, 0.15068296f, 0.23239441f, 0.06205221f, 
    0.13364859f, 0.09212662f, -0.04078150f, -0.19358197f, 0.13047397f, -0.09248389f, -0.15593939f, 0.05645911f, 
    0.04945786f, -0.02449533f, -0.13989708f, -0.07179993f, -0.00133610f, 0.09205476f, 0.11847059f, 0.14745624f, 
    0.11702179f, -0.01254959f, -0.07793400f, 0.11346124f, -0.05496910f, -0.21564190f, -0.11075008f, -0.14365909f, 
    -0.07389982f, -0.04475012f, 0.05155914f, -0.09196430f, 0.08321866f, 0.08499176f, 0.08195999f, -0.02621921f, 
    0.13743393f, -0.05978887f, 0.13371257f, 0.01034551f, -0.08166820f, -0.17261584f, -0.29208574f, -0.17499462f, 
    -0.00431697f, -0.10176506f, -0.05290715f, 0.11872393f, -0.14954603f, 0.02173618f, 0.11506093f, -0.11767518f, 
    0.08381872f, -0.02908918f, 0.04144920f, -0.13449152f, 0.15513475f, 0.03308639f, 0.09210549f, 0.10387690f, 
    -0.00499852f, 0.10021259f, -0.02414069f, -0.07767841f, 0.03579669f, -0.13967478f, 0.06066514f, -0.22196645f, 
    0.08144978f, -0.07448054f, 0.18911381f, 0.15309541f, -0.09760653f, 0.05476556f, -0.12972179f, -0.28602290f, 
    0.01992011f, 0.07983943f, 0.13388801f, 0.11569617f, -0.04746753f, 0.04140629f, -0.07890713f, 0.02421224f, 
    0.10673654f, -0.19998784f, 0.03493436f, -0.20797434f, -0.03964679f, 0.11849074f, -0.22069608f, 0.14728668f, 
    -0.16196385f, 0.29831415f, 0.06492043f, -0.17373505f, -0.11933424f, 0.01200813f, 0.13101684f, 0.03936918f, 
    -0.00905862f, -0.21610081f, 0.09172902f, 0.24145687f, 0.05265099f, 0.09975436f, 0.02497386f, 0.02704369f, 
    0.10373660f, 0.05270505f, 0.00649856f, -0.01795021f, 0.13198639f, -0.04131834f, -0.22322521f, -0.25283962f, 
    -0.12794185f, 0.05388885f, 0.05748842f, 0.17925812f, 0.02933990f, 0.23205815f, 0.07553106f, -0.11295765f, 
    -0.21692492f, 0.05556794f, -0.00429452f, 0.08571830f, 0.07489339f, 0.10298331f, -0.01667666f, 0.05553149f, 
    -0.07847917f, 0.10879602f, 0.10062486f, -0.01310439f, 0.01400163f, -0.09180663f, 0.05905390f, -0.04470909f, 
    -0.05084434f, -0.25178006f, 0.10320804f, -0.00271115f, -0.03326913f, 0.11401147f, 0.13154154f, 0.13837381f, 
    0.06598106f, -0.02692465f, 0.11256405f, -0.02356313f, -0.09896039f, -0.01975391f, -0.02339187f, -0.04647473f, 
    -0.04290481f, -0.46406510f, 0.13686237f, 0.04574701f, 0.10983934f, 0.07799686f, -0.01917857f, 0.04109472f, 
    -0.09533301f, 0.04268020f, 0.18673237f, 0.04502313f, -0.19818914f, -0.08154676f, 0.17919870f, 0.00614381f, 
    0.00473537f, -0.06565846f, 0.02183610f, 0.02199652f, 0.13026080f, 0.01334835f, -0.10217479f, -0.13576669f, 
    0.09420273f, 0.04147486f, 0.04644429f, 0.02793297f, -0.10664649f, 0.16428360f, 0.06019948f, 0.05796477f, 
    0.15913288f, 0.02659200f, -0.04482851f, 0.12809038f, -0.08756632f, 0.02763568f, -0.13392459f, -0.34246397f, 
    -0.11601803f, 0.01099520f, 0.12136489f, -0.04320674f, 0.03541047f, -0.02281410f, -0.22211684f, 0.15010317f, 
    0.05459920f, 0.02907994f, -0.03838630f, -0.05734224f, 0.04467511f, 0.04339174f, 0.09465365f, 0.23522617f, 
    0.09087980f, -0.27070001f, 0.01607248f, -0.00113813f, -0.07725304f, -0.03723873f, 0.06729095f, -0.10201670f, 
    0.15658425f, 0.20706369f, -0.31182599f, 0.15603980f, -0.05377086f, 0.02963730f, -0.13293105f, -0.09228406f, 
    -0.03527839f, 0.31635380f, 0.04537038f, 0.01870959f, -0.11504099f, -0.10034136f, 0.06197217f, -0.07267231f, 
    0.10161674f, -0.01443028f, -0.16333458f, 0.11057762f, -0.09766739f, 0.22246237f, -0.08217388f, 0.03559702f, 
    -0.21861671f, -0.01301337f, -0.02404551f, 0.34177211f, -0.27484953f, -0.00931004f, 0.11303362f, 0.13451511f, 
    -0.00599298f, 0.01000287f, 0.09329803f, 0.05325333f, -0.19968709f, -0.17542255f, -0.02125250f, -0.06489691f, 
    0.22381671f, -0.20488085f, -0.03626158f, -0.00202598f, -0.05627272f, -0.23383832f, 0.16499163f, -0.29790890f, 
    0.11651752f, -0.02757521f, 0.05532473f, 0.12430203f, -0.05604091f, 0.03231017f, 0.34624407f, 0.16393320f, 
    0.05240564f, -0.01061833f, 0.00277950f, 0.02952887f, 0.04301407f, -0.07275507f, -0.14925119f, -0.08262675f, 
    -0.25391486f, 0.00801717f, -0.04504196f, -0.07255913f, 0.09388761f, -0.01515880f, -0.00513542f, -0.06374289f, 
    0.08523334f, -0.19720416f, -0.24259700f, 0.02260070f, 0.05285510f, 0.06033293f, -0.03408182f, 0.02570502f, 
    -0.01863636f, -0.11220866f, -0.02752982f, 0.01971090f, 0.07632854f, 0.16960472f, 0.05481448f, -0.04900611f, 
    -0.05704169f, 0.05271580f, 0.05961721f, -0.04323216f, -0.40207848f, 0.03031113f, 0.12949730f, -0.12165097f, 
    -0.02520577f, 0.14305632f, 0.13630141f, 0.27821171f, 0.14981979f, 0.21685457f, -0.34248027f, -0.01444073f, 
    0.00524043f, -0.12282487f, 0.05446801f, 0.24676342f, -0.48660913f, 0.13260536f, -0.02069554f, 0.09831886f, 
    0.04927498f, 0.03968687f, -0.08043474f, 0.07195473f, 0.10374695f, -0.00319017f, 0.02370867f, -0.03419665f, 
    0.01560399f, 0.15005164f, 0.00150054f, 0.09491680f, 0.17376462f, 0.04595584f, 0.20115420f, -0.14818065f, 
    -0.25951180f, -0.10984317f, 0.18362865f, -0.09071008f, 0.02349500f, -0.12694308f, -0.17209116f, 0.48311704f, 
    -0.10046128f, 0.02582918f, -0.08120798f, -0.14173450f, -0.06505370f, -0.13942032f, -0.10205682f, -0.19403942f, 
    0.09519563f, 0.09325534f, 0.09480192f, -0.22555166f, 0.03409295f, -0.06057218f, 0.17662966f, -0.03960953f, 
    0.08407925f, 0.03654027f, -0.31926519f, -0.07243331f, 0.01373879f, -0.00440182f, -0.06559779f, 0.00306875f, 
    -0.01866047f, 0.06132638f, 0.23468111f, -0.07530674f, -0.05077672f, -0.05612574f, -0.15739156f, -0.07948620f, 
    0.14629114f, -0.06583874f, 0.17221054f, 0.13004826f, -0.08409141f, -0.12628907f, 0.04500517f, 0.12507738f, 
    0.00557247f, 0.03086916f, -0.04614541f, -0.00698867f, -0.35159129f, 0.15151779f, -0.08359487f, -0.00039027f, 
    -0.09824679f, 0.05292445f, 0.00434382f, 0.05952023f, 0.15870735f, 0.22182003f, -0.22086340f, -0.37328270f, 
    -0.17169747f, -0.03907752f, 0.12523784f, -0.05370895f, -0.07882203f, -0.09513784f, 0.22644755f, 0.06916145f, 
    -0.03976409f, -0.14023688f, -0.05625536f, 0.02969966f, 0.08842332f, -0.01512919f, 0.11632301f, -0.29399002f, 
    0.11296181f, 0.19546884f, -0.09193616f, 0.17789353f, 0.03525038f, -0.07848782f, -0.04020729f, 0.16270575f, 
    -0.02124270f, -0.01224875f, 0.02013391f, 0.04863835f, -0.02358344f, -0.06963071f, 0.02558173f, -0.04773100f, 
    -0.03749291f, 0.03970815f, -0.00888227f, -0.00115023f, 0.01852776f, -0.04459048f, 0.04705597f, -0.06501820f, 
    0.03254859f, -0.00168416f, -0.06323829f, 0.02534530f, 0.02708559f, -0.06131049f, -0.05471122f, -0.06025144f, 
    0.00442074f, -0.01271479f, -0.06127172f, 0.00587608f, 0.05547980f, -0.03216010f, 0.01824310f, -0.01079468f, 
    -0.03537335f, -0.01467422f, 0.01217962f, -0.01089856f, -0.01695103f, -0.00495347f, -0.01926884f, -0.00440977f, 
    -0.03080439f, -0.05111552f, 0.03131282f, -0.01191077f, -0.03139542f, 0.01883478f, 0.03001604f, -0.01352892f, 
    0.00753048f, 0.02696191f, -0.02149374f, -0.01626956f, -0.02169351f, -0.04243397f, -0.01853204f, 0.01703774f, 
    -0.01005421f, 0.05878065f, 0.02529707f, 0.00832421f, 0.04971521f, 0.02926163f, 0.02113605f, 0.02644800f, 
    0.02299975f, -0.03326945f, 0.01447308f, 0.05622477f, 0.00720926f, -0.03366438f, -0.03658476f, -0.03716179f, 
    0.00778249f, -0.06427281f, 0.00566060f, -0.04093857f, 0.00936445f, -0.03642726f, 0.02348260f, 0.00408994f, 
    -0.03580911f, 0.03377058f, 0.00071674f, -0.05095815f, -0.04834062f, -0.06048865f, 0.03138682f, 0.05235109f, 
    -0.06751179f, -0.06222805f, -0.04075995f, -0.00908095f, -0.02358688f, 0.04839892f, -0.00772933f, 0.03095723f, 
    0.03354738f, -0.03130672f, -0.03212012f, -0.04769552f, 0.04262199f, 0.01909163f, -0.06023131f, 0.04065451f, 
    0.00649316f, 0.03439375f, -0.04459983f, 0.04634538f, -0.00492318f, 0.00817866f, 0.00752187f, -0.01395003f, 
    -0.02856058f, -0.00355915f, -0.02668753f, 0.04302730f, -0.00028412f, 0.00346229f, -0.01391060f, 0.00161685f, 
    0.01536417f, 0.03891413f, -0.00884700f, -0.05208676f, 0.03106248f, -0.02190199f, -0.03437947f, -0.01871685f, 
    0.04050227f, -0.05395687f, -0.00150314f, 0.03171614f, 0.02414132f, -0.01581882f, 0.01189584f, 0.04613026f, 
    -0.00235358f, -0.05821007f, 0.05186708f, -0.03403175f, -0.02437185f, 0.04682212f, -0.05964657f, -0.04984136f, 
    -0.06229623f, -0.05402349f, -0.07122343f, 0.01080363f, 0.02934738f, -0.01517461f, -0.05207779f, 0.01183181f, 
    -0.06414583f, -0.02335857f, 0.05353257f, -0.05012850f, 0.03473050f, 0.02753633f, 0.00656791f, -0.03793974f, 
    0.01080069f, 0.03738017f, -0.04427263f, -0.00999433f, -0.06441170f, 0.00434219f, 0.02826427f, -0.06569310f, 
    -0.00060613f, -0.05868681f, -0.01036867f, -0.02395700f, -0.00768801f, 0.00842137f, -0.04301676f, -0.01771210f, 
    0.04379500f, -0.04577580f, 0.04045076f, 0.01159409f, -0.00178180f, -0.00880619f, -0.05292770f, 0.04661233f, 
    -0.06336585f, 0.02951560f, -0.04784058f, 0.04566541f, 0.04674511f, -0.04085619f, -0.01976984f, -0.00615346f, 
    -0.02694256f, 0.04981263f, 0.03855325f, -0.05843173f, 0.02655539f, -0.03851115f, 0.03159687f, -0.05573954f, 
    -0.02561612f, 0.03798604f, 0.02961417f, -0.01030567f, 0.02244170f, -0.02044343f, -0.05628080f, 0.02617761f, 
    0.04191767f, -0.05670105f, -0.05448207f, 0.02317188f, -0.00333740f, 0.00393327f, -0.00365507f, 0.05146777f, 
    0.03627331f, 0.03491371f, 0.00750381f, 0.04269309f, -0.05846579f, -0.05593337f, 0.01478755f, 0.00617243f, 
    0.04491663f, -0.02249333f, -0.02217216f, 0.00805700f, -0.03435219f, 0.02758930f, -0.00751735f, 0.05303632f, 
    -0.06760781f, 0.04021821f, 0.04416817f, -0.06781719f, -0.02304377f, 0.05123545f, 0.01157928f, 0.00580136f, 
    -0.04719495f, 0.01787269f, 0.03803499f, 0.02403498f, -0.05715356f, 0.04311777f, -0.00769331f, -0.00729880f, 
    -0.03248788f, 0.00038317f, -0.05185182f, -0.02117431f, 0.05466088f, 0.00105077f, -0.02371504f, -0.05160427f, 
    -0.04919325f, -0.03618841f, -0.05140836f, -0.00495699f, -0.03551104f, -0.01242887f, -0.00801625f, 0.01817965f, 
    -0.00145455f, -0.02378695f, 0.03162645f, -0.01417634f, 0.02466425f, -0.05358182f, -0.00951692f, -0.01162244f, 
    -0.06474482f, 0.01490053f, 0.02668150f, -0.04679521f, -0.00108035f, -0.04022040f, -0.01635522f, -0.03233360f, 
    -0.04672721f, 0.01077967f, 0.05647286f, 0.02300895f, -0.03029602f, 0.03626095f, 0.01796006f, -0.03298420f, 
    -0.21497674f, -0.06758191f, 0.09480929f, 0.14605039f, -0.10156701f, -0.06627429f, -0.13608284f, 0.06389552f, 
    -0.12663606f, 0.10509785f, 0.08360842f, 0.09768255f, -0.15196687f, -0.00185037f, 0.11028751f, 0.02765914f, 
    0.06016503f, 0.10986084f, 0.26932517f, 0.15274203f, 0.20532635f, 0.06407352f, -0.01161121f, 0.03070993f, 
    -0.16521044f, -0.03324914f, -0.08397388f, 0.21436249f, 0.14134565f, 0.04860761f, -0.08938131f, 0.02187993f, 
    -0.00244139f, -0.08189538f, -0.03819542f, 0.01915186f, 0.35990563f, 0.17072235f, 0.09175973f, -0.10764240f, 
    -0.12083634f, 0.01703480f, -0.03721762f, -0.01407686f, -0.04039740f, -0.14011724f, -0.27866486f, 0.03854683f, 
    -0.01482787f, 0.18194549f, 0.06800235f, -0.05906648f, -0.00387604f, -0.37153685f, 0.21416917f, -0.15232241f, 
    0.02156310f, 0.00753941f, 0.12173703f, 0.18393244f, -0.01100360f, -0.07250840f, -0.12014877f, 0.01457986f, 
    0.01240969f, 0.10579050f, 0.00501531f, -0.04925689f, 0.13373223f, 0.00910936f, -0.12734747f, 0.06008971f, 
    0.05325152f, -0.02394140f, -0.07604588f, 0.08557218f, 0.10192154f, -0.06129929f, -0.07961242f, -0.13510434f, 
    0.01715536f, -0.21910681f, -0.27419963f, 0.19138946f, 0.06167725f, 0.05876463f, -0.13499345f, -0.09124868f, 
    -0.07938603f, -0.02987402f, -0.28825521f, 0.06802049f, 0.06168709f, -0.12335458f, 0.19990006f, -0.00598872f, 
    -0.05884033f, -0.07899128f, 0.08278764f, -0.23504755f, -0.22919552f, -0.18824118f, 0.17816249f, 0.13089274f, 
    0.10803049f, 0.09851404f, -0.20864534f, -0.12472454f, 0.13569728f, -0.11810915f, -0.05005789f, -0.14321709f, 
    -0.07133709f, -0.05518823f, 0.01536154f, 0.02806675f, -0.01018808f, 0.10111967f, -0.09386820f, 0.14856057f, 
    -0.05803720f, 0.16642454f, -0.03102476f, 0.07583272f, -0.10951649f, 0.03009893f, -0.10327587f, -0.15389627f, 
    -0.14974034f, 0.18317616f, 0.01950085f, 0.09141121f, 0.00924349f, -0.18841715f, -0.09622448f, -0.15285039f, 
    -0.01474193f, -0.29869929f, 0.08880567f, 0.02648753f, -0.10631254f, -0.09280181f, 0.14610016f, 0.10568966f, 
    0.01332070f, 0.12556134f, 0.06592234f, 0.02174686f, -0.01605264f, -0.05790718f, -0.07968381f, 0.05238850f, 
    0.13096763f, 0.01211859f, 0.10857525f, 0.08896088f, 0.01561929f, -0.08218964f, -0.11017632f, -0.02128120f, 
    0.05490507f, 0.01426667f, -0.09844811f, -0.08141106f, -0.08651014f, -0.18585244f, 0.05968992f, 0.07730925f, 
    -0.02899468f, 0.09560227f, -0.09909113f, -0.00998513f, -0.33979914f, 0.09348211f, 0.17083785f, 0.15752760f, 
    0.09202024f, -0.04430260f, -0.08525359f, -0.20507513f, 0.27580628f, 0.24519154f, 0.06772303f, -0.06018646f, 
    -0.15182535f, 0.06741415f, -0.01112846f, 0.04489894f, 0.05183167f, 0.16565558f, 0.02972127f, 0.06114804f, 
    -0.23150665f, -0.07727439f, 0.08338870f, 0.08587087f, -0.00272217f, -0.08003481f, -0.03455996f, 0.03729712f, 
    0.14989962f, -0.02073175f, 0.04654377f, -0.14245331f, 0.12486759f, 0.03013054f, 0.18189144f, -0.13107932f, 
    0.01063557f, -0.02694009f, -0.00569697f, 0.12548478f, -0.08314206f, -0.02308359f, 0.02870164f, -0.02746290f, 
    0.02802167f, 0.16336067f, -0.31477711f, 0.09121481f, 0.00753663f, -0.03717770f, 0.01894683f, -0.06547086f, 
    0.02529619f, -0.13349515f, 0.00024694f, -0.16172050f, 0.16793592f, 0.12481774f, -0.07656397f, 0.11430871f, 
    0.07290516f, 0.02128844f, -0.21895523f, -0.25776631f, 0.22323258f, -0.03947451f, 0.12418054f, -0.01709195f, 
    -0.02037641f, -0.04771878f, -0.14166230f, 0.13279004f, -0.05328439f, 0.09458416f, 0.09522185f, -0.04826821f, 
    0.03655202f, 0.00061847f, 0.08258433f, 0.02242879f, 0.03292096f, 0.05845349f, 0.06795866f, -0.02997523f, 
    0.05196663f, 0.11018920f, 0.07990865f, 0.03413532f, 0.07138102f, 0.09192064f, -0.21565762f, 0.15916391f, 
    -0.07073984f, -0.00130726f, -0.22134040f, 0.03473718f, -0.03710894f, 0.15370426f, -0.07165438f, -0.03638584f, 
    -0.16106594f, 0.18729936f, -0.03405626f, 0.08121283f, 0.09453204f, -0.03730646f, -0.00860369f, 0.12607527f, 
    0.12820174f, 0.11558858f, -0.16603358f, -0.12757678f, 0.12462817f, 0.13938141f, 0.08533256f, 0.05316989f, 
    -0.03752036f, -0.00904577f, 0.01318023f, -0.05951533f, -0.02187646f, 0.00081796f, 0.04801617f, -0.03000285f, 
    0.01847942f, 0.02313806f, 0.02533077f, 0.04366221f, -0.02846013f, 0.00198383f, -0.04157768f, 0.00225773f, 
    -0.03459913f, -0.03976892f, 0.04250031f, -0.05827205f, -0.02205430f, 0.00740604f, -0.05688078f, 0.04624766f, 
    -0.06389976f, -0.02020696f, 0.00405301f, -0.01264597f, 0.03207577f, 0.01101858f, -0.02430202f, -0.05109145f, 
    -0.01147469f, 0.02175029f, 0.05035730f, -0.06160117f, -0.05459524f, -0.00557797f, 0.04004514f, -0.02788960f, 
    0.01774826f, 0.03727715f, -0.00352532f, 0.04915275f, -0.06317786f, -0.04838604f, -0.00604403f, -0.04165811f, 
    0.03244044f, 0.03365057f, -0.05555373f, -0.00073644f, -0.05484072f, 0.02411322f, -0.04245039f, -0.02322878f, 
    0.01830962f, 0.03135598f, -0.04085424f, -0.00165588f, -0.05768630f, -0.03852332f, -0.04239898f, -0.02465207f, 
    -0.04133250f, -0.04287564f, -0.04871145f, -0.01543162f, 0.02081222f, -0.01517964f, -0.03381833f, -0.04559033f, 
    0.01828212f, -0.00285760f, 0.01877272f, -0.04979352f, -0.01302010f, -0.04316227f, -0.02746249f, -0.02635570f, 
    -0.03277995f, -0.04792610f, 0.01996442f, 0.01650090f, 0.04365963f, -0.05851497f, 0.01288255f, -0.03264184f, 
    0.02199815f, 0.02785108f, -0.03088918f, 0.04107714f, 0.02432260f, -0.05533491f, 0.00054415f, -0.06207068f, 
    0.00249670f, -0.00419074f, -0.06047357f, 0.05038532f, 0.01206836f, -0.02862406f, 0.01006951f, -0.04020258f, 
    0.04147687f, 0.04631816f, -0.03452919f, -0.03676105f, -0.06058295f, 0.02475477f, -0.00060458f, 0.04543881f, 
    0.00486041f, 0.04859126f, -0.06087540f, 0.01589795f, -0.03152816f, -0.06151192f, 0.04166869f, 0.05183674f, 
    -0.04588934f, 0.01487772f, 0.02747704f, -0.04522702f, -0.03915388f, 0.04495011f, -0.03326086f, 0.00852433f, 
    0.00771598f, -0.02943600f, 0.05092394f, -0.04455232f, 0.05054336f, -0.05065863f, -0.06069407f, -0.03237955f, 
    0.04049365f, -0.02194746f, -0.06099281f, -0.00989598f, -0.05710683f, 0.03129975f, -0.00199923f, 0.04762116f, 
    0.05035885f, -0.00668266f, -0.03733440f, -0.03032133f, -0.03594416f, 0.03437046f, 0.02988627f, -0.03636828f, 
    -0.03477339f, 0.01470085f, -0.00549684f, 0.00208554f, 0.04517909f, 0.04365389f, -0.06266104f, -0.06117759f, 
    0.00271818f, -0.05125498f, 0.02541485f, -0.04107880f, 0.01828433f, 0.00946148f, -0.04545860f, 0.00501873f, 
    -0.06002583f, -0.03724107f, -0.03381277f, 0.02455080f, 0.02188988f, 0.03278924f, 0.00233848f, 0.01950249f, 
    -0.05587333f, -0.00712442f, -0.03894188f, -0.00853976f, 0.00293434f, 0.03935160f, -0.05741711f, 0.04106318f, 
    -0.04855296f, -0.03817883f, 0.02397454f, 0.01031529f, -0.01774588f, -0.02782512f, -0.01909950f, 0.02810061f, 
    0.01095229f, 0.02141017f, -0.03097060f, -0.02078594f, -0.04940696f, 0.00788082f, -0.03126632f, -0.00932950f, 
    0.03847790f, -0.01084648f, 0.00006432f, -0.04353435f, 0.00622360f, -0.05057973f, -0.05538286f, -0.02704437f, 
    -0.04462964f, 0.04250704f, 0.01311930f, 0.03322501f, 0.03816148f, 0.01253537f, 0.04788741f, -0.01455395f, 
    -0.02367411f, -0.00324392f, 0.01249213f, -0.04453509f, -0.06338643f, -0.02103510f, -0.03453370f, -0.01537277f, 
    -0.02211985f, -0.02388760f, -0.05132829f, 0.05044618f, -0.05517490f, -0.02715623f, 0.05241431f, -0.05232654f, 
    -0.00886908f, -0.05945331f, -0.01030887f, -0.00082418f, -0.01058029f, -0.00587576f, -0.00283380f, -0.01305268f, 
    0.04173060f, 0.00790697f, -0.00791411f, -0.05800667f, 0.05120990f, -0.05731825f, 0.03904473f, 0.03163456f, 
    0.03290655f, -0.02223298f, 0.00152220f, 0.04803104f, -0.06445947f, -0.00019903f, -0.06447116f, 0.05211353f, 
    0.01049771f, -0.04061174f, -0.05636115f, -0.05617344f, 0.01244624f, 0.04681737f, -0.05828464f, 0.00143408f, 
    0.01824925f, -0.01950609f, -0.04577749f, -0.05145600f, 0.02087313f, 0.04766747f, -0.02010789f, -0.00296478f, 
    -0.03346711f, 0.02655115f, -0.04944079f, -0.01210151f, 0.03787764f, -0.02743873f, -0.06258292f, -0.02433256f, 
    0.02186715f, 0.03759949f, -0.05677468f, -0.01499035f, 0.00538642f, 0.03430644f, -0.02129845f, 0.02194343f, 
    -0.04306320f, -0.01018078f, 0.03110535f, 0.01863755f, -0.01587127f, -0.02909712f, -0.01485832f, 0.04581981f, 
    -0.02211199f, -0.00304074f, -0.02706856f, -0.04476260f, -0.03585222f, -0.02444880f, -0.01319813f, 0.00527516f, 
    -0.02521937f, -0.04494460f, 0.03222014f, -0.05685208f, -0.04762222f, 0.02686485f, 0.01536077f, -0.05242376f, 
    0.02958569f, 0.00517344f, -0.01741321f, -0.00837345f, -0.06119540f, 0.02645433f, -0.01464332f, 0.05264417f, 
    -0.04087339f, -0.01013339f, 0.00350691f, -0.03357574f, -0.04109206f, 0.02427978f, -0.05621303f, 0.00726702f, 
    0.02560833f, -0.02094156f, 0.02306333f, -0.01657217f, 0.01808654f, -0.03955704f, 0.05043820f, 0.00749770f, 
    -0.04312434f, 0.05388743f, -0.03026769f, -0.00621871f, -0.01147928f, 0.04430953f, -0.00827860f, -0.04172329f, 
    -0.02888297f, -0.01692577f, 0.01473178f, -0.04561093f, 0.05061786f, -0.04973603f, -0.05741283f, -0.06263060f, 
    -0.03821314f, 0.02807410f, -0.03443043f, -0.04194219f, 0.03471072f, 0.02323648f, -0.00801859f, -0.00337092f, 
    -0.01449297f, -0.00379806f, -0.03178274f, -0.03809331f, -0.04743313f, -0.00122856f, -0.01088367f, -0.00191434f, 
    0.00380669f, -0.02350549f, -0.04800431f, 0.03439242f, -0.01600374f, 0.00426275f, 0.04061070f, 0.01671446f, 
    -0.00055634f, -0.00614159f, -0.02868967f, 0.00331842f, -0.03723178f, 0.02967840f, -0.03227985f, -0.02063651f, 
    -0.05482104f, -0.04068579f, 0.01941421f, -0.00220620f, -0.05152752f, 0.01423112f, 0.03987705f, 0.04973044f, 
    -0.01443430f, -0.03243054f, -0.04752231f, -0.01650693f, -0.05032424f, 0.01000349f, -0.02457128f, 0.01134378f, 
    0.00994104f, -0.00563878f, -0.00617945f, -0.05338958f, 0.00893289f, 0.03945712f, -0.05284601f, -0.04861454f, 
    -0.02247334f, -0.05781057f, -0.03432013f, 0.01053075f, 0.05101997f, 0.04046645f, 0.00078049f, -0.02604505f, 
    -0.05731125f, 0.03960614f, -0.03783970f, -0.04367699f, 0.01241127f, -0.04049407f, 0.02191898f, -0.01446244f, 
    0.04192911f, -0.00851818f, -0.00670222f, 0.02680416f, -0.06047423f, -0.02882200f, -0.02254812f, -0.05680395f, 
    -0.04100312f, -0.04816796f, -0.05940033f, 0.02724881f, -0.03165791f, 0.01854374f, 0.00316622f, -0.04971458f, 
    0.03685208f, -0.06300356f, -0.03132666f, -0.01027727f, 0.04606679f, 0.02684861f, 0.03290912f, -0.00988423f, 
    -0.05680754f, -0.02287626f, -0.00600763f, 0.04571266f, 0.01627408f, 0.03193772f, -0.02881138f, -0.05937307f, 
    0.02346360f, -0.00788251f, 0.04429236f, 0.01323694f, -0.00811370f, -0.06071521f, 0.00325501f, 0.02621670f, 
    0.03533461f, 0.03839780f, -0.05410310f, 0.02027760f, 0.02755479f, -0.02855119f, 0.03580830f, -0.05893600f, 
    -0.04820348f, -0.01196971f, -0.00804029f, 0.03255646f, 0.00274714f, 0.03015927f, -0.01838511f, -0.04687136f, 
    -0.00650368f, 0.05183411f, 0.04074836f, -0.04968873f, -0.04494306f, -0.00144692f, -0.00234112f, -0.05647870f, 
    -0.00693097f, 0.05242790f, -0.02037290f, -0.05319129f, -0.01473837f, 0.00517999f, 0.02241211f, -0.05204146f, 
    -0.02054871f, -0.05555278f, 0.02496230f, 0.04173670f, -0.05088188f, -0.00063664f, -0.02688104f, 0.02675313f, 
    -0.04461185f, 0.02866506f, -0.00982740f, 0.04801859f, -0.05023506f, 0.00365631f, -0.03225729f, 0.03629784f, 
    0.02516088f, 0.02223174f, 0.04209194f, -0.05448261f, -0.02518499f, -0.03021150f, -0.02018029f, -0.04996710f, 
    -0.01968921f, 0.03872332f, 0.01140469f, -0.05305131f, 0.00995707f, -0.00757931f, -0.01125111f, -0.04032696f, 
    -0.01570168f, -0.03163695f, -0.03407751f, -0.02775611f, -0.03207269f, 0.00030770f, -0.02852874f, -0.03612639f, 
    -0.02469864f, 0.04995491f, -0.03738189f, 0.01352374f, 0.03693388f, -0.01519656f, -0.00949304f, 0.00105601f, 
    -0.00530783f, 0.03559091f, -0.00692667f, 0.00162149f, 0.01247152f, -0.01999293f, 0.04595681f, -0.05638156f, 
    0.05274005f, 0.02002747f, -0.02996502f, -0.00375294f, 0.04404122f, -0.06332910f, -0.00594829f, 0.02894979f, 
    -0.05258973f, -0.05872165f, -0.06233196f, 0.02651195f, -0.02025162f, -0.00542989f, -0.00824538f, 0.02731382f, 
    -0.03704894f, -0.02776342f, 0.00493423f, -0.01336281f, -0.02385099f, -0.03472572f, 0.01759777f, 0.02434682f, 
    -0.03032735f, -0.04745873f, -0.02462061f, 0.09012045f, 0.05289934f, -0.06987409f, 0.01232188f, 0.11343558f, 
    -0.01459692f, -0.00747756f, -0.29411292f, 0.19758889f, -0.07549498f, 0.00896378f, -0.07428288f, -0.06102842f, 
    -0.10417704f, -0.06359898f, 0.19923633f, 0.00227119f, 0.05391253f, -0.05145918f, -0.18938403f, 0.12669395f, 
    -0.02467737f, -0.04385392f, -0.03420771f, -0.32310745f, -0.13265195f, -0.09922686f, 0.00043790f, 0.01798769f, 
    0.03298625f, -0.21758363f, -0.02650570f, -0.05688861f, -0.40737242f, -0.20177628f, 0.00693399f, -0.15743250f, 
    -0.03624607f, -0.09280585f, -0.01163236f, -0.00978631f, -0.19919352f, 0.36258999f, 0.28009921f, 0.10427469f, 
    0.06378793f, -0.16457604f, 0.16914155f, 0.01168808f, 0.03125065f, -0.00734897f, 0.06316670f, -0.04517484f, 
    -0.28716806f, 0.01749333f, 0.17921154f, -0.15036294f, 0.11769617f, 0.03125570f, 0.22875944f, 0.17355968f, 
    0.00410855f, 0.05331714f, -0.23939413f, -0.19159526f, -0.02045130f, 0.01467552f, -0.07083075f, 0.16475746f, 
    -0.19610667f, -0.01013127f, -0.02187018f, -0.08340522f, -0.06569836f, -0.00418954f, 0.02410422f, -0.21624525f, 
    -0.10269879f, 0.25355560f, 0.15004107f, 0.01147907f, 0.08442333f, -0.10400350f, 0.01245187f, 0.04716910f, 
    -0.02555261f, 0.04480217f, 0.57748121f, 0.02988453f, 0.09512576f, 0.04083689f, 0.15136768f, 0.25095236f, 
    0.03592667f, 0.12030547f, -0.00612765f, 0.24600092f, 0.17813762f, -0.05267286f, 0.00539850f, 0.01964437f, 
    -0.00651979f, 0.07337085f, 0.12626393f, -0.00501679f, 0.06128483f, -0.08845934f, 0.01173254f, 0.02351754f, 
    -0.08848068f, 0.15393871f, -0.13620324f, 0.06027077f, -0.10797939f, -0.12859249f, 0.06691792f, -0.08141344f, 
    0.17116320f, 0.08493675f, 0.09706318f, -0.04108949f, 0.02566998f, -0.13715242f, 0.18513174f, 0.25871885f, 
    0.07214773f, 0.09566240f, 0.18941207f, -0.01968429f, 0.05976258f, 0.25153103f, -0.08933836f, 0.22283216f, 
    0.17557575f, -0.02160497f, 0.07618792f, -0.05340616f, -0.08689529f, 0.04008083f, 0.00425753f, -0.01908777f, 
    0.12944673f, 0.01558162f, -0.02988954f, -0.13162439f, -0.10579560f, -0.15773244f, -0.03852358f, 0.01841207f, 
    -0.01831009f, -0.07745621f, -0.12993483f, -0.11315706f, -0.00781543f, 0.07173094f, 0.10701964f, -0.10930166f, 
    -0.11251704f, 0.09120716f, -0.03279534f, -0.20703521f, 0.08198255f, 0.07609671f, -0.12149715f, -0.02413582f, 
    -0.01685372f, 0.04689477f, -0.02186886f, -0.17291279f, 0.08295344f, -0.02253705f, 0.11033157f, 0.00420740f, 
    -0.12148677f, 0.13236251f, 0.04679441f, 0.15268540f, 0.16218416f, -0.43773353f, -0.07954449f, -0.03278800f, 
    -0.06287321f, -0.08787853f, -0.06934461f, 0.04260593f, -0.04317260f, -0.10004143f, -0.09323338f, 0.06059877f, 
    -0.06115871f, 0.02034540f, -0.03435682f, -0.19953419f, -0.03911904f, 0.02526737f, 0.30931121f, -0.08597721f, 
    0.16098899f, 0.06329728f, -0.01173837f, 0.03868288f, 0.08594713f, -0.00926590f, 0.00305557f, -0.02459419f, 
    0.09308960f, 0.12259074f, -0.16028807f, -0.06085341f, -0.15920918f, 0.14273839f, -0.13963705f, -0.01150021f, 
    0.19383343f, 0.02722944f, 0.02432618f, 0.10768631f, 0.04918939f, 0.15368353f, 0.08370574f, 0.11171348f, 
    0.17597793f, 0.22214976f, 0.12616654f, 0.13892919f, 0.24119176f, -0.07770101f, -0.25210434f, -0.02060677f, 
    -0.03141480f, -0.01621167f, -0.36763182f, 0.14785989f, -0.01160745f, 0.01660577f, -0.07731272f, -0.09186800f, 
    -0.13294534f, 0.04395085f, -0.18269938f, 0.19902688f, 0.17316025f, 0.06423315f, -0.16562362f, 0.01695657f, 
    0.10009070f, -0.12785777f, 0.05382640f, 0.03173231f, 0.03587935f, -0.16034062f, -0.12388469f, -0.24062254f, 
    -0.02572007f, -0.09228645f, 0.06935029f, -0.02838558f, -0.23370248f, -0.05824239f, 0.08134566f, 0.01476540f, 
    -0.16007671f, 0.02123971f, -0.09929580f, -0.11825211f, 0.06957694f, -0.01719863f, 0.12536156f, 0.08324410f, 
    0.01434755f, 0.11002510f, 0.08810174f, -0.00025225f, 0.01699926f, 0.12534636f, 0.08619937f, 0.03033309f, 
    -0.23197159f, 0.01481317f, 0.00276482f, 0.14350647f, -0.12961654f, 0.06234010f, 0.01246729f, 0.00888659f, 
    0.03202523f, -0.07072487f, -0.01748670f, -0.05450338f, -0.00040908f, -0.02206428f, -0.00192684f, -0.04356718f, 
    -0.00211952f, 0.03483386f, -0.02580098f, -0.04002945f, -0.05418040f, -0.06340936f, -0.02100128f, 0.01275587f, 
    -0.02112516f, -0.05378506f, 0.01449570f, -0.02190908f, -0.02758436f, -0.03063632f, 0.01617479f, -0.00337780f, 
    0.01381941f, 0.03812883f, -0.06552982f, -0.07412449f, 0.01428417f, 0.02333015f, -0.01499094f, -0.01598902f, 
    -0.02508820f, 0.03570016f, 0.01946687f, 0.01828787f, -0.01725584f, -0.00644679f, -0.07447942f, -0.04745530f, 
    -0.04692784f, -0.01226166f, -0.01587732f, -0.06094397f, 0.03721325f, -0.01958756f, -0.07159943f, 0.04251416f, 
    -0.06743777f, -0.03817644f, -0.02763193f, 0.00006388f, -0.06169931f, -0.06111263f, -0.02264690f, 0.01900423f, 
    0.00455135f, 0.00833875f, -0.04829063f, 0.01663005f, -0.05327683f, -0.00580096f, -0.01819946f, -0.02880117f, 
    0.03961840f, 0.00114891f, 0.01706802f, -0.00406691f, -0.04322926f, -0.06438006f, 0.03724075f, -0.06904147f, 
    -0.05942896f, 0.01121178f, -0.06122224f, -0.07217996f, -0.02281446f, 0.02189707f, -0.01942385f, -0.04063376f, 
    0.00640032f, -0.06690717f, -0.02070735f, 0.04225171f, 0.01406183f, -0.03358741f, -0.04630309f, -0.01636847f, 
    -0.01789793f, -0.00085535f, -0.01561609f, -0.06046304f, -0.02898879f, -0.01908900f, -0.01120339f, 0.02578474f, 
    0.04164248f, 0.00596682f, 0.01687485f, -0.03121562f, -0.01312959f, 0.01998337f, 0.00487608f, 0.04260034f, 
    0.05398873f, -0.01051263f, -0.06262518f, -0.02899543f, 0.00558985f, -0.02387694f, 0.03087100f, 0.01126178f, 
    0.02244248f, 0.00374222f, 0.04108454f, -0.03311651f, -0.05727550f, 0.03376392f, 0.00147436f, -0.02032409f, 
    -0.02567699f, -0.04792824f, 0.02075870f, -0.06363168f, -0.03472049f, -0.02221258f, 0.03221838f, 0.01960425f, 
    -0.01477898f, 0.02252192f, -0.04731552f, -0.01517098f, -0.00779406f, -0.03875512f, -0.04684275f, -0.05406227f, 
    -0.03344645f, -0.00541111f, 0.01484850f, 0.03477315f, -0.03392361f, -0.00304561f, 0.03093920f, -0.03486260f, 
    -0.06126249f, -0.03224388f, 0.00337197f, -0.00889961f, 0.02564784f, 0.04657695f, -0.02767342f, -0.00072709f, 
    0.03675744f, 0.01301188f, -0.03400882f, -0.03079819f, -0.03829801f, -0.00450738f, -0.05696687f, -0.04056064f, 
    -0.04854152f, -0.00040035f, -0.06058058f, -0.03860755f, 0.00429647f, -0.00428582f, -0.04242996f, -0.00997770f, 
    0.01903093f, -0.03627471f, 0.04081922f, -0.01241980f, -0.03951137f, -0.02069595f, -0.04068504f, 0.01189241f, 
    -0.00639352f, -0.02791821f, 0.00475869f, -0.01322894f, 0.01609331f, -0.05697040f, -0.04707054f, -0.00046342f, 
    0.03324905f, -0.04552629f, 0.01560154f, 0.00664579f, 0.04280685f, 0.01158256f, 0.04099782f, -0.04212601f, 
    0.04225663f, -0.02848224f, -0.04354359f, -0.05202851f, -0.05941262f, -0.00536198f, -0.06882515f, -0.05274270f, 
    0.03219960f, -0.02367028f, 0.02895221f, 0.05546178f, 0.02853582f, -0.02191683f, 0.03702160f, -0.05631460f, 
    -0.04039389f, -0.02906025f, 0.02120766f, -0.00591755f, -0.03118136f, 0.02548542f, -0.04245121f, -0.02025357f, 
    0.02583276f, 0.02815381f, 0.01675085f, -0.04689556f, 0.00194055f, -0.00329581f, -0.01083977f, -0.02476851f, 
    -0.01749985f, -0.04732252f, -0.05320112f, -0.05529792f, -0.06447538f, 0.03778051f, 0.01618349f, -0.02546441f, 
    -0.06532355f, 0.02503026f, -0.05054119f, -0.02103681f, -0.01949717f, -0.02797448f, -0.02402431f, -0.06939016f, 
    -0.06079899f, 0.04759607f, -0.02274221f, 0.02261394f, -0.06417377f, -0.06992750f, 0.00043388f, -0.00153711f, 
    0.04928651f, -0.05297483f, -0.02908130f, 0.02772008f, -0.06592931f, -0.02532460f, -0.02898618f, -0.00756422f, 
    0.03534351f, 0.01103004f, 0.01056851f, -0.02655989f, -0.04471602f, 0.00626271f, -0.04343974f, -0.03356694f, 
    -0.01230434f, -0.00648184f, 0.00020838f, 0.01369681f, 0.02361711f, 0.03392209f, -0.02851021f, 0.02493793f, 
    0.00913386f, -0.05942199f, -0.02832724f, -0.03484008f, -0.04901568f, -0.02743012f, -0.06133607f, -0.05361997f, 
    -0.00729651f, 0.02354136f, 0.02086236f, -0.02158565f, -0.03856758f, -0.06899017f, -0.03622097f, 0.02799619f, 
    0.03799524f, -0.04919722f, -0.03250632f, -0.02849929f, -0.02449292f, 0.04804929f, -0.04882875f, 0.03758230f, 
    -0.04736393f, -0.02666858f, -0.01645568f, -0.04187307f, -0.05970009f, -0.05701687f, 0.01890657f, -0.00407064f, 
    -0.05175757f, -0.04339312f, 0.02017884f, -0.05396328f, -0.04305163f, -0.00254712f, -0.02973321f, 0.00229639f, 
    0.02519860f, 0.03186958f, -0.04900615f, -0.00843574f, 0.00057225f, -0.06643202f, 0.03392341f, -0.01428472f, 
    -0.00820986f, -0.01253967f, -0.05303739f, -0.02541590f, 0.00918678f, -0.04058818f, 0.04942333f, 0.05582862f, 
    0.05433169f, -0.05904975f, -0.01195927f, 0.00544349f, -0.01941358f, -0.04933035f, -0.03239537f, -0.00998047f, 
    -0.00407121f, 0.05277738f, 0.01336295f, -0.03267453f, 0.03689115f, -0.03909966f, 0.01066250f, -0.05803977f, 
    0.00106469f, 0.00608597f, 0.00765568f, -0.02248812f, -0.00008386f, 0.01628115f, 0.03067491f, -0.00824729f, 
    -0.01197625f, -0.05031905f, -0.04596274f, -0.02031307f, -0.00167841f, 0.00260777f, 0.01790123f, -0.04201172f, 
    0.03168336f, 0.02672258f, 0.04629628f, 0.02910706f, -0.01808325f, -0.02361740f, -0.03117919f, -0.05397046f, 
    -0.06135129f, -0.05011976f, -0.03613139f, 0.01467617f, 0.02298689f, 0.03388492f, 0.00472487f, -0.03385339f, 
    -0.00873645f, -0.02513062f, 0.01963140f, -0.02737078f, 0.01493960f, -0.04992374f, 0.03650231f, -0.05614325f, 
    -0.03327863f, 0.01570944f, 0.02658105f, 0.02118365f, 0.02043136f, 0.03946980f, -0.01678338f, 0.00787549f, 
    0.03975778f, -0.01345517f, -0.01951476f, 0.00178435f, 0.02829791f, 0.01749293f, 0.01176528f, -0.00123436f, 
    0.01142030f, -0.05887611f, 0.01530910f, -0.02292228f, -0.03674234f, -0.03840192f, -0.02403286f, -0.01732518f, 
    0.03838585f, -0.05932868f, 0.03161597f, -0.05786506f, -0.02940371f, 0.04601329f, 0.03019067f, 0.01347056f, 
    0.00721259f, -0.02115494f, 0.00875129f, 0.04919747f, -0.03114001f, -0.05184341f, -0.02666131f, 0.03116320f, 
    0.02920505f, 0.02700170f, -0.04281870f, -0.01677050f, 0.02046004f, -0.06495727f, 0.02738070f, 0.01095301f, 
    -0.05199046f, -0.03313154f, -0.01494030f, -0.01802625f, -0.02375751f, 0.01897760f, 0.04840742f, -0.00330514f, 
    -0.01736492f, 0.00482889f, -0.02738461f, 0.00888986f, -0.03479001f, -0.00737285f, -0.00496442f, 0.01367080f, 
    -0.00391216f, 0.01149081f, 0.03080814f, -0.02062426f, 0.02022092f, 0.04210632f, 0.04120214f, -0.03493846f, 
    -0.02346671f, -0.04109609f, -0.01671935f, -0.01946318f, 0.02180240f, -0.02145605f, 0.02707379f, 0.05551758f, 
    0.05403263f, -0.00635516f, -0.06175281f, 0.01533083f, -0.05416766f, -0.03377078f, 0.00951693f, -0.02074518f, 
    0.02157860f, -0.06687697f, -0.06057271f, 0.03600163f, 0.04165629f, 0.02428245f, -0.03520423f, 0.01825730f, 
    -0.01872208f, -0.04787311f, -0.05851897f, 0.03639437f, -0.02017657f, -0.01998325f, 0.02010443f, -0.01410774f, 
    0.04149234f, 0.04704511f, 0.00858731f, 0.01627741f, -0.01768144f, -0.02940070f, -0.05681631f, -0.05832372f, 
    -0.00328542f, 0.02634248f, -0.05948859f, 0.05490003f, -0.04265013f, -0.04992491f, -0.04177506f, 0.02459179f, 
    -0.04962039f, -0.04412224f, -0.05190361f, -0.05265683f, 0.01908261f, -0.00199976f, -0.01864545f, -0.06391668f, 
    0.01863479f, -0.00544231f, -0.00819966f, -0.02960291f, 0.04065903f, 0.02752035f, 0.02287740f, 0.00930092f, 
    0.02621955f, -0.00044706f, 0.03389809f, 0.04423863f, 0.01820541f, -0.05599833f, -0.02207298f, -0.03400057f, 
    0.02122517f, 0.01129366f, 0.03735966f, 0.01325622f, 0.05056130f, -0.05915477f, -0.02745487f, -0.05735705f, 
    -0.03638442f, 0.00686555f, -0.06284990f, 0.04809196f, 0.05230439f, -0.05812159f, 0.01631241f, -0.02040653f, 
    0.04290211f, -0.00484259f, -0.00176575f, 0.01923078f, -0.05812492f, 0.03461720f, -0.00398896f, -0.06455579f, 
    0.02968651f, -0.05546242f, -0.06023779f, -0.00429372f, 0.01696016f, -0.00694873f, -0.05427981f, -0.00131086f, 
    -0.04075576f, -0.03859776f, -0.00642958f, -0.00880406f, 0.03889978f, 0.04596334f, -0.01441920f, 0.00956406f, 
    0.02474530f, 0.04776721f, 0.01900350f, 0.02610438f, 0.02148255f, -0.00663615f, 0.00634713f, 0.04377830f, 
    -0.07768250f, -0.37938938f, -0.20806313f, -0.02097041f, 0.02634277f, 0.05179865f, 0.06503456f, 0.00315429f, 
    0.01225876f, 0.16817716f, 0.36794612f, 0.09599268f, 0.16737875f, 0.04660154f, -0.12337838f, 0.03262348f, 
    -0.09075094f, -0.03886405f, -0.36496347f, 0.00695611f, 0.23231043f, 0.08776565f, 0.00977520f, 0.08885788f, 
    -0.05474437f, 0.03485426f, -0.02529054f, -0.35119334f, 0.00101395f, -0.05200966f, 0.01368700f, 0.02806446f, 
    -0.08181205f, 0.08914980f, -0.08080224f, 0.02815847f, -0.33235002f, 0.07701252f, -0.05879843f, 0.12033373f, 
    0.07895333f, -0.04448526f, 0.00312732f, -0.08825292f, -0.05395639f, 0.16685644f, 0.06503133f, 0.05180208f, 
    -0.15907186f, -0.13129637f, -0.05477395f, -0.07147627f, 0.10538866f, 0.04941565f, -0.14263184f, -0.52129710f, 
    -0.18023558f, 0.09680592f, 0.03831521f, -0.13083677f, 0.00248902f, 0.16771477f, -0.13685629f, 0.01099559f, 
    0.00193289f, 0.22834928f, 0.10180917f, -0.01670723f, 0.13300623f, 0.15833876f, 0.25119635f, -0.09633972f, 
    0.22584133f, 0.07184781f, 0.12413108f, 0.15919125f, -0.08725749f, -0.08031757f, -0.11600412f, -0.13760915f, 
    0.05948795f, 0.22317393f, -0.07675337f, -0.16118398f, 0.02843080f, -0.14191765f, -0.08204246f, 0.10541993f, 
    0.02656617f, -0.12891236f, 0.03564962f, -0.08398703f, -0.30027387f, 0.06495856f, 0.14722838f, 0.04242572f, 
    -0.12030344f, 0.04440945f, -0.03605048f, -0.00068925f, -0.04034858f, 0.09791183f, 0.05322954f, -0.17430957f, 
    0.07489562f, -0.05190131f, 0.11687349f, 0.03435560f, -0.33006138f, -0.16834541f, -0.03302107f, -0.02660941f, 
    -0.09742549f, 0.05948815f, -0.03558149f, 0.09900592f, -0.00900808f, -0.17643672f, -0.19317433f, 0.05169360f, 
    -0.12768690f, 0.04828839f, 0.04111720f, -0.01738669f, 0.10873611f, -0.09948216f, 0.14514612f, -0.24030989f, 
    -0.11505952f, -0.02072949f, -0.16821060f, 0.02752662f, -0.08880846f, -0.04182501f, 0.13660225f, 0.13769327f, 
    0.09312756f, 0.23304561f, 0.14193027f, -0.10420363f, 0.00639955f, 0.04398623f, -0.11987892f, 0.00507068f, 
    0.27284306f, 0.00420788f, -0.05732528f, 0.06494690f, 0.15951324f, -0.05077483f, -0.11225889f, 0.09303472f, 
    0.08585688f, -0.29108447f, -0.14647390f, 0.08303884f, 0.01231344f, -0.01472927f, 0.11212485f, 0.12186898f, 
    0.15639070f, 0.08239114f, 0.13605674f, 0.21896131f, -0.04835734f, 0.10330725f, 0.10813536f, -0.03244332f, 
    0.17746718f, 0.03353633f, 0.04589852f, 0.20524773f, 0.23195897f, -0.06476220f, -0.12873095f, -0.02526831f, 
    -0.15473181f, 0.05240551f, -0.01821437f, 0.05267546f, -0.07642702f, -0.14689586f, 0.02867513f, 0.15368082f, 
    0.14665101f, -0.06918193f, 0.09960302f, 0.15837944f, -0.02904184f, -0.03979247f, -0.11802291f, 0.06805559f, 
    0.13025668f, -0.00634546f, 0.08356845f, -0.02285904f, -0.02228025f, 0.02679374f, -0.18995246f, 0.07245146f, 
    0.06113838f, 0.03475520f, -0.00899366f, -0.01362455f, -0.08593152f, -0.10834520f, 0.05948438f, 0.08427020f, 
    0.03551315f, 0.12084451f, 0.06949542f, -0.09737819f, -0.12213226f, -0.01786705f, 0.16387244f, -0.01919698f, 
    0.10078610f, -0.18275231f, -0.09782709f, -0.15920711f, 0.11339805f, 0.04616696f, -0.05224306f, 0.15092500f, 
    -0.04477024f, -0.07561245f, 0.00088792f, 0.16214991f, -0.24851865f, -0.14359090f, -0.03234199f, 0.15966530f, 
    -0.10727149f, 0.18130165f, -0.04509489f, -0.46900314f, -0.00826617f, 0.05474778f, -0.17804714f, -0.08922410f, 
    -0.20322998f, 0.10594210f, -0.17760520f, -0.02727464f, -0.10799184f, 0.07485893f, -0.10700750f, -0.07068737f, 
    0.17055482f, -0.03833133f, -0.00576998f, -0.07782167f, -0.03745032f, 0.11357646f, 0.03861673f, 0.04534956f, 
    -0.01108916f, -0.13209024f, 0.19834712f, -0.21377061f, -0.13621740f, -0.26896116f, 0.04848723f, 0.09238523f, 
    0.13225718f, 0.07781123f, -0.11197140f, -0.06422318f, 0.11297043f, 0.05849829f, 0.12535065f, -0.20263781f, 
    -0.12483673f, -0.04570362f, -0.03051820f, 0.02076510f, 0.10688618f, 0.08505030f, -0.02038332f, -0.29446644f, 
    0.02731420f, 0.23440869f, 0.20565249f, 0.17743674f, -0.05857498f, 0.03996476f, -0.00801922f, -0.07071564f, 
    0.04868046f, 0.04610483f, 0.04388366f, 0.00038894f, 0.03425974f, 0.01595501f, -0.01165901f, 0.00819126f, 
    0.01256173f, -0.05651101f, -0.05926789f, 0.03929659f, 0.04412394f, 0.04379662f, -0.03734244f, 0.04188391f, 
    -0.01873473f, 0.04328249f, -0.02897174f, 0.00816524f, -0.01472664f, -0.03003899f, -0.05760045f, -0.04340632f, 
    0.02659716f, -0.03282731f, -0.05369158f, 0.00107067f, -0.00545814f, -0.00121547f, -0.02947428f, 0.04575094f, 
    -0.05636964f, -0.04925958f, 0.03120242f, 0.03363762f, -0.00130332f, 0.03683015f, -0.04998080f, -0.04883930f, 
    -0.04411756f, -0.01956835f, 0.01760892f, 0.01221321f, 0.02549844f, 0.02824621f, 0.04675152f, 0.00052674f, 
    0.02651755f, 0.03954176f, 0.02615199f, -0.01310911f, -0.02056079f, -0.01001531f, 0.01259058f, 0.03621109f, 
    -0.03024508f, -0.00031678f, -0.03558805f, -0.00529714f, -0.05544644f, 0.01179642f, 0.02233105f, 0.04062671f, 
    0.02640152f, -0.01088060f, -0.00997478f, -0.04681588f, 0.00444800f, 0.03041409f, -0.04211825f, 0.01670053f, 
    -0.01185639f, 0.00885094f, -0.03890007f, 0.02958424f, 0.03415408f, -0.05951000f, 0.02247762f, -0.00382548f, 
    0.03746278f, -0.03863270f, 0.00146968f, 0.00982367f, 0.01366766f, 0.04032674f, 0.01967622f, -0.00049910f, 
    -0.05477397f, 0.04816718f, -0.05235652f, 0.05063389f, 0.04328622f, 0.04545664f, -0.00767205f, 0.04009423f, 
    0.03123098f, 0.01504052f, -0.03097625f, -0.00231010f, -0.02303994f, -0.04508163f, -0.01572801f, -0.01947888f, 
    0.00727773f, -0.00182439f, 0.04879174f, -0.03076616f, -0.03400962f, -0.06232295f, 0.00176554f, 0.00905180f, 
    -0.05576118f, -0.04056965f, -0.05999015f, -0.04617978f, -0.05088475f, 0.02456857f, 0.03442190f, 0.04764622f, 
    -0.05668269f, -0.03072681f, -0.03335376f, -0.04808496f, -0.02140514f, -0.00491344f, 0.00951044f, -0.02762035f, 
    0.00632803f, -0.00995562f, -0.05480882f, 0.01743188f, 0.01546819f, -0.02378859f, -0.05579431f, -0.02558490f, 
    0.00284529f, -0.04818941f, 0.00638296f, -0.05425233f, 0.02890863f, -0.01051006f, 0.01872369f, 0.04993958f, 
    -0.06170827f, -0.03364439f, -0.05683919f, 0.03769996f, -0.06094098f, -0.02568985f, -0.05041401f, 0.03464890f, 
    -0.01213744f, -0.04827954f, -0.01387154f, 0.04533746f, 0.00228071f, -0.06391460f, 0.03057985f, -0.00273595f, 
    -0.05563935f, 0.01729530f, -0.03753840f, 0.00211591f, -0.02636183f, -0.05560003f, -0.03634284f, -0.01448283f, 
    0.00592642f, -0.00736457f, -0.06292117f, -0.04489149f, 0.04651339f, 0.01666038f, 0.02738789f, 0.00559512f, 
    -0.05737694f, -0.02429616f, 0.05256228f, -0.00449525f, 0.01332446f, -0.05476907f, -0.03912155f, 0.01315475f, 
    -0.06088011f, -0.05193550f, 0.02410849f, -0.03741442f, -0.01209862f, 0.02130454f, -0.01425231f, -0.01387295f, 
    -0.02548943f, 0.04558009f, 0.00712048f, 0.02687932f, -0.05040620f, -0.01809739f, -0.01408010f, -0.01872430f, 
    -0.02965047f, -0.02582910f, -0.03748116f, -0.01593080f, -0.01992377f, -0.03215749f, -0.02930481f, 0.04669087f, 
    -0.04557725f, 0.01940768f, -0.02482188f, -0.01416748f, -0.02306410f, 0.04921246f, -0.01389075f, -0.01696448f, 
    -0.02421574f, -0.02989021f, 0.03320735f, -0.06138043f, -0.05967787f, 0.04301002f, 0.01551190f, 0.02658900f, 
    -0.02779164f, 0.04145972f, -0.02177025f, 0.02455713f, -0.03257876f, -0.00375526f, -0.05980704f, -0.01056072f, 
    -0.03782666f, -0.06101319f, -0.04365201f, -0.02327340f, -0.05621554f, 0.03605250f, 0.05224723f, -0.05628981f, 
    -0.04748702f, 0.03885696f, 0.01053253f, -0.02921500f, 0.05097374f, -0.02364838f, -0.04113884f, 0.02569418f, 
    0.04912217f, -0.00002436f, -0.06078799f, -0.01237662f, -0.00417410f, 0.03153358f, 0.01187073f, -0.02208307f, 
    0.03052753f, -0.04391425f, -0.05271061f, -0.01410292f, 0.04041566f, 0.03330491f, 0.02979345f, -0.02671292f, 
    0.01973841f, -0.00119069f, 0.00791303f, -0.02936174f, 0.02322663f, 0.02555594f, 0.02232249f, 0.02487162f, 
    0.00425103f, -0.00984482f, 0.01947977f, -0.02272814f, -0.02087219f, 0.04379595f, -0.04196639f, -0.05383716f, 
    0.04106783f, 0.04443732f, 0.03723968f, -0.05112198f, 0.02875654f, -0.00983889f, 0.02178327f, -0.04675663f, 
    0.17814808f, -0.05179234f, -0.03907278f, 0.13440411f, -0.07698484f, 0.11988059f, 0.06913776f, 0.01323680f, 
    0.07134598f, -0.27943173f, -0.03513301f, -0.17116509f, 0.04717968f, -0.08714725f, 0.22274010f, 0.08037556f, 
    0.08147927f, 0.07466771f, -0.15133727f, 0.30186152f, 0.02934545f, 0.09025674f, -0.04601462f, -0.09508529f, 
    0.00921273f, 0.08809863f, 0.09122601f, 0.16244313f, -0.12047000f, -0.29045400f, 0.06028081f, 0.05131247f, 
    -0.01434650f, -0.07782346f, -0.11151376f, 0.11264750f, 0.13255188f, 0.08798066f, -0.21737342f, 0.10929646f, 
    0.02742079f, -0.02872893f, 0.02755362f, 0.10422397f, -0.07436550f, -0.11993069f, 0.10300923f, -0.08856588f, 
    -0.02482453f, -0.17344290f, -0.05484238f, 0.01238813f, -0.06377121f, -0.01955515f, 0.22225448f, 0.11683181f, 
    -0.04644602f, -0.03470762f, 0.13799298f, -0.12342108f, -0.01702738f, 0.01993590f, 0.03763571f, 0.06272934f, 
    0.26722735f, -0.20048389f, 0.15885413f, -0.02365429f, 0.07427641f, 0.10933073f, 0.09056723f, 0.02480822f, 
    -0.01281726f, 0.28891179f, -0.42769113f, -0.03645731f, 0.04251389f, 0.04060559f, -0.03389340f, -0.07718956f, 
    -0.04997532f, 0.01613266f, 0.02574790f, 0.12939137f, -0.15037720f, 0.03182240f, 0.06422942f, -0.05211303f, 
    -0.08244450f, 0.05339826f, -0.27239957f, 0.04397379f, -0.30701533f, 0.06197091f, 0.01742043f, 0.16326030f, 
    -0.03413905f, -0.15552747f, 0.03450495f, -0.03352568f, -0.24540369f, -0.02865344f, -0.08764846f, -0.25363189f, 
    0.00762559f, -0.07236683f, -0.06774783f, 0.02116615f, 0.38711831f, 0.05697786f, -0.16241463f, 0.05745248f, 
    -0.02104506f, 0.01273050f, 0.08443979f, 0.13546947f, 0.07205557f, -0.18933488f, -0.04452756f, 0.04379248f, 
    0.04787912f, 0.02537064f, -0.17029721f, 0.15883332f, 0.16909827f, -0.04945269f, -0.01456321f, -0.12885550f, 
    0.05700254f, -0.16049372f, -0.11389615f, 0.15703413f, -0.07563395f, -0.13268176f, 0.08904756f, -0.02429562f, 
    0.05541667f, 0.09394450f, 0.01468827f, -0.18604022f, -0.08041845f, 0.04329904f, -0.14139338f, 0.14677663f, 
    -0.17358601f, 0.24066341f, -0.28721991f, 0.08994588f, -0.14406948f, 0.05583165f, -0.03650397f, 0.10653637f, 
    0.08683172f, -0.02620529f, 0.02406834f, -0.18436979f, 0.10270154f, -0.02072453f, 0.00404015f, -0.09296901f, 
    -0.00286080f, 0.16182905f, -0.57456976f, 0.13003245f, 0.23882039f, -0.04947186f, 0.09446502f, -0.02257739f, 
    0.00292405f, -0.05405485f, -0.04082778f, -0.00500439f, -0.01242929f, 0.10289769f, -0.06101324f, -0.20938390f, 
    0.10121136f, 0.05192859f, 0.01742105f, 0.01481118f, -0.03960761f, -0.16875370f, 0.02962914f, 0.13720220f, 
    0.08799586f, 0.02703849f, 0.10812633f, -0.05515882f, -0.12672782f, -0.19543134f, 0.00541821f, -0.16117240f, 
    0.02146722f, 0.00245408f, -0.02935268f, 0.04689322f, -0.06140080f, -0.12356729f, -0.26336342f, -0.11628231f, 
    0.12629974f, 0.00807819f, -0.00111220f, -0.02181655f, -0.00126138f, 0.08246658f, 0.14793184f, 0.03551080f, 
    0.18079652f, -0.01156868f, 0.00216348f, 0.07953507f, -0.17494689f, 0.11635339f, 0.14291048f, -0.01851045f, 
    -0.07136735f, -0.09920845f, 0.17971732f, 0.08392271f, 0.00875862f, -0.00592600f, -0.10322206f, -0.02492965f, 
    0.07697581f, -0.38191271f, -0.27301899f, 0.27719498f, 0.15337338f, -0.06774138f, -0.24110636f, -0.12252069f, 
    0.13071278f, -0.10075536f, -0.07583338f, 0.20754290f, -0.14812230f, 0.00746285f, -0.25183171f, 0.05844756f, 
    -0.07960709f, 0.00685065f, 0.00713245f, -0.09850460f, 0.11284620f, -0.18579909f, -0.00237187f, -0.13448617f, 
    -0.10939951f, 0.12906234f, 0.01961053f, 0.07352713f, -0.05304574f, -0.04846718f, 0.07015401f, 0.02168308f, 
    -0.01114409f, 0.13278152f, 0.17529814f, 0.17137106f, -0.07052746f, 0.34525672f, 0.20051526f, 0.13291343f, 
    -0.26654032f, -0.11108062f, -0.09086563f, 0.07194275f, -0.02322738f, -0.02328198f, 0.00046111f, -0.19439529f, 
    0.35633320f, 0.02971714f, 0.04138565f, -0.09423236f, -0.01726008f, -0.01660241f, 0.17726062f, 0.00007868f, 
    -0.02766410f, -0.11741325f, 0.00950677f, 0.15551946f, -0.08438943f, 0.02200150f, 0.01803518f, -0.15462059f, 
    -0.00737393f, -0.00814920f, -0.05881978f, -0.02316636f, -0.03296298f, 0.00325375f, -0.02171359f, -0.00881165f, 
    0.01035597f, -0.04710364f, 0.02767725f, 0.02884057f, -0.01289429f, -0.03008158f, -0.05051694f, -0.02642023f, 
    -0.00896377f, 0.01568954f, -0.05117312f, -0.03956851f, -0.06520516f, -0.02177978f, 0.02429988f, -0.06226541f, 
    0.00684197f, 0.05319182f, 0.05145744f, -0.04936088f, 0.02387782f, -0.04605045f, -0.02678470f, 0.05007434f, 
    0.02979186f, -0.05851452f, 0.05194371f, 0.03328472f, 0.05351409f, -0.04357834f, 0.02693360f, 0.00867081f, 
    -0.02837736f, -0.02898933f, -0.03368652f, -0.02800515f, 0.02055803f, 0.00968366f, -0.03323283f, -0.04082994f, 
    0.00045491f, -0.04941021f, -0.00785795f, 0.01304607f, 0.04565713f, 0.00631772f, 0.01382831f, -0.04371881f, 
    0.01006641f, -0.04621758f, 0.04467162f, -0.02278836f, -0.05998259f, -0.06266194f, -0.05196233f, 0.02037683f, 
    0.00627006f, -0.03177351f, -0.03322376f, 0.01540907f, 0.01142838f, -0.02288093f, -0.00156514f, 0.02747093f, 
    -0.00695480f, 0.00868171f, 0.01837246f, 0.03784975f, -0.00959661f, -0.03703127f, -0.06481072f, 0.04576444f, 
    -0.00177269f, -0.00417035f, -0.05312834f, -0.05815727f, -0.04176316f, 0.01273920f, 0.02366233f, 0.03575048f, 
    -0.00599811f, 0.05121401f, -0.05195464f, -0.00565078f, -0.04057654f, -0.01174927f, 0.04625079f, 0.02393259f, 
    -0.01960075f, 0.01093689f, -0.04545937f, 0.03516333f, -0.04096366f, -0.03698131f, -0.00594517f, -0.03235573f, 
    0.02200211f, -0.03815605f, -0.06058662f, 0.04615472f, -0.05429522f, 0.02560058f, -0.01493753f, 0.02688004f, 
    -0.00853284f, -0.06319904f, -0.05511482f, 0.01147081f, -0.03647764f, 0.00188162f, 0.00600422f, -0.02064265f, 
    0.04338849f, 0.04206286f, 0.04408228f, -0.02949497f, -0.05847787f, 0.05008075f, 0.03245896f, 0.00086260f, 
    -0.01017995f, 0.03479964f, 0.01498365f, 0.03903887f, 0.04437770f, -0.01867677f, -0.00485078f, -0.02709643f, 
    0.00214644f, -0.04441326f, -0.04206728f, 0.02826968f, 0.01550690f, 0.05280879f, 0.01979382f, 0.01197340f, 
    0.04829021f, 0.04139584f, -0.01157984f, 0.02584580f, -0.04692649f, 0.01646307f, -0.02598939f, -0.05267740f, 
    -0.01979668f, 0.00829118f, -0.00784746f, 0.04629589f, -0.02405818f, -0.03682581f, -0.04765726f, 0.02410234f, 
    0.04160650f, 0.03013140f, 0.03940526f, -0.05315910f, -0.03827664f, -0.05753114f, 0.02303255f, -0.02510437f, 
    0.00857671f, -0.03351912f, -0.02726189f, -0.02451773f, 0.04035660f, -0.03393152f, -0.06290270f, 0.05350453f, 
    0.03233322f, 0.04015778f, 0.03138974f, -0.04527440f, 0.01348344f, -0.01285806f, -0.05163518f, 0.03322890f, 
    -0.04761322f, 0.01034243f, -0.02690233f, -0.02660106f, -0.03092616f, 0.04077206f, -0.02863060f, 0.00162378f, 
    -0.04408915f, -0.02075588f, 0.02234649f, -0.04090294f, 0.02115013f, 0.05706940f, -0.04287321f, -0.05024027f, 
    0.01843475f, 0.04368727f, -0.06337135f, 0.01843739f, 0.05463588f, -0.02423844f, 0.04145497f, -0.00822552f, 
    0.04799978f, -0.04633234f, 0.01953154f, 0.01878222f, -0.04781430f, 0.04559363f, -0.02735735f, -0.01312051f, 
    -0.02661524f, -0.01356301f, 0.00236306f, -0.01778454f, 0.03265495f, -0.05908365f, 0.02156036f, -0.02624716f, 
    0.04994766f, 0.02784610f, -0.00916347f, 0.01851770f, 0.01475024f, 0.02597208f, -0.02517532f, 0.00247236f, 
    -0.03539307f, -0.01213592f, 0.03756520f, -0.04945973f, -0.05790297f, -0.01349601f, -0.06063331f, -0.02629353f, 
    -0.04565920f, -0.05111940f, -0.04685234f, -0.06081884f, 0.03247208f, -0.05647929f, 0.05072438f, 0.03155818f, 
    -0.01474125f, -0.05186759f, -0.00398638f, -0.03985849f, -0.05565406f, -0.01951014f, 0.03411882f, -0.01140987f, 
    -0.06206397f, -0.03653735f, -0.02911875f, -0.03483426f, -0.04310653f, -0.03908393f, 0.02735569f, -0.04784995f, 
    0.00539613f, 0.02542848f, -0.01158779f, -0.01888250f, -0.03826273f, -0.03813199f, -0.05751042f, -0.01388793f, 
    -0.02227508f, 0.02296750f, 0.04681723f, 0.02720332f, 0.00882755f, 0.00985361f, -0.01371698f, 0.04665269f, 
    0.01980867f, 0.03968075f, 0.02691965f, -0.01338208f, 0.00310317f, -0.02362628f, -0.00683167f, 0.02431586f, 
    -0.04691029f, 0.02685372f, 0.05065609f, -0.01845841f, 0.02229600f, 0.00067665f, 0.04435711f, 0.01372450f, 
    -0.03243561f, -0.06288473f, 0.05036598f, -0.03424548f, -0.01342109f, -0.04523558f, -0.00700322f, -0.01158439f, 
    -0.01864024f, -0.03066362f, -0.03836739f, -0.04461675f, -0.06192666f, -0.02984020f, 0.04491087f, 0.03871509f, 
    -0.03587605f, 0.01232524f, 0.02613994f, 0.03372534f, 0.00773954f, -0.03028273f, -0.00481515f, -0.05495556f, 
    -0.05376901f, 0.05109528f, -0.05496752f, -0.02740414f, 0.00352201f, -0.02546388f, -0.01840433f, 0.04889097f, 
    -0.04104375f, -0.05522747f, -0.04061320f, 0.01913322f, -0.01761523f, -0.01170496f, -0.06180922f, -0.05410381f, 
    -0.05931326f, -0.03490919f, 0.00458002f, -0.04495417f, -0.04103879f, 0.00621659f, -0.01727683f, 0.05148981f, 
    0.00273146f, -0.01512830f, 0.02987697f, 0.03409302f, -0.01087824f, 0.01079706f, 0.02651331f, -0.05549172f, 
    -0.05605692f, -0.02657757f, 0.03734759f, -0.02109020f, -0.05881932f, -0.00655664f, -0.06344969f, -0.02585181f, 
    -0.05919204f, -0.02698900f, -0.06126814f, -0.05499662f, -0.01358291f, 0.02187743f, -0.04722307f, 0.04827406f, 
    -0.00418232f, -0.02884095f, 0.03444475f, 0.02264452f, -0.02963175f, -0.05050344f, -0.02768823f, -0.06232901f, 
    -0.00807350f, -0.04542269f, -0.04553131f, -0.05268801f, -0.01043112f, -0.02980549f, 0.04396017f, 0.01703156f, 
    0.01703036f, -0.04663847f, 0.01964881f, -0.01903488f, 0.02062504f, 0.00205001f, -0.01917796f, 0.02235695f, 
    0.01580715f, 0.02332757f, -0.04490788f, -0.03644021f, 0.02190211f, 0.01058274f, -0.03467605f, 0.03466888f, 
    0.03490078f, 0.04031105f, 0.00020231f, -0.01977489f, 0.03253499f, 0.01811174f, -0.01374565f, -0.00044705f, 
    -0.00642589f, 0.01906619f, -0.05510107f, 0.05317181f, -0.04991054f, 0.04352145f, 0.01991855f, 0.02941940f, 
    -0.00790615f, -0.04443281f, -0.04050498f, 0.01892264f, 0.02021552f, 0.02388753f, 0.03484825f, -0.01813555f, 
    0.00344397f, -0.05432840f, -0.05413844f, -0.00121083f, -0.06395171f, -0.03358944f, 0.02640045f, -0.01830314f, 
    0.01569360f, 0.04362920f, 0.03243051f, -0.03751799f, 0.02094463f, 0.03248190f, -0.04366161f, -0.06609309f, 
    -0.03906009f, -0.02521871f, -0.04734738f, -0.02496331f, 0.02866893f, 0.02105964f, 0.01430191f, -0.02641591f, 
    0.04568074f, 0.01853396f, -0.05344895f, -0.03212934f, 0.00989856f, -0.05992737f, 0.02348544f, 0.00335860f, 
    -0.00397453f, -0.01594094f, 0.05130321f, 0.00152504f, 0.03292444f, 0.04769486f, -0.00649860f, -0.04272614f, 
    -0.04506959f, -0.00661166f, -0.00118702f, -0.00427950f, -0.06555247f, 0.01864737f, -0.06172441f, -0.06152741f, 
    -0.01489270f, -0.05510489f, -0.03479271f, -0.02549758f, -0.06391682f, -0.00405382f, 0.00270976f, -0.04430389f, 
    -0.02785297f, -0.01394085f, -0.04191074f, -0.05079890f, -0.05852136f, -0.05382637f, 0.04901611f, -0.03954561f, 
    0.03369575f, -0.02068806f, -0.04554857f, -0.00833552f, 0.02248283f, 0.03486221f, -0.00758758f, -0.03792103f, 
    0.04580257f, -0.03360952f, 0.01713372f, -0.02105256f, -0.01218640f, 0.04612913f, -0.06152644f, -0.04635080f, 
    0.03428693f, -0.02558266f, 0.02981888f, 0.05006795f, 0.01827841f, 0.04928304f, 0.01693518f, 0.02812277f, 
    0.05140409f, 0.02864202f, 0.03321417f, -0.01360542f, -0.05527696f, 0.03548554f, -0.04390417f, -0.05525445f, 
    0.02051508f, 0.01596366f, -0.06305421f, -0.00843632f, -0.01689831f, -0.04438278f, -0.03016575f, 0.01287449f, 
    0.05736493f, -0.00792613f, -0.05559003f, -0.06447271f, 0.03075953f, 0.03786033f, -0.05626395f, 0.00463818f, 
    0.05039034f, -0.01003991f, -0.01878028f, 0.05377578f, 0.00524460f, 0.04901528f, -0.04212658f, -0.00231492f, 
    0.00416502f, 0.00771472f, -0.03986620f, -0.02394249f, -0.02430378f, -0.02208285f, -0.01483998f, 0.00496462f, 
    0.03638002f, -0.01323569f, 0.01521748f, -0.05697997f, -0.00897105f, -0.03263774f, 0.02176728f, 0.00768439f, 
    0.01703937f, 0.05393381f, -0.00113395f, 0.02206967f, -0.02235662f, 0.04858567f, 0.01417283f, -0.00626305f, 
    -0.06368101f, 0.02106095f, 0.02518770f, -0.04637272f, 0.00403426f, 0.00406512f, -0.03555534f, -0.02319617f, 
    0.02315084f, 0.19133261f, 0.11966544f, 0.01917728f, -0.17761265f, -0.04234086f, 0.11005523f, -0.06147548f, 
    -0.10737585f, 0.24313675f, -0.03502451f, -0.01322673f, 0.05035903f, -0.00451833f, -0.02107129f, 0.02871449f, 
    0.08310133f, 0.06444252f, -0.23924981f, 0.04476775f, 0.08092216f, 0.09811046f, 0.15496932f, 0.26543704f, 
    -0.09732430f, -0.03244277f, 0.00091297f, -0.15000226f, -0.09759621f, 0.12130616f, 0.13533215f, -0.02515145f, 
    0.07927146f, 0.04012997f, -0.02753148f, -0.04738107f, -0.00457176f, 0.03809725f, 0.08641037f, 0.12475079f, 
    0.13058063f, 0.04485087f, -0.03290789f, 0.03002954f, -0.01117794f, -0.06396493f, -0.18899299f, 0.23538543f, 
    -0.10072277f, -0.31433037f, 0.02399303f, 0.06873757f, -0.00246293f, -0.01392945f, -0.05851895f, 0.06205984f, 
    -0.03143518f, 0.02286111f, -0.02304627f, -0.06605944f, -0.15961452f, 0.05277348f, -0.12285861f, 0.28714415f, 
    0.19629404f, 0.05022987f, -0.19997530f, -0.05615084f, -0.02322748f, 0.09468391f, 0.06199288f, 0.04845562f, 
    0.44975674f, 0.06649828f, 0.19742914f, -0.07072727f, 0.02240159f, -0.19380084f, -0.07796597f, -0.08586667f, 
    0.00227574f, 0.32375339f, 0.06761964f, -0.11664717f, -0.06854419f, -0.04086388f, -0.02846247f, 0.27309638f, 
    -0.11641411f, -0.02870269f, -0.08488367f, -0.10478514f, 0.30770159f, -0.05316043f, -0.09311271f, 0.01062373f, 
    0.00073589f, -0.13630213f, -0.07530043f, 0.21206512f, -0.05021905f, 0.02182400f, -0.01996426f, -0.23410191f, 
    0.05792757f, 0.07924590f, 0.03174281f, -0.15817498f, -0.15602377f, -0.00594985f, 0.10419390f, 0.02407805f, 
    0.01965629f, 0.18207262f, 0.02644030f, -0.17761590f, -0.13676475f, -0.05227917f, 0.20670952f, -0.13600187f, 
    0.02777329f, -0.05779228f, 0.08550597f, 0.02084672f, 0.13123177f, -0.10097972f, 0.04927750f, 0.03719431f, 
    0.10602479f, -0.23066539f, 0.07429612f, 0.04314994f, 0.16485868f, -0.05761996f, 0.16842778f, 0.22658499f, 
    -0.25539497f, -0.01218605f, -0.12172620f, -0.06941952f, 0.02751281f, 0.08015309f, 0.00018474f, 0.02126446f, 
    0.10134818f, -0.24554844f, 0.21779178f, 0.10024804f, -0.04210952f, 0.01770357f, 0.02068690f, -0.02949794f, 
    0.04482086f, -0.15546140f, -0.02262596f, 0.01762062f, 0.07044403f, 0.11853769f, 0.11373682f, -0.09060172f, 
    -0.02597821f, -0.07484414f, -0.14506008f, 0.02629125f, -0.25109762f, -0.07127335f, -0.19150975f, 0.06092362f, 
    0.04928732f, -0.03483694f, -0.08652915f, 0.20092770f, -0.00764019f, 0.03983559f, -0.25677347f, -0.05744128f, 
    -0.10691577f, -0.07074681f, 0.00292883f, 0.05446273f, -0.24020216f, 0.02941393f, -0.06255893f, -0.01035302f, 
    0.04809011f, 0.13389778f, -0.20368923f, 0.01816899f, 0.00877081f, -0.04146141f, 0.07424651f, 0.17628677f, 
    0.09994072f, -0.03183873f, 0.08007838f, -0.01102664f, 0.08783665f, -0.12509651f, -0.20890617f, 0.02202679f, 
    0.03748147f, -0.16636571f, -0.01325036f, 0.05113366f, 0.04717243f, -0.01131966f, -0.13864918f, 0.00039435f, 
    -0.25929007f, 0.08247218f, 0.03926829f, -0.05137960f, 0.07044709f, 0.05551710f, 0.09185726f, -0.15324989f, 
    -0.04806594f, -0.01136279f, 0.07783014f, -0.09384803f, 0.07542420f, -0.04373265f, 0.02057208f, -0.03149909f, 
    -0.03632324f, -0.04364650f, -0.16729417f, -0.12161905f, -0.10768440f, -0.03036843f, -0.18042512f, 0.03629537f, 
    0.10673456f, -0.09231587f, -0.15301809f, -0.10357227f, 0.19328067f, 0.00847975f, -0.25754040f, -0.17972198f, 
    -0.13368842f, 0.06668458f, -0.28619060f, 0.10667382f, 0.08252564f, 0.05095840f, 0.01287805f, -0.03914465f, 
    0.17213117f, -0.07397076f, -0.07352830f, 0.04285363f, 0.22838783f, 0.03763155f, -0.08781525f, 0.01227836f, 
    -0.00695061f, -0.02450070f, 0.16645387f, 0.08090585f, 0.05833529f, -0.03112198f, -0.07335955f, 0.17111763f, 
    0.13090260f, -0.10548934f, 0.05615043f, 0.00167661f, 0.02812152f, 0.06010680f, -0.08265040f, 0.01244109f, 
    0.01521762f, -0.12922183f, 0.00345330f, -0.07539181f, 0.11775059f, 0.01616273f, -0.04013547f, -0.18445772f, 
    -0.06479339f, -0.00448178f, 0.04999224f, 0.02829644f, 0.07799168f, 0.01832788f, -0.04274200f, -0.05887742f, 
    -0.01775911f, -0.01904836f, 0.04492063f, 0.00727769f, 0.04982025f, -0.04700906f, -0.03454908f, 0.04500429f, 
    -0.04867858f, -0.04589280f, 0.05255914f, 0.03553387f, -0.03366694f, -0.02029481f, -0.05893582f, -0.00376748f, 
    -0.04834770f, 0.04489538f, 0.05013232f, 0.02375989f, -0.05940329f, -0.03110509f, -0.05612953f, -0.02012365f, 
    0.05276154f, 0.04773882f, 0.02328236f, -0.04077336f, 0.02285074f, -0.06383137f, -0.01474074f, 0.03936686f, 
    0.00304456f, -0.01096682f, -0.04787707f, 0.05070645f, -0.04304678f, -0.04023346f, -0.02472449f, -0.01610057f, 
    -0.04719706f, 0.05167834f, -0.02356926f, -0.01678965f, 0.03972207f, -0.02490181f, -0.02962606f, -0.01843839f, 
    0.03402974f, -0.01131794f, -0.02013047f, 0.02943599f, 0.04970228f, 0.01889813f, -0.00103770f, -0.03749558f, 
    -0.00647739f, -0.00336526f, -0.01994742f, -0.04107088f, 0.00477034f, 0.00540610f, 0.04163283f, 0.01019853f, 
    0.04906979f, 0.00941161f, 0.02910825f, -0.00293415f, -0.01977213f, 0.03041614f, 0.01400350f, -0.00565214f, 
    -0.06424317f, -0.04641509f, -0.04021299f, 0.00029399f, -0.04873281f, -0.04726529f, 0.03256390f, 0.03955632f, 
    -0.00128328f, -0.00628430f, -0.01701699f, -0.01464151f, -0.03821288f, -0.05739873f, -0.00811443f, -0.03148932f, 
    -0.04703385f, 0.00773792f, 0.02091199f, -0.03467190f, -0.01498915f, -0.04664735f, 0.02901345f, -0.01508637f, 
    0.04513501f, -0.03252998f, 0.01838693f, 0.04723911f, 0.03820667f, 0.04088191f, 0.05026097f, 0.02913675f, 
    -0.00547316f, -0.04673806f, -0.00930939f, 0.02618530f, 0.01471101f, 0.05228013f, -0.00439183f, -0.00953167f, 
    0.02269978f, -0.04756118f, 0.04267394f, 0.02883831f, -0.03857208f, -0.00930167f, -0.00563056f, -0.00805495f, 
    -0.00790293f, -0.05563568f, -0.05674646f, 0.01374878f, 0.04559703f, -0.01288004f, 0.03818786f, -0.00011688f, 
    0.03253581f, -0.04534735f, 0.01649815f, -0.04280987f, -0.00004145f, -0.02321246f, -0.01165050f, 0.03946078f, 
    0.00661567f, 0.00697824f, 0.01287701f, -0.03760842f, -0.01180445f, -0.04765114f, 0.04379250f, -0.04446826f, 
    -0.05224435f, 0.01323486f, 0.02558909f, 0.03130034f, -0.06227759f, -0.01906376f, -0.03205744f, -0.00342838f, 
    -0.03393077f, -0.04104879f, -0.02505347f, -0.05464196f, -0.06373334f, 0.00195343f, -0.01440402f, -0.03005195f, 
    0.03503406f, -0.03615541f, 0.02425604f, 0.04976756f, -0.02599465f, -0.02182126f, 0.05283160f, -0.05543610f, 
    0.00994703f, -0.00709030f, -0.01595792f, -0.05088499f, 0.00052982f, -0.00276740f, -0.04754251f, -0.01257686f, 
    -0.00805116f, -0.05083895f, 0.04271177f, -0.05225829f, -0.01272334f, 0.00548908f, -0.03177860f, -0.02313331f, 
    0.04670085f, -0.02068488f, -0.03648861f, 0.04938263f, 0.03712326f, 0.03796636f, 0.01390602f, 0.03015183f, 
    0.05257502f, -0.03375374f, -0.05367458f, -0.05658778f, -0.04214245f, -0.01606897f, -0.04556911f, 0.04879287f, 
    0.01775833f, -0.00094092f, 0.04323156f, -0.02491716f, -0.06281901f, 0.00122031f, -0.02757784f, 0.00261081f, 
    -0.03843759f, 0.02435959f, -0.06066378f, -0.00216500f, -0.02924898f, 0.05170050f, 0.02863779f, 0.00585860f, 
    0.00678795f, 0.01172183f, -0.05812857f, -0.02341749f, -0.05421360f, -0.04303383f, -0.05093652f, -0.04549072f, 
    0.01967420f, -0.01279377f, -0.00597497f, 0.03047858f, 0.04793675f, -0.06367462f, -0.05411162f, 0.03730287f, 
    0.00560147f, 0.04039277f, 0.03508963f, -0.02279377f, -0.01757213f, 0.00032463f, 0.05273049f, 0.02563834f, 
    -0.05841358f, 0.00137269f, -0.05041370f, -0.02161450f, -0.02046514f, -0.02664070f, 0.01791920f, -0.04475446f, 
    -0.02785800f, 0.01610113f, -0.05831256f, 0.00981044f, -0.05406625f, -0.00088487f, -0.04431329f, -0.05377307f, 
    -0.02940196f, -0.03734399f, 0.02339189f, -0.05155764f, -0.01196953f, -0.03169208f, 0.02357015f, 0.03636711f, 
    -0.04938200f, -0.04780030f, 0.00733717f, -0.01534364f, -0.06089184f, -0.05620341f, -0.06190470f, -0.05084156f, 
    0.03813518f, 0.03275043f, -0.06171938f, -0.00654708f, -0.04789311f, 0.03579947f, 0.03891400f, -0.06467015f, 
    -0.00494197f, 0.00166665f, -0.04316147f, -0.04886518f, 0.01304918f, -0.04548287f, -0.00914045f, -0.05504334f, 
    0.01583223f, -0.23965278f, 0.06215006f, 0.06468922f, 0.08603112f, -0.03920970f, 0.08213858f, 0.00381815f, 
    0.12455658f, -0.13132329f, -0.19590442f, -0.12400198f, -0.04837411f, 0.19668256f, 0.01208617f, -0.03300252f, 
    0.02872995f, -0.12142205f, 0.37097678f, -0.21018152f, -0.02689493f, 0.02467651f, -0.00075196f, -0.10250853f, 
    0.06597971f, -0.00012988f, 0.12324814f, 0.34119636f, 0.05795194f, -0.07429981f, 0.16550261f, 0.04842162f, 
    0.11022542f, 0.02928511f, 0.01212395f, 0.16875994f, 0.42309523f, -0.02651327f, -0.09544882f, -0.01695070f, 
    -0.04246413f, 0.07834322f, 0.10974900f, -0.03449664f, 0.04065840f, -0.03717467f, -0.06807402f, 0.06758200f, 
    0.03729242f, -0.11885775f, -0.02602042f, -0.29091847f, -0.04936000f, -0.10525295f, -0.47662139f, -0.10566556f, 
    -0.11153166f, 0.06906986f, 0.07534478f, 0.09480234f, 0.11326562f, 0.01002853f, 0.00872944f, 0.08141696f, 
    0.03056793f, -0.15888719f, -0.07552751f, -0.04008228f, -0.02290916f, 0.01151264f, 0.06157512f, -0.08329020f, 
    0.33062527f, 0.02805491f, -0.43293044f, -0.17751513f, -0.14121521f, 0.06946626f, 0.07320607f, 0.02704657f, 
    -0.13884370f, -0.23596436f, -0.14297597f, -0.14779176f, -0.08079553f, 0.21164307f, 0.28063747f, 0.07324674f, 
    0.15069987f, 0.02238094f, 0.15903799f, -0.14996648f, -0.16470625f, 0.14262810f, 0.07688590f, 0.00304757f, 
    -0.09599671f, 0.16982822f, 0.00018727f, -0.05255388f, -0.18185604f, -0.01016261f, -0.02618222f, 0.07015873f, 
    0.11321948f, -0.16134186f, 0.04491043f, -0.03196158f, 0.39408311f, -0.16330533f, -0.13153699f, 0.20285688f, 
    -0.06274178f, -0.01863198f, 0.10148542f, -0.00642082f, 0.11204201f, -0.00901871f, -0.10634650f, -0.19805387f, 
    0.09132954f, 0.10388769f, 0.12700078f, -0.07126596f, 0.10786701f, -0.00930925f, -0.06624097f, -0.01219310f, 
    0.05311966f, -0.02020616f, 0.07741125f, -0.07944888f, 0.02126014f, -0.08345504f, 0.03874433f, 0.15507428f, 
    -0.01571262f, -0.02228477f, 0.10432948f, -0.13607417f, 0.03159238f, 0.09527718f, 0.03230550f, -0.10965603f, 
    -0.02747527f, 0.03588358f, -0.09340245f, -0.07269184f, 0.10306653f, -0.17219350f, -0.03358269f, -0.10030034f, 
    -0.07143052f, 0.19030793f, 0.07737630f, 0.11801101f, -0.03671329f, 0.03699759f, 0.11171181f, -0.02813538f, 
    -0.02402719f, 0.03118078f, -0.43405625f, -0.02166017f, 0.08162788f, -0.17913175f, 0.07304482f, -0.13016097f, 
    -0.09899949f, -0.15002750f, 0.01618513f, -0.33904675f, -0.03851495f, -0.11085442f, 0.11402767f, 0.00628180f, 
    -0.03863969f, 0.01043283f, -0.08076608f, -0.10855086f, -0.06058529f, 0.10323907f, 0.03171632f, -0.03135707f, 
    -0.18862486f, 0.12407099f, 0.19076368f, 0.00278272f, -0.05403095f, 0.11260226f, 0.15593053f, -0.24983536f, 
    -0.00578019f, -0.05361833f, 0.07600617f, -0.14109141f, 0.06599274f, -0.02723375f, -0.25457564f, -0.08768560f, 
    0.02707281f, 0.03826505f, 0.07026773f, 0.01553353f, -0.12252495f, -0.23079136f, -0.06921785f, -0.18157640f, 
    0.01707804f, -0.05507979f, 0.12301835f, -0.22732015f, 0.14031924f, 0.05265408f, 0.06559388f, -0.17521046f, 
    0.20536029f, 0.03038646f, 0.00832913f, 0.07041813f, 0.02396312f, -0.04979802f, 0.03116908f, 0.07128783f, 
    0.00375361f, 0.06518974f, 0.24067520f, -0.13493128f, -0.29103443f, -0.03893017f, -0.06502256f, 0.12474640f, 
    0.02293264f, -0.02395855f, -0.09860451f, -0.04169294f, 0.07039472f, 0.10396326f, 0.02967327f, -0.12211926f, 
    -0.00288826f, 0.14618166f, -0.09180862f, -0.14264961f, -0.13866161f, -0.24735190f, 0.11441802f, 0.06001537f, 
    -0.09723304f, -0.11092082f, 0.02941659f, -0.09795539f, 0.11881287f, 0.20102732f, -0.18278483f, 0.11019073f, 
    -0.09884898f, 0.19554931f, 0.04925145f, -0.05209245f, 0.00475589f, 0.13787036f, 0.13583569f, -0.03437302f, 
    0.10779943f, -0.00562750f, -0.01373048f, 0.00517493f, 0.04843509f, -0.01407726f, 0.02205028f, 0.16977443f, 
    0.02460662f, 0.20081091f, 0.04712923f, -0.09128568f, 0.11659309f, -0.06973843f, 0.03387303f, 0.38999963f, 
    -0.02161746f, 0.06137275f, 0.13716678f, -0.02290956f, 0.08828531f, 0.00626309f, 0.12186383f, 0.06585880f, 
    0.03665682f, 0.03506245f, 0.02015483f, -0.02628518f, 0.03283091f, -0.02137574f, 0.01697078f, 0.00730082f, 
    0.00618105f, -0.02798588f, 0.02919513f, -0.00852486f, -0.04683932f, 0.00867951f, -0.02792086f, -0.05466961f, 
    0.04700200f, -0.04424165f, 0.01987021f, 0.03681619f, -0.04436382f, 0.01399750f, -0.04952414f, -0.01670124f, 
    -0.05898840f, -0.02050426f, 0.03345722f, -0.00182672f, 0.03740352f, 0.03014293f, -0.06500565f, 0.03215693f, 
    -0.01597034f, -0.00151993f, 0.03278805f, 0.05047431f, 0.01709688f, 0.01625321f, 0.04373940f, 0.01792138f, 
    0.01979188f, 0.02424276f, -0.00951488f, -0.01000227f, 0.03179089f, -0.03528737f, 0.02765739f, 0.00871757f, 
    0.00626139f, 0.01032051f, 0.00526155f, 0.03436340f, 0.04983881f, 0.01415112f, -0.06078219f, 0.01597086f, 
    0.00325149f, -0.01081360f, 0.01895736f, 0.00644615f, 0.01446562f, -0.05886655f, -0.06978814f, 0.02166326f, 
    -0.01543503f, 0.01166370f, -0.01812725f, -0.05788975f, -0.01852801f, -0.04558861f, 0.03592796f, 0.02720586f, 
    -0.03215645f, -0.03367675f, 0.02050101f, 0.03784987f, -0.05241353f, -0.03762595f, -0.05782306f, 0.04018389f, 
    -0.01348497f, 0.01384215f, -0.04596218f, -0.00183247f, -0.04273355f, -0.06920187f, -0.03151852f, 0.01039430f, 
    0.00848537f, 0.03971538f, -0.02033179f, 0.00963498f, 0.05586030f, -0.06887637f, 0.03095915f, 0.02564507f, 
    0.04512371f, -0.01263330f, -0.04112953f, -0.00660224f, 0.04146313f, 0.03352588f, 0.03121402f, -0.03235274f, 
    0.04195512f, -0.03848904f, -0.01259205f, 0.00987713f, 0.00777934f, -0.02447912f, -0.07442321f, -0.05437141f, 
    -0.04074071f, 0.03587166f, 0.02874738f, 0.03206049f, 0.02503080f, 0.00580925f, 0.03127886f, -0.05200184f, 
    0.00502915f, -0.03424337f, -0.05272988f, 0.04410979f, 0.01364269f, -0.03270328f, -0.04750563f, -0.06398618f, 
    -0.05697503f, 0.03740792f, 0.00421685f, 0.02919289f, -0.04070699f, 0.03167230f, 0.00439025f, 0.03427975f, 
    0.01164118f, -0.05044849f, -0.05829462f, 0.03318393f, -0.06043994f, 0.00529836f, -0.03561041f, -0.04845123f, 
    -0.00659467f, 0.03542184f, -0.05022101f, -0.05125006f, 0.04150980f, -0.03842807f, -0.05402923f, -0.01866883f, 
    -0.00390581f, 0.03179711f, 0.04319986f, -0.05078655f, 0.02409851f, -0.02429617f, -0.06992424f, -0.03460760f, 
    -0.02877109f, 0.05044417f, -0.06384268f, -0.00149781f, 0.03538879f, -0.07407859f, -0.04153415f, -0.01846542f, 
    0.01492636f, 0.04167422f, 0.00181407f, 0.01988051f, 0.01997561f, -0.05824451f, -0.05108168f, 0.04496000f, 
    0.03806533f, 0.03723717f, -0.03931202f, 0.03745172f, -0.06133291f, 0.03302029f, -0.03737675f, -0.00625573f, 
    -0.01367397f, -0.05955227f, -0.02444043f, -0.06307405f, 0.02910842f, -0.02680687f, 0.03792904f, 0.01982072f, 
    0.04134675f, -0.05341007f, 0.01714477f, 0.00903318f, -0.01849309f, 0.00374115f, -0.04588316f, -0.00110326f, 
    -0.03206779f, -0.04083914f, -0.00717660f, 0.01238874f, 0.01042920f, -0.02484101f, 0.01340826f, -0.03638793f, 
    -0.02387493f, 0.01522627f, -0.04707650f, -0.00907407f, 0.01060250f, -0.05331158f, -0.07533334f, -0.05982482f, 
    0.02052418f, -0.05232816f, 0.04943236f, 0.00852957f, -0.06247449f, 0.02531268f, -0.00531253f, -0.06862373f, 
    -0.02194250f, -0.03262185f, 0.02588893f, 0.01933981f, 0.02768840f, -0.04504805f, 0.01942715f, 0.03631485f, 
    0.02290559f, 0.01692920f, -0.05068282f, 0.00616842f, 0.02057494f, -0.01699151f, -0.04886078f, -0.01357411f, 
    -0.03270956f, 0.01093767f, 0.01213049f, -0.03872088f, 0.02988956f, -0.06118219f, -0.00585044f, -0.03802005f, 
    -0.01511244f, 0.00759695f, 0.00772839f, 0.02292589f, 0.01847659f, 0.05129192f, 0.03701179f, 0.00476509f, 
    0.02609942f, 0.02379586f, 0.03054877f, 0.02621773f, -0.03061302f, -0.02806927f, 0.00071022f, -0.05221031f, 
    -0.04949272f, 0.00709533f, -0.04539061f, -0.03594077f, 0.03662061f, 0.03787978f, 0.01733670f, 0.04399861f, 
    0.01207080f, -0.03017577f, -0.01307458f, -0.03811576f, 0.02957961f, -0.05346978f, -0.05864997f, 0.01011862f, 
    0.01530093f, -0.01975762f, -0.05096332f, -0.03947478f, -0.02968990f, 0.03219384f, 0.00035686f, -0.02884246f, 
    -0.10729838f, -0.02697800f, -0.04574405f, 0.02296719f, -0.02807810f, -0.06605672f, 0.03933391f, -0.05007222f, 
    0.00798467f, -0.01602685f, 0.07865678f, -0.04796258f, -0.04289886f, 0.09088767f, -0.09408478f, -0.08463137f, 
    0.07508324f, 0.08188751f, 0.25132322f, 0.03795801f, 0.23907818f, 0.14268671f, 0.11804289f, -0.02206308f, 
    0.02936936f, 0.11063062f, 0.04473688f, -0.40689361f, 0.29647419f, 0.26183206f, 0.14440541f, -0.05296021f, 
    0.09038309f, 0.15016566f, -0.01584631f, 0.04440358f, -0.12179096f, 0.25707495f, 0.25890934f, -0.23810026f, 
    -0.02098064f, -0.03121504f, 0.04657698f, 0.09224327f, 0.03251706f, -0.70745480f, -0.11952489f, 0.05749440f, 
    0.14048545f, 0.05016766f, 0.09421836f, -0.09569515f, -0.09358662f, -0.27098265f, -0.08688750f, -0.01789972f, 
    -0.34133834f, -0.06914187f, 0.13283360f, -0.06642620f, 0.09974527f, -0.07074096f, -0.01319470f, -0.02639894f, 
    -0.04480634f, 0.14504853f, 0.00600763f, 0.00561298f, -0.00265862f, -0.03033055f, -0.03888803f, -0.01297112f, 
    0.02546718f, 0.12614393f, 0.24300194f, 0.00170427f, 0.04151490f, -0.03164094f, -0.07194776f, 0.03413725f, 
    0.03845942f, -0.03891016f, 0.06789627f, -0.02795685f, -0.03759513f, 0.05396794f, 0.01304386f, -0.13423537f, 
    -0.06219070f, 0.04974018f, -0.26346827f, -0.30465358f, -0.18866435f, 0.04077302f, 0.17813829f, 0.04580108f, 
    -0.17324261f, -0.10444675f, -0.00472188f, -0.21041510f, -0.21069199f, -0.21690880f, 0.09933712f, -0.05266224f, 
    -0.06625795f, -0.00321553f, -0.12163649f, -0.12298663f, -0.27589610f, -0.00469234f, 0.08902984f, 0.00621600f, 
    -0.11854728f, 0.03202805f, -0.10644854f, -0.06078466f, 0.06051049f, 0.11522013f, -0.01038238f, 0.13541111f, 
    0.02307027f, -0.01984963f, -0.05292550f, 0.05725408f, -0.06319588f, 0.05526265f, -0.03856204f, -0.08932853f, 
    -0.19495320f, -0.05676160f, -0.00140438f, -0.04609539f, 0.24768096f, 0.02107617f, -0.13341735f, -0.08034865f, 
    -0.11955330f, -0.03221728f, 0.12888022f, 0.00682637f, -0.07658236f, -0.00881749f, 0.11075409f, 0.10998529f, 
    -0.16239657f, 0.08136374f, 0.10519214f, 0.01853683f, 0.10791590f, -0.10664593f, -0.12741117f, 0.20248835f, 
    -0.04213369f, -0.18739276f, 0.16232832f, 0.15034512f, 0.19712847f, 0.05130896f, -0.11908396f, 0.13073470f, 
    0.01797726f, 0.17139851f, -0.29480132f, -0.10227490f, -0.33194047f, 0.04485269f, -0.00049589f, 0.16998973f, 
    0.04978253f, 0.07885380f, 0.18581909f, -0.08971578f, 0.11754301f, -0.11407610f, 0.10748060f, 0.15900302f, 
    0.03308345f, 0.05180158f, -0.00511194f, 0.04770936f, 0.03342574f, 0.09009222f, 0.13488659f, 0.06163716f, 
    0.11167014f, -0.10474122f, 0.07608358f, -0.03488153f, -0.02171982f, 0.06997301f, 0.04924402f, 0.21408604f, 
    0.01157458f, 0.13038677f, 0.02098679f, 0.06639115f, 0.00427534f, 0.01055845f, 0.24415351f, -0.21213980f, 
    -0.03057987f, -0.10740983f, -0.00294757f, 0.01529070f, 0.10356987f, -0.02746089f, 0.02535339f, 0.06181000f, 
    -0.05994361f, 0.05952473f, -0.08096880f, 0.05178998f, 0.14544307f, -0.00765393f, 0.01051193f, -0.05978328f, 
    -0.03095602f, -0.06848145f, -0.16470295f, 0.10697410f, 0.00972987f, 0.02834842f, 0.12516530f, -0.15191272f, 
    0.17498039f, -0.20747624f, 0.13870482f, -0.05170577f, 0.11378149f, 0.01092383f, 0.05116482f, 0.00748477f, 
    -0.02314009f, -0.09278189f, -0.13019629f, -0.38389972f, -0.30741394f, 0.04850543f, -0.28509080f, 0.00110863f, 
    0.19792439f, 0.02726877f, 0.19493565f, 0.50533897f, 0.09504531f, -0.05325554f, 0.15613887f, 0.10334504f, 
    0.05817119f, 0.09542914f, 0.08316304f, -0.06529261f, -0.20092911f, -0.18090218f, 0.05282290f, -0.26153195f, 
    -0.01416989f, -0.13456455f, -0.05942194f, -0.06597842f, -0.05964036f, 0.09408668f, -0.40886235f, 0.00283243f, 
    -0.10334904f, 0.01144454f, -0.01649424f, -0.04384607f, 0.14380117f, -0.10926501f, -0.05943352f, -0.01291744f, 
    -0.09123267f, 0.06288162f, 0.14601518f, 0.00975557f, 0.06562241f, 0.12756538f, 0.10665160f, -0.12144198f, 
    0.02540346f, 0.22812396f, 0.03653474f, -0.05207885f, -0.03880435f, -0.06471567f, 0.06288030f, 0.07474445f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.07181990f, 0.00029844f, 0.08901128f, 0.04943470f, -0.04154124f, 0.03758786f, 0.14552757f, -0.00570617f, 
    -0.03321612f, -0.04419840f, 0.00028020f, 0.13766806f, -0.01823408f, -0.02868760f, 0.02740814f, -0.05718761f, 
    -0.03375786f, 0.05217297f, 0.03133929f, -0.05867151f, -0.01669036f, 0.03317351f, 0.04948062f, -0.03023031f, 
    0.02403997f, -0.01844401f, -0.05941863f, -0.02539453f, 0.02862857f, 0.00272116f, 0.04596729f, 0.00986765f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02696933f, 0.05014545f, -0.21146998f, 0.01012247f, -0.03955000f, 0.05041995f, -0.08786769f, -0.12714802f, 
    0.04581439f, -0.11903884f, -0.04782926f, -0.03157375f, 0.05275711f, -0.03305486f, -0.04776679f, 0.16453053f, 
    0.06548966f, -0.08252182f, -0.09606431f, -0.20477985f, -0.01593705f, 0.00668422f, -0.12198715f, 0.06463141f, 
    0.04992262f, -0.12659347f, -0.10296015f, -0.17073540f, -0.06872233f, -0.15009262f, 0.00286265f, 0.01024288f, 
    -0.12128700f, 0.13748115f, 0.03016456f, 0.03130058f, -0.07187498f, 0.16154370f, -0.12886874f, 0.05622107f, 
    -0.01505884f, -0.07231919f, 0.02375402f, -0.04279932f, 0.09918211f, 0.03705597f, -0.00991099f, -0.08911433f, 
    -0.16148633f, -0.08022448f, 0.05858107f, 0.05426742f, 0.00704159f, -0.09608925f, -0.14918087f, 0.10768677f, 
    -0.15843862f, 0.07908884f, 0.08590588f, -0.13456738f, 0.16705208f, -0.05199778f, 0.08899242f, 0.01482350f, 
    0.14713953f, -0.07558035f, -0.39897007f, 0.39194641f, 0.29479653f, 0.12194369f, 0.08882108f, 0.07985064f, 
    -0.01651972f, -0.11668105f, 0.08609395f, 0.32775190f, 0.11148775f, -0.01462145f, -0.01755399f, -0.02234162f, 
    -0.08996475f, 0.05928352f, -0.14413314f, 0.20904389f, -0.13501766f, -0.12462509f, -0.31826359f, 0.04671904f, 
    -0.36355338f, -0.01021191f, 0.13130662f, -0.33967325f, -0.05150636f, 0.31758216f, -0.01160670f, -0.08090600f, 
    0.28529114f, 0.16340056f, 0.35542214f, 0.43210158f, 0.11230532f, -0.07283409f, 0.03471562f, 0.13700050f, 
    -0.12722015f, 0.10323139f, 0.09723273f, -0.15797865f, -0.10239784f, -0.14939499f, -0.37540835f, -0.11087667f, 
    -0.12883240f, 0.17318025f, 0.00975314f, 0.12440991f, 0.12009338f, -0.07087093f, -0.17236349f, 0.12466525f, 
    0.31929225f, -0.14759986f, -0.10451113f, -0.02245042f, 0.10043211f, 0.17217466f, -0.15909620f, 0.17654182f, 
    -0.17509985f, -0.14243254f, 0.36701828f, -0.08101765f, -0.20583548f, -0.17635536f, -0.05837926f, -0.16027296f, 
    -0.13031331f, -0.10521048f, 0.10232048f, -0.22405943f, -0.02205377f, 0.16890690f, 0.11381797f, 0.15603803f, 
    0.29361349f, 0.05965669f, -0.04800908f, 0.24006748f, -0.12532541f, -0.10061601f, -0.11018283f, 0.07808226f, 
    0.46180812f, 0.12069104f, 0.00577568f, 0.02090879f, -0.14028972f, 0.16646521f, 0.15768926f, -0.30459207f, 
    -0.16609909f, -0.11028092f, -0.14415456f, -0.07517606f, -0.16353311f, -0.14867014f, -0.12504593f, 0.11483197f, 
    0.07256122f, 0.14242126f, -0.17385058f, -0.00112008f, -0.11184268f, -0.07401685f, -0.11414093f, -0.01497049f, 
    -0.15346123f, -0.02537101f, 0.13821012f, 0.14229107f, 0.13623764f, -0.03572038f, -0.09811255f, 0.10550997f, 
    0.11475741f, 0.07156168f, 0.14942561f, -0.11322839f, 0.14442441f, -0.00188143f, 0.06847822f, 0.00287175f, 
    0.17499337f, -0.16900383f, 0.11528295f, 0.33458763f, 0.28580371f, -0.00832679f, 0.17794536f, 0.13493812f, 
    -0.13281690f, 0.18462396f, -0.09470285f, 0.16731808f, -0.05376605f, -0.15354393f, 0.32930711f, -0.13888051f, 
    -0.08824781f, 0.06052104f, 0.08412030f, -0.20276539f, 0.00585590f, 0.10649948f, -0.39378726f, 0.17543580f, 
    0.37631211f, 0.08666241f, -0.05773783f, -0.18689029f, -0.00057162f, -0.00971372f, -0.00392412f, -0.23334390f, 
    -0.21026921f, 0.03792435f, -0.01525458f, 0.10929564f, -0.16411602f, -0.00942156f, 0.32441238f, 0.05274571f, 
    -0.00657327f, 0.01867405f, 0.07826384f, -0.12218814f, -0.15812644f, 0.03753831f, 0.12689455f, -0.05895923f, 
    0.39447659f, 0.15782815f, -0.11244865f, -0.35042366f, 0.02382283f, 0.00028476f, -0.17105101f, 0.13571848f, 
    0.26646510f, -0.12264589f, 0.05864193f, -0.27314934f, 0.12913886f, 0.29356629f, -0.06200966f, 0.23759535f, 
    0.01327355f, 0.14929540f, 0.04865557f, -0.15545085f, 0.17145739f, -0.07900556f, 0.08041591f, 0.02257580f, 
    0.07752632f, 0.07081346f, 0.15060320f, -0.09924182f, -0.15778615f, 0.10385764f, 0.14574769f, 0.01059262f, 
    0.07533573f, 0.10299592f, -0.05148159f, 0.41181371f, -0.00828605f, -0.07000901f, 0.02077614f, 0.07080398f, 
    0.38516915f, 0.16937798f, -0.02335114f, 0.11727676f, 0.15221968f, 0.10395628f, -0.15208475f, -0.67814291f, 
    0.25967592f, 0.05833584f, -0.26975489f, 0.12959586f, 0.03493035f, 0.17679599f, 0.14819972f, 0.14482875f, 
    0.08219215f, -0.04920726f, -0.15371515f, -0.00162725f, -0.10452970f, 0.28219232f, -0.34190324f, 0.04693525f, 
    -0.09898591f, -0.10596230f, 0.07820250f, 0.35954657f, -0.00554157f, 0.03829408f, -0.14280969f, 0.02452591f, 
    -0.38836196f, -0.12068424f, 0.09498362f, 0.16197337f, -0.08230598f, 0.11879700f, 0.08718664f, 0.14669208f, 
    -0.07692382f, -0.01247951f, -0.23111708f, 0.59836626f, 0.18540223f, -0.00621287f, -0.07115915f, -0.02308366f, 
    -0.02297042f, -0.09733682f, -0.10886705f, 0.16588026f, -0.13569656f, -0.03098929f, -0.23906247f, 0.03256597f, 
    0.06537264f, -0.02466180f, 0.12928559f, 0.52653742f, 0.03868212f, -0.11302818f, -0.54719192f, 0.15735413f, 
    0.23923281f, -0.04845886f, 0.17179373f, -0.41547567f, -0.07813196f, 0.16643991f, 0.04612859f, 0.15418647f, 
    0.08077743f, 0.13954167f, -0.05247945f, 0.59797800f, 0.33872017f, -0.04270335f, 0.19751903f, -0.01282248f, 
    0.07922627f, -0.11600230f, 0.08794046f, 0.20886827f, -0.06611646f, 0.03512194f, -0.08198831f, 0.01593720f, 
    -0.11690813f, -0.05042169f, -0.12778260f, 0.25688264f, 0.05824656f, 0.03221053f, -0.51168466f, 0.14590967f, 
    -0.07920737f, -0.01363783f, 0.16938511f, -0.35895562f, 0.06685703f, -0.24363728f, 0.14115854f, 0.12973864f, 
    0.48829094f, -0.12124705f, 0.19184136f, 0.04774733f, 0.36382896f, 0.14883371f, -0.12396529f, 0.02422367f, 
    0.14449818f, -0.00687251f, 0.14132378f, -0.27105379f, 0.16108795f, -0.04328600f, -0.09638587f, 0.10955924f, 
    -0.13901493f, 0.12321319f, 0.10224660f, 0.54013389f, -0.14397177f, -0.16825461f, 0.09361717f, 0.10261746f, 
    -0.12957750f, 0.05311696f, -0.17062572f, 0.15552691f, 0.14588732f, -0.00376219f, 0.15281869f, 0.07656851f, 
    0.01847849f, 0.09912623f, -0.08651430f, -0.15796471f, -0.04094448f, -0.13241975f, 0.13254406f, -0.00467866f, 
    -0.15287425f, -0.09088366f, 0.05747591f, 0.20728070f, 0.05698515f, 0.07168361f, -0.37173679f, 0.12758806f, 
    0.12090947f, 0.15951210f, 0.13581105f, 0.32074514f, -0.04086142f, 0.17462450f, -0.40803006f, 0.17027853f, 
    0.31236875f, -0.02548808f, 0.04007683f, -0.10330513f, -0.07143456f, -0.25980887f, -0.00288965f, 0.33400124f, 
    -0.16202787f, 0.06804320f, 0.02827827f, 0.09886976f, -0.04942928f, -0.00090025f, 0.27692065f, -0.04864460f, 
    -0.07393316f, -0.01626920f, -0.16178989f, 0.26479763f, -0.11405990f, -0.01584399f, 0.16454546f, 0.01657303f, 
    0.44876680f, -0.12556179f, 0.01450284f, -0.33545604f, 0.11729277f, 0.09339231f, -0.20723325f, 0.00883377f, 
    -0.01678535f, -0.05711811f, -0.12588485f, -0.28364211f, -0.01911128f, 0.10015648f, -0.12858526f, 0.08124924f, 
    0.32694402f, 0.10494998f, 0.20962705f, 0.13672678f, 0.28300285f, -0.02668905f, -0.03988140f, -0.14454590f, 
    0.08602238f, 0.03555071f, 0.16042311f, 0.14762147f, 0.13896814f, -0.18028815f, -0.16003841f, 0.05649870f, 
    -0.15926304f, -0.08238410f, 0.12586381f, -0.08809510f, 0.07141736f, -0.04089241f, -0.07058080f, 0.02787975f, 
    0.53727001f, 0.12400182f, 0.14934145f, 0.01078305f, -0.08260076f, -0.13978511f, -0.18449283f, 0.08173666f, 
    0.12517695f, 0.01590882f, 0.12263646f, -0.05736732f, 0.03663829f, 0.05760995f, 0.27977973f, -0.16641876f, 
    0.06653346f, -0.18366185f, 0.07367726f, 0.00454697f, 0.03508116f, -0.12280063f, 0.29826403f, -0.16520837f, 
    0.30109197f, 0.14649738f, 0.17234334f, -0.33404490f, -0.12420137f, -0.16040990f, 0.05451233f, -0.14763273f, 
    -0.13174187f, 0.09443057f, -0.13714801f, -0.31793842f, -0.06695859f, 0.08952883f, 0.06596361f, 0.19057226f, 
    0.05615193f, -0.05829911f, 0.05988485f, -0.11478680f, -0.19184232f, -0.14561859f, -0.17392632f, 0.13811076f, 
    -0.03132063f, 0.00388119f, -0.10656349f, -0.10357253f, -0.12088953f, 0.38408774f, -0.12366675f, -0.09847831f, 
    0.01753777f, 0.15405422f, -0.10154806f, 0.47511402f, 0.04694787f, 0.12185591f, -0.10975164f, 0.08014223f, 
    0.01760153f, 0.05425507f, 0.12803744f, 0.09689554f, 0.17345364f, -0.04401213f, -0.11652660f, 0.11499111f, 
    -0.08518680f, -0.04033291f, -0.17248535f, -0.00966433f, -0.10841830f, 0.04751248f, -0.09905539f, -0.10825294f, 
    0.04898269f, 0.17054980f, 0.17573516f, -0.13010076f, -0.15100263f, 0.13340147f, -0.21375240f, 0.09177128f, 
    -0.00764651f, 0.12530968f, -0.07793725f, 0.07374963f, -0.15827067f, -0.15717438f, 0.00319686f, 0.05227606f, 
    -0.03613978f, 0.04802753f, 0.10084853f, 0.09242357f, -0.14336482f, -0.02346472f, -0.17449807f, 0.02081132f, 
    0.20878020f, -0.09577991f, -0.05520710f, -0.51508397f, -0.13732643f, 0.03756047f, -0.09887358f, 0.07803130f, 
    -0.13798034f, 0.11789656f, 0.15032507f, 0.15943854f, -0.04115931f, 0.16573523f, 0.02754994f, -0.13288975f, 
    0.07402108f, 0.00234443f, 0.01879238f, 0.31230497f, 0.10763085f, 0.05694812f, -0.05950946f, -0.14911710f, 
    0.06167047f, -0.00307306f, -0.16920425f, 0.27959949f, -0.08892989f, -0.21476315f, -0.05780408f, -0.02529614f, 
    -0.00176657f, -0.04703189f, -0.17713325f, 0.02819705f, -0.02847839f, 0.16231407f, -0.04134419f, 0.13687329f, 
    -0.10992579f, -0.01697880f, 0.15089133f, -0.15402333f, 0.07122065f, -0.19202933f, -0.00778087f, -0.16331311f, 
    -0.00620676f, -0.16373248f, -0.15529528f, -0.11109480f, -0.00665033f, -0.07102591f, 0.06596279f, -0.07544095f, 
    -0.17377028f, -0.12800042f, -0.01587781f, 0.05441803f, -0.06993958f, 0.03976744f, 0.15176569f, -0.01286948f, 
    -0.35531884f, -0.02271153f, 0.12462767f, -0.27253938f, 0.01901503f, 0.13568255f, 0.08037736f, -0.11363152f, 
    0.12708335f, 0.03226616f, 0.08315220f, 0.07746476f, 0.02545724f, 0.22601366f, 0.31906736f, 0.05284785f, 
    -0.06215912f, -0.00805862f, -0.05795743f, -0.54139620f, 0.02597843f, 0.06813212f, -0.15384749f, -0.01481725f, 
    -0.21802530f, -0.16183265f, 0.10496891f, 0.32146192f, 0.06295393f, 0.41183898f, -0.00060414f, -0.12992769f, 
    0.37936795f, -0.00761909f, 0.37025264f, 0.31013000f, -0.04822430f, -0.17433186f, 0.29743800f, 0.02938955f, 
    -0.05318272f, -0.02994679f, -0.02599013f, -0.05480028f, 0.14146727f, -0.20744242f, -0.17264080f, -0.03811072f, 
    -0.12731205f, 0.17611913f, -0.03554503f, 0.01521994f, 0.06969431f, 0.00987301f, -0.26473156f, -0.13764165f, 
    0.40092945f, 0.00780165f, -0.10261244f, -0.04376648f, 0.06688038f, -0.08909143f, 0.03214863f, 0.16791655f, 
    -0.38658151f, -0.00211159f, -0.04666565f, -0.10298909f, 0.02637778f, 0.00501391f, -0.31437466f, -0.02709606f, 
    0.08585156f, -0.09920495f, -0.13398375f, 0.38729814f, -0.12565462f, -0.07093366f, 0.16659157f, -0.02940274f, 
    -0.05343498f, -0.08981352f, -0.09905453f, 0.18613985f, 0.02599189f, 0.04723813f, -0.21478064f, -0.11712870f, 
    -0.36132291f, 0.02135809f, 0.15225779f, 0.24689974f, -0.04620401f, -0.25972858f, 0.00502212f, 0.26599842f, 
    -0.02952438f, 0.15313849f, -0.45529976f, -0.42293072f, 0.17082849f, -0.01618057f, 0.27300680f, 0.01805480f, 
    -0.13551563f, 0.08320046f, 0.11964721f, 0.23564762f, 0.09426808f, -0.02274474f, -0.10454307f, -0.12933463f, 
    0.04244588f, -0.05830321f, -0.16939807f, -0.05114811f, 0.08671168f, -0.04118898f, 0.01264973f, 0.13367003f, 
    -0.10539339f, -0.04116358f, 0.15361215f, 0.16516200f, -0.08446932f, 0.29464325f, -0.05616442f, -0.11086023f, 
    0.38008544f, -0.08897217f, 0.09841937f, -0.16271253f, 0.26041621f, -0.05814543f, 0.25839317f, -0.11436675f, 
    -0.09546810f, -0.08710266f, -0.08823423f, -0.04182119f, -0.02743126f, -0.14646277f, 0.28346607f, -0.11110105f, 
    -0.08429059f, -0.07995968f, -0.06449749f, 0.10725346f, 0.06410427f, -0.05424695f, -0.51338673f, -0.12240117f, 
    0.14137459f, 0.10241868f, -0.08936447f, -0.03534304f, -0.02571590f, 0.06839391f, -0.10366906f, -0.01446578f, 
    0.49251479f, 0.07672212f, -0.06597460f, 0.50156331f, 0.26969144f, -0.08042999f, 0.25319752f, -0.14830875f, 
    0.10328679f, 0.12363980f, -0.13227162f, 0.11330615f, -0.00892088f, -0.15958777f, -0.18000506f, -0.06338731f, 
    -0.07444278f, 0.14614151f, -0.12786207f, -0.14981122f, -0.00061822f, 0.10231769f, 0.20442429f, -0.09565178f, 
    -0.11602910f, 0.11249666f, -0.16327599f, 0.06532364f, 0.11451121f, -0.05918762f, 0.17197654f, -0.20500875f, 
    -0.21764800f, 0.04774864f, -0.02107971f, 0.32150149f, 0.01003008f, -0.13024271f, 0.22156349f, -0.11282921f, 
    0.00380586f, 0.15554272f, 0.13264731f, 0.09336517f, 0.14991227f, -0.08885954f, 0.19284981f, 0.16592236f, 
    0.22785701f, 0.17153978f, 0.16460678f, -0.24415046f, -0.04716621f, 0.02740225f, 0.25583488f, 0.06668746f, 
    0.00564966f, -0.03020332f, -0.16261666f, -0.14534658f, -0.04895595f, 0.41152716f, -0.04155269f, -0.02276766f, 
    -0.21571866f, 0.09066878f, -0.15344051f, -0.20572141f, 0.14936323f, -0.11538119f, 0.21520208f, 0.00027805f, 
    -0.11723975f, 0.14113310f, 0.12419788f, 0.16603307f, 0.15431294f, 0.00893945f, 0.48278287f, -0.09096317f, 
    0.23964410f, 0.08033858f, 0.15694779f, -0.54336375f, 0.06188347f, 0.06743540f, -0.44566095f, 0.10319828f, 
    -0.48032567f, 0.10202994f, -0.05138946f, 0.14090732f, -0.07144288f, -0.12974571f, 0.10861459f, -0.05813897f, 
    -0.16613051f, 0.07202905f, 0.36158130f, -0.37120602f, -0.36320686f, -0.13357738f, 0.07489344f, 0.05921930f, 
    -0.06810416f, 0.11051968f, -0.05212554f, -0.17573342f, 0.02521404f, 0.10166215f, -0.24448387f, 0.04529287f, 
    0.20431942f, -0.16935705f, 0.01916134f, -0.30087379f, 0.00336187f, 0.17070977f, 0.42460445f, -0.02271506f, 
    0.24289514f, 0.02387689f, -0.01278172f, 0.01095031f, 0.15703404f, 0.28324124f, 0.16146557f, 0.38816610f, 
    0.16104473f, 0.14267129f, 0.11864738f, -0.22311597f, 0.02691595f, -0.00726558f, 0.03667443f, 0.08138648f, 
    -0.15406191f, -0.11728716f, 0.11845412f, -0.36218733f, 0.01383489f, 0.14603446f, 0.18622811f, 0.11615525f, 
    -0.11237425f, -0.00284192f, 0.04500214f, 0.09072905f, 0.00197572f, 0.08030981f, 0.03103103f, 0.07479452f, 
    0.01129052f, -0.02134406f, -0.09585197f, 0.35606056f, -0.13606317f, 0.33817753f, 0.11630826f, -0.17314129f, 
    0.05805220f, -0.07860958f, 0.33408615f, -0.02363641f, -0.35628730f, -0.10045131f, -0.26390010f, 0.09575861f, 
    0.05989038f, -0.01575614f, -0.04273304f, -0.05428974f, -0.07051485f, 0.16937594f, 0.28168371f, -0.13054250f, 
    0.16572620f, 0.07374641f, -0.05913845f, 0.07032987f, 0.00266609f, -0.10533467f, -0.15878147f, 0.04516936f, 
    0.04408922f, -0.10940612f, -0.06701951f, -0.15095077f, 0.07910335f, -0.40080491f, 0.07393059f, 0.31243175f, 
    0.05520006f, 0.17180172f, 0.02016843f, -0.19657116f, 0.42619771f, -0.13884549f, 0.17312759f, -0.15306152f, 
    -0.14528184f, 0.08487076f, 0.13260417f, -0.15420899f, -0.00861395f, 0.12028803f, -0.37205708f, -0.02836471f, 
    -0.28819713f, -0.03689240f, 0.11221111f, -0.11575263f, 0.09322704f, 0.01617569f, 0.22754994f, -0.13202542f, 
    -0.01118613f, 0.04747541f, 0.04117168f, 0.12287107f, 0.05758172f, 0.13326743f, 0.07277095f, 0.20131889f, 
    0.29359612f, -0.12570392f, -0.08665475f, -0.26392969f, -0.34522784f, 0.15656298f, 0.33714074f, -0.04192311f, 
    -0.14235790f, -0.04351962f, 0.15848367f, 0.14561459f, 0.07112073f, -0.04194197f, 0.01793469f, -0.04982981f, 
    0.37899691f, 0.13131721f, 0.15662126f, 0.02468438f, 0.04925147f, 0.02200497f, -0.13183749f, -0.13292968f, 
    -0.11263381f, 0.11518180f, -0.03876404f, -0.49958810f, 0.09611976f, 0.23552263f, -0.15648837f, 0.01099564f, 
    0.24242021f, 0.15835202f, 0.09809823f, 0.10853086f, 0.22703972f, -0.10819123f, -0.13748938f, -0.05685793f, 
    0.10817557f, -0.09285396f, 0.08049738f, -0.24594618f, -0.03467165f, 0.11969487f, 0.31588304f, 0.06304836f, 
    -0.19537139f, -0.01330042f, 0.07088722f, -0.20184232f, 0.16694663f, 0.03517070f, -0.04035675f, 0.03718715f, 
    0.25884223f, -0.09053438f, -0.09125752f, 0.31912005f, 0.06985007f, 0.21361780f, -0.01703163f, -0.17724419f, 
    -0.09154913f, -0.00295644f, 0.03551374f, 0.26395077f, 0.41086024f, -0.08186007f, -0.08473513f, -0.09110279f, 
    -0.05839058f, -0.16148524f, 0.07364254f, 0.11321286f, 0.12897798f, -0.22985123f, 0.33721980f, 0.14890677f, 
    0.04135469f, -0.00727983f, 0.07182012f, -0.44223431f, -0.03042410f, 0.10440541f, -0.17294170f, -0.11602031f, 
    0.27851376f, -0.05442224f, 0.10151603f, 0.03252075f, -0.02984363f, -0.19867823f, -0.00449484f, 0.18338378f, 
    -0.03398396f, 0.16039275f, 0.32882944f, 0.23444709f, 0.06473414f, -0.10740238f, -0.31006458f, -0.12397777f, 
    -0.05715930f, 0.07077778f, -0.11162861f, 0.06545987f, 0.04171887f, 0.23512417f, -0.12480013f, 0.11382230f, 
    -0.29661664f, -0.00508702f, -0.03145853f, 0.07911593f, 0.17960930f, -0.00247932f, 0.25886798f, -0.09335845f, 
    -0.15449351f, -0.08309732f, -0.10829207f, 0.30773529f, 0.05986011f, 0.08626077f, 0.04909722f, -0.20252866f, 
    -0.31578723f, 0.14858252f, 0.30602586f, -0.19265758f, -0.12402176f, 0.00537270f, 0.10931150f, 0.11071447f, 
    -0.15567884f, -0.02484767f, 0.15263098f, 0.23382725f, -0.11346972f, -0.10542520f, 0.48655313f, -0.00023057f, 
    0.02999848f, 0.14446117f, -0.17619911f, -0.01312745f, 0.02006439f, 0.17311111f, 0.22366577f, 0.04435836f, 
    -0.00128570f, -0.07693690f, 0.00092871f, 0.29372278f, 0.02768616f, -0.40521315f, -0.06111225f, -0.22251099f, 
    0.32194540f, -0.00187977f, -0.02924707f, -0.40967232f, -0.30145755f, -0.18974279f, 0.27556336f, 0.07438301f, 
    -0.00373444f, 0.01865915f, 0.02214709f, 0.08407593f, 0.18090840f, -0.03378096f, -0.19921242f, -0.02453298f, 
    0.04114732f, 0.05981961f, -0.04703721f, 0.05784650f, -0.04283997f, 0.14903481f, 0.24434991f, -0.06741039f, 
    0.06095437f, -0.07194144f, 0.13031940f, -0.00852804f, -0.11701746f, 0.44837955f, -0.14166728f, -0.00452645f, 
    -0.43071344f, -0.04539730f, 0.21935263f, -0.08015575f, -0.33382353f, -0.07698725f, -0.18154413f, -0.04313188f, 
    0.01680011f, 0.03923265f, -0.13356143f, -0.18410392f, 0.07447020f, 0.24924766f, 0.10738236f, 0.04045880f, 
    0.29225308f, -0.04503517f, -0.05603479f, -0.12184348f, 0.12702326f, -0.05085060f, 0.00084829f, -0.17553617f, 
    0.12945744f, -0.18359026f, -0.07371730f, 0.04865078f, -0.05161327f, 0.37631842f, 0.16047473f, 0.25689447f, 
    0.08998296f, -0.16313349f, 0.07626032f, 0.11551230f, -0.14194095f, 0.11278309f, 0.13597079f, 0.06169338f, 
    -0.08171953f, 0.15163757f, -0.13271596f, -0.20150211f, -0.05871075f, -0.15348606f, -0.12703292f, 0.07113890f, 
    0.12894562f, 0.00742807f, 0.01613805f, -0.05871811f, 0.14561342f, 0.09266901f, -0.10960357f, 0.09097932f, 
    0.08540080f, 0.04736131f, -0.06629924f, -0.03308184f, -0.12331712f, -0.26653492f, 0.12678728f, -0.17311729f, 
    -0.34703916f, -0.07199642f, 0.30978495f, 0.09680987f, -0.33339462f, -0.10495515f, 0.02422044f, 0.13791923f, 
    0.06777963f, -0.03662130f, 0.03234489f, -0.20548567f, 0.15071949f, 0.07330112f, -0.26126137f, -0.13305561f, 
    0.20272063f, 0.03714699f, 0.09657037f, 0.00526275f, -0.08812663f, 0.02940466f, 0.44273588f, -0.00679422f, 
    0.25281024f, -0.04254119f, -0.00693122f, 0.09490435f, 0.02829698f, 0.16898917f, 0.07456846f, 0.26895750f, 
    -0.11283061f, 0.13058543f, 0.06263652f, 0.28670904f, 0.14627013f, 0.09800174f, -0.21985966f, 0.10398826f, 
    0.05597060f, 0.09148385f, -0.08297703f, 0.13257159f, 0.10291941f, 0.25886708f, -0.27230749f, 0.09086642f, 
    -0.16000076f, -0.07851887f, 0.14297566f, -0.05094691f, 0.00509518f, 0.02190646f, 0.26737231f, -0.13273017f, 
    -0.32158405f, 0.06004472f, 0.09129866f, 0.29435432f, 0.14208549f, 0.16127378f, -0.12306044f, -0.30003476f, 
    0.01589908f, 0.13818000f, 0.08805655f, -0.03116520f, 0.23922510f, -0.16948797f, -0.02285458f, 0.00736132f, 
    0.15324330f, 0.03743124f, -0.03592419f, 0.13295458f, 0.13790171f, -0.03603157f, 0.13142487f, -0.09543063f, 
    -0.16645977f, 0.10163604f, 0.12035121f, 0.04134152f, -0.15881361f, -0.08389290f, 0.08076001f, -0.10737263f, 
    0.17632587f, -0.06990790f, 0.02276194f, 0.00286077f, -0.01678461f, -0.14548393f, 0.13159192f, -0.11808236f, 
    -0.26679417f, 0.12873578f, 0.31413347f, -0.29115349f, -0.34201160f, -0.01301909f, 0.08472239f, -0.03803064f, 
    -0.13177000f, 0.10550353f, 0.13083252f, -0.01548475f, 0.14208966f, 0.05346246f, 0.28455991f, 0.11444848f, 
    -0.02594672f, 0.14705974f, -0.07891475f, -0.03351783f, -0.03713977f, -0.13560489f, 0.22481006f, -0.00824255f, 
    0.05564576f, 0.04416204f, -0.09992015f, 0.08618303f, 0.07041184f, -0.30232468f, 0.14071180f, 0.31147069f, 
    -0.06107115f, -0.00806277f, -0.20379464f, 0.13561442f, 0.03760830f, 0.10199355f, -0.10609726f, 0.02570906f, 
    -0.04450718f, -0.15332995f, 0.14178193f, -0.11679070f, 0.07661081f, -0.00410892f, -0.16120566f, 0.05970779f, 
    -0.02511952f, -0.01418869f, -0.11942226f, -0.08969225f, -0.11134987f, -0.15047449f, -0.12750308f, -0.06137177f, 
    -0.17935036f, -0.14735377f, 0.14688510f, 0.05204969f, -0.14351487f, -0.01954620f, 0.03560001f, -0.13888626f, 
    -0.39491156f, 0.00226804f, -0.17451175f, 0.49692315f, 0.38503176f, -0.00639698f, -0.03464774f, -0.08386548f, 
    -0.00734759f, -0.08977896f, -0.14734825f, 0.34159184f, 0.02069744f, 0.22907725f, -0.00094989f, -0.13962308f, 
    0.09722479f, 0.12699582f, 0.07187489f, -0.24190249f, -0.13267392f, 0.15820318f, -0.16922271f, 0.09799675f, 
    -0.14814483f, -0.12717943f, 0.16968727f, -0.13424063f, -0.10125788f, -0.00568103f, -0.07209639f, 0.07542281f, 
    0.47735611f, 0.00834143f, -0.00534953f, 0.31275713f, 0.11986165f, -0.16377643f, 0.17564861f, -0.08826441f, 
    -0.10216683f, 0.12524909f, 0.04234157f, 0.39251786f, -0.10617139f, -0.25565055f, 0.31346911f, 0.14413221f, 
    -0.13253479f, 0.13434058f, -0.15487067f, 0.06661630f, -0.11086945f, -0.17035276f, 0.07002249f, -0.16815956f, 
    0.20508273f, -0.11749224f, 0.06854656f, -0.21642192f, 0.00141508f, -0.23374537f, 0.02358186f, -0.18952939f, 
    0.33212817f, 0.14356530f, 0.52398354f, 0.10826965f, -0.27328381f, -0.03158823f, -0.08318969f, 0.02522503f, 
    0.11680061f, -0.15519249f, 0.12639855f, -0.07242580f, 0.06046488f, -0.05366204f, 0.31354195f, -0.16145161f, 
    -0.25504416f, -0.01429275f, 0.01115290f, 0.13270845f, 0.01109444f, -0.05192349f, -0.05737568f, -0.07714263f, 
    0.34005666f, -0.11209530f, 0.17496087f, 0.16176461f, 0.06832212f, 0.18484430f, -0.10337704f, -0.31222716f, 
    -0.10663939f, -0.10466405f, -0.21638545f, 0.36779693f, 0.00908908f, -0.06529240f, 0.15948123f, 0.00753656f, 
    0.01252346f, 0.08768831f, -0.11158226f, -0.22942923f, -0.12782314f, -0.17254284f, -0.02599378f, -0.16513608f, 
    0.17807114f, 0.08947554f, -0.05005495f, 0.16308372f, -0.02109634f, 0.06419203f, -0.07738428f, 0.02172303f, 
    0.31078735f, -0.05478571f, -0.04710584f, -0.10016924f, 0.02812409f, 0.18628208f, -0.14912862f, 0.14058569f, 
    -0.08169728f, 0.02870061f, -0.15000124f, -0.05632790f, 0.04495280f, -0.12726666f, -0.05213553f, 0.17400366f, 
    -0.08953094f, 0.03220502f, -0.14195126f, -0.08442625f, -0.01701736f, 0.00073950f, -0.00281505f, -0.11979502f, 
    -0.15262069f, -0.03690182f, -0.03914932f, -0.06344312f, 0.09720381f, 0.12842362f, -0.14058486f, -0.14759366f, 
    0.08312975f, -0.00209352f, -0.14494187f, 0.04928617f, -0.04016835f, -0.13479182f, -0.02593624f, 0.00677380f, 
    0.00945858f, 0.04736727f, 0.01133847f, -0.15026708f, -0.21551073f, 0.07651099f, 0.00658295f, -0.03532643f, 
    0.16716227f, -0.01375331f, 0.16064323f, 0.44616550f, -0.14728071f, -0.03029233f, 0.14302447f, 0.14191124f, 
    0.00774784f, -0.13638212f, 0.00642073f, -0.11978477f, 0.09233355f, 0.05123972f, 0.14920674f, 0.03920019f, 
    0.10700969f, 0.09241894f, 0.02158914f, -0.04761405f, -0.15298538f, -0.21381953f, 0.10539785f, -0.16936728f, 
    0.06432658f, -0.03378288f, 0.46279213f, 0.29803714f, -0.06561132f, 0.16193314f, -0.11463372f, -0.10171910f, 
    0.03731428f, -0.13797393f, 0.04758678f, -0.28101784f, 0.07145161f, -0.02420434f, 0.30339333f, 0.04487455f, 
    -0.22273163f, -0.01020976f, 0.12321138f, 0.04515871f, -0.15498491f, 0.07795417f, 0.49667740f, -0.05344340f, 
    -0.20942011f, -0.01911682f, 0.16637783f, 0.40448448f, 0.12590224f, -0.01951532f, 0.13977206f, 0.09756199f, 
    -0.22247744f, 0.06578407f, -0.12438881f, -0.27325624f, -0.19820458f, -0.08621310f, -0.10783325f, -0.01366088f, 
    -0.10502063f, 0.09113574f, -0.18009868f, 0.29628921f, -0.02609338f, 0.08881504f, -0.35960066f, -0.12436190f, 
    0.38899198f, -0.07734731f, -0.15535647f, 0.44200361f, 0.05136741f, 0.07470679f, 0.19367453f, -0.09280822f, 
    0.09077797f, 0.04768991f, 0.09376805f, 0.21423915f, 0.16209188f, 0.09475203f, 0.13531353f, -0.61878461f, 
    -0.11451768f, 0.17082794f, 0.15824506f, -0.22933410f, 0.05103059f, -0.04147705f, -0.15169632f, -0.12855244f, 
    -0.10574596f, -0.14659658f, 0.03939333f, -0.27639353f, 0.17357011f, 0.27903003f, -0.07419937f, -0.14917819f, 
    -0.06157590f, 0.02668785f, -0.11699621f, -0.16781048f, -0.04396421f, 0.16755560f, 0.25194752f, 0.10142038f, 
    -0.13595062f, -0.12202004f, 0.08010177f, 0.29621673f, 0.11421153f, -0.12227465f, -0.13974927f, 0.35058427f, 
    0.00618151f, 0.06733915f, -0.33143371f, 0.40863952f, 0.00802681f, -0.04149885f, 0.13037255f, -0.11917926f, 
    -0.03396205f, -0.08546064f, 0.00767639f, 0.23688187f, -0.17061380f, 0.02704731f, -0.14171539f, 0.08979564f, 
    0.32526621f, 0.08592694f, -0.10323968f, 0.26920477f, 0.14827208f, -0.01954190f, -0.20180088f, -0.15666330f, 
    0.11758161f, 0.13479307f, -0.15427829f, -0.29904374f, 0.14962906f, -0.13235803f, 0.06185714f, 0.00699408f, 
    0.28254408f, -0.16666971f, 0.09873839f, -0.39159837f, 0.12444715f, -0.04470001f, 0.17909285f, -0.12008700f, 
    0.13824646f, 0.00340849f, 0.00246178f, -0.06933945f, 0.00050577f, -0.11175057f, 0.03946823f, -0.08745632f, 
    0.12466096f, -0.04512115f, -0.00945238f, 0.02286862f, 0.10172791f, 0.14815876f, -0.13351639f, 0.06323919f, 
    0.38535529f, -0.00839992f, 0.16834728f, 0.01834170f, -0.10755430f, 0.29295769f, 0.16552582f, -0.46097532f, 
    -0.07193741f, -0.17404754f, 0.15360638f, -0.24882612f, -0.09324769f, -0.01412450f, 0.30308068f, -0.00707708f, 
    -0.15122208f, 0.14985327f, -0.07947870f, 0.19616975f, -0.01264745f, 0.04761419f, -0.25809968f, 0.08698219f, 
    0.36542362f, -0.10192189f, -0.15397295f, -0.10259924f, -0.10632542f, 0.06838683f, 0.05492339f, -0.01565796f, 
    0.39800057f, 0.14884202f, 0.11470319f, -0.32636836f, 0.13278210f, -0.28270051f, -0.02670551f, -0.06571322f, 
    -0.25436267f, 0.06045923f, 0.02102379f, 0.21088950f, 0.12715332f, 0.03169121f, 0.20643319f, -0.02127344f, 
    -0.04734158f, 0.13685445f, -0.15107191f, -0.12657003f, -0.11961786f, 0.05305387f, 0.09745364f, 0.06352361f, 
    0.34147760f, 0.11487101f, -0.04314096f, -0.32969335f, 0.03185304f, -0.14570226f, 0.04773870f, -0.04156627f, 
    0.37361872f, 0.11096835f, 0.00182372f, -0.02426456f, -0.04241462f, 0.52215892f, -0.08515467f, -0.11649399f, 
    0.03526134f, -0.00676635f, 0.22786744f, -0.32374060f, 0.01270339f, 0.10719183f, 0.10942911f, 0.03681442f, 
    0.04576531f, 0.00142771f, 0.09977562f, -0.33090493f, 0.08212788f, 0.31738812f, -0.13952787f, -0.13079600f, 
    -0.15500233f, -0.11951267f, 0.06473169f, -0.04526892f, -0.11334001f, 0.03929049f, 0.15687563f, -0.16514674f, 
    0.24379914f, -0.09572780f, 0.00568267f, 0.52167594f, -0.04883917f, 0.04044127f, 0.13718681f, 0.09813284f, 
    -0.19950193f, -0.05970328f, 0.02992735f, 0.07792692f, 0.18829732f, 0.13238765f, 0.04785967f, -0.01065095f, 
    0.06860623f, 0.07953346f, -0.09217083f, -0.15935886f, 0.10290555f, 0.16088341f, 0.01157798f, -0.04772636f, 
    0.24569826f, -0.05272032f, 0.07133763f, -0.31083426f, -0.05283367f, 0.04952995f, -0.17931591f, 0.02914400f, 
    0.07301962f, -0.09555718f, 0.13190804f, -0.07794499f, -0.06559008f, 0.48222002f, -0.14975978f, -0.07787637f, 
    -0.56583941f, 0.10176879f, 0.30762908f, 0.34203565f, -0.32337564f, 0.04269292f, 0.26864859f, 0.14484477f, 
    0.00333762f, -0.04554301f, -0.11770739f, 0.11546805f, 0.16465603f, -0.05033253f, -0.37990427f, 0.15774693f, 
    -0.04428579f, -0.10487505f, -0.14103596f, -0.50185245f, -0.03439821f, -0.08674643f, -0.48420471f, 0.13918671f, 
    0.56886780f, 0.10312586f, -0.13854893f, 0.12527159f, -0.01731616f, 0.07023110f, -0.15672959f, -0.04919926f, 
    0.40184975f, 0.03215935f, -0.11744805f, 0.13070694f, 0.34968859f, 0.03747681f, 0.29485455f, -0.16015549f, 
    0.07947053f, -0.07662635f, -0.01982261f, 0.12022086f, -0.06718200f, -0.12144824f, -0.15376559f, -0.02825812f, 
    -0.18920983f, -0.12938502f, -0.14656483f, 0.18187062f, -0.11633077f, -0.05979154f, 0.27280197f, 0.03139672f, 
    -0.00680175f, 0.15237939f, -0.14157972f, -0.23571360f, -0.14509846f, -0.01637390f, -0.00795993f, 0.06321236f, 
    0.15832625f, 0.16584343f, 0.35610411f, 0.15066205f, -0.20702244f, -0.15432632f, -0.28937453f, -0.17196424f, 
    -0.14320868f, -0.09634969f, -0.15221103f, 0.10779381f, -0.06283060f, 0.23439392f, -0.21208811f, -0.03570624f, 
    -0.17699687f, 0.04358159f, 0.15002443f, 0.18084621f, -0.04032233f, 0.00700925f, 0.32740864f, -0.06642553f, 
    -0.14435638f, 0.01944754f, 0.12640797f, 0.12147553f, -0.02997244f, -0.08036280f, 0.05686344f, -0.07543337f, 
    0.22625299f, 0.10484017f, -0.02636142f, -0.39095244f, 0.33177987f, -0.12151095f, 0.33813798f, 0.00484024f, 
    0.13188538f, 0.14368963f, -0.11026372f, -0.31417587f, -0.16402015f, -0.03169498f, 0.24070378f, -0.03417240f, 
    -0.26782992f, 0.14155357f, -0.03166924f, -0.10726328f, -0.07034627f, 0.06956585f, 0.40828452f, 0.06329678f, 
    0.02677527f, -0.07655045f, 0.02797184f, 0.49798396f, 0.00112913f, 0.43047416f, -0.08099666f, -0.24183777f, 
    -0.19814967f, -0.17797925f, 0.37788090f, -0.18461755f, -0.18614608f, 0.16558865f, 0.30777910f, 0.00901315f, 
    -0.03732686f, 0.17082730f, -0.11166599f, -0.20734003f, 0.04550222f, -0.07267343f, 0.12536038f, -0.13876653f, 
    0.36605179f, -0.08369409f, -0.03537314f, -0.26528314f, 0.04111034f, -0.11100730f, -0.20478624f, 0.07395236f, 
    0.30451745f, -0.02399812f, 0.06938361f, -0.08510219f, 0.04301972f, -0.11343285f, -0.07521927f, 0.23471788f, 
    0.02105741f, 0.02651927f, -0.07011707f, -0.60116500f, -0.03642628f, -0.03288680f, 0.33196670f, -0.13975272f, 
    -0.16340449f, -0.15778956f, -0.12503919f, -0.18819734f, 0.10887486f, 0.09005331f, -0.42830822f, -0.03936181f, 
    0.21029830f, -0.08693305f, -0.17964937f, -0.15520117f, 0.12916264f, -0.10227926f, 0.43935853f, 0.06332869f, 
    0.20924510f, -0.12697618f, 0.09920936f, 0.01914195f, 0.08571050f, -0.01399500f, 0.12410995f, 0.29315990f, 
    0.18536787f, -0.09118321f, 0.12143927f, -0.26325694f, 0.05731505f, -0.05234980f, -0.07582791f, 0.13531047f, 
    0.08065213f, 0.07234457f, -0.06917118f, -0.11182897f, 0.12576000f, 0.35780859f, -0.28995663f, -0.09676620f, 
    -0.08747908f, -0.16635297f, -0.07588940f, 0.29934272f, -0.09015495f, -0.03105903f, 0.09705332f, -0.10850482f, 
    0.11392668f, -0.16330643f, 0.02149536f, -0.06931635f, 0.13401765f, -0.13097784f, -0.13373159f, 0.30706936f, 
    0.08922201f, -0.16923766f, 0.05384150f, 0.08783476f, 0.02125564f, -0.16985872f, 0.05652243f, 0.03427856f, 
    0.03166339f, 0.14798519f, 0.15060790f, -0.02362712f, 0.05479141f, -0.07179693f, -0.20190682f, 0.13091968f, 
    -0.16595767f, 0.14248909f, -0.01178135f, 0.01994186f, 0.13055897f, -0.08550512f, -0.22593343f, 0.04044024f, 
    -0.14573982f, -0.06159311f, 0.08283322f, -0.06901754f, -0.14594105f, -0.22606462f, 0.05208600f, 0.01006351f, 
    0.07626831f, -0.02615921f, -0.13301370f, -0.48937926f, -0.02304641f, 0.10969204f, 0.30156076f, -0.03260552f, 
    -0.14773378f, -0.11621484f, 0.15220621f, 0.11285111f, 0.01017100f, 0.00365969f, -0.27752608f, -0.09222781f, 
    0.32530913f, 0.00438561f, -0.10365198f, -0.03208413f, -0.06320013f, 0.13104513f, 0.05827140f, -0.02322089f, 
    -0.36782190f, -0.10804170f, 0.15406060f, -0.25930256f, -0.09288108f, 0.25819385f, -0.15165475f, 0.11834572f, 
    -0.08252595f, -0.10250949f, 0.23062232f, 0.18516521f, 0.08198904f, 0.13344736f, -0.28855440f, -0.17976587f, 
    -0.04589457f, 0.03589780f, 0.07833053f, 0.29288962f, -0.04868046f, -0.00363180f, 0.15669823f, 0.14203483f, 
    -0.01091257f, 0.08122107f, 0.14175799f, -0.19882046f, 0.07290509f, -0.12189265f, 0.24729390f, -0.07069318f, 
    0.52083397f, 0.12898593f, 0.12384155f, -0.23945135f, 0.08204969f, -0.30188388f, -0.09636015f, -0.06302159f, 
    -0.12774794f, -0.11246996f, 0.21977040f, 0.01276204f, 0.04605646f, 0.03529515f, -0.26987290f, -0.00510300f, 
    0.13255800f, -0.00678223f, -0.10571819f, 0.21188363f, 0.01275096f, -0.06015015f, 0.45693111f, -0.04637150f, 
    -0.18760438f, 0.01410847f, -0.12517013f, -0.20173301f, -0.08445688f, 0.08034299f, 0.51125669f, -0.13044691f, 
    -0.24684624f, -0.15934598f, -0.01682730f, 0.10221597f, -0.06567111f, -0.17669453f, 0.16389237f, 0.07609899f, 
    0.05979432f, 0.08871858f, -0.12745042f, 0.25471562f, 0.19098717f, -0.09005524f, 0.06733932f, 0.15143205f, 
    -0.05135616f, 0.09474184f, -0.01880199f, 0.37112197f, -0.15643646f, -0.06792535f, -0.10020103f, 0.15090249f, 
    -0.27565071f, -0.01539378f, 0.05157012f, -0.19372246f, 0.13282694f, 0.13675489f, -0.15480098f, -0.02476686f, 
    -0.04025755f, -0.17160457f, -0.12126702f, 0.11450366f, 0.03902406f, -0.23425008f, -0.11443721f, 0.10564803f, 
    0.27676278f, -0.09817982f, 0.49335706f, 0.60817832f, -0.06762764f, -0.00952062f, -0.14877260f, 0.14460455f, 
    0.17543688f, -0.16473335f, 0.05829136f, 0.21295378f, 0.01378260f, -0.11205775f, 0.34955823f, 0.15084952f, 
    -0.22044300f, 0.14897422f, -0.00380934f, -0.22828318f, 0.09476319f, 0.11425953f, 0.33370936f, 0.13058494f, 
    -0.08444506f, 0.09953999f, -0.02873363f, -0.02672078f, -0.00927535f, 0.18895753f, 0.02535238f, -0.22908373f, 
    0.30034369f, -0.01695693f, 0.20348850f, -0.47479627f, -0.33626270f, -0.11636870f, 0.14692275f, -0.15487891f, 
    -0.15793414f, -0.10559107f, 0.04545382f, 0.12379053f, -0.13806108f, -0.10440873f, 0.01472779f, 0.00165615f, 
    0.08351240f, 0.17141987f, 0.13996769f, 0.17789494f, -0.15611584f, -0.10925738f, -0.09608733f, 0.14927788f, 
    0.34690541f, -0.04869113f, 0.02370071f, 0.20676069f, -0.17412908f, 0.20301522f, 0.02741058f, -0.44404584f, 
    -0.18750653f, 0.06914902f, 0.12809035f, -0.14828232f, -0.14035954f, -0.13535705f, -0.16849765f, -0.07748738f, 
    0.01551388f, -0.10330129f, -0.13783252f, 0.21817084f, -0.00664004f, 0.26664305f, -0.10120320f, 0.08703943f, 
    -0.21713553f, 0.09989993f, -0.06467925f, 0.31275398f, -0.03117122f, 0.02469386f, 0.01049262f, -0.14181387f, 
    0.43412027f, -0.16709724f, 0.15477625f, 0.09015322f, -0.12672223f, -0.43336162f, -0.12979864f, 0.19504683f, 
    0.01399130f, -0.00561119f, -0.09547248f, 0.13805188f, 0.17361723f, 0.12859343f, -0.13357086f, 0.12954958f, 
    -0.09416766f, 0.07086755f, 0.13568623f, 0.01654652f, -0.09690750f, 0.22594629f, 0.36117288f, -0.13592875f, 
    0.12692772f, 0.10844800f, -0.18084887f, 0.06745664f, -0.10350636f, 0.11872226f, -0.33478794f, -0.10428637f, 
    -0.21931326f, 0.15098965f, 0.02759758f, -0.01615931f, -0.09053606f, 0.16881786f, -0.06239634f, -0.22472274f, 
    0.02805858f, -0.01547668f, 0.19640812f, 0.60426879f, 0.04383501f, -0.03905448f, -0.23372085f, 0.01009518f, 
    0.06263962f, -0.01380539f, -0.14378759f, 0.18475901f, -0.07099390f, 0.18882716f, 0.09993650f, 0.14717895f, 
    -0.30577156f, -0.10304388f, 0.08126671f, 0.20018229f, 0.03848929f, -0.07921199f, 0.32966089f, -0.02151666f, 
    -0.05652782f, -0.08990793f, 0.02593820f, 0.13037053f, -0.00448008f, -0.22574262f, 0.16224051f, -0.14067750f, 
    -0.16368541f, -0.12595432f, -0.05876940f, 0.05024582f, -0.09788567f, 0.06945989f, -0.23074876f, 0.12858979f, 
    -0.11146233f, 0.11945295f, 0.11493742f, -0.15195383f, 0.09242228f, -0.02138113f, -0.00142599f, -0.12566510f, 
    -0.14619669f, -0.00153393f, -0.16372940f, -0.05183872f, -0.00925926f, 0.08331690f, 0.08828843f, 0.06680060f, 
    0.04743603f, -0.00659416f, 0.16343564f, 0.04660967f, 0.14083177f, -0.17138086f, 0.03480440f, 0.02693534f, 
    -0.11354011f, 0.03417233f, -0.26066107f, 0.35988265f, 0.31325653f, -0.12476017f, 0.08064982f, -0.14946687f, 
    -0.09621546f, 0.02772802f, 0.02883755f, 0.33873785f, -0.10042717f, -0.01154830f, 0.35458836f, 0.05174313f, 
    0.19610222f, -0.05345078f, -0.12079389f, -0.35062709f, 0.11585454f, 0.12727231f, -0.29038098f, 0.02427759f, 
    -0.32466435f, 0.14557861f, -0.04855293f, -0.06176613f, 0.09054458f, -0.37488690f, -0.01766303f, -0.16866882f, 
    0.06739725f, 0.07351547f, 0.35193759f, -0.27518636f, -0.34658176f, -0.11412542f, -0.13665594f, 0.16483869f, 
    -0.04233118f, 0.05460799f, 0.13585351f, 0.02455598f, -0.14114431f, 0.36163679f, -0.19263092f, 0.09567424f, 
    -0.11239882f, 0.00522379f, -0.13594942f, 0.34591857f, -0.12879397f, 0.00546297f, 0.07498774f, 0.14260089f, 
    0.23644333f, 0.10041203f, 0.01378399f, 0.39364016f, -0.09694791f, 0.25045037f, -0.08963691f, -0.23913279f, 
    -0.07181840f, -0.10707400f, -0.15389206f, -0.08246035f, -0.00934826f, -0.00340757f, -0.05728954f, 0.15248021f, 
    0.14095458f, 0.15924039f, -0.13149518f, -0.01480454f, -0.14017384f, -0.09889671f, -0.16564497f, -0.01555261f, 
    -0.10026421f, -0.10560190f, 0.11237939f, -0.15948123f, 0.02345314f, -0.10921382f, -0.08442581f, 0.02621117f, 
    0.01872787f, 0.03663509f, 0.15501796f, -0.02525951f, 0.08501822f, 0.04098191f, -0.05004198f, -0.12667091f, 
    -0.26991183f, -0.12433060f, 0.35857141f, -0.09170890f, -0.31930298f, -0.04579219f, -0.25051901f, 0.06641506f, 
    0.06205111f, -0.16767533f, -0.05053562f, -0.07835892f, 0.08584125f, 0.21683708f, -0.00776376f, -0.16044141f, 
    0.04586135f, -0.08615068f, -0.12344276f, 0.21860699f, 0.06494977f, -0.00408198f, 0.20112167f, -0.02800633f, 
    0.25656068f, 0.14018117f, -0.13914891f, 0.11055539f, 0.07701086f, -0.32889971f, 0.16805589f, 0.26523864f, 
    0.03141925f, 0.08299309f, -0.48738369f, 0.17914289f, -0.13911599f, -0.16646901f, 0.32982263f, -0.15280227f, 
    -0.17761238f, 0.06266900f, 0.06534064f, -0.05229035f, 0.10108203f, -0.07627408f, -0.20166755f, -0.03866567f, 
    -0.20797674f, 0.04862044f, -0.10487212f, 0.09082355f, 0.16296820f, 0.05603699f, -0.04659236f, 0.14071418f, 
    0.33628532f, -0.06313047f, -0.06588521f, 0.38586608f, -0.16107379f, 0.06378242f, -0.06332145f, 0.36084056f, 
    0.36690953f, -0.10985234f, -0.05531463f, 0.04765958f, 0.22236300f, -0.00561365f, -0.03360969f, 0.09636610f, 
    -0.12678578f, 0.07487844f, 0.05353158f, 0.37704504f, 0.01960801f, 0.05931551f, -0.19415453f, -0.07287325f, 
    -0.29201674f, -0.03194339f, -0.10495690f, 0.34877169f, 0.08954576f, -0.07513611f, 0.10871906f, -0.15875079f, 
    0.01204408f, -0.11829421f, -0.06571195f, -0.16771725f, 0.00112673f, -0.36782670f, 0.07509086f, 0.06282112f, 
    -0.56110144f, -0.17224738f, 0.06736135f, 0.18791915f, 0.06715180f, 0.07770409f, -0.30779672f, -0.05718447f, 
    0.01099074f, -0.07573809f, -0.12103254f, -0.02377686f, -0.00200150f, 0.06861521f, 0.29169086f, 0.01617635f, 
    0.15674555f, 0.00056706f, -0.06529050f, 0.01318760f, -0.15904799f, 0.15741409f, 0.42665443f, -0.07851229f, 
    -0.11920293f, 0.14011528f, -0.05123096f, -0.11439636f, -0.15842018f, -0.01807466f, 0.12094421f, 0.09097914f, 
    0.16322784f, 0.05873458f, -0.34680486f, -0.14527556f, 0.21206164f, -0.17130448f, 0.30740973f, 0.08495121f, 
    -0.01887861f, -0.13357626f, -0.06853826f, 0.14385156f, 0.06542905f, -0.11805143f, 0.33016774f, 0.05068072f, 
    0.27019930f, -0.14541245f, -0.02685567f, -0.15826422f, -0.06717990f, 0.05238536f, -0.03677816f, -0.01639580f, 
    -0.18451340f, -0.05934766f, -0.06362192f, -0.23217636f, -0.02369116f, 0.22768098f, -0.05855254f, -0.30379713f, 
    0.46982184f, -0.08113484f, -0.26755175f, -0.08979436f, 0.08626071f, -0.01656440f, 0.36268005f, -0.14840910f, 
    0.09039289f, -0.15754391f, 0.17714249f, 0.21507077f, -0.09833247f, 0.03814657f, -0.28903720f, 0.14967482f, 
    0.01899479f, -0.11388173f, 0.07042266f, -0.03331172f, 0.11859441f, 0.01673830f, -0.32603157f, -0.17524289f, 
    -0.18593130f, -0.12276775f, 0.02508410f, -0.08207936f, -0.14400050f, 0.50196302f, -0.01682608f, -0.12145735f, 
    -0.24104688f, 0.05290688f, 0.14093454f, 0.11686015f, -0.06785479f, 0.07520475f, -0.24598426f, 0.03873839f, 
    0.07405896f, -0.02771668f, -0.05571355f, 0.32713732f, 0.04075492f, 0.25323281f, -0.09741841f, 0.04429031f, 
    0.31066757f, -0.16660032f, -0.10397228f, -0.02674198f, -0.00291672f, -0.02419417f, -0.23436220f, -0.05100890f, 
    0.23146039f, 0.12364975f, -0.04378080f, -0.21747079f, -0.05631559f, -0.06694911f, -0.04314436f, 0.12863643f, 
    -0.01049256f, -0.08342613f, -0.17378385f, 0.02702942f, 0.02493262f, 0.15753742f, -0.12712742f, -0.10824548f, 
    -0.03499289f, -0.12715234f, 0.08943989f, -0.20798278f, 0.10381696f, -0.02737885f, -0.10323459f, 0.17585103f, 
    0.03553792f, -0.13300191f, 0.07485080f, -0.11747893f, -0.11719758f, -0.09821039f, 0.02602649f, -0.10922196f, 
    0.01756728f, -0.10354359f, 0.12903729f, 0.02554488f, -0.15147109f, -0.20434874f, -0.03300228f, -0.20718293f, 
    -0.37085995f, -0.14830531f, 0.23928870f, -0.52243322f, -0.08176994f, 0.13093729f, -0.11264439f, 0.08475671f, 
    0.03176491f, 0.10763744f, -0.08917729f, 0.21617526f, 0.14289272f, 0.28171086f, 0.07040801f, 0.07277443f, 
    0.37462419f, -0.01441259f, 0.04219911f, -0.25839171f, 0.04723947f, -0.06630242f, 0.31599277f, 0.16944854f, 
    0.16294605f, -0.17335910f, 0.08028442f, 0.12823199f, 0.07434615f, -0.23935948f, 0.02123809f, -0.04383164f, 
    0.15896209f, -0.07251734f, -0.30435535f, -0.48012626f, 0.08077444f, -0.08621714f, 0.26008958f, 0.13237868f, 
    -0.14386579f, -0.17355800f, -0.09460789f, -0.04726572f, 0.04115791f, 0.13242151f, 0.26345143f, 0.04484494f, 
    0.37919739f, -0.03205110f, -0.16348067f, -0.31230623f, 0.04852731f, -0.06289458f, -0.11012533f, 0.10940972f, 
    -0.23546372f, 0.02712348f, -0.00374700f, -0.06861885f, -0.07168831f, 0.20140962f, -0.11485033f, 0.03984308f, 
    -0.09293645f, 0.14899449f, -0.22561818f, -0.40724853f, -0.19728313f, 0.10178692f, -0.02645678f, -0.03688688f, 
    -0.08434805f, -0.14907876f, 0.15604527f, 0.20678756f, -0.00403907f, 0.28206268f, -0.35551909f, -0.08580048f, 
    0.33527300f, 0.06071234f, -0.02040216f, -0.12896721f, -0.07341404f, -0.14347617f, 0.21638155f, 0.04211772f, 
    -0.20612666f, 0.08333556f, 0.09452400f, -0.04995614f, -0.08047088f, -0.02139294f, 0.12559222f, 0.33674988f, 
    0.04038604f, 0.14191791f, -0.13645352f, -0.45661694f, -0.04781583f, -0.00580699f, 0.38436761f, 0.11103293f, 
    0.01312279f, 0.14880487f, 0.00802358f, -0.11859937f, -0.08011224f, -0.17841573f, -0.09359166f, -0.03408065f, 
    0.12371662f, 0.04581499f, 0.13651745f, -0.11430165f, -0.07160655f, -0.01748200f, 0.16630495f, -0.16848889f, 
    -0.21960157f, -0.01923629f, 0.14934064f, 0.20441063f, -0.09054135f, 0.10146407f, -0.00064149f, 0.06303694f, 
    0.16134648f, -0.02896085f, 0.14819008f, -0.23080063f, -0.05754241f, -0.07774023f, 0.16225353f, 0.17956600f, 
    0.05724086f, 0.10870083f, 0.09625936f, -0.28115994f, 0.04374546f, 0.21011958f, -0.32955745f, -0.04477802f, 
    -0.03924764f, 0.08665152f, -0.09437367f, 0.23273119f, -0.00752298f, 0.09165408f, 0.28497875f, -0.12334793f, 
    -0.20056212f, 0.08310235f, 0.01675192f, 0.27431706f, 0.14123048f, 0.08931361f, 0.09928260f, 0.12623361f, 
    0.10997921f, -0.14151590f, -0.20419388f, -0.05367709f, -0.08674546f, -0.06063905f, -0.07145558f, 0.11049266f, 
    0.00663303f, -0.08209140f, -0.15928821f, -0.13788600f, 0.10067698f, -0.10836449f, -0.18720478f, 0.13581306f, 
    0.04906834f, 0.00732382f, 0.15899801f, -0.07482894f, -0.11120678f, 0.04363524f, -0.15461572f, -0.17205580f, 
    -0.09868133f, 0.16790982f, -0.10000297f, 0.00179215f, -0.03724235f, -0.12579611f, -0.09747072f, -0.05191658f, 
    0.01371470f, -0.14696401f, 0.02117473f, 0.01542065f, 0.15527616f, -0.10842089f, -0.01944926f, 0.11847852f, 
    -0.04205682f, -0.14987499f, -0.11312962f, 0.10784511f, 0.11193337f, -0.09376852f, -0.06850734f, 0.09328429f, 
    -0.00615691f, 0.05862580f, -0.02364093f, -0.21611321f, -0.02950931f, -0.00251292f, 0.02797270f, 0.14713298f, 
    -0.08609164f, 0.16971147f, -0.06130402f, -0.09753473f, -0.01058923f, -0.06944066f, -0.02389355f, -0.18199398f, 
    -0.30209097f, -0.01423356f, 0.00466282f, -0.28516847f, -0.29170114f, 0.08451679f, 0.01490085f, -0.10916892f, 
    0.16050722f, -0.16970292f, -0.15614417f, 0.19234285f, -0.07374101f, 0.20755972f, -0.30679265f, -0.09542869f, 
    0.32251328f, 0.15994297f, -0.17570798f, 0.13223377f, 0.02052047f, 0.14973374f, 0.23042208f, 0.15196669f, 
    0.14785552f, 0.01098310f, -0.08222844f, 0.14468403f, -0.01348764f, -0.00503155f, 0.05161939f, -0.28113040f, 
    -0.17656158f, -0.09360746f, -0.04096394f, 0.05200065f, 0.04384248f, 0.04086152f, -0.20306917f, -0.08085609f, 
    0.05404855f, 0.16167061f, -0.02858271f, 0.04700830f, -0.12538210f, -0.18686086f, -0.05211027f, -0.03298442f, 
    -0.03136772f, 0.16726577f, -0.17131934f, -0.07069840f, -0.17657293f, 0.12953764f, -0.07838346f, -0.06183227f, 
    -0.16043283f, 0.05402143f, 0.01259489f, -0.10309470f, 0.00732091f, 0.02760988f, -0.02695849f, -0.21537466f, 
    -0.07019351f, -0.08862032f, -0.14343902f, -0.02227300f, 0.02465272f, -0.00320021f, -0.07601249f, -0.15758519f, 
    -0.11120106f, -0.02081741f, 0.11643346f, 0.04282859f, 0.06592260f, -0.17738438f, -0.17409694f, -0.06608309f, 
    -0.19924168f, 0.14235045f, -0.09477802f, 0.08925697f, 0.15474363f, 0.04806523f, -0.09241197f, -0.00479098f, 
    0.12596624f, 0.06205622f, 0.05971129f, -0.08020837f, 0.05618605f, -0.01593677f, 0.03522524f, -0.10442136f, 
    0.33271125f, -0.05097467f, -0.26926458f, -0.30074278f, 0.18460129f, 0.13773568f, -0.53726560f, 0.14935823f, 
    0.00542200f, -0.13007367f, 0.08723975f, -0.09938329f, -0.08319111f, -0.10933169f, -0.25032511f, -0.14570580f, 
    0.12213971f, 0.10082418f, 0.03631398f, 0.30817860f, 0.11200619f, 0.18307404f, -0.11988524f, -0.13463189f, 
    -0.39854279f, -0.06343414f, 0.15312560f, -0.43117872f, 0.07912832f, 0.26930726f, 0.16661946f, 0.32595253f, 
    0.40725946f, -0.11297221f, 0.20726386f, 0.29866034f, 0.27894890f, 0.04382315f, -0.18898308f, 0.03369868f, 
    0.05313139f, 0.06143215f, -0.09049324f, 0.03659397f, -0.07803212f, 0.05589212f, 0.02959836f, 0.06271417f, 
    -0.26905459f, -0.11065368f, 0.06353062f, 0.10572448f, 0.16179417f, -0.16020185f, -0.25659296f, 0.17428800f, 
    0.10141905f, -0.14599757f, -0.15917510f, 0.22592375f, -0.00479959f, 0.30221039f, -0.08348033f, -0.16552477f, 
    -0.13458081f, -0.06831814f, -0.33036920f, -0.15401593f, 0.17394938f, 0.02372534f, -0.05895876f, 0.01983450f, 
    -0.03899848f, -0.05124438f, 0.15727480f, 0.23913936f, 0.06818733f, 0.16851586f, 0.04937613f, 0.02429119f, 
    0.41201171f, 0.04377388f, -0.01968364f, -0.35274851f, -0.06459824f, 0.11547214f, -0.18481889f, -0.01364945f, 
    -0.02797386f, -0.18286863f, 0.09180460f, -0.34646669f, 0.08574820f, 0.22787926f, 0.03297917f, 0.28442496f, 
    -0.04034794f, 0.01909132f, -0.10128625f, -0.08675274f, 0.05192525f, -0.08896749f, -0.04654392f, 0.12379528f, 
    0.11127651f, -0.01103687f, -0.17393431f, 0.00855429f, -0.13752951f, -0.10700752f, -0.02276804f, 0.16242617f, 
    -0.00594268f, 0.00836099f, -0.13183774f, -0.15742753f, 0.06841976f, -0.16866288f, -0.02288928f, 0.06511686f, 
    0.10882328f, 0.01591840f, -0.05604117f, -0.08540028f, 0.00568652f, -0.06273139f, -0.05493852f, -0.10117365f, 
    -0.12847820f, 0.01185390f, 0.11621993f, -0.30282694f, -0.13515893f, 0.02309399f, 0.17985986f, -0.02496524f, 
    -0.12604602f, 0.09539302f, 0.02632580f, 0.13927253f, 0.01339517f, 0.17766672f, -0.16173247f, 0.02327170f, 
    0.02145543f, -0.15012248f, -0.15309778f, -0.30834877f, -0.02967610f, -0.00642467f, 0.12412986f, 0.15584010f, 
    0.31720704f, -0.05858262f, -0.11766543f, 0.23822927f, 0.15146296f, 0.38893953f, -0.00901252f, 0.09932166f, 
    0.10881773f, 0.11438018f, 0.22436425f, -0.35621083f, -0.18875453f, 0.00616711f, 0.24152534f, 0.15902422f, 
    -0.16303316f, 0.16639805f, -0.09232192f, -0.04661867f, 0.08630155f, 0.34661689f, -0.03896127f, 0.15154196f, 
    -0.09722623f, -0.04419527f, 0.07199862f, -0.00596282f, -0.14060463f, 0.06128987f, -0.12333288f, -0.10781360f, 
    -0.11507782f, -0.11983331f, -0.09855767f, 0.19334143f, -0.02398920f, -0.23345666f, -0.05127397f, 0.22324575f, 
    0.23132858f, -0.03618933f, -0.41967469f, -0.10602580f, 0.11225354f, -0.06235756f, 0.12487430f, -0.05805294f, 
    -0.03317448f, 0.02419551f, 0.14906475f, -0.02627785f, 0.17094190f, -0.12890540f, -0.35875449f, -0.12746310f, 
    0.23142508f, 0.06669132f, 0.15222695f, 0.18534979f, -0.05987461f, -0.05327541f, -0.01884010f, 0.05142259f, 
    -0.29172626f, 0.13363270f, 0.11452211f, -0.10063552f, 0.12894253f, -0.22406635f, 0.10358998f, -0.00303647f, 
    -0.10452037f, -0.06259336f, -0.03518373f, 0.09933946f, -0.12188071f, -0.02822610f, -0.01996611f, -0.15022245f, 
    0.15561789f, 0.06373048f, 0.05187643f, -0.02214833f, -0.01419866f, -0.11022571f, 0.04734005f, -0.00566106f, 
    -0.09115787f, 0.16521534f, 0.14453155f, -0.10755939f, -0.01919502f, 0.06051546f, -0.00839074f, -0.05899969f, 
    -0.13464215f, -0.16411962f, -0.15286829f, -0.09903722f, 0.03118053f, 0.07456172f, -0.10927626f, -0.08779635f, 
    -0.11107608f, 0.05512279f, -0.07573375f, -0.14425851f, 0.04653976f, -0.14467955f, -0.18088208f, 0.11420001f, 
    -0.05071378f, 0.10693592f, -0.11833623f, -0.17079170f, 0.14932933f, -0.15634409f, -0.06950545f, 0.04860247f, 
    -0.14459112f, -0.01352676f, 0.01410402f, 0.12082447f, 0.10963878f, 0.06274491f, 0.09931137f, -0.11796047f, 
    -0.03434788f, -0.01847959f, -0.16607851f, -0.02341898f, -0.11321747f, -0.14544514f, 0.12817882f, -0.01425489f, 
    0.17661583f, -0.12341940f, 0.27951792f, -0.27456859f, -0.05550408f, 0.12441543f, -0.41026413f, 0.07349167f, 
    0.01489476f, -0.08230737f, -0.06368461f, -0.20812117f, 0.03953905f, -0.04812035f, -0.35663515f, -0.07110449f, 
    0.27293086f, -0.07923656f, -0.16767719f, -0.12533048f, -0.02089967f, 0.14148216f, 0.08014444f, 0.03983863f, 
    -0.00704234f, -0.03542388f, 0.14664716f, -0.05382010f, -0.13434809f, -0.18106858f, -0.03843421f, 0.24389565f, 
    -0.14728886f, 0.07911196f, 0.14102654f, 0.26770377f, -0.00168486f, 0.12565494f, -0.17308584f, 0.01443661f, 
    0.16882275f, -0.08122940f, -0.00649585f, 0.14275116f, 0.02068847f, 0.31413451f, -0.42134741f, -0.12451886f, 
    0.19190958f, -0.08354036f, 0.09922045f, -0.04248343f, 0.07525919f, -0.06660821f, 0.17365223f, 0.06352440f, 
    -0.06714546f, -0.08779773f, 0.11845126f, -0.15153721f, -0.18142895f, -0.06113126f, -0.15888871f, 0.08669373f, 
    0.35021240f, 0.15660018f, 0.46869412f, -0.20469160f, -0.00933195f, 0.04845668f, 0.00553649f, -0.10036454f, 
    0.04813765f, 0.02741959f, 0.07204007f, -0.10951462f, 0.12533529f, 0.06301094f, 0.00742098f, 0.09520014f, 
    -0.34734380f, -0.09741110f, -0.10640806f, 0.06308206f, -0.07367951f, -0.16649951f, -0.00803690f, 0.07270936f, 
    -0.00329868f, 0.06469126f, -0.10683931f, 0.43165970f, -0.17177060f, 0.03554550f, 0.07976530f, -0.03479236f, 
    -0.36995485f, 0.08375873f, 0.31797078f, -0.39691690f, -0.58028966f, -0.06055435f, 0.26723999f, -0.15917058f, 
    -0.17373794f, 0.07043606f, -0.06533876f, 0.27852306f, -0.09051625f, 0.20678404f, -0.09875336f, 0.11224271f, 
    0.41548297f, 0.17434116f, 0.17185238f, -0.18112545f, -0.10744298f, -0.08018950f, -0.06468412f, 0.10057146f, 
    0.00214300f, 0.06438588f, -0.00426785f, -0.08631335f, -0.01309052f, -0.19179574f, 0.00507606f, 0.27165365f, 
    -0.13408220f, -0.06419234f, -0.18349136f, -0.29478884f, -0.16820019f, -0.12147042f, 0.20649830f, -0.08830831f, 
    0.02714581f, -0.16421418f, -0.04621403f, 0.25123996f, 0.17453842f, 0.14419428f, -0.02306153f, -0.18102528f, 
    0.38138670f, 0.16890515f, 0.08647045f, -0.23166259f, -0.12376047f, 0.15257660f, -0.01523253f, 0.14137399f, 
    -0.29897723f, 0.11632317f, 0.15722121f, 0.04159930f, -0.05791195f, 0.41236329f, 0.17534254f, 0.23080119f, 
    0.30053914f, 0.11030876f, -0.10032848f, 0.33052382f, 0.19193363f, 0.02330086f, 0.26387760f, -0.03491372f, 
    -0.09499581f, -0.00329103f, -0.01259534f, -0.06742223f, 0.09436063f, -0.19390367f, 0.14951967f, 0.10723529f, 
    -0.03549790f, -0.04453646f, -0.07835153f, 0.11218891f, 0.04652705f, -0.06235018f, 0.08605497f, -0.05608436f, 
    -0.37499553f, -0.16053528f, 0.07228179f, -0.14391549f, 0.15074736f, 0.11946877f, 0.09301282f, -0.16514963f, 
    0.01072087f, 0.05781839f, -0.18449287f, -0.16773234f, -0.11610486f, -0.17674813f, -0.17671043f, -0.09642518f, 
    -0.06519628f, -0.00436090f, 0.10085108f, 0.02418614f, 0.15232132f, -0.03870253f, 0.04855433f, -0.07322811f, 
    0.07580167f, -0.10345881f, 0.02919068f, -0.00702890f, 0.12530252f, -0.04851310f, -0.19930525f, -0.04294261f, 
    0.11322456f, 0.02837272f, -0.06044362f, -0.20876428f, -0.06993797f, 0.07699121f, 0.07567163f, -0.09016231f, 
    0.39601457f, -0.12837715f, -0.34838498f, -0.18394737f, 0.03607073f, 0.05325470f, 0.28981817f, -0.13099386f, 
    0.09340590f, -0.16413799f, 0.16977924f, 0.20064642f, -0.09400024f, -0.05737665f, 0.42147917f, -0.03811270f, 
    -0.08109760f, 0.02217183f, 0.02238135f, -0.07084537f, 0.11870146f, -0.16290210f, 0.02096030f, -0.06823079f, 
    -0.37035489f, 0.08434733f, -0.04207568f, 0.04610978f, -0.07752676f, -0.11742464f, -0.17678437f, -0.03431006f, 
    -0.08383311f, -0.15716127f, 0.01260428f, 0.17060058f, -0.12166696f, -0.10454730f, 0.18243684f, -0.08316783f, 
    0.09116748f, -0.09910136f, -0.11452892f, 0.34543714f, 0.05609583f, -0.10876396f, 0.05667576f, 0.05901683f, 
    0.37090048f, 0.13018824f, 0.02010674f, -0.20201527f, -0.05101897f, 0.07380961f, 0.02486441f, -0.07541282f, 
    0.09420957f, -0.08353002f, 0.04280554f, -0.13232566f, -0.05930045f, 0.09765155f, -0.01452892f, 0.21007390f, 
    0.11140171f, -0.14874978f, 0.10849711f, -0.29546189f, 0.09612869f, -0.15662287f, 0.07765493f, -0.15656921f, 
    -0.17538270f, -0.10300717f, 0.13996704f, -0.16656759f, -0.15806593f, -0.26507837f, 0.13762240f, -0.15903652f, 
    0.15729916f, -0.08997260f, -0.08403476f, 0.06173645f, -0.02418000f, 0.00171531f, 0.02475489f, 0.15572070f, 
    0.23328520f, 0.05192249f, 0.16862233f, 0.17190479f, -0.08365291f, 0.11009865f, -0.17949243f, -0.28872445f, 
    -0.03350851f, 0.08290148f, -0.12444907f, 0.08724653f, -0.06839463f, -0.15406132f, -0.13366723f, -0.06436719f, 
    -0.02935185f, -0.02537542f, 0.07544372f, 0.03309557f, 0.03729140f, -0.05090782f, -0.13282345f, -0.00487369f, 
    -0.17773786f, -0.06353690f, -0.09622820f, -0.20076911f, 0.07179479f, -0.04077402f, -0.12007351f, 0.01017505f, 
    -0.01763530f, 0.04229718f, -0.16715711f, -0.11038587f, 0.13858162f, -0.05043968f, -0.13116385f, -0.05174786f, 
    0.28984824f, -0.10176881f, 0.14180088f, -0.20130037f, -0.12308417f, -0.15567352f, -0.06907258f, -0.16404966f, 
    0.02947645f, 0.01042114f, -0.13775489f, -0.17388351f, 0.15969062f, 0.08060850f, 0.14864069f, -0.00474473f, 
    -0.29909471f, -0.09863391f, -0.05509083f, 0.17476253f, -0.02255401f, 0.00911578f, 0.43409193f, 0.05152368f, 
    -0.00314414f, -0.04211936f, 0.17141546f, 0.49032354f, -0.06688068f, 0.04575349f, 0.17334911f, 0.01690451f, 
    0.28825355f, -0.13736080f, 0.13549984f, -0.22369821f, -0.26378977f, -0.17746963f, 0.19745499f, -0.12500121f, 
    0.05869757f, 0.11108378f, -0.16106585f, 0.13261902f, 0.18532977f, 0.29484352f, 0.00255747f, 0.17237161f, 
    -0.11628488f, -0.02389240f, 0.06213120f, 0.18415606f, -0.08048737f, 0.10320916f, 0.30816409f, 0.06451298f, 
    -0.23778230f, 0.04454654f, -0.03951326f, 0.11551934f, -0.00752564f, -0.00226460f, -0.12221979f, 0.13329719f, 
    0.12811202f, -0.12546830f, 0.11920264f, 0.23342420f, 0.02675846f, 0.15119794f, 0.15888065f, 0.15981559f, 
    0.11060781f, -0.01300439f, 0.03592239f, -0.17231825f, -0.10754769f, -0.06238091f, 0.15230781f, 0.16560771f, 
    -0.09863514f, 0.09292055f, -0.15541354f, -0.34641227f, 0.00597865f, 0.16882329f, -0.05130920f, 0.10271156f, 
    -0.03214248f, -0.10819014f, 0.04681014f, 0.11409002f, -0.04998992f, 0.35453087f, -0.10423884f, -0.13128589f, 
    -0.22305390f, -0.04487778f, -0.08454739f, -0.09884888f, 0.40082958f, -0.06301957f, 0.08886812f, 0.09499755f, 
    0.14334235f, 0.13209900f, -0.09447698f, -0.14088324f, -0.00958423f, 0.32246494f, 0.06442066f, 0.12100762f, 
    -0.08377914f, 0.07656737f, -0.15260500f, -0.20322941f, -0.06921405f, 0.03403921f, -0.42780662f, -0.15211502f, 
    0.07660143f, 0.02391143f, 0.14878257f, 0.18321693f, -0.01985499f, 0.27937117f, 0.00232906f, -0.22567831f, 
    0.21817629f, 0.14503506f, -0.04615393f, 0.24811319f, 0.33294404f, -0.09118194f, 0.07241563f, -0.02391241f, 
    -0.02705780f, 0.15702175f, 0.06405532f, -0.33817065f, -0.04142193f, -0.04028850f, 0.12930577f, -0.15653799f, 
    -0.18019740f, -0.08370876f, -0.06488045f, 0.25854272f, 0.03468071f, 0.10566005f, 0.12329081f, -0.01426735f, 
    0.37550673f, 0.17978764f, 0.05487058f, -0.04412904f, -0.00482847f, -0.03975609f, 0.06609140f, -0.05488523f, 
    0.16966385f, -0.07342545f, 0.15316172f, 0.05459145f, 0.25289658f, -0.02447846f, 0.06921481f, -0.04236331f, 
    -0.10042665f, -0.04776766f, -0.12545897f, -0.08807648f, -0.10932793f, 0.16571791f, 0.05973762f, 0.11331633f, 
    -0.25842619f, 0.08666506f, 0.17623563f, -0.05119920f, -0.10330470f, 0.14568329f, 0.32459104f, -0.07580084f, 
    -0.37371272f, 0.02600935f, 0.01627667f, 0.05015021f, 0.06337193f, -0.29478455f, 0.12307598f, 0.07593776f, 
    0.28285810f, 0.09089783f, -0.46736252f, 0.14530414f, -0.05594089f, 0.00319595f, -0.29220346f, -0.15175073f, 
    -0.09319414f, -0.10119815f, 0.04540977f, 0.21513030f, -0.07505523f, 0.05981964f, -0.02798925f, 0.16281332f, 
    0.04855797f, 0.09728163f, -0.11359943f, 0.52601308f, -0.08033074f, 0.05085785f, -0.02025912f, 0.14699875f, 
    -0.39852151f, -0.17217956f, 0.04692976f, -0.27407905f, -0.13377275f, -0.09632640f, -0.17132623f, 0.16883220f, 
    -0.09313735f, -0.06204659f, 0.44123730f, -0.00285149f, -0.36998335f, 0.03987449f, -0.26428339f, 0.16097239f, 
    -0.10144325f, 0.12292302f, 0.09259152f, 0.10906462f, 0.03890525f, 0.29225153f, -0.40831122f, 0.12751706f, 
    -0.09978310f, -0.13073002f, 0.07848459f, 0.35036603f, -0.16633572f, 0.12360397f, 0.31205425f, 0.01881739f, 
    0.35711271f, 0.08572327f, -0.09145379f, 0.11255948f, -0.09396155f, 0.17602411f, 0.00009789f, -0.21666862f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00989613f, -0.10855921f, -0.04742334f, 0.10293665f, -0.18826738f, 0.12185871f, 0.24097463f, 0.25641915f, 
    -0.15130761f, 0.15882620f, 0.07829131f, 0.09994812f, -0.03225101f, 0.17853132f, 0.12264211f, 0.06344473f, 
    0.37563702f, -0.10285452f, -0.16474561f, -0.09569428f, -0.14868760f, 0.01998827f, 0.23336601f, -0.11101745f, 
    -0.13633274f, -0.02784641f, 0.15024780f, -0.04968392f, 0.18950368f, 0.20346658f, -0.25188291f, 0.03140576f, 
    0.17284527f, 0.20249873f, 0.04636338f, 0.13635376f, 0.08682004f, 0.16758959f, -0.13609725f, 0.24133450f, 
    0.00155218f, 0.05721270f, 0.01289367f, -0.11268662f, 0.09252674f, 0.05557555f, 0.04819313f, -0.02730439f, 
    0.15386610f, -0.09930805f, 0.11621414f, 0.02165585f, 0.19657262f, -0.08623968f, 0.15182813f, 0.14182225f, 
    0.05268981f, -0.08183952f, -0.06627702f, -0.03195420f, -0.09188656f, 0.32107419f, 0.05094358f, 0.37748411f, 
    0.05959397f, 0.23826133f, 0.18425426f, 0.01264702f, -0.10089698f, 0.10554221f, 0.28111818f, 0.25538889f, 
    0.25586998f, 0.27245873f, -0.04081696f, -0.06511272f, 0.09439537f, -0.04212403f, -0.13283801f, 0.10040372f, 
    -0.06887291f, -0.00388073f, 0.05959563f, -0.31192857f, 0.30819464f, -0.01318611f, 0.15219563f, 0.12061457f, 
    0.06216668f, -0.19514537f, -0.14984711f, 0.22178620f, 0.03424946f, 0.14479220f, -0.07420818f, 0.06081856f, 
    0.13873713f, -0.19111535f, -0.17874007f, 0.03430384f, 0.08463669f, 0.06395969f, 0.28228414f, -0.03414390f, 
    0.14076258f, 0.07741753f, -0.09766902f, 0.06944353f, 0.11646476f, 0.01174567f, 0.05029540f, -0.16279764f, 
    0.13553816f, 0.40230310f, 0.06472567f, -0.02186401f, -0.03287720f, 0.47391674f, 0.00074550f, -0.03610982f, 
    0.15147264f, 0.21331790f, 0.06617475f, 0.05250359f, -0.04766671f, 0.18116224f, -0.26015803f, -0.08676996f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.07339489f, -0.04763775f, 0.17457071f, -0.39990678f, -0.04853582f, -0.03438066f, -0.10384346f, -0.30078253f, 
    0.17818326f, 0.03379668f, 0.07748844f, 0.05462925f, -0.53355855f, 0.12406674f, -0.05766929f, -0.00511262f, 
    -0.17080367f, 0.00107270f, -0.11979581f, 0.14571336f, 0.01426983f, -0.06656714f, -0.48553950f, 0.47509786f, 
    0.14870322f, -0.30363461f, -0.06923085f, -0.09998852f, 0.05740897f, -0.19886863f, -0.31805661f, 0.00255708f, 
    -0.20481561f, -0.00474220f, -0.29171598f, -0.00525900f, 0.15066037f, 0.09387419f, -0.03942394f, -0.14506866f, 
    -0.11415149f, -0.22341397f, 0.24494171f, 0.10745276f, 0.01190452f, -0.02163568f, 0.24535888f, 0.14280561f, 
    -0.21188013f, -0.44792363f, -0.03352020f, 0.31319660f, -0.23333789f, 0.77345228f, -0.25076348f, 0.11602337f, 
    -0.13070913f, 0.03485630f, -0.22736143f, -0.46199888f, -0.14655022f, -0.14164920f, 0.03392294f, 0.22571094f, 
    -0.62783319f, -0.46157208f, -0.25108021f, 0.02087713f, 0.01696518f, -0.01120470f, 0.21367176f, 0.24141400f, 
    0.21823625f, 0.01042446f, 0.13787736f, 0.33560762f, 0.01508548f, 0.19998716f, 0.05676919f, 0.21127829f, 
    0.11489654f, -0.02688617f, 0.12023721f, -0.17845757f, 0.37112513f, 0.12217318f, 0.05926925f, -0.03078686f, 
    0.17590784f, -0.04763728f, 0.17181528f, -0.12591752f, 0.19765218f, -0.21087191f, -0.21233740f, -0.00014250f, 
    -0.07794940f, 0.43557709f, 0.01761422f, -0.04214394f, -0.37763983f, -0.10694307f, 0.10650185f, 0.05905532f, 
    -0.05308099f, -0.10822425f, -0.06069574f, -0.06459999f, -0.05368419f, -0.06861402f, 0.18531093f, -0.24111885f, 
    -0.08149133f, 0.04762288f, -0.21375626f, 0.07461535f, 0.11361315f, 0.05009388f, -0.32225570f, 0.00705894f, 
    -0.10121681f, 0.03847590f, -0.26989558f, 0.03265942f, -0.35202071f, -0.05712675f, 0.25246045f, 0.29236504f, 
    -0.05601402f, -0.06635914f, 0.20580472f, 0.03062630f, -0.58634913f, -0.08010896f, 0.15247495f, 0.04582037f, 
    -0.29248437f, 0.04513389f, 0.14226386f, 0.17848600f, 0.14760751f, -0.06607185f, 0.13862544f, -0.06226744f, 
    0.14099146f, -0.23998794f, 0.02128637f, -0.27264151f, -0.01207135f, 0.07031465f, 0.04973875f, -0.17215011f, 
    0.04491514f, 0.00475116f, 0.29272759f, 0.16723090f, 0.28674614f, -0.22934276f, -0.22470696f, -0.14460823f, 
    -0.10763015f, 0.21258821f, -0.20129330f, 0.01054437f, -0.08925348f, 0.13492413f, -0.03327179f, -0.15096240f, 
    -0.08589138f, -0.10436644f, 0.09035399f, 0.00436796f, -0.09125727f, 0.07097906f, 0.15343519f, 0.16698097f, 
    0.01582943f, 0.05942074f, -0.01925284f, 0.07319079f, 0.03683076f, -0.46466976f, -0.34281045f, 0.20720993f, 
    -0.23680390f, 0.06606272f, -0.02002949f, -0.48342523f, -0.00056383f, -0.39372659f, 0.20102698f, 0.05164921f, 
    -0.23367134f, 0.00559156f, -0.18170874f, -0.30013433f, 0.03387535f, 0.03769947f, 0.00195967f, 0.06492494f, 
    0.08227687f, 0.23952964f, -0.35075825f, -0.44497383f, 0.08502141f, 0.01189918f, -0.06868591f, 0.28850716f, 
    -0.58683360f, 0.06754817f, -0.32468814f, -0.36248681f, 0.04824292f, 0.04263905f, 0.22398008f, 0.11800528f, 
    -0.02921156f, -0.02906802f, -0.12864499f, 0.03884987f, -0.05803689f, 0.07796102f, -0.14431603f, -0.11373406f, 
    0.14051946f, -0.41352552f, -0.03410798f, -0.04343082f, 0.24398333f, -0.08700711f, 0.00194544f, -0.05318029f, 
    -0.11676077f, -0.19800015f, 0.10214268f, -0.08958265f, 0.04221121f, -0.52238077f, 0.04464655f, -0.23939091f, 
    0.07227737f, 0.10706791f, 0.27783719f, -0.01698551f, 0.17824113f, 0.15086187f, -0.28972748f, -0.02835769f, 
    -0.17863242f, 0.01724816f, 0.05716186f, 0.07022112f, -0.02396568f, 0.05533117f, 0.10499871f, -0.39540821f, 
    0.04919278f, -0.05030558f, -0.26042506f, -0.62688637f, 0.24015582f, 0.04720232f, 0.20560937f, 0.06434823f, 
    0.25067309f, -0.63220340f, -0.43561605f, -0.16291034f, -0.80168891f, -0.30235142f, 0.12160534f, -0.15778114f, 
    0.14890158f, -0.43928349f, 0.04652521f, 0.00212113f, 0.02953553f, 0.32736000f, -0.35523254f, -0.01504518f, 
    -0.00664615f, 0.18272211f, -0.31990838f, 0.01813972f, 0.36081472f, -0.15165247f, 0.10207728f, 0.19051242f, 
    -0.32037672f, -0.18325941f, 0.31779873f, 0.21510400f, -0.10153762f, 0.44007424f, -0.54857183f, 0.06897392f, 
    -0.04218936f, -0.28494430f, -0.16511421f, 0.09108851f, 0.24481225f, 0.00076681f, -0.11372244f, 0.01316944f, 
    0.24840680f, -0.04514881f, 0.04525461f, 0.11516314f, 0.26079479f, -0.02249415f, -0.03654341f, -0.22794090f, 
    0.17725578f, -0.17479874f, 0.07213008f, -0.00093500f, 0.03879439f, -0.26914573f, -0.56999695f, -0.21402098f, 
    0.19436990f, 0.19764926f, -0.49680373f, -0.61431378f, 0.01481949f, -0.64768338f, 0.18986191f, 0.31070659f, 
    -0.22006445f, 0.16410877f, 0.14186649f, -0.16367680f, 0.29602262f, -0.16099302f, -0.04385597f, 0.22343561f, 
    -0.21079512f, -0.02919148f, 0.00811569f, -0.17862524f, -0.61622691f, 0.17091581f, 0.17790537f, -0.61731625f, 
    -0.04344178f, 0.01236972f, 0.29454532f, 0.24992165f, -0.38342452f, -0.08173053f, -0.44557431f, 0.07517812f, 
    -0.14318621f, -0.17629798f, -0.00481867f, -0.04886923f, -0.49285293f, -0.17380154f, 0.04959395f, -0.07233462f, 
    -0.06573174f, -0.03715859f, -0.30133647f, 0.03369996f, -0.02388385f, -0.30379456f, -0.50270879f, -0.08346395f, 
    -0.12633695f, -0.01360638f, -0.09182150f, -0.08198471f, 0.10766754f, -0.01861323f, 0.14415731f, -0.04448694f, 
    -0.05359676f, -0.25049841f, 0.08789817f, 0.21952267f, 0.01926940f, 0.00003200f, -0.18638162f, -0.54438198f, 
    0.07744975f, -0.00436151f, -0.48339239f, 0.09573035f, 0.02756022f, -0.04174599f, -0.75918549f, -0.58281916f, 
    0.08166645f, 0.00961748f, -0.27437058f, -0.06468464f, 0.13238718f, -0.04976416f, -0.48997679f, 0.09496836f, 
    -0.35184094f, 0.06364850f, -0.01264643f, -0.02497382f, 0.05658220f, -0.35523051f, -0.00369506f, 0.06107876f, 
    -0.04994613f, -0.20782185f, 0.11356919f, -0.07360493f, -0.01829350f, 0.03794933f, 0.08733038f, -0.22293939f, 
    0.25484505f, -0.47427484f, 0.06731483f, -0.39634264f, 0.20848916f, 0.16409479f, 0.01396328f, -0.20293835f, 
    0.00046626f, 0.29197884f, 0.13447091f, 0.12282568f, 0.15156199f, -0.09360702f, -0.62087417f, -0.07847288f, 
    0.04582326f, 0.04943917f, -0.03463551f, -0.06443096f, 0.30147704f, -0.01937356f, 0.27944577f, -0.35868818f, 
    -0.16984455f, 0.05342535f, -0.10610360f, 0.35003707f, -0.13091151f, -0.88111979f, 0.11788897f, 0.10813883f, 
    0.26890275f, -0.44030041f, 0.25252876f, 0.18372191f, -0.00519453f, -0.33967641f, 0.06697184f, 0.09866171f, 
    -0.19355007f, 0.08184055f, -0.06738157f, 0.14335382f, -0.31267679f, 0.18551031f, -0.06308901f, -0.27034688f, 
    0.14627852f, -0.05500317f, 0.25295144f, 0.35460031f, 0.08581413f, 0.12389166f, -0.28016868f, -0.44871369f, 
    -0.20465082f, -0.04661367f, 0.06480858f, -0.43143958f, -0.09556717f, 0.07609031f, 0.13078302f, -0.01270031f, 
    0.00808845f, -0.00336330f, -0.01809517f, 0.08108035f, -0.76568472f, 0.00157140f, -0.84442079f, -0.03743067f, 
    -0.00680704f, 0.04769181f, -0.43973047f, 0.07469537f, -0.01696649f, 0.00944340f, 0.08687700f, 0.16951872f, 
    -0.55845958f, -0.30162308f, -0.07923389f, -0.01131955f, -0.07007790f, -0.26264089f, 0.03107471f, -0.07297574f, 
    0.18936001f, 0.02951024f, -0.07748568f, -0.09059010f, 0.20202230f, 0.16048633f, -0.48493674f, 0.27226385f, 
    -0.04399214f, -0.09993247f, -0.22926927f, 0.20181377f, -0.07336267f, -0.05179077f, -0.13742642f, -0.04027089f, 
    -0.73590857f, 0.01372334f, -0.06054195f, 0.01668457f, 0.04499944f, 0.15042797f, -0.04943071f, 0.10525128f, 
    -0.01744957f, 0.10637435f, -0.05738693f, -0.06446322f, 0.03855689f, 0.01250484f, 0.13966615f, 0.00769881f, 
    -0.31716421f, -0.19745423f, -0.14682679f, -0.17134206f, -0.30911422f, 0.19749199f, -0.10035027f, 0.33019516f, 
    0.19862747f, -0.17928356f, -0.04429144f, 0.05581357f, 0.18964687f, -0.02165968f, -0.22950758f, 0.17317110f, 
    0.03415568f, 0.18024652f, 0.12874849f, 0.00676571f, 0.22266792f, -0.03170791f, -0.00467848f, -0.31537163f, 
    0.00708041f, -0.37001058f, 0.05504077f, -0.09396270f, 0.23308574f, -0.73909032f, 0.35956609f, -0.08501645f, 
    -0.79600012f, -0.09155709f, -0.13097690f, 0.17165877f, -0.03134790f, -0.22451504f, -0.12583661f, 0.27363640f, 
    -0.51452494f, 0.08606973f, 0.07484526f, 0.23715758f, 0.02009068f, -0.13796024f, 0.15071984f, 0.19168463f, 
    0.13165627f, 0.10600720f, -0.52486652f, 0.22309516f, -0.12570675f, 0.13308598f, -0.01684919f, -0.08203642f, 
    0.02273605f, -0.04979535f, 0.34828511f, -0.40196440f, 0.03728172f, 0.13034414f, -0.50133336f, -0.41080764f, 
    0.14186664f, 0.05804833f, 0.11307663f, -0.31775144f, 0.10880663f, -0.18951270f, 0.02956520f, 0.00417257f, 
    -0.18438379f, -0.26015463f, -0.14342068f, 0.02832190f, 0.68375194f, 0.03967715f, 0.01025643f, -0.00354526f, 
    0.01300164f, 0.19514924f, -0.14233597f, 0.00570794f, -0.09492279f, 0.57301009f, 0.24663658f, 0.06619422f, 
    0.07337698f, 0.01864491f, -0.31464922f, 0.06693279f, -0.45432210f, 0.02699775f, -0.65350312f, -0.07305188f, 
    0.00215999f, 0.03135014f, 0.00132136f, -0.07877816f, -0.21787797f, 0.12005462f, -0.00314188f, 0.02072977f, 
    -0.07148223f, 0.01080443f, 0.10253873f, -0.07660081f, -0.33903638f, 0.04622765f, -0.09046153f, 0.04445197f, 
    -0.02381580f, 0.22430111f, 0.02311411f, 0.07595832f, 0.22079663f, 0.29186964f, 0.04443469f, -0.06948102f, 
    0.03423986f, -0.02365109f, 0.02791630f, 0.06104258f, -0.02114097f, 0.04271723f, -0.01329698f, -0.39891851f, 
    0.24708480f, 0.17798336f, 0.01030041f, -0.12610494f, 0.18547951f, 0.02103233f, 0.01927437f, -0.18216221f, 
    0.27493471f, 0.14111009f, -0.05911310f, -0.02150319f, -0.38410756f, -0.21218438f, 0.06490673f, -0.24493054f, 
    0.07511630f, -0.21343820f, -0.18138470f, -0.02151833f, 0.01835136f, -0.01264267f, 0.00008046f, -0.08277399f, 
    -0.50115871f, -0.06669366f, -0.00927140f, -0.04818701f, -0.48977801f, -0.09603336f, -0.02621775f, 0.11388015f, 
    0.10373792f, 0.20571135f, -0.08188754f, 0.05917872f, -0.01232932f, 0.67203730f, 0.19505571f, -0.45998612f, 
    0.16482727f, 0.01545846f, 0.35116634f, 0.13635653f, -0.07247790f, 0.24689481f, -0.31487560f, -0.41224337f, 
    0.07083531f, -0.56962156f, -0.17703654f, -0.05614854f, -0.02437788f, -0.60510695f, -0.05012351f, -0.00397650f, 
    -0.46901363f, 0.01469040f, -0.38584611f, 0.09820344f, 0.14743111f, -0.42389396f, 0.15709242f, 0.34655741f, 
    -0.05344602f, 0.00953764f, -0.10171394f, 0.29364449f, 0.14842735f, 0.26001608f, 0.04272123f, 0.03425097f, 
    0.01259233f, -0.17715935f, -0.05568929f, -0.06278065f, 0.37740538f, -0.13046525f, 0.15111329f, 0.03627572f, 
    0.03548396f, 0.22796129f, 0.37054968f, 0.06971679f, -0.03005599f, -0.25883499f, -0.02378854f, -0.12933086f, 
    0.01394412f, 0.13565658f, -0.03771195f, 0.04965039f, 0.20922272f, -0.04085770f, -0.07183570f, -0.05893523f, 
    -0.18593854f, 0.05122380f, -0.04954466f, 0.29351512f, -0.08103341f, 0.02570255f, 0.29324922f, -0.70434308f, 
    -0.01888729f, 0.00956981f, -0.27858382f, -0.15669268f, -0.00244804f, -0.01924524f, -0.69873887f, 0.21015134f, 
    -0.33111516f, -0.06437317f, -0.15973429f, -0.40098301f, -0.52414632f, -0.01189103f, 0.04117221f, -0.37243927f, 
    0.18113673f, -0.00643982f, 0.02524842f, -0.02203342f, 0.02666692f, 0.02133512f, -0.28625524f, -0.20780364f, 
    -0.01921239f, -0.37693807f, -0.35406718f, 0.11307067f, -0.01736280f, 0.36613941f, -0.04433114f, 0.12886623f, 
    0.00784841f, 0.21303929f, -0.48012105f, -0.16234429f, -0.37499511f, -0.09001723f, 0.16424783f, 0.33102202f, 
    0.01565723f, 0.40315229f, -0.16276887f, -0.20915993f, 0.23693749f, -0.02613667f, -0.08452271f, -0.46048912f, 
    -0.84902453f, 0.06381062f, 0.02952523f, -0.01513800f, -0.03048167f, 0.01492848f, 0.15057474f, -0.00349172f, 
    -0.38103256f, 0.12043754f, 0.05791858f, -0.01893139f, 0.07561620f, -0.82520413f, -0.16260682f, -0.13357233f, 
    -0.00625813f, 0.17527886f, 0.34047067f, 0.06849114f, -0.06779440f, 0.21278219f, -0.08023268f, 0.00196861f, 
    -0.51188219f, -0.30969450f, -0.26944563f, -0.23530962f, -0.18720126f, -0.38670897f, -0.02684959f, -0.25339916f, 
    -0.27728295f, -0.01122697f, 0.20994833f, -0.33183014f, -0.37836045f, 0.27559996f, -0.02461671f, -0.16794515f, 
    -0.00199751f, -0.04053381f, 0.24676268f, 0.21633197f, 0.28369728f, 0.16376336f, 0.11108319f, 0.03065799f, 
    -0.05506050f, 0.17242229f, -0.06499622f, -0.03696055f, -0.08834188f, -0.72948861f, 0.15103938f, 0.07949976f, 
    0.10570590f, 0.00184994f, -0.07356595f, -0.04804866f, -0.08705646f, -0.10044264f, 0.11315406f, -0.34915945f, 
    0.18040866f, 0.22110666f, -0.09897100f, 0.04091453f, -0.15570152f, 0.14310451f, -0.15584438f, -0.04881538f, 
    -0.06363768f, 0.10770067f, -0.04570499f, -0.30298924f, -0.05159852f, -0.07526202f, -0.15379356f, -0.11329387f, 
    -0.08251472f, -0.05716127f, 0.03031180f, 0.05349138f, 0.28689647f, 0.03601316f, 0.06501347f, -0.13650155f, 
    0.29339698f, 0.19327891f, 0.11084083f, 0.21901387f, 0.25183657f, -0.00530930f, -0.28106293f, -0.19889019f, 
    -0.33659837f, 0.28879765f, 0.01110410f, 0.18005630f, 0.07916608f, -0.57733971f, -0.05587193f, 0.27371559f, 
    -0.28518778f, 0.15061761f, -0.06772025f, -0.35988164f, 0.17801446f, -0.68894476f, 0.14067855f, 0.23240022f, 
    -0.08508842f, -0.27085578f, 0.10764751f, 0.18730365f, 0.07383865f, -0.27238491f, -0.09239497f, -0.44124764f, 
    -0.13209769f, -0.38442647f, 0.06399660f, -0.00058104f, 0.08069929f, -0.06802065f, 0.17916948f, -0.03527095f, 
    0.17628920f, 0.16912855f, 0.07396776f, -0.22028112f, 0.14633960f, 0.24059205f, -0.00764913f, -0.02398312f, 
    0.05126160f, -0.53707564f, -0.48902738f, -0.09436807f, -0.34688276f, -0.32552534f, 0.00017282f, 0.20201136f, 
    -0.10504209f, -0.18640178f, -0.81027067f, 0.20085903f, 0.10287124f, -0.41774154f, -0.46789703f, -0.13454403f, 
    0.16850878f, -0.08303541f, 0.18378332f, 0.16247982f, 0.22402473f, 0.22118056f, -0.04885962f, 0.11571319f, 
    0.24105889f, 0.04568608f, 0.14209321f, 0.15367608f, 0.15667857f, -0.08195035f, -0.26904142f, -0.19074503f, 
    -0.23728864f, 0.01423788f, -0.68214107f, -0.31175333f, -0.28141448f, -0.22398028f, 0.14018518f, -0.01048438f, 
    -0.10135523f, -0.11254574f, -0.08679441f, -0.07839320f, 0.09184317f, 0.20148329f, -0.23334464f, -0.08784580f, 
    -0.80544049f, 0.05281844f, -0.06043974f, 0.00635616f, 0.05127845f, -0.21319775f, -0.11147723f, 0.18702655f, 
    -0.53299117f, -0.38297078f, 0.12290465f, 0.01564919f, 0.09850731f, -0.40309840f, -0.00121426f, 0.03668582f, 
    0.13506065f, 0.13105442f, -0.15578605f, -0.18405195f, 0.19818608f, 0.12708130f, 0.19966011f, 0.28853601f, 
    0.07891339f, -0.03666196f, 0.12138730f, 0.39973694f, 0.25269523f, 0.07266460f, 0.28074396f, 0.16013557f, 
    0.26099336f, -0.17564921f, 0.42387488f, 0.23832107f, -0.04567304f, 0.14211245f, -0.00764757f, 0.37957057f, 
    -0.02670659f, -0.30627069f, 0.00697131f, -0.43385741f, 0.05558150f, -0.28225443f, 0.28206545f, -0.08405333f, 
    -0.03583222f, 0.13838838f, 0.18955144f, 0.08642497f, -0.36043483f, -0.31270298f, -0.01775103f, -0.18840395f, 
    0.06561994f, -0.12363867f, 0.15546848f, 0.32862470f, -0.21127197f, -0.55485231f, -0.37146392f, -0.12520012f, 
    0.02227067f, -0.05006775f, -0.21515597f, 0.07544605f, -0.54543257f, 0.00674728f, 0.10496488f, 0.10486529f, 
    -0.00819832f, 0.38698623f, -0.04306857f, -0.36132026f, -0.34484696f, -0.09188420f, -0.51767731f, 0.24076787f, 
    0.36419195f, 0.15897629f, 0.18605776f, -0.27221933f, 0.19710387f, 0.03446129f, 0.12346379f, -0.45601428f, 
    -0.25078899f, 0.03269858f, -0.29424238f, -0.15668567f, -0.01505277f, -0.34694096f, 0.17908630f, -0.34725815f, 
    0.07087637f, -0.03274580f, -0.03837044f, -0.06703752f, -0.08405966f, -0.08675809f, 0.08388183f, 0.03842339f, 
    -0.26958635f, -0.02043566f, -0.10726696f, 0.41210476f, -0.00402703f, -0.00443889f, -0.04015424f, 0.11385432f, 
    0.07473589f, -0.06380138f, -0.39261517f, -0.33939505f, -0.36907861f, -0.35403198f, -0.35731822f, 0.04104261f, 
    -0.02731024f, -0.51823837f, -0.12509611f, 0.02019596f, -0.22124299f, 0.22295971f, 0.04362985f, 0.03478853f, 
    -0.13837500f, -0.69280308f, -0.07672302f, 0.04663416f, -0.01332215f, 0.13230884f, -0.00109044f, -0.29606402f, 
    -0.87879264f, -0.16109896f, -0.00740455f, -0.11980874f, -0.34982318f, 0.06923886f, 0.29582614f, -0.11381837f, 
    -0.38283750f, -0.65609550f, 0.11425520f, 0.09866662f, 0.32450977f, -0.32019249f, 0.06590645f, -0.23791429f, 
    0.04276283f, 0.06172277f, -0.19464365f, 0.13375722f, 0.24180195f, -0.03402601f, -0.00309688f, 0.09758790f, 
    -0.02720178f, -0.13993196f, 0.10976434f, -0.03443511f, 0.16043724f, 0.26206416f, 0.04777155f, 0.09417126f, 
    -0.03459642f, 0.03718505f, -0.13043027f, 0.08480127f, 0.04690117f, -0.17148469f, 0.34723368f, -0.95106417f, 
    -0.12480392f, 0.13622116f, -0.18844952f, -0.10589053f, -0.73178995f, 0.09248551f, -0.04820808f, 0.14992435f, 
    -0.37700501f, 0.22828543f, -0.29896963f, -0.27847329f, -0.30217555f, 0.12977548f, 0.12898600f, 0.02598451f, 
    -0.18573941f, 0.10441727f, -0.46274105f, -0.02630562f, 0.19478722f, 0.08455837f, -0.29442406f, 0.03420764f, 
    0.15116999f, 0.02003519f, -0.07254178f, 0.21289600f, -0.18287545f, 0.06195340f, -0.34080955f, 0.11197946f, 
    0.18298876f, 0.16925116f, -0.03959134f, -0.02185275f, -0.10239267f, 0.72986078f, -0.20466329f, -0.07632604f, 
    -0.37111461f, 0.19801910f, 0.03223229f, -0.08576415f, -0.01564796f, -0.01884450f, 0.11741809f, -0.27704096f, 
    -0.16416423f, -0.01525415f, 0.45061997f, 0.20206556f, -0.18160318f, -0.27168441f, -0.06812587f, -0.50767839f, 
    0.15506870f, -0.05100167f, 0.22825351f, 0.12016854f, -0.10981101f, -0.29299307f, -0.15650713f, 0.00240525f, 
    0.07608573f, -0.08072275f, 0.06994059f, -0.19683799f, -0.07768366f, -0.06080123f, -0.11497284f, 0.00578063f, 
    -0.04820303f, 0.14882357f, -0.04851954f, -0.02034086f, -0.17867713f, -0.11350473f, -0.16792440f, 0.07954568f, 
    0.09871439f, 0.12503420f, -0.16347584f, 0.05725811f, 0.06061288f, -0.20256248f, -0.09530375f, 0.02992797f, 
    0.26534137f, 0.03355895f, -0.25441140f, -0.05095514f, -0.26582715f, 0.09605984f, 0.14635640f, -0.02281742f, 
    -0.03878135f, -0.01053684f, -0.06882513f, -0.25237587f, -0.17422792f, -0.28702384f, -0.00931441f, 0.05619988f, 
    -0.01166871f, 0.03220772f, -0.10362978f, 0.08606412f, -0.26442960f, 0.03231984f, 0.05514163f, -0.20681168f, 
    -0.01265673f, -0.13655484f, -0.60614109f, -0.45185769f, 0.03575660f, -0.59861952f, -0.19583988f, 0.21971676f, 
    0.08850813f, -0.27702558f, -0.15892980f, -0.01119135f, 0.01726412f, -0.05553750f, 0.22047330f, -0.22553989f, 
    0.11893240f, 0.12482864f, 0.33406594f, -0.03514505f, 0.02142381f, 0.05433853f, 0.09731474f, -0.26384372f, 
    0.19265363f, 0.03830890f, 0.21756096f, 0.13566349f, -0.00134276f, 0.00768720f, 0.22473180f, -0.45284888f, 
    -0.00303324f, -0.19813249f, 0.01075544f, 0.05911727f, -0.11209057f, -0.04131315f, -0.71040481f, 0.26680440f, 
    0.24400327f, -0.22147250f, 0.00748056f, 0.02982471f, 0.23640445f, -0.66257274f, -0.09470706f, -0.45067069f, 
    0.32312939f, -0.41394976f, -0.08938056f, -0.02229726f, -0.09073473f, -1.02325296f, 0.26463863f, 0.07299489f, 
    0.37793517f, -0.10919541f, 0.01461968f, -0.06160311f, -0.05224209f, -0.02632410f, -0.01458936f, 0.15687859f, 
    0.09735671f, 0.30105755f, 0.26186275f, -0.53557605f, -0.20414734f, -0.01440978f, -0.07217506f, -0.04885096f, 
    -0.04892263f, -0.04159779f, -0.50303596f, 0.20601243f, 0.08732384f, -0.37103862f, 0.16196990f, 0.16250530f, 
    -0.57454407f, 0.00384689f, -0.40586630f, 0.03201844f, -0.30805570f, 0.22900485f, 0.03740965f, -0.01213984f, 
    0.02220082f, -1.02686143f, -0.04821795f, 0.00273737f, -0.03610733f, 0.14603795f, -0.29216379f, 0.07053454f, 
    0.03551081f, -0.09010006f, -0.26119798f, 0.01477445f, 0.03056610f, -0.06539189f, -0.28230423f, 0.20037819f, 
    -0.98861271f, -0.06586785f, 0.18827678f, 0.05823835f, 0.30961141f, -0.04237332f, 0.30266625f, 0.03465687f, 
    0.21853173f, 0.09475178f, 0.19041914f, -0.57503587f, 0.12525086f, 0.07969222f, -0.55968660f, -0.09008335f, 
    -0.06944426f, 0.02008076f, 0.07498103f, 0.05797377f, 0.22952935f, 0.03792705f, -0.19822842f, -0.00654258f, 
    0.08476676f, 0.15060616f, -0.08794212f, -0.22274299f, -0.27851725f, -0.37256444f, -0.08864500f, -0.35322362f, 
    -0.18883649f, 0.06428591f, -0.09926881f, -0.07959565f, -0.02728520f, 0.36401549f, -0.25821826f, 0.22421303f, 
    0.19695312f, -0.06387610f, -0.13003950f, 0.07514632f, -0.33067715f, 0.12858948f, 0.27308410f, -0.43615440f, 
    0.08078573f, -0.10334516f, 0.16362034f, -0.51821232f, 0.24098434f, -0.27923781f, 0.14243169f, 0.23547624f, 
    -0.09807402f, 0.09528572f, 0.32357678f, -0.09633979f, -0.25774646f, 0.04140356f, -0.03010601f, -0.54036570f, 
    0.12693259f, -0.06082568f, 0.04448862f, -0.13336882f, 0.03211431f, 0.45743674f, 0.03253746f, -0.18421131f, 
    0.16091256f, -0.32965603f, 0.15027975f, 0.23101862f, 0.24134633f, -0.58792710f, -0.32868120f, 0.03164046f, 
    0.25963908f, -0.20094040f, 0.00904178f, -0.12759659f, -0.10109877f, 0.03101933f, -0.35616583f, -0.22392435f, 
    -0.03653931f, 0.07187025f, 0.16181619f, -0.47136772f, 0.23424865f, -0.09063442f, -0.01973670f, -0.42861989f, 
    0.27864361f, 0.02641739f, -0.13905321f, 0.19990295f, -0.43080738f, 0.00968702f, 0.03382589f, 0.25721720f, 
    -0.02430315f, 0.07007610f, -0.03600381f, 0.03070615f, -0.01415759f, 0.11902266f, 0.06960493f, -0.00783926f, 
    0.00046609f, 0.15139771f, 0.06835534f, 0.04045119f, -0.28352848f, 0.13912022f, -0.04453260f, -0.07311586f, 
    0.17785637f, -0.01229731f, 0.02592464f, 0.03034235f, 0.01336200f, -0.06360912f, 0.08611775f, 0.05323748f, 
    -0.22460286f, 0.14972810f, -0.07292915f, 0.02626935f, -0.31126952f, -0.09540826f, -0.11085633f, 0.08642052f, 
    0.04272158f, -0.04489939f, 0.17435411f, 0.37934533f, -0.10642182f, -0.11812334f, -0.47028357f, 0.13827595f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.03860316f, 0.12144612f, -0.03571652f, -0.23388438f, 0.18192191f, 0.01644556f, 0.03887425f, -0.25002152f, 
    -0.18381464f, -0.05758176f, 0.14449528f, -0.13427086f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
