#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.03993404f, 0.86312705f, 0.31139427f, 0.08128842f, 0.01112218f, -0.53615838f, -0.74094528f, -0.13330786f, 
    -0.32674533f, -0.08724399f, -0.22525145f, 0.40018976f, 0.29054099f, -0.23328428f, 0.05414367f, 0.06540175f, 
    -0.03034073f, 0.31933728f, -0.12886986f, 0.28030020f, 0.43275389f, 0.42172185f, 0.04726138f, 0.24512009f, 
    0.29914895f, -0.14180481f, -0.04551264f, -0.26012400f, -0.24246991f, 0.77034020f, -0.26963115f, -1.06847572f, 
    0.22882330f, -0.90181667f, -0.58465672f, -0.43286997f, 0.44528076f, 0.14405686f, 0.26222184f, 0.20617563f, 
    -0.06190141f, -0.06321564f, -0.01525412f, 0.23334587f, 0.50406921f, -0.08886687f, -0.24990608f, -0.04533979f, 
    0.05773219f, -0.25589541f, 0.18765000f, 1.43204844f, -0.49740979f, -0.38819006f, -0.90943974f, 0.38884988f, 
    0.42744860f, -0.10126157f, 0.20161317f, 0.02211948f, 0.24496986f, -0.32857853f, -0.11761936f, 0.19050223f, 
    0.24779896f, 0.26867431f, -0.18363638f, 0.14772111f, 0.28708634f, 0.09271917f, 0.19045343f, -0.14185946f, 
    -0.00739142f, 0.02909369f, 0.26022378f, 0.98897469f, 0.32478079f, 0.01580510f, -0.47015911f, -0.07413294f, 
    0.44782361f, 0.18013121f, 0.46655142f, 0.41512600f, 0.69680870f, 0.07759181f, 0.33179644f, -0.06903246f, 
    -0.27046987f, 0.26938933f, 0.25935045f, 0.18461072f, -0.21715160f, 0.01317723f, -0.04567063f, -0.13839704f, 
    -0.14456463f, -0.11195492f, 0.29123947f, 0.20571856f, -0.10472064f, -0.60651118f, -0.29562038f, 0.10722977f, 
    0.42980558f, 0.37898281f, -0.24561401f, -0.44870147f, -0.68173540f, -0.78564894f, 0.28592709f, 0.45942113f, 
    0.18107492f, 0.14455390f, 0.10500561f, 0.17577167f, -0.50245541f, -0.63389742f, -0.30430013f, -0.15988533f, 
    -0.17542507f, 0.35761234f, 0.28321600f, 0.22747067f, 0.17585246f, -0.46481615f, -0.42376629f, 0.38302824f, 
    -0.65893936f, -0.80395055f, 0.25208652f, -0.07223867f, 0.78490376f, -0.07727830f, -0.17151029f, 0.45084596f, 
    0.31233552f, -0.21817102f, 0.27500245f, 0.24612574f, 0.33380187f, 0.22772725f, -0.12391637f, -0.11228861f, 
    0.05695612f, -0.07633053f, -0.27747864f, -0.29395175f, -0.27058798f, -0.10255706f, 0.71301699f, -0.27037710f, 
    0.59597105f, -0.04145770f, -0.41768563f, -0.33719832f, -0.80867064f, 0.36788708f, -0.07132614f, 0.27945170f, 
    -0.34205452f, 0.17203344f, -0.13515286f, -0.23413305f, -0.06843374f, 0.38069654f, 0.01914813f, 0.15997154f, 
    -0.04848462f, -0.02726579f, -0.04845640f, -0.21508583f, -0.14090978f, -0.48929092f, 0.01754734f, 1.12481546f, 
    0.45222789f, 0.41121846f, 0.98838824f, 0.72055584f, 0.29785213f, -0.08133247f, -0.38220054f, -0.18536697f, 
    -0.30209446f, -0.21451826f, 0.31100988f, -0.04774885f, 0.16007382f, -0.15297922f, -0.17736286f, 0.24857794f, 
    0.03520158f, -0.14788812f, -0.00392262f, -0.00145293f, 0.29362413f, -0.10915015f, -0.04629443f, -0.11941883f, 
    0.26451755f, 0.23718251f, 0.75535011f, 0.37358791f, -0.26280290f, 0.31651080f, -0.03219311f, 0.45389488f, 
    0.31042919f, 0.37894312f, -0.15736908f, 0.26686919f, 0.41444898f, 0.34646100f, 0.53397459f, 0.14439790f, 
    -0.29794249f, -0.22428131f, -0.17519559f, -0.11474395f, 0.14021656f, 0.14737594f, 0.11160018f, 0.22964080f, 
    0.35620669f, 0.70771348f, 0.23287772f, 0.57397211f, 1.04865766f, 0.87923944f, 0.75006962f, 0.28028154f, 
    -0.12604035f, 0.21506509f, -0.23499173f, 0.04120306f, 0.08750805f, -0.41809130f, -0.02639572f, -0.59878093f, 
    0.03217314f, -0.23737822f, 0.06697427f, 0.06290045f, -0.30586457f, 0.05369153f, 0.22351590f, 0.12060041f, 
    -0.01367464f, 0.18516304f, 0.65484792f, 0.07792854f, -0.03759538f, 0.15263373f, -0.32791883f, 0.30540827f, 
    0.64678699f, 0.68307680f, 0.50049722f, 0.57199448f, -0.19443409f, 0.09628080f, 0.25533262f, 0.29924813f, 
    -0.51285738f, -0.35455909f, -0.12601341f, 0.15276857f, 0.13399385f, -0.34510872f, 0.24766387f, -0.15359087f, 
    -0.21682468f, -0.42775190f, 0.00116588f, -0.31710729f, -0.15164758f, -0.10164121f, -0.44769701f, -0.42061701f, 
    -0.34554490f, 0.03387801f, -0.19126272f, -0.59753466f, -0.42658964f, -0.25003603f, -0.02853288f, -0.31163368f, 
    0.43668762f, -0.20690106f, 0.13355649f, -0.26100582f, 0.19875556f, 0.00776514f, 0.13211085f, -0.02771930f, 
    0.23331967f, 0.13309658f, 0.43981349f, 0.53141242f, -0.97228825f, -0.17232546f, 0.09964596f, -0.17987190f, 
    0.14313164f, -0.56845540f, 0.71452826f, 0.29445669f, 0.02392290f, 0.36762369f, -0.45948339f, 0.05209858f, 
    0.06437493f, -0.13268293f, 0.09086839f, 0.54183394f, 0.10377955f, -0.40068969f, 0.40857536f, 0.08661518f, 
    0.26278982f, -0.05271672f, 0.41370103f, 0.08264156f, 0.39173847f, 0.02312619f, -0.11731464f, -0.15070421f, 
    -0.13632037f, -0.55150801f, -0.30574849f, 0.44047716f, -0.58525497f, -0.45051000f, -0.58537328f, 0.26638487f, 
    0.54311424f, -0.35066622f, 0.18066047f, -0.21531028f, 0.42909390f, -0.24376358f, -0.17733048f, 0.09920672f, 
    0.10779121f, -0.14596431f, 0.32607889f, 0.52080774f, -0.23059762f, -0.03259881f, -1.02824318f, 0.57699263f, 
    -0.05795605f, -1.05503201f, -0.40702385f, 0.64425862f, -0.25384843f, -0.31651747f, 0.59870380f, 0.49964190f, 
    0.03307054f, -0.36373669f, -0.19807509f, 0.00866825f, -0.29994622f, 0.12236051f, 0.17968608f, -0.11657675f, 
    -0.01336212f, 0.08901614f, -0.04314326f, -0.16960664f, 0.04611207f, -0.08254970f, 0.20336911f, 0.06087587f, 
    -0.05759940f, 0.05743833f, 0.31700414f, 0.08862346f, -0.24935128f, -0.65749466f, -0.40554842f, 0.03686003f, 
    -0.44181591f, 0.44495219f, 0.13075817f, 0.24186666f, 0.41712382f, 0.11211469f, 0.34776366f, 0.27214685f, 
    0.25699183f, 0.28371972f, 0.33542722f, 0.05182799f, -0.23464170f, -0.21854357f, -0.02378046f, 0.63612258f, 
    -0.34672421f, -0.29578677f, -0.36536556f, -0.19346136f, 0.20684230f, 0.56680739f, 0.82320249f, -0.18321654f, 
    0.52927840f, 0.65170568f, -0.00914511f, -0.36551777f, -0.34570739f, -0.12555815f, 0.12117641f, -0.15652873f, 
    0.21072203f, 0.11353137f, 0.41389471f, 0.21697056f, 0.06920354f, -0.36488205f, -0.27384895f, -0.26489532f, 
    -0.17297697f, -0.51676321f, 0.13984944f, -0.44209284f, -0.83794117f, -0.53501028f, 0.77713269f, -0.08187400f, 
    -0.68881673f, -0.56118721f, 0.08308762f, -0.33213302f, 0.03536788f, 0.54164350f, 0.30339822f, 0.08444510f, 
    0.07222416f, 0.17202213f, 0.14591539f, -0.10682448f, 0.06740034f, -0.01787282f, -0.15033925f, 0.04479583f, 
    -0.02192645f, 0.05288775f, -0.54481453f, -0.59924883f, -0.87296927f, -0.89187473f, -0.06900693f, 0.01000146f, 
    0.64156067f, 0.69646156f, 0.03311982f, 0.52832216f, -0.18341909f, -0.17422591f, 0.25804493f, -0.28147429f, 
    -0.13565123f, -0.15388340f, -0.05508853f, -0.00963383f, 0.21277089f, 0.00835413f, -0.14191008f, -0.18657354f, 
    -0.20193411f, -0.16551137f, 0.04937831f, -0.08856332f, -0.94375390f, -0.56864816f, 0.19602324f, -0.24987477f, 
    0.12640661f, 0.86128128f, -0.37345785f, -0.19810942f, 0.24519582f, 0.41541326f, 0.45623028f, -0.52593279f, 
    0.15871352f, 0.46588978f, -0.00231481f, -0.25519755f, 0.16861889f, -0.17811532f, 0.02600713f, 0.22610149f, 
    0.28119996f, -0.24744725f, 0.13706507f, -0.11632507f, -0.60525119f, -0.46935567f, 0.33406448f, 0.33326960f, 
    -0.25953162f, -0.52323091f, -0.44320855f, -0.01275845f, 0.11182754f, -0.43500867f, -0.29245922f, -0.17498747f, 
    0.20444562f, 0.05107982f, -0.31738928f, 0.15800431f, -0.21551199f, -0.36372501f, -0.03155423f, -0.56622964f, 
    -0.19446291f, 0.01453739f, -0.07319637f, 0.14335525f, 0.42683056f, 0.37774268f, -0.49848071f, 0.22579235f, 
    -0.90364319f, 0.25566441f, 0.59972072f, -1.04263639f, 0.32194611f, 0.13995284f, -0.39874420f, 0.10738245f, 
    0.29201406f, 0.05736327f, -0.13829270f, -0.00335978f, 0.10040081f, -0.02926392f, 0.00567316f, -0.12173045f, 
    -0.09150813f, 0.41936991f, 0.19150308f, 0.09203824f, 0.37129560f, -0.10944218f, 0.11743735f, 0.00222962f, 
    -0.55025959f, -0.15591446f, 0.11579952f, 0.36419311f, -0.42378640f, -0.00306731f, 0.25625166f, -0.59084463f, 
    -0.61251509f, -0.37986034f, 0.00740491f, 0.20238048f, -0.32622856f, -0.05059814f, 0.22670721f, 0.43185034f, 
    0.25495541f, -0.05927508f, -0.31445891f, -0.46939105f, -0.29347491f, 0.00462633f, -0.00200375f, 0.34625697f, 
    0.86093265f, 0.69215399f, 0.34614408f, 0.50563949f, -0.12033318f, 0.23235174f, 0.13218193f, 0.18792914f, 
    -0.58647358f, 0.11769596f, -0.17658155f, -0.28927201f, 0.07704242f, 0.39625159f, 0.22144286f, -0.18411008f, 
    0.26035044f, 0.06892475f, 0.01132224f, 0.16039506f, -0.33571661f, -0.22013484f, 0.28469273f, 0.40622592f, 
    0.62796581f, 0.74325651f, 0.71987045f, -0.69704717f, -0.49924818f, -0.83959615f, -0.15692030f, -0.63316512f, 
    -0.56830603f, -0.38191456f, 0.24854925f, 0.28437546f, -0.01946052f, 0.03819541f, -0.14624776f, -0.16800837f, 
    -0.25755930f, -0.33219668f, 0.15744315f, -0.09878431f, -0.06710651f, -0.12462914f, 0.11470417f, -0.23828356f, 
    0.35683486f, 1.01981664f, 0.84460902f, -0.36080694f, 0.14935343f, 0.29693589f, -0.38003594f, -0.50452769f, 
    0.25045627f, -0.21950650f, 0.01878590f, -0.09170855f, -0.21124968f, -0.07257614f, -0.20498484f, -0.27151546f, 
    -0.20120694f, -0.38477981f, -0.53581750f, -0.22460231f, -0.50253534f, -0.12010416f, 0.06269535f, -0.10858499f, 
    -0.10634048f, 0.07390799f, -0.21741919f, -0.55658048f, -0.65801275f, -0.50298333f, -0.53421849f, -0.52320641f, 
    0.26975366f, 0.56588870f, -0.07507664f, 0.45970240f, 0.35272220f, 0.06973183f, -0.27267820f, -0.33699468f, 
    -0.07681584f, 0.15421325f, 0.19322589f, 0.09143759f, 0.05598395f, 0.12678626f, -0.18308021f, -0.04223920f, 
    0.07316720f, 0.25605583f, 0.12056795f, -0.13680759f, -0.93105412f, 0.55179882f, 0.84882468f, -0.43422458f, 
    -0.65347558f, -0.20866685f, 0.65836102f, -0.21619420f, -0.46531680f, 0.04561112f, -0.19177713f, -0.30510724f, 
    -0.00921615f, 0.01724856f, 0.03954192f, 0.33993793f, 0.02818089f, -0.12358144f, -0.26065668f, 0.16748156f, 
    0.00957154f, 0.05782567f, 0.22733630f, -0.02722890f, 0.13274369f, -0.46423393f, 0.08758769f, -0.52829295f, 
    -0.20496768f, 0.11094575f, 0.54311377f, -0.37907258f, -0.52500093f, -0.08806626f, -0.31840652f, -0.13697410f, 
    -0.67722970f, -0.56934756f, -0.68247926f, -0.18140465f, 0.25466970f, 0.03644165f, -0.49900874f, -0.46564034f, 
    -0.11007956f, -0.07950989f, 0.01219597f, 0.15651491f, -0.31985828f, 0.95413446f, 0.10621238f, 0.16736001f, 
    0.70182782f, 0.58301497f, -0.50351769f, -0.01918442f, 0.02427255f, 0.73678797f, 0.14203289f, -0.33912691f, 
    -0.04445114f, -0.10849762f, 0.00436834f, -0.22517471f, -0.12811500f, -0.23429471f, -0.05086065f, 0.07949916f, 
    0.21142422f, 0.12880130f, -0.11912419f, 0.23402314f, -0.17374055f, -0.05300835f, -0.83282685f, -0.88159627f, 
    -0.60829604f, 0.00431452f, -0.22992988f, 0.45737520f, 0.73090309f, -0.36250636f, 0.64602959f, 0.27803299f, 
    -0.18718207f, 0.21018998f, 0.15150192f, 0.29756820f, 0.09312247f, -0.35383588f, 0.01119229f, -0.09131572f, 
    -0.23066083f, -0.25945035f, -0.01699549f, -0.08056302f, 0.25252646f, -0.14616624f, -0.12437286f, -1.21650207f, 
    -0.68433648f, -0.01334806f, 1.01787496f, 0.36873046f, 0.52702242f, 1.14226246f, 0.22863691f, -0.04440035f, 
    -0.28498819f, -0.36611739f, -0.04663038f, 0.14943086f, 0.41007286f, 0.12134632f, -0.18782185f, -0.07805176f, 
    -0.22083944f, -0.11276103f, 0.01179611f, 0.07790338f, 0.16035594f, -0.09966741f, -0.03670228f, -0.27807549f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14271361f, 0.24103495f, 0.14286494f, 0.24074706f, 0.21415442f, 0.24376820f, -0.04606049f, 0.17391220f, 
    -0.09076428f, 0.06040954f, 0.04225215f, 0.05281080f, 0.22533387f, 0.23345871f, 0.11240516f, 0.03326331f, 
    -0.13966224f, 0.26234984f, 0.09134891f, 0.40047222f, 0.29174641f, 0.31237659f, 0.14870693f, 0.12774976f, 
    0.14858390f, 0.07213016f, 0.04683445f, 0.02980241f, -0.01776980f, 0.15817246f, 0.11979719f, 0.18821804f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05157975f, -0.01464728f, 0.03700221f, -0.01185069f, -0.01728495f, -0.00966514f, -0.00394661f, -0.04371111f, 
    0.02151318f, 0.02759622f, -0.02126533f, -0.04558913f, -0.05664697f, 0.03817099f, 0.00528823f, -0.02958364f, 
    0.00693490f, 0.03641687f, -0.05685782f, 0.02690286f, -0.05562326f, -0.03122153f, -0.05129150f, -0.04699430f, 
    0.04177214f, -0.02066674f, -0.04785889f, -0.02737192f, -0.02715560f, -0.00357914f, -0.05488276f, -0.04037371f, 
    0.01465513f, -0.02890967f, -0.02317565f, 0.03449671f, -0.02121569f, 0.02574169f, -0.04045493f, 0.04050601f, 
    -0.04189231f, -0.00241265f, 0.03148889f, -0.02159466f, -0.03486192f, -0.05088398f, 0.00802614f, -0.01899029f, 
    0.00816470f, -0.00178549f, -0.00248484f, 0.00595226f, 0.02655101f, -0.03456321f, 0.02689657f, -0.03722747f, 
    -0.02881800f, 0.00139485f, 0.03911627f, -0.04681629f, 0.01378073f, -0.00443709f, -0.00213031f, -0.02902350f, 
    0.00413802f, -0.05405448f, -0.02842768f, 0.02819304f, -0.05129061f, 0.00042826f, 0.03749842f, -0.02644196f, 
    -0.03208157f, -0.05841823f, -0.00471493f, 0.01188011f, -0.03159228f, -0.04521874f, 0.01543372f, -0.03408269f, 
    -0.01116913f, -0.04287788f, -0.03771882f, -0.02224929f, 0.02498494f, -0.05627770f, -0.03438835f, -0.01988296f, 
    -0.01415031f, 0.02651511f, -0.04132859f, 0.01029996f, 0.04525135f, 0.03051001f, -0.02456095f, 0.00950089f, 
    -0.04817691f, 0.01678194f, 0.03586518f, -0.00228831f, -0.02126222f, -0.04724727f, 0.01323742f, 0.03553470f, 
    -0.02519055f, 0.02281405f, -0.05279230f, 0.02581992f, -0.02582625f, -0.03166687f, -0.02050892f, -0.03514397f, 
    -0.04991235f, 0.03289054f, 0.00143706f, 0.01083576f, 0.03304618f, -0.00942011f, 0.01802989f, 0.00691465f, 
    -0.03283488f, -0.04855016f, 0.00061888f, 0.01336311f, 0.04013700f, -0.00969196f, 0.02824935f, 0.03252937f, 
    0.02369117f, -0.00488514f, -0.00481520f, 0.01338981f, -0.04533880f, 0.01414535f, 0.04217969f, 0.00190500f, 
    -0.05085705f, -0.05078188f, 0.00668778f, 0.00251749f, -0.04845399f, 0.02597737f, 0.02387844f, 0.01099509f, 
    0.01829337f, -0.05305162f, -0.00283719f, 0.01823510f, 0.02438071f, 0.00097025f, -0.05344852f, 0.01165716f, 
    -0.05506271f, 0.01517642f, 0.01635850f, 0.02374338f, 0.00501167f, 0.02954942f, -0.03960138f, 0.02964943f, 
    -0.04130773f, -0.03446234f, 0.03215211f, 0.02014213f, -0.01362987f, 0.03970899f, -0.00988977f, -0.03514049f, 
    -0.01884853f, -0.00285986f, 0.00161427f, -0.03250137f, 0.02631121f, -0.01350299f, -0.02086464f, -0.05597277f, 
    -0.03019759f, -0.02665921f, 0.03475798f, 0.02863747f, -0.00418603f, -0.05643381f, -0.05411157f, 0.01158364f, 
    0.01419037f, -0.03973771f, -0.02450774f, 0.02556060f, -0.00572270f, -0.00603980f, 0.01309181f, 0.03722641f, 
    -0.04010556f, -0.02054925f, 0.03151887f, 0.02440273f, 0.03865713f, 0.03557636f, -0.02924088f, 0.04088939f, 
    -0.01130864f, -0.03779465f, -0.00069992f, -0.02197706f, 0.03494136f, -0.00727246f, -0.02624826f, 0.03859244f, 
    -0.02143108f, 0.03999265f, 0.03918407f, 0.02422295f, -0.00627607f, -0.03700425f, -0.05641475f, -0.01356019f, 
    -0.02080290f, -0.02983765f, -0.02758536f, -0.03428110f, -0.01309069f, -0.05223142f, 0.01113247f, 0.02625939f, 
    -0.04044725f, -0.03103775f, -0.02315111f, 0.03330301f, -0.03433789f, -0.04096461f, -0.02698766f, -0.01178992f, 
    0.03840821f, 0.01831870f, 0.04033298f, -0.01649061f, 0.01827195f, -0.03419873f, 0.01299599f, -0.01202073f, 
    -0.02764959f, -0.04884519f, 0.03638288f, -0.04849423f, 0.00560095f, 0.00489847f, -0.03463705f, -0.00950638f, 
    -0.04174040f, -0.05562155f, 0.00724058f, 0.00756876f, 0.00881357f, -0.00993651f, -0.02926572f, -0.04305287f, 
    -0.00248258f, -0.00955421f, -0.04091024f, 0.01904091f, 0.01355340f, -0.00922807f, 0.03078450f, -0.03091469f, 
    0.01043455f, -0.01546902f, -0.02268204f, 0.03747017f, 0.01961007f, -0.04623562f, -0.03737112f, 0.03631480f, 
    0.00402866f, 0.00517953f, 0.02562213f, -0.02940607f, -0.04450792f, -0.00049272f, 0.01325806f, 0.00869700f, 
    -0.02873298f, 0.00414852f, -0.05355337f, -0.05163491f, 0.00432046f, -0.03974064f, -0.03406966f, 0.02508313f, 
    -0.04884082f, -0.02771597f, 0.00804205f, -0.04795347f, 0.02760581f, -0.03494399f, -0.01032803f, 0.02153465f, 
    0.03924422f, -0.03242988f, 0.00325405f, -0.02898821f, 0.03207578f, 0.04032699f, -0.05296276f, 0.03189768f, 
    -0.04895551f, 0.01761980f, 0.02572270f, 0.02124395f, 0.01961769f, -0.01552547f, -0.03466714f, 0.00908867f, 
    0.02573132f, 0.00443195f, 0.00815265f, -0.01220682f, -0.02699530f, -0.00114987f, -0.04474584f, 0.02856786f, 
    -0.02179691f, 0.01633793f, 0.03778215f, -0.01194542f, 0.00773940f, 0.03655685f, 0.00247586f, -0.05587116f, 
    0.01552085f, 0.03504083f, -0.02268942f, -0.03185815f, -0.03065195f, -0.04264465f, -0.04927185f, 0.01476121f, 
    -0.01634635f, 0.01225060f, 0.04876044f, -0.03125725f, 0.01256079f, 0.00063749f, 0.03895693f, 0.03283079f, 
    -0.00424331f, -0.02281950f, -0.03805074f, 0.00907453f, 0.01293482f, -0.03799080f, 0.01735663f, 0.00072538f, 
    -0.02502735f, 0.00547834f, -0.03447899f, 0.03501868f, 0.00795328f, -0.04733747f, -0.05528720f, -0.00927547f, 
    0.02327102f, 0.02495256f, 0.00206709f, -0.01918257f, -0.03685156f, -0.03771349f, -0.04075772f, 0.03693457f, 
    -0.01373939f, -0.03484879f, 0.00711258f, -0.04143393f, 0.00284028f, -0.02694109f, 0.02882738f, 0.00555886f, 
    0.03149460f, 0.03603174f, -0.05966283f, 0.01439826f, 0.02610497f, 0.00937811f, -0.05957492f, -0.03415041f, 
    -0.03111427f, -0.02784712f, 0.03694608f, 0.03110355f, -0.03710556f, -0.00384651f, -0.04372345f, -0.05512485f, 
    -0.01576819f, -0.04411003f, 0.00138927f, 0.01135118f, -0.04175933f, -0.01969791f, 0.02865526f, -0.02059500f, 
    -0.01860653f, -0.02471589f, -0.01954968f, 0.02841340f, 0.00349771f, -0.03020676f, 0.02044857f, 0.02827521f, 
    0.02384681f, 0.03605896f, 0.01199852f, 0.03332854f, -0.01610151f, -0.04047689f, -0.02485839f, -0.04162222f, 
    0.02841442f, 0.01942025f, -0.01701025f, -0.03961117f, 0.00858016f, -0.05081686f, 0.03525469f, 0.03657612f, 
    -0.01205381f, 0.01063899f, -0.00318384f, -0.01601690f, -0.01752375f, 0.02051034f, 0.02865927f, -0.02571093f, 
    -0.05312180f, 0.00776275f, -0.00862961f, 0.02023298f, 0.02867672f, -0.01304548f, 0.03269599f, -0.00373603f, 
    0.01139794f, -0.00796880f, 0.01119864f, 0.00983358f, 0.02191859f, 0.03476950f, -0.03260098f, 0.03610256f, 
    0.01560271f, 0.03405757f, -0.04016644f, 0.01114006f, -0.03783546f, -0.02863062f, 0.02930588f, -0.02561489f, 
    0.04614561f, -0.02249831f, -0.03942194f, 0.00330117f, -0.04113967f, -0.00223310f, -0.03328486f, 0.02583436f, 
    -0.02036773f, -0.04979866f, -0.01458407f, -0.03885077f, -0.01782742f, 0.03018081f, -0.00541635f, -0.01229620f, 
    -0.03932368f, 0.04339984f, -0.02977901f, 0.01511502f, 0.04658453f, -0.04525321f, -0.05504636f, 0.03275059f, 
    -0.02150995f, -0.01530194f, -0.02649423f, 0.01505822f, -0.00482515f, -0.02777579f, -0.00418402f, 0.01737792f, 
    -0.05462122f, 0.02600319f, -0.01069618f, -0.05448442f, -0.03350455f, -0.00701105f, 0.03528361f, -0.02011049f, 
    0.03842374f, 0.01357272f, -0.00993130f, 0.02513795f, -0.02838534f, -0.04947292f, -0.01731574f, 0.00027240f, 
    0.04924558f, 0.01180893f, 0.01565815f, -0.00699532f, 0.00517345f, 0.01765694f, -0.04496255f, -0.03066866f, 
    0.00214941f, 0.00257927f, -0.01134721f, -0.00021317f, 0.02402077f, -0.02244929f, 0.03055630f, -0.02973492f, 
    -0.05413687f, -0.02680375f, -0.00061264f, -0.03274745f, 0.02112909f, 0.02249374f, 0.03765456f, -0.01498437f, 
    0.00522311f, 0.00150248f, 0.01894358f, 0.02620322f, 0.00971948f, 0.03265055f, -0.00022734f, -0.02417372f, 
    -0.02951956f, 0.02030045f, -0.02127556f, -0.04403568f, 0.03566741f, -0.05218425f, -0.01682797f, 0.03790859f, 
    0.02844352f, 0.04331868f, 0.00526890f, 0.00705672f, -0.01489768f, 0.01959554f, -0.02455978f, -0.01514600f, 
    -0.04733767f, -0.03090954f, -0.00133600f, -0.02600576f, 0.01037867f, 0.03665600f, -0.02334744f, -0.04798372f, 
    -0.04554628f, -0.04141776f, 0.04286020f, -0.01692870f, -0.01239051f, 0.04574551f, -0.01924570f, -0.03322730f, 
    -0.05617436f, -0.04566144f, -0.05114925f, 0.00461534f, -0.00640460f, 0.00640499f, -0.05656806f, 0.03407250f, 
    0.03456980f, -0.04427124f, -0.05558128f, -0.05341652f, -0.00235272f, -0.00991933f, -0.02480416f, 0.03817879f, 
    -0.03746629f, 0.00913263f, -0.04604920f, 0.04592223f, -0.01412102f, -0.02541788f, -0.01887611f, 0.00248625f, 
    0.03871829f, -0.01593149f, 0.01384681f, -0.01988699f, 0.02795620f, -0.04564508f, -0.05292210f, -0.02698912f, 
    -0.03614452f, 0.04611713f, -0.01015557f, -0.01058292f, 0.01616671f, -0.02015762f, 0.02054693f, -0.04159653f, 
    -0.05246116f, 0.02619513f, 0.04861980f, 0.00245781f, 0.00783314f, 0.02410783f, 0.00668989f, -0.03992911f, 
    0.03979905f, -0.04759739f, -0.04439270f, -0.03295401f, -0.03065537f, -0.03068490f, -0.05622210f, -0.02247568f, 
    -0.04478176f, 0.02553729f, -0.02758848f, 0.00185608f, 0.04010740f, -0.01107025f, 0.03479516f, -0.02801595f, 
    -0.01084967f, 0.03550610f, -0.02942513f, 0.01211873f, 0.02834552f, -0.04642627f, -0.04540834f, 0.01617774f, 
    -0.02887339f, -0.01973378f, -0.01745669f, 0.04040099f, -0.00107806f, -0.01090798f, -0.05092248f, -0.01733911f, 
    0.04067502f, 0.00474489f, 0.04052623f, 0.01330689f, 0.00249446f, -0.04303530f, -0.04931033f, -0.04481936f, 
    0.03246642f, -0.00624184f, 0.02631395f, 0.02053900f, -0.04806089f, 0.04445178f, 0.01823859f, 0.03611634f, 
    -0.02149609f, -0.03658955f, -0.03721858f, -0.01084301f, -0.03825053f, -0.02813565f, -0.01148912f, 0.03262992f, 
    0.01261386f, -0.00376365f, -0.02245316f, -0.03319810f, -0.04989538f, -0.04551107f, -0.03837882f, 0.02245061f, 
    0.03573952f, 0.02572348f, -0.03911988f, 0.00404960f, -0.05363565f, -0.02984337f, 0.03449439f, -0.04874623f, 
    -0.04498183f, -0.01484193f, -0.00781490f, 0.02475721f, 0.02735093f, 0.02090488f, -0.00988136f, 0.03211857f, 
    -0.05321367f, 0.00928053f, 0.02728030f, -0.02446065f, -0.02413290f, -0.01668840f, -0.01872803f, -0.04973839f, 
    0.01623829f, -0.00556355f, 0.00546005f, -0.03734051f, -0.00190315f, -0.03944984f, -0.03530612f, -0.05051398f, 
    -0.01680481f, 0.02671645f, -0.00013467f, -0.04617462f, -0.01206383f, 0.02382470f, -0.05204648f, -0.02516425f, 
    -0.04399727f, -0.00294410f, -0.00476006f, -0.01672010f, 0.00572576f, 0.01692762f, -0.01062465f, 0.03241220f, 
    -0.03841152f, 0.00979508f, -0.04034420f, -0.00965947f, 0.02849143f, -0.05629110f, -0.00833550f, -0.00878486f, 
    -0.05660018f, 0.03348372f, 0.01467196f, -0.01653419f, -0.02333323f, -0.05386740f, -0.03079579f, 0.03788728f, 
    0.00228205f, -0.04694039f, -0.04610011f, 0.02947310f, 0.00919539f, -0.02743430f, 0.02997587f, 0.00690009f, 
    0.02728248f, 0.00526974f, -0.02784268f, 0.01728391f, 0.00750756f, 0.01892962f, -0.00346296f, -0.03358768f, 
    0.01944338f, -0.02301619f, 0.01403304f, -0.03470029f, 0.01341625f, -0.00445031f, -0.03513959f, -0.04288590f, 
    0.00399399f, 0.03549770f, 0.01920663f, 0.02599459f, 0.02687973f, -0.04512637f, -0.04869866f, 0.01662991f, 
    0.03028486f, 0.02957052f, 0.04037661f, -0.02306779f, 0.01803150f, -0.04930926f, -0.03034289f, 0.03749765f, 
    0.03665236f, 0.02300394f, -0.00307044f, -0.00397248f, 0.03283345f, 0.02951202f, 0.04169340f, -0.03117023f, 
    -0.01847472f, -0.00102719f, -0.04832997f, 0.04251705f, -0.02500869f, -0.02093134f, -0.04954921f, -0.03100944f, 
    -0.00902918f, -0.00492681f, 0.01531087f, 0.04668252f, -0.02063515f, -0.02479438f, 0.01086518f, -0.00757466f, 
    0.02568915f, -0.00774611f, -0.04441943f, 0.01027288f, 0.02127961f, 0.02196597f, -0.04414650f, 0.02786136f, 
    -0.04627873f, -0.00403933f, 0.00545662f, -0.02477264f, 0.05023741f, -0.01939902f, -0.02248790f, 0.03907054f, 
    0.02502342f, -0.01156028f, -0.02384982f, -0.04336024f, -0.01195194f, -0.00481049f, 0.04236466f, 0.01080564f, 
    0.02378107f, -0.02011007f, -0.03010414f, 0.04287331f, 0.00083289f, 0.03355044f, -0.02108515f, -0.04400264f, 
    -0.04298313f, -0.00472277f, 0.04265279f, 0.01172937f, 0.00605946f, -0.03460045f, 0.02136970f, -0.03753688f, 
    -0.01153277f, 0.03494832f, 0.00176204f, 0.02451148f, -0.04862658f, -0.03478407f, -0.04318085f, 0.03928994f, 
    -0.02261197f, 0.02017903f, -0.01313343f, -0.03472375f, -0.01265892f, -0.04217822f, 0.03013934f, -0.00038081f, 
    -0.03897817f, -0.00431352f, 0.03034335f, 0.02516933f, -0.03753297f, -0.02774939f, 0.00060028f, 0.01451071f, 
    -0.04046169f, -0.02174161f, -0.04174148f, 0.02405404f, 0.00193687f, -0.02969536f, -0.03629832f, -0.02384161f, 
    0.01297095f, -0.03561302f, -0.01039621f, 0.01838992f, -0.04906632f, 0.04044025f, -0.02160299f, -0.03614029f, 
    0.00946380f, 0.01394935f, -0.02155193f, 0.03900850f, 0.03876263f, -0.04083300f, -0.01374652f, -0.01718169f, 
    -0.03988019f, -0.05004539f, 0.01602520f, 0.04234467f, 0.01020114f, -0.02914484f, 0.00671833f, -0.05116965f, 
    -0.04448197f, 0.00825929f, -0.04694842f, -0.04875252f, 0.04914331f, -0.03927520f, -0.01568060f, -0.04569954f, 
    -0.00643588f, 0.01093045f, -0.00453371f, -0.03429399f, -0.05732281f, -0.04741957f, -0.03671723f, 0.01718104f, 
    0.01141790f, 0.00629787f, 0.02879306f, 0.03427931f, -0.01630909f, 0.02034553f, -0.01173238f, 0.02251223f, 
    -0.04530764f, -0.03253078f, -0.02187032f, -0.00448555f, 0.01148564f, -0.05153524f, 0.02041098f, -0.02552304f, 
    0.02267811f, 0.02163979f, 0.00117667f, -0.03402126f, 0.02929398f, -0.00511047f, -0.00580772f, 0.02739857f, 
    -0.00555191f, -0.01396752f, 0.00060966f, -0.02552794f, -0.04470758f, -0.04872186f, -0.00420074f, -0.01236321f, 
    -0.04356114f, -0.02809852f, -0.03227138f, -0.00444968f, -0.02089482f, 0.02779183f, -0.05065260f, -0.02524670f, 
    0.00838905f, -0.02860355f, 0.00367895f, -0.00539423f, 0.02086867f, 0.02528930f, 0.01108161f, 0.01369901f, 
    0.02529943f, -0.02856298f, 0.02987824f, 0.04075276f, -0.01268475f, 0.03333461f, -0.01905613f, 0.03327916f, 
    -0.00598885f, -0.02242740f, -0.03051479f, -0.00451208f, -0.02325737f, -0.04571622f, 0.00707968f, 0.03845787f, 
    0.04263873f, -0.04856404f, -0.01300611f, 0.04727926f, -0.04967894f, -0.03319328f, -0.02170595f, -0.01193992f, 
    -0.00673423f, 0.02036817f, 0.01763364f, -0.00540239f, -0.01591450f, 0.04708092f, 0.03267662f, 0.00382915f, 
    -0.02057885f, -0.01051702f, -0.03117112f, 0.03474077f, -0.01517578f, -0.03656057f, 0.01861922f, -0.05073233f, 
    0.00637129f, -0.00589952f, -0.01358183f, 0.02788829f, 0.02376542f, -0.03370606f, -0.02526823f, -0.02318528f, 
    -0.02273324f, -0.03074243f, 0.02189542f, -0.00636635f, -0.01420823f, 0.02116152f, 0.01772299f, -0.02757211f, 
    -0.04347772f, 0.01990260f, -0.04016173f, 0.01451944f, 0.01525817f, 0.04160479f, 0.02322815f, 0.00931399f, 
    -0.04111510f, 0.03891666f, 0.03699423f, 0.03666127f, 0.05037961f, -0.01713757f, -0.04493213f, -0.02577535f, 
    -0.02444427f, 0.04481196f, -0.00969762f, -0.00632140f, -0.01660502f, 0.03519270f, -0.02125987f, 0.00814255f, 
    -0.02854096f, -0.00237418f, -0.00302985f, 0.02321662f, 0.02183625f, 0.01878514f, -0.03189244f, 0.03994861f, 
    -0.01180567f, 0.03914695f, 0.01502209f, 0.01545162f, 0.01080890f, -0.00488758f, -0.03122758f, -0.02493889f, 
    -0.01275048f, -0.03158633f, -0.01305835f, 0.01957519f, 0.03371046f, 0.01326711f, 0.03658173f, -0.01731700f, 
    0.04806820f, -0.01592966f, 0.05763772f, 0.01281309f, -0.03452793f, -0.02525114f, -0.03324905f, -0.01558459f, 
    0.02923854f, 0.02245467f, -0.04679678f, -0.00948195f, 0.01448708f, 0.02297612f, 0.01903203f, -0.02454391f, 
    0.02860080f, 0.02961757f, 0.01804254f, 0.04662687f, 0.03364962f, -0.01084244f, -0.04598565f, 0.04718073f, 
    0.02632004f, 0.04199684f, -0.00295067f, -0.02633742f, 0.01591766f, -0.04831363f, -0.01022676f, -0.03955344f, 
    -0.00745761f, -0.02871372f, -0.03674890f, 0.02384004f, -0.01162629f, -0.05036210f, -0.00138483f, 0.01693667f, 
    0.00347609f, -0.03171039f, -0.01370169f, 0.01465787f, -0.03358343f, -0.01745493f, -0.01671644f, 0.04004319f, 
    -0.01365797f, -0.01578440f, -0.02236134f, -0.03288831f, -0.04171009f, 0.04593046f, -0.00679257f, 0.01372431f, 
    -0.01957867f, -0.01402601f, 0.02719264f, -0.04479666f, -0.04092521f, 0.00650895f, -0.01039194f, -0.03618977f, 
    0.04409254f, 0.00321169f, -0.02480354f, -0.05186100f, 0.03725891f, 0.04147343f, 0.00065760f, -0.03127002f, 
    -0.00773635f, -0.04882303f, 0.00735867f, -0.04939807f, -0.04915560f, -0.00117163f, 0.00870031f, 0.02266417f, 
    0.00566459f, 0.05974133f, -0.04013422f, 0.03451261f, -0.05514213f, 0.00255688f, 0.01019868f, -0.02392790f, 
    -0.04092377f, -0.03652567f, 0.02129960f, -0.05514711f, -0.01811775f, 0.02388099f, -0.03404023f, -0.04574642f, 
    -0.00214205f, 0.00612297f, -0.01157818f, -0.04378234f, 0.03605063f, 0.04132261f, -0.00105237f, -0.01202780f, 
    0.01258359f, -0.01321367f, 0.00739601f, 0.01922826f, 0.00763028f, 0.02482870f, -0.04343600f, 0.00024169f, 
    -0.00006438f, -0.04465722f, -0.01086734f, 0.00213242f, -0.04416192f, -0.00771015f, 0.02850227f, -0.02201574f, 
    0.03697138f, 0.02455810f, 0.04332410f, 0.00480297f, -0.01439577f, -0.03040517f, 0.04275915f, 0.00502415f, 
    -0.00343112f, -0.03028316f, -0.03356849f, -0.03283736f, -0.04486862f, -0.03293934f, -0.00551577f, -0.01069892f, 
    -0.03858017f, -0.01848286f, -0.03445897f, -0.02787150f, 0.00677620f, -0.01869243f, -0.00464883f, 0.01333588f, 
    0.01609145f, -0.04433211f, 0.01132868f, 0.00653261f, -0.01164745f, 0.01603049f, 0.04379723f, -0.02352428f, 
    -0.00827812f, -0.03306642f, 0.04770174f, 0.04795386f, 0.03722485f, -0.01003990f, 0.00726714f, -0.00376908f, 
    -0.00771687f, -0.02932240f, -0.01366571f, -0.01584564f, -0.01085527f, -0.04222966f, -0.04498098f, -0.02404961f, 
    0.00073762f, 0.03590202f, 0.00543197f, 0.04314455f, 0.03831578f, 0.02363667f, -0.00905662f, 0.00575643f, 
    -0.02814067f, 0.02921963f, 0.01613055f, 0.01058379f, 0.00269500f, 0.01029476f, -0.04813956f, -0.04201408f, 
    -0.00733397f, -0.01434867f, 0.01938075f, 0.02979927f, 0.02007541f, 0.00992454f, 0.00623791f, -0.02260803f, 
    0.01601968f, -0.00523224f, 0.03366751f, -0.05263767f, -0.02521687f, 0.00933213f, -0.03413001f, 0.02497932f, 
    -0.04720462f, -0.05926880f, 0.02632214f, 0.00489138f, 0.00316032f, -0.04042416f, -0.02310142f, -0.02060653f, 
    0.02158637f, 0.01768735f, 0.01750878f, 0.00284280f, -0.00473155f, -0.01160833f, -0.01640085f, 0.03124627f, 
    0.01386918f, -0.03697033f, -0.04406311f, -0.01504762f, -0.01454431f, 0.01199749f, -0.01032561f, -0.00164500f, 
    0.03495117f, -0.04524646f, 0.01578365f, -0.00032594f, -0.05341341f, 0.01304287f, -0.01710654f, 0.00664017f, 
    -0.04131550f, -0.05007223f, -0.04521057f, 0.02143882f, -0.03252956f, 0.01768785f, 0.00628481f, -0.02001934f, 
    0.03930524f, 0.03602382f, -0.02584579f, -0.05092277f, 0.03575315f, -0.00703987f, 0.04058989f, 0.01704246f, 
    -0.01785229f, -0.04443428f, 0.03714115f, 0.02018079f, -0.05330874f, 0.05922739f, -0.01890967f, -0.01597004f, 
    -0.02405800f, 0.01321125f, 0.00793550f, 0.01369013f, -0.02680616f, 0.03600572f, -0.02737988f, 0.00991262f, 
    0.01602745f, -0.00039370f, 0.00656981f, -0.01980115f, 0.03514362f, -0.00164280f, -0.03526290f, 0.04375760f, 
    -0.00523093f, -0.03732450f, -0.02561119f, -0.03150085f, 0.02317136f, 0.01718062f, -0.00922836f, -0.00792088f, 
    -0.03161350f, 0.00765221f, 0.03572086f, 0.00181093f, 0.04820250f, -0.01010201f, 0.00373342f, 0.00132284f, 
    -0.00883607f, 0.00861128f, -0.04961342f, -0.02701275f, 0.03732213f, 0.03364931f, -0.05060608f, 0.04353326f, 
    -0.02397664f, 0.00478011f, 0.02968640f, -0.03723148f, -0.03137109f, -0.02165678f, -0.01994250f, -0.04987805f, 
    -0.05341920f, -0.04647217f, 0.04689573f, 0.04614894f, 0.02014287f, 0.00389504f, 0.00186253f, 0.02002695f, 
    0.00408022f, -0.01039610f, 0.00378375f, -0.02145570f, 0.03107060f, 0.05097594f, 0.00045767f, -0.03058828f, 
    0.00097964f, 0.01321709f, 0.03632677f, 0.00400368f, -0.02045009f, -0.01039091f, 0.02571564f, 0.02825548f, 
    0.04166391f, -0.00512369f, 0.00503499f, -0.05361933f, -0.01731565f, -0.03299625f, 0.00407771f, 0.00171073f, 
    -0.01964409f, 0.03143141f, 0.04202887f, -0.04355800f, -0.05188394f, -0.00999789f, 0.03132195f, 0.00635806f, 
    -0.00239965f, -0.05910245f, -0.03927943f, -0.01702504f, -0.03261706f, -0.03777865f, -0.00764071f, -0.03736067f, 
    -0.04335885f, -0.01350962f, 0.01150579f, 0.03605004f, 0.02248849f, 0.02659893f, 0.02224724f, -0.00705534f, 
    0.01780091f, 0.00220087f, 0.02747585f, 0.03711841f, -0.04505689f, -0.04913102f, 0.00902172f, -0.04047110f, 
    -0.02793710f, 0.05786404f, 0.04391130f, 0.01815499f, -0.04424039f, -0.05173511f, 0.02489481f, -0.04542832f, 
    -0.00476166f, -0.00644548f, 0.01282007f, -0.04449693f, -0.01812692f, 0.04510457f, 0.04055813f, -0.01475570f, 
    -0.02884008f, -0.04444160f, 0.01094355f, -0.01434119f, -0.01594362f, 0.02522255f, -0.00394771f, 0.01513940f, 
    0.03729270f, 0.01150598f, -0.04378651f, 0.00157317f, -0.01632140f, 0.02752183f, -0.02387105f, -0.00759631f, 
    -0.00518018f, -0.03893531f, 0.04814150f, -0.04916880f, 0.03697318f, -0.03435635f, -0.04415076f, 0.03640318f, 
    0.00764905f, 0.01588139f, 0.03140723f, 0.01232112f, -0.04484297f, -0.00429970f, -0.02682247f, 0.03172176f, 
    0.01672260f, -0.00888725f, -0.02038964f, -0.02535147f, -0.01161021f, 0.00518756f, -0.03045458f, 0.04383105f, 
    0.00832890f, -0.03809679f, 0.05711291f, -0.02587246f, -0.01781246f, 0.00230920f, -0.04010471f, -0.04602394f, 
    -0.02926732f, 0.03358091f, -0.05529222f, -0.04942077f, 0.02605486f, -0.03948693f, 0.03150317f, 0.02229807f, 
    0.01479077f, 0.02168993f, -0.00797035f, -0.03892241f, 0.01897836f, 0.00377821f, -0.04810242f, -0.03000002f, 
    -0.03745890f, -0.02545998f, 0.01692618f, -0.01415574f, 0.04331368f, -0.01922313f, -0.01080571f, 0.03137261f, 
    -0.04460949f, -0.00980209f, 0.00948831f, -0.04009647f, 0.03669635f, 0.00747828f, 0.01776467f, -0.03709069f, 
    0.03516353f, -0.05027390f, -0.00837580f, -0.00547541f, -0.00408867f, 0.02884171f, -0.00758995f, -0.01182235f, 
    -0.01729479f, -0.05553040f, 0.02349515f, -0.05296542f, 0.02052051f, -0.00743531f, 0.04019325f, -0.01557192f, 
    0.01350465f, 0.03196815f, -0.03002428f, -0.03712597f, -0.02334515f, -0.04068247f, 0.02970076f, 0.04178505f, 
    0.03830708f, 0.02114184f, -0.04952770f, -0.00104817f, -0.04277160f, 0.03500968f, -0.00380393f, -0.00565938f, 
    -0.00694139f, 0.01094350f, -0.04444010f, 0.00075437f, -0.00746690f, 0.03067588f, -0.01027545f, 0.02921092f, 
    -0.01248313f, -0.02673112f, -0.05719478f, 0.01926447f, -0.01055368f, 0.01466723f, -0.02148307f, 0.02052880f, 
    -0.00772576f, 0.00193317f, 0.03589459f, 0.02971511f, 0.03482120f, -0.03092705f, 0.01764085f, -0.04479736f, 
    -0.05416618f, 0.03676299f, -0.05140260f, -0.01083249f, 0.01683615f, -0.03436065f, -0.04146309f, -0.02694816f, 
    0.01452240f, -0.03983918f, -0.03120149f, 0.01782107f, 0.03480779f, -0.00879538f, -0.03947685f, -0.01203400f, 
    -0.01394368f, -0.03652973f, 0.04212393f, -0.01346807f, -0.00100109f, -0.01301883f, 0.01545261f, 0.03011859f, 
    -0.00190786f, -0.00803511f, 0.04291785f, -0.00235826f, 0.02574434f, 0.02685340f, -0.02163805f, -0.01581272f, 
    0.02264822f, 0.01006785f, -0.01005063f, -0.04252011f, -0.01897301f, -0.02844403f, -0.03650836f, 0.02362154f, 
    0.03150330f, 0.01920751f, -0.00804977f, 0.03387833f, 0.01918450f, 0.00353986f, -0.02074590f, -0.02422738f, 
    -0.04025576f, 0.02645417f, -0.03871637f, 0.00440907f, 0.01443766f, -0.05959635f, 0.02073671f, 0.00742750f, 
    -0.01582706f, -0.03714352f, 0.02323265f, -0.01267645f, -0.04880524f, 0.02111928f, 0.02785303f, -0.05353337f, 
    0.01080132f, -0.01543899f, -0.04939013f, -0.05373940f, 0.03481514f, 0.01671508f, 0.01735577f, 0.02165088f, 
    -0.04696302f, 0.01632230f, -0.03827202f, -0.01839159f, -0.05122041f, -0.03394087f, -0.05796546f, -0.04533933f, 
    0.02725047f, -0.03397657f, -0.05175221f, 0.01099544f, 0.01645435f, -0.02856608f, -0.03005469f, -0.01433661f, 
    -0.02175002f, 0.01143768f, 0.00256957f, -0.05057547f, -0.01364512f, -0.03896470f, -0.03283614f, -0.04412552f, 
    -0.00564222f, -0.03971697f, -0.03640489f, 0.02480483f, -0.05204074f, -0.03865946f, -0.03977584f, 0.03693891f, 
    -0.02448338f, 0.02696541f, 0.04217124f, 0.01765051f, -0.05571490f, 0.00268342f, 0.00426349f, -0.01900326f, 
    -0.03730912f, -0.04179025f, -0.04223390f, -0.04589444f, 0.00493965f, -0.02583965f, -0.04978254f, 0.01995318f, 
    0.03219202f, -0.02436968f, 0.01661829f, -0.03251329f, -0.00836720f, 0.00799988f, -0.00310180f, 0.02928764f, 
    -0.03951308f, -0.02812583f, 0.01910602f, 0.03682020f, 0.03901945f, -0.05465477f, 0.01836327f, 0.01900421f, 
    -0.04817138f, -0.04128734f, -0.04184190f, -0.01819375f, -0.00130038f, 0.02965534f, -0.03891120f, 0.00007807f, 
    -0.04642190f, -0.01069793f, -0.05260347f, 0.01784940f, -0.02553100f, 0.02841900f, -0.05384303f, -0.02477501f, 
    -0.02933221f, -0.03828805f, 0.00161918f, -0.01826626f, 0.00372768f, -0.03799685f, -0.03077060f, 0.03330672f, 
    0.00681129f, 0.02108377f, 0.00771213f, 0.00866114f, 0.00744714f, -0.04572228f, 0.00737209f, -0.00915099f, 
    0.01402290f, -0.01929885f, -0.01295101f, -0.03591682f, -0.03811355f, 0.03079713f, -0.05699465f, 0.02477914f, 
    -0.01873635f, 0.00464906f, -0.05241556f, -0.00484292f, -0.01064587f, -0.01749672f, 0.02596162f, -0.04100549f, 
    0.02837739f, 0.04228839f, 0.03272728f, 0.00821197f, 0.01691056f, 0.00177185f, -0.00604710f, 0.00390240f, 
    0.01931927f, -0.01143346f, 0.04358433f, -0.04728574f, 0.00777217f, -0.00919039f, -0.00516416f, 0.00291529f, 
    0.02779977f, -0.06383200f, 0.00342921f, -0.00990695f, 0.00773067f, -0.05303650f, -0.00031991f, -0.06030699f, 
    0.03757530f, 0.00932350f, 0.03398375f, 0.00365054f, -0.02059078f, -0.01186034f, 0.02336130f, 0.04110567f, 
    -0.00667581f, 0.00469474f, -0.02148590f, -0.05455173f, 0.01212945f, -0.00746320f, -0.03273119f, 0.00279237f, 
    -0.04909737f, -0.04493998f, -0.04520214f, 0.03441734f, 0.00095838f, -0.04562496f, 0.02099408f, -0.00742470f, 
    -0.00489568f, 0.04747396f, 0.01413537f, 0.00832327f, -0.04349588f, 0.01465420f, -0.00062480f, 0.02177001f, 
    0.02588830f, -0.05219887f, -0.01847719f, -0.03618804f, -0.05369404f, -0.01130907f, -0.00179762f, -0.03623082f, 
    0.01735945f, -0.01767377f, -0.03258204f, -0.01123540f, -0.02448198f, -0.02288230f, -0.04886450f, -0.02066565f, 
    -0.02128990f, 0.03942388f, -0.04877046f, -0.02710480f, 0.03691753f, 0.03114163f, -0.05545001f, 0.01172477f, 
    -0.02331685f, -0.00033042f, -0.04088412f, 0.01426839f, -0.00637726f, -0.02146203f, -0.05255223f, -0.04183365f, 
    0.00213140f, 0.01193009f, 0.02961844f, -0.03094631f, 0.01333577f, 0.04237893f, -0.02541982f, -0.02661613f, 
    0.01596918f, 0.00908750f, -0.04834396f, 0.02406245f, -0.05034569f, 0.00065543f, -0.00583971f, -0.03974351f, 
    -0.04395772f, 0.04358166f, -0.01668911f, -0.03121169f, -0.02442931f, 0.03832932f, -0.05232035f, 0.01056233f, 
    -0.00311770f, 0.00052096f, -0.03639082f, -0.00576086f, -0.02358520f, -0.01357644f, -0.02237919f, -0.01156648f, 
    -0.04309167f, 0.00057007f, 0.03223768f, 0.01559547f, 0.00489735f, -0.05333582f, 0.03051188f, -0.02800997f, 
    -0.00695455f, -0.01131354f, 0.02381350f, -0.02361167f, -0.00404525f, -0.00967701f, -0.05641481f, 0.02740750f, 
    -0.01091134f, -0.03320299f, -0.00944654f, -0.01118507f, 0.01360704f, 0.00446366f, -0.04094087f, -0.05712527f, 
    0.18792689f, -0.12228900f, -0.09939421f, 0.02610345f, 0.23315583f, 0.18101537f, 0.05862000f, 0.04838572f, 
    0.09492002f, -0.02024608f, -0.00664987f, 0.11406986f, 0.09635279f, 0.15469924f, 0.10694698f, -0.21939020f, 
    -0.06797292f, 0.14826544f, 0.08305827f, 0.05693449f, 0.20526059f, 0.02684730f, 0.10484869f, 0.09000679f, 
    0.30470845f, 0.25889280f, -0.04015834f, 0.18697233f, 0.04612843f, 0.16804408f, -0.11701683f, 0.21701993f, 
    -0.11107652f, -0.01644376f, -0.04547268f, 0.06141786f, 0.05539456f, 0.08809266f, -0.12020419f, 0.14968793f, 
    0.05229853f, 0.02754812f, 0.03423212f, 0.09878714f, 0.00195220f, 0.11184137f, 0.11907155f, 0.12798902f, 
    0.18176654f, 0.22544818f, -0.22718678f, -0.08879725f, 0.14790148f, -0.03780980f, -0.01687133f, -0.11425815f, 
    0.14797480f, -0.06659165f, -0.10333718f, -0.14315286f, -0.14998260f, -0.09368845f, 0.03842467f, -0.11246529f, 
    0.09248675f, 0.02870638f, 0.18396468f, -0.03492594f, -0.06042683f, 0.05008274f, 0.23809037f, 0.05556356f, 
    -0.02081528f, 0.14204901f, 0.09547786f, 0.06751535f, 0.20878595f, 0.07150964f, -0.02029128f, 0.12536131f, 
    0.10924013f, 0.24765100f, 0.02834473f, -0.01328427f, 0.03487028f, -0.05988081f, 0.05845552f, 0.21089183f, 
    0.01278783f, 0.07741951f, -0.00746868f, 0.02707964f, 0.17336738f, -0.06676988f, 0.03744824f, -0.00835404f, 
    -0.01640518f, -0.20806567f, 0.21717407f, 0.14545435f, 0.06680609f, -0.14158745f, -0.01052752f, 0.02696128f, 
    -0.01423720f, 0.10161572f, 0.09073836f, -0.17584924f, 0.17265776f, -0.14835498f, 0.25159222f, 0.17970544f, 
    0.05988057f, 0.04470254f, -0.03897119f, 0.03930503f, -0.03727126f, 0.01869739f, 0.14550839f, 0.02295693f, 
    0.14602953f, -0.20229174f, 0.04770833f, 0.15419888f, 0.11359325f, 0.00669474f, -0.03605585f, 0.17715979f, 
    0.00304769f, 0.09063367f, 0.10821005f, 0.11485270f, -0.15967722f, -0.01015876f, -0.11360627f, -0.22049479f, 
    -0.08699211f, 0.00516052f, -0.00012005f, -0.12804303f, 0.00984166f, 0.01540785f, 0.06536766f, -0.04191012f, 
    0.01559916f, 0.11932994f, 0.10181032f, 0.07311744f, 0.00912260f, 0.02032803f, 0.02499302f, 0.03140463f, 
    0.05976093f, -0.00419456f, 0.00638809f, -0.08324721f, 0.17533866f, 0.15778455f, -0.21235093f, -0.14259571f, 
    0.00657652f, 0.16599689f, -0.16031402f, -0.00919417f, -0.06257760f, 0.04086693f, 0.09217221f, 0.14433286f, 
    -0.28586462f, -0.01585286f, -0.05772519f, -0.29469836f, -0.03425151f, 0.10577344f, 0.05257994f, 0.04269659f, 
    -0.04919265f, 0.04348363f, 0.05406610f, -0.03044159f, 0.17074180f, -0.03567537f, 0.03829116f, 0.01169142f, 
    0.05541113f, 0.01872919f, 0.09844835f, -0.03287141f, 0.09555153f, 0.00983376f, -0.06111151f, -0.11342560f, 
    -0.13962924f, -0.26692459f, -0.30440784f, -0.05293496f, -0.07548936f, -0.01641234f, -0.11895236f, 0.04742156f, 
    0.08029570f, -0.04374856f, -0.07138516f, -0.00755308f, 0.26223019f, 0.00278232f, -0.15477929f, -0.25370243f, 
    -0.09402264f, 0.08964127f, 0.07104556f, 0.03315472f, 0.05921867f, -0.06639908f, 0.10701019f, 0.17734402f, 
    -0.03107306f, -0.16907777f, -0.09396504f, -0.35755238f, -0.02088445f, -0.03181984f, 0.03586094f, -0.06037261f, 
    -0.00102010f, -0.01790929f, 0.06067052f, 0.10141952f, 0.40804842f, -0.12150746f, -0.19142686f, 0.02045087f, 
    0.06063594f, 0.04245266f, 0.12995951f, -0.05217148f, 0.03235769f, -0.01048474f, -0.00419116f, 0.16371828f, 
    -0.20431295f, -0.08973671f, 0.09011135f, -0.20917518f, -0.07436104f, -0.11431102f, -0.02747861f, 0.11690199f, 
    0.19277111f, 0.04188411f, 0.08600324f, 0.08544116f, -0.07453653f, 0.10250559f, 0.14294992f, 0.10125559f, 
    0.02290054f, 0.11033577f, 0.20618770f, 0.01035224f, 0.11930461f, 0.19088745f, 0.05131484f, 0.11480213f, 
    -0.02673738f, -0.26057267f, -0.04765895f, -0.03787828f, 0.04697151f, 0.00009875f, 0.06111662f, 0.10236859f, 
    0.22260886f, 0.03556044f, 0.02422279f, 0.00917313f, -0.13262929f, 0.18122938f, 0.16262943f, 0.14789271f, 
    0.09421810f, -0.01481121f, -0.04888552f, 0.06932088f, -0.10048715f, -0.05144668f, -0.05504847f, 0.08211233f, 
    0.06380760f, 0.39534986f, -0.28665370f, 0.05581233f, 0.26740664f, 0.07610539f, 0.02492228f, 0.18907574f, 
    0.10428593f, 0.24318510f, -0.02538628f, 0.06885211f, 0.12376444f, 0.06896570f, -0.04706793f, -0.04519612f, 
    0.04423651f, 0.12509450f, -0.01145628f, 0.17450891f, 0.17445484f, 0.18853889f, 0.02714475f, 0.13305570f, 
    -0.17036404f, -0.24967948f, -0.23842368f, -0.34162933f, -0.09118221f, -0.04534996f, -0.07110532f, 0.01819873f, 
    0.06769057f, 0.00945047f, 0.02449204f, 0.04988066f, -0.16812953f, -0.25495169f, 0.39292035f, -0.07918481f, 
    0.14430094f, -0.13010685f, 0.03057262f, -0.02151652f, 0.06096383f, -0.08346695f, -0.12607099f, 0.10706236f, 
    0.01340778f, -0.19385706f, -0.38473991f, -0.10102441f, -0.06085169f, 0.06906188f, 0.03417256f, 0.14567043f, 
    -0.11566687f, 0.14971796f, -0.02173852f, 0.20815033f, 0.03263030f, -0.01863534f, 0.26681355f, 0.04690268f, 
    -0.04344011f, -0.02392966f, 0.00732099f, 0.01264335f, -0.11944646f, 0.02016717f, 0.11078922f, 0.10570280f, 
    0.45948461f, -0.10123545f, -0.07986242f, -0.09973098f, -0.06333099f, -0.06815651f, -0.12785473f, -0.08115594f, 
    0.04295743f, 0.08193976f, 0.14722079f, 0.09812565f, 0.52345568f, -0.29048780f, 0.05355672f, 0.38270280f, 
    0.02908376f, -0.08544653f, 0.03392226f, -0.09801304f, 0.04087707f, 0.02189044f, 0.04131735f, 0.04669593f, 
    -0.03471866f, -0.01503912f, -0.00544950f, 0.00452233f, -0.03601369f, -0.03564472f, -0.04428557f, -0.05389764f, 
    0.01784987f, 0.03460874f, -0.02772583f, -0.04496327f, -0.01121391f, 0.02971152f, -0.00318538f, 0.01921504f, 
    0.00268124f, -0.03484429f, -0.02797369f, 0.03840891f, -0.05779343f, 0.02988875f, 0.03200649f, 0.03191512f, 
    -0.03809213f, 0.04216399f, -0.04151268f, 0.01710181f, -0.04672580f, -0.00794216f, -0.04646856f, -0.02677750f, 
    -0.02447743f, -0.00206370f, -0.02527612f, 0.01292367f, 0.03363387f, -0.00666647f, 0.00397605f, -0.02623272f, 
    -0.03763676f, -0.00433082f, 0.00710802f, -0.03378594f, -0.00696324f, -0.05114087f, -0.01086392f, 0.01681635f, 
    -0.04707476f, -0.04582988f, 0.03055505f, 0.02915907f, 0.03901011f, 0.01783768f, 0.01383811f, 0.04139095f, 
    0.03289088f, -0.03164219f, 0.00596699f, -0.00150263f, -0.03504296f, -0.00610481f, -0.01047926f, 0.02429558f, 
    0.02459204f, -0.04782396f, -0.03025625f, 0.02971324f, 0.03906372f, -0.00067487f, 0.01049775f, -0.04036035f, 
    -0.04214434f, -0.02406577f, -0.00238848f, 0.00552009f, 0.02230975f, -0.03434428f, 0.03547326f, 0.00862260f, 
    0.02178013f, 0.03876660f, -0.02748238f, 0.01189382f, -0.03873331f, -0.00602333f, -0.02701773f, 0.02234047f, 
    -0.03632183f, -0.04627050f, 0.03593602f, 0.00445470f, -0.01459485f, -0.01139883f, -0.01121946f, -0.04500334f, 
    0.02567896f, -0.02874075f, -0.05172550f, -0.00344988f, 0.00116596f, 0.02918147f, -0.03425681f, -0.01992187f, 
    -0.05344251f, -0.02484588f, 0.00558004f, 0.02899378f, 0.02658207f, -0.00529831f, 0.00613309f, -0.03363816f, 
    -0.03821685f, 0.05635523f, -0.01692631f, -0.01005090f, -0.00109597f, -0.03267109f, 0.03721610f, 0.00779023f, 
    0.00634120f, -0.03416969f, 0.04225068f, -0.05754721f, -0.02578056f, -0.03795967f, 0.02257808f, 0.00925360f, 
    -0.01932597f, 0.00480057f, -0.00522410f, -0.03650465f, -0.02671611f, -0.02792873f, -0.04574410f, 0.03696994f, 
    0.02770294f, -0.04574809f, 0.00446374f, -0.03882708f, -0.04343880f, -0.01569354f, 0.03319492f, 0.01656857f, 
    0.01365691f, -0.04683216f, -0.03898026f, -0.00488757f, -0.04966318f, -0.01287723f, 0.00077650f, -0.05481267f, 
    0.02448736f, -0.00142288f, 0.01362271f, 0.03753631f, 0.00581527f, -0.03084850f, 0.00960471f, -0.01531288f, 
    0.03563501f, 0.02426448f, 0.00990449f, 0.03046216f, -0.01714578f, 0.01528422f, -0.00672708f, -0.03661167f, 
    0.01458569f, -0.00452984f, -0.01296647f, 0.02905580f, -0.03725746f, 0.00952311f, 0.04766614f, 0.00673298f, 
    -0.00918718f, 0.02563920f, 0.03703263f, -0.00381559f, -0.04341682f, 0.02160885f, -0.05678772f, -0.02274949f, 
    -0.03383911f, -0.01472266f, 0.02315481f, -0.05401449f, -0.02667402f, 0.01006822f, 0.04800866f, -0.00603516f, 
    0.01065520f, 0.00471484f, -0.05265575f, 0.03525625f, -0.04408132f, -0.02850370f, -0.03252667f, 0.03692259f, 
    -0.04776783f, -0.02662033f, 0.05035029f, -0.00490519f, 0.01980946f, 0.00900020f, -0.02004831f, 0.04129004f, 
    0.00131029f, -0.03106989f, 0.00842236f, -0.04657645f, 0.01874942f, -0.04789274f, -0.04797493f, 0.00200633f, 
    -0.01173318f, 0.02479791f, 0.01538498f, 0.00346838f, 0.00534286f, -0.05034877f, 0.02734601f, -0.02855331f, 
    -0.01054310f, -0.04631381f, -0.02285517f, -0.00232332f, -0.00199732f, 0.04524968f, 0.04002346f, 0.04280981f, 
    0.03442785f, 0.03709083f, -0.03208216f, 0.00729070f, -0.03480424f, 0.02048089f, -0.04532312f, -0.01326520f, 
    0.03424102f, 0.03813495f, 0.01668474f, 0.05129568f, -0.00873595f, 0.00007121f, -0.01116773f, -0.01017466f, 
    0.03556994f, 0.00659307f, 0.03103625f, 0.02203616f, -0.04491135f, 0.02289109f, -0.04429574f, -0.01932215f, 
    -0.03279102f, -0.04056662f, 0.03179162f, -0.05204955f, -0.01372305f, -0.04092802f, 0.02537569f, 0.00832208f, 
    -0.02601787f, -0.03090406f, -0.03447111f, -0.01725084f, 0.01925983f, 0.00809487f, -0.02919876f, -0.02983878f, 
    -0.02864452f, 0.01201040f, 0.03136288f, -0.00779886f, -0.02952280f, 0.00330084f, 0.03530425f, 0.01460359f, 
    0.02882170f, 0.01401063f, -0.05379500f, 0.03480533f, -0.01398464f, -0.01566843f, -0.02102013f, 0.03148197f, 
    -0.04095949f, 0.00409073f, 0.02832456f, 0.03219315f, -0.00996656f, 0.00169138f, 0.04430753f, -0.00666654f, 
    -0.02246602f, -0.05517849f, 0.04196794f, -0.00022525f, -0.03671158f, 0.02853202f, 0.04147493f, -0.02902081f, 
    0.03680900f, -0.01565037f, 0.03681039f, 0.00725470f, -0.02910438f, 0.00700122f, 0.03758490f, -0.01696219f, 
    -0.03966957f, 0.00488805f, -0.03034853f, -0.01940423f, -0.03639911f, -0.01517525f, -0.00816881f, 0.03801478f, 
    0.00170928f, 0.01572119f, -0.01405858f, 0.00391327f, 0.00581992f, 0.04232448f, -0.03230079f, -0.03454404f, 
    -0.01277563f, -0.02913764f, 0.04786672f, -0.04096966f, -0.03378239f, -0.00624304f, 0.01917795f, 0.03280019f, 
    0.02004136f, -0.02764214f, 0.04372290f, 0.03208541f, -0.00084039f, 0.01189957f, -0.04340602f, -0.03268946f, 
    0.01099553f, -0.05237855f, -0.05905915f, 0.04591986f, 0.03123788f, -0.05547651f, 0.01559369f, -0.05457063f, 
    0.01543367f, -0.05226469f, -0.03260047f, -0.02273291f, 0.01962771f, -0.03966487f, -0.01953803f, -0.02080680f, 
    -0.04768673f, 0.02669543f, 0.03286400f, -0.01939722f, -0.03260792f, -0.02917181f, -0.03286277f, -0.03557352f, 
    -0.03658264f, 0.01284875f, 0.02746278f, -0.01731706f, 0.04233773f, 0.03673076f, 0.03569200f, 0.01915107f, 
    -0.02087636f, -0.04825530f, 0.01446482f, -0.01976825f, -0.04856913f, -0.04734424f, -0.02788462f, -0.01590854f, 
    -0.17218763f, 0.02818681f, -0.17695837f, 0.14438194f, 0.05571736f, 0.03823977f, 0.03342608f, -0.19346920f, 
    0.27137518f, 0.06848419f, 0.03955011f, -0.13428298f, -0.25945315f, 0.10012677f, -0.14294234f, 0.17799699f, 
    0.06626728f, 0.00444847f, -0.03545553f, 0.02222166f, 0.06375825f, -0.00210139f, 0.00643993f, -0.19343346f, 
    -0.22180462f, 0.01094843f, -0.21518217f, 0.17587763f, 0.05368127f, -0.22014059f, 0.01337951f, 0.08563823f, 
    -0.01440526f, -0.01090390f, -0.06166495f, 0.04646486f, -0.49376050f, 0.00035756f, -0.00174972f, 0.02505803f, 
    -0.01616569f, 0.00281647f, 0.19612499f, 0.03982759f, -0.05439336f, 0.02228024f, -0.01979565f, -0.09085434f, 
    -0.04976381f, 0.00122952f, 0.16876668f, -0.17532478f, 0.16456552f, -0.04598957f, -0.04336562f, -0.10653459f, 
    0.08811378f, 0.00948976f, 0.04036264f, 0.01703501f, 0.25353262f, 0.05517873f, 0.14070208f, -0.14999636f, 
    0.05451682f, 0.01822917f, 0.00381063f, 0.28104192f, -0.01198859f, -0.10504369f, -0.10767122f, 0.04958403f, 
    -0.19834559f, 0.18472628f, -0.00888040f, -0.18540253f, -0.12378531f, 0.27869293f, -0.02451302f, -0.00675052f, 
    0.15266153f, 0.00982504f, -0.05601460f, 0.04227326f, 0.07307303f, 0.01494683f, -0.01393363f, 0.14541624f, 
    0.11629824f, 0.11483984f, 0.01929729f, -0.06752107f, 0.07752360f, 0.03982019f, 0.02258877f, -0.03310878f, 
    -0.00488213f, -0.05105852f, -0.01740529f, -0.27118200f, 0.07654680f, -0.04376710f, -0.05093954f, 0.00082852f, 
    -0.04356084f, 0.08815169f, 0.06797245f, -0.01616266f, 0.08030521f, -0.17563961f, -0.14469354f, -0.20485507f, 
    0.11655442f, 0.02636875f, -0.01853419f, 0.02624904f, 0.02367934f, -0.06156661f, 0.10750116f, 0.00463574f, 
    -0.23128785f, 0.01715704f, -0.03287401f, 0.02602338f, -0.14181624f, 0.11932947f, 0.19896206f, 0.16705625f, 
    -0.01096654f, -0.03272205f, 0.04217385f, -0.03990037f, 0.11876966f, -0.04404992f, 0.18642540f, -0.04562635f, 
    0.00517598f, -0.08528163f, -0.04742638f, -0.10024031f, 0.04097523f, -0.17448933f, 0.03137974f, 0.10669979f, 
    -0.00818980f, 0.17957437f, 0.03178263f, 0.22255114f, 0.04941806f, -0.17600745f, -0.00008542f, 0.00983806f, 
    -0.08559621f, -0.06687331f, 0.12359568f, -0.00108874f, 0.42645705f, -0.03534287f, 0.12685536f, -0.11190528f, 
    0.11327971f, 0.02184171f, -0.00594478f, -0.00568938f, -0.07345531f, -0.01599929f, 0.07364864f, -0.02205300f, 
    0.22501868f, 0.24339136f, -0.00568659f, 0.30404294f, 0.03674859f, 0.09892313f, 0.05046397f, 0.17071442f, 
    -0.09392940f, -0.03844731f, 0.06322653f, 0.09025163f, -0.02814066f, -0.15969220f, -0.17616102f, 0.09983802f, 
    0.11259805f, -0.00732789f, 0.10691468f, 0.04644780f, -0.03692439f, -0.14346857f, -0.14706539f, -0.24068926f, 
    -0.06835144f, -0.12362026f, 0.02193645f, 0.24598914f, -0.12565100f, -0.11848963f, 0.23727436f, 0.07997284f, 
    -0.18678914f, 0.00129254f, 0.18258652f, -0.00122656f, 0.29494613f, -0.02861405f, -0.06514221f, 0.26610708f, 
    0.01876714f, 0.01827075f, -0.08149575f, 0.04694768f, -0.04520645f, 0.05129649f, -0.09280764f, -0.04909336f, 
    -0.19677204f, -0.02415546f, 0.20651780f, 0.62159401f, -0.16683024f, -0.05479935f, 0.11777557f, -0.01656546f, 
    0.00158041f, 0.04202767f, 0.01898498f, 0.06082909f, 0.18895198f, 0.12719044f, 0.27506942f, -0.10774814f, 
    -0.14658673f, 0.11269840f, 0.02837094f, 0.12627175f, -0.11573524f, -0.01829925f, -0.01320740f, 0.08604055f, 
    0.17053278f, 0.10805590f, 0.06264023f, -0.20343041f, 0.07116389f, -0.01766508f, -0.03155196f, -0.08529127f, 
    0.03148029f, 0.01983627f, 0.07081887f, -0.01232888f, -0.17190820f, 0.26706830f, -0.24445470f, 0.09705126f, 
    0.05227851f, -0.07771626f, -0.03269953f, 0.03105468f, -0.22257350f, -0.12597881f, -0.06341713f, -0.00425197f, 
    0.12567355f, 0.05456484f, -0.20914944f, 0.19883636f, -0.10142022f, -0.00007050f, 0.00789721f, 0.16158444f, 
    -0.18146291f, 0.04251250f, 0.08148974f, -0.04619720f, 0.20807011f, -0.10011534f, -0.07775059f, -0.02487330f, 
    0.20069236f, -0.00772634f, -0.01830476f, -0.01944868f, 0.06484921f, 0.01394471f, 0.08040640f, 0.01404036f, 
    0.29349056f, -0.19018738f, -0.09205279f, 0.09098818f, -0.03661087f, 0.02615810f, 0.02597595f, -0.07100806f, 
    0.16174117f, 0.13014038f, 0.03861229f, -0.00682967f, 0.00146112f, 0.11146048f, -0.34493214f, 0.12553324f, 
    0.21492326f, -0.00661403f, 0.03503358f, -0.21522784f, 0.17201184f, 0.20945705f, 0.14738438f, 0.08785989f, 
    0.07360847f, 0.23298492f, 0.39446083f, 0.37103987f, 0.00588356f, 0.07648993f, 0.03740398f, 0.06255987f, 
    -0.05514078f, 0.05559349f, -0.05430965f, -0.12550472f, 0.05639064f, 0.06539981f, 0.22254311f, -0.33516812f, 
    0.03852507f, 0.00023524f, 0.02215136f, 0.07446240f, -0.14301491f, 0.04276324f, 0.04835856f, -0.03985438f, 
    -0.11347940f, -0.23207776f, 0.17107782f, 0.15050471f, -0.07475210f, -0.06622348f, 0.04669589f, 0.01073140f, 
    0.06641287f, -0.00825097f, 0.03218447f, 0.17615440f, -0.09792832f, 0.02300974f, -0.18065044f, -0.26412484f, 
    0.12433580f, 0.11404904f, 0.08700769f, -0.00346058f, 0.00085652f, 0.06284899f, 0.00860739f, -0.00964800f, 
    0.03540754f, -0.10722969f, 0.19198240f, 0.13742958f, 0.00109625f, -0.04208670f, 0.03005416f, -0.07392602f, 
    0.06773678f, -0.02312512f, -0.06074692f, 0.03792677f, -0.05584496f, -0.11189329f, 0.14160888f, -0.20601024f, 
    -0.00324098f, -0.00987225f, 0.09771060f, -0.01699045f, 0.01031390f, 0.03856028f, 0.00140658f, 0.15079814f, 
    0.07829005f, -0.04909294f, 0.03644945f, -0.02045515f, -0.05123594f, -0.19059612f, -0.17928500f, 0.11065175f, 
    0.04445997f, -0.01247817f, 0.05153409f, -0.04715398f, -0.18822721f, 0.02765874f, 0.04460019f, 0.15603794f, 
    0.01913084f, 0.05800556f, -0.14465418f, -0.13947874f, 0.13044114f, -0.17899328f, 0.06354044f, 0.05537663f, 
    0.01604894f, 0.39315957f, -0.25345361f, -0.03992969f, 0.00300926f, -0.00525906f, -0.00514176f, -0.16590779f, 
    0.05913732f, 0.01472631f, 0.03768906f, -0.00069642f, -0.07532839f, -0.07537080f, -0.19383317f, -0.16047671f, 
    -0.07474034f, 0.16673124f, -0.10189709f, -0.07157335f, -0.05837993f, -0.04448836f, -0.10508183f, 0.06669655f, 
    -0.04871428f, -0.06604145f, 0.20829560f, 0.02051741f, -0.08865905f, 0.01417852f, 0.05829214f, 0.04890656f, 
    0.08275227f, -0.02669243f, 0.19649924f, 0.05479324f, 0.11768247f, -0.14966778f, -0.04397380f, 0.09026164f, 
    0.11001632f, 0.02754908f, -0.09252138f, -0.07835677f, 0.21357362f, 0.05465538f, -0.07269484f, 0.13445044f, 
    0.15089251f, 0.11913618f, -0.02093977f, 0.29880905f, -0.04043736f, -0.05367290f, -0.08115173f, 0.03205041f, 
    0.04013050f, 0.21111315f, -0.04248551f, 0.21494687f, 0.23071720f, -0.09602445f, 0.11273798f, 0.11867437f, 
    -0.15001410f, -0.03941529f, -0.06154053f, -0.03492085f, -0.00998800f, 0.04243991f, 0.04006335f, 0.18557070f, 
    -0.03059142f, -0.03014022f, -0.06623358f, 0.07842029f, 0.16314644f, 0.08112322f, 0.02328872f, 0.06490880f, 
    0.06386115f, 0.15249406f, 0.06346472f, 0.01237934f, -0.12385178f, -0.02557957f, 0.05915471f, 0.25847861f, 
    -0.22981010f, -0.03369613f, 0.04440745f, -0.03665848f, 0.16691601f, -0.00362580f, -0.02040488f, 0.05155106f, 
    0.05130821f, 0.07770082f, -0.16576216f, -0.10498851f, 0.00379344f, -0.03772954f, -0.31573597f, -0.10380572f, 
    -0.01381460f, 0.06997579f, 0.07698176f, 0.08695538f, 0.03607700f, -0.09678593f, 0.34797180f, 0.09149777f, 
    0.01508312f, 0.06764984f, 0.06986864f, 0.08720449f, 0.01674803f, 0.00845483f, -0.03566337f, -0.03407278f, 
    -0.17685412f, 0.11994603f, 0.15325494f, -0.05560406f, -0.04556899f, 0.18056221f, 0.10750983f, 0.06226737f, 
    0.00084036f, 0.05267755f, -0.05047477f, 0.03721074f, -0.11496399f, 0.06955061f, 0.20522353f, 0.26019418f, 
    -0.07951765f, -0.06100911f, 0.01425879f, 0.04328233f, -0.01269843f, -0.00674608f, 0.00786633f, -0.15857202f, 
    0.50822639f, 0.21549416f, -0.20556267f, 0.26936746f, 0.04572207f, 0.02450669f, -0.01033372f, -0.11287455f, 
    0.10760352f, -0.02007707f, -0.05144985f, 0.02775050f, -0.06784510f, 0.04207085f, 0.09030028f, 0.07252434f, 
    -0.11434098f, -0.04149643f, -0.02522661f, -0.12161399f, 0.04595708f, -0.00252311f, 0.09073311f, 0.02468580f, 
    0.01000542f, 0.37059456f, 0.22296467f, -0.00918387f, -0.10290948f, 0.20534350f, -0.03492440f, -0.21832675f, 
    0.04192508f, 0.03272658f, 0.03811355f, 0.09450355f, 0.09461529f, 0.04113781f, -0.11886624f, 0.14942135f, 
    -0.02902409f, -0.03285073f, -0.07121867f, -0.05180007f, 0.01563548f, -0.01143932f, -0.00046785f, 0.00713487f, 
    -0.29028928f, 0.08760794f, -0.01359638f, -0.13436618f, 0.11844305f, 0.15063299f, 0.10401416f, -0.14597481f, 
    0.06803609f, -0.07151025f, -0.02412265f, 0.02493221f, -0.37405792f, 0.17575116f, 0.09679789f, -0.04664383f, 
    0.06425142f, -0.06274872f, -0.04138046f, 0.12245899f, -0.04295924f, -0.03320648f, 0.12791704f, -0.02282124f, 
    0.04624508f, -0.28731620f, 0.21393812f, 0.18847254f, 0.12054696f, 0.08739484f, 0.10408924f, -0.17372605f, 
    -0.00697274f, -0.02431250f, 0.04629930f, -0.02014153f, 0.08877774f, 0.03682780f, -0.00334654f, 0.04718122f, 
    -0.09537862f, 0.09427356f, 0.02736990f, -0.08453807f, -0.05041897f, -0.04979784f, -0.06037752f, -0.02255544f, 
    0.23522781f, 0.16578561f, 0.16021630f, 0.00019725f, -0.04746234f, -0.03808632f, 0.06418788f, -0.15128079f, 
    0.11660327f, 0.08396697f, 0.15454081f, 0.11857510f, -0.05953433f, 0.12391546f, 0.25492731f, -0.12577014f, 
    -0.07661106f, -0.03139262f, 0.01688416f, -0.03708501f, -0.01194478f, 0.04604190f, 0.17174989f, -0.11940967f, 
    -0.00352547f, 0.09612413f, -0.05681938f, 0.20674418f, -0.10966680f, -0.02137001f, 0.00425787f, 0.01121037f, 
    0.03518070f, -0.18401469f, -0.02734504f, -0.04898670f, 0.12839338f, -0.15530948f, 0.04712698f, 0.09490016f, 
    -0.10824054f, -0.02723402f, -0.26809168f, -0.00096135f, -0.09068587f, -0.06018743f, 0.01528185f, -0.14857361f, 
    -0.26962358f, 0.23755488f, 0.03037367f, -0.22025897f, 0.15406385f, 0.12988502f, -0.00935544f, -0.04049689f, 
    0.12117460f, 0.10263589f, -0.07985462f, 0.02440377f, 0.28733978f, -0.06738328f, 0.20388475f, 0.05746953f, 
    0.15995690f, 0.07107918f, 0.05870571f, 0.08093334f, -0.00655904f, 0.06107160f, 0.05316212f, -0.01342887f, 
    -0.04092696f, 0.20802276f, 0.37850848f, -0.04044727f, -0.00512144f, -0.01554710f, -0.03660761f, 0.02790621f, 
    0.08942363f, 0.14922440f, -0.14422213f, 0.08319026f, 0.11629598f, -0.11804570f, -0.05245728f, 0.09736408f, 
    0.05300304f, 0.02495964f, -0.02703932f, -0.09569599f, 0.02200674f, 0.03148875f, 0.06799340f, -0.04473710f, 
    -0.37879330f, 0.21696366f, 0.05891215f, -0.22610205f, -0.04336608f, 0.16872582f, 0.04600848f, 0.01539113f, 
    -0.04702055f, 0.04487491f, -0.00537780f, -0.14800267f, -0.59882408f, 0.18355729f, 0.28091022f, -0.17421627f, 
    0.13774237f, -0.03023416f, 0.14517200f, 0.00087459f, 0.02414691f, -0.14839643f, 0.09732439f, -0.08583168f, 
    0.00948365f, 0.42179865f, 0.07910162f, -0.13424462f, 0.10299031f, 0.03669333f, 0.14456224f, -0.00577039f, 
    0.18064563f, 0.14893165f, 0.14868201f, 0.18490684f, 0.07136060f, 0.08952238f, 0.06910419f, -0.13533013f, 
    0.00311492f, -0.04792732f, 0.05880302f, 0.21733405f, -0.02219338f, 0.14826295f, -0.00840826f, -0.01052344f, 
    0.07805672f, -0.14756304f, -0.48786896f, 0.06342025f, 0.02345329f, 0.05401646f, -0.14115310f, -0.03198455f, 
    0.00907732f, 0.07795969f, -0.09779461f, 0.02739176f, -0.01609149f, -0.06277942f, 0.09797752f, 0.05043092f, 
    0.20343067f, 0.09682768f, 0.03921574f, 0.00025327f, 0.13692936f, -0.12005442f, 0.04815219f, 0.12897947f, 
    0.12455619f, -0.04070993f, -0.00576732f, -0.34519681f, 0.33790940f, -0.06591384f, 0.21153814f, -0.14742608f, 
    0.05554002f, -0.09550769f, -0.08236980f, -0.00009009f, -0.22914410f, 0.20750138f, 0.08509431f, 0.00441136f, 
    0.01662533f, 0.16193061f, 0.02260216f, 0.03019722f, -0.25441885f, 0.02054533f, 0.10561962f, 0.03241964f, 
    -0.61638951f, 0.02322477f, 0.01638334f, -0.21957719f, -0.08949801f, 0.00217282f, -0.24637988f, -0.15445939f, 
    0.00141407f, -0.15710908f, 0.14310555f, -0.08083285f, 0.13492379f, -0.08780856f, 0.09034938f, -0.12803899f, 
    -0.00016628f, -0.05374834f, -0.06010206f, 0.07432459f, 0.23864171f, 0.16694836f, 0.10802078f, 0.02015662f, 
    -0.03721129f, -0.14034805f, -0.01129238f, 0.05375505f, 0.08108147f, 0.03428780f, -0.04748524f, 0.09021416f, 
    -0.01478775f, 0.00789895f, -0.02975907f, -0.11602274f, 0.31376234f, -0.36702305f, 0.18583508f, -0.09226996f, 
    -0.01295878f, 0.13677925f, -0.09791273f, 0.11177843f, -0.01781011f, -0.01768335f, 0.08965515f, 0.06267013f, 
    -0.08787329f, -0.04080114f, -0.02662588f, 0.03317477f, -0.02519155f, 0.04884230f, 0.09654082f, 0.22140010f, 
    0.05595710f, -0.21934760f, 0.14860858f, -0.18244666f, -0.05247832f, 0.00695708f, -0.13915324f, -0.15086360f, 
    -0.10796708f, 0.06242283f, -0.01694346f, -0.08575071f, 0.12219128f, 0.09083593f, -0.00611194f, -0.16952805f, 
    0.14949907f, 0.12320744f, -0.01318117f, 0.07120496f, 0.05935934f, 0.08555061f, -0.09258617f, 0.04939232f, 
    0.15861188f, 0.17728446f, 0.17153521f, 0.10168780f, 0.38032934f, -0.12996435f, -0.15563031f, -0.30526087f, 
    0.12261285f, 0.12829119f, 0.19970745f, -0.05952764f, -0.03693290f, 0.03623391f, 0.02741327f, -0.05143822f, 
    -0.12290848f, 0.03945640f, -0.10857436f, 0.19234529f, -0.09081975f, 0.01421719f, -0.05139076f, -0.06093977f, 
    -0.15753628f, 0.19286162f, -0.10734707f, 0.02073530f, -0.01484075f, -0.14374430f, 0.05321969f, 0.07331055f, 
    0.09236826f, 0.18894337f, -0.06705961f, 0.23315734f, 0.05898930f, 0.19452156f, 0.06600785f, 0.17289443f, 
    0.32955757f, -0.24576846f, -0.06527368f, 0.21528175f, 0.10904355f, -0.06929169f, 0.10727014f, 0.13158022f, 
    0.00498674f, 0.19942255f, -0.17831908f, -0.01005996f, 0.14390154f, 0.06387848f, -0.28362283f, 0.11071584f, 
    -0.07636419f, 0.12139590f, 0.23744519f, -0.11106084f, 0.07146986f, 0.23513663f, 0.12981363f, 0.01253181f, 
    0.26064688f, 0.20472640f, 0.23543230f, 0.07029595f, -0.08531357f, -0.02024810f, -0.00616973f, -0.08624674f, 
    0.16266267f, 0.03077105f, 0.02323427f, 0.06662994f, 0.44403070f, -0.00565451f, 0.10582752f, 0.15081806f, 
    -0.02368413f, -0.01161071f, 0.06246277f, 0.15703997f, 0.05290083f, -0.08331202f, 0.08710270f, 0.15667590f, 
    -0.14340173f, 0.18702066f, -0.07894678f, -0.12920080f, -0.01910030f, 0.21083032f, -0.02640732f, 0.15640026f, 
    0.04664771f, -0.04562292f, 0.05525680f, -0.05891698f, -0.00662808f, 0.09246064f, 0.27717474f, -0.29295990f, 
    0.15872185f, 0.02699079f, 0.02850657f, 0.06053430f, 0.05808811f, 0.09865708f, 0.00621950f, 0.19002724f, 
    -0.01636835f, -0.15937880f, -0.05963696f, -0.17314367f, 0.02345846f, 0.12207967f, 0.01565869f, 0.12194449f, 
    -0.07637349f, -0.07696693f, -0.07388370f, -0.18698785f, 0.01242010f, -0.04308080f, -0.12437215f, 0.03933651f, 
    -0.04959900f, -0.00139821f, -0.04648734f, 0.07442068f, 0.03730093f, 0.02409686f, -0.10425921f, 0.33534959f, 
    0.26078087f, -0.04568346f, -0.10181739f, -0.21923354f, 0.13508448f, 0.02806310f, -0.03169177f, 0.03681822f, 
    0.11326437f, 0.12118729f, -0.02759464f, 0.06751640f, -0.04925879f, 0.42895526f, 0.11549329f, -0.08792616f, 
    0.04981481f, 0.02125015f, -0.02269246f, -0.04989110f, 0.30414233f, -0.08168391f, -0.11071537f, 0.05655998f, 
    0.09968667f, 0.27441615f, 0.11291488f, 0.06756344f, -0.05203222f, 0.01247817f, 0.03068959f, -0.05790277f, 
    0.11819098f, -0.00431928f, 0.05499312f, -0.02712642f, -0.52458346f, 0.05402908f, -0.09056010f, 0.06028162f, 
    -0.14056589f, 0.09221745f, 0.00222531f, -0.12369496f, 0.06480046f, 0.09258820f, 0.09083757f, 0.18650192f, 
    -0.19185917f, -0.12961194f, -0.00782342f, -0.05235399f, -0.32248750f, -0.18813802f, 0.15933585f, -0.34725079f, 
    0.00765205f, -0.33246446f, -0.16587520f, -0.22174719f, 0.25853717f, -0.10457033f, -0.17568724f, 0.11974702f, 
    -0.00118064f, -0.06643584f, -0.06122958f, 0.06698493f, -0.03587442f, 0.02641584f, 0.14130397f, -0.12151121f, 
    0.53690404f, 0.01383296f, 0.02523554f, 0.06159174f, 0.06591328f, -0.06578181f, 0.18255907f, 0.10172706f, 
    -0.05560945f, 0.00811062f, -0.07081432f, 0.02432202f, 0.24393073f, -0.12651099f, -0.02062668f, -0.06129537f, 
    -0.07568398f, 0.03266266f, -0.07284939f, -0.04841556f, -0.01044798f, 0.10098863f, 0.03109814f, -0.00794946f, 
    -0.04674648f, -0.03720731f, 0.00146934f, 0.02481167f, -0.04934940f, -0.04817547f, -0.05144415f, 0.02487057f, 
    -0.00236275f, 0.01325302f, -0.01100891f, -0.00319612f, 0.02114666f, 0.02819685f, 0.01566084f, -0.04803131f, 
    -0.02128501f, -0.00097498f, 0.00925025f, -0.00718469f, 0.03977557f, -0.00980015f, -0.00588185f, -0.01124236f, 
    0.03794327f, -0.02357454f, -0.01016800f, 0.02482074f, 0.02591009f, 0.00759670f, -0.00191326f, -0.04526345f, 
    -0.02426151f, -0.04979785f, -0.04574921f, 0.00648544f, -0.03515598f, 0.01116156f, -0.01455234f, -0.01673644f, 
    -0.01315197f, -0.04137861f, 0.02466751f, 0.03130370f, 0.04042213f, 0.01506084f, -0.05234656f, 0.03600824f, 
    0.01934481f, 0.04396015f, -0.05313960f, 0.01885946f, -0.03839140f, 0.02855534f, 0.04498898f, 0.00841232f, 
    0.02273577f, 0.00239016f, -0.04455394f, -0.03241144f, 0.02131970f, -0.02542913f, -0.01086077f, -0.00578588f, 
    -0.01822774f, 0.02317458f, 0.01466090f, -0.00260028f, -0.02865416f, 0.00512289f, 0.03725519f, 0.03748185f, 
    -0.03841884f, -0.01227746f, -0.03293965f, 0.04116910f, -0.05991383f, 0.00935537f, -0.05244799f, -0.05950719f, 
    -0.00644714f, -0.02310232f, -0.05085421f, -0.02265079f, -0.01475615f, -0.00639383f, 0.01486847f, -0.05413008f, 
    -0.03933467f, 0.03872294f, -0.01240439f, -0.00302280f, -0.04759456f, 0.01708744f, -0.01624735f, 0.00399311f, 
    -0.00224323f, 0.00978142f, 0.05490373f, -0.03847479f, 0.00719886f, 0.02572161f, -0.04004587f, 0.03636955f, 
    -0.03263826f, -0.00281310f, -0.03988060f, 0.01890756f, 0.04027516f, -0.04181851f, 0.03782220f, 0.04035454f, 
    -0.02843809f, -0.05427761f, 0.00033293f, 0.01912347f, 0.00055487f, 0.01298897f, -0.00183035f, 0.01814417f, 
    0.00435418f, -0.00942598f, -0.03177699f, 0.00037051f, 0.01542239f, 0.02062295f, -0.04277894f, -0.01252116f, 
    -0.03145862f, 0.02405495f, -0.03696283f, 0.00477502f, 0.00563781f, 0.02371633f, -0.04251091f, -0.05353492f, 
    0.02220687f, 0.02742069f, 0.02536463f, -0.03969351f, -0.05047002f, -0.01715106f, 0.02035885f, -0.04977174f, 
    0.02408784f, -0.04676187f, 0.01377625f, -0.03385524f, -0.04156842f, 0.03823898f, 0.02223790f, 0.02503503f, 
    -0.02300289f, 0.01587914f, 0.00881789f, -0.00244439f, -0.04879754f, 0.00426379f, 0.02073229f, 0.02994623f, 
    -0.03370244f, -0.01919116f, -0.01540164f, -0.01320616f, -0.03957873f, 0.01378950f, -0.05862144f, 0.03121612f, 
    0.02812576f, -0.00584335f, 0.02905625f, 0.00903952f, -0.00342531f, 0.00249477f, 0.03125143f, -0.01139920f, 
    0.03130393f, 0.02121028f, -0.02594332f, -0.05922589f, -0.00216267f, -0.06015344f, 0.04524571f, -0.05189392f, 
    -0.01058987f, -0.05680703f, 0.02667104f, 0.04018129f, -0.01472237f, -0.02722315f, 0.01731619f, -0.02004828f, 
    0.02506948f, -0.02901481f, -0.05355191f, 0.00924561f, -0.04551231f, -0.00340094f, 0.00488330f, 0.01704002f, 
    0.00614813f, -0.03523096f, -0.03707002f, -0.03734740f, 0.02835149f, -0.02844808f, -0.02798624f, -0.01006751f, 
    -0.04244366f, -0.03306950f, -0.04479875f, 0.01657968f, -0.05793045f, 0.03758573f, -0.03042709f, -0.02723887f, 
    -0.01563411f, 0.03406936f, -0.03562229f, -0.03976839f, -0.02918310f, -0.00436355f, 0.04040783f, -0.00029230f, 
    -0.02967240f, 0.03967680f, -0.01482855f, 0.02517127f, 0.00896438f, -0.05606651f, -0.01621636f, -0.00672095f, 
    0.00293300f, -0.02622065f, -0.04317020f, -0.05664679f, -0.01893369f, -0.04182458f, 0.01846756f, -0.01397008f, 
    -0.04971910f, -0.05213065f, -0.04279178f, 0.01892326f, 0.01627865f, 0.03223185f, 0.01512764f, 0.03555159f, 
    0.03634802f, 0.02680573f, -0.04176139f, -0.06019691f, -0.03581430f, -0.00488479f, 0.01227809f, -0.05617708f, 
    0.02219937f, -0.04168632f, -0.03653194f, -0.05300811f, -0.03674522f, -0.02928958f, 0.03888854f, -0.03955699f, 
    0.03657096f, 0.00212040f, -0.00269981f, 0.01890496f, -0.00513591f, -0.04783367f, 0.02765404f, -0.00000774f, 
    -0.01252827f, -0.04053413f, 0.02713763f, 0.01777256f, -0.04786711f, 0.01252441f, 0.01223413f, 0.03937092f, 
    -0.05491540f, 0.03256532f, -0.01126510f, 0.03020860f, 0.00476258f, 0.03180359f, -0.02278385f, 0.03345883f, 
    -0.05369718f, -0.01098085f, -0.05832848f, -0.04058541f, -0.04136559f, -0.02040031f, 0.02700871f, -0.02899212f, 
    -0.04064119f, 0.03404938f, 0.04290144f, -0.03420170f, 0.01819307f, -0.00693027f, -0.04438308f, 0.02665925f, 
    0.03235492f, -0.02779483f, -0.04082556f, -0.04166001f, -0.03060308f, -0.01640020f, -0.02413829f, 0.02757963f, 
    -0.04761882f, -0.00714724f, -0.03907486f, 0.01925480f, -0.01884676f, 0.03518770f, 0.00758459f, -0.04707852f, 
    -0.05143059f, 0.00878474f, -0.05077524f, -0.04592190f, -0.04186936f, -0.02125750f, -0.05221904f, -0.05136212f, 
    -0.03777343f, -0.04405712f, -0.03008093f, -0.01948462f, -0.01612254f, 0.02841082f, 0.01828169f, 0.04528349f, 
    -0.04379467f, 0.02395261f, -0.05666046f, -0.03703762f, -0.00321399f, 0.03682863f, -0.03579780f, 0.03462416f, 
    0.02438253f, 0.03560650f, -0.03053878f, 0.02217354f, -0.01348329f, -0.00469286f, 0.04072628f, 0.00493874f, 
    0.01186432f, -0.05132916f, -0.02853313f, 0.01171630f, -0.03695093f, -0.04892048f, 0.00656430f, -0.01022735f, 
    0.03355056f, 0.00541075f, 0.01027303f, -0.05747598f, -0.03971347f, 0.00894058f, -0.05099460f, -0.03564318f, 
    0.03182351f, 0.01614480f, -0.03854131f, 0.01252805f, -0.00776796f, 0.00801891f, -0.01444023f, -0.05884006f, 
    -0.05970583f, -0.03556479f, 0.02329720f, -0.04112266f, 0.02720176f, 0.01978220f, 0.03266638f, 0.01589909f, 
    -0.01894156f, 0.04630434f, -0.03811682f, -0.05119812f, 0.00924700f, -0.00491199f, 0.00937283f, 0.01385784f, 
    -0.04991437f, 0.01064719f, 0.03714830f, 0.02448901f, 0.04179816f, -0.03159755f, -0.01983020f, -0.05043115f, 
    -0.00798103f, -0.05580865f, -0.04798141f, -0.05151152f, 0.04416607f, -0.00701064f, -0.00195746f, -0.00379082f, 
    0.01032488f, 0.03865638f, -0.03178240f, -0.05302168f, -0.03748322f, -0.01713645f, -0.04383024f, -0.01685411f, 
    0.04302105f, -0.01149439f, 0.04146392f, 0.03374324f, 0.01658593f, 0.02451329f, -0.04969474f, 0.03823649f, 
    0.01917413f, -0.00370681f, 0.02345271f, -0.01791534f, 0.03913530f, -0.02707380f, -0.03938874f, -0.00703722f, 
    -0.01041688f, 0.00315999f, 0.02322764f, -0.02033448f, -0.03363654f, -0.03525799f, -0.02177445f, 0.02020522f, 
    -0.02491951f, 0.01539725f, 0.04438438f, 0.00921868f, -0.03579668f, -0.01647512f, 0.01113978f, -0.03891610f, 
    0.02682466f, -0.04816296f, 0.04072244f, 0.00959588f, 0.00567509f, -0.04282327f, -0.04231757f, -0.00401944f, 
    0.03169150f, -0.02179143f, -0.04205314f, 0.03059367f, -0.05713758f, 0.02140558f, -0.01449566f, -0.03338468f, 
    0.02887382f, -0.03447082f, 0.01487994f, -0.02430741f, 0.01997416f, 0.04248329f, 0.00605384f, 0.02161769f, 
    0.04155656f, -0.00206351f, 0.04278550f, 0.03517211f, -0.00798017f, -0.01658764f, 0.00919854f, -0.04208305f, 
    -0.00464292f, -0.00873866f, 0.03756951f, 0.02184784f, 0.04115646f, -0.04385661f, 0.00312234f, -0.00208860f, 
    0.03413798f, 0.03743334f, -0.05729800f, -0.02437141f, 0.03386066f, -0.02597017f, -0.04503842f, -0.02601494f, 
    -0.00552472f, 0.02376209f, -0.00951409f, 0.02076872f, 0.00328470f, -0.04146174f, 0.05337783f, -0.02668045f, 
    0.02908362f, -0.04673894f, 0.02451861f, 0.03971960f, -0.04066266f, -0.02897266f, -0.02287208f, -0.05989402f, 
    0.00100937f, -0.03880955f, -0.02477713f, -0.01659743f, 0.03147754f, -0.03141032f, 0.03302900f, 0.03471854f, 
    -0.01420198f, 0.01144841f, -0.00738320f, -0.01274336f, -0.02048942f, 0.00206413f, -0.04810829f, 0.02791574f, 
    -0.01541714f, 0.03614011f, -0.02037646f, 0.00245220f, -0.01281954f, 0.02726933f, -0.01896086f, -0.01778337f, 
    0.00905915f, 0.01695558f, -0.05985090f, 0.03399371f, -0.04096230f, 0.01294409f, -0.00282870f, -0.03276068f, 
    -0.02238161f, -0.02049728f, -0.00085624f, 0.03219385f, -0.04150581f, -0.00886849f, -0.00248789f, -0.05416729f, 
    0.03360858f, 0.00030964f, -0.00589388f, 0.03693974f, 0.03771381f, -0.04949317f, -0.01009877f, 0.03038670f, 
    0.01751202f, -0.04222546f, -0.03983555f, -0.01939617f, -0.01711003f, -0.04315756f, 0.00264960f, -0.05333930f, 
    0.01613513f, -0.04403770f, -0.04641361f, 0.03050700f, 0.04706372f, -0.02901382f, -0.00349988f, 0.02878323f, 
    0.02126837f, -0.00915358f, 0.04086231f, -0.03752732f, 0.01630947f, 0.00971416f, -0.02591238f, -0.02221672f, 
    0.04377964f, -0.02098869f, -0.02248276f, -0.03231070f, -0.02555458f, 0.00874845f, -0.05018469f, -0.03481880f, 
    -0.01236936f, -0.05280968f, -0.03774482f, -0.01110859f, 0.00603465f, 0.00283167f, 0.02106814f, 0.03770601f, 
    -0.03317901f, -0.05676667f, -0.03378500f, 0.00598639f, -0.02503876f, -0.05336443f, -0.04245007f, -0.03924443f, 
    -0.05478152f, 0.01397756f, 0.00993286f, 0.04033152f, 0.03646888f, 0.04245394f, 0.03721484f, -0.03072937f, 
    -0.04137622f, -0.03883762f, -0.00651565f, 0.04304808f, -0.04720101f, 0.00335443f, -0.03211838f, -0.02072577f, 
    -0.03549739f, -0.00736079f, 0.00697670f, 0.03003874f, 0.02553412f, 0.02353959f, -0.01674957f, -0.00944802f, 
    -0.01946385f, -0.02272907f, 0.04293021f, -0.04705704f, -0.05268426f, 0.00367510f, -0.01218707f, -0.00198990f, 
    -0.02966707f, -0.00476969f, -0.02492357f, -0.04196859f, 0.00283226f, 0.02978676f, -0.01863527f, -0.04416133f, 
    -0.00020918f, -0.05038590f, 0.01602732f, 0.02369344f, -0.03348702f, 0.00736607f, 0.01670566f, 0.00660653f, 
    -0.04454575f, -0.03454481f, 0.00969977f, -0.03157809f, 0.00152817f, -0.00246037f, -0.02196635f, -0.05503352f, 
    0.00476798f, -0.04542751f, -0.03505907f, 0.04419830f, 0.01042147f, -0.05422316f, -0.05771775f, -0.00982233f, 
    -0.03237568f, 0.02200814f, 0.00082444f, 0.04276235f, 0.00085340f, 0.01755315f, -0.00948121f, 0.02931052f, 
    -0.01777934f, -0.01044308f, 0.02477693f, -0.01093830f, 0.02380294f, 0.00911060f, -0.01648112f, -0.00998870f, 
    -0.01363549f, 0.03150159f, -0.03849930f, -0.02688546f, -0.03011648f, 0.01335797f, -0.01943948f, 0.01931277f, 
    -0.01001918f, -0.02484749f, 0.02207882f, -0.02359766f, 0.02165118f, 0.00671749f, 0.00981065f, -0.04224268f, 
    0.01825090f, -0.01471593f, -0.03986665f, 0.00986608f, -0.00114352f, -0.01382381f, 0.02540208f, 0.00755419f, 
    -0.02175441f, 0.00336045f, -0.05538145f, 0.02575140f, 0.04009502f, 0.01828182f, -0.03388447f, 0.02952810f, 
    0.01480953f, 0.02467803f, -0.00053510f, 0.01403194f, 0.00564677f, 0.03419109f, -0.04597230f, -0.03380107f, 
    0.00465531f, -0.02313415f, 0.01983921f, -0.00789859f, 0.03020231f, 0.02773167f, 0.04501319f, -0.02996847f, 
    -0.00638382f, 0.01396307f, -0.01687236f, 0.00429331f, 0.00934864f, -0.05217000f, 0.03752854f, -0.00260703f, 
    -0.03944109f, -0.00191955f, -0.01097599f, 0.03196589f, 0.00724379f, 0.04145418f, 0.04592086f, -0.04784892f, 
    0.03959094f, 0.03980345f, -0.00192927f, 0.01666289f, -0.05034989f, 0.00477978f, -0.02947496f, -0.05743318f, 
    -0.01249537f, -0.05844411f, 0.03147461f, 0.04004140f, 0.02708504f, 0.02766586f, 0.03782328f, -0.01399745f, 
    0.28891411f, -0.30690542f, -0.15763317f, 0.23888236f, -0.02330770f, -0.12073929f, -0.08244103f, -0.05202090f, 
    0.04602206f, 0.04576271f, -0.07769026f, -0.19872656f, -0.40413210f, -0.09029432f, -0.07443301f, 0.25065491f, 
    0.00506181f, -0.20505498f, -0.03744039f, -0.05702335f, 0.05223740f, 0.14391994f, -0.14111987f, -0.06316023f, 
    -0.12199513f, -0.03326933f, 0.21936414f, -0.29851693f, -0.05603210f, -0.09804889f, -0.01741543f, 0.05263743f, 
    0.06746443f, 0.02828956f, 0.02407608f, 0.07581051f, 0.40482685f, 0.03492600f, -0.12406949f, -0.14526744f, 
    -0.03380082f, -0.07426567f, -0.09474813f, -0.08275907f, -0.07435382f, 0.08506568f, -0.03152896f, 0.02279317f, 
    -0.50743794f, 0.07232409f, -0.03882941f, 0.14037403f, -0.05052515f, 0.04828029f, -0.03571425f, 0.11409270f, 
    0.00168327f, 0.10824450f, -0.03495720f, 0.26838082f, 0.39308763f, 0.12176394f, 0.17224181f, 0.02324537f, 
    0.00332740f, -0.07009760f, -0.04926503f, 0.01978596f, 0.06311870f, 0.09108767f, -0.00806530f, -0.01720518f, 
    0.51423699f, -0.03680436f, -0.14934327f, -0.19202565f, 0.00925209f, -0.03910828f, 0.08422830f, -0.12232123f, 
    0.02996692f, -0.03324696f, 0.07121605f, -0.07791924f, 0.11711970f, -0.05346280f, -0.14875650f, 0.50849694f, 
    0.05055859f, 0.02140165f, 0.03881847f, 0.11471698f, -0.17680129f, -0.01976261f, 0.02567160f, 0.00714368f, 
    0.35115880f, -0.09690209f, -0.05965919f, -0.07400829f, 0.12595034f, 0.02920291f, -0.00524130f, -0.00200407f, 
    0.27132010f, -0.10706047f, -0.05974584f, 0.10362949f, 0.18288824f, 0.24431127f, -0.01234615f, 0.39674386f, 
    -0.07543903f, -0.00717898f, 0.03664038f, -0.09636892f, -0.07512034f, -0.00252985f, -0.06954026f, -0.05300160f, 
    0.20610738f, 0.07473088f, 0.05396861f, 0.14166278f, 0.02383034f, 0.05525758f, 0.04913472f, -0.20140012f, 
    0.14723109f, 0.02839211f, -0.04134475f, -0.16738608f, 0.16534969f, 0.17757329f, 0.31835908f, 0.17905560f, 
    0.06613924f, 0.05871215f, -0.04481129f, 0.14578037f, -0.03319207f, -0.18232863f, -0.05021190f, 0.05717482f, 
    -0.34554020f, 0.13035835f, 0.23714156f, -0.02862763f, 0.17470153f, 0.02051322f, -0.01991638f, 0.01731849f, 
    -0.03753147f, -0.05052593f, -0.02565624f, -0.08566939f, 0.13039632f, 0.08830851f, 0.00728971f, 0.10216838f, 
    -0.10120306f, -0.12697916f, 0.09874678f, -0.01553231f, 0.11265375f, 0.02277949f, -0.09793516f, 0.03660575f, 
    -0.13841309f, -0.02451529f, 0.27660477f, -0.20298819f, 0.06161906f, -0.03731749f, -0.06879157f, 0.14521344f, 
    0.21153837f, -0.13628328f, 0.05480027f, 0.03001809f, -0.09948292f, -0.00156900f, 0.07762068f, -0.08671353f, 
    0.00842471f, -0.02860290f, -0.08240663f, -0.08998250f, 0.00117090f, 0.20662467f, -0.00962688f, 0.00244318f, 
    -0.20286630f, 0.19818456f, 0.14735839f, 0.02531172f, 0.14132534f, -0.11176873f, 0.02636846f, -0.02529152f, 
    0.16287933f, -0.01351445f, 0.05265946f, 0.01778639f, -0.17537294f, 0.03536408f, 0.20329055f, 0.15982035f, 
    0.08169392f, 0.05751367f, 0.08749826f, -0.06502112f, -0.01644070f, -0.02384361f, -0.07949569f, -0.01611588f, 
    -0.06715323f, 0.05416561f, 0.24751562f, 0.04866894f, 0.16719727f, 0.07162422f, 0.03489112f, -0.03446354f, 
    -0.09105502f, -0.00844970f, 0.04814509f, -0.11962368f, -0.25281861f, 0.30444160f, -0.19995183f, 0.09754234f, 
    -0.07579867f, 0.11350452f, -0.19887204f, -0.03995674f, -0.24438520f, 0.08787753f, -0.17049521f, 0.11553554f, 
    -0.14896896f, -0.05554993f, 0.29907355f, 0.02524176f, 0.07158282f, -0.09249028f, 0.00775450f, 0.04754171f, 
    -0.10161415f, -0.11044919f, -0.08479606f, 0.09860118f, 0.44479147f, 0.04379323f, -0.24707089f, -0.24418679f, 
    -0.15400001f, -0.11459408f, -0.07589407f, -0.06250635f, -0.03670715f, -0.11950736f, -0.01206977f, -0.02994198f, 
    0.27755067f, 0.28854242f, 0.10605688f, 0.01377660f, -0.05572679f, 0.00708186f, -0.15375124f, 0.09107338f, 
    -0.02707939f, 0.09896752f, 0.17584449f, 0.08745259f, 0.13445401f, -0.15607151f, 0.05265834f, 0.23131397f, 
    -0.05220184f, -0.02938604f, 0.01443231f, 0.01162276f, -0.01181497f, 0.01212725f, 0.14764151f, -0.11894926f, 
    0.22559851f, -0.19361290f, -0.19355763f, 0.02098372f, -0.06333948f, -0.07671791f, 0.06648711f, -0.19733515f, 
    0.09691370f, 0.07453094f, 0.23812033f, 0.05517889f, 0.26696071f, -0.24280202f, -0.00114189f, 0.08596323f, 
    -0.07170949f, -0.04354720f, -0.00324686f, -0.06552530f, -0.00081919f, 0.09932164f, -0.10870821f, -0.01054748f, 
    0.02744725f, 0.14467569f, 0.09557673f, 0.12083691f, 0.10022242f, 0.07996928f, -0.03541276f, 0.10467595f, 
    -0.05164137f, 0.11898720f, -0.03781915f, 0.02964206f, -0.23536116f, 0.27802220f, 0.08530790f, 0.19111435f, 
    -0.07725403f, -0.08468260f, 0.00311601f, 0.08228938f, -0.14994740f, -0.03412840f, 0.11702230f, -0.05104811f, 
    0.00749258f, 0.15597883f, 0.05329725f, 0.28902775f, 0.09093172f, 0.08719822f, -0.17457759f, -0.06763632f, 
    0.11898571f, 0.05676205f, 0.05032467f, -0.04775649f, 0.37195036f, -0.02870027f, -0.08115782f, 0.36627638f, 
    -0.00827195f, -0.04234283f, 0.10609375f, -0.02257734f, 0.13174018f, -0.02653108f, -0.07543524f, 0.04259748f, 
    -0.45632425f, 0.06922504f, 0.12128672f, 0.13309412f, 0.28729317f, 0.08200367f, 0.00938502f, 0.07934447f, 
    -0.03900702f, -0.01064097f, 0.09996932f, -0.00762305f, -0.42924625f, 0.37893718f, -0.04885275f, -0.09727522f, 
    0.04280075f, 0.11841944f, 0.04830036f, 0.00231243f, -0.13034622f, 0.02980671f, -0.01389142f, 0.11590111f, 
    0.00130324f, -0.02596167f, -0.14135164f, -0.09283204f, 0.13315435f, 0.07053771f, -0.09656687f, 0.09448427f, 
    0.00350904f, 0.12566504f, 0.12081309f, 0.13193752f, 0.38819641f, 0.03166914f, 0.03618037f, 0.10083650f, 
    0.10969582f, 0.01486743f, -0.02420619f, 0.06080776f, -0.07117867f, 0.03329386f, -0.07740242f, 0.04494298f, 
    -0.01036218f, 0.31372210f, 0.12742761f, -0.14326894f, -0.10134637f, 0.09774653f, -0.06555689f, 0.07790833f, 
    -0.09953030f, 0.05430451f, 0.30833676f, 0.05182363f, -0.06964669f, 0.12756191f, 0.03944267f, -0.06019607f, 
    -0.03702775f, 0.11017194f, 0.18767305f, 0.02871311f, -0.04205125f, 0.01750201f, -0.15381144f, 0.11164144f, 
    0.43775305f, -0.00261069f, 0.11049078f, 0.17736278f, -0.07801539f, 0.11472486f, 0.01743314f, 0.06965037f, 
    0.09500945f, 0.12530197f, 0.04978908f, 0.12897107f, 0.11786485f, -0.17090502f, 0.03470068f, -0.20744942f, 
    0.01197179f, -0.15950473f, 0.08229066f, 0.02171012f, 0.24774475f, 0.11798187f, -0.06933466f, 0.11167040f, 
    -0.05021153f, 0.26325536f, 0.01657882f, 0.33593240f, 0.03043499f, 0.02939946f, -0.02267041f, 0.01433432f, 
    0.00971036f, 0.12162157f, -0.08177644f, 0.09081644f, -0.43481794f, -0.24031892f, -0.14967309f, 0.13925157f, 
    0.04555570f, -0.05530972f, 0.10529634f, -0.05964770f, -0.00508139f, -0.00990940f, 0.03896640f, 0.19940655f, 
    0.01340674f, 0.13822201f, -0.07787032f, -0.24279392f, 0.00804116f, 0.13327256f, 0.18376084f, 0.04097036f, 
    0.10484465f, 0.07448746f, -0.06934577f, 0.07798934f, -0.48715687f, -0.31187528f, -0.06705676f, -0.02218496f, 
    0.11108840f, 0.00050618f, -0.01171273f, -0.19899555f, 0.03904757f, 0.03590196f, -0.08726230f, 0.08196483f, 
    0.07356850f, 0.08442291f, -0.13574146f, -0.18255879f, -0.08938659f, -0.14866465f, -0.14749220f, -0.03077825f, 
    -0.00775863f, -0.01561599f, -0.03556660f, -0.06061159f, 0.33169058f, -0.06059169f, 0.21113099f, 0.04402497f, 
    -0.08501723f, 0.03416964f, -0.09935402f, 0.03596310f, 0.16718256f, 0.09902449f, -0.02172225f, 0.03607358f, 
    0.26962629f, 0.02671452f, 0.10930169f, 0.10284097f, -0.01488111f, 0.02052517f, 0.09515695f, -0.02321210f, 
    -0.04007750f, 0.02608153f, 0.02350795f, 0.19053169f, 0.00401490f, 0.04262091f, 0.01810999f, 0.13865556f, 
    -0.08626007f, -0.10025306f, -0.15397741f, -0.05171208f, 0.14236091f, -0.21512429f, 0.02428423f, 0.11206661f, 
    0.06983002f, 0.10625530f, 0.01129708f, 0.15236521f, 0.20096371f, -0.02627507f, 0.03621119f, -0.15732679f, 
    0.06906860f, -0.14176369f, -0.09411972f, -0.08604452f, 0.04171078f, -0.10011469f, -0.12729082f, -0.11170812f, 
    -0.00941266f, -0.07119393f, 0.15025838f, -0.04665159f, -0.05890726f, -0.02620924f, 0.22484806f, 0.19464570f, 
    0.24612623f, 0.39712340f, 0.10356216f, -0.18612058f, -0.05360370f, -0.00066242f, -0.10473034f, -0.11145122f, 
    -0.09988619f, -0.13151787f, 0.06102630f, -0.12201076f, 0.04476673f, 0.10703307f, -0.22542444f, -0.09837396f, 
    0.00006146f, -0.09328049f, -0.22772361f, 0.01126679f, 0.02400004f, -0.12804568f, 0.11698386f, -0.06740360f, 
    0.19261417f, 0.09570856f, -0.04288313f, 0.06961855f, -0.17859852f, 0.04129636f, 0.02049541f, -0.01617476f, 
    -0.18024720f, 0.05831722f, -0.01081877f, -0.18704501f, 0.13115275f, -0.10233939f, -0.02503654f, 0.05583739f, 
    0.04090023f, -0.16103703f, 0.02196161f, 0.08631872f, 0.18896782f, 0.11818830f, -0.00006289f, 0.07532337f, 
    0.29348534f, 0.16197421f, 0.00158205f, 0.15373074f, 0.12786038f, 0.12042184f, 0.13284323f, -0.12126938f, 
    0.02927019f, 0.01641027f, 0.10175608f, 0.04429300f, -0.10774194f, 0.19801138f, 0.10560615f, 0.33796021f, 
    0.07951126f, -0.01542105f, 0.01520726f, 0.20137578f, 0.04261368f, 0.17416804f, -0.02802600f, 0.08466449f, 
    -0.09024859f, -0.01330411f, 0.22597599f, 0.11682802f, 0.18373357f, 0.11825601f, -0.01649423f, -0.14585552f, 
    0.02388002f, -0.09579810f, 0.07753867f, -0.00872710f, -0.37946391f, -0.30045629f, -0.12281390f, -0.07633277f, 
    0.11893158f, 0.20794345f, -0.08540967f, -0.10399510f, 0.07914135f, 0.03485747f, 0.17564580f, 0.15513760f, 
    0.17375951f, 0.34385866f, 0.05068878f, 0.28374934f, 0.00505456f, -0.06422400f, 0.09845796f, 0.02020564f, 
    -0.13382836f, -0.06516847f, -0.06028423f, 0.05153449f, -0.24025318f, -0.20135356f, -0.20673175f, 0.00784228f, 
    0.10688880f, 0.07439937f, -0.05482110f, -0.08818530f, -0.00862720f, -0.13549693f, 0.09413656f, -0.04619219f, 
    0.14224005f, 0.05249796f, 0.27458698f, 0.03530545f, 0.03298453f, -0.07200202f, 0.00031240f, -0.14987008f, 
    0.01791427f, 0.03500838f, -0.14371791f, 0.09623001f, 0.43205753f, 0.21580429f, 0.07621330f, 0.03093956f, 
    -0.01400708f, 0.01548940f, -0.05113437f, 0.20211810f, 0.00420918f, 0.05809703f, 0.13840263f, -0.09692649f, 
    0.15069346f, 0.15024132f, -0.10724895f, 0.10863110f, 0.04380566f, 0.07576854f, 0.19900252f, 0.01301028f, 
    0.08893867f, 0.11882710f, 0.01875200f, -0.20755766f, -0.48724928f, -0.18800206f, -0.16766760f, -0.26035371f, 
    0.17351751f, -0.02319656f, 0.02331137f, -0.07073691f, 0.13944013f, 0.10627823f, -0.04721535f, 0.02684824f, 
    0.03499890f, 0.05785056f, -0.07143159f, 0.02737094f, -0.15356688f, -0.05811552f, 0.14630446f, -0.02967215f, 
    0.06827029f, -0.04200685f, 0.07161117f, -0.18434969f, -0.00246560f, 0.08516230f, 0.23338401f, -0.06978057f, 
    -0.04238290f, -0.23354992f, 0.06352582f, 0.10948551f, 0.03052741f, 0.06093467f, 0.01003708f, -0.03710456f, 
    -0.21340622f, -0.11620586f, 0.38480717f, 0.24491061f, -0.14681424f, 0.01737184f, 0.11387719f, 0.05969409f, 
    -0.11150040f, -0.04829756f, 0.06634034f, 0.08664183f, -0.03612870f, -0.06309285f, 0.14546625f, -0.17434765f, 
    0.05459367f, 0.04379531f, 0.09120400f, -0.01176087f, -0.05841104f, 0.08863800f, 0.16230430f, 0.04680284f, 
    0.02073633f, -0.02828988f, -0.14690787f, -0.09495333f, 0.05537619f, -0.03627620f, 0.00515029f, -0.12780981f, 
    0.05927271f, 0.00671922f, 0.05634382f, -0.08687372f, 0.38793936f, 0.01948958f, 0.16880184f, 0.01565459f, 
    -0.09985209f, 0.01603295f, -0.12981044f, -0.14010526f, -0.03946605f, -0.04180302f, 0.15488468f, 0.10130178f, 
    -0.14257240f, -0.02375888f, 0.11572147f, -0.17375122f, -0.08255640f, 0.11433996f, 0.08669969f, 0.08529133f, 
    -0.02748003f, -0.09735899f, 0.04663792f, -0.07324146f, -0.04745182f, 0.02096762f, -0.18479715f, 0.15881714f, 
    -0.01529088f, -0.08429051f, -0.03785430f, 0.12974377f, -0.02166804f, 0.08209633f, -0.00275542f, 0.04123642f, 
    0.03937297f, -0.26783547f, 0.08872423f, 0.00637590f, 0.03718279f, -0.06080417f, -0.01744915f, -0.01479515f, 
    0.12701491f, -0.21534185f, 0.15482549f, -0.01337440f, 0.16260652f, 0.12097590f, 0.46447161f, 0.26143336f, 
    0.07377737f, 0.07064042f, 0.01897156f, 0.14504719f, -0.13548782f, 0.02822283f, 0.12920362f, 0.09432676f, 
    0.08049505f, 0.29416203f, -0.04814744f, 0.26987278f, -0.18078195f, -0.03711367f, 0.06132350f, 0.02297830f, 
    -0.02310805f, 0.05044279f, -0.06587712f, 0.02631889f, 0.24770519f, 0.32276675f, 0.39529809f, 0.34742928f, 
    -0.01503577f, 0.14151117f, 0.10042016f, 0.10444054f, 0.10608646f, 0.01792994f, 0.08440275f, 0.13245334f, 
    0.57171792f, 0.08013928f, 0.20027280f, 0.19616304f, -0.13796841f, -0.06338904f, 0.02825760f, 0.01469091f, 
    -0.10412240f, -0.16555718f, 0.22364838f, -0.07892755f, -0.09895789f, -0.01817868f, -0.19790079f, -0.08792889f, 
    0.27894986f, -0.02374992f, 0.12426358f, 0.12167598f, 0.06281563f, 0.19765821f, 0.12367760f, 0.09735403f, 
    0.13932581f, -0.18643454f, -0.23226455f, -0.04315709f, -0.02828651f, 0.04898736f, 0.00333371f, -0.08712054f, 
    0.12373679f, 0.01269478f, -0.00878034f, 0.11895230f, -0.26681721f, -0.02791773f, 0.00563394f, -0.08235380f, 
    -0.01032119f, 0.02272284f, 0.20426139f, 0.12654169f, -0.02072475f, 0.15602896f, -0.02385672f, 0.15481816f, 
    -0.00117815f, 0.05964759f, 0.18508999f, 0.05279585f, 0.11132657f, -0.22488761f, -0.00043874f, -0.13048372f, 
    0.03447732f, 0.17480917f, 0.10705806f, 0.03290536f, 0.01142404f, 0.10246729f, 0.14952339f, 0.09508362f, 
    -0.01834735f, 0.18161266f, -0.06937166f, -0.09561797f, 0.10135713f, 0.06909966f, 0.08954406f, 0.20716822f, 
    0.05036509f, 0.09019975f, 0.05304053f, 0.07717565f, 0.07436190f, 0.00850117f, -0.14665835f, -0.04451872f, 
    0.30454540f, 0.07970383f, -0.02018815f, -0.05227954f, -0.31352577f, 0.05780379f, 0.26927671f, -0.06770694f, 
    0.14948113f, -0.04530511f, 0.08042379f, 0.11452427f, 0.01720145f, 0.10409016f, 0.22030297f, -0.17307465f, 
    0.04806610f, 0.02801261f, 0.01257320f, -0.05576091f, 0.12503667f, 0.08436760f, -0.12267114f, 0.25732622f, 
    -0.01210048f, 0.06478690f, 0.11991361f, 0.07674424f, -0.28148052f, -0.08271442f, 0.02220454f, 0.02644426f, 
    0.07325720f, -0.04959129f, -0.00265291f, 0.21898635f, 0.17499240f, -0.08517882f, 0.00193639f, 0.00795913f, 
    0.00545395f, -0.19716863f, -0.08876709f, 0.09192742f, -0.04461608f, 0.15216690f, -0.05507060f, 0.04824957f, 
    -0.08320726f, -0.19167191f, -0.07512733f, 0.01822631f, -0.37910244f, -0.08143212f, 0.05208796f, -0.01038965f, 
    -0.09097421f, 0.03122069f, 0.03239001f, -0.13151306f, 0.24016474f, -0.00702408f, -0.05186462f, 0.03033756f, 
    -0.39012364f, -0.03771836f, -0.00232361f, -0.29005048f, 0.05804706f, -0.05677912f, 0.08481910f, -0.04073810f, 
    -0.02354924f, -0.02228968f, -0.00162770f, 0.01187335f, 0.24795106f, 0.31696597f, 0.10065956f, 0.30379641f, 
    0.12577759f, 0.09480426f, 0.10627577f, -0.02622471f, 0.06104621f, 0.16345417f, -0.02948073f, 0.10563479f, 
    -0.63674432f, 0.04261723f, 0.13784024f, -0.21263404f, 0.03967020f, 0.02302121f, 0.11589503f, 0.06769624f, 
    -0.12717439f, -0.15469588f, 0.05234757f, 0.05768841f, 0.00056114f, -0.14553083f, 0.46801373f, 0.05494854f, 
    -0.21741466f, -0.09011693f, 0.14189696f, 0.04496660f, -0.30275786f, 0.04104437f, -0.20122617f, -0.00957089f, 
    0.00461648f, -0.20948814f, -0.13091902f, 0.18464391f, 0.04636576f, 0.04397352f, 0.06590369f, 0.27789643f, 
    0.04316309f, -0.05055095f, 0.05561446f, 0.20423809f, -0.15072118f, -0.20842156f, -0.46205026f, 0.07383951f, 
    -0.05455977f, 0.07714964f, -0.05523070f, 0.07270320f, 0.12867355f, 0.07839977f, -0.09278350f, 0.19062422f, 
    0.13794519f, -0.00405505f, 0.15745047f, -0.10658185f, 0.14944267f, 0.08956175f, 0.08776626f, 0.01020939f, 
    0.39747044f, -0.03203953f, -0.06682409f, -0.03099136f, 0.50959903f, 0.05168993f, 0.21500076f, 0.45613948f, 
    -0.09803933f, -0.09863038f, 0.07670339f, 0.11146729f, -0.00776572f, 0.01452438f, -0.05985696f, 0.04408212f, 
    -0.12131258f, 0.01485679f, 0.00234014f, -0.10344710f, 0.06841238f, 0.10065304f, -0.00090460f, 0.06981935f, 
    0.07930908f, 0.01138998f, -0.01048782f, -0.11414368f, -0.11981235f, 0.11168981f, -0.37350854f, -0.04385819f, 
    0.04185307f, 0.11862492f, 0.03359240f, 0.07853354f, -0.02330625f, 0.03326657f, 0.02314205f, -0.19867517f, 
    0.35160255f, 0.40844145f, -0.00030916f, 0.01968742f, 0.10441395f, 0.05095863f, 0.18814977f, -0.00638771f, 
    -0.01488933f, -0.00692950f, -0.05879533f, -0.04225963f, -0.32945085f, 0.19916366f, 0.13897905f, 0.08105247f, 
    -0.00310117f, -0.05635756f, 0.08879740f, -0.07217081f, -0.08403515f, -0.12469748f, 0.14582284f, 0.17548285f, 
    0.39326638f, -0.00151274f, -0.20083600f, -0.09443424f, 0.03064747f, 0.04499652f, -0.00154936f, -0.05990903f, 
    0.02313102f, 0.02773453f, 0.13758549f, 0.09050748f, 0.17922758f, 0.01871623f, 0.08586231f, -0.11391234f, 
    0.12666851f, 0.00127897f, 0.11867654f, -0.03346461f, -0.06505974f, -0.02759671f, -0.10617692f, -0.00075085f, 
    -0.26648375f, -0.25943297f, 0.21967086f, 0.01008365f, 0.08177900f, -0.03121282f, 0.07557768f, 0.11035342f, 
    0.00445591f, -0.01829029f, 0.12502573f, -0.02572042f, -0.45540693f, 0.02458397f, 0.09994112f, -0.01785517f, 
    0.00602678f, 0.02609423f, -0.02943342f, 0.01712400f, 0.05879063f, 0.17252815f, 0.05613066f, -0.02407057f, 
    0.05318924f, 0.01492938f, -0.05916532f, 0.00541982f, -0.21635312f, 0.01793826f, -0.06691947f, 0.00242433f, 
    -0.09806095f, -0.03670105f, 0.01535014f, -0.00256460f, 0.50640988f, -0.05545573f, 0.07362857f, 0.22692198f, 
    0.02738647f, -0.07838950f, 0.05594670f, -0.01299337f, 0.07442302f, 0.10193557f, -0.04990712f, 0.08522842f, 
    -0.03869169f, 0.08799081f, 0.00958962f, -0.08521899f, -0.05647495f, 0.02155432f, -0.00347156f, 0.09904488f, 
    -0.09731581f, 0.01496864f, 0.06970419f, 0.02943264f, 0.29663220f, -0.35320917f, 0.10887212f, 0.14569750f, 
    -0.05052032f, 0.01696896f, 0.08266752f, 0.09728692f, 0.16771509f, 0.14524570f, -0.05216633f, 0.02564078f, 
    0.02302619f, 0.02178227f, -0.02368146f, -0.03686101f, 0.16525477f, -0.09919574f, -0.18725507f, 0.15442064f, 
    -0.00997298f, -0.07399494f, -0.10299536f, -0.06672305f, -0.09400209f, 0.01810857f, -0.04764063f, -0.00944113f, 
    -0.09734159f, -0.07286771f, -0.01614265f, 0.10076309f, 0.13605998f, 0.01156082f, 0.04828404f, -0.00126380f, 
    -0.20810017f, 0.39370057f, -0.17032158f, 0.05951935f, -0.11336409f, -0.00726390f, -0.05875936f, 0.19074097f, 
    0.04190983f, 0.04763192f, -0.06845899f, 0.00897035f, -0.07320894f, -0.08722559f, 0.03173739f, 0.00447428f, 
    0.01483537f, -0.08366446f, -0.13527195f, 0.05050316f, 0.09214284f, -0.11073022f, -0.06934358f, -0.07088979f, 
    0.48879072f, -0.22197585f, 0.06320305f, 0.04342626f, 0.09438936f, 0.12308923f, -0.11546379f, -0.11994785f, 
    0.04374033f, -0.06038991f, -0.12059227f, -0.03040956f, 0.03069205f, -0.07800960f, -0.00846223f, 0.00922316f, 
    0.02686844f, -0.03408644f, 0.03244067f, 0.03250314f, -0.02861918f, -0.11426759f, 0.05710736f, 0.19135170f, 
    0.33976156f, -0.09123099f, 0.14651169f, -0.02277701f, -0.08360878f, 0.09753849f, 0.10336886f, 0.01233320f, 
    -0.02236480f, -0.03561768f, -0.13827372f, -0.10326176f, 0.00819269f, -0.20412685f, 0.02913699f, -0.13418986f, 
    -0.08084564f, 0.06360171f, -0.08506274f, 0.03435757f, 0.15199673f, 0.00127818f, 0.06253529f, -0.02001847f, 
    -0.20162585f, 0.10084424f, -0.19590588f, -0.02946718f, 0.07629246f, 0.04853006f, -0.04010683f, -0.04920640f, 
    0.09532990f, 0.01840894f, 0.07656520f, 0.00663168f, -0.09965508f, -0.05153862f, 0.03121350f, -0.01382243f, 
    0.16828747f, 0.03093689f, 0.12632822f, 0.12403449f, 0.01041606f, -0.07242156f, 0.10254685f, -0.19406432f, 
    -0.25230366f, 0.09415732f, -0.05757503f, 0.04118096f, -0.05175927f, 0.04447793f, 0.01684142f, 0.08883741f, 
    -0.00966598f, -0.08808234f, 0.07854538f, 0.11053111f, -0.27655163f, -0.16369176f, 0.23326874f, 0.15483162f, 
    -0.07122375f, -0.09308060f, 0.05522605f, 0.07384239f, 0.02564238f, -0.04221150f, -0.10115623f, -0.00746948f, 
    -0.09916774f, -0.08805608f, 0.04107936f, 0.13577606f, 0.00972742f, -0.03526208f, -0.06264917f, -0.10486979f, 
    0.07532997f, -0.10703411f, 0.07546251f, -0.05898341f, 0.44265541f, 0.04331088f, 0.05208682f, 0.14058469f, 
    0.04486100f, 0.02487541f, 0.04960822f, 0.04877502f, 0.05753024f, -0.05523764f, 0.06559327f, 0.00641335f, 
    0.18821757f, 0.46561122f, -0.04397606f, 0.12544861f, -0.06839468f, 0.06168855f, 0.12671092f, -0.03476666f, 
    0.11887316f, -0.11308599f, 0.00054673f, 0.01298544f, 0.37760755f, 0.27828872f, 0.11078408f, 0.04722872f, 
    0.23909053f, -0.03597252f, 0.03842177f, -0.01300696f, -0.03854733f, -0.08016131f, 0.06186411f, -0.01906832f, 
    -0.27517945f, 0.13118000f, -0.09042546f, 0.04499703f, -0.06027622f, 0.00449520f, -0.03306239f, 0.07273930f, 
    0.08379506f, -0.01884963f, -0.09786472f, 0.02378360f, -0.41925377f, 0.06762208f, -0.17247835f, 0.00961246f, 
    0.04742404f, 0.13803276f, -0.15234336f, 0.09703627f, 0.10662007f, 0.01918449f, -0.02962532f, -0.08828083f, 
    -0.03499926f, -0.10731196f, 0.00292372f, -0.07315610f, 0.15543582f, -0.04394504f, 0.19793250f, -0.13740887f, 
    -0.02473771f, 0.16227467f, -0.01870661f, 0.00483910f, 0.07954289f, 0.15189937f, -0.17922893f, 0.01054037f, 
    0.06786342f, -0.01263900f, -0.03222859f, 0.11189058f, 0.07732468f, 0.05081340f, -0.00402003f, -0.14314261f, 
    0.02063449f, -0.10391941f, -0.09750690f, -0.15772893f, -0.01147837f, 0.11347646f, 0.07932869f, 0.03197484f, 
    0.07227314f, -0.02399631f, -0.11926621f, 0.02193454f, -0.55596530f, 0.23449375f, 0.18666227f, -0.20792080f, 
    0.02112583f, 0.08325879f, 0.11801450f, -0.06526455f, 0.05270211f, 0.04418893f, 0.14561464f, 0.05922985f, 
    0.00950779f, -0.03809192f, -0.00502174f, 0.02122750f, 0.00041127f, 0.00051277f, -0.03793845f, 0.03685885f, 
    -0.05851161f, -0.05999304f, 0.03171164f, -0.01253411f, -0.03052254f, -0.00062311f, -0.02736152f, -0.00719595f, 
    -0.03019340f, -0.04061056f, -0.01055519f, 0.02554936f, -0.02986825f, 0.00427790f, -0.04016354f, -0.04684891f, 
    0.03562675f, -0.00281614f, -0.03324375f, 0.02297295f, 0.01932641f, -0.04903265f, 0.02237010f, -0.03156684f, 
    0.02881901f, 0.00744146f, -0.02829070f, 0.01109356f, -0.03808128f, -0.01873546f, 0.03946793f, 0.02184738f, 
    -0.03903198f, -0.04333042f, 0.02876752f, -0.02831672f, 0.00774675f, 0.01581290f, 0.02112995f, -0.04477192f, 
    -0.03472109f, -0.05738178f, 0.02116949f, 0.02558747f, -0.05330000f, -0.04785007f, -0.00894444f, 0.04431839f, 
    -0.02220589f, -0.02125928f, -0.04551183f, -0.00729913f, 0.00523819f, 0.03264030f, 0.02505293f, 0.03719090f, 
    -0.04356391f, 0.01288888f, 0.03606464f, -0.04815687f, 0.00170365f, 0.01571324f, 0.03022762f, -0.01218421f, 
    0.02903310f, -0.04707474f, -0.02637647f, -0.03315641f, -0.03148020f, 0.00748959f, 0.04521294f, 0.00548462f, 
    0.03741424f, 0.03897069f, -0.04124476f, 0.00134759f, -0.03003065f, 0.03502629f, -0.00588664f, 0.04110096f, 
    0.00590327f, -0.04527751f, 0.04557427f, 0.03464282f, 0.00770457f, 0.02536013f, -0.04319613f, 0.02375230f, 
    0.00261120f, -0.00087993f, -0.01873535f, -0.02760056f, -0.03240177f, 0.00512844f, 0.02985352f, -0.04163049f, 
    0.03359098f, 0.01595163f, -0.01189731f, -0.05045554f, 0.01501662f, 0.00747538f, -0.05510198f, -0.02332958f, 
    0.02020678f, -0.00067838f, 0.00201058f, -0.02563580f, -0.05019157f, 0.04652441f, -0.00639025f, -0.05029699f, 
    -0.04524470f, -0.00997153f, 0.04048536f, 0.01631488f, -0.05299191f, 0.00799239f, -0.03728538f, 0.04151030f, 
    0.01635136f, 0.00791644f, -0.00898451f, -0.04424586f, -0.01701506f, -0.04407082f, 0.01262537f, 0.00139348f, 
    -0.00444853f, 0.02897176f, 0.02421016f, -0.03831001f, -0.02461575f, 0.01667565f, 0.00476685f, -0.04931867f, 
    -0.01582811f, -0.03406308f, -0.03628666f, -0.00093871f, -0.00655288f, -0.03157994f, -0.04364046f, -0.01205911f, 
    0.02837949f, -0.05911794f, -0.04273846f, -0.00645999f, 0.01882325f, -0.04348940f, 0.01544233f, -0.05247409f, 
    -0.01895845f, -0.02580547f, -0.02099819f, 0.02767162f, -0.04355996f, -0.02875546f, 0.01227151f, 0.02511101f, 
    -0.01732778f, -0.00565993f, -0.04858563f, -0.04398746f, 0.00959567f, -0.00215030f, -0.02268139f, -0.00816391f, 
    -0.00495759f, -0.03984187f, 0.03529134f, -0.02430679f, 0.03579578f, -0.02755907f, -0.00804428f, 0.04173068f, 
    -0.01792448f, -0.04577838f, 0.00193198f, 0.03398802f, 0.01009015f, 0.02855197f, -0.00993515f, -0.01708464f, 
    -0.03080504f, 0.01739139f, 0.02845950f, 0.00050971f, -0.04340298f, 0.00294015f, 0.00157086f, -0.03224352f, 
    -0.01326964f, -0.03373149f, 0.02934069f, 0.03445859f, -0.00293194f, 0.01066278f, 0.02691465f, -0.03904965f, 
    -0.00302364f, 0.02472085f, -0.02887783f, -0.00056590f, -0.02550291f, 0.03508713f, -0.01520881f, -0.00246521f, 
    0.01375443f, -0.03453208f, 0.02354696f, -0.00430967f, 0.01301484f, 0.03079027f, 0.01602399f, -0.02484464f, 
    -0.01582327f, -0.03987157f, 0.02268988f, 0.01261744f, -0.05202463f, -0.00115323f, -0.05761467f, -0.03222424f, 
    -0.03454045f, -0.04147973f, 0.03794606f, -0.02918501f, 0.02341693f, 0.04321634f, -0.03226567f, 0.00061423f, 
    0.02237748f, -0.04089827f, 0.01671419f, -0.02909303f, 0.00372389f, -0.00989513f, 0.02067106f, 0.00611117f, 
    0.01667723f, -0.02116925f, -0.01074422f, 0.01712388f, -0.03716702f, -0.05599302f, 0.02884313f, 0.02883255f, 
    0.02565121f, -0.04167378f, -0.05355424f, 0.00355283f, -0.05705057f, 0.02417235f, -0.03102660f, 0.03129428f, 
    -0.04328265f, -0.01971927f, 0.03695460f, 0.02320553f, -0.05608051f, -0.02994199f, 0.01227586f, -0.04029023f, 
    0.04042052f, 0.03889273f, 0.01665476f, 0.01152663f, -0.03280571f, 0.03612796f, 0.02653423f, -0.02849592f, 
    -0.01314842f, -0.05630439f, 0.03913473f, -0.00216117f, -0.00148468f, -0.04818844f, -0.00625585f, 0.05064182f, 
    -0.00935840f, 0.01595406f, 0.01829238f, 0.01100492f, -0.03813207f, -0.04655171f, -0.03751941f, -0.03053461f, 
    0.03082309f, 0.01927252f, -0.01071064f, 0.00102673f, -0.04027590f, -0.04046524f, -0.00604933f, -0.03892429f, 
    -0.04357411f, 0.03193573f, 0.00038914f, -0.00958576f, -0.01800980f, -0.00920455f, 0.01500813f, -0.04231901f, 
    0.00967681f, -0.01024819f, -0.01399390f, -0.00309077f, 0.04036758f, 0.00983738f, -0.02161846f, -0.03146721f, 
    0.00387970f, -0.01040312f, 0.03871364f, 0.00810157f, 0.00581191f, -0.02157136f, -0.05818665f, -0.00999904f, 
    -0.02007146f, 0.04466715f, 0.00605247f, 0.02884870f, -0.03194020f, 0.03972024f, 0.01228262f, -0.04274996f, 
    0.03528273f, -0.01810532f, -0.03356905f, -0.00515301f, 0.04230877f, 0.00127682f, 0.01063147f, -0.04930065f, 
    -0.00474341f, 0.04419630f, -0.03972838f, -0.03733646f, -0.00883240f, -0.02763295f, 0.00763491f, -0.04326229f, 
    -0.04210494f, -0.01942709f, 0.00312812f, -0.01545441f, -0.03469505f, 0.00605698f, -0.00866310f, -0.01553346f, 
    -0.03276528f, 0.03958793f, 0.00577686f, -0.01404834f, -0.03802669f, -0.03313515f, -0.01248380f, -0.02993175f, 
    0.00399379f, -0.05012908f, -0.00171891f, 0.01021309f, 0.04060204f, -0.05114499f, 0.02930844f, 0.00835199f, 
    0.03542303f, -0.00651784f, -0.02471410f, 0.04079842f, 0.02436996f, 0.01905798f, -0.01510144f, 0.01287563f, 
    -0.00141912f, -0.12894323f, -0.00968227f, 0.17885159f, 0.03802625f, 0.06794214f, -0.02453733f, 0.04438282f, 
    -0.00723124f, 0.04772438f, 0.10924605f, 0.13227899f, 0.33640048f, -0.07787498f, 0.07190213f, 0.26013577f, 
    -0.01450618f, -0.12023500f, 0.01678280f, 0.06713902f, -0.12622206f, 0.15459482f, 0.04903996f, 0.12319013f, 
    -0.39692616f, -0.32460213f, 0.06752272f, 0.32666597f, 0.13517405f, -0.00577042f, -0.08286598f, 0.15864709f, 
    0.28297099f, 0.14723571f, 0.12803043f, -0.06371679f, -0.27090195f, -0.15703592f, 0.14439921f, 0.07950565f, 
    -0.04003268f, 0.07528988f, -0.04027361f, -0.08825148f, 0.17386362f, -0.02342529f, -0.08399988f, -0.02629218f, 
    0.43508160f, 0.05652989f, 0.02685857f, 0.24279474f, 0.03886535f, 0.00991752f, 0.16314754f, 0.19278555f, 
    0.06391948f, -0.04918260f, -0.08266401f, 0.13634078f, 0.00412141f, -0.13092224f, 0.00221539f, 0.19996464f, 
    0.06161209f, -0.03779129f, -0.07173292f, -0.07165585f, -0.10016646f, 0.13908020f, -0.00156122f, 0.09448791f, 
    -0.04082736f, 0.13438144f, 0.15514185f, 0.24699311f, 0.07205912f, -0.14844492f, 0.03937555f, -0.00848435f, 
    -0.01083849f, -0.08016138f, 0.05738046f, 0.06039993f, -0.15320744f, -0.16093062f, 0.10467169f, -0.23406556f, 
    -0.05554701f, 0.06376715f, 0.07545859f, -0.02192284f, 0.02213759f, -0.03585065f, 0.00253330f, 0.09785197f, 
    -0.19881812f, -0.01605374f, 0.13114996f, -0.06499629f, 0.00803592f, -0.02216799f, 0.12189442f, 0.17748804f, 
    -0.04378395f, -0.12734237f, -0.09051393f, 0.08290936f, -0.32950467f, -0.08877843f, -0.02343451f, -0.43096602f, 
    -0.05971835f, 0.07703149f, 0.10069419f, -0.03546323f, -0.00882676f, -0.12939663f, 0.11858910f, 0.14095686f, 
    -0.03637495f, -0.05745219f, 0.10313028f, -0.16617738f, -0.04675311f, -0.13163997f, -0.12655026f, 0.00471080f, 
    0.22780818f, -0.22892432f, 0.08081568f, 0.15318793f, 0.33761969f, 0.00094768f, 0.13174379f, 0.23327503f, 
    0.18176378f, -0.06838187f, 0.09157098f, -0.05807680f, 0.02222776f, 0.13004762f, -0.01915933f, -0.03888848f, 
    -0.14982624f, -0.02512019f, 0.01177562f, -0.11078852f, 0.03387855f, 0.02422665f, -0.05020639f, 0.04172696f, 
    -0.05031167f, 0.22604634f, 0.08257996f, 0.06644286f, 0.20092845f, -0.11242848f, -0.00074628f, 0.19849865f, 
    0.12756717f, -0.08925737f, 0.02253507f, -0.03897114f, 0.02341130f, 0.07448630f, 0.00175659f, 0.08680681f, 
    -0.39250013f, -0.12704247f, 0.06486937f, 0.09008519f, 0.05786068f, -0.05098891f, 0.02556983f, -0.12565702f, 
    0.03361198f, 0.00722425f, -0.05960380f, 0.08082459f, 0.04917851f, -0.07413024f, 0.09284168f, -0.04366067f, 
    0.07701523f, -0.01559775f, -0.03386142f, 0.07035054f, 0.09726218f, -0.03840538f, 0.07949658f, 0.13053416f, 
    -0.31793240f, -0.06024757f, -0.26256460f, -0.20345789f, 0.00630543f, -0.05940552f, -0.08702850f, 0.10487924f, 
    -0.02043871f, 0.03046433f, -0.03695798f, -0.18098792f, -0.06809878f, 0.06461737f, -0.17503159f, 0.46463376f, 
    -0.09080601f, 0.11351515f, 0.11105631f, 0.04901075f, 0.07799008f, 0.06747435f, 0.19811539f, -0.06926608f, 
    0.03400570f, -0.17748369f, -0.12075056f, -0.04366811f, -0.01965549f, 0.07895397f, -0.05526073f, -0.16134112f, 
    0.01035910f, 0.03683216f, 0.09358018f, 0.02643446f, 0.22535546f, 0.26532063f, -0.10659219f, 0.05028133f, 
    0.13317060f, 0.00750989f, -0.07609394f, 0.08610470f, -0.01589087f, 0.06288227f, -0.06804407f, 0.01113826f, 
    0.18788783f, 0.20789476f, 0.09364702f, 0.01291730f, 0.11374212f, 0.00711438f, 0.22918241f, 0.08782364f, 
    -0.09176356f, 0.00036893f, 0.11346525f, 0.09678199f, 0.28001735f, -0.24609378f, 0.01536684f, 0.31683829f, 
    0.08367176f, -0.05068908f, 0.04687862f, 0.16696090f, 0.03812525f, 0.06438215f, 0.08878624f, 0.03060800f, 
    0.41994014f, 0.09484416f, -0.10536575f, 0.01121619f, -0.05728372f, 0.06892081f, 0.08048742f, -0.10286783f, 
    0.00672084f, -0.04931850f, 0.11589431f, -0.05665079f, -0.12925884f, -0.08147422f, 0.01951951f, -0.02712893f, 
    0.03433757f, 0.21146275f, -0.06025372f, -0.04629282f, 0.08374303f, 0.03579597f, -0.04416854f, 0.09313110f, 
    0.32837325f, -0.44825912f, 0.07875159f, 0.39937258f, -0.04127859f, -0.08589634f, -0.01285319f, 0.06032650f, 
    0.06121345f, -0.04187869f, -0.09676204f, 0.21356080f, -0.19625147f, -0.04378946f, -0.11338577f, 0.31233403f, 
    0.04945662f, 0.24101174f, 0.00189666f, -0.11746779f, -0.00221807f, -0.16955066f, -0.17566867f, 0.14963546f, 
    0.30370626f, 0.21585290f, 0.01024264f, -0.14520453f, 0.01682453f, -0.00805047f, -0.03565479f, 0.01445589f, 
    0.01438512f, -0.05508691f, -0.01161088f, -0.01642641f, -0.20799933f, 0.17123562f, 0.06411697f, -0.12773933f, 
    0.17002586f, 0.02669116f, 0.00086031f, 0.10504072f, -0.03937362f, -0.05371514f, 0.05961884f, -0.04725695f, 
    0.31468073f, 0.29354304f, -0.14839211f, 0.38776082f, -0.08460029f, 0.11984925f, -0.00654640f, 0.10843815f, 
    0.26157862f, -0.11213064f, 0.00473651f, -0.06593076f, -0.18881650f, -0.05111199f, 0.06707116f, -0.31524631f, 
    0.11990613f, 0.06753875f, 0.11602314f, -0.01709329f, -0.00970403f, -0.10897385f, 0.00169798f, 0.06215499f, 
    -0.11366989f, 0.09143846f, -0.13404824f, -0.00799974f, 0.06704375f, -0.00843399f, 0.19425905f, -0.01065203f, 
    0.00489448f, -0.02181251f, 0.06968005f, -0.01627473f, -0.07232657f, 0.05740913f, -0.01765512f, -0.18465874f, 
    0.06414497f, -0.09515053f, 0.09590219f, 0.16694920f, -0.11464190f, 0.16081212f, 0.13635059f, -0.10191072f, 
    0.00989707f, 0.23346587f, -0.02169685f, -0.04546864f, -0.01814552f, 0.04414746f, -0.09055360f, -0.09890625f, 
    0.05827769f, -0.02273397f, -0.11866827f, -0.19230324f, -0.17716429f, -0.04573159f, -0.16173305f, 0.27637428f, 
    0.07287994f, -0.00459176f, -0.06299361f, -0.07336230f, 0.11258040f, -0.18314010f, 0.03804813f, 0.08622181f, 
    -0.06651466f, -0.16633438f, 0.17205256f, 0.19340602f, 0.08264571f, 0.00519302f, 0.15352379f, -0.08739848f, 
    0.18904835f, -0.06536431f, -0.02608048f, -0.00616600f, -0.38477108f, 0.03216423f, -0.06787042f, 0.00746122f, 
    0.09512148f, -0.00357373f, 0.08139214f, 0.14533482f, 0.15323611f, 0.03208620f, -0.00054309f, -0.14788243f, 
    -0.06713510f, 0.01618161f, -0.00449420f, 0.18825714f, 0.04667936f, -0.05017745f, -0.12462969f, 0.07850464f, 
    0.00334188f, 0.10352433f, 0.19775814f, 0.03732245f, 0.21566236f, -0.04964564f, -0.02109146f, 0.01509101f, 
    0.04110658f, 0.08375258f, -0.04133480f, 0.08771826f, 0.13896149f, -0.05905459f, -0.06046092f, -0.03052617f, 
    0.11771589f, -0.03429942f, -0.02212325f, 0.03677545f, -0.02859616f, 0.10287442f, 0.13278075f, 0.00231665f, 
    -0.01193338f, 0.14422046f, -0.14743322f, 0.14966643f, 0.15765426f, 0.28460014f, -0.09252376f, -0.21350013f, 
    0.06022770f, 0.06614514f, 0.01075874f, -0.08168548f, -0.00834143f, 0.01925018f, -0.04486503f, 0.06639688f, 
    -0.12647335f, 0.07031199f, -0.02983592f, -0.12363835f, 0.08272801f, 0.01526230f, -0.02210860f, -0.03504326f, 
    -0.06401861f, 0.05033147f, 0.03431322f, 0.11678927f, -0.19587456f, 0.16987358f, -0.28502756f, -0.23293392f, 
    0.16400874f, -0.17016770f, 0.10565861f, 0.02793174f, -0.02531292f, 0.01273425f, -0.05532337f, -0.08464421f, 
    -0.38118142f, 0.08687717f, -0.00838941f, -0.09011669f, 0.00310200f, 0.12998751f, 0.22110415f, -0.09367670f, 
    0.06918383f, 0.14738505f, -0.19871020f, 0.12313487f, 0.04109124f, -0.04598406f, 0.21206012f, 0.18177596f, 
    -0.08621134f, -0.04470730f, -0.01644775f, 0.05615626f, -0.02377298f, -0.13361566f, -0.01435751f, 0.10193113f, 
    0.06353018f, -0.01887087f, 0.01942578f, 0.08792758f, -0.08558336f, -0.15567598f, 0.08357248f, 0.08692676f, 
    -0.09459724f, -0.01078233f, 0.02094082f, -0.09764252f, -0.11236264f, 0.12587771f, 0.28504026f, 0.10739671f, 
    0.10730037f, -0.04151754f, -0.15582791f, 0.04580187f, -0.01346821f, 0.03414067f, 0.01736928f, -0.12289925f, 
    0.59416360f, 0.00356677f, -0.04100788f, 0.07180036f, -0.07242561f, 0.14736965f, -0.02744481f, 0.14258267f, 
    0.04715683f, -0.00092406f, -0.02161659f, 0.15309994f, 0.04068363f, 0.15188316f, 0.01623973f, 0.02189071f, 
    -0.01251489f, -0.09997135f, 0.04724623f, 0.06192909f, -0.02774880f, -0.19534180f, -0.16113913f, -0.27704772f, 
    -0.00370511f, -0.02961904f, 0.07489460f, -0.06676394f, -0.14810318f, 0.10975941f, 0.26195771f, 0.03290252f, 
    -0.17504987f, -0.06193333f, 0.15439287f, 0.10482863f, 0.19100304f, -0.15993367f, 0.01223558f, 0.14091460f, 
    0.04420352f, 0.02976678f, -0.25727937f, 0.07769708f, 0.03123635f, -0.04213770f, -0.20197196f, 0.08654861f, 
    -0.22131644f, -0.06279631f, -0.13790038f, 0.28205720f, -0.04259147f, 0.00334382f, 0.17854650f, 0.05542175f, 
    0.05535856f, 0.02241287f, -0.02749190f, 0.03151131f, -0.18128638f, 0.09458385f, 0.19346651f, -0.10671034f, 
    0.07737909f, 0.08469329f, 0.06337494f, -0.09969056f, 0.05470528f, 0.08517850f, 0.02789867f, -0.16236508f, 
    0.24600643f, 0.09418891f, 0.00845057f, 0.12864131f, 0.16532287f, -0.06459281f, 0.10816068f, -0.08035205f, 
    0.00865372f, 0.23892370f, 0.01591078f, 0.09330045f, 0.16597560f, -0.01371558f, -0.20123522f, 0.13538782f, 
    0.01735517f, -0.01293196f, -0.04880784f, 0.05114859f, -0.15956737f, -0.08860784f, 0.08379694f, -0.03783229f, 
    0.22550365f, 0.12224131f, -0.06985787f, 0.32386389f, -0.03024326f, -0.09174109f, 0.08212151f, -0.04064573f, 
    0.05325157f, 0.04866933f, -0.00821173f, 0.15709887f, 0.25119480f, -0.04200201f, 0.06104423f, -0.33265382f, 
    -0.02626118f, -0.12961081f, -0.03426953f, 0.00973793f, 0.06556181f, -0.02281605f, 0.15234698f, -0.22446452f, 
    0.21810424f, -0.14020364f, 0.25132170f, 0.14209110f, -0.13288558f, 0.05771072f, -0.09384518f, -0.17220473f, 
    -0.01282931f, -0.06395798f, 0.03789806f, -0.09020609f, 0.15342748f, 0.10296978f, -0.14396311f, 0.02446480f, 
    0.13386548f, 0.01874383f, -0.00014737f, -0.14375259f, -0.06218522f, 0.08067893f, 0.25314170f, -0.00439421f, 
    -0.21162604f, 0.09261672f, 0.06186284f, 0.12038978f, 0.05733049f, 0.04204765f, 0.03815462f, -0.05097240f, 
    -0.06844946f, 0.14154048f, 0.09934763f, -0.14267956f, 0.51357192f, 0.08899036f, 0.12376545f, -0.22172113f, 
    0.09867224f, 0.05211596f, 0.01156800f, 0.00232472f, -0.09492916f, 0.00889347f, 0.05761054f, -0.10501299f, 
    -0.11199119f, -0.03848832f, 0.23348062f, 0.04736467f, 0.07038938f, 0.01451275f, -0.02579658f, 0.12781146f, 
    -0.18139726f, 0.19811207f, 0.16168357f, 0.24108647f, -0.21303360f, 0.21093979f, -0.08083862f, -0.28621799f, 
    0.10292497f, 0.12039619f, -0.02187074f, -0.05004745f, 0.10248358f, -0.06161080f, 0.02686838f, -0.02474348f, 
    -0.23302101f, -0.07817700f, -0.00572513f, 0.07912517f, -0.12509154f, 0.02144209f, 0.02887958f, 0.01804136f, 
    0.02576268f, 0.03723708f, -0.05562488f, 0.03188461f, -0.06444200f, 0.11793890f, 0.25376752f, -0.11481808f, 
    -0.03274930f, -0.06537357f, 0.08733158f, 0.10823372f, 0.10219917f, -0.03690442f, 0.07331026f, 0.24819155f, 
    0.00308412f, 0.00116962f, -0.00647597f, -0.05751715f, -0.05468931f, -0.05118716f, -0.02747122f, 0.00325222f, 
    0.02765082f, -0.00097578f, 0.02768784f, -0.02414895f, -0.00060327f, 0.03653026f, 0.03080492f, -0.03930308f, 
    -0.02776725f, -0.02641847f, -0.04198477f, -0.00485197f, -0.05663842f, 0.01692128f, -0.02109316f, 0.01706803f, 
    0.00731942f, -0.02058474f, 0.03734602f, -0.00457054f, 0.02685540f, -0.02225042f, 0.02792008f, 0.02198202f, 
    0.00513493f, -0.02662258f, 0.04013507f, 0.01456977f, -0.05950643f, 0.01109974f, 0.03412516f, -0.00041266f, 
    0.03467252f, -0.05251368f, 0.03315090f, 0.02495706f, -0.02219806f, -0.04801201f, -0.00743686f, -0.02618376f, 
    0.01754742f, -0.04864142f, -0.04098629f, -0.03217055f, -0.05395257f, 0.01666583f, 0.04116503f, -0.04046611f, 
    0.02361222f, -0.03502251f, -0.01766123f, 0.02632745f, 0.00272541f, -0.03079557f, -0.05817560f, -0.02579373f, 
    -0.04873187f, 0.02554046f, 0.04027964f, -0.02271030f, 0.00435196f, -0.05541016f, 0.02598432f, 0.01290786f, 
    -0.00592474f, -0.03037754f, 0.00133717f, 0.02945095f, 0.01895518f, -0.03540123f, 0.02712751f, -0.02310182f, 
    -0.03251444f, -0.01819625f, 0.00021684f, 0.01974698f, -0.03427338f, 0.03302538f, -0.00370887f, 0.04158867f, 
    0.02688967f, -0.04456817f, 0.03292898f, -0.00042636f, 0.02721001f, -0.04528814f, 0.02171417f, -0.02610334f, 
    0.03488558f, -0.00372401f, 0.00215885f, -0.04282048f, 0.02093568f, 0.00893345f, 0.03524423f, 0.00964279f, 
    -0.01620761f, -0.05222769f, -0.01573047f, -0.00388486f, 0.03088734f, -0.03864159f, 0.00918912f, -0.05883358f, 
    0.03258613f, -0.03938973f, 0.01956703f, -0.01123585f, 0.00356485f, 0.01418082f, -0.03606625f, 0.02057501f, 
    0.01971022f, -0.02661449f, -0.02435142f, -0.00448748f, 0.00582609f, 0.01390991f, 0.01038898f, -0.05669641f, 
    -0.00719127f, 0.03328651f, -0.00546805f, -0.01482979f, 0.03070748f, -0.03440249f, -0.03967264f, -0.00966072f, 
    0.02853656f, -0.04609794f, 0.02917812f, 0.01742937f, -0.01152645f, 0.01279912f, 0.00191852f, -0.05064663f, 
    -0.00724231f, 0.01886781f, -0.05775932f, -0.00933832f, -0.01161194f, -0.05754655f, -0.02788678f, -0.02146648f, 
    -0.03989548f, -0.03090806f, 0.03593115f, -0.02267392f, -0.01713433f, -0.01465228f, 0.03479930f, -0.00086202f, 
    -0.04746388f, 0.02531887f, -0.01480387f, -0.05512357f, 0.03975577f, -0.00162176f, 0.01714811f, -0.03839374f, 
    0.02859633f, -0.00335031f, -0.03424731f, -0.04605782f, -0.03234350f, 0.01317607f, 0.03251348f, 0.00930274f, 
    0.03554465f, -0.01266949f, -0.05460961f, -0.01327783f, -0.04924475f, -0.02890595f, -0.02162126f, 0.01427497f, 
    -0.04812295f, -0.03950111f, 0.02320670f, -0.02530136f, 0.03892254f, -0.04692805f, -0.04098392f, -0.02405429f, 
    -0.04315943f, -0.02704839f, -0.02022091f, -0.02301437f, 0.01440298f, -0.04102887f, 0.01121302f, -0.05105858f, 
    0.03654604f, -0.03320536f, -0.01243676f, 0.04248220f, -0.03620763f, -0.01207381f, 0.01363502f, -0.03107266f, 
    0.02843756f, -0.04451382f, -0.01003749f, -0.00678060f, 0.03058332f, -0.03332581f, 0.00980893f, 0.02377668f, 
    0.01098216f, -0.04385234f, 0.00329223f, -0.00999794f, 0.01971281f, -0.02823469f, 0.00373302f, 0.01329629f, 
    -0.05186908f, -0.00486345f, -0.05518189f, 0.03000347f, -0.03757412f, 0.00243400f, -0.00460407f, 0.04081885f, 
    -0.04159702f, 0.00309187f, 0.02563806f, 0.02329753f, -0.01622408f, 0.01485372f, -0.03417051f, 0.03342931f, 
    -0.05826529f, -0.04210008f, 0.03273288f, 0.01589818f, 0.02359001f, -0.03671794f, -0.00181449f, 0.00366096f, 
    0.01421678f, -0.04636379f, 0.00311138f, -0.05576660f, 0.02682522f, -0.02509838f, -0.01203077f, -0.01670669f, 
    -0.00780359f, 0.01123330f, 0.02173042f, -0.04872666f, -0.00840106f, 0.03354825f, -0.00974635f, -0.00884207f, 
    -0.05810119f, 0.02143363f, -0.01648623f, 0.03318646f, -0.00986096f, -0.02998836f, -0.00585838f, -0.00817482f, 
    0.02385434f, 0.03158985f, 0.01214694f, 0.00744835f, -0.05195741f, -0.03210481f, 0.03295614f, 0.00387868f, 
    -0.03388646f, 0.03424786f, 0.02301107f, 0.00263380f, 0.01951645f, -0.00460217f, 0.03982396f, 0.02812091f, 
    0.01410467f, -0.01353303f, -0.00773389f, -0.01891596f, 0.01534778f, -0.00955657f, -0.00575649f, -0.01913893f, 
    0.00353111f, 0.01988949f, -0.02667774f, -0.01393308f, 0.01774346f, -0.01813878f, -0.00297932f, -0.04749010f, 
    -0.02085110f, -0.01572987f, -0.03258587f, -0.02609490f, -0.00301685f, 0.03456384f, 0.01757043f, 0.03650253f, 
    -0.05648337f, -0.04783306f, -0.04499983f, 0.03392693f, 0.00435519f, 0.00338079f, -0.01125075f, -0.03816808f, 
    -0.00579159f, 0.03475768f, -0.04242123f, -0.05063811f, -0.02954596f, -0.00073139f, 0.03911687f, -0.03531389f, 
    -0.02129411f, -0.00283750f, 0.02133202f, -0.03078020f, -0.01673375f, -0.04740467f, -0.03653502f, -0.02085565f, 
    -0.03842988f, 0.02002399f, 0.01806494f, 0.02680993f, -0.03657678f, 0.01702886f, -0.03308032f, -0.05926635f, 
    -0.00537437f, -0.01715688f, -0.03877277f, -0.01409344f, -0.05594713f, -0.03525226f, -0.04652352f, 0.00406013f, 
    -0.02904837f, 0.02930647f, -0.05401073f, -0.02749146f, 0.02154576f, 0.02997001f, -0.02665470f, 0.02536279f, 
    -0.02145828f, -0.04075972f, 0.03298027f, -0.00915295f, -0.00054142f, -0.05876492f, 0.01589360f, -0.04408924f, 
    -0.02597054f, 0.03977271f, 0.01722810f, -0.02675184f, 0.03954651f, 0.03881622f, 0.01462955f, -0.01642305f, 
    -0.00947475f, -0.00254163f, 0.03130800f, 0.00747386f, -0.00712873f, -0.05668005f, -0.00078075f, -0.03007262f, 
    0.17144971f, 0.49825892f, 0.13141628f, 0.04101406f, -0.02395939f, 0.02837534f, 0.02963276f, -0.04493338f, 
    -0.23448992f, -0.05674094f, 0.15312666f, 0.07655358f, 0.20847522f, -0.06553295f, 0.00024780f, -0.15398668f, 
    -0.06444784f, -0.13603906f, 0.04692648f, 0.00858460f, -0.13963194f, 0.10539353f, -0.06417276f, 0.12439355f, 
    0.22161822f, -0.14333542f, 0.36570913f, 0.03451541f, -0.00735478f, 0.05677962f, 0.06288369f, 0.11193503f, 
    -0.05595495f, 0.06779720f, 0.11743515f, 0.06289696f, 0.36886296f, 0.31015846f, 0.17791414f, 0.05410478f, 
    -0.02287219f, 0.02582086f, 0.12607865f, 0.04211356f, -0.05204822f, 0.09489392f, -0.06057024f, -0.10097925f, 
    0.07660203f, -0.07990100f, -0.05819675f, 0.18283442f, -0.08769146f, 0.22776850f, -0.06318913f, 0.05176294f, 
    -0.05179943f, -0.05027221f, -0.08794539f, 0.18483572f, -0.42174238f, -0.18105294f, -0.30127141f, 0.22530225f, 
    0.04899676f, 0.03251286f, -0.00450986f, -0.05534624f, 0.07391729f, 0.05232599f, 0.08699013f, -0.07140364f, 
    -0.04143529f, 0.13746759f, 0.07449397f, 0.10618596f, -0.06894942f, -0.14292735f, 0.14605731f, -0.00128489f, 
    -0.12015908f, -0.15633543f, 0.06746271f, -0.03413109f, -0.15148622f, 0.27849048f, 0.14093809f, -0.12261070f, 
    0.00451787f, -0.04198038f, 0.04342453f, -0.02213615f, 0.03891093f, 0.01496359f, 0.10925897f, 0.05528213f, 
    0.32600060f, 0.22777452f, 0.10726202f, -0.07780121f, -0.01756154f, 0.16863114f, 0.15631998f, 0.00857593f, 
    -0.01382479f, -0.06613016f, -0.10295626f, 0.04026665f, -0.08427648f, 0.31292990f, 0.12691087f, -0.28472498f, 
    0.11611135f, 0.00008460f, 0.01534698f, -0.14600803f, 0.02192738f, 0.10394961f, -0.12734666f, 0.02380515f, 
    0.14125736f, 0.13761829f, 0.12279594f, -0.07946713f, 0.05733733f, -0.00891705f, -0.01991983f, 0.10359187f, 
    0.11057094f, 0.07113012f, 0.01088115f, -0.01081886f, 0.03307829f, 0.06609061f, -0.24498764f, 0.31606200f, 
    0.10463938f, 0.06153129f, 0.11566013f, -0.01552723f, -0.02676021f, 0.15231684f, 0.06850626f, -0.19087687f, 
    0.00813779f, -0.29199487f, -0.13270287f, -0.12978876f, 0.20350376f, 0.11334010f, 0.04456393f, -0.05652666f, 
    -0.00776483f, 0.08929822f, 0.03887642f, 0.04386798f, -0.17257650f, -0.03999748f, -0.14454667f, 0.26672259f, 
    0.01603116f, -0.05732414f, -0.00484791f, -0.14471705f, 0.07675992f, -0.12025858f, -0.11750043f, 0.23398367f, 
    -0.65965945f, -0.43839487f, -0.00133088f, 0.03042255f, -0.03232905f, 0.08693876f, 0.09447686f, -0.19409052f, 
    0.00342218f, -0.08581693f, -0.06666430f, -0.04861794f, 0.03740323f, 0.15249340f, 0.04369782f, -0.28319010f, 
    -0.07120967f, -0.10198221f, -0.09700005f, 0.12195306f, -0.11161150f, 0.05547157f, 0.04882736f, 0.21674533f, 
    -0.07882163f, -0.12210803f, -0.13005069f, -0.35093972f, 0.20389137f, 0.07840542f, 0.05076524f, 0.09352355f, 
    0.00256882f, 0.03137471f, -0.08216484f, -0.15152389f, -0.52542078f, -0.00478248f, -0.06046024f, -0.01905628f, 
    0.10929338f, 0.07844716f, 0.04365348f, 0.00572351f, 0.07392760f, -0.03965448f, 0.15254234f, -0.09172630f, 
    0.02497301f, -0.15963170f, -0.15913157f, -0.17379513f, 0.18626662f, 0.13773645f, -0.06868442f, -0.04116961f, 
    0.05305196f, 0.03378978f, 0.09282307f, -0.06485049f, 0.07030873f, -0.22952844f, -0.10705514f, 0.01505827f, 
    0.11377262f, 0.08388706f, 0.15860887f, -0.04122778f, -0.05471591f, 0.15392928f, -0.03775731f, -0.06504531f, 
    -0.12699595f, 0.01602914f, 0.06709482f, 0.10979235f, 0.09057783f, -0.10521457f, 0.09058470f, 0.06586764f, 
    0.00162118f, 0.01043561f, 0.02411466f, 0.02704412f, 0.14520933f, 0.06761225f, 0.26380804f, 0.20609342f, 
    -0.04266364f, -0.10919693f, -0.05274780f, 0.21565647f, 0.17045894f, 0.02514328f, -0.00336798f, 0.03598317f, 
    -0.00126114f, 0.00858379f, 0.06145106f, 0.06716044f, 0.06283699f, 0.11914448f, -0.07828949f, -0.10464157f, 
    0.11071944f, -0.06032145f, -0.00758867f, -0.06312976f, 0.13147856f, 0.01991798f, 0.06697708f, 0.19330096f, 
    0.11418741f, 0.25420657f, -0.15320227f, -0.16389088f, 0.10763972f, 0.03791350f, -0.20448013f, 0.07663862f, 
    0.31634700f, 0.09108318f, 0.14269571f, 0.29168528f, -0.13276641f, -0.17833300f, -0.12878388f, 0.00864742f, 
    -0.02483358f, -0.08843525f, 0.02862268f, 0.19423598f, -0.30651316f, 0.40578121f, -0.04653990f, 0.16177498f, 
    0.05327334f, 0.12414771f, 0.12229135f, -0.07139014f, 0.01461709f, -0.12597129f, 0.11018977f, 0.13477087f, 
    0.03795242f, 0.03840369f, -0.24152154f, -0.01284687f, 0.11486638f, -0.03621780f, 0.05686917f, 0.07198645f, 
    -0.02634154f, -0.08098251f, -0.06611412f, -0.07496743f, 0.14150275f, 0.19051670f, -0.17014202f, 0.09114414f, 
    0.02768979f, -0.05850658f, -0.03477253f, 0.00249786f, 0.15396236f, -0.18935186f, 0.05573317f, -0.12751654f, 
    0.25829107f, 0.19058359f, -0.43390724f, 0.02729668f, 0.15069471f, 0.06359071f, 0.01512693f, -0.09910330f, 
    -0.02838828f, -0.06973004f, -0.09402937f, -0.14834899f, -0.04333210f, 0.20775442f, 0.07207771f, -0.11766733f, 
    -0.00978039f, 0.02981108f, 0.06497682f, 0.03498676f, 0.02423538f, -0.00717803f, 0.06809364f, 0.08123756f, 
    -0.41752809f, -0.29175770f, -0.20905544f, -0.04613032f, 0.13119330f, 0.13724808f, 0.13514563f, -0.09773602f, 
    -0.03890641f, -0.01834279f, -0.00423325f, 0.02984474f, 0.21231160f, -0.01925782f, -0.00251804f, -0.11527024f, 
    0.00713112f, 0.05500325f, -0.07787809f, -0.04485831f, -0.04360262f, 0.16608843f, 0.15902469f, -0.02189926f, 
    -0.00582928f, -0.21522255f, -0.03806946f, 0.11602214f, 0.01619536f, 0.00337883f, 0.14931066f, 0.01571880f, 
    -0.07738545f, 0.01765483f, -0.19898008f, 0.01696419f, 0.28432408f, 0.12111354f, 0.17979461f, 0.19243856f, 
    0.08477367f, 0.15635213f, 0.01297574f, 0.05567592f, 0.17151435f, -0.09183724f, -0.05448631f, -0.15461300f, 
    -0.09071644f, -0.05757076f, 0.34517762f, -0.24401356f, -0.16736569f, 0.05176710f, 0.24089026f, 0.09514555f, 
    -0.06301212f, -0.02899976f, -0.19997595f, 0.08272481f, -0.06134428f, -0.18710166f, 0.07552838f, -0.18955664f, 
    -0.06110391f, -0.16058321f, -0.01818011f, 0.22280324f, -0.03439622f, 0.03066684f, 0.14171663f, -0.11058264f, 
    0.14238451f, 0.09460700f, 0.05611882f, 0.07094180f, 0.02788418f, -0.11103454f, -0.14723055f, -0.12104394f, 
    -0.01206500f, 0.14328320f, -0.01623641f, -0.15697448f, -0.01113466f, 0.24969545f, 0.09003241f, -0.04588924f, 
    -0.12437709f, 0.01414057f, -0.01786112f, 0.13115537f, -0.03310401f, -0.16314256f, 0.09051336f, -0.10588297f, 
    0.26246160f, 0.04286935f, -0.12065285f, -0.00066420f, 0.12424140f, 0.07933421f, 0.24540411f, 0.20647213f, 
    -0.11299827f, 0.05575031f, -0.02742590f, 0.00228722f, 0.03735216f, -0.08987242f, -0.03590648f, 0.16119283f, 
    -0.02290333f, 0.01915804f, -0.02198923f, -0.05689187f, -0.01421926f, -0.04761045f, -0.06919097f, -0.12864894f, 
    -0.29701585f, 0.11660630f, -0.06314527f, -0.06686809f, -0.14501186f, 0.01894790f, 0.03574150f, -0.16808496f, 
    -0.03946559f, -0.00567076f, 0.05266083f, -0.00409547f, 0.14785881f, -0.02517168f, -0.10621735f, 0.15471916f, 
    -0.13659388f, 0.01479125f, -0.04190516f, 0.10729963f, -0.10269437f, 0.07504777f, 0.07941143f, -0.03298665f, 
    -0.21751259f, -0.04820102f, -0.00462454f, -0.07761902f, -0.03133405f, 0.06567010f, 0.37089679f, -0.06320345f, 
    -0.02855223f, 0.24465293f, -0.13182047f, 0.06365053f, -0.08832888f, 0.26314461f, 0.00594566f, 0.12267416f, 
    0.04753020f, -0.05256454f, -0.14778298f, 0.07454275f, -0.10500810f, -0.03152643f, 0.07256377f, 0.13078432f, 
    0.21991891f, 0.21445285f, 0.02611514f, -0.07863142f, -0.01815314f, -0.13499592f, -0.11842861f, 0.16799590f, 
    -0.00587132f, -0.01662424f, -0.01513432f, -0.17242347f, -0.09976665f, 0.12859750f, 0.20122835f, 0.04284645f, 
    -0.14657488f, 0.05671165f, -0.02299566f, 0.01035567f, -0.04705733f, 0.07008503f, -0.00578981f, -0.09203716f, 
    -0.09375207f, 0.27201450f, 0.04618392f, -0.12600353f, 0.04709432f, 0.01446657f, 0.15781459f, 0.21592669f, 
    0.01507033f, 0.08285791f, 0.07317978f, -0.12278065f, -0.04556261f, 0.25503647f, 0.06760670f, 0.15147269f, 
    0.02813650f, 0.07707138f, 0.05125130f, -0.02435125f, -0.00751080f, 0.11414909f, -0.13496491f, -0.24561904f, 
    -0.03205794f, -0.07356380f, 0.00232182f, -0.11429574f, 0.18858154f, -0.05999414f, 0.04849073f, 0.06589634f, 
    0.06216990f, 0.07928573f, -0.01212303f, 0.11544728f, 0.40626550f, 0.08683570f, 0.22278486f, -0.04874817f, 
    0.11826658f, -0.06080230f, 0.10316143f, 0.13290557f, -0.02673899f, 0.02632662f, -0.19052987f, 0.12353001f, 
    0.43395844f, 0.13054588f, 0.14826967f, -0.03902419f, 0.07951540f, -0.10453875f, 0.14454931f, 0.25678107f, 
    -0.02900674f, 0.03464207f, -0.12205790f, 0.13046247f, 0.37482893f, -0.16538049f, 0.02110856f, 0.07612921f, 
    -0.18846242f, 0.08147493f, 0.03367176f, -0.07489730f, -0.13933071f, -0.01650923f, -0.02386914f, 0.00130820f, 
    0.07362601f, 0.17691620f, -0.14097606f, 0.04119201f, -0.04243296f, -0.06207488f, -0.09767847f, 0.15996730f, 
    0.10386822f, 0.17237975f, -0.10320142f, -0.05302522f, 0.10208657f, -0.21333463f, -0.01397479f, -0.07094252f, 
    0.09388795f, 0.10574855f, 0.04909404f, -0.15567368f, -0.10009070f, -0.06160158f, -0.00803010f, -0.09482446f, 
    0.04519442f, 0.06661556f, 0.04123700f, 0.25885463f, 0.08157447f, 0.03074917f, 0.01277577f, 0.17100050f, 
    0.14053576f, 0.08554093f, -0.13073765f, 0.09814050f, -0.12784719f, 0.13419613f, -0.10750908f, -0.12873307f, 
    -0.09436347f, -0.17565231f, 0.13674207f, 0.06992006f, -0.02515496f, 0.05189088f, -0.13240816f, -0.09042990f, 
    -0.40219125f, 0.12401754f, -0.02098791f, 0.01624069f, 0.09251016f, 0.09169947f, 0.09962765f, 0.09843634f, 
    0.07463945f, 0.22087848f, 0.06675841f, -0.22094929f, 0.18520010f, -0.13266107f, 0.01766369f, -0.15601031f, 
    -0.01710366f, -0.12968771f, 0.20505787f, 0.10231932f, 0.00939427f, 0.22112517f, 0.12495783f, 0.13715106f, 
    0.47660592f, -0.15139318f, 0.10419878f, 0.07696304f, -0.06497826f, 0.00672815f, 0.05171843f, 0.08345532f, 
    -0.04841429f, 0.10875297f, 0.13830347f, -0.02505202f, 0.27660963f, -0.01618928f, 0.01345785f, 0.35239145f, 
    -0.07915489f, 0.04550421f, 0.01005887f, -0.11792041f, -0.07137048f, 0.00619032f, 0.04140942f, -0.05772340f, 
    -0.11315413f, -0.07204970f, 0.25501370f, 0.14679794f, 0.02103405f, 0.03229434f, -0.10899629f, 0.16675371f, 
    -0.06651517f, 0.21954551f, 0.20019600f, 0.14138424f, 0.21267898f, 0.10468053f, -0.10695850f, 0.16572668f, 
    -0.13387467f, 0.11405833f, 0.09386501f, -0.00695358f, -0.11393418f, -0.11847948f, 0.00302781f, 0.12200084f, 
    0.58795279f, 0.23487796f, -0.16284524f, 0.13524111f, -0.03239749f, -0.07437328f, -0.01687272f, 0.13900927f, 
    -0.11869728f, -0.04399256f, 0.04988064f, 0.23373309f, 0.41814914f, 0.14649129f, -0.21672747f, 0.28398827f, 
    -0.00806845f, 0.11420398f, -0.14296404f, -0.03417107f, -0.06037078f, 0.04037899f, 0.02219760f, 0.12155950f, 
    0.39631706f, 0.24220474f, -0.02000365f, -0.13812551f, 0.11644949f, 0.11777016f, 0.06780641f, 0.07179400f, 
    -0.01661880f, -0.02073772f, -0.07141449f, 0.18574570f, -0.09332089f, -0.08497924f, -0.01131026f, 0.01061490f, 
    -0.01889254f, -0.08305562f, 0.16723309f, 0.15994103f, -0.14865679f, 0.15018353f, -0.16903418f, 0.02791437f, 
    0.36884248f, 0.05615195f, 0.23398434f, -0.48109984f, -0.15318087f, 0.02105772f, 0.00373054f, 0.03386007f, 
    -0.12755695f, 0.02712896f, 0.13385491f, 0.08340791f, 0.64327335f, 0.07776968f, 0.03294055f, -0.13027260f, 
    0.10716661f, -0.11013030f, 0.07776847f, 0.08501271f, -0.05757831f, 0.08921459f, 0.00324380f, 0.18111001f, 
    -0.22562550f, -0.09830532f, -0.00387670f, 0.19255611f, 0.02630528f, 0.06871793f, -0.00880757f, 0.10250951f, 
    -0.00984182f, 0.21411654f, -0.04182728f, 0.17029840f, -0.07833895f, 0.13171722f, 0.17048086f, -0.14429156f, 
    -0.03842281f, -0.13698049f, 0.16455075f, -0.03462722f, 0.04487576f, 0.11575560f, 0.11068576f, -0.06947095f, 
    -0.05969115f, -0.06663349f, -0.12965357f, -0.09928691f, 0.02922655f, -0.08489409f, -0.05060888f, -0.09819196f, 
    -0.05630698f, -0.14468250f, 0.03647738f, -0.06196205f, 0.09972747f, -0.03562080f, -0.24901342f, 0.14351420f, 
    0.03877639f, -0.04469151f, 0.05828956f, 0.02161305f, 0.08291046f, -0.02500000f, -0.00741608f, -0.01388368f, 
    0.36954921f, -0.00486019f, -0.02882570f, -0.14704196f, 0.06125784f, -0.01375075f, 0.02574293f, -0.06302416f, 
    0.14462022f, -0.06263803f, -0.10362440f, 0.13100299f, 0.17646936f, -0.11479672f, -0.06267883f, 0.19467491f, 
    0.19123848f, 0.11511178f, -0.07502677f, -0.10098522f, -0.03364318f, 0.06983636f, -0.09550906f, -0.05153025f, 
    0.24083686f, 0.13984157f, -0.07689844f, -0.02781304f, 0.14916340f, -0.04633233f, -0.04980398f, 0.07863314f, 
    -0.01781205f, -0.09214240f, -0.11118581f, -0.21772143f, -0.07648479f, -0.00868945f, -0.01064963f, 0.05765772f, 
    -0.10516658f, 0.10074472f, -0.03777459f, 0.06477713f, 0.07488465f, 0.09647896f, 0.03403176f, -0.00327187f, 
    0.04987424f, 0.07203162f, -0.02502907f, -0.17896338f, 0.07450982f, 0.05262166f, -0.05242230f, 0.03756781f, 
    0.12449107f, 0.07944485f, -0.00032348f, 0.13043280f, -0.01248179f, -0.06565659f, -0.10762388f, -0.01014078f, 
    -0.02637378f, -0.06705632f, 0.02561055f, -0.02420422f, 0.15001622f, -0.13844299f, -0.10840535f, 0.10762867f, 
    -0.18056515f, -0.27163577f, 0.26253885f, -0.38119531f, 0.05261303f, 0.02035751f, -0.08194888f, -0.06902266f, 
    0.10015619f, -0.06220723f, -0.13530475f, -0.12428325f, -0.06379672f, -0.10337523f, 0.01354642f, -0.13856736f, 
    -0.01136658f, -0.04453698f, -0.01188237f, 0.08174487f, -0.12049214f, 0.24847408f, 0.18052603f, 0.26100674f, 
    0.39863449f, 0.11443494f, 0.10956743f, -0.09783147f, 0.13058791f, -0.01558070f, -0.09412000f, 0.04164426f, 
    0.09589866f, 0.04521486f, -0.11307625f, -0.11313796f, -0.20196579f, -0.07598597f, 0.07684505f, -0.30989268f, 
    -0.01175012f, 0.00897933f, 0.02588121f, -0.04588501f, 0.10258721f, 0.00088859f, 0.05243025f, 0.03500656f, 
    0.34294999f, 0.19137305f, 0.11189682f, -0.20576845f, -0.03636785f, -0.01613329f, -0.12436648f, 0.14444895f, 
    -0.06241359f, 0.01665624f, 0.03941474f, -0.13367809f, 0.05218378f, -0.13947730f, -0.24086007f, 0.23812391f, 
    0.09458345f, 0.00404986f, -0.05917179f, -0.08525061f, 0.10898986f, -0.01617566f, -0.05581835f, 0.03993831f, 
    -0.27372018f, 0.18083459f, -0.02234096f, 0.25995380f, -0.08592883f, -0.01370799f, -0.04777314f, 0.16587538f, 
    -0.02466591f, -0.07905982f, -0.10736958f, 0.03053450f, 0.14104040f, 0.08392462f, 0.25256905f, -0.14468686f, 
    0.03703937f, -0.03356354f, 0.02060140f, 0.10962952f, 0.18775430f, 0.02102527f, -0.02376127f, 0.12405068f, 
    -0.16974147f, -0.16206443f, 0.24982744f, 0.00669835f, 0.11458662f, 0.09006561f, -0.16685128f, -0.01999630f, 
    -0.04060343f, -0.04803826f, 0.00687538f, -0.06762271f, -0.03471408f, -0.24666406f, -0.14798519f, 0.08438312f, 
    -0.04617102f, 0.05225881f, 0.01686303f, 0.02169234f, -0.07818662f, -0.03077593f, -0.03821883f, 0.20291628f, 
    0.33041388f, 0.36961585f, 0.04269645f, -0.21005067f, 0.09505123f, 0.01150990f, 0.08489862f, -0.00648576f, 
    0.01783617f, 0.01993628f, 0.08404189f, 0.12402878f, 0.22802486f, 0.01093990f, 0.19876291f, -0.20722353f, 
    0.04688482f, -0.01730690f, 0.06469579f, -0.00891642f, 0.16321068f, -0.13172805f, -0.07970769f, -0.05497520f, 
    0.07691477f, -0.04352227f, -0.09679075f, -0.11867516f, -0.03970411f, -0.10181952f, -0.00985227f, -0.00625201f, 
    -0.01886537f, -0.01069629f, -0.07243181f, 0.09405485f, -0.37158075f, 0.25849336f, -0.25793111f, 0.50091332f, 
    -0.15516466f, -0.03795841f, -0.11658973f, -0.01480057f, 0.11101139f, -0.06086679f, 0.14233188f, 0.03190275f, 
    -0.17784625f, 0.01247930f, -0.09490018f, -0.03758959f, 0.08327630f, -0.02547367f, 0.06798694f, -0.13756907f, 
    -0.05104361f, 0.04584032f, -0.01632402f, -0.19865042f, 0.09497320f, -0.07316554f, -0.28034759f, 0.19716772f, 
    0.02589775f, -0.10950721f, -0.02293940f, 0.04306353f, 0.17611608f, 0.03860507f, 0.02400445f, -0.06149213f, 
    0.22986843f, -0.00680357f, -0.14616288f, 0.11985701f, 0.08444978f, -0.06622589f, 0.06728007f, 0.04988153f, 
    0.02013277f, 0.00471585f, -0.01658561f, -0.02816299f, 0.02348909f, 0.27735856f, -0.10563251f, 0.20520242f, 
    -0.04882483f, -0.01089681f, -0.09148345f, -0.08975618f, -0.02418192f, 0.03623785f, 0.08456049f, 0.03694668f, 
    0.03125225f, -0.00234264f, 0.01346455f, 0.03301687f, -0.01610600f, -0.00948056f, -0.02755926f, -0.05148588f, 
    0.03980658f, -0.02011154f, -0.03340857f, -0.02710180f, 0.03189784f, 0.00707170f, -0.03968809f, -0.01897214f, 
    0.00710941f, -0.05484232f, -0.02489848f, -0.00817033f, -0.04942146f, 0.04256538f, -0.04959175f, -0.01555090f, 
    -0.00775668f, -0.04371969f, -0.00630797f, -0.01904806f, 0.01016772f, 0.00499655f, 0.04120893f, -0.01741969f, 
    -0.04827823f, -0.01464517f, -0.01174913f, -0.00942715f, -0.00830792f, -0.01697477f, 0.03273585f, -0.02049902f, 
    -0.02146133f, 0.02124980f, -0.01489554f, -0.00216501f, -0.01236134f, 0.04256766f, -0.01166908f, -0.04684538f, 
    0.01802022f, 0.03678611f, -0.02771616f, -0.00806666f, -0.04293294f, -0.02214923f, 0.03896800f, -0.03750034f, 
    0.01555484f, -0.00457003f, -0.03979143f, -0.04528444f, 0.01981233f, -0.02352646f, -0.04786062f, -0.01053730f, 
    -0.03150019f, 0.01365209f, 0.00556013f, 0.01164458f, -0.02263411f, -0.01001919f, 0.01868847f, 0.02611178f, 
    0.02454109f, 0.04273640f, 0.00369557f, -0.00385798f, -0.00702719f, -0.03983242f, -0.01723771f, -0.00620172f, 
    -0.00578769f, 0.00117743f, -0.04604622f, -0.04458629f, 0.00355293f, 0.02411829f, -0.05416770f, -0.00886715f, 
    0.01156940f, -0.04389958f, -0.02118018f, 0.01968069f, 0.03693635f, -0.04481842f, -0.00694089f, 0.00266668f, 
    -0.05563123f, 0.00631334f, -0.02720902f, -0.03340999f, 0.03567883f, -0.02534969f, 0.01453270f, 0.02479575f, 
    0.03695200f, -0.00392597f, 0.02743355f, 0.02724865f, -0.00945161f, 0.02837315f, -0.05673053f, -0.03488243f, 
    -0.04343345f, -0.01208352f, -0.03794301f, 0.03268526f, 0.02033066f, -0.02942022f, -0.00615508f, 0.02762347f, 
    -0.01692224f, 0.00157313f, -0.00185050f, -0.05033734f, 0.00299072f, -0.01509675f, 0.02401989f, -0.04851899f, 
    0.00111129f, 0.00235391f, -0.01865949f, 0.03501719f, -0.04769110f, 0.02834976f, -0.00750082f, 0.03903380f, 
    0.00320684f, -0.00061529f, -0.05269495f, -0.05140388f, -0.00491178f, 0.03049001f, -0.04660854f, 0.01127490f, 
    -0.04700746f, 0.02810897f, 0.02974099f, -0.03073595f, -0.01839872f, -0.03854516f, -0.01229521f, 0.03977294f, 
    -0.02823443f, -0.03887580f, -0.04084619f, -0.04235366f, -0.01803437f, 0.03592518f, 0.01890692f, -0.04456212f, 
    0.03388378f, 0.00520121f, -0.01869377f, -0.01423814f, 0.01970315f, -0.04599711f, -0.04018908f, 0.02294905f, 
    -0.02383683f, 0.02710787f, -0.02867084f, -0.00273867f, 0.00519157f, -0.04832064f, -0.05488614f, 0.00316717f, 
    0.04317914f, 0.03052888f, -0.05563203f, -0.03458764f, -0.05338724f, 0.02171239f, 0.03116331f, 0.00742602f, 
    -0.04445408f, -0.00528966f, -0.04251219f, 0.03867143f, -0.02711514f, -0.00690730f, -0.02479678f, -0.02822329f, 
    0.01550113f, -0.02804847f, -0.03170307f, -0.04647202f, -0.00906454f, 0.02207664f, 0.01810927f, -0.02417785f, 
    0.04345955f, 0.02331148f, 0.03139644f, 0.02554050f, 0.02509522f, -0.01201899f, -0.03761543f, 0.01741828f, 
    -0.03308893f, -0.03805391f, 0.03889266f, 0.03780298f, -0.02822028f, 0.02983653f, 0.00112627f, -0.02568899f, 
    -0.02103673f, -0.01942869f, -0.00017278f, 0.01041586f, 0.01072011f, -0.02740642f, -0.04306189f, -0.01485534f, 
    -0.02747390f, 0.04004615f, -0.03372817f, 0.02928183f, 0.02990323f, -0.05749368f, 0.01906973f, 0.03473622f, 
    0.01490861f, -0.02009493f, -0.01266517f, 0.01857166f, 0.01301480f, -0.02061963f, -0.04997812f, 0.00864427f, 
    -0.01101877f, -0.04291460f, 0.01946579f, -0.02033377f, 0.01859281f, 0.00959038f, -0.04204571f, -0.03339989f, 
    0.01737822f, 0.03643846f, -0.00399135f, 0.02385363f, 0.00684072f, -0.00485337f, -0.03192454f, -0.02120823f, 
    0.00620614f, -0.00443448f, -0.01802472f, -0.03919481f, 0.03605339f, -0.01866333f, -0.04586765f, -0.02871258f, 
    -0.03108916f, -0.00435467f, 0.01748589f, 0.03702211f, -0.02975222f, -0.02701172f, -0.02412195f, -0.00138392f, 
    0.02978809f, 0.01888233f, -0.04949259f, -0.05585877f, -0.05186410f, -0.01912703f, -0.02710659f, -0.05048991f, 
    0.02700663f, 0.01595208f, 0.03307610f, -0.03252680f, 0.04176717f, 0.00267366f, 0.03140060f, -0.01738297f, 
    0.01773933f, 0.02357527f, -0.01622501f, -0.00463607f, -0.00990391f, 0.02107818f, 0.02977343f, 0.03321858f, 
    0.00855051f, -0.03790841f, 0.04339818f, -0.00801637f, -0.00928125f, -0.03257184f, 0.01708414f, 0.03924884f, 
    0.04072710f, 0.03092807f, 0.03719338f, -0.05784275f, -0.04304265f, -0.00344808f, 0.01119813f, -0.04842864f, 
    0.01110693f, -0.00118277f, -0.01130028f, -0.01365798f, -0.05169151f, 0.01640877f, -0.02469205f, -0.05738887f, 
    -0.03484644f, -0.00708825f, 0.03956580f, 0.00567706f, -0.04972738f, -0.02160349f, -0.05683712f, -0.03827089f, 
    -0.04736836f, -0.03157441f, -0.04886997f, -0.02350024f, 0.01892317f, -0.02058012f, -0.04893622f, -0.00135689f, 
    0.01205206f, -0.00456794f, -0.02470178f, -0.04173260f, -0.01850533f, 0.00359954f, -0.04173959f, 0.01913913f, 
    -0.04784567f, 0.01108099f, -0.05816669f, 0.01240313f, -0.03522082f, 0.03336789f, -0.02276297f, 0.00232158f, 
    -0.03574339f, -0.03355581f, -0.00081483f, 0.00782758f, -0.04997548f, 0.01910801f, -0.02013458f, -0.05301707f, 
    -0.01965301f, 0.02879405f, -0.03438605f, -0.04501947f, 0.03890273f, -0.04349307f, -0.03689045f, 0.02410783f, 
    -0.03033767f, 0.01432801f, -0.01930436f, -0.05293523f, 0.01452828f, -0.00940968f, -0.05572056f, 0.04237300f, 
    0.03920288f, 0.03606334f, -0.02177725f, 0.02980022f, -0.05356608f, -0.02516825f, 0.01181475f, 0.02280978f, 
    -0.02096193f, -0.04352585f, 0.00634149f, -0.03689069f, -0.04083622f, -0.05542216f, 0.01775261f, 0.02430937f, 
    -0.00889127f, 0.02440468f, -0.05298511f, 0.00691518f, 0.00628902f, -0.02669772f, 0.01295285f, -0.05451832f, 
    -0.04055052f, -0.04223419f, 0.03503866f, -0.03486687f, 0.03738829f, 0.00115127f, -0.02840139f, -0.00858669f, 
    -0.00375288f, 0.00820550f, 0.00938393f, -0.04977494f, 0.03181383f, -0.00106276f, -0.02307285f, -0.02135939f, 
    0.01438247f, 0.00417554f, -0.04907281f, 0.05053498f, 0.02501601f, 0.01060360f, 0.01536209f, -0.03595781f, 
    0.04633756f, 0.01399919f, 0.03884204f, -0.02004086f, -0.03063788f, -0.05140789f, 0.04121926f, -0.05159334f, 
    0.02631363f, -0.05179698f, 0.04487239f, 0.00622664f, -0.04190138f, -0.04297885f, 0.01555989f, 0.00221842f, 
    -0.04815648f, 0.03390299f, -0.01546500f, 0.01491500f, -0.01965532f, -0.05193793f, -0.04724076f, -0.04330952f, 
    0.01682639f, -0.02000519f, 0.00492704f, -0.02726430f, 0.04203504f, -0.04343414f, -0.05390400f, -0.02410736f, 
    -0.02293791f, -0.01480567f, -0.01485431f, 0.01121493f, 0.02555642f, -0.03640420f, 0.01403812f, -0.03208012f, 
    -0.04507936f, 0.00439806f, -0.01957047f, 0.00352006f, -0.04698673f, 0.04304802f, -0.03197196f, -0.04184784f, 
    -0.02567341f, 0.02581930f, 0.01476171f, 0.00487483f, 0.00147203f, -0.01953674f, -0.01034513f, -0.00469310f, 
    -0.02395297f, -0.00199724f, 0.02739604f, -0.02473740f, -0.04440113f, -0.03270365f, -0.00023007f, 0.01609156f, 
    0.01593348f, 0.00085207f, 0.03497580f, -0.01357840f, -0.00098814f, 0.01963066f, -0.04661812f, 0.03078132f, 
    -0.02280610f, -0.05331374f, -0.01808398f, -0.00506056f, -0.02890370f, -0.02082539f, -0.04948922f, -0.05536642f, 
    -0.02978133f, -0.03436036f, -0.01744355f, -0.01850726f, -0.02624513f, 0.03705144f, 0.01404186f, -0.04926855f, 
    -0.01131650f, -0.01439983f, 0.03824783f, -0.01569671f, -0.02855819f, -0.01325317f, 0.02058719f, -0.03235118f, 
    -0.05506924f, -0.02362908f, -0.03260464f, 0.02038767f, -0.02049769f, 0.01561197f, 0.03345839f, 0.03462367f, 
    -0.00089462f, 0.01443932f, -0.04820405f, 0.03400585f, -0.04225489f, 0.00641746f, 0.02712763f, 0.04480119f, 
    0.00724248f, 0.03938285f, -0.01087995f, 0.02650826f, 0.00941356f, -0.04680706f, 0.04424324f, -0.01814830f, 
    -0.01975613f, 0.02940436f, 0.00958889f, -0.05101153f, -0.02227223f, -0.00786651f, -0.00890631f, -0.05161040f, 
    0.01834311f, 0.03794665f, 0.00796271f, 0.01653147f, 0.01888392f, -0.02588409f, 0.03028843f, -0.03923510f, 
    -0.02685804f, -0.02427461f, 0.03611330f, -0.01622467f, -0.02978310f, 0.01630651f, -0.04148573f, 0.02033336f, 
    -0.05116195f, 0.03658990f, -0.05454490f, -0.04236257f, -0.02371014f, -0.02525371f, 0.02199187f, 0.03080767f, 
    0.02120811f, 0.04316507f, 0.02258766f, -0.00108653f, -0.02631784f, -0.05245396f, 0.03577779f, -0.00773170f, 
    -0.00642367f, -0.04905356f, -0.04760887f, -0.01308153f, 0.00005761f, 0.03127267f, -0.03378876f, 0.01436195f, 
    0.03287701f, -0.01195010f, 0.04078028f, -0.03778718f, -0.04710275f, 0.02885201f, -0.05014956f, -0.01237004f, 
    0.01984943f, -0.02928501f, -0.05109300f, -0.01515949f, -0.01187404f, -0.03198346f, 0.00358147f, 0.03897512f, 
    0.01795729f, -0.01396673f, 0.03944303f, 0.00902405f, -0.05427455f, 0.00504794f, -0.00890543f, 0.02992966f, 
    -0.04282408f, -0.04249230f, 0.00972536f, 0.03374923f, -0.02461417f, -0.02525373f, -0.01486587f, -0.05196603f, 
    -0.03361298f, 0.02844724f, -0.03169088f, 0.03109980f, 0.03924634f, -0.00877201f, -0.04080794f, -0.05420867f, 
    -0.01552242f, -0.02134813f, 0.00458738f, -0.02701622f, 0.02180899f, -0.02122102f, 0.02212126f, 0.00424139f, 
    0.00528289f, 0.04477821f, -0.04563726f, 0.00787983f, -0.04321406f, 0.01033907f, -0.02775490f, -0.04471985f, 
    0.04597276f, 0.03730625f, -0.02050955f, 0.00773431f, 0.00597850f, 0.01666337f, 0.03927577f, 0.04623404f, 
    0.02349822f, -0.02497538f, -0.00578217f, 0.02404663f, -0.00486366f, -0.00844667f, 0.00746968f, 0.00098871f, 
    0.04382315f, -0.05414471f, 0.01983047f, -0.01540686f, -0.00867021f, 0.00126952f, -0.04114648f, -0.04639399f, 
    0.04103751f, 0.01645514f, 0.04184394f, 0.01108511f, 0.00303873f, 0.02179956f, 0.01652008f, -0.00323016f, 
    0.00379176f, 0.02135643f, 0.02276001f, -0.01139678f, 0.01155382f, -0.00489768f, 0.04351373f, -0.00426321f, 
    -0.04802571f, -0.02589756f, -0.03340304f, -0.02143084f, 0.03503872f, -0.02591689f, 0.04431076f, -0.02039563f, 
    -0.04454900f, -0.02003295f, 0.02696786f, -0.01274591f, 0.04141670f, -0.00989927f, -0.00229985f, -0.02755182f, 
    -0.04300957f, -0.03582877f, -0.00611772f, -0.00520103f, 0.04077017f, -0.05253214f, -0.00805714f, -0.01934984f, 
    -0.04828968f, -0.02744140f, 0.02305610f, -0.05053508f, -0.02093959f, -0.03052109f, 0.04038148f, -0.01292346f, 
    -0.01053752f, 0.04082697f, -0.05330652f, 0.04177308f, -0.04106051f, -0.03619350f, -0.01786850f, 0.01231415f, 
    0.01723983f, -0.01339006f, 0.00892760f, -0.01254034f, -0.04064197f, -0.05127288f, 0.04567072f, 0.02541122f, 
    -0.05425692f, 0.00283531f, 0.04052740f, -0.04769370f, 0.02367558f, 0.02824502f, -0.02124953f, 0.00686316f, 
    -0.00303469f, 0.01754019f, -0.03651489f, -0.00187010f, -0.04056691f, 0.02995946f, -0.04083923f, -0.00843225f, 
    -0.03207707f, 0.01412032f, -0.00729114f, 0.00877327f, -0.02929482f, -0.04276876f, 0.02591069f, 0.03749014f, 
    -0.04148442f, 0.04600386f, 0.04508070f, 0.04728328f, -0.05073109f, -0.05366541f, 0.02840254f, 0.02439668f, 
    -0.22726277f, 0.12564266f, -0.01865383f, -0.07584786f, -0.02176292f, 0.02293366f, 0.02234970f, -0.22045873f, 
    0.03573527f, -0.03582832f, 0.06068596f, -0.18305981f, -0.28241548f, -0.09809481f, -0.28174126f, -0.01282278f, 
    -0.00472233f, 0.00517694f, 0.02804004f, 0.02175497f, 0.02757547f, 0.20288809f, 0.05044217f, 0.00171090f, 
    -0.03623907f, -0.01790747f, 0.11044411f, 0.25783208f, 0.22040087f, -0.16367181f, -0.01323336f, 0.01846338f, 
    0.04717839f, -0.08698127f, 0.11045244f, -0.07836799f, -0.03442986f, 0.29487893f, -0.09248442f, 0.33002174f, 
    0.03659939f, 0.00445618f, 0.09713260f, -0.03421837f, 0.12608825f, -0.00532682f, -0.01562576f, -0.06388824f, 
    -0.25401568f, 0.19951981f, -0.19004436f, -0.04915655f, 0.01111460f, 0.06350920f, -0.04239280f, 0.04733887f, 
    0.04707148f, 0.04412224f, 0.02843042f, 0.09039155f, 0.48511663f, -0.01796923f, 0.01186518f, -0.10527223f, 
    0.10302220f, 0.01630430f, 0.06754395f, 0.14896697f, 0.06905703f, -0.05548007f, -0.05070487f, 0.01111779f, 
    -0.06571990f, -0.15698145f, 0.08336101f, -0.12047813f, -0.00925961f, 0.14706178f, 0.01334190f, -0.12553646f, 
    0.15883678f, 0.04879035f, 0.00732885f, -0.01280007f, -0.11146338f, 0.36187088f, -0.02762327f, -0.23564997f, 
    0.23018113f, 0.05269962f, 0.08979362f, -0.02206155f, -0.10749085f, 0.00358609f, 0.04660813f, 0.01073022f, 
    0.29345971f, -0.01076662f, -0.00311332f, -0.05439290f, 0.03959507f, -0.02791250f, -0.05078172f, -0.09779111f, 
    -0.04564564f, 0.05013087f, -0.00785430f, 0.08636376f, -0.11708453f, 0.46324518f, -0.17562057f, -0.27908188f, 
    0.39750329f, -0.12049468f, 0.09237406f, -0.03500792f, -0.05864337f, -0.13169484f, -0.02477197f, -0.01446215f, 
    0.07406358f, 0.13046929f, 0.19845167f, 0.21065034f, -0.00508098f, 0.10266643f, 0.15491585f, 0.08553284f, 
    0.03730748f, 0.10923579f, 0.08544034f, 0.14467867f, -0.00628836f, -0.19614840f, -0.07238887f, -0.02526718f, 
    0.09878118f, -0.06199541f, 0.10833865f, -0.07995588f, 0.00572400f, -0.12185679f, 0.10220430f, 0.19834019f, 
    0.07346520f, -0.36467767f, -0.01003769f, 0.22272700f, 0.07004324f, -0.07568263f, 0.10573023f, -0.19528159f, 
    0.03842709f, -0.13385826f, 0.18394527f, -0.02091499f, -0.01543618f, 0.00403721f, 0.00919691f, -0.07454721f, 
    0.07797442f, 0.04794182f, 0.05172438f, -0.01396269f, 0.07357408f, -0.01100201f, 0.13707928f, 0.10927030f, 
    -0.05749019f, -0.15808415f, 0.05675453f, 0.03911538f, -0.04247668f, 0.01155450f, -0.01717137f, 0.14977415f, 
    0.01034070f, -0.00275517f, 0.08841687f, 0.21777193f, 0.07025828f, -0.06581040f, -0.18539937f, -0.12223117f, 
    -0.01105371f, -0.01121143f, -0.00895748f, 0.02467060f, -0.00883204f, -0.21394935f, -0.08256243f, -0.01684427f, 
    -0.16461630f, -0.07719482f, -0.05640998f, 0.14760515f, -0.16800885f, 0.09168549f, 0.05985005f, 0.05479933f, 
    -0.08033461f, -0.11021039f, 0.17535390f, -0.01490307f, -0.21018219f, -0.12287111f, 0.13994542f, 0.05827944f, 
    0.00618485f, 0.04466685f, -0.11371240f, 0.03682049f, 0.13897850f, 0.03612597f, 0.03987228f, 0.04423352f, 
    -0.30582127f, -0.16970941f, 0.07186772f, 0.48109263f, -0.02675323f, 0.01121577f, -0.03636275f, 0.07056686f, 
    0.01408550f, 0.09029803f, 0.05558570f, -0.03528424f, -0.30620113f, 0.15971409f, 0.14782980f, -0.13871263f, 
    0.08790269f, 0.06706782f, 0.03781816f, -0.00765426f, 0.13144179f, 0.15816255f, -0.00575510f, -0.06314124f, 
    0.13262078f, -0.15983859f, 0.00375141f, 0.04265621f, 0.09018771f, -0.09820960f, 0.02514205f, -0.09789827f, 
    -0.00701035f, 0.05048124f, 0.07840833f, 0.15507883f, -0.03286249f, 0.37054086f, -0.23907557f, 0.15561225f, 
    -0.10854036f, -0.04231755f, -0.05832824f, 0.11809116f, 0.05432175f, 0.00238127f, 0.06281331f, 0.03120401f, 
    -0.14449129f, -0.00624494f, -0.09677522f, 0.02128166f, -0.12644850f, -0.01000561f, 0.08835280f, -0.04916983f, 
    -0.05729154f, 0.07666586f, 0.06177142f, 0.02828087f, 0.26277158f, -0.16204835f, 0.01916373f, 0.10485981f, 
    0.22534662f, 0.11583132f, -0.10848880f, -0.12934528f, 0.02769339f, 0.04024492f, 0.13766889f, -0.06267719f, 
    0.21486282f, -0.30997661f, 0.26715901f, -0.12583643f, -0.04660931f, -0.01488623f, 0.01717059f, -0.13247898f, 
    -0.03354840f, 0.00007947f, 0.04845248f, 0.12843916f, -0.22876458f, 0.11760934f, -0.16740218f, 0.11417012f, 
    0.15390660f, 0.08648586f, 0.10310382f, -0.17900452f, -0.01487515f, 0.08656526f, 0.12581159f, 0.07967857f, 
    -0.20190373f, -0.07869282f, 0.11254220f, 0.33010888f, 0.11907990f, 0.00338236f, 0.05285880f, 0.06166981f, 
    -0.05136630f, -0.01076715f, 0.07801163f, 0.01616397f, 0.25520688f, -0.04073108f, 0.01769384f, -0.36736158f, 
    0.05038574f, -0.08821863f, 0.01916906f, 0.06259248f, -0.02295428f, -0.00106141f, -0.08168691f, 0.01929800f, 
    0.13128591f, -0.15785445f, -0.09600201f, -0.02222958f, 0.10416757f, -0.04056854f, 0.13055864f, 0.03389208f, 
    0.09526759f, -0.00126055f, 0.08255631f, 0.19276755f, -0.27971447f, 0.08767962f, 0.13821104f, -0.16074860f, 
    0.16826177f, 0.06977746f, 0.05641616f, -0.07710820f, 0.07341484f, 0.04115296f, 0.03542338f, 0.09097441f, 
    -0.40632308f, -0.32689017f, 0.23414451f, 0.14259887f, 0.04287364f, 0.09563416f, -0.10979601f, -0.12689976f, 
    0.15704976f, 0.10089915f, -0.03872931f, 0.02614258f, 0.22043514f, -0.15431213f, 0.01133420f, -0.12788101f, 
    -0.00204438f, -0.02954701f, 0.08818401f, 0.10412399f, 0.02235040f, 0.04435619f, 0.01351008f, 0.18344474f, 
    0.06882358f, 0.31372073f, -0.04798547f, -0.26107347f, 0.03564837f, 0.00297928f, -0.03221101f, 0.03602312f, 
    -0.16228504f, -0.10775375f, -0.11598738f, -0.09306563f, 0.04329122f, 0.03110107f, -0.08143529f, -0.18488584f, 
    -0.03710893f, 0.08529036f, -0.04362458f, 0.06796548f, 0.12456577f, -0.14171591f, -0.02136740f, -0.00728529f, 
    0.20155221f, -0.00091915f, 0.36082461f, 0.22074233f, 0.05862601f, 0.10814983f, 0.21871397f, -0.00721554f, 
    0.02137685f, -0.09413497f, -0.11389193f, 0.00657886f, -0.05795359f, 0.16228391f, -0.04078650f, 0.11332116f, 
    0.05537331f, 0.01540974f, 0.06624141f, 0.28256595f, 0.06575453f, 0.11067586f, 0.06189226f, -0.16723812f, 
    -0.02138501f, -0.09807391f, -0.24455634f, 0.10313590f, -0.04003230f, 0.03150002f, -0.08035508f, -0.12550271f, 
    0.00165017f, 0.08360574f, 0.01627603f, -0.14377873f, -0.04650242f, 0.09446542f, -0.05133457f, 0.18372627f, 
    0.00286733f, 0.16503076f, 0.09690794f, -0.07059421f, 0.07027682f, -0.26941842f, 0.03206852f, -0.10748879f, 
    0.13061421f, 0.03024275f, 0.00611931f, -0.02283508f, 0.10808372f, 0.07457484f, 0.09124570f, 0.18171479f, 
    -0.17640498f, 0.19712077f, -0.10723506f, 0.01743977f, -0.06904919f, 0.37884071f, -0.23566185f, -0.47875082f, 
    -0.04726241f, -0.02498681f, -0.11717575f, -0.00226074f, 0.01040356f, -0.03378290f, -0.06593389f, -0.05784961f, 
    -0.00581760f, 0.08028285f, 0.13126284f, 0.14262624f, 0.00240542f, 0.05603809f, 0.00588149f, -0.11038065f, 
    -0.10406850f, 0.02332043f, 0.19736724f, -0.04035513f, -0.12578544f, 0.20940404f, -0.22612390f, -0.24812269f, 
    -0.02533995f, -0.05831692f, -0.04507549f, 0.00177105f, -0.18523943f, -0.00794747f, -0.06040128f, -0.16646470f, 
    -0.37969437f, 0.12030925f, 0.04946957f, -0.02177695f, 0.14468479f, 0.13572149f, 0.14352167f, -0.03855614f, 
    0.08509875f, 0.32985464f, -0.09541015f, 0.17576753f, -0.19092537f, -0.02259827f, -0.11763220f, 0.10456814f, 
    -0.10520871f, 0.01297968f, 0.00463354f, -0.04769853f, -0.16971053f, -0.09673977f, -0.02939235f, -0.00424883f, 
    0.23376596f, -0.30479583f, 0.13097350f, 0.08539188f, -0.04030498f, 0.06685927f, 0.02837230f, 0.03884574f, 
    -0.02610769f, -0.00227221f, -0.03147500f, -0.15450111f, -0.11661816f, -0.00596522f, 0.06791742f, 0.13519125f, 
    0.04058274f, 0.05191376f, -0.11224216f, 0.02389705f, -0.07252812f, 0.03026490f, 0.11463290f, -0.17066233f, 
    0.08984974f, 0.01967131f, -0.26718494f, -0.04908110f, -0.13647076f, 0.14492249f, 0.02735947f, 0.16117314f, 
    -0.03171464f, -0.00153978f, 0.08391669f, 0.03818442f, -0.06919931f, 0.31554586f, -0.06388560f, -0.01863174f, 
    -0.06352481f, -0.02838362f, 0.06794704f, 0.04995595f, -0.03573350f, -0.09846979f, -0.13686314f, -0.24755563f, 
    -0.01437406f, -0.08381704f, 0.10788433f, -0.10673536f, 0.00545301f, 0.23551324f, 0.13530390f, 0.09938888f, 
    -0.16199282f, 0.01533976f, 0.03824424f, 0.23715158f, 0.27890760f, 0.04325358f, 0.04942544f, -0.01786843f, 
    0.06136797f, 0.02625891f, -0.03025956f, 0.08625174f, -0.00169711f, -0.06901371f, -0.19047284f, 0.23648275f, 
    -0.02772685f, 0.00789445f, -0.00051602f, -0.04756219f, 0.05527296f, 0.00005126f, 0.16013323f, 0.05691953f, 
    0.14315154f, 0.05924897f, -0.17261928f, 0.12408968f, 0.15040080f, -0.04868348f, 0.12893997f, -0.04107580f, 
    -0.02648995f, 0.01729590f, 0.07709792f, -0.19258843f, 0.01522156f, 0.07364078f, 0.08217639f, -0.10909667f, 
    0.07077847f, -0.08211847f, -0.10106549f, 0.03303858f, 0.04758644f, -0.07105818f, 0.04058245f, -0.00249518f, 
    0.04179311f, 0.33896512f, 0.00622344f, -0.07310662f, 0.31779733f, -0.06827709f, -0.01657737f, -0.06920851f, 
    0.04870894f, 0.17200662f, 0.02977702f, -0.04440279f, -0.14931013f, -0.06741411f, 0.06196208f, -0.08701736f, 
    0.21101804f, 0.16852118f, 0.07686815f, 0.20755616f, 0.00644369f, 0.06389140f, 0.09000214f, 0.00206073f, 
    0.14997683f, 0.05466645f, -0.19197863f, 0.16487861f, -0.05207543f, 0.06635841f, 0.00300324f, -0.28777835f, 
    -0.15056957f, -0.20339195f, 0.06396902f, -0.00154777f, -0.00449432f, -0.03274567f, -0.17351653f, -0.19292611f, 
    0.19973278f, -0.08285315f, 0.11324237f, -0.05308488f, 0.08214523f, 0.05659608f, -0.18767916f, -0.00200473f, 
    0.01948147f, 0.10208909f, -0.09828362f, -0.04868831f, -0.04055130f, 0.37971011f, -0.11250640f, -0.19682936f, 
    0.04030053f, -0.01467871f, -0.05907210f, 0.09921338f, -0.01202844f, 0.14880687f, 0.31566066f, 0.06898324f, 
    -0.06696007f, 0.07204928f, -0.01603327f, -0.15762901f, 0.07156485f, 0.00346434f, 0.03564823f, -0.16379394f, 
    -0.03698259f, 0.01255740f, 0.17134921f, -0.23973216f, 0.68931228f, -0.14526772f, 0.20557687f, 0.08326608f, 
    0.07122495f, 0.00286301f, 0.13145865f, -0.20641452f, 0.07559729f, -0.01800180f, 0.11768147f, -0.05508727f, 
    0.01664514f, -0.03348625f, -0.00530589f, -0.12005205f, 0.00929081f, -0.01083870f, -0.14309222f, 0.18964861f, 
    -0.32169437f, 0.13362487f, 0.13456745f, 0.26100978f, -0.07344808f, 0.28379712f, 0.11926840f, -0.14458729f, 
    -0.06053019f, 0.22182401f, -0.03635900f, 0.05774648f, -0.12068625f, -0.13400742f, 0.10809312f, -0.01198372f, 
    0.21746756f, -0.02308315f, 0.22167833f, 0.08105175f, -0.11228710f, 0.09815347f, -0.12466139f, 0.02449259f, 
    -0.01506356f, 0.10306458f, -0.01022175f, 0.15314309f, 0.55624688f, -0.34582818f, 0.31317788f, 0.28801775f, 
    -0.03427154f, 0.13949595f, -0.05678993f, -0.12148734f, 0.09239157f, 0.02973713f, -0.06298637f, 0.16820632f, 
    -0.01475656f, 0.00478594f, -0.05820900f, 0.03041747f, -0.04993317f, -0.03908328f, -0.03644610f, 0.04234017f, 
    -0.04336017f, 0.04285213f, -0.02811109f, 0.03740579f, 0.00303823f, -0.04812683f, 0.00557843f, -0.04904838f, 
    -0.02782359f, -0.01593100f, -0.04366139f, 0.04002796f, 0.03880398f, -0.00062615f, -0.00202229f, -0.05933524f, 
    -0.02639551f, -0.01320697f, 0.00326402f, -0.00926952f, -0.03991076f, -0.00723781f, 0.01931875f, -0.02831130f, 
    0.01247129f, -0.00506162f, 0.00286294f, -0.03097599f, -0.02511690f, -0.01383095f, 0.01057069f, 0.04945305f, 
    0.01036807f, -0.02177796f, -0.00099861f, -0.04669914f, 0.00294558f, -0.05620921f, -0.01346307f, -0.01367715f, 
    0.00879532f, 0.01990805f, -0.01246353f, 0.03412958f, 0.01438704f, 0.02706266f, 0.03088625f, 0.02684675f, 
    0.01744894f, -0.00009328f, -0.01003062f, -0.03870825f, 0.03826697f, 0.01307209f, -0.00416920f, -0.00454538f, 
    -0.01982783f, -0.04059632f, 0.03700621f, -0.04440269f, -0.02211105f, -0.01236450f, -0.00855647f, -0.02210400f, 
    -0.00916865f, -0.00991982f, -0.00821557f, -0.01754357f, 0.01657135f, -0.02960938f, -0.03812772f, -0.02705218f, 
    -0.00898333f, -0.05031818f, -0.05364135f, 0.03535603f, -0.02919367f, -0.00922400f, 0.02631246f, -0.01087779f, 
    -0.01253748f, 0.02018924f, 0.01199431f, -0.02626854f, -0.00670160f, -0.05212018f, -0.00037783f, -0.03787887f, 
    -0.00953281f, -0.01171412f, 0.03620169f, -0.02215126f, -0.00499025f, -0.02492876f, -0.00341498f, -0.04746317f, 
    -0.01304986f, -0.01598421f, 0.03945354f, 0.00189114f, -0.04611208f, 0.04688384f, -0.00740173f, -0.04760294f, 
    0.00633269f, -0.02488083f, -0.03776316f, -0.02539868f, -0.04346092f, -0.02220824f, -0.05409404f, 0.01838425f, 
    -0.00234241f, 0.00302060f, 0.02163849f, 0.00519963f, 0.02351340f, -0.02166963f, -0.02954262f, 0.01678388f, 
    -0.03569968f, 0.02221076f, 0.02954206f, -0.04207674f, -0.01057518f, 0.02706742f, -0.02480738f, -0.03921447f, 
    -0.02766882f, 0.04178367f, -0.05698108f, 0.01092474f, 0.01166310f, -0.05452275f, 0.03766174f, -0.03886578f, 
    0.02436148f, 0.01882614f, 0.02477754f, -0.03983544f, 0.02993121f, 0.03230432f, -0.05569873f, -0.02779890f, 
    0.03166620f, -0.01225685f, -0.04763686f, -0.00270146f, 0.01788419f, 0.02244011f, 0.02174476f, -0.03739936f, 
    0.00080993f, -0.03793440f, -0.01358019f, -0.02766714f, -0.04495462f, 0.03692805f, -0.00312803f, 0.01182105f, 
    -0.04861682f, -0.01675894f, -0.05322491f, -0.02344717f, 0.01501451f, 0.03962420f, -0.05845291f, -0.01732576f, 
    -0.00452361f, -0.00278030f, -0.02641023f, 0.01872171f, 0.01862727f, -0.05150155f, -0.03583585f, -0.00145602f, 
    -0.03167081f, -0.00480151f, -0.01098428f, 0.02202372f, 0.04129360f, 0.03875320f, 0.04100090f, 0.04013073f, 
    0.02652871f, -0.05463872f, 0.04233824f, -0.00068867f, 0.01607146f, 0.03261559f, -0.01712734f, 0.02710977f, 
    -0.02267968f, 0.02571929f, -0.03915549f, 0.01375140f, 0.01364413f, 0.00183569f, -0.03216131f, -0.03433356f, 
    0.02835928f, 0.01032038f, -0.03692428f, 0.01357179f, -0.00271445f, -0.00941958f, -0.04125242f, -0.03788646f, 
    0.02394995f, 0.03032288f, -0.05843352f, 0.01145010f, -0.04298361f, 0.02814772f, 0.02813506f, -0.03000005f, 
    -0.03292318f, -0.05320255f, -0.01287982f, -0.02199624f, -0.04545280f, -0.05241514f, 0.02416303f, -0.02763410f, 
    -0.04300272f, -0.00712418f, -0.00149326f, -0.00203456f, -0.00917621f, 0.00915132f, -0.01020213f, 0.03279873f, 
    -0.05577274f, -0.04581802f, 0.01227095f, 0.01366147f, -0.03760529f, -0.02171936f, 0.00014434f, -0.03070236f, 
    -0.04054051f, 0.04140172f, 0.02940351f, 0.02838909f, 0.01480698f, -0.02629613f, -0.01353759f, 0.01154877f, 
    -0.00320096f, 0.00507124f, 0.01382782f, -0.03711678f, 0.01468439f, -0.04626225f, -0.02323485f, 0.03322943f, 
    0.02765215f, -0.01078621f, -0.03701790f, 0.01356483f, -0.04419222f, 0.03193593f, -0.01609862f, -0.05665686f, 
    -0.05508063f, -0.04121275f, -0.02531395f, -0.03483955f, -0.00747442f, -0.05440755f, 0.02461923f, -0.02175113f, 
    -0.00310493f, -0.00521114f, -0.03108087f, -0.02237324f, -0.00024935f, 0.00167020f, 0.03526478f, 0.02377394f, 
    0.02057230f, -0.04141570f, 0.01995514f, -0.03067715f, 0.01569143f, 0.03976313f, 0.04660037f, -0.05404500f, 
    -0.02380681f, -0.00874489f, -0.04058255f, -0.05347034f, 0.03802335f, 0.03521755f, -0.05017500f, -0.04657820f, 
    0.00479219f, -0.04509541f, 0.04194159f, -0.05123523f, -0.05446879f, -0.00551236f, -0.00932459f, -0.05507094f, 
    0.01451596f, -0.03580588f, -0.01766675f, 0.02202745f, 0.00037060f, 0.00356623f, 0.02473847f, -0.05664469f, 
    0.04350125f, -0.04292328f, -0.00789209f, -0.02556384f, 0.02803013f, 0.04031052f, -0.01525605f, 0.04212709f, 
    -0.01832620f, 0.01958780f, -0.03906325f, -0.04326153f, -0.04912699f, -0.04621452f, -0.02115651f, 0.03161437f, 
    -0.01328175f, -0.01370951f, 0.02612638f, -0.00432579f, 0.00694385f, 0.03769649f, 0.03168035f, 0.00117904f, 
    0.03556199f, 0.02844246f, -0.02578484f, -0.03387249f, 0.03416061f, 0.03856650f, -0.03432557f, -0.02620625f, 
    -0.04638308f, -0.05635837f, -0.01064024f, 0.01596499f, 0.03482284f, 0.02610098f, 0.03826124f, -0.02391135f, 
    0.03935695f, -0.02861586f, -0.03955375f, -0.03255879f, 0.04024785f, 0.03728446f, 0.03438539f, -0.02280935f, 
    -0.01513322f, -0.05502131f, 0.00365321f, 0.02640308f, -0.03785787f, -0.01605154f, -0.02383425f, 0.01725976f, 
    0.03954424f, -0.00942904f, -0.01306807f, -0.00658783f, -0.02014686f, 0.01908122f, 0.01452677f, -0.02270239f, 
    -0.03979532f, -0.04284749f, -0.02312762f, -0.02365996f, -0.03301645f, -0.01910077f, -0.03578047f, -0.02368158f, 
    0.03523567f, 0.04976057f, 0.01127038f, 0.01658052f, -0.00710902f, -0.03691406f, -0.05549795f, 0.01995193f, 
    0.00585353f, -0.00035336f, -0.00584012f, -0.01961510f, -0.00706084f, 0.00034583f, 0.01184821f, -0.01230759f, 
    -0.01863884f, 0.01630273f, -0.00566893f, -0.00396116f, -0.01336284f, -0.03315007f, 0.00270767f, 0.01578578f, 
    -0.00221248f, -0.00922404f, 0.01986981f, -0.01362179f, -0.03061056f, 0.01572541f, 0.04217024f, -0.05062747f, 
    0.03441682f, 0.03091490f, 0.02361835f, -0.03148023f, -0.01510600f, -0.00085489f, -0.00556051f, 0.04012047f, 
    -0.02855439f, -0.00556486f, -0.04120857f, -0.02222092f, -0.01914064f, 0.01835877f, 0.00844558f, 0.03938802f, 
    0.01577315f, 0.03862683f, 0.00138325f, -0.00954416f, 0.01412621f, -0.03831698f, -0.04666654f, -0.05004539f, 
    -0.00005321f, 0.01545663f, -0.02990617f, -0.00385587f, 0.03194235f, -0.02560940f, 0.03141643f, 0.00696684f, 
    0.03153767f, 0.00101796f, -0.01992853f, -0.03195751f, 0.01000091f, 0.01478467f, -0.00272607f, 0.01134372f, 
    -0.02867316f, 0.02325945f, 0.02270982f, 0.00125931f, -0.00626692f, -0.00964162f, -0.03256812f, -0.01173632f, 
    0.02371977f, -0.00794046f, -0.00529730f, -0.00263448f, -0.05129643f, -0.02372646f, -0.02696589f, 0.02724173f, 
    0.00848341f, -0.05389329f, 0.02297684f, -0.04647584f, -0.02750554f, 0.02543959f, -0.04540352f, 0.02713505f, 
    -0.02419813f, -0.04848157f, -0.03047970f, -0.00615215f, -0.04959489f, -0.01251651f, -0.03742003f, 0.03727017f, 
    0.03435476f, 0.02701720f, -0.00905479f, -0.00035065f, -0.01844821f, -0.03013603f, 0.01132264f, -0.04019167f, 
    0.01735028f, 0.04186450f, 0.02922832f, 0.03332148f, -0.04074977f, 0.02759574f, -0.03015425f, -0.04918393f, 
    0.03073446f, 0.00793910f, 0.04099116f, -0.05093835f, 0.02423305f, 0.00611991f, 0.01912319f, -0.04794343f, 
    0.02919990f, -0.03355904f, -0.02645843f, 0.03210077f, -0.02680024f, -0.05592582f, 0.01706715f, 0.02039697f, 
    0.01870009f, -0.04499069f, 0.03285838f, -0.01929211f, -0.01124502f, 0.02028396f, 0.00689605f, -0.01325429f, 
    -0.00189349f, -0.01946307f, -0.04797411f, -0.04054778f, 0.01421718f, 0.00232314f, -0.03814286f, -0.00068465f, 
    -0.04534895f, -0.04778622f, 0.01267281f, 0.03411502f, 0.01904059f, -0.03216514f, -0.03824722f, -0.05318518f, 
    0.01644439f, 0.03210850f, -0.01617170f, -0.01990701f, 0.02969069f, -0.00535436f, 0.01080784f, -0.01510992f, 
    -0.05464926f, -0.01137753f, -0.02338380f, -0.01012124f, 0.04271984f, 0.02476293f, -0.01650876f, 0.02126767f, 
    -0.00097413f, -0.04413743f, -0.01886843f, -0.00125413f, -0.05555713f, -0.03221516f, 0.01265702f, -0.04829112f, 
    -0.00274372f, -0.00972748f, 0.00620171f, -0.04073039f, 0.01164841f, -0.04960085f, -0.00870646f, 0.03184259f, 
    -0.05348141f, -0.05465276f, -0.05503384f, -0.00462137f, 0.02441580f, -0.03666865f, -0.01903792f, 0.00714487f, 
    -0.03443490f, -0.02113519f, -0.03891576f, 0.02948260f, -0.03825311f, -0.04890481f, 0.03487252f, 0.00733262f, 
    0.00059229f, 0.01727494f, 0.01650165f, -0.01005235f, -0.01238119f, -0.01760857f, -0.04529326f, 0.03170607f, 
    -0.05047033f, -0.04321947f, -0.00534641f, -0.00201999f, -0.04915901f, 0.02409913f, 0.01971651f, -0.03353231f, 
    -0.01490572f, 0.04261925f, 0.01171026f, 0.01211371f, -0.01535784f, -0.00776279f, -0.02326947f, 0.01285196f, 
    -0.02035354f, 0.04138796f, -0.01311943f, -0.01019057f, -0.05302087f, -0.02314832f, 0.04419002f, -0.02197571f, 
    -0.03945036f, -0.03136770f, 0.01246571f, 0.02028340f, 0.02103745f, -0.04948636f, -0.04283355f, 0.04136770f, 
    -0.02607113f, -0.02702039f, -0.00614078f, -0.02571649f, -0.00431716f, -0.03928341f, -0.03502329f, 0.00841180f, 
    0.03012052f, -0.00430416f, -0.00604488f, -0.01671221f, -0.03594225f, 0.03056006f, 0.00352803f, -0.01389493f, 
    -0.04319803f, 0.03965304f, 0.00501070f, -0.03788815f, -0.04248003f, -0.05398002f, -0.04654451f, -0.01148414f, 
    -0.03692472f, 0.02534667f, 0.03585535f, -0.00954123f, -0.03881932f, -0.03225951f, -0.00712420f, -0.03063149f, 
    -0.01331506f, 0.02514325f, -0.04516721f, -0.02696643f, -0.04203650f, -0.00736078f, -0.00401390f, -0.05193790f, 
    -0.02787381f, -0.03750503f, -0.04235165f, 0.01743234f, -0.02813718f, 0.04296606f, 0.02830477f, -0.01674772f, 
    0.04393042f, -0.02829156f, 0.03698445f, -0.02203138f, 0.01495697f, -0.02681858f, -0.05700483f, 0.00784323f, 
    0.03265085f, -0.05206055f, 0.01953073f, 0.00738821f, 0.04419912f, 0.03868305f, 0.00863963f, -0.02909031f, 
    -0.03377482f, -0.00462710f, -0.05437973f, 0.03536887f, 0.03898682f, 0.02970942f, 0.03521530f, 0.00178684f, 
    0.04221858f, -0.02501893f, -0.00877121f, 0.03103064f, -0.00511994f, 0.00136360f, -0.01546684f, 0.02287671f, 
    0.03039776f, 0.02833344f, 0.00715927f, -0.03300112f, 0.03400281f, -0.03178975f, -0.05551391f, -0.04534413f, 
    0.02264221f, -0.03731769f, -0.00461595f, -0.01965628f, -0.00351473f, -0.02661503f, 0.04225985f, 0.00762412f, 
    -0.04858694f, -0.04109278f, 0.03644716f, 0.01321032f, -0.00569962f, 0.02328780f, -0.02089038f, 0.01118963f, 
    -0.01859253f, -0.02730105f, -0.00791245f, 0.00385551f, -0.03037411f, 0.01566266f, -0.04376525f, 0.00594075f, 
    -0.03668221f, -0.02437205f, 0.01693220f, 0.03769389f, -0.04651418f, -0.02126144f, 0.02667723f, 0.03291184f, 
    -0.00967489f, 0.01212508f, -0.03274910f, -0.01887728f, -0.02876271f, -0.00716884f, -0.01311577f, -0.04990386f, 
    -0.13924290f, -0.31853238f, 0.31290156f, -0.04795846f, -0.22334234f, -0.06309912f, -0.06416725f, -0.06296981f, 
    0.14308460f, 0.01798485f, 0.06223494f, 0.08133628f, 0.40360573f, -0.12876104f, -0.22342169f, 0.06883504f, 
    0.09406465f, 0.17419027f, 0.07602713f, 0.02843923f, 0.15182649f, 0.14343807f, -0.04857668f, -0.03452371f, 
    -0.10100551f, -0.08078712f, 0.33618042f, -0.25851196f, -0.07848755f, 0.04811570f, 0.11701494f, 0.05792440f, 
    0.09575779f, -0.04405094f, -0.02141998f, 0.00319837f, 0.02395416f, -0.08006481f, -0.11609721f, 0.00804604f, 
    0.08797856f, -0.01175128f, -0.03455927f, 0.07298473f, 0.17906176f, -0.04749459f, 0.03897754f, 0.18012220f, 
    0.14771961f, 0.40564668f, -0.05392603f, 0.06899559f, 0.04233935f, 0.04866295f, 0.02101190f, 0.00200472f, 
    0.08301006f, 0.15129271f, 0.03641576f, 0.14324988f, 0.45070854f, -0.04924134f, 0.15101112f, -0.27742493f, 
    0.02930335f, 0.06061466f, 0.16662432f, 0.05442166f, -0.04745189f, -0.10462756f, -0.00214164f, -0.02117869f, 
    -0.09654472f, -0.41644454f, 0.08079967f, 0.01572958f, 0.14026693f, -0.04108210f, -0.05828715f, -0.15139727f, 
    0.08581859f, 0.09045888f, 0.04822336f, 0.04027769f, -0.28608525f, 0.05214969f, -0.14951789f, -0.09903197f, 
    0.05152512f, 0.04437105f, -0.05270042f, 0.01385387f, -0.04805354f, -0.02938340f, 0.08951508f, 0.05032209f, 
    -0.01978093f, -0.21179354f, -0.21269171f, -0.02624804f, 0.13117510f, -0.03721658f, -0.01794601f, -0.21978667f, 
    0.14152956f, 0.13046813f, -0.01269305f, 0.14112131f, -0.14193113f, 0.32024792f, -0.25268438f, -0.12040949f, 
    0.16846795f, -0.12245074f, -0.01764703f, -0.14060281f, -0.12855116f, -0.05890604f, 0.00328828f, 0.00997305f, 
    -0.11693586f, -0.07376592f, -0.09283432f, 0.09589688f, 0.11516403f, 0.18304355f, 0.17393813f, -0.10499713f, 
    0.02355240f, 0.05615250f, 0.10367888f, 0.06009402f, 0.14150189f, -0.05660432f, 0.20991574f, -0.02813313f, 
    0.01337020f, 0.15673950f, -0.09911484f, 0.08103951f, 0.09880099f, -0.03741299f, -0.06310943f, 0.01255712f, 
    0.17813209f, -0.26045579f, 0.08082560f, -0.00310656f, 0.13339207f, 0.03083939f, 0.09326272f, -0.01300500f, 
    -0.01109066f, 0.03887277f, 0.02246059f, 0.01692547f, -0.15003817f, 0.13292189f, 0.22001959f, -0.05802650f, 
    0.05335206f, 0.03510005f, 0.26252145f, -0.04643767f, 0.14910474f, 0.14725290f, 0.01302136f, 0.05383340f, 
    -0.01824670f, -0.08615812f, 0.10363001f, -0.36001590f, 0.04411931f, -0.11390393f, 0.04043676f, 0.13786644f, 
    -0.01612011f, -0.03733748f, 0.15444063f, 0.01137005f, 0.19143143f, 0.07102318f, 0.18706055f, 0.01943708f, 
    -0.09504692f, -0.06219437f, 0.10744179f, 0.07747507f, 0.10163914f, 0.24351004f, 0.12768601f, -0.12260284f, 
    0.03163536f, 0.13986912f, 0.01990801f, 0.09911758f, 0.14163697f, 0.07241126f, 0.10454765f, 0.01320575f, 
    0.04009556f, -0.03087870f, 0.04130545f, 0.18659806f, -0.14854421f, -0.02826132f, 0.04182716f, 0.00695055f, 
    0.11605310f, 0.03741141f, 0.03901745f, -0.05435778f, 0.05886979f, -0.06093324f, -0.13053066f, 0.05153876f, 
    0.03613456f, -0.02799456f, 0.09238474f, -0.05264928f, 0.05863212f, -0.05206114f, 0.12132935f, 0.17800358f, 
    -0.13314103f, -0.08210497f, -0.05637519f, -0.10959823f, -0.35480729f, -0.06467598f, -0.12144355f, 0.02502513f, 
    0.07511745f, -0.00989298f, -0.07888947f, -0.00562718f, 0.15657130f, 0.08830511f, -0.05277319f, 0.15345921f, 
    0.28506103f, 0.10028049f, 0.01815059f, 0.13058573f, 0.17717925f, -0.00929790f, -0.00534192f, 0.00894758f, 
    0.03214754f, 0.02953652f, -0.05570117f, -0.01053178f, 0.25277847f, 0.10432307f, -0.02611622f, -0.23577334f, 
    0.05628642f, 0.09568489f, -0.02641813f, -0.09587222f, 0.03739410f, 0.06589790f, 0.14547426f, 0.10569835f, 
    -0.15656333f, -0.01388647f, 0.14595869f, 0.00022736f, 0.06143013f, -0.04107228f, 0.00733759f, 0.05415796f, 
    0.02273069f, 0.10272118f, -0.11549725f, 0.07166441f, -0.37561971f, -0.10007276f, -0.10674012f, -0.14402430f, 
    -0.15556321f, 0.07875852f, -0.09356279f, -0.13473161f, 0.01037872f, 0.03983667f, 0.17114671f, -0.08940495f, 
    -0.18491472f, -0.00060947f, 0.38115573f, -0.34401572f, 0.05082297f, 0.02343708f, -0.01563295f, -0.14841966f, 
    -0.03986875f, -0.00686764f, 0.14090978f, 0.08091685f, -0.01501105f, -0.44540417f, 0.25764105f, -0.07479344f, 
    -0.21804108f, -0.03410889f, -0.05050039f, -0.10707494f, 0.13434532f, -0.02425351f, -0.08477284f, 0.00265192f, 
    -0.17068255f, -0.38219345f, -0.04959915f, -0.09897356f, 0.07236762f, -0.06296811f, 0.07414350f, 0.00302062f, 
    -0.06708555f, 0.01724342f, 0.00202763f, 0.07867661f, 0.06575180f, 0.14141330f, -0.00396461f, 0.25450009f, 
    -0.05508370f, -0.09004605f, 0.03667634f, 0.02233279f, -0.11288302f, 0.16073804f, 0.10791995f, -0.00073410f, 
    -0.14151554f, 0.00363102f, 0.23585522f, 0.00738353f, -0.03797957f, -0.00333611f, 0.00106729f, 0.03619955f, 
    -0.00461481f, -0.08529139f, 0.05490368f, -0.04692291f, -0.08178560f, -0.39932212f, 0.05375116f, 0.21535666f, 
    0.02225830f, -0.02951944f, -0.08170442f, -0.07008218f, 0.09400489f, 0.07188346f, 0.06548055f, 0.11907849f, 
    -0.18424848f, 0.02069638f, -0.05671249f, 0.26792991f, 0.14864908f, -0.09818187f, 0.02697770f, 0.17651492f, 
    0.03420997f, 0.07471514f, -0.00222467f, -0.03981595f, 0.26231426f, 0.19481717f, -0.39052010f, 0.36885723f, 
    -0.04598152f, -0.13339625f, 0.03367480f, 0.20272078f, 0.05375167f, -0.02069832f, -0.18153320f, 0.00296917f, 
    0.24682117f, -0.01262443f, 0.23073828f, 0.26494238f, -0.10329297f, 0.00524934f, -0.03685048f, -0.00656152f, 
    0.05666343f, -0.01777419f, -0.15369716f, -0.10831057f, -0.11013921f, 0.05205071f, 0.09354848f, 0.25122228f, 
    0.08974886f, 0.03794879f, -0.03042202f, -0.11312161f, 0.15272267f, -0.17860438f, 0.14371133f, 0.16727056f, 
    0.11738726f, -0.16408302f, -0.02211196f, 0.14505711f, 0.08781750f, 0.10933547f, 0.17270440f, -0.05462766f, 
    0.25695062f, 0.06996005f, -0.07718107f, 0.07402930f, -0.17790417f, -0.25528064f, -0.03516023f, -0.06041688f, 
    0.06602132f, 0.06722890f, -0.02636942f, 0.03850266f, 0.05985140f, 0.07769921f, 0.09851500f, -0.12383643f, 
    -0.09123550f, 0.03575929f, 0.21378008f, 0.03695960f, -0.03148571f, -0.05477664f, 0.02340639f, 0.16103452f, 
    -0.05404306f, -0.04717910f, 0.19717637f, 0.01639524f, -0.20103987f, -0.09783349f, 0.02533586f, 0.00418060f, 
    -0.02563778f, 0.09582762f, -0.11707207f, -0.00933994f, 0.06312002f, 0.08055006f, 0.00015492f, 0.05002873f, 
    0.18903039f, -0.12906572f, 0.11119121f, 0.26504961f, -0.02472205f, -0.03780466f, 0.08890150f, 0.03976465f, 
    0.06796704f, 0.14607178f, -0.01156036f, 0.15851247f, 0.48938197f, -0.02029409f, 0.15251501f, 0.08009697f, 
    -0.05721730f, 0.00446180f, 0.04423812f, 0.06138591f, -0.03314700f, 0.04319954f, -0.10023886f, 0.06521410f, 
    -0.36441097f, -0.06755347f, -0.01243909f, 0.17717716f, 0.11140507f, -0.09239828f, 0.06071360f, 0.10249735f, 
    -0.12208112f, 0.00059667f, 0.14951338f, 0.06804945f, 0.07587458f, 0.03144946f, 0.04137613f, 0.03105591f, 
    -0.07725372f, -0.07502782f, 0.12160904f, 0.18475828f, 0.19566879f, 0.06730399f, -0.01404808f, 0.07437520f, 
    -0.24877872f, -0.03660832f, 0.02957358f, -0.09534725f, 0.18181427f, 0.13716957f, -0.03893831f, -0.05907074f, 
    0.09912703f, 0.10449574f, -0.09797122f, 0.08525295f, -0.02421105f, -0.04907871f, 0.17163901f, 0.09799373f, 
    -0.05421752f, -0.06570161f, 0.07080032f, 0.12252836f, 0.00996850f, -0.00216565f, 0.03498397f, 0.06073233f, 
    -0.39377630f, 0.21151718f, -0.15017369f, -0.06383462f, -0.16455522f, -0.06409940f, 0.05354106f, 0.13029374f, 
    -0.01281713f, -0.02114850f, -0.05257631f, -0.08295383f, -0.25247133f, 0.15569545f, 0.28134105f, 0.13480453f, 
    -0.01004937f, -0.03283626f, -0.08834162f, 0.10543064f, -0.00913038f, 0.15397829f, 0.02864023f, -0.18198434f, 
    0.59434843f, -0.24539019f, 0.00361523f, 0.01058811f, -0.09863404f, 0.03558153f, -0.02857787f, -0.02147870f, 
    0.04322388f, 0.03880325f, 0.03863911f, 0.01522501f, 0.10680901f, 0.13155498f, 0.21269321f, 0.22469126f, 
    -0.03119487f, 0.02516436f, 0.00862425f, -0.01658037f, 0.10672587f, -0.17530087f, 0.00253843f, -0.01256229f, 
    -0.13368055f, -0.00931976f, 0.08472064f, 0.03551563f, -0.07697400f, 0.11484218f, 0.13162035f, -0.10476962f, 
    0.04860776f, 0.00601949f, 0.09358935f, 0.12843156f, 0.16735236f, -0.32631412f, 0.04583128f, 0.14400615f, 
    0.00316686f, 0.04381853f, -0.04247377f, -0.01470191f, -0.00120704f, 0.00258058f, -0.11957759f, 0.09267501f, 
    -0.44484395f, -0.10079908f, -0.24406479f, -0.19796929f, 0.10591060f, -0.02010556f, 0.05648152f, 0.03652531f, 
    0.07333457f, -0.00577164f, 0.02020181f, 0.11240558f, -0.43377286f, 0.06689039f, 0.03615426f, -0.07378362f, 
    0.12777592f, 0.00826968f, 0.03841316f, 0.02857094f, -0.07280231f, -0.02339513f, 0.12816867f, -0.13700598f, 
    -0.03976348f, 0.02602365f, 0.03045799f, -0.00224513f, 0.03465195f, -0.05716950f, -0.01110568f, -0.00033899f, 
    -0.04621199f, 0.07700365f, 0.05961436f, 0.14184250f, 0.07288615f, -0.32265800f, -0.08059841f, 0.11907999f, 
    -0.06924047f, 0.13653389f, 0.04559934f, -0.11639000f, -0.04186353f, -0.06555866f, 0.01941963f, -0.09472983f, 
    0.19481812f, 0.04729204f, -0.00584718f, 0.14978264f, -0.03190449f, -0.16962288f, 0.06656581f, -0.05163201f, 
    0.18843313f, 0.12730348f, 0.11294290f, 0.15099451f, 0.21320158f, 0.26235178f, 0.20571402f, -0.14349915f, 
    -0.07428557f, -0.04968830f, 0.09106463f, 0.07807767f, 0.03280191f, 0.03099665f, 0.08730322f, -0.25243244f, 
    -0.22420166f, 0.15783487f, 0.21003509f, 0.13833335f, -0.13580340f, 0.08378568f, -0.03053636f, -0.01860552f, 
    0.11739942f, -0.18172291f, 0.02026312f, -0.10360222f, 0.35857344f, -0.14866598f, 0.17159840f, 0.06338271f, 
    -0.08238866f, -0.03162571f, -0.02531940f, 0.07342377f, -0.04168608f, -0.01197949f, 0.05163352f, -0.03637683f, 
    -0.57316679f, -0.14832778f, -0.24893133f, -0.15669757f, 0.05217740f, 0.10847444f, -0.02411122f, 0.06778888f, 
    0.04378698f, 0.11287782f, -0.00416224f, -0.04694020f, -0.22281833f, -0.02529706f, 0.15478706f, -0.05087599f, 
    0.20664787f, 0.12768504f, 0.05230004f, 0.01903000f, -0.07103579f, 0.01003205f, -0.07002172f, -0.00479423f, 
    -0.11695672f, -0.09150545f, 0.35048440f, 0.01242978f, 0.06344565f, 0.04818219f, -0.11699314f, 0.19493441f, 
    -0.09731688f, 0.08725863f, 0.06217398f, 0.21833432f, 0.06857944f, 0.14338635f, -0.02874034f, 0.06131857f, 
    0.10737284f, 0.05380130f, 0.06937190f, 0.06240938f, 0.13644633f, -0.07055146f, -0.00807124f, 0.08397529f, 
    -0.38555333f, 0.05595812f, -0.24431825f, -0.14815517f, -0.01306408f, 0.06408260f, 0.01356812f, 0.04232142f, 
    -0.04189039f, 0.04194454f, 0.04306554f, 0.03143048f, -0.60310447f, 0.28839001f, -0.00758964f, -0.08736452f, 
    0.09005768f, 0.06033191f, 0.16726729f, 0.15257385f, 0.06657255f, -0.00729880f, 0.14309694f, 0.08096412f, 
    0.02410382f, 0.03482937f, 0.03060815f, 0.02429767f, 0.00213512f, -0.05229148f, -0.02358882f, -0.02632338f, 
    0.00615106f, -0.03982291f, -0.03022839f, 0.03010167f, -0.01231150f, -0.00703408f, 0.02025183f, -0.03367810f, 
    -0.04170894f, -0.03428028f, -0.03904178f, -0.05219596f, 0.00263422f, -0.02609047f, 0.02709266f, -0.04427074f, 
    0.02822868f, -0.02136506f, 0.00175276f, 0.04012963f, 0.02779096f, 0.00925255f, -0.03828022f, -0.01655602f, 
    -0.04359407f, -0.02487199f, 0.01152216f, 0.00735009f, 0.04261166f, 0.00930102f, 0.01360114f, -0.01859611f, 
    -0.02322744f, -0.01081654f, -0.04668711f, -0.01412917f, -0.02187455f, -0.04365490f, -0.01415804f, -0.00131629f, 
    0.03293026f, 0.00836117f, -0.03386612f, 0.04398791f, 0.03222060f, -0.04282481f, -0.01126287f, -0.04517792f, 
    0.04345709f, -0.05024361f, -0.01130710f, 0.03695643f, -0.00426304f, -0.05335569f, -0.01128015f, -0.02607705f, 
    0.03822333f, -0.01379342f, 0.01255006f, 0.02138397f, -0.04335594f, -0.03595333f, -0.01781872f, 0.02352572f, 
    -0.04335725f, 0.01824042f, -0.02094059f, -0.04427587f, 0.02268055f, -0.03845992f, -0.02247145f, -0.04067171f, 
    0.00478555f, -0.02401944f, -0.02139627f, -0.03474690f, -0.03394419f, -0.04233671f, 0.04129648f, 0.00123346f, 
    0.01355361f, -0.04451792f, -0.02928705f, -0.01972188f, 0.04142268f, 0.02910017f, -0.02290095f, -0.00735196f, 
    -0.01956790f, 0.00737989f, -0.01338459f, -0.04641418f, 0.04000418f, 0.01032409f, 0.03294832f, -0.03233810f, 
    -0.03456235f, 0.01713590f, -0.01372697f, -0.04576611f, 0.00413963f, -0.01705252f, -0.01477917f, 0.01024606f, 
    -0.05089404f, 0.02253097f, 0.00049045f, 0.03417607f, 0.01409666f, -0.04507454f, -0.04501161f, 0.00985295f, 
    -0.05680617f, 0.03976102f, 0.01200083f, 0.00460600f, 0.02529585f, -0.02196382f, -0.03214717f, -0.01886851f, 
    -0.03824300f, -0.05445379f, 0.02933959f, -0.02568001f, -0.02341084f, 0.03358214f, 0.03489245f, 0.03778613f, 
    -0.04486287f, -0.05572190f, -0.05578366f, -0.03168519f, 0.02173143f, -0.05815581f, -0.00418979f, 0.00912825f, 
    -0.02277176f, -0.04125045f, -0.02656692f, -0.00887729f, 0.01681638f, 0.02756683f, -0.03453699f, 0.01588184f, 
    -0.05349332f, -0.01538637f, 0.00220666f, -0.02611483f, 0.04056093f, 0.02664831f, -0.01239183f, 0.01860977f, 
    0.03630007f, -0.05690137f, 0.03851238f, -0.03503250f, -0.04416168f, -0.00603799f, 0.01233169f, -0.03750720f, 
    -0.01871433f, -0.00861191f, -0.01065804f, -0.03486820f, 0.01470328f, 0.03415464f, 0.02151760f, 0.01788885f, 
    -0.03394220f, -0.04182613f, 0.02970047f, -0.01750441f, -0.00982771f, -0.03165849f, 0.02407249f, -0.05103183f, 
    0.01213581f, -0.02901739f, 0.00433631f, 0.03771778f, 0.02842913f, 0.03077446f, 0.02110753f, -0.03311864f, 
    0.04154848f, -0.04365045f, -0.03538309f, 0.02512552f, 0.04467809f, 0.00092705f, 0.04596705f, -0.04930756f, 
    -0.03124268f, -0.04189832f, -0.05257111f, 0.02001027f, 0.00691767f, -0.01084397f, 0.01060942f, -0.03502652f, 
    0.01884921f, 0.03139506f, -0.04042736f, 0.01361326f, -0.05339390f, 0.01704328f, -0.01141249f, 0.02143227f, 
    0.03567187f, 0.01319256f, 0.00160769f, 0.00518259f, 0.02036959f, 0.02922999f, -0.05268062f, 0.00986415f, 
    -0.01155361f, 0.03980466f, 0.00552297f, 0.02182448f, 0.00029009f, -0.04234605f, 0.02932229f, 0.01290392f, 
    -0.01515656f, -0.05288931f, -0.03045469f, -0.00801888f, 0.00836131f, -0.01330896f, -0.04486287f, 0.00359171f, 
    -0.05736585f, 0.02560518f, -0.04001278f, -0.05383170f, 0.01195011f, 0.03770118f, 0.02164490f, -0.01557032f, 
    0.00936835f, -0.05652639f, 0.01306157f, -0.01784764f, -0.01368405f, 0.02523108f, 0.04345980f, 0.04197010f, 
    0.03938010f, -0.04623668f, -0.05499717f, -0.05308605f, -0.00237481f, 0.02713728f, -0.04050191f, 0.00894076f, 
    -0.03971688f, -0.03676063f, -0.02654440f, -0.00595883f, -0.02166944f, 0.03033220f, 0.01735624f, 0.03541011f, 
    -0.02904080f, 0.01242997f, -0.00200726f, -0.05626180f, -0.01608632f, -0.05298500f, -0.02753163f, -0.01127741f, 
    -0.02396956f, 0.00857007f, 0.03131228f, 0.02358179f, -0.02428069f, -0.03135808f, -0.02835898f, -0.03240535f, 
    -0.02698639f, -0.04113021f, -0.02768888f, 0.02631010f, -0.02660691f, 0.02071507f, -0.03448696f, -0.05809709f, 
    -0.01817912f, 0.01019751f, -0.02423269f, 0.03698235f, -0.01759516f, -0.02742304f, -0.01928082f, -0.03796514f, 
    -0.04762457f, 0.00712410f, 0.02889745f, -0.05040726f, 0.00366826f, 0.03003435f, -0.03895967f, -0.03779937f, 
    -0.01955135f, 0.02821944f, -0.05629903f, 0.00374348f, -0.03947054f, 0.01099164f, 0.01852004f, -0.01803114f, 
    0.03961416f, 0.03022642f, -0.01276073f, 0.02000433f, 0.00154324f, -0.01277493f, -0.04510546f, -0.00023095f, 
    0.04396069f, -0.00063281f, -0.01753376f, -0.05756956f, -0.01261342f, 0.01573205f, -0.04557551f, 0.03462424f, 
    -0.03668761f, -0.04571538f, 0.04165735f, -0.05189088f, 0.02579208f, 0.04204848f, 0.02125583f, 0.01353825f, 
    -0.04662651f, 0.04199559f, -0.03321328f, -0.01426087f, -0.01541959f, -0.00170209f, -0.05003962f, -0.01828497f, 
    -0.05561123f, -0.05776322f, -0.02905219f, 0.04193555f, 0.00781435f, -0.05429207f, 0.00827899f, -0.02022876f, 
    0.03524335f, 0.02885940f, -0.04155804f, 0.01845891f, -0.00361788f, 0.02374871f, 0.02282746f, -0.01087787f, 
    -0.03520683f, 0.03657675f, -0.02979584f, 0.01433519f, -0.00104029f, -0.00883137f, -0.04961740f, 0.04043799f, 
    -0.03725569f, 0.01405282f, -0.04439970f, 0.00108843f, 0.04069044f, 0.01284630f, 0.02031196f, 0.03732860f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00236638f, 0.01634464f, -0.02585313f, -0.03094871f, -0.00423445f, 0.09197030f, -0.04484459f, 0.03981433f, 
    -0.01807065f, 0.09804483f, 0.02507727f, 0.03600665f, -0.00701477f, 0.07900944f, -0.02686521f, 0.04325879f, 
    -0.02414022f, 0.12229136f, -0.01447291f, -0.05690665f, 0.02250156f, -0.05202896f, 0.07464526f, -0.00645964f, 
    0.00492191f, 0.03878992f, -0.04215547f, -0.04641711f, 0.00062970f, 0.03743718f, 0.00321873f, 0.02513978f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.08061524f, 0.07279783f, -0.12468868f, -0.17208983f, 0.10629880f, -0.05987453f, 0.15163177f, -0.64626986f, 
    0.36672243f, -0.00338664f, -0.14218609f, 0.02283199f, 0.11738274f, -0.23261358f, 0.09807666f, 0.18939139f, 
    -0.06066245f, -0.67672968f, -0.06786283f, 0.09672968f, -0.31601006f, 0.14177519f, 0.33231044f, 0.05846887f, 
    -0.03010887f, -0.69585180f, 0.16693142f, -0.17155300f, -0.02347460f, 0.20134045f, 0.28790784f, 0.12704004f, 
    -0.13186893f, 0.05866924f, -0.03256302f, -0.16875377f, 0.01880620f, 0.09883822f, -0.03334378f, -0.30855250f, 
    -0.40656924f, 0.17902997f, 0.00342926f, -0.05461791f, 0.25513411f, -0.28874660f, 0.28763857f, -0.00811123f, 
    0.00916628f, 0.01015512f, -0.77847683f, -0.08752246f, 0.26791617f, 0.19994345f, 0.32290944f, -0.06729230f, 
    0.00594936f, -0.39826101f, -0.41218388f, 0.14213666f, 0.02806235f, -0.15302409f, -0.21397419f, -0.02655978f, 
    0.13539575f, -0.03772730f, 0.09859108f, -0.05785824f, -0.00678590f, -0.01945340f, -0.16838270f, 0.31167814f, 
    -0.69457996f, 0.16679601f, 0.04383587f, 0.08050527f, -0.66165376f, 0.21723112f, 0.19143826f, 0.17988899f, 
    0.15262598f, -0.71670103f, 0.00322383f, -0.12169653f, -0.21231501f, 0.26392034f, 0.14520760f, 0.04399761f, 
    0.11265002f, 0.17965928f, 0.04058409f, -0.03411924f, -0.06561752f, -0.24868099f, -0.53251928f, -0.02702872f, 
    -0.16590433f, 0.05885623f, 0.13534863f, 0.03575432f, 0.14330359f, 0.28978536f, -0.17049667f, 0.05493614f, 
    0.15195575f, -0.47075889f, -0.00619670f, -0.05560625f, 0.13166907f, 0.34624293f, -0.37724894f, -0.18316087f, 
    -0.10644751f, 0.00997702f, 0.04129457f, -0.01374343f, -1.12053597f, 0.32006249f, -0.03151429f, -0.15617733f, 
    -0.12275387f, -0.50733787f, -0.20370911f, -0.15537828f, 0.06192678f, 0.05924030f, 0.17786501f, -0.05180202f, 
    0.15183131f, -0.17018835f, 0.07730159f, -0.03227154f, -0.08334595f, -0.34433573f, 0.03934300f, 0.23298368f, 
    0.10288551f, -0.12872572f, -0.07730263f, -0.01033289f, 0.29079702f, -0.42722976f, 0.20022149f, -0.03284314f, 
    0.10766825f, -0.04807049f, 0.19403455f, -0.04661448f, -0.58927941f, -0.07623303f, -0.36567625f, 0.01173895f, 
    0.05521793f, 0.26984632f, -0.32588723f, 0.14997180f, -0.12857533f, 0.21141142f, 0.38947919f, 0.10168388f, 
    -0.13696924f, -0.01672561f, 0.11836638f, -0.11431132f, 0.07536051f, -0.25934461f, 0.15461156f, -0.42565686f, 
    0.26332086f, -0.29921976f, 0.00768060f, -0.02732489f, 0.01293906f, 0.23499435f, 0.22409140f, 0.31583714f, 
    -0.10003772f, 0.25191507f, -0.08606789f, 0.14849791f, 0.30920190f, -0.49986494f, 0.10604180f, -0.11838103f, 
    -0.10372973f, 0.05949969f, -0.42990461f, -0.02294677f, -0.14866959f, -0.37640202f, 0.17845903f, -0.00147594f, 
    -0.16735262f, 0.10144806f, -0.14486234f, 0.12517571f, 0.06672394f, 0.37379253f, -0.16130008f, -0.10471649f, 
    -0.14144181f, 0.02397837f, -0.03630071f, 0.02571837f, -0.71083272f, -0.38859275f, -0.02879208f, -0.15077321f, 
    0.11898251f, 0.11748016f, 0.03799403f, -0.04996347f, 0.05030335f, -0.00729997f, -0.60515988f, 0.04830453f, 
    0.10261092f, 0.09551077f, 0.44906810f, -0.02052573f, 0.15520258f, -0.39762223f, 0.10945225f, -0.02558121f, 
    0.06892365f, -0.12836504f, -0.01614104f, -0.05097290f, -0.00241837f, -0.59107089f, -0.00315584f, 0.26312366f, 
    0.31725949f, -0.11634881f, -0.10814504f, -0.03002152f, 0.34460920f, 0.15838629f, -0.30308220f, -0.67393631f, 
    0.06348408f, 0.23480394f, 0.17472202f, 0.10767799f, -0.03152157f, 0.12541418f, -0.26089871f, 0.04861047f, 
    -0.01541063f, -0.03419082f, 0.22685936f, -0.10338455f, -0.08612337f, -0.25073075f, -0.44998071f, -0.01597458f, 
    -0.13714732f, 0.11304618f, 0.12491534f, -0.11340565f, 0.11913385f, 0.30519870f, -0.17258321f, 0.19177908f, 
    0.07751442f, 0.28221148f, 0.10716851f, -0.10722482f, 0.26772669f, 0.05322281f, 0.05721377f, -0.04579409f, 
    -0.15442613f, -0.36568046f, -0.66408432f, -0.02525219f, -0.26619756f, -0.53689682f, 0.24553716f, -0.00033915f, 
    0.04954385f, 0.32154438f, -0.48126802f, 0.07202025f, -0.15544602f, 0.01953056f, -0.69274527f, -0.11951241f, 
    -0.05085441f, -0.04319251f, -0.02279774f, 0.16850838f, -0.06716511f, -0.07131071f, -0.11042932f, -0.26513982f, 
    -0.56362647f, -0.46401989f, 0.11589535f, 0.14741331f, 0.28864646f, -0.06188295f, -0.16936094f, -0.43325546f, 
    0.03926856f, -0.11263555f, 0.15930204f, -0.17212006f, 0.29357636f, -0.00399035f, 0.31099880f, 0.05024786f, 
    0.15685414f, 0.49388355f, 0.35761237f, -0.11667843f, 0.04404017f, 0.45261914f, -0.24491051f, 0.05752095f, 
    0.04667277f, 0.03459585f, 0.05887214f, -0.16125619f, 0.07990243f, -0.07350957f, -0.12470371f, -0.03466471f, 
    -0.21697803f, 0.46821496f, 0.04167423f, -0.15050490f, -0.59039503f, 0.38049835f, -0.18668243f, -0.51937884f, 
    -0.06947455f, 0.42514211f, -0.17849371f, -0.11193201f, -0.37746403f, -0.06704681f, 0.08629351f, -0.09848639f, 
    -0.08349638f, -0.20556599f, -0.26619968f, -0.06014062f, -0.11682664f, 0.49788883f, -0.38425472f, 0.07379510f, 
    -0.10622386f, -0.12608224f, 0.09308270f, 0.13063861f, -0.16790454f, -0.03845891f, -0.14852643f, 0.33152509f, 
    -0.22273727f, 0.30220577f, 0.01319157f, -0.15112719f, 0.03136550f, -0.13788393f, -0.70009375f, 0.47266769f, 
    0.00848111f, 0.08469142f, 0.23769547f, -0.00901633f, -0.07979294f, -0.13643588f, 0.22716479f, -0.03369310f, 
    0.13170585f, -0.09487820f, 0.03471409f, 0.07364815f, -0.16850999f, -0.60964805f, 0.08060301f, -0.05148186f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.03089697f, 0.09182189f, -0.07497604f, -0.06068832f, -0.09602847f, 0.04987349f, 0.13627870f, -0.25364077f, 
    -0.06297569f, 0.08771878f, 0.31706783f, -0.16938357f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
