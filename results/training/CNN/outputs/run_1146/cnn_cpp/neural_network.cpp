#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.50047648f, -0.71101820f, 0.16854516f, 0.72478676f, 0.62622678f, 0.81253815f, 0.23691989f, -0.46134788f, 
    -0.45559776f, -0.47065851f, -0.20793197f, -0.37811381f, 0.22293998f, 0.25571954f, 0.08020925f, 0.04149340f, 
    -0.17470112f, 0.07272934f, 0.17116308f, -0.31511268f, 0.20196329f, -0.09076450f, -0.08077973f, 0.19540125f, 
    0.04573534f, -0.57723647f, -0.44122681f, -0.13256063f, -0.41029114f, -0.42498407f, 0.05737253f, 0.19434422f, 
    -0.56193846f, -0.28508314f, -0.08546533f, 0.00653584f, -0.30539751f, -0.17043188f, -0.46119210f, -0.40603510f, 
    0.19007830f, 0.15396380f, -0.18617225f, -0.05368332f, -0.20151938f, -0.24002630f, -0.23643290f, -0.15096281f, 
    -0.20688377f, -0.24794897f, 0.46880990f, 0.01495954f, 0.13505284f, -0.33274397f, -0.40553981f, 0.30456764f, 
    0.10939030f, -0.17479892f, -0.03498040f, 0.16840194f, 0.24984212f, 0.00934035f, 0.22903812f, -0.11740571f, 
    0.00394866f, 0.00596626f, 0.05473299f, 0.08417608f, -0.15782951f, 0.11106072f, 0.00326035f, 0.33101064f, 
    0.35223699f, 0.37908235f, 0.23881461f, -0.09418507f, -0.36462474f, 0.13551340f, 0.49597064f, 0.33476838f, 
    0.41621345f, 0.44007733f, -0.11777232f, -0.11160000f, -0.22970162f, -0.42450988f, -0.09042605f, 0.09107891f, 
    -0.20402364f, 0.25131026f, -0.08462447f, 0.26098713f, 0.03884450f, -0.10162433f, 0.13886638f, 0.00105250f, 
    -0.16312712f, -0.28341570f, -0.29880968f, -0.25665393f, 0.50334275f, 0.53859919f, 0.13605358f, -0.69145477f, 
    -0.34219873f, 0.15262456f, 0.08177444f, -0.03819190f, -0.38621080f, -0.30637601f, -0.32295331f, 0.51550961f, 
    -0.32664210f, -0.07162977f, 0.26630157f, 0.15276462f, 0.18602048f, -0.16962281f, -0.24459656f, 0.15972745f, 
    -0.21080293f, -0.18602444f, 0.15994950f, 0.13149014f, 0.19714795f, -0.28673574f, -0.21303742f, -0.31553200f, 
    0.29707643f, 0.27095866f, -0.50819474f, 0.20749080f, 0.51060259f, 0.54719424f, -0.22308031f, -0.59650779f, 
    -0.27822965f, 0.21823889f, 0.31268361f, -0.04075626f, 0.42333236f, -0.18427444f, -0.03666491f, 0.04464233f, 
    0.05745086f, 0.12281710f, -0.09527627f, -0.17105328f, -0.01970886f, -0.23608550f, 0.63847607f, -0.26905841f, 
    -0.84224582f, -0.48598415f, -0.04129636f, 0.93576568f, -0.13132076f, -0.01012161f, -0.46479642f, -0.49955648f, 
    -0.45331979f, -0.10382508f, -0.03632855f, 0.22563362f, -0.23087183f, -0.03615123f, -0.13573192f, -0.09125133f, 
    0.14853875f, -0.33010870f, 0.06167674f, 0.30718046f, -0.19598560f, -0.40960217f, -0.15400735f, -0.43504095f, 
    -0.39899287f, -0.24455382f, 0.73581594f, 0.58291990f, -0.47586954f, -0.56638795f, -0.42336854f, 0.46566269f, 
    0.52347684f, 0.28150773f, -0.19678345f, -0.25198099f, 0.13292655f, 0.06361855f, -0.12709133f, 0.28862911f, 
    -0.03291431f, 0.20656021f, -0.29411802f, -0.28704661f, -0.18416509f, 0.10821081f, 0.14423101f, 0.33996314f, 
    0.52705622f, 0.63950723f, 0.17756350f, -0.18584210f, -0.10643335f, -0.15763693f, 0.04917514f, 0.22267283f, 
    0.05882745f, -0.08458518f, -0.10184196f, -0.00523034f, -0.14086314f, 0.19843757f, -0.31560203f, 0.29401281f, 
    -0.00124274f, 0.08456054f, -0.32747692f, -0.07460928f, 0.08551955f, -0.25859642f, -0.33159074f, -0.27113235f, 
    -0.41975707f, 1.00236297f, -0.48547181f, -0.10792620f, 0.12782946f, -0.13773875f, 0.47024584f, -0.03853169f, 
    0.22172867f, -0.36479473f, -0.35541385f, 0.17811885f, -0.07617764f, 0.17354852f, -0.28785634f, 0.01416967f, 
    -0.05819651f, -0.17867580f, 0.26961723f, -0.04058746f, -0.09781675f, -0.18900448f, 0.00201762f, -0.05134993f, 
    0.12854742f, -0.18352668f, 0.49961784f, 0.33963013f, 0.37739450f, 0.10442040f, 0.33445549f, -0.20031212f, 
    -0.48432237f, 0.00301513f, 0.62419009f, -0.28259903f, -0.05785504f, 0.14933997f, 0.05293349f, 0.02157964f, 
    -0.17632750f, -0.00458071f, -0.27657321f, 0.09790874f, -0.12709248f, 0.26038814f, -0.03198647f, 0.05034702f, 
    0.06540237f, -0.06906448f, 0.04504440f, -0.68395782f, 0.52805060f, 0.22036693f, -0.10794805f, 0.10933440f, 
    -0.52473843f, -0.21190214f, -0.11199600f, 0.05955769f, -0.16845793f, -0.08978011f, 0.29197508f, -0.29335561f, 
    0.34608811f, 0.27158391f, -0.26036143f, -0.33538267f, -0.07893916f, 0.06819241f, -0.22799039f, 0.24003068f, 
    0.21200621f, -0.27027562f, 0.39535943f, 0.25197211f, 0.34952840f, 0.60850722f, -0.20174582f, 0.49583986f, 
    -0.18821414f, -0.17520851f, -0.34838650f, -0.13510364f, -0.64521182f, -0.54817969f, -0.25536665f, 0.20500226f, 
    -0.12530197f, -0.01875115f, -0.19777183f, -0.10741145f, 0.23557051f, 0.29589713f, 0.24767236f, 0.37389174f, 
    -0.15548566f, -0.25833687f, -0.29205161f, -0.23891747f, -0.24851374f, 0.12284721f, -0.34531656f, -0.65247023f, 
    -0.26082006f, 0.28212872f, -0.45494744f, -0.31225827f, -0.41847587f, -0.49764174f, -0.12350330f, 0.40687305f, 
    -0.01066985f, 0.16121866f, 0.09135193f, 0.34694675f, 0.21665147f, 0.13251795f, 0.06550818f, 0.07357410f, 
    -0.17635915f, -0.11561571f, 0.12307290f, 0.23250625f, 0.23838030f, 0.08394038f, 0.02318050f, -0.25678274f, 
    0.03080019f, 0.17036325f, 0.10306413f, 0.19262676f, -0.13916172f, -0.03013557f, -0.04717475f, 0.30206284f, 
    -0.18736866f, 0.65994334f, -0.21598335f, -0.20545380f, 0.00441606f, -0.51243263f, 0.26482034f, 0.15422463f, 
    -0.02884419f, -0.36351690f, -0.01520706f, 0.41511142f, 0.26555794f, -0.03792728f, -0.06425965f, 0.08295549f, 
    0.26476607f, 0.05173918f, 0.22103196f, 0.25787294f, -0.01551579f, -0.04511167f, 0.21864365f, -0.17549048f, 
    0.18967457f, -0.31312254f, 0.42012459f, 0.35298440f, -0.00639494f, 0.08135497f, -0.16112174f, -0.22147602f, 
    -0.29144797f, -0.31149039f, 0.26164126f, 0.10988504f, 0.09135890f, 0.21119834f, -0.01088757f, -0.23900121f, 
    -0.53658718f, -0.62041020f, -0.38096932f, 0.43131956f, 0.61354452f, 0.23063025f, 0.02909205f, -0.21895762f, 
    -0.48612919f, -0.62195110f, 0.25234407f, 0.15423425f, 0.11101866f, -0.48405448f, -0.25209180f, -0.05309965f, 
    0.07902898f, -0.03484286f, 0.38134581f, 0.24184492f, -0.06324136f, -0.19939308f, 0.08769547f, 0.10223798f, 
    -0.10056675f, 0.36910665f, 0.38839346f, 0.38982207f, 0.32802024f, 0.15680233f, -0.30955589f, -0.10686444f, 
    -0.32803452f, -0.37121868f, -0.39871797f, 0.00761029f, -0.38669401f, 0.04722917f, -0.02751352f, -0.11431352f, 
    0.13269149f, 0.30213681f, 0.17595364f, -0.35909861f, -0.09287732f, 0.04911055f, -0.05374513f, 0.04989193f, 
    0.05778658f, -0.16071673f, -0.87146389f, -0.96409810f, -0.23952402f, 0.49904257f, 0.32252854f, 0.47518426f, 
    -0.18670326f, 0.07319928f, 0.01077471f, 0.48378235f, -0.11064474f, -0.10406287f, -0.04930592f, -0.12801622f, 
    0.23101483f, -0.07822333f, 0.05352278f, -0.16776769f, -0.12077831f, -0.34530953f, 0.35867125f, -0.05590333f, 
    0.24277681f, 0.29837731f, 0.04100723f, -0.31419739f, 0.33559746f, -0.12635060f, -0.12367093f, -0.43305373f, 
    -0.47661585f, -0.00910340f, -0.52884001f, -0.46803924f, -0.03940935f, 0.24867949f, 0.35859269f, -0.12952188f, 
    -0.17711051f, 0.23942924f, -0.03684114f, 0.10854791f, -0.06547908f, 0.32520473f, -0.29965460f, -0.08872699f, 
    -0.25430137f, -0.21972091f, -0.31382954f, 0.29507220f, 0.24718910f, 0.30137867f, -0.32331920f, 0.08881265f, 
    -0.60866624f, -0.03615152f, -0.14803679f, -0.11117600f, 0.42359218f, -0.10628001f, -0.44391620f, -0.47917712f, 
    0.12290026f, 0.35835561f, -0.12129347f, -0.17152914f, -0.35366747f, -0.08817244f, -0.24545065f, -0.25606394f, 
    -0.17012779f, -0.27176079f, 0.14049537f, -0.03722281f, -0.51198220f, 0.40397617f, -0.32263353f, -0.27686229f, 
    0.35545409f, 0.01445193f, -0.12451514f, 0.04380361f, 0.19333540f, -0.28055990f, -0.05863428f, 0.06204558f, 
    0.11672768f, -0.15743275f, -0.00099808f, 0.00744334f, 0.03721293f, -0.07434367f, -0.24454875f, -0.24094689f, 
    0.42472667f, 0.15635762f, 0.01397986f, -0.24822868f, 0.23541316f, 0.27704468f, -1.09096062f, 0.23019184f, 
    0.19519068f, 0.35595009f, 0.25924441f, -0.76256579f, -0.40551016f, 0.68431014f, 0.07571647f, -0.02183668f, 
    0.16170095f, 0.29963118f, -0.31774861f, -0.00028488f, 0.17665133f, -0.10247395f, 0.03485820f, -0.01411105f, 
    -0.34903121f, -0.15524195f, -0.27205303f, 0.16202490f, 0.18900900f, 0.15233871f, 0.08697741f, -0.56656748f, 
    -0.55242705f, 0.00230495f, -0.45285162f, -0.76865000f, 0.29820058f, 0.03142501f, 0.14522186f, 0.19198644f, 
    0.35228652f, 0.23045582f, 0.06934822f, 0.08562223f, 0.41128111f, 0.38522086f, -0.13445137f, 0.17623717f, 
    -0.09327088f, -0.38400722f, -0.17476973f, 0.06938854f, -0.12569956f, 0.28053823f, -0.19837496f, -0.23997271f, 
    -0.79875416f, -0.32507047f, -0.38360611f, -0.52623981f, -0.75575042f, 0.55120164f, 0.32849601f, 0.46308264f, 
    0.15214047f, 0.58549601f, 0.00697972f, 0.53747702f, -0.25117540f, -0.12320174f, -0.29059312f, -0.14506426f, 
    0.31895337f, 0.02698921f, -0.10973535f, 0.08234768f, 0.00645749f, -0.02144871f, 0.01101541f, 0.32427108f, 
    -0.10643099f, 0.50391006f, 0.54090470f, -0.45157969f, -0.28763452f, -0.15061617f, 0.41535613f, -0.39818308f, 
    -0.04843604f, 0.24931914f, -0.09371654f, 0.17635176f, -0.26287094f, 0.04500446f, 0.18683058f, -0.34050956f, 
    -0.06513187f, -0.23829040f, 0.37062895f, -0.02610875f, -0.08223770f, -0.29217419f, 0.15439329f, 0.09683292f, 
    -0.06320568f, 0.23184586f, 0.51781094f, 0.05769463f, 0.08886906f, -0.01804754f, -0.33746320f, 0.51072228f, 
    -0.00332670f, 0.09602197f, 0.21903591f, 0.15667407f, 0.35549691f, 0.09278258f, -0.60602200f, 0.03857764f, 
    0.32339355f, 0.11316502f, -0.02405396f, -0.05602768f, -0.08178249f, -0.36357990f, -0.02229623f, -0.11621424f, 
    -0.36109698f, 0.29134142f, 0.32901439f, -0.29578674f, -0.47780898f, 0.10878163f, -0.20398621f, -0.40772179f, 
    -0.17567088f, 0.11634614f, -0.46166682f, -0.38472638f, -0.22056000f, 0.06428760f, -0.01055234f, 0.17650761f, 
    -0.40925995f, -0.20517005f, 0.12198573f, 0.34821561f, -0.21720693f, 0.06621562f, 0.00835876f, 0.14776932f, 
    -0.21357188f, 0.13954091f, 0.19825234f, 0.26825896f, 0.36384755f, 0.15754876f, 0.12046103f, 0.24913904f, 
    0.18874623f, 0.18832107f, 0.16170093f, 0.11169951f, 0.05819753f, -0.13409080f, -0.11694333f, 0.09377226f, 
    -0.25271988f, -0.43503329f, -0.18949926f, 0.28820133f, 0.03137658f, 0.00740154f, -0.25656006f, 0.00027521f, 
    -0.03854960f, -0.26876953f, 0.17798580f, 0.06820402f, 0.30818054f, -0.10349412f, 0.28979230f, -0.29418039f, 
    -0.75786912f, -0.76451111f, -0.06234210f, 0.42414740f, 0.50292814f, 0.33418670f, 0.01394248f, -0.00827724f, 
    -0.09294415f, 0.32122844f, -0.46702191f, -0.13231322f, -0.01053022f, -0.18719682f, 0.33984154f, -0.34051090f, 
    -0.09656119f, -0.04949200f, -0.20090902f, 0.31410724f, 0.36980969f, 0.21198745f, 0.58898807f, -0.07957192f, 
    -0.15015310f, -0.48123571f, 0.56749171f, -0.29373252f, -0.26624772f, 0.22800347f, 0.34054205f, -0.35501873f, 
    0.08304546f, 0.21570727f, 0.07782251f, -0.15881872f, 0.07715007f, -0.05924608f, -0.06471415f, -0.22253861f, 
    -0.23695555f, 0.09878229f, -0.07908901f, 0.25801584f, 0.11006010f, 0.01740152f, 0.26612428f, 0.92556417f, 
    -0.24208951f, -0.46137950f, -0.82569271f, -0.71527988f, 0.00830268f, 0.11356793f, 0.33259830f, 0.08822591f, 
    0.27311388f, 0.39171961f, 0.26752773f, 0.38844547f, -0.23964071f, -0.06062537f, 0.04352805f, -0.01073763f, 
    0.09926616f, -0.16077119f, 0.30095813f, 0.38693941f, -0.19908509f, -0.32439232f, 0.03954235f, -0.19008411f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02047031f, -0.23232658f, -0.20150159f, -0.10251145f, 0.20858619f, 0.06073611f, -0.02058373f, 0.36284682f, 
    -0.00517551f, 0.38322887f, -0.11310872f, 0.12178700f, -0.01910486f, -0.09035138f, -0.02802508f, -0.05745825f, 
    0.28519237f, -0.03636871f, -0.16319028f, 0.04436160f, 0.24016091f, 0.05133426f, 0.09647226f, 0.05086454f, 
    -0.01455585f, 0.31249771f, 0.07066229f, -0.17439331f, -0.10382584f, 0.46183136f, -0.03720140f, 0.16357093f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00165866f, -0.03979078f, -0.05151859f, -0.04660777f, -0.03468452f, 0.03955752f, -0.03243846f, 0.00662331f, 
    0.03819976f, -0.02340695f, -0.03610884f, 0.04122540f, -0.02819901f, 0.03831812f, 0.03913880f, 0.04090254f, 
    0.02219467f, 0.00250228f, -0.01501724f, -0.02911970f, -0.02163042f, -0.03612816f, -0.03343590f, -0.03862618f, 
    -0.03256274f, 0.01209380f, -0.00367592f, -0.01264703f, 0.02678127f, -0.05526226f, 0.03336845f, 0.01775689f, 
    0.02852767f, 0.01010889f, -0.04700869f, 0.02813820f, 0.02744332f, 0.04963776f, 0.03082924f, 0.02320240f, 
    -0.01304206f, -0.01736247f, 0.00460786f, 0.03843995f, -0.04854554f, 0.00660918f, 0.03003372f, 0.05080275f, 
    0.02976208f, 0.00087746f, 0.02645721f, 0.01786494f, 0.03210450f, -0.04405474f, -0.05354670f, 0.01487243f, 
    0.04137487f, 0.03366403f, -0.02843271f, -0.05461261f, -0.02408626f, 0.01879711f, -0.00194599f, 0.02607034f, 
    -0.00277942f, 0.04073016f, -0.00459759f, 0.03180296f, -0.05893948f, 0.02893397f, 0.00107965f, 0.02133460f, 
    -0.00687788f, -0.04847872f, 0.02402279f, -0.04823724f, 0.00697972f, 0.00677447f, 0.01239207f, -0.01474578f, 
    0.04969304f, -0.01886269f, -0.00371375f, -0.05218341f, -0.00648718f, -0.02557200f, -0.04158404f, 0.01556126f, 
    -0.05001205f, -0.04525664f, -0.02776837f, -0.05254918f, 0.02926259f, -0.04205815f, -0.04967941f, 0.04231624f, 
    0.00852685f, -0.01324280f, 0.05545255f, 0.02595793f, 0.03157618f, 0.02278520f, 0.02300440f, 0.00942180f, 
    0.04380206f, 0.03565747f, 0.02837433f, 0.02125238f, -0.04766012f, 0.00298593f, 0.04325639f, 0.03033900f, 
    -0.04946112f, 0.03136487f, 0.00956799f, -0.03095039f, -0.01392375f, 0.01970499f, -0.05231958f, 0.01787381f, 
    -0.02003684f, 0.04963978f, -0.01696669f, -0.02522362f, -0.04558504f, 0.02134259f, -0.03143375f, -0.01565930f, 
    0.02852924f, -0.01955996f, 0.03770511f, 0.03716248f, 0.04822769f, 0.00942094f, 0.02750224f, 0.00872763f, 
    0.02134923f, -0.05357050f, -0.02641282f, -0.02539993f, -0.00521050f, 0.03730351f, 0.03314372f, 0.02598192f, 
    -0.04328582f, 0.03736060f, -0.04221442f, -0.03436919f, -0.04353192f, -0.02110660f, 0.03479056f, -0.05882895f, 
    -0.04851295f, -0.00612641f, 0.04023402f, 0.02601029f, -0.02487196f, -0.04494327f, 0.02250466f, 0.02712117f, 
    0.01347215f, -0.05162722f, 0.02287511f, -0.01170295f, 0.02664019f, -0.02839488f, -0.00903945f, 0.01438501f, 
    0.03276648f, -0.01804989f, -0.01997710f, 0.00049891f, 0.02929547f, 0.00756888f, -0.03221241f, -0.05125746f, 
    -0.00680870f, 0.03795657f, 0.04058332f, 0.02541380f, 0.00776571f, -0.02625969f, -0.04547914f, -0.01047583f, 
    -0.01089575f, -0.05242321f, 0.01543928f, 0.03478381f, -0.03237479f, 0.00051296f, -0.04739062f, 0.00311487f, 
    0.02194327f, 0.00343722f, -0.01685937f, -0.01258467f, 0.03024752f, -0.04538293f, -0.03244117f, 0.00279800f, 
    -0.05659587f, -0.01170537f, -0.01507891f, -0.03901133f, -0.00685248f, -0.00192421f, -0.04812537f, -0.02597068f, 
    0.03615857f, -0.04246821f, -0.03976548f, -0.05230244f, 0.05084447f, 0.02642683f, 0.00936897f, -0.03763762f, 
    -0.01495113f, -0.03576562f, 0.00763087f, 0.00358114f, 0.01790710f, 0.03839053f, 0.03591062f, -0.05668753f, 
    0.03926498f, 0.02376629f, 0.04229103f, -0.02533395f, -0.02337324f, -0.02309126f, -0.03679726f, -0.03183204f, 
    -0.05208196f, 0.01870738f, -0.05739546f, -0.03463519f, -0.00762596f, -0.03842394f, 0.01265014f, 0.03091203f, 
    -0.03125372f, -0.01911547f, 0.02544215f, 0.03171510f, -0.04506014f, 0.00519024f, -0.03890514f, -0.00532241f, 
    0.01156787f, -0.04171506f, 0.00528490f, 0.04029007f, 0.00661690f, 0.03863877f, 0.02336822f, 0.02166909f, 
    0.03937944f, -0.02980474f, -0.03526662f, -0.05384338f, -0.00864933f, -0.04733509f, 0.02300261f, -0.02793203f, 
    -0.01723586f, 0.02730870f, -0.02268113f, -0.05854889f, 0.03866356f, -0.03302647f, -0.05495624f, 0.03901387f, 
    -0.00339896f, 0.00128491f, -0.03163182f, 0.04542614f, 0.01607057f, -0.02594900f, 0.03796606f, -0.05750901f, 
    -0.04994804f, -0.00826985f, 0.00989545f, -0.05322024f, -0.00293071f, -0.05003594f, -0.01089801f, -0.01382656f, 
    -0.04743067f, -0.00629531f, -0.03946519f, -0.05679316f, 0.03891291f, -0.00266101f, -0.04585983f, -0.03457217f, 
    0.00895985f, 0.03148675f, -0.02827621f, -0.03998973f, 0.00242853f, -0.04838785f, -0.00414283f, -0.05208306f, 
    -0.00597829f, -0.03820125f, -0.03118198f, -0.01801882f, 0.03981308f, -0.01609669f, -0.01428355f, 0.00328335f, 
    -0.01321841f, 0.00886095f, -0.03785421f, -0.01101606f, -0.04158436f, 0.01996390f, -0.02410446f, 0.04938570f, 
    -0.03134477f, 0.02749983f, 0.00544418f, -0.01860147f, 0.00859520f, 0.02619329f, 0.00678358f, -0.03705509f, 
    0.00491331f, 0.01322312f, -0.02699590f, 0.04933817f, -0.01872918f, 0.02393819f, 0.02328629f, 0.00234719f, 
    -0.00878077f, -0.01314330f, -0.01030994f, -0.03168896f, 0.01147236f, -0.03495997f, 0.02491372f, -0.02598880f, 
    -0.01266441f, -0.05217357f, -0.02270893f, 0.02251690f, 0.02772436f, 0.02947650f, -0.04042363f, 0.02529594f, 
    0.01316413f, 0.00821116f, 0.03529919f, -0.00508104f, -0.00933221f, 0.04018207f, -0.05419375f, 0.02627915f, 
    0.01245567f, -0.00938897f, -0.00322790f, -0.04009372f, 0.02552613f, 0.04128765f, 0.02885890f, -0.00811841f, 
    0.00427836f, -0.01904372f, 0.02946619f, 0.01829025f, 0.03571998f, -0.02287347f, 0.00809032f, -0.02743783f, 
    0.02961458f, -0.04379470f, 0.04206709f, -0.04431287f, -0.04846085f, 0.04299453f, 0.00275617f, -0.05546266f, 
    -0.13292395f, 0.40806475f, -0.24463210f, 0.01435643f, 0.05698888f, 0.05669360f, -0.02016641f, -0.11953386f, 
    -0.00596020f, 0.07344547f, -0.10321828f, 0.01911211f, -0.24598502f, -0.17020360f, 0.01845505f, -0.08542030f, 
    -0.17369708f, -0.10458534f, -0.05813332f, -0.04574593f, 0.09930338f, -0.01329479f, -0.01578325f, 0.00751975f, 
    -0.11432146f, 0.09132387f, 0.00705920f, -0.02086509f, 0.08477356f, 0.26675025f, 0.04444947f, -0.05532812f, 
    0.02314488f, 0.14955601f, 0.00946697f, -0.01904101f, -0.22136089f, 0.11142541f, -0.16882965f, -0.14223151f, 
    -0.03627917f, 0.00431907f, -0.02039573f, -0.10597664f, -0.13279311f, -0.04733493f, -0.01242674f, -0.08073949f, 
    -0.17172408f, 0.01202741f, 0.11130513f, 0.03655211f, -0.01766256f, 0.04324191f, 0.04905072f, 0.20090021f, 
    0.08977942f, -0.04051797f, -0.07687497f, 0.21775989f, 0.23986997f, 0.01203257f, -0.07283451f, -0.08835011f, 
    0.02671896f, 0.16782579f, 0.09409603f, -0.06147768f, 0.03936252f, -0.00307234f, 0.21946475f, 0.06190770f, 
    -0.03383045f, 0.14313848f, 0.17780098f, -0.02676234f, 0.07389440f, 0.03710611f, 0.04824739f, -0.03075560f, 
    -0.05633006f, -0.00861237f, 0.18263349f, -0.02378015f, 0.27147433f, 0.01421129f, -0.17164207f, 0.26427707f, 
    0.00770361f, 0.09109802f, 0.07897640f, -0.02931075f, 0.12867221f, 0.13223189f, 0.14521256f, -0.01006252f, 
    -0.00261999f, -0.04062085f, 0.18799905f, -0.09918297f, -0.00846967f, -0.08600467f, 0.03123841f, -0.00521645f, 
    0.02596018f, 0.06695273f, 0.17122306f, 0.00813472f, -0.00875440f, 0.17496434f, 0.16607825f, 0.19782910f, 
    0.00231007f, 0.04854080f, -0.03533006f, 0.20254408f, 0.10198014f, -0.02684055f, 0.01742710f, 0.15755470f, 
    0.37700167f, 0.22165716f, 0.35017878f, -0.03580008f, 0.01478780f, -0.02518655f, 0.03432809f, 0.05519059f, 
    -0.06569312f, 0.02539883f, -0.06825764f, 0.04049704f, 0.24662749f, -0.09973769f, -0.09488551f, -0.23956387f, 
    0.13668443f, -0.12681015f, -0.08944296f, -0.02626664f, -0.09063139f, 0.00107709f, 0.08168197f, 0.12063629f, 
    -0.03322814f, -0.00408036f, 0.09754398f, -0.10648715f, -0.17872193f, -0.06380626f, 0.02905488f, 0.08948530f, 
    -0.09879337f, -0.13551794f, -0.02036509f, -0.11151809f, -0.12098050f, -0.09104651f, 0.03074329f, -0.06620304f, 
    -0.17442334f, 0.03500156f, -0.02026480f, 0.07896873f, -0.13018645f, -0.20563829f, -0.11826675f, -0.15531947f, 
    -0.08830331f, 0.19598474f, -0.06460432f, 0.06200754f, -0.11578399f, -0.00561793f, 0.08241653f, -0.00127273f, 
    0.06139281f, 0.10518348f, 0.25504297f, 0.15148962f, 0.26460442f, 0.20559186f, 0.19215077f, -0.00644165f, 
    -0.09845711f, -0.03278830f, -0.00152734f, -0.02581665f, -0.03104698f, 0.13388903f, 0.05336518f, 0.11375938f, 
    -0.08998995f, 0.16336949f, 0.00218795f, 0.07468638f, -0.13101126f, 0.16967151f, 0.11249684f, -0.04327130f, 
    -0.09045744f, -0.14898802f, -0.06343255f, 0.02461389f, 0.21534882f, 0.11665248f, 0.16072470f, -0.13036633f, 
    -0.13105087f, -0.17304641f, 0.01941095f, -0.03788031f, 0.00308700f, 0.02137290f, -0.03066154f, -0.07446299f, 
    -0.29942620f, -0.23585406f, -0.26028508f, -0.04749749f, 0.02046255f, 0.03100913f, -0.07460199f, 0.07547151f, 
    0.01971274f, -0.18439087f, -0.05024529f, 0.08982550f, -0.17649481f, -0.06658369f, -0.02401964f, -0.00320572f, 
    -0.14062427f, -0.00912871f, -0.00047172f, -0.03059385f, -0.03693421f, -0.06702074f, -0.06083123f, 0.11250059f, 
    0.03358459f, -0.14317602f, -0.00383072f, -0.00456067f, 0.19331951f, 0.05829208f, 0.15530062f, 0.12515920f, 
    0.15418980f, 0.25767708f, 0.11892774f, -0.02731241f, 0.02635311f, 0.11111625f, -0.05786922f, 0.08180699f, 
    0.09491213f, 0.13947552f, 0.09310204f, 0.00560113f, 0.05579782f, 0.11867587f, -0.10063060f, -0.01028577f, 
    0.59611869f, 0.20402004f, -0.15644194f, -0.02968200f, 0.09940866f, 0.08138548f, -0.13839509f, -0.03374754f, 
    -0.00107392f, 0.08982228f, 0.06701116f, 0.09046929f, -0.40048528f, -0.19122709f, -0.03834539f, 0.05915412f, 
    0.06772961f, 0.01908591f, 0.16261704f, 0.04405194f, -0.02070420f, 0.09239749f, -0.11361817f, -0.08168795f, 
    -0.39673904f, -0.06906299f, -0.15629719f, 0.05424871f, -0.12643412f, 0.05406168f, 0.12204804f, 0.09121580f, 
    -0.00220739f, -0.07846686f, 0.02096267f, -0.04993741f, 0.28688964f, 0.04121747f, 0.26467988f, 0.18683453f, 
    0.01348448f, 0.03460118f, -0.08499519f, 0.09766152f, 0.06797533f, 0.02433527f, 0.09363660f, 0.07206155f, 
    -0.03772198f, 0.13000163f, -0.04761815f, 0.20876709f, 0.05264548f, -0.01664269f, -0.00916975f, 0.12459285f, 
    0.19370851f, 0.12414610f, 0.11977751f, 0.21377404f, -0.17301688f, -0.07940047f, 0.11670495f, 0.19946529f, 
    -0.07168002f, 0.02128227f, -0.06573865f, -0.11495932f, -0.10254239f, -0.10886674f, -0.09505744f, 0.00396141f, 
    0.03434306f, 0.11481395f, 0.01946448f, 0.06278831f, -0.06689624f, -0.03008640f, -0.05278697f, -0.10324328f, 
    -0.04364142f, 0.05519948f, 0.00701466f, 0.11101007f, -0.14859718f, -0.03751152f, 0.05860697f, 0.00979337f, 
    0.06122906f, 0.17631711f, 0.00855702f, 0.02105912f, 0.10265223f, 0.15534157f, 0.12202922f, 0.00685565f, 
    0.18236266f, -0.04925212f, 0.10565384f, -0.12899627f, 0.00777242f, 0.20173851f, -0.15481208f, 0.03660503f, 
    -0.09164978f, 0.11658996f, -0.04644608f, 0.16227965f, -0.10329399f, -0.18504597f, -0.20803584f, -0.04841723f, 
    -0.14693339f, 0.13438356f, 0.19892761f, 0.28507859f, -0.02054422f, 0.18148641f, 0.09201942f, -0.12494490f, 
    0.01815297f, -0.03642301f, -0.01269757f, 0.02242693f, -0.03297863f, 0.04132097f, -0.01920733f, -0.04952203f, 
    -0.01361227f, 0.01861573f, 0.01424738f, 0.02537224f, 0.01084342f, 0.00271503f, 0.00466098f, -0.04214013f, 
    -0.05365765f, 0.01254841f, -0.00086486f, 0.02888272f, -0.00368438f, -0.02425666f, -0.05465766f, 0.01004505f, 
    -0.02545054f, 0.01454749f, -0.04595605f, 0.01614970f, 0.02137174f, -0.00435605f, 0.01223379f, 0.00031415f, 
    -0.04614101f, 0.03158113f, -0.05496775f, -0.00924533f, -0.03716881f, 0.02078873f, 0.00645109f, 0.02182242f, 
    0.04467213f, 0.03610969f, -0.02433079f, -0.03368873f, 0.02016161f, 0.00602644f, 0.00818205f, 0.02885017f, 
    -0.02163728f, 0.04044788f, -0.03988414f, 0.03644021f, 0.04529122f, -0.02295519f, 0.04175209f, 0.02146301f, 
    -0.02037430f, 0.02640600f, 0.01386836f, -0.03306020f, 0.01136364f, -0.03367344f, 0.00964041f, -0.00933064f, 
    0.00759684f, -0.01345514f, -0.00149763f, 0.04341536f, 0.02437087f, -0.00920197f, 0.01227644f, 0.02066504f, 
    -0.02729370f, -0.04489359f, 0.00763068f, 0.01801058f, -0.01214301f, 0.01052461f, -0.00727709f, -0.04270250f, 
    -0.02220829f, 0.02416190f, -0.03511873f, -0.03078928f, -0.00079563f, 0.03912457f, -0.01726531f, 0.02453762f, 
    -0.03483915f, -0.01951811f, -0.01310257f, -0.03052793f, 0.04043372f, 0.04436571f, -0.05319575f, -0.01051392f, 
    -0.05187655f, -0.03556613f, 0.03000495f, 0.02024444f, -0.01049244f, 0.00503227f, -0.03878038f, -0.00479919f, 
    0.00560947f, -0.00441411f, 0.03565423f, -0.02690526f, -0.02493745f, 0.04482581f, 0.00739185f, -0.03722758f, 
    -0.00850560f, -0.01606727f, 0.02306859f, 0.00285579f, -0.03211498f, 0.00140118f, -0.01050601f, -0.00863537f, 
    -0.01004302f, -0.04209797f, -0.01752061f, -0.02228447f, -0.03375085f, -0.02873634f, -0.05552970f, 0.03457991f, 
    0.02378777f, 0.01336053f, -0.00254032f, -0.00554726f, -0.01983425f, -0.03064325f, -0.03335765f, 0.04418439f, 
    -0.00207000f, 0.01601499f, -0.00636016f, -0.02640371f, -0.03659647f, 0.02086264f, -0.03035343f, 0.02300613f, 
    -0.01256064f, 0.03253224f, -0.02278341f, 0.01274449f, 0.01681421f, -0.02619903f, -0.01600341f, -0.03681440f, 
    0.00056975f, -0.05657850f, -0.00901919f, -0.05197755f, -0.05514517f, -0.05523396f, 0.00243974f, -0.02460238f, 
    0.03835864f, 0.01495672f, 0.00932766f, -0.04332565f, 0.01736642f, 0.02230440f, -0.02900760f, -0.05238698f, 
    0.00294877f, 0.03397375f, -0.01117907f, -0.04520606f, 0.04357674f, -0.01162047f, 0.01367586f, -0.01874233f, 
    -0.01327430f, 0.02726215f, -0.02776745f, 0.04295093f, 0.04126214f, 0.00382471f, -0.00571717f, -0.01690303f, 
    0.01204452f, -0.04389116f, -0.05207356f, -0.03472488f, -0.03075019f, -0.03675012f, 0.00980499f, -0.02014211f, 
    0.01135690f, 0.02004579f, 0.00290382f, 0.03451215f, 0.04252623f, -0.00587013f, -0.00267872f, 0.00304998f, 
    0.02585691f, 0.02370484f, -0.04193000f, -0.02156478f, 0.02727833f, -0.00333014f, 0.02620269f, -0.03017610f, 
    0.01536060f, -0.03482161f, -0.04803135f, -0.03847802f, 0.01249014f, -0.00833386f, -0.01565428f, 0.01566241f, 
    -0.00006387f, 0.01227180f, -0.05454412f, -0.01297120f, -0.00942761f, -0.01063914f, -0.03873656f, -0.01497199f, 
    0.01217801f, -0.03244009f, -0.00920527f, 0.04255941f, 0.02405039f, 0.01706409f, -0.04213353f, 0.00849124f, 
    -0.00133751f, -0.02164965f, 0.00038042f, -0.04216577f, 0.01783029f, 0.02783965f, -0.00751587f, -0.02046155f, 
    -0.05285053f, -0.00425131f, 0.03905455f, -0.05072888f, -0.04990631f, -0.04458378f, -0.00078444f, 0.02680881f, 
    0.02746728f, 0.03199156f, -0.03005849f, -0.05441974f, -0.01141089f, 0.02624501f, -0.05069822f, -0.02930509f, 
    0.03016252f, 0.02286389f, -0.00491867f, -0.03819972f, -0.03168414f, 0.00949519f, -0.02410335f, -0.01703686f, 
    -0.03998660f, 0.02710346f, 0.01398043f, 0.01150370f, 0.03097039f, -0.03538977f, -0.02746179f, 0.00443007f, 
    -0.00981570f, -0.03392997f, -0.04835337f, -0.04567173f, -0.01339823f, 0.02755826f, -0.00299046f, 0.02133886f, 
    -0.00826978f, 0.01120705f, 0.01686349f, 0.03756252f, -0.05383251f, -0.02820221f, 0.02543006f, -0.02654551f, 
    -0.02857354f, 0.01608313f, 0.01603361f, 0.00121812f, 0.03112013f, -0.02638093f, -0.04074274f, 0.04484398f, 
    -0.00256584f, -0.04252005f, -0.04798522f, -0.01005347f, 0.02165354f, -0.05131713f, 0.00504856f, 0.02704365f, 
    0.03430815f, 0.00227811f, 0.04102539f, -0.02969371f, 0.00952930f, 0.02979047f, 0.02961029f, -0.04959695f, 
    0.01612423f, -0.01947186f, -0.02253322f, 0.03904764f, -0.04295683f, 0.02261457f, -0.01729974f, -0.05331431f, 
    -0.03360423f, 0.03122912f, -0.01419814f, -0.05049997f, -0.05062761f, 0.03388812f, 0.01506744f, -0.04143155f, 
    -0.00804890f, 0.02227163f, -0.02582770f, -0.05011035f, -0.02209557f, -0.05391597f, 0.02014842f, -0.00278182f, 
    -0.02356329f, 0.00340635f, -0.00777972f, -0.04584892f, 0.04498513f, -0.02314741f, -0.00855345f, -0.04375095f, 
    -0.01151880f, -0.04956032f, -0.02362771f, 0.04196347f, -0.00665951f, -0.02071366f, -0.00385266f, -0.04983898f, 
    0.00594635f, 0.03145334f, -0.04957872f, -0.01728529f, 0.00902415f, -0.04783509f, 0.00310907f, -0.03189954f, 
    -0.04203360f, 0.03168306f, -0.03972770f, -0.01994454f, -0.02490590f, 0.03332026f, 0.04268601f, 0.01722587f, 
    -0.03462328f, 0.01043850f, 0.04327659f, -0.04598749f, -0.01851335f, 0.00603474f, -0.01459383f, 0.00327173f, 
    -0.05209535f, 0.00480357f, -0.00758058f, -0.01192303f, 0.00006566f, 0.00003463f, -0.04641372f, -0.04788386f, 
    0.03227612f, -0.04514954f, 0.03986984f, 0.01774901f, -0.00313032f, -0.05117066f, -0.01243818f, 0.01362662f, 
    -0.00577270f, -0.00056820f, 0.00638175f, -0.00012041f, 0.03553948f, 0.02993982f, -0.02058474f, -0.03740624f, 
    -0.03873234f, 0.01069515f, -0.02556073f, 0.02843632f, -0.06234130f, -0.01423768f, -0.00135001f, 0.00216229f, 
    -0.01918038f, 0.03318986f, -0.04685661f, 0.00657890f, 0.03565966f, -0.01240238f, -0.03772295f, 0.02594797f, 
    -0.02728723f, -0.03868373f, 0.04041962f, -0.00434894f, 0.03596094f, -0.02497430f, -0.05900514f, -0.04058089f, 
    -0.03785341f, 0.04544545f, -0.04489868f, -0.03961455f, 0.01306827f, -0.02470028f, -0.05720221f, -0.00562573f, 
    0.01635198f, 0.03095040f, -0.03233015f, -0.04575620f, -0.03647776f, 0.00884798f, -0.03099530f, -0.05285995f, 
    0.04346100f, -0.05537743f, -0.02321346f, 0.01682432f, -0.04700219f, -0.05942541f, -0.03238418f, -0.03561370f, 
    -0.00272559f, -0.02563256f, 0.04351496f, -0.01549572f, -0.04340105f, 0.01953797f, 0.01592606f, -0.04820348f, 
    0.01124750f, 0.02058997f, 0.00802628f, -0.00016599f, 0.04185786f, -0.03673828f, -0.01118596f, 0.01836901f, 
    0.04571635f, -0.05428334f, 0.01335890f, 0.03638452f, 0.01874195f, -0.00184126f, -0.05694103f, -0.02680288f, 
    -0.00405961f, -0.04640623f, 0.00767455f, -0.00457371f, -0.04908455f, -0.00869562f, -0.05620448f, 0.00166782f, 
    0.02356266f, -0.03397313f, 0.02364475f, -0.02067492f, -0.00292875f, -0.02838847f, -0.00014838f, -0.02522571f, 
    0.02271431f, -0.04383305f, -0.02610346f, -0.00881889f, -0.03831131f, -0.02626879f, -0.05518014f, 0.01186433f, 
    -0.04323875f, -0.04566795f, -0.01874053f, -0.00439972f, 0.02387952f, 0.02026297f, -0.00638403f, -0.01595861f, 
    -0.02525250f, -0.05014994f, -0.02215929f, 0.02431958f, 0.00739655f, -0.01162288f, -0.02321059f, -0.00292357f, 
    0.02192621f, -0.00726346f, -0.04456614f, 0.03398530f, -0.04179767f, -0.00086249f, -0.05816504f, -0.04722257f, 
    -0.00199181f, -0.03559270f, -0.04386277f, 0.00268295f, -0.02364999f, -0.04272662f, 0.01349836f, -0.00765981f, 
    0.03460078f, -0.00537722f, 0.02706758f, -0.05489566f, -0.04273668f, -0.00575636f, -0.01781717f, -0.02620887f, 
    -0.01865382f, -0.01903149f, -0.00762177f, -0.04503811f, 0.01334099f, 0.02030205f, -0.00156461f, -0.02454085f, 
    -0.03385776f, -0.05492992f, -0.02112866f, 0.01679478f, 0.00041261f, 0.03363374f, 0.00497038f, -0.04324119f, 
    0.01640675f, -0.06032830f, -0.04073492f, -0.01048243f, -0.05006640f, 0.00745719f, -0.03829907f, 0.03445788f, 
    -0.05321263f, 0.02886805f, -0.04621657f, 0.01548780f, -0.05531404f, -0.03872254f, -0.01676316f, -0.03746825f, 
    -0.00962106f, -0.02097679f, 0.04004417f, 0.01272953f, -0.01960081f, -0.01332957f, 0.00300396f, -0.00063117f, 
    -0.02215014f, 0.00160128f, -0.02403484f, 0.03459429f, -0.03519234f, -0.03838114f, 0.03373700f, -0.01086691f, 
    -0.04276513f, -0.04286136f, 0.00623424f, -0.04542042f, -0.04695705f, -0.03230853f, -0.00231908f, -0.03650725f, 
    -0.02508128f, -0.04961783f, -0.02775731f, -0.04483618f, -0.00035176f, -0.04322509f, -0.03158410f, 0.04323366f, 
    0.00301799f, 0.00584081f, 0.03260883f, -0.04001810f, 0.03153505f, -0.01144615f, -0.03123272f, -0.01477080f, 
    0.03150757f, 0.01329635f, 0.01783431f, 0.02147258f, 0.02937603f, -0.05537784f, 0.02465681f, -0.02682844f, 
    0.03043956f, 0.01616872f, 0.03551786f, 0.00257633f, -0.06142738f, 0.03240884f, -0.02761120f, 0.00659396f, 
    -0.01043601f, -0.03155782f, -0.01088336f, -0.01836568f, 0.00268434f, 0.02093889f, -0.01253482f, 0.00858157f, 
    0.03973182f, -0.02114121f, -0.03599302f, -0.00652400f, 0.01784580f, -0.00499613f, -0.05150629f, 0.02070615f, 
    -0.01807057f, -0.03795100f, 0.04602021f, -0.02293487f, -0.02230473f, 0.00865571f, 0.02014058f, -0.03342074f, 
    -0.05380267f, 0.02487420f, 0.03591865f, -0.01807353f, -0.03299058f, 0.03774556f, 0.02674196f, -0.05104012f, 
    -0.05182750f, -0.04994526f, 0.02121059f, -0.05908838f, 0.02274320f, -0.01307344f, 0.03301711f, -0.01197195f, 
    0.02679105f, 0.02490506f, 0.03894702f, -0.03518726f, 0.00447144f, 0.00596581f, 0.00371758f, 0.04112557f, 
    0.01899880f, 0.02013826f, 0.01851588f, -0.03382299f, -0.04450764f, 0.01946321f, -0.05279618f, -0.02019077f, 
    0.01812234f, 0.00104900f, -0.00084119f, 0.01371212f, -0.01405508f, -0.05211240f, -0.05230069f, 0.02970886f, 
    -0.00404194f, 0.03011624f, -0.03799869f, -0.01176296f, -0.01817306f, 0.02091789f, 0.00942560f, 0.01696529f, 
    -0.02944377f, 0.04827973f, 0.01474678f, -0.05896754f, 0.01530959f, 0.01683381f, -0.01966009f, 0.03026441f, 
    -0.01146600f, 0.02650693f, 0.02806765f, 0.02234403f, -0.02225343f, 0.04234424f, 0.02169241f, -0.02935581f, 
    -0.02997624f, -0.01507181f, 0.02411195f, -0.01412865f, 0.04509224f, 0.02753094f, -0.03987198f, -0.03488128f, 
    -0.00073681f, -0.00933079f, 0.00712556f, -0.02670931f, 0.04411948f, -0.02960579f, -0.03148444f, -0.05903060f, 
    -0.00582591f, 0.00432407f, -0.04554500f, 0.02441702f, -0.00031262f, 0.00078528f, 0.03235483f, -0.04277160f, 
    -0.00606209f, -0.02383128f, -0.00181118f, 0.01720538f, 0.01610793f, 0.03886631f, 0.02272024f, -0.01118128f, 
    -0.01370339f, 0.00687345f, -0.03626193f, 0.01469210f, 0.00046333f, 0.02123653f, 0.04028951f, 0.01541592f, 
    0.03164211f, 0.00447748f, -0.05158921f, -0.01062414f, -0.01133889f, 0.00999920f, -0.01832219f, 0.01349713f, 
    -0.00924779f, -0.02042018f, 0.03728229f, -0.04245565f, 0.03084655f, -0.02781546f, -0.00389872f, 0.02394621f, 
    -0.20945060f, 0.19027984f, -0.09892579f, -0.03912684f, 0.12316535f, 0.15824232f, -0.06863133f, -0.13629699f, 
    0.02355926f, 0.14390539f, -0.05229867f, 0.07071435f, -0.26793131f, -0.23605293f, 0.14996137f, 0.08174674f, 
    -0.16851810f, -0.13329838f, -0.04257802f, 0.15161084f, -0.07987908f, -0.09529676f, 0.03503769f, -0.04782658f, 
    -0.08313785f, 0.00675018f, 0.01532088f, -0.09236643f, -0.05918973f, 0.09587409f, 0.05765438f, -0.04841330f, 
    0.13765998f, 0.07762122f, -0.00663626f, -0.01836369f, -0.05003720f, 0.07870006f, -0.07821868f, -0.09064880f, 
    -0.01392338f, -0.10206325f, -0.03792031f, -0.05135675f, -0.11798772f, 0.02557380f, -0.01169834f, -0.11830363f, 
    -0.17348818f, 0.09964402f, 0.14977509f, -0.04154465f, 0.03285303f, 0.10282285f, 0.12838893f, 0.01590957f, 
    0.06689328f, -0.13833812f, 0.06895509f, 0.15600243f, 0.25496557f, 0.08818243f, -0.17511809f, -0.21381199f, 
    -0.04292569f, 0.00282715f, -0.10908921f, -0.04311194f, -0.01116382f, -0.04994503f, -0.10990002f, 0.01465654f, 
    -0.21067870f, 0.16283742f, 0.41913885f, 0.08133621f, 0.06699689f, 0.02495990f, 0.13315840f, 0.00249565f, 
    0.02195631f, 0.17611782f, 0.03668499f, 0.07103445f, 0.11910141f, -0.27658802f, -0.28746250f, 0.41667709f, 
    -0.03046290f, 0.05589059f, 0.02984592f, 0.23169087f, 0.07832623f, 0.16114341f, 0.02721824f, 0.05770127f, 
    0.17385972f, 0.13183820f, 0.05954255f, -0.14776902f, -0.05658149f, -0.12445164f, -0.04669469f, -0.01845118f, 
    0.09211222f, 0.11148782f, 0.22578497f, 0.02538786f, -0.11254013f, 0.33141834f, 0.16447793f, -0.06492572f, 
    0.01632047f, -0.00743130f, 0.01338791f, 0.11809599f, 0.10261350f, -0.11504120f, 0.07682682f, -0.07042904f, 
    0.12392193f, 0.16022363f, -0.00256525f, -0.17536767f, -0.06737371f, -0.16795795f, -0.02456040f, 0.01042874f, 
    0.04484501f, 0.05436782f, -0.03980422f, -0.02470822f, 0.29450610f, -0.01653943f, 0.01202763f, 0.02885467f, 
    0.04593808f, -0.15779132f, 0.03071990f, -0.08032158f, -0.03131675f, 0.08080529f, 0.11468486f, 0.14107049f, 
    -0.05736759f, -0.02740435f, 0.15575473f, 0.02417511f, -0.09454605f, 0.07549535f, 0.14130968f, -0.01304862f, 
    -0.02958257f, -0.01976974f, 0.02395243f, -0.01215735f, -0.38172007f, -0.21259299f, 0.01721542f, 0.10874919f, 
    -0.06019685f, 0.05668823f, -0.05070208f, 0.04971449f, 0.04189529f, -0.04023992f, -0.07657409f, -0.03237775f, 
    0.02731962f, 0.22344862f, 0.03175486f, 0.01575941f, -0.14397420f, -0.05197739f, 0.05427272f, 0.01996137f, 
    0.05664489f, -0.04132174f, 0.11026981f, -0.01996457f, -0.02353396f, 0.08255449f, -0.00616098f, -0.08372637f, 
    -0.02944562f, 0.01639268f, 0.00392804f, -0.03549122f, 0.00976751f, -0.00230659f, -0.13658315f, 0.03289560f, 
    -0.24312267f, -0.05257661f, 0.28579828f, 0.20433435f, -0.02560823f, 0.14215821f, 0.03278538f, 0.02541285f, 
    -0.06701172f, -0.03762411f, 0.03827369f, -0.00009239f, 0.11430930f, -0.04531094f, -0.11908363f, -0.15378912f, 
    -0.23434363f, -0.02721150f, -0.06306954f, -0.04631272f, -0.00183578f, -0.01250940f, -0.01646231f, -0.04969830f, 
    0.07837499f, -0.13919853f, -0.10344630f, 0.09329054f, -0.00880245f, 0.02760198f, -0.14366902f, 0.16540739f, 
    -0.04330199f, 0.05683193f, 0.22799507f, 0.03559510f, -0.21195883f, -0.20007853f, 0.01244235f, 0.08032622f, 
    -0.01818590f, 0.00642488f, 0.17548852f, 0.04805539f, 0.01492580f, -0.00895121f, -0.01183070f, 0.01977395f, 
    -0.00914614f, 0.02816723f, 0.02976294f, 0.06958375f, 0.01842979f, 0.02570744f, 0.12922114f, 0.17495729f, 
    0.08802636f, 0.09168337f, -0.04625378f, 0.14986806f, -0.05765418f, 0.02304236f, 0.18309954f, 0.00419658f, 
    -0.02019386f, 0.01684225f, 0.02804288f, 0.10431944f, 0.01808366f, 0.03793875f, -0.00669064f, 0.11007194f, 
    0.80384403f, 0.19241628f, -0.30837378f, 0.06587663f, 0.20315903f, 0.05218106f, -0.06666660f, 0.05926344f, 
    -0.02456942f, 0.02104455f, 0.20272845f, -0.06735606f, -0.08748275f, -0.03847453f, 0.00732580f, 0.01449449f, 
    -0.00685513f, -0.10307443f, 0.14204311f, 0.08968949f, -0.10371267f, 0.09927319f, 0.14251386f, 0.04855492f, 
    -0.14881915f, 0.12581356f, 0.18331163f, 0.24144633f, -0.04361288f, -0.12453695f, -0.00073982f, 0.26136810f, 
    -0.02158072f, -0.01792265f, 0.09632783f, -0.02010226f, 0.17918448f, 0.08499229f, 0.20107605f, 0.15443616f, 
    -0.01079107f, -0.03562421f, 0.06223214f, 0.00132145f, 0.18960361f, 0.03219504f, 0.12649973f, 0.09309045f, 
    -0.01452146f, 0.03213430f, -0.03502231f, -0.04544529f, 0.15319236f, -0.03480735f, -0.03523241f, 0.04181458f, 
    0.10138512f, -0.00015721f, 0.08291472f, 0.03475905f, -0.27859056f, -0.26950783f, 0.23712757f, 0.25334907f, 
    -0.00750186f, -0.02081561f, -0.06474005f, -0.11252471f, -0.02709535f, -0.09338062f, -0.04185628f, 0.02726214f, 
    -0.14363541f, 0.06342771f, 0.05428017f, -0.21350740f, -0.06051042f, -0.09631496f, -0.07678845f, -0.08006094f, 
    0.01211071f, -0.04068064f, 0.00239354f, -0.00023062f, 0.02375758f, 0.22296856f, -0.04281472f, 0.14487952f, 
    -0.06990067f, 0.13613731f, 0.05974876f, 0.13049302f, 0.08008955f, 0.12718782f, 0.14841962f, 0.08098585f, 
    -0.04882874f, 0.05356863f, 0.10633556f, -0.05931845f, 0.11993016f, -0.05811482f, 0.01425029f, 0.08185750f, 
    0.00513081f, 0.11222605f, 0.01937391f, 0.11227878f, -0.13341360f, 0.15081213f, -0.11724336f, -0.05952461f, 
    -0.14128949f, -0.02222132f, 0.24766989f, 0.30874896f, -0.04668364f, 0.04866285f, 0.01462567f, 0.05687930f, 
    0.00918807f, -0.13979645f, -0.02415923f, -0.10397444f, -0.13784796f, 0.04956954f, -0.08885520f, 0.05001949f, 
    0.04066562f, 0.00007527f, 0.07563020f, -0.02395741f, 0.32825479f, 0.21687979f, 0.03715326f, 0.06433491f, 
    0.29102147f, 0.11635040f, 0.05063780f, 0.09625921f, -0.06175165f, -0.14202824f, 0.06417979f, 0.07712709f, 
    0.17576383f, -0.01290239f, 0.04509863f, 0.04676561f, 0.08782922f, 0.00087822f, 0.08284909f, 0.02432453f, 
    -0.11539009f, -0.05298482f, 0.07488407f, 0.07460285f, -0.08736189f, -0.16608396f, -0.03111502f, -0.09495198f, 
    0.02569542f, -0.02573377f, -0.04046619f, 0.01122690f, 0.18960667f, 0.16353622f, -0.05419639f, 0.25846863f, 
    0.23600315f, 0.02792057f, -0.03862116f, 0.15249965f, -0.00192390f, -0.01979380f, -0.04118949f, -0.09744838f, 
    -0.11322932f, 0.06004897f, -0.12452785f, -0.27059332f, -0.21376657f, 0.00640216f, 0.15169241f, 0.03558959f, 
    0.00260374f, 0.06143143f, 0.02477575f, 0.06719517f, -0.03290362f, 0.08200911f, -0.02142180f, 0.02989741f, 
    0.16006392f, -0.05099245f, -0.03427086f, 0.22437710f, 0.04877830f, 0.00844077f, 0.07780249f, 0.03699621f, 
    -0.01946869f, -0.17552640f, -0.10950480f, 0.05045850f, -0.08295974f, 0.29336232f, 0.17456596f, -0.06479613f, 
    0.10734459f, 0.02659450f, -0.09990413f, 0.07418457f, -0.16040170f, -0.09713402f, -0.03154594f, -0.13038883f, 
    -0.25434852f, -0.28131711f, -0.18801215f, -0.02691976f, -0.01650019f, -0.03957304f, -0.07443217f, -0.05529599f, 
    0.11983417f, 0.08600669f, -0.02773677f, 0.23302191f, -0.11781614f, -0.35942841f, -0.08264505f, -0.06886996f, 
    -0.11007706f, 0.04562347f, -0.01435933f, -0.04902161f, -0.05379430f, 0.11298611f, 0.01609316f, 0.15148799f, 
    -0.54156828f, -0.52342618f, -0.25243255f, -0.10838238f, 0.07392038f, 0.14221771f, -0.00476777f, 0.06753833f, 
    0.01059099f, 0.04254974f, 0.14733715f, 0.05599310f, -0.04453520f, 0.18610454f, 0.22949339f, 0.24332674f, 
    0.01188088f, 0.18519837f, 0.09202401f, -0.02703639f, 0.02865600f, -0.00951207f, -0.08074097f, -0.15647884f, 
    0.10293817f, 0.07244661f, 0.02356229f, 0.11496507f, 0.15824930f, 0.15005419f, 0.04102987f, 0.14026786f, 
    0.02236546f, 0.13233894f, -0.06504300f, -0.05289523f, 0.45184466f, 0.37795126f, 0.21668522f, 0.30408102f, 
    0.11060737f, -0.05507167f, -0.00413612f, 0.15599734f, -0.05252631f, 0.02709408f, -0.01224794f, -0.02446638f, 
    -0.00052982f, -0.11325622f, 0.01756696f, -0.16181143f, 0.08550494f, 0.10382681f, 0.10056257f, -0.03311775f, 
    -0.13726601f, 0.00471882f, 0.03507516f, -0.11676911f, -0.32558313f, -0.40673238f, -0.31437576f, -0.21010014f, 
    0.12726277f, 0.03706132f, 0.01447206f, -0.01965543f, -0.01642801f, 0.02196363f, 0.16063958f, 0.03540891f, 
    0.19448362f, 0.01798745f, 0.01690349f, 0.07380126f, 0.14590694f, -0.07394630f, -0.03360318f, 0.00389729f, 
    -0.00865310f, -0.05865311f, -0.08613358f, 0.04679315f, -0.24894671f, -0.14905010f, -0.15623049f, 0.03075529f, 
    0.04648807f, -0.07442823f, -0.02452305f, 0.12106635f, 0.06540766f, 0.01372736f, 0.02264573f, 0.03243202f, 
    0.34183219f, 0.46650851f, 0.23684163f, 0.00929909f, 0.14903928f, 0.15307321f, 0.17463580f, -0.03209455f, 
    -0.08914208f, -0.03392812f, 0.00339201f, -0.10999390f, 0.22165091f, 0.14028078f, 0.12834539f, 0.10551669f, 
    0.20932473f, 0.08351056f, 0.04353409f, 0.12343194f, -0.02891672f, -0.03168587f, 0.07658688f, -0.08619073f, 
    0.03319857f, 0.09141674f, 0.20964991f, 0.15297423f, -0.13528073f, -0.12316957f, -0.17660064f, -0.27503604f, 
    -0.11013045f, -0.15196793f, 0.00040565f, 0.06471792f, 0.12405774f, 0.04326538f, 0.03619097f, 0.11983978f, 
    0.04309032f, 0.02121543f, 0.05398532f, 0.05307487f, -0.02242526f, -0.06180717f, -0.00652396f, -0.09838104f, 
    -0.42474583f, -0.04391229f, 0.30112830f, -0.23982506f, -0.09063697f, 0.18337651f, 0.08632637f, -0.01514856f, 
    -0.09287769f, 0.00382910f, -0.10983706f, 0.02455198f, 0.19043019f, 0.12891200f, 0.16656442f, 0.18346262f, 
    0.08708145f, 0.03479777f, 0.05774035f, 0.03013834f, 0.07602331f, 0.09497898f, -0.10806319f, 0.05236178f, 
    0.54128671f, 0.18454711f, 0.12972355f, -0.06304595f, 0.18198735f, 0.07346661f, 0.14317955f, 0.11385734f, 
    -0.10011269f, 0.08497015f, 0.07385726f, -0.01343583f, -0.25072566f, -0.12525432f, -0.11564673f, -0.01480590f, 
    -0.08237599f, 0.05588047f, -0.03397827f, 0.01088794f, -0.17104173f, 0.03307251f, -0.05381882f, -0.11745031f, 
    -0.08154866f, -0.23217531f, -0.04383836f, 0.01108132f, -0.01318929f, 0.04467804f, 0.04121630f, -0.00653111f, 
    -0.14921540f, -0.18862186f, -0.02872888f, -0.12336739f, 0.22413957f, 0.30356121f, 0.05776479f, -0.08068608f, 
    0.18034549f, -0.10255842f, 0.10603910f, 0.19329424f, -0.01327209f, -0.04983243f, 0.01240069f, -0.02845850f, 
    -0.19313291f, -0.28215203f, -0.34847745f, 0.03432753f, 0.09264468f, 0.09524494f, 0.12355594f, 0.10643390f, 
    0.05641942f, 0.07089349f, 0.08674748f, -0.02206977f, 0.21006207f, 0.01348433f, 0.10013606f, -0.01640118f, 
    0.02331183f, -0.06104279f, -0.08245284f, -0.14905454f, -0.09886184f, -0.05658834f, -0.03486025f, 0.09356765f, 
    -0.01250227f, 0.06846263f, -0.15824968f, 0.09433263f, -0.00734590f, 0.03377966f, 0.06201454f, -0.05155820f, 
    -0.00399145f, -0.05981484f, 0.04085462f, 0.00175277f, 0.11824854f, 0.06293616f, 0.11245710f, 0.21873207f, 
    0.09313246f, -0.05381983f, 0.02290185f, 0.02031505f, 0.08642916f, 0.00464775f, 0.03638018f, 0.11986115f, 
    0.07008564f, 0.52376497f, -0.19562756f, -0.01853906f, 0.08310683f, -0.22328424f, 0.20531699f, -0.07861146f, 
    -0.13486955f, 0.10812368f, 0.05782016f, -0.03038961f, 0.09713374f, 0.01498768f, -0.06585422f, 0.11721338f, 
    0.04230039f, 0.17806838f, 0.03868724f, 0.09011674f, 0.05602853f, 0.06656747f, -0.00367479f, 0.06709263f, 
    -0.47448412f, -0.09733762f, -0.05697193f, -0.12894818f, -0.06884921f, 0.14940214f, -0.27134725f, -0.11311994f, 
    -0.18823990f, 0.00046027f, -0.07721858f, -0.03642289f, -0.12827654f, 0.47135088f, -0.37268028f, -0.08161817f, 
    -0.05286112f, 0.08757485f, 0.28028977f, 0.00191642f, -0.06382269f, 0.28915080f, 0.09158956f, 0.20678684f, 
    -0.16972040f, 0.09574740f, 0.11067677f, 0.10985491f, -0.13257270f, -0.01447048f, -0.07813552f, 0.08338276f, 
    -0.10482600f, -0.14688265f, -0.20893545f, -0.07631790f, 0.42741305f, 0.00738651f, -0.29633954f, 0.12989064f, 
    0.14394288f, 0.10442884f, 0.18085402f, 0.02300107f, -0.06078273f, 0.04060010f, 0.17333712f, -0.00175890f, 
    0.07305703f, -0.00796920f, 0.06084546f, 0.09244584f, -0.01828684f, 0.06253295f, 0.14191768f, -0.01570875f, 
    -0.02680332f, -0.17364238f, 0.13950461f, 0.00961265f, 0.42692035f, 0.20660782f, 0.05066732f, -0.07214394f, 
    0.01678545f, -0.06465551f, -0.12633176f, -0.12600280f, -0.11701492f, -0.09721407f, 0.11023573f, -0.11466576f, 
    -0.19937095f, -0.24307083f, 0.38060457f, -0.10152820f, -0.07045306f, -0.02184460f, -0.15391639f, 0.05689956f, 
    0.06108769f, 0.05506779f, 0.15172550f, 0.23547827f, -0.58020967f, 0.29527646f, 0.01919072f, 0.09648833f, 
    -0.04103151f, -0.13001354f, 0.08557407f, -0.11182768f, -0.00195521f, 0.14356235f, 0.04202350f, 0.12135235f, 
    0.34054530f, 0.07996818f, 0.55265379f, -0.07413657f, 0.07635111f, -0.08962298f, -0.39792815f, -0.04966533f, 
    -0.01807030f, 0.01535221f, -0.17510432f, 0.01752897f, 0.46032804f, 0.22413754f, -0.07671522f, -0.09693945f, 
    0.19973175f, -0.11362020f, 0.06203440f, 0.13583522f, -0.02273431f, 0.00465926f, 0.11973148f, 0.04387829f, 
    0.00344288f, 0.17521197f, 0.24130766f, 0.10860417f, -0.08157825f, 0.06317094f, 0.00493263f, 0.25091496f, 
    0.12991503f, -0.03489684f, -0.08917442f, 0.09890950f, 0.20920169f, -0.03842892f, -0.06400118f, 0.01218075f, 
    -0.14344870f, -0.04295886f, -0.05745254f, -0.06625722f, 0.05940288f, 0.05513374f, -0.02461881f, -0.26214713f, 
    -0.10576200f, -0.11225020f, -0.16011442f, -0.00255097f, 0.02343757f, 0.01321690f, 0.12288541f, 0.09460836f, 
    -0.03936838f, 0.09310780f, -0.37244678f, -0.07013761f, 0.16980428f, 0.22489445f, -0.06588498f, -0.24693288f, 
    0.00130940f, -0.00849874f, -0.07877863f, -0.02712571f, 0.03070500f, 0.02578591f, -0.15247306f, 0.06450862f, 
    0.15113539f, 0.27400458f, -0.16004089f, 0.02226816f, 0.05796644f, 0.05615032f, 0.06603014f, 0.01588034f, 
    0.07427236f, -0.13508883f, -0.02266575f, -0.03665994f, 0.01203724f, 0.44687936f, 0.42136794f, -0.06015509f, 
    -0.21371184f, -0.34524077f, -0.06813911f, -0.00530450f, -0.00888410f, 0.15798554f, 0.00086358f, -0.02040938f, 
    0.15249278f, 0.22319698f, -0.01867484f, -0.31492615f, 0.29037902f, 0.02860842f, 0.03447630f, -0.10610966f, 
    -0.00635322f, 0.05237596f, 0.06959054f, 0.16659175f, 0.06645183f, -0.12711336f, -0.16468140f, 0.00033317f, 
    0.03988601f, 0.16154587f, -0.08603709f, -0.05402922f, 0.04308607f, 0.04319243f, -0.01258976f, -0.07090035f, 
    0.00122453f, -0.17519003f, 0.09388413f, 0.13761635f, -0.10239299f, -0.04100532f, -0.07013861f, -0.02849269f, 
    0.02030070f, 0.11070477f, 0.15493509f, 0.17295547f, -0.01851288f, 0.27557382f, -0.09765916f, 0.12280414f, 
    -0.14604142f, -0.12933601f, 0.17008796f, -0.07320492f, -0.06998705f, 0.09001723f, -0.17961341f, -0.22682889f, 
    0.53100705f, 0.32120088f, -0.17542431f, -0.20653300f, 0.18989116f, 0.05099254f, -0.03774431f, 0.02826886f, 
    -0.13889563f, 0.06320926f, -0.06788604f, 0.17492522f, -0.03347170f, -0.32358372f, 0.22759001f, 0.25999966f, 
    0.08213354f, 0.29118639f, 0.13745494f, -0.13075504f, 0.12078408f, 0.01204418f, -0.03820958f, 0.17354672f, 
    0.41657951f, 0.01961231f, -0.28339645f, 0.08016539f, -0.00038509f, 0.21557140f, 0.24114729f, 0.04646270f, 
    -0.05704753f, 0.10384682f, -0.11388134f, 0.20552535f, -0.34641826f, -0.07947871f, 0.38733900f, -0.08746231f, 
    0.12085322f, 0.08746924f, -0.16241616f, -0.00827441f, -0.20851097f, -0.13415109f, 0.02523561f, -0.19331880f, 
    -0.22137903f, 0.02952446f, 0.07370679f, 0.09557639f, 0.07935416f, -0.04706670f, 0.21824302f, 0.02823741f, 
    -0.19470011f, -0.02330754f, -0.05422276f, 0.16208902f, 0.03532956f, 0.11414449f, -0.18535899f, 0.07189699f, 
    0.09230629f, -0.06081666f, -0.05018182f, -0.09604101f, -0.04376937f, -0.02924704f, -0.15599369f, -0.19065815f, 
    -0.11440236f, 0.14293255f, -0.06408559f, -0.06949378f, -0.01873369f, -0.12856358f, -0.20310971f, 0.04650078f, 
    -0.19383377f, 0.11558678f, -0.05128052f, -0.04756889f, -0.02415195f, 0.11352967f, 0.09002793f, 0.03179603f, 
    0.13134667f, 0.16952112f, -0.00994784f, 0.01214988f, 0.04333111f, 0.22361276f, 0.07679158f, -0.00500799f, 
    0.05465144f, -0.01723666f, 0.07362450f, 0.25656316f, 0.00839893f, 0.15589814f, -0.26622844f, -0.22493689f, 
    -0.05710838f, 0.12120771f, -0.18746503f, -0.10598746f, -0.61226940f, -0.18755542f, -0.24856453f, 0.34625512f, 
    -0.02150288f, 0.06638151f, 0.18090749f, -0.00073737f, -0.05405217f, 0.18138501f, 0.02729631f, -0.06438877f, 
    0.02649269f, -0.03130576f, 0.03566818f, 0.04018728f, -0.02924148f, -0.04619278f, 0.00139252f, -0.03053834f, 
    0.03748950f, 0.04362696f, -0.00386640f, 0.02830238f, -0.04028583f, 0.02530691f, 0.03239363f, -0.00182684f, 
    0.01734998f, 0.03100749f, -0.04002975f, 0.01724807f, 0.02479652f, 0.00597717f, -0.01727170f, 0.02027417f, 
    -0.02717749f, -0.04014804f, 0.04410652f, -0.00881071f, -0.00039299f, -0.05277752f, -0.03448085f, -0.04358327f, 
    0.02248248f, 0.01675815f, 0.00813861f, 0.04476478f, -0.02445208f, -0.05515461f, -0.02443317f, -0.01347383f, 
    0.02255334f, -0.05217375f, -0.00429246f, 0.00743981f, -0.04719308f, 0.00525691f, -0.04924137f, 0.00217615f, 
    -0.04115148f, 0.01743285f, -0.01643053f, -0.05321825f, -0.04041890f, 0.04209843f, -0.03429691f, -0.04737124f, 
    -0.04041319f, -0.02693546f, -0.01218302f, -0.05660513f, 0.02062076f, -0.00963285f, -0.01092660f, 0.02991235f, 
    -0.04310618f, -0.00520628f, 0.00154955f, 0.00466024f, 0.02937123f, -0.05150964f, -0.00267713f, 0.02101657f, 
    -0.00390374f, -0.00475359f, 0.00702757f, 0.02582197f, -0.03050383f, -0.05310113f, -0.03606147f, 0.02779732f, 
    -0.04116632f, 0.03009710f, 0.02399528f, -0.00422464f, -0.02231089f, 0.02642856f, -0.00878953f, -0.01594341f, 
    0.01645874f, -0.05101913f, 0.04050203f, 0.01203421f, -0.04633113f, 0.00600724f, -0.00126715f, 0.00575043f, 
    -0.04553860f, -0.04325048f, -0.03872522f, -0.01458111f, -0.04184065f, -0.02946311f, -0.02828505f, 0.02792673f, 
    -0.03753525f, -0.02585641f, 0.00951192f, 0.03852853f, -0.00027446f, -0.03873765f, 0.00896477f, -0.02153953f, 
    -0.03132200f, -0.04702206f, 0.00474422f, -0.01592595f, 0.00449827f, 0.04419558f, 0.03981315f, 0.03957595f, 
    0.03846096f, 0.02666514f, -0.01486954f, 0.00500685f, 0.02144169f, -0.04564418f, 0.02373166f, -0.02927114f, 
    -0.01976629f, 0.03368308f, -0.01379686f, -0.04485759f, -0.05172414f, -0.04132574f, -0.05454186f, 0.03466969f, 
    0.00617001f, -0.01940138f, 0.00348714f, -0.01394367f, 0.02111808f, 0.03588423f, -0.00435698f, -0.05140530f, 
    0.00118105f, -0.02353284f, -0.01523895f, 0.00507524f, -0.02858893f, -0.00762890f, -0.03719590f, 0.00547620f, 
    -0.04119003f, -0.03543777f, -0.04981814f, -0.00035440f, 0.00460005f, 0.03059114f, 0.00207556f, 0.02378730f, 
    -0.05487427f, -0.02809705f, -0.03027690f, 0.03148205f, -0.03936967f, -0.00067048f, 0.03508675f, 0.01571776f, 
    -0.02430118f, -0.02289145f, -0.04576533f, -0.03308675f, -0.04075751f, -0.01239600f, 0.04273040f, -0.02211275f, 
    0.02698636f, -0.00427862f, -0.04557286f, 0.01961865f, 0.02920980f, -0.02731915f, -0.00236380f, -0.03108435f, 
    -0.04226710f, 0.02197844f, 0.00730450f, 0.00487286f, -0.03962732f, 0.01744333f, -0.03113660f, -0.01945351f, 
    -0.02692829f, -0.05543726f, -0.04753608f, 0.00550470f, 0.03266818f, -0.00058994f, 0.02459891f, -0.05161855f, 
    -0.04719147f, -0.03830835f, -0.03752265f, -0.00535222f, -0.00715971f, 0.01850732f, -0.02082536f, -0.02992065f, 
    0.00008179f, -0.03512019f, 0.02186405f, -0.05688127f, 0.02278779f, -0.02494917f, 0.02190077f, -0.04304080f, 
    -0.03121067f, -0.03667106f, 0.00343831f, 0.04442055f, -0.01695549f, 0.02816997f, -0.02782185f, -0.05234480f, 
    0.03504653f, 0.00245027f, -0.04553746f, 0.01790583f, -0.01243405f, -0.02106314f, 0.02063535f, -0.03082437f, 
    -0.04003727f, 0.03546981f, -0.02591641f, -0.01056958f, 0.04480577f, 0.01777676f, -0.02589857f, -0.00926416f, 
    -0.02000288f, -0.05642900f, 0.00626596f, -0.01251299f, -0.02528215f, -0.04347191f, -0.05670874f, -0.04898619f, 
    0.02628752f, -0.05675844f, 0.02467846f, 0.03869699f, -0.00242770f, -0.02858477f, -0.04919308f, -0.03211295f, 
    -0.05123618f, -0.01165491f, -0.01040189f, -0.03499926f, 0.02157722f, 0.00025669f, 0.01260428f, -0.01926743f, 
    0.02600675f, 0.00449196f, 0.01619846f, -0.00054533f, -0.03619172f, -0.00967608f, 0.01321752f, 0.02480496f, 
    0.01340702f, -0.02334097f, -0.05495229f, -0.00879767f, -0.03429616f, -0.01160361f, -0.00614698f, 0.02001144f, 
    0.01575090f, -0.04027637f, 0.01269211f, -0.01726009f, -0.02490867f, -0.01428906f, -0.01746771f, 0.02691106f, 
    -0.05480694f, 0.04394069f, 0.00964196f, 0.04207383f, -0.01281890f, 0.03262144f, -0.04940845f, -0.02262197f, 
    -0.03464354f, -0.02042652f, 0.00269478f, -0.00170871f, -0.02574726f, 0.01188572f, -0.02171815f, 0.03024279f, 
    -0.00171154f, -0.01578424f, -0.03306621f, -0.02123413f, 0.04011081f, 0.00305143f, 0.01691027f, -0.01529613f, 
    0.02720526f, 0.01275963f, -0.03702802f, 0.03259747f, -0.04366069f, 0.02885810f, 0.03961489f, 0.02097500f, 
    -0.01334868f, 0.03978444f, 0.02569387f, 0.02060628f, -0.04453510f, 0.04448370f, -0.03447751f, 0.01518050f, 
    0.01036904f, -0.03518827f, 0.00024021f, -0.04917154f, -0.00367274f, 0.03683755f, -0.03748713f, -0.03953940f, 
    -0.04973821f, -0.00019685f, -0.00355985f, -0.04804557f, 0.01167434f, 0.03517318f, -0.03524819f, -0.03372994f, 
    0.04477752f, -0.00303126f, -0.03380493f, -0.01245070f, 0.03333431f, 0.00864085f, -0.00620811f, 0.04427858f, 
    -0.05242483f, 0.03746506f, -0.05541602f, 0.03844967f, -0.01133898f, 0.02629798f, 0.01638119f, -0.01194755f, 
    -0.01770956f, -0.04826596f, -0.03843344f, 0.03207820f, -0.02935482f, -0.00504411f, -0.01368579f, 0.03994260f, 
    -0.04454174f, 0.02589681f, 0.01756079f, 0.01611091f, -0.02802493f, 0.00671795f, -0.01666577f, 0.00968092f, 
    0.02041131f, -0.01873714f, -0.03772939f, -0.03423769f, 0.02091129f, -0.00687692f, 0.04295891f, 0.02000713f, 
    -0.02208961f, -0.02573973f, 0.03036478f, -0.04858097f, -0.03673660f, -0.04064791f, -0.05608163f, -0.05969021f, 
    -0.04988238f, -0.01588644f, 0.03714731f, 0.02919493f, 0.03459232f, 0.02817345f, -0.00915169f, -0.02402088f, 
    -0.05074339f, 0.04356284f, 0.03103997f, 0.01182814f, -0.01397218f, 0.01849453f, 0.02319021f, 0.00197893f, 
    0.00742465f, 0.03286141f, -0.02290187f, -0.00511181f, -0.00612298f, 0.04032141f, 0.01216824f, 0.03147140f, 
    0.00001036f, 0.02889659f, 0.03143878f, 0.03370691f, 0.01256775f, -0.04044314f, -0.01768658f, -0.03728467f, 
    0.00665791f, -0.05206564f, -0.04531902f, 0.01857540f, -0.00955422f, -0.03208622f, 0.00249821f, -0.02160510f, 
    0.00474044f, -0.02766798f, 0.02705994f, -0.05238193f, 0.00000920f, 0.02097414f, -0.04685225f, -0.01963956f, 
    0.04315336f, 0.02046857f, 0.01720233f, 0.03969531f, -0.01185937f, -0.00899462f, -0.01135216f, 0.03162686f, 
    0.03436171f, 0.02278459f, 0.03459569f, 0.02749587f, 0.03686430f, 0.02812992f, -0.02670630f, 0.02100892f, 
    0.01780716f, -0.02343151f, 0.03286137f, 0.02068490f, 0.00442236f, -0.04609182f, -0.03229303f, 0.03241110f, 
    -0.00429644f, -0.05390022f, -0.04015203f, 0.00391662f, 0.01953652f, 0.01862126f, -0.00018623f, -0.01051380f, 
    0.02868007f, 0.03255509f, 0.02378010f, -0.00814645f, -0.00734522f, 0.00284544f, -0.05840669f, 0.02080609f, 
    0.02190315f, 0.02396848f, -0.05406052f, -0.05570015f, -0.02420932f, -0.05546864f, -0.02450683f, -0.01956141f, 
    -0.05282441f, 0.03011883f, -0.04612749f, -0.03494523f, -0.02434979f, -0.03753155f, 0.00840531f, -0.05543679f, 
    0.02126910f, 0.00756871f, -0.00048054f, -0.03510080f, -0.05828141f, -0.00394212f, -0.05681011f, -0.04097522f, 
    0.01592551f, 0.03504518f, 0.01749782f, -0.02820690f, -0.05241488f, -0.04709855f, -0.02727133f, -0.04177620f, 
    -0.04005444f, -0.02897088f, -0.01413992f, -0.05178880f, -0.01683889f, -0.02120365f, 0.03747058f, -0.04843663f, 
    0.03800279f, 0.00563843f, 0.04338822f, 0.03685632f, -0.03279858f, -0.05493623f, -0.00578588f, -0.04592862f, 
    -0.03849320f, 0.01711554f, 0.02777516f, -0.06119367f, -0.05374475f, 0.00396413f, -0.00221263f, 0.00075234f, 
    0.02329205f, -0.00101774f, 0.03942655f, 0.01664139f, 0.03693495f, -0.00384494f, 0.01138152f, 0.04238305f, 
    -0.04628088f, 0.04087256f, -0.02983901f, -0.04484694f, 0.00902840f, -0.02936681f, 0.00118261f, -0.00042297f, 
    -0.05970586f, -0.05665820f, 0.02260168f, 0.00001888f, 0.03180989f, -0.00465889f, -0.06115134f, -0.03865394f, 
    -0.05522571f, 0.02476881f, 0.02518058f, -0.01523386f, -0.04235125f, -0.00099068f, 0.00421907f, 0.02663899f, 
    -0.02684055f, 0.01502078f, 0.01160107f, 0.02063202f, -0.03405075f, 0.00126765f, -0.03086989f, -0.03755699f, 
    0.00696438f, 0.00356694f, -0.02191915f, -0.02319586f, -0.03317374f, -0.02386547f, -0.03172515f, -0.00959738f, 
    0.01609576f, 0.04169242f, 0.02741777f, 0.00656473f, 0.03862852f, -0.04782644f, -0.04309963f, 0.02313466f, 
    -0.05163994f, -0.03688632f, -0.01288348f, 0.01439668f, -0.03726895f, -0.00877357f, -0.04257406f, 0.03763928f, 
    -0.01593516f, -0.04376679f, -0.01973601f, -0.02998248f, -0.01964732f, -0.05169021f, -0.03771457f, -0.01599295f, 
    -0.04692923f, -0.00583436f, 0.01218481f, -0.04745588f, 0.01876915f, 0.01599368f, 0.01344025f, -0.00814521f, 
    -0.03879143f, -0.01860405f, 0.02249999f, -0.01940105f, 0.01976898f, 0.03888596f, -0.05946976f, 0.03307955f, 
    -0.01904446f, -0.03710826f, 0.00860315f, -0.02497106f, 0.00816102f, -0.01118309f, -0.01751867f, -0.01518703f, 
    -0.02497882f, 0.02054696f, 0.03637548f, 0.03720826f, -0.04511899f, 0.03595769f, -0.04342602f, 0.01416605f, 
    0.00021421f, 0.03438991f, -0.04555009f, -0.00687185f, -0.03074370f, -0.04646379f, 0.00655481f, -0.02132410f, 
    -0.01002840f, -0.02173790f, -0.04524239f, -0.02857007f, -0.01759887f, -0.01255189f, -0.02240309f, 0.00087418f, 
    0.03559732f, 0.03048292f, -0.04166561f, 0.00370272f, -0.00757410f, -0.04893719f, -0.03913054f, 0.01960834f, 
    0.00889471f, 0.02237729f, -0.01244504f, 0.03376661f, 0.01118601f, -0.05784437f, -0.05227948f, -0.04116666f, 
    0.03280171f, -0.01188435f, -0.01712502f, -0.02776798f, 0.00049077f, 0.04038053f, -0.05905601f, 0.00085504f, 
    -0.00805106f, 0.01075413f, 0.03005781f, -0.01264635f, -0.05701084f, 0.02018115f, -0.02634112f, -0.02326960f, 
    -0.01266879f, 0.00383400f, -0.02994139f, -0.05270464f, 0.01521361f, 0.00423948f, 0.02690733f, -0.05706861f, 
    -0.05990499f, 0.03523387f, 0.02969991f, -0.01872552f, 0.02600312f, -0.03322739f, -0.04652280f, 0.02361123f, 
    -0.00228691f, -0.02246632f, -0.05086927f, -0.00562477f, -0.02557644f, 0.02455537f, 0.02905260f, -0.00064507f, 
    0.01244047f, 0.02142540f, 0.01399698f, 0.02584761f, -0.01397923f, -0.05432667f, -0.02242708f, -0.03956967f, 
    -0.00409645f, -0.02742036f, 0.02695822f, -0.03962644f, -0.00954221f, -0.01706124f, 0.00717263f, 0.03379257f, 
    -0.01546110f, -0.02138044f, -0.04059986f, -0.00225749f, -0.04029700f, -0.03861619f, 0.01365284f, -0.04892239f, 
    0.02252242f, 0.01472074f, -0.05740336f, 0.02333772f, -0.01399327f, 0.02902167f, -0.04903481f, 0.01444176f, 
    0.01170273f, -0.00372827f, -0.02333553f, -0.01416650f, 0.02837999f, 0.04019175f, -0.05049890f, 0.01458208f, 
    -0.03715423f, -0.03003501f, 0.02899340f, 0.03232106f, -0.03521618f, -0.00052542f, -0.00650749f, 0.01281256f, 
    -0.01140229f, -0.00673319f, -0.03899127f, -0.02460416f, -0.00014470f, 0.02161698f, -0.02165723f, 0.01097476f, 
    0.38995412f, -0.71884155f, 0.24937089f, -0.25124991f, -0.04302851f, 0.22768266f, -0.06336184f, 0.01215657f, 
    -0.08476338f, 0.05558779f, -0.02951468f, -0.00846127f, 0.06632037f, 0.19079661f, 0.03348815f, -0.04008759f, 
    0.00205997f, 0.04598199f, 0.11544384f, 0.19671461f, 0.10272422f, -0.00837522f, -0.03959423f, 0.01586531f, 
    -0.00917873f, -0.08188304f, 0.04439271f, -0.06293346f, -0.01037881f, 0.11440887f, 0.07610366f, 0.11253424f, 
    0.19204992f, -0.12588528f, 0.00951866f, 0.08035035f, 0.13678533f, -0.19902985f, 0.25204447f, 0.07353430f, 
    0.00421850f, -0.01847330f, -0.07267083f, -0.05171737f, 0.07183842f, -0.05897165f, 0.13987622f, 0.01515832f, 
    -0.15740359f, 0.23884882f, -0.19515014f, 0.05736186f, -0.04888518f, 0.11501873f, -0.01585742f, 0.14613941f, 
    -0.01967789f, 0.09576774f, -0.01631800f, -0.09713586f, -0.15667006f, -0.01590798f, 0.03151165f, 0.23857263f, 
    0.18414539f, -0.29021913f, -0.09623785f, 0.01211354f, 0.06291938f, 0.03745499f, 0.09362861f, 0.06301007f, 
    0.16672146f, -0.03783823f, -0.10590173f, -0.15849781f, -0.00295590f, -0.02555977f, 0.11257468f, 0.15093982f, 
    -0.07834503f, 0.03467255f, 0.04242219f, 0.04047843f, 0.11169918f, -0.05477408f, 0.29665983f, -0.03538210f, 
    0.14614756f, 0.00512462f, 0.05430370f, -0.06158371f, 0.03368915f, 0.02377970f, 0.04229092f, 0.06163239f, 
    -0.18529317f, 0.13362050f, -0.05566237f, 0.25086939f, 0.05234451f, 0.00331491f, 0.15538131f, -0.16809398f, 
    0.10421175f, 0.06436212f, 0.00828815f, 0.09774785f, 0.38600239f, -0.40604624f, 0.03367575f, -0.17959598f, 
    0.06175381f, 0.15787111f, 0.01424820f, 0.00477841f, -0.05227508f, -0.06628010f, 0.03219581f, -0.06016858f, 
    -0.03192140f, -0.12641880f, -0.27532327f, 0.07014221f, 0.15277566f, 0.02234602f, 0.01117286f, -0.07360344f, 
    0.09595256f, -0.04143952f, 0.08787949f, 0.00333839f, -0.17871757f, 0.23090091f, -0.03090932f, 0.20716082f, 
    0.03423244f, 0.10969294f, 0.01402594f, -0.11061772f, 0.05987652f, -0.08034612f, -0.09770744f, -0.04880581f, 
    0.17105256f, 0.24033217f, -0.14374866f, 0.00488998f, 0.14233327f, 0.02216893f, 0.01455855f, 0.16580805f, 
    -0.06322715f, 0.10625757f, 0.08373638f, -0.06566618f, 0.32158485f, 0.11791594f, 0.22611046f, -0.22172946f, 
    0.18489049f, -0.11069956f, 0.19028376f, 0.05067387f, -0.05910330f, -0.05381328f, 0.03504801f, -0.02081128f, 
    0.24694136f, -0.23127189f, 0.22320984f, -0.07858430f, 0.12703493f, 0.11626789f, 0.02338084f, -0.12299845f, 
    0.13002881f, -0.14555694f, -0.02291397f, -0.05968795f, 0.01869018f, 0.05758334f, -0.00163189f, 0.06307636f, 
    0.06580023f, 0.00624195f, 0.07532539f, -0.18696462f, 0.09577709f, 0.02610430f, -0.07846953f, -0.00942731f, 
    0.34851953f, -0.04158133f, 0.09197977f, -0.15383194f, 0.00344171f, -0.06156895f, -0.06560688f, 0.17865463f, 
    0.11513510f, 0.00246505f, 0.03221587f, -0.02021318f, 0.20918731f, -0.02961283f, -0.14015159f, 0.07489660f, 
    0.18395500f, 0.08364339f, -0.02537334f, 0.05829127f, -0.02766338f, -0.00481079f, 0.14348358f, -0.05436805f, 
    0.64201063f, -0.19710433f, 0.07725172f, 0.23923281f, 0.05952642f, 0.08302157f, -0.02143097f, 0.04545585f, 
    0.09848888f, -0.01787235f, 0.02847105f, 0.00951408f, 0.02441941f, 0.35901412f, -0.04013313f, 0.04517949f, 
    0.05750323f, -0.12746145f, 0.04856765f, 0.14037931f, -0.05201909f, 0.06017621f, 0.01747538f, -0.10220027f, 
    0.03362124f, 0.06254079f, -0.04283329f, 0.06447349f, 0.06038720f, -0.04242084f, -0.07612076f, 0.03084152f, 
    -0.04339124f, -0.12218974f, 0.00780474f, -0.00181582f, 0.17074747f, -0.08699760f, 0.00965302f, -0.15742289f, 
    0.03329568f, 0.08229303f, -0.01452075f, -0.05278819f, -0.02462117f, -0.04558123f, -0.08275485f, -0.01626645f, 
    -0.19038691f, -0.00044728f, 0.08365500f, 0.40598047f, 0.18406634f, 0.10654347f, 0.00742409f, -0.14432521f, 
    0.05671067f, -0.09625065f, -0.04362795f, -0.06452569f, 0.16310731f, 0.11430911f, -0.12695296f, -0.15036799f, 
    -0.12295721f, -0.10435612f, -0.15238285f, -0.03881583f, 0.08429874f, -0.03351528f, 0.16192876f, 0.06201497f, 
    0.13078298f, -0.08692364f, -0.16389458f, -0.29210800f, -0.03072060f, -0.07454047f, -0.15134194f, -0.02283261f, 
    0.07697450f, 0.04882411f, 0.15708156f, 0.09586861f, -0.04375544f, -0.13925014f, 0.02516842f, -0.12382835f, 
    -0.00597243f, -0.13359730f, 0.07140664f, -0.02296842f, -0.17332569f, 0.05607431f, -0.01626864f, -0.07015400f, 
    0.08320016f, -0.07385308f, 0.15387395f, -0.20227310f, -0.10062911f, 0.17450604f, -0.15083343f, -0.09442776f, 
    0.16376247f, 0.04682126f, 0.06370690f, -0.12445002f, 0.15188357f, 0.28770012f, 0.01193915f, -0.32257167f, 
    -0.09000350f, 0.06583118f, -0.05906621f, 0.18656161f, 0.02433450f, -0.06238757f, 0.00263905f, -0.05124058f, 
    0.01167918f, -0.02126287f, 0.06068174f, 0.09170435f, 0.05881080f, 0.00733037f, 0.02661602f, -0.00865226f, 
    -0.04993261f, -0.07082384f, -0.03459778f, -0.07953801f, -0.21164940f, 0.02168814f, 0.01012484f, -0.30948642f, 
    0.04702890f, -0.01765988f, 0.10201930f, 0.05578959f, -0.02609301f, 0.05960336f, 0.11371895f, 0.03499999f, 
    -0.09415694f, -0.15611479f, 0.03448141f, 0.04242855f, 0.16760039f, -0.20921564f, -0.07591950f, -0.15895692f, 
    0.07713879f, -0.10091303f, -0.02887156f, -0.12877762f, -0.25858122f, 0.06251674f, 0.37764603f, -0.51855719f, 
    0.00029150f, -0.24480926f, -0.05038194f, -0.03002952f, -0.09239797f, -0.05589987f, 0.18966320f, 0.03277639f, 
    -0.30953258f, -0.23359208f, 0.03353026f, 0.10544100f, 0.11979666f, -0.09298556f, 0.03083413f, 0.12237348f, 
    0.08296718f, 0.16267526f, -0.00772443f, -0.08880164f, -0.18827635f, 0.03945948f, 0.06680854f, 0.14667808f, 
    -0.26234591f, -0.02108877f, -0.02000005f, -0.12504253f, 0.09567618f, 0.13680436f, 0.00598093f, 0.06893535f, 
    -0.10070811f, -0.02623747f, 0.02959108f, -0.18835089f, 0.03975457f, -0.09064015f, 0.03484492f, 0.10176216f, 
    -0.04438367f, -0.03023922f, -0.12667575f, -0.05533894f, -0.02033202f, -0.13364984f, -0.15147673f, -0.10488703f, 
    0.08736401f, -0.02700151f, -0.02611242f, 0.11589640f, 0.23469251f, 0.24094552f, -0.01599653f, -0.09411345f, 
    0.22409652f, 0.20115703f, -0.11540656f, -0.01022169f, 0.15027221f, 0.21814941f, -0.05992346f, -0.05087155f, 
    -0.01383440f, 0.07712749f, -0.28024018f, 0.01999406f, 0.01763511f, -0.15201004f, -0.12501071f, 0.08429826f, 
    -0.01632839f, 0.15816350f, 0.00031727f, 0.08930533f, 0.09427341f, 0.11912467f, 0.20020448f, 0.09262655f, 
    -0.30580732f, 0.25425577f, 0.58707547f, -0.07679846f, -0.02600668f, 0.01722436f, -0.15775627f, 0.00679019f, 
    0.14126439f, -0.00237159f, 0.16213435f, -0.01348051f, -0.16328204f, -0.07956955f, -0.14090382f, 0.40695694f, 
    -0.09104928f, 0.10192539f, -0.05256759f, 0.13737191f, -0.02552534f, 0.09405216f, -0.01832014f, -0.09862981f, 
    0.24614424f, -0.08680563f, 0.00101478f, -0.10927355f, 0.05606667f, -0.02340226f, -0.04002847f, 0.06358764f, 
    0.06143943f, -0.12944572f, 0.10299239f, 0.08339263f, 0.22433096f, 0.17682807f, 0.11016074f, -0.38283646f, 
    -0.06110900f, -0.10185154f, 0.07870337f, 0.00660653f, -0.00060654f, -0.01286357f, 0.08147451f, 0.05449607f, 
    0.11653616f, -0.02752909f, 0.07712032f, -0.12175166f, -0.11599172f, 0.04270966f, 0.07937341f, -0.00144522f, 
    -0.04503084f, -0.02951135f, -0.07290497f, 0.00854329f, 0.06897447f, -0.07820297f, -0.16370399f, 0.30242527f, 
    0.08504844f, -0.22091702f, -0.10816617f, 0.08826526f, -0.02881091f, 0.08031226f, -0.11399757f, 0.11802272f, 
    -0.13290316f, 0.13074189f, 0.04955058f, -0.38345709f, 0.00045361f, -0.27705678f, -0.22655568f, 0.10501686f, 
    -0.01107089f, -0.03772178f, 0.03805596f, 0.07231962f, -0.22586858f, -0.11736264f, 0.29453894f, 0.07580803f, 
    -0.20108576f, -0.00248568f, -0.14302765f, -0.06283412f, 0.01727933f, 0.02819541f, 0.03467053f, -0.05374541f, 
    -0.05920414f, -0.04765735f, -0.33524010f, 0.02605264f, 0.03977828f, -0.05306381f, 0.08030091f, 0.04546700f, 
    0.04346094f, -0.27060589f, -0.11923295f, -0.04241429f, 0.26043454f, 0.06217198f, -0.27507100f, -0.06962491f, 
    -0.05163188f, -0.05905262f, 0.03468692f, 0.09777527f, -0.02758985f, -0.06216227f, -0.04441159f, -0.08716411f, 
    -0.06316139f, -0.14447653f, 0.32345375f, 0.17778909f, -0.07779818f, 0.03304065f, 0.15517792f, -0.02131682f, 
    0.06407183f, -0.00420859f, -0.03933689f, -0.10613748f, -0.05446248f, 0.14037229f, -0.04531420f, -0.44592986f, 
    0.02358028f, -0.05303716f, 0.23962174f, -0.03477465f, -0.00769321f, -0.03417515f, -0.01864572f, -0.02749742f, 
    -0.21915333f, -0.41564423f, -0.00085554f, 0.35590118f, -0.10533404f, -0.11884134f, 0.22586167f, 0.05079165f, 
    -0.00093087f, -0.09849624f, 0.14839008f, -0.01299803f, -0.00685458f, -0.06157681f, 0.16938332f, 0.03297709f, 
    -0.01655075f, 0.06319170f, -0.19497854f, -0.28386980f, 0.04665440f, 0.10529118f, 0.07125533f, 0.02495290f, 
    -0.19264562f, 0.06721010f, 0.21037269f, -0.06030694f, -0.02335402f, -0.01822178f, 0.18705894f, 0.02879433f, 
    -0.02613952f, 0.07240362f, 0.12140133f, 0.07567773f, 0.05935358f, -0.00661760f, 0.01990724f, -0.05538342f, 
    -0.05076239f, 0.12562561f, 0.16258234f, 0.14014776f, -0.08878195f, 0.07208548f, -0.12374445f, 0.02869983f, 
    -0.06126842f, -0.07007410f, -0.29160684f, 0.19041307f, 0.15380986f, 0.14918360f, -0.05629580f, 0.02806970f, 
    0.05765114f, 0.02405360f, 0.11899456f, 0.05338837f, -0.03661824f, 0.03847279f, 0.34321961f, 0.16999394f, 
    -0.01712502f, -0.09502646f, 0.11300767f, -0.22566070f, 0.05190773f, -0.04112472f, 0.10954085f, 0.22237720f, 
    0.02214237f, 0.70402527f, 0.16932872f, 0.14122587f, -0.06815118f, -0.17066547f, 0.21952711f, -0.16500546f, 
    0.09224851f, 0.01695455f, -0.12080143f, -0.08644986f, 0.04032283f, 0.15077728f, 0.54640782f, -0.17704374f, 
    0.00184094f, 0.01169520f, -0.06466038f, 0.18238199f, 0.00566170f, -0.15143083f, -0.03370064f, -0.07135379f, 
    -0.03339323f, 0.08444628f, 0.08108370f, -0.13359271f, 0.06474298f, 0.03607948f, 0.03679151f, 0.01280307f, 
    -0.27382779f, 0.15092301f, -0.14547017f, 0.18467620f, 0.07302658f, 0.04178141f, 0.05113247f, 0.06597000f, 
    -0.00745768f, -0.00495889f, 0.00365392f, -0.25118834f, 0.05136194f, 0.05664276f, -0.01466353f, -0.05192640f, 
    -0.01340611f, -0.11785710f, -0.17574599f, -0.20887801f, 0.01041650f, -0.03129391f, 0.00223271f, 0.05733844f, 
    -0.04347168f, 0.01805567f, -0.15564632f, -0.07154151f, -0.07946903f, 0.47810313f, -0.02215290f, -0.03489714f, 
    -0.00595991f, 0.14762136f, 0.00835309f, 0.01564923f, -0.11744969f, 0.04819640f, -0.04566484f, -0.06534544f, 
    0.27829608f, -0.19844086f, 0.01862186f, -0.00526063f, -0.02271070f, 0.15822184f, -0.11206803f, -0.01550128f, 
    0.02723648f, -0.01431882f, -0.10592999f, 0.03781629f, 0.02516560f, 0.14048116f, 0.01456237f, -0.02340050f, 
    -0.03512664f, -0.00619513f, 0.00266449f, -0.09970524f, 0.05493279f, 0.21268317f, -0.16794994f, 0.17356835f, 
    0.10065939f, 0.24549735f, -0.13749875f, -0.20902458f, 0.03881818f, 0.07529362f, -0.14019623f, 0.04618443f, 
    -0.01742240f, -0.08741458f, -0.09629715f, 0.01438033f, -0.14660276f, -0.00553230f, 0.01960175f, 0.20344968f, 
    0.13641907f, -0.07170498f, -0.03011828f, 0.04778662f, 0.15333275f, 0.02942252f, 0.21791193f, 0.15156756f, 
    0.02438489f, 0.04227186f, -0.16262092f, 0.14237247f, 0.04220790f, 0.08567135f, 0.06179212f, -0.08689857f, 
    0.07156725f, 0.00037636f, -0.05302570f, 0.05621883f, 0.10791398f, 0.00598447f, 0.13297532f, -0.09559065f, 
    -0.00298477f, -0.02039943f, -0.13118745f, -0.02765549f, 0.04763081f, 0.08844405f, -0.12742472f, 0.15129437f, 
    -0.16223055f, 0.25990993f, -0.20545328f, 0.23343489f, 0.06205171f, 0.05041637f, 0.09149329f, 0.03451663f, 
    -0.06751877f, 0.11241736f, 0.09606256f, 0.01936821f, 0.00318489f, 0.01517714f, 0.06103805f, -0.26839870f, 
    -0.05234719f, 0.05595399f, -0.19794448f, 0.04869356f, -0.00935600f, -0.01470820f, -0.08974896f, 0.04491454f, 
    -0.21075611f, -0.01790381f, 0.12662239f, 0.19367565f, 0.06101459f, 0.02603425f, -0.06213801f, 0.14556003f, 
    0.10059306f, -0.00585090f, 0.07172931f, 0.03217106f, -0.19803558f, -0.07181965f, 0.20819488f, 0.07834364f, 
    -0.09590288f, 0.14158340f, 0.00361961f, -0.03475695f, -0.15929143f, 0.03787172f, -0.07751936f, -0.10078747f, 
    0.00173936f, 0.08463668f, -0.29571363f, 0.04550732f, -0.06889362f, -0.02678242f, -0.03100781f, -0.22912674f, 
    0.18262334f, 0.10153676f, 0.01164443f, 0.10883775f, -0.29413593f, -0.09125560f, -0.12777531f, -0.13197559f, 
    0.07940492f, -0.11416240f, 0.01771211f, 0.01344783f, -0.04005399f, 0.12593962f, -0.00541286f, -0.17659742f, 
    -0.15448654f, -0.37405932f, -0.30518982f, 0.06846169f, -0.06000569f, 0.12841003f, -0.04899083f, -0.01862513f, 
    0.04147634f, -0.02277290f, 0.18300030f, -0.02368754f, 0.04019956f, 0.22885972f, 0.30323225f, 0.21490414f, 
    -0.13411856f, 0.19920559f, 0.17338388f, 0.14394678f, 0.00864759f, -0.00851315f, -0.22377744f, -0.08654264f, 
    0.34548706f, 0.20211037f, 0.36703545f, 0.48273036f, 0.11466126f, 0.12211871f, 0.09195042f, 0.11581776f, 
    0.09469256f, 0.09959207f, -0.15072000f, -0.20904712f, 0.25489724f, 0.19867577f, 0.21502109f, 0.25361073f, 
    0.25959805f, 0.03870158f, 0.14939767f, 0.17493679f, 0.07114124f, 0.05359184f, 0.02741613f, -0.00268253f, 
    0.08649233f, -0.04257901f, 0.05844703f, -0.14264953f, -0.02315922f, -0.12147620f, -0.15501387f, -0.34899282f, 
    -0.15409636f, -0.02974662f, 0.07499147f, -0.00367935f, -0.15940870f, -0.26426449f, -0.05711366f, 0.03812759f, 
    0.02288251f, 0.06032408f, -0.13581319f, -0.18857613f, -0.01916419f, -0.17949358f, 0.10158522f, 0.05016857f, 
    0.02724454f, -0.03049913f, 0.23131619f, 0.03542621f, 0.07269234f, -0.05707160f, -0.30246601f, 0.12696916f, 
    -0.19108249f, 0.06754027f, -0.03298265f, -0.02847072f, 0.39602891f, -0.03308994f, 0.04329563f, 0.41387826f, 
    0.08266959f, 0.06875040f, -0.06047301f, 0.27237982f, 0.07693453f, -0.09520739f, -0.03097923f, -0.11737929f, 
    0.06055070f, 0.33078101f, 0.05921026f, 0.08817313f, 0.12657376f, 0.02465553f, 0.00441690f, -0.10937848f, 
    0.07968035f, -0.04751818f, -0.07838445f, 0.19349368f, 0.27181309f, 0.37603810f, 0.25938120f, 0.40655917f, 
    0.15350951f, 0.02170809f, 0.12561274f, 0.26567766f, 0.01709807f, 0.00537605f, 0.02134568f, 0.02304148f, 
    0.04618950f, 0.07269984f, -0.01727385f, 0.24832724f, -0.00517189f, 0.04090725f, 0.03980837f, -0.03714716f, 
    0.02526499f, -0.13604103f, 0.01710353f, -0.00836689f, -0.06997198f, -0.19976655f, 0.09674045f, -0.00888052f, 
    -0.04254477f, -0.08839676f, -0.15826640f, 0.14056282f, 0.08328854f, -0.08000705f, -0.09694596f, -0.14940853f, 
    -0.01166553f, -0.15266906f, 0.45817402f, 0.10414723f, -0.03580923f, -0.04460717f, -0.02446307f, 0.01329725f, 
    -0.15216297f, -0.19656199f, 0.01439076f, -0.14263496f, 0.27381843f, 0.12183171f, -0.06003744f, 0.15821025f, 
    0.01858140f, -0.11828444f, -0.02153713f, 0.03776189f, -0.02938353f, -0.05842825f, -0.11703227f, 0.13175574f, 
    0.21418065f, 0.12268323f, 0.14742963f, -0.08965714f, 0.16710098f, -0.09044500f, 0.08488254f, 0.12349920f, 
    -0.16771339f, -0.03362659f, -0.02849357f, 0.06011828f, -0.00158753f, -0.12492263f, -0.35277557f, 0.40732965f, 
    -0.06856090f, 0.08519803f, -0.12762001f, -0.08031420f, 0.04704968f, -0.10564823f, -0.12656167f, -0.09328546f, 
    -0.19838138f, -0.17235412f, -0.21484278f, -0.21888451f, 0.04689528f, 0.00788020f, -0.05727518f, -0.02915867f, 
    -0.10801595f, -0.07281646f, -0.08817711f, -0.03901524f, -0.00413538f, 0.26154676f, 0.26764604f, 0.28383628f, 
    0.10910127f, 0.08314633f, -0.01820303f, 0.22615908f, -0.05586429f, 0.06187560f, 0.04114114f, -0.02562079f, 
    -0.18033506f, -0.23606507f, -0.02362110f, 0.22517873f, 0.17892036f, -0.06037037f, -0.06155320f, 0.10527074f, 
    0.07082438f, -0.08412306f, -0.02037659f, -0.12510973f, 0.07531761f, -0.07410141f, -0.01671326f, 0.19072062f, 
    -0.04582287f, -0.09575897f, -0.06588127f, -0.04688590f, -0.01001478f, -0.12291786f, -0.03546533f, 0.06948660f, 
    -0.14940615f, 0.00618917f, 0.14130048f, -0.07804720f, 0.03319636f, 0.13063402f, -0.07182511f, 0.06524633f, 
    0.00609203f, -0.20100741f, 0.17331609f, -0.19736615f, -0.30712697f, -0.13483402f, 0.08363352f, 0.04383177f, 
    0.09100627f, -0.03933215f, -0.21805942f, 0.08590669f, 0.08507172f, -0.07475800f, -0.17791155f, -0.15311123f, 
    0.31965038f, -0.63477051f, 0.07351331f, -0.24402462f, -0.14596799f, 0.10445607f, -0.12467041f, 0.01931264f, 
    0.07831761f, 0.11910996f, 0.01269109f, 0.06230474f, 0.09883472f, 0.17570108f, -0.08170126f, -0.12955803f, 
    -0.01230431f, 0.10669142f, 0.10006607f, 0.10197755f, -0.01233960f, -0.01891465f, 0.09279490f, 0.07819404f, 
    -0.05174227f, -0.17084974f, 0.04032016f, 0.02784915f, -0.00530033f, -0.01017867f, 0.03024878f, 0.13100100f, 
    0.10967399f, -0.25754806f, -0.03840407f, -0.05193858f, 0.21507120f, -0.26407751f, 0.30211428f, 0.03119742f, 
    -0.13352816f, -0.09856191f, -0.05857909f, 0.05328406f, 0.11439929f, -0.02426450f, 0.13505727f, 0.10269672f, 
    0.02585971f, 0.18132615f, -0.18352266f, 0.09359671f, 0.07164751f, 0.06007525f, 0.08048709f, 0.14712329f, 
    -0.11397590f, 0.14902191f, 0.04227677f, -0.08254474f, -0.07938752f, -0.00890767f, -0.00261551f, 0.09565440f, 
    0.12557399f, -0.03262397f, -0.02503950f, 0.05146321f, 0.16408999f, 0.00052917f, 0.06401391f, 0.12313361f, 
    0.01240573f, -0.03174465f, -0.04949428f, -0.23947033f, -0.11304860f, 0.01869832f, 0.15529281f, 0.17179909f, 
    0.02362852f, 0.01898548f, 0.07801062f, 0.09707637f, 0.02452118f, -0.04005386f, 0.30034366f, -0.14755875f, 
    0.11570027f, 0.11542771f, -0.07084893f, 0.03807845f, 0.04980566f, 0.09922036f, -0.05965889f, -0.01548349f, 
    -0.19408014f, 0.11398793f, -0.13321617f, 0.26730657f, -0.02017255f, 0.01699417f, 0.24917185f, -0.08692603f, 
    0.12119647f, -0.02642136f, -0.00025585f, 0.06263655f, 0.29548880f, -0.29344955f, -0.04285307f, -0.13833043f, 
    0.03423600f, 0.12924798f, 0.04038557f, 0.05658812f, -0.00144114f, 0.02213388f, 0.00068368f, -0.01972654f, 
    -0.04795932f, -0.13434468f, -0.26251870f, 0.01925998f, 0.03880841f, 0.06497215f, 0.13951351f, 0.00863159f, 
    -0.03475092f, -0.15120104f, 0.09445611f, -0.04079422f, -0.28403983f, 0.09356438f, -0.05139183f, 0.29031703f, 
    0.13360085f, 0.15318084f, 0.05101958f, -0.20280033f, -0.02678572f, -0.02061088f, -0.15355772f, -0.09628981f, 
    0.02001752f, 0.11134829f, -0.12009086f, 0.06409170f, 0.15545323f, 0.07233355f, 0.12274627f, 0.12453299f, 
    -0.05502934f, 0.09670449f, -0.06370541f, -0.08245581f, 0.23251647f, 0.16069007f, 0.15519327f, -0.20554845f, 
    0.18942793f, -0.07704028f, 0.09568397f, -0.02176311f, -0.24197818f, -0.06315794f, -0.03788345f, -0.06757098f, 
    0.16452008f, -0.27080667f, 0.22733611f, -0.14955264f, 0.03667676f, 0.10050128f, -0.22641255f, -0.07319245f, 
    0.00448461f, -0.15011443f, 0.07978711f, -0.05983258f, -0.05690366f, -0.00959738f, -0.08202133f, 0.08269629f, 
    -0.02005130f, 0.01362452f, 0.15948398f, -0.09647327f, -0.01041358f, -0.13277243f, 0.07347966f, -0.04720189f, 
    0.34128630f, -0.04866287f, 0.13436759f, -0.21159755f, 0.05550469f, -0.01967921f, -0.04211645f, 0.17509824f, 
    0.03115591f, 0.07170593f, 0.01602536f, -0.08872312f, 0.18471307f, -0.00677722f, -0.06757865f, 0.18799740f, 
    0.22704017f, 0.15535201f, -0.04424782f, 0.08075631f, -0.03678207f, -0.03302974f, 0.00009731f, -0.15954295f, 
    0.52603024f, -0.20808235f, 0.06432314f, 0.16735798f, -0.08286491f, 0.05589799f, -0.07957608f, 0.02903103f, 
    0.10700281f, -0.07198319f, -0.03572838f, -0.16720781f, 0.07334244f, 0.21454258f, 0.00369165f, 0.01591182f, 
    0.14796005f, -0.03302576f, 0.10150039f, 0.11670670f, 0.00013094f, 0.08374987f, 0.11871395f, 0.00891269f, 
    0.06324149f, 0.10078754f, -0.03066357f, -0.01258771f, 0.09067219f, 0.05977356f, 0.02689907f, 0.09350496f, 
    0.01413885f, 0.01449703f, 0.11366951f, 0.10422070f, 0.12313488f, -0.13154002f, -0.11886437f, -0.15584560f, 
    0.04420262f, -0.02548761f, 0.03989693f, -0.11313837f, -0.01530708f, -0.09606561f, -0.19392797f, -0.07611836f, 
    -0.14157207f, -0.00983424f, 0.25889277f, 0.35346907f, 0.05264007f, 0.13264386f, -0.01767752f, -0.07284568f, 
    0.08729349f, -0.00715018f, 0.03307603f, -0.11752283f, 0.32062668f, 0.13235077f, -0.17554222f, -0.14224102f, 
    -0.05380322f, 0.05133566f, -0.07533505f, 0.01539768f, 0.08465877f, -0.15661980f, 0.05961254f, 0.02442232f, 
    0.00855714f, -0.06698472f, -0.01809527f, -0.13584451f, -0.03381009f, -0.08707689f, -0.01130045f, 0.04254565f, 
    0.01057335f, 0.01589740f, 0.04058561f, -0.08986401f, 0.07147561f, 0.03825010f, -0.17039981f, -0.11676284f, 
    -0.00422272f, -0.08069137f, 0.13980380f, 0.01896558f, -0.10487125f, 0.03991911f, 0.02852019f, -0.01024452f, 
    0.00244793f, -0.17739411f, 0.13355711f, -0.36320594f, -0.08461215f, 0.09481506f, -0.10954054f, -0.07987590f, 
    0.10411215f, -0.05496660f, 0.02096094f, -0.12300629f, 0.17296228f, 0.16006427f, -0.07137661f, -0.32575417f, 
    0.04282192f, 0.06983809f, -0.08229045f, 0.19832475f, -0.06788553f, -0.05856211f, 0.03659692f, -0.05621872f, 
    0.11174325f, 0.07025641f, 0.19184098f, 0.14911275f, 0.05686631f, -0.08990265f, -0.07658064f, 0.06659961f, 
    -0.01618024f, -0.14794001f, -0.02131003f, -0.03689638f, -0.22125217f, -0.07005223f, -0.01441675f, -0.13624352f, 
    -0.02545015f, -0.05633017f, 0.11733858f, 0.07601546f, -0.10678747f, -0.10068680f, -0.03534941f, -0.03995260f, 
    -0.04715581f, -0.13813818f, -0.06909511f, -0.17893991f, 0.01701128f, -0.16196826f, -0.02874328f, -0.01610219f, 
    0.07508759f, -0.15554821f, 0.13040438f, -0.02264814f, -0.10395449f, 0.06294188f, 0.31166410f, -0.31113264f, 
    0.09197489f, -0.23378557f, -0.12253706f, 0.02436225f, -0.07643290f, -0.06274594f, -0.01445035f, -0.04389902f, 
    0.33782125f, -0.41376343f, 0.23281443f, -0.07269949f, -0.11407632f, 0.07287724f, 0.02165708f, 0.01092995f, 
    0.00952193f, 0.18397251f, 0.08091651f, -0.01428506f, -0.04211381f, 0.05355664f, 0.12992401f, 0.03124991f, 
    -0.21535809f, -0.12128899f, 0.03885942f, 0.11217608f, -0.07382365f, -0.11060409f, -0.19287321f, -0.03724091f, 
    0.02374927f, 0.10257898f, 0.00517310f, -0.05053968f, 0.02177111f, 0.00968058f, 0.01385105f, 0.02620744f, 
    0.03377274f, -0.06627810f, -0.03456866f, 0.00590820f, 0.23582646f, -0.10452544f, 0.16733275f, -0.02316586f, 
    -0.03856502f, -0.05203790f, -0.07748213f, -0.03489022f, 0.13636470f, -0.25994536f, 0.23789778f, -0.23324491f, 
    0.07248804f, 0.10926146f, -0.06785226f, 0.08169618f, 0.01232067f, 0.13143548f, 0.04871066f, 0.13237581f, 
    0.10442909f, 0.15340964f, -0.16213723f, 0.19169305f, -0.00325012f, -0.01103366f, -0.10436025f, 0.14863253f, 
    -0.02692340f, -0.07337236f, 0.00064958f, -0.07289542f, -0.05590278f, -0.17109172f, 0.00804926f, -0.01528208f, 
    0.11602484f, 0.18909571f, 0.29884183f, -0.10570106f, -0.01288162f, 0.00142737f, -0.03556553f, 0.11685108f, 
    -0.02303631f, 0.02926890f, -0.04995879f, -0.04502430f, -0.01800733f, -0.13796978f, 0.07167459f, 0.03314709f, 
    0.09877338f, 0.07744090f, 0.03988140f, 0.03136918f, -0.00228936f, 0.02858944f, 0.08660147f, 0.14169256f, 
    0.14430663f, 0.13944876f, -0.04078433f, 0.04038865f, 0.09070595f, -0.05731260f, 0.03222862f, -0.01281096f, 
    0.26053044f, 0.01446436f, -0.05100975f, -0.10306726f, 0.51406735f, 0.01017808f, 0.06639731f, -0.12027813f, 
    0.10264118f, 0.11517528f, 0.02095041f, -0.03126031f, 0.20924719f, -0.00957407f, 0.07492686f, 0.07503064f, 
    0.18810265f, 0.17885119f, 0.09321925f, 0.05958222f, -0.02134736f, -0.10436637f, -0.08303256f, -0.01791884f, 
    0.07389283f, 0.02026621f, -0.02930676f, 0.07145731f, -0.04773619f, -0.05323500f, -0.02578191f, 0.26519600f, 
    -0.01578101f, -0.00362695f, -0.04917878f, -0.06221915f, -0.11641964f, -0.08052457f, 0.10845125f, 0.02474217f, 
    0.03218994f, 0.23544984f, -0.18599318f, -0.27491000f, -0.01232147f, -0.01484594f, 0.08563328f, 0.07092302f, 
    -0.05160802f, 0.03620865f, 0.05498504f, -0.01257973f, -0.22162654f, -0.14596729f, 0.15901786f, -0.11534950f, 
    0.12416916f, 0.00842161f, 0.12290293f, 0.07406620f, -0.02391600f, -0.02292951f, 0.06537132f, 0.05253305f, 
    0.16638672f, 0.00462767f, 0.16990353f, -0.07991877f, 0.07815519f, -0.00433013f, 0.08104770f, 0.19929862f, 
    0.05682753f, -0.20011857f, 0.02402820f, 0.11955433f, 0.23363227f, 0.08973274f, 0.08638268f, 0.24308188f, 
    -0.07865773f, -0.10007207f, -0.03863420f, 0.01005101f, 0.00457667f, 0.11430302f, -0.04578744f, -0.12076428f, 
    -0.08635378f, 0.08188741f, 0.08918251f, -0.01858607f, -0.07973551f, 0.06900015f, 0.20451240f, 0.06613652f, 
    0.06534118f, 0.02013762f, -0.08319996f, 0.10804855f, 0.25933003f, 0.14987323f, -0.00023462f, -0.00289607f, 
    -0.04605634f, -0.10443207f, -0.05577284f, -0.12973234f, 0.00266224f, 0.02672218f, 0.05967476f, 0.06863156f, 
    0.39691082f, -0.51716781f, 0.08820917f, 0.17274453f, -0.22839276f, -0.02209638f, -0.06372159f, 0.24038081f, 
    0.12076552f, 0.00403005f, -0.02920309f, -0.07386286f, -0.14447218f, 0.01623878f, 0.11804425f, 0.15450791f, 
    0.06204511f, 0.02219702f, -0.08279206f, -0.03266257f, -0.00995791f, -0.10425226f, -0.10684420f, 0.08013304f, 
    0.13681515f, 0.07108873f, 0.06026312f, -0.02299370f, 0.07282187f, -0.00161950f, 0.00172888f, 0.02400929f, 
    -0.00993345f, -0.05103939f, -0.04957492f, -0.23451647f, 0.16846739f, 0.07666714f, 0.06891123f, 0.00181707f, 
    0.04590828f, 0.16017662f, -0.02444623f, -0.09650266f, -0.02915945f, 0.02262199f, -0.05011379f, 0.17276014f, 
    -0.01038860f, 0.00198091f, -0.09882452f, 0.38584888f, 0.18770491f, 0.04956291f, 0.02074175f, -0.07395285f, 
    -0.00260075f, -0.00402263f, -0.01930480f, -0.06225409f, -0.21089523f, -0.08408458f, -0.04819919f, -0.23098302f, 
    0.01807483f, 0.04873278f, -0.00375654f, 0.11496879f, 0.02345708f, 0.04103890f, 0.11121994f, -0.34306371f, 
    -0.23050055f, -0.10390179f, -0.16315082f, -0.03882487f, -0.14536546f, -0.10445837f, -0.04268510f, -0.05284749f, 
    -0.00448461f, -0.20638660f, -0.02932701f, -0.19235624f, 0.37095216f, 0.26985073f, 0.11440690f, -0.14875759f, 
    0.04282780f, -0.13542898f, 0.07141618f, 0.00120258f, 0.09326594f, -0.01322743f, 0.15755081f, 0.20080833f, 
    0.20475160f, 0.10065892f, 0.15914395f, -0.13498297f, -0.00202105f, 0.05372417f, -0.06017498f, 0.00474941f, 
    0.38361448f, 0.04069768f, -0.14490168f, 0.05343297f, 0.07567384f, 0.12734720f, 0.23049870f, 0.06336310f, 
    -0.06025939f, 0.11694442f, 0.08011177f, 0.03408732f, -0.02611658f, -0.07247658f, -0.09228539f, -0.00895898f, 
    0.25539505f, 0.22294915f, 0.24433789f, 0.17750616f, -0.01062165f, 0.01864556f, 0.02952475f, -0.06098858f, 
    0.07546536f, -0.00020107f, 0.04444638f, 0.11298209f, -0.32749200f, 0.06179184f, -0.01256296f, -0.01373746f, 
    -0.05970654f, 0.08323807f, 0.16960306f, 0.03070062f, 0.05266989f, 0.05369613f, -0.00938510f, -0.01581367f, 
    0.20780367f, 0.02144666f, 0.19106117f, 0.10610305f, 0.04686261f, 0.04499926f, 0.00719809f, -0.06072441f, 
    0.08709487f, 0.04429963f, -0.16072035f, 0.13677631f, 0.14115383f, -0.18298195f, -0.03149458f, -0.18251607f, 
    -0.06852742f, -0.04981277f, 0.15355211f, 0.16391636f, -0.07817249f, -0.07936282f, 0.09193845f, 0.04830800f, 
    0.00214781f, -0.04836013f, -0.03788431f, 0.02736710f, 0.00650639f, -0.03722615f, -0.05235050f, -0.02561449f, 
    0.01222267f, 0.02399349f, -0.05737988f, -0.02247057f, -0.01343338f, -0.02906949f, 0.03523817f, 0.01251249f, 
    -0.00825094f, -0.03450251f, -0.04501880f, -0.00217551f, 0.00814486f, -0.03046671f, 0.02154414f, 0.02132762f, 
    0.02149644f, -0.01902175f, -0.01703714f, 0.01495920f, 0.01023152f, 0.02004521f, -0.04798790f, -0.04836269f, 
    0.00163995f, -0.02292356f, -0.00242810f, -0.03809511f, 0.01854686f, -0.01052190f, 0.01700928f, -0.03601748f, 
    0.01396583f, 0.02889064f, 0.01646523f, 0.04156803f, 0.02227043f, -0.03782601f, -0.05788291f, -0.05041932f, 
    -0.04771429f, 0.00200956f, 0.00362582f, -0.04185368f, -0.02420313f, 0.03239448f, 0.00854538f, -0.02050464f, 
    0.02310185f, 0.00744873f, -0.01373728f, -0.00003455f, -0.02031688f, 0.01760885f, 0.01324180f, 0.00810930f, 
    -0.04680241f, -0.01652830f, -0.02119583f, -0.01531503f, 0.01983942f, 0.00230200f, -0.00265653f, 0.01341563f, 
    -0.04796952f, -0.00265658f, 0.01527155f, 0.03443589f, 0.04995599f, -0.04944666f, 0.02468589f, 0.01492793f, 
    0.01943652f, -0.01683201f, -0.04472566f, 0.01770132f, -0.01837491f, 0.01828408f, 0.01361511f, 0.01460252f, 
    0.01576954f, 0.04967175f, -0.00765252f, 0.02428574f, -0.04437826f, -0.01792705f, -0.03997056f, 0.02704527f, 
    -0.05260987f, -0.03929685f, 0.03000486f, 0.00396832f, -0.01479805f, -0.02129678f, -0.04521547f, -0.04785113f, 
    -0.03628066f, 0.02204032f, 0.02242287f, -0.00882332f, -0.00467589f, 0.02721852f, 0.00696193f, -0.04365821f, 
    -0.00252606f, 0.02522927f, -0.00815890f, -0.03215415f, -0.01055475f, -0.01262356f, 0.03965648f, -0.02264267f, 
    -0.03846952f, -0.04874570f, 0.01117505f, -0.00982470f, -0.00003660f, -0.01260291f, -0.02474419f, -0.05601462f, 
    0.02868467f, 0.04176942f, -0.02378804f, 0.01906128f, -0.00093231f, -0.02771619f, 0.01166252f, -0.05024705f, 
    -0.02738326f, 0.00791821f, -0.03107141f, 0.01526294f, -0.02000492f, -0.02297051f, -0.05167537f, -0.05036803f, 
    0.03314429f, -0.05321770f, -0.04356603f, -0.00781155f, -0.04617732f, 0.01914056f, -0.03448820f, 0.00588253f, 
    -0.02764318f, 0.02294715f, 0.02535911f, -0.03427271f, -0.04033620f, -0.02181176f, -0.01449775f, -0.02552868f, 
    -0.05264081f, -0.02934145f, 0.03742671f, -0.03347398f, -0.03539059f, -0.02666442f, -0.03386649f, 0.01724379f, 
    -0.04514090f, -0.00288886f, -0.04526573f, 0.03557126f, -0.03883213f, -0.00632218f, 0.00676302f, 0.03188318f, 
    -0.00067580f, 0.02521834f, 0.04063553f, 0.01848394f, 0.03794482f, -0.00672542f, 0.01558966f, 0.00525209f, 
    -0.03256717f, -0.01180548f, -0.02130097f, -0.05615710f, -0.00266135f, 0.01930349f, -0.00493069f, 0.03854172f, 
    0.00103317f, -0.03152525f, -0.03135947f, 0.02820899f, 0.00248210f, 0.00075471f, 0.04584166f, 0.02435350f, 
    -0.01806913f, 0.02004540f, 0.02995930f, -0.01744202f, -0.04281050f, 0.02048948f, 0.04649677f, -0.03681188f, 
    0.02156513f, -0.03011793f, 0.03065102f, -0.00486839f, -0.04797060f, -0.00002989f, -0.03459537f, 0.00857236f, 
    0.00935880f, 0.04730663f, -0.01897820f, 0.04559493f, 0.01457949f, 0.02304699f, -0.02288928f, -0.03995352f, 
    -0.03271511f, -0.00035054f, -0.00135454f, 0.00689989f, -0.02769054f, 0.00148536f, 0.00142529f, -0.02141176f, 
    0.00233224f, 0.03595905f, -0.05243687f, -0.04345554f, -0.03823780f, 0.04504888f, -0.05442848f, -0.02261347f, 
    0.05143236f, -0.01217059f, -0.00053454f, 0.03259238f, 0.03264602f, -0.02242443f, 0.03281936f, 0.04396267f, 
    0.00575125f, 0.04639101f, -0.01428566f, -0.03074359f, -0.03190426f, -0.00736425f, -0.01009368f, 0.01248587f, 
    -0.04343110f, -0.02364853f, 0.00578722f, 0.02037792f, -0.01447595f, -0.04071428f, -0.00411040f, -0.00777212f, 
    0.03794531f, -0.01728019f, 0.01294309f, 0.02399758f, 0.03360682f, 0.03299598f, 0.00598826f, 0.02622529f, 
    -0.00493209f, -0.05409557f, -0.00532408f, -0.02706182f, 0.05040598f, 0.01140668f, -0.02350626f, -0.01746553f, 
    -0.03965426f, 0.00725597f, -0.03808882f, -0.03881705f, 0.01391147f, 0.01502063f, 0.02090004f, -0.04726960f, 
    -0.00787280f, -0.04410635f, -0.04656411f, -0.04527710f, -0.00161404f, -0.01888759f, -0.04073130f, -0.00359553f, 
    -0.01036680f, 0.00219680f, -0.04182759f, 0.00238077f, -0.02502265f, -0.00964772f, -0.03717625f, 0.03071594f, 
    0.00307039f, 0.01414153f, -0.00093981f, 0.01085941f, 0.04153719f, 0.04229983f, -0.04627757f, -0.02857529f, 
    0.03288738f, -0.04921780f, 0.04086326f, -0.01836617f, -0.03979688f, 0.01280015f, 0.01220822f, -0.01159093f, 
    -0.00313813f, -0.02237969f, 0.03756081f, -0.02369096f, 0.03131534f, -0.01556979f, -0.03721632f, -0.04928636f, 
    -0.04145038f, 0.00497440f, -0.02299359f, -0.02792758f, -0.02426598f, 0.02060822f, 0.03453071f, 0.02129574f, 
    -0.02337652f, -0.03527699f, -0.04651919f, 0.00643135f, -0.03465203f, -0.02375925f, -0.05363157f, 0.03361672f, 
    -0.00901672f, -0.00311541f, 0.03830276f, 0.00005622f, 0.02259488f, -0.04277777f, 0.01560999f, 0.04439709f, 
    -0.00195531f, -0.05799784f, -0.05286765f, 0.00047792f, -0.03422156f, 0.00129503f, 0.04521407f, 0.00177578f, 
    -0.04203435f, 0.01815933f, 0.01568351f, 0.02744119f, 0.00146302f, -0.05550623f, 0.00207830f, 0.00010923f, 
    -0.04074149f, 0.03393820f, 0.03486653f, -0.00298293f, 0.03974682f, 0.00227079f, -0.04166211f, 0.03932050f, 
    0.02810665f, -0.05548334f, -0.01617533f, -0.05213593f, 0.02556411f, 0.02632656f, -0.04349431f, 0.02108203f, 
    -0.01255115f, 0.74020541f, -0.27694497f, -0.22688739f, 0.11987806f, 0.10546064f, -0.07984901f, -0.12520741f, 
    -0.11086886f, 0.01750449f, -0.07904467f, 0.03211158f, -0.26939076f, -0.24222326f, 0.05411873f, 0.00917062f, 
    0.04148852f, -0.09833411f, 0.00724794f, 0.05599341f, 0.02052134f, 0.00386437f, 0.16120550f, 0.05929701f, 
    -0.27952179f, 0.00678857f, -0.16436699f, 0.12916167f, -0.04582055f, 0.08333033f, -0.06053414f, -0.12504758f, 
    0.14233170f, 0.06764910f, -0.05650147f, -0.01682430f, 0.01335603f, 0.32393071f, -0.02388303f, -0.04669278f, 
    0.04971998f, 0.05242354f, 0.07934872f, 0.04955144f, -0.25005668f, 0.24842873f, -0.03977953f, 0.13594867f, 
    -0.39695334f, 0.08078686f, 0.06507822f, 0.12358864f, 0.10690627f, 0.00443877f, -0.02737149f, 0.07703557f, 
    -0.07633763f, -0.20481792f, 0.11881749f, 0.14507176f, 0.39664653f, 0.19041249f, -0.18964264f, -0.28544313f, 
    0.02417535f, 0.13211666f, 0.03389175f, -0.03615608f, 0.03904647f, -0.00738368f, -0.01972485f, -0.15528895f, 
    -0.22201310f, 0.04121285f, 0.24115285f, -0.01525086f, 0.06133372f, 0.05736416f, 0.18555364f, -0.02187620f, 
    0.00217795f, 0.04855018f, 0.06751510f, 0.03326273f, 0.19755934f, -0.22390978f, 0.08181383f, 0.11619677f, 
    -0.09953458f, 0.11459764f, 0.11566626f, 0.04974788f, 0.01474642f, 0.09296555f, 0.10294382f, -0.11231329f, 
    -0.07308410f, 0.05166495f, -0.05914619f, 0.00900696f, -0.06613471f, 0.06510509f, 0.02900030f, -0.05248343f, 
    0.12108429f, 0.15182053f, 0.23627295f, -0.00490914f, -0.71963847f, 0.29407564f, -0.11632551f, 0.22632664f, 
    0.15405874f, 0.01531923f, 0.00737410f, -0.05493095f, 0.01325923f, -0.01200631f, -0.03543286f, -0.15149133f, 
    -0.24817349f, -0.07490870f, 0.09943976f, -0.17226650f, -0.01541835f, 0.06443966f, -0.00868249f, 0.03192534f, 
    0.04655159f, -0.02312325f, -0.00111967f, 0.04877436f, 0.32219100f, 0.13001962f, 0.14769806f, -0.17781712f, 
    -0.04461649f, 0.06562553f, 0.18884088f, 0.06327587f, 0.03257572f, 0.09589808f, 0.00937649f, -0.03348315f, 
    0.01490480f, -0.07158660f, 0.35597020f, 0.48071429f, 0.01615476f, 0.33430642f, 0.12086700f, 0.00232730f, 
    0.12067202f, 0.02078292f, -0.12268128f, -0.07481537f, -0.08438703f, -0.19926785f, -0.12233872f, 0.12607001f, 
    0.15737219f, 0.01976213f, 0.02259869f, -0.01589409f, 0.03469794f, -0.02593894f, 0.01627454f, -0.02826512f, 
    0.02780820f, -0.04711452f, 0.07705133f, -0.09672430f, -0.20898704f, -0.06797937f, -0.15326974f, -0.22340193f, 
    -0.00939138f, 0.10598925f, 0.28135201f, 0.07619049f, -0.19887091f, -0.02906568f, 0.08487337f, -0.00165582f, 
    0.03221253f, 0.03526242f, -0.06804688f, 0.02730075f, -0.06615068f, -0.09350648f, 0.01690619f, 0.13991810f, 
    -0.10849606f, 0.09985285f, -0.01887570f, 0.05472305f, 0.08858925f, 0.02469982f, -0.06490152f, 0.00399730f, 
    -0.14195183f, 0.00533991f, 0.12211567f, 0.04048461f, -0.16892841f, -0.02182927f, 0.26348802f, 0.40054837f, 
    -0.08797006f, 0.09450281f, -0.06097216f, 0.09369424f, 0.00706748f, -0.06855886f, -0.04606459f, -0.01076859f, 
    0.05782082f, 0.12470217f, -0.05408741f, -0.19754054f, 0.19069499f, 0.01559111f, -0.23938046f, -0.09929639f, 
    0.02468149f, 0.18223554f, -0.06435390f, 0.23292367f, -0.00272802f, -0.04875237f, 0.02662197f, 0.19826411f, 
    0.11247831f, 0.06633516f, 0.15353779f, 0.14839219f, -0.00307724f, -0.05040417f, 0.00303975f, 0.07965006f, 
    0.02153702f, -0.01717302f, -0.11045730f, 0.17913750f, -0.00046993f, 0.05456007f, 0.01633654f, 0.12439560f, 
    0.12104639f, 0.08005044f, 0.06203764f, 0.12902117f, -0.20632091f, -0.01347269f, 0.12306611f, 0.11509421f, 
    -0.05592071f, -0.17897823f, -0.13779961f, -0.06933770f, 0.10031021f, 0.01349236f, -0.05422948f, -0.05766873f, 
    0.80843663f, 0.16875908f, -0.06588167f, 0.00437068f, 0.02933786f, -0.05090320f, 0.03103292f, 0.10765156f, 
    0.00785576f, -0.13041335f, 0.02521173f, 0.02473317f, 0.32758838f, -0.08743615f, 0.00144854f, 0.24820194f, 
    0.09468026f, 0.05637865f, 0.02994778f, 0.19652642f, 0.07919069f, 0.02628487f, -0.06042346f, 0.13161322f, 
    -0.15365386f, -0.09693261f, 0.16366997f, 0.24013782f, 0.13150664f, 0.04368574f, 0.04156949f, 0.21980827f, 
    -0.04714829f, 0.08322988f, 0.06318654f, 0.17767476f, -0.04199634f, -0.03675632f, -0.17726026f, 0.24320889f, 
    0.00794508f, 0.12511773f, -0.06135079f, -0.07616726f, 0.13681211f, -0.07877044f, 0.00473866f, 0.01972701f, 
    -0.31564006f, -0.08337922f, -0.13551566f, -0.17537344f, 0.05716034f, -0.09790936f, -0.00916465f, 0.15040471f, 
    -0.03715084f, -0.07760311f, 0.04190983f, 0.13329881f, -0.27406317f, -0.16383767f, 0.07642853f, 0.29547620f, 
    0.17432599f, -0.00319587f, 0.04847635f, 0.08561785f, -0.06591123f, 0.00662759f, 0.01476955f, 0.11952391f, 
    -0.25017694f, -0.00948723f, 0.09768976f, -0.11496481f, 0.14278515f, -0.10091256f, -0.07232698f, 0.05319926f, 
    -0.02885119f, -0.00026848f, 0.08226111f, 0.02231402f, 0.20587072f, 0.00959862f, -0.08781918f, 0.49306238f, 
    -0.03291179f, 0.05179554f, -0.10039178f, 0.02404350f, 0.07033396f, 0.10654660f, 0.11498382f, 0.15746339f, 
    -0.42202565f, 0.07488150f, 0.00090765f, -0.12624152f, 0.09377529f, 0.07369088f, -0.05026527f, -0.01934165f, 
    -0.01940290f, 0.09611109f, 0.10384403f, -0.11224009f, -0.40966621f, 0.26052499f, -0.26486975f, 0.31418657f, 
    -0.04526413f, 0.04938029f, -0.01216958f, 0.05637917f, -0.10996989f, 0.02092997f, 0.01001037f, -0.07784379f, 
    -0.01457129f, -0.01384262f, 0.00056535f, -0.00871331f, 0.03071481f, 0.01969838f, -0.04708544f, -0.02950354f, 
    -0.02043134f, 0.04623747f, 0.03583807f, -0.02956019f, -0.01471471f, 0.00493953f, -0.02610146f, 0.04560301f, 
    -0.04842722f, -0.03412158f, -0.05486305f, -0.02582240f, 0.04036402f, 0.03213099f, -0.01964970f, -0.05169414f, 
    0.01147362f, 0.01576019f, 0.01383405f, 0.03823375f, -0.05545888f, -0.02517218f, -0.01279100f, 0.03853406f, 
    -0.03361129f, 0.03096435f, 0.00729072f, -0.04720061f, -0.02242318f, 0.02169677f, -0.01822262f, 0.02449196f, 
    -0.01638106f, -0.01689942f, -0.01886597f, -0.05285129f, 0.01598226f, -0.02350418f, -0.01317485f, 0.03713790f, 
    0.03991409f, 0.02716923f, -0.03889453f, -0.01754868f, 0.03277017f, -0.05014060f, 0.02989860f, -0.00158223f, 
    0.02237768f, -0.04050875f, -0.04031967f, -0.04014757f, 0.00381845f, -0.05533284f, -0.02880390f, -0.04116658f, 
    0.02600811f, -0.04590061f, 0.00710602f, -0.06077419f, 0.04643961f, 0.02158179f, -0.02465555f, 0.03138290f, 
    0.02328885f, 0.01955753f, -0.04460831f, -0.03134547f, 0.02858564f, -0.02905220f, -0.00617552f, 0.00252983f, 
    0.02789717f, 0.01252373f, -0.02624550f, 0.03033567f, -0.02250722f, -0.03772969f, 0.00033858f, 0.02224565f, 
    0.03748243f, 0.03194071f, -0.04523737f, 0.01460843f, -0.04056827f, -0.04539951f, -0.03342496f, -0.05130653f, 
    0.00402735f, 0.02649825f, 0.01086182f, 0.00309508f, 0.00024252f, -0.05752777f, 0.00023958f, -0.01046835f, 
    -0.00082642f, -0.03866864f, -0.00630531f, 0.03770000f, -0.04986243f, -0.00588036f, -0.05477168f, -0.01204579f, 
    0.02606177f, -0.04220077f, -0.03952119f, -0.02418864f, 0.00681211f, 0.04299558f, -0.01405492f, -0.03674125f, 
    0.00709842f, 0.02917250f, -0.03571361f, -0.00037154f, -0.01389912f, -0.00117282f, 0.00998770f, -0.05850460f, 
    0.00300810f, -0.01907798f, 0.02496064f, -0.05593240f, -0.05363347f, -0.00396847f, -0.01717087f, -0.05866996f, 
    -0.02986329f, 0.03042265f, 0.04239186f, -0.04208020f, 0.03935660f, -0.01132971f, -0.01219770f, -0.03285975f, 
    0.03761163f, 0.03784420f, 0.00108366f, 0.02342666f, -0.04222024f, 0.00234159f, 0.00281233f, 0.00519485f, 
    0.03383095f, -0.00971351f, -0.03271713f, -0.02985791f, -0.01128621f, -0.02148120f, -0.01925189f, 0.04576989f, 
    -0.04504949f, 0.02600542f, 0.00093508f, -0.05492260f, 0.02044880f, 0.03037050f, -0.03903322f, 0.02849663f, 
    -0.04420745f, 0.03579481f, 0.00876631f, -0.03623468f, -0.02654599f, -0.01381259f, 0.04765509f, 0.00372709f, 
    -0.03623809f, 0.02490529f, 0.01011324f, -0.01363196f, -0.00625563f, 0.03446074f, 0.03676506f, 0.03152759f, 
    -0.04761123f, 0.03253689f, -0.00901407f, 0.02410264f, -0.05215639f, 0.00161918f, -0.04654598f, -0.05591882f, 
    -0.00931260f, -0.05240681f, -0.04809304f, 0.02127861f, 0.01122275f, -0.04219851f, -0.03567490f, 0.04207937f, 
    -0.05494320f, 0.04088113f, 0.04472340f, 0.02424704f, -0.00677834f, -0.03915478f, 0.02995674f, 0.01984246f, 
    -0.03666022f, -0.05198308f, -0.04714660f, 0.00395154f, 0.01460105f, -0.00861131f, -0.05519729f, -0.03732299f, 
    0.03456851f, -0.00447293f, -0.01570027f, -0.01580574f, 0.02494097f, 0.03346253f, -0.01932342f, 0.00943851f, 
    -0.02123621f, -0.03811451f, -0.04545107f, 0.03154006f, 0.01405731f, 0.03107680f, -0.04344124f, 0.04427580f, 
    0.03230103f, 0.01511237f, 0.01659141f, -0.01933676f, -0.01725461f, 0.02615745f, 0.01023475f, 0.02940305f, 
    -0.01422387f, 0.01696145f, 0.02783101f, -0.02909017f, -0.02865319f, 0.00053862f, 0.04641121f, -0.00398481f, 
    0.02084517f, 0.03495686f, -0.01688174f, -0.04749185f, -0.03977764f, 0.04334706f, -0.00548486f, -0.06133797f, 
    -0.00170775f, 0.00985418f, -0.03429852f, -0.00474299f, 0.02603719f, 0.01747787f, -0.02415548f, 0.01540752f, 
    0.04310209f, 0.03172244f, -0.00696832f, -0.02339753f, 0.01042365f, -0.01210731f, -0.04946205f, 0.00260216f, 
    -0.04251564f, -0.03894455f, -0.01963073f, 0.00240703f, -0.03886902f, 0.02441775f, 0.00222055f, -0.01531927f, 
    0.03455359f, -0.03452610f, -0.03339101f, -0.01241416f, -0.00190546f, 0.02698443f, 0.03536729f, -0.01830125f, 
    -0.00141537f, 0.03303874f, -0.01266676f, 0.04986355f, 0.01177684f, 0.01423130f, -0.02838461f, -0.01822730f, 
    0.01954510f, -0.02374599f, 0.04256679f, 0.01868007f, 0.03125549f, 0.01569821f, 0.00426851f, 0.00590820f, 
    0.04200364f, -0.03572898f, -0.06280792f, -0.04055963f, -0.01289039f, -0.05366787f, 0.03375842f, -0.05540565f, 
    0.04114874f, -0.01672178f, 0.02586647f, 0.01169340f, -0.03339835f, -0.05529796f, 0.02619780f, -0.03926148f, 
    0.03706786f, -0.03292771f, -0.03119225f, 0.04400286f, -0.01410273f, 0.03483925f, -0.01094500f, 0.05020277f, 
    -0.01809605f, 0.03029996f, 0.04253801f, -0.02426518f, 0.02218518f, -0.05556009f, 0.02808997f, 0.00099213f, 
    -0.04374690f, -0.01329271f, -0.04167741f, -0.00105008f, -0.03894813f, -0.03858052f, 0.03899846f, -0.02789016f, 
    -0.04760966f, -0.04052036f, -0.05796000f, -0.03042702f, -0.01529084f, -0.00956692f, 0.02102717f, -0.04903280f, 
    0.00058260f, 0.03035763f, 0.02920354f, 0.04482995f, 0.02020866f, -0.01416497f, -0.00890741f, -0.02886525f, 
    -0.00528899f, 0.00093253f, -0.05913781f, 0.00741764f, -0.02651114f, 0.04189799f, 0.03445348f, -0.04428366f, 
    -0.00327556f, -0.05459562f, 0.01739801f, 0.00001945f, -0.03607272f, 0.03603166f, 0.01815416f, 0.03122025f, 
    -0.02538963f, -0.05130737f, 0.01833163f, 0.00886741f, -0.05342236f, -0.04886188f, -0.01218167f, -0.04954160f, 
    -0.02391019f, -0.03922090f, -0.05650426f, 0.00255404f, 0.00456953f, -0.03984629f, -0.01698354f, -0.01562003f, 
    -0.00292800f, -0.05549482f, -0.02769791f, 0.03547057f, 0.02806752f, -0.04772137f, -0.04718475f, 0.01515754f, 
    -0.03345402f, -0.05696263f, -0.02484433f, -0.00056113f, -0.02420118f, 0.00480020f, -0.02954478f, 0.00947924f, 
    -0.00059139f, -0.04655382f, 0.01638567f, -0.02448818f, 0.03004686f, -0.05598710f, -0.00211553f, -0.03616599f, 
    -0.02162574f, 0.00712048f, -0.01743846f, 0.01053531f, -0.02909642f, -0.01428576f, 0.00642833f, 0.01364008f, 
    0.03545729f, -0.05210247f, -0.02991279f, 0.04294821f, -0.04045782f, 0.03299294f, -0.02652496f, 0.02829894f, 
    -0.05661710f, -0.02083582f, 0.00322678f, -0.04538397f, -0.04568400f, -0.03941257f, -0.02847192f, 0.02463288f, 
    -0.01573280f, -0.01842555f, 0.04320731f, -0.02860275f, -0.03283690f, -0.04309242f, -0.05458812f, -0.02031162f, 
    -0.04622986f, -0.00039201f, -0.01628254f, 0.00835638f, 0.04461670f, 0.00186514f, -0.04264185f, 0.03059000f, 
    -0.04035483f, 0.04417004f, -0.05495976f, 0.00817201f, -0.03926592f, -0.01328100f, -0.05301018f, -0.04872853f, 
    0.01536327f, 0.00685673f, -0.03948851f, -0.01070021f, 0.03537301f, -0.04619718f, -0.00252535f, 0.02347394f, 
    0.03789430f, 0.02347784f, -0.03584092f, -0.03757209f, 0.03217611f, -0.01633591f, -0.02928671f, -0.04086004f, 
    0.01656448f, -0.03352839f, 0.01303034f, -0.00344337f, -0.03240624f, 0.03528357f, -0.04506451f, -0.02757168f, 
    -0.02395697f, -0.02983181f, -0.01073112f, -0.02229926f, 0.01960244f, 0.00582599f, 0.03654750f, 0.01376006f, 
    -0.03202840f, 0.01113873f, 0.02210205f, -0.02564849f, -0.03717120f, -0.02512579f, -0.02091990f, -0.01013913f, 
    -0.03816136f, -0.04159403f, -0.04240680f, -0.03225494f, -0.04560465f, 0.02959839f, -0.03283142f, -0.05049822f, 
    -0.01977923f, -0.04670348f, 0.03858280f, 0.00784935f, -0.04370655f, 0.03253165f, -0.02148901f, -0.04795193f, 
    0.00159575f, 0.02448598f, -0.02249124f, 0.00696713f, -0.02746743f, 0.02402244f, -0.05187457f, -0.01110061f, 
    0.01000011f, 0.00356841f, -0.03081468f, 0.01447732f, 0.03344018f, 0.03455173f, -0.02495493f, -0.01142303f, 
    -0.00869764f, -0.03098821f, -0.02781888f, -0.00481728f, 0.03854275f, -0.03561431f, -0.05099958f, -0.00278894f, 
    0.00298592f, 0.03817570f, -0.04147161f, -0.01853311f, 0.03031141f, -0.05036012f, -0.00599651f, -0.02963533f, 
    -0.04684401f, -0.05028479f, 0.02836437f, 0.04049381f, -0.03645913f, 0.03906166f, 0.03140020f, -0.02498784f, 
    -0.02108778f, -0.01881727f, 0.04367154f, 0.01877859f, -0.00306900f, 0.03205586f, -0.04408156f, -0.02165481f, 
    -0.03537396f, -0.05124970f, 0.02909313f, -0.00806044f, -0.00694118f, 0.03553441f, 0.04211890f, -0.05546054f, 
    0.02081255f, -0.00390475f, -0.03426406f, -0.05473782f, 0.03985503f, -0.01373732f, 0.02543814f, 0.01315668f, 
    -0.04638007f, 0.02726477f, 0.02948799f, -0.00939482f, -0.00007251f, -0.03608821f, -0.00985862f, -0.00476282f, 
    -0.03073452f, -0.05076066f, -0.05338955f, -0.00074692f, -0.04752677f, -0.00503210f, -0.04068446f, -0.04883645f, 
    -0.02268127f, 0.01761262f, -0.02897939f, -0.03163164f, -0.00854174f, 0.00483848f, -0.00500206f, -0.04336365f, 
    0.03069608f, -0.03487805f, -0.05696560f, -0.01223144f, -0.04429067f, 0.02524384f, 0.00734806f, -0.01954711f, 
    0.00914118f, 0.03445371f, 0.03124853f, -0.02078622f, -0.05681608f, -0.05563629f, -0.03926708f, -0.03072876f, 
    -0.05552511f, 0.00967605f, -0.01295741f, -0.00114514f, 0.04109273f, -0.00510782f, -0.01718763f, 0.03114984f, 
    0.01101330f, -0.05497125f, 0.00130496f, 0.02679858f, -0.02534672f, -0.03109911f, 0.00008733f, -0.02399175f, 
    0.00305195f, 0.02250661f, -0.00167173f, 0.03893104f, 0.02628947f, 0.00188929f, 0.02476803f, -0.01390242f, 
    -0.03283685f, 0.03116110f, -0.01060737f, -0.01808146f, -0.03440350f, -0.00991261f, 0.01970763f, -0.05588761f, 
    -0.02447548f, -0.04696291f, 0.00089682f, 0.01842829f, -0.04975656f, -0.04132554f, 0.03343751f, -0.00596728f, 
    0.03239570f, 0.01828964f, -0.02278027f, 0.00593620f, -0.05096589f, -0.02359809f, 0.01905027f, 0.01637175f, 
    -0.00279263f, -0.05284450f, -0.02763063f, -0.04764904f, 0.03797123f, 0.02088795f, -0.01437276f, -0.05248777f, 
    0.02702381f, -0.01736757f, 0.02305080f, -0.00559800f, 0.00789251f, -0.00903999f, -0.00643187f, -0.01895912f, 
    -0.02909281f, 0.03210945f, 0.03839095f, -0.00951009f, -0.01723373f, -0.03820185f, -0.03355253f, 0.04494390f, 
    0.00315411f, 0.03012566f, 0.04104513f, -0.04263791f, 0.02162092f, 0.00633050f, -0.00597364f, 0.01585623f, 
    0.02594369f, 0.01936846f, 0.02627731f, 0.00976310f, -0.02960799f, 0.00837067f, 0.01385657f, 0.00881970f, 
    -0.03069496f, -0.02838290f, 0.00414734f, -0.03874449f, 0.02456102f, -0.04818966f, -0.00920630f, 0.04464857f, 
    0.02976840f, 0.00020426f, 0.03639342f, -0.01295658f, 0.03070292f, 0.03106728f, 0.01619571f, -0.02060196f, 
    -0.05263202f, -0.00128663f, -0.01267258f, 0.01193364f, -0.04444086f, 0.02910146f, 0.02968887f, -0.00633653f, 
    0.02095033f, -0.00736071f, 0.02785008f, 0.02313566f, -0.01257672f, 0.04303890f, 0.00717577f, -0.00252595f, 
    -0.01910557f, 0.02120929f, 0.02359272f, -0.02961100f, -0.02082087f, -0.00387629f, 0.01681638f, -0.04601286f, 
    -0.02258176f, 0.04123129f, -0.00509810f, -0.01097086f, -0.04550558f, 0.00668575f, -0.01576454f, -0.02290773f, 
    -0.00144570f, -0.00574881f, -0.02258103f, 0.01004135f, -0.01947644f, -0.02804071f, -0.04278520f, 0.03030952f, 
    0.06491536f, -0.19818917f, 0.13507837f, -0.04929117f, -0.03763676f, -0.08938748f, -0.02442254f, 0.02977904f, 
    0.13153604f, -0.01452422f, -0.09827030f, 0.09514415f, -0.12781878f, 0.20281294f, 0.13044338f, 0.08820701f, 
    -0.11739117f, -0.03772028f, 0.03357771f, -0.11421600f, 0.07169438f, -0.03036194f, -0.03693981f, 0.05366424f, 
    -0.15985855f, -0.10115340f, -0.04399351f, -0.15418053f, 0.04034337f, 0.20200053f, 0.07126284f, 0.02380568f, 
    0.08356211f, -0.08081066f, -0.23672791f, -0.06036497f, -0.14315936f, -0.41185015f, -0.15452069f, -0.11546054f, 
    0.07923934f, -0.03265417f, -0.13352583f, 0.06074454f, 0.14822559f, -0.01327993f, -0.10922694f, -0.08466974f, 
    0.08493894f, 0.30878648f, -0.31415731f, 0.26895335f, 0.16167942f, 0.30696538f, -0.05339678f, 0.20406431f, 
    0.02035736f, 0.11664316f, -0.10284369f, 0.18976566f, -0.08565439f, -0.52405775f, 0.03795190f, 0.12193225f, 
    0.06297809f, -0.01305132f, -0.04710681f, 0.17466325f, 0.06636430f, 0.05654178f, 0.05253655f, 0.03734651f, 
    -0.13089086f, 0.29277053f, 0.47547546f, -0.07401326f, -0.15312146f, 0.00380925f, -0.10734101f, 0.12721401f, 
    0.01223016f, -0.09840865f, 0.14426471f, 0.03930033f, -0.08748895f, -0.09392371f, 0.31789497f, 0.29886669f, 
    -0.01809878f, 0.07244576f, -0.00466886f, 0.08645930f, 0.06452567f, 0.00289180f, -0.15076253f, -0.01093016f, 
    0.06208541f, -0.27320036f, -0.08918434f, -0.00469817f, 0.15271279f, 0.10323302f, -0.05803004f, -0.06464990f, 
    0.06138315f, -0.02270500f, 0.13948242f, -0.08641447f, 0.30239129f, -0.16731788f, -0.06279778f, -0.40919879f, 
    -0.02114233f, 0.14771549f, 0.06055440f, -0.03182411f, -0.03711780f, 0.04499184f, 0.11422577f, -0.09219136f, 
    0.16755593f, -0.31734067f, 0.11770809f, 0.03136117f, 0.03973461f, 0.10980651f, -0.04001922f, -0.03733422f, 
    0.04552785f, -0.07755329f, 0.02453024f, 0.00705545f, -0.09192662f, 0.06973518f, 0.15852223f, 0.35979870f, 
    0.07080339f, 0.05352048f, -0.11155786f, 0.12197822f, -0.07000919f, 0.08931401f, -0.20322549f, 0.06019570f, 
    0.34087163f, 0.27531791f, -0.01311006f, 0.03237374f, 0.02446930f, -0.15963729f, -0.10813560f, 0.22218965f, 
    -0.11215480f, 0.06205801f, 0.07545054f, -0.18736914f, 0.14704768f, 0.16815779f, 0.56359762f, 0.10367978f, 
    0.13022850f, 0.13152809f, 0.10554432f, -0.02719073f, 0.02671543f, -0.03945655f, -0.04491957f, -0.07599580f, 
    0.14644198f, -0.10109796f, -0.29527757f, -0.10278207f, -0.09515653f, -0.06064704f, -0.00116919f, -0.01440197f, 
    0.09907573f, -0.20431167f, 0.07745340f, -0.12120982f, 0.27642137f, -0.18887930f, -0.28738678f, 0.07015163f, 
    0.00548641f, -0.00527756f, -0.11571977f, -0.03245417f, -0.06392514f, 0.06519179f, 0.02647966f, -0.04074390f, 
    0.18152827f, 0.14200439f, 0.42325369f, 0.10932763f, -0.09456381f, 0.03991619f, 0.19713616f, 0.07909209f, 
    0.03469121f, 0.05481050f, -0.17830846f, 0.03058121f, 0.31296942f, 0.14521477f, 0.06355959f, -0.10188366f, 
    0.13079955f, -0.08438131f, -0.09595551f, 0.02892150f, 0.06703060f, -0.08722155f, -0.03205758f, -0.07491304f, 
    -0.24719156f, -0.29010823f, 0.06249194f, 0.28464445f, -0.00384882f, -0.05851580f, 0.19604212f, 0.11186424f, 
    0.24003120f, -0.03498578f, -0.11365851f, 0.04802608f, 0.20534861f, 0.37114581f, 0.23318054f, 0.29856083f, 
    0.11332178f, -0.12523434f, -0.03996720f, 0.07246235f, -0.05864605f, -0.12702696f, 0.10703230f, 0.11532357f, 
    0.12445372f, 0.07648223f, 0.06099411f, 0.12562993f, 0.11875132f, -0.06836984f, -0.02879465f, 0.07115963f, 
    0.09660022f, 0.04837535f, 0.02505690f, -0.14881927f, 0.11077759f, -0.08208711f, 0.09815203f, 0.06362205f, 
    0.02575701f, 0.10662577f, 0.04375509f, 0.15268953f, 0.03704116f, 0.04227173f, -0.09077442f, 0.00071262f, 
    -0.15957205f, -0.05999520f, 0.21211980f, 0.47321409f, 0.02607229f, 0.09072464f, -0.06156892f, -0.01415277f, 
    0.05023542f, -0.06343710f, -0.04574776f, -0.17512991f, -0.06457382f, 0.08094861f, 0.01889895f, 0.13002491f, 
    -0.01090502f, -0.06587403f, 0.02210825f, 0.00407931f, 0.03063823f, 0.04516435f, -0.00852211f, 0.06198010f, 
    -0.16610020f, 0.45135304f, -0.06999234f, -0.03749572f, 0.17603458f, -0.06313957f, 0.09282824f, -0.12652785f, 
    -0.03365118f, -0.08189084f, 0.03873532f, 0.02984851f, 0.39845285f, -0.07699116f, 0.05648469f, 0.07212047f, 
    0.02931666f, -0.01038420f, -0.03677503f, 0.13016674f, 0.01147857f, -0.24030863f, -0.06346719f, 0.12040655f, 
    -0.31445849f, -0.13829270f, -0.22793366f, -0.11835817f, 0.07581639f, -0.00270310f, -0.00897268f, 0.10255173f, 
    -0.07358777f, 0.01763921f, 0.02847661f, 0.24004090f, 0.23201291f, 0.44076988f, 0.26989254f, 0.22042252f, 
    0.15318429f, 0.24309038f, -0.00142046f, -0.00010852f, -0.01939762f, -0.02261965f, -0.11689290f, 0.01918927f, 
    0.08270492f, -0.11131793f, -0.22814377f, 0.20557742f, 0.10251314f, -0.07613505f, -0.06158854f, 0.02195607f, 
    0.07814974f, 0.00530542f, -0.08368812f, -0.01987382f, -0.05953230f, 0.10537557f, -0.12772840f, -0.06634714f, 
    0.02530485f, 0.03126973f, -0.06322947f, -0.08491715f, -0.04385034f, -0.01726410f, 0.03678215f, -0.00487380f, 
    0.30502495f, -0.36624849f, 0.24436936f, -0.01753158f, -0.00819489f, 0.37200478f, -0.26780537f, -0.01838462f, 
    0.00057347f, -0.16113432f, 0.03844688f, 0.07370293f, 0.02911397f, -0.11652222f, 0.02196029f, -0.15265660f, 
    0.02999754f, -0.03692809f, 0.02990657f, 0.04242375f, 0.04272940f, 0.00935601f, 0.01862126f, -0.04301530f, 
    0.12045721f, -0.30342525f, -0.01278853f, 0.07016068f, 0.05583765f, 0.02642574f, 0.20653528f, 0.09265855f, 
    -0.07927012f, 0.05306178f, 0.08271357f, 0.08035018f, -0.29063836f, -0.53586763f, -0.05272857f, -0.07235453f, 
    -0.04634446f, -0.01226716f, 0.10782529f, 0.06898241f, 0.02759845f, 0.09945610f, 0.14955296f, -0.00407245f, 
    0.04502358f, -0.01289953f, -0.01749753f, 0.04548702f, -0.02359243f, -0.02333383f, -0.10959100f, -0.08316689f, 
    -0.18243377f, -0.08259227f, -0.17563190f, -0.17182471f, 0.03182600f, 0.10753129f, 0.13229667f, 0.15848188f, 
    -0.05745849f, 0.00567267f, 0.12542504f, 0.08925906f, 0.18086077f, 0.07553927f, 0.15742216f, 0.28080562f, 
    0.43820933f, 0.06031433f, 0.09146132f, 0.14564770f, -0.00008414f, -0.02509589f, 0.24132936f, -0.08080511f, 
    -0.05022803f, 0.04499808f, -0.06694145f, 0.09161315f, -0.08812594f, 0.18080063f, 0.20801838f, -0.07041175f, 
    -0.09079279f, 0.10230350f, 0.13987756f, 0.01767096f, -0.02334743f, 0.06831722f, 0.19927832f, 0.14245959f, 
    -0.11742081f, -0.03377938f, 0.02107227f, 0.00219915f, -0.01093759f, 0.07425462f, 0.01396954f, -0.12562549f, 
    -0.08338935f, -0.10972860f, -0.04460833f, 0.06856427f, -0.00400527f, 0.00082593f, -0.03094056f, 0.05367094f, 
    0.15363112f, 0.11894224f, 0.08061280f, 0.11644489f, -0.03635092f, 0.12656820f, -0.09080419f, 0.01577516f, 
    0.24744943f, -0.02847843f, 0.17072688f, 0.15811345f, -0.02596637f, -0.03354349f, 0.05602434f, 0.12705721f, 
    0.16727985f, 0.11669014f, 0.10438852f, 0.17058568f, 0.49340910f, 0.13151053f, 0.14211975f, 0.08825496f, 
    0.00207621f, -0.07336742f, 0.09430092f, 0.13800147f, 0.11254149f, 0.20658728f, 0.07070188f, 0.09225009f, 
    0.37308717f, 0.26608872f, 0.23542756f, 0.09703932f, -0.04340425f, -0.00036017f, -0.03549090f, 0.00286951f, 
    -0.09169982f, -0.03358191f, 0.01409954f, 0.05968648f, -0.16929188f, -0.06760974f, 0.07864391f, 0.02705402f, 
    -0.02466080f, -0.18252507f, -0.03059033f, -0.01489286f, -0.07677665f, -0.18367071f, -0.07081944f, 0.08086876f, 
    0.23075967f, -0.07003344f, 0.11531089f, 0.04709013f, 0.00851940f, 0.02577315f, 0.22240573f, 0.05474605f, 
    0.10182209f, -0.01987984f, -0.12248477f, 0.08271091f, 0.18206915f, 0.29002216f, -0.15002769f, -0.00017743f, 
    -0.01797001f, 0.00236428f, 0.00821656f, 0.05489136f, -0.06154431f, -0.13191016f, -0.12822090f, -0.13410091f, 
    0.03469884f, 0.17994355f, 0.06568737f, 0.15663861f, 0.04605097f, 0.16532205f, -0.05530163f, 0.15602858f, 
    -0.02332213f, -0.25075740f, -0.00155786f, -0.03803284f, 0.20364499f, 0.26918423f, 0.12142591f, 0.16536395f, 
    -0.06134279f, 0.00886317f, 0.03550511f, 0.02502056f, -0.07544835f, -0.07005714f, 0.02420285f, -0.06104928f, 
    -0.37517849f, -0.05627780f, 0.00176737f, -0.05932083f, 0.07380740f, -0.00278459f, 0.06961416f, -0.00779129f, 
    -0.08066770f, 0.06521334f, -0.11131386f, -0.08249434f, 0.80236071f, 0.30021787f, 0.15450943f, 0.10434376f, 
    0.08211228f, 0.07191413f, 0.11633974f, -0.02138006f, -0.14175859f, -0.06042911f, -0.03560618f, 0.05869702f, 
    0.00386780f, -0.34327942f, -0.18896008f, -0.15172802f, 0.08720119f, 0.08606435f, 0.09013740f, -0.02696840f, 
    -0.10857186f, -0.03358976f, -0.10593837f, 0.11307807f, -0.15887226f, -0.06959629f, -0.22391327f, 0.07912984f, 
    -0.11327974f, 0.12347846f, 0.22788455f, -0.08807995f, 0.20151216f, -0.05527770f, -0.16081579f, 0.02263535f, 
    0.14769754f, -0.16379090f, 0.12064502f, -0.26476681f, -0.09228525f, -0.04660011f, -0.02407774f, 0.18975802f, 
    -0.00984565f, 0.14310335f, 0.02806495f, 0.21119578f, 0.07454780f, 0.14279868f, -0.00640262f, -0.00073715f, 
    0.17598510f, -0.04074158f, 0.03681819f, -0.04145527f, -0.06242822f, -0.13442163f, -0.18405105f, -0.04846244f, 
    -0.21318249f, -0.09333948f, 0.48665950f, -0.15668322f, -0.08777283f, 0.05545141f, -0.01422965f, 0.20937838f, 
    -0.12267480f, 0.00894034f, 0.10717104f, -0.02400978f, -0.23117888f, -0.11560988f, -0.11469784f, -0.34213343f, 
    -0.00159283f, -0.00175108f, -0.00612933f, -0.01941508f, 0.15104707f, -0.06593689f, 0.05092135f, -0.12988792f, 
    -0.33073193f, -0.46144265f, -0.27318069f, -0.16005780f, 0.09170306f, 0.07377332f, -0.05637604f, -0.09969879f, 
    -0.05060077f, 0.06501617f, -0.08966181f, -0.07811164f, 0.36398265f, 0.20527989f, 0.05865585f, 0.10640793f, 
    -0.03020812f, -0.06356658f, -0.08279707f, 0.11405835f, -0.02377657f, 0.03196912f, -0.03267982f, -0.00441767f, 
    0.37251651f, 0.12102046f, 0.08624759f, 0.18980888f, -0.00016006f, -0.07591394f, 0.05314386f, 0.04974833f, 
    0.06519371f, 0.06407748f, 0.01662831f, -0.22804576f, -0.19193214f, 0.26372564f, -0.30369714f, 0.09028661f, 
    0.06204718f, -0.10481968f, -0.00493769f, -0.13472407f, -0.15441875f, -0.07334614f, -0.14172238f, -0.09084238f, 
    0.37509096f, 0.15661307f, 0.10714250f, 0.05046089f, 0.02214463f, -0.04335549f, -0.08912705f, 0.01095047f, 
    0.00513572f, -0.03107484f, 0.00418076f, 0.00019826f, -0.37559476f, -0.34306490f, -0.32715794f, -0.04517208f, 
    0.12400304f, -0.04828834f, 0.02639508f, 0.19671163f, 0.10590290f, 0.04670686f, -0.01064854f, -0.05014545f, 
    0.42467749f, 0.15115447f, -0.02338155f, -0.09836344f, -0.00812799f, 0.16600136f, -0.05489830f, 0.18398467f, 
    0.01100774f, -0.13419977f, -0.04394182f, -0.17310776f, 0.28465274f, -0.28711128f, -0.14808849f, -0.08583996f, 
    0.05180410f, -0.06883065f, -0.02963383f, -0.02793488f, 0.11272554f, 0.09235352f, 0.06369904f, -0.15848093f, 
    -0.49020380f, 0.26326677f, -0.08694024f, 0.40863505f, 0.35825613f, 0.26511690f, -0.06624248f, -0.06676017f, 
    -0.17782366f, 0.05498600f, 0.01409240f, 0.02340318f, -0.31727389f, -0.14320469f, 0.03878984f, 0.12231144f, 
    0.04795778f, 0.07064634f, -0.04128052f, 0.05307480f, 0.13071364f, 0.15810199f, 0.24673943f, 0.13106699f, 
    0.01345962f, -0.01772429f, -0.13961598f, -0.04699882f, 0.07598553f, 0.03322281f, 0.06682730f, -0.14168996f, 
    0.10268442f, 0.10712694f, -0.18328519f, -0.11384457f, -0.16774555f, 0.17204593f, 0.05663213f, 0.03361371f, 
    0.08212623f, -0.02648660f, -0.12801874f, 0.11474521f, -0.03497031f, 0.24923162f, 0.03808941f, 0.28043035f, 
    0.43559828f, -0.04513842f, 0.02998445f, -0.05658473f, 0.19840175f, 0.19885136f, 0.10090629f, 0.14008325f, 
    0.02672529f, 0.01746234f, 0.09420426f, 0.18166769f, 0.00073839f, 0.32749262f, 0.16125385f, -0.14838631f, 
    0.04375042f, -0.04389347f, -0.08181768f, 0.04484441f, 0.16474973f, 0.28764996f, 0.21839181f, 0.14939474f, 
    -0.10225906f, 0.04101652f, 0.15121080f, 0.11179732f, 0.21331996f, 0.17230600f, 0.05492270f, 0.04123509f, 
    -0.00127451f, 0.12846854f, 0.07237054f, 0.04477178f, -0.15530843f, -0.10997686f, -0.00600901f, 0.51947874f, 
    0.08207434f, 0.22751577f, 0.26740229f, 0.25149140f, 0.14442876f, 0.19694237f, 0.10080978f, 0.09938341f, 
    0.42235538f, 0.00733795f, -0.05669671f, -0.14781995f, -0.16317666f, 0.00818523f, 0.04587669f, 0.02634043f, 
    0.13281699f, 0.29261595f, 0.42718458f, 0.04614014f, 0.07632940f, 0.18610501f, 0.21326864f, 0.02134725f, 
    0.16281244f, 0.05232825f, 0.22720441f, 0.12182660f, 0.14116570f, 0.12804082f, 0.29832843f, -0.01077635f, 
    0.17742050f, -0.04131104f, -0.19911344f, 0.15652491f, -0.08014140f, 0.10525285f, 0.11273061f, 0.02588425f, 
    0.01038802f, -0.12857130f, -0.06309665f, -0.07202554f, 0.04953942f, 0.01817085f, 0.13412641f, -0.01357925f, 
    0.12793644f, 0.13309507f, 0.18831153f, 0.15739526f, 0.07000621f, 0.05133038f, -0.15245114f, -0.01398049f, 
    0.29992613f, -0.35726738f, 0.23092546f, 0.23049057f, 0.03102778f, 0.09032953f, 0.34996670f, 0.25506333f, 
    0.03584285f, 0.05714807f, -0.14749798f, 0.00358623f, -0.13294366f, -0.03865258f, 0.03701038f, 0.20034842f, 
    0.09626247f, 0.02110283f, -0.00686650f, 0.12487573f, -0.01877662f, -0.13451561f, -0.11581604f, -0.12164759f, 
    0.06425722f, 0.15455592f, -0.11558110f, 0.12324610f, -0.01911058f, -0.03631915f, -0.04707149f, -0.11683737f, 
    0.06272581f, 0.01918305f, 0.29715034f, -0.00643742f, 0.16904826f, -0.01555770f, 0.06447552f, 0.08425500f, 
    0.01447012f, 0.06725875f, -0.16002348f, 0.00195853f, -0.04091168f, -0.09191408f, -0.00620544f, 0.14730799f, 
    -0.53601617f, 0.04608338f, 0.33996728f, 0.19508663f, 0.08351062f, 0.27426910f, 0.00531897f, 0.06217046f, 
    0.02547327f, 0.03092421f, 0.04952476f, 0.01676383f, 0.35493648f, -0.39098141f, -0.06625069f, 0.12285925f, 
    -0.06575050f, 0.24924162f, 0.20848085f, 0.09521067f, -0.02936583f, -0.08826192f, -0.08449081f, -0.03012040f, 
    -0.65198857f, 0.32024255f, 0.13186377f, 0.34300998f, 0.26001796f, 0.02877964f, -0.11811086f, -0.02372498f, 
    -0.03474013f, -0.00767243f, -0.01366555f, 0.10311226f, -0.12082729f, 0.02471071f, -0.04228257f, 0.05719754f, 
    0.03923706f, 0.12988517f, 0.26573941f, 0.25610316f, 0.12861566f, -0.00846201f, 0.01425011f, 0.20468637f, 
    0.12524968f, -0.04625691f, 0.00673515f, 0.04216015f, 0.03170112f, 0.08791409f, 0.21430112f, 0.18776117f, 
    0.15071823f, 0.09992327f, 0.16152464f, 0.26834112f, -0.05155109f, -0.00009785f, 0.01171380f, 0.19273858f, 
    0.20479536f, 0.02143469f, -0.07935049f, 0.39312375f, 0.07291246f, -0.20071693f, -0.17672440f, -0.10488989f, 
    -0.20961617f, 0.15272525f, 0.29059216f, 0.16453542f, 0.13556349f, 0.18922657f, -0.04406026f, 0.20977962f, 
    0.09687833f, -0.04706072f, 0.04487557f, -0.17641880f, 0.05004119f, 0.41805404f, 0.16941856f, 0.24119940f, 
    -0.05434809f, -0.20933294f, 0.06460012f, 0.09723347f, -0.07399997f, 0.23412615f, 0.03825349f, 0.10069616f, 
    -0.18791234f, 0.14788428f, 0.35383213f, 0.08585044f, 0.19827589f, -0.08357305f, -0.10155116f, 0.04389398f, 
    -0.12736481f, 0.06062539f, 0.17975186f, 0.02308657f, 0.57200158f, -0.05272805f, -0.05356240f, 0.37272236f, 
    0.04152132f, 0.21590795f, -0.11786926f, 0.01678067f, 0.15054050f, 0.08136430f, 0.06729726f, 0.03403630f, 
    0.25764379f, 0.13304682f, -0.29078305f, 0.24503666f, -0.07535114f, -0.08348645f, -0.04371098f, 0.09539022f, 
    0.25390249f, 0.22118594f, 0.14723247f, -0.04293996f, -0.23424079f, -0.04439742f, 0.19673988f, 0.20621140f, 
    -0.06655706f, -0.02402424f, 0.00854967f, 0.04016795f, -0.03357211f, -0.05060733f, -0.11083227f, -0.06105359f, 
    -0.11055776f, -0.17169668f, -0.07390183f, 0.02211381f, -0.03585074f, -0.02947412f, -0.09563424f, -0.12730269f, 
    -0.11105298f, 0.03638499f, -0.12085608f, -0.09626426f, 0.39899263f, 0.21546899f, 0.13971587f, 0.17217530f, 
    0.11327715f, -0.09655491f, 0.00635169f, 0.10945568f, 0.19736674f, 0.32509449f, 0.20856157f, 0.14874390f, 
    0.18009971f, 0.10015065f, 0.09872440f, -0.22375512f, 0.17583187f, 0.09868480f, -0.06714432f, 0.13223040f, 
    -0.00737295f, -0.18729945f, 0.09744912f, -0.21465711f, 0.16726209f, 0.43128070f, 0.14541470f, -0.11657094f, 
    -0.06347363f, -0.02600092f, -0.00591095f, 0.07113655f, 0.05603670f, 0.22260337f, 0.05306062f, -0.13670443f, 
    0.19147778f, 0.26106149f, -0.09797994f, -0.19965802f, -0.06115011f, -0.12475033f, 0.14872208f, 0.07825131f, 
    0.08310284f, -0.06005667f, 0.16652915f, 0.08007491f, 0.33227271f, 0.23348977f, 0.02055117f, -0.10454734f, 
    0.18449244f, 0.09102207f, 0.06145007f, -0.04115892f, -0.04595377f, -0.03418825f, -0.11071401f, 0.00850415f, 
    -0.14158064f, -0.21301319f, -0.11713734f, -0.06765912f, 0.00448403f, -0.01547017f, -0.24762027f, -0.06290186f, 
    0.10520850f, 0.11568271f, 0.13320886f, -0.00141130f, 0.09661750f, 0.18186311f, 0.02062258f, 0.01977556f, 
    -0.02116043f, -0.01307397f, 0.03124196f, -0.18949790f, -0.13027482f, -0.22421382f, 0.04370399f, -0.21847558f, 
    0.02839128f, -0.20484328f, 0.14235082f, -0.06012847f, -0.05509888f, -0.16244608f, 0.12640022f, 0.10908484f, 
    0.16616647f, 0.09463044f, 0.00045805f, 0.01592631f, 0.14084838f, -0.19825700f, -0.04490579f, 0.16980928f, 
    -0.05931693f, -0.12166108f, 0.05717162f, -0.12164778f, 0.08363044f, -0.06789810f, -0.01396772f, -0.10566875f, 
    0.40189984f, 0.08370042f, -0.29354158f, 0.04754056f, -0.02111557f, 0.03393644f, 0.10681067f, 0.07333140f, 
    -0.01825838f, -0.02387156f, -0.04863111f, 0.01184102f, 0.13574822f, 0.36868030f, 0.11767162f, -0.25365344f, 
    0.13367207f, -0.01566015f, 0.01641435f, -0.12874556f, 0.12952839f, -0.10360967f, 0.09385872f, 0.07510500f, 
    -0.13952436f, 0.02229892f, 0.18886229f, 0.21274777f, -0.03198199f, -0.01813254f, -0.06628536f, 0.06993394f, 
    -0.15298697f, -0.13372348f, -0.15482880f, -0.08910299f, -0.03674736f, 0.00685542f, -0.09125251f, 0.31118435f, 
    -0.00431568f, 0.13217252f, -0.06977758f, -0.01194903f, 0.09223158f, -0.00432089f, -0.15646012f, 0.10281739f, 
    -0.08094650f, 0.18666670f, 0.20135225f, 0.06516775f, -0.03720393f, -0.07585385f, -0.25289777f, -0.15016776f, 
    -0.09431583f, -0.05141290f, -0.11469464f, -0.09070683f, 0.19100901f, 0.06055737f, 0.02967834f, -0.20797484f, 
    0.09281747f, 0.20788410f, 0.02035497f, 0.19935462f, -0.02179364f, 0.03443012f, 0.19616093f, 0.03835544f, 
    -0.03568648f, 0.09402358f, -0.07999823f, -0.03083530f, 0.02024743f, 0.05331020f, -0.02909026f, -0.01671780f, 
    0.07388587f, 0.02654658f, 0.05120327f, -0.04990287f, 0.16106756f, 0.07442535f, -0.18208355f, -0.18304518f, 
    0.08914151f, 0.05776043f, 0.14278027f, -0.00924294f, -0.00783403f, 0.09880766f, 0.08317248f, 0.10373912f, 
    -0.08012041f, -0.09953871f, 0.09457678f, -0.02727930f, -0.20000373f, -0.05709164f, -0.05654985f, 0.06287973f, 
    0.09217740f, 0.33560717f, -0.01460719f, 0.19616312f, 0.06061609f, -0.00427840f, 0.25080761f, 0.07718904f, 
    -0.16064520f, -0.21889953f, -0.11357218f, -0.14630555f, -0.06369796f, 0.07731832f, -0.02219872f, -0.13386188f, 
    0.25406098f, 0.31994760f, -0.32344911f, -0.04522101f, 0.12456123f, -0.02011515f, 0.24518128f, 0.03707952f, 
    0.11540834f, 0.04128448f, -0.02290305f, 0.16947253f, -0.24471357f, 0.12730448f, 0.12370709f, 0.08329099f, 
    0.11451448f, -0.04658493f, -0.16967212f, -0.07859585f, -0.08166321f, 0.07171202f, 0.11109165f, 0.03007364f, 
    0.03625070f, 0.10003763f, 0.20064270f, -0.28162923f, 0.04277904f, 0.02917761f, -0.10877277f, -0.07865980f, 
    0.02972357f, 0.11617873f, 0.03677429f, 0.09585951f, 0.04809335f, -0.01272305f, 0.03964860f, -0.02462292f, 
    0.09092442f, 0.06411886f, -0.07526585f, 0.08147979f, -0.04012588f, 0.02496268f, 0.09903108f, 0.03990994f, 
    0.19766077f, 0.00101217f, 0.01803989f, 0.11347410f, 0.05785522f, 0.09887613f, 0.05092860f, 0.03012706f, 
    0.01551576f, 0.05257968f, 0.07089967f, -0.25014615f, -0.04427479f, 0.07019281f, -0.23456784f, -0.07336359f, 
    0.12142625f, -0.00462871f, 0.18615247f, -0.21537222f, -0.00530470f, 0.14929432f, 0.05920256f, 0.01157059f, 
    0.10341761f, 0.10805572f, 0.10650823f, -0.04286150f, 0.09229454f, -0.03574952f, 0.07104892f, -0.06607135f, 
    0.10244279f, 0.17680271f, -0.21006432f, 0.20303831f, -0.16858953f, -0.35230276f, -0.06488846f, -0.16184396f, 
    0.03861649f, 0.21516167f, -0.05500377f, 0.09485321f, 0.04673925f, 0.04526829f, -0.03389164f, -0.11396276f, 
    0.03503246f, -0.24655800f, -0.29184353f, -0.05922989f, 0.06660528f, 0.23543188f, 0.09211183f, 0.10208966f, 
    0.12501167f, -0.04346650f, 0.04260796f, 0.13299060f, -0.04836328f, 0.19833356f, -0.10917868f, -0.04850885f, 
    0.04333031f, 0.04937493f, 0.09684398f, -0.05686249f, 0.08000357f, 0.03712040f, 0.09631269f, 0.09270682f, 
    -0.14945345f, -0.00014442f, 0.13568690f, -0.03068339f, -0.18784115f, -0.10740783f, -0.10684892f, -0.15480433f, 
    0.15135944f, -0.00806889f, 0.02067295f, 0.23948380f, 0.17922695f, 0.06661692f, 0.00737615f, -0.09711864f, 
    0.04383221f, 0.11484323f, 0.09678310f, 0.13235267f, 0.01949933f, 0.04862062f, 0.10639364f, 0.13396044f, 
    0.01423034f, 0.05861523f, 0.07994247f, 0.21270637f, -0.11042275f, -0.09847015f, -0.06755170f, -0.13636065f, 
    -0.05380082f, -0.17929640f, 0.04024906f, 0.16614118f, 0.13799584f, -0.10511092f, 0.10593100f, 0.08196875f, 
    0.16606481f, 0.12411312f, 0.10217526f, -0.00390531f, 0.12234173f, -0.00076069f, 0.11216449f, 0.14116712f, 
    -0.17110236f, 0.00579335f, -0.08702668f, 0.24634387f, -0.18127713f, -0.02139580f, 0.06588949f, -0.16940384f, 
    -0.05829308f, 0.12038558f, -0.17766728f, 0.11104202f, -0.14093781f, -0.47604966f, -0.22331575f, 0.01476833f, 
    0.00598843f, 0.08402983f, -0.08251821f, 0.03310071f, 0.10485013f, -0.01989550f, 0.29268274f, 0.04929126f, 
    -0.07281019f, -0.23648623f, 0.02061656f, 0.14780261f, 0.12016929f, -0.01950951f, 0.06462827f, -0.02467200f, 
    -0.05690954f, 0.10288620f, 0.05665582f, 0.00650728f, 0.09657584f, 0.13439332f, -0.02714951f, 0.09728853f, 
    0.17456414f, 0.12716858f, 0.12140906f, 0.04631421f, 0.17370209f, 0.10317463f, 0.12045959f, 0.09407656f, 
    0.02439104f, -0.03086109f, 0.04130355f, -0.02641361f, 0.12151939f, 0.11794731f, 0.12060423f, 0.11885877f, 
    -0.15276784f, -0.07489684f, -0.00486462f, 0.03770755f, -0.08667032f, -0.07957251f, 0.00868293f, 0.03000158f, 
    -0.06401998f, -0.02614836f, -0.09045601f, 0.09312557f, 0.23132882f, 0.20453878f, 0.06523174f, 0.31926581f, 
    0.06065314f, 0.16662230f, -0.11646567f, -0.01458004f, 0.00813231f, 0.20875406f, -0.01710676f, -0.00543296f, 
    -0.15217040f, 0.13659440f, -0.07936426f, -0.15836222f, -0.10848431f, -0.02688898f, 0.01040856f, 0.13717376f, 
    0.10826639f, -0.12149452f, -0.00596063f, 0.16915271f, 0.12471350f, 0.20359899f, 0.09845254f, 0.17372489f, 
    -0.00413300f, -0.18329738f, -0.08309221f, 0.10062459f, -0.07633604f, -0.01984608f, 0.04137320f, 0.19224602f, 
    0.05644903f, -0.07184807f, 0.12210691f, 0.07290226f, 0.09181863f, 0.11541200f, 0.17370065f, 0.14986627f, 
    0.08116052f, 0.01131007f, 0.00285964f, -0.10313980f, 0.02906079f, 0.07141463f, -0.12130024f, -0.07161791f, 
    -0.06378197f, -0.10626487f, -0.08633839f, -0.05545590f, -0.05976870f, 0.00956186f, 0.03142549f, -0.12605947f, 
    0.13472293f, 0.10102350f, 0.10976528f, 0.22822502f, 0.03140428f, -0.14319019f, 0.03727038f, -0.16854504f, 
    -0.05727571f, -0.07450256f, 0.12763385f, 0.09831293f, -0.03889015f, 0.04175989f, 0.15363052f, 0.13835874f, 
    0.18411463f, -0.14550561f, -0.23826839f, 0.25795963f, 0.06637467f, 0.27545673f, -0.00818680f, -0.02937935f, 
    -0.13374189f, -0.03889159f, 0.00996123f, -0.10879044f, -0.14626175f, 0.12489660f, -0.06018385f, 0.16031383f, 
    0.17874548f, 0.01821501f, 0.05146639f, -0.04140554f, 0.00177899f, -0.05461110f, -0.21337508f, -0.12207460f, 
    0.11731171f, 0.02441966f, 0.00451457f, 0.23057166f, 0.10843837f, 0.01898185f, 0.03183892f, 0.19382276f, 
    -0.04639716f, 0.08230218f, -0.19068696f, 0.03908655f, 0.11077710f, 0.08559941f, 0.12279567f, -0.06760261f, 
    -0.03315728f, -0.05168078f, 0.02547763f, 0.11951025f, -0.09658323f, 0.01942241f, -0.03346511f, -0.21680005f, 
    0.11797054f, -0.01501279f, -0.02874682f, 0.06173732f, 0.14342861f, 0.05230777f, 0.03413661f, -0.14890853f, 
    -0.08102192f, 0.06652110f, -0.25785494f, -0.01421437f, 0.11564854f, -0.00983323f, -0.15832733f, -0.03471347f, 
    0.07363060f, 0.23295525f, -0.02166215f, -0.11816371f, 0.03375218f, 0.01059511f, 0.02310924f, 0.07874630f, 
    0.05725358f, -0.15440378f, 0.16396414f, -0.03340740f, 0.09866908f, 0.00303189f, -0.13666119f, 0.11272093f, 
    -0.00908355f, -0.01990206f, -0.02264682f, -0.03877182f, 0.07237943f, -0.01806242f, -0.10196343f, 0.08326285f, 
    0.04544208f, 0.00752930f, 0.03137492f, 0.04595067f, -0.08767972f, -0.06354895f, -0.09624198f, -0.04523553f, 
    0.02094635f, 0.19903103f, 0.07865687f, 0.38635159f, 0.17419712f, -0.03275137f, 0.20609294f, -0.12031399f, 
    -0.07720630f, -0.10236577f, -0.01690951f, -0.02675106f, 0.07386514f, 0.20017362f, 0.05660307f, -0.02903770f, 
    0.04960269f, 0.06104926f, 0.01982582f, 0.12903291f, 0.12349787f, 0.09509502f, 0.08447132f, -0.01288003f, 
    -0.06057728f, 0.07174125f, 0.05601019f, 0.05519630f, -0.01263442f, -0.02831083f, 0.11027166f, 0.03698145f, 
    0.11307544f, 0.07120885f, 0.11883526f, 0.21237795f, -0.00695125f, -0.16084452f, -0.14182688f, -0.07732739f, 
    0.00642355f, -0.05711085f, -0.02426485f, 0.15609437f, -0.11901613f, -0.27940589f, -0.08584281f, -0.21438499f, 
    -0.40161660f, -0.11849099f, 0.02902118f, 0.15396969f, 0.14022884f, 0.09828672f, -0.06833746f, -0.08282688f, 
    0.06648816f, 0.00660046f, 0.02398547f, -0.08077129f, 0.13998398f, 0.22345200f, 0.08912083f, 0.16592716f, 
    -0.18785410f, -0.05567504f, -0.01138074f, -0.05613435f, 0.09936339f, 0.01915802f, 0.00360059f, 0.18025181f, 
    0.28119451f, 0.34543020f, 0.13042858f, -0.22018908f, 0.01836427f, -0.10518817f, -0.01927687f, -0.00034332f, 
    -0.11647438f, 0.04949872f, -0.06930840f, 0.00439387f, -0.10697842f, -0.14481600f, 0.16707322f, -0.00647892f, 
    0.01748285f, 0.05178811f, -0.06401926f, 0.04836071f, -0.25480211f, 0.06277017f, -0.17581639f, -0.11861227f, 
    0.04090285f, -0.09627615f, -0.03711802f, 0.00139591f, -0.02759678f, 0.11809482f, 0.10689167f, -0.10966066f, 
    -0.15005802f, 0.05760884f, 0.05538034f, -0.05195929f, -0.06173490f, 0.15308478f, -0.19075271f, -0.18064591f, 
    -0.04825111f, -0.00444539f, -0.04006591f, 0.05464787f, -0.09019372f, -0.03421414f, -0.05817031f, -0.17194726f, 
    -0.09815799f, -0.12525220f, -0.11686753f, 0.07940144f, -0.00526241f, 0.03546528f, -0.04113902f, 0.08397550f, 
    -0.14139731f, 0.01115044f, 0.04120428f, -0.17254034f, 0.08956320f, 0.21233077f, 0.20375168f, -0.25953281f, 
    0.10321472f, -0.08248511f, -0.02617477f, 0.07709798f, -0.12656233f, 0.10066392f, 0.09344549f, 0.00624006f, 
    0.06119475f, -0.01847194f, -0.02585203f, 0.04903886f, 0.17566028f, -0.06176703f, -0.12148274f, -0.08615064f, 
    -0.03865688f, -0.32260531f, 0.06928132f, -0.22660500f, -0.17917775f, 0.26244128f, 0.54417759f, -0.26266488f, 
    0.01476305f, -0.04345831f, 0.03983542f, -0.01490235f, 0.06022245f, 0.08314748f, -0.05016996f, 0.03032325f, 
    -0.23573111f, -0.35744610f, 0.03863382f, 0.16087940f, 0.23724122f, 0.20618288f, 0.14668036f, 0.06420311f, 
    -0.00641469f, 0.03240631f, 0.06624140f, -0.00412715f, 0.03067693f, -0.17924017f, -0.03105251f, 0.13432182f, 
    0.05965469f, 0.04639169f, 0.02725343f, 0.09120601f, -0.04202392f, 0.15569603f, 0.00457282f, -0.05220899f, 
    0.04857351f, 0.03940124f, 0.03968763f, -0.04721859f, 0.14183609f, -0.05258301f, 0.09758714f, 0.12030470f, 
    -0.08320569f, 0.08454207f, 0.07149756f, 0.03610794f, -0.06218156f, 0.10300623f, 0.08045576f, 0.09658487f, 
    0.02442029f, -0.01338333f, 0.05584969f, -0.00506291f, 0.05934143f, 0.03469360f, 0.14555120f, 0.20006143f, 
    0.21982673f, -0.17025952f, 0.19102976f, -0.19561155f, -0.12330769f, 0.14564535f, 0.18566516f, -0.08428359f, 
    0.04912499f, 0.01494597f, -0.00063944f, -0.16902430f, -0.19623014f, 0.32682183f, -0.00130880f, -0.03369325f, 
    -0.02358077f, 0.00491518f, -0.00488858f, -0.01626887f, -0.00326210f, 0.15413614f, 0.03799818f, 0.08386063f, 
    0.11919804f, -0.24168347f, -0.10677711f, 0.26841685f, 0.10188124f, 0.02063488f, -0.03771575f, -0.05881833f, 
    -0.00173639f, 0.09404786f, -0.01081194f, 0.06091009f, -0.05534529f, 0.07708079f, -0.30960169f, 0.14153384f, 
    0.10716758f, 0.04435655f, 0.03622364f, 0.07037182f, -0.09273808f, 0.05051033f, -0.02621478f, 0.05339214f, 
    0.17592868f, 0.08357423f, 0.10353311f, -0.11342970f, 0.01676112f, -0.14477663f, -0.06058525f, 0.02587433f, 
    -0.03189424f, 0.02257626f, 0.08043563f, 0.24908952f, 0.21498306f, -0.07297175f, 0.28673929f, -0.03732813f, 
    0.01083934f, -0.05563114f, 0.07487551f, 0.14765626f, 0.02630700f, 0.09436288f, 0.00092859f, 0.16919622f, 
    0.06799378f, 0.14341979f, -0.19973575f, 0.02945037f, 0.00898686f, 0.00199408f, 0.03932133f, 0.01837995f, 
    0.03815829f, -0.02208090f, -0.05611572f, -0.07655220f, -0.01009461f, -0.10552302f, -0.15782371f, -0.01361707f, 
    0.06164899f, -0.26816696f, 0.00211832f, 0.11919872f, 0.10484919f, -0.05845508f, 0.05459872f, 0.02736547f, 
    -0.11359556f, -0.14702845f, -0.04247675f, -0.07726820f, 0.01029500f, -0.02376694f, -0.02223771f, -0.01052666f, 
    0.00822834f, -0.04704790f, -0.01076448f, 0.09428824f, -0.06238666f, -0.01875455f, -0.08080183f, 0.18919478f, 
    -0.18046360f, -0.01974176f, -0.01167942f, 0.19453679f, 0.02807623f, 0.03152323f, 0.02865867f, 0.03584142f, 
    0.01415638f, 0.08443944f, -0.08771729f, 0.16079712f, 0.21530001f, 0.01267102f, 0.05433889f, 0.01163654f, 
    -0.04647885f, 0.06370707f, -0.36037818f, 0.12950386f, 0.03023771f, 0.20154601f, 0.06694888f, -0.03028501f, 
    0.00989515f, 0.04679615f, -0.05253068f, -0.04678050f, 0.05523170f, -0.02318181f, -0.07727704f, -0.06797992f, 
    -0.23668242f, -0.33804268f, 0.08612695f, 0.10442112f, -0.05009223f, -0.02255277f, -0.14514633f, -0.01691664f, 
    0.01570231f, -0.11532550f, -0.00560238f, -0.02799718f, 0.07561169f, -0.03043808f, -0.17494966f, -0.17665835f, 
    -0.04309620f, 0.05813116f, 0.24183470f, 0.02153249f, 0.00677628f, -0.04324814f, -0.12219357f, 0.00469556f, 
    -0.09206835f, 0.15772675f, -0.10128140f, 0.16568147f, 0.08265270f, 0.03065735f, 0.09699614f, 0.06421980f, 
    -0.20098843f, -0.10720209f, 0.14885265f, 0.07105207f, -0.07230011f, -0.13963629f, 0.00636558f, -0.11520598f, 
    -0.15782344f, 0.11397222f, 0.10241755f, -0.04362581f, 0.02287983f, 0.13444822f, -0.05487466f, -0.06183704f, 
    -0.24803790f, -0.02029300f, 0.04404861f, -0.17541444f, -0.12342308f, -0.16388063f, 0.03230901f, 0.15674575f, 
    -0.00354858f, 0.04691250f, -0.09542856f, 0.22438630f, 0.00993591f, 0.03608930f, 0.04953530f, -0.15811017f, 
    0.04795512f, 0.05820254f, 0.04190713f, 0.23759805f, -0.01521935f, -0.02032924f, 0.13490960f, -0.04796754f, 
    -0.33512172f, 0.00904103f, -0.24502325f, -0.29560062f, 0.11146662f, 0.14990784f, -0.09653530f, 0.03537580f, 
    -0.07671803f, 0.07150308f, 0.12315325f, 0.10247665f, -0.03116716f, 0.29203507f, 0.19367334f, -0.03206037f, 
    -0.01332671f, -0.16179827f, -0.04611789f, -0.04726934f, -0.05526765f, 0.03812030f, 0.29157764f, 0.19222732f, 
    0.41801125f, 0.14707519f, 0.24096468f, 0.05287508f, -0.05594224f, -0.02567741f, -0.14723055f, 0.00946368f, 
    -0.00351853f, 0.13480389f, -0.02239315f, 0.07772245f, -0.24984372f, -0.08033986f, 0.18652911f, 0.01770509f, 
    0.03173889f, -0.03728060f, 0.08436084f, -0.04607894f, 0.00015255f, 0.19725978f, -0.08481123f, -0.11179502f, 
    0.37470317f, -0.02822593f, 0.08269931f, 0.16468360f, -0.02086872f, -0.06636373f, 0.06447348f, -0.13725279f, 
    -0.15642709f, 0.06086920f, 0.05723663f, -0.18571433f, -0.10662400f, -0.14138399f, 0.00351882f, 0.13603425f, 
    -0.08445141f, -0.15577222f, 0.03582138f, -0.07790824f, -0.02256209f, -0.02331331f, -0.05735075f, -0.10982300f, 
    -0.14209768f, -0.19967404f, -0.19033183f, -0.16552590f, -0.03397120f, 0.04259793f, 0.05592113f, 0.04394892f, 
    -0.08401737f, -0.02063030f, -0.08072655f, -0.19283557f, -0.00426897f, 0.14181590f, 0.15797439f, -0.15354580f, 
    0.04897277f, -0.12309714f, -0.00486195f, 0.20074150f, -0.02633679f, 0.03587086f, 0.10013764f, 0.05034643f, 
    0.03061616f, 0.11100459f, -0.16459648f, 0.03404594f, 0.13627642f, -0.22471502f, 0.17081545f, 0.09781241f, 
    0.09163848f, 0.06249209f, 0.01664248f, -0.13443454f, 0.02261004f, 0.21373250f, 0.40846372f, -0.07825033f, 
    0.02932126f, -0.02955689f, -0.11736549f, -0.01775510f, 0.09986166f, 0.02340301f, -0.01873095f, 0.15751179f, 
    -0.01682052f, -0.33940360f, 0.13419113f, 0.09833183f, 0.09864794f, 0.26559108f, -0.18847224f, 0.00112081f, 
    -0.01043932f, 0.09291372f, -0.05768209f, -0.29896215f, -0.19170611f, -0.12699340f, -0.01811968f, 0.02938492f, 
    -0.11259606f, -0.11823492f, 0.01104136f, 0.04498976f, 0.02255499f, 0.10484574f, 0.06866715f, 0.07444292f, 
    0.14118245f, 0.01967438f, 0.00563792f, -0.01803759f, 0.16169226f, -0.14420538f, 0.07395645f, 0.05128627f, 
    -0.01861515f, -0.10979038f, -0.04264386f, -0.11098363f, 0.05656256f, -0.20818640f, 0.16741171f, 0.02143688f, 
    -0.06978417f, -0.08222923f, -0.17843734f, 0.14615765f, 0.30791497f, 0.23421097f, 0.11233920f, 0.14310110f, 
    0.16450126f, 0.10580330f, -0.01290930f, -0.04316169f, 0.21255049f, 0.17581576f, 0.09804703f, -0.08650807f, 
    -0.14342080f, -0.03378169f, -0.00023494f, -0.11933596f, -0.18812840f, 0.17514081f, -0.01720604f, -0.18950860f, 
    0.04040638f, 0.08618484f, 0.10694376f, -0.02968797f, 0.03239406f, 0.16922729f, -0.01011109f, 0.05294876f, 
    -0.24241494f, -0.06563680f, 0.17396851f, -0.13235575f, 0.10371618f, -0.00961826f, 0.02523113f, 0.09670237f, 
    0.00665478f, 0.05140356f, 0.04092126f, 0.05728645f, -0.05150486f, -0.15041758f, -0.01907819f, 0.06601502f, 
    -0.03549521f, 0.04836857f, -0.01256863f, 0.21872406f, -0.02418349f, 0.06481612f, -0.06447691f, 0.08923308f, 
    -0.05074804f, 0.07681075f, -0.19889143f, -0.11560983f, -0.06211322f, -0.04449158f, 0.07305886f, -0.06987452f, 
    0.28934833f, 0.19793835f, 0.12137092f, 0.10076427f, -0.03117247f, 0.13558969f, 0.11930683f, -0.11973835f, 
    0.03856125f, 0.06188322f, 0.13317125f, -0.16144556f, 0.10658447f, 0.00223629f, 0.24187127f, 0.11755944f, 
    -0.34506759f, -0.12283175f, -0.23103429f, -0.11123699f, -0.10061028f, -0.03895141f, 0.22897887f, -0.17872125f, 
    -0.03781057f, -0.16231692f, 0.08204932f, -0.01898263f, -0.23723882f, 0.02278099f, -0.03361101f, 0.15448648f, 
    -0.02350458f, -0.06731389f, 0.22662175f, -0.14254075f, 0.00786504f, 0.00941604f, -0.03911057f, -0.16422455f, 
    -0.32094508f, -0.07438952f, 0.05801158f, 0.08402517f, 0.14830321f, 0.11305677f, 0.07559410f, -0.02661077f, 
    0.05414278f, -0.00743489f, 0.00337404f, 0.05003780f, -0.26011065f, -0.28819546f, -0.10365562f, 0.01093399f, 
    0.03821316f, 0.02256652f, -0.07565662f, 0.04574401f, -0.05427403f, -0.10656319f, -0.01926803f, -0.03521914f, 
    -0.04818417f, -0.07045815f, 0.06782191f, -0.03931418f, 0.17846739f, -0.00485756f, -0.04207641f, -0.06692424f, 
    -0.02602569f, -0.19546761f, -0.07582770f, 0.08241197f, -0.12877372f, 0.00876546f, -0.03746829f, 0.04204914f, 
    0.10413460f, 0.00991299f, 0.15529568f, -0.06762194f, -0.10748143f, -0.17635266f, -0.11885465f, 0.26806906f, 
    -0.14332685f, -0.21242279f, 0.14350472f, -0.02024797f, -0.01167244f, -0.09723365f, -0.14056318f, 0.03295986f, 
    0.06401371f, 0.10108197f, 0.11962611f, -0.10929295f, -0.20121886f, -0.01503079f, -0.02008182f, 0.13541996f, 
    -0.04728538f, 0.05811927f, 0.03252798f, -0.11031125f, -0.06302392f, -0.10641287f, -0.12913139f, 0.00147893f, 
    0.18231577f, -0.03241769f, 0.01194826f, 0.24727553f, -0.18138783f, 0.06524967f, -0.01376060f, 0.11831677f, 
    0.02203766f, -0.01742249f, 0.05251968f, -0.15639868f, -0.10439208f, -0.22202307f, -0.00261604f, 0.00484937f, 
    0.02795384f, 0.09981590f, 0.19566053f, -0.01703391f, 0.12485982f, 0.14361228f, 0.03666633f, -0.06558879f, 
    -0.17436041f, 0.27357376f, 0.03230861f, -0.03165765f, -0.00825073f, 0.10426192f, 0.00661830f, -0.02321787f, 
    0.02233541f, 0.01778753f, 0.06012553f, 0.24341364f, -0.03668490f, -0.05710782f, 0.17143117f, 0.03005188f, 
    -0.06333457f, 0.09200980f, -0.07219457f, 0.01984886f, -0.20783637f, -0.18880506f, -0.04647340f, -0.01786506f, 
    -0.03669433f, 0.04337052f, -0.27998051f, 0.10530750f, -0.06805243f, -0.05473247f, 0.20245463f, -0.04490387f, 
    -0.01243645f, -0.09300734f, 0.11852665f, -0.07275882f, 0.40426612f, 0.41684294f, 0.23372529f, 0.06427805f, 
    -0.17478062f, -0.13108751f, 0.00385803f, -0.07773810f, 0.10355151f, 0.01407109f, 0.14137623f, 0.16740122f, 
    0.02219092f, 0.21310066f, 0.45956337f, 0.37642640f, -0.09384394f, -0.24987392f, 0.00883735f, -0.16786872f, 
    -0.11705942f, 0.00320685f, 0.03405191f, 0.08176653f, -0.05190600f, 0.10204548f, 0.17004131f, -0.09535076f, 
    0.04865616f, -0.15914354f, 0.05082127f, -0.02734368f, 0.10027714f, -0.02513537f, 0.04928546f, -0.09809674f, 
    0.17872836f, 0.13162705f, 0.01826049f, -0.12513016f, 0.05535214f, 0.02576804f, -0.11094934f, 0.01563978f, 
    0.18710791f, 0.23870708f, 0.10702202f, -0.08865847f, -0.12824683f, -0.31077561f, -0.12623738f, -0.16826583f, 
    0.02387016f, -0.04117886f, 0.08549796f, -0.03887329f, -0.14214367f, -0.09042606f, -0.08702253f, -0.12101773f, 
    -0.13054177f, -0.05886329f, 0.20256554f, -0.08560403f, -0.13319547f, -0.11185290f, -0.01013459f, 0.05134821f, 
    0.03640916f, 0.00824971f, -0.05778718f, -0.14962290f, 0.09080181f, 0.27775225f, 0.01723713f, 0.21778831f, 
    -0.14457606f, -0.07943833f, 0.06482005f, -0.09934392f, -0.00236986f, 0.06085584f, 0.04649887f, 0.05778727f, 
    -0.06500942f, 0.12443042f, -0.09940770f, -0.16954800f, 0.11985923f, -0.16434377f, 0.01722821f, 0.07964854f, 
    0.05285129f, -0.12704363f, -0.05486957f, -0.09220234f, 0.27875340f, 0.66128200f, 0.07469440f, -0.03665753f, 
    0.01140535f, -0.12530711f, 0.03730682f, -0.04604269f, 0.06908175f, 0.11646073f, -0.08611927f, 0.13258052f, 
    0.13823064f, 0.11784746f, -0.18145427f, -0.01532497f, 0.06158711f, -0.01613384f, -0.03052980f, 0.02179863f, 
    0.06303697f, -0.03056972f, -0.13757484f, 0.23597082f, -0.07086085f, -0.12335373f, -0.08263525f, -0.23656750f, 
    -0.04145075f, 0.01522980f, 0.00281141f, -0.18138237f, -0.16089565f, -0.04730382f, 0.20565009f, -0.08285387f, 
    0.05703552f, 0.00507026f, -0.09949642f, 0.08350611f, -0.05082206f, 0.03966084f, -0.10791096f, -0.08574742f, 
    0.17496029f, 0.07666661f, 0.01711943f, 0.03298546f, -0.05001437f, -0.10874397f, 0.05711364f, 0.01642383f, 
    -0.00096450f, -0.03095826f, 0.01911989f, 0.01490793f, -0.05732922f, -0.15587181f, -0.11882182f, -0.17513232f, 
    0.02771507f, -0.14961168f, 0.05037659f, 0.14515330f, 0.18038996f, -0.11335088f, -0.08321369f, 0.24117781f, 
    0.12066430f, -0.18658628f, 0.34502941f, 0.02024142f, 0.01167060f, -0.12727582f, 0.18547867f, -0.18280497f, 
    0.00423166f, 0.01418846f, -0.08497854f, 0.03381270f, 0.16419955f, -0.09082873f, -0.22792265f, 0.13789588f, 
    -0.20241816f, 0.08762223f, -0.06170364f, -0.17695025f, -0.01120334f, 0.09750558f, 0.06718979f, -0.10240772f, 
    -0.05555532f, 0.24490710f, -0.02281035f, -0.02835934f, -0.03100067f, -0.08822642f, 0.04735119f, 0.05044588f, 
    -0.07229459f, -0.21118058f, 0.09204308f, 0.13987018f, 0.13372429f, 0.00552218f, 0.01214176f, 0.07421940f, 
    0.00797706f, 0.05310629f, -0.00231607f, 0.02258698f, -0.02146275f, 0.07527654f, 0.07215258f, -0.02430780f, 
    -0.22790319f, 0.07506395f, -0.03668112f, -0.25591949f, -0.09754623f, 0.08268566f, -0.09581597f, 0.15961081f, 
    0.09355886f, 0.18967938f, -0.13717848f, 0.14844438f, 0.02326212f, 0.01573204f, -0.03227365f, -0.19408311f, 
    0.04578975f, 0.09682322f, -0.03531318f, 0.02522492f, 0.11655916f, 0.06309123f, 0.13334613f, 0.03864159f, 
    -0.04561918f, -0.07277293f, -0.00619220f, -0.02923258f, 0.02483280f, -0.12410037f, 0.39916259f, -0.29249236f, 
    -0.04034502f, 0.04059939f, 0.04801434f, -0.11858727f, 0.02551476f, 0.07357846f, 0.01127809f, -0.00111754f, 
    0.14657539f, -0.17033155f, -0.01620573f, 0.17254944f, -0.01108241f, 0.14283791f, 0.29285875f, -0.14914061f, 
    -0.01636982f, -0.01396456f, 0.06335545f, -0.05094364f, -0.02466993f, 0.13378178f, -0.14896311f, -0.10380752f, 
    0.07923462f, 0.09627213f, -0.21563599f, -0.05216896f, -0.02806311f, -0.06959124f, 0.01639141f, 0.03871765f, 
    -0.11997266f, 0.14586714f, 0.00739163f, 0.13165507f, 0.04276956f, 0.02497227f, -0.14959612f, -0.16619346f, 
    0.04328527f, 0.14202505f, 0.26496261f, -0.13417438f, -0.17362660f, -0.04486381f, 0.15138800f, 0.15387708f, 
    0.04120422f, 0.01239559f, 0.00742591f, 0.04493768f, -0.07340696f, -0.02904852f, 0.07830986f, 0.04041214f, 
    0.07519639f, -0.01873178f, 0.11468356f, -0.02126347f, 0.06294090f, 0.00653455f, 0.12676288f, -0.15656152f, 
    -0.05046376f, 0.15381856f, 0.12528621f, -0.08165840f, -0.08622634f, -0.23289290f, 0.02834921f, 0.09507099f, 
    0.11126584f, 0.31441534f, -0.02758256f, 0.07894702f, 0.02517159f, -0.04321537f, 0.02141066f, -0.00796142f, 
    -0.35410056f, -0.01759555f, -0.03761534f, -0.15684463f, -0.11190996f, -0.12462039f, -0.04364605f, -0.13031812f, 
    0.16894436f, 0.18326825f, 0.10322867f, 0.12727611f, 0.10611699f, 0.15279377f, 0.03087212f, -0.03827717f, 
    -0.03795474f, -0.19834211f, 0.20370981f, 0.05165173f, -0.11191347f, -0.04088732f, 0.10885056f, 0.03750483f, 
    0.08347860f, -0.02441747f, -0.08294301f, -0.03249187f, -0.02825618f, 0.13143414f, 0.13654874f, 0.18778116f, 
    -0.07390212f, 0.00030967f, -0.12597086f, 0.11124907f, -0.16613317f, 0.01182546f, 0.08675919f, 0.05187517f, 
    0.03257518f, 0.08557767f, 0.14001213f, -0.08986421f, 0.10833494f, -0.07961188f, 0.15300384f, 0.02286176f, 
    0.14031698f, 0.09770167f, 0.32210910f, 0.09382535f, -0.09832774f, -0.21255808f, 0.00040150f, 0.13016681f, 
    0.08666892f, -0.15115592f, 0.21851927f, 0.06410266f, -0.16849828f, 0.10951453f, -0.23083238f, -0.06463435f, 
    0.10649577f, -0.04889948f, 0.03346796f, 0.03545093f, 0.00851935f, -0.04360371f, -0.06221137f, -0.03165924f, 
    -0.66231465f, -0.26934919f, 0.08692837f, 0.15095703f, 0.11376826f, 0.23517412f, -0.03395087f, 0.10751164f, 
    0.12077420f, 0.00089150f, 0.19306216f, 0.02362784f, 0.32908902f, 0.01717195f, -0.31749162f, 0.26753837f, 
    0.07009892f, 0.05665247f, -0.05733316f, -0.00683948f, 0.22466546f, 0.05968702f, -0.08243640f, 0.21664222f, 
    -0.07152656f, 0.08944352f, -0.02583539f, 0.21161625f, -0.02506200f, -0.02597163f, -0.12123429f, 0.10111030f, 
    -0.03451474f, 0.00213979f, 0.25887716f, 0.08275305f, -0.05097557f, -0.12330873f, 0.14091887f, 0.01660759f, 
    0.20166413f, 0.06203208f, 0.01920591f, 0.02552617f, -0.03711288f, -0.01376182f, 0.05173165f, 0.08807661f, 
    -0.02274491f, 0.09097099f, 0.03287887f, -0.01724322f, 0.07505999f, -0.03571330f, -0.10400778f, -0.05106642f, 
    0.03049647f, -0.03707980f, 0.12258920f, -0.00575020f, 0.11226644f, -0.32948706f, -0.05622729f, 0.42153352f, 
    -0.06538205f, 0.03801025f, -0.13750400f, 0.07891291f, 0.18126692f, -0.16556545f, -0.08245921f, 0.13306308f, 
    -0.08593469f, 0.12068073f, 0.04874558f, -0.11649131f, -0.04591168f, 0.15237127f, 0.08378237f, 0.08865643f, 
    -0.09315346f, -0.08179872f, 0.23082075f, 0.12972178f, 0.21323627f, -0.03966936f, -0.25732234f, 0.12254717f, 
    0.03961200f, 0.08124480f, -0.02846123f, -0.00480789f, -0.00154570f, -0.13055682f, 0.02219402f, -0.17024164f, 
    0.01583616f, -0.03217945f, 0.04100425f, -0.06359930f, -0.04251826f, -0.28265759f, 0.08633459f, 0.08918417f, 
    0.19342025f, -0.09483665f, 0.18733746f, -0.02668578f, 0.49690229f, 0.26138484f, 0.08228135f, 0.06966463f, 
    0.15291594f, 0.05914383f, 0.08099200f, -0.02308629f, 0.01103109f, 0.00098192f, -0.08497076f, 0.06584379f, 
    -0.02165215f, -0.07860105f, 0.00032148f, -0.03258621f, -0.04124441f, -0.09784118f, -0.08572119f, -0.02757817f, 
    -0.19864024f, -0.02447773f, 0.15773743f, 0.01982110f, -0.16315748f, -0.05185874f, -0.09183237f, -0.12964043f, 
    -0.07797055f, 0.02815445f, -0.02610714f, -0.01904656f, 0.19867882f, -0.03274691f, -0.01333881f, -0.11074363f, 
    0.22658873f, -0.18089309f, 0.08580178f, -0.00228629f, 0.06214324f, 0.02670671f, 0.04553172f, -0.07897701f, 
    -0.05878203f, 0.14911669f, -0.04884106f, 0.01559783f, -0.14565694f, -0.19308211f, 0.13560045f, 0.10555834f, 
    -0.04414959f, 0.02491253f, 0.01210477f, -0.00087007f, 0.10236412f, 0.07283251f, -0.02614276f, 0.05031219f, 
    0.37996483f, 0.07967772f, -0.29812947f, 0.24706736f, -0.05470457f, 0.02413967f, 0.03528870f, 0.09895966f, 
    0.08068602f, -0.15615897f, -0.03264140f, 0.09503963f, -0.04805179f, 0.52660352f, 0.01478341f, -0.08593129f, 
    0.24098615f, 0.09694488f, 0.04201399f, -0.01197531f, 0.09227191f, -0.06461804f, 0.03477034f, 0.11619242f, 
    -0.12273233f, -0.19372481f, 0.04069025f, -0.07907986f, -0.02957781f, 0.00479397f, -0.04630884f, 0.03071841f, 
    -0.10663903f, -0.09414443f, -0.25719303f, 0.01149504f, 0.25208116f, -0.11699019f, 0.02435476f, 0.15788773f, 
    -0.12426136f, -0.04253994f, -0.07169083f, 0.09852687f, -0.03021623f, 0.09142498f, -0.05291240f, 0.33895746f, 
    -0.12881227f, -0.05781278f, 0.06140257f, 0.00717048f, -0.03589283f, -0.00561613f, -0.11885102f, 0.06326475f, 
    -0.10835671f, 0.04797779f, 0.01532770f, 0.02763862f, 0.05088513f, -0.02765073f, 0.09784087f, -0.08230166f, 
    -0.06517471f, 0.12992908f, -0.08885263f, 0.16279401f, 0.03290967f, -0.03056166f, 0.11118984f, 0.01661118f, 
    -0.02939535f, 0.09004384f, -0.20639604f, -0.26552853f, 0.05276739f, 0.00809475f, -0.11244466f, -0.08097295f, 
    0.01870028f, -0.01707193f, 0.07386389f, -0.07469022f, 0.23470487f, 0.20644356f, -0.04360707f, -0.09122479f, 
    -0.06640715f, 0.12508291f, 0.04416179f, 0.01256715f, -0.05094985f, 0.04715177f, 0.05737812f, 0.12728794f, 
    -0.14531521f, 0.08890232f, -0.04047266f, 0.07995971f, -0.15287118f, -0.02429635f, 0.05308482f, 0.06221594f, 
    -0.15309447f, 0.14867069f, -0.03601117f, 0.23725674f, 0.04671768f, -0.10827953f, 0.02271872f, -0.15881319f, 
    -0.10683589f, -0.10477131f, 0.03526876f, -0.03012671f, -0.12934840f, 0.08728170f, 0.05146089f, -0.05709485f, 
    0.29565009f, 0.08041941f, -0.13434184f, 0.01591151f, 0.07657728f, 0.07879333f, 0.19464764f, 0.02805638f, 
    0.07765356f, 0.04958020f, 0.00626062f, 0.07076517f, -0.30594563f, 0.13953072f, -0.05963140f, -0.21472093f, 
    -0.08417182f, -0.20775801f, -0.12225357f, -0.13309741f, -0.06359629f, 0.04317407f, -0.03344531f, 0.03626341f, 
    -0.23540545f, 0.36777237f, 0.18256214f, 0.09766004f, -0.06099258f, -0.02584133f, 0.14425620f, 0.14305165f, 
    -0.03116319f, -0.15333647f, -0.02364873f, -0.05662346f, 0.05078959f, 0.06810973f, 0.17802610f, -0.09409621f, 
    0.06674860f, 0.04507061f, -0.13832635f, -0.02551189f, -0.00317852f, 0.06726336f, 0.06558637f, 0.09109796f, 
    0.04724679f, 0.16686542f, 0.21209353f, 0.00935763f, 0.11855593f, 0.11957899f, -0.00436393f, -0.04920374f, 
    0.08241621f, 0.03212762f, -0.02587044f, -0.29087782f, 0.04226185f, 0.01176004f, -0.05391175f, 0.02440820f, 
    0.08531004f, 0.18916473f, 0.09496105f, -0.03949607f, -0.14881121f, 0.01904335f, 0.11405133f, 0.06890970f, 
    -0.31891367f, -0.11468698f, 0.20109791f, -0.20663300f, -0.10113885f, 0.14028724f, 0.09177028f, 0.00969714f, 
    0.06704397f, 0.19746892f, -0.23454037f, 0.27060550f, -0.23476434f, -0.08663162f, 0.08661060f, -0.05571853f, 
    0.04499245f, 0.05975541f, 0.08615518f, 0.04938387f, -0.02112948f, 0.02311136f, -0.13361099f, -0.18247475f, 
    0.31513944f, 0.18594716f, 0.05072741f, -0.12884195f, -0.01423013f, 0.20688947f, 0.17350869f, 0.10349689f, 
    -0.11785407f, -0.08424562f, -0.15920475f, -0.07464721f, -0.10759855f, 0.13879402f, 0.08449610f, -0.02497239f, 
    -0.08087309f, -0.00664388f, 0.08849214f, 0.02786344f, -0.00981911f, 0.15421124f, -0.02051040f, 0.07832448f, 
    -0.03065465f, 0.10534693f, 0.02398505f, 0.16188240f, -0.06770091f, 0.04340591f, 0.07117910f, 0.01050867f, 
    0.05993670f, 0.14056236f, -0.00540050f, 0.18406883f, 0.29546216f, 0.11609492f, 0.07251769f, -0.09845933f, 
    0.03833859f, 0.02764459f, 0.12125233f, 0.04747574f, -0.04001012f, -0.01524372f, -0.00170276f, 0.07857364f, 
    -0.01140614f, -0.09613666f, -0.17282312f, 0.07143329f, -0.13016477f, -0.04791727f, -0.06605522f, -0.10673250f, 
    0.01499618f, -0.07254109f, 0.00452276f, 0.06655817f, 0.21725552f, 0.00989678f, 0.34544116f, -0.15398537f, 
    0.05663092f, 0.00540449f, 0.06634290f, -0.04171588f, -0.03976793f, -0.01069294f, -0.00582893f, 0.03633231f, 
    0.13796273f, -0.03161609f, -0.06578315f, 0.14918467f, -0.15802312f, 0.22260286f, 0.02260596f, -0.02379908f, 
    -0.01998017f, 0.07236915f, -0.06099454f, 0.24596614f, 0.14532398f, -0.31951660f, -0.03793151f, 0.03245743f, 
    -0.01389237f, -0.00632362f, 0.06914076f, 0.08167230f, 0.10603169f, 0.06669860f, 0.09680840f, -0.05631370f, 
    -0.24959172f, 0.05098638f, 0.07354781f, 0.24363127f, 0.14761348f, 0.03280850f, 0.16845605f, 0.10413877f, 
    0.10367829f, 0.04413078f, 0.21244580f, -0.10676425f, 0.14710779f, -0.07749736f, 0.02379458f, 0.28200182f, 
    0.13195306f, -0.11286903f, -0.04257276f, 0.12291306f, -0.02004440f, 0.11625766f, -0.12376163f, 0.08910792f, 
    0.09929976f, 0.05351601f, 0.08295606f, 0.01726263f, 0.10572149f, -0.07537077f, -0.07738750f, -0.00183703f, 
    -0.16004507f, 0.06752329f, 0.08380295f, -0.06453805f, -0.01786252f, 0.06615403f, -0.05444356f, -0.03735802f, 
    -0.08560205f, 0.03126312f, -0.04914105f, -0.09768410f, 0.05915351f, -0.04177290f, 0.10104675f, 0.14504705f, 
    0.30103680f, -0.23228148f, 0.32466325f, -0.12218790f, -0.06001788f, 0.02546840f, 0.27883258f, -0.06399217f, 
    0.07633773f, 0.06485431f, -0.12429384f, 0.02505445f, -0.12726215f, 0.15989381f, 0.04982239f, -0.02388586f, 
    -0.12489251f, -0.00538214f, 0.05133808f, -0.16943096f, -0.07567394f, 0.06430996f, 0.05176574f, 0.03938956f, 
    0.34298852f, -0.14012918f, -0.22135375f, 0.47669664f, 0.16118924f, -0.03462240f, -0.07820448f, 0.03505301f, 
    0.11371439f, -0.05106798f, -0.05932118f, 0.13424861f, -0.12115063f, 0.34573072f, -0.37732780f, 0.03877298f, 
    0.20046882f, 0.08912121f, 0.02088301f, -0.02502980f, 0.00743104f, 0.08257397f, -0.02945958f, -0.01182037f, 
    0.15459765f, -0.02078701f, 0.14635280f, -0.13944164f, -0.06914990f, -0.15546708f, -0.09812497f, 0.10718857f, 
    0.03818559f, -0.04653925f, -0.05448849f, 0.30331612f, 0.27623630f, 0.12527719f, 0.12337188f, 0.22632523f, 
    -0.13907181f, -0.13060240f, -0.01781813f, 0.09489007f, 0.11362106f, 0.15203813f, 0.11147276f, 0.46654171f, 
    0.08896235f, 0.22933598f, 0.08083578f, -0.01867110f, -0.11863775f, -0.15893963f, -0.17003882f, -0.12557089f, 
    0.01508416f, 0.04677335f, 0.01164990f, 0.05695967f, 0.06204782f, -0.06571073f, -0.07212377f, -0.09168369f, 
    0.04909243f, -0.07557416f, 0.07891518f, 0.14629839f, -0.01733181f, -0.01000468f, 0.24301730f, 0.04593787f, 
    0.00516975f, -0.11005198f, -0.04216797f, -0.24483515f, -0.15644287f, -0.05481971f, -0.07217033f, -0.08637034f, 
    0.00673233f, -0.16805498f, -0.11408565f, 0.10883901f, -0.10657851f, -0.00029953f, -0.08376539f, 0.26751775f, 
    -0.14784898f, 0.05620504f, 0.01559042f, 0.18715319f, -0.08960558f, -0.02780004f, -0.06813075f, -0.03162854f, 
    -0.03196423f, 0.17339210f, 0.02352234f, 0.15186667f, 0.00983610f, 0.04726685f, 0.05149405f, 0.13399233f, 
    -0.09424082f, 0.13108788f, -0.30513567f, 0.25970775f, 0.12825002f, 0.09458692f, 0.14989704f, -0.05923352f, 
    -0.07206254f, -0.04203212f, -0.00290000f, -0.08087483f, -0.00308438f, 0.06561510f, -0.06986409f, 0.04531358f, 
    -0.25452137f, -0.21715663f, -0.04507028f, 0.22625960f, 0.01055188f, 0.02975908f, -0.03988999f, 0.04238278f, 
    -0.03619741f, -0.09462884f, 0.00215203f, 0.03374585f, 0.11799168f, 0.27291024f, -0.07478883f, -0.20877847f, 
    -0.23269609f, -0.26516837f, -0.02399924f, -0.21681120f, -0.11565405f, 0.00393735f, -0.04519638f, 0.04110103f, 
    -0.27125368f, 0.36972362f, 0.08979551f, 0.17954253f, -0.01028960f, 0.19335026f, 0.12557602f, 0.12416555f, 
    -0.17182349f, -0.12179050f, 0.10810193f, 0.02033347f, -0.02399632f, -0.13860896f, 0.14804180f, -0.15050663f, 
    0.01674568f, 0.17193934f, -0.05889334f, 0.01964697f, 0.11600120f, 0.07198944f, -0.09399366f, -0.04288010f, 
    -0.14301443f, 0.10458119f, 0.17843765f, -0.05580545f, 0.02655943f, 0.09524718f, 0.18674697f, 0.09581782f, 
    0.07515490f, 0.12440937f, -0.02151446f, -0.01163564f, 0.08160652f, 0.16111274f, -0.08418074f, -0.03611072f, 
    0.11795188f, 0.09060188f, 0.06765083f, 0.01834903f, -0.12408023f, -0.03262468f, 0.02972869f, 0.09015749f, 
    -0.26448143f, -0.10598662f, -0.12224115f, -0.39360315f, 0.20741728f, 0.02885048f, 0.05246929f, 0.09975655f, 
    -0.13499145f, 0.20955057f, 0.09093103f, 0.17608704f, -0.30497816f, 0.10704605f, 0.21290436f, -0.06377815f, 
    0.06564033f, 0.00961652f, 0.00729003f, 0.05229997f, -0.11494819f, 0.03210856f, 0.06334941f, -0.15163118f, 
    0.42669427f, 0.14927083f, 0.30005518f, 0.07906151f, 0.01260188f, 0.03944353f, 0.05835757f, 0.11555338f, 
    -0.10017423f, -0.02951940f, -0.15185714f, -0.05179587f, -0.02369137f, 0.25536823f, 0.25118613f, 0.08585235f, 
    -0.03961807f, -0.02953654f, 0.08561695f, 0.10413256f, 0.02105496f, 0.20827417f, -0.02188194f, -0.05167036f, 
    0.32706535f, 0.24399064f, 0.14968917f, 0.28447837f, -0.05062368f, -0.09297356f, 0.03747975f, -0.10114508f, 
    0.03544302f, 0.14905867f, 0.05909493f, -0.02479894f, -0.01567926f, -0.18572576f, 0.16574882f, 0.27640027f, 
    -0.10348765f, -0.14461093f, 0.08805916f, -0.08452086f, -0.05005449f, -0.08595778f, -0.06256463f, -0.05323434f, 
    0.16496348f, 0.07144894f, -0.08663336f, -0.06933025f, -0.20203774f, 0.04656392f, -0.00999324f, -0.09215767f, 
    -0.01613166f, 0.00443753f, -0.01045297f, 0.00891559f, 0.20456839f, 0.18576621f, 0.28384957f, -0.03108924f, 
    0.15304080f, 0.04241489f, 0.18876100f, 0.15997128f, 0.17680085f, 0.11492556f, 0.11496536f, 0.05176638f, 
    0.16808519f, 0.13326125f, 0.00357484f, 0.09691308f, -0.01410307f, 0.08127435f, 0.08013854f, 0.09882746f, 
    -0.06238329f, -0.02721540f, -0.15729973f, 0.04763894f, 0.21769585f, -0.12773213f, 0.05652731f, 0.04278784f, 
    -0.04415849f, 0.06557931f, 0.01792605f, 0.16925292f, 0.25700429f, 0.03736668f, 0.01677794f, 0.05937242f, 
    -0.03315070f, -0.04792003f, 0.04742976f, -0.04909493f, 0.04958561f, 0.04885561f, 0.04774750f, -0.04700635f, 
    -0.01512280f, 0.04617890f, -0.01242216f, -0.03788716f, -0.02573616f, -0.05019350f, -0.01259940f, -0.03594406f, 
    -0.02351373f, 0.04453061f, -0.02237878f, 0.01492382f, -0.02395050f, -0.04447030f, -0.04553116f, -0.03825390f, 
    -0.04121384f, 0.01357989f, -0.03993757f, -0.04718136f, 0.02483711f, 0.03581701f, -0.04816239f, 0.01439163f, 
    0.00613954f, 0.02729133f, -0.04645845f, 0.01062765f, 0.01467344f, 0.01389494f, -0.04743598f, -0.03898481f, 
    -0.01928928f, -0.00287458f, -0.04592412f, -0.02013479f, -0.04991389f, 0.05060810f, 0.02738446f, -0.02773893f, 
    0.02615539f, 0.02034557f, -0.04546183f, -0.02907823f, 0.00537866f, -0.02064848f, -0.03380052f, 0.02648024f, 
    0.03653773f, 0.02242666f, 0.04848926f, -0.03543781f, 0.03204859f, -0.03773765f, 0.04948828f, -0.00788826f, 
    -0.02747767f, -0.01385815f, -0.02122539f, -0.04725239f, -0.02503194f, 0.05065281f, 0.01346730f, 0.02119755f, 
    0.03064038f, -0.03539025f, -0.04934409f, -0.04694705f, 0.04504638f, -0.02494236f, -0.01865923f, 0.01194118f, 
    0.01539431f, 0.01720562f, -0.01735597f, -0.04020777f, -0.02874900f, 0.02932181f, 0.00614298f, 0.04076089f, 
    -0.00117253f, -0.02755543f, -0.03364718f, 0.04131212f, 0.01015652f, -0.04247820f, 0.01858265f, 0.01662414f, 
    -0.04721694f, 0.03352356f, -0.00787979f, 0.02107072f, -0.02102625f, -0.00351087f, -0.00830860f, 0.04054275f, 
    0.00535617f, 0.03221975f, 0.01950926f, 0.00533655f, 0.01245434f, -0.00845678f, 0.04589562f, -0.03995619f, 
    -0.00271455f, 0.03046699f, 0.00031884f, -0.00425401f, -0.04739509f, 0.04108346f, -0.02895357f, -0.04125033f, 
    -0.04735272f, -0.01017498f, 0.05056471f, 0.03291028f, -0.04569505f, -0.04505340f, -0.02659043f, -0.00351757f, 
    0.02582007f, -0.01857577f, -0.01518312f, -0.04082903f, 0.03022752f, -0.02733329f, 0.00807711f, -0.00144445f, 
    -0.00780548f, -0.03686291f, -0.05030300f, 0.04784023f, 0.00896164f, 0.03407191f, -0.04359099f, -0.02229269f, 
    0.02622052f, -0.02134277f, -0.04514934f, 0.04281251f, -0.04023154f, -0.01912433f, 0.01554172f, -0.04133099f, 
    0.03895246f, 0.03473032f, -0.00668664f, 0.00166476f, -0.02080249f, -0.01409959f, -0.00276163f, -0.04223542f, 
    0.02902618f, -0.01668996f, -0.04401662f, -0.01761050f, -0.04314189f, -0.00840953f, -0.00641955f, 0.03132892f, 
    0.00941145f, 0.01889223f, 0.02024432f, 0.02984647f, 0.00652652f, -0.02370441f, 0.02422440f, -0.04411922f, 
    -0.02745696f, 0.02208728f, 0.03940621f, -0.01459736f, -0.02101492f, -0.03008778f, -0.03879961f, 0.02762088f, 
    -0.03604802f, -0.03782773f, 0.00398666f, -0.04859471f, 0.03704755f, 0.02490377f, -0.04500600f, -0.01200293f, 
    -0.01704325f, 0.00268801f, 0.04469541f, -0.01181184f, 0.02075448f, -0.04329075f, -0.04251337f, 0.01669045f, 
    -0.01258756f, -0.02131628f, 0.03938086f, 0.03175753f, 0.01272829f, -0.04171233f, -0.03393285f, -0.00807202f, 
    -0.01171208f, 0.01648152f, -0.03403849f, -0.01249311f, -0.02396682f, -0.04841033f, 0.03750812f, 0.00085889f, 
    -0.00434206f, -0.02277452f, -0.04245649f, -0.01440614f, 0.01695997f, 0.03767158f, 0.01239112f, -0.02563953f, 
    0.01211686f, -0.04694754f, 0.03791998f, -0.00276224f, -0.00698360f, 0.00663176f, -0.02692158f, -0.01410830f, 
    -0.05041602f, 0.02014187f, 0.02597854f, -0.03863927f, -0.04706248f, -0.02333749f, -0.02076526f, 0.01592699f, 
    0.02958892f, -0.00819586f, -0.00169511f, 0.01138840f, -0.04129012f, 0.04963666f, 0.01372920f, -0.03574727f, 
    -0.04961829f, -0.01148334f, -0.01275963f, -0.01399947f, 0.00244519f, -0.02647145f, 0.00693787f, -0.04681483f, 
    0.03636337f, -0.02630282f, 0.01445268f, -0.02538889f, -0.02641022f, 0.01511977f, 0.01481238f, -0.03783671f, 
    0.02366572f, -0.00495230f, 0.02452100f, 0.02060027f, -0.03568109f, 0.04066741f, -0.04175936f, -0.02440624f, 
    0.03641302f, -0.04986279f, 0.00639117f, -0.01250227f, 0.02459767f, -0.01997301f, -0.02847381f, 0.04743609f, 
    -0.00586568f, -0.00484827f, 0.00985252f, -0.02322244f, 0.00821313f, 0.02661427f, -0.04326390f, -0.02664539f, 
    0.04063143f, -0.01367951f, -0.02171225f, -0.01428737f, -0.03138117f, -0.04182957f, -0.04358862f, -0.04058655f, 
    0.04548377f, 0.00073232f, 0.04169821f, 0.00469855f, -0.01291446f, -0.00223746f, -0.01426520f, 0.02267881f, 
    0.04146462f, -0.00935484f, 0.01613455f, 0.02326053f, 0.04706607f, -0.04004602f, -0.01304491f, -0.01760916f, 
    -0.01860272f, -0.00355608f, 0.04244484f, -0.04589473f, -0.01273931f, -0.00894325f, -0.00576642f, -0.04311375f, 
    -0.01666868f, -0.01132212f, -0.01042865f, -0.01385380f, 0.04625650f, 0.01240116f, -0.04959618f, 0.02662921f, 
    -0.02137109f, 0.00393675f, -0.02705875f, 0.00938099f, -0.04293770f, 0.04552642f, 0.04584775f, 0.01488282f, 
    0.00859625f, 0.03884220f, 0.03593587f, -0.00065488f, 0.02958243f, -0.02377821f, 0.00446896f, -0.01642921f, 
    -0.03430062f, -0.04345312f, -0.01752967f, -0.01492538f, -0.00226715f, -0.03906390f, -0.03149161f, -0.04280391f, 
    -0.01055317f, -0.03712188f, -0.00581055f, 0.01250199f, 0.02332709f, -0.04119828f, 0.04809035f, 0.02481697f, 
    0.04431435f, 0.03106883f, -0.04383000f, 0.02481622f, -0.02592397f, -0.00440509f, 0.01335031f, 0.02024728f, 
    0.02155599f, -0.02188861f, 0.00122672f, 0.03196977f, 0.03560448f, 0.01715459f, 0.03785961f, 0.00347395f, 
    -0.04105532f, -0.00727413f, -0.01606931f, -0.00982360f, -0.04650453f, 0.03321891f, -0.00153951f, -0.03518157f, 
    -0.01040234f, -0.02479489f, 0.02651188f, -0.03904930f, -0.02031525f, 0.04325339f, 0.00146800f, -0.03060139f, 
    0.01939153f, -0.04965264f, 0.03775139f, -0.05316400f, 0.02966057f, 0.00693951f, 0.01216409f, -0.05039351f, 
    -0.04057771f, -0.01536913f, -0.02747247f, 0.00531964f, -0.01694055f, 0.04242794f, -0.03473788f, -0.01823148f, 
    -0.01353458f, -0.01583524f, 0.04386284f, -0.00963998f, 0.02974888f, -0.02722252f, -0.01495994f, -0.03539567f, 
    -0.01356960f, -0.03152123f, -0.04335386f, 0.01727398f, 0.02572131f, -0.01125631f, 0.01840419f, -0.00865793f, 
    -0.02328793f, -0.02546920f, -0.00854452f, -0.04510396f, -0.03791278f, -0.00865692f, 0.01431179f, -0.01287728f, 
    0.04371853f, -0.04137810f, 0.02862075f, 0.00451130f, 0.03125802f, -0.02378461f, -0.05501771f, 0.00477737f, 
    -0.00907294f, 0.03470100f, -0.04220869f, -0.02298671f, -0.02297486f, -0.03348111f, -0.03576587f, -0.00061036f, 
    0.02471124f, 0.00905638f, -0.01006807f, -0.04097821f, 0.04085870f, -0.01679957f, -0.04408176f, 0.02562873f, 
    -0.03867134f, 0.00793492f, -0.04518840f, -0.02951682f, 0.03541192f, 0.04192453f, -0.04853897f, -0.04194063f, 
    0.04115636f, 0.00771396f, 0.02788733f, 0.03944419f, 0.03145352f, -0.02100309f, 0.03410942f, -0.02868957f, 
    -0.00287247f, 0.02101827f, 0.00826691f, 0.03389196f, 0.02117985f, -0.05708417f, -0.05297491f, 0.01892017f, 
    -0.03433358f, -0.01343883f, 0.01923704f, 0.00635875f, -0.05152454f, -0.03606499f, -0.02319414f, 0.01652477f, 
    -0.03775573f, -0.01477330f, 0.00686702f, -0.04079426f, -0.02477607f, 0.01932450f, 0.02456227f, -0.02802464f, 
    0.03764602f, -0.00204356f, -0.05770090f, 0.02550654f, 0.01286711f, 0.01896672f, 0.03345714f, -0.01588906f, 
    -0.04228569f, 0.01476913f, -0.04214616f, 0.00406767f, 0.02809618f, 0.03993087f, 0.01667320f, -0.01195332f, 
    -0.02172941f, -0.00509238f, -0.01354602f, -0.00866298f, 0.02970509f, -0.04591672f, -0.01159016f, -0.00076921f, 
    0.01423692f, -0.04579289f, -0.03783930f, 0.00750940f, 0.00901400f, -0.01205660f, 0.00513570f, -0.03063584f, 
    -0.05417070f, -0.03354910f, 0.00865965f, -0.00042855f, -0.04249107f, 0.01988940f, 0.01624631f, -0.03649661f, 
    -0.02542585f, 0.01113661f, 0.00375364f, 0.01965767f, 0.01833815f, 0.01429133f, -0.04873674f, 0.00664019f, 
    -0.04994800f, -0.05192418f, -0.03958028f, -0.00380962f, -0.00404370f, -0.02068580f, 0.00744860f, -0.00615783f, 
    0.01546892f, 0.02339161f, -0.02545101f, -0.04036315f, -0.00992617f, 0.01474305f, -0.02348783f, -0.01797653f, 
    -0.00871471f, 0.02246930f, 0.02981772f, 0.01176625f, -0.00654510f, -0.00536068f, -0.02909350f, -0.02002995f, 
    0.01868981f, -0.04972626f, 0.01232067f, -0.01235755f, -0.04137193f, -0.02229854f, -0.02473752f, 0.01612676f, 
    0.03599371f, -0.05642730f, -0.05840440f, 0.03217366f, -0.05467939f, 0.02629316f, -0.02327286f, -0.03630227f, 
    -0.02215437f, 0.03114195f, -0.05419404f, -0.05480595f, 0.04159790f, 0.00614114f, 0.03766951f, -0.02178067f, 
    0.00935761f, -0.02634182f, 0.03452655f, 0.02083912f, -0.03138809f, -0.01508134f, 0.00422324f, -0.00395600f, 
    0.00893262f, -0.04012657f, 0.04442910f, -0.05564286f, -0.02376679f, 0.00982906f, -0.01183941f, 0.02029753f, 
    0.03407457f, 0.00422492f, 0.03397049f, -0.00515245f, -0.02669295f, -0.01509605f, -0.05141311f, 0.00322210f, 
    -0.00435074f, -0.02716114f, 0.03329474f, 0.03898572f, 0.01867042f, 0.04200555f, 0.00194456f, -0.01490590f, 
    -0.05248670f, -0.03202761f, 0.02835849f, 0.00213447f, -0.00887490f, -0.04318482f, -0.01580019f, -0.04784286f, 
    -0.01538352f, 0.03780024f, 0.03132888f, 0.04263220f, -0.02332833f, 0.05418126f, -0.00081777f, 0.02529480f, 
    -0.05850912f, -0.01086944f, -0.04512624f, 0.02260438f, -0.02312965f, -0.00653413f, -0.05181152f, -0.04707418f, 
    -0.00645051f, -0.00947923f, -0.01693811f, -0.03952992f, -0.02015753f, 0.02250568f, -0.03812201f, -0.05575814f, 
    -0.05034863f, 0.04372305f, -0.00728040f, -0.05240531f, 0.02389295f, -0.00201449f, -0.02941700f, -0.03357580f, 
    -0.04297825f, -0.03808198f, -0.00814343f, -0.03600300f, 0.02574553f, 0.03357873f, 0.02744943f, -0.03949127f, 
    0.02828192f, -0.03035358f, -0.03999097f, 0.03117451f, -0.02570713f, -0.02228262f, 0.03492297f, 0.01111824f, 
    -0.02078449f, -0.05910107f, -0.04495939f, -0.05233056f, -0.05557323f, 0.03420723f, 0.01409568f, -0.04010283f, 
    -0.02445468f, -0.05489635f, 0.01067615f, -0.05566830f, -0.04628566f, 0.00372686f, -0.03051138f, 0.02782965f, 
    0.01597235f, 0.03258735f, 0.01348912f, 0.00385032f, -0.00741058f, 0.01153283f, -0.01970468f, 0.02401312f, 
    0.01623855f, 0.02749980f, -0.02355477f, -0.03390533f, -0.02056358f, -0.03077720f, 0.03048988f, -0.01392181f, 
    0.02305854f, 0.02655719f, -0.02792705f, -0.04665210f, 0.03842771f, -0.02485255f, -0.04768351f, 0.03582287f, 
    0.02679714f, -0.03503407f, 0.01134147f, -0.04372545f, 0.02425070f, 0.03932227f, -0.05658129f, -0.03666515f, 
    -0.02745822f, 0.00122607f, -0.01530646f, 0.03200931f, -0.00724137f, 0.02623922f, -0.00444514f, -0.02136717f, 
    -0.00376866f, -0.00293609f, 0.02032859f, -0.00094341f, -0.05756810f, 0.02183052f, -0.02635069f, -0.01684523f, 
    -0.04877149f, -0.00737667f, 0.03585679f, -0.04121069f, -0.03500715f, 0.02027384f, -0.05023352f, 0.01649661f, 
    0.00986960f, -0.04478236f, -0.00199409f, 0.03437581f, -0.04679986f, 0.02451164f, 0.01379117f, 0.02392176f, 
    0.05224345f, -0.03328280f, 0.02180742f, -0.04257230f, 0.02602754f, 0.03460452f, -0.05607475f, -0.00186836f, 
    0.07612657f, 0.26674637f, -0.09157950f, -0.13421594f, -0.06716251f, -0.13985842f, -0.00677179f, 0.06994441f, 
    0.20356490f, 0.05168375f, 0.08998296f, 0.13405944f, 0.12089562f, 0.07918537f, -0.00006799f, -0.26204619f, 
    0.02546381f, -0.01068176f, -0.07706811f, -0.19044995f, -0.17411415f, -0.14310540f, -0.22046685f, -0.22088544f, 
    -0.24359508f, -0.27408254f, -0.14736517f, -0.21211746f, -0.13404088f, -0.06186157f, -0.11062526f, -0.01865513f, 
    0.20482032f, 0.13292429f, 0.01529154f, 0.10035725f, 0.02275467f, -0.02079279f, -0.04024476f, -0.10399564f, 
    -0.03889137f, -0.08541121f, -0.15070216f, -0.24222949f, -0.05651382f, -0.11160908f, 0.06334296f, -0.22113095f, 
    0.10756619f, -0.11358526f, 0.15131484f, -0.09505754f, 0.06975766f, -0.08233017f, 0.05725192f, 0.12243380f, 
    0.08895476f, 0.05919343f, 0.11883170f, 0.12757312f, 0.19088234f, -0.09811650f, 0.01691704f, 0.11741789f, 
    -0.07051695f, 0.08265101f, -0.01043814f, -0.05251076f, 0.15659317f, -0.02046304f, 0.04119304f, -0.12265310f, 
    0.09048597f, 0.29339403f, -0.10564949f, -0.08762534f, 0.09332982f, -0.03018583f, 0.12326068f, 0.00207164f, 
    -0.16150360f, 0.09442138f, -0.08797086f, -0.08168063f, -0.06327535f, 0.11082244f, 0.09159850f, -0.03680909f, 
    0.10527974f, 0.12115651f, 0.15620022f, 0.09873489f, 0.17656778f, -0.02255034f, 0.16966490f, 0.11484738f, 
    -0.12973665f, 0.07493742f, -0.00162584f, 0.03737050f, -0.10506648f, -0.00891455f, -0.03530987f, -0.08025994f, 
    -0.18821722f, -0.09618529f, -0.16209714f, -0.25534290f, -0.09151886f, 0.10123129f, -0.09318396f, 0.31610656f, 
    0.02137200f, 0.19738063f, -0.13073386f, 0.00952734f, 0.09589521f, 0.01484616f, -0.05522648f, 0.04328594f, 
    -0.34953141f, 0.15666509f, 0.12136923f, -0.11547442f, -0.18537346f, -0.24449396f, -0.09990274f, -0.15453383f, 
    -0.12360760f, -0.11893874f, -0.12231062f, -0.04231991f, 0.20405135f, -0.01211920f, 0.17742668f, -0.05132568f, 
    0.02699280f, 0.31050643f, 0.00612014f, 0.06502260f, 0.03068462f, 0.06320842f, 0.04343650f, 0.05860195f, 
    -0.23614570f, -0.12496407f, -0.18666120f, -0.27428550f, 0.09317834f, 0.03090680f, -0.02255271f, -0.23827425f, 
    -0.06465326f, -0.02111729f, 0.11373486f, -0.09976323f, -0.14357789f, 0.05321171f, -0.05464454f, -0.13910975f, 
    0.05356408f, 0.13605659f, -0.02420254f, -0.12780564f, -0.04989270f, -0.06115839f, 0.09818672f, 0.06804037f, 
    -0.14716662f, -0.01236726f, 0.00354309f, -0.06032426f, -0.08360271f, -0.15982252f, -0.02026244f, 0.10558143f, 
    0.07381427f, 0.07593093f, 0.31582671f, 0.10844617f, -0.01612650f, -0.04044306f, 0.17110163f, -0.07888583f, 
    -0.12161918f, -0.17901835f, 0.04426027f, 0.03041285f, -0.03974934f, 0.00318998f, 0.06748305f, -0.06982218f, 
    0.15716836f, 0.15859787f, -0.02216448f, 0.05459608f, 0.03961192f, 0.03501084f, 0.28585944f, -0.00496963f, 
    0.05493346f, -0.00972988f, 0.03604966f, 0.10185892f, -0.54641151f, -0.05375671f, 0.06350454f, -0.13020349f, 
    0.02710660f, -0.07901933f, -0.11274938f, -0.11867347f, -0.12321649f, -0.02678069f, -0.03045987f, 0.01350825f, 
    -0.14560173f, -0.15675227f, 0.20693356f, -0.04145248f, -0.09960841f, 0.03989524f, -0.16352227f, 0.16896026f, 
    0.06929477f, 0.12757386f, 0.14263678f, -0.03701846f, 0.00057988f, -0.11193658f, 0.06568276f, -0.13822764f, 
    0.06417851f, 0.01134665f, -0.10331609f, 0.01499539f, -0.16130456f, -0.13335200f, -0.06877097f, 0.00104231f, 
    0.09315370f, 0.16009063f, -0.03308067f, 0.04701876f, 0.10043566f, 0.09997156f, 0.06281453f, 0.03638937f, 
    -0.01130599f, 0.00015319f, -0.05202886f, -0.29306459f, -0.09244030f, 0.00195964f, 0.00368258f, 0.09761567f, 
    0.10805717f, 0.14872044f, 0.07988130f, -0.06309840f, 0.13569389f, 0.16454296f, 0.13736907f, 0.20841193f, 
    0.14685938f, 0.11872768f, -0.02864254f, 0.14591226f, -0.02238275f, 0.10638609f, 0.15236048f, 0.04882759f, 
    0.18506625f, 0.05897523f, -0.02935909f, 0.04945583f, -0.03463208f, -0.06360752f, 0.03973363f, -0.07363150f, 
    0.13131477f, 0.06898709f, -0.02940879f, 0.15208466f, -0.08503801f, -0.01833538f, 0.01580141f, -0.17474902f, 
    -0.32026684f, 0.00233458f, 0.06061009f, 0.08842224f, 0.00828567f, 0.20721526f, -0.01522036f, 0.17774890f, 
    0.09915116f, -0.02126933f, 0.14509597f, -0.06275900f, 0.18812387f, 0.29254982f, -0.11932030f, -0.00321721f, 
    -0.02810349f, 0.00267694f, 0.16666578f, -0.11307947f, 0.27097768f, 0.04607311f, 0.13519694f, 0.22275098f, 
    -0.19843794f, 0.15673770f, 0.11815416f, -0.02985013f, -0.13907754f, -0.02768162f, -0.17662263f, 0.01109303f, 
    0.24866883f, 0.00343934f, 0.11631421f, 0.31121767f, 0.16144492f, -0.14267403f, 0.20581202f, -0.04469344f, 
    0.09364838f, 0.07344250f, -0.00975058f, 0.01787544f, 0.04243790f, -0.07936067f, 0.05040243f, 0.13010119f, 
    -0.08125491f, 0.05059839f, -0.03574385f, -0.07659286f, -0.23752962f, -0.15817158f, -0.21253544f, -0.20704895f, 
    -0.00104742f, -0.19160198f, 0.09031007f, 0.15820275f, 0.17923135f, -0.01177913f, 0.10080990f, 0.17729278f, 
    0.02322167f, 0.18253675f, 0.04813574f, -0.02409870f, 0.14611951f, -0.02824455f, -0.03504322f, 0.11345795f, 
    -0.12107807f, 0.08344403f, -0.04906213f, 0.10181623f, -0.20266585f, 0.10611162f, 0.09447633f, -0.09326117f, 
    0.03209809f, 0.18207818f, 0.03173614f, 0.32481527f, 0.03069765f, -0.04772159f, -0.32111245f, 0.13791002f, 
    -0.03852423f, 0.01393686f, -0.08821503f, 0.14744675f, -0.05724261f, -0.06912564f, 0.20210510f, 0.10551742f, 
    0.14631131f, 0.16545273f, 0.19061363f, -0.13915721f, -0.13053353f, -0.00880845f, -0.04710170f, 0.00311475f, 
    -0.03400778f, 0.07384103f, 0.04268663f, -0.14536050f, -0.33150116f, 0.07142980f, -0.05211281f, -0.19433367f, 
    -0.01961777f, 0.03284425f, 0.03788450f, 0.09125224f, 0.09826093f, -0.04896043f, 0.01991353f, 0.12203843f, 
    -0.31805569f, -0.23741427f, -0.12070924f, -0.16739115f, 0.19685729f, 0.08726630f, 0.04309180f, -0.00965939f, 
    0.32689589f, -0.02037325f, -0.05343806f, -0.03458005f, 0.17240247f, -0.08032197f, 0.05782386f, 0.05685863f, 
    -0.04227643f, -0.05924164f, 0.09882813f, 0.03161672f, -0.10759195f, 0.14289983f, 0.10129502f, 0.00045292f, 
    -0.28864786f, 0.24319755f, -0.16245884f, 0.01415174f, 0.06482426f, 0.03468605f, -0.13059068f, 0.03638607f, 
    -0.03288119f, -0.05439571f, -0.04264120f, 0.08944040f, 0.13966326f, -0.01368889f, -0.24252324f, 0.19062911f, 
    0.09113155f, -0.02885007f, 0.10868745f, 0.10493790f, 0.07117099f, -0.04552872f, 0.11328053f, -0.08451514f, 
    -0.13401000f, 0.22442620f, 0.31741846f, -0.35460833f, 0.05285070f, 0.02030037f, 0.13633400f, 0.00595893f, 
    -0.00338599f, 0.02349575f, 0.06123865f, -0.03556360f, 0.11721539f, -0.25503346f, 0.38741946f, -0.02605307f, 
    -0.02052000f, 0.08980361f, 0.00081690f, 0.15056114f, 0.05340264f, 0.00217606f, 0.04658033f, 0.06361929f, 
    -0.17189525f, -0.00182495f, -0.06242101f, 0.13756394f, -0.10551760f, 0.11580142f, 0.03056157f, -0.13045073f, 
    0.18285687f, -0.03842277f, 0.14824140f, -0.09698325f, -0.35580054f, 0.05175657f, -0.11783937f, -0.10910592f, 
    0.05783562f, 0.08101022f, 0.08960228f, -0.36495215f, 0.04828810f, -0.03638276f, 0.09821635f, -0.02661656f, 
    -0.44311437f, -0.10094899f, 0.02246719f, -0.14107071f, -0.03985845f, -0.01881672f, -0.08184561f, -0.18047102f, 
    -0.01117192f, -0.14943162f, -0.05801017f, 0.00318097f, -0.09095874f, 0.03728882f, -0.20467645f, 0.18856983f, 
    0.10717571f, 0.21615799f, 0.12003648f, 0.05202628f, -0.13186161f, -0.04333739f, -0.02207524f, -0.03791583f, 
    -0.24581127f, 0.06451724f, 0.01448498f, 0.11906614f, 0.11084437f, 0.02178958f, -0.01112219f, 0.04771319f, 
    -0.00320927f, -0.04387821f, 0.09687917f, -0.00466836f, -0.21862565f, -0.36845160f, 0.06388693f, -0.15552056f, 
    0.18183987f, -0.06061975f, 0.07939249f, -0.10783794f, -0.05685731f, -0.08803091f, -0.01690112f, 0.03726510f, 
    0.02839521f, -0.42518058f, -0.00809132f, -0.30564016f, 0.05147877f, 0.02447963f, -0.06307708f, 0.07600076f, 
    0.16043854f, -0.09864479f, 0.08354843f, 0.06613728f, -0.04621613f, 0.00017879f, -0.03556089f, 0.01545569f, 
    0.04904187f, -0.23354135f, 0.04717963f, -0.01265006f, -0.00253128f, -0.16803282f, -0.00459390f, 0.18485554f, 
    0.11942574f, 0.24323346f, -0.04892375f, -0.12337377f, 0.12388197f, -0.03967959f, 0.09541383f, 0.13474476f, 
    0.05871561f, 0.13621910f, 0.03707878f, 0.00618599f, -0.27429858f, 0.00852776f, 0.11963331f, 0.23441745f, 
    0.05576577f, -0.04475241f, -0.01447391f, 0.08608893f, -0.04650780f, -0.12017764f, -0.05984160f, 0.02886087f, 
    0.47539294f, -0.30289981f, 0.15876240f, -0.05484068f, 0.04387987f, 0.12300552f, -0.16714683f, 0.06377349f, 
    0.06487172f, 0.14048991f, -0.09544882f, 0.00373128f, -0.02946535f, -0.12096334f, -0.10897597f, 0.05753057f, 
    0.17376818f, 0.13840613f, -0.09170603f, 0.02344424f, 0.06128717f, -0.03201085f, 0.07347403f, 0.15654534f, 
    0.11067242f, 0.14074326f, -0.13494100f, 0.13011511f, 0.07568893f, 0.08542180f, 0.05428390f, 0.01650429f, 
    0.09922647f, 0.02955115f, 0.19110775f, 0.00400396f, -0.07074641f, -0.05201170f, 0.01571300f, 0.14000395f, 
    -0.04680789f, -0.04218395f, 0.02338421f, -0.08221522f, -0.09068391f, 0.10461066f, -0.21085910f, 0.03787615f, 
    0.26307750f, 0.17010215f, -0.27073523f, 0.35264522f, 0.06126337f, 0.02907577f, 0.13212062f, 0.00530856f, 
    0.04078002f, -0.13555019f, -0.07219032f, -0.07586825f, 0.47338217f, -0.08415034f, 0.16858938f, 0.24335517f, 
    -0.04122211f, 0.25829247f, 0.01006711f, 0.08178923f, 0.08083634f, 0.05276388f, 0.07912336f, 0.12575896f, 
    0.01467725f, 0.13565251f, -0.10601307f, 0.17434035f, -0.02472625f, -0.01048381f, 0.18848826f, 0.08986761f, 
    0.00652379f, 0.08294615f, 0.02422528f, 0.22308569f, 0.04155660f, 0.18433125f, 0.07804067f, -0.32642138f, 
    0.08727138f, -0.04445428f, 0.04358731f, -0.15667450f, -0.01450480f, -0.12698036f, 0.11614582f, -0.02420664f, 
    -0.17216167f, 0.03229860f, 0.05862029f, -0.38631564f, 0.03285500f, -0.02248565f, -0.08456989f, 0.07231188f, 
    0.13507676f, 0.09120866f, 0.08678371f, 0.19247067f, -0.07504983f, 0.03261835f, -0.03823031f, -0.17653036f, 
    0.13815722f, 0.06973930f, -0.07140501f, 0.03773655f, -0.04967333f, -0.05920537f, -0.08866740f, 0.03187307f, 
    -0.01209302f, 0.09345761f, 0.20883514f, 0.04311679f, 0.07148979f, -0.29396239f, -0.10209834f, 0.08259198f, 
    -0.10435497f, -0.07542277f, -0.06233591f, 0.03749346f, 0.05494357f, 0.24621639f, -0.06610382f, 0.20214823f, 
    0.07584028f, 0.06436995f, 0.03753185f, -0.14018643f, 0.05341399f, 0.03710106f, 0.05271502f, 0.05363264f, 
    -0.31615081f, -0.14779583f, -0.08877226f, -0.03156134f, 0.04597575f, -0.07770007f, -0.04650338f, -0.24558727f, 
    0.01808189f, 0.08057600f, -0.09947819f, -0.00704523f, -0.14884132f, 0.36980799f, -0.32050389f, 0.01721684f, 
    -0.01515275f, 0.03463830f, 0.07856764f, -0.04821091f, 0.04752026f, 0.17295186f, 0.06695199f, 0.17408097f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05004392f, 0.07533576f, -0.02665994f, -0.01115466f, 0.08725581f, -0.12924010f, -0.05858874f, 0.04209087f, 
    0.00428065f, 0.03753728f, 0.07251712f, -0.11245821f, 0.07918750f, 0.15512304f, 0.01503191f, -0.04438598f, 
    -0.05515040f, -0.01667334f, 0.07596239f, 0.08739258f, 0.19655564f, 0.09106895f, 0.09235503f, -0.00299156f, 
    0.10344596f, -0.03306379f, 0.05211338f, 0.18738127f, 0.01351845f, 0.00285016f, 0.16384238f, 0.07059108f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.15987468f, -0.01597508f, -0.05788808f, -0.12738366f, 0.04939125f, 0.16713746f, -0.08120329f, 0.06225486f, 
    -0.02156417f, -0.49636015f, -0.11540005f, 0.32422107f, -0.25350013f, -0.29289097f, 0.15070668f, 0.20714046f, 
    0.16452299f, 0.05651522f, -0.28430438f, 0.05927084f, 0.30239969f, -0.01809666f, 0.14025845f, 0.05547734f, 
    0.27342033f, -0.08466765f, -0.07820833f, 0.17534491f, 0.05583085f, -0.10938257f, 0.05190305f, -0.22677529f, 
    -0.04482938f, -0.13125464f, -0.08354030f, -0.02660813f, -0.18698867f, 0.13196400f, -0.34312057f, -0.01452393f, 
    0.04176434f, 0.33871722f, -0.29594043f, -0.09225033f, 0.15887807f, 0.07018125f, -0.15907095f, -0.20132752f, 
    0.09027069f, -0.11547437f, -0.25660473f, 0.25595388f, 0.15046823f, 0.40736076f, 0.04165185f, -0.07658380f, 
    -0.09225581f, -0.27158478f, -0.04390492f, 0.19604984f, -0.10965469f, -0.00315830f, 0.02952186f, 0.19827098f, 
    0.10168312f, -0.12634225f, -0.12525967f, 0.11611890f, -0.10855440f, 0.40137288f, 0.55040532f, -0.16785087f, 
    -0.09686781f, 0.29276329f, 0.08899768f, 0.37694708f, 0.04589849f, -0.23322661f, 0.06466165f, -0.00656437f, 
    0.17367810f, 0.07791308f, 0.33091941f, -0.07849925f, 0.00131331f, 0.07197583f, 0.29120210f, 0.00177488f, 
    -0.11914278f, -0.47046077f, 0.16154473f, 0.22734821f, -0.15574923f, 0.11991360f, -0.30289349f, 0.07408933f, 
    -0.00385866f, -0.02690471f, -0.06007720f, 0.17490996f, 0.07014094f, 0.04147892f, 0.10739886f, 0.15790629f, 
    0.16507028f, -0.36987007f, -0.36301810f, 0.14007092f, -0.28314596f, 0.03461135f, 0.01920311f, 0.19265246f, 
    0.00019824f, 0.15343022f, -0.03932302f, -0.05371523f, 0.27156648f, 0.36381605f, -0.16728419f, -0.30002362f, 
    -0.40391147f, 0.01942848f, 0.13433470f, 0.10254739f, 0.17187381f, 0.09865701f, 0.34131962f, -0.20809101f, 
    -0.07519451f, -0.03575956f, -0.08318137f, -0.15831159f, -0.01996501f, 0.10945155f, -0.27846983f, -0.06970425f, 
    0.03365189f, 0.48705581f, -0.30995786f, 0.48645601f, 0.44599605f, 0.20150587f, 0.04666379f, 0.33594874f, 
    -0.12188543f, 0.03619150f, 0.19696411f, 0.04554133f, -0.03790627f, 0.15954462f, -0.03124767f, -0.10452487f, 
    -0.22697951f, 0.11640953f, 0.07589255f, -0.02749523f, -0.07297065f, 0.08946915f, -0.14645596f, -0.03935063f, 
    0.07203250f, -0.08297067f, 0.05411693f, 0.04938008f, -0.02775217f, 0.01154007f, -0.01109424f, -0.15700841f, 
    -0.15365063f, 0.23123407f, -0.01954799f, -0.10278460f, -0.09080417f, -0.06020863f, -0.12928876f, -0.30308914f, 
    0.09933408f, 0.17165115f, 0.25703052f, 0.04315085f, 0.01775943f, 0.20546627f, 0.14258896f, -0.12130357f, 
    0.06693646f, -0.05757990f, 0.08327738f, -0.07777923f, 0.02242651f, -0.09674398f, 0.03086887f, -0.10717092f, 
    -0.02599826f, -0.20529743f, 0.15889515f, 0.04451896f, -0.16107233f, -0.01066503f, -0.13024051f, 0.11018547f, 
    0.01694215f, 0.23624870f, 0.02358945f, -0.04478900f, -0.18581934f, -0.09580781f, 0.05463749f, -0.14458643f, 
    0.07265306f, -0.05812461f, -0.03930720f, -0.09198076f, 0.06790179f, 0.04956378f, -0.05495244f, 0.05850527f, 
    -0.16684575f, -0.11031032f, -0.22017354f, 0.06784468f, 0.00041923f, -0.06465354f, -0.23738690f, -0.13646141f, 
    0.15728363f, 0.26101041f, 0.04502076f, -0.16376492f, 0.12682548f, -0.06602541f, 0.19487403f, 0.12637682f, 
    0.11924677f, -0.47558489f, 0.27817258f, 0.12980179f, -0.29507634f, -0.03240065f, 0.09984685f, 0.07716155f, 
    0.14828695f, 0.13492960f, 0.25643146f, 0.22788349f, 0.22881974f, 0.08869510f, -0.04938095f, -0.18653415f, 
    -0.37635013f, 0.19840851f, -0.13654594f, 0.04902574f, 0.00166571f, -0.16932121f, 0.03241162f, -0.14154404f, 
    0.09504945f, 0.12297931f, -0.13388403f, 0.14676178f, -0.18860593f, 0.05980073f, 0.57535899f, 0.13570563f, 
    -0.06623966f, 0.14145011f, 0.19408545f, -0.10942074f, 0.37677097f, -0.16092321f, 0.14091998f, 0.20025189f, 
    -0.09419673f, -0.09262098f, 0.32696417f, 0.27992982f, 0.28020620f, -0.18246531f, 0.22104590f, -0.22043414f, 
    -0.11425632f, -0.02456236f, -0.29453555f, -0.26666078f, 0.13722287f, 0.10893577f, -0.28855672f, 0.33567068f, 
    0.02807697f, -0.20241278f, 0.08802595f, -0.08443723f, -0.22700538f, 0.33451474f, -0.18073617f, -0.15006983f, 
    -0.13453403f, 0.17915842f, 0.18799657f, -0.17676768f, 0.09240359f, 0.14766005f, 0.11235358f, -0.23553887f, 
    -0.03869456f, 0.11690976f, 0.25466675f, -0.66874474f, 0.13200693f, 0.35100436f, 0.24354805f, -0.25715363f, 
    0.08531203f, -0.00742893f, 0.25786489f, -0.17574231f, -0.12577559f, 0.16380551f, 0.50346226f, 0.38558090f, 
    -0.09295388f, 0.12522650f, -0.01880763f, -0.15195788f, 0.04870579f, 0.00596919f, 0.49193668f, -0.15242258f, 
    0.07303643f, 0.19923267f, -0.03057346f, -0.11740203f, -0.05828343f, -0.00918570f, -0.05707609f, 0.14917503f, 
    0.16205420f, 0.10122809f, -0.28550339f, -0.27773830f, -0.03366806f, 0.18788917f, 0.19269286f, 0.34946963f, 
    -0.06171351f, -0.15804842f, -0.08174568f, 0.15368572f, 0.17617787f, -0.05615288f, -0.14740096f, 0.22753528f, 
    -0.02693426f, -0.21454187f, 0.08778561f, 0.04127338f, -0.10057720f, 0.21081538f, 0.48939458f, 0.03631153f, 
    -0.06928096f, -0.22188410f, 0.30121717f, -0.08744905f, -0.12873639f, -0.19056952f, 0.06954160f, 0.00287900f, 
    0.10525009f, 0.06535471f, -0.00143873f, -0.11566086f, -0.00926695f, -0.17269693f, 0.29164335f, 0.38989425f, 
    0.51878649f, -0.12982723f, 0.18089578f, 0.12115769f, 0.04671264f, 0.16152973f, -0.23274826f, 0.20822512f, 
    0.09395583f, 0.15570271f, -0.15031065f, 0.03407905f, -0.02042142f, 0.01670295f, -0.05771424f, -0.04100167f, 
    -0.01202640f, 0.31722397f, 0.23845838f, 0.03690179f, 0.42153487f, 0.24338017f, -0.07737265f, -0.20692971f, 
    -0.05746119f, 0.04114420f, 0.39601237f, 0.26964486f, -0.18972242f, 0.26897234f, -0.13208444f, -0.11673330f, 
    -0.37721875f, 0.05315075f, 0.25685942f, 0.02441343f, 0.06055752f, 0.05296653f, 0.22883746f, 0.13200825f, 
    0.08786946f, 0.24242157f, -0.10836930f, -0.12601613f, 0.34474945f, -0.38823050f, 0.34510663f, 0.02703318f, 
    -0.13434978f, 0.41633070f, 0.05681317f, -0.22330014f, 0.05196738f, 0.18508656f, 0.16971822f, 0.24323268f, 
    -0.07876686f, -0.01241447f, -0.08601882f, -0.37119752f, -0.01121747f, 0.09385791f, 0.00691308f, -0.22771169f, 
    0.02278471f, -0.34665614f, -0.20449176f, -0.04891826f, 0.07114304f, 0.12182730f, 0.33783278f, 0.33057612f, 
    0.06549409f, 0.29927722f, 0.11092506f, -0.08631675f, 0.31132632f, -0.04548533f, 0.05619268f, -0.01180894f, 
    0.04661129f, -0.21342607f, 0.14016737f, -0.35434553f, -0.03614413f, 0.15058035f, 0.06570461f, 0.12466080f, 
    -0.14080924f, -0.05568141f, -0.14732480f, 0.03663872f, 0.06308208f, -0.01013056f, -0.04022103f, 0.34809744f, 
    0.01946046f, -0.28293431f, 0.12171683f, 0.42641157f, -0.13369897f, -0.15343541f, -0.03646841f, -0.00801931f, 
    -0.02183323f, -0.11184146f, -0.14833802f, -0.07618776f, 0.03062263f, -0.15903366f, 0.01472493f, -0.03045535f, 
    -0.06208589f, 0.05758717f, -0.05492713f, 0.10334896f, -0.09498496f, -0.04111836f, 0.16279081f, 0.08888449f, 
    0.11671001f, -0.17617865f, -0.08281598f, -0.06015011f, -0.11645838f, -0.11530355f, 0.10305368f, -0.14378054f, 
    0.00929471f, 0.00338289f, -0.13688393f, -0.04425503f, 0.08612417f, 0.15919384f, -0.04967472f, -0.07207435f, 
    0.00873029f, -0.08898224f, 0.09796318f, 0.05860901f, 0.16270302f, -0.01917137f, 0.20932062f, 0.01706528f, 
    0.08642940f, 0.26131263f, -0.26836345f, -0.06482215f, 0.08144321f, -0.10460908f, -0.02672389f, 0.15882891f, 
    -0.11901135f, 0.15025568f, -0.17425159f, 0.18882275f, -0.15851834f, 0.12429324f, 0.15409674f, -0.02784295f, 
    0.07799141f, -0.29821062f, -0.26295522f, 0.00526224f, 0.11091638f, -0.11713301f, -0.18080963f, -0.05991932f, 
    0.11250839f, 0.22326607f, -0.04781520f, -0.16336045f, 0.24731122f, -0.25790170f, -0.01571662f, 0.13380592f, 
    -0.13030709f, -0.41480714f, -0.38464576f, 0.15291429f, -0.34536865f, -0.23268084f, -0.00623904f, 0.45267540f, 
    0.11673807f, 0.01650812f, -0.14265257f, -0.31553632f, 0.10856825f, 0.18513143f, -0.18976025f, 0.05669704f, 
    -0.01853079f, 0.29781559f, 0.07190745f, 0.05464000f, -0.03268161f, 0.08070689f, 0.19498532f, 0.23916243f, 
    -0.17234288f, 0.25160247f, 0.16305998f, 0.03970981f, 0.43499053f, -0.29643229f, 0.11968659f, -0.16074288f, 
    0.14103146f, -0.33092111f, 0.33868358f, -0.16527045f, -0.22260278f, 0.08906944f, -0.12191117f, 0.04758373f, 
    -0.01154079f, -0.17323835f, 0.24547911f, -0.11679818f, 0.36296713f, -0.21608070f, 0.18382129f, -0.12507075f, 
    0.28191072f, -0.24487123f, -0.10875886f, -0.04199458f, -0.02606096f, -0.06383000f, -0.19142865f, 0.16796766f, 
    -0.14319688f, 0.16605708f, 0.15268895f, -0.10877699f, -0.04877249f, -0.11072119f, -0.29071662f, 0.04872190f, 
    -0.17408441f, 0.10062981f, -0.31119892f, -0.19031805f, 0.14936227f, -0.15288413f, 0.00227435f, -0.17408781f, 
    -0.08800040f, -0.16272455f, 0.04883660f, 0.18146470f, 0.29348484f, 0.20920235f, 0.15004185f, 0.01911022f, 
    -0.29382658f, 0.10489298f, 0.24844155f, 0.21308914f, -0.02621865f, 0.03477907f, 0.03976012f, -0.32511708f, 
    0.16270196f, -0.03937482f, -0.18189178f, -0.07113608f, 0.03431785f, -0.06013801f, 0.04299004f, -0.04929765f, 
    -0.06929083f, -0.05502833f, -0.05386484f, -0.00494754f, -0.12182585f, -0.13270172f, -0.04928964f, -0.13600381f, 
    0.12527007f, -0.09984731f, 0.00276214f, 0.06810234f, -0.03793602f, 0.11321484f, -0.05673273f, -0.02953462f, 
    -0.16860712f, -0.16047618f, -0.08168837f, -0.20386006f, 0.05471658f, 0.17461477f, 0.03464833f, -0.00717167f, 
    -0.01023108f, 0.24014999f, 0.04197187f, 0.14276306f, -0.07709805f, -0.20371763f, -0.03532181f, -0.11431308f, 
    -0.10084925f, 0.06610909f, -0.53717220f, -0.34080353f, 0.16516623f, 0.35018623f, -0.06393466f, -0.20329767f, 
    -0.08798620f, -0.14644152f, -0.62115788f, 0.26187798f, 0.18182451f, 0.13460863f, -0.25632638f, 0.00183887f, 
    0.29439601f, -0.01069343f, -0.06377715f, 0.10460972f, 0.11670785f, 0.14440536f, -0.10768316f, 0.10275063f, 
    0.14502284f, -0.07102390f, 0.10576050f, -0.10600322f, 0.27930582f, -0.08239946f, -0.34278849f, -0.11287975f, 
    -0.11247939f, 0.12630238f, 0.32349679f, 0.12329441f, 0.15231627f, 0.19446453f, -0.06844462f, -0.15227428f, 
    -0.11834648f, 0.11240885f, -0.03043744f, 0.06390613f, 0.07370871f, -0.16255583f, -0.04524053f, 0.14624363f, 
    0.76615936f, -0.35113713f, -0.07677173f, 0.34403691f, 0.12581177f, -0.10300750f, -0.04031910f, 0.22547233f, 
    0.14779839f, -0.18176289f, 0.12871845f, 0.12326775f, -0.10971338f, 0.23426753f, -0.19234489f, -0.03148570f, 
    0.12981977f, -0.38261789f, -0.18195921f, 0.16568834f, 0.08273008f, -0.16311169f, 0.13945012f, 0.29479453f, 
    -0.01891493f, 0.05231258f, -0.14232858f, -0.39867982f, 0.21664502f, -0.17022698f, 0.09554163f, -0.05691788f, 
    0.64636320f, 0.05602975f, -0.11733137f, 0.11143801f, 0.00823587f, 0.04783627f, 0.04366843f, 0.42403126f, 
    -0.01522317f, 0.11788134f, -0.16087094f, -0.09383657f, -0.12189229f, 0.21216229f, -0.24309544f, 0.13351209f, 
    0.05649834f, 0.31692913f, -0.15339871f, 0.22861704f, 0.23830262f, -0.16286258f, -0.00739986f, 0.05813749f, 
    0.01017920f, -0.04763199f, 0.23979159f, -0.37126410f, -0.04731293f, -0.11647639f, 0.31408101f, -0.17606078f, 
    0.15971608f, 0.12246352f, 0.15916337f, 0.00235488f, 0.14717907f, 0.07611974f, -0.00994200f, 0.00197360f, 
    0.05545915f, 0.20493312f, 0.12143511f, -0.05556376f, 0.08407406f, -0.11457223f, -0.24622968f, -0.10736438f, 
    0.16531755f, -0.38717887f, 0.28883240f, 0.13503584f, -0.21282655f, 0.04782028f, 0.08726855f, 0.16758348f, 
    -0.06775223f, -0.07224569f, 0.35134357f, 0.05511614f, 0.00257275f, 0.25315166f, -0.21394956f, -0.22170404f, 
    -0.21130538f, -0.19620155f, 0.21543215f, 0.20009233f, -0.06627990f, 0.00726078f, 0.33640796f, 0.15322185f, 
    0.08516391f, -0.09733320f, -0.06571410f, 0.16498142f, 0.15749730f, -0.07668126f, -0.28658199f, 0.00492693f, 
    -0.11249728f, 0.21367107f, 0.00694944f, -0.06230587f, 0.31336629f, -0.06488521f, 0.01329327f, -0.29459867f, 
    0.15928251f, 0.14122568f, -0.14068092f, 0.28324744f, 0.28177679f, -0.17299798f, 0.28765106f, 0.19308288f, 
    0.13181804f, -0.12985669f, 0.09087995f, 0.26665863f, 0.15040845f, 0.00014949f, -0.11359195f, -0.30891857f, 
    -0.06789658f, -0.02511515f, 0.00895402f, -0.11199872f, -0.17932785f, -0.03324107f, 0.33010557f, 0.02994066f, 
    -0.02955501f, 0.32363021f, -0.04514994f, 0.35200894f, 0.34029269f, -0.24809846f, 0.07449190f, 0.19953732f, 
    -0.08417410f, 0.16858722f, -0.03358938f, -0.27373925f, 0.12504150f, 0.12429059f, 0.33101344f, -0.07158532f, 
    0.03462150f, -0.39294335f, -0.01421587f, -0.15686390f, -0.04932652f, 0.03273798f, -0.53593582f, 0.03483776f, 
    -0.07515831f, 0.11178315f, -0.13786906f, -0.02510709f, 0.02247668f, 0.07857061f, 0.13533732f, 0.00928522f, 
    -0.00542942f, -0.38238990f, 0.03343793f, -0.17907628f, 0.15340902f, -0.14319424f, -0.14205825f, 0.20445950f, 
    -0.13316929f, -0.12722860f, -0.28305835f, -0.28402156f, -0.04133340f, 0.32616580f, -0.17530559f, -0.00562094f, 
    0.00696317f, 0.22930899f, 0.29984668f, 0.15776032f, 0.10925702f, -0.13850699f, 0.61097395f, 0.19080694f, 
    -0.13795844f, 0.16712923f, 0.12398817f, 0.12657186f, -0.06114993f, 0.29605633f, -0.20398866f, -0.16583337f, 
    -0.04139402f, -0.19636762f, 0.06089944f, 0.38843033f, -0.17755494f, -0.08939447f, 0.10900064f, -0.01421442f, 
    -0.07831170f, -0.08440625f, 0.13110648f, 0.03994564f, 0.26688921f, -0.13826478f, 0.33715004f, 0.20756742f, 
    -0.45567095f, -0.34489772f, 0.02270837f, 0.20927078f, 0.17044824f, 0.00736149f, -0.17764123f, -0.15244621f, 
    -0.04815954f, -0.08162671f, 0.13377960f, 0.16706857f, 0.13864721f, 0.01024363f, 0.12470603f, 0.15502451f, 
    -0.03290620f, 0.09341624f, -0.17381459f, 0.38474637f, 0.29742762f, -0.03352413f, 0.15989861f, 0.38315034f, 
    0.10584602f, -0.08996224f, 0.16168502f, -0.06157802f, 0.06804478f, -0.02880230f, 0.09835181f, -0.53738892f, 
    0.07412495f, -0.18456246f, -0.28622353f, -0.23586412f, 0.00793339f, -0.03721841f, 0.03550138f, 0.47162265f, 
    -0.08109909f, -0.13425799f, 0.17205457f, 0.09160090f, 0.26635078f, -0.16618279f, -0.63527119f, 0.14859615f, 
    0.07590412f, 0.52995956f, 0.20949353f, 0.04702326f, 0.32811791f, 0.19009615f, 0.00801361f, 0.09653586f, 
    -0.09618098f, 0.07698832f, 0.19766223f, -0.13447492f, 0.29651916f, -0.41235104f, 0.12535627f, 0.15389553f, 
    0.28077880f, 0.21639131f, -0.17144315f, -0.20302223f, 0.00944574f, -0.06029556f, 0.10063455f, 0.24691635f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.13092837f, -0.11567133f, 0.10199024f, -0.01474642f, -0.03602246f, -0.05058738f, -0.09349344f, 0.01548087f, 
    0.01321667f, 0.11876003f, 0.14456418f, 0.12938887f, 0.02278144f, 0.14075126f, 0.12416738f, -0.14525932f, 
    0.10702696f, -0.12110408f, 0.20346797f, -0.05472951f, -0.21262255f, 0.06595829f, 0.24562292f, 0.08185165f, 
    0.07549288f, 0.18963821f, 0.00371747f, 0.04253086f, 0.11886108f, -0.14356148f, -0.00595282f, -0.07584203f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.11336159f, 0.23858446f, 0.20243926f, -0.02373948f, 0.14350499f, 0.00522073f, -0.02489929f, -0.30743206f, 
    0.06744382f, 0.27191922f, 0.02402953f, 0.12254678f, 0.16975783f, -0.23119567f, -0.47248754f, -0.23420519f, 
    0.00126558f, -0.27579096f, -0.81019336f, 0.11785096f, -0.10598885f, -0.47737953f, -0.50784445f, 0.09962818f, 
    0.11175705f, -0.19664317f, -0.06388423f, 0.31072509f, 0.18691650f, 0.01052662f, -0.05596386f, -0.43074298f, 
    -0.08292351f, 0.43229121f, 0.21895751f, 0.03785976f, -0.14701936f, 0.17611952f, -0.08573598f, -0.00790761f, 
    -0.25872359f, 0.31999853f, -0.22462285f, 0.04240825f, 0.26535046f, -0.15898518f, 0.12273631f, -0.12583382f, 
    -0.05908968f, -0.33921725f, -0.12921485f, 0.22570550f, -0.12788484f, 0.33706805f, 0.14975169f, -0.35326043f, 
    -0.10443173f, 0.18184096f, 0.08508509f, -0.35738450f, -0.01707634f, 0.09716094f, -0.80965799f, -0.27606702f, 
    0.03049009f, -0.20213641f, -0.09529176f, -0.35322818f, -0.64082175f, -0.17549413f, -0.09406887f, -0.23070256f, 
    -0.02851758f, 0.17227550f, 0.09741402f, 0.33579880f, -0.07356060f, 0.28309336f, 0.06636078f, -0.15490799f, 
    -0.18240540f, -0.07408818f, 0.18653305f, -0.33638659f, 0.08956680f, -0.67150569f, 0.19190624f, 0.21510206f, 
    -0.13236615f, 0.14703374f, -0.11792950f, -0.06453798f, 0.24692787f, -0.00635729f, 0.02465115f, -0.11436446f, 
    0.24479578f, 0.09144856f, 0.24237104f, 0.21044721f, 0.00660574f, -0.24333967f, -0.28869131f, 0.17947179f, 
    0.07676580f, -0.22972091f, 0.30007604f, 0.11736755f, -0.37038901f, -0.06602165f, -0.12016043f, -0.03591132f, 
    -0.09052700f, 0.34651461f, -0.03885486f, -0.24752125f, 0.01620633f, -0.69261771f, -0.30220997f, 0.18975626f, 
    -0.19158278f, 0.03306299f, -0.35946074f, 0.15247636f, -0.08068248f, 0.10698675f, 0.09546182f, -0.43010706f, 
    0.15608168f, -0.32263505f, 0.24104169f, -0.21212900f, 0.21481375f, -0.07634306f, -0.28213903f, 0.07126152f, 
    0.07276142f, -0.17741294f, -0.35698614f, 0.14263615f, 0.05780656f, -0.51990527f, -0.18740319f, -0.15703359f, 
    0.02127533f, -0.26726231f, -0.05828176f, -0.16974849f, 0.07436918f, 0.42453441f, 0.09107445f, 0.10340671f, 
    0.12948777f, 0.04136296f, -0.13457043f, 0.17864069f, -0.41810662f, 0.14572148f, 0.09687067f, 0.10706452f, 
    -0.13928503f, 0.22125930f, -0.11712626f, 0.08827690f, 0.18550743f, 0.09593344f, -0.15199073f, 0.20900083f, 
    0.12418183f, 0.23665830f, -0.60091102f, -0.56923735f, 0.25421458f, 0.05786514f, -0.30394867f, -0.02470093f, 
    -0.05691291f, 0.14829484f, -0.07486857f, 0.02923233f, 0.09433033f, -0.24113861f, -0.16823095f, 0.02966160f, 
    0.17464598f, 0.18963762f, -0.14660519f, -0.17179564f, 0.01606627f, -0.06880464f, 0.08994136f, 0.23330820f, 
    0.21206166f, -0.15603977f, -0.86123055f, -0.33907297f, -0.53228980f, 0.05693496f, -0.21284616f, -0.04404078f, 
    0.19948892f, -0.65038449f, -0.12918496f, 0.23564765f, -0.21952315f, -0.13718307f, 0.13850270f, -0.00601785f, 
    -0.22746788f, 0.03564897f, 0.22785620f, 0.04578999f, 0.09965427f, -0.04848263f, 0.23418309f, 0.25583270f, 
    -0.54788411f, -0.23789188f, 0.15917142f, -0.55277115f, 0.04182479f, -0.24547911f, -0.07822208f, 0.24674352f, 
    -0.62830585f, 0.11685024f, -0.05199066f, -0.28210163f, 0.25438789f, 0.10897698f, -0.12754396f, -0.19662821f, 
    0.21863770f, -0.50300425f, 0.19078599f, -0.34130523f, 0.22167076f, 0.34950921f, 0.15889484f, -0.11176921f, 
    0.31684873f, -0.31636125f, -0.01236249f, -0.34190574f, 0.14105828f, -0.00005148f, 0.22023715f, -0.46031788f, 
    -0.39616531f, -0.12548007f, -0.02076853f, 0.03161740f, -0.13840774f, -0.56541252f, 0.49876440f, 0.08284447f, 
    -0.06425873f, -0.17805767f, -0.50050968f, 0.12132942f, -0.12857139f, -0.09944852f, 0.09236293f, -0.01573678f, 
    -0.19182885f, -0.26049432f, 0.32624373f, 0.06181788f, 0.09953895f, 0.33533052f, 0.09767957f, -0.10802477f, 
    -0.11814646f, 0.42927384f, -0.06180047f, 0.09446996f, 0.06905760f, 0.02314558f, -0.29290468f, -0.31689283f, 
    -0.11190169f, 0.11895754f, -0.35484430f, -0.28302020f, 0.41169965f, -0.60543573f, -0.22341326f, -0.34296688f, 
    -0.07263716f, 0.29913819f, -0.09445760f, -0.60002375f, -0.09214991f, -0.02009105f, 0.16138002f, -0.57105470f, 
    0.11807083f, -0.06818984f, 0.22854778f, 0.03300160f, -0.28182545f, 0.04728964f, -0.01306601f, -0.22118267f, 
    0.15525341f, -0.37842900f, 0.02292295f, 0.15158148f, 0.07777682f, -0.03113332f, 0.14962494f, -0.00811609f, 
    0.21937750f, -0.43218341f, 0.23658019f, 0.29742649f, -0.64834708f, 0.05655266f, -0.04688727f, 0.28064060f, 
    0.46259412f, -0.01160536f, -0.22802351f, 0.34226513f, 0.03325596f, -0.35182518f, -0.29643622f, 0.09449151f, 
    -0.76748729f, -0.21415614f, -0.35021266f, -0.38874957f, -0.37725404f, -0.23114261f, 0.04158695f, -0.05999617f, 
    0.15927121f, 0.30117205f, -0.16157085f, 0.24312034f, 0.05203502f, -0.86363673f, 0.06265958f, 0.16346483f, 
    0.05062802f, 0.03770035f, 0.22374710f, -0.40059683f, 0.23582661f, 0.32290307f, -0.30559051f, 0.02350000f, 
    0.04639546f, -0.40860519f, 0.15543658f, -0.04115978f, -0.46244955f, -0.14828081f, -0.37491295f, 0.42084241f, 
    0.38860601f, -0.65888435f, -0.03054225f, -0.08823319f, 0.02624599f, 0.03931616f, 0.17838287f, -0.09498291f, 
    -0.17496492f, -0.16458948f, 0.33593324f, 0.24498087f, -0.02568469f, -0.37556782f, -0.21548116f, -0.67687654f, 
    -0.15826859f, -0.01454094f, 0.20550135f, 0.00566071f, -0.29741243f, 0.32994175f, -0.41166463f, -0.24254850f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.06659716f, -0.02430514f, -0.03621231f, -0.05722115f, 0.01028952f, -0.13627212f, 0.22423287f, -0.07004118f, 
    -0.02116844f, -0.15076345f, 0.00220285f, 0.09840135f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
