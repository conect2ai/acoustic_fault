#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.59029174f, 1.38224876f, -0.30299038f, -1.04832435f, -0.46303609f, -0.70636219f, -0.53612673f, -0.31657240f, 
    -0.33028436f, 0.04465849f, -0.49427995f, -0.58302695f, 0.90473342f, -0.37476668f, -0.89479452f, 0.36592862f, 
    -0.03776029f, 0.75984347f, -1.33814335f, -0.90686285f, -1.02333081f, 0.01770157f, -0.62976187f, -0.99318033f, 
    -0.30159536f, -0.40008476f, -0.64051425f, 0.99804187f, 0.66436875f, -0.56604177f, 0.40631479f, -0.54801953f, 
    0.64884001f, -0.67870516f, -0.22664577f, -0.81096870f, 0.33366206f, 0.04342904f, 0.30177647f, 0.19028743f, 
    0.86860746f, -0.23535772f, 0.12890308f, 0.13367902f, 0.55123252f, 1.06310630f, -1.52408254f, 0.49998933f, 
    -0.45682842f, -0.02654913f, 0.55392796f, 0.36673793f, -0.33703101f, -0.27327380f, -0.69604450f, -0.75710034f, 
    -0.29708630f, -0.65430290f, -0.67153394f, 1.10702491f, 0.22674645f, 0.21792409f, 0.69246995f, -1.49738383f, 
    -0.96731144f, 1.28416109f, -0.43579802f, -1.28015113f, -0.92987186f, 0.67059761f, -0.07844070f, 0.43834487f, 
    -0.26840171f, -0.48014233f, 0.56968445f, -0.99860620f, -0.97671580f, -0.81455028f, 0.20547417f, -0.90916491f, 
    -1.10268652f, 0.67163217f, 0.81392050f, 0.61878389f, -0.13232914f, 0.43695003f, -0.44491407f, -0.29377165f, 
    0.10936920f, -0.04944174f, 1.13270962f, 0.50323939f, -1.09240544f, 0.04023618f, -0.65825993f, -1.07261086f, 
    0.69777215f, -0.00509468f, -0.01855180f, 0.56546444f, -1.46917069f, -0.42968342f, -1.30873120f, -0.90185153f, 
    -0.88692951f, -0.27628151f, -0.22065406f, 0.55988097f, -0.58019537f, -0.33677453f, -0.79285342f, 0.63859761f, 
    0.22481699f, -0.64156938f, 0.62760973f, 0.82519442f, 0.15470287f, 1.43883276f, -0.37281060f, -0.60376453f, 
    1.28081810f, 0.55685157f, 0.24606848f, -0.24537621f, -0.22980216f, -0.21708001f, -0.54160649f, -1.76718521f, 
    -1.34852660f, 0.76810122f, 1.20097899f, 0.70787233f, 0.25107542f, -0.21833326f, -0.03693726f, 0.70150006f, 
    1.05527031f, -0.82217216f, -0.83332837f, -0.25223142f, 0.28031799f, 0.34180820f, -0.05527703f, 0.19075446f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02050978f, 0.69598597f, -0.26354027f, 0.29142833f, 0.22988376f, 0.25890899f, 0.70231628f, 0.31918558f, 
    0.17118271f, -0.15282430f, 0.37729672f, 0.28896070f, 0.12652835f, 0.19327800f, 0.47847232f, 0.31887603f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.30986819f, 0.34824538f, 0.14812903f, -0.08786297f, -0.52574968f, -0.25443852f, -0.33102086f, -0.37108481f, 
    -0.16107933f, 0.00251660f, -0.00839415f, -0.01097745f, 0.01260298f, 0.04800726f, 0.10812449f, 0.11269227f, 
    0.20962574f, 0.02035208f, 0.16272812f, 0.15636121f, 0.20670705f, 0.26636145f, -0.37074491f, -0.15729956f, 
    -0.07210314f, -0.08343408f, 0.01341924f, 0.06480038f, -0.19158028f, -0.20561805f, -0.02366208f, -0.19375747f, 
    -0.00313985f, -0.04407692f, -0.02296238f, -0.09102026f, -0.11829969f, -0.12147949f, -0.06080007f, 0.03116542f, 
    0.60742456f, 0.41909447f, 0.09311529f, -0.33470568f, -0.05697217f, 0.31378928f, 0.28642240f, 0.24120575f, 
    0.09208888f, 0.07799771f, 0.00593254f, 0.01390418f, 0.01883311f, -0.08131796f, -0.01577672f, -0.03137437f, 
    -0.14541638f, -0.15641601f, -0.18112305f, 0.04958956f, -0.50887698f, 0.18238680f, -0.29119584f, 0.36120099f, 
    -0.10647593f, -0.01328103f, 0.03057821f, -0.01908013f, 0.02379681f, 0.08413504f, 0.03451523f, 0.05290829f, 
    -0.01765387f, 0.00104380f, 0.07166493f, 0.01341366f, -0.01411731f, 0.05114096f, 0.09359406f, -0.19380076f, 
    0.00501736f, -0.07213110f, 0.00974377f, 0.03376835f, 0.07831367f, -0.05399106f, -0.02648058f, -0.00441520f, 
    0.06542306f, 0.00077957f, -0.28951880f, -0.24517269f, -0.37967417f, -0.16771923f, -0.48668700f, -0.11979336f, 
    0.00521411f, 0.00890309f, -0.02503241f, -0.03322604f, -0.12463149f, -0.83237791f, -0.24125183f, -0.52538615f, 
    -0.17085044f, -0.20340577f, -0.13699251f, 0.17968276f, -0.21998662f, 0.11547136f, -0.04402832f, -0.08503813f, 
    -0.24268559f, 0.05551912f, 0.12204954f, 0.06323198f, -0.10115007f, -0.11953219f, -0.21315823f, 0.06697119f, 
    0.16329946f, 0.24181102f, 0.24942660f, -0.17220387f, -0.07783452f, 0.05646188f, 0.01745365f, 0.10582885f, 
    -0.23444711f, -0.27469641f, -0.21611957f, -0.24349661f, -0.07121195f, 0.04188429f, 0.00278793f, -0.08375052f, 
    -0.13039094f, -0.03416846f, -0.01424352f, -0.10373656f, 0.54666567f, 0.58628762f, 0.27477714f, -0.83166641f, 
    -0.02847800f, 0.03936800f, 0.05972856f, 0.07926137f, 0.06360263f, 0.03369446f, 0.17920825f, -0.11544111f, 
    -0.01296348f, -0.02610324f, -0.05870328f, 0.03570096f, -0.00929787f, -0.11812585f, 0.02243631f, -0.01265517f, 
    0.24716179f, 0.42344308f, 0.25224718f, -0.70993340f, 0.11098691f, -0.02216470f, 0.19022705f, -0.01537343f, 
    -0.15526423f, 0.03846206f, 0.03236333f, -0.09422959f, -0.07496592f, -0.05171182f, 0.01812593f, -0.12783030f, 
    -0.18067288f, -0.01921545f, 0.06388149f, -0.05173576f, -0.07113355f, -0.04259501f, -0.14389466f, 0.04416731f, 
    0.13169476f, 0.02211996f, 0.03673230f, -0.01467643f, 0.04580020f, 0.10715265f, -0.04280531f, 0.04935925f, 
    0.04341815f, 0.07218295f, 0.10494293f, -0.05327610f, 0.19727494f, -0.04584813f, 0.00685777f, -0.03122945f, 
    0.15285257f, 0.05304272f, -0.53025186f, -0.04401573f, -0.14582464f, -0.18009523f, -0.07153664f, 0.08121572f, 
    0.00953905f, -0.01641272f, -0.13622099f, 0.01037506f, -0.03883280f, -0.09764483f, -0.14399192f, -0.07622685f, 
    0.02332119f, -0.15536354f, -0.17575324f, -0.08101988f, 0.23210180f, 0.49306586f, 0.15432598f, -0.53045696f, 
    -0.18830061f, 0.08229882f, 0.01557384f, 0.11838055f, -0.28810331f, 0.03215011f, -0.01759129f, -0.01755476f, 
    -0.03340934f, 0.04313865f, -0.02752451f, -0.04290625f, -0.00672670f, -0.08944066f, 0.18352978f, 0.04694112f, 
    0.18580613f, 0.30438390f, -0.23456553f, -0.00818810f, 0.17097381f, 0.05869957f, 0.07203262f, 0.08676907f, 
    0.00485183f, -0.04770818f, -0.00161044f, -0.15860823f, -0.00765775f, -0.05788189f, 0.03269342f, -0.07562438f, 
    -0.01842194f, -0.02885014f, 0.00592718f, -0.02664432f, -0.34564465f, -0.13234495f, -0.21331410f, 0.11514835f, 
    -0.16044588f, -0.00070902f, -0.01995091f, 0.01173302f, 0.03064826f, 0.07838406f, 0.05153172f, 0.00091907f, 
    -0.21327707f, -0.03219061f, -0.06725997f, -0.13153009f, 0.07191196f, 0.05586158f, 0.01615874f, 0.02853188f, 
    0.67451692f, -0.38378960f, -0.59144861f, 0.01661927f, -0.03338518f, 0.25388512f, 0.13643363f, 0.12062854f, 
    -0.21228892f, 0.00817860f, -0.09617388f, -0.03117283f, -0.22423179f, -0.02127679f, -0.01892380f, 0.06540622f, 
    0.13783567f, 0.07352670f, 0.05688389f, 0.03804725f, -0.21626997f, -0.20710178f, -0.18409565f, -0.07956626f, 
    -0.30780157f, -0.35229295f, -0.12085690f, -0.22664459f, 0.02427963f, -0.00347914f, -0.05181419f, 0.00639405f, 
    -0.04866983f, -0.04827577f, 0.04558276f, -0.21160132f, 0.02639176f, -0.12417293f, -0.08210947f, -0.12426405f, 
    -0.06599506f, -0.18306604f, -0.48922530f, -0.43729573f, -0.96665955f, 0.11421679f, -0.14464381f, -0.36895525f, 
    -0.28117722f, 0.07794391f, -0.09779570f, -0.03557411f, -0.01740359f, 0.02733925f, 0.02893627f, -0.22878838f, 
    -0.07492711f, -0.45945752f, -0.07750358f, -0.12451300f, 0.02391953f, -0.01548169f, -0.24453332f, -0.03247036f, 
    0.04254501f, 0.21869798f, 0.00049090f, 0.21906300f, 0.10224772f, -0.23720431f, 0.01407312f, 0.03027543f, 
    0.10119579f, 0.03314549f, -0.06050247f, 0.00439068f, 0.04032972f, 0.18016343f, 0.06812473f, 0.06969911f, 
    0.35850096f, 0.41578394f, 0.35354900f, 0.49682581f, 0.13070203f, 0.03640053f, -0.14476928f, 0.07201260f, 
    0.07857317f, -0.00614323f, 0.01005535f, -0.01291334f, 0.02286003f, -0.08011285f, 0.02987074f, -0.02672662f, 
    0.02617980f, 0.04655820f, -0.24550134f, 0.04128509f, 0.78598756f, 0.30594292f, -0.06055731f, 0.23464206f, 
    0.21303818f, -0.08794583f, 0.01802825f, 0.00494604f, -0.07635292f, -0.02179083f, -0.04356322f, 0.08274841f, 
    -0.08079442f, -0.06242421f, 0.02334741f, 0.01517115f, -0.17532161f, 0.23776165f, 0.22752428f, -0.01657884f, 
    0.12541804f, -0.05515285f, 0.02841302f, 0.12626022f, 0.04573533f, -0.06470507f, -0.05826762f, -0.05011890f, 
    0.02551229f, -0.00525830f, 0.10587376f, 0.12209673f, 0.10957673f, 0.04778650f, 0.10475010f, -0.12819429f, 
    -0.06331379f, -0.01568603f, -0.02930323f, -0.12001203f, 0.16300319f, 0.53507191f, -0.29832250f, 0.33273014f, 
    0.21869677f, -0.09352144f, 0.22897565f, 0.03563927f, -0.27462491f, 0.09211534f, -0.17490214f, -0.09695314f, 
    -0.25050592f, 0.23139457f, -0.08592364f, -0.14074969f, 0.10270340f, 0.04798902f, -0.08393648f, -0.16816744f, 
    -0.66278970f, -0.01857612f, -0.12826863f, -0.00337857f, -0.10872370f, 0.05959231f, 0.28422192f, 0.36889088f, 
    -0.08862246f, 0.15239137f, 0.03336995f, 0.05984607f, 0.10577915f, 0.01137163f, -0.06417246f, -0.04357946f, 
    0.03876637f, -0.06379087f, -0.11011446f, 0.05103698f, -0.88806713f, 0.36926216f, -0.17729318f, 0.03367498f, 
    0.41645885f, -0.07617827f, -0.04576388f, 0.03185339f, 0.28822583f, -0.05368306f, 0.00195058f, -0.03599427f, 
    0.10658965f, 0.00240491f, -0.00935267f, -0.04865892f, -0.01181453f, 0.15148123f, -0.13765660f, 0.02863514f, 
    -0.17229100f, 0.08218955f, -0.26179156f, -0.27768230f, 0.22324811f, 0.31968448f, -0.07402521f, -0.10976803f, 
    0.03780531f, -0.01618289f, -0.05897480f, 0.05282608f, 0.00025111f, -0.08515048f, 0.08793670f, -0.01886233f, 
    -0.13373728f, -0.03297955f, -0.21008129f, -0.56815374f, 0.25298193f, 0.02283911f, -0.04814399f, 0.07575187f, 
    0.16785358f, -0.10523047f, -0.01962866f, 0.01571118f, -0.08294567f, -0.04630668f, -0.02752727f, -0.00592495f, 
    -0.05444955f, -0.07959741f, 0.01006185f, 0.10263778f, 0.23194408f, -0.15490763f, 0.07293949f, 0.00436522f, 
    -0.05964225f, 0.13347587f, -0.04183251f, 0.11098668f, -0.54374456f, 0.05356297f, -0.39568725f, -0.16400534f, 
    -0.07400565f, -0.04707380f, 0.01889184f, -0.03069078f, -0.03128612f, 0.10858817f, 0.18324399f, 0.06789134f, 
    -0.09052866f, 0.07812976f, 0.10926052f, 0.04070120f, -0.30496705f, 0.19115254f, -0.26651296f, 0.15350364f, 
    -0.24389632f, -0.19893540f, -0.03210875f, 0.02190442f, -0.37913287f, 0.27082530f, 0.07334632f, -0.04051679f, 
    0.03751345f, 0.07504744f, 0.03399472f, 0.06647488f, 0.07199505f, 0.14141805f, -0.33766818f, 0.05348835f, 
    0.02481759f, -0.02749986f, -0.20477675f, 0.04384581f, -0.05793740f, -0.03501399f, 0.01012104f, 0.06003508f, 
    0.15930340f, -0.09050737f, -0.20501749f, 0.25682852f, -0.04371333f, 0.07666044f, -0.00065635f, -0.04434006f, 
    -0.05424487f, 0.03197534f, -0.02989985f, -0.00672050f, 0.98532665f, -0.14220728f, -0.04894040f, 0.18087429f, 
    -0.01509826f, -0.04674989f, -0.05278791f, 0.02101034f, -0.04248628f, -0.01447892f, -0.01354853f, 0.18420428f, 
    -0.06192381f, -0.24153401f, -0.00991556f, 0.09143849f, -0.03280119f, -0.25083470f, 0.01113904f, 0.02623891f, 
    0.41728517f, -0.67735738f, -0.15634909f, 0.07528958f, -0.26954541f, -0.06093881f, -0.01107019f, 0.11757486f, 
    -0.16360813f, -0.02485972f, 0.17042091f, -0.27213490f, 0.03842326f, -0.24751714f, -0.05914551f, 0.08239868f, 
    -0.05021953f, -0.13759108f, -0.05219559f, 0.03008257f, -0.21704547f, -0.23865633f, 0.34596378f, -0.02326433f, 
    -0.23066922f, 0.18753667f, 0.04087659f, -0.09978254f, -0.03624618f, 0.04073033f, 0.01353028f, 0.02298537f, 
    -0.04916928f, 0.20595208f, -0.07854857f, -0.00091681f, -0.10160170f, 0.06019045f, 0.08353433f, 0.08985045f, 
    0.02309094f, -0.85363388f, 1.02544153f, -0.15532404f, 0.09623988f, -0.21621841f, -0.03553046f, -0.07962289f, 
    0.07335755f, -0.01917321f, 0.00122701f, -0.05083410f, -0.03402537f, 0.01689763f, 0.02386351f, -0.00297983f, 
    0.08927661f, -0.03077214f, 0.03005329f, 0.07481369f, 0.00272844f, -0.07334019f, 0.11402357f, 0.19998223f, 
    0.00686088f, 0.17373051f, -0.40025768f, -0.19889049f, 0.12434329f, -0.35223436f, -0.04942688f, 0.37974212f, 
    0.10789826f, -0.06178087f, -0.02915608f, -0.06521509f, -0.08220465f, 0.06144107f, 0.28080860f, -0.06413849f, 
    -0.41889179f, -0.41697019f, 0.42470390f, 0.53994703f, -0.45935205f, 0.09940443f, -0.03492668f, -0.00489734f, 
    0.18367796f, 0.01123801f, -0.06846351f, -0.01248443f, -0.07010575f, 0.04436342f, -0.09390473f, -0.05598380f, 
    -0.02561003f, 0.06759030f, -0.15743101f, 0.17613029f, -0.07788157f, -0.29928368f, 0.18218490f, -0.14896081f, 
    -0.43814540f, -0.03767387f, 0.05497355f, -0.03745646f, -0.01159375f, 0.11291258f, 0.00316955f, 0.05100436f, 
    0.04495011f, 0.03857433f, 0.08611610f, 0.20186298f, -0.03053566f, 0.05835779f, 0.21929455f, -0.17224444f, 
    -0.04165118f, -0.07876103f, -0.00279970f, -0.10825063f, 0.08027305f, -0.04885581f, -0.06914966f, 0.02706004f, 
    0.07787824f, 0.10527417f, -0.08243779f, -0.15445010f, 0.05810331f, -0.15037507f, 0.01095885f, -0.04484759f, 
    -0.07344214f, -0.10740852f, 0.11635697f, -0.01673959f, -0.33124635f, 0.52053070f, -0.34560132f, 0.24887018f, 
    0.40200117f, 0.00859770f, -0.20543675f, -0.21297540f, -0.14814223f, 0.09440392f, 0.09821990f, 0.10315847f, 
    0.28518429f, 0.13778281f, -0.00373605f, 0.12043602f, 0.06979534f, -0.04388598f, 0.24660620f, 0.04856375f, 
    0.03517811f, 0.26525378f, -0.18181802f, 0.18163176f, 0.30393034f, -0.12620825f, 0.00293663f, 0.07661211f, 
    -0.12470098f, -0.01174991f, -0.00549587f, 0.10627038f, 0.07778841f, 0.02124398f, 0.02373505f, -0.02800633f, 
    -0.05412105f, 0.04441849f, -0.11353993f, 0.01109051f, 0.41391510f, -0.58224171f, -0.72456294f, 0.05735848f, 
    -0.27899942f, 0.17368089f, 0.14889030f, -0.34002027f, 0.12437654f, 0.10957188f, -0.04304882f, 0.05914583f, 
    -0.01193651f, 0.03618227f, -0.12361496f, -0.00444580f, 0.06233473f, 0.00633972f, -0.39450082f, -0.20672953f, 
    -0.35652435f, -0.04446702f, -0.14132240f, -0.03672811f, -0.24839759f, 0.01018470f, -0.08572752f, -0.01460434f, 
    0.08015575f, -0.01354676f, -0.00259155f, -0.02028382f, -0.02138994f, 0.01084726f, -0.10718925f, -0.19281782f, 
    0.03125621f, 0.17126606f, -0.01137079f, 0.14694329f, -0.32590958f, -0.19103195f, 0.09823991f, -0.75352097f, 
    0.13926184f, -0.04473110f, -0.10122067f, -0.07394093f, 0.07586353f, 0.06721269f, -0.06624576f, -0.01819131f, 
    -0.00038815f, 0.01758175f, 0.01204978f, -0.12758018f, -0.29393727f, -0.23577750f, 0.04491595f, -0.07873330f, 
    -0.61651123f, 0.14111608f, 0.39285952f, -0.27852884f, -0.31939283f, 0.16103363f, 0.03761588f, -0.42629373f, 
    0.00605821f, -0.35362712f, 0.04538121f, 0.13695647f, -0.00226655f, 0.00443353f, -0.12838319f, 0.06398853f, 
    0.09708229f, -0.23405561f, -0.15635929f, 0.20798104f, -0.45499825f, -0.25037289f, -0.73653096f, 0.20218831f, 
    -0.66556704f, 0.02990091f, 0.17393427f, 0.03328799f, -0.13824508f, 0.05859694f, -0.01911194f, 0.05380033f, 
    -0.02959079f, -0.04173347f, -0.07308200f, -0.06220770f, -0.00777240f, 0.04767023f, 0.10619094f, 0.11002079f, 
    0.10947914f, -0.10522170f, 0.13852699f, 0.02985819f, 0.01879937f, -0.01084630f, -0.20410866f, -0.12897605f, 
    0.24037364f, -0.46002209f, -0.08018706f, -0.16609679f, -0.04385426f, 0.00239420f, 0.02928529f, 0.03392484f, 
    -0.15360324f, -0.04775571f, 0.09502044f, -0.10587085f, -0.52682972f, 0.27859458f, 0.11724650f, -0.25147822f, 
    -0.12450203f, 0.00444395f, -0.08661783f, -0.06237249f, -0.03070378f, 0.07963452f, -0.21340422f, -0.10793565f, 
    -0.11576155f, -0.11355469f, 0.01101302f, 0.01898570f, 0.08200107f, 0.06600399f, 0.27478766f, -0.05345808f, 
    -0.22984426f, 0.13316682f, 1.11779451f, 0.23340571f, 0.47944191f, -0.11033227f, -0.03994519f, 0.16841835f, 
    0.23617567f, 0.01049533f, 0.08757038f, 0.08639172f, 0.09403544f, -0.28208482f, 0.22334582f, 0.00114156f, 
    -0.01075216f, 0.01447384f, 0.02163161f, -0.09014170f, -0.30905759f, -0.02820836f, 0.24784406f, 0.09858471f, 
    -0.11633262f, 0.18678442f, 0.04692154f, -0.12260221f, -0.25007868f, -0.06171685f, 0.00568860f, 0.00558757f, 
    -0.05777487f, 0.08434132f, 0.02535973f, 0.11837398f, 0.01569732f, -0.09977527f, 0.03913382f, -0.05911750f, 
    -0.10221865f, -0.41745919f, 0.59997362f, 0.11378580f, 0.57614309f, -0.24442033f, 0.19886966f, -0.14582862f, 
    0.23305565f, 0.06264635f, -0.01438644f, -0.05486399f, -0.12743701f, 0.06534043f, 0.21752974f, -0.06628188f, 
    -0.00880475f, -0.14878581f, 0.23616442f, 0.10220220f, -0.41282973f, -0.25737286f, -0.48061097f, -0.24165264f, 
    0.24928579f, 0.10783972f, 0.06441010f, 0.00878985f, -0.01886804f, 0.06883290f, 0.00054296f, 0.07098855f, 
    -0.22718854f, 0.09902227f, -0.11729055f, -0.02093039f, -0.19269529f, 0.34463137f, 0.21367116f, -0.24600306f, 
    0.08956482f, -0.24880593f, -0.37950483f, 0.01290593f, 0.48400998f, 0.23172124f, 0.09799223f, -0.12416665f, 
    0.05230812f, 0.11869635f, -0.13593301f, 0.08647537f, -0.02109362f, 0.06718379f, -0.03208058f, 0.01020715f, 
    0.00389986f, 0.17787199f, -0.03994577f, 0.13650632f, 0.03413985f, -0.46449479f, 0.62893403f, 0.15186554f, 
    -0.27360359f, -0.13854849f, 0.10839254f, -0.00409232f, 0.34186950f, 0.01106920f, 0.20255107f, 0.08890071f, 
    0.22885486f, 0.04286955f, -0.12196673f, 0.01274115f, 0.15613043f, 0.08789611f, -0.10788333f, 0.06442358f, 
    -0.58015287f, -0.26395094f, -0.25804916f, -0.23306790f, -0.53771979f, 0.11241181f, -0.40929154f, 0.06239079f, 
    -0.04596178f, -0.27419516f, -0.06775661f, -0.12459283f, -0.05785700f, -0.38063887f, -0.02509314f, -0.04030024f, 
    0.19044140f, 0.04947171f, 0.01405661f, -0.39372894f, -2.51575089f, 0.94499952f, 0.10598955f, -0.42129320f, 
    -0.24635364f, -0.02453839f, 0.19016232f, -0.24489766f, -0.18447608f, -0.42006457f, -0.35298356f, 0.30003214f, 
    -0.08278408f, 0.05708691f, -0.14352702f, 0.11954375f, 0.17909935f, 0.44925758f, -0.21963544f, -0.23260954f, 
    0.13376443f, -0.04359849f, -0.39294624f, -0.29211420f, 0.24554902f, -0.06371158f, -0.00437175f, -0.06141651f, 
    0.00946111f, -0.14553414f, 0.00983410f, 0.04657092f, -0.11297417f, -0.02892643f, 0.03897252f, 0.11640543f, 
    -0.13170223f, 0.01502285f, -0.12692127f, -0.11915676f, 0.32118684f, 0.01627153f, -0.04004718f, -0.25055900f, 
    0.51144177f, 0.14229755f, 0.14583142f, -0.22879227f, 0.14864148f, -0.26048288f, 0.01862258f, 0.05926622f, 
    -0.16500901f, 0.03471430f, -0.06411760f, 0.10472595f, -0.09183968f, 0.04772677f, -0.10592082f, 0.01079824f, 
    0.00492530f, -0.20983499f, 0.01195493f, -0.01426840f, 0.16255289f, -0.09595630f, 0.25315112f, -0.04123631f, 
    -0.07801935f, 0.10929672f, 0.02717783f, -0.01540783f, 0.04093779f, -0.03149861f, -0.01066625f, -0.01996508f, 
    0.08223771f, 0.02920994f, -0.18806691f, -0.15843281f, -0.74271220f, -0.01450530f, -0.44685391f, -0.25320858f, 
    -0.50959718f, -0.14508937f, -0.40255249f, 0.14606415f, 0.21494026f, -0.01543399f, -0.14810780f, 0.00421922f, 
    0.04285793f, 0.05738874f, 0.13595520f, 0.05282683f, 0.09780936f, -0.17749076f, -0.15043049f, -0.05488903f, 
    -0.37325111f, -0.10335374f, -0.07043692f, 0.21086925f, 0.44144148f, -0.08995958f, 0.11672506f, -0.00071983f, 
    -0.03140261f, 0.01232503f, -0.12936066f, -0.09219066f, -0.18263637f, 0.07093592f, 0.14230895f, -0.06136956f, 
    -0.00646579f, 0.02528432f, 0.05312986f, 0.10956967f, -0.16964480f, 0.04025448f, -0.51480818f, 0.23928396f, 
    0.31055498f, 0.03638029f, -0.17167145f, 0.09090738f, -0.07960974f, 0.17561272f, -0.15570170f, 0.04592710f, 
    -0.11245493f, -0.10368511f, -0.03269516f, -0.26239163f, -0.12646253f, 0.00928098f, -0.18839037f, -0.11884808f, 
    -0.47507581f, -0.22517979f, -0.56310982f, -0.03220499f, 0.48806939f, 0.30856279f, 0.05371575f, 0.10906347f, 
    0.01281069f, 0.10038415f, -0.11762550f, 0.12978958f, -0.00532490f, 0.06697651f, -0.08264496f, 0.22986834f, 
    -0.02655161f, 0.06234910f, 0.03919564f, 0.00359827f, -0.51678360f, 0.26410356f, -0.00855540f, 0.17451434f, 
    -0.25358620f, 0.50564462f, 0.03447981f, 0.39788520f, 0.17110783f, -0.03352169f, -0.06302277f, -0.26976544f, 
    0.15983811f, -0.05109445f, -0.15938556f, -0.09353010f, -0.14501536f, -0.17950056f, -0.15238035f, -0.05585893f, 
    -0.06925528f, 0.96994293f, -0.19875066f, -0.14957444f, 0.42529440f, 0.48424435f, 0.02465842f, 0.05618480f, 
    -0.24681406f, -0.10113358f, -0.26136199f, 0.01074561f, 0.11442433f, 0.06641618f, 0.16439454f, -0.08276840f, 
    -0.01121341f, -0.02631447f, 0.02645796f, 0.05195257f, -0.64826906f, 0.06697692f, 0.35050043f, 0.38140908f, 
    0.59455729f, -0.07054325f, 0.08338021f, -0.26519719f, 0.07550339f, -0.13636869f, -0.16795872f, 0.08392242f, 
    -0.05395377f, -0.23625064f, 0.15944064f, -0.07244594f, -0.00667777f, 0.02344900f, 0.02736754f, -0.13886389f, 
    0.37793919f, 0.40657428f, -0.19482018f, 0.26119626f, 0.37413859f, 0.11836764f, 0.09466584f, 0.09217879f, 
    0.24728984f, 0.22182401f, 0.05922883f, 0.01135194f, -0.00209518f, 0.00361798f, 0.02295432f, 0.05916441f, 
    0.10439876f, 0.26252428f, 0.01841183f, 0.16750550f, 0.26972303f, 0.11485580f, 0.13398628f, -0.25167611f, 
    -0.18224829f, 0.01134238f, -0.17905073f, -0.21734516f, -0.06547917f, -0.07349429f, -0.10755329f, -0.09291985f, 
    -0.01993483f, 0.01291019f, 0.07059437f, -0.01730810f, -0.06103143f, -0.32235542f, -0.22567451f, -0.22533435f, 
    -0.19666071f, -0.12328389f, 0.21828233f, 0.23056372f, 0.09273529f, -0.26691374f, 0.05495352f, -0.07928376f, 
    -0.07659403f, -0.07480145f, 0.00590602f, 0.02536962f, -0.03532618f, 0.11400915f, 0.03098815f, 0.02609724f, 
    0.09498551f, -0.07352173f, 0.19981702f, 0.08151317f, -0.56565368f, 0.22158527f, -0.42310673f, -0.24109130f, 
    -0.26103410f, 0.04365624f, 0.03741835f, 0.01910083f, -0.00369611f, 0.04302778f, 0.08524149f, 0.02908710f, 
    0.02146699f, 0.02968114f, 0.03692662f, 0.05061570f, 0.12115972f, 0.10712139f, -0.24205817f, 0.25520775f, 
    -0.02661468f, -0.02811112f, -0.04348536f, -0.05902089f, -0.12497973f, 0.06699655f, 0.04044648f, 0.05330054f, 
    -0.01832175f, 0.01738023f, 0.03845362f, -0.10214410f, 0.03398313f, -0.07966153f, 0.17627332f, 0.19585757f, 
    -0.08311710f, -0.02073617f, -0.05431306f, -0.03000028f, -0.07934662f, -0.81408077f, 0.18313876f, -1.09500241f, 
    -0.17434379f, -0.12802723f, -0.33159330f, 0.02312235f, 0.42018265f, -0.31807199f, 0.00440930f, -0.15446877f, 
    -0.03055733f, -0.16785634f, -0.03569175f, -0.01627153f, -0.04980636f, -0.26768288f, -0.03288301f, 0.00443293f, 
    0.11070541f, -0.08295582f, 0.06417200f, 0.04677987f, 0.12834854f, -0.09657443f, -0.17208518f, -0.10459727f, 
    0.01134921f, -0.09771523f, 0.12289945f, -0.16143399f, 0.00517613f, -0.07711618f, -0.00598243f, -0.11037333f, 
    -0.15960273f, -0.03455473f, 0.01939567f, -0.11578690f, -0.08202924f, 0.31818646f, 0.02759472f, 0.56684190f, 
    -0.08575156f, -0.16690403f, -0.03184806f, -0.02028450f, -0.22493201f, 0.09594186f, -0.08038170f, 0.00186529f, 
    -0.03117666f, 0.05784842f, 0.03306305f, -0.01387450f, -0.18042552f, -0.15446098f, -0.22531861f, -0.12761928f, 
    -0.07420217f, 0.00319190f, 0.02112322f, 0.06177929f, -0.12646241f, -0.10490729f, -0.07732227f, 0.01107330f, 
    0.04772615f, -0.00648935f, -0.00939442f, -0.04799672f, -0.00804091f, 0.09483688f, -0.06837285f, 0.06940801f, 
    0.28576714f, -0.22886807f, 0.15032350f, 0.40629122f, 0.19479255f, 0.12221812f, -0.09782213f, 0.13236569f, 
    0.18867631f, 0.06178869f, 0.01942950f, 0.06802283f, 0.05799690f, 0.10703393f, 0.13506337f, 0.13043118f, 
    0.09796063f, 0.04823356f, 0.12966566f, -0.10272160f, -0.16946587f, -0.01458540f, -0.12988748f, 0.05530892f, 
    -0.01074816f, -0.11649675f, 0.30626783f, -0.15582620f, 0.01247055f, 0.00858249f, 0.02761989f, -0.07484800f, 
    0.03094969f, 0.32304576f, -0.02425858f, -0.08419989f, 0.05927277f, -0.09615932f, -0.23888795f, -0.15025523f, 
    -0.06018960f, -0.31110024f, -0.04480526f, -0.19559711f, 0.16375025f, 0.00858924f, 0.51106369f, 0.08445808f, 
    0.32885095f, -0.12212833f, 0.27089769f, 0.19297595f, 0.16220978f, -0.06299083f, -0.06945202f, -0.00499721f, 
    -0.01605681f, -0.02989510f, 0.08772950f, -0.04115532f, -0.01663590f, -0.18986240f, -0.00164114f, -0.22517359f, 
    0.30634880f, 0.16727746f, 0.06641556f, 0.14877342f, -0.02860659f, -0.02048973f, -0.06289198f, -0.05644804f, 
    -0.16967227f, 0.28190693f, 0.22880903f, -0.15483114f, 0.07369380f, 0.08150768f, 0.05185500f, 0.18621813f, 
    0.08472005f, -0.00403315f, -0.17998704f, -0.02519796f, -0.18473110f, 0.18176268f, 0.11715424f, -0.44072977f, 
    -0.30770168f, 0.16635846f, 0.10856529f, -0.05492812f, 0.05379476f, 0.09712894f, 0.06658758f, -0.01899549f, 
    -0.10563710f, 0.25740793f, -0.20966195f, -0.12202382f, -0.00863868f, -0.08189274f, -0.10083974f, 0.00920724f, 
    -0.21496600f, -0.44598487f, 0.33735922f, -0.08263557f, 0.05554661f, -0.35352066f, -0.07167578f, -0.12236574f, 
    0.10642438f, 0.02773926f, 0.00833498f, -0.08261888f, -0.09879877f, 0.00644608f, -0.04099757f, 0.07699023f, 
    0.07610153f, 0.15228277f, -0.02972287f, -0.04833948f, -0.03057581f, -0.13917281f, -0.06010834f, -0.23896068f, 
    0.04114163f, -0.17764093f, 0.09060897f, -0.02251010f, -0.15515329f, -0.03182161f, 0.09087291f, -0.08309460f, 
    0.09924129f, -0.12705742f, 0.02411843f, -0.26600128f, -0.11600061f, -0.10336253f, -0.07847489f, -0.24157801f, 
    0.13532348f, 0.07998271f, -0.05275294f, 0.00284581f, -0.11157449f, 0.10728103f, 0.05411578f, -0.01451450f, 
    -0.04871703f, -0.14847291f, -0.00330904f, -0.02290613f, 0.03925709f, -0.03859226f, -0.07025301f, -0.00750841f, 
    -0.14117789f, 0.23324265f, -0.11365817f, -0.12448797f, -0.03305383f, 0.03503366f, 0.23472108f, -0.06612723f, 
    -0.03151779f, -0.23999062f, 0.33372617f, -0.05376958f, -0.13597335f, 0.12930892f, 0.03781886f, -0.00922775f, 
    -0.12045999f, 0.08412068f, -0.03795988f, 0.03695924f, 0.02646921f, -0.08775446f, 0.12370509f, 0.25500566f, 
    -0.30658925f, 0.06329036f, 0.24021512f, -0.11075736f, -0.19542427f, 0.15492621f, -0.00720796f, 0.14672348f, 
    -0.07024132f, -0.10879613f, 0.06692287f, -0.11194753f, -0.02528409f, 0.13041952f, 0.00038830f, 0.03346727f, 
    -0.00551319f, -0.11947105f, -0.11633705f, -0.13886981f, 0.18814075f, -0.05077697f, 0.13547841f, -0.48889926f, 
    0.33428484f, 0.04182260f, 0.08597775f, -0.14249171f, -0.02115592f, 0.00025300f, 0.01420345f, -0.09030846f, 
    0.05080503f, -0.05045347f, 0.01744933f, -0.25141209f, -0.09992412f, -0.27315533f, 0.32426044f, -0.29021052f, 
    -0.04335939f, -0.06951290f, -0.27123097f, 0.02133699f, 0.19327486f, 0.02443964f, -0.00869918f, -0.14190750f, 
    -0.04882155f, 0.00318509f, 0.28997999f, 0.21348512f, 0.10547008f, 0.19398046f, 0.02049510f, -0.02442727f, 
    0.07995252f, 0.08058409f, 0.09748271f, 0.16437554f, 1.00930798f, -0.74732983f, 0.07667254f, 0.02136416f, 
    -0.27890036f, 0.10672874f, -0.22289895f, -0.03238416f, -0.22990403f, 0.14023171f, 0.07945848f, -0.02375513f, 
    0.00493190f, -0.14112380f, 0.24938314f, -0.25644210f, -0.29037243f, 0.02814524f, 0.21384394f, 0.03537244f, 
    0.09429847f, -0.19996446f, -0.01542519f, 0.08143368f, -0.24372257f, 0.05822219f, -0.09931013f, -0.15616606f, 
    0.18250620f, 0.27569294f, -0.01805916f, 0.03374296f, -0.08567236f, 0.04621271f, 0.01258025f, 0.06703054f, 
    0.15721501f, 0.04671741f, 0.04466615f, 0.14856471f, 0.02401987f, -0.30428463f, 0.49084413f, -0.16303369f, 
    -0.59703928f, 0.10682594f, -0.03034725f, 0.10684469f, -0.08055882f, 0.06404089f, 0.10956652f, -0.07447781f, 
    -0.05150769f, -0.01127364f, 0.12323134f, -0.02429480f, 0.05684979f, -0.02990785f, 0.17088518f, 0.20278610f, 
    0.10819698f, 0.11337584f, 0.40427691f, 0.30836859f, -0.35034519f, -0.19067754f, -0.07012796f, 0.12910149f, 
    0.13242818f, 0.00289177f, 0.03043744f, 0.06615090f, -0.02212169f, 0.02177386f, -0.00450558f, -0.10668062f, 
    -0.11556237f, -0.05113676f, -0.17996101f, -0.39645702f, -0.40257847f, -0.33347762f, -0.24618167f, 0.22757374f, 
    0.15651658f, 0.09825259f, 0.11020584f, -0.01729133f, 0.00233705f, 0.08543152f, 0.13003702f, -0.14145806f, 
    -0.01558789f, 0.03769480f, -0.06256469f, -0.20437220f, -0.15334272f, 0.28194970f, 0.08112065f, -0.09825335f, 
    0.35565469f, 0.03573909f, -0.01725919f, -0.41746739f, 0.30634326f, -0.04442792f, 0.17816626f, 0.00705575f, 
    -0.07880517f, -0.13601808f, 0.03956240f, 0.04643533f, -0.07122156f, -0.03141891f, -0.00151830f, -0.02871632f, 
    0.14812657f, -0.03002208f, 0.07963808f, -0.03499288f, 0.35529009f, -0.01738832f, 0.40618977f, -0.00342083f, 
    -0.18371271f, 0.24565959f, 0.15527335f, -0.34119660f, 0.04839465f, -0.02849818f, 0.13351266f, -0.03501556f, 
    -0.02122363f, 0.07740756f, 0.00198831f, -0.03214913f, 0.05752150f, -0.12009101f, -0.15779480f, 0.14200027f, 
    -0.13222629f, 0.04510708f, 0.12835391f, -0.44242755f, -0.06135221f, 0.05638938f, 0.08830397f, 0.07198912f, 
    -0.07958175f, 0.03369713f, 0.19054161f, -0.03034909f, -0.01708952f, -0.14024954f, -0.05005069f, -0.01174780f, 
    0.04078411f, 0.05119743f, 0.05217630f, 0.04585188f, -0.24968870f, -0.01354076f, -0.19332908f, -0.27039650f, 
    0.28529069f, -0.06949759f, -0.04481863f, -0.08952767f, -0.02253417f, -0.05352407f, 0.25131896f, -0.02207668f, 
    -0.10912331f, -0.13201407f, 0.16774234f, -0.17934038f, -0.16166709f, 0.24805053f, 0.14662091f, -0.14884454f, 
    -0.46352986f, -0.06113615f, -0.66874170f, -0.39517015f, -0.15544498f, 0.06547669f, -0.02410981f, -0.10933871f, 
    -0.14057282f, 0.08598158f, -0.03246982f, 0.02216033f, -0.18032368f, 0.09313244f, -0.14292844f, -0.14805607f, 
    -0.10310610f, 0.01189143f, -0.05407555f, 0.05097439f, 0.62811041f, -0.02263889f, -0.45996460f, -0.01617877f, 
    0.07838882f, 0.16329244f, -0.21561486f, 0.02200357f, -0.28463489f, 0.17830329f, 0.01877616f, -0.00621236f, 
    -0.11109296f, -0.03066435f, -0.09551091f, 0.29309520f, 0.02927361f, 0.06928736f, -0.29019049f, 0.04458117f, 
    -0.38691431f, -0.69925165f, -0.99515373f, -0.39003941f, -0.04936215f, -0.15807776f, 0.19840570f, 0.34597343f, 
    0.20796928f, -0.18188293f, 0.00234822f, -0.01392455f, -0.02339066f, 0.08411423f, 0.05057311f, -0.03167501f, 
    -0.10615371f, 0.28789124f, 0.09639288f, -0.08419045f, -0.38291296f, 0.29434162f, 0.25150964f, 0.07159338f, 
    -0.03124409f, 0.02338490f, -0.27195299f, -0.12945376f, 0.18819508f, -0.12129058f, -0.04583666f, 0.01387192f, 
    -0.07664716f, 0.03379150f, 0.01346618f, 0.00974726f, -0.08279502f, 0.19325940f, -0.22974819f, -0.10024098f, 
    -0.65848672f, -0.64664531f, -1.00422668f, 0.03205000f, -0.05704856f, -0.20509100f, -0.19472504f, -0.28955036f, 
    -0.14216816f, -0.17331927f, -0.06382117f, 0.02808741f, -0.00955966f, -0.03318086f, 0.01779947f, -0.00061325f, 
    -0.05341180f, 0.08831221f, 0.13361567f, -0.01373220f, -0.35761881f, 0.05851034f, 0.16241847f, -0.34542215f, 
    -0.05152585f, -0.02561970f, 0.04697019f, -0.01892799f, 0.01555971f, -0.05595665f, -0.04326582f, -0.08885489f, 
    0.02633407f, -0.00612861f, -0.02026390f, 0.25369287f, 0.10667169f, 0.05944422f, -0.00642449f, 0.13756271f, 
    0.11694869f, -0.07872065f, -0.01255148f, 0.01029134f, -0.05008523f, 0.00489785f, -0.01684474f, -0.06378463f, 
    -0.02044077f, 0.02091449f, -0.13941370f, -0.15194592f, -0.14235538f, -0.10055545f, -0.11563784f, 0.02500965f, 
    -0.07244221f, -0.06869058f, -0.12570755f, -0.08120867f, -0.09553535f, 0.72834498f, -0.58343732f, 0.02150105f, 
    0.15466812f, -0.00178519f, -0.00784210f, -0.12193640f, 0.22910628f, 0.21893756f, 0.33265427f, -0.15845847f, 
    0.29056379f, 0.11440605f, -0.05713272f, -0.09023646f, 0.45620674f, 0.02820209f, 0.24212301f, 0.31256568f, 
    -0.33129987f, 0.59078312f, 0.03549476f, -0.05464379f, 0.08580133f, -0.40720946f, -0.02456902f, -0.26265171f, 
    0.11607095f, 0.28244278f, -0.15502347f, 0.08253445f, 0.00703329f, 0.05246265f, 0.06410626f, 0.02274221f, 
    -0.01476750f, -0.06127230f, 0.09697326f, -0.10854365f, -1.15362918f, -1.40440595f, -0.00378408f, 0.17778741f, 
    0.13263200f, -0.21828619f, 0.01302326f, -0.41119641f, -0.23495448f, -0.26669580f, -0.06317516f, -0.01451540f, 
    -0.07456331f, -0.08610819f, 0.05784055f, -0.04529066f, -0.01964224f, -0.00893403f, 0.25552440f, -0.05334896f, 
    -0.47820970f, -0.27982798f, -0.76905322f, 0.05368872f, 0.25058880f, -0.07901178f, 0.13336891f, 0.07847329f, 
    -0.17965792f, -0.31540102f, 0.01662862f, -0.06599071f, 0.08481185f, 0.06501497f, 0.03833378f, 0.06230465f, 
    -0.00617378f, 0.11803932f, 0.37431350f, 0.08191535f, 0.03542513f, -0.26710793f, 0.05934981f, -0.04563894f, 
    -0.00771360f, 0.02341055f, 0.08447757f, 0.03651842f, -0.11908203f, -0.09209335f, -0.10462844f, -0.11800446f, 
    -0.07355220f, -0.00621804f, -0.08296043f, -0.11507271f, -0.11091400f, -0.18636604f, -0.09001703f, 0.05612663f, 
    0.50845051f, 0.05158014f, -0.39585072f, 0.00071530f, -0.20717961f, 0.24094240f, 0.18158792f, 0.14390717f, 
    -0.00756729f, -0.55413407f, 0.11757576f, 0.07911038f, -0.03453386f, -0.07588787f, 0.11192829f, 0.03799059f, 
    -0.00543251f, 0.11338971f, -0.21872367f, -0.01837713f, -0.49685168f, -0.93113792f, -1.00608778f, -0.30313337f, 
    -0.02441054f, -0.12340105f, -0.09901533f, -0.14796124f, 0.05451166f, -0.65915680f, 0.03063804f, -0.03340311f, 
    -0.16706996f, 0.01657267f, 0.00676309f, -0.10660207f, -0.05536325f, 0.29467016f, 0.16390075f, 0.07426482f, 
    -0.46875188f, 0.09283546f, 0.48208249f, 0.04751633f, -0.27559420f, -0.05857209f, -0.12292664f, -0.07834360f, 
    -0.14597084f, -0.26161304f, -0.23433751f, -0.01747262f, 0.00912557f, 0.06542657f, 0.05108034f, 0.00312134f, 
    -0.00161174f, 0.04731579f, -0.18008582f, -0.11030152f, -0.09093674f, 0.18586990f, 0.18712246f, -0.21421617f, 
    0.16276772f, 0.05257647f, -0.04429555f, -0.04876097f, -0.04654773f, -0.07720081f, 0.06181883f, -0.12590696f, 
    0.17476727f, 0.10960525f, 0.15731816f, 0.07638559f, -0.00538839f, 0.06352888f, -0.33567214f, 0.13307884f, 
    -0.83041143f, 0.82422787f, 0.46480274f, -0.03902538f, 0.58123845f, -0.21686956f, -0.09848355f, -0.15726548f, 
    -0.02272918f, 0.27636069f, 0.01567036f, 0.17852521f, 0.11007918f, 0.13522467f, 0.08662430f, -0.01612743f, 
    0.01431489f, 0.01833631f, 0.10410281f, -0.00996059f, 0.48863894f, 0.03760876f, -0.53014064f, -0.23171107f, 
    0.13623577f, -0.09413381f, -0.18759120f, 0.31818983f, 0.26395452f, -0.01353924f, 0.02686561f, 0.12587993f, 
    0.08097479f, -0.24013354f, -0.01698311f, 0.01796350f, 0.02571792f, -0.02351011f, 0.08760364f, 0.10048937f, 
    -1.09203684f, 0.36618361f, -0.30534893f, 0.05593701f, -0.30807427f, 0.10774450f, -0.16329649f, 0.01356877f, 
    -0.14007810f, -0.08967010f, 0.06871193f, -0.00082457f, 0.03440977f, -0.01393391f, 0.00975043f, 0.09847175f, 
    -0.03269342f, -0.05630876f, -0.24626297f, -0.13336258f, -0.33892199f, -0.36889741f, 0.35745254f, -0.54836833f, 
    0.34047887f, -0.23485081f, 0.26123765f, -0.05019142f, 0.33207643f, -0.13033338f, 0.05267059f, 0.05655664f, 
    0.02480573f, -0.01823029f, 0.04041984f, -0.00067363f, -0.05894990f, -0.15310341f, -0.08609349f, -0.03170217f, 
    0.65092707f, -0.76748192f, -0.06569589f, -0.58221054f, -0.05657785f, -0.09575226f, 0.10427051f, -0.38568503f, 
    0.23789804f, 0.15550283f, -0.02365211f, -0.00025519f, -0.10151453f, -0.12024100f, -0.00910162f, -0.05820424f, 
    -0.00090125f, -0.13006604f, 0.17375106f, -0.06376859f, 0.01263877f, 0.32345769f, -0.14399952f, -0.06266159f, 
    -0.12850548f, 0.08588541f, 0.02421950f, 0.18349656f, -0.10112029f, -0.06173606f, -0.05329276f, -0.04821305f, 
    0.04590834f, 0.00204950f, 0.00471378f, 0.06918246f, -0.02230155f, -0.06908539f, -0.18805410f, 0.09480668f, 
    -0.03540858f, 0.22891797f, 0.05838056f, -0.09761196f, -0.15738223f, -0.11732934f, -0.04024803f, 0.03784847f, 
    -0.05639635f, -0.08304614f, -0.04354937f, -0.24796116f, -0.19283715f, -0.27871794f, -0.23167589f, 0.04586837f, 
    0.02126154f, -0.02424761f, 0.06837664f, 0.01858265f, 0.20110719f, -0.54509282f, 0.13263845f, -0.10309360f, 
    0.26607281f, 0.04410927f, 0.09636188f, 0.18240577f, -0.41800773f, -0.08012063f, -0.08838147f, 0.03314804f, 
    -0.21483229f, -0.04281015f, -0.15788475f, 0.06822602f, -0.27649048f, -0.06080504f, 0.00710782f, -0.03074597f, 
    0.84210986f, -0.63728261f, -0.45109546f, -0.04006615f, -0.18285297f, 0.28915271f, 0.00395495f, -0.09320597f, 
    -0.09258273f, -0.18333915f, 0.03362462f, -0.07432958f, 0.06082550f, -0.01429090f, -0.03505593f, -0.05262773f, 
    -0.02355824f, 0.12932736f, -0.11051378f, -0.18504518f, 0.51711696f, -1.28241754f, 0.45794168f, 0.87921327f, 
    0.35384199f, -0.06265637f, 0.19828796f, -0.11991306f, 0.20435074f, -0.07699821f, 0.07927468f, 0.19201283f, 
    0.03194500f, -0.04413757f, -0.01837449f, -0.06120083f, 0.05468118f, -0.08288564f, 0.12639150f, -0.14918712f, 
    -0.41267416f, -0.85359854f, 0.08911534f, 0.66254991f, -0.02405313f, -0.02655192f, 0.08550786f, -0.11422934f, 
    -0.09348396f, 0.12856455f, -0.02868761f, -0.05664145f, -0.09183644f, -0.02625885f, 0.02071160f, 0.05320665f, 
    0.19862758f, -0.10357966f, 0.17286001f, -0.06283702f, 0.06358718f, 0.17603537f, 0.02233151f, 0.03153424f, 
    -0.22822051f, -0.00117806f, -0.00483647f, 0.00028884f, -0.06029813f, -0.11617666f, 0.02388081f, -0.00352784f, 
    0.11250143f, -0.00293468f, -0.03190428f, -0.08522954f, -0.36158469f, 0.20108359f, 0.11729806f, 0.03490186f, 
    -0.59807420f, -0.39866006f, 0.50032437f, -0.17355496f, 0.37762323f, -0.07393256f, -0.02727272f, -0.10208675f, 
    0.18000510f, 0.25928888f, 0.06391012f, -0.07476589f, 0.20961033f, -0.11598741f, -0.06793259f, 0.04499019f, 
    -0.02604652f, -0.26057583f, 0.05075392f, -0.18571618f, -1.59338105f, -1.24763465f, -0.02316312f, 0.25873166f, 
    0.36527973f, 0.05452763f, -0.01130917f, 0.15306899f, 0.07520314f, -0.02324148f, 0.06378506f, 0.01472709f, 
    -0.07191703f, -0.14781885f, -0.09342760f, 0.03935989f, -0.05780238f, -0.05756639f, 0.12400106f, -0.10363624f, 
    0.37655422f, -0.18820542f, -0.04582293f, -0.19062582f, -0.03888916f, 0.10219336f, 0.13431677f, 0.01150442f, 
    -0.09259264f, -0.05745522f, 0.16562828f, 0.00325109f, 0.12286075f, 0.09017783f, 0.10787652f, 0.01709526f, 
    0.01896991f, 0.01362684f, 0.03878773f, -0.03688635f, -0.01758815f, 0.05426759f, 0.04527598f, 0.06326994f, 
    0.09521402f, 0.07655805f, 0.01692581f, 0.24851295f, -0.05696927f, -0.04867109f, -0.02240775f, -0.15819864f, 
    0.02418925f, 0.00159271f, -0.28410059f, -0.14708576f, -0.14984153f, -0.29374567f, 0.08961899f, 0.08678532f, 
    0.64983106f, -0.51972353f, -0.73091882f, -0.28416875f, -0.27136362f, -0.04622810f, -0.12533577f, 0.16763043f, 
    0.11410605f, -0.34956732f, 0.05466840f, 0.08755757f, -0.02486565f, 0.13970463f, -0.03486255f, -0.00292846f, 
    -0.00770536f, 0.01482949f, 0.11463947f, 0.05017191f, -0.20833106f, 0.15159693f, -0.02266027f, -0.05512403f, 
    -0.15246926f, 0.09397236f, -0.00282191f, -0.08659773f, 0.01857023f, -0.01833499f, 0.09699796f, 0.03360709f, 
    0.11698481f, -0.11425257f, 0.09509892f, 0.04967699f, -0.06362495f, -0.00977474f, -0.05098444f, 0.01071492f, 
    -0.22223659f, 0.12853327f, 0.55058217f, 0.31287664f, 0.07829798f, 0.24799049f, 0.08936108f, -0.07423369f, 
    -0.10206101f, -0.12145732f, -0.04758223f, -0.11575299f, -0.01091038f, -0.11420296f, -0.07969713f, 0.14230810f, 
    -0.09876502f, -0.13824823f, -0.12072865f, -0.37045044f, 0.04405430f, -0.26118761f, -0.20401463f, 0.11031716f, 
    -0.01756238f, 0.05652102f, 0.03849993f, -0.01362493f, -0.09187195f, 0.30318683f, -0.00425726f, 0.10242005f, 
    -0.00136435f, -0.02578316f, 0.08367409f, -0.05743897f, 0.24802516f, 0.28377607f, -0.06613961f, 0.15362164f, 
    -0.24135710f, -0.43718305f, -1.29719079f, -0.75716710f, -0.08438946f, -0.08392094f, -0.23427969f, 0.03634579f, 
    -0.19143300f, -0.39958242f, -0.06226390f, -0.10669719f, -0.01626789f, 0.05205776f, 0.08699764f, 0.08287859f, 
    0.00569766f, 0.02182160f, -0.07254636f, -0.08428126f, -0.84150088f, 0.02206459f, 0.46549609f, 0.24689440f, 
    -0.03469421f, -0.03968324f, -0.09373584f, -0.10711811f, -0.11623900f, -0.10392030f, -0.09286167f, -0.13131055f, 
    -0.10375379f, -0.12349213f, -0.10549519f, -0.41334334f, -0.24465865f, -0.34368962f, -0.35120735f, -0.09785128f, 
    -0.19667779f, -0.02631277f, 0.02005276f, 0.07526970f, -0.23680885f, -0.09643442f, -0.01837057f, 0.02325597f, 
    0.00058150f, -0.01530545f, 0.03612304f, 0.03805685f, 0.04694519f, 0.10480979f, 0.15588222f, 0.06209498f, 
    0.20884247f, 0.11566822f, 0.10690820f, 0.15020698f, 1.09628451f, 0.47645470f, 0.05465255f, -0.26022652f, 
    0.19568285f, 0.14082703f, 0.10223868f, -0.03029655f, 0.09573640f, 0.17486955f, 0.31906375f, -0.02284132f, 
    0.01561780f, -0.06557103f, -0.05814794f, -0.26502714f, 0.02121791f, 0.03120829f, -0.07085516f, -0.07135998f, 
    0.26120186f, -0.50238717f, -0.59990066f, 0.02794800f, 0.07603083f, 0.00978116f, 0.02663940f, 0.14758044f, 
    0.03071592f, 0.04728279f, 0.07535471f, -0.05090801f, -0.03625704f, -0.04345680f, -0.10199982f, -0.01187951f, 
    0.01402110f, 0.00118209f, 0.09088214f, 0.08234371f, 0.58056229f, -0.32226482f, -0.54948771f, -0.37668675f, 
    -0.14108458f, 0.27307427f, -0.36524323f, -0.02134029f, 0.02368771f, 0.04427452f, -0.08530002f, 0.14603342f, 
    0.22934332f, 0.02097666f, 0.06658996f, 0.03934479f, 0.14123929f, 0.05340774f, 0.07598922f, 0.19687770f, 
    0.59531271f, 0.25058556f, 0.09169477f, -0.16805726f, 0.03623756f, -0.01014457f, -0.42019778f, -0.06168207f, 
    -0.10706940f, -0.24775623f, 0.04369972f, 0.05870508f, 0.00690204f, 0.02835588f, 0.02687172f, 0.05347908f, 
    -0.00087466f, -0.04491699f, -0.16653226f, -0.51606846f, -0.50393671f, 0.13649239f, 0.23000221f, -0.00535619f, 
    -0.42602727f, -0.09589822f, -0.10453187f, -0.09609511f, 0.00875545f, -0.03488319f, -0.20385441f, -0.02186473f, 
    -0.08916447f, -0.13137227f, -0.02030183f, 0.17649010f, 0.09536099f, 0.02565936f, -0.06495823f, -0.00331804f, 
    -0.19614880f, -0.09853810f, 0.07630953f, 0.09622859f, 0.19527845f, 0.13773809f, -0.17516647f, -0.04751572f, 
    0.01522782f, -0.05719826f, 0.04983226f, 0.02059276f, 0.16100864f, -0.05067527f, -0.05215995f, -0.16348436f, 
    -0.08033523f, 0.23546837f, -0.07676968f, 0.16074230f, 1.10215020f, -1.06568551f, -0.61940527f, 0.12929372f, 
    -0.09006223f, 0.40874735f, -0.06422172f, -0.13129143f, -0.13386728f, -0.20060669f, -0.04977426f, 0.02128912f, 
    0.04354517f, 0.06214526f, 0.05800710f, 0.09111889f, 0.02895983f, 0.11839686f, -0.14787526f, -0.00471342f, 
    -0.20551178f, -0.27138063f, -0.22289275f, 0.02976239f, -0.08592344f, -0.14096248f, 0.02645441f, 0.10134520f, 
    0.09540564f, 0.08708797f, -0.02936739f, -0.02978225f, 0.04808463f, -0.04853429f, 0.02609624f, -0.12626497f, 
    0.11632608f, 0.14333388f, 0.09967602f, 0.16400968f, -0.74599254f, -0.17402160f, 0.36725348f, 0.07079607f, 
    0.00848650f, -0.16639444f, -0.02778213f, -0.04970874f, -0.04210443f, -0.02979190f, 0.03564467f, 0.05322942f, 
    0.07332775f, 0.17290725f, 0.15365854f, -0.11000062f, 0.00063471f, 0.00515248f, -0.12973076f, 0.01065947f, 
    0.00850200f, -1.09910321f, -0.85319567f, -0.21856219f, 0.24749665f, -0.19786091f, 0.16491479f, 0.21147622f, 
    0.21037659f, 0.04374199f, 0.12088743f, -0.07938149f, -0.08313309f, -0.02129312f, 0.02837561f, 0.01106807f, 
    -0.00153105f, -0.00767795f, 0.00617264f, -0.15441151f, -0.23086441f, 0.20531653f, 0.07566075f, 0.14654422f, 
    0.24486855f, 0.04004380f, 0.03302394f, -0.02777825f, 0.03840171f, -0.16666737f, 0.04385638f, 0.01975373f, 
    0.08364265f, 0.00835782f, -0.03809774f, -0.02225938f, -0.06973281f, 0.04234319f, 0.20663734f, 0.06833237f, 
    -0.09929989f, 0.38145545f, -1.23335648f, -0.14936985f, 0.32582736f, 0.21232899f, -0.05635880f, 0.28579459f, 
    -0.14974143f, 0.22957830f, 0.10114092f, 0.00752534f, -0.04263983f, 0.07726052f, -0.04829121f, 0.02154716f, 
    -0.04427890f, 0.07013307f, -0.10969620f, 0.08893201f, 0.36526838f, -0.04323014f, 0.23967156f, -0.25245148f, 
    -0.22067371f, -0.17816266f, 0.30978283f, -0.01140528f, 0.02292396f, 0.02983448f, -0.00545165f, -0.02732551f, 
    0.02135252f, -0.07950260f, 0.07530884f, 0.03270190f, -0.08003366f, -0.07668222f, -0.18624189f, -0.17073268f, 
    -0.43001875f, -0.44879395f, 0.31848341f, 0.34892032f, -0.67880511f, -0.08417422f, -0.00848220f, 0.05952600f, 
    0.19500321f, 0.17494403f, 0.08740087f, 0.00923596f, 0.09135699f, 0.04574412f, -0.04307362f, 0.00878407f, 
    0.11481567f, 0.15055153f, 0.14378364f, 0.15215589f, 0.12043302f, -0.28350374f, -0.69267708f, -0.03470914f, 
    0.11589879f, 0.00073461f, -0.11676328f, 0.24397263f, -0.06392351f, 0.02248091f, -0.06036755f, -0.07899580f, 
    0.06004006f, 0.01421835f, -0.05500363f, 0.05278760f, 0.22631143f, 0.03499963f, -0.15996841f, 0.18772544f, 
    -0.00437328f, -0.08922321f, 0.06549536f, -0.13691773f, 0.16907047f, 0.02757616f, 0.14185101f, -0.02880245f, 
    -0.06680145f, -0.20456892f, 0.25958964f, 0.20042560f, 0.02338288f, 0.01067409f, -0.02998049f, 0.15578561f, 
    -0.20743214f, -0.00489792f, -0.22856095f, 0.00733056f, -0.74252641f, -0.83940494f, 0.02724010f, -0.16027991f, 
    0.05635042f, 0.10104977f, -0.09997612f, -0.26515976f, -0.03203935f, -0.26174638f, 0.01454749f, -0.03147427f, 
    0.05744029f, -0.26663807f, 0.01160707f, 0.32304677f, 0.01817727f, -0.42735514f, -0.19719218f, 0.12516609f, 
    -0.27716255f, 0.07072756f, 0.35383260f, 0.40511218f, -0.67844802f, 0.13710667f, -0.29015782f, -0.08690132f, 
    0.05755496f, -0.20907010f, -0.05457599f, -0.07881550f, 0.08583443f, -0.02731896f, -0.09555417f, -0.06904456f, 
    -0.14714544f, -0.09064285f, 0.03318671f, 0.03783398f, -0.23112889f, -0.42284209f, -0.62502885f, 0.30023316f, 
    -0.51817900f, -0.26641610f, 0.04557930f, 0.00893794f, 0.23162644f, -0.06023873f, 0.01769630f, -0.08026886f, 
    -0.09659991f, -0.11956064f, -0.01387709f, 0.13896763f, -0.11156872f, 0.02047005f, 0.11326247f, -0.22762214f, 
    0.15283430f, -0.25046328f, -0.57372504f, 0.26702103f, -0.24063787f, -0.08728758f, 0.05537764f, -0.04416080f, 
    0.09096587f, 0.02383984f, 0.07754919f, 0.09091955f, 0.01617985f, 0.10846957f, -0.02694019f, -0.09929019f, 
    0.06293145f, 0.12114187f, 0.14325592f, 0.30737886f, -0.27738705f, -0.04511276f, -0.33891994f, -0.30954862f, 
    0.12611301f, 0.03218273f, 0.17788462f, 0.36920157f, -0.03675780f, 0.19545703f, 0.00987312f, 0.00997760f, 
    -0.01558102f, 0.03041945f, -0.14059755f, -0.03043808f, -0.08186044f, 0.00493393f, -0.09355448f, 0.00227607f, 
    0.56032681f, 0.16979559f, -0.06883637f, -0.06178408f, -0.04160038f, -0.27626598f, -0.07833266f, 0.11812747f, 
    0.11158567f, 0.33121085f, 0.00894896f, -0.00550989f, -0.10025001f, -0.17677227f, -0.00569989f, 0.01442678f, 
    0.00616980f, 0.04421835f, -0.09741104f, -0.19648805f, -0.28223488f, -0.29786023f, -0.05281773f, 0.16862795f, 
    -0.19112602f, -0.04804030f, -0.40364516f, 0.12545231f, -0.10568696f, 0.24873085f, -0.02028328f, 0.05178743f, 
    0.08774679f, -0.12850738f, -0.06527855f, 0.01863482f, 0.01020130f, 0.00290205f, 0.04331726f, 0.00972246f, 
    0.04550299f, -0.13659641f, 0.51312733f, -0.23026747f, -0.10383472f, 0.01010668f, 0.06018841f, -0.36655101f, 
    -0.26877323f, -0.04514049f, -0.07623313f, 0.00172459f, 0.02795557f, 0.09083368f, -0.03287293f, -0.03290695f, 
    -0.09061623f, -0.14461508f, -0.10194160f, 0.02042411f, 0.19649833f, -0.28470665f, 0.13099745f, -0.53010166f, 
    0.27194989f, -0.10886841f, -0.16843642f, 0.14777137f, -0.01436006f, -0.13201119f, -0.02887062f, 0.16310546f, 
    0.14021969f, 0.06479284f, -0.15554982f, 0.21940474f, 0.15682235f, 0.19936997f, 0.04467307f, 0.02352324f, 
    0.29319474f, 0.14064290f, 0.50322711f, 0.71764016f, -0.91094154f, 0.10389087f, -0.19748004f, -0.59770864f, 
    0.09184740f, -0.33276770f, 0.05341693f, -0.13643445f, 0.17269947f, 0.17079285f, 0.06716873f, 0.13057037f, 
    0.00744565f, -0.01769077f, 0.01060772f, 0.09546027f, -0.32023606f, 0.56886840f, -0.48614776f, -0.29262093f, 
    0.08640987f, -0.09661139f, 0.00862706f, 0.23502502f, -0.05565656f, -0.11866724f, 0.11110544f, -0.01487189f, 
    0.00878295f, -0.14717399f, 0.06117961f, 0.09779011f, 0.23420846f, -0.17759171f, 0.06724072f, -0.03846237f, 
    -0.08987104f, -0.12806062f, -0.13845690f, -0.03751707f, 0.17689590f, -0.23348010f, 0.10293961f, 0.38930830f, 
    -0.43330127f, -0.26088807f, -0.02973926f, 0.10295348f, -0.15996188f, 0.07958401f, -0.07174336f, -0.08747344f, 
    -0.27832580f, -0.04796156f, -0.23649114f, -0.33426321f, -0.04533301f, 0.27286020f, -0.21213171f, 0.28291231f, 
    0.37865436f, 0.17538157f, 0.04538170f, 0.10937005f, 0.01453170f, 0.24018604f, -0.07037303f, -0.00874321f, 
    0.18937321f, 0.03609061f, 0.09318597f, 0.05320932f, 0.26006380f, -0.36221081f, 0.10618550f, 0.25427589f, 
    -0.51747173f, 0.10682894f, -0.78032368f, 0.00969871f, 0.18351641f, -0.07310417f, -0.05147865f, -0.06428477f, 
    -0.08397507f, 0.02820868f, -0.18441902f, 0.17973912f, 0.12180992f, -0.10098598f, -0.04031256f, 0.00286017f, 
    -0.00308625f, -0.11780277f, -0.06863284f, -0.26812485f, -0.21556059f, 0.01394563f, -0.11882414f, 0.36771271f, 
    0.12631209f, -0.11199438f, -0.02932861f, -0.13249050f, -0.41891709f, -0.18276039f, -0.02203652f, 0.11294147f, 
    -0.19239804f, 0.05457044f, -0.00531533f, -0.04017954f, -0.19812533f, -0.40557241f, -0.31198362f, -0.00131511f, 
    -0.21399678f, -0.37805396f, 0.48979086f, -0.20107204f, -0.70055246f, -0.18558347f, -0.05607245f, -0.05977293f, 
    0.23432025f, -0.10438406f, -0.21334696f, 0.01599627f, 0.10953299f, 0.24532923f, 0.08775248f, -0.00587612f, 
    0.20560287f, 0.18743120f, 0.34233186f, 0.32121694f, -1.25726759f, -0.06719416f, 0.20378439f, 0.41067740f, 
    -0.28357592f, 0.17104986f, 0.01041720f, 0.21020405f, 0.52684355f, 0.24581455f, -0.28192046f, -0.14619350f, 
    -0.14225720f, -0.20586596f, 0.07070716f, 0.14993000f, -0.30585068f, -0.11395791f, 0.08136883f, 0.12257503f, 
    -0.25449240f, -0.15250476f, 0.35369575f, 0.05851432f, 0.10834911f, -0.04145640f, 0.03878094f, -0.09644908f, 
    0.13208665f, -0.04672631f, 0.07274155f, -0.04045672f, -0.16525413f, 0.08621172f, 0.05714537f, 0.12161600f, 
    0.02309915f, 0.10968454f, 0.26682353f, 0.06521371f, -0.59877771f, 0.14100164f, 0.22938395f, -0.16949508f, 
    0.24045818f, -0.15047605f, -0.02953451f, 0.40333048f, -0.11140890f, 0.22041330f, -0.23308188f, 0.16712718f, 
    -0.13226773f, 0.24369104f, 0.07894106f, 0.13773997f, 0.11968382f, 0.10647772f, 0.04651375f, 0.18820703f, 
    -0.30184141f, 0.02030054f, -0.48657116f, -0.08279116f, 0.08049921f, 0.20116383f, 0.00334339f, 0.09054448f, 
    -0.19098926f, 0.03453093f, -0.15362597f, 0.11866900f, -0.00669693f, -0.01949702f, -0.00397975f, 0.34430519f, 
    -0.27111340f, -0.19115001f, -0.42012700f, -0.32930568f, 0.00163832f, -0.69088119f, 0.12283804f, -0.30485082f, 
    -0.50598824f, -0.32774323f, -0.47568068f, -0.08268800f, 0.18882209f, -0.25995132f, -0.17587340f, 0.02247395f, 
    -0.05506821f, 0.05758422f, 0.01138260f, 0.23308828f, 0.04176146f, 0.05616092f, 0.08494070f, -0.19071518f, 
    0.08623086f, -0.05909669f, -0.83459955f, 0.31609824f, 0.05884713f, 0.05046271f, -0.23250070f, 0.34069335f, 
    -0.00704137f, 0.07464394f, -0.04790637f, -0.09390602f, -0.00607047f, 0.14800639f, 0.08013063f, 0.11963574f, 
    -0.02103411f, 0.29456007f, 0.03019437f, 0.17842764f, -0.78459305f, 0.11409121f, -0.24702913f, 0.09367542f, 
    0.10092613f, 0.03031064f, -0.02201052f, -0.42123571f, 0.47011203f, -0.01994423f, -0.06061907f, 0.18640281f, 
    0.00462742f, 0.11622123f, -0.04070952f, 0.06042987f, -0.05182290f, -0.36853904f, -0.04096690f, -0.08811929f, 
    -0.01773385f, 0.16854051f, 0.06109298f, 0.09394903f, 0.28977197f, -0.02140027f, 0.02981188f, 0.00249155f, 
    -0.00297359f, 0.11090823f, -0.15551887f, -0.01512425f, 0.10441068f, 0.00961351f, -0.14527817f, 0.13602681f, 
    0.06129339f, 0.15985791f, 0.04646442f, 0.25202972f, -0.21693853f, 0.09637807f, -0.50575751f, 0.44971687f, 
    -0.08349340f, 0.04439217f, -0.23634894f, -0.37510034f, 0.06947877f, 0.04988776f, -0.20338270f, 0.04567490f, 
    -0.10399128f, -0.14429273f, -0.00745946f, -0.01247795f, 0.10313131f, -0.10308967f, 0.17714994f, -0.10416342f, 
    -0.10652115f, 0.12511505f, 0.03152343f, 0.03076439f, 0.03971021f, -0.01037119f, -0.17208932f, -0.18391439f, 
    0.02473615f, 0.09354413f, -0.09053317f, 0.19997124f, -0.07968617f, -0.15157057f, -0.18904704f, -0.21319777f, 
    -0.16668613f, -0.04350218f, -0.18319039f, -0.16780125f, -0.04452442f, -0.40686223f, -0.51808596f, 0.44389313f, 
    -0.08964124f, -0.14492749f, -0.25348920f, 0.40447158f, -0.09126452f, -0.21050806f, -0.13226576f, 0.10229236f, 
    0.02278955f, 0.25191164f, -0.02542766f, -0.07673528f, -0.05072745f, 0.31565669f, -0.05197129f, 0.07147919f, 
    1.07158720f, -0.49013767f, 0.40398896f, 0.24782555f, 0.00574460f, 0.04877938f, -0.09468413f, -0.40211892f, 
    0.24494694f, -0.06751370f, -0.10167109f, 0.01861695f, 0.04050296f, -0.05413585f, -0.03289988f, 0.06158753f, 
    0.12115820f, -0.23093879f, 0.13035907f, 0.22581260f, -0.20783584f, -0.14085875f, -0.03284124f, 0.69557428f, 
    -0.25482205f, -0.14596146f, -0.21363358f, 0.02572577f, 0.03910695f, 0.11591249f, 0.09174140f, -0.19706436f, 
    -0.15608940f, -0.06986180f, 0.02989643f, 0.01588878f, 0.05351827f, 0.10887931f, 0.02410535f, -0.37166569f, 
    0.23518638f, -0.18478754f, -0.17617056f, -0.38712570f, -0.19749396f, -0.11738606f, -0.19969703f, 0.05151424f, 
    -0.29134041f, 0.03871612f, -0.01180688f, 0.12194436f, 0.10193712f, -0.02405048f, -0.14858143f, 0.14682932f, 
    -0.01326953f, -0.02365155f, -0.03946263f, 0.06016480f, 0.31567776f, -0.46817324f, -0.05259224f, 0.24782926f, 
    0.14883226f, 0.00017001f, 0.00854283f, -0.08568661f, 0.07955087f, -0.13316613f, -0.04987478f, 0.10108806f, 
    -0.09853586f, -0.05474954f, -0.14072016f, 0.01252206f, 0.10018436f, 0.12957308f, 0.08656369f, 0.01228842f, 
    -0.01908148f, 0.18968418f, 0.08178493f, 0.03208087f, -0.13645506f, 0.04470192f, 0.13168779f, 0.16709517f, 
    0.08471430f, 0.00111856f, -0.18647286f, 0.01557341f, -0.03408764f, 0.03482242f, -0.04809571f, 0.00487000f, 
    -0.03795857f, -0.02256476f, -0.09129333f, -0.17972174f, -0.29250282f, -0.35732105f, 0.34127724f, 1.01456487f, 
    -0.15922727f, -0.01738954f, 0.22986054f, 0.21748163f, 0.22616659f, -0.17519778f, -0.11191753f, -0.00749050f, 
    0.14589541f, 0.11559588f, -0.12509967f, 0.09726235f, 0.09727621f, 0.08965454f, 0.00146244f, 0.08260202f, 
    0.24758171f, -0.45394549f, 0.36903527f, -0.36599147f, 0.21254545f, 0.13563320f, 0.14911452f, -0.25584733f, 
    -0.02260692f, -0.19875179f, 0.11711812f, 0.11267286f, 0.09347632f, -0.22535279f, 0.07042553f, 0.00858548f, 
    0.09225920f, -0.04478788f, -0.04888383f, -0.31279629f, -0.21127853f, -0.72936195f, -0.22365382f, 0.17798884f, 
    -0.03758727f, 0.09055697f, -0.61574984f, 0.32912013f, -0.52969939f, -0.00193334f, 0.04905953f, 0.05507698f, 
    0.02525948f, 0.02889259f, -0.24973063f, 0.02610245f, -0.11890046f, -0.07253073f, -0.02841781f, -0.12326561f, 
    0.35827002f, -0.42400664f, 0.10499856f, 0.04554813f, 0.22514535f, -0.22809468f, -0.34921777f, 0.17515677f, 
    -0.11078795f, 0.02952469f, 0.03315316f, 0.03275669f, 0.17488204f, -0.02237982f, -0.04839132f, 0.10086875f, 
    0.00596330f, 0.04800155f, -0.08879714f, 0.12393762f, 0.45337737f, 0.20016436f, 0.13165818f, -0.02291831f, 
    -0.16463485f, 0.02816903f, 0.11649039f, -0.06294860f, -0.00780729f, 0.07403115f, -0.19887516f, -0.05516816f, 
    -0.04146118f, -0.04346310f, -0.06471647f, -0.01424179f, 0.07476351f, 0.14082897f, -0.10737147f, 0.08119872f, 
    0.14641763f, -0.13096660f, 0.23477539f, 0.39563337f, -0.09738243f, -0.13769774f, -0.12007335f, 0.03235610f, 
    0.00570337f, -0.06120124f, -0.02848803f, 0.03043536f, 0.04861364f, 0.16576378f, 0.15526883f, -0.06240792f, 
    -0.05934474f, 0.21530709f, 0.16662502f, -0.03296744f, -0.31001338f, -0.25527206f, -0.33481506f, -0.40488401f, 
    -0.20766823f, -0.15381405f, -0.63679987f, -0.04275128f, 0.07604561f, -0.21241201f, -0.08480511f, 0.07003532f, 
    0.07302465f, -0.03573359f, 0.18691993f, 0.14687407f, -0.06850560f, 0.12657955f, 0.45192632f, -0.17027105f, 
    -0.32182887f, 0.18868768f, -0.53974736f, 0.46287745f, 0.10506210f, -0.14417203f, -0.10137340f, -0.03931757f, 
    -0.10857920f, 0.09180837f, -0.02390024f, -0.03671504f, -0.11683398f, -0.27157822f, 0.03892057f, 0.07385407f, 
    -0.18980128f, -0.22658105f, -0.08973812f, -0.38086024f, -0.75847811f, -0.07957616f, -0.51109278f, 0.22168453f, 
    -0.09629176f, -0.02807628f, 0.18850783f, 0.09544650f, 0.08665180f, -0.06770536f, -0.21365331f, 0.09452176f, 
    0.18638074f, 0.10063840f, -0.01141226f, 0.11179865f, 0.00106069f, 0.11601796f, -0.21490474f, -0.22796099f, 
    -0.99906486f, 0.09011059f, -0.57903266f, 0.32589093f, -0.60828084f, 0.04404641f, 0.13798767f, -0.03329646f, 
    0.03706335f, 0.09383448f, -0.10841587f, -0.02182991f, 0.12455134f, -0.04536969f, -0.03001351f, 0.00630757f, 
    -0.02740444f, 0.04583863f, 0.02487333f, 0.13165572f, 0.70845252f, -0.07848448f, 0.73268175f, 0.10239351f, 
    -0.06679405f, -0.00599616f, 0.25538960f, -0.17340150f, 0.28721461f, -0.03321012f, -0.20195623f, -0.06132139f, 
    -0.11918730f, 0.06845453f, 0.07970393f, -0.05675044f, 0.06216564f, 0.08967674f, 0.10223722f, 0.12109523f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.29109180f, 0.15798029f, 0.15451963f, -0.10888226f, -0.16937867f, 0.00674169f, 0.00682410f, -0.22837372f, 
    0.11358722f, 0.05407001f, 0.02438594f, 0.05974933f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
