#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.67299253f, -0.09569363f, -0.88168067f, 0.25957429f, 0.78359240f, 0.57758713f, -0.36499098f, -0.31026676f, 
    -0.20698696f, -1.35318196f, 0.13487567f, -0.46481156f, 0.10509053f, 1.16150200f, 0.00561838f, 0.09114225f, 
    -0.01701173f, 0.64531732f, -1.28356111f, -0.13394490f, 0.67016149f, 1.11470938f, 0.72483963f, 0.19781989f, 
    -0.29024589f, -0.63137466f, -0.12210068f, 0.81389254f, -0.60854369f, -1.10167146f, 0.13859949f, -0.79862106f, 
    -0.19470438f, -0.71363312f, -0.39502522f, -0.19529064f, -0.85943538f, 0.52808785f, 0.60912979f, 0.46797431f, 
    0.18092081f, 0.45330283f, 0.21133445f, -0.21574527f, 0.56614321f, -0.44199899f, -1.33219337f, -0.66601831f, 
    0.75276607f, -0.02560202f, 0.30432224f, -0.85345954f, 0.34865153f, -0.33991295f, 0.83208716f, -0.99414921f, 
    0.95622993f, -0.69289947f, -0.76290137f, -0.77157754f, 0.56446481f, 0.55457944f, 0.12432693f, 1.35706639f, 
    0.80298281f, -0.70666569f, -0.00622480f, 0.41787052f, -0.69413006f, 0.15585254f, 0.07673495f, 0.35954231f, 
    -0.91604787f, -0.90968645f, -0.74948800f, -0.43666354f, -0.80361158f, -0.31086618f, 0.47508743f, 0.03890425f, 
    -0.14631845f, 0.15939330f, -1.09518778f, -1.28331280f, -0.73325247f, 0.12403737f, 0.17249636f, 0.74660313f, 
    0.02055321f, -0.04555056f, 1.12693596f, -0.52919930f, 0.52409923f, 0.85944057f, 0.69190621f, 0.61760682f, 
    -0.32802710f, 0.22659259f, -0.28367674f, -0.04868606f, 0.19082959f, -0.81035221f, 0.35473254f, -0.85864776f, 
    0.40448812f, 0.72325122f, -0.55478269f, -0.21206051f, 0.57233691f, 0.72878331f, 1.03456020f, 0.91908532f, 
    -0.13747209f, 0.49943700f, 0.21875122f, 0.46052045f, 0.54265851f, 0.94245982f, 0.87051934f, 0.49231291f, 
    0.30782253f, -0.35719204f, 0.58949363f, -0.73277843f, 0.16553853f, -0.17627639f, -1.29936314f, 1.10601997f, 
    0.67426986f, -0.60413086f, 0.53690672f, 0.64183855f, -0.45772487f, 0.38529158f, -0.04807113f, 0.80784535f, 
    -0.11679544f, -0.42480496f, 0.48026940f, 0.39304098f, 0.45057699f, -0.54702425f, -0.82025903f, 0.57219392f, 
    -0.79640746f, 1.54396689f, -0.79861230f, -0.45618105f, 0.70050079f, -0.98925787f, 0.05610157f, -0.37327170f, 
    0.42552453f, -0.44583467f, -1.27878034f, -0.07603514f, 0.33027336f, 0.54406595f, 0.95521593f, -0.16063294f, 
    -0.49354917f, -0.29267284f, 0.88175458f, 1.30586255f, 0.72483742f, -0.95491838f, 0.32630703f, -0.09515674f, 
    0.28307167f, 0.55721205f, -0.07623136f, 0.45625731f, 0.65266359f, -1.06588602f, -0.90171880f, 0.34003189f, 
    0.83909112f, -0.23025693f, -0.32790881f, 0.74877691f, 0.32724643f, 1.01720750f, 0.60768247f, 0.71987969f, 
    -0.40064517f, -1.36044192f, 0.02109054f, 0.50954193f, 0.33828625f, -0.46845907f, -0.15013069f, -0.80424047f, 
    -0.15689041f, -0.87960964f, -0.92620063f, -0.37592992f, 0.24455358f, 0.51449347f, -0.58264548f, 0.71692222f, 
    -0.25090203f, -0.47541451f, -1.10692322f, -0.22215743f, 0.31393620f, -0.58710498f, 0.04804269f, 1.32470679f, 
    0.34574407f, 0.91920036f, 0.12546574f, -0.83276618f, -0.47889951f, 0.32934061f, 0.20381613f, -0.42874959f, 
    0.89324176f, 1.03905308f, -0.60879046f, 1.05833006f, -0.09252726f, -0.67739898f, -0.31451225f, -0.40685809f, 
    -0.34129405f, -0.59735572f, 0.26355299f, 0.94748694f, -0.58604383f, 0.57970464f, 0.60270452f, 0.10598016f, 
    0.45770869f, 0.65770870f, -0.53649193f, -0.86429161f, -0.59092951f, 0.72543615f, 0.94946128f, 0.06356627f, 
    0.12047657f, 0.34863734f, -0.20697492f, 0.25032657f, 1.09400558f, 0.99611217f, -1.05358911f, -0.21849053f, 
    0.23520797f, 0.11416337f, -0.20870288f, -0.75958955f, -0.45208848f, -1.56498897f, -0.30401668f, -0.84839767f, 
    1.17624831f, 0.45034558f, 0.17511313f, 0.17783220f, -0.14413781f, -0.08472889f, -1.11898148f, 0.27116156f, 
    -0.57558268f, -1.21500945f, -0.77715898f, -0.40789697f, 0.16923946f, -0.60194188f, -0.74297684f, 0.78855723f, 
    -0.20391141f, -0.35746095f, -0.73673499f, -0.69760442f, -0.26200211f, 0.56958008f, -0.63947445f, 0.83680254f, 
    1.00059319f, -1.28111744f, 0.39746568f, -0.57326841f, 0.66134018f, 0.20265444f, 0.00790616f, -0.00346146f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.15693992f, 0.25070143f, -0.09095471f, 0.07894373f, 0.25280657f, 0.09630582f, 0.13723055f, 0.05642601f, 
    0.07856172f, 0.27293947f, 0.28374609f, 0.10208683f, 0.06299878f, 0.26130056f, 0.33515483f, 0.10813522f, 
    0.03051146f, 0.12264717f, -0.01045572f, 0.08707919f, -0.04198961f, 0.26106840f, 0.07121382f, -0.02014125f, 
    -0.11967477f, 0.20917262f, 0.17187160f, -0.10024615f, 0.26782805f, 0.02763350f, 0.26980186f, -0.10479136f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.25535238f, 0.33919027f, 0.02218369f, -0.20704049f, -0.25991309f, 0.07546441f, 0.10693907f, -0.13602102f, 
    0.19673024f, -0.13943237f, 0.02117230f, -0.03450206f, -0.07503974f, 0.09080546f, 0.11201199f, -0.05913547f, 
    0.13825861f, -0.05664120f, -0.02399514f, 0.02766211f, 0.45534405f, 0.16426368f, 0.10237924f, -0.27202427f, 
    -0.12968865f, 0.04035598f, -0.01189622f, -0.15277772f, 0.05359020f, -0.10609515f, 0.02034135f, -0.08636349f, 
    -0.08529454f, 0.04326479f, 0.10129404f, 0.07774081f, -0.01079335f, 0.02073894f, 0.05100790f, 0.02767422f, 
    0.26856330f, 0.04377188f, 0.44405067f, 0.07616928f, -0.21832691f, 0.03022118f, 0.09249146f, 0.13691263f, 
    0.03250447f, 0.01535372f, -0.05251390f, 0.01929595f, -0.06534337f, -0.05530680f, -0.03151420f, 0.06138985f, 
    0.08320901f, 0.00475106f, 0.02631207f, 0.09414203f, 0.24161051f, -0.44126227f, 0.20244458f, 0.18764283f, 
    0.00462810f, 0.06496640f, 0.20442079f, 0.03486729f, -0.03900072f, -0.03004064f, -0.09046128f, -0.01478482f, 
    -0.00474745f, 0.06685334f, 0.03893274f, -0.01262012f, 0.01590871f, 0.05069906f, -0.05773499f, -0.03498084f, 
    0.07096394f, -0.18549404f, 0.09064757f, -0.01436412f, 0.05681892f, -0.11728149f, -0.01560666f, 0.02959190f, 
    -0.08335359f, 0.03777328f, 0.04525483f, -0.03631001f, 0.10131264f, 0.01029634f, 0.03716013f, -0.08557433f, 
    -0.00192627f, -0.03109926f, 0.02426153f, -0.02874634f, 0.03299542f, -0.03302315f, -0.16879851f, -0.11810741f, 
    -0.34785712f, 0.09753660f, 0.10170295f, 0.01885138f, 0.05078663f, 0.01661662f, 0.05815206f, 0.00449661f, 
    0.06826993f, 0.07268207f, 0.02364458f, 0.01183546f, -0.02039853f, 0.00165646f, -0.10281421f, 0.10027789f, 
    0.22668800f, -0.48331010f, 0.11791010f, 0.05112474f, -0.42686415f, -0.06806739f, 0.00405183f, -0.03585391f, 
    -0.11119986f, -0.08363041f, -0.15736398f, 0.08466907f, -0.02763663f, -0.04702327f, -0.04161216f, -0.02387387f, 
    -0.14222781f, 0.09202930f, 0.06379279f, 0.02640619f, -0.14672390f, 0.04466039f, 0.06602827f, -0.21293302f, 
    0.45006692f, -0.16556039f, -0.03523870f, 0.00112310f, 0.18115056f, 0.06630041f, 0.00635136f, 0.06093842f, 
    0.09468021f, -0.10234206f, -0.15567818f, 0.00562375f, -0.06239179f, 0.02971257f, 0.03854093f, 0.00690336f, 
    -0.31856480f, -0.50001854f, -0.28731808f, 0.10575104f, -0.15300089f, -0.04116739f, -0.13084193f, 0.03902028f, 
    0.19544946f, -0.00376292f, 0.02386514f, -0.14645374f, -0.13729750f, -0.03035629f, 0.03328653f, 0.07951232f, 
    0.01463542f, 0.04681173f, 0.06862169f, 0.01511693f, -0.27644330f, 0.00297778f, -0.13349868f, 0.06472541f, 
    -0.12161383f, -0.03378708f, -0.11820471f, 0.04785171f, -0.06715845f, 0.03814016f, 0.05104770f, -0.14391543f, 
    -0.10168394f, -0.03819224f, 0.06348930f, -0.02147071f, -0.05386099f, -0.06959164f, 0.06589802f, 0.01633839f, 
    0.25972164f, 0.09870393f, -0.03064015f, -0.07279556f, -0.00874598f, 0.00773833f, -0.03480798f, 0.00548760f, 
    0.04539803f, -0.02070780f, -0.09304765f, -0.02268796f, 0.00556979f, -0.01747743f, 0.02239111f, 0.01419455f, 
    0.05146893f, -0.00507564f, -0.11172131f, 0.03758010f, 0.15426864f, -0.28370857f, 0.14605387f, 0.11006736f, 
    -0.10655542f, -0.03891994f, 0.03700283f, -0.09699132f, -0.01778991f, 0.00768403f, 0.01667197f, -0.03862729f, 
    0.02215619f, 0.03215519f, -0.02069111f, 0.01458193f, -0.09269699f, 0.05337045f, -0.05078125f, -0.08518407f, 
    -0.21454297f, -0.14402878f, 0.09577187f, -0.00451464f, -0.05835089f, -0.04061952f, -0.10514116f, 0.03218123f, 
    -0.10118061f, -0.01475683f, 0.03142046f, 0.01206892f, -0.00470892f, 0.00356962f, -0.02973733f, -0.04167604f, 
    0.03340071f, 0.05712890f, -0.19305100f, 0.07060041f, 0.26950184f, 0.01459146f, 0.01239479f, -0.14090273f, 
    0.11830989f, -0.03851910f, -0.18095003f, -0.10612812f, 0.05762779f, 0.04131375f, -0.06901764f, -0.04399953f, 
    0.00468918f, 0.01387694f, 0.01797184f, 0.06853242f, 0.07206732f, -0.12113290f, 0.00964945f, 0.06685705f, 
    -0.22646955f, 0.07675195f, 0.14632899f, 0.06401656f, 0.22219935f, 0.00678417f, -0.08277553f, 0.05288628f, 
    -0.00322044f, -0.04053459f, 0.06302488f, -0.08150943f, -0.02980020f, -0.01627360f, -0.09288253f, -0.04641310f, 
    -0.00929551f, 0.03021319f, 0.10696277f, 0.01119581f, -0.03596127f, -0.06685159f, -0.03190812f, 0.07113843f, 
    0.15292305f, -0.00189199f, 0.14224204f, 0.11184146f, 0.04578212f, -0.12764184f, -0.00748000f, -0.00477986f, 
    0.10574011f, -0.11092325f, 0.04917071f, 0.06369177f, 0.11016918f, -0.13570845f, -0.18722431f, 0.06054136f, 
    0.40785378f, -0.07792638f, 0.07686027f, -0.13954425f, 0.11944779f, -0.00512474f, -0.06629601f, 0.03936489f, 
    -0.01729009f, 0.10696574f, 0.06982454f, 0.05457657f, -0.03225303f, -0.05933498f, 0.13674450f, -0.14630364f, 
    -0.15491614f, 0.22997807f, -0.13355890f, -0.13247401f, -0.15519053f, 0.23410819f, 0.09373162f, -0.09166391f, 
    -0.25068429f, 0.08295875f, 0.13272661f, -0.06412157f, 0.04692958f, -0.03571332f, 0.04526642f, -0.09484779f, 
    0.05109292f, 0.04332862f, -0.06140893f, 0.03627015f, 0.01469277f, -0.00994794f, 0.10485930f, 0.03291208f, 
    0.00123659f, 0.12492138f, -0.07549036f, -0.13042651f, 0.34808737f, -0.17915480f, -0.07533054f, -0.19751170f, 
    0.07571244f, 0.08063685f, -0.03576015f, 0.00690652f, 0.04233125f, -0.02611395f, 0.05838852f, -0.10606590f, 
    0.03664649f, 0.05707310f, -0.00312084f, -0.05662414f, -0.42165446f, 0.04415587f, 0.01449686f, -0.16337703f, 
    0.03387510f, -0.04347845f, -0.09244276f, -0.09355745f, -0.00789157f, -0.04183477f, 0.06867234f, -0.04763421f, 
    0.16761792f, 0.12057878f, -0.01030028f, -0.07122762f, -0.08635719f, -0.08903769f, -0.14047007f, -0.05957318f, 
    -0.17006402f, 0.00548870f, 0.16246706f, -0.20429258f, 0.08836561f, -0.12313144f, -0.21857762f, 0.03811559f, 
    -0.10527529f, -0.01037230f, -0.10530457f, 0.05467126f, -0.03894607f, 0.04404406f, -0.09511925f, 0.03139209f, 
    0.03045250f, 0.10256775f, -0.10363614f, -0.04759606f, -0.17594491f, -0.46153432f, 0.06818470f, 0.05662089f, 
    -0.01472853f, 0.02051354f, 0.03064756f, -0.06335392f, -0.02081418f, -0.01319131f, -0.09513649f, -0.07704492f, 
    -0.08710895f, 0.03411024f, -0.11721532f, 0.06366684f, 0.00638307f, 0.06548193f, 0.01588301f, -0.09491148f, 
    -0.10090449f, 0.09524978f, 0.04618055f, -0.05427823f, 0.05502335f, -0.15698822f, -0.03660291f, -0.01232319f, 
    0.11059849f, -0.04596145f, 0.06111267f, 0.06589568f, 0.08613981f, -0.03378231f, -0.04227734f, 0.04372734f, 
    -0.02443451f, 0.04030387f, -0.10045071f, -0.20756690f, 0.21843436f, -0.14615361f, 0.01490977f, -0.24489865f, 
    0.03156060f, -0.21615298f, -0.17615664f, -0.04037409f, 0.06210177f, 0.02028472f, -0.05205508f, -0.07200539f, 
    -0.06784370f, -0.06669458f, -0.04544074f, 0.05964488f, -0.08246306f, 0.14718346f, 0.07626028f, 0.09317211f, 
    0.27095893f, -0.11370269f, 0.11761054f, 0.00757328f, 0.37342367f, -0.19571005f, -0.11216827f, 0.12390897f, 
    0.12110042f, -0.02292809f, 0.10085642f, 0.16751328f, -0.14348556f, 0.05022084f, -0.08974379f, -0.00170372f, 
    0.10970055f, 0.06946262f, -0.09147505f, -0.02983258f, -0.37572515f, -0.09141143f, -0.03436375f, 0.11429276f, 
    0.02221419f, 0.06377600f, -0.02127695f, 0.02682950f, 0.04889268f, -0.08627972f, 0.07379296f, -0.01594933f, 
    0.06024054f, 0.09277128f, -0.00062249f, -0.06493421f, 0.04722889f, -0.03241543f, -0.05129983f, -0.10817547f, 
    -0.11847474f, 0.20023003f, 0.09108306f, -0.19216204f, -0.32429278f, 0.06393798f, 0.06172305f, 0.05981454f, 
    0.10740665f, -0.09490785f, -0.00515364f, 0.05879525f, 0.02383044f, 0.01702489f, 0.04730650f, 0.04400919f, 
    0.11177941f, 0.05939108f, 0.05862120f, -0.00334826f, -0.02592721f, 0.25680032f, -0.04098844f, 0.04037718f, 
    0.36402717f, -0.15645184f, -0.21250278f, -0.03389634f, -0.01215473f, 0.04731323f, 0.05955895f, -0.05903476f, 
    0.02679697f, 0.03932776f, 0.06745339f, 0.12141818f, 0.03831843f, -0.05915523f, 0.06252819f, -0.01022814f, 
    -0.46781769f, 0.21118376f, -0.11477184f, -0.01064205f, -0.40426490f, -0.02334226f, 0.08170804f, -0.06065623f, 
    0.02341646f, 0.02348018f, 0.00359438f, 0.07485100f, -0.07583775f, 0.04257400f, 0.03129991f, -0.07287839f, 
    -0.10514318f, 0.02924556f, -0.02418792f, 0.05691168f, -0.01182268f, -0.53595960f, 0.05216723f, 0.13131148f, 
    -0.29562411f, 0.04493401f, -0.07355084f, 0.03714642f, -0.00963071f, -0.00478334f, -0.14674869f, -0.05264441f, 
    -0.04975416f, -0.01899674f, 0.06473572f, -0.04058254f, -0.01814563f, -0.03267405f, -0.06879561f, 0.00017918f, 
    -0.23686469f, 0.03060679f, 0.11774066f, 0.02719177f, 0.01480518f, 0.03133169f, -0.13389549f, -0.01883511f, 
    -0.13721798f, 0.09525356f, -0.02778400f, 0.02744697f, -0.13415842f, -0.01525723f, -0.10134169f, -0.10779169f, 
    0.03439540f, 0.09393975f, 0.03575027f, -0.12085818f, 0.22041878f, -0.30897093f, 0.16964754f, -0.15855667f, 
    0.28953716f, -0.26295972f, 0.03935059f, -0.01813309f, 0.03552835f, 0.02754939f, 0.04722220f, 0.03451194f, 
    -0.07131830f, -0.01220943f, 0.02927792f, 0.02891844f, -0.04206956f, -0.02858908f, -0.17964241f, 0.05833044f, 
    0.01838191f, -0.04068935f, -0.19170815f, -0.02374932f, -0.23775755f, 0.02541447f, -0.02565165f, -0.18316528f, 
    -0.06215380f, 0.05233371f, 0.02833676f, 0.02157086f, 0.05233702f, -0.09714589f, 0.17122105f, 0.07769322f, 
    -0.02878510f, -0.01236256f, -0.00510378f, 0.11167368f, -0.15324979f, 0.08809712f, -0.14060836f, 0.00118854f, 
    0.05767997f, 0.05741289f, 0.14782391f, -0.02801682f, -0.00156346f, -0.01027893f, -0.05247513f, -0.00928539f, 
    -0.01521259f, -0.10016418f, 0.03457504f, 0.07031880f, 0.04274131f, 0.00722271f, 0.03121468f, -0.03856025f, 
    -0.43561143f, 0.13261592f, -0.22711559f, 0.05616333f, -0.07579269f, 0.04709858f, 0.00754719f, -0.05767349f, 
    -0.18404071f, 0.00474805f, 0.07072139f, 0.16881245f, -0.08052845f, 0.02386824f, 0.04306353f, 0.05036327f, 
    -0.16397351f, 0.02605305f, 0.05092191f, -0.01774283f, -0.02595844f, -0.22247192f, 0.13878444f, -0.41101351f, 
    0.04427585f, -0.10198732f, -0.01572168f, -0.04983867f, 0.03302623f, 0.00503550f, -0.07569319f, -0.00413869f, 
    -0.02486059f, 0.05136237f, -0.18783671f, -0.05640334f, -0.07432450f, -0.20679076f, 0.03630589f, -0.18862171f, 
    -0.19070911f, 0.17230146f, 0.00965083f, 0.05628288f, 0.03446644f, 0.02061538f, 0.03393831f, 0.11231244f, 
    -0.01632583f, 0.03347491f, -0.09849527f, -0.06218693f, -0.00859387f, -0.01136353f, 0.00019074f, 0.15487880f, 
    -0.01398164f, 0.04161506f, 0.08938402f, 0.00603723f, 0.26647383f, -0.13764358f, -0.06717389f, 0.02408522f, 
    -0.25269827f, 0.03280612f, 0.08282761f, 0.00754520f, 0.03546207f, 0.09664348f, 0.06378260f, 0.00188625f, 
    0.08411218f, -0.00101147f, -0.07295067f, 0.03400779f, 0.17165412f, -0.05586620f, -0.04017913f, 0.02235407f, 
    -0.19669688f, -0.15006423f, 0.04406663f, 0.03570950f, -0.20049135f, -0.01795486f, 0.10433840f, 0.01627310f, 
    0.11841553f, -0.10206317f, 0.06450314f, 0.08379734f, 0.05893385f, 0.00372079f, 0.01066337f, -0.03995378f, 
    0.00386460f, -0.20582028f, -0.00532913f, -0.00738092f, 0.53030181f, -0.25939918f, 0.19271070f, -0.29899600f, 
    -0.13756804f, -0.10264866f, -0.31097013f, -0.07043009f, -0.01185331f, 0.00106507f, -0.07914978f, -0.01449495f, 
    -0.03685996f, 0.04240304f, 0.19247031f, -0.11863486f, -0.08839474f, -0.08114499f, -0.10361111f, -0.01633821f, 
    0.20048150f, 0.16263942f, 0.03062217f, -0.04768876f, -0.15822886f, 0.19289126f, -0.02137516f, 0.03924192f, 
    0.11092491f, 0.11821433f, -0.05335334f, -0.07478185f, 0.03223976f, 0.13292083f, -0.07732160f, 0.06482731f, 
    0.10046284f, -0.23529346f, -0.20874417f, -0.19089347f, 0.35166979f, -0.10520073f, -0.12624814f, 0.04842027f, 
    -0.08097361f, -0.08819740f, 0.10402014f, 0.04506731f, 0.17033109f, 0.08091518f, 0.00242663f, 0.00127936f, 
    0.03668673f, 0.04768924f, -0.05056057f, 0.16216132f, -0.05303905f, 0.09660722f, -0.08391439f, -0.01011066f, 
    0.43416283f, 0.02539787f, 0.15634498f, 0.09817336f, 0.04958910f, 0.05744396f, 0.04601862f, 0.03011096f, 
    0.00195292f, 0.08479585f, 0.17173900f, 0.03592683f, -0.04932421f, 0.03676554f, -0.16428185f, 0.01938436f, 
    0.02303174f, 0.03919378f, 0.08155886f, 0.07552111f, -0.16939832f, 0.12225057f, -0.02736782f, -0.11058786f, 
    0.16638614f, 0.04495032f, -0.01876853f, 0.02936402f, -0.08813130f, 0.08577925f, 0.15139864f, -0.01948120f, 
    -0.04549931f, -0.00817722f, 0.02180740f, -0.14783421f, 0.04546246f, -0.04517232f, 0.11185183f, 0.16661511f, 
    0.14543833f, 0.26473820f, 0.11802003f, 0.00632101f, 0.29982960f, -0.17190132f, -0.03661285f, 0.02528194f, 
    -0.01948582f, 0.11524268f, -0.00132648f, 0.02283724f, 0.06169172f, 0.02669162f, 0.03126231f, -0.00284822f, 
    0.00842656f, 0.02325032f, 0.01480321f, 0.09919074f, 0.30075103f, 0.09366443f, 0.09874203f, 0.15812412f, 
    0.31339443f, -0.01971146f, -0.05233495f, -0.00795777f, 0.01053357f, -0.00884823f, 0.02992160f, 0.00703322f, 
    0.01922864f, -0.01066828f, -0.07252590f, 0.04175506f, -0.03600132f, 0.07009938f, 0.06697853f, -0.02992983f, 
    -0.31578669f, 0.11912035f, -0.22788356f, -0.31877896f, 0.00756637f, 0.10223331f, 0.15471031f, -0.01223648f, 
    -0.05511177f, -0.07428492f, -0.02214914f, 0.02639654f, 0.12468102f, -0.00278170f, -0.00655827f, -0.01430199f, 
    -0.00608608f, 0.08065686f, -0.04839437f, 0.03660383f, 0.10719217f, -0.10807715f, 0.02346590f, 0.03215587f, 
    -0.00993800f, -0.11309073f, -0.12606558f, -0.18811889f, 0.00815941f, 0.04213331f, 0.08526920f, 0.16335806f, 
    -0.08601058f, 0.06770916f, -0.05116018f, -0.06540552f, -0.01469774f, 0.06273219f, 0.18032499f, 0.04894279f, 
    -0.28230014f, -0.09147082f, -0.22892140f, -0.40742657f, 0.16956989f, -0.02929850f, 0.05695606f, 0.02508044f, 
    -0.02227965f, 0.05796354f, 0.07224155f, -0.11567711f, 0.16470900f, 0.10170761f, 0.11501580f, -0.01461253f, 
    -0.00103564f, -0.08535984f, -0.04494742f, -0.04731255f, 0.14612621f, 0.02476388f, -0.07766294f, 0.07911411f, 
    -0.23973998f, -0.05430926f, 0.05122271f, -0.03690055f, -0.06027566f, 0.08466071f, 0.15515924f, 0.06751851f, 
    -0.11542905f, -0.00601529f, 0.02105965f, 0.05449701f, 0.10068786f, 0.00305339f, -0.01349921f, -0.01883466f, 
    0.14550798f, 0.14554518f, -0.04384460f, 0.07780271f, 0.07867967f, -0.07887200f, -0.03250956f, 0.05085080f, 
    0.01972841f, -0.02630811f, 0.10376164f, 0.08414132f, 0.04435747f, 0.19683637f, -0.07171283f, 0.09984174f, 
    0.03903287f, -0.07224117f, -0.12447733f, -0.02187923f, 0.30683011f, -0.13382222f, 0.05720150f, -0.25893182f, 
    -0.04091320f, 0.07673412f, 0.00285824f, -0.11630885f, 0.16225496f, -0.11892495f, -0.17291102f, -0.06459258f, 
    -0.15727147f, -0.06333151f, 0.06634478f, -0.05165545f, -0.09055944f, 0.15282117f, 0.03495203f, 0.00886236f, 
    -0.13224287f, -0.13657795f, 0.12140328f, -0.02169016f, 0.29651284f, -0.09444154f, -0.01731845f, 0.03194330f, 
    -0.07039157f, 0.05712476f, 0.02727002f, 0.01933378f, 0.10299049f, -0.01525330f, 0.05822512f, -0.06856528f, 
    -0.10181895f, -0.09989914f, -0.01911015f, 0.04873283f, -0.11465333f, -0.03765316f, -0.04601088f, -0.19717059f, 
    0.04846553f, 0.00074416f, -0.13423830f, 0.22625577f, 0.04850299f, -0.01817898f, -0.04387344f, -0.06032854f, 
    0.08968076f, -0.00276482f, 0.11859746f, -0.06974746f, 0.09617025f, -0.21074426f, -0.08604752f, -0.17782533f, 
    -0.03278634f, -0.23731500f, -0.05796447f, -0.32089105f, -0.01547721f, 0.13411003f, 0.02151053f, 0.01622352f, 
    0.03270537f, -0.00860474f, -0.09515960f, -0.06086791f, -0.03700478f, 0.10065763f, -0.09869439f, -0.09987121f, 
    -0.05951353f, -0.02076991f, 0.10504065f, 0.01257497f, 0.06559838f, 0.07012853f, 0.16063635f, 0.07448819f, 
    -0.02324237f, -0.03476653f, -0.12523878f, -0.04139384f, 0.00617915f, -0.02423670f, 0.00407539f, -0.08341228f, 
    0.12501328f, 0.06293258f, 0.04186144f, -0.02537435f, 0.04953629f, -0.15223166f, -0.06086484f, 0.02734635f, 
    -0.06750939f, -0.43860900f, 0.08057340f, -0.23395465f, 0.24074644f, -0.02871727f, -0.11908972f, -0.02881935f, 
    0.04321970f, 0.00687976f, -0.17739053f, -0.05206908f, -0.03097423f, -0.10966855f, -0.10245118f, -0.10854874f, 
    0.00692865f, -0.10367285f, 0.17498007f, -0.06292941f, -0.29825008f, 0.25590578f, -0.00870508f, -0.13505514f, 
    0.05713796f, -0.08468346f, -0.02321586f, -0.08130985f, -0.09985638f, -0.04863208f, -0.03560931f, -0.06519348f, 
    -0.01754891f, -0.07992055f, -0.02789361f, 0.01203919f, -0.08371362f, 0.09438239f, 0.00476755f, 0.12918164f, 
    0.25848675f, -0.09329468f, -0.20556942f, -0.00590270f, -0.19403498f, 0.06802539f, -0.02173434f, -0.02219460f, 
    0.02889121f, 0.14033425f, -0.02767785f, -0.02980267f, -0.02440147f, 0.01496446f, -0.07548300f, 0.11039916f, 
    0.12682226f, -0.04602334f, -0.12026607f, 0.02475876f, -0.11583506f, 0.23280406f, -0.21310745f, 0.08974550f, 
    -0.01442713f, -0.00529306f, 0.08753116f, 0.08514772f, 0.02855325f, 0.04900099f, -0.01985598f, -0.01692163f, 
    -0.07152495f, 0.04740616f, -0.12329086f, -0.01348575f, -0.02565340f, 0.03497048f, -0.18957138f, -0.05865148f, 
    0.22960953f, -0.34311092f, -0.09233769f, 0.09576627f, -0.04863142f, -0.12451232f, 0.03362297f, 0.02729393f, 
    0.12249788f, 0.06117626f, 0.06444831f, -0.04726722f, -0.01876502f, -0.06074460f, -0.06302884f, 0.10892984f, 
    -0.02020903f, -0.09899676f, -0.17411491f, 0.01744684f, -0.19190976f, 0.05082802f, 0.11091941f, -0.22832347f, 
    -0.19798072f, -0.01279688f, 0.02078792f, 0.09311198f, 0.02583028f, 0.05470941f, -0.17038411f, -0.15782903f, 
    0.19957680f, 0.02537864f, 0.07068540f, -0.07157558f, -0.02894829f, -0.06887968f, -0.02527621f, 0.09250214f, 
    -0.21079156f, -0.29332432f, -0.34229761f, -0.37786719f, -0.00194763f, 0.05494352f, -0.03558051f, 0.01457081f, 
    -0.05322786f, 0.14369339f, 0.04476410f, 0.13553753f, 0.04660596f, -0.10728942f, 0.02295929f, -0.11660709f, 
    -0.04876548f, -0.04980838f, -0.10788822f, 0.09865998f, 0.02218166f, -0.47302616f, 0.09384589f, -0.02406523f, 
    0.21743245f, -0.04818150f, -0.09341320f, -0.01436628f, -0.01938836f, -0.10939086f, 0.07929764f, 0.00086947f, 
    -0.18045589f, 0.05795371f, -0.03159221f, -0.15865199f, -0.01666990f, 0.11496164f, 0.06144762f, -0.05144744f, 
    0.26279998f, 0.04324148f, 0.02504167f, 0.20666583f, 0.24814449f, -0.08114787f, -0.07470474f, -0.08464574f, 
    0.07449608f, 0.17313136f, 0.13729446f, -0.05626483f, 0.01361190f, 0.11391386f, -0.00160237f, 0.00312995f, 
    0.00325966f, -0.02209589f, -0.13465205f, -0.03831350f, 0.27932000f, 0.00973932f, 0.06265152f, -0.03262573f, 
    0.12590362f, 0.02319546f, -0.10489222f, -0.19819817f, 0.01126377f, 0.01147406f, 0.05365971f, -0.02356181f, 
    0.03062789f, -0.02409944f, -0.02718286f, 0.07446259f, -0.07732057f, -0.03925653f, 0.03154547f, -0.01326489f, 
    0.48347810f, -0.01827954f, 0.10466595f, -0.05748459f, 0.25073498f, -0.05766292f, -0.08333255f, 0.00456774f, 
    0.05456774f, 0.06518062f, 0.06656455f, 0.04933850f, -0.04673694f, 0.00096245f, 0.07662174f, -0.01206563f, 
    -0.02586518f, -0.03054951f, -0.07315815f, -0.05088200f, -0.24086364f, -0.34774065f, -0.17403150f, -0.04157107f, 
    -0.35954294f, 0.07153520f, -0.13296467f, -0.04146193f, 0.02136473f, 0.05676680f, -0.03662090f, 0.02347746f, 
    -0.02067963f, 0.00989984f, 0.00981873f, -0.09239937f, -0.02366329f, 0.12336277f, -0.02185767f, -0.06989453f, 
    0.25942537f, 0.15796152f, 0.02665369f, 0.00893477f, -0.04344448f, -0.05980552f, 0.01337918f, 0.00963214f, 
    -0.03276050f, -0.02777692f, -0.02923821f, 0.10704300f, 0.05091121f, 0.02369944f, 0.04713273f, -0.03193858f, 
    -0.03527566f, -0.04309649f, 0.03790668f, -0.04269405f, -0.00057893f, 0.02955044f, 0.18534437f, 0.09578402f, 
    0.19221656f, -0.14798103f, -0.08812042f, -0.21465634f, 0.01801842f, 0.05174688f, -0.05006203f, -0.02465825f, 
    -0.15236373f, 0.03197659f, 0.07856525f, -0.06151448f, 0.02887244f, -0.05738305f, 0.00080269f, -0.00430484f, 
    -0.08175166f, 0.12397686f, 0.05656660f, -0.13561112f, -0.06213521f, -0.07014058f, 0.16242933f, -0.01799538f, 
    0.04638759f, -0.05395223f, 0.03534427f, -0.15489128f, 0.05671079f, -0.20437379f, -0.03201303f, 0.06843132f, 
    0.07604226f, -0.00239901f, 0.09481531f, -0.03466722f, 0.13764708f, -0.07429639f, 0.08473437f, -0.33193067f, 
    -0.01480568f, 0.05454095f, -0.06451132f, 0.12355150f, -0.03073228f, -0.02098217f, -0.18583448f, 0.05316196f, 
    0.08719683f, -0.10103951f, -0.02589631f, 0.02172219f, -0.05387406f, 0.16150692f, 0.08616001f, -0.02903366f, 
    0.04845983f, -0.42875603f, -0.16535327f, -0.00864431f, -0.32802176f, -0.17666888f, 0.00914305f, -0.12131860f, 
    -0.12776884f, 0.04377561f, -0.02209242f, 0.11428896f, 0.04201919f, -0.13240327f, -0.02140899f, 0.00535348f, 
    -0.04318012f, 0.01781072f, 0.05489678f, -0.00093839f, 0.43523282f, -0.43062606f, 0.04462354f, 0.11543038f, 
    -0.19592096f, -0.12626614f, 0.02430352f, 0.02437295f, -0.09592716f, -0.04693227f, -0.04137219f, -0.02504966f, 
    0.13511682f, -0.01357246f, -0.02108349f, 0.08158126f, -0.09145097f, 0.05657234f, 0.00715871f, -0.04283119f, 
    -0.21405494f, 0.07998089f, 0.11039181f, -0.13087974f, 0.04475768f, 0.00842927f, -0.04672598f, 0.00865579f, 
    0.11242908f, 0.05584707f, -0.07026809f, -0.05991627f, 0.01208134f, -0.01755616f, 0.01216490f, -0.04215678f, 
    -0.06492467f, -0.02989574f, -0.00572284f, -0.00230115f, -0.15382794f, -0.02136417f, -0.01511753f, 0.07290328f, 
    0.00859123f, -0.05193100f, -0.13989720f, 0.01270066f, -0.01891283f, 0.06761824f, 0.10537428f, -0.02307975f, 
    0.03621701f, 0.04525773f, 0.05341336f, 0.06240813f, -0.01334770f, 0.05838256f, -0.13636793f, -0.02130020f, 
    -0.10082650f, 0.08712111f, 0.07593693f, 0.01951649f, -0.03593003f, -0.04970970f, 0.09887780f, 0.05293922f, 
    -0.08283713f, -0.11168128f, -0.11347973f, 0.09317891f, -0.05913276f, 0.00510972f, 0.01452228f, 0.02054995f, 
    -0.12544417f, 0.01773955f, 0.01157345f, 0.00830101f, -0.20330630f, 0.02033569f, 0.04923167f, -0.17898817f, 
    -0.00808905f, 0.10184791f, 0.01741488f, 0.05432982f, 0.00730159f, -0.01135780f, -0.07567457f, 0.01378778f, 
    0.09573220f, 0.04388144f, -0.03125577f, -0.12141607f, -0.05589009f, 0.02466165f, -0.11826158f, -0.02836633f, 
    0.34574768f, 0.08934049f, -0.37463993f, 0.05258395f, -0.11858859f, -0.08406125f, 0.05894873f, 0.07515180f, 
    -0.05265857f, -0.00229235f, -0.06467038f, -0.02834550f, 0.00694243f, 0.02089545f, 0.04487596f, -0.04505666f, 
    0.05331932f, -0.12621203f, 0.04092696f, 0.13611463f, -0.24733904f, 0.01717650f, 0.15447000f, 0.08352748f, 
    -0.08659750f, 0.08864345f, -0.22899675f, -0.00783875f, 0.06575039f, 0.11002048f, -0.07472760f, -0.04457517f, 
    -0.00032000f, 0.19058962f, -0.10994840f, -0.21707591f, -0.08308099f, -0.07489045f, -0.00875232f, -0.03390099f, 
    0.02468674f, 0.00700497f, -0.13895619f, -0.33453465f, -0.17585428f, 0.15442857f, -0.03548422f, -0.01825061f, 
    -0.10020528f, 0.00126380f, -0.06701841f, 0.00625229f, -0.04598061f, -0.02919872f, 0.03169537f, -0.01059319f, 
    -0.06807644f, 0.03006704f, -0.03704327f, -0.01526142f, 0.10964600f, 0.01092064f, 0.10693007f, 0.08844047f, 
    0.19817519f, -0.06637860f, -0.08635582f, -0.05382575f, 0.05155614f, 0.11575842f, 0.02163191f, 0.05925401f, 
    0.01257508f, -0.05966627f, 0.03712080f, -0.01606259f, -0.07383322f, -0.08051065f, -0.01133301f, -0.07912056f, 
    0.01836121f, 0.16815916f, 0.03800019f, -0.11839674f, -0.00807850f, 0.07647335f, 0.09423035f, 0.10680821f, 
    -0.03591799f, -0.10069129f, -0.03843064f, -0.02429352f, 0.01727409f, -0.07622352f, -0.04237601f, -0.00733375f, 
    -0.04801184f, 0.00177326f, -0.05981323f, -0.02867177f, -0.10633371f, -0.02390981f, -0.13395175f, 0.13047008f, 
    -0.26293451f, 0.08568681f, 0.03924339f, 0.09336388f, -0.03802952f, 0.13750435f, 0.03797982f, -0.00393711f, 
    0.04862984f, 0.00123084f, -0.05061940f, 0.00968234f, -0.06493551f, 0.04310917f, -0.03227346f, -0.02551063f, 
    0.08740632f, -0.13216986f, 0.02358497f, -0.14766346f, -0.06948855f, 0.11237053f, 0.05619629f, 0.12741548f, 
    -0.08165601f, -0.05425948f, 0.06478546f, 0.08071977f, -0.04554292f, -0.12076772f, -0.04565886f, -0.05550180f, 
    -0.06328089f, 0.07971913f, -0.15859909f, 0.03118862f, -0.21637297f, -0.22480565f, 0.03019078f, -0.26871869f, 
    -0.38231593f, 0.11753719f, -0.03383005f, -0.20902397f, -0.04383646f, 0.02052985f, -0.04241198f, 0.07092977f, 
    -0.06977455f, -0.06408790f, 0.05321046f, -0.06632128f, -0.02582936f, 0.14098589f, -0.06378837f, -0.05326969f, 
    -0.27710912f, 0.27311897f, -0.16439036f, -0.06737473f, -0.11918367f, -0.01352668f, 0.07956894f, 0.03851358f, 
    -0.14771454f, 0.03316012f, -0.10540438f, 0.06929406f, -0.01338077f, -0.03898491f, 0.00305659f, 0.02977703f, 
    0.00056028f, 0.02305437f, -0.08542943f, 0.08072082f, -0.31222093f, 0.03938305f, 0.09193595f, -0.13829896f, 
    0.20286658f, 0.10322283f, 0.19067514f, 0.05538813f, 0.03820629f, -0.07529948f, 0.00877111f, -0.03309347f, 
    -0.00526154f, -0.11781165f, -0.02349182f, 0.00514060f, 0.03005162f, -0.05295686f, -0.06905325f, -0.03494363f, 
    0.26962638f, -0.68852192f, -0.00846092f, -0.23308651f, -0.17161736f, 0.19668949f, -0.06234978f, 0.08908897f, 
    -0.01179401f, 0.01808855f, -0.02720083f, -0.01715125f, 0.07185897f, 0.02810207f, -0.05517515f, 0.01503463f, 
    -0.02249487f, 0.09944798f, -0.14432524f, -0.09611623f, 0.27492088f, 0.12766911f, -0.15966567f, 0.12131295f, 
    -0.19061938f, -0.11252990f, 0.02287714f, 0.02155216f, -0.04268399f, -0.03300380f, -0.02384525f, 0.01565243f, 
    0.04603330f, -0.00818578f, -0.01189974f, 0.03757269f, -0.05018955f, -0.11280469f, 0.18712099f, -0.04042371f, 
    0.32496658f, -0.14381643f, 0.23346250f, -0.00629304f, 0.16190217f, -0.12571022f, -0.07423908f, -0.06942416f, 
    0.06100143f, 0.02378271f, 0.07845547f, -0.08016824f, -0.02771482f, -0.06350288f, 0.00218170f, 0.03819010f, 
    -0.11526644f, 0.00761367f, 0.04204776f, -0.02538473f, -0.01144542f, 0.01482748f, -0.29303375f, -0.09095051f, 
    0.08109660f, 0.01604092f, 0.07926273f, 0.02382002f, -0.03717677f, -0.10322288f, -0.07024550f, 0.00731988f, 
    -0.06497998f, 0.07020280f, -0.04602630f, -0.07771227f, -0.04519805f, -0.02865980f, -0.15677303f, -0.06653196f, 
    0.54750824f, 0.00039355f, 0.12196305f, 0.02914738f, 0.12550627f, -0.16263264f, 0.04897537f, -0.04602952f, 
    -0.03695640f, 0.08019181f, -0.01790991f, -0.01810408f, 0.08538979f, 0.01131495f, -0.07158402f, 0.08321002f, 
    -0.05128054f, 0.02456665f, 0.08214595f, -0.01166219f, -0.28991091f, -0.27614260f, -0.19474111f, -0.16956176f, 
    -0.32889551f, -0.02933085f, 0.12773977f, -0.06867211f, 0.09939960f, -0.16168210f, 0.04406063f, 0.05782486f, 
    0.00211170f, -0.03422675f, -0.00840856f, -0.03105856f, -0.04918274f, 0.02685663f, 0.07488191f, -0.09669460f, 
    0.14631343f, -0.12948568f, -0.10008238f, -0.14050663f, -0.21709923f, -0.02964815f, 0.03147057f, 0.07097454f, 
    -0.04694106f, -0.01396354f, -0.11040263f, 0.03649588f, 0.05886989f, -0.06480973f, -0.12066633f, -0.04455058f, 
    0.04571523f, -0.02907693f, -0.01554109f, 0.01474218f, -0.00664468f, -0.10592164f, -0.09313156f, -0.08405330f, 
    -0.19206066f, 0.07400710f, -0.19076066f, 0.24518600f, 0.05526336f, 0.08038390f, -0.04244950f, -0.03663053f, 
    0.04740305f, -0.03961436f, 0.02254278f, 0.06256727f, 0.02929896f, 0.07380472f, -0.04904655f, -0.14597997f, 
    -0.18991449f, -0.00833138f, -0.11591383f, -0.07988141f, -0.15121450f, -0.23066764f, -0.19562840f, 0.23381269f, 
    -0.16801511f, 0.10140782f, -0.11929420f, -0.01854290f, -0.01045513f, -0.07803763f, -0.01640359f, -0.03049408f, 
    -0.09477905f, 0.10258324f, 0.13593145f, 0.03249563f, -0.22257927f, 0.23879939f, -0.01472983f, -0.02363936f, 
    -0.09057696f, -0.02344644f, -0.06508545f, -0.04712393f, -0.02335172f, -0.01299721f, 0.02659404f, -0.03996692f, 
    -0.11195201f, 0.01753119f, -0.05136518f, 0.00519642f, -0.06007287f, -0.04393972f, 0.05927328f, -0.02207633f, 
    -0.24764381f, -0.12503631f, -0.06742959f, -0.04709596f, -0.03732184f, 0.00635082f, -0.22410622f, -0.07410656f, 
    0.13360444f, -0.09384834f, 0.09923390f, -0.13456978f, 0.05738044f, -0.01058868f, -0.00385293f, -0.00793144f, 
    0.07392295f, 0.02242854f, -0.05846017f, 0.10220522f, 0.07044456f, 0.01827564f, 0.21209502f, 0.08765990f, 
    -0.07577155f, -0.04430205f, 0.12372901f, -0.03277466f, -0.07577825f, 0.02243469f, -0.06460761f, 0.05839837f, 
    0.02063724f, -0.05048663f, -0.05686469f, 0.05856274f, 0.02076170f, -0.00904896f, -0.02641151f, 0.08778495f, 
    -0.09879751f, -0.01841753f, 0.02268177f, -0.07906347f, -0.13779016f, -0.07745688f, -0.03197016f, -0.04177078f, 
    -0.02694376f, -0.09537379f, 0.11440251f, 0.03106361f, -0.01499307f, 0.02755640f, -0.08568040f, -0.01353955f, 
    -0.06684680f, -0.08226104f, -0.04571441f, -0.07092988f, 0.07455538f, -0.03585101f, -0.18048896f, -0.00449321f, 
    -0.11364274f, -0.03146044f, -0.05527464f, 0.01250234f, -0.01391313f, 0.05444052f, -0.09176213f, -0.07930464f, 
    0.15335660f, -0.05453860f, 0.02937216f, 0.02426933f, -0.10282242f, 0.04229695f, -0.01788065f, 0.03005001f, 
    -0.13958259f, 0.22222669f, 0.08380121f, 0.24106266f, 0.12809062f, 0.03887463f, 0.12979445f, 0.03130850f, 
    0.06085208f, 0.01450690f, -0.00357275f, 0.09451827f, -0.01001590f, -0.05970502f, -0.05995845f, 0.01982159f, 
    -0.05484387f, 0.03996403f, 0.05854908f, -0.14459749f, 0.02917012f, -0.30981618f, -0.10180656f, -0.11351407f, 
    0.06106317f, -0.06109077f, -0.04408746f, 0.01952737f, 0.01067334f, 0.06430991f, -0.07133963f, -0.01978179f, 
    -0.01447160f, 0.05288421f, -0.04423057f, -0.07183659f, 0.01890034f, -0.00149481f, -0.03591867f, 0.02544308f, 
    0.10911433f, 0.13287860f, -0.06695125f, 0.05991531f, -0.00422552f, -0.19588582f, -0.12085070f, 0.03268042f, 
    -0.04750144f, -0.01556704f, -0.11517077f, -0.10004218f, 0.05270237f, -0.08654668f, 0.04403954f, -0.08818077f, 
    -0.01666204f, 0.19184247f, 0.07370403f, -0.05431059f, 0.14317936f, -0.14026657f, -0.01740216f, -0.06164238f, 
    -0.12448183f, -0.12681898f, -0.04875324f, 0.04157814f, -0.00012413f, -0.06895957f, -0.03902280f, 0.00997132f, 
    0.01419786f, -0.04027005f, 0.06911790f, -0.04533648f, 0.16088511f, -0.03228831f, -0.10910996f, -0.08150264f, 
    -0.24265394f, -0.19039206f, -0.27494580f, -0.14347564f, -0.37295774f, -0.07000738f, -0.00014823f, -0.06280073f, 
    -0.07310352f, -0.03182583f, -0.11466080f, -0.00492019f, 0.05843539f, -0.00281424f, -0.01649859f, 0.09555631f, 
    -0.10142520f, 0.03546187f, -0.02037162f, 0.05496113f, 0.24746011f, 0.20619236f, -0.07961199f, 0.09143668f, 
    -0.00515623f, -0.02170136f, 0.14195839f, -0.00170598f, -0.05610372f, -0.04273316f, 0.02417324f, -0.06014242f, 
    -0.06042285f, 0.02568362f, 0.01287116f, -0.06448004f, 0.04777835f, 0.01462424f, -0.02671956f, -0.08698209f, 
    -0.16616732f, -0.93066001f, -0.12826273f, 0.08049563f, -0.22526008f, 0.05390800f, -0.09759413f, 0.12466821f, 
    0.01214118f, -0.13760202f, 0.08508477f, 0.01047156f, -0.02268400f, -0.04260637f, -0.01210545f, 0.03304501f, 
    -0.01672520f, 0.05144015f, -0.03307611f, -0.01121067f, -0.23815656f, -0.77400130f, -0.44834381f, 0.04505126f, 
    0.04145174f, -0.16244800f, -0.07414216f, -0.02463908f, -0.03346258f, -0.07552917f, -0.09959132f, -0.03839502f, 
    -0.05044125f, 0.14308378f, 0.02733531f, -0.03265977f, -0.06231064f, -0.01210039f, -0.10900607f, 0.02817618f, 
    -0.35491848f, 0.28226504f, 0.05725668f, -0.03227447f, 0.02535112f, -0.09106333f, 0.00231813f, -0.00718577f, 
    0.10601178f, -0.00198968f, -0.01425865f, -0.02494613f, -0.07076012f, 0.08350401f, 0.00076065f, -0.03712311f, 
    0.05706056f, -0.12129696f, 0.10710549f, -0.02039451f, -0.06427355f, -0.02351470f, -0.07904399f, 0.02250272f, 
    -0.19691275f, 0.07034421f, -0.01419755f, -0.01116856f, -0.07099094f, -0.06347404f, -0.12201124f, 0.09481311f, 
    -0.01893093f, -0.00232062f, -0.09221265f, -0.03314490f, -0.03189615f, 0.03438728f, -0.24069557f, 0.11227482f, 
    0.37224695f, 0.40067303f, 0.00306267f, -0.02268898f, 0.02550875f, -0.00448592f, 0.05849569f, -0.01004286f, 
    0.03166220f, -0.05894809f, -0.13119778f, -0.07120820f, -0.11943524f, 0.06460174f, -0.09250154f, -0.01263985f, 
    -0.05804653f, 0.00870972f, 0.17378440f, 0.03121140f, 0.24182957f, -0.28244150f, 0.09980630f, -0.07608717f, 
    -0.19285215f, 0.01170834f, -0.08518886f, 0.07555795f, -0.11102621f, 0.04487819f, -0.05660221f, 0.00750247f, 
    0.07477455f, -0.13611904f, 0.03539186f, -0.02124366f, 0.07371096f, 0.03553633f, -0.03241127f, 0.06823813f, 
    -0.64557648f, -0.03608849f, -0.17943843f, -0.03845776f, 0.23324148f, -0.12743188f, 0.12252000f, 0.11135987f, 
    0.00447671f, -0.03401121f, 0.01604705f, -0.00729478f, -0.02681768f, -0.10500581f, 0.03155233f, -0.08230621f, 
    -0.05120135f, -0.12591147f, 0.04604615f, 0.03342441f, 0.24397407f, -0.20855592f, -0.15679805f, 0.11568154f, 
    -0.07111166f, -0.13479693f, -0.01760616f, 0.07514869f, -0.03968393f, 0.08527178f, 0.00637737f, 0.10608689f, 
    -0.05365033f, -0.00956343f, -0.01265541f, -0.09952901f, 0.03001544f, 0.03636918f, -0.04873120f, -0.00535348f, 
    0.48868671f, -0.18823363f, -0.10163137f, 0.25463006f, -0.04097846f, 0.08035430f, -0.00857015f, 0.08634552f, 
    0.08430765f, -0.08776176f, 0.00301739f, 0.00862163f, -0.22686946f, 0.04774841f, -0.12502515f, -0.01751379f, 
    0.07333364f, 0.09446871f, 0.00669314f, -0.07946526f, 0.19959995f, 0.20283064f, 0.06682808f, 0.15426549f, 
    -0.08920681f, -0.05423937f, 0.01393494f, -0.02219686f, 0.00435425f, 0.00632811f, -0.08729170f, 0.02968727f, 
    0.05248683f, -0.05656127f, 0.03257117f, 0.07829034f, -0.06922013f, 0.11048314f, -0.03351224f, 0.02548212f, 
    0.25610524f, 0.31847066f, -0.08285722f, 0.17162989f, 0.07380511f, 0.02199317f, 0.10666332f, 0.00043358f, 
    0.04931514f, 0.05383010f, 0.05694679f, 0.02046166f, -0.04210702f, -0.05260066f, -0.04840980f, 0.05085510f, 
    0.03690402f, 0.06241018f, 0.03099782f, -0.08659959f, -0.24807259f, -0.57808781f, -0.57348877f, 0.20378757f, 
    0.06071285f, -0.03310086f, 0.07100663f, 0.11199339f, 0.06177242f, -0.03717767f, -0.01082468f, 0.04424726f, 
    -0.08052552f, -0.14578153f, -0.03455741f, -0.10376968f, -0.02105631f, 0.21516919f, 0.00149696f, -0.05145341f, 
    0.12129696f, 0.25906408f, -0.20405494f, 0.06081983f, 0.09852368f, -0.10250629f, 0.03530263f, -0.06974842f, 
    -0.02320999f, 0.07347437f, -0.01360604f, -0.08614726f, 0.02687570f, 0.17714477f, -0.00533156f, -0.04965234f, 
    0.05106064f, -0.04555561f, -0.01697489f, 0.06855736f, -0.33468759f, 0.09530594f, 0.13585648f, -0.05426170f, 
    -0.09974279f, -0.01615916f, -0.12370428f, 0.02394555f, -0.00349973f, -0.15412052f, 0.02818634f, -0.04388043f, 
    -0.02042117f, 0.05628046f, -0.00488117f, 0.05576940f, 0.01527631f, -0.10979716f, 0.03172994f, -0.04502323f, 
    -0.09520274f, -0.01826019f, -0.13719715f, -0.10373807f, -0.05750727f, -0.05003238f, -0.19086622f, 0.01473309f, 
    -0.00751406f, -0.03436082f, -0.08822027f, -0.02858311f, 0.10939242f, -0.00466532f, 0.04684752f, -0.08046322f, 
    -0.00197706f, -0.09004063f, 0.07627825f, 0.03959570f, -0.42126533f, -0.12281255f, -0.01710445f, 0.06658335f, 
    0.28960967f, 0.17085017f, 0.15081428f, 0.05124853f, 0.02633404f, 0.07468008f, -0.12043083f, 0.05383430f, 
    0.03185210f, 0.03050377f, 0.03507485f, -0.06746426f, 0.02554638f, -0.08670198f, 0.13449743f, -0.03739648f, 
    0.05103423f, 0.05052947f, 0.04835283f, 0.17193216f, -0.03418608f, 0.01106991f, -0.21504581f, -0.07879150f, 
    -0.08172718f, -0.08410583f, -0.03860693f, 0.06587863f, -0.04179468f, 0.04692353f, 0.10272789f, 0.04720154f, 
    0.10405120f, -0.04123460f, 0.14027773f, 0.09002890f, 0.03335781f, 0.22703315f, 0.25277334f, 0.22168833f, 
    -0.02845375f, 0.03934859f, -0.00459007f, -0.04159990f, -0.08145564f, 0.07246262f, 0.09445512f, -0.00868456f, 
    -0.07808936f, -0.07724118f, -0.14161177f, -0.09016187f, -0.03329435f, 0.06424518f, 0.10901032f, -0.04690542f, 
    0.22475636f, 0.20874970f, 0.04654576f, 0.21948491f, 0.09263214f, -0.01255406f, 0.14476708f, 0.02626764f, 
    0.12473065f, -0.05695186f, -0.05371812f, 0.00419852f, -0.08854447f, -0.03499849f, -0.03377530f, -0.03444951f, 
    0.03315052f, 0.13246393f, 0.10523777f, 0.01893006f, 0.17865133f, 0.08016180f, -0.12435855f, 0.17796493f, 
    0.11974765f, -0.07540644f, 0.10378442f, 0.01435330f, 0.08357604f, 0.01100956f, 0.10720778f, -0.04772311f, 
    -0.02631200f, 0.05097618f, 0.09512538f, -0.10646531f, -0.00194112f, -0.10126777f, 0.01381981f, 0.07896367f, 
    -0.31644750f, -0.34979039f, -0.08792498f, 0.12008433f, 0.19766314f, 0.09259796f, -0.02863224f, 0.11058178f, 
    -0.02878881f, 0.07268661f, -0.03716172f, -0.10320694f, 0.09562162f, 0.10868638f, -0.07644357f, 0.04604142f, 
    -0.06519905f, 0.12257683f, 0.16710740f, -0.11696064f, -0.31323412f, 0.07367135f, -0.05767213f, -0.00965046f, 
    0.03150336f, 0.08323069f, -0.03546497f, 0.08450577f, -0.05564644f, 0.01881210f, 0.04870912f, 0.04599170f, 
    -0.05205316f, 0.00365819f, -0.09509235f, 0.04396659f, 0.03638366f, -0.00207601f, 0.04442721f, -0.02797208f, 
    0.20249690f, 0.23703347f, -0.50076121f, -0.06867344f, 0.09118026f, -0.01570727f, 0.01822369f, 0.09074097f, 
    0.10800197f, -0.10363750f, 0.00038309f, 0.04955844f, -0.03639218f, 0.08911771f, 0.05344484f, -0.01310004f, 
    0.11691968f, 0.00280698f, 0.03837070f, 0.01112445f, -0.09136058f, 0.19912151f, -0.26079208f, 0.17392649f, 
    -0.15207195f, -0.10633686f, -0.07288093f, 0.13273132f, -0.00014498f, -0.09055801f, -0.01510778f, 0.05422876f, 
    0.04237637f, -0.03802338f, 0.06294090f, 0.06423297f, 0.00785432f, 0.10281663f, -0.01661678f, 0.08673929f, 
    0.14221463f, 0.34446105f, -0.24950986f, -0.13825564f, 0.12829091f, 0.09705674f, -0.03696525f, -0.06004436f, 
    0.10161044f, 0.05445614f, -0.03962261f, 0.11390225f, 0.00746068f, 0.04148384f, -0.02325837f, 0.01890959f, 
    -0.01967708f, -0.14955837f, -0.01548851f, 0.05362596f, -0.68002713f, 0.13244636f, -0.07813226f, 0.18537952f, 
    0.12850699f, 0.05251700f, -0.03375327f, 0.06164065f, 0.08458699f, 0.15561688f, 0.03629877f, 0.00358879f, 
    -0.07846158f, -0.08060306f, 0.01688805f, -0.02604043f, -0.04362596f, -0.01247153f, 0.10000870f, 0.11961481f, 
    -0.30317688f, -0.27218080f, 0.22474082f, 0.08589821f, -0.00639921f, -0.00134986f, -0.04933010f, -0.09939151f, 
    -0.06855478f, 0.00912578f, 0.02159118f, -0.05302143f, -0.02044428f, -0.01522365f, -0.00970541f, -0.08019078f, 
    -0.14498338f, 0.09504633f, -0.01868665f, -0.03324929f, 0.15813339f, -0.22833455f, -0.04947828f, -0.01701131f, 
    -0.17941663f, -0.08667823f, 0.04744219f, -0.05251914f, 0.01488443f, -0.06694075f, 0.09461529f, -0.02503471f, 
    -0.01957255f, -0.01354158f, 0.03860298f, -0.09845150f, 0.09026882f, -0.06668835f, -0.05032790f, 0.00454116f, 
    0.07344040f, 0.04371466f, -0.01860966f, 0.00796208f, 0.11754596f, 0.07679325f, 0.10221753f, 0.02507291f, 
    0.10987373f, -0.01997730f, 0.11269456f, -0.00684162f, 0.04434350f, -0.09338863f, 0.08849255f, -0.07522631f, 
    0.00819442f, 0.02409593f, -0.00225848f, 0.08820245f, -0.09804370f, 0.31008384f, -0.23728861f, -0.03679888f, 
    -0.03183704f, 0.04447794f, -0.01367149f, 0.11623662f, 0.08203620f, -0.04807342f, 0.00045937f, 0.07322866f, 
    0.03684485f, -0.01001114f, -0.14951935f, -0.06384602f, -0.15706863f, 0.06516052f, -0.05565875f, -0.10519546f, 
    -0.30540639f, 0.24027555f, 0.02139631f, -0.01844026f, -0.02313460f, 0.08202187f, 0.01610839f, 0.00199985f, 
    0.03675036f, 0.02065087f, 0.02005599f, -0.02526081f, 0.06718893f, -0.03657727f, 0.02362237f, 0.12745777f, 
    0.05645412f, -0.06765235f, -0.04113960f, 0.00680157f, 0.00868796f, 0.02659506f, -0.10527413f, 0.15874851f, 
    0.01832711f, -0.06875595f, -0.06719868f, -0.02009556f, -0.09134630f, -0.15559746f, -0.14994586f, -0.11155064f, 
    0.12192556f, 0.00739555f, -0.03115055f, 0.02443010f, -0.03854388f, -0.01755426f, -0.08287661f, 0.05497347f, 
    -0.10839818f, 0.04744593f, -0.17951630f, -0.05377692f, 0.18877752f, 0.06408262f, -0.14911704f, -0.20739432f, 
    0.14182690f, 0.05065337f, -0.02766759f, -0.10052825f, 0.11769558f, 0.01310352f, 0.04126382f, 0.00941817f, 
    0.03544237f, -0.08930644f, -0.02219281f, -0.03147534f, 0.07039819f, -0.16188771f, 0.13938789f, -0.04505254f, 
    -0.07036437f, -0.14953466f, -0.00530066f, 0.09519640f, 0.00284872f, 0.04893614f, 0.12521520f, 0.05372433f, 
    0.09168778f, -0.05712098f, -0.14850692f, -0.02137027f, 0.05681481f, -0.02710208f, -0.04068325f, 0.00755068f, 
    0.30109397f, 0.17452410f, 0.09403021f, -0.01893273f, -0.02450871f, -0.06563850f, 0.00661839f, 0.12328922f, 
    0.05607852f, -0.01841727f, -0.05752399f, -0.06993219f, -0.13677843f, -0.08886014f, -0.03214792f, 0.01635285f, 
    -0.02007082f, -0.02302604f, -0.00852674f, -0.06554542f, 0.28971198f, 0.03902935f, -0.23915604f, -0.01335108f, 
    -0.15681192f, 0.07313405f, -0.08365989f, -0.08834878f, 0.00302271f, 0.01933438f, -0.19170083f, -0.01094531f, 
    0.04170939f, 0.10045495f, 0.05221482f, -0.17314246f, -0.03940276f, -0.00814608f, -0.14685535f, -0.07576367f, 
    -0.26798958f, -0.00167792f, 0.28308010f, -0.07718683f, -0.24670537f, 0.08979409f, 0.13702171f, 0.04309464f, 
    -0.25712702f, -0.15465041f, -0.00607445f, 0.00013334f, 0.03955697f, -0.03337105f, -0.04157737f, -0.03655453f, 
    0.16751264f, -0.12139799f, -0.10286019f, -0.03743692f, -0.58056211f, -0.12849046f, -0.03855510f, 0.10480656f, 
    0.17922626f, 0.01789776f, 0.05616875f, -0.01369254f, 0.04908005f, 0.05634429f, -0.04919084f, -0.08365964f, 
    0.13148265f, 0.03634663f, 0.05595399f, -0.03684098f, 0.16491908f, -0.00651817f, 0.03643271f, -0.06392722f, 
    -0.45863914f, -0.35501692f, 0.17822255f, 0.09232473f, 0.08564396f, -0.10489133f, -0.08954202f, 0.02535909f, 
    0.06312048f, -0.00272828f, 0.16971730f, 0.03981889f, -0.00887999f, -0.15488930f, 0.00277299f, 0.05498887f, 
    0.01692728f, -0.00304929f, 0.02926286f, 0.03278325f, 0.48732886f, -0.16156709f, -0.06993797f, -0.19021071f, 
    -0.20902523f, 0.06542679f, -0.04789460f, 0.05754957f, -0.11861465f, -0.05174944f, 0.01778669f, 0.02763346f, 
    0.01915133f, -0.05621972f, 0.05983453f, -0.00815977f, -0.02429298f, -0.14969262f, 0.05240240f, -0.21902715f, 
    -0.45505303f, 0.02642924f, 0.12294403f, -0.09795079f, -0.05456779f, -0.03097397f, 0.02198927f, -0.12666716f, 
    0.03571875f, 0.01808904f, -0.07931518f, -0.05347036f, -0.02049397f, 0.11293770f, 0.05148372f, -0.16449849f, 
    0.04660648f, -0.04536457f, -0.06215616f, 0.03168628f, 0.04919677f, -0.21919832f, 0.17783287f, 0.06403672f, 
    -0.12128267f, 0.01124515f, 0.15260795f, -0.09460957f, 0.07000131f, 0.05008822f, 0.12896846f, -0.03085994f, 
    -0.03183259f, 0.04224006f, 0.13327716f, 0.03899806f, 0.03620167f, -0.11489471f, 0.04026363f, 0.17000891f, 
    0.11009734f, -0.22205655f, 0.01241243f, -0.06396091f, -0.06395084f, -0.08370924f, 0.02056493f, -0.11749446f, 
    -0.02298623f, -0.20405258f, 0.00445939f, 0.08179734f, -0.07616099f, -0.08740854f, 0.06561974f, -0.03950159f, 
    -0.02910930f, 0.08259472f, -0.02809113f, 0.25104547f, -0.23132330f, -0.10502359f, 0.31538433f, 0.12752694f, 
    -0.04209644f, 0.03391629f, 0.15291250f, -0.01085973f, -0.01577521f, 0.08148301f, 0.10140630f, 0.04826425f, 
    -0.02098019f, -0.01533283f, 0.02858550f, 0.01174663f, -0.13695540f, -0.02947444f, -0.03720597f, 0.02778403f, 
    0.04998498f, 0.20406507f, -0.01058652f, 0.15488434f, -0.22256903f, 0.12044504f, -0.03431946f, 0.02032321f, 
    0.04107801f, 0.09317211f, -0.05836850f, -0.08586216f, 0.06795382f, 0.02156096f, 0.03193775f, -0.02150906f, 
    0.01587406f, -0.03752217f, -0.07747384f, 0.08971797f, -0.16600911f, 0.10909734f, -0.10351007f, -0.02150364f, 
    0.19167811f, -0.02365536f, -0.05477851f, 0.09600014f, 0.11466542f, -0.02744456f, -0.09196415f, 0.05660298f, 
    -0.07744331f, 0.06247217f, 0.01210926f, -0.02659667f, 0.01120231f, -0.17145360f, 0.00792765f, -0.07120161f, 
    -0.55388039f, 0.15602694f, -0.02063304f, 0.09041195f, 0.14350361f, -0.05281730f, -0.00850372f, 0.08636896f, 
    -0.05863135f, -0.01651583f, -0.00098947f, 0.05384154f, -0.03005153f, 0.01489316f, 0.09021654f, 0.02526995f, 
    -0.05466773f, 0.05770165f, 0.04845727f, -0.02939446f, -0.03771209f, -0.08607265f, 0.15325195f, 0.14158358f, 
    -0.04923397f, -0.10139238f, -0.02460174f, 0.12823778f, -0.10679363f, 0.02270178f, 0.04547362f, -0.01246967f, 
    -0.06973223f, -0.15513159f, 0.04366753f, 0.09813634f, 0.05254097f, 0.03751992f, 0.10687318f, 0.15197761f, 
    -0.89824665f, 0.22581291f, 0.07275484f, 0.02343305f, 0.14802153f, 0.11878099f, 0.01640003f, 0.00136789f, 
    0.01327391f, 0.08278821f, -0.07303178f, -0.01104707f, -0.00175557f, 0.08878842f, -0.06691220f, -0.09212590f, 
    0.17635345f, 0.11610604f, 0.07828312f, -0.23941618f, 0.02058693f, -0.10786784f, 0.03913607f, 0.22641921f, 
    0.09549485f, -0.05366077f, 0.11858998f, -0.03789195f, -0.02637552f, 0.02263523f, 0.05782193f, 0.05810426f, 
    -0.10702732f, 0.05183250f, -0.04933878f, -0.04654247f, -0.00692807f, -0.00073594f, 0.10914145f, 0.03798192f, 
    0.22374788f, 0.01907371f, 0.20190232f, 0.02763181f, -0.15613568f, -0.16349025f, 0.01990161f, -0.04976144f, 
    0.03966694f, -0.08760677f, 0.01255331f, -0.12203363f, 0.01118511f, 0.07542573f, 0.15889613f, -0.08803196f, 
    -0.05454374f, 0.06966759f, 0.10779184f, 0.03772084f, 0.23275612f, -0.09594862f, -0.24132915f, 0.09643181f, 
    -0.54262877f, -0.11559062f, -0.10719249f, 0.04314734f, -0.13727625f, 0.02061697f, -0.13851336f, -0.01550803f, 
    0.11572036f, -0.08210485f, -0.08176080f, 0.09922598f, -0.09192068f, 0.02366520f, -0.13167867f, -0.08432584f, 
    -0.29162315f, 0.44563931f, -0.08327626f, -0.34247273f, 0.03469050f, 0.08628760f, 0.15009573f, 0.17942406f, 
    -0.08894549f, -0.11759942f, 0.15885416f, 0.06172070f, -0.07989792f, -0.15653831f, -0.12256073f, 0.02872600f, 
    0.05343527f, 0.00086542f, -0.01507356f, -0.03881984f, -0.77046555f, -0.18111183f, -0.12218142f, -0.15659945f, 
    -0.06532196f, -0.02105731f, 0.01469858f, 0.12225816f, 0.02869847f, -0.09608619f, 0.20255485f, 0.05045736f, 
    0.16398689f, -0.02869290f, 0.02152298f, -0.02350131f, -0.08562469f, -0.12046476f, -0.02598295f, -0.00951397f, 
    -0.42108494f, 0.08182005f, 0.21003576f, 0.04815816f, -0.33156157f, 0.01853155f, 0.04229159f, 0.06830380f, 
    -0.23655707f, -0.04982826f, 0.05081527f, -0.19033317f, -0.00935600f, -0.11462586f, -0.09136935f, -0.05839899f, 
    -0.03135062f, 0.04936815f, 0.03446503f, -0.07143403f, 0.06643138f, -0.07597979f, -0.10683976f, -0.16739191f, 
    0.02270227f, 0.03101260f, 0.01355671f, -0.07315395f, 0.07816214f, 0.13921359f, 0.09279777f, 0.07444928f, 
    0.07017979f, -0.09715126f, 0.00873040f, -0.20599994f, -0.21251199f, -0.02558482f, -0.02886672f, -0.04208734f, 
    -0.42777878f, -0.25211480f, 0.11981272f, 0.02726106f, -0.17772569f, 0.05471174f, 0.01920352f, -0.05461702f, 
    0.02515042f, 0.00455889f, 0.08285106f, -0.03655100f, -0.07846802f, -0.12038610f, -0.05145945f, -0.06315975f, 
    0.05868350f, 0.12771754f, -0.13940939f, 0.03044590f, -0.36786696f, 0.19944426f, -0.33997506f, -0.15578271f, 
    0.01685351f, 0.07174574f, 0.15488379f, 0.00494980f, -0.12688310f, 0.01048866f, -0.04857793f, 0.12209032f, 
    0.10854286f, -0.18915056f, -0.05386618f, 0.01481316f, 0.01104788f, -0.02743226f, 0.01750293f, -0.16296209f, 
    -0.05350371f, -0.00696955f, -0.10438340f, 0.25676760f, 0.17489101f, -0.13214800f, -0.13740332f, 0.14715052f, 
    0.16346061f, 0.17725521f, 0.04653311f, -0.12673815f, 0.02079790f, 0.18091732f, 0.14638484f, 0.07400368f, 
    0.11101803f, -0.09870413f, -0.15335943f, -0.07468906f, -0.07833742f, 0.03081714f, 0.00748424f, 0.22090101f, 
    0.30097240f, -0.07047277f, -0.05892197f, 0.22189540f, -0.08786277f, 0.10910231f, 0.03732980f, -0.17877448f, 
    -0.01309979f, 0.05258474f, 0.00651679f, 0.05213707f, 0.06790356f, -0.23647089f, 0.08292314f, 0.06259409f, 
    -0.30442548f, -0.15813741f, -0.08944760f, 0.06779455f, 0.11583076f, 0.05818149f, 0.13102734f, 0.05039113f, 
    -0.03807805f, 0.25277033f, 0.06551418f, 0.09796449f, 0.09727244f, 0.09430558f, -0.05529766f, 0.03049268f, 
    -0.03209940f, 0.03196613f, -0.16543813f, 0.05204549f, -0.67796534f, -0.35291380f, 0.04262425f, -0.09068700f, 
    0.09951732f, 0.11319846f, 0.01955450f, -0.18308263f, 0.06831051f, -0.13646479f, 0.04149943f, 0.06885765f, 
    -0.10292272f, 0.06644958f, 0.06580146f, 0.03512900f, 0.15189014f, 0.07876511f, -0.13431768f, 0.01154283f, 
    0.01679801f, 0.16063553f, 0.23469166f, 0.08416666f, 0.00878863f, -0.12432864f, -0.02579625f, -0.09479327f, 
    -0.08193995f, -0.06552004f, 0.02808535f, -0.00108396f, -0.04740809f, 0.06003072f, 0.06100355f, -0.00724424f, 
    0.00933096f, 0.08135892f, 0.11026827f, -0.02750900f, -0.11210061f, 0.02759982f, -0.04278546f, -0.05285217f, 
    -0.00063233f, 0.13667542f, -0.01819383f, -0.04993052f, 0.11498939f, 0.03467248f, -0.07808176f, 0.09109035f, 
    -0.09193502f, -0.06412710f, -0.18948576f, 0.06055509f, 0.12248897f, -0.05672370f, 0.01155595f, -0.01373457f, 
    0.05838121f, -0.01696226f, 0.26010710f, 0.22229396f, -0.19621171f, 0.03922138f, 0.21763943f, 0.05355781f, 
    0.08202421f, 0.05425896f, 0.01724860f, -0.05518661f, -0.13154323f, -0.03109888f, 0.05232048f, 0.00028850f, 
    -0.04573988f, 0.14052969f, -0.02356981f, -0.04510653f, 0.13799380f, 0.03128393f, 0.21468283f, 0.04095398f, 
    -0.03893967f, 0.01954173f, -0.00987790f, -0.01078810f, -0.07606135f, 0.00049425f, -0.03137584f, 0.07454304f, 
    -0.00827355f, 0.01913955f, 0.10335021f, -0.04754603f, -0.04477682f, 0.11489852f, 0.02045294f, -0.02650904f, 
    -0.15640739f, -0.11731462f, 0.05518303f, 0.19362451f, -0.21811330f, 0.01754967f, -0.01131116f, -0.03482028f, 
    0.06747087f, 0.00089121f, 0.11866489f, 0.08466975f, -0.04471463f, 0.05601105f, 0.01109553f, -0.01675295f, 
    -0.02536945f, 0.05283470f, 0.00292611f, -0.08916616f, 0.25577691f, 0.21090047f, 0.11286522f, -0.14463943f, 
    0.10391570f, -0.07420005f, 0.00673092f, -0.05062134f, -0.08660410f, -0.07425457f, 0.11441065f, -0.01952145f, 
    -0.00432770f, -0.14794055f, 0.03442144f, 0.28553298f, -0.06451150f, 0.07787151f, 0.07722688f, 0.08354907f, 
    -0.21010087f, -0.08396252f, 0.25145864f, 0.26256669f, -0.26753166f, -0.20793124f, -0.19083725f, 0.08784725f, 
    -0.02157701f, 0.11915831f, 0.06826003f, 0.03223161f, 0.02800234f, -0.01846965f, -0.18396583f, -0.09047502f, 
    -0.03649797f, -0.25759748f, 0.04432097f, 0.08707009f, -0.15311091f, 0.13953339f, -0.26349053f, -0.17818220f, 
    -0.03786337f, 0.11816919f, 0.01287197f, 0.08271205f, -0.02128905f, -0.16723174f, -0.10649957f, -0.02601385f, 
    -0.07370521f, 0.01500517f, -0.00018191f, -0.00181165f, -0.09262320f, 0.05756890f, 0.00332666f, 0.04672519f, 
    0.24262610f, -0.01302181f, -0.00647218f, 0.04393810f, -0.13706742f, -0.08750766f, 0.01743504f, 0.02581430f, 
    0.06618457f, 0.08407591f, -0.06082237f, -0.18981291f, 0.01631350f, 0.08695113f, 0.15668020f, -0.05266433f, 
    -0.15064608f, 0.01793029f, 0.05623107f, 0.08614687f, -0.15634626f, 0.05557838f, 0.09025083f, 0.13893889f, 
    0.17704338f, -0.13116708f, 0.04785296f, -0.06438874f, -0.11557876f, 0.08342740f, 0.07298709f, 0.00763828f, 
    -0.09601300f, -0.00494501f, -0.10565112f, 0.01575009f, 0.07077588f, 0.03358671f, 0.02528320f, 0.11050163f, 
    0.02405784f, -0.00374945f, -0.01889119f, 0.17652999f, -0.07081397f, -0.02889232f, 0.04471176f, 0.07828463f, 
    0.04330776f, 0.07224522f, -0.14919958f, 0.03549210f, 0.01700578f, 0.01176567f, 0.05245259f, 0.09166496f, 
    0.03598611f, -0.12911768f, 0.19119141f, 0.00099500f, -0.04169333f, -0.02698985f, -0.12110087f, 0.01918379f, 
    -0.02008572f, -0.10328196f, 0.05196257f, 0.02263843f, -0.03348011f, 0.20808499f, -0.10463323f, 0.10953536f, 
    0.21949358f, 0.04239644f, -0.12963846f, -0.17436193f, -0.00199789f, -0.13172190f, -0.06451301f, -0.01584943f, 
    -0.02868387f, -0.10559364f, 0.12924246f, 0.33377978f, -0.12436249f, -0.03912600f, -0.06539140f, 0.06102572f, 
    -0.10410750f, 0.22455750f, 0.13039167f, -0.05645012f, 0.06009363f, 0.12692954f, 0.08663632f, 0.01354576f, 
    0.00626540f, -0.11390103f, -0.11351306f, -0.03022429f, -0.05008964f, 0.02233151f, -0.06372868f, 0.29819602f, 
    0.22024956f, -0.01363872f, 0.01273020f, -0.02755658f, -0.01952528f, -0.02682841f, -0.08837438f, -0.09648799f, 
    0.03350307f, 0.13938694f, 0.12978277f, -0.11773553f, 0.07863237f, -0.00734616f, -0.00417724f, -0.05584063f, 
    0.08202519f, 0.02903447f, 0.09091944f, -0.05089266f, -0.09275933f, -0.06488620f, -0.02440318f, 0.03106076f, 
    -0.01202185f, 0.01078286f, 0.06411654f, 0.00215197f, -0.00071812f, -0.02052732f, 0.01877511f, 0.02103907f, 
    -0.08385699f, -0.02767278f, 0.07414602f, -0.01445176f, 0.12997611f, -0.14339718f, 0.02955469f, -0.03053414f, 
    -0.31710511f, 0.02331615f, 0.00001417f, -0.00105129f, 0.00489832f, 0.06854496f, 0.06583858f, 0.11916045f, 
    0.04540339f, 0.02810222f, -0.08820365f, 0.05713935f, -0.00078350f, 0.14431639f, -0.00018036f, 0.05023115f, 
    -0.45491499f, -0.01500631f, -0.27417657f, -0.10288369f, -0.07664617f, 0.15145549f, 0.11131464f, -0.02027361f, 
    -0.12576883f, -0.17520638f, 0.06879705f, -0.05725781f, 0.03240087f, -0.01564928f, 0.06555264f, 0.12263184f, 
    0.04112129f, -0.14775337f, 0.00467163f, -0.04398125f, 0.11402861f, -0.08771496f, -0.00641272f, 0.08797790f, 
    -0.35208279f, -0.28587639f, -0.06040283f, -0.15212983f, 0.19620314f, 0.08500935f, -0.12823807f, 0.14107953f, 
    0.13394636f, 0.14375547f, 0.13098606f, -0.14613940f, -0.04578992f, 0.08269177f, 0.03295072f, -0.10644642f, 
    -0.57807291f, -0.04702029f, -0.26522553f, -0.19811295f, -0.16443533f, 0.10801937f, -0.02883233f, 0.01733917f, 
    0.10730642f, -0.19820809f, 0.02039952f, 0.00313942f, -0.09523152f, 0.00452659f, -0.06142417f, -0.02285293f, 
    -0.10234545f, -0.06749027f, 0.03185834f, -0.00734259f, 0.08871925f, 0.16258542f, -0.19063160f, 0.09759093f, 
    0.19538294f, 0.07393192f, -0.20315434f, -0.04798139f, -0.01979084f, 0.04223912f, 0.01675898f, 0.11225331f, 
    0.13122720f, 0.04555985f, 0.17409137f, -0.11568097f, 0.09459860f, 0.00899000f, -0.20789829f, -0.15929720f, 
    0.03971123f, 0.04243080f, -0.01541537f, 0.19363466f, 0.00418710f, 0.03038703f, -0.07701863f, -0.03181175f, 
    0.10967162f, -0.06568787f, -0.03575892f, -0.15172569f, -0.10100311f, 0.10080977f, 0.17613287f, -0.06097131f, 
    -0.02855139f, -0.01552427f, -0.11822990f, -0.16688842f, -0.11628138f, 0.29462245f, -0.00482082f, -0.15684554f, 
    -0.31601551f, -0.02969081f, -0.03485150f, -0.17042130f, -0.04693058f, 0.10771234f, -0.11902024f, 0.06486584f, 
    -0.04410940f, 0.01977252f, -0.06476630f, 0.16412748f, -0.01573499f, -0.06413431f, 0.07085338f, 0.08499293f, 
    -0.15021849f, -0.38563100f, -0.11626191f, -0.11656141f, 0.08626965f, -0.01704899f, 0.01468547f, -0.07079723f, 
    -0.01253519f, -0.09604563f, -0.03811083f, -0.00628029f, 0.03821684f, 0.20810626f, -0.03964330f, 0.03847425f, 
    -0.02956998f, -0.12359759f, -0.09182708f, 0.10676254f, 0.00055697f, -0.27489263f, -0.05129865f, 0.13776428f, 
    -0.04239947f, -0.03351280f, 0.03226589f, 0.06498139f, -0.03931775f, -0.00937315f, 0.05363305f, -0.08439011f, 
    -0.12293176f, 0.09163561f, 0.02953936f, -0.11576388f, 0.01549578f, 0.02219570f, -0.11045609f, 0.05165428f, 
    0.41112140f, -0.61188376f, -0.27209473f, -0.02135465f, -0.18575364f, -0.05332173f, 0.12970257f, -0.17501532f, 
    0.11941464f, 0.01173013f, -0.06152740f, 0.02721700f, 0.00014474f, 0.09239762f, 0.06397830f, 0.13736540f, 
    -0.00650196f, -0.00827667f, -0.17322528f, 0.09298572f, -0.04233830f, -0.17552826f, -0.25995192f, -0.26630279f, 
    0.27625874f, -0.07416076f, 0.00385193f, 0.02457263f, 0.00641083f, -0.14139539f, 0.03179665f, -0.04308533f, 
    -0.06553844f, 0.07234426f, -0.18865564f, 0.07998376f, 0.07660924f, 0.04945672f, 0.09264366f, 0.02357878f, 
    0.24633233f, -0.27096558f, -0.09492127f, 0.12679081f, -0.04311146f, -0.06523733f, -0.04585848f, 0.06531245f, 
    0.05445478f, 0.08718003f, -0.02118914f, -0.04942800f, -0.05226135f, 0.05899112f, 0.01878734f, -0.04230923f, 
    0.04819218f, -0.08927187f, 0.11243441f, -0.17789122f, -0.12596069f, -0.21535686f, 0.12995735f, -0.40336031f, 
    0.10377532f, -0.11092438f, -0.01283217f, -0.03928611f, 0.05606995f, -0.14451912f, -0.04348798f, 0.12801844f, 
    -0.12704615f, 0.09755214f, 0.12687111f, -0.05643466f, 0.05885543f, -0.00090203f, -0.02048499f, -0.06011119f, 
    0.23623691f, 0.10523176f, 0.01431442f, -0.04171310f, -0.03340387f, 0.05331709f, 0.04538761f, 0.02023845f, 
    -0.21180570f, -0.00811951f, -0.03177751f, 0.02203956f, -0.06130116f, -0.02019922f, -0.04972274f, 0.01193533f, 
    -0.13097018f, 0.17100909f, 0.04774604f, 0.01571403f, -0.33094811f, 0.14149494f, -0.15487871f, 0.30426598f, 
    -0.40829414f, 0.08145825f, 0.15660262f, -0.12191490f, 0.13642210f, 0.10084846f, -0.14058456f, 0.04171353f, 
    0.14040051f, -0.03015679f, -0.19857724f, 0.11814873f, -0.05279886f, 0.10257630f, -0.07481340f, 0.01896420f, 
    -0.38970318f, 0.10223446f, -0.17442334f, -0.29861346f, 0.11545858f, -0.00012076f, -0.04158252f, -0.05508144f, 
    -0.11864960f, -0.10015707f, 0.03298862f, 0.01674997f, -0.10246835f, 0.07145388f, 0.09171912f, -0.08955512f, 
    -0.00924625f, -0.07650986f, 0.12463822f, 0.05176768f, -0.10101873f, 0.11915334f, -0.08812704f, -0.12891087f, 
    0.18559629f, 0.05145149f, 0.00882270f, 0.12903596f, -0.08775172f, 0.07399693f, 0.01067619f, -0.09761624f, 
    0.03907682f, -0.06057321f, 0.00438734f, -0.02815262f, 0.04408006f, -0.06324250f, 0.16848649f, 0.11201699f, 
    -0.05749751f, -0.32711238f, 0.02262100f, 0.12360720f, 0.37112510f, 0.02753471f, -0.03293489f, -0.03896255f, 
    0.03192987f, -0.02089728f, -0.16705886f, -0.03621022f, -0.01251437f, 0.11547843f, 0.06397996f, -0.09023164f, 
    -0.08986143f, -0.13434398f, -0.19531032f, -0.07113791f, -0.08378758f, -0.15590203f, -0.07082873f, -0.00976864f, 
    -0.12902661f, 0.03055700f, -0.00796642f, 0.02523001f, -0.16230591f, -0.02757296f, -0.03960340f, -0.06950388f, 
    0.02879025f, 0.10645157f, 0.16314627f, 0.03924843f, -0.09375531f, 0.08989471f, 0.09747219f, 0.01702782f, 
    -0.27000830f, 0.25515577f, -0.06630738f, 0.33647287f, -0.04431213f, -0.21171243f, -0.06655951f, 0.02365679f, 
    0.02293878f, -0.01535894f, -0.10717379f, 0.11775854f, 0.05769140f, 0.02507363f, -0.03387890f, -0.03934292f, 
    -0.00453819f, -0.14598285f, -0.04945464f, -0.21323857f, -0.48238945f, 0.38539121f, 0.02997715f, 0.14753544f, 
    -0.14955045f, -0.14625449f, 0.02967245f, 0.08108124f, 0.14016804f, 0.12147535f, -0.00629019f, 0.01557505f, 
    -0.01429329f, -0.02045292f, 0.17762563f, -0.06014768f, 0.05359972f, -0.15448354f, -0.04236724f, 0.02127984f, 
    0.05506847f, -0.11418781f, 0.00695279f, 0.02201505f, -0.01587874f, -0.05815232f, -0.19554071f, 0.16281740f, 
    -0.08460365f, 0.03007799f, -0.03801830f, 0.04345822f, 0.01723068f, -0.05506863f, -0.00263024f, 0.01457241f, 
    -0.04100977f, 0.02771699f, 0.08666109f, -0.04842215f, -0.06705841f, -0.30859807f, -0.06004683f, 0.07050212f, 
    0.14177914f, -0.08684146f, 0.08596761f, 0.02933713f, -0.16494629f, -0.00833694f, -0.01464022f, -0.05869206f, 
    0.04661497f, 0.09623016f, -0.27375823f, 0.05738787f, 0.10958819f, -0.08235450f, 0.06490693f, -0.09676532f, 
    -0.13975303f, 0.12792119f, -0.00089374f, 0.26704571f, 0.24846143f, 0.14487958f, 0.03308100f, 0.00686262f, 
    0.18726571f, -0.08243959f, -0.15411812f, 0.05142129f, -0.18014742f, -0.01345961f, -0.00741390f, 0.12258183f, 
    -0.02898703f, 0.21641776f, 0.22638932f, 0.05918309f, -0.05754947f, -0.50760823f, 0.05587332f, -0.18775027f, 
    0.01851321f, 0.08695022f, 0.08702671f, 0.01314946f, -0.02319240f, -0.00886021f, 0.03072970f, 0.09655862f, 
    0.04475779f, 0.13070001f, 0.05521416f, -0.02121889f, -0.00282537f, -0.12658130f, -0.02627327f, -0.06002088f, 
    -0.31867173f, 0.38216376f, 0.20099795f, 0.08888582f, -0.34472156f, 0.10892844f, -0.00650718f, -0.00822937f, 
    0.02817745f, 0.04419434f, -0.06278810f, 0.01320816f, 0.02599615f, 0.08044928f, -0.21754912f, 0.02750884f, 
    0.04001242f, -0.01539162f, -0.01855451f, -0.24867047f, -0.46899942f, 0.04309109f, 0.06869432f, 0.16818762f, 
    0.08004984f, 0.11578243f, -0.24239427f, 0.01798970f, 0.00825610f, 0.09142490f, 0.04832912f, -0.02087358f, 
    -0.05863137f, -0.00142890f, -0.09858247f, 0.06756496f, -0.02610403f, -0.05104580f, -0.08739197f, 0.10156134f, 
    0.09527288f, 0.13653274f, -0.03051418f, 0.16260102f, -0.16760491f, 0.04278663f, 0.07817513f, 0.02453232f, 
    0.04142017f, -0.04776441f, -0.06480964f, -0.02330626f, -0.03775464f, -0.05953080f, -0.10553844f, 0.08234309f, 
    -0.03747914f, 0.09938513f, -0.21601580f, 0.08079758f, 0.02959562f, -0.03901937f, -0.04531695f, -0.05816599f, 
    0.14706549f, 0.03404117f, 0.01362116f, -0.12740716f, -0.17942454f, -0.15236120f, -0.06685876f, -0.05526216f, 
    -0.09595971f, -0.03227409f, 0.05361564f, -0.00440590f, 0.08190628f, 0.18950510f, 0.07204816f, 0.00890860f, 
    -0.11390263f, 0.09045341f, -0.07684185f, -0.07961328f, 0.07992369f, -0.07699476f, -0.16341341f, -0.03997783f, 
    -0.17023550f, 0.12983453f, -0.18558164f, -0.06460568f, 0.02452784f, 0.01416265f, -0.04336700f, 0.01402486f, 
    -0.03245275f, -0.00233670f, 0.09226316f, 0.11993677f, -0.22828618f, 0.29981273f, -0.02551649f, -0.07702622f, 
    -0.21618773f, -0.07249696f, -0.07142888f, 0.01652886f, 0.08874170f, -0.07136681f, 0.02575403f, 0.10828039f, 
    -0.05822584f, 0.02129045f, -0.07999051f, 0.05020221f, -0.08636347f, 0.06676810f, 0.04838898f, 0.11476626f, 
    -0.08429502f, 0.03608324f, -0.24440676f, 0.23005715f, -0.24971569f, -0.20877494f, 0.08052751f, -0.05679756f, 
    0.12100404f, 0.02496201f, -0.00714333f, -0.02139845f, 0.01734887f, 0.04673248f, 0.14822380f, -0.00914475f, 
    -0.03340269f, 0.16648166f, -0.22755356f, 0.07007375f, 0.06594106f, -0.35973036f, 0.03551343f, 0.15326861f, 
    0.03186170f, 0.06612372f, -0.00472937f, 0.05594666f, -0.07172141f, 0.00153587f, 0.14212087f, -0.01739349f, 
    -0.06596232f, -0.04162066f, 0.05490018f, -0.06237253f, -0.00688341f, 0.02520991f, -0.10628048f, -0.31057730f, 
    0.20897824f, -0.31033662f, -0.09003784f, -0.10098343f, -0.00524851f, -0.07948001f, 0.12804154f, -0.01007202f, 
    -0.02950678f, -0.04085857f, 0.02041497f, 0.12324298f, -0.00439029f, -0.01077948f, 0.12926605f, -0.09950461f, 
    -0.09582065f, 0.01326525f, -0.10218335f, 0.07175916f, -0.04535102f, 0.25341603f, 0.10782654f, -0.03735735f, 
    -0.33756766f, 0.18211870f, -0.06543386f, 0.15755168f, -0.01803721f, -0.16200215f, 0.01885256f, 0.03051850f, 
    -0.09081388f, -0.02884048f, -0.06071940f, 0.12848425f, -0.05052446f, -0.14596832f, 0.08091956f, 0.07599184f, 
    0.63772774f, -0.08126707f, -0.00711551f, -0.26341635f, 0.04314418f, 0.02506778f, 0.08765173f, 0.01160124f, 
    -0.06157535f, -0.13126963f, 0.02845127f, -0.13357547f, 0.25426498f, -0.01458768f, -0.04340299f, 0.03733002f, 
    -0.01836183f, 0.08829941f, -0.04591610f, 0.12015152f, -0.04588629f, 0.06258860f, -0.28475511f, -0.46475706f, 
    -0.12734683f, -0.01590602f, 0.09180125f, 0.20953494f, -0.02035828f, -0.01121705f, -0.01469400f, 0.01452055f, 
    -0.10729547f, -0.04918557f, -0.09015537f, 0.03020627f, -0.18732801f, 0.07291827f, 0.07514134f, 0.03356041f, 
    -0.01171780f, 0.01394939f, 0.01328321f, -0.08984322f, 0.14445722f, -0.01990730f, 0.13862687f, 0.11290920f, 
    -0.10085962f, 0.02825032f, 0.02377207f, 0.03116950f, 0.16666180f, 0.04022431f, -0.10283503f, 0.12343211f, 
    -0.03711278f, 0.16727003f, 0.08195554f, 0.06296539f, 0.01905989f, 0.10605407f, -0.06813479f, 0.29936200f, 
    0.06400125f, -0.00055684f, 0.05525195f, -0.00495278f, 0.00700417f, 0.07740666f, 0.02111628f, -0.03336670f, 
    0.06592456f, -0.06477072f, -0.02550248f, -0.04455282f, 0.00725643f, -0.04753797f, -0.06734654f, -0.02079373f, 
    0.10220750f, 0.06120431f, 0.26484671f, 0.06920782f, 0.21056978f, 0.12119236f, 0.14817628f, 0.04025542f, 
    0.08137360f, -0.00991130f, -0.03427521f, -0.00676099f, 0.07056173f, 0.03620639f, -0.10288607f, 0.04869546f, 
    0.06803402f, 0.02471604f, -0.02724697f, 0.03381440f, 0.03788403f, -0.11820644f, 0.17240687f, 0.03573760f, 
    -0.11420114f, 0.11228909f, -0.11346900f, 0.03855931f, 0.04889558f, -0.04805081f, -0.07229853f, 0.07674055f, 
    -0.00278474f, -0.01752628f, -0.03674827f, -0.04822735f, 0.00050994f, 0.01669157f, 0.04730316f, -0.05604014f, 
    0.03066076f, 0.25521973f, 0.12734780f, 0.13750114f, 0.09614005f, 0.09327944f, 0.06531952f, -0.04797629f, 
    -0.01468837f, -0.03082550f, -0.10893722f, 0.01065201f, 0.11918373f, 0.02752503f, -0.04758731f, 0.03393028f, 
    0.00490442f, 0.01445893f, 0.03598830f, 0.00132987f, 0.17192717f, 0.22391100f, 0.08069796f, 0.10969899f, 
    0.19926633f, -0.06618173f, 0.09648304f, -0.08510155f, 0.06572486f, -0.03481286f, -0.16067460f, -0.02397826f, 
    -0.03380890f, 0.00138111f, -0.10231698f, -0.01353789f, 0.03531088f, -0.00787890f, 0.00183627f, -0.03164609f, 
    0.06319606f, -0.25121254f, -0.04702725f, 0.02774214f, -0.06698038f, 0.10464589f, -0.06904227f, -0.00565324f, 
    -0.06361204f, -0.05804434f, -0.04265697f, 0.01678402f, -0.07516757f, -0.00180450f, -0.01658814f, -0.04124057f, 
    -0.05515149f, -0.02063732f, 0.01010659f, -0.04379539f, 0.21309745f, 0.02296250f, 0.23309688f, 0.16746300f, 
    0.20055406f, 0.00464968f, 0.14932433f, 0.01559165f, 0.07764127f, -0.07137015f, 0.02716279f, 0.02254762f, 
    -0.07587118f, 0.03354197f, -0.04214074f, -0.06432270f, 0.05470463f, 0.08696734f, -0.00077660f, -0.05191562f, 
    0.15633249f, 0.16340306f, -0.27922928f, 0.13773742f, 0.33221731f, -0.21283938f, -0.10155102f, -0.06063098f, 
    -0.03635764f, -0.03216057f, -0.08858079f, -0.00486265f, -0.04066070f, 0.06258028f, -0.07745207f, -0.05437069f, 
    -0.12462065f, 0.04539613f, -0.04324830f, 0.02812301f, -0.55370992f, 0.30368176f, -0.10315984f, -0.03809888f, 
    -0.05849359f, 0.02813380f, 0.00964424f, -0.12605850f, 0.02618301f, -0.14412259f, 0.02841313f, -0.05764801f, 
    -0.03627704f, -0.04777818f, -0.11512609f, -0.09426540f, -0.00486445f, 0.04310072f, -0.02376324f, -0.05711691f, 
    0.03218568f, 0.14357573f, 0.20913473f, 0.09461279f, 0.14815861f, 0.13293530f, 0.00588306f, -0.08967733f, 
    -0.09673823f, -0.01811967f, -0.03386429f, -0.01489661f, -0.00424547f, -0.10306043f, -0.03995191f, 0.03639305f, 
    -0.05965722f, 0.00979160f, 0.10768741f, -0.01781300f, 0.12787184f, 0.15822545f, 0.20389333f, -0.08047979f, 
    0.12549147f, -0.07758996f, 0.00876670f, -0.10046401f, -0.06678178f, -0.04944509f, 0.05227456f, 0.04371311f, 
    -0.02003752f, -0.08242047f, -0.06698436f, 0.08286814f, -0.05778139f, 0.05922233f, 0.07647294f, -0.05991166f, 
    -0.23700120f, -0.15483259f, -0.07434054f, -0.09635241f, -0.09868418f, -0.15824629f, -0.03618099f, -0.01607947f, 
    -0.07459605f, -0.05261609f, 0.06124149f, -0.03761578f, -0.02916495f, -0.08575162f, -0.00805401f, -0.02695405f, 
    -0.00811156f, -0.01773226f, -0.03108975f, -0.05211097f, -0.05259526f, 0.11761053f, -0.08165347f, 0.01623856f, 
    -0.02031503f, -0.01370349f, 0.03501652f, -0.06134000f, -0.03089490f, -0.02335869f, -0.02712136f, -0.00041564f, 
    -0.00973192f, -0.09064884f, -0.06459717f, -0.07480673f, -0.09912902f, 0.00660208f, 0.00884499f, -0.08779567f, 
    -0.13879529f, 0.08638594f, -0.00095476f, -0.23343311f, -0.05732193f, 0.09820777f, -0.05947531f, 0.02748389f, 
    0.05670734f, -0.04246434f, -0.03313870f, -0.02697221f, -0.01598872f, -0.08697753f, -0.02157061f, -0.02089931f, 
    -0.04617424f, 0.02618292f, 0.01144954f, 0.02822394f, 0.03446139f, -0.01475232f, -0.19630013f, -0.27409923f, 
    -0.22881958f, -0.10082731f, -0.09245834f, 0.00266411f, -0.03596777f, -0.06521947f, -0.02260285f, -0.01799181f, 
    -0.02409312f, -0.09270827f, -0.11109576f, 0.02174870f, -0.00853203f, -0.09069738f, -0.04812044f, -0.00874684f, 
    0.21147501f, -0.54730004f, 0.12953946f, 0.04656434f, -0.20465879f, 0.04400920f, -0.05202547f, -0.03775169f, 
    -0.17856096f, -0.08212594f, -0.00919515f, -0.05409226f, -0.05437403f, -0.04049281f, -0.10037083f, -0.01456120f, 
    0.07072570f, -0.07308672f, -0.08575200f, -0.05157610f, 0.03370941f, 0.17616409f, 0.02837626f, -0.18653247f, 
    -0.13827002f, -0.16671751f, 0.07190167f, 0.02922268f, -0.12335369f, 0.11358848f, -0.07798065f, -0.06286389f, 
    0.01063952f, -0.04211194f, 0.05781993f, -0.09888268f, -0.00234527f, -0.06863488f, -0.08117708f, 0.07042143f, 
    -0.21348646f, -0.00356313f, 0.10176294f, 0.11476132f, 0.08983676f, 0.06777023f, -0.12159263f, -0.10596798f, 
    0.17524844f, 0.00226003f, -0.07265415f, 0.03897419f, 0.00565822f, -0.04294728f, -0.09295846f, 0.02595855f, 
    -0.12237576f, 0.02957660f, -0.08345003f, 0.02962950f, 0.03445465f, 0.01031866f, 0.11580560f, 0.11005832f, 
    0.11744962f, -0.04087234f, 0.03506336f, -0.02099808f, 0.02633118f, -0.07289082f, -0.00974464f, 0.07980242f, 
    0.02915082f, -0.01130791f, -0.05813743f, 0.03012314f, -0.04972021f, -0.01357630f, -0.02787971f, -0.02145220f, 
    -0.16061491f, -0.41090450f, -0.17751494f, -0.16988827f, -0.29553890f, 0.04165258f, -0.00888079f, -0.00706838f, 
    -0.05425345f, -0.07660791f, -0.00952587f, -0.05965100f, -0.02892582f, -0.04965842f, -0.00339923f, 0.00410872f, 
    0.15053597f, 0.00745165f, -0.02176183f, 0.05128405f, 0.12296218f, 0.15114196f, 0.08197089f, -0.01041480f, 
    0.10025437f, 0.00300023f, 0.13694683f, -0.02831622f, -0.00620010f, -0.03032011f, -0.03483251f, 0.01276937f, 
    -0.01275297f, -0.00044419f, -0.12782519f, -0.01035146f, 0.04536254f, -0.04728909f, -0.07121851f, 0.04234003f, 
    -0.37132159f, 0.12003770f, -0.21240158f, -0.02966122f, -0.02125177f, -0.02163065f, -0.17789312f, -0.07955371f, 
    0.04804897f, -0.09812377f, -0.03061427f, 0.04319298f, 0.00845662f, -0.00469456f, -0.12488961f, -0.02486188f, 
    0.04105141f, 0.02100446f, 0.00822889f, -0.04310740f, 0.04186219f, 0.12855306f, 0.04901114f, 0.02027702f, 
    0.20227095f, 0.08017435f, -0.11874299f, -0.08562031f, -0.00034780f, 0.00148570f, -0.03978264f, 0.06681468f, 
    0.01841795f, -0.02540874f, -0.03078146f, -0.03068968f, -0.04944918f, 0.11092111f, 0.07366100f, -0.01191947f, 
    -0.08000219f, 0.02368842f, 0.03161801f, 0.12397225f, 0.14555474f, 0.12845223f, -0.02401149f, -0.09957026f, 
    0.03912558f, -0.07769819f, 0.00657558f, 0.00688746f, 0.04531248f, -0.09222370f, -0.06954189f, -0.06402639f, 
    -0.05486009f, -0.01114458f, -0.01920150f, -0.04678912f, -0.36743787f, -0.02748614f, -0.46720326f, -0.01166124f, 
    0.14933220f, -0.03534502f, -0.12912154f, -0.08834956f, -0.02945479f, -0.07812054f, -0.16452436f, 0.06834488f, 
    -0.03062135f, -0.05248700f, 0.00793695f, -0.05390817f, -0.07822233f, -0.06924925f, -0.04852589f, 0.07748859f, 
    -0.00137094f, 0.24832943f, 0.05207646f, 0.00209941f, -0.02304129f, -0.12956929f, -0.02735333f, -0.05324841f, 
    0.03446173f, -0.11559017f, -0.03483449f, 0.02684815f, 0.00658119f, 0.13328810f, -0.02556510f, 0.04168922f, 
    0.02513122f, -0.00090425f, 0.00281723f, -0.08346357f, 0.15357375f, -0.29585823f, 0.03265044f, 0.04820085f, 
    -0.13974620f, 0.05315961f, 0.00765202f, -0.03724727f, -0.08143890f, -0.00895568f, 0.00377685f, -0.00657023f, 
    -0.04693062f, 0.05360975f, -0.13061537f, -0.09296425f, 0.06829507f, -0.06261086f, 0.01955205f, -0.03277067f, 
    0.04551861f, 0.14710248f, 0.23824659f, 0.06370261f, 0.13578324f, -0.00083358f, 0.11938716f, -0.05943126f, 
    -0.03950651f, -0.07329569f, 0.01146442f, 0.00118148f, 0.03704280f, -0.02881136f, -0.04750125f, -0.15202270f, 
    -0.02878307f, 0.00027380f, 0.01443639f, -0.06621512f, 0.05381358f, -0.47385371f, 0.01320098f, -0.10091300f, 
    -0.14742731f, -0.03985433f, -0.11163588f, -0.00409276f, -0.13356747f, -0.06870577f, -0.07531100f, 0.02882637f, 
    -0.07693911f, -0.02032562f, -0.05028173f, -0.01409105f, 0.14609209f, -0.01739347f, 0.00510656f, 0.00687422f, 
    0.27328637f, 0.02482084f, 0.20745917f, -0.06095884f, 0.13379891f, -0.03563117f, 0.12563044f, -0.05654720f, 
    -0.06237594f, -0.00787476f, -0.05934088f, 0.07276376f, -0.06694345f, 0.03582786f, -0.11485577f, -0.04947771f, 
    -0.02852387f, 0.04121733f, -0.00187909f, -0.08058916f, 0.16915552f, 0.03785055f, -0.07390662f, 0.16685875f, 
    0.32621565f, -0.02921099f, -0.00949004f, -0.02695755f, -0.07815545f, -0.11016442f, -0.09315643f, 0.02665820f, 
    -0.07689158f, -0.00129282f, -0.06860312f, -0.05164867f, -0.00922560f, -0.00774144f, -0.06964935f, -0.01938496f, 
    0.01620847f, 0.05944274f, -0.02306821f, 0.06333187f, 0.10692403f, 0.05490242f, -0.12456124f, 0.00764249f, 
    -0.05703367f, -0.09419126f, -0.01610777f, -0.03342275f, -0.01336390f, -0.08695161f, -0.04135878f, -0.04220496f, 
    0.00133550f, 0.03413780f, -0.01164580f, -0.09751999f, -0.03160436f, 0.32273743f, -0.05622215f, -0.04778429f, 
    -0.10842592f, 0.06885551f, 0.08140454f, -0.05503590f, 0.00867623f, 0.02041809f, -0.06041558f, 0.01948063f, 
    -0.03569634f, -0.00881970f, -0.00419518f, 0.04914782f, -0.04966882f, 0.02703043f, -0.02904792f, -0.00876469f, 
    -0.06238346f, -0.02330155f, 0.08831985f, -0.01286197f, 0.11989189f, -0.12718365f, -0.09221766f, 0.02431310f, 
    -0.08370374f, 0.17293227f, -0.03493392f, -0.02574235f, -0.12479825f, -0.08355732f, 0.04785554f, 0.00905614f, 
    0.01637492f, 0.07293978f, 0.09939456f, -0.00023039f, -0.00456573f, -0.14352246f, 0.10319453f, 0.09695160f, 
    0.11494455f, -0.13362256f, -0.03288752f, 0.01265658f, -0.11443567f, 0.10721774f, -0.06272269f, -0.07217563f, 
    0.04365473f, 0.05538943f, -0.05308022f, 0.05222143f, -0.02428905f, -0.08076782f, 0.05641462f, -0.00380219f, 
    -0.05524432f, -0.13202786f, 0.14522323f, -0.04551694f, 0.09395081f, -0.08704005f, -0.08489674f, -0.07226417f, 
    -0.04673611f, 0.08022474f, -0.01071245f, -0.00458290f, -0.10940903f, -0.17796552f, 0.02569191f, -0.02648607f, 
    0.03808883f, 0.00282014f, 0.14200228f, -0.02747208f, -0.20257191f, 0.09721567f, 0.01127913f, -0.23653401f, 
    -0.32677144f, -0.02018275f, -0.03233518f, -0.00172536f, -0.01531464f, -0.06370065f, 0.07659730f, -0.03859342f, 
    0.00304468f, 0.02632299f, -0.00409161f, -0.09919805f, 0.01876096f, -0.14052583f, 0.01398043f, -0.05448829f, 
    0.14411876f, 0.01043517f, 0.03941533f, -0.01691461f, 0.11495392f, -0.08944669f, -0.06416613f, -0.08957911f, 
    0.01098740f, -0.03540407f, -0.02020446f, -0.09713968f, 0.07670452f, 0.00033416f, -0.09482732f, -0.05086631f, 
    -0.06895961f, 0.04980842f, -0.02462166f, 0.07360271f, -0.18536611f, -0.10523237f, 0.17510280f, -0.10728812f, 
    0.03136568f, -0.00640703f, -0.07044917f, 0.07466202f, -0.03120452f, -0.07978412f, -0.04996448f, -0.01712707f, 
    -0.01599068f, -0.01938065f, -0.00964749f, -0.04914886f, 0.03973950f, -0.11572978f, 0.03537859f, -0.12065867f, 
    -0.00649927f, 0.02541430f, 0.05727300f, -0.26052469f, -0.08638270f, -0.00901984f, -0.02258242f, -0.08190505f, 
    -0.11054559f, -0.10858952f, 0.01958741f, 0.01115647f, 0.02096205f, 0.04982082f, -0.09194919f, -0.03101916f, 
    0.12126113f, -0.08205725f, -0.12737599f, 0.02242341f, 0.08829854f, 0.05955351f, -0.31401157f, 0.14664012f, 
    0.06730479f, 0.01761753f, 0.12732251f, -0.11631951f, -0.12923197f, -0.07691297f, 0.03691044f, 0.08268440f, 
    0.00390509f, -0.04100806f, 0.09654561f, -0.03760525f, 0.01130885f, -0.04707619f, 0.17592612f, 0.02676462f, 
    -0.24576147f, -0.13286290f, 0.33130288f, -0.21852000f, -0.15529107f, 0.01333129f, -0.04207623f, 0.00081581f, 
    -0.05075210f, 0.02160486f, 0.08525033f, 0.10412224f, -0.07020754f, 0.09177981f, -0.08494607f, -0.08813591f, 
    0.02682800f, 0.04434179f, -0.30782080f, -0.03897248f, -0.26373369f, 0.17252888f, 0.22043006f, -0.14679010f, 
    -0.08426110f, 0.06370366f, -0.02586375f, -0.11093210f, 0.08276064f, 0.00521292f, -0.08087108f, 0.02221543f, 
    -0.06143559f, 0.10513169f, 0.04348036f, -0.11225385f, 0.01578151f, -0.01771139f, -0.05114606f, 0.09129780f, 
    0.23197104f, 0.21697025f, -0.03830121f, 0.02917192f, 0.13165827f, -0.10225938f, -0.12394216f, -0.12556140f, 
    -0.08368623f, -0.09238905f, 0.10761984f, 0.01442489f, 0.04104466f, -0.01177651f, -0.01245016f, -0.06210679f, 
    0.01318592f, 0.01868571f, 0.06734384f, -0.10498188f, -0.16174781f, 0.17710285f, 0.02221732f, -0.06688514f, 
    -0.13609526f, 0.05587500f, -0.00623426f, 0.00407493f, 0.07171420f, -0.00916900f, -0.02445650f, 0.03044711f, 
    -0.04494000f, 0.00599637f, 0.07957134f, -0.08211648f, -0.05967754f, -0.01103177f, 0.00925628f, -0.12415791f, 
    0.24888408f, 0.18986757f, -0.10431393f, 0.02922790f, 0.17804247f, 0.10314291f, -0.01041701f, -0.08882015f, 
    -0.02817228f, 0.02065565f, 0.10545340f, 0.06467451f, 0.05051739f, 0.01636295f, -0.17243677f, 0.02566268f, 
    0.03299553f, 0.13417427f, 0.04304142f, 0.09947196f, 0.08673187f, 0.09151211f, -0.20452951f, 0.00922505f, 
    0.17809060f, 0.08823098f, 0.06560320f, -0.14559531f, -0.06580891f, -0.07856892f, -0.00838799f, 0.12718871f, 
    -0.05900087f, 0.02879066f, 0.05162605f, -0.16560920f, 0.01483823f, 0.05361903f, 0.11366217f, 0.01259583f, 
    0.01515420f, 0.00829936f, 0.04972490f, 0.11788809f, 0.05602368f, -0.00724623f, -0.05743023f, -0.12113989f, 
    -0.14167966f, 0.08898839f, -0.05927808f, -0.01551828f, -0.05984104f, -0.04560797f, 0.02045249f, -0.02104420f, 
    -0.04854109f, -0.00496438f, 0.00124475f, 0.07590050f, 0.09629508f, 0.07549576f, -0.03709557f, -0.10452510f, 
    0.00718512f, 0.01105893f, 0.03602482f, 0.09238174f, -0.03367120f, -0.05506797f, 0.11611724f, 0.00230130f, 
    -0.00185604f, -0.13443756f, 0.00091894f, -0.15747309f, -0.08148137f, -0.00589724f, 0.13883151f, -0.05993905f, 
    -0.05630215f, 0.19622326f, -0.32788888f, 0.07884933f, -0.07621700f, 0.06269175f, -0.01926684f, -0.16252740f, 
    -0.14577381f, 0.01306983f, 0.04105042f, 0.04453139f, 0.11758717f, -0.00986146f, -0.03722918f, -0.01102169f, 
    -0.06431979f, -0.15750520f, 0.10132024f, 0.00649545f, -0.03329919f, 0.00279725f, 0.14560366f, 0.06828257f, 
    0.20381758f, -0.05142203f, -0.09947874f, 0.08092149f, -0.07315399f, 0.02177195f, 0.00410469f, -0.07156268f, 
    -0.07978364f, -0.13086842f, 0.08742432f, -0.02526928f, -0.01359145f, 0.09067497f, 0.00696245f, 0.03163481f, 
    0.16828792f, -0.06646194f, -0.24672841f, 0.06228705f, 0.06267155f, 0.12817687f, 0.04672429f, -0.04289390f, 
    -0.06583526f, 0.03608051f, -0.04646732f, 0.08229729f, -0.04218814f, 0.04471819f, -0.03975015f, 0.03342063f, 
    0.00246809f, 0.06333403f, 0.06586946f, -0.05094447f, -0.12076101f, 0.16150331f, -0.16897923f, -0.05730924f, 
    -0.12491740f, 0.02109752f, 0.02078987f, -0.09167822f, -0.01413099f, 0.05423211f, 0.03950521f, 0.06246580f, 
    0.07263751f, 0.01213028f, 0.07008269f, -0.06092174f, -0.07196636f, -0.00182270f, 0.05454433f, -0.01284024f, 
    0.10626633f, -0.06821394f, -0.23323940f, -0.04425139f, 0.09389479f, 0.00096213f, -0.02812761f, -0.05382906f, 
    -0.01513187f, -0.00628160f, 0.10445687f, -0.00117196f, 0.09180070f, -0.01553772f, 0.10770053f, 0.02194146f, 
    0.06344011f, 0.07002579f, 0.14952601f, 0.00542842f, -0.24363352f, 0.00580312f, -0.12477583f, -0.24599031f, 
    -0.26423180f, -0.02913578f, -0.07332596f, -0.04749271f, 0.02477811f, 0.01112868f, 0.11444502f, -0.01491733f, 
    0.07319409f, -0.06114719f, 0.03558630f, -0.01624745f, -0.07466128f, -0.27200764f, -0.03954518f, 0.05132468f, 
    -0.20992900f, -0.02389223f, -0.06781057f, -0.46377397f, -0.16249923f, 0.09935174f, -0.11817380f, -0.07306755f, 
    0.12329587f, -0.12516780f, 0.13691042f, 0.02101413f, -0.00603981f, -0.07742070f, 0.05882727f, -0.09294515f, 
    0.01006409f, -0.06090014f, -0.03593302f, -0.14174426f, -0.02359656f, 0.00875206f, -0.09819334f, 0.03961477f, 
    0.11644643f, 0.08084510f, 0.06461422f, -0.01130582f, -0.05172314f, -0.05660995f, 0.00616862f, -0.02425308f, 
    -0.03540403f, 0.06925740f, -0.05355937f, -0.11136563f, 0.11824317f, 0.05850266f, 0.03899653f, -0.14262220f, 
    0.10036784f, 0.03546086f, -0.06292647f, 0.18565404f, -0.00297564f, -0.05439172f, 0.06139508f, -0.32616392f, 
    -0.07300562f, -0.12403088f, 0.09911371f, 0.01105414f, 0.01633805f, -0.07078315f, 0.14016549f, -0.03868600f, 
    0.02864213f, -0.06879836f, 0.19683342f, -0.14100640f, 0.18233985f, -0.01992231f, 0.06876685f, 0.00604947f, 
    0.10113905f, 0.01879567f, 0.05681249f, -0.02035692f, 0.00010550f, -0.00614845f, 0.01004469f, 0.02516879f, 
    0.05431586f, 0.02292269f, -0.06322154f, 0.06637528f, -0.05762535f, 0.04178612f, -0.02959427f, 0.12732184f, 
    -0.05078137f, -0.09885326f, 0.12769939f, 0.09589203f, 0.10231568f, -0.19724654f, 0.00049937f, -0.00690401f, 
    -0.01944754f, 0.02684911f, -0.01657839f, -0.08568561f, -0.05821811f, 0.01694657f, 0.10666617f, 0.04722855f, 
    0.01671579f, -0.03306322f, 0.05391057f, -0.00321200f, -0.10326515f, -0.19877730f, 0.09176818f, 0.05850527f, 
    0.22098526f, 0.11627223f, 0.09319022f, -0.06054600f, -0.01229819f, -0.11208666f, 0.11869320f, 0.04143488f, 
    0.05137927f, 0.04764272f, -0.04227975f, -0.08855434f, -0.00086385f, 0.04349103f, 0.00372414f, -0.10423277f, 
    -0.09674682f, -0.07515455f, 0.14585599f, 0.01291982f, 0.13603857f, 0.02274325f, 0.00104186f, 0.01187033f, 
    -0.16014689f, 0.08057524f, 0.11448668f, 0.00369065f, -0.03272906f, 0.07689344f, 0.04371596f, -0.02025993f, 
    -0.00096155f, -0.05367322f, 0.08840651f, 0.00493846f, -0.27516070f, -0.16180289f, 0.07368115f, -0.58751768f, 
    -0.23871900f, -0.10775137f, 0.01441998f, -0.06442702f, -0.00956643f, -0.09496677f, 0.11951488f, 0.07713380f, 
    0.06071023f, 0.05432843f, -0.08758051f, -0.13232763f, 0.08244927f, -0.06809381f, -0.31275114f, -0.05685333f, 
    -0.26168612f, -0.04297339f, -0.24475488f, -0.29700795f, -0.15173392f, 0.07429992f, -0.05391411f, -0.12391351f, 
    -0.02292317f, -0.14331855f, 0.08860295f, 0.00646322f, -0.01224079f, -0.00686413f, -0.01115850f, -0.04360478f, 
    0.00852320f, -0.12363816f, -0.07431044f, -0.01779052f, -0.09574495f, 0.25002134f, -0.13827223f, -0.07751160f, 
    -0.16271999f, -0.02850802f, 0.06456579f, -0.16743207f, 0.07168896f, -0.06998239f, 0.09380868f, -0.00697656f, 
    0.01464380f, -0.02303821f, 0.06913505f, -0.12481365f, 0.02015870f, -0.06593443f, 0.10214881f, -0.08210029f, 
    -0.21954396f, -0.26288772f, 0.04549959f, 0.18717609f, -0.08578819f, 0.00558269f, 0.06885248f, -0.02860444f, 
    0.07179836f, -0.01924561f, -0.16405062f, 0.07473706f, 0.00845963f, -0.01026510f, 0.00335859f, -0.05064696f, 
    -0.03049329f, 0.04694364f, -0.08943779f, 0.09768157f, 0.39248499f, -0.30093497f, -0.08145551f, 0.09118777f, 
    0.07977534f, -0.07762955f, -0.02870173f, -0.06675670f, 0.11385080f, 0.14630301f, -0.08472054f, 0.06160146f, 
    0.01564972f, 0.07589737f, -0.00920014f, -0.03726600f, -0.00077207f, 0.06797410f, -0.01899138f, 0.04808747f, 
    -0.07709225f, -0.07555102f, -0.00613593f, -0.21164072f, 0.18559323f, 0.13664329f, -0.14812122f, -0.01355349f, 
    -0.06437620f, 0.23361579f, -0.01268576f, -0.01954512f, 0.05148541f, 0.25737488f, -0.01799709f, -0.01704629f, 
    0.02368921f, -0.00281013f, 0.03763455f, -0.17825297f, -0.20256741f, 0.27574533f, 0.01265335f, 0.07349531f, 
    -0.12107184f, 0.04372313f, -0.02393537f, -0.17557637f, -0.06491033f, 0.14856316f, -0.06258534f, -0.08391393f, 
    0.05424676f, 0.06238249f, 0.19135611f, 0.14299130f, 0.13376123f, 0.08669966f, -0.08959226f, 0.09150137f, 
    0.06831561f, 0.01900404f, 0.00661059f, -0.15660150f, -0.11463895f, 0.02385556f, 0.05978024f, -0.03193059f, 
    -0.07398652f, -0.06630368f, 0.07820592f, 0.02446662f, 0.04348546f, 0.10951160f, 0.03216381f, 0.06483074f, 
    -0.00652377f, 0.03424959f, -0.00526881f, -0.06569672f, 0.06446093f, 0.02202391f, -0.05044233f, 0.06839155f, 
    0.01679811f, 0.06484524f, -0.15630460f, -0.03702309f, -0.16306376f, 0.10030220f, -0.01583610f, -0.14951250f, 
    0.03447046f, 0.11356346f, 0.07762181f, 0.13529409f, -0.13123794f, 0.05822543f, 0.04637177f, 0.01780968f, 
    0.20716074f, 0.11596840f, -0.27149168f, -0.52108967f, -0.32139426f, 0.00973543f, 0.05125066f, -0.03335533f, 
    -0.05278993f, -0.04058389f, -0.10200720f, -0.02120305f, -0.09571099f, 0.03882193f, -0.04884946f, -0.15230569f, 
    0.02542945f, -0.01194214f, 0.17530394f, 0.02501625f, -0.61394566f, 0.23794010f, 0.23134862f, -0.06364088f, 
    -0.20205751f, 0.04701112f, 0.09301959f, 0.02649206f, -0.03079737f, -0.02862809f, 0.00699913f, 0.00655823f, 
    -0.10119924f, 0.02948433f, 0.00225204f, 0.14880061f, 0.04194419f, 0.22115184f, -0.15787409f, 0.02563351f, 
    0.07798318f, -0.35503796f, -0.03715076f, 0.25050181f, 0.00288109f, -0.12796970f, 0.07142595f, -0.04437391f, 
    -0.04415530f, -0.13929346f, -0.06212789f, 0.02574576f, -0.06516460f, -0.02479599f, 0.00588048f, -0.07626121f, 
    0.06086594f, 0.01742290f, 0.12023840f, -0.03295176f, -0.06126150f, -0.11396780f, -0.01282430f, 0.17482610f, 
    -0.04067257f, -0.04485757f, 0.05569682f, -0.05403488f, -0.11347625f, 0.00993440f, 0.02814475f, 0.08332872f, 
    0.04624068f, 0.01437883f, 0.02959379f, -0.09714040f, -0.03795978f, -0.10078850f, 0.00039639f, -0.15884593f, 
    0.06084957f, 0.04280521f, -0.26858458f, 0.17025167f, -0.14407115f, 0.07054482f, 0.03484418f, 0.07732031f, 
    0.05024438f, -0.12506856f, -0.02880776f, 0.14044955f, -0.02943143f, 0.02493661f, 0.02788421f, -0.00923168f, 
    0.04982166f, -0.00738439f, -0.03733348f, 0.03962309f, -0.00155838f, -0.01566201f, 0.11754894f, -0.31025323f, 
    -0.07520322f, -0.22509852f, -0.02262861f, 0.12667485f, 0.17679982f, 0.02496825f, 0.00780471f, -0.02197355f, 
    0.11627144f, 0.03229717f, 0.06586060f, 0.03027988f, 0.03740031f, -0.03054671f, 0.00791420f, -0.09174325f, 
    0.21479553f, 0.00515927f, -0.03138768f, -0.38099408f, -0.30384296f, -0.00162893f, 0.08024818f, -0.04183118f, 
    -0.03256302f, -0.17149319f, 0.00798684f, -0.06948544f, -0.01645539f, 0.05801008f, -0.08841169f, -0.06094585f, 
    0.11373042f, -0.12588024f, 0.02366460f, -0.02326832f, -0.07719678f, 0.02290125f, 0.04401022f, 0.08938897f, 
    -0.22815068f, 0.00932555f, 0.06892217f, 0.02466942f, 0.03263818f, -0.15992765f, -0.01758348f, -0.02343636f, 
    -0.09528281f, -0.07098442f, 0.03970280f, 0.03053315f, -0.05273402f, -0.11998003f, -0.11733422f, -0.07071097f, 
    0.34992263f, -0.51489651f, 0.25172332f, 0.01917670f, 0.00268490f, 0.00286326f, -0.01634747f, -0.03701602f, 
    0.02584147f, -0.06753618f, 0.04591019f, 0.04474276f, 0.13702945f, 0.06447625f, 0.03080942f, 0.03131334f, 
    -0.00542950f, -0.14867194f, -0.08174329f, 0.01164920f, -0.52160639f, 0.14157163f, -0.00049231f, 0.03251090f, 
    0.04554717f, 0.03742854f, 0.01256407f, 0.09881139f, 0.14452097f, 0.06932314f, 0.05978866f, 0.00870964f, 
    -0.05950077f, -0.01229295f, -0.00536914f, 0.13204715f, -0.11908702f, -0.05726432f, -0.14888999f, 0.06314284f, 
    0.34539646f, -0.41126561f, 0.15845343f, -0.13358112f, 0.21355146f, -0.18945934f, 0.04911131f, 0.01930354f, 
    0.16345130f, -0.12941326f, 0.03637751f, -0.09368396f, -0.13673624f, -0.04870838f, -0.07755304f, 0.03784436f, 
    0.02553426f, 0.17947704f, -0.08258874f, 0.22763507f, 0.57947880f, 0.12666088f, -0.21366896f, 0.05898559f, 
    0.07121098f, 0.05657834f, -0.10337914f, 0.00713638f, 0.02618732f, 0.06961378f, -0.03819302f, -0.02340483f, 
    -0.00610676f, 0.05763742f, -0.07264663f, 0.05575634f, -0.01362679f, 0.04325562f, -0.03375242f, -0.06337136f, 
    -0.00988849f, -0.36107281f, 0.27774569f, -0.16156940f, -0.34398040f, 0.03466337f, 0.09030575f, 0.01735770f, 
    -0.06866758f, -0.00082052f, -0.13776483f, -0.10356206f, -0.09615418f, -0.09802356f, -0.06309580f, -0.10206733f, 
    -0.01500161f, 0.05611916f, 0.01458422f, -0.02077136f, 0.15991886f, -0.15481517f, 0.01225644f, 0.13889654f, 
    -0.15249531f, -0.03551280f, 0.03521105f, 0.10310739f, 0.20121595f, -0.08221554f, 0.00620449f, 0.07853564f, 
    0.01601055f, 0.05225138f, -0.03962356f, 0.11477891f, 0.03479033f, 0.11525077f, 0.04076131f, 0.02319350f, 
    -0.20510918f, 0.25829634f, 0.10447376f, -0.51783347f, -0.05665296f, -0.05768789f, 0.04815266f, -0.12141500f, 
    0.07423925f, 0.06279825f, 0.05244922f, -0.02645213f, -0.01192407f, -0.13414186f, -0.02306605f, -0.01450854f, 
    -0.03562248f, 0.00888502f, -0.12271657f, -0.07779174f, -0.26224867f, -0.04096061f, -0.02745163f, 0.17911603f, 
    0.02079225f, 0.02513660f, 0.02105218f, 0.10045731f, 0.02548893f, 0.00246493f, 0.09257798f, -0.03460333f, 
    -0.12021969f, -0.03419041f, -0.04262282f, -0.00160496f, -0.10687165f, 0.10115267f, 0.06246125f, 0.06707276f, 
    -0.00504164f, -0.29027689f, 0.13971792f, -0.15329251f, -0.19569220f, -0.15424840f, 0.05141768f, 0.07316535f, 
    0.10406020f, 0.09690646f, -0.06600701f, 0.03278495f, 0.12886767f, 0.03839556f, 0.06076044f, 0.08236970f, 
    0.07106775f, 0.09667572f, 0.12074352f, -0.16428751f, 0.27274379f, 0.04612433f, 0.00700262f, -0.39197963f, 
    -0.51626378f, -0.04082815f, 0.02252614f, -0.01061658f, -0.08896077f, 0.10454826f, -0.23462801f, -0.00837649f, 
    -0.00337001f, -0.15658551f, 0.03845349f, 0.06130231f, 0.03505913f, -0.06668058f, 0.04531839f, -0.02395893f, 
    -0.68302542f, 0.28213590f, 0.23108377f, -0.16367002f, 0.02448350f, 0.06011683f, 0.18752262f, -0.00701359f, 
    -0.04260975f, 0.02602011f, -0.01442931f, 0.01943804f, -0.04498817f, 0.00263212f, 0.05388872f, 0.09407409f, 
    0.09124319f, 0.06757662f, -0.17714626f, 0.16413352f, 0.26648438f, -0.16046600f, 0.25290525f, -0.03585346f, 
    -0.03074831f, 0.07469743f, 0.03247404f, -0.03839626f, -0.06102496f, -0.02694025f, -0.06704842f, -0.05910407f, 
    0.05933104f, -0.00548070f, 0.10830498f, -0.02318355f, -0.09246778f, -0.07882172f, -0.03475816f, 0.10296102f, 
    -0.27341673f, -0.12176112f, -0.20769462f, 0.17190248f, 0.08953478f, 0.17830871f, -0.05536054f, -0.08938840f, 
    -0.01980609f, 0.14249235f, 0.01564061f, -0.05835774f, 0.00900094f, -0.06793194f, -0.10018153f, -0.07720054f, 
    -0.15558754f, -0.06187009f, 0.00813994f, -0.01532834f, 0.21817818f, -0.58410257f, 0.34351492f, -0.18324955f, 
    -0.19649434f, -0.07661998f, 0.08989504f, -0.13255771f, 0.01078262f, 0.06700923f, 0.02667274f, 0.07127774f, 
    0.21289265f, -0.14528947f, -0.08775716f, -0.06497797f, 0.08059980f, -0.01006368f, -0.05743115f, -0.03021597f, 
    -0.10145658f, -0.28768229f, -0.14471033f, 0.13368890f, 0.00148589f, 0.06253712f, 0.05077955f, -0.15847127f, 
    -0.07786285f, 0.06655512f, -0.11607608f, 0.10333296f, -0.04362806f, -0.06661991f, 0.15181161f, -0.10602591f, 
    -0.05123967f, -0.03986470f, 0.05067950f, 0.01693866f, 0.10977979f, 0.01466296f, -0.06294020f, -0.11307534f, 
    -0.13628586f, -0.17745611f, 0.03928607f, -0.09355632f, 0.00563143f, -0.13968644f, 0.09487288f, -0.00911454f, 
    -0.09764732f, -0.00369720f, -0.05629485f, 0.11301670f, 0.09523246f, 0.01276040f, 0.10950292f, 0.13155670f, 
    -0.12671073f, -0.28441429f, 0.07259066f, 0.05420118f, 0.07432270f, -0.16863866f, 0.02983215f, -0.06888779f, 
    -0.02390326f, -0.00814559f, -0.01367551f, 0.04708770f, 0.04162023f, -0.07512145f, -0.06601398f, 0.13981549f, 
    0.03248559f, -0.15466955f, 0.03955402f, 0.06990601f, -0.27823755f, -0.08016299f, 0.34968388f, -0.19316906f, 
    0.02281753f, 0.08528294f, 0.05390524f, 0.04644237f, 0.15437070f, -0.10404810f, 0.09070462f, 0.02526372f, 
    0.07532629f, 0.02317279f, 0.08242869f, 0.00134708f, 0.06974565f, 0.07155675f, -0.06322815f, 0.02428304f, 
    0.30135494f, -0.17620674f, 0.03681010f, 0.04463246f, -0.04941484f, -0.17258246f, 0.01857393f, -0.16541603f, 
    -0.01047387f, -0.16230923f, -0.07766656f, 0.12261565f, -0.08258396f, -0.19760866f, 0.01484795f, -0.03703207f, 
    0.05432892f, -0.08409284f, -0.14278553f, -0.14432526f, 0.16258621f, 0.03524188f, -0.10539871f, 0.09377015f, 
    0.02011515f, -0.09220603f, -0.03477779f, 0.04887049f, -0.00983690f, 0.02955703f, -0.04310717f, 0.05056598f, 
    -0.00486862f, -0.02723576f, 0.02118576f, 0.01689792f, 0.08593579f, 0.05977486f, -0.04812277f, 0.00930607f, 
    0.10432839f, 0.19823179f, -0.24601161f, 0.05203976f, -0.06465237f, -0.03331316f, -0.08974054f, -0.06787814f, 
    -0.05898124f, -0.04190830f, 0.00553111f, 0.00716645f, -0.06573754f, -0.16538881f, -0.02813883f, -0.21004438f, 
    -0.03677914f, 0.04601154f, 0.03906614f, -0.01804408f, -0.30357540f, -0.22887315f, 0.10284100f, 0.07244153f, 
    0.11360046f, 0.02764481f, 0.00713111f, 0.06619038f, -0.08167560f, -0.00540493f, 0.01148281f, 0.00315982f, 
    -0.05284217f, -0.06557770f, -0.02794324f, -0.02871234f, -0.09512091f, -0.29774278f, 0.01431136f, 0.01046527f, 
    -0.18795064f, 0.05343056f, -0.13209544f, -0.01360190f, 0.08319818f, 0.05551926f, 0.02185872f, -0.03165714f, 
    0.03244704f, 0.13673873f, 0.05256845f, -0.03700268f, 0.04248388f, -0.02165153f, 0.11483113f, 0.00222734f, 
    0.07343911f, 0.21482141f, 0.08747399f, 0.10557168f, 0.20461980f, 0.11892871f, 0.09340537f, 0.03118474f, 
    -0.06959414f, -0.07248925f, -0.03254334f, 0.11683801f, -0.01338575f, 0.08545023f, -0.03314240f, -0.00237629f, 
    -0.04958676f, -0.14172769f, -0.07512082f, -0.02342005f, -0.04694596f, 0.03841980f, -0.03904203f, -0.01121438f, 
    0.10781455f, 0.19624630f, 0.19652469f, -0.10346611f, -0.30574808f, 0.16202757f, -0.02382666f, -0.01610273f, 
    0.05911760f, 0.05819502f, 0.02670043f, 0.00673626f, 0.06432644f, 0.00366976f, 0.05365971f, 0.07725858f, 
    0.18913975f, -0.07906710f, -0.09249227f, 0.02768060f, -0.73015982f, -0.43081072f, -0.05212767f, 0.10117452f, 
    -0.03139411f, 0.12168605f, 0.08661152f, -0.01717119f, 0.00219752f, -0.08870425f, 0.16635942f, 0.01945825f, 
    -0.00554161f, -0.01264376f, 0.09197727f, 0.01014939f, -0.05578647f, -0.03101572f, 0.04952827f, -0.01056021f, 
    0.22485170f, 0.09558018f, 0.10601258f, -0.07987874f, -0.04742051f, 0.01148833f, -0.07953540f, 0.09885360f, 
    0.00098286f, 0.00271122f, 0.08221134f, -0.04174531f, -0.04906737f, 0.07339248f, -0.09230317f, -0.00944118f, 
    -0.08855782f, -0.09440487f, -0.14875963f, -0.01026639f, 0.04881501f, -0.00509506f, 0.04011679f, -0.02578042f, 
    -0.01149225f, 0.10624883f, 0.06729688f, 0.00865027f, 0.01161545f, -0.04001368f, 0.05880222f, -0.01311186f, 
    -0.03038660f, -0.00637794f, 0.03118198f, 0.02524384f, 0.00261707f, 0.06445679f, 0.01482794f, 0.08101878f, 
    -0.05340292f, -0.08324232f, -0.01680843f, -0.02914797f, -0.09721079f, -0.02091333f, 0.07638287f, -0.00641948f, 
    0.04211054f, -0.00271161f, 0.03743459f, -0.07871319f, 0.01277175f, -0.09473570f, -0.00541232f, -0.14542019f, 
    0.06770204f, 0.09567449f, 0.15776867f, 0.08454435f, 0.03416140f, -0.21116690f, 0.00971054f, -0.03598458f, 
    0.17553051f, 0.00426993f, -0.03455243f, 0.10505380f, -0.02893733f, 0.02515981f, -0.00667520f, 0.00725685f, 
    -0.09988143f, 0.00923423f, 0.00321156f, -0.01212760f, 0.07068682f, 0.01528914f, 0.05383813f, 0.11614262f, 
    -0.58704472f, -0.46266904f, -0.15620467f, -0.20191540f, -0.03610248f, 0.07674440f, -0.01544916f, -0.05529219f, 
    -0.06511545f, 0.10793860f, -0.04144447f, -0.06721471f, -0.06408535f, 0.02940375f, 0.02661096f, 0.03467073f, 
    -0.01179782f, 0.12936465f, 0.04618856f, 0.00261649f, -0.67359453f, -0.37547475f, -0.07519723f, -0.06650829f, 
    -0.12730679f, 0.14047511f, 0.08267488f, -0.10195018f, -0.12051711f, 0.08165277f, 0.07375664f, -0.05906492f, 
    -0.03844838f, 0.04567487f, 0.04477641f, 0.03866448f, 0.07808823f, 0.04947193f, 0.15267311f, -0.00574840f, 
    -0.47382796f, 0.05810748f, -0.14977524f, -0.10483751f, 0.15223224f, 0.05417090f, 0.11480548f, -0.09940103f, 
    -0.00567548f, 0.01297533f, 0.09169825f, 0.06123379f, 0.01709771f, -0.02098509f, 0.08580790f, 0.07814565f, 
    -0.00722975f, 0.06545642f, -0.07451592f, 0.05432184f, -0.11521972f, -0.05120290f, -0.04116679f, -0.01292715f, 
    0.01335516f, -0.02601195f, 0.07769308f, 0.15491804f, 0.01929401f, -0.03208647f, 0.07245743f, -0.10838714f, 
    0.02853221f, -0.06257227f, 0.15901834f, 0.03198769f, 0.01475140f, 0.04720088f, 0.13682395f, -0.02091382f, 
    -0.07229095f, -0.05733573f, -0.14877133f, 0.17973942f, 0.15649366f, 0.07092124f, 0.02859313f, -0.03153290f, 
    0.04318507f, 0.05684390f, 0.02731121f, 0.06457783f, 0.08470950f, -0.09196562f, 0.24984372f, -0.03529203f, 
    0.04053907f, -0.03126077f, -0.02312835f, -0.08350077f, 0.19797999f, 0.00167761f, -0.02886653f, -0.02097472f, 
    0.03567449f, -0.13576397f, -0.12716819f, -0.04937676f, 0.03581802f, -0.07102054f, -0.02967628f, 0.05236859f, 
    -0.07203146f, -0.03220788f, -0.05502312f, -0.06468485f, 0.03230676f, 0.02070073f, -0.09259758f, -0.06269134f, 
    -0.57533574f, -0.37999284f, -0.17350335f, -0.02529498f, -0.14445931f, 0.13092196f, 0.00911066f, -0.08713597f, 
    -0.04960201f, 0.03428573f, 0.00355113f, 0.09942023f, -0.06421424f, 0.19662015f, -0.03628730f, 0.15022787f, 
    0.07210020f, 0.06642652f, -0.08150605f, 0.00785402f, -0.11655197f, -0.09729412f, 0.09795634f, 0.07091597f, 
    0.28493080f, 0.09266581f, 0.09989580f, -0.00259444f, 0.04787206f, -0.11548863f, -0.04853641f, 0.08336723f, 
    -0.00289765f, 0.05279800f, 0.07977901f, 0.01690490f, 0.11231868f, 0.01054338f, 0.03525900f, 0.03125331f, 
    -0.32717866f, -0.24378809f, -0.15376231f, -0.13123536f, -0.03485576f, 0.14460567f, 0.00845786f, -0.00963846f, 
    -0.07351990f, 0.06140134f, 0.01446182f, 0.02463971f, 0.13323247f, -0.00374073f, 0.04235588f, 0.00206222f, 
    -0.02631664f, -0.11525167f, 0.01115268f, -0.05376843f, 0.29693288f, 0.12831041f, -0.00125949f, -0.00633253f, 
    0.03508531f, 0.04689055f, 0.09031269f, 0.04587485f, -0.08368510f, 0.01102982f, -0.07612012f, 0.01550042f, 
    0.05816865f, -0.02519742f, -0.00245764f, 0.08884238f, 0.09522299f, -0.30203429f, -0.14173581f, 0.04741828f, 
    0.08183088f, 0.20284186f, 0.11533300f, 0.04320783f, 0.11436722f, 0.08020847f, -0.01038202f, 0.17291383f, 
    0.06349576f, 0.03825527f, 0.04744456f, -0.00121842f, 0.04436466f, 0.04599782f, -0.00370938f, -0.11551564f, 
    -0.08568392f, -0.09317806f, -0.19645722f, -0.01294498f, -0.66249758f, -0.23079012f, 0.09340930f, -0.18160810f, 
    -0.42834249f, 0.15876599f, -0.02213123f, 0.02323855f, -0.03926197f, 0.10064478f, -0.02823899f, 0.00493339f, 
    -0.00408145f, 0.13780531f, -0.03507572f, 0.04175412f, 0.01595833f, -0.09949686f, -0.07285998f, -0.09963614f, 
    -0.60509408f, -0.45712185f, -0.18236826f, -0.17295274f, -0.22748145f, 0.13915189f, 0.07392268f, 0.02965480f, 
    -0.10173559f, -0.10366653f, 0.15130207f, -0.02132955f, -0.08927246f, -0.09854383f, 0.04530046f, 0.07465424f, 
    -0.16849677f, -0.13194796f, 0.09455883f, -0.00104171f, -0.20454107f, -0.00637373f, -0.12241572f, -0.17642194f, 
    0.04186337f, 0.05540897f, 0.05850720f, -0.04027481f, 0.08299534f, 0.07906772f, 0.00223631f, -0.00927684f, 
    0.03386334f, 0.00927442f, 0.02527828f, 0.10442496f, 0.13966611f, 0.25966492f, 0.07485162f, 0.15865932f, 
    0.29520684f, 0.09496399f, -0.09392210f, 0.05300446f, -0.09636730f, -0.13580671f, -0.14019220f, 0.02352075f, 
    0.11504439f, 0.02639692f, 0.01135604f, 0.02653791f, -0.07412587f, -0.03140265f, -0.05991480f, -0.07581899f, 
    0.04839797f, 0.06401327f, -0.03045478f, -0.04109136f, -0.53937578f, 0.31769082f, -0.08236163f, -0.22165067f, 
    -0.22632869f, 0.07150547f, -0.07224923f, -0.07869097f, 0.00836952f, -0.04055712f, -0.10729765f, 0.00401479f, 
    -0.06526969f, 0.08888893f, -0.02510844f, -0.04265624f, -0.06642656f, 0.00064535f, -0.17177568f, 0.01228543f, 
    0.17984696f, -0.05678681f, -0.10256202f, -0.04285840f, -0.03896621f, 0.00277388f, -0.09341504f, 0.00136877f, 
    -0.04911989f, 0.01248669f, -0.03231410f, 0.01484217f, -0.08286414f, -0.01861658f, -0.03513508f, -0.03278394f, 
    0.08589809f, -0.00576104f, -0.10530248f, 0.12570341f, 0.25368080f, 0.10310394f, 0.14857624f, -0.05914804f, 
    -0.08352916f, 0.06663623f, -0.07074302f, 0.06055859f, 0.02034675f, -0.00949086f, -0.04301018f, -0.04448204f, 
    0.11283794f, -0.10349061f, -0.01834575f, 0.02912223f, -0.00948615f, -0.31608218f, -0.11342692f, 0.00464172f, 
    0.13151380f, 0.13231359f, 0.01597668f, 0.04691684f, 0.04785231f, 0.04978087f, -0.03169750f, 0.03270910f, 
    0.01941865f, 0.08343048f, -0.04368381f, 0.05915153f, 0.00857191f, 0.03355003f, 0.03056290f, 0.12336967f, 
    0.01633111f, -0.26373535f, -0.06937537f, 0.04774391f, -0.38220164f, -0.41493264f, -0.15952641f, -0.04600425f, 
    0.31918457f, 0.05306316f, 0.06397936f, 0.03599972f, -0.09380091f, -0.07582694f, 0.02358933f, -0.02873686f, 
    -0.14590919f, 0.02577411f, 0.02718440f, 0.01091274f, 0.08341647f, 0.10240366f, 0.08555733f, 0.09586666f, 
    0.02642808f, -0.28136122f, 0.14433613f, 0.01956966f, -0.20969656f, -0.05012334f, -0.01312442f, -0.03256963f, 
    -0.12476134f, 0.04629275f, -0.18718453f, -0.07869191f, 0.06255040f, -0.03894485f, -0.05141116f, -0.10720800f, 
    -0.03462878f, -0.18924123f, -0.11939773f, -0.04280300f, -0.03448529f, 0.00193806f, 0.14501123f, -0.02345077f, 
    -0.00463894f, -0.02624519f, 0.09291890f, -0.03818874f, 0.00540136f, 0.02734692f, -0.23157461f, -0.00055814f, 
    0.05336438f, 0.05384965f, -0.05989934f, 0.00240827f, 0.02959835f, 0.03150109f, -0.12988794f, -0.08788350f, 
    -0.42205653f, -0.33949742f, 0.09738449f, -0.09382876f, 0.06557824f, -0.10061511f, 0.07070000f, 0.03982049f, 
    0.09361988f, -0.19167392f, -0.09291596f, 0.05491438f, 0.05973933f, 0.09920914f, -0.03486126f, -0.09609961f, 
    -0.05070435f, -0.08024121f, -0.13421291f, 0.08785031f, 0.17665459f, 0.19340365f, -0.14415938f, 0.10107420f, 
    0.07613214f, 0.06583282f, -0.30022147f, 0.06255502f, 0.01042561f, 0.02084302f, -0.03222655f, 0.06608513f, 
    0.04200232f, 0.00162025f, 0.10050851f, -0.06367397f, 0.10460298f, -0.03778172f, 0.07407174f, 0.12867084f, 
    -0.39305237f, -0.07562807f, 0.07876845f, 0.04401582f, 0.12030390f, 0.00176128f, 0.06020545f, 0.01988188f, 
    0.04504054f, -0.05387222f, 0.00473881f, 0.05443982f, -0.06793538f, 0.02806245f, -0.02781143f, -0.08100525f, 
    -0.05252485f, -0.03171345f, 0.01253114f, -0.10439558f, 0.18605390f, -0.04221657f, 0.00891895f, -0.03517267f, 
    0.07811527f, -0.01026790f, -0.06704040f, -0.06973530f, -0.04985460f, -0.17018512f, -0.07234132f, -0.02542250f, 
    0.00738578f, 0.06045391f, -0.04250051f, -0.03894436f, -0.04043249f, 0.01561374f, -0.01272752f, -0.05729851f, 
    0.02981913f, 0.04540104f, -0.22646660f, -0.03450502f, 0.42763671f, 0.13070408f, -0.16793282f, 0.02851649f, 
    0.11584295f, 0.04575644f, -0.03890305f, -0.05554390f, -0.02214991f, 0.01440261f, 0.12361594f, 0.01275508f, 
    -0.01270722f, 0.11058491f, -0.08770332f, 0.04037290f, 0.30683106f, 0.09881116f, -0.17681468f, 0.07810218f, 
    -0.06505215f, 0.13846055f, 0.01573905f, -0.05812980f, -0.05291085f, 0.01994426f, -0.02444970f, 0.11278510f, 
    -0.01538973f, 0.05045812f, 0.06771395f, -0.07587553f, 0.04977398f, 0.08771472f, -0.07254116f, 0.05784283f, 
    0.09794270f, 0.12482882f, -0.15753637f, -0.32212290f, -0.04274223f, -0.29230085f, -0.13086499f, 0.05912485f, 
    -0.15325980f, -0.20741548f, 0.00196822f, -0.04788502f, 0.01608879f, 0.00237761f, -0.00742858f, 0.15401775f, 
    -0.07371396f, -0.02683516f, 0.10806362f, 0.00981992f, -0.05763185f, 0.18591438f, -0.03950724f, -0.07460552f, 
    0.05020360f, 0.07654878f, -0.02223280f, -0.02073186f, -0.15579589f, -0.04931430f, -0.07683506f, 0.08819585f, 
    0.04241632f, -0.11675481f, 0.04364441f, -0.05923601f, -0.02841320f, -0.12906729f, 0.12038804f, 0.05060677f, 
    -0.46968904f, -0.51270247f, -0.21055362f, -0.18338542f, -0.14251365f, 0.03190340f, 0.03139315f, 0.09513459f, 
    0.01879287f, 0.15597457f, -0.14838627f, 0.00083444f, -0.03774724f, -0.00815401f, 0.01738349f, 0.00100652f, 
    -0.01504324f, -0.09054364f, -0.09959594f, -0.08157608f, 0.18025230f, -0.16385350f, 0.03843549f, 0.09025384f, 
    0.03831410f, 0.05165534f, 0.04508057f, -0.02462798f, 0.03570633f, 0.05801573f, 0.01590243f, 0.05118242f, 
    0.02924659f, -0.02088210f, -0.01105945f, 0.04712999f, -0.03870924f, -0.00901733f, 0.11903839f, -0.03003834f, 
    0.23522192f, -0.31346434f, -0.14826842f, -0.10918849f, -0.04912289f, 0.02011805f, 0.03999214f, 0.01247800f, 
    -0.01929975f, 0.04576102f, 0.10219420f, -0.04885392f, -0.11982417f, -0.04439740f, 0.06253638f, 0.04733391f, 
    0.02565083f, -0.07000906f, -0.00132071f, -0.06276184f, -0.05032118f, 0.00765030f, -0.12801716f, -0.25348625f, 
    -0.25513601f, 0.10875818f, 0.01070165f, -0.07053472f, 0.01844267f, 0.08369183f, 0.03071974f, -0.01038546f, 
    0.01176194f, -0.04450689f, -0.07009033f, -0.01579878f, 0.01739561f, 0.02207930f, -0.06672408f, 0.05253660f, 
    -0.53229839f, 0.17071243f, -0.08941378f, -0.06075536f, -0.03234781f, -0.07415435f, -0.02926046f, -0.04632641f, 
    0.05903114f, -0.00049213f, 0.04040155f, -0.03347277f, 0.05281761f, -0.03431331f, 0.04390350f, 0.02019838f, 
    0.05281653f, -0.06284588f, -0.02844667f, 0.01125728f, -0.09742985f, -0.24229629f, 0.04236313f, 0.04325855f, 
    -0.24894844f, 0.18868424f, 0.01778904f, 0.06077477f, 0.07496005f, 0.12621017f, -0.08533356f, -0.03161715f, 
    0.00086713f, -0.01238230f, 0.07928369f, -0.20084018f, 0.08130693f, -0.05132871f, -0.03267115f, -0.12663023f, 
    0.09296471f, -0.12217049f, -0.23685603f, 0.10063986f, -0.28066516f, -0.14475501f, -0.02232850f, -0.02890762f, 
    0.05517126f, -0.03148657f, -0.01340234f, 0.01309842f, 0.01464739f, 0.06980573f, -0.00667419f, 0.13014379f, 
    0.13257140f, 0.08930982f, -0.00949668f, -0.11064244f, -0.32404339f, 0.05446405f, 0.11641601f, -0.05471565f, 
    -0.06013401f, -0.02106740f, 0.00688908f, -0.02300981f, -0.05643437f, 0.03982887f, -0.06073945f, -0.00796991f, 
    0.04943430f, -0.02478793f, -0.05687269f, -0.03637515f, -0.12914222f, -0.03015197f, -0.02672405f, 0.02677580f, 
    0.60340273f, 0.15432325f, -0.28826615f, -0.03770472f, -0.07488638f, 0.00660331f, 0.03473248f, 0.05642441f, 
    0.03094436f, 0.10571222f, 0.14445530f, 0.14223261f, -0.09563067f, -0.06546535f, 0.09958255f, 0.04286173f, 
    -0.14404656f, 0.01206583f, -0.01663836f, 0.08086941f, -0.51284319f, 0.34346199f, -0.09501825f, 0.06520426f, 
    -0.00523335f, -0.02086398f, 0.04951019f, 0.02485406f, -0.03393706f, -0.06491452f, -0.02144374f, 0.06398887f, 
    -0.02642063f, -0.00401464f, 0.11196986f, 0.00023972f, 0.09135231f, 0.04252801f, -0.07545061f, 0.00839619f, 
    0.38013810f, -0.11359185f, -0.29382920f, 0.25690430f, -0.13707626f, 0.06548978f, 0.06140016f, -0.01667076f, 
    0.02839850f, -0.02951386f, 0.11769288f, 0.01967914f, -0.03712340f, 0.14634328f, 0.05516099f, 0.08359732f, 
    0.05770076f, -0.04602936f, 0.03034315f, 0.04998721f, 0.07921463f, 0.13313243f, -0.20135826f, -0.05512151f, 
    0.05341889f, -0.05564151f, -0.02013315f, -0.02440773f, 0.05012320f, -0.05708195f, 0.21949302f, 0.05206502f, 
    -0.08715320f, 0.03930544f, -0.07672562f, 0.06181224f, -0.05365549f, 0.06720629f, 0.04910909f, -0.01081847f, 
    0.08630915f, -0.06665204f, -0.10701080f, 0.09489169f, 0.16482766f, -0.11934473f, 0.15957381f, -0.00787904f, 
    0.07441980f, -0.23647615f, 0.07199278f, -0.03172693f, -0.23808028f, 0.07724735f, -0.05252609f, 0.10472924f, 
    0.06633559f, -0.06987379f, 0.11616182f, 0.05222921f, 0.54577136f, 0.01978640f, -0.24651319f, -0.13818972f, 
    0.10054088f, 0.01242688f, -0.05478060f, -0.06371046f, -0.01575003f, 0.01117146f, 0.12501864f, 0.00673540f, 
    0.03246660f, 0.09232100f, -0.02862635f, 0.13691537f, 0.04134560f, -0.02140035f, 0.00760260f, -0.00294554f, 
    0.17861935f, -0.22169393f, -0.24090472f, 0.03664844f, -0.24150544f, 0.09147506f, 0.01980675f, -0.04913079f, 
    0.00811129f, -0.03060213f, 0.02593033f, -0.03391970f, 0.06831559f, -0.03208331f, -0.04141655f, -0.01502891f, 
    0.03482865f, -0.11222699f, -0.08280794f, -0.02782142f, -0.25575492f, 0.14585459f, -0.07025441f, 0.01441743f, 
    0.10403040f, 0.00460814f, 0.02389522f, 0.06799062f, -0.01468174f, 0.20245285f, -0.02491448f, 0.05144861f, 
    0.00277663f, -0.03256634f, -0.01788468f, -0.01544621f, -0.03383267f, -0.11109975f, -0.04103208f, -0.06352825f, 
    -0.06904098f, -0.07277239f, 0.01232001f, -0.02471134f, 0.03826359f, -0.02253838f, 0.05721725f, 0.06823720f, 
    0.03383327f, -0.05319273f, -0.12200454f, -0.08430333f, 0.02053348f, 0.01852555f, -0.10412259f, -0.08142658f, 
    -0.09607562f, -0.00024788f, -0.08769345f, -0.07335758f, 0.50097400f, 0.01160622f, -0.22616404f, -0.18192728f, 
    -0.00469433f, -0.07888122f, 0.06989340f, 0.02134372f, 0.10996442f, 0.00973496f, 0.11292215f, -0.10945348f, 
    -0.01293666f, 0.05003928f, 0.10200036f, -0.01113567f, -0.04964038f, -0.06766369f, 0.05147229f, 0.00813884f, 
    -0.37997946f, 0.39147666f, -0.08686908f, -0.02833347f, 0.05193831f, 0.07709906f, -0.10242566f, 0.11334336f, 
    -0.00886534f, -0.00699521f, 0.02349216f, -0.03196165f, 0.13073015f, -0.11821438f, 0.09080261f, -0.03761376f, 
    -0.00021318f, 0.01734315f, -0.04856569f, -0.16479816f, -0.12687895f, -0.09185371f, -0.21634921f, -0.14776343f, 
    0.31486854f, -0.01625859f, -0.11941036f, -0.03570295f, 0.01746905f, 0.01014413f, -0.04605572f, -0.02117896f, 
    0.02051934f, -0.01751858f, 0.02120367f, 0.23503336f, -0.02361259f, 0.09083899f, 0.12343134f, 0.00275918f, 
    -0.07238498f, 0.06278802f, -0.01251137f, 0.10436039f, -0.11323448f, -0.10709029f, 0.05091986f, -0.05609308f, 
    0.01292137f, -0.14215216f, 0.14554749f, -0.02884540f, 0.01174617f, -0.06561513f, -0.09408238f, 0.12084834f, 
    -0.03040274f, 0.10554357f, -0.03323536f, -0.03685419f, -0.11786020f, 0.14389826f, -0.01839415f, 0.12052025f, 
    0.10914179f, 0.30345425f, 0.09431350f, 0.02031666f, -0.04513205f, 0.09176019f, -0.06451426f, 0.02760530f, 
    0.13388519f, 0.05528237f, -0.08809924f, -0.09426578f, -0.03034912f, -0.18985723f, -0.03314159f, 0.10978448f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02919816f, 0.01590117f, -0.07143898f, -0.02126370f, 0.02598842f, 0.01752287f, -0.03248330f, -0.06286447f, 
    -0.00964912f, 0.03060051f, 0.07753070f, 0.01326398f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
