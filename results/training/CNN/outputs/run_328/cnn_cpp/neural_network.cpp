#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.46981025f, 0.04544791f, -0.22391325f, -1.81673455f, -0.30962506f, -0.46023640f, 0.54934883f, 0.57922608f, 
    -0.05561614f, 1.61101532f, -0.64631903f, -1.63427627f, -0.43034625f, 0.26395237f, 0.65968198f, -0.43759412f, 
    -0.24515510f, 0.29942691f, 1.47352445f, -0.11231940f, 1.07116997f, 0.76343608f, 0.74114692f, 1.11643136f, 
    -0.36896440f, 0.01494516f, -0.65303171f, 1.23105574f, 0.87078780f, 0.66702902f, -1.27986133f, -1.15177751f, 
    -0.59265029f, 0.68858790f, 0.11421669f, -0.42454627f, 0.82116896f, 2.06538486f, 0.06791739f, 0.92782313f, 
    0.18779935f, -0.43980861f, 0.50918615f, 0.15664010f, 0.09830128f, -1.74625528f, 1.65424895f, 0.66704148f, 
    0.58199835f, 0.32963359f, 0.69059581f, -0.68117750f, -0.10274548f, -0.14894199f, -0.55275655f, 0.50291288f, 
    1.72757208f, 1.04221547f, -0.53481257f, 0.44524607f, 0.27999815f, 0.55456662f, 0.43879858f, 1.31604636f, 
    0.92924362f, 0.79478717f, -1.16456676f, 0.40339682f, -0.82061386f, -0.00868749f, 0.62299877f, -0.23609066f, 
    0.37931025f, 1.30165088f, 1.09711528f, -0.50013947f, -0.69982928f, 1.04743052f, -0.20962046f, 0.06753664f, 
    -0.73693204f, -0.96807933f, -1.71760154f, 1.26367295f, 0.78609502f, 0.39355168f, 1.04966164f, -0.30649227f, 
    -0.24470393f, -0.19019486f, 1.42884505f, 0.55599296f, 0.72241724f, -0.72408479f, -0.37384275f, 0.71903110f, 
    -0.23341842f, 0.27686787f, 0.98631626f, -1.21996844f, -1.12847710f, -1.13083744f, 0.64710653f, -0.81985211f, 
    -0.02138447f, 0.28284156f, -0.29762107f, 0.73081160f, -0.82948864f, -1.94223583f, -0.99781483f, 0.63547367f, 
    1.79003763f, 0.76998121f, -0.09738225f, 0.09958717f, -0.18438005f, 0.25784993f, -0.70839536f, -1.38370383f, 
    0.11422905f, -1.63163745f, 0.15745445f, 0.64488536f, -0.14941384f, -0.59379613f, -0.91381860f, 1.21102226f, 
    -1.32233965f, -0.61109835f, -0.71825528f, -0.79760301f, -0.59918535f, -0.52792412f, -0.77213252f, -0.84873271f, 
    1.16145885f, 1.49275768f, -1.11228883f, 1.50304806f, -0.39162013f, -0.35523725f, 0.42458257f, 0.06757807f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.44567916f, 0.01520508f, 0.27918303f, 0.25560805f, 0.37376839f, 0.27349728f, 0.02810561f, 0.09929383f, 
    0.24190760f, 0.23189485f, 0.04823153f, 0.28464079f, 0.61037749f, 0.23279396f, 0.17533019f, 0.23706083f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.64707071f, -0.47109479f, -0.30760762f, 0.30363512f, -0.15359889f, -0.01970145f, -0.17773402f, -0.00744543f, 
    -0.05227628f, 0.03385565f, -0.01012219f, -0.04778182f, 0.00783004f, -0.20469846f, -0.06893650f, -0.10777701f, 
    0.06461438f, 0.00381208f, -0.03008916f, -0.26530901f, -0.03841233f, -0.05860509f, -0.05086940f, 0.16303670f, 
    0.07618725f, -0.11411451f, 0.05865442f, -0.00550491f, -0.02966072f, -0.10032644f, -0.25805035f, 0.00879574f, 
    0.19058022f, -0.03374327f, -0.10579280f, -0.09890547f, 0.02136803f, -0.09737518f, -0.05062714f, -0.09870628f, 
    0.46872699f, 0.09998316f, -0.09972249f, -0.03585429f, 0.02167404f, -0.12886512f, -0.16955601f, 0.16135232f, 
    -0.04973095f, -0.12750643f, -0.10071647f, 0.03076806f, -0.04702258f, -0.07914986f, 0.00984708f, 0.09908682f, 
    0.00083261f, 0.07154725f, -0.00567542f, 0.09271275f, 0.25028169f, 0.08240047f, 0.12415192f, -0.00976892f, 
    0.17268692f, -0.16309603f, -0.13310595f, 0.01660405f, 0.02898839f, 0.03363652f, -0.01241666f, -0.03151556f, 
    -0.03480275f, -0.05490085f, 0.02853187f, 0.03464028f, -0.00849152f, 0.01836170f, 0.14570341f, 0.03720161f, 
    0.14458804f, 0.19151206f, 0.02316583f, -0.35790974f, 0.36623663f, -0.22866234f, 0.02416798f, 0.19101067f, 
    -0.00237051f, -0.07101296f, 0.12599763f, 0.06360836f, -0.17092112f, 0.05591433f, -0.10384335f, -0.00104337f, 
    0.08415178f, 0.10926660f, -0.20463511f, 0.00748747f, 0.23400505f, 0.16324252f, 0.35113707f, 0.19010395f, 
    0.41629088f, 0.00060758f, -0.16566464f, 0.08561975f, -0.06620597f, -0.08248319f, 0.08374205f, -0.06171914f, 
    -0.08984087f, -0.09718306f, 0.10464490f, 0.11336639f, -0.16972527f, 0.01841810f, -0.12618373f, 0.11003289f, 
    -1.25537312f, -0.18105021f, 0.30011234f, 0.06287710f, -0.03040181f, -0.05869038f, -0.16372643f, 0.08510813f, 
    -0.34588039f, 0.11664912f, 0.09091178f, -0.04434649f, 0.10273002f, -0.08969678f, 0.09039509f, -0.26640469f, 
    -0.13824119f, -0.09973882f, -0.06350256f, 0.04666450f, 0.20566975f, 0.07750560f, -0.12755713f, -0.17609814f, 
    0.16857532f, -0.07231913f, -0.02552036f, -0.23410237f, 0.16703951f, 0.16212377f, -0.07852125f, -0.02766101f, 
    -0.00664983f, -0.10318752f, 0.08382463f, -0.00633029f, -0.01587900f, 0.03381501f, 0.08097743f, -0.10616220f, 
    -0.04049056f, 0.39969307f, 0.00284495f, 0.05221583f, 0.44067925f, -0.17026906f, -0.11527538f, -0.15519182f, 
    0.11155206f, 0.06092041f, -0.09092835f, -0.22673187f, 0.00282806f, -0.03210225f, 0.01865407f, 0.11681074f, 
    0.09620967f, -0.34303960f, -0.04883889f, 0.15073676f, -0.51066303f, 0.29106814f, 0.30725864f, 0.12595914f, 
    -0.57520306f, -0.02006579f, 0.14430299f, 0.12950474f, 0.19117154f, -0.18814674f, 0.02414954f, 0.01821294f, 
    -0.19538313f, -0.08619144f, -0.04886786f, 0.07051712f, 0.19865529f, -0.04627500f, 0.11397994f, 0.12618963f, 
    0.39416805f, 0.12370723f, -0.29913095f, -0.32238087f, -0.05706027f, 0.12329029f, -0.17915069f, -0.19585176f, 
    0.20218384f, -0.11708478f, -0.10480130f, -0.01791878f, 0.10157687f, 0.00266035f, 0.05256304f, -0.11640377f, 
    0.02306351f, -0.02354064f, 0.01533624f, 0.10367670f, 0.12025909f, -0.51278824f, -0.14781713f, 0.02619702f, 
    -0.40883854f, 0.06304105f, 0.05917005f, -0.15193176f, 0.20363647f, -0.04160319f, 0.06880648f, 0.08636419f, 
    -0.06972825f, 0.05721707f, 0.09066579f, 0.08643901f, -0.05272555f, 0.11824192f, -0.10849675f, -0.09240309f, 
    -0.21109274f, 0.45334345f, 0.10060830f, -0.39079678f, -0.51817971f, 0.13175680f, -0.00581588f, -0.05882086f, 
    0.06033840f, -0.09289192f, 0.04482722f, 0.02075630f, -0.04363477f, 0.08252358f, -0.04612886f, 0.10273159f, 
    0.00777775f, 0.10818188f, -0.01028017f, 0.01473943f, 0.44305369f, -1.04131567f, 0.19904104f, 0.26207715f, 
    -0.22965208f, -0.06703414f, -0.07229589f, -0.04829744f, 0.02274453f, -0.02599790f, -0.05095254f, -0.27627999f, 
    0.12886862f, -0.04306246f, 0.03964823f, -0.11431780f, -0.18409705f, 0.11213429f, 0.09251177f, 0.02104284f, 
    0.19447227f, -0.27920485f, 0.27549255f, 0.00881210f, 0.11367752f, -0.01405191f, -0.18101905f, 0.08968326f, 
    -0.12958221f, 0.09259539f, 0.02061901f, 0.06183667f, 0.06882814f, -0.00806290f, -0.04083589f, -0.01958837f, 
    0.06408755f, 0.13176340f, 0.00637401f, -0.13624199f, -0.28094643f, 0.03731702f, 0.08742884f, -0.00445284f, 
    0.08561534f, -0.10800454f, -0.00735033f, 0.01845471f, 0.04572197f, 0.05884903f, -0.04858080f, 0.05454767f, 
    0.17718354f, 0.01764878f, -0.02133702f, -0.12260031f, -0.08552792f, 0.04760513f, -0.03210865f, -0.20399354f, 
    -0.11262138f, -0.03810918f, -0.35763237f, -0.15395823f, -0.16519333f, 0.12944946f, 0.00507718f, -0.05367384f, 
    0.19082175f, 0.14394571f, -0.09242743f, -0.07533681f, 0.14134230f, 0.17304778f, -0.03520112f, -0.01849783f, 
    -0.00343842f, -0.10079116f, -0.22546336f, -0.22886944f, 0.36276668f, -1.26252699f, 0.22752081f, -0.42805460f, 
    -0.13853942f, -0.15775017f, -0.08668298f, -0.13652150f, -0.02213486f, -0.15247034f, -0.08109350f, 0.01755454f, 
    -0.21449782f, 0.04575595f, -0.01356153f, -0.11056060f, -0.09005819f, -0.02683515f, 0.05570428f, -0.10366812f, 
    0.49771658f, 0.06519596f, 0.20619957f, 0.17665780f, 0.15105163f, 0.00374068f, -0.10391615f, 0.03933090f, 
    0.05878392f, 0.22938824f, 0.10938976f, 0.12122253f, -0.07552587f, -0.15768407f, -0.21948494f, -0.05803840f, 
    0.05519148f, 0.10459682f, 0.12469383f, 0.12064619f, -0.02359345f, -0.08716815f, -0.25132224f, 0.02825939f, 
    -0.16894853f, 0.07093226f, -0.10516524f, 0.07590038f, 0.06304239f, -0.05802047f, 0.04812218f, 0.07244102f, 
    0.08028493f, 0.17804997f, -0.03128677f, -0.01558240f, -0.00414140f, -0.21334875f, -0.09165239f, 0.01368950f, 
    0.00238540f, -0.05632110f, 0.30520022f, 0.05248366f, 0.32622668f, -0.13384059f, -0.13506414f, 0.05383794f, 
    -0.03977714f, 0.05653892f, -0.07537512f, -0.01074447f, 0.00766625f, 0.07547691f, 0.07755005f, -0.14964566f, 
    -0.06922477f, -0.20482039f, 0.11057205f, -0.00769714f, -0.28583336f, 0.01768894f, -0.38865203f, -0.09258910f, 
    0.07430167f, -0.04462066f, 0.10496471f, -0.02287984f, -0.13544257f, -0.14621001f, 0.08337948f, 0.08983500f, 
    0.11982454f, -0.05108133f, 0.00276670f, 0.03901171f, -0.17343152f, 0.01025699f, 0.02292437f, -0.07968741f, 
    0.18485834f, 0.26596799f, 0.00536708f, -0.16379668f, -0.00307214f, -0.26957008f, 0.00639046f, 0.02616675f, 
    -0.11002281f, 0.14578301f, -0.00402529f, 0.10422247f, -0.02365847f, -0.13711639f, 0.05783572f, 0.00400050f, 
    -0.10376373f, 0.01553276f, 0.03480040f, 0.24236372f, 0.28325149f, -0.07570056f, -0.10994231f, 0.21214606f, 
    0.05765830f, 0.07151216f, -0.14065409f, 0.06895860f, -0.01225920f, 0.04248724f, 0.17274328f, 0.06671820f, 
    -0.06763662f, 0.20242012f, -0.08181074f, 0.00405547f, 0.16009013f, -0.03200634f, -0.09489725f, 0.07291014f, 
    0.05749062f, 0.24578151f, -0.05852632f, 0.11651459f, 0.11696418f, -0.03165979f, -0.07647367f, 0.07536954f, 
    -0.00795093f, 0.03902269f, -0.11981456f, -0.12628473f, -0.12758201f, 0.09553513f, -0.00319899f, -0.03108585f, 
    -0.06940779f, 0.15042886f, -0.05147445f, -0.02592427f, -0.23408224f, 0.15091388f, -0.20443046f, 0.07301987f, 
    -0.47522321f, -0.09541243f, 0.13101439f, -0.05623695f, -0.21881640f, 0.24819906f, -0.02303567f, 0.14093602f, 
    -0.12845670f, 0.02526044f, 0.03763591f, 0.03069200f, -0.01726706f, 0.10952091f, -0.12302051f, 0.01659653f, 
    0.17355956f, 0.13837190f, 0.00170958f, 0.11044037f, -0.06687474f, -0.01942868f, -0.12791219f, -0.05655628f, 
    0.00218182f, -0.02337565f, 0.03213163f, -0.10721833f, -0.11554531f, 0.01391857f, 0.02365019f, 0.23066419f, 
    -0.07204072f, 0.06207174f, -0.04853522f, -0.19185857f, 0.11561628f, 0.39500591f, 0.03851911f, 0.15139802f, 
    -0.04936866f, 0.25494593f, -0.10921036f, 0.35722148f, -0.05229633f, 0.14902651f, 0.05870812f, -0.12832098f, 
    0.07839976f, 0.08816752f, -0.07639885f, -0.05548942f, 0.29030779f, -0.26118833f, 0.07076452f, -0.00056780f, 
    0.48752934f, -0.19402026f, -0.26730669f, 0.03435163f, -0.27101329f, -0.16370183f, 0.11553615f, -0.08802621f, 
    -0.03275891f, 0.06699336f, 0.02033560f, 0.01703687f, -0.05061661f, -0.02569274f, 0.04216819f, 0.20618270f, 
    0.09784887f, -0.06523761f, -0.06194815f, 0.00408009f, -0.34415081f, 0.20449764f, 0.04156737f, -0.16110514f, 
    -0.00498584f, 0.03659112f, 0.08923499f, 0.23716375f, 0.16807649f, 0.22650629f, 0.12198176f, -0.02855301f, 
    0.11078511f, 0.12049101f, 0.08244627f, -0.01783967f, -0.02880915f, -0.24330077f, -0.09812534f, -0.05187666f, 
    -0.31427440f, -0.11690979f, -0.45817083f, -0.96948218f, 0.08231191f, 0.03194329f, -0.13105689f, 0.00668431f, 
    -0.01260795f, -0.07595515f, 0.05023515f, -0.16101414f, -0.01228548f, -0.14888664f, 0.00664857f, -0.13431577f, 
    -0.04225308f, -0.16358125f, 0.02465761f, -0.31887284f, -0.38646600f, 0.34764203f, -0.18404076f, -0.31818262f, 
    0.38193861f, -0.20973091f, 0.14433871f, -0.00061266f, -0.08778665f, 0.10639504f, 0.05635912f, -0.21276291f, 
    0.06815170f, 0.12790322f, -0.29766256f, -0.04840992f, 0.06205882f, 0.11211757f, -0.16649348f, 0.17391908f, 
    0.59109765f, -0.02900110f, -0.21021020f, -0.48537263f, -0.52221990f, 0.07595467f, 0.21680801f, -0.03447452f, 
    -0.08898052f, 0.09702545f, -0.01598535f, -0.13250765f, -0.04598698f, -0.17476583f, -0.19757505f, 0.00654502f, 
    -0.00803587f, -0.10785681f, 0.02941694f, -0.05314606f, 0.35766909f, -0.22635078f, -0.25880602f, 0.31972614f, 
    -0.58706576f, 0.04492489f, -0.23084714f, 0.21900789f, 0.28269815f, 0.33992392f, 0.04426838f, -0.16027726f, 
    -0.16688697f, 0.20285617f, -0.02613085f, 0.04320189f, 0.01705322f, 0.08975112f, 0.19041766f, 0.01178193f, 
    -0.63611388f, 0.18297873f, 0.10668306f, -0.25562313f, 0.20713598f, 0.17269428f, -0.19827826f, 0.02030443f, 
    0.10901315f, -0.04977880f, -0.21187262f, 0.05183489f, 0.09990247f, -0.03512460f, 0.01031894f, -0.08705853f, 
    -0.15014407f, -0.08268902f, -0.10198591f, 0.01619219f, -0.22839443f, 0.18616466f, -0.21211396f, -0.07938655f, 
    0.05267844f, 0.02205630f, 0.08727959f, 0.21203309f, -0.06758601f, -0.15527453f, -0.02391471f, 0.01734671f, 
    -0.07975180f, 0.00524720f, -0.09983541f, 0.03012123f, 0.13027421f, 0.05029177f, -0.06007619f, -0.06916485f, 
    0.20307815f, -0.31308144f, 0.17936651f, -0.21110682f, 0.01800200f, 0.19626909f, -0.00126024f, 0.27000254f, 
    -0.19163676f, 0.04039855f, 0.00534481f, 0.14306660f, 0.03438314f, -0.01983391f, -0.06881379f, 0.06083523f, 
    -0.16910253f, 0.11763743f, -0.21632697f, -0.01616334f, 0.46017560f, 0.10698147f, -0.28612518f, 0.00583641f, 
    -0.10263057f, -0.04830091f, 0.01256590f, 0.06090301f, 0.02912358f, 0.22514243f, -0.10745855f, 0.11190634f, 
    -0.03850067f, 0.16525406f, -0.03233643f, 0.00685320f, -0.00090182f, -0.04857078f, -0.11220245f, 0.07526627f, 
    0.42670941f, 0.29501632f, -0.07706530f, 0.18523212f, -0.03688810f, -0.36841744f, 0.22288021f, -0.00667736f, 
    -0.05542894f, -0.13951413f, -0.18994300f, 0.10017330f, 0.00041345f, 0.11105405f, 0.13178076f, 0.09001651f, 
    0.04083094f, 0.02368098f, 0.11474128f, 0.10765899f, -0.00892513f, 0.36520654f, -0.17404787f, -0.40740299f, 
    0.02868589f, 0.09788667f, 0.09755386f, 0.06354283f, -0.09137931f, -0.07020689f, 0.01810305f, 0.05783949f, 
    -0.06372456f, -0.23890355f, -0.04053277f, 0.07323835f, 0.08811438f, -0.09466508f, -0.13527402f, 0.07460486f, 
    -0.26870248f, 0.07054686f, -0.22420542f, 0.05142000f, 0.02575889f, 0.03659809f, 0.15509968f, 0.21493950f, 
    0.13090651f, -0.07408357f, -0.01151910f, 0.03971945f, 0.05341724f, -0.00755453f, -0.05342313f, -0.08901310f, 
    0.06656341f, -0.10205159f, -0.26502284f, -0.07894680f, 0.18922803f, -0.02087605f, -0.04631826f, 0.06615746f, 
    0.11348978f, -0.32329944f, -0.16758072f, -0.01196830f, 0.11539702f, -0.14883661f, 0.12340567f, -0.03728590f, 
    -0.04119957f, -0.17620634f, 0.15138839f, -0.05559697f, -0.10254090f, -0.13461803f, 0.12353895f, 0.01571871f, 
    -0.39119592f, 0.27589744f, -0.11097981f, -0.06581381f, -0.15088198f, -0.04425370f, 0.10774980f, 0.18984987f, 
    0.01985039f, -0.04750971f, -0.10575766f, 0.14062147f, -0.03081899f, 0.04960019f, -0.16495834f, -0.14938612f, 
    -0.05119797f, -0.00918402f, 0.03875258f, 0.01486966f, -0.14957657f, 0.10460839f, 0.13523448f, 0.14275037f, 
    0.23386550f, -0.22405367f, -0.09732426f, -0.42556149f, 0.05504785f, 0.09889714f, 0.05512799f, -0.03878560f, 
    -0.02260981f, -0.02174919f, 0.01808947f, 0.08179132f, 0.00280885f, 0.09704541f, 0.00644112f, 0.03192366f, 
    0.43296123f, -0.26266932f, 0.50160772f, 0.09107984f, 0.39463264f, -0.09440525f, -0.19610544f, -0.22377159f, 
    0.06235235f, -0.01586092f, 0.09686848f, -0.15493336f, -0.08425643f, 0.08606938f, -0.00019764f, -0.12584850f, 
    -0.22916877f, 0.05230382f, -0.03876098f, -0.09516279f, -0.48065811f, -0.35356897f, -0.08542858f, 0.24566409f, 
    -0.48367751f, -0.02682181f, -0.12831947f, 0.05506865f, -0.00614376f, 0.07275546f, 0.03138946f, 0.05527771f, 
    0.10396849f, -0.06309556f, -0.02456421f, 0.06940113f, -0.09554034f, 0.07154739f, -0.17105512f, -0.13518083f, 
    -0.58689427f, -0.36271423f, -0.48532134f, -0.11990381f, -0.58368987f, 0.16992947f, 0.04671352f, 0.16102773f, 
    -0.23420063f, -0.05062118f, -0.15861177f, -0.02343562f, -0.11669822f, -0.04167410f, -0.05221513f, -0.01689375f, 
    -0.07451924f, 0.16598456f, -0.01155078f, 0.00184188f, 0.46651024f, 0.17730609f, -0.48474762f, -0.07337283f, 
    -0.19721991f, 0.00505351f, -0.04403364f, 0.16328089f, -0.16392207f, -0.18330409f, 0.03564718f, -0.04963866f, 
    0.00535152f, -0.12552588f, 0.02240726f, 0.02584625f, -0.09499999f, -0.22059301f, 0.03509705f, -0.10177563f, 
    -0.57215357f, 0.56835586f, 0.20265517f, 0.23130834f, 0.00255628f, 0.07424167f, 0.05623259f, -0.05320759f, 
    -0.01300578f, 0.13938774f, -0.02549112f, -0.18974803f, -0.01443784f, -0.02235775f, -0.11358358f, -0.03030632f, 
    0.10630950f, 0.07573049f, 0.17552269f, -0.03364781f, 0.17228781f, 0.07882807f, 0.26169825f, 0.20242783f, 
    -0.01694691f, -0.13374674f, -0.08946881f, -0.03300645f, 0.04754244f, 0.18445131f, -0.09281241f, -0.03002011f, 
    -0.03921778f, -0.06093672f, 0.04948711f, -0.03939187f, -0.13127495f, -0.00530840f, 0.11338300f, 0.09031665f, 
    -0.69231105f, -0.67789119f, -0.31843179f, -0.37975621f, -0.42650348f, -0.21130769f, -0.00287491f, -0.02857661f, 
    0.02441304f, -0.16417614f, -0.15808155f, -0.07610688f, 0.06910798f, -0.02191446f, 0.13409521f, 0.03712590f, 
    -0.02860275f, -0.00049606f, -0.08468772f, 0.12860119f, -0.17248008f, -0.17597082f, -0.27853626f, 0.27023980f, 
    0.33335650f, 0.02079148f, 0.16394867f, 0.03767934f, 0.06105481f, 0.06462169f, 0.12786347f, -0.02896357f, 
    0.05814167f, -0.31585702f, -0.05142941f, -0.04696844f, 0.04199362f, -0.03282925f, 0.10022335f, -0.13576318f, 
    0.46443015f, -0.43914789f, -0.16812661f, 0.11977821f, -0.11591804f, -0.20205787f, -0.06786157f, 0.00885244f, 
    0.08892462f, -0.00167112f, -0.13706984f, -0.04440913f, -0.09013645f, 0.06284497f, -0.04863185f, -0.18182629f, 
    0.08909066f, 0.07790799f, 0.09931113f, -0.01907190f, -0.03963913f, 0.04294483f, -0.11207429f, -0.21003547f, 
    -0.16627225f, -0.02464927f, -0.10211008f, -0.11303303f, 0.21501189f, 0.04347615f, 0.08174866f, -0.12029725f, 
    -0.08184320f, 0.06785094f, -0.04126749f, -0.05964218f, 0.07495768f, -0.13876465f, 0.07703303f, 0.12380584f, 
    -0.26721787f, -0.64217442f, -0.05387336f, 0.01142968f, -0.02753360f, 0.19883251f, -0.08830095f, 0.19162440f, 
    0.12074120f, -0.20723736f, 0.07398170f, 0.17977069f, -0.02769756f, -0.17366248f, -0.11561815f, 0.01143281f, 
    -0.06099951f, -0.03051941f, 0.01874368f, -0.08118640f, -0.67905837f, 0.27979165f, -0.28873676f, 0.22792107f, 
    0.44919670f, -0.01992849f, 0.16509447f, 0.01850074f, 0.04576771f, 0.04755292f, 0.06210214f, 0.02466349f, 
    -0.00032041f, -0.28985339f, 0.09043234f, -0.03665687f, 0.06310527f, -0.05389141f, 0.13577709f, 0.06132798f, 
    -0.36352012f, -1.08764052f, -0.36025244f, 0.26557830f, 0.27148616f, -0.03210942f, 0.12896267f, 0.09822786f, 
    -0.09120199f, -0.16091497f, -0.08154082f, 0.03569122f, -0.10147715f, 0.09737211f, 0.15971979f, -0.02752626f, 
    -0.10461951f, -0.08110090f, -0.00473298f, -0.03239396f, 0.52921325f, -0.34583604f, 0.21722053f, -0.27569503f, 
    -0.21308799f, -0.13563791f, -0.17065895f, -0.10744957f, 0.02330259f, -0.02683454f, 0.07631545f, -0.06846647f, 
    -0.00536362f, -0.07847507f, -0.00097759f, -0.02913730f, 0.10327686f, 0.06026414f, 0.12393161f, 0.03140569f, 
    0.20665058f, -0.43307132f, -0.09658998f, 0.08433267f, 0.12002671f, 0.03036305f, -0.05381781f, 0.16618830f, 
    0.05413919f, -0.17981414f, 0.04301503f, 0.09464777f, -0.12300816f, 0.02300218f, -0.05088771f, 0.09343346f, 
    -0.04636443f, 0.14214776f, -0.03330295f, -0.12440370f, 0.30705547f, 0.18362668f, -0.35654214f, -0.02179995f, 
    -0.19754036f, -0.21283048f, -0.19824676f, -0.08946958f, 0.04663501f, -0.14718308f, -0.04047085f, 0.04906170f, 
    0.04691256f, 0.02918189f, 0.13246468f, -0.12575208f, -0.09234387f, 0.11789102f, -0.14000806f, 0.08836643f, 
    0.08179643f, -0.09010652f, -0.15075909f, -0.18931127f, -0.32237032f, -0.05530661f, -0.27866176f, 0.00678564f, 
    -0.17042466f, 0.02555166f, -0.14642712f, 0.08289787f, -0.01286117f, 0.01949665f, 0.01792010f, 0.01818469f, 
    -0.01099631f, -0.01650542f, 0.09654699f, 0.07154313f, 0.44000164f, 0.31347716f, -0.08160063f, 0.13278060f, 
    0.08512888f, -0.01558695f, 0.14115004f, -0.04191865f, -0.16512077f, -0.14538959f, 0.02804742f, -0.03584527f, 
    -0.26666093f, -0.17019230f, 0.00888820f, -0.06408537f, 0.13295178f, -0.02924767f, 0.05163698f, -0.02694738f, 
    0.46586683f, 0.44691819f, 0.15549777f, 0.03302059f, 0.20487042f, -0.05483397f, 0.09879757f, 0.01306500f, 
    0.03674109f, 0.17155795f, -0.04491979f, -0.06636326f, -0.05101179f, -0.05787815f, -0.06352649f, 0.00733940f, 
    -0.02390278f, 0.26673236f, 0.19862767f, 0.03398739f, -0.59711266f, 0.55269057f, -0.03545858f, 0.06333444f, 
    0.20144214f, -0.04459078f, 0.18488669f, 0.03393479f, 0.05841379f, -0.08986077f, -0.09811117f, -0.04066428f, 
    0.00595900f, 0.07878148f, 0.02255087f, -0.05571101f, -0.07921103f, -0.22963567f, 0.16851473f, 0.13913508f, 
    -0.00531479f, -0.09607770f, 0.22358933f, 0.24115711f, 0.00874971f, -0.00240770f, 0.02327640f, 0.11990871f, 
    -0.00250276f, -0.04409849f, 0.09734303f, 0.01159358f, -0.10488053f, 0.06620989f, 0.12561418f, -0.12985790f, 
    -0.10104423f, 0.05526599f, -0.00753268f, -0.00014613f, 0.22253087f, 0.26339549f, -0.32809302f, -0.07070886f, 
    -0.56366628f, 0.01615535f, -0.13565518f, 0.00709509f, -0.15504004f, 0.01149488f, 0.01347882f, 0.15818803f, 
    0.00401669f, -0.05896359f, 0.03959848f, 0.15907168f, -0.10563787f, 0.06762577f, -0.02378524f, -0.20986839f, 
    -0.15763418f, 0.17627080f, 0.13900356f, -0.20687313f, -0.00647896f, 0.04518515f, 0.05894580f, -0.06162728f, 
    0.06176647f, 0.15519689f, 0.09816270f, -0.05973957f, 0.07990262f, 0.02827096f, -0.07654244f, 0.01816957f, 
    0.17417563f, -0.19410133f, -0.01633144f, 0.03565614f, -0.35682732f, -0.49323356f, 0.20502615f, 0.27765357f, 
    -0.07969928f, -0.25430533f, -0.00089454f, 0.00368274f, -0.12680352f, 0.07010482f, -0.02775917f, 0.04435982f, 
    -0.14363188f, -0.08796809f, 0.08844893f, 0.06285802f, -0.12662542f, 0.10274386f, 0.08011487f, 0.18189263f, 
    -0.33071211f, 0.05820634f, 0.00207668f, -0.02838548f, 0.01316504f, 0.04820779f, -0.14806241f, -0.07107610f, 
    0.15635939f, 0.08208041f, -0.10930111f, -0.15239263f, 0.05612032f, 0.02195328f, -0.01947841f, 0.02435153f, 
    0.07707645f, 0.00956299f, 0.03388887f, -0.02352386f, 0.64633912f, 0.20893374f, -0.21790543f, 0.05825338f, 
    0.02003766f, 0.17129716f, 0.10394788f, 0.23722899f, 0.10613224f, 0.04469325f, -0.08743732f, -0.04371215f, 
    -0.14349763f, 0.00023730f, -0.02050608f, -0.14184612f, 0.01845226f, 0.01692994f, -0.00362635f, 0.08400930f, 
    0.42895877f, 0.30300835f, -0.34244820f, -0.45781279f, 0.09370527f, 0.08299685f, -0.03253349f, -0.17841983f, 
    0.07992404f, -0.14327191f, -0.23426387f, -0.09119143f, -0.04780889f, 0.08002061f, 0.07686651f, 0.13730691f, 
    -0.09058398f, -0.20455916f, -0.03023698f, -0.15126202f, -0.24921072f, -0.33212569f, 0.33719832f, 0.20883851f, 
    -0.03961970f, -0.09488132f, -0.16051650f, 0.12312562f, -0.10515580f, -0.04137907f, 0.08414331f, 0.03075895f, 
    0.03048384f, -0.10797915f, 0.01533786f, -0.00334451f, -0.05891213f, 0.02528775f, -0.02701004f, 0.02179323f, 
    0.28201365f, -0.49448994f, 0.12548244f, -0.19642943f, -0.04867799f, -0.25993443f, -0.10308260f, 0.06314333f, 
    -0.17291440f, 0.05093968f, 0.05948371f, -0.04662070f, 0.02416612f, 0.00760536f, -0.15467632f, 0.07605940f, 
    -0.12018232f, 0.05486714f, -0.00310432f, 0.10906307f, -0.27333185f, -0.03212955f, -0.31907234f, -0.23961104f, 
    0.23647006f, -0.04039076f, 0.09361905f, -0.07906520f, 0.08836823f, -0.18599972f, 0.00448941f, -0.02351087f, 
    -0.05519895f, 0.11104314f, -0.02761488f, 0.08622150f, -0.05267001f, -0.17157081f, 0.03007957f, -0.07092446f, 
    0.00970203f, -0.50632203f, 0.29666579f, 0.09405467f, 0.00841079f, -0.23614827f, 0.08992106f, -0.02571687f, 
    -0.15994261f, 0.13563386f, 0.09243403f, 0.17040332f, 0.05823039f, -0.07074761f, -0.02379743f, -0.34781682f, 
    0.05438987f, -0.08160972f, 0.09175039f, -0.01107056f, -0.10811825f, 0.07851528f, -0.16472839f, -0.01204830f, 
    0.11542959f, 0.06659900f, 0.04649212f, -0.02769682f, 0.15893011f, 0.12395932f, 0.10322595f, 0.12181383f, 
    -0.12918308f, -0.18250503f, -0.00758595f, -0.03729343f, -0.18432383f, -0.08687915f, 0.15370478f, 0.21739349f, 
    -1.18273461f, 0.19801271f, 0.06012861f, 0.12273103f, 0.33045200f, 0.04354690f, 0.09899496f, 0.17565927f, 
    0.05195314f, 0.21221717f, 0.03343751f, 0.03166585f, 0.08747073f, 0.23158075f, 0.04728608f, 0.02995042f, 
    0.12894456f, 0.18158458f, 0.10984895f, -0.19636779f, -0.16644152f, 0.09723192f, -0.41825780f, 0.22309116f, 
    -0.06190214f, -0.06093060f, -0.06189156f, 0.04056004f, 0.09961317f, -0.02218403f, -0.13839740f, 0.01938516f, 
    0.15093951f, -0.05849233f, -0.12599309f, -0.14317751f, 0.17559764f, 0.17102294f, -0.22513999f, 0.01812727f, 
    0.15353659f, 0.01979581f, -0.08869810f, 0.09706841f, -0.29260144f, -0.06510504f, 0.12288933f, 0.12183551f, 
    0.14870544f, -0.01864095f, 0.18157098f, -0.04027258f, 0.03471356f, 0.05453247f, 0.01718087f, -0.09190951f, 
    0.07187230f, 0.03783810f, 0.01702342f, 0.20035221f, -0.83485782f, 0.38552609f, 0.11192349f, -0.05381874f, 
    -0.17396849f, -0.07330923f, -0.14853102f, 0.03961100f, -0.05172990f, -0.07596694f, -0.02221981f, 0.03446144f, 
    -0.16992687f, -0.10558528f, 0.03805268f, 0.05339313f, -0.04980609f, -0.22401524f, -0.18193781f, -0.07784528f, 
    0.24285237f, -0.02843005f, -0.02683210f, 0.11809625f, 0.30630940f, 0.01219918f, -0.13485190f, -0.03064072f, 
    0.05878792f, 0.02009311f, -0.07771114f, 0.22137187f, -0.02507491f, 0.32412478f, 0.25475204f, 0.03408526f, 
    -0.16010930f, 0.15598357f, -0.36244914f, 0.25652480f, -0.09167764f, -0.07735855f, -0.26908582f, -0.29397023f, 
    0.10029131f, 0.03203803f, 0.04246945f, -0.08322744f, -0.02035411f, 0.00777755f, 0.01537818f, -0.03097614f, 
    0.07282192f, -0.11969520f, -0.10695775f, -0.14471610f, -0.09552948f, 0.03627282f, -0.17267995f, 0.04858532f, 
    0.08529719f, 0.28337404f, 0.35337624f, 0.19758511f, -0.13743116f, -0.20872848f, 0.07852799f, -0.09789554f, 
    -0.11507149f, -0.05769413f, -0.05899291f, -0.00537895f, -0.05484720f, 0.08304057f, 0.06158407f, 0.08296923f, 
    -0.09833334f, 0.17561892f, -0.00002685f, 0.03352712f, 0.18612239f, 0.09713710f, 0.07376524f, 0.07614829f, 
    0.17305014f, -0.13554952f, 0.11916935f, -0.09079119f, 0.14352041f, 0.11203592f, -0.15274376f, -0.10990731f, 
    0.06103208f, 0.17185846f, 0.22731903f, -0.00247772f, 0.10601485f, 0.02932805f, 0.01891105f, -0.08012680f, 
    0.01373060f, -0.05970822f, -0.07541062f, 0.24164824f, -0.16591653f, 0.10568262f, 0.19067937f, -0.08759938f, 
    -0.09416828f, 0.12606961f, 0.04965014f, -0.06298207f, 0.03576024f, -0.13090168f, 0.05583245f, 0.18956912f, 
    -0.05106418f, -0.10829768f, 0.10849279f, 0.11064841f, -0.53384733f, 0.02310838f, 0.49227217f, 0.12230838f, 
    -0.40823045f, -0.01248823f, -0.03999865f, -0.06749248f, -0.05643457f, 0.06717144f, 0.06035946f, 0.03795395f, 
    -0.12228159f, -0.08907373f, -0.02930018f, -0.06570344f, 0.12421484f, 0.06434812f, 0.17228855f, -0.04599653f, 
    -0.35670531f, -0.43033978f, 0.08821941f, 0.35056868f, -0.07549145f, -0.02757402f, 0.20238762f, -0.08268314f, 
    0.06959005f, -0.10784873f, 0.05256096f, -0.04179639f, -0.17643520f, 0.09327655f, 0.09199174f, -0.04300697f, 
    0.15914200f, 0.09370752f, -0.15721959f, -0.05619670f, 0.02618152f, 0.04719904f, -0.05716974f, -0.00143258f, 
    0.20959677f, -0.25504014f, 0.00255857f, 0.11282951f, -0.03792595f, -0.01295945f, -0.18360507f, -0.18084957f, 
    0.09095360f, 0.06642175f, 0.24666762f, -0.16119768f, -0.23240413f, -0.01530557f, -0.06079855f, -0.00343941f, 
    -0.13954559f, 0.11516205f, 0.06212403f, 0.05624261f, -0.16586179f, -0.16293375f, -0.09358564f, -0.19762871f, 
    -0.02834015f, 0.09127700f, -0.00089526f, 0.14469378f, 0.09640738f, 0.05349664f, 0.02609868f, -0.03132612f, 
    -0.12098935f, 0.30137569f, 0.02581966f, -0.16795932f, -0.58694261f, 0.27527541f, -0.13390428f, 0.08050271f, 
    -0.28481513f, 0.18055761f, -0.09463664f, 0.06973336f, -0.19952700f, 0.00395731f, -0.03600365f, -0.06600986f, 
    -0.00320033f, -0.02954904f, -0.11321903f, 0.02632071f, -0.14467637f, 0.04384376f, 0.00341406f, 0.10394630f, 
    0.28094599f, 0.17590840f, 0.21902171f, 0.01808907f, 0.07069628f, -0.11546542f, -0.09788629f, 0.01729433f, 
    -0.00980945f, 0.21803856f, 0.00002835f, -0.18940957f, -0.01487818f, 0.08052136f, -0.05938631f, 0.30971885f, 
    -0.04807430f, -0.01789873f, -0.03494934f, 0.14577647f, -0.97822517f, -0.54974473f, -0.15174173f, -0.04957965f, 
    -0.06360210f, 0.15026851f, 0.28181669f, -0.16634065f, 0.01237903f, 0.06310409f, -0.00464417f, 0.13186607f, 
    0.12127604f, -0.20016763f, -0.04476896f, 0.12476497f, 0.13922687f, 0.00389042f, -0.17094195f, -0.00807117f, 
    -0.61136669f, 0.24134913f, -0.41319242f, -0.27804321f, 0.00286145f, 0.10030588f, 0.05473402f, -0.01740935f, 
    -0.03769981f, -0.35385963f, 0.19230770f, 0.06064314f, -0.02277664f, -0.18539998f, -0.00097378f, 0.03834720f, 
    0.04330847f, -0.08496754f, 0.13497353f, 0.03270157f, -0.28413877f, -0.23794761f, -0.05029028f, 0.12188917f, 
    0.02199139f, 0.00557657f, -0.14165603f, -0.33561862f, -0.13278578f, 0.24156135f, -0.00544963f, 0.21620861f, 
    -0.03833792f, -0.05368673f, -0.16207856f, 0.12586653f, 0.04567069f, -0.27602792f, -0.09568891f, -0.05502737f, 
    -0.00411232f, 0.05938943f, 0.22421353f, 0.35800904f, -0.07374897f, 0.03176473f, 0.14887103f, 0.02767462f, 
    0.07356369f, 0.11812797f, -0.10330876f, 0.18797803f, -0.03802151f, 0.04456235f, -0.03126884f, -0.19352701f, 
    -0.05611671f, -0.28463241f, -0.32851520f, -0.02991796f, 0.07401615f, -0.23394978f, -0.04916354f, 0.11069986f, 
    -0.59046489f, 0.01187621f, 0.08819111f, -0.05848012f, 0.07868988f, -0.08986293f, 0.07406291f, 0.14256793f, 
    0.03476049f, 0.06219870f, 0.09188478f, -0.15464169f, -0.00190493f, 0.06805774f, 0.04585447f, -0.08106492f, 
    0.01466324f, 0.05285500f, -0.10016149f, -0.06626457f, 0.20177379f, 0.07538264f, 0.12697132f, 0.03276080f, 
    -0.20187470f, -0.15603594f, 0.07922243f, -0.00598268f, -0.00230935f, -0.18195969f, -0.12395110f, 0.08466224f, 
    0.13089351f, 0.03357877f, 0.22222057f, 0.03015712f, -0.10403789f, -0.40430689f, 0.10896083f, -0.07145685f, 
    0.36719957f, 0.14885159f, -0.01038227f, 0.11250229f, -0.10521181f, -0.09950833f, 0.01926111f, -0.20500043f, 
    0.01653424f, 0.09443746f, -0.31095320f, 0.12919581f, 0.05691511f, -0.03002174f, 0.20587675f, 0.10600151f, 
    -0.34298587f, -0.13809961f, -0.09299474f, 0.33270520f, 0.40761369f, -0.05057740f, -0.05829019f, -0.08376620f, 
    0.17441894f, -0.05461297f, -0.23325258f, 0.05055942f, 0.03841115f, 0.25142467f, 0.14761382f, 0.01347540f, 
    -0.19091572f, -0.31088665f, -0.09434655f, -0.17333488f, -0.16135055f, 0.53702015f, -0.06840986f, -0.12586740f, 
    -0.43660879f, 0.01313908f, 0.04276169f, -0.03849546f, -0.03989032f, -0.04069814f, 0.08172369f, 0.11836388f, 
    -0.08686534f, -0.07740511f, -0.33986038f, 0.09889857f, -0.15341057f, -0.07265820f, 0.03807190f, 0.08387943f, 
    -0.14371532f, 0.33950019f, -0.32890710f, 0.37260935f, -0.49414113f, -0.22420076f, -0.00659363f, -0.12819213f, 
    0.17125724f, -0.05060713f, -0.06143305f, 0.14900775f, -0.02343685f, -0.03368061f, -0.03634745f, -0.07294665f, 
    -0.09953498f, 0.02985513f, -0.24317603f, -0.04512034f, 0.31555685f, -0.08317103f, -0.05729811f, -0.00358995f, 
    -0.01991566f, -0.07998113f, -0.04134076f, 0.06731345f, 0.00153585f, 0.16821392f, 0.06442942f, -0.08129679f, 
    -0.01253118f, 0.02888410f, -0.03924553f, 0.13481766f, -0.06328314f, -0.00176834f, -0.07460917f, -0.07239979f, 
    0.23903133f, -0.08409641f, -0.10679009f, 0.32512024f, -0.07518486f, 0.04813859f, -0.15111941f, 0.09540903f, 
    0.09369808f, -0.03014281f, 0.07452420f, 0.16537380f, 0.04204453f, 0.08142354f, -0.14243922f, -0.02433434f, 
    0.04715683f, 0.00605841f, 0.09932541f, -0.10000504f, -0.26189446f, 0.40156168f, 0.25620434f, 0.04217540f, 
    -0.50646079f, 0.07397495f, 0.00687159f, 0.04324550f, -0.04758975f, 0.11390709f, -0.15055925f, -0.07455872f, 
    -0.09382952f, 0.02645433f, -0.09557937f, 0.13571893f, -0.01005881f, -0.06921287f, -0.04199578f, 0.04315912f, 
    -0.44157624f, 0.44304085f, 0.00073412f, 0.05944584f, -0.36823058f, 0.11512202f, -0.10040131f, 0.12328736f, 
    0.07851281f, -0.14297858f, 0.09266678f, -0.09903362f, 0.03446563f, -0.21287370f, -0.03403552f, 0.13075131f, 
    0.05469966f, -0.31789672f, 0.12020111f, 0.07895625f, 0.02973556f, -0.98049259f, -0.08224376f, 0.04320065f, 
    0.07648210f, 0.07227711f, 0.13972658f, 0.10287354f, -0.02423245f, 0.09333996f, -0.07982187f, -0.02849324f, 
    0.12007795f, 0.09018164f, 0.23714074f, -0.04409559f, 0.11280890f, -0.06135920f, 0.07503047f, -0.06044392f, 
    -0.20539574f, 0.26377255f, 0.22178240f, 0.14849681f, -0.10734421f, 0.02452992f, 0.00538742f, -0.00889107f, 
    0.08977413f, -0.02989272f, -0.14839937f, 0.09006808f, 0.10111613f, -0.01499006f, -0.00315322f, -0.02188843f, 
    0.17754476f, -0.16442263f, 0.02164081f, -0.43131164f, 0.01696576f, -0.07764906f, -0.04945910f, -0.63282430f, 
    0.08544890f, -0.21076958f, 0.02228371f, -0.06152144f, -0.20681313f, -0.24467954f, -0.07787872f, -0.06673113f, 
    -0.08834431f, 0.25082242f, -0.03908683f, -0.23833914f, -0.09846408f, 0.00370564f, 0.19429794f, -0.05450165f, 
    0.33152905f, -0.78543675f, 0.03287936f, -0.30126065f, 0.08490435f, -0.03283143f, 0.00923266f, -0.11437886f, 
    0.05993264f, -0.05591924f, -0.07184109f, 0.03989604f, 0.14521907f, 0.23229609f, 0.01514100f, 0.04609932f, 
    -0.04650407f, -0.09595685f, -0.22156022f, 0.16415632f, -0.07208322f, -0.11170404f, -0.49460122f, -0.45474824f, 
    0.17691498f, 0.16235316f, -0.05533008f, 0.09805559f, -0.18639547f, -0.17741017f, -0.13062567f, -0.00832075f, 
    -0.05669908f, 0.01530888f, -0.00018007f, -0.03415817f, -0.07508853f, 0.23867795f, 0.16688228f, 0.10594150f, 
    -0.15298574f, 0.03552910f, 0.07091698f, 0.02900855f, 0.22986232f, -0.11616688f, -0.06482938f, 0.07048648f, 
    -0.18060583f, 0.01946893f, -0.12105893f, 0.05745369f, 0.03925725f, -0.09621786f, 0.07034696f, 0.13346820f, 
    -0.14193293f, 0.16708399f, 0.19602150f, 0.13351810f, 0.18859375f, -0.17568475f, 0.24175172f, 0.03809099f, 
    -0.02603030f, 0.25353429f, -0.07536114f, 0.06627628f, 0.01239896f, -0.01276429f, -0.17847164f, 0.05492932f, 
    0.01331516f, -0.06132536f, -0.02275856f, -0.05634296f, 0.10783690f, 0.12447233f, 0.19485758f, -0.07500802f, 
    0.23423344f, -0.32030728f, 0.26393744f, -0.05857388f, 0.01550132f, 0.20510820f, -0.10887314f, -0.16108386f, 
    -0.07525335f, 0.09212317f, -0.00551646f, -0.14343703f, 0.00600059f, -0.03790877f, 0.00451203f, -0.19409142f, 
    -0.13356794f, -0.11683244f, 0.23590669f, 0.00381918f, 0.01387511f, 0.48260322f, 0.29721847f, 0.01318940f, 
    0.49292961f, -0.16056155f, 0.33850104f, 0.05159856f, 0.09978887f, 0.15841602f, -0.12672904f, 0.06095932f, 
    -0.07297883f, -0.08515669f, 0.10473265f, 0.06442617f, 0.05207525f, 0.18646313f, 0.00138190f, 0.08594364f, 
    -0.32887208f, -0.23660246f, -0.15408386f, -0.23034027f, -0.14817749f, -0.20282763f, -0.03410973f, -0.02807427f, 
    -0.08961125f, -0.09544542f, 0.07757688f, -0.12521312f, -0.09563295f, -0.04342120f, -0.06796467f, 0.02835926f, 
    -0.09386599f, -0.11491785f, -0.07975255f, 0.02445956f, -0.23681907f, -0.07383415f, -0.27089849f, -0.01745207f, 
    0.17906787f, -0.09015418f, -0.15683649f, -0.21392098f, -0.07748795f, -0.08538327f, -0.07244080f, 0.10248640f, 
    0.11231980f, -0.04953627f, -0.01217499f, -0.18923633f, 0.01192029f, 0.04507522f, 0.02518753f, 0.07109006f, 
    -0.61514378f, 0.36725932f, 0.08841210f, -0.33002305f, -0.28961009f, -0.00752949f, -0.13198884f, -0.03305552f, 
    0.05861726f, -0.08598096f, -0.15617155f, 0.02833104f, -0.07794481f, -0.10059243f, -0.12879433f, 0.07222014f, 
    -0.02917115f, 0.06750893f, -0.06450571f, 0.03888268f, -0.03094291f, -0.02666591f, 0.14761177f, -0.05721887f, 
    -0.38644055f, 0.10134097f, -0.06240646f, 0.03053688f, -0.03054589f, 0.00947234f, 0.02342171f, 0.01779228f, 
    -0.05592974f, -0.05689757f, -0.14854850f, 0.03857765f, -0.05769743f, -0.05175015f, -0.13241881f, -0.11183209f, 
    0.10452875f, -0.06074895f, -0.06321531f, -0.06631673f, 0.10584401f, 0.22096023f, -0.11073811f, 0.05302433f, 
    0.03614094f, 0.05361015f, -0.09081966f, 0.01956445f, -0.10621597f, -0.11211676f, 0.06041395f, 0.06751613f, 
    -0.15807383f, 0.04912043f, 0.05617905f, -0.05847697f, -0.15262508f, -0.48483616f, -0.36580220f, 0.13499317f, 
    -0.08248885f, -0.05884704f, -0.09783892f, -0.02386660f, 0.05938074f, -0.10432141f, -0.04833231f, -0.06344443f, 
    -0.02462000f, 0.06970680f, 0.03580560f, -0.12401330f, -0.02577431f, -0.10816177f, -0.01528266f, -0.06045114f, 
    -0.09020977f, -0.34272790f, -0.37403458f, -0.44186753f, -0.40778139f, 0.00223850f, -0.13835786f, -0.08577880f, 
    -0.01966171f, -0.16604960f, -0.14081815f, -0.05857931f, -0.21296899f, -0.08020770f, -0.18350129f, -0.13855579f, 
    0.09838725f, -0.00902020f, 0.04264118f, 0.12283609f, 0.21030134f, -0.34385163f, 0.05796603f, 0.13931635f, 
    0.43639398f, 0.15295446f, -0.01002058f, -0.06690480f, 0.13372234f, -0.04415467f, 0.02395214f, -0.12304319f, 
    0.00462106f, -0.04599173f, -0.03820235f, -0.07995439f, -0.06360431f, -0.13129799f, 0.00906477f, -0.01690067f, 
    -0.28969225f, 0.01905377f, -0.32693642f, -0.14414154f, -0.26546332f, -0.11175817f, -0.05220268f, -0.09419078f, 
    -0.02684550f, 0.02105172f, -0.11401543f, -0.19407195f, 0.06106449f, -0.01787159f, -0.03642024f, -0.12694436f, 
    -0.06821934f, 0.00407284f, 0.01339579f, 0.10198403f, -0.22847970f, 0.27950510f, 0.32089537f, 0.31423154f, 
    0.22265939f, 0.24107416f, 0.13668053f, 0.14046037f, 0.03748081f, 0.00877565f, -0.11798906f, 0.02093638f, 
    -0.06126374f, -0.08081310f, -0.03968876f, 0.13146362f, 0.01310402f, 0.09533018f, 0.03348843f, -0.09826221f, 
    0.03583968f, 0.19966640f, 0.39461866f, -0.00078328f, 0.22930270f, -0.07997661f, 0.18611170f, 0.06507074f, 
    -0.05559393f, -0.02045791f, -0.09968919f, 0.10459324f, -0.03039741f, 0.02949071f, -0.13956146f, -0.05310871f, 
    -0.01319762f, 0.09178142f, 0.06057883f, -0.04313808f, -0.00851145f, 0.35130024f, 0.06796052f, 0.05310294f, 
    0.27014703f, 0.03437313f, 0.15029338f, -0.10838319f, -0.04960883f, -0.15522686f, -0.10204665f, 0.03410310f, 
    -0.10520152f, -0.18586215f, -0.23409489f, 0.05329620f, 0.00663009f, 0.20562886f, 0.03680905f, -0.05790920f, 
    0.14916280f, 0.34091303f, 0.11288266f, 0.09477495f, 0.39847088f, 0.23705329f, 0.02343601f, -0.14623228f, 
    0.10149014f, 0.13205211f, -0.01267291f, -0.12999986f, 0.02733007f, 0.03182814f, -0.15971495f, 0.01111701f, 
    -0.27265629f, -0.03815362f, 0.04275150f, -0.02212304f, 0.55994189f, -0.85216129f, 0.23274593f, 0.05397791f, 
    -0.44454882f, 0.18788435f, -0.05559175f, -0.05749093f, 0.04326429f, -0.05719643f, -0.00285107f, 0.01615385f, 
    -0.06683879f, -0.05129154f, -0.02136378f, -0.01137990f, 0.17809176f, -0.03857313f, -0.00666368f, -0.15558779f, 
    -0.31414640f, 0.08553752f, -0.07536391f, -0.37813026f, -0.27111638f, -0.10336765f, -0.16580644f, -0.09992684f, 
    -0.06429612f, -0.34715992f, 0.09577068f, 0.06883339f, -0.06066018f, 0.29220197f, -0.07311498f, 0.01126369f, 
    0.11325492f, -0.26455355f, -0.52555513f, 0.28125900f, -0.43542019f, 0.54237789f, 0.03386853f, -0.38349733f, 
    -0.35160235f, -0.06754228f, -0.01598374f, -0.02334598f, 0.01545515f, -0.19709599f, 0.21375509f, -0.02046416f, 
    -0.17470081f, 0.05003114f, 0.08324001f, -0.14117177f, -0.04260767f, -0.04123914f, 0.04294734f, 0.05605542f, 
    0.30530608f, 0.37766531f, -0.04783900f, 0.14567955f, 0.04532299f, 0.17914586f, 0.02662973f, -0.21254170f, 
    -0.09921484f, -0.02665980f, 0.09611385f, 0.05569842f, -0.02836196f, -0.09492841f, -0.09984110f, -0.18197450f, 
    0.02293412f, 0.19749293f, 0.10787367f, -0.20315446f, -0.07169342f, -0.15656427f, -0.13024700f, -0.18998423f, 
    -0.06387603f, 0.20018017f, 0.05466689f, -0.07531139f, -0.02510331f, -0.10743922f, 0.10186803f, 0.03237480f, 
    -0.01150855f, -0.08599037f, -0.03864722f, -0.08171620f, -0.00325210f, 0.04963855f, -0.02561221f, -0.10869592f, 
    0.21189812f, 0.11746008f, -0.16692995f, 0.20062710f, 0.17980336f, 0.07147155f, 0.00656301f, -0.20062995f, 
    -0.08436865f, -0.00746264f, -0.00565071f, -0.05519675f, 0.07787175f, -0.00212971f, 0.06319884f, -0.07818422f, 
    0.05458882f, -0.00242437f, 0.15420245f, -0.03026114f, -0.05310776f, 0.11200835f, 0.12486158f, -0.01435889f, 
    0.14159499f, -0.07241926f, -0.07006364f, -0.21670076f, -0.05819178f, -0.11030103f, -0.17827462f, -0.04192867f, 
    -0.06058959f, -0.25111714f, -0.06308222f, 0.04910745f, -0.04815329f, 0.00774936f, 0.07014748f, 0.06626539f, 
    0.21071437f, 0.08875352f, 0.07068668f, -0.00046423f, 0.09795500f, 0.08368409f, -0.12499703f, -0.01982156f, 
    -0.08472096f, -0.00113046f, 0.10273832f, -0.05791140f, 0.01388528f, -0.05131567f, -0.17071223f, 0.14080191f, 
    -0.10486128f, 0.15490241f, -0.07743972f, 0.06798968f, 0.09514911f, -0.18937945f, -0.54874945f, 0.01681562f, 
    0.17460528f, 0.04132288f, 0.03856928f, -0.09530497f, -0.10619629f, -0.10219622f, 0.01170600f, -0.03089748f, 
    -0.03832492f, 0.17107752f, 0.04577173f, -0.07697365f, -0.03616633f, 0.03926946f, 0.02253591f, -0.13937223f, 
    -0.03051837f, -0.14195627f, 0.16488904f, -0.06641334f, 0.16725436f, 0.17253378f, 0.09409421f, -0.16843061f, 
    -0.05390214f, 0.01597974f, 0.02255591f, 0.22455265f, -0.14297491f, 0.02518704f, -0.10180257f, -0.09961613f, 
    -0.00468296f, 0.21543533f, 0.02709166f, -0.05712694f, -0.12839492f, -0.11445732f, 0.38447374f, -0.07191505f, 
    0.25719574f, -0.10827500f, -0.23097277f, -0.05951870f, -0.17072311f, -0.04866262f, -0.02641160f, -0.04227880f, 
    0.03104088f, -0.03746659f, 0.01378132f, 0.08824631f, -0.14322788f, 0.12085684f, 0.00457744f, 0.03483166f, 
    0.27000868f, -0.20528436f, -0.15157001f, -0.07489800f, 0.07426809f, 0.05910046f, -0.05072826f, -0.15079093f, 
    -0.06993834f, -0.00189331f, 0.20245688f, 0.19602503f, 0.02697957f, 0.20081234f, -0.16187546f, 0.00905116f, 
    0.11630873f, 0.24499625f, 0.04993139f, 0.15474968f, -0.37194273f, -0.05490165f, 0.35287195f, -0.33861282f, 
    -0.01837270f, -0.09709818f, 0.00401267f, -0.01142911f, -0.05857834f, -0.12083886f, 0.11448427f, 0.10968652f, 
    0.16278651f, -0.07078765f, -0.06889290f, -0.08433814f, 0.13604176f, -0.03344439f, -0.20795488f, -0.02888627f, 
    0.00809943f, 0.05052606f, 0.16089307f, 0.11589002f, 0.22028065f, -0.23868249f, -0.13087232f, 0.12801713f, 
    -0.08413564f, 0.15205857f, 0.07634642f, -0.14971498f, -0.06174676f, -0.15498763f, 0.10464352f, 0.07625821f, 
    0.05042596f, -0.09191816f, 0.10378958f, -0.00387048f, -0.41384384f, 0.35821450f, 0.42180654f, -0.20307586f, 
    -0.26634625f, 0.09452274f, 0.18318284f, -0.19808556f, 0.15006414f, -0.19869322f, 0.04311766f, 0.06247403f, 
    -0.11102090f, 0.10523844f, 0.08766310f, -0.16931553f, -0.02968784f, -0.21138561f, 0.12146800f, -0.07698882f, 
    -0.24088287f, -0.02276866f, -0.41001108f, -0.46454605f, -0.30888346f, 0.09182626f, -0.00831337f, -0.39324185f, 
    0.06824753f, -0.01923629f, 0.17231221f, 0.04598317f, 0.17483495f, -0.10871830f, -0.02343285f, -0.21491222f, 
    0.03110129f, -0.31961861f, 0.06013279f, -0.11513491f, 0.09690870f, -0.12052891f, -0.33413550f, 0.10960995f, 
    0.12812684f, 0.00971323f, -0.14509477f, -0.05641710f, -0.07180037f, -0.04771093f, -0.00052180f, 0.03099864f, 
    -0.13277714f, -0.03151727f, 0.07957061f, 0.02955981f, -0.01480125f, -0.06517263f, 0.23514201f, -0.05837874f, 
    -0.05474610f, -0.66857731f, 0.09841545f, 0.02967964f, -0.00192427f, -0.32483819f, 0.06279946f, 0.02778505f, 
    -0.02428316f, 0.01720501f, 0.07989947f, -0.03531020f, 0.18735103f, -0.40075076f, -0.15724407f, -0.15212065f, 
    0.03117619f, -0.03506730f, 0.27338096f, 0.05634807f, -0.85475212f, 0.35014957f, 0.02705275f, 0.39119485f, 
    -0.05487920f, 0.08364680f, 0.01637913f, -0.12002255f, 0.21048136f, 0.05866706f, -0.00726324f, -0.03311426f, 
    0.12976921f, 0.09905814f, 0.15833358f, 0.10750566f, -0.06920160f, 0.08925434f, -0.20755802f, -0.02756245f, 
    0.28006095f, -0.02707952f, -0.20398708f, 0.11100432f, -0.08629921f, 0.14115772f, 0.08215331f, 0.11556268f, 
    0.09816550f, -0.27148145f, 0.07009328f, 0.02274515f, -0.03042763f, -0.06572136f, 0.11968838f, 0.11110160f, 
    0.05987760f, -0.09369891f, 0.16512732f, 0.00694336f, -0.12285239f, -0.05952324f, 0.25400105f, -0.42878556f, 
    -0.62101668f, -0.12697068f, -0.06533883f, 0.12168963f, -0.05611658f, 0.08811615f, -0.04732235f, 0.01922455f, 
    0.08606829f, -0.11671411f, -0.11584206f, -0.09740561f, 0.01460556f, -0.04749263f, 0.07520234f, -0.13077822f, 
    -0.33798012f, 0.13214242f, 0.33097455f, -0.34702232f, 0.00325144f, -0.01944039f, 0.06244719f, -0.08892195f, 
    -0.10307834f, -0.03595490f, -0.01799633f, -0.02955608f, 0.00380392f, -0.18791646f, -0.00048480f, 0.07369839f, 
    0.13332312f, 0.17972554f, -0.11356484f, 0.05915120f, -0.00971377f, -0.51594871f, -0.16200280f, 0.13130844f, 
    -0.01922142f, 0.04018761f, -0.00458204f, -0.04017982f, -0.02974518f, -0.13843703f, -0.02126589f, -0.02348321f, 
    0.16895628f, 0.22022495f, -0.01224775f, -0.04392443f, 0.14672861f, -0.20045196f, -0.07833874f, -0.17812581f, 
    -0.19626291f, 0.20011590f, -0.15089561f, -0.30931398f, -0.18609722f, 0.07944415f, -0.15306148f, 0.05407230f, 
    0.05402122f, -0.09201948f, 0.00278092f, -0.07009859f, 0.26576823f, -0.02782641f, -0.17684928f, -0.08420287f, 
    0.06314820f, -0.15134610f, 0.02078822f, -0.10992465f, -0.32360664f, -0.11238630f, 0.20572305f, -0.44724670f, 
    -0.47908252f, -0.12875967f, 0.12350334f, -0.15327798f, 0.03136400f, -0.04311275f, -0.13831815f, 0.03916072f, 
    -0.05671725f, -0.03509415f, -0.11415921f, -0.14340423f, -0.04923448f, 0.23650447f, 0.17076033f, 0.12706782f, 
    0.50905490f, -0.42742521f, 0.32617030f, -0.14838891f, -0.45086142f, -0.02126724f, 0.13525663f, 0.09834840f, 
    0.11591423f, -0.06641176f, -0.03511010f, 0.11961007f, 0.09402058f, -0.03886280f, 0.01614469f, 0.04780487f, 
    0.06252401f, -0.22768474f, -0.22492704f, -0.12760153f, 0.99956816f, 0.16217798f, -0.10294717f, -0.31279790f, 
    0.10653038f, 0.14695972f, -0.08691451f, 0.13950224f, -0.13254207f, 0.13056505f, -0.08026440f, 0.05197669f, 
    0.12509562f, 0.19294468f, -0.01112677f, -0.00738114f, 0.10692876f, -0.15123755f, -0.03659096f, -0.02717619f, 
    -0.31177926f, -0.21930133f, 0.02782517f, -0.02161414f, -0.28514823f, 0.03470143f, 0.14160880f, 0.25550839f, 
    -0.02852028f, -0.15110005f, -0.16710821f, -0.18846899f, -0.04623679f, -0.09103246f, 0.06701391f, -0.02320838f, 
    -0.17806904f, -0.22081508f, 0.02068689f, 0.15519358f, -0.12604629f, -0.37818548f, -0.26059821f, 0.29442072f, 
    0.11673667f, -0.03760207f, 0.03106009f, -0.05169972f, -0.05878020f, 0.22095440f, -0.19470648f, -0.00985480f, 
    0.02506056f, 0.07037634f, 0.11404869f, 0.02101712f, -0.12059762f, 0.16452400f, 0.01135098f, 0.07787663f, 
    -0.02092320f, -0.16734785f, -0.00636240f, 0.39389646f, 0.01676552f, 0.23553033f, 0.06487014f, -0.03670485f, 
    -0.03585694f, 0.22290276f, -0.03109129f, -0.00504453f, -0.05839787f, -0.12639605f, 0.03634637f, -0.11647010f, 
    -0.16956498f, -0.03337603f, -0.01114747f, 0.01749391f, 0.24101624f, 0.00535000f, 0.30223277f, -0.24470448f, 
    -0.15994734f, -0.20375662f, 0.18682839f, 0.17298305f, 0.16371249f, -0.06110265f, 0.08495601f, -0.03069356f, 
    0.11187433f, 0.18121591f, 0.11893863f, 0.04563564f, 0.15062200f, 0.00038542f, 0.01368537f, -0.07723502f, 
    -0.00704564f, -0.53582793f, 0.01949969f, -0.13574968f, -0.14505072f, -0.12784129f, 0.13152434f, -0.08864717f, 
    0.07636502f, -0.01401007f, -0.19558024f, -0.21754536f, -0.07384282f, 0.07710712f, 0.01345444f, 0.21795855f, 
    0.20960766f, 0.10209055f, -0.12781242f, 0.19365078f, 0.60792398f, -0.69644362f, 0.53428537f, -0.06145570f, 
    0.23857129f, 0.11679185f, -0.06205314f, 0.01030421f, -0.03536981f, -0.07101561f, -0.04047383f, -0.14998934f, 
    -0.05387951f, -0.04715507f, 0.11056371f, -0.01990229f, -0.00683845f, -0.08734264f, 0.01533692f, 0.20097712f, 
    0.62959778f, 0.39646047f, 0.15669906f, -0.11088618f, 0.03152724f, 0.19495209f, 0.07386045f, 0.09704965f, 
    -0.00852128f, -0.02121672f, -0.14074910f, 0.05129482f, 0.07026343f, 0.04549726f, -0.04176252f, 0.17891510f, 
    0.11606171f, -0.02794567f, -0.25270176f, 0.09948392f, -0.37501600f, -0.49104407f, -0.09540128f, -0.01170478f, 
    0.26628432f, -0.04694399f, 0.02745482f, 0.04975588f, 0.06002064f, -0.08846888f, 0.14284545f, -0.08248164f, 
    0.02709659f, -0.12869865f, 0.07547390f, -0.12079472f, 0.05492168f, -0.14739339f, -0.05471613f, 0.19536033f, 
    -0.57503581f, -0.39642489f, -0.04714498f, -0.19259657f, -0.17296368f, -0.00228786f, 0.18486267f, -0.06735524f, 
    -0.05292547f, -0.05870333f, 0.05027174f, -0.10688776f, 0.01510052f, -0.14429176f, 0.05155244f, -0.17258130f, 
    0.11603164f, 0.23373331f, 0.14921698f, 0.11822429f, -0.14902890f, 0.12054065f, 0.24241775f, -0.02558169f, 
    -0.19270933f, 0.22517075f, -0.00526437f, 0.06330604f, -0.07046094f, -0.02213449f, -0.01440623f, 0.18461165f, 
    0.04535350f, 0.23726740f, 0.05352037f, 0.05479086f, -0.03052004f, -0.04981036f, -0.19150819f, -0.16437489f, 
    -0.85539657f, -0.53486961f, -0.44609952f, -0.15958965f, -0.17037815f, 0.15071689f, -0.00752753f, -0.09484839f, 
    -0.03222160f, -0.04023931f, 0.17565864f, 0.02600337f, 0.00380338f, 0.06053027f, -0.00425301f, 0.03077215f, 
    -0.03068938f, 0.03167615f, 0.17534389f, -0.02408888f, -0.64523530f, 0.05748273f, -0.16914758f, -0.20498271f, 
    0.07642029f, 0.17682545f, 0.22089951f, -0.18015833f, 0.08494261f, 0.09491518f, 0.07504413f, -0.02639776f, 
    -0.03120775f, -0.22808343f, 0.19430643f, 0.01486651f, -0.02793845f, 0.23861405f, 0.04418887f, 0.08535779f, 
    -0.65455663f, -0.12578061f, 0.00443148f, -0.13694410f, -0.01886046f, 0.08235591f, -0.04623786f, -0.10818802f, 
    -0.02929100f, 0.06927481f, -0.04454979f, -0.07970777f, 0.18423517f, 0.03901391f, 0.08602312f, -0.16417606f, 
    0.16956031f, 0.23609179f, 0.23476213f, 0.15497428f, -0.54270899f, -0.20066090f, 0.24313320f, -0.03558452f, 
    -0.38499379f, 0.13670804f, 0.07648220f, -0.04893993f, -0.04256927f, 0.03265130f, 0.07950058f, 0.20377679f, 
    -0.03008342f, 0.08512200f, -0.01401305f, 0.14325830f, 0.02351981f, -0.04781040f, -0.17425333f, -0.04645530f, 
    -0.69525361f, 0.05709801f, -0.18217771f, -0.12636343f, -0.22268201f, 0.20718114f, -0.03878319f, -0.06258334f, 
    -0.04897517f, -0.10486815f, -0.09731747f, 0.03336291f, -0.03810940f, 0.17889047f, 0.00669608f, -0.03916966f, 
    -0.05382067f, 0.13290809f, -0.01712572f, -0.01946429f, 0.16711497f, 0.25393552f, -0.04133084f, -0.01031595f, 
    0.06092609f, -0.14111562f, 0.09611140f, -0.00590463f, 0.04094851f, 0.03034244f, -0.02209336f, -0.02031740f, 
    -0.07246543f, 0.00489391f, 0.00544818f, -0.05574661f, -0.06313323f, 0.22648722f, -0.08571328f, -0.00775921f, 
    -0.96534455f, -0.52482373f, 0.13676997f, -0.00994139f, -0.05039440f, 0.14841950f, 0.10303022f, -0.06197519f, 
    -0.00627380f, -0.07708021f, 0.05651120f, 0.00679632f, -0.03892588f, 0.18616728f, 0.06469452f, 0.04778197f, 
    0.10188317f, 0.17043340f, -0.00117184f, 0.05625921f, 0.29347903f, 0.04019096f, 0.01676719f, -0.03655607f, 
    -0.11858037f, 0.11298434f, -0.14778402f, 0.27430150f, -0.20128326f, 0.01086862f, -0.00089138f, -0.01524877f, 
    0.04614876f, -0.12138081f, -0.08031499f, 0.07983654f, -0.02696482f, 0.04932465f, -0.07426618f, -0.00505140f, 
    0.49369591f, 0.10972705f, -0.13794675f, 0.04154615f, -0.14213239f, -0.24390930f, -0.13728635f, 0.05588628f, 
    -0.02387134f, -0.05356923f, -0.00983061f, -0.07109109f, -0.09086519f, -0.15071639f, -0.06457158f, -0.09887825f, 
    0.15513127f, 0.08343863f, -0.05853858f, -0.02166572f, 0.02014146f, -0.23041031f, 0.16145551f, -0.28847572f, 
    0.08431312f, 0.29515606f, -0.04386238f, 0.11438861f, -0.08368134f, 0.06173766f, 0.06599139f, -0.11743092f, 
    -0.13872695f, -0.05143687f, -0.02594966f, 0.06106715f, -0.02699007f, -0.17938636f, -0.06882711f, 0.23861282f, 
    -0.10144058f, -0.08764207f, 0.06752538f, 0.15028113f, 0.13722599f, 0.11397932f, 0.06472638f, -0.04937250f, 
    0.04231551f, -0.04724510f, 0.01130472f, 0.06849501f, -0.01368355f, -0.16188639f, 0.01304158f, 0.00515877f, 
    -0.27701378f, -0.43014312f, -0.23645538f, -0.14143118f, -0.85013926f, -0.17031935f, -0.43044326f, -0.00296942f, 
    0.19469045f, 0.07091943f, 0.04728954f, -0.16143526f, 0.06661914f, 0.24982177f, 0.11461672f, -0.03708488f, 
    0.00674615f, -0.01129504f, 0.05109073f, 0.12549971f, -0.04825699f, 0.17874369f, -0.09271007f, 0.13437004f, 
    -0.36910117f, 0.28883731f, -0.10991053f, -0.24085212f, 0.03599642f, -0.13158442f, 0.08880872f, 0.01887124f, 
    -0.11471769f, -0.07384747f, 0.00754165f, -0.00905678f, -0.13474806f, 0.00135703f, 0.16418806f, 0.14298055f, 
    -0.12392401f, -0.00403503f, 0.25525814f, -0.07502510f, -0.34228751f, 0.48432606f, -0.10707191f, 0.22925089f, 
    -0.06046115f, 0.24581331f, -0.00780437f, 0.04778404f, -0.15485066f, 0.04531896f, 0.06471408f, 0.17708233f, 
    -0.06554011f, 0.01818668f, 0.03838236f, -0.06823971f, 0.14452530f, -0.15375815f, -0.07325946f, 0.06753409f, 
    -0.42161500f, -0.77101481f, -0.30701151f, -0.35177520f, -0.39537662f, 0.02459092f, 0.02850307f, 0.20522332f, 
    0.04637282f, 0.20117821f, 0.04186580f, 0.00228067f, -0.03776253f, 0.01470397f, -0.09829587f, -0.04092550f, 
    -0.01395132f, -0.10955402f, -0.20371208f, -0.12123888f, 0.60096550f, 0.10716932f, -0.35462701f, -0.18128704f, 
    0.20908871f, 0.12905905f, -0.06260494f, -0.07812399f, 0.12653252f, -0.08208092f, 0.21830110f, 0.02009752f, 
    -0.07220276f, 0.11539627f, 0.00039967f, -0.00671880f, -0.14317967f, -0.02157717f, 0.02628636f, 0.11739033f, 
    0.59532732f, -0.30166709f, -0.13276789f, 0.06448592f, -0.27960613f, 0.03349778f, 0.03045741f, 0.05525317f, 
    -0.03514452f, -0.07822813f, 0.10309437f, 0.10540935f, 0.03077075f, 0.07139583f, -0.00289265f, 0.03761603f, 
    -0.00119011f, -0.00316746f, -0.02268786f, 0.05029123f, -1.07097113f, -0.09368860f, -0.00089940f, 0.04566701f, 
    -0.08119233f, -0.12628418f, 0.26588473f, -0.00240419f, 0.17394282f, -0.06123819f, -0.14125240f, 0.08628666f, 
    0.16503744f, 0.14373852f, 0.01531581f, -0.07673156f, 0.06814477f, -0.06992494f, -0.13970296f, 0.04435651f, 
    0.02345408f, -0.24652085f, 0.23066023f, 0.04894120f, 0.19718920f, -0.00467610f, 0.20063931f, 0.06942531f, 
    0.02301724f, -0.04258876f, 0.06994235f, -0.08119375f, -0.09452240f, 0.05100057f, 0.11250243f, 0.17279756f, 
    0.03609131f, -0.12168157f, -0.08464693f, -0.15156126f, 0.75492990f, 0.14571691f, -0.30741364f, -0.06729241f, 
    0.16093202f, -0.06598821f, -0.06968962f, -0.05297902f, -0.03981582f, -0.09608416f, 0.15575294f, 0.05666313f, 
    0.01512228f, 0.07418461f, -0.11932726f, 0.07317491f, -0.01589524f, 0.05657804f, -0.01558148f, 0.06939762f, 
    0.35355926f, -0.08830062f, -0.09470699f, -0.22465451f, -0.28257355f, 0.05524980f, 0.15409172f, -0.12068570f, 
    0.10142039f, 0.00077819f, 0.11890377f, -0.09049645f, -0.06755342f, -0.10730504f, 0.08808259f, -0.22367485f, 
    0.08323246f, -0.03102403f, 0.05056776f, 0.00556585f, -0.92472047f, 0.12249784f, 0.09455145f, -0.01183419f, 
    0.24063887f, -0.01459776f, -0.01242954f, -0.00443784f, 0.15024608f, -0.02599294f, -0.05544201f, 0.06296308f, 
    0.20487778f, 0.04487968f, -0.04748391f, -0.11464161f, -0.11833685f, 0.00483072f, -0.25968903f, -0.02955617f, 
    -0.03812406f, 0.38172382f, -0.07859038f, -0.23033270f, 0.11447705f, 0.09963196f, -0.12523650f, -0.00050148f, 
    0.16622439f, -0.02241186f, 0.04461000f, 0.22396043f, -0.13128592f, -0.07873700f, 0.03284008f, -0.04770725f, 
    -0.06294215f, 0.23158674f, -0.17464171f, 0.05360171f, 0.51778477f, -0.16089433f, 0.07794486f, -0.22291587f, 
    0.06440348f, -0.16486999f, -0.23057097f, 0.10521302f, -0.13741155f, -0.36267567f, 0.01460577f, -0.09294213f, 
    0.05381341f, 0.11236025f, -0.13750133f, -0.02845656f, -0.02197805f, -0.03072679f, -0.12851816f, -0.13269331f, 
    -0.19852060f, -0.11378284f, 0.00516002f, 0.06948304f, -0.12950300f, 0.06174930f, -0.02952051f, 0.03329216f, 
    -0.02424118f, -0.05815994f, -0.11145670f, -0.17360616f, 0.04314958f, -0.06496563f, -0.08043990f, -0.17131315f, 
    -0.10839887f, -0.19591044f, -0.10126751f, -0.04141295f, 0.38375005f, 0.14862595f, -0.20592768f, -0.16687487f, 
    0.35215411f, 0.05501125f, -0.22909856f, -0.06457324f, -0.09559811f, -0.19957763f, -0.09064275f, 0.20281342f, 
    -0.01658319f, 0.02549724f, -0.12883453f, 0.01926075f, 0.03224456f, -0.01195832f, 0.23505834f, -0.01047290f, 
    -0.12104791f, 0.05467597f, -0.33003795f, 0.07219708f, 0.07846736f, -0.02603761f, 0.03882188f, -0.15786025f, 
    -0.06897592f, -0.26106316f, 0.17926477f, -0.02043104f, 0.07073516f, 0.10424586f, 0.00685368f, 0.20028144f, 
    0.26739699f, 0.11115969f, 0.05642275f, 0.03482441f, 0.35227591f, 0.19074653f, -0.15680067f, 0.14983667f, 
    -0.09361429f, -0.30050451f, -0.11781976f, -0.13821693f, 0.12239902f, 0.03637621f, -0.14040357f, 0.02046774f, 
    0.09421568f, -0.06556205f, -0.02730604f, 0.16156076f, -0.01577910f, -0.01734239f, -0.00368219f, 0.10399715f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14586881f, 0.03303421f, -0.10576953f, 0.00414714f, -0.00772009f, -0.02590569f, 0.01690307f, -0.05693839f, 
    -0.03267508f, 0.00138122f, 0.09251516f, 0.05859129f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
