#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.27596274f, 0.90309566f, 0.35880998f, 0.27212077f, -0.79657573f, -0.20492427f, -0.38790083f, 0.18646842f, 
    -0.30713367f, -0.43580207f, 0.91268891f, 0.48567501f, -0.64501083f, -0.04888812f, 0.18872643f, -0.24058628f, 
    0.20169480f, 0.58194524f, -0.49261579f, -0.39204469f, -0.69115710f, -0.18453728f, -0.33106664f, 0.60434294f, 
    -0.41354746f, -0.44384104f, -0.54932326f, -0.68879634f, -0.01234354f, -0.34964803f, 0.43274832f, -0.73985845f, 
    0.51853359f, -0.28189152f, -0.30104280f, 0.25660393f, -0.45698753f, -0.00748654f, 0.07121815f, -0.57842612f, 
    -0.71020013f, -0.89448237f, 0.31376842f, 0.57813931f, 0.44940540f, 0.48156491f, -0.48569089f, 0.34697062f, 
    0.43730792f, -0.48193184f, 0.05846571f, 0.13941093f, -0.16491881f, -0.03407273f, -0.03972823f, -0.68566304f, 
    -0.34404773f, -0.14061475f, -0.90441245f, -0.13302171f, 0.71912903f, 0.09091690f, -0.18413080f, -0.47558132f, 
    -0.50664425f, -0.27278465f, 0.29515174f, 0.01479571f, -0.31333417f, 0.61174947f, -0.36499712f, 0.09676025f, 
    -0.99312443f, -0.45960090f, 0.39065626f, -0.12395485f, 0.83041412f, -0.25970113f, 0.33701658f, -0.20220327f, 
    0.31423146f, 0.00789959f, -0.80778152f, -0.70422035f, 0.45277345f, 0.93522882f, 0.70212114f, -0.13852282f, 
    0.06449447f, 0.12115256f, -1.22579372f, 0.00459824f, -0.11260539f, -0.37672621f, 0.20646635f, 0.47245073f, 
    0.36871552f, 0.45413211f, -0.22992121f, -0.14404365f, 1.29726601f, -0.71256447f, -0.70095104f, 0.28686267f, 
    0.08630974f, -0.10991450f, 0.30880043f, -0.17592286f, -0.23108928f, -0.54121822f, -0.29308257f, 0.22072962f, 
    -0.49877784f, 0.20910126f, -0.13339816f, 0.07087083f, 0.60712749f, 0.20544770f, 0.23431353f, 0.29218957f, 
    -0.62036031f, 0.24118806f, -0.25208300f, 0.51716608f, 0.24913098f, -0.32099697f, 0.71177483f, 0.59162575f, 
    0.32547459f, -0.15561873f, -0.20538816f, -0.48312768f, -0.07443649f, 0.06596553f, 0.00777042f, -0.38531718f, 
    -0.69523114f, 0.48490965f, 0.02990887f, 0.54988480f, -0.75830722f, -0.37471059f, 0.04581930f, -0.69208652f, 
    -0.51179588f, -0.41860786f, 0.59951425f, -0.46440297f, -0.56684721f, -0.65398467f, -0.00845532f, -0.69210511f, 
    -0.26959145f, -0.62953633f, -0.66543293f, -0.24212849f, 0.19399752f, 0.49636832f, -0.23551950f, 0.08420208f, 
    -0.35888427f, -0.44337082f, -0.25508112f, -0.42293903f, 0.73088527f, 0.49178219f, -0.19971809f, -0.39825517f, 
    0.25511476f, 0.35526410f, -0.44839153f, 0.48808330f, 0.62586123f, 0.50402623f, -0.63860881f, -0.81619716f, 
    0.03993081f, 0.00199300f, -0.37296614f, 0.11272917f, 0.87001032f, -0.33053616f, -0.35251698f, 0.59233636f, 
    0.72192395f, 0.47235197f, -0.39524278f, -0.44244021f, -0.22972280f, 0.66327286f, -0.24060382f, 0.05949713f, 
    0.69396508f, -0.60815030f, 0.08846591f, -0.17302907f, 0.42925107f, -0.37392187f, 0.27526185f, 0.25669581f, 
    -0.04210047f, 0.49331713f, -0.16133691f, -0.34492919f, -0.38233542f, 0.35182533f, 0.24220341f, -1.44144011f, 
    0.81764150f, -0.26512432f, 0.21103685f, 0.29238409f, 0.42585385f, -0.20770101f, -0.32937321f, 0.12616728f, 
    0.29286143f, 0.06315592f, 0.44869825f, 0.09797082f, 0.00921653f, 0.08779398f, -0.13035341f, -0.38316172f, 
    -0.44039261f, 0.10921801f, 0.24632348f, -0.27282205f, -0.77585596f, -0.72611326f, -0.77256411f, 0.01483028f, 
    -0.51108509f, -0.33526891f, 0.27346915f, 0.50253761f, 0.14049242f, 0.34666103f, -0.46842080f, -0.33244333f, 
    0.28468007f, 0.05045595f, -0.29852223f, -0.82446873f, -0.84846783f, -0.61455667f, 0.91558754f, 0.38148817f, 
    -0.29291263f, 0.11989864f, -0.06534521f, 0.01508793f, 1.39143658f, -0.97440946f, -0.77478045f, 0.95586538f, 
    -0.41200882f, -0.51404601f, -0.29042491f, 0.20215589f, 0.10726192f, 0.00649447f, 0.41692561f, 0.25393620f, 
    0.26972595f, 0.50534385f, -0.05780344f, 0.12060089f, 0.32195449f, 0.43721080f, -0.20795362f, 0.02864175f, 
    0.01562316f, -0.38138539f, 0.08014783f, -0.15547724f, 0.34260783f, 0.51493561f, 0.42395556f, 0.53248745f, 
    0.57954943f, -0.77445728f, 0.21708363f, -0.50856090f, 0.31637093f, -0.02171524f, 0.09754173f, 0.18872216f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01992370f, 0.11516009f, 0.11348429f, -0.06135727f, -0.02037447f, 0.29568925f, 0.26991776f, 0.31437695f, 
    -0.08167572f, -0.06213483f, 0.30607027f, 0.08778994f, 0.37247515f, 0.04893381f, 0.18810484f, 0.18252416f, 
    -0.06187018f, -0.32591504f, 0.11390015f, 0.09553958f, -0.01399418f, -0.06011368f, 0.37735975f, 0.38976789f, 
    0.12316658f, 0.03304439f, 0.13815674f, -0.15866455f, 0.43491641f, -0.58000290f, -0.23909467f, 0.25481626f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00213589f, 0.00605684f, -0.00015392f, 0.00577320f, -0.03514671f, -0.01857858f, 0.01937851f, 0.02540944f, 
    -0.02066451f, 0.01417779f, 0.03212734f, -0.04164126f, -0.03613813f, 0.01081821f, -0.03790902f, 0.02781090f, 
    0.01589719f, 0.03433283f, -0.00672658f, 0.03004870f, 0.00870432f, 0.03466368f, 0.02777669f, -0.01031248f, 
    -0.03746826f, -0.03174936f, 0.02681691f, -0.03552911f, 0.01459726f, 0.03072575f, 0.03505890f, -0.02018620f, 
    -0.02290640f, -0.00473369f, 0.00073178f, 0.01646125f, 0.00427424f, -0.00775611f, -0.03909819f, 0.01124954f, 
    -0.02419728f, -0.00335293f, 0.01534088f, 0.01139722f, -0.03789634f, 0.02650568f, -0.00223165f, 0.01252494f, 
    -0.04018058f, 0.02829963f, -0.02134216f, 0.00103340f, -0.03956045f, 0.02576063f, 0.02203192f, -0.01735882f, 
    0.00593787f, 0.01927077f, -0.00357228f, 0.01571195f, 0.02386229f, -0.03707146f, -0.00992457f, 0.02073814f, 
    0.00004158f, 0.01518109f, -0.02959578f, 0.00898058f, -0.04446402f, -0.02795434f, 0.01052496f, -0.00668031f, 
    -0.01737590f, -0.00725659f, -0.00434326f, 0.03467097f, -0.02465206f, 0.00004743f, 0.02975279f, -0.04768500f, 
    -0.03057913f, 0.03060964f, -0.01156760f, -0.03145354f, 0.02505028f, -0.01755182f, -0.00329501f, 0.00828719f, 
    -0.02624876f, -0.02208347f, 0.01513378f, 0.00719212f, 0.01034182f, -0.00625043f, -0.00340480f, -0.03433165f, 
    0.03063961f, 0.01118658f, 0.02303751f, -0.04217966f, -0.00860492f, -0.01546987f, -0.00943540f, -0.00806760f, 
    -0.02569029f, 0.01004357f, 0.02230924f, 0.02710344f, -0.01843937f, -0.01695506f, 0.00216223f, 0.01374904f, 
    0.00756771f, -0.03461455f, -0.02413739f, 0.00066313f, 0.02642073f, 0.00761204f, 0.03007410f, 0.03319123f, 
    -0.01025294f, 0.01082822f, 0.02842065f, 0.00933724f, -0.00152688f, -0.01272525f, -0.02147727f, 0.01149505f, 
    -0.01990468f, -0.00634897f, 0.00715080f, -0.04304416f, -0.03831534f, -0.03688998f, -0.03956900f, -0.03430600f, 
    -0.02638855f, -0.01783867f, 0.03140759f, -0.04389257f, -0.01077802f, 0.01852154f, -0.00064519f, -0.01797327f, 
    -0.00560754f, -0.04476606f, -0.03900759f, 0.02618098f, 0.02799789f, -0.03965047f, -0.01415094f, 0.02534692f, 
    -0.02962842f, 0.00097865f, -0.02687952f, -0.04892075f, -0.00970078f, 0.01786239f, -0.03169740f, -0.01822463f, 
    0.00947412f, -0.01861720f, -0.01567636f, 0.00227036f, 0.03250650f, 0.00340528f, -0.00319912f, 0.00025901f, 
    -0.01506380f, -0.03592674f, -0.00323819f, 0.02143036f, -0.03563988f, -0.01816785f, 0.02373188f, 0.01531534f, 
    -0.02093608f, 0.02516802f, -0.02953051f, -0.00533567f, -0.04776908f, -0.03790510f, -0.02068841f, 0.00759414f, 
    -0.03999997f, 0.00959545f, -0.03589404f, -0.00951678f, 0.00479367f, 0.01611587f, 0.02111494f, -0.01485267f, 
    -0.03334077f, -0.01409580f, -0.03441763f, -0.00396737f, 0.02566282f, -0.02894814f, 0.01736094f, 0.01663569f, 
    0.03051586f, -0.03292701f, 0.01727731f, 0.00778331f, -0.04235883f, -0.02440371f, -0.03847935f, 0.01088879f, 
    -0.04448368f, 0.01356790f, -0.03294571f, -0.00856726f, -0.03549923f, -0.01199142f, 0.02443617f, -0.02818964f, 
    0.02261291f, -0.02865319f, -0.00943018f, -0.00127039f, -0.02444499f, 0.02410817f, 0.03161903f, -0.03607532f, 
    0.00090535f, -0.02102005f, 0.00580612f, -0.03437696f, -0.00589842f, -0.03877880f, -0.02559742f, -0.01481180f, 
    -0.04153789f, -0.00087238f, 0.02210720f, -0.03532118f, -0.02263997f, 0.01596140f, 0.00877923f, -0.03658112f, 
    -0.03182488f, -0.02033388f, -0.02003874f, -0.02213038f, 0.02136497f, 0.01628785f, 0.00421536f, -0.01819795f, 
    0.02965796f, 0.00367985f, -0.01669490f, -0.02917648f, -0.03378531f, 0.02557940f, -0.02187830f, -0.02973010f, 
    -0.02347680f, -0.02464638f, 0.01455812f, 0.02434706f, -0.03414640f, 0.02835779f, -0.02904352f, 0.00814180f, 
    -0.02387742f, 0.00667916f, 0.02805186f, -0.02464900f, 0.01882718f, -0.03498903f, -0.02864748f, 0.01093552f, 
    0.01069731f, 0.00075159f, -0.03579252f, -0.02969782f, 0.03147503f, 0.02960843f, 0.03039814f, -0.02582135f, 
    0.02548356f, -0.01685993f, -0.03959038f, -0.01647320f, -0.03413944f, 0.01313451f, 0.01440655f, -0.01102433f, 
    -0.02369030f, -0.02690567f, -0.00695474f, -0.01264832f, -0.03754637f, 0.01913652f, -0.04027218f, 0.02839319f, 
    -0.00630277f, -0.04327863f, -0.02130305f, -0.04152200f, 0.02905341f, -0.03240884f, -0.01958175f, 0.01785160f, 
    0.00389397f, 0.00131529f, -0.01702347f, 0.00815262f, -0.03796181f, 0.00604535f, 0.01187715f, 0.02408968f, 
    -0.01760962f, -0.03249641f, 0.01436921f, -0.02706211f, -0.01386866f, -0.01625895f, -0.04076263f, -0.03462947f, 
    0.00023771f, 0.00680635f, -0.00253916f, 0.02289672f, 0.01315525f, -0.04398807f, 0.00157491f, -0.03621191f, 
    0.02735038f, -0.02153156f, -0.01910412f, -0.00145244f, 0.02720591f, -0.00066911f, 0.01777744f, 0.01560903f, 
    -0.00406457f, -0.01271203f, 0.01298716f, 0.02761529f, 0.02199375f, -0.01013956f, -0.00818228f, -0.03025267f, 
    -0.04654861f, -0.00559840f, -0.03976259f, -0.00958126f, 0.00882524f, -0.01232552f, 0.01505849f, 0.00005258f, 
    0.01569125f, -0.01673377f, 0.03488339f, 0.02414998f, 0.00022795f, 0.01751772f, 0.02448182f, 0.00923848f, 
    -0.00483886f, 0.01939220f, 0.02414748f, 0.01317398f, -0.01370599f, 0.01087881f, 0.00948064f, 0.01858906f, 
    0.00005174f, -0.02256298f, 0.00454255f, -0.02612534f, -0.01255064f, 0.00071840f, -0.01104111f, -0.02870413f, 
    0.02860559f, -0.03120862f, -0.02369860f, 0.01124066f, 0.00624038f, -0.00922328f, 0.02434670f, -0.01337882f, 
    0.02221778f, -0.03792397f, 0.02411407f, -0.00783778f, 0.02529072f, -0.04097337f, -0.00736937f, -0.03813022f, 
    0.01719338f, -0.01024641f, -0.01615414f, 0.01170930f, -0.00127205f, -0.02785317f, -0.00054438f, -0.02466510f, 
    -0.02032659f, 0.00532021f, 0.02038755f, 0.00822645f, -0.00498587f, 0.00570018f, 0.01496915f, 0.01323973f, 
    0.00857581f, 0.03098794f, -0.00994838f, 0.02892579f, -0.00249920f, 0.00099162f, -0.02192603f, -0.03001237f, 
    0.01317875f, 0.01429787f, 0.01254422f, -0.04529456f, 0.00680928f, -0.01085783f, -0.04945584f, -0.01870043f, 
    -0.04206740f, 0.03268472f, -0.02114309f, 0.01409920f, 0.01230058f, -0.03648854f, -0.03061014f, 0.02973092f, 
    -0.00998860f, 0.01806973f, 0.02899124f, 0.01715667f, 0.03487043f, -0.01336129f, 0.02185357f, -0.04032828f, 
    0.00503109f, -0.03397961f, -0.03515542f, -0.02297559f, 0.00057410f, 0.02581266f, 0.02672914f, 0.01340472f, 
    0.02619307f, 0.02807993f, -0.04164605f, 0.01062437f, 0.03598091f, 0.02180111f, 0.00698324f, 0.03248918f, 
    0.01298258f, 0.00901704f, -0.02137991f, -0.01741898f, -0.00239090f, -0.02605643f, 0.01765804f, -0.00797149f, 
    -0.03363556f, -0.04411348f, -0.04203567f, 0.01152778f, 0.02779691f, -0.02312364f, -0.01459686f, -0.04686242f, 
    -0.00622934f, 0.01260156f, 0.03061380f, -0.01964551f, 0.02476484f, -0.03401811f, 0.02880759f, 0.01399472f, 
    -0.01076277f, -0.02887993f, 0.01179258f, -0.02886440f, -0.00568429f, 0.00716624f, -0.01861403f, -0.03730265f, 
    -0.02130033f, -0.01593177f, -0.01142789f, -0.03727162f, -0.00835438f, -0.03743375f, 0.01452426f, -0.02338078f, 
    0.03279180f, -0.02845034f, 0.02054160f, -0.01133515f, -0.01898196f, -0.00160106f, 0.02092854f, -0.04381618f, 
    0.01810760f, 0.00635278f, 0.01531852f, -0.01797636f, 0.01500345f, -0.02263493f, -0.03535468f, -0.02752228f, 
    0.01243891f, -0.00355621f, -0.01888778f, -0.01234762f, -0.04318526f, -0.04636594f, 0.02596171f, -0.04225602f, 
    -0.01441557f, 0.00439248f, 0.02861196f, 0.00398290f, -0.01486969f, 0.03258258f, 0.00346480f, 0.00431267f, 
    0.03355360f, 0.02980536f, -0.03687972f, -0.03674049f, 0.00046252f, 0.00758462f, 0.00979553f, -0.00479269f, 
    -0.02977890f, -0.02320071f, -0.01402001f, -0.02653261f, -0.01012412f, -0.02624156f, -0.03779975f, -0.03280383f, 
    -0.02593052f, -0.02528745f, 0.01217665f, -0.04205597f, -0.03984106f, -0.02082612f, -0.01123257f, -0.00690552f, 
    -0.00215957f, -0.00370279f, 0.01359150f, -0.02163860f, 0.03286858f, 0.01419808f, -0.03212876f, -0.03341819f, 
    -0.04281037f, -0.04334370f, -0.00620830f, 0.00633673f, -0.00121570f, 0.01912142f, 0.02445090f, -0.00410199f, 
    -0.02784931f, -0.03410096f, 0.00077661f, -0.03898005f, 0.02257549f, 0.00891031f, -0.03451449f, -0.01913877f, 
    0.00598622f, -0.02834817f, -0.03997482f, 0.02567554f, -0.01064936f, 0.02946298f, -0.02863822f, 0.03343540f, 
    0.00502690f, -0.03323134f, -0.01572712f, 0.01535632f, -0.02653429f, -0.03056016f, -0.00161426f, 0.00746800f, 
    -0.00158282f, -0.03497475f, -0.01129399f, -0.01636959f, 0.03389492f, -0.00712509f, -0.00657843f, -0.03399768f, 
    0.02760466f, 0.01403513f, 0.01809156f, 0.03147254f, 0.01972365f, 0.01134987f, 0.02524411f, 0.01640424f, 
    0.01448922f, -0.02819794f, 0.00406997f, 0.03439244f, 0.00330170f, -0.01856362f, 0.03241240f, -0.03076570f, 
    -0.02919289f, 0.04441991f, 0.01320756f, -0.01214649f, -0.02828467f, 0.01443897f, 0.01148206f, -0.00751577f, 
    0.00009860f, -0.01437633f, -0.02238128f, -0.03947860f, 0.01349351f, 0.02513665f, 0.03285094f, 0.03511776f, 
    0.01951903f, -0.03413143f, 0.03318739f, -0.03770952f, 0.02145167f, 0.00741963f, -0.01502695f, 0.00975749f, 
    0.18371169f, -0.19010749f, 0.23232457f, 0.13699073f, 0.17974961f, -0.09329788f, 0.01799096f, -0.04800645f, 
    0.05056932f, 0.06739721f, 0.03854041f, -0.01429588f, -0.08829252f, -0.01919416f, 0.05543194f, -0.15988967f, 
    -0.08540253f, 0.08181871f, 0.04863448f, 0.20976985f, 0.30146989f, -0.24878941f, 0.36657518f, -0.27181208f, 
    0.27499694f, 0.12209665f, 0.13445181f, -0.05063739f, -0.14365286f, -0.01461982f, 0.11910790f, 0.14615946f, 
    -0.01425184f, -0.07463509f, 0.09559247f, 0.04447464f, 0.06611948f, -0.07558449f, -0.10010211f, -0.09945655f, 
    -0.05445410f, -0.04861284f, 0.09783445f, -0.05379593f, 0.30823833f, -0.07190491f, 0.14889918f, 0.04138545f, 
    0.00551689f, -0.05768916f, -0.03948444f, -0.01210185f, -0.01067941f, 0.14414489f, -0.04407778f, 0.05568704f, 
    0.07057684f, -0.03192858f, -0.06323529f, -0.07292696f, 0.08492662f, -0.01427619f, 0.16648246f, 0.21227595f, 
    0.39029720f, -0.00627016f, 0.00456230f, 0.08434814f, 0.10123792f, -0.04056052f, -0.11917782f, 0.10290620f, 
    -0.02687029f, 0.03736454f, 0.04798504f, -0.10592665f, 0.03786759f, 0.01287306f, -0.00209279f, -0.08686141f, 
    0.02558989f, -0.00781149f, -0.11055513f, -0.06080808f, 0.28349635f, 0.18516229f, 0.05129221f, 0.08224877f, 
    0.02248671f, 0.08271462f, 0.04961814f, 0.03666656f, -0.02090999f, -0.01776796f, -0.01358634f, -0.09663279f, 
    -0.15833943f, 0.04432761f, 0.00772024f, 0.27608213f, -0.36650640f, 0.09684861f, 0.08591032f, 0.19600286f, 
    -0.16993333f, 0.08976309f, -0.07998036f, 0.17165543f, -0.02357042f, 0.00389679f, -0.15808624f, 0.07046081f, 
    -0.04733775f, -0.10306572f, 0.05920509f, 0.00028782f, 0.04307101f, 0.09357980f, 0.05546769f, 0.05067540f, 
    -0.06378330f, 0.05569789f, -0.23699316f, 0.04695404f, 0.19691105f, 0.02300649f, -0.05050547f, -0.16439514f, 
    0.06430805f, -0.09836436f, 0.03544259f, 0.00242896f, 0.03308232f, 0.11514660f, 0.01600672f, -0.01695941f, 
    -0.11923268f, -0.07449487f, -0.02882471f, 0.03367423f, -0.29295477f, 0.16582225f, -0.06329970f, 0.22654493f, 
    0.41797987f, 0.05912464f, -0.10215482f, -0.02609601f, -0.07117124f, 0.05712190f, -0.16708148f, 0.08221584f, 
    -0.03795547f, 0.10286722f, -0.03448313f, 0.00653492f, 0.05322959f, 0.00584615f, -0.03019286f, 0.05669774f, 
    -0.12929244f, 0.04720910f, 0.30693647f, 0.08785149f, 0.37518245f, -0.08597149f, -0.07124241f, 0.07107778f, 
    -0.17951339f, 0.25838420f, -0.05657832f, 0.05710521f, 0.14871714f, 0.06331642f, -0.18988295f, -0.16131318f, 
    0.04332781f, -0.06120722f, 0.06540789f, 0.00004618f, -0.21534988f, 0.45839211f, 0.30485395f, -0.21401463f, 
    0.21857058f, 0.16324608f, 0.15444246f, 0.04951711f, 0.14059238f, 0.20274013f, -0.05642731f, -0.07358273f, 
    -0.05707269f, 0.00078277f, 0.08636830f, -0.15782779f, -0.04555808f, -0.01125694f, -0.09374579f, -0.19143824f, 
    0.23125501f, -0.03150914f, 0.02739233f, -0.29154781f, 0.43615249f, -0.04121332f, 0.00947935f, -0.01808672f, 
    0.07233626f, -0.03249608f, -0.00668700f, 0.01377858f, 0.06049310f, -0.03465816f, -0.04673084f, 0.09924309f, 
    0.02519577f, 0.07547309f, -0.02491905f, 0.13130070f, 0.31377620f, -0.58110070f, 0.72987294f, 0.06988727f, 
    0.40461338f, 0.17229231f, 0.19109437f, 0.17255634f, 0.29676563f, -0.17297153f, -0.08759505f, -0.13301586f, 
    0.01527621f, 0.01484109f, 0.08868536f, -0.09815803f, -0.15413766f, 0.15074739f, -0.10999878f, 0.02966574f, 
    -0.11356937f, 0.24767278f, -0.08953413f, 0.17869976f, 0.42502308f, 0.05663850f, -0.03958832f, 0.06559652f, 
    0.01157461f, 0.09287555f, -0.04967412f, 0.09080087f, 0.02388121f, 0.04286884f, -0.02125728f, 0.02351246f, 
    0.01153396f, -0.01882551f, 0.04235439f, -0.13671066f, 0.02598769f, -0.08009991f, 0.16207838f, -0.11446644f, 
    -0.08842206f, -0.01644091f, -0.05289255f, -0.00461762f, -0.09649525f, -0.03098080f, -0.02452144f, -0.01116589f, 
    0.09062636f, 0.00191351f, 0.07849369f, 0.02016819f, 0.03792359f, 0.02129833f, -0.06196624f, 0.11191615f, 
    -0.20458733f, -0.19775863f, 0.26314369f, 0.00907463f, 0.05538370f, -0.05081215f, 0.02406312f, -0.04559075f, 
    -0.03555574f, -0.00952841f, -0.04321590f, 0.03752116f, 0.02082482f, -0.06656759f, 0.05289455f, -0.00782978f, 
    -0.05692704f, 0.00470548f, -0.01346532f, 0.06078385f, -0.18735760f, 0.31522802f, 0.01716330f, 0.23119657f, 
    0.06549643f, 0.13030718f, 0.08850829f, 0.26829055f, -0.18684635f, 0.10985267f, -0.03836204f, 0.02636597f, 
    0.06316302f, 0.02844490f, -0.01405567f, 0.05874637f, 0.07430749f, 0.19566914f, 0.02256697f, 0.16149706f, 
    -0.10623016f, 0.05466147f, 0.02729947f, -0.07293884f, 0.37935346f, -0.15567255f, 0.07132495f, -0.04343415f, 
    -0.06559827f, -0.09612413f, -0.08454508f, -0.03296916f, -0.00972679f, -0.05679455f, -0.07091389f, 0.11896384f, 
    0.00728555f, -0.01321221f, -0.05921504f, 0.07978533f, -0.31887743f, 0.18370865f, 0.22245382f, 0.13525075f, 
    0.44836503f, 0.18480456f, 0.16546854f, 0.09120603f, -0.19966191f, 0.16890085f, -0.12477858f, 0.07700394f, 
    0.09307498f, 0.10123514f, 0.07118107f, 0.03041031f, 0.07487225f, 0.07353275f, -0.04666576f, 0.07281652f, 
    -0.13774677f, 0.39049214f, -0.16345319f, 0.18258044f, -0.19236065f, 0.14470525f, -0.16203322f, 0.08500143f, 
    -0.12265910f, 0.03427745f, -0.06258126f, 0.07555958f, -0.03915956f, 0.07445972f, -0.08153051f, -0.02926929f, 
    0.01483615f, 0.00195763f, -0.08214224f, 0.04742472f, 0.02368821f, -0.52322209f, 0.46829134f, -0.13074423f, 
    0.25339088f, -0.16589032f, -0.01294161f, -0.09599916f, 0.08566409f, -0.08813018f, -0.02515395f, -0.02496660f, 
    0.01096093f, -0.05548738f, 0.01405704f, -0.04670407f, -0.13482794f, 0.10640904f, 0.00977028f, -0.11047471f, 
    -0.23643266f, 0.12452184f, -0.13386390f, -0.11522235f, -0.18674709f, 0.18143113f, 0.07613660f, -0.04603697f, 
    -0.01229751f, 0.03921093f, -0.04518487f, -0.15371992f, -0.00717044f, 0.03859805f, 0.09923233f, 0.03384442f, 
    -0.08478256f, 0.03201991f, 0.00935133f, -0.17411789f, -0.35335574f, 0.07000808f, -0.08521395f, 0.28797910f, 
    -0.31565258f, -0.01155558f, -0.01838190f, 0.20261137f, -0.10063790f, 0.00549405f, -0.14915620f, 0.07620008f, 
    -0.02455897f, -0.02001455f, 0.00475732f, -0.06480617f, -0.02169321f, 0.17034847f, 0.06470148f, 0.05526601f, 
    -0.00054747f, -0.05850583f, 0.01353198f, -0.09717833f, -0.15780362f, 0.01528773f, 0.07078190f, -0.10829698f, 
    -0.11121777f, 0.11622374f, -0.04733656f, -0.06487779f, -0.02127047f, -0.06269863f, 0.08848263f, -0.03446243f, 
    -0.02449566f, 0.10148490f, 0.06074500f, -0.07031723f, 0.64762121f, -0.19759203f, 0.17770444f, -0.11314838f, 
    0.26178518f, 0.23804350f, 0.16075368f, 0.16013834f, 0.14645909f, 0.02299572f, -0.17754252f, 0.10160529f, 
    0.11311539f, 0.06207870f, -0.01613268f, -0.10726871f, -0.02325976f, 0.04909839f, 0.03102033f, 0.02640290f, 
    -0.28136101f, -0.19699854f, -0.05440604f, -0.01094118f, -0.15718496f, 0.04067189f, -0.13248199f, 0.07822826f, 
    -0.04566269f, -0.02916609f, -0.01188092f, 0.04913833f, -0.01088991f, -0.12264559f, -0.08211396f, 0.14967160f, 
    0.07488546f, 0.08549019f, 0.03585219f, 0.12330742f, -0.08585594f, -0.14098872f, 0.09810942f, -0.07626231f, 
    0.33120739f, -0.08095594f, 0.04704596f, 0.04026562f, 0.06143056f, -0.03936064f, -0.01582418f, -0.02764986f, 
    -0.01914238f, -0.02846031f, 0.00208147f, -0.00362285f, -0.15480390f, -0.10852239f, -0.02552803f, 0.15374748f, 
    -0.16716480f, -0.14960720f, 0.13194773f, 0.09309649f, -0.02537499f, -0.03282068f, -0.02267641f, 0.03654464f, 
    -0.07660010f, -0.00039586f, -0.01778529f, -0.04832033f, -0.10000163f, 0.03716525f, 0.11674534f, -0.03205077f, 
    0.04914406f, 0.07884798f, -0.07154805f, 0.12522435f, -0.12855174f, 0.33219194f, 0.11811171f, 0.27350923f, 
    0.56009322f, 0.27617732f, -0.10597775f, 0.12481200f, -0.10697126f, 0.03824463f, -0.16104878f, 0.13043940f, 
    0.11667646f, 0.03038687f, 0.11791772f, 0.01016831f, 0.04014268f, -0.10955385f, -0.09514783f, -0.02728647f, 
    -0.43158978f, 0.46421283f, -0.27045459f, 0.40452927f, 0.15144040f, 0.04998124f, -0.00134961f, 0.04522014f, 
    0.01255422f, -0.13158365f, 0.00530407f, 0.06123032f, -0.02389546f, -0.00477977f, -0.00936163f, 0.08241276f, 
    0.13239159f, -0.15372221f, 0.21892771f, -0.02597096f, -0.12090307f, -0.25710273f, -0.06710955f, -0.21760650f, 
    -0.09427351f, -0.01602422f, 0.02200603f, -0.06660780f, -0.10729890f, 0.06899473f, -0.10419223f, -0.02708986f, 
    -0.00970131f, -0.08330043f, 0.09584387f, 0.10219605f, 0.12813509f, -0.04990637f, -0.12489161f, -0.20469120f, 
    -0.05265005f, -0.12501372f, 0.01446312f, -0.05712648f, -0.02163003f, -0.06022120f, 0.01220239f, -0.04702036f, 
    -0.06529292f, 0.01823745f, -0.01002345f, 0.07856421f, -0.06431931f, -0.17472419f, -0.04190855f, 0.05211471f, 
    -0.03641419f, 0.04853983f, 0.05435993f, 0.01997865f, -0.10610812f, -0.20488122f, -0.03572419f, 0.21346597f, 
    0.05520134f, -0.13054164f, 0.12852548f, -0.07083153f, -0.02553483f, -0.13880272f, 0.08630034f, 0.05180185f, 
    0.01556909f, 0.03792365f, -0.08130399f, 0.06355406f, -0.04299770f, 0.15827535f, -0.00562160f, -0.09158596f, 
    0.01199145f, -0.02645020f, -0.03385575f, 0.01605335f, -0.00911973f, -0.00277926f, 0.01960640f, 0.02553099f, 
    0.01415499f, -0.04380246f, 0.00640337f, -0.01433779f, -0.03429924f, 0.02093253f, 0.03036367f, -0.03716960f, 
    -0.04454321f, 0.02022303f, -0.01239295f, 0.00422591f, -0.02186202f, -0.04011459f, 0.04340979f, 0.00808811f, 
    -0.01375215f, -0.03535646f, -0.00166385f, 0.03211552f, 0.02872144f, 0.02460029f, -0.02493063f, 0.03220998f, 
    0.01118107f, -0.02320025f, -0.01653551f, 0.00932130f, -0.02793497f, 0.01241773f, 0.00609971f, -0.03629351f, 
    0.03217916f, -0.01016221f, 0.02342048f, 0.02704111f, 0.03653331f, 0.00139295f, -0.04397454f, -0.04718896f, 
    0.00815432f, -0.03120484f, -0.01390943f, 0.00549973f, 0.02109351f, -0.00986688f, -0.04968376f, -0.02366717f, 
    0.02162245f, -0.04071096f, 0.02589401f, 0.01350899f, -0.00186108f, -0.02656973f, -0.02025129f, -0.03112237f, 
    -0.00228256f, -0.03288032f, -0.03045784f, -0.00981317f, -0.01161308f, -0.01780331f, -0.05062077f, -0.04259673f, 
    -0.01083736f, 0.01306481f, 0.02044006f, 0.01169865f, -0.00089716f, -0.02767105f, -0.00589592f, -0.01484931f, 
    0.00783130f, -0.02008323f, 0.03220636f, -0.00291889f, -0.02663204f, -0.02762086f, -0.01282944f, 0.02231095f, 
    0.02372315f, 0.01204296f, 0.00682044f, -0.02367356f, -0.02607091f, 0.01820455f, -0.02345044f, -0.01337330f, 
    0.00778389f, 0.01445573f, -0.00773611f, 0.03010715f, -0.01915081f, 0.00597209f, -0.04438573f, -0.00109061f, 
    0.02673922f, 0.01572386f, -0.04147370f, -0.03389213f, -0.03449895f, 0.03400465f, -0.01555493f, 0.02043591f, 
    -0.01710647f, 0.02299532f, 0.01614489f, -0.00744957f, -0.00798734f, -0.02006683f, 0.00150424f, 0.01187565f, 
    -0.01268213f, 0.02390789f, -0.01512098f, 0.03145571f, 0.00423701f, 0.00325985f, 0.01042603f, 0.02496523f, 
    0.00815128f, 0.00181338f, -0.00239567f, 0.01250897f, -0.01781516f, -0.02007845f, -0.01781579f, 0.00635657f, 
    0.02105588f, -0.00276910f, 0.01158436f, -0.03993728f, 0.02129627f, -0.03000125f, 0.01371181f, 0.00399549f, 
    -0.03155458f, -0.02460585f, -0.02684602f, -0.03245870f, -0.01803839f, 0.02149195f, -0.01319638f, -0.02215370f, 
    -0.04294858f, -0.00825283f, -0.02610172f, 0.01672520f, 0.02260720f, -0.01081194f, 0.02509575f, 0.01547210f, 
    0.00489787f, 0.02685352f, 0.04358803f, 0.00765542f, -0.02019786f, 0.00528771f, -0.04556187f, 0.02606119f, 
    -0.01059795f, -0.03563093f, -0.04646977f, 0.00538594f, 0.02577555f, 0.00662182f, 0.00655927f, -0.04374827f, 
    0.02455267f, -0.00186033f, -0.03694065f, -0.00772916f, 0.02639551f, 0.01549859f, 0.04463324f, -0.01228307f, 
    -0.03092019f, -0.04285998f, -0.04348075f, -0.03109849f, -0.03650891f, -0.02668977f, 0.02409081f, -0.00881645f, 
    0.03703570f, -0.00187765f, -0.00632457f, 0.00897097f, 0.00542297f, -0.02910245f, 0.02055320f, -0.02264494f, 
    0.00601087f, -0.01961047f, 0.03207327f, 0.01069800f, -0.00768053f, -0.02802989f, 0.01831285f, -0.03875402f, 
    -0.02930957f, 0.02120665f, -0.01009699f, 0.01417063f, -0.03413531f, 0.01793993f, 0.00856288f, 0.01467560f, 
    0.01144339f, -0.00969329f, 0.01135352f, 0.03203791f, -0.00322254f, -0.00217037f, 0.01906028f, -0.03183543f, 
    0.01109264f, 0.01548964f, 0.02814829f, 0.00764674f, 0.03462962f, 0.01157251f, 0.01192113f, -0.01139908f, 
    -0.03721859f, 0.01461022f, -0.01162031f, -0.01099602f, -0.02384438f, -0.01354810f, -0.02656257f, 0.00988054f, 
    -0.04013341f, 0.00081840f, -0.00788213f, -0.00707212f, -0.00168570f, 0.01189386f, -0.00333709f, 0.03209011f, 
    -0.00585627f, -0.00824231f, 0.00506077f, -0.04076149f, -0.02899085f, 0.00990888f, -0.04255486f, -0.01265621f, 
    -0.01231216f, 0.02760814f, -0.01152214f, -0.01694638f, -0.04016149f, -0.03721473f, 0.00737332f, 0.01826939f, 
    -0.02971468f, 0.03021971f, -0.03205814f, 0.01560879f, 0.01300744f, -0.03184687f, -0.03376546f, -0.01645296f, 
    -0.00439625f, -0.03179000f, 0.02529476f, -0.03950613f, 0.01861750f, -0.01014015f, -0.00763220f, 0.00197136f, 
    -0.01878899f, -0.04584987f, -0.01775337f, -0.03371609f, -0.04240541f, -0.02780358f, 0.01745951f, -0.02138329f, 
    0.00707849f, -0.01847410f, 0.00221604f, 0.00134749f, -0.00993034f, 0.00523039f, 0.01407363f, -0.01052833f, 
    0.01454687f, -0.00257956f, 0.00305870f, -0.01513313f, 0.00633918f, 0.03317915f, -0.03156858f, -0.00521122f, 
    0.02599797f, -0.01247277f, -0.00188330f, -0.02343556f, -0.00371242f, -0.01675196f, -0.00530600f, -0.04154011f, 
    0.02142303f, -0.01027585f, -0.01966826f, -0.00331653f, 0.02434706f, -0.03094146f, 0.02745494f, 0.01031483f, 
    0.01590208f, 0.02301986f, -0.00777951f, 0.01974024f, 0.03844095f, 0.00459083f, -0.05454699f, 0.02735306f, 
    -0.00959782f, -0.00424431f, 0.03180541f, -0.01234729f, -0.03391516f, -0.03684226f, -0.01372256f, -0.03545251f, 
    -0.02836658f, 0.04129715f, -0.03483716f, 0.00786109f, -0.01584084f, 0.03032970f, 0.01278785f, -0.02580949f, 
    0.01461889f, 0.01027214f, -0.00483575f, -0.00735727f, 0.03091232f, -0.00257594f, 0.01283561f, 0.01279318f, 
    0.02289287f, -0.04042956f, -0.02276211f, -0.01031625f, 0.03034119f, 0.03158300f, -0.01999497f, 0.01410176f, 
    -0.00554762f, -0.00443242f, 0.01832414f, 0.01043519f, 0.01259097f, -0.00342250f, -0.00354116f, 0.03814722f, 
    -0.01433574f, 0.00696042f, -0.01819945f, 0.02752742f, 0.00947270f, 0.01593879f, -0.00555793f, -0.02379164f, 
    -0.00666912f, 0.03866152f, -0.03348167f, 0.01944219f, 0.00911996f, -0.02002474f, 0.03909051f, 0.02608775f, 
    -0.02241316f, 0.01703733f, -0.05260648f, 0.01432515f, 0.02899328f, -0.01257477f, 0.03503767f, 0.01373364f, 
    0.01778034f, 0.01891371f, -0.04163251f, -0.04041738f, 0.02088489f, 0.04073923f, 0.01255211f, 0.02686004f, 
    -0.00624722f, 0.01925681f, -0.01268140f, 0.00202971f, -0.05116962f, -0.00995432f, 0.01840536f, 0.01860430f, 
    0.01578340f, 0.00961458f, 0.02731930f, 0.01631236f, 0.00282559f, -0.02379320f, 0.02309003f, 0.03451988f, 
    -0.02997677f, 0.01616649f, -0.01221088f, -0.04643196f, -0.04948236f, 0.02800800f, 0.00550993f, -0.00092040f, 
    0.02808055f, 0.00268427f, -0.02191787f, 0.01802268f, -0.02603573f, 0.02445711f, -0.01972564f, 0.00070179f, 
    0.02544092f, -0.00771069f, 0.01436767f, -0.02352620f, 0.01135608f, -0.03177579f, 0.03169276f, -0.02859326f, 
    -0.04471222f, 0.02918699f, 0.01083663f, 0.03283453f, -0.02891060f, -0.03736195f, 0.01301040f, -0.03434721f, 
    0.02625091f, -0.03154833f, 0.00393598f, 0.03275068f, -0.02275393f, 0.03341585f, -0.03343571f, -0.01833980f, 
    0.02945410f, -0.02509495f, 0.04315585f, -0.03371986f, 0.00922849f, 0.01319388f, -0.02751092f, 0.00824626f, 
    0.02688294f, 0.01118224f, -0.04561787f, -0.00273653f, -0.00334986f, 0.00824384f, -0.04727649f, -0.01791516f, 
    -0.03821641f, 0.01608350f, -0.01461313f, -0.03901886f, -0.02497669f, 0.02334173f, -0.04161544f, 0.01936715f, 
    -0.04048312f, -0.01083403f, -0.01115771f, 0.01121986f, -0.01326989f, -0.00142928f, 0.00613074f, 0.02622228f, 
    -0.02640186f, -0.02177168f, 0.01702367f, 0.03212019f, -0.00536795f, -0.00838441f, 0.01268707f, -0.02438070f, 
    0.00166851f, 0.03014915f, -0.03222079f, -0.02280011f, 0.02577882f, 0.01425678f, 0.02405185f, 0.00929381f, 
    0.03342575f, 0.01560565f, -0.01746701f, -0.03539618f, -0.03227903f, 0.01760211f, -0.04179267f, 0.01454012f, 
    -0.02786686f, -0.04850817f, -0.01423378f, -0.02411460f, -0.03228667f, -0.00395015f, -0.00848345f, 0.02720016f, 
    0.02264127f, 0.02763996f, 0.02602378f, -0.00752693f, -0.04425240f, -0.00024558f, 0.01083710f, 0.01939230f, 
    -0.03355059f, 0.02786378f, -0.03657518f, -0.03861460f, 0.01098316f, 0.02694909f, -0.02685181f, 0.02871331f, 
    -0.00938550f, 0.03125851f, 0.02179567f, 0.01447192f, 0.00978880f, -0.03419477f, -0.00076882f, -0.02542832f, 
    -0.03185752f, -0.03997969f, -0.05760709f, 0.01751394f, 0.00465074f, -0.03670267f, 0.00722124f, -0.02284562f, 
    -0.04426406f, -0.00909631f, -0.00865661f, -0.01013567f, -0.03056323f, -0.01072196f, -0.02563744f, -0.00190166f, 
    0.02023572f, 0.01672659f, -0.00556442f, 0.03647383f, 0.02811881f, 0.02578435f, -0.02034950f, -0.01227433f, 
    -0.03073915f, -0.04659193f, -0.02642184f, 0.02384985f, -0.03763444f, -0.01633097f, -0.01566027f, -0.02885139f, 
    -0.03026257f, -0.01907171f, 0.03017214f, -0.00642470f, -0.01243106f, -0.01669310f, -0.03963648f, -0.00562421f, 
    -0.00758321f, 0.01396768f, 0.03148530f, -0.01491587f, 0.01213223f, 0.00072153f, -0.02825304f, -0.01587079f, 
    -0.03318524f, -0.01251548f, -0.01556350f, 0.00603338f, -0.04170356f, -0.01224657f, -0.03509000f, 0.00907003f, 
    -0.04069466f, 0.01774749f, -0.02218793f, 0.01122824f, -0.01041689f, -0.00449958f, 0.03386873f, 0.00393319f, 
    0.02841092f, 0.03566915f, 0.03584294f, -0.04013225f, -0.03940066f, -0.00971360f, 0.03871678f, 0.01032586f, 
    -0.03697673f, -0.02138916f, -0.00021788f, 0.03261969f, -0.02385298f, -0.04093759f, -0.03960790f, -0.02680171f, 
    0.00769723f, -0.03944029f, 0.04003813f, -0.02207108f, -0.02123766f, 0.01824895f, -0.04257342f, -0.02157421f, 
    -0.01294685f, -0.01378723f, 0.02603650f, -0.02955330f, -0.01431614f, -0.03506077f, 0.01458147f, 0.00379618f, 
    0.51730520f, -0.34316796f, -0.05240557f, 0.11525434f, -0.03888207f, 0.02194071f, -0.03477624f, 0.12659594f, 
    0.13876295f, -0.09929153f, -0.03287212f, -0.05811136f, 0.01680982f, 0.06152027f, 0.11462361f, -0.04167280f, 
    0.17319033f, 0.09081445f, 0.06624681f, 0.07898773f, 0.29454967f, -0.21145765f, 0.41378185f, -0.30301991f, 
    0.43357447f, 0.13770463f, 0.17410682f, -0.03610002f, 0.02291662f, 0.07916784f, 0.09484090f, -0.04299399f, 
    0.04555403f, -0.02062174f, 0.11414807f, -0.02822684f, -0.00999569f, -0.11313440f, 0.02210917f, -0.03739293f, 
    -0.28971288f, -0.05513708f, 0.21279304f, 0.06270023f, 0.04954436f, -0.06496551f, 0.14380659f, 0.05419870f, 
    -0.07500660f, 0.06340839f, -0.04903398f, 0.01573038f, 0.02337093f, -0.01312323f, -0.04199770f, 0.18142118f, 
    0.22317994f, 0.00611878f, 0.13958231f, 0.10777412f, -0.10991967f, -0.04741600f, 0.25039327f, 0.26991290f, 
    0.06194137f, -0.15301368f, -0.10146508f, 0.07855583f, 0.03554595f, 0.03184238f, -0.01215572f, 0.00008710f, 
    -0.02804957f, -0.10545097f, -0.07046049f, 0.06170898f, 0.09846362f, -0.13332674f, -0.00047672f, -0.01166159f, 
    -0.44847977f, -0.14913704f, 0.00409806f, 0.11317066f, 0.25211927f, -0.00451104f, 0.01558374f, -0.08352686f, 
    -0.17304437f, -0.03571101f, -0.06812967f, 0.04529329f, -0.06894171f, 0.08513710f, 0.05361656f, -0.09635469f, 
    -0.08602601f, 0.10182457f, -0.08485848f, -0.16133015f, 0.00374447f, 0.19878609f, -0.01110669f, 0.03187045f, 
    -0.16571194f, 0.00370263f, -0.02902383f, 0.09452208f, 0.08370073f, 0.06817251f, -0.07880873f, 0.13364610f, 
    -0.02254409f, -0.03186024f, -0.00434471f, 0.02791019f, -0.06350158f, 0.00890164f, 0.08908299f, 0.11476201f, 
    -0.35169327f, 0.02865402f, -0.14234513f, 0.31173995f, 0.05329917f, -0.06925242f, -0.04333247f, -0.05605371f, 
    0.04133493f, -0.12944707f, -0.02159340f, 0.04505648f, -0.03190224f, 0.05090837f, -0.02625057f, 0.01337511f, 
    -0.05284246f, 0.00867327f, -0.04688753f, -0.11695182f, -0.15025347f, 0.08476476f, 0.09194006f, 0.24009503f, 
    0.12304749f, -0.03010394f, -0.18688440f, 0.04857142f, -0.00740034f, 0.04893223f, -0.05673701f, 0.14368486f, 
    0.00721899f, -0.02801240f, -0.14579290f, 0.08745799f, 0.03915636f, 0.13221753f, -0.10824905f, -0.10473045f, 
    -0.22257033f, -0.14041801f, 0.16605376f, 0.32593364f, 0.31687486f, -0.12734096f, -0.06261966f, 0.26474506f, 
    -0.17849745f, 0.02001841f, -0.16876787f, 0.07719310f, 0.03274634f, 0.03149261f, -0.21860564f, -0.03554989f, 
    -0.00897039f, 0.03275489f, -0.08758770f, -0.08959579f, -0.14051771f, 0.04027635f, 0.32917291f, -0.08555456f, 
    0.00259032f, -0.09983891f, 0.00453521f, 0.10650533f, 0.02017979f, 0.19222857f, 0.04095452f, -0.18133669f, 
    -0.11416941f, -0.03709283f, -0.10032398f, -0.07180945f, -0.02770654f, 0.00597370f, -0.07467084f, -0.17209072f, 
    -0.36595327f, -0.12837270f, 0.07308315f, -0.13182446f, 0.41439262f, -0.26291919f, 0.05061137f, 0.13608067f, 
    0.02861737f, 0.06603032f, -0.00600985f, 0.08465114f, -0.05082630f, -0.04100335f, -0.03916612f, 0.00387025f, 
    0.01163849f, 0.09918772f, 0.00962269f, 0.06647670f, 0.23094837f, -0.99452698f, 0.45850602f, 0.05425549f, 
    0.21565184f, 0.25649565f, -0.01681597f, 0.02080157f, 0.37116563f, -0.04338792f, -0.05312911f, 0.02424222f, 
    0.07415019f, 0.04648208f, -0.00114657f, -0.15510927f, -0.16993159f, -0.00992312f, 0.07161713f, 0.12997387f, 
    -0.20860864f, 0.25928026f, 0.18797030f, 0.31291193f, 0.06354459f, -0.07147287f, -0.02110039f, 0.03846999f, 
    0.01005416f, -0.02038136f, -0.03801690f, -0.08154207f, 0.01306427f, 0.04288318f, -0.02395021f, 0.00726968f, 
    0.03431230f, -0.03068384f, -0.03006800f, -0.05615902f, 0.18304385f, -0.10564373f, 0.12938291f, 0.04384736f, 
    -0.06821346f, -0.03496430f, -0.03434153f, -0.04750877f, -0.00273691f, 0.06553549f, 0.00746348f, -0.07665104f, 
    0.00386827f, 0.07982894f, 0.09386336f, 0.02931806f, -0.10850745f, -0.19838271f, -0.03314753f, 0.03444059f, 
    0.38341928f, -0.10449311f, 0.16370480f, -0.07272055f, 0.03695228f, -0.10079446f, -0.03750509f, -0.00751237f, 
    0.00072338f, -0.02357426f, -0.05815699f, 0.03011351f, -0.00413617f, -0.00651612f, 0.13555306f, -0.05629511f, 
    -0.01046747f, -0.00821490f, 0.02992545f, 0.11314638f, -0.09906593f, -0.15330212f, -0.01453339f, 0.28269780f, 
    0.19441821f, 0.12446924f, 0.08924478f, 0.18896982f, -0.10003009f, 0.06285633f, 0.01867832f, 0.11603869f, 
    0.11110513f, 0.14732009f, -0.00220365f, -0.03697408f, 0.07799979f, 0.14571524f, 0.00217830f, 0.06074600f, 
    -0.20758608f, -0.14060821f, -0.29054990f, 0.08409607f, 0.29323754f, -0.00732672f, -0.02361220f, 0.04029383f, 
    -0.14941193f, -0.09523921f, -0.10611887f, -0.05646285f, -0.03173719f, -0.08807302f, -0.03130213f, -0.02807823f, 
    0.11138966f, 0.10079405f, -0.03216439f, 0.11016659f, -0.12063137f, -0.17422847f, 0.44650245f, 0.17651214f, 
    0.32249141f, 0.04755123f, -0.01992216f, -0.05850724f, -0.06373460f, 0.08924793f, 0.00076782f, 0.13203646f, 
    0.05869943f, -0.15170425f, -0.17656285f, 0.05502025f, -0.02404100f, -0.11053836f, -0.04489493f, -0.05457332f, 
    -0.10479004f, 0.10879024f, -0.14982602f, 0.19352993f, -0.28307971f, 0.11583808f, -0.11425748f, 0.17478628f, 
    0.06725731f, 0.20668481f, -0.13228016f, -0.00115456f, 0.07189670f, 0.13539310f, -0.17664461f, 0.03079238f, 
    -0.06891783f, 0.02114918f, 0.03390535f, -0.11503410f, 0.57888824f, -0.34138298f, 0.35973483f, -0.34874651f, 
    0.15370244f, -0.26678082f, 0.00277228f, 0.13769498f, 0.14926331f, -0.09018382f, -0.07828539f, -0.04071862f, 
    -0.00966844f, -0.00231559f, 0.05125820f, 0.02223745f, 0.01913158f, 0.03795795f, 0.00933282f, 0.04878014f, 
    0.27108714f, 0.14272992f, -0.00200265f, -0.09791750f, -0.07059249f, 0.04725694f, 0.00200790f, -0.07184767f, 
    0.01943477f, 0.07413622f, -0.06127959f, -0.06089472f, 0.12309790f, -0.06505092f, 0.08518401f, 0.12867963f, 
    -0.02065563f, -0.08508658f, -0.01204233f, -0.09887896f, 0.33592033f, 0.20277117f, -0.08359399f, 0.16093922f, 
    -0.28056538f, 0.01574858f, -0.04961698f, 0.20394729f, 0.00734309f, 0.03398610f, -0.12093949f, 0.06547338f, 
    -0.14243370f, 0.02824425f, 0.04946159f, -0.00544384f, -0.04465603f, 0.22298256f, -0.02736259f, 0.02526105f, 
    0.17826156f, 0.03231563f, 0.12537989f, -0.08434205f, 0.06669337f, 0.10453255f, -0.05541762f, -0.00345956f, 
    0.08264966f, 0.08161236f, -0.07334012f, 0.02101254f, 0.08062601f, 0.02055120f, 0.06705607f, 0.04098362f, 
    0.01610756f, 0.05661431f, 0.08629673f, -0.04326938f, -0.22436403f, -0.45904878f, 0.41810164f, -0.17714712f, 
    0.12389703f, 0.08337533f, 0.01182765f, 0.06956418f, 0.03968382f, -0.04145011f, 0.11512838f, 0.00501474f, 
    -0.04572357f, -0.01950857f, 0.10921926f, 0.05476387f, 0.03079452f, 0.00076006f, -0.01100852f, 0.08736202f, 
    0.22534876f, 0.07311690f, -0.04202293f, -0.07453962f, 0.05981224f, -0.01795585f, -0.06886644f, 0.06475255f, 
    0.05403267f, 0.05306349f, 0.02206311f, 0.08263112f, -0.00615578f, -0.03935900f, 0.02879566f, 0.11055943f, 
    0.00981103f, 0.00449481f, 0.08978327f, 0.03321278f, -0.18363051f, -0.08283459f, -0.07234311f, -0.01078141f, 
    0.20776059f, -0.01487987f, -0.02834165f, -0.07289351f, 0.07910463f, -0.03539598f, -0.13440831f, -0.03329748f, 
    -0.08288489f, -0.00725953f, 0.05125369f, -0.02488284f, -0.05902269f, 0.00525357f, 0.06614651f, 0.12692603f, 
    0.27391300f, -0.07508217f, 0.17689076f, -0.02991780f, -0.13817801f, -0.01067916f, -0.03188043f, 0.09052686f, 
    0.02509991f, 0.05750750f, -0.05529105f, -0.02976585f, -0.01681626f, 0.03366939f, 0.08347247f, -0.01539188f, 
    -0.00125352f, -0.05078550f, 0.00884571f, 0.10945445f, -0.01626118f, 0.07455628f, 0.55386269f, 0.28797141f, 
    0.09000810f, -0.00275349f, -0.29912886f, 0.03932227f, 0.12370245f, -0.09683610f, 0.05380291f, 0.10601879f, 
    -0.03508550f, -0.15134060f, -0.05812684f, -0.02670225f, -0.03626743f, -0.05231577f, -0.04276486f, -0.06120136f, 
    0.16733941f, 0.39540794f, -0.13633174f, 0.26015413f, -0.39309075f, 0.07838850f, 0.01389975f, -0.04908104f, 
    0.04849078f, -0.23249981f, -0.04164688f, 0.02637547f, 0.05684733f, 0.03097025f, 0.04712521f, 0.02078703f, 
    0.21855167f, 0.00293213f, 0.16982146f, 0.07304055f, -0.00515516f, -0.16150065f, 0.15068687f, -0.02185274f, 
    0.07724492f, 0.06008851f, 0.07444482f, 0.03493125f, 0.05681591f, 0.13205630f, 0.02715515f, 0.00237410f, 
    0.05959924f, -0.04787138f, 0.05918622f, -0.01300054f, -0.16370200f, -0.14449629f, -0.08716803f, -0.16442256f, 
    -0.12727930f, -0.05748851f, 0.05297445f, 0.03984295f, 0.05144803f, -0.08582360f, 0.06232661f, -0.00907723f, 
    -0.05250206f, 0.08044145f, -0.13716541f, 0.03287242f, -0.17883977f, -0.01558661f, 0.02023374f, -0.16632746f, 
    -0.19262518f, -0.09075609f, -0.05432812f, -0.14803819f, 0.13055469f, -0.13187595f, 0.26136494f, -0.01149324f, 
    -0.00814221f, -0.04698823f, 0.03266980f, 0.00664758f, 0.23415077f, -0.08914613f, -0.08485741f, 0.11280446f, 
    0.05324719f, 0.10437690f, -0.06147005f, -0.00605711f, -0.04656271f, -0.04139681f, 0.05767768f, -0.00565871f, 
    0.39421216f, 0.23097548f, -0.52479541f, 0.44403377f, -0.11256224f, 0.07516403f, -0.09684335f, 0.18273875f, 
    -0.17943259f, 0.02841091f, -0.06847137f, -0.02606353f, -0.05312949f, 0.01223282f, -0.02358182f, 0.00658185f, 
    0.06393194f, -0.03892573f, 0.06971817f, 0.03641295f, -0.40489715f, 0.10589410f, 0.00831430f, -0.00349880f, 
    -0.09541968f, 0.04707471f, -0.00150545f, 0.05769643f, 0.03718896f, -0.07543556f, 0.05030929f, -0.07835343f, 
    -0.08538062f, -0.05054393f, -0.08105686f, 0.00089662f, -0.06916086f, 0.09166256f, -0.05036762f, -0.06615643f, 
    -0.16013712f, 0.07692368f, 0.36364397f, 0.21259500f, -0.32172492f, -0.02925449f, -0.02565404f, 0.00866205f, 
    -0.04871280f, 0.03042916f, 0.02231878f, -0.00436636f, 0.02373607f, -0.00064230f, 0.17395535f, 0.13361081f, 
    0.04612080f, 0.15801592f, 0.01918824f, 0.18396705f, 0.07748222f, 0.02731330f, 0.26066300f, 0.28055415f, 
    -0.17418866f, -0.31221280f, 0.02907114f, -0.04772719f, 0.13759677f, -0.01948776f, 0.15316848f, -0.11757872f, 
    0.03406268f, -0.15884782f, 0.06102379f, -0.00680827f, -0.03102890f, 0.03312501f, 0.01257387f, 0.01869553f, 
    0.05947617f, 0.28023896f, 0.14445813f, 0.02945355f, -0.18464114f, -0.02223147f, -0.00761606f, 0.16426466f, 
    0.11492509f, 0.27886230f, -0.12543340f, 0.06810974f, 0.03649480f, -0.01809963f, -0.11890875f, 0.04892647f, 
    -0.10303333f, -0.12210319f, 0.00914236f, -0.22987938f, -0.03110398f, -0.18288527f, -0.24270993f, 0.10416303f, 
    -0.01735891f, 0.01248048f, -0.04851087f, 0.06973144f, 0.10126041f, -0.13052669f, -0.09318079f, 0.07939641f, 
    -0.08768384f, 0.02830055f, -0.07664553f, 0.03734448f, -0.01693088f, 0.09558030f, 0.10005472f, -0.02043933f, 
    0.11959260f, 0.12709892f, 0.21298690f, 0.00676335f, -0.19838494f, -0.06054913f, -0.19918656f, 0.01764757f, 
    0.04255066f, 0.12488729f, 0.03020297f, 0.00146987f, -0.01666943f, 0.00398478f, -0.01061215f, 0.13160923f, 
    -0.00130629f, -0.15018302f, -0.06039940f, -0.04532353f, 0.43043062f, 0.10124230f, 0.05866391f, 0.33901814f, 
    -0.18050545f, -0.15979455f, -0.00376782f, -0.14548935f, 0.03463978f, 0.02761233f, 0.02485602f, -0.03009915f, 
    0.02542313f, 0.01633773f, -0.04062942f, 0.12092337f, -0.05823289f, -0.05723779f, -0.05559457f, -0.02460378f, 
    0.37209007f, 0.04418607f, 0.09895699f, 0.47920612f, 0.06262691f, -0.15593038f, 0.00416340f, -0.12827441f, 
    -0.09455414f, -0.13738109f, -0.03140912f, -0.10630364f, -0.09732778f, 0.16988194f, 0.03291550f, 0.08817396f, 
    -0.06706533f, -0.02486205f, -0.26470599f, 0.06853221f, 0.33122519f, 0.12213312f, 0.50671178f, 0.20228359f, 
    -0.28155544f, -0.11524276f, -0.24413653f, -0.19135748f, 0.03317942f, -0.28601283f, 0.09897888f, -0.04643188f, 
    -0.04576674f, 0.01025741f, -0.00072843f, 0.04472413f, 0.07865329f, -0.02380352f, 0.00489533f, 0.00634510f, 
    0.03967499f, 0.09306875f, 0.20783991f, 0.16829439f, -0.06335153f, 0.04402699f, -0.10003753f, -0.18836711f, 
    0.00669488f, -0.12138816f, 0.04654489f, 0.03164394f, 0.10039119f, 0.10692018f, -0.00729293f, 0.03603558f, 
    -0.12988864f, 0.00098093f, -0.02145773f, 0.10990005f, -0.65642935f, 0.15738177f, -0.31444937f, -0.06133760f, 
    -0.35467622f, 0.03638403f, 0.05587491f, 0.18268594f, -0.04920453f, 0.32036698f, -0.01364061f, 0.06886738f, 
    -0.10069072f, 0.05157728f, 0.04115151f, 0.02101367f, 0.26399231f, -0.07879586f, -0.11640820f, 0.13134107f, 
    0.14028998f, 0.00757659f, 0.23642120f, 0.15093036f, -0.13678776f, -0.09008593f, -0.07833195f, -0.00588915f, 
    0.04649946f, -0.05755644f, -0.02293278f, -0.17517312f, 0.07182488f, -0.06075732f, -0.04820916f, 0.00104619f, 
    -0.07620797f, -0.05078010f, 0.00134309f, -0.06656180f, -0.26360020f, -0.05421948f, 0.03198251f, -0.02905768f, 
    0.04436700f, -0.06606723f, 0.14946350f, 0.14639136f, 0.07552686f, -0.05742394f, 0.09294827f, -0.02198249f, 
    -0.01583994f, -0.03476310f, -0.07646116f, 0.24746431f, -0.06561423f, -0.08424659f, -0.02771984f, 0.00025645f, 
    0.04177814f, 0.17229235f, -0.19880189f, 0.01592165f, 0.00440932f, 0.04501058f, 0.00789661f, 0.05812770f, 
    0.06509324f, 0.06168843f, -0.07440482f, 0.03805345f, 0.00535348f, 0.02110108f, -0.04100765f, 0.06243186f, 
    -0.04360956f, -0.07579222f, 0.05797933f, 0.00731287f, 0.00923781f, -0.17100795f, 0.09903340f, 0.03272382f, 
    0.05213206f, 0.01662972f, -0.01449382f, 0.07816725f, 0.05141724f, 0.03335591f, 0.06056511f, 0.02745452f, 
    0.04388608f, 0.03137379f, -0.01963413f, -0.04703410f, -0.00242381f, -0.05436683f, -0.00336808f, 0.18966417f, 
    0.00047398f, 0.03497978f, -0.18290190f, -0.06313917f, -0.19762246f, -0.07904732f, -0.03621871f, 0.08372590f, 
    -0.01599023f, 0.24159946f, -0.01656472f, 0.06931767f, 0.02753743f, -0.00135838f, -0.08917600f, -0.00261570f, 
    -0.04560273f, 0.00322961f, 0.08659244f, 0.17961521f, 0.24739259f, -0.13452470f, 0.39639094f, 0.35310489f, 
    -0.25341243f, -0.01893690f, -0.04311093f, -0.08729162f, 0.16083945f, -0.01467564f, 0.07940808f, -0.00424559f, 
    -0.08230281f, -0.10066462f, 0.03927204f, 0.09871794f, 0.13019282f, 0.02869132f, -0.00425948f, 0.13125573f, 
    -0.14158897f, -0.16669841f, -0.06912750f, 0.11587462f, 0.22724012f, -0.11622129f, 0.03126424f, 0.01623978f, 
    -0.11639045f, -0.08135789f, -0.21149966f, 0.09427773f, 0.00047453f, -0.01401014f, -0.00991869f, 0.22931202f, 
    -0.11392314f, 0.00500821f, -0.09078459f, 0.15809529f, -0.11957800f, 0.29675603f, -0.21104096f, 0.28265131f, 
    -0.04242957f, 0.02121832f, -0.11553086f, 0.04290180f, 0.01332118f, -0.01870494f, -0.07440680f, -0.06218133f, 
    0.00017242f, 0.01669982f, -0.02089323f, 0.05502329f, 0.20995662f, -0.09154852f, 0.15755646f, 0.00866428f, 
    0.18443793f, -0.06041136f, -0.05220698f, -0.05056009f, -0.15355177f, -0.02490327f, -0.03600129f, -0.01986175f, 
    0.07809729f, -0.04567884f, 0.08359292f, 0.10350622f, 0.08977235f, 0.11374702f, -0.00721593f, 0.01424684f, 
    0.11912555f, 0.12842278f, 0.09105652f, -0.03387799f, 0.25251344f, -0.12248871f, -0.10447836f, 0.13096161f, 
    0.18117587f, 0.01803337f, -0.04990079f, 0.07356878f, 0.02941794f, 0.03791434f, -0.03063544f, 0.06019735f, 
    -0.08691355f, -0.03075958f, 0.00929001f, 0.00654165f, 0.02134003f, 0.01879444f, 0.05968823f, -0.03069917f, 
    0.04368380f, -0.08137075f, -0.13746811f, 0.04446986f, -0.01532855f, 0.08819464f, -0.04362166f, 0.03808299f, 
    0.12316307f, -0.04324542f, -0.06909411f, -0.03382699f, 0.00338698f, -0.10693493f, -0.02997647f, -0.00877307f, 
    -0.05058688f, -0.02893674f, 0.11993924f, -0.00966299f, -0.11124883f, -0.16124299f, 0.25202978f, 0.24404384f, 
    -0.07527604f, -0.01092183f, 0.00195067f, -0.09446802f, 0.01029730f, 0.02176908f, 0.15530828f, -0.09361524f, 
    0.01403031f, -0.08016920f, -0.01008883f, 0.04639876f, -0.00380756f, 0.12001640f, -0.07132518f, 0.05480418f, 
    0.08885475f, -0.13567559f, -0.26505226f, 0.00756974f, 0.37663719f, -0.08211443f, -0.03304182f, 0.05750434f, 
    0.05454723f, -0.05358773f, -0.05235304f, 0.02007973f, 0.00512422f, 0.07093379f, -0.00858282f, 0.10806452f, 
    0.18837869f, 0.06910704f, 0.19981828f, 0.19346520f, 0.01213578f, 0.27287415f, -0.07366277f, 0.05659643f, 
    -0.13202998f, 0.00829784f, -0.01112233f, 0.00486668f, -0.01677257f, 0.36983937f, -0.13610891f, 0.04398078f, 
    0.03413264f, 0.05399241f, -0.09507681f, 0.11720093f, 0.15928049f, -0.07610732f, 0.05606309f, 0.08189018f, 
    0.09929697f, -0.00680773f, -0.14310661f, 0.30199486f, -0.00149481f, -0.00511897f, 0.01318203f, 0.16803436f, 
    0.01812414f, 0.03695597f, -0.11965570f, -0.02002911f, -0.03886956f, -0.00860530f, -0.02351269f, 0.02132107f, 
    -0.05283806f, -0.01987349f, 0.05451990f, -0.02244784f, 0.49230883f, -0.19517881f, 0.20554781f, 0.33810499f, 
    -0.26556402f, -0.23855759f, -0.05490911f, -0.23811609f, 0.10793736f, -0.10902817f, 0.07155717f, -0.11038104f, 
    -0.02615503f, -0.01883274f, 0.00753956f, 0.04921650f, -0.01448420f, -0.05205373f, 0.00438761f, 0.01488291f, 
    0.04918291f, -0.28452557f, 0.20046458f, 0.00019583f, -0.20054184f, -0.13867830f, -0.02401052f, 0.03886069f, 
    0.26053664f, 0.20491949f, -0.07419875f, -0.12035190f, 0.09881773f, -0.01635749f, -0.04748048f, -0.02021717f, 
    0.07294620f, -0.06470268f, -0.08444440f, 0.04690423f, -0.02139044f, -0.00860715f, -0.01586643f, -0.07429211f, 
    -0.02039006f, -0.01031445f, 0.04238645f, 0.06953549f, -0.00774005f, -0.05092458f, 0.13933636f, 0.15016860f, 
    0.11163493f, 0.06835023f, -0.10216778f, 0.14076410f, -0.00693727f, 0.08343196f, -0.03061222f, 0.00456655f, 
    -0.04290563f, -0.00960233f, 0.13557878f, 0.06073051f, -0.01411815f, 0.09078714f, 0.10099558f, -0.00581673f, 
    0.04021058f, 0.02735060f, 0.10099546f, 0.03960091f, 0.12463893f, 0.07338682f, -0.00931024f, -0.00663197f, 
    -0.19018614f, -0.09089134f, -0.08235919f, -0.02879154f, -0.32590839f, 0.07967975f, -0.06955763f, 0.18720815f, 
    -0.34011972f, -0.02255085f, -0.04013955f, 0.03588715f, -0.01144133f, 0.03964870f, -0.18159990f, 0.08369414f, 
    0.01979641f, -0.01425138f, 0.01377775f, -0.07869072f, -0.05752448f, -0.07072718f, 0.08764715f, -0.02470890f, 
    0.12261704f, -0.12945190f, 0.38605046f, -0.28752646f, 0.04755693f, -0.00529436f, 0.04403534f, -0.08826812f, 
    0.01970520f, 0.04127685f, -0.00394383f, 0.07958469f, -0.09352402f, -0.08902415f, -0.10110056f, 0.16856253f, 
    0.06115920f, 0.09230212f, 0.03966296f, -0.06196456f, -0.22201353f, 0.09430692f, -0.19831493f, 0.00523235f, 
    -0.09194351f, 0.03757381f, 0.01968126f, -0.03778698f, 0.05668532f, 0.03107725f, -0.03229045f, -0.14344479f, 
    0.04867471f, -0.03223938f, 0.04333705f, 0.12821697f, -0.07211662f, 0.00409802f, -0.09262694f, 0.07685556f, 
    0.02942842f, -0.15688199f, -0.18011944f, -0.00781550f, -0.03134879f, 0.06130520f, -0.10366847f, -0.10881276f, 
    0.06666170f, 0.07743150f, -0.00556538f, -0.08913414f, 0.13916545f, 0.08065131f, 0.06828048f, -0.09255340f, 
    0.17407669f, -0.03370488f, 0.04261630f, 0.17851450f, 0.07198870f, -0.12934636f, -0.07803213f, 0.00092476f, 
    -0.10740976f, 0.29705873f, -0.16928707f, 0.01168128f, 0.03211293f, 0.06141686f, 0.11427987f, -0.13890427f, 
    -0.00294701f, 0.06223087f, -0.02337991f, 0.00424998f, -0.02080449f, 0.01757995f, 0.06311890f, 0.05342177f, 
    -0.06617053f, -0.34360772f, 0.11402285f, 0.17615153f, 0.01550776f, -0.02230370f, -0.07899576f, 0.00976786f, 
    -0.14937983f, -0.13584532f, 0.05239660f, -0.00382843f, 0.01406245f, -0.14328137f, -0.04715796f, -0.02772900f, 
    -0.05295460f, 0.02668459f, -0.09746114f, -0.15405710f, 0.21689919f, -0.02062750f, 0.17093174f, -0.09440920f, 
    -0.06309651f, -0.01437206f, -0.00959573f, 0.05148444f, -0.14469664f, 0.00493559f, -0.03075724f, -0.06802092f, 
    0.12296637f, 0.03119248f, 0.03188279f, 0.07407239f, 0.06692302f, 0.01056651f, -0.06148815f, -0.06284569f, 
    0.17143139f, -0.16171020f, 0.20305352f, 0.17803562f, 0.01404571f, -0.00319436f, 0.01673870f, 0.14222658f, 
    -0.00660391f, 0.01547134f, -0.04293384f, 0.05924489f, 0.04396026f, -0.08374320f, -0.10809486f, -0.06409525f, 
    0.14947936f, 0.10773525f, 0.13894799f, -0.09345450f, 0.00713835f, -0.11375570f, 0.30713049f, 0.10926301f, 
    -0.11045890f, 0.08010259f, 0.00381175f, 0.02426389f, -0.00172615f, 0.07909221f, 0.06419925f, -0.04717520f, 
    0.02176722f, 0.02521166f, -0.09418058f, -0.05370752f, -0.01894148f, -0.02020400f, 0.05937660f, -0.10995911f, 
    -0.13831192f, -0.10280915f, -0.11349633f, 0.18925364f, -0.15671021f, 0.29475236f, -0.02964501f, -0.18695568f, 
    0.01462077f, 0.08153538f, 0.24931116f, 0.00038314f, -0.09711624f, 0.01476322f, 0.01271843f, -0.05510633f, 
    -0.08780177f, -0.04297585f, 0.10731548f, 0.00087175f, -0.55923027f, -0.27480441f, 0.01256199f, -0.15020543f, 
    0.10919189f, -0.07798545f, 0.06551349f, -0.04276876f, 0.03915251f, -0.03613963f, -0.02135973f, 0.10245728f, 
    0.04882269f, 0.13106576f, 0.14298280f, -0.08179905f, -0.08065797f, 0.07387077f, -0.02446534f, 0.15849677f, 
    0.07826783f, 0.30124936f, -0.02259776f, 0.31697568f, -0.03506028f, 0.06219271f, -0.05446134f, -0.00151148f, 
    -0.10208887f, 0.20973931f, 0.11881132f, -0.12884954f, -0.00080853f, -0.03504465f, -0.03193198f, -0.14690445f, 
    0.09318656f, 0.04247669f, -0.11784729f, -0.12481912f, 0.65419710f, 0.61273307f, -0.60222113f, 0.09789173f, 
    0.78038645f, 0.07111610f, -0.10136326f, -0.17071427f, 0.05469396f, 0.01636232f, -0.00306240f, 0.01903483f, 
    0.06495370f, -0.03687747f, -0.04455957f, 0.33212525f, -0.14863293f, -0.06169450f, 0.08934055f, -0.02181425f, 
    0.22152214f, -0.19383971f, 0.20586032f, 0.01080028f, -0.10227802f, 0.06926374f, -0.11781964f, -0.03966415f, 
    0.15677439f, 0.09300995f, 0.11328623f, 0.03640348f, -0.09594610f, -0.11886881f, 0.05162320f, -0.03216211f, 
    -0.04260132f, 0.06062273f, -0.08725123f, 0.02989633f, -0.11790828f, 0.11516691f, -0.25520289f, 0.07871713f, 
    0.05756187f, 0.15700436f, -0.00641189f, 0.00337428f, -0.06676070f, 0.03152691f, 0.06547681f, -0.03118591f, 
    -0.07569724f, -0.04628442f, 0.02664454f, -0.00462820f, 0.05733162f, -0.00765866f, -0.08114677f, -0.10960294f, 
    0.01032447f, 0.05882381f, 0.21205102f, 0.03388040f, 0.07148767f, 0.00558785f, 0.16884638f, -0.00186565f, 
    0.05364978f, -0.01748632f, 0.06831861f, -0.07292449f, -0.04071895f, -0.06191344f, -0.01918122f, -0.01478439f, 
    0.01027464f, 0.09366514f, -0.07903023f, -0.07509848f, -0.18309318f, -0.10565794f, -0.11160242f, 0.14652596f, 
    -0.09456351f, 0.01622633f, 0.07401010f, -0.07159773f, 0.03024627f, -0.07718877f, -0.05311675f, -0.01469566f, 
    0.01610738f, 0.14354898f, 0.10492422f, 0.24283528f, 0.19215634f, 0.09422173f, 0.11340128f, 0.14336236f, 
    -0.05711145f, -0.12042070f, 0.12046985f, 0.35556701f, -0.16168384f, -0.04250111f, -0.11620271f, 0.07079173f, 
    0.05420378f, -0.01374762f, 0.04977879f, 0.05492428f, -0.07517753f, 0.03642718f, 0.05412941f, 0.03330546f, 
    0.19233103f, 0.06339863f, 0.07378989f, 0.07534686f, -0.38475338f, -0.15722084f, -0.16482872f, 0.11639165f, 
    -0.08702678f, -0.18707426f, 0.05750348f, 0.05131077f, -0.03501976f, -0.08008579f, -0.08290642f, -0.11344821f, 
    0.09934199f, 0.18184723f, 0.03444555f, -0.09414552f, 0.07395446f, 0.05210876f, -0.01987029f, -0.09761084f, 
    0.09483913f, -0.10611880f, -0.02521924f, 0.14015661f, -0.19532757f, 0.08244360f, 0.11450155f, -0.04842449f, 
    -0.08477016f, -0.06986646f, 0.09082861f, 0.05445366f, -0.08353372f, 0.06503446f, 0.02015159f, 0.01023830f, 
    0.11313920f, 0.01997047f, 0.08946292f, -0.05522624f, 0.20041460f, 0.06768661f, -0.20227876f, 0.12558345f, 
    -0.09427281f, 0.17513892f, 0.07450769f, 0.03345528f, -0.03240704f, -0.01211052f, 0.04002361f, -0.05932656f, 
    -0.05193193f, -0.07554149f, -0.01117984f, -0.10074978f, -0.03885059f, 0.17587847f, -0.15126720f, 0.03776395f, 
    -0.67594081f, -0.20630752f, -0.08138595f, -0.18632850f, -0.04227523f, -0.10674498f, -0.05508185f, -0.00063987f, 
    -0.14279166f, -0.02431601f, -0.01093569f, 0.13139029f, 0.03421779f, -0.02688486f, 0.08761713f, 0.04642026f, 
    -0.02654287f, 0.02725758f, 0.09863622f, 0.08739228f, -0.44603273f, -0.13411793f, 0.13510063f, -0.28074995f, 
    0.08529191f, -0.08506661f, 0.03645818f, -0.17254545f, -0.00820043f, -0.10177831f, 0.12216066f, -0.06753746f, 
    0.00878388f, 0.01917533f, -0.16989438f, 0.25525561f, 0.10521833f, -0.11859193f, 0.02934234f, -0.10741671f, 
    -0.01529040f, 0.09333006f, 0.18148826f, -0.16322045f, 0.17032652f, -0.10446867f, 0.06716804f, -0.06755872f, 
    0.05990141f, -0.08641410f, 0.01213157f, -0.00608822f, 0.09823909f, 0.07898325f, -0.03920935f, 0.22135976f, 
    -0.01273522f, 0.03818902f, -0.18966348f, -0.03121357f, -0.07755069f, 0.21528900f, -0.24215052f, 0.18933375f, 
    -0.02797260f, 0.06325676f, 0.00842907f, -0.03800834f, 0.01211889f, 0.18336548f, 0.21557969f, -0.05846617f, 
    0.08807032f, 0.22706267f, 0.03792414f, -0.12901279f, -0.06088362f, 0.04783784f, 0.05724428f, 0.13964748f, 
    -0.10886935f, 0.10461367f, 0.11797394f, -0.10829111f, -0.24466559f, -0.05738986f, -0.07773380f, 0.06156974f, 
    -0.08744946f, 0.00113299f, -0.03753310f, 0.01739785f, 0.00277655f, -0.06729587f, 0.02218327f, -0.10133677f, 
    0.06053194f, 0.10780077f, 0.02149586f, -0.00738960f, 0.02981788f, -0.15892126f, 0.08453543f, 0.25965172f, 
    -0.00138237f, 0.08570784f, -0.03724632f, 0.07089812f, 0.02960709f, -0.07831728f, 0.12204428f, 0.00917502f, 
    -0.07079072f, -0.06475523f, -0.05310544f, -0.00355336f, 0.09401843f, -0.03362445f, 0.17392696f, 0.11160246f, 
    0.01019920f, 0.21721621f, -0.00229856f, -0.18020976f, 0.05389873f, -0.03918595f, 0.16016722f, -0.08056868f, 
    0.07353711f, 0.10227278f, 0.07916536f, 0.02285787f, -0.01173842f, -0.05571496f, -0.09403025f, 0.06142797f, 
    0.02126156f, -0.03061667f, 0.01800453f, -0.08608780f, -0.39793116f, -0.26144940f, 0.14690602f, 0.03794176f, 
    -0.12655038f, -0.11975805f, 0.01279891f, -0.11025498f, 0.05955734f, 0.13645780f, -0.02154111f, -0.05870567f, 
    -0.04811246f, 0.07604081f, -0.03745376f, -0.05246083f, 0.01356609f, 0.12029834f, -0.04824697f, -0.02722342f, 
    -0.20851903f, -0.20855319f, 0.59093249f, -0.33859548f, 0.07646069f, 0.05568667f, 0.14010888f, -0.00391536f, 
    0.06414929f, -0.02521288f, -0.02450953f, 0.07481671f, -0.06863847f, -0.03494361f, -0.07921586f, 0.16806428f, 
    0.01867653f, 0.19360982f, 0.04544680f, -0.10952327f, -0.12891114f, 0.02588543f, -0.03612216f, -0.04278123f, 
    -0.03287163f, 0.01638145f, -0.05493947f, -0.09709116f, 0.00268520f, 0.01129417f, 0.04926749f, 0.04198081f, 
    0.14856294f, 0.02665613f, 0.15620309f, 0.16208972f, 0.05152834f, -0.11710215f, -0.08473472f, -0.01522389f, 
    -0.01475823f, 0.03939575f, -0.15431406f, 0.15891716f, 0.07569381f, 0.02509483f, -0.19945008f, -0.09096403f, 
    -0.04451178f, -0.05535751f, -0.05036640f, 0.01155331f, 0.12558627f, -0.08938587f, -0.07100311f, 0.05827076f, 
    -0.09853297f, -0.02762708f, -0.16988716f, -0.19200021f, 0.25018206f, 0.08901149f, 0.12665910f, -0.24414696f, 
    0.11330192f, 0.06765679f, 0.12194934f, -0.04770479f, 0.03883569f, 0.10119302f, 0.08810834f, 0.02848671f, 
    0.03509274f, -0.02006663f, 0.13935189f, 0.14835089f, 0.10601950f, 0.05703913f, -0.07472934f, 0.00943035f, 
    -0.03260569f, -0.01344114f, 0.00041730f, 0.02532048f, 0.00568564f, 0.02256022f, 0.00313458f, -0.03805483f, 
    -0.04426394f, -0.04005146f, -0.03014530f, -0.03028202f, 0.01076308f, -0.02887668f, -0.00801982f, -0.00510384f, 
    -0.02215981f, -0.00688201f, 0.00343787f, -0.00427769f, -0.03067736f, -0.04515690f, -0.01804853f, -0.03126190f, 
    -0.03298536f, 0.01723603f, -0.03246855f, -0.02364812f, 0.01805641f, -0.00499704f, -0.00460144f, 0.01655041f, 
    0.03178906f, -0.03783063f, 0.00544133f, -0.01250772f, -0.02071778f, 0.01503165f, 0.02681451f, -0.02811077f, 
    -0.04483298f, -0.04006371f, -0.00358595f, 0.00072168f, -0.00937738f, -0.02052368f, -0.02197979f, -0.00184362f, 
    -0.01552268f, 0.02030288f, 0.01976101f, -0.01002158f, -0.02444474f, -0.04429992f, 0.02521359f, -0.01828295f, 
    -0.04433741f, -0.03095501f, -0.03890807f, 0.01515040f, -0.01189334f, 0.00093205f, -0.04508038f, 0.00838037f, 
    -0.01948739f, -0.03004719f, -0.04095751f, -0.02643466f, -0.03454902f, -0.03866472f, 0.00823531f, 0.00077699f, 
    -0.02322696f, 0.01868459f, -0.01724668f, -0.02670596f, -0.03817488f, 0.01150404f, -0.03413771f, -0.03057525f, 
    -0.03832868f, 0.03289887f, -0.02845488f, 0.02031486f, -0.01546093f, -0.01078707f, -0.01427497f, 0.00191322f, 
    0.03130525f, -0.01933795f, -0.03936020f, -0.00955115f, -0.03002753f, 0.02800724f, -0.01914905f, -0.04474598f, 
    -0.01326064f, 0.01779566f, 0.00233738f, -0.02356687f, -0.03189287f, -0.02327251f, 0.00188668f, -0.01613761f, 
    -0.00009263f, -0.02633073f, -0.00205474f, 0.02815882f, 0.00899257f, -0.03464816f, -0.00122550f, 0.02771798f, 
    -0.03303604f, 0.01244608f, 0.00758384f, 0.01182144f, 0.00685710f, 0.01503951f, -0.03886645f, -0.02695548f, 
    -0.02226056f, 0.02694385f, 0.02563355f, 0.02411931f, -0.04279339f, 0.02041179f, -0.02164817f, 0.00484669f, 
    -0.01713515f, -0.00428584f, -0.03461775f, -0.03052681f, -0.02191877f, -0.01502574f, -0.01338635f, -0.01565734f, 
    0.01959621f, -0.04179913f, -0.04511284f, 0.02136474f, -0.02225062f, -0.00736251f, -0.03500591f, -0.01792055f, 
    -0.00404548f, -0.00121789f, -0.03978809f, 0.02588595f, -0.02426000f, -0.03143253f, -0.04506444f, 0.02888127f, 
    -0.00305219f, -0.01306285f, -0.02460781f, 0.03186077f, 0.00062753f, 0.02874043f, 0.03184218f, -0.01121402f, 
    -0.02848171f, -0.01457766f, -0.02855994f, -0.04467393f, 0.01087085f, -0.04006336f, -0.02259455f, -0.02635967f, 
    -0.01607919f, -0.03633097f, -0.03438548f, -0.01039570f, -0.00506196f, -0.03608572f, -0.02847582f, -0.01938328f, 
    -0.01904974f, 0.02004069f, -0.01277943f, -0.02448788f, 0.02436236f, 0.00669801f, -0.01873620f, -0.01153978f, 
    -0.03515867f, -0.00055086f, -0.02144284f, -0.00355123f, 0.00362307f, 0.00136549f, -0.01912910f, -0.03755909f, 
    -0.04018591f, 0.02113403f, -0.01660185f, 0.02753196f, -0.00290996f, -0.00026155f, 0.01394763f, -0.00833775f, 
    0.01181306f, 0.02757747f, -0.02509751f, 0.03351945f, 0.02205822f, -0.01522720f, 0.03105082f, -0.00666160f, 
    -0.01551540f, 0.02289945f, 0.01063976f, -0.03102203f, 0.02982401f, 0.01117112f, -0.00825309f, 0.00491895f, 
    0.00474003f, 0.00898671f, 0.01375167f, -0.04406614f, 0.01818762f, -0.02664472f, 0.01778500f, 0.00529000f, 
    -0.01069592f, 0.02081306f, -0.01452866f, -0.02455320f, 0.00016574f, -0.01629656f, 0.00947820f, 0.01488904f, 
    -0.01045750f, 0.00110444f, 0.01445088f, -0.02622432f, -0.03750344f, -0.01425912f, -0.01989612f, -0.00278424f, 
    0.00583756f, 0.03050070f, -0.01997783f, -0.02445499f, 0.00386363f, -0.00050586f, -0.04094082f, 0.00697280f, 
    -0.01247345f, 0.01079013f, 0.01771680f, 0.03774495f, -0.02673036f, -0.02017608f, -0.01928701f, -0.03905191f, 
    -0.03140673f, -0.00206540f, -0.02744561f, 0.02400913f, -0.00408220f, 0.02750471f, -0.03987841f, 0.02282954f, 
    0.02500902f, 0.00353659f, 0.01495008f, -0.00162533f, -0.04160216f, 0.00502282f, -0.04033314f, -0.04022223f, 
    0.00691646f, -0.02126540f, 0.02934531f, 0.01165739f, -0.03268637f, 0.01011444f, -0.01172168f, 0.00666499f, 
    -0.01152769f, -0.01505629f, 0.01454338f, -0.03946797f, 0.01722770f, 0.00139962f, -0.04531631f, -0.03863664f, 
    -0.01238263f, -0.00126605f, -0.03635526f, -0.04000346f, 0.00682882f, 0.00415537f, 0.01974287f, 0.00457895f, 
    0.03259160f, 0.03024766f, -0.02601807f, 0.02479245f, -0.00962818f, -0.04312620f, -0.00859164f, 0.02612862f, 
    -0.00308216f, -0.00157322f, -0.02421279f, -0.03771924f, 0.02374564f, -0.00392955f, -0.03125656f, -0.02723241f, 
    -0.00391710f, 0.02616597f, 0.02181572f, -0.00803343f, 0.02898762f, -0.02846464f, -0.04156008f, 0.01861312f, 
    0.00073695f, -0.01277922f, -0.01488012f, -0.02251323f, -0.01846328f, 0.00566367f, -0.00123894f, 0.00089146f, 
    0.02030809f, 0.01937599f, -0.02976498f, -0.01348448f, 0.00450856f, -0.02578172f, -0.00418022f, -0.01949231f, 
    0.01342131f, -0.01644460f, 0.03326003f, -0.01548589f, 0.01560690f, -0.03226686f, 0.01968929f, -0.02179540f, 
    -0.02276305f, -0.02412121f, -0.00931506f, 0.01125659f, -0.01452094f, -0.03145409f, -0.01166730f, 0.03075735f, 
    0.00701546f, 0.02448885f, 0.01074767f, -0.01806285f, -0.01300984f, -0.02342646f, -0.00090928f, -0.02782911f, 
    -0.02397101f, 0.00721038f, -0.03122086f, 0.02272784f, -0.02013352f, -0.00135832f, 0.00722840f, -0.01056542f, 
    -0.02639898f, 0.00922720f, 0.00468063f, 0.01390219f, 0.00275225f, 0.00504936f, -0.02170180f, 0.01007244f, 
    -0.00020700f, -0.04230257f, -0.04178255f, -0.04210767f, 0.02093150f, -0.01729372f, -0.04444122f, 0.01044858f, 
    -0.02576230f, 0.02364498f, -0.03568974f, -0.00448775f, -0.03482841f, 0.00791875f, -0.02074575f, -0.01651101f, 
    0.00591177f, -0.01227739f, -0.01519242f, -0.03220063f, 0.03030161f, 0.01353745f, 0.00385851f, -0.04117900f, 
    -0.00801788f, -0.03178069f, 0.00981231f, 0.00240164f, -0.02692946f, -0.00306406f, -0.01140569f, 0.02700958f, 
    0.02046907f, -0.00376406f, -0.00177167f, -0.02828763f, -0.02727032f, -0.01285971f, 0.00260876f, 0.00602612f, 
    -0.03645381f, -0.02230742f, -0.03633419f, 0.03823676f, 0.03309879f, 0.00003549f, 0.02755529f, -0.04302001f, 
    -0.02873646f, -0.04118471f, -0.02172598f, 0.02299302f, -0.01053447f, 0.02037966f, -0.01459630f, 0.03268586f, 
    0.01374488f, -0.02376722f, -0.03744796f, 0.01173606f, 0.01694469f, 0.00136512f, -0.00991998f, -0.02375686f, 
    0.01949733f, -0.00654832f, -0.00331091f, 0.01563025f, -0.01438987f, -0.03717822f, -0.01355004f, 0.01144827f, 
    -0.01661761f, -0.04539062f, -0.00537364f, -0.03132611f, 0.00701252f, -0.03233732f, 0.00068709f, -0.02541138f, 
    -0.01330532f, 0.01993548f, -0.04019017f, 0.01308412f, -0.02899210f, -0.00197613f, 0.03229833f, 0.03139152f, 
    -0.00463147f, -0.01381840f, 0.00291484f, -0.04500353f, -0.03439820f, -0.03229854f, -0.03561243f, -0.00446692f, 
    -0.03320655f, -0.02043930f, -0.02885080f, 0.01056295f, 0.01131996f, -0.00377416f, 0.00678700f, -0.00964175f, 
    0.02475260f, -0.03844087f, 0.02017425f, -0.01458013f, -0.03887030f, -0.03635095f, -0.02011073f, -0.03679813f, 
    0.01899406f, -0.00453659f, -0.02790969f, -0.00927019f, 0.03039796f, 0.02874676f, -0.03216339f, 0.03308684f, 
    -0.02448091f, 0.00397205f, -0.01235666f, -0.03263066f, -0.01233983f, -0.01279952f, -0.02930583f, -0.02773528f, 
    -0.01382775f, 0.01237763f, 0.00021598f, -0.01846867f, -0.00045745f, -0.03789510f, -0.00492875f, -0.03324083f, 
    0.00645431f, -0.01326348f, -0.02369110f, -0.04056102f, -0.03403095f, 0.01460916f, -0.04398955f, 0.01293669f, 
    -0.01475488f, 0.01394082f, 0.00821142f, -0.01089247f, 0.02630201f, 0.02277164f, 0.02219749f, -0.01152736f, 
    -0.04247037f, -0.00701192f, 0.00307993f, 0.03048330f, 0.02976111f, 0.00633416f, 0.02038914f, 0.01744313f, 
    0.02294991f, 0.00338151f, 0.02980785f, -0.02613765f, 0.01669324f, 0.01426293f, 0.00980649f, 0.01244787f, 
    -0.03217575f, -0.03817070f, -0.00062045f, 0.02835421f, 0.00861107f, -0.03243325f, 0.01107309f, -0.00459419f, 
    -0.02703024f, -0.02851260f, 0.01274933f, 0.03105437f, -0.01195504f, -0.02455757f, -0.04199397f, 0.02597379f, 
    0.02430056f, -0.01265558f, -0.02540829f, -0.00704751f, -0.00918577f, 0.02831812f, 0.02329002f, 0.00393126f, 
    -0.00481854f, 0.01034558f, 0.03238407f, 0.02637303f, -0.04466737f, 0.02145432f, -0.04026588f, 0.02839588f, 
    -0.01783970f, -0.02995143f, 0.02424311f, -0.02130141f, -0.00628946f, -0.02735078f, 0.01986097f, 0.00295147f, 
    0.02462341f, 0.00733500f, 0.03245504f, -0.01572497f, 0.02285203f, -0.02396534f, 0.01298660f, -0.04382633f, 
    -0.04418881f, 0.03290026f, 0.03155379f, 0.00820589f, 0.02459054f, 0.01852153f, 0.00227455f, 0.00060114f, 
    -0.03785424f, -0.02100341f, -0.03522906f, -0.03652144f, -0.02678948f, 0.02351466f, 0.00986773f, -0.00628122f, 
    -0.02383887f, -0.02568250f, 0.01929628f, -0.03313463f, -0.01490348f, -0.03483643f, -0.02376763f, 0.03075099f, 
    0.02160781f, -0.03496258f, -0.02734350f, 0.00175677f, -0.03838882f, -0.01253934f, 0.00353119f, 0.02439168f, 
    -0.01842205f, -0.03058405f, 0.02345222f, -0.02879431f, -0.03203227f, -0.01581331f, 0.02778505f, -0.04268316f, 
    0.02416204f, 0.01880459f, 0.01375546f, 0.00862595f, 0.02237529f, -0.02697996f, 0.00336210f, -0.00350658f, 
    -0.03530460f, -0.02810702f, 0.03582826f, 0.00815652f, 0.01191316f, -0.04381783f, -0.02556764f, -0.03597676f, 
    -0.04597979f, 0.01221543f, -0.02454118f, -0.04302982f, -0.01104616f, -0.02799340f, -0.02534951f, 0.01856053f, 
    0.03455115f, -0.02644924f, -0.01644180f, 0.01683567f, 0.01136865f, -0.00197562f, -0.04008310f, -0.02703726f, 
    0.00134200f, 0.00942540f, 0.01856453f, 0.02054952f, -0.01370364f, 0.01713981f, 0.01742289f, -0.01938914f, 
    -0.00464162f, -0.03709806f, -0.03661143f, 0.01342057f, -0.01714532f, 0.01436891f, -0.01348681f, 0.02811378f, 
    0.04216899f, 0.03842800f, 0.00085148f, -0.00532207f, -0.00796389f, 0.03243116f, -0.00558271f, -0.00725020f, 
    -0.00323066f, 0.01696193f, 0.02856712f, -0.02338274f, -0.00236170f, -0.02382999f, 0.00542045f, -0.01401459f, 
    0.02635670f, -0.00301319f, 0.00147187f, -0.01397150f, -0.01485233f, 0.02691759f, -0.02659149f, 0.03548561f, 
    -0.01132343f, -0.04215165f, 0.03051545f, -0.03289643f, -0.04626067f, -0.01541126f, -0.02677771f, -0.03675510f, 
    -0.03075725f, -0.03529389f, -0.03900622f, 0.02662973f, -0.00629003f, -0.00916056f, 0.02538227f, 0.02693073f, 
    0.01202419f, 0.03440709f, 0.01795866f, -0.00149409f, -0.00287759f, -0.00020267f, 0.01113962f, 0.02078221f, 
    0.01751825f, -0.01981633f, -0.00652729f, -0.04066076f, -0.00430037f, -0.00939283f, -0.03397610f, 0.02843393f, 
    0.02191626f, 0.02548004f, 0.01524805f, 0.00708819f, 0.01193016f, -0.03829303f, 0.01883999f, -0.00253295f, 
    -0.03507242f, 0.01757243f, -0.04444797f, 0.01564817f, -0.04239196f, -0.00288357f, 0.01324871f, -0.03379757f, 
    -0.00170990f, -0.03346071f, 0.01844125f, -0.01830096f, -0.03151369f, 0.02974227f, -0.01997649f, 0.01541876f, 
    0.00419079f, 0.01857083f, -0.01812276f, -0.01663166f, 0.00174904f, 0.00987822f, -0.01590688f, -0.02180772f, 
    0.02784266f, -0.03782460f, 0.03105040f, -0.00110528f, -0.02021204f, -0.00586333f, 0.01546106f, 0.01995673f, 
    0.02112992f, 0.00362406f, -0.03217613f, 0.01034670f, -0.02193607f, -0.01605327f, 0.00944040f, 0.00997197f, 
    -0.01183327f, -0.03926613f, 0.00423317f, -0.04279582f, 0.02707910f, -0.00990547f, 0.00917051f, 0.04454985f, 
    0.02068317f, -0.02109129f, -0.01894538f, -0.02238063f, 0.00241768f, -0.00641998f, -0.03135798f, -0.03201289f, 
    0.01436260f, -0.03548527f, 0.01663976f, -0.01264976f, 0.02991333f, 0.02151765f, -0.04515092f, 0.02661004f, 
    -0.01595710f, 0.00763012f, -0.02371841f, 0.03773628f, -0.01573727f, 0.01877107f, -0.04599741f, -0.00669241f, 
    -0.03776675f, -0.03613875f, 0.00952723f, -0.00143812f, -0.03027448f, -0.00096212f, 0.01296758f, -0.03081818f, 
    -0.00053050f, -0.01641573f, 0.00881958f, -0.03638973f, -0.01769428f, -0.04604582f, -0.03983287f, 0.00854470f, 
    0.00143920f, -0.04016024f, -0.01041142f, -0.00442952f, 0.02743028f, -0.01284462f, -0.00101318f, -0.03451663f, 
    0.00429496f, 0.02657877f, 0.00792260f, -0.03010214f, 0.00362783f, -0.02988794f, 0.02080540f, -0.00015162f, 
    0.01428698f, -0.02096826f, -0.01501363f, 0.00388328f, 0.02255135f, -0.03137850f, -0.04259537f, 0.01499897f, 
    -0.00931764f, -0.02313988f, 0.00671155f, -0.01781289f, -0.04155784f, -0.01998970f, 0.01826816f, -0.01501453f, 
    -0.03873864f, -0.02801837f, -0.00117668f, 0.00864909f, -0.03030649f, -0.00448174f, -0.01004727f, 0.00570921f, 
    -0.02703929f, 0.00893796f, -0.01936440f, -0.03043553f, 0.01930949f, -0.03919434f, -0.01752308f, -0.00234211f, 
    0.02405995f, -0.01902333f, 0.02800377f, 0.01407893f, -0.01967854f, -0.02409613f, -0.02218598f, -0.03699267f, 
    0.00562460f, 0.01886241f, 0.02400079f, 0.03113636f, -0.03083542f, 0.01760832f, 0.01921879f, 0.00381253f, 
    -0.00535595f, 0.00378428f, -0.04502647f, 0.00562839f, 0.02700627f, 0.02475993f, -0.05049201f, 0.01394469f, 
    -0.03544271f, -0.02348696f, 0.01123525f, 0.02615056f, 0.00891821f, 0.01432152f, 0.00060539f, -0.03884472f, 
    -0.01122180f, 0.03201137f, -0.02713172f, -0.03638231f, 0.00144118f, -0.03399609f, -0.00463767f, -0.03330259f, 
    0.02329959f, -0.04347467f, -0.00426803f, -0.02102302f, 0.01684698f, -0.00446650f, -0.00834330f, 0.00102263f, 
    0.02416567f, 0.00988242f, 0.01585488f, 0.02991549f, -0.00028927f, -0.04426892f, -0.03410057f, 0.01171149f, 
    -0.03023186f, 0.00401085f, 0.01832384f, 0.02662211f, -0.01094755f, -0.02462643f, 0.03484506f, -0.04257047f, 
    -0.01361205f, -0.01028117f, 0.03233301f, 0.02478281f, 0.02312016f, -0.02652475f, 0.00391034f, 0.00186131f, 
    -0.02738418f, -0.02082406f, -0.00346910f, -0.00831930f, 0.02790347f, -0.00373423f, -0.00008600f, 0.00672779f, 
    0.01586368f, -0.00727251f, -0.00409125f, 0.02711367f, -0.01051583f, -0.01871676f, 0.03331450f, -0.03390937f, 
    -0.02925552f, -0.00938987f, -0.04883074f, -0.02100042f, 0.00950181f, 0.03302582f, 0.00836379f, 0.00105458f, 
    0.01541160f, -0.01617931f, 0.01193852f, -0.04225091f, 0.04561580f, -0.03407002f, -0.00722603f, -0.01297715f, 
    0.00510904f, 0.02503202f, -0.00646931f, 0.02759195f, 0.00228190f, -0.01484007f, 0.00087642f, 0.04284840f, 
    0.02896163f, 0.02497795f, -0.03807120f, -0.01728486f, 0.00069553f, 0.01639177f, -0.04796235f, -0.00002175f, 
    -0.01901319f, 0.02309729f, 0.00786742f, -0.03160615f, -0.00427644f, -0.04302403f, 0.00400926f, -0.00865504f, 
    -0.01919279f, 0.02229379f, -0.00796230f, -0.04571377f, -0.04340084f, -0.01322456f, -0.01030077f, 0.02190553f, 
    -0.00781020f, -0.00749867f, 0.02376709f, 0.02605298f, -0.02294910f, 0.00738675f, 0.01507205f, 0.00063207f, 
    0.00094085f, -0.02445463f, -0.03134221f, 0.02170909f, -0.01298959f, 0.02695591f, -0.04558208f, 0.02309310f, 
    -0.00252878f, -0.01533826f, -0.01689091f, 0.01941933f, -0.03185589f, -0.04815258f, 0.00362974f, 0.02531903f, 
    -0.00206272f, -0.00140340f, -0.00908400f, -0.03244789f, 0.01274756f, -0.00944629f, -0.01710076f, 0.02049879f, 
    -0.02809484f, -0.02803583f, 0.02345079f, -0.00006077f, -0.01570564f, -0.01054282f, 0.01734447f, 0.02666961f, 
    -0.04000010f, 0.01579986f, -0.01914224f, -0.04174941f, 0.02838330f, -0.02473431f, -0.04852839f, -0.01501812f, 
    0.00398951f, -0.01396576f, -0.01388481f, -0.01625720f, 0.02998372f, 0.02404094f, 0.01779308f, 0.01099623f, 
    -0.04026786f, 0.02879233f, 0.02116399f, 0.00738738f, -0.04336722f, -0.01313803f, 0.00970616f, 0.01678610f, 
    -0.05077773f, -0.01891341f, 0.00662651f, -0.03827976f, -0.00068304f, 0.02529810f, -0.04750309f, 0.02413111f, 
    -0.04171765f, -0.04588758f, -0.04764512f, -0.04305153f, -0.01956515f, 0.01214174f, 0.00105116f, 0.00306581f, 
    0.01271719f, 0.01475949f, 0.02383619f, 0.00601265f, 0.00804394f, -0.04577427f, -0.00723328f, -0.02089590f, 
    -0.04283047f, -0.01025424f, 0.03014403f, 0.02950233f, -0.02282323f, -0.01769675f, 0.02512383f, -0.00549343f, 
    -0.01668339f, -0.03098353f, -0.01181538f, -0.02888790f, -0.04518968f, -0.04165352f, 0.01833943f, 0.02810585f, 
    0.00201240f, 0.02858885f, -0.01305982f, -0.01923541f, -0.01698316f, -0.00684968f, 0.00544997f, 0.00222546f, 
    -0.02305817f, -0.03336721f, 0.02943393f, 0.02846134f, -0.04030565f, -0.01116276f, -0.00736124f, -0.01023350f, 
    -0.00178256f, 0.01329728f, -0.00847718f, -0.04506550f, 0.02324099f, 0.02224530f, 0.01893584f, -0.02633633f, 
    -0.00520190f, -0.00572378f, -0.00670554f, 0.02497303f, -0.02060072f, 0.00803791f, -0.02787507f, 0.03072281f, 
    -0.03588546f, 0.03032832f, 0.01113683f, -0.02652870f, 0.01989683f, -0.02863214f, 0.01249184f, 0.02467291f, 
    -0.01226728f, 0.00705827f, -0.00409942f, -0.00137909f, 0.02585250f, -0.03995156f, -0.03545438f, 0.00172785f, 
    0.00082743f, -0.02268703f, 0.02755469f, -0.03142968f, -0.01346057f, 0.02988333f, -0.00756767f, 0.01254487f, 
    0.02084312f, -0.03914170f, -0.00957433f, -0.01213025f, 0.02798981f, -0.01583746f, -0.00169169f, 0.01789329f, 
    -0.01241377f, 0.01443252f, -0.00295665f, -0.00104286f, -0.02071276f, 0.02913727f, 0.00974450f, 0.02321262f, 
    -0.01892277f, 0.04029658f, 0.00479499f, 0.02604543f, 0.00959777f, -0.03753909f, 0.01806134f, -0.04507058f, 
    -0.00727714f, 0.04053838f, -0.02951687f, 0.01621443f, -0.03407889f, -0.02327689f, -0.02442286f, 0.00077615f, 
    0.00148958f, 0.00253431f, -0.00327814f, 0.01297546f, 0.02734554f, 0.00337548f, 0.02450956f, -0.00264341f, 
    0.01393882f, 0.01345213f, -0.04446831f, 0.01719858f, 0.00407308f, -0.00493236f, -0.00811188f, -0.04151957f, 
    -0.01472002f, -0.00031927f, -0.01743065f, 0.01985226f, -0.00529953f, -0.00517610f, 0.01824070f, 0.02497217f, 
    -0.04345533f, -0.04252555f, -0.00991587f, -0.02254498f, -0.04172733f, -0.01450643f, -0.03298749f, 0.01443467f, 
    0.01705906f, -0.04362941f, 0.01055050f, 0.00351154f, -0.00647128f, -0.01177968f, -0.00020318f, 0.02016737f, 
    -0.04056411f, -0.03614170f, -0.03455847f, -0.01240529f, 0.02117662f, -0.02551140f, -0.01248654f, 0.01594189f, 
    -0.01359965f, 0.01847860f, 0.01429157f, 0.01931020f, -0.03672490f, 0.02023581f, 0.01976865f, -0.00582820f, 
    -0.00557628f, -0.04650720f, 0.02586007f, -0.00179237f, -0.00005676f, -0.01931814f, -0.04339492f, 0.02528533f, 
    -0.02752940f, 0.00013178f, 0.00633150f, 0.01564286f, -0.04157952f, -0.00162533f, 0.02223696f, -0.04487315f, 
    0.16774029f, 0.20993406f, 0.36258632f, 0.16988344f, -0.22187397f, 0.13095805f, -0.10160075f, -0.11535007f, 
    0.18935964f, -0.16484295f, -0.17985205f, 0.00672448f, -0.05715448f, -0.08829163f, -0.08495689f, -0.06409172f, 
    -0.05419419f, -0.06857774f, -0.17132050f, 0.07270610f, 0.39314708f, -0.05966764f, 0.46890536f, 0.05967277f, 
    -0.07908804f, 0.14156720f, -0.06139325f, 0.01685314f, 0.11472791f, -0.05124599f, -0.16988745f, -0.00996617f, 
    0.01422478f, 0.10240980f, -0.00407754f, 0.08129536f, 0.19568828f, -0.12438808f, 0.02442919f, 0.14038792f, 
    0.05661406f, 0.11989199f, 0.19669537f, -0.33904696f, 0.01572016f, 0.02218908f, 0.06507115f, 0.09121831f, 
    0.03648986f, 0.03117668f, 0.06279680f, 0.02767688f, 0.03175408f, 0.18885352f, -0.03055462f, 0.28869054f, 
    -0.03850284f, -0.04034096f, 0.10893952f, -0.07713930f, -0.10195377f, 0.02896458f, 0.06109134f, -0.18320692f, 
    0.03359799f, 0.07908789f, 0.00255385f, 0.12243234f, -0.16677950f, 0.09548492f, 0.04784640f, 0.02902618f, 
    0.00091881f, -0.04758640f, 0.05705017f, 0.16731414f, 0.09692756f, -0.10916641f, 0.07214828f, 0.03506890f, 
    0.17550510f, 0.16702965f, 0.19930543f, 0.06596649f, -0.24007161f, -0.07013126f, -0.14717644f, -0.21226262f, 
    -0.00160985f, -0.03830176f, -0.06494886f, 0.07808330f, 0.08556803f, 0.03345811f, 0.01885837f, -0.04169786f, 
    0.08147234f, 0.01549495f, 0.18388520f, 0.37028059f, 0.13693960f, 0.11574821f, -0.03020730f, 0.17129590f, 
    -0.01924351f, -0.10273483f, -0.07903004f, -0.03423586f, 0.13635343f, -0.07378238f, 0.00492876f, -0.03362074f, 
    -0.09013390f, -0.04617565f, -0.07636131f, 0.06093192f, 0.13919753f, -0.03081428f, -0.00763567f, 0.08014993f, 
    0.22598542f, 0.19597436f, -0.19235419f, 0.06250325f, 0.11467105f, 0.10314969f, 0.03350127f, -0.01372578f, 
    0.00087727f, 0.15200941f, -0.04037145f, 0.01697863f, 0.07183342f, 0.10775788f, -0.07011638f, 0.04096682f, 
    -0.00835783f, 0.01240518f, -0.06023303f, 0.28225335f, 0.09624501f, 0.07414191f, -0.55118096f, -0.10390662f, 
    -0.09573524f, 0.04603034f, 0.07317165f, 0.26140323f, -0.05460844f, 0.07616962f, 0.01548585f, -0.08464409f, 
    -0.04770339f, 0.05332872f, -0.01184145f, -0.03883815f, 0.02039384f, 0.11469328f, -0.01556475f, 0.11282918f, 
    -0.11125334f, -0.06219813f, -0.55350661f, -0.04593410f, -0.02798267f, -0.05274623f, 0.13405938f, 0.30919570f, 
    0.09642952f, 0.24921384f, 0.09200698f, 0.02109079f, -0.06998342f, -0.01431423f, -0.11368519f, -0.01598709f, 
    -0.00848898f, 0.15284224f, 0.07323521f, 0.02391084f, -0.14860019f, -0.85910237f, -0.58895916f, -0.04339793f, 
    -0.21691559f, -0.02979416f, 0.12827051f, 0.10079086f, -0.02772747f, 0.00815838f, 0.23191039f, 0.06605439f, 
    0.05263219f, 0.03684210f, -0.00839237f, -0.01908950f, -0.00335595f, -0.01850300f, 0.00219291f, -0.11598662f, 
    -0.09211543f, -0.29421616f, -0.42811975f, -0.20511416f, -0.12541915f, 0.06849493f, 0.19908141f, 0.17225564f, 
    0.05131721f, 0.08568417f, 0.03084197f, -0.02261168f, -0.13843775f, 0.04998150f, -0.15371101f, 0.03392376f, 
    0.04312008f, 0.05973676f, 0.02529444f, 0.02705910f, 0.18545549f, -0.37445876f, 0.37253794f, 0.42036620f, 
    -0.11488570f, -0.11210934f, 0.33056632f, -0.22910307f, 0.26537490f, -0.08243731f, -0.25036615f, 0.03632678f, 
    -0.15162586f, 0.02761278f, -0.05983488f, 0.03831084f, 0.06430449f, -0.15899892f, 0.22122294f, -0.00204916f, 
    0.23443945f, -0.19894205f, -0.15722063f, -0.04580781f, -0.07723701f, 0.09496631f, 0.08296518f, 0.08707894f, 
    -0.09064285f, 0.17040217f, 0.01015939f, -0.09345796f, 0.02469104f, -0.10023344f, 0.03286645f, 0.06798437f, 
    0.03275630f, -0.06416295f, 0.07265409f, 0.00017460f, 0.01573658f, 0.26122308f, 0.16302827f, 0.18106122f, 
    -0.08300874f, -0.09863041f, -0.08461158f, -0.10989601f, -0.06494847f, -0.06468555f, -0.14795581f, 0.00544110f, 
    -0.01732695f, 0.02022275f, 0.12370677f, -0.04960671f, 0.13549013f, 0.12442964f, 0.06293983f, 0.03131614f, 
    -0.02230621f, 0.16296184f, 0.14963499f, 0.12598123f, -0.24437103f, -0.09391059f, -0.09092097f, -0.18243325f, 
    0.12163791f, -0.02185602f, -0.05908049f, -0.01345617f, 0.03562427f, -0.00540771f, -0.00698572f, 0.03818795f, 
    0.12492993f, 0.13734695f, -0.00464136f, 0.02198781f, 0.32752526f, 0.11442599f, -0.06221795f, -0.06522171f, 
    -0.03011965f, 0.18144026f, -0.01146402f, 0.21968928f, 0.07015330f, 0.11603169f, 0.07892421f, 0.06593718f, 
    0.06521877f, 0.20262524f, 0.07241955f, -0.06529437f, -0.14771497f, 0.06023053f, -0.11703987f, -0.18636082f, 
    0.39421475f, 0.21680412f, 0.24684040f, -0.23204735f, 0.03171223f, 0.10770372f, -0.35455188f, 0.18083216f, 
    0.10961641f, -0.12940226f, 0.10097855f, 0.04847215f, 0.19910394f, 0.14750494f, 0.05165778f, 0.12816937f, 
    -0.01911912f, 0.02198436f, -0.21869496f, -0.17960705f, 0.37808409f, 0.15630253f, -0.26019183f, -0.12659973f, 
    -0.27429742f, -0.02467176f, 0.03874893f, 0.15442123f, -0.03210688f, -0.09372223f, 0.02166788f, -0.01074571f, 
    -0.05298842f, 0.20552292f, 0.03120085f, 0.08567291f, -0.05639724f, 0.12716405f, -0.02983523f, -0.01997638f, 
    -0.01817777f, 0.30613741f, 0.01490958f, 0.06192673f, 0.05487136f, -0.12465311f, -0.17307317f, 0.22330920f, 
    0.05035405f, 0.11698853f, -0.03802387f, -0.13910320f, 0.16203775f, 0.09596100f, 0.13559099f, -0.01514748f, 
    0.02504073f, 0.05205308f, 0.10116361f, 0.09613065f, 0.15186971f, 0.13323770f, 0.59897321f, -0.00349473f, 
    -0.14528838f, 0.20137286f, -0.19067889f, -0.21568994f, 0.05021491f, -0.12054691f, -0.10902030f, -0.06266549f, 
    -0.01432956f, -0.01164719f, -0.07640717f, 0.05846639f, -0.07730857f, -0.06619117f, 0.02290554f, -0.04667448f, 
    0.02039034f, -0.17974383f, 0.09299464f, 0.23571175f, -0.03127993f, -0.14502069f, -0.00467908f, -0.10631455f, 
    -0.04524970f, -0.07294945f, -0.02394821f, 0.11274088f, -0.04208708f, 0.10767949f, 0.21457134f, 0.10332295f, 
    -0.00153421f, 0.12976223f, -0.09613028f, -0.15088816f, 0.11406382f, 0.10735629f, -0.00111824f, 0.30148792f, 
    -0.03205764f, -0.08198960f, -0.03715375f, -0.12827982f, 0.13516825f, 0.08588776f, -0.13840233f, 0.08318490f, 
    -0.09589332f, -0.09013455f, 0.02600296f, -0.04982247f, 0.19362472f, 0.14374015f, -0.04351339f, 0.07106613f, 
    0.03899565f, 0.03981988f, 0.00494547f, 0.20949778f, -0.12942968f, -0.08369215f, 0.01660110f, -0.03313437f, 
    0.06833148f, 0.02260329f, 0.04115525f, 0.03034257f, 0.01442849f, -0.05026265f, 0.08733755f, 0.08050663f, 
    0.24483389f, 0.04212093f, 0.03365285f, 0.10922817f, -0.25891235f, -0.13602929f, 0.02680064f, -0.43347454f, 
    0.10465277f, 0.01725068f, -0.02554798f, 0.02065844f, 0.13229354f, -0.14999084f, -0.01474348f, 0.08002657f, 
    -0.18475121f, -0.08758838f, 0.12963988f, 0.04914568f, -0.00723941f, -0.08514640f, 0.00145007f, -0.05378344f, 
    0.15192132f, 0.05684893f, 0.17183951f, 0.18902436f, 0.11466165f, 0.01509428f, -0.12826617f, -0.04095045f, 
    0.02517117f, -0.12398662f, -0.05004268f, -0.12779221f, -0.10952640f, -0.03903712f, 0.06118670f, -0.12210224f, 
    -0.20755038f, -0.02537831f, -0.13270935f, -0.26447782f, 0.14321674f, 0.23319592f, 0.27081987f, -0.17908126f, 
    -0.15670452f, -0.07436086f, -0.37479776f, -0.09147058f, -0.07362135f, -0.16909806f, -0.00279157f, 0.01179500f, 
    0.06948624f, 0.07463978f, 0.03504522f, 0.10724985f, -0.02563737f, 0.01593088f, -0.17115848f, -0.20502418f, 
    -0.04229426f, 0.22171076f, 0.19994763f, 0.09543426f, -0.13780248f, -0.03442225f, -0.06739950f, -0.11937506f, 
    0.10215502f, -0.06378909f, -0.09719960f, 0.00956649f, -0.00505910f, -0.07377793f, -0.03946762f, 0.04929206f, 
    0.12787981f, 0.23699860f, 0.01935878f, 0.06690222f, 0.07004648f, 0.16613320f, -0.60473388f, -0.14802444f, 
    -0.13470687f, 0.02295917f, 0.07737236f, 0.32738969f, -0.08531329f, 0.06657743f, 0.06392410f, -0.14341505f, 
    -0.09537134f, -0.08391903f, -0.01076046f, -0.02898467f, 0.03383872f, 0.01911126f, -0.02530302f, -0.02207490f, 
    0.46298614f, -0.15217629f, -0.46354395f, 0.45510784f, -0.01231202f, 0.02271008f, 0.03209170f, 0.01398881f, 
    0.20282467f, 0.18101533f, 0.04302384f, -0.04360105f, 0.05910137f, -0.00033157f, 0.07155537f, 0.03896216f, 
    0.05920848f, 0.00017367f, 0.28583029f, 0.01785513f, 0.02738121f, 0.06506781f, 0.04101582f, 0.12860119f, 
    -0.05824105f, -0.09123544f, 0.02505027f, -0.02308201f, -0.02465672f, -0.02815880f, 0.09308362f, 0.21537194f, 
    0.06823894f, 0.27538711f, 0.28137118f, -0.22229329f, 0.05410390f, 0.07355507f, 0.04304204f, -0.02286471f, 
    0.04739480f, -0.06248344f, -0.10518783f, 0.05362695f, -0.06098486f, -0.09682973f, -0.02451755f, -0.10663144f, 
    0.00748885f, -0.06728315f, 0.12906969f, 0.15815876f, -0.07709165f, -0.03448144f, 0.00287582f, -0.15647823f, 
    0.13159190f, 0.04785771f, 0.07161730f, 0.14347154f, -0.14097781f, -0.28035152f, 0.01378676f, 0.09936996f, 
    -0.04989869f, -0.07707956f, 0.01066868f, -0.04389473f, 0.16461228f, 0.05139698f, -0.13965896f, 0.07763457f, 
    0.03847616f, 0.17988020f, 0.02904198f, -0.06941088f, 0.10148156f, 0.10873736f, 0.09670354f, 0.03790445f, 
    -0.19544694f, -0.57638854f, -0.26210284f, 0.01858400f, 0.00622440f, 0.06281548f, 0.02245335f, 0.03225546f, 
    -0.07956025f, -0.03965346f, 0.03518361f, -0.04713954f, 0.01756067f, 0.05715040f, -0.06190646f, -0.07092055f, 
    0.03274598f, -0.15513849f, 0.08340421f, -0.04212312f, -0.08691715f, -0.19564271f, -0.13883649f, -0.15110500f, 
    0.19266355f, 0.02032073f, 0.00989820f, 0.03703536f, -0.02520850f, 0.09671941f, -0.01610318f, -0.14603205f, 
    -0.13894892f, -0.04496586f, 0.01028584f, 0.10345796f, 0.06318449f, -0.05864918f, 0.17795590f, 0.02554148f, 
    -0.19454169f, 0.07675505f, 0.06067975f, 0.26371410f, -0.05752043f, -0.06235000f, -0.04757273f, 0.06643908f, 
    -0.04626108f, 0.00127723f, -0.03830023f, -0.01302840f, -0.00337684f, -0.09732098f, -0.06115368f, 0.01912855f, 
    0.04187293f, 0.04363902f, 0.10044572f, -0.06330240f, -0.27999839f, 0.09935244f, 0.07010340f, 0.33231556f, 
    -0.03114546f, 0.00141480f, -0.01299659f, 0.07573412f, -0.04406044f, 0.21043834f, -0.01845427f, -0.03114333f, 
    -0.01969345f, -0.05422094f, -0.08928049f, 0.16691619f, 0.09874520f, -0.05069628f, -0.00017518f, 0.16921210f, 
    -0.33148041f, -0.24352010f, -0.16742836f, 0.03749022f, 0.02428815f, -0.05003196f, -0.02404897f, -0.07345858f, 
    -0.01256880f, -0.23252001f, -0.04594345f, 0.03838076f, -0.09744812f, 0.04622030f, 0.05521669f, -0.02455648f, 
    0.10038842f, 0.02490906f, 0.16793275f, -0.04594703f, 0.13463314f, 0.10383328f, -0.10265059f, 0.11063311f, 
    0.01770521f, 0.05332680f, 0.04166363f, -0.01603419f, 0.07090021f, 0.17120337f, 0.05843972f, -0.00201910f, 
    0.01831314f, 0.01184448f, -0.02742066f, 0.15681243f, 0.07875186f, 0.05471027f, 0.09994610f, 0.14539281f, 
    -0.35528499f, 0.07076911f, -0.06257834f, 0.31844038f, 0.06333437f, -0.00873410f, -0.14321908f, -0.02102954f, 
    -0.06137159f, -0.07466154f, 0.02124890f, -0.04568820f, -0.00732162f, -0.01439019f, -0.00536138f, 0.06797123f, 
    0.09150524f, -0.00430972f, -0.00846932f, -0.03776343f, -0.12505275f, 0.11408948f, 0.33688217f, 0.34860194f, 
    -0.02877847f, 0.01994766f, -0.04408902f, 0.08426844f, 0.04149278f, 0.05224038f, 0.03670155f, 0.03081135f, 
    0.07494463f, 0.05268389f, -0.00353433f, 0.05688170f, -0.01233353f, 0.13569854f, -0.06990579f, -0.05698333f, 
    -0.23218164f, -0.23501192f, 0.31634831f, 0.23324491f, 0.09599081f, -0.06900714f, 0.04285325f, -0.13058595f, 
    -0.11831048f, 0.11672044f, 0.00675045f, 0.00742160f, 0.01527689f, 0.10495152f, 0.09804589f, -0.00572533f, 
    -0.04742611f, 0.04376388f, -0.09685272f, -0.04862458f, -0.01249945f, -0.01959812f, 0.45421466f, -0.08098689f, 
    0.01732887f, -0.04715736f, -0.06523325f, -0.29012665f, 0.01466356f, 0.05892457f, 0.07516880f, 0.07069968f, 
    0.17460243f, 0.19910978f, 0.08031652f, 0.04069812f, -0.07662425f, -0.11701033f, -0.04097820f, -0.04392697f, 
    -0.65471858f, 0.11662168f, 0.27875549f, 0.18685248f, -0.04564593f, -0.14181213f, -0.01665092f, -0.02436124f, 
    0.02111213f, 0.27896041f, 0.05382248f, 0.11162550f, 0.01097657f, -0.00349914f, 0.05016890f, -0.06529453f, 
    -0.00284579f, -0.03414550f, 0.08147833f, -0.02309023f, -0.27519232f, -0.33912909f, 0.07123645f, -0.45229459f, 
    0.02847900f, 0.11160003f, 0.16302985f, -0.00723999f, 0.13315842f, 0.15624800f, 0.03511116f, 0.08866189f, 
    0.02983271f, -0.01023526f, -0.03448112f, 0.07993586f, 0.07098331f, 0.08977503f, 0.16668750f, 0.13231663f, 
    -0.17244378f, 0.21270882f, 0.15994279f, 0.36114246f, -0.11438219f, -0.09087769f, 0.05590744f, -0.03707940f, 
    0.04329706f, 0.02896375f, 0.05742441f, 0.05185873f, 0.10291105f, 0.05279223f, -0.05631636f, 0.03482643f, 
    0.12166759f, -0.06772820f, 0.04476535f, 0.11746041f, 0.14998902f, -0.15249518f, -0.10739153f, -0.12913792f, 
    0.13144135f, 0.06872946f, 0.05408859f, -0.01527981f, 0.05650944f, 0.05727116f, 0.01222035f, -0.03270453f, 
    -0.03987107f, 0.07098304f, 0.13232701f, 0.13589065f, 0.10825468f, -0.03262077f, 0.02639722f, 0.00284984f, 
    0.37763461f, -0.21354783f, -0.20507443f, -0.12575309f, 0.04160909f, -0.02243957f, 0.03522408f, 0.04749004f, 
    -0.11012063f, -0.01348189f, -0.02274730f, -0.02028160f, -0.08171260f, 0.00308044f, -0.01042892f, -0.03237992f, 
    0.03924990f, -0.10088113f, 0.08320305f, -0.00339452f, 0.02079872f, -0.13049541f, 0.19489798f, 0.27251264f, 
    0.05316740f, 0.08061523f, 0.12152876f, -0.03611480f, 0.18265909f, 0.01853375f, 0.08718552f, -0.05170710f, 
    0.16629225f, 0.07166396f, 0.13942082f, -0.07327037f, 0.07321958f, -0.08509729f, -0.01853878f, -0.02641258f, 
    -0.21674956f, -0.16561036f, -0.40093806f, 0.06815019f, -0.16040593f, 0.06275732f, -0.17675856f, 0.17416438f, 
    -0.04240921f, -0.04853475f, -0.04239611f, 0.06590886f, 0.04371708f, 0.12716468f, 0.18975843f, -0.03694272f, 
    0.07597361f, -0.03730812f, -0.07507329f, -0.02268160f, -0.22971413f, -0.12457889f, 0.34829974f, 0.25265747f, 
    -0.10549346f, -0.08096921f, -0.11947194f, -0.20046636f, 0.00841378f, -0.02997747f, 0.06402995f, -0.08382509f, 
    0.02802291f, -0.26514143f, -0.13630237f, 0.18880601f, -0.03933816f, -0.09871708f, -0.06040736f, -0.20700657f, 
    0.08366966f, -0.19346906f, -0.09809405f, 0.08438746f, -0.12043300f, 0.08680698f, 0.10212886f, -0.07284611f, 
    0.04959419f, 0.21429485f, -0.00271747f, -0.12583284f, 0.09444194f, 0.06865785f, 0.13005553f, -0.03733514f, 
    0.06034898f, 0.11866451f, -0.00118595f, -0.04925988f, 0.32961336f, -0.14283662f, -0.47880036f, -0.16783978f, 
    -0.00859247f, -0.09404963f, 0.13329738f, 0.14406101f, -0.02440576f, 0.14697567f, -0.15445323f, -0.03747915f, 
    -0.07027344f, -0.00958865f, -0.04211589f, 0.03919889f, -0.10445752f, -0.00641940f, 0.06461865f, 0.11502837f, 
    0.28271049f, -0.03228315f, 0.11680289f, -0.16205391f, 0.09800168f, -0.13214822f, -0.06245032f, -0.14634459f, 
    -0.13162941f, -0.05522527f, -0.01776701f, 0.07722037f, 0.16260415f, -0.02481297f, -0.01363261f, 0.27206758f, 
    0.03783862f, -0.05284285f, -0.01208799f, -0.02618052f, 0.29167038f, -0.02813951f, -0.15409029f, -0.02331022f, 
    0.01739818f, -0.07502209f, 0.03009398f, 0.02368688f, -0.07868291f, -0.03644210f, 0.06478242f, -0.14880285f, 
    -0.03463286f, -0.08921992f, 0.02106744f, 0.05228941f, 0.11979140f, 0.16227531f, 0.03182255f, 0.03157552f, 
    0.20394742f, -0.06775629f, -0.04516718f, -0.04340110f, 0.13707101f, 0.12702651f, -0.01487900f, 0.11184926f, 
    -0.07197438f, -0.09979122f, 0.03573789f, 0.05729040f, 0.04708599f, 0.08839260f, 0.01969780f, 0.13775705f, 
    0.15614817f, 0.06210736f, 0.09807620f, 0.00260246f, -0.65468794f, 0.09051387f, 0.29731089f, 0.21073478f, 
    0.01779902f, 0.20708051f, -0.04824547f, 0.11987201f, -0.02409897f, 0.10965150f, 0.27869043f, -0.03760957f, 
    -0.06637685f, 0.06279299f, 0.18621451f, 0.18416148f, 0.06731379f, 0.05334510f, 0.08491967f, 0.04694870f, 
    0.11291736f, 0.07322509f, -0.10430271f, -0.03102463f, 0.10969724f, -0.06872904f, -0.00894840f, -0.02797361f, 
    -0.01349308f, -0.04042678f, -0.03231569f, 0.00190344f, -0.08411862f, -0.06088128f, -0.04622933f, 0.03379882f, 
    -0.03811935f, -0.11373678f, -0.01715347f, 0.07719421f, -0.14802833f, -0.06684542f, -0.40916464f, -0.06624871f, 
    -0.08176485f, 0.05773982f, -0.19798896f, -0.06378497f, -0.02961731f, -0.17921101f, -0.00375251f, 0.12449471f, 
    0.04585074f, 0.09161391f, 0.16007383f, 0.06943236f, -0.07489879f, -0.04283198f, -0.14283118f, -0.08587375f, 
    0.23100963f, -0.11704755f, -0.11766481f, 0.01002421f, 0.02937515f, 0.07095844f, 0.09235909f, 0.07996320f, 
    -0.03585008f, 0.00651541f, 0.01712160f, -0.00029895f, -0.00938054f, 0.03719568f, -0.00119454f, 0.00113744f, 
    0.05614120f, -0.07799227f, 0.01598969f, 0.02090572f, -0.19991986f, -0.05897717f, 0.59929150f, 0.08658504f, 
    -0.22545442f, -0.00723719f, -0.01482857f, -0.19004551f, 0.03253158f, 0.05755394f, 0.15764593f, 0.02348085f, 
    -0.00690059f, -0.10062539f, -0.04385696f, 0.06445207f, -0.04671099f, -0.05231469f, -0.04159256f, -0.05704671f, 
    0.40732583f, 0.33230537f, -0.19712317f, 0.03493708f, -0.23796263f, 0.14008391f, 0.17650694f, -0.01539019f, 
    0.14125648f, -0.00673951f, 0.02371279f, 0.02877230f, 0.03624799f, 0.09845185f, 0.09266520f, 0.04298491f, 
    0.15360133f, 0.12429145f, -0.02921090f, 0.09964757f, -0.10038082f, -0.20016564f, -0.00312485f, -0.04680386f, 
    0.04044259f, -0.00318887f, -0.06311528f, -0.11953349f, -0.13196397f, -0.00662045f, 0.15278977f, 0.22917213f, 
    0.06231940f, -0.01705457f, 0.10157257f, 0.05369833f, -0.08676462f, -0.09860743f, -0.03402120f, -0.01604785f, 
    -0.19890566f, -0.03575581f, 0.04216810f, -0.10370769f, 0.06140618f, -0.12929499f, -0.07091265f, -0.20026773f, 
    -0.01842526f, -0.11006407f, 0.03977693f, 0.07751083f, -0.16119386f, 0.05808832f, -0.00612740f, -0.09685346f, 
    0.04239524f, -0.06031878f, -0.00275360f, -0.00306787f, 0.29495007f, 0.11309890f, 0.05987220f, -0.14956658f, 
    -0.01377040f, -0.02875203f, 0.00648107f, 0.08275343f, 0.07691585f, -0.03568476f, 0.13615553f, 0.00366299f, 
    0.00117363f, 0.09051488f, 0.08238938f, -0.00191117f, 0.03452722f, -0.11443832f, 0.05726676f, 0.15393126f, 
    -0.08657109f, -0.33503088f, 0.07340790f, -0.09924202f, 0.20048796f, -0.00635508f, 0.13843279f, 0.00010820f, 
    -0.01586362f, 0.02179668f, 0.05929954f, -0.09084234f, 0.01963654f, 0.01098717f, -0.09435979f, 0.12618302f, 
    0.00594086f, -0.08129637f, 0.19544296f, -0.02334952f, -0.08362271f, -0.08011862f, -0.08767791f, -0.04622446f, 
    0.37721556f, 0.06830295f, 0.02809273f, -0.07358237f, -0.04373292f, 0.14987348f, -0.06203541f, -0.12039638f, 
    -0.07399489f, -0.08361723f, 0.00566445f, 0.11407883f, -0.06454432f, -0.20937154f, 0.07824953f, 0.00098758f, 
    -0.12128153f, -0.02541813f, -0.08137269f, 0.18836395f, 0.04693455f, -0.03185221f, -0.03592056f, -0.01050264f, 
    -0.16408698f, -0.06113645f, -0.01953912f, 0.04407835f, 0.09890584f, -0.07569215f, -0.10317064f, -0.22704616f, 
    0.03528106f, -0.06893779f, 0.18217979f, 0.10278749f, -0.19125694f, 0.04318545f, -0.00800243f, 0.23109855f, 
    -0.07531621f, 0.16654448f, -0.05345719f, -0.00116769f, -0.06552115f, 0.23765075f, 0.00964146f, -0.00708018f, 
    -0.00878750f, 0.04655170f, 0.00941231f, 0.07500646f, 0.00086028f, -0.05190220f, 0.08949290f, 0.15296255f, 
    -0.17395784f, -0.23925902f, -0.08460688f, -0.17353863f, -0.02005269f, -0.09193948f, -0.07482263f, -0.11946285f, 
    -0.11711910f, -0.20145479f, -0.07882816f, -0.05803986f, -0.09661983f, 0.00649207f, 0.02423422f, 0.03562457f, 
    -0.02892184f, 0.10648487f, 0.03724134f, -0.20420513f, 0.17649184f, 0.13654409f, 0.13911444f, 0.01287807f, 
    0.07672168f, -0.03688144f, 0.14924869f, 0.02441270f, -0.07231919f, 0.09651422f, -0.03202830f, -0.05120524f, 
    0.02924814f, -0.08153144f, 0.00757394f, 0.09281732f, 0.11369583f, -0.07505414f, -0.03352250f, 0.01407302f, 
    -0.13447754f, -0.00455747f, 0.09041376f, 0.15169033f, -0.03722696f, 0.00969587f, -0.07265102f, -0.00017480f, 
    -0.08891448f, -0.10945542f, -0.00110557f, 0.05361520f, 0.11852671f, -0.05036110f, -0.02755637f, -0.01688898f, 
    0.06457140f, 0.07744349f, 0.25378516f, -0.02760956f, -0.24537660f, 0.05108444f, 0.48161000f, 0.17268807f, 
    -0.06250390f, 0.09063580f, -0.06709799f, 0.01377933f, 0.03558730f, 0.02398320f, -0.07837079f, 0.06390604f, 
    0.12432281f, 0.01311354f, -0.05590505f, 0.11596464f, 0.00914736f, 0.06820463f, -0.04032719f, -0.07053895f, 
    -0.48530427f, -0.22444458f, 0.26828605f, 0.14828146f, -0.06713922f, 0.05664942f, -0.09061278f, -0.21728414f, 
    0.08117338f, -0.04178534f, -0.09410825f, 0.07117806f, 0.02601659f, 0.05318191f, 0.02219598f, 0.05351193f, 
    0.00408087f, -0.01568986f, -0.00617648f, -0.01658648f, -0.14041328f, 0.16101162f, 0.29663423f, -0.11374802f, 
    0.19169229f, -0.05664157f, -0.09801191f, -0.11518488f, -0.02513020f, -0.04276494f, -0.07474167f, 0.07284054f, 
    0.13759145f, -0.00873372f, 0.11741386f, -0.04648319f, -0.11497191f, -0.02445490f, -0.03745601f, 0.02896713f, 
    -0.59860522f, 0.11463562f, 0.15467431f, 0.21171907f, -0.00873691f, -0.18040366f, -0.06114593f, -0.01374266f, 
    0.06087371f, 0.21769054f, -0.11888225f, 0.08688152f, 0.10111514f, -0.03054645f, 0.06057940f, 0.01249863f, 
    0.05537263f, -0.01312361f, 0.01459829f, -0.02474846f, 0.19104221f, -0.07605483f, -0.07852162f, -0.22805735f, 
    0.43036011f, 0.29327822f, -0.08081348f, -0.05861882f, 0.07610248f, 0.10970686f, -0.02105464f, -0.03930764f, 
    0.03669360f, -0.00255048f, -0.09274410f, 0.25476766f, 0.05209348f, -0.10834416f, 0.14502262f, 0.05104128f, 
    -0.22698492f, 0.15905102f, 0.12808488f, 0.23903295f, -0.14210850f, -0.00545584f, -0.11290751f, -0.04652571f, 
    0.02973898f, 0.07734361f, 0.04588742f, 0.16029625f, 0.01436884f, 0.02018586f, -0.04671765f, 0.00333843f, 
    0.02418446f, 0.10502034f, 0.01590632f, 0.09731546f, 0.16214024f, -0.05177225f, -0.04440973f, -0.00392893f, 
    0.19761662f, 0.10068858f, 0.09745853f, -0.12545449f, -0.03582212f, 0.05600276f, -0.05126027f, 0.01112835f, 
    -0.03526755f, -0.00374139f, -0.06283043f, 0.11627775f, -0.06065394f, -0.08269576f, -0.05292257f, -0.03031572f, 
    0.37638724f, -0.04473921f, 0.08740801f, 0.05519055f, 0.28692704f, 0.05815267f, 0.12245356f, 0.07231928f, 
    -0.04651025f, 0.01810065f, -0.02600408f, -0.07734623f, -0.06498063f, -0.02655418f, 0.01588088f, -0.04913172f, 
    0.05247838f, 0.04112018f, -0.04606396f, -0.02900654f, -0.12321799f, -0.03361493f, 0.00745642f, 0.18960559f, 
    -0.09400115f, -0.01975577f, 0.12973677f, -0.06810448f, 0.07463539f, 0.08752945f, -0.02853742f, 0.03149484f, 
    0.09456459f, 0.11393009f, 0.24730958f, 0.13038006f, 0.09518088f, -0.08514792f, 0.06657456f, 0.09645190f, 
    -0.16559532f, -0.14091834f, -0.21431778f, 0.06442910f, -0.23471515f, -0.05499652f, -0.02741026f, 0.08516618f, 
    -0.11110967f, -0.03448173f, -0.06194473f, -0.03129857f, -0.00892168f, 0.01642566f, 0.11685610f, -0.01098719f, 
    0.12090752f, -0.02960247f, -0.02094104f, 0.13638794f, -0.48606294f, -0.13410226f, 0.12562406f, 0.09630226f, 
    0.03219394f, -0.07263829f, 0.01307161f, -0.09349669f, -0.27398196f, -0.00464976f, -0.00386978f, 0.00351231f, 
    0.20067616f, -0.19114438f, -0.24885887f, 0.10711969f, -0.04542571f, -0.13503271f, -0.00538822f, -0.03441890f, 
    0.20372717f, -0.21236658f, -0.08020363f, 0.01755914f, -0.24744026f, 0.15055683f, 0.10207475f, -0.11504900f, 
    0.14248021f, 0.23044670f, 0.10708736f, -0.06367561f, -0.00871266f, 0.09779253f, -0.10528693f, 0.07517846f, 
    0.00559401f, -0.02761756f, 0.12411994f, -0.08586849f, 0.43043986f, -0.00101581f, -0.15554507f, 0.00207505f, 
    0.21106115f, -0.02893869f, 0.17749612f, 0.21507764f, -0.03206787f, 0.07305895f, -0.12103838f, -0.02687815f, 
    -0.00415724f, -0.01161485f, -0.01017964f, -0.04505317f, -0.01227619f, 0.10918766f, -0.04513001f, 0.10667460f, 
    0.20414725f, 0.07682737f, 0.13212818f, -0.21381855f, 0.26663542f, -0.09722549f, -0.05487440f, -0.07954800f, 
    -0.03691458f, -0.03122932f, -0.04214186f, 0.12143982f, 0.14237133f, -0.13899904f, 0.04667987f, -0.00826414f, 
    -0.13794346f, 0.05791123f, -0.01134181f, -0.04292969f, 0.11374735f, 0.12699592f, 0.04334016f, -0.01909125f, 
    0.14391020f, -0.03539754f, 0.14165011f, -0.06775093f, -0.10584517f, -0.04119668f, 0.08214398f, -0.05008651f, 
    0.01135117f, -0.06632318f, -0.03807729f, 0.18742497f, 0.04828528f, -0.01840833f, -0.04791019f, -0.06028510f, 
    0.16403869f, -0.04748864f, 0.05681743f, -0.08800960f, 0.20330140f, 0.01634981f, 0.06948207f, 0.05015242f, 
    -0.04882265f, -0.00856054f, 0.09861003f, -0.00845074f, 0.01969462f, -0.00343449f, -0.03994028f, 0.14254242f, 
    -0.01556180f, -0.07797384f, -0.02385545f, -0.03611556f, -0.68778908f, 0.18724538f, 0.20600791f, 0.19976136f, 
    0.04687804f, 0.06663848f, 0.04224567f, 0.06089973f, 0.00247384f, 0.11975837f, 0.20401496f, 0.06703576f, 
    0.08035858f, 0.15386757f, 0.05876087f, 0.03650692f, 0.08247574f, 0.08844374f, 0.05350231f, 0.20523538f, 
    0.25966746f, 0.30224884f, 0.06860503f, -0.03714927f, 0.22150317f, -0.05009481f, -0.00229649f, -0.01002642f, 
    -0.06989498f, -0.00666459f, -0.02592830f, -0.01728089f, 0.05268838f, 0.02310859f, -0.00656050f, 0.04338970f, 
    0.06870612f, 0.07078321f, -0.02133765f, 0.18574780f, -0.09157006f, -0.15805994f, -0.18407623f, -0.07613589f, 
    -0.03800530f, 0.03124103f, -0.04632123f, 0.04684658f, 0.05047175f, -0.20482294f, 0.00893757f, 0.04703165f, 
    0.00252943f, 0.00812411f, 0.04033649f, 0.03394356f, 0.03134670f, -0.05773625f, 0.00189628f, 0.13460787f, 
    0.29945329f, 0.03437742f, -0.00574137f, -0.04959169f, 0.17229889f, 0.06485403f, 0.09543796f, 0.00810660f, 
    -0.04971071f, 0.08511762f, -0.00577817f, -0.02284819f, 0.01075131f, -0.00217596f, 0.00009212f, 0.05999613f, 
    0.03223477f, -0.13760765f, 0.01093310f, 0.05441899f, -0.51647890f, -0.12006988f, 0.60235685f, -0.06209450f, 
    -0.17486775f, 0.06326488f, -0.07708901f, -0.11658167f, -0.01954789f, 0.08258744f, -0.01482709f, 0.12049467f, 
    0.08063326f, -0.04546997f, -0.08661923f, 0.08468634f, -0.08057735f, 0.01399041f, -0.07285763f, 0.00539873f, 
    0.09926201f, 0.39234400f, -0.00471506f, -0.16457403f, -0.40041962f, 0.23763049f, 0.09899575f, -0.13230684f, 
    -0.05453464f, -0.17788249f, 0.05974294f, 0.11462906f, 0.01667315f, -0.12686153f, 0.12135587f, -0.01363384f, 
    0.05140661f, 0.18936089f, -0.01376965f, 0.02196587f, 0.00319930f, -0.14606746f, 0.06023912f, -0.01957394f, 
    0.13237633f, 0.07445963f, -0.07867759f, -0.07261125f, -0.06375209f, 0.00988962f, 0.05697680f, 0.04942217f, 
    0.05741956f, -0.09082684f, -0.00113201f, 0.04681300f, -0.12312316f, -0.12046128f, -0.01198831f, -0.01359863f, 
    -0.09361848f, -0.00303808f, 0.03903175f, -0.08365829f, 0.06354479f, -0.15051284f, -0.14129673f, -0.15135619f, 
    -0.05286676f, -0.06137785f, -0.10227553f, -0.05482195f, -0.14817306f, -0.02241076f, 0.05467212f, -0.01863920f, 
    -0.07698392f, -0.06160447f, -0.10602612f, -0.15079089f, 0.32844481f, 0.12609929f, 0.19415177f, -0.13667002f, 
    0.12104743f, 0.07803798f, 0.07903356f, -0.00646727f, 0.01109174f, -0.04858549f, 0.03229644f, 0.03506024f, 
    -0.10921130f, 0.00008527f, 0.09413157f, 0.01831787f, 0.06123327f, -0.12493534f, -0.12320852f, 0.01052604f, 
    0.00909626f, 0.33486572f, 0.34630102f, -0.29380158f, 0.00119079f, -0.07683659f, 0.00464524f, -0.12559438f, 
    0.05554410f, -0.19546682f, -0.06257956f, 0.00017058f, 0.07732790f, -0.07117143f, 0.07839588f, 0.13421498f, 
    0.10427672f, 0.19656925f, 0.10751678f, -0.04662932f, 0.06938948f, 0.18588470f, -0.05756263f, 0.01734196f, 
    -0.13273965f, -0.04577873f, 0.10907961f, 0.13575314f, -0.07934114f, -0.06459229f, -0.07572868f, 0.03735570f, 
    0.21465713f, 0.06474733f, -0.09631331f, 0.02222144f, 0.01079371f, 0.01112621f, 0.00173411f, -0.02603339f, 
    0.12726264f, 0.13173060f, -0.16348359f, -0.05047914f, 0.01284184f, 0.28288117f, 0.07101262f, 0.04977291f, 
    0.12065720f, 0.27940971f, -0.03256339f, -0.05739285f, -0.05920494f, -0.04532302f, 0.28655195f, -0.04695186f, 
    0.01569435f, 0.01802745f, -0.12310215f, 0.00621618f, -0.02417673f, -0.01251224f, -0.23156063f, -0.28793278f, 
    0.03151662f, 0.16390800f, 0.17111948f, -0.06479210f, 0.00558655f, 0.04384711f, -0.10235366f, -0.10577212f, 
    -0.02969207f, -0.03503155f, 0.09764527f, -0.08275349f, -0.00649380f, 0.10905639f, -0.15674169f, 0.00628821f, 
    -0.30258578f, -0.24783990f, -0.29466528f, -0.00720709f, -0.09847619f, 0.16324456f, 0.10428263f, -0.00713199f, 
    0.01686964f, -0.01790552f, 0.10626344f, 0.04876336f, -0.04763390f, 0.02970773f, -0.04537390f, -0.09960416f, 
    0.01937648f, -0.04031928f, -0.03128297f, 0.14242008f, 0.11054264f, 0.15317324f, 0.18811522f, -0.15060885f, 
    0.11983516f, -0.04337312f, -0.02873627f, -0.08589310f, -0.07298890f, -0.00063313f, 0.09986198f, 0.02274464f, 
    0.13003215f, 0.10628070f, 0.02577325f, 0.03602210f, 0.01609334f, 0.13178332f, 0.13186209f, -0.10796670f, 
    -0.24060453f, -0.16964413f, 0.00344237f, 0.02027275f, 0.16758239f, 0.16296235f, 0.32412964f, 0.23930600f, 
    0.13680878f, 0.14457767f, -0.10751515f, 0.03456288f, 0.06052202f, -0.00485625f, 0.00376233f, -0.07106699f, 
    0.05314835f, 0.09323514f, -0.11836319f, -0.00738765f, 0.07646312f, -0.27312389f, -0.05020111f, -0.20447226f, 
    0.11989388f, 0.15571521f, 0.13747440f, 0.09246758f, 0.17221904f, 0.00961304f, -0.04445107f, -0.01484825f, 
    0.05956215f, -0.07439262f, 0.04002221f, 0.01794522f, 0.02955126f, 0.06183672f, 0.07349365f, 0.04546268f, 
    0.45614180f, -0.05236344f, -0.11756733f, -0.36022455f, -0.08733176f, 0.03946980f, 0.03448781f, -0.06613021f, 
    0.10131510f, 0.02012978f, -0.02221756f, -0.00741698f, 0.23454902f, -0.09768548f, -0.09340159f, 0.02021568f, 
    -0.00431946f, -0.02594745f, 0.02892533f, -0.04172594f, 0.43678677f, 0.29997522f, -0.09907643f, 0.10862868f, 
    -0.23031245f, -0.01920838f, 0.01826408f, 0.06558070f, -0.09966436f, 0.02276810f, -0.15840337f, -0.17628549f, 
    0.01722150f, -0.10543813f, -0.03903611f, -0.00241056f, -0.00044826f, -0.12780245f, 0.02650606f, 0.02104324f, 
    0.45373264f, -0.16349554f, -0.07794374f, -0.02190116f, -0.18159097f, 0.18612498f, 0.02506531f, 0.07679749f, 
    -0.01248383f, 0.05414419f, -0.10236999f, 0.08010130f, 0.13513625f, 0.06219360f, -0.04977498f, -0.02431489f, 
    -0.00589303f, 0.01688847f, 0.04076917f, -0.06163990f, -0.08003195f, 0.30867237f, 0.18639384f, -0.19438772f, 
    -0.19102660f, -0.40322256f, 0.23237300f, -0.20067286f, -0.21266329f, 0.03025080f, 0.14035347f, -0.04760545f, 
    0.02212567f, 0.23374155f, 0.07157212f, 0.13265716f, 0.02755047f, -0.07961656f, 0.16603233f, 0.17613402f, 
    -0.06345203f, -0.15606941f, -0.07854095f, -0.17421909f, 0.00741615f, 0.08727085f, 0.13603169f, 0.06144122f, 
    0.09933849f, -0.02956374f, -0.07734831f, -0.02955044f, -0.01522470f, -0.03187743f, 0.02345146f, -0.04134418f, 
    0.08472082f, 0.15529771f, -0.12377648f, 0.08852748f, 0.03030022f, 0.03006776f, 0.03815883f, 0.07763646f, 
    -0.05304413f, 0.00127014f, 0.08606666f, 0.04510557f, 0.00429889f, -0.07112844f, 0.10957880f, -0.03033391f, 
    -0.02487020f, 0.04148741f, -0.04354523f, -0.08374863f, -0.04238283f, -0.05275284f, 0.06722818f, -0.13496600f, 
    0.05204740f, 0.18095466f, 0.11682264f, -0.12073905f, -0.08599866f, -0.13880625f, -0.16133490f, -0.11860421f, 
    0.01063757f, -0.01418896f, 0.06298730f, 0.00689389f, 0.04148121f, -0.00735731f, -0.04852184f, 0.07575040f, 
    -0.05606877f, -0.04317053f, 0.09745923f, 0.02786914f, 0.02213471f, -0.00285823f, -0.18114039f, -0.18153892f, 
    0.14003910f, 0.04218257f, 0.10599907f, -0.13315023f, 0.23540729f, 0.25536284f, 0.06071268f, -0.07689054f, 
    0.04040978f, -0.06963634f, -0.07502321f, 0.03270477f, -0.04533039f, -0.00690087f, 0.05778034f, -0.12022862f, 
    -0.05447313f, 0.00306615f, 0.04747721f, 0.09463412f, 0.26956731f, 0.21726421f, 0.19127114f, -0.10538394f, 
    0.05966711f, 0.15392295f, -0.05656127f, -0.03254391f, -0.06993772f, -0.18442354f, -0.03984658f, -0.15576553f, 
    -0.00586362f, 0.15448149f, -0.11928754f, -0.08125946f, 0.29985309f, 0.06384752f, -0.09036047f, -0.20542389f, 
    0.01985059f, 0.16256225f, 0.00169549f, -0.10383030f, 0.38161606f, 0.27185521f, -0.11284938f, -0.19486316f, 
    -0.17506079f, -0.09591650f, 0.20227824f, -0.00004383f, -0.07657360f, -0.10741482f, 0.01581787f, -0.01564656f, 
    0.13823643f, 0.00838765f, 0.00107415f, -0.00431242f, 0.20621943f, 0.10825527f, 0.15646297f, 0.02006955f, 
    0.20779873f, -0.20974050f, 0.11575545f, 0.14785436f, 0.08527541f, -0.11066709f, 0.24383070f, -0.10396155f, 
    0.14932269f, -0.00563281f, 0.05625599f, -0.17328887f, 0.26936570f, 0.03692015f, 0.11254191f, -0.02175531f, 
    -0.15431179f, -0.09019125f, 0.01921682f, -0.17949420f, -0.20191230f, -0.02737868f, -0.02495774f, -0.03738100f, 
    0.07322468f, -0.01848241f, -0.03580134f, 0.15968370f, 0.28589141f, -0.09705247f, 0.08759543f, 0.08431143f, 
    0.27362600f, -0.04187858f, 0.02168730f, 0.30592257f, 0.01209389f, -0.07843304f, -0.03421666f, 0.12008264f, 
    -0.07846396f, -0.06337518f, 0.11834048f, -0.01146551f, 0.08154649f, 0.05383031f, -0.01246331f, 0.10025392f, 
    -0.06240897f, -0.23109226f, 0.08787621f, -0.02485543f, 0.13344869f, 0.10343479f, 0.23375836f, -0.22453091f, 
    0.08852919f, -0.03305941f, -0.03651970f, -0.05202848f, 0.01208504f, -0.07676618f, 0.10125437f, -0.00658312f, 
    0.09871797f, 0.09436473f, 0.06292463f, 0.13211155f, -0.08149702f, 0.14238255f, 0.19248039f, -0.05915496f, 
    0.04111527f, 0.26418811f, 0.19473980f, 0.01437933f, 0.05748381f, 0.03821944f, -0.00815284f, 0.00922529f, 
    -0.06530769f, -0.01507945f, 0.10613029f, 0.03028859f, 0.06809382f, 0.06018768f, -0.01607949f, 0.07959300f, 
    0.03700485f, 0.06450017f, 0.05561414f, 0.04468499f, 0.41015500f, 0.27202845f, -0.11083123f, 0.16979687f, 
    -0.13668342f, 0.00550941f, 0.18437076f, 0.14275499f, -0.06718830f, -0.04126737f, -0.12572415f, -0.01255231f, 
    0.02152514f, 0.18547465f, 0.15360901f, 0.11568491f, 0.04720694f, -0.10734980f, 0.11511469f, -0.04020547f, 
    0.18749563f, -0.02861105f, 0.09029352f, 0.20042777f, 0.02407698f, -0.07944166f, 0.01416443f, -0.03358925f, 
    -0.08793070f, 0.00399203f, 0.04697486f, 0.10596666f, 0.09803165f, -0.01065520f, 0.01717209f, 0.04953640f, 
    -0.02463190f, -0.01327725f, 0.02768895f, -0.26320255f, -0.10854188f, -0.23301691f, -0.07683459f, 0.04671742f, 
    0.06893680f, 0.13156977f, 0.14876075f, 0.04778807f, 0.10994631f, 0.13098463f, -0.08082596f, -0.07802804f, 
    0.01273858f, -0.18470056f, 0.02870748f, -0.22259691f, 0.01232471f, 0.05627032f, -0.10210411f, -0.07985976f, 
    0.06670020f, 0.09417348f, 0.19257958f, -0.09353382f, 0.01434547f, -0.03699586f, -0.05279097f, -0.06353694f, 
    0.04790397f, -0.07092813f, 0.06364782f, 0.03892407f, 0.04766163f, 0.03657033f, 0.01910927f, 0.06245907f, 
    -0.08055060f, 0.09524948f, 0.14567080f, -0.09949445f, 0.18050855f, -0.01097529f, -0.14181004f, -0.13075276f, 
    -0.07340340f, -0.03375850f, 0.06880620f, 0.06815683f, 0.27809653f, -0.07205553f, -0.09996970f, -0.11704702f, 
    -0.09441294f, -0.05608452f, -0.02267667f, -0.05693233f, -0.08606534f, -0.10458025f, 0.05574514f, 0.03786799f, 
    0.27279803f, -0.02351832f, 0.21437347f, -0.05890578f, 0.37878081f, 0.05421675f, 0.14853460f, 0.22625735f, 
    -0.09612162f, 0.13929980f, 0.10120089f, 0.09596436f, 0.02853990f, 0.12264404f, 0.19039413f, 0.15977353f, 
    0.20323493f, 0.37132049f, 0.16084868f, 0.30287927f, 0.06036574f, 0.15963978f, 0.04062540f, 0.04854191f, 
    -0.04774432f, -0.10458883f, -0.02623575f, -0.01337185f, -0.04563848f, -0.11656331f, 0.04088025f, -0.10852669f, 
    -0.03944593f, -0.08560104f, -0.11162172f, -0.11062595f, -0.13576399f, -0.07145119f, -0.00265842f, -0.08071183f, 
    -0.11418249f, -0.09298510f, -0.11359230f, -0.04004110f, -0.10107600f, -0.00250429f, -0.03239246f, 0.03326381f, 
    -0.01125069f, -0.00265337f, -0.01161658f, -0.01645431f, 0.05907273f, 0.05332112f, -0.07764295f, -0.05443026f, 
    -0.06489410f, -0.01252766f, -0.00716079f, -0.11690526f, -0.09731141f, 0.18584482f, 0.08206377f, -0.02423448f, 
    0.08912201f, 0.08729950f, -0.01998343f, 0.13810924f, -0.02408223f, 0.00276782f, 0.21520126f, -0.09161887f, 
    0.14775887f, 0.17965889f, -0.08505651f, 0.07684173f, 0.13290526f, 0.03848450f, 0.01024131f, 0.01048317f, 
    0.48829269f, -0.12680911f, 0.16064034f, -0.02514585f, 0.04416421f, -0.12574469f, 0.21231930f, 0.20245200f, 
    -0.24375506f, 0.07068866f, 0.06943124f, -0.08886030f, -0.03560111f, -0.08081726f, 0.06992643f, 0.12331682f, 
    0.11150150f, 0.12964906f, -0.07134617f, 0.15315145f, 0.00695452f, 0.01819678f, 0.04004953f, -0.35142580f, 
    -0.20332134f, 0.04441274f, 0.15435915f, 0.04517380f, -0.01880026f, -0.10635422f, 0.13266006f, -0.02730962f, 
    0.01299661f, 0.11801611f, -0.07238162f, 0.00863879f, 0.11794472f, -0.27061924f, 0.01287718f, -0.19041875f, 
    0.12799840f, -0.30783242f, -0.19938505f, -0.09315008f, 0.00856569f, 0.08307167f, -0.04270918f, -0.10564549f, 
    0.14462826f, -0.00078358f, 0.02343682f, -0.06717035f, 0.13578182f, 0.21012884f, 0.12822445f, 0.15571168f, 
    0.20174266f, 0.08528687f, 0.17361191f, 0.15106376f, 0.37228242f, -0.26266897f, -0.11520866f, -0.11137713f, 
    0.00175780f, 0.01759108f, -0.07002988f, -0.08681779f, 0.11320816f, -0.07544044f, 0.00985088f, -0.08646579f, 
    -0.07469182f, 0.08961596f, 0.01686072f, 0.02196379f, 0.02297060f, 0.03467315f, 0.10318398f, -0.11044580f, 
    -0.10034479f, -0.12810910f, -0.04995874f, 0.12480894f, 0.36937049f, 0.07942092f, -0.02654780f, 0.21123746f, 
    -0.06200219f, 0.04502212f, 0.11388607f, 0.02985404f, -0.13059340f, -0.12478814f, -0.00529571f, 0.01461027f, 
    -0.09319885f, 0.04414155f, 0.21537715f, -0.16112417f, -0.03943889f, -0.10802191f, 0.16833892f, 0.05813861f, 
    -0.26804370f, -0.00512006f, -0.05788036f, 0.24684037f, -0.03619041f, -0.08604155f, -0.06932412f, 0.06372809f, 
    -0.01421916f, -0.04379228f, 0.18511514f, 0.12292720f, 0.01272396f, 0.05436036f, -0.21558656f, -0.02945807f, 
    0.01699651f, -0.27708846f, 0.08436272f, 0.22350805f, 0.08265270f, -0.02585744f, -0.10389606f, 0.01516009f, 
    0.03275900f, -0.02937704f, 0.00446183f, -0.01562391f, 0.05265170f, -0.13168432f, 0.00017090f, 0.08148441f, 
    0.02986754f, 0.06384195f, 0.00936823f, -0.07066790f, -0.13070729f, -0.07518125f, 0.02422447f, 0.31145969f, 
    0.09870463f, 0.01468717f, -0.02089512f, -0.18684596f, -0.16651024f, 0.08100051f, -0.15569837f, 0.02243075f, 
    0.03408485f, -0.05178249f, -0.05997429f, 0.06800709f, -0.08971862f, 0.00830020f, 0.01630809f, 0.08249201f, 
    -0.26110247f, 0.03780672f, 0.16305999f, 0.47160703f, -0.01184780f, 0.13029449f, 0.00821459f, -0.12497003f, 
    -0.26568043f, 0.08372977f, 0.02074724f, 0.00651783f, -0.07823507f, -0.12241586f, -0.09794191f, -0.00671129f, 
    -0.04511677f, -0.17439575f, 0.07363016f, 0.05435149f, -0.43969777f, 0.60327882f, 0.05101182f, -0.02904679f, 
    0.09190566f, 0.16793956f, 0.13490433f, -0.05094447f, 0.18777998f, -0.08993028f, -0.17949268f, -0.13768102f, 
    -0.02463848f, 0.09302606f, 0.05986756f, -0.13435680f, -0.06880259f, -0.13072151f, -0.12283935f, 0.03327434f, 
    0.37828633f, 0.11455462f, 0.08259570f, 0.09493986f, 0.09350646f, 0.15862060f, -0.10839803f, -0.10925138f, 
    -0.09975760f, -0.08407855f, 0.02120189f, -0.02311187f, 0.05060801f, -0.12042693f, 0.04303177f, 0.02891081f, 
    -0.08432947f, -0.04374368f, 0.17165866f, -0.02146872f, 0.19552933f, 0.24444570f, 0.07013109f, 0.10693806f, 
    0.67236763f, 0.09876927f, 0.11070922f, 0.19410931f, 0.30068511f, -0.08027074f, 0.00394982f, 0.09267065f, 
    -0.10133796f, -0.00016734f, 0.09892192f, -0.05004743f, 0.04142406f, -0.04912042f, -0.01349226f, -0.08359619f, 
    -0.01477304f, -0.05247659f, 0.06778466f, -0.05866114f, 0.13623512f, 0.05537910f, -0.17464057f, -0.08136194f, 
    0.00410494f, 0.06533512f, -0.03088142f, -0.06391980f, -0.12364036f, -0.03735971f, 0.00053976f, 0.06020092f, 
    -0.06017593f, 0.04238863f, 0.03820639f, -0.14776577f, -0.01841915f, -0.05280431f, -0.08019109f, -0.09030218f, 
    -0.14258030f, -0.06982468f, 0.12436829f, 0.14239883f, -0.11401816f, 0.03578354f, 0.00024827f, -0.02247983f, 
    -0.00084014f, -0.04659487f, 0.08846419f, 0.01617172f, 0.02580159f, -0.10075530f, -0.19296387f, 0.16016667f, 
    0.13911873f, -0.04816404f, 0.12804200f, 0.00697114f, -0.12104735f, -0.02223472f, 0.12919305f, 0.07997841f, 
    0.06789237f, -0.02902447f, -0.06207516f, -0.01015325f, -0.06166557f, 0.01938516f, 0.05996488f, 0.06836603f, 
    0.08443744f, 0.04550804f, -0.07840836f, 0.08642226f, -0.34045699f, 0.07937928f, -0.25518176f, 0.24922100f, 
    0.01259962f, 0.05592969f, 0.12026792f, 0.07444458f, -0.12475333f, 0.05762567f, -0.02926356f, 0.01136948f, 
    0.19911119f, 0.18345036f, 0.07253249f, 0.18832977f, 0.19931544f, 0.29196459f, 0.12060799f, 0.16388121f, 
    -0.09565283f, -0.17377286f, -0.09019448f, 0.20191288f, 0.20678431f, -0.11930960f, 0.00886601f, 0.08378549f, 
    -0.12219410f, -0.00713900f, 0.07913984f, 0.06698099f, -0.03957180f, 0.03518003f, -0.02277141f, 0.13741989f, 
    -0.09803796f, 0.08811845f, 0.25627473f, 0.01007355f, -0.35373694f, 0.03925830f, -0.31831300f, 0.25878388f, 
    0.05984505f, 0.02263786f, 0.21609882f, -0.12414068f, -0.04994132f, 0.20767909f, -0.12841156f, -0.01484698f, 
    0.25008103f, 0.24062586f, 0.10065283f, 0.04863477f, 0.19453737f, 0.17444105f, 0.11369781f, 0.18721086f, 
    -0.35209054f, -0.06911465f, -0.03755373f, 0.28096408f, -0.22727847f, -0.04491586f, 0.11187801f, 0.10314918f, 
    -0.24709488f, -0.10338684f, -0.12780310f, 0.14917530f, 0.06303089f, -0.13143118f, -0.06876598f, 0.11669456f, 
    0.02353651f, -0.04829796f, -0.06378860f, 0.07256210f, 0.39401686f, -0.01156692f, 0.03614521f, -0.04606945f, 
    0.01262307f, 0.00610671f, 0.09581234f, 0.14311396f, 0.06347939f, -0.24189095f, -0.00962505f, -0.02687649f, 
    -0.01897039f, 0.02550379f, 0.03507060f, 0.04799170f, 0.09026956f, -0.04538970f, 0.08139931f, 0.00782720f, 
    -0.33657327f, 0.03105153f, -0.03171359f, -0.03717766f, -0.12686723f, -0.01100990f, -0.01655804f, 0.10261770f, 
    0.08420108f, 0.03492502f, -0.01288362f, 0.05791619f, 0.07846157f, 0.07755924f, 0.08905007f, 0.03285478f, 
    0.10181610f, -0.07653202f, -0.17655435f, 0.04783504f, -0.16416572f, -0.17865099f, 0.07234648f, 0.17051522f, 
    -0.27073866f, -0.14187488f, -0.00048990f, 0.10821172f, -0.07042537f, 0.07776712f, -0.06204467f, -0.01886304f, 
    0.02714819f, -0.03037380f, 0.00926850f, 0.10943549f, 0.05385781f, 0.15873043f, -0.31816930f, 0.01538499f, 
    -0.06579496f, 0.02136830f, 0.11463363f, -0.13849585f, -0.09940505f, -0.06075545f, 0.10123748f, 0.02930393f, 
    -0.03502473f, 0.02793739f, -0.04833604f, -0.02377007f, -0.05626052f, 0.10708221f, -0.04226398f, -0.00739519f, 
    0.02589771f, 0.13337144f, -0.18949720f, -0.11866955f, 0.69723850f, -0.07266861f, -0.08553618f, 0.06860607f, 
    0.03060100f, 0.06081671f, 0.10530098f, 0.03656279f, -0.03941062f, 0.15111934f, -0.04746407f, 0.01175070f, 
    0.02426910f, 0.17302209f, 0.00912583f, -0.05946836f, -0.05110050f, -0.01551578f, 0.08973358f, 0.01540015f, 
    -0.13638984f, -0.06516418f, 0.04476431f, 0.05762359f, -0.20905575f, -0.15115836f, -0.05342016f, 0.12729606f, 
    -0.07874861f, 0.03377187f, 0.08204009f, 0.04763589f, 0.09790584f, -0.08039431f, -0.03430565f, 0.07911701f, 
    0.22779851f, 0.09316326f, 0.02269189f, 0.17689228f, 0.18307327f, -0.21448073f, -0.25761575f, 0.10681521f, 
    0.43064061f, -0.04825091f, -0.00920235f, 0.15989366f, -0.05237648f, 0.03073753f, 0.02885293f, 0.02330409f, 
    -0.00832947f, -0.08682212f, -0.00728870f, 0.00136069f, -0.01209328f, 0.10717283f, 0.26337636f, 0.10492099f, 
    0.13734993f, -0.12554641f, 0.02710861f, 0.03433872f, -0.14326890f, -0.16379479f, 0.17851105f, 0.08527708f, 
    -0.12741525f, 0.06332825f, -0.04801103f, -0.10352109f, -0.11132107f, -0.04158225f, 0.09668324f, 0.02652511f, 
    0.06141200f, 0.02134906f, -0.18372893f, 0.11181428f, -0.17777924f, 0.00272638f, -0.35426834f, 0.20297022f, 
    0.15023415f, 0.01448618f, 0.06515442f, -0.20902783f, -0.06296591f, 0.07184987f, -0.26058012f, -0.05525782f, 
    0.08546279f, 0.07337049f, 0.06930651f, 0.00050866f, 0.02974190f, 0.14270262f, -0.01581667f, 0.03915047f, 
    -0.59512913f, -0.17230460f, 0.07899915f, 0.03636837f, 0.21892872f, -0.19693114f, -0.10036918f, 0.08096851f, 
    0.05093214f, -0.08046708f, -0.07609160f, 0.01023458f, -0.07526010f, 0.01356096f, 0.09807552f, 0.11081102f, 
    -0.04700692f, 0.22182415f, -0.09076258f, -0.02242150f, -0.08858546f, -0.00196327f, -0.05301215f, -0.31537136f, 
    -0.13733229f, -0.04264591f, 0.07570526f, 0.00217400f, 0.03296932f, 0.03285749f, -0.00771266f, 0.09523387f, 
    0.06552409f, 0.06219739f, 0.03551784f, 0.10970722f, 0.09992613f, -0.15497994f, -0.24400976f, -0.09759727f, 
    -0.07959738f, -0.01412307f, 0.04650166f, 0.08435123f, 0.06853309f, 0.06336269f, -0.08006059f, 0.01589767f, 
    0.00060379f, -0.00809065f, 0.13571018f, 0.21084452f, -0.05594616f, -0.27059194f, -0.02670247f, 0.12785891f, 
    -0.17513810f, -0.11558999f, 0.04117844f, -0.10688441f, -0.08787538f, -0.03679398f, -0.03092438f, 0.13862234f, 
    -0.04418875f, 0.04018106f, 0.06048756f, -0.00916563f, 0.09415109f, -0.07118696f, 0.10641965f, 0.15924604f, 
    -0.04158260f, -0.03279717f, 0.04503946f, -0.02623322f, 0.02203058f, 0.21665987f, -0.16600950f, -0.11670823f, 
    0.04844376f, 0.05280210f, 0.02537426f, 0.07357584f, 0.00008200f, 0.01421691f, -0.02383519f, -0.06548712f, 
    0.00616372f, -0.06568360f, -0.05681244f, -0.05755136f, -0.01676339f, -0.04790219f, -0.06148188f, 0.04876981f, 
    0.03516174f, -0.01981642f, -0.04024859f, -0.01041064f, -0.01321091f, -0.05138865f, -0.05816219f, -0.03515134f, 
    -0.04510237f, -0.04156056f, -0.01467104f, -0.03438516f, -0.02827219f, -0.00156021f, -0.06519441f, -0.02272808f, 
    -0.03591850f, -0.02184286f, -0.02149380f, -0.05322858f, -0.03771448f, -0.06359354f, -0.01138892f, -0.00826140f, 
    0.04495048f, -0.01710440f, -0.03506167f, -0.02686084f, -0.04334584f, 0.02416357f, -0.02062719f, 0.00988356f, 
    0.03962259f, -0.01340195f, -0.01107213f, -0.06849123f, -0.01179757f, -0.05827321f, -0.02604784f, -0.01646889f, 
    -0.02177382f, -0.05202428f, -0.01045924f, 0.03304309f, 0.00253566f, -0.02169973f, -0.03610935f, 0.00594504f, 
    0.00641758f, 0.01597642f, -0.00301880f, 0.01818272f, 0.05205807f, 0.05153172f, -0.04417291f, -0.04372315f, 
    -0.00996696f, -0.06015006f, -0.03055974f, -0.00694204f, -0.00673884f, -0.05831839f, -0.04775364f, 0.00172225f, 
    -0.04231792f, -0.04444159f, -0.07327665f, 0.00834241f, -0.00925879f, 0.02378033f, -0.01002289f, 0.01336857f, 
    0.01933691f, 0.05490343f, -0.01643544f, -0.02271659f, -0.05653584f, -0.03212046f, -0.03307538f, -0.06083358f, 
    -0.08107941f, -0.05334410f, -0.02960545f, 0.00363490f, -0.04437960f, -0.04312579f, -0.04231443f, -0.03803060f, 
    -0.00984332f, 0.00395432f, -0.04530353f, -0.03855412f, -0.05047013f, -0.01450217f, -0.06792340f, -0.03544876f, 
    -0.00689373f, -0.04543372f, -0.02767858f, 0.00973591f, 0.06568921f, -0.00955312f, -0.04457743f, -0.02110963f, 
    0.00338641f, -0.00327408f, -0.00996212f, -0.00741641f, -0.01125153f, 0.07118747f, -0.00511874f, -0.01796259f, 
    -0.01077387f, 0.03665884f, -0.00897220f, 0.01305534f, -0.04767938f, -0.06358451f, -0.06259663f, -0.04886577f, 
    -0.05067171f, 0.00490669f, -0.00294192f, -0.06262210f, -0.05000471f, -0.02772655f, -0.04649312f, 0.02328766f, 
    -0.05334911f, 0.00060068f, -0.03683764f, -0.05741014f, -0.02217864f, 0.00395189f, -0.02234957f, -0.04827137f, 
    -0.02092587f, 0.00735215f, 0.00081940f, -0.01729278f, -0.03368535f, -0.05921181f, -0.06429118f, -0.01137234f, 
    -0.07924312f, -0.03414785f, -0.07566199f, -0.04982241f, -0.06327771f, -0.05619787f, -0.05532167f, -0.02319467f, 
    -0.00844002f, 0.03628930f, 0.00741748f, -0.05392016f, -0.02862451f, -0.04598216f, -0.05840280f, 0.00447585f, 
    -0.05987655f, -0.04529344f, -0.02399791f, 0.01036342f, -0.01753788f, -0.05912567f, -0.03571644f, -0.03231661f, 
    -0.06347097f, -0.07715698f, -0.04638357f, -0.04680831f, -0.00060892f, -0.05651898f, -0.00220617f, -0.00931034f, 
    0.04345193f, 0.05408053f, 0.05095439f, -0.03288452f, -0.00123118f, -0.01283277f, -0.05780087f, -0.00563040f, 
    -0.07015327f, -0.03133326f, -0.00687138f, -0.06364751f, -0.05704083f, -0.00364921f, -0.05701028f, -0.01659814f, 
    -0.02894690f, -0.00794533f, 0.02182920f, -0.01140533f, -0.06002719f, -0.00085465f, -0.00978389f, -0.01078515f, 
    -0.02013197f, -0.00489181f, 0.00081809f, -0.03156686f, -0.02892320f, 0.00181739f, -0.06111552f, -0.07425377f, 
    0.00687818f, -0.03113346f, -0.03489395f, -0.02691677f, -0.02228333f, 0.01489603f, -0.00253673f, -0.00479157f, 
    -0.01751527f, -0.04179987f, -0.03959978f, -0.05008940f, 0.02705821f, -0.02898596f, -0.01025953f, -0.06322524f, 
    -0.06092642f, -0.00204720f, -0.06487525f, -0.05564798f, -0.05221371f, 0.02539849f, -0.03904042f, 0.00403903f, 
    0.02956459f, -0.02134053f, 0.01240195f, -0.03355868f, -0.00275136f, -0.06420889f, -0.01066371f, -0.00878350f, 
    -0.04992768f, -0.03418630f, 0.00748043f, -0.02614792f, -0.03097087f, -0.01177509f, -0.05914925f, -0.00931707f, 
    -0.04945093f, -0.04326176f, -0.06889264f, -0.07476684f, -0.00755624f, -0.06451292f, -0.05911424f, -0.05151495f, 
    -0.00412347f, -0.00046377f, -0.04996291f, -0.06059227f, -0.05422858f, 0.01316889f, -0.05548069f, -0.00951379f, 
    -0.06844157f, -0.06674087f, -0.05468292f, -0.03518685f, -0.00177018f, -0.00338204f, -0.00429431f, -0.02604036f, 
    -0.01318799f, -0.06124033f, -0.07102504f, -0.03658965f, -0.06615875f, -0.02228967f, -0.05231003f, 0.03847885f, 
    0.00229354f, 0.02361853f, -0.04929524f, -0.03969087f, 0.05670526f, 0.02517822f, 0.02728423f, -0.02165917f, 
    -0.01678619f, 0.00218602f, 0.01756253f, -0.02486826f, -0.04302812f, -0.04556846f, -0.06486988f, -0.06503820f, 
    -0.00989180f, -0.01442229f, -0.01804266f, 0.04247803f, 0.00294929f, -0.00445454f, 0.00925417f, 0.01355030f, 
    -0.02423563f, 0.03350404f, 0.01231994f, -0.01605414f, -0.05875570f, 0.05036063f, 0.04254534f, 0.01367772f, 
    0.02003385f, -0.00442914f, -0.03912384f, -0.04810773f, 0.00823660f, -0.02646120f, -0.07613651f, -0.05764177f, 
    -0.00370343f, -0.03810676f, 0.07474620f, 0.05008580f, -0.01721695f, -0.00351902f, -0.03583436f, 0.01134508f, 
    -0.02280573f, -0.04668370f, -0.01798016f, -0.02018742f, 0.01699099f, -0.03816100f, -0.04578757f, 0.00650560f, 
    -0.02950708f, -0.02504992f, -0.02659530f, -0.02357821f, -0.04227949f, -0.05797754f, -0.05305195f, 0.01044820f, 
    -0.05896733f, -0.07207454f, -0.04380608f, -0.01836885f, -0.02915487f, -0.02115148f, -0.01954279f, -0.01193376f, 
    0.00482555f, -0.03188334f, -0.03287480f, 0.00927232f, -0.03143994f, -0.04727709f, -0.03147555f, 0.00754346f, 
    -0.02279083f, -0.05747187f, -0.01307643f, -0.05733411f, -0.00874035f, -0.00085399f, -0.00467558f, 0.05956379f, 
    0.00565356f, -0.04622006f, 0.01074650f, -0.00961813f, -0.01130724f, -0.06339493f, -0.04164082f, -0.08059027f, 
    -0.05379232f, -0.00533764f, -0.04421881f, 0.05833226f, 0.05725478f, -0.00525028f, -0.00438305f, -0.02834023f, 
    -0.06403884f, -0.00116893f, -0.03904628f, -0.04805117f, -0.03163337f, -0.05111477f, -0.00428779f, -0.01198292f, 
    -0.01171724f, 0.00353401f, -0.04985500f, -0.02139836f, -0.05241577f, 0.03966284f, 0.05218100f, -0.01670004f, 
    -0.04934785f, -0.01559921f, -0.04166296f, -0.03376653f, -0.02285308f, -0.04600677f, -0.04883060f, -0.07840972f, 
    -0.01277971f, -0.03846951f, -0.03075908f, -0.03741447f, -0.01517451f, -0.07211076f, -0.03812154f, -0.03932210f, 
    -0.00385431f, -0.00259147f, -0.00793591f, 0.07884284f, 0.01843507f, 0.06945199f, -0.02332052f, -0.00254714f, 
    -0.03484468f, -0.04891009f, -0.04394924f, -0.03146619f, -0.06110590f, -0.06249395f, -0.03880614f, -0.01994569f, 
    -0.06080098f, -0.02713445f, -0.00102042f, -0.03836121f, -0.02031717f, -0.02591520f, -0.07269486f, 0.00611460f, 
    0.03983944f, -0.02793616f, -0.00218580f, -0.03519566f, 0.00171630f, -0.01280506f, -0.04841908f, -0.03016355f, 
    -0.02329488f, -0.06815656f, -0.05821362f, -0.06981819f, -0.07102354f, -0.03900967f, 0.00171910f, -0.04448241f, 
    -0.02707168f, -0.01901377f, 0.04667396f, -0.03867184f, -0.02052994f, -0.00290154f, -0.06134043f, -0.00030811f, 
    0.00091764f, 0.00333537f, -0.02293391f, 0.01524713f, 0.02351421f, -0.05662210f, -0.03947188f, -0.03353685f, 
    -0.04482987f, 0.00295313f, -0.01814934f, -0.01380698f, 0.00419084f, -0.04335468f, -0.00446069f, 0.07709275f, 
    0.04430135f, 0.06939081f, -0.02324641f, -0.04248462f, 0.03504933f, -0.02793841f, -0.00508160f, -0.00582482f, 
    -0.01014033f, 0.03691404f, -0.01340637f, 0.04812002f, 0.00829909f, -0.02105190f, -0.02066335f, -0.05933858f, 
    -0.00154774f, -0.03423417f, -0.07455400f, 0.00901625f, -0.05339869f, 0.02854295f, 0.06457674f, 0.04234773f, 
    -0.02422496f, -0.04915203f, -0.01117578f, -0.07486321f, -0.04318664f, -0.04555715f, -0.06552123f, -0.05862048f, 
    -0.00871221f, -0.01037649f, -0.02051172f, -0.07328517f, -0.06532547f, -0.07264960f, -0.06654695f, 0.00466165f, 
    0.03062657f, 0.01489496f, -0.03621939f, -0.05594236f, 0.00085482f, 0.02628861f, 0.01323331f, -0.06693877f, 
    -0.01501862f, 0.01141599f, -0.04909267f, -0.05168455f, -0.02493089f, -0.00737843f, -0.05547846f, 0.01425638f, 
    -0.00484072f, -0.02312903f, -0.04269323f, 0.00046687f, 0.00461284f, -0.06340624f, -0.06045789f, -0.02923246f, 
    -0.06284725f, -0.05572786f, -0.01812296f, -0.03912090f, -0.04827384f, -0.04874239f, -0.05582876f, -0.04040106f, 
    0.02412903f, 0.02290003f, -0.02648717f, -0.06380144f, -0.02556905f, 0.00911364f, -0.01007019f, 0.00220296f, 
    -0.03162390f, 0.02148771f, -0.01038933f, -0.02973473f, -0.06733322f, -0.01580595f, -0.03880865f, 0.00257388f, 
    -0.01355792f, -0.02583870f, -0.01519161f, -0.07357310f, -0.01954784f, -0.00438955f, 0.04077113f, -0.01591640f, 
    -0.00024390f, 0.02682548f, -0.01080910f, -0.04040930f, -0.02462780f, -0.03785292f, -0.08493011f, -0.06257728f, 
    -0.02883611f, -0.04113729f, -0.04345011f, -0.01920401f, -0.01096732f, -0.07030308f, -0.04390435f, -0.00755423f, 
    -0.03070839f, -0.05076985f, 0.00547221f, 0.06518951f, -0.05453784f, -0.06098494f, -0.03905528f, -0.03204159f, 
    -0.06872003f, -0.07465811f, -0.06231899f, -0.03804541f, -0.02557145f, -0.06160985f, -0.05102347f, 0.00074926f, 
    -0.06003071f, -0.02105498f, -0.01575110f, -0.04041197f, -0.05137589f, -0.04857515f, -0.04182757f, 0.00364400f, 
    -0.06067531f, -0.00420578f, -0.06078402f, -0.04302688f, -0.00766679f, -0.06338985f, -0.06474870f, -0.03122907f, 
    0.06977387f, -0.21126461f, 0.63130021f, -0.33649689f, -0.06557533f, 0.03272849f, 0.10428923f, -0.13725798f, 
    0.08239707f, -0.05563978f, -0.10497312f, 0.03889444f, -0.06531596f, -0.00782986f, 0.01948970f, 0.10226644f, 
    -0.02988610f, 0.03469070f, 0.04739382f, 0.14358158f, 0.31913206f, 0.02874626f, 0.21338317f, -0.18466856f, 
    -0.23800354f, -0.01517933f, 0.13244879f, 0.07870720f, -0.01562579f, -0.05703294f, -0.21631074f, 0.01788954f, 
    0.04008362f, 0.02918090f, -0.01717553f, -0.00344300f, 0.16536470f, 0.05771878f, -0.08821315f, 0.11248510f, 
    0.06515951f, -0.17674565f, -0.18307054f, -0.06784298f, 0.05764045f, -0.03043815f, -0.08848195f, -0.16000786f, 
    0.13149323f, 0.01239101f, 0.03455558f, 0.06172446f, -0.02593322f, 0.06082131f, -0.11550771f, 0.10049888f, 
    0.07655554f, -0.05270104f, 0.05638687f, 0.03381900f, 0.19884633f, -0.17721580f, -0.08427270f, 0.11567666f, 
    -0.00927643f, 0.25034216f, -0.20104957f, 0.02527068f, 0.03137765f, 0.02382427f, -0.02067259f, 0.04888465f, 
    -0.00346872f, 0.04005682f, -0.06294699f, 0.04777910f, 0.10466320f, -0.08768045f, 0.07037931f, 0.07496592f, 
    -0.09966734f, -0.42796096f, -0.03764587f, 0.18062015f, -0.07748584f, -0.00842223f, -0.13704173f, -0.03416535f, 
    -0.17336339f, -0.14503503f, -0.02270604f, 0.04018931f, 0.06030526f, -0.06468630f, 0.05261820f, 0.08620958f, 
    0.08930235f, 0.03816241f, -0.11314537f, 0.18794441f, 0.11469963f, 0.17182896f, 0.17939109f, 0.14941670f, 
    -0.07151977f, 0.05735699f, -0.11603533f, -0.00625010f, -0.00322115f, -0.04457797f, -0.06711936f, -0.00336693f, 
    0.00662495f, -0.02619215f, 0.01898062f, 0.03806355f, -0.03058580f, 0.04702194f, 0.09440805f, 0.07302760f, 
    0.03343272f, -0.25261921f, -0.26923856f, 0.27984723f, 0.07973886f, -0.04051726f, 0.02985992f, 0.04372892f, 
    0.04449250f, 0.02452995f, -0.08043646f, -0.05073597f, -0.01542866f, 0.03758094f, -0.00535853f, 0.06914798f, 
    0.14696431f, 0.09141471f, -0.01590537f, 0.08124155f, -0.14120124f, -0.18172918f, -0.10557548f, 0.25686973f, 
    0.13050340f, 0.08405640f, -0.00506350f, -0.02613917f, 0.09719191f, 0.17578800f, -0.06146919f, 0.05604437f, 
    -0.00010673f, 0.06656676f, -0.02077002f, -0.00879508f, -0.05664696f, -0.01895880f, -0.09389614f, -0.01271676f, 
    0.02652832f, -0.19843827f, -0.12299468f, 0.23831044f, -0.00157618f, 0.11953682f, 0.02816706f, -0.07364716f, 
    0.03438413f, 0.23081867f, 0.12870237f, 0.20538393f, -0.04268762f, -0.00503571f, -0.04395384f, -0.02433483f, 
    -0.06362233f, 0.04561328f, 0.10134817f, -0.00311570f, -0.52847528f, -0.21372704f, 0.08682418f, -0.05299625f, 
    0.13674983f, -0.08583921f, 0.06383709f, 0.09281677f, 0.04360221f, -0.01853766f, 0.06333876f, 0.16263255f, 
    0.09870353f, 0.04098573f, 0.16534686f, -0.13541552f, -0.13943231f, 0.04866630f, -0.00921591f, -0.00287063f, 
    0.49466491f, 0.11585720f, -0.18186788f, 0.07078488f, 0.03476356f, 0.03493118f, 0.12530348f, 0.08855065f, 
    -0.04441791f, 0.25649324f, 0.15895613f, 0.00254727f, -0.09380113f, 0.01417714f, 0.01201612f, 0.05790579f, 
    0.03093071f, 0.11733811f, -0.04293016f, -0.04271535f, 0.82091904f, 0.02623383f, 0.35451737f, 0.23259418f, 
    0.71260804f, 0.06922917f, 0.22509822f, -0.02461058f, 0.23672381f, -0.14636615f, -0.19887048f, 0.01658911f, 
    0.11181369f, -0.00601144f, 0.09570529f, 0.09838967f, -0.23097757f, 0.13269110f, 0.23686892f, -0.03690983f, 
    0.22105901f, -0.30601624f, 0.00307356f, 0.06609394f, 0.02086735f, 0.10503260f, -0.05853824f, 0.04514337f, 
    0.15843961f, 0.13105471f, 0.07241993f, 0.02241904f, 0.01010401f, -0.08739958f, 0.01430263f, 0.08551272f, 
    0.04136533f, -0.02527676f, -0.02004936f, -0.01896694f, 0.04172657f, 0.22563772f, 0.06134708f, -0.05734043f, 
    -0.16389324f, -0.03798870f, -0.11446517f, -0.01929495f, -0.07768683f, -0.05292464f, -0.11442360f, -0.09498926f, 
    -0.03452776f, -0.09535433f, 0.06387860f, -0.15672575f, -0.01989191f, 0.24717002f, 0.10240480f, 0.11890705f, 
    -0.30331039f, 0.06828641f, 0.42230219f, -0.11260986f, -0.24107927f, -0.00596122f, 0.03949403f, -0.06929925f, 
    0.15538417f, -0.04590173f, -0.05748042f, -0.02192631f, -0.03638345f, -0.01688718f, -0.04780745f, -0.04961549f, 
    -0.05564798f, 0.10274782f, -0.05678188f, 0.06652419f, -0.08547816f, 0.04716729f, -0.01529428f, 0.25114036f, 
    -0.04822850f, 0.22603671f, 0.02325866f, 0.02335291f, 0.01703207f, -0.00449024f, 0.00913552f, 0.03393750f, 
    0.01411563f, 0.15246142f, 0.11943609f, 0.16572084f, 0.11002116f, 0.18238574f, -0.07150528f, -0.07266899f, 
    -0.08223294f, -0.20365793f, 0.10981628f, 0.32268995f, -0.12374141f, -0.02039690f, -0.15132712f, 0.04317733f, 
    0.06984700f, -0.06475072f, 0.04207756f, 0.08918392f, -0.02392464f, 0.10422982f, -0.03262045f, 0.18373388f, 
    0.09743531f, 0.01147420f, -0.15357730f, -0.19994996f, -0.36336112f, -0.10099573f, -0.05726669f, 0.12689039f, 
    -0.00398180f, -0.21627031f, 0.02270959f, -0.04808077f, 0.01129986f, -0.19014445f, -0.07473529f, 0.04518545f, 
    -0.00948338f, 0.11838511f, 0.01200456f, -0.07371330f, -0.03286422f, 0.10347290f, -0.10149419f, -0.06850146f, 
    0.16716547f, 0.19389632f, -0.01113485f, 0.14113458f, -0.06834621f, 0.05740896f, -0.11298231f, 0.05330949f, 
    0.10612568f, 0.09403015f, -0.07873406f, -0.02825562f, -0.01561095f, -0.01332500f, 0.10353611f, -0.05004675f, 
    -0.01848909f, 0.14985043f, 0.18401761f, 0.07497361f, 0.00985414f, -0.07586115f, 0.24374692f, -0.05275428f, 
    -0.16052990f, 0.16773768f, 0.04802603f, -0.10378683f, 0.05981312f, -0.03826932f, -0.07377685f, -0.04564708f, 
    -0.04565585f, -0.00486541f, -0.04838321f, -0.12906419f, -0.10918212f, 0.09297121f, -0.12944865f, 0.14509575f, 
    -0.56457847f, -0.07859889f, 0.07588977f, 0.04590679f, -0.02432598f, -0.08743351f, -0.06781347f, -0.06876782f, 
    -0.14018467f, -0.09679171f, -0.02796592f, 0.09540142f, -0.03533031f, 0.02200310f, 0.22414444f, 0.16203144f, 
    -0.10750183f, -0.00704158f, 0.01019452f, -0.01436132f, -0.37924254f, 0.04116109f, 0.11720440f, 0.10440617f, 
    -0.15366721f, -0.05972502f, -0.08517334f, -0.10555220f, 0.03493393f, -0.00082979f, -0.06410982f, -0.07602961f, 
    -0.03405682f, 0.03131263f, -0.05428507f, 0.15916675f, 0.06735170f, 0.02340307f, 0.04925218f, 0.14297137f, 
    -0.11431886f, 0.13221954f, 0.27179858f, -0.09884992f, -0.10390194f, -0.10504311f, 0.07153083f, -0.07960711f, 
    0.05902283f, 0.04146784f, 0.02947029f, 0.01689080f, 0.02891261f, 0.07309711f, 0.04449838f, 0.02240281f, 
    0.09701930f, 0.20080669f, -0.01768503f, 0.00446148f, 0.54758483f, 0.20817845f, -0.18503739f, 0.05724774f, 
    0.13211451f, -0.01773836f, 0.08796678f, 0.01970920f, 0.02039090f, 0.01524263f, 0.02313508f, 0.11246195f, 
    0.08523875f, 0.16681392f, -0.00184588f, -0.13090682f, -0.01224006f, 0.03082271f, 0.06501823f, 0.15425067f, 
    -0.18826509f, 0.05861320f, 0.18465950f, 0.09235921f, -0.31256336f, 0.04237901f, -0.09744246f, -0.06955063f, 
    -0.06199552f, -0.02398027f, -0.09615122f, -0.08494425f, -0.04420879f, -0.07123737f, -0.01825358f, 0.05983230f, 
    0.01383392f, 0.12000784f, -0.01959035f, -0.21829766f, -0.16349438f, -0.47205970f, -0.01430096f, 0.14470366f, 
    -0.06419167f, 0.06037388f, -0.17479660f, -0.01329710f, -0.10330694f, -0.25935185f, 0.11837835f, 0.02184694f, 
    -0.04976285f, 0.00934620f, -0.06429330f, 0.07861460f, -0.00139626f, -0.07909667f, -0.08195692f, -0.05883713f, 
    -0.06276650f, 0.12974261f, 0.32134968f, -0.17572959f, -0.05133111f, -0.01369543f, 0.01533062f, -0.01674115f, 
    0.10915633f, -0.00554986f, 0.02405926f, -0.02289189f, -0.00766120f, 0.04014910f, -0.02382556f, 0.09808495f, 
    0.01180599f, 0.12894775f, 0.02181402f, 0.13018057f, -0.31097096f, -0.06515950f, -0.10545965f, 0.04405310f, 
    0.05360581f, -0.11552852f, -0.10241894f, 0.04226822f, 0.17317310f, 0.07581078f, -0.12354882f, 0.01070576f, 
    -0.09057372f, -0.03940225f, -0.01019364f, -0.02248482f, -0.08683268f, -0.07257030f, -0.02455082f, -0.02298661f, 
    -0.40306848f, -0.05631983f, 0.23587975f, 0.17289959f, 0.19758366f, 0.11398987f, 0.04236644f, 0.16024958f, 
    0.24465503f, 0.15152563f, 0.01829874f, 0.09110090f, -0.13425550f, -0.02928039f, -0.04643704f, 0.14674717f, 
    0.00923891f, -0.00330161f, 0.28956914f, -0.08215620f, -0.09768368f, 0.01984175f, 0.02329566f, -0.18596973f, 
    -0.15524676f, -0.22105190f, -0.08319524f, -0.02236451f, -0.02460427f, -0.13422586f, -0.00455685f, 0.07728831f, 
    0.15126875f, 0.11313474f, 0.17621320f, -0.12070992f, 0.03920540f, 0.03908115f, -0.01501896f, -0.07065842f, 
    0.09523455f, -0.14826456f, -0.15527311f, 0.14345503f, -0.14114927f, -0.04867752f, -0.13393779f, -0.05707643f, 
    -0.09686849f, -0.09931590f, -0.04554731f, -0.04165747f, 0.10928786f, -0.09927172f, -0.00049203f, 0.01364560f, 
    0.01241075f, 0.05284391f, -0.02659711f, -0.01950355f, -0.01176497f, -0.09181319f, 0.09447701f, 0.05477928f, 
    0.10718588f, 0.02689483f, 0.16679986f, -0.06284220f, 0.03293547f, 0.06590938f, -0.04925918f, 0.01413040f, 
    0.10393763f, 0.08553220f, 0.11022583f, 0.06875447f, 0.08813693f, 0.23286502f, 0.07906970f, 0.13047124f, 
    -0.70045185f, -0.04164686f, 0.19781052f, 0.07201062f, 0.13855921f, -0.29682103f, 0.02400007f, -0.07112890f, 
    -0.09378852f, -0.06790852f, -0.01659931f, -0.03016054f, 0.00844376f, -0.05791711f, -0.02020568f, -0.04301705f, 
    -0.20477697f, -0.22228831f, -0.08095322f, -0.01192493f, -0.16847077f, -0.17315836f, -0.13910465f, 0.28218982f, 
    -0.28310928f, -0.17224829f, -0.06491458f, 0.01370108f, -0.00878357f, -0.00673946f, -0.14455563f, 0.00565144f, 
    -0.09189873f, 0.11770579f, 0.00475306f, 0.12987454f, 0.05549937f, 0.17478950f, 0.03086896f, 0.11482324f, 
    0.12241300f, 0.31556228f, -0.04403586f, 0.12644595f, 0.14211716f, 0.07862708f, -0.00949498f, 0.06417269f, 
    0.08933277f, -0.04242348f, -0.03314995f, -0.04991136f, -0.12535881f, -0.08954564f, -0.15056269f, -0.04424206f, 
    -0.20840602f, -0.00268274f, -0.14839850f, -0.20957081f, -0.15256472f, 0.25327983f, -0.04327122f, 0.00416097f, 
    0.23580308f, 0.21110955f, 0.18520440f, 0.10184748f, 0.05635365f, 0.18211025f, -0.11606795f, 0.14605509f, 
    -0.03641811f, 0.02874854f, -0.14568344f, 0.17868222f, -0.08600751f, 0.16546142f, -0.02348544f, 0.16221806f, 
    0.07249166f, 0.05101645f, -0.02660605f, -0.14939728f, -0.18784681f, 0.11491213f, 0.12304853f, -0.02923737f, 
    0.22027704f, -0.10450159f, 0.00401617f, -0.07385941f, 0.00962066f, 0.05891518f, 0.09566964f, 0.01157318f, 
    0.21468884f, 0.08685064f, 0.27395433f, 0.47619793f, -0.13797440f, -0.05389209f, -0.09135080f, 0.29911587f, 
    0.19507669f, -0.19074124f, 0.07626046f, -0.03884850f, 0.03959600f, 0.05517392f, -0.04113894f, -0.08106554f, 
    0.06265926f, 0.01037305f, 0.14081578f, -0.01623613f, 0.07094060f, 0.19325995f, 0.16303311f, 0.10863813f, 
    0.00361424f, 0.12450839f, -0.12495997f, 0.01145565f, 0.05957854f, 0.20249580f, 0.22281629f, 0.04677580f, 
    -0.02464015f, 0.11922853f, -0.09113954f, -0.04069351f, -0.04008933f, 0.01365031f, 0.08700249f, -0.04954483f, 
    -0.08615895f, -0.00027704f, 0.06794555f, 0.39004523f, -0.18625547f, 0.09880838f, -0.02854460f, -0.04442432f, 
    0.20800325f, 0.12471088f, 0.09858682f, 0.21366251f, 0.11831427f, 0.12196868f, -0.04709407f, -0.01592787f, 
    0.01362366f, 0.06733148f, 0.09277500f, -0.03680830f, -0.00124586f, 0.00008568f, 0.15430917f, 0.20315355f, 
    -0.16628765f, 0.13823858f, 0.23504217f, -0.28684875f, 0.02554678f, -0.10503270f, -0.09352499f, 0.05819132f, 
    0.36794415f, 0.12328044f, 0.04500126f, 0.08988820f, 0.09679547f, 0.00425615f, 0.05873954f, -0.03926763f, 
    0.11553559f, 0.07361040f, 0.12317647f, 0.21880674f, 0.16674411f, -0.03716828f, -0.13759620f, -0.16833073f, 
    0.13685620f, 0.03539837f, -0.10405381f, -0.14609869f, 0.00205122f, 0.05971752f, -0.02412364f, 0.28152800f, 
    0.20178072f, 0.03997795f, 0.07533988f, -0.07749560f, -0.05767542f, -0.08008457f, 0.09662460f, -0.07680339f, 
    -0.04464642f, 0.01779185f, 0.05423922f, 0.02577533f, -0.12634113f, -0.07301999f, 0.09241875f, 0.03438603f, 
    0.22527568f, 0.16085674f, -0.02937553f, -0.01466772f, 0.02876368f, -0.02075074f, -0.00898061f, -0.00709075f, 
    0.18288681f, 0.01416528f, 0.01490979f, 0.08578975f, 0.00169434f, 0.45697302f, 0.43070278f, 0.06045553f, 
    -0.16344433f, -0.16837683f, 0.04383022f, 0.39418769f, -0.07877715f, -0.13756177f, 0.01816556f, -0.04631161f, 
    -0.02195884f, 0.08732799f, 0.01528828f, 0.06992391f, 0.23941001f, 0.37232110f, 0.15992433f, 0.01309673f, 
    -0.15234590f, 0.11554951f, 0.02520747f, 0.03137625f, 0.19670106f, 0.16028211f, 0.17358656f, 0.01127974f, 
    0.07065607f, 0.15162987f, -0.03053878f, 0.16703759f, 0.04499297f, 0.08540508f, -0.04775821f, 0.05366161f, 
    0.18149464f, -0.02223922f, 0.21065766f, 0.24179235f, -0.14115535f, -0.03405778f, -0.12763873f, -0.07249911f, 
    -0.07761206f, 0.11083954f, -0.04921744f, -0.00166343f, -0.04946670f, -0.09810578f, -0.18356146f, 0.09407695f, 
    0.02691530f, 0.06309509f, -0.00941721f, 0.00469581f, 0.09618735f, 0.28997168f, -0.00229858f, -0.01659513f, 
    -0.43503356f, -0.08159285f, -0.20090234f, -0.01413629f, -0.05629163f, -0.13067533f, -0.11670066f, 0.06920966f, 
    0.05584206f, -0.06147687f, -0.08843391f, -0.12070236f, -0.06349277f, -0.02182475f, -0.06034131f, 0.02566493f, 
    0.01820490f, -0.03010316f, -0.09085295f, -0.10997236f, 0.13868710f, 0.33538833f, 0.33955505f, -0.05058634f, 
    -0.13181007f, 0.13671090f, 0.05372846f, -0.06812717f, 0.16929178f, 0.00311299f, -0.07129388f, -0.05966787f, 
    -0.01227952f, -0.04199593f, 0.08442703f, 0.04963914f, -0.04043247f, 0.05961629f, 0.02628082f, -0.18845175f, 
    0.08859050f, 0.15395519f, 0.31782252f, -0.05584095f, -0.18068571f, 0.19699679f, 0.08729127f, 0.03981050f, 
    0.11778995f, 0.00688138f, 0.01200004f, -0.05579221f, 0.02455174f, 0.03397076f, 0.06837449f, 0.14696783f, 
    -0.14287154f, -0.07335626f, -0.16969246f, -0.39100868f, -0.05317906f, 0.37773126f, -0.02866963f, -0.11645564f, 
    -0.01599709f, 0.13778314f, 0.02407124f, 0.09334950f, 0.02783247f, -0.02155674f, -0.08636586f, -0.19651257f, 
    -0.16814454f, -0.08860501f, -0.07151294f, -0.11920836f, -0.29507658f, 0.07162779f, -0.09574312f, -0.17619969f, 
    0.19093823f, 0.03373354f, 0.24147102f, -0.06822670f, 0.26197177f, 0.12775467f, 0.04752389f, 0.06033552f, 
    0.07791388f, 0.08432156f, 0.15139012f, 0.02358630f, 0.07976151f, 0.04776970f, 0.25840014f, -0.01904276f, 
    0.08872725f, 0.27993497f, 0.18037961f, 0.15578973f, -0.51291764f, -0.01678769f, -0.28626770f, 0.18015243f, 
    -0.05942834f, -0.03466329f, -0.06279529f, 0.06563443f, -0.01886483f, 0.08903300f, -0.16197337f, -0.01290620f, 
    -0.07938020f, -0.02063035f, 0.00104656f, 0.14290382f, -0.13590875f, 0.15675625f, -0.02345078f, -0.00616621f, 
    -0.09179047f, 0.02217533f, 0.11380950f, -0.01732059f, 0.13859268f, -0.09458666f, -0.30904600f, -0.23600549f, 
    -0.06829724f, -0.21116830f, 0.09234379f, 0.17621312f, -0.14675257f, -0.00486119f, 0.20324712f, 0.03845816f, 
    -0.07802418f, 0.18530925f, 0.11262060f, -0.05362503f, -0.64325714f, 0.03850080f, 0.08025407f, 0.20806497f, 
    0.20044325f, -0.20281588f, -0.11556507f, -0.22679216f, -0.12136567f, 0.02730969f, -0.09714156f, 0.00409386f, 
    0.26500529f, -0.12347303f, 0.08380661f, -0.07896683f, 0.05016990f, -0.11473083f, 0.23453799f, 0.05954628f, 
    -0.21698010f, -0.09181007f, -0.16392238f, 0.24836117f, -0.05618888f, -0.10261444f, -0.02966032f, 0.00487079f, 
    -0.10970635f, -0.04326756f, 0.05624058f, -0.04989424f, 0.03047717f, -0.03727391f, 0.15036120f, -0.01791087f, 
    0.17444886f, -0.09577570f, 0.13162421f, 0.17937225f, 0.14970461f, 0.54973924f, 0.07378514f, 0.06295957f, 
    0.08910094f, 0.00177232f, 0.13344938f, 0.24018064f, 0.21639262f, 0.18674511f, 0.01967604f, 0.17486592f, 
    -0.00212296f, 0.00455792f, -0.13041788f, -0.04081426f, -0.02606525f, 0.21918376f, 0.04060925f, -0.08878261f, 
    -0.23614651f, -0.13292299f, 0.02430034f, 0.09318483f, 0.03022472f, -0.16387691f, -0.06046727f, -0.07325190f, 
    -0.12557498f, -0.13639104f, -0.21449625f, -0.24120750f, -0.09222623f, 0.15097414f, 0.10121428f, -0.06848301f, 
    -0.16983514f, -0.02246097f, -0.15960447f, -0.15061304f, 0.03012849f, 0.11828586f, 0.12667400f, -0.04170864f, 
    -0.14605930f, 0.07900289f, 0.07939547f, 0.04004255f, -0.13221464f, -0.11412172f, 0.11400691f, 0.06785844f, 
    0.08324862f, 0.03104234f, 0.02226856f, 0.04712808f, -0.14563702f, 0.16762400f, -0.31440291f, -0.35439473f, 
    -0.34680951f, -0.01579933f, -0.21733819f, 0.09789833f, 0.18958238f, -0.05171946f, -0.15156500f, -0.08623173f, 
    -0.01280471f, -0.05410195f, 0.03513000f, 0.04856602f, 0.05311408f, -0.00933855f, 0.02076448f, -0.01748140f, 
    0.00138500f, 0.01394056f, -0.04463874f, 0.00475152f, -0.27251843f, 0.35440877f, -0.27474263f, -0.32491472f, 
    0.05185689f, 0.09109505f, 0.11011513f, 0.14182393f, -0.06137164f, 0.22814414f, -0.12685478f, 0.04672297f, 
    -0.06079854f, -0.10710221f, -0.13171913f, 0.01519017f, -0.10995059f, -0.08800138f, -0.00281781f, 0.00769197f, 
    0.01807656f, 0.41020951f, -0.26619238f, 0.13068292f, 0.38617316f, 0.09757028f, 0.12271013f, 0.08704293f, 
    0.11774939f, 0.37192005f, -0.05983204f, 0.12271141f, 0.01580047f, -0.03719932f, 0.09327390f, 0.04599955f, 
    0.04396631f, -0.14534681f, 0.16731027f, 0.15960672f, -0.16703016f, -0.11086453f, -0.14820214f, 0.03571331f, 
    -0.23919018f, -0.24921718f, -0.32382369f, -0.10139505f, -0.17630099f, -0.18345036f, 0.05678101f, 0.00358643f, 
    -0.10382596f, 0.00561091f, 0.05715755f, -0.21255583f, 0.14929885f, 0.01971586f, 0.14555284f, 0.01144871f, 
    -0.15062736f, -0.13496538f, -0.01009677f, -0.21170089f, -0.15438834f, -0.20810650f, -0.18709373f, -0.11749228f, 
    0.01746831f, -0.09295174f, 0.03400794f, -0.12689275f, -0.12042566f, -0.12860391f, -0.03055818f, -0.08819809f, 
    0.35310385f, 0.12057189f, 0.21817125f, 0.20860514f, 0.07423943f, 0.08586057f, -0.23699088f, 0.05768240f, 
    0.08829869f, -0.08868056f, 0.03897666f, 0.11090592f, -0.17935368f, 0.10270572f, 0.02900108f, 0.01780060f, 
    0.05529229f, 0.09548949f, 0.13296296f, 0.06140173f, 0.15486652f, 0.06092651f, 0.08811885f, 0.13457061f, 
    -0.10166383f, 0.32446280f, -0.14045370f, -0.00984691f, 0.14922912f, 0.06131576f, -0.00190319f, -0.07441396f, 
    0.08410929f, 0.10502277f, -0.03066882f, 0.02037746f, -0.11536211f, -0.06946912f, 0.06197870f, -0.05985020f, 
    -0.01888205f, 0.00126244f, 0.16476978f, 0.03569069f, -0.53743106f, 0.21774466f, -0.23472859f, 0.09888595f, 
    0.03198881f, 0.00472701f, -0.22991866f, -0.43084735f, -0.26015943f, -0.03640702f, 0.08289390f, 0.08174321f, 
    -0.04423420f, -0.15779740f, 0.07103941f, 0.06065308f, 0.01366567f, -0.17334162f, -0.14212288f, -0.12004350f, 
    0.04840077f, 0.19502035f, 0.26998678f, 0.19026993f, 0.03354493f, -0.00106832f, 0.09612264f, 0.08491823f, 
    -0.00531231f, 0.10070972f, 0.05425600f, 0.00565942f, 0.13768461f, 0.07642718f, 0.26758343f, 0.00332992f, 
    0.19056532f, -0.01165056f, -0.07186960f, 0.28521937f, 0.04842319f, 0.16314514f, 0.20102991f, 0.28372231f, 
    0.11856414f, 0.05469345f, 0.11020587f, 0.04599462f, 0.12785354f, -0.13881661f, 0.19189540f, -0.05704212f, 
    0.05321581f, 0.00226636f, 0.14590624f, -0.09523322f, 0.02859391f, 0.09270180f, -0.11840504f, -0.01332828f, 
    0.51078314f, 0.48834324f, 0.39699084f, 0.10246573f, 0.02014293f, 0.02272620f, 0.13381967f, 0.06705400f, 
    0.10405281f, 0.38826886f, 0.00956989f, -0.01984165f, -0.07047977f, -0.05697957f, -0.03427915f, -0.03638079f, 
    -0.29979679f, -0.10677918f, -0.23928840f, -0.05997311f, -0.46272051f, -0.18442874f, -0.10210960f, -0.38783100f, 
    -0.09003797f, 0.00052276f, 0.01622169f, -0.11414938f, -0.26495773f, -0.20668034f, -0.05526973f, 0.05093166f, 
    0.09678032f, -0.04402804f, -0.03458826f, 0.09357311f, 0.07380535f, 0.09547666f, -0.06377940f, -0.08126102f, 
    0.33296037f, 0.26132110f, 0.47352582f, -0.08806364f, 0.04386590f, 0.14373799f, 0.09238891f, 0.01049557f, 
    0.09227986f, 0.07663827f, 0.11928655f, 0.04852894f, 0.08529199f, 0.02210997f, 0.01627955f, 0.00872245f, 
    -0.03973420f, -0.05107674f, 0.06265476f, 0.08233026f, 0.16504669f, 0.17642358f, 0.22304802f, 0.01312932f, 
    0.13182962f, 0.05257909f, 0.12905219f, -0.05541555f, 0.09786541f, -0.07153505f, 0.01743542f, -0.06264795f, 
    0.04941287f, 0.07392264f, 0.04942621f, 0.05949114f, 0.02478080f, 0.00416258f, -0.01941929f, -0.01538746f, 
    0.07590663f, 0.25999606f, -0.00154475f, -0.06027142f, 0.26867351f, 0.05846320f, -0.00466331f, -0.05012436f, 
    0.20308976f, -0.06118912f, 0.00816914f, -0.03222091f, 0.04203961f, 0.09188125f, 0.13332340f, 0.05543098f, 
    0.08064430f, -0.14492260f, -0.15657242f, 0.05652588f, 0.25022304f, 0.26238957f, 0.11647733f, 0.04660758f, 
    0.04462269f, 0.10564347f, -0.06303605f, 0.11002275f, 0.00048036f, -0.07582951f, -0.07625426f, 0.01728568f, 
    0.00378896f, -0.10739662f, 0.17709607f, -0.02117177f, 0.15104067f, 0.12986025f, 0.00706621f, -0.07797195f, 
    0.21966274f, 0.21503621f, 0.04680347f, 0.08804988f, 0.29558194f, 0.13528059f, -0.06627023f, 0.01477612f, 
    0.11772476f, -0.19953401f, -0.05509169f, 0.03617854f, 0.02429934f, 0.10303101f, 0.07990091f, 0.07057258f, 
    0.06333009f, 0.08265150f, -0.16068304f, 0.21288723f, -0.21890622f, 0.04762941f, -0.25850749f, 0.05624686f, 
    -0.09502650f, 0.14108095f, -0.08511395f, -0.10472869f, -0.33866373f, 0.00916934f, 0.01079005f, -0.14262454f, 
    -0.07623576f, 0.09950233f, 0.00560197f, 0.11246870f, 0.03950384f, -0.15083008f, -0.10796623f, -0.03248833f, 
    0.24044098f, 0.10765659f, 0.16310890f, 0.13613558f, 0.26704270f, 0.15402265f, 0.03040220f, 0.10395472f, 
    0.07946528f, 0.01980687f, 0.10343590f, 0.04702203f, -0.02596188f, 0.08528756f, 0.06127867f, 0.05143711f, 
    -0.04367778f, 0.11560429f, -0.09990295f, -0.11725765f, -0.39043683f, -0.03269189f, -0.03354584f, 0.06717741f, 
    -0.16208066f, 0.03246009f, -0.04887056f, -0.12567927f, -0.10506814f, -0.00750288f, 0.11619972f, -0.02950683f, 
    -0.02985973f, 0.00581507f, -0.22856139f, 0.17706729f, -0.05046916f, -0.27741355f, -0.14643963f, -0.10821026f, 
    -0.47550955f, -0.06147474f, 0.12913714f, 0.02479118f, 0.24596858f, 0.04129520f, -0.03909813f, -0.18540597f, 
    -0.08975851f, 0.06126778f, -0.00586540f, -0.06100480f, -0.03069313f, -0.22335126f, -0.01236336f, 0.12565422f, 
    0.07537606f, -0.02288916f, -0.03686498f, 0.04466800f, -0.06232455f, 0.21778423f, 0.16798624f, 0.00655773f, 
    0.05879152f, -0.11834208f, -0.00380532f, 0.07438355f, -0.12967758f, 0.08532662f, -0.00456163f, 0.05425522f, 
    0.00097645f, 0.00961837f, -0.02795618f, 0.04325201f, 0.09102529f, -0.05830061f, 0.08264598f, 0.21838477f, 
    0.09399842f, 0.24282999f, 0.37225291f, 0.17568639f, 0.08468262f, -0.11123236f, 0.13776881f, -0.17459187f, 
    0.07623779f, 0.21116911f, 0.10369866f, -0.00531161f, -0.01814379f, -0.13745344f, 0.01130100f, -0.01591041f, 
    0.14071526f, 0.09004226f, -0.12708601f, 0.29864171f, -0.02613674f, 0.18219085f, 0.50942510f, 0.24685495f, 
    0.26150411f, 0.03428077f, 0.10802556f, 0.13968733f, -0.13538603f, 0.09082078f, -0.02167971f, 0.05440462f, 
    -0.02535292f, 0.07591813f, 0.34947315f, -0.11711285f, 0.22575839f, -0.05471661f, -0.01201487f, 0.16380560f, 
    -0.04063415f, 0.19990669f, -0.13495824f, -0.21840733f, -0.15331188f, 0.01994871f, -0.04035003f, -0.16764286f, 
    -0.05909907f, -0.15921174f, 0.03758901f, -0.00988172f, -0.05189004f, 0.14742619f, -0.07157147f, 0.20669402f, 
    -0.01395319f, -0.12829895f, 0.02409798f, 0.03920436f, -0.52812344f, -0.07753829f, 0.22905387f, 0.26594135f, 
    0.17363046f, -0.08011847f, 0.05044026f, -0.12804310f, -0.10221862f, 0.10885106f, 0.18214306f, -0.11903279f, 
    0.04374747f, -0.18358594f, -0.00849847f, -0.23831832f, 0.19584130f, 0.20722376f, -0.05701293f, -0.09586869f, 
    -0.02144879f, 0.02734545f, -0.24504545f, -0.29519668f, -0.27911851f, 0.12959963f, -0.13430505f, -0.03692465f, 
    0.04972253f, 0.05034209f, 0.07135681f, 0.02784904f, 0.02987450f, 0.00592128f, 0.08627525f, -0.06735322f, 
    0.12673058f, 0.29069078f, 0.19570911f, -0.04249679f, -0.60802019f, -0.10617574f, -0.13996537f, -0.40552554f, 
    -0.02349984f, 0.03630976f, 0.11042045f, -0.21549153f, -0.10682370f, -0.13289134f, 0.05360493f, 0.10792325f, 
    0.04110711f, 0.00897572f, -0.07179381f, 0.22987637f, -0.01264346f, 0.02409506f, 0.02281812f, -0.10910832f, 
    -0.21045697f, -0.14711517f, -0.15622093f, -0.27147555f, -0.07759423f, 0.00824461f, -0.03181525f, -0.23331642f, 
    -0.04618638f, -0.03918861f, -0.05212033f, -0.07802529f, 0.03028147f, -0.17993248f, 0.05296239f, 0.06503286f, 
    -0.09292461f, -0.18007056f, 0.07824451f, -0.06801739f, 0.19130172f, 0.02410122f, 0.10753760f, 0.20555657f, 
    0.06074808f, 0.07331084f, 0.02665781f, -0.15048361f, 0.08294071f, -0.03959290f, -0.14865753f, -0.03056709f, 
    0.14545546f, -0.01538939f, -0.00102962f, -0.01899869f, 0.13681258f, 0.10357664f, -0.18541980f, 0.10052904f, 
    -0.20272629f, -0.20639640f, -0.29831854f, -0.14517024f, 0.04380932f, -0.05868493f, -0.13871612f, 0.00515507f, 
    -0.01458833f, 0.01090521f, 0.03184804f, 0.14659585f, 0.00503497f, -0.07095111f, 0.13132364f, 0.09672569f, 
    0.20897903f, 0.20433331f, 0.23419663f, 0.24098462f, 0.11197917f, 0.18717904f, 0.54404706f, 0.24642196f, 
    0.21790293f, 0.04641693f, 0.21760431f, 0.01529446f, 0.20174369f, 0.33837920f, 0.01767096f, -0.01578422f, 
    0.02696341f, 0.00590594f, -0.04288830f, -0.09882534f, 0.16733080f, -0.05421873f, -0.01797388f, 0.21059638f, 
    -0.39278087f, -0.06213466f, -0.08915832f, -0.06770474f, 0.05896047f, 0.08155803f, -0.03814728f, -0.08310307f, 
    0.10722538f, -0.03288399f, -0.05359237f, -0.05605897f, -0.01995070f, -0.00475280f, -0.05635956f, 0.09784476f, 
    0.02218149f, -0.07012598f, 0.13434424f, -0.01464975f, 0.11631332f, 0.08124025f, 0.42492849f, 0.31591135f, 
    0.27093256f, 0.05385797f, 0.11718460f, 0.12140269f, -0.01924071f, -0.13142210f, -0.00922302f, -0.03082019f, 
    0.08654144f, 0.11899736f, 0.12926042f, 0.05899007f, 0.01560770f, 0.02890370f, -0.01010688f, -0.00002747f, 
    -0.12179605f, 0.01602187f, 0.41918999f, -0.09894217f, 0.02629028f, -0.11931588f, 0.08066433f, -0.09453930f, 
    -0.16325152f, -0.07901464f, 0.04481992f, -0.06746174f, 0.10084844f, -0.04890476f, -0.10383120f, 0.08396132f, 
    0.01761954f, -0.03973498f, 0.07392843f, 0.07289908f, -0.18876763f, -0.33988824f, -0.32796106f, -0.06888376f, 
    0.11807561f, 0.20877558f, -0.11256436f, -0.14930263f, -0.02106635f, 0.02848019f, 0.07885993f, 0.11947687f, 
    0.17125465f, 0.12546572f, 0.15083458f, 0.28112659f, 0.16609448f, -0.23475769f, -0.11797057f, -0.15558572f, 
    0.13005257f, 0.09203929f, -0.10183848f, 0.05646360f, 0.05867597f, 0.09280767f, -0.07244471f, 0.04251387f, 
    -0.00149652f, 0.11254011f, 0.00494683f, 0.09517229f, 0.07897517f, 0.09221379f, -0.00328720f, 0.17214453f, 
    -0.31723419f, -0.26194581f, -0.31492138f, -0.23165332f, -0.41134539f, -0.07461741f, -0.00235599f, -0.18061377f, 
    -0.16636696f, -0.21057278f, 0.06876802f, -0.15695925f, -0.37120512f, -0.08654334f, 0.01971588f, 0.04222941f, 
    0.13873258f, -0.11890691f, -0.10497032f, 0.09678124f, -0.06259742f, -0.10474639f, -0.18918051f, -0.16684961f, 
    0.01598867f, 0.01115827f, -0.01147522f, -0.01283179f, 0.02994156f, -0.03738428f, 0.02567824f, -0.03160218f, 
    -0.03172792f, -0.02651590f, -0.03761813f, -0.02556688f, 0.01284851f, -0.02377882f, -0.01068919f, -0.00615769f, 
    -0.03975408f, -0.01571954f, 0.01753220f, -0.01756004f, -0.04305465f, -0.03100351f, -0.03044893f, -0.01062946f, 
    -0.04049464f, -0.03841604f, -0.02136126f, -0.00060583f, -0.02043310f, -0.00462602f, 0.01563056f, 0.01835180f, 
    -0.00674268f, -0.01450372f, -0.03260120f, -0.00143358f, -0.01339985f, 0.01370017f, -0.01609991f, -0.01604532f, 
    -0.02372114f, 0.02213402f, -0.03675213f, -0.04092711f, 0.02813117f, 0.01322682f, 0.01982607f, -0.03332889f, 
    0.00612849f, -0.03164682f, -0.01853156f, -0.03017366f, 0.02946367f, 0.00652490f, 0.00469267f, 0.00688858f, 
    0.00432820f, 0.00903534f, -0.00931077f, -0.02193018f, 0.00445678f, -0.03113045f, -0.00742003f, -0.01596709f, 
    0.01026294f, -0.04049025f, 0.00471124f, -0.00687374f, 0.02599405f, -0.00880731f, -0.02323310f, 0.00766669f, 
    0.01115513f, 0.01902918f, -0.02290201f, -0.03879174f, 0.00974831f, 0.00661091f, -0.01223008f, -0.01853781f, 
    -0.04024312f, -0.01354731f, 0.00907950f, 0.02880790f, -0.03728727f, -0.00926945f, -0.00813183f, 0.01040392f, 
    -0.01343295f, 0.02125063f, 0.00645081f, -0.04137161f, 0.00277783f, -0.00481651f, 0.01736761f, -0.01800347f, 
    -0.02085219f, 0.02425896f, 0.00480057f, 0.00650761f, -0.01852999f, -0.02281286f, -0.00090524f, -0.02669720f, 
    0.01082981f, 0.00475399f, 0.02602918f, -0.01438091f, -0.01794437f, -0.03072064f, -0.03589521f, 0.02275906f, 
    -0.01603301f, -0.03714603f, 0.01419043f, -0.04217254f, 0.03035565f, 0.00781735f, -0.04358485f, 0.02373055f, 
    -0.02110855f, 0.00491132f, -0.02708518f, -0.03501116f, 0.00892490f, 0.00936293f, -0.01071530f, -0.01414441f, 
    -0.04159388f, 0.01874131f, -0.01859092f, -0.01347652f, 0.02517840f, -0.03349105f, -0.01972597f, 0.00604099f, 
    -0.04186365f, -0.02025530f, 0.01160093f, -0.02066384f, -0.01729509f, 0.01214860f, -0.01600672f, 0.00293724f, 
    -0.02358527f, -0.02865692f, -0.02824925f, -0.03634086f, 0.02261826f, -0.03511257f, 0.01378624f, 0.03104104f, 
    0.01389119f, 0.00647470f, -0.02656895f, 0.01489355f, -0.00009349f, 0.02681864f, 0.00122323f, -0.01198120f, 
    0.01528683f, -0.01922436f, -0.02502073f, -0.00305726f, 0.02524255f, -0.01369758f, 0.00249741f, 0.01619206f, 
    0.00876581f, 0.01278688f, -0.04160462f, -0.02204128f, 0.00172391f, -0.04538486f, 0.00053319f, -0.02110175f, 
    -0.00153213f, 0.01675332f, 0.02762779f, -0.02411425f, 0.00219175f, -0.00760057f, 0.00127589f, -0.03761711f, 
    0.02418783f, -0.00142440f, 0.01913355f, 0.03134515f, 0.00808774f, -0.04302878f, -0.03636727f, -0.03694230f, 
    -0.04520670f, 0.01265157f, -0.04405773f, -0.02645845f, -0.04087824f, -0.02629150f, -0.03544609f, -0.00471608f, 
    -0.01665694f, -0.03010969f, 0.02566480f, -0.01532216f, 0.02804961f, -0.02145401f, 0.01027770f, -0.02768423f, 
    0.03269461f, 0.00506111f, 0.03110744f, -0.02854095f, 0.00744406f, 0.00964053f, -0.03155926f, -0.01554557f, 
    -0.04411378f, -0.03854106f, -0.02392685f, 0.01065522f, 0.02593859f, -0.01774174f, -0.03489619f, 0.02694774f, 
    0.00800317f, 0.00841454f, -0.00810163f, 0.00047751f, 0.00053727f, 0.02727520f, -0.03412892f, 0.00192029f, 
    -0.01151807f, 0.01068652f, 0.01869742f, -0.04527814f, 0.00518028f, 0.01256678f, -0.02459067f, 0.00236959f, 
    0.01185217f, 0.01722351f, -0.01347405f, -0.02270396f, -0.01521783f, 0.01097087f, 0.02772779f, 0.01184641f, 
    -0.02794213f, -0.04090491f, 0.00310909f, -0.02377127f, -0.00906908f, 0.02218970f, 0.00320591f, -0.00241660f, 
    0.02968640f, -0.00323691f, 0.01255076f, 0.02431292f, 0.02478455f, -0.03143147f, 0.01743805f, 0.01379524f, 
    -0.02974158f, -0.00454083f, -0.04408382f, 0.00556530f, 0.02800275f, -0.04066038f, -0.04392194f, -0.01316544f, 
    0.02341726f, -0.03203200f, 0.01751477f, -0.01076742f, 0.00746059f, 0.00623362f, -0.02751092f, -0.03533682f, 
    0.01609104f, -0.01168380f, -0.01232626f, -0.02356165f, 0.00030888f, -0.00869805f, 0.00683247f, 0.00757211f, 
    -0.02668428f, -0.00463756f, 0.02758698f, 0.03245514f, -0.03411391f, -0.02075346f, 0.02742812f, -0.00258610f, 
    0.00090057f, -0.00635962f, -0.00638793f, -0.03663431f, -0.03614448f, 0.03147336f, -0.04344494f, -0.02599579f, 
    -0.03318208f, -0.04106271f, -0.02035294f, -0.00222047f, 0.03029841f, 0.00847608f, -0.02850678f, -0.03549296f, 
    -0.01247744f, 0.00325297f, 0.02415676f, -0.04295846f, 0.02560881f, -0.01553807f, -0.04263236f, -0.03736025f, 
    -0.02600488f, -0.02495454f, -0.04216462f, 0.00471258f, -0.04540858f, 0.02744791f, 0.00101010f, 0.02301793f, 
    -0.02057451f, -0.00110183f, -0.02401400f, 0.00991952f, -0.02362109f, 0.01507881f, -0.03715509f, -0.00259504f, 
    -0.00144798f, 0.02735879f, -0.01250642f, -0.02860700f, -0.01295996f, -0.02464973f, 0.01761036f, -0.00923131f, 
    0.02661236f, 0.03304610f, 0.02810119f, 0.00934086f, 0.00600107f, -0.02720398f, 0.02332361f, -0.01573727f, 
    0.03069939f, 0.02040215f, 0.03279965f, 0.02732895f, -0.04268402f, -0.01189576f, -0.03272492f, 0.03185377f, 
    -0.01569295f, -0.03652287f, -0.00431615f, -0.02872319f, -0.00605930f, 0.00072124f, -0.03479179f, -0.00896391f, 
    -0.01537907f, -0.00909650f, -0.02836385f, 0.00204147f, 0.00559282f, -0.03019660f, 0.02615174f, -0.04257417f, 
    -0.01482728f, -0.02511169f, 0.00771114f, -0.02329066f, -0.01404278f, 0.01810972f, -0.03149900f, -0.00800114f, 
    -0.01466969f, -0.00290177f, 0.01828836f, -0.03597786f, -0.00286945f, 0.02268054f, -0.04223579f, 0.02363991f, 
    -0.01369176f, 0.00517665f, -0.03679533f, -0.03482518f, -0.00901264f, -0.00827804f, -0.00135326f, -0.00599302f, 
    0.00670951f, 0.01150890f, -0.00025899f, -0.04435464f, -0.01984493f, -0.00357488f, 0.01474063f, -0.03446948f, 
    0.01114743f, 0.01364990f, 0.01956721f, -0.00522517f, -0.01085671f, 0.02231757f, 0.00952987f, 0.00861558f, 
    -0.03400893f, -0.00717416f, 0.00928023f, 0.00020170f, 0.01545051f, -0.04325986f, -0.03267204f, -0.01741774f, 
    0.02661179f, -0.00500604f, 0.02936033f, -0.03014220f, -0.03885537f, -0.02897990f, 0.01853517f, 0.00298929f, 
    -0.04546992f, 0.00114759f, -0.04435991f, -0.03850975f, -0.00899833f, 0.03211171f, -0.02747997f, 0.03138985f, 
    0.03243313f, -0.02858327f, 0.00824288f, 0.01791229f, 0.00869570f, 0.01511208f, 0.01131568f, 0.02926728f, 
    0.02925966f, -0.00205740f, -0.03395475f, 0.02749218f, -0.01291757f, 0.01524311f, 0.02301628f, -0.01160337f, 
    0.03216013f, 0.02074964f, -0.02183606f, -0.04190743f, 0.00618261f, -0.02536318f, -0.00205961f, 0.03125937f, 
    -0.01801209f, -0.04471638f, -0.00464921f, -0.02624706f, -0.03095906f, 0.02560687f, 0.00359892f, 0.01393548f, 
    -0.04050816f, -0.03974143f, -0.01139287f, -0.00334820f, 0.03117053f, -0.04355315f, 0.02435730f, 0.01281775f, 
    -0.01477337f, 0.02198359f, 0.00572855f, -0.02286036f, 0.00151416f, 0.03312081f, 0.00928157f, 0.00036893f, 
    -0.03802888f, -0.00749209f, 0.01623504f, 0.00591948f, -0.02743270f, -0.00215310f, 0.01446838f, -0.03823430f, 
    -0.00531390f, 0.03021428f, -0.02518280f, 0.01653116f, 0.02361131f, 0.02065523f, -0.03098006f, -0.02629776f, 
    -0.01495288f, -0.00067452f, -0.04080993f, 0.03311996f, 0.02734636f, 0.02028718f, -0.03669241f, -0.03722189f, 
    0.00529746f, -0.00544834f, -0.02427680f, -0.03587693f, -0.03781137f, -0.03042221f, 0.01123668f, 0.01538876f, 
    -0.02601477f, 0.03091278f, 0.00073341f, -0.01366542f, -0.01863798f, 0.01030160f, -0.02293613f, -0.00830380f, 
    -0.01686270f, 0.01641673f, -0.02156982f, 0.00954480f, 0.01545652f, -0.03600351f, 0.02041913f, -0.02832985f, 
    0.01427102f, -0.03425017f, -0.02329499f, -0.03275531f, -0.03194232f, -0.02229155f, 0.02202061f, -0.03032242f, 
    0.02159152f, -0.03134018f, -0.01887175f, 0.03197760f, 0.00410161f, -0.00069958f, 0.01499200f, -0.03593536f, 
    -0.02855603f, 0.02941541f, -0.00635383f, 0.01957064f, 0.02411758f, -0.02533971f, -0.03607063f, -0.02130397f, 
    -0.01385207f, -0.04139209f, 0.03351198f, -0.00077081f, 0.03283925f, -0.00354418f, -0.04242676f, -0.03846571f, 
    -0.00639725f, -0.01381512f, -0.00896731f, 0.01416917f, -0.04160998f, -0.00831671f, -0.03447109f, 0.01040544f, 
    -0.00634971f, 0.02407606f, -0.02840118f, 0.00224094f, 0.02211348f, 0.01944636f, 0.03295883f, 0.00840827f, 
    0.00350762f, -0.01350433f, -0.03788946f, 0.01247146f, 0.03406867f, 0.02370823f, 0.02530476f, 0.01826397f, 
    0.03692801f, -0.02748639f, -0.01166437f, -0.03425941f, -0.03430370f, -0.00810948f, -0.00664356f, -0.00756722f, 
    -0.03792780f, -0.01667819f, 0.02487588f, -0.02429666f, 0.03326685f, 0.01593392f, -0.00400884f, -0.01845690f, 
    -0.02985703f, -0.00717556f, -0.02214746f, -0.01290585f, 0.00837155f, 0.03083113f, -0.00678136f, 0.02065163f, 
    0.02333646f, -0.02362779f, -0.00108657f, 0.01202285f, 0.02920801f, -0.02133803f, -0.04174654f, -0.02236916f, 
    -0.01397363f, -0.01089225f, -0.00743189f, -0.03637058f, -0.04474968f, -0.03866809f, -0.03770707f, 0.02310410f, 
    -0.00637471f, -0.02511266f, 0.02633564f, -0.00604300f, -0.02279457f, -0.04432981f, -0.00401290f, -0.01579616f, 
    0.02045751f, 0.04412066f, 0.04790952f, 0.00082335f, 0.00486961f, -0.01823967f, -0.00311156f, 0.01867700f, 
    0.01946088f, -0.04943753f, -0.01824190f, -0.04988339f, -0.04711507f, 0.01743159f, 0.00399522f, 0.01441985f, 
    0.03041317f, -0.02328059f, -0.03035870f, -0.01695704f, 0.00357500f, 0.01031580f, 0.02087783f, 0.02106424f, 
    -0.01850379f, -0.04047766f, 0.00526752f, 0.01945842f, 0.00486633f, -0.02720439f, -0.00280450f, 0.01793826f, 
    -0.03566904f, -0.02160432f, -0.03714628f, 0.01051786f, 0.03567189f, -0.01545340f, 0.02622134f, -0.03819931f, 
    0.00613151f, 0.00439593f, -0.02252099f, 0.02050225f, 0.01410707f, 0.02114280f, 0.01088552f, -0.00957564f, 
    0.03562380f, -0.02889025f, 0.00663988f, 0.03410552f, 0.02159025f, 0.00311020f, 0.02489177f, 0.00832879f, 
    -0.01485606f, -0.01219521f, -0.03823163f, -0.04110869f, -0.01139308f, -0.04439655f, 0.00486807f, -0.00276787f, 
    -0.02770813f, -0.00767614f, 0.03636902f, 0.02249772f, -0.03364849f, -0.04206041f, -0.00394084f, 0.00658407f, 
    0.00034809f, -0.00987055f, -0.02795300f, -0.02841168f, 0.00302650f, -0.01921938f, -0.00697622f, -0.01624536f, 
    -0.01969932f, 0.02906349f, -0.02139974f, 0.03932684f, -0.02009076f, 0.00265707f, 0.00889799f, 0.01922533f, 
    -0.03462852f, -0.04700359f, -0.01315839f, -0.02534348f, -0.00721237f, -0.01345716f, -0.01535835f, 0.01379432f, 
    -0.02948091f, -0.01251637f, -0.01633760f, -0.02518185f, -0.02613093f, -0.02454748f, -0.00718156f, -0.03015430f, 
    0.00976939f, 0.01380434f, -0.01232711f, 0.02764309f, -0.02469837f, -0.02678184f, 0.00400226f, -0.00714253f, 
    -0.00655175f, -0.03922246f, -0.01906606f, 0.02344520f, -0.02289499f, -0.00404781f, -0.02135846f, -0.04055920f, 
    0.03075527f, 0.02484531f, -0.02476327f, 0.02474914f, -0.01776103f, -0.03977119f, -0.01947215f, -0.00702478f, 
    -0.03588104f, -0.03727761f, 0.00514502f, 0.03420977f, -0.01284915f, 0.03040284f, -0.02054188f, -0.03464222f, 
    -0.03820842f, 0.02661215f, 0.00301783f, -0.01593434f, 0.02979952f, -0.03059511f, 0.02090643f, -0.00800858f, 
    -0.01975531f, -0.01374856f, -0.03429426f, 0.02712949f, 0.02852413f, -0.01130699f, -0.03746824f, -0.01428110f, 
    -0.02836004f, -0.04296844f, -0.03688382f, -0.01656356f, 0.03687746f, 0.00428061f, -0.03517234f, 0.00463812f, 
    -0.01734100f, 0.02443944f, -0.00773464f, -0.02478067f, 0.00156775f, -0.00353458f, -0.03155043f, -0.02538686f, 
    0.00429816f, 0.00092471f, 0.02470769f, -0.01608854f, -0.01153747f, 0.02629457f, 0.03813766f, 0.02610191f, 
    0.02242583f, 0.03893313f, 0.01777308f, -0.02368287f, -0.00780436f, 0.00767877f, -0.02580416f, 0.00677991f, 
    -0.00294005f, -0.02611553f, -0.03520931f, 0.03239910f, -0.02495973f, -0.03224116f, 0.02703353f, 0.00149203f, 
    -0.03741553f, -0.03564897f, -0.03733175f, 0.03045751f, -0.00003785f, -0.00177815f, 0.00308461f, 0.00904991f, 
    -0.03318407f, 0.02486168f, -0.01954866f, -0.04270060f, -0.00271848f, 0.00806761f, -0.03892291f, 0.01572784f, 
    -0.00040612f, -0.00787176f, -0.03812185f, -0.01609833f, -0.03169378f, 0.02282154f, 0.01401935f, -0.02806787f, 
    0.02666874f, 0.02907025f, -0.03221417f, -0.02982689f, 0.01572261f, 0.03326191f, 0.03782506f, 0.02925202f, 
    -0.01977890f, 0.01366163f, 0.00856796f, -0.03396390f, -0.03519407f, 0.01291715f, 0.00342515f, 0.01933546f, 
    -0.03901652f, -0.04536556f, -0.03235247f, 0.02324294f, 0.02481944f, -0.03707711f, -0.00832279f, -0.00842843f, 
    -0.00871955f, -0.02728415f, -0.01507121f, 0.00711558f, -0.03132673f, 0.02808776f, 0.00668889f, -0.00743757f, 
    0.02317604f, -0.03511220f, 0.00708413f, -0.01924828f, 0.01494091f, 0.00382978f, 0.01465172f, 0.02413636f, 
    -0.01423552f, -0.03728338f, 0.01679035f, -0.00121205f, -0.01384922f, 0.01721836f, 0.04068577f, -0.02719567f, 
    0.01692236f, 0.01177200f, -0.03552729f, -0.03857924f, -0.01176039f, -0.02441600f, 0.00474395f, 0.00499505f, 
    -0.03362063f, -0.00342242f, -0.02767086f, -0.00664421f, 0.01603489f, -0.00888654f, 0.00635361f, -0.03080060f, 
    -0.00292354f, 0.00575725f, 0.03045142f, -0.00834379f, -0.02206828f, -0.02121443f, -0.02398965f, -0.01558069f, 
    0.02115381f, 0.02031401f, 0.00578598f, 0.01825643f, -0.04357439f, -0.03083880f, -0.03393282f, 0.00768260f, 
    0.03012166f, 0.01475199f, -0.00572188f, 0.01932394f, 0.01404321f, 0.03097619f, 0.01921916f, 0.02061607f, 
    -0.02418791f, 0.00449421f, 0.03327167f, -0.03372994f, 0.02061324f, -0.02902250f, 0.02779819f, -0.03285357f, 
    0.03275378f, -0.02293844f, 0.01791780f, -0.01476573f, 0.01970435f, -0.02856582f, -0.02126138f, -0.01299818f, 
    -0.00636676f, 0.02190751f, 0.02397543f, -0.00382403f, 0.04727800f, -0.01821872f, -0.01594318f, -0.02044849f, 
    -0.02706502f, -0.04190181f, 0.00970625f, 0.01890684f, -0.01651502f, 0.03574581f, -0.00406474f, 0.00139341f, 
    -0.02259937f, 0.03310116f, 0.01668752f, 0.00847111f, -0.00381570f, -0.03153772f, -0.03445058f, 0.01764470f, 
    0.02039579f, 0.04934701f, 0.03185960f, 0.00145821f, -0.00017545f, 0.02491347f, -0.01867237f, -0.03056957f, 
    -0.03074455f, 0.01777763f, -0.01410464f, 0.02116742f, -0.02565289f, -0.03218177f, -0.01936729f, 0.02793274f, 
    -0.04609976f, -0.01828576f, 0.01533868f, -0.01343626f, 0.02363012f, 0.03092584f, -0.03457544f, 0.02008709f, 
    -0.02995452f, -0.03311571f, 0.02030054f, -0.03832401f, -0.02103094f, -0.00917137f, -0.02565623f, -0.04336202f, 
    0.00211121f, -0.03885882f, 0.03014282f, -0.01754840f, -0.03403340f, 0.01247521f, -0.01432815f, 0.03981769f, 
    0.03365523f, -0.01300076f, -0.02435506f, 0.00051213f, -0.02404637f, 0.00123746f, 0.02093243f, 0.03184995f, 
    0.00476293f, -0.03853328f, -0.01698238f, 0.01829167f, -0.00780920f, -0.02912812f, -0.03314073f, 0.01360639f, 
    -0.02572335f, 0.04605094f, -0.01340832f, -0.01239004f, -0.00109530f, 0.02368835f, -0.03827941f, -0.02634224f, 
    0.01249234f, 0.01357621f, -0.01151067f, -0.03324322f, 0.01118721f, 0.02493028f, 0.01855490f, -0.00224014f, 
    -0.01960999f, -0.02826362f, 0.00887629f, -0.02031179f, 0.02263002f, -0.00861756f, -0.00187897f, -0.02257234f, 
    -0.01033112f, 0.01477076f, 0.03231374f, -0.00694215f, -0.03671654f, -0.01857576f, -0.01733054f, 0.02464537f, 
    -0.02421128f, -0.03980798f, -0.01069722f, -0.00834041f, 0.00821255f, -0.01989125f, -0.02403245f, -0.03304895f, 
    -0.02492496f, -0.00771929f, 0.03557369f, -0.03070687f, -0.00674935f, 0.03184286f, 0.01070716f, -0.01406858f, 
    -0.02283420f, -0.05014728f, 0.02011776f, -0.02769143f, -0.03118101f, -0.02496806f, -0.02879304f, -0.00500631f, 
    0.01434400f, -0.01507645f, -0.03932640f, -0.00225769f, 0.01804247f, -0.00071061f, -0.00016387f, -0.00094422f, 
    0.01769633f, 0.02504221f, -0.00784332f, -0.03503494f, -0.02232079f, -0.02629380f, -0.03203162f, -0.00478976f, 
    -0.00334658f, -0.03885205f, 0.02213197f, 0.00418734f, 0.00849933f, -0.00716546f, 0.01414771f, -0.02894737f, 
    -0.02118915f, -0.02390315f, -0.03142440f, 0.00527190f, 0.03134977f, 0.01958212f, 0.03305605f, -0.01091107f, 
    -0.01400888f, -0.01962605f, 0.03882870f, -0.00650699f, 0.01811467f, -0.04529497f, 0.01490717f, -0.02374023f, 
    0.02641909f, 0.00088085f, -0.00473713f, 0.01219841f, -0.01017910f, 0.04196355f, 0.01467565f, -0.01714943f, 
    -0.00779444f, 0.01123886f, 0.02558038f, 0.00386750f, 0.00846495f, 0.03627266f, -0.00055826f, -0.02001659f, 
    -0.00397034f, 0.02893582f, 0.02336713f, 0.01923123f, -0.00851853f, 0.02798020f, -0.00153124f, 0.00252768f, 
    -0.00218316f, -0.01884104f, 0.00664134f, -0.04645467f, 0.00884639f, 0.00111007f, 0.03167225f, -0.01668710f, 
    -0.04511314f, 0.01813966f, 0.02561001f, -0.01693110f, 0.00893356f, 0.00186374f, -0.02929197f, -0.03254521f, 
    0.02010522f, -0.02303805f, -0.01919299f, 0.02632328f, 0.02126513f, -0.01068144f, -0.02941981f, 0.01526620f, 
    -0.00392166f, 0.00656171f, -0.01717242f, -0.02724146f, 0.01440138f, 0.01926918f, -0.03408868f, -0.02495160f, 
    0.03224145f, 0.02730598f, 0.01914724f, -0.00701916f, 0.02007665f, -0.03637281f, 0.00959388f, 0.01626865f, 
    0.02982600f, -0.03724088f, -0.00206175f, -0.03331488f, 0.01723309f, -0.02677139f, 0.01578088f, -0.03108988f, 
    -0.01980571f, -0.01146655f, 0.02561338f, -0.00644632f, -0.03467359f, 0.00983788f, -0.03207652f, -0.00519310f, 
    -0.02614039f, -0.02750373f, -0.01557253f, 0.00232824f, -0.02357269f, 0.02417636f, 0.00182842f, -0.02559892f, 
    0.00708637f, -0.04087849f, 0.01874033f, -0.02789494f, -0.04629182f, -0.04227334f, -0.03557352f, 0.03058044f, 
    0.02018426f, -0.02441710f, -0.01978093f, -0.00723448f, 0.02282462f, 0.01257341f, -0.02755301f, 0.01123892f, 
    -0.01646718f, -0.02829995f, 0.02582491f, 0.01631051f, -0.01260857f, -0.01527815f, -0.02213275f, 0.02246478f, 
    0.02082697f, 0.02874363f, 0.01164552f, -0.00875932f, -0.03101883f, 0.00689969f, -0.00586451f, -0.04406924f, 
    0.00183946f, 0.01823307f, 0.01174346f, 0.02727000f, 0.01118892f, 0.03136767f, 0.01926294f, -0.01499143f, 
    -0.01756793f, -0.03202242f, -0.00530799f, -0.01085309f, 0.02168685f, 0.02415538f, 0.01020837f, 0.01156670f, 
    -0.01685853f, -0.01901348f, -0.01699404f, -0.01141667f, -0.00571038f, -0.04179216f, -0.01698289f, -0.01636345f, 
    0.00224298f, -0.03387955f, 0.03194595f, 0.01125388f, 0.02268337f, 0.02420696f, -0.02217778f, -0.03761876f, 
    0.01550394f, 0.01921366f, 0.01672724f, -0.00833974f, 0.01408110f, -0.03558317f, 0.01788054f, 0.01131864f, 
    -0.03930893f, -0.01251131f, -0.00944328f, 0.02475149f, 0.02790572f, -0.03719166f, -0.02879042f, -0.03787844f, 
    0.03222366f, -0.03548821f, 0.02258943f, 0.02706407f, -0.03538894f, -0.01036223f, 0.00668556f, 0.02758632f, 
    -0.04529580f, -0.03770043f, -0.04388116f, -0.01160496f, -0.04061959f, -0.04044348f, 0.00090589f, -0.01071022f, 
    -0.00855805f, 0.00632255f, 0.00284554f, -0.04179711f, -0.02182688f, 0.02102646f, -0.02199451f, -0.02111151f, 
    0.01974159f, -0.02070766f, 0.00321721f, 0.01165364f, -0.03741916f, 0.03266609f, -0.03789964f, 0.03271041f, 
    0.01939868f, 0.01629178f, -0.02540590f, -0.02479582f, 0.03267129f, -0.00328442f, 0.00946548f, 0.01118684f, 
    -0.01971600f, -0.00128839f, 0.01537639f, -0.03461146f, -0.00068874f, 0.00614838f, 0.01542250f, -0.04463511f, 
    0.01268931f, 0.02358710f, -0.01959621f, 0.02248570f, -0.03632747f, 0.01680631f, -0.01275689f, -0.01486681f, 
    0.03036031f, -0.02516155f, -0.01850706f, 0.01672752f, 0.02076334f, -0.01309314f, -0.01110343f, -0.03014341f, 
    0.00489437f, -0.01819249f, 0.02875080f, 0.02371409f, -0.04056733f, 0.00854004f, 0.00133571f, -0.01515980f, 
    -0.01396496f, 0.02944582f, -0.00407557f, -0.02429525f, -0.01937477f, -0.02361117f, -0.02282611f, -0.02691706f, 
    0.02244948f, 0.01201259f, -0.00202208f, -0.00221475f, -0.02196207f, -0.02972892f, 0.00629212f, 0.00625949f, 
    0.00875603f, -0.03765059f, -0.04267883f, -0.01882057f, -0.00649894f, 0.02764006f, 0.02865326f, 0.02030551f, 
    -0.03957223f, -0.01218934f, -0.03292593f, -0.03235370f, 0.01472594f, 0.03280953f, -0.03156374f, -0.04168381f, 
    -0.01554296f, -0.04034011f, 0.00353491f, -0.00049619f, 0.01648972f, -0.02143199f, -0.02153439f, 0.00593435f, 
    -0.03626810f, 0.02989904f, -0.00444165f, -0.03287303f, 0.00435250f, -0.00359244f, -0.03708990f, -0.01546996f, 
    -0.00799984f, -0.00572470f, 0.01230614f, -0.03974117f, -0.01663159f, -0.02524910f, -0.01860830f, -0.04025513f, 
    0.03298447f, 0.00121774f, 0.00065937f, 0.02406663f, -0.03778213f, 0.00921600f, -0.00452896f, 0.00635637f, 
    -0.01924211f, 0.00025715f, -0.02204029f, 0.01426345f, -0.00464679f, -0.04043023f, 0.01869597f, -0.02027636f, 
    0.00825597f, -0.00753997f, -0.02112547f, -0.01589426f, -0.01108914f, 0.00676096f, -0.01375324f, 0.03063543f, 
    -0.03207572f, 0.01899378f, 0.02802308f, -0.02954509f, 0.01211426f, -0.01516908f, -0.01397743f, -0.00689037f, 
    -0.04407691f, -0.03298016f, 0.02094263f, 0.00963091f, -0.03773606f, -0.02076927f, -0.02976417f, -0.02342174f, 
    0.01065239f, 0.03296250f, -0.04140300f, -0.01441806f, 0.00131227f, -0.02480051f, 0.02840570f, -0.02632087f, 
    0.02090791f, 0.00466431f, -0.02319887f, 0.00175878f, 0.01731346f, -0.01572373f, -0.01592592f, 0.00232960f, 
    -0.01416687f, -0.02875020f, -0.00362051f, -0.01282401f, 0.02400889f, 0.01816217f, -0.02296149f, -0.00866113f, 
    0.03181653f, 0.03275859f, -0.00157948f, -0.03583613f, 0.02032457f, -0.03426016f, -0.03593343f, 0.02642252f, 
    0.01628294f, 0.00823643f, -0.00528431f, 0.00811752f, -0.01844096f, 0.01636417f, 0.01442925f, 0.00782841f, 
    0.01733352f, -0.03664758f, -0.03718206f, -0.01072392f, 0.02696925f, -0.00814875f, 0.02312622f, 0.00266730f, 
    -0.03596453f, -0.02990406f, -0.00609343f, -0.01245834f, -0.00005053f, 0.00201843f, -0.01800058f, -0.02619654f, 
    -0.04187569f, 0.00519940f, -0.00224473f, 0.02378877f, -0.00249652f, 0.00948412f, 0.02513687f, -0.03927082f, 
    -0.02299808f, -0.04360387f, -0.04397783f, -0.02668663f, 0.01255014f, 0.02646414f, 0.01269462f, -0.02558261f, 
    0.00528977f, 0.02799460f, 0.01060678f, 0.03087361f, 0.02834040f, 0.01051763f, -0.00355933f, 0.03345070f, 
    -0.04284575f, -0.00446028f, -0.02431605f, -0.01540700f, 0.02014382f, 0.01343874f, -0.00539477f, -0.03040024f, 
    -0.04049335f, -0.03812243f, -0.03122276f, 0.01640660f, 0.01136942f, -0.00883396f, 0.00571540f, -0.02973518f, 
    -0.03150290f, 0.02185388f, 0.02568572f, -0.02846435f, 0.02222141f, 0.01849716f, 0.02070783f, -0.00363543f, 
    -0.04104033f, -0.00913534f, -0.03599240f, -0.02873364f, -0.02617655f, -0.01924161f, -0.02330937f, -0.04471481f, 
    -0.01798557f, -0.00822287f, 0.01561973f, 0.00611385f, 0.02747325f, -0.01788809f, 0.00003097f, 0.01307347f, 
    -0.04228248f, 0.02087119f, -0.01463490f, -0.01942779f, -0.02739252f, -0.01683038f, 0.00440180f, -0.00011007f, 
    0.02964743f, -0.03943446f, -0.03080151f, -0.01999843f, 0.01201164f, 0.01322117f, 0.01397594f, 0.01151421f, 
    -0.02190004f, 0.02303841f, 0.00879443f, -0.02557986f, -0.03655336f, -0.00494928f, -0.02971687f, 0.00020553f, 
    0.00695472f, 0.00563759f, 0.01231902f, -0.03108490f, 0.00566632f, 0.02231457f, -0.02640735f, 0.02383244f, 
    0.00313641f, -0.03735027f, -0.01335215f, 0.00875673f, 0.01944870f, -0.02170202f, -0.00501679f, -0.00790884f, 
    -0.02775555f, 0.02386037f, -0.03162090f, -0.00573671f, -0.01047451f, 0.02016282f, -0.03560753f, -0.04206139f, 
    -0.02321012f, -0.04010134f, -0.01214633f, -0.03928082f, -0.00974195f, -0.02422576f, 0.00295692f, -0.02063294f, 
    0.01087399f, -0.04394886f, 0.03297491f, -0.03648394f, 0.01638359f, 0.03268193f, 0.01484858f, 0.02583379f, 
    -0.00343808f, 0.00250110f, -0.00652621f, 0.02769233f, 0.02000574f, -0.02257870f, 0.00625973f, 0.00519804f, 
    -0.00575689f, -0.03299802f, 0.01168285f, 0.00276578f, 0.01379441f, -0.00006266f, 0.00664817f, -0.02825053f, 
    0.02414572f, -0.01444046f, -0.02666645f, 0.02035308f, -0.02464819f, -0.02004396f, -0.00514878f, -0.02723252f, 
    0.02166721f, -0.02807209f, 0.02451674f, 0.03246149f, -0.03795889f, 0.02342129f, -0.01644371f, -0.00824322f, 
    -0.04391273f, 0.02170558f, -0.00901595f, 0.02300711f, -0.00162644f, 0.00560664f, -0.03759796f, 0.01777994f, 
    -0.02868697f, -0.02473068f, -0.01549711f, 0.00109979f, -0.00967904f, -0.03272055f, -0.01293608f, 0.02449056f, 
    0.00834880f, -0.02852828f, -0.02534683f, -0.01471173f, -0.01245520f, -0.02728818f, 0.02110588f, -0.03505078f, 
    -0.00130180f, -0.03338286f, 0.03560229f, 0.02111200f, 0.03238224f, 0.01519806f, 0.00845759f, 0.03282253f, 
    0.02159517f, 0.00148898f, -0.04383239f, -0.00045801f, -0.03295496f, -0.04185332f, -0.01204062f, -0.02840448f, 
    -0.01621151f, -0.00902040f, 0.00084941f, 0.00661765f, -0.03800624f, -0.03365519f, -0.01911754f, -0.02897268f, 
    -0.04275168f, -0.00992319f, -0.01776794f, 0.02313987f, -0.02345741f, -0.01348379f, 0.02761317f, -0.02608422f, 
    -0.01747028f, 0.01780326f, -0.02160912f, 0.00676835f, 0.01464742f, -0.01254116f, 0.01536081f, -0.03578033f, 
    -0.01889700f, -0.00900383f, -0.01841476f, 0.01592492f, 0.00156726f, -0.03102051f, -0.01126873f, 0.02191800f, 
    -0.03608275f, -0.01249492f, 0.01366778f, -0.02604474f, -0.04058692f, 0.01539146f, 0.01983393f, 0.01848554f, 
    -0.00796410f, -0.00390169f, -0.03754950f, 0.02316996f, 0.01277926f, -0.01743956f, 0.00551839f, -0.02041808f, 
    -0.02392867f, -0.03845826f, -0.02344412f, 0.02008242f, -0.00644363f, -0.01666358f, -0.03236917f, -0.03254078f, 
    0.01057386f, -0.03240188f, 0.03088029f, -0.02076801f, 0.00692997f, -0.01565595f, 0.01966768f, 0.03012170f, 
    -0.01755591f, 0.00386544f, -0.03815241f, -0.03847780f, 0.02414481f, -0.00605229f, -0.00622348f, -0.01147150f, 
    0.00515820f, 0.00821270f, -0.02373629f, 0.01445415f, -0.02417726f, -0.01267818f, 0.02149886f, 0.01912186f, 
    0.00335337f, -0.00589842f, -0.00915688f, 0.01284163f, -0.01705255f, -0.03768889f, -0.04078858f, -0.00756758f, 
    -0.03675469f, -0.02776999f, 0.01327381f, -0.00262311f, 0.02714843f, -0.01826219f, -0.04103062f, -0.01687364f, 
    -0.03180679f, -0.03654459f, -0.00945150f, -0.01610467f, 0.02068670f, -0.03230702f, -0.02846977f, -0.02790854f, 
    -0.03580776f, 0.00503272f, -0.03050130f, 0.01408820f, -0.01006282f, -0.02308584f, -0.03854287f, 0.00125339f, 
    -0.02112010f, 0.00805870f, 0.02442636f, -0.00584540f, 0.00303565f, -0.00095282f, -0.02032100f, -0.03119745f, 
    -0.02075297f, -0.04022540f, 0.02896081f, -0.03743539f, -0.01651688f, -0.03713290f, -0.01517319f, 0.00404721f, 
    0.00694384f, 0.02454448f, 0.01236570f, 0.03162170f, -0.00894381f, -0.02967923f, -0.02034040f, 0.03007453f, 
    0.00781527f, -0.04530428f, 0.02317151f, -0.00948592f, 0.02814018f, 0.01952190f, 0.03526461f, -0.01313435f, 
    -0.00109439f, -0.00879590f, 0.02551921f, -0.02405332f, -0.02384392f, -0.00629797f, -0.04170640f, -0.03512429f, 
    -0.03199516f, -0.02000872f, -0.00045135f, 0.02022724f, -0.04364577f, -0.01878303f, -0.00476211f, -0.02516666f, 
    -0.00610446f, 0.02847428f, 0.01749128f, -0.02295898f, 0.02230704f, 0.01574330f, 0.00845205f, -0.02779010f, 
    -0.04204603f, -0.02826525f, 0.02773647f, 0.01489603f, 0.02756331f, 0.01416252f, -0.02566994f, -0.01025699f, 
    -0.03997592f, -0.02856644f, 0.00201317f, -0.01803942f, 0.02609650f, -0.01307201f, -0.03969188f, -0.03090058f, 
    -0.00054589f, 0.00721276f, 0.02663035f, -0.00384859f, 0.02858934f, -0.02572797f, 0.00883703f, -0.01656912f, 
    -0.00730065f, 0.00412120f, 0.02419312f, -0.03808262f, -0.01407471f, 0.00475667f, 0.01769145f, 0.00469099f, 
    -0.00611871f, -0.00602506f, 0.00933746f, -0.04542703f, 0.00821035f, -0.03892821f, -0.04357318f, -0.02225239f, 
    -0.01012048f, 0.01288324f, 0.00225498f, 0.03892693f, -0.03111363f, 0.02403375f, 0.03253345f, -0.01421473f, 
    -0.02210769f, 0.00476546f, 0.02540665f, -0.01899558f, -0.03234800f, 0.02576059f, -0.01169572f, 0.01703492f, 
    -0.01615452f, 0.01220787f, 0.00184840f, -0.02920379f, 0.01119661f, -0.00203479f, -0.03529080f, -0.03456862f, 
    -0.03724407f, 0.00822402f, 0.00671501f, 0.02170214f, 0.00216311f, -0.00076774f, 0.00579835f, 0.02544883f, 
    0.01837837f, 0.02519573f, -0.04543883f, 0.03008776f, 0.02058571f, -0.03320654f, -0.01156343f, -0.02236057f, 
    -0.03304235f, 0.03469639f, -0.03068471f, -0.02332524f, -0.03188554f, 0.01520210f, -0.03226529f, -0.00244357f, 
    0.02261743f, -0.03822224f, -0.03865438f, 0.03086448f, -0.01919904f, -0.00411501f, 0.02025826f, -0.00626157f, 
    -0.02006433f, -0.02026786f, -0.01855677f, 0.02073058f, 0.03789363f, 0.00007695f, 0.02263782f, -0.03366457f, 
    -0.04135113f, -0.02421544f, 0.00845149f, -0.01652320f, 0.02140262f, -0.04136809f, -0.02886321f, -0.02823718f, 
    -0.01703144f, -0.01715069f, -0.01138587f, -0.01882642f, -0.00933617f, 0.02489414f, -0.02505022f, -0.04693389f, 
    -0.00904302f, 0.03816687f, 0.00840672f, -0.03087081f, -0.04095602f, 0.02271011f, -0.02561436f, -0.01643416f, 
    -0.02163353f, -0.02113548f, 0.01727791f, 0.02805441f, 0.02321690f, 0.03474888f, -0.03122587f, -0.03579301f, 
    0.02245948f, -0.04205550f, 0.00551675f, -0.03776506f, -0.00184715f, 0.01535910f, -0.02701446f, -0.02374882f, 
    -0.03322785f, 0.01611947f, 0.02757946f, 0.00010180f, 0.00334964f, -0.01019299f, -0.01113011f, -0.04005324f, 
    0.01045004f, -0.01986470f, 0.02465434f, -0.01034459f, 0.01871943f, 0.01819111f, 0.01925336f, -0.03781490f, 
    0.01831512f, -0.00959135f, -0.04423311f, 0.01824471f, -0.02131017f, 0.00528964f, 0.02570763f, -0.02395124f, 
    0.00428092f, 0.03531856f, 0.02326400f, -0.01709619f, -0.02728200f, -0.01154031f, -0.01011038f, -0.00687824f, 
    0.01992201f, -0.02518174f, 0.00677490f, 0.02634130f, -0.01852884f, -0.02153730f, -0.04008926f, -0.03331474f, 
    0.03372612f, 0.00779014f, 0.02359908f, 0.01231611f, 0.02011367f, 0.02615092f, -0.04585131f, -0.03318906f, 
    -0.00577033f, -0.03513688f, 0.02677881f, -0.00060467f, -0.02583445f, 0.03137247f, 0.02495268f, -0.00800153f, 
    -0.00045978f, 0.01996343f, -0.02072386f, -0.04632436f, 0.01793165f, -0.02643552f, -0.03598282f, 0.01498600f, 
    -0.03181370f, -0.03798041f, -0.02014896f, 0.03590417f, -0.03047585f, -0.02422373f, -0.01731746f, -0.00003413f, 
    0.03352271f, 0.01269470f, -0.02177659f, -0.00465412f, -0.01372402f, -0.01563377f, 0.00922046f, 0.02195974f, 
    0.00893406f, 0.02297767f, 0.03147110f, -0.04930087f, -0.03711373f, -0.00041212f, 0.03073680f, 0.02086625f, 
    0.00377366f, -0.01226758f, 0.00592814f, -0.01524669f, -0.00045785f, -0.03948123f, -0.01891091f, -0.01052705f, 
    -0.03011858f, -0.01216792f, -0.02828408f, -0.02185668f, -0.02550531f, -0.04167572f, -0.01955508f, 0.02129391f, 
    0.00585626f, 0.01889152f, -0.00644110f, -0.01948726f, 0.00958721f, -0.00866755f, -0.02573063f, -0.02267533f, 
    -0.00446750f, -0.03063504f, 0.01978483f, 0.02615225f, -0.00413735f, -0.00645056f, 0.01821551f, -0.00588605f, 
    0.00448438f, 0.02230175f, -0.04589766f, -0.04203006f, -0.00097861f, -0.02643934f, -0.01238348f, 0.03071334f, 
    0.01743345f, 0.02004365f, -0.01352471f, 0.00345533f, 0.00677089f, -0.01674345f, 0.02425589f, 0.00256002f, 
    0.02200927f, -0.02428263f, -0.00278970f, -0.02336237f, -0.03185233f, -0.04292312f, -0.02596700f, -0.02308597f, 
    0.04326438f, -0.00241836f, 0.00857833f, -0.03286593f, -0.03556087f, -0.04636838f, 0.01579847f, 0.02418037f, 
    -0.02342699f, -0.01780854f, 0.02142188f, 0.02552555f, 0.01512650f, 0.00147874f, -0.03716860f, 0.01462565f, 
    -0.00749447f, 0.01311619f, 0.00835877f, -0.00823878f, -0.02312557f, 0.02505204f, -0.03486390f, 0.01257513f, 
    0.00747748f, -0.02000110f, 0.00306696f, -0.02572953f, 0.02686231f, 0.00624266f, -0.01509870f, -0.04050012f, 
    -0.02487886f, 0.01690544f, -0.03724417f, -0.03361154f, 0.01908659f, -0.00266508f, -0.00757369f, -0.00441617f, 
    -0.01984495f, -0.00414399f, -0.04307484f, -0.03512949f, -0.04625053f, -0.02192956f, -0.01823084f, 0.01100361f, 
    -0.00615147f, -0.04092781f, 0.00674148f, -0.01721768f, 0.02731937f, 0.00432020f, 0.00391262f, -0.01289816f, 
    0.02646700f, 0.01460482f, -0.02645033f, -0.02979726f, -0.02436837f, 0.00795210f, 0.00071419f, 0.01605779f, 
    0.03589044f, -0.03542924f, -0.00897149f, -0.03248429f, 0.01979510f, 0.03010453f, -0.01749203f, 0.02280618f, 
    -0.02058007f, -0.03276756f, 0.00470533f, 0.00470082f, 0.04827080f, 0.02134138f, -0.01305455f, -0.04297692f, 
    -0.04075727f, 0.04161849f, 0.02256437f, 0.02796355f, 0.02206349f, 0.02578747f, -0.02083557f, 0.03280149f, 
    0.00657173f, -0.01340419f, 0.02733624f, -0.00822187f, -0.01964092f, 0.01446382f, -0.00357327f, -0.02428263f, 
    -0.03890264f, 0.01354779f, 0.02096470f, -0.02434994f, 0.02536243f, 0.01533625f, -0.04451165f, -0.01532396f, 
    0.02209139f, 0.03258020f, -0.01915605f, 0.00594633f, 0.01337285f, 0.00534467f, 0.02786306f, -0.01555181f, 
    0.02344047f, -0.03217978f, -0.01129735f, -0.01993465f, -0.02803321f, -0.01112979f, -0.00917075f, -0.04072974f, 
    -0.03221332f, -0.03095899f, -0.04681396f, 0.01479697f, 0.02970856f, -0.00234017f, 0.01233135f, 0.02730492f, 
    0.01292574f, 0.01037353f, 0.01014390f, -0.01561248f, 0.00726898f, -0.04563833f, -0.00537369f, -0.00421477f, 
    -0.02822718f, -0.02893271f, 0.00548248f, 0.01400086f, 0.03086061f, -0.00865541f, 0.00720287f, 0.02285950f, 
    -0.00680457f, -0.04469900f, -0.02924649f, -0.00886817f, -0.03979280f, -0.02468157f, 0.00231657f, -0.04304801f, 
    -0.04435499f, -0.01765343f, 0.02058159f, -0.04345418f, 0.02568904f, 0.00569017f, -0.02028506f, -0.02951647f, 
    0.01669190f, -0.02241307f, 0.03266833f, 0.00375084f, -0.00347185f, 0.00212213f, 0.01491845f, 0.00876886f, 
    -0.02134862f, -0.03949094f, -0.03763966f, -0.00024570f, 0.01414897f, -0.01614100f, -0.00140638f, -0.00892913f, 
    -0.02224536f, -0.01733527f, 0.00931316f, 0.00499614f, -0.02191290f, -0.04224998f, -0.01402530f, -0.02318119f, 
    0.02916614f, -0.02693582f, -0.01239979f, 0.00928332f, -0.01616519f, -0.03475465f, -0.01275953f, 0.00055681f, 
    -0.02909338f, 0.02506033f, 0.00982667f, -0.00121330f, -0.02445887f, 0.02034909f, -0.03965681f, -0.01872014f, 
    0.01548455f, -0.00336653f, 0.02819396f, -0.01207686f, 0.00351327f, -0.03361095f, -0.01501642f, 0.02509935f, 
    -0.02304288f, 0.01559518f, -0.03367148f, 0.00270915f, -0.00886595f, -0.03279163f, -0.02536576f, -0.02269905f, 
    -0.02668981f, -0.02722305f, 0.00237714f, -0.02459981f, -0.02056937f, -0.02593492f, -0.00056741f, 0.01810186f, 
    -0.00758346f, 0.00312962f, -0.01616070f, -0.02782325f, -0.02619880f, 0.00916449f, -0.00208762f, -0.01858082f, 
    -0.01205904f, -0.01633991f, 0.01889600f, -0.00645109f, 0.01770272f, -0.03198693f, -0.04156734f, 0.01446363f, 
    -0.00606141f, -0.04011904f, 0.03257569f, 0.00247993f, 0.01706913f, 0.02048956f, 0.00558266f, 0.00128883f, 
    -0.00649460f, -0.01319789f, 0.02422726f, 0.01867598f, 0.01486754f, -0.03659165f, 0.02762328f, -0.04387958f, 
    0.00690830f, 0.00025125f, 0.03504738f, -0.03741999f, -0.03104128f, 0.00072759f, 0.00182041f, -0.04421470f, 
    -0.02230689f, 0.01442471f, -0.01979648f, -0.02147379f, -0.00428589f, -0.01816639f, 0.02278497f, -0.03073355f, 
    -0.00638148f, 0.03017160f, 0.00087053f, 0.00159920f, 0.00765033f, 0.03725306f, -0.02458934f, 0.02343825f, 
    0.01983673f, 0.02334510f, 0.00538633f, 0.03860262f, -0.00782653f, -0.03424417f, 0.02709664f, 0.00060260f, 
    -0.00550002f, -0.04093904f, -0.02643937f, 0.03485867f, -0.01346807f, 0.02844339f, 0.00059499f, 0.00861061f, 
    0.03101606f, -0.01158002f, -0.02319332f, 0.02100421f, -0.01657283f, -0.01092143f, 0.01448208f, -0.00922845f, 
    -0.04431214f, -0.00026678f, 0.00220914f, -0.02415705f, -0.00749256f, -0.03943910f, 0.00390748f, 0.01069620f, 
    0.00257452f, -0.01494581f, 0.01878489f, -0.01465743f, 0.00186386f, -0.02142485f, -0.03472978f, -0.00092553f, 
    -0.00724392f, -0.03094120f, -0.00132476f, -0.04037678f, 0.03269443f, 0.03169599f, 0.01438438f, -0.01398632f, 
    0.01382607f, -0.02158255f, 0.00189526f, 0.02492471f, -0.01016278f, 0.00215196f, -0.03772829f, -0.02567437f, 
    0.02351791f, -0.00331537f, -0.01204679f, -0.00988456f, -0.03884318f, 0.00935445f, -0.04148707f, 0.03195437f, 
    0.00989030f, 0.02012114f, 0.02212924f, -0.01366493f, 0.02777140f, -0.04433342f, 0.01965302f, 0.00021600f, 
    0.00087573f, 0.02876755f, -0.03397757f, 0.01900350f, -0.00986149f, 0.00455399f, -0.00750454f, 0.00471554f, 
    -0.00269654f, -0.04111994f, -0.00139212f, -0.00064809f, -0.03377602f, -0.02779444f, -0.03445458f, -0.04333166f, 
    -0.04006550f, -0.00392644f, -0.02160752f, 0.00633136f, -0.02911235f, 0.01832741f, -0.04196769f, 0.03588894f, 
    -0.43132949f, 0.02597250f, -0.62629920f, 0.46659663f, -0.56321096f, 0.16951284f, -0.15439780f, -0.19006033f, 
    0.12345692f, -0.11417315f, -0.09353280f, 0.01297559f, 0.09174210f, -0.00882971f, -0.03065736f, -0.29243568f, 
    0.16576581f, 0.04719421f, -0.10787869f, 0.05893674f, -0.13782391f, -0.23929614f, -0.34261072f, 0.11723772f, 
    -0.06584091f, 0.33752581f, 0.04357182f, -0.01652964f, 0.03823458f, 0.06224131f, 0.01115058f, 0.10206846f, 
    0.04600206f, 0.00029863f, 0.04634402f, -0.07415635f, -0.14371414f, -0.04000331f, -0.07860029f, 0.09438749f, 
    0.06731208f, 0.28346777f, 0.41844332f, 0.07777669f, 0.01902116f, 0.13792013f, 0.17225905f, 0.21669233f, 
    -0.07438199f, 0.04111896f, 0.04269272f, -0.03147426f, -0.00644129f, -0.00145089f, 0.11101156f, 0.13303162f, 
    -0.11506911f, 0.06145981f, 0.10151508f, -0.04925485f, -0.07693985f, 0.24204390f, 0.36511382f, 0.05757284f, 
    -0.02650284f, -0.00327559f, 0.20535867f, 0.11697362f, 0.06373946f, 0.04601407f, 0.06725936f, -0.05644160f, 
    -0.07477228f, -0.10872079f, -0.05826036f, 0.09483849f, -0.04178862f, -0.01047950f, -0.04569568f, -0.01440931f, 
    0.21102571f, 0.38606060f, 0.32402742f, 0.22834466f, 0.04356700f, -0.11026418f, -0.05070586f, -0.08036995f, 
    0.14238298f, -0.00964296f, 0.08935284f, 0.15222064f, 0.04486026f, 0.00007201f, 0.08173643f, -0.08916439f, 
    -0.05622951f, -0.09973529f, 0.13190262f, 0.09014493f, -0.00495634f, -0.30225334f, -0.40604314f, -0.38267681f, 
    -0.11296294f, -0.07643498f, -0.01504359f, -0.06792128f, 0.04018145f, 0.00465360f, 0.03233337f, -0.09221298f, 
    0.06667346f, 0.01472230f, -0.15623887f, -0.04294829f, 0.11558499f, -0.00802152f, 0.07812679f, 0.00620009f, 
    0.10914007f, 0.35025594f, 0.30943882f, 0.10477473f, 0.06580436f, 0.01291301f, -0.05410944f, 0.07234231f, 
    -0.04863274f, 0.04473405f, 0.05036914f, 0.06076161f, 0.06144082f, -0.06530523f, 0.01538338f, -0.01657982f, 
    -0.04116283f, -0.02767103f, 0.01695018f, -0.07737102f, 0.28253248f, 0.24775273f, 0.06850568f, -0.08129828f, 
    -0.07447357f, -0.08664533f, 0.05680884f, 0.20023842f, 0.00104458f, 0.01858057f, 0.15351322f, -0.03234252f, 
    -0.01448375f, -0.10239894f, -0.07354692f, -0.05253682f, 0.03063546f, 0.07097948f, -0.03278327f, -0.08585859f, 
    -0.04444036f, 0.15051736f, -0.20344941f, -0.06770695f, 0.07969504f, -0.05899280f, 0.05618998f, 0.20086282f, 
    0.02540798f, 0.07540886f, -0.00133732f, 0.00957493f, 0.03283059f, -0.08461303f, -0.03881392f, -0.00007430f, 
    0.02207674f, 0.00355010f, -0.10540647f, -0.05748183f, 0.13389575f, -0.31427380f, -0.27415648f, 0.12944704f, 
    -0.14631799f, -0.02382791f, 0.05888162f, 0.12311766f, 0.00345078f, -0.01799599f, 0.18939920f, 0.10662134f, 
    0.04979132f, -0.03539772f, -0.18798317f, 0.12955862f, 0.06093514f, -0.04334488f, 0.01115515f, 0.06850538f, 
    -0.35699695f, -0.04712570f, -0.02779342f, 0.03886082f, 0.03832453f, 0.06362969f, 0.01715068f, 0.09202383f, 
    0.02581185f, 0.07736472f, 0.02086668f, -0.01651346f, 0.04438110f, -0.03193379f, -0.06439292f, 0.02382157f, 
    -0.02962139f, -0.03269346f, -0.09020453f, -0.03515214f, -0.46612063f, -0.52214527f, -0.55452025f, 0.27356148f, 
    -0.88708836f, 0.14378934f, 0.03375069f, -0.32500476f, 0.18082508f, 0.26001567f, 0.10309817f, 0.19365980f, 
    -0.05964947f, -0.01911378f, -0.05659427f, -0.07082377f, 0.05676329f, -0.31764439f, -0.07746898f, 0.26215553f, 
    0.17884168f, 0.26062903f, 0.16726708f, 0.11090465f, -0.07649730f, -0.00620756f, 0.21435417f, 0.09405085f, 
    -0.08290231f, -0.01444511f, 0.00829574f, -0.11780120f, -0.01557617f, -0.02000449f, 0.00083674f, 0.04175412f, 
    -0.01151689f, -0.02595903f, 0.01996802f, -0.07038967f, -0.13943329f, -0.05287831f, -0.08572343f, -0.06438182f, 
    -0.14666183f, -0.09865453f, 0.11656956f, -0.04494951f, 0.07675415f, 0.01789467f, -0.02940949f, -0.01211576f, 
    -0.04320518f, 0.06082005f, 0.04844019f, -0.02363853f, -0.00608948f, -0.17163767f, 0.02693364f, -0.04036263f, 
    -0.00144986f, -0.26552793f, -0.63856280f, 0.02106374f, -0.32657817f, -0.02689078f, -0.08370979f, -0.14642976f, 
    -0.10697342f, -0.03149722f, -0.03574250f, 0.02684423f, 0.00986692f, 0.01816610f, -0.02427707f, 0.00150139f, 
    0.02173532f, 0.02042877f, 0.05255200f, 0.05475394f, 0.43886921f, -0.13234830f, 0.22958049f, -0.02838233f, 
    0.12593405f, 0.02401853f, -0.04821098f, 0.08313548f, 0.14149082f, 0.04909710f, 0.07319183f, 0.01631895f, 
    -0.08181033f, -0.02245141f, -0.02608414f, -0.10565392f, -0.13522218f, -0.17964645f, 0.04040601f, 0.01226755f, 
    0.26724386f, 0.18558808f, 0.16172634f, -0.04154130f, 0.00213429f, 0.08341309f, -0.14979513f, -0.01981076f, 
    -0.02942064f, 0.04851182f, 0.03788010f, -0.03083893f, 0.05550056f, -0.08119878f, -0.00685105f, -0.06357893f, 
    0.08910814f, 0.03090920f, 0.04527135f, 0.10139979f, 0.59174532f, 0.05676800f, 0.13695787f, 0.04912949f, 
    -0.01218016f, 0.09103078f, 0.06788122f, 0.26450953f, 0.19312020f, 0.12701397f, 0.08886939f, 0.00698331f, 
    -0.14267640f, -0.02904357f, 0.00045377f, -0.00676699f, -0.03159169f, -0.04818113f, -0.02782937f, -0.01482153f, 
    -0.29968119f, -0.10501571f, 0.21941122f, -0.28439954f, -0.07512591f, -0.17052199f, -0.00154934f, -0.00051959f, 
    0.10871441f, 0.13063112f, 0.08852733f, -0.04787264f, 0.09354031f, -0.04792572f, 0.06654461f, -0.01071172f, 
    0.03133689f, -0.05795050f, -0.09111632f, -0.16655476f, -0.15786710f, -0.10940995f, -0.14359511f, -0.08291211f, 
    -0.41656899f, -0.08608431f, -0.08193407f, -0.19568536f, -0.05220795f, 0.10650811f, 0.01023887f, 0.07064921f, 
    0.05984381f, -0.03435578f, 0.00419755f, -0.06689358f, -0.00272065f, -0.05339363f, 0.01243527f, 0.12899026f, 
    0.61204445f, -0.25468916f, -0.40920520f, -0.08490394f, -0.13345683f, -0.05900544f, 0.01958065f, 0.02627061f, 
    -0.02457981f, -0.05240192f, 0.05639311f, 0.14155446f, 0.15802798f, 0.11433186f, -0.04441362f, -0.01123000f, 
    0.00238177f, -0.00477827f, -0.05022461f, 0.04235565f, 0.32580024f, -0.41811779f, -0.34333020f, -0.44580033f, 
    -0.10504527f, 0.00600601f, 0.00424762f, -0.03220616f, -0.02465974f, -0.05903600f, -0.11722856f, -0.04551755f, 
    -0.02826430f, -0.05726708f, 0.11418665f, -0.14757891f, 0.01293238f, 0.03560637f, -0.00693391f, -0.12304998f, 
    0.04988356f, -0.23714185f, -0.36349005f, -0.08062126f, -0.12952343f, 0.01680193f, -0.01300592f, 0.01336319f, 
    -0.04166742f, -0.07314532f, -0.15558982f, 0.03493874f, 0.04655211f, -0.06045150f, 0.03890127f, 0.00423878f, 
    -0.00695605f, -0.12266802f, -0.04143020f, 0.02202715f, -0.74808961f, 0.00322661f, 0.19953150f, -0.12824814f, 
    0.13050272f, 0.06530597f, 0.05019283f, -0.03255309f, 0.24107049f, 0.01980269f, 0.19770662f, 0.02136224f, 
    -0.12827727f, -0.13491771f, 0.11363143f, 0.16617388f, 0.04046587f, -0.11071505f, -0.08133095f, 0.01492629f, 
    0.04215048f, -0.21414082f, -0.34818077f, -0.14989932f, 0.16256206f, -0.00523144f, -0.03204661f, -0.18055069f, 
    -0.08174349f, 0.03705809f, -0.03843414f, 0.03624185f, 0.05839953f, 0.01525476f, 0.03609448f, -0.15027118f, 
    -0.04321444f, -0.07670869f, 0.08790324f, 0.07638339f, 0.08733840f, 0.36136368f, 0.36296740f, 0.13770619f, 
    -0.12208059f, 0.00721893f, -0.12664668f, -0.21253535f, 0.06732807f, 0.07244983f, -0.02421111f, -0.01766853f, 
    0.02594423f, 0.00348590f, 0.07587168f, -0.10576798f, 0.00314522f, 0.06322087f, -0.04612771f, -0.06184991f, 
    -0.17140143f, -0.18901137f, -0.17438817f, -0.07676430f, -0.40045387f, -0.02486744f, -0.05348726f, -0.12842447f, 
    0.04352612f, -0.00572789f, -0.11694534f, -0.04122303f, 0.06104144f, -0.07412873f, -0.01723073f, -0.09800947f, 
    -0.00210514f, 0.11215619f, 0.03999651f, -0.05161420f, 0.37822467f, 0.09857151f, 0.25352296f, 0.07287904f, 
    -0.09204441f, 0.05012749f, 0.16396235f, 0.35499805f, 0.24859555f, 0.00889525f, 0.15683562f, -0.08367914f, 
    -0.14697157f, -0.04931794f, -0.04588326f, -0.03573043f, 0.02357712f, 0.03600747f, 0.00916312f, -0.00920845f, 
    0.55637908f, -0.03898218f, 0.28572059f, 0.05188852f, -0.11686143f, -0.06557034f, 0.12762327f, 0.13977973f, 
    0.00006659f, 0.06421992f, 0.05936024f, -0.15273878f, 0.03056123f, -0.03173158f, 0.20766166f, -0.01443078f, 
    -0.08540328f, 0.16168088f, 0.03443865f, 0.03125554f, -0.01889551f, -0.01349056f, -0.21781209f, -0.04571149f, 
    -0.09078167f, 0.02983698f, 0.09472799f, -0.01127383f, 0.03844409f, -0.01715879f, 0.00937768f, 0.02781763f, 
    -0.10879177f, -0.03769204f, 0.04023118f, -0.14708631f, 0.00944766f, -0.05278082f, -0.09399079f, 0.01478807f, 
    0.10656673f, 0.16815399f, -0.03913144f, 0.02271351f, 0.02505983f, -0.04998480f, 0.02605294f, 0.00311227f, 
    -0.04821840f, 0.04448180f, -0.04885409f, -0.01345177f, -0.01682674f, 0.08667527f, 0.07937371f, -0.07844223f, 
    -0.07743827f, -0.02891138f, -0.13951795f, 0.01000680f, 0.01930103f, -0.36685380f, -0.09836287f, -0.28987163f, 
    -0.20050550f, -0.11098244f, -0.06616157f, 0.08923191f, 0.01703576f, 0.00457876f, -0.14514701f, 0.09597906f, 
    0.00112795f, 0.10262518f, 0.00002523f, -0.13501944f, -0.06391818f, -0.31604052f, -0.08809773f, -0.04460530f, 
    0.00723831f, -0.04036545f, 0.01046561f, -0.02642796f, -0.04003616f, 0.01084570f, 0.02927435f, -0.02539479f, 
    -0.01969927f, -0.02381242f, 0.02875371f, 0.00584749f, -0.00873476f, 0.03164491f, 0.01307370f, -0.04412938f, 
    0.00879051f, 0.00799875f, -0.02671305f, -0.00389578f, -0.02834584f, -0.01068627f, 0.01921155f, -0.02419658f, 
    0.02358583f, -0.01252965f, 0.00877133f, 0.03119840f, 0.02666852f, 0.00827515f, 0.01137112f, -0.02020449f, 
    0.01428827f, -0.00514404f, -0.02838457f, 0.01186053f, -0.01464836f, -0.02467525f, -0.02244946f, 0.01947276f, 
    -0.00644820f, 0.00223509f, -0.02231072f, 0.03073747f, -0.02158716f, -0.00629199f, -0.02851830f, -0.01091691f, 
    -0.01395891f, -0.04450555f, -0.00425770f, 0.02188172f, -0.03042560f, -0.02723244f, 0.01034923f, -0.00291125f, 
    -0.03371086f, -0.01769715f, -0.00905842f, 0.03000495f, -0.03335937f, 0.00498940f, -0.00322017f, 0.02143767f, 
    0.01749984f, -0.00608721f, -0.01944775f, 0.00548977f, 0.01059951f, 0.00282566f, -0.01441857f, 0.00838425f, 
    -0.03051012f, 0.00667691f, -0.03539259f, 0.02497546f, 0.01543349f, 0.02636460f, -0.04586585f, -0.04067476f, 
    -0.02159318f, 0.02398424f, 0.00403239f, -0.00170588f, 0.03466376f, -0.04264553f, 0.02944106f, -0.02274877f, 
    0.01472415f, -0.04295199f, 0.02952533f, -0.02870771f, -0.00567348f, 0.01643394f, 0.00313222f, -0.04067878f, 
    0.01725809f, 0.00581746f, 0.01969204f, 0.01985194f, 0.00545270f, -0.04354516f, -0.01508791f, 0.02090316f, 
    0.02401345f, -0.03341885f, -0.04428290f, -0.02119515f, 0.01778523f, -0.04328603f, 0.02569572f, -0.02374967f, 
    -0.00146749f, -0.03490921f, -0.00642828f, -0.03697222f, 0.00401568f, 0.02940330f, -0.00859633f, -0.01516552f, 
    0.00167917f, 0.00672445f, -0.04331798f, -0.02695590f, -0.00222280f, 0.02421029f, 0.00196788f, -0.02936830f, 
    -0.00417293f, 0.01062189f, -0.02984399f, -0.02540515f, 0.01024178f, -0.00836881f, 0.01455747f, -0.01660644f, 
    -0.00307886f, -0.02738930f, 0.02497907f, 0.01851401f, -0.02062111f, 0.01912167f, -0.04434441f, -0.03553089f, 
    0.00993662f, -0.01947645f, -0.00672072f, -0.02196100f, -0.02871498f, -0.00964260f, -0.01428299f, -0.03071919f, 
    0.02800212f, -0.01333566f, -0.02383507f, -0.02028385f, -0.03296140f, -0.03722236f, 0.00621167f, -0.02532671f, 
    0.01837566f, -0.01813339f, -0.04580676f, -0.02381437f, -0.02463032f, 0.02019435f, -0.03799644f, 0.01462799f, 
    0.03224488f, 0.02299362f, 0.02057326f, 0.03401543f, 0.00692459f, 0.01802088f, -0.02472439f, -0.01812397f, 
    0.02383120f, 0.01631563f, 0.02973362f, 0.02104727f, 0.01423988f, -0.01150418f, -0.02497585f, -0.03377328f, 
    -0.01471451f, -0.02170019f, -0.02429097f, 0.00047362f, 0.00627349f, 0.01892500f, -0.01958951f, 0.02139129f, 
    -0.03154867f, -0.03803355f, -0.00706196f, -0.01751449f, 0.00824695f, -0.00706259f, -0.00505693f, -0.02161097f, 
    -0.03241822f, -0.00047745f, -0.03454141f, -0.01111532f, -0.02020549f, -0.03867171f, -0.00188500f, 0.01127446f, 
    -0.02177947f, 0.02120511f, 0.00376754f, -0.00664063f, -0.03111061f, 0.02627781f, -0.00957716f, 0.01267855f, 
    -0.00240868f, 0.00089476f, -0.03140802f, -0.00418538f, 0.02110517f, -0.00397269f, -0.02519264f, -0.01429710f, 
    0.02001010f, -0.04104104f, -0.00482255f, 0.01940328f, -0.00890862f, 0.01654565f, -0.01202055f, -0.04730790f, 
    0.02541791f, 0.02990448f, 0.01102145f, -0.00423777f, 0.02025317f, -0.00214607f, 0.02203337f, -0.02267380f, 
    -0.03333768f, -0.02866760f, 0.00215373f, 0.00431601f, -0.04636802f, 0.02349578f, 0.02153862f, -0.01344683f, 
    0.02597765f, -0.00517419f, 0.03249833f, 0.01282397f, -0.03252699f, 0.02771723f, 0.01301836f, 0.01819252f, 
    0.02843947f, -0.03511896f, -0.00788989f, -0.02867782f, -0.00736310f, -0.01712379f, -0.04247554f, 0.00946692f, 
    -0.03081683f, 0.03069054f, -0.04496818f, -0.02212100f, -0.00693200f, 0.03244866f, -0.01733143f, 0.01780268f, 
    -0.04216317f, 0.02222282f, -0.00860911f, -0.00326494f, 0.02339808f, -0.04246303f, 0.01193001f, 0.03203604f, 
    -0.00967969f, -0.03250737f, -0.03047409f, -0.04648313f, 0.01787319f, -0.02956550f, 0.00062951f, -0.00069644f, 
    0.00192087f, 0.00648315f, 0.01006949f, -0.02301463f, -0.02824923f, -0.01183685f, 0.03032263f, -0.00144086f, 
    -0.02869574f, -0.03380485f, -0.00119290f, -0.01268839f, 0.02802311f, -0.01307794f, -0.03768620f, -0.03730997f, 
    0.01943467f, -0.02268969f, 0.02199297f, -0.02584311f, -0.00324864f, -0.03774989f, -0.03704494f, -0.03310559f, 
    -0.01422371f, -0.00007365f, -0.00626584f, -0.00218547f, 0.02353904f, -0.04370023f, -0.04419241f, -0.02329005f, 
    -0.00184966f, -0.04073891f, -0.00262772f, -0.02999369f, -0.03331148f, -0.01107684f, -0.03450800f, 0.03421806f, 
    -0.04075689f, -0.03097645f, 0.00041087f, 0.03648103f, 0.01443120f, 0.03435834f, 0.02046861f, -0.00917575f, 
    -0.02480207f, -0.02997219f, 0.02499312f, -0.02647611f, 0.02226016f, -0.01848210f, -0.03537919f, 0.01276389f, 
    0.02889189f, -0.03312918f, -0.00031795f, -0.00043140f, -0.02938577f, 0.04490334f, -0.00642558f, -0.00502143f, 
    -0.02526633f, 0.02642237f, -0.02244569f, -0.01715598f, 0.01063257f, 0.01009331f, 0.00228193f, 0.01381632f, 
    0.00079098f, -0.02617813f, 0.00106217f, -0.01120238f, -0.02103298f, 0.01722765f, -0.00780237f, 0.00734958f, 
    -0.01675966f, -0.02192904f, 0.00461979f, 0.00342615f, 0.01936611f, -0.02353981f, -0.00367071f, 0.01310114f, 
    0.02703936f, 0.01673840f, -0.03474159f, 0.02599132f, -0.01179707f, -0.03421598f, -0.02008686f, -0.00096217f, 
    0.00612320f, -0.00496977f, -0.03298958f, 0.00509985f, 0.01639585f, -0.01908401f, 0.02068502f, -0.03740604f, 
    0.00629290f, 0.00864600f, 0.03417535f, -0.03207447f, 0.02626477f, 0.01290660f, -0.00203702f, 0.00391051f, 
    -0.03535195f, 0.02340703f, -0.03389993f, 0.00790138f, -0.04465023f, 0.01498287f, 0.02641929f, -0.03749542f, 
    0.01728534f, -0.03081990f, 0.02017528f, 0.02049318f, 0.02426374f, -0.00652680f, -0.00823134f, 0.02327674f, 
    0.02717793f, -0.01921078f, -0.01014457f, -0.01341877f, -0.03347734f, 0.03247644f, 0.01515038f, -0.01994779f, 
    0.02355488f, -0.01446695f, -0.03027784f, -0.04111165f, -0.03269753f, 0.01144120f, 0.02139428f, 0.01007057f, 
    0.01900484f, -0.02023891f, -0.01735295f, -0.03452423f, -0.01281913f, -0.03018197f, 0.03192662f, -0.03897660f, 
    0.03164748f, -0.04090495f, -0.02287308f, -0.04542121f, -0.03724950f, -0.03311382f, 0.00368793f, -0.03321853f, 
    0.00375224f, -0.04632483f, -0.00501306f, 0.03044418f, 0.02118206f, -0.02017611f, -0.03946188f, -0.00821809f, 
    0.00317918f, -0.03346553f, -0.03444608f, 0.02681174f, 0.01034794f, -0.02787086f, -0.00539709f, -0.03076243f, 
    0.00978802f, -0.03383232f, 0.01926456f, 0.01641526f, -0.01242970f, -0.03692171f, 0.03185164f, -0.01043653f, 
    0.02718486f, -0.00149499f, -0.01494731f, -0.02285015f, -0.03915090f, 0.00327325f, -0.04402257f, -0.00073420f, 
    -0.03491661f, 0.00257947f, 0.00588935f, 0.02108419f, 0.00476956f, -0.00537924f, -0.03525295f, 0.02427830f, 
    -0.01294373f, -0.03585092f, 0.02058630f, 0.02873389f, 0.02160936f, -0.01297039f, 0.01542968f, 0.00484465f, 
    0.00555761f, 0.01729472f, 0.02988447f, -0.02269481f, -0.03743997f, 0.01415509f, 0.02747147f, -0.00930570f, 
    -0.03223814f, 0.00745507f, -0.02140996f, -0.03983162f, -0.02847951f, 0.03356149f, -0.00078640f, 0.02479666f, 
    0.01379419f, 0.01704163f, -0.01038271f, 0.02237108f, 0.02934066f, -0.03764876f, 0.01257750f, 0.01454945f, 
    -0.00747481f, -0.02919773f, -0.01476141f, 0.01718490f, 0.02964043f, -0.02148095f, -0.04091544f, -0.01300142f, 
    -0.01298910f, -0.00494697f, 0.03135362f, -0.03558826f, -0.03452418f, -0.00665773f, 0.01427286f, 0.02746841f, 
    -0.00445055f, -0.01068552f, -0.02811759f, -0.00408371f, -0.00928860f, -0.01484216f, -0.03541790f, 0.01557570f, 
    -0.01195335f, 0.01463645f, 0.00914102f, -0.01670448f, -0.03614917f, -0.00446511f, 0.01203227f, 0.03220446f, 
    -0.02376515f, -0.00302108f, 0.03704745f, -0.02126228f, 0.02081757f, -0.00880709f, -0.04092470f, 0.01962463f, 
    -0.01171105f, -0.04111470f, 0.02346130f, -0.03846971f, -0.03612801f, 0.00050496f, -0.02553739f, -0.01392601f, 
    0.01184972f, -0.01269319f, -0.01032168f, -0.02666005f, 0.03889985f, -0.01078423f, -0.00750272f, -0.04627764f, 
    -0.02220459f, -0.03204937f, -0.02919682f, 0.01994047f, 0.02450402f, -0.02617925f, -0.03819941f, -0.01325227f, 
    0.01102049f, 0.02135757f, 0.01775833f, 0.00772540f, 0.02710783f, -0.02571426f, 0.03023617f, 0.00438281f, 
    -0.03411249f, 0.00869322f, -0.03817771f, -0.00405540f, -0.00432859f, -0.03606391f, 0.02936056f, -0.00452262f, 
    0.01467085f, 0.00510823f, 0.01248859f, -0.02863630f, -0.00190159f, 0.03508865f, -0.03564679f, -0.02468237f, 
    0.02091159f, -0.03299366f, -0.02648125f, 0.03032241f, -0.00432689f, 0.01334975f, -0.00936465f, -0.02697721f, 
    0.03175485f, -0.02095421f, 0.02059559f, -0.02225128f, -0.04249366f, -0.02226640f, -0.01260651f, 0.03240085f, 
    0.02226047f, -0.02608233f, 0.00097697f, -0.03558540f, -0.01646042f, -0.01688565f, -0.00540313f, 0.01128680f, 
    0.02305944f, 0.02263218f, 0.02603427f, 0.00172838f, -0.01814906f, -0.04272188f, -0.02038391f, 0.01125802f, 
    -0.01732919f, -0.03991708f, -0.02643650f, -0.02289842f, 0.02576125f, 0.01767790f, -0.03269347f, -0.03309676f, 
    -0.04380145f, 0.01890624f, 0.00862492f, 0.02370112f, 0.02770611f, -0.00313648f, 0.00538290f, -0.02450483f, 
    0.00882486f, -0.04103517f, -0.01590630f, -0.02791719f, 0.03029943f, 0.01483542f, 0.02231794f, -0.03339970f, 
    0.00597749f, -0.03278153f, 0.01105603f, -0.00484484f, -0.04044504f, 0.03121986f, -0.02109323f, 0.00514294f, 
    -0.02333293f, -0.00567775f, -0.01144327f, -0.02456224f, -0.01764222f, -0.03392317f, 0.00793982f, -0.00364083f, 
    -0.00940872f, 0.02780678f, 0.01429727f, -0.01525063f, 0.03343455f, 0.03053298f, 0.00304447f, -0.00678744f, 
    -0.01806840f, 0.02712483f, 0.00438440f, -0.01239585f, 0.01448955f, -0.01626365f, -0.00662615f, 0.01164356f, 
    -0.03512852f, -0.03105481f, -0.01048373f, -0.01616252f, -0.00200619f, -0.03186506f, 0.01785660f, -0.00546036f, 
    0.01759751f, -0.01654262f, 0.00218452f, 0.01196398f, 0.00204454f, 0.02339662f, -0.00170175f, 0.02469061f, 
    -0.02346855f, 0.01652617f, -0.02897367f, -0.01140302f, -0.04631409f, -0.00972005f, 0.02745614f, -0.03741902f, 
    0.01152773f, 0.02124365f, 0.01902823f, -0.01891028f, 0.00854884f, -0.02628583f, 0.03852654f, -0.03920602f, 
    -0.00232091f, -0.03606091f, -0.02701739f, 0.03258630f, -0.01641200f, -0.01080098f, 0.02639000f, -0.00517313f, 
    -0.03507157f, 0.00152957f, 0.00150780f, 0.00564930f, 0.01343230f, -0.00032251f, -0.01572210f, 0.01322378f, 
    -0.00317529f, -0.00939605f, 0.00367245f, 0.00827890f, 0.01555298f, 0.00149506f, 0.00028164f, 0.03589009f, 
    0.01387425f, 0.02120421f, -0.03699185f, 0.01130348f, -0.02955453f, -0.03523144f, 0.02086013f, 0.00214368f, 
    0.00287882f, 0.01754580f, 0.03701492f, -0.02865133f, 0.03460820f, 0.02044727f, -0.04196449f, 0.03066068f, 
    -0.00688711f, -0.02156877f, 0.01324298f, 0.00086285f, 0.01306175f, -0.01261517f, -0.03558271f, -0.03683750f, 
    -0.03991628f, 0.03410057f, -0.01905511f, -0.00359401f, -0.02036450f, -0.01664919f, 0.00620673f, -0.03135206f, 
    -0.03508862f, -0.00596627f, -0.03693692f, -0.04001221f, -0.02241423f, -0.01946114f, 0.01176535f, -0.01464967f, 
    -0.03577420f, 0.01862623f, 0.02747800f, -0.02567777f, -0.00976846f, 0.00112052f, 0.03027529f, 0.01471132f, 
    0.00532022f, -0.00881119f, -0.01142185f, 0.00945312f, -0.01386356f, -0.02669605f, 0.02844213f, -0.03848034f, 
    -0.02651605f, -0.01158791f, -0.00302816f, 0.01675275f, -0.03428119f, -0.03041661f, 0.02387844f, -0.03322368f, 
    -0.01417846f, 0.02811846f, 0.01011200f, -0.00950617f, 0.01525947f, -0.02012887f, -0.00715504f, -0.03773494f, 
    0.00638573f, 0.00222400f, -0.01794282f, 0.02194549f, 0.00012966f, -0.01218217f, 0.02742300f, -0.00515504f, 
    -0.01498350f, 0.03043714f, 0.01919835f, -0.01981918f, -0.02608193f, -0.02431934f, -0.03393721f, 0.02508973f, 
    -0.00806906f, -0.02005501f, -0.03592876f, 0.01483273f, 0.03488242f, -0.00691322f, 0.00852251f, -0.01352442f, 
    -0.01475503f, 0.00204985f, 0.00356354f, -0.03327322f, -0.01633746f, -0.04223287f, 0.01800638f, 0.01973218f, 
    -0.01989133f, -0.00503463f, 0.02578607f, -0.01875872f, 0.02970162f, -0.00135380f, 0.01153563f, -0.03417630f, 
    0.01898703f, 0.02376033f, 0.00438757f, -0.03730522f, -0.04431574f, 0.01187927f, 0.01262444f, 0.00803234f, 
    -0.02199337f, -0.02178185f, -0.02615599f, 0.02454564f, -0.00607724f, -0.00550253f, 0.02767395f, 0.02089777f, 
    0.02113414f, -0.03567118f, -0.00868848f, 0.03145621f, -0.01500512f, 0.02724756f, -0.01888470f, 0.00041595f, 
    -0.01913931f, 0.02745557f, -0.04093014f, -0.02464829f, -0.02456307f, -0.01568595f, -0.00654860f, 0.01743498f, 
    -0.02435322f, -0.02751434f, -0.01319995f, 0.02320698f, -0.03003706f, 0.02823564f, 0.00229933f, -0.02250830f, 
    0.02810163f, -0.00834274f, 0.00339579f, 0.01499842f, -0.01715745f, -0.01938027f, -0.00661522f, -0.01295231f, 
    -0.02448080f, 0.01438360f, -0.01865775f, -0.01836322f, 0.01986044f, 0.01501987f, 0.00744888f, -0.03552723f, 
    0.02722467f, 0.00862299f, -0.04372920f, -0.00575463f, -0.03134361f, 0.03179026f, -0.03821995f, -0.01675238f, 
    0.02783374f, -0.02656998f, 0.00654991f, -0.02933848f, 0.03022617f, 0.00755446f, 0.00928570f, 0.01287512f, 
    -0.01713163f, 0.00587582f, 0.00875740f, 0.03759752f, -0.01210681f, -0.02611816f, -0.02550697f, -0.01366625f, 
    0.03492361f, 0.00029390f, 0.01679698f, 0.01493712f, 0.00895618f, -0.04186825f, -0.03253129f, 0.02116110f, 
    0.00683372f, -0.02136188f, 0.00341001f, -0.01202598f, -0.02993715f, -0.01736555f, 0.01482663f, 0.03747170f, 
    -0.04118226f, -0.00612450f, -0.00700727f, 0.00030927f, -0.04385739f, 0.02466392f, 0.02836566f, -0.03917301f, 
    0.01263290f, 0.01111010f, 0.02747878f, -0.01447552f, 0.01476800f, -0.03080542f, -0.00367769f, -0.01572905f, 
    0.01155702f, -0.02598583f, -0.01140297f, -0.00251989f, 0.01983136f, 0.02642159f, 0.02846356f, -0.04349153f, 
    0.04872642f, 0.00934788f, -0.00130545f, -0.00771298f, -0.02811941f, -0.01014516f, 0.02679336f, -0.02747873f, 
    -0.02637127f, 0.02339872f, -0.00740641f, 0.00202696f, 0.02614964f, -0.01566625f, -0.01077150f, -0.00716147f, 
    -0.01754155f, -0.03518456f, 0.01939390f, 0.00179621f, -0.02532250f, -0.03233495f, 0.03455636f, -0.00517181f, 
    -0.04280628f, -0.03421706f, -0.01293917f, -0.02362429f, -0.03990663f, 0.01547210f, -0.00043600f, 0.00363293f, 
    -0.03734282f, 0.00428314f, -0.03318684f, 0.01699603f, -0.02614743f, -0.01705943f, -0.01070887f, -0.02740715f, 
    -0.01253208f, 0.00761021f, -0.01623079f, 0.03411344f, 0.03115010f, -0.02272621f, -0.02500000f, -0.03938327f, 
    0.00083171f, 0.02165780f, 0.00112833f, -0.02440498f, -0.02592560f, -0.03323583f, 0.00891034f, 0.02792811f, 
    0.03932840f, 0.02615776f, 0.01866819f, 0.00318342f, 0.01615054f, 0.00480391f, 0.02949973f, -0.03461539f, 
    -0.02637090f, -0.01394047f, -0.03801968f, 0.01634708f, -0.02881168f, -0.04224074f, 0.00102434f, 0.02502179f, 
    -0.02548251f, 0.02701430f, 0.03517829f, 0.01740344f, 0.02886050f, 0.01740091f, -0.03314949f, -0.04115620f, 
    -0.00264440f, -0.01901048f, -0.00053611f, 0.01039850f, 0.00907511f, 0.01600426f, -0.00028572f, -0.00883432f, 
    -0.03029617f, 0.01800316f, -0.00932303f, -0.01253593f, 0.01801524f, 0.00876018f, 0.00936596f, 0.03549487f, 
    -0.04196174f, -0.02550767f, 0.00466791f, 0.01768868f, -0.01788079f, 0.01195254f, 0.00317890f, -0.03750250f, 
    0.01982800f, -0.02260910f, 0.01616294f, -0.00925239f, 0.00148004f, 0.01069692f, 0.01873972f, -0.02354861f, 
    -0.01692215f, 0.02847552f, 0.02564001f, -0.00353440f, -0.03252654f, -0.00733929f, -0.00259066f, -0.00286251f, 
    -0.00014048f, 0.03230028f, 0.01478365f, 0.00562804f, 0.01502925f, -0.02659509f, -0.01189177f, -0.01416248f, 
    -0.02496563f, -0.00523450f, 0.00747401f, 0.01899361f, -0.02821971f, -0.03980769f, 0.01585164f, -0.01812676f, 
    0.03066128f, 0.01352410f, 0.00180685f, -0.04894573f, -0.04155948f, -0.00783226f, 0.01850924f, -0.02960078f, 
    0.00961352f, 0.00645830f, 0.00638899f, -0.02983123f, 0.00717130f, -0.02256168f, 0.03055118f, 0.00061767f, 
    0.01590001f, 0.01188184f, -0.04138727f, -0.01769883f, 0.00126580f, 0.02565567f, 0.02448558f, -0.02429578f, 
    -0.01831609f, 0.02865865f, -0.02461637f, 0.00170632f, -0.03167707f, -0.03700481f, -0.02852157f, -0.04515413f, 
    -0.04261696f, -0.00843710f, -0.03472138f, -0.00270592f, 0.00881149f, -0.02017353f, 0.02372946f, -0.01507996f, 
    -0.00082481f, -0.04654819f, 0.01971531f, 0.01708378f, 0.01258275f, 0.01357281f, -0.01993478f, -0.00314155f, 
    -0.03506383f, 0.02961967f, 0.02029786f, 0.02631183f, 0.02104812f, 0.02159173f, -0.03757922f, -0.03890623f, 
    -0.01007599f, -0.01703594f, 0.00998966f, -0.03417872f, 0.01008616f, -0.01051939f, 0.02469193f, -0.03419246f, 
    0.03091088f, -0.01652708f, 0.03200981f, -0.04022362f, 0.03167845f, -0.00906979f, -0.01089427f, -0.01960474f, 
    0.00808313f, -0.01926723f, -0.02409837f, 0.01353646f, -0.03193078f, 0.02205526f, -0.02728932f, -0.03151398f, 
    -0.03672317f, 0.01185728f, 0.01300181f, 0.00858313f, 0.00931593f, -0.00478388f, 0.01920410f, 0.00624418f, 
    -0.02594808f, -0.03293288f, -0.00734007f, -0.00586680f, -0.00102958f, 0.03223158f, 0.00555519f, -0.04572716f, 
    -0.03362323f, -0.01201593f, -0.00963773f, -0.02425136f, -0.01635152f, 0.00054260f, -0.01988094f, -0.03588184f, 
    0.02889442f, 0.00249472f, -0.00732207f, 0.02988060f, -0.02155340f, 0.01346248f, 0.01560598f, 0.02938983f, 
    0.02465051f, -0.03279244f, -0.03197225f, -0.04129739f, 0.02746280f, -0.01711610f, 0.02172843f, 0.02407310f, 
    0.02676394f, -0.03412241f, -0.01610285f, -0.03714265f, -0.02491996f, -0.04463459f, -0.03308048f, 0.02412600f, 
    0.00917651f, -0.01872462f, -0.00632485f, -0.03620367f, -0.02602145f, -0.03168110f, 0.03806448f, 0.00505836f, 
    -0.00844142f, 0.01028909f, 0.03675192f, -0.02749224f, 0.00786358f, -0.01207866f, -0.02981091f, 0.03426878f, 
    0.03088547f, -0.02037445f, 0.02775721f, -0.01128641f, -0.00168371f, -0.01936811f, 0.00704084f, -0.03742838f, 
    0.02579736f, -0.01852956f, 0.01620691f, 0.00570956f, -0.02895011f, -0.00730570f, -0.01769091f, 0.00425068f, 
    -0.04239984f, -0.04540680f, -0.03013311f, -0.02331657f, -0.03598986f, -0.01731771f, 0.02982837f, -0.03706159f, 
    0.01536430f, 0.01681967f, 0.00249828f, -0.00246148f, -0.00868667f, -0.02246262f, 0.00987217f, -0.00262057f, 
    0.02283442f, -0.02966004f, 0.00757804f, -0.02336426f, -0.03009185f, -0.04532726f, -0.02097543f, -0.03585291f, 
    0.00776573f, 0.00697609f, -0.03619718f, -0.01931805f, -0.02911533f, 0.00026883f, 0.03651930f, -0.00863800f, 
    0.00634473f, -0.01296627f, 0.00056164f, 0.02113054f, 0.02604519f, 0.01385407f, -0.00745183f, 0.03484914f, 
    0.00107308f, -0.01340199f, -0.02439707f, -0.02077479f, -0.00678157f, 0.02196712f, -0.03514495f, -0.00969590f, 
    0.00812640f, 0.01729880f, -0.02263257f, -0.00239270f, -0.03580768f, 0.00640391f, -0.03964894f, -0.02815606f, 
    -0.02511763f, -0.03119409f, -0.03474927f, 0.01599008f, -0.03946415f, 0.02766297f, -0.00135136f, -0.01120264f, 
    -0.01080222f, -0.00193074f, 0.01890566f, -0.02574912f, -0.02299221f, -0.04423631f, 0.01754408f, -0.00780511f, 
    0.01154529f, -0.03837611f, 0.02501919f, -0.01662953f, -0.03886655f, -0.00600728f, 0.02104075f, 0.00716663f, 
    -0.01001958f, 0.02266688f, 0.01779873f, -0.02298067f, 0.03037603f, -0.00320633f, -0.03910695f, -0.04957368f, 
    0.01396526f, -0.04786223f, 0.00567766f, -0.03927685f, -0.02334137f, -0.04179206f, -0.02586822f, -0.01349394f, 
    -0.00135175f, -0.03738263f, 0.02337991f, -0.04179035f, 0.00793583f, -0.00031591f, -0.03574178f, -0.02248339f, 
    -0.01709714f, -0.04500383f, -0.02853190f, 0.00831990f, 0.02338888f, 0.02842416f, -0.00909191f, -0.03855022f, 
    -0.03996870f, -0.03108291f, 0.01304009f, -0.02870887f, -0.00324586f, 0.00207026f, 0.01920983f, -0.00836222f, 
    0.03078270f, 0.02158886f, -0.04174831f, -0.02614213f, 0.02588468f, 0.00431194f, 0.01828046f, -0.03680852f, 
    0.02546449f, -0.01232751f, -0.02882047f, 0.01998952f, 0.03227367f, 0.00971585f, 0.00393413f, -0.00414401f, 
    -0.01659252f, -0.04284748f, 0.03028306f, 0.01934607f, -0.03774651f, -0.00356561f, 0.01480550f, 0.02344112f, 
    -0.00124496f, 0.01474275f, 0.02187962f, 0.01314043f, 0.02147906f, 0.01918367f, -0.02146541f, -0.01198398f, 
    -0.02779134f, 0.00945834f, -0.03556548f, -0.04698155f, 0.01383490f, -0.02928267f, 0.01925196f, -0.03370495f, 
    -0.01395328f, 0.02504940f, -0.02256191f, 0.02268430f, -0.00870498f, -0.03307934f, -0.01890684f, 0.01128328f, 
    0.02007820f, 0.02560748f, 0.02028932f, -0.00900325f, 0.02970457f, 0.03272833f, 0.02264979f, -0.02506316f, 
    0.02285030f, -0.01214461f, -0.04326548f, -0.01239414f, 0.01971367f, 0.00685116f, 0.01776642f, 0.01443723f, 
    -0.01464021f, 0.02260830f, -0.00550902f, -0.01834159f, 0.00948456f, 0.02512047f, 0.02871323f, 0.02478512f, 
    0.02104490f, -0.02584241f, -0.04024602f, -0.04355729f, 0.02633871f, -0.04191659f, -0.02242666f, 0.00958793f, 
    -0.04626547f, 0.00746688f, 0.00435438f, 0.00207677f, 0.00173703f, -0.03848895f, -0.04308890f, 0.00323895f, 
    -0.04156553f, -0.00983359f, 0.00845934f, -0.02887708f, 0.00030987f, -0.00102013f, -0.02567143f, 0.00222912f, 
    -0.00530770f, 0.01456135f, -0.03935986f, -0.02788693f, 0.00381286f, 0.03149262f, 0.00127219f, -0.02777802f, 
    -0.00408391f, -0.02643594f, 0.00483568f, 0.02699584f, -0.03982508f, 0.03295279f, -0.01507606f, 0.00967030f, 
    0.00689485f, 0.00184364f, -0.03533587f, 0.00421242f, 0.02427125f, 0.00712265f, -0.01646938f, -0.01549782f, 
    -0.02664066f, -0.02780327f, -0.01333830f, -0.02831724f, 0.02157235f, 0.01035216f, -0.01942922f, -0.01419020f, 
    -0.00778030f, -0.03664400f, -0.01744066f, -0.02930541f, 0.03131935f, -0.02581934f, -0.02136385f, 0.01062571f, 
    -0.04221289f, 0.00618098f, -0.01522588f, 0.01668800f, -0.03008702f, -0.03206299f, -0.03439497f, -0.02149504f, 
    -0.04182813f, -0.01799873f, 0.01883695f, 0.01257005f, 0.01395357f, -0.01563485f, 0.00548677f, -0.02879605f, 
    0.02401867f, -0.04233227f, -0.00496285f, 0.01907771f, -0.03661603f, 0.00264165f, -0.00786444f, 0.03538054f, 
    0.03071727f, -0.00738031f, 0.01711004f, -0.00929507f, 0.00449258f, -0.03700245f, -0.04591518f, -0.04188436f, 
    0.01298295f, -0.02331241f, -0.04216750f, -0.02553416f, -0.00185115f, -0.00082811f, 0.00903257f, 0.02826851f, 
    0.01255267f, 0.03254540f, -0.04218601f, -0.03322498f, 0.02112750f, 0.01100977f, 0.01045560f, 0.00152999f, 
    0.01198796f, 0.02812328f, -0.00288514f, 0.02663105f, -0.02245121f, -0.01811733f, 0.02328737f, 0.03070022f, 
    -0.02290513f, 0.02453854f, -0.00993324f, 0.01190786f, -0.03917798f, -0.00652009f, -0.01504184f, -0.03332479f, 
    0.00426374f, 0.01406335f, 0.01308757f, 0.02980201f, 0.00458162f, 0.00516893f, 0.03127890f, -0.03919522f, 
    -0.03237488f, 0.02985753f, 0.01262103f, -0.00348316f, 0.02534546f, -0.01712858f, -0.00882664f, 0.00910023f, 
    -0.01666984f, 0.02185371f, -0.03981547f, -0.00466496f, -0.04572298f, 0.01080125f, 0.00986834f, 0.00304550f, 
    0.03571291f, -0.01694876f, 0.02793986f, 0.02515776f, 0.00652637f, -0.03056614f, -0.03835853f, -0.03629436f, 
    -0.01655566f, 0.02748462f, -0.03273160f, -0.04832234f, -0.01143445f, 0.01749445f, -0.01736665f, 0.03113314f, 
    0.02341586f, -0.04457394f, 0.02250976f, 0.02806531f, -0.00714809f, 0.02132213f, -0.00398313f, -0.03269247f, 
    -0.02623443f, -0.02324239f, 0.03552228f, 0.00003535f, 0.00257279f, 0.01354397f, -0.03815341f, -0.01816332f, 
    -0.02282931f, -0.02021389f, 0.03111105f, 0.02932249f, 0.02624405f, -0.01776222f, -0.00789875f, -0.00955899f, 
    -0.00066266f, -0.00392054f, -0.01771571f, -0.03046111f, -0.00021961f, -0.04216148f, 0.01056239f, 0.01697118f, 
    0.00829207f, 0.03112780f, -0.01862537f, 0.01357982f, -0.02417828f, 0.02914659f, -0.01093157f, -0.01044672f, 
    -0.03757653f, -0.04667675f, -0.00332736f, 0.02894961f, -0.01408715f, 0.00044172f, 0.01076542f, 0.00383195f, 
    -0.04176849f, -0.00972807f, -0.01898915f, -0.02052297f, 0.01385527f, 0.02835127f, -0.03740728f, 0.00986002f, 
    -0.01515866f, -0.01670363f, 0.01137353f, 0.02707240f, -0.02523746f, -0.01344695f, -0.02630857f, -0.00506440f, 
    -0.01279049f, 0.00276395f, -0.00373761f, -0.00390899f, 0.02717168f, -0.01537603f, -0.03013274f, 0.00753886f, 
    -0.03162085f, 0.02339705f, 0.01187140f, -0.03053037f, -0.03951871f, -0.01777682f, -0.03704630f, -0.03346307f, 
    -0.01350640f, -0.04067735f, 0.01050845f, -0.02726275f, 0.02583465f, -0.00292347f, 0.03524194f, 0.02130958f, 
    -0.00777195f, -0.00508150f, -0.00301137f, 0.01867590f, -0.01416634f, -0.01954991f, -0.01716200f, -0.00389909f, 
    0.03667829f, 0.02066623f, 0.00262361f, -0.00774767f, -0.04085357f, 0.01566407f, -0.03688231f, -0.01464947f, 
    0.02389652f, 0.00475940f, -0.01300138f, -0.04250685f, 0.00195114f, -0.02110030f, -0.01507257f, -0.03546368f, 
    0.02629581f, -0.02107599f, 0.00992277f, -0.04529666f, -0.04127615f, 0.02573081f, 0.01489751f, -0.03168880f, 
    0.02745686f, -0.02548890f, -0.02275700f, 0.00538965f, 0.03243373f, -0.04722860f, -0.00200302f, -0.02479913f, 
    -0.00787136f, -0.02812391f, 0.00176671f, -0.00568194f, 0.01899803f, -0.01212411f, -0.04294661f, 0.02993871f, 
    -0.02888030f, 0.00723277f, 0.03099912f, -0.02558840f, -0.02864904f, -0.03032598f, -0.01415839f, 0.01722395f, 
    -0.00708925f, 0.03052007f, -0.01055723f, -0.00778477f, 0.00481378f, 0.02822999f, 0.02934368f, -0.00889966f, 
    0.01645746f, -0.03522833f, 0.03141134f, -0.01909657f, -0.01687957f, -0.04582253f, -0.03947150f, -0.03920852f, 
    0.02977506f, 0.02361343f, -0.00308481f, -0.04703305f, 0.03260921f, -0.04139454f, -0.03949721f, -0.02294546f, 
    0.02800057f, 0.02791311f, -0.01750754f, -0.04139442f, 0.02317351f, 0.01854436f, -0.01452836f, -0.02631206f, 
    -0.02256793f, 0.02616100f, -0.04742436f, 0.03312560f, -0.03730083f, -0.00664072f, 0.02497914f, 0.01567417f, 
    0.02296307f, 0.01693707f, -0.00893650f, -0.00721272f, 0.02693739f, -0.01541285f, 0.01543182f, -0.03101712f, 
    0.02914102f, -0.04218411f, -0.03557044f, 0.02982047f, -0.04181185f, -0.00716985f, 0.02871161f, -0.01597638f, 
    0.01353474f, 0.00209094f, -0.01999147f, 0.02467049f, -0.04347841f, -0.00160037f, 0.00528687f, 0.01750544f, 
    -0.01439058f, -0.03680481f, 0.01878409f, -0.03423075f, -0.04192805f, -0.00110398f, -0.02885126f, -0.03014007f, 
    0.01419963f, -0.04388481f, -0.02400971f, 0.01762936f, -0.00272063f, -0.03689163f, 0.00911950f, 0.01286801f, 
    0.02315507f, 0.03487256f, 0.02058698f, 0.02442335f, 0.00552328f, 0.01859444f, -0.03482005f, 0.01435337f, 
    -0.03929327f, 0.00403952f, 0.02104054f, 0.03432508f, 0.00665529f, 0.03671874f, -0.02423882f, -0.02857524f, 
    -0.03566345f, -0.03713436f, 0.01741364f, 0.01647869f, 0.01317334f, -0.03609532f, 0.03206440f, 0.03084355f, 
    0.00333540f, -0.00781056f, -0.02231394f, 0.03150957f, 0.03239287f, 0.00582283f, 0.02928835f, -0.03077262f, 
    0.03340377f, 0.02889322f, 0.00892039f, 0.00462630f, -0.01115710f, -0.01146184f, 0.01977079f, -0.01703622f, 
    -0.03752939f, -0.00893953f, 0.00811436f, 0.00355738f, -0.00034928f, 0.01483361f, 0.01706126f, -0.02187138f, 
    -0.01682147f, -0.00880352f, -0.02571688f, -0.01245598f, 0.01704865f, 0.00865151f, -0.01589657f, -0.02919928f, 
    0.02744643f, -0.02130898f, -0.03178812f, -0.02370152f, -0.00560681f, -0.01159994f, 0.00322155f, 0.02635347f, 
    -0.02750096f, 0.02992489f, 0.00579356f, -0.04733763f, -0.03521032f, -0.02263820f, -0.02935457f, -0.01138984f, 
    -0.01026896f, -0.04180540f, -0.01806457f, 0.02899280f, 0.02207155f, 0.03561105f, -0.04275741f, -0.01318518f, 
    -0.01606329f, -0.01704267f, -0.01825584f, -0.02762650f, -0.04060750f, 0.01334407f, 0.01083906f, -0.03887157f, 
    -0.02235627f, 0.03604756f, -0.00827615f, 0.03192201f, 0.01565478f, 0.00874243f, -0.01355242f, 0.02250561f, 
    0.02260988f, 0.02316354f, -0.02071428f, 0.02508018f, -0.00472279f, 0.00628235f, -0.04722610f, -0.03078664f, 
    -0.03682077f, 0.02477646f, -0.03839757f, 0.01402798f, 0.00599122f, 0.00988633f, -0.00155699f, -0.02091138f, 
    -0.02501331f, -0.04350431f, -0.01244732f, -0.02769802f, -0.00541147f, 0.02733082f, -0.00220622f, -0.04619874f, 
    -0.04088845f, 0.02773376f, 0.03024542f, 0.00683160f, -0.01769288f, -0.02575521f, -0.02837497f, -0.03577751f, 
    -0.01169374f, -0.04691947f, 0.02993761f, -0.02954141f, 0.00726314f, 0.00387728f, -0.02547148f, -0.02059697f, 
    -0.00586750f, 0.00499820f, -0.01404747f, -0.02233463f, 0.01095559f, -0.00157588f, -0.02224629f, -0.03357054f, 
    0.02835724f, 0.01819106f, -0.01186073f, -0.04648419f, -0.03708706f, 0.00835618f, 0.03630370f, -0.03950229f, 
    0.01709000f, -0.02586984f, -0.03897872f, -0.03689444f, 0.02258846f, -0.01288189f, 0.00264697f, -0.00050783f, 
    0.02913931f, -0.02806544f, -0.00660098f, 0.01035470f, -0.02185644f, 0.03552293f, -0.01571727f, -0.00775412f, 
    0.01582818f, -0.03784601f, 0.02324294f, 0.01008909f, 0.02331498f, -0.02622201f, -0.01895097f, -0.02099703f, 
    0.02432298f, 0.00597022f, 0.02987924f, 0.01401975f, 0.00429964f, -0.03573637f, -0.00275080f, 0.01068333f, 
    -0.03491389f, -0.03307804f, 0.02119676f, -0.00342080f, -0.02129916f, 0.00706492f, 0.00348877f, -0.02933687f, 
    0.00518361f, 0.01289685f, 0.03058916f, -0.04278116f, -0.02403559f, -0.00417732f, -0.02546013f, 0.00606276f, 
    0.02487329f, -0.03353475f, 0.01648845f, -0.00177052f, 0.02562822f, -0.02631354f, -0.01140323f, 0.03326262f, 
    -0.00736921f, 0.02289096f, -0.00602831f, -0.04134791f, -0.00508314f, -0.04607963f, 0.00284297f, 0.00004282f, 
    -0.04713304f, 0.00260674f, -0.01883776f, 0.02649760f, -0.01974987f, 0.00047252f, 0.00561851f, 0.01575388f, 
    -0.01082543f, -0.00723676f, -0.03646236f, -0.00220009f, -0.02738091f, 0.01728921f, -0.01749174f, 0.01566647f, 
    -0.00458079f, 0.00584982f, -0.04566615f, -0.00544652f, -0.03912299f, -0.03345999f, -0.01650751f, -0.04288276f, 
    -0.01322076f, 0.01938899f, 0.02372005f, 0.01054238f, -0.01113702f, -0.03694096f, -0.03862367f, 0.02123154f, 
    0.02057069f, -0.00121511f, 0.01601823f, 0.03326043f, 0.02522065f, 0.01340375f, -0.00487967f, 0.00469411f, 
    -0.01567805f, -0.03203153f, -0.03224804f, 0.02636223f, -0.00346961f, 0.01485821f, -0.02649281f, 0.00410088f, 
    -0.00886642f, 0.02098967f, 0.02302149f, 0.02783636f, -0.00964660f, 0.01242880f, 0.01006731f, -0.01019363f, 
    0.02872654f, -0.03512522f, 0.00929035f, 0.02180162f, 0.01475108f, -0.02539549f, -0.04553536f, -0.03465023f, 
    0.00113632f, 0.03330213f, 0.00378552f, -0.00670563f, 0.02241668f, 0.01203075f, 0.00127022f, 0.00304683f, 
    0.02773821f, 0.03119994f, -0.02663829f, -0.01635535f, 0.00491148f, 0.03412774f, -0.00732752f, -0.01935843f, 
    0.01460657f, -0.01191067f, 0.01168628f, 0.01606793f, -0.01879414f, 0.00010831f, -0.02139653f, 0.01325093f, 
    0.00281287f, -0.03077700f, 0.00895793f, 0.03046829f, 0.01494710f, -0.00742076f, 0.01707765f, 0.01563315f, 
    -0.04671556f, -0.01900006f, -0.01546052f, 0.00502092f, -0.02664464f, 0.02647637f, 0.00134269f, -0.03576309f, 
    -0.03297394f, 0.02716652f, -0.03238880f, 0.00216543f, -0.00430125f, 0.02812426f, -0.02089511f, 0.03539362f, 
    0.00936193f, 0.01163234f, -0.04250997f, -0.00546798f, 0.02826771f, -0.01645261f, 0.02186578f, 0.00547630f, 
    -0.01544811f, -0.01428994f, -0.00494113f, -0.01424070f, -0.00109421f, 0.00276846f, -0.03329369f, 0.01463506f, 
    -0.01946380f, 0.00711303f, 0.02654348f, 0.01630537f, 0.00225506f, -0.00510166f, 0.01047620f, -0.03200861f, 
    -0.03288651f, 0.00707238f, -0.02611933f, -0.02712370f, -0.02610745f, -0.01978334f, -0.04575708f, 0.02316292f, 
    -0.04457025f, 0.00335772f, 0.00234966f, -0.02955560f, 0.00953543f, -0.01024012f, -0.00558317f, 0.00071596f, 
    0.01495829f, 0.00940009f, -0.04626525f, -0.04185717f, -0.03713496f, -0.01586178f, -0.04501088f, -0.00099754f, 
    0.02739281f, -0.03677363f, -0.03846540f, -0.02194668f, 0.00310695f, -0.03880304f, -0.00008291f, -0.03927992f, 
    -0.02175262f, 0.01884756f, 0.02519039f, -0.00378950f, 0.00820165f, -0.00518523f, 0.01674799f, -0.01727157f, 
    -0.00963757f, 0.00670183f, -0.01901047f, 0.01022628f, -0.01436754f, -0.01284224f, 0.03112412f, 0.01557989f, 
    0.02033663f, 0.01650234f, -0.02206710f, 0.01787465f, 0.04001632f, -0.01276085f, 0.01415652f, -0.00038698f, 
    -0.03888623f, 0.03270589f, -0.00874398f, 0.02050220f, -0.01872981f, -0.03896864f, -0.02323543f, 0.02334711f, 
    -0.03218982f, -0.02578459f, -0.01536365f, -0.04224718f, -0.01053116f, -0.00834873f, 0.03473468f, 0.02254600f, 
    0.00197121f, -0.04062754f, 0.00065474f, -0.03556530f, 0.02002686f, -0.00065043f, -0.02774267f, -0.03892871f, 
    -0.03845258f, 0.01746245f, -0.00233843f, 0.03752642f, 0.00024645f, -0.03092500f, -0.02204023f, 0.02577626f, 
    -0.01231837f, 0.01594120f, -0.02007684f, -0.03798040f, 0.02088584f, 0.03379206f, 0.01478936f, 0.02225053f, 
    0.00590787f, 0.02507875f, -0.04275549f, 0.00369147f, 0.02889619f, 0.00427316f, -0.04472783f, 0.03041442f, 
    0.00959546f, 0.00787040f, 0.02932967f, -0.01382726f, 0.01958479f, 0.00841338f, 0.02378206f, -0.02351894f, 
    0.03525126f, 0.01433157f, 0.01874428f, -0.02594086f, -0.04100673f, 0.00853635f, -0.04440028f, 0.02474780f, 
    0.02442254f, -0.00291286f, 0.03519319f, -0.00473006f, 0.03445585f, -0.04034607f, -0.02520703f, -0.01095400f, 
    -0.02036517f, -0.00540246f, -0.01321170f, -0.01363471f, -0.00718694f, -0.03748098f, -0.00715971f, -0.00001882f, 
    -0.00142911f, -0.03776718f, -0.02482178f, -0.01931735f, 0.02176996f, -0.01396273f, -0.04096827f, -0.02041572f, 
    -0.01657453f, 0.01404582f, -0.01849189f, -0.00874963f, 0.01033064f, 0.02971582f, 0.02695619f, -0.02154722f, 
    0.00354525f, -0.02959794f, -0.02550597f, -0.00099761f, -0.03335380f, -0.01459320f, 0.03055917f, -0.02992312f, 
    -0.03061887f, -0.02803787f, 0.02106187f, 0.03340306f, -0.01862920f, 0.02891411f, -0.03212314f, -0.01020864f, 
    0.02679067f, 0.00841812f, -0.03930045f, -0.00221590f, 0.02994216f, 0.03011459f, -0.03143697f, -0.01736654f, 
    -0.01147390f, -0.04226350f, 0.01312071f, -0.03387701f, -0.02738755f, -0.02931994f, 0.01043491f, -0.00496659f, 
    -0.03401409f, 0.00014012f, -0.03375515f, -0.04171263f, -0.00045976f, 0.01285909f, -0.02480407f, -0.00191395f, 
    0.03098385f, -0.04292312f, 0.00066808f, 0.01298147f, -0.00718759f, 0.00273946f, 0.01440987f, 0.02625089f, 
    -0.00417399f, 0.00906653f, 0.00896139f, -0.03600514f, -0.00507025f, 0.02060420f, -0.04170551f, -0.02395033f, 
    -0.04466590f, -0.01265086f, -0.03419460f, -0.02541957f, 0.01715853f, -0.03094433f, -0.03956019f, 0.02138085f, 
    -0.02852950f, 0.00568052f, 0.00748574f, 0.02057217f, 0.00130012f, 0.01441310f, -0.04266400f, -0.03799760f, 
    -0.00462904f, -0.01649182f, 0.02722481f, -0.03474525f, -0.02540007f, -0.00391949f, 0.03494486f, -0.02069289f, 
    0.01060316f, 0.00860619f, -0.03079731f, 0.01265088f, 0.03507872f, 0.02802862f, 0.00878252f, 0.01818915f, 
    -0.00619104f, 0.03144440f, -0.04650512f, 0.03229233f, -0.01405350f, 0.01515826f, -0.00040072f, -0.03476793f, 
    -0.02825839f, 0.02048595f, 0.00884419f, -0.01495362f, 0.02975201f, -0.02045215f, -0.02652359f, -0.00914727f, 
    -0.04036521f, -0.03941609f, -0.03588384f, -0.00669483f, -0.02642323f, 0.01391289f, -0.02022431f, -0.01274934f, 
    -0.03507151f, 0.00045495f, 0.00881783f, 0.02986165f, -0.00752456f, 0.00432097f, -0.04320424f, -0.03036921f, 
    0.00554169f, 0.00434444f, 0.01845674f, -0.04781872f, -0.02988955f, 0.01524590f, -0.03910711f, 0.02701509f, 
    0.03522079f, 0.00189127f, -0.02663369f, -0.03935322f, -0.02124504f, -0.00463566f, -0.01523450f, 0.02435799f, 
    0.01055272f, 0.01259247f, -0.00904227f, 0.00544019f, -0.03940364f, 0.01303068f, -0.00768482f, -0.03222930f, 
    -0.04038268f, -0.03028641f, -0.03399381f, 0.01490557f, -0.02537934f, -0.01546681f, -0.02245370f, -0.03149697f, 
    0.01335053f, -0.01356500f, -0.00726458f, -0.03946047f, -0.03315785f, 0.01963586f, -0.02010305f, -0.00664341f, 
    -0.01772305f, 0.00816047f, -0.01107283f, -0.02645573f, -0.03205064f, 0.03117564f, -0.00772042f, -0.02539946f, 
    -0.01190951f, -0.01292956f, -0.04288179f, 0.00750873f, -0.02129133f, -0.00432796f, 0.03552974f, -0.02978833f, 
    -0.00613993f, -0.03471761f, -0.02725031f, -0.03453261f, 0.03084856f, -0.03342021f, 0.01003353f, -0.03073226f, 
    -0.01002506f, 0.01955413f, -0.00715456f, -0.01787788f, -0.04134000f, -0.00060673f, -0.01107333f, 0.01401981f, 
    0.02091305f, -0.01614817f, 0.00034587f, -0.03283961f, -0.03491201f, 0.00304283f, 0.01448794f, -0.00093620f, 
    -0.02266300f, -0.02893547f, -0.00036414f, -0.02019481f, -0.02653720f, -0.02454360f, -0.00841997f, -0.03485067f, 
    0.01283360f, -0.02806827f, -0.00751776f, 0.00955475f, -0.01354101f, 0.03226539f, -0.04116830f, 0.02391692f, 
    -0.03207552f, -0.04274351f, 0.00788440f, -0.01480911f, -0.00315092f, -0.04337681f, -0.02945962f, 0.00724984f, 
    -0.00462928f, -0.03139269f, -0.01067478f, -0.01448181f, 0.02233030f, -0.00732692f, 0.02122100f, 0.00646969f, 
    -0.03521766f, -0.00431036f, -0.03073637f, 0.00294953f, 0.00788616f, -0.02139156f, 0.01932678f, -0.00374142f, 
    0.00772067f, 0.01485935f, -0.03549172f, -0.03681201f, -0.00975902f, -0.02725757f, 0.00853702f, -0.01395394f, 
    -0.03001058f, -0.02197644f, -0.01869309f, 0.01405873f, -0.03230236f, 0.01532122f, 0.00353821f, -0.02765304f, 
    -0.03718002f, -0.01935407f, -0.01477637f, -0.04118547f, -0.03558207f, 0.01830586f, 0.02598140f, 0.02801806f, 
    0.02230734f, 0.01364394f, 0.01720384f, -0.01347472f, -0.03441719f, -0.02331878f, -0.00228512f, 0.01709287f, 
    0.01626072f, -0.01241731f, -0.01165397f, 0.02658573f, -0.03305215f, -0.02955301f, -0.01907005f, -0.03444884f, 
    -0.00072671f, -0.03691557f, -0.00774830f, 0.00115995f, 0.02812560f, -0.01010628f, -0.04437623f, -0.02780863f, 
    -0.00380809f, -0.00196976f, -0.00952956f, -0.01890408f, -0.00639115f, -0.00692366f, -0.02806595f, -0.00107047f, 
    -0.00034089f, -0.01667269f, 0.03190340f, -0.04481551f, -0.00085556f, -0.02755352f, 0.01640720f, -0.00226143f, 
    0.00131509f, 0.03092698f, 0.01327280f, -0.02003411f, 0.03287024f, -0.04108775f, -0.03724495f, -0.03136678f, 
    -0.03404815f, 0.00413923f, -0.01288063f, 0.01876843f, 0.01508813f, -0.04398688f, 0.01276686f, 0.01433643f, 
    -0.01581995f, 0.00096872f, -0.02126246f, 0.02133190f, -0.00415878f, 0.00102147f, -0.01267325f, -0.01621042f, 
    0.01291988f, -0.03174668f, -0.02369620f, -0.01295404f, -0.03887867f, 0.01655197f, -0.03045576f, -0.02291781f, 
    0.01218489f, -0.03988797f, -0.03860974f, 0.03106643f, -0.01895088f, -0.00072524f, 0.00394335f, -0.01728500f, 
    -0.00314425f, -0.04124409f, 0.03292017f, -0.02369097f, 0.02538309f, 0.02987578f, -0.04347591f, -0.02546393f, 
    -0.00727319f, -0.00589937f, -0.01455677f, 0.03233165f, -0.01839424f, -0.02141677f, 0.00964629f, 0.01823290f, 
    0.00635266f, 0.00882547f, 0.01859299f, -0.02506189f, -0.03863434f, 0.01889660f, 0.00372747f, -0.04475150f, 
    0.00883856f, -0.00939200f, -0.01842438f, -0.00867651f, 0.01970292f, -0.04241629f, -0.02457142f, 0.01890461f, 
    0.02661817f, -0.02339326f, -0.00869371f, 0.01510109f, -0.01665574f, -0.02798294f, 0.02204151f, 0.03194497f, 
    0.03064937f, -0.00435606f, -0.04490383f, 0.02612639f, -0.04447462f, 0.02084892f, 0.03320096f, -0.00792843f, 
    -0.02529763f, 0.00520123f, 0.01132507f, -0.04444898f, -0.04305359f, -0.01895984f, -0.02316245f, -0.00589438f, 
    0.01650896f, 0.03326574f, -0.00965990f, -0.01785805f, 0.00889500f, 0.02754543f, -0.00478417f, -0.00133260f, 
    0.02373702f, -0.03812177f, 0.03320809f, 0.00031279f, 0.01604686f, 0.01885759f, 0.00653962f, 0.00084525f, 
    0.00455253f, 0.01598112f, 0.00295534f, 0.01496169f, 0.01444852f, 0.00892645f, 0.00546041f, 0.00461806f, 
    0.01227962f, -0.02618344f, 0.01422863f, 0.01679946f, -0.04109308f, -0.03278314f, -0.04208541f, -0.02983218f, 
    -0.01769379f, -0.00436573f, -0.02768822f, -0.04487374f, -0.00563744f, 0.02124382f, 0.02525833f, 0.03150580f, 
    0.02085903f, -0.01125637f, -0.03139797f, -0.02829336f, 0.00552751f, -0.02591324f, -0.04456961f, 0.00731212f, 
    -0.02617244f, -0.00596150f, -0.00754581f, -0.00248279f, 0.02534917f, 0.00067293f, -0.03587106f, -0.00168004f, 
    0.03133562f, 0.03326332f, 0.00008767f, -0.01587912f, 0.02403278f, 0.00207135f, -0.00677169f, -0.02358395f, 
    -0.03978936f, 0.00943405f, 0.01817854f, 0.02891805f, 0.00375153f, -0.00246176f, -0.01913197f, -0.04053446f, 
    -0.01210714f, -0.04338407f, 0.01672100f, 0.00804606f, -0.02811247f, 0.02945859f, 0.00443179f, -0.01436923f, 
    -0.01191673f, 0.01816534f, 0.02567688f, -0.00444017f, 0.01408083f, -0.01579937f, -0.04465103f, 0.01792087f, 
    0.00144588f, -0.03668311f, -0.02470241f, 0.02795565f, 0.00411108f, 0.01465031f, 0.01617314f, -0.04046236f, 
    -0.02878733f, 0.02099409f, -0.01344609f, -0.02366152f, 0.00243192f, -0.03621108f, -0.02658834f, -0.04019603f, 
    -0.03912061f, -0.02279177f, 0.02913617f, -0.00799495f, 0.00694470f, 0.00520636f, -0.02111941f, 0.01008500f, 
    0.02004101f, 0.00158094f, 0.01142452f, 0.01153319f, -0.04402088f, 0.00935541f, -0.00966777f, -0.03841368f, 
    0.02524841f, -0.03242142f, -0.01133017f, 0.01945847f, -0.02145047f, -0.00288676f, -0.02557620f, 0.00029035f, 
    -0.01754421f, 0.00411189f, -0.02877534f, 0.01388013f, 0.03203952f, -0.03810111f, -0.02104477f, 0.02971299f, 
    0.01697667f, 0.01379592f, -0.02080325f, -0.00030544f, -0.02423182f, -0.00849647f, -0.03763464f, -0.02066713f, 
    -0.00338207f, 0.01769106f, 0.00083146f, -0.00843055f, 0.01682464f, -0.00147274f, -0.01854283f, 0.01009392f, 
    0.00664498f, 0.00630169f, 0.00549579f, -0.02123487f, 0.00188911f, 0.01687956f, -0.03403673f, 0.01703766f, 
    0.03070363f, -0.03503962f, -0.03027967f, 0.01423390f, 0.00825029f, -0.01783061f, 0.02292333f, 0.01142920f, 
    0.00069720f, 0.00489096f, 0.02786130f, -0.03043405f, -0.00420026f, -0.01704683f, -0.02701516f, 0.02882504f, 
    -0.04092308f, -0.03479473f, -0.03245174f, 0.01191851f, -0.02503979f, 0.02609748f, -0.01008824f, -0.03911955f, 
    -0.04324546f, -0.02810849f, -0.01118763f, 0.02530788f, -0.04373758f, -0.01963220f, -0.02075602f, -0.02739188f, 
    0.01160121f, 0.02839214f, -0.04356009f, -0.01251351f, 0.00112785f, -0.02247215f, 0.01764554f, 0.00773225f, 
    0.02648371f, 0.00910789f, -0.01879778f, -0.01479978f, -0.02916344f, -0.00999567f, 0.03275346f, -0.01323420f, 
    0.00817101f, -0.04046703f, 0.01332797f, -0.00928830f, -0.00907857f, -0.00328366f, 0.01595363f, 0.03121543f, 
    -0.00379281f, 0.00056120f, 0.02670343f, -0.00344171f, -0.03532485f, -0.03761449f, 0.02112148f, -0.02736933f, 
    0.02576929f, -0.01315363f, -0.01741192f, -0.02476723f, 0.02700774f, -0.02889019f, -0.02716455f, -0.04032306f, 
    0.02451087f, -0.01669126f, -0.02604913f, -0.04310631f, -0.04253615f, 0.02545763f, -0.04528995f, -0.04164867f, 
    -0.02226408f, 0.00746605f, -0.02041560f, -0.03433627f, 0.01165668f, 0.00134624f, -0.00699811f, -0.02334406f, 
    -0.02060219f, 0.00830314f, -0.00270743f, 0.01297538f, -0.03543458f, 0.02752904f, -0.03916310f, 0.00198347f, 
    -0.01714580f, -0.02187845f, -0.02214373f, 0.02728096f, 0.02033557f, -0.04136609f, -0.03113194f, -0.01347696f, 
    0.01163986f, -0.00479935f, 0.01657427f, -0.01206022f, 0.02028640f, 0.03162709f, 0.02589490f, -0.00939888f, 
    -0.04147825f, -0.02935436f, -0.03205426f, -0.03415206f, 0.00210203f, -0.04040802f, -0.04452323f, -0.03720694f, 
    0.01360652f, -0.03647980f, -0.00519974f, -0.02863087f, 0.01887825f, -0.03158898f, -0.01268536f, -0.01109131f, 
    -0.02911883f, -0.01739441f, -0.02072126f, 0.00637063f, -0.02516851f, -0.00058548f, -0.00387256f, 0.00295224f, 
    -0.03977204f, -0.01477456f, -0.04009638f, 0.01694582f, -0.03888035f, 0.03115216f, -0.00357295f, 0.01733194f, 
    -0.00987361f, 0.00038171f, -0.01111878f, 0.01292130f, 0.01049366f, 0.00139481f, -0.00753308f, -0.01473642f, 
    0.00431593f, -0.03221045f, 0.01891978f, 0.02282913f, -0.04421065f, 0.00232739f, -0.01380670f, -0.00376921f, 
    0.01838991f, 0.02294397f, -0.04542090f, 0.01225296f, 0.01066183f, -0.01317095f, -0.03151023f, -0.03301239f, 
    0.02294122f, 0.02908869f, -0.03587908f, 0.01578290f, -0.03978382f, -0.01873891f, 0.02493296f, 0.00282010f, 
    -0.03891634f, -0.02453118f, 0.00823421f, -0.02137693f, -0.00951115f, -0.01177561f, 0.02304075f, 0.02845438f, 
    -0.04028505f, 0.00041479f, 0.01698515f, 0.01019201f, 0.01867526f, 0.02522243f, 0.03078212f, -0.02351265f, 
    -0.02481909f, -0.04104735f, -0.04197815f, 0.02521716f, -0.01212236f, 0.03239140f, -0.02512445f, 0.02241593f, 
    0.01107337f, -0.00894734f, -0.02558609f, -0.01122426f, -0.02667946f, -0.04506722f, -0.00435500f, 0.02693420f, 
    -0.00427919f, 0.02910648f, -0.03451179f, 0.02490735f, 0.03208965f, 0.02891476f, 0.00084501f, -0.02827188f, 
    -0.01685842f, -0.00590709f, -0.00904221f, -0.01120413f, 0.02090027f, -0.03423740f, -0.01503593f, 0.01070349f, 
    -0.02176963f, 0.01543244f, -0.02779608f, -0.01865536f, 0.03090467f, -0.01858930f, -0.03702611f, -0.02929236f, 
    -0.00752895f, 0.01488861f, -0.00107944f, 0.01966675f, -0.00312629f, 0.02472327f, 0.03060383f, -0.03465708f, 
    -0.02155211f, 0.03090690f, 0.00470240f, -0.03176625f, -0.00316640f, -0.00542156f, -0.03959871f, 0.02370096f, 
    -0.02524168f, -0.03173382f, 0.02752029f, 0.00106352f, -0.02961154f, 0.00754558f, -0.00628772f, -0.02055150f, 
    -0.02289224f, -0.00490834f, -0.00929205f, 0.03148389f, 0.00957863f, -0.02913361f, 0.03243078f, -0.02101126f, 
    -0.03693985f, 0.02368846f, -0.03341061f, -0.03977018f, -0.04335459f, 0.02358659f, 0.01682118f, -0.02063924f, 
    0.02645409f, -0.01113624f, 0.01727236f, -0.03819876f, 0.00491676f, 0.01970814f, -0.00237905f, 0.01508854f, 
    -0.00994159f, 0.01726488f, -0.02898515f, -0.01121374f, 0.01114179f, -0.01764058f, -0.04183580f, 0.02584500f, 
    0.00162012f, 0.01666758f, -0.02799385f, 0.02111463f, -0.00240851f, 0.00580277f, 0.00033663f, 0.01515738f, 
    -0.00865960f, 0.02208881f, -0.00750219f, 0.00442625f, -0.02557783f, -0.01375673f, 0.02056540f, 0.01471358f, 
    0.02244367f, 0.00429596f, -0.01807073f, 0.01997129f, 0.02315717f, -0.00799776f, 0.01817345f, -0.01486907f, 
    -0.02513728f, 0.00727208f, -0.01020893f, 0.02485331f, 0.02108921f, -0.04264985f, 0.01852982f, 0.01007459f, 
    0.02513174f, 0.01756276f, -0.01137609f, -0.03635487f, 0.01877026f, -0.01615955f, -0.04725663f, 0.02235759f, 
    -0.00704877f, -0.03031015f, -0.02814968f, 0.00386740f, 0.03214347f, -0.02166721f, 0.01056696f, -0.03866883f, 
    0.01367478f, -0.03415291f, -0.02854737f, -0.04363068f, 0.02693253f, 0.02593121f, -0.00083485f, -0.01720940f, 
    -0.01942326f, 0.00633645f, -0.02663093f, -0.02411650f, -0.04024488f, 0.02275333f, 0.00191516f, -0.02536359f, 
    0.00600023f, -0.00857749f, -0.00006976f, 0.00895186f, 0.03067558f, -0.01829506f, -0.01443195f, 0.01937472f, 
    0.01102044f, -0.00068985f, 0.01549651f, -0.02602049f, -0.00648251f, -0.02204306f, 0.01329462f, 0.00226251f, 
    -0.02674163f, -0.01260166f, -0.04565975f, 0.00707328f, 0.01139504f, -0.01483717f, -0.03346110f, -0.01477090f, 
    -0.03844574f, -0.03837261f, 0.02183064f, -0.02110082f, -0.00469138f, -0.01247647f, -0.02430111f, -0.00446495f, 
    0.03178123f, -0.04610147f, 0.00415347f, 0.00977867f, -0.01865021f, -0.00915662f, -0.03889875f, 0.01024903f, 
    -0.00819131f, 0.04174409f, -0.03879780f, 0.01528908f, -0.01311949f, -0.04267705f, -0.00532306f, -0.02857447f, 
    -0.01426473f, -0.02200459f, -0.00912895f, 0.02053303f, -0.03212788f, 0.00187397f, -0.00883958f, -0.01095223f, 
    -0.03605739f, -0.03567059f, 0.02170763f, -0.01316306f, -0.04582515f, -0.00794215f, -0.03632364f, 0.03034364f, 
    0.02941296f, -0.00390334f, 0.01003093f, -0.00965048f, 0.02702340f, -0.03724018f, 0.02148329f, -0.03653753f, 
    0.03086502f, -0.01758054f, 0.00885870f, 0.00479362f, -0.00492237f, -0.02566465f, -0.01200711f, -0.01984635f, 
    -0.00457751f, -0.00899961f, -0.03455371f, -0.00260648f, 0.01754197f, -0.04536941f, -0.00338540f, 0.01029022f, 
    0.01006494f, -0.03120883f, 0.01701129f, -0.02169214f, -0.01885332f, -0.01018614f, -0.01384692f, -0.02825617f, 
    -0.01423731f, 0.03345763f, -0.02700057f, -0.02822975f, 0.03131245f, -0.02230283f, 0.02784561f, -0.01634871f, 
    0.03018874f, 0.04108348f, -0.01133532f, 0.02665406f, 0.01102858f, -0.04000138f, 0.02965052f, 0.02760102f, 
    0.00905185f, 0.01707643f, 0.00224069f, -0.00491182f, -0.03632626f, 0.02500468f, 0.01612780f, 0.00850654f, 
    0.01929231f, -0.03097428f, 0.02991840f, -0.02018766f, 0.00251652f, -0.00547138f, 0.02991761f, -0.04698657f, 
    -0.04333928f, 0.01400955f, -0.03711680f, -0.01783615f, -0.00757219f, -0.02031286f, 0.00903410f, 0.00615408f, 
    -0.03510428f, 0.02297042f, -0.02031840f, -0.04300977f, 0.01717603f, -0.04213952f, -0.02592921f, -0.03339673f, 
    0.01024005f, 0.01107138f, 0.01052142f, 0.01917774f, -0.00619368f, -0.03050789f, -0.03059966f, -0.03413141f, 
    0.02731124f, -0.00578415f, -0.04554756f, 0.01854584f, -0.01659342f, -0.00338491f, 0.00828261f, 0.02203902f, 
    0.02582205f, -0.02653706f, 0.01671540f, 0.01874300f, -0.01533803f, 0.03228059f, 0.02150767f, -0.02196045f, 
    -0.03629449f, -0.00984749f, -0.03963417f, -0.02770601f, -0.02600090f, -0.01252997f, -0.02941321f, -0.00781185f, 
    0.03101780f, 0.01329665f, 0.00515180f, -0.02993902f, 0.01203066f, -0.02693876f, -0.02630885f, -0.00934993f, 
    -0.04447713f, -0.00986554f, -0.02237285f, -0.04561356f, -0.04392579f, -0.04532500f, -0.01696328f, -0.01933816f, 
    0.02698363f, 0.00802204f, 0.00197932f, 0.02969143f, 0.02938571f, 0.00911109f, -0.00847345f, -0.01545458f, 
    0.03166306f, 0.01411379f, 0.00976768f, -0.02530592f, 0.02929053f, -0.00527457f, 0.02680661f, -0.04461485f, 
    -0.02997366f, -0.03582808f, -0.03459243f, 0.00032658f, 0.00689733f, -0.01008612f, 0.01490150f, 0.01045398f, 
    0.00946886f, -0.01941702f, 0.02547855f, -0.00613152f, -0.00537737f, 0.03001492f, -0.02082331f, -0.03414618f, 
    -0.01727380f, -0.02164756f, -0.02206087f, -0.04430487f, 0.02300427f, -0.01306372f, -0.03472524f, -0.00386136f, 
    -0.03025638f, -0.00449497f, 0.00834024f, -0.04033656f, -0.00928646f, 0.00131435f, 0.00341883f, 0.01301436f, 
    -0.02783724f, 0.00887026f, -0.03710801f, -0.00965397f, 0.02925236f, 0.01516599f, 0.01500682f, -0.00885603f, 
    0.02179325f, -0.03085428f, 0.02456186f, -0.03958001f, -0.00225779f, -0.01475482f, -0.02408724f, -0.00913677f, 
    0.01128335f, -0.00983821f, -0.03025506f, 0.00698646f, 0.02853583f, -0.01456128f, -0.03816452f, -0.03196019f, 
    -0.02481401f, -0.01425633f, 0.03178448f, 0.00953434f, -0.04534863f, -0.01986309f, 0.02249515f, 0.01720899f, 
    -0.00057088f, -0.02132913f, 0.00247338f, 0.02966793f, -0.03325833f, -0.02953971f, 0.02932137f, 0.00362661f, 
    0.00286286f, 0.02885227f, -0.02702039f, -0.03001886f, 0.01330763f, -0.04283107f, 0.00900171f, -0.01836869f, 
    -0.03740510f, -0.02575913f, 0.00978687f, -0.03313622f, -0.04533924f, -0.02754565f, -0.04470086f, 0.01142614f, 
    -0.00322664f, 0.01810250f, -0.04347365f, 0.03157335f, -0.03259763f, 0.03133793f, -0.00241533f, 0.02920599f, 
    -0.01800828f, 0.00612826f, -0.03571453f, 0.01724555f, -0.02600400f, 0.01626367f, 0.03050784f, -0.04104326f, 
    0.00278155f, 0.02706187f, -0.02412726f, -0.02315967f, -0.02038223f, -0.03354486f, 0.00579049f, -0.00833535f, 
    0.02691754f, -0.02471217f, -0.03254399f, 0.01899639f, 0.00372900f, 0.03388293f, 0.00307264f, -0.03727406f, 
    -0.01829886f, 0.02549659f, 0.02100985f, -0.01659380f, -0.00586873f, -0.01050921f, 0.02687985f, -0.02089419f, 
    -0.03294921f, -0.00442189f, 0.02563185f, -0.04364619f, 0.01822803f, -0.00497899f, 0.00894694f, -0.03093037f, 
    0.01183400f, 0.02688193f, 0.00217391f, -0.02557125f, -0.03388754f, -0.00609510f, -0.04536269f, -0.04082054f, 
    -0.03471581f, 0.01750036f, -0.04285268f, -0.00837529f, -0.02205657f, 0.01625415f, -0.00838953f, -0.00485759f, 
    -0.01628156f, 0.01330352f, -0.00447800f, -0.03980295f, 0.02792313f, 0.01395684f, 0.00984477f, -0.03947342f, 
    0.00414626f, -0.00800337f, -0.03290098f, 0.00815044f, -0.01446385f, -0.02940096f, -0.04211622f, 0.00250550f, 
    0.01455414f, -0.00987114f, 0.00873094f, 0.00424946f, 0.01648481f, -0.03462163f, -0.03446848f, -0.00210188f, 
    0.01418669f, -0.00837144f, -0.02885483f, 0.00969337f, -0.02333092f, -0.01184352f, 0.00283899f, 0.03133487f, 
    -0.00444142f, -0.02739597f, -0.04157374f, -0.02335974f, 0.02910259f, 0.01305153f, 0.03024582f, -0.04032011f, 
    -0.01623013f, 0.00401359f, 0.02159921f, 0.01943766f, 0.01064435f, -0.01482806f, -0.04030709f, -0.00399085f, 
    0.01147466f, 0.02444329f, -0.01657893f, 0.01687201f, 0.03043858f, -0.04358648f, -0.00107179f, -0.02558786f, 
    0.01287887f, -0.01086336f, 0.00971744f, 0.02665506f, 0.03166352f, -0.02696458f, -0.00535914f, 0.02361302f, 
    -0.02209294f, -0.01157487f, -0.02910620f, 0.01065010f, -0.03905037f, 0.00308070f, -0.02104303f, -0.02896513f, 
    -0.01891133f, 0.02548679f, -0.03532107f, -0.00352195f, 0.01513366f, -0.03688056f, -0.00489078f, -0.01070533f, 
    -0.02487879f, -0.00837473f, -0.00631186f, -0.01258395f, 0.01137236f, -0.03262533f, -0.02338328f, 0.01925285f, 
    0.00117375f, -0.01752771f, -0.02925136f, -0.00631841f, -0.00076402f, -0.02396249f, -0.02056446f, 0.02626978f, 
    0.00681888f, -0.03877482f, -0.04580420f, -0.03659105f, -0.01892045f, 0.00052923f, 0.02695072f, 0.00602446f, 
    -0.01100983f, -0.02301369f, -0.04244840f, -0.03769680f, 0.03091716f, -0.01565915f, -0.02082084f, -0.01505210f, 
    0.02498881f, 0.02212406f, -0.02744856f, 0.02719414f, -0.02272915f, 0.03204899f, 0.02878551f, 0.02806461f, 
    -0.00017547f, -0.01989662f, 0.02360556f, 0.03950763f, -0.02685812f, -0.02866749f, 0.01169667f, -0.00187125f, 
    -0.02789399f, 0.02368851f, -0.03688448f, 0.02985971f, -0.04616388f, 0.01322622f, -0.03871664f, 0.03065168f, 
    -0.04151665f, -0.03833833f, -0.03411578f, 0.03312326f, -0.00055284f, -0.01885111f, 0.01531748f, -0.03981097f, 
    0.02200663f, 0.00046783f, -0.03768157f, 0.02266570f, -0.00684320f, 0.00482744f, -0.03196761f, -0.00290320f, 
    -0.01877977f, -0.02152850f, 0.02250875f, 0.02580125f, 0.03942742f, 0.01937934f, -0.04283452f, 0.00993721f, 
    -0.02568698f, -0.04560733f, 0.01590488f, -0.04281262f, -0.03586363f, 0.01558942f, 0.01019764f, 0.01966702f, 
    -0.01513423f, -0.01073202f, -0.00711270f, -0.02458278f, 0.03573288f, -0.00449710f, 0.01785482f, 0.01754110f, 
    -0.02818303f, 0.00992903f, 0.01664600f, -0.01642364f, -0.03612920f, 0.01171340f, -0.00855986f, -0.01023679f, 
    0.01760459f, -0.03421029f, 0.02259605f, -0.00721641f, 0.01332410f, -0.00785420f, -0.00559051f, -0.00371998f, 
    -0.03445097f, 0.01764023f, -0.04014818f, -0.04003469f, 0.03222910f, 0.02604204f, -0.00751185f, -0.01344051f, 
    0.39276436f, -0.16208065f, -0.20709775f, 0.41008797f, -0.00683613f, -0.09468602f, 0.11496260f, 0.14073920f, 
    -0.14345545f, 0.13559508f, 0.11635090f, -0.00678645f, -0.02846184f, -0.09503751f, -0.13744645f, 0.14068000f, 
    -0.02500276f, 0.02735209f, -0.05068354f, -0.00538687f, -0.67017204f, -0.02821574f, -0.49690801f, 0.31876487f, 
    -0.31100231f, -0.06698432f, 0.03269652f, 0.00719745f, 0.08710678f, -0.01183709f, 0.08255839f, -0.06690042f, 
    -0.03443631f, -0.00241973f, 0.09107769f, -0.01419744f, -0.15703699f, 0.12803060f, -0.07124037f, -0.07655868f, 
    -0.09817540f, -0.19463910f, -0.03101438f, -0.00806957f, -0.09933654f, -0.03720577f, 0.01803404f, -0.12209181f, 
    0.07828771f, 0.07333969f, -0.02558185f, -0.01652833f, 0.03168345f, 0.06959634f, 0.02661354f, 0.00158588f, 
    0.06685919f, -0.04403517f, 0.18187857f, 0.18200390f, 0.08380017f, -0.07060239f, 0.14421603f, 0.02291601f, 
    -0.18078247f, 0.03458116f, -0.01048085f, 0.01351197f, 0.09628531f, 0.13507986f, 0.12892814f, -0.01235229f, 
    -0.06070603f, -0.03653685f, -0.00956512f, 0.02452131f, -0.08281208f, -0.04776961f, 0.05001770f, 0.04772554f, 
    -0.00265279f, 0.18287604f, 0.46229091f, 0.10393251f, 0.08111362f, -0.02735382f, -0.03286386f, 0.20275733f, 
    -0.01333559f, 0.03931448f, 0.07078265f, 0.10755260f, -0.00945878f, -0.12225910f, -0.00668366f, -0.02697181f, 
    -0.04726895f, -0.02245236f, 0.15324634f, -0.16581181f, 0.34931973f, -0.41495633f, -0.05295702f, 0.04786896f, 
    -0.01262831f, 0.01023911f, 0.06487642f, 0.12945423f, -0.00704517f, -0.03633233f, -0.05452128f, -0.11580443f, 
    0.02462685f, 0.01179627f, -0.01489418f, 0.05127429f, -0.03022692f, -0.07685687f, -0.09386469f, 0.08402129f, 
    0.15763864f, 0.00508527f, 0.36579227f, 0.06954599f, 0.02415502f, -0.02307162f, -0.03586728f, 0.06034813f, 
    -0.13489561f, 0.02497208f, 0.08066564f, 0.07089023f, -0.03316625f, -0.14916684f, -0.06420489f, -0.05903448f, 
    -0.05297491f, -0.17419448f, 0.23866962f, -0.02970597f, 0.11094779f, 0.09102738f, 0.11905699f, 0.14402959f, 
    -0.22853692f, -0.02139394f, 0.04616243f, -0.02035470f, -0.13624723f, 0.10013652f, -0.04267302f, 0.00665907f, 
    -0.08792344f, 0.02747720f, -0.01518131f, 0.01121797f, -0.04981778f, -0.09017109f, 0.08375472f, 0.00229290f, 
    -0.15567492f, 0.09630387f, 0.17863172f, 0.39695278f, -0.32403854f, 0.07998069f, -0.09077401f, 0.04228415f, 
    -0.12064333f, 0.02719865f, -0.05113872f, 0.08347514f, -0.20190097f, 0.08715672f, 0.11394550f, -0.06983142f, 
    -0.02560233f, 0.00833490f, -0.07937200f, 0.08831570f, -0.30791083f, -0.08983149f, -0.08132391f, -0.23392065f, 
    -0.13450572f, -0.07665724f, -0.11503594f, -0.19143042f, 0.14854564f, 0.02880294f, -0.11951558f, 0.05241153f, 
    -0.03153467f, 0.12650445f, -0.02154643f, -0.14536154f, -0.04410902f, 0.12472333f, -0.03112612f, 0.16538939f, 
    -0.11437439f, 0.19443721f, 0.22724734f, 0.28066826f, -0.19651091f, -0.03784653f, -0.14715758f, -0.02787359f, 
    0.04265252f, 0.08389264f, 0.05445470f, 0.01171484f, 0.01212283f, -0.05083254f, 0.01799852f, -0.12993227f, 
    0.04257387f, -0.03298456f, 0.00877529f, -0.10694576f, -0.04064613f, 0.75719088f, -0.86415243f, 0.42799515f, 
    0.05027014f, 0.06417038f, -0.06601815f, 0.53775126f, 0.00872036f, 0.12937336f, 0.05015066f, 0.11809363f, 
    0.09545393f, -0.28569102f, -0.07454374f, 0.11399921f, 0.07524641f, 0.28044334f, -0.03826295f, -0.08188785f, 
    0.00792192f, 0.05611419f, 0.28785491f, -0.07603908f, -0.13292126f, 0.08194655f, -0.05132066f, -0.07658853f, 
    0.05533762f, 0.03831165f, 0.04473191f, 0.04662368f, -0.03314779f, -0.04439733f, -0.01549981f, 0.09353785f, 
    -0.00509764f, -0.04654990f, -0.02144116f, -0.03025415f, -0.21013586f, -0.05636119f, -0.25278398f, 0.05963925f, 
    0.06817189f, 0.20565878f, 0.05368862f, 0.20189410f, -0.07488109f, 0.04653453f, -0.06919634f, 0.08437023f, 
    0.03054403f, -0.03065867f, 0.07650241f, 0.03630364f, 0.00779142f, 0.09987056f, -0.17207642f, -0.01665531f, 
    0.36882269f, -0.03695335f, -0.51128507f, 0.35714862f, 0.09692331f, 0.14602210f, 0.20762673f, 0.21131612f, 
    0.04676675f, 0.04018025f, 0.02885464f, -0.04010054f, -0.06002996f, -0.17043580f, 0.00075703f, -0.04609048f, 
    0.00663960f, 0.04737447f, -0.01761917f, 0.00193951f, -0.16681525f, -0.13434264f, 0.07862227f, 0.03365706f, 
    -0.14286426f, -0.04577745f, 0.00417721f, 0.04656107f, -0.05206794f, -0.14792249f, -0.13544749f, -0.02073567f, 
    0.04180288f, 0.04604076f, 0.08330037f, 0.06407942f, 0.19215076f, 0.06818204f, 0.13983515f, 0.14530125f, 
    -0.06035889f, -0.02803911f, 0.19769323f, 0.23034810f, -0.13094610f, -0.04061161f, 0.07816254f, 0.17998244f, 
    -0.01422728f, 0.06705247f, 0.04568167f, 0.04768320f, -0.07873955f, 0.12927373f, 0.05607133f, 0.08123752f, 
    -0.00578477f, -0.08784328f, 0.18634948f, 0.05965325f, -0.32933825f, -0.10202550f, -0.20717119f, 0.13101226f, 
    -0.18141571f, -0.14072740f, 0.01862260f, 0.00822493f, -0.07978064f, -0.01791011f, -0.04199709f, -0.02223049f, 
    -0.04968743f, 0.13944666f, 0.03954836f, -0.16992491f, 0.15458894f, 0.10103472f, 0.07964624f, -0.03278850f, 
    -0.10994874f, -0.25606358f, 0.22302964f, 0.08865900f, -0.21850052f, 0.08288361f, 0.07044194f, 0.11633258f, 
    -0.25991562f, -0.03233221f, 0.02072147f, 0.07261964f, -0.06927095f, 0.14665788f, 0.08811392f, 0.07469097f, 
    0.00234921f, 0.09672459f, 0.08956169f, 0.22616503f, 0.27477980f, 0.29859388f, -0.62241423f, 0.39181408f, 
    0.06426954f, 0.12317101f, 0.11243167f, 0.12705877f, 0.06453440f, 0.11622738f, 0.03292722f, 0.00834198f, 
    -0.02571426f, -0.06348296f, 0.07687550f, -0.03806726f, 0.05577822f, 0.08346606f, 0.06998037f, 0.07182959f, 
    -0.25253463f, 0.05493777f, -0.15406947f, -0.27691421f, -0.02009314f, -0.04231274f, -0.04761311f, -0.04391276f, 
    0.08843459f, 0.04299039f, 0.09433004f, 0.20109023f, -0.04982856f, 0.08102611f, 0.07285968f, -0.15487713f, 
    0.04902982f, 0.12950870f, 0.05921537f, 0.20772742f, -0.03384928f, -0.35452586f, 0.15689471f, -0.00008987f, 
    0.28634548f, 0.00305606f, 0.09219923f, 0.01935354f, -0.06747653f, -0.00083707f, 0.19635184f, -0.04952924f, 
    0.14760186f, -0.06092797f, -0.19281693f, 0.00798261f, 0.09589717f, -0.20098853f, -0.05359247f, -0.00120478f, 
    0.13602033f, -0.04853154f, -0.28125447f, 0.02209654f, 0.06236509f, -0.08271582f, 0.09639972f, 0.10099460f, 
    -0.02865936f, -0.05831453f, 0.01183062f, -0.07863723f, 0.11003215f, 0.02203411f, -0.11589772f, 0.01817084f, 
    -0.04300142f, 0.01414190f, -0.07494421f, 0.01433920f, -0.09097239f, 0.09048808f, -0.01825763f, 0.03714501f, 
    -0.21519424f, -0.11777098f, -0.07447112f, -0.01306106f, 0.09893136f, 0.28053761f, 0.13254325f, -0.07036277f, 
    -0.01508140f, 0.00757344f, -0.04003296f, -0.19040161f, -0.03079829f, 0.04987699f, 0.00279166f, -0.01393380f, 
    0.05504709f, 0.11152743f, -0.11819001f, 0.09437089f, 0.08038895f, -0.03734246f, 0.08792032f, 0.02591833f, 
    0.02639502f, -0.02823414f, -0.00274824f, 0.01259667f, -0.01387929f, -0.05424231f, 0.07361098f, -0.10562038f, 
    -0.00442272f, -0.04073576f, 0.05898734f, 0.18987802f, 0.14015999f, 0.19773607f, 0.12261341f, 0.31935281f, 
    0.04568863f, 0.05038534f, 0.03581554f, 0.09094360f, -0.00884638f, 0.02697095f, 0.07114428f, 0.11127605f, 
    -0.01163425f, 0.02901705f, -0.10918651f, 0.04556189f, 0.10902330f, -0.05991791f, 0.09690245f, -0.01329259f, 
    0.24140729f, -0.04082884f, -0.41912064f, 0.23365876f, 0.01904299f, -0.02648136f, 0.08297588f, 0.09062590f, 
    -0.11708903f, 0.16764887f, -0.03313192f, 0.00573703f, 0.06402933f, -0.06850279f, -0.06357411f, 0.05390696f, 
    0.02621341f, -0.02053910f, -0.03307619f, -0.04878661f, -0.16334650f, -0.17645021f, -0.21091279f, -0.05630217f, 
    -0.26053569f, -0.09150414f, 0.21010020f, -0.18591766f, -0.14371467f, 0.25998968f, -0.02987635f, -0.07006687f, 
    -0.04853060f, 0.05361370f, -0.00162432f, -0.10861099f, -0.00940658f, 0.11086773f, -0.00053123f, 0.02810939f, 
    -0.11040038f, -0.14813301f, 0.46606725f, -0.21833627f, 0.16564126f, 0.03176053f, 0.09200341f, -0.00378678f, 
    0.17925322f, 0.04179782f, 0.02482286f, -0.09955976f, -0.07043377f, 0.05086790f, 0.04943362f, -0.03678140f, 
    -0.13960297f, 0.00074346f, -0.16277404f, -0.00596248f, -0.02951703f, 0.04295994f, -0.13770938f, -0.08331122f, 
    -0.07941081f, 0.02652151f, 0.06127443f, -0.01762507f, -0.03722949f, 0.03663166f, 0.10157546f, 0.01855811f, 
    0.10802851f, 0.15908061f, 0.11435009f, 0.15144303f, -0.02815381f, -0.00136174f, -0.06367811f, 0.02653195f, 
    -0.02767118f, 0.24946187f, 0.23244034f, 0.05155378f, 0.08324907f, 0.05744656f, -0.09576555f, -0.02720892f, 
    -0.06679454f, -0.01297510f, 0.04579345f, -0.02029022f, -0.04891665f, -0.03200538f, -0.05993226f, 0.05224974f, 
    0.10777635f, 0.00073190f, -0.13777567f, -0.09415324f, 0.42575413f, 0.07331527f, -0.27887440f, -0.08716106f, 
    -0.11269805f, -0.02141518f, -0.02333291f, 0.04578689f, -0.05812501f, 0.17103669f, -0.02088044f, 0.02251760f, 
    0.08764097f, -0.13233469f, 0.07222034f, 0.03941899f, -0.06725141f, -0.03669301f, -0.03930220f, 0.05533838f, 
    -0.02641647f, 0.03393851f, -0.01951355f, 0.01084139f, 0.00027898f, 0.00327547f, -0.01051519f, -0.00508669f, 
    -0.00601807f, -0.03884182f, -0.00610127f, 0.01239530f, -0.01316116f, -0.03323062f, 0.00462592f, -0.01863861f, 
    -0.03107729f, 0.02242343f, 0.00343266f, -0.04281556f, 0.02182027f, -0.03528774f, -0.00025899f, 0.00650126f, 
    -0.03412921f, -0.02280191f, -0.02495337f, -0.00247136f, 0.02852614f, -0.02322928f, -0.02136811f, -0.03022439f, 
    0.02769850f, -0.02289562f, 0.00013820f, -0.00466818f, -0.00974378f, 0.03679300f, -0.00500176f, -0.03269092f, 
    -0.04618040f, 0.01090873f, -0.01193299f, -0.04504107f, -0.01655718f, 0.02929945f, 0.01940414f, -0.00358935f, 
    -0.01500436f, 0.00456322f, -0.01303480f, -0.01965252f, 0.02627083f, -0.00319912f, 0.00247710f, -0.00678154f, 
    0.02170707f, 0.01483348f, 0.02783529f, -0.00333728f, 0.02374320f, -0.00212794f, 0.01473958f, -0.00040162f, 
    0.02237233f, -0.00968237f, 0.01464509f, -0.02129442f, 0.02311848f, -0.00808612f, -0.03689523f, -0.01813574f, 
    -0.02433051f, 0.00547554f, 0.00181208f, -0.01971671f, -0.00088178f, -0.00637391f, -0.00370249f, 0.02266949f, 
    -0.04446873f, -0.03064927f, -0.01677813f, 0.00243179f, -0.04131547f, 0.01912787f, 0.00635839f, -0.04273180f, 
    -0.00709129f, -0.02270027f, 0.01731583f, 0.00157247f, -0.02405746f, -0.02800658f, -0.04166368f, 0.01867269f, 
    0.00006715f, 0.00611494f, -0.01428406f, -0.01883722f, -0.00519012f, 0.01613152f, -0.01860588f, 0.00275112f, 
    -0.03278476f, -0.02837363f, -0.01137952f, -0.03827273f, -0.04182217f, 0.02132504f, -0.01728808f, 0.02106651f, 
    -0.04304867f, 0.02080893f, 0.00737580f, 0.00018714f, -0.02818635f, -0.04411698f, 0.01679386f, -0.03841810f, 
    -0.03111735f, 0.02737825f, -0.02041318f, -0.03692560f, 0.01893049f, -0.02095895f, 0.01700463f, 0.00226673f, 
    0.01315093f, 0.00647251f, -0.02522771f, -0.00274680f, 0.01999380f, -0.03200854f, -0.00120463f, -0.01052421f, 
    -0.00402381f, -0.00164855f, -0.01075853f, 0.00748246f, -0.00899077f, -0.01672664f, 0.01748736f, -0.03592929f, 
    0.00027872f, 0.00381228f, 0.00619486f, 0.02711244f, 0.02627662f, -0.01211873f, 0.00017055f, 0.00884343f, 
    0.00759317f, -0.03659779f, -0.02466776f, -0.01351666f, -0.02220017f, 0.01115040f, 0.02083601f, 0.02028069f, 
    0.01333246f, 0.00882041f, 0.02388224f, -0.00722711f, 0.03653448f, -0.01472796f, -0.01656796f, 0.00447359f, 
    0.03130461f, -0.00410755f, 0.00571772f, -0.02631898f, -0.04234434f, -0.03198566f, -0.02118148f, 0.01216452f, 
    -0.02900635f, 0.02834856f, -0.02746509f, -0.04683033f, -0.04408007f, 0.01339258f, 0.00033818f, -0.01937747f, 
    -0.02455152f, -0.04624823f, 0.01868678f, 0.02757614f, -0.01689899f, -0.02278853f, 0.02364061f, -0.00804037f, 
    -0.02033118f, -0.02185417f, -0.04014703f, 0.01257061f, -0.02347567f, -0.04445793f, -0.02218925f, -0.01315723f, 
    0.01128901f, -0.00740146f, -0.02918266f, 0.02246124f, 0.00796451f, -0.03754356f, -0.01579707f, 0.02118694f, 
    -0.00801252f, 0.02213177f, 0.02406919f, -0.02459704f, -0.03629401f, 0.00185999f, 0.02293108f, -0.00684886f, 
    -0.01111327f, -0.03122293f, 0.01911150f, 0.01199642f, -0.02777361f, 0.03045762f, 0.04077597f, -0.01049586f, 
    0.01825988f, 0.01841129f, -0.02201002f, 0.02211848f, -0.01549808f, 0.03015693f, 0.02361402f, -0.00055621f, 
    -0.01234878f, -0.01028880f, 0.03117656f, 0.01817641f, -0.01402741f, -0.01841327f, -0.03076546f, 0.03614655f, 
    0.03643559f, -0.01962948f, -0.03333820f, -0.02110824f, -0.00837106f, -0.01505558f, 0.02279911f, -0.00741623f, 
    -0.03785125f, -0.00173799f, -0.00142059f, 0.00455532f, -0.01659805f, 0.01693060f, -0.03333617f, -0.04631178f, 
    0.02582292f, -0.03047582f, -0.03069463f, -0.04380523f, 0.01838165f, 0.02628933f, -0.03905288f, -0.01844366f, 
    -0.00184124f, -0.03842697f, -0.00731371f, 0.04325536f, 0.02036183f, -0.01158778f, -0.00389037f, 0.02349543f, 
    -0.00304050f, 0.00715936f, -0.02666507f, -0.03484320f, -0.02070652f, -0.02412832f, 0.01531692f, -0.02083854f, 
    -0.01837364f, 0.02488917f, 0.02743216f, -0.02845406f, 0.02267877f, 0.01718833f, 0.01208645f, -0.03892230f, 
    0.02528318f, -0.01341087f, 0.00399338f, -0.01951535f, -0.03110443f, 0.01383272f, -0.02199040f, 0.01468860f, 
    0.00515233f, 0.02113430f, -0.00359484f, -0.02744937f, -0.03169699f, -0.01477226f, 0.00025189f, -0.02590471f, 
    -0.01553742f, 0.01688892f, -0.03176050f, 0.01463943f, 0.02599281f, -0.00569163f, 0.02123320f, -0.00128276f, 
    0.00310588f, -0.00111746f, 0.01619349f, -0.01105027f, 0.02583351f, 0.02207051f, -0.03413816f, 0.03171629f, 
    -0.01922678f, -0.00512163f, -0.00838683f, -0.03785214f, 0.01531364f, 0.02786636f, -0.03034647f, -0.03177375f, 
    0.00563016f, 0.02510284f, -0.02373914f, -0.02303359f, 0.01505545f, 0.00222016f, 0.02108401f, -0.00698172f, 
    -0.02564544f, 0.03422436f, 0.02861353f, -0.02498170f, 0.01843875f, -0.01597890f, 0.01904474f, -0.02010000f, 
    0.03436316f, 0.01825156f, 0.02742475f, -0.00715562f, -0.03675922f, 0.02166040f, 0.02855451f, 0.02234633f, 
    0.02627686f, -0.00599697f, -0.04254867f, 0.02444333f, -0.01077817f, -0.01085268f, 0.01462558f, 0.01583596f, 
    0.03061843f, -0.00555489f, -0.01318586f, -0.04485362f, 0.00377403f, -0.01406528f, -0.03449319f, 0.02069097f, 
    0.02397214f, 0.02983924f, -0.02618708f, 0.03277295f, 0.00429330f, -0.00162461f, -0.01904701f, 0.00754119f, 
    -0.01922142f, -0.01190124f, -0.00820132f, -0.00908270f, -0.01058713f, -0.01885521f, -0.02307623f, 0.00152715f, 
    0.00056654f, -0.00446676f, 0.01868426f, -0.02394419f, -0.01852110f, 0.03142628f, -0.03091744f, -0.00685068f, 
    0.02258639f, 0.03160229f, -0.00525686f, -0.01196412f, 0.03097181f, -0.01750129f, -0.00519470f, -0.00100319f, 
    -0.02204825f, -0.01371517f, 0.01078355f, 0.01613902f, 0.02768457f, 0.03382288f, 0.00366091f, -0.03751998f, 
    -0.04111316f, 0.02038428f, 0.01807043f, -0.03636813f, 0.02257423f, 0.04134919f, -0.02020506f, 0.02007329f, 
    -0.04432026f, -0.03957361f, 0.02153679f, -0.04033627f, -0.04506430f, -0.00379091f, 0.01508994f, 0.01632699f, 
    -0.04259498f, 0.02118606f, 0.02107057f, 0.01785505f, -0.01011483f, 0.00674863f, -0.00096947f, 0.00709522f, 
    0.02113259f, -0.03333044f, -0.04058167f, 0.01197503f, -0.04406937f, 0.03319568f, 0.01909267f, 0.02171561f, 
    0.02159127f, -0.03969924f, -0.00782103f, -0.03762188f, -0.01706405f, 0.02667315f, -0.01576121f, -0.02586767f, 
    -0.04364080f, -0.03703590f, 0.01047897f, 0.01111321f, -0.01252271f, -0.01580306f, -0.00009176f, -0.02021722f, 
    0.02305743f, 0.00112957f, 0.02638991f, -0.03408175f, 0.00064425f, 0.02934123f, 0.00253454f, -0.04085006f, 
    0.01688025f, 0.01393211f, 0.00168679f, -0.03520152f, -0.03383363f, 0.02154486f, -0.01753438f, -0.00677829f, 
    0.02782212f, -0.03856270f, -0.03370936f, -0.03870375f, 0.01226059f, 0.02622931f, 0.00547315f, -0.03508222f, 
    0.01584852f, -0.01926042f, 0.00698866f, -0.00107707f, -0.01990225f, -0.02126964f, -0.04370698f, -0.03072686f, 
    0.01343888f, -0.00221606f, 0.02342435f, -0.02365526f, -0.03927751f, -0.04194876f, 0.01823813f, -0.03715429f, 
    0.00838505f, 0.02502476f, -0.04356788f, 0.01117738f, -0.01890284f, -0.02695335f, 0.01894042f, -0.02219259f, 
    0.00751853f, -0.01397357f, 0.01753169f, -0.04089204f, -0.00616413f, 0.01954257f, -0.00155124f, 0.02782173f, 
    -0.01295405f, 0.00680998f, 0.00275584f, 0.00808776f, -0.02461573f, 0.01777044f, -0.02286721f, -0.02167122f, 
    0.01007162f, -0.02342596f, -0.00880808f, 0.01418151f, 0.03175691f, -0.04099285f, -0.04458781f, -0.04463817f, 
    0.02656866f, -0.00955417f, 0.03117852f, -0.00589338f, -0.01712878f, -0.01601462f, -0.04144665f, -0.04335086f, 
    0.03304366f, 0.02457252f, 0.00885086f, -0.01017617f, -0.03605280f, -0.02596333f, -0.04234786f, -0.02094235f, 
    0.01310093f, -0.00552572f, -0.00944502f, -0.02240982f, 0.00731661f, -0.01911176f, 0.00191900f, 0.00754044f, 
    -0.00666359f, 0.03062921f, 0.01011637f, 0.00280462f, 0.01502914f, -0.02214450f, -0.03566904f, 0.02586743f, 
    0.02642627f, 0.00732937f, 0.00869893f, 0.03027132f, 0.01804819f, 0.00047639f, -0.02153431f, -0.04097136f, 
    -0.01836963f, -0.02255965f, -0.01372119f, -0.02693236f, 0.02338335f, -0.04054788f, 0.00935140f, -0.00055727f, 
    0.03728699f, 0.02606960f, -0.02148443f, 0.00329725f, -0.02869446f, 0.02235921f, -0.01038447f, -0.01220764f, 
    -0.01924188f, -0.02361129f, 0.00780319f, -0.00838761f, 0.00909174f, 0.01882920f, 0.02953685f, -0.01615504f, 
    0.02820280f, 0.02061927f, -0.03781131f, 0.02488854f, -0.01028841f, 0.00433096f, 0.01933581f, 0.01620885f, 
    0.01368812f, 0.00192148f, -0.01159664f, 0.01229499f, -0.00605429f, 0.04458682f, -0.03307048f, 0.01680630f, 
    -0.00053905f, -0.02374820f, -0.01441525f, 0.01236660f, 0.00856792f, -0.01116279f, -0.02712714f, -0.02493512f, 
    0.00478476f, -0.00917561f, -0.02628334f, 0.01575441f, -0.00553988f, -0.01370342f, 0.01963197f, -0.01915336f, 
    -0.02463748f, 0.01201383f, -0.03148587f, -0.01867996f, -0.00580924f, -0.03687975f, -0.02623419f, 0.03133196f, 
    -0.01119306f, -0.00211142f, 0.02042212f, -0.03505859f, -0.03839544f, -0.02849770f, 0.01819267f, 0.02362001f, 
    -0.00914339f, -0.00289287f, -0.02745242f, -0.01247685f, 0.02755371f, -0.01553218f, 0.03754649f, 0.03344638f, 
    -0.01556483f, -0.02658402f, -0.01716226f, 0.02187514f, -0.02815814f, -0.03394059f, -0.00639440f, -0.00456209f, 
    -0.01721587f, 0.03000183f, -0.03224569f, -0.03586422f, -0.02925065f, 0.01626123f, 0.02089547f, -0.03266947f, 
    -0.04355371f, 0.01951572f, 0.01127573f, 0.00111007f, -0.01665278f, 0.01396931f, -0.02661887f, 0.02106342f, 
    0.02475297f, -0.03637061f, 0.03124248f, -0.00232677f, -0.01124699f, -0.03923056f, 0.00380767f, -0.00764281f, 
    -0.04328939f, 0.01012244f, -0.01741347f, -0.04187001f, -0.04171180f, -0.02025252f, -0.01690722f, 0.01501559f, 
    0.02118034f, -0.04368764f, -0.01094536f, 0.01531071f, 0.02937283f, -0.01272631f, 0.00836991f, -0.03050086f, 
    -0.01747530f, 0.01613567f, -0.03773524f, -0.00984166f, -0.00053913f, 0.01159475f, 0.01689071f, -0.03271582f, 
    0.02480347f, 0.01652560f, -0.00220651f, -0.04035139f, -0.00518907f, -0.01712226f, -0.00767981f, -0.03377272f, 
    -0.01333776f, 0.00731705f, 0.01857816f, 0.02607748f, 0.03150610f, -0.02555607f, -0.00819433f, 0.01059631f, 
    -0.04099913f, 0.01245451f, 0.03123977f, 0.02838017f, -0.01304572f, -0.00193475f, -0.02382709f, -0.04120507f, 
    0.02085520f, -0.02589926f, 0.02763258f, -0.01112405f, -0.00966569f, 0.02639084f, 0.01561110f, 0.00563341f, 
    0.02667832f, -0.03373171f, 0.01925527f, 0.02738966f, -0.03726038f, -0.03094465f, -0.02257819f, 0.02141968f, 
    0.00416832f, -0.02798646f, -0.00898032f, -0.02639781f, 0.00106162f, 0.01385172f, -0.02629970f, 0.00425484f, 
    0.00747759f, -0.00835283f, -0.03443151f, -0.02718559f, 0.02130970f, 0.02091165f, 0.02304468f, -0.02011568f, 
    -0.03517856f, -0.02718284f, -0.04225612f, -0.02651721f, 0.02551896f, -0.03941514f, -0.00380517f, -0.02368530f, 
    -0.02665389f, -0.00543805f, 0.00311215f, 0.02332362f, 0.03041627f, 0.03011556f, -0.03102011f, -0.01231584f, 
    -0.02868987f, -0.04242283f, 0.02732219f, -0.02165095f, 0.03258036f, -0.00424052f, -0.04004459f, -0.03995906f, 
    -0.04468877f, -0.04476813f, 0.03054371f, 0.01300918f, -0.02952277f, -0.03716872f, -0.03015434f, -0.03216779f, 
    0.00245309f, -0.01605172f, 0.03054972f, -0.03513244f, -0.04325024f, 0.02793654f, 0.01917054f, 0.00883906f, 
    0.03345333f, -0.00735909f, -0.02658210f, 0.01216323f, 0.03751869f, -0.00603202f, -0.02624813f, -0.01929549f, 
    0.00628153f, 0.01014496f, 0.00031101f, 0.01924879f, 0.03398030f, -0.00778803f, -0.02050196f, -0.03707189f, 
    -0.02851353f, 0.02823560f, -0.00565452f, 0.02580019f, -0.00997424f, 0.02048845f, 0.01286536f, -0.01198755f, 
    0.03252020f, -0.02354454f, -0.03571152f, -0.04141440f, -0.03976175f, 0.03253710f, -0.01769770f, -0.00019512f, 
    -0.03553568f, 0.03102482f, 0.02492336f, -0.00320152f, 0.03176460f, 0.01801803f, -0.02848012f, 0.02458864f, 
    0.02770852f, -0.02581865f, -0.04455432f, -0.03800424f, 0.01694977f, 0.02708472f, -0.03351256f, -0.02011207f, 
    -0.02499426f, -0.01292427f, -0.01445327f, -0.03570851f, -0.04395706f, 0.00866998f, -0.01460153f, 0.02162286f, 
    -0.02185641f, 0.00672808f, 0.01904735f, -0.00081094f, 0.01877287f, -0.03316154f, 0.01046670f, -0.01043015f, 
    -0.03462945f, -0.03605369f, -0.01424641f, 0.00816537f, -0.02578628f, -0.00421731f, 0.00376676f, -0.01550065f, 
    -0.00598071f, 0.01520302f, -0.02116358f, -0.01454298f, -0.00589705f, 0.00670844f, -0.02597862f, 0.00244998f, 
    -0.03760554f, -0.02278464f, 0.02591137f, -0.04068242f, -0.03389471f, -0.03841589f, -0.01642906f, -0.02136488f, 
    -0.04050941f, 0.00408281f, 0.01068579f, -0.00631097f, -0.01567143f, -0.03604465f, -0.03441958f, 0.03101102f, 
    0.01230882f, -0.03470984f, 0.01967165f, -0.03699686f, -0.02508189f, -0.02361936f, -0.01204603f, -0.04402502f, 
    -0.02027481f, -0.00798668f, 0.01448097f, -0.02558750f, 0.01235085f, 0.00019868f, -0.02156731f, -0.00161669f, 
    0.02866217f, 0.02975059f, -0.02736303f, -0.01886929f, -0.03948568f, 0.01895173f, -0.00903174f, -0.04251280f, 
    0.02842264f, 0.02115403f, -0.03276941f, 0.03186997f, -0.02887850f, -0.03607953f, 0.03376421f, -0.02374516f, 
    0.00367677f, 0.02104431f, 0.02154178f, 0.02120707f, 0.02979436f, 0.02271446f, 0.01564365f, 0.01538854f, 
    -0.03037682f, 0.01877212f, -0.04082637f, -0.01428284f, 0.00780841f, 0.01211006f, -0.02830881f, 0.02663775f, 
    -0.02691708f, -0.01741472f, -0.03510029f, 0.01072638f, 0.01830693f, -0.03881006f, -0.03142850f, -0.03879541f, 
    0.00213295f, -0.02746230f, -0.00058060f, -0.01598967f, -0.03237960f, 0.00721522f, -0.02014718f, 0.02511062f, 
    0.01241011f, -0.03846905f, 0.02498608f, -0.01356058f, -0.01894571f, -0.01240203f, -0.03640879f, -0.00710826f, 
    -0.01095038f, 0.00448687f, 0.00204651f, 0.03115494f, -0.02363518f, -0.04108670f, 0.02223095f, 0.02984961f, 
    0.00455863f, -0.00511015f, -0.02755190f, 0.01010861f, -0.03665746f, -0.03167967f, 0.00879859f, -0.00579809f, 
    0.02503776f, 0.00151419f, 0.00065127f, -0.00196387f, 0.02516204f, -0.00791271f, -0.01156040f, -0.00076567f, 
    0.00244665f, -0.01857142f, -0.01019374f, -0.01792082f, 0.00825660f, -0.02653956f, -0.01195229f, -0.00677060f, 
    0.03054702f, 0.02432504f, -0.01066109f, -0.01723755f, 0.03119007f, 0.03098686f, 0.01681256f, 0.01325686f, 
    -0.03549965f, 0.02786618f, -0.02326228f, -0.01236626f, -0.04415880f, -0.03713711f, -0.03047482f, -0.02253461f, 
    -0.01934518f, -0.04071955f, -0.04425519f, -0.00101966f, -0.02299965f, -0.03218167f, -0.02222339f, -0.01463350f, 
    -0.04166149f, -0.02163880f, 0.01639823f, 0.01796981f, -0.03350985f, 0.00500920f, -0.01511423f, 0.00744611f, 
    0.00678265f, -0.04024673f, -0.01999021f, 0.02744566f, 0.03053928f, -0.02195835f, 0.02923544f, 0.01835156f, 
    -0.00595334f, -0.01465130f, 0.00310856f, -0.02113056f, -0.00702444f, -0.02365210f, 0.02175464f, 0.02249427f, 
    0.03234351f, 0.00786103f, -0.02345897f, -0.01415411f, -0.00933192f, -0.00731736f, -0.04134851f, 0.00167312f, 
    -0.01007010f, -0.01456134f, -0.01802848f, 0.01892406f, -0.02903835f, 0.02323121f, 0.02174533f, -0.03224769f, 
    0.01700745f, 0.03244974f, 0.02918254f, 0.00351272f, 0.03303032f, -0.03044879f, -0.02082864f, -0.03736104f, 
    -0.02342650f, -0.00964153f, -0.03928088f, -0.03246382f, -0.02024376f, 0.02712262f, -0.03241845f, -0.01897738f, 
    -0.02055763f, 0.03139243f, -0.03887130f, -0.01156451f, -0.04223514f, -0.00602707f, 0.00291004f, -0.00601077f, 
    -0.00217786f, 0.01337470f, 0.00639423f, 0.01778221f, -0.04211935f, -0.03842896f, -0.03493256f, -0.01545781f, 
    -0.00509783f, 0.01197231f, -0.01445655f, -0.04182628f, -0.02485354f, 0.01677397f, -0.03630805f, 0.03266717f, 
    0.01949966f, -0.01612832f, -0.03413886f, -0.02240708f, -0.00238165f, 0.01072189f, 0.02507311f, 0.01284918f, 
    0.02579302f, 0.02268111f, -0.00454294f, 0.01004634f, 0.02036003f, 0.02355076f, -0.01961892f, 0.01614297f, 
    -0.03165340f, 0.03376040f, 0.02955555f, 0.01248410f, 0.00704133f, 0.00816659f, -0.01195546f, -0.02817173f, 
    -0.03655280f, 0.03038294f, 0.01891032f, -0.00923299f, -0.01566718f, -0.03207229f, 0.01616209f, -0.02780686f, 
    0.02850428f, -0.00870302f, 0.03157155f, -0.02280232f, -0.01204522f, -0.01402656f, -0.04411529f, 0.02714540f, 
    -0.02929024f, 0.01265041f, 0.00571842f, 0.00514706f, -0.02373234f, 0.03124077f, -0.01816577f, 0.00269201f, 
    0.00534774f, -0.03374332f, -0.03504492f, 0.00361327f, 0.01963552f, -0.00511766f, -0.00858958f, -0.02908247f, 
    0.00124636f, -0.01095295f, -0.03354945f, -0.03170290f, -0.03930931f, 0.03001315f, -0.02730469f, 0.01104292f, 
    -0.04025232f, -0.03475057f, -0.01998627f, 0.03079844f, -0.02523879f, -0.03446484f, -0.00534761f, 0.02528200f, 
    0.00363231f, 0.00475955f, 0.01664824f, -0.03543438f, -0.00966342f, 0.02267984f, -0.03391267f, 0.03904806f, 
    0.02945567f, -0.04345779f, -0.01214200f, 0.00553666f, -0.02836530f, -0.02829187f, -0.00004551f, -0.03900089f, 
    -0.03247018f, 0.00012929f, -0.00908363f, 0.00095667f, -0.00510563f, -0.00588299f, -0.00404783f, -0.02109874f, 
    0.03142917f, 0.02761442f, -0.01999303f, 0.03147555f, -0.03766469f, -0.02730969f, -0.04205796f, 0.03326144f, 
    -0.01673471f, -0.01718550f, -0.01414706f, -0.00922635f, -0.00372698f, -0.01950134f, 0.00488286f, 0.00084825f, 
    -0.03650631f, -0.02066944f, 0.01414551f, -0.04104364f, 0.01814247f, 0.02284368f, 0.02669868f, -0.04408244f, 
    -0.01181776f, -0.03627168f, -0.00497795f, -0.00783814f, 0.01511839f, -0.03362714f, 0.03614044f, 0.02887118f, 
    -0.00630914f, -0.03861153f, -0.01014312f, 0.03886115f, 0.02093850f, -0.03069509f, -0.04123262f, 0.01434495f, 
    0.03105235f, -0.01411049f, -0.01928408f, -0.03216577f, -0.00995115f, -0.01763596f, -0.01184223f, -0.00856445f, 
    -0.02315084f, -0.01012199f, 0.03882263f, -0.03229577f, -0.00273825f, -0.02692987f, -0.03779944f, -0.00883102f, 
    0.03298112f, 0.02941087f, -0.00010479f, -0.04356119f, -0.01513627f, -0.03558580f, -0.01634729f, -0.02282917f, 
    -0.01559773f, 0.00678515f, 0.00917532f, 0.02402316f, -0.01427958f, -0.02115656f, -0.03289675f, -0.02482791f, 
    0.02797535f, 0.00260036f, 0.01281068f, 0.01828076f, 0.01019935f, -0.00543817f, 0.01736502f, 0.01439528f, 
    0.01929425f, -0.04502566f, -0.01843623f, -0.03755142f, 0.02331817f, -0.05437024f, -0.05901692f, 0.00923685f, 
    -0.04581409f, -0.04324736f, 0.00811547f, -0.02113991f, -0.06215990f, -0.04214359f, -0.01817479f, -0.04406305f, 
    0.00236981f, -0.02380144f, -0.03389591f, 0.01820076f, -0.01118265f, -0.02751832f, -0.06206811f, -0.02404396f, 
    -0.00723999f, 0.00001234f, -0.01874125f, 0.00702362f, -0.06402234f, -0.02533791f, -0.04766525f, -0.00433992f, 
    -0.00566480f, -0.04283767f, -0.05564472f, -0.05334551f, -0.04639913f, -0.00040174f, -0.03558727f, -0.02944182f, 
    0.01833226f, -0.00634341f, -0.03969110f, 0.00967356f, 0.02385011f, 0.02333217f, -0.02419315f, -0.02283925f, 
    0.03135401f, -0.01747233f, 0.01633314f, -0.01124560f, -0.02580956f, -0.02441752f, 0.02515586f, -0.01043027f, 
    -0.01979869f, -0.03459492f, -0.01977929f, 0.02224897f, 0.01460019f, -0.01040575f, 0.02946486f, -0.00837417f, 
    -0.00800403f, 0.00872203f, 0.00615861f, -0.04001135f, 0.01534507f, -0.03779291f, -0.04603151f, 0.02653846f, 
    -0.01847771f, -0.00472077f, -0.02238154f, 0.02339200f, 0.02258778f, -0.02486148f, -0.00068937f, -0.04138608f, 
    0.00093529f, -0.02002025f, 0.02907214f, -0.02748979f, -0.01776665f, -0.01082597f, 0.03214633f, -0.00328279f, 
    0.01536023f, -0.01772559f, -0.01876736f, -0.02940196f, -0.04143763f, -0.00142878f, -0.02489418f, -0.06529853f, 
    0.01042249f, 0.00119967f, -0.03667805f, 0.02089708f, -0.04952274f, -0.05265421f, -0.04989511f, -0.00085440f, 
    -0.04180106f, -0.02891577f, -0.02129628f, 0.01584099f, -0.03736405f, -0.04796378f, -0.02955141f, -0.06917373f, 
    -0.01513415f, -0.03928796f, 0.01197353f, -0.03484553f, 0.00719985f, -0.04183197f, 0.01830988f, -0.03514542f, 
    0.03344914f, -0.01048072f, 0.02229419f, -0.02645780f, -0.03101427f, 0.00502227f, -0.01856001f, -0.01150605f, 
    0.01549872f, 0.02227424f, -0.00241004f, -0.01017706f, 0.02481465f, -0.01354453f, 0.01258552f, -0.00800704f, 
    -0.03961570f, -0.01318209f, -0.02397886f, -0.02740913f, 0.00846900f, -0.01010591f, 0.01150934f, -0.01904654f, 
    -0.02384319f, -0.04402350f, 0.02961928f, -0.00080413f, -0.03468350f, 0.01097502f, -0.00335067f, -0.00159136f, 
    -0.02632125f, -0.02049414f, 0.00646441f, -0.03129973f, 0.01212730f, 0.02512348f, -0.02432560f, -0.03764862f, 
    0.00721021f, -0.04304085f, -0.02995063f, -0.02553793f, -0.01350687f, -0.04176502f, 0.00042341f, 0.02168060f, 
    -0.04119271f, 0.01575089f, -0.04425301f, -0.00283442f, -0.06093521f, -0.01145488f, -0.05188734f, -0.04808625f, 
    -0.05670269f, -0.00844059f, -0.03198742f, -0.00271465f, -0.06181538f, -0.00111883f, 0.00278103f, -0.00937422f, 
    -0.06582721f, -0.00763818f, -0.06443307f, -0.03465664f, -0.05475428f, -0.01844885f, -0.02198947f, -0.01911978f, 
    -0.03667984f, -0.03938521f, -0.02172339f, -0.01843411f, -0.00943993f, 0.00959976f, -0.03162000f, -0.02129637f, 
    -0.02102036f, 0.02027850f, 0.01597716f, -0.03885661f, -0.00784530f, -0.02818161f, -0.00476454f, 0.01530742f, 
    -0.00248230f, -0.03769384f, 0.01453179f, -0.04630298f, -0.04722333f, -0.00392507f, 0.00711034f, -0.02927089f, 
    -0.03617038f, -0.00897958f, -0.05811189f, -0.03476773f, -0.04766620f, 0.00330557f, -0.04720337f, -0.00846037f, 
    -0.01787841f, 0.02274053f, -0.05543505f, -0.04476570f, -0.02909084f, -0.05591558f, -0.03561004f, -0.01365730f, 
    -0.00622215f, 0.01085660f, 0.01163510f, 0.00647851f, -0.04650962f, 0.01341265f, -0.03541931f, -0.05764106f, 
    -0.01047212f, -0.02277430f, 0.02361128f, -0.02552529f, -0.02593657f, 0.01453614f, -0.01051418f, 0.01595890f, 
    -0.04418316f, 0.00688917f, 0.00648172f, 0.01818453f, 0.01313477f, -0.04042138f, -0.01708496f, -0.00333132f, 
    -0.03186911f, -0.03226720f, -0.03504171f, -0.04344027f, -0.07132997f, -0.04123532f, -0.01215404f, 0.00477048f, 
    -0.02348158f, -0.04386497f, -0.06173613f, -0.03655060f, -0.02856581f, -0.03184276f, -0.02814721f, -0.01820420f, 
    -0.02266424f, -0.04368332f, -0.00840065f, -0.05568330f, -0.03545849f, -0.00576724f, -0.00985378f, -0.01523325f, 
    -0.00345928f, -0.04092767f, -0.04035418f, -0.05320806f, -0.04720798f, -0.04982303f, -0.03998798f, -0.00977495f, 
    -0.00500498f, -0.03212099f, -0.03386787f, -0.00244317f, -0.01826400f, -0.05259241f, -0.01670130f, -0.02606768f, 
    -0.02812642f, -0.01253908f, -0.01910802f, -0.04815007f, -0.02108269f, 0.00645906f, 0.03317475f, -0.02051689f, 
    -0.02229413f, 0.00148739f, -0.01147852f, -0.03921951f, -0.03535258f, 0.00730194f, 0.01154024f, -0.00414650f, 
    -0.02706825f, 0.00261835f, 0.00070305f, 0.02690847f, 0.02774581f, -0.02712802f, -0.01793306f, -0.01320835f, 
    -0.01001093f, 0.00225548f, -0.01387560f, 0.00286593f, 0.03220366f, -0.03771688f, 0.00792132f, 0.00218409f, 
    0.02689785f, -0.02969141f, 0.02119985f, 0.01081564f, -0.03251263f, -0.00948123f, -0.03254182f, -0.00043504f, 
    -0.02738228f, 0.00735317f, -0.04469086f, -0.00899162f, -0.02412987f, -0.04234044f, 0.03265253f, 0.01357731f, 
    -0.03734183f, -0.02598364f, 0.02069707f, -0.03118528f, 0.01845936f, 0.03965604f, -0.02003409f, -0.03855592f, 
    -0.03580519f, 0.02298031f, -0.04531327f, -0.05029946f, -0.02413046f, -0.01226398f, -0.06856443f, -0.00865351f, 
    -0.02205555f, 0.01076643f, 0.02421045f, -0.05440307f, -0.03006577f, -0.03094931f, 0.01061573f, -0.00825907f, 
    -0.03255043f, 0.02614288f, -0.02532155f, 0.00627053f, 0.00694566f, -0.01850022f, -0.03200814f, 0.01551312f, 
    -0.00582328f, -0.05327117f, 0.01434895f, -0.02672200f, -0.01766296f, -0.03310147f, -0.00134643f, -0.04644483f, 
    -0.04041110f, 0.04258571f, -0.04563824f, -0.06189390f, -0.05899419f, -0.00903756f, -0.03806134f, -0.03313642f, 
    -0.06267864f, -0.01981533f, -0.01413539f, -0.01776716f, -0.00726848f, 0.01152972f, 0.00029712f, -0.01178165f, 
    0.00069056f, -0.01020402f, 0.00831233f, -0.03953989f, -0.00981878f, 0.01447582f, -0.03637771f, -0.02865627f, 
    -0.03655971f, 0.00365617f, -0.03515792f, 0.02017273f, -0.03993228f, -0.01319024f, -0.02366908f, -0.00217073f, 
    -0.04335887f, -0.05474806f, -0.02577712f, -0.00649503f, -0.03041434f, -0.00968068f, -0.02372217f, -0.03670028f, 
    -0.05268218f, -0.02659810f, -0.01932460f, -0.03550430f, 0.01573617f, -0.03856556f, -0.04838543f, -0.02939902f, 
    -0.02148493f, -0.05805475f, -0.02407138f, -0.03161943f, -0.01101863f, -0.00997964f, -0.03596060f, -0.06143812f, 
    0.00058608f, -0.07538010f, -0.04369465f, -0.01417492f, 0.00941246f, 0.00679646f, -0.04624476f, -0.02236653f, 
    -0.00475674f, 0.00806148f, -0.00974241f, -0.00190386f, 0.00228418f, -0.02721461f, 0.00700945f, -0.04123871f, 
    -0.05892140f, -0.03419250f, 0.01215785f, -0.04747788f, -0.02021528f, -0.00314028f, -0.01430568f, -0.04840875f, 
    -0.02165087f, 0.01873052f, -0.01696361f, -0.04506037f, -0.03144814f, 0.01455903f, -0.04966983f, -0.02347421f, 
    -0.02486027f, -0.03070086f, -0.03964296f, -0.00661183f, -0.01286043f, -0.01241336f, -0.05551333f, 0.00203674f, 
    0.00172110f, -0.00076650f, -0.05537869f, -0.06080051f, -0.03352140f, -0.01162856f, -0.01363605f, 0.00902154f, 
    -0.06368768f, 0.00915492f, -0.03374793f, -0.03868058f, -0.05401355f, -0.04312302f, 0.01726873f, -0.01607470f, 
    -0.00873262f, -0.00813191f, -0.04877272f, 0.01297062f, 0.01219456f, -0.03094181f, -0.02003128f, 0.00198323f, 
    0.02586899f, -0.00954362f, 0.00557906f, -0.02151163f, -0.01756069f, -0.03535570f, -0.02151265f, 0.01554868f, 
    0.01736704f, -0.01050965f, -0.03678021f, 0.01792461f, -0.04010520f, -0.01073582f, 0.02671366f, -0.03072949f, 
    -0.01626221f, -0.03787794f, -0.03526634f, -0.01295891f, -0.01361137f, -0.05230489f, -0.01374082f, -0.05333470f, 
    -0.04786505f, -0.00327708f, -0.00436248f, -0.06031581f, 0.00225435f, 0.00044564f, -0.04182822f, -0.01089070f, 
    -0.03882159f, 0.00243822f, 0.00544273f, -0.03969843f, 0.00794663f, -0.03675457f, -0.00949797f, -0.00372821f, 
    0.02644390f, 0.00888176f, 0.03071129f, -0.01389538f, -0.02760657f, -0.03903865f, 0.00913859f, 0.00091080f, 
    -0.03263470f, -0.04316949f, -0.05338041f, -0.05392663f, 0.00151617f, -0.01950041f, -0.01867042f, -0.01494153f, 
    0.03275358f, -0.01193234f, 0.01327442f, 0.02756540f, 0.01794567f, -0.02504422f, 0.00989284f, -0.03719399f, 
    0.02058983f, -0.02691944f, -0.00382006f, -0.04314114f, -0.03379437f, -0.01766093f, -0.00462598f, 0.01285654f, 
    0.02057800f, 0.00163609f, -0.00334843f, -0.04331337f, -0.03858880f, -0.03676374f, -0.00788937f, -0.01674883f, 
    -0.04131797f, -0.02065558f, -0.05945225f, -0.00235054f, -0.02902335f, 0.00206678f, -0.04480033f, -0.00294962f, 
    -0.04783299f, -0.03702368f, -0.02847494f, -0.05655718f, -0.07010388f, -0.00078367f, -0.04854712f, -0.04328479f, 
    -0.03304844f, -0.05563912f, -0.05421852f, -0.04536296f, -0.05260141f, -0.04410924f, -0.04381132f, -0.03928745f, 
    -0.04861068f, -0.06429169f, -0.01403507f, 0.02159071f, -0.00491563f, -0.00241866f, -0.03133633f, -0.05894462f, 
    -0.05859431f, -0.04749218f, -0.00286339f, -0.01052595f, -0.04614943f, -0.02749661f, -0.04229167f, -0.03100424f, 
    -0.00571653f, -0.03803454f, -0.04320042f, -0.04248286f, -0.02728143f, -0.00338086f, -0.01068532f, -0.04437950f, 
    -0.03462873f, 0.00711344f, 0.00002938f, -0.01946319f, -0.01438753f, -0.02810644f, 0.00298926f, -0.03313788f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02600209f, -0.01807917f, 0.03324144f, 0.06648627f, 0.03376408f, 0.08851743f, 0.00087684f, -0.01745112f, 
    0.04894930f, 0.21927369f, 0.19265471f, 0.10721456f, -0.03287801f, -0.05672973f, 0.07222590f, 0.09058458f, 
    -0.01891123f, -0.04165471f, -0.01143016f, -0.00009392f, 0.01400391f, -0.01400992f, 0.00469134f, 0.03294593f, 
    0.02106772f, -0.00019738f, -0.01912604f, 0.02347555f, 0.04294066f, 0.00077180f, 0.02292301f, -0.03029229f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.00238116f, 0.00388809f, -0.11546227f, -0.25006384f, -0.06314884f, 0.16905916f, -0.03657829f, -0.08048861f, 
    -0.03345508f, 0.27718553f, 0.27798465f, -0.12528701f, -0.13280925f, 0.19594522f, 0.18750122f, 0.31442827f, 
    0.13864163f, -0.07887859f, -0.15294057f, -0.01226176f, 0.02857584f, -0.35826388f, 0.14048423f, -0.14147042f, 
    0.13887650f, -0.17275380f, -0.08154902f, -0.03470861f, -0.15241286f, 0.02928298f, -0.12710464f, 0.02237255f, 
    0.02127626f, 0.08054166f, 0.01101445f, 0.37753734f, 0.10801063f, 0.19299190f, -0.13867284f, 0.07825004f, 
    -0.25851294f, 0.42405644f, 0.30117947f, 0.08444488f, -0.38349959f, -0.05367985f, -0.19764635f, -0.07158638f, 
    0.24120724f, 0.04762826f, 0.08283263f, -0.08128062f, -0.11547777f, 0.41915926f, -0.08212291f, 0.16561627f, 
    0.16449116f, 0.06944069f, -0.01337061f, 0.09782178f, -0.13015492f, 0.01040991f, -0.10889626f, -0.16704126f, 
    -0.07053797f, 0.30572477f, 0.14277251f, -0.04155853f, -0.21501833f, -0.02587787f, 0.03289998f, -0.02412722f, 
    -0.09276994f, -0.79116434f, -0.15702718f, 0.29511702f, 0.42287356f, 0.03713486f, -0.19003628f, 0.04554714f, 
    0.32092339f, -0.16471793f, 0.16322961f, -0.01505264f, 0.17431414f, -0.11199345f, 0.08117998f, 0.10366980f, 
    -0.05657018f, 0.16569558f, -0.08942197f, 0.02158990f, -0.00625522f, 0.00672534f, 0.00295460f, -0.01747395f, 
    -0.07684152f, -0.34537706f, -0.12910305f, 0.00391767f, 0.00730760f, 0.30637071f, 0.17509872f, -0.15094566f, 
    -0.17360044f, -0.09023441f, -0.02453197f, 0.10339466f, 0.43037573f, -0.08735361f, -0.01636500f, -0.07187083f, 
    -0.15336305f, 0.00295527f, -0.10310771f, 0.17401418f, -0.05036103f, -0.15184984f, 0.02929752f, 0.12788680f, 
    0.11091434f, 0.05343523f, 0.03873685f, -0.15711230f, 0.38556308f, -0.00050650f, 0.00545915f, 0.15111373f, 
    0.08634432f, 0.06124093f, 0.15738162f, 0.18011004f, -0.40572920f, 0.20562291f, -0.00593275f, -0.07108283f, 
    0.42199999f, -0.11981916f, -0.03806853f, 0.10406820f, 0.20066839f, 0.11902536f, 0.54122287f, 0.19734050f, 
    -0.19916554f, -0.08735468f, 0.13395357f, 0.09290939f, 0.04515166f, 0.00674174f, -0.00388518f, -0.12950683f, 
    0.16790263f, -0.15954274f, -0.09972787f, 0.12145612f, -0.22731046f, -0.15040378f, 0.06480019f, -0.11007078f, 
    0.02087435f, 0.01554373f, -0.07290655f, -0.27767074f, 0.07355515f, 0.15102479f, -0.02289876f, 0.09106860f, 
    -0.42527053f, -0.26612106f, -0.04044496f, 0.28058183f, 0.19541878f, 0.04470362f, 0.31393221f, 0.29606459f, 
    0.24856579f, -0.05226605f, 0.05927354f, -0.10912065f, -0.07688854f, -0.31903547f, 0.13749909f, 0.05559879f, 
    -0.05548259f, -0.14733806f, -0.12084156f, 0.05509387f, -0.16220482f, -0.14512886f, 0.15309802f, 0.11322702f, 
    -0.12969491f, 0.18836242f, 0.05802261f, 0.35330069f, -0.02120928f, 0.11105490f, -0.06370134f, 0.11419862f, 
    -0.10791764f, 0.03027381f, 0.19945432f, 0.11228420f, 0.26940688f, -0.07869971f, 0.04389422f, -0.17361496f, 
    0.09444319f, 0.02938685f, -0.04360464f, 0.04461074f, 0.10362420f, -0.19225486f, 0.00816208f, -0.08202443f, 
    0.02811234f, 0.15815723f, 0.10655565f, 0.00660652f, -0.49887380f, -0.02386624f, 0.09580233f, -0.01396850f, 
    -0.05060191f, 0.32736972f, -0.15914975f, -0.00908588f, -0.20478235f, -0.02118819f, -0.10111745f, 0.12226129f, 
    0.05291512f, 0.00639051f, 0.01796770f, 0.01224131f, 0.06794731f, 0.09168492f, 0.30068097f, 0.40902841f, 
    -0.15146247f, -0.07119639f, 0.14749905f, 0.15041824f, -0.09241360f, -0.21144913f, -0.07844061f, -0.08667489f, 
    -0.11066834f, -0.03089338f, -0.11395106f, 0.02493827f, -0.36478654f, 0.02891081f, 0.14991333f, 0.16874652f, 
    0.15435290f, 0.36934429f, 0.15331465f, 0.33648205f, 0.24435459f, -0.26124409f, -0.05373975f, 0.09125980f, 
    -0.06202641f, -0.22060373f, -0.13575207f, -0.24402140f, -0.11740272f, 0.05554402f, -0.08133487f, 0.30852225f, 
    0.37640956f, -0.16228144f, 0.13622917f, 0.09737919f, -0.13483965f, -0.03818383f, 0.11275911f, 0.01953088f, 
    -0.10255717f, 0.06132471f, 0.06931318f, 0.08742595f, 0.41838381f, 0.03288485f, -0.02272762f, 0.02213207f, 
    -0.08738654f, -0.14403561f, -0.00871230f, -0.17831533f, -0.03410767f, 0.38433760f, -0.11991184f, -0.03091231f, 
    0.34853575f, -0.34961098f, 0.01016934f, 0.21336277f, 0.00471647f, -0.03611298f, 0.13408254f, -0.10834843f, 
    0.21553367f, -0.03552610f, 0.06954496f, 0.12772775f, -0.00358053f, 0.30047449f, 0.10641903f, 0.06500839f, 
    0.05486494f, -0.01350680f, 0.13701120f, 0.02447530f, 0.02493571f, -0.00450645f, -0.01266058f, -0.16808136f, 
    0.07471655f, 0.12684795f, -0.17332727f, -0.09444033f, -0.31806812f, 0.02332538f, -0.09749818f, -0.05276981f, 
    -0.02519553f, 0.26642314f, 0.09568013f, 0.00582870f, 0.22257613f, -0.02080929f, 0.29141262f, 0.24603231f, 
    -0.46488002f, -0.09015512f, 0.11097474f, -0.08842612f, 0.07465593f, -0.05840801f, 0.14537226f, 0.03269346f, 
    -0.01136767f, 0.10049390f, 0.17393698f, -0.11768402f, 0.32730362f, 0.16305719f, 0.15454042f, 0.00832725f, 
    0.06454062f, 0.25555879f, 0.08239985f, 0.33535659f, 0.42015243f, -0.03266071f, 0.11405531f, 0.06481414f, 
    0.18505406f, 0.17488642f, 0.11373165f, -0.22257660f, 0.13713449f, -0.00420424f, 0.03813434f, -0.09502360f, 
    0.17294472f, 0.10101985f, -0.15620680f, -0.01089108f, 0.18118432f, 0.09789134f, -0.06062750f, 0.03788951f, 
    0.00522103f, -0.15190682f, 0.16496044f, -0.02052548f, 0.18912522f, 0.08288945f, -0.07602917f, 0.03649668f, 
    0.02255716f, -0.15558867f, 0.12625386f, -0.15495744f, -0.01199772f, 0.20750830f, 0.07620799f, 0.10689703f, 
    0.28316891f, -0.17565148f, 0.09502944f, 0.02381741f, -0.31478462f, -0.10007247f, -0.15508798f, 0.26156476f, 
    0.01076641f, 0.12427527f, -0.03136326f, 0.14017102f, -0.15664861f, 0.13638808f, -0.13558890f, -0.12423260f, 
    0.13265169f, 0.01567044f, -0.15991676f, 0.02242550f, 0.02912052f, -0.14963545f, -0.07800896f, 0.16444719f, 
    0.13823634f, 0.03648072f, -0.14752017f, 0.24601965f, -0.11568155f, -0.04562387f, 0.01142099f, -0.13736726f, 
    0.00596865f, -0.41180700f, 0.19882303f, -0.03581884f, -0.06938850f, -0.17465429f, -0.27570924f, -0.33133647f, 
    0.00113677f, -0.09859715f, -0.17649262f, 0.03382525f, -0.01370365f, 0.06161723f, 0.00461755f, 0.16894133f, 
    -0.13061891f, 0.03001383f, 0.14337668f, -0.07051913f, -0.11945998f, 0.03323180f, 0.00323810f, 0.10242199f, 
    -0.15015379f, 0.17672575f, -0.01149641f, -0.14770354f, 0.14767502f, -0.36974928f, 0.08452538f, -0.06106486f, 
    0.24586166f, 0.10062183f, -0.19009800f, -0.07081636f, 0.01191907f, -0.17644723f, -0.10343217f, 0.37045595f, 
    -0.00570429f, -0.18116067f, 0.13646168f, -0.14828327f, 0.14906280f, 0.22549681f, 0.06158461f, 0.10070559f, 
    0.03086668f, 0.03428143f, -0.01108688f, 0.10469084f, -0.18186158f, -0.16690457f, 0.17050850f, -0.05279654f, 
    -0.00672192f, -0.15161358f, -0.03748403f, 0.11707049f, 0.10091075f, -0.12871675f, -0.12344068f, 0.05563926f, 
    -0.08031078f, -0.28264657f, -0.00411556f, 0.12835024f, -0.22645743f, 0.15615647f, 0.07954304f, -0.05501454f, 
    -0.25212175f, -0.15301870f, 0.10420365f, 0.06277493f, 0.06048185f, 0.19470294f, -0.09113614f, 0.10491232f, 
    0.11754337f, -0.07807278f, 0.16692306f, -0.17292096f, 0.08129754f, -0.09850232f, -0.16606022f, 0.01138952f, 
    -0.05895116f, 0.10975930f, -0.11125217f, -0.23990910f, -0.20018148f, -0.03655798f, 0.11974083f, 0.13949139f, 
    0.30457774f, -0.28517836f, -0.01002961f, 0.15193951f, -0.38010240f, 0.08501883f, -0.18899073f, 0.29764000f, 
    0.28402808f, 0.07251256f, 0.00490391f, 0.09595726f, -0.02579773f, 0.36646461f, 0.15099373f, -0.02644017f, 
    0.01798483f, -0.16400228f, -0.00661358f, 0.00179805f, 0.32282233f, 0.15433039f, -0.07521345f, 0.02282552f, 
    0.09559978f, -0.25740659f, -0.04895980f, 0.07627132f, 0.44248027f, 0.05650302f, -0.13529345f, -0.12479881f, 
    -0.05909903f, 0.10500734f, 0.18601881f, 0.20721222f, 0.25268710f, 0.11296674f, 0.06005645f, -0.31396559f, 
    -0.07623969f, -0.03390672f, -0.03556339f, 0.08237191f, -0.14980584f, 0.19251838f, -0.15118031f, -0.13695192f, 
    -0.08385100f, -0.17308110f, -0.09702417f, 0.08672378f, 0.16916075f, -0.05129592f, -0.07228988f, 0.04910713f, 
    0.04628368f, 0.20081915f, -0.15396379f, 0.10147129f, 0.23304558f, -0.31012943f, -0.10870555f, 0.13476931f, 
    -0.09468780f, -0.22087097f, -0.24464592f, 0.08123132f, 0.06424422f, 0.12236919f, -0.25135785f, 0.04657584f, 
    0.34161839f, 0.11176845f, 0.17400496f, -0.01848890f, -0.09469319f, 0.25181511f, -0.01626941f, -0.04199514f, 
    0.09855565f, -0.14443536f, -0.13601464f, -0.14647667f, -0.42872366f, -0.01058264f, -0.17379791f, -0.13690868f, 
    -0.15362518f, -0.22225583f, 0.15783593f, -0.09570353f, 0.04118527f, 0.34966102f, -0.01187597f, 0.14620686f, 
    -0.46198106f, 0.30334496f, 0.17343336f, -0.12176660f, 0.24506913f, 0.12819649f, -0.13053639f, 0.15673292f, 
    0.00789139f, -0.11330124f, 0.08695987f, 0.11128970f, -0.05957757f, 0.07892400f, 0.05323552f, -0.04553216f, 
    -0.00201712f, -0.18181597f, -0.16029133f, -0.00561634f, 0.63992596f, -0.12446953f, -0.07038031f, 0.16482055f, 
    0.07948158f, 0.31653586f, 0.12883639f, -0.14321949f, -0.08754255f, -0.14553276f, 0.14791127f, -0.07377822f, 
    -0.07206856f, -0.27246353f, 0.01312232f, -0.08028068f, -0.08082780f, -0.13105828f, 0.07882537f, -0.35187605f, 
    -0.11784170f, 0.09476514f, 0.11548459f, -0.17925707f, 0.09246245f, 0.19399592f, 0.05017596f, 0.00563142f, 
    0.03507525f, -0.07073612f, -0.01604629f, 0.12286409f, 0.25074601f, 0.04343268f, -0.16581760f, -0.07741044f, 
    -0.06202765f, 0.00250522f, -0.05471611f, -0.02885519f, 0.00530435f, -0.39932778f, -0.15205765f, -0.14495763f, 
    0.20359288f, 0.30314779f, -0.17676759f, 0.21255466f, 0.05662800f, -0.00790506f, -0.16101252f, 0.25796095f, 
    -0.18097572f, 0.13133486f, -0.15923215f, -0.09620235f, 0.10814720f, 0.14889465f, 0.11207128f, -0.04604156f, 
    0.12765923f, -0.02463707f, 0.04232596f, 0.15067762f, -0.31184444f, -0.00403111f, -0.13144171f, 0.13293256f, 
    -0.17464542f, -0.08974298f, -0.09335279f, 0.01124515f, -0.33954510f, -0.06294920f, 0.08077233f, 0.03979170f, 
    0.05693936f, 0.11150331f, 0.18753722f, 0.34825402f, 0.08029102f, 0.10359394f, 0.01743612f, -0.07551637f, 
    -0.57074368f, -0.14457001f, 0.09224149f, -0.13754173f, 0.17118235f, -0.54567653f, 0.08371984f, 0.15566796f, 
    0.04482661f, 0.17053242f, -0.16310586f, -0.07621014f, 0.34346768f, -0.00199574f, -0.09240504f, 0.06553251f, 
    0.07587069f, 0.34192654f, -0.06334531f, 0.40494487f, -0.31370541f, 0.14513835f, 0.05966206f, 0.13694941f, 
    0.22258092f, -0.04233294f, -0.08194650f, 0.07600021f, 0.15355368f, 0.12270887f, 0.23703614f, -0.12391250f, 
    -0.13717745f, -0.08981644f, 0.16751571f, -0.14550947f, -0.01920496f, -0.10803800f, 0.08900643f, 0.08828843f, 
    -0.14756101f, -0.10201300f, 0.06387030f, 0.16108043f, -0.22736241f, 0.16426884f, 0.12338958f, 0.12159155f, 
    0.13727506f, -0.07475582f, -0.15332085f, -0.27040076f, 0.29686469f, 0.16776574f, 0.02253668f, 0.04280732f, 
    0.10006545f, -0.39436311f, -0.30757722f, 0.14889501f, 0.36338913f, 0.10527761f, 0.26089105f, -0.11939725f, 
    0.09122928f, 0.04476185f, 0.08232454f, 0.15871662f, -0.09699481f, 0.05022775f, -0.15872896f, -0.04483546f, 
    0.11634564f, -0.12860096f, 0.05998535f, -0.12324388f, 0.54760653f, -0.12267586f, -0.12791491f, -0.12757057f, 
    0.05490702f, -0.14852875f, 0.11506856f, -0.12672420f, -0.03616954f, 0.17836937f, 0.15436962f, -0.00619927f, 
    0.13952088f, 0.31418127f, -0.02640139f, 0.35923940f, -0.23433547f, -0.12309925f, 0.26142752f, -0.03052261f, 
    0.05478158f, 0.09045776f, 0.17212863f, -0.08661044f, 0.06621174f, 0.27809390f, -0.04843478f, -0.08973668f, 
    0.02771104f, 0.04467524f, 0.08305886f, -0.15384053f, -0.70707345f, -0.03381875f, 0.00031970f, -0.11259947f, 
    -0.01988669f, 0.02354554f, 0.11188363f, 0.14992876f, -0.11672513f, 0.37278745f, -0.09240387f, -0.14529040f, 
    0.03247806f, 0.17978716f, 0.22372530f, 0.10921255f, -0.08198299f, 0.01445947f, 0.51996887f, -0.09680831f, 
    -0.00663518f, 0.05869403f, -0.14447138f, -0.11436543f, -0.14491579f, -0.10552655f, -0.03134020f, -0.13878579f, 
    0.10405704f, 0.09603430f, 0.14900638f, -0.14134827f, 0.15881990f, -0.03627650f, -0.11225511f, -0.02270798f, 
    0.07162136f, -0.13690843f, -0.01040180f, -0.14638586f, 0.32504150f, 0.04316168f, -0.01452564f, 0.14520423f, 
    -0.40760946f, 0.38725978f, 0.10124394f, 0.28058830f, -0.06438784f, -0.07101861f, -0.20865726f, 0.20336878f, 
    -0.02536080f, 0.02287436f, -0.07009432f, 0.06664807f, -0.02895168f, 0.02743309f, -0.05090513f, -0.01369899f, 
    -0.00902796f, 0.05779540f, -0.17317277f, -0.01205298f, 0.33172831f, 0.13708220f, -0.14640239f, 0.12240747f, 
    -0.15064310f, 0.16717260f, -0.13278374f, -0.07867312f, -0.01161624f, 0.30232558f, -0.12424931f, -0.06809480f, 
    -0.30855390f, 0.24474826f, 0.29770753f, -0.17562300f, 0.49094200f, -0.09196693f, 0.03635135f, -0.19742909f, 
    0.20075271f, 0.01296976f, -0.06419352f, -0.10689545f, -0.02326011f, -0.05915927f, 0.11535159f, 0.01235791f, 
    0.11029218f, 0.10550679f, 0.07188389f, 0.16988656f, 0.60067225f, -0.07436249f, 0.13713522f, 0.03669611f, 
    -0.10233493f, 0.38559559f, 0.18970470f, 0.10673270f, -0.34399924f, 0.14615989f, 0.14561242f, -0.12415791f, 
    -0.37521034f, -0.00040041f, 0.08539575f, 0.04285234f, 0.52301925f, -0.06095135f, 0.19368656f, -0.06999654f, 
    0.03041469f, -0.03565875f, -0.14860490f, 0.15987715f, 0.04037310f, -0.15903060f, -0.00997782f, -0.17789231f, 
    0.07046257f, -0.07964548f, 0.00159450f, 0.08793576f, -0.20073681f, 0.06683403f, 0.13081513f, -0.11720019f, 
    -0.03219394f, 0.13568480f, -0.15565607f, -0.26875171f, 0.13422740f, -0.33133450f, -0.13910967f, 0.06018508f, 
    -0.16337368f, -0.05823690f, -0.03281364f, -0.13720746f, -0.04534753f, 0.05297901f, -0.39223352f, -0.05314447f, 
    -0.02927176f, -0.03766230f, 0.08712300f, 0.04772926f, 0.00305980f, -0.20623323f, -0.02021282f, 0.11943027f, 
    0.02799955f, 0.15606742f, 0.15149669f, -0.18012877f, -0.09543404f, 0.09882902f, 0.07972942f, -0.12795533f, 
    0.01075005f, 0.03966911f, 0.00469638f, 0.26104212f, -0.27651238f, -0.16097435f, 0.08109953f, 0.16340303f, 
    0.03408849f, 0.24288790f, 0.20725717f, -0.02868895f, -0.46825460f, 0.08883557f, 0.01470901f, 0.16546999f, 
    0.08721305f, -0.00727047f, 0.07513002f, 0.09279276f, 0.03632859f, 0.30562839f, 0.12670393f, 0.16438727f, 
    0.14956577f, 0.03238312f, 0.05729169f, 0.08134329f, 0.06523780f, -0.02203931f, 0.11368592f, 0.13288674f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.09817325f, 0.34029907f, -0.18333974f, 0.21632664f, -0.01995729f, -0.05368628f, -0.17150696f, -0.02554851f, 
    0.29273000f, 0.22035153f, -0.01178837f, 0.16395357f, 0.14316006f, 1.30567896f, 0.37084734f, 0.62158650f, 
    0.45046556f, 0.21025138f, -0.03402566f, -0.10121930f, 0.43966311f, 0.16359170f, 0.28726768f, 0.00687198f, 
    -0.00986986f, -0.11553379f, -0.00168575f, -0.02164020f, 0.01164720f, -0.10905203f, 0.86364573f, 0.32014623f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.28838804f, 0.02754759f, 0.17732821f, -0.05471004f, -0.33432311f, -0.01273304f, -0.33876243f, -0.33552298f, 
    0.13695750f, 0.13846208f, -0.14239091f, 0.17807353f, 0.27017495f, 0.29849622f, 0.24873391f, 0.17856285f, 
    0.21499680f, -0.11720209f, 0.26613018f, -0.44124469f, -0.02999114f, 0.20446706f, -0.12877168f, -0.09894505f, 
    0.08392629f, -0.27654076f, -0.55380368f, -0.14915912f, -0.34831697f, -0.32516116f, 0.33950377f, -0.00961881f, 
    -0.10798381f, 0.28951600f, -0.74128652f, 0.07571361f, 0.04772811f, -0.66411734f, 0.07168826f, -0.08241558f, 
    -0.00596240f, 0.00362223f, -0.21717584f, -0.13739905f, 0.07570221f, -0.04236431f, 0.19837663f, -0.11281618f, 
    0.15477385f, 0.07135030f, 0.24424644f, -0.26354405f, 0.00122732f, 0.33783400f, 0.33639398f, 0.03720114f, 
    -0.50422734f, 0.37157696f, 0.10720620f, 0.18913595f, -0.51862931f, -0.34199220f, 0.30900019f, 0.26036161f, 
    0.22976191f, 0.36637822f, -0.48517960f, -0.26118571f, -0.10146706f, 0.57637334f, 0.36101034f, 0.17153794f, 
    -0.12810300f, -0.08816867f, -0.26383570f, 0.16544813f, -0.10163748f, -0.03997431f, -0.25656345f, 0.28347340f, 
    -0.39248312f, -0.09239256f, -0.29734883f, -0.18506551f, 0.05753462f, -0.40391323f, -0.84356111f, -0.02839029f, 
    -0.65342766f, 0.23344159f, 0.16224258f, 0.13144733f, -0.12850091f, 0.08002634f, -0.02708224f, 0.06334747f, 
    -0.04657945f, -0.10092774f, 0.47936943f, -0.31126150f, 0.02032077f, 0.31951270f, 0.44066358f, 0.04455027f, 
    0.10090321f, 0.04130403f, -0.17257825f, -0.22282578f, -0.28161886f, -1.76328146f, 0.00170867f, -1.28700185f, 
    0.09952578f, -0.44028363f, 0.19920664f, -0.29713240f, -0.53600067f, -0.02289169f, -0.45375732f, 0.23759969f, 
    0.03049808f, -0.19586089f, -0.19159329f, -0.20735565f, -0.07396515f, 0.25441560f, -0.71761221f, -0.11905084f, 
    -0.19990733f, 0.12682408f, -0.04887364f, -0.18582618f, -0.26720613f, -0.13203561f, 0.02934656f, -0.53765553f, 
    0.19868086f, 0.04175860f, -0.53090852f, 0.18541507f, -0.22858916f, -0.09806240f, -0.05161636f, 0.04083097f, 
    0.03880701f, -0.03484843f, 0.06466462f, 0.17770167f, 0.17229414f, -0.50549638f, 0.33469623f, 0.03443738f, 
    0.20629881f, -0.34467709f, 0.08527363f, -0.04150510f, 0.23978411f, -0.09713722f, -0.32294348f, 0.05956436f, 
    0.24764878f, 0.10021114f, -0.32956734f, -0.48829117f, 0.13345735f, -0.14858285f, -0.58600169f, 0.03266393f, 
    0.00614335f, 0.15755853f, 0.01840839f, -0.09583804f, 0.38892895f, 0.02945595f, 0.03213922f, -0.13178286f, 
    0.35677603f, -0.24008566f, -0.38353863f, 0.27831480f, 0.16359471f, -0.20278291f, -0.19687948f, -0.19443618f, 
    -0.00765505f, -0.14480811f, 0.20252621f, 0.13617335f, -0.03829709f, -0.18547089f, -0.14117482f, 0.21999428f, 
    -0.08787783f, 0.21618758f, -0.19928288f, 0.15368204f, -0.07823627f, -0.18066186f, 0.15173976f, 0.00622192f, 
    -0.57964641f, -0.65644848f, 0.18653078f, -0.13870569f, -0.19047344f, -0.36835992f, -0.20415035f, -0.22233669f, 
    -0.57860613f, -0.00265220f, -0.31115845f, 0.39831662f, -0.05252289f, -0.19855967f, 0.32668397f, -0.01214971f, 
    -0.66245717f, -0.27200887f, 0.08280315f, 0.16150555f, 0.26146886f, 0.20170315f, -0.07859853f, 0.13604756f, 
    -0.41538355f, -0.22383824f, 0.18003820f, 0.36635205f, 0.08267993f, 0.39306161f, -0.41782600f, -0.31295249f, 
    -0.35449389f, 0.29720354f, -0.01288019f, -0.52912062f, -0.04614861f, 0.02575643f, -0.20287506f, 0.07710277f, 
    -0.12858345f, 0.10494930f, -0.23824583f, 0.07296594f, -0.84676081f, -0.19410789f, 0.13289280f, -0.00369766f, 
    0.53257620f, 0.15718827f, 0.04457364f, 0.14090954f, -0.16721658f, -0.23778297f, -0.44652212f, -0.22152103f, 
    0.18815373f, -0.74633098f, -0.40351483f, -0.01128460f, 0.31545040f, 0.05633656f, -0.18111260f, 0.37544605f, 
    -0.72683734f, 0.15181044f, 0.08725689f, -0.12252527f, 0.18550321f, -0.70098615f, 0.07279264f, -0.27367461f, 
    0.00030995f, -0.32812536f, -0.45569542f, -0.38489550f, -0.12966728f, 0.08504232f, 0.01919631f, 0.23704103f, 
    0.03754676f, 0.13426380f, 0.17292291f, -0.55289644f, -0.45175150f, -0.09700532f, -1.02149248f, -0.20939566f, 
    0.18808232f, 0.09560271f, -0.21789250f, 0.20631389f, -0.36502266f, 0.05380612f, -0.15117142f, -0.48177856f, 
    -0.22795975f, -0.03371331f, -0.18273143f, 0.04436375f, -0.31993291f, -1.01453066f, -0.17409554f, -0.52152884f, 
    -0.38591745f, 0.39877158f, -0.53204626f, 0.43218407f, -0.69008029f, 0.13627690f, -0.16387634f, -0.68577683f, 
    0.18111047f, -0.01557022f, -0.06798145f, 0.42873600f, 0.31135312f, -0.16093332f, -0.26985598f, -0.23364250f, 
    0.05807108f, -0.32403660f, -0.56514454f, -0.38335249f, 0.14089502f, -0.00862998f, -0.20445067f, 0.42299759f, 
    0.34957090f, -0.84464705f, 0.20325011f, 0.27504537f, -0.40162072f, -1.61937785f, 0.33208337f, -1.58579433f, 
    -0.17547946f, -0.32878676f, -0.12239281f, -0.27923292f, -0.53304726f, 0.28040043f, -0.01493634f, 0.05605409f, 
    -0.22572161f, -0.42362586f, -0.00583265f, 0.17035984f, -0.25745079f, -0.00718660f, -0.42363149f, 0.08176409f, 
    -0.14060670f, -0.16683562f, -0.26247114f, 0.14458768f, 0.32833382f, -0.73799455f, 0.21942055f, 0.02742169f, 
    -0.31280914f, 0.09448382f, -0.00552517f, 0.31336296f, -0.32526952f, -0.94904500f, -0.35433319f, -0.85959995f, 
    -0.32525119f, 0.29485306f, -0.18449764f, -0.36840165f, -0.39598966f, -0.26863229f, -0.00913560f, 0.45687887f, 
    0.02477722f, -0.10541198f, 0.20646892f, -0.55629444f, 0.02674392f, 0.06079040f, -0.99878865f, -0.09526181f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.10303207f, 0.15289611f, 0.18696468f, -0.10355555f, 0.02808619f, 0.05299264f, -0.19917884f, 0.00085234f, 
    -0.24637541f, -0.10261264f, -0.21368936f, -0.20145452f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
