#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.33344841f, 0.07685920f, 0.91301876f, 0.47278428f, 0.85260677f, 0.78251201f, -0.25407723f, -0.18137214f, 
    0.00039943f, -1.01987791f, -0.70638043f, -1.17536592f, 0.58797801f, 0.13221656f, -0.21431006f, 0.62390757f, 
    -0.52965724f, 0.42211974f, 1.42957830f, -1.36989665f, 0.05176639f, 0.84355319f, -0.35576716f, -0.42853528f, 
    -0.00277894f, 0.19272712f, 0.17127886f, -0.56219977f, 0.09082515f, 0.70623320f, -0.93471009f, -0.65244937f, 
    -0.11937506f, 0.63846958f, 0.24714607f, 0.87002975f, 0.95670420f, 1.04913402f, -0.59396362f, 0.29549417f, 
    0.62713540f, 0.87017655f, 0.61646211f, -0.34979966f, 0.30949476f, 0.53426206f, 0.89638507f, -0.45039701f, 
    -1.18869209f, -0.24409898f, -1.41800547f, 0.05274366f, 0.26752648f, -0.01424385f, 0.88101363f, 1.17471218f, 
    -0.19421162f, 0.09859824f, -0.79487836f, 0.83292079f, -0.77280474f, 0.54682994f, 0.47462490f, 0.09749489f, 
    -0.94418079f, -0.84135276f, -1.08699906f, -0.98795366f, 0.50463206f, -0.33274442f, 0.26797381f, 0.71797687f, 
    -0.81472737f, -0.47724792f, -0.56383246f, 0.21586031f, 0.94015342f, 1.16083789f, 0.36453915f, 0.40198234f, 
    0.75652641f, -1.09699082f, 0.97909206f, -0.99343741f, -0.67019480f, -0.06073061f, -0.54997116f, -0.40047297f, 
    -0.86661732f, -0.02946914f, -1.35408843f, 0.52544892f, -0.88936418f, 0.19049586f, 0.74794853f, -0.69547546f, 
    -0.55446416f, 0.61286443f, -0.36850280f, -1.08045959f, -0.83382404f, -0.67659354f, -0.11364385f, -1.00760961f, 
    -0.26880351f, 0.65843898f, 0.36853993f, -0.17788477f, -1.78171039f, -0.87885147f, 0.70947039f, -0.08338875f, 
    0.07072767f, 0.38371626f, -0.16375342f, 0.45755234f, 0.34917852f, 0.73149526f, 0.19113387f, 0.30340704f, 
    -1.25464392f, -0.93949169f, -0.88518953f, -0.19339532f, -0.49352074f, 0.01712940f, 0.91384023f, 0.97255880f, 
    -0.28532124f, 0.81690085f, 0.36855605f, -0.66410786f, 0.01584086f, -0.28461999f, -0.01183425f, 0.88872385f, 
    0.76954871f, 0.35131091f, 0.24384956f, 0.51589012f, -0.20934381f, 0.24345198f, 0.87596446f, 0.66875756f, 
    1.09487391f, 1.04255700f, 0.35566837f, -0.99740195f, 0.06316184f, -0.06180951f, 0.12977383f, -0.20173122f, 
    0.18875796f, 0.61226481f, 0.43718532f, 0.35048652f, 0.81806475f, 1.02241230f, -0.80854750f, -0.45048130f, 
    0.55103177f, -0.40868807f, -1.17411602f, 0.76526737f, -0.61116445f, -0.76122463f, -0.64727527f, 0.21295485f, 
    0.14039914f, -0.00299328f, -0.08899277f, -0.83309990f, -1.16436982f, -0.92654639f, 0.35212025f, -0.88146573f, 
    -0.46608034f, -0.46023756f, -0.10788474f, -0.06179495f, 0.28125513f, -0.36218643f, 0.43156564f, -1.25322747f, 
    -0.55940807f, -0.85099566f, -0.00398313f, 0.66804892f, -0.92464232f, 1.30605125f, 0.93547493f, 0.90361112f, 
    0.20886651f, -0.71271545f, 0.04984658f, 0.41376743f, 0.69905305f, -0.50087482f, -1.15071440f, -0.97674096f, 
    -0.97884113f, -0.28653979f, 0.28608170f, 0.82233858f, -0.58351642f, -0.40323973f, -0.63901210f, -0.15410437f, 
    1.06604850f, 1.11730707f, -0.97250354f, 0.69530714f, -0.01974916f, 0.25862092f, 0.62069887f, 0.43070510f, 
    -1.24406970f, 0.60888964f, 0.66085684f, -0.55859011f, 0.49740851f, 0.42910817f, -0.82757688f, -0.43246326f, 
    -0.82800758f, 0.68574297f, -0.14120965f, 0.78630286f, 0.73560804f, -1.23426867f, 0.72394800f, 0.33732423f, 
    -0.65832466f, -0.49840817f, 0.00254947f, -1.10177493f, -0.02878482f, 1.10183549f, 0.94237649f, 0.43060225f, 
    -0.42140919f, -0.26098081f, -0.33175167f, 0.52294582f, -0.46563396f, -0.94751275f, 0.05416647f, 0.82486761f, 
    0.64288890f, -0.86876732f, 0.35975423f, 1.06863093f, -1.43741167f, 0.96978164f, -0.56985229f, 0.58799547f, 
    1.42662704f, 0.45723128f, -0.18993552f, -0.23335655f, 0.34903973f, -0.96455431f, -0.30135068f, -0.00500628f, 
    0.91131979f, 0.77853751f, -0.58214349f, -0.21693537f, -0.69631231f, -0.60794216f, -1.18325758f, -0.52472585f, 
    -0.24473286f, 0.66733283f, 0.46726549f, 0.67817718f, 0.38912562f, 0.13081922f, -0.22060528f, -0.94663846f, 
    -0.83404946f, -0.29213351f, -1.13004589f, 1.10021460f, -0.36660469f, 0.85667306f, -0.26189646f, 0.10989776f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.04376488f, 0.11199235f, 0.04985708f, -0.13926861f, -0.12744994f, 0.29122680f, 0.03122099f, -0.01478598f, 
    0.18295662f, -0.02340045f, 0.17197433f, -0.18731594f, -0.11868928f, 0.42571917f, 0.41910347f, 0.34120303f, 
    0.08096740f, -0.05993996f, 0.60570699f, -0.40412387f, -0.18882130f, -0.11369799f, -0.11464947f, 0.00328549f, 
    -0.11096244f, 0.20449120f, -0.03871122f, -0.28561482f, -0.00527120f, -0.35824567f, 0.03285526f, -0.12362992f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.12986596f, 0.23011333f, -0.11070184f, 0.13338006f, -0.07163271f, 0.29011497f, -0.18550837f, -0.03159189f, 
    -0.04923742f, 0.14150333f, -0.06459178f, 0.08981440f, 0.07119434f, 0.14507063f, -0.10949757f, -0.12961420f, 
    -0.05681716f, 0.11320496f, 0.11099067f, -0.02129595f, 0.01239391f, 0.06656393f, 0.01102168f, -0.15942934f, 
    -0.11149118f, -0.05124439f, -0.01393242f, 0.29172385f, 0.31108150f, 0.00429062f, 0.05824216f, 0.06328968f, 
    -0.25537440f, -0.05762119f, -0.13838781f, 0.10329862f, 0.07619861f, -0.24719803f, 0.02894197f, -0.07245987f, 
    0.05653586f, 0.06212247f, 0.07583424f, -0.03807116f, 0.15545841f, 0.14730486f, 0.31694022f, 0.21540241f, 
    -0.03969880f, 0.01866360f, -0.09685479f, 0.01912801f, 0.16376045f, 0.05213450f, -0.07051402f, -0.03455536f, 
    0.00176570f, -0.05145106f, 0.36635035f, 0.15269046f, -0.02288521f, 0.02796995f, -0.02275951f, 0.18216445f, 
    -0.10749789f, 0.02633504f, 0.10425414f, -0.02482651f, -0.13765575f, 0.02754962f, 0.13917026f, -0.00941879f, 
    0.15971398f, -0.09181260f, 0.31978545f, -0.17848018f, 0.13432410f, 0.04362804f, -0.14931293f, 0.02864281f, 
    -0.11755863f, -0.49265337f, 0.24933542f, -0.23553127f, 0.09624986f, -0.10830832f, -0.17195007f, 0.07257910f, 
    -0.04168979f, 0.02561558f, -0.04852871f, -0.02901283f, 0.05270834f, -0.19050300f, 0.00024848f, 0.05634580f, 
    -0.08581643f, -0.00305200f, 0.01384175f, 0.18587056f, 0.06775761f, -0.00521658f, 0.12402204f, 0.05221466f, 
    0.02231605f, -0.13773461f, -0.00768878f, -0.02650869f, 0.36516044f, -0.07932024f, -0.16545402f, -0.19505712f, 
    -0.06991969f, 0.16840985f, -0.03135219f, 0.07048352f, -0.24389066f, -0.22286829f, 0.16796784f, 0.07975582f, 
    0.08837513f, 0.26047283f, -0.08890912f, -0.12412925f, 0.03209290f, 0.01605544f, 0.18204048f, 0.01077002f, 
    -0.02624474f, 0.22832157f, 0.16817681f, -0.11302669f, 0.17041734f, 0.10457265f, 0.00418044f, 0.01073981f, 
    0.15133621f, 0.01703092f, -0.02811698f, -0.01000674f, 0.03495834f, 0.01997184f, 0.16070111f, 0.09850857f, 
    -0.18050441f, 0.18440016f, 0.06495751f, 0.27123466f, 0.24370389f, 0.12265053f, 0.08504666f, -0.15977181f, 
    0.08086734f, 0.04028673f, 0.37048909f, -0.22230104f, 0.16280140f, 0.03108015f, 0.04028400f, -0.03487964f, 
    0.18119478f, -0.01070689f, -0.05650915f, 0.05684010f, 0.03350231f, -0.03650123f, 0.17098723f, -0.03476690f, 
    -0.09774750f, 0.00450913f, 0.01493061f, -0.05074018f, -0.15146427f, 0.09641556f, 0.22740658f, 0.05121026f, 
    -0.38187158f, 0.20901729f, 0.13676223f, -0.06262922f, -0.10407187f, -0.19168884f, -0.31087461f, 0.12661101f, 
    -0.05131423f, 0.06244257f, -0.00257002f, 0.25386372f, -0.02049639f, 0.15659392f, 0.07575185f, -0.06572063f, 
    0.39428160f, 0.18381448f, 0.11987238f, -0.18662611f, 0.14108428f, 0.00578969f, -0.09296641f, -0.15217593f, 
    0.06157876f, -0.01560762f, 0.04398388f, -0.19861728f, -0.13055660f, -0.14782459f, 0.18520740f, -0.06607650f, 
    0.01706186f, -0.22358240f, 0.08428584f, 0.02120714f, 0.09314016f, -0.02099868f, 0.20702851f, 0.04018954f, 
    0.04098443f, -0.00347415f, -0.44063553f, -0.14999114f, 0.04696300f, 0.17357083f, -0.17906275f, -0.19912387f, 
    0.04296775f, 0.18389924f, 0.00921204f, -0.26076531f, 0.02882037f, -0.09242055f, 0.08225609f, 0.12392505f, 
    -0.10223272f, -0.04126147f, 0.29173562f, -0.11609697f, 0.05385745f, -0.11896399f, -0.08525758f, -0.03069381f, 
    -0.10379006f, -0.13990819f, 0.02994937f, -0.11377108f, 0.06427890f, 0.14857173f, 0.06279913f, -0.18273655f, 
    -0.01097662f, -0.11472937f, 0.15831666f, -0.08139621f, 0.30188414f, 0.05964257f, 0.10363875f, -0.05146125f, 
    0.13829157f, 0.00397823f, -0.07293271f, 0.02584544f, 0.04195563f, 0.18627398f, -0.22073482f, -0.54638261f, 
    -0.05588838f, -0.17017627f, -0.19133531f, -0.12988225f, -0.13117808f, -0.00292546f, 0.26785883f, -0.06971362f, 
    -0.02141653f, -0.07042356f, 0.14083757f, -0.10336900f, -0.09447797f, -0.11253215f, 0.04429540f, 0.35006291f, 
    -0.11326040f, -0.43693563f, 0.05489014f, 0.11695722f, -0.04950241f, -0.03924952f, 0.03081645f, 0.11847542f, 
    -0.01275247f, -0.01912961f, 0.00908146f, 0.03151110f, 0.04802549f, -0.00208656f, -0.01919658f, -0.00511049f, 
    -0.00512008f, -0.05978411f, 0.05806874f, -0.03350056f, -0.01369407f, -0.00252091f, 0.00801893f, -0.03222165f, 
    -0.02333189f, 0.00045701f, -0.05850295f, -0.05947104f, 0.03910449f, 0.03313297f, 0.02536810f, -0.00352490f, 
    -0.05294950f, -0.02226561f, 0.03698690f, -0.03486180f, -0.03667802f, -0.05423597f, 0.01206199f, 0.02694192f, 
    0.02981511f, -0.05241727f, 0.04926085f, -0.02839550f, 0.04535567f, -0.01415077f, -0.05635374f, 0.02594144f, 
    -0.04981402f, -0.01265128f, 0.03381276f, -0.06188871f, 0.02870155f, -0.06426097f, -0.06301858f, -0.04505581f, 
    -0.02115162f, -0.01840034f, 0.01570906f, -0.00527703f, -0.03590840f, -0.01566131f, 0.04406042f, 0.04486051f, 
    -0.00171996f, 0.03792319f, 0.05400321f, -0.02833883f, 0.00511734f, -0.03015551f, -0.04642993f, 0.03186116f, 
    0.01916672f, 0.01304245f, -0.03453878f, -0.05560328f, 0.02888309f, 0.05316063f, -0.00552441f, -0.05531580f, 
    -0.06192577f, 0.01209562f, -0.03953794f, -0.01435243f, -0.02925683f, 0.04748172f, 0.04169746f, 0.03209556f, 
    -0.00576032f, 0.02084700f, -0.03020861f, 0.03369496f, -0.02229600f, -0.04994848f, 0.03659592f, 0.00472253f, 
    -0.01025173f, -0.05221263f, -0.02732670f, 0.01426337f, 0.05277792f, 0.01147282f, 0.01905035f, 0.01987824f, 
    0.02107317f, 0.00632177f, 0.04241586f, -0.01191351f, -0.05232658f, -0.04845884f, 0.04211519f, -0.05395791f, 
    -0.04984743f, -0.00010121f, -0.05710993f, -0.05214838f, -0.04492491f, 0.02314521f, -0.05854256f, -0.01124544f, 
    -0.04856631f, -0.01277070f, -0.01475472f, -0.04999705f, -0.03230510f, 0.02444270f, 0.05043570f, -0.02447300f, 
    -0.04344596f, -0.04786889f, -0.01497766f, -0.03285718f, -0.01657708f, 0.03752913f, -0.01757000f, -0.04632640f, 
    -0.03007857f, -0.02267117f, -0.01527522f, 0.00835265f, 0.00105867f, -0.01090099f, -0.03805862f, -0.05404118f, 
    0.00181150f, 0.03915330f, 0.04499597f, 0.02676941f, -0.02408122f, 0.01890842f, -0.00039881f, 0.03847866f, 
    -0.02515897f, 0.00226928f, -0.04610475f, -0.01576269f, -0.02929615f, 0.01163180f, -0.03896583f, -0.05912605f, 
    0.01914749f, 0.03345839f, 0.01436757f, 0.04199763f, -0.04357320f, 0.04859157f, -0.00712878f, -0.05042575f, 
    -0.06346495f, -0.04649059f, 0.04919134f, -0.06096981f, 0.02475264f, 0.02031660f, 0.02720803f, 0.03464573f, 
    0.04344221f, 0.02523329f, -0.02289597f, 0.03368830f, 0.05948048f, -0.02023668f, 0.03716296f, -0.02349362f, 
    0.04328020f, 0.04450550f, 0.00750277f, 0.01723660f, -0.00781174f, 0.00427867f, -0.04934284f, -0.03210429f, 
    -0.05160182f, -0.05294651f, -0.06567923f, 0.04598872f, -0.01220862f, 0.04279892f, -0.06752568f, 0.00434918f, 
    0.02143496f, -0.02347117f, -0.01811234f, 0.04039221f, -0.03684441f, -0.04988909f, 0.04006216f, 0.03962388f, 
    -0.04667290f, -0.04456998f, -0.02713809f, -0.04060877f, -0.03702575f, 0.02625760f, -0.06361392f, 0.03571771f, 
    -0.05351029f, -0.06179834f, -0.06025302f, -0.05104272f, 0.02255705f, 0.02100766f, 0.01585348f, -0.06448196f, 
    -0.02395759f, 0.03701001f, -0.04222264f, -0.00341558f, -0.02391136f, 0.05367551f, -0.00338037f, -0.01007659f, 
    -0.06506603f, -0.02382727f, -0.05713343f, -0.02115759f, 0.01894734f, 0.03908939f, -0.06435473f, -0.05611680f, 
    0.00346344f, -0.06440131f, 0.01031503f, -0.01551037f, 0.01508599f, 0.00668375f, 0.02530200f, 0.03175518f, 
    0.02044557f, 0.04458091f, 0.03110084f, -0.02882512f, -0.05042346f, 0.03948446f, -0.03927840f, -0.05367837f, 
    0.01384493f, -0.02442370f, 0.04703379f, -0.05103449f, 0.00778196f, 0.04507078f, 0.05598957f, 0.04576809f, 
    -0.00978210f, -0.04986953f, -0.02777984f, 0.03651363f, -0.04774865f, -0.05696222f, -0.02841856f, -0.04977334f, 
    0.02866913f, -0.02738325f, 0.03734246f, -0.01651934f, -0.02921675f, -0.03503644f, 0.03187468f, 0.01085432f, 
    -0.03525338f, 0.02708981f, 0.04156036f, 0.05442885f, -0.00287250f, 0.00599831f, 0.02809272f, -0.06295795f, 
    -0.04078723f, -0.03471665f, -0.00835230f, 0.00636804f, -0.01839844f, -0.04573583f, -0.00464819f, 0.00692136f, 
    0.03672764f, -0.05227368f, -0.04547097f, -0.03873167f, 0.01175045f, -0.02974805f, -0.02393511f, -0.02887123f, 
    -0.01833907f, -0.03473131f, -0.01702312f, 0.04118009f, -0.00484882f, -0.04854036f, 0.02081430f, -0.04149418f, 
    -0.05753164f, -0.06291647f, 0.04310752f, -0.03363584f, -0.00952029f, -0.03767235f, -0.03188565f, 0.03858931f, 
    0.04172542f, -0.00412390f, 0.03546435f, -0.00915385f, 0.01003150f, 0.03927109f, 0.01107359f, -0.05485673f, 
    -0.03345625f, -0.03098422f, -0.05307138f, 0.03727967f, -0.01764788f, -0.03801767f, 0.00872742f, -0.04730961f, 
    0.00923981f, -0.01631355f, -0.02053369f, -0.04465575f, 0.04771408f, 0.02784151f, -0.05029930f, 0.03742239f, 
    -0.04004744f, -0.00888529f, -0.03204051f, -0.06578234f, -0.01786093f, 0.00201917f, -0.00368308f, 0.04916647f, 
    -0.02068586f, 0.04277883f, -0.01442419f, -0.01567426f, 0.00816408f, 0.05020124f, -0.03896470f, 0.00752480f, 
    0.01209349f, -0.05324170f, -0.04621137f, 0.05215513f, -0.05330282f, -0.06417508f, -0.06283365f, -0.02356178f, 
    -0.01906849f, -0.04391300f, 0.03775540f, -0.01567178f, -0.03581565f, 0.04200132f, 0.04635580f, -0.05233171f, 
    0.01897633f, -0.03106982f, 0.01954992f, 0.02935566f, 0.00167311f, -0.03264631f, 0.01880013f, -0.01868293f, 
    -0.03940514f, 0.04448649f, 0.04930264f, -0.03185889f, -0.03477813f, -0.02135272f, 0.04641480f, -0.05337847f, 
    0.04453192f, -0.02682357f, -0.02318366f, 0.01790894f, 0.04201910f, 0.01763776f, 0.01857059f, -0.01948476f, 
    0.02484177f, -0.02351302f, 0.00079951f, -0.00321220f, 0.03944196f, -0.04503043f, 0.04609515f, -0.03686570f, 
    -0.01583080f, -0.01559874f, 0.03307856f, -0.05932000f, -0.01504780f, -0.00299911f, 0.04494279f, -0.05677057f, 
    0.01007083f, 0.00970639f, -0.05664189f, 0.03893119f, -0.02642134f, 0.02091198f, -0.00952767f, -0.01741707f, 
    0.03069238f, -0.05431715f, -0.03539183f, -0.02449130f, 0.04067126f, 0.05291650f, -0.05517665f, -0.04110520f, 
    -0.01837855f, 0.03178731f, -0.06095520f, -0.00073488f, 0.00459354f, 0.03471562f, -0.05753645f, -0.02633772f, 
    0.03236411f, 0.01382452f, -0.00515096f, -0.02053164f, -0.06005636f, 0.02556994f, -0.04024220f, -0.05441701f, 
    -0.03169397f, -0.02292602f, -0.01000744f, 0.05052733f, -0.04990270f, 0.00560366f, -0.06139517f, 0.03382067f, 
    -0.00621646f, -0.06241021f, -0.00867860f, -0.02781301f, -0.00741031f, -0.04008547f, 0.04235364f, -0.06126113f, 
    0.00539016f, -0.05734840f, -0.02865415f, -0.03270972f, -0.02289026f, 0.00908606f, -0.03046272f, 0.04154450f, 
    -0.06203179f, -0.01075962f, -0.03556640f, 0.04865365f, -0.00402119f, -0.02209174f, 0.02767115f, 0.03927187f, 
    -0.05307672f, -0.05188841f, -0.00586236f, -0.03028247f, 0.03316540f, 0.02131175f, -0.01656835f, -0.01143804f, 
    -0.00299963f, 0.04149985f, -0.01747087f, -0.04470283f, -0.05612278f, -0.05947205f, -0.03101475f, 0.00813384f, 
    -0.00765292f, -0.01333356f, 0.04965528f, 0.01544835f, 0.02499426f, -0.04427838f, -0.04491588f, -0.05649228f, 
    0.00120945f, -0.02180340f, 0.01208828f, -0.02993150f, -0.04273657f, -0.02575700f, 0.03586008f, 0.01118469f, 
    0.03114967f, 0.03399652f, 0.04369924f, 0.02582273f, 0.04868664f, -0.03498838f, -0.04043170f, -0.05580163f, 
    -0.00605572f, -0.01362515f, -0.04065953f, -0.04473462f, 0.03698824f, -0.01514760f, -0.04974587f, -0.06219288f, 
    -0.03399220f, 0.01425312f, -0.04640494f, -0.00815640f, -0.01886279f, 0.02821870f, 0.02991088f, 0.00141607f, 
    0.01927352f, -0.04007941f, 0.01493696f, 0.00143213f, -0.02031539f, 0.00527711f, -0.03743094f, -0.02435491f, 
    -0.04188050f, 0.02945457f, 0.00972957f, 0.03894830f, -0.02734554f, 0.03830862f, -0.03005056f, 0.00640359f, 
    0.00298987f, -0.04486451f, -0.00714139f, -0.01409033f, 0.01388588f, 0.04183611f, 0.03326373f, -0.00328111f, 
    -0.00470655f, -0.00546338f, -0.04327985f, -0.06219878f, 0.01917531f, -0.05175206f, -0.04416611f, 0.04474967f, 
    0.03624010f, -0.05899049f, 0.01444076f, -0.03013481f, 0.01873347f, 0.00985240f, -0.06492472f, 0.00475146f, 
    -0.02483348f, -0.05263666f, -0.06101594f, -0.01200315f, -0.01843914f, 0.03876615f, -0.02922323f, 0.03759285f, 
    -0.02590054f, -0.05690080f, 0.03788326f, -0.04657491f, -0.01638851f, -0.02380024f, 0.03054326f, -0.05733766f, 
    -0.02519243f, 0.03764179f, -0.02948029f, -0.01304528f, -0.01409307f, -0.04891698f, -0.02512829f, -0.00487940f, 
    0.04348395f, 0.05024543f, -0.00492630f, -0.04863553f, -0.01684961f, 0.03890382f, 0.03267602f, -0.01414125f, 
    0.01979497f, -0.01381629f, -0.03246615f, 0.01013163f, -0.05397317f, -0.02875707f, -0.03924668f, -0.01152597f, 
    0.03636145f, -0.00417194f, 0.04630518f, 0.04287215f, 0.01678482f, -0.06285671f, 0.04176311f, 0.02006406f, 
    -0.02839167f, -0.05038854f, 0.01892368f, -0.06187426f, 0.00161869f, 0.03591203f, -0.04513706f, 0.00516009f, 
    -0.02913877f, -0.04072197f, 0.04065070f, -0.04876261f, -0.04214839f, -0.00772796f, 0.00936297f, -0.06547920f, 
    -0.03568947f, -0.01374948f, 0.01991818f, 0.02103792f, -0.05814450f, -0.03880626f, -0.05086093f, -0.00987952f, 
    -0.02195104f, 0.01980626f, 0.01747607f, 0.02713245f, -0.05649434f, -0.02692046f, -0.03792202f, 0.00240754f, 
    0.02684961f, -0.01187841f, -0.04456003f, -0.05567843f, 0.04457535f, -0.00572376f, 0.03965360f, -0.00246585f, 
    -0.03260917f, 0.01299744f, 0.00339970f, -0.03637076f, -0.02043545f, -0.04856624f, 0.05473701f, 0.03320016f, 
    -0.02159193f, -0.05473417f, -0.00041192f, -0.02001016f, -0.05509238f, 0.03963233f, 0.04400454f, -0.02211680f, 
    -0.04159112f, -0.01585656f, -0.00279474f, 0.02465631f, -0.02533604f, 0.04303771f, -0.02903412f, -0.00838555f, 
    0.04224367f, 0.02110844f, 0.04745679f, 0.00568630f, -0.00726224f, 0.03489481f, 0.03247661f, -0.03719676f, 
    0.01041639f, 0.00678888f, -0.00363728f, 0.05269632f, -0.05968474f, -0.02450561f, -0.06368937f, -0.00602683f, 
    0.04490099f, -0.04567489f, 0.02853851f, -0.01900510f, -0.04157810f, 0.03645591f, 0.03862304f, -0.03290614f, 
    0.01114756f, -0.02211535f, 0.05402471f, -0.03363101f, -0.05501254f, 0.03634882f, -0.06345882f, -0.03872003f, 
    0.00082931f, -0.02559195f, 0.03531005f, 0.02660945f, 0.01644431f, -0.00587170f, 0.02642041f, 0.04994926f, 
    -0.02355049f, 0.04845434f, -0.02272203f, 0.00753793f, 0.05165286f, 0.00589670f, -0.04715727f, 0.01333526f, 
    -0.02806491f, 0.04462767f, 0.00902711f, 0.04059999f, -0.05793683f, -0.04771563f, 0.01045015f, -0.02672303f, 
    -0.04542740f, -0.02208011f, 0.04915617f, 0.01856589f, -0.06339716f, -0.01723314f, 0.02706069f, 0.00800557f, 
    0.02188630f, 0.05095344f, -0.05643329f, -0.02104422f, -0.02239339f, -0.02590634f, 0.01235917f, 0.05159499f, 
    0.05352160f, -0.02280314f, -0.05891180f, 0.05310586f, 0.03045225f, 0.00808874f, -0.00547764f, -0.04371323f, 
    0.03654046f, 0.03925309f, -0.04192555f, -0.03798506f, -0.02690873f, -0.00407155f, -0.01290869f, -0.04294289f, 
    0.04240058f, -0.05563163f, -0.05495988f, 0.04952555f, -0.05457282f, -0.02879974f, 0.01829625f, 0.03894153f, 
    0.00231800f, -0.00006095f, -0.01824063f, -0.02797445f, -0.02242800f, -0.01211859f, -0.03541528f, 0.03983706f, 
    0.03484774f, -0.06705742f, -0.04303101f, -0.01673869f, -0.04958510f, 0.03361543f, -0.00116657f, -0.01076851f, 
    -0.00799043f, -0.02753328f, -0.05225875f, 0.00686432f, -0.03479674f, 0.01808381f, 0.03643911f, -0.00415219f, 
    0.02923066f, 0.00211875f, -0.04747214f, -0.03255361f, -0.06329215f, 0.00488061f, -0.03578691f, 0.01275764f, 
    0.01583782f, -0.02992807f, 0.00711022f, 0.04836086f, -0.02187146f, 0.04115552f, -0.01944014f, -0.03597289f, 
    -0.00077091f, -0.02137336f, 0.02547086f, -0.04463890f, -0.05997100f, 0.01938008f, 0.01569985f, -0.03594099f, 
    -0.02472405f, -0.02297247f, 0.01667873f, 0.03239010f, -0.06010440f, -0.01979917f, 0.00932060f, 0.00020286f, 
    -0.05863212f, 0.04688941f, -0.02760837f, -0.05822377f, 0.03203902f, -0.06115983f, 0.02426866f, 0.04951468f, 
    -0.01316285f, -0.00584996f, 0.02881356f, -0.01904058f, 0.04543262f, 0.00062239f, 0.02704524f, 0.02605152f, 
    -0.02600604f, 0.02298215f, -0.01051590f, 0.02449120f, -0.06348215f, -0.01815099f, -0.00659670f, -0.00875378f, 
    -0.06308829f, 0.03935866f, 0.01316999f, 0.04687267f, 0.00744439f, 0.01570121f, 0.03940247f, -0.04629343f, 
    -0.32071093f, -0.30798146f, 0.03665409f, 0.20605318f, -0.11743036f, 0.00125042f, -0.05979488f, 0.13880987f, 
    -0.01656772f, 0.04237003f, 0.31728214f, 0.14532621f, -0.02649970f, 0.03635359f, 0.09284059f, 0.11729702f, 
    -0.04002586f, 0.11041656f, 0.02108107f, -0.39978763f, -0.20520012f, 0.04074681f, -0.07066314f, -0.03394521f, 
    0.06795553f, 0.03650462f, -0.04905488f, -0.37048280f, -0.26357651f, -0.05551370f, -0.11231066f, 0.15151070f, 
    0.10997576f, 0.15173343f, -0.52645540f, -0.10198063f, 0.16800089f, -0.07202179f, 0.12397254f, 0.09256721f, 
    0.12226794f, -0.20622444f, -0.18540263f, 0.21948162f, 0.03593834f, 0.19087318f, -0.05005177f, -0.11389533f, 
    0.03826749f, -0.05679667f, 0.00979433f, 0.09172802f, -0.21471198f, 0.04837465f, 0.08194005f, 0.19497773f, 
    0.03104552f, -0.03244838f, -0.06059361f, -0.01666793f, 0.25640523f, -0.13737200f, 0.16087098f, -0.18784811f, 
    0.35427350f, -0.30014613f, -0.04140623f, -0.09383404f, 0.12003180f, 0.21192451f, 0.07898823f, 0.11296351f, 
    -0.23115860f, -0.02507106f, -0.11679737f, 0.09565618f, 0.34182674f, 0.04226718f, -0.06250130f, 0.06497991f, 
    -0.18907553f, -0.32519594f, 0.04615997f, 0.03651028f, -0.16612788f, -0.08056406f, -0.26461866f, 0.14900121f, 
    -0.05222123f, 0.04420220f, -0.27793249f, 0.14507739f, 0.06695279f, 0.03089141f, -0.03900765f, -0.05450277f, 
    0.02702986f, -0.26940474f, 0.02528873f, -0.03474164f, 0.21555014f, -0.27982023f, -0.01764091f, -0.16910954f, 
    -0.07429092f, -0.26469341f, -0.01021114f, -0.01105622f, -0.57481062f, 0.21885920f, 0.00115067f, 0.04644847f, 
    0.09569370f, -0.08389223f, 0.08106234f, 0.16729888f, 0.03741813f, 0.33026254f, 0.02074171f, -0.04740010f, 
    -0.06786141f, -0.11501176f, 0.14183697f, -0.02275764f, -0.15750977f, 0.03145456f, 0.30083033f, -0.23610587f, 
    -0.27434215f, -0.07015891f, 0.12509087f, 0.08304367f, -0.21674351f, 0.15908396f, 0.09013468f, 0.33724585f, 
    -0.03551863f, 0.05850061f, 0.08871994f, 0.00416963f, -0.09531840f, -0.06271120f, -0.12169003f, -0.06720018f, 
    0.64471680f, 0.28779751f, 0.08964051f, 0.13601921f, -0.13291602f, -0.05754532f, 0.07701805f, -0.08197559f, 
    0.11056330f, -0.01434451f, -0.04063969f, -0.27407053f, -0.06862732f, 0.01235741f, 0.13528182f, -0.16824315f, 
    -0.01039636f, 0.17700687f, -0.17881580f, 0.00818423f, -0.16772321f, -0.23343965f, 0.06123191f, 0.02172278f, 
    -0.08908316f, -0.09939912f, -0.05639330f, 0.43085799f, 0.08397377f, 0.04582750f, 0.11919970f, -0.04234387f, 
    -0.03508705f, 0.07926284f, 0.03317119f, 0.09081291f, -0.00024987f, -0.41670302f, -0.21130016f, 0.03407433f, 
    0.12350535f, -0.11679696f, -0.09421153f, -0.03536757f, -0.09128144f, 0.49937946f, -0.24741384f, -0.15408775f, 
    0.13899384f, -0.17880842f, 0.06149612f, 0.12258185f, 0.18168831f, 0.12002460f, 0.18443124f, 0.34739295f, 
    -0.09366883f, 0.10203209f, 0.14177124f, 0.13566668f, 0.02685520f, 0.08492883f, 0.16895311f, 0.55135477f, 
    -0.10161042f, 0.02764436f, 0.07175376f, -0.04078771f, -0.08353592f, -0.12092794f, -0.02913126f, -0.06321500f, 
    -0.56690365f, 0.12699379f, -0.15140489f, 0.00525416f, -0.07810429f, 0.00577964f, -0.28333399f, 0.00121924f, 
    0.16157253f, -0.00267666f, -0.06775612f, 0.07497626f, 0.00699617f, 0.15682018f, 0.07127728f, -0.14549856f, 
    0.13890190f, 0.16358298f, -0.21760339f, -0.15085776f, -0.31044382f, 0.08919757f, 0.28003910f, 0.04387560f, 
    -0.11183592f, 0.02187381f, -0.06646556f, -0.12653804f, 0.05381357f, -0.13782828f, 0.18805912f, 0.04865207f, 
    0.07167950f, 0.17493623f, 0.20101678f, 0.00716495f, -0.30525044f, -0.02417009f, 0.22583929f, -0.00964260f, 
    0.14046918f, -0.10523709f, -0.26474288f, 0.14016280f, -0.06774522f, -0.10858051f, 0.07446768f, 0.03140783f, 
    0.21159366f, 0.03306304f, 0.10574244f, 0.00061472f, 0.08731911f, -0.01702292f, -0.30144200f, 0.04743303f, 
    0.07074814f, 0.18186957f, 0.23885320f, 0.09259701f, -0.18899632f, 0.28698629f, 0.12725255f, -0.07750399f, 
    0.28901476f, -0.12360207f, 0.00843751f, 0.05264053f, -0.09354360f, -0.10173268f, 0.03908610f, -0.19339480f, 
    -0.03428145f, -0.02541023f, 0.01125317f, 0.01984561f, -0.02794005f, -0.03364836f, -0.05818946f, 0.02056529f, 
    0.02986366f, -0.02166081f, -0.02521142f, 0.02164452f, 0.00113308f, -0.00502297f, 0.01341392f, 0.03522789f, 
    -0.06414623f, -0.00858591f, -0.05022231f, -0.01899479f, 0.01416580f, -0.05011506f, 0.00665075f, 0.01830258f, 
    -0.04631367f, 0.00838130f, 0.00994089f, -0.03398744f, -0.06529338f, -0.01839442f, 0.03820319f, 0.04421395f, 
    0.00305500f, 0.02978891f, -0.06203266f, 0.01778328f, 0.05106867f, -0.00209743f, 0.01779243f, -0.04553147f, 
    0.05097146f, 0.01312238f, -0.05261059f, 0.00850964f, -0.05514239f, -0.06381427f, 0.01992266f, 0.01631420f, 
    0.02856446f, -0.02678383f, 0.02711858f, -0.06261618f, -0.03855105f, -0.00548720f, -0.00125725f, -0.00929974f, 
    -0.02540648f, -0.03001319f, -0.05023254f, 0.04167876f, 0.01885886f, -0.03172693f, -0.04375230f, -0.05763631f, 
    -0.05663127f, 0.01210039f, 0.04326867f, -0.01033807f, -0.02096404f, 0.04634223f, -0.00480034f, -0.04277044f, 
    -0.02336474f, 0.02523243f, -0.00975391f, -0.02628692f, -0.01612128f, 0.04693324f, -0.02067501f, -0.05219662f, 
    -0.00388998f, -0.05635627f, -0.04052079f, 0.02911950f, 0.01512112f, -0.05110668f, 0.01874973f, -0.03648938f, 
    -0.04220461f, -0.02934065f, 0.01748987f, -0.06350760f, -0.06082902f, 0.01662345f, -0.02358353f, -0.03949117f, 
    -0.06485407f, -0.06034957f, -0.03444897f, 0.01286782f, 0.01542923f, 0.04946686f, 0.01182583f, -0.06200120f, 
    -0.06462541f, -0.01509184f, -0.00123981f, -0.03731610f, -0.01388313f, -0.01676113f, -0.01941738f, 0.02147092f, 
    -0.04798758f, 0.01262562f, -0.02347245f, -0.01269116f, -0.01411388f, -0.01444461f, -0.06137993f, 0.01926475f, 
    0.05129650f, -0.03753428f, -0.03246258f, 0.03203140f, 0.00939265f, -0.04311179f, 0.01061088f, -0.04109188f, 
    -0.00313194f, 0.01092599f, -0.02602862f, -0.00550581f, -0.00517291f, -0.06517812f, 0.04438217f, 0.00479545f, 
    -0.02911687f, -0.04780679f, 0.02483717f, -0.04706115f, -0.00988237f, 0.03635837f, 0.03310428f, 0.00920465f, 
    -0.04907788f, -0.06520970f, -0.05908739f, 0.03913628f, 0.03599623f, -0.00864787f, 0.04225010f, -0.01072635f, 
    -0.01562185f, -0.01740279f, 0.00173347f, 0.02843783f, -0.03041310f, 0.04461371f, -0.03944214f, -0.03940229f, 
    0.02286201f, -0.04141448f, -0.06387072f, 0.04460221f, -0.04553065f, -0.04780655f, 0.00092016f, 0.03906437f, 
    -0.03626514f, 0.00354236f, 0.03025880f, 0.05859055f, 0.00800242f, 0.01680923f, -0.03301979f, -0.03170658f, 
    0.03046339f, -0.03508372f, -0.05028468f, -0.05570146f, -0.00351593f, 0.00095139f, 0.02618238f, -0.03163223f, 
    -0.06321630f, -0.02037660f, -0.02321864f, -0.05255968f, 0.00033141f, -0.03578077f, 0.03520888f, 0.03633381f, 
    -0.00784191f, 0.01728548f, 0.02433694f, 0.05142156f, -0.00881676f, 0.03599046f, 0.04415983f, -0.03677042f, 
    0.00636528f, -0.01050604f, -0.06138958f, 0.04022138f, 0.01224630f, 0.04078421f, -0.03589096f, -0.01631977f, 
    -0.02212168f, -0.01895010f, -0.01681020f, 0.02102207f, -0.00639619f, -0.02524369f, 0.02530358f, -0.03626703f, 
    0.00635265f, -0.01231625f, -0.04790783f, -0.01879260f, 0.03551238f, -0.03432196f, -0.02497313f, 0.00380666f, 
    0.01418141f, -0.02989563f, 0.03497168f, -0.06342378f, -0.02141217f, 0.04400807f, -0.04642602f, -0.01275685f, 
    -0.05048449f, 0.04204820f, 0.04704807f, -0.05960048f, -0.04578220f, 0.00260784f, -0.05909711f, -0.02121627f, 
    0.00236882f, -0.04194202f, -0.01646888f, -0.03382009f, 0.03869095f, -0.02668161f, 0.01903542f, 0.02989459f, 
    0.04594592f, -0.04265980f, 0.01575242f, 0.03935676f, -0.03092500f, 0.01535903f, 0.00311300f, -0.05206829f, 
    -0.03536578f, -0.05056665f, 0.02186678f, -0.02196226f, -0.04643532f, 0.02299913f, -0.06441355f, -0.03324290f, 
    -0.03199324f, 0.04980497f, -0.01443826f, 0.01563985f, -0.05730368f, 0.01836923f, -0.03351710f, -0.00196431f, 
    -0.05471359f, 0.02037517f, -0.05323942f, 0.01239332f, -0.05051891f, 0.01898132f, 0.02417992f, 0.01557002f, 
    0.02865084f, -0.02678536f, -0.02678119f, -0.05234089f, -0.03489002f, -0.06578945f, -0.02051709f, -0.03940893f, 
    -0.00476928f, -0.11645099f, -0.02923740f, 0.11223599f, 0.16448633f, 0.05086336f, -0.08064865f, -0.16942011f, 
    -0.24925040f, 0.22227041f, 0.17845210f, 0.13751321f, 0.00380084f, 0.01624443f, -0.05799051f, 0.00333156f, 
    -0.09522904f, 0.12807646f, -0.08832850f, -0.35362098f, 0.10656186f, -0.14354239f, 0.08368823f, 0.09873247f, 
    -0.10388432f, 0.02912760f, 0.00547171f, -0.01244179f, 0.26215065f, -0.14367002f, -0.20615494f, -0.10678868f, 
    -0.08115618f, -0.10847943f, 0.02971169f, 0.31543660f, -0.03726015f, -0.11343592f, 0.01123462f, 0.03726222f, 
    0.07979857f, -0.08729807f, -0.11627355f, -0.01697922f, -0.18047260f, -0.07343899f, -0.02362086f, 0.29637805f, 
    0.06627244f, 0.02966287f, -0.02411749f, -0.04871013f, 0.14073259f, 0.14042546f, -0.00811365f, -0.23540035f, 
    0.01675875f, 0.25996554f, 0.02400521f, -0.10213176f, 0.05177959f, -0.17914024f, 0.01008774f, -0.09100492f, 
    0.10598200f, 0.01586035f, 0.18116781f, 0.17797047f, -0.07814114f, -0.08709350f, -0.01876345f, -0.06407750f, 
    0.04835759f, 0.11381018f, -0.09962029f, 0.08490124f, -0.00299235f, -0.03854459f, -0.06748474f, 0.07113349f, 
    0.16663623f, -0.30484378f, -0.14455748f, 0.13010675f, 0.31447312f, -0.14935447f, 0.00382898f, 0.02528270f, 
    0.08707348f, -0.17601918f, -0.16346334f, -0.06878638f, 0.25870311f, 0.15757498f, 0.02604190f, -0.09192467f, 
    0.21068162f, 0.18842274f, 0.08613753f, 0.14962468f, 0.06622534f, 0.19035332f, 0.02545057f, -0.01754945f, 
    0.22001375f, -0.08201718f, -0.03673060f, -0.05438609f, -0.19834524f, -0.05237675f, -0.19675899f, -0.09733294f, 
    0.07620633f, -0.11378965f, 0.11895572f, 0.12882392f, 0.08610626f, -0.02987851f, 0.09331530f, 0.12448365f, 
    0.01360016f, 0.04319864f, 0.02813968f, 0.08822545f, 0.10529974f, 0.06450813f, -0.22592846f, 0.05651400f, 
    -0.01811437f, 0.06100683f, 0.16797248f, 0.04059659f, -0.02961082f, 0.14523490f, 0.05505634f, -0.23461999f, 
    -0.24196993f, -0.03225965f, 0.05520913f, -0.12615967f, -0.17630729f, 0.10765719f, -0.01961216f, 0.01480118f, 
    -0.15560503f, -0.04184949f, -0.13650057f, 0.05992834f, -0.09599707f, -0.17782246f, -0.00054083f, 0.06275056f, 
    0.00410327f, -0.42110541f, 0.16254978f, -0.18490630f, 0.22313119f, 0.12177707f, 0.01927483f, 0.10090271f, 
    0.25154710f, 0.03292920f, -0.04857004f, 0.19713041f, 0.05980612f, 0.20154910f, 0.00305383f, 0.26829305f, 
    0.10461720f, 0.06970312f, 0.03331270f, 0.29429296f, 0.04756384f, 0.16172628f, -0.06332386f, -0.01600705f, 
    0.10828661f, -0.08324162f, -0.05411538f, -0.06990633f, 0.08981628f, -0.18556157f, 0.01599514f, 0.00299139f, 
    -0.01193567f, 0.09791972f, -0.12519963f, 0.01962826f, 0.02207853f, -0.66297495f, -0.13657331f, -0.60836095f, 
    -0.01297066f, 0.05254188f, -0.15364996f, -0.02752138f, 0.18830399f, -0.18714620f, 0.10638925f, -0.01528858f, 
    0.17198107f, 0.17325093f, -0.18509616f, -0.06915010f, -0.03748654f, 0.10410435f, -0.01705043f, -0.27071539f, 
    0.00510964f, -0.28647316f, -0.07831895f, -0.04756287f, 0.06332555f, -0.03966799f, 0.02967504f, 0.07754955f, 
    -0.04601049f, -0.16896451f, -0.21850429f, 0.06801281f, -0.09322253f, 0.13710043f, 0.07910334f, 0.03423383f, 
    -0.10011852f, -0.35615703f, 0.01743488f, 0.05754771f, -0.00511250f, 0.02992039f, 0.03204813f, -0.01504729f, 
    0.21457271f, -0.20520483f, 0.19187510f, 0.07127261f, 0.06124283f, -0.14813010f, 0.13816169f, -0.07862435f, 
    0.15175070f, 0.13261773f, 0.08074600f, 0.06685098f, -0.01201136f, 0.29587892f, 0.07496909f, 0.23385412f, 
    0.01859194f, 0.12484188f, -0.04769959f, -0.03693824f, -0.09866589f, -0.05625153f, 0.11534870f, 0.28361893f, 
    0.10768521f, 0.09340551f, 0.09130299f, 0.19253750f, 0.01389930f, 0.19040382f, -0.06566009f, -0.41957918f, 
    -0.22598171f, -0.02563045f, 0.02892316f, -0.07477076f, -0.01018183f, -0.03428467f, -0.03376752f, 0.11676119f, 
    0.03307816f, 0.13586973f, 0.11594594f, -0.00142773f, -0.03554327f, 0.05267216f, 0.04058914f, -0.20158869f, 
    0.25622788f, -0.03409945f, 0.19907798f, -0.25910869f, -0.12880655f, -0.14907300f, 0.17028151f, -0.04077258f, 
    -0.22171792f, 0.07690510f, 0.24046075f, -0.18904527f, 0.16841836f, 0.09211394f, -0.22637591f, -0.10400709f, 
    0.03889167f, 0.12731305f, 0.29982260f, -0.64503944f, -0.08962098f, 0.05434548f, -0.04311554f, 0.02532969f, 
    0.08292218f, -0.06398281f, -0.06793600f, -0.29411077f, 0.07435536f, -0.24317987f, 0.13605687f, 0.06366333f, 
    0.12980378f, 0.00358313f, -0.01398999f, -0.28178376f, 0.08414935f, 0.24648747f, 0.33254296f, -0.17257422f, 
    -0.00072560f, -0.17722586f, -0.21208532f, -0.06347079f, -0.51794571f, 0.06970135f, 0.01361520f, -0.10121899f, 
    0.15216574f, 0.19074084f, 0.05940782f, -0.13121705f, 0.03092948f, 0.40872088f, -0.02665586f, -0.14823626f, 
    0.12265317f, 0.07771471f, 0.07647800f, 0.03020974f, 0.00367533f, 0.08945225f, 0.06378325f, 0.13886133f, 
    0.14476973f, 0.11393240f, -0.14424886f, 0.23124950f, 0.21302903f, -0.24359253f, 0.19581442f, -0.31954649f, 
    -0.13650616f, -0.02226058f, 0.12026370f, 0.08317474f, -0.15758757f, 0.02380813f, 0.11523250f, 0.09073318f, 
    0.08504066f, -0.09773750f, -0.13090682f, 0.12016251f, 0.16342133f, -0.05163962f, 0.06812452f, -0.12350830f, 
    -0.13300946f, 0.07035061f, -0.01671816f, 0.05593524f, -0.18315242f, 0.03040308f, 0.03283427f, 0.12231083f, 
    0.14021726f, -0.16344208f, 0.06007025f, -0.15565382f, -0.31755999f, -0.08519837f, -0.01800655f, 0.03147607f, 
    0.16012889f, 0.04842706f, 0.16724525f, 0.06570686f, -0.08903332f, -0.03775270f, -0.00752269f, 0.14324132f, 
    -0.02902513f, -0.10265649f, -0.14067012f, -0.12246145f, -0.01111596f, -0.21208110f, 0.04439311f, -0.15104645f, 
    0.05261697f, -0.03899382f, -0.06419028f, -0.02039670f, 0.06163346f, 0.12557602f, 0.14803618f, 0.12629195f, 
    0.18556966f, -0.00280402f, 0.08288530f, 0.01587827f, 0.03982164f, 0.17972718f, 0.09633811f, -0.28792530f, 
    0.25263795f, -0.09199287f, 0.02188980f, -0.02049969f, -0.15929860f, -0.01363374f, 0.00506497f, 0.08134538f, 
    0.18800402f, 0.16471660f, -0.11270393f, -0.03839886f, -0.05948799f, -0.09775743f, -0.04160725f, -0.07318877f, 
    0.18964684f, 0.16416018f, 0.15396488f, -0.12455177f, -0.01465666f, 0.04372335f, -0.01538645f, -0.11629371f, 
    0.07877800f, -0.04971848f, -0.22069527f, 0.05189032f, -0.19956058f, 0.11837494f, 0.03480047f, -0.07432557f, 
    -0.01732403f, 0.09008376f, 0.12870695f, -0.05677244f, -0.06849875f, -0.16354096f, 0.00305583f, -0.17121853f, 
    -0.06869241f, 0.09294808f, 0.04701220f, -0.27780595f, -0.35632017f, -0.08656053f, -0.24237154f, 0.11490923f, 
    -0.21254224f, 0.06236546f, -0.02151318f, 0.11780985f, 0.07391227f, 0.11970406f, -0.14595780f, 0.24116874f, 
    0.08227520f, 0.01874464f, -0.01355644f, -0.03425338f, 0.14730097f, 0.01035519f, 0.25492871f, 0.52517158f, 
    -0.19945297f, -0.25931212f, -0.14317767f, 0.25781387f, 0.05995510f, -0.20286112f, 0.03627899f, -0.26297790f, 
    -0.03354778f, -0.20691349f, -0.07892672f, 0.02707612f, 0.06278197f, -0.00833265f, -0.06763474f, -0.07699914f, 
    0.33143839f, -0.04616277f, 0.05554761f, -0.09681978f, 0.02100977f, 0.25240722f, -0.28581142f, 0.05850147f, 
    -0.14785922f, 0.19267602f, -0.44752109f, 0.21963906f, 0.04640456f, -0.15205544f, 0.07605345f, 0.08112378f, 
    0.00107745f, -0.18417144f, 0.38060457f, 0.39115682f, 0.21249586f, 0.09257302f, 0.10039274f, 0.10778251f, 
    0.14741741f, -0.15723453f, 0.02319670f, -0.43884331f, -0.23848787f, 0.02940663f, -0.17422271f, 0.14033489f, 
    -0.13113227f, -0.01290399f, 0.04812420f, -0.32579589f, -0.39455038f, -0.01014264f, 0.21345863f, 0.04032888f, 
    -0.15811628f, 0.13719292f, -0.04266216f, 0.12705266f, 0.56725627f, -0.11212843f, -0.39818361f, -0.15496272f, 
    -0.16446143f, -0.11762926f, -0.02625472f, -0.04458904f, 0.04396008f, 0.21763279f, -0.00157391f, -0.41304857f, 
    -0.01919565f, -0.11147238f, -0.20630139f, -0.04205414f, 0.20490514f, -0.13577336f, 0.18508838f, -0.16973151f, 
    -0.12133484f, 0.05148041f, -0.07185107f, 0.14662561f, 0.03548134f, 0.04206597f, -0.03882619f, 0.35965636f, 
    -0.23906952f, 0.09210052f, -0.26104331f, 0.27901962f, 0.15410668f, 0.25669646f, -0.30744371f, -0.03483319f, 
    0.10619987f, -0.02678233f, 0.05526488f, 0.11222144f, 0.11620283f, -0.21008579f, 0.22147624f, 0.01812361f, 
    0.26153487f, 0.34927505f, 0.35743117f, 0.26363137f, -0.06611129f, 0.02431156f, -0.00977035f, 0.16435269f, 
    0.07354735f, -0.07017782f, 0.47224474f, 0.04865773f, -0.04024483f, 0.00189490f, 0.01577445f, -0.17709710f, 
    -0.11577928f, -0.00202283f, 0.08931719f, -0.31031784f, -0.34093547f, -0.21777864f, 0.14695050f, -0.10257851f, 
    0.21391945f, 0.17585105f, -0.00047259f, -0.33586439f, 0.02187169f, 0.05602316f, 0.10526909f, -0.19485472f, 
    -0.00979328f, -0.03467757f, -0.04974281f, 0.00533175f, 0.03863970f, -0.27884138f, -0.48446459f, -0.15696114f, 
    -0.35130730f, -0.00003477f, 0.21439230f, -0.12449513f, -0.02520971f, -0.24359411f, 0.18519031f, -0.13919607f, 
    0.04243229f, -0.09000533f, -0.18068165f, 0.15298931f, 0.04626892f, -0.07157586f, 0.03345288f, -0.03620786f, 
    0.25297865f, -0.00752618f, -0.08435626f, -0.10006347f, -0.10831404f, -0.24964319f, 0.01049954f, -0.07737820f, 
    0.19971517f, 0.15002295f, -0.00747304f, -0.15542474f, 0.00785195f, 0.16779158f, 0.28364030f, 0.14511243f, 
    0.07973232f, 0.31181112f, 0.05284962f, 0.08930933f, -0.17653893f, 0.04423909f, 0.26941252f, -0.29879332f, 
    -0.06443503f, -0.25596362f, -0.03717246f, 0.13431323f, -0.11240505f, 0.22365502f, 0.27171585f, 0.19793248f, 
    -0.05087447f, 0.18803407f, -0.08056895f, 0.07849064f, 0.23061232f, 0.03763328f, -0.07935136f, -0.11675186f, 
    0.24818355f, 0.16191624f, -0.03419957f, 0.03012189f, 0.00025321f, 0.16416460f, 0.17425545f, 0.07023741f, 
    -0.09179585f, -0.08700367f, -0.09631545f, -0.02218851f, 0.26859972f, -0.05172538f, -0.48785374f, -0.06817149f, 
    -0.18003073f, 0.09160219f, 0.10759597f, -0.20812126f, 0.04153576f, 0.00481325f, 0.01465278f, -0.06253835f, 
    0.04611298f, -0.36066115f, -0.18517919f, -0.09007270f, 0.03030857f, 0.03730373f, -0.01684159f, -0.02708543f, 
    0.03023446f, 0.25563622f, -0.09137470f, -0.12034763f, -0.01143833f, 0.07202264f, 0.00899826f, 0.07179250f, 
    -0.16350628f, -0.39588371f, 0.01263304f, -0.05313033f, -0.12677388f, 0.15246260f, -0.05222040f, -0.14062844f, 
    0.05970775f, 0.09396449f, -0.05350277f, -0.00633481f, -0.33368635f, -0.17778581f, -0.19428061f, 0.06826542f, 
    0.00369231f, 0.06912760f, 0.09293739f, -0.03203365f, -0.02175978f, -0.07977348f, 0.00203223f, -0.05678171f, 
    -0.08596862f, -0.00086968f, 0.00737841f, 0.20422028f, 0.62766802f, 0.12946691f, -0.16106042f, -0.10350397f, 
    0.04035004f, 0.04404382f, 0.01724040f, -0.12993950f, -0.18169917f, -0.18118678f, 0.12941535f, -0.00959428f, 
    -0.05593396f, -0.05954522f, -0.49977729f, -0.05132292f, 0.11062120f, -0.20005268f, 0.02560510f, 0.03664780f, 
    -0.09437991f, -0.21438532f, -0.08725242f, -0.18184367f, 0.06656467f, 0.28133836f, 0.34146157f, 0.31043106f, 
    0.14301160f, 0.33715528f, 0.14860894f, -0.12159459f, 0.16878927f, 0.15865287f, -0.08939563f, -0.33831173f, 
    0.12193982f, 0.11407439f, 0.04019429f, -0.03058000f, -0.05879666f, -0.00123545f, 0.04450098f, 0.09761564f, 
    -0.14035021f, 0.04205248f, -0.04666419f, 0.00770861f, 0.18888153f, -0.06564856f, 0.00338132f, -0.01218024f, 
    0.37026834f, 0.19298223f, -0.02553697f, -0.27080867f, -0.05709233f, -0.02272829f, 0.09337327f, -0.30508187f, 
    0.00956290f, 0.00921217f, 0.04840269f, 0.11590430f, -0.17885920f, 0.38069782f, 0.13839434f, -0.00799163f, 
    0.22957623f, 0.21482708f, 0.04706360f, 0.31474799f, -0.03564329f, -0.24381696f, 0.04481540f, 0.05838946f, 
    -0.04772155f, -0.13235927f, 0.04335891f, 0.18766274f, -0.17355788f, -0.10720847f, 0.05620592f, 0.16415848f, 
    0.03071387f, 0.09167437f, -0.01012484f, 0.01862886f, 0.07673141f, 0.13722533f, 0.32939732f, 0.14881039f, 
    0.19069664f, 0.04352500f, 0.14105295f, 0.25324401f, 0.26749417f, -0.00688838f, 0.13329890f, 0.17285442f, 
    0.06905255f, 0.10082582f, 0.07692231f, 0.00983260f, 0.11304603f, 0.02092680f, 0.18193983f, 0.10020860f, 
    0.23235288f, 0.23997755f, 0.19687809f, -0.03366800f, -0.04122139f, -0.07368966f, -0.06508379f, -0.46501765f, 
    -0.16551986f, -0.07640728f, 0.13605078f, 0.13458402f, 0.06218578f, -0.09848020f, 0.15544537f, -0.10016958f, 
    -0.04526121f, -0.36857495f, 0.00093133f, 0.46571526f, 0.02127186f, 0.01632620f, 0.22322537f, -0.17231473f, 
    0.07686812f, -0.03981867f, 0.37675646f, -0.28101814f, 0.13591799f, 0.13555110f, -0.00695762f, 0.05545082f, 
    0.04295580f, -0.12571625f, 0.08693954f, 0.27687570f, -0.06962761f, -0.26281148f, 0.20829839f, 0.03547412f, 
    0.03339674f, 0.01588960f, 0.12264766f, 0.23392436f, 0.00178182f, 0.30058461f, -0.15280533f, 0.02266491f, 
    0.01059376f, -0.20068417f, 0.00140195f, -0.02595471f, -0.02806894f, -0.04293475f, -0.00929057f, -0.48547211f, 
    0.18242481f, 0.16821140f, 0.10332499f, -0.09449518f, 0.04847034f, -0.03495304f, -0.03098853f, -0.08490178f, 
    -0.02394853f, 0.11438042f, 0.06735108f, 0.04478027f, 0.12965553f, -0.04089566f, 0.15968330f, -0.26848364f, 
    -0.07052847f, -0.24016792f, 0.04887648f, -0.05999059f, 0.15337755f, -0.02752828f, -0.00120496f, 0.08897136f, 
    0.16716288f, -0.31706515f, 0.27695146f, -0.25422174f, -0.07681871f, 0.13624971f, -0.09533501f, 0.02056657f, 
    0.07910977f, -0.88376403f, -0.14864963f, -0.33134454f, 0.00512784f, -0.10477495f, 0.18986163f, -0.01587222f, 
    -0.11070959f, -0.01179106f, -0.78052127f, -0.07261764f, -0.12657982f, 0.08089721f, 0.11785084f, -0.01263781f, 
    -0.05021021f, -0.09613295f, 0.02377639f, -0.36744478f, -0.11011190f, 0.28156072f, 0.17334923f, 0.06099561f, 
    -0.06742436f, -0.09119622f, -0.03048469f, 0.19621623f, 0.26317257f, -0.24524115f, 0.04669548f, -0.15298550f, 
    0.11133482f, -0.24689640f, 0.06873117f, -0.05415003f, 0.02843092f, -0.17227824f, 0.03673403f, -0.28459370f, 
    0.14161277f, 0.08586274f, 0.19805753f, 0.20985837f, 0.15340947f, 0.21470176f, 0.18707077f, 0.31794903f, 
    -0.14630070f, 0.01068793f, 0.05236010f, -0.11750963f, 0.07505661f, 0.06564986f, 0.08514323f, 0.23185156f, 
    0.15989561f, -0.13500969f, 0.00061736f, -0.02384645f, 0.19111723f, 0.01797483f, 0.17097433f, 0.02968126f, 
    -0.02855815f, -0.01767866f, -0.12512062f, 0.07601473f, 0.00823752f, -0.03695431f, -0.05934925f, 0.05368846f, 
    0.16287968f, 0.44333813f, -0.04190968f, -0.32541627f, -0.01789373f, -0.03306857f, -0.07051647f, 0.11859154f, 
    0.03421640f, 0.14785974f, -0.79884613f, 0.04633712f, 0.00742943f, 0.16861252f, 0.03376953f, -0.01638969f, 
    0.12046981f, 0.11983612f, -0.04549652f, 0.62826192f, -0.13837732f, 0.32549340f, -0.03620963f, -0.02911132f, 
    -0.31063232f, 0.15069655f, 0.02713646f, 0.17419422f, -0.25645545f, -0.17420764f, -0.44906253f, 0.09696064f, 
    0.02914722f, 0.12159956f, -0.20774497f, -0.01854652f, 0.09160836f, 0.02820903f, 0.33896109f, 0.03896401f, 
    0.12279029f, 0.18865725f, 0.02171325f, -0.09900022f, 0.15924235f, 0.13217616f, -0.14786635f, 0.06302796f, 
    0.23531309f, 0.03934848f, -0.10045438f, -0.20817700f, 0.05888647f, 0.08775301f, -0.03388356f, -0.20642605f, 
    0.26652420f, -0.23375882f, 0.04198752f, -0.15080030f, 0.08117084f, 0.14378154f, 0.08437593f, -0.03763536f, 
    -0.23586506f, 0.12597607f, -0.06032484f, -0.08047882f, -0.03012003f, -0.21976061f, 0.17891322f, 0.17393398f, 
    0.09260616f, -0.02276486f, 0.17187077f, 0.12027612f, 0.02519049f, 0.10558339f, 0.17053203f, -0.02602284f, 
    0.11759374f, 0.17838603f, 0.34647214f, -0.25531185f, -0.23764007f, -0.06277868f, -0.12512028f, -0.17798491f, 
    0.09555206f, -0.15061894f, 0.03895099f, 0.28469512f, -0.28650701f, -0.26273781f, -0.00901700f, -0.24941698f, 
    0.25142780f, 0.11238299f, 0.18317732f, -0.06297806f, -0.34643745f, -0.04425487f, -0.21970549f, 0.03219063f, 
    -0.19070388f, 0.09758603f, -0.11022463f, 0.03348712f, 0.05954304f, -0.16287242f, -0.40133539f, -0.03793546f, 
    -0.23127845f, -0.15011615f, -0.20496671f, 0.01965241f, -0.19649670f, 0.06865755f, -0.14122909f, -0.29080093f, 
    0.19657327f, 0.06659716f, -0.15124927f, 0.02414195f, -0.15301941f, -0.01870654f, -0.00804695f, -0.66978121f, 
    -0.10640735f, -0.05486586f, 0.19279949f, -0.02397721f, 0.05747991f, -0.08598704f, -0.15935712f, 0.06453133f, 
    -0.86335337f, -0.28721651f, -0.08652110f, 0.05394032f, 0.09490363f, 0.03521567f, 0.20065084f, -0.10974603f, 
    0.05661182f, 0.05473795f, 0.01325851f, -0.04056128f, -0.06097754f, 0.15141737f, 0.08223700f, 0.15794787f, 
    0.09410763f, -0.17423470f, 0.03010984f, -0.41632763f, 0.18773128f, -0.05092555f, -0.13145453f, -0.05156791f, 
    0.22062692f, -0.23957662f, 0.06038618f, 0.16289696f, -0.01667781f, -0.02069715f, -0.03741510f, -0.09175031f, 
    0.10617065f, 0.00771192f, -0.00957711f, -0.40236291f, -0.23737873f, -0.06984501f, -0.08325681f, 0.09478266f, 
    0.20250396f, -0.24549086f, -0.12977433f, -0.12595879f, -0.00304080f, 0.10241952f, 0.05810291f, 0.02088339f, 
    -0.13524918f, -0.15809788f, -0.02484131f, 0.09767296f, -0.16204770f, -0.14635171f, -0.01584937f, 0.08398336f, 
    -0.08504906f, 0.14142849f, 0.00135263f, -0.12985589f, 0.03539888f, 0.05397285f, -0.01407595f, 0.04548126f, 
    0.14634836f, -0.18907678f, -0.21396929f, -0.23970783f, 0.00783005f, 0.12584715f, -0.03615805f, -0.11865868f, 
    -0.07912762f, -0.10211137f, 0.18665206f, 0.12522000f, 0.00947440f, -0.00116469f, 0.04819627f, 0.06507011f, 
    0.13144855f, -0.16536793f, 0.02926437f, 0.16364025f, 0.00230012f, 0.07131385f, 0.07981264f, -0.04552783f, 
    0.01822314f, -0.04485993f, 0.14562902f, 0.16500844f, 0.02373507f, 0.08644871f, 0.01045175f, -0.25647411f, 
    -0.07073075f, -0.15186940f, 0.18434182f, -0.20667392f, -0.00216320f, 0.02022652f, -0.13175608f, 0.11602362f, 
    -0.11115309f, 0.03281015f, 0.09331702f, -0.28789353f, -0.02894419f, -0.01855420f, -0.10647571f, 0.08270494f, 
    0.01061545f, -0.01395150f, -0.21722797f, 0.13800623f, 0.21626210f, 0.15593402f, 0.14857243f, -0.07087001f, 
    -0.10914192f, -0.24065237f, 0.05685880f, 0.00668507f, -0.00308856f, -0.05240417f, 0.30115920f, -0.15538222f, 
    -0.11651635f, -0.06830072f, 0.01950157f, -0.08191541f, -0.05042036f, -0.23004334f, 0.06388267f, 0.12353278f, 
    0.10614319f, 0.24147145f, 0.03819522f, 0.01638773f, 0.02297225f, 0.05828996f, -0.39798900f, 0.01557780f, 
    0.19760424f, 0.24069752f, -0.07325829f, 0.19361994f, 0.02490317f, -0.03394965f, -0.04693700f, 0.09372156f, 
    0.08720933f, 0.16451576f, 0.14046142f, -0.39320749f, -0.05009510f, 0.00263098f, 0.06788237f, 0.07815122f, 
    -0.06513802f, -0.10137293f, -0.07790048f, -0.06572445f, -0.06715769f, 0.09277875f, -0.01860573f, -0.01670024f, 
    -0.00432955f, 0.07132041f, 0.06590487f, 0.47030976f, 0.05241511f, 0.03680455f, -0.02494047f, 0.00870813f, 
    -0.39852849f, -0.05508833f, 0.18811293f, 0.25806990f, 0.10205999f, -0.18603045f, -0.10181545f, -0.02869914f, 
    -0.24821608f, 0.08172603f, 0.05370300f, -0.01390361f, -0.49071270f, 0.27364811f, -0.40785033f, -0.11175824f, 
    0.07002615f, -0.30915380f, 0.11213589f, 0.03703462f, -0.03085939f, 0.15052690f, 0.14781794f, 0.43723986f, 
    0.24533357f, -0.09007004f, -0.05485571f, -0.32532722f, 0.03065471f, 0.16922131f, 0.00713456f, 0.29511645f, 
    0.00481130f, -0.08915540f, -0.03218352f, -0.09287661f, 0.25234535f, -0.04734702f, 0.29246947f, 0.04916584f, 
    -0.26380020f, 0.16540590f, -0.12638932f, -0.05319426f, -0.17950161f, 0.34035775f, -0.25167823f, 0.07862326f, 
    -0.01431676f, 0.11351802f, -0.58553773f, -0.26411304f, -0.01080129f, -0.14122410f, 0.08716655f, 0.05229999f, 
    0.10948268f, -0.15722713f, 0.05483913f, -0.02332927f, 0.10567471f, 0.02190149f, -0.01320393f, -0.07635000f, 
    -0.30982995f, 0.01315423f, 0.08488473f, -0.26531821f, 0.07349917f, 0.09279308f, 0.14361024f, 0.01843045f, 
    0.11809498f, 0.03728596f, 0.06162814f, 0.08503553f, -0.01920266f, -0.01496857f, 0.14103609f, 0.23066345f, 
    0.06961598f, -0.21203342f, -0.14901094f, 0.06155775f, 0.01114396f, 0.07658089f, 0.23678212f, 0.16736306f, 
    0.03623560f, -0.06350935f, -0.17867620f, -0.14021219f, 0.28083965f, 0.05431055f, -0.13519967f, 0.04972186f, 
    0.33851194f, 0.08214065f, 0.27705294f, -0.20892987f, 0.06058370f, 0.19435090f, 0.15897520f, -0.12751718f, 
    0.14645293f, -0.01255521f, 0.27094081f, -0.03825101f, -0.03956328f, -0.14213063f, 0.09864126f, -0.22427949f, 
    0.04782708f, 0.01954241f, -0.05825920f, -0.03789093f, -0.01145546f, -0.05097028f, -0.04005793f, 0.04726680f, 
    -0.01126236f, 0.02395126f, 0.01183455f, -0.01993800f, -0.05990394f, 0.03511205f, 0.04487501f, 0.04466504f, 
    -0.01302276f, -0.05822278f, -0.00218066f, 0.02783855f, 0.02265605f, 0.04053605f, -0.00007078f, -0.05929074f, 
    -0.05407989f, -0.04758773f, -0.01818100f, -0.00235675f, -0.05555902f, -0.00565842f, -0.03574146f, 0.03950626f, 
    0.01691127f, -0.02881554f, -0.02415729f, -0.01434338f, 0.02335386f, -0.01265943f, 0.00691047f, -0.02105304f, 
    0.01791125f, -0.05826706f, 0.03662909f, 0.02494645f, -0.01343274f, -0.00959601f, -0.06029239f, -0.04682527f, 
    -0.04711715f, -0.00277369f, -0.02803370f, 0.04484896f, -0.00250846f, 0.03223199f, -0.05423659f, 0.00242522f, 
    0.04690916f, 0.02566914f, -0.00812949f, -0.05804649f, 0.02489071f, -0.05382133f, -0.00312807f, -0.03823416f, 
    -0.06704064f, 0.01822923f, 0.02099454f, 0.05202512f, 0.02354675f, 0.01724978f, 0.04797409f, -0.04359675f, 
    -0.04229331f, 0.04490739f, -0.04932055f, 0.04573724f, 0.04048063f, -0.01484001f, -0.01549033f, -0.01051417f, 
    -0.03859459f, -0.01366317f, -0.04496520f, -0.04740997f, -0.05709531f, -0.00400232f, 0.01375722f, -0.00908531f, 
    0.04614338f, 0.01028255f, 0.04682966f, -0.00978085f, -0.01314961f, 0.00823954f, -0.04995238f, -0.01856341f, 
    0.00666272f, 0.02367124f, -0.00801152f, 0.01857658f, -0.00376585f, -0.00689753f, 0.00067767f, -0.03878187f, 
    -0.04772562f, 0.04196122f, -0.00714866f, 0.00873469f, -0.02745069f, 0.03694132f, 0.02614904f, 0.04552642f, 
    0.02707680f, 0.04334484f, -0.03547959f, -0.04965475f, -0.03695380f, -0.00201506f, 0.02739913f, 0.03474411f, 
    0.03231104f, -0.06392340f, -0.05786401f, 0.03010156f, -0.02832329f, 0.01667102f, -0.02677926f, -0.02729797f, 
    0.02436828f, -0.05389082f, 0.02470885f, -0.03794533f, -0.00888265f, 0.04899501f, 0.00412973f, 0.04173588f, 
    0.01338622f, -0.02925908f, 0.02692762f, 0.01246106f, 0.00791823f, 0.03187369f, -0.06053883f, -0.03584206f, 
    -0.00368940f, -0.00374665f, -0.01615713f, 0.03883653f, 0.01052676f, 0.04256137f, -0.00432203f, 0.00408107f, 
    0.00188837f, -0.04299706f, 0.01476776f, -0.03182817f, 0.04171070f, -0.02764659f, -0.04038111f, -0.05669352f, 
    0.01246458f, 0.02745840f, 0.03760012f, -0.03845463f, 0.04891440f, -0.02739060f, -0.04709058f, -0.00523408f, 
    -0.02134497f, -0.04371885f, -0.01615064f, 0.03298562f, -0.03718022f, 0.01497949f, 0.02329778f, 0.04180483f, 
    -0.01555996f, -0.04667672f, -0.06419994f, -0.00256914f, 0.04775349f, 0.00677020f, -0.04302744f, -0.03760738f, 
    -0.05713825f, 0.00371392f, 0.00804608f, -0.00392684f, -0.02808951f, -0.00804717f, -0.01067053f, -0.04535971f, 
    0.02670470f, -0.00087027f, 0.02722404f, 0.01295841f, 0.02620929f, 0.03257090f, -0.03329833f, -0.03325391f, 
    -0.04408307f, -0.02533125f, 0.02640661f, 0.02072169f, 0.03237384f, 0.03385157f, -0.03055714f, -0.04025601f, 
    0.02135466f, -0.02933099f, 0.02787124f, 0.04409571f, 0.04039054f, -0.03590153f, -0.05297071f, -0.02761360f, 
    -0.00536788f, -0.01497909f, 0.02782959f, 0.04516671f, -0.05895395f, 0.04840215f, -0.04627614f, 0.01127787f, 
    -0.03320963f, -0.02879335f, -0.03558837f, 0.01814782f, 0.01741668f, 0.04932310f, -0.00156412f, -0.06301650f, 
    -0.04708450f, -0.04233871f, 0.02427840f, 0.01716628f, -0.00956982f, -0.00463455f, -0.05074477f, -0.02659896f, 
    -0.05346631f, -0.00644971f, -0.05997735f, 0.00299414f, -0.04392248f, 0.02800638f, -0.00792778f, -0.04229456f, 
    0.00317455f, -0.03200117f, -0.03887657f, 0.02785615f, -0.06376690f, -0.00395986f, -0.00227039f, -0.05351893f, 
    -0.02873074f, -0.02278964f, -0.01060362f, -0.01718417f, -0.07062444f, 0.02035922f, -0.01816070f, 0.02099311f, 
    -0.02675784f, -0.00837116f, -0.01422598f, -0.00968136f, -0.05188946f, 0.04150167f, -0.00276285f, 0.00275707f, 
    -0.04947817f, -0.04212515f, -0.05476779f, -0.03251323f, -0.01036450f, -0.00733734f, -0.01154994f, 0.04429033f, 
    0.00083289f, -0.05878948f, -0.04751967f, -0.01101278f, -0.06542130f, -0.03500282f, 0.03746999f, 0.00823134f, 
    -0.04540606f, 0.01949092f, -0.04554489f, -0.01806472f, -0.00044855f, 0.01118035f, -0.03032964f, 0.03212262f, 
    -0.04856866f, -0.05685810f, 0.04405584f, -0.04034277f, -0.04325006f, 0.02816954f, -0.00984537f, -0.02943588f, 
    0.04844418f, 0.00946203f, -0.00774170f, 0.03959700f, 0.00730361f, 0.03209342f, 0.02808484f, 0.01445469f, 
    0.03233895f, -0.03789298f, 0.03310865f, 0.03679717f, -0.05690501f, -0.03439029f, -0.01982522f, 0.00346262f, 
    -0.04076509f, -0.04299428f, -0.01132200f, 0.03476807f, 0.04419552f, 0.02938536f, -0.01244573f, 0.00831482f, 
    0.02739494f, 0.00131762f, -0.02843913f, -0.05273793f, -0.02196123f, -0.00297997f, -0.00265109f, -0.05420304f, 
    0.02493247f, 0.05377758f, -0.00953570f, -0.04233943f, 0.02682956f, -0.02018555f, 0.04044806f, -0.00037480f, 
    -0.06503455f, -0.00586901f, 0.02605278f, 0.04279073f, -0.00781543f, -0.01958220f, 0.03812835f, 0.02002406f, 
    -0.05677687f, -0.00869303f, 0.01837802f, 0.04577684f, 0.00087103f, -0.06379579f, -0.03925923f, -0.01218360f, 
    -0.01986791f, 0.01353774f, 0.03438369f, -0.05328339f, 0.04705674f, -0.00234533f, 0.03827725f, -0.00206829f, 
    -0.00430880f, -0.00440447f, 0.06546528f, 0.02483497f, -0.05316429f, -0.02604135f, 0.01163396f, -0.06171260f, 
    0.00991323f, -0.00969053f, -0.03132622f, -0.03229561f, 0.05266299f, -0.04082486f, -0.03954757f, -0.02384204f, 
    -0.06323483f, -0.00090447f, 0.04050691f, -0.02871693f, 0.03610887f, -0.05679873f, -0.04961367f, -0.01316188f, 
    -0.01419361f, 0.04286008f, -0.04297053f, 0.04750382f, 0.02308028f, 0.01482348f, -0.03700734f, 0.03817414f, 
    0.04020058f, -0.02772676f, -0.00888605f, -0.04847044f, -0.01839650f, 0.02207231f, -0.04607872f, 0.00073291f, 
    -0.03271755f, -0.03444015f, -0.00494816f, 0.01227447f, -0.04724424f, -0.01302810f, 0.01909030f, 0.02001069f, 
    0.03742208f, 0.04441690f, -0.04657729f, 0.02651361f, -0.00833506f, -0.03021954f, -0.06899883f, -0.02836476f, 
    -0.01877949f, -0.00191868f, -0.00525837f, 0.04025063f, -0.00440521f, -0.01763198f, -0.01929850f, 0.03352927f, 
    -0.05999710f, -0.02082120f, 0.04464709f, -0.04433090f, 0.02273824f, 0.02191248f, -0.01009793f, -0.04963883f, 
    -0.02190976f, 0.03911819f, 0.04115378f, -0.05055311f, -0.00734355f, 0.04475996f, 0.03351074f, 0.01610046f, 
    0.00943746f, 0.04112403f, 0.05329469f, -0.04856714f, 0.02883534f, 0.04791124f, 0.03273960f, -0.04764398f, 
    -0.01867322f, 0.00451971f, 0.00824291f, -0.04284690f, 0.02104728f, -0.04108758f, 0.00665791f, 0.00807747f, 
    -0.03246500f, 0.04680111f, -0.04369829f, 0.04922898f, 0.05496623f, 0.00932966f, 0.04020024f, -0.03956999f, 
    -0.03816726f, 0.04070843f, -0.00593997f, 0.04781513f, 0.01233419f, -0.00796136f, -0.04605269f, -0.05247115f, 
    -0.06625821f, 0.02243499f, -0.01336519f, 0.01192988f, -0.00150507f, 0.01670631f, -0.04357367f, -0.00718516f, 
    0.04073939f, 0.03485609f, 0.00901121f, 0.03984221f, -0.05051277f, -0.02336254f, 0.02104052f, -0.04220186f, 
    -0.01107688f, -0.03306562f, 0.00156634f, -0.01094887f, -0.00772111f, -0.03142660f, -0.04278914f, -0.00021380f, 
    0.00102266f, 0.02792441f, 0.01847200f, -0.03155227f, -0.06006044f, 0.05331981f, -0.00939210f, 0.01926061f, 
    -0.04222269f, -0.02309684f, -0.04865107f, 0.01856389f, 0.03611272f, -0.00215804f, -0.03097249f, -0.00097575f, 
    -0.05484443f, -0.05319251f, -0.02395013f, 0.00853372f, -0.03792071f, 0.04783141f, -0.02668898f, -0.01054023f, 
    0.00242974f, -0.02472662f, -0.05288422f, 0.03141621f, -0.06804328f, -0.00637927f, -0.00101375f, 0.03341839f, 
    -0.03576864f, -0.03075338f, 0.03759662f, 0.04345515f, -0.00407579f, -0.06015352f, -0.06680653f, -0.02328783f, 
    -0.06406139f, 0.04486349f, -0.04665558f, 0.01256066f, -0.00046252f, -0.05498858f, 0.03259740f, 0.03020073f, 
    0.01262476f, -0.02749520f, -0.04424482f, 0.03706716f, -0.07047234f, -0.02575492f, 0.00546140f, -0.05900761f, 
    -0.04072215f, -0.03344342f, -0.00240309f, -0.05638124f, 0.04862365f, 0.00189271f, 0.01484504f, 0.00386903f, 
    0.02341392f, -0.01259958f, 0.03650513f, 0.01470484f, -0.02349977f, 0.02084569f, -0.00883279f, -0.01697773f, 
    -0.24702866f, 0.05004092f, 0.04245191f, 0.30117211f, 0.17550580f, 0.06029334f, 0.07520326f, 0.11768035f, 
    -0.13017352f, -0.49136689f, -0.08706638f, -0.00470059f, 0.20556401f, 0.01083718f, 0.04753297f, 0.01980289f, 
    -0.13251191f, -0.06212892f, -0.03949632f, -0.26484981f, -0.14145936f, -0.07994215f, -0.01099293f, -0.06861338f, 
    -0.26001990f, 0.03329919f, 0.06517062f, 0.07171053f, -0.12636483f, 0.01467919f, -0.03468563f, -0.08004463f, 
    -0.21272391f, 0.06225687f, 0.15449239f, -0.09020223f, -0.54832971f, -0.18677188f, 0.18809956f, -0.04932144f, 
    -0.00306883f, 0.10157376f, 0.07568347f, -0.10894714f, -0.17663397f, -0.01947980f, 0.21431713f, 0.18116996f, 
    -0.31967762f, -0.12783353f, -0.05155055f, -0.10626178f, 0.10860829f, 0.22016039f, -0.40213966f, 0.22271903f, 
    0.26940966f, -0.01102865f, 0.07289459f, 0.03141895f, -0.22576801f, 0.04827020f, -0.19983250f, 0.00742490f, 
    -0.20393287f, -0.08424940f, 0.16249903f, 0.03604331f, 0.08948991f, -0.02857043f, 0.01592902f, -0.09812976f, 
    -0.19428900f, 0.12624918f, -0.04529469f, 0.37198892f, 0.11624726f, 0.12699272f, 0.18646824f, -0.04913624f, 
    -0.30368793f, 0.48980346f, -0.18007028f, 0.01567374f, -0.34238052f, -0.03132249f, -0.12088234f, 0.01296212f, 
    0.15086442f, 0.03369912f, 0.27689615f, -0.28685552f, 0.19124906f, 0.20267546f, 0.11349636f, 0.00058948f, 
    -0.11620605f, -0.02301398f, -0.02866687f, -0.39380375f, -0.12612113f, 0.18674268f, 0.30592817f, 0.06202865f, 
    0.08905166f, 0.04088100f, 0.05325519f, 0.05229133f, 0.03294560f, -0.19184674f, 0.11379047f, 0.11692481f, 
    -0.04407490f, 0.01108541f, 0.05361034f, 0.02430558f, -0.33136156f, 0.04889530f, 0.13814160f, 0.32485011f, 
    -0.22900212f, 0.01020826f, -0.03314547f, 0.14146197f, 0.08549873f, 0.19396280f, -0.24636205f, 0.16956684f, 
    0.17541097f, 0.21984805f, -0.26378661f, 0.07482289f, 0.20601431f, 0.16452000f, 0.04032697f, -0.25761259f, 
    0.07680523f, -0.02336578f, 0.15904082f, -0.08251759f, 0.13139504f, -0.13059807f, 0.10588999f, -0.10425510f, 
    -0.08080549f, 0.15672240f, 0.35748020f, -0.02645140f, -0.15829498f, -0.00217391f, -0.27052361f, -0.00561939f, 
    -0.11809066f, -0.67440659f, 0.12839884f, 0.10530325f, 0.34411946f, -0.12050027f, 0.08394068f, 0.13768111f, 
    0.35255194f, -0.13472673f, -0.07447878f, -0.41382843f, 0.15175109f, -0.17009251f, -0.10470770f, -0.09401443f, 
    0.00083829f, 0.24606431f, 0.12251070f, -0.22155237f, -0.21196711f, 0.05325340f, 0.24938290f, -0.00160893f, 
    0.10064975f, 0.02006588f, -0.25902486f, 0.12542340f, 0.10433834f, 0.17817071f, 0.15926583f, -0.27243844f, 
    -0.10695532f, -0.14494401f, 0.00512645f, 0.13137481f, 0.16815728f, -0.13974519f, 0.23555876f, 0.10987126f, 
    -0.00074048f, 0.19241242f, -0.05647067f, 0.02043949f, -0.00069352f, 0.11724027f, 0.12366521f, 0.15208811f, 
    -0.24697269f, 0.07144083f, 0.12583941f, 0.06905738f, -0.04853592f, -0.11169188f, 0.25308999f, -0.20427084f, 
    -0.04852660f, 0.34746447f, -0.01924770f, 0.05903447f, 0.11447473f, -0.26200795f, 0.04458753f, 0.04167039f, 
    0.34144244f, -0.09831915f, 0.41919076f, -0.22782463f, -0.17966123f, 0.04501321f, 0.05010788f, 0.21242143f, 
    -0.10056271f, 0.03865214f, 0.03873818f, -0.04815142f, -0.04180875f, 0.22329780f, 0.18702419f, 0.24827369f, 
    -0.26154825f, -0.00353554f, 0.28563929f, 0.00739362f, -0.26057941f, 0.31445533f, 0.00697994f, 0.18956065f, 
    -0.08845667f, -0.00607257f, 0.15244259f, -0.52831018f, -0.14767873f, 0.10333295f, 0.11639909f, -0.02181146f, 
    -0.11497366f, -0.12914711f, 0.10199355f, -0.16124859f, 0.60129231f, -0.02735622f, 0.01295929f, 0.30262390f, 
    0.09444527f, 0.29596421f, 0.12005780f, -0.02494927f, 0.07325270f, 0.18007344f, -0.22223859f, -0.49843690f, 
    0.22222991f, 0.10665350f, 0.19143258f, 0.18753688f, -0.18048996f, 0.27690336f, 0.00744382f, -0.09109798f, 
    -0.00916495f, 0.16385853f, -0.02329991f, 0.16207777f, -0.13026936f, -0.09596996f, -0.02899668f, -0.42717633f, 
    -0.19845806f, -0.19115189f, 0.07204029f, -0.05052511f, 0.08166564f, -0.02525606f, -0.24942033f, -0.24536094f, 
    0.22717220f, 0.17916965f, -0.33430326f, -0.24853219f, -0.00539078f, 0.18651775f, 0.19305171f, -0.00124344f, 
    -0.15190324f, 0.24934027f, 0.23101756f, -0.29916126f, 0.04602368f, 0.15094607f, -0.00365795f, 0.13021055f, 
    0.18133728f, -0.23246326f, 0.36320391f, -0.60673165f, 0.34026417f, -0.18070924f, 0.21108094f, -0.01856520f, 
    0.16369165f, 0.21837115f, -0.14516203f, -0.26016647f, -0.03117398f, -0.24254467f, -0.08968815f, -0.28283751f, 
    -0.04079501f, -0.10557239f, 0.01730493f, 0.25243977f, -0.41243881f, -0.06392234f, -0.08917349f, 0.17252019f, 
    0.22671424f, 0.15491650f, -0.18948929f, 0.15955761f, -0.00718316f, 0.17052038f, -0.15067415f, -0.04693170f, 
    -0.08695301f, 0.19676973f, -0.01225114f, -0.19060791f, 0.06835869f, -0.07118198f, -0.06477275f, -0.10417208f, 
    0.08921022f, -0.12488763f, -0.14800060f, 0.02419221f, 0.00470781f, 0.11697534f, 0.02787898f, -0.49706084f, 
    -0.30663696f, -0.24735764f, -0.12470996f, -0.00869630f, 0.12463173f, 0.04249237f, 0.02214474f, -0.00523501f, 
    0.25299507f, 0.36409438f, -0.39029357f, 0.20847572f, -0.04787436f, 0.00707159f, -0.04206644f, -0.09913943f, 
    -0.14633504f, 0.12256928f, -0.18860567f, -0.03486187f, -0.03263342f, 0.14348982f, 0.08166557f, 0.20104355f, 
    0.07468292f, -0.10862614f, 0.13193278f, -0.21756770f, -0.10581808f, 0.24380909f, 0.02283693f, 0.12766096f, 
    0.16785063f, -0.03018829f, -0.06464873f, -0.66811073f, -0.27606806f, -0.17837405f, -0.14661130f, 0.00584153f, 
    0.13273859f, 0.03551022f, -0.13254692f, 0.10105676f, -0.81670713f, 0.30239704f, 0.32221946f, -0.06245230f, 
    0.03679764f, 0.08864805f, -0.18686919f, 0.06695927f, -0.03741280f, 0.24217123f, 0.03051852f, 0.08057818f, 
    -0.12727165f, -0.03241664f, 0.10907112f, 0.00153181f, 0.25198171f, 0.15885012f, -0.10955009f, -0.25480878f, 
    0.19304463f, -0.32380348f, 0.09984167f, 0.04856117f, 0.06216121f, 0.21135297f, -0.11860268f, 0.04019593f, 
    0.14491065f, 0.06061996f, -0.17008042f, 0.03334486f, -0.02102096f, 0.19348563f, 0.08572610f, -0.08946228f, 
    0.13004655f, 0.14581995f, -0.14293931f, -0.17229900f, -0.17547846f, 0.00279350f, -0.30490336f, -0.10452406f, 
    0.02807474f, 0.05562419f, 0.08424285f, 0.21507873f, -0.40474567f, -0.04902211f, 0.06320485f, 0.03289719f, 
    0.26148614f, -0.00891016f, -0.28123239f, 0.01643397f, -0.24106559f, 0.12482208f, 0.10104413f, 0.16962650f, 
    -0.17832066f, -0.03815947f, 0.00502997f, -0.31033584f, -0.45766014f, -0.09646615f, 0.10421918f, 0.06757648f, 
    -0.07277345f, 0.03516911f, -0.18739700f, -0.03547020f, 0.00797253f, 0.05603236f, -0.30081609f, 0.02408495f, 
    0.11596736f, 0.02486644f, -0.00880317f, 0.05286479f, -0.16512434f, 0.03351455f, 0.08709738f, 0.05516204f, 
    -0.05738745f, -0.36149904f, 0.17367396f, -0.05219591f, 0.03353722f, 0.09282175f, -0.24977817f, 0.31573451f, 
    -0.59233010f, 0.09354724f, -0.14843579f, 0.04830139f, 0.24561994f, 0.03920272f, 0.04425300f, -0.43647063f, 
    -0.01828532f, -0.21183048f, -0.24096358f, 0.08685417f, -0.21902533f, -0.12024979f, 0.02756940f, 0.01829504f, 
    -0.16705222f, 0.07691646f, -0.11505900f, 0.01030723f, 0.14755976f, -0.06318776f, 0.32367262f, 0.19976249f, 
    -0.19044138f, -0.04180069f, 0.18965578f, 0.08613824f, 0.08378730f, 0.05812801f, 0.16274378f, 0.03420513f, 
    0.12100547f, 0.08494216f, 0.51914889f, 0.25080627f, -0.18834326f, 0.08286443f, 0.14935784f, -0.02539240f, 
    0.03768136f, -0.14764249f, -0.00042431f, -0.46794564f, -0.29824734f, -0.36957964f, 0.07198381f, 0.16311769f, 
    0.06411973f, -0.03544817f, 0.11386235f, -0.05854081f, 0.95260429f, 0.23473603f, 0.08407879f, 0.12245200f, 
    0.14318670f, -0.04540887f, -0.02066021f, -0.05040643f, -0.15499827f, 0.17596787f, 0.04137751f, 0.13820291f, 
    0.17407529f, 0.07457480f, 0.05828070f, -0.04930317f, 0.00588407f, -0.21190314f, 0.06166098f, 0.34175706f, 
    -0.15327685f, 0.09719567f, 0.12909362f, 0.11809319f, 0.24153148f, -0.12894225f, 0.13584821f, 0.17583284f, 
    -0.30334207f, -0.06439751f, 0.04904758f, 0.02636660f, 0.03119553f, -0.11946347f, -0.16113874f, -0.26511049f, 
    -0.60942483f, -0.40625942f, 0.09804925f, 0.09740704f, 0.13265987f, -0.23711625f, 0.23846133f, -0.14144465f, 
    -0.02931388f, 0.20996515f, 0.27714059f, 0.05678667f, -0.16147751f, -0.03209403f, 0.19757962f, -0.04122671f, 
    0.07922582f, -0.03028818f, 0.06598020f, -0.03263341f, -0.12580711f, 0.22585049f, -0.02477936f, 0.00543478f, 
    -0.01393742f, 0.13287479f, 0.25652027f, 0.17503518f, 0.16572055f, -0.17237440f, -0.24792559f, -0.17216119f, 
    0.06902727f, -0.24299523f, 0.04246989f, 0.07400223f, -0.14511265f, -0.32154340f, -0.13171324f, -0.19209732f, 
    -0.12318576f, -0.19995429f, -0.08463950f, 0.02523154f, -0.13272575f, -0.14642808f, -0.07672291f, 0.09111638f, 
    0.17752053f, 0.09342353f, 0.17624581f, -0.23969933f, -0.17332755f, 0.09190669f, -0.11186583f, -0.35676196f, 
    -0.08988956f, 0.25217992f, 0.07696678f, 0.01147739f, 0.04239686f, -0.02457995f, 0.16350277f, 0.11471387f, 
    -0.01402188f, -0.06095884f, 0.01314197f, -0.21449664f, 0.07576693f, -0.11987734f, 0.06339578f, -0.05083661f, 
    0.16549617f, 0.10331660f, -0.02722231f, -0.10593157f, 0.07536963f, 0.03203769f, -0.06716874f, 0.07189713f, 
    0.17136151f, 0.13603872f, -0.17649929f, 0.03706153f, -0.01774098f, -0.08701611f, 0.07143272f, -0.07080253f, 
    -0.14881764f, -0.10851207f, 0.04763233f, 0.10635964f, 0.04722943f, 0.04725183f, 0.12550817f, 0.01020590f, 
    0.06240340f, 0.23746824f, -0.19484191f, -0.00541906f, 0.08293021f, 0.21366687f, -0.08589678f, 0.07688756f, 
    0.04409554f, -0.15013990f, 0.03696591f, -0.02848332f, -0.02222538f, 0.16109648f, -0.13563034f, -0.10146269f, 
    -0.04887202f, -0.19910425f, -0.01705602f, -0.03689662f, 0.11689793f, 0.09717911f, 0.00981001f, 0.16161489f, 
    0.10275722f, 0.07163677f, 0.16697490f, -0.11277866f, -0.08367728f, -0.03848549f, -0.40453792f, -0.02335824f, 
    -0.13221353f, 0.07369615f, 0.02071848f, -0.03604151f, 0.08006407f, -0.09919675f, 0.06652035f, -0.44773793f, 
    -0.06664924f, -0.01183606f, 0.01936634f, -0.00705923f, -0.07374294f, 0.03788972f, 0.02976188f, 0.05237734f, 
    -0.55939436f, -0.09894079f, -0.03662205f, 0.05013217f, 0.00647245f, -0.09157152f, -0.02935020f, -0.17580232f, 
    -0.10655224f, -0.53234333f, -0.06773651f, -0.53577119f, 0.15272294f, 0.12225355f, 0.04922125f, 0.12422561f, 
    0.08901466f, 0.29922113f, 0.07690106f, 0.11033131f, -0.10638314f, 0.01545555f, 0.15233007f, 0.16312954f, 
    0.05589817f, 0.02881135f, 0.10432838f, 0.27221420f, 0.21339424f, 0.09098109f, -0.00711125f, 0.01813228f, 
    0.11324312f, -0.07618397f, -0.00478275f, -0.02662811f, 0.14246649f, 0.11169589f, 0.30085987f, 0.04720405f, 
    -0.14509109f, 0.02609193f, -0.17150076f, 0.20392615f, -0.14431529f, -0.64790595f, -0.70836401f, -0.38694432f, 
    -0.02092286f, -0.08998473f, 0.11067202f, 0.06136063f, 0.11540253f, -0.05207425f, 0.04782844f, 0.15099356f, 
    0.28037992f, 0.07757821f, -0.00941489f, -0.42533061f, -0.03599522f, 0.09841266f, -0.08210448f, -0.65047240f, 
    -0.01351416f, -0.15310068f, 0.10002028f, -0.15192479f, 0.08527850f, -0.00939889f, -0.02096559f, 0.01482072f, 
    -0.06377656f, 0.07758484f, -0.17704034f, -0.06546001f, 0.00991639f, -0.17964980f, -0.00124122f, -0.04671042f, 
    -0.08511560f, -0.45888370f, -0.45591414f, -0.07060502f, 0.16904432f, -0.02222600f, -0.02049801f, -0.12581019f, 
    0.07019327f, 0.07140321f, 0.43731606f, 0.14370809f, -0.18365745f, 0.11631112f, 0.14603457f, -0.14129192f, 
    0.04350400f, 0.07036121f, 0.25204945f, 0.08623575f, 0.17251424f, 0.11220120f, -0.10553245f, 0.12043187f, 
    0.02546871f, 0.13204569f, 0.21900776f, 0.22217509f, 0.15266421f, -0.06314265f, 0.02519415f, -0.01719629f, 
    0.09173465f, -0.14281705f, 0.09934506f, 0.13309118f, 0.02608006f, 0.49756917f, 0.13865881f, -0.23537685f, 
    -0.04350108f, -0.11521126f, 0.12426017f, -0.02016736f, -0.11226208f, -0.04055582f, 0.17859747f, 0.17502441f, 
    0.18259847f, -0.05625500f, 0.12572971f, 0.00414836f, 0.06978654f, -0.04955893f, 0.04907135f, -0.26924443f, 
    0.13316484f, 0.00628048f, -0.00082567f, 0.07487904f, -0.15091611f, -0.03341851f, -0.12365421f, -0.08781544f, 
    -0.66731662f, 0.02106652f, -0.07939559f, 0.05573794f, -0.08037917f, 0.14897770f, -0.20453140f, 0.07748619f, 
    0.11233570f, 0.15258932f, 0.12484600f, 0.33028859f, -0.17472261f, -0.08165684f, -0.11712907f, 0.01951561f, 
    0.08036870f, 0.02952731f, -0.72260481f, -0.25694174f, 0.20697580f, -0.02529537f, 0.01398532f, 0.00138902f, 
    -0.07167613f, -0.03599695f, 0.11979699f, 0.18418433f, 0.20352158f, 0.04527264f, -0.04138924f, 0.07299361f, 
    0.01141991f, -0.11861478f, 0.06751684f, 0.03200952f, 0.06215549f, -0.15882736f, -0.24923632f, 0.06301045f, 
    -0.14301549f, 0.10917533f, -0.09603731f, 0.03874441f, 0.16729845f, 0.45703071f, 0.10220941f, -0.13639066f, 
    0.09619322f, 0.14914902f, 0.01526069f, -0.09193439f, 0.10026620f, -0.11441988f, -0.26992336f, 0.02877648f, 
    0.02416698f, 0.16512038f, -0.00307703f, 0.16592784f, -0.29390427f, 0.17644861f, 0.05656794f, 0.42785442f, 
    -0.32367337f, -0.13986643f, -0.17235757f, -0.01037529f, -0.07944807f, -0.05063833f, -0.00368342f, -0.21627778f, 
    0.29414737f, 0.24323250f, 0.15076560f, -0.05173232f, 0.04335004f, -0.05139863f, 0.04286524f, -0.00435627f, 
    -0.03167027f, -0.49185923f, -0.25298545f, -0.32509983f, 0.09367432f, 0.18535313f, 0.02282349f, -0.08977285f, 
    -0.09454161f, 0.18821956f, 0.20585781f, -0.23570037f, -0.13996612f, -0.21264750f, -0.09597645f, 0.01332266f, 
    -0.07663211f, -0.02305824f, 0.06267653f, -0.11709117f, -0.13986158f, 0.09427491f, -0.11144185f, -0.01236283f, 
    -0.21100552f, -0.16719612f, 0.04068320f, -0.14342390f, 0.11532920f, -0.06759743f, -0.20288950f, -0.17286050f, 
    -0.11861634f, 0.01635102f, 0.01533496f, 0.04929011f, -0.16829295f, 0.29035488f, 0.20192666f, 0.06848776f, 
    0.04674555f, 0.16156590f, -0.00612711f, -0.16287386f, -0.05432588f, 0.01928899f, 0.26164445f, -0.38165075f, 
    0.12120624f, -0.08676019f, -0.06062887f, 0.05332728f, -0.23170783f, 0.14418642f, -0.02885830f, -0.17260273f, 
    -0.11298280f, -0.00299103f, -0.05631480f, 0.08881964f, 0.06431583f, -0.06686930f, -0.02124833f, -0.08629034f, 
    0.10113505f, 0.09477378f, -0.08511217f, 0.19763529f, 0.01493233f, 0.17877144f, -0.17000233f, -0.04057555f, 
    0.01178169f, -0.21890177f, -0.33037671f, -0.04007014f, 0.09183050f, 0.07076360f, -0.07664622f, -0.12215348f, 
    0.12005836f, -0.06120588f, -0.06701509f, -0.29028714f, -0.43909848f, 0.16546018f, 0.19126537f, 0.11413413f, 
    -0.08173288f, -0.17498271f, -0.18545350f, -0.65445858f, -0.40335146f, 0.09112457f, -0.32291207f, -0.05607889f, 
    -0.23446347f, 0.04020014f, -0.01132418f, 0.29239511f, 0.37630537f, 0.49415869f, -0.07239991f, 0.00360363f, 
    0.08345904f, -0.04951765f, -0.07825289f, 0.14166103f, 0.03739392f, -0.35814780f, -0.17363456f, 0.01983883f, 
    -0.01213959f, 0.15198629f, 0.10635997f, -0.03420519f, 0.11746652f, -0.00292935f, 0.17193966f, -0.10349473f, 
    -0.26757997f, -0.11842193f, 0.06166425f, 0.10034022f, 0.01144534f, 0.06921628f, 0.14790645f, 0.16528098f, 
    0.18001854f, -0.18777387f, 0.07835965f, 0.10639025f, 0.01748553f, 0.00075804f, 0.06446810f, -0.15465111f, 
    0.40088868f, 0.19042084f, -0.55633301f, -0.16080622f, -0.06499597f, 0.31061736f, -0.26104352f, -0.05532451f, 
    -0.06535445f, -0.23885357f, 0.20987058f, 0.02093827f, 0.02005975f, -0.05719939f, -0.07841303f, -0.19639415f, 
    -0.00766214f, 0.32845023f, -0.04647436f, -0.10367383f, 0.18851490f, -0.06794725f, -0.03008831f, 0.00791843f, 
    0.15496840f, 0.10929301f, -0.05986978f, 0.45264158f, 0.16882633f, 0.10559931f, 0.06019629f, 0.10272026f, 
    -0.08665291f, 0.16440019f, -0.06658472f, 0.14694843f, 0.35974035f, 0.14797974f, -0.08196200f, -0.11028907f, 
    -0.08827297f, -0.02663407f, 0.15180689f, -0.11799101f, 0.04876855f, 0.32975069f, -0.22975734f, 0.24407671f, 
    -0.15820792f, 0.10057791f, 0.12344341f, -0.03800566f, 0.05490303f, -0.09063276f, 0.41087547f, 0.16439641f, 
    0.04031513f, -0.19833294f, 0.07007404f, 0.08159453f, 0.01104656f, 0.01289252f, -0.01607546f, 0.31402233f, 
    0.13922395f, 0.05867133f, -0.02107274f, -0.01904187f, 0.22345245f, -0.10135206f, -0.08391908f, 0.01949781f, 
    0.20475711f, 0.15919690f, -0.25020674f, 0.05193242f, 0.01426627f, -0.01869920f, 0.17157027f, 0.12685786f, 
    0.13303871f, -0.51735026f, -0.09746736f, 0.16684553f, 0.17276533f, 0.11351067f, -0.09536522f, -0.02433123f, 
    0.05395396f, -0.09808113f, -0.28787619f, -0.10938033f, -0.10754462f, -0.13393091f, 0.06768757f, 0.07497890f, 
    0.03690792f, -0.09099544f, 0.12632327f, 0.03845464f, 0.04402951f, -0.09094347f, -0.30283609f, 0.06896768f, 
    -0.06212395f, 0.12905402f, 0.01315283f, 0.06931369f, 0.13763504f, -0.27015370f, -0.34508055f, -0.51334959f, 
    0.12399065f, -0.16390041f, -0.13149866f, -0.03008350f, 0.00910545f, -0.06162364f, 0.09372044f, 0.21073368f, 
    -0.22451234f, -0.02317015f, -0.11688545f, -0.08169481f, -0.08910991f, 0.10376856f, -0.23961197f, 0.17556071f, 
    0.01266854f, 0.02209340f, 0.12250142f, 0.00678163f, -0.16157760f, -0.09033842f, -0.15199904f, 0.09109653f, 
    -0.31008109f, 0.09026463f, 0.05838052f, 0.00601591f, 0.10090066f, 0.05020133f, 0.18481965f, 0.17672232f, 
    0.09766351f, 0.22588898f, -0.32925698f, 0.08852294f, 0.14736819f, 0.09406820f, 0.11306706f, -0.06764336f, 
    0.14479788f, 0.00941987f, 0.16408403f, 0.13070025f, 0.03162723f, -0.04894393f, -0.03230435f, 0.06575702f, 
    -0.04602434f, -0.01780398f, 0.04036514f, -0.04467114f, 0.13396478f, 0.11549862f, 0.08287653f, 0.01537867f, 
    -0.22374764f, 0.15339012f, -0.12651911f, -0.59233493f, -0.27209362f, 0.00802910f, 0.11601870f, 0.03414530f, 
    0.02067415f, 0.20304006f, 0.13623114f, 0.07949424f, -0.41890901f, -0.01661271f, 0.06486833f, 0.00522485f, 
    -0.14142922f, -0.04224919f, 0.07127856f, 0.08911978f, 0.11425050f, 0.00678588f, 0.07716136f, 0.04022070f, 
    -0.14890105f, 0.05690853f, -0.05343171f, 0.08955221f, 0.18708624f, 0.09048746f, 0.00939924f, 0.00009775f, 
    -0.09937013f, -0.20828965f, 0.06070530f, 0.10322034f, 0.05124159f, -0.15950094f, -0.03560922f, -0.24439149f, 
    0.14738619f, 0.11820899f, 0.05550234f, 0.12933518f, 0.11748606f, 0.03494942f, -0.19097672f, -0.03354394f, 
    -0.10558362f, 0.11386783f, 0.10569090f, -0.27170303f, -0.03942826f, -0.00536775f, -0.12120029f, -0.07302682f, 
    0.00206864f, -0.18240485f, -0.14344880f, 0.09333557f, -0.06768678f, -0.04663594f, 0.09532529f, 0.02756308f, 
    -0.05401020f, 0.07409897f, -0.09978057f, -0.14200966f, -0.03247945f, -0.09639680f, -0.03678214f, 0.03880519f, 
    -0.07771602f, 0.03053193f, 0.05199520f, -0.49753106f, -0.35817066f, 0.30094030f, 0.25552729f, 0.04730655f, 
    -0.12368219f, -0.03753183f, 0.09523449f, 0.18498874f, 0.08369660f, 0.08256428f, 0.39079985f, -0.12082335f, 
    -0.24544129f, -0.24334079f, -0.13084355f, 0.20541467f, 0.02814512f, -0.21285389f, 0.23074311f, 0.32457936f, 
    0.02751999f, 0.18252605f, -0.20255516f, -0.12978770f, 0.01613884f, -0.04265713f, -0.02660593f, 0.01796978f, 
    0.02947972f, 0.08467072f, 0.27578077f, 0.06556022f, 0.16862890f, -0.04864703f, 0.19116795f, -0.17067240f, 
    0.15874422f, 0.10774917f, 0.00133485f, 0.06776256f, 0.13295825f, 0.09582936f, -0.06508665f, 0.14327966f, 
    0.22828752f, 0.13011496f, 0.15393698f, 0.02608916f, 0.07851415f, -0.10576894f, 0.10640121f, -0.03810494f, 
    0.00596537f, -0.03756924f, -0.33198640f, -0.16070576f, -0.07274126f, 0.24493726f, -0.05103685f, 0.20529601f, 
    -0.02552912f, -0.10751414f, 0.07534420f, 0.22639775f, -0.30611968f, -0.04216519f, 0.17214887f, -0.14167510f, 
    0.08259661f, -0.02153615f, -0.01860819f, 0.28435621f, -0.17731221f, 0.05840917f, -0.20454822f, 0.04739679f, 
    -0.01951008f, -0.05776284f, 0.02259981f, 0.07906034f, 0.38055199f, 0.19966106f, 0.08724409f, 0.13801986f, 
    0.03623098f, 0.03252558f, 0.00712349f, 0.05951063f, -0.06006528f, 0.04853975f, 0.08658489f, 0.27509919f, 
    -0.15994681f, 0.26509371f, 0.21940115f, 0.07634690f, 0.12319502f, -0.07956780f, -0.06803202f, 0.13739312f, 
    -0.15155379f, 0.03601006f, 0.16342470f, 0.01526144f, 0.06526204f, -0.07281561f, -0.03060819f, -0.90399349f, 
    -0.36216813f, -0.01783049f, 0.21728402f, 0.00088454f, 0.21674423f, 0.19741255f, -0.32798672f, -0.18976535f, 
    0.29353607f, 0.39409977f, 0.39375538f, -0.02734297f, 0.09082738f, 0.04121665f, -0.21826753f, 0.03258032f, 
    0.06053060f, -0.45091698f, 0.04676269f, -0.21620633f, 0.10438523f, 0.09734904f, 0.11690147f, -0.03675586f, 
    -0.05772043f, -0.06029700f, -0.21104327f, -0.14596967f, -0.60764998f, 0.00570669f, -0.12946306f, -0.03076490f, 
    -0.17633785f, 0.00503637f, 0.16483872f, 0.10726396f, 0.13341507f, 0.07241567f, 0.09398277f, -0.01312019f, 
    -0.04524857f, 0.19145115f, -0.23049380f, 0.15048783f, 0.20701417f, 0.07218257f, 0.23205635f, -0.11998782f, 
    -0.16657105f, -0.07079662f, -0.09529553f, -0.05386877f, -0.03685397f, 0.36260927f, 0.20769893f, -0.05567436f, 
    0.13114998f, -0.02383066f, 0.10293932f, -0.13439651f, 0.05669079f, -0.08482254f, 0.16892740f, 0.26678836f, 
    0.29808629f, -0.00793476f, 0.14158921f, 0.05502722f, -0.10475001f, -0.03193939f, 0.22066785f, -0.31408799f, 
    0.04023508f, -0.39005610f, 0.00595919f, 0.16184631f, 0.16521135f, 0.02918757f, -0.00268488f, 0.16653316f, 
    -0.49414101f, 0.08809767f, 0.03822615f, 0.11323494f, 0.00249842f, 0.07951625f, -0.07622112f, -0.21560197f, 
    -0.16915312f, -0.19998740f, -0.13036104f, 0.11936984f, -0.10716890f, -0.12113716f, 0.10730329f, 0.07116600f, 
    -0.02158368f, 0.18940963f, -0.61270291f, -0.23951136f, 0.01405569f, 0.17991482f, 0.26815152f, 0.06762358f, 
    0.05503371f, -0.04362247f, -0.15134388f, -0.32930318f, 0.11374813f, -0.20361921f, 0.18752354f, 0.31188732f, 
    -0.02333617f, 0.06397440f, -0.11203010f, -0.08856014f, -0.33257064f, -0.54019785f, -0.10320224f, 0.18567139f, 
    0.04707201f, -0.11577536f, 0.14938457f, -0.15757647f, -0.08815561f, 0.22750334f, 0.31816790f, -0.10875271f, 
    -0.07728487f, 0.09176555f, -0.00851260f, 0.03857397f, 0.07456629f, 0.11164756f, 0.42083016f, 0.20423959f, 
    0.11392157f, 0.19351193f, 0.10630424f, -0.10021870f, 0.01033436f, 0.12405151f, 0.02410679f, 0.25010681f, 
    0.07238839f, 0.15556519f, 0.07420266f, 0.02735358f, -0.14098667f, 0.07651136f, 0.01408678f, -0.01308941f, 
    0.21430163f, 0.27829283f, 0.38086423f, 0.11094764f, -0.02080667f, -0.01294657f, 0.18379703f, -0.11838530f, 
    -0.00937076f, -0.32907197f, 0.02146258f, -0.08843265f, 0.19368714f, 0.08136124f, 0.06324311f, 0.00181427f, 
    -0.13553734f, -0.15434583f, -0.09677436f, -0.10576191f, 0.04550836f, 0.02583432f, 0.09390701f, -0.05147839f, 
    0.05019988f, -0.01872067f, 0.09905273f, -0.20673019f, -0.13932747f, -0.46464980f, 0.06684762f, 0.08426864f, 
    -0.06017114f, -0.00447717f, 0.03574235f, 0.08956996f, 0.16178700f, 0.00769453f, -0.31263909f, -0.14535783f, 
    0.39739233f, 0.25220174f, 0.05446792f, 0.13521492f, -0.00726580f, 0.42044184f, 0.13965613f, 0.19596338f, 
    0.01643026f, 0.11179943f, 0.06647693f, 0.27142623f, -0.01753382f, 0.02781418f, -0.07605924f, -0.06944174f, 
    -0.15444933f, 0.20939270f, 0.17694290f, -0.11646906f, -0.23439626f, -0.11515784f, -0.15330549f, 0.15164158f, 
    0.08596115f, 0.10392033f, 0.04680483f, -0.02915604f, 0.03575410f, 0.19665197f, 0.04617892f, 0.00601260f, 
    0.11167955f, -0.05752040f, -0.07642505f, -0.20004472f, 0.20654713f, -0.06908415f, -0.09385169f, 0.38335809f, 
    0.31452769f, 0.21879888f, -0.17171997f, 0.10962672f, 0.09451809f, -0.09126675f, 0.39966857f, 0.06604400f, 
    -0.00255844f, 0.05202395f, 0.01022164f, -0.15298384f, -0.15294479f, -0.02695468f, 0.00666509f, -0.08028185f, 
    0.00588339f, -0.06637733f, -0.06533829f, 0.00551728f, -0.30702269f, 0.09540034f, -0.07713871f, -0.10476887f, 
    -0.08727625f, -0.06985333f, -0.14026614f, -0.10039597f, -0.79964262f, -0.19763713f, 0.13313617f, -0.04676851f, 
    0.04585971f, 0.11971972f, 0.11084581f, -0.10746270f, 0.17718957f, -0.43905011f, -0.57890040f, -0.25815463f, 
    0.04131972f, 0.12201437f, -0.10646041f, 0.25358322f, 0.17761721f, -0.10609972f, -0.60844862f, -0.10706389f, 
    -0.07124623f, 0.11524141f, 0.06761228f, -0.03135967f, 0.02259308f, 0.08199042f, -0.23336622f, -0.35965249f, 
    0.12194764f, -0.36927599f, 0.08388817f, 0.16123602f, 0.11214084f, -0.06706677f, -0.02730134f, -0.03698625f, 
    0.09274922f, 0.05475128f, 0.02085452f, -0.05574533f, 0.09891947f, 0.05786752f, -0.18633151f, -0.02037054f, 
    0.13709298f, 0.25249937f, 0.12498078f, -0.15954706f, -0.07543427f, -0.04333615f, 0.05253356f, 0.03346779f, 
    0.07100655f, -0.13976087f, -0.84249210f, -0.12676750f, 0.15998048f, 0.06027161f, -0.01236932f, -0.07552863f, 
    0.26777285f, 0.06561545f, -0.07645410f, 0.04146669f, 0.16889510f, -0.29563305f, -0.00637472f, 0.15051988f, 
    -0.11928996f, -0.00519727f, 0.00520716f, -0.05158119f, -0.11563689f, -0.00315457f, -0.19270520f, -0.12307091f, 
    -0.09540687f, 0.12714736f, 0.08663264f, 0.07569222f, 0.09969060f, -0.10592815f, 0.00700041f, 0.04196586f, 
    0.05556906f, 0.00648991f, 0.24416548f, -0.06277800f, -0.06548313f, -0.00898061f, -0.13636756f, 0.11301626f, 
    -0.32133093f, 0.05658149f, 0.15260598f, 0.08938797f, -0.11696886f, 0.13307753f, 0.13315548f, 0.08955666f, 
    -0.35203329f, -0.17028263f, -0.01624418f, 0.12896325f, 0.06319151f, 0.08931602f, -0.22435346f, 0.21840619f, 
    0.26730523f, 0.15328316f, 0.17149594f, 0.16862682f, 0.02861670f, 0.03526025f, 0.03783322f, -0.25838226f, 
    0.01531564f, -0.28587487f, -0.14413132f, -0.46154049f, 0.13203797f, 0.05597591f, 0.04415998f, -0.03575354f, 
    -0.01449549f, -0.18369515f, 0.19441766f, -0.03222355f, -0.18813737f, -0.13593525f, -0.06354489f, 0.03505024f, 
    0.02645092f, 0.05789968f, -0.07721114f, -0.09982808f, -0.05143449f, -0.01575349f, -0.13218105f, 0.17611575f, 
    0.04269329f, 0.02365642f, -0.09938084f, -0.26139131f, 0.13354240f, 0.15497804f, 0.07035380f, 0.01502180f, 
    -0.03715894f, 0.09366257f, 0.01461817f, 0.05628545f, -0.00872801f, 0.04390688f, 0.21777470f, -0.10564759f, 
    -0.09363549f, 0.02011691f, 0.23851445f, -0.18522188f, 0.06099022f, 0.00599351f, -0.10927108f, -0.15616477f, 
    -0.06191102f, 0.11168653f, -0.00090870f, 0.12063932f, 0.09265099f, -0.00482458f, -0.06381005f, 0.13622451f, 
    0.18374060f, -0.01377896f, 0.25797710f, 0.01210649f, -0.02732836f, 0.05746600f, -0.01697052f, 0.17597626f, 
    0.12836038f, 0.28476387f, 0.00281032f, -0.05293543f, -0.04076727f, 0.14529662f, -0.22317822f, 0.05600907f, 
    0.05859973f, -0.19178934f, -0.16454937f, -0.14124547f, -0.05097194f, 0.12584947f, -0.03263555f, -0.09012374f, 
    0.14121406f, 0.03026404f, -0.10402205f, -0.05711986f, -0.11081618f, 0.21368772f, -0.01244126f, -0.05105297f, 
    0.04588922f, 0.04384106f, -0.01582909f, -0.19433089f, -0.14633399f, -0.30031151f, 0.12745927f, 0.21219897f, 
    -0.13414417f, -0.09487867f, 0.06210073f, -0.16273920f, -0.22594574f, 0.06079589f, -0.09131405f, -0.05209222f, 
    0.10503321f, 0.33915585f, 0.11769931f, -0.04754018f, 0.11238213f, -0.35522050f, 0.11388010f, -0.21712866f, 
    0.06572473f, 0.00574261f, 0.26292643f, -0.00647425f, 0.04878404f, -0.03048434f, 0.24653995f, 0.00579208f, 
    -0.35844651f, 0.18284637f, -0.03131565f, -0.29408044f, -0.01475445f, 0.17004646f, -0.15200104f, 0.08810296f, 
    -0.05882670f, -0.31948605f, 0.06838655f, -0.04848262f, -0.02882479f, -0.09231368f, -0.05131715f, 0.07055116f, 
    0.14758165f, 0.26151657f, -0.01670517f, 0.00438029f, -0.19982816f, 0.13800915f, -0.02470761f, 0.04115526f, 
    0.03467980f, -0.37800407f, 0.03142524f, 0.01587296f, 0.03701054f, 0.02220666f, 0.05078602f, -0.36225155f, 
    0.05373712f, 0.04090228f, 0.07006155f, 0.02790552f, 0.24449790f, -0.12460753f, -0.06052222f, -0.12442727f, 
    0.14813529f, 0.07398413f, 0.11771949f, 0.04955503f, -0.10634308f, -0.23484038f, -0.21506670f, 0.03299243f, 
    0.12367844f, 0.10768642f, -0.02475628f, -0.07958379f, 0.26490763f, 0.26757267f, -0.05989024f, 0.08419721f, 
    -0.20404737f, -0.15413994f, 0.02414895f, -0.24964210f, 0.07811124f, 0.20815668f, 0.09809218f, 0.09944944f, 
    -0.12557511f, -0.03959273f, -0.04877400f, 0.11249435f, 0.20439988f, 0.14469336f, 0.30117637f, 0.18909347f, 
    0.01582820f, 0.07257593f, -0.05627312f, 0.06658233f, 0.11772583f, 0.00365089f, -0.12061399f, 0.40964767f, 
    0.06815758f, -0.09684356f, 0.01215764f, 0.06223677f, 0.02529652f, -0.16035713f, -0.07340199f, -0.03791619f, 
    -0.05290863f, 0.00364008f, -0.02373203f, -0.01037152f, -0.02509686f, -0.03408763f, -0.00331043f, -0.06908040f, 
    -0.02712411f, -0.05002479f, -0.03570888f, -0.03818993f, -0.02403564f, -0.02207789f, 0.04699067f, -0.00589359f, 
    0.00369521f, -0.04408255f, -0.05049609f, 0.03457383f, 0.02216428f, -0.04420562f, -0.04794099f, -0.03276078f, 
    -0.04974885f, -0.02249124f, -0.03389318f, 0.00929328f, -0.01502009f, 0.03419564f, -0.00072014f, -0.04669701f, 
    0.02166255f, 0.02119809f, -0.00104367f, -0.04340263f, 0.00293130f, -0.02823838f, -0.04647476f, 0.03100481f, 
    -0.05226268f, -0.04081758f, -0.05959883f, 0.00396762f, -0.00234724f, -0.06151961f, 0.02173806f, -0.02606761f, 
    0.04371987f, -0.01877447f, 0.04366952f, -0.04216031f, -0.02624684f, -0.01194176f, 0.04348718f, 0.02929442f, 
    0.02726926f, -0.00556188f, -0.04962250f, -0.00724855f, -0.02565464f, -0.01465612f, 0.02650876f, -0.04889443f, 
    0.00566256f, 0.04549265f, 0.02849946f, -0.04391359f, 0.04724677f, -0.03137594f, 0.01493562f, 0.04090527f, 
    -0.04961634f, -0.03981237f, -0.00234268f, -0.01919566f, -0.03742706f, 0.00986269f, -0.00220904f, -0.03406338f, 
    -0.01529691f, -0.04002541f, 0.03368754f, 0.03289153f, 0.04339237f, -0.00354367f, -0.01813108f, 0.04099655f, 
    0.04733825f, -0.04674737f, 0.01840922f, 0.01013046f, -0.06214371f, -0.05182005f, -0.01630457f, -0.02883160f, 
    -0.02807623f, -0.04767831f, -0.04973062f, -0.06173290f, -0.03785292f, -0.02794441f, -0.03691418f, 0.05031650f, 
    0.01982666f, -0.01809789f, 0.03654302f, 0.01000201f, 0.04276892f, 0.05342635f, -0.04336061f, 0.01906675f, 
    -0.02081637f, -0.03541424f, 0.01964863f, 0.03499762f, 0.04389567f, -0.05581260f, -0.01164412f, 0.02583491f, 
    -0.04193132f, -0.04455672f, 0.00031517f, -0.06452407f, -0.01273643f, -0.02911613f, -0.02571527f, -0.02527991f, 
    0.02145667f, -0.03729140f, -0.04412887f, -0.05071373f, -0.01446674f, -0.02007634f, -0.01694909f, 0.05094915f, 
    -0.04678819f, -0.03042048f, 0.01592600f, 0.00698982f, -0.02145058f, 0.02789779f, -0.00167690f, 0.00610222f, 
    0.04430956f, 0.01247001f, 0.03908421f, -0.02782932f, 0.01252384f, -0.03471094f, 0.04019707f, 0.03686860f, 
    0.04157446f, 0.04284763f, 0.03674786f, -0.05237056f, -0.01045217f, -0.05932660f, -0.04391049f, -0.03221700f, 
    0.02140150f, -0.06685305f, -0.04382379f, 0.04477375f, -0.04543862f, -0.01290984f, 0.00335172f, 0.03205678f, 
    -0.04884125f, -0.04156632f, 0.00229406f, 0.04927430f, -0.07075356f, 0.03837739f, -0.03098560f, -0.00468429f, 
    0.04959041f, -0.06809857f, 0.03169005f, 0.01013852f, 0.02178886f, 0.01762894f, 0.04579804f, -0.02932161f, 
    -0.02714115f, 0.04431707f, -0.02614287f, 0.03550750f, -0.00599055f, -0.01052367f, -0.06191748f, 0.01310306f, 
    0.04389078f, -0.02668831f, 0.01512386f, -0.05016270f, -0.03183821f, 0.00277616f, -0.02673380f, 0.05622377f, 
    -0.04091775f, -0.04997739f, -0.00895697f, -0.00007888f, -0.05084371f, 0.02500412f, -0.01214838f, 0.01509487f, 
    0.00794615f, 0.00779583f, 0.01170217f, -0.05180996f, -0.04066964f, 0.05030357f, -0.02066022f, -0.02339448f, 
    0.03949959f, -0.02022584f, 0.02586548f, -0.03170130f, -0.00722354f, -0.03320896f, -0.01111997f, -0.01359855f, 
    0.04193702f, 0.03108465f, -0.00536122f, 0.02445245f, -0.06292669f, -0.05172881f, 0.02099889f, -0.03304002f, 
    -0.06839276f, -0.03350034f, -0.05155670f, -0.05236594f, -0.00742237f, -0.06439885f, -0.01706009f, -0.00260153f, 
    0.00828477f, 0.01536972f, 0.02991468f, 0.03879679f, -0.04003972f, 0.00579404f, 0.01667339f, -0.04242523f, 
    0.01349810f, -0.02046691f, -0.02605722f, 0.00994728f, 0.04855547f, 0.04258297f, 0.00899452f, 0.04609501f, 
    0.00768254f, 0.00614888f, -0.04136534f, -0.01706946f, 0.00420049f, -0.02404657f, 0.02974129f, 0.01407589f, 
    0.05302013f, -0.00529506f, -0.03093987f, -0.00326029f, -0.03931420f, -0.02574034f, -0.05340437f, 0.03047883f, 
    -0.01745982f, 0.02695291f, 0.04290320f, -0.02893745f, 0.03419407f, -0.05590400f, 0.04076988f, -0.01900063f, 
    -0.02109168f, 0.04077264f, 0.01949916f, 0.00680578f, -0.04636600f, -0.06498200f, -0.01182215f, -0.04086759f, 
    0.10105380f, 0.08206683f, 0.08990417f, 0.16697100f, -0.15700793f, -0.09262341f, 0.05798060f, 0.04316535f, 
    -0.04323043f, 0.15575756f, 0.16861366f, 0.25329438f, -0.03183622f, -0.00850398f, 0.16314480f, -0.05724159f, 
    0.08450533f, 0.06335744f, 0.27195984f, 0.08872546f, -0.36879283f, 0.06131239f, 0.01951161f, -0.24561179f, 
    -0.11274828f, -0.17168602f, 0.14451006f, -0.05433044f, -0.19887736f, -0.06323542f, 0.02866722f, -0.30691865f, 
    0.02669541f, -0.10432567f, -0.04220882f, -0.15242410f, 0.03583805f, -0.03027724f, -0.11739345f, -0.02084806f, 
    -0.06878245f, 0.15365469f, -0.12389237f, 0.08196270f, -0.08709380f, -0.12028970f, -0.11447272f, -0.45753375f, 
    0.09129781f, 0.18289185f, -0.16277573f, 0.11608952f, 0.03068158f, -0.18073803f, -0.16970561f, -0.12854795f, 
    -0.20096694f, -0.08963683f, 0.04242061f, 0.20090090f, 0.04578206f, 0.08543006f, -0.00635680f, -0.53055847f, 
    0.06599952f, -0.02317995f, -0.08063299f, -0.20047237f, 0.19049560f, -0.22726581f, 0.14551519f, -0.07388611f, 
    0.25709733f, 0.14498709f, 0.32867119f, -0.14206719f, 0.07160663f, 0.02635509f, 0.05786492f, 0.23717538f, 
    0.14877653f, -0.30655369f, -0.09891688f, -0.87936538f, 0.31652519f, 0.02307380f, 0.13837521f, 0.06231534f, 
    0.00845573f, 0.05896912f, -0.16690063f, -0.34290722f, -0.41299614f, 0.07546300f, -0.19555748f, 0.01223247f, 
    0.20297560f, 0.19056292f, -0.30062324f, -0.17555958f, -0.07062910f, 0.14203727f, 0.25181481f, -0.02682039f, 
    0.16026491f, 0.00475324f, -0.08283775f, 0.12760173f, 0.05268665f, -0.01456758f, 0.29547971f, 0.10177188f, 
    -0.21357863f, -0.12783106f, -0.01728187f, 0.25714740f, 0.03979013f, -0.29266435f, -0.22674865f, -0.04162949f, 
    0.06461883f, 0.09529445f, -0.07051589f, 0.11351552f, 0.13712178f, 0.05424317f, -0.11609860f, -0.01293427f, 
    -0.14442943f, -0.11123308f, -0.02292933f, 0.02079141f, -0.07698952f, 0.09023174f, 0.14901339f, 0.20132431f, 
    0.14338499f, -0.19556805f, -0.01276547f, -0.12329712f, 0.08113249f, -0.01300750f, -0.10321649f, -0.05311203f, 
    -0.23868492f, -0.21428438f, -0.01995738f, 0.19445880f, -0.02346262f, -0.08969405f, 0.07273165f, -0.06076089f, 
    -0.12475218f, 0.14654265f, 0.13883293f, -0.23073861f, -0.00992226f, -0.00264457f, -0.12589046f, -0.22009042f, 
    -0.06025691f, 0.07403756f, -0.23506071f, -0.33069193f, -0.51653427f, -0.02432787f, 0.05838794f, 0.13174006f, 
    -0.19906133f, -0.18173590f, 0.03031202f, 0.00358330f, 0.08509827f, 0.31044582f, -0.28236741f, -0.08383379f, 
    0.05711451f, -0.11109994f, 0.13492455f, 0.05223383f, -0.12608503f, -0.08122177f, 0.02766153f, 0.08675033f, 
    -0.02256609f, -0.28518060f, 0.04691041f, 0.09726782f, 0.09782079f, -0.06750707f, 0.18507737f, 0.00582301f, 
    0.37933800f, -0.12642053f, 0.12838098f, -0.09277202f, -0.17889507f, 0.13643858f, -0.06785282f, -0.02415190f, 
    0.46277344f, -0.08012704f, -0.11149302f, 0.09889457f, 0.03892002f, 0.19341114f, 0.02301389f, 0.16419712f, 
    -0.02518796f, 0.03016480f, 0.03235212f, 0.09227996f, 0.05199575f, -0.05690653f, -0.15247314f, -0.10351197f, 
    0.20168376f, 0.08274890f, 0.05196968f, 0.19374809f, 0.14587031f, -0.14846709f, 0.08495153f, 0.22599913f, 
    0.11432685f, 0.07314996f, 0.24729733f, 0.13491970f, 0.03080960f, -0.01568986f, 0.09868620f, 0.05560927f, 
    -0.05509008f, -0.15086471f, -0.03073076f, 0.20994355f, 0.26830003f, 0.04413524f, 0.05726678f, 0.01779944f, 
    0.16281961f, -0.01173687f, -0.03573932f, 0.13275415f, 0.21804345f, -0.02309172f, -0.03017247f, -0.13897087f, 
    -0.23456486f, -0.13561958f, 0.24937747f, -0.03354954f, 0.28389579f, -0.05297890f, 0.27318731f, -0.15973732f, 
    -0.22587788f, -0.01323149f, 0.06412449f, 0.11391062f, -0.09831297f, 0.01887193f, -0.40122157f, 0.11185693f, 
    0.05671553f, 0.06782939f, 0.05151251f, 0.11009892f, -0.03761256f, 0.00147744f, 0.28516367f, -0.02130142f, 
    0.24963751f, 0.03930176f, 0.01114606f, -0.04025930f, 0.08213354f, -0.02351004f, 0.10011921f, -0.14759897f, 
    -0.17263812f, -0.00587896f, -0.06700791f, 0.24113773f, 0.08424661f, 0.06877522f, -0.03405692f, 0.05875100f, 
    -0.69695127f, -0.37493914f, -0.01010398f, 0.26095885f, -0.01769970f, 0.03923873f, -0.08177719f, -0.09835016f, 
    0.12839350f, -0.17606555f, 0.09966020f, 0.07323486f, -0.08112039f, -0.12389009f, 0.18043259f, 0.19175541f, 
    0.02761562f, 0.00345353f, 0.06891517f, 0.20921689f, 0.08234186f, 0.16556124f, 0.08942243f, -0.29509026f, 
    -0.06016215f, 0.19354792f, -0.06036010f, 0.09579840f, 0.23323926f, 0.00840011f, 0.17414577f, -0.06735461f, 
    -0.08495343f, 0.04665639f, 0.04373215f, -0.04648202f, 0.01283490f, 0.02007599f, -0.07931104f, 0.22655368f, 
    0.06529837f, -0.09034129f, -0.21106841f, -0.07947197f, 0.18078925f, 0.28991550f, -0.11525792f, -0.15175687f, 
    0.21712460f, 0.06951955f, 0.05804846f, -0.00143811f, -0.11399094f, 0.02706290f, 0.32847130f, -0.36182734f, 
    -0.00967478f, 0.02622736f, -0.12268257f, 0.14505593f, 0.33942229f, -0.21469083f, -0.15274176f, 0.16593356f, 
    0.28070983f, -0.22107808f, -0.08229052f, -0.21107309f, 0.00556384f, 0.08573317f, 0.02890746f, -0.10198979f, 
    0.17378210f, 0.02224804f, -0.00598723f, -0.05513332f, -0.27761069f, -0.03387763f, 0.07287468f, 0.05860101f, 
    0.19524050f, -0.11935987f, 0.15721886f, -0.12344673f, -0.08438374f, -0.04346776f, 0.33163249f, -0.19026276f, 
    -0.11509808f, 0.01650646f, 0.06796346f, 0.12284427f, 0.19685134f, -0.08062731f, 0.02749211f, -0.00916217f, 
    0.11201093f, -0.14671749f, -0.05381021f, -0.30257910f, 0.19483668f, -0.05597834f, -0.15762797f, -0.06231988f, 
    -0.05091425f, -0.07653169f, 0.10287210f, -0.02148046f, 0.11164735f, 0.01684285f, 0.24734701f, -0.26099503f, 
    -0.21727373f, -0.18365930f, 0.02464521f, 0.04075924f, 0.11553889f, 0.16141117f, -0.01334615f, -0.09072036f, 
    0.16199830f, 0.23627242f, -0.05286264f, -0.14675315f, -0.04988966f, -0.03247306f, 0.17861578f, 0.03173574f, 
    -0.20622629f, 0.09666172f, -0.13447180f, -0.00485489f, -0.07001239f, 0.04575953f, 0.13029233f, 0.17076571f, 
    -0.25622430f, 0.05654557f, 0.07513468f, -0.08787014f, 0.12828349f, -0.00831437f, -0.09005558f, -0.02147572f, 
    0.29779562f, -0.35376805f, -0.28448582f, -0.06566032f, 0.09118738f, -0.01279020f, -0.28790545f, -0.03744144f, 
    0.02040917f, 0.06725508f, 0.03721682f, -0.30967185f, -0.10944598f, -0.16775379f, 0.12661000f, 0.09215678f, 
    0.15732084f, 0.06934065f, -0.23063166f, 0.12318970f, -0.13931483f, -0.12713872f, 0.06433810f, 0.06529003f, 
    -0.14177220f, -0.04594145f, 0.02804950f, -0.09269092f, 0.10477210f, -0.15234752f, -0.13202831f, -0.25851619f, 
    0.01919455f, -0.10593296f, 0.13156225f, -0.04369476f, 0.21139488f, 0.32271817f, -0.04255961f, 0.19202577f, 
    0.09286982f, -0.12957610f, 0.04242882f, -0.19041610f, -0.08177990f, 0.26599026f, -0.41514060f, -0.19116701f, 
    -0.12303554f, 0.23156738f, 0.16041699f, 0.08492745f, 0.01302130f, -0.18946046f, 0.17068143f, 0.06948153f, 
    0.16121899f, -0.06826933f, 0.04170505f, -0.08115652f, 0.03102562f, 0.07849642f, 0.14624089f, 0.13668595f, 
    0.14279115f, -0.05288778f, 0.05272771f, 0.07768995f, 0.04760379f, 0.06597860f, -0.08337609f, 0.15775709f, 
    -0.08218066f, 0.15864213f, 0.01584264f, -0.08976737f, 0.17300698f, -0.32778934f, -0.22943084f, -0.00361968f, 
    0.13537100f, -0.13790700f, -0.33583260f, -0.11563358f, 0.17660680f, 0.04425029f, 0.02827317f, 0.22004211f, 
    -0.07050255f, 0.02089088f, 0.25952742f, -0.04212375f, -0.09252904f, -0.14911954f, 0.00546623f, -0.11201316f, 
    -0.18996541f, 0.13431412f, 0.16778663f, 0.18984219f, 0.14170115f, -0.13395835f, -0.15610023f, 0.03968493f, 
    0.02602144f, 0.04751649f, 0.11046498f, -0.00463567f, -0.23467541f, 0.32086369f, 0.01138950f, -0.07550043f, 
    -0.08002853f, -0.01741580f, -0.00243410f, -0.06493823f, 0.04159793f, -0.00644772f, -0.16191982f, 0.26811814f, 
    -0.23751657f, 0.15955500f, 0.06029987f, 0.09745084f, -0.17839935f, -0.00403782f, -0.05131591f, 0.02591041f, 
    0.17473561f, 0.10460752f, -0.00687188f, -0.00510959f, 0.07777047f, 0.00358713f, 0.12853348f, -0.42312938f, 
    0.14628930f, -0.17836961f, 0.00098335f, 0.09213496f, 0.09040065f, -0.01253306f, 0.01626696f, -0.14476253f, 
    0.06580082f, -0.00085832f, -0.20378803f, -0.10439686f, -0.12282573f, 0.00661962f, -0.04831612f, 0.21571656f, 
    0.13657436f, -0.48796919f, -0.29743770f, 0.29142946f, 0.15927161f, 0.07959294f, 0.01079299f, 0.01090460f, 
    -0.02062553f, 0.09344774f, 0.37020615f, 0.13911887f, -0.66147673f, -0.20203538f, -0.04561540f, -0.16660158f, 
    -0.06245183f, 0.10432278f, 0.01792196f, 0.02698685f, -0.07910675f, -0.09884512f, -0.02849727f, -0.07776404f, 
    -0.35652599f, 0.05881463f, -0.02294312f, -0.10408557f, -0.43937451f, 0.11956182f, 0.26496702f, 0.11734989f, 
    0.09603018f, -0.01517638f, 0.06437147f, -0.04918033f, -0.06735444f, -0.04286047f, 0.08614780f, -0.40539542f, 
    0.04963931f, -0.05520918f, -0.27243778f, -0.02342081f, 0.19194517f, 0.03116189f, 0.29017597f, 0.22645439f, 
    -0.08510193f, -0.07686622f, 0.23830916f, -0.12458538f, -0.06109994f, -0.17871746f, 0.07695778f, 0.44500843f, 
    -0.19387460f, 0.30572295f, 0.11611710f, 0.05541700f, -0.00791791f, -0.01087607f, -0.13976674f, -0.12139131f, 
    0.05648512f, -0.22548914f, 0.31545454f, 0.01733111f, 0.00791759f, -0.09491895f, -0.12234160f, 0.04530718f, 
    -0.00153848f, -0.36637869f, 0.05669923f, -0.00689235f, 0.17942531f, -0.05321276f, -0.01176562f, 0.03102645f, 
    0.07544754f, 0.12811834f, -0.28028256f, -0.04117874f, 0.29006365f, 0.09874753f, -0.02382028f, -0.01794439f, 
    0.02014653f, -0.03082934f, 0.27657443f, -0.06015907f, 0.00788012f, 0.14079617f, 0.18009159f, -0.09585571f, 
    0.00504695f, -0.10741885f, 0.17685874f, 0.06454003f, 0.22616059f, 0.01293809f, 0.13543306f, 0.09305655f, 
    -0.12343024f, -0.01681540f, 0.00674131f, 0.00555857f, 0.05185395f, 0.19374017f, 0.06921270f, -0.48823193f, 
    0.04133535f, -0.15931599f, -0.28601769f, 0.12136795f, 0.01399906f, -0.07456301f, 0.04375356f, 0.38209999f, 
    -0.08524691f, -0.17685857f, -0.13084085f, 0.04951579f, -0.01306442f, -0.01929881f, -0.12961532f, -0.10502553f, 
    0.00516410f, -0.17492865f, -0.08871035f, 0.01678800f, -0.11026161f, -0.21139407f, -0.13042316f, 0.07222544f, 
    -0.21420407f, 0.16637789f, -0.29324856f, 0.03398515f, -0.13255061f, -0.29381770f, -0.09592606f, -0.01619636f, 
    0.09061705f, 0.28282556f, 0.19438168f, -0.15567426f, -0.37257966f, -0.11318105f, 0.22127599f, 0.06659598f, 
    -0.02497524f, 0.10018367f, -0.32665798f, -0.11548544f, -0.27887207f, 0.07198277f, -0.14549829f, 0.01012733f, 
    -0.00601039f, 0.07546540f, 0.05980520f, -0.37621126f, 0.18836260f, 0.43123636f, 0.15288693f, 0.19879238f, 
    0.01076175f, -0.18426469f, -0.13760696f, 0.08135574f, 0.39419040f, -0.09425581f, -0.31345367f, 0.19402294f, 
    -0.09524719f, -0.14291888f, -0.03623635f, -0.09838025f, -0.03138472f, -0.11731363f, 0.17097481f, -0.13470697f, 
    -0.05675202f, 0.08638532f, -0.03966334f, 0.08005103f, 0.01244311f, -0.14502160f, 0.06341109f, -0.35187963f, 
    0.55161631f, 0.19445723f, 0.16346380f, 0.09186032f, -0.09769981f, -0.03127445f, 0.17645451f, 0.08122512f, 
    -0.12757003f, 0.06142854f, -0.05696931f, -0.11709987f, -0.06249878f, 0.01327199f, 0.04485134f, -0.22558741f, 
    0.09725593f, -0.04500219f, 0.13966340f, 0.08028393f, -0.09753168f, -0.02412329f, 0.05701037f, -0.09472749f, 
    0.05198521f, 0.38248873f, 0.13079415f, -0.40356848f, -0.24736908f, -0.04651182f, -0.00798434f, -0.04592502f, 
    0.01190271f, -0.00903364f, 0.03714533f, -0.18805659f, 0.38692150f, -0.01740517f, 0.17387480f, 0.15887783f, 
    0.00439874f, 0.07191566f, 0.09288979f, 0.19626631f, -0.05131149f, 0.35520175f, 0.14175923f, 0.09056780f, 
    0.13869826f, 0.05483064f, 0.01242780f, -0.23770960f, -0.12819137f, -0.17649114f, 0.14530832f, 0.16230862f, 
    -0.02603636f, 0.21766034f, -0.06526001f, 0.04724332f, 0.00672102f, -0.16324535f, 0.15088807f, 0.08822586f, 
    0.36005917f, 0.12867846f, 0.03676565f, 0.11619253f, -0.13573737f, 0.21760899f, 0.02975797f, -0.05205481f, 
    0.27064136f, 0.22895128f, 0.18940656f, 0.07686689f, -0.23700853f, -0.03785984f, 0.04944243f, 0.01351436f, 
    0.11622524f, 0.38893589f, -0.05366503f, -0.09032360f, -0.06317028f, -0.21347240f, 0.15117362f, 0.08400299f, 
    -0.06235196f, -0.00631959f, 0.01209175f, -0.01239643f, -0.00012893f, -0.04392695f, -0.03074509f, 0.01072905f, 
    0.04379856f, -0.02629960f, -0.02002489f, 0.00901375f, -0.03764120f, 0.00452206f, -0.01353292f, 0.04008693f, 
    -0.03042657f, 0.02158833f, -0.00742291f, 0.02306173f, -0.02395233f, -0.01596405f, -0.04332104f, -0.02346927f, 
    0.04984356f, 0.02900836f, -0.01988688f, 0.04870412f, 0.04257301f, 0.03259544f, -0.03165313f, -0.05833550f, 
    0.04052418f, 0.01663086f, -0.00166430f, -0.05561848f, 0.03096051f, 0.02569832f, -0.00098929f, 0.03385254f, 
    -0.02591881f, -0.05813517f, -0.01212385f, 0.04185225f, 0.01987579f, -0.04150071f, -0.00750879f, 0.02373333f, 
    0.03712858f, -0.01855185f, 0.01836464f, -0.01338045f, 0.02495636f, 0.05413840f, 0.00090277f, -0.03315363f, 
    -0.01591305f, 0.02056421f, -0.04376403f, -0.00202300f, 0.04621748f, 0.02917911f, 0.02780772f, -0.01854736f, 
    -0.01724289f, -0.04350464f, 0.01852792f, 0.03301109f, -0.01250077f, 0.01833183f, -0.01833961f, -0.01275747f, 
    0.03576929f, 0.04683940f, -0.04607222f, -0.05453700f, -0.00288276f, 0.04363739f, 0.01821222f, 0.01911843f, 
    -0.01562557f, -0.06284943f, 0.01596766f, -0.00562810f, 0.05009197f, -0.06141526f, -0.04339660f, 0.00044146f, 
    -0.02730895f, 0.00785163f, -0.05464317f, -0.04657014f, -0.03240100f, 0.04240124f, -0.02860458f, 0.02944869f, 
    -0.02132150f, 0.05393355f, -0.02724261f, -0.06087604f, 0.03959438f, 0.02298865f, 0.05138466f, 0.03625543f, 
    0.01196596f, 0.00334581f, -0.03628463f, 0.04859709f, 0.04317920f, 0.00023630f, -0.04499188f, -0.00768628f, 
    -0.05045754f, -0.00382419f, 0.04223120f, 0.02644689f, 0.04725378f, 0.04269488f, -0.03507395f, -0.01513724f, 
    0.01039698f, 0.00807059f, 0.04152817f, 0.04464763f, -0.05582135f, -0.03362304f, 0.03267206f, 0.00161479f, 
    -0.05360290f, -0.05723727f, -0.06150419f, -0.04807505f, 0.01424818f, -0.04184038f, 0.01444249f, -0.02440976f, 
    -0.01418543f, -0.05402305f, 0.04827721f, -0.04070829f, -0.03172500f, -0.04762991f, -0.00383580f, -0.00343172f, 
    -0.00832602f, -0.06473697f, 0.02250194f, -0.05727750f, -0.00502780f, -0.03899055f, 0.02411674f, -0.01785740f, 
    0.02670171f, -0.02212775f, -0.05478521f, -0.02612935f, 0.04660065f, 0.01213634f, -0.04089036f, 0.03697713f, 
    0.04586414f, 0.00204899f, -0.06588211f, 0.01191412f, -0.02893313f, -0.00701109f, 0.04256372f, 0.03269798f, 
    0.03623145f, 0.02722919f, -0.01884262f, -0.03405000f, -0.03213580f, -0.04020621f, -0.01916560f, 0.00861750f, 
    0.02334734f, 0.04485185f, -0.05943892f, 0.00202129f, -0.03288581f, 0.01143198f, 0.03935970f, 0.04762639f, 
    0.02799833f, -0.05498214f, 0.03205076f, -0.03428635f, 0.03048787f, -0.01963045f, 0.03418413f, -0.01398649f, 
    -0.06261239f, 0.01832748f, 0.04882035f, -0.03543412f, -0.04455658f, 0.00010665f, -0.02755325f, 0.00885109f, 
    -0.01254368f, -0.00756016f, -0.01930137f, -0.05980207f, -0.01749116f, 0.00808821f, -0.06209158f, -0.02069966f, 
    0.00322869f, -0.06220381f, -0.02534302f, -0.05473673f, -0.05745343f, -0.02791463f, -0.02585073f, 0.03989244f, 
    -0.03667878f, 0.03771885f, 0.01477860f, 0.02918251f, 0.03155533f, 0.01987038f, -0.03981587f, 0.00579728f, 
    0.04581761f, 0.04463432f, -0.03448813f, -0.03335653f, 0.03490495f, -0.00909123f, -0.06055184f, -0.01565115f, 
    -0.04421185f, -0.04977773f, -0.05670479f, -0.03138767f, 0.03087249f, -0.01335889f, 0.04391775f, 0.03095703f, 
    -0.00942252f, -0.06074730f, 0.00466819f, 0.03278115f, -0.00164795f, 0.02191439f, -0.00119271f, -0.04931005f, 
    0.00648186f, -0.05149456f, 0.04067769f, -0.01309907f, -0.00469997f, -0.00453889f, 0.00202677f, -0.02670107f, 
    0.02917767f, -0.02353927f, -0.06023479f, -0.05143254f, -0.03787844f, -0.03467526f, -0.04975910f, -0.02904566f, 
    -0.06744286f, -0.05361000f, 0.00121306f, 0.00213591f, -0.02028913f, -0.03320791f, -0.00624258f, -0.02463752f, 
    0.00047567f, -0.04586451f, -0.04439776f, 0.04830522f, 0.00504998f, 0.03497088f, 0.00071816f, 0.03634864f, 
    0.02299379f, -0.03918842f, -0.02164001f, 0.00887159f, -0.05619449f, -0.01213504f, -0.02419381f, -0.03433182f, 
    0.09317200f, 0.03979000f, 0.11248054f, 0.13511486f, -0.02283754f, -0.01124306f, -0.01600312f, 0.10853305f, 
    0.12050393f, -0.10304976f, 0.14249752f, -0.22446977f, 0.18671146f, 0.00449369f, -0.12935372f, 0.03014004f, 
    0.02876020f, 0.12110642f, 0.29520190f, 0.29700309f, -0.08611137f, 0.15346909f, 0.02383945f, 0.00023756f, 
    -0.00576563f, 0.17026721f, 0.14478330f, -0.12286320f, 0.00885877f, -0.24693567f, -0.05211438f, 0.06851868f, 
    -0.17813896f, -0.06130509f, 0.14770608f, 0.17144252f, 0.10435490f, -0.16834335f, -0.02915580f, 0.02879444f, 
    0.01040140f, 0.05116902f, -0.15859383f, -0.00245447f, 0.23278177f, 0.26606533f, -0.07912312f, 0.10579924f, 
    -0.13063529f, 0.09535514f, -0.11178894f, -0.04091778f, -0.16810730f, 0.17347124f, -0.07447172f, -0.77686226f, 
    -0.05776670f, 0.06384348f, -0.15108845f, -0.09523997f, 0.01831928f, 0.14699583f, -0.08404715f, 0.24788961f, 
    0.16617191f, -0.07586887f, -0.09713104f, -0.11903622f, 0.26840243f, 0.01110336f, 0.04173787f, 0.06137929f, 
    0.08577697f, 0.39895776f, 0.21406220f, -0.10447732f, -0.07745458f, -0.07970291f, 0.02737638f, 0.22072849f, 
    -0.00514660f, 0.13249634f, -0.13223208f, -0.06295441f, 0.02802511f, -0.00682969f, -0.00039309f, 0.01723286f, 
    0.01221247f, 0.14883138f, 0.18225253f, 0.00972372f, 0.10505194f, -0.09097125f, -0.17870274f, -0.04511340f, 
    -0.06410832f, -0.02815059f, -0.09611361f, -0.13514207f, 0.18938421f, -0.10559208f, 0.10951030f, -0.14301975f, 
    -0.21947518f, 0.01890178f, 0.23134904f, 0.27050385f, -0.29049933f, 0.24782941f, -0.00702047f, -0.31802192f, 
    0.06795404f, -0.04985144f, 0.02191755f, 0.08645629f, -0.02331349f, 0.00348735f, -0.03991517f, 0.12522873f, 
    0.08445840f, 0.00204007f, -0.00906878f, 0.26378638f, 0.01140187f, 0.11951436f, -0.00891944f, -0.16451710f, 
    0.11031538f, -0.00416517f, 0.04855056f, 0.03521281f, -0.05409994f, 0.08777366f, 0.10345379f, -0.35527641f, 
    -0.40531412f, 0.23890911f, -0.01289987f, 0.23805815f, 0.07558426f, 0.19115841f, 0.17954251f, 0.25299901f, 
    -0.34710911f, -0.70735645f, -0.08048676f, 0.06101625f, 0.02327863f, -0.00935669f, 0.06201232f, -0.04861845f, 
    -0.07498771f, -0.16868798f, -0.02318450f, 0.09633703f, -0.09316381f, 0.06920887f, -0.09248425f, -0.25927997f, 
    0.05590110f, 0.03690912f, 0.04009795f, 0.06905465f, -0.16037513f, -0.10095420f, 0.00129845f, -0.04241695f, 
    0.03982900f, -0.10259116f, 0.06714662f, -0.22911207f, 0.11283118f, -0.28027192f, 0.11914603f, 0.06868924f, 
    -0.21805753f, 0.11750109f, 0.00958927f, -0.19801979f, 0.19298600f, 0.25313744f, -0.03273270f, 0.10627166f, 
    -0.15482405f, 0.14204566f, -0.20872192f, -0.05720647f, 0.00661187f, -0.46890184f, -0.50970143f, -0.01626905f, 
    0.29942358f, -0.04666271f, -0.10017198f, -0.11000621f, -0.04066074f, -0.04364863f, -0.17556612f, 0.30173865f, 
    0.05074671f, -0.26023760f, 0.07691691f, 0.21503095f, -0.03319033f, -0.11301318f, 0.01093702f, -0.43994209f, 
    -0.07298498f, 0.09193183f, 0.22750530f, 0.08025318f, 0.24179907f, 0.07735837f, 0.07770188f, 0.13185363f, 
    0.16695285f, 0.18435913f, 0.32842222f, -0.24077696f, -0.05737770f, -0.09364475f, 0.12518169f, -0.15048088f, 
    0.08153049f, 0.17648165f, -0.15444288f, 0.16455702f, 0.20851444f, 0.01328852f, 0.07779800f, 0.05206451f, 
    -0.07345273f, 0.09726840f, 0.30109054f, 0.11114442f, -0.03133375f, -0.17146626f, 0.02643093f, 0.02618664f, 
    0.01048709f, -0.00726795f, -0.01598580f, 0.24101818f, -0.15468885f, -0.23465024f, 0.08927682f, -0.14961718f, 
    0.09963875f, -0.24963288f, 0.16021706f, -0.14903083f, 0.16233400f, -0.05625934f, 0.05417538f, -0.05253261f, 
    -0.21267368f, 0.03486712f, 0.11384432f, 0.14254315f, -0.03441558f, -0.03580885f, 0.11511387f, -0.16901092f, 
    -0.02235470f, -0.08080296f, -0.02484307f, -0.00104468f, -0.28990802f, -0.10274607f, 0.05227584f, 0.35601503f, 
    0.20717664f, -0.12451705f, -0.09466838f, 0.05236290f, 0.06326476f, -0.07792248f, 0.06764323f, -0.36071482f, 
    -0.01920029f, 0.21207312f, -0.10894722f, 0.00884136f, -0.18344839f, 0.07825044f, 0.04622842f, 0.00517181f, 
    -0.25144881f, -0.14193141f, -0.38102475f, 0.12485066f, 0.27718005f, 0.29605627f, 0.17320348f, 0.03795614f, 
    -0.08171376f, 0.10488524f, -0.06262198f, -0.03855057f, 0.01328834f, 0.07162690f, 0.20306812f, -0.05118724f, 
    0.07709680f, 0.17196386f, -0.22128150f, -0.07114120f, -0.10721999f, -0.25044441f, -0.06121033f, 0.00965141f, 
    -0.09359813f, 0.12244444f, -0.01588838f, -0.26542109f, 0.09817137f, -0.14196610f, 0.11555282f, -0.02595753f, 
    0.03746576f, -0.08439426f, 0.03972453f, -0.14639150f, -0.09824859f, -0.32529989f, -0.04840215f, 0.11077251f, 
    0.30930376f, 0.09416480f, 0.07343213f, -0.11348174f, 0.07643233f, 0.18720141f, 0.31620279f, 0.09041002f, 
    -0.00207899f, 0.07175244f, -0.23100045f, 0.09912844f, 0.16551518f, 0.24307574f, 0.26771092f, -0.36049393f, 
    0.09289067f, 0.09740894f, 0.15226275f, 0.00224061f, 0.04650942f, -0.02514756f, -0.13365962f, 0.27375579f, 
    -0.07009375f, -0.23989852f, 0.08243278f, -0.07967847f, 0.03832406f, 0.34274998f, 0.21755029f, 0.07484634f, 
    0.00981805f, -0.12239988f, -0.09515134f, 0.23070201f, 0.06869852f, 0.01291199f, -0.02206331f, 0.06119914f, 
    -0.18394762f, -0.02794622f, 0.03163907f, -0.06946401f, -0.09378799f, 0.15608707f, 0.04036576f, 0.16050488f, 
    0.09451021f, 0.00332080f, 0.22757149f, 0.28409368f, 0.32922876f, -0.20517741f, -0.10899404f, -0.14192832f, 
    -0.20405632f, -0.04076178f, 0.06271069f, 0.03427552f, -0.04961871f, 0.08388729f, -0.10893866f, 0.05806832f, 
    -0.14258431f, -0.05580213f, 0.03802381f, 0.17309496f, -0.11713802f, 0.13316242f, 0.05289681f, -0.02493067f, 
    -0.07404921f, 0.05182288f, 0.01965996f, -0.01876047f, -0.12396365f, 0.39835465f, 0.08010665f, -0.15361589f, 
    0.06910801f, 0.05578085f, -0.07607364f, 0.25852332f, 0.19204767f, 0.22422931f, 0.37881941f, -0.14305781f, 
    0.04320970f, 0.10584460f, -0.10993624f, 0.20814098f, 0.15854676f, 0.05888760f, -0.05097668f, -0.07163638f, 
    -0.36347485f, 0.10951818f, -0.02087183f, 0.07122561f, 0.02234975f, 0.00354915f, 0.01662758f, -0.14602382f, 
    0.26672238f, -0.04927498f, 0.01107246f, 0.03688395f, 0.24883439f, -0.05163599f, 0.08642734f, 0.21311362f, 
    0.01377470f, -0.29884177f, -0.24215673f, -0.02694998f, 0.20841284f, 0.07679474f, -0.05898953f, -0.03309799f, 
    0.15774842f, 0.09293580f, -0.12833601f, 0.13789469f, 0.31087196f, -0.19105987f, 0.03153368f, 0.06025920f, 
    0.13385536f, 0.05722231f, 0.09362841f, -0.11865897f, -0.37340695f, -0.03351903f, -0.05557523f, -0.07376122f, 
    0.10389923f, 0.00787641f, 0.04725083f, 0.28274477f, 0.12959726f, 0.17916065f, -0.07462375f, -0.00820573f, 
    0.14214630f, -0.23367819f, 0.25582546f, -0.07098873f, 0.43669549f, 0.08692698f, -0.54063857f, -0.19463609f, 
    0.01344470f, 0.06109700f, -0.02680913f, 0.29217544f, -0.09685117f, 0.06175235f, -0.14998883f, -0.15837063f, 
    -0.05415029f, -0.20744008f, -0.02736993f, 0.09744994f, 0.14639306f, -0.06666073f, 0.28770345f, -0.00972931f, 
    0.07914995f, 0.11248733f, 0.06855169f, 0.05149704f, 0.17029206f, -0.06717375f, -0.17425814f, -0.38596392f, 
    -0.05895894f, -0.09047927f, 0.06882928f, -0.12747756f, -0.16364574f, 0.10746202f, 0.00906993f, -0.18918367f, 
    -0.21939605f, -0.04387682f, -0.21934019f, 0.04127558f, 0.18085767f, 0.14061919f, 0.28054550f, 0.06600320f, 
    0.08132638f, -0.08959448f, -0.40364677f, 0.02073224f, -0.08561393f, -0.01116509f, -0.13615175f, 0.42351210f, 
    0.03585434f, 0.01776914f, 0.02883525f, 0.28229609f, -0.07081833f, -0.03787331f, 0.11922873f, -0.08401350f, 
    -0.03725645f, 0.07525648f, -0.13271177f, -0.16339608f, 0.00994149f, -0.08921349f, 0.20182577f, 0.00852375f, 
    0.03007198f, 0.10807034f, -0.07499740f, 0.06727661f, -0.17239946f, -0.26189217f, -0.18934219f, -0.02904484f, 
    0.15332614f, -0.32864955f, 0.25930226f, -0.13872831f, 0.26249519f, 0.00999805f, -0.11036933f, 0.09932391f, 
    -0.05361920f, -0.06264390f, 0.03659601f, 0.24058233f, 0.00468975f, 0.21167725f, -0.06252204f, -0.25312003f, 
    0.15153652f, 0.06364532f, 0.00413087f, 0.18475224f, 0.03945793f, 0.00586713f, -0.15852785f, 0.31719992f, 
    -0.18769692f, 0.06033338f, 0.11598366f, 0.13155159f, -0.01687768f, -0.30999941f, -0.12160233f, 0.16401453f, 
    -0.03131618f, 0.29330269f, 0.30784178f, -0.13214800f, -0.12016860f, -0.07159916f, 0.15039428f, 0.20976119f, 
    0.08873347f, 0.04569957f, -0.32832417f, -0.09960433f, 0.04083767f, 0.07121851f, 0.02416968f, 0.01161513f, 
    0.23344697f, 0.03961962f, 0.14928073f, 0.05329854f, 0.02784596f, -0.18250033f, -0.11657940f, -0.02833400f, 
    0.20904206f, 0.17146586f, -0.14710718f, 0.05400366f, 0.26744184f, -0.04939860f, 0.00089668f, -0.09727747f, 
    -0.14739257f, -0.20453790f, 0.20715064f, 0.04288671f, 0.13668069f, 0.24829248f, -0.02411001f, -0.06344116f, 
    -0.13793078f, -0.05438193f, 0.37102336f, -0.15191793f, -0.12295135f, -0.16539873f, -0.22804701f, -0.25402620f, 
    0.04654455f, 0.19629720f, -0.00020170f, -0.03232611f, -0.14114827f, -0.25203663f, 0.30960241f, -0.09354334f, 
    -0.19183013f, -0.06461759f, 0.06071243f, -0.01874827f, 0.26036486f, 0.05147771f, -0.07201253f, 0.00044939f, 
    0.35620895f, 0.34760556f, 0.05494415f, -0.05944689f, 0.03394379f, -0.07829302f, -0.09072864f, 0.03823296f, 
    0.06458811f, -0.09389850f, -0.07319184f, -0.28696799f, 0.19210029f, 0.32287717f, 0.10848874f, -0.44130135f, 
    -0.03163232f, -0.12474222f, -0.09293018f, -0.12889926f, -0.28249884f, 0.02612416f, 0.03831403f, 0.29970858f, 
    0.07751252f, 0.07158792f, -0.14165816f, 0.15830369f, 0.16843478f, -0.35668397f, -0.05108810f, 0.08988549f, 
    0.22342768f, 0.21955614f, -0.08507665f, -0.34363085f, -0.16050872f, 0.07171007f, -0.03241437f, -0.09474450f, 
    -0.11667778f, 0.12595490f, 0.15196463f, 0.10777276f, 0.11875124f, 0.18198816f, 0.10833553f, -0.03323188f, 
    0.08528971f, 0.00729261f, 0.13484286f, -0.02896020f, -0.11851776f, -0.07700616f, -0.24020188f, -0.35884449f, 
    0.08720245f, -0.00812375f, -0.07073145f, -0.02089374f, 0.03023214f, 0.07429268f, 0.05730749f, -0.10702912f, 
    0.07570408f, 0.18586874f, 0.05988710f, -0.04109667f, -0.18526140f, 0.12274028f, -0.01941977f, 0.33360878f, 
    -0.09092956f, -0.18680872f, 0.02932669f, 0.26842099f, -0.08765969f, 0.13264960f, -0.06423350f, -0.16857368f, 
    0.06794114f, 0.21350978f, -0.15383989f, 0.06372619f, -0.05469438f, 0.01933622f, -0.00373637f, 0.12378221f, 
    0.01957943f, -0.17075418f, 0.38953447f, 0.09228239f, -0.42858702f, 0.27131912f, 0.04463767f, 0.17802405f, 
    -0.03259828f, -0.08015285f, 0.01946265f, -0.07421266f, 0.06720848f, -0.42327741f, -0.14844796f, 0.24449265f, 
    0.37351882f, 0.12111626f, 0.24582842f, -0.13846464f, -0.08733698f, -0.08199759f, -0.12936716f, 0.06341715f, 
    -0.09702665f, 0.02996780f, -0.15698166f, -0.13437526f, -0.27799150f, -0.50074911f, -0.19392908f, 0.12949614f, 
    -0.02353885f, 0.23524337f, 0.00284646f, 0.26102853f, -0.06561300f, -0.05321809f, 0.03483481f, -0.06402536f, 
    0.18549700f, 0.15043394f, 0.07252005f, -0.20048934f, 0.13306369f, 0.19677410f, -0.04184661f, -0.10948346f, 
    0.03729966f, -0.38596871f, 0.03466488f, 0.00915757f, 0.00929262f, 0.19042629f, 0.17779647f, 0.15648729f, 
    -0.11488340f, 0.01901291f, -0.30729347f, 0.11361227f, 0.10786845f, -0.07046880f, -0.10819936f, -0.00134775f, 
    -0.27841491f, -0.27599490f, 0.13273914f, 0.41166660f, 0.18590398f, -0.01178213f, 0.00616570f, 0.00830587f, 
    -0.16301836f, -0.01121970f, 0.07961139f, -0.16788514f, 0.19602564f, 0.10407340f, 0.20257038f, -0.08712777f, 
    -0.01171064f, 0.14204095f, -0.06817627f, 0.17575036f, 0.20478158f, 0.00189740f, -0.07730155f, -0.26458818f, 
    -0.08448890f, -0.03902601f, 0.06263578f, 0.25170118f, -0.07368899f, 0.04917992f, -0.17871900f, 0.03890912f, 
    0.05286872f, -0.20951143f, 0.10854373f, -0.04143105f, 0.01440600f, -0.17422026f, -0.19222936f, -0.18231773f, 
    0.00951526f, 0.02293803f, -0.06299403f, -0.07382834f, -0.13977273f, -0.11846116f, 0.15837747f, 0.07296757f, 
    -0.15596107f, 0.12863795f, 0.04145198f, -0.04815624f, 0.11187919f, 0.05781813f, -0.05990336f, 0.20215307f, 
    -0.12758180f, -0.23470795f, 0.09987080f, 0.01647722f, -0.07783827f, 0.13546294f, 0.17835669f, -0.23132773f, 
    0.30241621f, -0.03554061f, -0.03158564f, -0.01753762f, -0.29529488f, -0.15661737f, -0.23730305f, 0.01345873f, 
    0.12346947f, 0.03273036f, 0.05001097f, 0.05601401f, 0.02374859f, 0.24454586f, -0.05045881f, 0.04013580f, 
    0.05154162f, -0.22014277f, 0.03019593f, -0.13485101f, 0.19786304f, -0.11689521f, 0.01595156f, 0.21146601f, 
    -0.02659693f, 0.16744895f, 0.06888653f, 0.17568168f, -0.08402409f, -0.23674506f, 0.03319514f, -0.03426784f, 
    0.04312162f, -0.11708076f, 0.00271286f, -0.09334560f, -0.24843469f, 0.11940233f, -0.22571981f, -0.02668029f, 
    -0.09513866f, -0.00390973f, -0.31058264f, 0.03121014f, 0.11319181f, -0.26785493f, 0.13598210f, -0.06686446f, 
    0.10105395f, -0.12055304f, 0.14752156f, -0.12831017f, -0.14426900f, 0.04124236f, 0.13251530f, 0.07324248f, 
    -0.13122903f, -0.05819645f, -0.15157536f, -0.18817893f, 0.11318770f, 0.28583312f, 0.05478335f, -0.09058674f, 
    -0.02342528f, 0.14917304f, -0.10032289f, 0.05275815f, 0.02874976f, 0.04931788f, 0.13677330f, 0.06556391f, 
    0.02101120f, 0.02352408f, 0.07276984f, -0.06966156f, 0.18577696f, -0.12092264f, 0.05025321f, 0.01367256f, 
    0.07238262f, 0.08228724f, -0.22298309f, -0.09094539f, 0.19012010f, 0.00771470f, -0.03991766f, -0.13839002f, 
    -0.10911844f, -0.03794695f, 0.13044567f, -0.21251543f, 0.08086482f, 0.29290700f, 0.00958758f, -0.11973594f, 
    -0.00017125f, -0.16875798f, -0.17385562f, -0.40093869f, -0.22736335f, 0.39580968f, -0.17504776f, -0.01190238f, 
    0.02900138f, 0.01129239f, 0.10033754f, -0.17621370f, -0.04415718f, 0.27493307f, 0.39443308f, 0.05695949f, 
    -0.01931979f, 0.08685303f, 0.10274877f, 0.10191694f, -0.01279269f, 0.06238160f, -0.09864774f, -0.14078490f, 
    -0.12460246f, -0.05355102f, 0.06785203f, -0.20932139f, 0.10606908f, 0.04846661f, -0.08082600f, 0.26506382f, 
    -0.07253148f, -0.06985365f, 0.00660365f, -0.09454466f, -0.14461316f, 0.01150116f, 0.05379387f, 0.24288009f, 
    0.07862047f, -0.15333392f, 0.16914132f, -0.12975343f, -0.04761612f, 0.06359062f, 0.08227003f, 0.24078391f, 
    0.12079646f, 0.14338173f, -0.01955285f, -0.03796303f, -0.11280248f, -0.09808828f, -0.19036509f, 0.04120423f, 
    0.07064415f, -0.19644782f, 0.03889934f, 0.11665680f, -0.12818994f, -0.25859880f, 0.04864669f, -0.15291944f, 
    0.16454111f, 0.08034284f, -0.13760911f, 0.01735380f, 0.07387248f, -0.03175134f, -0.05839490f, -0.04406614f, 
    -0.04272923f, -0.08761118f, -0.04572793f, -0.08895011f, 0.20234339f, 0.10487495f, -0.02032351f, 0.15421556f, 
    -0.05749734f, -0.15801926f, 0.03214402f, -0.19622439f, 0.06370080f, -0.36954167f, -0.22815861f, -0.12890376f, 
    0.22009419f, 0.40614331f, 0.13010661f, 0.31489876f, -0.39830443f, 0.37156141f, 0.23851889f, 0.12558733f, 
    0.06398129f, -0.16744128f, 0.03926565f, -0.20671242f, 0.21471329f, -0.03869907f, 0.18631838f, 0.04795492f, 
    -0.27107221f, 0.16421369f, -0.08924769f, -0.25156200f, 0.07901952f, -0.07398828f, -0.16965130f, 0.10029443f, 
    -0.18669076f, -0.02416753f, -0.18482390f, -0.11510094f, -0.05911111f, 0.13341124f, 0.11779711f, 0.06130064f, 
    -0.12321498f, -0.07750362f, 0.09583072f, -0.07156000f, -0.00247145f, 0.01264500f, 0.17631367f, -0.03815173f, 
    0.02598521f, -0.04854594f, 0.12235474f, 0.27375862f, 0.00086176f, -0.04945942f, 0.04733930f, -0.18284506f, 
    0.16675633f, 0.12536296f, 0.08440715f, 0.28577107f, -0.03886463f, 0.12897535f, -0.10852347f, -0.25886080f, 
    -0.08757209f, 0.01336826f, 0.08044460f, -0.24337237f, -0.12299389f, -0.24853118f, -0.09103393f, -0.01027389f, 
    -0.17794742f, 0.13513231f, 0.24418433f, 0.16111322f, 0.28793871f, -0.15798633f, 0.02734575f, -0.03587448f, 
    -0.04197854f, -0.40249094f, 0.12982310f, 0.05391165f, 0.22873180f, 0.06396212f, 0.27541223f, 0.10031516f, 
    0.19215749f, 0.06580365f, -0.13667905f, 0.17132230f, 0.18761854f, -0.04793471f, -0.06393138f, 0.04412893f, 
    0.17713682f, -0.00756090f, 0.01314586f, -0.07207102f, 0.07962862f, 0.09981491f, 0.15866412f, 0.10322648f, 
    -0.22786015f, 0.07169983f, -0.06625190f, 0.19734727f, 0.20413184f, 0.10180485f, 0.19208190f, -0.29243195f, 
    0.05350876f, -0.04943635f, -0.04512703f, -0.02106295f, -0.01972944f, 0.05408326f, -0.06683537f, -0.05737314f, 
    0.01423913f, 0.00333056f, 0.04535135f, -0.02203526f, 0.04624224f, 0.01807896f, -0.00163863f, 0.01928225f, 
    0.01253748f, 0.03060503f, -0.01450052f, 0.01435617f, 0.02398952f, -0.01446850f, 0.02113691f, -0.06671105f, 
    0.03186664f, 0.03748627f, -0.04860969f, 0.01236026f, -0.05120170f, 0.04491031f, 0.00655832f, -0.02429160f, 
    -0.06073923f, -0.03901780f, -0.01951558f, -0.00975162f, 0.02688090f, -0.02526775f, -0.03802131f, 0.01483083f, 
    0.00804830f, -0.01003773f, -0.06240316f, -0.04259078f, 0.03776306f, 0.05198600f, -0.06824864f, -0.04236671f, 
    -0.02277974f, 0.01435450f, -0.02251110f, 0.02240238f, 0.00602478f, 0.02500614f, 0.02627245f, -0.01100717f, 
    0.04731179f, -0.00500850f, -0.04588880f, 0.01346063f, 0.04506699f, 0.03450019f, 0.00535878f, -0.05345295f, 
    -0.05296903f, -0.04701734f, -0.00666854f, -0.04176096f, 0.02503336f, -0.01467799f, 0.00581589f, 0.05031477f, 
    -0.03394262f, 0.04336596f, 0.02085863f, -0.00320295f, -0.03703383f, -0.01151629f, -0.03648111f, 0.00396595f, 
    0.00901940f, 0.04988587f, -0.00118310f, -0.01231725f, -0.00866439f, 0.00147647f, 0.04774082f, -0.04012054f, 
    -0.00896812f, 0.03357583f, 0.04710309f, -0.02148546f, -0.03148195f, -0.03990640f, 0.02411358f, -0.05277415f, 
    -0.01437489f, -0.03243849f, 0.03223680f, -0.01116747f, -0.05830107f, -0.01074499f, 0.03704507f, 0.01494276f, 
    -0.03887573f, 0.02268757f, 0.01112641f, -0.02053087f, 0.03319620f, -0.00103205f, -0.01162189f, 0.03305468f, 
    -0.06669556f, -0.03516372f, -0.00063118f, 0.02660171f, -0.01289389f, -0.01256453f, -0.01858009f, -0.05871956f, 
    0.01236668f, 0.00457298f, -0.04862369f, -0.01471132f, 0.02782650f, -0.06290093f, -0.00606280f, 0.03546255f, 
    0.03265876f, -0.00941453f, 0.00864062f, -0.07109337f, -0.02214595f, 0.02402749f, -0.06872941f, 0.03324290f, 
    -0.05798937f, 0.00813460f, 0.03908338f, 0.00190895f, -0.01468128f, -0.04797190f, -0.00319872f, -0.01450866f, 
    -0.06326713f, -0.04976235f, -0.04321644f, 0.01711678f, -0.01172990f, -0.01559507f, 0.00132057f, 0.02859979f, 
    -0.01891595f, -0.04615860f, 0.03551565f, 0.03329630f, -0.00692003f, -0.00625644f, -0.00875150f, 0.04749100f, 
    0.00397372f, 0.04775382f, -0.05521660f, -0.00497573f, -0.03697257f, -0.02575377f, 0.02681953f, 0.01409237f, 
    -0.03384061f, -0.05265047f, -0.01604571f, 0.02817123f, -0.06581479f, -0.00136937f, 0.02562016f, 0.01529093f, 
    0.00478317f, -0.03263183f, 0.00812299f, -0.01024169f, 0.02617433f, -0.02690081f, 0.00885918f, -0.03473662f, 
    0.02871648f, 0.03486828f, -0.02717868f, -0.03195171f, 0.02923447f, -0.03575164f, 0.01941483f, 0.01571208f, 
    0.02793860f, 0.05314006f, -0.05561012f, -0.00196677f, -0.03582862f, 0.04010420f, 0.03368515f, -0.02872775f, 
    0.04824047f, -0.02827404f, 0.04812745f, -0.05046053f, -0.04278264f, -0.00117392f, -0.01594477f, 0.03302277f, 
    0.01288140f, -0.01102528f, -0.05898158f, 0.04245605f, 0.04858786f, 0.01984063f, -0.04107352f, -0.01352086f, 
    0.01331129f, -0.05514686f, -0.04473092f, -0.03301368f, -0.00910337f, 0.02925440f, 0.01713060f, 0.03670431f, 
    0.05400259f, -0.01928474f, 0.03640312f, -0.05735638f, -0.02608533f, -0.05645481f, -0.00346238f, 0.01873548f, 
    -0.03039409f, -0.03463025f, -0.00259794f, -0.05543205f, -0.01902375f, -0.00903007f, 0.02654307f, 0.05324361f, 
    0.03632988f, 0.03824564f, -0.06212852f, -0.04312813f, -0.05956227f, 0.02173844f, -0.05797398f, -0.05716876f, 
    0.04308269f, 0.04605878f, 0.01689004f, -0.00003726f, 0.00690130f, -0.03457662f, 0.03112485f, -0.02248063f, 
    -0.06982630f, -0.06488775f, 0.03448033f, -0.01552983f, -0.06022001f, 0.03876344f, 0.01151307f, -0.04542034f, 
    -0.03035494f, -0.05776420f, -0.00186513f, -0.02363338f, -0.01591454f, -0.04642085f, -0.05942516f, 0.01458051f, 
    -0.02650076f, 0.04470434f, 0.03263499f, -0.04444544f, -0.05083714f, 0.04310474f, 0.04465649f, -0.01060566f, 
    -0.04530014f, 0.03143471f, 0.01309463f, 0.03866149f, -0.01521691f, -0.06739900f, -0.00034144f, 0.01102357f, 
    0.01069460f, 0.02270428f, -0.04902551f, -0.06571030f, -0.00823944f, 0.04338959f, -0.04890005f, 0.04299643f, 
    -0.03041624f, -0.02298228f, 0.01171336f, -0.03422808f, 0.02398663f, -0.02613771f, 0.02409192f, 0.01611824f, 
    -0.00776514f, 0.00178892f, -0.04504289f, -0.04740483f, -0.01467206f, -0.01703280f, 0.04578481f, -0.03668540f, 
    -0.03379286f, -0.04506216f, -0.00219307f, 0.00481105f, 0.03926785f, 0.00378305f, 0.04562218f, 0.03430637f, 
    0.04101454f, 0.01914913f, -0.06037703f, 0.00757147f, -0.05547679f, 0.04783438f, -0.00718658f, -0.03462446f, 
    0.03383903f, 0.00256838f, 0.04913988f, -0.05502379f, -0.02442878f, -0.04464654f, 0.03087384f, 0.03623096f, 
    -0.02763608f, -0.05616718f, 0.02633874f, 0.02590729f, -0.03721598f, 0.01908955f, -0.02714520f, 0.00746882f, 
    -0.00910710f, -0.04219486f, -0.06405500f, 0.00936718f, -0.06022910f, -0.02762999f, 0.02202110f, -0.05183622f, 
    -0.00089006f, -0.02669490f, -0.02682669f, -0.06226256f, -0.05714357f, -0.04415787f, -0.00866243f, -0.04327888f, 
    -0.04985680f, -0.05297903f, -0.06587254f, 0.02267956f, -0.01333913f, 0.03501008f, 0.03144036f, 0.00488199f, 
    -0.00719667f, -0.06451831f, 0.03538615f, -0.00044191f, 0.02478650f, 0.01567745f, 0.03043108f, -0.06045794f, 
    -0.04756945f, -0.05825395f, 0.04200211f, -0.01381076f, -0.05045225f, 0.00686013f, -0.00390403f, 0.03921814f, 
    -0.06174230f, 0.04222162f, -0.03781135f, -0.06104643f, -0.04593017f, -0.00156681f, 0.02215312f, 0.03449547f, 
    -0.02719639f, -0.03684356f, 0.03083898f, 0.03777213f, -0.05190130f, -0.01868570f, -0.05663713f, -0.01686482f, 
    -0.05827228f, 0.02351369f, -0.03529150f, -0.05257983f, 0.02566562f, 0.04729114f, -0.06792213f, -0.00788156f, 
    -0.01441812f, 0.00789190f, -0.06747332f, -0.04740332f, -0.05127542f, -0.05141343f, -0.03673068f, -0.02356969f, 
    -0.06122368f, -0.06812283f, -0.02120996f, 0.02528639f, 0.03146473f, -0.05777363f, 0.02287591f, -0.00267882f, 
    -0.01529399f, 0.03133207f, 0.02248140f, -0.03839220f, -0.00199786f, -0.03459103f, -0.00716671f, 0.02686818f, 
    -0.05661882f, 0.01853212f, -0.06705971f, 0.04229040f, 0.01563435f, -0.05128259f, -0.02572655f, 0.01051641f, 
    -0.06494419f, 0.02550078f, -0.01787801f, -0.00685156f, -0.05662033f, 0.04948202f, 0.01661323f, -0.02205886f, 
    0.04035246f, -0.03740042f, -0.06559642f, -0.04561814f, 0.04543129f, 0.03425872f, -0.00104535f, -0.03324350f, 
    0.00031627f, -0.01542014f, 0.04589831f, 0.02270802f, -0.00113709f, 0.00002458f, 0.04599428f, 0.02369666f, 
    0.00494498f, 0.00731801f, -0.01986241f, -0.03604735f, -0.05807462f, 0.01562912f, 0.03996452f, 0.00087241f, 
    0.02876152f, -0.04730835f, -0.05080370f, -0.01790616f, 0.04871393f, 0.01836527f, 0.01110218f, -0.01084710f, 
    -0.06071209f, -0.06285304f, 0.02463679f, 0.02880794f, 0.03471097f, 0.02902781f, -0.03629071f, 0.00677197f, 
    -0.01369246f, 0.04675487f, -0.03876647f, -0.05142761f, -0.02792289f, -0.02174372f, 0.02036644f, 0.04072820f, 
    0.03485031f, -0.00273490f, -0.06070736f, 0.00495558f, -0.01603540f, 0.00351543f, -0.06622908f, 0.04613812f, 
    0.00822849f, 0.02770986f, 0.05093619f, -0.02658319f, 0.02631387f, 0.04016431f, 0.01909539f, -0.00665919f, 
    -0.02848550f, 0.03963571f, -0.00518786f, -0.06538870f, 0.01634173f, -0.02715424f, 0.03876958f, 0.01409952f, 
    -0.05909815f, -0.01178988f, -0.05801315f, 0.02189566f, 0.00579439f, -0.05225385f, 0.00345953f, 0.00826619f, 
    -0.02523784f, 0.00980390f, -0.06488696f, -0.00235626f, 0.03893428f, -0.06678059f, -0.02599205f, 0.03480670f, 
    -0.05508850f, -0.01363744f, 0.02191277f, -0.05220339f, -0.04554771f, -0.04702838f, 0.03991026f, 0.01480661f, 
    0.04086846f, -0.02778119f, -0.05237092f, 0.00384926f, -0.01160922f, -0.05520867f, -0.01477014f, -0.01742681f, 
    -0.02363355f, 0.00785532f, -0.06172599f, -0.01562838f, -0.01244638f, 0.00716085f, -0.05699236f, 0.04048040f, 
    0.03767434f, 0.01663920f, -0.04379615f, 0.03473755f, -0.02605900f, 0.01423380f, 0.04707976f, -0.00736250f, 
    0.00836572f, 0.00845384f, -0.06650246f, 0.02918277f, -0.00775404f, 0.01250426f, 0.04186935f, -0.01482997f, 
    -0.18154426f, -0.02988878f, -0.00581578f, -0.10793757f, 0.22224136f, 0.10626977f, 0.01081529f, 0.19746695f, 
    -0.07556430f, 0.03161789f, -0.07012651f, 0.00652042f, -0.03209083f, -0.01912649f, 0.16533722f, -0.05715067f, 
    0.11276383f, 0.04830759f, 0.11607263f, 0.08942166f, -0.36877924f, -0.05877631f, -0.19100653f, 0.01059461f, 
    0.07150050f, 0.03742047f, 0.00189098f, -0.20823401f, 0.00316889f, 0.05762197f, 0.06878088f, -0.01982241f, 
    -0.50915831f, -0.07524189f, -0.23621762f, -0.09441335f, -0.07112399f, 0.16006282f, -0.33225328f, -0.03208226f, 
    0.19468249f, 0.08442371f, -0.27147031f, 0.03605792f, -0.06349633f, 0.19827825f, 0.09903236f, 0.19214433f, 
    0.07405699f, 0.05669331f, 0.02964971f, 0.13625525f, -0.03140802f, -0.17373407f, -0.05914876f, -0.11169160f, 
    -0.33348554f, 0.00259094f, 0.10626061f, 0.24156171f, 0.01149262f, 0.21683380f, -0.16759062f, 0.18841419f, 
    0.11112106f, -0.10738672f, 0.20619108f, -0.01295651f, -0.16109699f, 0.00966376f, 0.14312910f, -0.02166101f, 
    0.03872009f, 0.02865946f, -0.00742049f, -0.10864396f, -0.02543227f, 0.06219190f, 0.30895597f, 0.13339962f, 
    0.12098116f, 0.29319260f, 0.30561909f, -0.13133073f, -0.19688241f, 0.02656882f, -0.01867677f, -0.09860542f, 
    -0.01985083f, 0.23154779f, 0.09506854f, 0.14739040f, 0.03168945f, -0.07130136f, -0.03591109f, -0.02332719f, 
    0.10491782f, 0.06623447f, 0.26022065f, 0.06911866f, -0.14501600f, 0.13205054f, 0.11803263f, -0.16623834f, 
    -0.03717260f, 0.12262774f, 0.15353055f, -0.20192556f, 0.17236349f, 0.21405455f, -0.12658124f, -0.26525733f, 
    -0.16579972f, -0.35280144f, 0.19021328f, -0.03457512f, 0.11466274f, 0.27798921f, 0.10971775f, 0.30552459f, 
    0.22767280f, 0.00820072f, -0.06457250f, 0.20114890f, 0.06374259f, -0.22335520f, -0.00949366f, 0.13443434f, 
    -0.19824915f, 0.01902855f, -0.03409788f, 0.10697414f, -0.31631348f, 0.10434277f, -0.16714786f, -0.25796625f, 
    0.00603321f, -0.05254078f, 0.00925872f, -0.10055266f, 0.05838252f, -0.00887625f, 0.06515194f, 0.11074851f, 
    -0.21075723f, -0.35573345f, -0.06547718f, -0.04473844f, 0.14597480f, 0.03062895f, 0.08040439f, 0.08931812f, 
    -0.28908798f, -0.19892843f, -0.21960592f, -0.02295605f, -0.08928819f, 0.06090828f, 0.02316686f, 0.05635322f, 
    -0.00546941f, -0.25809899f, 0.17500077f, 0.17670546f, -0.07896064f, -0.06336797f, -0.05506404f, -0.04903107f, 
    -0.06523997f, 0.18455699f, -0.11942097f, 0.20382819f, -0.44500548f, 0.38666078f, -0.19331759f, -0.08057169f, 
    0.03298835f, 0.09860478f, -0.07965060f, -0.17288163f, 0.02298801f, 0.26802167f, 0.58980083f, 0.13242474f, 
    0.17015690f, -0.04688216f, -0.40224507f, 0.01267232f, -0.17163371f, -0.53646189f, -0.42256367f, 0.05900698f, 
    0.25009447f, 0.06650690f, 0.22062618f, -0.18831958f, -0.03664457f, -0.33616543f, -0.10773923f, -0.02044745f, 
    0.23448087f, -0.04231458f, 0.03418533f, 0.19449264f, -0.19057672f, -0.05044179f, 0.20875432f, -0.42741200f, 
    0.49971229f, 0.24163848f, 0.07318444f, 0.01525320f, 0.07707073f, -0.03376744f, -0.31035921f, -0.14663844f, 
    -0.07780384f, 0.29157972f, -0.18807822f, -0.36571717f, -0.02141473f, 0.02095235f, -0.16872688f, -0.13825774f, 
    0.27335900f, 0.25659570f, -0.09889816f, -0.08280443f, 0.19034664f, 0.06679182f, 0.01165172f, -0.12239932f, 
    -0.02986011f, 0.01470389f, -0.19302820f, -0.15823597f, -0.03818091f, 0.14852111f, 0.10459807f, -0.01232106f, 
    -0.01659702f, 0.30652168f, -0.09682269f, 0.02309836f, 0.09861092f, 0.01217700f, -0.09384114f, 0.15495978f, 
    -0.09279694f, 0.24280864f, -0.22502153f, 0.04898239f, 0.08007584f, 0.16005613f, -0.08177245f, -0.01147610f, 
    -0.05126281f, 0.04702774f, -0.11278708f, 0.14788561f, 0.34074241f, 0.26399744f, -0.06296702f, 0.04826843f, 
    0.07627553f, 0.07993268f, 0.06169916f, -0.07943422f, 0.24943930f, -0.04326657f, 0.07366525f, 0.00555381f, 
    -0.06817225f, 0.02335628f, -0.06349958f, 0.14763908f, 0.04860296f, 0.03309646f, 0.02521927f, -0.25487477f, 
    0.30831748f, 0.14018579f, -0.29141575f, -0.12080991f, -0.02154780f, -0.11282730f, -0.08551395f, 0.03313419f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.19739650f, -0.04745281f, 0.01046304f, 0.04833070f, -0.06755213f, -0.06085093f, 0.16866611f, 0.02867544f, 
    -0.05835306f, 0.19846137f, -0.03338161f, -0.00821203f, 0.03358551f, 0.07610958f, 0.12952636f, 0.08953263f, 
    0.03126658f, 0.06771567f, 0.13288677f, 0.05029625f, 0.03507929f, 0.03588027f, -0.10111767f, -0.26211029f, 
    -0.00983740f, 0.07509199f, 0.17044300f, 0.23797931f, 0.01301345f, -0.00329130f, 0.02288417f, 0.07464179f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.30363375f, -0.09822525f, 0.08856325f, -0.14291966f, -0.27219620f, 0.14073963f, -0.07643561f, -0.06025537f, 
    -0.00031310f, -0.73521376f, -0.41579273f, -0.15013570f, 0.03373738f, 0.28351471f, 0.77945423f, -0.15630583f, 
    -0.24998955f, 0.36106122f, -0.64245749f, 0.49066117f, 0.02172256f, 0.11824087f, -0.24661319f, -0.04432873f, 
    -0.06636941f, 0.16376317f, 0.10157605f, -0.54940403f, 0.36982498f, -0.16285808f, -0.08116414f, -0.00061570f, 
    -0.16855218f, -0.08989985f, 0.01212044f, 0.16094263f, 0.10853771f, -0.15265138f, -0.13200766f, 0.48255295f, 
    0.52023298f, 0.18651213f, -0.38793215f, -0.10098717f, -0.14075617f, -0.17296171f, 0.52947879f, -0.02192836f, 
    -0.03377705f, -0.26774985f, -0.07499553f, 0.01673880f, 0.04476564f, 0.30595139f, -0.09120622f, -0.29162917f, 
    -0.03393850f, -0.29838601f, -0.50153416f, 0.49112570f, 0.07048963f, 0.15946098f, -0.14587475f, -0.03571438f, 
    0.24122828f, 0.03921369f, -0.16254309f, 0.00856629f, -0.19765106f, -0.05992976f, -0.41461995f, -0.24176744f, 
    -0.60296702f, -0.28797457f, -0.25602898f, -0.14390567f, -0.03756094f, -0.22784616f, -0.35029051f, -0.50742072f, 
    0.94470447f, -0.05623439f, 0.08306098f, 0.51345736f, -0.13068725f, 0.24255148f, 0.01159306f, 0.41461512f, 
    -0.14781626f, -0.48943087f, 0.06097784f, -0.17572995f, 0.09458443f, -0.13679220f, -0.02052356f, -0.09803966f, 
    -0.34879431f, 0.15522178f, 0.11408358f, 0.09944401f, -0.31358555f, -0.16932310f, -0.26410815f, 0.24974848f, 
    0.11405708f, -0.10605520f, 0.14857061f, -0.12968759f, -0.08517593f, -0.28524691f, -0.35868335f, 0.08728589f, 
    0.43629953f, -0.14837991f, -0.67935276f, -0.53666830f, 0.00744869f, -0.10005213f, 0.65840721f, -0.12373476f, 
    -0.08214961f, 0.51001227f, 0.44414496f, 0.03198005f, -0.72942585f, 0.06450678f, -0.16191545f, 0.52952665f, 
    0.37821183f, 0.10592111f, -0.16285427f, -0.02835030f, -0.55229539f, 0.14121808f, 0.22633915f, -0.41843030f, 
    -0.06358120f, -0.49004406f, -0.11688296f, -0.13179606f, -0.05859599f, 0.21911779f, -0.55054635f, -0.24997236f, 
    -0.06506843f, 0.42872402f, -0.05842915f, -0.45074704f, -0.10453053f, 0.38382864f, -0.68710637f, 0.03239847f, 
    -0.10843173f, 0.10971224f, 0.22774407f, -0.12769933f, -0.28171194f, 0.13111334f, 0.11826777f, 0.37472138f, 
    0.02961939f, -0.13168316f, -0.05561548f, 0.11468482f, -0.25003698f, -0.01652263f, -0.26589054f, -0.11868657f, 
    0.33888832f, 0.26502693f, 0.41347545f, -0.01880037f, -0.03634438f, 0.11948653f, -0.05406305f, 0.20454505f, 
    -0.52868766f, 0.59026611f, 0.40100300f, 0.28297856f, -0.13599594f, -0.65493685f, -0.25406069f, -0.80871832f, 
    -0.01290667f, -0.26161024f, -0.12290528f, 0.22241135f, 0.08218452f, -0.15441969f, -0.14850554f, -0.38950023f, 
    -0.02713839f, -0.01853637f, -0.13769118f, 0.03053498f, 0.47813183f, 0.00574559f, -0.36153457f, 0.64611202f, 
    -0.31735575f, -0.64281768f, -0.51446646f, 0.11527570f, 0.07769299f, 0.27398062f, -0.12810947f, -0.36251375f, 
    -0.15114567f, -0.30499405f, 0.53417641f, -0.41689366f, -0.01345741f, -0.52019364f, -0.41802266f, 0.09661040f, 
    -0.15071510f, -0.03587896f, 0.27983272f, -0.32950026f, 0.11593669f, -0.02543904f, -0.11922263f, -0.04577668f, 
    -0.30787691f, 0.16817534f, -0.04254574f, -0.16324292f, 0.07008919f, 0.06735210f, 0.16529763f, -0.13763142f, 
    0.28921700f, -0.40034026f, 0.41885257f, -0.10926619f, 0.08184469f, -0.11896025f, -0.27623808f, 0.26530316f, 
    0.09557343f, -0.40993139f, -0.28390419f, -0.19683300f, -0.08875842f, 0.34458894f, 0.02872667f, 0.94442606f, 
    -0.11225463f, -0.29734698f, -0.35166588f, -0.35761169f, -0.07258404f, -0.16473357f, -0.06637986f, 0.14900467f, 
    -0.22482096f, 0.02527439f, -0.05356092f, 0.08741660f, -0.12364581f, 0.07270076f, -0.52618533f, -0.30218938f, 
    0.14072913f, 0.58395511f, 0.16013770f, -0.15888222f, -0.10933290f, -0.46972370f, -0.17588815f, -0.28487390f, 
    -0.15256383f, -0.11523143f, 0.10435942f, -0.22872892f, -0.07403754f, 0.57465965f, 0.46547726f, -0.02145260f, 
    -0.13315538f, 0.73498106f, -0.36503154f, 0.14984049f, 0.46927220f, -0.13766953f, 0.00283035f, -0.48055819f, 
    0.21757460f, 0.12510632f, -0.01510347f, 0.12962011f, -0.38454792f, 0.13261577f, 0.14581585f, -0.42493665f, 
    -0.23774196f, 0.88864553f, -0.06122492f, 0.13007915f, 0.03723946f, 0.54606742f, -0.00349206f, 0.05969683f, 
    -0.62070543f, 0.14475034f, 0.15397364f, -0.53137797f, 0.08779044f, -0.36582184f, 0.41748086f, 0.46456745f, 
    0.14454734f, -0.50950527f, 0.00617886f, -0.63812453f, 0.14086062f, 0.07533253f, 0.03893854f, -0.37338576f, 
    0.21314226f, 0.11176697f, 0.08995989f, 0.17198096f, -0.51562983f, -0.16223781f, 0.49636886f, -0.59761256f, 
    -0.35531589f, -0.14728878f, 0.05359417f, -0.07078668f, 0.00366878f, -0.40218806f, -0.61394083f, 0.78246516f, 
    0.33902934f, -0.46088898f, -0.12023572f, 0.30660269f, -0.14863846f, 0.05856210f, -0.01805868f, -0.50181234f, 
    0.15198097f, 0.07056897f, -0.02715998f, 0.54411519f, 0.36271605f, -0.16955484f, 0.15410370f, -0.01952873f, 
    0.02569620f, 0.01192224f, -0.01534669f, 0.00332625f, 0.88215053f, -0.17991115f, 0.10496143f, -0.02661507f, 
    -0.23162569f, -0.35885823f, 0.83078951f, -0.10788895f, -0.07150403f, -0.24677993f, -0.23403238f, -0.65606940f, 
    0.12367600f, -0.79281485f, -0.01189261f, -0.13616879f, 0.13367182f, -0.19065353f, 0.38680607f, -0.22688711f, 
    -0.04608954f, -0.17440692f, 0.53523427f, 0.02688477f, -0.37490201f, 0.10887817f, -0.03380216f, -0.17580056f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04570426f, 0.14908239f, -0.08840583f, -0.01886589f, 0.18549733f, -0.05475747f, -0.06333896f, -0.31981242f, 
    -0.09577434f, -0.07443903f, 0.07501026f, -0.16246317f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
