#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.94190782f, 0.91314900f, -0.30952746f, -0.29131323f, 0.56030703f, -0.02604368f, 0.31523213f, -0.04068717f, 
    0.12304101f, 0.77985585f, 0.16296110f, 0.24978593f, 0.42897040f, 0.24482942f, -0.25466529f, 0.27253616f, 
    0.48208195f, -0.15141053f, 0.66973317f, -0.97792053f, -0.78053963f, 0.13019066f, 1.31328881f, -0.44416705f, 
    0.06765795f, -0.19030358f, -0.17847690f, -0.71816862f, -0.10435589f, -0.51091182f, -0.11478471f, 0.35478300f, 
    -0.76714480f, -0.45874277f, -0.32878491f, -0.23438796f, 0.71703857f, -0.72218800f, -0.43178764f, 0.64339477f, 
    -0.23142181f, 0.52127266f, -0.09973816f, -0.35668617f, -0.38300696f, 0.40214324f, 1.05789268f, -1.16492260f, 
    -0.08739968f, -0.43856704f, -0.44234490f, -0.37254986f, 0.13495058f, 0.10006007f, 0.30264121f, 0.39123797f, 
    0.27854842f, 0.02593064f, 0.25443497f, 0.26069066f, -0.03554689f, 0.50565737f, -0.17790700f, 0.36992946f, 
    0.91851360f, 0.01728468f, -0.86422545f, -0.39515954f, -0.01879184f, 0.32312509f, 0.32413945f, -0.25028667f, 
    0.85331124f, -0.03595937f, -0.56149834f, -0.69259548f, 0.47050908f, 0.03448155f, 0.24281415f, -0.04072369f, 
    0.25291863f, -0.06154491f, 0.43472692f, 0.74866319f, 0.62958014f, -0.06333745f, -0.23753631f, 0.19242789f, 
    -0.73836273f, -0.46020502f, 0.60144520f, -0.97992706f, 0.02117179f, -0.68427402f, -0.36015484f, -1.02819169f, 
    -0.18316324f, -0.21673681f, -0.02520376f, -1.10592747f, -0.74578702f, -0.48937732f, 0.83899570f, 0.65748674f, 
    0.47630018f, -0.06154196f, 0.05433309f, -0.01331561f, -0.17644900f, -0.23448811f, 0.78388232f, -0.10438233f, 
    -0.11919760f, -0.35538864f, 0.40781647f, -0.29546830f, 0.53556681f, -0.49161237f, -0.17987213f, 0.68123353f, 
    -0.47539753f, 0.28933302f, -0.31209689f, 0.47765610f, 0.19342345f, 0.34946248f, -0.61227268f, -0.17655775f, 
    0.62023568f, 0.64044678f, 0.43940216f, 0.59509778f, 0.43468934f, -0.31056216f, 0.26017487f, -0.21260267f, 
    0.39617646f, -0.57042468f, -0.08715966f, 0.08643971f, 0.15017666f, 0.32672942f, 0.23152670f, 0.47097936f, 
    -0.05430769f, -0.25495446f, 0.10866857f, 0.09275925f, -0.76281124f, -0.33985329f, -0.00657128f, 0.70158410f, 
    0.43355408f, -0.69734669f, -0.76262885f, 0.10213421f, 0.09289037f, -0.02365742f, -0.19312857f, 0.06565776f, 
    -0.36703643f, -0.29889208f, 0.48517296f, 0.63882667f, 0.28177345f, 0.15737525f, 0.66679275f, -0.26041478f, 
    0.27208531f, -0.14694099f, -0.05484544f, -0.20688587f, -0.82170105f, -0.48237151f, -0.41405940f, -0.46405011f, 
    0.26608232f, 0.14149144f, -0.38803759f, -0.19803424f, 0.69284016f, 0.68041086f, 0.72717685f, -0.74770397f, 
    -0.32114738f, -0.45121098f, 0.10951824f, 0.11909838f, -0.06629527f, 0.67162132f, 0.45899722f, -0.42259130f, 
    -0.16241491f, -0.34781021f, -0.13146992f, -0.40250325f, -0.42339098f, -0.27930552f, 0.29259375f, 0.48644763f, 
    -0.11120041f, -0.34680751f, 0.27840713f, 0.57291204f, -0.44006610f, -0.55262297f, -0.29552940f, 0.16651118f, 
    0.54125434f, 0.19653061f, -0.65434331f, -0.46099451f, 0.69137305f, -0.26729012f, 0.06834012f, 0.21813224f, 
    -0.58567148f, 0.15125647f, 0.46604913f, -0.26594362f, 0.04005878f, 0.48252317f, -0.06792883f, -0.66543406f, 
    0.40228879f, -0.43246764f, -0.13703440f, 0.06159043f, -0.30771986f, -0.50362581f, -0.09219079f, 0.48083246f, 
    0.42727119f, 0.46061677f, -0.69556081f, -0.20338179f, -0.06534185f, -0.01451509f, -0.56968462f, -0.60317010f, 
    -0.08047853f, 0.35744536f, 0.05430695f, -0.98226768f, 0.59968328f, 0.19069286f, 0.39076072f, 0.15459329f, 
    -0.40996689f, -0.48342583f, -0.19866590f, -0.21920694f, -0.52457947f, -0.61218351f, 1.23556638f, -0.33879802f, 
    -0.28223491f, 0.04722191f, -0.13308734f, 0.10913924f, 0.26769796f, -1.02006388f, -0.25240293f, -0.69579351f, 
    0.29790100f, 0.14486505f, -0.47788164f, 0.39489090f, -0.12679197f, 0.39322904f, 0.03972263f, 0.75273347f, 
    -0.56143236f, 0.25254551f, -0.38456902f, 0.56242347f, -0.38654843f, -0.56486744f, 0.53670806f, 0.72217304f, 
    -1.27375233f, 0.68609679f, -0.03134651f, -0.24742725f, 0.26165211f, 0.07461713f, -0.00925807f, -0.14115742f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.24988200f, 0.41937113f, 0.07046104f, -0.09155869f, 0.20649131f, 0.15516180f, 0.26326761f, -0.12608483f, 
    0.11565238f, -0.16505423f, 0.50719982f, 0.07887834f, -0.28217518f, -0.09263453f, -0.39662045f, 0.33415332f, 
    0.05169640f, -0.22223465f, 0.02614380f, 0.08502894f, 0.13949282f, -0.07309753f, -0.08807088f, 0.42963573f, 
    0.53324872f, -0.12128236f, 0.08624962f, 0.13237648f, -0.17934960f, 0.54154354f, -0.32263070f, -0.03797480f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.77868062f, -0.11173903f, -0.17039353f, -0.09222395f, -0.27110302f, -0.29161450f, 0.12703216f, 0.04095221f, 
    0.10490431f, 0.24608490f, -0.21528417f, 0.12179808f, -0.03314165f, 0.13221902f, 0.06142102f, 0.11361729f, 
    0.23440745f, 0.16334520f, 0.28821364f, -0.67130125f, 0.10281239f, -0.21309707f, 0.07716312f, -0.09765653f, 
    0.22838870f, -0.09367450f, -0.02714393f, -0.08750324f, -0.00213070f, -0.12424950f, -0.15944675f, -0.03038298f, 
    -0.02661265f, 0.04038556f, 0.12987210f, 0.11031561f, 0.60816211f, -0.28080243f, -0.12785071f, -0.07884508f, 
    -0.04660136f, -0.07852753f, 0.27507567f, 0.01439909f, 0.01401053f, 0.23240878f, 0.00830915f, -0.54935801f, 
    0.06880032f, 0.06161904f, 0.13845220f, -0.08836588f, 0.00850898f, -0.05718444f, -0.10949582f, 0.01778786f, 
    0.12778459f, 0.06738672f, 0.05460193f, 0.14698273f, 0.18631625f, 0.18703686f, 0.10446154f, -0.13269731f, 
    -0.30523661f, -0.66328710f, -0.07404815f, 0.03617040f, 0.00849021f, 0.00175567f, 0.11693498f, -0.01526894f, 
    0.26008874f, 0.11619603f, -0.07095511f, 0.19372579f, -0.02472247f, 0.09967770f, 0.07749896f, -0.11010563f, 
    0.06431359f, -0.32003805f, -0.23851931f, -0.06882384f, -0.17623220f, -0.09546007f, -0.16487800f, -0.15464567f, 
    -0.16046393f, 0.05813647f, 0.20330511f, -0.12405931f, -0.42207563f, 0.11848729f, -0.10084857f, 0.00849848f, 
    0.13949293f, -0.05396581f, 0.21911642f, -0.14015038f, 0.02736345f, 0.25532681f, -0.00058422f, -0.10374191f, 
    -0.24297109f, 0.11050645f, 0.00611502f, 0.03714184f, -0.05433332f, -0.55423689f, -0.42463726f, -0.52681136f, 
    -0.01293439f, 0.07112738f, -0.17675348f, -0.05606610f, -0.01391848f, -0.03092850f, -0.12981132f, -0.28209609f, 
    -0.10961848f, -0.06265151f, -0.11333175f, -0.04981570f, -0.01441001f, 0.07599325f, -0.14626621f, 0.18707551f, 
    0.12674308f, -0.40593660f, -0.08869731f, -0.12961915f, 0.12441234f, -0.03448967f, 0.11947589f, -0.03383363f, 
    0.14841600f, 0.03997575f, 0.09488312f, -0.02804403f, 0.07640926f, 0.11342514f, 0.18800728f, 0.09945996f, 
    -0.11291463f, 0.08875323f, -0.08732115f, -0.05253509f, 0.02833196f, -0.07237013f, -0.00316277f, 0.08236302f, 
    -0.00814725f, -0.06042005f, -0.16815540f, 0.36281589f, -0.19219717f, -0.16095318f, -0.03298150f, -0.03982210f, 
    0.07711355f, -0.08823983f, -0.04320117f, -0.23336637f, 0.22834063f, -0.08472811f, 0.12871727f, 0.06603406f, 
    -0.02206990f, -0.01916342f, 0.08817316f, -0.10673951f, -0.01873506f, 0.47940627f, -0.10151130f, -0.10689685f, 
    0.10955408f, 0.02325273f, -0.00678777f, 0.04782776f, 0.34853870f, -0.30631670f, -0.58794141f, 0.08831955f, 
    0.05447595f, -0.02385766f, 0.01479580f, 0.10665999f, -0.01346773f, 0.32458335f, -0.58756715f, -0.21421999f, 
    -0.00380431f, -0.06250896f, -0.01479005f, 0.05529532f, 0.05653283f, 0.20452555f, 0.18555364f, -0.23523290f, 
    -0.10610147f, -0.17091374f, -0.04422962f, -0.10310083f, -0.00567302f, -0.00248560f, 0.02509461f, -0.01897878f, 
    -0.12672086f, 0.06107639f, 0.16935949f, -0.00446242f, 0.25572556f, 0.09164879f, 0.16599917f, -0.01022733f, 
    -0.07146499f, 0.22766759f, 0.32223508f, 0.14683971f, 0.06269902f, 0.16502234f, 0.10798210f, 0.21710195f, 
    0.11174084f, -0.23034468f, 0.07194690f, -0.06105855f, -0.07790408f, -0.03873383f, 0.07522400f, 0.03189928f, 
    0.00969504f, -0.03692594f, -0.43668279f, 0.22148582f, 0.06091217f, -0.18705818f, -0.00846423f, -0.10073797f, 
    0.04406155f, 0.01229813f, 0.01105832f, -0.50870347f, -0.00291636f, 0.13516408f, 0.01645121f, 0.05351289f, 
    -0.03621781f, 0.14150628f, 0.10044632f, 0.19233364f, -0.41304648f, -0.36738586f, -0.38027212f, -0.15645339f, 
    -0.38191360f, 0.21966559f, -0.00644148f, 0.04389887f, 0.17505047f, -0.10859513f, 0.07728735f, 0.21273799f, 
    0.12650424f, 0.21573494f, 0.01319860f, 0.03354152f, 0.16599686f, 0.04867752f, 0.16759363f, -0.42749119f, 
    -0.14292933f, -0.21942912f, -0.24649538f, 0.10378823f, 0.03286804f, -0.06735393f, -0.14826691f, 0.13675095f, 
    -0.30499756f, -0.37566891f, 0.15714481f, -0.09680925f, -0.03769349f, -0.15075746f, 0.04705695f, 0.09441524f, 
    0.50056112f, 0.09376503f, -0.15861200f, -0.19981544f, 0.27456832f, -0.07680787f, 0.04712852f, -0.10725264f, 
    -0.05156297f, -0.08519093f, 0.12081067f, 0.24758929f, -0.12732577f, 0.03746171f, 0.01998141f, 0.04756508f, 
    -0.04640001f, -0.00989635f, -0.08181438f, -0.43712211f, 0.00976824f, -0.03715978f, 0.05836840f, 0.10733232f, 
    -0.04938681f, -0.04720441f, -0.00973318f, 0.19671127f, 0.19150366f, -0.14693199f, 0.04630219f, -0.10045454f, 
    -0.02273598f, 0.06204439f, 0.06852312f, -0.02307848f, -0.03789559f, -0.24713829f, -0.28365621f, 0.12438257f, 
    -0.09556573f, 0.09430648f, 0.17432474f, 0.16027771f, 0.03598058f, -0.52658534f, -0.25581419f, 0.06648391f, 
    0.00161708f, -0.06052803f, 0.21968238f, 0.13212061f, 0.15212566f, 0.13435085f, -0.09176904f, 0.20030038f, 
    0.18265535f, -0.07613684f, 0.03134547f, -0.09108284f, -0.12842895f, -0.01574120f, 0.04364325f, -0.25486037f, 
    0.18165109f, 0.09786572f, 0.04502358f, 0.08719618f, -0.08748060f, -0.09065319f, 0.10459856f, 0.06155137f, 
    -0.29144919f, -0.00520901f, 0.09892131f, 0.05670013f, 0.05703863f, 0.03361046f, -0.08853259f, -0.01749910f, 
    0.12460012f, -0.19118083f, -0.04774659f, 0.07419643f, -0.14919087f, 0.00358253f, -0.05939192f, -0.01498921f, 
    0.03513347f, 0.09977444f, 0.01966226f, -0.11231005f, 0.07403822f, -0.02287364f, -0.16060752f, 0.17510176f, 
    0.05120812f, 0.12317037f, -0.01705234f, 0.72316855f, -0.13080145f, -0.80250549f, -0.11092731f, 0.05876221f, 
    -0.09720830f, -0.00587302f, -0.05820943f, 0.03448651f, -0.16018452f, -0.06770141f, -0.04549164f, 0.10155066f, 
    -0.13611192f, 0.00556890f, -0.00352649f, 0.01377575f, 0.07731184f, -0.00132119f, -0.08823790f, -0.12226660f, 
    0.01782861f, 0.08125018f, -0.01331546f, 0.19345288f, 0.05207761f, 0.06320170f, 0.07311945f, -0.01369806f, 
    -0.22846501f, -0.11812896f, -0.03045208f, -0.15065388f, 0.14553137f, -0.17794909f, 0.02677172f, 0.10092330f, 
    -0.01853885f, -0.05226375f, 0.11354563f, 0.09061248f, 0.09403118f, 0.03431511f, 0.06567176f, 0.00390150f, 
    -0.23674399f, -0.34355646f, 0.32674623f, -0.12521788f, 0.04971199f, -0.25507283f, -0.01378320f, 0.08365928f, 
    0.08809424f, 0.56945765f, 0.04738103f, -0.46640342f, -0.15866806f, -0.27851674f, -0.10275721f, -0.02032195f, 
    0.16846816f, -0.04028414f, -0.16213128f, 0.18808553f, 0.14618748f, -0.16035372f, -0.06159563f, -0.23447980f, 
    0.06539750f, -0.01787744f, 0.05506368f, 0.15204374f, -0.04021621f, -0.56334215f, -0.11214746f, -0.14484450f, 
    -0.07871802f, 0.05144558f, -0.00621155f, -0.01950532f, -0.27881962f, 0.09279345f, 0.09732693f, 0.04858748f, 
    -0.00602686f, -0.08514101f, 0.01747911f, 0.10946595f, -0.00595102f, -0.45994815f, -0.00096340f, -0.02454294f, 
    -0.06499287f, -0.05889977f, -0.07001361f, 0.07329577f, 0.01308811f, -0.03468770f, -0.45641002f, 0.09132876f, 
    -0.00118991f, -0.03582642f, -0.02751870f, -0.02702462f, -0.07782916f, -0.13653302f, -0.00475545f, -0.07826731f, 
    0.14741820f, -0.01000420f, 0.06018616f, 0.02898526f, -0.06058233f, 0.04182531f, 0.12444240f, 0.07164557f, 
    0.19721690f, 0.16916046f, -0.07006408f, 0.16707073f, 0.20402892f, -0.10043067f, 0.03566733f, 0.16536468f, 
    0.20350558f, -0.01934100f, -0.27526984f, -0.18551402f, 0.03964216f, -0.05663230f, -0.10204647f, 0.03352554f, 
    -0.03975120f, 0.05397888f, 0.38506851f, -0.06342258f, 0.00175063f, -0.02020150f, -0.01423461f, -0.09141924f, 
    -0.14988665f, -0.03789397f, -0.04177834f, 0.54766297f, -0.02141099f, -0.20491108f, -0.06354918f, 0.06589104f, 
    -0.09789879f, -0.04816122f, 0.06846017f, -0.11960451f, 0.32507974f, -0.26021874f, 0.12640963f, 0.04731715f, 
    -0.22677831f, -0.03432627f, 0.23948961f, 0.07129627f, -0.00254097f, 0.58721900f, -0.30099201f, -0.32282436f, 
    0.14672494f, 0.13230892f, 0.01083362f, -0.01980351f, -0.00919339f, 0.00754459f, -0.14920001f, -0.25777438f, 
    -0.12100431f, 0.04266952f, 0.03786479f, 0.13501212f, -0.01814871f, -0.02209974f, 0.10291406f, 0.42152825f, 
    -0.29759014f, -0.22269064f, -0.13236631f, -0.00266112f, 0.12654437f, 0.30215970f, 0.14865527f, -0.08592375f, 
    0.11106813f, 0.03241170f, 0.04747165f, -0.49892494f, 0.00082695f, -0.18559204f, 0.13480344f, -0.13440739f, 
    -0.13838971f, 0.18786857f, 0.10299295f, 0.16109771f, -0.02711466f, -0.08479314f, -0.12508436f, 0.18571684f, 
    -0.07825469f, 0.01475998f, 0.17250095f, -0.22965811f, -0.58423340f, -0.21365765f, 0.08571993f, 0.21719758f, 
    0.02791004f, -0.19061543f, -0.18232550f, 0.05704178f, -0.26912180f, -0.56147182f, -0.12019785f, -0.08973449f, 
    -0.14700536f, -0.05262743f, -0.05218700f, 0.15517846f, 0.25256425f, -0.14611325f, -0.11603814f, 0.09270903f, 
    -0.00616155f, 0.04917502f, 0.03093386f, 0.21245699f, -0.12382258f, 0.03629402f, -0.10823875f, -0.16545960f, 
    -0.03194232f, 0.12703374f, 0.17943676f, -0.16909488f, 0.11040852f, 0.14043741f, 0.17017241f, 0.25640762f, 
    0.28289801f, -0.01387885f, -0.09732340f, -0.00993772f, 0.11830170f, -0.08401938f, -0.02684871f, -0.02039024f, 
    -0.17143247f, 0.14330211f, 0.01038640f, 0.03947818f, 0.00930804f, 0.07462917f, 0.00504920f, 0.07804690f, 
    -0.02257357f, 0.05876433f, -0.18210955f, 0.12103760f, 0.05757049f, 0.05058685f, 0.04414016f, 0.01065921f, 
    -0.19274731f, 0.07700410f, 0.17098102f, 0.14805211f, 0.10881292f, -0.01876968f, -0.14540522f, 0.14438926f, 
    -0.28576502f, 0.17863923f, 0.15351696f, -0.34568602f, 0.12542067f, 0.09631627f, 0.10240992f, 0.20145959f, 
    0.05414344f, 0.09203750f, 0.17315435f, 0.03517746f, -0.28559202f, -0.32778075f, -0.50406456f, -0.08348230f, 
    -0.22646888f, 0.05508603f, -0.14913480f, -0.04362950f, -0.00164438f, 0.01143314f, 0.09758459f, -0.04230590f, 
    -0.06029680f, -0.14855368f, -0.08796708f, 0.02183564f, -0.07729197f, -0.12156636f, 0.03486889f, 0.10472666f, 
    0.04197096f, -0.12410311f, 0.01107148f, 0.06693750f, -0.03723453f, 0.00506686f, 0.16495402f, 0.14541192f, 
    0.24625659f, -0.29955736f, -0.12587765f, -0.28365362f, -0.10945012f, -0.17095038f, -0.07246759f, -0.01750755f, 
    -0.02614623f, -0.10572568f, -0.02029739f, -0.02776616f, 0.08386452f, -0.00745394f, 0.03152147f, 0.03827484f, 
    -0.42861679f, -0.05207542f, -0.39521039f, 0.30670217f, -0.02905891f, 0.00162880f, -0.03864343f, 0.03399719f, 
    0.18455906f, -0.27492470f, -0.21879157f, -0.73551792f, -0.23168963f, -0.05002423f, -0.04983169f, 0.03154130f, 
    -0.19755992f, -0.27021933f, 0.24242459f, 0.13823523f, 0.16481221f, -0.07530812f, 0.00525026f, -0.04411244f, 
    0.02247776f, -0.14990124f, -0.09303810f, -0.34070030f, -0.47359240f, -0.52722448f, -0.08706739f, 0.03369712f, 
    0.00232464f, -0.06333734f, -0.06580837f, -0.02811073f, -0.02386484f, -0.10224168f, 0.12536943f, -0.02454070f, 
    -0.08300832f, -0.01842768f, 0.14464703f, 0.07737041f, 0.03005537f, -0.04029321f, -0.07058958f, 0.02418158f, 
    -0.04255450f, -0.08539399f, 0.10034180f, -0.09636014f, -0.08093734f, -0.03903300f, 0.00362687f, 0.13928300f, 
    0.07181574f, -0.01091756f, -0.17872779f, 0.02292382f, 0.07018510f, 0.04058854f, -0.10841580f, -0.08426125f, 
    0.14540097f, 0.07981502f, 0.02644840f, 0.07327263f, 0.08180469f, 0.17679495f, -0.02298402f, 0.09365924f, 
    -0.03573670f, 0.26162666f, 0.23621276f, 0.15351377f, -0.01393620f, -0.19960354f, 0.17597373f, 0.15265666f, 
    0.23827048f, -0.13031243f, 0.04347150f, -0.14742778f, 0.23917130f, -0.07413038f, 0.00744003f, -0.05276463f, 
    0.06499971f, 0.10591520f, -0.34833300f, -0.11924035f, -0.47059536f, -0.10148591f, 0.04617314f, 0.04364552f, 
    -0.08150811f, 0.02524477f, -0.05072139f, -0.22779839f, 0.03730331f, 0.00431713f, 0.08608846f, 0.25966883f, 
    0.04202319f, 0.17761570f, -0.11590518f, 0.01601411f, -0.13080508f, -0.04159272f, -0.17293517f, -0.06352580f, 
    -0.10820361f, -0.06085557f, -0.14122781f, -0.01404158f, -0.18565629f, -0.05120058f, -0.14523624f, -0.66883498f, 
    -0.18090142f, 0.14325961f, 0.02446066f, 0.15074143f, 0.04456616f, 0.03289773f, 0.00948555f, 0.08839317f, 
    0.06968516f, 0.14200303f, -0.09094704f, -0.09571443f, -0.32085997f, -0.03389073f, -0.04906356f, 0.56453294f, 
    0.24593136f, -0.04467632f, 0.08154391f, 0.21436979f, -0.00411449f, 0.29227436f, 0.16170992f, -0.38190728f, 
    -0.31475732f, -0.31201959f, -0.24940614f, 0.11579155f, -0.17493516f, -0.17912152f, 0.02505094f, -0.11456982f, 
    -0.15810299f, 0.08399190f, 0.01530327f, -0.03059248f, 0.12382399f, 0.10408342f, 0.03374151f, -0.08132285f, 
    0.04588520f, 0.00740113f, -0.23318793f, -0.01947415f, -0.01167316f, 0.03301498f, 0.18031476f, -0.02334434f, 
    0.17795850f, 0.02338590f, -0.07436601f, 0.36558187f, -0.01085885f, -0.14171587f, 0.04876238f, -0.04555715f, 
    -0.08322992f, -0.32986611f, -0.22772536f, -0.02913577f, -0.00693280f, 0.03502300f, 0.12934104f, 0.09847534f, 
    0.17692025f, -0.00118272f, 0.04319202f, -0.03320013f, 0.13601825f, -0.04961755f, -0.30699649f, -0.20070687f, 
    0.10247798f, 0.06357857f, 0.00479905f, -0.01505877f, -0.14316717f, 0.05468411f, 0.15141036f, 0.09125374f, 
    0.06990753f, 0.05033841f, -0.06397620f, 0.01693455f, 0.05214504f, 0.02163956f, 0.00701280f, 0.29839540f, 
    -0.23633102f, -0.36943007f, -0.03214637f, 0.01870453f, 0.07126269f, 0.02427758f, 0.04379794f, -0.05121171f, 
    0.33616358f, 0.17455979f, -0.36711398f, 0.05236365f, -0.04340639f, 0.11634662f, 0.09388454f, 0.07808501f, 
    -0.19281113f, -0.13350065f, 0.12886322f, -0.17388931f, -0.02108101f, 0.04955540f, -0.12180622f, 0.03814195f, 
    -0.06143392f, 0.13339718f, 0.00371536f, -0.37093124f, -0.50247502f, 0.06786571f, 0.22250880f, -0.09925523f, 
    0.04461860f, -0.03800918f, 0.13563555f, -0.30266887f, -0.00928403f, 0.20372176f, -0.10890394f, -0.22636364f, 
    0.20806047f, 0.10854979f, 0.08024829f, -0.03869440f, 0.24782121f, -0.32096523f, -0.06168234f, -0.25309768f, 
    -0.12958755f, -0.19993940f, 0.08981797f, 0.03093792f, -0.05488624f, -0.03952390f, -0.21917443f, -0.12947977f, 
    -0.07905809f, -0.07238183f, 0.01353347f, 0.00472756f, -0.02672693f, 0.03658752f, -0.04631008f, -0.02718963f, 
    -0.01887527f, 0.04617077f, 0.04390556f, 0.02174113f, 0.10898672f, -0.11668137f, 0.16920997f, 0.01252431f, 
    0.02984197f, -0.14667870f, 0.05498958f, -0.03075199f, 0.08949357f, 0.03199456f, -0.04455606f, 0.04644394f, 
    -0.02685134f, -0.06279463f, -0.14924343f, -0.05869177f, -0.08374421f, -0.22757676f, 0.02117131f, -0.10829712f, 
    0.08742779f, 0.28386298f, 0.07120460f, 0.15926436f, -0.03517240f, -0.00151951f, 0.02832120f, -0.05732669f, 
    -0.14537178f, -0.16147645f, -0.02787391f, -0.14789242f, 0.04615738f, 0.04637140f, -0.00598927f, 0.09013549f, 
    0.01374005f, 0.08594910f, 0.09818192f, 0.00051467f, 0.02366173f, 0.08626274f, -0.01777325f, 0.14334969f, 
    0.05975621f, 0.04755394f, 0.03902071f, -0.01522932f, 0.33833709f, -0.40955025f, -0.22840707f, 0.09280251f, 
    0.03830958f, 0.05033667f, 0.03921052f, -0.04726308f, 0.03659187f, -0.21030438f, -0.21894492f, 0.06692286f, 
    -0.08363716f, -0.00670305f, -0.16598858f, -0.05229076f, 0.01487776f, 0.02084823f, -0.20341156f, -0.04732060f, 
    -0.00701687f, -0.18022271f, -0.01677486f, -0.05159946f, -0.00186681f, 0.07983175f, -0.12669426f, 0.14908901f, 
    -0.03939250f, 0.00143907f, 0.02867372f, 0.10295369f, 0.26939154f, 0.15646251f, -0.07415128f, 0.02790123f, 
    -0.04463150f, 0.26117772f, -0.01091040f, 0.30911487f, 0.07334512f, 0.07623850f, 0.16786835f, 0.05219198f, 
    0.19229646f, -0.11060936f, 0.00069464f, -0.23288599f, -0.17417514f, -0.03043597f, -0.00036689f, -0.07775165f, 
    -0.12290480f, -0.01954796f, -0.21590020f, -0.19094579f, -0.11192663f, 0.01233484f, 0.03130257f, -0.12471708f, 
    0.12033579f, -0.01486224f, 0.02276199f, 0.04288126f, -0.06540617f, 0.07697924f, 0.02389619f, 0.00044534f, 
    -0.02133645f, -0.01644288f, 0.02357905f, 0.14827245f, 0.00961267f, -0.09862165f, -0.30954739f, -0.01835797f, 
    -0.03587580f, -0.02825372f, 0.32262152f, 0.05144355f, -0.08731260f, -0.17884058f, 0.04249569f, 0.36169809f, 
    0.01169953f, 0.11720116f, -0.03717689f, 0.04724574f, 0.12080452f, 0.00715611f, -0.18484099f, -0.08651648f, 
    -0.02232352f, 0.05306969f, -0.25560078f, -0.07970855f, -0.01242488f, 0.10483170f, 0.13958293f, 0.12288582f, 
    0.25987366f, -0.41069004f, 0.18275718f, -0.00879904f, 0.10469656f, -0.07165489f, 0.15632534f, 0.05605111f, 
    -0.03819510f, 0.31408679f, -0.01207689f, 0.02090447f, -0.09445508f, 0.12033860f, -0.03692831f, 0.02658722f, 
    -0.04735611f, -0.03662454f, -0.06018624f, -0.10560327f, 0.04838205f, -0.05236840f, -0.15245937f, 0.07575063f, 
    0.10282661f, 0.02602770f, 0.23137541f, 0.24584416f, 0.15578729f, -0.17360595f, -0.06802604f, -0.03227028f, 
    0.13334255f, 0.14660230f, -0.01893898f, -0.01424967f, 0.04832197f, 0.12489872f, 0.07496952f, 0.08842213f, 
    -0.02889310f, 0.02846759f, -0.07477421f, 0.01353667f, 0.20665431f, 0.16805133f, 0.12096237f, -0.01192530f, 
    0.01400543f, 0.00864993f, 0.00645194f, 0.03718229f, -0.13550369f, -0.13805650f, 0.14696009f, -0.01591206f, 
    0.05130448f, 0.27508971f, 0.01982810f, -0.01000366f, 0.12005859f, 0.07578170f, -0.03970060f, -0.08931023f, 
    -0.03559712f, 0.00280080f, -0.12047556f, 0.00304346f, 0.06519581f, 0.04846136f, -0.08057062f, -0.21140604f, 
    -0.17371069f, -0.25906333f, -0.02757093f, -0.00846741f, -0.08572695f, 0.07470610f, -0.02111016f, -0.04398809f, 
    0.16941169f, -0.27776888f, 0.34065086f, 0.06585433f, 0.18483043f, 0.01859589f, -0.05553345f, 0.03055962f, 
    0.25080255f, -0.04181549f, 0.06317595f, -0.18854013f, 0.16726817f, -0.12598638f, 0.15513606f, 0.14420632f, 
    0.06760985f, -0.20635645f, -0.07099074f, -0.24485235f, 0.25424391f, 0.10109919f, 0.14976121f, 0.15453938f, 
    -0.15845391f, 0.04489942f, 0.15499736f, -0.00524123f, 0.10777383f, 0.14379263f, 0.04406480f, -0.06273536f, 
    -0.08006578f, -0.00625927f, 0.06799217f, -0.10211120f, -0.43652254f, 0.09328006f, -0.27448919f, -0.22565432f, 
    -0.12837127f, 0.06798793f, 0.02375814f, 0.06887691f, 0.15976553f, -0.00362468f, -0.00017324f, -0.18277605f, 
    0.15691316f, 0.02508036f, 0.04810963f, 0.02093114f, 0.10019232f, 0.31079420f, 0.13378283f, 0.04590704f, 
    -0.25881776f, 0.06314737f, -0.16652778f, 0.06428775f, -0.12431680f, -0.06990794f, -0.00085540f, 0.00872145f, 
    0.08634111f, 0.14749394f, 0.14612255f, 0.27380016f, -0.10730989f, -0.03313424f, 0.04169197f, 0.07118073f, 
    -0.13933228f, -0.39362517f, 0.10571871f, 0.12727776f, 0.05791814f, -0.16277136f, -0.04112391f, -0.17658347f, 
    0.15229291f, -0.08769654f, -0.06998309f, -0.18348224f, -0.03915482f, 0.10701334f, -0.11563080f, -0.01581444f, 
    0.03048354f, 0.02108259f, -0.16481838f, -0.02887910f, -0.16965054f, -0.06907729f, -0.39132667f, -0.02999757f, 
    0.04365175f, 0.15105765f, -0.24274902f, -0.08997937f, -0.11924250f, -0.02903719f, 0.03648869f, 0.02796835f, 
    0.09655507f, -0.08813096f, 0.04704844f, 0.06607594f, -0.47867149f, -0.09667005f, -0.11896817f, -0.04887373f, 
    -0.08558065f, -0.09955223f, 0.02883723f, 0.14610179f, -0.03608655f, 0.10618461f, 0.17580141f, -0.10998097f, 
    -0.02784252f, 0.09719447f, -0.04812970f, -0.13296427f, 0.00114053f, -0.12672128f, 0.04703460f, -0.08211877f, 
    -0.18701458f, 0.06026084f, 0.00075440f, -0.02085190f, -0.13428602f, -0.03743872f, -0.11224706f, 0.00381984f, 
    0.04950152f, 0.09939267f, 0.08841169f, 0.09978227f, -0.00737961f, 0.05537290f, 0.08601907f, 0.21530172f, 
    0.14877748f, 0.01805265f, -0.14806247f, 0.11163337f, -0.03430664f, 0.11322786f, 0.11399556f, -0.02000559f, 
    0.10442687f, -0.01585741f, -0.24871510f, -0.13522185f, -0.01413548f, 0.11976950f, -0.18276015f, -0.05694807f, 
    -0.11297373f, 0.18666333f, 0.08738577f, -0.16817847f, 0.12887163f, 0.00288615f, 0.05497510f, -0.06459230f, 
    0.01791567f, -0.04707518f, -0.00190327f, -0.01045784f, 0.26432788f, -0.03451999f, 0.16548795f, 0.04127865f, 
    0.04708550f, 0.01814343f, -0.21900360f, 0.01310810f, 0.00132009f, 0.16685519f, -0.17272794f, 0.03270685f, 
    0.02045671f, -0.02475203f, 0.09950795f, 0.19210494f, 0.09766421f, -0.02338309f, 0.16130795f, 0.20706171f, 
    -0.03173384f, 0.01203062f, -0.09994376f, 0.03386477f, 0.05349487f, -0.00514388f, -0.03355160f, 0.03661572f, 
    0.01625348f, -0.03062982f, 0.04217909f, 0.08717661f, -0.09701071f, 0.35163602f, -0.05999531f, 0.20985267f, 
    0.21625665f, -0.04303941f, -0.12424103f, 0.11950771f, -0.02424862f, -0.06401507f, 0.11933536f, 0.19317695f, 
    -0.11721578f, -0.03123840f, 0.07122591f, 0.16876708f, -0.03444386f, -0.14371374f, -0.03903885f, 0.18293628f, 
    0.09404433f, -0.06162546f, -0.08729755f, -0.03685625f, 0.10713425f, 0.00714360f, 0.05633982f, 0.14121673f, 
    0.09777989f, 0.12106510f, 0.09885436f, -0.17294100f, -0.04910415f, 0.03592269f, -0.17565843f, 0.28319120f, 
    -0.16577555f, -0.18914385f, -0.17334481f, -0.09826540f, 0.02828123f, -0.05494380f, 0.02199349f, -0.16864364f, 
    -0.01684522f, -0.12419300f, -0.09515864f, -0.06811246f, 0.00779188f, -0.18462971f, -0.28406718f, -0.03055008f, 
    -0.01174695f, -0.02961117f, -0.10993262f, -0.08198978f, -0.41910791f, -0.07101082f, -0.15435508f, -0.43715119f, 
    -0.12874976f, 0.00128224f, 0.25181502f, 0.13027725f, 0.08092830f, -0.17096719f, -0.05043259f, 0.01631822f, 
    0.08673121f, 0.17619374f, 0.12780654f, 0.07968415f, 0.07939649f, -0.07876567f, 0.05824839f, -0.24874096f, 
    -0.02689469f, 0.06186075f, 0.18430588f, 0.02221849f, 0.06876963f, -0.00621518f, 0.11332345f, 0.05974120f, 
    -0.02643525f, -0.03197245f, 0.16487005f, 0.01600284f, -0.06876943f, 0.05491387f, 0.06307217f, -0.06255904f, 
    0.06997626f, -0.13619238f, -0.17800424f, 0.15375681f, -0.00744421f, 0.09498480f, 0.19598341f, -0.09462331f, 
    -0.01549172f, -0.40415877f, 0.15885434f, 0.10321550f, -0.27628499f, 0.06568922f, 0.08897821f, 0.10387341f, 
    0.11138540f, 0.11976364f, 0.00866253f, 0.06835032f, 0.01787788f, 0.14397807f, 0.22290964f, -0.02622201f, 
    -0.00110396f, -0.05822394f, -0.11385325f, -0.00629019f, -0.19036168f, 0.11944230f, -0.15751068f, 0.00117075f, 
    -0.02904839f, 0.02845550f, 0.07685626f, 0.08721752f, 0.03632777f, 0.01761477f, 0.08687887f, -0.07672541f, 
    0.02445812f, -0.02078064f, -0.04928531f, 0.03966666f, 0.02620746f, 0.18648624f, 0.07100023f, -0.09889841f, 
    0.04336390f, 0.12831172f, 0.03779496f, 0.03632301f, -0.10823744f, 0.08825731f, -0.08554704f, 0.07375322f, 
    0.07058866f, 0.17787008f, 0.02588416f, -0.20632559f, 0.01219909f, 0.19691704f, 0.23134887f, 0.05409472f, 
    0.02603074f, 0.03365690f, 0.01031501f, 0.01398078f, 0.07420484f, 0.18995017f, 0.26805317f, 0.08440072f, 
    0.16501844f, -0.26980355f, 0.07089970f, -0.08224492f, 0.02986871f, -0.22899334f, 0.06806684f, -0.11378012f, 
    -0.09698521f, -0.09751478f, -0.05717933f, -0.13232996f, 0.02373322f, 0.10952878f, 0.13389181f, 0.10913900f, 
    0.09396262f, -0.02758440f, -0.02977485f, -0.27982715f, 0.07032773f, 0.08460938f, -0.09910182f, -0.16964081f, 
    -0.03756596f, 0.01630986f, 0.22441962f, -0.07671853f, -0.06683907f, 0.06746433f, 0.11514753f, 0.19736952f, 
    0.06649818f, 0.07521833f, 0.08539903f, 0.06604365f, 0.03754073f, 0.00734659f, -0.29228592f, -0.03046879f, 
    -0.06176664f, 0.02780047f, 0.11695269f, -0.07306277f, -0.09614697f, -0.13178447f, 0.10577952f, -0.19472612f, 
    -0.02246894f, -0.19493410f, 0.02117134f, 0.08333694f, -0.02709209f, -0.35864371f, 0.02447264f, -0.02612988f, 
    -0.18370841f, 0.21433640f, 0.10135570f, 0.14206119f, -0.01148310f, -0.07226541f, -0.25524491f, 0.19027805f, 
    -0.03061970f, -0.01510326f, 0.20620590f, 0.04244922f, 0.04090602f, 0.08783880f, 0.04816835f, -0.07376064f, 
    -0.01190455f, -0.01352076f, 0.05794763f, -0.03182450f, 0.11192454f, -0.11131855f, 0.08785558f, 0.23014665f, 
    0.08252837f, 0.16474302f, -0.14474927f, -0.00369437f, 0.19794415f, -0.13996471f, 0.06855585f, 0.16954310f, 
    0.10868129f, 0.01531096f, 0.00017444f, -0.21940859f, -0.13091530f, 0.27474681f, 0.20350626f, -0.17464817f, 
    0.14339054f, 0.00644535f, -0.13582282f, -0.33187348f, -0.30444935f, 0.24020959f, 0.06971962f, 0.13835195f, 
    -0.05963335f, 0.16979751f, 0.10749016f, -0.04471625f, 0.05245996f, -0.18742415f, 0.12444814f, 0.05005611f, 
    0.03244305f, -0.06452102f, 0.11328973f, -0.05296953f, 0.02892777f, -0.02068801f, 0.04512784f, -0.20525192f, 
    0.00613572f, -0.01645455f, 0.03654953f, -0.02611784f, 0.19195214f, -0.44922644f, -0.07098062f, 0.00290889f, 
    0.09814889f, 0.04307691f, 0.15753388f, 0.04207284f, 0.08313660f, -0.13507386f, -0.09293257f, -0.27162668f, 
    0.03020472f, -0.01613772f, 0.14965291f, -0.43931383f, -0.15378904f, 0.09733918f, -0.07859395f, 0.22418326f, 
    -0.03139341f, 0.05054288f, -0.00073545f, -0.00738149f, -0.11029842f, -0.18008003f, -0.11138515f, -0.05454722f, 
    0.09480660f, 0.06299984f, 0.20884772f, 0.12939771f, 0.47705266f, 0.09289274f, 0.13159584f, -0.20359603f, 
    -0.00897200f, 0.05417023f, 0.18609096f, -0.05464710f, 0.15528320f, -0.18798478f, -0.04421973f, -0.06536409f, 
    0.08830351f, 0.10572978f, -0.01666019f, 0.02340609f, -0.07897290f, 0.17382604f, 0.02920825f, -0.11329009f, 
    0.21562678f, 0.16178836f, 0.11184760f, 0.10156644f, 0.20408349f, -0.03357083f, 0.20053677f, 0.14204992f, 
    0.12013200f, 0.03024479f, -0.13329472f, -0.10103760f, -0.24232835f, 0.01189166f, -0.04241640f, -0.05544762f, 
    0.03864940f, -0.12033124f, -0.15286069f, 0.00125908f, 0.01123246f, 0.20755874f, 0.12407454f, -0.06089817f, 
    0.05016718f, -0.06765986f, -0.04242764f, 0.05940954f, 0.05505622f, 0.04944865f, -0.19707446f, -0.20445508f, 
    -0.08856606f, -0.04102552f, 0.21887419f, -0.23052341f, 0.07959971f, 0.01154845f, 0.11034517f, 0.03190936f, 
    -0.05949615f, 0.07180248f, -0.00125510f, 0.04933236f, -0.02572839f, -0.06883094f, -0.21573672f, 0.05778432f, 
    -0.00400549f, 0.38177758f, -0.15024117f, 0.22053446f, 0.28214389f, 0.00273206f, 0.01664847f, -0.04353765f, 
    -0.19110137f, -0.30235115f, 0.15263824f, 0.23317246f, 0.17863920f, 0.21698467f, -0.21538888f, 0.10723901f, 
    -0.00886945f, -0.04199694f, 0.09313866f, 0.00668636f, 0.05978173f, 0.18070345f, -0.02692696f, 0.02964950f, 
    0.21365266f, 0.14965199f, -0.01622326f, -0.16950507f, -0.02385905f, 0.09420085f, -0.02909982f, -0.10730400f, 
    -0.10675932f, 0.04061812f, 0.08019731f, 0.01865509f, -0.13065156f, -0.16060188f, 0.15559022f, 0.01682705f, 
    0.03972231f, -0.26305485f, 0.01767060f, 0.00848172f, 0.09204897f, 0.08766796f, 0.10010125f, -0.06919450f, 
    0.04164110f, 0.03557844f, -0.20121008f, 0.06018615f, 0.03460585f, -0.02104531f, 0.00554858f, -0.05750261f, 
    -0.01714165f, 0.21410391f, -0.15717363f, 0.10134935f, -0.04498143f, -0.06400733f, 0.01340396f, -0.08612957f, 
    -0.00973435f, -0.00272825f, 0.16601518f, 0.05722757f, 0.01819364f, -0.01244228f, 0.01120970f, 0.15613495f, 
    0.01421420f, -0.02623661f, 0.01270898f, -0.08301504f, 0.02096418f, -0.13492343f, -0.10545619f, -0.04048908f, 
    -0.06582615f, 0.05646050f, 0.10467219f, -0.03090798f, 0.14689709f, 0.13128877f, -0.00512591f, 0.03105450f, 
    -0.15803498f, -0.04431169f, -0.01364949f, -0.03876753f, -0.08388779f, 0.09890336f, 0.00144872f, 0.07626523f, 
    0.08696210f, 0.00000060f, -0.20184706f, -0.26851442f, -0.19557318f, 0.01010554f, -0.07666204f, 0.05819295f, 
    0.04516387f, 0.01771039f, -0.02071980f, 0.15943626f, 0.09228952f, -0.12395981f, -0.08392567f, -0.11394060f, 
    -0.09774195f, 0.24625890f, -0.18568148f, 0.04920556f, 0.16284403f, 0.09499740f, 0.28179553f, -0.03613530f, 
    -0.01276219f, -0.22627896f, 0.01316689f, 0.03539533f, -0.03451373f, 0.12310757f, -0.04502722f, -0.20594935f, 
    -0.05496157f, 0.06384531f, 0.04895898f, -0.13808802f, 0.07825784f, -0.00106490f, 0.10845940f, 0.11923781f, 
    0.00112080f, 0.01655801f, 0.13343012f, 0.01366676f, -0.05097699f, 0.01954458f, -0.10002546f, 0.04959240f, 
    0.04484139f, -0.08860739f, 0.20103128f, -0.02525743f, 0.02461366f, 0.04785666f, -0.05141247f, -0.03058463f, 
    -0.03576742f, -0.14447695f, -0.02199831f, 0.19097906f, -0.04721036f, -0.08841235f, -0.08257152f, 0.07029994f, 
    -0.06590141f, 0.08119278f, 0.02521716f, 0.29557618f, 0.08105746f, 0.61586392f, 0.09237237f, -0.21140628f, 
    0.16159722f, -0.24186483f, -0.09039604f, 0.09011903f, -0.03773607f, -0.04501820f, -0.11155378f, 0.30220914f, 
    -0.00226200f, -0.02448872f, -0.06112372f, 0.01921404f, -0.01357647f, 0.09144963f, 0.03408069f, -0.04796732f, 
    -0.00160800f, 0.15801865f, 0.04028666f, -0.07776496f, 0.04827150f, 0.17503881f, 0.09318941f, -0.39370018f, 
    0.28969204f, 0.12026346f, -0.06685515f, 0.06615102f, 0.09027027f, -0.22080924f, 0.17401172f, 0.28513816f, 
    -0.24604778f, -0.52881277f, -0.25458458f, -0.17784806f, 0.16425079f, -0.17872824f, 0.19944462f, -0.12690833f, 
    -0.10978980f, 0.18028185f, 0.01530777f, 0.06691916f, 0.06834988f, 0.00401360f, 0.00648537f, -0.26515293f, 
    -0.11770049f, 0.07618003f, -0.26410162f, 0.09623212f, 0.31129104f, 0.06564298f, 0.19897392f, -0.06865777f, 
    0.19940424f, -0.09587477f, 0.05494490f, 0.07737868f, -0.22056502f, -0.32497060f, -0.01282962f, 0.03051343f, 
    0.00110383f, -0.29849297f, 0.03704695f, 0.11478362f, -0.05745688f, 0.24279708f, 0.19307873f, 0.19294904f, 
    0.10983852f, 0.07732293f, 0.16444002f, -0.02914522f, 0.28435263f, 0.15103267f, -0.21168616f, -0.09477452f, 
    0.06298855f, 0.14708304f, 0.09284269f, 0.03657056f, 0.10876675f, -0.10679983f, 0.10276172f, 0.08610984f, 
    0.04668063f, -0.00973439f, -0.04910451f, 0.05365166f, -0.11729747f, -0.16439040f, 0.09814814f, 0.29382482f, 
    -0.32224092f, -0.47429976f, 0.04049662f, 0.02228082f, 0.00777632f, 0.11589251f, -0.03689808f, -0.01798484f, 
    0.20530686f, 0.28427336f, -0.07951553f, -0.05329416f, 0.04253623f, -0.00122767f, 0.22318399f, 0.19616565f, 
    -0.04360525f, -0.18736891f, 0.08554772f, -0.12539808f, 0.00337774f, 0.00227095f, -0.17952932f, -0.00937927f, 
    0.02235354f, 0.14960817f, -0.45512170f, -0.51892459f, -0.70609337f, 0.19221340f, 0.16224222f, -0.08986098f, 
    0.17122866f, 0.02185754f, 0.06135033f, -0.38560426f, -0.08040141f, 0.42141476f, -0.01773358f, 0.07038905f, 
    0.09976826f, -0.04619789f, 0.05853980f, 0.09812022f, 0.15578473f, -0.28440958f, -0.00624967f, -0.09021170f, 
    -0.20142406f, -0.15919150f, -0.05555424f, 0.08440884f, -0.01751618f, -0.04958550f, -0.38432160f, 0.00462066f, 
    -0.10233051f, 0.01350116f, -0.11108194f, 0.01552138f, 0.00659494f, 0.02269671f, -0.13478120f, -0.04168482f, 
    0.02650667f, 0.02686063f, -0.05598224f, -0.13837396f, 0.12610559f, -0.07705788f, 0.05446204f, 0.01310757f, 
    0.00009567f, -0.01164792f, 0.03537722f, -0.05899498f, 0.20734791f, 0.12572680f, -0.03985826f, 0.10209231f, 
    -0.01216607f, -0.16591434f, -0.26945245f, -0.00633275f, -0.09120020f, -0.18297046f, -0.01141961f, -0.05728212f, 
    0.00693777f, -0.17893544f, -0.12721628f, 0.07004472f, -0.08172094f, 0.08566216f, -0.01802308f, -0.22340517f, 
    -0.01997727f, -0.12357377f, 0.02585365f, -0.10607270f, 0.19545048f, -0.00870779f, -0.05520041f, -0.08430630f, 
    -0.06323325f, -0.09631874f, 0.01557311f, -0.35172316f, -0.15702005f, -0.44346210f, 0.08493179f, 0.11656878f, 
    0.02939500f, 0.06810017f, 0.06575239f, -0.02844237f, 0.27474239f, -0.40227643f, -0.18196087f, 0.09867972f, 
    0.07306368f, -0.04076136f, -0.05705690f, 0.03519662f, -0.03111752f, -0.19206187f, 0.01979126f, 0.14530590f, 
    -0.07140367f, 0.11887719f, -0.03044311f, 0.10722256f, 0.07858920f, 0.01114606f, -0.18546358f, 0.04707018f, 
    -0.05309088f, -0.05452165f, -0.11216763f, -0.07883938f, 0.02555810f, 0.00294952f, 0.15081912f, 0.25975797f, 
    0.04376160f, 0.06381470f, -0.08123923f, 0.15670121f, 0.17036797f, 0.03662725f, 0.17724025f, 0.15019472f, 
    0.07913428f, 0.26002246f, -0.05186817f, 0.16452526f, 0.02508808f, 0.01276180f, -0.04362709f, 0.09149195f, 
    0.22349417f, -0.43229878f, 0.03233110f, -0.28616506f, -0.20875530f, -0.01710141f, -0.11373821f, -0.07165743f, 
    -0.01563261f, -0.04029260f, -0.30377349f, -0.46144387f, -0.17709225f, 0.16283390f, 0.05994588f, -0.18935488f, 
    -0.00366168f, -0.00983208f, 0.06929465f, 0.13279198f, -0.06333461f, 0.02197217f, -0.07268348f, 0.22019432f, 
    0.03349134f, 0.15560794f, 0.15532744f, 0.04657336f, 0.28496927f, -0.48336449f, -0.53250349f, 0.01283510f, 
    0.08389293f, 0.04366096f, -0.04333656f, 0.08690748f, -0.00941308f, -0.39826211f, 0.03690397f, 0.43533364f, 
    0.06046572f, 0.13417642f, 0.03522719f, 0.01358780f, 0.05420380f, -0.00765246f, -0.13675119f, -0.07812385f, 
    0.07346532f, -0.22382578f, -0.27830720f, -0.16829494f, -0.02488132f, 0.03787472f, -0.13243571f, 0.08937354f, 
    0.06865349f, -0.33644277f, 0.24327530f, 0.09286681f, 0.14858465f, -0.02746075f, -0.12186512f, 0.07025741f, 
    0.19524843f, -0.01350482f, -0.44182354f, -0.19849347f, -0.20469341f, -0.07126542f, 0.14665535f, -0.08365233f, 
    0.13325863f, 0.05475741f, 0.06328560f, -0.18282269f, 0.21759064f, -0.11625780f, -0.01792376f, 0.01733891f, 
    -0.20326072f, 0.00197743f, -0.08426359f, 0.08939448f, -0.24165393f, -0.01794803f, 0.06353649f, 0.09517250f, 
    0.03521242f, 0.05676010f, -0.01688335f, 0.41450253f, -0.21278432f, -0.35105565f, -0.02736813f, -0.04884674f, 
    0.04030391f, -0.07173893f, -0.03564155f, 0.03825464f, -0.05923489f, -0.01618822f, -0.06823283f, -0.00145932f, 
    0.10075221f, 0.02332814f, 0.01747142f, 0.09124561f, -0.04202369f, -0.25200638f, 0.19271529f, -0.36184499f, 
    -0.22102296f, 0.04688675f, -0.02193638f, 0.03301299f, -0.13579629f, -0.01034839f, 0.08095816f, 0.08010402f, 
    -0.05980156f, 0.07027627f, -0.05550965f, -0.17336538f, -0.02026303f, -0.12360069f, 0.16155842f, -0.13938043f, 
    -0.03920157f, -0.04636756f, 0.15903449f, 0.07953922f, 0.04787912f, 0.05777118f, -0.05392983f, -0.15941519f, 
    -0.16101661f, -0.13555950f, -0.17677325f, 0.08180588f, -0.02139161f, -0.08697368f, 0.18519782f, -0.04231799f, 
    -0.12510996f, 0.17815694f, 0.28694254f, 0.07383246f, 0.07565869f, -0.05324610f, -0.08463159f, 0.07912988f, 
    0.03223638f, 0.04748416f, -0.31941175f, 0.03024429f, -0.08482412f, -0.00749760f, 0.08180434f, -0.09739129f, 
    -0.09646713f, -0.04225400f, -0.09063291f, 0.60891581f, 0.20656724f, -0.24881807f, -0.19853018f, -0.33746439f, 
    0.17021248f, 0.09901595f, 0.13916939f, 0.02798189f, -0.10014690f, -0.09971610f, -0.05596791f, 0.07185046f, 
    0.03001032f, -0.03916377f, 0.07489865f, -0.19565123f, 0.24788789f, 0.08393291f, -0.09427104f, -0.06255687f, 
    -0.19007610f, 0.05953122f, -0.13293664f, 0.13731380f, -0.07393251f, 0.05826215f, 0.33919016f, 0.15287879f, 
    -0.06812689f, -0.28190637f, -0.44307214f, 0.08559584f, 0.22046621f, 0.00740184f, 0.10869850f, 0.19523045f, 
    -0.14007467f, -0.40312260f, 0.01349209f, -0.03104668f, -0.05524980f, 0.08988790f, 0.09315279f, 0.06453652f, 
    -0.03342469f, 0.35987836f, 0.14471531f, 0.03805067f, -0.09387469f, 0.12208869f, 0.07629441f, 0.01566366f, 
    0.07491352f, 0.69523281f, 0.07534013f, 0.00069411f, 0.09771906f, -0.05161723f, 0.03148815f, -0.05399300f, 
    -0.05461045f, -0.06785282f, -0.01747818f, 0.06872387f, -0.12290042f, 0.15287025f, -0.06138395f, 0.07270367f, 
    0.01561895f, -0.20240755f, 0.11497798f, 0.35808679f, 0.13554886f, -0.04246143f, 0.00017389f, -0.01187420f, 
    0.08437714f, -0.09435496f, -0.03077562f, -0.06364650f, -0.09895873f, -0.20573062f, 0.00190814f, 0.08187886f, 
    0.04937365f, -0.04273598f, 0.02878059f, -0.09225293f, -0.12687995f, -0.24051712f, -0.02290872f, 0.08366710f, 
    -0.03681251f, 0.07744316f, -0.10048051f, 0.03898992f, 0.32724848f, 0.26291823f, -0.03117581f, -0.07268666f, 
    0.28228378f, -0.07547386f, 0.08374294f, -0.00044468f, 0.22630686f, 0.28519598f, 0.29143435f, -0.19914633f, 
    -0.28422838f, -0.02191483f, 0.01220960f, 0.20511523f, -0.06244439f, -0.00904569f, -0.10356749f, -0.18931876f, 
    0.09808140f, -0.06498523f, 0.10445796f, 0.02041068f, 0.12306890f, 0.01229134f, 0.00600608f, -0.02448991f, 
    0.04139248f, 0.19535427f, 0.08978731f, 0.08853387f, -0.00084749f, -0.07083706f, 0.07329632f, 0.01382785f, 
    0.07249467f, 0.06173873f, 0.23964463f, 0.24860729f, -0.08175952f, 0.02242813f, -0.12619965f, -0.04624591f, 
    -0.03115980f, -0.00810809f, 0.09230846f, -0.01913778f, -0.12813024f, -0.09498229f, -0.09757414f, 0.11753979f, 
    0.02831575f, -0.01474106f, 0.02194717f, -0.05623557f, -0.08566432f, -0.10779230f, -0.01543762f, 0.11183023f, 
    -0.19094281f, -0.11790355f, 0.15850583f, -0.08883201f, 0.16086783f, 0.23340401f, 0.04013903f, -0.35561776f, 
    0.09992355f, -0.07436686f, 0.05331328f, 0.02513086f, 0.00687618f, -0.13153633f, 0.06073747f, -0.10687333f, 
    0.09443401f, -0.25370604f, 0.10305184f, 0.02130810f, -0.14157572f, -0.15052786f, -0.09434919f, -0.24394086f, 
    -0.06494195f, -0.26449659f, 0.11284620f, 0.06991310f, -0.03255527f, -0.01871689f, 0.11907370f, -0.06387858f, 
    -0.04744411f, 0.03042603f, -0.00351749f, -0.00403896f, -0.02277825f, -0.01936481f, 0.00436863f, -0.02307373f, 
    0.04334715f, -0.00045678f, 0.01916571f, -0.03642609f, -0.00929045f, -0.01204585f, -0.02746877f, -0.02247295f, 
    -0.02532788f, 0.05259012f, 0.01199996f, -0.06148692f, -0.00598116f, -0.04408632f, -0.02901831f, 0.01227854f, 
    -0.02143518f, 0.01257419f, 0.00920175f, -0.07309853f, -0.06301039f, -0.00111485f, 0.02167109f, -0.02520059f, 
    -0.00548422f, 0.01122255f, -0.05762049f, -0.04415750f, 0.04288136f, -0.06118915f, 0.03370075f, -0.00444076f, 
    -0.03759205f, -0.01591918f, 0.03323178f, -0.03124269f, 0.02422640f, -0.05868659f, 0.05261935f, 0.01419082f, 
    0.04425126f, 0.00795508f, 0.01778435f, -0.04885328f, -0.01928617f, -0.00502215f, -0.04896439f, -0.03568149f, 
    -0.02826082f, 0.01411203f, -0.00003205f, -0.04427234f, 0.04664002f, -0.02582439f, -0.06173004f, -0.04827913f, 
    -0.02057905f, 0.03918880f, 0.03266238f, -0.04851990f, 0.00847848f, 0.00797299f, -0.05195399f, -0.01788434f, 
    0.02745246f, 0.02097013f, -0.01777983f, -0.04743348f, -0.00731917f, -0.00417364f, -0.01203419f, -0.00924116f, 
    -0.03879155f, -0.01158884f, 0.04708751f, 0.03134485f, -0.05318386f, 0.04370429f, -0.02304303f, 0.00500062f, 
    0.02972399f, 0.02786856f, 0.01700813f, -0.03533280f, -0.01483227f, 0.00573093f, -0.01818701f, -0.00482565f, 
    0.01417355f, -0.03578360f, -0.03509131f, -0.05709789f, 0.01558284f, -0.01861351f, 0.02657713f, 0.04544546f, 
    -0.04024559f, -0.02470591f, -0.01294116f, 0.02318362f, -0.01749076f, -0.04528042f, -0.01768902f, 0.05160821f, 
    -0.01321460f, -0.00801411f, 0.05472961f, -0.00804176f, -0.00278329f, 0.01856892f, 0.00499918f, 0.02763978f, 
    -0.04342519f, -0.05483863f, 0.01181874f, 0.02885903f, -0.05737687f, -0.00606237f, -0.05498282f, -0.01176253f, 
    0.03611451f, 0.00157609f, -0.01306223f, 0.03680234f, -0.04525780f, 0.05767954f, 0.04600050f, 0.03496535f, 
    0.03067395f, -0.06672462f, 0.04380262f, -0.04004296f, -0.02054016f, 0.01933015f, -0.00074009f, 0.01699507f, 
    -0.05868345f, -0.03033175f, -0.02730655f, -0.02789666f, -0.06444792f, 0.03301378f, -0.04706976f, -0.03063959f, 
    0.02278831f, 0.03170383f, -0.07475853f, -0.00457128f, -0.02798058f, 0.04275926f, -0.06825446f, -0.06060013f, 
    -0.02912887f, 0.02172400f, -0.07005499f, 0.01911178f, 0.04242212f, -0.00829339f, 0.01222832f, 0.00788856f, 
    0.04765375f, -0.04484497f, 0.02550559f, -0.03899786f, -0.05578042f, 0.01781945f, 0.00875502f, -0.05119438f, 
    0.00581967f, 0.00088322f, 0.02229801f, -0.04086506f, -0.01313266f, 0.05505061f, -0.00841205f, 0.00398370f, 
    -0.06597597f, -0.01614787f, -0.02036318f, -0.03416714f, 0.00095712f, -0.03989674f, -0.02501137f, 0.02460777f, 
    0.03613718f, 0.03211242f, -0.07064103f, -0.05309692f, 0.00072272f, -0.04088933f, 0.02684601f, 0.00469921f, 
    -0.04531328f, -0.04105022f, -0.04031624f, -0.02489565f, 0.04416659f, -0.04964092f, -0.06324077f, -0.01299839f, 
    -0.01402545f, -0.00670564f, -0.01234759f, -0.00165133f, -0.05935892f, 0.00482249f, -0.02843951f, -0.04313535f, 
    0.02700521f, 0.02453544f, -0.02711950f, -0.01165166f, -0.03656973f, -0.03590767f, 0.05371320f, 0.00891400f, 
    -0.05208455f, -0.02686349f, -0.00064899f, 0.01809048f, -0.04380745f, -0.01242408f, -0.06305797f, -0.01115678f, 
    0.01367194f, -0.02237932f, 0.01680825f, -0.03980797f, 0.01181096f, -0.00266327f, 0.04097925f, -0.06621724f, 
    0.01369666f, -0.01986919f, 0.02304421f, -0.00807530f, -0.05329839f, -0.00680178f, -0.04937968f, 0.01628352f, 
    0.02087619f, 0.04680680f, -0.00348059f, -0.02828342f, 0.01194060f, -0.05976579f, 0.01351804f, -0.04417139f, 
    -0.06949680f, -0.02162252f, 0.05045062f, 0.03309006f, -0.02465653f, 0.04099888f, 0.01601914f, -0.00516225f, 
    -0.02708765f, -0.04178907f, -0.05935044f, 0.03260058f, 0.02128143f, -0.06176379f, -0.05934762f, -0.06217695f, 
    -0.05624558f, -0.01970896f, 0.03507857f, 0.02922823f, 0.03907019f, -0.05478464f, 0.00938863f, 0.04718235f, 
    -0.00525931f, 0.03152903f, 0.05185775f, 0.04693900f, -0.01007580f, 0.00869219f, 0.04510164f, 0.01732951f, 
    -0.05198564f, 0.16572402f, 0.13100417f, -0.11026722f, 0.05093422f, 0.12380590f, 0.02865689f, -0.12198846f, 
    -0.11077493f, 0.18057768f, 0.05795238f, 0.06946949f, 0.01330876f, 0.11845291f, 0.04637256f, -0.02673957f, 
    0.10323868f, 0.09490750f, 0.20898630f, -0.08349030f, 0.35525978f, -0.18567559f, 0.14164661f, 0.02219363f, 
    -0.16502810f, -0.05357059f, -0.24987374f, -0.07806350f, -0.00086084f, -0.06252545f, 0.01410532f, 0.05843514f, 
    -0.11789561f, -0.13306545f, -0.04059643f, 0.05465868f, 0.21355839f, -0.12557693f, 0.13894431f, -0.05111728f, 
    0.10206308f, -0.04105263f, 0.14498681f, 0.01746983f, 0.06583618f, 0.09127859f, -0.23958112f, -0.16715261f, 
    0.06726296f, 0.11826960f, 0.23951322f, -0.14219216f, 0.03495644f, 0.08114092f, 0.02259775f, 0.08910768f, 
    0.13645169f, 0.14444688f, 0.02026871f, -0.06061106f, -0.00070047f, 0.02341550f, 0.05573970f, -0.12848514f, 
    0.02581791f, 0.25887117f, -0.17779276f, 0.02982062f, 0.05002395f, -0.13300297f, 0.16835427f, 0.07252654f, 
    0.27929524f, 0.01709922f, 0.19746834f, 0.12862508f, 0.09049588f, 0.06430269f, -0.26250696f, -0.01697082f, 
    0.04030045f, -0.13832207f, 0.11634930f, -0.09986720f, 0.14816891f, -0.06861563f, -0.10842022f, 0.13110800f, 
    -0.14589189f, 0.14615577f, -0.19041115f, -0.23541035f, -0.13885714f, 0.06542278f, -0.04110089f, 0.14638746f, 
    0.08073453f, -0.01170040f, 0.11621428f, 0.01143586f, -0.07406760f, -0.17216583f, -0.24377756f, -0.17787366f, 
    -0.15326656f, 0.20840992f, 0.06922978f, -0.00909205f, -0.42491734f, 0.26956090f, 0.00453685f, 0.04204089f, 
    0.04808937f, -0.01584398f, -0.17501478f, 0.18153441f, 0.15133755f, 0.01712166f, 0.19966011f, -0.03206828f, 
    0.14063652f, 0.04869620f, 0.11611310f, -0.09218698f, 0.07776878f, 0.05086594f, 0.08781096f, 0.08696851f, 
    -0.00635666f, -0.18240859f, 0.00280659f, -0.00445383f, 0.02393201f, 0.04772436f, -0.02501000f, 0.09172877f, 
    0.05677083f, 0.03001282f, 0.02357517f, 0.17514634f, 0.16311118f, 0.00706134f, -0.08866299f, -0.10812652f, 
    -0.01925703f, -0.00333765f, 0.06109560f, -0.05279091f, -0.12340518f, 0.05923841f, 0.03687009f, 0.03088568f, 
    0.06549514f, -0.35600314f, -0.19837470f, -0.08678680f, -0.08991286f, 0.09816298f, -0.19329691f, 0.06430151f, 
    -0.09327935f, -0.05012381f, -0.00494854f, 0.13298126f, 0.03006037f, 0.08574921f, -0.02370428f, 0.04520915f, 
    0.03275241f, 0.00863640f, 0.11149965f, -0.33346316f, -0.02248134f, 0.07785843f, 0.06976752f, 0.04158517f, 
    -0.17832687f, -0.00157968f, -0.02217294f, -0.14705406f, -0.10146730f, -0.13364518f, 0.09406665f, 0.06410738f, 
    0.01457208f, -0.14423022f, 0.04064014f, -0.00704625f, 0.03500691f, 0.03104434f, -0.17349374f, -0.19322285f, 
    0.00546122f, 0.02842417f, 0.08310870f, -0.01648434f, -0.01873938f, -0.14816488f, 0.06899773f, 0.05502843f, 
    -0.15070975f, 0.04615412f, -0.07647616f, -0.01908686f, -0.02270955f, -0.16277237f, 0.06512229f, -0.04124214f, 
    0.02443219f, 0.04343032f, 0.09529518f, 0.03807371f, 0.00426950f, 0.09875550f, 0.11445173f, 0.09714693f, 
    -0.04188542f, 0.26180005f, 0.03550067f, 0.19538052f, 0.09567095f, -0.01822422f, 0.04311991f, 0.09905388f, 
    0.11072293f, 0.10796794f, 0.07259206f, -0.02983503f, -0.00657236f, -0.06610706f, 0.09238206f, -0.02050220f, 
    -0.09859296f, -0.14752653f, -0.12672058f, -0.01405717f, -0.12942694f, -0.07611088f, -0.04067079f, -0.01106780f, 
    0.08597454f, -0.05973701f, -0.16904187f, -0.02656390f, 0.06529284f, -0.06292218f, 0.04540984f, 0.16893086f, 
    0.07141025f, -0.04998087f, 0.01251595f, -0.04266153f, -0.47850639f, 0.38322604f, 0.37353790f, -0.18329804f, 
    0.23014538f, 0.12859197f, -0.14722756f, 0.03882436f, -0.05248340f, -0.06388808f, 0.05125491f, -0.13008806f, 
    -0.21748507f, 0.01622202f, 0.00254910f, 0.17955033f, 0.12615234f, -0.06805541f, -0.20113854f, 0.21953322f, 
    -0.02019123f, 0.09317242f, 0.04161269f, 0.07918795f, 0.15186062f, 0.00034832f, 0.16515163f, 0.18843913f, 
    0.06130074f, 0.00980024f, -0.13459204f, 0.24904315f, 0.20525111f, -0.01585387f, -0.02748013f, -0.08074850f, 
    -0.04530272f, 0.10358401f, -0.07669994f, 0.12266890f, 0.30574691f, 0.04550129f, -0.19423215f, -0.06736016f, 
    -0.02012324f, -0.04884565f, 0.13507292f, -0.02702867f, 0.01147857f, 0.10117745f, 0.06784982f, 0.07560968f, 
    0.05950002f, -0.07342894f, -0.13008049f, 0.29459983f, 0.44915012f, 0.02397860f, -0.30819991f, 0.02945944f, 
    -0.01419348f, 0.02041909f, 0.14443704f, -0.11972129f, 0.28652647f, 0.17603913f, 0.05103561f, 0.05331085f, 
    -0.04057538f, 0.06401090f, 0.00621439f, -0.12386804f, -0.13387926f, -0.09626338f, 0.09147680f, 0.01056570f, 
    -0.21687770f, 0.06849887f, 0.12937602f, 0.00716217f, 0.01272727f, -0.03856621f, -0.15311174f, -0.06038536f, 
    0.05260959f, 0.11541458f, -0.14926399f, 0.02731192f, 0.09285513f, -0.12439825f, -0.05783258f, 0.19462593f, 
    0.08969432f, -0.09472603f, 0.02224730f, 0.18246064f, 0.10329051f, -0.00655757f, -0.09322355f, -0.15436448f, 
    -0.29213819f, 0.18304931f, 0.25136432f, 0.23229253f, -0.01727931f, -0.16567491f, 0.03112777f, -0.04372684f, 
    -0.53441072f, -0.13891344f, 0.02200472f, -0.05818432f, -0.07374099f, -0.06728583f, -0.21405037f, -0.07615528f, 
    0.14184748f, -0.48409709f, -0.00512645f, -0.17590635f, -0.12343559f, -0.11026019f, -0.16086583f, -0.03270430f, 
    -0.23374762f, -0.03495224f, 0.25628817f, 0.17256068f, 0.11892613f, -0.05163876f, -0.14080317f, 0.14020549f, 
    0.09356646f, -0.15647332f, -0.10513642f, -0.32946697f, 0.40916151f, 0.18617547f, -0.15532143f, -0.07080565f, 
    0.12810244f, 0.12537362f, 0.01715098f, -0.01528656f, -0.31674811f, 0.24638957f, -0.03439150f, 0.12270479f, 
    0.10800385f, -0.33100513f, -0.06918448f, -0.08575732f, 0.07083960f, 0.01116051f, 0.06223855f, 0.04797816f, 
    0.16234568f, 0.01122634f, -0.21934329f, -0.04525664f, -0.12034190f, 0.16118777f, -0.04273777f, 0.27124852f, 
    0.01643959f, -0.12538211f, -0.06891711f, 0.09366428f, -0.07723189f, -0.09594569f, -0.00689105f, -0.04278411f, 
    0.00443570f, -0.03714469f, 0.07345215f, 0.10306370f, 0.11396708f, -0.06278138f, 0.00520370f, -0.11411493f, 
    0.06664588f, 0.05156922f, 0.06185118f, 0.06936178f, 0.07805668f, 0.15401745f, 0.20320942f, 0.03597510f, 
    0.00739599f, -0.10520630f, -0.13190325f, 0.06243925f, -0.21200383f, -0.05364763f, -0.12594695f, 0.10171916f, 
    -0.01385292f, 0.00541609f, -0.12261559f, 0.36446646f, -0.05258659f, -0.07994864f, -0.24708092f, -0.00987385f, 
    0.00748485f, -0.07366539f, 0.13677621f, -0.08467673f, 0.09049536f, 0.08116037f, -0.11469375f, -0.12558070f, 
    0.09165025f, 0.06161838f, -0.21284536f, 0.05339932f, -0.21290524f, -0.16969243f, 0.22471640f, 0.11718819f, 
    -0.00445237f, -0.23218434f, 0.03913621f, 0.02083823f, -0.05729365f, 0.28181866f, -0.17794111f, -0.00992386f, 
    0.02529721f, -0.07571969f, -0.21277495f, 0.11439262f, -0.04268173f, 0.18116687f, 0.06746431f, -0.15424310f, 
    -0.49028364f, 0.25588626f, -0.01691745f, -0.00921327f, 0.15129369f, -0.14276147f, 0.04942505f, -0.36447191f, 
    -0.19440535f, -0.35351273f, -0.00013472f, -0.03107905f, -0.00892794f, -0.03835701f, -0.03118314f, 0.10608758f, 
    -0.25321910f, -0.11859260f, -0.25810102f, 0.11455447f, -0.04182250f, 0.02601432f, -0.10344263f, -0.02060091f, 
    0.19586401f, 0.05159509f, 0.14755818f, 0.16104023f, 0.10110583f, -0.03606751f, 0.09514005f, 0.18675649f, 
    -0.00639266f, -0.03170619f, 0.17674133f, 0.21290122f, 0.36971197f, -0.01283791f, 0.04187562f, 0.11396724f, 
    0.10498257f, 0.11129124f, 0.03524430f, -0.57616621f, -0.14395724f, -0.08612872f, -0.17591175f, 0.11358277f, 
    -0.10622171f, -0.03557589f, -0.19494219f, 0.08160121f, -0.52449155f, 0.31361783f, -0.09661068f, -0.04525933f, 
    0.23297280f, 0.02756956f, -0.15321307f, -0.05144497f, 0.22133091f, 0.24665803f, 0.09992352f, 0.23328532f, 
    -0.16552003f, 0.00907226f, -0.01383997f, -0.10976970f, 0.04521775f, 0.09598275f, -0.26529095f, -0.35910639f, 
    0.21205895f, -0.07381207f, 0.01560642f, -0.11331181f, -0.03121892f, -0.10901913f, -0.11239477f, -0.40916169f, 
    -0.69150418f, -0.47875190f, -0.00158497f, -0.03413429f, 0.32976133f, 0.11328515f, 0.05698125f, -0.23436937f, 
    -0.10517645f, -0.10053536f, 0.12876783f, 0.19081973f, 0.10790181f, 0.04794225f, -0.03032796f, -0.12129646f, 
    0.09174259f, 0.07088394f, -0.00767557f, -0.17334756f, -0.06007241f, -0.02916075f, 0.06039905f, 0.09311838f, 
    -0.11292230f, 0.02524614f, -0.05205296f, -0.00218369f, -0.07740289f, -0.02334965f, -0.15030144f, -0.05809630f, 
    -0.10198551f, 0.12741613f, 0.25552356f, -0.02670841f, 0.05479927f, -0.12155782f, -0.12971553f, -0.10683502f, 
    -0.19218834f, 0.02893754f, 0.09955803f, 0.06230093f, -0.11010912f, 0.10512478f, -0.15829556f, -0.02458893f, 
    -0.06264795f, 0.05871412f, -0.20638295f, 0.21916620f, 0.38288277f, -0.05428990f, -0.13029183f, -0.04909671f, 
    0.11256897f, -0.01192054f, -0.22865878f, 0.08858152f, -0.06643944f, 0.17815804f, 0.01055033f, -0.10262273f, 
    -0.17292152f, -0.13528734f, 0.02208010f, 0.17153500f, -0.03398118f, -0.06445170f, 0.13808589f, -0.09991433f, 
    0.04193114f, -0.23273894f, 0.14785886f, -0.05289578f, 0.15725356f, 0.17738812f, 0.09644318f, -0.02967693f, 
    -0.21258347f, 0.09955840f, -0.01058529f, 0.14385955f, 0.12056920f, -0.12974739f, 0.24346714f, -0.15578614f, 
    -0.04797320f, 0.03081393f, 0.03645116f, -0.04300970f, 0.15747514f, 0.12729466f, 0.14797570f, 0.08178496f, 
    0.08021091f, 0.02663481f, -0.11717982f, 0.13673487f, 0.20438135f, 0.13489032f, 0.21566308f, -0.14509046f, 
    -0.21636121f, 0.02549111f, 0.03621461f, 0.25163114f, 0.06465430f, -0.07283669f, 0.01226486f, 0.05962208f, 
    0.21385609f, 0.06489990f, 0.05593178f, -0.08919335f, 0.17844716f, -0.17146476f, -0.01426150f, 0.05244121f, 
    0.01556322f, 0.06392179f, 0.21465617f, 0.00293853f, -0.34447989f, -0.01607446f, -0.10991859f, 0.06074464f, 
    0.06135631f, 0.08688586f, -0.06100353f, 0.09979266f, -0.06945578f, -0.25096998f, 0.21625598f, -0.10620999f, 
    -0.06515928f, 0.13782665f, 0.22703576f, 0.20883189f, 0.03446631f, -0.00274355f, -0.18281598f, -0.00103696f, 
    0.04059645f, 0.12735768f, 0.03897468f, 0.00834095f, -0.07554766f, 0.21625553f, -0.29320967f, -0.29937086f, 
    0.03386868f, 0.10796931f, 0.09859396f, 0.04366914f, -0.08607525f, 0.04544058f, 0.07396442f, -0.20154423f, 
    -0.24889600f, 0.01293823f, 0.08566511f, -0.21085033f, -0.20148951f, -0.06056461f, -0.08724084f, 0.03995336f, 
    0.14413448f, 0.07426191f, 0.00306476f, -0.08720649f, -0.26828891f, 0.05706669f, 0.00881802f, 0.06531020f, 
    -0.04689305f, -0.06255517f, 0.03883800f, 0.04860384f, -0.06753533f, -0.15818632f, -0.00508879f, 0.25459856f, 
    -0.00929802f, -0.12868430f, 0.14518546f, -0.02744615f, -0.11348893f, 0.10288937f, -0.00681472f, 0.02625656f, 
    0.03600858f, 0.11763246f, 0.08406385f, 0.01285903f, 0.04472808f, -0.24162878f, 0.00919269f, 0.02893605f, 
    0.16973484f, 0.06285413f, -0.00988537f, -0.02474875f, 0.07975022f, 0.13908987f, -0.32907513f, -0.30541560f, 
    -0.37366840f, 0.19281632f, 0.03512868f, 0.00957080f, -0.03863163f, 0.26074719f, 0.19904801f, -0.13390417f, 
    -0.12632866f, -0.27227986f, 0.17229390f, 0.02397289f, 0.04097241f, -0.04769026f, 0.07544462f, -0.04049947f, 
    -0.09621437f, -0.17433885f, -0.22513491f, 0.06375544f, 0.09947207f, 0.06542446f, 0.07212339f, -0.03946730f, 
    0.03127619f, -0.01124827f, 0.03637743f, 0.06681875f, 0.20973308f, 0.02447075f, 0.10783905f, 0.23541264f, 
    -0.14960177f, -0.45532858f, 0.04132192f, -0.07091964f, -0.08741719f, 0.22741117f, -0.05697049f, -0.02631354f, 
    0.00019857f, -0.03288364f, -0.06395674f, 0.15630786f, 0.01042356f, 0.00540172f, 0.12588628f, -0.09828124f, 
    -0.13231936f, 0.00140147f, 0.01170480f, 0.20723423f, 0.23244379f, -0.20954280f, -0.05830256f, -0.14285009f, 
    -0.01260114f, -0.09619276f, -0.12539215f, 0.11361553f, -0.08826037f, -0.14863686f, -0.27381134f, -0.06657751f, 
    0.00504815f, -0.15361345f, -0.00178079f, 0.24217340f, -0.10231671f, -0.01743133f, -0.05092823f, -0.04352614f, 
    -0.45749494f, 0.12373865f, 0.19805734f, 0.08251949f, -0.04326126f, 0.27403027f, 0.11646249f, -0.34079596f, 
    -0.01922742f, -0.35768616f, -0.03135251f, -0.18309055f, 0.22325741f, 0.11537740f, 0.18801670f, 0.29978067f, 
    0.04598160f, 0.10487416f, 0.37048268f, -0.36500791f, -0.15528546f, 0.30854130f, 0.00924498f, 0.32059422f, 
    0.20075114f, 0.06923084f, -0.13489777f, 0.06620098f, -0.08379371f, -0.18156530f, -0.02673543f, -0.06400389f, 
    0.04941693f, 0.17597429f, 0.10966212f, -0.04872035f, -0.23221609f, 0.11661422f, -0.05341517f, -0.11563401f, 
    -0.02337358f, 0.04884238f, 0.23412512f, -0.33684978f, 0.26308462f, 0.12239540f, -0.02268206f, 0.01786419f, 
    -0.16529231f, 0.09265016f, -0.07239993f, -0.04223760f, 0.07735944f, -0.05610584f, -0.10090110f, 0.05813546f, 
    -0.06079551f, -0.29700416f, -0.00478524f, -0.14402607f, -0.26834932f, 0.08293040f, 0.14627327f, -0.11093701f, 
    0.04967758f, 0.09465238f, 0.23613679f, 0.00104941f, -0.01093619f, -0.09766297f, 0.03356387f, -0.05553662f, 
    0.12373193f, 0.02202285f, -0.09731638f, 0.10200148f, 0.00591758f, -0.05076795f, 0.08471679f, -0.24426880f, 
    -0.14930505f, -0.16368331f, 0.16641559f, -0.00452360f, 0.17486893f, -0.03861649f, 0.14496006f, 0.06801030f, 
    -0.10332579f, -0.26542446f, 0.06326026f, 0.09344911f, 0.04734110f, -0.15626726f, -0.18644774f, 0.06229378f, 
    0.24915045f, 0.02449959f, 0.04389169f, 0.06291061f, 0.05428740f, -0.04330065f, 0.01289412f, 0.11641555f, 
    -0.25019899f, -0.51814479f, -0.01675304f, 0.12624639f, -0.05248972f, 0.14870612f, 0.06054706f, 0.05370627f, 
    0.01255108f, -0.15655945f, -0.16961390f, 0.13068868f, -0.00138637f, -0.18833423f, 0.16230594f, 0.18867192f, 
    0.01317067f, -0.05111293f, -0.04337111f, -0.04089571f, 0.12208018f, 0.17069419f, 0.23022051f, -0.17808387f, 
    -0.21757130f, 0.21284349f, 0.04209395f, 0.20006834f, 0.15934065f, -0.04314578f, 0.11852665f, 0.22680181f, 
    -0.04655251f, -0.20519485f, 0.16169296f, -0.06379088f, 0.13491467f, 0.16034281f, 0.01417582f, -0.13627283f, 
    0.02721895f, 0.29820019f, 0.11951702f, 0.04566099f, 0.00070313f, 0.06740410f, -0.08405045f, 0.06057221f, 
    0.01859832f, 0.12755030f, -0.19485039f, -0.06376889f, -0.02788348f, 0.00604794f, 0.07325782f, 0.18750426f, 
    -0.23300296f, -0.21134247f, -0.16753945f, 0.04944789f, 0.20314893f, -0.06779379f, 0.01633458f, 0.04467487f, 
    0.06570545f, -0.08638427f, 0.07245029f, -0.09804112f, -0.05634478f, 0.00978476f, -0.10524563f, 0.08078484f, 
    -0.16341266f, -0.15191104f, 0.09550663f, -0.01443933f, 0.15794916f, 0.05900083f, -0.10457877f, 0.00052865f, 
    -0.07028560f, -0.02660521f, -0.09262504f, 0.04427817f, -0.08158828f, -0.15723218f, -0.13147989f, -0.00293578f, 
    0.01291148f, 0.06570789f, 0.07839900f, -0.08555786f, -0.43660283f, -0.20768704f, -0.22332595f, 0.10808888f, 
    0.04766396f, 0.12469459f, -0.14619078f, -0.02835434f, -0.08890618f, 0.00237096f, 0.12289223f, 0.04570172f, 
    0.13613667f, 0.08478443f, 0.05669057f, 0.07110278f, -0.23284456f, -0.68696201f, -0.00944875f, -0.01464970f, 
    0.15979345f, 0.16299802f, 0.05056777f, 0.10294551f, -0.00569538f, -0.38904974f, -0.51566529f, -0.27242076f, 
    -0.28438967f, 0.20342457f, 0.00744520f, 0.21732834f, 0.00810628f, -0.25178659f, -0.04782947f, 0.13217518f, 
    -0.14890255f, -0.06744293f, 0.17433007f, -0.15428619f, 0.00394184f, -0.04837766f, -0.04190794f, 0.06954800f, 
    -0.21911803f, -0.10169274f, -0.08363304f, 0.07761095f, -0.06136195f, -0.02993712f, -0.02153842f, 0.09233275f, 
    0.03343259f, 0.03258325f, -0.07814262f, 0.17706279f, 0.07628637f, 0.02105815f, 0.01592651f, 0.01078468f, 
    0.09903559f, 0.01987426f, 0.08348645f, -0.39675540f, -0.00912713f, 0.23621678f, 0.06353931f, -0.06801374f, 
    0.10274502f, 0.05434815f, -0.11353872f, -0.12337161f, -0.13340726f, -0.15992028f, 0.26674601f, -0.07439891f, 
    -0.23429587f, 0.31481841f, 0.15264767f, 0.29030818f, -0.02299497f, -0.05092938f, 0.11403338f, 0.07141249f, 
    -0.20097044f, 0.10050262f, 0.08229124f, 0.14212289f, -0.01236968f, 0.01926912f, -0.03407601f, -0.09490583f, 
    0.16597854f, 0.06697518f, 0.19439256f, 0.10738460f, 0.06922214f, -0.24738567f, 0.10695158f, 0.23224594f, 
    -0.07170927f, 0.17329884f, 0.00818571f, 0.12792537f, 0.06905147f, -0.22520033f, 0.11041500f, 0.02637298f, 
    -0.06632012f, -0.16818862f, -0.02889664f, 0.02523845f, 0.01777676f, 0.14195649f, -0.29327050f, -0.01194191f, 
    0.14832908f, -0.24102506f, -0.39342815f, -0.03190461f, 0.03149092f, 0.09560724f, 0.01872572f, 0.15067089f, 
    0.07572021f, 0.09824303f, 0.55532646f, 0.32329008f, 0.18651111f, -0.11454484f, -0.02781930f, -0.04733521f, 
    -0.00208803f, 0.10887326f, 0.04806929f, 0.46127731f, 0.22325127f, 0.08083802f, 0.05596811f, 0.07565528f, 
    -0.01035809f, 0.03615522f, -0.03283441f, -0.13174281f, 0.35074276f, 0.16434009f, 0.05906387f, 0.10931375f, 
    0.04833844f, -0.00559905f, 0.13177051f, 0.02388721f, -0.29647207f, 0.00808753f, 0.08301463f, 0.23419166f, 
    0.06394119f, 0.05801585f, 0.00166986f, -0.00445627f, 0.02013207f, 0.02635353f, -0.19082245f, -0.21905079f, 
    -0.03487688f, 0.00781943f, 0.00235307f, -0.02370322f, 0.09124799f, -0.05688656f, -0.04085777f, -0.28736213f, 
    -0.20935185f, 0.12346589f, -0.21359780f, -0.13758005f, 0.04409697f, 0.05437192f, -0.04896004f, 0.23310494f, 
    0.00713920f, 0.01873955f, -0.14450778f, -0.09299380f, -0.04280030f, 0.33261567f, -0.00009132f, 0.12535441f, 
    0.24892281f, -0.30466300f, -0.29264012f, 0.03048159f, -0.19215353f, 0.05809756f, -0.09837642f, -0.00531058f, 
    0.01672593f, -0.13233270f, -0.04375677f, 0.12813237f, -0.03677143f, 0.02393501f, 0.11263555f, 0.08098644f, 
    -0.02694137f, 0.19218375f, -0.06673528f, 0.23994607f, 0.07047838f, 0.09585109f, 0.14830150f, 0.01776904f, 
    0.14833631f, -0.15519302f, 0.06256009f, -0.02395808f, -0.08192901f, 0.02607282f, 0.17198576f, -0.04838193f, 
    0.16030514f, -0.12731774f, 0.09767157f, 0.13593383f, 0.00517148f, 0.01489924f, 0.00003327f, 0.22242276f, 
    0.18373576f, 0.07426921f, -0.08717372f, 0.01501269f, 0.07667789f, 0.21675724f, -0.28904229f, -0.13980678f, 
    -0.08475158f, 0.05473565f, 0.04191731f, -0.10801510f, -0.17198154f, -0.03467081f, 0.14647636f, -0.20893164f, 
    0.00348994f, 0.03143956f, 0.14584382f, 0.02852147f, 0.09973781f, 0.24539651f, 0.12254978f, 0.14676823f, 
    0.09107614f, 0.17639977f, 0.21213882f, 0.04549346f, 0.16841581f, 0.05910794f, 0.13233188f, 0.03925052f, 
    0.09567676f, 0.47778562f, 0.14883061f, 0.11280174f, 0.11396582f, 0.07491200f, 0.03358695f, 0.03926625f, 
    0.03643429f, -0.11152228f, -0.43747428f, -0.37899154f, -0.04572868f, -0.04334651f, 0.02370460f, -0.03500079f, 
    0.06138911f, 0.04360447f, 0.05263231f, 0.11584864f, 0.04902932f, 0.09193459f, 0.04109786f, 0.18109418f, 
    0.07099133f, 0.03083446f, -0.10237458f, -0.08955066f, -0.33725625f, -0.28382888f, 0.22862266f, -0.19366330f, 
    -0.21301699f, -0.06684736f, 0.05956584f, 0.08179957f, 0.14376646f, -0.04750909f, -0.08253177f, 0.06439779f, 
    -0.15024708f, -0.14402279f, -0.13270977f, 0.02473809f, -0.20507398f, -0.17605820f, -0.11341350f, 0.00981345f, 
    -0.00338980f, -0.17323810f, -0.09293368f, -0.08098490f, 0.15044318f, -0.21985912f, -0.17935236f, -0.29913583f, 
    0.08499108f, -0.03239892f, -0.09968414f, -0.07233872f, 0.05546711f, 0.05611730f, 0.11222900f, 0.25598702f, 
    -0.00689607f, 0.12248398f, 0.04023239f, 0.12515408f, 0.10440325f, -0.16345376f, 0.37912831f, 0.27246207f, 
    0.22675683f, -0.00155867f, 0.12194502f, 0.05009166f, 0.14959656f, -0.02721337f, -0.03873473f, 0.03288655f, 
    -0.08212511f, 0.13111335f, 0.19573970f, 0.10305765f, 0.12857583f, -0.02661470f, 0.02736558f, 0.14064386f, 
    0.10222744f, 0.04718699f, 0.08508254f, 0.32463634f, 0.24732754f, 0.15349367f, 0.06811479f, 0.12147278f, 
    0.10421383f, -0.14359584f, 0.10666889f, -0.03196643f, 0.29138803f, 0.58293080f, 0.20416895f, 0.07064198f, 
    0.08769877f, -0.07854905f, 0.01761783f, 0.01039117f, -0.17870112f, 0.30905584f, 0.17266105f, 0.31252903f, 
    0.21910214f, 0.11551515f, -0.01435821f, -0.03682723f, 0.09317543f, 0.15735163f, -0.28818700f, -0.01940879f, 
    0.29530701f, -0.03510873f, -0.12662464f, 0.24137664f, 0.24268733f, 0.33222750f, -0.02197730f, -0.42039895f, 
    -0.25464034f, -0.16687027f, 0.14106725f, -0.01557179f, -0.00636079f, 0.16344951f, -0.01150028f, -0.18185812f, 
    -0.07400282f, -0.36171252f, -0.10442986f, -0.19533090f, -0.23659724f, -0.14818506f, -0.18405032f, 0.11866115f, 
    0.17868650f, 0.01443089f, -0.01512547f, 0.03956721f, 0.03832147f, 0.13589294f, 0.15300888f, -0.04576036f, 
    0.02152041f, 0.03416043f, -0.55532080f, 0.11654112f, 0.22104461f, -0.03429475f, 0.02433209f, -0.05606514f, 
    0.19256490f, -0.04782893f, 0.33571672f, -0.33975467f, -0.15407085f, 0.05715587f, -0.13592878f, -0.03213154f, 
    -0.09260096f, -0.15309900f, 0.09484050f, 0.06896780f, -0.26758355f, 0.23426883f, 0.28645784f, 0.05756597f, 
    0.08069175f, 0.19371065f, 0.08602167f, 0.03940874f, 0.43990800f, 0.18292366f, -0.15678981f, -0.21558942f, 
    -0.04839804f, -0.15690950f, 0.08469569f, 0.08749324f, -0.03150089f, 0.06654487f, 0.08726618f, 0.05099899f, 
    -0.04039204f, -0.10228067f, 0.04346826f, 0.04973930f, 0.04432804f, 0.17068379f, 0.13444327f, 0.05884168f, 
    -0.34108275f, -0.23282780f, -0.01534303f, 0.03784225f, 0.03120661f, 0.07045999f, 0.08387795f, 0.05919388f, 
    0.08719028f, 0.01278875f, 0.05412779f, -0.07715535f, -0.01924272f, 0.01270470f, 0.24063076f, 0.27932549f, 
    -0.11519706f, -0.10257537f, 0.00152334f, -0.00958887f, -0.13575736f, -0.02195299f, -0.09309559f, 0.08940961f, 
    0.10391186f, 0.35030374f, -0.34501898f, -0.07946769f, -0.15438414f, -0.07530072f, -0.00425386f, -0.15020797f, 
    -0.08101896f, -0.05401296f, 0.08877511f, -0.21797252f, 0.17590792f, 0.15373977f, -0.16814154f, -0.08648724f, 
    -0.03777407f, -0.07331230f, 0.13721359f, 0.10549396f, -0.03231567f, -0.14394957f, 0.27637389f, 0.05291033f, 
    -0.14427473f, -0.07363690f, 0.05518663f, -0.10749113f, -0.02647409f, -0.17907515f, -0.20330110f, 0.04344463f, 
    -0.04290135f, 0.02538857f, 0.07803255f, 0.06536066f, -0.04112302f, -0.14788696f, -0.01355589f, 0.04938095f, 
    0.02566491f, -0.01284361f, -0.09451213f, -0.08615307f, 0.08595359f, -0.00566988f, 0.09301528f, 0.01424498f, 
    0.01483438f, 0.09387962f, -0.01600108f, -0.04083964f, 0.07040653f, 0.07654770f, 0.08545052f, 0.00625591f, 
    -0.32114890f, -0.27324736f, -0.04143966f, -0.10942475f, 0.03762892f, -0.08192007f, 0.14767717f, -0.06843161f, 
    -0.04319854f, -0.43064907f, 0.10355700f, 0.07819939f, -0.02749367f, -0.05093143f, -0.17541675f, -0.16474934f, 
    -0.06983597f, 0.12408432f, -0.07270030f, 0.01420975f, 0.10500106f, -0.03586759f, -0.02926092f, 0.05153398f, 
    -0.07394408f, 0.15258113f, 0.05188766f, -0.21442281f, 0.07902332f, 0.00532941f, 0.06194907f, -0.01699225f, 
    -0.10135330f, 0.00694099f, -0.02919391f, 0.04929052f, -0.02452089f, -0.18954052f, -0.01868576f, 0.00026677f, 
    0.06505632f, 0.00868822f, 0.07482371f, 0.12994748f, -0.00786260f, -0.22654103f, 0.05136630f, -0.09683917f, 
    -0.05582915f, -0.04350115f, -0.05019586f, -0.03130860f, 0.06702044f, 0.13770968f, -0.22619516f, -0.06150233f, 
    -0.16522267f, -0.11246367f, -0.03578063f, 0.04456772f, 0.03772409f, 0.09539066f, 0.18688715f, 0.15901028f, 
    -0.13005297f, 0.02546634f, -0.04615387f, 0.03035421f, 0.11873154f, -0.06691547f, 0.14101382f, 0.08393615f, 
    0.20458926f, 0.00175164f, -0.01792585f, -0.00783252f, 0.00095327f, 0.17990696f, 0.14631437f, 0.06909777f, 
    0.09250990f, -0.34708115f, -0.12891091f, -0.14400834f, -0.26944870f, -0.01601774f, -0.09451567f, -0.01876730f, 
    -0.00420371f, -0.18493682f, -0.35726637f, -0.03334794f, 0.08626745f, 0.01473930f, 0.01777261f, -0.19162680f, 
    0.05885845f, 0.00195323f, 0.09366679f, 0.18072002f, -0.16439600f, 0.06342287f, -0.12993775f, -0.01382428f, 
    -0.04420174f, 0.11384736f, 0.16274187f, 0.13322765f, -0.08925138f, -0.53443712f, -0.05367365f, 0.11284339f, 
    -0.16636540f, 0.06664320f, -0.09207161f, -0.06900238f, 0.14846219f, -0.23865707f, 0.33174139f, 0.36818537f, 
    0.00156262f, -0.09865730f, -0.13744576f, -0.09814665f, 0.09587803f, 0.05230439f, 0.14321594f, -0.12751892f, 
    0.09264749f, -0.25335237f, -0.32511246f, 0.03067176f, 0.08875329f, 0.15936071f, 0.23637967f, -0.04366770f, 
    -0.01327771f, 0.09255371f, 0.12486432f, -0.07546011f, 0.21732080f, -0.11813579f, -0.30725047f, 0.20649965f, 
    0.02528683f, -0.02808954f, 0.05752093f, 0.02059161f, 0.02112198f, 0.01993099f, -0.03501437f, -0.02885184f, 
    0.04861022f, 0.03114683f, -0.00153801f, -0.01580265f, 0.03432613f, 0.01020692f, -0.04885754f, -0.02177647f, 
    -0.06750301f, 0.01790568f, -0.03021114f, 0.01444140f, 0.04011227f, 0.03582864f, -0.04307586f, -0.01368395f, 
    -0.01865852f, -0.06739419f, -0.02356843f, 0.04185740f, -0.01605900f, 0.01456171f, 0.00037196f, -0.01873144f, 
    0.04053102f, -0.01447647f, -0.03029896f, -0.05989160f, 0.04189984f, 0.01025492f, -0.04986482f, -0.00720368f, 
    0.03416912f, 0.04207622f, 0.02357935f, 0.01163629f, 0.04422882f, -0.00221832f, -0.02146786f, -0.02296235f, 
    0.03792315f, -0.05505487f, -0.03059464f, -0.03123154f, -0.00029050f, -0.01031346f, -0.05148430f, -0.03288499f, 
    0.02819715f, -0.03880503f, 0.05002693f, -0.00807612f, 0.03482537f, -0.04033683f, 0.01754611f, 0.02955415f, 
    -0.01369472f, -0.01497199f, -0.00286679f, 0.02902131f, -0.01991667f, -0.00391654f, 0.03797402f, -0.06180822f, 
    0.03816934f, -0.01258815f, -0.01391328f, 0.04692476f, 0.03354616f, -0.02513453f, 0.04284228f, 0.03678234f, 
    -0.04887675f, -0.03065512f, -0.04761006f, -0.03680911f, 0.01702241f, -0.03143026f, 0.00588325f, 0.00643501f, 
    -0.01547577f, 0.04981693f, -0.00235459f, -0.03859461f, -0.05207488f, -0.04617221f, -0.07412929f, -0.06381464f, 
    -0.03688635f, -0.03291336f, 0.02658568f, -0.04709354f, 0.03495695f, 0.00982487f, 0.02609939f, 0.01610137f, 
    -0.01517711f, -0.04953208f, -0.06606477f, -0.05286663f, 0.01550004f, -0.01942404f, -0.03976301f, -0.04241120f, 
    -0.04853655f, 0.04950084f, -0.01719704f, 0.01905466f, -0.04339875f, -0.04784095f, -0.03095751f, -0.01970182f, 
    0.03369976f, 0.00466055f, 0.03949324f, -0.06390151f, 0.00347329f, 0.04125892f, 0.06799266f, 0.02164256f, 
    -0.01252072f, -0.01781317f, 0.01154297f, 0.02962156f, -0.03880405f, -0.05347056f, 0.00645313f, 0.00387100f, 
    0.04632393f, 0.03457447f, -0.04871224f, -0.00391811f, -0.05625802f, -0.04102338f, -0.02659326f, -0.04784898f, 
    -0.04323695f, 0.00934318f, 0.02769938f, -0.00565755f, 0.02344429f, -0.06326642f, 0.03036282f, -0.01965162f, 
    0.00438470f, 0.05032801f, 0.00056766f, 0.02241845f, 0.02528308f, 0.02888302f, 0.00957560f, -0.02763340f, 
    -0.04559739f, -0.06527315f, 0.00454563f, 0.00677822f, 0.06380738f, 0.01137399f, 0.02860314f, -0.01460296f, 
    0.04237948f, 0.00974918f, -0.05098809f, 0.03159407f, 0.05285763f, 0.04280817f, -0.02310802f, 0.03632673f, 
    -0.02710100f, -0.00898781f, -0.06002244f, -0.04516162f, -0.02278273f, -0.06481378f, -0.00521620f, 0.02963243f, 
    0.04128788f, -0.00618356f, 0.03929375f, -0.00698890f, -0.04930034f, -0.06097137f, -0.00322647f, -0.06733190f, 
    0.01956772f, -0.03828027f, -0.01446415f, 0.03511878f, 0.00883676f, -0.02398999f, 0.03027909f, 0.02479058f, 
    -0.06408533f, -0.03945598f, -0.00068192f, -0.00116769f, -0.05919659f, -0.03704659f, 0.02450418f, 0.01771006f, 
    -0.03261884f, 0.00862836f, -0.06397168f, -0.00448660f, -0.04237400f, 0.03486567f, -0.06353246f, -0.06238427f, 
    -0.06163327f, -0.05387288f, -0.04855669f, 0.01477224f, 0.02613276f, -0.00868804f, -0.01295811f, -0.02832382f, 
    -0.03742131f, -0.04137602f, -0.04700686f, 0.06732605f, -0.01021755f, -0.04007488f, -0.03862184f, 0.03500908f, 
    0.01936163f, 0.00463797f, 0.03448888f, 0.00666963f, -0.02556425f, 0.01860156f, -0.02594090f, -0.00603540f, 
    -0.03773218f, 0.03350526f, -0.00763387f, -0.03609268f, -0.01415266f, 0.01616728f, 0.02663169f, 0.01984331f, 
    -0.00063817f, -0.01490750f, 0.00279391f, -0.01204934f, 0.01355586f, 0.00628445f, 0.00409154f, -0.02696744f, 
    0.05053335f, 0.00245681f, 0.01672194f, -0.00051433f, 0.05299011f, -0.04456558f, 0.01330661f, 0.00423489f, 
    -0.06456058f, -0.07492893f, -0.01677507f, 0.02115780f, 0.01392696f, -0.01333005f, 0.02665094f, -0.02944047f, 
    0.05839827f, -0.00179608f, -0.04557762f, 0.01489566f, 0.04625033f, -0.04766801f, 0.03599857f, 0.02150369f, 
    0.01539284f, -0.03966595f, -0.01065555f, 0.05069302f, 0.03622940f, 0.04590195f, -0.06201392f, -0.00336154f, 
    0.01944573f, -0.08573847f, -0.04806664f, 0.14934807f, 0.14645976f, 0.13025126f, -0.23848134f, -0.19080272f, 
    -0.16001029f, 0.04259033f, 0.16127832f, -0.11435823f, -0.12293239f, -0.04106619f, 0.03748155f, -0.12776749f, 
    0.03333588f, -0.20873885f, -0.17180644f, 0.10743008f, 0.08276389f, 0.00333455f, 0.14504801f, 0.11844949f, 
    0.10165831f, 0.12690908f, 0.24715005f, 0.10504460f, 0.02191707f, 0.03787399f, 0.16562808f, -0.01217858f, 
    0.11990168f, -0.05689565f, -0.02204816f, 0.25164920f, -0.26140863f, 0.08904229f, 0.02663982f, 0.02956148f, 
    0.17382108f, 0.19278730f, 0.16418399f, 0.17963856f, 0.12519945f, 0.10934459f, 0.12684716f, 0.31664628f, 
    -0.02966000f, -0.10243757f, -0.09440400f, 0.01585532f, 0.12493990f, 0.06133774f, -0.01091227f, 0.00713257f, 
    -0.20012389f, -0.06614316f, 0.02273145f, 0.08594795f, -0.07721405f, -0.19161303f, -0.16778418f, 0.07116110f, 
    0.06609115f, 0.03785316f, -0.06479029f, -0.02569518f, -0.07326210f, -0.06807230f, 0.00859441f, -0.06453593f, 
    -0.23694615f, 0.25258610f, -0.01547562f, 0.06076214f, -0.01573834f, -0.04934490f, 0.01072752f, -0.02161482f, 
    -0.18497363f, 0.10769209f, 0.12070867f, -0.09954295f, 0.04634574f, 0.10911450f, -0.08957577f, 0.07657640f, 
    0.01991487f, -0.25637048f, -0.03091768f, 0.25902283f, 0.04458755f, 0.10696008f, 0.08383447f, -0.00591557f, 
    -0.04936153f, 0.09793364f, 0.05170625f, -0.15294741f, -0.12313192f, 0.14737451f, -0.06079305f, 0.14682853f, 
    0.00105217f, 0.00474682f, -0.04706321f, -0.04043059f, 0.12610279f, -0.24327777f, -0.17500040f, 0.03879508f, 
    0.08399664f, -0.17599961f, 0.15342176f, 0.04143238f, -0.34339061f, 0.03887540f, -0.19287524f, -0.11356436f, 
    0.02778698f, 0.09019937f, -0.09333833f, -0.14547876f, -0.36991256f, -0.15675268f, -0.09245764f, -0.17923048f, 
    -0.06527684f, 0.04913430f, 0.16563146f, 0.05388059f, 0.08360617f, -0.33658686f, -0.32479975f, -0.14212610f, 
    0.00650511f, -0.08562503f, 0.12545720f, -0.03980883f, -0.19913496f, -0.25190255f, -0.27515426f, -0.52790684f, 
    -0.15345138f, -0.10191584f, -0.06456248f, 0.09783209f, -0.05273729f, 0.03263937f, -0.21793373f, -0.22596876f, 
    -0.39604440f, 0.31153819f, 0.22267808f, -0.01579705f, -0.06451821f, 0.11953339f, 0.14145131f, 0.01662756f, 
    -0.05517342f, 0.19016998f, 0.09977899f, 0.05831881f, -0.06613628f, 0.02376406f, 0.07719480f, -0.01344774f, 
    -0.03235602f, 0.06791485f, -0.10708291f, 0.20993567f, 0.04915120f, 0.10946631f, 0.11149576f, 0.19341531f, 
    0.02676030f, -0.02648025f, 0.12930885f, 0.02185019f, 0.16832986f, 0.25938404f, 0.07706427f, -0.09454600f, 
    -0.03114012f, -0.04942819f, -0.04034724f, -0.03204757f, -0.07012881f, 0.01467933f, 0.16292639f, 0.15691581f, 
    0.03032661f, 0.01966971f, 0.09699327f, 0.10618822f, 0.10630226f, 0.18212126f, -0.14801830f, 0.05613863f, 
    0.04435292f, 0.04017413f, 0.05093899f, 0.02683402f, 0.22406168f, 0.14458467f, 0.03434920f, 0.08301077f, 
    0.05136500f, -0.02521853f, -0.14722686f, -0.11600757f, -0.13950607f, 0.06211421f, -0.21337509f, -0.18948324f, 
    -0.00671179f, 0.00257916f, -0.22100340f, -0.09839892f, 0.10402934f, 0.01114527f, 0.09731312f, -0.05330988f, 
    -0.14649311f, 0.02464357f, -0.08307190f, -0.12003713f, 0.14139502f, 0.01088624f, -0.13247818f, -0.14360304f, 
    -0.21590686f, -0.39380655f, 0.01351438f, -0.10122569f, -0.05689801f, 0.23648538f, 0.06371273f, 0.18304850f, 
    0.00924274f, -0.04256732f, -0.05631747f, 0.26875764f, -0.08481957f, -0.10092411f, 0.01861585f, 0.01891266f, 
    0.07995003f, 0.04412220f, 0.12824775f, 0.15565439f, 0.40441051f, -0.24300858f, 0.02127414f, -0.07713968f, 
    0.08402208f, -0.02592599f, 0.20913738f, -0.08097429f, -0.12674977f, 0.03990612f, -0.25281358f, 0.10338432f, 
    0.12639782f, 0.01775897f, 0.00863303f, 0.06546351f, -0.04629524f, 0.05092636f, -0.21604988f, -0.06755491f, 
    -0.07499360f, 0.02966874f, 0.20600137f, 0.05399450f, 0.18129240f, 0.17483602f, -0.03009001f, -0.03304555f, 
    0.21352775f, 0.05112306f, 0.11558662f, -0.09530688f, 0.07261989f, 0.13628642f, 0.17107689f, -0.00051655f, 
    -0.36526927f, -0.11804601f, -0.13443454f, -0.15121642f, -0.00424792f, -0.30153015f, -0.00651776f, -0.00539913f, 
    -0.15254115f, 0.25225517f, 0.12044161f, 0.08350272f, -0.13318928f, 0.03347329f, 0.02859862f, 0.14017148f, 
    0.03976646f, 0.03779151f, -0.42843583f, -0.43971765f, -0.61977124f, -0.02792059f, 0.09263999f, -0.14659931f, 
    0.19342507f, -0.07755116f, 0.07711166f, 0.03837697f, -0.08334120f, -0.21645090f, -0.06522305f, -0.02405589f, 
    0.06945824f, 0.18773176f, 0.09656604f, 0.05369552f, 0.15289868f, -0.15130067f, 0.11458543f, 0.04156545f, 
    -0.08207298f, -0.06284363f, -0.08517740f, -0.11771040f, 0.16445546f, 0.22627294f, -0.47809720f, -0.13500209f, 
    -0.02495948f, -0.18088506f, -0.21243387f, 0.10952228f, 0.08904763f, -0.00558734f, 0.11917893f, -0.00528564f, 
    0.11785129f, -0.12060954f, 0.07379118f, 0.00725350f, -0.06524292f, -0.02154971f, 0.01200544f, 0.58695465f, 
    -0.00855944f, 0.07169838f, -0.13828109f, -0.12236130f, -0.14807568f, -0.19094960f, 0.11039522f, 0.10905404f, 
    0.31539899f, 0.13873595f, -0.07658651f, 0.02940739f, 0.17017019f, 0.07324887f, -0.07904087f, 0.20205584f, 
    -0.08563249f, -0.14027952f, -0.03992463f, 0.11802614f, -0.03273460f, 0.01633708f, -0.00524254f, 0.08080421f, 
    0.02177088f, 0.38619083f, -0.19591258f, -0.08752587f, -0.41048083f, 0.09647793f, -0.09032546f, 0.05253814f, 
    0.07560267f, -0.01580384f, 0.11663262f, -0.43027857f, -0.12379675f, -0.09928881f, -0.01900136f, 0.03284086f, 
    0.02293857f, -0.16311316f, -0.16657083f, 0.05520281f, -0.08423799f, -0.32920995f, 0.03583621f, 0.05776505f, 
    -0.18023020f, 0.02958479f, 0.07363728f, -0.02763061f, -0.11268152f, -0.20998710f, -0.24738406f, -0.01346611f, 
    -0.01570508f, 0.08697568f, 0.03964094f, 0.13908012f, 0.11349655f, -0.04760514f, -0.24381721f, -0.04335081f, 
    0.01440910f, -0.14146253f, 0.03330101f, -0.16693318f, 0.01354803f, -0.08146100f, 0.14934272f, -0.16443375f, 
    0.01617784f, 0.08718763f, 0.02647816f, 0.07588897f, 0.07089569f, 0.04563976f, 0.14033072f, 0.02612482f, 
    -0.39803305f, -0.32233712f, -0.17417462f, 0.10990974f, -0.00657532f, -0.18048604f, 0.14739916f, -0.04867696f, 
    -0.01856906f, 0.16070488f, -0.21827593f, -0.32706106f, -0.44730303f, 0.05702899f, -0.12080099f, 0.11292211f, 
    0.02805656f, 0.14489134f, 0.28634810f, 0.08780126f, 0.14938807f, -0.11349578f, 0.04001215f, -0.06321493f, 
    -0.02442713f, -0.02063864f, 0.01247232f, 0.26716852f, -0.19005176f, 0.22100611f, -0.21482711f, -0.28654507f, 
    -0.03161380f, 0.05029531f, 0.03930055f, 0.14798328f, 0.61473429f, 0.10086221f, 0.20470338f, -0.00354697f, 
    0.06070050f, 0.08090935f, -0.09435082f, 0.11143477f, 0.03811966f, 0.12412294f, -0.23452269f, -0.03391254f, 
    -0.09538302f, -0.05920285f, 0.00991038f, -0.03769646f, -0.14033821f, 0.03642989f, 0.03916698f, -0.17064913f, 
    -0.05431669f, -0.18467979f, -0.10291880f, -0.10861835f, -0.09529708f, -0.05731265f, 0.11800116f, 0.60845464f, 
    -0.10669243f, 0.19752389f, 0.02622908f, 0.18344991f, -0.01717237f, 0.03042814f, 0.19982412f, -0.02662092f, 
    0.06756081f, 0.03340212f, 0.23579457f, -0.01748344f, 0.09902493f, 0.05172966f, 0.13756266f, 0.08857770f, 
    0.05848169f, -0.30135465f, -0.12324240f, 0.01735503f, 0.05533094f, -0.06433284f, -0.08318355f, 0.14525020f, 
    -0.12143431f, 0.05472105f, -0.21440530f, -0.25165617f, -0.24394369f, -0.03773386f, -0.06311031f, -0.00157830f, 
    0.10929330f, 0.02745901f, 0.00898549f, -0.42330268f, 0.15329219f, -0.27956825f, 0.09685268f, 0.08049407f, 
    0.03534531f, 0.24489865f, 0.24798153f, -0.00887888f, -0.45535332f, -0.79909158f, -0.36134103f, 0.03301693f, 
    -0.15019798f, 0.40443093f, -0.11342146f, 0.03692613f, -0.12450721f, 0.03281734f, 0.02997265f, 0.04786991f, 
    -0.15827858f, 0.02581957f, 0.12925023f, 0.00093999f, 0.10387176f, 0.21581893f, -0.03416939f, -0.28650045f, 
    0.20291227f, -0.14001942f, -0.10834108f, -0.19742334f, 0.01361636f, 0.13473305f, -0.15562651f, 0.16261742f, 
    0.20023195f, -0.01269910f, 0.02577729f, -0.10744280f, 0.25621912f, -0.12500890f, 0.03010987f, -0.10610200f, 
    0.01730986f, -0.16732213f, -0.06630071f, 0.00521576f, -0.19465029f, 0.18234694f, -0.15272090f, 0.09538130f, 
    -0.26038578f, 0.21533886f, -0.04290013f, -0.13541421f, 0.06844433f, 0.06719879f, -0.11245669f, 0.01191531f, 
    -0.02401919f, 0.02056098f, 0.44347632f, -0.28834325f, -0.30855975f, -0.08829876f, 0.00665103f, 0.29119352f, 
    0.11201509f, 0.08200590f, -0.13793333f, 0.34055254f, 0.21697167f, 0.25099212f, 0.05759026f, 0.06354626f, 
    0.03229958f, 0.11748162f, -0.11263753f, -0.10288185f, 0.42316681f, 0.04540780f, 0.06477477f, -0.11440901f, 
    0.09647024f, -0.07950836f, 0.17970264f, 0.06891949f, -0.10166159f, -0.21662965f, 0.12303291f, -0.29101253f, 
    0.01671051f, -0.20925206f, -0.07482006f, -0.01136127f, 0.03131732f, 0.02287072f, 0.22729535f, -0.22630878f, 
    -0.29625046f, 0.06686772f, -0.02253108f, -0.02521602f, -0.05780186f, -0.03088685f, -0.00433120f, -0.11868157f, 
    -0.25822142f, -0.08131453f, -0.10281859f, -0.03955030f, -0.30725396f, 0.05623300f, 0.08736987f, 0.07072397f, 
    -0.08807237f, -0.06649122f, -0.27293721f, -0.05718771f, -0.17866281f, 0.11455740f, -0.14921780f, 0.07567006f, 
    -0.11272880f, -0.16108768f, 0.04510155f, -0.15048774f, 0.03393447f, 0.04999614f, -0.26200047f, -0.03654580f, 
    0.00926608f, -0.24226557f, -0.09206364f, 0.11753011f, 0.13661227f, -0.17324297f, -0.03234515f, -0.08609954f, 
    -0.02335550f, 0.03645893f, 0.03831587f, 0.34529370f, -0.25047550f, -0.42310345f, -0.05888599f, -0.15394516f, 
    0.15546124f, 0.02433022f, 0.05291723f, 0.17209996f, -0.09235615f, 0.25849473f, 0.03927765f, -0.04336751f, 
    -0.04321958f, 0.04592418f, -0.06085075f, -0.00037036f, -0.02492727f, 0.06651622f, 0.16190583f, 0.35754851f, 
    -0.08380658f, 0.11540370f, -0.05140740f, -0.13219766f, 0.13556324f, 0.08354403f, -0.10741737f, 0.09005001f, 
    -0.16904624f, -0.06214636f, -0.01525008f, -0.02796659f, 0.13362817f, -0.04037796f, -0.09442680f, 0.01374201f, 
    -0.23726068f, -0.20464621f, 0.07372153f, -0.06295060f, 0.05669807f, -0.00957470f, -0.04671900f, -0.26988009f, 
    0.13027950f, 0.32161435f, 0.11567832f, -0.08545250f, 0.09725627f, -0.22289705f, -0.06808396f, -0.11010797f, 
    0.02538824f, 0.60412413f, 0.19949049f, 0.24180061f, 0.03719913f, 0.09056304f, 0.26313940f, 0.01214023f, 
    -0.02531036f, -0.05009470f, 0.05856372f, -0.20907152f, -0.26206142f, 0.21760876f, -0.00295651f, -0.02293143f, 
    0.00401544f, 0.09718188f, -0.11556042f, 0.21722329f, 0.27364212f, 0.19884479f, -0.08489624f, 0.07534873f, 
    0.07779800f, 0.01643450f, 0.02789642f, -0.05837646f, -0.03639947f, -0.07319809f, -0.19465336f, -0.15219288f, 
    -0.14920077f, -0.22443326f, 0.06595780f, 0.02795298f, 0.08888135f, -0.05102618f, 0.16451381f, 0.17641971f, 
    0.08726144f, -0.05596078f, -0.03801966f, 0.11384702f, -0.07696602f, -0.11555528f, 0.14715341f, 0.00036384f, 
    0.21528275f, 0.12783612f, -0.13104104f, -0.08172873f, 0.08121199f, -0.08644334f, 0.02122990f, -0.24454837f, 
    -0.26836088f, 0.13353258f, -0.16563709f, -0.14697734f, -0.08956183f, -0.00304070f, 0.02572024f, -0.00807501f, 
    -0.49269798f, -0.20755112f, 0.21223384f, -0.01458977f, 0.01903767f, -0.07400678f, 0.14064458f, 0.08919947f, 
    -0.09889075f, 0.06441072f, 0.31582296f, 0.13360371f, -0.03385081f, 0.07972027f, -0.18503967f, -0.07949667f, 
    -0.11708296f, -0.00041384f, 0.20682847f, 0.27026072f, 0.11729965f, -0.07885449f, -0.01657424f, 0.02213330f, 
    -0.01867644f, -0.13664377f, 0.04349430f, -0.30128890f, 0.19241971f, -0.03424594f, -0.04925851f, 0.00552099f, 
    0.00418016f, 0.09738619f, 0.02100569f, 0.09579481f, 0.35760430f, 0.47877187f, 0.03508511f, -0.00706901f, 
    0.00809544f, 0.12528487f, 0.12848096f, 0.08937921f, -0.09460577f, 0.15133323f, 0.18225735f, -0.03387173f, 
    -0.08804315f, 0.09476292f, 0.12792818f, -0.05019677f, 0.04685562f, 0.01524477f, 0.04799312f, -0.09130630f, 
    0.12131560f, 0.12897803f, -0.14827394f, -0.05653207f, 0.03559143f, -0.00461723f, -0.02162115f, -0.01557690f, 
    -0.18253131f, 0.12694515f, 0.05782856f, 0.30440828f, 0.14285704f, -0.13031048f, -0.08807283f, -0.17363770f, 
    -0.31660447f, -0.15027745f, -0.34667465f, -0.03121834f, -0.12735505f, 0.05552143f, -0.06244868f, -0.02067988f, 
    -0.19717991f, 0.09592346f, 0.18088312f, 0.01587024f, 0.00239772f, 0.02714520f, 0.07945684f, 0.04282594f, 
    0.06646241f, 0.07132164f, -0.18791823f, 0.15493846f, 0.21103352f, -0.11001924f, 0.08251471f, -0.09587393f, 
    0.05484121f, -0.08423506f, 0.07291791f, -0.18634053f, 0.02156257f, 0.13593003f, -0.02849977f, 0.00022427f, 
    -0.02182091f, -0.12510462f, -0.05667083f, 0.08192147f, -0.11973246f, 0.27924085f, -0.04198307f, 0.18326057f, 
    0.05563388f, 0.07745791f, -0.11737669f, 0.02689785f, 0.24810621f, 0.44353482f, -0.18503839f, 0.13895723f, 
    -0.09727761f, -0.13276558f, 0.02557516f, -0.01902186f, 0.00591441f, -0.02964055f, 0.16765191f, 0.08499917f, 
    0.07724921f, -0.06306361f, 0.04859257f, 0.05192230f, -0.00101524f, 0.13292693f, 0.10058062f, 0.37059078f, 
    -0.32111844f, -0.03437457f, -0.31549770f, -0.11015301f, -0.08074287f, -0.05252992f, -0.00364839f, 0.16831318f, 
    0.22320671f, 0.13314040f, -0.21520987f, 0.07433281f, -0.05017840f, 0.05504912f, -0.11582990f, 0.19846042f, 
    -0.02709594f, -0.03557861f, 0.03691305f, -0.02103489f, -0.12727678f, -0.06388744f, -0.18572910f, 0.05506388f, 
    -0.00473178f, 0.10225256f, 0.01199120f, 0.07560756f, 0.02965973f, 0.02748520f, 0.06102670f, -0.02813726f, 
    0.02145777f, 0.00371486f, 0.10780357f, -0.22998643f, -0.08206349f, 0.12923974f, 0.10009467f, 0.10757601f, 
    -0.06389160f, 0.03747256f, 0.05046159f, 0.17855962f, 0.03231329f, -0.50842851f, -0.17381437f, -0.38264334f, 
    -0.10547094f, -0.27706522f, 0.03148934f, 0.06552445f, -0.08442320f, 0.00705681f, -0.45098796f, -0.19132619f, 
    -0.13477431f, -0.05023673f, 0.04550774f, 0.13109374f, -0.03191930f, 0.00806167f, 0.00437648f, -0.00232188f, 
    -0.11742415f, -0.05208451f, -0.09733013f, -0.05595032f, 0.06770056f, -0.09729205f, 0.23443371f, -0.00496818f, 
    0.05226332f, 0.03327831f, 0.09123295f, 0.10720255f, 0.07458851f, 0.06866281f, 0.02354584f, -0.03192443f, 
    -0.23254423f, -0.13275404f, -0.10758442f, -0.02317714f, -0.11019909f, -0.18881077f, 0.27454114f, -0.09635495f, 
    -0.09690128f, -0.26569578f, -0.09627735f, -0.02366047f, -0.15780325f, -0.03389263f, -0.21848190f, -0.24936451f, 
    0.02049741f, 0.02767277f, 0.08402286f, 0.13548160f, 0.13533221f, -0.18600261f, -0.02300358f, -0.08758759f, 
    0.02082495f, 0.07976417f, -0.02415269f, -0.02453550f, 0.01533860f, 0.19181085f, -0.07286821f, -0.03321397f, 
    -0.16419549f, -0.10773055f, 0.08424612f, 0.01122811f, 0.33834693f, -0.18971506f, 0.07993735f, -0.17554653f, 
    0.00365839f, -0.12792753f, 0.04114908f, 0.09650452f, 0.08865920f, 0.25254697f, -0.10688278f, -0.09426931f, 
    -0.11324550f, -0.09439949f, -0.06391766f, -0.07678197f, -0.02231407f, -0.12012536f, 0.10423653f, -0.07609946f, 
    -0.30356324f, -0.18355842f, -0.22758782f, -0.20621963f, -0.16509080f, 0.10487372f, 0.01258095f, 0.53010023f, 
    -0.01715372f, 0.06956731f, -0.02288021f, 0.09419879f, -0.00119109f, -0.00651943f, 0.15663254f, 0.12191121f, 
    0.46295676f, 0.08249591f, -0.04653253f, -0.09254835f, 0.10337149f, 0.12153726f, 0.03661107f, 0.09805708f, 
    0.14219412f, -0.13232519f, 0.00859756f, -0.13638945f, -0.18351528f, -0.04203706f, -0.17837362f, 0.20800765f, 
    -0.04608924f, -0.21315694f, -0.04276467f, -0.03454666f, 0.16980816f, -0.00719866f, -0.04619671f, -0.25778699f, 
    -0.03699332f, 0.05910658f, 0.00839284f, 0.10354703f, 0.20402887f, 0.04073981f, -0.01836935f, 0.00166409f, 
    0.14005485f, 0.19027978f, -0.02115743f, -0.00779694f, 0.06667882f, -0.66933632f, -0.08974233f, -0.32525045f, 
    -0.04377455f, -0.10043665f, -0.06575207f, 0.03854324f, -0.08959924f, -0.10713599f, 0.02512101f, 0.34044829f, 
    0.09438916f, 0.11403143f, -0.07427868f, -0.11374336f, 0.03601407f, 0.01436337f, 0.08210084f, -0.22310047f, 
    0.12143090f, -0.25884759f, -0.16462685f, -0.17881401f, -0.07723211f, 0.06457692f, -0.01504968f, 0.05654054f, 
    0.20454410f, -0.20611487f, 0.06283706f, -0.22167411f, 0.06499231f, -0.20499644f, -0.22755034f, 0.07600564f, 
    0.24361572f, -0.12978472f, -0.45196065f, -0.39119709f, -0.32676139f, -0.35168755f, -0.00888425f, -0.09607390f, 
    0.02492061f, -0.07377633f, 0.09425896f, 0.06447822f, -0.02567823f, -0.12609884f, -0.03412313f, 0.04441370f, 
    -0.01322634f, 0.09057367f, -0.16012032f, 0.18132135f, 0.31613037f, 0.09221593f, -0.00453671f, 0.03440528f, 
    -0.08609730f, 0.04570119f, 0.12221929f, 0.02189799f, -0.07022816f, -0.00871668f, -0.00645020f, 0.06202710f, 
    0.06364458f, -0.08113420f, 0.14578712f, -0.13015421f, -0.03050814f, 0.05748073f, 0.20368120f, 0.01519579f, 
    0.20994775f, -0.00660527f, 0.19923697f, 0.20374461f, 0.09383684f, 0.09499078f, -0.12917572f, 0.24991590f, 
    -0.02627483f, -0.06680145f, -0.09328367f, -0.00223511f, -0.07909899f, -0.09630879f, -0.02299594f, 0.20877866f, 
    0.00429142f, 0.01604835f, -0.19517995f, -0.04286742f, -0.07487455f, 0.00882469f, 0.10862338f, -0.23286188f, 
    -0.33984512f, -0.05449897f, -0.09422056f, 0.18540391f, -0.12417128f, 0.07428966f, -0.13234819f, -0.06569318f, 
    -0.34378779f, 0.33469608f, -0.32246014f, 0.09334278f, -0.15690093f, -0.18555756f, -0.02440808f, 0.10654813f, 
    -0.02374270f, -0.08690753f, 0.10510781f, -0.00766612f, 0.10500740f, 0.02591515f, -0.04895635f, 0.10912749f, 
    0.01619544f, 0.04056614f, 0.01311817f, -0.03994885f, 0.04503025f, 0.06121291f, 0.07920974f, -0.07355855f, 
    -0.13160935f, 0.10919905f, -0.01739854f, -0.10484127f, -0.07626058f, 0.39111385f, 0.08135135f, 0.11444107f, 
    0.15323865f, -0.09467863f, -0.10084995f, 0.01814606f, 0.36566210f, -0.67499399f, -0.17801712f, 0.03016348f, 
    -0.08031603f, -0.07226170f, 0.06957410f, -0.02579163f, 0.05315052f, 0.28248286f, -0.34334990f, -0.52587163f, 
    -0.05992965f, 0.09209182f, -0.03196166f, 0.05229257f, -0.05930614f, 0.00746575f, 0.05996213f, 0.01604819f, 
    -0.01559522f, 0.11807604f, 0.06410507f, -0.04093803f, 0.06564654f, -0.13697702f, 0.07534771f, 0.05980600f, 
    0.02071328f, -0.06915394f, 0.03787734f, -0.06369144f, 0.07984802f, 0.02237249f, -0.10589671f, 0.09653904f, 
    -0.01022777f, -0.16467349f, -0.19263950f, 0.07184299f, -0.05650853f, -0.05119037f, 0.07245518f, 0.07551244f, 
    -0.09187368f, -0.24422073f, 0.02927905f, 0.03258324f, 0.01351783f, 0.01938953f, 0.03670103f, -0.18902016f, 
    0.04871700f, -0.16485991f, -0.09746099f, 0.02552534f, 0.16755500f, -0.00730816f, -0.02113026f, -0.02765543f, 
    -0.14209864f, -0.03999439f, -0.04674714f, 0.03809019f, -0.11882196f, 0.12423413f, 0.06931022f, 0.04078428f, 
    0.01970415f, -0.16288127f, 0.08306880f, -0.07714134f, -0.18169560f, -0.20364362f, 0.35155538f, -0.04044725f, 
    0.15931301f, 0.00019211f, 0.06478491f, -0.10415129f, 0.05916911f, -0.00972827f, -0.07307630f, 0.28316563f, 
    -0.05914810f, 0.05056703f, -0.13153477f, 0.06312995f, 0.10888638f, 0.16230296f, -0.01194838f, -0.18378223f, 
    0.04642275f, -0.07907213f, -0.05834938f, 0.04567583f, 0.10885181f, 0.04282250f, 0.03165864f, 0.11121030f, 
    -0.07669952f, 0.06308494f, -0.21171632f, 0.09300721f, 0.04276231f, 0.05222066f, -0.00613874f, 0.06139869f, 
    0.28772929f, 0.17312832f, -0.19013542f, 0.02571986f, -0.03370807f, 0.02337690f, -0.03946896f, 0.10683689f, 
    0.27132046f, 0.03984388f, -0.12667559f, -0.43992999f, -0.02665514f, -0.02965432f, -0.16543677f, 0.03015448f, 
    0.00333606f, 0.03654183f, 0.15874641f, -0.10505544f, -0.03376125f, 0.17048265f, 0.01867058f, -0.01295285f, 
    -0.01816637f, 0.05599451f, 0.07013883f, 0.43964148f, 0.18930933f, -0.06310222f, 0.00576991f, -0.02462013f, 
    -0.08006724f, -0.03493629f, 0.12518947f, 0.08589883f, 0.70445842f, -0.37369332f, -0.58577609f, -0.38254541f, 
    -0.22278886f, 0.01931643f, -0.07280608f, 0.02547490f, -0.02397018f, 0.10279480f, -0.25019914f, 0.16496386f, 
    0.17310649f, 0.05985848f, -0.06086250f, -0.14406721f, 0.02504294f, 0.14818941f, -0.15515980f, -0.20341370f, 
    -0.06724209f, -0.18743609f, 0.05679224f, -0.14405036f, 0.09383378f, -0.05962577f, 0.09218204f, -0.15154620f, 
    0.16070631f, -0.08864392f, -0.15393296f, -0.16590023f, -0.11026721f, 0.04039573f, 0.02579707f, -0.01988813f, 
    0.15425262f, -0.01893699f, -0.30868423f, -0.03204277f, -0.00955524f, -0.10705033f, -0.15573628f, 0.04071847f, 
    -0.14326240f, 0.04540586f, 0.16301222f, -0.07561409f, 0.16820051f, 0.00928163f, 0.04470138f, 0.12209176f, 
    -0.11242434f, 0.03367584f, -0.12877665f, 0.30462423f, -0.44685468f, -0.00534815f, 0.24371442f, 0.14979362f, 
    -0.06454097f, 0.24152978f, 0.04398330f, -0.24170694f, -0.20600574f, -0.35818893f, 0.08964889f, -0.12531762f, 
    0.15822244f, -0.01943194f, -0.01676344f, -0.04545536f, -0.07278660f, -0.11358237f, -0.37537903f, -0.10969131f, 
    0.22064269f, 0.15962040f, 0.22081706f, 0.27300939f, 0.06904890f, 0.32667816f, 0.43699485f, -0.11209507f, 
    -0.11922467f, 0.36668408f, -0.04454426f, 0.19969164f, 0.11808800f, -0.12871915f, 0.07635283f, 0.11694752f, 
    -0.03043727f, 0.20504300f, 0.05003962f, -0.18190572f, 0.09355740f, -0.06337334f, 0.05427097f, 0.17071907f, 
    -0.10923223f, 0.20933554f, 0.09655032f, 0.02212190f, -0.23470272f, 0.01287247f, 0.08400299f, -0.06387258f, 
    0.24619099f, 0.21735390f, -0.49041301f, -0.16257593f, 0.16800694f, 0.15802787f, 0.17517366f, 0.07693999f, 
    -0.03019639f, -0.01917472f, 0.11374657f, 0.06053911f, 0.08297790f, -0.15473334f, -0.20944095f, -0.17953442f, 
    -0.05476731f, -0.04908415f, -0.14203052f, 0.20484185f, -0.05525700f, -0.03551052f, 0.08093495f, -0.08757582f, 
    0.16832344f, -0.03212855f, -0.13719454f, 0.22469449f, -0.14953947f, 0.02884460f, -0.04860338f, -0.12379027f, 
    0.06030940f, -0.06704695f, -0.03963545f, 0.14604497f, -0.22046512f, -0.35098282f, -0.24425370f, 0.16226181f, 
    -0.03473820f, -0.08475707f, 0.02655319f, -0.04596987f, -0.14935587f, -0.03092049f, -0.34980965f, -0.14636134f, 
    0.00895520f, -0.02741618f, -0.03029741f, -0.02072362f, -0.20878080f, -0.05382030f, 0.08017763f, -0.09259643f, 
    -0.11033980f, -0.06157731f, -0.14180809f, -0.01579978f, -0.02832085f, -0.21810523f, -0.09900696f, 0.16657853f, 
    -0.03106687f, -0.34245223f, -0.04029009f, 0.05008262f, 0.07879521f, -0.08200936f, 0.01558836f, -0.06410784f, 
    0.01266343f, 0.19020697f, -0.04517880f, -0.02030340f, 0.15498562f, 0.07187708f, -0.04105257f, -0.10998956f, 
    -0.02127958f, 0.03513063f, -0.06917058f, -0.04233729f, -0.03322783f, -0.02361863f, 0.19739455f, -0.01634598f, 
    -0.11032864f, -0.08856293f, -0.04329703f, 0.12351845f, 0.04155429f, 0.21634804f, -0.02869428f, -0.11780468f, 
    0.09649693f, -0.07537987f, 0.04403189f, 0.12298977f, 0.20292240f, -0.15487313f, -0.05868553f, 0.02401802f, 
    0.03861685f, 0.01563219f, -0.13109884f, -0.03361691f, 0.25615299f, -0.12757841f, 0.28610119f, 0.01964585f, 
    -0.12810664f, -0.35619983f, 0.04737495f, 0.09685940f, -0.03404330f, -0.00967471f, -0.03494242f, 0.04397374f, 
    -0.13670665f, 0.16101865f, -0.04504343f, 0.20253853f, 0.02182016f, 0.10113208f, -0.06027411f, -0.22914046f, 
    0.16014247f, -0.07816023f, 0.25308931f, -0.11043282f, 0.05580839f, 0.10616792f, 0.25218472f, 0.13734917f, 
    -0.27962205f, 0.18952294f, -0.07675055f, 0.08313404f, -0.44056556f, 0.03325891f, 0.07423411f, -0.02106100f, 
    0.18134369f, 0.07688323f, 0.28425691f, -0.08062518f, 0.16986631f, -0.11801676f, 0.09761798f, 0.17307296f, 
    0.16447383f, -0.05377298f, -0.23619637f, -0.09967296f, -0.04558041f, -0.02340921f, 0.05829072f, -0.07591882f, 
    -0.12424157f, 0.12851930f, -0.29444841f, 0.11183026f, -0.06824292f, -0.01523807f, 0.07409097f, 0.03837891f, 
    -0.05391955f, -0.00429290f, -0.04409726f, -0.13875116f, 0.01886057f, 0.09716638f, 0.07679678f, 0.04797595f, 
    0.11230576f, -0.19763605f, 0.20016049f, 0.10881847f, -0.07655139f, -0.51850486f, 0.20442764f, -0.18996483f, 
    0.20463119f, -0.22184883f, -0.00304345f, -0.04009474f, -0.03479842f, -0.10132552f, 0.23056771f, -0.13952847f, 
    0.13536020f, -0.04926404f, 0.11984037f, -0.03700927f, 0.04107741f, 0.01789208f, 0.14459047f, -0.02246946f, 
    -0.13705710f, -0.00410515f, 0.40060121f, -0.24512476f, -0.07356350f, -0.11109918f, 0.19693945f, -0.14997710f, 
    -0.06409090f, -0.20702614f, 0.06333330f, 0.23773518f, -0.18252574f, 0.16578551f, 0.07669359f, 0.08766230f, 
    -0.03062172f, -0.03441656f, 0.02229085f, -0.05403809f, -0.03423861f, 0.02162671f, -0.06661373f, -0.00950026f, 
    -0.02869223f, -0.02864867f, -0.00438433f, -0.04449398f, -0.01095589f, -0.00842024f, -0.03831938f, -0.06408056f, 
    -0.02895611f, -0.00795472f, -0.02173144f, -0.03295556f, -0.00629557f, 0.00309218f, -0.06424343f, -0.00723895f, 
    -0.00888576f, 0.02852027f, 0.03750077f, -0.02372307f, 0.03400070f, 0.03802934f, 0.04177657f, 0.02814399f, 
    -0.00815969f, 0.00225915f, 0.03023225f, 0.06033559f, 0.03668914f, -0.01235360f, -0.06509987f, -0.06222998f, 
    -0.00956750f, 0.03026666f, 0.01872536f, -0.03664136f, -0.06428086f, 0.04737132f, -0.03496394f, 0.02292846f, 
    -0.00280847f, 0.00889305f, 0.04753687f, -0.05952286f, -0.05288870f, -0.03708402f, 0.02467221f, 0.01133225f, 
    0.00780096f, 0.02181728f, 0.02718664f, -0.03663978f, -0.01184816f, 0.03978469f, 0.03022933f, 0.04078916f, 
    0.02271008f, -0.00793288f, -0.03118105f, -0.03350181f, 0.02886758f, -0.06299011f, -0.04150671f, 0.03946542f, 
    -0.05615647f, -0.03571194f, -0.01688485f, 0.02530651f, -0.02070705f, 0.01720010f, 0.00864931f, -0.03077746f, 
    0.03499698f, -0.05776311f, 0.02263477f, -0.00548911f, 0.04035596f, 0.01002368f, -0.03144961f, 0.04735588f, 
    0.02495109f, -0.00625141f, -0.01907466f, -0.06556144f, 0.01974358f, 0.03622724f, -0.05197634f, 0.01946269f, 
    -0.01340154f, -0.05278701f, 0.00157556f, -0.02110965f, 0.01467274f, 0.04275993f, 0.04583438f, -0.02601240f, 
    -0.02329702f, -0.00354579f, 0.01808532f, -0.00793571f, 0.00726531f, -0.00314870f, 0.05205650f, -0.05888605f, 
    0.01431775f, 0.02546975f, 0.03280902f, -0.05184837f, -0.06113392f, 0.04453736f, -0.05449912f, -0.04563081f, 
    0.00169981f, 0.03577290f, 0.04728631f, 0.02341973f, -0.06491426f, -0.03100185f, -0.04235918f, -0.01150483f, 
    -0.01312054f, 0.03511569f, -0.04548846f, -0.05454943f, -0.05133126f, -0.00562854f, 0.03476678f, -0.03124588f, 
    -0.02222943f, -0.02134334f, -0.03034623f, -0.00097420f, 0.02004779f, 0.00719461f, -0.03517964f, -0.05831556f, 
    -0.04829169f, 0.01401896f, -0.03064588f, -0.01635937f, 0.03875620f, -0.00212974f, -0.02382050f, -0.03979179f, 
    -0.01346987f, -0.03794507f, -0.05075898f, -0.06361235f, -0.05222833f, -0.03121741f, 0.00253106f, 0.01663141f, 
    -0.04481045f, 0.05384665f, -0.00504640f, 0.00141981f, -0.04374424f, 0.05391374f, -0.01475164f, 0.02488905f, 
    -0.02541606f, -0.05667823f, 0.01495921f, 0.00496619f, 0.00704233f, 0.02537784f, -0.00112441f, 0.02013286f, 
    -0.04531115f, 0.02915519f, -0.05298645f, -0.05803700f, 0.00598107f, -0.04151146f, -0.06583848f, -0.00960421f, 
    0.04342465f, -0.02618479f, 0.00644749f, 0.01728818f, -0.03588581f, 0.01409598f, -0.03342687f, -0.01484161f, 
    0.01720247f, -0.04609952f, -0.06199105f, -0.01673103f, 0.02415800f, -0.03243564f, -0.05032882f, -0.01464379f, 
    -0.03247111f, 0.03144849f, -0.05055610f, -0.03942654f, 0.00347623f, 0.03425331f, 0.00464945f, 0.03895364f, 
    0.00631912f, 0.01173498f, -0.02525134f, -0.06487348f, 0.02717875f, -0.02612319f, -0.00724287f, -0.03370272f, 
    -0.00098101f, 0.01631726f, -0.05296547f, -0.00233414f, 0.01421113f, 0.01976761f, 0.04933819f, -0.01488668f, 
    0.01828346f, -0.02235641f, -0.03952697f, -0.00976118f, -0.02403823f, -0.06126985f, 0.00633580f, -0.03051745f, 
    -0.00919321f, 0.03036670f, -0.00994555f, -0.06741983f, -0.05222867f, -0.02903911f, -0.06728508f, -0.01835881f, 
    -0.05312185f, -0.03745233f, -0.00244833f, -0.02683992f, -0.01769122f, 0.03995780f, 0.01241148f, 0.04775818f, 
    -0.06681634f, 0.03615082f, -0.00751519f, -0.06332944f, -0.03062390f, -0.01443952f, -0.01492882f, -0.01375274f, 
    0.02863649f, 0.04515339f, -0.00530317f, -0.00671403f, 0.02874252f, -0.04227706f, -0.04049512f, -0.00557488f, 
    -0.00819100f, -0.05646404f, 0.04327348f, 0.01588100f, 0.03096566f, -0.05479631f, -0.03399371f, -0.06188072f, 
    0.04979586f, -0.05449372f, -0.05258085f, -0.05670207f, -0.05124181f, -0.01351702f, -0.01736216f, 0.01690935f, 
    -0.05703859f, -0.04559088f, 0.03791284f, 0.02141298f, -0.01417799f, 0.04963954f, 0.03859711f, -0.01138035f, 
    0.22452803f, 0.31398663f, 0.22667457f, 0.30762503f, -0.24644189f, 0.11056785f, 0.17186345f, 0.04390557f, 
    -0.21125117f, 0.01953746f, 0.06665748f, 0.10980477f, 0.06307201f, -0.09329777f, 0.12325625f, 0.00966909f, 
    -0.03446627f, -0.27745384f, 0.14982550f, -0.20664552f, 0.32977539f, -0.05475483f, 0.03031139f, 0.21533932f, 
    0.18610160f, 0.12936255f, 0.08933867f, 0.09026618f, -0.21431364f, -0.14978348f, -0.06246945f, 0.00175904f, 
    0.28503785f, -0.00799646f, 0.04963586f, 0.27811536f, -0.09610833f, -0.19304384f, 0.22944631f, -0.03734627f, 
    0.08333444f, 0.12848419f, 0.19725525f, -0.05879233f, 0.18329863f, 0.03919803f, -0.04061498f, 0.26700220f, 
    0.15008840f, 0.03123924f, -0.08969302f, -0.10077339f, 0.09154501f, 0.14874558f, -0.03721938f, 0.07646012f, 
    0.09008745f, 0.05272071f, -0.01082817f, 0.04221893f, 0.01696950f, -0.04733188f, -0.11813173f, 0.00280835f, 
    0.17566764f, 0.01529922f, -0.02483389f, 0.07630309f, 0.02680258f, -0.18415855f, 0.15762575f, -0.00928034f, 
    0.09832853f, 0.09629931f, 0.22005506f, -0.10196024f, 0.00395634f, 0.06290095f, -0.09113197f, -0.03560358f, 
    -0.18807344f, 0.02475196f, 0.30994940f, 0.10185172f, -0.09955300f, -0.04105518f, -0.17574687f, 0.07739375f, 
    0.07345000f, 0.12167790f, -0.21851639f, -0.07784343f, 0.10941883f, 0.00926708f, -0.13665290f, -0.01677999f, 
    -0.01728847f, -0.08148147f, 0.03821241f, 0.08829972f, 0.40832257f, -0.02805433f, 0.02039060f, -0.07960783f, 
    -0.02141989f, 0.01687038f, 0.12608746f, 0.06085654f, -0.02790194f, 0.16390614f, -0.04949687f, 0.02416691f, 
    0.08720980f, -0.02068450f, -0.04541673f, -0.24176665f, -0.31233677f, 0.05362001f, 0.09034320f, -0.16890614f, 
    0.02584264f, -0.02081832f, -0.03799571f, -0.17278455f, -0.18033986f, -0.28069988f, -0.09254962f, 0.26293355f, 
    0.09333342f, 0.06682710f, 0.00509671f, 0.00432473f, -0.00628586f, -0.05624522f, 0.03536136f, 0.19847926f, 
    -0.00471709f, 0.05949483f, -0.00372452f, -0.03699343f, -0.09885665f, -0.08398473f, -0.13243367f, -0.47248766f, 
    -0.14485449f, -0.03710086f, -0.03566416f, 0.13351171f, 0.10813650f, -0.03852571f, -0.15208684f, -0.00994748f, 
    -0.16858386f, 0.07271293f, 0.00032930f, -0.32253206f, 0.15951699f, 0.09849325f, 0.35604858f, 0.13752975f, 
    -0.04978254f, 0.10852005f, 0.08471109f, 0.09485743f, 0.01561639f, 0.04128269f, 0.00033920f, 0.04606697f, 
    0.00611079f, 0.01101683f, -0.11696826f, 0.05811298f, -0.26722187f, 0.02723002f, 0.19247554f, 0.10509720f, 
    0.01316417f, -0.02093904f, -0.18081623f, 0.17893472f, 0.04721785f, 0.12007638f, 0.01757745f, 0.11795183f, 
    0.08298111f, -0.06705161f, -0.14421143f, 0.00882012f, 0.06079524f, 0.05988320f, -0.03651949f, 0.15539160f, 
    0.23955254f, 0.09729440f, -0.03581169f, 0.08562110f, 0.08095766f, 0.16799943f, 0.09456762f, 0.00839425f, 
    0.13754842f, -0.00381420f, 0.01787489f, -0.02212719f, 0.11206363f, 0.21212506f, 0.00664171f, 0.04361648f, 
    0.03696335f, -0.07532047f, -0.01538871f, 0.00720401f, -0.06480716f, -0.08282416f, 0.10864266f, -0.19798020f, 
    -0.11567152f, 0.15510377f, 0.07547289f, -0.17711432f, -0.00741598f, 0.08269021f, -0.14875333f, -0.28782800f, 
    -0.17832643f, 0.08633205f, -0.01097282f, -0.00369660f, 0.13919364f, 0.02688751f, -0.08038612f, -0.10203664f, 
    -0.01712480f, -0.14284346f, -0.16941361f, -0.16554324f, -0.13883673f, 0.09254693f, -0.01338620f, 0.09790293f, 
    -0.01812635f, -0.11292142f, 0.15534268f, -0.03134766f, 0.04210015f, 0.05184851f, -0.19531856f, -0.11207912f, 
    0.12202758f, 0.05091710f, 0.02384272f, 0.05917716f, -0.21062969f, 0.54247683f, 0.14585517f, -0.23773000f, 
    0.10945156f, 0.10904785f, -0.15937607f, -0.09851051f, -0.04857512f, -0.05261807f, -0.14678892f, -0.29115105f, 
    0.05131905f, -0.09097619f, -0.05170217f, -0.08006527f, -0.05526766f, -0.00026221f, 0.14319652f, -0.18145753f, 
    0.50807428f, 0.08514187f, -0.06439538f, 0.10866243f, 0.13788074f, 0.01558847f, 0.02149760f, -0.23972313f, 
    0.18706475f, 0.55450171f, 0.11497387f, -0.16843873f, 0.08993626f, 0.13404183f, -0.10863532f, 0.05366150f, 
    0.02573379f, -0.24008463f, -0.46544886f, -0.08226269f, 0.14707300f, 0.12287220f, -0.02769776f, 0.04901709f, 
    -0.26151016f, 0.13545157f, 0.34326011f, 0.01115768f, -0.00224781f, -0.06579117f, 0.02576052f, 0.03322031f, 
    0.05857445f, -0.04636458f, -1.17381501f, 0.23155926f, -0.15778713f, 0.04263498f, 0.26848516f, 0.05889932f, 
    0.01936608f, -0.02789186f, 0.06291161f, 0.12524988f, -0.15980253f, -0.22484112f, -0.09621893f, -0.03790273f, 
    0.12442845f, 0.04560821f, -0.15431099f, 0.13798825f, -0.47355017f, -0.01219415f, 0.17215636f, -0.08165210f, 
    0.24461959f, -0.03156102f, -0.02257596f, 0.04329754f, 0.15784542f, -0.37968573f, 0.16195153f, -0.00815345f, 
    0.00829531f, 0.28633809f, -0.07118724f, 0.09193328f, 0.08155462f, 0.06352690f, 0.21885361f, 0.32971382f, 
    0.01046892f, -0.01235842f, 0.02379021f, -0.09878621f, -0.05890684f, 0.03280070f, 0.07201806f, 0.23910990f, 
    0.14185469f, 0.16325738f, -0.17441118f, -0.05680577f, -0.13620301f, -0.04936654f, 0.13518120f, 0.02781556f, 
    -0.05010260f, 0.11565747f, 0.14871322f, 0.03097679f, 0.12833630f, 0.03588570f, -0.06081838f, -0.03028506f, 
    -0.14508425f, 0.00166838f, 0.07258985f, -0.14577249f, -0.06353567f, -0.13117804f, 0.00504092f, -0.15443771f, 
    0.16922002f, 0.27968520f, -0.43773594f, 0.06526780f, 0.10965572f, -0.11282221f, 0.06406908f, -0.07773958f, 
    0.07552493f, -0.00088714f, 0.17445141f, -0.14989272f, -0.53197557f, -0.43451002f, 0.04754258f, 0.01044171f, 
    0.14798748f, -0.01998686f, -0.04882878f, -0.01511661f, -0.28960648f, -0.19230117f, -0.19442521f, -0.15651049f, 
    0.01122327f, -0.25482452f, 0.21698460f, -0.04825033f, -0.10240553f, -0.23244059f, -0.40006876f, -0.08246434f, 
    -0.06829090f, 0.11280884f, -0.05608916f, 0.03105137f, 0.11958259f, -0.12434585f, 0.02204404f, -0.08831134f, 
    -0.36550534f, -0.07518993f, -0.12227973f, -0.11313666f, 0.09684760f, -0.05272867f, 0.01928475f, -0.04703493f, 
    -0.12836443f, -0.23109812f, 0.07445396f, 0.10358198f, 0.05413140f, 0.12905750f, 0.00500967f, -0.12106441f, 
    -0.51046973f, 0.29535389f, 0.15875444f, 0.03307332f, -0.05677202f, -0.08027275f, 0.12121176f, 0.17427123f, 
    0.10505206f, 0.22943805f, -0.47257993f, -0.46091771f, -0.06050878f, 0.18662873f, 0.20242713f, -0.03758223f, 
    -0.18484440f, 0.13718291f, 0.24310781f, 0.27168244f, -0.06861469f, -0.05542735f, -0.03010062f, -0.03015731f, 
    0.08095128f, 0.04111218f, 0.06788588f, 0.06722953f, -0.28495312f, -0.22566357f, -0.21757978f, 0.02126170f, 
    -0.01434102f, 0.03454341f, -0.04461220f, -0.00586635f, 0.39110535f, 0.20717515f, 0.26321116f, -0.08517814f, 
    -0.16231702f, -0.09615599f, 0.00653680f, 0.06938460f, 0.03578329f, -0.10896669f, 0.09992986f, 0.00485877f, 
    -0.15298568f, 0.07474782f, -0.12936014f, -0.01119991f, -0.02810180f, 0.12970020f, 0.13163202f, 0.07623681f, 
    0.16695413f, -0.14798824f, 0.02912547f, -0.09461505f, -0.14002711f, 0.03302327f, 0.14802712f, 0.52113128f, 
    0.09387258f, 0.26436046f, 0.04840925f, 0.02116613f, 0.06291851f, 0.01437519f, 0.02161225f, 0.05163708f, 
    0.43839628f, 0.13537994f, 0.05547394f, 0.11239125f, 0.14290315f, 0.18279241f, 0.18407977f, 0.22130665f, 
    0.11158080f, -0.27961978f, -0.33301520f, 0.04002319f, -0.03444424f, -0.06813341f, -0.15084346f, 0.06233752f, 
    0.18491405f, -0.02594435f, -0.03787342f, -0.04425216f, -0.00313720f, -0.00705106f, -0.05257754f, -0.05825667f, 
    -0.05849588f, -0.02822535f, 0.08307616f, 0.07593207f, -0.09775324f, -0.09488395f, -0.11107761f, 0.08479960f, 
    0.05035563f, -0.01772141f, 0.00344062f, 0.17287357f, -0.35291493f, -0.45903093f, -0.30883107f, -0.05867723f, 
    0.12711202f, -0.11443126f, 0.24839526f, 0.08065355f, -0.15954812f, -0.27685192f, -0.42338118f, -0.26179850f, 
    0.01253156f, 0.13228181f, 0.06582741f, -0.19441678f, 0.03358263f, 0.06534462f, 0.21196239f, -0.07974476f, 
    0.02546749f, 0.06009846f, 0.07284604f, 0.07884308f, -0.13075939f, 0.04275112f, 0.04120195f, -0.17236722f, 
    -0.06659473f, -0.26245028f, -0.02362001f, 0.03564762f, -0.11230112f, -0.01921138f, 0.11886390f, -0.07535805f, 
    -0.17117368f, 0.17146307f, -0.04815678f, -0.08203383f, -0.00086588f, 0.07853422f, -0.10596145f, -0.03327947f, 
    -0.01795857f, -0.25362670f, -0.19810125f, -0.11567928f, 0.05194612f, 0.01688715f, -0.12903406f, 0.06810571f, 
    -0.08471517f, 0.17969598f, -0.33441058f, 0.31589317f, 0.23130356f, -0.17169331f, 0.10101873f, -0.05303054f, 
    -0.03912790f, 0.15259962f, 0.01179852f, -0.01933290f, 0.00341322f, 0.29331186f, 0.03166505f, -0.06303881f, 
    -0.10125153f, -0.01744238f, 0.07760817f, 0.11311790f, 0.06965487f, 0.06292853f, -0.10229892f, -0.13426997f, 
    0.05133536f, 0.05488522f, -0.11520941f, 0.01938167f, 0.05307487f, 0.48596352f, 0.27876922f, 0.30894479f, 
    -0.09386684f, 0.21366803f, 0.03662530f, 0.09180455f, -0.10198953f, -0.08774537f, -0.16015683f, -0.19662035f, 
    -0.21378167f, -0.08584548f, 0.01982282f, 0.02855103f, -0.04741672f, 0.08767661f, 0.20321685f, 0.06723320f, 
    -0.18547817f, -0.31964052f, -0.06505728f, -0.11610819f, 0.11643844f, -0.10100030f, 0.04359261f, 0.06554645f, 
    -0.04196306f, 0.02617212f, -0.10214617f, -0.02263003f, 0.00450755f, 0.21364827f, 0.12432597f, -0.04355816f, 
    -0.21805157f, -0.11013857f, -0.14624391f, 0.33263594f, 0.07005471f, 0.05043576f, 0.03049184f, 0.03640037f, 
    -0.03715843f, -0.02169363f, 0.22004247f, 0.22266981f, 0.34800324f, 0.11023527f, 0.07672825f, 0.04081389f, 
    -0.02162383f, -0.11460611f, -0.01910248f, -0.73567992f, -0.16835703f, -0.06897688f, 0.28240731f, 0.00536053f, 
    0.02202470f, -0.04825399f, 0.10002136f, 0.19603197f, 0.25391433f, -0.39701539f, 0.06807452f, 0.08105165f, 
    0.06250396f, 0.13432200f, -0.09340080f, -0.03477193f, -0.24027602f, 0.13680592f, -0.19021754f, 0.13975678f, 
    0.04207925f, 0.05631045f, 0.05993709f, -0.07918130f, -0.34390056f, -0.16460000f, -0.12081695f, 0.02747332f, 
    -0.05164355f, 0.13555558f, 0.01531649f, -0.07489149f, -0.11579677f, -0.16265313f, -0.06454384f, -0.10010037f, 
    0.22720991f, -0.01196946f, -0.03715980f, 0.00188545f, 0.15757558f, -0.16669752f, -0.03000467f, -0.32405135f, 
    0.16098180f, 0.00753458f, 0.08602247f, -0.06704973f, 0.24942002f, -0.05501986f, -0.13580513f, -0.13266887f, 
    -0.11045814f, -0.25842097f, -0.09690725f, 0.23925017f, 0.19304118f, -0.14419435f, -0.04365616f, 0.06783704f, 
    0.01635745f, -0.03371950f, -0.18111579f, -0.17653975f, 0.10045075f, -0.04520993f, 0.13395496f, 0.00029304f, 
    0.04948141f, -0.14685369f, 0.08860625f, 0.13520491f, 0.08689223f, 0.08830802f, 0.12370069f, 0.02090337f, 
    0.00423689f, 0.03847016f, 0.03585117f, -0.06654488f, -0.30724961f, -0.30126214f, -0.07728502f, 0.03873617f, 
    -0.00340436f, 0.07987576f, -0.11775833f, 0.05682978f, 0.04644899f, 0.36124465f, -0.02952852f, 0.17985550f, 
    0.02048438f, 0.03160618f, 0.02810355f, 0.13554971f, -0.06665692f, 0.09276928f, 0.18902743f, -0.17976275f, 
    -0.29603305f, 0.12694882f, 0.02535413f, 0.05239554f, 0.05651215f, 0.06433828f, 0.24975361f, -0.03014331f, 
    -0.22898282f, -0.33551702f, 0.06914611f, -0.15473516f, -0.18174970f, -0.09000011f, 0.14090402f, 0.06488378f, 
    0.08268771f, -0.09214747f, -0.16542484f, 0.08227971f, -0.02397537f, -0.06819632f, -0.07528517f, 0.16331077f, 
    -0.05451484f, 0.23390947f, -0.03354485f, 0.06823126f, 0.09974658f, 0.11314791f, 0.21662249f, -0.10800380f, 
    -0.22484237f, -0.30382821f, 0.13445464f, -0.12255336f, 0.23138201f, 0.24805984f, 0.08439271f, 0.05164839f, 
    0.06033468f, 0.01632735f, 0.00114029f, 0.20242064f, 0.22164723f, 0.24491872f, -0.09935039f, 0.11597496f, 
    0.00515374f, -0.02163067f, -0.15243082f, 0.01935068f, 0.31171706f, -0.30983284f, 0.09925912f, 0.18121061f, 
    -0.07710831f, -0.11626233f, -0.08334613f, 0.01776414f, -0.11473865f, -0.08926404f, -0.08765386f, 0.24244443f, 
    0.14689317f, -0.08832588f, 0.06038133f, 0.25104502f, 0.05189885f, 0.05183235f, 0.50536078f, 0.01896920f, 
    -0.23117447f, -0.12787680f, 0.12748182f, 0.10718074f, 0.14792556f, 0.22618598f, -0.06896329f, 0.11431376f, 
    0.20817275f, -0.20989154f, 0.28997800f, -0.16859542f, 0.05805150f, 0.04780192f, 0.14133699f, 0.20939897f, 
    -0.08849259f, 0.22068110f, -0.31375980f, -0.09943859f, -0.18488625f, -0.09107280f, 0.10815408f, -0.07722723f, 
    -0.13145432f, 0.04122690f, 0.04918656f, -0.00859206f, 0.12652199f, 0.03375011f, -0.05838199f, 0.06922149f, 
    -0.22108807f, 0.04818303f, -0.37850896f, -0.32089299f, 0.07853781f, -0.00286818f, 0.11229798f, 0.15379754f, 
    0.07564405f, 0.16736540f, 0.13620539f, -0.42549157f, -0.01877406f, 0.21194357f, -0.00949761f, 0.03557166f, 
    0.13412127f, -0.04397569f, 0.08702021f, 0.20061038f, -0.37689403f, -0.13323282f, -0.16771126f, 0.07322016f, 
    0.14610405f, 0.02698147f, 0.05546351f, -0.01341828f, 0.16424599f, 0.58262616f, 0.25408623f, -0.21080425f, 
    0.14332835f, 0.00508884f, 0.09714712f, -0.01075573f, 0.16184874f, -0.01778459f, 0.08866811f, 0.04390168f, 
    -0.12246488f, 0.07797524f, 0.00964569f, 0.03337001f, -0.07397917f, 0.01661050f, 0.17929478f, 0.32594195f, 
    0.14035997f, -0.58819920f, 0.11090871f, -0.30111936f, 0.03854358f, 0.03349228f, 0.10025496f, -0.10173617f, 
    -0.03859665f, -0.14942960f, -0.27038941f, 0.16430594f, -0.17512356f, 0.00498751f, 0.01815299f, -0.07847375f, 
    -0.05111935f, 0.10384658f, 0.24472141f, -0.01595838f, -0.00680366f, -0.04050802f, -0.02484229f, -0.13977171f, 
    -0.06110222f, 0.06109119f, 0.27742827f, 0.11753391f, 0.34092975f, 0.10939038f, 0.03583661f, 0.02266571f, 
    0.06279613f, -0.15415269f, -0.11876260f, -0.52512199f, -0.60827541f, -0.30405876f, -0.14419705f, -0.00539126f, 
    0.03543437f, 0.20775142f, 0.03561705f, 0.07092616f, -0.00030616f, -0.06967273f, -0.09867705f, 0.20898651f, 
    -0.10073072f, -0.03908058f, -0.14142895f, -0.17814380f, -0.07968327f, -0.05262329f, -0.12621799f, -0.14646055f, 
    0.02936860f, -0.27960202f, -0.07944103f, 0.05389829f, -0.22775534f, -0.27030113f, -0.03840145f, -0.13193721f, 
    -0.01873344f, 0.01133773f, 0.05115261f, 0.05670119f, 0.01677182f, 0.05121443f, 0.06677259f, 0.01866610f, 
    0.07828683f, -0.17740101f, -0.09290031f, -0.01071247f, 0.05173681f, -0.14034969f, -0.07475736f, -0.24411713f, 
    0.08466028f, -0.12963738f, 0.38359413f, -0.16929150f, 0.02972781f, -0.08153768f, -0.00080616f, -0.12627184f, 
    -0.05047508f, -0.21851461f, -0.15379055f, 0.17537327f, -0.01472088f, 0.10382397f, 0.26698193f, 0.02819512f, 
    -0.00453809f, -0.04896148f, 0.24031216f, 0.23202164f, -0.07911997f, 0.17117009f, -0.12531045f, 0.03937728f, 
    0.02303320f, -0.16502939f, 0.04668427f, 0.23119614f, 0.02804076f, 0.16284724f, 0.07588476f, 0.11195130f, 
    -0.04177080f, 0.01045712f, 0.04587772f, -0.00814836f, 0.28362629f, 0.19072050f, -0.15189239f, -0.00985469f, 
    -0.13987714f, -0.04598439f, 0.05580159f, 0.01172903f, -0.08893888f, 0.37270382f, 0.30174628f, 0.12111062f, 
    0.20493717f, -0.05741430f, -0.07338358f, 0.00168294f, 0.16681692f, 0.11790949f, -0.00351512f, 0.05119797f, 
    -0.13435258f, 0.13058107f, 0.01179409f, -0.05936286f, 0.09842432f, 0.13715154f, 0.08963000f, 0.21631488f, 
    -0.02058646f, -0.42749193f, -0.06266868f, -0.01772031f, -0.13643728f, 0.10289352f, 0.08809663f, -0.01392867f, 
    -0.08592001f, -0.07498360f, 0.19914319f, -0.08211376f, 0.01375632f, -0.08001376f, -0.04808630f, -0.15111178f, 
    -0.05669740f, 0.06109341f, -0.00221199f, 0.15835465f, 0.01069740f, -0.17563675f, -0.04142704f, -0.00397574f, 
    -0.17203821f, -0.19009963f, 0.09114347f, -0.09165533f, 0.54672426f, 0.00738371f, -0.01371574f, 0.07252278f, 
    0.11056718f, 0.01765802f, 0.09081073f, -0.24143961f, 0.04286914f, 0.00422948f, -0.01985219f, -0.08880522f, 
    0.21897399f, 0.03050067f, 0.13342066f, 0.04968417f, -0.05049903f, -0.88332629f, 0.11558801f, 0.06766261f, 
    -0.15457289f, -0.01672366f, -0.15457144f, 0.03443886f, 0.02241613f, 0.15573916f, 0.05318089f, 0.08299032f, 
    -0.22178149f, 0.00836389f, 0.04612866f, 0.08338819f, -0.08684396f, 0.01149270f, 0.35953662f, 0.08495569f, 
    -0.28212804f, -0.01117876f, 0.08447668f, -0.05322805f, 0.07963783f, -0.06190576f, -0.06628864f, 0.63212597f, 
    -0.27794826f, -0.05315914f, 0.10127158f, -0.13294871f, 0.17821293f, -0.00521746f, -0.04092583f, 0.13609244f, 
    -0.01501573f, -0.05489976f, -0.26934323f, 0.18646386f, -0.08064763f, 0.17248709f, -0.02694977f, 0.26238188f, 
    -0.02416063f, -0.23261340f, -0.02079184f, 0.04906692f, 0.06436504f, 0.03906985f, -0.00455442f, 0.30449805f, 
    0.05704139f, 0.15429477f, 0.19498591f, 0.02138039f, 0.21925962f, -0.00311529f, 0.04591895f, 0.04656602f, 
    -0.07429617f, 0.05267259f, 0.04794861f, -0.30542237f, 0.00864664f, 0.20092474f, -0.20991321f, -0.15222067f, 
    -0.00787745f, 0.03256789f, -0.05723492f, 0.04194527f, 0.02234614f, 0.21407188f, 0.00571810f, 0.00651619f, 
    0.03606908f, 0.06302245f, -0.00600348f, -0.01886915f, -0.14450523f, 0.37726712f, -0.00601017f, 0.16609064f, 
    -0.02904431f, 0.06599460f, 0.22765803f, 0.20957524f, 0.01559489f, -0.01227173f, -0.03475326f, -0.19093625f, 
    0.12625575f, -0.06523193f, -0.01745205f, -0.03485039f, 0.02076965f, 0.00011588f, -0.06756245f, -0.02263610f, 
    -0.11173423f, 0.13706331f, -0.09773335f, -0.14644194f, 0.06685542f, -0.03788751f, 0.32445580f, 0.05044368f, 
    -0.08065721f, -0.25439054f, -0.13882861f, 0.12591636f, 0.12473095f, 0.10290113f, 0.15814719f, 0.20212002f, 
    -0.04365979f, -0.20869142f, -0.05093239f, 0.15077886f, 0.04585557f, -0.23516960f, -0.05878897f, -0.06358209f, 
    -0.15918417f, -0.09500450f, 0.19923124f, -0.04558052f, 0.09754565f, 0.16113642f, -0.05237592f, -0.08509585f, 
    -0.04570057f, 0.18473661f, 0.11723506f, -0.14820841f, 0.07054549f, -0.11941757f, -0.06362223f, -0.01095065f, 
    0.07870569f, 0.00791247f, 0.05977212f, -0.07021797f, 0.47504905f, -0.08954843f, 0.09214244f, 0.02282444f, 
    -0.04675907f, -0.22152796f, 0.01658148f, 0.05527945f, 0.03455407f, 0.24569370f, -0.19932622f, -0.08365129f, 
    0.08276200f, -0.00952807f, -0.18235825f, -0.06558340f, 0.12024889f, 0.31801033f, 0.03729152f, -0.22709243f, 
    -0.11990906f, 0.10511202f, 0.00725571f, -0.18837711f, 0.15122877f, -0.04212872f, 0.00544332f, 0.03489702f, 
    -0.02429411f, -0.03888207f, 0.02370190f, 0.02471801f, -0.00816306f, 0.07974686f, 0.21157894f, 0.05368072f, 
    -0.02583155f, -0.16775455f, -0.17949015f, -0.07297313f, -0.02344564f, -0.11591322f, 0.09644703f, 0.09267993f, 
    0.00712989f, -0.38708326f, -0.02141970f, -0.05497425f, -0.11274365f, -0.15426964f, 0.05279994f, -0.16707972f, 
    -0.08167145f, -0.10995284f, -0.21129578f, 0.05935385f, 0.02605129f, -0.06823577f, -0.22680421f, -0.13168968f, 
    0.09547829f, 0.09889621f, 0.00882592f, 0.07295500f, -0.13822754f, -0.13861457f, -0.00310509f, -0.02526614f, 
    -0.09783175f, 0.00089731f, -0.05323202f, 0.03471649f, -0.45739403f, -0.07679336f, 0.21577784f, -0.07029822f, 
    0.01682475f, -0.03471909f, -0.08971500f, 0.06031871f, 0.09208956f, 0.07429096f, -0.03558590f, -0.02970250f, 
    0.03954064f, -0.01765664f, -0.01605132f, 0.05352342f, -0.14355130f, -0.16756307f, -0.01321101f, -0.27500576f, 
    -0.04841383f, 0.02917968f, -0.15207268f, -0.17134590f, -0.28464919f, -0.21134041f, -0.25998083f, 0.07679018f, 
    -0.01792600f, 0.07177036f, 0.01675618f, 0.12106714f, -0.04729963f, -0.08591274f, 0.22565748f, 0.13215970f, 
    0.14226530f, -0.07001930f, 0.21075569f, 0.07907155f, 0.25049052f, 0.16781795f, -0.12665522f, -0.07166061f, 
    -0.20418206f, -0.02971190f, -0.25693318f, -0.19723560f, -0.03201557f, -0.11121131f, -0.18580948f, 0.09625272f, 
    0.12859163f, 0.08468967f, -0.00032354f, -0.23437996f, 0.02207469f, 0.06534951f, -0.03423099f, -0.18864900f, 
    -0.06489758f, -0.03634996f, 0.11638228f, -0.13136084f, 0.23644537f, 0.09099830f, 0.06193125f, -0.13292532f, 
    0.19331494f, -0.16406956f, -0.08793836f, -0.10256807f, 0.63616872f, -0.37410060f, 0.14576776f, 0.01527887f, 
    -0.12711984f, -0.25524420f, 0.18092322f, 0.05288906f, 0.15484923f, -0.08102610f, 0.01744767f, 0.19336724f, 
    -0.10769781f, 0.07614442f, 0.06063965f, 0.07489351f, 0.00665381f, 0.11356936f, 0.05821955f, -0.13354313f, 
    -0.06896479f, 0.04388393f, 0.04329709f, -0.13462433f, 0.14137690f, -0.00256550f, -0.19254644f, 0.74752277f, 
    0.21353418f, -0.21495914f, 0.06496920f, -0.31260592f, 0.09876507f, 0.22482121f, 0.04262113f, 0.02585341f, 
    -0.29965928f, -0.22863644f, -0.45281571f, -0.00950682f, -0.13043584f, -0.28403592f, -0.05537789f, -0.00239942f, 
    -0.07561096f, -0.20768371f, -0.11096705f, -0.08666892f, 0.04582154f, -0.06516987f, 0.15378875f, 0.19424374f, 
    0.14665121f, 0.13348584f, 0.08763839f, -0.35215476f, -0.07347979f, 0.00331971f, -0.00815113f, -0.02197576f, 
    -0.04446070f, 0.01232510f, 0.10401091f, -0.02808999f, 0.08705164f, 0.13337924f, 0.08642541f, 0.01381008f, 
    0.00411550f, 0.15433039f, -0.09069961f, 0.11270669f, 0.23946193f, -0.19390462f, -0.16793182f, -0.06072661f, 
    -0.04834380f, -0.03917469f, 0.21982718f, -0.09910497f, -0.12344688f, 0.08542275f, -0.04679489f, -0.29585105f, 
    0.12517436f, 0.11802284f, 0.15732273f, 0.22375883f, 0.23952462f, 0.07734121f, -0.15939732f, -0.03783656f, 
    -0.07558098f, -0.04233336f, 0.05572530f, 0.11766450f, 0.08189286f, 0.06511460f, 0.02484716f, 0.02719331f, 
    -0.21946220f, -0.35539418f, 0.00978463f, -0.03915484f, 0.00210015f, -0.05618994f, 0.00710441f, 0.04211891f, 
    -0.15817557f, -0.21824440f, -0.29897588f, -0.03106493f, -0.06604238f, 0.01485034f, 0.16489807f, -0.01010535f, 
    0.00241457f, -0.29378945f, -0.16680001f, -0.09746327f, -0.07371760f, -0.16621320f, 0.08424229f, 0.10656707f, 
    -0.15628920f, -0.25091013f, 0.29076284f, 0.19230705f, 0.18720064f, 0.07350729f, 0.15687969f, 0.04580422f, 
    0.18856095f, -0.04169951f, 0.02757856f, 0.08188496f, -0.17612487f, -0.10550438f, -0.11848457f, -0.05486213f, 
    -0.05708465f, 0.08973592f, -0.04498567f, 0.11368622f, 0.04593237f, -0.14502160f, -0.37959069f, -0.04190719f, 
    0.03938947f, -0.15999834f, -0.33319721f, 0.02262863f, 0.03454714f, -0.03538939f, -0.17967194f, 0.03718945f, 
    0.12718944f, -0.13674085f, -0.11163112f, -0.07425924f, 0.02459522f, 0.03388110f, -0.27587721f, -0.12385152f, 
    -0.15421496f, -0.24301128f, -0.11607169f, -0.47884166f, -0.16218489f, 0.10799576f, 0.11015597f, -0.07237200f, 
    0.11974765f, -0.05275723f, 0.03732834f, -0.01460146f, -0.00970491f, 0.01488152f, 0.17833890f, 0.02989240f, 
    0.06555894f, 0.39021772f, 0.32231617f, -0.16374663f, 0.00368636f, 0.13113336f, 0.20102645f, 0.02072283f, 
    0.03866740f, 0.10304648f, -0.03289770f, 0.11191426f, 0.06056846f, -0.04047321f, 0.08538358f, 0.22870231f, 
    -0.09173457f, 0.08095118f, -0.30168989f, -0.09944206f, -0.10992544f, -0.01684547f, 0.15481135f, 0.00920400f, 
    0.17990680f, -0.06601263f, -0.04137774f, 0.04027724f, -0.06127002f, 0.23799792f, 0.00762619f, -0.03798512f, 
    0.11465552f, 0.17379864f, -0.01061383f, -0.01290261f, 0.15632896f, -0.20803440f, -0.18217710f, -0.00894201f, 
    0.03091609f, 0.08501672f, 0.08766519f, -0.07600222f, 0.03117539f, 0.11549335f, -0.23571737f, -0.02568693f, 
    0.07950105f, 0.04811644f, 0.11275455f, 0.18595091f, 0.03746926f, -0.17347117f, -0.04144723f, -0.24747661f, 
    -0.05431357f, -0.09243691f, -0.10091919f, 0.00751276f, -0.10168908f, -0.01926425f, -0.08888894f, 0.18407862f, 
    -0.15243316f, -0.19853799f, 0.10533926f, 0.04106872f, -0.04677921f, 0.17146453f, 0.19408566f, 0.05307654f, 
    -0.05349483f, -0.11114970f, 0.19380192f, 0.09707101f, 0.06364167f, 0.08696700f, 0.16490531f, 0.11883090f, 
    0.04499593f, -0.13097218f, 0.09473464f, 0.34183094f, 0.08408791f, -0.10327587f, 0.10780819f, 0.09272579f, 
    -0.04942388f, 0.00719826f, -0.06633141f, 0.09002965f, 0.43497333f, -0.02302592f, 0.14265989f, 0.15791768f, 
    0.10455591f, 0.08449639f, 0.04841194f, -0.16076869f, 0.09790451f, 0.00987568f, 0.07172363f, -0.02151269f, 
    0.12482579f, 0.18826792f, -0.16189027f, -0.02415395f, -0.44382805f, -0.34353116f, -0.24958670f, 0.01710148f, 
    0.03993219f, 0.01170079f, 0.04441980f, 0.19555900f, -0.18653671f, 0.13760531f, 0.07071484f, 0.21222760f, 
    0.06274999f, 0.17822237f, 0.15026873f, -0.03566778f, -0.04202414f, 0.14959136f, 0.14584203f, -0.27698529f, 
    -0.27619287f, 0.06519414f, 0.07817843f, -0.16856246f, 0.12179900f, -0.06809606f, -0.14002217f, 0.15945618f, 
    -0.47155884f, -0.39432037f, 0.06298738f, 0.00377337f, -0.16802688f, 0.02110991f, -0.08153563f, -0.27134678f, 
    -0.23765893f, 0.11854306f, 0.13226758f, 0.13241743f, 0.12447820f, 0.00461586f, -0.17799541f, -0.00850538f, 
    0.00182341f, -0.08232355f, 0.11209644f, -0.06715582f, -0.12545414f, -0.05172105f, -0.02411930f, 0.03285526f, 
    0.05335312f, -0.14635873f, 0.31884983f, 0.24062327f, 0.36214697f, -0.07179108f, -0.05844143f, 0.10806683f, 
    -0.05366458f, -0.05981496f, 0.01512974f, -0.16402473f, 0.15440771f, 0.22920336f, -0.02253001f, 0.11206261f, 
    0.02966017f, 0.15128843f, 0.05125614f, -0.07625115f, 0.29058620f, 0.04659877f, 0.31743190f, -0.04474412f, 
    -0.08598451f, 0.10923176f, 0.04857396f, 0.04634549f, -0.06185105f, -0.01762088f, -0.28028423f, -0.07950513f, 
    0.04279384f, 0.12064065f, 0.09282167f, 0.05905746f, 0.14549619f, 0.07856269f, -0.09567167f, 0.07164906f, 
    -0.06012290f, 0.00369809f, -0.00967673f, -0.01222596f, 0.00039692f, 0.02586875f, -0.18365623f, -0.34674647f, 
    0.01777442f, 0.06795657f, -0.13984478f, -0.08750868f, -0.15903391f, -0.05879009f, 0.07060695f, 0.07896984f, 
    -0.04083470f, -0.02416483f, 0.04539355f, -0.04885566f, -0.15050028f, 0.09267926f, 0.01016831f, 0.04538600f, 
    0.13721119f, -0.23770173f, -0.44500786f, -0.09799351f, -0.03285199f, 0.10729925f, -0.09278423f, 0.06414755f, 
    0.06417024f, 0.03373560f, -0.10654168f, -0.09508034f, 0.17386886f, -0.12910661f, -0.06057465f, 0.20681395f, 
    0.08747272f, 0.11425842f, 0.18330412f, -0.04606130f, -0.17475256f, -0.00661892f, -0.00434164f, -0.03187211f, 
    0.08262491f, -0.02406547f, -0.03725173f, -0.14564687f, -0.38115966f, 0.31334496f, -0.08990688f, -0.28223413f, 
    0.21114866f, -0.02397969f, -0.05056455f, 0.05880747f, 0.14976104f, -0.24124196f, 0.13631929f, -0.15561983f, 
    0.04926606f, 0.22671601f, -0.02536159f, -0.06764558f, 0.05548309f, 0.12781273f, -0.27921665f, -0.04101115f, 
    -0.16278370f, -0.08417881f, 0.08239368f, -0.09901457f, -0.00011380f, -0.02837668f, 0.11455954f, -0.16378562f, 
    0.05797701f, 0.13730012f, 0.21295926f, 0.11230043f, 0.08733532f, 0.03739555f, 0.23917933f, 0.03940494f, 
    -0.02161309f, -0.03490993f, -0.01630451f, -0.02051077f, -0.07012154f, -0.10763465f, 0.01527058f, 0.22769821f, 
    0.11051074f, -0.17984806f, -0.24155360f, 0.12452028f, -0.15689768f, -0.11474161f, 0.14248925f, 0.03542074f, 
    0.03680896f, -0.19365664f, -0.18869500f, 0.04482200f, -0.10048237f, -0.19410871f, -0.03517710f, -0.13481116f, 
    -0.04703677f, -0.10545917f, -0.06980894f, -0.24404502f, -0.05410967f, 0.17373970f, -0.15801215f, -0.03057173f, 
    0.07072403f, 0.08164688f, 0.04400514f, 0.11830810f, -0.24957792f, -0.08353692f, -0.03579668f, -0.04005700f, 
    0.03069169f, -0.16307966f, 0.02250020f, 0.05387415f, 0.00462926f, 0.06966868f, -0.35014531f, -0.12953047f, 
    -0.01685133f, 0.04205194f, -0.08834884f, -0.06189491f, -0.00517415f, 0.08159763f, -0.07051475f, -0.30733252f, 
    -0.17575081f, -0.02651821f, 0.02079848f, -0.06580135f, 0.10943790f, -0.08017867f, -0.06007237f, 0.03242178f, 
    0.05488727f, -0.04395769f, 0.10367073f, 0.08797485f, 0.06571274f, -0.00554546f, -0.07558851f, 0.08721233f, 
    -0.04660525f, 0.05566527f, 0.02618677f, 0.07012281f, 0.00785457f, -0.04470449f, -0.01074699f, 0.09405927f, 
    0.10502385f, -0.20953771f, 0.02447180f, 0.05638819f, 0.15539022f, -0.14259152f, -0.06716141f, -0.10954734f, 
    0.11805698f, 0.01621771f, -0.20277052f, -0.17176731f, 0.15073013f, 0.04372189f, -0.06583291f, -0.03076882f, 
    0.09664849f, 0.21703219f, 0.04210446f, -0.08612691f, 0.03559958f, 0.07570520f, 0.11223253f, 0.06219110f, 
    -0.11019508f, 0.03606760f, 0.11327187f, -0.00936993f, -0.31213343f, 0.25626889f, 0.14861283f, -0.07688627f, 
    0.27930948f, 0.14724705f, 0.10786223f, -0.15769336f, 0.05936062f, -0.10310057f, 0.18692721f, 0.30767828f, 
    0.04563794f, 0.09588408f, 0.13668649f, 0.08054002f, 0.12691586f, 0.03117088f, -0.26059708f, -0.11936958f, 
    0.07337301f, -0.10409313f, 0.10505058f, -0.05758306f, -0.01900478f, -0.13236235f, -0.22960407f, -0.04712812f, 
    -0.02598211f, 0.03356848f, -0.16913503f, 0.09281714f, 0.20431884f, 0.05258268f, 0.14209105f, -0.02957526f, 
    -0.34840590f, -0.18373691f, -0.06598364f, 0.15467334f, -0.26237765f, 0.23485057f, 0.17661804f, 0.49944687f, 
    0.03197538f, -0.14420797f, -0.20698515f, -0.31880191f, -0.05123293f, -0.08401073f, 0.08828849f, 0.07875208f, 
    0.05068428f, 0.01314932f, 0.10092599f, -0.35127813f, -0.08120061f, 0.03591781f, -0.06163094f, 0.11118589f, 
    -0.06927586f, 0.07545495f, -0.08335048f, 0.09699681f, 0.19423656f, 0.14542797f, 0.00323188f, 0.11125190f, 
    0.07338578f, 0.10723741f, 0.04773596f, -0.07470633f, 0.23461667f, -0.27756086f, -0.10937224f, -0.05256360f, 
    -0.06297769f, 0.00629505f, -0.02321146f, 0.11596994f, -0.05207618f, -0.01673661f, 0.06142399f, -0.23053455f, 
    -0.19719367f, 0.01167485f, -0.04996769f, -0.04402353f, -0.01690922f, -0.12188309f, -0.26051632f, -0.46776995f, 
    -0.39379904f, 0.09988754f, -0.05774449f, -0.07148477f, -0.06296049f, 0.08129834f, -0.06224818f, -0.02122373f, 
    -0.19289258f, -0.46568358f, -0.01205782f, -0.13881451f, -0.02188857f, -0.09268771f, 0.05083141f, 0.00658285f, 
    -0.11108850f, -0.20463003f, -0.30763581f, -0.01904686f, -0.18903574f, 0.11054166f, -0.00469206f, 0.10776693f, 
    0.04298777f, 0.01265395f, -0.34392327f, -0.10633990f, -0.01255842f, -0.11495952f, -0.18160067f, 0.02832914f, 
    -0.06403738f, -0.12762229f, 0.06590788f, 0.22895321f, 0.16480955f, -0.19220759f, 0.02182209f, -0.13421507f, 
    0.04891854f, -0.06696867f, -0.03993713f, 0.20403190f, -0.32719806f, -0.18737836f, 0.03453630f, 0.01152867f, 
    0.17135020f, -0.03231289f, -0.06952301f, -0.02469462f, -0.07265197f, 0.10163663f, -0.28926316f, -0.02399410f, 
    0.15480052f, -0.07349730f, -0.13210918f, 0.16556704f, -0.16411945f, 0.04981363f, 0.03558561f, 0.06419085f, 
    -0.08036718f, 0.07059890f, -0.16050395f, 0.08346296f, 0.20053416f, 0.09712034f, 0.04864879f, 0.05012780f, 
    -0.00676915f, -0.09942988f, 0.12167972f, -0.05667556f, 0.12973137f, 0.09074009f, 0.02448660f, 0.09653135f, 
    -0.08463030f, -0.19254680f, 0.02971870f, -0.03541824f, 0.06302632f, 0.16466765f, 0.23885235f, 0.08010419f, 
    0.10808128f, 0.29931420f, 0.33825701f, -0.25465396f, 0.09086119f, -0.14289768f, 0.07885019f, 0.22575876f, 
    0.29637262f, 0.44952089f, 0.15036073f, 0.05120767f, -0.01940613f, 0.14015417f, 0.13920911f, 0.07823539f, 
    0.08122928f, -0.03519665f, -0.20600758f, -0.49195236f, -0.37939733f, 0.21236329f, -0.05661408f, -0.09508191f, 
    -0.11160926f, -0.00408700f, 0.04508512f, 0.17647770f, 0.22282423f, 0.24447419f, -0.03922559f, 0.06008380f, 
    0.08407206f, 0.01840087f, 0.05769336f, -0.06088063f, 0.06065171f, -0.24216357f, -0.24662484f, 0.05312037f, 
    -0.27489859f, -0.06349961f, -0.06106844f, -0.00735842f, -0.01034071f, 0.04788558f, 0.21270171f, -0.02462301f, 
    -0.04177617f, -0.00489830f, -0.02833239f, 0.01934667f, -0.00614865f, 0.08311661f, 0.00434033f, -0.06490590f, 
    0.00147007f, -0.05059820f, -0.04598488f, -0.07096867f, 0.03900176f, 0.05331034f, 0.17602348f, -0.23394547f, 
    -0.19922456f, -0.38349572f, -0.20329702f, -0.11185625f, -0.03760050f, -0.04442817f, 0.01100391f, 0.00165564f, 
    -0.71552026f, -0.31211659f, -0.00051185f, 0.08602427f, 0.00922090f, -0.09044337f, 0.03678790f, 0.08257335f, 
    0.00356791f, 0.14335746f, 0.22291355f, 0.30364597f, -0.03920242f, -0.01345677f, -0.05882660f, 0.22982845f, 
    0.31002286f, 0.34450781f, 0.20950472f, 0.34997782f, 0.38354769f, -0.09840430f, 0.13058671f, 0.07982845f, 
    -0.06446362f, 0.14501627f, 0.13581806f, -0.16429363f, -0.02171304f, -0.17590177f, -0.11102781f, -0.09854047f, 
    0.13712236f, 0.17383233f, 0.11896391f, 0.02177370f, 0.13295045f, 0.16372004f, -0.30509162f, -0.06042109f, 
    0.20517625f, 0.09884746f, 0.02037071f, 0.29029056f, 0.08487757f, 0.21790162f, 0.23212019f, 0.14247887f, 
    -0.08493447f, 0.00687474f, 0.09970880f, -0.11189479f, 0.08781665f, 0.02511560f, -0.08705783f, 0.00183042f, 
    -0.18755509f, -0.08783403f, 0.11191618f, -0.02018497f, -0.10504974f, 0.08142595f, -0.10207154f, -0.12584551f, 
    -0.77545190f, -0.35650131f, -0.11619681f, 0.19964942f, 0.15363561f, 0.17131771f, -0.01850695f, 0.14406808f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.38299674f, 0.09097748f, 0.24126914f, 0.25618845f, 0.09537862f, 0.06450016f, -0.01982714f, 0.19587329f, 
    -0.00653709f, 0.00978371f, 0.07558182f, 0.01557882f, -0.01648971f, -0.01277603f, 0.15023276f, 0.17802286f, 
    -0.06962078f, -0.03372324f, 0.15631287f, -0.09346478f, 0.21355624f, 0.12087103f, 0.12375460f, 0.00141321f, 
    -0.08616236f, 0.16919421f, 0.02632492f, 0.01179412f, 0.19298933f, 0.25245550f, 0.11007708f, -0.05024148f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.28459391f, 0.13072620f, -0.06949271f, 0.14054561f, -0.01048386f, 0.13121100f, 0.14960235f, -0.12264202f, 
    -0.02485784f, 0.08218474f, 0.14889845f, -0.68156499f, -0.35692140f, 0.00464706f, 0.17483047f, -0.13615893f, 
    0.02709080f, -0.20791002f, 0.19090737f, 0.45967016f, 0.04470670f, -0.45902598f, 0.04779045f, -0.17369145f, 
    -0.31982592f, 0.35659853f, -0.12767389f, 0.11886536f, 0.32310721f, -0.01961326f, 0.29086444f, 0.14352791f, 
    -0.83632565f, 0.57048196f, -0.14589345f, -0.34656602f, -0.17026292f, -0.49811620f, 0.15020137f, -0.31471926f, 
    0.38973406f, 0.06202655f, -0.42454049f, 0.08778752f, 0.30287060f, -0.23943663f, 0.21839981f, -0.15107845f, 
    0.04818155f, 0.36524555f, -0.32641590f, 0.47745848f, -0.19542728f, 0.27891695f, 0.12905447f, -0.10208756f, 
    0.22442554f, 0.24209860f, 0.00813798f, -0.06251054f, -0.60157198f, 0.10624613f, -0.34908986f, 0.24634913f, 
    0.12700206f, -0.30425438f, -0.17442587f, 0.17746948f, 0.09266035f, -0.09504802f, 0.20111080f, 0.22104995f, 
    0.01232416f, -0.08092631f, -0.10579961f, -0.54912019f, 0.13661735f, -0.07291825f, -0.04574165f, 0.35445350f, 
    0.15823616f, 0.18804191f, 0.13029252f, -0.05254807f, 0.34787631f, 0.28376430f, -0.07303665f, 0.15875223f, 
    0.13894194f, -0.21716124f, 0.11017451f, 0.07516655f, 0.36434710f, -0.01099784f, 0.00910724f, -0.55726147f, 
    0.08389279f, 0.10872366f, -0.18164849f, -0.10200837f, 0.36349624f, 0.21189728f, 0.19121195f, -0.10113107f, 
    -0.37276766f, 0.00297566f, 0.07555278f, 0.42964992f, 0.07910158f, -0.00958646f, 0.16106966f, 0.08232324f, 
    0.06727550f, 0.05784922f, 0.35387644f, -0.33514208f, 0.24309142f, 0.38547328f, -0.22173065f, 0.05962381f, 
    0.04943493f, -0.12148520f, -0.24616747f, -0.07849115f, 0.21667975f, 0.16955797f, 0.43403021f, -0.26645941f, 
    0.08499747f, -0.47587803f, -0.14367314f, -0.06908855f, -0.16812889f, 0.10949172f, 0.21688387f, -0.45312828f, 
    -0.10913744f, 0.01771260f, -0.23340346f, 0.00481008f, 0.25139952f, 0.08022363f, 0.21077538f, 0.16523388f, 
    0.06917426f, -0.18570678f, -0.03136121f, 0.50545049f, 0.24378343f, -0.42858270f, 0.10413153f, 0.05919958f, 
    -0.14657755f, -0.16358796f, 0.41403636f, 0.35019657f, 0.49607903f, 0.40998140f, -0.16957255f, 0.42442822f, 
    0.12750258f, -0.13516562f, 0.07415704f, -0.25977328f, -0.25780535f, 0.06417387f, 0.01511092f, -0.27559870f, 
    0.33955821f, -0.10219749f, -0.09751242f, -0.15469317f, 0.04096773f, -0.28215373f, 0.24270941f, -0.32348156f, 
    -0.02656965f, 0.09454168f, -0.15596226f, 0.26717117f, -0.21597715f, 0.05452855f, 0.32060114f, -0.13032468f, 
    0.10868958f, 0.07545172f, 0.27419800f, 0.09753454f, -0.20262603f, 0.17720416f, -0.23023966f, 0.62306118f, 
    0.03361759f, -0.32311890f, -0.27318808f, 0.02996790f, -0.14186677f, 0.07962164f, 0.37014365f, -0.40078104f, 
    0.21912387f, -0.02331197f, -0.07097826f, -0.00965577f, 0.28111434f, -0.32016248f, 0.34228066f, -0.11963634f, 
    -0.09710838f, 0.15887199f, -0.50700963f, 0.00429425f, -0.17355581f, 0.24595107f, 0.13169684f, -0.04903302f, 
    0.08789197f, -0.35356688f, 0.35558233f, 0.15718181f, -0.26778650f, 0.34909415f, 0.03124525f, 0.40892124f, 
    -0.34910306f, 0.28753841f, -0.30852383f, -0.11404689f, 0.05942868f, 0.02684117f, -0.07993606f, 0.23636161f, 
    -0.28496319f, -0.04921953f, -0.34225675f, -0.12584783f, -0.03317662f, 0.05289971f, 0.15649132f, 0.20132442f, 
    -0.06328259f, -0.04467474f, -0.42451403f, -0.21875507f, 0.20464225f, 0.63316470f, 0.06850828f, 0.11186262f, 
    -0.02139015f, 0.46398500f, 0.17724170f, 0.01408798f, 0.45910352f, 0.05883166f, 0.22202246f, -0.42257854f, 
    0.08326618f, 0.33702317f, -0.48495221f, -0.25051668f, -0.34200284f, -0.18174697f, 0.13159274f, -0.29139379f, 
    -0.02939465f, -0.15613167f, 0.07063009f, 0.32041118f, -0.05940876f, -0.64171779f, 0.01491914f, -0.18666205f, 
    0.05858796f, 0.24350700f, 0.19396088f, 0.08960892f, 0.10656386f, -0.12634282f, 0.29353991f, 0.06679391f, 
    0.41632840f, 0.40839389f, -0.11063086f, 0.28770748f, -0.43530127f, 0.11816036f, -0.18177827f, 0.22154687f, 
    -0.20671536f, 0.07082778f, -0.09814195f, 0.06088724f, 0.23067965f, 0.08113371f, -0.04613909f, 0.19307478f, 
    -0.33163902f, 0.07662921f, -0.18645461f, -0.30444095f, -0.07669900f, -0.04726443f, 0.31283623f, -0.00785724f, 
    -0.06729555f, -0.25825104f, -0.33771306f, 0.21638770f, 0.27150279f, 0.34187096f, -0.13601761f, -0.01755311f, 
    -0.58938617f, 0.16639279f, -0.07149895f, -0.16912001f, 0.50193083f, 0.37656865f, -0.03805472f, 0.16889706f, 
    -0.17552772f, -0.10713941f, 0.05495211f, -0.00813197f, -0.08469492f, -0.20959704f, -0.20596443f, -0.04170876f, 
    0.02428957f, 0.03541204f, 0.10628751f, -0.18959905f, -0.17082891f, -0.17303525f, 0.07238349f, 0.04934712f, 
    0.05919698f, -0.10583826f, -0.13038099f, 0.04300433f, -0.03062281f, -0.10688395f, -0.07854117f, -0.13319574f, 
    -0.01042006f, -0.10642177f, 0.08090398f, -0.22767372f, -0.11018164f, 0.07929063f, -0.21600331f, -0.05504957f, 
    -0.03278384f, -0.07542402f, 0.01670089f, -0.09457701f, -0.06906901f, 0.09732995f, 0.11280147f, 0.07369492f, 
    -0.19336508f, -0.17483878f, -0.01267605f, -0.14204752f, 0.10418192f, -0.17986067f, -0.14436956f, -0.08892228f, 
    -0.07291236f, -0.15360789f, -0.19039406f, 0.01370710f, 0.12489352f, 0.11664943f, -0.04935934f, -0.17290193f, 
    -0.08327810f, -0.02469700f, -0.10089311f, -0.16650723f, -0.00783157f, -0.13311407f, 0.12757105f, -0.12281998f, 
    0.11510018f, 0.18152025f, -0.16059560f, 0.18479525f, -0.01009508f, -0.13374488f, 0.18947783f, -0.32698184f, 
    0.23391533f, 0.03938473f, 0.14552817f, -0.25048932f, 0.30825582f, -0.20124832f, -0.03619882f, 0.17082225f, 
    -0.01003721f, 0.09288082f, -0.09103978f, -0.13394336f, 0.20051046f, 0.56295598f, 0.36402810f, -0.13124461f, 
    -0.05517354f, -0.08178624f, 0.25425693f, 0.11102232f, 0.12610091f, -0.05530379f, -0.35776842f, -0.22368667f, 
    -0.32899213f, -0.00701914f, 0.12828615f, 0.12597910f, 0.29949224f, -0.12606917f, -0.03709104f, -0.16996942f, 
    -0.17636222f, -0.15901007f, 0.10259578f, -0.67434728f, -0.05886974f, -0.22576191f, 0.07285687f, -0.25618443f, 
    0.16142909f, -0.08695215f, 0.63082898f, 0.28489089f, 0.39048609f, -0.20569758f, 0.05709535f, 0.12340515f, 
    0.02459669f, 0.20214559f, 0.19488609f, 0.00523057f, 0.12135977f, 0.06581415f, 0.06495386f, -0.23088042f, 
    -0.16176505f, 0.11376891f, -0.07144531f, 0.04168564f, 0.17449710f, -0.02786100f, -0.18936327f, 0.03478344f, 
    -0.10208324f, -0.18231608f, 0.13243087f, -0.26606983f, -0.23718295f, -0.06902103f, 0.00766557f, -0.17258413f, 
    0.11731166f, 0.01334485f, 0.12725352f, 0.10121135f, -0.16218780f, -0.02817056f, -0.15655139f, -0.13701484f, 
    0.05230412f, -0.02028953f, -0.05598849f, -0.22952749f, 0.13920480f, -0.13122682f, 0.04506914f, -0.08225466f, 
    0.52768791f, 0.20926955f, 0.29936686f, 0.56252170f, 0.17608356f, 0.05554475f, -0.31717867f, 0.38604975f, 
    0.16053614f, -0.06526341f, 0.11253176f, -0.55115104f, -0.39412969f, -0.22452751f, 0.25707778f, 0.05489984f, 
    0.02704895f, 0.17300679f, -0.23304924f, 0.41291609f, -0.01978518f, 0.02445635f, 0.11265976f, 0.03742320f, 
    -0.38213417f, -0.13686413f, 0.09538348f, -0.20670719f, -0.08774981f, 0.16633433f, -0.00422271f, -0.10998480f, 
    0.57591432f, -0.42588785f, -0.56830710f, -0.06979490f, -0.02516122f, -0.34863892f, 0.26047969f, 0.22906682f, 
    -0.12621492f, 0.08739771f, -0.02247482f, 0.45477074f, 0.05448057f, -0.28247908f, -0.15198593f, 0.64579952f, 
    -0.11300410f, 0.24929592f, -0.46163711f, -0.39290288f, 0.21430044f, 0.18930407f, 0.46346185f, 0.07949124f, 
    0.22936781f, -0.17618416f, 0.34704670f, 0.48754889f, 0.05312465f, 0.12976585f, -0.09190009f, -0.34892160f, 
    0.11350690f, 0.52198195f, 0.29148045f, 0.29401791f, -0.10598363f, -0.12017362f, -0.31904921f, 0.16121632f, 
    -0.00502229f, -0.04545072f, 0.19208547f, 0.03537422f, -0.17940527f, -0.07125191f, 0.04149352f, -0.03094625f, 
    -0.12740195f, -0.08966151f, 0.18749334f, 0.10763779f, 0.14244154f, -0.20337151f, 0.08876930f, -0.02330170f, 
    -0.16056070f, 0.66460735f, -0.07098671f, -0.34592387f, 0.10088740f, 0.04341711f, -0.12182529f, 0.06473666f, 
    0.37580794f, -0.20780025f, -0.01323303f, 0.43442655f, 0.01770371f, -0.01020946f, -0.14570573f, 0.30560085f, 
    -0.13215482f, -0.12973878f, 0.21745764f, 0.16652143f, -0.10377062f, -0.42413816f, 0.17745002f, 0.20425679f, 
    -0.15512025f, 0.41660652f, 0.49042544f, 0.27046430f, 0.03322202f, 0.05060053f, -0.00858250f, -0.17554951f, 
    0.15200804f, -0.06487287f, -0.29467654f, -0.09041908f, -0.40987441f, -0.20625809f, -0.04305675f, 0.16046588f, 
    0.06289163f, -0.24482261f, 0.15643394f, 0.21960844f, -0.04073193f, -0.19369556f, 0.05588945f, 0.31919673f, 
    0.24881437f, 0.04216594f, 0.03873491f, -0.60704237f, 0.02728989f, -0.24514291f, -0.07797448f, 0.20692603f, 
    -0.00675522f, 0.20851050f, 0.36580306f, 0.21661460f, 0.30528384f, 0.02945416f, 0.24241358f, -0.15030718f, 
    0.15999754f, 0.21292491f, 0.21609317f, -0.06718070f, 0.15729579f, -0.26009101f, -0.15055014f, -0.69455248f, 
    0.37687290f, -0.29355496f, 0.07648293f, 0.01924661f, 0.10499313f, -0.14752658f, -0.07187229f, 0.01150836f, 
    -0.01418927f, -0.12153031f, 0.22417465f, 0.50266016f, -0.22872654f, 0.19306460f, 0.17413703f, -0.03539010f, 
    0.12691398f, -0.13896729f, 0.14606450f, 0.09262774f, -0.21067481f, -0.73959213f, 0.15095092f, 0.11210263f, 
    0.00883188f, 0.08482202f, 0.00121622f, 0.15339188f, -0.18668863f, -0.03809205f, 0.04321813f, 0.27146149f, 
    -0.45643988f, 0.50345796f, -0.10143745f, -0.37428051f, 0.01062050f, -0.01035159f, 0.15848322f, -0.41364852f, 
    0.05978172f, -0.00239547f, -0.04840609f, 0.54422456f, -0.17070782f, 0.13410603f, 0.21072964f, -0.30312237f, 
    0.12437534f, -0.20282611f, 0.10934685f, 0.14451799f, 0.07552850f, -0.35280392f, 0.42905596f, -0.09231026f, 
    0.21086934f, 0.31950027f, 0.32154617f, 0.15592879f, 0.45335487f, 0.07102587f, -0.00105020f, 0.12830533f, 
    0.06787421f, -0.11353497f, 0.01978067f, 0.10797354f, 0.23642115f, -0.24129078f, 0.13109508f, 0.34390777f, 
    -0.60434198f, 0.05579856f, 0.46082860f, 0.59125042f, -0.31087717f, 0.01179426f, 0.11805349f, -0.08438518f, 
    0.12890585f, -0.25005260f, -0.08852480f, 0.02190650f, 0.06566671f, -0.09601013f, 0.24371848f, -0.03709207f, 
    0.02878647f, -0.30646437f, -0.03358161f, -0.25985909f, -0.16202784f, 0.07237378f, 0.27774960f, -0.15923238f, 
    -0.19297771f, -0.10474705f, 0.16940095f, -0.17572522f, -0.14361106f, 0.09117445f, 0.05495767f, -0.01646981f, 
    0.12134519f, 0.04842669f, 0.01243677f, -0.27129823f, -0.09214120f, 0.05591949f, -0.31062359f, -0.07178148f, 
    0.02108831f, 0.02854904f, 0.15732989f, -0.00482383f, -0.30225861f, -0.04501615f, -0.05622333f, -0.10681271f, 
    0.14731190f, 0.03086401f, 0.05532555f, -0.04372777f, -0.25065008f, -0.17572448f, -0.12461263f, 0.26911858f, 
    -0.18338810f, 0.43953362f, 0.04971905f, -0.26303962f, 0.36272228f, 0.17081122f, -0.10158519f, -0.03727512f, 
    -0.32245645f, 0.18132491f, -0.28262627f, 0.11855027f, -0.12590455f, 0.25357372f, 0.38922796f, -0.14773969f, 
    -0.05866117f, -0.21367411f, -0.23336361f, -0.08870796f, 0.18530647f, 0.04871959f, -0.08171527f, -0.05432101f, 
    -0.47960299f, 0.01956263f, 0.22442977f, -0.22567615f, 0.46414295f, -0.05634317f, 0.15990716f, 0.01438222f, 
    -0.08258882f, 0.46761113f, -0.39095801f, 0.09131925f, 0.20291066f, -0.08139853f, 0.04511783f, 0.13182697f, 
    -0.09339841f, -0.05368840f, 0.03302338f, -0.41538373f, 0.01679538f, -0.00220101f, 0.02082646f, 0.35278329f, 
    -0.03788808f, 0.23095630f, 0.05401928f, -0.22290665f, 0.08370888f, 0.32350540f, 0.12264632f, 0.12124582f, 
    -0.05367187f, 0.21474819f, 0.15700631f, -0.05284583f, 0.02476043f, -0.09538753f, 0.10736484f, -0.42332482f, 
    -0.09787112f, -0.20427448f, -0.00722384f, 0.08199133f, 0.02968084f, 0.11497436f, -0.21800420f, -0.19247368f, 
    -0.17644171f, 0.08301082f, -0.01700373f, 0.05086361f, -0.19430032f, -0.14811261f, -0.16919470f, 0.06721617f, 
    0.01293263f, 0.07828957f, -0.11943111f, -0.07500824f, -0.09233854f, 0.11828395f, 0.10243984f, -0.14604373f, 
    -0.03675042f, 0.02500939f, -0.11355528f, -0.07349203f, 0.05444031f, 0.14510836f, 0.00716746f, 0.10336892f, 
    0.46891078f, -0.29970673f, -0.01716159f, 0.30371925f, -0.16702649f, 0.25994122f, -0.26366442f, 0.41091347f, 
    0.16253310f, 0.13821314f, -0.26938853f, 0.14449582f, 0.03085571f, -0.14829716f, -0.27463034f, 0.08466279f, 
    -0.15578103f, 0.10098378f, -0.12450597f, -0.17873172f, 0.27390191f, 0.21815400f, 0.29229388f, -0.05530111f, 
    0.05460490f, 0.37802619f, -0.05818271f, 0.57783556f, 0.38350397f, 0.48509607f, 0.01295592f, 0.33272299f, 
    -0.46836588f, 0.13799569f, -0.10422345f, -0.03104372f, 0.44486538f, 0.02717193f, 0.09696946f, 0.06409238f, 
    -0.59695423f, 0.06000742f, 0.05647687f, 0.33207169f, 0.05322113f, -0.13783889f, -0.07822059f, 0.10875984f, 
    0.05455489f, -0.06576003f, 0.43689689f, -0.19121604f, 0.45809579f, 0.00393463f, -0.39113125f, -0.16913770f, 
    0.14167812f, 0.01893145f, 0.17456077f, 0.06788303f, 0.30074665f, 0.14165378f, 0.36191711f, -0.16804251f, 
    -0.61337405f, 0.25614440f, -0.53243482f, 0.26531187f, 0.27092156f, -0.50328642f, 0.10208472f, 0.25550482f, 
    0.13598040f, -0.03905224f, -0.09413792f, 0.00610117f, 0.16894636f, -0.46149391f, 0.16399163f, 0.27364582f, 
    -0.05278521f, 0.38646287f, -0.16807479f, -0.18879727f, 0.34300345f, 0.34192133f, -0.06084275f, -0.02473356f, 
    -0.00984931f, 0.23056564f, 0.26348940f, -0.18568733f, 0.01314306f, -0.28605059f, 0.03579994f, -0.16671972f, 
    -0.19411184f, 0.53003263f, 0.26589122f, -0.05714514f, 0.05724619f, 0.11653835f, -0.05054942f, -0.14946561f, 
    0.28990379f, -0.15106282f, -0.06739612f, 0.09438435f, 0.05058881f, 0.19305092f, 0.02294792f, 0.00032907f, 
    0.03360040f, -0.10561420f, -0.38378835f, -0.34812859f, -0.22515450f, 0.34744221f, -0.01419357f, -0.01298551f, 
    -0.14732818f, 0.25770661f, 0.24620546f, -0.05022990f, 0.07323202f, -0.07446852f, 0.08929402f, 0.10955154f, 
    0.41124541f, 0.19429195f, 0.05587051f, -0.11489846f, -0.16524048f, 0.27579579f, -0.21872911f, -0.38758314f, 
    -0.28158343f, -0.00286679f, 0.18411340f, 0.40339035f, -0.18031749f, -0.27650490f, 0.16828962f, -0.40843087f, 
    0.03778450f, -0.02039742f, 0.11155229f, -0.12170041f, 0.03063277f, -0.08284067f, 0.23622827f, 0.08041828f, 
    0.04529827f, 0.43756092f, -0.26000464f, -0.12527637f, -0.16629499f, 0.37497443f, 0.06462637f, 0.23790208f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01303844f, -0.19409701f, 0.20812999f, 0.18361364f, 0.09322129f, 0.05581966f, 0.33384284f, 0.05958490f, 
    -0.02724074f, 0.34431949f, 0.03697011f, -0.09340445f, -0.10484830f, 0.08089907f, -0.11637972f, -0.02751044f, 
    0.26657248f, -0.16350658f, 0.07063948f, 0.01646350f, 0.02310632f, 0.02033381f, 0.24789168f, 0.07454212f, 
    0.20956291f, 0.16955873f, -0.11142404f, 0.14617133f, 0.15123323f, -0.05653523f, -0.18029515f, 0.31114015f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.07649472f, 0.54656035f, -0.05932206f, -0.38985586f, 0.19206797f, 0.24860382f, 0.17518027f, -0.92041790f, 
    0.27871418f, -0.09261880f, -0.10487051f, -0.09831021f, -0.21482483f, -0.44472066f, 0.13742602f, 0.14077064f, 
    -0.82196635f, -0.37842658f, 0.40836084f, -0.00891926f, 0.19852963f, 0.04891273f, -0.35633066f, 0.00140053f, 
    -0.09493637f, -0.52558118f, -0.02408816f, -0.35207644f, -0.72399271f, -0.45855156f, 0.14500988f, -0.16301693f, 
    0.21580406f, -0.99619025f, -0.12490896f, 0.10590762f, 0.03570601f, 0.11967050f, 0.13093626f, -0.47684416f, 
    -0.44818294f, 0.09773887f, 0.08730222f, 0.13050242f, -0.34551004f, 0.40636748f, -0.15604752f, 0.50968945f, 
    -0.71896005f, 0.22117175f, 0.36320812f, 0.16677488f, 0.26911393f, -0.15156981f, 0.34415001f, 0.02738298f, 
    0.10675958f, -0.27541411f, 0.05447846f, -0.05851391f, -0.20573622f, -1.03779376f, -0.03518011f, 0.32238325f, 
    -0.35098341f, -0.24281619f, 0.24047455f, 0.09441014f, -0.16927704f, -0.28049138f, 0.05819127f, 0.45088992f, 
    -0.69218308f, 0.30834177f, -0.02515401f, 0.06359190f, 0.26103234f, -0.61609149f, -0.11902849f, 0.01059651f, 
    0.41860333f, -0.58372003f, -0.28039196f, 0.04062549f, -0.39063630f, -0.42130628f, 0.21870567f, 0.15864561f, 
    0.01787025f, 0.19761324f, -0.07370555f, -0.07617835f, -0.12326665f, 0.40246212f, 0.07341307f, -0.76484793f, 
    -0.28322700f, 0.34785464f, -0.12720151f, 0.10400250f, -0.10977757f, 0.16907671f, 0.32412204f, 0.12278878f, 
    -0.06622497f, -0.09102905f, -0.15016058f, 0.09182038f, 0.35406980f, -0.10301208f, -0.04257017f, -0.07537720f, 
    -0.24064738f, -0.53149813f, -0.32380852f, -0.64848602f, -0.51888895f, -0.04815322f, -0.48361284f, -0.59123647f, 
    0.20110099f, 0.27683625f, -0.05795196f, -0.50596386f, 0.06221385f, 0.48762929f, 0.21639310f, -0.35548323f, 
    -0.61603040f, 0.00167698f, -0.36951080f, 0.06427468f, 0.07845794f, 0.20623226f, 0.24517077f, -0.33025947f, 
    0.33123583f, -0.23292436f, -0.04376677f, -0.07484877f, -0.00026039f, -0.92949355f, -0.13168947f, -0.63906538f, 
    0.13365684f, 0.20545249f, 0.02843785f, -0.00832610f, 0.12852496f, 0.08482169f, 0.06669822f, -0.01168995f, 
    -0.14516790f, -0.53498995f, -0.06785278f, 0.17966396f, 0.19641671f, -0.14612690f, -0.01972015f, 0.24064842f, 
    0.17325793f, -0.54657680f, 0.14648013f, -0.09866369f, 0.34851411f, 0.03884956f, 0.03826468f, 0.06205634f, 
    -0.36542314f, 0.06263095f, -0.11755197f, 0.00088896f, -0.01213335f, 0.25425830f, -0.24271834f, -0.02515217f, 
    0.06810874f, -0.32793117f, -0.81748283f, 0.08355958f, 0.01427553f, 0.20273805f, -0.41709751f, 0.02691695f, 
    0.13022704f, -0.03389818f, -0.16675514f, 0.25980371f, 0.07548404f, -0.86582088f, -0.12068358f, -0.28391623f, 
    -0.16312028f, -0.64646995f, 0.35232168f, -0.20125510f, -0.75589401f, -0.65724856f, -0.69408470f, -0.03225076f, 
    -0.29107624f, -0.44358218f, -0.10096688f, 0.06492346f, 0.03347062f, -0.27199164f, -0.02966532f, 0.37817875f, 
    0.37777263f, -0.14935620f, 0.43922490f, 0.29058006f, 0.01116801f, -0.86159629f, -0.00356329f, 0.14840461f, 
    -0.49719572f, 0.29532120f, 0.11569986f, 0.22986777f, -0.09428707f, 0.37976268f, -0.24153191f, -0.81194025f, 
    0.27605850f, 0.58514225f, -0.24805139f, -0.23968177f, -0.79860699f, 0.15515658f, -0.67514104f, 0.12568714f, 
    0.18986589f, -0.84501314f, 0.15977128f, -0.14751151f, 0.26021367f, -0.33457994f, 0.08947508f, -0.05146796f, 
    -0.00781797f, 0.21816067f, -0.48920175f, 0.16598120f, 0.06876209f, 0.27371129f, -0.11207091f, -0.07509363f, 
    -0.01842347f, 0.28195533f, -0.15491293f, -0.19859897f, -0.47546154f, 0.35644555f, 0.02398034f, 0.02920361f, 
    0.14465171f, -0.16439280f, -0.12092933f, 0.12943101f, -0.44949430f, -0.50309873f, -0.50344867f, 0.48552203f, 
    -0.07455929f, 0.39538944f, -0.16421491f, -0.06164299f, -0.38961774f, -0.19051835f, 0.01569321f, 0.09419272f, 
    -0.81302786f, 0.28294632f, -0.23711824f, -0.07695477f, -0.35022461f, -0.15192470f, -0.40196693f, -0.44605726f, 
    0.35018891f, 0.16554585f, -0.03563126f, 0.27293706f, 0.22526960f, 0.04228006f, 0.08565860f, 0.43392575f, 
    0.10449648f, -0.56372881f, 0.13905364f, 0.11275245f, -0.20188783f, 0.13645850f, 0.04894240f, -0.10882638f, 
    0.56433499f, -0.42295599f, 0.00424573f, -0.08089645f, 0.14006074f, -0.43747777f, -0.21501566f, 0.16974278f, 
    0.47702920f, -0.42905864f, 0.23479551f, 0.02382850f, 0.04792821f, -0.45952010f, -0.16617222f, -0.34486052f, 
    -0.60718620f, -0.00450658f, -0.12377486f, 0.40200830f, -0.62040782f, -0.42958710f, -0.17492278f, 0.42034885f, 
    -0.02814584f, -0.77199519f, -0.22320785f, 0.32401404f, -0.22619557f, -0.53935003f, -0.28824571f, 0.27698997f, 
    -0.50524521f, -0.09790482f, 0.02848935f, -0.16193084f, -0.50791216f, -0.46877435f, -0.18480542f, -0.09106822f, 
    0.10586411f, -0.52346426f, -0.52466375f, -0.48993438f, 0.34993514f, 0.35519594f, 0.71347839f, -0.60713452f, 
    0.42117688f, 0.07903367f, 0.04663317f, -0.54862332f, 0.37267032f, -0.29274035f, -0.13865197f, 0.10800287f, 
    0.29649892f, -0.22923741f, 0.24315207f, 0.28558013f, -0.11720277f, -0.51932043f, -0.23744570f, -0.06371567f, 
    0.22449999f, -0.29953495f, -0.12580109f, 0.13646758f, -0.10202822f, 0.40009752f, 0.09290230f, -0.52545738f, 
    -0.23769596f, -0.22539403f, 0.30882236f, 0.16740441f, -0.18184026f, -0.09894361f, 0.16446395f, -0.27779892f, 
    -0.35736331f, 0.20406744f, 0.12558796f, -0.44401658f, 0.60089052f, 0.20048751f, -0.63994491f, 0.05879676f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.19749789f, 0.17812805f, 0.27424431f, 0.06576768f, 0.03516477f, -0.10522623f, 0.12619491f, -0.28163826f, 
    0.16017920f, 0.24470940f, 0.22964427f, 0.11522613f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
