#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.63967454f, -0.11857530f, 0.15618272f, -0.77362072f, -0.46180883f, -0.20876192f, 0.20652142f, 0.22663027f, 
    0.27341765f, 0.43622100f, 0.49980214f, -0.13344644f, 0.20194066f, 0.52222687f, 0.31262094f, 0.16349392f, 
    0.69002509f, -0.16243570f, 0.68588734f, 0.51125830f, 0.76342624f, 0.12189109f, -0.38885388f, 0.08855010f, 
    0.07855655f, 0.14816301f, -0.11625365f, 0.77951771f, 0.15437481f, 0.43153030f, -0.22975636f, 0.29046202f, 
    0.08877223f, -0.11455547f, -0.18812479f, -0.30687326f, -0.04340415f, 0.33845645f, 0.19012430f, 0.41850629f, 
    0.53191209f, 0.66518092f, 0.04359089f, -0.26622573f, -0.21616651f, 0.81758058f, -0.07138711f, 0.42997724f, 
    0.25634450f, 0.19316900f, -0.10965938f, 0.02599664f, 0.27776533f, 0.43453789f, -0.09319257f, 0.35069749f, 
    0.28487787f, 0.58769512f, -0.03200410f, -0.04899718f, -0.48271626f, -0.13901550f, -0.04052646f, -0.00699585f, 
    -0.65578973f, -0.64567995f, 0.37622589f, -0.32060930f, 0.51413834f, -0.38395804f, -0.16868788f, -0.08541626f, 
    0.22234935f, 0.58037978f, 0.15036979f, 0.22588199f, -0.14688474f, -0.43299997f, -0.14798352f, -0.09745792f, 
    -0.32836887f, -0.68502182f, 0.53120244f, 0.18248631f, -0.08643088f, -0.20165510f, -0.64399326f, 0.05083492f, 
    0.26716393f, -0.10919759f, -0.03291672f, -0.20578256f, -0.10087109f, -0.39983135f, 0.68743742f, -0.70267296f, 
    -0.18576153f, 0.07918252f, -0.08913834f, 0.21703511f, 0.01071641f, 0.49866188f, 0.03388729f, -0.54684812f, 
    0.52918273f, -0.07868697f, 0.02129889f, 0.03333465f, -0.75168866f, -0.25453046f, -0.37627298f, 0.44154558f, 
    0.72664350f, 0.10374212f, 0.15810756f, -0.03194646f, -0.19452772f, 0.09812088f, -0.12641914f, 0.01948365f, 
    -0.53122026f, -0.04339883f, 0.70033103f, -0.15067822f, -0.18284886f, -0.06720612f, -0.13925050f, 0.41598293f, 
    0.27863011f, 0.53927773f, -0.51408041f, 0.07335271f, 0.52363217f, -0.08828176f, 0.16327141f, -0.00963042f, 
    -0.20972909f, -0.55531919f, 0.06505204f, -0.44845268f, -0.22130701f, -0.24844490f, 0.02785198f, 0.63677341f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22050337f, -0.29328415f, -0.00537605f, -0.18429695f, 0.08240610f, -0.54360199f, 0.03654700f, -0.20115991f, 
    0.14367652f, -0.02751681f, 0.08304621f, -0.11015306f, -0.31969145f, -0.07846075f, -0.11224237f, -0.22524555f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.13556993f, 0.03059177f, 0.04495306f, 0.17212489f, 0.07172807f, -0.07464257f, 0.09434649f, 0.21036366f, 
    -0.13906360f, 0.16127400f, -0.22195925f, 0.12882090f, 0.03083364f, 0.22152720f, 0.08118851f, 0.07717377f, 
    0.03593846f, -0.41367328f, 0.14504400f, 0.15072379f, -0.26899222f, 0.20934758f, -0.05522922f, -0.02618187f, 
    0.01719228f, -0.04706774f, -0.18183422f, 0.19332556f, 0.26722175f, -0.09315207f, 0.01286370f, -0.04723395f, 
    -0.06657919f, -0.05038663f, -0.01208732f, -0.02959028f, -0.11623484f, -0.13290028f, 0.17385663f, 0.02730329f, 
    0.15149167f, 0.14472474f, -0.02900571f, -0.06561979f, 0.03956208f, 0.16374592f, -0.30504265f, -0.44042343f, 
    0.06051126f, -0.01617857f, -0.06826495f, -0.05730836f, -0.11741929f, -0.05813213f, -0.13555507f, -0.10380898f, 
    0.14955780f, -0.03341232f, -0.11848798f, 0.10196331f, -0.02614736f, -0.13639154f, 0.03559542f, -0.19542132f, 
    0.05569155f, 0.20205919f, 0.04438305f, -0.00904194f, -0.13088953f, -0.16164483f, 0.06799521f, 0.11071980f, 
    0.28159761f, 0.00834790f, -0.07508987f, -0.08254848f, 0.11450958f, -0.22213918f, 0.19897680f, 0.08445992f, 
    0.07538980f, -0.17678389f, 0.20157664f, 0.05439017f, 0.02472673f, -0.10286048f, -0.06243880f, 0.12304821f, 
    -0.01371629f, 0.06291693f, 0.03966643f, -0.02582556f, -0.00021633f, 0.11888485f, -0.01279071f, 0.20064637f, 
    -0.01469866f, 0.06586864f, 0.30337843f, 0.16771303f, -0.09112919f, -0.15965548f, -0.01366884f, 0.02321342f, 
    0.15746614f, 0.02750476f, -0.11015010f, -0.28621992f, 0.03148819f, -0.26737857f, 0.05226055f, -0.06365978f, 
    -0.18964000f, -0.01751095f, -0.23106275f, -0.06934264f, 0.16131647f, 0.07198729f, -0.01002703f, 0.01359852f, 
    -0.13568611f, 0.21956080f, -0.02944326f, 0.05314676f, -0.07353424f, -0.04986858f, 0.17438881f, 0.17864212f, 
    0.08665594f, -0.23645796f, 0.15382767f, 0.08826939f, -0.17536440f, -0.12192222f, -0.14645733f, 0.24828653f, 
    0.15102030f, 0.03798134f, 0.13927370f, 0.09365907f, -0.07627110f, 0.08374377f, -0.11032451f, 0.04342149f, 
    0.10253421f, -0.35529524f, -0.14899702f, 0.05835531f, 0.07756199f, -0.03449522f, 0.07656930f, -0.05479298f, 
    0.07724799f, 0.01085713f, -0.25656477f, 0.05717243f, -0.06503256f, -0.22579558f, 0.05057316f, -0.05930829f, 
    0.21522731f, 0.17814714f, 0.10341799f, 0.04605711f, -0.01808479f, -0.12021090f, -0.13813901f, 0.00002107f, 
    -0.11911525f, 0.04955209f, 0.08551647f, 0.27415022f, -0.24478416f, -0.05255650f, -0.28571734f, -0.05618720f, 
    0.05403702f, -0.05690177f, -0.00693942f, 0.00892580f, 0.03917538f, 0.08066334f, 0.07094588f, 0.02046131f, 
    0.12767249f, -0.20435444f, 0.01710713f, 0.03371574f, -0.18019134f, 0.02171652f, -0.04154036f, 0.12756406f, 
    0.11806326f, -0.09870007f, -0.06675082f, 0.03021447f, 0.08769046f, 0.04863866f, -0.03874669f, 0.00046767f, 
    0.13280255f, -0.14029922f, 0.08605648f, -0.26522270f, 0.04873592f, 0.17368349f, -0.08702716f, 0.35238546f, 
    0.21542549f, -0.22016411f, 0.03917236f, -0.02830702f, 0.09298147f, 0.01572487f, 0.01579784f, -0.01273776f, 
    0.02741846f, 0.00673424f, 0.12814312f, 0.05910621f, -0.13624209f, -0.01611832f, -0.08458203f, 0.13982067f, 
    0.04656833f, -0.21308854f, -0.01773159f, -0.07290964f, 0.03109603f, 0.04404039f, 0.16980255f, -0.17180765f, 
    0.05216847f, -0.12559699f, -0.04926836f, -0.07988665f, -0.07323662f, 0.05142331f, 0.02253172f, 0.03740240f, 
    0.08931525f, 0.03405764f, 0.07564369f, 0.08417394f, 0.12370741f, 0.01287073f, 0.00150669f, -0.17305152f, 
    -0.13914351f, -0.27792281f, -0.08645649f, 0.08797947f, 0.35752493f, 0.42312801f, 0.03287495f, 0.11415830f, 
    -0.13416168f, -0.07309350f, 0.22952153f, -0.04252952f, 0.08079438f, -0.14837807f, -0.04869454f, -0.08240413f, 
    0.01458896f, 0.06681407f, 0.08104195f, 0.18814084f, 0.19173008f, -0.01402353f, 0.06742543f, 0.04683436f, 
    0.08761764f, -0.03625366f, 0.05918532f, -0.04363619f, -0.10091458f, -0.06056733f, -0.03142160f, -0.38353312f, 
    -0.10100029f, 0.00039747f, 0.02286211f, 0.03855104f, -0.01070282f, -0.20185983f, -0.07851415f, 0.13575473f, 
    -0.01339595f, 0.07143477f, -0.00036583f, 0.07089844f, -0.03074177f, -0.08103906f, -0.05949256f, 0.04421548f, 
    -0.06538647f, -0.07323869f, 0.04390443f, -0.05918626f, 0.01647335f, -0.03653339f, -0.02440337f, 0.04748919f, 
    -0.07802548f, 0.00212146f, -0.06909880f, -0.09499816f, 0.04797497f, 0.04666331f, -0.01052568f, 0.04458165f, 
    -0.00881064f, -0.04333008f, 0.00698209f, -0.03217928f, -0.02605024f, 0.05646414f, 0.03667730f, 0.04714660f, 
    -0.00152611f, 0.02012781f, -0.05341390f, -0.06245282f, -0.08338921f, 0.01750840f, -0.07029927f, -0.07305466f, 
    -0.01903040f, -0.00557639f, -0.02604681f, 0.01655948f, -0.04771143f, 0.01894742f, -0.03872971f, -0.03815031f, 
    0.02369684f, 0.06028376f, 0.01454424f, 0.05546212f, -0.03840590f, -0.08075099f, -0.01743835f, 0.06243704f, 
    0.05966793f, -0.00879483f, 0.03851544f, 0.03126892f, -0.04209446f, 0.00880083f, 0.04469549f, -0.07379445f, 
    -0.06358489f, -0.04438866f, 0.01622605f, 0.04675211f, -0.01034464f, -0.05645349f, -0.05600945f, 0.00184467f, 
    -0.04154503f, -0.03430464f, -0.08946303f, 0.04574824f, -0.08664253f, -0.03927543f, -0.07093079f, 0.01904662f, 
    -0.05452156f, -0.04864091f, 0.01294550f, 0.01017736f, -0.00392657f, -0.03465639f, 0.06337056f, 0.05843766f, 
    -0.03216717f, -0.08778106f, -0.07293252f, -0.06739791f, 0.00903769f, -0.08469070f, 0.05041153f, 0.02599833f, 
    0.00407409f, 0.04345572f, -0.04555347f, 0.03636520f, -0.01830317f, -0.06507964f, -0.07407990f, -0.06573353f, 
    -0.03560446f, -0.01114851f, 0.03365970f, 0.03643644f, -0.04245495f, 0.05134079f, 0.01985141f, -0.03569474f, 
    -0.01822334f, 0.06957497f, -0.05497814f, -0.03542135f, -0.09009840f, 0.01294513f, -0.08257491f, 0.06112744f, 
    -0.08642889f, 0.05678037f, 0.02166660f, 0.01947048f, -0.02076471f, -0.06897221f, -0.05343935f, 0.06622666f, 
    -0.09116132f, -0.06282996f, -0.07305353f, -0.00720001f, -0.07478892f, 0.05397094f, 0.03240140f, -0.04125358f, 
    0.05617302f, -0.02038847f, 0.04290178f, 0.03117882f, -0.02726590f, 0.05245790f, -0.03497138f, 0.05291894f, 
    0.28404289f, 0.04504960f, -0.21871161f, 0.06197866f, 0.02494674f, -0.02224687f, -0.04121370f, 0.01086614f, 
    -0.03269495f, 0.16398238f, -0.01641615f, -0.14585292f, -0.14030191f, 0.05425423f, -0.01762405f, -0.01746161f, 
    0.00434267f, -0.11745237f, -0.01569110f, 0.14756866f, 0.04650038f, 0.05854428f, 0.19075204f, 0.14457260f, 
    0.05314449f, 0.04458170f, -0.07650956f, 0.16638868f, -0.18229716f, 0.03579759f, 0.03245628f, 0.01709654f, 
    0.11963278f, 0.13225728f, -0.00989826f, 0.04147590f, 0.17926030f, 0.01093152f, 0.12898469f, 0.00478528f, 
    -0.02837299f, 0.02893945f, 0.01999473f, 0.07109520f, 0.05093311f, 0.23761646f, 0.01474173f, -0.20222576f, 
    -0.12670676f, 0.05216106f, -0.09303759f, 0.25360331f, 0.01513521f, 0.04582395f, -0.05203781f, -0.10288272f, 
    -0.06469809f, -0.09355665f, -0.03981532f, 0.10535775f, 0.04743423f, 0.08466804f, 0.08135179f, -0.02903636f, 
    0.25950137f, 0.35764813f, -0.16471829f, -0.10314484f, 0.02741151f, -0.06655417f, 0.02179366f, -0.04339215f, 
    -0.33507892f, 0.00736117f, -0.03926952f, 0.10439172f, 0.00490814f, -0.03211848f, 0.07234746f, -0.02953875f, 
    0.09121715f, -0.15945818f, -0.50217003f, -0.25898242f, 0.01008150f, -0.00610785f, -0.08618366f, 0.09762372f, 
    0.10715160f, -0.00922483f, -0.25570396f, -0.12412185f, -0.42769542f, 0.13324514f, 0.00750681f, -0.00966637f, 
    0.01403282f, -0.05388567f, 0.05974169f, 0.08264329f, -0.11691811f, 0.05337678f, 0.08055994f, 0.16895130f, 
    0.08751452f, -0.01218531f, 0.04383314f, 0.03752975f, -0.01746078f, -0.16776106f, 0.02745075f, -0.27477616f, 
    -0.05204059f, -0.12784059f, -0.02842983f, -0.00814471f, -0.02256398f, -0.04905374f, 0.03481581f, 0.26726520f, 
    -0.15242602f, 0.11465959f, 0.02972677f, 0.10539480f, 0.06002660f, 0.01800205f, 0.36317104f, 0.31730792f, 
    0.02629732f, -0.04751580f, -0.23035297f, -0.13615419f, 0.07579761f, -0.17672053f, 0.02528337f, -0.39566562f, 
    0.26094258f, -0.22085127f, -0.09436578f, -0.04680112f, 0.11411421f, 0.11434513f, -0.02449131f, 0.09974986f, 
    -0.03280537f, 0.08140472f, -0.22276157f, -0.29917005f, -0.04750217f, -0.20765927f, -0.17300138f, 0.06038346f, 
    -0.04272385f, -0.47033229f, 0.28222397f, -0.13859563f, 0.17911866f, -0.03506713f, 0.03415835f, -0.01022864f, 
    -0.02575679f, -0.00019064f, 0.04041865f, 0.22142780f, -0.06948703f, 0.01863286f, 0.02412762f, 0.10317720f, 
    0.13503793f, 0.07758971f, -0.03591894f, 0.06437674f, 0.05981423f, -0.10158471f, 0.04732569f, -0.05298908f, 
    0.10708533f, 0.10729719f, 0.07361694f, 0.01474366f, 0.10463835f, 0.04704646f, -0.11517051f, 0.06271678f, 
    -0.00141552f, 0.05047692f, 0.12380046f, 0.00991918f, -0.01174083f, 0.33702207f, 0.11320776f, 0.08938342f, 
    0.03081805f, 0.04953973f, -0.06097240f, -0.02298132f, -0.07568575f, 0.06354012f, 0.29258841f, 0.09064177f, 
    0.08272024f, -0.06555755f, 0.07013606f, 0.05649272f, 0.01991515f, 0.01347028f, -0.02822227f, 0.43639389f, 
    0.15517379f, 0.28613162f, 0.09547960f, 0.15282047f, -0.05501457f, 0.08989014f, -0.11757155f, 0.01477780f, 
    -0.02531574f, 0.22721702f, 0.08799384f, -0.06908075f, 0.01561649f, -0.06292985f, 0.03491271f, 0.11826263f, 
    -0.04012767f, -0.19719012f, 0.03950145f, -0.02288357f, -0.05943093f, -0.08725997f, -0.16456766f, -0.14748096f, 
    0.12795040f, -0.02679370f, 0.02241062f, -0.04213863f, 0.06981973f, 0.04044043f, -0.00488483f, 0.08282745f, 
    -0.05145000f, -0.08805618f, -0.28278852f, 0.10881577f, -0.09037715f, -0.50422472f, -0.17943348f, 0.04307857f, 
    0.02391154f, -0.04914504f, -0.10127988f, 0.07926415f, 0.20289914f, 0.18774752f, 0.28963032f, -0.06352662f, 
    0.00611831f, -0.13290465f, -0.02969122f, -0.03256552f, 0.09291935f, 0.12417015f, -0.09749248f, -0.08087978f, 
    -0.03080812f, 0.02948738f, 0.00761400f, 0.10707044f, 0.12015130f, 0.08632573f, -0.13265952f, -0.05009181f, 
    -0.06962045f, 0.11420843f, -0.10340957f, -0.08976770f, 0.02543228f, 0.01816546f, -0.01272262f, 0.07544813f, 
    0.16315195f, -0.05286117f, 0.15758215f, -0.07068843f, 0.05538118f, -0.18876263f, 0.08354345f, 0.11502298f, 
    -0.14996156f, -0.10719864f, 0.14526758f, 0.02055920f, -0.05631692f, -0.04892739f, 0.07172360f, 0.02901805f, 
    0.18614194f, 0.03583065f, 0.09655081f, -0.41929120f, 0.01080538f, -0.03419425f, -0.09200542f, 0.04566540f, 
    -0.04540997f, 0.10724687f, 0.03284902f, 0.17679019f, 0.16274598f, -0.26824409f, -0.12721559f, -0.07038013f, 
    0.17466584f, 0.20871679f, 0.00738759f, -0.05262906f, -0.05866347f, 0.02634884f, 0.01340507f, -0.04233979f, 
    -0.03056232f, -0.02880911f, 0.13048714f, -0.00273689f, 0.18864910f, 0.18836446f, -0.11659846f, -0.00317998f, 
    0.03848702f, 0.00387875f, 0.13017732f, 0.25589746f, 0.03168872f, -0.26380897f, 0.01190337f, -0.15435426f, 
    -0.12677056f, -0.10691693f, -0.09373387f, -0.00868803f, -0.07616745f, -0.23581205f, -0.00964158f, 0.13040289f, 
    0.24148314f, 0.03027771f, -0.13226934f, -0.08765270f, 0.11247954f, 0.06022200f, 0.04307569f, 0.06829982f, 
    -0.10880205f, -0.16989456f, 0.04700087f, -0.03749462f, 0.05058924f, -0.10792314f, 0.10738610f, -0.10451100f, 
    0.24498999f, 0.11679580f, 0.14147869f, -0.08069918f, -0.08769384f, -0.05124486f, 0.08378482f, 0.07661661f, 
    0.09205010f, -0.12520503f, -0.11683311f, -0.27054918f, 0.13250950f, -0.02863775f, -0.14496115f, -0.12410049f, 
    0.22983499f, -0.12822698f, -0.01674422f, -0.30500755f, 0.06252303f, 0.21833220f, 0.07344689f, 0.09525112f, 
    -0.06107683f, -0.07138676f, 0.05718063f, 0.08440179f, -0.14097157f, 0.17708166f, -0.03028612f, -0.08413856f, 
    -0.10769274f, 0.03939350f, 0.18020855f, 0.25828347f, -0.16353483f, -0.05659943f, -0.40207204f, 0.09895116f, 
    0.14687215f, -0.02325877f, -0.12876944f, -0.22161494f, -0.14790489f, -0.02559187f, -0.25824890f, 0.03136739f, 
    0.12170763f, 0.14074863f, 0.03800859f, -0.10338932f, 0.07776131f, -0.11482420f, -0.30154073f, 0.06245052f, 
    -0.20570441f, 0.03335897f, 0.13659087f, 0.16464506f, -0.09080461f, -0.01081196f, -0.11196315f, -0.50389510f, 
    0.04614395f, 0.14428276f, 0.12596960f, 0.01181945f, 0.17245370f, 0.06961841f, 0.04973162f, -0.16540529f, 
    0.01602087f, -0.18188205f, 0.08995369f, -0.07785787f, 0.08687036f, -0.06727274f, 0.07639246f, 0.23682670f, 
    0.16042715f, -0.09945023f, -0.15449880f, -0.18705341f, 0.02341618f, -0.00843275f, -0.10147237f, 0.04175185f, 
    0.03645447f, 0.00812055f, -0.18936975f, 0.12383270f, 0.21678856f, 0.31883687f, 0.13141702f, -0.03765771f, 
    0.14851150f, -0.06183033f, 0.08976092f, -0.22876114f, 0.27077618f, -0.13443998f, 0.26578724f, 0.04112701f, 
    0.12654662f, 0.01890805f, -0.06256197f, -0.02813003f, -0.03938464f, -0.05939306f, -0.12741698f, 0.21856497f, 
    -0.01605379f, 0.15437169f, 0.04004657f, 0.08939084f, -0.13505767f, 0.02085431f, -0.15133020f, -0.03547542f, 
    0.15655883f, -0.17493607f, 0.14212948f, 0.10389496f, -0.07260893f, -0.20169644f, 0.11892847f, 0.00928059f, 
    -0.08022056f, 0.13265729f, -0.18946248f, 0.17805731f, 0.01730627f, 0.06272366f, 0.00458719f, -0.08747406f, 
    -0.45893443f, 0.10947823f, -0.05939005f, -0.06692286f, 0.04428203f, -0.17317335f, -0.10843970f, 0.03742371f, 
    0.10966954f, 0.01737716f, -0.03381716f, 0.03554910f, 0.10125653f, 0.00108939f, 0.11174234f, 0.02959517f, 
    0.01293498f, 0.03951286f, 0.14749768f, 0.05026761f, -0.19432443f, -0.14322065f, -0.05367747f, 0.11955352f, 
    -0.00972854f, 0.15713947f, 0.25423771f, 0.03630440f, -0.04163346f, -0.15921058f, -0.08321559f, 0.00151963f, 
    0.03767397f, 0.13053249f, 0.07680828f, -0.23516883f, 0.00841241f, -0.06371246f, -0.07982765f, -0.11529198f, 
    0.09394819f, 0.01923981f, 0.00309170f, -0.00349414f, -0.25215015f, -0.21956103f, -0.08977428f, 0.14074861f, 
    0.11717921f, -0.02893328f, -0.10530041f, -0.14576764f, 0.01295117f, -0.16570644f, -0.06894723f, -0.23339087f, 
    -0.07372652f, 0.08718026f, -0.02287072f, 0.13583024f, 0.23126116f, -0.07980501f, -0.05067735f, -0.19798625f, 
    -0.07377397f, 0.08980621f, -0.06759435f, -0.01278565f, -0.17984413f, -0.09774970f, -0.10061315f, -0.03932762f, 
    -0.39776999f, -0.02000529f, -0.07221030f, 0.02868119f, 0.07302251f, 0.32468295f, -0.05193982f, 0.00666035f, 
    0.20356724f, 0.42077073f, 0.06453776f, -0.12043981f, 0.04402655f, 0.03722025f, -0.12211634f, -0.03885306f, 
    0.10289956f, -0.17971338f, 0.05484041f, 0.19920041f, -0.02325659f, -0.04078081f, 0.07110491f, -0.13152142f, 
    -0.06748269f, 0.05279901f, -0.01598653f, 0.42669779f, 0.19125111f, -0.04998490f, 0.10767964f, -0.00406948f, 
    -0.01119546f, -0.12400039f, -0.08994378f, 0.09395941f, 0.14612477f, 0.10851287f, -0.03435361f, -0.00593554f, 
    0.10822345f, -0.06434152f, 0.05539909f, -0.16626023f, 0.30566475f, 0.03815835f, -0.00499330f, 0.21573161f, 
    0.14328365f, 0.09953758f, -0.02062592f, -0.10750505f, -0.13075936f, -0.27250522f, 0.02828113f, -0.07043042f, 
    -0.08108439f, 0.10313795f, 0.01366771f, -0.17507581f, -0.09651221f, -0.04831735f, -0.01354703f, 0.07611446f, 
    0.04097080f, -0.19968973f, -0.10426641f, -0.05398448f, 0.28188089f, 0.05191190f, 0.02804117f, -0.19100916f, 
    0.03396356f, -0.30145866f, 0.08151998f, 0.03667416f, 0.04843865f, -0.12291460f, -0.04076787f, -0.11694308f, 
    0.10037190f, 0.07814522f, 0.10461132f, -0.01022004f, -0.09792519f, -0.08859121f, 0.03637546f, 0.03604691f, 
    0.13336614f, -0.07121757f, -0.14987636f, -0.15628123f, 0.03917478f, 0.04080797f, 0.05940426f, 0.05717846f, 
    -0.00552282f, 0.27049103f, -0.01756071f, -0.16511118f, -0.21174648f, -0.02351263f, 0.21425933f, 0.19003247f, 
    -0.16947646f, 0.13873419f, 0.09663747f, -0.18154852f, 0.07931809f, -0.04427161f, -0.17830448f, -0.00846610f, 
    0.04264379f, 0.08240750f, -0.09215102f, -0.01291250f, -0.22874066f, -0.39613545f, -0.44032279f, 0.03594514f, 
    0.10855813f, -0.01878555f, 0.22118065f, -0.13800494f, -0.07506536f, -0.05531734f, 0.06068198f, -0.16695990f, 
    0.06891841f, 0.10367175f, 0.20451422f, 0.05815519f, 0.09661576f, -0.02383495f, 0.11071621f, -0.09577933f, 
    0.12451494f, -0.01739236f, -0.02577329f, -0.01586336f, 0.10474115f, 0.18444355f, -0.16575164f, -0.23402052f, 
    -0.25730842f, -0.23849002f, -0.03781191f, 0.07434583f, -0.26181132f, 0.01757603f, -0.02126225f, 0.13749015f, 
    0.04185873f, -0.04362220f, -0.24311063f, 0.12122472f, 0.00720242f, -0.26829025f, 0.04149909f, -0.03048793f, 
    -0.02473557f, -0.16146338f, -0.11781839f, -0.08573938f, -0.02712180f, 0.08286799f, 0.09396524f, -0.07257003f, 
    0.05899903f, -0.17851368f, -0.29149985f, 0.00063772f, -0.07615891f, -0.00924885f, 0.09238898f, 0.04545708f, 
    0.00490698f, 0.02376137f, 0.00117587f, 0.08642040f, 0.11127368f, -0.06895913f, 0.11609067f, -0.10328758f, 
    0.16874060f, -0.04156128f, -0.01702137f, -0.07025552f, -0.20995651f, 0.04297097f, 0.10565516f, 0.12610014f, 
    -0.00503786f, 0.18991399f, 0.12908597f, -0.27090305f, -0.09346296f, 0.03941125f, -0.11462804f, -0.08251291f, 
    -0.13819392f, -0.10466652f, 0.09540936f, 0.05853209f, 0.18889092f, -0.09777451f, -0.02686200f, -0.00634661f, 
    0.05535726f, -0.05139808f, 0.07076836f, 0.18183187f, 0.12637165f, -0.08372329f, 0.01830793f, 0.01293235f, 
    -0.08692782f, 0.38107449f, -0.21070096f, 0.14690255f, 0.21216889f, 0.11794573f, -0.10045183f, 0.13241984f, 
    0.15795380f, 0.03345142f, 0.01858345f, 0.14654139f, -0.10766988f, 0.07761025f, 0.02158853f, 0.00211262f, 
    -0.04966431f, 0.27030733f, 0.03741122f, 0.01725557f, -0.18280144f, 0.02887659f, 0.00637271f, 0.04553761f, 
    -0.14183021f, -0.06150487f, 0.08478650f, 0.04477285f, 0.30168852f, -0.08323584f, -0.07968023f, 0.06295350f, 
    0.09281973f, -0.04704797f, 0.02617012f, -0.17692184f, 0.17078418f, -0.27158836f, -0.19338864f, -0.00159671f, 
    0.18136728f, 0.06863784f, -0.39425978f, -0.13063371f, -0.07363766f, -0.00591239f, 0.27759412f, -0.13213079f, 
    0.06356296f, 0.03270072f, 0.03073108f, 0.10149536f, 0.11922546f, 0.03049590f, -0.05602203f, 0.03733150f, 
    -0.05678167f, 0.17928654f, -0.06238684f, 0.04854546f, 0.10122635f, -0.20644078f, -0.11097336f, 0.00082568f, 
    0.05995735f, 0.04733235f, -0.01027053f, 0.01238356f, -0.21185645f, -0.00604269f, -0.11079083f, -0.04625120f, 
    -0.06339044f, 0.14534836f, 0.06060718f, -0.15559891f, 0.04500354f, -0.12270197f, 0.16999400f, -0.09710682f, 
    -0.07424077f, -0.08801760f, -0.06134495f, 0.03670875f, 0.15028045f, 0.08819307f, -0.05445654f, 0.02293230f, 
    0.23609200f, 0.01325011f, 0.03788124f, 0.07348886f, 0.05338205f, -0.17803763f, -0.15337545f, -0.04900770f, 
    -0.05651250f, 0.23685060f, 0.16092415f, 0.05054744f, 0.23830751f, 0.04285632f, 0.07068347f, -0.01227366f, 
    0.02903540f, 0.07087746f, 0.21366197f, 0.03308790f, -0.00431543f, -0.05878295f, 0.15254687f, -0.00421809f, 
    -0.24819069f, 0.15535483f, 0.05187537f, 0.13814707f, 0.28091589f, 0.02958610f, 0.04492411f, -0.06368849f, 
    -0.31558818f, -0.15767679f, 0.19161610f, -0.02352847f, -0.01488429f, 0.18942949f, 0.01268010f, 0.01181320f, 
    -0.06788617f, 0.09148124f, -0.17579247f, 0.08110801f, 0.01194769f, 0.07247022f, -0.11906206f, 0.20685734f, 
    -0.11944107f, -0.04354465f, 0.08300504f, -0.21076025f, -0.14893070f, 0.18465026f, 0.00708581f, -0.15025823f, 
    0.27351967f, -0.13647054f, -0.02565347f, -0.05752742f, 0.09201903f, 0.08213152f, 0.06859186f, -0.06693662f, 
    0.00841958f, -0.17647807f, 0.14525729f, 0.20318292f, 0.08920144f, -0.05382025f, 0.05176327f, 0.10833658f, 
    -0.00146228f, -0.10121402f, -0.27296513f, -0.00678401f, 0.00585919f, 0.06421322f, 0.07457221f, 0.00795572f, 
    0.07132554f, -0.12047002f, 0.04427870f, -0.33071727f, 0.01290873f, 0.15586373f, 0.15036233f, 0.04019493f, 
    -0.14469963f, -0.22942300f, 0.00218193f, 0.22419170f, 0.01695776f, 0.15747850f, -0.00093621f, -0.10571157f, 
    -0.05550400f, -0.25459674f, 0.03953107f, 0.15388826f, -0.42512032f, -0.23758322f, -0.27721438f, -0.06699970f, 
    -0.09185898f, -0.21673372f, 0.17860334f, -0.11179274f, -0.21274133f, -0.16717024f, 0.11580806f, -0.20327321f, 
    -0.00559485f, 0.10211644f, -0.16994761f, -0.03097252f, 0.01661860f, -0.01855391f, -0.08395265f, -0.18108951f, 
    0.15708745f, 0.04144800f, -0.10546638f, -0.01280310f, 0.04910309f, -0.09783547f, 0.06221933f, 0.03236813f, 
    0.10384161f, -0.30333996f, -0.01244344f, 0.02492953f, 0.25034419f, -0.05623619f, 0.06261502f, -0.04496006f, 
    -0.15707609f, -0.32268986f, 0.05520495f, -0.22841148f, -0.26681447f, 0.10436787f, 0.02989146f, -0.10632145f, 
    -0.13146394f, -0.06885312f, -0.13206264f, -0.11482222f, 0.04149959f, -0.16338974f, -0.27751228f, 0.05173540f, 
    0.19655690f, -0.00267588f, -0.26547405f, -0.20095134f, 0.24845329f, -0.06290176f, -0.04134386f, -0.00862833f, 
    0.06944264f, 0.08873370f, 0.02345732f, 0.19272423f, -0.08741453f, 0.26626602f, 0.14312418f, 0.07639644f, 
    -0.06416822f, 0.03352292f, -0.00374336f, 0.06917086f, -0.09883223f, 0.09680148f, 0.03136147f, 0.02206584f, 
    0.05465693f, -0.17168070f, 0.09911455f, 0.12107018f, 0.16011038f, -0.20816050f, -0.25539744f, -0.06404173f, 
    -0.02984212f, -0.10667213f, 0.11776242f, -0.20300423f, -0.16614316f, 0.13221744f, 0.26328781f, -0.03888863f, 
    -0.05830495f, -0.24354228f, -0.03008521f, -0.11592336f, 0.14083111f, 0.03100620f, 0.18805334f, 0.04669377f, 
    0.40307119f, -0.19919714f, 0.15805367f, 0.15944971f, 0.00503222f, -0.01921279f, 0.02003260f, 0.09020909f, 
    -0.05222946f, -0.06390747f, 0.11785046f, -0.12999249f, -0.07961857f, -0.07004234f, -0.01454172f, 0.11536779f, 
    -0.02566844f, 0.12251689f, 0.13570550f, 0.06945426f, 0.14693159f, -0.06926096f, -0.13530090f, 0.00735997f, 
    0.01319278f, 0.08003348f, 0.09554503f, 0.10783923f, 0.26335853f, 0.05209007f, -0.02443794f, 0.07862888f, 
    -0.18293558f, 0.02504449f, -0.13395306f, -0.08381928f, -0.07790574f, 0.17757821f, 0.15303950f, 0.09513251f, 
    -0.10657402f, -0.03860700f, -0.12620990f, 0.17329107f, 0.10195709f, 0.13027321f, 0.00047095f, 0.01158270f, 
    0.07953393f, 0.15690126f, -0.05153838f, 0.10243214f, 0.00318012f, -0.09842645f, -0.06539714f, -0.05379996f, 
    0.05904093f, 0.08605579f, -0.35212332f, 0.08495954f, -0.22316283f, 0.28413320f, -0.07904480f, -0.19359158f, 
    -0.01135276f, 0.20001538f, 0.08381572f, 0.15442593f, 0.03549686f, -0.15815848f, 0.14488347f, 0.16719317f, 
    0.17320986f, 0.20021881f, -0.30542144f, -0.05185839f, -0.12044871f, -0.00155446f, 0.23237424f, -0.06098089f, 
    0.19448622f, -0.01249607f, -0.09971935f, -0.19113189f, -0.13991423f, 0.05006393f, 0.13559462f, -0.00709729f, 
    0.04845193f, 0.12476183f, -0.23211206f, -0.00373669f, 0.04594056f, 0.09980253f, -0.12172818f, 0.16708575f, 
    -0.01995648f, -0.01672802f, 0.37158886f, -0.05908450f, -0.13292296f, 0.04510548f, -0.02886346f, 0.07885399f, 
    0.03936731f, 0.13130772f, 0.05002775f, -0.15808494f, -0.26542196f, -0.17969944f, 0.26152569f, 0.24663851f, 
    -0.01370765f, 0.01722345f, -0.14646313f, 0.16999467f, -0.27061182f, -0.15203509f, -0.29916710f, 0.15212440f, 
    0.15065002f, -0.16872677f, -0.01392186f, 0.28166038f, -0.10182130f, -0.28325045f, -0.28555223f, 0.24144746f, 
    -0.03083602f, -0.09516169f, 0.23730192f, 0.02445660f, -0.30591080f, 0.14333302f, -0.50513113f, 0.21563055f, 
    0.02181436f, 0.14622663f, -0.11857881f, 0.09471700f, 0.02474822f, -0.05336395f, -0.14698902f, 0.35790661f, 
    0.00885327f, 0.05919355f, -0.16905816f, 0.02836306f, -0.15540126f, -0.00901973f, 0.15253620f, 0.04256887f, 
    0.27945450f, 0.09579748f, 0.06528669f, 0.02222880f, -0.08421140f, -0.04754602f, -0.01167724f, -0.06555159f, 
    0.02017228f, -0.20193814f, -0.38372263f, 0.25838390f, -0.01404499f, -0.08420289f, 0.03147348f, 0.02110337f, 
    -0.07985207f, -0.04715253f, 0.20674331f, -0.17402397f, 0.05248768f, -0.04552694f, 0.09595559f, 0.05943136f, 
    -0.01794852f, 0.08148999f, -0.16170214f, -0.05887755f, -0.25854242f, -0.10608466f, 0.07458377f, -0.02817138f, 
    0.28583822f, -0.19874482f, -0.05879022f, 0.04567536f, -0.01710489f, -0.03421106f, 0.27610639f, -0.01176436f, 
    -0.15372768f, -0.14011437f, -0.05660154f, 0.04507128f, 0.11628699f, 0.25606269f, 0.18895692f, -0.24362101f, 
    0.06128632f, 0.17744489f, -0.05872872f, -0.14776704f, 0.09654704f, 0.01172878f, -0.41453105f, 0.02498369f, 
    0.08064799f, 0.21151029f, -0.12239234f, -0.01104367f, 0.01519861f, -0.01207698f, 0.14384402f, 0.08797155f, 
    -0.08354062f, 0.00783093f, 0.19214410f, -0.25205696f, 0.11985748f, 0.00012200f, -0.04898102f, -0.12428465f, 
    -0.03754789f, 0.26085162f, 0.05773822f, 0.23569277f, -0.05744126f, -0.03383739f, 0.08399111f, -0.04152992f, 
    -0.08381125f, 0.06728985f, 0.00729958f, 0.04763293f, 0.04968616f, -0.08767576f, -0.07354587f, 0.08551252f, 
    0.03198591f, -0.00496480f, 0.20763782f, 0.29916587f, 0.26517716f, 0.06042907f, -0.07192340f, 0.02991715f, 
    -0.08120997f, 0.20571440f, 0.21408986f, 0.24855010f, 0.30068949f, -0.00158846f, 0.23277786f, 0.05629846f, 
    -0.07482703f, 0.12723437f, -0.05024245f, 0.16334586f, -0.19374065f, -0.22341889f, 0.04958740f, 0.07098626f, 
    0.20719390f, -0.13630794f, -0.05891189f, 0.18761262f, 0.07265537f, -0.12997070f, -0.32080910f, 0.03778881f, 
    -0.04243685f, -0.05353603f, -0.00254961f, -0.10728331f, 0.20114633f, -0.01170394f, -0.15086344f, -0.23644528f, 
    -0.03709585f, -0.13269711f, 0.01284911f, 0.11307397f, 0.15097891f, -0.10621682f, -0.01580453f, -0.12919606f, 
    -0.25313902f, -0.06114809f, -0.01292696f, 0.14048088f, -0.11050065f, -0.09614316f, -0.04525314f, -0.09924923f, 
    0.18753664f, 0.05056821f, -0.03528323f, 0.20347653f, 0.16978948f, -0.01364226f, -0.03753373f, -0.00647447f, 
    0.02796011f, 0.16564958f, -0.19545393f, -0.17190252f, -0.09231756f, 0.12441989f, 0.14366713f, -0.10973161f, 
    -0.04051388f, -0.03338094f, -0.00551151f, -0.00834925f, -0.32971734f, 0.11466253f, 0.05372117f, -0.07842931f, 
    -0.03748937f, -0.33137569f, -0.09549422f, -0.21361881f, 0.14025454f, 0.36137339f, 0.07963666f, 0.16626295f, 
    0.02441483f, -0.02848778f, 0.00318102f, 0.07701983f, -0.21353526f, 0.00840109f, -0.07614263f, -0.07231423f, 
    0.07799848f, 0.03533468f, -0.11224885f, 0.08025060f, -0.16456679f, -0.25108325f, 0.03090256f, 0.14730901f, 
    0.12888354f, -0.05624764f, 0.07203664f, -0.33871680f, -0.09595095f, 0.06542796f, 0.28599402f, -0.30691031f, 
    0.21672092f, -0.10420549f, 0.02530566f, -0.01413961f, 0.06025515f, 0.18163322f, -0.06068135f, 0.25123325f, 
    -0.03438136f, -0.34360582f, 0.08726967f, -0.09401106f, -0.06171060f, -0.06899130f, 0.02973516f, -0.01061421f, 
    0.30810338f, -0.06575642f, 0.01526826f, 0.00754398f, 0.04895674f, -0.08695156f, 0.06085514f, 0.12704846f, 
    -0.17812441f, -0.01246907f, 0.03665307f, 0.05401319f, -0.00955668f, -0.22303841f, -0.25281841f, 0.11492568f, 
    0.11210159f, 0.08933438f, -0.44454131f, -0.11087362f, -0.16829722f, 0.24336791f, 0.08348600f, 0.09908886f, 
    -0.08119528f, 0.00698575f, -0.02430065f, -0.11183269f, 0.22242698f, -0.05054403f, -0.10645697f, 0.16382353f, 
    -0.13305764f, -0.12673791f, -0.09268829f, 0.05658574f, -0.32148379f, 0.02315677f, 0.01054759f, 0.10505378f, 
    -0.04498784f, 0.09956675f, 0.08801307f, 0.00790902f, 0.00568167f, -0.18307626f, 0.16418156f, 0.04067848f, 
    -0.10845414f, 0.00102048f, -0.02140902f, -0.14698856f, -0.15848885f, -0.10891087f, 0.07254274f, -0.04960150f, 
    -0.02422338f, -0.07397564f, 0.07658430f, 0.10338447f, 0.02579768f, 0.07473671f, -0.06310253f, 0.07137343f, 
    0.03694452f, 0.09983042f, 0.05167584f, -0.07944750f, -0.08014782f, -0.22417143f, -0.06759017f, 0.04759286f, 
    0.51475292f, -0.19810840f, -0.10352428f, 0.03297731f, 0.12285733f, 0.19146164f, -0.04897103f, -0.05943419f, 
    -0.08942466f, 0.44189247f, 0.02347800f, 0.11703064f, -0.00726937f, -0.05784886f, -0.02342477f, 0.00705333f, 
    0.03087576f, 0.10795514f, 0.04373888f, 0.16030331f, 0.03065257f, -0.07953741f, -0.01277863f, 0.01402147f, 
    0.04524582f, -0.00819384f, -0.14351234f, -0.16667444f, -0.27408919f, -0.18155208f, -0.07108269f, -0.00799556f, 
    -0.00920132f, 0.02487814f, -0.03931083f, 0.01948272f, 0.05277368f, 0.20640394f, 0.04090251f, -0.16044925f, 
    0.04694286f, -0.05481885f, -0.09936873f, -0.00324102f, 0.09479935f, 0.05662272f, -0.25850818f, 0.06945439f, 
    -0.21314730f, -0.03644742f, 0.06622689f, -0.05544935f, 0.01376696f, 0.05967100f, 0.30016151f, 0.18241784f, 
    -0.03786864f, -0.03421804f, 0.00752811f, -0.02890812f, 0.01861089f, -0.19865634f, -0.11955845f, 0.19762784f, 
    -0.01587756f, -0.06828904f, 0.07588803f, 0.06629416f, -0.10531823f, 0.18808506f, -0.02162368f, -0.04008277f, 
    0.20788434f, 0.24102573f, -0.00939336f, 0.08578351f, 0.09316886f, 0.11338290f, -0.20177141f, 0.09554121f, 
    0.00422457f, -0.15753298f, -0.04525120f, -0.20559326f, -0.02697892f, -0.08869142f, 0.00011482f, -0.03472356f, 
    0.27655962f, 0.04690155f, -0.43980038f, -0.28383243f, -0.05984011f, 0.11340140f, 0.01644738f, 0.10129395f, 
    -0.16384040f, -0.03429018f, -0.06660645f, 0.13656339f, -0.36283290f, 0.02890429f, 0.07011874f, 0.12327193f, 
    -0.05109591f, 0.05235779f, -0.17227398f, 0.17870903f, 0.00201698f, 0.04327327f, 0.04851330f, 0.04706052f, 
    0.12740266f, -0.08660764f, 0.05748453f, 0.15521590f, 0.01303719f, -0.52433532f, -0.62650818f, 0.10671014f, 
    0.02225921f, 0.09124129f, -0.17606229f, 0.18465218f, -0.11144340f, 0.06454665f, -0.15626630f, -0.07862160f, 
    -0.26058382f, 0.19393356f, 0.05915496f, -0.01652363f, 0.04756430f, 0.03385414f, -0.07666961f, 0.11791757f, 
    0.22056457f, -0.04294027f, 0.04977245f, 0.11019391f, -0.15634610f, -0.06075409f, 0.19884202f, -0.17055896f, 
    -0.20450595f, 0.11796565f, 0.09800652f, 0.05567060f, 0.08475917f, 0.01995702f, -0.15896787f, -0.02357823f, 
    0.09921040f, 0.14597522f, -0.02817068f, -0.17152372f, -0.12863457f, -0.09406284f, -0.07530124f, 0.00188423f, 
    -0.00967599f, -0.09419420f, -0.09121559f, -0.02066124f, -0.16177478f, -0.06482545f, -0.02865265f, 0.20614065f, 
    0.14729385f, 0.07682703f, -0.00192183f, -0.39801192f, -0.13935351f, -0.02662176f, 0.09782466f, 0.11598209f, 
    -0.14223517f, 0.02415078f, 0.17730969f, 0.04344583f, 0.28509516f, 0.20533909f, -0.06093840f, -0.16389164f, 
    -0.05906348f, 0.01542846f, 0.07112813f, 0.02231506f, -0.00364694f, -0.24958524f, -0.10719824f, 0.09943765f, 
    0.00029940f, 0.05459671f, 0.11352219f, 0.05507626f, -0.12928772f, 0.07322699f, -0.02352173f, 0.07505066f, 
    -0.06727537f, 0.07777027f, -0.13015071f, 0.07717888f, 0.06132748f, 0.13027751f, 0.25665915f, 0.10345350f, 
    -0.11105437f, 0.02326815f, 0.04696175f, -0.15645893f, 0.04352899f, -0.10207686f, 0.08714879f, 0.15508267f, 
    -0.00944269f, -0.03742651f, -0.00040065f, 0.04547127f, -0.06422766f, 0.02310010f, 0.06794254f, -0.04623407f, 
    0.03789413f, -0.00098501f, -0.06496157f, 0.01862707f, -0.00979770f, -0.05115029f, 0.07291961f, -0.03596550f, 
    0.06075083f, -0.01692831f, -0.02694084f, -0.02713625f, -0.04686916f, 0.01288090f, 0.03481241f, 0.02020006f, 
    -0.03767272f, 0.06025210f, -0.05376853f, -0.04709282f, 0.07227546f, -0.01084067f, -0.00238155f, 0.01545315f, 
    -0.06116539f, 0.01391824f, 0.07086110f, 0.02281955f, 0.01004078f, -0.07230920f, -0.05358313f, 0.03645170f, 
    -0.07001543f, -0.01368131f, -0.06971969f, -0.00612509f, 0.07195326f, -0.02050502f, -0.05208461f, -0.06385587f, 
    0.07796927f, 0.01640701f, -0.05464641f, -0.07730135f, -0.08163308f, 0.00203746f, 0.07328252f, 0.07696304f, 
    0.02083209f, -0.08122517f, -0.06953365f, 0.00163630f, 0.03660350f, -0.04327410f, -0.03855661f, 0.06889720f, 
    0.02536838f, -0.08512118f, -0.01931421f, 0.05010760f, -0.07119434f, -0.04862516f, 0.04432422f, -0.07056449f, 
    0.00573337f, 0.07019310f, -0.09157764f, -0.01558159f, 0.01340139f, -0.02780443f, -0.06742127f, 0.07027416f, 
    0.04443515f, -0.07743245f, -0.06729764f, -0.04388445f, -0.06558757f, -0.07466602f, 0.05937076f, 0.01855693f, 
    -0.07710537f, 0.00074600f, 0.01182294f, -0.01209952f, -0.08034227f, -0.05448196f, -0.02771335f, 0.00971378f, 
    -0.01431516f, 0.01222847f, -0.00368131f, -0.01445051f, 0.06919596f, -0.00401419f, -0.01436430f, 0.00948675f, 
    -0.03151023f, 0.04171588f, -0.01555098f, -0.06214260f, 0.03290991f, -0.05187907f, -0.03123805f, -0.04651679f, 
    -0.08950893f, -0.03508353f, -0.04898402f, 0.05808208f, -0.03542398f, -0.00517778f, -0.08440308f, 0.02556440f, 
    -0.06139629f, -0.05980970f, 0.03018363f, -0.08413590f, 0.01041417f, 0.06467538f, 0.03272635f, -0.03194102f, 
    0.02941869f, -0.07804456f, -0.08706125f, 0.02844424f, 0.00535337f, -0.03858192f, 0.01889255f, 0.03412644f, 
    0.04924352f, -0.04072546f, -0.03223443f, -0.04827030f, -0.05136552f, -0.09196062f, 0.00553325f, 0.02436311f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.17181943f, -0.05114591f, 0.05040723f, -0.08083956f, -0.12589507f, 0.08296742f, 0.13310067f, 0.10468365f, 
    -0.00158077f, 0.11366374f, -0.03012945f, 0.10478269f, 0.06086194f, 0.04339187f, 0.13569203f, -0.05314314f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.36029890f, 0.01957226f, -0.02429777f, -0.55727535f, -0.25813505f, 0.25568223f, 0.35825938f, 0.19678450f, 
    0.38082296f, -0.28332829f, -0.03784205f, -0.34171918f, 0.34592414f, -0.36713645f, -0.13338196f, -0.11312443f, 
    0.02156185f, 0.04459910f, 0.23453179f, -0.49899855f, -0.19224410f, -0.00328072f, 0.15630533f, -0.24334821f, 
    -0.18292211f, -0.43788812f, 0.42582545f, 0.29325357f, 0.08144744f, 0.43044236f, 0.31937367f, 0.15216294f, 
    -0.14984652f, -0.10675763f, 0.09353602f, -0.08936937f, 0.09586731f, -0.12262935f, -0.06825298f, 0.03848192f, 
    0.11708967f, 0.12479408f, -0.09722470f, -0.23191221f, -0.25549290f, -0.11762293f, -0.13998708f, 0.16978635f, 
    -0.13710529f, 0.84408098f, -0.25583529f, 0.03939446f, 0.35302395f, -0.18560152f, -0.12783624f, -0.14335708f, 
    -0.04111557f, -0.59574205f, 0.21251515f, 0.23863603f, -0.18730634f, -0.06270792f, 0.01904943f, -0.03852153f, 
    0.21674311f, 0.34661135f, -0.04850847f, 0.45669052f, -0.28436700f, 0.24709539f, -0.21461377f, -0.15852642f, 
    -0.30574307f, 0.35607931f, 0.15313350f, 0.12411145f, 0.31672817f, -0.11092293f, -0.11489373f, -0.03529962f, 
    0.38950804f, -0.20719704f, 0.01299716f, 0.08165167f, -0.38870969f, -0.18130474f, 0.12618332f, 0.20698442f, 
    0.06467851f, -0.02807213f, -0.04784334f, 0.11976275f, 0.40205190f, -0.06320385f, -0.00996752f, 0.04134436f, 
    -0.11108337f, 0.44074756f, 0.07609541f, 0.37044966f, 0.26283717f, 0.47864553f, -0.10856123f, -0.37043512f, 
    0.00094616f, 0.55981630f, 0.13610454f, -0.05132168f, -0.06675569f, -0.33110893f, -0.04591391f, -0.21588910f, 
    -0.41059539f, 0.23246710f, 0.21582048f, -0.32614869f, 0.09602407f, 0.56729889f, 0.10573360f, 0.21100049f, 
    -0.28916067f, 0.14847249f, -0.04197633f, -0.18480001f, 0.26393133f, 0.14604452f, -0.21284467f, 0.05524189f, 
    -0.15663174f, -0.05371955f, 0.02958264f, -0.11976645f, 0.34515831f, 0.03133394f, 0.08383266f, -0.25915006f, 
    0.38545510f, -0.15209919f, 0.11591306f, 0.37505513f, 0.21510270f, 0.44446456f, -0.21330139f, -0.07461103f, 
    -0.05954401f, 0.16177021f, -0.17904940f, 0.02798748f, -0.15746328f, -0.22917768f, -0.09398665f, -0.00122072f, 
    0.07945842f, 0.02859043f, 0.00231376f, -0.01549268f, -0.10365559f, -0.20613773f, -0.04973691f, -0.14171717f, 
    0.02097887f, -0.09500196f, 0.08791757f, 0.22485910f, 0.35751304f, -0.42386305f, 0.14573286f, 0.16332957f, 
    0.12779868f, 0.42652079f, -0.30843952f, -0.38292921f, 0.18879810f, -0.31806740f, -0.50499868f, 0.11706295f, 
    -0.21592791f, 0.40917796f, -0.11020879f, 0.17387645f, -0.17542742f, 0.16591081f, -0.30199245f, 0.24975905f, 
    -0.30612779f, 0.46191853f, -0.19412510f, 0.01114137f, 0.18129028f, -0.10298213f, 0.45603147f, 0.14558113f, 
    -0.16376542f, -0.52355009f, 0.09461141f, 0.35575932f, -0.16184402f, -0.06900809f, 0.19456203f, -0.24456061f, 
    0.33702895f, -0.01471498f, 0.24176310f, -0.55661404f, 0.28580621f, -0.26505458f, 0.16017066f, 0.03355137f, 
    -0.27720484f, -0.26345319f, -0.00481302f, 0.05287769f, -0.10797625f, -0.19539654f, -0.08378381f, -0.16220525f, 
    -0.07995258f, 0.17848471f, 0.08605093f, 0.06597792f, -0.05461732f, -0.23460421f, 0.09721317f, -0.05735362f, 
    0.24983355f, 0.29525703f, -0.08016422f, -0.28918844f, 0.40105176f, -0.05314348f, 0.16597492f, 0.22171977f, 
    0.03974611f, -0.10102165f, -0.72646582f, -0.19152769f, -0.31139922f, 0.03780099f, -0.23773438f, -0.15288472f, 
    0.25630680f, 0.32372510f, -0.05321516f, -0.30972767f, 0.04217745f, 0.06329557f, -0.07083284f, 0.27863419f, 
    -0.22498314f, 0.20588903f, -0.07462917f, 0.25150311f, -0.14015909f, -0.35508621f, -0.14483912f, 0.18511105f, 
    0.31535304f, -0.40511605f, -0.11059556f, 0.25384653f, 0.39331141f, 0.10608795f, 0.17286754f, -0.01066577f, 
    0.32688293f, -0.15207586f, -0.38898623f, 0.39110518f, -0.22826241f, -0.10659908f, -0.39057985f, 0.10187379f, 
    -0.08718918f, 0.25514323f, -0.06615689f, 0.34529248f, -0.24591717f, 0.13261487f, -0.66276401f, 0.40024695f, 
    -0.36551604f, 0.42846131f, -0.05668033f, 0.24105880f, 0.11793462f, -0.22639836f, 0.26841444f, -0.12421974f, 
    -0.17029335f, -0.32697049f, -0.15749712f, 0.03820755f, 0.12849802f, -0.18314473f, 0.54251969f, -0.11279675f, 
    -0.23760942f, -0.04324178f, 0.26017311f, 0.12761810f, 0.08969980f, 0.46622857f, 0.36297828f, -0.03873226f, 
    0.10288407f, -0.44201535f, 0.12100568f, -0.13982004f, -0.03861920f, -0.15994340f, 0.23384283f, 0.03845959f, 
    0.21070614f, 0.16104555f, -0.00330009f, -0.23559175f, -0.05403424f, 0.37292156f, 0.32925647f, -0.10850427f, 
    0.17287986f, 0.04577873f, 0.00038662f, 0.35339111f, 0.12982313f, -0.37149414f, -0.02527950f, -0.22714701f, 
    0.06404716f, -0.00405340f, -0.58264416f, 0.21145211f, -0.02087407f, 0.21481553f, 0.60495842f, 0.18393804f, 
    0.02465171f, 0.48210391f, -0.04412814f, 0.09497148f, -0.17184538f, 0.28521687f, 0.01820076f, -0.14763480f, 
    0.17729458f, -0.09093372f, 0.07085538f, 0.19856086f, -0.35635319f, -0.07655343f, 0.47675139f, 0.16459578f, 
    0.11093464f, -0.38182402f, -0.23420772f, -0.53250092f, 0.13097255f, 0.31624779f, -0.02726641f, 0.31629369f, 
    0.03450083f, -0.34374502f, 0.07781174f, 0.22575356f, -0.31986600f, -0.02520725f, 0.41153800f, -0.18482262f, 
    0.06489530f, -0.21707775f, -0.09723063f, -0.00816624f, 0.12316626f, 0.31755134f, 0.13866094f, 0.44672883f, 
    -0.13656524f, -0.15945709f, -0.14734890f, -0.44539422f, 0.40263057f, 0.11731430f, -0.05155214f, -0.09365758f, 
    -0.20935561f, -0.26347777f, -0.24620430f, -0.36405373f, 0.56958175f, 0.05916798f, -0.11926729f, 0.34317872f, 
    0.44861606f, 0.09037063f, 0.36918515f, 0.02991154f, -0.13527274f, 0.13584493f, -0.24937411f, -0.14758635f, 
    0.22108978f, 0.19908799f, -0.06533553f, 0.35642177f, -0.03465104f, -0.19944488f, 0.27525476f, -0.28227004f, 
    -0.11659718f, -0.30081546f, -0.29762048f, 0.27664456f, 0.06295339f, 0.25240523f, 0.33043864f, 0.24201465f, 
    0.17304322f, 0.35832191f, 0.09526922f, 0.19966859f, 0.27005711f, 0.49444586f, -0.38260326f, 0.06454295f, 
    0.07321622f, -0.35527644f, -0.32896659f, 0.16698208f, 0.04398494f, -0.14675853f, -0.25832641f, 0.04834607f, 
    -0.23239185f, 0.16557524f, -0.10436258f, -0.09552375f, -0.06593169f, -0.11829197f, -0.05050936f, -0.02936692f, 
    -0.10986509f, -0.10756436f, 0.10815559f, 0.19814654f, -0.09265582f, -0.22616997f, -0.21367888f, -0.08185357f, 
    0.12273793f, -0.10679065f, 0.00057986f, 0.01195732f, 0.03628317f, -0.03703979f, 0.54805124f, -0.32160291f, 
    0.21547601f, -0.68621683f, 0.33079728f, -0.45097974f, 0.01039233f, 0.09901630f, -0.14045905f, -0.05177820f, 
    -0.07508520f, -0.03398725f, 0.09906688f, -0.26880267f, 0.08853390f, 0.01716339f, 0.26665011f, 0.40528047f, 
    0.27055037f, -0.23315538f, -0.38526225f, 0.25648519f, -0.07750656f, 0.48018649f, -0.00183342f, 0.04486294f, 
    0.36682737f, 0.08817095f, 0.11068179f, 0.51993048f, 0.27272198f, -0.03387892f, -0.25362730f, -0.06067733f, 
    0.28276476f, -0.35433045f, -0.43853506f, 0.26026523f, -0.06838252f, 0.23184213f, -0.23422094f, 0.07413540f, 
    0.35337541f, 0.28300273f, -0.20559880f, 0.35258591f, 0.01677020f, 0.10099716f, -0.10593718f, 0.06903540f, 
    -0.33074635f, -0.08650817f, -0.18989332f, -0.02648289f, 0.16005357f, -0.14815211f, -0.17309606f, 0.06099368f, 
    -0.00217850f, 0.16076307f, 0.08722016f, 0.55004287f, -0.15990791f, 0.16798870f, -0.31893054f, 0.41426167f, 
    0.23305584f, -0.23678505f, 0.03139819f, -0.32252470f, -0.11785924f, 0.17469406f, -0.03919991f, 0.20879191f, 
    0.04492944f, 0.09313001f, 0.05675443f, -0.11978751f, 0.17124289f, 0.37608832f, -0.19467519f, 0.42655620f, 
    -0.16501720f, 0.32250509f, 0.32982942f, -0.25316802f, 0.08844861f, -0.37463394f, -0.27966195f, 0.15521646f, 
    0.48901564f, -0.21761146f, -0.14209561f, 0.41080025f, -0.34135371f, -0.11543691f, 0.05786612f, -0.18192145f, 
    -0.24988575f, 0.46204194f, 0.31569117f, -0.11617234f, 0.24430871f, -0.22473662f, -0.03349590f, 0.06297080f, 
    -0.18745445f, 0.09431487f, 0.23746336f, -0.44667953f, 0.11533976f, 0.03314752f, 0.50004643f, 0.37188098f, 
    -0.30277216f, 0.04109411f, -0.06381736f, -0.12073977f, -0.14748491f, -0.05733758f, 0.10802924f, -0.12831742f, 
    0.39968339f, -0.21102054f, 0.03091286f, 0.31290144f, -0.14782830f, -0.52400696f, -0.04442247f, 0.23748899f, 
    -0.36152521f, -0.00742177f, -0.46035677f, 0.25273037f, 0.12347922f, 0.27238929f, 0.16630919f, 0.21271686f, 
    -0.11833674f, -0.11188466f, -0.24970707f, 0.52803004f, -0.32873344f, -0.15384677f, -0.21488591f, -0.00379546f, 
    0.20985846f, -0.08388628f, 0.00689041f, 0.40570605f, 0.20681867f, 0.39569426f, 0.01480145f, 0.07600296f, 
    -0.08312017f, 0.19741200f, 0.09894866f, 0.20819275f, 0.29907560f, -0.28164124f, 0.33147144f, -0.23839073f, 
    -0.12889762f, 0.18151569f, 0.35757291f, 0.18267800f, 0.11980060f, -0.38322476f, -0.52551866f, 0.17267528f, 
    0.32368103f, 0.17589664f, -0.21459536f, -0.02710049f, -0.10066080f, 0.12666975f, 0.03408719f, 0.06481122f, 
    -0.26749608f, -0.16102976f, -0.26458693f, -0.24437790f, 0.32356766f, -0.00002016f, 0.21671964f, 0.02364887f, 
    -0.08657455f, 0.07717164f, -0.05666974f, -0.08496837f, -0.14184786f, -0.18903781f, -0.06486795f, 0.07592545f, 
    -0.11057382f, -0.12129629f, -0.08145341f, 0.08189788f, -0.19408101f, 0.08420362f, -0.15702127f, 0.02046555f, 
    0.36654165f, -0.04301289f, -0.13700373f, 0.06801271f, -0.23503833f, -0.18180206f, 0.33307177f, 0.01654316f, 
    -0.33842003f, 0.31876537f, 0.29942262f, -0.13964060f, 0.16860206f, -0.32025987f, 0.02220742f, 0.08563872f, 
    0.29635718f, 0.08782656f, 0.07626752f, -0.13485402f, 0.39666107f, 0.31075993f, 0.22738704f, -0.17237371f, 
    0.13401045f, -0.28862417f, 0.16118915f, -0.20887171f, -0.36562720f, 0.09457095f, -0.12681638f, 0.20898226f, 
    0.22522222f, -0.42163473f, -0.19365123f, -0.19301859f, -0.14317881f, 0.40035090f, 0.20596583f, -0.20633233f, 
    0.27019936f, 0.08105385f, -0.36817667f, 0.34148681f, 0.37491763f, -0.27809417f, -0.13232194f, 0.08302494f, 
    -0.06146098f, 0.09726662f, 0.09196732f, 0.11851148f, -0.06558757f, -0.29345492f, 0.05525639f, 0.31317389f, 
    0.06642327f, -0.30158696f, 0.20041126f, -0.35894793f, 0.10598399f, 0.50554162f, 0.46295470f, 0.12893270f, 
    0.03585297f, 0.02161728f, 0.15134259f, -0.16172802f, -0.19576073f, -0.22012489f, 0.42653757f, 0.34792617f, 
    0.30135703f, -0.17044152f, -0.14340761f, -0.22833684f, 0.16380517f, 0.44517875f, 0.23097205f, 0.06348687f, 
    0.10584027f, -0.13523699f, 0.07632304f, -0.19990896f, 0.02560323f, 0.34807926f, -0.11067335f, -0.12463918f, 
    -0.10069212f, -0.53170544f, 0.41144738f, 0.31715477f, 0.01021745f, -0.37666646f, 0.53286701f, -0.23095509f, 
    0.04940120f, -0.14824198f, 0.12518500f, -0.35201102f, -0.02076668f, -0.14976940f, 0.19722036f, 0.17196228f, 
    -0.05444809f, -0.03835160f, 0.39762896f, -0.12114173f, 0.03562214f, 0.24456225f, 0.18090090f, 0.11136389f, 
    -0.21835911f, -0.08370566f, 0.22357294f, 0.01614249f, -0.20357901f, -0.12419042f, 0.22824025f, -0.14167583f, 
    0.09567222f, -0.07100081f, 0.05878112f, 0.05814081f, -0.23333853f, -0.24386287f, -0.05069947f, -0.20836160f, 
    0.20337711f, 0.03599856f, 0.09191999f, 0.17763846f, 0.12330559f, 0.16902705f, 0.28318724f, 0.38381660f, 
    0.22974050f, 0.13567786f, -0.42934090f, -0.16569626f, -0.20822980f, -0.24099056f, -0.39112261f, -0.20733537f, 
    -0.02666891f, -0.05118972f, 0.15242514f, 0.03282765f, -0.20906454f, -0.12988356f, -0.12249786f, -0.20752767f, 
    -0.23000851f, 0.19500229f, -0.13358760f, 0.03322372f, -0.17744619f, 0.04592749f, -0.07318035f, 0.03524163f, 
    -0.08275430f, -0.12650348f, 0.08203825f, -0.19936416f, -0.16790520f, -0.18624692f, 0.42243183f, 0.13719651f, 
    0.03556550f, 0.00019327f, 0.37320009f, 0.40623292f, 0.16186284f, 0.31213796f, -0.01579153f, -0.04874623f, 
    -0.07815028f, -0.32828394f, -0.17209035f, -0.31810138f, 0.54855198f, -0.01112932f, 0.43743524f, 0.44538507f, 
    -0.35887504f, -0.11228833f, -0.14716806f, 0.21181938f, 0.23666327f, 0.31001881f, -0.47918731f, -0.03188878f, 
    0.09298848f, -0.14127339f, -0.05260573f, 0.28056574f, -0.32329500f, 0.29052725f, 0.03117043f, -0.00356868f, 
    -0.13775441f, 0.20229487f, -0.38177240f, -0.38199258f, -0.11144336f, 0.55133271f, 0.21302022f, 0.16155639f, 
    0.06831914f, 0.51656061f, -0.22439151f, 0.02286078f, 0.19193503f, 0.35704407f, 0.10921995f, 0.33481440f, 
    -0.18838519f, -0.29674342f, 0.06529625f, 0.16090330f, -0.06977859f, -0.17873214f, -0.50374675f, 0.24423370f, 
    0.31924433f, -0.17396104f, 0.21939157f, -0.09862901f, -0.33229715f, -0.29370913f, 0.15155824f, 0.22698495f, 
    -0.05386662f, 0.06914587f, -0.24177001f, 0.30611375f, 0.31275779f, 0.21145691f, 0.04548419f, -0.13040164f, 
    0.00479591f, 0.26522368f, -0.24308828f, -0.27509847f, 0.30254757f, -0.22013080f, 0.14600337f, -0.27610695f, 
    0.40781787f, -0.10124184f, 0.27573428f, 0.19064696f, 0.03678326f, 0.34938210f, 0.09916537f, 0.21923605f, 
    0.21303636f, -0.09841544f, -0.11078554f, 0.52085173f, 0.24946871f, -0.11512961f, -0.24134445f, -0.50831944f, 
    -0.59534585f, -0.07938665f, 0.12263928f, 0.01565560f, -0.02235061f, 0.26973799f, -0.30042630f, -0.19850686f, 
    0.36399880f, -0.12081512f, 0.08024908f, -0.38516480f, -0.27511352f, -0.15645081f, 0.22829507f, -0.20923965f, 
    0.38604021f, -0.29011363f, -0.22293916f, 0.13489442f, 0.46348840f, 0.02087517f, 0.20961024f, -0.03093054f, 
    0.13729712f, 0.31313288f, 0.00913092f, -0.39541820f, 0.03248912f, -0.00584046f, -0.04140661f, -0.02876084f, 
    -0.15247400f, 0.35073388f, -0.33252868f, -0.18169479f, -0.18913528f, 0.50682831f, -0.30281776f, -0.03066006f, 
    -0.19692995f, -0.25652766f, -0.13788536f, 0.03765514f, -0.05888090f, 0.00064640f, 0.05303040f, -0.18852131f, 
    -0.14310052f, 0.19201761f, -0.14905630f, -0.22004119f, -0.25227538f, -0.23966897f, 0.08675712f, -0.06384009f, 
    -0.19919802f, -0.16344513f, 0.07999651f, -0.38151833f, 0.20694321f, -0.12853065f, 0.45415479f, -0.25166062f, 
    0.13078299f, 0.15192910f, -0.24934807f, 0.50335300f, 0.30304617f, -0.34433651f, 0.42781264f, -0.22929716f, 
    0.31805313f, 0.40503407f, -0.02919114f, 0.50253248f, 0.17989063f, 0.08989202f, -0.32384259f, -0.20300487f, 
    0.18474434f, -0.28494251f, -0.09586730f, -0.19902918f, -0.10176795f, 0.13131741f, 0.17162344f, 0.16859883f, 
    0.06497455f, -0.15440689f, -0.24197513f, 0.28805584f, -0.01021675f, -0.39224392f, -0.20591475f, 0.16167660f, 
    0.09135494f, -0.30174685f, -0.30045006f, 0.21607655f, 0.33090979f, 0.20522575f, 0.31071302f, 0.09992065f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.46409357f, 0.09631726f, -0.15809582f, 0.33035281f, -0.02410831f, -0.12800898f, -0.11996189f, 0.10120359f, 
    0.00756407f, -0.10378113f, 0.28880715f, -0.02732426f, -0.13973206f, -0.24450028f, 0.06503417f, 0.36553201f, 
    0.06602708f, 0.13876797f, 0.05068589f, 0.12523039f, 0.15565328f, 0.48083290f, 0.61380607f, 0.32007831f, 
    -0.00515974f, 0.40656275f, 0.04342275f, 0.02808960f, 0.25100669f, 0.34089452f, -0.18151045f, 0.29473266f, 
    0.13419019f, 0.15697213f, 0.51753557f, 0.72642589f, 0.22202845f, -0.10897514f, -0.09264284f, 0.47134265f, 
    0.05773894f, 0.34996432f, 0.16454999f, 0.50509351f, -0.08389020f, 0.26104942f, 0.38705659f, -0.16585115f, 
    -0.09340557f, 0.52044398f, -0.10054114f, -0.03186055f, -0.02760870f, 0.15006700f, 0.04871660f, 0.34687510f, 
    0.15284738f, -0.32256699f, 0.31277138f, -0.04233345f, 0.01976282f, 0.19692382f, -0.14764819f, -0.10106888f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.61641157f, -0.18484785f, -0.11720172f, 0.23129566f, 0.23614398f, 0.10211543f, 0.31966445f, 0.00205345f, 
    0.07853978f, -0.01534185f, -0.29802644f, 0.35725451f, -0.28596658f, 0.07577418f, -0.50365573f, -0.13686420f, 
    -0.18687306f, 0.44397402f, 0.05006374f, 0.15524174f, 0.44026968f, 0.10746446f, -0.48032147f, -0.16289033f, 
    -0.20297720f, 0.07909121f, 0.13806176f, 0.05545582f, -0.67128187f, -0.08640768f, 0.08862611f, 0.08900981f, 
    0.25207099f, 0.07069865f, 0.04879903f, -0.53378618f, 0.34004179f, 0.62994426f, -0.25946561f, 0.04888903f, 
    0.11540687f, -0.18434919f, -0.44959652f, -0.10243393f, 0.10319690f, -0.07998384f, -0.22774152f, -0.08229486f, 
    -0.12309417f, -0.03945474f, 0.09955932f, -0.00448209f, -0.35304973f, 0.00959440f, -0.14702646f, 0.01935815f, 
    0.11936355f, 0.12957659f, 0.03491514f, -0.29835817f, 0.01393476f, 0.23788343f, 0.19731280f, 0.47753358f, 
    0.00608552f, 0.10020383f, -0.00727813f, -0.17718048f, -0.04920898f, 0.16187522f, -0.18472756f, 0.23991442f, 
    0.22307329f, -0.00561810f, -0.07477742f, -0.12782209f, -0.26768455f, -0.05435957f, 0.00827924f, -0.24361408f, 
    0.25699729f, -0.13562623f, 0.17112140f, 0.16330732f, 0.09532771f, -0.42415911f, -0.40084288f, 0.29839706f, 
    0.14249188f, -0.04841584f, -0.00029878f, 0.11659414f, -0.09001841f, 0.23053248f, 0.27059862f, -0.07309052f, 
    0.03460915f, -0.13052632f, -0.05635584f, -0.38547555f, 0.18049340f, 0.31706533f, -0.10175586f, -0.06311405f, 
    -0.03542402f, -0.10673789f, -0.11725949f, 0.15871096f, 0.15432334f, 0.21214095f, -0.23279206f, 0.18366607f, 
    0.03739026f, -0.09782556f, -0.04652835f, 0.19654574f, 0.50953734f, -0.00349686f, -0.04042896f, 0.08044835f, 
    0.02931861f, 0.26158696f, 0.15446573f, -0.37374863f, 0.00673223f, 0.25524244f, 0.03521042f, 0.48942596f, 
    -0.70170575f, 0.24173078f, -0.07334177f, 0.45078763f, 0.04249072f, -0.17844006f, 0.05617834f, 0.08468762f, 
    0.03722058f, 0.10261662f, 0.04585514f, 0.32531542f, -0.16248892f, -0.13877773f, 0.31722701f, -0.19422710f, 
    0.04060829f, 0.15526715f, 0.21931201f, 0.22466683f, 0.18882677f, 0.26531941f, -0.09153354f, -0.01648582f, 
    0.13090454f, 0.15500911f, -0.09876906f, -0.09759282f, -0.11879412f, 0.27114859f, 0.09569052f, -0.18071443f, 
    0.16932529f, -0.05652281f, -0.31214309f, -0.10033429f, -0.17806597f, -0.04619238f, 0.17449832f, -0.21292453f, 
    0.08908920f, -0.25506312f, 0.13992603f, -0.33237883f, 0.28425190f, 0.22839692f, -0.09345153f, -0.00114886f, 
    0.01147045f, 0.08151709f, 0.01478986f, 0.18159625f, -0.12546264f, 0.65438485f, 0.05142018f, -0.14406210f, 
    0.10646387f, -0.42900354f, -0.23617657f, 0.07180080f, 0.01947463f, -0.00533158f, 0.18075992f, 0.05140401f, 
    0.39868659f, -0.22623868f, 0.14500380f, -0.00893526f, 0.26908359f, 0.23909715f, 0.17944412f, -0.09593577f, 
    0.02481746f, -0.02039568f, 0.02258720f, -0.11780670f, 0.11782341f, -0.07145090f, 0.13833025f, 0.30049995f, 
    0.38667753f, -0.08388743f, -0.26628369f, -0.26159188f, -0.11844012f, -0.19342501f, -0.05799360f, 0.16861397f, 
    0.01168049f, -0.05981200f, 0.17389460f, 0.00730626f, -0.48142835f, -0.11595754f, 0.46443596f, 0.30574712f, 
    0.09285080f, 0.15549894f, 0.17514648f, -0.22157478f, 0.03699580f, -0.05220362f, 0.39136359f, 0.03324325f, 
    -0.04021508f, 0.13940717f, 0.06494118f, 0.14265944f, -0.03699008f, -0.19972257f, -0.05045331f, -0.01613639f, 
    -0.06171365f, 0.13939649f, -0.09286417f, -0.09773657f, 0.02796076f, -0.33191851f, 0.26718721f, 0.11366869f, 
    0.01151717f, 0.64063746f, 0.17220792f, 0.03682309f, 0.09142435f, -0.44831720f, 0.23833737f, 0.15097724f, 
    -0.09759073f, -0.00992313f, -0.02863472f, -0.04405103f, -0.17919834f, 0.07819973f, -0.27135286f, -0.65615684f, 
    -0.16317669f, -0.14848053f, -0.20416355f, -0.27599272f, -0.23423515f, 0.04527078f, 0.18940879f, 0.05403818f, 
    0.44664210f, -0.04783643f, -0.03226145f, 0.05587899f, 0.31885475f, -0.20298338f, 0.09626109f, -0.11330083f, 
    -0.24539170f, 0.15783407f, 0.13475981f, 0.05291289f, -0.33291227f, 0.21265094f, 0.45178932f, 0.13324209f, 
    0.01976677f, -0.17562097f, 0.08953623f, -0.14213003f, 0.30830219f, -0.04709097f, -0.05925785f, -0.10372787f, 
    -0.05540731f, -0.10105713f, 0.11270548f, 0.17306012f, -0.06070936f, 0.01018498f, 0.21680866f, -0.26859546f, 
    0.00316700f, 0.24261712f, -0.01357380f, -0.11214135f, 0.22072715f, 0.07828862f, 0.08958300f, 0.14259622f, 
    -0.07504630f, 0.01630254f, 0.00429140f, -0.19822060f, 0.03896659f, -0.17143366f, 0.13909382f, 0.14356653f, 
    -0.50004673f, 0.31935695f, -0.06075861f, 0.00440819f, -0.10738823f, 0.10507613f, -0.02347594f, 0.10034562f, 
    0.38999799f, 0.07594974f, -0.40468892f, -0.16741689f, -0.10359269f, -0.01367535f, -0.26655826f, -0.46466646f, 
    -0.09922095f, -0.10279328f, 0.32294586f, 0.06436674f, -0.00081700f, -0.04554800f, -0.02413485f, -0.13129270f, 
    0.18440859f, 0.17337555f, -0.05970407f, 0.06609571f, 0.20751548f, -0.01070675f, 0.32993212f, -0.31435972f, 
    -0.10116127f, -0.09355205f, -0.05352009f, -0.51917249f, 0.10244567f, 0.52604789f, -0.13226198f, -0.30385455f, 
    0.11397706f, -0.25018272f, 0.17573747f, -0.55377465f, 0.21492530f, -0.09175756f, 0.22841567f, 0.32291839f, 
    0.11254312f, -0.82494587f, -0.01445995f, 0.36453152f, 0.06904473f, -0.23391728f, -0.07226299f, 0.20757225f, 
    0.25335398f, -0.04199135f, 0.08940164f, -0.41276574f, -0.08653229f, -0.10577097f, 0.10589340f, 0.34956175f, 
    0.03917608f, 0.15077667f, -0.02874180f, 0.13022439f, 0.02587801f, 0.20236465f, -0.13198726f, -0.05282295f, 
    -0.29067311f, 0.08406193f, -0.12988040f, 0.25525263f, -0.18814388f, -0.10665183f, -0.78685969f, 0.03314732f, 
    -0.71044993f, 0.28183606f, 0.08518127f, 0.06901903f, -0.03270213f, 0.11431646f, -0.17265402f, 0.02777743f, 
    -0.42641982f, 0.02296450f, -0.41396403f, -0.02713591f, 0.55642861f, -0.12543288f, -0.46038479f, 0.09091282f, 
    0.18123405f, 0.04520858f, 0.32570913f, -0.02666852f, -0.06822365f, -0.14149652f, -0.05244274f, 0.26614788f, 
    0.04099018f, 0.38396585f, -0.17817980f, -0.27804846f, 0.27138945f, 0.19010562f, 0.16684726f, 0.05448848f, 
    -0.10951620f, -0.25907195f, -0.03562966f, 0.18726218f, -0.45354062f, 0.23894362f, -0.08276267f, 0.05869640f, 
    -0.05852327f, -0.86423200f, 0.33853078f, -0.35044336f, -0.06159608f, 0.05860170f, -0.02177844f, 0.04304883f, 
    -0.05655743f, -0.13936135f, -0.06881523f, -0.06293176f, 0.08559608f, -0.04252922f, -0.02919677f, 0.01214604f, 
    -0.11336514f, -0.10529292f, 0.03095318f, -0.12763371f, -0.05347528f, -0.03787929f, 0.00395679f, 0.01769213f, 
    0.06024031f, 0.07608642f, -0.12826738f, -0.11698554f, -0.12923801f, -0.04618778f, 0.03101588f, 0.00125894f, 
    -0.01551565f, -0.14099735f, 0.03647107f, 0.09665042f, 0.01704423f, 0.02211483f, 0.00940293f, -0.14457498f, 
    0.05985489f, 0.06992342f, -0.09457929f, 0.02558608f, 0.08747834f, 0.02033551f, -0.03468435f, 0.02678226f, 
    0.03928590f, 0.01927394f, 0.01948666f, -0.03056324f, -0.07620104f, -0.10143260f, -0.04566855f, 0.08585785f, 
    -0.03874186f, 0.08801703f, -0.01128364f, -0.07835064f, -0.11320096f, 0.12228346f, -0.13152790f, -0.13452762f, 
    0.05533246f, -0.02154659f, 0.09394201f, 0.03522842f, -0.01108749f, 0.03965669f, -0.08582430f, -0.01334246f, 
    0.10748839f, -0.04092775f, 0.00277308f, -0.00910088f, 0.15527359f, 0.15226969f, -0.01050748f, 0.10210542f, 
    -0.38676065f, 0.09638856f, -0.21596815f, 0.34570017f, -0.30923313f, 0.00624353f, -0.50288999f, -0.01694505f, 
    -0.76865005f, 0.20070794f, -0.02320972f, 0.13372925f, 0.14822605f, 0.14535561f, -0.10659238f, -0.10709092f, 
    -0.44533142f, 0.17093864f, -0.17246030f, -0.01452285f, 0.70216304f, -0.08637296f, -0.46128768f, 0.17409420f, 
    0.11731112f, 0.00892178f, 0.28818449f, 0.06741157f, 0.13280310f, -0.02144601f, -0.29521254f, 0.32633755f, 
    0.09753250f, 0.27106380f, -0.26672614f, -0.11095896f, 0.26340222f, 0.13852777f, -0.11547170f, -0.00226796f, 
    0.12366897f, -0.11067795f, 0.05861022f, -0.05457142f, -0.47420549f, 0.31697938f, -0.23452102f, 0.22950418f, 
    0.03182574f, -0.22755179f, 0.11794958f, 0.06845555f, 0.00457470f, -0.13590476f, 0.02017551f, 0.17641830f, 
    -0.19461551f, -0.35545939f, -0.13159178f, 0.19455351f, 0.17726377f, 0.07736079f, 0.27452996f, 0.09711237f, 
    -0.42855078f, 0.09894978f, -0.05933718f, 0.24983440f, 0.08181819f, 0.05167056f, 0.03865026f, -0.04489923f, 
    -0.28187144f, 0.13877274f, 0.12827200f, 0.18549672f, 0.22433653f, 0.20217688f, -0.28007001f, 0.25204667f, 
    -0.18563919f, 0.06840546f, -0.03778272f, 0.00843400f, 0.08657833f, -0.26175448f, 0.07749944f, 0.19432828f, 
    0.46122503f, 0.17659503f, 0.22796100f, 0.15647200f, 0.18029872f, 0.06052501f, -0.07768367f, 0.19692293f, 
    -0.07179336f, 0.17171480f, 0.13045225f, -0.29766092f, 0.23563837f, -0.01889657f, -0.04973279f, -0.06256493f, 
    -0.02850790f, 0.14696020f, 0.02983305f, -0.33624145f, -0.22755884f, 0.53186840f, 0.18423177f, -0.05049836f, 
    -0.28906655f, -0.40246123f, -0.22367147f, 0.16111742f, -0.08437947f, -0.27198672f, 0.23081742f, 0.06399601f, 
    0.05603981f, -0.00419151f, 0.08850671f, 0.00735099f, -0.06091746f, -0.08222494f, -0.03321434f, 0.06920354f, 
    -0.02836273f, -0.06316559f, -0.10544865f, -0.09384508f, -0.04837252f, 0.10040633f, -0.04825715f, -0.19279452f, 
    -0.16416347f, -0.16582942f, -0.00442473f, -0.00866181f, 0.08374067f, -0.07367279f, 0.09339333f, -0.01172389f, 
    -0.12449510f, -0.02858350f, -0.07874165f, -0.05221231f, -0.01683784f, -0.04103156f, -0.01148187f, -0.13013573f, 
    -0.02019945f, -0.12187417f, 0.04610196f, -0.02295487f, -0.15411159f, -0.01823241f, 0.05949035f, -0.14718631f, 
    -0.06105261f, 0.01026932f, -0.14526062f, 0.02168451f, 0.07690430f, 0.06003254f, -0.13193272f, 0.05945373f, 
    -0.01913626f, -0.02104537f, 0.01271331f, -0.05822284f, 0.00205201f, 0.14803988f, -0.16861059f, -0.00975442f, 
    -0.09528555f, 0.02212214f, -0.07651077f, -0.07112551f, 0.00493249f, -0.17843556f, -0.09213323f, -0.13353921f, 
    -0.19533643f, 0.13367674f, -0.11746889f, 0.35055798f, 0.00640936f, -0.19031100f, -0.02625750f, 0.01269819f, 
    0.09236868f, 0.02116969f, -0.10816986f, 0.00432762f, 0.33531502f, -0.09795352f, -0.41544661f, 0.36207849f, 
    -0.08039690f, 0.24672382f, 0.13547766f, -0.04375347f, 0.03708804f, 0.08438260f, 0.31156385f, -0.09429469f, 
    -0.05090884f, 0.15104729f, 0.09006981f, 0.10429415f, -0.08146780f, 0.08384033f, -0.27453470f, 0.10653776f, 
    -0.08149667f, 0.12342755f, -0.05371820f, 0.30954921f, 0.28754508f, -0.16283667f, 0.30990437f, 0.18727651f, 
    -0.11554629f, 0.13442844f, -0.10092597f, 0.33138552f, -0.24820197f, -0.16202664f, 0.15407991f, -0.14948291f, 
    0.04516417f, 0.12512149f, 0.01754078f, -0.09622777f, 0.17784239f, -0.37671700f, 0.17694944f, 0.04321320f, 
    -0.02521719f, 0.86927277f, -0.12611397f, 0.17420387f, -0.01367987f, 0.39825237f, -0.14960413f, -0.09586255f, 
    -0.01453344f, 0.08565196f, 0.11994494f, -0.04160748f, -0.12649497f, -0.09535459f, -0.05658773f, -0.09955972f, 
    -0.02496832f, 0.03010151f, 0.05103521f, -0.09903679f, -0.01384726f, 0.00833687f, 0.04096639f, -0.11218595f, 
    -0.00185437f, -0.01442498f, 0.03837261f, -0.04273498f, 0.04398590f, 0.03951460f, 0.02148927f, -0.10975886f, 
    -0.08761381f, -0.05711647f, -0.13632700f, 0.08510964f, 0.10693930f, 0.00923748f, 0.08787803f, -0.07894912f, 
    -0.00597085f, 0.01558603f, 0.10094445f, -0.05948599f, 0.08825492f, -0.00176761f, -0.00626004f, 0.02683772f, 
    0.02185793f, -0.06166714f, -0.12457235f, -0.00468447f, 0.08829007f, -0.12940417f, 0.03135044f, -0.15071675f, 
    0.06501618f, 0.01236960f, -0.11987211f, -0.00763444f, 0.07079072f, 0.07769535f, 0.04989600f, 0.04791176f, 
    -0.06750641f, 0.05237094f, -0.07557274f, 0.05161922f, -0.11149769f, 0.05975556f, -0.05095108f, -0.01097482f, 
    0.05522108f, 0.03350266f, -0.04116611f, 0.21277475f, 0.21249034f, 0.15737922f, -0.08904058f, 0.16010396f, 
    0.04661545f, 0.03821414f, -0.14545694f, 0.20111871f, -0.20944870f, 0.05504457f, -0.45179003f, 0.02748335f, 
    -0.38764867f, 0.20686930f, 0.24365166f, 0.05916719f, -0.22275117f, -0.01642600f, -0.22991520f, 0.11213195f, 
    -0.09609217f, 0.15478808f, 0.02787851f, -0.03474695f, 0.19870490f, 0.10747288f, -0.22904721f, 0.10487024f, 
    0.08339200f, 0.06154406f, 0.14535652f, 0.19852391f, 0.44392508f, 0.30888015f, 0.04607821f, 0.12398839f, 
    0.01743267f, 0.14807048f, -0.24343443f, -0.07562024f, 0.16030933f, 0.17239314f, -0.21763206f, 0.07694469f, 
    0.07084572f, -0.15056685f, -0.10333689f, 0.11752645f, 0.14621767f, -0.00051978f, 0.13630107f, 0.09505599f, 
    -0.09900422f, 0.12070145f, -0.06099066f, 0.13077191f, 0.10827265f, -0.04719267f, 0.01580982f, 0.13595462f, 
    -0.02934905f, -0.38262561f, 0.07702812f, -0.68171573f, 0.05118624f, 0.15149219f, -0.06771220f, -0.61594427f, 
    -0.54330724f, 0.03263518f, 0.33979675f, 0.04836541f, 0.59641695f, 0.07747485f, 0.48740783f, 0.02132491f, 
    0.28234866f, 0.22092491f, -0.27097210f, 0.09396635f, 0.48932415f, -0.01429855f, 0.17461458f, 0.06516999f, 
    -0.38010657f, 0.23276134f, -0.12791614f, -0.01893960f, -0.66144651f, -0.23408099f, 0.13279584f, 0.14147516f, 
    0.06713747f, 0.00813292f, 0.57390481f, -0.33681098f, 0.33067718f, -0.02094209f, -0.28740743f, 0.23320559f, 
    0.00868456f, 0.20732738f, 0.08581234f, 0.28573105f, -0.16521150f, -0.13030891f, 0.11651752f, -0.36658823f, 
    -0.11039174f, 0.32269540f, 0.02510677f, -0.42003644f, -0.09722354f, 0.24968383f, -0.13347322f, 0.25756091f, 
    -0.41798782f, 0.06508805f, 0.12971319f, 0.12919433f, 0.06680569f, -0.02310848f, 0.04733215f, 0.13760452f, 
    -0.23589256f, 0.06769904f, 0.08967229f, 0.20791581f, -0.11527116f, -0.04984096f, 0.03023707f, -0.06222153f, 
    0.03591719f, 0.13934673f, -0.02364673f, -0.05417230f, 0.38813284f, -0.13244817f, -0.00767267f, -0.00347910f, 
    -0.00466190f, -0.07485048f, 0.35965005f, 0.21491957f, 0.22711058f, 0.15886024f, 0.36869228f, -0.06268058f, 
    0.06352188f, 0.26710159f, -0.22344916f, -0.08005272f, 0.48879084f, 0.24881046f, -0.07610243f, -0.04259455f, 
    -0.31680843f, -0.08980285f, 0.02542132f, 0.25820607f, 0.14035247f, 0.05078664f, -0.19830413f, -0.09455133f, 
    -0.11953964f, -0.03360612f, 0.13298462f, 0.31587645f, -0.17002776f, -0.05781372f, 0.12541234f, -0.04738421f, 
    -0.04113108f, 0.05558003f, 0.08725207f, 0.23168007f, 0.15884840f, -0.12811212f, 0.11958941f, 0.17425555f, 
    0.12396599f, 0.43689895f, -0.08845134f, 0.17734647f, 0.00631788f, 0.32454348f, -0.15169196f, -0.17059283f, 
    -0.27736092f, 0.03470397f, -0.00493673f, -0.16512288f, 0.04500827f, 0.24734443f, -0.25080720f, -0.57707447f, 
    0.05140943f, -0.00003806f, 0.09567709f, -0.12719841f, 0.21856077f, 0.00824160f, 0.51281071f, -0.15871356f, 
    -0.02020235f, 0.01307227f, 0.07181697f, 0.17571163f, 0.55916780f, -0.11220421f, -0.14760727f, -0.26927039f, 
    -0.28643706f, 0.31330582f, -0.22921990f, -0.00712061f, 0.14400689f, 0.25346211f, 0.39994192f, 0.11357218f, 
    -0.14654446f, -0.50530988f, 0.19184770f, -0.15424246f, 0.64782089f, 0.43530834f, -0.39786851f, -0.05356552f, 
    0.07665527f, 0.00564646f, -0.22044909f, 0.09884339f, 0.08253636f, 0.28219482f, -0.31556764f, 0.08758927f, 
    0.08551992f, -0.07969899f, 0.08079763f, 0.19009835f, -0.11594869f, -0.00304488f, -0.33346537f, 0.18968217f, 
    0.21203728f, 0.42288440f, 0.31081039f, 0.01848907f, 0.08308650f, 0.04416852f, 0.14966454f, 0.60520083f, 
    0.02876632f, 0.00556671f, 0.01169643f, -0.08030231f, 0.07991088f, -0.12953030f, -0.02876155f, 0.04781662f, 
    -0.03869925f, 0.03311434f, -0.12230268f, 0.03792352f, 0.04895274f, 0.10387954f, 0.02469142f, -0.02819234f, 
    0.07292432f, -0.08476269f, -0.05775234f, -0.03033579f, -0.07160903f, -0.10503117f, -0.05181465f, 0.08796643f, 
    -0.03693457f, -0.05260144f, -0.11401410f, -0.03374822f, 0.13178787f, 0.00137987f, -0.03687680f, -0.03353361f, 
    -0.16994259f, -0.12742539f, -0.09694851f, -0.12432141f, -0.01616219f, -0.01725773f, -0.06997342f, 0.08262116f, 
    -0.05001810f, 0.00234471f, 0.03388396f, -0.04341645f, -0.16217795f, -0.01965108f, -0.11077371f, 0.05576427f, 
    -0.01446013f, -0.09953864f, 0.06527773f, -0.02675335f, -0.07456853f, -0.07996202f, -0.03768926f, -0.11872487f, 
    0.07718755f, -0.08976832f, 0.06412723f, 0.09442252f, 0.06231703f, -0.00305360f, 0.08760854f, 0.01132909f, 
    0.07970957f, 0.06955310f, -0.10132067f, -0.03511584f, -0.12293643f, 0.00483451f, -0.13595526f, -0.12065537f, 
    -0.09145787f, -0.00032721f, -0.06106955f, -0.06887606f, 0.01607156f, 0.09999618f, -0.09520929f, -0.13603172f, 
    -0.09069124f, 0.02119397f, -0.05502573f, -0.12184530f, 0.06522886f, 0.07430183f, -0.08636811f, -0.06035213f, 
    -0.02499378f, -0.07910967f, -0.01805726f, -0.10506053f, 0.06925505f, -0.05621031f, -0.09993811f, 0.02132089f, 
    -0.08070001f, 0.03802848f, 0.02766412f, 0.09264071f, -0.14688948f, -0.01449086f, -0.05558342f, -0.02722647f, 
    0.04062168f, -0.11541761f, 0.05748567f, -0.13522658f, -0.15782121f, -0.10530812f, -0.10646559f, -0.05545681f, 
    -0.01760991f, 0.01516554f, 0.01715170f, 0.04326775f, -0.03666876f, 0.11130662f, 0.02535319f, 0.03954383f, 
    0.01883720f, 0.02291642f, -0.13731575f, 0.11886008f, 0.05726673f, 0.06165180f, -0.07508948f, -0.13318817f, 
    0.19500500f, 0.02260256f, 0.07314659f, 0.18618450f, 0.21710256f, 0.02693178f, -0.19652304f, -0.13321042f, 
    -0.05878411f, 0.04433722f, -0.35766318f, 0.09141059f, -0.48061296f, -0.06803781f, -0.42995477f, -0.03651082f, 
    -0.19476986f, 0.07967984f, -0.03613375f, 0.11816483f, 0.08573434f, 0.09165612f, -0.37675980f, 0.25334209f, 
    -0.29656115f, 0.22094597f, 0.13056244f, -0.08036812f, 0.14827131f, 0.11701968f, 0.14663048f, 0.14639010f, 
    0.44462371f, -0.13829648f, 0.19280080f, 0.00621092f, 0.24564581f, 0.36007005f, -0.20610297f, 0.24112789f, 
    0.12266920f, 0.21858878f, -0.20818564f, 0.03938085f, 0.28531998f, 0.16623513f, -0.18542546f, 0.08331675f, 
    -0.12144037f, 0.02096023f, 0.00591782f, -0.00456679f, 0.00963474f, 0.33101606f, 0.15032451f, 0.09522943f, 
    -0.22658844f, -0.18490770f, 0.16401386f, -0.15935028f, -0.05442186f, -0.33871549f, -0.00753527f, 0.21099778f, 
    0.37325844f, -0.07685328f, -0.13451990f, -0.16820617f, -0.00701508f, 0.39196205f, -0.27199632f, -0.11456319f, 
    -0.06569814f, -0.15219918f, -0.23570313f, -0.12423743f, -0.36161479f, -0.02854626f, 0.16939837f, -0.00381506f, 
    0.13168763f, -0.03353990f, -0.04365841f, 0.10256428f, 0.15454417f, -0.18448898f, -0.41029286f, 0.28213733f, 
    -0.23721156f, 0.10242978f, -0.01487477f, 0.06342649f, -0.67190278f, 0.00632872f, 0.17446434f, 0.20688163f, 
    0.07770094f, 0.00824558f, 0.15721829f, 0.02879009f, 0.38464889f, 0.04052046f, 0.25977588f, 0.20200184f, 
    0.10992984f, 0.22785364f, -0.30781272f, 0.35841939f, -0.13541782f, 0.22497314f, -0.26018053f, -0.06529235f, 
    -0.11676259f, 0.10156643f, -0.12179758f, -0.01451547f, 0.23953654f, -0.04278957f, 0.00312417f, 0.27840972f, 
    -0.06811606f, -0.49223703f, 0.34227517f, 0.01745712f, 0.00745739f, -0.01014460f, 0.03656817f, 0.17043149f, 
    0.49337757f, 0.01457690f, 0.02421657f, -0.46338195f, -0.06829491f, 0.09421170f, -0.33981422f, 0.23124269f, 
    -0.12056858f, -0.07993831f, -0.11152235f, 0.10422260f, -0.50522715f, -0.14466286f, -0.32099125f, -0.08410525f, 
    -0.47215140f, -0.06301542f, 0.24289781f, 0.20417918f, -0.01235161f, -0.18533175f, -0.05147984f, 0.39300284f, 
    0.04888949f, 0.19506356f, -0.23013228f, 0.05926804f, 0.59887034f, 0.12781602f, -0.40685678f, -0.07475801f, 
    -0.06480298f, -0.07897487f, -0.02573389f, 0.39086980f, 0.15677333f, -0.09017139f, -0.21387935f, 0.28978589f, 
    -0.12081626f, 0.02871731f, -0.21076502f, 0.27020991f, 0.14735687f, 0.42527962f, -0.24729380f, 0.11202528f, 
    0.09549558f, 0.00302758f, 0.07709830f, -0.09004174f, 0.12122197f, 0.04979779f, -0.08162547f, 0.15838324f, 
    -0.04985864f, 0.21207894f, 0.31182468f, -0.01344288f, -0.05228297f, 0.09336817f, -0.05265408f, 0.02928635f, 
    -0.24179642f, 0.09612665f, -0.01144563f, 0.55284446f, -0.23612741f, -0.26494145f, -0.11982592f, -0.15741949f, 
    0.10540508f, 0.02161199f, -0.11428944f, -0.12050630f, -0.16026658f, -0.06145093f, 0.33507740f, 0.29450175f, 
    0.28376180f, -0.09155183f, 0.26301581f, 0.17270057f, 0.33693337f, 0.29110050f, 0.33725846f, -0.31816661f, 
    0.24010316f, 0.28367320f, 0.01221903f, 0.05943242f, 0.60298431f, 0.30085790f, 0.11986308f, -0.12289312f, 
    -0.21022873f, -0.02310379f, -0.19643155f, 0.34981996f, -0.32425430f, -0.72832388f, -0.33204573f, -0.12031870f, 
    0.00862220f, -0.10630723f, 0.42996582f, -0.33441344f, 0.19336665f, 0.08515278f, 0.31943461f, 0.29980969f, 
    0.08022876f, -0.01715128f, 0.09562871f, 0.01380972f, 0.13176599f, -0.50682056f, 0.16516441f, -0.05874897f, 
    0.25775290f, -0.21834394f, -0.02319672f, -0.09810042f, -0.06162369f, 0.12829158f, -0.03384831f, -0.38298681f, 
    0.42803568f, 0.26674673f, 0.10390024f, -0.42152113f, -0.00162178f, 0.26885813f, -0.24627103f, -0.22171937f, 
    0.14703253f, 0.07261010f, -0.21257769f, -0.31849721f, 0.39096802f, -0.03705066f, 0.50221330f, -0.07189868f, 
    -0.03616817f, -0.16244534f, 0.25500688f, 0.09578855f, 0.13578346f, -0.16800436f, -0.00547399f, -0.07569028f, 
    0.00220443f, 0.36451226f, -0.19699100f, -0.11228723f, 0.16752559f, 0.14087479f, 0.11337604f, -0.06351003f, 
    -0.31085986f, -0.39796108f, 0.10903641f, -0.11354656f, 0.35090253f, 0.34166095f, -0.14054953f, 0.06354956f, 
    -0.11829216f, 0.07826153f, -0.12756521f, 0.22853214f, 0.17390586f, 0.19846256f, -0.14440912f, 0.13294636f, 
    -0.07067558f, -0.04213849f, -0.02330363f, 0.13308136f, 0.12914453f, -0.03525447f, -0.18786758f, 0.13053636f, 
    0.21116588f, 0.26791695f, 0.57317334f, 0.24644078f, 0.10770090f, 0.32584691f, -0.03140779f, 0.42561999f, 
    0.36626545f, 0.00180831f, 0.13704830f, 0.09388917f, 0.09409982f, 0.01549351f, -0.00484898f, -0.47751707f, 
    -0.13776176f, -0.09641138f, -0.47041702f, 0.03101503f, 0.64018714f, -0.06337794f, -0.21832480f, 0.29288095f, 
    0.02535308f, 0.24217927f, 0.00229011f, -0.14485238f, -0.02505415f, 0.25125271f, 0.27496421f, -0.02635209f, 
    -0.19876039f, 0.09823007f, 0.11936592f, -0.06513989f, -0.07849581f, -0.06898871f, -0.12837774f, 0.00936001f, 
    0.00492733f, 0.13640530f, 0.12106711f, 0.07892746f, 0.15841042f, -0.26845279f, 0.20920861f, -0.04159402f, 
    0.04875860f, 0.09618495f, -0.20071782f, 0.46434009f, -0.31022730f, -0.15591872f, 0.50809282f, -0.17713255f, 
    0.03013316f, 0.12369390f, 0.03333308f, 0.04058572f, -0.37700441f, -0.33817208f, 0.10062723f, 0.06976007f, 
    0.04399017f, 0.54190993f, 0.06743256f, -0.13235471f, -0.01985653f, 0.29264191f, 0.06515954f, 0.05988451f, 
    0.62421852f, 0.08521907f, -0.06441570f, -0.56403542f, -0.06014924f, 0.32885790f, -0.39711794f, -0.58236176f, 
    0.20834127f, -0.10697165f, 0.04825384f, -0.32871401f, 0.30146965f, 0.01371173f, 0.58907068f, -0.04258336f, 
    0.25503615f, -0.31312513f, -0.13717462f, 0.07756464f, 0.25026935f, 0.09256821f, 0.28322265f, 0.10837802f, 
    -0.21528074f, 0.08139119f, 0.07825048f, 0.10898291f, -0.26692000f, 0.13738976f, 0.21480559f, -0.00040412f, 
    -0.23942883f, -0.28559080f, 0.04246734f, -0.02396557f, 0.19738956f, -0.17827922f, -0.37543032f, 0.11959780f, 
    0.05390756f, -0.01753833f, -0.16796666f, 0.44536468f, 0.07568953f, 0.22615398f, 0.17952889f, 0.02267016f, 
    0.08117929f, 0.07784845f, 0.04600015f, -0.05338641f, -0.02474788f, -0.17346255f, -0.13269389f, 0.09661534f, 
    0.14840612f, -0.01192869f, 0.77122015f, 0.35341272f, -0.12737761f, 0.23243308f, 0.05557575f, 0.36998376f, 
    -0.19661660f, 0.13454506f, 0.00712547f, -0.12409549f, -0.30205497f, 0.16637304f, -0.28030354f, -0.51760417f, 
    0.15363781f, 0.11279624f, -0.10125717f, -0.26402909f, -0.45858151f, 0.12647370f, 0.61639631f, -0.07810962f, 
    0.22159843f, -0.33783793f, 0.22028394f, 0.28580791f, 0.62469858f, -0.04694411f, -0.15414815f, -0.05924588f, 
    -0.18944725f, 0.41381061f, -0.04828218f, 0.08038570f, -0.15263501f, 0.36797875f, 0.43080434f, -0.08001416f, 
    0.12093072f, -0.60585022f, -0.29527134f, -0.13202362f, 0.45868328f, 0.31885412f, -0.39128563f, -0.00527223f, 
    -0.09372700f, -0.24689728f, -0.04269233f, 0.09023251f, 0.20802695f, 0.42190203f, -0.41762307f, -0.15125510f, 
    -0.05096339f, 0.17754555f, -0.11516334f, 0.11126478f, 0.14408287f, 0.03102626f, -0.13186820f, 0.25251538f, 
    -0.03289594f, -0.03568809f, 0.22112890f, 0.00642187f, -0.06550088f, 0.07471573f, 0.14840473f, 0.30714804f, 
    -0.04448749f, 0.13267763f, -0.09042367f, 0.29962084f, 0.19620454f, -0.02513120f, 0.16928449f, -0.05829465f, 
    0.11489090f, 0.07057784f, -0.17734997f, 0.12313354f, 0.25115663f, 0.10411529f, -0.06761779f, 0.15703794f, 
    -0.01938693f, 0.02202290f, -0.15362406f, -0.06665298f, 0.33811891f, 0.40864703f, 0.04894460f, -0.20100833f, 
    -0.13140064f, 0.26324767f, 0.18802896f, 0.01019367f, -0.12504151f, 0.15794189f, 0.11927239f, 0.08492474f, 
    0.02311050f, -0.20858172f, -0.08965834f, -0.20920651f, 0.01359680f, -0.20520875f, 0.30835891f, 0.09342214f, 
    -0.00242598f, -0.08553668f, -0.00611633f, 0.38215840f, -0.16181356f, -0.14054157f, 0.22454900f, -0.17021559f, 
    0.12366453f, -0.02250197f, 0.03440839f, -0.07654049f, -0.33918658f, -0.06986916f, 0.23531696f, 0.02595749f, 
    0.15534949f, 0.78878993f, 0.25030857f, 0.07247297f, -0.01294921f, 0.29835606f, 0.12337226f, -0.02345141f, 
    0.34052062f, -0.04658754f, -0.07823177f, -0.07765301f, 0.15749116f, 0.08691917f, -0.02422639f, -0.29495952f, 
    -0.06352443f, 0.00956467f, -0.61945146f, -0.18942796f, 0.06253407f, 0.08925336f, -0.28832760f, -0.20291774f, 
    0.07483866f, -0.28978384f, 0.10801610f, 0.06891207f, 0.04698010f, -0.00949378f, -0.12933101f, 0.19193484f, 
    -0.13190500f, -0.03415103f, 0.13102610f, 0.11574667f, 0.06344555f, -0.22890683f, 0.16564186f, 0.15495376f, 
    0.28257871f, 0.11001973f, 0.35487783f, 0.06233342f, -0.09555589f, -0.01976624f, 0.03532190f, 0.27425963f, 
    -0.02530466f, 0.16072699f, 0.06311740f, 0.12129881f, 0.01203151f, 0.15903175f, 0.12899597f, 0.01951573f, 
    -0.10870655f, 0.10829771f, -0.00948259f, -0.05818767f, -0.01538550f, 0.32430542f, 0.02272727f, 0.09391369f, 
    -0.05099291f, -0.10628892f, 0.10804485f, 0.24172653f, 0.07031251f, -0.36654648f, 0.19928390f, 0.01533243f, 
    0.12979491f, 0.08295231f, -0.03914142f, 0.02168790f, 0.00888648f, 0.11691462f, -0.03914788f, 0.02092858f, 
    0.13797629f, -0.06687167f, -0.03914509f, -0.06234072f, -0.45553482f, 0.14103299f, -0.07474546f, 0.30100167f, 
    -0.09350123f, 0.00759422f, 0.09764229f, 0.11860458f, -0.15047173f, -0.16868407f, 0.13801809f, 0.04091974f, 
    -0.00276139f, 0.15597646f, -0.16152149f, -0.00670372f, -0.19124492f, 0.15247400f, -0.14822647f, 0.13347206f, 
    -0.46045792f, -0.00498981f, 0.29970631f, 0.47736081f, 0.23976071f, 0.31540278f, 0.15792176f, -0.02963380f, 
    0.12614241f, 0.29222378f, -0.29652461f, 0.31700969f, -0.20728552f, -0.04891926f, 0.16595791f, 0.16340813f, 
    -0.11802663f, 0.05789050f, -0.04169032f, 0.38499343f, 0.34067020f, -0.14748210f, 0.01270377f, 0.25698280f, 
    0.13168766f, -0.02205854f, 0.13410459f, 0.38890153f, 0.10586599f, 0.16403832f, -0.28004470f, 0.00709746f, 
    0.34580842f, -0.16791743f, 0.06088215f, -0.42869395f, -0.10985160f, 0.26751950f, -0.51087493f, -0.44137958f, 
    -0.15756625f, -0.13536136f, -0.01674957f, -0.11317127f, -0.06277077f, 0.07273227f, 0.43751341f, 0.07736527f, 
    0.46426186f, -0.16402493f, -0.36482605f, -0.17255577f, 0.09979529f, -0.29563326f, -0.19497998f, 0.14851561f, 
    0.02199667f, 0.00500857f, 0.38021159f, -0.12779470f, -0.64254087f, 0.11103755f, 0.52939290f, 0.20244144f, 
    0.43005773f, -0.02134147f, -0.27315393f, -0.35476044f, 0.19496855f, -0.08961385f, -0.43608454f, 0.29964206f, 
    -0.11105469f, -0.23883021f, 0.12097113f, 0.26323804f, -0.01258074f, 0.15227029f, -0.04853628f, -0.22866532f, 
    -0.03827836f, 0.29366055f, 0.08745773f, -0.45098054f, 0.30108443f, -0.08562060f, 0.13931793f, 0.05245489f, 
    -0.25280899f, -0.58004731f, 0.10982502f, -0.16799290f, 0.02272780f, -0.24379924f, 0.14939855f, 0.42534775f, 
    -0.37374237f, 0.31817570f, 0.11603525f, 0.23806533f, 0.19991720f, -0.05893045f, -0.02117258f, -0.08406746f, 
    0.22782353f, -0.05156922f, -0.00236829f, -0.18408599f, -0.14761230f, -0.04226240f, 0.17886963f, -0.32777673f, 
    -0.03659470f, 0.04831381f, 0.19176540f, -0.04521227f, 0.03034803f, 0.02414125f, 0.15881634f, -0.52785861f, 
    0.17183195f, 0.24369338f, -0.00057698f, -0.11056636f, -0.15802392f, -0.19273318f, 0.59887248f, 0.07560239f, 
    0.08817443f, -0.24940889f, 0.02795569f, -0.83007640f, 0.00652936f, 0.40137786f, 0.02043884f, -0.07695683f, 
    -0.04802868f, -0.20856039f, 0.23329137f, -0.67800611f, 0.13407090f, -0.02934939f, 0.09494408f, 0.16929139f, 
    -0.01246528f, -0.42144665f, -0.04031827f, 0.26332009f, -0.09538823f, -0.34922484f, 0.09378202f, 0.16164438f, 
    0.36068875f, -0.14376722f, -0.04793143f, 0.07339803f, 0.00004418f, -0.34917653f, 0.34301320f, 0.16778685f, 
    -0.37913603f, -0.86541027f, -0.05540927f, -0.14013211f, 0.32598725f, 0.17201906f, 0.37572417f, -0.33606467f, 
    -0.12054704f, -0.06021728f, 0.37311038f, -0.03257305f, -0.30330655f, -0.03295619f, 0.26276076f, 0.12805799f, 
    0.40014189f, 0.17143279f, -0.16553855f, 0.04280027f, 0.12377660f, 0.09696415f, -0.48704571f, -0.11405793f, 
    -0.07707849f, 0.09325808f, 0.17782021f, 0.00177429f, 0.18122637f, -0.28688088f, 0.15327591f, 0.19333118f, 
    0.41190875f, 0.04018303f, 0.50172639f, -0.03686505f, 0.26720792f, 0.70656258f, 0.04408820f, 0.01425131f, 
    -0.04585242f, 0.22252211f, 0.19040747f, -0.07502082f, -0.16523531f, -0.16032994f, -0.57344270f, -0.26204169f, 
    0.08513014f, 0.31412745f, -0.07677487f, -0.09776966f, 0.07719540f, 0.32023618f, -0.03187947f, 0.10080715f, 
    -0.08774363f, -0.12428232f, -0.36012107f, 0.05566971f, -0.08690373f, -0.40633988f, 0.10124380f, -0.08693900f, 
    -0.52957231f, -0.11960069f, -0.02608214f, -0.00355623f, -0.25985199f, 0.12914851f, 0.16856775f, -0.40904823f, 
    0.02795730f, 0.15097295f, -0.29014227f, 0.18440218f, -0.54226321f, 0.05892827f, 0.03897810f, -0.12841688f, 
    0.28106773f, -0.00916091f, 0.27054831f, 0.39917907f, 0.29365006f, 0.22285384f, 0.22407030f, -0.20157267f, 
    0.43945566f, -0.06244637f, -0.41198641f, 0.05201789f, 0.07483865f, 0.15284839f, 0.00569151f, -0.12950349f, 
    0.12077952f, 0.03636700f, -0.04479580f, -0.04888896f, -0.30597520f, 0.02333679f, -0.58462274f, -0.27430278f, 
    0.00006519f, 0.03352219f, 0.05348980f, -0.24562572f, 0.34214997f, 0.20748499f, 0.14170153f, 0.34323901f, 
    0.08499449f, -0.05058552f, -0.11087824f, 0.19474077f, -0.15317991f, -0.20242441f, -0.40080053f, 0.00173726f, 
    0.21254054f, -0.33452690f, -0.02883090f, -0.18232350f, -0.06499662f, 0.26844877f, 0.05464300f, 0.12462605f, 
    0.18651265f, 0.24640676f, 0.08972715f, -0.19652389f, -0.37016365f, -0.05295279f, -0.57589275f, -0.11271650f, 
    0.05152315f, 0.11712887f, -0.50915921f, -0.56990254f, 0.02137833f, 0.10193683f, -0.18047647f, -0.46363246f, 
    -0.07706251f, -0.77067101f, 0.24117529f, 0.14129926f, -0.04066237f, 0.13973820f, 0.20431741f, -0.25011659f, 
    -0.10168760f, 0.20086098f, -0.64399111f, 0.01934041f, 0.73536903f, 0.19053023f, -0.02563349f, -0.21676962f, 
    -0.24125108f, -0.56253046f, 0.14975880f, 0.15333973f, 0.10296387f, -0.20256950f, -0.37262344f, -0.13997898f, 
    0.00500050f, 0.18394101f, 0.33582467f, -0.07746638f, 0.13327052f, 0.32622817f, 0.16617288f, 0.22083688f, 
    0.07659042f, -0.30042854f, -0.06858461f, 0.32865110f, -0.27318031f, -0.05952852f, -0.30609041f, 0.01495515f, 
    0.12482996f, -0.06156122f, 0.22333582f, 0.04309604f, -0.02814781f, 0.01166251f, -0.02416513f, -0.32641956f, 
    0.18499075f, 0.22093956f, -0.07374690f, -0.00442564f, 0.33150029f, 0.25438327f, 0.40700197f, 0.13474871f, 
    0.23045184f, 0.04890068f, -0.07027087f, 0.16717947f, -0.02578610f, -0.08387332f, 0.13581575f, -0.12599914f, 
    0.08882234f, -0.05287701f, -0.07305398f, -0.16022414f, 0.22623269f, 0.23792963f, -0.28325072f, -0.14016132f, 
    -0.18858950f, 0.02582698f, 0.14431138f, 0.04319131f, -0.22333860f, 0.01836228f, 0.40735930f, 0.09571526f, 
    -0.06769390f, 0.05325262f, 0.07482377f, -0.43028563f, -0.01917044f, 0.27655494f, 0.14916554f, -0.12244580f, 
    0.07293170f, -0.02562925f, 0.03140985f, 0.15388502f, -0.01087864f, -0.10483719f, 0.14074680f, -0.02624457f, 
    -0.00800537f, -0.12763637f, 0.11823568f, 0.15226857f, -0.16714789f, -0.19309056f, 0.04028068f, 0.03594521f, 
    0.31162667f, 0.70301396f, 0.13229957f, -0.12854126f, 0.06806808f, -0.13850917f, 0.30528367f, 0.24953724f, 
    -0.54511774f, -0.03605196f, 0.06377079f, 0.26250222f, -0.26343691f, -0.19355486f, 0.17313160f, -0.38687477f, 
    0.01109697f, 0.06666173f, -0.42894861f, 0.19388033f, -0.23378429f, 0.03842647f, 0.25562266f, 0.12617928f, 
    0.11100626f, 0.19747348f, 0.16819581f, 0.25915855f, 0.25493392f, 0.17799129f, 0.38922462f, -0.15856540f, 
    0.29743108f, -0.10471416f, -0.32277858f, -0.02347106f, 0.38741502f, 0.08507758f, -0.06722254f, -0.06044269f, 
    -0.01033472f, 0.10170159f, -0.10826234f, 0.23548448f, -0.13590653f, -0.09573509f, -0.48156664f, -0.14093331f, 
    0.06959814f, 0.03344247f, 0.16148393f, -0.09777480f, 0.20375533f, 0.18828125f, 0.17023817f, 0.31827125f, 
    -0.03440873f, 0.07106391f, 0.10467675f, 0.18209764f, -0.16579047f, -0.20870234f, -0.18656434f, 0.06531841f, 
    0.08939540f, -0.43130991f, -0.10951342f, -0.17744280f, -0.12119200f, 0.32499650f, 0.02810002f, 0.00203573f, 
    0.68131626f, -0.23685856f, -0.06529649f, -0.21804821f, -0.05030655f, 0.07889577f, -0.13024807f, -0.07058446f, 
    -0.17531700f, -0.07042901f, 0.01247788f, -0.15630130f, 0.04302705f, 0.06003861f, 0.14443377f, 0.18665813f, 
    0.04795279f, -0.16564277f, -0.07329259f, 0.12359221f, -0.32276076f, -0.12962244f, -0.00743795f, 0.47685766f, 
    0.33331582f, -0.25022602f, 0.03563903f, -0.05199723f, -0.24979278f, 0.05231704f, -0.27996704f, 0.10903493f, 
    0.17258829f, 0.52039522f, 0.11338303f, 0.22950980f, -0.07036468f, -0.41088307f, 0.29513004f, 0.25432372f, 
    -0.06827229f, 0.22520499f, 0.06973249f, 0.20607768f, 0.14135624f, 0.05947930f, -0.13529389f, 0.14166997f, 
    -0.01865576f, 0.18607652f, 0.05814315f, -0.19611160f, 0.50694913f, 0.20506026f, 0.08151978f, 0.18236488f, 
    -0.05202733f, -0.24736668f, 0.20227881f, 0.42428216f, -0.02414668f, -0.10771586f, 0.08095342f, -0.13494588f, 
    0.44147626f, 0.09382597f, 0.00451660f, -0.78222680f, 0.00088207f, 0.05453173f, -0.07230835f, 0.00886836f, 
    0.24472152f, -0.04041306f, 0.16773754f, -0.11534623f, 0.10385550f, -0.08371950f, 0.23208323f, 0.16097498f, 
    -0.08154007f, 0.05748988f, -0.05829443f, 0.25406435f, -0.15366821f, 0.09845075f, 0.23882140f, 0.04036694f, 
    0.26293138f, -0.07038501f, -0.01674250f, 0.04693708f, 0.44740078f, -0.10724059f, -0.20872812f, -0.08346123f, 
    -0.30091706f, -0.00838413f, 0.30029410f, 0.19350825f, -0.02545963f, -0.02890682f, -0.00106790f, 0.01952308f, 
    -0.07447521f, 0.13366860f, -0.00218483f, 0.36479944f, -0.00488361f, -0.01665833f, 0.18912664f, 0.21971433f, 
    -0.03283902f, -0.02292646f, 0.05233721f, 0.12053968f, 0.13661774f, -0.27418384f, -0.19014120f, 0.19580722f, 
    0.12628782f, 0.04320714f, 0.35153496f, 0.25401092f, -0.06026276f, 0.18440564f, -0.10082723f, -0.04533728f, 
    -0.03203185f, 0.07753508f, -0.09599073f, 0.46335396f, -0.09193303f, -0.15602253f, 0.29410034f, -0.20110327f, 
    0.07279880f, 0.08063356f, -0.26897740f, 0.07718008f, -0.30234846f, -0.05937871f, 0.02474722f, 0.16264218f, 
    0.36639941f, -0.03859160f, -0.21681419f, 0.01713646f, 0.56831986f, 0.49707967f, 0.29774341f, -0.07352582f, 
    -0.07146429f, 0.21864966f, 0.23580614f, 0.07187791f, -0.13561146f, 0.12145555f, 0.38327584f, 0.07807970f, 
    -0.00514834f, -0.19570591f, -0.07950081f, -0.09695838f, -0.13558470f, -0.26411372f, -0.07173052f, 0.02864689f, 
    0.02848018f, -0.08721519f, 0.29640487f, 0.34510067f, -0.21549173f, -0.12982965f, 0.33694777f, -0.23022905f, 
    -0.07305419f, 0.08178972f, 0.11001863f, -0.19659461f, -0.27113417f, 0.14406842f, 0.13635075f, -0.01948673f, 
    0.11599829f, 0.11274847f, 0.13767089f, -0.11686498f, -0.09640483f, 0.02479470f, 0.23087420f, -0.13264789f, 
    0.33593670f, -0.54981440f, -0.06209982f, -0.38858676f, -0.05124900f, 0.14581528f, -0.15119746f, 0.05978043f, 
    -0.17399253f, -0.15102324f, -0.20156091f, 0.28293401f, -0.41391760f, -0.07877766f, -0.85963762f, -0.07607513f, 
    -0.56595814f, 0.14061390f, -0.00860641f, 0.01662218f, -0.55541730f, 0.01274342f, -0.08275538f, 0.26520637f, 
    0.15125585f, -0.40879500f, -0.01676113f, 0.08167322f, -0.33526877f, 0.41587710f, -0.48164153f, -0.11659737f, 
    0.42869389f, 0.08423927f, -0.09442428f, 0.24838826f, 0.02446282f, 0.20629331f, -0.47617933f, 0.00945986f, 
    -0.01120692f, -0.17287256f, -0.66020787f, 0.04033161f, 0.27640757f, 0.42643693f, -0.46782622f, 0.06580584f, 
    0.11453684f, 0.21140984f, -0.08529355f, 0.12570792f, 0.12891015f, 0.21229951f, -0.04301912f, 0.12657206f, 
    -0.28117490f, -0.28531995f, 0.08672433f, 0.33090669f, -0.02643142f, -0.03100622f, -0.15111975f, -0.07157277f, 
    0.39567393f, 0.18982959f, -0.04261998f, 0.11685998f, -0.21325396f, -0.15765612f, -0.08893500f, 0.20313174f, 
    0.24496619f, 0.03144347f, 0.24953823f, -0.21259317f, 0.13805360f, 0.07938240f, 0.00727586f, -0.15713637f, 
    0.14380842f, -0.20375627f, 0.08003761f, 0.17889044f, -0.20156676f, -0.01239313f, -0.19948651f, 0.13827726f, 
    0.30958620f, -0.03819614f, 0.17875803f, 0.03921939f, -0.28511018f, 0.46429506f, 0.29028720f, 0.13714391f, 
    0.38831535f, 0.10739797f, -0.41353625f, 0.12095552f, -0.17375667f, -0.02690331f, 0.19698270f, 0.02400356f, 
    0.05534258f, -0.16859770f, 0.35633591f, -0.08793401f, 0.39212221f, 0.43035430f, -0.40370598f, 0.16228507f, 
    -0.01687162f, 0.17905204f, 0.05444500f, 0.22187652f, 0.36166167f, 0.42486334f, 0.29290077f, 0.13236785f, 
    0.19684331f, -0.34777194f, 0.07718299f, -0.41270858f, -0.05520999f, -0.19763403f, 0.21870275f, 0.13661857f, 
    0.26298082f, -0.03044865f, 0.02701204f, 0.35612258f, -0.08828240f, 0.10579786f, -0.34968838f, 0.08441912f, 
    -0.17733869f, 0.11626962f, -0.08071316f, -0.08420704f, -0.06263604f, 0.07948799f, -0.30134702f, 0.21339007f, 
    0.09194966f, 0.01897806f, 0.02324207f, 0.04731094f, -0.42670295f, 0.10892643f, 0.24659546f, 0.12244845f, 
    -0.18698566f, -0.00692920f, 0.05934469f, 0.05140678f, -0.24121001f, 0.16491581f, -0.39753374f, -0.02699997f, 
    0.13914165f, 0.13902433f, 0.03415441f, 0.53091508f, -0.02542594f, -0.33605605f, 0.24317494f, 0.17017591f, 
    -0.09297936f, -0.00811793f, -0.09085986f, 0.17594394f, -0.08714333f, 0.11433303f, 0.11860507f, 0.01712007f, 
    -0.00102612f, 0.23630591f, 0.00920011f, 0.13173687f, 0.07814440f, 0.46204114f, 0.23029745f, 0.19335495f, 
    -0.05301607f, -0.25862968f, 0.14612956f, 0.30592966f, 0.00030550f, -0.03335823f, -0.20970552f, -0.40561119f, 
    0.20875347f, -0.04640476f, 0.05618049f, 0.38020799f, -0.03253542f, -0.16811948f, -0.19551200f, 0.19606659f, 
    0.16879697f, 0.11408259f, 0.00819188f, -0.19238731f, 0.29184872f, -0.05451119f, 0.03512903f, 0.07747504f, 
    0.27848190f, -0.23575744f, 0.22956674f, 0.06881191f, -0.05095683f, -0.00025647f, 0.24060343f, 0.31998459f, 
    0.35937646f, 0.03434180f, 0.03891518f, -0.09229038f, -0.27283761f, 0.19852833f, 0.03632513f, 0.25881937f, 
    0.25285330f, 0.13621347f, -0.21333483f, 0.50753421f, -0.18144749f, -0.02566806f, 0.09314011f, 0.19343589f, 
    -0.05558667f, -0.04788636f, 0.49083281f, -0.16430438f, 0.09881411f, 0.05874175f, 0.03807260f, 0.17639218f, 
    0.06266113f, 0.51343387f, 0.02709109f, 0.06199459f, 0.60566396f, 0.26235822f, 0.39876276f, -0.05361259f, 
    0.12384391f, -0.06688655f, -0.27547836f, -0.06955327f, 0.09221429f, -0.22517638f, 0.09472826f, -0.28826079f, 
    0.33309188f, 0.07465909f, 0.02701122f, -0.01680782f, -0.26010361f, -0.06146805f, -0.23698618f, -0.13332236f, 
    0.11324383f, -0.08317988f, -0.41793928f, -0.34366179f, -0.16537972f, 0.01416105f, 0.67713088f, -0.03099468f, 
    0.61802775f, -0.20884363f, 0.01927125f, -0.01404868f, 0.02554071f, -0.14918979f, 0.04436317f, -0.02930279f, 
    0.14551093f, 0.12972958f, 0.10787381f, -0.00576955f, -0.27790833f, 0.33082178f, 0.33843067f, 0.12032367f, 
    -0.03023486f, -0.10857071f, -0.12270909f, -0.03853747f, 0.14523134f, 0.23624289f, -0.39310396f, 0.01331150f, 
    0.00005253f, -0.11078497f, 0.22403719f, 0.28978708f, -0.24840273f, -0.05055412f, 0.24658412f, -0.22181951f, 
    -0.05510770f, 0.08125630f, -0.11961842f, -0.06297390f, 0.24460055f, -0.07614076f, 0.03362492f, 0.12872294f, 
    -0.08509899f, -0.05594853f, 0.08613109f, 0.29528791f, 0.04410058f, 0.08369930f, -0.17379698f, 0.12712669f, 
    0.08454165f, -0.21403983f, -0.08098648f, -0.18374947f, 0.10994691f, -0.00669577f, 0.28538328f, -0.16497894f, 
    0.09570425f, -0.05098820f, 0.22916955f, -0.06593823f, 0.04671361f, 0.06797627f, 0.37993771f, 0.05522956f, 
    0.04211049f, -0.00397293f, -0.01968901f, 0.13694449f, -0.22486375f, -0.20184608f, 0.28674683f, 0.09642831f, 
    0.36397043f, -0.21749495f, -0.03461427f, 0.09509919f, 0.11395574f, -0.26396650f, -0.08149134f, 0.14455351f, 
    0.14909990f, 0.32724470f, 0.37392318f, 0.03834671f, -0.33284301f, -0.27218515f, -0.15007621f, -0.04356994f, 
    0.05103850f, 0.24533327f, 0.32056916f, -0.23292890f, 0.04907183f, -0.24982744f, 0.08664862f, 0.22294222f, 
    0.04365924f, 0.17458647f, -0.03480634f, -0.15518625f, 0.04080658f, 0.44936839f, 0.03347946f, -0.00209650f, 
    0.20289165f, -0.46987426f, -0.08021686f, 0.56903100f, -0.00039992f, -0.37793845f, 0.23898494f, -0.25954551f, 
    -0.07791495f, 0.05855227f, -0.07542229f, 0.01681018f, -0.00913968f, -0.06838615f, -0.12176929f, -0.11280084f, 
    0.02278895f, -0.10302858f, -0.08013205f, -0.03968446f, -0.03138679f, 0.00854526f, 0.02258356f, -0.06717847f, 
    -0.14314525f, 0.09597573f, -0.12061477f, 0.01234619f, 0.07547924f, -0.04683049f, 0.00555999f, -0.00366674f, 
    0.00387778f, -0.09327576f, -0.11206300f, -0.03556241f, 0.03405098f, -0.14343056f, 0.09776168f, -0.07774051f, 
    0.09712344f, -0.10952064f, -0.09461343f, -0.07982388f, -0.11761655f, -0.14112309f, -0.01115464f, -0.05683680f, 
    -0.07232703f, -0.11226987f, 0.03443104f, 0.10132629f, -0.10377256f, 0.02119075f, 0.06530801f, 0.06376750f, 
    -0.05425496f, -0.05840164f, -0.09642988f, 0.01984435f, -0.08941384f, -0.11673874f, -0.14748225f, -0.02501398f, 
    -0.00520887f, 0.12316091f, 0.04328673f, -0.11580051f, 0.01436216f, 0.08425580f, -0.04612285f, -0.02768385f, 
    0.53644758f, 0.04802535f, 0.05758357f, -0.28004643f, 0.18356970f, 0.34644803f, -0.03509566f, -0.36506328f, 
    -0.13063696f, -0.08589628f, -0.04798440f, -0.08971100f, 0.34888315f, -0.02885833f, -0.08163673f, 0.16014333f, 
    0.09002700f, 0.21686491f, -0.25431675f, 0.01942023f, -0.02503807f, 0.18264042f, 0.51100367f, -0.00730276f, 
    -0.04770092f, 0.02895883f, -0.06070422f, -0.11008316f, -0.19865021f, 0.04618513f, -0.00910485f, -0.08309421f, 
    -0.00691642f, 0.04543750f, 0.54025072f, -0.08469970f, 0.02674963f, -0.18086156f, 0.29722190f, -0.00898649f, 
    0.04816526f, 0.37634221f, -0.00033325f, 0.45055383f, -0.17842700f, 0.07739934f, 0.52805871f, 0.02768540f, 
    -0.08392569f, 0.02480401f, -0.10157977f, -0.09394018f, -0.37772813f, -0.06565192f, 0.03893940f, 0.21921238f, 
    -0.07027615f, 0.24495371f, 0.28680772f, 0.02583774f, 0.13353346f, -0.00994340f, -0.09849477f, -0.24872360f, 
    -0.24392375f, 0.18900988f, -0.01972779f, -0.23731111f, 0.20636313f, 0.00880526f, 0.03139284f, 0.37893593f, 
    0.08273586f, 0.04886374f, 0.06799746f, 0.29646981f, -0.51948464f, -0.12216505f, -0.34903124f, 0.07181396f, 
    0.03233862f, 0.08216418f, 0.28008196f, -0.08658218f, -0.18703988f, -0.18813376f, -0.09536456f, -0.01534557f, 
    -0.16782902f, 0.18380025f, -0.18140164f, 0.01137171f, 0.26722476f, 0.21527247f, -0.22190893f, 0.03956001f, 
    -0.22124289f, -0.12093813f, 0.08345756f, 0.33689985f, 0.26617935f, 0.20956178f, -0.12236245f, 0.09890910f, 
    -0.11835439f, 0.13027813f, -0.31889021f, 0.27716386f, -0.13623126f, -0.18777716f, -0.13684528f, 0.04285920f, 
    -0.03607999f, 0.05454206f, 0.00708050f, 0.25477812f, 0.22704715f, -0.01063498f, 0.03472508f, 0.22260511f, 
    -0.26013681f, -0.02424321f, -0.19780615f, 0.45804128f, 0.13565513f, 0.24292660f, -0.25730449f, -0.23994288f, 
    0.27640751f, 0.10709308f, 0.11109659f, -0.41027036f, 0.06879355f, 0.18728049f, -0.29340589f, -0.01519890f, 
    -0.02576360f, -0.01434042f, -0.22073191f, -0.23379232f, -0.07900050f, 0.14287218f, 0.18191499f, -0.18308671f, 
    0.01006438f, -0.29279345f, 0.04390675f, 0.04478975f, -0.11901610f, -0.10352213f, 0.18860453f, 0.21406794f, 
    -0.25104925f, 0.11308844f, 0.16502599f, -0.02678864f, 0.25309661f, 0.15224263f, 0.18016015f, -0.05029236f, 
    0.24609803f, -0.18121681f, 0.02525228f, -0.15450691f, 0.24955831f, 0.28478605f, -0.75963682f, 0.40824816f, 
    -0.07145589f, -0.04008593f, 0.17224452f, -0.08472225f, 0.18537892f, 0.34006250f, -0.07387350f, 0.17054231f, 
    0.10868791f, -0.23074625f, 0.07186936f, 0.03055261f, 0.11400240f, 0.36754906f, -0.14287040f, 0.15709463f, 
    -0.04091853f, 0.30841649f, 0.08534909f, 0.17110017f, 0.09093731f, -0.48571303f, 0.21689200f, -0.04529255f, 
    -0.07089545f, -0.05679493f, -0.09476895f, 0.43795127f, 0.13944229f, 0.07513088f, 0.16631010f, -0.03686327f, 
    -0.27997980f, 0.08310697f, -0.21605849f, 0.21289089f, -0.13422665f, 0.00600530f, -0.29967204f, 0.27548999f, 
    0.02694562f, 0.16770905f, -0.15665992f, -0.06412088f, 0.01083425f, 0.02186953f, 0.08188051f, 0.10536126f, 
    -0.15060742f, 0.13379505f, 0.39490345f, 0.01964705f, -0.42700547f, -0.12923579f, 0.08360101f, 0.27146631f, 
    0.36246714f, 0.28453240f, 0.07344981f, 0.00167119f, 0.13452481f, -0.31471807f, 0.42988846f, 0.09045191f, 
    -0.08947973f, 0.16968465f, -0.05449430f, 0.11284968f, -0.03882130f, -0.13700885f, 0.31444493f, -0.12475200f, 
    0.04722448f, 0.30901936f, 0.12288004f, -0.18813488f, 0.00720120f, 0.19783352f, 0.36758289f, 0.15421748f, 
    -0.00439385f, 0.15740454f, -0.12868305f, 0.23092763f, 0.01519528f, -0.04255651f, 0.18654361f, -0.03212086f, 
    -0.04703518f, -0.04131886f, 0.08313015f, -0.11981058f, 0.07200222f, 0.06012520f, -0.09666999f, -0.06744921f, 
    -0.05310535f, -0.07649796f, 0.01908892f, -0.00457837f, -0.08207569f, 0.04396632f, -0.11758921f, 0.10896777f, 
    -0.09114994f, 0.01414236f, 0.05345409f, -0.08824441f, -0.04524247f, 0.04138813f, -0.08576756f, 0.10168390f, 
    -0.05603473f, 0.05475441f, -0.02718994f, 0.03863613f, -0.06484243f, -0.06644579f, 0.03637844f, -0.13029103f, 
    -0.11988689f, 0.04501800f, -0.07538177f, -0.08030089f, -0.03154850f, 0.03049324f, -0.12696682f, -0.09904493f, 
    -0.01691347f, 0.00901818f, -0.00085482f, 0.10221834f, -0.06324048f, 0.10953284f, -0.04941054f, -0.02476824f, 
    -0.11907737f, 0.00526414f, -0.09312333f, -0.08688446f, -0.05730626f, 0.03489955f, -0.02892791f, 0.04002774f, 
    -0.07419238f, 0.09397294f, -0.03941210f, 0.07019551f, -0.08718865f, 0.07236940f, -0.00150697f, -0.11678310f, 
    0.37800395f, -0.08934323f, -0.13373534f, 0.30979687f, 0.15696706f, 0.18960808f, -0.31017822f, 0.18466380f, 
    -0.08661766f, 0.00606388f, -0.42148256f, 0.19948874f, -0.12852192f, -0.05580696f, -0.25769913f, 0.34859523f, 
    -0.07479361f, 0.39285621f, 0.01211902f, -0.08823684f, 0.07942844f, -0.02352253f, 0.15239948f, -0.00137129f, 
    -0.15469544f, 0.25302443f, 0.08075237f, 0.01253924f, -0.54294342f, 0.06601414f, -0.33418673f, 0.09237954f, 
    -0.11241888f, 0.06738964f, 0.07843824f, 0.18124455f, 0.29851475f, -0.15805967f, 0.28473309f, 0.25323763f, 
    -0.02931912f, 0.18838140f, -0.45207658f, 0.36107156f, -0.11753012f, -0.01511366f, 0.24464999f, -0.05237861f, 
    0.09897991f, 0.03783548f, -0.08488478f, 0.06853326f, 0.10310517f, -0.38857067f, 0.06897653f, 0.23022492f, 
    -0.20723186f, -0.47487134f, 0.25370756f, 0.05418393f, 0.05744949f, 0.35204330f, -0.11262475f, 0.11481681f, 
    0.07475012f, 0.27059066f, -0.07391781f, -0.42904404f, 0.03206177f, 0.13173707f, 0.10598194f, -0.08865313f, 
    0.19402912f, -0.09164970f, 0.37806734f, 0.03317458f, 0.53785080f, 0.02873846f, -0.25222546f, -0.24712314f, 
    -0.23747441f, -0.05811122f, 0.07610989f, 0.07648014f, 0.09597013f, 0.16702579f, 0.14716379f, -0.12065292f, 
    0.10500786f, 0.10953148f, -0.38386863f, 0.08429055f, 0.28444585f, -0.05391132f, -0.34993711f, -0.12739287f, 
    -0.17569475f, -0.21789025f, 0.18147148f, -0.24663721f, 0.03748810f, 0.11008299f, 0.05492484f, -0.10954350f, 
    -0.07827139f, 0.11436506f, -0.04562676f, 0.02955684f, 0.21898933f, 0.30260804f, 0.01138881f, 0.22332579f, 
    -0.06206085f, -0.28444356f, -0.01691425f, 0.24422434f, -0.34583271f, -0.08650719f, -0.28103235f, 0.23205137f, 
    0.30640122f, 0.28966498f, 0.27048230f, -0.13583170f, -0.06335652f, 0.34352010f, 0.03687352f, 0.14115326f, 
    -0.01984328f, 0.02059822f, -0.06805027f, 0.03293499f, -0.24411429f, -0.09237512f, -0.03175546f, 0.06591346f, 
    0.22183536f, -0.09186260f, 0.30021945f, -0.14293182f, 0.43391511f, -0.00584338f, 0.30909702f, -0.01059445f, 
    0.24146999f, -0.11188660f, 0.00003357f, 0.25563893f, -0.08684977f, 0.07538151f, 0.43857047f, 0.20526937f, 
    0.46131873f, 0.01488964f, 0.26665360f, 0.00438652f, -0.03301303f, 0.38320124f, 0.16038790f, -0.09782898f, 
    0.19137089f, 0.02960210f, -0.31890753f, 0.29705626f, -0.32302830f, -0.18422441f, -0.00770715f, 0.05703903f, 
    -0.00494911f, -0.15029712f, 0.44028229f, -0.03263922f, 0.26530045f, 0.27124608f, -0.16462743f, 0.09291686f, 
    -0.10936737f, 0.15542066f, -0.11488408f, 0.02790176f, 0.26264453f, 0.26883009f, 0.05936344f, -0.11813944f, 
    0.25066295f, -0.41574678f, -0.11720213f, -0.36915919f, 0.09550332f, 0.00489868f, -0.02349617f, -0.26676384f, 
    0.54988593f, 0.28172126f, -0.09729956f, -0.04921282f, -0.05188651f, 0.13204709f, 0.06186964f, -0.13963318f, 
    0.21474937f, -0.06956436f, 0.06191299f, -0.44319543f, 0.18087293f, 0.11040798f, 0.05175147f, -0.01058940f, 
    0.19012970f, -0.45619893f, 0.06563891f, -0.06887418f, 0.06404228f, 0.18698332f, 0.09073225f, -0.08591748f, 
    0.04946301f, 0.20400639f, 0.08755857f, 0.08642233f, -0.00458827f, 0.00046000f, 0.20056826f, 0.07546276f, 
    -0.21151511f, -0.13839811f, 0.13432494f, -0.05938960f, -0.21183358f, -0.01599701f, -0.02216094f, 0.06192778f, 
    0.06890444f, 0.11379383f, 0.25797513f, 0.22746868f, -0.25340658f, 0.04309767f, 0.17057677f, 0.08231760f, 
    0.03129241f, -0.21331008f, 0.06620350f, 0.18279393f, -0.15423420f, -0.04350621f, 0.10565328f, 0.04698860f, 
    0.24919763f, 0.57902932f, 0.46118176f, 0.12347187f, 0.02758905f, -0.09781104f, 0.13342255f, -0.14170706f, 
    -0.02369594f, 0.36536908f, -0.10059692f, -0.01345485f, -0.09129975f, 0.12059321f, -0.13979360f, 0.10443031f, 
    0.19817735f, 0.16854034f, -0.11278879f, -0.08869663f, -0.12006505f, -0.03959888f, 0.08285236f, -0.05912838f, 
    0.17526990f, 0.06578033f, 0.39049560f, 0.07154232f, -0.14253993f, -0.03790347f, 0.34551567f, -0.03139173f, 
    0.12052031f, 0.00800665f, -0.31957653f, -0.01586620f, 0.10232493f, 0.21463202f, -0.13953120f, -0.09461311f, 
    -0.51462835f, -0.04245448f, 0.29151660f, 0.10318340f, 0.15153821f, 0.02830723f, -0.25292623f, -0.05720317f, 
    -0.07842341f, 0.05214369f, 0.00267738f, 0.31980276f, 0.05918932f, -0.01998890f, 0.01363701f, 0.35008040f, 
    -0.00901569f, -0.17301966f, 0.10017546f, 0.42009813f, 0.25962126f, -0.37893921f, -0.07889870f, 0.21414113f, 
    0.23817366f, 0.60499388f, 0.07242320f, 0.39434108f, -0.07825956f, 0.09513786f, -0.22258003f, -0.02578610f, 
    -0.40485501f, -0.06622266f, 0.08829989f, 0.03789143f, 0.13154839f, -0.25325483f, 0.31562543f, 0.08805710f, 
    0.04911352f, -0.04499157f, 0.06509955f, 0.14086409f, 0.11824820f, -0.12825228f, -0.16955872f, -0.06345841f, 
    -0.40995347f, 0.05151128f, 0.22232507f, 0.11522097f, 0.27330020f, 0.20827325f, -0.41715023f, 0.07790645f, 
    -0.18594289f, 0.16707645f, -0.01444587f, 0.05911721f, 0.70444930f, -0.00239292f, -0.10511561f, 0.17794994f, 
    0.08265467f, -0.09472455f, 0.13223632f, 0.25323844f, 0.09897690f, 0.37425885f, 0.02609334f, 0.06972886f, 
    -0.08771381f, -0.01484686f, 0.01333459f, -0.16625965f, 0.13352270f, 0.11162910f, -0.18713152f, -0.08183026f, 
    0.08752082f, 0.14120001f, -0.09700146f, -0.01558324f, -0.09715912f, 0.21757743f, 0.06617883f, 0.12543876f, 
    -0.09673230f, -0.03461098f, 0.00539603f, -0.02694271f, 0.05043589f, 0.01974894f, 0.09186047f, -0.00815532f, 
    -0.55043453f, 0.12071541f, 0.02422111f, 0.43105787f, -0.22236823f, -0.23264644f, -0.02296323f, -0.12630725f, 
    0.10590180f, 0.09406933f, 0.03783993f, -0.15974893f, -0.37283501f, 0.10114805f, -0.45771953f, 0.23171133f, 
    -0.01072593f, 0.00360684f, -0.05249833f, 0.04696518f, -0.04478012f, 0.35137978f, 0.10807738f, -0.76380432f, 
    0.17347872f, -0.10673640f, 0.09498664f, -0.11517366f, 0.13410567f, 0.13733403f, 0.14328888f, -0.20009269f, 
    -0.03497303f, 0.01702095f, -0.51625478f, -0.76899546f, -0.49598438f, -0.06687124f, -0.23233351f, -0.77288467f, 
    -0.02414855f, -0.48130563f, 0.39074415f, -0.93934870f, 0.19197148f, -0.02070786f, 0.12826125f, 0.12073518f, 
    0.04373661f, -0.09764218f, 0.10960083f, 0.07845040f, -0.29103205f, -0.32278869f, 0.23518844f, -0.13299698f, 
    0.31484354f, 0.60596162f, -0.07370294f, 0.17796110f, 0.07957636f, -0.31124663f, 0.39143109f, -0.16529557f, 
    0.19758520f, 0.38790613f, 0.11231124f, -0.18147147f, -0.11222098f, 0.17510289f, -0.01329042f, -0.01650326f, 
    0.08316459f, -0.03999005f, -0.19901943f, -0.06960856f, 0.16241378f, 0.03431244f, -0.71910197f, -0.20679839f, 
    -0.16258924f, -0.02605981f, 0.35675851f, 0.23210096f, 0.41879493f, 0.30649695f, -0.19169278f, -0.10857416f, 
    -0.27435949f, 0.50298572f, -0.21277545f, 0.06600999f, 0.55545992f, -0.06036627f, -0.02174505f, -0.08623350f, 
    -0.18860152f, -0.41560495f, 0.18958846f, -0.20325136f, 0.08959679f, 0.38129488f, -0.42468408f, 0.08966590f, 
    -0.07901046f, -0.02993037f, -0.11285603f, 0.23529094f, 0.21918374f, 0.22430639f, 0.11878189f, 0.00254789f, 
    -0.01478627f, -0.23187035f, -0.07026316f, 0.20399290f, -0.33111346f, 0.00256755f, -0.28944555f, 0.24565515f, 
    0.20885333f, -0.36640880f, 0.47089189f, -0.40341157f, 0.00591086f, 0.29586175f, -0.04181425f, 0.39490643f, 
    0.54536867f, -0.15334576f, -0.03320787f, 0.02077663f, 0.29380304f, 0.11383766f, -0.07542446f, -0.21139656f, 
    -0.13843042f, -0.03154369f, -0.61617213f, -0.24208583f, 0.08749428f, -0.05386367f, -0.18044987f, -0.02655455f, 
    -0.03994877f, -0.22255784f, 0.07111762f, 0.13613351f, 0.06037106f, 0.03179822f, -0.01058880f, 0.01972420f, 
    -0.11222386f, 0.06997228f, -0.00806067f, 0.03137317f, 0.19714433f, -0.06965614f, 0.00648351f, 0.06412171f, 
    0.31708884f, -0.02044296f, 0.59553784f, 0.00443211f, -0.01374971f, 0.04683514f, 0.11378531f, 0.29327300f, 
    -0.04234934f, 0.36341146f, 0.25545889f, -0.01461732f, 0.16247949f, 0.11232971f, 0.16355829f, -0.01224264f, 
    0.03639813f, 0.05499005f, 0.09076728f, -0.06955378f, -0.25937492f, 0.63447565f, 0.03169385f, -0.05940650f, 
    -0.12610191f, -0.10109451f, 0.22648804f, 0.00112732f, -0.10094041f, -0.43696004f, 0.23386697f, -0.26016256f, 
    -0.10186829f, 0.04192144f, 0.05210903f, 0.10386971f, 0.01127146f, -0.04407148f, 0.12222205f, -0.06342720f, 
    -0.09183248f, 0.09820783f, 0.02530875f, 0.03244600f, 0.04252516f, -0.05398822f, 0.00993323f, -0.11821976f, 
    0.00114979f, -0.06925297f, -0.06581165f, -0.04582829f, 0.06329669f, -0.00659555f, 0.02103429f, -0.12082469f, 
    0.01981172f, -0.03589540f, -0.15386721f, -0.10257354f, -0.08626099f, -0.10279545f, 0.01634874f, -0.05436588f, 
    -0.12765753f, -0.10226744f, -0.11510994f, 0.03314818f, -0.07664325f, 0.00790852f, 0.05471926f, 0.04917552f, 
    0.01668657f, 0.08526827f, 0.03088894f, -0.04086613f, 0.01188614f, -0.15732622f, -0.00304563f, 0.06855686f, 
    -0.11658640f, -0.02023473f, -0.04923810f, -0.08261803f, -0.04471507f, 0.05035982f, -0.07482450f, 0.05843859f, 
    -0.01741389f, 0.08692345f, -0.15071431f, 0.06830360f, -0.04356820f, -0.00336694f, -0.14011216f, 0.01083764f, 
    0.34393781f, 0.27227139f, -0.08469806f, -0.04857057f, -0.16977023f, 0.14744359f, -0.11926528f, -0.09525673f, 
    0.12866543f, 0.10390847f, 0.25512883f, -0.07160769f, 0.44858313f, 0.05645466f, 0.29117575f, -0.01695398f, 
    0.27637762f, -0.13496861f, 0.05171417f, 0.30831105f, -0.22536746f, -0.06976938f, 0.61720252f, 0.04481040f, 
    0.41584396f, 0.11457838f, 0.08098614f, 0.08145376f, 0.14396526f, 0.36478975f, 0.01442214f, 0.08118147f, 
    -0.05996702f, 0.04417906f, 0.05204239f, 0.27599832f, -0.29396510f, -0.20367147f, -0.03158608f, -0.05285055f, 
    0.09009968f, -0.07923432f, 0.27707934f, 0.03917553f, -0.01209168f, 0.32281828f, 0.02274031f, 0.16806148f, 
    0.06335178f, 0.08535138f, -0.06024973f, 0.06656124f, 0.25671646f, 0.22202781f, 0.16393481f, 0.02585721f, 
    0.04082641f, -0.22413729f, 0.12975350f, 0.06546168f, 0.03250972f, -0.00063663f, -0.00032123f, -0.38860139f, 
    0.40365589f, 0.12429562f, -0.00666296f, -0.12371696f, -0.15093781f, 0.15477289f, -0.32755291f, 0.14873706f, 
    0.21715461f, 0.01300973f, 0.30335128f, -0.21666767f, -0.18938640f, -0.12147947f, 0.27218217f, 0.18108389f, 
    -0.04863451f, -0.08592474f, 0.11567608f, 0.22187307f, -0.53853965f, -0.32341769f, 0.32872984f, 0.17134660f, 
    0.46425980f, -0.26857740f, -0.25748125f, -0.01886313f, -0.02634100f, 0.12344701f, -0.20434518f, -0.07658551f, 
    -0.08222941f, 0.26883572f, 0.08963636f, 0.41615015f, -0.14492635f, -0.21809433f, -0.02289083f, -0.03327246f, 
    -0.05269359f, 0.18502004f, 0.06867813f, -0.05726077f, 0.15941031f, 0.39851636f, 0.04051051f, 0.22326745f, 
    0.02275668f, 0.06404135f, -0.04112691f, 0.29385498f, 0.44029424f, -0.02356421f, 0.05472798f, 0.05480795f, 
    0.00885698f, 0.00288893f, 0.05807926f, 0.44602454f, -0.09778735f, -0.04466129f, -0.22708918f, -0.22809565f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.18242489f, -0.32816848f, -0.07851022f, 0.03627367f, -0.17985795f, -0.32435954f, 0.11397534f, -0.12447790f, 
    0.11381857f, 0.02231985f, -0.09694765f, 0.47097829f, -0.12030459f, 0.05788895f, 0.24720165f, 0.39324743f, 
    0.15840292f, -0.15359740f, -0.09228464f, 0.08970686f, -0.05003284f, 0.07968970f, 0.20073105f, 0.15601474f, 
    0.32969564f, 0.15725815f, 0.07064725f, 0.14879791f, 0.11486571f, 0.27295846f, -0.04835274f, -0.39774901f, 
    0.29732800f, 0.05892818f, 0.20660049f, -0.15307641f, 0.04731181f, 0.14764434f, 0.21311785f, 0.06751530f, 
    -0.06864789f, 0.12980194f, 0.30465272f, 0.25384459f, -0.03818473f, 0.12784024f, -0.09699222f, 0.12558389f, 
    0.24357527f, 0.16699050f, 0.06111364f, -0.01576608f, 0.12280665f, -0.01971767f, 0.29624411f, 0.08597428f, 
    0.13673434f, 0.23736109f, -0.18377005f, 0.08395961f, 0.07058510f, -0.04328733f, 0.32890955f, 0.16562331f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.26418167f, -0.87346393f, 0.14520361f, 0.14653043f, -0.14251666f, -1.03102744f, 0.03296686f, -0.10070453f, 
    -0.24141586f, 0.01554104f, -0.04295582f, 0.07039269f, -0.11234181f, -0.21136196f, -0.16748586f, 0.11105341f, 
    -0.82150006f, -0.00534170f, 0.05525108f, -0.22742338f, -0.60889167f, -0.56198883f, 0.13779131f, -0.49591777f, 
    0.07294193f, 0.08831833f, -0.41909954f, 0.28870589f, -0.02576343f, -0.40130600f, 0.17055047f, -0.77347541f, 
    -0.14878502f, -0.22449930f, -0.33822629f, 0.06215197f, -0.13992743f, -0.09355205f, -0.12078222f, 0.39408290f, 
    -0.55859298f, 0.27475342f, 0.14341572f, 0.22224230f, 0.19866121f, 0.04536559f, 0.04262538f, 0.13920939f, 
    -0.57630724f, 0.06136387f, 0.03802090f, 0.09109684f, -0.21341211f, 0.17651974f, 0.31251368f, 0.24082792f, 
    -0.15262701f, -0.00979720f, -0.08117224f, -0.14688657f, 0.04140965f, 0.09111699f, 0.26567695f, -0.09550036f, 
    -0.06808438f, 0.12876050f, 0.17543298f, 0.05042027f, -0.18514737f, 0.46365309f, 0.43493053f, -0.08915640f, 
    0.24836116f, 0.30822730f, -0.08297702f, -0.04344778f, 0.00998425f, 0.10498794f, -0.50157249f, -0.12690388f, 
    -0.63376123f, -0.08621557f, 0.00187707f, 0.22408012f, 0.07811791f, 0.04283551f, -0.10641681f, -0.47844192f, 
    -0.11272824f, -0.68460608f, -0.64200521f, -0.10185840f, 0.17455336f, -0.02775926f, -0.20779003f, 0.47552469f, 
    0.17028800f, 0.09404224f, -0.79906708f, -0.15204848f, -0.07241154f, 0.07196384f, -0.23323344f, 0.01322306f, 
    0.41812620f, 0.02215948f, 0.22448291f, 0.18452297f, -0.43358374f, 0.15488775f, -0.03367689f, -0.12250664f, 
    0.04944840f, -0.51047999f, 0.07651040f, 0.02701976f, -0.02647156f, -0.50716746f, -0.12765197f, 0.04960378f, 
    -0.68820012f, 0.21237509f, -0.39191508f, 0.41473708f, 0.25971809f, 0.01812885f, -0.07395404f, 0.03157197f, 
    0.36119553f, 0.41724750f, 0.33760241f, -0.01272622f, 0.30493590f, -0.61881220f, -0.19719718f, 0.07652403f, 
    -0.01839625f, 0.18592833f, -0.08971833f, -0.08443183f, 0.09624576f, 0.11421117f, 0.10071700f, -0.20756243f, 
    0.16795869f, 0.02712471f, -0.13444750f, 0.20822228f, 0.21579425f, -0.16740103f, -0.21715949f, 0.08170840f, 
    -0.22375791f, -0.05678346f, 0.54889566f, -0.03933252f, 0.06833820f, -0.46530765f, 0.41970652f, -0.57132071f, 
    0.08187387f, -0.29325026f, 0.06240278f, 0.03519407f, -0.09313092f, -0.03060138f, -0.56998283f, -0.00488064f, 
    -0.60854256f, 0.24010649f, -0.25631222f, 0.08889423f, 0.05416706f, -0.15487929f, -0.10742503f, -0.28418365f, 
    -0.48941711f, 0.24466020f, 0.06458796f, -0.00100111f, -0.12829340f, -0.19287622f, 0.10535342f, -0.62062371f, 
    -0.37988374f, 0.19347002f, 0.50167012f, -0.09656633f, 0.01859335f, 0.05437332f, -0.28056523f, -0.46465448f, 
    0.07705623f, 0.04480786f, 0.09974928f, -0.49635717f, -0.10575894f, 0.21237524f, 0.24465595f, -0.12333305f, 
    0.19907396f, -0.25800785f, 0.00841345f, -0.66695476f, -0.05812778f, -0.00243488f, -0.69148225f, -0.00382868f, 
    0.22891811f, -0.12544276f, 0.05859063f, 0.00517775f, -0.44239742f, 0.18509495f, -0.09642828f, 0.22683661f, 
    -0.53482658f, 0.00058245f, 0.15571921f, -0.38926801f, -0.09653223f, -0.02137864f, -0.45403826f, 0.13703117f, 
    0.79590499f, 0.23946406f, 0.46980661f, 0.08458386f, -0.00070956f, -0.60462117f, 0.18023200f, -0.32628191f, 
    0.26503086f, -0.00424242f, -0.34970039f, -0.45266262f, 0.07628641f, 0.06574653f, 0.10485471f, -0.12312099f, 
    0.11109105f, 0.38118199f, -0.68711144f, 0.09066040f, -0.40780532f, 0.19679335f, -0.11362666f, 0.03480488f, 
    0.22219053f, 0.10116544f, -0.51777619f, 0.22907390f, 0.06174690f, -0.01758703f, 0.08165990f, 0.01405115f, 
    -0.21206217f, -0.22753289f, -0.58358294f, 0.05162259f, -0.06293511f, -0.30159724f, -0.36802721f, -0.05613137f, 
    -0.34923583f, 0.05896627f, -0.10352506f, -0.03464899f, -0.05316792f, -0.15746610f, 0.23618934f, 0.13209088f, 
    0.09024423f, 0.08397079f, -0.10145443f, -0.22628713f, -0.25203171f, 0.14473492f, -0.00054740f, 0.09605420f, 
    -0.08762162f, 0.15696889f, -0.19504727f, -0.22806472f, 0.06599741f, -0.01184988f, -0.08184571f, -0.60807091f, 
    0.20944043f, -0.11122304f, 0.18872482f, -0.06688980f, -0.00229396f, 0.21192908f, 0.26583451f, -0.09098254f, 
    -1.04794645f, 0.05559728f, -0.12968056f, 0.16597316f, 0.06650202f, 0.24789596f, 0.09963001f, -0.02633042f, 
    -0.15811792f, 0.19236554f, -0.16804615f, -0.06906476f, -0.25162551f, 0.08587768f, 0.18066783f, 0.17277592f, 
    0.00554618f, -0.01102517f, -0.11543203f, 0.06913933f, 0.06423735f, 0.06415037f, 0.18600215f, 0.12513612f, 
    -0.30177179f, -0.16947247f, -0.04502734f, -0.26303464f, -0.34122851f, 0.51145250f, -0.45897055f, 0.07253121f, 
    -0.44998482f, -0.21237457f, -0.00251400f, 0.33301091f, -0.08754237f, 0.16740185f, 0.21190754f, 0.33818185f, 
    -0.20718193f, 0.02255605f, -0.09066719f, 0.03802096f, -0.01613664f, 0.18053535f, 0.15244381f, -0.42460284f, 
    -0.02662390f, -0.64315689f, -0.55396062f, -0.11712652f, -0.05225116f, 0.33492237f, -0.32423645f, 0.64897323f, 
    0.03751250f, -0.22915119f, -0.08255978f, -0.39914644f, -0.08965953f, 0.02820079f, 0.06539695f, -0.43955481f, 
    0.24151473f, -0.00368706f, 0.22274826f, 0.26492360f, -0.83754861f, -0.06092314f, -0.06396568f, -0.03268061f, 
    0.30976287f, 0.00039284f, -0.04277618f, -0.05146765f, 0.18691435f, -0.31943232f, 0.10371454f, -0.32104588f, 
    0.20601937f, 0.08190223f, 0.55448085f, -0.53578925f, -0.05774593f, -0.09980921f, 0.14383087f, 0.24005595f, 
    -0.14106502f, 0.18599753f, -0.07513436f, 0.10568715f, -0.22223638f, -0.08402292f, 0.32898948f, -0.10920822f, 
    0.40917596f, -0.25512338f, -0.10558180f, -0.04373995f, -0.01511583f, 0.08200648f, -0.52481186f, -0.20704919f, 
    -0.54580724f, -0.10776557f, -0.11143161f, 0.03213236f, 0.28984424f, 0.37598598f, -0.96043056f, 0.01402073f, 
    -0.01468857f, 0.29457664f, -0.55472380f, -0.33778399f, 0.02592259f, 0.05830711f, 0.46416193f, 0.32496768f, 
    -0.62328535f, -0.33445320f, -0.32927999f, -0.15829642f, -0.19543393f, 0.24743198f, 0.14319235f, -0.59893209f, 
    0.16763140f, 0.19772877f, 0.13416398f, -0.06975748f, -0.09797557f, 0.00464294f, 0.08824494f, 0.07787404f, 
    -0.00899273f, 0.13584049f, -0.01712274f, -0.00897883f, 0.18927458f, 0.05816022f, -0.03292289f, 0.05133104f, 
    -0.08544479f, -0.23634373f, -0.13830425f, -0.38216844f, -0.03022319f, 0.00780947f, 0.08227477f, 0.25928733f, 
    -0.02252588f, 0.10996207f, 0.21379276f, -0.07779798f, 0.34705329f, 0.37783277f, -0.52956796f, 0.05892763f, 
    -0.54464036f, 0.12041982f, -0.11413359f, -0.20451568f, -0.10093302f, -0.37061432f, 0.53659815f, 0.09657295f, 
    -0.05383209f, -0.02933734f, -0.04083168f, -0.65105051f, 0.25034702f, -0.47886360f, 0.23613806f, -0.16065486f, 
    -0.74440056f, -0.57198441f, -0.08084682f, -0.38895220f, -0.59771919f, -0.25265476f, 0.57724816f, 0.37139642f, 
    0.35466540f, 0.28102157f, 0.16269469f, -0.08587723f, 0.24982570f, -0.19112863f, -0.19467734f, 0.03610355f, 
    0.47717437f, 0.11338660f, -0.36762598f, 0.10700284f, 0.16677971f, 0.05821524f, -0.06401389f, -0.92868501f, 
    -0.20924358f, -0.75239670f, -0.08659090f, -0.04198369f, -0.53988844f, 0.14440736f, 0.18009958f, -0.05367323f, 
    0.01817539f, -0.40563846f, 0.83788431f, 0.15207510f, -0.89474875f, 0.06353714f, 0.13039947f, 0.11713737f, 
    0.43205512f, -0.24904427f, -0.38119096f, 0.14262168f, 0.03287330f, -0.14916821f, 0.13742472f, -0.09483592f, 
    0.15869549f, 0.27559727f, -0.08399434f, 0.21448557f, 0.11493849f, 0.07560072f, 0.40720168f, -0.28658167f, 
    0.30010748f, 0.04632165f, -0.01353042f, -0.02408706f, -0.02348664f, -0.56152266f, -0.33378610f, -0.19604623f, 
    0.23826388f, -0.30687034f, -0.30004063f, 0.29388681f, 0.00242303f, -0.07404699f, -0.20774142f, -0.12661946f, 
    0.33188108f, -0.13458548f, -0.24904588f, 0.27664089f, -0.14416370f, -0.20822270f, -0.23478191f, 0.03372607f, 
    -0.41311795f, -0.84449673f, -0.18823248f, -0.50374800f, -0.52445930f, 0.15103656f, 0.05171226f, 0.15015617f, 
    0.15524125f, 0.00147251f, 0.20283090f, -0.04335772f, 0.08574422f, -0.42960045f, -0.77115661f, -0.27542263f, 
    -0.39551547f, 0.18311220f, -0.09625461f, -0.30928862f, 0.05745456f, -0.02159743f, -0.79026759f, -0.80848992f, 
    -0.91599637f, -0.16954276f, 0.21474622f, 0.13449250f, 0.31935811f, 0.03342271f, 0.03753294f, -0.01404963f, 
    -0.52155274f, -0.11400885f, -0.00819362f, -0.03888163f, 0.00239317f, -0.08939922f, 0.47087467f, -0.05863376f, 
    -0.23392338f, -0.04962698f, -0.02170135f, -0.00095831f, 0.08720387f, -0.28313792f, 0.22270660f, -0.09712880f, 
    0.18502356f, 0.23687336f, 0.18006708f, -0.14586322f, 0.13915823f, 0.06106640f, 0.23518436f, -0.01647186f, 
    -0.13167132f, 0.39383811f, -1.62559724f, -0.10697052f, 0.35242063f, 0.13147572f, 0.01606930f, 0.15345991f, 
    -0.85775149f, -0.15526775f, 0.09748227f, 0.06215850f, 0.19980413f, 0.14864473f, 0.09512582f, 0.29621479f, 
    -0.00016024f, -0.27324799f, 0.03763012f, -0.12784766f, 0.10062867f, -0.25153965f, -0.06269898f, -0.05177019f, 
    0.11364800f, -0.41175681f, -1.45603764f, -0.57247865f, 0.19867481f, 0.01896062f, 0.07494650f, 0.09698277f, 
    0.31753036f, -0.26804543f, 0.00026834f, -1.00158441f, -0.36951399f, -0.26444265f, 0.21693687f, -0.09798372f, 
    0.23746805f, 0.19158094f, -0.10287771f, 0.07901020f, 0.06984974f, -0.15101516f, -0.14222354f, 0.21038495f, 
    0.28305706f, 0.00676320f, 0.03408010f, -0.04569682f, -0.16530056f, 0.11870439f, 0.04296071f, 0.21292374f, 
    0.20438844f, 0.20351279f, 0.17019793f, 0.25977468f, -0.21334055f, -0.00039669f, -0.50700498f, -0.32152238f, 
    -0.87001210f, 0.25324783f, 0.20350938f, -0.05241513f, 0.31001765f, -0.52507657f, 0.13137831f, 0.21669942f, 
    0.26450840f, -0.33739856f, -0.27487376f, -0.58701867f, -0.19499797f, -0.43223271f, -0.11167309f, 0.07260584f, 
    -0.00848235f, -0.19901067f, -0.18393432f, 0.08056340f, 0.09380636f, 0.21954806f, -0.18586296f, -0.01098440f, 
    0.17046015f, 0.19238293f, -0.80114096f, 0.24926683f, -0.15590854f, 0.04885208f, -0.07471512f, -0.26592824f, 
    0.01898202f, 0.14945699f, -0.33351111f, 0.05371114f, 0.10357697f, -0.12004937f, -0.45112458f, 0.08151007f, 
    -0.50294316f, -0.55976397f, -0.07701679f, 0.08322202f, 0.05396665f, -0.06642468f, -0.78302360f, 0.10254011f, 
    0.40100995f, 0.00254718f, -0.06567884f, 0.04708154f, 0.19126539f, 0.02532115f, -0.43186831f, 0.33127820f, 
    0.10043249f, 0.17402259f, 0.29979494f, 0.26100433f, 0.00312595f, 0.25294104f, -0.02721073f, 0.09624766f, 
    -0.30122003f, -0.52034146f, -0.18888307f, 0.29958305f, -0.58675689f, -0.24708833f, 0.08028511f, 0.15984102f, 
    -0.24418345f, -0.00938009f, -0.00879336f, -0.11412898f, 0.21350248f, -0.80986154f, -0.04602605f, -0.05799718f, 
    0.13839650f, 0.01028427f, -0.14938377f, 0.01424638f, 0.12327172f, -0.02936960f, -0.17018925f, 0.25165355f, 
    0.16926514f, -0.08930283f, 0.20646295f, 0.17201330f, -0.03489495f, 0.03455752f, -0.08801045f, -0.21161580f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.23216450f, 0.04756170f, -0.02389144f, -0.22207503f, 0.21459267f, 0.28069213f, -0.02939354f, -0.39767000f, 
    -0.34985146f, -0.09179469f, 0.06318422f, -0.10399354f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
