#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.08386537f, -0.66696584f, -0.56761181f, -0.32877249f, -0.28353512f, 0.24376422f, -0.86964065f, 0.41450009f, 
    0.54498738f, -0.09640956f, -0.32439122f, -0.32921037f, -0.42959136f, 0.20206840f, -0.15609063f, 0.23178868f, 
    0.28084287f, -0.31856200f, -0.24098922f, 0.07298181f, -0.23021306f, 0.13860236f, 0.24767603f, -0.06845200f, 
    -0.01686092f, 0.60205203f, 0.66349053f, 0.67810166f, -0.03483946f, -1.02988946f, -0.58646786f, -0.42777029f, 
    0.18525469f, -0.07293467f, -0.16369562f, 0.08866061f, 0.35942274f, -0.28017715f, 0.45134935f, -0.17046100f, 
    0.03986731f, -0.10285000f, 0.43026781f, 0.09970930f, -0.13266478f, -0.42661336f, -0.01579936f, -0.24113305f, 
    -0.09058885f, 0.12758292f, 0.88274026f, 0.68902093f, 0.09880871f, -0.15298472f, -0.18461873f, 0.17486088f, 
    -0.61943108f, 0.02185208f, 0.03911023f, 0.32747859f, 0.37080741f, 0.02296041f, 0.09533533f, 0.14128676f, 
    -0.11123157f, -0.25769988f, 0.20864952f, 0.14854452f, 0.40866494f, -0.36809033f, 0.38558593f, 0.08089473f, 
    -0.18071596f, -0.10925414f, -0.22743693f, 0.00681518f, -0.03039847f, -0.38421240f, 0.52232862f, -0.93865925f, 
    -0.42069858f, 0.67154104f, 0.71687740f, -0.23669742f, 0.30545199f, 0.30505234f, -0.17916395f, -0.31312117f, 
    0.02883722f, -0.30122486f, 0.01288276f, -0.46470243f, -0.19548173f, -0.04111465f, -0.20799874f, -0.13848987f, 
    -0.13910525f, 0.26035225f, 0.56510699f, -0.41850153f, -0.40171319f, -0.64509827f, -0.44407624f, -0.43020290f, 
    -0.46357733f, -0.31136203f, 0.88890308f, 0.68593103f, -0.15428291f, 0.51348966f, -0.55516684f, -0.04993271f, 
    -0.10894854f, -0.49311540f, -0.05220312f, -0.05619784f, 0.07605834f, -0.13994294f, 0.08591501f, -0.03859480f, 
    -0.15268701f, -0.14452995f, -0.29430068f, -0.19398341f, 0.15643848f, -0.49642774f, 0.53127772f, 0.01325019f, 
    -0.17344880f, -0.38692173f, -0.54952204f, -0.25382894f, 0.53036791f, 0.37233129f, -0.03789270f, -0.36197370f, 
    0.45957991f, -0.07835216f, -0.41511285f, -0.35772496f, -0.17931299f, 0.06735689f, -0.38225347f, 0.04749974f, 
    0.04870191f, 0.39230424f, -0.27636996f, -0.08628420f, -0.16508487f, -0.08249614f, 0.54990375f, -0.26049921f, 
    0.13095085f, -0.75921845f, -0.08877172f, 0.57715803f, -0.48151845f, -0.36366239f, 0.17986955f, -0.27442214f, 
    0.43505269f, 0.65098453f, 0.24560581f, -0.15621082f, 0.33769038f, -0.11689804f, -0.28670585f, 0.02333825f, 
    -0.06743756f, -0.07094449f, 0.25441495f, 0.26294148f, 0.00426292f, 0.51071471f, 0.27102247f, -0.69377208f, 
    0.71734893f, 0.74748218f, -0.77256006f, 0.33886674f, -0.34559256f, 0.27354738f, -0.51364332f, -0.58599395f, 
    -0.63671619f, -0.20385766f, 0.26025057f, 0.38081431f, 0.12241842f, -0.44326934f, -0.16252370f, 0.09654497f, 
    0.33450121f, 0.10850698f, 0.30815989f, -0.09296166f, -0.09036670f, -0.18777424f, -0.39087945f, -0.10292029f, 
    0.72636718f, 0.54498786f, 0.30943254f, 0.80523884f, 0.60636771f, 0.08920269f, -0.29594752f, 0.49195126f, 
    0.22242115f, -0.05251962f, -0.51753628f, -0.12576000f, -0.14175968f, 0.20742330f, 0.25851551f, 0.28754655f, 
    0.04209412f, -0.02507383f, -0.33107629f, 0.13972190f, 0.10450009f, -0.10809295f, 0.09245318f, 0.35343343f, 
    0.09989017f, -0.05971274f, -0.32306105f, -0.85936260f, -0.74891239f, -0.41378424f, 0.16578975f, 0.24868672f, 
    0.42161754f, 0.30735010f, 0.31253552f, -0.34289506f, 0.08126064f, -0.05737400f, -0.06225190f, 0.06104793f, 
    0.00980716f, -0.12638481f, 0.13818531f, 0.15502192f, -0.03138468f, -0.17164180f, -0.15036327f, -0.36668473f, 
    -0.17414846f, 0.03014479f, 0.72789091f, 0.66568440f, -0.65004665f, -0.49701139f, -0.59978634f, 0.27260849f, 
    -0.27253416f, -0.20634393f, -0.19864014f, -0.24658631f, 0.28598297f, 0.42180172f, 0.27008906f, 0.59129500f, 
    -0.15276079f, 0.36200845f, -0.24847859f, 0.04606947f, -0.17522539f, 0.29823810f, -0.17559482f, 0.39967349f, 
    -0.07330454f, -0.00053022f, 0.04014836f, -0.62824190f, -0.74930322f, -0.65320879f, -0.45459723f, -0.17987841f, 
    -0.53667104f, -0.54030281f, -0.32245919f, -0.39878097f, 0.35417673f, -0.06554189f, 0.10934020f, 0.31456536f, 
    0.04076042f, 0.03887282f, -0.00231784f, 0.01194729f, 0.03508541f, 0.10767763f, 0.08887301f, -0.16615605f, 
    -0.13600045f, -0.08649424f, 0.03116176f, -0.12035213f, -0.19362831f, 0.67776763f, 0.65223283f, -0.36819118f, 
    0.80480111f, 0.71837664f, 0.28581005f, -0.81437993f, 0.19680934f, -0.32875335f, -0.09144510f, 0.30281422f, 
    0.14531983f, 0.27822316f, 0.07391177f, -0.02130010f, 0.09635322f, -0.13570541f, -0.28319448f, -0.12213157f, 
    0.18591180f, -0.04127309f, -0.13874955f, 0.07732984f, -0.19989116f, -0.22642611f, 0.90547603f, -0.73677856f, 
    0.93090767f, -0.62074339f, 0.53753364f, -0.30082014f, -0.52866828f, -0.31109524f, -0.20970027f, 0.20900065f, 
    -0.17637898f, -0.23019357f, -0.04455778f, 0.07460830f, 0.06441946f, 0.01316748f, 0.15604441f, 0.12681000f, 
    0.09921252f, 0.04723154f, -0.45526445f, 0.23821177f, -0.04164534f, -0.28911379f, -0.12348849f, -1.25265241f, 
    -0.10801518f, 0.65157962f, 0.14140040f, 0.55093193f, 0.20844088f, 0.36886182f, -0.23776804f, 0.04299371f, 
    -0.05422575f, 0.23967557f, -0.34193268f, 0.46382290f, 0.43699181f, 0.06108406f, 0.04400745f, 0.13472846f, 
    -0.09283753f, 0.08023653f, 0.04265844f, 0.22997355f, 0.08475861f, -0.01462287f, -0.31330368f, 0.49672514f, 
    -0.32523632f, -0.50059068f, -0.01220220f, -0.09652623f, -0.52113599f, -0.65073758f, 0.15457964f, -0.14094077f, 
    -0.14798279f, -0.48935392f, -0.46580735f, 0.33049127f, -0.22356424f, -0.29654253f, -0.09412406f, -0.43882781f, 
    0.11424261f, 0.11283308f, -0.00486894f, 0.25576779f, 0.12337209f, 0.02291390f, -0.05620653f, -0.09100109f, 
    -0.04154750f, -0.28646523f, -0.32033437f, -0.25254640f, -0.13403934f, 0.16911954f, -0.22363141f, -0.20321220f, 
    -0.20939219f, -0.15105991f, -0.08864854f, -0.16638909f, 0.26149547f, -0.20786647f, 0.14905888f, 0.40979370f, 
    0.13579838f, 0.13677029f, 0.28915605f, 0.22192134f, 0.45111567f, 0.16775765f, -0.53816807f, 0.32098761f, 
    0.41842690f, 0.81427997f, -0.35890687f, 0.03265238f, 0.14321606f, -0.01534799f, 0.53914618f, -0.52096301f, 
    0.38084292f, 0.47934666f, 0.52683854f, 0.38744909f, -0.39745823f, -0.38669819f, -0.45285740f, -0.15807413f, 
    0.07483651f, -0.24699666f, -0.30380377f, -0.17457205f, 0.13478957f, 0.19942042f, -0.08777416f, -0.06638474f, 
    -0.08249328f, -0.43320027f, 0.73723435f, 0.76012397f, 0.61928517f, -0.46793461f, 0.43681368f, -0.83576423f, 
    0.27369443f, 0.07440954f, -0.23590906f, 0.03488826f, 0.23039295f, 0.04380593f, -0.06694974f, 0.09634491f, 
    0.35269141f, -0.03018948f, 0.41432914f, 0.15389718f, 0.11426387f, 0.27283552f, 0.31063613f, 0.09017039f, 
    0.03241074f, 0.08201517f, -0.02900487f, 0.75640851f, 0.74330956f, 0.79932594f, -0.16519798f, -0.82740259f, 
    -0.43740463f, -0.51140243f, 0.21683910f, -0.04388733f, 0.64687008f, 0.27953681f, 0.11128740f, 0.01325493f, 
    -0.14292333f, 0.19298355f, 0.13529959f, -0.10019091f, -0.02649987f, -0.18337655f, -0.06010483f, 0.08721936f, 
    0.03262812f, 0.19498040f, -0.24871217f, 0.06611518f, 0.34440395f, 0.21562921f, 0.55997628f, -0.35112995f, 
    0.12276993f, -0.19125617f, -0.30443391f, -0.72171551f, -0.67166841f, -0.58954692f, 0.18985057f, 0.47571123f, 
    -0.06623329f, 0.22119711f, 0.31321320f, -0.20331727f, -0.03057045f, -0.33481014f, 0.00920891f, -0.12205178f, 
    0.26106867f, 0.58254468f, -0.02330858f, 0.11253435f, 0.00941950f, -0.26940677f, -0.22051820f, 0.21133330f, 
    -0.64367133f, 0.39474022f, 0.16276403f, -0.69100940f, -0.45058268f, -0.60688400f, -0.25193533f, 0.14448561f, 
    0.38432610f, 0.12454078f, 0.34862474f, 0.03049231f, 0.17411725f, -0.21496977f, 0.27866223f, 0.38654360f, 
    0.48809066f, -0.14635932f, 0.16599047f, -0.06242089f, -0.16365616f, 0.56417966f, 1.14075124f, 0.81674570f, 
    0.78527766f, -0.16939598f, 0.06850187f, -0.12754869f, -0.44261718f, 0.24248226f, 0.25847268f, 0.29046994f, 
    -0.00022575f, 0.27675489f, -0.35799557f, -0.15286687f, -0.09372737f, -0.10159354f, 0.02001012f, -0.09581343f, 
    -0.15576744f, 0.04312513f, -0.06266140f, 0.60332012f, 0.02151979f, 0.31145149f, 0.10972000f, -0.36732647f, 
    -0.03548972f, 0.04065038f, -0.06391302f, -0.23100628f, 0.16051231f, -0.27899113f, -0.50349307f, 0.41298562f, 
    -0.16795298f, 0.28963485f, 0.42663801f, 0.34758815f, -0.37878382f, -0.27054697f, 0.19266771f, 0.10902377f, 
    0.41208380f, 0.45623893f, -0.30738652f, -0.45105392f, 0.38231179f, -0.03474291f, -0.07680669f, -0.07769394f, 
    -1.19253862f, 0.65613598f, 0.04320072f, -0.38667989f, 0.04439406f, -0.30342904f, 0.73930955f, 0.47594431f, 
    -0.29093203f, 0.13354999f, -0.45091835f, 0.02938553f, 0.40508240f, -0.03472818f, 0.12611341f, -0.20443143f, 
    -0.23626183f, 0.02135885f, 0.07949560f, -0.14638104f, 0.39886472f, 0.29465774f, 0.16901354f, 0.31218603f, 
    0.01488988f, 0.35409170f, -0.12573683f, 0.23347814f, 0.88682348f, 0.68919843f, 0.65403235f, 0.41441384f, 
    0.15279548f, 0.30343273f, 0.16572365f, -0.10152777f, 0.25112608f, 0.08913176f, -0.33915451f, -0.34453520f, 
    -0.20560710f, -0.20527838f, 0.32130602f, -0.26747772f, -0.19273418f, 0.26891717f, -0.02110563f, 0.07429908f, 
    -0.01388560f, 0.24115101f, -0.35219547f, -0.32495940f, -0.34444124f, -0.55184358f, -0.34674436f, 0.00960261f, 
    0.62818772f, -0.50341296f, -0.24206151f, -0.10061405f, -0.22826530f, -0.12953757f, -0.09108294f, -0.06988361f, 
    0.03209743f, 0.00657285f, 0.13415138f, 0.07440701f, 0.00389480f, -0.13304475f, 0.23214571f, -0.21321431f, 
    0.37201825f, -0.14242966f, 0.05472677f, 0.65103918f, -1.04667377f, 0.38975599f, 0.34154731f, -0.27085266f, 
    0.52315372f, 0.35413596f, 0.43751475f, 0.51288211f, 0.33845925f, -0.15171613f, -0.17320672f, -0.48771811f, 
    0.20704624f, -0.22725447f, -0.10407758f, 0.07466902f, -0.11376650f, 0.35611981f, 0.01314948f, 0.07301431f, 
    -0.06043783f, -0.06590381f, -0.03327356f, 0.18633112f, -0.37823063f, -0.74840361f, -0.46961811f, 0.05511080f, 
    0.28784621f, 0.21482573f, -0.11510188f, -0.41163853f, -0.15283211f, -0.72802877f, -0.48229039f, -0.01461405f, 
    0.03437164f, 0.28263822f, 0.24897091f, 0.53890830f, 0.16222589f, 0.26222929f, 0.08048739f, 0.01829980f, 
    0.09931368f, 0.21534923f, 0.02360101f, 0.07450897f, -0.15929228f, -0.71694058f, -0.55643070f, 0.36142319f, 
    0.13244379f, -0.65002888f, -0.32481983f, 0.20560044f, -0.22022569f, -0.06518017f, -0.07658536f, 0.29029706f, 
    0.23437688f, -0.32590771f, 0.51901442f, 0.09804625f, 0.25286001f, -0.49591950f, 0.06121690f, 0.01638427f, 
    -0.16219936f, -0.02859175f, 0.24397023f, 0.02997524f, 0.03196710f, 0.31542218f, -0.59893829f, -0.07569600f, 
    -0.12256214f, 0.29871908f, 0.56156385f, -0.62352663f, -0.23939750f, -0.50078076f, -0.42321149f, -0.26440424f, 
    0.35436514f, 0.46898267f, 0.22910458f, -0.08791956f, 0.07813781f, 0.48505449f, 0.12387010f, 0.06256532f, 
    -0.11527788f, 0.09620378f, -0.16928156f, -0.07145298f, -0.08165897f, 0.31691474f, -0.10158669f, 0.56614923f, 
    0.45243096f, -0.27821514f, 0.48104069f, 0.34016997f, -0.71962690f, -0.52240580f, -0.53571820f, 0.20670703f, 
    -0.10904132f, 0.10563797f, 0.30001500f, 0.40094787f, -0.00468454f, -0.00052568f, -0.10550491f, 0.05849748f, 
    0.13028109f, -0.08676576f, 0.07073110f, 0.31763455f, 0.08538680f, -0.20338741f, -0.20120363f, 0.43677449f, 
    -0.60920101f, -0.55094314f, 0.01979096f, -0.00281011f, 0.64159763f, 0.85227054f, 0.31010413f, -0.69909352f, 
    0.08145637f, -0.41262567f, 0.25369084f, 0.35644206f, -0.06951790f, 0.23520163f, -0.11045643f, -0.36024672f, 
    -0.25330371f, -0.14931801f, -0.25722805f, 0.14982159f, 0.06490777f, -0.12048925f, -0.06222725f, -0.31424412f, 
    0.00546107f, 0.70388830f, 0.51417196f, -0.23043013f, 0.62852144f, 1.07679451f, 0.36350083f, 0.49245638f, 
    0.46934187f, 0.64732444f, 0.37094465f, -0.22973010f, 0.25231454f, 0.02689289f, 0.26003176f, -0.04922877f, 
    0.09223779f, -0.13842931f, 0.09636236f, -0.07402496f, -0.18178383f, 0.39515623f, -0.07430101f, 0.06031642f, 
    0.09710842f, 0.16636111f, 0.31602567f, 0.16711484f, 0.09698101f, 0.33636072f, 0.35547978f, -0.61639977f, 
    -0.78918046f, -0.47884488f, -0.44480610f, 0.02687171f, 0.08582581f, -0.04238806f, -0.08724375f, 0.34844595f, 
    -0.16172943f, -0.17254089f, 0.12884445f, 0.18650074f, -0.24207446f, 0.16341688f, 0.10801950f, -0.11774812f, 
    0.31460658f, 0.11401954f, -0.14746559f, -0.36869580f, 0.04895242f, -0.15847923f, -0.44388399f, -0.50892383f, 
    0.74370939f, 0.84748167f, 0.31570914f, -0.06865358f, 0.31086487f, -0.06835482f, -0.12469174f, -0.06188634f, 
    -0.07949493f, 0.13619152f, 0.05860632f, 0.36159086f, -0.02832633f, -0.00336553f, 0.07800273f, -0.10392677f, 
    -0.02524805f, -0.10675918f, -0.29537898f, 0.10454356f, -0.97639877f, 0.39638898f, 0.62805814f, -0.31574970f, 
    -0.32561332f, 0.76886624f, 0.31975964f, 0.39153585f, 0.62981623f, 0.61746639f, 0.14668356f, -0.20545764f, 
    0.03555580f, -0.30220336f, -0.45850360f, 0.20807959f, -0.33713457f, -0.16567270f, -0.40044639f, 0.17233641f, 
    -0.06423154f, -0.07806335f, 0.29575485f, 0.30048355f, -0.13330866f, -0.50659692f, 1.03737795f, -0.22126000f, 
    -0.98796058f, -0.21385594f, 0.33055094f, 0.49176502f, -0.46382919f, 0.37474239f, 0.37509149f, 0.12367199f, 
    0.08287249f, -0.49187016f, -0.19454840f, -0.44364020f, 0.12900372f, 0.16898309f, -0.07752507f, 0.33274898f, 
    0.06786129f, -0.36346808f, -0.22390588f, 0.01307470f, -0.16156699f, 0.35155442f, 0.10549767f, 0.85377175f, 
    -0.59599704f, -0.45436126f, -0.41235369f, 0.06265396f, -0.27172536f, -0.27251768f, -0.42185807f, 0.10098255f, 
    0.13278335f, 0.30301717f, 0.61789250f, -0.05366447f, -0.42573711f, -0.55309922f, 0.10082946f, -0.02845902f, 
    0.22038475f, -0.40715179f, 0.04213445f, -0.17984080f, 0.18393904f, 0.35855114f, 0.04977490f, 0.00356713f, 
    -0.32363439f, -0.06379712f, -0.41452065f, 0.13788292f, -0.79922581f, 0.03417714f, -0.72879505f, -0.64146870f, 
    -0.13417491f, -0.36174703f, -0.02421680f, -0.38738918f, -0.13609275f, -0.37495828f, -0.26938248f, -0.27955040f, 
    -0.47685170f, -0.21389213f, -0.21765248f, 0.14652327f, 0.11446843f, -0.04298091f, -0.26913676f, -0.13520367f, 
    0.81508106f, 0.69295806f, 0.29433227f, 0.67301410f, -0.21275680f, 0.14338340f, 0.26129726f, -0.08610127f, 
    0.27026221f, -0.28694758f, 0.18011911f, -0.06898090f, 0.05327183f, -0.21961641f, -0.01801169f, -0.21474534f, 
    0.16068038f, 0.08429222f, 0.29171765f, 0.12229324f, -0.20735541f, -0.21991935f, -0.26866412f, -0.00266931f, 
    0.07736450f, -0.34514764f, -0.58458149f, -0.57058913f, 0.31870592f, -0.59847313f, -0.31814963f, 0.08436161f, 
    0.54162055f, 0.05300720f, -0.11580755f, 0.18936369f, 0.32782552f, 0.34338501f, 0.37059751f, 0.23840180f, 
    -0.57825136f, -0.21176116f, 0.11578947f, -0.49323472f, -0.25091895f, 0.47557870f, 0.06150362f, -0.06956266f, 
    0.03341856f, 0.16160332f, 0.17219526f, -0.22332832f, -0.64210075f, 0.52010441f, 0.93158144f, 0.70636940f, 
    0.27620137f, -0.38417119f, 0.37291807f, -0.12258793f, -0.41241625f, 0.09745663f, 0.02231085f, 0.27943799f, 
    0.33148298f, -0.18859699f, -0.37710869f, -0.10557552f, -0.45332652f, -0.21463676f, 0.21932372f, -0.11452852f, 
    0.06842080f, 0.01009620f, -0.20899241f, -0.33001360f, -1.20659232f, -0.30552098f, 0.29308841f, 0.38610071f, 
    -0.38505825f, 1.01700187f, 0.04314166f, -0.13629904f, 0.36895716f, -0.02373969f, 0.14028519f, -0.20958012f, 
    0.09552477f, 0.29166311f, -0.23010759f, 0.09966610f, -0.19660912f, 0.04664064f, -0.22860947f, 0.11529473f, 
    -0.06817228f, -0.02467736f, -0.17226544f, 0.14855585f, -0.06016184f, -0.48806706f, -0.14073354f, -0.28603160f, 
    0.42597800f, -0.04165640f, -0.93342370f, -0.73117679f, -0.71994776f, -0.15665348f, -0.59736037f, 0.45526892f, 
    0.31534591f, -0.40611845f, 0.07021358f, -0.17290996f, -0.15298593f, 0.03840487f, -0.26731828f, 0.21409233f, 
    -0.07091534f, -0.12023431f, 0.08429052f, 0.02022296f, 0.27028129f, -0.01539479f, 0.67159456f, 0.28892723f, 
    0.82011455f, 0.87094498f, 0.28718215f, -0.19867699f, -0.59761816f, 0.38602701f, 0.23981693f, -0.30738372f, 
    -0.44160414f, 0.17125127f, -0.06947611f, -0.28977662f, -0.02441039f, 0.13334906f, 0.23511766f, 0.15176246f, 
    0.07053243f, 0.04778060f, -0.09768199f, -0.36101121f, 0.00117879f, -0.07093710f, -0.29475635f, -0.36526391f, 
    -0.68283391f, -0.28010905f, 0.36549386f, -0.04846701f, 0.11212845f, -0.26522449f, 0.36287612f, 0.22972068f, 
    -0.38251886f, -0.12286207f, -0.06905607f, 0.37677458f, -0.35363409f, -0.27121690f, -0.13667932f, 0.15600537f, 
    0.44910207f, 0.03356339f, 0.02658385f, 0.26575586f, -0.26811421f, -0.03810706f, 0.26334250f, -0.02344085f, 
    -0.45664740f, 0.93398213f, 0.34496483f, 0.45497927f, 0.57604492f, -0.36404476f, 0.28197455f, 0.08612238f, 
    -0.42180917f, 0.33612001f, -0.10985947f, 0.00322981f, 0.06813746f, 0.30365449f, 0.26749057f, 0.43318242f, 
    0.24078903f, 0.39484465f, 0.04416012f, -0.04299179f, -0.25290594f, 0.03038443f, 0.06452917f, 0.09858587f, 
    1.04037941f, 0.17980699f, -0.50225848f, -0.77143353f, -0.39083406f, -0.00012832f, 0.42065307f, 0.28056502f, 
    -0.21553110f, -0.40776461f, 0.14808288f, 0.24832228f, 0.21317530f, 0.17355664f, -0.48064342f, 0.03578117f, 
    -0.01569632f, -0.03819679f, -0.03910129f, -0.01655256f, -0.08825999f, 0.01396339f, -0.09627917f, -0.27658877f, 
    0.24817853f, -0.65495765f, -0.05649633f, -0.07677256f, 0.11234980f, 0.40943214f, 0.18072362f, -0.32780683f, 
    -0.14059070f, -0.54369444f, -0.10317548f, 0.14888580f, 0.46069756f, -0.08931689f, -0.02183621f, 0.04961531f, 
    0.20537519f, 0.04628429f, -0.30356514f, -0.03830277f, 0.31698507f, 0.13172586f, -0.04089006f, 0.51471668f, 
    0.22579327f, -0.30068809f, 0.49986988f, 0.25238547f, 0.67955762f, 0.90095413f, 0.34292275f, -0.03934881f, 
    -0.00938562f, -0.49515295f, -0.34479856f, 0.19947317f, 0.07114748f, 0.12845893f, 0.17177273f, 0.19114238f, 
    -0.25237212f, -0.38399130f, 0.56011033f, 0.07800753f, -0.10301054f, -0.16979468f, -0.14997160f, 0.08313952f, 
    -0.27829793f, -0.30468667f, 0.18373691f, -0.45882684f, -0.54326785f, -0.48947877f, -0.27400738f, -0.49542028f, 
    -0.03819840f, 0.25383464f, -0.19280590f, 0.56359428f, 0.66227174f, 0.10797432f, 0.26178801f, -0.14026545f, 
    -0.05752898f, -0.09056070f, -0.14015150f, 0.21738560f, 0.11739917f, 0.34985834f, 0.10265020f, 0.13148503f, 
    0.32829532f, 0.26603481f, 0.28481671f, 0.42743650f, 0.40421045f, -0.80768991f, -0.31698415f, 0.69524068f, 
    0.16642377f, -0.95377803f, -0.22741710f, 0.43973663f, -0.51658690f, -0.26654845f, 0.15431097f, 0.46698684f, 
    0.15612154f, -0.26054323f, 0.07702214f, -0.05599875f, -0.11351060f, -0.10551121f, -0.12245531f, -0.36021015f, 
    0.19019549f, 0.20959580f, -0.19432141f, 0.16126211f, -0.02019965f, 0.98911327f, 0.46944958f, -0.12482509f, 
    0.17922352f, 0.28110394f, 0.64067638f, -0.06765248f, -0.60351837f, 0.18487337f, 0.30325216f, 0.14738876f, 
    -0.08739258f, -0.25316727f, 0.07171404f, 0.02544796f, 0.06483167f, 0.07876989f, -0.31876567f, -0.12912223f, 
    0.39971751f, -0.31327337f, 0.19002743f, 0.25334528f, -0.22600278f, 0.27984151f, 0.73653525f, 0.19205692f, 
    0.57126176f, 0.22503129f, 0.78609562f, -0.51711547f, 0.54010135f, 0.39596713f, -0.43607345f, 0.04809809f, 
    0.21588072f, -0.28757530f, -0.05568253f, 0.01368611f, -0.50390631f, 0.15382755f, -0.26044485f, 0.02697781f, 
    -0.02175185f, -0.36084709f, -0.02312407f, 0.14762932f, 0.16452843f, 0.03577108f, -0.15384395f, -1.28495669f, 
    -0.19329649f, -0.46746260f, -0.00289552f, -0.54077989f, 0.62560040f, 0.10724831f, -0.17582230f, 0.56616694f, 
    0.69192505f, 0.06038114f, -0.52101392f, 0.32150695f, 0.21583775f, 0.44233072f, -0.06880275f, 0.25389728f, 
    0.01637343f, 0.09463421f, 0.03376095f, 0.04905022f, 0.10405424f, 0.11042127f, 0.09095406f, 0.01839505f, 
    -0.57376289f, -0.40338752f, -0.67449850f, -0.63747436f, 0.25077444f, -0.08669350f, 0.84535521f, 0.53314573f, 
    0.19086701f, 0.63239998f, 0.23356320f, -0.02881829f, -0.00738168f, -0.36338526f, -0.20817110f, -0.10022748f, 
    0.26888087f, 0.22253631f, -0.14358613f, 0.12127590f, 0.19989508f, -0.11393267f, -0.16383512f, 0.20673007f, 
    0.09297387f, -0.01097508f, 0.12678415f, 0.02087229f, 0.81139570f, 0.41728446f, -0.28732118f, 0.48393521f, 
    0.27110961f, 0.34519175f, -0.04529487f, -0.12378188f, -0.14140344f, -0.47809958f, -0.14596520f, -0.05984110f, 
    0.23098540f, 0.19327913f, -0.56042379f, -0.25738469f, -0.22753894f, -0.38797808f, -0.21416645f, -0.21136676f, 
    -0.06075398f, -0.04966247f, 0.80180097f, 0.57822877f, -0.09626005f, 0.13956948f, 0.20170660f, -0.32320517f, 
    0.24870121f, -0.34269950f, 0.22079165f, 0.41036102f, -0.23759936f, -0.05376368f, 0.05381912f, -0.14367661f, 
    -0.14500552f, -0.23995209f, -0.27130628f, 0.11753035f, -0.36966309f, 0.10018646f, 0.21250485f, 0.30956814f, 
    0.46033403f, 0.40570056f, -0.26273274f, 0.75828189f, -1.24704063f, -0.33891198f, 0.61143672f, 0.53510964f, 
    -0.77938348f, 0.60892898f, 0.09839133f, -0.21622372f, 0.43287522f, 0.23388404f, 0.26036736f, -0.29630646f, 
    -0.06747162f, 0.22717685f, -0.26357919f, -0.06259236f, 0.05317454f, 0.05806260f, -0.05054123f, -0.03244370f, 
    0.01378275f, 0.10476707f, 0.01439647f, -0.07719511f, -0.82343012f, 0.10309075f, 0.88410181f, 0.60560834f, 
    -0.18186520f, -0.06733736f, 0.00266259f, 0.41202372f, -0.02770139f, -0.38031808f, -0.01128228f, -0.06051731f, 
    0.07470683f, 0.39523745f, 0.04686233f, -0.01539608f, 0.45725152f, 0.30417159f, -0.26385060f, 0.12051791f, 
    -0.14084563f, -0.20536363f, 0.02112368f, -0.31672680f, -0.35784197f, -0.44859874f, 0.73986995f, -0.77801263f, 
    0.83231050f, -0.62159801f, 0.48456442f, -0.38874519f, -0.30115461f, 0.13812187f, -0.06250589f, -0.42751440f, 
    0.12220693f, -0.18202676f, 0.02350208f, -0.36205304f, -0.09363055f, 0.25009084f, 0.24842691f, -0.02052340f, 
    -0.03288205f, -0.07297944f, 0.03989473f, -0.23991217f, -0.14520876f, -0.00067203f, 0.24503446f, 0.30135316f, 
    0.32079664f, 0.91412681f, 0.38747796f, 0.01088606f, -0.47989103f, -0.43680012f, 0.44268498f, -0.22592388f, 
    -0.36247882f, -0.19063495f, -0.50882930f, 0.30677611f, -0.11855777f, 0.27670431f, -0.28665033f, -0.11006707f, 
    0.27042270f, 0.04205653f, 0.43080378f, 0.36698669f, 0.02209292f, -0.09644660f, 0.20585752f, -0.90115166f, 
    -1.00351000f, 0.29134107f, 0.52195418f, 0.11223321f, -0.02472125f, 0.58903968f, 0.70321685f, -0.11817983f, 
    -0.49117267f, 0.07776643f, -0.27036157f, -0.04356225f, 0.20582162f, -0.12371872f, 0.24415764f, 0.30004430f, 
    -0.32036182f, -0.26603678f, -0.10241634f, -0.06161962f, 0.04038969f, -0.23214994f, 0.28229052f, 0.23504010f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.05499302f, 0.01939246f, 0.01454318f, -0.06647214f, -0.03085378f, 0.19736262f, -0.08151256f, 0.03779097f, 
    0.26898938f, 0.18343477f, 0.14302438f, 0.31501210f, 0.24527216f, 0.12384988f, 0.32395136f, 0.13591456f, 
    0.21770230f, 0.12621109f, 0.02855213f, 0.13519593f, -0.02134520f, 0.27617407f, 0.17145617f, 0.25351512f, 
    0.19863303f, 0.09015311f, 0.08821237f, 0.00843812f, 0.18128653f, 0.27657515f, 0.19112262f, 0.04629448f, 
    0.24403793f, 0.21917129f, 0.21372296f, 0.03521274f, -0.08548433f, -0.00602086f, 0.18132584f, -0.10879419f, 
    0.20609288f, 0.18937363f, 0.20565116f, 0.22530806f, 0.08285181f, -0.08480541f, 0.19391282f, 0.10150041f, 
    -0.15040842f, 0.10285553f, -0.01487102f, 0.10805743f, -0.00415650f, 0.20451675f, 0.16869958f, 0.21971712f, 
    0.08845797f, 0.18166725f, 0.01603721f, 0.07577634f, 0.19039568f, -0.05022293f, 0.08166336f, 0.09190799f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.25658727f, -0.17482717f, -0.04348356f, -0.18026057f, 0.02122414f, 0.06054149f, -0.01013930f, 0.00706214f, 
    -0.07203739f, 0.00230607f, 0.09380819f, -0.04496169f, -0.16552405f, 0.24780802f, -0.05509015f, 0.15764365f, 
    -0.04130873f, -0.13720718f, -0.17800277f, 0.06410358f, -0.03637030f, -0.03562047f, 0.02194460f, 0.05208102f, 
    0.00776356f, -0.05884802f, 0.05688549f, -0.25959325f, 0.03540779f, 0.03575478f, -0.03875716f, -0.12551098f, 
    0.03696842f, -0.09396942f, -0.02718922f, -0.04308604f, -0.30044276f, 0.14758071f, -0.04204510f, -0.00878375f, 
    -0.16154511f, 0.04206974f, -0.21224920f, -0.13606136f, 0.05427698f, 0.04520122f, 0.16521513f, -0.05064289f, 
    0.00789304f, 0.13094190f, 0.02674369f, -0.36079895f, 0.01388434f, 0.06031285f, 0.00991259f, -0.00441262f, 
    0.12227542f, -0.06561060f, 0.04156461f, 0.10242479f, -0.07208774f, 0.14267759f, -0.08011921f, 0.12417446f, 
    0.02369773f, -0.01980644f, 0.02346919f, -0.11542474f, 0.01500461f, -0.09049993f, -0.02184963f, -0.14659604f, 
    0.15300846f, -0.13842466f, 0.17210919f, -0.19148861f, 0.04188542f, 0.10311780f, 0.12992129f, -0.06668705f, 
    0.00933183f, -0.02669147f, 0.09366410f, 0.04230522f, -0.56781036f, 0.09889953f, 0.15977778f, -0.18729509f, 
    0.06167298f, 0.07529338f, 0.01597578f, 0.06278531f, 0.02870796f, -0.10343441f, 0.06057641f, -0.03065429f, 
    0.16541055f, -0.06098374f, 0.01157940f, 0.17556097f, -0.02099192f, -0.00466003f, -0.07411331f, 0.05717175f, 
    -0.01078415f, -0.02883790f, 0.01583400f, -0.15452784f, 0.11814903f, 0.00259994f, -0.17102785f, -0.38497165f, 
    0.00639248f, -0.05079057f, 0.03083684f, -0.01100431f, 0.06763737f, -0.02646064f, -0.04040318f, 0.02790968f, 
    -0.15412067f, 0.02726888f, 0.09774113f, -0.17726186f, -0.11071233f, 0.02830764f, -0.07111835f, 0.06516809f, 
    0.00606905f, -0.04643455f, -0.10528773f, 0.02711960f, -0.25714090f, -0.44417867f, 0.00000745f, 0.04931287f, 
    0.01343943f, -0.06903180f, 0.01675023f, 0.02573252f, -0.01817266f, -0.00248605f, -0.10622044f, -0.06317321f, 
    -0.19385594f, -0.14557420f, 0.16228691f, -0.24033366f, -0.11951873f, -0.07773028f, 0.11152045f, -0.07576730f, 
    -0.05079259f, -0.00461079f, -0.05856617f, 0.03852282f, 0.30383974f, 0.21294883f, -0.05555121f, -0.00876562f, 
    -0.17893802f, -0.03552406f, 0.04743005f, -0.05979741f, 0.00141681f, -0.00412418f, -0.01070866f, -0.04730319f, 
    -0.04238478f, 0.00600483f, -0.08779009f, 0.13829175f, 0.03607985f, 0.11491534f, -0.06744976f, -0.01626422f, 
    -0.07931030f, -0.15043306f, 0.09824786f, -0.03824754f, 0.04097100f, -0.16236441f, -0.03504866f, 0.07390434f, 
    -0.02468844f, 0.03860924f, -0.07362475f, 0.01901535f, -0.06535576f, 0.03473850f, 0.01083089f, 0.05267321f, 
    -0.01976962f, -0.04352680f, -0.02263512f, -0.20343047f, 0.07885137f, 0.06270190f, 0.08739191f, 0.09828559f, 
    -0.02363445f, -0.06357831f, -0.08109775f, 0.08616640f, 0.20452389f, -0.15817851f, 0.01065217f, 0.11754625f, 
    -0.00487093f, 0.12236931f, -0.03431031f, -0.00785176f, -0.13804705f, -0.05847207f, 0.00451149f, -0.00027817f, 
    0.13249335f, 0.12940250f, -0.06447777f, -0.26187846f, -0.16490607f, 0.02658158f, -0.07649914f, 0.03400065f, 
    0.02259793f, -0.08361656f, -0.02577869f, -0.07499905f, -0.19036625f, -0.00373786f, -0.18865395f, 0.01277260f, 
    -0.05394228f, -0.20199768f, -0.08813237f, 0.02407212f, -0.04202724f, 0.04848874f, 0.06913184f, 0.00426766f, 
    -0.07083509f, 0.22899176f, 0.06353181f, -0.00320689f, -0.05035931f, 0.08211217f, -0.00154415f, -0.05068450f, 
    -0.13592820f, 0.07930230f, 0.03665078f, 0.03230726f, -0.28424132f, -0.06598840f, 0.17696115f, -0.18935534f, 
    -0.00540114f, 0.08302824f, 0.05388120f, -0.05158543f, 0.07648867f, -0.00927976f, -0.01852936f, -0.01855867f, 
    0.25673336f, 0.03877038f, 0.05069857f, -0.10994732f, -0.15066166f, -0.17544705f, -0.06814121f, 0.01942962f, 
    -0.04101702f, -0.07165066f, -0.08759837f, 0.08785995f, -0.00547263f, -0.05364544f, 0.01064857f, 0.01190023f, 
    -0.15759563f, -0.09355378f, 0.01012467f, 0.01250010f, 0.08042032f, 0.12565604f, -0.11995430f, -0.08540770f, 
    0.09009272f, 0.10091936f, -0.02282875f, -0.07580600f, 0.02343472f, -0.02513741f, -0.02401070f, 0.03143340f, 
    0.08777004f, -0.01026639f, -0.04354515f, 0.06410560f, -0.06429761f, 0.11045253f, 0.01915251f, 0.20161159f, 
    -0.05618475f, 0.05107765f, 0.06345569f, -0.00318703f, -0.07006900f, 0.06141655f, -0.17098762f, -0.07453290f, 
    0.15831900f, -0.03835210f, 0.06400082f, -0.26027688f, -0.03878013f, 0.01799048f, 0.02317378f, 0.01250629f, 
    -0.01829450f, 0.01332614f, 0.00148577f, 0.04824938f, 0.12819825f, -0.02663574f, -0.07241067f, 0.19322804f, 
    0.07216530f, -0.10889815f, 0.10331787f, -0.02913558f, -0.06232322f, 0.07413031f, -0.04687120f, 0.03960643f, 
    -0.22105584f, -0.10721330f, 0.15396401f, 0.09384958f, 0.10610428f, 0.00146392f, -0.02841326f, -0.04102343f, 
    0.06255599f, -0.18161055f, 0.01906472f, -0.01286491f, -0.31382555f, -0.07713351f, -0.06674620f, 0.20086932f, 
    -0.07155533f, 0.02205374f, 0.01211867f, 0.10170149f, 0.07840098f, 0.11552908f, -0.09388205f, -0.05575219f, 
    -0.14187093f, -0.16189267f, 0.09782498f, 0.12930980f, 0.02535556f, 0.04300152f, -0.04363989f, -0.02894729f, 
    0.09637956f, 0.03579765f, 0.02792639f, -0.02130613f, 0.02301527f, -0.00928730f, 0.14982811f, 0.06463388f, 
    -0.05465148f, 0.01692411f, -0.11479577f, 0.04500985f, 0.07574501f, -0.02587069f, 0.07173008f, 0.01469364f, 
    -0.38390434f, -0.13430150f, 0.11455757f, -0.00521703f, -0.03828897f, 0.02557224f, 0.09137917f, -0.03596546f, 
    0.00045516f, 0.11440943f, 0.07954992f, -0.03997935f, -0.02412527f, 0.09029374f, 0.07239779f, 0.08656648f, 
    -0.09798006f, 0.03139190f, -0.01825350f, 0.00667007f, -0.11583138f, 0.07415234f, 0.09855121f, -0.08613531f, 
    0.20373596f, -0.01987339f, 0.13717081f, 0.09653243f, -0.14717408f, -0.05184683f, 0.05573652f, 0.02529408f, 
    -0.01412644f, -0.00945554f, -0.10553533f, -0.13327014f, 0.30202708f, 0.15861283f, 0.17573647f, -0.20359039f, 
    0.10778081f, 0.09800706f, -0.06866499f, 0.05734807f, 0.09344667f, -0.02688962f, -0.05637796f, 0.04638252f, 
    0.36722803f, 0.00694746f, 0.04542396f, 0.01902285f, -0.06348230f, 0.13297224f, 0.08617380f, -0.12083212f, 
    0.00237750f, 0.02732852f, 0.04923420f, -0.01293124f, 0.34273860f, 0.07565011f, 0.05981427f, -0.34852263f, 
    0.11354943f, 0.05081951f, 0.08852728f, -0.01741748f, 0.04784612f, 0.07985754f, 0.01524300f, -0.04125917f, 
    -0.18088439f, 0.04740014f, 0.18000394f, -0.11011127f, 0.03812653f, 0.00156107f, -0.00529734f, -0.12917054f, 
    0.05999720f, 0.00036306f, -0.07487805f, -0.02492280f, 0.02645334f, -0.26900756f, -0.01659741f, 0.06254995f, 
    -0.09452029f, 0.06078650f, -0.11335351f, -0.02962064f, -0.03086753f, 0.12697533f, -0.03662112f, 0.05999052f, 
    0.03292271f, -0.04183384f, -0.15118836f, 0.09638193f, -0.05648439f, -0.02693221f, -0.00644899f, 0.06163931f, 
    0.00961276f, 0.01012143f, 0.05804575f, 0.01204318f, -0.24787726f, -0.11871566f, -0.16653755f, -0.00935113f, 
    0.00490229f, -0.00039288f, -0.06770208f, -0.01607555f, 0.00719641f, -0.01317320f, -0.05400046f, 0.02334037f, 
    -0.12312767f, 0.07384009f, 0.06873763f, 0.12194222f, -0.01474680f, -0.03071344f, -0.00937982f, -0.12787525f, 
    -0.01497159f, -0.05078383f, -0.00511411f, -0.04425881f, -0.27001205f, -0.02419130f, 0.00903339f, 0.01427311f, 
    -0.00122970f, -0.00478545f, -0.05385926f, -0.00186681f, -0.06066488f, 0.06547969f, -0.07177502f, 0.06462777f, 
    -0.08385292f, -0.33895010f, 0.12644181f, -0.04822702f, 0.04533131f, -0.02527296f, 0.05749745f, -0.01817168f, 
    -0.06052060f, -0.00563329f, 0.00226151f, -0.00077421f, 0.00999432f, -0.03669975f, 0.16320427f, 0.27998325f, 
    -0.11403915f, 0.00476892f, 0.07588900f, -0.07111349f, 0.05346766f, -0.02420277f, -0.05586258f, 0.03330041f, 
    -0.07045835f, 0.08568544f, 0.00893174f, -0.19720896f, 0.03942452f, -0.00132456f, 0.14183830f, 0.01975314f, 
    0.02218414f, -0.05510874f, -0.06430902f, 0.05803221f, -0.05441569f, -0.14509876f, -0.17323771f, 0.10655940f, 
    -0.08202858f, 0.02864721f, 0.03825859f, -0.03169645f, 0.02625034f, -0.03695174f, -0.02056765f, -0.07310713f, 
    -0.29700071f, 0.10579551f, -0.00122493f, -0.23100656f, -0.08840522f, 0.09303883f, 0.00491744f, 0.10063547f, 
    -0.05157084f, -0.00955738f, -0.06845880f, -0.01275657f, -0.23035163f, -0.01146549f, 0.02911079f, -0.04767181f, 
    0.08704141f, 0.04102196f, -0.03826193f, -0.05113677f, 0.05332552f, -0.09608941f, 0.02355349f, -0.05745018f, 
    0.05674980f, 0.00205658f, -0.21384920f, 0.14190108f, -0.18587355f, -0.06183943f, 0.07651837f, 0.00615137f, 
    -0.07065979f, 0.10499820f, -0.09713244f, 0.02942984f, 0.20438993f, 0.02762805f, -0.18908775f, -0.27668059f, 
    0.02814669f, -0.03906413f, 0.07921448f, 0.10171767f, -0.00913217f, 0.06894752f, -0.07502154f, -0.02717997f, 
    0.05760542f, -0.06980021f, -0.12038404f, 0.23589405f, -0.00409261f, -0.04586189f, -0.08351736f, -0.08098154f, 
    0.05294678f, 0.00093862f, 0.02118549f, 0.06236393f, 0.13874950f, -0.24020615f, 0.01092895f, 0.04215509f, 
    -0.10367393f, -0.09544723f, -0.02400683f, 0.17402536f, 0.00616637f, -0.02152471f, 0.01760017f, -0.02835406f, 
    0.14611122f, 0.07381076f, 0.00953613f, 0.02764864f, -0.23130260f, -0.17217553f, -0.09124258f, 0.01033687f, 
    -0.00257343f, -0.01370215f, 0.10598982f, -0.20678653f, 0.45680249f, -0.00380384f, -0.08957581f, -0.05954226f, 
    -0.00874510f, -0.01197001f, -0.08127387f, 0.08702923f, 0.02920871f, -0.08426013f, -0.01224733f, 0.05754049f, 
    0.01127531f, 0.29646549f, 0.07167583f, -0.33888572f, 0.05616355f, 0.05837040f, -0.05723491f, 0.04681885f, 
    -0.08617941f, -0.01256376f, -0.07553453f, 0.00454350f, -0.04465716f, 0.04922863f, 0.00232836f, 0.07874551f, 
    -0.02370906f, 0.00228384f, 0.08416378f, 0.00478421f, -0.08562459f, -0.02321399f, -0.00141065f, -0.02950713f, 
    0.07646310f, 0.05419727f, -0.02741393f, 0.02548913f, -0.03374179f, 0.04192248f, -0.08770670f, 0.08485916f, 
    -0.00291090f, 0.03612742f, 0.00684799f, 0.00443063f, 0.13823466f, -0.09228757f, 0.03721279f, 0.32666069f, 
    -0.14173564f, -0.05094630f, -0.09789485f, -0.10154574f, -0.03106373f, 0.05139618f, -0.04584920f, 0.05850853f, 
    -0.26327521f, 0.08301211f, -0.08817191f, 0.24491854f, 0.00832860f, 0.01975741f, 0.13837610f, -0.01037847f, 
    0.01376832f, 0.00143562f, -0.10913750f, -0.00662193f, 0.28925601f, 0.08434890f, -0.12996635f, 0.10045006f, 
    -0.06483343f, 0.05663899f, -0.05303649f, -0.12697464f, 0.04075225f, 0.04642317f, -0.06244664f, 0.15164942f, 
    0.11744085f, -0.05516277f, -0.03512913f, 0.13960803f, 0.09331660f, -0.02251811f, -0.07609464f, 0.02866361f, 
    -0.02776786f, -0.05439902f, 0.03525904f, -0.05643011f, -0.35135779f, 0.14532144f, 0.06945102f, 0.09712076f, 
    0.10647984f, 0.03109300f, 0.09837960f, 0.03205458f, 0.05713057f, -0.00227595f, -0.04068965f, -0.08198003f, 
    -0.14983383f, 0.07140383f, 0.09638191f, -0.19402044f, -0.09626757f, -0.09689129f, 0.10996336f, 0.07195039f, 
    0.10077502f, 0.08106882f, 0.02872922f, -0.06429959f, -0.00892864f, -0.00997136f, -0.25221500f, -0.07974679f, 
    -0.00422878f, -0.01596984f, -0.03913138f, -0.00508850f, -0.09717730f, -0.07396699f, 0.02461976f, 0.14604473f, 
    0.01780223f, 0.01061740f, 0.15786463f, -0.06920844f, -0.05486028f, -0.12617591f, 0.04226804f, 0.06024790f, 
    -0.04967155f, -0.07611004f, 0.06052401f, 0.00768366f, 0.22637694f, -0.23679331f, -0.07127889f, 0.12806241f, 
    -0.19130835f, 0.03031681f, -0.01660346f, 0.04047925f, -0.02320990f, -0.11257236f, -0.02238219f, 0.23422031f, 
    0.11466765f, -0.05200206f, 0.00984307f, -0.07273090f, 0.13447236f, -0.02657642f, -0.13609131f, -0.10272650f, 
    -0.00400173f, 0.04821849f, -0.12132528f, -0.11532401f, -0.18790546f, -0.07505029f, -0.10079223f, -0.21859565f, 
    0.07218620f, -0.02896444f, -0.04419102f, 0.10945079f, -0.05014351f, -0.03045964f, -0.03144201f, -0.01547207f, 
    0.04053169f, -0.20862773f, 0.01618930f, -0.08939450f, -0.01075237f, 0.05634451f, -0.19697903f, 0.02672702f, 
    -0.01465923f, 0.04143214f, -0.14885281f, -0.02433042f, -0.03286623f, 0.06467745f, -0.12607692f, -0.08883384f, 
    0.02611598f, 0.04933345f, -0.04923458f, -0.21855232f, 0.00892579f, 0.07840057f, 0.05421630f, 0.02405375f, 
    0.20349650f, 0.05068806f, 0.05312562f, 0.25048774f, -0.04451387f, 0.00042946f, -0.01655102f, 0.05730189f, 
    0.00703430f, 0.03045302f, -0.06415118f, 0.09647977f, 0.07113408f, -0.06832216f, 0.10503066f, -0.18438992f, 
    0.09756985f, 0.11194264f, -0.08129009f, 0.10961778f, -0.08253606f, 0.02198532f, 0.06749506f, -0.01721691f, 
    0.25012156f, -0.23427401f, -0.01731888f, -0.13954949f, 0.03332656f, -0.04468370f, 0.08425995f, 0.02864087f, 
    -0.01439228f, 0.16543086f, 0.00664565f, 0.00324105f, 0.11220060f, 0.12156092f, 0.06650828f, -0.05854773f, 
    -0.03388370f, -0.03833023f, 0.07106943f, 0.00813363f, -0.08037030f, 0.03074266f, 0.04145328f, 0.01400812f, 
    0.06120000f, 0.10035340f, 0.06084651f, 0.04216035f, -0.06969222f, 0.05748366f, 0.01899716f, -0.02329922f, 
    0.03512530f, -0.02654853f, -0.08362831f, -0.03707366f, -0.16962034f, -0.36166072f, -0.28602755f, 0.15321644f, 
    0.11843334f, -0.04083553f, 0.00997367f, -0.02264941f, -0.00638066f, 0.01947071f, -0.11650768f, 0.11543915f, 
    0.28028437f, -0.02647753f, -0.15063933f, 0.20971046f, -0.04443565f, 0.03132477f, 0.02695491f, -0.02366458f, 
    0.01659411f, 0.03551603f, 0.02459273f, 0.14915773f, -0.18107015f, -0.09831531f, -0.06136325f, -0.16939329f, 
    -0.04236437f, -0.06545896f, 0.10516042f, 0.00754319f, 0.00639131f, -0.07103326f, -0.08188562f, 0.00408009f, 
    0.08387975f, 0.04904509f, -0.07540072f, 0.06706260f, -0.15449965f, 0.03453818f, 0.00226087f, -0.11405814f, 
    -0.00425058f, 0.09359493f, 0.03901257f, 0.07934007f, 0.13513841f, 0.05967101f, 0.17766403f, 0.00751281f, 
    -0.05949114f, -0.16694434f, 0.00795516f, -0.01122588f, 0.14749444f, 0.05560836f, -0.17431451f, 0.05987906f, 
    0.04351887f, 0.19579996f, -0.08943009f, 0.02922424f, 0.03946342f, -0.02607808f, 0.02417553f, 0.05040994f, 
    0.18986399f, 0.12278522f, -0.00407009f, 0.09409101f, -0.05514035f, 0.07895345f, -0.08454111f, -0.00175194f, 
    -0.04873452f, -0.08300614f, 0.06131470f, 0.01925528f, -0.00915617f, -0.02351379f, -0.00578837f, -0.00682642f, 
    -0.12636402f, -0.07105887f, -0.00742919f, -0.10983609f, -0.03817765f, 0.00468841f, -0.00247440f, 0.04106962f, 
    0.14207318f, 0.04518007f, -0.06938716f, -0.02186032f, 0.03514127f, -0.01839360f, 0.10399541f, -0.03112920f, 
    0.01872417f, 0.06263046f, -0.03483871f, 0.07195696f, -0.03538819f, 0.14504933f, 0.01326270f, 0.10430599f, 
    0.10157597f, 0.03413898f, 0.07064994f, 0.19032407f, 0.00153525f, 0.04059993f, 0.11239387f, 0.00114171f, 
    -0.05144041f, 0.01745993f, 0.02034168f, 0.00826761f, -0.08258466f, -0.27637112f, -0.01084811f, -0.00685998f, 
    0.14185429f, 0.05719248f, -0.03604016f, -0.04798205f, -0.00571995f, -0.07774954f, 0.10406530f, 0.07932757f, 
    -0.11304220f, 0.14974742f, -0.18423146f, -0.23099275f, 0.11207992f, 0.04295281f, -0.09442625f, 0.01897560f, 
    -0.02427221f, 0.04194589f, 0.03304100f, -0.05645967f, 0.17982024f, 0.03893201f, -0.00537320f, 0.19817241f, 
    -0.02713622f, 0.07536666f, 0.02197871f, 0.01590771f, 0.06394964f, 0.03307646f, 0.11440696f, 0.03749013f, 
    0.00589595f, 0.09090160f, -0.10666765f, -0.02695320f, 0.02874574f, -0.02095275f, 0.01779976f, 0.12570046f, 
    0.08368476f, 0.00925416f, -0.06355997f, -0.03348716f, 0.35779396f, -0.06997565f, 0.00183685f, 0.11651971f, 
    0.00018362f, 0.06596290f, -0.02821572f, -0.04500773f, 0.20102687f, -0.05255859f, 0.06663188f, -0.06633205f, 
    0.11278226f, 0.05192002f, -0.15188858f, -0.12539966f, -0.15155886f, 0.11596848f, 0.13289854f, -0.01000219f, 
    0.06952525f, 0.12742206f, -0.07977529f, 0.04133230f, -0.30458727f, 0.07650692f, -0.26810744f, -0.00974277f, 
    -0.08007857f, -0.01498257f, 0.01782947f, 0.05614136f, -0.08480890f, -0.04142189f, -0.12124024f, 0.05610131f, 
    -0.21655972f, -0.06479751f, -0.11391368f, -0.09146029f, -0.01981919f, 0.03068718f, -0.02139373f, -0.04371445f, 
    0.05237204f, 0.00442167f, -0.00611486f, 0.06087392f, 0.07650679f, -0.26727796f, -0.06361461f, 0.07515631f, 
    0.00339844f, -0.05999995f, -0.01314935f, 0.01555865f, -0.03571754f, 0.04548780f, -0.05032024f, -0.04694341f, 
    0.13890938f, -0.04150441f, -0.07050757f, 0.00708476f, 0.04061279f, -0.06145385f, -0.12936264f, 0.04102658f, 
    -0.10983904f, -0.11333203f, -0.04110106f, -0.12732027f, 0.26125121f, 0.05842498f, 0.01959642f, 0.17619078f, 
    -0.04370264f, -0.03198954f, -0.05031660f, -0.00888881f, 0.01964136f, 0.03129132f, -0.07718941f, 0.04983607f, 
    -0.09238020f, -0.11400652f, -0.02977027f, -0.05193595f, 0.08803181f, 0.01111825f, 0.02518637f, 0.03299832f, 
    0.02616789f, -0.09952720f, 0.02617284f, 0.09533797f, -0.21750540f, -0.05965316f, -0.16925296f, -0.07719237f, 
    -0.00461448f, -0.03281233f, 0.10634839f, -0.03244733f, 0.02576650f, 0.07019605f, -0.02210317f, -0.05106578f, 
    -0.47830153f, 0.01232838f, 0.05324406f, 0.01999878f, 0.11384010f, -0.00774916f, 0.00866902f, -0.04888147f, 
    0.05696197f, -0.06934909f, 0.01357631f, -0.01427230f, -0.39420569f, -0.06851057f, -0.10602510f, -0.30090237f, 
    -0.17811112f, 0.01461075f, -0.09532636f, -0.01323868f, 0.09976082f, -0.01634664f, 0.05812541f, 0.01269482f, 
    0.08085827f, -0.08402537f, 0.01301103f, -0.24121872f, 0.02317332f, -0.14914457f, 0.03914050f, 0.09792275f, 
    0.04789022f, 0.02901078f, 0.10739537f, -0.09834619f, -0.06804490f, -0.10256887f, -0.13278145f, -0.17435227f, 
    0.11431510f, -0.15390597f, 0.09202287f, 0.07699542f, -0.05475058f, -0.03875880f, -0.07866483f, -0.28648943f, 
    0.24562699f, -0.02214485f, -0.04461708f, 0.16085710f, -0.04506343f, -0.01200696f, 0.00933684f, -0.00132969f, 
    -0.06979334f, -0.01766146f, -0.14182027f, 0.03096804f, -0.09387941f, -0.02701293f, -0.08638220f, 0.13835129f, 
    0.02278429f, 0.12686627f, -0.09033243f, 0.03224155f, 0.04989372f, -0.25808439f, -0.00405788f, -0.03968894f, 
    0.28717536f, -0.10300853f, -0.10161804f, -0.06639192f, -0.10780369f, 0.07461563f, -0.04201534f, -0.01711655f, 
    -0.02971691f, 0.11861672f, -0.04571490f, -0.09470689f, 0.27193260f, -0.13050126f, -0.13827689f, 0.06404775f, 
    -0.08716438f, 0.08601993f, 0.06940450f, 0.06331327f, 0.08468528f, -0.04434977f, -0.04537444f, -0.04027190f, 
    -0.03328947f, -0.03325360f, 0.11628277f, -0.11816879f, -0.03445726f, -0.04024286f, 0.04223468f, 0.04619055f, 
    0.09202135f, -0.02553854f, 0.05742742f, -0.03823070f, 0.33396646f, -0.04906886f, -0.05779696f, 0.09352481f, 
    -0.03190241f, -0.00158050f, -0.02056031f, 0.06336372f, -0.08169540f, -0.06704783f, 0.03479155f, -0.15548478f, 
    0.17065576f, -0.14932051f, -0.01034084f, -0.13513114f, 0.00574213f, -0.04647330f, 0.02177499f, 0.06549264f, 
    0.04037870f, -0.03162547f, -0.01181019f, -0.09130939f, -0.12788276f, 0.21824589f, 0.01704757f, 0.02166165f, 
    -0.06809869f, 0.04876811f, -0.05566308f, -0.01498559f, 0.08758816f, 0.05052897f, -0.01162283f, 0.08499923f, 
    0.44730622f, -0.20163664f, 0.10515525f, -0.20068651f, 0.01863030f, -0.21551292f, -0.10361727f, -0.07907554f, 
    -0.16221137f, -0.07832652f, 0.06026238f, -0.06506080f, 0.12702572f, -0.05744452f, -0.06380621f, -0.22461261f, 
    0.05122298f, -0.04026201f, -0.03254037f, -0.14200073f, -0.02387403f, 0.03604578f, 0.00035167f, 0.00734441f, 
    0.08127134f, 0.01226966f, 0.22238027f, 0.13961136f, -0.05756731f, -0.04017321f, -0.00244802f, -0.01605852f, 
    -0.03471567f, -0.22166288f, 0.07438102f, -0.21342269f, 0.00149308f, -0.09291280f, -0.14009343f, -0.11054060f, 
    0.06459424f, -0.04663729f, -0.00487569f, 0.03387149f, 0.04488332f, -0.09589252f, 0.05708862f, 0.09362690f, 
    -0.34967309f, -0.28288761f, 0.02776213f, 0.17824493f, -0.05839598f, -0.00030103f, -0.06442746f, 0.06460630f, 
    0.05349468f, -0.03081743f, -0.06866482f, 0.07404771f, 0.19686255f, -0.18273169f, 0.10819551f, -0.08754022f, 
    0.01721999f, -0.10134495f, 0.00504058f, -0.06433865f, -0.16921397f, 0.04573371f, 0.12017775f, 0.06418974f, 
    0.04116255f, 0.17062554f, 0.09906801f, 0.13123195f, -0.11879865f, -0.00540425f, 0.09594585f, 0.05178451f, 
    0.02568809f, 0.02540473f, -0.13615149f, 0.13898586f, -0.23444329f, 0.17588966f, 0.01316179f, -0.09588055f, 
    0.10242645f, -0.06680033f, 0.07185412f, 0.01100256f, 0.05449936f, 0.10663950f, -0.00103645f, 0.00904380f, 
    0.26179197f, -0.14574948f, -0.06231852f, -0.15619989f, 0.03685170f, 0.01595804f, -0.03894886f, 0.05453505f, 
    0.10829452f, -0.08112284f, 0.01757730f, 0.05411358f, 0.18492328f, -0.08046360f, -0.13998824f, 0.17350733f, 
    0.11594401f, 0.09740754f, -0.07445861f, -0.05876065f, 0.02901678f, -0.06849611f, -0.00819967f, -0.12447678f, 
    0.21635820f, -0.01670134f, 0.08109744f, 0.05197668f, -0.10757004f, -0.00473352f, 0.10613744f, -0.06505656f, 
    -0.00803858f, -0.14800318f, 0.00120185f, 0.12751849f, 0.21030350f, -0.49942037f, 0.12084512f, 0.07357324f, 
    -0.11492365f, 0.04897998f, -0.01433249f, 0.05522031f, 0.05509484f, 0.00535904f, -0.00628607f, -0.06824320f, 
    -0.13484396f, 0.16464721f, -0.19268501f, 0.00583350f, -0.01254662f, -0.04072329f, -0.11356510f, -0.09310100f, 
    -0.07095933f, -0.10532089f, 0.10311074f, 0.03661600f, -0.41606691f, -0.30179599f, -0.33030125f, 0.06381399f, 
    0.11756494f, -0.09541593f, -0.07290010f, 0.12897564f, 0.14511770f, -0.06639316f, 0.06182949f, -0.25105241f, 
    0.12259177f, -0.06801862f, 0.02236690f, 0.22217470f, -0.10389362f, -0.00423264f, 0.05838059f, 0.11541545f, 
    -0.00750865f, 0.07987839f, -0.03843754f, -0.02048887f, -0.10181462f, 0.17353764f, -0.10792545f, 0.16629188f, 
    -0.15027615f, 0.09131589f, -0.08772334f, -0.09696570f, -0.04029386f, -0.06126274f, -0.07887899f, -0.02651918f, 
    -0.34840509f, -0.04416504f, -0.07888785f, 0.20194805f, 0.06386223f, 0.02365315f, -0.07223148f, 0.04686319f, 
    -0.02590308f, 0.01894124f, -0.00078692f, 0.00643736f, -0.31474161f, -0.00887575f, -0.08872041f, -0.05022151f, 
    -0.02928467f, 0.09384593f, 0.05252284f, 0.01868505f, -0.03474564f, 0.10077363f, -0.12400842f, -0.05211467f, 
    -0.15163022f, -0.00911903f, 0.00919523f, -0.00794446f, -0.03883929f, -0.11620935f, 0.10027745f, 0.00711728f, 
    -0.05711519f, 0.01988101f, -0.00363235f, 0.06775459f, 0.21813571f, 0.08581858f, -0.00522325f, 0.01586912f, 
    -0.09131893f, 0.00853474f, 0.08873383f, 0.07646313f, -0.07054431f, 0.04339557f, 0.04842444f, -0.11500145f, 
    0.28031233f, 0.12699741f, 0.00349312f, 0.20221707f, -0.06282523f, -0.09548610f, 0.06086435f, 0.13871334f, 
    0.03182041f, 0.02364682f, 0.01231014f, -0.01488848f, 0.05747510f, 0.04497185f, -0.10047256f, -0.09257600f, 
    -0.02554748f, 0.01334960f, 0.04849589f, -0.01777561f, -0.04238308f, -0.03759971f, 0.09045367f, 0.02855447f, 
    -0.34773085f, 0.07980204f, 0.14344424f, -0.20367900f, 0.05596578f, 0.08902053f, 0.02156034f, 0.00986310f, 
    0.06067622f, -0.07952441f, 0.02721851f, -0.01138912f, 0.21910018f, -0.02070444f, -0.24658096f, 0.02015770f, 
    0.03018190f, -0.06442308f, 0.06724221f, -0.07434616f, -0.03591555f, 0.02423640f, -0.05904364f, -0.00205713f, 
    -0.07729889f, 0.07398473f, -0.13064174f, 0.05509568f, 0.09096200f, 0.00328083f, 0.00551664f, 0.02598638f, 
    0.02346368f, -0.03391241f, 0.08217213f, -0.06634086f, 0.08794866f, 0.14392921f, 0.05678581f, 0.25866130f, 
    -0.08906128f, -0.16585110f, 0.09320194f, 0.03901687f, 0.00865084f, -0.07969273f, -0.05180572f, -0.01823157f, 
    -0.18587209f, 0.04297311f, -0.00589458f, -0.17842080f, -0.00462791f, 0.05194446f, 0.10856924f, -0.06983747f, 
    -0.08110482f, -0.01937748f, -0.07316908f, -0.05059363f, 0.16039909f, -0.18314561f, -0.03452645f, -0.22042944f, 
    -0.10641902f, -0.04565895f, -0.14656213f, -0.04307375f, 0.06077891f, 0.02577900f, -0.02450465f, -0.09048656f, 
    0.15341662f, -0.05667306f, -0.03825722f, 0.01600729f, 0.08327430f, -0.02594061f, 0.05069768f, -0.07058295f, 
    -0.05045826f, -0.04228130f, 0.00008605f, 0.00806825f, 0.00021419f, -0.14274836f, -0.14417741f, -0.11286979f, 
    0.06496467f, 0.04232267f, 0.00698707f, -0.02863812f, -0.02079950f, -0.08217870f, -0.01767168f, -0.02592684f, 
    0.01595457f, -0.04297320f, 0.03491285f, -0.04830790f, -0.15528983f, 0.01407885f, -0.09879743f, 0.04753681f, 
    0.03829734f, -0.11091794f, 0.00891863f, -0.03691705f, -0.15067875f, -0.11940306f, -0.10665753f, 0.01171938f, 
    -0.00619013f, 0.05533614f, -0.01447378f, -0.00102971f, -0.00167240f, 0.00982767f, 0.01615610f, 0.01297802f, 
    -0.12058251f, 0.02471929f, 0.01716164f, -0.03844106f, -0.00946516f, -0.14195333f, -0.00682749f, 0.00424896f, 
    0.04695849f, -0.08913781f, -0.06111275f, 0.02630415f, -0.05310535f, 0.15722515f, -0.01716888f, 0.03761259f, 
    0.01665418f, -0.00729480f, -0.00082615f, 0.07850607f, -0.05043121f, -0.02900417f, 0.09370302f, 0.06407811f, 
    0.12956554f, 0.02698410f, 0.01171245f, -0.13379706f, 0.08828560f, -0.08494245f, 0.04450243f, -0.00065826f, 
    -0.05991258f, -0.07715844f, -0.02640755f, 0.04665984f, -0.11810692f, 0.06204686f, 0.08606758f, -0.11842619f, 
    -0.12422983f, 0.06905525f, 0.01179812f, 0.06279839f, -0.05937582f, -0.02245438f, -0.01427676f, -0.06207016f, 
    -0.07596133f, 0.06783028f, -0.15582493f, -0.23075332f, 0.04559908f, 0.02660778f, 0.11115582f, 0.01816900f, 
    0.07651597f, -0.06598869f, -0.06995035f, -0.14133690f, -0.13370146f, 0.01114831f, -0.05985854f, -0.04398232f, 
    0.04645793f, -0.04646583f, 0.08150002f, -0.11481588f, -0.10256550f, -0.08380732f, -0.07347842f, -0.03032945f, 
    -0.10422704f, 0.16523735f, 0.05836830f, -0.06977651f, -0.00238514f, -0.03256281f, 0.07808548f, 0.00202296f, 
    -0.00377123f, 0.03787576f, 0.08515720f, 0.06592327f, -0.06837137f, 0.00306426f, -0.00902759f, -0.09499127f, 
    -0.12131612f, -0.08696309f, -0.01007280f, 0.02587933f, -0.11661100f, 0.06244412f, 0.00415098f, 0.03766815f, 
    0.18777506f, 0.00606661f, -0.21772845f, 0.09469291f, -0.00241432f, 0.00582212f, -0.10921008f, 0.00659515f, 
    0.02707991f, 0.03738416f, 0.03090256f, 0.04661269f, -0.04138895f, -0.09563986f, -0.00210461f, 0.02979953f, 
    -0.03830184f, 0.02744780f, -0.02071247f, 0.00521674f, 0.00307676f, 0.04797161f, -0.06267653f, 0.03343739f, 
    -0.00758728f, -0.05208554f, -0.04379458f, -0.04084659f, 0.01632044f, -0.16370179f, -0.09206598f, -0.03351092f, 
    0.07474050f, 0.02986612f, 0.06915328f, 0.05039327f, -0.18130322f, -0.04310371f, -0.05474899f, 0.04908337f, 
    -0.06432672f, 0.03534879f, 0.02443012f, 0.15704782f, 0.01656362f, 0.02541776f, 0.00584327f, -0.09742195f, 
    -0.11362541f, -0.24730296f, -0.06104254f, -0.06585090f, -0.06828439f, -0.01393385f, -0.06084209f, -0.01524211f, 
    -0.10834024f, -0.07367540f, -0.05294933f, 0.06994060f, 0.32745826f, -0.11723854f, -0.15058547f, -0.13401866f, 
    -0.20780648f, -0.01169478f, -0.05607399f, 0.02861114f, 0.03011597f, -0.04985124f, -0.01280178f, -0.01865299f, 
    0.26972628f, -0.07054199f, -0.01705111f, -0.02889623f, 0.02127468f, 0.04031222f, -0.13060288f, -0.06548411f, 
    -0.10020868f, -0.12288836f, 0.06415913f, -0.19993789f, 0.09934584f, -0.02289973f, -0.05927459f, -0.10597876f, 
    0.10570542f, -0.01302492f, 0.01168354f, -0.15457715f, -0.01121847f, 0.01907273f, -0.02138233f, -0.07185753f, 
    0.23472741f, -0.22537312f, 0.08874577f, 0.04694615f, 0.00158011f, -0.06040245f, -0.00372367f, 0.06824914f, 
    -0.04163912f, 0.02331988f, -0.03109102f, 0.06870682f, 0.16122854f, -0.12529869f, -0.01954159f, -0.06266613f, 
    0.06227805f, 0.00824283f, 0.08326778f, -0.05820715f, -0.02228710f, 0.02897834f, 0.06608409f, -0.00236273f, 
    -0.19231497f, 0.01263906f, -0.10594660f, 0.01429551f, -0.02184683f, 0.03475389f, -0.04825266f, -0.02595630f, 
    -0.08470149f, -0.00217943f, 0.02378463f, -0.00912477f, 0.30970109f, 0.14815891f, 0.11084653f, 0.06896675f, 
    0.03931648f, -0.14249511f, 0.03556877f, 0.14271019f, -0.03484400f, -0.00484198f, 0.04842212f, -0.08007829f, 
    0.30533925f, 0.12473894f, 0.02720605f, 0.04572343f, -0.09205364f, 0.01577825f, -0.00746239f, 0.04462328f, 
    -0.13799381f, 0.17157191f, -0.02420808f, -0.08417896f, 0.19504602f, -0.10941792f, 0.06931628f, 0.03075846f, 
    -0.00293860f, 0.01072401f, 0.10264317f, -0.03573271f, -0.07549588f, -0.00360075f, 0.08744748f, -0.10121622f, 
    -0.17280403f, 0.02339654f, 0.06825583f, -0.33548462f, 0.02605129f, 0.10010257f, -0.00586967f, 0.01932776f, 
    -0.10524788f, 0.06160452f, -0.01017315f, -0.03004675f, -0.16123536f, -0.06526254f, -0.24091604f, -0.36368996f, 
    0.00584605f, 0.02385416f, 0.02688948f, -0.09212315f, -0.05355039f, 0.07489991f, 0.08433689f, 0.04520551f, 
    0.05367594f, -0.01588591f, -0.03015033f, -0.05399648f, 0.00237693f, -0.01502965f, -0.00078952f, 0.02620571f, 
    -0.11102413f, -0.00712507f, 0.07197693f, -0.00340985f, 0.35018316f, 0.04464947f, 0.03110507f, 0.01112028f, 
    -0.17920634f, -0.04575243f, 0.05930433f, -0.08043294f, 0.01339970f, -0.01069853f, -0.03532159f, -0.10568216f, 
    0.01091567f, -0.12579413f, 0.04931374f, -0.04469244f, 0.00771607f, 0.02822975f, -0.08706022f, 0.02544460f, 
    0.01238595f, -0.03020766f, -0.18036211f, -0.03356767f, 0.31086367f, -0.15609846f, 0.08512583f, -0.00673884f, 
    -0.07290198f, -0.00025019f, 0.00998594f, 0.01138691f, 0.02283938f, -0.05859165f, 0.06135428f, -0.00575524f, 
    -0.28504780f, -0.05268289f, -0.02805558f, -0.13454823f, 0.06066793f, -0.03749266f, -0.08461947f, -0.05139653f, 
    -0.04864125f, 0.12856422f, 0.03387319f, -0.00696429f, 0.09294298f, -0.26418534f, 0.07268938f, 0.11322810f, 
    0.07141836f, 0.01521710f, 0.02197785f, -0.13749278f, 0.03386633f, -0.01449792f, -0.02765271f, -0.00153713f, 
    -0.01739916f, -0.11225794f, -0.03704170f, 0.09491575f, -0.14538497f, 0.00774346f, -0.00779033f, -0.00601242f, 
    -0.04807290f, -0.02014485f, -0.03554410f, 0.04844102f, 0.00165374f, 0.06865080f, -0.00388300f, 0.07406287f, 
    -0.11052256f, 0.04233720f, -0.05677463f, 0.00964608f, -0.04411141f, -0.12711057f, -0.01003520f, -0.06322484f, 
    -0.23136050f, 0.04637617f, -0.02713078f, -0.10608987f, -0.00445260f, -0.14422067f, 0.10859454f, -0.06717091f, 
    -0.09617990f, 0.05247901f, -0.01230945f, 0.12297244f, 0.00530528f, -0.02035459f, -0.01119216f, 0.00366897f, 
    -0.08116332f, 0.03976069f, -0.10540338f, -0.04521902f, -0.03655948f, -0.09688426f, 0.08170076f, -0.09290396f, 
    0.00076867f, 0.04040621f, -0.01925825f, 0.12136301f, -0.02960582f, 0.11499658f, 0.00999895f, 0.00972230f, 
    0.01238985f, 0.16990237f, -0.09168762f, -0.00671457f, 0.15718268f, -0.10231426f, 0.20966731f, 0.09809002f, 
    -0.17293850f, 0.01265163f, 0.01869838f, 0.03946726f, -0.05549524f, -0.00698163f, 0.06776332f, -0.00671346f, 
    0.46784148f, -0.04327622f, -0.05430474f, -0.16519141f, 0.05464895f, 0.06202753f, 0.04889436f, -0.13836551f, 
    -0.01920642f, 0.05780109f, 0.06362662f, -0.17278951f, 0.14890110f, -0.02727859f, 0.06128207f, -0.08139137f, 
    0.05730160f, 0.01892387f, 0.01107979f, 0.07461591f, -0.00152921f, 0.02275932f, 0.05109659f, -0.09107785f, 
    -0.10238231f, 0.13377008f, -0.01273774f, -0.04004783f, 0.15021518f, -0.04696013f, -0.03548830f, 0.01993828f, 
    -0.04543963f, 0.03980352f, -0.03517792f, 0.05182834f, 0.25787050f, 0.17052965f, 0.12271178f, 0.02673768f, 
    -0.07841259f, -0.11278783f, -0.09005638f, 0.00568772f, -0.02245541f, -0.00646965f, -0.05866905f, -0.01599559f, 
    0.14779224f, -0.02177236f, 0.13665102f, 0.13614549f, -0.06873627f, -0.04393481f, -0.03900592f, 0.02597605f, 
    -0.01937692f, 0.04947832f, 0.01015721f, 0.05709378f, 0.05267420f, -0.12795314f, -0.15048313f, -0.10821472f, 
    0.03197001f, -0.00283569f, -0.05335398f, -0.02526889f, 0.05428246f, -0.03544530f, 0.08109961f, -0.02146007f, 
    0.10819111f, 0.07773456f, -0.04986813f, -0.07442638f, 0.06580213f, 0.03113372f, 0.01725406f, -0.03040229f, 
    -0.05206053f, 0.00567412f, 0.03667786f, -0.05279980f, 0.44973478f, -0.10681650f, 0.10442549f, -0.13027413f, 
    0.03431977f, 0.05725940f, -0.02715344f, 0.04053025f, 0.00036553f, -0.06574190f, 0.05731878f, 0.00644460f, 
    0.15607233f, 0.06451576f, -0.19513588f, -0.03025451f, -0.11018542f, 0.04166760f, -0.01950277f, 0.04081163f, 
    0.00935488f, 0.00962743f, -0.12853010f, -0.00229206f, -0.12367342f, -0.28269628f, -0.14206789f, -0.09773966f, 
    0.04502802f, -0.00418901f, -0.01638627f, -0.15755521f, -0.07673476f, 0.02610498f, -0.13556655f, 0.08016238f, 
    0.00516824f, -0.10808842f, -0.08955251f, -0.01156712f, 0.05215394f, -0.02747405f, -0.07763688f, -0.05211382f, 
    0.00428538f, 0.03649962f, 0.04016282f, -0.00279200f, 0.20847633f, -0.19265829f, -0.00408488f, -0.03192957f, 
    -0.09633568f, -0.05658925f, -0.10916369f, -0.04664109f, 0.16693516f, -0.02777006f, -0.05989871f, -0.08793022f, 
    0.03704991f, -0.09061808f, 0.00066845f, 0.05751195f, -0.08919746f, 0.05805565f, -0.04197522f, 0.02168621f, 
    -0.00956041f, 0.10844356f, 0.00374938f, -0.05711864f, -0.13613881f, -0.16116154f, -0.13915163f, 0.07678413f, 
    -0.08266124f, 0.00949576f, 0.09156960f, 0.08519661f, 0.04990892f, 0.02227456f, 0.02379517f, 0.06539980f, 
    0.05878299f, -0.09877486f, -0.21809265f, 0.07861125f, -0.16915323f, 0.06729197f, -0.02312461f, -0.05778956f, 
    0.10223201f, -0.01632632f, -0.05180017f, 0.05814003f, 0.11293877f, -0.09430517f, 0.07119335f, -0.05270169f, 
    0.06009476f, 0.05328761f, 0.02448613f, -0.01842833f, 0.01197647f, 0.03473607f, -0.00483438f, 0.02377937f, 
    -0.08661631f, -0.09811611f, -0.02637255f, -0.10329629f, -0.04678455f, -0.02954786f, -0.01869674f, -0.10831980f, 
    -0.08977903f, -0.01455358f, 0.06612898f, -0.04634240f, -0.14874616f, 0.18894601f, -0.01223225f, 0.04890149f, 
    -0.03460825f, 0.04151629f, -0.05537834f, 0.00855709f, -0.09479228f, 0.09735183f, -0.06952611f, 0.12413059f, 
    -0.01259673f, -0.07514075f, 0.02449267f, 0.04983287f, -0.00741905f, 0.11073634f, 0.08259444f, -0.06897274f, 
    -0.06843853f, -0.02582289f, -0.01861474f, -0.04691621f, 0.15024392f, 0.14568709f, 0.12845480f, 0.02027731f, 
    0.07742877f, 0.11187968f, 0.10519008f, -0.05144951f, 0.01355452f, 0.00065964f, -0.11367006f, 0.05063201f, 
    -0.34970865f, -0.32186544f, -0.11726950f, 0.07617237f, -0.10590097f, -0.08304409f, -0.02396635f, -0.09646976f, 
    -0.05025472f, -0.13118891f, 0.02896658f, -0.00890269f, -0.04617483f, -0.13360052f, -0.07105957f, -0.05811109f, 
    -0.08856798f, -0.05699737f, -0.02252033f, -0.05695810f, -0.03197446f, -0.00163751f, 0.00699782f, 0.06694343f, 
    0.11452965f, -0.11258932f, 0.00564448f, 0.03516642f, -0.09918225f, -0.01012200f, -0.08859607f, 0.18311276f, 
    0.00457894f, 0.02108181f, -0.02687793f, -0.04303363f, 0.04570911f, 0.12785991f, 0.02204234f, 0.01934852f, 
    -0.11479682f, -0.03089316f, -0.00426785f, 0.03936674f, -0.02510107f, -0.02190151f, 0.06634123f, 0.03762716f, 
    0.48275372f, -0.34377360f, 0.09042104f, 0.07917370f, -0.03711652f, -0.06826314f, -0.04137725f, -0.00437679f, 
    -0.11293165f, 0.08599252f, 0.01680050f, -0.04501136f, 0.37277374f, 0.10003145f, -0.22170742f, 0.10113493f, 
    0.01674521f, 0.07731977f, 0.06809615f, 0.01089840f, 0.00797457f, -0.04457191f, 0.05993156f, -0.04500271f, 
    0.06502562f, 0.00207303f, 0.03011096f, -0.01588284f, -0.03604575f, 0.06077368f, 0.06434638f, -0.07483942f, 
    -0.05929082f, -0.11210995f, -0.03041791f, 0.04844950f, 0.25572473f, -0.00029998f, 0.08269631f, -0.03151806f, 
    -0.00489711f, 0.07677585f, -0.01162835f, 0.03619777f, -0.03963816f, 0.01423767f, -0.05613187f, 0.09781318f, 
    0.09450708f, -0.05631564f, -0.05073920f, -0.06114862f, 0.06526689f, -0.04042716f, 0.06771409f, -0.00374628f, 
    -0.09746287f, 0.01135176f, -0.02615560f, -0.01366689f, -0.06882015f, 0.10728293f, -0.06285689f, -0.03834914f, 
    -0.10231689f, 0.10954471f, 0.00094148f, -0.03327685f, 0.00143599f, 0.09140408f, -0.01058280f, -0.02190081f, 
    -0.56333107f, -0.24160783f, 0.05548671f, 0.02356209f, -0.04757844f, 0.09528555f, 0.03913498f, 0.01666994f, 
    -0.01376406f, -0.05298051f, 0.04081553f, -0.01266011f, -0.08906253f, -0.27618486f, -0.23756644f, 0.14569321f, 
    0.01900950f, 0.00737006f, -0.02683543f, 0.00455158f, -0.01465126f, 0.05671568f, -0.02165663f, -0.06446540f, 
    0.09867342f, 0.01250250f, 0.07126670f, 0.15443203f, 0.00140379f, 0.03731637f, 0.01128826f, -0.01277199f, 
    -0.03700906f, 0.05490813f, 0.00915579f, -0.20797426f, 0.06760394f, 0.01727022f, 0.06619861f, 0.05824628f, 
    0.13271728f, -0.00348481f, 0.00952009f, -0.05957744f, 0.02458842f, -0.06078922f, -0.03315500f, -0.14693077f, 
    -0.30416009f, -0.43217883f, -0.36263260f, -0.00609492f, -0.03274031f, -0.00932604f, 0.07517525f, -0.02118462f, 
    -0.04812267f, 0.01846040f, -0.07050289f, -0.07289205f, -0.00738355f, 0.06727006f, -0.02228660f, 0.14647022f, 
    -0.06790012f, 0.10271388f, 0.01291372f, 0.08055674f, 0.02110432f, -0.01566289f, -0.01604381f, 0.04736819f, 
    -0.12431639f, 0.16462760f, 0.11071485f, -0.10846401f, -0.04485441f, -0.07308707f, 0.02902666f, -0.00789953f, 
    -0.03833948f, -0.03187256f, -0.04667271f, 0.09429526f, -0.16028124f, -0.06886883f, -0.17316739f, 0.00629801f, 
    -0.01290286f, -0.03816222f, -0.04285464f, -0.05430963f, 0.11197899f, 0.06296052f, -0.09016391f, 0.01142738f, 
    0.01071999f, 0.10430451f, -0.04250694f, 0.06853148f, -0.12072155f, -0.10937189f, 0.03907637f, 0.01594028f, 
    -0.09047413f, 0.01139089f, 0.01797538f, 0.01139690f, -0.03173417f, -0.05544896f, 0.03576599f, -0.15835473f, 
    -0.07940213f, 0.05805861f, -0.12063865f, -0.09302443f, -0.00967239f, 0.06519733f, 0.13934320f, -0.07167231f, 
    0.08375732f, 0.00672711f, 0.00584047f, 0.14714143f, -0.05750784f, -0.04683469f, 0.00206480f, -0.05496040f, 
    0.00552475f, -0.02781273f, -0.10042099f, -0.00911613f, 0.04975523f, 0.17664777f, 0.14397663f, -0.12584451f, 
    -0.00436195f, -0.11104422f, -0.08868326f, -0.09880655f, 0.00890835f, -0.10162848f, 0.00171328f, 0.06812120f, 
    -0.09172445f, 0.09527443f, 0.15839358f, 0.10435328f, 0.07981846f, -0.01668695f, -0.01038385f, 0.01842310f, 
    0.00949849f, 0.04186191f, -0.05964874f, -0.04648503f, 0.21992183f, -0.16345517f, -0.05340767f, 0.02339925f, 
    -0.04175615f, 0.02300746f, 0.11370254f, -0.10801769f, 0.05520922f, -0.03183153f, -0.06715652f, -0.05545325f, 
    0.14657441f, 0.03623428f, 0.03475175f, -0.01140305f, -0.02852866f, 0.00684543f, -0.02711238f, -0.03680849f, 
    -0.03662691f, 0.00608234f, 0.00071665f, 0.01973103f, -0.21185757f, -0.15146060f, -0.26270813f, -0.19893193f, 
    -0.09895906f, -0.07379059f, 0.02014375f, -0.03843723f, -0.07605100f, -0.05296556f, 0.03428030f, -0.03038633f, 
    0.01689922f, 0.03519242f, 0.03573736f, 0.10621706f, 0.00776338f, 0.06653649f, -0.01842438f, -0.05506586f, 
    0.04139895f, -0.03580919f, 0.04275354f, -0.07706497f, -0.21500112f, -0.12969543f, 0.03455433f, -0.13625883f, 
    -0.06213627f, -0.06450322f, -0.04760645f, 0.00181191f, -0.06251803f, -0.14801240f, -0.05697973f, -0.00472290f, 
    -0.31054336f, 0.13032092f, -0.02461430f, -0.19182694f, 0.02655023f, -0.11293302f, -0.01653491f, 0.03436357f, 
    0.07193999f, -0.03279333f, 0.03262599f, -0.00495987f, 0.05102737f, 0.22537333f, 0.10463711f, -0.16366473f, 
    -0.12526911f, 0.05725377f, 0.03639762f, 0.13880932f, 0.01630115f, -0.08110739f, 0.03160721f, 0.01460793f, 
    0.20977204f, -0.08509424f, -0.02387702f, 0.03929359f, -0.04880328f, 0.04453162f, 0.08260836f, 0.08316909f, 
    0.02307487f, 0.06289152f, -0.07713782f, 0.05647120f, -0.14808547f, 0.34429577f, 0.09929151f, 0.04091594f, 
    -0.07929548f, 0.03853787f, -0.00385684f, -0.00323880f, -0.01344288f, 0.11713336f, 0.09434554f, 0.04840161f, 
    -0.08756579f, -0.33999544f, -0.21692817f, 0.05763511f, -0.05511227f, -0.05865712f, 0.07921351f, 0.05235372f, 
    0.03117809f, 0.06154457f, 0.07735060f, 0.06421632f, 0.24429783f, -0.10988796f, -0.07010522f, -0.04640342f, 
    -0.08803795f, -0.03355325f, 0.03073710f, -0.12577711f, -0.06954698f, 0.02109353f, 0.05855512f, 0.09810644f, 
    0.17397535f, 0.07292674f, -0.04518252f, -0.04381024f, 0.04617671f, 0.07579806f, -0.09670245f, -0.06828911f, 
    0.04739872f, 0.04055125f, -0.00320427f, -0.06949392f, -0.04705305f, 0.10638191f, -0.02412115f, 0.13645642f, 
    0.00220736f, 0.02220302f, 0.02089913f, -0.02908309f, -0.05045974f, 0.02657484f, -0.04322155f, -0.00097134f, 
    0.11770464f, 0.06055678f, 0.06500551f, 0.12761712f, 0.10195807f, 0.05687623f, -0.12602608f, -0.04677173f, 
    0.11039682f, -0.00718071f, -0.08542254f, 0.00879995f, 0.31034487f, 0.03637569f, -0.20433652f, 0.17876209f, 
    0.01750984f, -0.03739959f, 0.07376117f, -0.04886260f, 0.01564671f, -0.00716329f, -0.05572069f, 0.10844299f, 
    0.08783001f, 0.06449769f, -0.07254854f, -0.03236866f, -0.10919116f, -0.17437948f, 0.12310913f, -0.06702723f, 
    -0.05078653f, -0.01203755f, 0.03636470f, 0.06753742f, -0.12912090f, -0.07241104f, 0.04540063f, 0.06317292f, 
    0.06904558f, 0.05345942f, 0.01852101f, -0.01789963f, -0.05646639f, -0.00206685f, -0.01405196f, -0.03160741f, 
    0.01038334f, -0.05138213f, -0.08756647f, 0.06159693f, -0.01710263f, -0.07539134f, -0.04631782f, 0.13480781f, 
    -0.03067524f, 0.13083968f, -0.01092320f, 0.05419649f, 0.04054557f, 0.06973924f, 0.11986213f, 0.11085929f, 
    0.03805057f, -0.03536619f, -0.09735149f, 0.06370089f, 0.02114109f, -0.03903607f, 0.02862582f, -0.09557699f, 
    -0.18650113f, -0.13621630f, -0.02949171f, 0.23005061f, 0.00013837f, 0.01302884f, 0.12558365f, -0.05033973f, 
    0.03176475f, 0.05631829f, -0.03280676f, 0.11382277f, 0.07655565f, -0.07608192f, -0.01504647f, -0.12930004f, 
    -0.11917052f, 0.01783013f, 0.02148540f, -0.02280206f, 0.02766319f, -0.13440683f, 0.03824725f, 0.06589876f, 
    0.18444230f, 0.05211766f, 0.24753322f, 0.07766806f, -0.00508816f, 0.00294855f, -0.04507027f, -0.11644516f, 
    0.02650658f, 0.05024546f, -0.02499824f, -0.08614590f, 0.03354507f, 0.00059905f, -0.20087601f, 0.00282144f, 
    -0.09857388f, -0.00009726f, -0.08436205f, 0.11024041f, -0.00596011f, -0.07282370f, -0.00891602f, 0.01783544f, 
    -0.76472265f, -0.42536175f, 0.03084661f, 0.03731312f, -0.02836715f, 0.04925649f, -0.11604954f, -0.01325012f, 
    -0.03656599f, 0.07509688f, 0.03769143f, -0.03607294f, -0.00494862f, 0.07904027f, -0.11851906f, -0.20522264f, 
    -0.11895929f, -0.05425746f, -0.02328528f, 0.06971625f, 0.00393707f, -0.11568929f, -0.00901047f, 0.03976895f, 
    -0.22214535f, 0.00820696f, -0.06679124f, -0.01514944f, -0.16602701f, -0.02710367f, 0.04605703f, -0.00227752f, 
    -0.02092772f, -0.02747745f, -0.08332374f, 0.06709564f, -0.25676215f, 0.00474575f, 0.11983583f, 0.06603064f, 
    -0.10157979f, -0.02255626f, 0.04292640f, 0.07462927f, -0.01169938f, 0.02623503f, 0.07589569f, 0.00742303f, 
    -0.19852197f, -0.16458289f, -0.14919540f, -0.12182918f, -0.01651312f, -0.03566844f, -0.03564751f, -0.01740963f, 
    -0.08598435f, -0.05006992f, -0.03065386f, 0.03060747f, -0.10992493f, 0.08747052f, 0.14361103f, 0.10745209f, 
    0.01934165f, 0.12981418f, 0.00518268f, 0.00856169f, 0.02274371f, 0.07953089f, -0.01693524f, -0.01010436f, 
    -0.22470191f, -0.02543419f, 0.05187348f, -0.00234014f, -0.04671642f, 0.01318781f, 0.03480049f, 0.04915622f, 
    0.01647345f, -0.00724573f, 0.05143606f, 0.01532027f, 0.35890442f, 0.27056447f, -0.15979905f, 0.18763523f, 
    -0.04723593f, 0.03508384f, 0.17307614f, 0.08974077f, -0.12300147f, 0.02671069f, -0.07427502f, 0.03932912f, 
    0.13256690f, -0.19459133f, -0.08552067f, 0.13038684f, -0.08358673f, -0.00455026f, -0.01101120f, -0.04707470f, 
    0.03986989f, -0.10056145f, 0.08731419f, -0.06587999f, 0.13467546f, 0.04381920f, 0.15877609f, 0.07099815f, 
    -0.03080318f, -0.20293625f, -0.02156792f, 0.05258787f, -0.05947509f, -0.01002092f, -0.07422322f, -0.02440996f, 
    -0.08348311f, -0.09276897f, -0.09808383f, 0.14995125f, -0.00516838f, 0.08948908f, -0.03965756f, -0.02001656f, 
    0.03743947f, -0.04233242f, -0.07669166f, 0.03368415f, -0.02900464f, -0.28711993f, 0.16211987f, -0.10607313f, 
    0.00035850f, 0.10945310f, 0.17569441f, -0.03112372f, 0.07934187f, 0.05765295f, 0.00782722f, -0.04195561f, 
    -0.20853236f, -0.28907347f, -0.07034876f, 0.01735263f, -0.11811431f, -0.05485703f, 0.00404602f, 0.00736967f, 
    0.04884831f, -0.05883917f, -0.04175895f, 0.01859308f, -0.58375585f, -0.22772348f, -0.03079882f, 0.03852665f, 
    0.06773714f, -0.00180048f, -0.01619103f, 0.10949483f, -0.10814170f, 0.06328965f, 0.00422194f, 0.02642309f, 
    -0.67850810f, -0.13333765f, 0.21189438f, 0.22123496f, -0.06035093f, -0.02953908f, -0.00018724f, 0.02088847f, 
    -0.05978290f, -0.01972713f, 0.15120006f, 0.10603105f, 0.25403231f, -0.19064467f, 0.14129272f, -0.07843352f, 
    -0.03682199f, 0.09205269f, 0.09993260f, 0.00439817f, 0.01885986f, 0.00807777f, 0.12712142f, 0.09365529f, 
    -0.15506816f, -0.14019467f, -0.20986606f, -0.07363732f, -0.05065983f, 0.10728973f, -0.03936337f, -0.18961149f, 
    -0.17841573f, -0.20391226f, 0.02049883f, 0.03440718f, -0.15772933f, 0.23773561f, 0.12982604f, -0.03779877f, 
    -0.02813888f, 0.02931949f, 0.03624424f, 0.02473853f, 0.05439578f, -0.03526571f, -0.06344710f, 0.04968520f, 
    0.25406674f, 0.00570450f, -0.00053139f, 0.11216491f, -0.17863069f, 0.04963108f, 0.00980535f, 0.00481195f, 
    0.01989175f, 0.08128858f, 0.08825466f, 0.06303813f, -0.16909374f, -0.05001685f, 0.11336530f, 0.23765403f, 
    0.03354681f, -0.03767126f, 0.04031020f, 0.07788917f, 0.01710061f, 0.07035854f, -0.01070321f, 0.02530633f, 
    -0.01648307f, 0.02579963f, -0.09648761f, 0.09340908f, -0.09184213f, -0.07555433f, 0.05806841f, 0.04932785f, 
    -0.08859535f, 0.02710268f, 0.06354214f, 0.01644349f, 0.12407196f, -0.07369239f, 0.15688352f, 0.24211541f, 
    0.08666717f, 0.01633182f, 0.08558923f, 0.11278326f, 0.14621970f, 0.09626647f, 0.08909554f, 0.06968240f, 
    -0.06462310f, 0.11986972f, -0.21872632f, -0.14885414f, 0.07179205f, 0.06074655f, -0.06939135f, 0.00672139f, 
    -0.02413209f, 0.10779476f, -0.05518239f, 0.03229354f, -0.03080888f, 0.02050668f, 0.14717914f, -0.17621905f, 
    -0.00060809f, 0.14247611f, 0.03381055f, -0.10398789f, -0.00269123f, 0.03113527f, 0.10589511f, -0.01445823f, 
    -0.43292847f, 0.13471173f, -0.02531588f, -0.12144612f, 0.00222894f, -0.01663299f, 0.00501090f, 0.00879692f, 
    0.20092498f, 0.07807976f, -0.10576376f, -0.07023016f, 0.17990424f, -0.01802373f, -0.06364541f, 0.13619453f, 
    -0.04898831f, -0.07063632f, 0.04435467f, -0.08303195f, -0.10427745f, 0.07693719f, -0.02267081f, 0.02949889f, 
    0.00906454f, -0.02836704f, 0.17314798f, 0.07054237f, -0.03008965f, -0.02538008f, 0.01889721f, 0.01035918f, 
    -0.04866023f, -0.01615798f, -0.03796289f, -0.04197042f, -0.10339975f, -0.01331093f, 0.08388815f, -0.08203079f, 
    0.12374931f, 0.06868016f, 0.01491117f, -0.10614326f, -0.02405128f, -0.04920293f, 0.04234183f, -0.01798205f, 
    -0.14666554f, -0.17540187f, 0.09649389f, 0.11155498f, -0.18009141f, -0.08170652f, -0.05926423f, -0.11332627f, 
    0.20293850f, -0.00707404f, -0.08915146f, -0.14951049f, -0.12125792f, -0.44490424f, 0.07084364f, -0.07497313f, 
    -0.15877634f, -0.05788598f, -0.04521536f, -0.06400274f, 0.04672705f, 0.10106634f, -0.06632834f, 0.03157615f, 
    -0.24637036f, -0.22043583f, 0.17345557f, 0.00115112f, 0.01213077f, -0.09699459f, -0.08815673f, -0.21688467f, 
    -0.01700507f, -0.08703564f, -0.00003535f, 0.02607317f, 0.00387649f, 0.01089968f, 0.13609312f, 0.01990953f, 
    0.06112382f, -0.07672484f, -0.01005124f, 0.00606856f, 0.09033793f, -0.14082737f, 0.14978233f, -0.04682605f, 
    -0.09982894f, -0.26218510f, 0.16048858f, 0.02834640f, -0.02375343f, 0.00751550f, -0.13415349f, -0.08355191f, 
    0.06578419f, 0.10984246f, 0.03811347f, 0.00565047f, 0.06445894f, -0.00956442f, -0.03954652f, -0.08985262f, 
    0.02958286f, 0.03628052f, 0.06002051f, 0.06705078f, 0.00911475f, -0.00516695f, -0.01187302f, 0.08378261f, 
    0.03027528f, 0.08244313f, 0.03451617f, 0.04163582f, -0.12222235f, -0.07883251f, -0.00351938f, -0.08095098f, 
    -0.04293707f, -0.25611764f, -0.04861842f, -0.08906878f, 0.06132428f, 0.05516386f, -0.02310138f, 0.00123425f, 
    -0.04598066f, -0.07748076f, 0.01277691f, 0.03911918f, -0.07719547f, -0.05009663f, 0.00050855f, 0.03234955f, 
    -0.22487856f, -0.14242806f, 0.21318808f, 0.03884113f, 0.00489682f, -0.06938751f, 0.04612208f, 0.09866066f, 
    -0.04352311f, 0.06355570f, -0.07919638f, 0.05628433f, -0.53595996f, 0.22305895f, 0.11882628f, -0.00167520f, 
    -0.03722649f, 0.01852007f, -0.10978621f, -0.15014514f, -0.06228559f, -0.01356063f, -0.05155896f, 0.03659658f, 
    -0.02206651f, 0.05417787f, 0.05901586f, -0.06002034f, 0.14529786f, 0.03199632f, -0.10608377f, 0.00641819f, 
    0.06663959f, -0.06505042f, 0.04729152f, 0.08747089f, 0.05340344f, -0.09809741f, 0.06509625f, -0.19818479f, 
    0.19584966f, 0.04399313f, 0.01347512f, 0.03805935f, -0.00284934f, -0.08198372f, -0.05384459f, 0.01913903f, 
    -0.18586038f, 0.04212185f, 0.13059920f, 0.14398611f, 0.01376256f, 0.01594793f, 0.01501438f, 0.04234678f, 
    0.10255124f, -0.03010095f, -0.08766058f, -0.06026536f, -0.15520065f, -0.16266978f, 0.12869459f, 0.20256370f, 
    -0.10074247f, 0.04119360f, -0.00610748f, -0.10428952f, 0.16408597f, -0.03485871f, -0.11096430f, 0.00181124f, 
    -0.20483425f, 0.27269417f, -0.06488957f, -0.35587937f, -0.00242513f, -0.06242428f, 0.03171798f, -0.02768835f, 
    0.00345768f, -0.02988854f, 0.00932454f, -0.03162138f, 0.15899549f, -0.20550789f, -0.09208477f, 0.08501749f, 
    -0.05257943f, 0.04163630f, 0.07672790f, 0.00001333f, 0.01008843f, 0.08108763f, 0.00035375f, -0.05424175f, 
    -0.19807914f, -0.15111916f, 0.10170540f, 0.09940750f, -0.07722468f, 0.09515315f, -0.02345468f, -0.03251135f, 
    0.04742707f, 0.11732184f, -0.08639202f, -0.05935921f, -0.30841053f, -0.10445728f, 0.08362396f, 0.16586225f, 
    0.06724489f, -0.04841647f, 0.15577148f, 0.05846905f, 0.00009653f, 0.04934930f, 0.00649259f, 0.13538249f, 
    0.20504788f, 0.20680197f, -0.09283043f, 0.03990696f, 0.03109558f, 0.03829907f, -0.07743429f, 0.12806615f, 
    -0.02284300f, 0.00146758f, 0.03810248f, -0.07221740f, 0.09086085f, 0.03116156f, 0.04717695f, 0.04013041f, 
    -0.01768868f, -0.06164502f, 0.11438029f, 0.03950553f, -0.02401457f, 0.11325602f, 0.01966363f, 0.03337695f, 
    0.13060753f, -0.24945711f, -0.08391884f, 0.01142766f, -0.01255344f, 0.09680287f, 0.09170702f, -0.04002470f, 
    -0.03299536f, 0.14367025f, -0.12275659f, 0.01994338f, -0.08604940f, -0.02661186f, 0.19142625f, 0.04631082f, 
    0.01222271f, -0.10541496f, 0.03586176f, -0.04393164f, 0.00291852f, -0.02892570f, 0.17097984f, 0.05336015f, 
    -0.04035603f, 0.11697850f, 0.08450150f, -0.09942827f, -0.00320204f, 0.04872626f, 0.06635720f, 0.06741827f, 
    -0.01013015f, 0.01266860f, 0.07855547f, -0.13060506f, -0.07792911f, 0.05781288f, -0.03263618f, -0.11856516f, 
    0.03096971f, 0.03249115f, -0.06574500f, -0.02343312f, -0.07557040f, 0.03406710f, -0.09439608f, -0.01796669f, 
    0.11046071f, -0.02949957f, -0.22795480f, -0.11832269f, -0.00908889f, -0.01904847f, 0.06467799f, 0.00210067f, 
    -0.15507218f, -0.08950842f, 0.09842185f, 0.08800040f, -0.57501554f, 0.27835715f, 0.04049452f, -0.00126145f, 
    0.01041941f, -0.12541540f, 0.01310319f, -0.00640177f, 0.01344655f, 0.02265199f, -0.01618198f, 0.04237444f, 
    -0.13734187f, -0.03145991f, 0.14440995f, 0.14435746f, -0.04310056f, 0.05160552f, -0.02858447f, 0.05632799f, 
    -0.00110848f, -0.09659453f, -0.11350973f, 0.05766292f, 0.02159764f, 0.15282600f, -0.11457416f, 0.00729718f, 
    -0.02407712f, 0.15858425f, -0.00148025f, 0.11567848f, -0.00799607f, -0.07263983f, -0.05176048f, 0.02791675f, 
    -0.09499145f, 0.07135433f, -0.20257401f, 0.10861880f, 0.00866514f, -0.06589485f, -0.03950570f, 0.02167254f, 
    0.05215709f, -0.01993536f, -0.05863016f, 0.01417007f, 0.05777073f, 0.02387093f, 0.07832851f, -0.26753142f, 
    0.07441251f, -0.10117313f, -0.01533924f, 0.09784949f, 0.10179155f, -0.06444892f, -0.04297752f, -0.10491016f, 
    -0.01652420f, -0.04524248f, 0.09914936f, -0.15116245f, -0.04555167f, 0.09249656f, 0.09552985f, 0.07298175f, 
    -0.07545967f, 0.01221060f, 0.03798907f, -0.00359714f, -0.04022889f, -0.01467920f, 0.07654907f, 0.02071147f, 
    -0.06382885f, -0.00297051f, -0.02870052f, 0.01659396f, -0.00563714f, 0.03219702f, 0.02580735f, -0.02840065f, 
    -0.18264985f, -0.02936968f, 0.07905475f, 0.05865553f, 0.08888382f, 0.12294338f, 0.02067243f, 0.07866520f, 
    0.04710535f, -0.03366937f, -0.03626019f, 0.05350652f, -0.04168958f, 0.10221412f, 0.02875432f, 0.19967194f, 
    0.06840681f, 0.02836172f, -0.10469373f, 0.03052558f, -0.17116883f, 0.13135149f, 0.08169294f, -0.14696997f, 
    -0.13218071f, -0.02351716f, 0.00155562f, 0.03181619f, -0.01597416f, -0.09562543f, -0.07427182f, -0.06409485f, 
    -0.11762243f, 0.02018768f, -0.08179941f, -0.04083725f, -0.03881274f, -0.04422866f, 0.11051419f, 0.01535313f, 
    -0.03335696f, -0.04842618f, 0.04037406f, 0.11254904f, -0.06081628f, -0.13830258f, -0.04978522f, -0.00405146f, 
    0.10291764f, 0.10871650f, -0.05830786f, 0.05095595f, 0.02549371f, 0.06065622f, -0.01381001f, 0.09109197f, 
    0.06952000f, 0.00634875f, -0.06873964f, -0.02673707f, -0.05423018f, -0.15920839f, 0.02396521f, 0.09947964f, 
    0.10195417f, 0.11758641f, -0.03460761f, -0.06973622f, 0.02373319f, -0.06101864f, 0.02685985f, -0.04878106f, 
    -0.26449648f, 0.02465596f, -0.02948731f, 0.19455610f, 0.06828242f, -0.01247993f, 0.07389924f, -0.00811881f, 
    -0.00799522f, -0.02857981f, 0.16052401f, 0.02507693f, 0.09395836f, 0.07581826f, 0.02982786f, 0.00829692f, 
    0.06775894f, 0.06327894f, 0.00044131f, 0.13697727f, -0.06041562f, 0.09786974f, -0.00181311f, 0.06667610f, 
    -0.01101299f, -0.06207351f, 0.10067341f, 0.08060071f, -0.09882288f, -0.01168616f, -0.07330248f, 0.07268781f, 
    -0.01905669f, 0.09932167f, -0.13492173f, 0.01945603f, -0.41726151f, 0.30998835f, -0.04685006f, -0.06763276f, 
    0.08597765f, -0.10002655f, 0.02365734f, -0.06635416f, -0.01186311f, -0.03254753f, -0.03906563f, -0.01181717f, 
    0.00740322f, 0.00301997f, -0.09012980f, -0.22524251f, 0.02620743f, 0.06369112f, 0.09609359f, 0.04019438f, 
    -0.10162963f, -0.00399922f, -0.04623483f, 0.02177557f, 0.10534997f, 0.00061312f, -0.01942426f, -0.15597177f, 
    0.06797373f, 0.09965321f, 0.02374170f, 0.11764957f, 0.05818990f, -0.06007706f, -0.01125993f, 0.05966593f, 
    0.17556433f, 0.18961513f, 0.05661837f, 0.16740757f, 0.05820742f, 0.02885102f, -0.04776141f, -0.01356821f, 
    0.00918540f, -0.17587361f, -0.07901502f, 0.01669942f, -0.15906651f, 0.01475105f, -0.23699965f, -0.19104330f, 
    0.00208969f, -0.00718381f, -0.02229015f, 0.06973915f, -0.10414340f, -0.10760656f, 0.03191588f, 0.06356261f, 
    -0.15472446f, -0.06497168f, -0.02982667f, 0.06390484f, 0.09129869f, 0.07292052f, 0.00773613f, -0.13274814f, 
    0.06731662f, 0.07327013f, -0.13874927f, -0.02811864f, 0.01662929f, 0.19682358f, -0.16004099f, 0.02978751f, 
    -0.19880132f, 0.06734081f, 0.01154136f, 0.02809870f, -0.06291329f, -0.10100285f, 0.11886033f, -0.02102296f, 
    0.06718947f, -0.00099657f, 0.03987744f, 0.09794785f, -0.02558725f, -0.02858795f, -0.06358782f, 0.07381208f, 
    0.04782040f, 0.00140609f, -0.05108730f, -0.03692852f, 0.07461447f, 0.07449954f, -0.03532517f, -0.21156816f, 
    0.17991345f, -0.35578501f, 0.13481516f, 0.02239380f, -0.00731987f, -0.19102898f, -0.20132312f, -0.19401857f, 
    -0.18067446f, 0.13798267f, -0.44785643f, -0.13223709f, 0.00769813f, 0.06963381f, -0.01237734f, 0.07311628f, 
    -0.05816055f, -0.04014692f, -0.11210262f, 0.02304919f, 0.10908975f, -0.11270762f, -0.04604276f, 0.15946677f, 
    0.02065516f, -0.09895485f, -0.09247904f, -0.01867702f, -0.06859671f, 0.03572490f, -0.11076973f, -0.03728857f, 
    -0.14893751f, 0.02634685f, 0.07233907f, 0.31833178f, -0.19699846f, -0.20966783f, 0.09964751f, 0.15300135f, 
    0.13058285f, 0.02703012f, 0.02322032f, 0.12121394f, 0.05371934f, -0.16372614f, -0.08070751f, 0.12058607f, 
    0.12214423f, -0.14238627f, 0.02828848f, 0.04693314f, 0.02638016f, 0.15009658f, 0.11830325f, 0.08553202f, 
    0.01084299f, 0.11983509f, 0.16160144f, -0.07399705f, 0.06182934f, -0.01383003f, 0.07140175f, -0.08562753f, 
    -0.03486631f, 0.03141390f, -0.02975386f, 0.03784762f, -0.08228116f, -0.11081187f, -0.31069574f, -0.09952341f, 
    0.08633783f, 0.03856755f, -0.14258169f, -0.02383275f, -0.01568715f, 0.02610025f, -0.01834860f, 0.01187707f, 
    -0.09347411f, 0.16796932f, 0.05265612f, 0.07460303f, -0.17977355f, -0.02360547f, 0.06212534f, -0.01611001f, 
    -0.02398338f, -0.11109231f, 0.14877200f, -0.01548818f, -0.31565264f, -0.10579603f, -0.19872487f, 0.08824271f, 
    0.08528610f, 0.03380575f, -0.06224936f, -0.03189534f, -0.00495032f, -0.03610202f, 0.14691184f, 0.08719867f, 
    -0.16145875f, -0.05805275f, 0.25849414f, 0.17778149f, -0.00779186f, 0.03583239f, -0.04996917f, 0.10786114f, 
    -0.02869981f, 0.02004997f, -0.03106848f, 0.01737961f, -0.10583730f, 0.14523464f, 0.21674505f, -0.16917653f, 
    0.01847528f, -0.10289096f, 0.04942403f, 0.19172741f, 0.07800040f, 0.01330057f, 0.02861642f, -0.06126555f, 
    -0.44955644f, 0.20862448f, -0.01131416f, -0.16205576f, 0.16357344f, -0.02374583f, -0.03177828f, 0.04846281f, 
    0.05197021f, 0.13808428f, 0.02228118f, -0.01600253f, 0.09616850f, -0.06088039f, 0.04665295f, 0.00257237f, 
    0.07653587f, -0.02249797f, -0.06281898f, 0.04946669f, -0.03104913f, -0.04548240f, 0.08120143f, -0.16605835f, 
    -0.14624482f, -0.12708685f, -0.07029078f, 0.01489111f, 0.16903478f, 0.07980813f, 0.01220306f, 0.08389246f, 
    0.07508364f, 0.09328814f, 0.19765973f, 0.00151807f, 0.10616599f, -0.01568487f, -0.21342930f, -0.01263526f, 
    0.02887800f, -0.07033058f, -0.15552860f, -0.08381314f, 0.02563120f, 0.02988865f, -0.15951189f, 0.02764811f, 
    0.07313349f, 0.00966656f, 0.10930973f, -0.03236900f, -0.07246798f, -0.03701647f, 0.04058532f, 0.05117797f, 
    -0.08374406f, 0.11877041f, 0.13724540f, 0.12834103f, 0.17112519f, 0.11372244f, -0.01111927f, -0.08918279f, 
    -0.01030859f, -0.03805868f, 0.06425390f, 0.07690229f, -0.04033856f, -0.09475039f, -0.08532962f, -0.01990401f, 
    0.01634813f, 0.10005987f, 0.18094945f, 0.26304233f, -0.02718093f, -0.04738524f, 0.00980920f, 0.08407865f, 
    -0.10383213f, 0.05730942f, 0.01703683f, -0.00342349f, -0.06308863f, -0.10045004f, -0.04816294f, 0.06768282f, 
    -0.11912204f, 0.04675899f, -0.06842862f, 0.07236652f, -0.15833080f, -0.00382110f, 0.16067693f, 0.19213970f, 
    -0.03834432f, 0.10996196f, 0.09535705f, 0.05107063f, -0.04154236f, -0.02588890f, -0.05338310f, -0.04022529f, 
    0.06838863f, -0.15466568f, 0.08692535f, -0.00896570f, -0.07397164f, 0.15716389f, -0.24716046f, -0.05476619f, 
    -0.01174094f, -0.08625313f, -0.04875252f, 0.12691292f, 0.06373591f, -0.11677478f, 0.14958973f, 0.04736760f, 
    -0.41916987f, -0.18160442f, -0.10114980f, 0.05698530f, -0.02142840f, 0.03759202f, 0.11786760f, 0.09393451f, 
    0.20264140f, 0.07197402f, 0.06160717f, -0.11289054f, -0.04237394f, -0.00477435f, 0.22024854f, -0.18747959f, 
    0.08039720f, -0.03132648f, -0.01756029f, 0.04455441f, 0.12589598f, -0.02413003f, 0.11620717f, -0.09107141f, 
    -0.11584815f, -0.13921294f, -0.12187259f, 0.02942017f, 0.10473037f, 0.09777084f, 0.02783942f, -0.05592050f, 
    0.14083453f, -0.17508109f, -0.02610817f, -0.09284772f, -0.13512914f, 0.23075244f, -0.07306964f, -0.01369563f, 
    0.11154017f, -0.04805191f, -0.11063965f, -0.08408187f, -0.04179469f, -0.10829632f, -0.05403960f, 0.05920722f, 
    -0.06168988f, 0.02378983f, -0.14446925f, -0.06160127f, 0.04882807f, -0.03086129f, -0.06359024f, 0.05998970f, 
    0.02546561f, 0.22126226f, 0.13949135f, -0.00852451f, -0.06805456f, -0.12702085f, -0.03367392f, 0.13267276f, 
    0.01196274f, 0.03012979f, -0.00395216f, 0.02349006f, 0.03016665f, -0.00766983f, 0.03698668f, -0.01022486f, 
    0.10156565f, -0.11039574f, 0.02704374f, -0.02171052f, -0.01304960f, -0.09949787f, 0.07063097f, -0.01627307f, 
    -0.01477837f, 0.04372962f, 0.02005615f, 0.22037275f, -0.02281834f, 0.00831399f, 0.05832108f, -0.00272314f, 
    -0.10045590f, -0.08331350f, 0.07625814f, -0.00929339f, -0.16724318f, -0.04341322f, 0.11525917f, 0.15009059f, 
    -0.19605398f, -0.23041262f, -0.01963629f, -0.01559547f, -0.04037786f, 0.20029891f, 0.02132565f, -0.00487064f, 
    -0.07116390f, 0.03513131f, 0.01263135f, 0.03112269f, -0.00117833f, 0.10308278f, 0.26863751f, -0.27997956f, 
    0.08169304f, 0.06986348f, -0.08133637f, -0.02042840f, 0.09030572f, -0.06173005f, 0.00652268f, 0.01549033f, 
    0.05127401f, 0.00971642f, -0.10078299f, 0.06637575f, -0.02233951f, -0.10229646f, -0.03591900f, 0.06194361f, 
    -0.02950015f, -0.01061712f, 0.10646841f, 0.12662145f, -0.03416272f, 0.21951163f, -0.08179770f, 0.02856090f, 
    0.03407389f, -0.01125214f, -0.17359440f, -0.16817889f, 0.14822730f, 0.06503946f, 0.04716661f, -0.04708017f, 
    0.07751583f, -0.07736696f, -0.06165894f, -0.02225471f, 0.12236221f, -0.17751221f, 0.07059135f, -0.20525801f, 
    0.10481729f, -0.09095998f, -0.19753762f, 0.01607841f, 0.24231926f, -0.28874487f, -0.03408885f, -0.03590566f, 
    0.06702526f, 0.01119299f, -0.14594975f, -0.12621517f, -0.17882426f, -0.15213767f, -0.04409342f, 0.09469676f, 
    -0.25667635f, 0.12567337f, -0.00937579f, 0.22280858f, 0.01629473f, 0.00122508f, 0.05350562f, 0.06611533f, 
    -0.02065033f, -0.37369284f, 0.02028413f, -0.00973571f, 0.18389720f, 0.09867267f, -0.00583438f, 0.16027024f, 
    0.04433507f, 0.09061229f, 0.06166058f, 0.02817200f, -0.03443015f, -0.01325126f, -0.11690104f, -0.07102941f, 
    0.06971703f, 0.13824497f, 0.11980113f, 0.00524779f, -0.06424891f, 0.02028279f, -0.00168979f, -0.02734247f, 
    -0.02764892f, 0.01570690f, 0.09698973f, 0.03374289f, -0.26725897f, -0.04315664f, -0.14528574f, -0.02162024f, 
    0.06307177f, -0.09230494f, 0.02064676f, 0.16560651f, -0.05473569f, 0.19575973f, 0.14358875f, 0.03466726f, 
    -0.27256918f, 0.03420066f, 0.17923187f, -0.41064423f, 0.00477269f, 0.04101764f, -0.05070615f, 0.13398877f, 
    0.07481671f, 0.01044736f, -0.01107474f, -0.06283107f, -0.28924435f, 0.12285335f, -0.08736045f, -0.30352002f, 
    0.11774321f, 0.00893943f, -0.08909446f, -0.01602178f, -0.01606709f, -0.10195526f, -0.06039029f, -0.24358377f, 
    0.02982500f, -0.04774301f, -0.05869499f, 0.06644532f, -0.10411116f, -0.02493457f, 0.01185266f, 0.00836217f, 
    -0.25156927f, 0.08546391f, 0.12097502f, -0.03531618f, -0.09650496f, -0.05842419f, 0.21805845f, -0.25209689f, 
    -0.05249281f, -0.04459003f, -0.01177766f, -0.08000360f, 0.06305221f, 0.07211930f, 0.06742632f, 0.07928452f, 
    0.07499035f, -0.15417358f, -0.17652535f, -0.19752288f, 0.10484284f, 0.18701677f, -0.01566151f, -0.01741308f, 
    0.01377660f, 0.01995036f, 0.15613024f, -0.17950383f, -0.14034487f, 0.00298701f, 0.21082942f, 0.27178243f, 
    0.03072019f, 0.04338028f, -0.03228552f, -0.04593047f, 0.01569281f, 0.01665698f, 0.09889432f, 0.15564582f, 
    -0.01573924f, 0.09894058f, 0.02775315f, 0.26579151f, -0.08132274f, 0.07902430f, -0.06049140f, -0.04457293f, 
    0.11605004f, 0.05312943f, -0.09980194f, 0.08137344f, -0.14786664f, -0.14967255f, 0.17221111f, 0.05690254f, 
    -0.00392423f, -0.00468732f, 0.10282201f, 0.01510540f, 0.00661672f, 0.11015402f, -0.12793785f, 0.10005796f, 
    0.06645906f, -0.01964183f, 0.15027577f, 0.01977889f, 0.04456707f, 0.06006363f, 0.07146950f, -0.06936845f, 
    -0.04595201f, -0.18595819f, 0.04058899f, 0.10182184f, -0.14117341f, -0.11105806f, -0.17987585f, 0.08958458f, 
    0.14430656f, 0.04482991f, 0.10156444f, -0.07341497f, 0.10527906f, -0.09599600f, -0.03624024f, 0.06271744f, 
    -0.14540043f, 0.00474999f, -0.00257221f, -0.18814124f, -0.00840004f, 0.04528697f, -0.02829967f, 0.06391747f, 
    -0.03485371f, -0.12974970f, 0.02872798f, -0.06522368f, -0.04802822f, 0.02195799f, -0.04484415f, 0.05076677f, 
    -0.01508475f, 0.03145596f, 0.03430349f, -0.14036842f, 0.05710201f, 0.00368264f, -0.16122369f, 0.01001993f, 
    -0.04865674f, 0.02150334f, 0.24688599f, 0.00002018f, -0.02999706f, -0.03359679f, -0.04209643f, -0.12670329f, 
    0.11568556f, -0.06467901f, -0.00157777f, 0.00623666f, -0.49584568f, -0.13268101f, -0.11251841f, 0.08004206f, 
    0.07569525f, 0.03584489f, 0.06591396f, -0.06692782f, 0.03803796f, -0.00525052f, 0.09572389f, -0.04741501f, 
    -0.01145208f, 0.04722482f, -0.10017503f, -0.15947896f, -0.01390108f, 0.10813508f, -0.00791116f, -0.03695292f, 
    0.05844451f, 0.01578122f, -0.15684234f, -0.05111520f, -0.04158785f, 0.17024605f, 0.13153386f, -0.10719672f, 
    -0.08431204f, -0.02716200f, 0.10642970f, -0.10352604f, 0.12638541f, 0.01199288f, -0.23383793f, -0.03008679f, 
    0.01349298f, -0.10980756f, -0.05803191f, -0.08967665f, 0.05400428f, -0.12752770f, 0.11634783f, -0.00847028f, 
    0.14728282f, 0.06277177f, -0.02901240f, -0.27726609f, -0.45102280f, -0.03165003f, 0.02622980f, -0.25689781f, 
    0.00802676f, 0.00137476f, -0.03505303f, -0.03043008f, 0.07916290f, -0.11598296f, -0.00519040f, -0.13899575f, 
    -0.04296260f, -0.17641571f, 0.18701792f, 0.04865887f, 0.15113854f, 0.07609200f, -0.08344294f, -0.09005766f, 
    0.10308786f, -0.01071371f, 0.06197371f, 0.04067154f, 0.04281007f, 0.18350124f, 0.17597811f, -0.11383242f, 
    -0.06775995f, 0.15408994f, -0.07073899f, 0.01677692f, -0.06683303f, 0.03326515f, 0.00875205f, -0.04798745f, 
    -0.05122194f, 0.00015481f, -0.02475350f, -0.04946086f, 0.02462683f, 0.05827010f, 0.11123940f, -0.03225211f, 
    0.09317437f, 0.23689492f, -0.00343695f, 0.06307934f, -0.35321400f, 0.05353800f, -0.05343724f, -0.17834119f, 
    0.10226518f, 0.00624974f, 0.11419464f, 0.02176654f, -0.02230275f, 0.00231471f, -0.06386921f, 0.00269314f, 
    -0.28092134f, 0.09137935f, -0.04193038f, -0.20697077f, -0.03409644f, -0.09721105f, 0.02110363f, -0.07171498f, 
    -0.02704888f, -0.03930207f, 0.02308910f, 0.11043208f, -0.14007568f, 0.10217931f, 0.09304436f, 0.14708608f, 
    0.06885596f, -0.17980218f, -0.02807870f, 0.03024466f, -0.00130995f, -0.01095004f, -0.23968820f, 0.02625429f, 
    0.09454978f, 0.14964557f, -0.12958093f, 0.19540913f, -0.04296108f, 0.03917043f, 0.04111307f, -0.02346187f, 
    -0.03221408f, 0.15543300f, 0.01784066f, -0.02305826f, 0.08322096f, -0.13251324f, 0.13222420f, 0.01456364f, 
    0.01267043f, 0.06038566f, 0.09557079f, -0.08838442f, 0.01301767f, 0.14759383f, 0.11680986f, 0.01918821f, 
    -0.18586420f, -0.42460766f, -0.06031979f, -0.07607551f, 0.02468922f, 0.10634975f, -0.01717545f, -0.07359295f, 
    0.01966288f, -0.07694736f, 0.09015509f, 0.11466966f, -0.17866313f, 0.04461108f, 0.04466226f, 0.03419217f, 
    0.00268198f, 0.04011095f, 0.05518471f, 0.02379751f, 0.03907143f, 0.08769969f, 0.05541120f, 0.00209653f, 
    -0.09541843f, 0.07328234f, -0.30521119f, 0.03637327f, 0.07404139f, 0.03117194f, 0.04570672f, -0.02859864f, 
    -0.14202276f, 0.07027169f, -0.04108321f, -0.21874490f, 0.22043200f, -0.11071838f, 0.03809642f, -0.04494986f, 
    -0.03588632f, -0.03494617f, 0.00864329f, 0.01163714f, 0.01745107f, -0.20512243f, -0.17482127f, 0.01625713f, 
    -0.18071240f, 0.12746178f, 0.14168389f, -0.23771985f, -0.12151375f, 0.06468206f, 0.08468214f, 0.03145761f, 
    0.05356834f, -0.01869009f, -0.01860478f, -0.07369946f, -0.22221519f, -0.08755736f, -0.16705331f, -0.06130290f, 
    0.02516902f, -0.09276672f, 0.03937123f, 0.02218029f, 0.05829779f, 0.02744765f, 0.11563768f, 0.01192520f, 
    -0.08543479f, -0.14499247f, -0.11165581f, 0.21144962f, 0.01732926f, 0.12358583f, -0.03850765f, -0.00512459f, 
    0.05106612f, -0.03132537f, -0.14277361f, -0.04470170f, -0.31759936f, -0.01046165f, -0.14177738f, -0.22262397f, 
    -0.04361496f, -0.00291814f, 0.02474480f, 0.01730315f, -0.00395152f, -0.07376172f, -0.07151548f, 0.04443409f, 
    0.00660781f, -0.03908643f, -0.02008937f, 0.05345012f, 0.00333264f, 0.01177167f, 0.00811114f, 0.02726770f, 
    -0.12639308f, 0.00767354f, 0.05210013f, 0.04741689f, 0.19985992f, 0.12604356f, 0.18986608f, 0.32579079f, 
    0.01590671f, 0.05198935f, 0.02378492f, -0.01686526f, 0.01864146f, -0.02641014f, -0.02615196f, 0.01667631f, 
    0.20186925f, -0.12968823f, 0.14643028f, -0.13293514f, -0.00303537f, 0.00361908f, 0.04793300f, 0.11390495f, 
    -0.00486464f, -0.00664655f, -0.15123571f, -0.12582590f, -0.12865077f, 0.01396952f, 0.00730330f, -0.12745115f, 
    -0.00355584f, 0.07587364f, 0.04740264f, 0.04725984f, 0.06203245f, -0.10518340f, 0.03230987f, 0.09531993f, 
    -0.03808848f, -0.09915461f, -0.11912022f, -0.05035689f, -0.03256634f, 0.07398755f, -0.05924510f, -0.06686963f, 
    -0.06708698f, -0.04964443f, -0.02463713f, -0.22288497f, -0.21268833f, -0.03374610f, -0.00203114f, -0.00639556f, 
    0.01969823f, 0.05403019f, 0.14112744f, 0.00133885f, -0.02041342f, 0.00022248f, 0.15014650f, 0.07755715f, 
    -0.12142844f, 0.11635643f, 0.17558858f, 0.18183137f, 0.15807556f, -0.01280532f, -0.02730258f, 0.01842985f, 
    -0.09590022f, -0.06554206f, -0.11711881f, 0.00823199f, -0.32591924f, 0.10795870f, 0.00021715f, 0.32668373f, 
    0.04639104f, 0.13321327f, -0.03005165f, 0.08641066f, 0.05102383f, 0.10255295f, 0.06056553f, -0.09020463f, 
    -0.03256185f, -0.05932659f, -0.14853077f, -0.26875359f, 0.03647274f, 0.01832584f, -0.09245013f, 0.13962756f, 
    0.02580047f, -0.09536126f, 0.06059409f, 0.06412826f, 0.02535559f, -0.04156556f, -0.04976681f, 0.05007309f, 
    -0.00974314f, -0.00908841f, 0.10194749f, -0.05601465f, 0.04181832f, -0.18171509f, -0.16400343f, -0.16610099f, 
    -0.44590196f, 0.17484924f, -0.01626649f, 0.12749133f, -0.01287656f, -0.05453685f, 0.06355972f, 0.03395226f, 
    -0.04139718f, 0.09329478f, -0.06765475f, -0.00113248f, -0.01288989f, 0.00507772f, 0.16590188f, 0.04578703f, 
    0.03681511f, 0.05527826f, -0.03863734f, -0.08085489f, -0.08114505f, 0.13985355f, -0.19968368f, 0.06683453f, 
    0.11710433f, -0.15103768f, 0.00313032f, 0.00315678f, 0.00858447f, -0.00809983f, -0.00314111f, -0.08966234f, 
    -0.07917798f, 0.04117718f, -0.15925273f, 0.08126945f, 0.15718050f, -0.11995135f, 0.03480587f, -0.10158469f, 
    -0.10994066f, 0.02673891f, -0.01280283f, 0.07808623f, -0.02710804f, -0.01578156f, 0.07250590f, 0.11181722f, 
    0.10696545f, -0.13336758f, -0.26240885f, -0.16868992f, -0.05149143f, -0.05298125f, -0.13100712f, 0.07730934f, 
    0.02139289f, 0.13925761f, -0.04729288f, 0.04084535f, 0.01950736f, -0.10175416f, 0.05365736f, -0.16561691f, 
    -0.03775653f, -0.07651642f, 0.05869025f, 0.04967992f, -0.12102401f, -0.01001864f, -0.04688678f, 0.06164433f, 
    -0.12196644f, -0.00505246f, -0.05111176f, -0.10041050f, 0.06037373f, -0.01044065f, -0.10443610f, -0.03677435f, 
    0.00517211f, 0.00206899f, -0.11465951f, -0.21634348f, -0.05083539f, 0.03756803f, -0.04583412f, -0.19513935f, 
    0.00552812f, -0.07343557f, 0.08685558f, -0.10766622f, -0.11664354f, 0.06678022f, 0.17341988f, -0.18241990f, 
    -0.00412364f, 0.02218583f, -0.05217758f, -0.04538396f, -0.02371347f, 0.06087502f, -0.03506241f, -0.00592868f, 
    -0.12229196f, -0.10399141f, -0.06261864f, -0.14541721f, 0.00732311f, 0.23735955f, 0.01997115f, -0.09543222f, 
    0.13618693f, 0.06648899f, -0.00935747f, -0.00042170f, -0.10003993f, -0.04909340f, -0.09802515f, 0.00562917f, 
    0.17562769f, -0.25004950f, -0.06548735f, 0.11486855f, -0.00517033f, 0.03096075f, -0.00964235f, 0.07585476f, 
    0.14168851f, 0.00577559f, -0.00766344f, 0.03443084f, -0.22587186f, 0.03488585f, 0.16123591f, -0.03608055f, 
    -0.04811163f, -0.00667682f, 0.04123167f, 0.13616145f, -0.03493058f, 0.03702740f, -0.09336986f, -0.00349211f, 
    0.13670036f, 0.07656018f, -0.15575218f, -0.17693384f, 0.02122608f, 0.00863664f, -0.05604991f, -0.01215126f, 
    -0.09746327f, -0.01366521f, -0.05862806f, 0.01000958f, -0.03568311f, -0.41070193f, -0.25971535f, 0.10896318f, 
    -0.10162908f, 0.03350980f, -0.02283986f, -0.01512149f, -0.01790992f, -0.04992709f, 0.02755591f, -0.04196294f, 
    0.16263838f, -0.26502088f, -0.01532622f, 0.16792555f, -0.16931926f, 0.10442641f, 0.14569585f, 0.02975058f, 
    -0.14463924f, 0.04616657f, 0.07480831f, 0.24240781f, -0.41462475f, 0.03416954f, -0.30967441f, 0.29070142f, 
    0.02880647f, 0.08672689f, 0.05627006f, -0.02569461f, 0.02661077f, -0.04176577f, -0.06853700f, -0.08573183f, 
    0.12015344f, 0.04847448f, -0.03531588f, 0.23887390f, -0.00210501f, 0.02011565f, -0.08822442f, 0.04585841f, 
    -0.05326672f, 0.18514648f, 0.01194104f, -0.00393629f, -0.11589716f, -0.09256678f, -0.24477054f, -0.25596371f, 
    -0.10535844f, 0.07186568f, -0.16224231f, -0.01066675f, -0.05667299f, -0.10628115f, 0.07903779f, 0.15501994f, 
    -0.04237904f, 0.13736516f, 0.09875444f, 0.01133678f, 0.04615214f, -0.05472747f, 0.04869925f, -0.07545564f, 
    0.06914417f, 0.12155765f, -0.05045320f, -0.02218014f, -0.08590085f, 0.10661524f, 0.22610559f, -0.08464933f, 
    -0.03598551f, 0.01656020f, 0.13434297f, -0.10594425f, -0.08100270f, -0.00230306f, 0.01443329f, 0.06234796f, 
    -0.07786176f, -0.18557461f, 0.09377836f, 0.10923387f, -0.00141688f, 0.00717772f, 0.04740781f, -0.02646642f, 
    -0.00354358f, -0.09616005f, -0.04720163f, 0.03555287f, 0.26020312f, -0.19384520f, 0.03906279f, 0.04046257f, 
    -0.01527593f, 0.05058829f, 0.06668806f, -0.00204297f, 0.11566989f, -0.07923754f, 0.08917245f, 0.09996811f, 
    0.00898539f, 0.07814940f, -0.05431919f, -0.11702435f, 0.07300515f, 0.00254139f, 0.09124877f, -0.07282908f, 
    -0.02924960f, -0.10659637f, 0.02142464f, 0.09005392f, 0.08007911f, 0.13974808f, -0.09824146f, -0.28975049f, 
    -0.03908550f, 0.04651404f, 0.12686023f, -0.02509193f, 0.01764853f, -0.00782113f, -0.08808161f, -0.04111933f, 
    -0.22587277f, 0.04018980f, 0.17142853f, -0.10807814f, -0.03182893f, 0.01745213f, 0.07692542f, 0.01679446f, 
    -0.02564003f, 0.01673383f, -0.07117200f, 0.09700209f, 0.07006034f, -0.12135487f, -0.06678993f, -0.13995947f, 
    -0.03375442f, 0.01735690f, 0.05723717f, 0.06865922f, 0.08191474f, 0.09573463f, -0.22361588f, -0.09222192f, 
    -0.04774445f, -0.25005507f, -0.28211915f, 0.18268086f, 0.04058033f, 0.02140263f, 0.10375551f, -0.10859250f, 
    0.09932670f, -0.12677731f, 0.12242865f, -0.09567510f, 0.11352757f, 0.03236654f, -0.09456667f, -0.06521664f, 
    -0.03324952f, 0.06170375f, 0.00261893f, 0.02471445f, -0.01939377f, -0.09145571f, 0.07630876f, -0.13429423f, 
    0.27305573f, 0.15586464f, 0.00623887f, -0.37704033f, -0.17969792f, -0.06042290f, -0.02822683f, -0.01126921f, 
    0.11438227f, 0.07032294f, 0.04706550f, -0.01751580f, -0.14860880f, 0.07405870f, -0.11757972f, -0.08363139f, 
    -0.12289496f, -0.01062402f, -0.04452304f, -0.22396488f, -0.08107282f, 0.05947153f, -0.07427455f, -0.05189312f, 
    0.23191340f, -0.01825547f, 0.03655314f, -0.14421006f, -0.00441202f, 0.01778072f, 0.09309962f, 0.00212917f, 
    0.07995777f, 0.02122212f, -0.00527711f, -0.10375942f, -0.21858700f, 0.20975557f, -0.06410493f, 0.01888710f, 
    -0.18166864f, 0.06060225f, -0.01740155f, 0.13471410f, 0.10262331f, 0.01791799f, 0.01754895f, -0.05904131f, 
    0.21144752f, 0.05175376f, 0.10498232f, -0.07982080f, -0.02637871f, 0.03833662f, 0.05039417f, 0.18442468f, 
    -0.15516692f, 0.12615497f, 0.14063255f, 0.15000254f, 0.21760082f, -0.14360482f, 0.05847330f, -0.14703129f, 
    -0.15028445f, 0.02628609f, -0.05923114f, 0.04469270f, -0.13784599f, 0.08274042f, -0.03434891f, -0.03289710f, 
    -0.28345087f, -0.29760206f, 0.03238949f, -0.12309241f, 0.13784930f, -0.04744794f, 0.01252346f, -0.02251202f, 
    -0.10315927f, 0.05311853f, 0.10986984f, 0.11169056f, 0.13789651f, 0.02644165f, 0.06032391f, -0.03808065f, 
    0.11324941f, 0.11658691f, 0.00616591f, 0.06824295f, -0.00339299f, -0.03698146f, 0.16051558f, -0.04946510f, 
    -0.24694793f, 0.16589227f, 0.04410578f, 0.01056699f, -0.00270913f, 0.01378493f, -0.15501475f, 0.03968278f, 
    -0.11177091f, -0.02765238f, 0.07638478f, 0.07328324f, 0.61396766f, -0.00388863f, 0.07348941f, -0.20113626f, 
    -0.06105321f, -0.04440602f, -0.06907894f, 0.04560060f, 0.00867619f, 0.01478905f, -0.06388786f, 0.01840882f, 
    0.24120307f, -0.21149668f, 0.08387788f, -0.21085070f, 0.01113634f, 0.02059304f, -0.01262481f, 0.06731591f, 
    0.00970687f, 0.12381590f, 0.02045864f, -0.12514965f, 0.06321189f, 0.23700866f, 0.30177969f, 0.11925786f, 
    -0.13098946f, -0.03245586f, 0.06985421f, -0.00253415f, 0.11982844f, 0.04729815f, 0.08921754f, -0.00899382f, 
    -0.05302965f, 0.12410999f, 0.01030280f, -0.36820522f, 0.02298722f, 0.09528520f, -0.04537222f, 0.03721787f, 
    -0.17580077f, -0.11345141f, 0.04669303f, -0.21212140f, 0.11194190f, -0.36820132f, -0.02801683f, -0.05176312f, 
    0.00473680f, 0.06047574f, 0.02712872f, -0.09013848f, 0.05830807f, 0.08738796f, -0.00734085f, -0.05078072f, 
    0.15607470f, 0.22520395f, 0.02283342f, 0.25718421f, 0.03400456f, 0.07124170f, -0.00125908f, 0.04033781f, 
    -0.06938775f, -0.02911507f, 0.03584255f, -0.06973518f, -0.01144760f, -0.12257504f, 0.02339538f, 0.03901665f, 
    0.03057552f, -0.09810521f, 0.05267204f, 0.06743225f, -0.08973116f, 0.02141272f, -0.03203336f, -0.09433082f, 
    -0.23820026f, 0.09851757f, -0.17349362f, -0.16460538f, 0.04426264f, -0.02554853f, 0.00694797f, 0.07532196f, 
    -0.12302189f, 0.03688232f, -0.01294650f, -0.04637957f, 0.23789397f, 0.08142817f, 0.06064467f, -0.10669703f, 
    -0.11678228f, 0.09684668f, -0.04236611f, 0.05248897f, 0.06915352f, 0.04430348f, 0.07771706f, -0.11039753f, 
    0.17925024f, 0.09183004f, 0.14398830f, 0.04379686f, 0.08110750f, 0.01001581f, 0.09749854f, -0.06025743f, 
    -0.01435307f, 0.06609267f, -0.01165847f, 0.00220421f, 0.15602066f, -0.10117390f, -0.00273268f, 0.00171305f, 
    0.03591942f, -0.06342299f, 0.01718271f, -0.11803840f, 0.01119526f, 0.01519479f, 0.05136628f, -0.02200611f, 
    -0.02648709f, 0.10834298f, -0.14781231f, 0.09685253f, -0.14690760f, 0.00129148f, -0.07316385f, -0.08568511f, 
    -0.09972455f, -0.04097588f, -0.02816381f, -0.02784591f, 0.17905928f, -0.22987461f, 0.13562395f, 0.29228470f, 
    0.07244257f, -0.02902519f, -0.01468690f, 0.01457427f, -0.05466388f, -0.04584655f, -0.07894793f, -0.11154566f, 
    -0.00219750f, -0.06632271f, -0.09352390f, -0.15232649f, 0.01979703f, -0.00136225f, -0.02539741f, -0.09384840f, 
    -0.02667404f, -0.00582687f, 0.04141483f, -0.03674612f, 0.08928725f, 0.14000182f, 0.08396902f, 0.12757963f, 
    -0.00308611f, 0.02945787f, 0.08319249f, -0.02451500f, -0.03828313f, -0.00518245f, 0.00038030f, -0.00942382f, 
    -0.20569842f, 0.11110248f, -0.06333170f, 0.06888282f, -0.03083177f, -0.11807298f, -0.04922896f, 0.01956477f, 
    -0.00745180f, -0.06090717f, 0.01983926f, 0.02019130f, 0.10140214f, 0.07396747f, 0.11470922f, 0.14265499f, 
    0.03295142f, 0.04094725f, -0.01534986f, -0.03752843f, 0.02294676f, -0.03064969f, -0.09796736f, -0.09611688f, 
    -0.20952171f, 0.12049881f, -0.13172963f, -0.10307980f, 0.02045974f, -0.01233585f, -0.00417087f, -0.05850142f, 
    -0.09615340f, 0.00467764f, 0.03282859f, -0.02957249f, -0.16831309f, 0.00082261f, 0.05209390f, 0.10302338f, 
    -0.08564119f, -0.13846467f, 0.03454949f, 0.02618387f, 0.02327249f, -0.04158510f, 0.10274057f, -0.05214804f, 
    0.12689590f, -0.07336256f, 0.04075539f, -0.01146968f, -0.07526308f, 0.02561729f, -0.05272225f, 0.06342580f, 
    -0.05807280f, -0.00409036f, -0.09281111f, -0.14433432f, 0.07945257f, 0.09396496f, 0.09960221f, 0.09202447f, 
    0.01220317f, -0.01085220f, -0.08703615f, -0.05208082f, -0.09519524f, 0.01421433f, -0.04325506f, 0.01897521f, 
    0.03490046f, 0.07682246f, 0.04940104f, 0.07630994f, 0.07765631f, 0.04688778f, -0.02264034f, 0.03298039f, 
    -0.01291578f, -0.02004826f, -0.00264349f, -0.11320387f, -0.16308713f, 0.03808511f, -0.18433744f, -0.14311384f, 
    -0.15581079f, 0.05173076f, -0.16368692f, -0.05656017f, -0.03004275f, -0.04718466f, 0.00222806f, -0.04493944f, 
    -0.01849450f, -0.24700907f, -0.06210735f, -0.08744915f, 0.04237537f, -0.00745361f, 0.05553291f, -0.05824367f, 
    -0.02946031f, -0.09016771f, 0.03774022f, -0.03141658f, -0.04421828f, -0.08598582f, -0.15385301f, -0.18192144f, 
    0.00909899f, -0.02734725f, -0.08333959f, -0.01773265f, 0.04742470f, -0.02072596f, 0.06536581f, 0.00052220f, 
    -0.04981476f, -0.19081752f, -0.09250402f, 0.10922515f, -0.05469218f, -0.16098866f, -0.02771102f, -0.02866405f, 
    -0.05105180f, 0.02771141f, 0.03808165f, -0.02704593f, -0.00843713f, 0.00524769f, -0.06053671f, 0.14260882f, 
    -0.06493594f, -0.05959417f, 0.00748314f, -0.02451926f, -0.01944699f, -0.05518569f, -0.03567700f, -0.03482676f, 
    -0.04745868f, -0.17268623f, -0.15444221f, -0.21023184f, -0.01468409f, -0.02382309f, -0.01713290f, -0.03258083f, 
    -0.10455238f, 0.05116326f, 0.03440927f, -0.08202017f, -0.03074197f, 0.09497158f, 0.03382728f, -0.00186931f, 
    0.07424892f, -0.09124666f, -0.00226640f, -0.07738480f, -0.03551619f, 0.01573238f, -0.02945191f, -0.14169604f, 
    0.16788359f, -0.12749052f, 0.11879369f, 0.08282116f, 0.11913036f, 0.00428391f, -0.01496147f, 0.00174452f, 
    -0.05242084f, 0.02772584f, -0.05137039f, -0.05198391f, -0.18001476f, 0.05258013f, 0.02080068f, -0.09343244f, 
    -0.02040468f, 0.02455027f, -0.05684156f, -0.09490959f, -0.13509476f, 0.02607881f, -0.04555773f, -0.08279333f, 
    0.11356169f, 0.13263945f, 0.17877306f, 0.14314726f, 0.12489954f, 0.03997612f, -0.00004851f, 0.04250101f, 
    -0.04720892f, 0.00104493f, -0.03105354f, 0.01179344f, -0.05571003f, 0.09125932f, -0.03755538f, -0.01270557f, 
    -0.08320607f, -0.03783724f, -0.01189557f, 0.03491465f, -0.05437102f, 0.10058147f, -0.01160935f, -0.01362215f, 
    -0.00490124f, 0.05149049f, 0.11340965f, -0.11167808f, 0.04737608f, 0.02367257f, 0.04310652f, -0.00156197f, 
    -0.00001969f, -0.02966495f, -0.03668481f, -0.03675055f, 0.14827204f, 0.08505477f, 0.14447686f, 0.08903275f, 
    0.13475408f, 0.06866087f, 0.05401227f, -0.02787756f, -0.05543696f, -0.05042378f, -0.07711007f, -0.05490658f, 
    -0.09013885f, -0.16713637f, 0.07700668f, -0.05712463f, -0.05249831f, -0.12315630f, -0.03986796f, 0.00204905f, 
    0.05083681f, -0.02214608f, 0.02491108f, -0.05641339f, -0.17579763f, 0.16460744f, -0.08818989f, -0.10037863f, 
    -0.04078347f, -0.07839892f, -0.12936990f, 0.02402449f, -0.06308024f, 0.02745462f, 0.04386104f, 0.01644350f, 
    -0.20542255f, 0.07913363f, 0.08410868f, -0.01077774f, -0.03463787f, 0.00490368f, 0.02110974f, -0.04309777f, 
    -0.02540065f, -0.02537439f, -0.03776110f, 0.04814728f, -0.12652172f, 0.12897523f, 0.02670408f, -0.03823139f, 
    -0.02125486f, -0.00920859f, 0.00134306f, -0.08229617f, -0.08252410f, -0.00021823f, -0.02769626f, -0.12985128f, 
    -0.03166590f, -0.00160948f, -0.10352004f, -0.00301695f, -0.05383364f, -0.14911720f, -0.08269764f, -0.04724263f, 
    -0.03526659f, 0.01855670f, 0.00852082f, -0.02835817f, 0.02576494f, 0.19215463f, 0.01485434f, 0.11575044f, 
    0.03002128f, 0.00474631f, -0.05403155f, -0.09055681f, -0.00650677f, 0.00573033f, 0.02835534f, -0.00906004f, 
    -0.06534580f, 0.02928304f, -0.05565061f, -0.04098230f, 0.11090792f, -0.00125921f, 0.05603201f, -0.10047588f, 
    0.04173403f, 0.03676326f, 0.00292705f, 0.02034909f, -0.21540000f, 0.21755220f, 0.13394408f, 0.11898998f, 
    0.03930289f, -0.07102127f, 0.07365648f, -0.02461624f, 0.08388130f, 0.00720996f, -0.00705265f, -0.08492003f, 
    -0.11663590f, 0.07804357f, 0.04221079f, 0.02227108f, 0.03811359f, -0.10046899f, -0.08436581f, 0.00397043f, 
    -0.03720990f, 0.01076206f, -0.03354930f, -0.01177003f, 0.19233115f, -0.07782485f, 0.12807898f, 0.18951732f, 
    -0.04522427f, -0.07694200f, -0.06703852f, 0.01008500f, -0.05654558f, -0.04337990f, 0.06041656f, -0.03454801f, 
    -0.20973974f, 0.04087162f, -0.02050531f, -0.08013161f, -0.12344182f, 0.00138139f, 0.07594087f, -0.01145018f, 
    -0.04589671f, -0.04634922f, -0.08026604f, -0.06117667f, 0.21414636f, 0.06096114f, 0.12683591f, 0.01308110f, 
    -0.11127825f, 0.00733395f, -0.02332069f, -0.03304296f, 0.01106754f, 0.11445145f, 0.03702651f, 0.02919434f, 
    -0.23188268f, 0.06457183f, -0.01565639f, -0.07691530f, -0.04168728f, -0.06364908f, -0.03414355f, -0.06794031f, 
    -0.10347613f, -0.02310737f, -0.04316104f, -0.06182277f, 0.10716485f, -0.08388261f, 0.14882466f, -0.21302778f, 
    -0.08428481f, 0.02023125f, -0.02726507f, -0.01071255f, -0.04938221f, 0.03267703f, -0.04692886f, -0.03414517f, 
    0.00964195f, -0.01445934f, 0.01008284f, 0.13285227f, -0.11581492f, 0.01764201f, -0.07812847f, -0.03046186f, 
    -0.10147568f, 0.03554851f, -0.04472980f, -0.06980478f, -0.42306381f, 0.16335490f, 0.00743663f, -0.15313238f, 
    0.05855544f, -0.02033899f, -0.05177230f, -0.03101150f, -0.05931785f, -0.03310053f, 0.04865108f, 0.03817489f, 
    -0.11458497f, 0.09204924f, 0.12437323f, 0.08192559f, 0.05352152f, 0.09154703f, 0.09287827f, -0.03879892f, 
    -0.04317218f, 0.00712391f, 0.02972653f, -0.03990232f, -0.08833995f, -0.05150073f, -0.09373686f, -0.07581896f, 
    -0.03811806f, -0.03090909f, -0.04445679f, -0.04166834f, 0.00028798f, -0.05286095f, -0.02749229f, -0.08530241f, 
    -0.01600697f, -0.01109937f, -0.07456484f, 0.03216548f, -0.03570612f, -0.00434678f, -0.02636130f, 0.01670169f, 
    0.05643581f, -0.01073524f, 0.02344909f, -0.03040319f, -0.02200272f, -0.08817968f, 0.00894850f, 0.04666704f, 
    0.01506797f, 0.02205517f, -0.00903714f, -0.03935200f, -0.04112037f, -0.03074106f, -0.00279378f, -0.05927762f, 
    -0.12127023f, -0.05192860f, -0.09657079f, -0.10890830f, 0.01997405f, 0.07738814f, -0.05013052f, -0.05710688f, 
    0.00944576f, 0.05596906f, -0.03338078f, -0.08562255f, 0.02278425f, 0.19105990f, 0.13083021f, 0.15943316f, 
    0.10011359f, -0.00195064f, 0.07499842f, -0.07563120f, -0.03899373f, 0.04217281f, 0.02151604f, -0.11094516f, 
    0.28866947f, 0.10247540f, 0.11948791f, -0.03660940f, -0.06644598f, -0.06068993f, 0.01471390f, -0.01385154f, 
    -0.05813827f, 0.07309435f, 0.05171520f, -0.02989595f, -0.28661758f, 0.11184815f, -0.09922236f, -0.08307198f, 
    -0.10750993f, -0.02967558f, -0.03776876f, -0.07203765f, -0.01251995f, 0.07707394f, 0.05378990f, -0.06789659f, 
    0.22455782f, -0.28259027f, -0.11369143f, 0.01690562f, -0.04915242f, -0.00613176f, -0.01729037f, -0.06107317f, 
    0.00697208f, -0.06157821f, -0.05422616f, -0.07055636f, -0.14003551f, 0.05286010f, 0.03100793f, 0.16610429f, 
    0.14892165f, 0.01707651f, -0.00775439f, -0.07081985f, -0.01885054f, 0.02798987f, 0.05322290f, -0.02173446f, 
    -0.04649031f, 0.12778476f, 0.15253964f, 0.09896386f, 0.07524617f, 0.04390297f, 0.11660076f, 0.02343604f, 
    -0.02740209f, 0.10240756f, 0.06740537f, -0.10973507f, 0.11698721f, -0.03926711f, 0.05019375f, -0.19233941f, 
    -0.02611673f, -0.00011642f, -0.01801250f, -0.07496491f, -0.02839249f, -0.02270647f, 0.00693690f, -0.00914244f, 
    -0.19970079f, -0.06204698f, -0.12360534f, -0.11321237f, 0.02394002f, -0.00374470f, -0.07601355f, -0.02040525f, 
    0.02531054f, -0.05480436f, -0.03081558f, 0.03741128f, 0.16777946f, 0.17517427f, -0.01876128f, -0.13514182f, 
    -0.10440883f, -0.05116399f, -0.04633859f, -0.03380384f, -0.06823746f, -0.00533561f, -0.06144940f, -0.02660044f, 
    0.18286353f, -0.17158230f, 0.06072846f, -0.00970248f, 0.03649946f, -0.01276816f, -0.05578194f, -0.04152401f, 
    -0.06901672f, 0.02228661f, 0.00441926f, -0.06481203f, 0.05726676f, 0.10147682f, 0.07441092f, 0.09441989f, 
    -0.09231491f, -0.06807978f, 0.08282609f, -0.01793932f, -0.04016483f, 0.08640155f, 0.03208432f, -0.03373241f, 
    -0.11385833f, 0.09898712f, -0.04790188f, -0.09925457f, -0.01168677f, -0.01724223f, -0.02193682f, -0.13998710f, 
    -0.02176481f, 0.01091210f, -0.03291375f, 0.04972064f, 0.08714484f, -0.15394689f, 0.14918718f, 0.00213493f, 
    0.08133103f, 0.08911590f, -0.03453836f, -0.00301666f, -0.01671786f, 0.10012534f, 0.03917960f, 0.03567022f, 
    -0.31079304f, -0.08703475f, 0.20220457f, -0.14423406f, 0.01330810f, 0.02091825f, -0.04342495f, -0.01156875f, 
    -0.06691079f, -0.01132645f, -0.11397771f, 0.01338063f, 0.05136961f, -0.14886951f, -0.19719721f, -0.12799273f, 
    0.15530904f, -0.00650285f, -0.07374893f, -0.08292305f, 0.01738360f, -0.03904545f, 0.08623892f, -0.01497080f, 
    0.09019423f, 0.13106591f, -0.13752039f, -0.04238725f, 0.02937605f, 0.10242882f, -0.02819104f, 0.03494783f, 
    -0.00136186f, -0.04192407f, 0.06956996f, 0.03680117f, 0.06958926f, -0.10375816f, -0.06053590f, -0.02291047f, 
    0.00691095f, -0.15047501f, 0.08290616f, -0.14518780f, -0.04699180f, -0.10812505f, 0.05499976f, 0.02625260f, 
    0.00513340f, 0.04575624f, 0.06062645f, 0.08106858f, -0.08295140f, 0.01240844f, -0.01580836f, 0.04418699f, 
    -0.01516637f, 0.04795364f, -0.08329613f, -0.02742504f, 0.02945809f, -0.03967579f, -0.05152400f, 0.01495717f, 
    0.07464396f, -0.07549608f, -0.11186431f, -0.01296849f, 0.15514983f, -0.06564077f, -0.20088033f, 0.09980869f, 
    0.11223911f, 0.27620706f, -0.01183425f, -0.08717019f, -0.01959864f, 0.06470913f, 0.09608833f, -0.02824025f, 
    0.05190278f, 0.06594802f, 0.09577049f, 0.18094274f, -0.00759596f, -0.12664928f, -0.15053642f, -0.18834977f, 
    0.07499718f, -0.06930432f, -0.11430011f, -0.06275126f, -0.13113052f, 0.00024984f, 0.12032220f, -0.12468512f, 
    0.03419282f, -0.15910745f, 0.06491844f, 0.04172995f, 0.09483302f, -0.01178082f, -0.05236892f, -0.03381589f, 
    -0.01494037f, 0.11259046f, -0.12692258f, 0.03575710f, -0.17504026f, 0.13564658f, 0.00214997f, 0.03999454f, 
    -0.05191557f, 0.02529199f, -0.18473880f, -0.00056987f, 0.00530570f, 0.05018527f, -0.03728935f, -0.13182189f, 
    0.01766759f, 0.20291501f, -0.20442575f, -0.11874501f, 0.12038194f, 0.00075903f, -0.08363786f, -0.04448851f, 
    0.06151688f, -0.03433091f, 0.10533828f, 0.09737637f, -0.22387367f, 0.03107117f, 0.10705197f, -0.16064297f, 
    -0.05409705f, 0.01741259f, -0.00885673f, -0.07315464f, -0.03006284f, -0.04893363f, 0.06218593f, -0.00078771f, 
    0.10613989f, -0.06932472f, -0.11609940f, 0.02319499f, 0.06893436f, -0.11011731f, -0.06888781f, 0.03767593f, 
    0.07062362f, 0.00234047f, 0.00454871f, -0.00332305f, -0.01161247f, -0.19053300f, -0.20332019f, -0.13174807f, 
    0.01951741f, -0.15117374f, -0.15428790f, -0.02033453f, 0.05470031f, 0.04936317f, -0.01666541f, -0.05071597f, 
    -0.11701318f, -0.10101650f, 0.06140760f, 0.01166787f, -0.14816937f, -0.15307526f, 0.02759228f, -0.00463303f, 
    -0.00772896f, 0.05359346f, -0.06085227f, 0.05182432f, -0.19889975f, -0.13021298f, -0.08535219f, -0.17649837f, 
    -0.03695633f, -0.04085944f, -0.06745663f, 0.09974672f, 0.10026688f, -0.03093366f, 0.09696281f, -0.14596918f, 
    -0.15163796f, 0.06089548f, -0.03551704f, -0.25084725f, -0.11560611f, -0.04257537f, 0.00485474f, 0.04831586f, 
    0.10518498f, 0.03535279f, 0.02603769f, 0.03083330f, -0.10387102f, 0.07601219f, 0.06396592f, 0.13282536f, 
    -0.02599447f, -0.08060314f, 0.01015432f, 0.02268196f, 0.07155924f, 0.09217867f, -0.11202139f, 0.00866898f, 
    0.06851907f, -0.07746264f, -0.07274650f, -0.03388565f, 0.12271621f, 0.09755915f, 0.00590785f, -0.03078453f, 
    0.07745889f, 0.03576133f, 0.07457618f, 0.06230474f, 0.20356527f, 0.05342629f, -0.21557310f, -0.19437529f, 
    0.11379458f, 0.10424675f, -0.00333998f, 0.02545273f, 0.07990593f, -0.03660889f, -0.03908440f, -0.00608107f, 
    0.01523997f, -0.08736454f, -0.27319673f, -0.15794601f, 0.03292552f, -0.01995100f, 0.07909624f, -0.00091270f, 
    0.13629125f, 0.11943287f, 0.00656129f, 0.09605406f, -0.06123861f, 0.00634281f, -0.12221362f, -0.18152653f, 
    -0.13103338f, 0.01186092f, -0.10145985f, -0.01164647f, 0.01757784f, 0.08146656f, 0.04598899f, 0.04470524f, 
    0.14342129f, -0.01456016f, -0.07230635f, -0.02752804f, 0.11169237f, 0.00326189f, -0.07574385f, 0.01626173f, 
    0.09678496f, 0.02536030f, 0.00465556f, 0.06714563f, -0.06144915f, -0.08005738f, 0.06510416f, -0.08792491f, 
    -0.14658083f, 0.00585481f, -0.10605298f, 0.07333647f, 0.02560787f, -0.06986347f, 0.07971864f, 0.05774063f, 
    0.08838633f, -0.05837404f, 0.12305991f, 0.05002733f, -0.02625172f, 0.06089452f, 0.00051510f, -0.07503231f, 
    0.01938920f, -0.00992217f, 0.02632693f, -0.10667545f, 0.21606246f, -0.11526991f, 0.13403937f, 0.08792074f, 
    -0.01077419f, 0.00027181f, 0.00143618f, -0.05094581f, 0.14086498f, -0.06589027f, -0.09736701f, -0.09190553f, 
    -0.08226086f, -0.04562573f, 0.02350484f, -0.15828535f, 0.01055771f, -0.04663315f, 0.05804545f, -0.09958931f, 
    -0.02265350f, 0.00665273f, -0.06493262f, -0.03201886f, 0.17277580f, -0.02905461f, 0.03485019f, 0.08082528f, 
    -0.16555893f, -0.00998863f, -0.00391875f, 0.05589626f, 0.02584308f, -0.07401778f, 0.07803654f, -0.00034465f, 
    -0.19191882f, -0.12839125f, 0.05509792f, -0.19133385f, -0.02925288f, -0.09317861f, -0.04767232f, -0.01797140f, 
    -0.02278129f, 0.09212773f, -0.00988059f, 0.00557993f, 0.02119548f, -0.28472129f, 0.20671181f, -0.06846186f, 
    0.04280962f, 0.08813420f, -0.01230491f, -0.12702039f, 0.07490114f, 0.03304214f, 0.03929505f, 0.10740410f, 
    -0.14575794f, -0.08004108f, -0.20400047f, -0.16449171f, -0.13076295f, -0.01653442f, 0.00753915f, -0.13786651f, 
    -0.05587348f, 0.06540276f, -0.03159376f, 0.10142083f, -0.04736067f, 0.00125743f, -0.12353775f, -0.05046243f, 
    0.03684711f, -0.04355586f, -0.05093205f, 0.06626762f, 0.07390884f, 0.03660639f, 0.06968212f, 0.03629015f, 
    -0.01356217f, -0.11218818f, 0.08677491f, -0.01508363f, -0.04719717f, -0.02865841f, -0.05131280f, 0.02560868f, 
    0.09022007f, -0.06758265f, -0.06983615f, 0.07594100f, 0.24472277f, -0.05342478f, 0.02126233f, 0.13640136f, 
    0.01160130f, -0.05583652f, -0.08818220f, -0.00891163f, 0.03742570f, -0.03936908f, -0.04187832f, -0.04505220f, 
    -0.25529021f, -0.06942991f, -0.09359753f, -0.15751079f, -0.04608689f, -0.03531083f, 0.06556688f, 0.03378147f, 
    0.04925860f, 0.05610104f, 0.06985133f, -0.03611748f, 0.04938434f, 0.13442594f, 0.00088843f, -0.03269546f, 
    -0.12366458f, -0.02787458f, -0.02208729f, 0.01838557f, -0.12611829f, -0.06704868f, -0.03122071f, -0.00330267f, 
    0.14451963f, -0.03932359f, 0.02618984f, 0.11220431f, -0.06842584f, -0.00164954f, -0.02189692f, -0.01725415f, 
    0.00924882f, -0.10483975f, -0.03864765f, 0.05872010f, 0.09533685f, 0.23037055f, -0.26087469f, 0.12239861f, 
    0.04674901f, 0.04353439f, -0.10610493f, 0.00160512f, -0.05166100f, -0.09141760f, -0.03299223f, 0.11672632f, 
    0.06760073f, 0.24144293f, -0.17211917f, -0.06170037f, -0.05456088f, 0.02325987f, -0.01971050f, -0.09205049f, 
    0.00392643f, -0.19566260f, 0.11244678f, -0.00322037f, -0.06195950f, 0.00343276f, -0.29578927f, -0.30256167f, 
    -0.01781041f, 0.07418886f, 0.07663381f, -0.06257121f, 0.07743129f, 0.07775291f, -0.16137932f, -0.18193185f, 
    0.15268590f, -0.10074867f, -0.02275413f, 0.08175226f, 0.07559050f, 0.01060589f, -0.07279038f, -0.10004812f, 
    -0.07717209f, 0.07841680f, 0.06006996f, -0.04759591f, 0.04601157f, 0.00727976f, 0.15935716f, -0.03406892f, 
    0.07280826f, -0.02454659f, -0.06266566f, 0.09618665f, -0.02033686f, 0.02549340f, -0.00841871f, -0.02263800f, 
    0.12426320f, -0.02963931f, 0.08550747f, 0.10414274f, -0.01211683f, 0.01008532f, 0.00982407f, -0.00691389f, 
    0.04670243f, 0.01948682f, -0.03161234f, -0.17552918f, -0.06035180f, 0.07754835f, 0.03500223f, 0.02770150f, 
    0.04783881f, -0.04451362f, -0.10786216f, 0.02756048f, 0.06228844f, -0.00355637f, -0.01578970f, -0.00530604f, 
    -0.18896419f, 0.02830490f, -0.23611736f, -0.21489887f, -0.10630238f, 0.01894671f, -0.05698688f, -0.14400423f, 
    0.07000965f, 0.05386357f, -0.05226199f, -0.00865262f, -0.01085093f, -0.04318168f, 0.11215334f, 0.26212037f, 
    0.11290953f, -0.05341396f, -0.09622710f, -0.01335040f, 0.05604352f, 0.03816009f, 0.14140961f, -0.04529782f, 
    -0.07934048f, -0.00921863f, 0.08725398f, -0.00164841f, 0.08236177f, -0.02109333f, -0.13662185f, -0.03923277f, 
    0.07474056f, -0.03159240f, 0.07474361f, -0.04854005f, -0.01802705f, 0.02626279f, 0.00294949f, 0.06817981f, 
    -0.03363879f, -0.03415333f, -0.04103481f, -0.18543965f, -0.01977792f, 0.06011077f, 0.11809709f, 0.07762156f, 
    -0.02659412f, 0.24485478f, -0.17788827f, -0.07460449f, 0.04540888f, -0.01315765f, -0.14217469f, 0.00767099f, 
    0.15574989f, 0.00041151f, 0.05761842f, -0.01731346f, -0.23818202f, -0.03380075f, -0.05010602f, 0.04057464f, 
    -0.05860750f, 0.04655983f, 0.14240104f, -0.10365494f, 0.00727943f, 0.02957997f, -0.08290761f, 0.05121626f, 
    -0.01795179f, -0.06897807f, -0.01664254f, 0.12110033f, 0.01414659f, -0.04739739f, -0.06224188f, 0.01284558f, 
    0.08059826f, -0.14127043f, 0.09933204f, -0.05313037f, 0.02822354f, 0.03509555f, 0.14656866f, 0.18510567f, 
    -0.00471389f, 0.01658347f, 0.02093445f, 0.01655686f, 0.06862337f, -0.08505396f, 0.05087211f, 0.03559751f, 
    -0.15844794f, -0.03632558f, 0.05259275f, -0.20365316f, -0.00156899f, -0.03341270f, -0.02059712f, 0.12102100f, 
    0.11237533f, -0.09187517f, -0.07704280f, 0.06556053f, -0.09366556f, 0.11645490f, -0.00741616f, 0.10645697f, 
    -0.04439773f, 0.07512099f, -0.00633627f, -0.08048200f, 0.01758103f, 0.08267579f, 0.00094341f, 0.05231818f, 
    0.23203027f, -0.03167989f, -0.11788339f, 0.12956394f, 0.14150083f, 0.03137544f, -0.00989685f, -0.08111868f, 
    0.06360608f, 0.03904367f, -0.03201858f, 0.01781819f, -0.12289111f, -0.17137882f, 0.16004488f, 0.07310977f, 
    -0.05194172f, -0.02553705f, -0.01775890f, -0.01765758f, 0.01085909f, 0.04018359f, 0.06531998f, -0.09504566f, 
    -0.04368169f, 0.04255196f, 0.09092019f, 0.16988763f, -0.15462315f, -0.01705280f, -0.06170940f, -0.12248661f, 
    -0.00264280f, -0.03086925f, -0.11926707f, 0.02879697f, 0.03099816f, -0.02077523f, 0.01985571f, 0.09504274f, 
    -0.02473290f, -0.12407710f, -0.04905483f, -0.12760761f, -0.01565642f, -0.03148704f, -0.19116516f, 0.00779792f, 
    0.09158704f, -0.02444559f, -0.11451273f, 0.06034042f, 0.03152302f, -0.02664061f, 0.10698339f, -0.00132764f, 
    0.06841958f, 0.03886988f, 0.00763424f, -0.12776330f, -0.11892365f, 0.21245624f, -0.09618873f, 0.00199659f, 
    -0.03020698f, -0.05029891f, -0.03388797f, -0.04223312f, 0.09237275f, -0.01067711f, -0.00053475f, 0.05703693f, 
    0.11696307f, -0.20314766f, 0.07110477f, -0.01955124f, 0.01333256f, -0.14395815f, -0.01256493f, -0.01098650f, 
    -0.01920016f, 0.04820704f, 0.02681711f, -0.02450952f, 0.06565871f, -0.23725013f, -0.02345877f, -0.14772412f, 
    0.01611531f, -0.17654811f, -0.26290065f, -0.02135800f, 0.09076386f, -0.02065508f, 0.07023778f, -0.18482819f, 
    -0.21055689f, -0.25821725f, 0.15192488f, 0.26731172f, 0.05372354f, -0.05311387f, -0.03420105f, 0.06063057f, 
    0.14500614f, 0.03394526f, 0.04494835f, 0.00738980f, -0.10765190f, -0.16307953f, 0.17087758f, -0.06806401f, 
    0.05431188f, -0.06155130f, 0.02066170f, -0.26371965f, -0.03030378f, -0.01610854f, -0.00602762f, 0.05299211f, 
    0.18579215f, 0.16140850f, 0.03559487f, 0.04905713f, 0.02280472f, -0.05142529f, -0.04892168f, 0.10322168f, 
    -0.07088090f, -0.09135330f, 0.13842405f, 0.01048176f, 0.20208688f, -0.04445155f, 0.27471778f, -0.00619824f, 
    0.00991076f, 0.10008848f, 0.03872842f, -0.06563701f, 0.01033526f, 0.07556725f, 0.01185164f, -0.10995798f, 
    0.00825269f, 0.13973835f, 0.21333255f, 0.03892734f, 0.01879046f, 0.12636036f, 0.00697066f, 0.00348378f, 
    -0.00806490f, 0.01939702f, -0.05138195f, -0.00146171f, 0.01598777f, 0.25127846f, 0.04761377f, 0.08542293f, 
    0.00463144f, 0.00873311f, -0.06551141f, 0.06063376f, 0.10160951f, 0.03513247f, 0.06667372f, 0.05769963f, 
    0.08904005f, -0.18731302f, -0.05460185f, -0.09075201f, 0.06690457f, -0.09234352f, 0.11588924f, -0.04191177f, 
    -0.04885123f, 0.07993574f, 0.08295175f, -0.08001743f, 0.12613259f, -0.19651888f, 0.07718606f, 0.13459358f, 
    -0.13397303f, -0.09458622f, 0.08551904f, 0.10703184f, -0.00465750f, 0.01822186f, -0.01075397f, -0.04078376f, 
    0.25821593f, 0.24461809f, -0.02019163f, -0.05809558f, -0.02146420f, -0.17982668f, -0.04612880f, -0.07462040f, 
    0.01559601f, -0.02327718f, 0.04238440f, -0.05360930f, 0.12675817f, -0.23539919f, 0.01986058f, -0.30990469f, 
    -0.08182112f, 0.03089871f, -0.01751351f, 0.13689259f, -0.04553140f, 0.02031719f, 0.00547888f, 0.05477382f, 
    -0.03982800f, 0.02497571f, -0.17562684f, -0.10114589f, 0.09607885f, 0.06864923f, -0.14469616f, -0.01356552f, 
    -0.05009656f, -0.03267774f, 0.02699656f, -0.01809562f, -0.22609600f, 0.01278446f, 0.17367280f, 0.02180573f, 
    -0.00696938f, 0.02778355f, 0.06148626f, 0.11934932f, 0.03742083f, -0.07089063f, -0.05192907f, 0.01396270f, 
    -0.14133175f, 0.12915251f, 0.30259976f, -0.03881839f, 0.09888825f, 0.09395175f, 0.02038074f, -0.08451162f, 
    -0.00630830f, -0.01739369f, -0.04038931f, -0.06239466f, -0.14089647f, -0.20297799f, -0.08270958f, -0.04642581f, 
    0.04607599f, 0.10603780f, -0.03580889f, -0.00903990f, -0.10090602f, -0.03920832f, -0.12587155f, -0.08699553f, 
    -0.12540938f, 0.17604819f, -0.02439435f, -0.28821740f, 0.03497224f, 0.01659171f, -0.09989820f, 0.00268251f, 
    -0.00193679f, -0.13759105f, 0.22041188f, 0.02079117f, -0.33892149f, 0.05741766f, 0.02964579f, -0.22523873f, 
    -0.03372152f, 0.05805676f, 0.02091701f, 0.00812919f, -0.10876991f, -0.05551038f, -0.02820593f, -0.06996314f, 
    0.30264577f, 0.02816600f, -0.18364584f, -0.10237247f, 0.01059262f, 0.00222646f, 0.01552191f, -0.09593003f, 
    -0.12527880f, -0.04524274f, -0.10803448f, 0.02311251f, -0.10812003f, 0.01418934f, -0.05173787f, -0.01235664f, 
    0.04135132f, 0.07574585f, 0.00973169f, -0.06215744f, -0.09307849f, 0.09522633f, -0.03117250f, 0.10576827f, 
    -0.09420670f, -0.00388338f, 0.05025386f, -0.06609960f, 0.06430128f, -0.07612933f, -0.00899844f, -0.06401862f, 
    -0.02233989f, -0.09389019f, -0.02276984f, 0.05836605f, 0.26435959f, 0.23777895f, -0.02885076f, 0.05044059f, 
    -0.07617604f, 0.04598726f, 0.07620380f, 0.05688022f, 0.00320827f, 0.04096530f, 0.11355221f, -0.10504838f, 
    0.22484057f, -0.23054150f, 0.04424093f, 0.04886049f, 0.07369757f, 0.13834882f, 0.00224911f, -0.08453321f, 
    -0.09665643f, -0.05834230f, 0.01730535f, -0.17090896f, 0.22382206f, 0.04167658f, 0.25255328f, -0.01725003f, 
    0.09009155f, 0.01931870f, -0.00547659f, -0.08024117f, -0.04446561f, -0.02223543f, -0.03707577f, -0.00519219f, 
    0.03653932f, 0.11111048f, -0.15510063f, -0.19353466f, -0.03050196f, 0.07785897f, -0.02487867f, 0.04316955f, 
    -0.07815221f, -0.02280723f, 0.06673840f, 0.03262140f, -0.02595302f, 0.06496618f, -0.19955994f, -0.20236953f, 
    0.07302333f, -0.03030262f, -0.00796257f, -0.10244887f, 0.04871962f, 0.10628583f, -0.20160916f, 0.02157281f, 
    0.23508368f, 0.05076072f, 0.15001011f, -0.11807441f, -0.01641111f, 0.13966970f, 0.04329365f, -0.05100438f, 
    -0.12655537f, -0.09014346f, -0.07443327f, -0.06279972f, -0.08996472f, 0.00970094f, 0.13807756f, 0.09273405f, 
    0.01758052f, 0.03266460f, 0.06925350f, 0.04681367f, -0.07744385f, 0.01138412f, -0.05960628f, -0.21682271f, 
    0.45077607f, -0.43717048f, 0.16160065f, 0.00126253f, 0.09647319f, -0.04779132f, -0.05200397f, -0.00048033f, 
    -0.08378899f, -0.00001792f, -0.03925118f, 0.06215268f, -0.24862604f, 0.25426096f, -0.26428810f, -0.13198212f, 
    0.11803113f, -0.03886901f, 0.10637849f, -0.04321474f, -0.04726980f, 0.07939667f, -0.05387798f, 0.03665078f, 
    -0.36151549f, -0.19657014f, -0.04227481f, 0.22112426f, 0.07647373f, 0.09162115f, -0.06371804f, -0.03641968f, 
    -0.13708727f, -0.04899308f, 0.04629742f, 0.02743554f, 0.38488856f, -0.07644437f, 0.05218919f, -0.06665922f, 
    0.04997032f, 0.14288969f, 0.19039974f, 0.02040971f, -0.04148097f, 0.04196776f, 0.01524344f, 0.09257355f, 
    0.11817387f, 0.07547568f, -0.15992640f, 0.32517287f, -0.10713186f, -0.03769327f, 0.07468676f, -0.04061254f, 
    0.02497395f, -0.07801673f, -0.19901472f, 0.04726109f, 0.09349620f, -0.20641115f, -0.03285598f, 0.06050678f, 
    -0.05211894f, -0.02504976f, 0.05663149f, -0.12367757f, 0.06823042f, 0.12380974f, -0.07035260f, -0.01359053f, 
    0.01166469f, 0.01919373f, -0.05834775f, -0.03645799f, -0.05551909f, 0.04026530f, -0.06395722f, 0.11549658f, 
    0.02747625f, 0.00614816f, 0.05791711f, -0.11625746f, -0.23667799f, -0.00721068f, 0.05995582f, -0.27272204f, 
    -0.03079998f, -0.04924539f, 0.05285465f, -0.05021802f, -0.00934440f, -0.01684614f, -0.15479682f, -0.05693716f, 
    -0.13240072f, 0.11042931f, -0.20276986f, 0.22113840f, 0.04491458f, -0.03863093f, 0.00523022f, -0.02471525f, 
    -0.01605599f, 0.10096553f, 0.03548218f, -0.04026968f, -0.30281565f, 0.30277196f, -0.16081637f, -0.08749041f, 
    0.05712411f, -0.00260914f, -0.02641271f, -0.11342818f, -0.03387627f, -0.00153137f, 0.04517881f, 0.06221808f, 
    -0.15627302f, -0.03305559f, 0.14663953f, -0.14513975f, -0.00937679f, -0.02183310f, 0.02011634f, -0.02761868f, 
    0.08290608f, -0.04215388f, -0.05916038f, 0.00916311f, -0.04148144f, -0.06329449f, -0.00578915f, -0.03112478f, 
    0.15771782f, 0.03202363f, -0.00555385f, -0.04590221f, 0.04676770f, -0.00240492f, -0.06999952f, 0.05442015f, 
    -0.04553048f, -0.14672466f, 0.01569433f, -0.00645563f, 0.01864577f, -0.04161654f, -0.08775001f, 0.01362003f, 
    0.00341440f, 0.04479598f, 0.02262504f, -0.03093393f, -0.05622294f, -0.33269912f, 0.20496865f, -0.04092393f, 
    0.01025125f, 0.00879434f, -0.03742856f, 0.19905463f, 0.05766639f, 0.03779024f, 0.03342956f, -0.09639741f, 
    -0.07644560f, 0.01383229f, 0.13449889f, -0.08665390f, -0.10759179f, -0.01711977f, -0.00173258f, 0.01176529f, 
    0.01869193f, 0.03172873f, 0.03460908f, 0.06441772f, -0.04127747f, -0.15347378f, -0.15006085f, -0.00086103f, 
    -0.05482886f, 0.09926153f, 0.05115523f, -0.06097639f, -0.03434833f, 0.10479692f, -0.02389953f, 0.04665727f, 
    -0.18758731f, 0.07186797f, 0.02274407f, 0.11254452f, 0.07895947f, 0.00823410f, 0.02544163f, 0.07907436f, 
    0.08963864f, -0.00255952f, -0.10420834f, -0.02974761f, -0.04912160f, -0.06879768f, 0.07483625f, 0.14800787f, 
    0.06052378f, 0.00215370f, 0.02124295f, -0.04540450f, 0.00523119f, 0.08064120f, -0.11054838f, 0.04954637f, 
    -0.38674647f, 0.37501210f, -0.22085176f, 0.13626933f, 0.06814802f, -0.04182207f, 0.02181296f, 0.07702796f, 
    0.01105973f, -0.00149598f, 0.05932416f, 0.09785360f, -0.12352759f, -0.29559031f, -0.05511686f, 0.04371532f, 
    -0.01113652f, 0.00230394f, 0.03644434f, -0.11844518f, -0.00228340f, 0.08076198f, 0.02325805f, 0.05579422f, 
    -0.00736894f, 0.06461206f, -0.15947326f, -0.09034102f, 0.01336063f, -0.05480495f, 0.00969312f, 0.03471146f, 
    0.17667429f, 0.04012706f, -0.03211085f, -0.06204327f, -0.14199884f, 0.00653388f, 0.02625579f, -0.18039060f, 
    -0.04355098f, -0.03231459f, -0.02386188f, 0.04899143f, -0.01550546f, 0.02514426f, -0.03822758f, -0.03387357f, 
    -0.14856239f, -0.06537519f, 0.08859676f, 0.05044191f, 0.07024240f, -0.05787622f, -0.14403144f, -0.00934444f, 
    -0.13626166f, 0.08015753f, -0.06362890f, 0.16570598f, 0.39010936f, 0.12181440f, -0.27256557f, -0.16474321f, 
    0.17425807f, -0.12263154f, 0.17241921f, -0.01082346f, -0.14428069f, -0.08793873f, -0.06263799f, 0.01379640f, 
    -0.04867925f, 0.22036359f, 0.15902102f, 0.16522574f, 0.04771605f, 0.06975137f, -0.01488980f, 0.02564008f, 
    0.03158053f, 0.06190610f, -0.06520414f, -0.01268987f, -0.00530866f, -0.03985557f, -0.15518114f, 0.07264074f, 
    0.04799306f, -0.03086373f, -0.06558581f, 0.06865956f, 0.06798781f, -0.03621833f, -0.00031450f, -0.14089754f, 
    -0.28163910f, 0.14446720f, -0.09966168f, -0.35384953f, 0.10547768f, -0.09606981f, -0.03882378f, 0.16912413f, 
    -0.02654872f, 0.11199789f, 0.01620844f, -0.04637421f, -0.29257870f, -0.41164464f, 0.06444229f, -0.14490148f, 
    0.08415466f, -0.00128030f, -0.08573388f, 0.03174553f, -0.00455783f, 0.03549455f, -0.06706870f, 0.03859349f, 
    -0.29178360f, 0.04074623f, -0.23292617f, 0.02053691f, -0.05630524f, 0.05116347f, 0.05542916f, 0.07311320f, 
    -0.03395728f, 0.04673982f, 0.05979524f, 0.03707502f, -0.30937034f, 0.29236230f, 0.12680675f, -0.13839309f, 
    0.02441693f, 0.06274567f, -0.07641039f, -0.08859616f, 0.02408925f, -0.04664868f, 0.02933949f, -0.00774712f, 
    -0.06368571f, -0.09792428f, -0.08592822f, -0.04032988f, -0.01906287f, 0.00368068f, 0.01429963f, -0.16171084f, 
    -0.02960881f, 0.05989485f, -0.03890352f, -0.02787301f, -0.22689012f, -0.15889975f, -0.03016370f, -0.10061309f, 
    0.02106437f, -0.10695770f, 0.04563694f, -0.01796667f, -0.01285308f, -0.02874056f, -0.00145971f, 0.08613769f, 
    0.03669617f, -0.46332449f, 0.01082176f, 0.00910085f, -0.01238082f, -0.01886778f, -0.01627318f, 0.07524946f, 
    -0.11331049f, 0.04376872f, -0.01467913f, -0.00201684f, -0.12678954f, -0.15416078f, -0.05874496f, 0.00091977f, 
    0.01214946f, -0.05602365f, 0.01210597f, -0.03863129f, 0.14995220f, 0.04366350f, 0.13734286f, 0.09886976f, 
    -0.05797799f, 0.07467254f, 0.04719827f, -0.10097211f, 0.01052660f, 0.02409447f, 0.02045008f, -0.06447881f, 
    -0.01403035f, -0.12453693f, 0.03472480f, 0.06924213f, -0.45400369f, -0.00192784f, -0.10929805f, 0.03651967f, 
    0.07936511f, 0.00251066f, 0.03160264f, -0.03536307f, -0.06607840f, 0.03997042f, 0.09239481f, 0.09272680f, 
    0.21887264f, 0.12857218f, -0.02328283f, 0.21488307f, -0.08047681f, -0.04190109f, -0.04206441f, 0.08172888f, 
    0.14234602f, 0.03373200f, -0.05121900f, -0.00451559f, -0.38207746f, -0.16190310f, 0.13249105f, -0.02277480f, 
    -0.03864288f, 0.04740975f, 0.12604891f, -0.13632704f, -0.13709271f, 0.01209474f, -0.17731249f, 0.09343182f, 
    -0.13685384f, 0.08246791f, -0.00485563f, -0.15841497f, -0.07153966f, -0.05902509f, 0.10982264f, -0.18716086f, 
    -0.07710344f, -0.04898143f, -0.00855150f, -0.03368969f, 0.43829432f, -0.05174088f, -0.20028372f, 0.20793346f, 
    0.00589735f, -0.04574560f, 0.00148162f, 0.16229668f, 0.05343254f, 0.06096601f, 0.11450940f, 0.09481199f, 
    -0.01205294f, -0.08332125f, 0.07991556f, -0.12274384f, -0.06782901f, -0.02436562f, 0.08820419f, -0.16117159f, 
    -0.05559969f, 0.00966158f, -0.08870808f, -0.04408456f, -0.36800820f, 0.01808917f, 0.05979201f, -0.00489246f, 
    0.15359361f, -0.06118733f, -0.11538269f, -0.11787639f, 0.00120720f, 0.00973658f, -0.07379050f, 0.02568945f, 
    -0.41326162f, -0.16549067f, -0.00033240f, -0.00447412f, 0.21881776f, -0.01094165f, -0.07043243f, 0.03818515f, 
    0.02185509f, 0.12626424f, 0.13061488f, 0.10901756f, -0.01699424f, 0.07645698f, -0.00803819f, -0.10799734f, 
    -0.04851619f, 0.10044122f, 0.09152442f, -0.11312671f, 0.01400038f, -0.17464161f, -0.11765107f, 0.05973598f, 
    0.18522544f, -0.01015511f, 0.00071589f, -0.08876766f, -0.15761319f, 0.00942416f, -0.08595418f, -0.00346826f, 
    0.07335339f, -0.04028742f, -0.16419299f, -0.07931153f, -0.01840866f, 0.06566738f, 0.00161332f, -0.00273378f, 
    -0.00417854f, -0.02380336f, -0.02438019f, -0.01661009f, 0.06378505f, -0.10926386f, -0.03175826f, -0.06154635f, 
    -0.00150551f, -0.06999917f, -0.00114898f, -0.07529283f, 0.10061151f, 0.06051457f, -0.02624265f, 0.08094592f, 
    0.15544647f, 0.11335044f, 0.04198866f, 0.02245452f, -0.07565982f, 0.05704384f, -0.15341274f, -0.16660704f, 
    -0.04828641f, -0.07234485f, -0.02469308f, 0.06874850f, 0.01904162f, 0.05768618f, 0.11798435f, -0.09439972f, 
    -0.47553700f, -0.29000992f, -0.13400687f, -0.25540170f, 0.09211625f, -0.01666043f, -0.03198661f, 0.06373796f, 
    0.05317890f, 0.05456962f, -0.03352971f, 0.09000783f, 0.11707398f, 0.04110337f, 0.02521631f, -0.07609583f, 
    -0.06567599f, 0.10018352f, -0.04524978f, 0.00908744f, -0.06510424f, -0.01936755f, -0.06218344f, -0.09769930f, 
    -0.15689865f, -0.21343398f, -0.03773561f, -0.00736321f, 0.02358401f, -0.00189485f, -0.02063759f, -0.06011225f, 
    0.00263424f, -0.02076420f, 0.07898492f, 0.08528104f, 0.25003058f, 0.11371575f, -0.11124744f, -0.13019307f, 
    0.03132175f, 0.07843971f, 0.04406386f, -0.02200378f, 0.01928022f, -0.03068101f, -0.07553967f, -0.02033648f, 
    -0.33819419f, -0.01992656f, -0.07289461f, -0.18526144f, 0.15150994f, 0.01458981f, 0.03977779f, 0.02177599f, 
    0.08240069f, -0.03238840f, 0.06848023f, 0.01762490f, -0.22983703f, -0.06636240f, 0.06730155f, 0.04447724f, 
    0.07885594f, -0.11285300f, 0.02964033f, -0.01945429f, 0.02180900f, 0.09040690f, -0.01846641f, 0.08619953f, 
    0.14143401f, -0.09334937f, 0.07419392f, 0.19498394f, -0.02097504f, -0.16097146f, 0.04917467f, 0.02812262f, 
    -0.03970911f, 0.06342576f, -0.00162395f, 0.07654249f, -0.10534319f, -0.02029491f, 0.09308504f, 0.07044502f, 
    -0.03673083f, 0.10471820f, -0.03372472f, 0.00110274f, 0.05595598f, 0.00476433f, -0.00124502f, -0.09588973f, 
    0.07499477f, 0.02266630f, -0.01073167f, 0.06215408f, 0.00749644f, 0.13320658f, -0.05209923f, 0.00658979f, 
    0.00618788f, 0.10689791f, 0.01630936f, 0.06884948f, -0.14193471f, -0.30263701f, -0.06706664f, -0.03837039f, 
    0.04770456f, -0.04925422f, 0.01769017f, -0.06830808f, -0.00211753f, -0.07393360f, -0.10317671f, 0.09465799f, 
    -0.38626558f, -0.06167959f, -0.06485663f, -0.10380252f, -0.01232439f, -0.05030246f, -0.03856983f, 0.02721551f, 
    -0.10652095f, 0.13143319f, 0.07394921f, 0.10095897f, -0.34826872f, 0.11536446f, 0.11246110f, 0.13195805f, 
    0.10482379f, 0.03189493f, -0.03508811f, -0.01110797f, -0.05133312f, -0.11618543f, 0.00960883f, 0.19919728f, 
    -0.01718656f, 0.08362869f, -0.01292228f, -0.04353990f, 0.14514308f, 0.00460514f, -0.00105326f, 0.10924850f, 
    -0.00753574f, 0.06338572f, -0.06432414f, 0.06303261f, 0.15396589f, 0.11415008f, 0.01133267f, -0.08599881f, 
    -0.00336655f, 0.05776208f, -0.00207573f, 0.06978489f, 0.04615725f, 0.12596913f, 0.11667649f, 0.08618473f, 
    -0.42597461f, -0.15604147f, -0.03068689f, -0.05151432f, 0.07542244f, -0.00949027f, 0.02280718f, -0.08143549f, 
    0.08195186f, 0.07473859f, -0.07229399f, 0.10192286f, 0.14990886f, 0.18669727f, -0.00018196f, 0.02819338f, 
    0.10341009f, -0.05432079f, -0.04636377f, -0.07524466f, -0.05249938f, 0.03810626f, 0.16606098f, 0.08171526f, 
    -0.00014581f, 0.03867263f, -0.07721420f, 0.01288112f, -0.09195182f, 0.07866356f, 0.07121278f, -0.01235457f, 
    0.07106852f, 0.18031503f, 0.04782457f, -0.00385567f, 0.02165042f, 0.07362652f, -0.09534125f, -0.17556114f, 
    0.00839105f, -0.03230083f, -0.05444317f, 0.03338325f, -0.05540928f, -0.10024379f, 0.15307450f, 0.03675978f, 
    0.09482746f, -0.04967028f, -0.03339293f, -0.04077597f, -0.05463445f, 0.00847043f, 0.02129124f, -0.06320046f, 
    0.02770830f, -0.05827986f, 0.02291567f, -0.04362757f, -0.04033224f, -0.16646771f, -0.01724187f, 0.06908343f, 
    0.04771838f, 0.04930496f, 0.06877610f, 0.00905993f, 0.06561139f, 0.01049546f, -0.02531111f, -0.04201155f, 
    0.17812650f, -0.05728368f, -0.06821697f, 0.05040271f, 0.06546110f, -0.04099107f, 0.04562563f, -0.00955346f, 
    -0.04292427f, 0.03291016f, 0.08805914f, -0.00885454f, 0.07768545f, 0.03115545f, -0.03736300f, 0.05795093f, 
    0.02359444f, 0.02114083f, 0.02548465f, 0.06846384f, -0.00906184f, 0.01674260f, 0.03934625f, 0.07553134f, 
    0.30455875f, 0.11508242f, -0.13336073f, -0.04254353f, -0.08201480f, -0.01304462f, 0.06341903f, 0.04331973f, 
    0.02680966f, -0.05344339f, 0.05411435f, 0.14525686f, 0.02926248f, -0.09725703f, 0.01829307f, 0.09503788f, 
    0.11055849f, 0.01471958f, -0.06671818f, 0.22497614f, -0.06468954f, 0.14909369f, 0.11843301f, 0.12807162f, 
    0.19488180f, 0.16272441f, -0.01540093f, -0.01001280f, 0.04031873f, -0.03599337f, -0.00003289f, 0.08836790f, 
    0.15067801f, -0.15504441f, -0.07374974f, -0.07087584f, -0.10524592f, -0.16652635f, -0.15060133f, -0.00088044f, 
    0.00529871f, 0.00642784f, -0.03851325f, 0.04365239f, 0.07035393f, 0.02873242f, 0.04560231f, 0.12196664f, 
    0.17984544f, 0.10901888f, 0.12469039f, -0.07650992f, 0.03481615f, 0.05401490f, 0.10944679f, 0.04880958f, 
    0.02832962f, 0.10716539f, 0.03840490f, 0.07063969f, 0.16528571f, 0.15140872f, -0.10548797f, -0.06460291f, 
    -0.13048597f, -0.02604020f, -0.03087130f, -0.01859552f, -0.03424064f, 0.04198337f, 0.03568597f, -0.07366490f, 
    -0.12198486f, 0.03111519f, -0.06297946f, -0.08989412f, -0.07126211f, -0.06151067f, -0.07493310f, 0.00597786f, 
    -0.00972076f, -0.06853873f, -0.03284733f, 0.07407286f, -0.27401397f, -0.09524306f, -0.15325728f, 0.04733836f, 
    0.04017034f, -0.12422758f, -0.04575062f, -0.09892938f, -0.04344866f, 0.00173777f, -0.11486610f, -0.02364097f, 
    -0.04174641f, 0.05590042f, -0.06934256f, 0.06432176f, 0.04713165f, -0.05669884f, -0.05104930f, 0.02816336f, 
    -0.01177472f, -0.05513155f, 0.16230276f, -0.06113247f, 0.18732461f, -0.05610821f, 0.10337115f, -0.01101391f, 
    0.00341801f, 0.08479314f, 0.04396768f, -0.00904143f, 0.00376686f, -0.17730667f, -0.20650351f, -0.14616001f, 
    -0.54033983f, -0.38891864f, 0.08123843f, -0.22747602f, 0.07629380f, -0.01517871f, -0.08458379f, -0.12797695f, 
    0.10601044f, 0.04357248f, -0.05486241f, 0.08541036f, 0.03003915f, 0.02418798f, -0.01373641f, -0.05996407f, 
    -0.01629754f, 0.08674505f, 0.00400578f, 0.11158659f, 0.04446242f, -0.00000172f, -0.00975778f, -0.01369031f, 
    0.10047086f, -0.05437494f, 0.00447512f, 0.15033017f, -0.03335392f, -0.18188144f, 0.12799673f, 0.03186384f, 
    0.04825498f, -0.02170092f, -0.02385118f, 0.01235796f, 0.22325717f, -0.11422238f, -0.11201095f, 0.07298369f, 
    -0.00761502f, -0.01015002f, -0.08739112f, 0.10928404f, -0.02193116f, 0.00347938f, -0.05536240f, 0.01120613f, 
    0.35943940f, 0.10413048f, 0.06909499f, -0.10083619f, 0.04512862f, 0.06707840f, 0.08132932f, 0.05411338f, 
    -0.08019131f, -0.05069287f, 0.03041110f, -0.06986777f, -0.40809143f, -0.24070343f, -0.13770141f, -0.21380734f, 
    0.00694815f, -0.14562537f, -0.13098474f, 0.02374508f, 0.02850901f, -0.06412449f, 0.05471369f, -0.05089941f, 
    0.16485935f, -0.02769574f, 0.00857708f, 0.14291486f, -0.04295303f, 0.05858351f, -0.03269760f, 0.08618692f, 
    0.08080534f, 0.13421769f, 0.02417018f, -0.02987581f, -0.33610240f, -0.05018385f, -0.01846178f, 0.00952263f, 
    -0.02398906f, 0.01235456f, -0.04859672f, 0.08387758f, -0.07531480f, 0.07065685f, 0.12280659f, 0.09135830f, 
    -0.24391751f, -0.10579820f, 0.10305294f, -0.01385192f, 0.00864418f, -0.08327836f, -0.07729690f, -0.07229202f, 
    0.05179918f, -0.17344828f, -0.02494481f, -0.02016358f, 0.26814443f, 0.03921015f, -0.04256071f, -0.03368732f, 
    0.00837435f, -0.04577493f, 0.12820274f, 0.01592501f, -0.00838551f, 0.09013380f, 0.06062738f, 0.14676191f, 
    -0.07870154f, -0.22397700f, -0.10365541f, -0.10227244f, -0.00501631f, -0.03447141f, -0.08375349f, -0.07924783f, 
    -0.03509812f, -0.14972191f, 0.12636285f, -0.09813402f, 0.06086330f, 0.06719902f, -0.05341921f, 0.02464367f, 
    -0.03032124f, -0.07533813f, -0.03969080f, 0.00232806f, 0.09346976f, 0.10731684f, -0.00522209f, 0.02089073f, 
    -0.00481121f, 0.07406494f, -0.09772287f, 0.02365698f, 0.04654611f, 0.10849950f, -0.00528131f, 0.06567717f, 
    -0.07352997f, -0.05601356f, -0.05298961f, 0.15815505f, -0.43451494f, -0.35435036f, -0.07125296f, -0.05903185f, 
    0.13943622f, 0.05618371f, 0.14011025f, -0.09724565f, 0.08977120f, 0.03345383f, 0.01271047f, 0.11461961f, 
    -0.10175072f, -0.20835367f, -0.18589753f, -0.27326405f, 0.00730074f, 0.01329759f, -0.02407533f, -0.01957847f, 
    -0.00064240f, -0.08215471f, -0.05152597f, -0.00827509f, 0.10644304f, 0.09719007f, -0.04871048f, 0.11303291f, 
    -0.13816850f, -0.05108425f, 0.06630151f, -0.07446603f, 0.04429355f, 0.10365301f, 0.05269017f, -0.00743956f, 
    0.19235626f, 0.03543933f, -0.09110133f, -0.07249810f, -0.06226202f, -0.08506859f, -0.01036693f, -0.01924765f, 
    -0.00093430f, 0.00223366f, -0.04165842f, 0.05034105f, -0.06060281f, -0.14049485f, -0.17130177f, 0.04476486f, 
    -0.00275392f, -0.08191333f, -0.09229369f, -0.06028927f, -0.08950154f, -0.15778761f, -0.21316326f, -0.02696536f, 
    -0.27673066f, -0.30804235f, -0.01896494f, 0.04001813f, -0.00401780f, 0.04293110f, 0.11819915f, -0.02027782f, 
    0.18732454f, 0.15781808f, 0.02190405f, 0.01535458f, -0.02927676f, -0.34781653f, -0.14594819f, 0.07851904f, 
    -0.00874814f, -0.03969651f, 0.03714987f, 0.05979848f, 0.02068488f, -0.05299653f, 0.02809166f, 0.00828729f, 
    -0.26358855f, -0.00466155f, -0.08695463f, 0.05871914f, 0.09087643f, -0.06870685f, 0.01366943f, -0.02599997f, 
    -0.09186938f, 0.02507103f, 0.06486678f, -0.00333439f, -0.22802119f, -0.16173089f, 0.08201402f, 0.07656038f, 
    0.04517914f, -0.08341609f, -0.08259756f, -0.00547699f, 0.04758922f, -0.09823439f, 0.00562013f, 0.04223044f, 
    -0.18974762f, -0.08771750f, 0.08671815f, -0.09900194f, 0.09026723f, -0.10021560f, 0.06560348f, 0.15400019f, 
    0.01840043f, 0.10584782f, -0.00625263f, 0.05120321f, 0.09537046f, 0.04323857f, -0.06012483f, -0.06997972f, 
    -0.03698963f, 0.04946467f, -0.06591217f, 0.01281589f, 0.00443187f, -0.07261357f, 0.07233288f, -0.00694645f, 
    0.26010019f, 0.09233383f, -0.13700648f, -0.12922931f, 0.05194563f, -0.15630558f, -0.13108493f, 0.03205446f, 
    -0.03861289f, -0.05282025f, 0.08496312f, 0.01124189f, 0.36225435f, 0.03358068f, 0.02015049f, -0.09052079f, 
    -0.01442549f, -0.03608087f, -0.05630554f, 0.03072830f, 0.07957331f, 0.01202918f, -0.02268388f, -0.04628357f, 
    0.38131535f, 0.05552762f, -0.10384518f, -0.03603003f, 0.12924780f, 0.01458058f, -0.16693443f, -0.00001819f, 
    0.02843863f, -0.00084635f, -0.01099369f, -0.07203124f, -0.18941987f, 0.06736553f, 0.04991951f, 0.07035118f, 
    0.09309061f, 0.07533313f, -0.06993019f, -0.02729642f, 0.01376919f, 0.07067835f, -0.08271956f, -0.12205166f, 
    -0.22876658f, 0.15020193f, -0.06893054f, 0.15718903f, -0.06351335f, 0.01048660f, 0.07054686f, 0.04474564f, 
    -0.00038598f, -0.02653044f, 0.03027036f, -0.02743630f, -0.31828493f, 0.22921424f, 0.02140390f, -0.15689375f, 
    -0.04435746f, 0.12779051f, 0.04981573f, 0.00603276f, 0.09559689f, 0.00145113f, 0.07797261f, -0.02217515f, 
    0.09041125f, -0.16864704f, -0.05015739f, 0.08168509f, 0.18104126f, -0.12266718f, -0.02608210f, 0.05562975f, 
    -0.02967111f, 0.04110060f, -0.14077172f, -0.03854050f, -0.14682803f, 0.08920387f, -0.09121974f, 0.33688730f, 
    -0.14287050f, 0.02319157f, -0.05163782f, -0.07329541f, -0.07672904f, -0.08709422f, 0.03612285f, -0.06312604f, 
    -0.02916690f, 0.01707752f, -0.01170200f, -0.15750875f, 0.02839557f, 0.00932025f, 0.01942164f, 0.10439332f, 
    -0.00603726f, -0.07023807f, 0.03710279f, 0.00103005f, 0.03201432f, 0.00881136f, -0.07599165f, 0.06384568f, 
    -0.04928650f, -0.01615074f, -0.02569104f, -0.14993845f, -0.03189442f, 0.05971866f, 0.02154151f, -0.10704762f, 
    0.13432828f, -0.12829871f, -0.09410959f, 0.02061867f, 0.15512453f, -0.03636627f, -0.04803729f, -0.06363608f, 
    0.01183357f, 0.01222998f, -0.01059738f, 0.00812073f, 0.05848736f, 0.14949811f, -0.15565668f, -0.15288138f, 
    -0.11392891f, -0.00180651f, -0.01166295f, -0.03391862f, 0.05913623f, -0.00255222f, -0.10077972f, -0.04865520f, 
    0.11482993f, -0.11224440f, -0.02121137f, 0.33432245f, -0.07451724f, 0.01719288f, 0.11315213f, 0.04041806f, 
    0.10390716f, 0.00595313f, 0.07466907f, 0.06312072f, 0.13226895f, -0.13502976f, -0.06079773f, -0.00192515f, 
    0.05916560f, -0.05279064f, -0.11721268f, -0.11573689f, -0.10480410f, 0.00086626f, 0.03594866f, 0.00324672f, 
    0.03971918f, -0.03130485f, 0.13277790f, -0.02549827f, -0.04044436f, -0.00609367f, -0.03826582f, -0.00196900f, 
    -0.07474051f, -0.05854892f, 0.05834853f, 0.13949348f, -0.14966419f, 0.27432796f, -0.00233351f, -0.01090388f, 
    0.04542564f, -0.14913909f, 0.04623239f, 0.02405656f, 0.12652598f, -0.00507266f, 0.04978124f, 0.01809728f, 
    0.09365325f, 0.08083232f, -0.00068529f, 0.09642123f, -0.09882930f, -0.00169516f, -0.02168124f, 0.00196560f, 
    0.02912107f, -0.07557150f, -0.08580028f, -0.14376552f, -0.14716753f, -0.19770057f, -0.05233352f, -0.13263467f, 
    0.10371798f, 0.02959885f, -0.03917090f, 0.18254007f, -0.02206329f, -0.05053880f, 0.07383049f, 0.06175080f, 
    0.27557302f, 0.19484615f, -0.14966932f, 0.07923558f, -0.04247835f, 0.02434080f, 0.06060251f, 0.00652313f, 
    0.02690716f, 0.02618100f, -0.10253980f, -0.03736578f, 0.42025787f, 0.17817123f, 0.03759530f, -0.17531508f, 
    0.02661981f, -0.04984791f, -0.00468773f, 0.06734469f, 0.07667182f, 0.08483277f, 0.04151037f, 0.03455440f, 
    0.30553922f, -0.01665451f, -0.13904944f, 0.20978096f, -0.18339440f, -0.04407202f, 0.00839397f, -0.01183382f, 
    0.07973929f, 0.00187767f, 0.06702271f, -0.03940124f, -0.01748491f, -0.11451390f, -0.02275845f, 0.23885722f, 
    -0.10332143f, -0.00889820f, -0.00435086f, 0.06346049f, -0.01266100f, -0.09411862f, -0.07184529f, -0.11452438f, 
    0.40477121f, 0.18925104f, -0.15612677f, -0.17968771f, 0.05093217f, 0.00407275f, -0.08142574f, 0.04665052f, 
    0.01894857f, 0.00126461f, 0.05506885f, -0.02564188f, 0.07067260f, 0.03562189f, -0.01716280f, -0.01687411f, 
    -0.05803962f, 0.04242890f, 0.00055955f, -0.04823194f, 0.06342675f, -0.09359688f, -0.11619759f, -0.13078651f, 
    -0.41619623f, 0.06594057f, 0.03173662f, 0.05424649f, -0.06807891f, 0.02611807f, -0.02652831f, 0.00701730f, 
    -0.07831045f, -0.05620654f, 0.06940334f, 0.02103755f, -0.07121260f, -0.31488094f, 0.00406983f, -0.20884477f, 
    0.00047743f, 0.02887425f, -0.04348792f, 0.01240420f, 0.01428941f, -0.04241012f, -0.08656976f, 0.04302315f, 
    0.14614546f, 0.00055034f, -0.03104983f, 0.07952946f, 0.02580871f, 0.04357377f, -0.01969566f, -0.11842808f, 
    -0.09193975f, -0.02026037f, -0.02671519f, 0.08416424f, -0.40362880f, -0.28808013f, 0.00074811f, -0.27898467f, 
    0.01344883f, -0.06933961f, 0.02840112f, 0.15380868f, -0.08092994f, -0.04853784f, -0.03867827f, -0.02003057f, 
    0.12315024f, -0.05064206f, 0.10156412f, 0.02073803f, -0.09309136f, 0.00060787f, -0.03893127f, 0.04684132f, 
    -0.06239356f, -0.17078042f, 0.08120118f, -0.06579634f, -0.05416653f, 0.18867403f, 0.01027690f, 0.11631157f, 
    -0.08785399f, 0.08473623f, -0.07076867f, 0.00550510f, 0.06556162f, -0.03873015f, 0.08032864f, -0.02738412f, 
    -0.13137877f, 0.06007019f, -0.08910760f, -0.02446916f, -0.00039735f, -0.01081344f, 0.10110993f, 0.06664167f, 
    -0.13035406f, 0.02298432f, 0.01724201f, -0.02643824f, -0.01897944f, 0.23407075f, -0.12478204f, -0.01922970f, 
    0.14552781f, 0.06397146f, 0.03776224f, -0.03298722f, 0.06751639f, 0.05095606f, -0.02853678f, -0.02556435f, 
    0.12098095f, -0.07366708f, 0.11014234f, 0.17855102f, 0.02469882f, 0.10446271f, 0.01987124f, 0.01636318f, 
    -0.03329172f, 0.02460355f, 0.03471792f, 0.05865861f, -0.23453170f, -0.07770919f, -0.12232833f, -0.14774424f, 
    0.04408240f, 0.00083371f, 0.02855199f, 0.06559450f, 0.04468078f, 0.01127113f, -0.01453636f, -0.05335634f, 
    0.17008124f, 0.10401530f, -0.19945541f, 0.00971249f, 0.13437226f, -0.02006877f, 0.03805266f, 0.02236581f, 
    0.00799907f, 0.01068079f, 0.01274018f, 0.03244967f, -0.06131933f, -0.32413059f, -0.02367846f, -0.02008128f, 
    -0.11493341f, 0.06656422f, 0.13229197f, 0.02716380f, -0.15936625f, 0.04022058f, 0.05390722f, -0.15364736f, 
    -0.50194257f, -0.13226667f, -0.03570458f, -0.09766941f, 0.05179334f, 0.24045132f, -0.09715608f, 0.05040894f, 
    -0.05956374f, 0.02309174f, -0.07565184f, -0.16082764f, 0.05441380f, -0.06566717f, 0.00156230f, 0.17469935f, 
    0.00045927f, -0.00926400f, 0.03746654f, -0.01814588f, -0.01135560f, 0.07169695f, 0.01203857f, -0.00929301f, 
    0.05150937f, -0.08207960f, -0.08770718f, 0.01019220f, 0.01726794f, 0.03740167f, -0.16006188f, -0.05017156f, 
    0.09181802f, 0.00241616f, -0.09002139f, 0.05250480f, -0.08935586f, -0.06401152f, -0.32942650f, 0.02255894f, 
    0.05509343f, -0.08421133f, -0.03722668f, 0.02652654f, 0.10436966f, 0.02889194f, -0.04225884f, 0.00406808f, 
    0.16910739f, -0.19017476f, -0.03862932f, -0.21573988f, 0.06975912f, 0.03401906f, -0.11816846f, 0.00552912f, 
    -0.02902122f, 0.01506920f, -0.00745545f, 0.00424693f, -0.27444708f, 0.14589477f, 0.06005748f, -0.03829165f, 
    0.02405589f, -0.07707439f, -0.02647203f, -0.05386076f, 0.05699085f, 0.05867263f, 0.09041572f, -0.09125101f, 
    0.03233822f, -0.21446219f, 0.10428778f, 0.18558201f, -0.00121034f, 0.04428211f, 0.07349555f, -0.02237018f, 
    0.04304222f, 0.01202365f, 0.07091332f, 0.10695402f, -0.10662009f, 0.11751461f, 0.02996975f, 0.05282288f, 
    0.04381738f, -0.01550576f, 0.03862679f, 0.06019320f, -0.00825855f, -0.01035102f, 0.05606641f, 0.04156217f, 
    -0.17383099f, -0.00545391f, -0.27562749f, 0.14734232f, 0.04551638f, -0.01429892f, 0.06476779f, 0.06490135f, 
    0.00438143f, 0.07479978f, -0.03877214f, 0.03258338f, -0.08582985f, -0.18096398f, -0.11480423f, -0.11438915f, 
    -0.02737391f, 0.01881491f, -0.01114537f, 0.03736011f, -0.06602015f, -0.00187182f, -0.00873231f, -0.01162845f, 
    0.12215982f, 0.02655307f, 0.05038645f, 0.08461731f, -0.12927543f, -0.09159467f, -0.02787782f, -0.03042166f, 
    0.09300552f, -0.04814705f, -0.05121364f, -0.04793001f, 0.03230568f, -0.24998713f, 0.07376583f, -0.01553860f, 
    -0.04386244f, 0.03625374f, -0.10064988f, 0.04418463f, -0.06434852f, -0.01869604f, 0.03838569f, 0.00698669f, 
    -0.15400587f, -0.05141582f, -0.15194432f, 0.00460937f, 0.06789543f, 0.06323891f, 0.02395781f, -0.12634498f, 
    0.00724404f, -0.02058402f, -0.04079488f, 0.00177651f, -0.05439047f, 0.07406412f, -0.00440498f, 0.06057094f, 
    -0.07297160f, -0.04674559f, -0.03669441f, 0.08269636f, -0.10719913f, -0.04539230f, 0.05107478f, 0.00420131f, 
    0.20501009f, 0.01692717f, -0.09969524f, -0.16900483f, 0.06387235f, -0.08502281f, -0.02731094f, -0.02719441f, 
    0.06283675f, 0.13490508f, 0.00312655f, 0.05206553f, 0.01443618f, 0.13289614f, 0.03305205f, -0.09955502f, 
    -0.12782708f, -0.03762000f, 0.01520857f, -0.01883963f, -0.07976318f, 0.05641602f, -0.08037755f, -0.10679159f, 
    -0.36504593f, 0.08498961f, -0.07905146f, -0.13348000f, 0.13141163f, -0.09013044f, 0.02950620f, -0.08213160f, 
    0.01823771f, -0.02121322f, 0.02172702f, 0.01979881f, 0.30730930f, -0.07315350f, -0.08051699f, 0.09570216f, 
    0.11965967f, -0.04298345f, -0.02241328f, -0.04325260f, -0.00983885f, 0.04142056f, 0.09410037f, 0.00785929f, 
    -0.05913391f, 0.09264906f, -0.30457431f, -0.10789356f, 0.05369383f, -0.01026709f, 0.04943952f, -0.01647413f, 
    0.03800778f, 0.02234665f, 0.01398442f, -0.06504401f, 0.09574053f, -0.13403983f, -0.00209008f, 0.01002183f, 
    -0.05261218f, 0.04646759f, -0.04116211f, 0.11746474f, -0.01605760f, -0.05571511f, -0.04952703f, -0.04827194f, 
    -0.05007302f, 0.00972295f, -0.02390395f, -0.02416664f, -0.02066124f, -0.00925565f, 0.11136781f, -0.02320779f, 
    -0.02584596f, -0.04301722f, 0.03690299f, -0.13822065f, -0.08037003f, 0.09935070f, -0.02423754f, -0.31301370f, 
    -0.09651738f, -0.12181457f, -0.01923341f, 0.08633149f, -0.01959324f, 0.00794561f, 0.04455720f, 0.05165642f, 
    0.14540559f, 0.23694630f, -0.01306080f, 0.02641005f, 0.09750361f, 0.02168768f, -0.13034695f, -0.03086950f, 
    -0.03768734f, 0.00060596f, 0.05970404f, 0.08106694f, -0.33259934f, 0.15573649f, -0.17670931f, -0.01214737f, 
    0.17949073f, 0.03029306f, 0.06156720f, 0.00587930f, -0.03212774f, -0.00006587f, 0.07024947f, 0.06790827f, 
    -0.19720626f, 0.02770867f, 0.10035242f, -0.09931421f, -0.08953559f, 0.01496555f, -0.07845216f, -0.04154262f, 
    -0.06765886f, 0.01662502f, 0.00717816f, 0.00891456f, -0.01596406f, -0.01543484f, -0.06031967f, -0.22108603f, 
    -0.03206987f, 0.05726049f, 0.06811535f, -0.03530797f, -0.05175493f, 0.04898122f, 0.16109465f, 0.03773833f, 
    0.07240568f, -0.08029483f, 0.02711088f, -0.24045722f, -0.15608017f, 0.10626799f, -0.03850888f, -0.03835627f, 
    -0.03722478f, -0.15849766f, -0.07554353f, -0.02273906f, -0.30645043f, 0.11098952f, 0.15359929f, -0.08285712f, 
    -0.02166945f, -0.03785583f, -0.07132464f, -0.05972459f, 0.04077755f, 0.07512695f, 0.12589151f, 0.01242561f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03336648f, 0.01758630f, 0.00545912f, -0.02893959f, 0.03271261f, -0.02724645f, 0.00809273f, -0.04696295f, 
    -0.04511966f, -0.00415790f, 0.03606245f, 0.03119634f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
