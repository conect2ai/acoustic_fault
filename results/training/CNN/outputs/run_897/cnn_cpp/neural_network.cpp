#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.77182090f, 0.46377638f, -0.04111850f, 0.30711481f, 0.89347476f, 0.11741892f, -0.27730927f, -0.17772032f, 
    0.38613510f, 0.11666045f, -0.09667062f, 0.01064828f, 0.09765643f, -0.26058403f, 0.07880146f, -0.07548372f, 
    0.02557638f, 0.02447962f, 0.07774157f, 0.12365860f, 0.04052919f, -0.17745048f, -0.00268683f, -0.09307542f, 
    0.06520023f, 0.35402882f, 0.23451585f, 0.47056445f, 0.85412461f, 0.42393762f, -0.17239662f, 0.13064943f, 
    -0.09642640f, 0.23180592f, 0.16649927f, -0.36119473f, -0.19701816f, 0.08522423f, 0.24175824f, -0.05991300f, 
    -0.05784304f, -0.07621226f, 0.13052808f, -0.09522331f, -0.00627969f, 0.06674740f, 0.12090097f, -0.23024938f, 
    0.00543583f, -0.14687955f, -0.23972875f, -0.13378045f, -0.17979389f, -0.04914297f, -0.28186876f, -0.04120373f, 
    -0.45834979f, -0.33519074f, -0.26576263f, 0.25178015f, -0.48711583f, -0.22753257f, -0.14873059f, 0.24703339f, 
    -0.17207648f, -0.74126279f, -0.01275615f, -0.05081428f, -0.00921870f, -0.08033619f, 0.16547143f, -0.04699421f, 
    -0.03888884f, -0.10090929f, -0.05184654f, 0.42980364f, 0.05960521f, 0.57123804f, 0.57882911f, 0.73686701f, 
    0.09831940f, -0.18594487f, -0.15305145f, -0.20107064f, -0.51191944f, 0.25348774f, 0.22858980f, -0.01472513f, 
    0.36551291f, 0.12936603f, 0.05518754f, 0.01398207f, 0.15695655f, 0.28547981f, 0.24658322f, 0.00506200f, 
    0.28502950f, 0.01808922f, 0.00666252f, 0.09261078f, 0.38625041f, 0.25250548f, -0.50005203f, -0.26424617f, 
    -0.44819587f, 0.57681781f, -0.26926741f, -0.44412702f, -0.14052744f, -0.67608333f, -0.19950089f, 0.05166709f, 
    0.23255669f, 0.05127419f, -0.16555957f, -0.00817741f, 0.28797662f, -0.02474516f, 0.09944849f, 0.02111887f, 
    0.14616077f, -0.15129688f, -0.04249783f, 0.02757899f, -0.03308051f, -1.10712028f, 0.05979829f, -0.18766725f, 
    -0.34828347f, -0.24198540f, 0.05058260f, 0.65832973f, 0.17630397f, 0.01249540f, 0.48085326f, -0.11189491f, 
    -0.11041184f, 0.16405372f, -0.21654840f, 0.15702893f, 0.01570029f, 0.04828109f, 0.00734084f, 0.24299334f, 
    -0.02227253f, 0.03798027f, -0.12035662f, 0.09037673f, 0.09776252f, 0.09740008f, -0.28808460f, -0.55067253f, 
    -0.59863448f, -0.13977019f, -0.39153028f, 0.10097677f, 0.01600561f, 0.33000314f, 0.45150822f, -0.03216305f, 
    -0.24481055f, -0.09589693f, -0.26189131f, -0.16098194f, -0.07595467f, 0.07242394f, 0.12364209f, -0.35553762f, 
    -0.17735273f, 0.13623063f, 0.01147373f, 0.11137683f, 0.24020275f, -0.03622514f, 0.13450913f, 0.02446819f, 
    0.90540993f, -0.23821673f, 0.28631979f, 0.42076275f, 0.05404865f, -0.32708091f, 0.27240691f, -0.04276848f, 
    0.04089292f, 0.08945618f, -0.12632830f, 0.13187380f, 0.10216963f, 0.12363242f, -0.00129670f, -0.22084861f, 
    -0.33335143f, -0.35472727f, 0.01896985f, -0.42021188f, -0.14588390f, -0.06516802f, -0.08424176f, 0.10526049f, 
    0.05910415f, 0.25285104f, 0.64682651f, -0.45650691f, -0.22943011f, 0.07937749f, -0.28101563f, 0.34801060f, 
    0.17072351f, 0.27779016f, 0.46719024f, 0.34656954f, -0.10247505f, 0.12995309f, 0.12569296f, 0.14348452f, 
    0.24206293f, 0.01409111f, -0.00446921f, 0.25826141f, 0.11797691f, -0.02675935f, -0.18805867f, 0.20654605f, 
    0.06220503f, 0.28418815f, 0.88943046f, 0.74236822f, 0.22328928f, 0.11413666f, -0.77617222f, 0.55151647f, 
    -0.24308245f, -0.36529079f, 0.31710118f, 0.10819127f, 0.24304615f, -0.20329082f, -0.13801724f, 0.13235897f, 
    0.04329789f, -0.15811148f, 0.08257335f, -0.00479466f, -0.17359032f, 0.04278618f, 0.10226206f, 0.06549834f, 
    0.07343833f, -0.01231375f, 0.08554079f, -0.46953541f, -0.74000174f, -0.34910020f, -0.39261323f, 0.14795654f, 
    0.54941791f, 0.25169668f, 0.24461548f, 0.31300181f, -0.22548851f, -0.05906184f, -0.05266043f, -0.07926710f, 
    -0.13641365f, -0.40492657f, 0.12910032f, 0.12676667f, 0.25855607f, -0.22297326f, -0.01342549f, 0.00554078f, 
    -0.23943613f, -0.19736347f, 0.20090200f, -0.27339134f, -0.53558189f, 0.34596953f, 0.50297189f, -0.05613615f, 
    0.34805000f, 0.82901073f, -0.21350056f, 0.06940912f, 0.42004287f, 0.20952590f, 0.16351420f, -0.03007297f, 
    0.16190335f, -0.24068959f, -0.07081474f, -0.05561388f, -0.09265433f, -0.10857844f, -0.13202570f, -0.05485052f, 
    0.10951522f, -0.02340404f, 0.04912599f, -0.05819700f, 0.57863539f, -0.01486994f, -0.08024251f, 0.63776541f, 
    -0.01614671f, 0.39837730f, 0.70662296f, 0.22920331f, 0.44565195f, 0.07965340f, -0.26107106f, -0.07361602f, 
    -0.12197467f, -0.17255643f, -0.04954966f, 0.14291288f, -0.20597047f, -0.07413006f, -0.07051767f, -0.01355344f, 
    0.13386197f, -0.04271067f, 0.12640603f, -0.12203950f, 0.21223105f, 0.03741395f, -0.42369348f, 0.27168718f, 
    0.11557646f, -0.29483297f, -0.00654971f, -0.67334157f, 0.31734756f, 0.11376763f, -0.37292752f, -0.14879000f, 
    -0.07169504f, -0.10408914f, -0.25037819f, -0.13053425f, 0.27276859f, 0.18071161f, -0.20019524f, -0.07725285f, 
    -0.27374816f, 0.12825309f, 0.15855676f, 0.34939471f, 0.15018073f, -0.02624515f, 0.16327430f, -0.10607777f, 
    -0.59518474f, -0.39073128f, 0.14339110f, 0.02427074f, 0.35088423f, -0.48048186f, -0.28967440f, -0.06085981f, 
    -0.10493396f, -0.12001842f, -0.12947781f, 0.19678825f, -0.31368044f, 0.32324910f, -0.08619249f, 0.14766282f, 
    0.08691933f, -0.06375575f, -0.00852371f, 0.07373759f, 0.25720596f, 0.13150884f, 0.14206682f, -0.14123785f, 
    0.06518899f, 0.41729605f, -0.31323183f, 0.19756755f, -0.84583366f, -0.39077306f, -0.11449914f, -0.26121721f, 
    -0.68401754f, -0.15261036f, -0.03379483f, 0.23761643f, 0.29365331f, 0.03317725f, 0.11622882f, -0.28565809f, 
    -0.15118074f, -0.12025008f, 0.13437317f, 0.06007639f, 0.00476595f, -0.11681180f, 0.08188063f, 0.22391339f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.09867695f, -0.00380368f, 0.02879868f, 0.17596537f, 0.18357928f, 0.05390661f, 0.07261038f, 0.14636998f, 
    0.16906244f, -0.00073556f, -0.01052885f, -0.06120483f, 0.11768550f, 0.13383636f, 0.19332168f, 0.35951409f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.19128495f, -0.02284947f, -0.06905536f, 0.12537618f, 0.09768537f, -0.05683449f, -0.07745545f, -0.01822028f, 
    -0.19715609f, -0.08401366f, 0.05781654f, -0.01133028f, 0.18281731f, -0.07366043f, -0.03650786f, -0.12732784f, 
    -0.09758419f, 0.05450162f, -0.05659812f, 0.02962068f, 0.01988281f, -0.00982225f, -0.00475822f, -0.08921796f, 
    -0.06071104f, 0.09264925f, -0.12824568f, 0.11636668f, 0.11742636f, 0.01104382f, 0.07323862f, -0.00520130f, 
    0.00391054f, 0.08506458f, -0.08193855f, -0.10435160f, 0.07077958f, -0.10128374f, -0.15957409f, 0.06723470f, 
    -0.02271446f, -0.07845516f, 0.01357509f, -0.04915150f, -0.05945093f, 0.11312352f, -0.04453515f, 0.02336196f, 
    -0.02998746f, 0.17922759f, 0.09184636f, -0.12443493f, -0.02934515f, 0.10112973f, 0.02241953f, 0.16786994f, 
    -0.06889654f, -0.01418374f, -0.01078050f, -0.01877376f, 0.04779713f, 0.12849957f, 0.05376085f, 0.07252780f, 
    -0.00221260f, -0.00662103f, 0.02271181f, 0.03292076f, 0.00222816f, 0.08229282f, 0.10139651f, 0.00227090f, 
    0.01620536f, 0.16154508f, 0.12038169f, 0.23852949f, 0.11583661f, 0.15416363f, 0.05122921f, 0.03862249f, 
    0.10583439f, 0.05516017f, -0.10782301f, 0.02845212f, -0.15973224f, -0.23520595f, 0.31546918f, 0.06128665f, 
    0.00575371f, -0.07970721f, 0.06601832f, -0.02837245f, -0.19523658f, 0.01871639f, -0.04503762f, 0.10388230f, 
    0.13449208f, -0.10085917f, 0.21380125f, -0.23858242f, -0.10405197f, 0.01762498f, -0.06285267f, -0.01736914f, 
    -0.04226374f, -0.03539119f, -0.07627106f, 0.01376046f, 0.75264990f, -0.33145583f, -0.01359792f, -0.10961097f, 
    -0.08571748f, -0.05973777f, 0.00833313f, -0.04035797f, 0.08659835f, -0.14256267f, 0.07388138f, 0.13699163f, 
    0.19347629f, 0.29109159f, 0.01887634f, 0.11839119f, 0.22046751f, 0.03343763f, -0.11728581f, 0.14592251f, 
    0.05026557f, -0.04664127f, 0.04078924f, -0.11790002f, -0.27194095f, 0.23093809f, -0.01070533f, -0.10259975f, 
    -0.00303342f, -0.08992582f, 0.01758775f, -0.03880266f, 0.04049696f, 0.01463124f, -0.12569357f, -0.05940725f, 
    0.03204996f, 0.12112705f, 0.13316342f, 0.08676977f, 0.07248168f, -0.13161393f, 0.16216426f, 0.04107879f, 
    0.05181118f, 0.19394794f, -0.21791993f, -0.03658877f, 0.02132689f, 0.14351922f, -0.01081407f, -0.04397546f, 
    0.01414055f, -0.14433120f, 0.12913179f, 0.17170212f, 0.05943923f, -0.18794455f, -0.02323351f, -0.04237599f, 
    -0.00135829f, -0.03089408f, -0.00590249f, 0.17210825f, 0.09482366f, 0.18375942f, -0.01521054f, -0.07726038f, 
    -0.08612408f, -0.05773702f, 0.00705194f, 0.02012413f, -0.23154904f, -0.36147401f, -0.00675793f, 0.04645488f, 
    -0.06864610f, -0.08556465f, -0.00768892f, -0.04451304f, -0.01097882f, 0.02033021f, -0.11774097f, 0.09207846f, 
    -0.03847757f, -0.05628609f, -0.05589732f, 0.05715545f, -0.03551625f, -0.05545335f, -0.12249254f, -0.06458703f, 
    0.07005271f, -0.02140125f, -0.04828684f, 0.16158368f, 0.21703586f, 0.04177798f, 0.05919374f, -0.00472031f, 
    -0.06139060f, -0.05147267f, -0.01120883f, 0.04669349f, 0.01027082f, -0.00392542f, 0.12981418f, -0.01393310f, 
    -0.08746433f, 0.02181789f, -0.03479113f, -0.01727375f, 0.09186451f, 0.02390328f, 0.02697957f, 0.13431187f, 
    0.00757998f, -0.04094450f, -0.03968268f, -0.08593580f, 0.22851944f, -0.00339320f, 0.15854219f, 0.07606520f, 
    0.08820333f, 0.04094246f, -0.02478561f, 0.05455074f, 0.06829676f, 0.10108691f, 0.05149747f, 0.12215666f, 
    -0.06841577f, -0.21063259f, 0.12978633f, -0.10864047f, -0.01753955f, 0.10512101f, 0.05390493f, 0.02559579f, 
    0.21202010f, 0.03168960f, 0.06269727f, -0.06745487f, -0.21560085f, -0.16435337f, -0.12790936f, 0.05590345f, 
    -0.06119976f, 0.05570743f, -0.05585687f, -0.12588035f, 0.06844984f, 0.00274101f, -0.00228991f, -0.11679796f, 
    -0.07229985f, -0.09502270f, -0.08198676f, -0.15245502f, -0.00312821f, -0.10587516f, 0.09031536f, 0.00986970f, 
    0.12310747f, -0.01029427f, -0.05836455f, 0.05811450f, 0.04176159f, -0.00309216f, 0.22307909f, 0.13601090f, 
    -0.02447790f, 0.01220749f, 0.02277997f, -0.08043875f, 0.08695547f, 0.09614944f, -0.13277921f, 0.02032139f, 
    0.13489452f, 0.03207381f, 0.03726448f, -0.06818422f, -0.10184323f, 0.01888664f, -0.04703414f, 0.04704300f, 
    -0.07835494f, 0.06229112f, 0.04026198f, 0.09531955f, 0.46811512f, 0.14130062f, -0.02903979f, -0.04766890f, 
    -0.00029920f, 0.00064365f, 0.10027493f, 0.00418567f, 0.07330482f, 0.02752350f, 0.08024390f, 0.11478019f, 
    -0.00675575f, -0.00718743f, -0.05542340f, -0.08835641f, 0.04740079f, 0.01279815f, -0.08829767f, 0.00202180f, 
    0.15041573f, -0.10391153f, 0.08454912f, -0.13457316f, -0.02751986f, -0.15088074f, -0.17104921f, -0.09058131f, 
    0.06777635f, -0.01484903f, -0.07017193f, -0.03016009f, 0.03885990f, -0.07949008f, 0.11598931f, -0.07107695f, 
    0.25684273f, 0.03829939f, 0.08145855f, 0.08388431f, 0.06161839f, 0.09805486f, 0.03588987f, 0.10936798f, 
    0.00803227f, 0.18602112f, -0.13035882f, 0.04172635f, -0.29133433f, 0.12055923f, -0.11687925f, -0.19077085f, 
    0.10064235f, -0.13826528f, 0.09752028f, 0.08803224f, 0.16267557f, -0.03683874f, 0.01708024f, -0.05167545f, 
    0.10037460f, -0.06166130f, -0.01882264f, -0.10967270f, -0.04579389f, 0.09746468f, 0.10189925f, 0.10185077f, 
    0.10120916f, -0.00106868f, -0.01460504f, 0.06217387f, -0.19150572f, 0.02783970f, -0.04414958f, 0.03415904f, 
    0.11170896f, 0.11159308f, -0.02808339f, 0.13639210f, 0.02376446f, -0.01768139f, 0.01525031f, 0.08379287f, 
    -0.09395678f, 0.21893185f, 0.08682178f, -0.19267128f, 0.01235752f, 0.01010407f, 0.02929603f, 0.05140448f, 
    0.11059496f, 0.10518255f, 0.02256571f, -0.01967069f, 0.10399069f, 0.17186438f, 0.14437719f, -0.23835441f, 
    0.01762748f, 0.04863534f, -0.08823773f, 0.12282831f, 0.09423475f, 0.00995788f, 0.04033735f, 0.00717609f, 
    0.22558020f, 0.10420374f, -0.03703031f, -0.00842953f, 0.05684644f, -0.00178526f, 0.04468572f, 0.07962894f, 
    0.07667336f, 0.08706100f, 0.01610964f, 0.25073496f, 0.17293030f, -0.11615106f, 0.37099802f, 0.12570679f, 
    0.10705405f, -0.05527386f, -0.03628366f, -0.02061213f, -0.05677044f, -0.06537547f, -0.03548805f, -0.19096284f, 
    0.45704785f, -0.20244174f, -0.10796393f, 0.27580267f, -0.13057104f, -0.07316752f, 0.05951026f, 0.06381641f, 
    -0.06971469f, 0.08715995f, 0.01517730f, -0.04074753f, -0.33449259f, -0.03619113f, -0.20882076f, -0.05164002f, 
    -0.15097134f, 0.07819191f, 0.09679851f, -0.04006636f, -0.07415418f, -0.11888104f, -0.04085415f, -0.05210641f, 
    -0.05082720f, 0.06186570f, -0.06671070f, -0.09733128f, 0.05502468f, -0.08213095f, -0.10972653f, 0.02280131f, 
    -0.09163918f, -0.11172718f, 0.11639825f, 0.09754568f, -0.06227694f, 0.26864463f, 0.08703932f, 0.10245135f, 
    0.06996138f, 0.04269101f, 0.00008911f, 0.00672295f, -0.01419924f, 0.08661081f, 0.05007662f, 0.04785586f, 
    -0.04860304f, -0.03085678f, -0.03664363f, 0.16860120f, -0.05320558f, 0.08718868f, 0.01813089f, 0.12887786f, 
    0.09775747f, 0.03634299f, -0.12538359f, -0.16792409f, 0.37921944f, 0.20066465f, -0.09061395f, 0.02994023f, 
    0.03943012f, -0.03818716f, 0.10093859f, 0.02772057f, -0.03726832f, -0.04653738f, 0.06679345f, -0.01833347f, 
    0.11977506f, -0.21474482f, -0.21519820f, 0.01280371f, 0.05133415f, -0.02027435f, 0.15288959f, -0.14394471f, 
    0.02094952f, 0.08407921f, 0.08553494f, 0.04493073f, 0.20667481f, -0.28203157f, -0.04543323f, -0.00408846f, 
    0.07870018f, 0.11102153f, 0.11094123f, -0.00992643f, -0.00318573f, 0.01496035f, 0.12976871f, -0.21233022f, 
    0.08634263f, -0.18927559f, 0.21075465f, -0.15231423f, 0.07809030f, 0.00865620f, 0.02900024f, 0.08907390f, 
    -0.02639761f, -0.08089241f, -0.00633841f, 0.07922747f, -0.08074845f, 0.12998354f, -0.00798942f, -0.11033670f, 
    -0.04381380f, -0.03912829f, -0.07530152f, 0.07457776f, 0.00665936f, -0.05887934f, 0.12640873f, 0.01685998f, 
    0.30367705f, 0.04482894f, -0.24974360f, 0.09682318f, 0.04453355f, -0.08069140f, -0.09271182f, -0.08733140f, 
    -0.05368855f, -0.05281806f, -0.08800777f, 0.01092204f, -0.16889492f, 0.18076612f, 0.04553310f, 0.26418030f, 
    0.02125314f, -0.05792102f, 0.06498805f, -0.07068450f, 0.02145727f, -0.08822747f, -0.06288940f, -0.05653489f, 
    0.02014261f, 0.10626529f, 0.13804530f, -0.24968864f, -0.00590361f, 0.04640365f, 0.12206607f, -0.11579948f, 
    -0.02180998f, -0.06397083f, 0.09008609f, 0.04654367f, 0.03081958f, -0.00223601f, 0.06695241f, 0.02100372f, 
    0.06417621f, 0.12363415f, 0.10419123f, -0.13863581f, -0.01523401f, 0.06783946f, 0.00811673f, 0.09977549f, 
    -0.03287560f, 0.20912598f, 0.09600867f, 0.06972447f, 0.10375326f, 0.00843300f, 0.18686767f, -0.02013334f, 
    -0.06069718f, 0.08163483f, 0.10673312f, 0.07960559f, 0.19742653f, 0.33545902f, 0.25714925f, -0.11120851f, 
    0.06567339f, 0.09489734f, 0.08007424f, 0.02963280f, 0.04366850f, -0.07185559f, 0.02421885f, -0.00781257f, 
    -0.23037179f, -0.16313656f, 0.20477748f, -0.01490548f, 0.08691332f, -0.06909420f, -0.02941270f, 0.05171627f, 
    0.18640116f, -0.04478970f, -0.00025971f, 0.11930978f, 0.01467070f, -0.18948036f, -0.29076955f, -0.32803005f, 
    0.06960844f, -0.05828939f, -0.08345780f, -0.02949315f, 0.12042740f, -0.01464249f, 0.02416742f, 0.08221469f, 
    0.13728230f, -0.08965944f, -0.20738369f, -0.07467806f, -0.03937854f, 0.07846400f, 0.10227635f, -0.09783884f, 
    0.00300980f, 0.04140547f, -0.12167562f, 0.02928279f, 0.09571899f, 0.16713527f, 0.13758647f, 0.05796039f, 
    -0.14842619f, 0.07827304f, 0.15827343f, -0.05741961f, -0.05010472f, -0.04589355f, 0.03389692f, 0.02697873f, 
    -0.19427358f, 0.00533989f, 0.07710420f, 0.24980873f, 0.02913230f, -0.00703564f, 0.14896005f, -0.00772373f, 
    -0.11811832f, 0.06110168f, 0.05959202f, 0.01965481f, -0.21157974f, 0.21253300f, 0.22784925f, -0.07430983f, 
    0.05418842f, 0.25742584f, 0.05197726f, 0.05494668f, -0.14994393f, -0.07445069f, -0.14815331f, 0.04911526f, 
    0.15234312f, -0.31164849f, -0.16890018f, -0.22113895f, 0.10892476f, -0.06226953f, -0.02696839f, 0.03065396f, 
    0.03010517f, 0.05675338f, 0.08422149f, 0.11002885f, 0.11788723f, -0.08502588f, 0.02583541f, -0.03522467f, 
    -0.00856588f, -0.10295572f, 0.03337324f, -0.07466593f, 0.08376152f, 0.05563613f, 0.05091411f, -0.06377308f, 
    0.07499690f, 0.11890224f, 0.06395104f, -0.02016237f, -0.06206658f, 0.02314250f, -0.04779362f, -0.03759155f, 
    0.04024680f, 0.00376666f, -0.02353390f, 0.05717590f, 0.02116149f, -0.09084183f, -0.21023393f, 0.16819106f, 
    0.03199797f, 0.01178423f, 0.06412326f, 0.04425041f, 0.16202609f, 0.04587837f, -0.04653576f, 0.11986208f, 
    -0.12815447f, -0.13402948f, 0.08226880f, -0.09354954f, 0.07687523f, -0.01870568f, 0.22053818f, 0.10434908f, 
    0.00622660f, 0.08715621f, -0.11977145f, 0.01863031f, 0.16330168f, 0.25563836f, 0.04959045f, 0.11461563f, 
    0.16020840f, 0.09598057f, 0.12907681f, 0.02122537f, -0.15615718f, 0.08047903f, 0.00610545f, 0.09784258f, 
    -0.21129753f, -0.25348884f, -0.08556326f, -0.14576297f, 0.05128513f, -0.04153939f, -0.01816461f, 0.00128816f, 
    0.12956196f, 0.09087330f, 0.00159247f, 0.16208157f, -0.02395327f, -0.06783810f, 0.06028078f, 0.03060324f, 
    0.01415629f, -0.20661232f, -0.13141017f, 0.10764249f, 0.02693095f, 0.09330533f, 0.15757573f, 0.02692909f, 
    0.14114100f, 0.04829840f, -0.00152023f, 0.06253657f, -0.11194494f, 0.09790593f, 0.08560988f, 0.14388430f, 
    0.07094931f, -0.08476163f, 0.11972329f, -0.06415858f, -0.03090445f, -0.13943420f, 0.22280301f, 0.09044436f, 
    0.01446345f, 0.11475760f, -0.02539971f, 0.15971540f, 0.04892512f, 0.06748346f, 0.13382511f, 0.10925975f, 
    0.07613170f, -0.19291186f, 0.01741336f, 0.09986316f, 0.07657737f, 0.00969481f, 0.04896249f, -0.02124203f, 
    0.10564952f, 0.03088799f, 0.07099680f, 0.08129719f, -0.33675274f, -0.14169428f, -0.03769127f, -0.08913907f, 
    -0.10263294f, 0.01367919f, 0.04553724f, -0.05675051f, 0.03363097f, 0.03185789f, -0.00604460f, -0.06154037f, 
    -0.10761847f, -0.17550068f, -0.09777396f, -0.31632808f, 0.03042389f, 0.04234567f, 0.09634954f, -0.06525797f, 
    0.02979219f, 0.04342901f, -0.08816030f, 0.03472937f, 0.09658634f, 0.04495488f, 0.10109936f, 0.25460032f, 
    0.05887537f, 0.19992943f, -0.01555347f, -0.06357438f, 0.10736223f, -0.00425734f, -0.06092279f, 0.03278020f, 
    0.10589918f, 0.08530095f, -0.09221210f, 0.06157601f, 0.06498525f, 0.06090421f, 0.03069761f, 0.10488655f, 
    0.06426568f, 0.15822174f, 0.14387320f, 0.17718427f, -0.17165036f, 0.31659028f, -0.01851001f, 0.14391147f, 
    -0.01129674f, -0.02015079f, -0.08999651f, 0.13398500f, 0.00106200f, 0.10723805f, 0.00439643f, 0.11299422f, 
    0.03276967f, -0.05642610f, -0.15708642f, -0.14951240f, -0.01504693f, -0.02039821f, -0.16301326f, -0.04968045f, 
    0.09243678f, -0.13792948f, 0.06931753f, -0.09597036f, -0.24100299f, -0.09317108f, -0.13592413f, -0.01187590f, 
    0.17936422f, 0.07091818f, 0.00872943f, -0.01039340f, 0.03226699f, -0.12525892f, 0.07161570f, -0.06104476f, 
    0.09680031f, -0.22934397f, 0.06036609f, 0.00503646f, 0.05682632f, 0.00830160f, 0.07577651f, 0.02964305f, 
    0.17555200f, 0.12934132f, -0.06869078f, 0.01762198f, -0.13408759f, -0.00626448f, 0.04400519f, -0.10193861f, 
    -0.01388752f, -0.08460340f, 0.18491057f, 0.10587018f, 0.13582008f, 0.05520775f, -0.07117444f, 0.07707340f, 
    0.21199414f, 0.01163224f, -0.10838327f, -0.00838078f, -0.04414530f, -0.04283453f, 0.21146795f, 0.02258958f, 
    0.11468370f, 0.02030647f, 0.00747559f, 0.07787151f, 0.07052086f, 0.31538111f, 0.11727094f, 0.01155481f, 
    0.08766998f, 0.11080179f, 0.16574509f, 0.06122022f, 0.06880574f, 0.02612093f, 0.12516509f, 0.00927398f, 
    -0.03249814f, -0.00675668f, 0.00713637f, -0.06105604f, -0.04693546f, -0.06478771f, -0.05571013f, -0.00550173f, 
    0.02024909f, -0.07285426f, 0.02536155f, 0.00878272f, -0.05200013f, -0.04403306f, -0.07120550f, -0.06164564f, 
    -0.06903610f, 0.00184745f, -0.08122080f, -0.02173142f, 0.00395977f, 0.00471148f, -0.04579303f, 0.04876356f, 
    -0.00654404f, -0.02613017f, 0.08949475f, -0.00266201f, -0.07551073f, 0.04224133f, 0.01925318f, 0.03712158f, 
    0.01859559f, -0.06068963f, -0.01963223f, -0.03886529f, 0.04685928f, 0.04372247f, -0.05576530f, 0.02450554f, 
    0.07285339f, 0.01925838f, -0.02854053f, -0.06267865f, 0.00288926f, 0.05865970f, -0.07880904f, -0.10402969f, 
    -0.08544641f, 0.02327750f, 0.01287758f, -0.01125230f, -0.00650023f, -0.07010458f, 0.04398137f, 0.01993993f, 
    0.02698805f, -0.03818551f, 0.05050006f, -0.10290590f, 0.07130532f, 0.05232842f, -0.05167307f, -0.03099559f, 
    -0.04541989f, -0.06817864f, -0.09109172f, 0.01147603f, 0.01159423f, -0.06385039f, 0.04709934f, -0.04137637f, 
    0.02689328f, 0.02665529f, 0.11595333f, 0.09985612f, -0.03444663f, -0.09700830f, 0.04544194f, 0.07162901f, 
    -0.08941317f, 0.00596079f, -0.03652431f, -0.05705659f, -0.01734959f, -0.03750969f, -0.01080169f, -0.02094279f, 
    -0.00558130f, -0.04078210f, 0.01040824f, -0.07475806f, 0.06194920f, 0.01069674f, -0.02697611f, 0.00895603f, 
    -0.09385682f, 0.00924817f, 0.00829905f, -0.08623315f, 0.02048335f, -0.08554497f, 0.03986937f, -0.01716891f, 
    -0.00668583f, 0.02951995f, -0.01133822f, 0.03102883f, -0.05441171f, -0.05065285f, -0.08953840f, -0.08736404f, 
    -0.02748809f, 0.04878776f, -0.01012642f, -0.07880591f, 0.04428453f, -0.03445359f, -0.01531854f, 0.06726917f, 
    0.04088547f, 0.03173755f, 0.04552580f, 0.03046658f, -0.05490791f, -0.03803535f, -0.04028078f, -0.02363678f, 
    -0.05819797f, 0.04537625f, -0.05418631f, -0.03196799f, 0.03264032f, -0.10552873f, -0.03544446f, 0.03026408f, 
    -0.05229595f, 0.00967671f, -0.01649302f, -0.00182647f, -0.06829894f, -0.01212965f, -0.02729366f, 0.04553733f, 
    0.02199560f, -0.04506310f, -0.08312841f, 0.03206784f, 0.01912909f, -0.01526487f, -0.03405840f, -0.02521821f, 
    0.07765822f, -0.06326596f, -0.02814117f, 0.00673639f, -0.04386351f, -0.00249696f, -0.06555413f, -0.05254345f, 
    -0.00991038f, -0.07781448f, -0.05888344f, 0.07171264f, 0.02162433f, -0.00458468f, -0.06539620f, 0.01088708f, 
    -0.05131639f, -0.04812905f, 0.04154751f, -0.03644766f, 0.01940057f, 0.01794565f, -0.05034101f, 0.00874033f, 
    -0.02061329f, 0.03063788f, -0.02411633f, -0.08112507f, -0.05185758f, -0.08084942f, 0.03756575f, -0.07610490f, 
    0.02969171f, -0.00209828f, 0.04300159f, 0.00036773f, 0.03326870f, -0.07010006f, 0.02442823f, 0.03241846f, 
    0.33765653f, 0.09443878f, -0.07569855f, 0.00775177f, 0.06664085f, 0.03573884f, 0.05103998f, -0.08487377f, 
    -0.02899305f, -0.05895622f, -0.03315910f, -0.07969873f, 0.00734499f, -0.04577342f, -0.26578695f, 0.03484438f, 
    -0.02128826f, 0.08382270f, 0.20598556f, 0.03309380f, 0.07240720f, -0.12926497f, -0.13116366f, 0.07357527f, 
    0.03356765f, 0.01983042f, 0.04328277f, 0.01666276f, -0.13237116f, 0.13140418f, -0.14459500f, -0.06805296f, 
    0.20623006f, 0.02708719f, -0.01294563f, 0.21677972f, -0.06055977f, -0.16256723f, -0.08395800f, 0.09164868f, 
    0.15179467f, -0.05772310f, -0.05720579f, 0.02292235f, 0.02600330f, -0.23311901f, -0.07837988f, -0.14544831f, 
    0.19602488f, 0.16085847f, -0.12506030f, 0.13246913f, -0.00303268f, 0.03205536f, 0.05759834f, 0.19599447f, 
    -0.11236165f, 0.05025586f, -0.11314745f, -0.02398909f, 0.18810908f, 0.23446926f, 0.17825639f, -0.13221455f, 
    -0.02076918f, 0.10581966f, -0.09494664f, 0.12033918f, -0.04457498f, -0.04641096f, 0.03946577f, 0.01030947f, 
    0.19570139f, 0.22658253f, 0.02180362f, 0.14574648f, 0.11935513f, -0.00928001f, -0.12138259f, 0.03211118f, 
    0.04719072f, 0.12677915f, 0.31338403f, 0.04371777f, 0.14500697f, 0.09667421f, -0.14429191f, -0.19148602f, 
    0.02310224f, -0.04387055f, 0.01496143f, 0.15192670f, 0.15098797f, -0.02510865f, 0.15078549f, -0.06549836f, 
    0.05906648f, -0.07255477f, -0.03484765f, -0.05909830f, 0.01067944f, 0.12454522f, 0.04532058f, 0.09988306f, 
    -0.00166782f, -0.03779604f, -0.10220562f, -0.20428911f, -0.00288279f, -0.19471130f, -0.03039801f, 0.03706064f, 
    -0.04849794f, 0.12929231f, -0.06720465f, -0.03952682f, -0.05002216f, -0.06970025f, 0.08819640f, 0.01966788f, 
    0.09908471f, -0.11057100f, 0.21835779f, 0.23108701f, -0.08377124f, -0.02086471f, 0.20495228f, 0.04680250f, 
    -0.01993397f, 0.15617470f, -0.10279441f, 0.17123951f, -0.17304745f, 0.12249335f, -0.02616328f, 0.01462994f, 
    -0.04575005f, 0.12798114f, 0.04904836f, 0.03129975f, -0.04434245f, 0.09096763f, 0.03687406f, 0.02718841f, 
    -0.12722534f, -0.15619692f, -0.12498195f, -0.11317523f, 0.12669301f, -0.08149422f, -0.01571724f, 0.04658845f, 
    -0.09155732f, -0.05048282f, 0.11806159f, -0.00795135f, 0.30308005f, -0.15253940f, -0.00616050f, 0.10925125f, 
    -0.09326304f, 0.04609604f, -0.18967424f, 0.03619335f, -0.10543527f, 0.09581020f, 0.10216401f, 0.03221963f, 
    0.10753859f, 0.12152118f, 0.16235603f, 0.24814665f, -0.04880284f, -0.12471903f, -0.11140703f, 0.04587128f, 
    -0.15383932f, 0.02355422f, -0.00970994f, -0.02135103f, -0.14818992f, 0.00902261f, 0.04451133f, 0.04691077f, 
    -0.03644343f, -0.09737030f, 0.07647487f, -0.05684727f, 0.02373200f, -0.07029532f, -0.13333118f, 0.00970065f, 
    -0.04170256f, 0.12540185f, -0.06776706f, 0.07645808f, 0.15727897f, 0.01503690f, -0.06763925f, -0.04380686f, 
    -0.16005787f, -0.06951075f, 0.02292676f, 0.02792080f, 0.10264844f, 0.16744728f, 0.25803992f, -0.15258741f, 
    -0.09243114f, 0.16534619f, 0.00210101f, 0.08236961f, 0.02911776f, -0.02285306f, 0.12665908f, -0.02306886f, 
    -0.33543572f, -0.03542863f, -0.18308771f, 0.04247320f, -0.05284978f, 0.04334213f, -0.01302205f, 0.13428517f, 
    0.18802448f, 0.04767284f, 0.03090473f, -0.01143554f, -0.15730956f, 0.02031334f, 0.11894415f, 0.00211334f, 
    0.20151971f, 0.02637115f, 0.00469778f, 0.01400882f, 0.04985661f, 0.04267462f, -0.05887857f, 0.04432115f, 
    0.03328180f, -0.01097433f, -0.08447581f, -0.05606475f, -0.08827540f, 0.03764562f, -0.00261668f, 0.04699046f, 
    0.09965164f, 0.00724715f, 0.03371527f, -0.15957582f, -0.31194347f, -0.16330233f, -0.04758001f, 0.15492299f, 
    -0.00898057f, 0.00682945f, 0.06535421f, -0.06299166f, 0.00490966f, 0.17509906f, 0.05705466f, -0.12878785f, 
    -0.21755281f, -0.03838466f, 0.25960127f, 0.29722866f, 0.04727427f, 0.02379474f, -0.10942043f, 0.14782533f, 
    0.07294551f, 0.06454130f, -0.13316217f, 0.13567752f, -0.12420802f, 0.11516222f, -0.04283606f, 0.20468317f, 
    0.12681241f, 0.03384546f, 0.02309855f, -0.12730874f, 0.05470798f, -0.00898226f, -0.02443275f, 0.05019389f, 
    0.12010464f, -0.02682408f, 0.03101171f, -0.14899975f, -0.03611982f, -0.05646153f, -0.02747394f, 0.13873729f, 
    -0.08047580f, 0.06662227f, -0.10015827f, 0.02198201f, 0.27762616f, -0.26446688f, 0.15687877f, 0.00943350f, 
    0.08768880f, 0.08421183f, 0.06324980f, 0.07319078f, 0.04092227f, 0.07801655f, 0.02470017f, 0.23396945f, 
    -0.03597964f, -0.01616876f, 0.17271166f, 0.30270305f, -0.03953521f, 0.12085600f, -0.09384287f, 0.19693778f, 
    0.13016780f, 0.03527998f, -0.02568807f, -0.10398325f, 0.16561788f, -0.03773749f, 0.01129402f, -0.11696377f, 
    0.02805489f, 0.01599144f, -0.13361168f, 0.00735645f, 0.03987836f, -0.11913559f, 0.00117851f, -0.04729261f, 
    0.19658911f, 0.06263689f, 0.21998310f, -0.05146673f, 0.01342928f, -0.04081672f, -0.00661362f, 0.14182566f, 
    -0.02841990f, -0.04247370f, 0.01301331f, 0.15830255f, -0.08468959f, 0.05271677f, -0.07627686f, -0.15460542f, 
    -0.09460986f, -0.06456864f, 0.10237803f, 0.01525653f, 0.06884754f, -0.18669660f, -0.04129759f, 0.16926485f, 
    0.00654895f, 0.07856156f, -0.07178559f, -0.10043135f, 0.05042613f, 0.11547251f, -0.10923844f, 0.12868667f, 
    -0.00516094f, 0.00515499f, -0.06663163f, 0.08557002f, -0.27763459f, -0.39546862f, -0.14601798f, -0.17989084f, 
    0.05751147f, -0.11721699f, -0.01530229f, -0.04571430f, 0.08211754f, 0.04049986f, 0.09734190f, 0.03710550f, 
    0.08256210f, 0.06161080f, 0.07155476f, -0.08529805f, -0.02023024f, 0.09379961f, 0.11005857f, 0.02632599f, 
    0.17658117f, -0.04913443f, 0.06711353f, -0.06797019f, -0.21309246f, -0.00654914f, -0.12538847f, -0.03992528f, 
    0.09340420f, -0.01721526f, 0.10043686f, -0.00104984f, -0.07620884f, -0.02357221f, -0.03459617f, 0.19349359f, 
    0.24193062f, 0.04846471f, 0.14441478f, 0.13878232f, -0.03882517f, -0.05671165f, 0.09708410f, -0.01913835f, 
    0.04865416f, 0.04394351f, 0.04332216f, 0.21055067f, -0.05970227f, 0.11109032f, 0.06916922f, -0.12021493f, 
    -0.04810609f, 0.11041348f, -0.02888362f, 0.09992547f, 0.09867503f, -0.04111407f, 0.05708786f, -0.06464083f, 
    0.08931711f, -0.21973611f, -0.04043810f, 0.14370756f, 0.04419304f, 0.01878532f, 0.04010874f, 0.08727645f, 
    -0.00202506f, 0.04932948f, -0.08218038f, 0.12422683f, 0.07414696f, 0.00905911f, -0.09382835f, -0.26181647f, 
    0.08959460f, 0.07108308f, -0.06084247f, 0.02421287f, 0.10808297f, 0.01488568f, 0.01884746f, 0.11817475f, 
    0.23075865f, -0.16245572f, -0.16282991f, -0.21277179f, -0.06925464f, -0.03587401f, 0.01194522f, -0.06850300f, 
    0.03181524f, 0.00048448f, 0.20469511f, -0.06651789f, 0.15104400f, 0.14295474f, -0.09049313f, -0.10694812f, 
    -0.00669895f, -0.04927715f, 0.09354877f, 0.13639702f, 0.10501976f, -0.02726030f, 0.11190464f, -0.07532012f, 
    -0.23157731f, 0.08868306f, 0.03186711f, 0.20854792f, 0.06465651f, 0.03611746f, 0.02487123f, -0.04717726f, 
    0.03243651f, 0.09184990f, 0.08914618f, -0.01745002f, -0.46888557f, 0.25274453f, 0.06686001f, 0.05364318f, 
    0.01097431f, 0.05982536f, 0.01939018f, -0.00403919f, -0.09380532f, -0.08446656f, -0.08549981f, -0.09228265f, 
    0.01877485f, -0.20719203f, -0.03824277f, -0.14358589f, 0.01358836f, -0.15232883f, 0.10876706f, -0.13379937f, 
    -0.06121863f, 0.09628244f, 0.06007022f, 0.10820941f, 0.02004058f, 0.05659698f, 0.01120667f, 0.02199081f, 
    -0.03651135f, 0.04567245f, 0.00803642f, -0.01592816f, 0.03099113f, 0.08129174f, 0.10126430f, 0.04026527f, 
    -0.20523138f, -0.05852306f, -0.15420625f, 0.03890528f, -0.01560857f, -0.00317453f, -0.08346185f, -0.02178220f, 
    -0.03021767f, -0.07665016f, 0.05368675f, 0.01759013f, 0.25921050f, -0.14897348f, 0.01555845f, 0.21552928f, 
    0.04836036f, 0.08314879f, -0.01629331f, -0.03859661f, 0.02584473f, 0.13449027f, -0.00950639f, -0.00673668f, 
    0.03678594f, 0.01613306f, 0.14676239f, 0.11071064f, 0.04197951f, -0.07181920f, 0.14487410f, 0.07347715f, 
    -0.00470061f, 0.09434675f, -0.07946315f, 0.00006547f, 0.08428588f, 0.14398164f, 0.12768492f, 0.18220730f, 
    0.08142942f, 0.13160644f, 0.01749417f, 0.12941277f, -0.04229948f, 0.06751341f, -0.02732957f, 0.04747413f, 
    0.20394449f, 0.28655156f, 0.08822535f, -0.20972256f, -0.03266302f, 0.05163398f, -0.09066518f, -0.02388233f, 
    0.01779853f, 0.04389997f, -0.04654248f, 0.11229328f, 0.13948067f, 0.14904207f, 0.07231616f, -0.21276820f, 
    -0.07826106f, -0.11110208f, -0.07648623f, -0.02947697f, -0.00037629f, -0.00199084f, -0.06395468f, 0.14261992f, 
    0.16351727f, 0.06471112f, -0.08403843f, 0.13869372f, 0.18148799f, -0.05960855f, 0.11012767f, 0.04929978f, 
    0.11735302f, 0.12683696f, -0.04127423f, 0.25172430f, 0.25237772f, 0.08468310f, -0.01230432f, -0.11834092f, 
    -0.01757160f, -0.10561773f, -0.00217645f, -0.03436908f, 0.13037324f, -0.06606822f, -0.13291775f, -0.07639439f, 
    0.15070336f, 0.09064258f, 0.01568102f, 0.25545454f, -0.03430424f, 0.07130908f, 0.09275722f, 0.06241834f, 
    -0.04294741f, 0.12864313f, 0.04755359f, 0.06983699f, 0.04197710f, 0.08308876f, -0.09270990f, -0.13486798f, 
    0.20271647f, 0.10644554f, -0.01625152f, 0.06088403f, -0.06181959f, -0.04314839f, 0.03429813f, -0.01412425f, 
    0.23718870f, 0.16284961f, -0.16127209f, 0.06879883f, 0.20559549f, 0.05043298f, 0.09557372f, -0.05913205f, 
    0.01560798f, 0.03900847f, 0.06149028f, 0.04820148f, -0.09911043f, 0.00588496f, 0.14127445f, -0.02398737f, 
    -0.09327557f, -0.02552099f, 0.01353635f, 0.11331914f, -0.02824329f, 0.06873374f, 0.02667956f, 0.04749471f, 
    -0.12528951f, -0.02035956f, 0.06120754f, 0.09393585f, 0.06287301f, 0.13641326f, 0.11533011f, -0.10462743f, 
    0.01905377f, 0.09443180f, -0.00071696f, -0.13700913f, 0.14921424f, -0.15347308f, 0.11660223f, -0.20401530f, 
    0.00084314f, 0.05195807f, -0.07987285f, -0.06024511f, 0.01156748f, -0.10470771f, -0.01335706f, 0.00407201f, 
    0.16026190f, 0.06121678f, -0.15595150f, -0.10523064f, 0.16612928f, 0.09982423f, 0.14557931f, -0.01400921f, 
    0.02865570f, 0.09056316f, -0.02739574f, 0.12857318f, -0.22141694f, 0.29069114f, -0.00234211f, -0.11672875f, 
    0.01366767f, 0.01128785f, 0.09753306f, -0.04146482f, 0.01013528f, 0.13616443f, -0.06012537f, -0.08149689f, 
    -0.18208954f, 0.05945869f, 0.02324593f, -0.08619384f, 0.06004314f, -0.05333060f, 0.08787095f, -0.01782472f, 
    -0.04437757f, 0.03367723f, -0.02150339f, 0.04819025f, 0.21023771f, 0.03150368f, -0.00086559f, 0.15176962f, 
    0.05269678f, -0.04636013f, 0.08623987f, 0.04916098f, -0.07584945f, -0.01404715f, 0.19470914f, 0.00308185f, 
    0.14818966f, -0.03475576f, 0.11726800f, 0.30538812f, 0.06456415f, 0.04589532f, 0.00445969f, 0.09799583f, 
    0.03434619f, 0.11645035f, -0.10658774f, 0.00987008f, -0.02476319f, -0.09768355f, 0.11400204f, 0.39216799f, 
    -0.13062356f, -0.03736402f, -0.12142151f, -0.07390949f, -0.09420721f, -0.05718096f, 0.02806498f, 0.16676243f, 
    0.04610274f, 0.05374071f, -0.04451967f, 0.05920804f, 0.05887802f, 0.05718231f, -0.00400777f, -0.05227615f, 
    -0.04193863f, -0.05418018f, -0.01590470f, -0.00222269f, 0.01443690f, -0.03659426f, 0.00737755f, -0.00499790f, 
    0.01349534f, -0.06361209f, 0.02858584f, -0.02484977f, -0.03219740f, -0.06182314f, -0.03616873f, 0.05019230f, 
    0.00135610f, 0.00472449f, -0.03590707f, 0.04006065f, 0.00731622f, -0.01008781f, -0.01384982f, 0.03786747f, 
    0.02349682f, 0.04240540f, -0.01445448f, 0.01681820f, 0.05121766f, -0.01177005f, 0.05702313f, -0.04184466f, 
    -0.07017790f, -0.01888010f, -0.01207355f, -0.05159461f, -0.02569876f, 0.03550562f, -0.06407472f, -0.05410616f, 
    -0.04400229f, -0.02682648f, -0.06302574f, -0.07395917f, -0.06032131f, 0.02555736f, 0.05277567f, -0.06727037f, 
    0.00022252f, -0.03690229f, 0.05455798f, -0.02087087f, 0.01600821f, -0.03373612f, -0.01498656f, 0.02634210f, 
    0.04967802f, -0.06267835f, -0.04376306f, -0.01608228f, -0.03605016f, -0.07365450f, -0.05222797f, -0.07303499f, 
    0.00091118f, -0.08304983f, -0.08460402f, 0.01173143f, 0.03775572f, 0.02055668f, 0.00065660f, -0.04074701f, 
    -0.04806253f, -0.03230867f, 0.01077917f, 0.03841370f, 0.05235713f, -0.01894138f, 0.00052558f, 0.05238629f, 
    0.01839656f, 0.04420723f, 0.01884221f, -0.04341619f, 0.04768224f, 0.05086654f, -0.01297572f, 0.00986228f, 
    -0.01251612f, 0.06742129f, 0.00343002f, -0.05849583f, -0.03262768f, -0.00448000f, -0.07713677f, -0.06177698f, 
    0.05106337f, 0.05881337f, -0.03380815f, -0.05617941f, 0.00989033f, 0.05908046f, -0.07430308f, 0.00420276f, 
    0.04395009f, -0.07295960f, -0.03831389f, 0.00841636f, 0.03935365f, 0.05852971f, 0.02566873f, -0.00566478f, 
    -0.01819844f, 0.04153161f, 0.05399813f, -0.00976005f, -0.06607171f, -0.00795523f, -0.04522853f, -0.04791521f, 
    0.01394301f, -0.04171658f, -0.00800235f, 0.05479601f, 0.03323388f, -0.08221406f, 0.03998185f, -0.02154854f, 
    -0.03753728f, 0.00452674f, 0.02791049f, 0.03554004f, -0.05776924f, 0.02153896f, -0.03919335f, 0.00605960f, 
    -0.03284481f, -0.05861637f, -0.03162727f, 0.05340243f, 0.02890713f, -0.06464037f, -0.02754747f, 0.04938822f, 
    0.01560355f, 0.04036730f, 0.03715654f, 0.02425547f, 0.05175296f, 0.02475483f, 0.01810346f, 0.03536320f, 
    -0.04291030f, -0.05256908f, -0.03122041f, -0.03309922f, -0.01098817f, -0.06229888f, -0.05713453f, 0.04611434f, 
    0.00362864f, -0.06499325f, 0.01563887f, -0.01644631f, -0.08712396f, -0.01255186f, -0.02280933f, 0.01544608f, 
    -0.00867929f, -0.03677629f, 0.01792421f, 0.03846795f, -0.07367521f, -0.07099324f, -0.04349051f, 0.02986870f, 
    0.03703837f, 0.03334931f, -0.04220978f, -0.05656797f, -0.02436517f, -0.00297201f, 0.01246267f, 0.00908672f, 
    0.27854815f, -0.00339447f, 0.15044899f, -0.02370364f, -0.10527762f, 0.04245690f, 0.00622582f, 0.02091847f, 
    -0.00272114f, 0.06631503f, 0.00243272f, 0.07473766f, 0.32914180f, 0.27916986f, 0.16121770f, 0.21480446f, 
    0.03465599f, 0.21852924f, 0.14399032f, 0.07427894f, 0.02861660f, 0.03571304f, -0.01181032f, 0.04377067f, 
    -0.01104689f, 0.02727461f, 0.11579499f, 0.12212946f, 0.00456603f, -0.10107534f, -0.07117154f, 0.00914377f, 
    -0.07021298f, -0.02808434f, 0.13522704f, 0.01236034f, 0.10506327f, -0.00166073f, 0.17561279f, 0.10565003f, 
    -0.06259126f, 0.12093271f, -0.00220046f, 0.02097908f, 0.03469609f, -0.07863051f, 0.00588839f, 0.00967413f, 
    0.15954782f, 0.10345625f, 0.00504244f, 0.15664153f, -0.07976441f, -0.01651094f, 0.08153822f, -0.08736837f, 
    -0.09141034f, 0.06358992f, 0.11868615f, -0.04867041f, -0.18109888f, 0.08896905f, -0.02617494f, -0.10841707f, 
    0.13299783f, 0.00273486f, 0.00324013f, -0.02286718f, 0.10551640f, -0.06533369f, 0.00002628f, 0.07409126f, 
    -0.10750704f, 0.02208750f, -0.31035405f, -0.07024288f, 0.10474496f, 0.07289132f, -0.01933897f, 0.06699353f, 
    -0.05850979f, -0.01212586f, -0.07901658f, -0.03650995f, 0.12087861f, 0.00281833f, 0.20664689f, 0.02619949f, 
    -0.18840967f, -0.04358213f, 0.05102166f, -0.04329985f, -0.05354460f, 0.00613894f, 0.02899257f, 0.01480956f, 
    -0.08880942f, -0.11137883f, -0.16089956f, 0.03836533f, -0.03438187f, 0.05921014f, 0.02890166f, -0.07624370f, 
    0.08801346f, -0.06320617f, -0.00524193f, -0.02033287f, -0.29338562f, 0.01322681f, 0.20897841f, 0.11571703f, 
    -0.11365577f, -0.14413160f, 0.07269246f, 0.05869638f, -0.05764794f, -0.02651594f, -0.05268730f, 0.01978597f, 
    -0.12441190f, -0.09375759f, -0.12117928f, -0.10639126f, 0.11348926f, 0.05801064f, -0.01178944f, -0.03408241f, 
    -0.04440503f, 0.13483006f, 0.22275208f, 0.12512915f, -0.40987396f, 0.08642887f, -0.05400217f, 0.08435288f, 
    -0.12331876f, 0.05245758f, 0.09902192f, 0.08087245f, -0.07727765f, 0.08731149f, -0.02774787f, -0.05613745f, 
    0.22051525f, 0.19022393f, 0.12327940f, 0.02352434f, -0.10281099f, -0.06336336f, -0.05093582f, -0.05183541f, 
    -0.07421596f, -0.01682766f, -0.05964174f, -0.08296912f, 0.09052095f, -0.04855878f, -0.07615317f, 0.03364837f, 
    -0.07231380f, -0.05407010f, 0.02121186f, -0.01222428f, 0.05579484f, -0.00932109f, -0.03873351f, -0.09197164f, 
    -0.02473155f, 0.03421567f, -0.02635268f, -0.09906473f, 0.01877294f, -0.00559787f, 0.01429049f, 0.06699647f, 
    0.16559832f, 0.03259570f, -0.15781803f, 0.13963029f, -0.14874870f, 0.05547654f, 0.16148065f, 0.22701612f, 
    0.04460503f, -0.01698312f, -0.01848287f, -0.09235726f, -0.14920427f, -0.02423910f, 0.07555428f, -0.11702341f, 
    0.02605819f, 0.06316476f, -0.09559666f, -0.21397325f, -0.07154542f, -0.05433040f, 0.06906145f, 0.06152964f, 
    0.05686603f, -0.05334281f, 0.07082418f, 0.03903098f, 0.05311749f, 0.06182531f, -0.05012666f, -0.16067117f, 
    0.07430280f, 0.04084287f, -0.05602281f, -0.01206060f, 0.04904635f, 0.08584213f, -0.01898903f, 0.19163480f, 
    0.21715334f, -0.09877957f, -0.12857601f, 0.26996613f, 0.01731097f, -0.04768482f, 0.03791512f, -0.07435632f, 
    -0.02873552f, 0.00900282f, 0.03429836f, 0.23855567f, 0.05511443f, 0.09991407f, -0.01577626f, -0.22276717f, 
    0.08007853f, -0.01272905f, 0.08480924f, -0.03468108f, 0.05674952f, -0.05312454f, -0.00577262f, 0.06239807f, 
    -0.06888042f, 0.37069643f, 0.11274236f, 0.07427581f, -0.04569086f, 0.02614571f, -0.01041564f, -0.08385956f, 
    -0.08183669f, 0.02527932f, 0.13361411f, -0.01822543f, -0.15024850f, -0.06456439f, 0.01132564f, 0.03845942f, 
    0.10676229f, -0.08383404f, 0.04646071f, -0.00487611f, -0.05153077f, -0.04110027f, 0.11440770f, 0.03813432f, 
    -0.02509047f, 0.15490517f, -0.14673549f, 0.19132933f, 0.18040611f, 0.11210313f, -0.02855684f, -0.03400904f, 
    -0.06494705f, 0.05054386f, -0.03524433f, -0.03880315f, 0.04356346f, -0.19784760f, -0.05891275f, -0.05816926f, 
    -0.05880890f, 0.05388262f, -0.02430567f, 0.05231927f, -0.05478025f, -0.10252150f, 0.09133770f, 0.10984832f, 
    0.18867914f, -0.11728909f, 0.06967293f, -0.08752766f, 0.12177110f, 0.03474573f, 0.02117884f, 0.02143761f, 
    -0.03296494f, 0.10350693f, -0.00486463f, 0.07508106f, -0.17269401f, -0.17088050f, 0.19354039f, -0.10275708f, 
    -0.09317753f, -0.04207899f, -0.06146278f, 0.09398955f, 0.02642494f, 0.03142144f, 0.09550272f, 0.00412414f, 
    -0.16625218f, 0.02530349f, 0.01435641f, 0.21701348f, -0.05306901f, 0.04073660f, 0.01334261f, 0.02829141f, 
    -0.01852095f, 0.17610127f, -0.09216207f, 0.00807048f, -0.46073991f, 0.26533794f, -0.03308108f, -0.18757702f, 
    0.10545512f, 0.09811747f, 0.03702141f, 0.10628614f, 0.01644651f, 0.06202048f, -0.14818750f, -0.00328067f, 
    -0.28734216f, 0.18638396f, -0.00814281f, -0.12440643f, 0.14875545f, -0.11341958f, 0.07690226f, 0.05910509f, 
    0.08884346f, 0.04884157f, -0.01656628f, 0.02883172f, 0.37169799f, -0.01809623f, -0.04122860f, 0.09543609f, 
    0.06645066f, -0.02335444f, 0.13129176f, 0.00772833f, -0.03797468f, 0.09920965f, 0.03645237f, -0.03252799f, 
    0.04335556f, -0.07712572f, -0.01491720f, 0.28431028f, -0.00022718f, -0.06194368f, 0.04233631f, 0.07349224f, 
    0.06511194f, 0.05082244f, -0.02689672f, 0.14765336f, 0.15805185f, -0.06768811f, 0.12097694f, 0.13622713f, 
    -0.04752125f, -0.08066826f, 0.03717550f, -0.14508216f, -0.02112003f, -0.14133319f, 0.06416970f, 0.08448645f, 
    0.08599780f, 0.19458954f, 0.04313887f, -0.09057637f, -0.03748332f, 0.08907341f, 0.15886213f, 0.07418757f, 
    -0.00732297f, -0.00784484f, 0.03948696f, -0.07870856f, -0.01047164f, 0.11143026f, -0.01102415f, -0.05413697f, 
    0.15253837f, 0.08030927f, 0.13558775f, -0.04231930f, 0.00616797f, -0.09349383f, -0.02890123f, 0.11074231f, 
    -0.15361913f, -0.06441755f, 0.01975432f, -0.06568760f, -0.06001217f, -0.00036875f, -0.11361890f, -0.06270782f, 
    0.11714299f, 0.13224292f, 0.04118979f, 0.34089929f, -0.01796061f, 0.10504788f, -0.03424426f, -0.05764480f, 
    0.20023786f, -0.07527521f, 0.00557002f, -0.04956580f, 0.09603857f, -0.14291672f, -0.08659814f, -0.17272876f, 
    0.07065419f, 0.23128466f, -0.01029331f, 0.05567891f, -0.03485580f, 0.02686704f, -0.00606615f, 0.00562664f, 
    -0.13870002f, -0.06024666f, -0.05347233f, -0.00532003f, -0.01289334f, -0.04793454f, 0.04664183f, 0.22935326f, 
    0.02018630f, -0.04924233f, 0.08165577f, 0.03952611f, -0.16346972f, 0.00556520f, 0.03584495f, 0.02954129f, 
    -0.18595617f, 0.16098830f, 0.15875581f, 0.25125670f, -0.04622425f, -0.02129509f, -0.12846513f, 0.14735113f, 
    -0.11692734f, 0.05699844f, 0.20292500f, 0.12905905f, 0.05737992f, 0.08261140f, -0.12518910f, -0.04554064f, 
    0.02676996f, -0.05707589f, -0.03062122f, 0.00026406f, 0.06365225f, 0.03346961f, 0.26166326f, 0.05022776f, 
    0.11526144f, 0.00081820f, 0.06163278f, 0.06628533f, 0.08173124f, -0.00559794f, 0.10852586f, -0.10586192f, 
    -0.09068533f, -0.12394008f, -0.07285023f, -0.17569797f, -0.19200113f, -0.21984200f, 0.22904478f, 0.10503665f, 
    0.04354383f, 0.03762456f, 0.04494726f, 0.05204228f, 0.03161643f, 0.02741514f, 0.06362972f, -0.04071396f, 
    -0.39007756f, 0.02664364f, 0.28868970f, 0.34034249f, -0.06630971f, -0.03424587f, 0.11408428f, 0.05183477f, 
    0.01085106f, 0.17067410f, -0.03701920f, 0.13995932f, 0.15660952f, 0.08959841f, 0.07688276f, -0.11550516f, 
    0.07029923f, 0.01625803f, -0.01134006f, 0.03448181f, 0.09937362f, 0.07471023f, -0.09065070f, -0.00034589f, 
    -0.12866382f, 0.14954144f, -0.00467975f, -0.09498681f, 0.14882267f, -0.09629356f, -0.00086122f, -0.03428161f, 
    -0.16531770f, -0.17775211f, 0.10671455f, 0.12302314f, 0.31477758f, -0.04730511f, -0.01764828f, 0.01725878f, 
    0.00874626f, 0.17804305f, -0.13255581f, 0.02343177f, -0.17323697f, 0.04649123f, 0.04902910f, 0.06773051f, 
    -0.17343096f, 0.17121920f, 0.04843013f, 0.04198876f, 0.02997107f, -0.08284391f, -0.20758981f, 0.00052877f, 
    0.06976601f, 0.04496387f, -0.07360506f, 0.06955000f, 0.04310919f, -0.16910875f, -0.08427143f, 0.04086728f, 
    0.06621427f, -0.02581559f, 0.04317617f, -0.16756029f, 0.07081039f, -0.10921995f, -0.08872035f, 0.03420366f, 
    0.05317051f, -0.14195670f, 0.11099228f, 0.30270359f, 0.06436823f, -0.04652178f, -0.01485254f, 0.02612611f, 
    -0.05022862f, 0.02703623f, 0.03463202f, -0.02611192f, -0.07350191f, -0.21441250f, -0.00613189f, 0.18401687f, 
    -0.04209722f, -0.07334003f, -0.05405826f, -0.12899934f, -0.02713246f, -0.02042357f, -0.03217437f, -0.05303724f, 
    -0.05973235f, 0.00712864f, 0.13386904f, -0.00627414f, -0.09059233f, 0.01167641f, 0.00515413f, 0.02857926f, 
    -0.03791942f, -0.03703903f, -0.12960130f, -0.24942328f, -0.06466629f, 0.01452815f, -0.17445008f, 0.13030347f, 
    -0.11307581f, -0.03940179f, 0.00772018f, -0.06727922f, 0.05610600f, 0.08401793f, -0.04717986f, -0.00343580f, 
    -0.16609283f, -0.04924792f, 0.00300263f, -0.18829578f, 0.07757633f, 0.00704186f, 0.07179724f, -0.00629370f, 
    0.01918244f, 0.02796336f, -0.00552807f, 0.01889871f, 0.36703423f, 0.08426193f, 0.11536724f, 0.10056255f, 
    0.10772881f, 0.12897572f, -0.03339345f, 0.06864253f, 0.01377339f, 0.02364228f, 0.00266047f, 0.01898692f, 
    0.25369248f, 0.02190704f, 0.35575476f, 0.03688930f, -0.09105399f, 0.04024070f, 0.14283681f, 0.03538652f, 
    0.07860336f, -0.09982202f, 0.01957726f, -0.02090899f, -0.08936882f, 0.01690825f, -0.04127685f, -0.15445806f, 
    0.17057426f, -0.08727883f, 0.00193155f, 0.04754578f, 0.08404287f, -0.00716427f, -0.17409007f, -0.07025924f, 
    -0.17332785f, 0.09314846f, 0.02414829f, -0.08808970f, 0.02438170f, -0.10994888f, -0.02114936f, -0.07558740f, 
    -0.00766075f, -0.00455824f, 0.05803011f, -0.06146005f, 0.14665598f, 0.08953590f, -0.17611966f, -0.03888053f, 
    0.11070472f, 0.02104822f, 0.04348429f, -0.11104769f, -0.04085204f, -0.01035292f, -0.04461212f, 0.00278059f, 
    0.33075684f, 0.23549142f, 0.11209745f, -0.14210497f, 0.05582311f, 0.07336825f, 0.11481497f, -0.04816880f, 
    -0.02520667f, -0.23786587f, -0.05383161f, -0.05700751f, 0.46041468f, 0.05728234f, 0.05297201f, 0.00271709f, 
    -0.07465617f, -0.01235270f, -0.00476002f, 0.05428769f, -0.06237708f, -0.01306244f, 0.01345971f, 0.14298339f, 
    0.19319101f, -0.11482184f, -0.09760947f, 0.09037394f, -0.09777060f, 0.08580019f, 0.08057035f, -0.00041408f, 
    0.03625250f, 0.14571780f, 0.03465540f, 0.04338283f, -0.25597090f, 0.10109685f, 0.11513614f, 0.06854759f, 
    -0.05965508f, 0.04667750f, -0.05761027f, -0.06958903f, 0.00292725f, -0.05309211f, -0.06793714f, -0.01461155f, 
    -0.00176143f, -0.00021468f, 0.17872964f, -0.08389897f, -0.03879907f, 0.09126952f, -0.00314569f, -0.09013195f, 
    -0.00913819f, 0.10230978f, 0.10789343f, -0.09849333f, 0.19758819f, 0.05642773f, -0.04579130f, -0.17569934f, 
    -0.04626472f, 0.06754223f, -0.02258831f, 0.18583839f, 0.09005937f, 0.18707183f, -0.09737854f, 0.02501377f, 
    0.02980757f, -0.03994555f, -0.06053456f, 0.04952454f, -0.07116599f, -0.06607368f, 0.03342447f, -0.04692784f, 
    -0.00666014f, 0.00742759f, 0.01497338f, -0.00361827f, -0.05763420f, -0.03682598f, 0.00258367f, 0.04635886f, 
    -0.07568556f, 0.03750243f, -0.05344245f, -0.04123820f, 0.00962240f, -0.03320236f, -0.02386182f, -0.05564436f, 
    0.04585999f, -0.08317457f, 0.02812320f, -0.00951516f, -0.07374118f, 0.02253678f, -0.06700461f, -0.07310727f, 
    -0.02917845f, -0.04532908f, -0.01945663f, -0.03688698f, -0.07638484f, -0.01539651f, -0.06937204f, 0.00493096f, 
    -0.00316550f, -0.07462769f, -0.08480555f, 0.05223205f, -0.02524760f, -0.04226429f, -0.04853772f, -0.03026937f, 
    -0.00304658f, 0.03209492f, -0.02998524f, 0.01924768f, 0.02546249f, -0.03783529f, -0.01235939f, -0.08478969f, 
    -0.06196376f, -0.04170840f, 0.04143795f, 0.05342393f, 0.03614404f, 0.01253135f, 0.04917592f, -0.02642615f, 
    0.00584095f, 0.01677899f, -0.03334678f, -0.00139138f, 0.06029056f, 0.03623558f, -0.07931527f, -0.04308215f, 
    -0.07366785f, -0.02367282f, 0.04134636f, 0.01707339f, -0.07881593f, -0.02816531f, -0.00477998f, -0.05998612f, 
    0.01922880f, 0.00539083f, 0.00800497f, 0.05242924f, -0.00184828f, -0.04678470f, 0.04544305f, 0.00401835f, 
    -0.07429699f, -0.06000159f, 0.02971539f, 0.04213386f, -0.06905480f, -0.04780024f, -0.08086456f, 0.01480281f, 
    0.05371095f, -0.05144972f, -0.07678713f, 0.05724852f, -0.04556074f, 0.06048641f, 0.01995758f, 0.03987882f, 
    -0.02712763f, -0.03661079f, -0.05838332f, -0.00143531f, 0.00863191f, 0.03675048f, 0.01726784f, 0.03454977f, 
    0.04324459f, 0.04707446f, -0.03011907f, 0.05684816f, -0.04672779f, -0.03006265f, -0.01282054f, -0.01226752f, 
    0.03335726f, 0.05521709f, 0.00030528f, -0.03292647f, -0.02744494f, -0.06397250f, -0.01028777f, 0.04966924f, 
    -0.06569574f, 0.01998295f, -0.00237316f, 0.02829438f, -0.03490672f, 0.03291340f, -0.07035398f, 0.02632281f, 
    -0.07226470f, 0.05251849f, -0.00368591f, 0.02136960f, -0.03455291f, -0.07675255f, -0.06888758f, 0.05341069f, 
    0.05564284f, 0.06014469f, -0.04811297f, 0.05684807f, -0.03592102f, -0.00008524f, -0.05987675f, -0.05787271f, 
    0.03426158f, 0.05895235f, 0.02534362f, 0.01656558f, -0.01852020f, -0.06611138f, 0.04052690f, 0.03667061f, 
    0.04927988f, -0.03083919f, 0.01005804f, -0.01592691f, -0.06445193f, 0.04659292f, -0.00173058f, 0.00983332f, 
    -0.02786035f, 0.05435114f, -0.04197205f, -0.03030155f, -0.01258834f, -0.05333433f, 0.04272445f, -0.01829080f, 
    -0.03715634f, -0.00446331f, -0.01429847f, -0.03780365f, 0.02161214f, -0.02830842f, 0.00780964f, -0.05871145f, 
    0.01894254f, -0.07072157f, -0.00920154f, -0.07186803f, -0.06020519f, -0.07104518f, 0.04525006f, 0.00370270f, 
    -0.01944799f, -0.07572260f, 0.04363769f, 0.03095938f, 0.01675222f, -0.03444073f, -0.04715818f, -0.01642208f, 
    -0.00917542f, -0.03775940f, 0.03298309f, 0.02273741f, -0.02581401f, 0.02765506f, -0.05213259f, 0.01221799f, 
    -0.06770150f, 0.05814539f, -0.04657225f, -0.05497403f, 0.05349737f, -0.04263052f, -0.06593589f, -0.08200590f, 
    -0.06832968f, 0.01777034f, 0.03860283f, -0.05727709f, 0.04347447f, 0.04343894f, -0.02082931f, -0.03357122f, 
    0.00117863f, 0.01428931f, -0.04555554f, -0.06112599f, 0.03639459f, -0.00139971f, -0.05073538f, 0.04991925f, 
    0.02477402f, 0.00671107f, -0.04043183f, -0.05724105f, 0.00607402f, 0.01745846f, 0.03151605f, -0.05532992f, 
    0.02285285f, -0.00128799f, 0.00899713f, -0.02303567f, -0.00791662f, 0.02555974f, 0.05583773f, -0.04064678f, 
    0.04655588f, 0.01766097f, 0.02872250f, -0.03209263f, 0.00473525f, -0.07300290f, -0.02361724f, -0.03306144f, 
    0.01968430f, -0.07703618f, 0.04431581f, -0.06108776f, -0.01901124f, -0.03504407f, -0.06152369f, -0.03379911f, 
    -0.06230974f, -0.06191066f, -0.06398825f, 0.06364889f, 0.00127662f, -0.00494039f, -0.02978153f, 0.03046749f, 
    -0.01942350f, -0.04611034f, 0.05140185f, 0.01036041f, -0.07430840f, 0.04251715f, -0.06885615f, -0.05019584f, 
    -0.03982788f, 0.05381962f, 0.02211540f, -0.05263967f, 0.01283994f, 0.04409694f, 0.01331329f, 0.04101597f, 
    0.05661551f, 0.03307611f, 0.01786219f, -0.04808212f, -0.03375876f, -0.02366691f, 0.01405602f, -0.03990557f, 
    0.00872686f, -0.04753089f, 0.06247133f, -0.00570310f, -0.01848920f, -0.02754761f, -0.00643379f, -0.04226428f, 
    -0.02925743f, 0.05413629f, -0.06397514f, -0.07183892f, -0.07398566f, -0.00691143f, -0.05885535f, -0.03473476f, 
    0.01130765f, 0.00871547f, 0.03037334f, 0.04818033f, -0.06940121f, 0.03284742f, 0.05027466f, -0.02489867f, 
    0.00762483f, -0.01580494f, -0.02986897f, -0.06262255f, 0.04843368f, -0.04061493f, 0.05204754f, 0.00140649f, 
    0.05878922f, -0.05089858f, 0.00134360f, -0.01194418f, 0.00622170f, 0.03169987f, -0.06512089f, -0.00764973f, 
    -0.07848175f, -0.06064983f, -0.01810913f, -0.02895336f, -0.00531823f, 0.01628566f, -0.00018502f, -0.07119631f, 
    -0.00747311f, -0.07359708f, -0.03065308f, 0.00333927f, 0.02794475f, -0.06492712f, 0.05011248f, 0.04900238f, 
    -0.03850133f, -0.05068561f, 0.02123401f, 0.01230796f, -0.07625962f, -0.06788093f, 0.01140204f, 0.02614008f, 
    -0.00750293f, 0.01617518f, 0.01174588f, 0.02908066f, 0.01386606f, -0.06529202f, 0.03754628f, -0.06684380f, 
    0.04144274f, -0.02491860f, 0.05471265f, -0.05256233f, 0.05454580f, -0.02620064f, 0.04092399f, 0.04462598f, 
    0.01788794f, -0.07697280f, 0.03860303f, -0.03938452f, -0.05517192f, 0.01300424f, 0.03855412f, 0.00795116f, 
    -0.41516936f, 0.33493975f, 0.17132363f, -0.23038593f, 0.07426558f, 0.07009943f, -0.02210759f, -0.07120129f, 
    -0.05333514f, 0.10513461f, 0.06716114f, -0.07433231f, -0.26955441f, -0.13694662f, 0.11793462f, -0.29857251f, 
    0.22156252f, -0.06475597f, -0.11910068f, -0.04819062f, 0.01234183f, -0.01992746f, 0.02139876f, -0.06932615f, 
    -0.08014988f, 0.12105210f, -0.07567570f, -0.01793024f, 0.02454551f, 0.10851987f, 0.11256328f, -0.01933828f, 
    -0.01873893f, 0.05652719f, 0.04065389f, 0.11347719f, -0.04737213f, 0.15125002f, -0.06408221f, -0.12634662f, 
    0.13045381f, -0.01625369f, -0.01239405f, -0.05297741f, -0.02795421f, 0.02300571f, -0.02102388f, -0.08858071f, 
    -0.05408721f, -0.01359580f, -0.05042323f, -0.01382332f, 0.03300315f, 0.00439420f, -0.06409847f, 0.08145311f, 
    0.08601085f, -0.03365739f, -0.05626766f, 0.04271748f, 0.03244505f, -0.11951788f, -0.12865005f, 0.18901904f, 
    -0.01730832f, 0.06446335f, 0.04521425f, 0.12992299f, -0.05601005f, -0.07165181f, 0.05918390f, 0.04946281f, 
    0.11088710f, -0.15998581f, 0.33076057f, 0.05029708f, -0.22675039f, -0.05471072f, 0.08807084f, -0.07445188f, 
    -0.07307009f, -0.08079916f, -0.02762424f, 0.13634962f, -0.16867068f, 0.20080496f, -0.11374214f, 0.06168536f, 
    0.13189045f, 0.00269883f, -0.08861915f, -0.09839398f, -0.00621398f, -0.09215022f, 0.11679427f, 0.05223788f, 
    -0.15275154f, 0.13237150f, 0.19079340f, 0.27763322f, 0.02356574f, 0.06925882f, 0.09364712f, 0.01478476f, 
    -0.03856372f, 0.05509891f, 0.02863682f, 0.02330730f, 0.15312839f, 0.03024935f, 0.04977793f, 0.01018076f, 
    0.16224883f, 0.05906417f, -0.02894506f, 0.00164102f, -0.15962479f, 0.00697369f, 0.02179473f, -0.00816658f, 
    0.07302358f, 0.05922969f, 0.05718476f, -0.02569910f, 0.03804116f, 0.07933456f, 0.09801341f, 0.00854773f, 
    0.04600281f, 0.14183702f, -0.10259488f, -0.03871200f, 0.66472977f, -0.26316631f, 0.12705994f, 0.07050513f, 
    -0.07749259f, -0.09825302f, -0.07988596f, -0.07128248f, 0.15277822f, -0.00603573f, 0.10332389f, -0.01172945f, 
    -0.20204146f, -0.08789020f, 0.05697266f, -0.05719483f, 0.05164529f, 0.01685555f, -0.10268939f, 0.03079732f, 
    0.12721781f, -0.05124671f, 0.14244053f, 0.03357895f, -0.11556126f, 0.06389126f, 0.02006868f, -0.00693816f, 
    -0.02010347f, 0.07317393f, 0.07192964f, -0.05892759f, -0.03306952f, 0.05536220f, 0.03746765f, -0.02004870f, 
    -0.11171231f, 0.04855802f, -0.09170678f, -0.00252383f, 0.04917840f, 0.11120825f, 0.01806134f, -0.03058771f, 
    0.00672250f, 0.11656208f, 0.03361423f, 0.00073716f, 0.26211274f, -0.07233325f, -0.13912031f, -0.09092712f, 
    0.13674600f, 0.09305193f, 0.00020140f, 0.14114112f, 0.06075470f, -0.03711052f, -0.05678562f, 0.00014289f, 
    0.18176335f, -0.03065469f, -0.02497441f, 0.14999525f, -0.00783178f, -0.11383943f, -0.02980035f, 0.09038583f, 
    0.18186392f, 0.04643056f, -0.03534323f, -0.07589981f, 0.19207019f, 0.05783195f, -0.18989354f, -0.03124859f, 
    -0.07669670f, 0.02759633f, 0.04349301f, 0.10302042f, 0.08795002f, -0.01192696f, -0.04039369f, 0.16038989f, 
    0.22907935f, -0.10964707f, -0.06912632f, -0.15935457f, -0.19770171f, 0.00924837f, -0.09953257f, 0.15489615f, 
    0.12137148f, 0.04365585f, -0.06845823f, 0.18608880f, 0.13501613f, -0.05850724f, 0.07137940f, 0.04349957f, 
    0.06191447f, -0.09640729f, -0.14664574f, 0.05856524f, 0.15541835f, -0.05271735f, -0.02878212f, -0.19727916f, 
    0.24208453f, -0.29494670f, -0.02536451f, 0.01081081f, 0.01962475f, 0.11999131f, 0.18257302f, 0.10883743f, 
    0.01120053f, 0.02576081f, -0.05642234f, 0.00823099f, -0.00232599f, -0.02801228f, 0.03132582f, 0.01448275f, 
    -0.16683967f, 0.10502614f, -0.18255472f, 0.12208956f, 0.04235462f, 0.05090866f, -0.11680625f, -0.08285147f, 
    -0.01211299f, -0.03726599f, 0.11249551f, -0.18802355f, 0.00790586f, -0.31694719f, -0.05653984f, 0.13225254f, 
    0.15446165f, -0.01121061f, 0.46364373f, 0.06986193f, 0.30741563f, 0.09271117f, -0.02193072f, -0.09843879f, 
    0.12995040f, -0.13009785f, -0.05875835f, 0.18977727f, 0.27779409f, 0.10441018f, 0.07326360f, -0.09379105f, 
    -0.06778630f, -0.03475023f, 0.02780574f, -0.08209872f, -0.10242651f, 0.13699980f, -0.05871912f, 0.07170925f, 
    0.01384159f, -0.00443323f, 0.05913892f, -0.08608624f, 0.21468230f, 0.28248331f, -0.14650090f, 0.03165996f, 
    -0.05592674f, 0.06387006f, -0.00242842f, -0.08858117f, 0.21431409f, 0.09656150f, 0.11234054f, -0.02315668f, 
    0.09170060f, -0.10345169f, 0.03251182f, 0.03373681f, 0.00663651f, -0.07940472f, 0.22794680f, -0.07248913f, 
    0.00443414f, 0.05294874f, 0.02845497f, 0.01560480f, 0.28770617f, -0.10995719f, -0.12222839f, 0.03734034f, 
    0.08762486f, 0.27052918f, 0.04178140f, 0.06521783f, 0.01237018f, 0.00963053f, 0.02093095f, 0.06516208f, 
    0.01932630f, -0.21094328f, -0.08873820f, 0.11201949f, 0.22888443f, 0.10897387f, 0.11653292f, 0.13109306f, 
    0.09154600f, -0.07704525f, 0.28110802f, 0.13395229f, -0.05995819f, 0.13466766f, 0.15240464f, -0.19969299f, 
    -0.04055448f, 0.00051126f, -0.16456515f, 0.04811719f, -0.11294825f, 0.03030355f, 0.17510296f, 0.13613518f, 
    0.27658165f, -0.05294235f, 0.03418497f, 0.08774686f, 0.02684096f, -0.05211315f, -0.05575082f, -0.01948674f, 
    -0.02351126f, -0.05233466f, -0.01187819f, -0.06519332f, -0.30325505f, 0.07715346f, 0.06100545f, -0.16641238f, 
    0.06696498f, -0.03358458f, 0.08338306f, 0.08841565f, 0.11688135f, -0.04100395f, -0.02454081f, 0.09528439f, 
    0.01240488f, 0.02012646f, 0.02333843f, 0.01341950f, 0.02730830f, 0.02601527f, 0.00016569f, -0.06435201f, 
    -0.07171515f, 0.01287138f, 0.02868702f, -0.02312320f, 0.00026317f, 0.06113558f, 0.01325136f, -0.05381025f, 
    0.00528284f, -0.04756992f, -0.03475039f, 0.03663495f, 0.03439197f, -0.03905782f, -0.00097333f, -0.02367483f, 
    -0.02709885f, -0.02840089f, -0.04003422f, -0.02460118f, -0.06804439f, 0.03639047f, -0.07696477f, -0.03300605f, 
    0.03952923f, 0.04441474f, 0.03721645f, 0.02427554f, -0.05058308f, 0.03620833f, 0.00085458f, -0.07099124f, 
    -0.00334764f, 0.05613536f, -0.06982835f, 0.04524915f, -0.05022638f, 0.02282633f, -0.06353425f, -0.05608467f, 
    -0.02715521f, 0.06059928f, 0.00289984f, -0.04890788f, -0.00639587f, -0.00522774f, -0.02305673f, -0.05442081f, 
    0.03810359f, -0.05595111f, -0.05447448f, 0.03708741f, -0.08204759f, -0.07698112f, -0.05695473f, -0.02280475f, 
    -0.01884314f, 0.01001185f, 0.00989050f, 0.04147314f, 0.04785001f, -0.03396085f, -0.01623830f, -0.07375023f, 
    -0.04802591f, 0.01633350f, 0.05256537f, 0.02362761f, 0.00863701f, 0.04191563f, 0.06678136f, 0.04873790f, 
    -0.02065406f, -0.00963971f, -0.02615190f, 0.03216217f, 0.03611812f, -0.02802186f, -0.02083844f, -0.02055268f, 
    -0.06362846f, -0.01861078f, -0.07268092f, 0.03488335f, 0.00692347f, -0.06489187f, -0.00577119f, -0.07352223f, 
    -0.05203199f, -0.06293005f, -0.06264834f, -0.04035825f, -0.03260823f, -0.06827613f, 0.04847651f, 0.01535471f, 
    0.02142325f, -0.02984750f, -0.02443315f, -0.06893827f, 0.03420782f, -0.00362834f, 0.04775660f, 0.05921081f, 
    -0.00083703f, 0.01744862f, 0.06060971f, 0.00684551f, -0.07211075f, 0.04604452f, 0.00002866f, 0.03694740f, 
    -0.03105408f, -0.07597917f, 0.05440689f, 0.04552232f, 0.04089939f, -0.06517746f, -0.02991792f, 0.05897290f, 
    -0.04862268f, 0.05803927f, -0.05456016f, -0.02141758f, -0.04264230f, 0.00471867f, -0.04895707f, -0.03070258f, 
    -0.02318230f, -0.07092751f, -0.00672042f, 0.02564979f, -0.02311272f, -0.03525118f, 0.01160979f, 0.06162306f, 
    -0.00207942f, -0.02940707f, -0.02683134f, 0.01700361f, 0.05156044f, -0.04739264f, -0.03166940f, 0.00655044f, 
    -0.05526330f, -0.04606877f, -0.07565731f, -0.06497221f, 0.04875898f, 0.02716685f, 0.01612477f, 0.01045074f, 
    -0.07338759f, -0.06081490f, 0.04985655f, 0.04922466f, -0.05065617f, -0.07727026f, -0.00266054f, -0.06970467f, 
    -0.06638418f, 0.04742690f, -0.01157899f, -0.05510379f, 0.00650171f, -0.00257477f, -0.01605594f, 0.01404712f, 
    -0.00637209f, -0.00303926f, -0.06082892f, -0.02573455f, 0.00683420f, -0.02377708f, 0.04564412f, 0.05704998f, 
    -0.00626058f, -0.05355010f, 0.02222057f, 0.02344987f, -0.07172795f, 0.05311225f, 0.00902690f, -0.02070006f, 
    0.12144271f, -0.04904795f, -0.04123984f, -0.12014794f, 0.01329644f, 0.05515227f, 0.08071908f, 0.02027047f, 
    0.05079367f, -0.05584833f, 0.06927395f, 0.07001277f, -0.14376804f, 0.00459501f, -0.08021297f, 0.01969471f, 
    0.01311524f, 0.00401441f, -0.02873631f, 0.05714155f, -0.03496430f, -0.02734739f, -0.05065771f, 0.21198457f, 
    0.22251865f, -0.00866000f, -0.01867347f, 0.19841792f, -0.04837741f, 0.03751475f, 0.04096791f, -0.12703064f, 
    0.04634060f, -0.00893094f, 0.10673715f, 0.17071255f, 0.00251681f, 0.10352212f, -0.03397803f, -0.13814411f, 
    -0.04060704f, 0.01454401f, 0.15096158f, 0.01709716f, 0.09244791f, -0.02353578f, 0.08209240f, 0.08448937f, 
    -0.08598348f, 0.11097023f, 0.09201701f, 0.10414952f, 0.12425285f, 0.01876774f, -0.00684216f, -0.13103025f, 
    -0.00743393f, -0.04699454f, 0.12136963f, 0.11498818f, 0.04958016f, -0.03921060f, 0.06797026f, -0.07764065f, 
    0.00865074f, -0.01821554f, 0.06517624f, 0.04973174f, 0.02203154f, -0.03259654f, -0.05113752f, 0.09721864f, 
    0.11816549f, 0.01051008f, -0.16876176f, 0.00532218f, 0.10881244f, 0.09871704f, 0.04126299f, -0.02536229f, 
    0.00795779f, 0.05525934f, -0.00841555f, -0.11664042f, 0.15616633f, -0.12194759f, -0.05210362f, -0.05867160f, 
    -0.04098819f, 0.02466844f, -0.11882718f, 0.14147536f, 0.07745455f, 0.06317864f, 0.15067929f, -0.08770544f, 
    0.23524819f, -0.13194016f, 0.04482939f, 0.12099733f, 0.04901699f, 0.12992004f, 0.15211448f, -0.03216480f, 
    0.04966014f, -0.00754253f, 0.00132206f, -0.00025158f, -0.33114892f, -0.08499951f, 0.13607331f, 0.02960936f, 
    -0.05791277f, -0.01439819f, -0.04746702f, 0.02716383f, 0.00046928f, 0.01017357f, -0.02660637f, -0.08093375f, 
    -0.08768135f, -0.05610264f, -0.03323004f, 0.04996546f, -0.09376647f, -0.00970160f, 0.07089972f, -0.11424162f, 
    0.01387200f, 0.10053021f, -0.01074245f, 0.12418304f, -0.29163697f, 0.23324990f, 0.00810413f, -0.04749744f, 
    0.03358296f, -0.01005843f, 0.05054043f, 0.00367262f, -0.04634847f, 0.14593060f, -0.05609509f, 0.01073457f, 
    -0.22411749f, 0.04378193f, -0.14221676f, -0.15086675f, 0.02712983f, -0.08735055f, 0.03492354f, -0.06780564f, 
    0.03378478f, -0.04628400f, 0.04620815f, -0.08754563f, 0.38431776f, -0.07209865f, 0.02503755f, 0.13302639f, 
    0.04141720f, 0.04643683f, 0.01575281f, -0.00569273f, -0.12058285f, 0.19541597f, 0.04270961f, 0.02996671f, 
    0.00630112f, -0.03154994f, 0.14929955f, 0.21857670f, -0.06395217f, 0.04233918f, 0.02544947f, 0.04034821f, 
    0.03169849f, -0.03348904f, 0.01611841f, 0.04182354f, 0.22617403f, 0.18873295f, 0.15341501f, 0.09668706f, 
    -0.07899903f, -0.02433240f, 0.13243394f, -0.03391273f, 0.04887836f, -0.11880410f, 0.05662027f, 0.04688554f, 
    0.13733286f, 0.07673603f, 0.16005556f, 0.22350538f, -0.03996174f, 0.00165583f, 0.04934040f, 0.17424272f, 
    -0.01068824f, 0.03860478f, 0.03050866f, 0.09154818f, 0.22791488f, 0.16438290f, -0.08099518f, 0.16380848f, 
    -0.21776140f, 0.15804850f, -0.04328390f, -0.01461113f, 0.17562155f, 0.06069599f, 0.05036498f, -0.18018498f, 
    -0.14642420f, -0.01307713f, 0.04503542f, -0.05074131f, -0.04769074f, -0.06906220f, -0.14683843f, 0.18377411f, 
    -0.12344434f, -0.12459227f, -0.13974778f, -0.08308099f, 0.05770722f, -0.03438655f, 0.05676505f, 0.12082108f, 
    -0.23983824f, -0.05701480f, -0.14612979f, 0.01533995f, -0.01612021f, 0.07390792f, 0.05284268f, 0.02447566f, 
    0.02876291f, -0.06260764f, -0.08194368f, -0.01817286f, -0.11657569f, 0.03421887f, 0.11537549f, -0.03883776f, 
    -0.12171782f, 0.03742645f, -0.05435780f, -0.06741794f, 0.18486536f, 0.28480396f, 0.09773303f, 0.04965780f, 
    0.05502171f, 0.07012133f, -0.05755103f, 0.06469490f, -0.00073349f, 0.16005753f, -0.07706299f, 0.08010475f, 
    -0.00856903f, 0.01687570f, 0.15301694f, -0.10965998f, -0.04696930f, -0.01405255f, -0.00025062f, -0.00636109f, 
    0.05199768f, -0.10292224f, 0.05749681f, 0.05287142f, 0.03727983f, 0.10531054f, 0.10043466f, 0.00846470f, 
    -0.00712796f, -0.14404327f, 0.03727655f, 0.01790526f, -0.01292239f, 0.15297142f, -0.06366722f, 0.09997189f, 
    -0.29639381f, 0.07770715f, -0.26460356f, 0.12077668f, -0.06869174f, 0.03982256f, -0.16641216f, 0.00126839f, 
    0.12324025f, -0.00808040f, 0.06381516f, -0.10989921f, -0.00933285f, 0.17961232f, -0.05348405f, -0.08679526f, 
    -0.02783147f, 0.05535268f, 0.07708520f, -0.03624723f, -0.00178103f, 0.09060883f, 0.01574793f, 0.00822052f, 
    0.19605017f, 0.03622579f, 0.15605778f, -0.25511456f, 0.06258643f, -0.02056146f, 0.07858433f, -0.10123702f, 
    -0.00010350f, -0.10297754f, 0.24592547f, -0.01910644f, 0.33003372f, -0.08937734f, 0.13557136f, 0.04264689f, 
    -0.20512815f, 0.14648513f, 0.09912997f, 0.00038697f, -0.03661752f, -0.10515088f, 0.13260321f, 0.05373704f, 
    0.33898178f, 0.04066224f, 0.09795540f, 0.20381047f, -0.13195950f, 0.18553111f, -0.02920192f, 0.09988311f, 
    -0.01379678f, 0.03704319f, -0.05186363f, 0.05610127f, -0.37128627f, 0.15945078f, -0.00960472f, 0.01445427f, 
    -0.11585618f, 0.08275010f, -0.07217240f, -0.17883109f, -0.05410062f, -0.07261037f, -0.00205350f, -0.08116032f, 
    -0.01317266f, -0.00432436f, 0.14886008f, -0.34825951f, 0.10858326f, 0.02090022f, -0.03271187f, -0.03066442f, 
    0.05448973f, 0.01339702f, 0.01206242f, 0.05233688f, -0.31603226f, 0.05766237f, -0.10492746f, -0.05801842f, 
    -0.00547352f, 0.12589516f, -0.13836150f, 0.08247779f, -0.06830794f, 0.08328392f, -0.01023461f, -0.02762894f, 
    0.02151297f, 0.23042932f, 0.13243315f, 0.07706334f, 0.25950900f, 0.00766224f, -0.00479889f, -0.12133605f, 
    0.12310462f, 0.02865922f, 0.06530584f, -0.03338616f, -0.00591763f, 0.07607652f, 0.03370950f, 0.07466487f, 
    0.13401987f, -0.00558280f, -0.05367701f, -0.07381249f, 0.02519726f, 0.02297841f, -0.07545840f, 0.10876660f, 
    0.11615106f, -0.11710139f, -0.10042246f, -0.07435147f, -0.04899390f, 0.09267399f, -0.01329637f, 0.07671035f, 
    0.14362718f, 0.08926041f, 0.10927232f, 0.33886421f, 0.05498307f, -0.06608752f, 0.00072038f, 0.15761141f, 
    0.17187388f, -0.05646081f, -0.10012632f, -0.23398763f, 0.01040870f, -0.15917093f, -0.07667889f, -0.12082054f, 
    0.12335474f, 0.27418566f, -0.02842289f, -0.07389084f, 0.02616250f, -0.06405635f, -0.01345417f, 0.09361947f, 
    -0.12716796f, -0.00258667f, -0.00069423f, 0.07643072f, 0.24063258f, 0.00391760f, 0.03785733f, 0.24485463f, 
    0.03699466f, -0.00855136f, 0.17420752f, 0.17458352f, -0.18991727f, -0.11095693f, -0.08138942f, -0.03988391f, 
    -0.07196921f, 0.16548429f, 0.00545589f, 0.06672920f, 0.13613980f, -0.05529184f, -0.02881082f, 0.16243191f, 
    -0.17988648f, -0.05407408f, 0.20051955f, 0.14053360f, 0.05356772f, 0.15426765f, -0.10952314f, 0.07418300f, 
    0.07662429f, 0.04045760f, -0.23617169f, -0.05949124f, 0.10468276f, 0.01533083f, 0.30895904f, -0.11871371f, 
    0.14413577f, 0.11001977f, -0.03565409f, -0.01816641f, 0.10345731f, 0.17006987f, 0.08860762f, -0.15571743f, 
    0.15551756f, -0.05108796f, -0.26002476f, -0.14069299f, 0.31701180f, -0.09553707f, -0.03841612f, 0.10912067f, 
    0.11677304f, 0.05420189f, -0.10232232f, -0.05327049f, -0.08919327f, 0.04192821f, 0.01517403f, 0.00747697f, 
    -0.11962841f, 0.29474261f, -0.02304178f, 0.08321816f, -0.19034308f, 0.03622615f, 0.12661628f, 0.16387950f, 
    -0.02501361f, 0.13673097f, 0.02747823f, -0.01945843f, 0.21760023f, -0.17300780f, 0.13824403f, -0.18915443f, 
    0.15273102f, 0.13624670f, 0.07444602f, 0.09823981f, 0.00044273f, 0.02620998f, 0.00774690f, 0.03780003f, 
    -0.11649580f, -0.00396950f, 0.00113181f, -0.13973071f, 0.03922326f, -0.11801907f, 0.00315473f, -0.08820332f, 
    -0.06794634f, -0.14491056f, 0.09856131f, -0.00439930f, 0.07413137f, 0.15094405f, 0.04047066f, -0.06410754f, 
    0.00332058f, 0.15264857f, -0.17255268f, 0.12630732f, -0.19821465f, 0.08837856f, 0.09425491f, 0.08574700f, 
    -0.05757018f, 0.24452876f, -0.13376103f, 0.10588249f, -0.00715676f, -0.17519630f, -0.19566178f, 0.04253289f, 
    0.07364410f, -0.03315930f, 0.06771810f, 0.02818875f, 0.09956460f, 0.06815094f, -0.11026169f, 0.01354689f, 
    -0.05088964f, -0.02982137f, -0.06983361f, -0.14958091f, 0.03711675f, -0.06203204f, 0.01001686f, -0.06877888f, 
    0.12111517f, -0.15342936f, 0.07812376f, 0.21955772f, -0.00154163f, 0.01782206f, 0.09473849f, 0.01513710f, 
    -0.00171142f, 0.07004155f, 0.04584100f, 0.02361149f, -0.00682931f, -0.12081029f, -0.11244999f, 0.29863331f, 
    -0.05604462f, 0.13228594f, -0.08516074f, -0.00636942f, 0.04434012f, 0.05315780f, -0.08353138f, -0.05040139f, 
    -0.13864365f, 0.08576874f, 0.22840157f, -0.14477719f, -0.02173809f, 0.01097455f, -0.01976013f, 0.16700634f, 
    -0.02304179f, -0.05053807f, 0.04350920f, -0.04663700f, 0.03639261f, -0.08189595f, -0.11957789f, 0.16567491f, 
    -0.06420918f, -0.04939328f, -0.11794431f, 0.04725453f, 0.06818828f, 0.07424957f, 0.01482461f, -0.05471148f, 
    -0.12383832f, -0.01540396f, 0.01849538f, -0.25137079f, 0.12546720f, -0.08750747f, 0.01109285f, 0.05836609f, 
    0.01955744f, -0.05514478f, -0.01663911f, -0.04025170f, 0.37434185f, -0.03317410f, 0.07818986f, 0.11163772f, 
    -0.04993989f, -0.02043297f, -0.09467998f, 0.01269944f, -0.01189594f, 0.01206786f, -0.07548185f, 0.07372193f, 
    -0.00608808f, -0.00058334f, 0.15331243f, -0.02264517f, 0.01503577f, -0.14246610f, 0.00416487f, 0.12435062f, 
    0.04176015f, -0.03608571f, 0.01359727f, 0.01103993f, 0.13463624f, 0.08930838f, -0.10738917f, -0.08944987f, 
    -0.00967610f, -0.05103365f, 0.06691409f, -0.16070196f, 0.11783184f, -0.00421956f, 0.08835949f, 0.00652645f, 
    -0.03840458f, 0.13973171f, -0.13689633f, -0.00004276f, -0.21749988f, -0.01109953f, -0.02460946f, -0.01849388f, 
    0.00003392f, -0.06444899f, 0.10935415f, -0.07352350f, -0.00052830f, 0.23673400f, -0.08775800f, 0.01143578f, 
    0.04381064f, 0.04496705f, 0.03263239f, -0.07996400f, 0.08422414f, -0.03875409f, -0.00307443f, -0.05920308f, 
    0.06248404f, -0.00677122f, 0.10221872f, 0.03180134f, 0.06936260f, -0.00784529f, 0.08564767f, 0.10206084f, 
    -0.00036633f, -0.08557794f, 0.09448659f, 0.09508389f, 0.39394724f, -0.28780118f, 0.13219078f, 0.03597287f, 
    -0.08262178f, 0.05653134f, 0.00790844f, 0.11885880f, 0.00810103f, -0.04057501f, -0.00460858f, -0.02888662f, 
    0.30422416f, -0.05022502f, -0.12577520f, 0.10615948f, -0.11203172f, 0.00276405f, -0.08728738f, 0.07253196f, 
    0.03038719f, 0.15272087f, 0.06929564f, 0.08596207f, -0.27294803f, 0.13533375f, 0.01212696f, 0.00968637f, 
    0.03634792f, 0.02930249f, -0.06079626f, -0.12337355f, 0.11479025f, 0.04313246f, -0.10634689f, 0.05044210f, 
    -0.02561112f, 0.09251548f, 0.07649991f, -0.35190123f, 0.01236971f, -0.02217500f, 0.04384698f, -0.03739055f, 
    0.07954430f, -0.04475184f, 0.00833424f, 0.02473938f, -0.03232309f, 0.20983705f, -0.19337717f, -0.24087662f, 
    0.07592600f, 0.13650991f, 0.04939568f, 0.06608092f, 0.03998697f, 0.09785583f, -0.02496202f, -0.11168539f, 
    0.26146036f, -0.22771555f, -0.19178665f, 0.41037053f, 0.27274576f, -0.11928514f, 0.01850660f, -0.07972498f, 
    0.07092304f, -0.06863002f, -0.03968335f, 0.06755535f, 0.03538220f, -0.09134121f, -0.18631202f, 0.09881368f, 
    -0.05021590f, 0.04559669f, -0.08506829f, -0.03956886f, -0.00875640f, -0.11578487f, 0.01256049f, 0.04958923f, 
    0.12287044f, -0.16734876f, -0.14465323f, -0.00158139f, -0.12440439f, 0.14134997f, 0.01325436f, 0.04302979f, 
    0.06198513f, -0.06749520f, 0.03523896f, -0.08943715f, -0.11213650f, -0.14911985f, 0.10216909f, 0.32594311f, 
    0.11336016f, -0.00296704f, -0.05045645f, 0.01392053f, -0.04826745f, 0.03778908f, -0.06290291f, 0.02113813f, 
    0.04341498f, -0.16621396f, -0.10984462f, -0.08034272f, 0.02436295f, 0.05344907f, 0.06770171f, 0.08204532f, 
    0.00314395f, 0.08315353f, -0.10574575f, -0.01660684f, -0.08918434f, 0.23053004f, 0.08274569f, -0.00120678f, 
    -0.07125877f, 0.08302128f, -0.10899562f, 0.02546259f, 0.04445821f, 0.02067265f, -0.01043960f, -0.11609565f, 
    0.17603609f, 0.01460464f, 0.03833947f, -0.00126042f, -0.06163184f, 0.05597580f, 0.05401780f, 0.06295241f, 
    0.08065499f, 0.08165336f, 0.17384338f, -0.11430181f, 0.15474461f, 0.04431021f, -0.14817907f, -0.03924428f, 
    0.10014868f, 0.10470355f, 0.07968854f, -0.05751751f, 0.02312115f, 0.06028711f, -0.14408265f, -0.00068274f, 
    0.12940361f, 0.08726089f, 0.13279843f, -0.26992074f, -0.14632824f, 0.10647105f, -0.11192427f, 0.07999235f, 
    0.09359248f, 0.12829402f, -0.00969580f, -0.05003285f, 0.16651885f, 0.14969546f, -0.14600466f, 0.04420000f, 
    0.00279381f, 0.07096231f, 0.01735508f, -0.02087309f, 0.07643765f, 0.02205198f, 0.02348590f, -0.06698138f, 
    0.26917034f, -0.05615874f, 0.07735209f, 0.17404445f, -0.18950322f, -0.18818250f, 0.05798635f, 0.00634777f, 
    -0.03678533f, -0.16690673f, -0.05839292f, -0.10044013f, -0.09229289f, 0.08187548f, 0.02871402f, -0.10228281f, 
    0.18152015f, 0.19614159f, 0.02416648f, 0.17645237f, -0.02439137f, -0.05938829f, -0.05768546f, 0.04424440f, 
    0.08724422f, -0.23125888f, -0.08288945f, -0.04152269f, 0.02290613f, -0.03898937f, 0.13276419f, 0.11066233f, 
    0.08061289f, 0.13583806f, 0.02935048f, 0.11047371f, -0.22056052f, -0.00049348f, 0.01241315f, 0.10698140f, 
    -0.00673084f, 0.03500361f, -0.06680100f, 0.12189153f, 0.11792094f, -0.06201548f, -0.03661218f, 0.06102096f, 
    0.27968296f, -0.01464457f, 0.02552241f, 0.12976776f, -0.07034612f, -0.12677954f, 0.01290999f, -0.09603348f, 
    -0.13764571f, -0.01995905f, 0.13834594f, 0.00997016f, -0.19216865f, 0.16590020f, -0.03941576f, -0.00723967f, 
    0.05842020f, -0.06749103f, 0.12053897f, 0.14644171f, 0.04143981f, 0.03173742f, 0.03180569f, 0.06653355f, 
    0.13522395f, -0.00254949f, 0.36404347f, -0.14546995f, -0.17488256f, 0.06074805f, 0.05780844f, -0.09999505f, 
    0.09234443f, 0.06982940f, 0.01114698f, 0.08902406f, 0.10059022f, 0.14595863f, 0.07312154f, 0.21282715f, 
    -0.03008448f, -0.09157867f, -0.04893814f, -0.10859573f, 0.02190748f, -0.00570881f, -0.02521692f, 0.09192624f, 
    -0.12004890f, -0.02051776f, 0.07313447f, -0.02299558f, 0.10713650f, -0.05306021f, 0.12975156f, -0.06872712f, 
    -0.10790184f, 0.10011321f, -0.10001869f, -0.02189321f, 0.23036528f, 0.31014201f, 0.06067930f, -0.05169905f, 
    -0.22784474f, -0.13782784f, -0.02614574f, 0.06250677f, 0.09775528f, 0.08013120f, 0.01709791f, 0.13692819f, 
    -0.29317725f, -0.07001727f, 0.10091974f, 0.04029185f, 0.04478825f, -0.04456351f, 0.04260093f, -0.05981354f, 
    0.20124789f, 0.01298038f, -0.08069857f, 0.06450742f, 0.22382773f, -0.19530404f, -0.23079005f, -0.27039164f, 
    0.11305855f, 0.08096589f, -0.02085390f, 0.03413280f, 0.20411737f, -0.04456219f, -0.01874664f, -0.01675707f, 
    -0.05971292f, -0.22967325f, -0.16927719f, -0.37606752f, -0.00920802f, -0.01431463f, 0.02503832f, -0.02280993f, 
    0.08710864f, -0.15755205f, 0.08462980f, -0.00044694f, -0.07393244f, 0.01478629f, 0.32791460f, -0.12390835f, 
    -0.05317216f, -0.19992891f, -0.02061620f, 0.08382748f, 0.02963563f, 0.05678984f, -0.00021390f, -0.00453208f, 
    -0.09230045f, 0.09066857f, -0.03814604f, 0.26897255f, 0.03580600f, -0.03839682f, -0.06214122f, 0.07214940f, 
    -0.06767391f, -0.03113184f, 0.16726395f, -0.10033439f, -0.07919170f, 0.07956202f, 0.10632180f, 0.12171771f, 
    -0.16264971f, -0.03307557f, -0.15186769f, -0.05152468f, 0.08085664f, 0.09178645f, 0.00317885f, 0.11630303f, 
    -0.10160251f, -0.21449463f, -0.24720819f, -0.36801401f, 0.22886853f, -0.02359539f, 0.18916316f, 0.08047567f, 
    0.05838764f, -0.11129984f, -0.06737918f, 0.17123003f, 0.04714230f, -0.18794264f, -0.15133736f, -0.18925209f, 
    0.09969907f, -0.00077435f, -0.09860890f, 0.16216433f, -0.04086336f, -0.02687539f, -0.00714041f, -0.02653705f, 
    0.18718775f, 0.10709614f, -0.00036791f, 0.10872272f, 0.04588339f, 0.04476893f, 0.06783792f, -0.16705187f, 
    0.12813939f, 0.03504265f, 0.10332259f, 0.15460634f, 0.00871683f, 0.02811197f, -0.17140193f, 0.21026453f, 
    -0.03086771f, -0.13670282f, -0.07632174f, -0.02524938f, 0.06982346f, -0.09035330f, 0.12527159f, -0.07628365f, 
    -0.27297637f, -0.03075591f, 0.26332697f, 0.02204817f, 0.05557754f, -0.04728673f, 0.06195698f, 0.02114643f, 
    0.10305040f, 0.05863709f, -0.15117718f, -0.08300559f, 0.00546996f, 0.06141526f, -0.00601730f, 0.05456800f, 
    0.04339080f, -0.05308749f, -0.12014300f, 0.11501845f, 0.05180170f, 0.01411069f, 0.12966976f, 0.09928623f, 
    0.14403637f, -0.31522930f, -0.24369764f, 0.08075586f, 0.14977892f, -0.04043591f, -0.12766096f, -0.04110607f, 
    0.08254126f, 0.05292496f, -0.03138642f, 0.09727678f, -0.05140018f, -0.02014172f, 0.13280848f, -0.18320674f, 
    -0.07362390f, -0.04015762f, -0.02679166f, -0.06557057f, 0.08936741f, 0.06610136f, 0.04892193f, -0.07329300f, 
    0.29018477f, 0.04564637f, -0.09731395f, 0.39549610f, -0.01634178f, 0.02848242f, -0.01284105f, 0.07579178f, 
    0.07500807f, -0.10136538f, 0.06360280f, -0.15295032f, -0.17391819f, -0.10301886f, 0.33448502f, 0.04199362f, 
    0.00741810f, 0.15511531f, -0.01949592f, -0.02590114f, -0.08847581f, 0.13079494f, 0.07369578f, 0.19426958f, 
    0.16334948f, -0.11303326f, 0.03815510f, 0.09417725f, -0.01274922f, 0.14677545f, 0.01567942f, 0.03042511f, 
    0.05281348f, 0.03183958f, 0.18018621f, 0.05006728f, -0.44194210f, 0.13334790f, -0.03632522f, -0.08462652f, 
    0.02614879f, 0.04858044f, 0.11453345f, -0.02692302f, 0.11034006f, 0.07715687f, 0.07480951f, 0.03657769f, 
    0.03398798f, -0.05935870f, -0.23290491f, -0.01028083f, 0.09812535f, 0.19808564f, 0.11043363f, -0.03148378f, 
    0.02379425f, 0.13592835f, -0.26511759f, -0.05127758f, -0.08268634f, -0.01087305f, 0.07112879f, 0.19397482f, 
    0.04531333f, 0.11929173f, 0.01684929f, -0.13970010f, 0.01598688f, 0.03693202f, -0.26021382f, -0.01330446f, 
    0.09020747f, -0.00976942f, -0.05564817f, -0.05714022f, 0.09387249f, -0.05192670f, -0.03362526f, 0.15764730f, 
    0.00041879f, 0.04684580f, -0.00019332f, 0.28512412f, -0.13329184f, 0.02121221f, -0.05771179f, 0.00185012f, 
    -0.17103100f, -0.01304798f, -0.01978430f, 0.11777985f, 0.02884065f, 0.04470875f, -0.01670693f, 0.14188513f, 
    0.27943707f, 0.05516568f, -0.21742053f, 0.04261292f, -0.01213862f, -0.06278971f, -0.09082107f, 0.02907153f, 
    0.08572945f, -0.10716068f, 0.03829606f, -0.04806039f, -0.37461644f, 0.24606352f, -0.04786320f, -0.05189532f, 
    0.05158189f, -0.08993846f, -0.00816676f, -0.02982772f, -0.03472816f, -0.12752235f, -0.09327414f, -0.18062523f, 
    0.09531696f, -0.14243415f, 0.09857636f, -0.19531369f, -0.02158288f, -0.17919095f, 0.09132814f, -0.01585871f, 
    0.09279547f, 0.05363080f, -0.20266113f, -0.00809627f, -0.11256762f, -0.01957725f, -0.10840347f, 0.16035648f, 
    -0.07221637f, -0.05871926f, 0.18052952f, 0.07948400f, 0.18181846f, -0.08554878f, -0.17708451f, 0.02976032f, 
    0.19106407f, -0.18732226f, -0.02788992f, 0.13607191f, 0.00341204f, 0.03230796f, 0.14565219f, -0.00519668f, 
    0.04271645f, -0.11364366f, 0.17957288f, 0.08342479f, 0.07637569f, 0.04711746f, 0.23500934f, 0.17094347f, 
    0.02924147f, -0.08608534f, -0.02201657f, -0.04814336f, -0.10563750f, 0.02954925f, 0.06816582f, 0.07379409f, 
    0.21617189f, -0.13029976f, 0.12336010f, 0.04636041f, 0.08220287f, -0.02003687f, 0.06730843f, -0.08002654f, 
    0.03508084f, 0.01076103f, -0.06729147f, 0.01116581f, 0.23792964f, 0.11662327f, 0.08703519f, 0.39747509f, 
    0.00745425f, 0.05854324f, -0.07461255f, 0.00037231f, 0.06029348f, 0.06746209f, 0.05238019f, -0.06276205f, 
    -0.12387277f, -0.01376585f, 0.12070394f, 0.01952345f, -0.07214115f, 0.13528003f, 0.08346248f, 0.18343011f, 
    -0.05839782f, 0.00951735f, 0.05821514f, 0.11729621f, 0.12435751f, 0.06518780f, 0.28655818f, 0.12223516f, 
    0.01214659f, 0.01904629f, -0.15668845f, 0.06080155f, 0.02035884f, -0.01641621f, 0.06892201f, -0.00628785f, 
    0.05737722f, -0.21294631f, 0.05825770f, -0.04264704f, 0.07503667f, 0.06836279f, 0.16476744f, 0.00357357f, 
    0.03099163f, 0.02401569f, 0.09436125f, 0.05717089f, -0.13391437f, -0.06021373f, -0.04780329f, 0.18438290f, 
    -0.11793863f, 0.00006353f, 0.04755882f, -0.02287087f, -0.01443875f, 0.04017170f, -0.08427800f, -0.03497720f, 
    -0.14851093f, -0.06887295f, 0.01347046f, -0.04300789f, -0.01836261f, -0.03502027f, 0.01749772f, 0.26307380f, 
    0.00399857f, -0.06896791f, -0.05527057f, 0.06445283f, 0.20562483f, 0.14986722f, 0.01551190f, 0.16270499f, 
    -0.09124586f, 0.03260250f, 0.02667601f, -0.11593053f, 0.10512542f, 0.10735213f, -0.00361361f, -0.00729855f, 
    0.00309286f, 0.06608883f, -0.13312292f, 0.00155832f, -0.10486686f, -0.03328305f, 0.03200338f, 0.01780690f, 
    -0.00167625f, -0.01583635f, 0.08827771f, 0.02642534f, -0.25658506f, 0.36915052f, 0.08151405f, 0.20087434f, 
    0.00819720f, 0.09265611f, 0.00784512f, -0.04727905f, 0.02795081f, 0.06991473f, -0.00241103f, 0.03600298f, 
    -0.07895800f, -0.10454871f, 0.06287492f, 0.13687170f, -0.14775276f, -0.10782550f, 0.00441729f, 0.06422734f, 
    0.01352365f, -0.01048231f, 0.22437227f, -0.04089980f, 0.28420159f, -0.26953423f, -0.03625154f, 0.05933497f, 
    -0.01879427f, 0.13592046f, 0.04092380f, 0.12648933f, -0.01613044f, -0.06609327f, 0.03976154f, -0.08755185f, 
    0.44020775f, -0.07718571f, 0.08083061f, 0.07528184f, -0.11721214f, -0.04080849f, -0.12172278f, -0.04349833f, 
    0.01669373f, 0.04671887f, 0.09844038f, 0.10096338f, -0.33146489f, 0.01410116f, -0.09453992f, 0.00035232f, 
    -0.03029356f, 0.08598713f, -0.00134903f, 0.00277866f, 0.06175503f, 0.01052439f, -0.12736571f, 0.04592974f, 
    -0.03258323f, 0.05845891f, -0.05810483f, -0.35102579f, 0.02881682f, -0.01957787f, 0.09552838f, -0.01021401f, 
    0.15743092f, 0.04498515f, -0.01743515f, 0.00993199f, -0.20112172f, 0.30077207f, -0.05908822f, 0.00157093f, 
    0.21546701f, 0.03632602f, -0.01070962f, -0.05656174f, 0.07659725f, 0.03002247f, 0.12051155f, 0.00311394f, 
    -0.02173766f, -0.33406639f, -0.29409495f, 0.26316857f, 0.16724768f, -0.08736962f, -0.09695230f, -0.08466060f, 
    0.06153773f, 0.10537978f, 0.05702240f, 0.06547610f, -0.04419631f, -0.10477182f, -0.03987923f, 0.16556093f, 
    -0.06533963f, -0.20857912f, -0.16963354f, 0.09889480f, -0.01347181f, -0.05536764f, 0.00186525f, 0.05396811f, 
    0.19453335f, -0.07556837f, -0.01337691f, 0.27978447f, -0.05752539f, 0.11756457f, -0.02481589f, 0.01589905f, 
    0.09703321f, 0.00378889f, 0.04264174f, -0.12578484f, -0.22231273f, -0.17638445f, -0.13034609f, 0.06602490f, 
    -0.03788320f, 0.00581540f, 0.04795882f, 0.10952996f, -0.00184190f, 0.12264802f, 0.19317207f, 0.04936805f, 
    0.10851087f, 0.08466292f, 0.06915686f, -0.02397721f, 0.07633533f, -0.02652849f, -0.01201439f, 0.00970471f, 
    0.09370939f, 0.03574213f, 0.12748362f, 0.07093342f, -0.09650123f, -0.05408841f, 0.25825810f, 0.01316532f, 
    -0.06446920f, -0.01158967f, 0.03895694f, -0.05331756f, -0.04063896f, 0.02071564f, 0.09196931f, 0.03402467f, 
    0.12147563f, -0.07008941f, 0.07306192f, -0.21367042f, -0.04571191f, 0.07327164f, -0.00697216f, -0.06101609f, 
    0.04045073f, 0.06622803f, -0.05205247f, -0.07846899f, 0.18511771f, -0.06126378f, -0.08713851f, -0.03607179f, 
    0.09784139f, 0.17633443f, -0.18482406f, 0.07852504f, 0.09683527f, 0.01164115f, -0.14136700f, -0.07274885f, 
    0.37478802f, 0.10639507f, 0.13398376f, -0.20650998f, 0.10768197f, 0.03853478f, -0.03977390f, 0.11206929f, 
    0.02585587f, 0.15597861f, 0.05739186f, 0.31999046f, -0.08989786f, 0.01863237f, -0.13124938f, 0.17846133f, 
    0.01681244f, -0.04234331f, -0.18485847f, -0.00290028f, 0.05550826f, 0.11922635f, 0.12229156f, 0.01802709f, 
    0.00547886f, 0.32528880f, 0.04877724f, -0.07608750f, -0.16186069f, -0.09999736f, -0.06237655f, -0.02186968f, 
    -0.02701141f, -0.09291815f, 0.00797137f, -0.11193769f, -0.25944427f, 0.22976187f, -0.10306755f, -0.02732243f, 
    0.22901118f, -0.05822117f, -0.07110093f, 0.08583422f, -0.03749734f, -0.08926653f, -0.06892613f, 0.01917809f, 
    -0.01587700f, -0.06253611f, -0.15160626f, -0.10341228f, 0.09206866f, -0.08488166f, 0.04509814f, -0.02232126f, 
    0.05236666f, -0.01333382f, 0.08070645f, 0.03755722f, 0.09133694f, 0.01360252f, 0.18746303f, -0.05791408f, 
    0.10579732f, 0.05658357f, -0.01537328f, 0.13291347f, -0.03494329f, 0.11359797f, 0.01749732f, 0.08816788f, 
    0.16560318f, -0.04047431f, 0.07493036f, 0.25907201f, -0.10169976f, 0.00417292f, 0.19613157f, -0.01888433f, 
    -0.00833499f, -0.00460578f, 0.15121534f, -0.01913733f, 0.22751549f, 0.11346272f, 0.17585984f, -0.07320894f, 
    0.03665564f, 0.02105724f, 0.00010817f, -0.01728025f, 0.02753855f, 0.04497623f, 0.14288646f, 0.09167810f, 
    -0.20752697f, 0.20591475f, 0.04562106f, -0.06979899f, 0.11370322f, 0.04252307f, 0.06823675f, 0.08228573f, 
    0.02947219f, -0.02120929f, 0.03567592f, 0.01474486f, -0.26681948f, -0.02589732f, 0.03551135f, -0.17902847f, 
    -0.07239407f, 0.00202005f, -0.02543242f, -0.01574800f, -0.08422561f, -0.00119441f, -0.04139792f, 0.00268588f, 
    0.20270687f, 0.01503658f, -0.04638515f, -0.00696617f, -0.01927736f, 0.04345570f, -0.00274836f, 0.03823031f, 
    0.18025944f, 0.02809772f, -0.03021092f, 0.13996874f, -0.23774834f, -0.02108547f, 0.18152311f, -0.00174566f, 
    0.06159712f, -0.08745205f, -0.13075939f, 0.06188708f, -0.00847842f, -0.07134249f, -0.05892672f, -0.08490907f, 
    0.01445980f, -0.23257104f, -0.08347297f, 0.04206664f, 0.06039257f, -0.04597267f, 0.04801489f, 0.14450985f, 
    0.01185955f, 0.05565683f, -0.17918694f, -0.13684523f, 0.11195923f, 0.04916925f, -0.13849057f, 0.15916747f, 
    -0.04947887f, 0.02722814f, -0.01453071f, 0.01305303f, -0.10022206f, 0.00902020f, -0.05533775f, 0.03608725f, 
    0.28269956f, -0.07696712f, 0.10140432f, 0.11970643f, -0.22681081f, -0.16989437f, -0.08395179f, 0.10628303f, 
    -0.01193597f, -0.06146829f, 0.26872200f, 0.06228629f, -0.06401335f, 0.31372124f, -0.12406534f, 0.00738346f, 
    0.09924740f, -0.08956080f, -0.04735277f, -0.06924210f, 0.17886436f, 0.01115609f, 0.10029639f, -0.02141404f, 
    -0.38556930f, 0.16420828f, 0.09608600f, 0.17380139f, -0.00431050f, 0.02345471f, -0.01044506f, 0.08767445f, 
    0.05270076f, -0.01520818f, 0.02063621f, -0.07502863f, -0.08434124f, 0.24459217f, -0.06207436f, -0.04052713f, 
    0.01963027f, 0.00778498f, -0.03209433f, -0.01649573f, -0.04160101f, 0.01906955f, -0.03625763f, -0.06512430f, 
    0.15196015f, -0.06923608f, 0.05836153f, 0.09392026f, -0.13802963f, -0.03289862f, 0.23098032f, -0.13236256f, 
    0.02980287f, 0.14541610f, 0.05868023f, -0.09069607f, 0.41462398f, -0.09949373f, 0.08781493f, -0.03258068f, 
    -0.03409188f, 0.06087655f, 0.00888051f, 0.08393628f, 0.02437025f, -0.03386786f, 0.11287981f, -0.01547197f, 
    -0.23103978f, -0.27913362f, 0.03930376f, -0.11440674f, -0.03099568f, 0.11763627f, -0.00992439f, 0.11241475f, 
    0.09556934f, -0.09122285f, 0.08200403f, 0.05847472f, -0.19740416f, 0.13659866f, 0.00303195f, 0.03326910f, 
    0.00660116f, 0.06169947f, -0.11838993f, -0.08437202f, -0.08358885f, 0.08971306f, 0.10025575f, 0.00353805f, 
    0.13249934f, 0.13303661f, -0.01282597f, 0.02655852f, 0.02704783f, -0.07309298f, -0.00094577f, 0.08176150f, 
    -0.07350250f, 0.12074062f, -0.08189071f, 0.00484608f, 0.17368613f, 0.05741595f, -0.15503207f, 0.06650984f, 
    0.09816410f, -0.08207712f, 0.08599455f, 0.13570686f, 0.11521757f, 0.02432124f, -0.06438501f, 0.06490438f, 
    0.05238537f, -0.27808589f, 0.02977475f, 0.33523479f, 0.16124083f, -0.04653155f, -0.10132702f, -0.08624487f, 
    -0.10811294f, 0.08449104f, -0.01975584f, -0.04094478f, 0.05416502f, -0.14818954f, -0.03073023f, 0.33335707f, 
    -0.04498128f, 0.06793115f, 0.00600689f, 0.05382787f, 0.13043036f, -0.01417462f, 0.14518827f, -0.09308965f, 
    -0.21914841f, -0.03087300f, 0.08639407f, -0.05789197f, -0.14102338f, 0.11104672f, 0.03832116f, 0.12966454f, 
    -0.06002485f, -0.15318432f, 0.06176101f, -0.27186355f, -0.03708488f, -0.19347443f, 0.12054590f, 0.28975800f, 
    -0.02806085f, 0.08230336f, -0.00487142f, -0.03019053f, -0.17908522f, 0.01887412f, 0.11613441f, 0.08195607f, 
    0.18491203f, -0.02900389f, 0.03618058f, -0.11543358f, -0.05918650f, -0.03821509f, -0.00799140f, 0.12306672f, 
    0.09829137f, -0.00431609f, 0.01325991f, 0.10968734f, 0.02745771f, 0.17909734f, 0.14900823f, 0.11355410f, 
    -0.11082772f, -0.03057934f, -0.04087956f, 0.01394764f, 0.07179046f, -0.04618680f, 0.04524120f, 0.07111327f, 
    -0.09288990f, 0.00292411f, 0.20670943f, 0.07897929f, 0.04139126f, 0.10175120f, 0.02073193f, 0.04461150f, 
    0.04710820f, -0.01916778f, -0.18331383f, 0.01076921f, 0.01146488f, 0.06914442f, 0.02615199f, 0.06237219f, 
    0.08588982f, -0.01316920f, 0.01596712f, -0.12737499f, -0.03653196f, 0.06147963f, -0.10461634f, -0.00577084f, 
    0.05133440f, 0.08123022f, -0.08626723f, -0.11707409f, -0.08905249f, -0.13656461f, -0.07948612f, 0.06342382f, 
    0.01556370f, -0.03872417f, 0.09152155f, 0.13418004f, -0.04895499f, -0.04829067f, -0.06221133f, 0.02887760f, 
    -0.00989782f, 0.00346009f, 0.00162739f, 0.00397177f, 0.09286857f, -0.07670214f, 0.13246442f, 0.04292445f, 
    0.32387629f, 0.16416721f, 0.07681166f, 0.14885598f, 0.01530208f, 0.05120216f, -0.26042715f, 0.19430682f, 
    -0.07263381f, -0.15389392f, -0.01835791f, -0.03329042f, 0.03855507f, -0.13831906f, 0.10396128f, 0.01039586f, 
    0.05606956f, -0.07151847f, 0.03676111f, 0.04515431f, 0.04149858f, -0.12916794f, -0.06417334f, 0.04079018f, 
    0.43799567f, -0.05474199f, 0.00377645f, 0.15008299f, 0.02260531f, -0.02065977f, 0.05939889f, 0.02072173f, 
    0.09948952f, 0.17492485f, -0.06298850f, 0.04768597f, -0.28947681f, -0.11471947f, -0.00529792f, 0.00850400f, 
    -0.10544015f, -0.09591404f, 0.12165078f, -0.01815161f, 0.11207510f, -0.08353336f, -0.11228762f, 0.17109179f, 
    0.07783492f, 0.12061228f, -0.00593831f, -0.25706929f, -0.04758542f, 0.02604130f, 0.03225321f, 0.03633019f, 
    0.07490741f, -0.05506449f, 0.11201108f, 0.01902413f, -0.20484997f, -0.04968785f, 0.00415074f, -0.19651258f, 
    0.03922107f, 0.06049057f, -0.05554011f, -0.00538329f, -0.07234121f, 0.12104920f, 0.06381301f, 0.07168640f, 
    -0.19810273f, -0.01102894f, -0.19795345f, -0.04905085f, 0.26153278f, -0.03189469f, 0.06148316f, 0.02758908f, 
    -0.00472003f, 0.09440362f, 0.04402113f, -0.00551861f, -0.24441539f, -0.21868864f, -0.15641506f, -0.34152603f, 
    0.01976105f, -0.09953894f, -0.20360933f, -0.00447499f, 0.02146786f, -0.03065137f, 0.03713819f, 0.04559914f, 
    0.06656833f, -0.13116038f, -0.15468448f, 0.06387992f, 0.00140460f, 0.08573787f, -0.03566153f, -0.11714794f, 
    0.20859601f, 0.01485950f, -0.00796465f, -0.19267580f, -0.18851344f, -0.07371067f, -0.19924641f, 0.07683339f, 
    0.06814979f, 0.08532273f, 0.06435174f, 0.03796276f, -0.04174132f, 0.05049523f, 0.01468913f, 0.09639247f, 
    -0.27780679f, 0.09082286f, 0.05971615f, -0.15853257f, 0.03899911f, -0.14310513f, -0.02964854f, 0.10530803f, 
    0.03352286f, -0.07091589f, -0.04629194f, -0.00185584f, 0.05693130f, 0.04137300f, 0.14727339f, 0.22381838f, 
    -0.07270003f, -0.11502270f, 0.16152218f, 0.04525102f, -0.07310236f, 0.06035960f, 0.07140483f, -0.01215326f, 
    0.06369881f, -0.01830711f, 0.06894488f, 0.03853212f, -0.14075556f, 0.03830400f, 0.01850987f, 0.00148880f, 
    -0.00158878f, -0.00548340f, -0.01796698f, -0.01522925f, -0.07994475f, 0.05916698f, -0.15407078f, -0.03378334f, 
    0.28595266f, 0.10043382f, 0.00367048f, 0.00896217f, -0.01670583f, 0.06262288f, 0.00287320f, -0.03209089f, 
    0.21728897f, 0.16515598f, 0.29598996f, -0.07779284f, 0.03499015f, 0.09592147f, -0.02665274f, 0.08613110f, 
    0.02655517f, 0.02437656f, -0.06442060f, 0.25406376f, 0.39210942f, -0.13690071f, -0.18519858f, 0.01278869f, 
    0.17141970f, 0.06591163f, -0.05157805f, -0.03976863f, 0.07417882f, -0.03223801f, 0.12478159f, 0.03977837f, 
    0.11860597f, 0.27232629f, 0.03856107f, 0.04194649f, -0.23070461f, -0.14604068f, -0.05962969f, 0.07732330f, 
    0.06327575f, 0.00013031f, -0.11870176f, -0.11991676f, 0.24392967f, 0.03297662f, 0.12698710f, -0.18639185f, 
    0.10473215f, -0.00011519f, -0.01145833f, -0.00488065f, -0.01412257f, -0.07711300f, -0.02761965f, -0.02385766f, 
    -0.17646849f, -0.12033159f, -0.13213640f, -0.27018741f, 0.08595561f, -0.02787681f, 0.02905636f, 0.07410061f, 
    0.13952935f, -0.02795669f, 0.01599905f, 0.06707665f, -0.13233525f, 0.07666416f, 0.02794269f, 0.00292039f, 
    0.10611320f, 0.01642733f, 0.04771475f, 0.16737625f, -0.09116930f, -0.00798613f, 0.04510277f, 0.10025555f, 
    0.05398824f, -0.04403523f, -0.01293465f, 0.22350490f, -0.02566783f, 0.07473790f, 0.05104301f, -0.00949304f, 
    -0.04259067f, -0.08153109f, 0.18884513f, -0.01309096f, 0.03205630f, 0.09014045f, -0.12383045f, -0.05838190f, 
    -0.00146708f, -0.03790934f, 0.02666642f, 0.02126084f, 0.13319813f, 0.21946572f, 0.05163078f, 0.07228315f, 
    0.13496031f, 0.05075728f, -0.00166134f, -0.01302076f, -0.00984208f, -0.06275277f, 0.07565092f, -0.00866114f, 
    0.00342774f, -0.01458881f, 0.06345979f, 0.08395644f, -0.07086571f, -0.05298428f, -0.15846328f, -0.11086630f, 
    -0.08022801f, 0.07028478f, -0.02427181f, -0.01411143f, -0.08871774f, 0.04762669f, -0.03528235f, 0.10086977f, 
    -0.00073584f, -0.10691647f, -0.00124675f, 0.07325350f, 0.12062815f, -0.05984366f, 0.02769662f, -0.07357570f, 
    0.02990094f, -0.00459087f, -0.04619701f, -0.08126800f, 0.19082162f, 0.15674055f, -0.27376518f, -0.12207568f, 
    -0.09151128f, -0.16454400f, -0.08248025f, -0.00835737f, 0.07173978f, 0.00427453f, -0.14041409f, 0.08605798f, 
    -0.37545967f, 0.04364208f, 0.23756158f, -0.11755137f, 0.16018686f, 0.01172950f, -0.05907650f, 0.01722596f, 
    0.07703879f, 0.06114449f, -0.04595841f, -0.00937178f, 0.50975376f, 0.10642876f, 0.11497051f, 0.06643733f, 
    0.07290602f, 0.02632969f, -0.07972212f, 0.13972585f, 0.04031674f, 0.03795521f, 0.04232630f, -0.04873228f, 
    0.14130761f, 0.16367424f, -0.03432056f, 0.24295186f, 0.18725774f, 0.06022163f, 0.14939795f, 0.04230904f, 
    0.08492399f, 0.03187992f, -0.04536784f, 0.11929636f, 0.02667696f, -0.16981387f, 0.06790080f, -0.27660179f, 
    0.01133416f, -0.03422126f, 0.00051766f, 0.06243116f, -0.03775193f, -0.06313392f, -0.01747497f, 0.03716999f, 
    -0.03534504f, -0.02642483f, 0.17201029f, -0.14107476f, -0.04687046f, 0.12761116f, 0.02246335f, 0.03010294f, 
    -0.02789630f, -0.13539058f, -0.00151738f, -0.08422510f, 0.54607099f, -0.06862225f, -0.12754942f, -0.32316679f, 
    -0.05941770f, 0.05025281f, -0.00009482f, -0.13454682f, 0.05086526f, -0.00642723f, 0.00239175f, -0.08134039f, 
    0.15600406f, 0.19546111f, 0.05545516f, 0.17570698f, 0.23896387f, 0.02895767f, 0.02841397f, 0.08361705f, 
    -0.01781230f, -0.10519870f, -0.13455541f, -0.03076304f, 0.13046028f, 0.16817085f, 0.06537559f, -0.21909955f, 
    -0.11162674f, 0.03405898f, 0.08633240f, -0.03109821f, -0.00704259f, 0.09478492f, -0.13865134f, 0.00820284f, 
    -0.26431051f, 0.21604849f, -0.13411510f, -0.01214824f, -0.01214097f, -0.01892259f, 0.06605918f, 0.04001686f, 
    0.06751083f, 0.18551591f, -0.06539187f, 0.07168044f, 0.06164008f, 0.18674594f, -0.07280680f, 0.16471477f, 
    0.12579398f, -0.10291290f, 0.10353452f, -0.00781000f, -0.03648897f, -0.10475805f, 0.11999729f, 0.01432705f, 
    -0.01820458f, -0.11659043f, 0.14309326f, 0.16581081f, 0.00267957f, 0.04628592f, -0.04308585f, -0.06882386f, 
    -0.06840458f, 0.07757520f, 0.04607374f, 0.02974563f, -0.01134342f, -0.01147017f, -0.11584683f, 0.00113291f, 
    -0.11207675f, 0.03373288f, -0.05136801f, 0.11984521f, -0.07542786f, 0.12830645f, -0.06885257f, 0.11224158f, 
    -0.18402052f, -0.25985679f, -0.08896068f, 0.01470407f, 0.18594022f, -0.01786807f, -0.10125900f, 0.03215975f, 
    -0.05078022f, -0.13419680f, -0.05265907f, -0.00538530f, -0.29421419f, -0.20689873f, -0.07707028f, -0.02474714f, 
    -0.04330472f, -0.07239643f, 0.03428790f, -0.01636532f, 0.09497623f, 0.00816779f, 0.08330290f, 0.07117556f, 
    0.09078769f, 0.15452087f, 0.10506618f, 0.16673715f, -0.15641981f, -0.03975669f, 0.02530300f, 0.03174698f, 
    0.04174481f, -0.04343043f, 0.05746728f, 0.03720043f, -0.34346890f, 0.04403419f, 0.03422578f, -0.20832367f, 
    0.06124314f, 0.07260775f, -0.04280712f, 0.01888387f, 0.01358441f, 0.00986943f, 0.04327540f, -0.02802429f, 
    0.09134033f, -0.03067951f, -0.05130238f, 0.03745509f, 0.07318477f, 0.06148976f, -0.02690912f, 0.07899955f, 
    0.00278615f, -0.03377829f, -0.05565860f, 0.07472202f, 0.03571475f, 0.09294502f, 0.04542882f, -0.07785381f, 
    0.07546387f, 0.00546820f, -0.09648142f, 0.06512117f, 0.00218585f, -0.07266464f, -0.04232122f, 0.02423834f, 
    0.32897848f, -0.14306158f, 0.12206934f, 0.06373546f, -0.24342182f, -0.09280007f, 0.06930350f, -0.24799681f, 
    0.06227398f, 0.00679534f, -0.05811652f, -0.04751560f, 0.03841210f, 0.14459176f, -0.31010094f, -0.03189733f, 
    0.06080450f, 0.01867426f, 0.04051132f, 0.02451300f, 0.05813649f, -0.09766246f, -0.27700067f, 0.05667711f, 
    -0.12505546f, 0.14788213f, 0.11662290f, -0.01827712f, 0.17873532f, -0.10302861f, -0.06548236f, 0.03639252f, 
    -0.05588224f, 0.04661237f, 0.04252744f, 0.18886799f, -0.71407878f, 0.04785964f, -0.00285177f, -0.18599409f, 
    0.19452170f, 0.14054507f, 0.03155517f, 0.11429179f, 0.03755217f, 0.11011897f, -0.05715232f, 0.02990147f, 
    0.28639385f, -0.00591505f, 0.09621581f, -0.03603362f, -0.24429832f, -0.16099565f, 0.03553481f, -0.00193191f, 
    -0.13292450f, 0.00339926f, -0.04740253f, -0.02716612f, 0.06267621f, 0.10539608f, -0.07092551f, 0.19653492f, 
    -0.07507865f, 0.03936264f, -0.01823502f, -0.08515704f, 0.08913390f, -0.03727283f, 0.00627974f, 0.00080301f, 
    -0.09079508f, -0.29263541f, -0.19508471f, 0.00136092f, 0.05153225f, 0.07674889f, 0.09765331f, 0.00753720f, 
    0.22711769f, 0.01451417f, 0.05821044f, 0.08933000f, -0.00953109f, 0.07178409f, 0.08827314f, 0.12649351f, 
    0.00015943f, 0.06067218f, 0.09969833f, 0.00845647f, 0.02881437f, 0.19368908f, -0.09359889f, 0.07252385f, 
    0.24151468f, 0.06541517f, 0.15408869f, 0.15472040f, -0.10790132f, 0.07634989f, 0.12793341f, -0.04860970f, 
    0.09658213f, 0.10835379f, 0.03117902f, -0.06890168f, 0.26818043f, -0.04307772f, 0.05335204f, -0.15949813f, 
    0.06181334f, 0.08260938f, 0.14833711f, 0.08940969f, -0.11670439f, 0.03242443f, 0.00746400f, 0.14515498f, 
    -0.33059722f, 0.36755002f, 0.12275624f, -0.31554392f, 0.02233508f, -0.01403138f, 0.09711199f, -0.05393020f, 
    0.03885202f, 0.07838821f, 0.07949930f, 0.05045400f, -0.16892211f, -0.01685881f, 0.25636140f, -0.27613294f, 
    0.20851740f, 0.00574168f, -0.12436663f, -0.06920666f, -0.09980571f, 0.09310876f, 0.03211438f, -0.05725500f, 
    -0.05275618f, 0.02601323f, -0.17561615f, -0.03639901f, 0.19947354f, 0.09878072f, 0.10644843f, -0.17875211f, 
    0.05458609f, 0.03219283f, 0.09551047f, -0.00027590f, 0.10656196f, 0.10468463f, -0.11815380f, -0.15306158f, 
    0.03466167f, 0.08567736f, 0.09153688f, -0.05789749f, -0.04035152f, 0.01758780f, 0.11862257f, 0.03258091f, 
    -0.05035929f, 0.15888225f, 0.01344972f, 0.09709258f, 0.00376682f, -0.15140119f, -0.22653177f, -0.08909724f, 
    -0.01866326f, 0.00600367f, 0.15093809f, 0.10183115f, 0.08809873f, -0.05573031f, -0.05822383f, 0.13471553f, 
    0.14275233f, 0.05921064f, 0.23220740f, 0.09980539f, -0.07366582f, -0.07755106f, 0.05497624f, -0.00666850f, 
    0.02550183f, 0.19917415f, -0.01686415f, 0.15526956f, 0.14572510f, 0.19135380f, 0.20338143f, -0.11154988f, 
    -0.10800485f, 0.01984787f, -0.15554921f, -0.00046368f, -0.16457817f, 0.10780444f, 0.11161147f, -0.00867040f, 
    -0.02369672f, 0.07763176f, -0.04210503f, -0.08134072f, -0.25065485f, -0.13538271f, 0.00873339f, 0.07381999f, 
    -0.04076407f, 0.07100430f, 0.20088059f, 0.13730383f, 0.14953288f, 0.06138721f, 0.03702017f, -0.02795291f, 
    -0.00925543f, -0.07364171f, -0.08913339f, 0.03959698f, 0.53005737f, -0.16199069f, -0.02420526f, -0.03768641f, 
    0.06040427f, -0.06958532f, -0.05300709f, -0.00295947f, -0.07690662f, 0.04720279f, 0.01229878f, 0.04863253f, 
    0.04544141f, 0.33037964f, -0.20560831f, 0.02611284f, 0.07620473f, 0.13156943f, -0.01930427f, -0.02194689f, 
    -0.01898996f, -0.00556798f, -0.07685673f, 0.09296458f, 0.24985933f, -0.10232715f, 0.10933141f, -0.10538494f, 
    0.00739354f, -0.10721292f, 0.12728387f, -0.11005159f, 0.03119037f, 0.07598002f, 0.05935711f, -0.02560477f, 
    -0.21349908f, 0.06770402f, 0.02046705f, -0.21514028f, -0.02704599f, -0.03471428f, 0.04937524f, 0.07334942f, 
    0.06574407f, -0.01722708f, -0.12315265f, -0.08106778f, -0.06754677f, 0.11140846f, -0.07006331f, -0.01178265f, 
    0.08650547f, 0.03629499f, 0.02133793f, 0.05378318f, -0.05912033f, 0.01286175f, -0.00950164f, -0.07356565f, 
    -0.07525662f, 0.01876760f, -0.14506267f, 0.18399151f, -0.04515423f, 0.07894540f, -0.03781036f, -0.00973647f, 
    0.02595450f, 0.06186413f, 0.11137037f, 0.02924473f, 0.35433856f, 0.06412891f, -0.15532678f, 0.24260074f, 
    -0.00898729f, -0.02232280f, -0.04325306f, -0.01261354f, -0.12282392f, -0.00308280f, -0.03535448f, -0.03968254f, 
    -0.16101553f, 0.29431909f, 0.05014955f, -0.04440939f, -0.09176723f, -0.03013293f, 0.00261343f, 0.02733240f, 
    0.06130966f, 0.13965951f, 0.09375507f, -0.01931455f, 0.09342095f, 0.02035797f, 0.17718881f, -0.06762285f, 
    0.03456806f, -0.03039785f, -0.02538812f, -0.03526803f, 0.02554702f, 0.04936421f, -0.01378877f, -0.11829482f, 
    0.00979621f, 0.10696810f, -0.05423319f, -0.21315812f, 0.09071559f, -0.03984402f, 0.10216448f, 0.07113070f, 
    -0.04659969f, 0.10457260f, 0.01319892f, 0.02477092f, 0.24296732f, -0.02444417f, 0.03450403f, 0.01353246f, 
    0.00623566f, 0.02371239f, -0.03182411f, -0.00428489f, -0.04364982f, 0.04708653f, -0.06360021f, -0.08604022f, 
    0.18447344f, -0.14420670f, -0.07326185f, 0.10964113f, -0.14056535f, 0.05075417f, -0.01614062f, 0.08333784f, 
    0.11373385f, 0.02739147f, 0.00601705f, -0.01128852f, -0.07755331f, -0.00470751f, -0.16381976f, 0.00948870f, 
    0.00189301f, 0.05880747f, -0.04063962f, -0.00033849f, 0.03713021f, 0.05229344f, -0.06271286f, -0.05930037f, 
    -0.02651178f, 0.02041959f, 0.07295629f, -0.15191172f, 0.05344497f, -0.17834826f, 0.10349429f, 0.01843941f, 
    0.08271931f, -0.03577939f, 0.15725811f, 0.01034377f, -0.12254082f, 0.10909225f, 0.11306929f, 0.02675501f, 
    0.06044733f, -0.04535715f, 0.03768246f, 0.02637273f, -0.07802906f, 0.02259267f, 0.02784397f, -0.00236683f, 
    -0.25073257f, 0.05931368f, -0.00520916f, 0.13177617f, -0.10004006f, 0.04042259f, 0.00454625f, 0.00083441f, 
    0.00832363f, 0.02035975f, 0.05532323f, -0.06998508f, 0.68321204f, 0.05791412f, -0.16541682f, -0.02483283f, 
    0.02857658f, -0.07192074f, 0.06187860f, 0.03983882f, -0.06624494f, 0.03097693f, -0.01866569f, 0.04559505f, 
    0.23574014f, 0.02537256f, -0.13521524f, -0.12626590f, 0.20299490f, 0.03694930f, 0.01572974f, -0.12976457f, 
    0.06332207f, 0.00809628f, -0.00182993f, 0.04700992f, 0.31679234f, -0.39511371f, 0.03670472f, 0.12902980f, 
    -0.03235798f, 0.05678917f, 0.13287532f, -0.04908377f, 0.07470259f, -0.05259597f, 0.14068440f, -0.03588944f, 
    0.00697360f, -0.01921242f, 0.18214554f, 0.10422931f, 0.05919596f, 0.15528238f, 0.06149470f, 0.11776208f, 
    -0.04269933f, 0.02431795f, -0.05770010f, -0.04138627f, -0.17119169f, 0.10179444f, -0.02852079f, -0.16160002f, 
    -0.05967133f, -0.11238647f, -0.04632645f, 0.11481825f, 0.01605515f, -0.08418493f, 0.08349481f, -0.04537563f, 
    0.06151451f, 0.00035567f, -0.16947341f, -0.06652112f, 0.14979124f, 0.07731620f, 0.05709352f, -0.01351240f, 
    -0.08724084f, 0.06618617f, -0.04303854f, -0.05481520f, -0.13332492f, 0.06961367f, -0.01371515f, 0.06624864f, 
    0.04623156f, 0.01732608f, -0.09551584f, 0.10609459f, 0.07322229f, -0.00615605f, -0.06378275f, -0.04716603f, 
    0.32560432f, 0.02979967f, -0.07246050f, 0.12274214f, -0.08586780f, 0.05306390f, -0.13227275f, -0.07691201f, 
    0.02670906f, -0.07239389f, 0.01779446f, -0.00753026f, 0.31658608f, 0.02912875f, 0.04338896f, 0.13458258f, 
    0.01685696f, 0.00296754f, 0.00165163f, 0.07329461f, 0.07322307f, -0.00945529f, -0.03238210f, 0.12342630f, 
    -0.12968233f, -0.20409767f, -0.04159778f, -0.15030800f, 0.04453405f, 0.02515920f, 0.06777418f, 0.10499611f, 
    0.06389865f, 0.10755906f, -0.08854831f, 0.17644420f, 0.31808144f, 0.17605008f, -0.25090644f, -0.05761207f, 
    0.05945895f, -0.06258983f, -0.01433579f, 0.11427689f, 0.03377590f, -0.10764774f, -0.03817181f, -0.08900420f, 
    -0.03367468f, 0.04872699f, 0.04089790f, -0.16690737f, 0.08394113f, 0.06297588f, 0.08772922f, 0.05976830f, 
    -0.01177717f, -0.00837004f, -0.04121919f, -0.05705174f, 0.02019898f, -0.13478947f, -0.02525462f, 0.01658582f, 
    -0.04661276f, 0.04699575f, 0.00807533f, 0.02623064f, -0.03413228f, -0.00290022f, -0.02587410f, -0.01649673f, 
    -0.22998230f, 0.15474539f, -0.02878579f, 0.04472219f, 0.15814915f, -0.13658644f, -0.06731800f, 0.16006684f, 
    0.06473133f, -0.01469313f, 0.12972817f, 0.17821448f, 0.21038908f, -0.29469168f, 0.04571050f, 0.05966868f, 
    -0.08511078f, 0.08579009f, -0.12262327f, 0.18117139f, 0.10961675f, 0.05370663f, 0.21638502f, -0.13869201f, 
    0.37922069f, -0.17065196f, 0.07819065f, -0.26194379f, -0.03858013f, 0.04799718f, 0.07238563f, -0.05230000f, 
    -0.11083328f, 0.04208349f, 0.10296848f, 0.00159922f, 0.31079662f, -0.11363498f, 0.11206115f, 0.00538880f, 
    0.01387470f, -0.02753779f, -0.00872147f, -0.05922485f, 0.15716296f, -0.02537727f, 0.07509451f, 0.00380548f, 
    -0.25729913f, 0.00282220f, 0.14776143f, 0.06159287f, -0.01198681f, 0.06699551f, -0.05704123f, 0.22210445f, 
    -0.01326939f, 0.03344623f, -0.03358749f, -0.01769804f, -0.24881284f, 0.00677409f, -0.09367613f, 0.05968651f, 
    0.04093979f, -0.02005879f, -0.05045166f, 0.02705524f, -0.01133929f, 0.09592873f, -0.02911420f, 0.07817304f, 
    -0.00113995f, 0.15477099f, 0.01456690f, 0.07226026f, 0.10177920f, 0.00242132f, 0.05004705f, 0.11184375f, 
    -0.13050224f, 0.05493711f, 0.15549529f, 0.00406163f, 0.22669968f, 0.01667898f, 0.07781073f, -0.11424381f, 
    0.06948592f, -0.00510197f, 0.03830157f, 0.02497712f, -0.02107078f, 0.03942805f, 0.12687507f, 0.12900867f, 
    0.06097223f, 0.01239924f, -0.06013221f, 0.05696801f, -0.06927251f, 0.09346423f, -0.13989466f, 0.07034856f, 
    0.14507033f, -0.02289402f, 0.05007034f, -0.03437456f, -0.16594209f, -0.17892191f, -0.03534319f, -0.13670823f, 
    0.03885971f, -0.03487777f, 0.03658157f, -0.08567487f, 0.02196819f, -0.05846184f, -0.00998178f, 0.04901996f, 
    0.35249063f, -0.00273385f, 0.10323441f, 0.04118950f, -0.05114516f, 0.16140684f, 0.02844606f, 0.09156318f, 
    -0.01589798f, 0.08817397f, -0.11816090f, 0.02471561f, 0.13129489f, 0.20054904f, -0.08518250f, 0.18820325f, 
    -0.10444378f, 0.01301587f, 0.11707704f, 0.01981099f, -0.01032624f, -0.01571539f, -0.01241806f, -0.00951400f, 
    0.11118410f, -0.02355839f, 0.09000444f, 0.14896786f, -0.03022351f, -0.05988774f, -0.17797996f, 0.00572502f, 
    0.08148161f, 0.05567343f, -0.06523714f, -0.03788956f, -0.10563978f, -0.12585826f, 0.06070639f, 0.17369287f, 
    -0.19069588f, -0.01040886f, -0.02934255f, 0.02232238f, -0.01604200f, -0.06221778f, 0.03244420f, 0.01221291f, 
    0.31214020f, 0.26399964f, -0.14031610f, 0.13000625f, -0.01471813f, 0.04734139f, 0.07759779f, 0.06856344f, 
    -0.12235868f, 0.04125614f, 0.02124104f, 0.08613148f, 0.10738271f, 0.33259189f, 0.11154927f, -0.13016415f, 
    0.08655293f, 0.00841034f, -0.02754859f, -0.02495613f, 0.02074712f, 0.00319080f, -0.00551425f, -0.00562728f, 
    0.08128585f, 0.01351080f, -0.06943733f, -0.01059082f, 0.00549501f, 0.06972794f, -0.03290002f, 0.07801325f, 
    -0.07092372f, 0.05668956f, 0.04700436f, 0.00075821f, 0.09684300f, 0.12880683f, 0.03875733f, -0.01871106f, 
    -0.11540632f, -0.05119104f, -0.08007377f, 0.08419362f, 0.06710556f, 0.02005145f, 0.00006498f, -0.05024466f, 
    -0.07075740f, 0.03773052f, -0.18684822f, -0.06082290f, 0.02124648f, -0.00816446f, -0.04262048f, -0.06649704f, 
    0.00125269f, -0.04880160f, -0.07387903f, -0.06187307f, -0.47122493f, -0.05947367f, 0.10319178f, 0.18032482f, 
    -0.12958340f, -0.07465143f, 0.04185339f, -0.02538385f, 0.05889634f, 0.03903933f, -0.05977713f, -0.04377479f, 
    0.00268151f, 0.07982745f, 0.07870048f, -0.01912509f, -0.07842634f, 0.06398239f, 0.12668312f, -0.00057789f, 
    -0.08744119f, 0.09012373f, 0.11826795f, 0.07026105f, -0.36492220f, 0.35356265f, -0.05558761f, 0.11006166f, 
    -0.13621421f, -0.00158254f, 0.05008725f, -0.03685061f, -0.16006508f, 0.05313672f, -0.05040358f, 0.03142408f, 
    0.23024830f, -0.00351788f, -0.01357578f, 0.14102976f, -0.14778493f, -0.07115259f, -0.06021584f, -0.14576681f, 
    -0.21729474f, -0.02789955f, -0.06974182f, -0.03124736f, 0.15994102f, -0.13363136f, 0.04934851f, 0.21658501f, 
    -0.07898785f, -0.00106039f, 0.07599194f, -0.05705098f, -0.08947688f, 0.05505427f, 0.00456301f, -0.08443066f, 
    -0.10439553f, 0.05424614f, 0.22528997f, 0.07040042f, 0.04554901f, -0.05377520f, 0.07535145f, 0.12945327f, 
    0.05183100f, -0.05925211f, 0.02051379f, 0.07274539f, -0.12565796f, 0.00550759f, 0.30616128f, 0.21791027f, 
    0.01146714f, -0.04534832f, -0.04444275f, -0.18021457f, -0.01716739f, 0.05096951f, 0.04889568f, -0.14094600f, 
    -0.16912147f, -0.04413742f, 0.09252499f, -0.04384081f, 0.05735936f, -0.08077639f, -0.07225042f, 0.01083844f, 
    0.04592630f, 0.08998032f, -0.05198910f, 0.00188495f, 0.13926835f, 0.00989472f, 0.23829807f, 0.13900077f, 
    0.02520325f, 0.01289078f, -0.18165007f, -0.02208414f, -0.02901157f, 0.07507548f, 0.08990760f, -0.14193742f, 
    -0.06576869f, -0.06530280f, -0.12816033f, 0.05565682f, 0.07924159f, 0.05388788f, 0.16775441f, 0.14216320f, 
    -0.05929441f, -0.11467367f, 0.08659206f, -0.09813220f, 0.15303144f, -0.07461882f, 0.17122532f, 0.07379027f, 
    0.07119410f, 0.14650299f, -0.00727515f, -0.01755657f, -0.07173948f, 0.13198327f, 0.09625500f, 0.06097474f, 
    0.04261095f, -0.04521482f, -0.00577700f, -0.00748867f, -0.11212818f, -0.06849912f, 0.00077591f, -0.08224162f, 
    0.14274025f, 0.06510229f, 0.09668443f, -0.00887378f, -0.28769246f, -0.04608568f, -0.12177134f, 0.23577794f, 
    -0.18913178f, -0.04757817f, 0.15946421f, -0.03949416f, -0.01736229f, -0.03622213f, 0.03496875f, -0.03887603f, 
    -0.19395567f, -0.03076315f, -0.01133443f, -0.11869123f, -0.00280518f, 0.05350303f, 0.07567801f, 0.00569510f, 
    0.01582387f, -0.01455163f, -0.32771060f, -0.01616761f, -0.05785825f, 0.07343727f, 0.06676459f, 0.21445611f, 
    0.03354131f, 0.19180332f, -0.05307746f, -0.17527768f, -0.15759785f, -0.03599882f, -0.10521581f, -0.01169865f, 
    0.22347279f, 0.07255760f, 0.00826494f, -0.00236781f, 0.00393418f, -0.04768678f, 0.01578845f, 0.09547176f, 
    0.12628470f, 0.13377583f, 0.07502012f, 0.10882446f, 0.36259937f, 0.07213061f, 0.02114103f, 0.07399808f, 
    0.03513766f, -0.14552748f, 0.02520774f, 0.15398850f, -0.02500634f, -0.05204429f, 0.08290860f, 0.09081996f, 
    0.01150144f, 0.20055021f, -0.06404640f, 0.09231754f, -0.01558793f, -0.01767186f, -0.16212660f, -0.04057111f, 
    0.13252974f, -0.14740096f, 0.12613787f, -0.03870719f, 0.07978504f, -0.18913570f, 0.03315928f, -0.01741225f, 
    0.08940762f, -0.12652457f, 0.03966691f, -0.02744578f, -0.02307416f, -0.04839047f, 0.09241683f, -0.15788041f, 
    0.25816613f, -0.03806960f, 0.19017050f, 0.02617470f, -0.00897831f, -0.01861226f, -0.02067596f, -0.01803261f, 
    0.04244608f, 0.06912085f, -0.15413524f, 0.03703515f, -0.24793619f, 0.02668762f, -0.04744033f, -0.16077721f, 
    -0.03397708f, -0.00564841f, 0.08746081f, 0.02913955f, 0.04536542f, -0.05108208f, -0.13076665f, 0.06743187f, 
    0.00269992f, 0.03255624f, -0.18563956f, -0.08966714f, 0.01479148f, 0.04170305f, 0.02525177f, -0.09656231f, 
    0.12047125f, -0.02114292f, 0.01958496f, 0.03129490f, 0.01123687f, 0.07933995f, -0.08284791f, 0.04528729f, 
    0.04229823f, 0.02407922f, -0.07054304f, 0.03256003f, -0.05539047f, -0.06765869f, 0.11675820f, 0.05231231f, 
    0.09357278f, -0.17109971f, 0.21448250f, 0.15216166f, -0.10666444f, -0.07637360f, -0.14159951f, -0.09513631f, 
    0.01386760f, -0.06357484f, -0.00353460f, 0.03476109f, 0.24890772f, 0.04107960f, 0.08126279f, 0.46451119f, 
    0.06946333f, 0.03313858f, -0.06474996f, -0.13329667f, 0.02254422f, 0.07592742f, 0.15278757f, 0.10753958f, 
    -0.09876273f, -0.08314817f, 0.17135522f, 0.00538009f, 0.03826637f, 0.02814161f, 0.21601430f, 0.08867824f, 
    -0.15222818f, 0.02148954f, 0.06980670f, -0.01523678f, 0.17027511f, 0.25940388f, 0.09407892f, -0.00152634f, 
    -0.10217202f, 0.11249107f, -0.05568352f, 0.03047502f, -0.04186675f, 0.02709177f, 0.05575260f, 0.01525711f, 
    -0.30482945f, 0.06082316f, 0.11825317f, -0.20074533f, 0.08989892f, 0.07029320f, 0.15410569f, -0.06643530f, 
    0.23576534f, -0.08765727f, 0.06305171f, 0.09965117f, 0.07268590f, -0.10794303f, -0.11823266f, -0.13645272f, 
    -0.00145736f, -0.04561388f, -0.10054842f, 0.02807198f, 0.04945496f, -0.08975454f, 0.03452528f, 0.11909389f, 
    -0.03050133f, -0.20227994f, -0.17873754f, -0.15128879f, 0.05901246f, 0.05484770f, 0.15859757f, 0.03042688f, 
    -0.00143324f, -0.09009625f, -0.11629467f, -0.00909617f, 0.05872396f, -0.03592008f, 0.14234373f, 0.11785539f, 
    -0.11075637f, 0.03752424f, -0.02153550f, 0.05887893f, 0.01265263f, -0.02060394f, -0.02782231f, -0.01674150f, 
    0.22864664f, 0.03332257f, -0.12335242f, -0.10751677f, 0.06279653f, -0.12072857f, 0.07895629f, 0.01859272f, 
    -0.08603857f, 0.05904781f, 0.14736983f, 0.01795234f, -0.18473086f, 0.17953619f, 0.08160783f, 0.05547449f, 
    -0.03944213f, 0.08688813f, -0.03703826f, -0.04815143f, 0.08065855f, 0.01531697f, -0.03453223f, 0.03008173f, 
    -0.00105462f, -0.01459772f, -0.03507740f, -0.15632240f, 0.03373769f, -0.01149706f, -0.13668746f, 0.20028092f, 
    -0.00956801f, -0.20217231f, 0.14840740f, -0.03747853f, 0.02264891f, -0.05349533f, -0.17177247f, 0.07558341f, 
    0.01016186f, -0.11922086f, -0.01167959f, -0.05361548f, 0.07815902f, 0.08022560f, 0.07183812f, -0.01681378f, 
    0.38735330f, 0.27736616f, -0.01550238f, 0.14710987f, -0.05109286f, -0.08450960f, -0.00770184f, -0.09622868f, 
    0.02730059f, 0.08715507f, 0.14422807f, 0.02033732f, -0.05235725f, -0.02096336f, -0.08334082f, 0.05456282f, 
    0.11514343f, -0.00445446f, 0.04500281f, -0.00305384f, 0.18458362f, 0.12937212f, -0.04091509f, 0.08648839f, 
    -0.15190816f, -0.13026039f, 0.10541180f, -0.14085215f, -0.06201747f, 0.13779336f, 0.18546379f, 0.03162646f, 
    0.26703852f, 0.03736249f, 0.02274970f, -0.02718195f, -0.01225638f, 0.09167023f, -0.02694210f, -0.09156141f, 
    0.03253574f, 0.20472282f, -0.06383555f, 0.07920744f, 0.02819465f, 0.12404351f, 0.20260383f, 0.12379073f, 
    0.16219124f, -0.21661302f, -0.15948234f, 0.27216843f, 0.21962026f, -0.09400205f, -0.06976561f, -0.06400254f, 
    0.05439636f, 0.04115376f, 0.03282611f, -0.00149857f, -0.02933859f, -0.10408539f, -0.14911789f, 0.09451774f, 
    -0.09187178f, -0.12525292f, -0.02675398f, -0.01583323f, 0.01298751f, 0.00250101f, 0.06127901f, 0.02055647f, 
    0.30039075f, -0.10863301f, 0.09905551f, 0.12466969f, -0.11402377f, 0.04951442f, -0.09776895f, -0.02817073f, 
    0.20815723f, -0.04655590f, 0.10818194f, -0.13956916f, -0.05620565f, -0.36759815f, 0.06189952f, 0.30347028f, 
    0.02310831f, -0.01061396f, -0.06006623f, -0.08342561f, 0.04893488f, 0.00315028f, 0.08666935f, -0.00317405f, 
    0.36576983f, -0.01808155f, -0.19763210f, 0.06056399f, 0.12399353f, 0.09237545f, 0.04372855f, 0.16306782f, 
    0.06141364f, 0.07911272f, 0.01310418f, 0.00375550f, 0.07697310f, 0.33956176f, 0.30630776f, -0.04276663f, 
    -0.08248531f, 0.08439671f, 0.03419978f, 0.06474274f, 0.04351972f, 0.01661513f, 0.03108404f, -0.06122935f, 
    0.24099806f, 0.17055380f, -0.01992507f, -0.07015192f, -0.00563040f, -0.00165653f, -0.00749356f, 0.03047765f, 
    0.03982598f, 0.10680931f, 0.15727757f, -0.06424126f, 0.08621009f, 0.09536503f, -0.04803361f, -0.01936561f, 
    0.14451484f, 0.02632044f, -0.03726519f, -0.02117821f, 0.06944972f, -0.04495843f, -0.01544412f, -0.10027828f, 
    0.15340111f, 0.00637139f, -0.08556628f, -0.13328016f, -0.06014215f, 0.11573486f, -0.01360931f, 0.07951272f, 
    0.11576568f, 0.03699785f, -0.11165290f, 0.02369124f, 0.11807304f, 0.00534013f, -0.26639378f, 0.13932388f, 
    -0.00059778f, -0.09791081f, -0.10493622f, -0.11840504f, 0.01804521f, 0.03663962f, 0.10941839f, -0.02519705f, 
    0.14239219f, 0.23976918f, 0.05373425f, -0.01472228f, -0.12290794f, 0.01053721f, 0.07624689f, -0.16488867f, 
    0.05658684f, -0.01564242f, -0.03318515f, -0.02561603f, -0.14635596f, 0.11752606f, -0.00055074f, 0.05981392f, 
    0.14070311f, 0.04035522f, 0.02738411f, 0.17671199f, -0.07533839f, -0.11082866f, 0.01205285f, -0.01223142f, 
    0.07237449f, -0.25236994f, -0.07285719f, -0.02701333f, 0.08394604f, -0.08046426f, 0.00332095f, 0.06934758f, 
    0.06751839f, -0.02032907f, 0.00859387f, -0.05626225f, 0.00641464f, -0.02414683f, 0.12779723f, 0.03034012f, 
    0.05687388f, 0.12571222f, -0.03980770f, 0.10069706f, -0.05889932f, -0.04578122f, -0.04196522f, -0.00148537f, 
    0.21446694f, 0.12751684f, 0.06563054f, 0.19233966f, -0.02926187f, -0.11497850f, 0.12740079f, 0.00686532f, 
    -0.09332547f, 0.03360384f, 0.09313722f, 0.07188293f, -0.08217081f, 0.15409611f, 0.10856162f, 0.02271627f, 
    -0.01538484f, 0.00107039f, 0.06447491f, 0.11344771f, 0.11533253f, 0.06386270f, 0.02955736f, 0.04518799f, 
    -0.01021483f, 0.04251983f, 0.01496996f, -0.01250177f, -0.01391182f, -0.01883604f, 0.01497417f, 0.00638691f, 
    -0.07064597f, 0.04920641f, -0.01745056f, -0.03283172f, -0.05747053f, 0.06143654f, 0.02468852f, -0.06405423f, 
    -0.05715064f, -0.01462684f, -0.05714664f, -0.06444157f, -0.05180793f, -0.05748313f, 0.01311420f, -0.01345825f, 
    0.01317021f, -0.05150060f, -0.02235100f, -0.04199791f, -0.04196753f, 0.00755820f, 0.00767580f, -0.06157359f, 
    -0.04975607f, 0.00569720f, -0.04976941f, 0.04218576f, -0.02040194f, -0.02563907f, -0.05649909f, 0.01943346f, 
    0.03383323f, 0.00154393f, -0.00803611f, -0.00413985f, -0.01594459f, -0.03046776f, -0.00288946f, -0.03240722f, 
    -0.01833914f, 0.00358769f, 0.05273001f, -0.05844277f, 0.01913256f, 0.03960098f, -0.03881092f, 0.06073933f, 
    0.06320275f, 0.06495812f, 0.03770287f, -0.03403653f, -0.06661537f, -0.02541403f, -0.03900926f, -0.01685739f, 
    -0.02903255f, 0.03534704f, -0.06953651f, 0.00959867f, -0.06895288f, 0.00781733f, -0.01125984f, -0.06887561f, 
    0.00272284f, -0.01981250f, 0.03007388f, -0.03642613f, -0.04553189f, 0.03699197f, 0.00653740f, -0.01882627f, 
    0.05997151f, 0.06405663f, 0.07124165f, -0.05962868f, -0.00362544f, 0.00112234f, -0.04260068f, -0.04808407f, 
    0.02895837f, -0.04894373f, -0.00251347f, -0.05059242f, 0.01380987f, -0.04319073f, 0.06284223f, -0.00366722f, 
    0.00982482f, 0.02316731f, -0.02738428f, -0.02629720f, -0.01751598f, 0.03413171f, -0.04552388f, 0.01172284f, 
    0.02291350f, -0.01830702f, 0.03353465f, 0.03997446f, -0.05418614f, -0.02133215f, 0.03831920f, 0.03341157f, 
    0.00512660f, -0.03854040f, 0.05413592f, 0.03549446f, 0.04758539f, 0.00857469f, 0.01099295f, 0.00263698f, 
    0.04994923f, 0.01929913f, -0.02129937f, -0.07968867f, 0.01890540f, 0.01175723f, -0.03330123f, -0.01295678f, 
    -0.06337745f, 0.04721335f, 0.00637338f, -0.02748017f, -0.07905391f, 0.05106348f, -0.02408011f, -0.01816271f, 
    0.05581260f, 0.00027634f, -0.06295654f, 0.05432387f, -0.03994022f, -0.05088982f, 0.04797331f, 0.06056598f, 
    -0.03224822f, 0.05737521f, 0.00632215f, -0.04869987f, -0.00165699f, -0.03794655f, -0.00647578f, 0.03928843f, 
    -0.05991338f, -0.05313984f, 0.05240096f, 0.05064791f, -0.01889497f, -0.01897226f, -0.05904026f, 0.06241104f, 
    -0.06063103f, 0.03016676f, 0.02968328f, -0.05609827f, -0.06501745f, 0.01574569f, -0.03212466f, 0.06297297f, 
    0.04890654f, -0.03347361f, -0.04172206f, -0.04059133f, -0.03273780f, -0.07239565f, -0.03122958f, 0.05242831f, 
    -0.06279024f, -0.03039431f, 0.04452713f, 0.00705178f, -0.07108782f, 0.00985560f, -0.06927817f, 0.02332081f, 
    0.00736280f, 0.01829409f, -0.00325390f, -0.06056200f, -0.02229528f, -0.03450773f, -0.06365567f, -0.05520542f, 
    -0.16544856f, 0.24494009f, 0.11605895f, -0.03533567f, -0.09300394f, 0.09273518f, -0.00585370f, 0.02878318f, 
    0.08393364f, 0.21981552f, 0.06077879f, -0.05883582f, -0.12220346f, -0.06055570f, 0.13439386f, 0.15952957f, 
    0.21710478f, 0.01824686f, -0.07020152f, -0.07076178f, -0.05752372f, 0.14928336f, -0.00654739f, -0.08800153f, 
    -0.11583585f, -0.05998490f, -0.02084542f, -0.17245620f, 0.23960704f, -0.03665156f, 0.02627158f, -0.02644274f, 
    0.03339424f, 0.14681475f, 0.03134678f, -0.03214049f, 0.23827477f, 0.17196558f, -0.19470385f, 0.06617693f, 
    0.05174996f, -0.02212535f, 0.11304260f, 0.00165079f, 0.08656967f, 0.09669489f, -0.04492805f, 0.04367749f, 
    -0.30079579f, 0.08769237f, 0.11686468f, -0.10770035f, 0.00530297f, -0.15163177f, -0.17873512f, -0.10286480f, 
    0.12872669f, -0.00087952f, 0.13603599f, 0.04255245f, 0.34253222f, -0.13764063f, -0.00480453f, 0.06361200f, 
    0.03679615f, -0.01530142f, 0.05657402f, -0.00023256f, 0.01592319f, 0.04884270f, 0.00564186f, -0.00550072f, 
    -0.00727262f, 0.06830230f, 0.08746956f, -0.12500136f, -0.02708599f, -0.18715595f, 0.10372048f, -0.01167004f, 
    0.04015440f, -0.09678454f, -0.03135192f, 0.09902537f, -0.03395415f, 0.00707461f, 0.18483233f, -0.01998464f, 
    0.02240496f, -0.03651200f, -0.06049402f, -0.00436617f, -0.17585672f, -0.00734530f, 0.11353098f, 0.02186650f, 
    0.04703068f, 0.13904542f, 0.09911264f, 0.21513207f, -0.02156148f, 0.10049479f, 0.00953498f, -0.14598489f, 
    0.10555766f, -0.10172614f, 0.11131277f, -0.09838730f, 0.44402701f, 0.01627239f, 0.02853633f, 0.01637628f, 
    0.13683066f, -0.04540265f, 0.03084405f, 0.06002472f, -0.04298476f, 0.02587681f, -0.13868801f, -0.03187553f, 
    -0.10116314f, 0.18998545f, -0.00636884f, -0.13515964f, 0.17225987f, 0.09380464f, -0.00633831f, -0.00432301f, 
    0.02470844f, -0.01882180f, -0.11012513f, 0.08776475f, 0.36404258f, -0.21462564f, 0.15092233f, -0.00729337f, 
    -0.04521441f, -0.10374165f, 0.08150049f, -0.03012151f, 0.06773683f, 0.08955620f, 0.05021405f, 0.12074015f, 
    -0.19948195f, 0.20892760f, 0.01730345f, 0.04571380f, -0.04742372f, -0.01355514f, -0.05433596f, 0.01746633f, 
    0.00129182f, 0.02521713f, 0.07243916f, -0.08007044f, -0.04396598f, 0.04928434f, -0.03237297f, -0.18084522f, 
    0.06996375f, 0.01972624f, 0.05807607f, 0.04536668f, 0.07928930f, -0.01171490f, 0.01007045f, -0.04820886f, 
    -0.26326799f, 0.05515983f, -0.03466262f, -0.09809934f, -0.09177627f, 0.05446796f, -0.07932366f, -0.07806013f, 
    0.04392446f, 0.09289546f, 0.03154241f, 0.10397742f, 0.09050835f, 0.04984062f, -0.24585153f, -0.08033583f, 
    -0.05286894f, 0.05401181f, -0.04654852f, 0.04385711f, 0.00156622f, 0.01655331f, 0.01878707f, -0.07710173f, 
    0.04971972f, -0.06337014f, 0.04030265f, 0.01599121f, 0.04224478f, -0.04562359f, 0.04098213f, -0.06268308f, 
    0.05505230f, -0.05022445f, -0.04094397f, -0.02680293f, -0.06939739f, 0.04696401f, 0.02480645f, 0.01027161f, 
    0.05876623f, 0.03576376f, -0.04554584f, 0.01347309f, -0.06680715f, -0.05697490f, -0.00272576f, -0.04265739f, 
    -0.07518348f, 0.04617091f, 0.04977642f, 0.00395834f, -0.05462704f, 0.02224933f, -0.05723788f, 0.06009356f, 
    -0.01448428f, 0.04561203f, -0.04917150f, -0.06391348f, 0.05531828f, -0.02040990f, -0.05020206f, -0.03820325f, 
    0.00547109f, 0.00075136f, -0.04742835f, -0.06712664f, 0.05831861f, -0.06125181f, 0.03772696f, 0.04692362f, 
    -0.03119960f, -0.05781498f, -0.03986041f, -0.05816787f, -0.01765200f, -0.04002011f, -0.06393618f, 0.05816004f, 
    0.03149190f, 0.02149365f, -0.04926895f, -0.04669883f, 0.03623468f, -0.01820578f, 0.04285416f, 0.00046960f, 
    -0.01114292f, -0.03965707f, -0.02504315f, -0.06420088f, 0.03431209f, 0.06257963f, -0.04962093f, -0.03366343f, 
    -0.04651062f, -0.06256540f, -0.04398775f, -0.06879237f, 0.03183668f, -0.07730941f, -0.01734480f, -0.02903821f, 
    -0.06741361f, 0.05732537f, 0.01939988f, -0.05511321f, 0.04104953f, -0.00497488f, 0.04682531f, -0.04922871f, 
    0.03148926f, -0.02314094f, 0.06487148f, 0.02636506f, 0.02119587f, -0.05594050f, -0.04424594f, -0.00546885f, 
    -0.04278475f, -0.02366898f, -0.00218099f, -0.00414468f, 0.05617750f, -0.02208587f, -0.06384832f, -0.01843208f, 
    -0.03117872f, -0.07598683f, -0.03994845f, 0.04425074f, -0.00468439f, 0.01942336f, -0.02818030f, -0.01899732f, 
    0.03406592f, -0.06512845f, 0.05323916f, -0.06821605f, -0.06215680f, 0.05219626f, 0.00024877f, 0.03774235f, 
    -0.00155916f, 0.00125169f, -0.02905682f, -0.02901356f, -0.05229449f, 0.05984587f, 0.05924320f, -0.02314482f, 
    0.01390764f, 0.02569888f, -0.05514433f, -0.06511991f, -0.05540228f, -0.05287077f, 0.01080104f, -0.07140959f, 
    -0.00517290f, -0.04632048f, -0.06355872f, 0.03955920f, -0.00944426f, -0.03546421f, -0.07504999f, -0.03797879f, 
    -0.03422081f, 0.03240627f, 0.03419739f, 0.04930465f, -0.05346174f, -0.07359676f, 0.00462735f, -0.07702004f, 
    0.02706506f, -0.03906918f, -0.06275514f, -0.01958535f, -0.01893010f, 0.01415248f, 0.06040508f, -0.07803302f, 
    0.03506601f, -0.00158022f, -0.00780566f, 0.00014535f, 0.03954949f, -0.03569121f, -0.05767507f, -0.01456234f, 
    -0.00670106f, 0.02267960f, -0.02392329f, 0.02770259f, 0.03115589f, 0.00255434f, 0.05837224f, -0.04998888f, 
    0.06364536f, -0.01697828f, 0.05072830f, 0.03952483f, 0.04477159f, -0.00975526f, 0.02714211f, -0.03303992f, 
    0.02498447f, -0.07575960f, 0.04625154f, -0.07049538f, 0.02332496f, -0.00666007f, 0.05412061f, -0.06876306f, 
    -0.06472692f, -0.00952614f, -0.01495925f, -0.04088243f, 0.06110178f, -0.02235429f, -0.06202453f, -0.06075037f, 
    0.01093645f, -0.05820224f, -0.06371053f, 0.03635469f, 0.05716949f, -0.07480951f, -0.02064552f, 0.01421617f, 
    0.01904958f, 0.05221084f, -0.02254476f, 0.01989611f, -0.02132224f, -0.05475083f, -0.03494785f, 0.00340925f, 
    0.05182754f, -0.03392199f, -0.00593451f, -0.07256901f, 0.03697544f, -0.07359029f, -0.05618742f, -0.03458034f, 
    0.05012626f, -0.02392254f, 0.01791061f, -0.05408301f, -0.05003215f, 0.00609004f, 0.04498009f, -0.01869829f, 
    -0.03198261f, -0.04410095f, 0.03842809f, -0.03115126f, -0.06796157f, -0.05027428f, 0.00468274f, -0.00756376f, 
    0.01330250f, 0.00668085f, 0.01714724f, 0.05055438f, 0.02225462f, 0.01777259f, -0.05316754f, -0.07181074f, 
    -0.04426985f, -0.00530554f, 0.00368544f, -0.05624601f, 0.05219389f, -0.03767555f, 0.03529174f, 0.04500049f, 
    -0.05679706f, -0.00472024f, -0.04519099f, -0.00881926f, -0.00074101f, -0.04689743f, -0.00347952f, -0.01853456f, 
    -0.05855463f, -0.04780241f, 0.06264640f, 0.04341203f, 0.02073494f, 0.02957808f, 0.03925829f, -0.00520162f, 
    -0.03081023f, -0.00811721f, -0.05708018f, -0.07308759f, 0.05369347f, -0.05975755f, -0.03744766f, -0.00335802f, 
    0.04031317f, 0.00650232f, -0.05656673f, 0.06426420f, 0.01699030f, -0.07866421f, 0.04077067f, -0.04947630f, 
    0.00614587f, -0.05185280f, 0.03251645f, 0.04452644f, -0.02685597f, 0.03086362f, -0.04036101f, 0.02958255f, 
    0.05382188f, 0.01613345f, -0.05392676f, -0.06203654f, -0.01714524f, 0.05176456f, -0.04376424f, -0.03813968f, 
    0.04000149f, -0.06989264f, 0.05691289f, -0.06059092f, 0.04202871f, -0.06958228f, 0.01640998f, -0.01356174f, 
    0.03256655f, -0.01197747f, -0.03405776f, -0.00411188f, -0.05295154f, -0.00503289f, 0.01814053f, 0.00910782f, 
    -0.06622342f, -0.05122384f, 0.00111124f, 0.04553616f, -0.07383562f, -0.02879218f, -0.07000534f, -0.04651733f, 
    -0.07135876f, -0.00391060f, -0.04519559f, 0.01799878f, -0.07427219f, 0.06187728f, 0.00118748f, -0.02277876f, 
    -0.05215761f, -0.04038033f, 0.02885031f, -0.02495058f, 0.02543138f, -0.06049919f, -0.07753611f, -0.04096894f, 
    -0.00352701f, -0.02580405f, -0.00485828f, -0.01434735f, -0.07615656f, -0.03433078f, 0.04340622f, 0.03990177f, 
    -0.04908673f, 0.06273551f, 0.03312390f, -0.00270916f, 0.00047160f, 0.03086623f, 0.02056170f, -0.07378507f, 
    0.05029913f, -0.07013080f, 0.00112268f, 0.06102694f, -0.01239038f, -0.01354561f, -0.04823502f, -0.01321683f, 
    0.04465549f, -0.07142616f, 0.05533261f, 0.00064868f, 0.04881822f, 0.02160902f, 0.03064241f, 0.03128551f, 
    -0.05984250f, -0.00266716f, 0.00429425f, 0.01721815f, 0.03035246f, 0.02861805f, 0.06395218f, 0.00767338f, 
    -0.12447304f, 0.08088475f, 0.11065613f, -0.14902793f, 0.03330348f, 0.06024304f, 0.08152954f, 0.04663567f, 
    0.00611068f, -0.11243176f, 0.01542103f, 0.05698296f, -0.33339885f, -0.04526719f, -0.00255493f, -0.17255889f, 
    0.06949001f, -0.04062931f, 0.00404799f, -0.05442789f, 0.02017338f, 0.07215194f, -0.07669560f, 0.20388260f, 
    0.09690629f, 0.11478040f, 0.08340521f, 0.03583119f, -0.04687613f, 0.02642807f, 0.13446444f, -0.01972231f, 
    0.05988613f, 0.09064283f, 0.03500353f, 0.24761268f, -0.20134194f, 0.30148625f, -0.14526595f, -0.22318090f, 
    0.09951398f, 0.03733679f, -0.01737927f, -0.01732162f, 0.06836689f, -0.08181133f, -0.05293116f, 0.02303925f, 
    -0.30064023f, 0.03132880f, 0.19792338f, -0.00234682f, 0.15831396f, 0.04721956f, 0.02580705f, 0.02371296f, 
    -0.06655268f, -0.01516478f, -0.04605342f, 0.09572511f, 0.31812376f, -0.09763786f, -0.06062348f, -0.07901933f, 
    0.07268026f, -0.02513372f, 0.03129523f, 0.06376386f, 0.04472377f, 0.01679195f, 0.06453134f, 0.11761289f, 
    0.19779843f, -0.07466396f, 0.11381523f, 0.16697933f, -0.07086512f, -0.04929705f, 0.05346863f, 0.04395501f, 
    -0.05772087f, 0.00534796f, 0.04122346f, -0.02472973f, 0.06895506f, 0.01382965f, -0.09908550f, -0.11056601f, 
    -0.03404303f, -0.08201638f, -0.08112901f, 0.01024750f, 0.15415719f, 0.05091069f, 0.14047144f, 0.01787101f, 
    -0.03170076f, 0.06821852f, 0.18614914f, 0.11423518f, 0.09305286f, 0.08406839f, 0.09441825f, -0.10053441f, 
    -0.10075990f, 0.08205162f, 0.04895830f, 0.01886370f, -0.47336456f, 0.03969723f, 0.20817511f, -0.00218475f, 
    0.01286199f, 0.15320620f, -0.00088564f, -0.09275700f, -0.07539666f, 0.02662236f, -0.09472271f, 0.05222368f, 
    -0.04979748f, -0.07301369f, 0.10022856f, 0.02994193f, -0.07513729f, -0.03231363f, 0.11154233f, 0.08076071f, 
    -0.04275527f, 0.10233408f, -0.07986108f, 0.04684562f, 0.07115859f, 0.20202792f, 0.06820718f, 0.03682051f, 
    -0.08325692f, -0.06028283f, 0.02170391f, -0.05019462f, -0.00147732f, 0.11856891f, 0.08772112f, 0.01383751f, 
    -0.34097975f, 0.16098492f, -0.13138038f, -0.09104650f, 0.07478623f, 0.06905571f, -0.00142167f, -0.08090326f, 
    0.12139446f, -0.09370951f, 0.13976140f, 0.09543116f, 0.24138032f, -0.07564311f, 0.06683204f, 0.22111885f, 
    0.12186920f, 0.10614816f, 0.06166402f, -0.07032221f, -0.03848704f, 0.17601593f, 0.03762151f, 0.03080160f, 
    -0.07672891f, -0.02260059f, 0.23701409f, 0.18432890f, -0.01268671f, 0.03711727f, -0.02868064f, 0.05997400f, 
    0.06523500f, 0.04313716f, 0.06213864f, 0.04174150f, 0.31692567f, 0.06297401f, 0.03715700f, -0.04720051f, 
    0.11776742f, 0.10126427f, 0.09492216f, -0.02970266f, 0.03522087f, -0.01836645f, -0.02873930f, 0.14616954f, 
    0.24812880f, -0.21942256f, -0.03361655f, 0.15880816f, 0.15245165f, 0.00893742f, 0.22252528f, -0.12497031f, 
    0.03475262f, -0.00955516f, -0.10388952f, -0.07175845f, 0.09392604f, -0.02214335f, -0.19557415f, 0.36946663f, 
    0.00453846f, 0.20441177f, 0.09289346f, -0.07794940f, 0.05885324f, 0.08482164f, 0.03494880f, -0.05570936f, 
    -0.22057998f, -0.00867840f, 0.15629041f, 0.02180718f, 0.03519432f, -0.03684190f, -0.02802835f, 0.01271979f, 
    -0.07235709f, -0.04485129f, 0.09725811f, -0.00901543f, -0.02562972f, 0.02340279f, 0.20118843f, 0.13866799f, 
    0.14149578f, 0.09708229f, 0.07122117f, -0.11279170f, -0.06950827f, 0.01965584f, 0.06047367f, 0.01280564f, 
    -0.32144743f, 0.18145424f, 0.20147084f, -0.13605846f, 0.07073591f, -0.05615130f, -0.07401033f, 0.00142348f, 
    0.04058250f, 0.05511539f, 0.17853449f, 0.01271475f, 0.16417763f, 0.26066303f, 0.08711553f, 0.20096044f, 
    0.04947550f, 0.03147448f, 0.00532598f, -0.03893875f, 0.01052759f, -0.13233984f, 0.08241574f, 0.02341847f, 
    -0.12757458f, -0.01750423f, -0.16606972f, 0.43958983f, -0.08813689f, 0.16835707f, 0.10326505f, 0.08403318f, 
    -0.02333491f, -0.01818193f, -0.32404277f, -0.08655958f, 0.16940442f, 0.05940509f, -0.05198245f, 0.04655248f, 
    0.03961889f, 0.10227415f, 0.19307867f, -0.18231362f, -0.08785109f, -0.14393921f, 0.03019933f, 0.02552175f, 
    0.04762412f, 0.13503012f, -0.01468859f, -0.09721566f, -0.04375082f, 0.03096927f, -0.01596098f, -0.05012851f, 
    -0.03016020f, 0.01877561f, 0.04405932f, -0.02164459f, -0.40260643f, 0.16763619f, 0.07048490f, 0.00562139f, 
    -0.00750063f, 0.18154694f, 0.12955149f, -0.05571659f, -0.03563533f, -0.07075424f, 0.12433839f, -0.09224322f, 
    -0.07308129f, 0.07255226f, 0.15700035f, 0.19134387f, -0.07443430f, -0.10074144f, -0.07456853f, 0.14200532f, 
    -0.15882450f, -0.08274468f, 0.05373928f, 0.04136154f, -0.09872333f, 0.05002758f, 0.17768283f, -0.05547616f, 
    -0.00026965f, -0.02753552f, 0.05195781f, 0.05683632f, 0.00608175f, 0.02861415f, -0.05030365f, -0.00756299f, 
    0.41369629f, 0.20952179f, -0.09123100f, 0.05905750f, -0.04796481f, -0.09869140f, 0.01200589f, 0.00883025f, 
    0.03259265f, 0.01675838f, -0.10427393f, 0.07417255f, -0.20219861f, -0.06946594f, -0.18837892f, 0.20432316f, 
    -0.01099424f, 0.09607638f, 0.06262238f, -0.15477598f, 0.01425472f, 0.15320188f, -0.20198855f, 0.07332491f, 
    -0.30900970f, -0.06898610f, 0.16468860f, -0.25037560f, -0.10943723f, -0.10284556f, -0.05407140f, 0.00567333f, 
    0.13236448f, -0.02890069f, 0.07291722f, 0.14264743f, -0.16519666f, 0.10619017f, -0.10304441f, 0.10226779f, 
    0.09145506f, 0.08317572f, -0.06854244f, -0.17704612f, -0.09511835f, 0.00630728f, 0.00295774f, -0.10756891f, 
    0.05099194f, -0.09045371f, -0.08785798f, 0.22259934f, 0.09680359f, 0.01207239f, -0.00255943f, -0.13771595f, 
    0.00104650f, 0.11290448f, 0.00826463f, -0.03488379f, -0.16156158f, -0.18330218f, -0.11474695f, 0.00884960f, 
    0.11954231f, 0.00940648f, -0.03336887f, 0.00175726f, -0.05964009f, 0.02835717f, -0.13274325f, 0.08245891f, 
    0.13859764f, -0.07343298f, -0.04824648f, -0.18872395f, 0.00738537f, 0.11647607f, -0.02050115f, -0.05612051f, 
    0.19285709f, 0.03595559f, -0.00154164f, 0.11029559f, -0.02428157f, -0.03745826f, -0.11468890f, 0.12785424f, 
    0.16426675f, 0.01130079f, -0.01845041f, -0.02232822f, 0.05887143f, -0.13270292f, -0.04645792f, -0.08451844f, 
    -0.14467576f, -0.20277250f, -0.02264213f, -0.16032363f, 0.11535466f, -0.02740126f, -0.03173903f, 0.08213182f, 
    -0.04617174f, 0.03771674f, -0.01933529f, 0.09299719f, 0.36936241f, 0.07252076f, 0.11764946f, -0.02879612f, 
    -0.04830138f, 0.03221127f, -0.02786575f, 0.07494263f, -0.08447721f, -0.05866983f, 0.01795542f, -0.06886077f, 
    0.22816023f, 0.14260297f, -0.01194581f, -0.00426604f, -0.03787464f, -0.12039397f, -0.04426014f, 0.03388380f, 
    0.09027816f, 0.07691374f, 0.26567149f, 0.06314484f, 0.15045291f, 0.09333482f, -0.17692985f, -0.15445434f, 
    0.06748530f, -0.00166498f, -0.07030379f, 0.10748658f, 0.03305637f, -0.06845482f, 0.09465171f, -0.10627943f, 
    0.00784876f, 0.02846152f, 0.12158255f, -0.10636636f, -0.10766275f, 0.18846589f, 0.01500388f, -0.02944428f, 
    0.08440483f, 0.00466213f, 0.03063624f, -0.17335747f, 0.38571492f, 0.10108453f, -0.25355300f, -0.00366436f, 
    -0.01776441f, 0.00104821f, 0.02955613f, -0.10609662f, 0.07401294f, -0.00680196f, 0.03691257f, -0.14657958f, 
    0.08697257f, 0.07551292f, 0.10852798f, 0.12564330f, -0.06538284f, -0.06335705f, 0.13937521f, -0.00472142f, 
    0.03878968f, -0.06542122f, -0.05476842f, 0.07675657f, 0.24548103f, -0.12865323f, 0.09372641f, 0.00027160f, 
    0.12811683f, 0.10566080f, 0.03615734f, 0.09763266f, -0.01199475f, 0.10850625f, -0.00623562f, 0.04200532f, 
    -0.16578318f, -0.22182378f, -0.08132219f, -0.00556149f, 0.12928860f, -0.03187698f, 0.11384771f, 0.07045384f, 
    0.10547018f, 0.04707730f, 0.04941949f, 0.04545004f, 0.00231904f, 0.04237227f, -0.00721121f, -0.04097755f, 
    0.00134868f, -0.02653418f, -0.18086345f, 0.16213724f, -0.05422943f, -0.02908934f, 0.04686425f, -0.03365920f, 
    0.14868386f, 0.04122725f, 0.09173696f, 0.07189299f, -0.01673991f, -0.07040985f, 0.03465769f, 0.01195800f, 
    -0.08167517f, -0.03535958f, 0.08923091f, -0.01289195f, 0.00873819f, 0.23149620f, -0.09547643f, -0.07036225f, 
    -0.12873773f, 0.04972496f, 0.15016636f, 0.17468391f, 0.02456063f, -0.00481865f, -0.01925411f, -0.05388714f, 
    0.02734663f, 0.21096225f, 0.02180998f, -0.22167252f, -0.01538010f, -0.00811910f, 0.04786544f, -0.07807547f, 
    0.06545594f, -0.02417338f, -0.00614947f, -0.02126617f, -0.01645634f, 0.07186108f, 0.05336497f, -0.09834301f, 
    0.09461628f, 0.00273869f, -0.01394208f, 0.10077991f, -0.00760041f, -0.00355941f, -0.02243284f, 0.17597224f, 
    0.15334640f, -0.06607807f, -0.01389597f, 0.15503566f, -0.01078494f, 0.04366618f, 0.04579897f, -0.09179275f, 
    0.18761948f, 0.07321694f, 0.04596233f, 0.33445391f, 0.01712941f, 0.11529249f, -0.00199921f, -0.09958702f, 
    0.17257671f, -0.02152791f, 0.02376788f, 0.04237096f, 0.08597285f, -0.07116784f, 0.07551478f, -0.10852780f, 
    0.18958877f, 0.20671132f, 0.06080740f, 0.14221235f, -0.01304196f, 0.00709136f, -0.03940997f, -0.09309602f, 
    -0.09971441f, 0.03900020f, 0.00856777f, 0.11399129f, -0.13465983f, 0.06669320f, -0.02222952f, -0.06729101f, 
    0.09859192f, -0.01354818f, 0.05942822f, 0.11004916f, -0.07927233f, -0.09991645f, -0.01850322f, 0.07809867f, 
    0.07775404f, 0.11414819f, -0.23406142f, 0.07547861f, 0.13730849f, 0.09765413f, 0.00489696f, 0.08364172f, 
    -0.03005225f, 0.07162970f, 0.10430039f, 0.05593346f, -0.01669738f, -0.03047027f, -0.11951703f, -0.01678424f, 
    -0.04172042f, 0.01815612f, -0.11650101f, 0.14322129f, 0.10200717f, -0.03035981f, 0.11656120f, 0.01957762f, 
    0.19822748f, -0.10671280f, 0.02598482f, -0.00057661f, 0.05467711f, 0.09323698f, 0.15812990f, 0.02814724f, 
    0.04627561f, 0.06084264f, -0.07501929f, -0.04097319f, -0.16410527f, -0.13079689f, 0.11101735f, 0.16588964f, 
    0.00525525f, -0.10093082f, -0.13048275f, 0.06990118f, 0.01684066f, -0.01152564f, 0.06656396f, -0.02367335f, 
    -0.23154518f, 0.01214570f, -0.01941151f, 0.16944972f, -0.06000844f, 0.10631057f, 0.11577801f, 0.04567995f, 
    0.00472943f, 0.18253337f, -0.00791928f, 0.15043876f, -0.26408508f, 0.20684026f, -0.11042484f, -0.01302985f, 
    0.10901347f, 0.09485710f, 0.03945399f, 0.00630752f, 0.02451282f, 0.16915248f, -0.04660260f, 0.02787808f, 
    -0.32050672f, 0.03228853f, 0.00785075f, -0.19258992f, 0.10036502f, -0.14904384f, -0.06170525f, -0.09472882f, 
    0.01502077f, -0.07227186f, 0.12183026f, 0.04932036f, 0.38724840f, 0.03766953f, 0.12652998f, 0.07475886f, 
    0.06122166f, -0.00865465f, -0.00555925f, 0.03249196f, -0.17381750f, 0.09536867f, 0.10152724f, 0.08824619f, 
    -0.03792986f, 0.06428044f, -0.04463833f, 0.33398852f, 0.01503172f, 0.00777869f, 0.00810185f, 0.03103556f, 
    0.05740491f, 0.01326802f, -0.03314428f, 0.08855656f, 0.15282515f, -0.02271049f, 0.18508120f, 0.20186101f, 
    -0.03529364f, -0.01398873f, 0.06516746f, -0.08606737f, -0.04341901f, -0.12303865f, 0.06844022f, -0.03568777f, 
    -0.29615587f, 0.18677588f, -0.00868171f, -0.17187692f, 0.02695902f, -0.05391572f, -0.03986957f, -0.02942867f, 
    0.05011565f, 0.06617075f, -0.02433740f, -0.06777232f, -0.08213306f, 0.01462675f, 0.14207360f, -0.15981328f, 
    0.14700891f, -0.02103484f, -0.07972566f, 0.03487988f, -0.08979604f, 0.05596456f, -0.07881875f, 0.02877721f, 
    -0.22774920f, -0.13947614f, -0.09474355f, -0.07947570f, 0.11573809f, 0.05304730f, 0.05485569f, 0.02621380f, 
    0.06206292f, -0.00651587f, 0.07903395f, 0.26328906f, -0.02861212f, 0.21152169f, -0.28607646f, -0.15702166f, 
    0.29957801f, -0.10101247f, 0.07807145f, 0.00435799f, 0.08869447f, -0.00092621f, 0.01096499f, -0.02679062f, 
    -0.12011784f, 0.10177391f, -0.00315666f, -0.07304823f, 0.01804647f, 0.09729426f, -0.09413635f, -0.08088965f, 
    -0.05415795f, 0.01558060f, -0.00518743f, 0.00779754f, 0.05770630f, -0.26850033f, 0.03552940f, 0.26358092f, 
    -0.06769238f, -0.06065464f, 0.08359677f, 0.04231250f, -0.05392850f, 0.05995371f, 0.11740353f, 0.07823372f, 
    -0.20385444f, 0.08078153f, 0.17435560f, 0.15912518f, 0.10555846f, 0.01253083f, -0.01527494f, 0.11824183f, 
    -0.06003960f, 0.01193033f, 0.01579301f, 0.08462721f, -0.03554314f, 0.03078869f, -0.12434284f, 0.04400457f, 
    0.10243665f, -0.06336425f, -0.13646910f, -0.01443803f, 0.07102180f, 0.05988798f, 0.25082815f, 0.00981018f, 
    0.20940416f, -0.07915760f, 0.13717826f, -0.10466853f, 0.07439672f, 0.02173835f, 0.07272167f, -0.00385302f, 
    -0.07641289f, -0.01794044f, 0.06750437f, -0.07048010f, 0.10595034f, -0.31042507f, 0.14563361f, 0.04865155f, 
    0.18902840f, -0.05270947f, -0.06873610f, 0.10396522f, -0.04740610f, -0.03747918f, -0.00931966f, -0.08226001f, 
    -0.40872270f, 0.10971864f, 0.16289444f, 0.15534428f, 0.01896216f, 0.09416191f, -0.00736703f, 0.13245459f, 
    -0.00509945f, 0.12872082f, -0.05460581f, 0.05796317f, 0.24403521f, -0.04317774f, -0.04160926f, -0.11002124f, 
    0.10687964f, -0.09035822f, -0.04738908f, -0.09133942f, 0.09223393f, 0.10370564f, 0.07246154f, 0.14048342f, 
    -0.26058662f, 0.16788220f, 0.00028147f, 0.04605425f, 0.02755073f, -0.05759782f, -0.07464542f, -0.03249407f, 
    -0.00078050f, 0.00192109f, 0.05094182f, 0.04829387f, 0.14972633f, 0.01734919f, 0.07285093f, -0.26061815f, 
    0.11674878f, 0.12699978f, 0.09023859f, 0.01917053f, -0.08840110f, 0.00436715f, 0.09222392f, -0.00817927f, 
    -0.17817181f, 0.19016168f, -0.15629242f, 0.17570932f, 0.00423567f, 0.13377823f, -0.06829306f, 0.11146297f, 
    0.09980035f, -0.04258036f, 0.01958558f, -0.02136870f, 0.09119167f, -0.24891333f, -0.05688826f, -0.17120078f, 
    0.07014494f, 0.00014969f, 0.14988358f, -0.04433315f, 0.05049269f, -0.03949234f, 0.01556094f, 0.06622490f, 
    -0.02321345f, -0.05026282f, -0.02545666f, -0.07996836f, -0.07147536f, 0.03138627f, -0.03300716f, -0.01256028f, 
    -0.01734348f, -0.07785919f, 0.06032846f, 0.03985042f, 0.06082546f, -0.01167068f, -0.01572050f, -0.08026769f, 
    0.04615449f, 0.03293603f, 0.04429956f, -0.07341006f, 0.04836114f, 0.02836420f, -0.06323677f, -0.02380340f, 
    -0.05092055f, -0.08004433f, -0.07735331f, -0.01635808f, 0.04752174f, 0.02451588f, 0.06448144f, 0.05262727f, 
    0.05534617f, -0.06096580f, -0.00211106f, 0.06613795f, -0.02311117f, -0.07105476f, 0.00913569f, 0.04567150f, 
    -0.01497347f, 0.01459522f, -0.04811278f, -0.03456264f, 0.00771495f, 0.01279589f, 0.02729242f, -0.04187142f, 
    0.00793822f, 0.05909919f, -0.03533173f, 0.05025454f, -0.00504761f, 0.01119689f, -0.01260564f, -0.01259637f, 
    0.01862027f, 0.00715614f, 0.04894072f, 0.03857060f, -0.03335182f, 0.01199540f, -0.06721161f, -0.06991922f, 
    0.00790079f, -0.02833277f, -0.06795531f, -0.00250527f, -0.03961509f, -0.03366358f, -0.07498111f, 0.00608322f, 
    0.05470172f, -0.01352229f, -0.00657702f, -0.05904433f, -0.01124984f, 0.04689789f, -0.00120342f, -0.05091503f, 
    -0.03230082f, 0.04439307f, -0.04283680f, 0.02903712f, 0.03932393f, -0.00856688f, -0.06664730f, -0.03674074f, 
    0.02773096f, -0.03128882f, -0.05818760f, -0.02800079f, -0.03852632f, -0.03494289f, -0.01394394f, -0.07437260f, 
    -0.03404613f, 0.02580350f, -0.00823449f, 0.01698079f, -0.06274976f, -0.03790048f, 0.00508778f, -0.00206910f, 
    -0.04788143f, -0.02336237f, 0.04883894f, 0.01275147f, -0.04040959f, -0.06239934f, 0.00487184f, -0.05566916f, 
    -0.06224504f, -0.06955540f, 0.02836252f, -0.07346904f, -0.01012162f, -0.05235106f, 0.05409349f, 0.02903237f, 
    0.03069176f, -0.00630825f, -0.07121243f, -0.04083431f, 0.01370869f, -0.00758650f, -0.06365775f, -0.01376573f, 
    0.03731636f, -0.06092248f, 0.01186948f, 0.06014142f, 0.05741800f, -0.04574445f, 0.06157160f, 0.03513101f, 
    -0.03069333f, -0.01700012f, -0.07220940f, 0.05033442f, 0.00379055f, 0.00238355f, -0.00718167f, 0.01466134f, 
    0.02867370f, 0.05191182f, -0.01007590f, 0.01395101f, -0.05959155f, 0.03334032f, -0.07506420f, 0.04559621f, 
    0.03312097f, 0.04004330f, -0.07957447f, 0.04874909f, -0.04824629f, -0.04450048f, 0.01773055f, -0.03906123f, 
    -0.01770663f, -0.02325109f, 0.04277666f, 0.05525679f, 0.04094042f, 0.00727337f, 0.02933102f, 0.01960591f, 
    -0.02898422f, 0.01689184f, -0.08061659f, -0.05361046f, 0.03892682f, -0.00827729f, -0.01387849f, 0.03399378f, 
    -0.00098289f, 0.04922400f, -0.01133974f, -0.03607114f, -0.04557034f, -0.03357067f, 0.01413586f, 0.04365159f, 
    -0.02858650f, -0.00433647f, -0.01980849f, -0.05055988f, -0.04396548f, -0.01815425f, 0.01182058f, -0.06516797f, 
    0.04148543f, 0.01236893f, 0.03550693f, -0.03348380f, 0.01749938f, 0.01588639f, 0.04132998f, -0.06840609f, 
    -0.04236899f, 0.02243285f, 0.01689879f, -0.02654075f, -0.02271128f, 0.04328463f, 0.01399476f, -0.01023073f, 
    -0.02107327f, -0.04955716f, 0.03216908f, 0.06355867f, 0.02160549f, -0.01625659f, 0.03856713f, 0.04087118f, 
    0.01129280f, 0.02270874f, 0.04041297f, -0.01731459f, 0.01834387f, 0.06752671f, 0.00521145f, 0.05230152f, 
    0.03150946f, -0.01575747f, -0.04150664f, 0.04630940f, 0.03504227f, 0.02629011f, -0.06775720f, 0.01973893f, 
    -0.03413067f, -0.00331029f, -0.07237104f, 0.06218912f, -0.03625365f, -0.06563602f, -0.02995404f, 0.02068699f, 
    -0.02866108f, 0.00548505f, 0.02543779f, 0.02735601f, 0.05732871f, 0.05574424f, -0.08050201f, 0.02121081f, 
    -0.07632483f, -0.05474101f, -0.00854840f, 0.05577509f, -0.03049652f, 0.03629188f, 0.01812783f, -0.03996313f, 
    -0.02948731f, -0.04534462f, -0.04700354f, -0.01734656f, -0.04798379f, -0.03626609f, -0.01641521f, 0.04172955f, 
    -0.02418587f, -0.06730964f, -0.05066859f, -0.00214895f, -0.07031217f, -0.07796676f, 0.03613858f, -0.00684691f, 
    -0.05082035f, -0.01458755f, -0.00609081f, -0.03081039f, -0.04356009f, -0.03656730f, -0.05856206f, -0.05035203f, 
    -0.01211626f, 0.05796826f, -0.00331216f, -0.06022836f, -0.01027273f, 0.02888079f, 0.05555146f, -0.04009414f, 
    -0.01744561f, 0.00581408f, 0.01599886f, 0.02804632f, -0.04258387f, -0.02609201f, -0.07647654f, -0.01025453f, 
    0.05591653f, 0.02126160f, -0.02012728f, 0.06093327f, -0.03432908f, 0.02112921f, -0.01753376f, -0.07186593f, 
    -0.06154775f, 0.06392436f, -0.06254040f, 0.04867541f, -0.03876674f, -0.01372304f, 0.04281608f, 0.01796068f, 
    -0.04173579f, -0.00015979f, 0.04681828f, 0.01868676f, -0.01181107f, -0.00527032f, -0.06978062f, -0.02001105f, 
    -0.05009436f, 0.05924170f, -0.00636864f, -0.00317576f, -0.03648526f, -0.03402019f, 0.05327430f, -0.07491553f, 
    -0.05785362f, -0.05477009f, 0.02114499f, 0.02162125f, -0.03953769f, -0.00321069f, -0.04631650f, -0.00093368f, 
    0.05255876f, -0.05807135f, 0.02942860f, 0.01053755f, -0.00714644f, 0.02578061f, -0.00164024f, 0.02096677f, 
    0.01520000f, -0.03589339f, -0.06353553f, 0.01212799f, 0.05865623f, 0.03532938f, 0.05680573f, -0.05742289f, 
    -0.02275395f, -0.03339041f, -0.06868318f, -0.05583496f, -0.05525101f, 0.03238845f, -0.04127079f, 0.03135699f, 
    0.00106336f, -0.02870009f, -0.06352380f, 0.04791510f, -0.03456181f, -0.05854208f, 0.01738956f, -0.03139283f, 
    0.00522073f, -0.04017454f, -0.02068431f, -0.06164227f, -0.04914571f, 0.06278045f, -0.07590170f, -0.04606110f, 
    -0.02546632f, -0.00920333f, -0.04570449f, -0.02111668f, 0.06141754f, 0.06190947f, 0.05067489f, 0.00519283f, 
    0.29881608f, 0.00583512f, 0.12485611f, 0.15103276f, -0.09892177f, -0.00680556f, 0.15038195f, 0.03934570f, 
    0.08395454f, 0.02086563f, 0.06700835f, -0.03199666f, 0.04074902f, 0.07007207f, -0.11659635f, 0.28008941f, 
    -0.10316733f, 0.07819682f, 0.09599639f, -0.08758835f, -0.07957629f, -0.01898307f, -0.09944549f, 0.08402037f, 
    -0.03921887f, 0.05692655f, 0.01344510f, -0.13365725f, 0.15075240f, -0.05427173f, 0.13618371f, -0.06382556f, 
    -0.03278707f, 0.04018174f, -0.02493764f, -0.02538530f, 0.25389719f, 0.22464083f, -0.05596066f, -0.07272453f, 
    -0.06152047f, -0.02411999f, -0.03698936f, -0.01848998f, 0.03031491f, -0.01445106f, -0.06856512f, -0.08929647f, 
    -0.26280111f, -0.24565923f, 0.13031352f, -0.15703250f, 0.24099986f, 0.00914889f, 0.06467570f, 0.07639214f, 
    0.05766884f, 0.00494347f, -0.13758546f, 0.10135371f, 0.50285935f, 0.02074141f, -0.02655617f, -0.37948662f, 
    0.04958857f, 0.02589501f, -0.20926271f, 0.15012638f, 0.13168301f, 0.09756471f, 0.00585704f, -0.02299211f, 
    0.23072326f, 0.03172230f, -0.16981047f, -0.04343827f, -0.03735453f, -0.08612868f, 0.09590328f, 0.08764834f, 
    0.05596029f, 0.07164221f, 0.16253668f, -0.04789181f, 0.25574118f, -0.06061339f, 0.17421612f, -0.17459339f, 
    -0.15023740f, -0.05907319f, 0.21079777f, 0.22804597f, -0.00673903f, 0.14200166f, 0.10598049f, -0.00327779f, 
    -0.10050186f, -0.02718100f, 0.12150987f, -0.06173841f, -0.09384206f, 0.04908220f, 0.02990904f, -0.02710591f, 
    -0.12478137f, -0.06175289f, 0.17772548f, -0.17116506f, 0.13874598f, 0.06141447f, 0.13891847f, -0.20759438f, 
    -0.14425825f, 0.18861131f, 0.07769094f, -0.20425655f, -0.05714021f, -0.07579082f, 0.00150068f, -0.06135659f, 
    0.13033780f, -0.23986882f, 0.01914918f, -0.16163510f, 0.26884800f, -0.10502036f, 0.18020007f, 0.08325078f, 
    -0.04679270f, -0.01770577f, -0.14356673f, 0.14787243f, 0.00665510f, 0.12130512f, -0.00048340f, -0.03073278f, 
    -0.12625678f, 0.04958463f, 0.06128892f, -0.04152526f, 0.05934783f, 0.18243888f, 0.03294938f, 0.02453677f, 
    -0.01770383f, 0.22664976f, -0.14107405f, 0.22255562f, 0.10772711f, 0.06270559f, 0.00141940f, -0.02601579f, 
    0.01996391f, 0.05892777f, 0.14374714f, -0.05394790f, 0.18041888f, -0.05024413f, -0.11311834f, 0.02866954f, 
    0.14424993f, -0.07339363f, -0.08489852f, -0.01620828f, 0.04645301f, 0.11024494f, 0.08390865f, -0.03699334f, 
    -0.11768656f, -0.08468762f, 0.25211969f, -0.02992530f, 0.00054581f, -0.02363366f, 0.10185561f, -0.07735808f, 
    -0.13829845f, -0.00211042f, 0.02083756f, -0.06629529f, -0.10137578f, 0.05979853f, -0.11380129f, -0.08830621f, 
    -0.01801733f, 0.13457780f, -0.02711589f, 0.16796257f, -0.11063509f, 0.06790598f, -0.08096907f, -0.01494226f, 
    0.24981543f, 0.03664105f, 0.07833967f, 0.20306230f, -0.09477598f, -0.02578140f, -0.00081984f, -0.01796096f, 
    0.04144459f, 0.01260250f, -0.02729442f, -0.08484884f, 0.14148968f, 0.03480611f, -0.01794407f, 0.20541538f, 
    0.01710410f, 0.13079792f, 0.01971790f, 0.01133006f, -0.03001639f, -0.05243226f, -0.03555248f, 0.04470070f, 
    -0.24053873f, -0.13603495f, -0.05641559f, -0.13449167f, 0.12365367f, -0.02850609f, -0.00500409f, -0.07852523f, 
    -0.00484095f, -0.05553280f, -0.08647330f, -0.02685679f, 0.11050798f, 0.27139002f, -0.29863718f, 0.00687269f, 
    0.03332951f, -0.06902799f, 0.00345602f, 0.01376312f, -0.00033233f, -0.09195452f, -0.05360127f, -0.02920441f, 
    -0.31297868f, 0.18631572f, 0.17128742f, -0.19570580f, 0.02195926f, 0.04393173f, 0.03275293f, -0.05250463f, 
    -0.04630040f, -0.10487103f, 0.00524591f, 0.01270994f, 0.41542590f, -0.03689206f, 0.14039546f, 0.13763836f, 
    0.02913994f, 0.06947924f, -0.02052568f, 0.11164231f, 0.03311946f, 0.01743799f, -0.02554251f, -0.05726529f, 
    -0.16647993f, 0.09290285f, 0.11239613f, 0.08827075f, 0.11842261f, -0.06615335f, -0.05346003f, 0.13306595f, 
    0.05262167f, 0.03512102f, 0.03049009f, 0.03535522f, 0.03762392f, -0.16775437f, 0.03850352f, -0.20061697f, 
    -0.09912999f, -0.08292716f, -0.03799669f, 0.05112870f, 0.05303229f, 0.03485584f, 0.15032206f, 0.00938979f, 
    0.17686819f, -0.11197678f, 0.06194374f, -0.19902249f, 0.02642883f, 0.06214621f, 0.09204959f, -0.09472277f, 
    -0.04258419f, -0.10366323f, 0.08890872f, 0.01702519f, 0.11508873f, -0.20700839f, 0.14287660f, -0.00086270f, 
    -0.00248387f, 0.12296003f, -0.01832263f, -0.05302648f, 0.00083021f, -0.01284185f, 0.02043904f, -0.01400817f, 
    -0.23695542f, 0.06747705f, 0.20895514f, 0.14687209f, 0.12307151f, 0.02372644f, -0.02487253f, 0.22791126f, 
    -0.02995177f, 0.08264344f, -0.04034663f, 0.02587953f, 0.03247828f, -0.00541314f, 0.04642225f, -0.05264416f, 
    -0.02136498f, 0.03920006f, -0.09427166f, 0.04217417f, 0.14199114f, 0.14258879f, -0.02424154f, 0.13828167f, 
    0.00986837f, 0.27012259f, -0.10971357f, 0.15186924f, 0.09334294f, 0.03282415f, -0.01504091f, -0.01305933f, 
    -0.04129473f, -0.01344111f, 0.10717202f, 0.09163325f, 0.05750795f, 0.02044193f, -0.11427747f, 0.00684539f, 
    0.13415657f, 0.02405214f, 0.04752696f, -0.09338223f, 0.01852699f, 0.11231962f, 0.09741031f, 0.01868680f, 
    -0.26471338f, 0.07885347f, 0.07658006f, -0.06745753f, -0.08292494f, 0.06010301f, -0.13613145f, 0.00523261f, 
    0.01569315f, 0.04016570f, 0.03063687f, -0.01716456f, -0.09458081f, -0.18793875f, -0.14726898f, -0.20328258f, 
    -0.03654426f, 0.06579099f, 0.07280637f, -0.07842463f, 0.08386477f, 0.04233223f, -0.00340987f, -0.02055156f, 
    -0.29599723f, 0.16301906f, -0.02324386f, 0.03904045f, 0.00766440f, 0.09278053f, -0.05487580f, 0.05951181f, 
    0.08953754f, 0.01602702f, 0.01839759f, 0.04614634f, -0.15983109f, -0.17974806f, -0.06414415f, -0.17853415f, 
    -0.04445455f, -0.25444236f, -0.04845536f, 0.00013839f, -0.00104926f, -0.04511151f, -0.01650493f, -0.00902112f, 
    0.06220051f, 0.05154836f, 0.11136013f, -0.01818358f, -0.05621519f, -0.00919365f, 0.01874226f, -0.06627937f, 
    0.00692794f, -0.07307064f, -0.11930238f, -0.00330569f, 0.04861998f, -0.13365096f, -0.06090840f, -0.03042899f, 
    -0.22342788f, -0.07460696f, 0.03613992f, -0.05304846f, 0.02331441f, 0.03115689f, 0.02497489f, -0.12766925f, 
    0.13379231f, -0.07185730f, -0.01109212f, 0.14146295f, -0.00805118f, -0.01320448f, 0.08169549f, 0.20812899f, 
    0.06757022f, 0.06958400f, -0.08622483f, 0.12741193f, 0.30831546f, 0.21015990f, 0.05657151f, -0.17289580f, 
    0.05412275f, 0.04651592f, -0.05540551f, 0.15384157f, 0.01922969f, 0.03122467f, -0.05015636f, 0.04471516f, 
    0.41489384f, -0.00311252f, 0.10776459f, -0.10587876f, -0.13677338f, -0.04500973f, 0.05516715f, -0.11289475f, 
    0.09125730f, -0.06074594f, 0.18599907f, -0.03539566f, -0.21123008f, 0.08752111f, 0.02762674f, -0.10345986f, 
    0.09710532f, -0.10473648f, 0.05694384f, 0.14735739f, 0.07916170f, -0.01123051f, 0.01991805f, 0.03311961f, 
    -0.21457954f, 0.17679249f, 0.08268905f, 0.16134688f, 0.03034040f, 0.04545613f, 0.01439098f, -0.04642127f, 
    0.05012592f, 0.00195893f, 0.10643472f, -0.03178329f, 0.21193647f, -0.04980361f, -0.15698838f, -0.17932701f, 
    0.14697354f, 0.12452534f, -0.04258769f, 0.02315727f, -0.10212805f, 0.01739805f, -0.00932169f, -0.04858689f, 
    0.49051148f, 0.09482063f, -0.10531639f, -0.27472556f, 0.01988013f, -0.00364213f, 0.20413244f, -0.11582780f, 
    0.02336664f, 0.02213171f, -0.02518124f, 0.11961076f, 0.42108467f, 0.07708939f, -0.04283062f, 0.10262057f, 
    -0.11524465f, -0.06258390f, 0.00968512f, -0.14452298f, 0.11378917f, 0.09518243f, 0.04613215f, 0.03036977f, 
    -0.18296736f, -0.13900000f, -0.10726517f, 0.07977737f, 0.14896616f, 0.02849439f, 0.04515964f, 0.04410478f, 
    0.12366684f, 0.00845670f, 0.08681563f, 0.04811545f, -0.12617420f, -0.05748217f, 0.15528560f, 0.05823060f, 
    0.04793580f, -0.10270116f, -0.02064534f, 0.01805027f, 0.01986017f, 0.04255966f, 0.10595392f, -0.03194945f, 
    -0.04691858f, 0.09562505f, 0.11495455f, 0.03636168f, -0.06055420f, 0.06163666f, 0.05777590f, -0.03904700f, 
    -0.08198704f, 0.14073431f, 0.02433733f, -0.07823438f, 0.15150790f, -0.09142724f, 0.00660204f, -0.01428192f, 
    -0.09345444f, 0.03332583f, -0.10610647f, 0.29342800f, 0.08437175f, 0.00706753f, -0.06023559f, 0.07737164f, 
    0.04302370f, -0.17518538f, 0.03070386f, 0.16150646f, 0.04690533f, -0.11625441f, -0.17198779f, -0.04633907f, 
    -0.04309069f, -0.01281622f, -0.03564944f, 0.11805566f, 0.03668919f, 0.05342817f, 0.06706667f, -0.05298573f, 
    -0.07335465f, 0.05480458f, -0.07819862f, -0.02352494f, 0.01345618f, 0.02928008f, 0.16151448f, -0.02085982f, 
    -0.10595974f, -0.01105140f, -0.12253710f, 0.31975290f, 0.04567218f, -0.06626109f, 0.04420259f, 0.06021867f, 
    -0.04494281f, -0.02068608f, -0.04469176f, -0.30091667f, -0.04344618f, 0.10381223f, -0.01408476f, -0.05187995f, 
    -0.11058509f, -0.04045512f, -0.03898688f, -0.01032687f, 0.00497277f, 0.26299220f, 0.10795515f, 0.15474352f, 
    -0.17191288f, 0.10376620f, 0.10000201f, -0.13987237f, 0.03681384f, -0.00597330f, -0.03154382f, -0.07236605f, 
    0.09320988f, 0.07559551f, 0.15031627f, -0.01470468f, 0.01187389f, 0.02691077f, -0.11943910f, 0.16464314f, 
    0.01264199f, 0.02641808f, 0.03043970f, 0.00592515f, 0.05645964f, 0.09574506f, 0.15163483f, -0.03604665f, 
    0.05603104f, 0.00826170f, 0.07847611f, 0.20869008f, 0.07486745f, 0.22480209f, 0.14250478f, 0.05809224f, 
    0.09947094f, 0.02122971f, -0.36296982f, -0.05463791f, -0.09867023f, -0.11828381f, 0.16170572f, 0.08534228f, 
    0.10627427f, 0.03503677f, 0.08527058f, -0.12820072f, -0.02149388f, -0.01149304f, -0.33608937f, 0.14104502f, 
    -0.10824237f, 0.05966686f, 0.04664324f, -0.16090156f, 0.05494055f, -0.10590895f, -0.12650628f, -0.06993885f, 
    -0.01023414f, 0.01681008f, 0.10542210f, 0.17897795f, 0.01494641f, -0.08135126f, 0.05241575f, -0.20952858f, 
    -0.10767074f, 0.05763754f, 0.02888483f, 0.03806654f, 0.14903453f, 0.01794821f, 0.10059023f, 0.11886474f, 
    0.17919964f, 0.26222417f, 0.00163600f, 0.03180842f, 0.00024693f, 0.07381968f, -0.14078529f, 0.11706089f, 
    0.00873681f, -0.21887977f, 0.00432315f, -0.21156363f, -0.01783340f, 0.18921192f, 0.03420837f, -0.02888001f, 
    -0.01387396f, -0.02187843f, 0.01235896f, -0.02975569f, -0.11879424f, -0.15356603f, -0.12330512f, -0.07801585f, 
    0.20021276f, 0.19779085f, 0.08449732f, -0.03437895f, -0.09888893f, 0.06006915f, 0.06869148f, -0.01016773f, 
    0.21754913f, 0.13208482f, -0.13955142f, -0.01587435f, -0.29925242f, 0.10972136f, -0.00697627f, 0.12495069f, 
    -0.02789989f, -0.02132407f, 0.16095337f, -0.00489568f, 0.03101230f, -0.12257683f, -0.10084844f, -0.04612774f, 
    0.02584684f, -0.13163918f, 0.01482505f, -0.03231990f, -0.03338118f, 0.15896992f, 0.03781319f, 0.04764593f, 
    0.11208766f, -0.05461308f, 0.15268895f, 0.11872179f, 0.15093625f, -0.06331026f, -0.05677862f, -0.02821345f, 
    -0.00393180f, -0.03547255f, -0.00230425f, -0.00660789f, -0.14566503f, 0.11320546f, 0.12142374f, 0.12357437f, 
    -0.00991055f, 0.01766055f, -0.07199859f, -0.05291162f, -0.00964118f, -0.00239126f, 0.00080412f, -0.07725579f, 
    -0.04890056f, 0.02699346f, -0.02909119f, 0.01956735f, 0.04003272f, 0.02729879f, 0.00811568f, -0.04686850f, 
    0.03207035f, 0.00759744f, -0.03291942f, -0.02981008f, -0.01149600f, -0.04529942f, 0.05722509f, 0.05748935f, 
    -0.08014643f, 0.03119822f, 0.05318299f, 0.06323093f, -0.07197041f, -0.07017225f, 0.02353883f, -0.05985158f, 
    0.01729175f, 0.01960368f, -0.00557232f, 0.00153828f, -0.06416022f, -0.01303498f, 0.04430624f, -0.04494853f, 
    -0.04662161f, -0.05884840f, 0.04032670f, 0.03025169f, 0.00034300f, -0.01584087f, 0.04872333f, 0.01528773f, 
    0.01602588f, 0.05667278f, 0.00850833f, 0.03688864f, 0.03602416f, -0.00205553f, -0.00327441f, 0.04205436f, 
    0.01971941f, 0.03481166f, 0.03942614f, -0.07003401f, -0.00542738f, -0.06067310f, 0.03201971f, 0.00414360f, 
    0.00190303f, -0.03510120f, -0.06525148f, -0.04363555f, 0.03101543f, 0.06269100f, 0.00185125f, -0.04293703f, 
    0.01208510f, -0.04859638f, -0.02438287f, 0.02418889f, 0.02788517f, 0.00845792f, 0.02460400f, -0.01040835f, 
    0.03445338f, -0.06777689f, 0.00151027f, -0.02187161f, -0.07360885f, -0.03728627f, -0.05150383f, 0.04797878f, 
    -0.06568717f, -0.07193819f, 0.03770879f, 0.05226151f, -0.07558680f, -0.05106481f, -0.04841859f, -0.01746080f, 
    -0.05885995f, -0.03313117f, 0.00172814f, 0.01565992f, -0.05946812f, 0.02460207f, -0.05646770f, 0.03810638f, 
    0.06142713f, -0.01600098f, 0.01875406f, -0.07496315f, 0.00424886f, 0.03738914f, 0.05737685f, -0.00968554f, 
    -0.06104026f, -0.03989631f, 0.04983656f, -0.01250892f, -0.03135385f, -0.04403554f, 0.01855352f, -0.00354479f, 
    -0.04219664f, 0.05017607f, 0.01920478f, -0.05762871f, -0.06723972f, 0.05231803f, 0.06283966f, 0.01168259f, 
    -0.02822706f, 0.00009806f, -0.07220785f, -0.07195894f, 0.01849459f, -0.07074507f, -0.07439805f, -0.04489231f, 
    0.00430751f, 0.00439893f, -0.04138222f, -0.03549349f, -0.01609567f, -0.08077990f, 0.01188633f, 0.03714517f, 
    -0.00859139f, -0.05541010f, 0.05657665f, 0.02849242f, 0.03644665f, -0.02489827f, 0.04660067f, -0.07720476f, 
    -0.02270463f, 0.01875534f, -0.07145470f, -0.02195513f, -0.06546581f, -0.04329646f, 0.01401858f, 0.00466031f, 
    -0.02779447f, -0.01220818f, -0.03259699f, -0.05887748f, -0.06286390f, 0.04408206f, 0.00493413f, 0.00149269f, 
    0.02049887f, 0.01336739f, -0.05622733f, 0.06529245f, -0.02688226f, 0.00627487f, -0.06280087f, 0.00731370f, 
    0.01207610f, 0.05684097f, 0.00656339f, -0.07752509f, 0.01957433f, 0.02902110f, -0.02714002f, -0.03756862f, 
    0.04087197f, 0.04155872f, 0.00034648f, -0.03204500f, 0.01272104f, -0.04165053f, -0.06319714f, -0.07558106f, 
    0.01530299f, 0.00926426f, -0.06728900f, -0.08440191f, -0.00876299f, 0.04516679f, -0.04502676f, 0.01909295f, 
    -0.03570581f, -0.04797266f, -0.01233541f, 0.04482913f, -0.08396428f, 0.02199951f, 0.03382273f, -0.04551188f, 
    -0.02442999f, -0.02795101f, 0.02361347f, -0.05516525f, -0.08626326f, 0.03316450f, 0.00797381f, 0.02301669f, 
    -0.03953051f, -0.05736969f, -0.00517563f, -0.03928746f, -0.05930489f, 0.06165192f, 0.04231180f, 0.01736770f, 
    -0.02036273f, 0.00841337f, -0.02594033f, -0.04022465f, 0.01312824f, 0.01984617f, 0.04911335f, -0.00072201f, 
    -0.04485842f, -0.00618570f, 0.03419813f, -0.04397070f, 0.02102714f, 0.00442322f, -0.03980985f, -0.02275944f, 
    0.05796250f, -0.00761186f, -0.02237533f, 0.01503791f, 0.01661852f, -0.04505504f, 0.04097820f, 0.03012641f, 
    -0.04299986f, 0.02335336f, -0.05210175f, -0.03738019f, 0.03596443f, -0.07892578f, -0.01250106f, 0.00915712f, 
    0.05038155f, -0.07352109f, 0.05408099f, 0.04511070f, -0.02793011f, -0.06359427f, -0.05392687f, -0.04297717f, 
    -0.07449610f, 0.04297147f, -0.00270337f, 0.00335964f, -0.01175034f, 0.00004879f, 0.03321971f, -0.00936776f, 
    0.02266160f, -0.06058266f, 0.01491064f, -0.01383681f, 0.04770653f, -0.03921529f, -0.06623413f, -0.04827568f, 
    -0.07600998f, -0.05382134f, -0.05487390f, -0.00366312f, 0.05051091f, 0.03956608f, -0.02239117f, -0.01616314f, 
    0.02490561f, 0.00752154f, -0.01009329f, -0.07983858f, -0.07452711f, -0.05471119f, 0.01319489f, -0.00435891f, 
    0.00969075f, -0.02420497f, 0.02869503f, 0.02523253f, 0.03541176f, -0.03099211f, 0.04573904f, 0.02105344f, 
    -0.07782659f, 0.05654224f, -0.00768713f, -0.03165190f, 0.02077269f, 0.03761081f, -0.07962006f, 0.03154239f, 
    0.01141911f, -0.04988574f, -0.07523217f, 0.06174612f, -0.05621333f, 0.01248740f, -0.02172801f, 0.00634444f, 
    -0.02522105f, -0.00308338f, 0.00510640f, -0.07743862f, -0.05900619f, -0.02681692f, -0.03757441f, -0.01248472f, 
    -0.03719057f, 0.04844216f, 0.05153771f, 0.06188506f, 0.03553389f, -0.00772193f, 0.01745637f, -0.02483243f, 
    -0.06210420f, 0.02984229f, -0.01331243f, 0.00990095f, -0.05989444f, -0.04916620f, 0.05421537f, 0.03448798f, 
    -0.01029841f, 0.01137315f, 0.04423536f, -0.03999867f, 0.01073178f, 0.05326453f, -0.02422687f, -0.06404521f, 
    -0.03470316f, -0.05505131f, -0.06644762f, 0.03930121f, -0.01822110f, -0.05743856f, -0.06438939f, -0.00435858f, 
    -0.04608990f, 0.02250827f, 0.04876600f, -0.04186930f, 0.05311441f, -0.00666371f, -0.01997394f, 0.02020432f, 
    0.01901179f, 0.06206715f, -0.02214623f, -0.01828644f, -0.07922205f, 0.01561503f, -0.01914179f, 0.04339886f, 
    -0.02324166f, -0.08053605f, -0.03886237f, -0.03080426f, 0.02861105f, -0.00926933f, -0.04472412f, -0.00177371f, 
    -0.01211114f, 0.29722384f, -0.04128951f, -0.24854238f, 0.01356751f, 0.07707434f, 0.03953958f, 0.08531259f, 
    -0.01887853f, 0.05394076f, 0.03232211f, 0.03059240f, -0.01539697f, 0.23843791f, 0.18624076f, -0.28163418f, 
    0.02173996f, -0.00636792f, 0.05989568f, -0.00804364f, 0.01804311f, -0.01127039f, -0.00154752f, 0.03880803f, 
    0.17500590f, 0.04809769f, -0.12448414f, 0.05077638f, -0.04273878f, 0.00188723f, -0.05428229f, -0.06166614f, 
    0.17949861f, 0.09737315f, 0.04369759f, 0.23132157f, -0.02550419f, -0.06798438f, -0.01618471f, 0.01905419f, 
    0.07136692f, -0.04045700f, 0.08022011f, -0.02439513f, 0.01167133f, 0.00504357f, 0.06464225f, -0.07256242f, 
    0.27153271f, 0.19460562f, -0.13586688f, 0.27268210f, -0.13950925f, 0.08129606f, -0.06325185f, 0.03859434f, 
    -0.07246212f, 0.05936371f, -0.02318497f, -0.06701633f, -0.22778037f, 0.01218326f, -0.02677614f, 0.20667666f, 
    -0.01109726f, -0.06054951f, 0.11748410f, 0.00204460f, -0.00857490f, 0.08142198f, 0.01318394f, -0.05139019f, 
    -0.06244524f, 0.14668499f, 0.04995492f, 0.08924169f, 0.06808361f, 0.15321550f, -0.03596474f, -0.00815583f, 
    -0.11606497f, 0.12450252f, 0.03950298f, 0.11010586f, -0.09043919f, 0.03724293f, 0.06909594f, 0.08387930f, 
    0.05124978f, 0.08430619f, -0.16588995f, 0.04652998f, -0.03983995f, 0.02942921f, 0.02529972f, 0.00422658f, 
    0.13481520f, -0.12549312f, -0.00293197f, 0.01675246f, 0.10116507f, 0.08148554f, -0.00487381f, 0.06677204f, 
    0.05638506f, 0.04659212f, -0.17728901f, -0.07436547f, 0.09358731f, -0.12289829f, 0.07663514f, 0.10355537f, 
    -0.01155185f, -0.11296979f, -0.06854178f, 0.10755646f, -0.01058681f, 0.02962027f, 0.06612070f, 0.11783869f, 
    -0.20404646f, 0.10281357f, 0.07147452f, 0.21478309f, -0.10461955f, 0.13286468f, 0.07878143f, -0.05347391f, 
    -0.01527093f, 0.21523947f, 0.01783788f, 0.01077419f, -0.26688600f, 0.18942735f, 0.03880483f, -0.08931699f, 
    0.08714365f, 0.05309982f, 0.07094429f, -0.01091034f, 0.06522397f, 0.09753422f, -0.11567032f, -0.02143345f, 
    -0.33480319f, -0.04019565f, 0.05921121f, -0.16698492f, -0.01483721f, -0.06514768f, -0.02639043f, -0.00524039f, 
    -0.08567636f, -0.08001992f, -0.09875957f, 0.04372223f, 0.25697345f, 0.08146977f, 0.04421912f, -0.01874776f, 
    -0.07454129f, 0.06943927f, 0.02644407f, 0.08458443f, -0.14943130f, -0.03065431f, 0.11926733f, -0.01763343f, 
    0.04853494f, 0.09763015f, -0.04812790f, 0.24825828f, 0.07140201f, -0.08354959f, -0.11463682f, -0.02293709f, 
    0.03526335f, -0.04761725f, -0.01297765f, 0.08149166f, 0.07795545f, -0.07274034f, 0.12770386f, 0.30092621f, 
    -0.07660516f, -0.08616442f, -0.01495864f, -0.11118951f, -0.02365756f, -0.04530676f, 0.00808618f, 0.03691972f, 
    -0.13227099f, -0.01064654f, 0.11577610f, 0.04029512f, 0.06608681f, -0.08843209f, -0.08814336f, -0.04746692f, 
    0.05274097f, -0.08437867f, 0.01945922f, 0.15914965f, 0.12833706f, 0.12259202f, 0.19460137f, -0.10879076f, 
    -0.03928918f, 0.08169866f, -0.11356848f, 0.06468676f, -0.04581971f, 0.06064046f, 0.07463770f, 0.00238398f, 
    -0.10416549f, -0.02455145f, -0.19744812f, -0.06337935f, -0.00605320f, 0.06578919f, 0.17864487f, 0.12793559f, 
    -0.01223539f, 0.03557355f, -0.04352472f, 0.00084126f, 0.19520527f, 0.24778029f, 0.18035376f, 0.00759397f, 
    0.15435183f, 0.03247245f, -0.04197818f, 0.08615270f, 0.08646268f, 0.13701777f, 0.07900596f, 0.08090670f, 
    -0.13576630f, -0.18704303f, 0.07765960f, -0.12919310f, 0.01266907f, 0.03442311f, -0.01270090f, 0.01433489f, 
    0.12579766f, -0.00685450f, 0.05565821f, -0.08207089f, -0.17016380f, -0.26614979f, -0.23271406f, 0.16932836f, 
    -0.06144256f, 0.04613883f, 0.05194207f, -0.08166406f, -0.03299295f, 0.11029145f, -0.05993886f, -0.00640578f, 
    -0.13174623f, -0.10770619f, 0.05724480f, -0.05097233f, 0.02785114f, -0.03285757f, 0.10941251f, 0.09759835f, 
    0.08336537f, -0.05193736f, -0.08774915f, 0.03711478f, 0.01571080f, 0.08091886f, 0.09152047f, 0.17484592f, 
    0.01509085f, -0.00490986f, -0.04018398f, -0.11616740f, 0.11088562f, 0.02497054f, -0.10623813f, 0.12865411f, 
    0.06129325f, -0.01938988f, 0.15357178f, -0.00021578f, -0.03847682f, -0.05774485f, -0.01824827f, 0.10921890f, 
    -0.01839908f, 0.03131121f, -0.00094553f, 0.03400257f, 0.44582054f, 0.10271125f, 0.04839270f, -0.02952999f, 
    -0.03032480f, 0.10877229f, 0.04403244f, 0.03285850f, 0.10095358f, 0.02824343f, -0.00746982f, 0.10027754f, 
    0.05941141f, -0.11003189f, -0.06041667f, 0.07881650f, 0.00978178f, 0.03993046f, -0.02380496f, 0.07792567f, 
    0.08610792f, -0.12183895f, 0.05620568f, -0.09386981f, 0.30937660f, -0.23086359f, -0.00439333f, -0.08716504f, 
    0.05867795f, 0.01721114f, -0.04730368f, 0.03289569f, 0.07426796f, -0.10007187f, 0.05019525f, -0.10664411f, 
    0.12375820f, 0.01360710f, 0.18784425f, -0.05623552f, 0.04429866f, 0.08847407f, 0.10575938f, 0.08344816f, 
    0.09123694f, 0.15823582f, 0.08762992f, 0.17285070f, -0.30630955f, 0.11330894f, -0.00096572f, -0.11004981f, 
    0.03058755f, -0.01311721f, 0.12663038f, 0.02602683f, 0.11441560f, -0.05762643f, 0.10706390f, 0.07462106f, 
    0.05540678f, -0.20718411f, -0.09745562f, -0.09496031f, 0.02541052f, 0.13173185f, -0.02124973f, -0.00554897f, 
    0.16186322f, -0.06582273f, -0.00540520f, -0.04697992f, 0.02862535f, 0.01121904f, -0.13382231f, -0.08748493f, 
    0.03488310f, 0.01292096f, -0.00182963f, 0.19067100f, -0.03930290f, -0.04166009f, 0.07934089f, 0.16009620f, 
    0.33410659f, -0.14617588f, 0.04304016f, 0.13638490f, -0.17200758f, 0.08123740f, -0.01351066f, -0.01855081f, 
    -0.04660881f, -0.12507412f, -0.00940600f, -0.06512235f, 0.14228438f, -0.05800093f, 0.00408313f, 0.26623249f, 
    -0.13142717f, 0.07625474f, 0.15234226f, 0.02726651f, -0.00435336f, -0.02466316f, -0.10397136f, 0.03244961f, 
    -0.13307270f, 0.01828244f, 0.26844579f, 0.13484368f, 0.02637473f, -0.02334067f, -0.04296151f, -0.01551381f, 
    -0.03726158f, 0.04092551f, 0.04631713f, 0.07319639f, 0.09840577f, 0.04873335f, -0.10497443f, 0.06388156f, 
    -0.01882294f, -0.11887708f, 0.00032792f, -0.12298872f, -0.07775652f, 0.00458441f, -0.03723413f, -0.05752648f, 
    0.19814080f, 0.35888487f, -0.01643605f, 0.08828230f, -0.00005025f, 0.09872190f, 0.02799610f, 0.05971468f, 
    -0.13910510f, 0.14380102f, 0.01275876f, 0.10006835f, 0.09201103f, 0.14764915f, 0.17740470f, -0.17691250f, 
    0.17753609f, 0.05266614f, -0.00674767f, 0.00633820f, 0.05451434f, 0.01103462f, 0.09717600f, 0.15351115f, 
    0.01641762f, 0.13171230f, -0.02082425f, 0.08549097f, 0.02115763f, 0.13652118f, 0.07270672f, 0.01743677f, 
    -0.02812440f, 0.01367968f, -0.03841259f, -0.09711202f, 0.18335861f, -0.11726275f, 0.10586717f, -0.05386655f, 
    -0.13022031f, -0.04220676f, -0.00651282f, 0.10978572f, -0.00948578f, -0.07747705f, 0.03018992f, -0.00265112f, 
    0.08690490f, -0.14088106f, -0.15261409f, -0.19482642f, 0.02337721f, -0.04751569f, 0.02373622f, -0.14094470f, 
    -0.01690349f, -0.09881942f, -0.02852444f, -0.03618930f, -0.43243799f, -0.24982384f, 0.06787796f, 0.12401329f, 
    0.03457684f, 0.09968876f, 0.02535466f, -0.00646927f, -0.03872803f, 0.00353835f, -0.01297027f, -0.04846991f, 
    0.03316895f, 0.06756022f, 0.10738976f, 0.02200414f, 0.06837554f, -0.02071219f, -0.04767885f, 0.07495413f, 
    -0.09900314f, 0.12099105f, 0.01654769f, 0.16410357f, -0.45242578f, 0.39230299f, 0.01795066f, 0.15811856f, 
    -0.00370439f, -0.08239767f, 0.01137832f, -0.04986149f, -0.04272691f, 0.06548256f, -0.02396279f, 0.14329523f, 
    0.12006858f, 0.24163078f, -0.13061585f, 0.24223243f, -0.05020821f, -0.12468825f, -0.07109334f, -0.10636664f, 
    -0.11417603f, -0.03027372f, -0.02288279f, -0.04644462f, 0.32642066f, -0.08530414f, 0.01229223f, 0.16175808f, 
    -0.03748228f, 0.06569078f, 0.08158553f, -0.06283033f, 0.02862157f, 0.11931798f, -0.10365944f, 0.14799124f, 
    -0.15882401f, 0.05902009f, 0.19532041f, 0.00235296f, -0.00954441f, 0.05519944f, -0.01402750f, 0.06918537f, 
    -0.01604286f, 0.07045145f, 0.02534678f, 0.07628249f, -0.09685896f, -0.07283076f, 0.31229767f, -0.07079689f, 
    -0.07654120f, -0.01453860f, -0.03565275f, -0.12908204f, -0.05539557f, -0.00214891f, -0.03374563f, 0.04623649f, 
    0.01662503f, -0.10448460f, 0.15680762f, -0.03052268f, -0.11273334f, 0.02846855f, -0.07205427f, 0.03474000f, 
    -0.11007264f, 0.06569362f, 0.06922252f, 0.11285914f, 0.12255763f, -0.08741567f, 0.14240998f, 0.11869625f, 
    -0.05840658f, -0.04329753f, -0.06538972f, -0.09731608f, 0.04726363f, 0.07050654f, 0.09500261f, -0.12783319f, 
    -0.16848725f, 0.12213415f, 0.02674231f, 0.09480345f, 0.07358254f, -0.08155082f, 0.08259550f, 0.05134475f, 
    -0.19987974f, 0.02407634f, 0.06305013f, -0.23441955f, 0.18887728f, 0.04156237f, 0.10653723f, 0.02019771f, 
    -0.14263055f, 0.13634008f, -0.05852953f, -0.05907277f, -0.09500225f, 0.08081002f, 0.06982453f, 0.17911161f, 
    -0.16200563f, -0.10450003f, 0.08408617f, 0.05741243f, -0.04631250f, -0.04841856f, -0.01331556f, 0.03530901f, 
    0.06442914f, 0.06733821f, 0.13038892f, 0.10570078f, 0.11439176f, -0.02115790f, -0.04909942f, -0.16624770f, 
    0.14555125f, 0.04826910f, -0.01092716f, -0.03463891f, 0.09778399f, -0.02473495f, 0.08880446f, 0.04183346f, 
    0.05321549f, -0.07243393f, -0.03447405f, -0.06391826f, 0.01736331f, 0.12713012f, 0.10044401f, -0.14608271f, 
    0.03139475f, 0.02229631f, -0.31307432f, -0.05726916f, -0.10640337f, -0.01165092f, 0.25163838f, 0.10591005f, 
    -0.08047167f, 0.05172030f, 0.16049077f, -0.07154205f, -0.13591586f, -0.01706303f, -0.20295522f, 0.10190552f, 
    -0.07371221f, 0.03605239f, 0.02795120f, 0.04116359f, 0.02307719f, -0.13091311f, -0.11012214f, -0.04509109f, 
    0.02645000f, 0.03748083f, 0.16529521f, 0.06754721f, 0.08234219f, 0.01668480f, 0.09673683f, -0.03591999f, 
    -0.06988210f, 0.10706607f, 0.10561616f, 0.03262429f, -0.06791364f, 0.02826331f, -0.01071627f, 0.03300145f, 
    0.21341310f, 0.00781033f, -0.16196987f, -0.20093636f, 0.18421902f, -0.04182497f, -0.19475937f, 0.03636372f, 
    -0.03091346f, -0.07557367f, 0.13815527f, -0.04861871f, 0.06261355f, 0.04336832f, -0.01590635f, 0.10876651f, 
    -0.14421767f, -0.09771112f, 0.06255201f, -0.09494230f, 0.05305233f, 0.00374977f, 0.01540864f, -0.11877517f, 
    0.33793688f, 0.19939630f, 0.05571369f, 0.08485089f, -0.06489806f, 0.00121326f, 0.05063467f, -0.06285559f, 
    0.05166435f, 0.09508209f, -0.14643934f, 0.01322857f, -0.20630740f, -0.08918884f, -0.12980919f, 0.12407783f, 
    0.02916940f, -0.11593928f, 0.10911387f, 0.01696297f, 0.10423204f, 0.02603003f, -0.06360572f, 0.00242854f, 
    -0.16106194f, -0.17526212f, -0.04086066f, -0.21141371f, 0.05181078f, 0.16910139f, 0.08991688f, -0.03467604f, 
    0.02670021f, 0.07627364f, 0.00711848f, -0.03115669f, 0.04714051f, 0.01178634f, -0.04180209f, -0.02549102f, 
    0.05170701f, 0.01290707f, -0.16648121f, 0.16432044f, -0.09836172f, 0.16035454f, 0.11012116f, 0.09040979f, 
    -0.01752000f, -0.03789592f, 0.04478970f, 0.02069077f, 0.03531319f, -0.00306866f, -0.00286280f, -0.06382468f, 
    -0.04006262f, -0.00823086f, -0.03183774f, -0.10002259f, 0.08054566f, -0.00427269f, -0.01945328f, -0.06863210f, 
    -0.00900545f, -0.05451401f, -0.04688751f, -0.00656870f, -0.05115597f, 0.01367970f, 0.05174720f, -0.01405643f, 
    -0.00603724f, -0.06940111f, -0.08184614f, 0.02785483f, -0.09038028f, -0.01165878f, 0.05083700f, -0.01124124f, 
    -0.06622566f, 0.06115188f, 0.01418169f, 0.03388146f, -0.02733529f, 0.09618437f, -0.05621535f, -0.06899823f, 
    -0.05483916f, -0.00299137f, -0.08896568f, -0.09009781f, -0.07331418f, 0.02049852f, -0.05510725f, 0.05906422f, 
    -0.09443033f, -0.02661738f, -0.03152232f, 0.03517619f, -0.03094209f, -0.06418756f, 0.05946178f, 0.02956819f, 
    -0.01390491f, 0.05378321f, -0.03249631f, 0.05134291f, -0.06200661f, -0.10782483f, 0.01007555f, 0.03415253f, 
    -0.04918496f, -0.04395178f, -0.02182811f, -0.02530669f, 0.02581862f, 0.06343052f, 0.00903588f, 0.05729124f, 
    -0.03101400f, -0.05574333f, -0.08430766f, 0.00078932f, 0.01190780f, -0.05323837f, -0.05691250f, 0.01223088f, 
    0.02537862f, -0.07382625f, 0.04780017f, -0.04171407f, -0.06879383f, -0.03778668f, -0.07225991f, -0.09181143f, 
    0.05152870f, 0.04089408f, -0.04782164f, -0.08574903f, -0.06855460f, -0.03303234f, 0.04006369f, 0.02681724f, 
    0.05531536f, 0.01262895f, 0.05606502f, 0.03620299f, -0.02868928f, -0.00793882f, 0.04627787f, 0.02360233f, 
    0.01290547f, -0.02941270f, 0.02772649f, -0.06992809f, 0.08635470f, -0.02206519f, -0.02258419f, -0.11263136f, 
    0.04828630f, -0.01872034f, 0.02480360f, -0.03608313f, -0.04626787f, -0.04087199f, -0.02164460f, 0.04489261f, 
    -0.08288144f, -0.08608887f, 0.02026686f, 0.04598111f, -0.01630421f, 0.01448051f, -0.01674611f, -0.02818937f, 
    0.02130017f, 0.03526147f, -0.06750810f, 0.00846277f, 0.05764342f, 0.08735626f, -0.00959684f, -0.03548803f, 
    0.01627979f, -0.00251723f, -0.08004101f, -0.02738916f, -0.02495478f, 0.01497034f, -0.03593192f, 0.01739215f, 
    0.00619107f, -0.03908261f, -0.00609276f, 0.04027085f, -0.02778307f, -0.05580662f, -0.08427138f, 0.03409569f, 
    0.02589301f, -0.02934986f, -0.04693270f, -0.02074586f, -0.10411166f, 0.04740433f, 0.02153310f, 0.05499842f, 
    -0.08395996f, -0.07459334f, 0.05704328f, 0.03499111f, 0.02293621f, 0.03630765f, -0.04564337f, 0.06308248f, 
    -0.06094372f, 0.02518195f, -0.01475462f, -0.03079062f, -0.00335006f, -0.01910602f, 0.04981998f, 0.03725149f, 
    -0.06015057f, 0.02793969f, 0.01742242f, -0.08366729f, -0.09739442f, -0.01981741f, -0.03534719f, 0.04191664f, 
    -0.03503534f, -0.00671220f, -0.00883652f, -0.07058521f, 0.01285407f, -0.03971959f, 0.01449560f, 0.03110618f, 
    0.02566529f, 0.03143993f, -0.04869769f, -0.01755337f, 0.02163258f, 0.04620099f, -0.00953612f, 0.05291082f, 
    -0.00611438f, 0.02944618f, -0.05979637f, -0.04366238f, -0.04048502f, -0.05230638f, -0.01068841f, -0.04501378f, 
    -0.01490342f, -0.05014431f, 0.00875277f, -0.05463128f, -0.04778621f, 0.05216265f, -0.05690528f, 0.01329656f, 
    -0.03846501f, 0.05281870f, 0.06365680f, 0.03882548f, -0.04068441f, 0.00119761f, -0.01889159f, 0.06232340f, 
    -0.01961725f, -0.06814816f, 0.06378763f, 0.03530872f, 0.06171419f, 0.02089009f, 0.02065084f, -0.02676727f, 
    -0.07438824f, 0.01711754f, 0.05927664f, -0.07284781f, -0.07404406f, 0.01955227f, 0.03624865f, -0.02706647f, 
    -0.06934609f, -0.06485341f, 0.03985938f, -0.03201853f, -0.06321110f, -0.04990577f, 0.01525597f, -0.02006705f, 
    -0.01021989f, -0.05100150f, 0.04435363f, 0.01695528f, -0.04746428f, -0.07197428f, 0.03308657f, 0.02778924f, 
    -0.00032065f, -0.07414781f, -0.05329014f, 0.05586356f, 0.00150153f, 0.02754675f, -0.00332820f, -0.03834162f, 
    0.01429288f, 0.06203050f, -0.01136996f, -0.05067160f, 0.06244216f, 0.01208621f, -0.01715759f, -0.03189942f, 
    -0.01074967f, -0.05050466f, -0.06284509f, 0.05879755f, -0.07395674f, 0.01077271f, -0.05594195f, -0.00903477f, 
    0.05906127f, -0.02060729f, -0.05108560f, -0.05485892f, -0.02655624f, 0.02133597f, 0.01383597f, 0.03532776f, 
    -0.04390806f, -0.07669298f, 0.02219191f, -0.04193330f, 0.04392061f, -0.06559651f, -0.07164211f, -0.07740501f, 
    -0.06266904f, -0.07232121f, 0.00344992f, -0.03688741f, -0.02263423f, 0.06237280f, 0.05015701f, -0.02826259f, 
    0.01774323f, 0.01247440f, -0.03182470f, -0.06767941f, -0.07117401f, -0.01344982f, -0.03356836f, -0.04738650f, 
    -0.00556821f, -0.00792184f, 0.03210491f, -0.01866820f, -0.03928926f, -0.00852639f, 0.02741289f, -0.04284836f, 
    0.04906210f, 0.02292541f, -0.04991559f, 0.04569234f, -0.07431021f, 0.00415974f, -0.06311661f, -0.05188569f, 
    -0.05335657f, 0.01104295f, 0.00624887f, -0.07337017f, 0.03233030f, -0.03713550f, -0.02176040f, 0.05072265f, 
    0.02342309f, -0.03702699f, -0.02492283f, -0.01566912f, -0.04684890f, 0.00075915f, 0.01254752f, -0.06931189f, 
    0.03553493f, 0.03134622f, 0.00484256f, -0.00814697f, -0.02362610f, 0.04870430f, -0.05922266f, -0.00827586f, 
    0.03043971f, -0.02605847f, -0.03214059f, 0.02989009f, -0.02555003f, -0.06201538f, -0.00426153f, 0.00211875f, 
    -0.03765111f, -0.00735439f, -0.02518587f, -0.03829996f, 0.01420523f, -0.04915887f, 0.03527631f, -0.04960490f, 
    -0.03793224f, -0.06628680f, 0.02226594f, 0.00073999f, 0.06403936f, 0.03157113f, 0.02340863f, -0.01334687f, 
    -0.04838252f, 0.06352532f, -0.02736211f, -0.00265920f, -0.05616861f, -0.04358963f, 0.04067556f, -0.01326562f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02921927f, 0.16215855f, 0.06158011f, 0.04248871f, 0.14880668f, -0.07519618f, -0.05901973f, 0.03369364f, 
    0.07536368f, 0.11929507f, -0.05956678f, -0.13716008f, 0.10907403f, -0.00259037f, -0.02531792f, 0.03680477f, 
    -0.00214127f, 0.01050858f, 0.10324611f, -0.07353847f, 0.04821794f, -0.06642648f, 0.02422682f, -0.09079570f, 
    0.07222448f, -0.05477663f, 0.13399681f, 0.11185343f, 0.09989508f, 0.07769520f, -0.07027249f, 0.08042881f, 
    -0.01283202f, 0.04185298f, -0.01607947f, -0.01802813f, 0.06222825f, -0.10758457f, 0.01790739f, 0.06317098f, 
    0.11985237f, 0.05005408f, -0.02175397f, -0.05070409f, -0.01950179f, 0.04514478f, -0.03001219f, 0.11575592f, 
    0.09032740f, 0.04884195f, 0.01435458f, 0.06034740f, 0.04264719f, -0.01961846f, 0.00905613f, 0.04154114f, 
    0.02115139f, -0.04255278f, 0.09718800f, 0.16730115f, -0.12221020f, -0.06340928f, -0.00888523f, -0.07628260f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03217600f, -0.11043492f, 0.11576129f, -0.22220984f, -0.01675659f, -0.09156814f, 0.49131852f, 0.27097017f, 
    0.03161708f, 0.12799938f, -0.11678914f, -0.04480646f, 0.23486342f, 0.21377470f, -0.11182865f, 0.04246285f, 
    0.07964929f, -0.16265206f, 0.26541036f, -0.05302231f, 0.17640382f, -0.00605793f, 0.02963236f, -0.16235258f, 
    0.07622107f, -0.09077752f, 0.18723407f, -0.15836127f, 0.09996200f, 0.17950873f, -0.04170013f, 0.14171223f, 
    0.18652377f, 0.26512995f, -0.11087780f, -0.25596169f, 0.09347887f, 0.02822940f, -0.36127940f, -0.26845080f, 
    0.20042901f, 0.00675954f, -0.36728826f, 0.00417389f, -0.12401090f, 0.18515477f, -0.17427856f, -0.07876995f, 
    0.16891365f, 0.00022211f, -0.12620103f, -0.10753713f, -0.11438571f, 0.08995523f, 0.14802547f, 0.17172229f, 
    -0.06964483f, 0.04244266f, 0.28408706f, -0.08584447f, 0.04564695f, -0.29604524f, 0.03025483f, -0.02227029f, 
    -0.07755049f, 0.13619591f, 0.16692877f, 0.30750239f, 0.08677470f, 0.01868893f, -0.26768658f, -0.02881133f, 
    0.14059678f, 0.08432926f, -0.01148542f, 0.25782210f, -0.08734206f, -0.19949351f, -0.16696908f, 0.06550249f, 
    0.00811662f, -0.13100052f, -0.01493294f, -0.03106899f, 0.03015202f, 0.09591104f, -0.07932048f, -0.04066511f, 
    -0.17028350f, 0.54613274f, -0.05164990f, 0.08990357f, -0.24799597f, -0.20449494f, -0.16136384f, -0.27983555f, 
    0.13766240f, -0.21287070f, 0.04850311f, 0.17936701f, -0.08101282f, 0.03982013f, 0.09985821f, 0.22852759f, 
    -0.19544940f, -0.04682066f, 0.13896897f, -0.11183508f, 0.11049251f, -0.11908405f, -0.10091692f, -0.28790322f, 
    -0.02416434f, -0.33712578f, 0.11841080f, 0.06994908f, 0.36078194f, -0.03817038f, 0.17773244f, 0.09308957f, 
    -0.03849043f, -0.12447356f, -0.11841211f, 0.13598087f, 0.01702288f, 0.33038816f, -0.10066664f, 0.10186262f, 
    -0.14200172f, 0.08982458f, 0.01370122f, -0.08497724f, 0.13088064f, -0.04542814f, -0.24163347f, 0.04687623f, 
    -0.23397329f, -0.20448549f, -0.00574381f, -0.21415453f, 0.09225306f, -0.04043960f, 0.07508850f, 0.00267825f, 
    -0.12567475f, 0.18863492f, -0.09930969f, 0.10855120f, -0.07468326f, 0.04425677f, 0.10448651f, 0.22928119f, 
    0.22678754f, -0.34089476f, 0.12860128f, 0.25601661f, 0.26656345f, 0.21951574f, 0.29262766f, 0.41601124f, 
    0.10609443f, 0.12152671f, 0.04952108f, -0.22135168f, -0.14534056f, -0.19132967f, 0.31405458f, 0.02879947f, 
    0.13339652f, 0.04405819f, -0.04697496f, -0.10606204f, -0.06663749f, -0.08457287f, 0.44662926f, 0.20689009f, 
    0.04330514f, 0.10583939f, -0.05974884f, -0.01513147f, -0.28164560f, -0.04525051f, -0.31652638f, 0.33803397f, 
    0.05104316f, 0.05106180f, -0.10601974f, 0.18194568f, -0.40159762f, -0.09198299f, 0.01052929f, 0.06681409f, 
    -0.13411051f, -0.12452801f, -0.04465082f, -0.03782747f, -0.08327901f, 0.09532905f, -0.14786631f, 0.09030624f, 
    0.00136081f, 0.02858225f, 0.03813472f, -0.00169255f, 0.06587726f, 0.04634567f, -0.06847829f, -0.00781539f, 
    -0.06257636f, -0.13293751f, -0.03301453f, 0.12610126f, -0.08665955f, -0.13166888f, -0.13691948f, -0.06970871f, 
    -0.01705199f, -0.06946409f, -0.07508887f, -0.02260804f, -0.13346267f, 0.01475262f, 0.02989200f, 0.04068083f, 
    0.01312412f, 0.01140215f, -0.12378458f, -0.13779162f, -0.12708290f, -0.10192987f, -0.02692618f, -0.03015381f, 
    0.06803463f, -0.11543446f, 0.08602820f, 0.09541085f, -0.01091692f, -0.06651372f, -0.04767037f, 0.07186180f, 
    -0.04641559f, -0.00657399f, -0.03778248f, 0.11720730f, -0.00906841f, 0.08111370f, 0.03210374f, 0.07093579f, 
    0.04404526f, 0.08943841f, -0.04730079f, 0.01281528f, -0.10466217f, -0.06484041f, -0.12178445f, -0.00954905f, 
    0.00179523f, -0.01752738f, 0.00436363f, 0.05624785f, -0.12025708f, 0.09442017f, 0.07260096f, -0.02169304f, 
    0.08185203f, -0.01885778f, 0.06081429f, 0.09846617f, -0.11158948f, 0.09436476f, 0.05529533f, -0.04831181f, 
    -0.02957435f, -0.10743596f, 0.00287576f, 0.09307807f, -0.01760656f, 0.07970512f, -0.13017221f, 0.04624727f, 
    0.06048085f, -0.09635940f, -0.05129529f, -0.14639150f, -0.00136104f, -0.03683130f, -0.12273204f, 0.02602606f, 
    0.00234880f, -0.08345094f, 0.07133586f, 0.04395263f, 0.02910815f, -0.00018563f, 0.00789984f, -0.10110697f, 
    -0.00354413f, -0.09935478f, 0.01923625f, -0.01680144f, -0.03664590f, 0.03989473f, -0.04520610f, 0.06256635f, 
    -0.15195261f, -0.00752523f, 0.10685387f, 0.04959702f, -0.08004932f, -0.08444645f, -0.06202612f, 0.09402576f, 
    -0.00473361f, 0.08047933f, -0.11262393f, -0.02136379f, -0.09151862f, -0.12884569f, 0.02905078f, 0.07495691f, 
    0.28020743f, 0.07207917f, -0.13664760f, 0.14129119f, -0.23409875f, 0.15740412f, 0.07506388f, 0.09360547f, 
    -0.07330388f, 0.22250193f, -0.12459081f, -0.07714759f, 0.28880495f, 0.11879358f, 0.00726933f, 0.07856860f, 
    0.05686668f, 0.06452211f, -0.16455023f, -0.08311867f, 0.04250330f, -0.17068429f, 0.17135923f, -0.18502626f, 
    -0.12837864f, -0.01496131f, 0.06351755f, -0.16674851f, -0.08559401f, -0.02932114f, -0.29926392f, 0.25969175f, 
    0.40410990f, -0.27133331f, 0.48079246f, -0.07841291f, -0.02856300f, -0.17667665f, -0.11712135f, -0.01576360f, 
    -0.13121139f, 0.03161311f, 0.15592633f, -0.05141689f, 0.06740309f, 0.07107487f, 0.13024786f, 0.09769706f, 
    0.20177852f, 0.22010750f, 0.07934564f, -0.04875780f, 0.12156563f, 0.23833054f, -0.04213533f, 0.18363269f, 
    0.11952131f, -0.04973045f, 0.02598616f, 0.11812449f, 0.10681022f, 0.03990187f, 0.00645387f, 0.08990796f, 
    -0.05472333f, -0.21933170f, -0.21636243f, -0.07502785f, -0.01469334f, -0.00126390f, 0.29224724f, -0.50867105f, 
    0.17995083f, 0.16634345f, -0.03499875f, 0.07241239f, 0.05451301f, -0.17360504f, 0.12357596f, 0.11335763f, 
    0.02514360f, -0.19805788f, -0.02766838f, -0.01876093f, 0.13144667f, -0.02495470f, 0.10288029f, -0.03511444f, 
    0.19561426f, 0.05732318f, -0.05733807f, 0.00404649f, 0.20258087f, 0.16019097f, -0.05981693f, -0.00367696f, 
    0.23251259f, 0.03704669f, -0.00261349f, -0.05838583f, -0.00880303f, 0.30071795f, -0.24761088f, 0.16969381f, 
    0.31136748f, 0.04308309f, -0.14617428f, 0.04236400f, -0.06791221f, 0.17723218f, 0.02558422f, 0.16424033f, 
    -0.01020598f, -0.38828394f, 0.01205483f, -0.03509535f, 0.11339810f, 0.07448789f, 0.18046039f, -0.10744376f, 
    0.03258824f, 0.05552178f, -0.14035510f, -0.25618091f, 0.33043313f, 0.06168372f, 0.04959472f, 0.00145619f, 
    -0.02663438f, 0.16268620f, 0.14979862f, 0.08451283f, 0.14940175f, 0.03304325f, 0.00010894f, 0.11090704f, 
    -0.08626348f, -0.16047280f, 0.10963639f, -0.05557380f, -0.08292536f, -0.04958343f, 0.02013050f, -0.07912840f, 
    0.09412225f, -0.02989675f, 0.15164611f, -0.00160552f, 0.03659938f, -0.13624926f, 0.16634089f, 0.23632535f, 
    0.34914055f, -0.33400527f, 0.11137117f, 0.16831680f, -0.05841869f, -0.11953557f, 0.25604516f, 0.21430872f, 
    0.03900044f, -0.07503949f, 0.12721063f, -0.03588069f, -0.00534226f, -0.04868547f, 0.16394623f, 0.11296737f, 
    0.24483635f, 0.05630916f, 0.00627842f, -0.06418436f, 0.00439855f, -0.11104808f, 0.13124350f, 0.21376707f, 
    -0.02325067f, -0.06074999f, -0.10345169f, -0.03030574f, -0.11027768f, -0.15507349f, -0.13490231f, -0.09086848f, 
    0.08849538f, 0.04966900f, -0.02670339f, 0.03995479f, -0.08059032f, -0.06019258f, 0.05509749f, -0.02816851f, 
    0.31837717f, -0.16032217f, 0.14323784f, -0.21035548f, -0.30727971f, 0.01687054f, 0.43136108f, 0.06667090f, 
    -0.19748960f, 0.12854484f, -0.08794471f, -0.14594483f, -0.00868761f, 0.20100693f, 0.07504804f, 0.10198302f, 
    -0.01891067f, 0.03042299f, 0.03522749f, 0.04848599f, -0.11091857f, -0.04009238f, 0.00779752f, -0.03643870f, 
    0.11769342f, -0.36499673f, -0.05169855f, -0.14372613f, 0.02642387f, -0.14502397f, 0.28024027f, 0.20028397f, 
    0.05062038f, 0.06359844f, 0.12834974f, 0.14214598f, -0.02082219f, 0.16330422f, -0.05935762f, -0.23532966f, 
    0.24288134f, -0.09573250f, -0.09750769f, 0.10969952f, -0.06948315f, -0.14472820f, 0.08014307f, 0.12833051f, 
    0.14665882f, 0.09079791f, 0.12358943f, 0.09168136f, -0.00334540f, -0.03266564f, 0.33823308f, -0.13720396f, 
    0.11085407f, 0.08113988f, 0.11774286f, -0.17075813f, 0.20222312f, 0.03927732f, 0.05255317f, -0.04772338f, 
    0.34861091f, -0.06186487f, 0.17039129f, -0.06843761f, -0.05892563f, -0.03164348f, 0.28375649f, -0.24614985f, 
    0.14921492f, 0.24445792f, -0.06462906f, -0.01943140f, 0.13014822f, -0.33352315f, 0.11600640f, -0.05698282f, 
    0.11873959f, -0.32388741f, 0.11067637f, -0.11015995f, 0.17466092f, 0.09628612f, -0.06481790f, -0.20243450f, 
    0.16740805f, 0.05880687f, 0.37320688f, 0.00396597f, 0.22722985f, -0.24706575f, -0.05500989f, 0.15083535f, 
    0.15312549f, -0.22111566f, -0.13455127f, -0.01009191f, 0.05711935f, 0.22297356f, -0.11890268f, -0.09723986f, 
    0.40497574f, -0.08873761f, -0.27785245f, 0.06396310f, 0.08357694f, -0.14216842f, -0.18330300f, 0.07464697f, 
    0.01502812f, -0.49907351f, 0.01355811f, -0.03651978f, 0.28204128f, -0.17356990f, 0.22130238f, -0.05414294f, 
    0.07515658f, -0.04664965f, 0.04757055f, -0.12705861f, 0.34071532f, 0.01577586f, 0.01713713f, 0.07863189f, 
    0.16903114f, -0.15868080f, -0.09432479f, -0.17845200f, -0.01111771f, 0.00663680f, 0.22198300f, -0.04445698f, 
    0.04847792f, 0.12104391f, 0.05477551f, -0.25739449f, 0.19795480f, -0.11009143f, 0.13830516f, -0.03906604f, 
    0.12364212f, -0.02375899f, 0.14986406f, -0.06811941f, -0.05493794f, 0.06875283f, -0.01303857f, -0.08556961f, 
    0.25682399f, -0.32858312f, 0.01021972f, -0.26461241f, 0.07766310f, 0.04854970f, 0.18873498f, 0.13561429f, 
    0.22683331f, 0.25958684f, 0.12769461f, 0.06564038f, -0.09202631f, -0.09634231f, -0.02406235f, -0.11380462f, 
    0.10629246f, -0.11711398f, -0.23154849f, 0.01303224f, -0.03413520f, -0.03831965f, -0.13871913f, 0.15669487f, 
    -0.00130035f, 0.03152100f, 0.10950614f, 0.04458830f, -0.00331984f, -0.19444439f, 0.30519670f, 0.08459527f, 
    -0.02503436f, -0.10235297f, -0.07584852f, -0.05803388f, 0.12594450f, -0.09295246f, 0.04980611f, -0.12286688f, 
    -0.11185377f, 0.06015380f, 0.04115290f, -0.05644413f, 0.07860541f, 0.10009950f, -0.09329720f, -0.10262460f, 
    -0.06342906f, -0.00776739f, 0.06074948f, -0.08945844f, 0.05984020f, -0.07389802f, 0.01462726f, -0.12003205f, 
    0.09929481f, 0.05886273f, -0.08394973f, -0.06286912f, 0.00771623f, -0.04522834f, -0.11084352f, -0.08338879f, 
    -0.09680318f, -0.00763410f, 0.07892181f, -0.14002596f, -0.08828893f, 0.00041838f, 0.08067863f, 0.04741127f, 
    -0.02220693f, -0.10848524f, -0.10905886f, -0.05935788f, 0.00125466f, -0.08949182f, 0.08877129f, -0.04474749f, 
    -0.02937162f, 0.09783483f, 0.09736732f, 0.04015215f, -0.02140452f, 0.02122661f, -0.07156722f, -0.11183899f, 
    -0.11341459f, 0.09238601f, 0.07070806f, 0.05093309f, -0.00361035f, -0.11516312f, 0.05359934f, -0.11630119f, 
    -0.10525218f, -0.00359589f, -0.07716687f, -0.05430214f, 0.06518956f, 0.08115075f, 0.11841440f, -0.11253594f, 
    -0.31841335f, -0.02409110f, -0.07513262f, -0.02080076f, 0.20531456f, 0.03051498f, 0.11286493f, -0.36651322f, 
    0.24312736f, -0.03562488f, 0.11122577f, -0.19594483f, -0.18984248f, -0.23698190f, 0.27740842f, -0.01672492f, 
    -0.02969254f, -0.04267276f, 0.23583849f, 0.12091541f, 0.06036768f, 0.01098210f, 0.09992144f, 0.13479857f, 
    0.20263691f, 0.07381774f, -0.09435725f, -0.09424832f, 0.11287321f, 0.19531706f, 0.03623864f, 0.26203543f, 
    -0.07114359f, 0.31082183f, -0.04284344f, 0.01905274f, 0.03617973f, 0.05704229f, -0.15557578f, -0.01893934f, 
    0.09658499f, 0.03775822f, 0.13394934f, 0.05403778f, 0.10803134f, -0.05553276f, -0.14258458f, 0.31129557f, 
    0.13224564f, -0.12150308f, -0.02371727f, 0.01656268f, 0.26174396f, -0.03456857f, 0.39669567f, -0.15500551f, 
    -0.01153960f, -0.00178466f, -0.16503063f, -0.18410178f, 0.01194554f, -0.08315805f, 0.06366866f, 0.08314814f, 
    0.29765034f, 0.07081416f, 0.08948617f, -0.06751406f, 0.01167299f, 0.10990169f, -0.15891740f, 0.11407528f, 
    -0.17731597f, 0.03777721f, 0.03456835f, 0.00842694f, 0.04376684f, -0.03229815f, -0.03646055f, 0.11090205f, 
    0.05929229f, 0.05395613f, -0.13848746f, 0.08956008f, -0.15314923f, -0.29766324f, 0.21331410f, -0.02918835f, 
    0.13219938f, -0.02292251f, 0.02365939f, 0.08596883f, -0.06824265f, -0.13762614f, 0.17365661f, 0.32044798f, 
    0.31051567f, -0.41151667f, 0.45380339f, 0.18350053f, 0.23571727f, -0.26486325f, 0.17630526f, 0.07930755f, 
    0.04403773f, 0.04497454f, 0.31781918f, 0.00907115f, 0.00547696f, 0.05333500f, 0.11507002f, 0.15218425f, 
    -0.07046634f, 0.29594335f, 0.07799567f, 0.07472820f, 0.10708988f, 0.23429944f, 0.03345273f, 0.13141099f, 
    -0.10412982f, 0.03343673f, -0.09484509f, 0.19310355f, -0.14501129f, 0.14873213f, -0.03360257f, -0.01066514f, 
    -0.07980742f, -0.00353286f, -0.01105127f, -0.14380512f, 0.08538378f, 0.01681441f, 0.04358102f, -0.09797819f, 
    -0.13359308f, -0.05284069f, -0.02529782f, 0.00295874f, 0.01563106f, 0.09702363f, -0.09915091f, 0.12062299f, 
    -0.11472704f, 0.05457053f, -0.02140954f, -0.02559258f, -0.03187343f, -0.03219448f, -0.02826435f, -0.01021287f, 
    -0.15002261f, 0.09158480f, -0.11796216f, -0.11643574f, -0.06983425f, -0.06626858f, -0.09063600f, -0.14903142f, 
    -0.08693145f, -0.00227068f, -0.10340884f, -0.03383199f, -0.12217447f, 0.04406108f, 0.09167281f, -0.08138983f, 
    -0.07643101f, -0.06090346f, 0.08441645f, 0.03975113f, 0.11646120f, -0.06367643f, -0.08997676f, 0.00442681f, 
    0.05208306f, -0.01795047f, 0.11262970f, 0.04056256f, -0.10691103f, -0.09378640f, -0.09572659f, -0.04084931f, 
    -0.10101414f, -0.01589213f, 0.03297950f, -0.10554966f, -0.04879412f, -0.11090030f, 0.09441273f, -0.06218550f, 
    -0.17894332f, 0.09985342f, -0.06427772f, 0.13662343f, 0.28012377f, -0.01106716f, 0.16410232f, 0.00412503f, 
    0.17195220f, -0.08127983f, 0.05255345f, 0.17350511f, -0.05659849f, -0.19705041f, 0.05259836f, -0.11284821f, 
    0.10681944f, -0.11457124f, 0.05458022f, 0.03898790f, -0.04603538f, 0.18797220f, -0.02214292f, 0.25627676f, 
    0.23016062f, 0.05623458f, 0.17933452f, 0.32520267f, 0.13021706f, 0.06293964f, 0.27340803f, -0.17755592f, 
    -0.11819545f, 0.36643398f, -0.48267242f, -0.02049096f, -0.12003732f, 0.09072720f, 0.05531630f, 0.08407334f, 
    0.23274004f, -0.08136607f, -0.31911138f, -0.01015589f, -0.06261805f, 0.18255565f, 0.24747655f, 0.01167803f, 
    0.05166204f, -0.20827627f, -0.07043913f, -0.11340096f, 0.18747501f, -0.13819592f, -0.06928995f, 0.15849468f, 
    0.01317814f, 0.07815988f, -0.17431557f, 0.12093533f, 0.02423009f, 0.09184774f, 0.01101532f, 0.07070117f, 
    -0.07127395f, -0.12100592f, -0.00357906f, -0.06881846f, -0.07460122f, 0.03287588f, 0.05111422f, 0.25815994f, 
    -0.11539281f, -0.00538452f, 0.03657183f, 0.01952800f, 0.06398617f, 0.45934194f, -0.08172406f, -0.06088735f, 
    -0.11529070f, 0.07789899f, -0.02477496f, 0.08763255f, -0.06068505f, -0.08247837f, 0.26400697f, 0.15792197f, 
    -0.16286680f, -0.04556612f, -0.25515422f, 0.19451936f, 0.14090088f, -0.07804854f, -0.01865873f, -0.18136343f, 
    -0.03257841f, -0.00866844f, -0.00377745f, -0.25581861f, 0.28977343f, 0.06410527f, 0.02363516f, 0.10471214f, 
    -0.16699974f, 0.05822471f, -0.02464077f, -0.11031321f, -0.08823956f, 0.11491876f, 0.06535019f, -0.04993032f, 
    0.09986915f, 0.50750643f, 0.01981330f, -0.10426218f, -0.19243608f, 0.27353823f, -0.22966814f, 0.03471788f, 
    -0.10829546f, -0.10451212f, 0.11359753f, 0.11504813f, 0.25071278f, -0.17527825f, 0.11635576f, -0.09111490f, 
    0.10980181f, 0.00168579f, 0.25334114f, 0.05416630f, 0.12285970f, 0.08454211f, 0.26377425f, 0.18629512f, 
    0.06083160f, -0.08931439f, 0.01579756f, -0.24106985f, -0.22068852f, 0.15520142f, 0.06425156f, -0.01980936f, 
    -0.00920901f, 0.17184445f, 0.20093866f, -0.09738855f, -0.05603043f, -0.14791569f, 0.23409501f, -0.00524843f, 
    0.21009772f, -0.07802604f, -0.19755134f, 0.03676592f, 0.00158369f, 0.26925635f, 0.12476546f, 0.15442675f, 
    -0.04210234f, -0.15583463f, 0.02126200f, 0.25856525f, 0.07831059f, -0.27615383f, 0.10278201f, -0.15294027f, 
    0.12959723f, -0.10286824f, 0.09155045f, -0.13092381f, 0.08078467f, -0.18675581f, -0.08296261f, 0.33353877f, 
    -0.02615984f, 0.05161469f, -0.03894993f, -0.00996902f, 0.07629260f, 0.03869793f, 0.03221126f, -0.06595910f, 
    0.04513908f, 0.00082403f, 0.09171171f, 0.16047648f, -0.42041987f, -0.26135060f, -0.06647411f, 0.03374669f, 
    -0.00297887f, 0.24064341f, 0.06530235f, -0.04719123f, 0.26130730f, 0.00795969f, -0.28307912f, -0.14912254f, 
    -0.16116582f, -0.05463630f, -0.02538848f, 0.23331040f, 0.16845211f, -0.07577615f, -0.22129112f, 0.05194531f, 
    -0.06031803f, -0.28955665f, 0.23969917f, 0.03749872f, 0.09777053f, 0.10703252f, -0.03799768f, 0.07426821f, 
    -0.07184515f, 0.35075468f, 0.10106041f, 0.22388715f, 0.07150797f, -0.24684709f, -0.08470461f, -0.17808603f, 
    -0.00358292f, -0.18989822f, -0.03694645f, 0.13786167f, 0.36725506f, -0.05323321f, 0.25707564f, 0.27277690f, 
    -0.01882215f, 0.03565248f, 0.13858792f, 0.04010376f, -0.08595312f, -0.14655419f, 0.09894355f, -0.10237012f, 
    0.11369677f, 0.19499967f, 0.06379350f, 0.10472322f, 0.08153463f, 0.19435236f, -0.21953574f, 0.19039693f, 
    0.03762235f, -0.01585406f, 0.01413571f, 0.18592992f, -0.02476997f, 0.06553461f, 0.08150504f, 0.04464684f, 
    0.07566559f, 0.09484392f, 0.00314152f, -0.04262993f, -0.04317364f, -0.10320222f, -0.10836782f, -0.10831927f, 
    -0.08119268f, -0.05581724f, -0.01822374f, 0.00036706f, -0.11782356f, 0.09775447f, -0.12614343f, 0.03542806f, 
    -0.00372785f, -0.08240327f, 0.05393124f, 0.09946658f, 0.05021226f, 0.09038927f, -0.06242029f, -0.10425796f, 
    -0.07205734f, -0.03823132f, 0.06574163f, -0.11059952f, -0.00881772f, 0.02541822f, 0.00318246f, -0.02481467f, 
    -0.00444757f, -0.10418243f, 0.05517064f, -0.01866615f, 0.09036099f, 0.01350444f, -0.04177724f, -0.10546765f, 
    0.01541128f, 0.05311658f, 0.06037813f, 0.06227331f, -0.10392711f, -0.00579352f, -0.03336754f, -0.15544289f, 
    -0.02117720f, 0.02726768f, 0.09148870f, 0.10482470f, 0.02548834f, 0.03283501f, 0.08661495f, -0.10439641f, 
    -0.02763514f, -0.09698024f, -0.12803984f, -0.14327201f, 0.04939620f, -0.05376963f, -0.05389558f, 0.09785512f, 
    0.06156532f, -0.14740425f, 0.06812713f, -0.15468496f, -0.25312102f, -0.03288086f, 0.32272735f, -0.05442199f, 
    -0.00006223f, -0.01511244f, -0.00437559f, 0.01108902f, 0.19021626f, 0.35215276f, -0.05143554f, 0.07708043f, 
    0.02790383f, 0.12324941f, 0.11376884f, -0.03062919f, -0.04432662f, 0.13500062f, 0.24323700f, 0.06165008f, 
    -0.07751588f, -0.19651356f, -0.18106702f, -0.03356578f, -0.19015020f, 0.24766301f, -0.19792292f, 0.03670330f, 
    0.26228064f, -0.42214510f, 0.24712741f, 0.09100008f, 0.14089154f, -0.00016527f, 0.00859781f, -0.13658252f, 
    0.09014744f, 0.08165405f, 0.22455291f, 0.06387870f, -0.05045084f, -0.02760804f, -0.05080729f, 0.21336392f, 
    0.17590059f, 0.34691021f, 0.02030065f, 0.11996000f, 0.15679322f, 0.18303695f, -0.13084686f, -0.02686335f, 
    0.06397527f, -0.01226513f, 0.29033458f, -0.12354203f, -0.04267185f, -0.14721113f, -0.00703023f, 0.06110553f, 
    0.04155944f, -0.17536815f, 0.05532251f, 0.06127445f, -0.04447686f, 0.08280957f, -0.05692545f, -0.09880725f, 
    -0.00269693f, 0.18475465f, 0.11853599f, -0.03364768f, 0.18168348f, 0.05349808f, 0.12534209f, -0.01526534f, 
    -0.04137052f, 0.22945403f, -0.13458529f, -0.07888858f, 0.16002394f, 0.16558701f, 0.15697499f, -0.06579971f, 
    -0.21284194f, -0.11347911f, 0.02405755f, -0.16710038f, -0.11661937f, 0.11590831f, -0.04871120f, 0.29687223f, 
    0.29984778f, -0.03032076f, 0.46771851f, -0.08893616f, -0.13114871f, 0.02902023f, -0.08370230f, -0.16416816f, 
    -0.05291344f, -0.10390069f, 0.23792353f, 0.04968986f, 0.00999998f, 0.26681429f, 0.07335993f, 0.06903568f, 
    0.09625050f, 0.01742915f, -0.10963784f, 0.05293369f, 0.12399534f, -0.07669213f, 0.20117250f, 0.17531455f, 
    -0.10173153f, -0.07879985f, 0.06580181f, -0.06002696f, -0.18276168f, 0.07371981f, 0.01063466f, 0.04114404f, 
    -0.13067287f, -0.01211785f, 0.10338897f, -0.12059645f, 0.05925961f, 0.03607988f, -0.08983747f, 0.10003462f, 
    0.01818053f, -0.02892703f, -0.12917137f, 0.04069064f, -0.06735371f, -0.10466246f, 0.04785921f, 0.04601727f, 
    0.10061093f, -0.05114964f, 0.00479545f, -0.05242062f, 0.02930414f, -0.09353492f, -0.09430504f, -0.14478211f, 
    -0.05941492f, -0.10218606f, -0.15156679f, -0.07899645f, 0.01056898f, 0.07419825f, 0.07223006f, 0.10227038f, 
    -0.11469319f, -0.01934940f, -0.11867181f, -0.12707037f, -0.04970899f, -0.06780132f, 0.06782752f, -0.00482400f, 
    -0.15680081f, -0.10051954f, -0.07571869f, -0.12261220f, 0.08429644f, -0.10244410f, 0.10771942f, -0.09823181f, 
    -0.06471629f, -0.09448562f, 0.10561215f, 0.07743502f, -0.05846562f, -0.10347997f, 0.07078537f, -0.13424051f, 
    0.05559344f, 0.11898731f, 0.04983448f, 0.09593672f, 0.07329579f, -0.01215248f, -0.08120468f, 0.03842720f, 
    0.13955684f, 0.17691445f, 0.05979842f, -0.03211673f, 0.22768593f, -0.05366144f, -0.33336914f, 0.14532469f, 
    -0.00889559f, 0.00384903f, 0.08978159f, -0.00001577f, 0.02116262f, -0.25057435f, -0.04633329f, 0.09817829f, 
    0.09527422f, 0.15064034f, 0.01821093f, 0.01544863f, -0.00347183f, 0.02887672f, 0.00453026f, -0.17388374f, 
    -0.09025848f, 0.14233151f, 0.25284839f, -0.03674649f, 0.25289059f, -0.22282290f, 0.05928073f, 0.03160402f, 
    0.00838215f, 0.03183943f, 0.01238118f, 0.22962256f, 0.08256770f, -0.03305287f, 0.29976130f, 0.12049256f, 
    0.05236991f, 0.02909555f, 0.03177572f, 0.07347502f, -0.08296856f, -0.03799001f, -0.25199142f, -0.05243318f, 
    -0.05577125f, -0.07467546f, 0.03329967f, -0.12498271f, -0.07360729f, -0.16057512f, 0.23125842f, 0.19909485f, 
    0.00167772f, -0.09611256f, 0.01306406f, 0.20347469f, -0.00954765f, 0.23130511f, 0.16624866f, 0.00495258f, 
    0.22255443f, 0.15401262f, 0.23562679f, -0.22266434f, 0.04632185f, -0.09109152f, 0.00692428f, 0.12744227f, 
    -0.12212375f, 0.02789526f, 0.04024453f, -0.01145211f, 0.18397838f, -0.04427917f, -0.06919959f, 0.00906972f, 
    0.05580936f, -0.17311922f, 0.07416288f, 0.02414395f, 0.07699814f, -0.01981336f, 0.01579637f, -0.01520767f, 
    0.24901763f, -0.47028694f, 0.18717466f, -0.02487466f, 0.26999861f, 0.05603984f, 0.05663189f, 0.27969673f, 
    0.01145430f, -0.33299908f, 0.09158561f, 0.23045154f, -0.07144397f, 0.14752164f, 0.28013894f, -0.14619835f, 
    0.31812224f, 0.08511448f, 0.04671672f, 0.12150253f, 0.10841537f, -0.15400508f, -0.20040549f, -0.04418338f, 
    0.07783049f, -0.02083545f, -0.12494547f, -0.08686592f, -0.25482100f, -0.17645632f, -0.07074153f, 0.03192816f, 
    -0.07904880f, -0.04651384f, 0.29015452f, 0.14023249f, -0.01479701f, -0.15635636f, -0.09966880f, 0.03849173f, 
    -0.23739217f, -0.17264274f, 0.13656178f, 0.12624298f, -0.00481899f, 0.12249020f, 0.25653899f, -0.50983649f, 
    0.22444724f, 0.16819561f, 0.03818433f, 0.15576205f, -0.01196125f, 0.11731199f, -0.08429623f, -0.09047379f, 
    0.02188507f, -0.35821050f, 0.16152573f, -0.10317157f, 0.28601688f, -0.02638347f, 0.17291126f, 0.09490707f, 
    0.16813654f, -0.01625312f, -0.06389067f, 0.02311004f, 0.23967372f, -0.18639749f, -0.13719903f, -0.05420843f, 
    0.01938334f, -0.32587361f, -0.19150974f, -0.15533166f, 0.04037084f, 0.16699985f, -0.18328618f, 0.13713089f, 
    0.24261098f, -0.11441448f, 0.02494284f, -0.12437914f, 0.00053229f, 0.03618715f, 0.09541081f, 0.29134500f, 
    0.21238920f, -0.21477945f, -0.07371443f, -0.10788650f, 0.04794576f, 0.06790223f, -0.04883273f, -0.35655022f, 
    -0.01089758f, 0.00668265f, -0.08042406f, -0.19922845f, 0.03619864f, -0.23068011f, -0.12209477f, 0.02499144f, 
    -0.34990737f, -0.10080779f, -0.04699142f, 0.14310968f, 0.26740777f, -0.04021114f, -0.06345984f, -0.02578068f, 
    0.14283240f, -0.01531369f, 0.01379741f, -0.03185919f, 0.14506437f, 0.01143272f, -0.03698558f, 0.01813278f, 
    0.07681301f, -0.03455812f, 0.02307509f, 0.09495674f, 0.21368690f, -0.24940622f, 0.02191152f, 0.17167173f, 
    0.10906882f, -0.05740450f, 0.21710271f, 0.23748349f, 0.15008891f, 0.07762196f, 0.14963762f, 0.03204202f, 
    -0.21768954f, 0.28073856f, -0.09482954f, -0.34159455f, -0.20016776f, -0.00867050f, 0.10890314f, 0.19465150f, 
    -0.01518998f, 0.08398870f, -0.14685039f, 0.09499034f, 0.06001092f, 0.22953869f, 0.47205070f, 0.01532363f, 
    -0.01679740f, -0.19059880f, -0.01678366f, -0.10491516f, -0.07724535f, -0.14789243f, -0.15784189f, 0.07779194f, 
    0.05343894f, -0.12997575f, -0.11923050f, -0.02607138f, 0.22753319f, 0.15753226f, 0.08210579f, -0.03094734f, 
    -0.13471031f, 0.06951429f, -0.02417851f, -0.13022071f, 0.09814487f, -0.02740627f, 0.00382641f, -0.06171017f, 
    0.08254412f, -0.09542967f, -0.04052919f, 0.07707594f, -0.07593869f, 0.06983863f, -0.04222110f, 0.08804680f, 
    0.07062614f, -0.06121486f, -0.09558079f, 0.01673199f, -0.12617433f, 0.09225845f, -0.10760126f, 0.05186122f, 
    -0.09601811f, 0.10179311f, 0.07450300f, -0.07221968f, 0.04364771f, 0.03320149f, 0.10221760f, -0.09436263f, 
    -0.12439484f, -0.12421812f, -0.04577680f, -0.00915914f, 0.01856896f, 0.00506168f, -0.09571461f, 0.09721506f, 
    -0.11520698f, -0.03581637f, -0.08381578f, -0.08889803f, -0.04039521f, 0.08263531f, 0.00263970f, 0.04024435f, 
    -0.01835008f, 0.03619325f, -0.08980552f, -0.06260890f, -0.07806604f, 0.00072596f, 0.05690057f, -0.13064638f, 
    0.11799113f, -0.11972751f, -0.11740726f, -0.05488225f, 0.05544398f, -0.12220147f, 0.10365727f, 0.03916663f, 
    -0.12941709f, 0.10379331f, 0.20557481f, 0.12715794f, 0.05090827f, 0.05626296f, 0.39797068f, 0.08027253f, 
    0.22360888f, 0.19656806f, -0.09674933f, 0.22892140f, 0.05815461f, 0.35910305f, -0.27847624f, 0.06422644f, 
    -0.11153620f, 0.01139630f, 0.13500629f, -0.03890695f, 0.01972044f, 0.04596659f, -0.01254078f, 0.06785619f, 
    -0.07269703f, 0.08161654f, -0.14961410f, 0.15155517f, -0.21851338f, 0.16508855f, -0.05031545f, -0.35258466f, 
    0.02553189f, -0.15744255f, -0.26438087f, 0.16182536f, 0.16496964f, 0.14342186f, -0.17414413f, 0.03945290f, 
    -0.03013699f, -0.11294932f, -0.11466971f, -0.00780624f, -0.09180047f, 0.14225727f, 0.07446940f, -0.01446770f, 
    0.20297347f, 0.03354957f, -0.07840203f, 0.13217930f, 0.14436515f, 0.08961279f, -0.01531777f, -0.37241399f, 
    -0.07272633f, 0.01692125f, 0.09991225f, -0.00128613f, 0.23382241f, -0.15161142f, 0.04413747f, -0.06642522f, 
    0.19412352f, 0.03568722f, -0.24466415f, 0.02197022f, -0.25149980f, 0.03381594f, -0.03815451f, 0.27363235f, 
    -0.18410644f, -0.10705501f, 0.05859328f, 0.00910606f, -0.33764452f, 0.10404173f, 0.43931320f, 0.02365227f, 
    0.09194362f, 0.12168036f, 0.07878859f, -0.01522476f, -0.33358467f, 0.42254600f, 0.15756391f, 0.19894145f, 
    0.19525833f, 0.09513408f, -0.09746659f, 0.03805260f, -0.05966666f, 0.12705722f, 0.41723138f, 0.00646349f, 
    0.03373714f, 0.07044249f, -0.21710676f, -0.06163812f, 0.01839367f, 0.10056029f, -0.00648782f, 0.06265351f, 
    0.15713073f, -0.04725696f, 0.20699973f, 0.06236145f, -0.08902005f, -0.06850993f, 0.38996151f, -0.01730810f, 
    -0.40537477f, -0.20528749f, -0.04800658f, -0.02858204f, 0.19320297f, 0.34571764f, 0.02669679f, 0.26879987f, 
    0.03510926f, -0.05841497f, -0.17797624f, -0.02013399f, 0.13586231f, 0.24247782f, 0.01224682f, -0.03879472f, 
    -0.11311691f, 0.05211174f, 0.00667037f, 0.01796285f, -0.05441661f, 0.06627803f, -0.06528374f, -0.08303680f, 
    0.06536140f, 0.03851937f, 0.04204403f, -0.07366575f, -0.08998813f, -0.04210334f, 0.00883508f, -0.01290012f, 
    0.06920701f, -0.04485457f, 0.06843241f, -0.11235385f, -0.08921612f, 0.00265458f, -0.06790942f, 0.08778611f, 
    -0.07548859f, 0.10038055f, -0.12742195f, -0.09408014f, 0.04961232f, -0.04003863f, 0.08963694f, -0.11007544f, 
    -0.01855830f, 0.06517854f, 0.11078004f, 0.05962732f, -0.01770022f, -0.12426849f, -0.09091578f, -0.00138532f, 
    -0.03542294f, -0.08561650f, -0.05935741f, -0.06542209f, -0.05320656f, 0.02617298f, 0.02725057f, 0.04464163f, 
    -0.08091941f, -0.04282041f, -0.10085690f, -0.02712621f, 0.08146335f, -0.11795329f, -0.06965976f, 0.04383228f, 
    -0.07688240f, -0.08715687f, 0.01491693f, -0.10553695f, 0.04735839f, -0.09066300f, -0.12296972f, 0.09965652f, 
    -0.06489016f, -0.06339724f, -0.01732801f, -0.03523033f, -0.05152629f, -0.09679435f, 0.05786416f, -0.09628247f, 
    -0.04875778f, 0.01161742f, 0.06574527f, -0.00175114f, -0.11070365f, -0.03644679f, -0.09876265f, 0.07501302f, 
    0.10589217f, -0.12200244f, -0.05230330f, 0.00628775f, -0.06874412f, 0.10375009f, -0.02377696f, 0.11416085f, 
    0.11803847f, -0.08603520f, -0.10139336f, -0.00387667f, -0.07535903f, -0.03403386f, 0.01912832f, 0.12309790f, 
    -0.10497932f, -0.10555332f, 0.10843796f, 0.00793149f, -0.02081994f, -0.01045848f, -0.07580194f, -0.11118621f, 
    -0.04649447f, -0.09755242f, -0.06299613f, -0.03978038f, 0.11785245f, -0.12125994f, -0.04045987f, 0.02206479f, 
    -0.05649436f, 0.08073211f, -0.07886838f, 0.10700926f, -0.01738463f, 0.12357292f, -0.07652623f, 0.10053825f, 
    0.01856702f, -0.08575824f, 0.11275373f, -0.02735856f, 0.02837133f, 0.05168238f, 0.09762483f, 0.00147443f, 
    -0.18706708f, -0.18226594f, -0.16023162f, 0.06437911f, -0.12324977f, 0.12659292f, -0.12646429f, 0.01036741f, 
    0.09774179f, 0.02043154f, -0.05424757f, -0.32490119f, 0.12008314f, 0.29471448f, 0.19828379f, -0.07767151f, 
    -0.08204021f, 0.44619486f, 0.00521830f, 0.01756620f, 0.19020447f, -0.25438139f, 0.17956403f, 0.08511630f, 
    -0.21943456f, 0.03943422f, -0.36575770f, 0.04192597f, 0.08199069f, 0.26464999f, -0.25292867f, 0.16823107f, 
    0.13962938f, 0.27850074f, 0.08644428f, -0.10687065f, 0.05645295f, -0.34196460f, -0.08400971f, 0.08096868f, 
    -0.16004172f, 0.01843367f, 0.24484794f, 0.03837736f, 0.10593333f, 0.38552374f, -0.15072784f, -0.07387997f, 
    0.13528937f, 0.43549523f, 0.01203363f, -0.00482332f, 0.04296691f, 0.28035459f, 0.09999748f, -0.02007064f, 
    0.11933375f, 0.11039131f, 0.00582501f, 0.14754337f, -0.11844520f, -0.15821986f, 0.10136519f, 0.06301717f, 
    -0.04043745f, -0.24931382f, 0.05058866f, 0.02002908f, -0.00361588f, 0.06023160f, 0.25133649f, -0.14172654f, 
    0.24015568f, 0.01531208f, -0.03501753f, 0.00325523f, -0.00819568f, 0.01084480f, 0.23479237f, 0.03393540f, 
    0.09947535f, 0.14243190f, -0.14691581f, 0.11848775f, -0.00562547f, -0.16348015f, 0.03170129f, -0.05936497f, 
    0.05428310f, -0.53587341f, 0.20568709f, -0.22626628f, 0.20187254f, 0.30378127f, 0.08056580f, 0.22874153f, 
    -0.18554506f, 0.52325147f, -0.17128389f, -0.26590496f, -0.36525038f, 0.10719250f, -0.34521496f, -0.04981270f, 
    0.32045460f, -0.02896492f, -0.29386833f, -0.07848904f, -0.02117427f, 0.12003324f, -0.11867918f, 0.17297159f, 
    0.08503231f, -0.02380610f, 0.01117095f, 0.00411755f, -0.10904946f, -0.33876500f, 0.29375795f, 0.00025251f, 
    -0.00312688f, 0.03977266f, 0.00274795f, -0.31650397f, 0.15051635f, -0.19233991f, -0.03502192f, 0.00938128f, 
    -0.05263381f, -0.06255661f, -0.03199558f, -0.07479468f, -0.05958582f, 0.09128176f, -0.01031843f, -0.12169668f, 
    -0.11259362f, -0.10278256f, -0.09227255f, -0.02008192f, 0.02993119f, -0.11101872f, 0.04633605f, 0.09393743f, 
    0.03016454f, -0.07473665f, -0.06381775f, -0.11052661f, -0.06209220f, -0.07650147f, -0.03719157f, -0.02949865f, 
    0.07400179f, -0.07205088f, -0.04951058f, 0.01384138f, -0.04213285f, 0.09390397f, 0.05865024f, 0.08637041f, 
    0.09543110f, -0.10130782f, -0.07611376f, -0.04717284f, -0.06949732f, -0.03518112f, 0.03458552f, -0.04482944f, 
    0.07795396f, -0.11458741f, 0.01434116f, 0.07572694f, 0.05667895f, -0.05177957f, 0.00604315f, -0.09734586f, 
    -0.07291842f, -0.09767897f, 0.01353075f, 0.06597015f, 0.00207423f, 0.12067561f, 0.08833127f, 0.01091364f, 
    -0.05137596f, 0.04077673f, 0.12048514f, 0.00058509f, -0.05649148f, 0.05451836f, -0.03762272f, 0.10273971f, 
    0.29098085f, 0.16617998f, -0.16211402f, -0.08251048f, 0.07987694f, 0.11346941f, -0.00438701f, 0.14588054f, 
    -0.09758039f, 0.19563667f, 0.03818121f, -0.28289020f, 0.24034974f, -0.03024926f, -0.05140626f, -0.04745299f, 
    0.09182480f, -0.15867268f, 0.12119032f, -0.00380175f, 0.13208498f, -0.36570930f, -0.17462718f, -0.27379194f, 
    0.16586426f, 0.04432249f, -0.05003034f, -0.20635663f, 0.24435036f, -0.13575649f, -0.17918262f, 0.23659091f, 
    0.35280019f, 0.00975576f, -0.05773158f, -0.09922548f, 0.23688821f, -0.00557121f, -0.04981276f, -0.14688976f, 
    -0.01727510f, -0.06723446f, 0.04244117f, -0.02062270f, -0.03183510f, 0.09657957f, -0.34248927f, 0.12611315f, 
    -0.01696929f, 0.23025984f, -0.08084565f, -0.11355203f, 0.12440560f, 0.18870683f, 0.06938159f, 0.29169658f, 
    -0.01514261f, 0.03227977f, 0.03658557f, -0.07690935f, -0.17385434f, -0.00677283f, -0.07949211f, -0.07322652f, 
    -0.06423561f, 0.13156100f, 0.36164409f, -0.08845855f, 0.22990285f, -0.08827769f, -0.09833227f, 0.25310034f, 
    -0.00038493f, 0.08620037f, -0.10346220f, -0.09470852f, -0.08836868f, 0.06482030f, -0.06386543f, -0.09780975f, 
    -0.05985421f, 0.05265947f, 0.31171450f, -0.07150163f, -0.12268887f, 0.06772107f, 0.11389945f, -0.08492691f, 
    0.22216174f, -0.07054392f, 0.11437768f, 0.21062443f, 0.07290883f, 0.24259846f, 0.09427360f, -0.05649608f, 
    -0.21848503f, 0.18235557f, -0.10273017f, 0.02398634f, 0.16952221f, -0.06292508f, 0.17399795f, 0.08633715f, 
    -0.04258230f, 0.07509552f, -0.14002725f, 0.06195192f, -0.06535444f, -0.15489170f, -0.29263610f, 0.02299437f, 
    -0.00183014f, 0.15470350f, 0.01752840f, 0.12269480f, -0.22154108f, -0.16150340f, -0.13166237f, -0.16492511f, 
    0.02471709f, 0.01394215f, 0.11360360f, 0.19821464f, -0.24425882f, 0.00469882f, -0.03766121f, 0.01350838f, 
    0.06642438f, -0.00773590f, 0.32873720f, 0.04964802f, 0.05536210f, -0.10695145f, 0.04466523f, 0.17142828f, 
    0.13049689f, 0.21298434f, -0.08579741f, 0.07795247f, 0.15845689f, 0.07725840f, -0.14193115f, 0.01498764f, 
    0.08548115f, 0.11733558f, 0.15468746f, -0.04620935f, 0.01544822f, 0.04465607f, 0.16184254f, -0.21899039f, 
    0.00136344f, 0.10103635f, 0.04568355f, -0.01485489f, -0.13508150f, 0.40963748f, -0.22877105f, -0.11459379f, 
    -0.09356342f, 0.23176649f, 0.11756583f, 0.19459398f, -0.09452387f, -0.00433253f, -0.01943673f, 0.03539359f, 
    -0.08376539f, 0.11027627f, 0.00191922f, 0.11094099f, -0.04763911f, 0.11803765f, -0.20613202f, -0.06005621f, 
    0.17753489f, -0.05835816f, 0.08853152f, 0.01174116f, -0.14089200f, -0.10025220f, 0.08857910f, 0.04852571f, 
    -0.05641596f, 0.06718155f, 0.32279518f, 0.18781020f, -0.28633484f, -0.12261641f, 0.09582772f, -0.02411495f, 
    0.00499283f, -0.00560770f, -0.18998477f, 0.26493788f, 0.12300850f, 0.01222381f, -0.08700264f, -0.00174365f, 
    0.20359777f, -0.08379015f, 0.06908134f, -0.09168898f, 0.27013558f, -0.03591395f, -0.32948264f, 0.01087429f, 
    -0.10440107f, 0.00533831f, -0.12684175f, 0.11217012f, 0.22070180f, -0.45012447f, -0.11076599f, -0.27565277f, 
    0.09234685f, -0.05362360f, 0.33244759f, 0.03567459f, 0.27499297f, -0.11218238f, -0.01631772f, 0.16205886f, 
    -0.01742229f, 0.26739955f, 0.07752680f, -0.26187003f, 0.05515242f, -0.06518288f, 0.01087949f, 0.18196979f, 
    0.03777099f, 0.07395449f, -0.20057538f, 0.00327356f, 0.03674550f, 0.25375405f, 0.24637149f, -0.09039860f, 
    0.10941761f, 0.10565792f, -0.01384186f, -0.11471206f, 0.05250983f, -0.08604144f, -0.15764551f, 0.17783111f, 
    -0.09834594f, -0.04380489f, 0.08235078f, 0.09619027f, 0.16994484f, 0.11734655f, -0.02306146f, 0.09137826f, 
    -0.13625693f, 0.04534143f, -0.03934462f, 0.07701444f, -0.12072871f, -0.10532986f, 0.07175677f, -0.06945641f, 
    -0.06296904f, -0.12901568f, -0.02414314f, -0.10499272f, 0.07835617f, 0.05965392f, -0.06607301f, -0.04174353f, 
    0.10946145f, -0.12050387f, 0.09139826f, 0.09670779f, 0.06870265f, -0.11478466f, -0.14310312f, -0.09675223f, 
    -0.10195944f, 0.02339605f, -0.12421744f, 0.10880480f, -0.12851040f, 0.06232399f, -0.00080338f, -0.02202479f, 
    0.07505532f, -0.08353107f, -0.10438340f, 0.08194387f, -0.10096601f, -0.13915935f, -0.06925520f, -0.10973245f, 
    0.00821833f, 0.00927673f, -0.05398810f, -0.06243902f, -0.08927946f, -0.04154882f, -0.05345429f, 0.02936993f, 
    -0.00100957f, 0.00989719f, -0.03531843f, -0.08812161f, 0.05890013f, 0.05141625f, 0.02450025f, -0.09461150f, 
    0.07023135f, 0.01047959f, 0.03892707f, 0.05173855f, -0.13003439f, 0.07073336f, -0.12058429f, 0.09128462f, 
    0.23033334f, 0.01720172f, 0.11793626f, 0.24440339f, -0.18645890f, -0.00738472f, 0.16233601f, -0.00139414f, 
    0.14188762f, 0.27647614f, -0.05347897f, 0.31397769f, 0.20799775f, 0.27784207f, -0.20090827f, -0.01592771f, 
    0.01762985f, -0.13298984f, -0.04972043f, 0.02692461f, 0.19652030f, 0.10619684f, 0.10398436f, -0.00996602f, 
    -0.09628546f, 0.37369642f, -0.10383984f, -0.05650089f, -0.22156061f, -0.30587944f, -0.10053241f, -0.28937331f, 
    0.21567334f, -0.21726321f, 0.02180837f, -0.03533558f, 0.26455751f, 0.26440272f, -0.12580068f, 0.00967950f, 
    -0.16907366f, -0.07378966f, 0.08083336f, 0.10613690f, -0.06820362f, 0.15164122f, 0.10205754f, -0.04863907f, 
    0.18749410f, -0.03771893f, 0.02265380f, 0.00673146f, 0.40049362f, 0.26304144f, -0.01142905f, -0.02645989f, 
    0.08202711f, -0.00430142f, 0.14994058f, -0.00901530f, 0.47196433f, 0.18408258f, 0.12415607f, 0.08429046f, 
    -0.03507814f, -0.08355399f, 0.03456457f, -0.13136739f, -0.00197997f, -0.09985366f, 0.01565619f, 0.04648825f, 
    0.05474909f, -0.00862706f, 0.09390917f, 0.07143377f, 0.05160088f, 0.05923958f, -0.05736709f, 0.10293722f, 
    0.08186682f, -0.04541111f, -0.00025651f, -0.00721993f, -0.07685153f, -0.09021015f, 0.07331468f, 0.04179350f, 
    -0.13075121f, 0.00614141f, 0.05995639f, 0.07785638f, -0.01091511f, -0.07233399f, -0.09671469f, 0.00740802f, 
    -0.06452386f, 0.11106157f, 0.00639632f, -0.10585579f, -0.01731299f, -0.03553203f, -0.14663287f, -0.10337315f, 
    -0.11341534f, 0.04869083f, 0.10054385f, 0.05836830f, 0.03162336f, 0.04337415f, -0.06795511f, 0.09643527f, 
    -0.07247087f, -0.01344647f, -0.11667093f, -0.03090938f, 0.07073113f, 0.06990041f, -0.03801500f, -0.10019848f, 
    -0.06173408f, 0.05343746f, -0.13914435f, 0.00443447f, 0.01340193f, 0.08769871f, 0.12215299f, -0.05477226f, 
    0.08620740f, -0.01813034f, -0.03431417f, -0.00036070f, 0.06268322f, -0.09512854f, -0.10374540f, -0.06381926f, 
    0.07213794f, -0.04563629f, 0.02494047f, -0.12505841f, 0.08516096f, 0.01304946f, 0.02451470f, -0.08038118f, 
    0.06190074f, -0.11904188f, 0.08981705f, 0.11448579f, 0.08927197f, -0.05927494f, 0.01957607f, -0.05430986f, 
    -0.09022626f, -0.10762207f, -0.12906982f, -0.04660155f, -0.10607003f, 0.01938330f, -0.02975273f, -0.10255395f, 
    -0.03139298f, -0.01597422f, -0.00658954f, -0.02498158f, 0.02143491f, -0.13618025f, -0.12830664f, -0.10383046f, 
    -0.06999819f, 0.03154073f, 0.03192635f, 0.00376141f, -0.12768425f, -0.03661935f, 0.02731862f, -0.12397185f, 
    -0.11805838f, 0.08778766f, 0.01626515f, 0.11343801f, -0.00517277f, -0.03051239f, 0.02313539f, -0.07326739f, 
    0.05632074f, 0.00682187f, 0.03104681f, -0.07440437f, 0.07392185f, -0.09904743f, -0.02759223f, 0.09607682f, 
    0.34715891f, -0.03055177f, -0.21372022f, -0.00580847f, -0.15523483f, 0.10968279f, 0.14565510f, 0.16002469f, 
    -0.09350165f, 0.18569398f, -0.06640920f, -0.06563045f, 0.21165748f, 0.00163034f, -0.00379259f, 0.07616458f, 
    -0.07579884f, -0.15493865f, -0.03589778f, -0.02217991f, 0.15889968f, -0.27988949f, -0.01629399f, -0.26867613f, 
    0.20326908f, -0.04332331f, 0.25328535f, -0.20987271f, -0.03221974f, -0.24669118f, -0.01102296f, 0.07602821f, 
    0.14554611f, -0.10810634f, -0.13972704f, -0.16295487f, 0.25413647f, 0.10375796f, -0.15362348f, 0.13894816f, 
    -0.07325868f, 0.03512147f, -0.15760833f, -0.02261078f, 0.05319353f, 0.10587927f, 0.07005381f, -0.08015493f, 
    0.20485266f, 0.09367824f, -0.07063573f, 0.10071887f, 0.00611484f, 0.18523198f, -0.05776773f, 0.29951519f, 
    -0.05644450f, 0.03915603f, 0.18308039f, 0.04907293f, 0.24733238f, -0.01834618f, 0.03282074f, -0.01361381f, 
    -0.03316105f, 0.09444693f, 0.20268849f, 0.09821626f, 0.19864552f, 0.02374589f, -0.13328400f, 0.23042287f, 
    -0.10918890f, 0.10505297f, 0.07829332f, -0.12784898f, 0.01649553f, 0.21404497f, -0.08662922f, -0.02040505f, 
    -0.09356819f, 0.41708103f, -0.03595052f, -0.08195153f, 0.06592820f, -0.32236198f, 0.10756636f, -0.25451002f, 
    -0.23342238f, -0.09543886f, 0.20686759f, -0.04484880f, 0.09724442f, -0.05077788f, -0.12429615f, 0.43066674f, 
    -0.24284753f, 0.06797539f, 0.42030069f, 0.16263835f, 0.00063136f, -0.13302974f, 0.29703900f, 0.05477586f, 
    0.05544897f, -0.11011953f, 0.00428011f, -0.01038687f, -0.03615735f, 0.10201869f, -0.34621337f, -0.13412583f, 
    0.27569887f, 0.46714917f, 0.04350264f, 0.03571640f, -0.17794631f, -0.12991506f, 0.21483932f, -0.13095962f, 
    -0.00760213f, 0.05932852f, 0.27169600f, 0.06738945f, -0.07135520f, -0.07478957f, -0.03491285f, 0.13079481f, 
    0.03767902f, 0.08711736f, 0.10761654f, -0.02125382f, -0.12025824f, 0.11146280f, 0.00409952f, -0.07905556f, 
    0.05169095f, -0.00499796f, 0.05495515f, -0.00332083f, 0.03386720f, -0.00120819f, 0.09765818f, -0.09619593f, 
    0.05714678f, -0.12414922f, -0.05951477f, 0.11016411f, -0.00358141f, 0.00609339f, -0.07558317f, 0.11962982f, 
    0.06813894f, 0.03438289f, 0.10618391f, -0.01066770f, -0.01709030f, -0.09821549f, 0.09631549f, 0.02014405f, 
    -0.06876542f, -0.13218544f, -0.03815172f, 0.03756526f, 0.05113430f, -0.05300409f, -0.07672279f, -0.11445566f, 
    -0.07795728f, -0.08818679f, -0.02044600f, 0.08346195f, -0.08154773f, 0.10764185f, 0.02325631f, -0.09239446f, 
    -0.07424266f, 0.10443022f, 0.04702738f, 0.01163285f, 0.01622903f, -0.05567115f, -0.09595637f, 0.01856601f, 
    0.00791402f, -0.03714592f, -0.10719390f, -0.05975301f, -0.09334868f, -0.10182387f, 0.08023269f, -0.09284618f, 
    0.03163885f, -0.12696832f, 0.11622851f, 0.08263314f, -0.09324963f, 0.04991211f, -0.12194872f, -0.06728875f, 
    -0.02487634f, 0.15893333f, -0.04695490f, 0.05434852f, -0.13016640f, -0.06315415f, 0.34219712f, 0.08977580f, 
    0.01460532f, 0.36099643f, -0.25356561f, -0.00500435f, -0.03876026f, 0.33806518f, 0.13155288f, 0.10266222f, 
    -0.22509459f, 0.01020396f, 0.01482293f, 0.02829246f, -0.05019964f, -0.04138377f, 0.15943801f, 0.01770250f, 
    0.19517057f, 0.22856539f, 0.49628624f, 0.20983960f, -0.23672637f, 0.08191393f, 0.16506562f, 0.02042291f, 
    -0.00238331f, -0.11970511f, 0.17444929f, -0.02319416f, -0.05983342f, 0.10363839f, 0.07670705f, -0.16437563f, 
    -0.09524471f, 0.05998246f, 0.05479036f, -0.08196966f, -0.25408241f, -0.01313293f, 0.34925413f, 0.18805899f, 
    0.10508536f, 0.09022917f, 0.08741744f, -0.05656397f, 0.12786961f, 0.33968893f, 0.11339274f, -0.06989392f, 
    -0.25505444f, 0.02455008f, 0.27578521f, 0.19772315f, 0.30450878f, -0.06095956f, -0.15137881f, -0.07433841f, 
    0.25610915f, 0.17228551f, 0.11895960f, 0.12166282f, 0.14426661f, -0.10469761f, -0.19691871f, -0.01024521f, 
    -0.11007451f, 0.14322212f, 0.02194597f, -0.00653910f, 0.14383997f, -0.06479347f, 0.03289949f, -0.14560473f, 
    0.05451249f, 0.12726524f, 0.42606187f, 0.13569684f, 0.11754955f, 0.18756405f, -0.08607865f, -0.14875299f, 
    -0.24510004f, 0.43123344f, 0.14969225f, -0.09996876f, -0.15258372f, 0.30264974f, 0.15263030f, -0.02377959f, 
    0.08268672f, -0.07632373f, -0.09145305f, 0.07740130f, -0.05757260f, 0.06943949f, -0.03116888f, -0.18804006f, 
    0.21974431f, -0.18981376f, -0.03830614f, -0.08011738f, -0.14108385f, -0.40429461f, -0.07145120f, 0.03226084f, 
    -0.03679706f, 0.07813908f, 0.16604088f, 0.01343974f, -0.02580322f, 0.22047408f, 0.01217825f, 0.04585350f, 
    0.01185021f, -0.03169250f, 0.03450159f, 0.10410672f, -0.00002772f, 0.05096719f, 0.24172971f, -0.10623255f, 
    0.06288601f, -0.01010050f, -0.11101414f, -0.10907947f, -0.11338668f, -0.13015765f, 0.23626339f, -0.00848020f, 
    -0.03175299f, -0.01032240f, 0.29967526f, 0.11342590f, -0.05797383f, 0.10118482f, -0.09232730f, 0.30131006f, 
    0.16405872f, 0.06324475f, -0.08266295f, 0.15471546f, 0.11812061f, 0.05742021f, 0.09991525f, -0.16027597f, 
    0.12334711f, 0.02849057f, -0.41164985f, 0.03859526f, 0.28298882f, -0.14888844f, -0.14878134f, 0.15994763f, 
    0.13599253f, 0.06104097f, 0.03507972f, -0.08991341f, 0.08096889f, 0.04990342f, -0.00475745f, 0.24488190f, 
    -0.21599317f, 0.09905238f, 0.00764023f, 0.02607941f, 0.30957556f, 0.26559851f, 0.12803142f, -0.18740864f, 
    -0.03306395f, -0.10511827f, -0.24586555f, 0.06344575f, 0.18359172f, 0.15494552f, -0.04309964f, 0.03634153f, 
    -0.09037755f, -0.00161192f, -0.19702902f, -0.13873252f, -0.11476594f, -0.01958910f, 0.23026393f, -0.19924794f, 
    -0.09348883f, -0.05213183f, -0.11594317f, -0.03957628f, -0.00238879f, 0.10644879f, 0.18010436f, -0.10374259f, 
    0.10665811f, -0.21993722f, 0.13681491f, -0.01028449f, 0.12292929f, -0.19142234f, 0.18671329f, 0.05436884f, 
    0.10930236f, -0.03799593f, -0.33250168f, -0.02569159f, 0.20858046f, -0.24855252f, 0.04205811f, -0.05038293f, 
    0.21007927f, -0.51265830f, -0.12040356f, -0.27901554f, 0.28099170f, 0.06043005f, -0.20755093f, 0.18246517f, 
    0.13461038f, -0.10172620f, -0.04337560f, 0.03190433f, -0.09296536f, 0.09306102f, -0.05719085f, 0.29220539f, 
    0.22421809f, 0.09562074f, 0.08278489f, -0.03013728f, 0.25544479f, 0.39293867f, -0.09960345f, -0.13691375f, 
    0.09495278f, 0.11155122f, -0.07578687f, -0.00017849f, 0.17846699f, -0.13677880f, 0.07127593f, 0.10469525f, 
    0.19359399f, 0.09562653f, -0.16602525f, 0.21244375f, 0.05819435f, -0.04891523f, -0.19903798f, -0.08929727f, 
    0.15743953f, 0.12682460f, -0.01706676f, 0.02309291f, 0.12284836f, -0.11252868f, 0.13934559f, -0.07545601f, 
    -0.10756250f, 0.23863396f, 0.11951969f, -0.02629891f, 0.03765397f, -0.08555413f, -0.13139917f, 0.19302721f, 
    -0.27728224f, 0.37039077f, -0.21235739f, 0.00553700f, -0.06986142f, -0.16811056f, -0.13215388f, 0.13418476f, 
    0.25950220f, -0.00906802f, 0.05741624f, 0.18968956f, 0.12773541f, -0.21898557f, 0.01748767f, 0.19371320f, 
    -0.23843363f, -0.08166575f, 0.32818139f, 0.08861177f, -0.09934139f, 0.22563757f, -0.01629707f, 0.02400151f, 
    -0.01475452f, 0.27459079f, -0.09890793f, 0.11325889f, 0.29481533f, 0.26115227f, 0.10015296f, 0.08896089f, 
    -0.04468079f, 0.08963808f, -0.21327849f, 0.19976373f, -0.03454711f, 0.19200498f, 0.13268024f, -0.06287551f, 
    -0.14117616f, -0.13796207f, 0.10197350f, 0.11009559f, -0.11634267f, -0.06822237f, 0.19645964f, 0.02697398f, 
    0.21059144f, 0.12866576f, 0.07338294f, 0.11042890f, 0.23261924f, 0.37212527f, -0.19915217f, 0.06132285f, 
    0.01674900f, 0.08599506f, 0.15821795f, -0.06561704f, 0.30296490f, -0.12865864f, 0.22034445f, -0.06079492f, 
    0.15242605f, -0.15763442f, 0.18354359f, 0.07383306f, 0.02399527f, 0.09691996f, -0.22035512f, -0.10957296f, 
    -0.06602689f, 0.11613461f, 0.00098404f, -0.16428137f, -0.01667434f, 0.12162509f, -0.02680077f, -0.01247767f, 
    0.00369250f, 0.04245684f, -0.14210467f, -0.07791060f, 0.06413976f, 0.25493005f, 0.23333564f, 0.21246298f, 
    0.19651173f, 0.03817579f, -0.04312092f, 0.03193167f, 0.12316341f, -0.04642099f, -0.16174361f, -0.11554501f, 
    0.01198436f, -0.03802675f, 0.22468445f, -0.05572664f, -0.00974641f, -0.21014608f, 0.04787512f, -0.08666460f, 
    0.07853548f, -0.07588788f, -0.07144341f, -0.17450438f, 0.10514243f, -0.12297034f, 0.02407916f, -0.05484124f, 
    0.07670622f, -0.06054034f, -0.08549703f, -0.09823204f, -0.04353904f, -0.05075618f, 0.16590685f, 0.00343965f, 
    -0.11267173f, -0.01799819f, 0.20117851f, -0.00497404f, 0.21156012f, 0.31896165f, 0.17505272f, 0.13352829f, 
    0.17392620f, -0.21473818f, 0.12291621f, -0.11222716f, 0.35911012f, 0.24091524f, -0.07783647f, 0.13126202f, 
    0.18755497f, 0.11529370f, 0.10431925f, -0.04056880f, -0.09385685f, 0.29620019f, -0.10645068f, -0.13944510f, 
    0.27353635f, 0.05212702f, 0.16749381f, -0.09240726f, -0.01763430f, 0.16995312f, -0.23083813f, 0.19437236f, 
    0.06816140f, -0.02636101f, 0.07410768f, 0.09758411f, -0.07557949f, -0.14883400f, 0.26749247f, 0.01271207f, 
    -0.06980946f, -0.06207172f, 0.15384911f, -0.07436340f, 0.00772089f, -0.08854926f, 0.04622797f, 0.06808691f, 
    0.07350448f, -0.02945324f, -0.07866143f, -0.09592675f, -0.05394502f, 0.06507447f, 0.01989688f, -0.06569114f, 
    -0.14621621f, -0.05933327f, -0.00118082f, -0.12878114f, -0.06165516f, 0.03460690f, 0.08290733f, 0.00623994f, 
    0.12029646f, -0.09472132f, 0.03847474f, -0.08284460f, -0.17189512f, -0.11619746f, 0.02388306f, 0.01961040f, 
    0.08721156f, -0.11829520f, -0.08411758f, -0.11185962f, -0.09435292f, 0.06809606f, -0.07134163f, -0.05462210f, 
    -0.06651334f, -0.10974471f, -0.06904221f, 0.04623668f, -0.00720046f, -0.03844179f, -0.05047557f, 0.09885564f, 
    -0.09165399f, 0.07877930f, 0.02612203f, -0.11699779f, -0.07070338f, 0.08331967f, 0.12164133f, -0.05730347f, 
    -0.09249932f, -0.01185517f, 0.06779062f, -0.06001445f, -0.09408716f, 0.05031436f, 0.03164724f, 0.11485220f, 
    0.11817339f, 0.01954370f, -0.05100473f, -0.05273516f, 0.08562119f, 0.04472092f, -0.04298776f, 0.09863377f, 
    -0.00678169f, 0.14416784f, 0.15539810f, -0.01321218f, 0.07240308f, -0.04065338f, -0.01636214f, -0.15734783f, 
    -0.02604987f, 0.04024121f, 0.00722828f, -0.29351085f, -0.00482034f, -0.10185061f, 0.11093273f, -0.04219769f, 
    -0.11887567f, 0.32344148f, 0.09601358f, -0.04737816f, 0.09240077f, -0.36861551f, 0.08684804f, 0.10830066f, 
    -0.02352565f, -0.11637639f, -0.23047557f, -0.13836253f, 0.11420844f, -0.10028331f, -0.01464607f, 0.13982332f, 
    0.22293469f, -0.09620087f, 0.26553643f, 0.21248321f, 0.12529655f, -0.36571643f, 0.16818805f, 0.05531838f, 
    0.17095760f, 0.04361764f, 0.28410181f, 0.02545986f, 0.00015186f, -0.01889575f, -0.25489253f, 0.34762681f, 
    0.05077982f, 0.15254861f, 0.10532854f, 0.11827537f, 0.14573970f, 0.00818271f, 0.32147706f, -0.25960615f, 
    0.10800412f, 0.02354733f, -0.13287139f, 0.14661738f, -0.30027649f, -0.07446889f, -0.00444038f, -0.01498591f, 
    0.37478742f, 0.29742628f, 0.17210715f, 0.24097289f, 0.03243423f, -0.05212206f, 0.09690217f, 0.18848598f, 
    -0.21452881f, -0.02052638f, 0.08584586f, -0.03710699f, -0.15402351f, -0.16369808f, -0.00594195f, -0.01274499f, 
    0.06608701f, -0.24577315f, 0.08998770f, 0.00514042f, -0.15050349f, 0.12149565f, -0.00624878f, 0.23507164f, 
    0.38178083f, -0.01532304f, 0.20392007f, 0.17951329f, -0.15843776f, -0.01539488f, 0.25771829f, -0.02866464f, 
    0.34251460f, -0.06212169f, 0.12871668f, 0.14724058f, 0.16267295f, -0.17119583f, 0.18626656f, 0.18211120f, 
    -0.08285107f, 0.01171975f, 0.01607427f, 0.03492635f, 0.09172747f, -0.09342798f, 0.20484190f, 0.20748350f, 
    -0.20641108f, -0.31551254f, -0.04767403f, 0.09808622f, 0.30380043f, 0.21602866f, -0.16395308f, 0.09623624f, 
    0.08517330f, 0.12735336f, -0.24429509f, 0.18878017f, -0.02276180f, 0.14433765f, -0.00267640f, -0.05925381f, 
    -0.17540681f, 0.04323703f, 0.24517041f, 0.12811711f, 0.01014266f, 0.02756563f, 0.24320891f, -0.06527940f, 
    -0.02477626f, 0.14357805f, -0.07370223f, 0.16686766f, 0.07388844f, 0.02312660f, -0.23583187f, -0.04809025f, 
    -0.01653381f, 0.22171442f, 0.18647496f, -0.09495057f, -0.01051724f, 0.00794867f, 0.26838410f, -0.11800690f, 
    -0.12562954f, 0.01004177f, -0.16621606f, 0.13202170f, -0.14164111f, 0.24970557f, -0.26102138f, -0.12315089f, 
    -0.13725412f, -0.23464453f, 0.21612796f, 0.29022273f, 0.14313836f, -0.11327174f, 0.02637908f, -0.15202235f, 
    0.15875989f, -0.04663137f, 0.06340794f, 0.09426580f, -0.04009293f, -0.08581624f, -0.20700671f, 0.17265911f, 
    0.16717981f, 0.14441262f, 0.02464257f, -0.03482857f, -0.06973685f, -0.17599998f, 0.12396222f, -0.31674248f, 
    -0.11443485f, -0.06807330f, 0.29540157f, 0.01938531f, -0.25210643f, -0.16235766f, 0.08376016f, 0.03695795f, 
    0.06321167f, 0.03418704f, -0.05877837f, -0.08365786f, -0.16065885f, 0.02566018f, 0.04712320f, 0.00442624f, 
    0.07267892f, -0.02875128f, 0.08547559f, -0.01431548f, -0.02614961f, 0.01457147f, 0.01692112f, 0.01690911f, 
    0.06462373f, -0.12004040f, -0.04151411f, -0.00717910f, -0.10837985f, -0.13231824f, -0.07109737f, -0.15883769f, 
    -0.14423436f, -0.11804079f, -0.03460120f, 0.04118049f, -0.04287230f, 0.01032531f, 0.00336160f, -0.02034524f, 
    0.04720880f, 0.03693791f, -0.10679072f, 0.08799952f, -0.10389120f, -0.11299739f, -0.10250201f, -0.13849543f, 
    -0.05980269f, 0.00746644f, -0.08781362f, -0.00951882f, -0.01555632f, 0.08058092f, 0.01382416f, 0.10096222f, 
    -0.11004487f, -0.00908334f, -0.10595410f, -0.05511872f, 0.03934602f, 0.00162218f, -0.10781092f, 0.01637824f, 
    0.08875402f, 0.00491555f, -0.14058140f, 0.01077567f, 0.00738432f, -0.09739781f, 0.00867565f, -0.02042583f, 
    0.09090205f, 0.17385881f, 0.09082964f, 0.16726562f, -0.11378365f, 0.10368999f, -0.04300009f, 0.09459144f, 
    0.00626186f, 0.06423935f, -0.08448324f, -0.23353045f, -0.05367367f, -0.07094818f, 0.20326601f, -0.07599679f, 
    0.11473072f, 0.26214314f, 0.17297119f, 0.02796650f, -0.17607540f, 0.17796662f, -0.04661524f, 0.10476162f, 
    0.16328932f, 0.05563739f, -0.05745831f, -0.04662130f, -0.16358234f, 0.36551023f, -0.21009952f, -0.04849107f, 
    0.19249460f, 0.27753451f, 0.03219465f, 0.14927530f, 0.04296342f, -0.24191473f, -0.13412029f, -0.00368676f, 
    -0.07884137f, -0.04977840f, -0.05667293f, -0.11812900f, -0.05965987f, 0.08036166f, -0.13658871f, 0.20225844f, 
    -0.07146083f, -0.06050353f, 0.07336611f, 0.02334888f, 0.03433863f, -0.13928527f, 0.22187196f, 0.08547433f, 
    0.10805469f, 0.09311619f, -0.06371278f, 0.25387478f, -0.24172387f, 0.08650927f, 0.02594595f, 0.00696197f, 
    0.12007191f, 0.02728688f, -0.24696632f, 0.00774598f, -0.02815949f, -0.00553597f, 0.04797486f, 0.00471187f, 
    0.03260393f, -0.05366733f, -0.00556643f, 0.06032648f, 0.23059987f, 0.24262756f, 0.02953263f, 0.02199640f, 
    -0.06298958f, -0.04926481f, 0.02171600f, 0.08654863f, 0.14044155f, 0.17789042f, 0.07560474f, 0.01022877f, 
    -0.22218709f, 0.25337294f, 0.01120555f, 0.03983972f, 0.17896464f, -0.41845801f, 0.24603713f, -0.24963799f, 
    -0.18076539f, -0.13835259f, -0.22027919f, -0.16100706f, 0.19530044f, 0.38671491f, -0.07755109f, 0.16323052f, 
    0.09344997f, -0.11088591f, 0.12626812f, -0.00695153f, 0.00963372f, -0.00228051f, 0.19670747f, -0.15262066f, 
    0.21490434f, 0.19012998f, -0.05715952f, -0.07389975f, -0.05459639f, 0.30514571f, -0.01845877f, 0.02152850f, 
    0.04907411f, -0.05287746f, 0.09204457f, -0.19738756f, 0.58337259f, -0.03864253f, -0.09066132f, -0.04795679f, 
    -0.10475286f, 0.07610172f, 0.06319419f, -0.10593835f, -0.23188899f, 0.06002966f, 0.05363502f, -0.01452198f, 
    -0.09686407f, -0.00756116f, -0.04894575f, -0.04978046f, -0.22254850f, 0.13743879f, 0.40266174f, -0.01600923f, 
    -0.03274801f, -0.06646229f, 0.25625011f, -0.07326271f, -0.05678816f, 0.40994608f, -0.07662123f, 0.30197883f, 
    0.00640637f, 0.30983275f, -0.29000828f, 0.29208410f, -0.27953169f, 0.14266662f, 0.24376659f, -0.51430702f, 
    0.03023403f, 0.22123495f, -0.23564699f, 0.09094062f, 0.08010460f, 0.18926691f, 0.08266244f, 0.18049337f, 
    -0.07142985f, 0.01304402f, -0.01137297f, 0.04376700f, -0.03306802f, -0.01700275f, 0.07928020f, 0.05060590f, 
    -0.19328724f, -0.06962543f, -0.03216132f, 0.04223979f, 0.19081606f, 0.16668354f, 0.19129226f, 0.07039240f, 
    0.06997279f, -0.05692571f, -0.32817331f, 0.16870753f, -0.04889807f, -0.04145003f, 0.00576112f, -0.10459831f, 
    -0.33975932f, 0.06990381f, 0.07697142f, 0.22093798f, 0.02349005f, -0.01886832f, 0.10756716f, -0.16309254f, 
    0.31225637f, -0.00198328f, -0.01907540f, -0.29323116f, -0.20716143f, -0.06130590f, 0.29273018f, -0.04139804f, 
    0.01702166f, 0.32767472f, 0.23017327f, -0.10266209f, -0.01560759f, 0.04701611f, -0.03730022f, 0.13075095f, 
    0.01125215f, 0.11633405f, -0.11191279f, 0.07631187f, 0.01597549f, 0.43678653f, -0.19980960f, 0.01933632f, 
    -0.06999072f, 0.47461876f, -0.13803057f, 0.04728973f, -0.14145598f, -0.05892654f, -0.18284507f, -0.05317125f, 
    0.05275981f, 0.06275622f, 0.07738313f, -0.06643278f, -0.02300263f, 0.27931160f, -0.14107765f, 0.20856620f, 
    -0.10707229f, -0.16870496f, 0.02247469f, 0.02905643f, 0.25317019f, -0.03042410f, 0.41277489f, -0.09977439f, 
    -0.12646420f, 0.09488122f, -0.22297651f, 0.09092137f, -0.20084253f, -0.05553234f, 0.10821736f, -0.11644639f, 
    0.18643728f, 0.17644873f, 0.15363915f, -0.00788410f, 0.17952029f, 0.05743489f, -0.10069618f, -0.00534887f, 
    -0.15200226f, 0.09685735f, -0.10782863f, 0.31186432f, 0.06570605f, -0.08461681f, -0.07213978f, -0.05207104f, 
    -0.03381184f, -0.32892632f, 0.18367149f, -0.06906001f, -0.10842936f, -0.01855863f, 0.13915332f, 0.00557445f, 
    0.13056798f, -0.05977235f, 0.28395408f, 0.18906814f, 0.11856311f, -0.27311146f, 0.26962888f, -0.01708370f, 
    -0.11070114f, -0.36489281f, -0.22062190f, -0.05832034f, 0.26190436f, 0.11882077f, 0.23519014f, 0.11707170f, 
    0.14231686f, -0.09797493f, -0.00417772f, 0.01956305f, 0.03643640f, -0.25294164f, 0.03693018f, -0.10829362f, 
    -0.01686563f, -0.09661546f, 0.00192026f, -0.10981304f, -0.15893590f, -0.03834579f, -0.32315242f, 0.22233167f, 
    -0.10911274f, -0.09950738f, -0.01858224f, 0.22336064f, 0.16535516f, 0.01490169f, 0.10744394f, 0.01755361f, 
    0.23801026f, 0.20822811f, 0.05170438f, -0.06459365f, 0.05314054f, -0.05449139f, -0.25235587f, 0.02679495f, 
    -0.08060242f, 0.10503256f, -0.03525631f, -0.19403368f, -0.17592813f, -0.41770831f, 0.26575872f, 0.02536510f, 
    0.05050277f, -0.02110174f, 0.01706184f, -0.09693567f, -0.17969094f, 0.33342847f, 0.01259224f, 0.17140783f, 
    0.16618748f, -0.06614417f, 0.21488379f, 0.14490752f, 0.15336630f, 0.02552851f, 0.01967702f, 0.18952829f, 
    0.37524155f, 0.00295191f, 0.15978949f, 0.12323052f, -0.09771838f, -0.16510303f, 0.28927037f, 0.09082178f, 
    0.14333475f, 0.08986683f, 0.05667191f, -0.07130456f, -0.09601218f, -0.20249932f, -0.10950680f, 0.18348716f, 
    -0.07961699f, -0.20301984f, -0.01555326f, -0.11911600f, -0.10095835f, -0.16844800f, 0.24769609f, 0.39366388f, 
    -0.01993099f, -0.12577046f, 0.07210859f, 0.19103658f, -0.25892553f, 0.22425267f, 0.10789634f, 0.00406009f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.10741048f, 0.09241693f, 0.18699774f, -0.01809107f, -0.07707174f, 0.04746295f, 0.06245171f, -0.02771729f, 
    -0.10937933f, 0.01611662f, 0.01894958f, 0.00642908f, 0.15617870f, 0.00543053f, -0.08626456f, 0.12808345f, 
    0.04482415f, 0.10934983f, 0.12224558f, -0.08929247f, 0.08595058f, 0.00788850f, -0.04906904f, 0.14346708f, 
    -0.06221696f, 0.08068876f, -0.03290629f, -0.10612769f, 0.17046678f, -0.20026764f, -0.06717449f, 0.04958631f, 
    0.13060538f, -0.03471212f, -0.09846117f, 0.05443658f, 0.08535833f, 0.04540587f, 0.14336722f, 0.09215488f, 
    0.07645725f, 0.04482829f, 0.11181567f, 0.06230906f, 0.10581943f, -0.01374807f, -0.02520406f, 0.01586659f, 
    -0.03578024f, -0.06794500f, 0.16563702f, 0.10382250f, -0.01883746f, 0.05713608f, 0.09569027f, -0.05976393f, 
    0.15448594f, -0.12952948f, 0.00246511f, 0.07142524f, 0.10459267f, 0.09372116f, 0.17337759f, -0.03700799f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.50421631f, 0.23833598f, -0.52682364f, 0.11160807f, -0.00034285f, -0.05602004f, 0.41497803f, -0.12798859f, 
    -0.50415665f, 0.32301477f, -0.62178457f, -0.12191746f, 0.31079724f, -0.13327505f, -0.03359056f, 0.05326758f, 
    -0.18843113f, -0.28454456f, 0.14470467f, -0.01403728f, -0.03946120f, 0.09898731f, 0.02553164f, -0.05241625f, 
    -0.36004063f, 0.21915396f, -0.04100617f, -0.03882579f, 0.05329205f, 0.10900687f, -0.07083084f, -0.08667084f, 
    -0.21288399f, -0.46972683f, 0.04318030f, 0.01586926f, -0.47464469f, -0.29271904f, -0.27988380f, -0.03504196f, 
    0.16366145f, 0.07406518f, 0.05738708f, -0.09495334f, -0.48775035f, 0.04026257f, 0.10440912f, -0.18919124f, 
    0.16664210f, 0.28693783f, 0.14678903f, -0.17535926f, 0.09531742f, -0.07798801f, 0.11402437f, -0.00140504f, 
    -0.36849532f, -0.09347332f, -0.20790507f, 0.28897026f, 0.20972401f, 0.10014253f, -0.04946546f, 0.04061231f, 
    0.39203423f, 0.29022294f, -0.09040073f, -0.03963048f, 0.03007509f, -0.24253346f, -0.20404635f, -0.03563488f, 
    0.36048815f, 0.09231050f, 0.40188283f, 0.11174255f, -0.14297445f, -0.08497219f, -0.02241426f, 0.21853349f, 
    -0.13874459f, 0.00561559f, 0.15041994f, -0.09193657f, -0.31149796f, -0.34173861f, 0.01104086f, 0.16089207f, 
    -0.16435425f, -0.41603643f, -0.06494185f, 0.06534201f, 0.05408666f, 0.14655775f, -0.01287643f, 0.07398668f, 
    -0.37290180f, 0.18792142f, 0.10573429f, 0.09846777f, 0.08891337f, -0.00841610f, -0.22310156f, 0.09389736f, 
    0.00180062f, 0.07478871f, -0.11800656f, 0.16128802f, -0.30413583f, -0.07170463f, -0.03939518f, -0.06328765f, 
    0.16643147f, -0.23047961f, 0.04415895f, -0.24491996f, -0.22707835f, 0.08148387f, -0.26107770f, 0.25437528f, 
    -0.29595149f, 0.02752633f, 0.25727209f, -0.10096627f, 0.33672029f, 0.12318769f, 0.19377826f, 0.18462482f, 
    -0.39074287f, -0.28869972f, 0.16343772f, -0.02731036f, 0.04528487f, 0.14380167f, -0.08731023f, 0.17047064f, 
    -0.16586640f, -0.54803932f, -0.26099378f, 0.02404604f, -0.04356362f, 0.18418637f, 0.03267193f, -0.06294418f, 
    0.00699905f, 0.23340097f, -0.07425527f, 0.00465833f, 0.27871913f, 0.25497437f, 0.00814806f, -0.42744648f, 
    -0.28710493f, -0.02921280f, 0.03459438f, -0.12829804f, -0.07186463f, 0.17637677f, -0.01640182f, 0.07769226f, 
    0.26382118f, -0.38649857f, -0.02161554f, -0.51225036f, -0.17968786f, -0.11839128f, -0.29731229f, -0.05720520f, 
    -0.10588356f, -0.08379547f, 0.04636177f, -0.33406806f, -0.26271003f, 0.06111570f, 0.17552705f, -0.47217643f, 
    0.07181710f, 0.05004579f, 0.07532863f, 0.01123275f, -0.09843008f, -0.05593488f, 0.15119135f, 0.21416874f, 
    -0.00656391f, 0.00368490f, 0.23160258f, -0.41643155f, 0.13406697f, 0.20675245f, -0.23669794f, 0.15180852f, 
    -0.03262414f, -0.32989281f, -0.08455759f, -0.04575751f, -0.02914281f, -0.38100806f, 0.17498979f, 0.10525039f, 
    -0.03238510f, 0.14581849f, -0.21212214f, -0.07387599f, 0.17393556f, -0.49972844f, -0.07437914f, 0.27622429f, 
    -0.05417601f, 0.05507852f, -0.31186810f, 0.05114040f, -0.14152627f, -0.11686904f, 0.12259024f, -0.24393442f, 
    -0.10745231f, 0.24245250f, 0.27323401f, -0.03885306f, 0.21201092f, -0.14175482f, -0.02842393f, -0.07292325f, 
    -0.18252425f, 0.21293294f, -0.06647886f, -0.26541215f, -0.00948584f, -0.00054092f, 0.16147965f, -0.07102149f, 
    -0.09996738f, 0.03668594f, 0.05528028f, -0.03959794f, 0.03128995f, -0.00948436f, -0.16960941f, 0.20697919f, 
    0.03506807f, 0.06164160f, -0.53150159f, 0.21569906f, -0.00001915f, -0.00797204f, -0.13935193f, -0.16043979f, 
    -0.00703099f, 0.00207681f, -0.34847766f, 0.06519804f, -0.50789797f, 0.18790269f, -0.19927393f, -0.38022658f, 
    0.10212944f, -0.27563071f, 0.10301667f, -0.07250308f, 0.07763546f, 0.03997088f, -0.06076028f, -0.06865434f, 
    -0.36578697f, 0.01879833f, -0.59304863f, 0.09290987f, -0.47242916f, -0.13346775f, 0.06218718f, 0.01721413f, 
    0.28872031f, -0.15258403f, 0.19308446f, -0.09207141f, 0.08861512f, -0.12976120f, -0.07379847f, -0.21574906f, 
    -0.03225353f, 0.17218690f, 0.15401529f, 0.02699051f, 0.22928807f, -0.05103064f, -0.01661004f, 0.01035378f, 
    -0.07445244f, -0.32021773f, -0.11993074f, 0.08705128f, 0.01260118f, 0.04310991f, 0.07640851f, -0.07494792f, 
    0.16114703f, -0.11810924f, -0.08568397f, 0.17888403f, -0.07211041f, -0.07046115f, -0.27495146f, 0.03521384f, 
    -0.08412062f, 0.20178209f, -0.14481716f, 0.25167486f, -0.08885196f, -0.10177914f, -0.33834961f, -0.06768718f, 
    -0.05445116f, -0.08363619f, -0.36639950f, 0.32169768f, 0.11458943f, -0.49450657f, 0.19105043f, -0.30952099f, 
    -0.69433314f, 0.27055508f, 0.22851735f, 0.05893024f, -0.02134133f, 0.24297704f, -0.01296641f, 0.03394303f, 
    0.14338446f, 0.10693036f, 0.15590975f, 0.06619409f, -0.24772325f, 0.14800942f, -0.09608537f, -0.08950049f, 
    -0.16921040f, -0.16782305f, 0.17754835f, -0.00152648f, -0.29180124f, 0.10678330f, 0.11346970f, 0.21705259f, 
    -0.06107674f, -0.08127370f, 0.14311075f, -0.10319109f, -0.06181625f, -0.30614093f, -0.04652027f, -0.02460051f, 
    -0.30354244f, 0.05801203f, -0.06284323f, -0.01644229f, -0.13621038f, 0.04985615f, 0.26985767f, 0.05962976f, 
    0.16091152f, 0.07377650f, 0.00202831f, 0.02146622f, 0.11960097f, 0.10562417f, 0.16383959f, 0.23931311f, 
    -0.18348204f, -0.48915923f, 0.10347737f, -0.03927153f, -0.25259846f, 0.11578576f, 0.05796954f, 0.13729757f, 
    -0.00834497f, -0.02114773f, -0.15839556f, -0.06800046f, -0.37165794f, -0.39826727f, 0.12801972f, 0.13116014f, 
    -0.34193245f, 0.21416868f, -0.40790981f, 0.08956970f, -0.10107916f, -0.06521872f, -0.37612322f, -0.14146942f, 
    -0.02171352f, -0.61753064f, -0.25628132f, -0.13784772f, -0.04271081f, -0.08698137f, 0.07702503f, -0.20320877f, 
    0.08878847f, 0.06921946f, 0.09546132f, -0.05448657f, 0.08119876f, 0.05790583f, 0.01757380f, 0.07275878f, 
    -0.20331848f, -0.10353200f, -0.21454497f, -0.00017158f, 0.25165752f, -0.54557496f, 0.11411073f, -0.06679174f, 
    0.14737691f, 0.03060871f, 0.03679100f, -0.37443992f, 0.13486712f, 0.26534134f, -0.34122899f, 0.00193111f, 
    0.03576896f, 0.09302492f, 0.04862405f, -0.63072950f, 0.25926551f, -0.04932203f, 0.24826469f, 0.23018366f, 
    -0.05020851f, -0.37029290f, 0.08364314f, 0.00067761f, -0.11891959f, -0.01210164f, 0.19318475f, -0.18066259f, 
    0.43528166f, -0.12595193f, 0.16406384f, -0.10451268f, 0.13367938f, 0.22457811f, -0.22287707f, -0.09057747f, 
    0.09000195f, -0.25056109f, -0.19707146f, 0.00976219f, -0.04260137f, 0.31909016f, 0.09477949f, -0.31227985f, 
    0.27847570f, 0.11573171f, 0.01692211f, -0.12167323f, -0.18612698f, 0.00790280f, -0.09585501f, -0.40256393f, 
    -0.03623411f, -0.11880235f, -0.35210469f, -0.11890371f, 0.25639462f, 0.30074599f, -0.00176087f, -0.11280825f, 
    0.14582580f, -0.11314485f, -0.40043584f, 0.01359278f, -0.13422410f, 0.28148890f, 0.07434594f, 0.08973222f, 
    -0.08413631f, 0.16315170f, 0.08474165f, 0.01118755f, -0.28435275f, 0.10395256f, -0.17617732f, 0.03153946f, 
    0.05322910f, -0.06670655f, 0.00833281f, 0.24137440f, 0.09933232f, -0.00601235f, 0.34429118f, 0.01804062f, 
    -0.35009357f, -0.05642107f, -0.35844123f, 0.03882305f, 0.11779253f, 0.07714847f, -0.38338920f, -0.15837060f, 
    -0.00853984f, -0.03168059f, -0.02451100f, 0.12310635f, 0.03067710f, -0.26239133f, -0.12509593f, 0.13128090f, 
    -0.24004136f, -0.39160800f, 0.27280334f, 0.09642442f, -0.08201864f, -0.31182539f, -0.52692938f, 0.23536523f, 
    0.18788759f, -0.21967831f, -0.13538919f, -0.12850247f, -0.15831798f, 0.21821605f, 0.04448494f, -0.03138261f, 
    0.23330088f, 0.11375983f, 0.16472828f, -0.04945962f, -0.22193328f, -0.33384097f, -0.01543287f, 0.29251966f, 
    0.21573640f, -0.38108224f, 0.04476530f, 0.01502294f, -0.45693666f, 0.24300838f, -0.10895216f, 0.04373781f, 
    -0.04711552f, -0.18122533f, 0.05052310f, -0.09907639f, 0.12277599f, -0.33245343f, -0.23977356f, -0.01675702f, 
    -0.43063104f, 0.07275395f, -0.07216801f, -0.21655059f, 0.23604502f, -0.03432375f, 0.23767309f, -0.23998493f, 
    0.03073833f, -0.01910713f, -0.07420877f, -0.52980542f, -0.06028079f, 0.09655302f, 0.09614239f, 0.10352207f, 
    -0.15005443f, 0.02482767f, -0.29762810f, 0.20789415f, -0.07046474f, -0.36528125f, 0.32673946f, 0.26399735f, 
    -0.13820872f, -0.11201342f, -0.39614064f, 0.06582703f, 0.08915456f, 0.27751899f, -0.17670958f, -0.11837897f, 
    -0.05065132f, -0.20863518f, 0.09050497f, -0.11040042f, -0.07973210f, 0.16133021f, 0.11961009f, -0.44481885f, 
    0.24329819f, 0.03357485f, 0.03006462f, 0.09616677f, 0.11455247f, -0.00645623f, -0.04285761f, -0.07681096f, 
    -0.37013340f, -0.13306971f, -0.29400089f, -0.10286301f, 0.11636341f, -0.25229099f, -0.09048936f, -0.02314671f, 
    0.37656599f, -0.31719804f, 0.07680643f, 0.32755530f, -0.15961698f, -0.05665456f, 0.10217182f, -0.04747095f, 
    0.18143892f, -0.07603525f, 0.07744043f, 0.29189280f, 0.15020362f, -0.03012171f, -0.20522694f, -0.39604309f, 
    0.06541438f, 0.28191057f, 0.24545023f, -0.00626977f, -0.25441748f, -0.08301681f, 0.24903874f, -0.02208161f, 
    -0.04083692f, -0.09344845f, 0.01861765f, 0.13049267f, -0.23663218f, 0.05528201f, -0.22817276f, -0.30310446f, 
    0.04739036f, -0.30480462f, 0.24747679f, 0.01345542f, 0.10900143f, -0.08608384f, 0.01999601f, -0.09774525f, 
    -0.33686617f, -0.01836112f, 0.10611260f, 0.11316716f, 0.18085553f, -0.25793144f, 0.08951772f, 0.08754132f, 
    -0.32611910f, -0.04521081f, -0.08806600f, -0.01688062f, -0.27532822f, 0.14875625f, 0.09950401f, 0.15585436f, 
    -0.05910288f, -0.13499655f, 0.17054603f, 0.04979510f, -0.42256868f, -0.12155642f, 0.04115207f, -0.09311830f, 
    0.30544481f, 0.14032516f, -0.03628924f, 0.29512301f, -0.00013004f, 0.04633927f, 0.20943925f, -0.01036488f, 
    -0.48921883f, 0.01049731f, -0.02253717f, 0.03017441f, 0.18170774f, -0.11381977f, 0.02606113f, 0.13752060f, 
    -0.07259724f, -0.24318394f, 0.01213444f, -0.06477007f, 0.15744632f, -0.05854301f, 0.10724630f, -0.20322685f, 
    -0.35659650f, 0.07828283f, 0.15152563f, -0.32968223f, 0.00650546f, 0.29262137f, -0.37986904f, 0.21812239f, 
    -0.05053492f, -0.28908136f, -0.01298969f, 0.10300034f, -0.08572559f, -0.03973788f, -0.16024828f, 0.11832149f, 
    0.06942051f, 0.25106069f, 0.08783019f, 0.11718660f, 0.09457901f, 0.07283816f, -0.02771054f, -0.20359020f, 
    -0.28919387f, 0.29020244f, 0.05006143f, 0.05293054f, 0.17775898f, -0.08840211f, -0.04856580f, 0.08471212f, 
    0.37473270f, 0.09776422f, -0.42585862f, 0.03757330f, 0.06146036f, -0.36872905f, -0.01120798f, 0.07976358f, 
    -0.28774130f, -0.17311859f, 0.12365542f, 0.27804160f, 0.16298816f, 0.13275181f, -0.25929707f, 0.08946250f, 
    -0.18014497f, 0.04115046f, -0.00096332f, -0.02233775f, 0.11598926f, -0.11443118f, -0.35321257f, -0.11527306f, 
    -0.01749634f, 0.05167824f, -0.18904153f, 0.00302744f, 0.10112517f, 0.02244720f, 0.30060172f, 0.07746765f, 
    0.30843598f, -0.06275222f, 0.07288729f, -0.37273780f, -0.42003855f, -0.08247025f, 0.13497245f, 0.18638639f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.03246303f, -0.05326394f, -0.08326355f, 0.12817730f, 0.16858551f, 0.12450999f, 0.05579819f, -0.20596579f, 
    -0.07985140f, -0.08092552f, 0.11152074f, -0.02379240f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
