#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.60698438f, 0.34796402f, -0.07433420f, -0.29721594f, 0.04100418f, 0.25113043f, 0.30718783f, 0.24983996f, 
    -0.06400138f, -0.26430908f, -0.24770302f, 0.73182786f, -0.09746071f, -0.49014011f, 0.24983449f, -0.07316816f, 
    -0.23676355f, -0.27152348f, -0.15440528f, 0.27580214f, -0.03226922f, 0.29990858f, 0.23038672f, -0.25164685f, 
    -0.05079853f, -0.83151269f, -0.23767212f, -0.52067119f, -0.77372348f, -0.60000277f, 0.28337303f, 0.04867691f, 
    0.46958280f, 0.08358347f, 0.20128427f, 0.14246325f, -0.51725131f, -0.44076595f, -0.46303031f, -0.04855495f, 
    0.41024032f, 0.18943705f, 0.08276638f, 0.33655989f, 0.05443513f, -0.22553508f, 0.00744700f, 0.07595525f, 
    -0.34175441f, -0.20348364f, 0.35785845f, -0.15165453f, -0.28317654f, 0.15197772f, 0.09911761f, 0.29304743f, 
    0.22205488f, 0.26407292f, 0.14656986f, -0.29525897f, 0.11944386f, 0.37852737f, -0.13253443f, -0.32679054f, 
    0.08338053f, 0.12371430f, -0.17517982f, 0.16488935f, -0.26428720f, 0.07959818f, 0.23586726f, -0.03108758f, 
    -0.12511371f, 0.04798563f, -0.02344687f, -1.15877104f, 0.11650962f, -0.58435357f, -0.73096818f, -0.38301575f, 
    0.53598493f, 0.55210370f, 0.43146050f, 0.14809926f, 0.43805644f, 0.10131565f, -0.12214611f, -0.10498223f, 
    -0.25747240f, 0.11998283f, -0.01655561f, -0.20338748f, 0.26519939f, 0.08701737f, -0.34172401f, -0.07712339f, 
    0.22740521f, 0.14219576f, -0.05058432f, 0.31954059f, -0.51647979f, -0.50066084f, -0.36529419f, -0.29303601f, 
    0.36341467f, -0.34982130f, -0.54579425f, -0.62783051f, -0.42929301f, 0.18384151f, -0.13416252f, -0.30639994f, 
    -0.03133845f, -0.00076625f, -0.39380243f, 0.05675068f, -0.14246529f, -0.24094497f, -0.20151904f, -0.15455431f, 
    -0.23991950f, -0.03437195f, -0.19601528f, 0.04175754f, -0.19186194f, 0.26620099f, -0.87295449f, -0.28112713f, 
    0.24055633f, -0.42904127f, 0.16123417f, 0.28498024f, 0.25188443f, 0.17920043f, 0.17162095f, -0.19712378f, 
    -0.22292261f, 0.23297013f, 0.20755117f, 0.31113291f, 0.06125386f, -0.27294415f, -0.09885775f, -0.02507337f, 
    -0.36332268f, -0.18966594f, 0.10815378f, 0.10913841f, 0.06755720f, 0.01816352f, -0.28053129f, -0.51878828f, 
    -0.69391191f, -0.35234249f, -0.18527585f, 0.05562852f, 0.15476441f, 0.27561229f, -0.12785867f, -0.15333585f, 
    -0.49297386f, -0.32329470f, -0.44070315f, 0.22239570f, 0.09661002f, 0.01472048f, -0.25822133f, 0.00182643f, 
    -0.40327287f, 0.08060526f, -0.18419655f, 0.15581521f, -0.00661842f, -0.32693669f, -0.61251658f, -0.17307273f, 
    0.02805989f, -0.02103908f, 0.29629603f, 0.25684756f, 0.46071261f, 0.17924605f, -0.03936950f, 0.00951488f, 
    0.19227658f, -0.21805263f, -0.06400283f, 0.36070004f, -0.29042733f, -0.08022865f, -0.15501480f, -0.17244208f, 
    -0.23760313f, -0.02332892f, -0.23286296f, 0.04286869f, 0.09058139f, 0.30559814f, 0.10865811f, 0.16639550f, 
    -0.59630603f, -0.36452058f, 0.17113343f, 0.38458392f, 0.51873928f, 0.13343582f, 0.30370986f, -0.08213720f, 
    0.53091037f, -0.00848353f, 0.11240694f, 0.09995534f, 0.12197252f, -0.24813332f, -0.09506817f, -0.12560019f, 
    -0.26371622f, -0.05459302f, 0.21201456f, -0.17851934f, -0.15386590f, -0.09781386f, -0.23138797f, -0.17878976f, 
    0.01748426f, -0.67136908f, 0.57690454f, 0.17727357f, 0.05910732f, 0.18685210f, -0.50552011f, -0.08549105f, 
    0.15751553f, 0.14309706f, 0.14913434f, 0.15416181f, -0.04858673f, -0.10389338f, -0.36835402f, 0.20786476f, 
    0.17415236f, -0.12364842f, -0.22295146f, 0.06828689f, 0.08105012f, -0.16520056f, 0.25619495f, 0.07796515f, 
    -0.02394323f, -0.22068056f, 0.28410995f, -0.13792843f, -0.40233976f, -0.04824371f, -0.46605372f, -0.66010952f, 
    -0.38503203f, -0.40417528f, -0.19453926f, -0.59034604f, 0.37398085f, 0.16099571f, 0.04965059f, -0.17415379f, 
    0.00155595f, 0.10586988f, -0.15728222f, -0.01573160f, -0.23459503f, -0.07393578f, -0.27645153f, 0.16590333f, 
    -0.15812291f, -0.03428119f, -0.14031506f, 0.47415698f, 0.31237817f, -0.34677806f, -0.08889895f, -0.03257933f, 
    -0.19651584f, -0.27564219f, 0.50676787f, 0.22254783f, -0.47451288f, 0.29818380f, -0.14649999f, -0.14915961f, 
    -0.31330037f, 0.28513396f, 0.01801319f, 0.37547880f, -0.19678555f, -0.06667607f, -0.16720173f, -0.04768037f, 
    0.02103372f, 0.09305715f, -0.05228023f, -0.11509468f, 0.30773222f, 0.29563999f, 0.01931551f, 0.38715947f, 
    0.31543094f, -0.14755689f, -0.40960675f, -0.34335613f, 0.10388674f, 0.36767325f, 0.02986367f, 0.20712158f, 
    -0.03840016f, -0.24152844f, -0.34303039f, 0.01288450f, -0.00939274f, 0.07309762f, 0.01373606f, -0.15767527f, 
    0.07991616f, -0.19830114f, -0.15077862f, -0.05992518f, 0.22918016f, 0.29096046f, -0.19295774f, 0.04602021f, 
    0.13801895f, -0.02218935f, 0.26831996f, 0.23396204f, -0.21750411f, 0.16218169f, 0.30242258f, -0.05334798f, 
    0.47611222f, -0.22673547f, -0.27534762f, -0.15544000f, -0.31925371f, 0.12465321f, -0.02454644f, -0.03617262f, 
    -0.06648809f, 0.28406960f, 0.16957511f, -0.46488664f, -0.07097842f, 0.06510759f, 0.88164240f, 0.58475548f, 
    0.29177991f, -0.63774633f, -0.66737729f, 0.30172557f, 0.18269916f, 0.16282488f, -0.51278186f, -0.18912093f, 
    -0.06119105f, -0.14760503f, 0.10996745f, -0.01545017f, 0.11394688f, 0.04572468f, -0.13180196f, 0.44371215f, 
    -0.11272390f, -0.26553392f, -0.16297567f, 0.07372922f, -0.30262721f, 0.05197356f, -0.06101270f, -0.87754738f, 
    -0.97905475f, -0.04290644f, 0.60814923f, 0.73228049f, 0.67231888f, 0.26244402f, -0.22110105f, -0.05249657f, 
    -0.22060788f, 0.02081334f, -0.19765632f, -0.22557747f, 0.42166996f, -0.23669106f, -0.32853565f, 0.56718910f, 
    0.31144774f, -0.22846997f, -0.23452747f, -0.14516626f, 0.11079863f, -0.03507913f, -0.07532983f, 0.13462451f, 
    0.24524458f, 0.25478834f, 0.34344763f, 0.28259504f, 0.24713509f, 0.05457017f, 0.16447663f, -0.12856531f, 
    -0.25859690f, -0.05492213f, 0.16683394f, -0.24631634f, -0.02633770f, -0.06634314f, 0.30315685f, 0.09871536f, 
    -0.19010720f, -0.10565499f, 0.12289392f, -0.10885502f, 0.17911735f, 0.17317900f, -0.07010184f, -0.14665869f, 
    -0.16081069f, -0.05787164f, 0.23400044f, 0.26418495f, -0.73962212f, -0.68053794f, 0.13411434f, -0.40322793f, 
    -0.11476765f, -0.10983176f, -0.00045821f, 0.35310596f, 0.60856664f, -0.35465273f, 0.04992617f, -0.13804322f, 
    -0.40553132f, -0.06459118f, -0.18087381f, -0.47282508f, -0.26360068f, 0.21641974f, 0.23311630f, -0.00311535f, 
    0.38060424f, 0.04232625f, -0.46398073f, -0.36998817f, -0.67532015f, -0.37619111f, -0.54159081f, 0.36017096f, 
    0.08108916f, 0.47677100f, 0.34955630f, 0.06209027f, 0.34630117f, 0.46573085f, 0.22185197f, 0.16571061f, 
    -0.08680470f, -0.24816360f, 0.07800961f, -0.17594470f, -0.11990209f, -0.16435881f, -0.11364032f, -0.04328080f, 
    0.22171897f, 0.15586750f, -0.21053407f, 0.50258237f, 0.12873757f, -0.14070919f, 0.44449928f, -0.35585460f, 
    0.03079829f, 0.33245155f, -0.38610524f, -0.40165138f, -0.16562559f, 0.29097569f, -0.24801983f, 0.16762178f, 
    0.07879118f, 0.09903977f, -0.26102984f, -0.01821833f, 0.12827232f, -0.02320262f, 0.10757329f, 0.13825078f, 
    0.26804557f, 0.18516663f, 0.13955684f, -0.36883426f, -0.10105672f, -0.23593070f, -0.08005283f, 0.81074524f, 
    -0.05236547f, 0.54651231f, -0.16375323f, -0.53816557f, -0.63217115f, -0.35839495f, 0.19707990f, 0.45593074f, 
    0.03975537f, -0.26582384f, -0.30887422f, 0.04667117f, 0.32082409f, 0.35022601f, -0.12135433f, -0.15251669f, 
    -0.50916004f, 0.19024587f, -0.06711631f, -0.06667369f, -0.07238536f, -0.48354295f, -0.17474294f, -0.68173814f, 
    -0.32595539f, -0.07914798f, -0.15184334f, 0.36350676f, -0.36601040f, -0.49256170f, 0.49351701f, 0.17267792f, 
    0.32931882f, 0.25530639f, 0.35967550f, 0.02736078f, 0.03180386f, -0.29457062f, 0.13654524f, -0.25171739f, 
    -0.33912790f, -0.01371413f, 0.21523266f, 0.00083312f, 0.20380066f, -0.02783609f, 0.36282364f, 0.07102589f, 
    0.05861474f, -0.14713590f, -0.11199361f, -0.17445749f, -0.30092517f, -0.55617851f, -0.29420200f, -0.58645326f, 
    0.29853690f, -0.17437857f, 0.11581887f, 0.25461090f, 0.47541517f, 0.07041565f, 0.30452549f, 0.07031199f, 
    -0.03940029f, -0.14395282f, -0.31869036f, -0.00352511f, -0.20712969f, -0.19482262f, 0.07287425f, 1.00752223f, 
    0.01501576f, 0.10434519f, 0.06317364f, -0.58271080f, 0.09395992f, 0.13089092f, -0.45047677f, -0.24016821f, 
    -0.39586130f, -0.01404895f, -0.24914075f, -0.33802423f, 0.18002269f, 0.37803337f, -0.10295564f, 0.11525436f, 
    0.12530078f, -0.28260630f, 0.27710399f, -0.01944961f, -0.21997002f, 0.14682710f, 0.24820448f, 0.06463192f, 
    0.55786073f, 0.16535811f, -0.28789240f, -0.58009624f, -0.54874277f, 0.05893022f, 0.27284202f, 0.48722723f, 
    -0.22812586f, -0.14219438f, -0.65565926f, -0.16413802f, -0.04419530f, -0.24648920f, 0.04332511f, 0.31990811f, 
    -0.25157535f, -0.26263258f, -0.18473783f, -0.08317529f, -0.03288126f, -0.32048839f, -0.23503351f, -0.43749279f, 
    -0.29441747f, -0.40791801f, -0.35509700f, 0.48005655f, 0.33117136f, -0.13871288f, -0.60873461f, -0.42173943f, 
    -0.25104117f, 0.02032950f, 0.30948415f, 0.08429683f, -0.37667316f, -0.30506012f, 0.64802700f, -0.33519697f, 
    0.04974166f, -0.19290657f, 0.14970081f, -0.16352305f, -0.57894969f, -0.00781336f, 0.37457895f, -0.14484413f, 
    -0.07603437f, 0.17773823f, 0.45918220f, 0.58451146f, 0.01829978f, -0.09986924f, -0.51449376f, -0.58406639f, 
    -0.24755101f, 0.02581788f, 0.23563187f, 0.29407653f, 0.14009652f, 0.18133941f, -0.21049224f, 0.05757058f, 
    0.10857386f, -0.12948576f, 0.19626495f, -0.12005801f, -0.19616255f, -0.03493005f, -0.08133221f, 0.01809089f, 
    -0.11293375f, -0.16506326f, 0.14900248f, 0.05729247f, 0.71852303f, 0.03980848f, -0.04391878f, -0.28653997f, 
    -0.07940458f, -0.00900990f, 0.21270707f, -0.06923933f, -0.50990885f, 0.22173294f, -0.20873517f, 0.21148612f, 
    -0.42302144f, -0.09928910f, -0.08465444f, 0.08447338f, 0.15471333f, -0.10009807f, -0.22136842f, -0.25293183f, 
    -0.19538273f, -0.26964995f, -0.17896357f, -0.61805201f, 0.49796790f, 0.09227086f, -0.35950795f, -0.43759882f, 
    0.03033280f, 0.15600686f, -0.08591314f, -0.25563666f, 0.08118661f, 0.17447121f, 0.18708913f, -0.20818540f, 
    -0.00952960f, 0.18186414f, 0.05306555f, -0.30951235f, -0.08569730f, 0.12398067f, -0.07718008f, 0.26596865f, 
    0.21412443f, 0.09379867f, -0.41471440f, 0.11930550f, 0.37447801f, 0.07945990f, 0.20908591f, -0.40031686f, 
    -0.29268801f, -0.40404323f, 0.31641775f, -0.31075260f, 0.09604101f, 0.16644418f, 0.30749074f, -0.27178371f, 
    0.25646794f, -0.02929255f, 0.08442669f, -0.27970666f, -0.29029542f, -0.32053542f, 0.14303362f, 0.07375394f, 
    -0.25773761f, -0.10681678f, 0.38180169f, 0.26329371f, 0.18350124f, 0.26856092f, 0.07090954f, -0.41177768f, 
    -0.03860887f, 0.48321295f, 0.62096411f, -0.19264087f, 0.59419143f, 0.03757725f, -0.61447227f, -0.51704186f, 
    0.01288093f, 0.05318136f, 0.19311512f, -0.20362879f, -0.08271701f, -0.31796446f, -0.16990514f, 0.38284263f, 
    0.08567153f, -0.19836392f, 0.08810437f, -0.16115385f, -0.08553921f, 0.08772278f, 0.11348496f, -0.11997513f, 
    -0.71723473f, -0.62705749f, -0.50977844f, -0.60838902f, 0.18624732f, -0.22685622f, 0.39008704f, 0.64334959f, 
    0.47749504f, -0.19841810f, 0.05921689f, 0.13997786f, 0.23803554f, -0.05462996f, 0.28680885f, -0.20805728f, 
    -0.08738318f, 0.09477849f, 0.11193106f, -0.17378680f, -0.21063200f, -0.22592689f, -0.19455652f, -0.13564710f, 
    0.55283856f, 0.15786396f, -0.27769607f, -0.50203484f, -0.63940990f, 0.21677148f, 0.06345541f, 0.05460368f, 
    -0.13996525f, 0.31856626f, -0.05648537f, 0.02562826f, 0.09735924f, 0.06043301f, 0.16451466f, -0.01604510f, 
    -0.07187673f, 0.24227881f, -0.14361234f, -0.13980567f, 0.20192656f, -0.18596113f, -0.09908658f, -0.11533884f, 
    0.02646061f, -0.15179251f, -0.57952791f, -0.19180702f, 0.37926280f, 0.45595244f, -0.34359562f, -0.31078586f, 
    -0.06945591f, -0.36829916f, -0.16485223f, 0.06898510f, -0.32699361f, 0.18538982f, 0.00395007f, -0.22685763f, 
    -0.09974919f, 0.18032899f, 0.26366678f, 0.20847811f, 0.13383491f, -0.31651706f, -0.05723158f, 0.17871483f, 
    -0.05889522f, -0.18250357f, -0.24573873f, -0.75667304f, -0.46098664f, -0.30686456f, -0.56745881f, 0.24182788f, 
    0.35741001f, 0.09440131f, -0.24092214f, -0.32773438f, 0.18955600f, -0.13758934f, -0.08289308f, 0.49565414f, 
    -0.10022918f, -0.16272753f, -0.16345736f, -0.34211016f, -0.38507339f, -0.21638115f, -0.22178026f, -0.04885994f, 
    0.09942296f, 0.16383660f, -0.23312333f, -1.14874065f, -0.57836306f, -0.21867250f, -0.19884276f, 0.36573458f, 
    -0.04148661f, 0.08009396f, 0.20596482f, 0.75953668f, 0.56356341f, -0.27995467f, -0.05024693f, -0.34782842f, 
    0.06973989f, 0.22348672f, 0.10655604f, -0.14230877f, -0.05998390f, -0.21692893f, -0.07114408f, -0.08109739f, 
    0.31934080f, 0.18537766f, 0.04626930f, 0.15493491f, -0.02989964f, -1.01964116f, -0.00474468f, 0.67401612f, 
    0.42845336f, 0.69995731f, 0.83104450f, -0.70939815f, -0.71980530f, -0.10877575f, -0.04261426f, 0.31697422f, 
    -0.30458257f, -0.17743227f, -0.34432167f, 0.18056387f, -0.01860256f, -0.19403955f, -0.07512557f, 0.20773138f, 
    -0.11296008f, -0.02099354f, 0.08235160f, 0.00048047f, -0.44301867f, -0.75349176f, -0.23857458f, -0.73000515f, 
    -0.28933910f, -0.07244346f, 0.06205332f, 0.50043660f, 0.21405661f, -0.13818352f, 0.06177612f, 0.37879685f, 
    0.46803987f, 0.06917498f, -0.01403955f, 0.11219037f, -0.08852259f, 0.10554779f, -0.20739280f, 0.13521594f, 
    -0.21067135f, -0.09845872f, -0.22367656f, 0.06292178f, -0.06625314f, 0.05999169f, 0.35567072f, 0.29169205f, 
    0.36474997f, -0.01605260f, -0.06576668f, -0.69550961f, -0.57986051f, 0.05917895f, -0.12088402f, 0.18050705f, 
    0.10576042f, -0.26385909f, -0.21767211f, 0.08024422f, 0.12487525f, -0.15694207f, 0.05484794f, 0.12919846f, 
    0.10391321f, -0.32510921f, -0.23395762f, -0.04106666f, 0.04558573f, 0.37442961f, -0.29295659f, 0.37829491f, 
    0.25276092f, 0.44961971f, 0.23940361f, -0.67856371f, -0.18021928f, 0.08543471f, -0.03413602f, -0.17498906f, 
    0.07935158f, 0.38251930f, -0.17729358f, -0.29437351f, -0.04055056f, -0.03563689f, 0.21054207f, 0.09884965f, 
    -0.13308431f, -0.08753511f, 0.19785468f, 0.00864111f, -0.13611592f, -0.09598294f, 0.01622857f, 0.00208652f, 
    0.61233270f, -0.20602149f, -0.69285756f, -0.58697504f, -0.62509793f, 0.58641249f, 0.70051277f, 0.60726756f, 
    -0.19198695f, -0.42512360f, -0.28874606f, -0.30193990f, -0.25200546f, 0.41536355f, -0.32738823f, -0.13218217f, 
    -0.00235045f, 0.20154959f, 0.32558319f, 0.12109546f, -0.14165753f, -0.03735191f, 0.21773922f, 0.11285489f, 
    -0.19496317f, -0.05500970f, 0.69449282f, 0.17820221f, -0.62965369f, -0.16714132f, -0.66794646f, -0.20605947f, 
    0.12953992f, 0.42832938f, 0.20212545f, -0.24889362f, -0.04037718f, 0.23285988f, 0.07738294f, -0.13316606f, 
    -0.15623419f, 0.40621859f, -0.00987764f, 0.00895742f, -0.36612853f, -0.14778475f, 0.56262505f, 0.31412560f, 
    -0.35164067f, -0.22481559f, 0.09620763f, 0.11665357f, 0.45525694f, -0.19866379f, -0.29509449f, 0.20844752f, 
    -0.37998921f, -0.13849030f, -0.05236337f, 0.32379368f, -0.08527588f, -0.33877784f, -0.16394687f, 0.39671674f, 
    -0.04851118f, -0.07736298f, -0.29764307f, 0.13249668f, 0.34983325f, 0.32763618f, 0.28555796f, 0.22544603f, 
    -0.18188767f, -0.40797848f, -0.54688227f, -0.31207356f, -0.52776772f, -0.43154630f, -0.14403529f, 0.15247053f, 
    -0.13536118f, -0.24286638f, 0.01964994f, 0.48103172f, -0.62124294f, 0.06194843f, 0.07650204f, -0.16089430f, 
    0.03935342f, 0.14119057f, -0.11039893f, -0.11941209f, 0.22969984f, -0.19813402f, 0.14952104f, 0.01756452f, 
    0.32849395f, 0.05547942f, 0.03696775f, 0.50812209f, 0.36534294f, -0.17727801f, -0.03370434f, 0.14743975f, 
    -0.07651243f, -0.12724105f, 0.12679619f, 0.15774518f, -0.22752926f, -0.25685430f, 0.26048425f, -0.24700660f, 
    0.47637075f, -0.70121199f, 0.23618828f, 0.25757357f, 0.16243400f, 0.23744373f, -0.39673945f, -0.14858450f, 
    0.32701331f, -0.28360081f, -0.10950980f, 0.11584130f, -0.42194867f, -0.84873837f, -0.09250217f, -0.26733765f, 
    -0.40451205f, -0.09225980f, 0.33874199f, -0.52237034f, -0.47937837f, -0.43071812f, -0.05072810f, -0.15224342f, 
    -0.04789780f, -0.15672094f, -0.42167941f, -0.23641130f, -0.11234443f, -0.44277135f, -0.20032090f, -0.13550802f, 
    -0.11295520f, -0.02143056f, 0.06678507f, -0.29226670f, -0.02251399f, -0.08129195f, -0.43897647f, 0.35913929f, 
    -0.00613090f, -0.09856894f, -0.02964451f, -0.38765082f, -0.43752411f, -0.13723432f, -0.19016859f, 0.01263765f, 
    0.27727610f, 0.18496269f, 0.12155232f, 0.27283943f, 0.19091915f, 0.09072419f, -0.11331840f, -0.10674389f, 
    0.09282050f, -0.28143513f, 0.10516740f, 0.38234353f, 0.14990908f, 0.18430170f, 0.30571011f, -0.44848701f, 
    -0.38936216f, -0.41491339f, -0.37979624f, -0.10329583f, -0.20342378f, -0.19152305f, -0.47274700f, -0.75875187f, 
    -0.36866787f, 0.36843860f, -0.22084485f, 0.18814667f, -0.05394009f, -0.10575881f, -0.00053970f, 0.34084561f, 
    -0.09350940f, -0.24153523f, -0.29207024f, -0.20262691f, -0.02239330f, 0.38680717f, 0.22347890f, 0.01943954f, 
    0.03057432f, 0.06809302f, 0.15710320f, -0.14803448f, 0.12991293f, 0.20296289f, -0.11984053f, -0.20298186f, 
    -0.08444764f, -0.31364280f, -0.32514191f, 0.28276432f, -0.02046416f, 0.07534166f, -0.21440813f, -0.06209859f, 
    -0.06105888f, -0.10207798f, 0.25116295f, 0.01043773f, -0.06633756f, 0.05654172f, -0.19616763f, 0.17980443f, 
    0.33122823f, -0.17069474f, 0.38768354f, -0.08361728f, -0.35848635f, 0.31096521f, 0.00247656f, -0.26352623f, 
    0.03286302f, 0.23160596f, 0.06070484f, -0.28574947f, 0.05473649f, 0.24413109f, 0.09404873f, -0.07117437f, 
    -0.19900267f, 0.27045920f, 0.13653211f, -0.06291004f, -0.21366686f, -0.02964162f, 0.14998041f, -0.30439281f, 
    0.24906172f, 0.03576905f, 0.54207337f, 0.78001493f, 0.23062418f, -0.56108689f, -0.11296864f, -0.26699865f, 
    -0.03912083f, 0.41534752f, -0.08269376f, -0.69413841f, -0.32335943f, 0.24715956f, 0.16542988f, -0.20758022f, 
    -0.18290797f, 0.24253592f, -0.21068603f, 0.08645045f, -0.08197385f, 0.11562350f, -0.19524829f, 0.09771744f, 
    -0.42978421f, 0.23087712f, 0.21488479f, -0.09192834f, -1.08784187f, -0.07862391f, 0.61542034f, 0.02581206f, 
    0.70916593f, 0.28509989f, -0.05831087f, -0.69916785f, 0.02447934f, 0.10146233f, -0.32536396f, 0.00942478f, 
    -0.39450571f, 0.11081217f, -0.24993251f, -0.33631119f, 0.01897112f, 0.43897721f, -0.02982084f, 0.19908728f, 
    -0.11628331f, -0.11934783f, -0.01116432f, -0.22783759f, 0.51451880f, -0.11263100f, 0.48485684f, 0.26390782f, 
    -0.54652929f, -0.21073519f, -0.34827051f, -0.12575856f, -0.00206918f, -0.33366102f, 0.29886273f, -0.26035249f, 
    0.07976869f, 0.47683576f, -0.36292908f, -0.33792362f, 0.02678381f, -0.00065412f, 0.28792429f, 0.25014758f, 
    -0.15201463f, -0.26964039f, -0.25621930f, -0.38248757f, -0.06024011f, -0.64263761f, -0.00815093f, 0.43885300f, 
    0.44022271f, -0.48115602f, -0.51461130f, 0.08185445f, 0.04081809f, 0.03766323f, -0.44677570f, -0.29513592f, 
    0.04350907f, 0.27779013f, 0.08003752f, 0.04309547f, 0.38127592f, -0.06014645f, 0.01311225f, -0.22072390f, 
    -0.30788192f, -0.21327072f, -0.21873674f, -0.00983646f, -0.35548496f, -0.58851004f, 0.07183839f, -0.34253627f, 
    0.26010194f, 0.34142548f, -0.04400872f, -0.50224447f, -0.30596620f, 0.39534661f, 0.00047694f, -0.22533110f, 
    0.24320146f, -0.23833030f, 0.00140568f, -0.19882128f, 0.43991590f, -0.03258438f, 0.19137062f, 0.04195368f, 
    -0.29822198f, -0.07480693f, -0.22764358f, -0.15116815f, -0.24262512f, 0.40546179f, 0.40363735f, 0.53407580f, 
    0.11772349f, 0.09149729f, 0.04211499f, -0.56252784f, 0.11289073f, 0.24703054f, 0.15219104f, -0.14585319f, 
    0.20754655f, 0.08910131f, 0.16459653f, 0.05826997f, -0.08824806f, -0.34938949f, -0.12986840f, -0.17569354f, 
    0.02776785f, -0.11130393f, 0.20413998f, -0.16501857f, 0.14511806f, -0.16405225f, 0.08880199f, 0.21164189f, 
    -0.42377499f, -0.41892946f, -0.13967057f, -0.24368988f, -0.47333580f, -0.18155162f, -0.10266864f, 0.07705445f, 
    -0.24967259f, -0.02269303f, 0.35048804f, 0.24940084f, 0.34498972f, -0.25910714f, 0.23935921f, 0.08928216f, 
    -0.06587058f, -0.02761186f, -0.21072218f, -0.16017883f, -0.07349026f, -0.29403898f, -0.31507203f, 0.00128207f, 
    0.19116636f, 1.13536978f, -0.93983531f, -0.04117087f, -0.10586140f, -0.65450960f, -0.00345716f, -0.10804975f, 
    -0.01897600f, 0.36117163f, 0.10038708f, -0.02286288f, 0.20939314f, -0.39277643f, -0.09293058f, 0.31404945f, 
    -0.07136282f, -0.40814573f, -0.19977170f, 0.34491819f, -0.01795602f, -0.20294589f, -0.22611986f, 0.11977030f, 
    0.22436057f, -0.35422528f, -0.67704767f, -0.47770557f, 0.01116524f, -0.05279260f, 0.27524614f, 0.03913019f, 
    -0.41521060f, -0.04120521f, 0.60597932f, -0.60035026f, 0.36513132f, 0.14139147f, 0.06971665f, -0.42044032f, 
    -0.39143655f, -0.19758582f, -0.10739122f, -0.18637027f, -0.48961648f, 0.27392194f, 0.19284284f, 0.15759990f, 
    0.01637681f, -0.09085593f, 0.37849233f, -0.50087976f, -0.38151556f, 0.03816089f, 0.41632932f, 0.60781813f, 
    0.29501230f, -0.34824708f, 0.24621883f, 0.15755673f, 0.50010252f, -0.28083706f, -0.01929549f, 0.16592310f, 
    -0.23931892f, 0.22385761f, -0.11128385f, -0.06125721f, -0.05560469f, -0.07605877f, -0.20329036f, -0.28296867f, 
    0.08039349f, -0.00549578f, 0.03777765f, 0.06402708f, -0.45993161f, 0.45797420f, -0.02407347f, 0.19346863f, 
    -0.12652905f, -0.41354549f, -0.01309403f, 0.26199478f, -0.15333101f, 0.04722492f, -0.03670327f, -0.05310448f, 
    -0.06359573f, 0.15238257f, -0.10660326f, -0.07914574f, 0.06358464f, -0.17176068f, -0.31066391f, 0.02623708f, 
    0.07466158f, -0.02689737f, 0.23368973f, 0.24800824f, 0.24030735f, 0.42882803f, -0.25089496f, -0.16507480f, 
    0.07551999f, 0.32631010f, -0.03194623f, 0.21844047f, -0.07244473f, 0.03142480f, 0.40358195f, -0.05555742f, 
    0.48664340f, -0.40133962f, -0.29648727f, 0.25578365f, -0.03119889f, 0.14520670f, 0.19602489f, -0.24260750f, 
    -0.28940913f, -0.11160183f, 0.08176171f, 0.03563397f, -0.16666993f, 0.08064538f, 0.16968919f, 0.56847984f, 
    0.29091984f, -0.04542442f, -0.66775823f, -0.59421784f, -0.06674284f, -0.25935879f, -0.42075527f, -0.57849908f, 
    0.21091892f, -0.14853078f, -0.26439130f, -0.27672538f, -0.32191065f, 0.14915939f, -0.10966200f, 0.04139176f, 
    -0.29081327f, 0.07394356f, -0.25044087f, -0.04317383f, -0.04849647f, 0.01300840f, -0.01375243f, 0.17797787f, 
    -0.06444068f, -0.20295864f, 0.22773436f, -0.30340084f, -0.22870502f, -0.20189700f, 0.20169047f, -0.01936829f, 
    -0.11116977f, 0.40246552f, -0.20674387f, 0.49675354f, -0.49527937f, 0.34047395f, -0.05609792f, -0.16270676f, 
    -0.16752060f, -0.07575382f, 0.15548751f, 0.14482376f, -0.12365024f, 0.18595348f, 0.10586140f, 0.08540300f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14940773f, -0.43523893f, 0.02739735f, 0.14995651f, -0.17957200f, 0.12703799f, -0.21106082f, -0.11644370f, 
    -0.02660169f, 0.05271118f, 0.00455254f, 0.10247461f, -0.17031768f, 0.10650657f, 0.21413507f, 0.26285619f, 
    -0.13388717f, 0.07159428f, 0.08409628f, -0.06760231f, 0.06993479f, -0.02842035f, -0.32015705f, 0.08947135f, 
    0.06254727f, 0.11331125f, 0.23029888f, -0.02566267f, 0.20850947f, 0.06972128f, 0.00446371f, 0.08501177f, 
    0.08801755f, 0.13223796f, 0.04047300f, -0.03151446f, 0.15886079f, 0.02734852f, 0.12204853f, -0.11334658f, 
    -0.00345989f, 0.26364577f, -0.02139410f, 0.10219773f, 0.12758350f, -0.20892872f, -0.29968408f, -0.28047964f, 
    0.07942479f, 0.22322543f, 0.21177201f, 0.14969051f, -0.05111899f, -0.02040896f, 0.13143092f, 0.14793889f, 
    0.04408209f, 0.13059422f, -0.00999915f, 0.35149169f, 0.07607415f, -0.08542133f, -0.03734777f, -0.04333205f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.09935281f, 0.08614407f, 0.27001569f, -0.10404720f, -0.11295070f, -0.09330460f, 0.04518114f, -0.06202202f, 
    0.04281823f, 0.03386171f, -0.08545168f, 0.10659055f, 0.29830581f, -0.10329986f, 0.11341170f, -0.09175146f, 
    -0.01856465f, -0.05370582f, -0.01018756f, -0.06715572f, 0.00907611f, -0.03800053f, -0.23738572f, -0.05899665f, 
    0.01619416f, 0.01311253f, 0.17721295f, -0.09599771f, -0.09945455f, -0.03739216f, -0.04247634f, 0.01525925f, 
    0.10055993f, 0.09110387f, 0.13490579f, 0.17596331f, 0.44110584f, -0.22236533f, -0.03992760f, 0.04304449f, 
    -0.01982357f, -0.07743927f, 0.08443552f, -0.10521188f, -0.08443117f, 0.06506141f, -0.11184026f, 0.01733858f, 
    -0.07022613f, -0.06240480f, -0.05029488f, 0.05092040f, 0.04736075f, -0.04704735f, 0.10280579f, 0.05280986f, 
    0.00646274f, 0.10544997f, 0.01555253f, -0.06564289f, 0.23340061f, -0.01363108f, 0.11229399f, 0.01009416f, 
    -0.04282296f, 0.00703726f, -0.00578504f, -0.15721808f, -0.04239646f, 0.06029720f, 0.10112078f, 0.04884542f, 
    0.01813822f, 0.09445167f, -0.19521692f, 0.12909554f, 0.20097756f, -0.07731526f, 0.13036075f, 0.14039089f, 
    0.02459338f, 0.03504769f, 0.02118834f, -0.01874311f, 0.03327768f, 0.00173837f, 0.09039909f, 0.04440149f, 
    -0.09903691f, -0.05612059f, -0.03051338f, -0.10903610f, -0.01359375f, 0.02870765f, 0.08810531f, 0.11976614f, 
    0.20378059f, 0.01836671f, 0.03435374f, -0.00408189f, -0.07163477f, -0.05890170f, -0.09208918f, -0.17592660f, 
    0.02139852f, 0.09105242f, -0.06173469f, -0.08669833f, 0.29245338f, -0.14369942f, 0.02855300f, -0.12406866f, 
    -0.03896928f, 0.18161602f, -0.00287655f, -0.13188304f, 0.00931272f, 0.01876580f, -0.02247850f, 0.00465894f, 
    -0.09790299f, -0.05640643f, -0.06885082f, -0.00264262f, 0.16146401f, -0.06074183f, 0.09907998f, 0.16476309f, 
    -0.03886821f, 0.02764400f, -0.05284585f, -0.10242133f, -0.40506041f, -0.02734369f, 0.09242041f, 0.13490950f, 
    0.13475847f, 0.10074322f, 0.17343216f, 0.01818436f, -0.19153623f, 0.10822023f, -0.17381294f, 0.13878189f, 
    0.06857029f, 0.08645338f, 0.12893012f, -0.07101416f, -0.02385826f, -0.06851026f, -0.13673100f, -0.13300748f, 
    -0.05642049f, -0.07767057f, 0.02503818f, -0.09479290f, 0.14685136f, 0.07535692f, 0.29441798f, -0.16039766f, 
    -0.12303547f, -0.02917094f, -0.13171376f, -0.15717432f, -0.04039864f, 0.10559516f, -0.08732816f, 0.01395778f, 
    -0.27528703f, 0.18893787f, 0.18711580f, 0.17037544f, -0.03917411f, -0.10223091f, 0.01756374f, -0.03213239f, 
    -0.01921168f, -0.13743025f, -0.08773597f, 0.04191895f, 0.21182242f, 0.24459116f, -0.20864457f, 0.28936023f, 
    0.02570933f, 0.05605124f, -0.11119052f, 0.19361892f, -0.03390298f, -0.04313342f, 0.02225345f, 0.01654452f, 
    0.08144149f, -0.04318656f, 0.17848989f, -0.20236176f, -0.19973847f, 0.01394531f, -0.07488339f, -0.03035209f, 
    -0.01566997f, -0.02354238f, -0.00258184f, 0.00347546f, -0.25464362f, 0.02156609f, 0.01905409f, -0.00724596f, 
    0.08600000f, 0.07629918f, 0.00974486f, 0.06619538f, 0.03126623f, 0.02625795f, 0.11899418f, 0.07038599f, 
    0.25018230f, -0.13350137f, -0.08686214f, -0.17129685f, -0.02154415f, -0.01507404f, -0.06584334f, -0.06978096f, 
    0.00686073f, 0.03736936f, 0.12072162f, -0.01567275f, -0.03368016f, 0.02143387f, 0.11972663f, -0.21728118f, 
    0.06223001f, 0.07954595f, -0.12271471f, 0.08771367f, -0.01222963f, 0.14883743f, 0.04265960f, 0.08275777f, 
    -0.04508552f, 0.01436625f, 0.03119756f, -0.13779379f, 0.08139593f, 0.19219716f, -0.08168264f, 0.28359702f, 
    0.03979865f, -0.00034372f, -0.03146916f, -0.02669060f, 0.12569229f, -0.32723308f, 0.13843627f, -0.24690804f, 
    -0.05906108f, -0.07402400f, -0.04045547f, -0.11082618f, -0.13123089f, -0.19437630f, 0.05968749f, 0.05075028f, 
    -0.14532782f, -0.08752284f, -0.04685425f, -0.28248036f, 0.07076260f, 0.00005845f, 0.13766620f, 0.04610014f, 
    -0.15330738f, 0.02366466f, -0.15591827f, -0.10589166f, -0.07268131f, 0.15060222f, 0.01638169f, -0.19417331f, 
    -0.00963241f, 0.06929971f, -0.09269961f, 0.09929051f, -0.01733043f, -0.00597336f, 0.00720432f, -0.08161906f, 
    -0.07755901f, 0.00754920f, 0.05538393f, 0.04009783f, 0.13886592f, 0.02354001f, -0.06271480f, 0.10612132f, 
    -0.10491257f, 0.07809719f, -0.06699049f, -0.01925219f, 0.00454683f, 0.12746651f, -0.17742468f, 0.19501281f, 
    -0.05124805f, 0.12347367f, -0.07037608f, 0.23965548f, 0.00747761f, 0.08959061f, 0.10478627f, 0.03389040f, 
    -0.34457964f, 0.27151215f, -0.02647691f, -0.18769100f, -0.03843670f, 0.01259703f, -0.00782209f, -0.02744497f, 
    0.05755284f, -0.08985674f, 0.12289147f, 0.10817353f, -0.16734405f, 0.08831427f, 0.00695257f, 0.09369807f, 
    -0.03338499f, 0.07712288f, 0.01157343f, 0.00676704f, -0.02809294f, 0.05146078f, -0.09123170f, 0.05668766f, 
    -0.11494331f, 0.03108140f, 0.06902909f, -0.12133634f, 0.08082514f, 0.04289010f, 0.23530491f, 0.07897378f, 
    0.07784260f, 0.15763065f, 0.14768547f, 0.04329388f, -0.03995920f, -0.07273007f, 0.11364888f, -0.11577121f, 
    0.05475486f, 0.17410645f, 0.23635976f, -0.02854783f, 0.01202702f, 0.19822213f, 0.16032599f, 0.13970895f, 
    0.09231775f, -0.01397782f, 0.17355923f, -0.10080849f, -0.19521992f, 0.02159055f, 0.06839705f, 0.07459349f, 
    -0.02984008f, 0.02519449f, 0.05773225f, -0.17431776f, 0.11221624f, -0.03400540f, -0.01909651f, -0.17091091f, 
    -0.09538773f, -0.11316375f, -0.06621042f, -0.27020180f, 0.01174067f, -0.00532403f, 0.06937769f, -0.07985388f, 
    -0.29024479f, 0.01530741f, 0.20874394f, -0.17526865f, -0.05595551f, -0.07258035f, 0.01255824f, -0.05454288f, 
    -0.03118107f, 0.07897491f, 0.12748204f, 0.00106895f, -0.16384526f, 0.02877281f, -0.13512412f, -0.11002572f, 
    0.12344272f, -0.09299712f, -0.00065672f, 0.00618327f, -0.02875236f, 0.01234014f, 0.05191674f, 0.00917051f, 
    -0.00332484f, -0.13664436f, -0.19816914f, -0.01899315f, 0.03906666f, 0.08584160f, 0.19721395f, 0.10097776f, 
    0.03547862f, 0.00144037f, 0.05428028f, -0.07257741f, 0.35547444f, 0.25267741f, -0.00395795f, 0.04251806f, 
    -0.02673546f, 0.08817647f, 0.02415125f, -0.06892604f, 0.14473878f, 0.10452148f, 0.02844778f, 0.05650533f, 
    0.20835152f, 0.00456971f, 0.18314911f, -0.25311002f, -0.00624436f, -0.02998400f, -0.15166351f, -0.00067302f, 
    -0.00634843f, 0.02513439f, 0.01907596f, 0.00198712f, 0.38396928f, -0.45654309f, -0.01984006f, -0.10738074f, 
    -0.03240021f, -0.06658110f, -0.10695502f, -0.09714162f, -0.04619369f, 0.01416312f, -0.01336040f, -0.00293653f, 
    -0.12501225f, 0.08099853f, -0.05106637f, 0.04138282f, 0.16661282f, -0.07700774f, -0.03862799f, 0.05285444f, 
    -0.03121847f, -0.17544444f, -0.00739782f, 0.00721565f, -0.09932183f, 0.03699026f, -0.06404389f, -0.11680890f, 
    -0.10776484f, 0.10819991f, -0.01772349f, -0.02339811f, -0.02046181f, -0.05075587f, 0.05864996f, 0.04720582f, 
    0.05766120f, -0.20070216f, 0.00104650f, 0.10070729f, 0.09989071f, -0.03252999f, 0.16557640f, 0.11517751f, 
    0.01866175f, -0.04680450f, -0.15081386f, 0.01576119f, -0.33869591f, 0.34576377f, 0.03943207f, 0.08236227f, 
    0.18786275f, -0.11694027f, 0.05823944f, -0.12058093f, -0.05797426f, 0.05050760f, 0.05443987f, 0.14802006f, 
    -0.00679420f, 0.13551444f, -0.15158111f, -0.24191302f, -0.01626163f, 0.05917928f, -0.01830084f, 0.04475920f, 
    -0.04303543f, -0.01728017f, 0.05185881f, 0.08789477f, -0.15757154f, 0.06407684f, -0.20739952f, 0.04612043f, 
    0.17697772f, -0.12470142f, 0.09379960f, 0.26891336f, -0.03340892f, 0.06919055f, 0.00022951f, 0.09313415f, 
    -0.17652243f, -0.10490028f, -0.08054690f, 0.06813341f, 0.06082900f, 0.20075019f, -0.00730989f, -0.00100192f, 
    -0.00166555f, -0.05141549f, -0.17240600f, -0.00908491f, 0.06006654f, -0.03635241f, -0.00354515f, -0.12936921f, 
    -0.08083779f, 0.10736739f, 0.05790799f, 0.08544649f, 0.03373954f, 0.07461577f, 0.04814342f, -0.03875572f, 
    0.01977133f, 0.00572593f, -0.03313387f, -0.04229481f, 0.16776067f, 0.06462430f, 0.14574383f, -0.00277137f, 
    0.02649507f, 0.15168747f, 0.14946716f, 0.12306499f, -0.11765088f, -0.21431085f, -0.10975032f, -0.06127004f, 
    -0.08202964f, -0.01595875f, -0.04129775f, 0.26993161f, -0.00923486f, 0.03074823f, 0.04018062f, 0.03797397f, 
    -0.01997266f, 0.05380680f, -0.03792948f, -0.11335598f, 0.06133170f, -0.09460231f, 0.12658839f, 0.19711715f, 
    0.07018419f, 0.05876000f, 0.08202331f, -0.04711911f, 0.08197326f, 0.12543310f, 0.01201984f, 0.13430877f, 
    0.04982062f, -0.12168964f, 0.08814378f, -0.29880136f, 0.03301458f, -0.05555872f, 0.10290623f, 0.10788178f, 
    -0.18345684f, 0.30406773f, 0.02559744f, 0.34507853f, -0.01675561f, -0.15879975f, 0.09766255f, -0.04326464f, 
    0.00809498f, -0.13486525f, -0.02871401f, -0.07117635f, 0.23713262f, -0.25146124f, 0.12652208f, -0.10286234f, 
    -0.04876113f, 0.05825555f, -0.21971749f, 0.13040787f, -0.00854418f, -0.25743631f, 0.15487729f, 0.04381416f, 
    -0.16150478f, 0.11204779f, -0.15436375f, -0.23592679f, -0.01045864f, -0.04647206f, 0.10371894f, 0.06476206f, 
    -0.06919431f, -0.03050516f, -0.01818884f, -0.12682192f, 0.07184232f, 0.27482900f, -0.10995766f, 0.12136663f, 
    0.01155339f, -0.04924436f, 0.02841393f, 0.08349551f, 0.01884503f, 0.01047851f, -0.12007415f, -0.03934276f, 
    -0.14330092f, 0.21613850f, -0.15064204f, -0.10151128f, 0.18528286f, -0.07315171f, 0.01885376f, 0.09045891f, 
    0.11621620f, -0.03182335f, -0.03957870f, 0.00132877f, -0.07619030f, 0.08043743f, 0.12675153f, -0.06813174f, 
    -0.04416261f, -0.00761926f, -0.11385970f, -0.03324972f, 0.12318537f, 0.09611063f, 0.08875825f, 0.06746832f, 
    -0.09146105f, -0.30250946f, -0.11606190f, 0.03534028f, 0.06412711f, 0.06398182f, -0.08944562f, 0.09671073f, 
    0.02667777f, -0.06300742f, 0.04027734f, -0.02864958f, -0.07893833f, 0.09161415f, 0.38433459f, -0.28171554f, 
    0.06459294f, 0.00650362f, -0.08154889f, -0.10300121f, -0.04415502f, -0.01347389f, 0.11250325f, -0.00472818f, 
    -0.20973961f, 0.16611741f, -0.18859063f, -0.06787471f, 0.03221883f, -0.14044924f, 0.05623241f, 0.26344275f, 
    -0.10959784f, -0.00610722f, -0.05973760f, 0.16942576f, 0.18939087f, 0.10581043f, 0.02077802f, -0.01566163f, 
    -0.08751346f, -0.01426805f, -0.00841031f, -0.24837373f, 0.03287177f, 0.10328962f, 0.07084436f, -0.03448592f, 
    0.04832474f, 0.10556725f, -0.04964433f, 0.00287452f, 0.08245618f, 0.14731809f, 0.11323988f, -0.11140776f, 
    0.12548189f, 0.06048213f, 0.16686594f, 0.05645251f, -0.00396791f, -0.11402541f, 0.27956241f, -0.20413227f, 
    -0.08506387f, -0.00635812f, -0.06665806f, -0.20544028f, 0.05664545f, 0.05417243f, 0.07054309f, 0.00110089f, 
    -0.11675750f, 0.01751900f, -0.19051020f, 0.00849072f, -0.01928590f, 0.01219724f, -0.01111357f, 0.11649621f, 
    -0.00449378f, -0.00631514f, -0.00436443f, -0.03023857f, -0.04899852f, -0.19671221f, -0.05665365f, 0.00798362f, 
    0.13682859f, 0.09760882f, 0.03412534f, -0.01718622f, 0.08351671f, -0.07980698f, 0.11174078f, 0.10808063f, 
    -0.00956671f, -0.02639677f, -0.01820919f, 0.00531304f, 0.02720585f, -0.00729622f, 0.01902131f, -0.03785568f, 
    0.02499351f, 0.01965609f, 0.02501121f, 0.00665848f, 0.00770290f, -0.03111213f, -0.01501851f, 0.01242762f, 
    -0.03173051f, 0.02495085f, 0.03011390f, 0.01926133f, -0.02021874f, -0.03794546f, 0.03289530f, -0.01656336f, 
    -0.03437442f, 0.02326841f, -0.01916316f, -0.03701476f, -0.01609239f, -0.01704140f, -0.04052396f, -0.03735977f, 
    -0.02132730f, -0.03659191f, 0.00758773f, 0.02845393f, -0.02718367f, 0.02104434f, 0.02302554f, 0.00874865f, 
    -0.00342443f, 0.00183843f, -0.04342950f, 0.02845665f, -0.02055065f, -0.03176886f, 0.01490168f, 0.01628579f, 
    -0.02112708f, -0.02256870f, 0.00667540f, 0.00679200f, -0.03652395f, -0.03612275f, 0.01085567f, 0.02219125f, 
    0.02299706f, 0.00021364f, -0.03765094f, 0.00925721f, -0.00940702f, -0.01490051f, -0.01106684f, 0.02376990f, 
    -0.02038826f, 0.00962165f, -0.01419296f, -0.02473171f, 0.02553057f, -0.04338824f, -0.02656289f, -0.01739324f, 
    -0.00914549f, 0.02673522f, 0.00973168f, -0.02470346f, 0.00767971f, -0.03431092f, -0.01400408f, -0.01880638f, 
    0.00576102f, 0.00497786f, 0.00919587f, -0.00516387f, 0.01246288f, -0.01710087f, 0.00787414f, 0.01819285f, 
    -0.01940992f, -0.00158654f, -0.03325030f, 0.00724704f, -0.02788374f, 0.00185969f, 0.01145411f, 0.01039654f, 
    0.01756323f, -0.01598370f, -0.03458800f, 0.01415190f, 0.00344213f, 0.00276110f, 0.01856383f, -0.02896661f, 
    -0.02563285f, 0.02478397f, 0.00255523f, -0.00803842f, 0.00783475f, -0.02220358f, -0.03369048f, 0.03058174f, 
    -0.00761107f, 0.00769373f, -0.01251432f, 0.00480409f, 0.02646616f, -0.03616829f, -0.00502249f, 0.02393957f, 
    -0.02562303f, -0.00321213f, -0.03312130f, 0.02219205f, -0.01139446f, -0.01562049f, -0.02699490f, 0.00232430f, 
    -0.01836246f, 0.02270897f, 0.02863373f, -0.03822796f, -0.01917152f, -0.02016923f, -0.04206866f, -0.03787723f, 
    -0.03140666f, -0.01643479f, 0.02168747f, -0.00425817f, -0.03427260f, -0.03473588f, -0.00449815f, -0.01480556f, 
    0.01228224f, -0.01297450f, -0.03795800f, 0.01506044f, 0.01843240f, -0.01190610f, 0.00413031f, 0.00903599f, 
    -0.01451139f, -0.00070076f, 0.03587065f, -0.02135283f, 0.01565577f, 0.01417310f, 0.00727392f, -0.00625026f, 
    -0.02069727f, 0.01788571f, -0.02296154f, -0.02500823f, 0.02007595f, 0.01211397f, -0.02490106f, -0.02872179f, 
    0.01089270f, 0.01862066f, 0.02495298f, -0.03582750f, -0.03726405f, -0.03844582f, 0.00637478f, -0.01610059f, 
    -0.03977501f, -0.03416611f, -0.02573828f, -0.00469566f, 0.01842354f, 0.02147756f, -0.02844560f, -0.03315376f, 
    0.00821145f, 0.01907863f, 0.02032975f, 0.02651209f, -0.02560513f, -0.03130056f, 0.02032497f, 0.01696884f, 
    0.03356795f, 0.00443385f, 0.01112411f, 0.02044893f, 0.02588108f, -0.03871837f, -0.01617396f, -0.01001583f, 
    -0.03134515f, -0.01371487f, -0.00820700f, -0.00866983f, -0.03845557f, 0.01417817f, 0.00767578f, -0.00918875f, 
    -0.01063550f, 0.02882559f, -0.00274952f, -0.02028611f, -0.00314216f, 0.02886516f, -0.02459865f, 0.00347200f, 
    0.01749228f, -0.03859549f, -0.03914187f, -0.01339922f, -0.03952114f, 0.02584819f, 0.00727221f, 0.02061430f, 
    0.01477002f, -0.01661737f, 0.01197707f, 0.00388588f, -0.03356623f, -0.01817597f, -0.01984330f, -0.01984752f, 
    -0.02367654f, 0.01349486f, -0.02660016f, 0.00502018f, 0.01048467f, -0.00383770f, 0.00731983f, -0.00831839f, 
    -0.04156758f, -0.01150592f, -0.00562032f, 0.01440089f, -0.02933292f, 0.01509118f, 0.00256359f, -0.01117420f, 
    -0.01916452f, 0.01668074f, 0.00118629f, -0.03318450f, -0.01266578f, 0.01756850f, -0.01672862f, 0.00745567f, 
    -0.02735658f, 0.02770426f, 0.02318135f, 0.00102560f, 0.01532197f, -0.00935161f, 0.01851469f, 0.02163069f, 
    0.01546435f, -0.03531021f, 0.02095499f, -0.03621334f, -0.03092965f, -0.03978893f, -0.02314150f, -0.02568114f, 
    0.02171027f, -0.02481156f, 0.02217978f, 0.00472133f, -0.03307764f, 0.01213873f, -0.04119555f, -0.00721032f, 
    0.01957454f, -0.01160698f, -0.03201203f, -0.00227617f, 0.01310903f, -0.02131050f, -0.03667219f, -0.00888194f, 
    -0.03028771f, -0.00309048f, 0.00956751f, -0.01266477f, 0.00274291f, -0.01536688f, -0.01565460f, -0.01796274f, 
    0.00946530f, -0.02916631f, -0.00989657f, 0.00338304f, 0.01734589f, 0.00499696f, -0.01607451f, -0.02983671f, 
    -0.02086455f, -0.04216806f, -0.00586707f, -0.01651150f, -0.00846167f, 0.01657069f, 0.02248326f, 0.00690123f, 
    0.01439204f, 0.02636091f, -0.01905023f, -0.00202596f, -0.02329385f, 0.00525082f, -0.02276580f, -0.01487280f, 
    -0.01748863f, 0.02882565f, 0.01909061f, 0.01481552f, -0.03789547f, -0.01891242f, 0.01104535f, -0.03296519f, 
    0.02067296f, -0.02272641f, -0.01994266f, -0.00405089f, -0.00239339f, -0.01530999f, -0.00641083f, 0.01792803f, 
    -0.03586570f, 0.02064412f, -0.02490372f, -0.00018151f, -0.01532676f, 0.00097994f, -0.02839357f, -0.03846204f, 
    0.01106493f, -0.00501827f, -0.00506878f, -0.02716474f, 0.00362315f, -0.04339105f, -0.02325916f, -0.03043948f, 
    -0.03185522f, 0.01993896f, -0.02940259f, -0.00222396f, 0.01928453f, -0.01458284f, -0.01914693f, -0.03511984f, 
    0.02219079f, 0.01114801f, -0.01767074f, 0.02760117f, -0.01126693f, -0.03131689f, -0.03893595f, -0.01782003f, 
    0.01496057f, 0.00789413f, -0.02047437f, -0.02609949f, -0.03604629f, 0.00439209f, -0.03259355f, 0.00334220f, 
    0.00641405f, 0.00984031f, -0.01972977f, 0.02200003f, 0.00571857f, 0.00923455f, -0.03557874f, -0.03015173f, 
    -0.03281664f, -0.02439501f, -0.03938505f, 0.00099810f, -0.01420826f, 0.01192959f, 0.01423415f, -0.04384889f, 
    0.00536670f, -0.01495632f, -0.03629670f, 0.01039931f, -0.01422197f, -0.04375923f, -0.04439423f, -0.02984091f, 
    -0.01039233f, 0.00194224f, -0.00759308f, -0.01191488f, 0.03687048f, -0.01253819f, 0.00624752f, 0.01419637f, 
    0.01554774f, -0.00059482f, -0.03346292f, 0.01387163f, -0.01762852f, -0.00204166f, 0.01116962f, 0.01958053f, 
    -0.03210574f, -0.02929673f, -0.02204957f, 0.01521815f, -0.04115574f, -0.02086262f, -0.00995244f, 0.00541594f, 
    0.00790756f, 0.01289979f, -0.00875728f, 0.03316203f, 0.02393840f, -0.00800755f, 0.00664886f, -0.01963388f, 
    -0.03760068f, -0.00501034f, 0.02824072f, 0.01189829f, -0.02018340f, -0.00986176f, 0.02331351f, 0.01726840f, 
    0.01875933f, -0.04303516f, -0.00504777f, -0.04224088f, -0.01626304f, -0.01285866f, 0.00418029f, -0.03877015f, 
    -0.02550469f, -0.02208561f, 0.02340417f, 0.01349354f, 0.01965227f, -0.03796108f, -0.00631759f, 0.00281120f, 
    0.00160015f, -0.00718358f, 0.01578524f, -0.03207919f, -0.03947609f, -0.00665896f, -0.01869349f, -0.02048540f, 
    -0.00972343f, 0.02352037f, 0.00112266f, 0.01025526f, 0.00713626f, -0.02202544f, 0.02580030f, 0.00534410f, 
    -0.02729951f, -0.02891863f, -0.04284899f, 0.00934434f, 0.00281650f, -0.00640381f, -0.01939400f, -0.00644423f, 
    -0.03855164f, -0.00009690f, -0.04291745f, 0.01265038f, 0.00573123f, 0.01934892f, -0.00587389f, -0.02758269f, 
    -0.01539639f, 0.00825399f, -0.00725598f, -0.00894328f, -0.02385294f, 0.02076296f, -0.00209367f, -0.00695144f, 
    -0.03988573f, -0.03051397f, -0.00707692f, 0.00965079f, 0.02747522f, -0.01690574f, 0.03144703f, -0.01280001f, 
    0.04010552f, 0.01176134f, -0.00677013f, 0.01669338f, -0.04253751f, 0.00027661f, 0.00032101f, -0.04162716f, 
    -0.02479042f, -0.03462867f, -0.01841970f, -0.01385721f, -0.03378021f, 0.02648404f, 0.00557365f, -0.01368456f, 
    0.00979320f, 0.02166318f, -0.00202256f, 0.01791595f, -0.03577164f, 0.02599821f, -0.01427425f, -0.01077838f, 
    0.00210989f, 0.02629888f, 0.01040756f, -0.02303563f, 0.02295597f, 0.01903027f, 0.00184649f, 0.02655701f, 
    0.02742083f, 0.01046584f, 0.01538844f, -0.00730378f, -0.01784980f, -0.00714437f, 0.01135943f, -0.03465808f, 
    -0.02692324f, -0.01715134f, -0.03609477f, -0.01114368f, -0.00677739f, 0.02300482f, -0.03851592f, -0.00799818f, 
    -0.01447829f, 0.03317023f, 0.01438878f, -0.02837021f, -0.02514267f, 0.02661092f, 0.01547146f, 0.03101729f, 
    -0.00774372f, -0.01129279f, -0.04310302f, -0.03506718f, -0.02960605f, -0.00800529f, 0.01089884f, -0.00211110f, 
    0.02124139f, -0.01392616f, 0.00535909f, -0.03417135f, 0.02189726f, -0.02581734f, 0.01825862f, 0.01446488f, 
    -0.01486967f, -0.02110901f, 0.00627610f, -0.03943892f, 0.00600650f, -0.00858192f, -0.00426077f, -0.04188880f, 
    0.00783470f, -0.02893577f, 0.02566730f, -0.04203219f, -0.03925891f, -0.03835956f, -0.02434766f, 0.00504562f, 
    -0.00313882f, -0.01919252f, -0.03549170f, -0.01498007f, -0.00218566f, 0.00508372f, 0.02203492f, -0.02956174f, 
    0.03136773f, 0.02495425f, -0.04328860f, 0.00321739f, -0.00610856f, 0.00899747f, -0.03579647f, -0.03000804f, 
    -0.02275117f, -0.00127094f, -0.00775276f, -0.03026642f, 0.00434601f, 0.00775399f, 0.00957053f, -0.02246803f, 
    -0.03878589f, -0.01858016f, 0.00443930f, -0.03370542f, 0.02810273f, -0.04238801f, -0.03696740f, -0.03944136f, 
    0.00966655f, 0.02497544f, -0.01225256f, -0.01451498f, -0.01101802f, -0.03695684f, 0.00357253f, -0.00574596f, 
    0.01726720f, -0.00685652f, 0.01317535f, 0.00484013f, -0.02779223f, -0.02690638f, 0.00452779f, -0.00606461f, 
    0.01956610f, 0.02329666f, -0.02914671f, 0.01879364f, 0.02118872f, 0.00376503f, 0.01581166f, 0.00254294f, 
    0.01164273f, -0.02632480f, -0.02158412f, 0.02425883f, 0.00541849f, -0.02198025f, -0.03266518f, -0.02345535f, 
    0.02817801f, 0.00989788f, -0.01789054f, 0.02037763f, -0.03889475f, -0.00821417f, 0.03506289f, 0.02644321f, 
    0.01798219f, -0.01428285f, -0.02257413f, 0.00400258f, 0.02048763f, 0.00667246f, 0.00528459f, 0.02970759f, 
    0.01156624f, -0.00849548f, -0.02677037f, 0.01637875f, -0.00525800f, 0.02663131f, -0.01252800f, -0.02277886f, 
    0.00750555f, -0.03852838f, -0.00573942f, 0.01866867f, 0.01527742f, 0.01354738f, 0.02009144f, -0.00028921f, 
    -0.03280997f, 0.00515428f, -0.03852868f, -0.00874660f, 0.02354675f, 0.00244745f, 0.00730617f, -0.03597628f, 
    -0.03119324f, 0.02181035f, -0.04139215f, 0.01780667f, -0.03060585f, -0.00697744f, -0.02520289f, -0.02211452f, 
    -0.00132363f, -0.01337541f, 0.02565419f, -0.00783464f, -0.01756236f, -0.03107935f, -0.00859737f, 0.00164142f, 
    0.01353474f, 0.01580773f, -0.00702230f, -0.01828812f, 0.00290194f, 0.00866548f, 0.02615057f, 0.00969473f, 
    -0.00345675f, 0.00784007f, -0.03745863f, -0.00615145f, -0.02378595f, -0.04152168f, -0.00036483f, -0.02008690f, 
    0.03665893f, 0.02786781f, -0.04271832f, 0.02827610f, -0.02669519f, -0.04059967f, -0.02884714f, 0.00168527f, 
    -0.02661794f, -0.03917444f, -0.03392325f, 0.02708931f, 0.02211494f, 0.00652352f, -0.01243851f, -0.02359810f, 
    0.01803076f, -0.01105989f, -0.01769423f, -0.03766130f, 0.02200945f, -0.04157181f, -0.03361709f, -0.01616480f, 
    0.01417994f, -0.03939078f, 0.02527027f, 0.01966042f, -0.02995566f, 0.01599211f, -0.02558736f, -0.00486529f, 
    0.03658532f, -0.03206509f, -0.03216979f, -0.02597130f, 0.02019671f, 0.00326042f, -0.01022634f, -0.01587928f, 
    0.37220669f, 0.09708354f, -0.22340593f, 0.20000836f, -0.00700381f, -0.01118183f, -0.03742897f, 0.05999261f, 
    0.00194252f, -0.03665007f, -0.02064342f, -0.18227115f, 0.13288102f, 0.33649421f, -0.04724488f, -0.33329943f, 
    -0.00675611f, -0.00785373f, 0.01437515f, -0.02163487f, 0.01076451f, -0.10060908f, -0.05771884f, 0.17561689f, 
    0.16356932f, -0.03764926f, -0.05455739f, 0.06927212f, 0.01323739f, -0.11346585f, -0.02877266f, -0.02031218f, 
    -0.01625130f, 0.05622032f, 0.01548269f, -0.00827923f, -0.24122642f, -0.01837756f, -0.44501805f, -0.40510714f, 
    0.07490156f, 0.00030912f, 0.08298334f, -0.02374337f, 0.03543618f, -0.12365059f, -0.06288248f, 0.01326763f, 
    0.28670600f, 0.21515650f, 0.25972691f, 0.02235777f, 0.18110797f, 0.10879374f, 0.03214014f, -0.05442994f, 
    0.03543044f, -0.04203901f, 0.01540578f, 0.07813681f, 0.40466160f, -0.31153932f, -0.15541789f, -0.13509530f, 
    0.06205066f, -0.06734516f, -0.05232970f, -0.08149553f, -0.01436943f, 0.08273077f, 0.02733475f, -0.09923095f, 
    0.20482291f, 0.16585188f, 0.04738988f, -0.02158844f, 0.19275132f, 0.02223307f, 0.01969473f, 0.09562042f, 
    0.01846203f, -0.00297169f, -0.02361850f, -0.02181663f, 0.10243437f, 0.04446736f, 0.04166602f, 0.23080447f, 
    -0.05977942f, -0.02863667f, -0.02239753f, -0.07319330f, 0.01875701f, -0.06606490f, -0.11585059f, -0.02014269f, 
    0.05029821f, -0.10100850f, 0.01953272f, 0.10903924f, -0.02935876f, 0.00890336f, -0.05286829f, -0.00291737f, 
    -0.17980295f, -0.09135682f, 0.03775681f, -0.00422481f, -0.30101663f, 0.07214767f, 0.11029036f, 0.15331858f, 
    0.00842394f, -0.05392794f, -0.00066806f, -0.02632945f, -0.01031023f, 0.00352625f, -0.05347298f, -0.10146904f, 
    0.33580413f, 0.11282485f, 0.10446788f, 0.01861150f, 0.02192741f, -0.00493777f, -0.14040360f, -0.01588011f, 
    -0.03354088f, -0.02312727f, -0.00284682f, 0.06348339f, 0.14769275f, -0.00980013f, 0.13139641f, 0.14266886f, 
    0.01973098f, 0.00697582f, 0.08490934f, 0.02931789f, -0.00803306f, 0.14366175f, -0.00210622f, -0.02105324f, 
    0.19171610f, 0.27728659f, 0.23318256f, 0.19404662f, -0.04354257f, -0.00732171f, -0.09289093f, -0.02681879f, 
    -0.04729912f, -0.15944692f, 0.00247183f, -0.02373969f, 0.21623276f, -0.01549433f, -0.02493046f, 0.03170043f, 
    -0.10189628f, 0.01313732f, -0.01245731f, 0.02691167f, 0.15176874f, 0.02356208f, 0.12762149f, -0.02115191f, 
    0.21072343f, -0.12381122f, -0.12602229f, -0.07024193f, -0.03711766f, -0.00395833f, 0.04270639f, 0.04707059f, 
    0.06481276f, -0.08092266f, -0.01294801f, 0.03953792f, 0.31543079f, -0.36273226f, 0.10060184f, 0.11985730f, 
    -0.09421989f, 0.04580174f, 0.07080542f, 0.09880073f, 0.29181373f, -0.13672869f, 0.00444423f, -0.05111022f, 
    0.11787547f, 0.12422109f, -0.03496881f, 0.08897728f, -0.03438516f, -0.04752110f, 0.01576295f, -0.00387077f, 
    -0.01770880f, 0.00273506f, -0.02955149f, -0.08656122f, -0.06863557f, -0.12949444f, -0.12570341f, -0.17762002f, 
    -0.08769718f, 0.16997327f, -0.07856017f, 0.08625012f, -0.02389511f, -0.06746943f, -0.00153107f, 0.11152139f, 
    0.04816454f, -0.44295463f, -0.33419526f, -0.19545764f, 0.00293019f, 0.01379958f, 0.03036272f, 0.01038033f, 
    -0.03741176f, 0.11321954f, 0.14022727f, -0.08681992f, 0.06612026f, 0.08414558f, 0.00284582f, -0.10726901f, 
    -0.02594449f, -0.02310090f, 0.01235718f, 0.16794582f, -0.03790741f, -0.09036540f, -0.02246302f, -0.09553857f, 
    0.16773359f, 0.18981141f, 0.02204688f, -0.17596897f, 0.03390800f, 0.02430688f, 0.03155145f, 0.07737684f, 
    0.00085997f, -0.02486481f, 0.17633384f, 0.05067286f, -0.03797385f, 0.09563449f, 0.05599528f, -0.03929415f, 
    0.05444959f, 0.04066579f, -0.06320415f, -0.11474919f, -0.05588981f, -0.06026657f, -0.05388204f, 0.00747694f, 
    0.15850511f, 0.03831846f, 0.06127765f, -0.13025309f, -0.15992993f, -0.02004339f, 0.04169412f, -0.12027734f, 
    -0.05320843f, -0.00760202f, 0.04433545f, -0.02766520f, 0.26612976f, 0.08899237f, -0.05110137f, -0.16374816f, 
    -0.11887447f, 0.15119711f, -0.06787126f, 0.14785685f, -0.03666304f, 0.03257023f, -0.01323593f, -0.02165936f, 
    0.19156276f, 0.10329797f, -0.00233076f, 0.10780718f, 0.05347798f, 0.03622013f, 0.03707964f, 0.09104142f, 
    0.09766869f, -0.04272966f, -0.11253417f, -0.20107797f, -0.06095552f, -0.02554139f, 0.26384982f, 0.06295985f, 
    0.04907954f, 0.12856889f, 0.14658919f, 0.06361941f, 0.02421088f, -0.02743154f, -0.02291408f, -0.09151075f, 
    0.03777384f, -0.14067516f, 0.15774368f, -0.01325355f, 0.06290883f, 0.02436975f, -0.02339596f, -0.03416600f, 
    -0.04194603f, -0.02696103f, -0.03941090f, -0.00193303f, -0.03746789f, 0.01976784f, 0.02536996f, 0.00892911f, 
    0.08921960f, 0.01138665f, -0.00500002f, 0.11489464f, -0.09064395f, -0.16251348f, -0.02069006f, 0.06593464f, 
    0.02934795f, -0.05606165f, -0.09857289f, -0.11649923f, -0.03783555f, 0.16541174f, -0.00835492f, -0.05463355f, 
    -0.05475353f, 0.08085677f, -0.02407405f, -0.03698936f, 0.02908563f, -0.10570800f, 0.00136175f, -0.24207091f, 
    -0.04372595f, 0.13377883f, -0.04675765f, -0.07998565f, 0.00960884f, -0.02314890f, -0.03949196f, -0.01050174f, 
    0.23275889f, -0.00253021f, 0.05919602f, -0.13707753f, -0.11632247f, 0.02583100f, 0.03828216f, 0.04800735f, 
    -0.07792227f, 0.00666238f, -0.06098804f, -0.03383957f, 0.04036751f, -0.30375323f, -0.09372793f, -0.30365428f, 
    0.00964788f, 0.05713021f, 0.01850770f, -0.04937626f, 0.06104526f, -0.04378677f, 0.07772893f, 0.01743222f, 
    -0.00626465f, -0.15050587f, -0.07932399f, -0.26663718f, -0.01549485f, 0.01803764f, 0.01025828f, -0.02319703f, 
    0.08965370f, -0.00724396f, 0.04329611f, -0.04612436f, 0.26653937f, 0.13045610f, 0.21254146f, -0.27092528f, 
    0.07074474f, 0.10203731f, 0.20589907f, -0.01270596f, -0.04767770f, 0.04078256f, 0.01559041f, -0.02777662f, 
    0.21695012f, 0.04047870f, -0.16216235f, -0.15356545f, 0.11575168f, 0.04641624f, 0.07432745f, -0.00801890f, 
    0.04432206f, -0.01891519f, 0.02218135f, 0.00342024f, -0.30326179f, -0.10595592f, 0.09269797f, -0.12887999f, 
    0.01219992f, 0.00815151f, -0.03035863f, -0.09907614f, -0.01871124f, -0.18468939f, -0.07374517f, -0.08240617f, 
    0.26841173f, 0.08735894f, -0.03381120f, -0.03587741f, -0.05115617f, -0.01745347f, 0.17045051f, 0.25581554f, 
    0.05658634f, 0.06899208f, 0.08560689f, -0.03003343f, 0.02141797f, -0.06366678f, -0.39348280f, -0.10249215f, 
    0.05735121f, -0.06101630f, -0.00119579f, 0.03232421f, 0.01925474f, 0.05646653f, 0.03748060f, 0.13519651f, 
    -0.07341413f, 0.25686708f, 0.21533282f, -0.07956926f, 0.15414108f, -0.01897692f, -0.08426709f, 0.03298020f, 
    0.01854380f, -0.02243819f, -0.01134726f, -0.07230517f, 0.11547074f, 0.02351711f, 0.02989087f, 0.01453994f, 
    -0.02488702f, -0.01316988f, 0.05284829f, 0.00139483f, 0.02520696f, -0.04542103f, 0.03905600f, -0.00553193f, 
    0.33400255f, -0.11791088f, -0.61208969f, -0.18046761f, -0.01427931f, 0.03649722f, 0.11521132f, 0.12682855f, 
    0.03937209f, 0.01824533f, -0.01990794f, -0.01533027f, -0.23383829f, -0.33303487f, 0.22151798f, 0.03813438f, 
    -0.00265361f, 0.10842407f, 0.15958419f, 0.06340112f, 0.12362318f, 0.02220518f, 0.03750465f, -0.07314188f, 
    -0.05731167f, 0.02163755f, 0.01278311f, -0.07107221f, -0.08459456f, 0.02564684f, 0.05792190f, 0.13770066f, 
    0.04665304f, 0.13240267f, 0.13499533f, -0.19031389f, 0.17995287f, 0.16738568f, 0.09184332f, -0.09722630f, 
    -0.03690196f, 0.14315602f, 0.16328378f, 0.00517170f, -0.06370362f, -0.06765030f, -0.01989495f, -0.07020938f, 
    0.10862463f, -0.20746674f, 0.14770193f, -0.15117005f, 0.10227192f, 0.05781737f, 0.02621888f, 0.07458947f, 
    -0.09888496f, 0.01300858f, 0.12836573f, 0.08391987f, 0.11594102f, 0.35824645f, 0.17611726f, -0.03489904f, 
    0.03906628f, 0.11092816f, 0.01952317f, 0.08539543f, 0.06400122f, 0.01576799f, 0.06264802f, 0.09252575f, 
    -0.09497651f, 0.03126652f, -0.01958169f, -0.00087873f, -0.02675138f, 0.07167932f, 0.08113418f, -0.09764992f, 
    -0.05539989f, -0.02744303f, -0.13541263f, -0.02481566f, 0.30680788f, 0.28512046f, 0.21000452f, -0.11422591f, 
    0.12705921f, 0.21174118f, 0.13471457f, 0.01707682f, 0.03499873f, 0.01302131f, 0.05158304f, -0.01621875f, 
    0.01053412f, 0.04582226f, -0.09890751f, -0.01766744f, 0.00784330f, 0.02408023f, -0.03273010f, -0.09245651f, 
    -0.11676534f, 0.03304333f, -0.02879623f, 0.03778557f, -0.09037759f, 0.00353692f, 0.07171673f, 0.10859231f, 
    0.03065927f, 0.05282693f, -0.02530207f, -0.03524766f, -0.01896694f, -0.02557276f, 0.01630399f, 0.03279239f, 
    0.38114810f, 0.04429714f, -0.30706036f, 0.24881390f, 0.03730228f, -0.02858404f, 0.01450274f, 0.00511862f, 
    -0.03742843f, 0.00541046f, -0.10683596f, 0.08832540f, 0.29133841f, 0.04686349f, -0.05600507f, -0.19840674f, 
    -0.04237214f, 0.07049236f, 0.04101180f, 0.21508949f, 0.07520353f, 0.08735068f, 0.04421642f, 0.08794179f, 
    0.07888258f, -0.07983230f, 0.02096630f, -0.00147204f, 0.09033553f, -0.05864130f, 0.06149503f, 0.09570358f, 
    0.04189988f, -0.07634606f, -0.03088370f, -0.00850173f, -0.11297152f, -0.05441045f, 0.08749069f, 0.15218517f, 
    0.10429929f, 0.03214975f, 0.04918016f, 0.07587974f, -0.00295071f, -0.09610879f, -0.04363817f, -0.14325996f, 
    0.01374627f, -0.18835489f, 0.09834730f, -0.03660506f, 0.14638318f, 0.09965482f, 0.06217598f, -0.17650124f, 
    -0.09152959f, 0.04060319f, -0.03610733f, 0.00708931f, 0.24826713f, -0.01831538f, -0.04378489f, 0.04287547f, 
    -0.04925548f, -0.00447904f, -0.04153480f, 0.01812115f, -0.02776388f, -0.03278059f, -0.02562507f, 0.06976592f, 
    0.06341463f, 0.00307206f, -0.00212922f, -0.12497263f, 0.15743904f, 0.12227452f, 0.03080152f, 0.04346124f, 
    0.05850230f, 0.02239100f, 0.05563048f, 0.04394611f, 0.33976784f, -0.45578083f, -0.02765553f, -0.12306995f, 
    -0.07186226f, -0.11618125f, 0.10702906f, 0.09215174f, -0.02018207f, 0.08930182f, -0.01570285f, -0.02965152f, 
    0.13082799f, 0.12386807f, 0.14370306f, 0.02598722f, 0.09654931f, 0.13841422f, 0.07663598f, -0.00564197f, 
    -0.00720978f, -0.00067091f, 0.00328247f, -0.04083455f, 0.06182639f, -0.00675208f, 0.18162102f, 0.15146624f, 
    -0.06275797f, 0.01442036f, -0.04634653f, -0.07586008f, 0.08003623f, -0.02536332f, -0.04027734f, -0.16343327f, 
    -0.19221577f, -0.10280795f, 0.04710975f, 0.02148875f, 0.10220690f, -0.05888623f, -0.02083490f, -0.06615121f, 
    -0.07637524f, 0.00320284f, -0.05379871f, 0.00443955f, 0.05605035f, -0.03837753f, 0.04971612f, 0.09756435f, 
    -0.07287860f, 0.01888297f, -0.08300241f, -0.05866662f, 0.07313834f, -0.09780264f, -0.03282769f, -0.10480540f, 
    0.16454323f, 0.15339924f, -0.09059629f, 0.03529949f, -0.01017026f, 0.06850877f, 0.00128199f, 0.13424748f, 
    0.00574281f, -0.01341943f, -0.01518374f, 0.07606130f, 0.02211703f, -0.01250170f, 0.00544858f, -0.05053140f, 
    0.03374531f, -0.06534135f, 0.12216960f, -0.04048711f, -0.04006396f, 0.07444606f, -0.07666678f, -0.07827733f, 
    -0.04120202f, 0.00729646f, -0.02364323f, -0.02478056f, 0.01726581f, -0.03893626f, 0.01264930f, 0.02031254f, 
    0.02554521f, -0.01617797f, -0.02252617f, -0.00184869f, -0.03987500f, -0.04026671f, -0.02121308f, -0.02991260f, 
    -0.01372733f, -0.01708410f, 0.02936137f, -0.03312508f, -0.03311049f, 0.02641018f, -0.00891031f, 0.02006021f, 
    -0.01554146f, -0.01602460f, -0.00037972f, -0.02710310f, 0.02836361f, -0.03071711f, -0.01610319f, 0.01010406f, 
    -0.01440478f, 0.00627079f, 0.01803320f, -0.02141381f, 0.00090020f, 0.00186235f, -0.01247275f, -0.01569493f, 
    -0.00942763f, -0.03819247f, 0.01266834f, -0.02970750f, -0.02794637f, 0.02297243f, -0.02748672f, 0.02863203f, 
    -0.00684441f, 0.01412475f, -0.01653508f, -0.01084672f, -0.01895087f, 0.01479124f, 0.00278663f, -0.00731259f, 
    0.01067166f, 0.02304537f, 0.00742750f, -0.01232776f, -0.01584364f, -0.03666797f, -0.01501608f, -0.03287898f, 
    0.00220231f, -0.02081648f, -0.00126587f, -0.02705311f, 0.02929447f, -0.01508447f, -0.01166264f, 0.01921410f, 
    -0.00436392f, -0.04139500f, -0.00695816f, 0.02979791f, 0.02059745f, 0.00733592f, -0.01620915f, -0.03159266f, 
    -0.02920629f, -0.03607999f, -0.03870865f, -0.03320189f, 0.01404369f, -0.00030855f, 0.02918067f, 0.00964692f, 
    0.00843538f, 0.02776564f, 0.02097800f, -0.03552640f, 0.00379123f, -0.03212043f, -0.01865301f, -0.00050254f, 
    0.01882624f, 0.02424861f, 0.02403217f, -0.01488050f, 0.02180134f, -0.00389950f, -0.03340013f, -0.02419968f, 
    -0.01139911f, 0.01108290f, 0.02253985f, 0.02349226f, 0.01222636f, 0.00374487f, 0.02963242f, -0.03532289f, 
    -0.04003796f, 0.01816961f, 0.00268820f, 0.00953092f, 0.01547059f, 0.01421495f, -0.03209277f, -0.02074346f, 
    -0.01959104f, 0.02772087f, -0.00935006f, 0.00281483f, 0.00977281f, -0.03736657f, -0.00189430f, -0.02311229f, 
    -0.02539408f, -0.01586198f, 0.00027347f, -0.00062248f, 0.02192882f, -0.02132550f, -0.02915680f, -0.01946993f, 
    0.01343027f, 0.00107414f, -0.00919349f, 0.02561345f, 0.00355406f, 0.00271254f, 0.02081665f, -0.02961086f, 
    -0.02656750f, -0.02992246f, -0.02572671f, -0.01985470f, 0.02310324f, -0.03210739f, 0.02166923f, 0.00375244f, 
    0.01530166f, -0.03761074f, 0.00640149f, 0.00391989f, -0.04085431f, 0.01579769f, 0.00986418f, -0.03143909f, 
    -0.01825450f, -0.00466212f, -0.02388918f, -0.02485043f, -0.01929028f, -0.00733939f, 0.01562141f, 0.02145364f, 
    0.02067426f, 0.01556675f, -0.01524946f, 0.00454853f, -0.00574184f, -0.01152529f, -0.01739680f, -0.03478241f, 
    0.02266017f, 0.00403854f, 0.00825370f, -0.02781249f, 0.01914791f, 0.01874222f, 0.02720613f, 0.02199207f, 
    -0.01252699f, 0.00389559f, 0.01151994f, -0.03910773f, 0.02163979f, 0.01722722f, -0.00683564f, -0.00510477f, 
    0.00133491f, -0.03109003f, -0.02738760f, -0.04194302f, -0.03861168f, 0.00455153f, 0.02556095f, -0.01501242f, 
    -0.00064023f, 0.01236038f, 0.00390197f, -0.03349571f, -0.02196692f, -0.01145448f, -0.00195716f, 0.02126070f, 
    -0.00006453f, 0.02259638f, -0.03493550f, 0.00608175f, 0.02370170f, 0.02255889f, -0.02500951f, -0.02055329f, 
    -0.02022262f, -0.01052499f, -0.02305666f, -0.04134005f, -0.03232170f, 0.02199749f, 0.00335170f, 0.00427753f, 
    -0.00078090f, -0.03939673f, 0.01185664f, -0.02479406f, 0.01655916f, -0.00754620f, 0.03100832f, 0.00377821f, 
    -0.03838525f, 0.02303851f, -0.01912371f, 0.02469447f, -0.01939836f, -0.03677475f, -0.02666356f, -0.03703487f, 
    -0.02033246f, 0.02933992f, -0.00007292f, 0.01981881f, -0.01336088f, 0.02706246f, 0.02437902f, -0.02436141f, 
    -0.01743098f, 0.00944341f, -0.00235777f, -0.01930847f, 0.01177374f, 0.02872073f, -0.02570367f, -0.01507065f, 
    0.00453013f, -0.00884063f, -0.00628346f, -0.00338328f, 0.02888891f, 0.02203688f, -0.00167469f, 0.00086229f, 
    -0.03619253f, -0.02635172f, -0.02751223f, -0.00120121f, -0.00889613f, -0.00036131f, -0.02456688f, 0.02605697f, 
    -0.02465033f, 0.02252393f, 0.00263616f, 0.01521176f, -0.02970180f, -0.01612665f, -0.02789603f, 0.00323462f, 
    -0.01854356f, -0.01745771f, -0.03200521f, 0.00375785f, -0.04107299f, -0.04047066f, -0.00889294f, 0.02688148f, 
    0.02069803f, 0.01200750f, -0.01741555f, -0.02067805f, -0.00365960f, -0.03001916f, 0.01569121f, -0.01281536f, 
    -0.01720900f, 0.00161761f, -0.01868497f, 0.01659593f, -0.04117622f, -0.01888510f, 0.01946487f, -0.01522015f, 
    0.02825152f, -0.03159278f, 0.00541561f, 0.02958647f, 0.02379281f, 0.00794105f, 0.00370419f, 0.01284444f, 
    0.02698404f, -0.01758903f, -0.03421408f, -0.03588439f, 0.00700797f, 0.00020497f, -0.01139033f, 0.02431193f, 
    -0.00834519f, -0.01498253f, -0.03306181f, -0.03846483f, -0.00477358f, -0.03521620f, -0.01051743f, 0.00184219f, 
    0.01308751f, -0.03166488f, -0.03333409f, 0.00267031f, 0.02376355f, 0.01724777f, -0.00231339f, -0.00687833f, 
    -0.02259179f, -0.02940389f, -0.01418670f, -0.03341099f, 0.01786921f, 0.00904686f, -0.02105984f, -0.02693903f, 
    0.01428117f, 0.02341547f, -0.00697544f, -0.00463897f, -0.03302691f, -0.01170047f, 0.02164919f, 0.00473932f, 
    -0.01390435f, 0.02860219f, -0.01446796f, 0.02182179f, -0.03773307f, -0.02506483f, -0.01040316f, -0.01318033f, 
    0.00510804f, -0.02068697f, -0.02599972f, -0.02967225f, -0.02120432f, -0.03695226f, 0.01955553f, -0.00486830f, 
    -0.03464343f, -0.00056242f, -0.02597575f, -0.01599555f, 0.00490735f, 0.01353150f, -0.01686241f, 0.02624315f, 
    -0.04146021f, -0.01494436f, -0.01333750f, 0.00791988f, -0.01223354f, 0.00526674f, -0.02875374f, -0.00711241f, 
    -0.02164101f, -0.01019762f, -0.01048447f, -0.01780327f, 0.00123056f, -0.00205927f, 0.00977281f, -0.03622555f, 
    -0.02582391f, 0.00390519f, 0.00004625f, -0.00010761f, 0.00018343f, 0.01643587f, -0.04112563f, -0.01316964f, 
    0.00886785f, -0.02207123f, 0.01793789f, -0.01044779f, -0.01923182f, 0.02462349f, 0.02498523f, -0.01350515f, 
    0.01945132f, 0.02802873f, 0.01953764f, 0.00919907f, -0.00077618f, 0.01424515f, 0.02595413f, -0.04117528f, 
    -0.01994160f, 0.01612330f, 0.02924864f, -0.00235544f, 0.01735167f, -0.00933841f, 0.01704326f, 0.02888256f, 
    -0.00420336f, 0.01207488f, -0.03569761f, -0.02112005f, 0.02297499f, -0.03678297f, -0.02339993f, -0.01163050f, 
    -0.00973539f, -0.03567462f, 0.01190212f, 0.02134418f, 0.01517241f, -0.00726343f, 0.00097766f, -0.00041715f, 
    0.00417500f, 0.01913221f, -0.02067143f, -0.03546041f, -0.01342064f, 0.00006070f, -0.02394771f, 0.02918808f, 
    -0.02336171f, -0.02074404f, -0.03085787f, 0.00093120f, -0.01916102f, -0.00496848f, 0.02092065f, -0.01948907f, 
    -0.01461428f, -0.02979633f, -0.03320461f, -0.00534787f, -0.01858751f, -0.02530840f, -0.03187015f, -0.01187142f, 
    -0.02007207f, 0.00067786f, -0.03166215f, -0.01370761f, -0.04099998f, 0.02602191f, -0.02590468f, 0.01207974f, 
    -0.00679686f, 0.02415330f, 0.02279101f, -0.02868310f, -0.03735014f, 0.00169187f, -0.02119998f, -0.02685702f, 
    -0.03741839f, -0.02604603f, -0.03590955f, -0.02575818f, -0.03674449f, 0.02318415f, 0.00877525f, -0.02414356f, 
    0.02859346f, -0.03019241f, 0.02040191f, -0.02231113f, 0.02684711f, -0.03444857f, 0.02296466f, -0.02679217f, 
    0.00908727f, -0.01853380f, 0.00701857f, -0.00775237f, 0.00681642f, 0.01165039f, 0.01129560f, -0.01893360f, 
    -0.00700354f, 0.02735082f, 0.02127271f, 0.01852687f, -0.03266781f, 0.01102995f, -0.00046273f, -0.02484480f, 
    0.02430262f, -0.02553019f, -0.01674790f, -0.03769070f, -0.03082412f, -0.01028179f, -0.04117623f, -0.02543143f, 
    0.00411675f, -0.03367490f, -0.03809582f, 0.01800639f, -0.03750460f, -0.02964946f, 0.00781355f, -0.01695767f, 
    0.00590687f, -0.01777941f, 0.02562658f, -0.00367276f, -0.04104851f, 0.02561406f, 0.01254021f, -0.01072055f, 
    0.01241495f, 0.01544209f, -0.00551725f, -0.02279836f, 0.00174045f, -0.01916232f, 0.00774497f, -0.03821056f, 
    0.00927417f, -0.01208972f, -0.02346596f, -0.02054493f, 0.01342361f, 0.00911117f, -0.00610711f, -0.00200746f, 
    0.00870825f, 0.00495581f, -0.03103011f, -0.03478312f, -0.00852495f, -0.01726725f, 0.02467140f, 0.01825081f, 
    0.01534184f, -0.01042691f, -0.01710085f, 0.01941585f, -0.02499448f, 0.01116430f, 0.00852775f, -0.00558736f, 
    -0.02487127f, 0.02852885f, -0.02080175f, -0.01460081f, -0.01343864f, 0.02569982f, -0.02289290f, -0.00026721f, 
    -0.02109856f, 0.02456063f, 0.02429292f, -0.02701903f, -0.02876960f, -0.03005011f, -0.00378815f, 0.00573396f, 
    -0.00040458f, 0.00766905f, -0.00939585f, -0.01682265f, -0.04063518f, -0.02170486f, 0.01436395f, -0.02042229f, 
    -0.02117583f, 0.02270104f, -0.03751969f, 0.01839618f, -0.02430255f, 0.02743935f, -0.02578120f, 0.01481183f, 
    -0.03622817f, -0.00145739f, -0.03185075f, -0.00337640f, -0.04017447f, -0.01690250f, 0.01743748f, -0.03006691f, 
    -0.03352309f, 0.02107804f, -0.00416847f, -0.02437188f, 0.02996148f, 0.01674605f, 0.00481924f, -0.04029517f, 
    -0.03580194f, -0.00443934f, 0.01805087f, -0.03859548f, -0.01255065f, -0.03142510f, 0.02065418f, -0.00201424f, 
    -0.03563270f, 0.02993547f, -0.01178006f, -0.04048871f, -0.02979854f, -0.02621635f, 0.02421081f, 0.02139767f, 
    -0.02932886f, 0.02518152f, -0.01217367f, -0.01648520f, -0.00987117f, 0.02050393f, -0.02838656f, 0.00834658f, 
    0.01199402f, -0.01519873f, -0.03699791f, -0.00861270f, -0.04131388f, -0.02119708f, 0.01349634f, 0.00176675f, 
    -0.00686435f, 0.00357351f, -0.02724923f, -0.03437410f, -0.01867771f, 0.02125746f, 0.01357334f, -0.01591342f, 
    -0.02589663f, -0.02133991f, -0.00602855f, -0.01492299f, -0.04005229f, 0.02723372f, 0.01485542f, -0.04145658f, 
    -0.03557209f, -0.02153591f, -0.03489596f, -0.01068845f, 0.01562730f, -0.01074827f, -0.01151957f, -0.03319243f, 
    0.00011612f, 0.02347522f, -0.02305953f, 0.02581983f, -0.04116033f, -0.02717858f, -0.01565479f, 0.00824918f, 
    -0.03625463f, -0.02996970f, -0.01826319f, -0.02739947f, 0.02793802f, -0.00859760f, 0.02625875f, -0.03713011f, 
    0.00206633f, -0.00950462f, 0.01487834f, 0.02821542f, 0.02005225f, -0.03651240f, -0.03904114f, 0.02386776f, 
    0.02677863f, -0.01930897f, -0.00385099f, -0.01529861f, -0.03669231f, -0.00093126f, -0.00207337f, 0.01292309f, 
    -0.02990550f, -0.01620501f, -0.02887162f, -0.01302743f, 0.01024163f, 0.00407027f, 0.02158344f, -0.03247286f, 
    0.02751760f, 0.00056435f, -0.02422846f, -0.02428396f, 0.00129253f, -0.00185990f, -0.01171963f, -0.01655294f, 
    0.03325756f, -0.03941851f, -0.01038849f, -0.03508924f, -0.02288228f, -0.02486746f, 0.01923351f, -0.00160725f, 
    -0.04161640f, -0.02864204f, -0.03729854f, 0.02257805f, 0.00327200f, -0.02309630f, 0.01621911f, -0.01255920f, 
    0.01921598f, -0.01322703f, -0.02585392f, 0.02618214f, -0.01564839f, -0.03423369f, 0.00009353f, -0.01354003f, 
    -0.02765378f, 0.01320452f, 0.01889289f, 0.01711796f, -0.02558809f, -0.04103991f, -0.04180674f, -0.02118794f, 
    0.01566329f, -0.02244499f, -0.03944115f, -0.01818723f, -0.02501521f, 0.02630151f, 0.00713132f, -0.01102097f, 
    -0.00616520f, -0.02499384f, 0.01885988f, -0.02511365f, -0.02564310f, -0.01394674f, -0.02554382f, -0.02871369f, 
    0.30181298f, 0.04058512f, 0.01839711f, 0.06216228f, 0.09990449f, -0.08554365f, 0.00539364f, -0.11268233f, 
    0.01476583f, -0.00008605f, 0.02750723f, -0.08070816f, -0.41717100f, 0.19041221f, 0.04116940f, 0.17174578f, 
    -0.07935565f, -0.05029609f, -0.03085194f, -0.06655908f, 0.03601030f, 0.03401940f, -0.10683545f, -0.20210718f, 
    0.12929299f, 0.07882582f, -0.00082818f, -0.00833988f, 0.08812774f, -0.02888615f, -0.01687092f, -0.15325348f, 
    0.06085741f, -0.06469563f, 0.09216619f, -0.07787477f, -0.35099861f, 0.18901011f, 0.15470856f, 0.04541656f, 
    -0.10645090f, -0.08599517f, -0.07082835f, 0.16126493f, 0.07808006f, 0.09266488f, -0.00324848f, -0.08926968f, 
    -0.01889910f, -0.00145401f, 0.06539784f, 0.04919184f, -0.03043623f, -0.02184737f, -0.04812272f, 0.05052935f, 
    0.06894337f, 0.07214385f, 0.07627589f, 0.09576411f, 0.29755732f, 0.19983101f, -0.04245678f, -0.08551355f, 
    0.01335027f, -0.08086116f, -0.02069307f, 0.00989641f, 0.14921032f, 0.12962797f, -0.03642012f, 0.14510781f, 
    -0.18907443f, 0.05512217f, 0.07019859f, -0.08781146f, -0.16743802f, 0.08319551f, -0.13222973f, -0.05534313f, 
    0.13206638f, -0.01636529f, -0.05081878f, -0.03863720f, 0.13238962f, -0.06474012f, 0.04791195f, 0.29338422f, 
    -0.06644586f, -0.00072350f, -0.00903524f, -0.00605423f, 0.00841977f, 0.00588804f, -0.08754811f, 0.08891950f, 
    -0.09425514f, -0.07345080f, 0.26845369f, 0.13239884f, -0.00258971f, -0.04987363f, 0.01557545f, 0.05916123f, 
    0.12473429f, 0.07582696f, -0.05843283f, 0.11417427f, -0.37128091f, -0.11363474f, 0.01089009f, 0.17754495f, 
    -0.02346742f, -0.10663913f, -0.03538012f, 0.10508201f, 0.09592238f, 0.03640343f, 0.12848584f, -0.03752815f, 
    0.13233331f, 0.30369207f, 0.06401577f, 0.01223735f, -0.12386103f, -0.04528559f, -0.01261456f, -0.07909150f, 
    0.09680486f, -0.00045942f, 0.08562293f, -0.00563487f, 0.14161557f, 0.18798962f, 0.01401693f, -0.14967850f, 
    -0.05228587f, -0.08647737f, 0.07878995f, 0.03071805f, 0.01377280f, -0.04144887f, 0.25495026f, -0.17316842f, 
    0.02358082f, -0.15353023f, -0.15863092f, 0.08063780f, 0.05137132f, -0.00277101f, 0.06177387f, -0.04446544f, 
    0.09095080f, 0.04272671f, -0.03712719f, 0.00674568f, 0.23044373f, -0.05489285f, 0.13905686f, 0.12566225f, 
    0.01919195f, -0.00575619f, 0.03665608f, -0.00882084f, -0.01291520f, 0.12007073f, -0.01672351f, 0.04040964f, 
    0.56771827f, -0.01754161f, -0.37833700f, 0.01586927f, 0.02569424f, -0.03593262f, -0.00460414f, -0.11762015f, 
    0.04661225f, 0.18709470f, -0.18144110f, 0.16349483f, 0.03642501f, -0.36176574f, 0.23051076f, 0.07689746f, 
    -0.12657012f, -0.11454041f, 0.15035701f, -0.03790447f, 0.12277550f, 0.08158676f, 0.13485508f, 0.07677840f, 
    -0.02354573f, -0.19193009f, 0.08911547f, 0.18540613f, 0.09926429f, -0.02462755f, -0.01291095f, 0.02243241f, 
    0.03934338f, -0.01422577f, -0.03445413f, 0.01982460f, -0.04227633f, 0.08902460f, 0.17629415f, -0.17951255f, 
    -0.02470393f, -0.00922034f, -0.01800582f, -0.13098100f, -0.00277255f, -0.12644535f, 0.21154660f, -0.21977381f, 
    -0.04831520f, 0.27532366f, 0.02735211f, -0.09655882f, 0.02445309f, 0.03687165f, -0.11897252f, -0.01376428f, 
    0.04721416f, 0.07110928f, 0.07749067f, 0.02079718f, 0.27009037f, -0.08946805f, 0.04612113f, -0.03373967f, 
    0.18300442f, 0.13635942f, -0.07125094f, -0.04721548f, 0.03508744f, -0.00116529f, -0.00933408f, -0.07784197f, 
    0.33024231f, -0.36229458f, 0.13724992f, -0.21183893f, 0.07695261f, 0.13481234f, 0.04156156f, -0.10366896f, 
    -0.01254224f, -0.03271393f, -0.05781185f, -0.06240442f, -0.03751199f, 0.29280287f, 0.33791631f, -0.11545853f, 
    -0.02322588f, 0.02845725f, 0.05587474f, 0.03509617f, 0.04450479f, 0.28442067f, -0.00063583f, -0.05426511f, 
    0.09776865f, 0.20163906f, -0.14367923f, -0.12678519f, 0.14740053f, -0.10042774f, 0.11380980f, -0.02699354f, 
    -0.03854283f, -0.09538904f, -0.05596665f, -0.00975004f, 0.49668396f, 0.05415542f, -0.02745707f, -0.18718976f, 
    0.17801459f, 0.05587429f, -0.13893081f, -0.00769805f, 0.04765887f, -0.07186058f, 0.06176529f, -0.00917900f, 
    0.09134533f, 0.04322531f, 0.00144185f, -0.23093398f, 0.07535386f, 0.03181250f, 0.16288583f, -0.13972323f, 
    -0.05673252f, -0.07835298f, 0.00648391f, 0.08714961f, -0.16557354f, 0.04414339f, -0.16562718f, -0.08815522f, 
    -0.07495761f, -0.06009984f, 0.14187598f, -0.10229035f, 0.03477831f, -0.02427689f, -0.06965051f, 0.10128073f, 
    0.20333628f, -0.09266850f, -0.13417608f, 0.06056837f, -0.04450909f, -0.04410252f, 0.11021937f, 0.02689898f, 
    0.11319574f, 0.09236455f, -0.01099661f, -0.01841794f, 0.05839641f, 0.12754408f, -0.06481569f, -0.00063116f, 
    0.05663485f, 0.01547767f, 0.11090644f, 0.06207441f, -0.12430682f, -0.19464789f, 0.08146002f, -0.14935862f, 
    0.14862752f, 0.00954275f, -0.04376902f, -0.05383386f, -0.07368619f, -0.18401201f, 0.11901496f, 0.00497793f, 
    0.02872395f, 0.02621234f, 0.03658191f, -0.01518558f, 0.09225690f, 0.15482479f, -0.09630185f, -0.02418948f, 
    -0.08525917f, -0.20603502f, 0.07750557f, 0.06889647f, 0.09230635f, 0.00099443f, -0.08560085f, -0.04297604f, 
    -0.05808126f, -0.68455380f, 0.28357583f, -0.11170542f, 0.23419863f, -0.01813282f, -0.10205013f, -0.00102880f, 
    -0.01018701f, -0.02530034f, -0.05455177f, 0.12935433f, -0.07198254f, 0.17847890f, 0.05677148f, 0.00073006f, 
    -0.02379679f, -0.07640806f, -0.09295215f, -0.12557831f, 0.14887255f, -0.04170505f, -0.07606217f, 0.00804955f, 
    0.30929771f, 0.00694620f, -0.06025145f, -0.10014033f, 0.00869974f, -0.07739606f, 0.01396004f, -0.04112864f, 
    0.04608012f, 0.07941142f, 0.00373116f, -0.00988634f, -0.17778121f, -0.11015729f, 0.08660030f, 0.02276586f, 
    0.06587453f, -0.02746902f, -0.00233048f, 0.11067937f, -0.03611371f, -0.00310876f, -0.03294804f, 0.02784598f, 
    0.07553017f, 0.17892866f, 0.06184024f, -0.10457127f, 0.10246789f, 0.13137442f, -0.12443507f, -0.09556897f, 
    0.06666202f, 0.04586043f, 0.06397835f, -0.08702491f, -0.52305275f, 0.04014130f, 0.02224875f, 0.06220109f, 
    -0.20336320f, -0.20211598f, 0.00434081f, 0.10394470f, 0.17292601f, -0.09204444f, 0.18244246f, 0.02305375f, 
    0.29095221f, -0.61327004f, 0.29577512f, 0.00046622f, -0.17423853f, 0.07246718f, -0.07117840f, 0.02126285f, 
    0.17965305f, -0.09449933f, 0.03966840f, -0.10530102f, -0.10231163f, 0.12573363f, 0.18942082f, -0.00465589f, 
    -0.01451567f, -0.00353791f, -0.00136442f, 0.05836508f, 0.04638831f, 0.05014454f, 0.04671069f, -0.02602202f, 
    0.04203158f, -0.00596855f, -0.37591156f, -0.12054034f, -0.01682282f, 0.14978677f, -0.03009329f, 0.14261156f, 
    0.02430105f, 0.10389084f, 0.00459991f, -0.07242779f, 0.18439998f, -0.09237987f, -0.23001340f, 0.00063040f, 
    0.02104779f, 0.05950661f, -0.10801233f, -0.06451415f, 0.03094736f, 0.08824058f, 0.06779827f, -0.02835475f, 
    0.01193904f, -0.00775868f, -0.01985745f, -0.20215350f, 0.11981846f, -0.00028787f, -0.18126105f, -0.01108019f, 
    -0.05192125f, 0.05877697f, -0.11406624f, 0.02637483f, -0.01980189f, 0.18419366f, -0.27406931f, 0.06525863f, 
    0.12368459f, -0.04654973f, -0.18179257f, 0.06065604f, 0.23431230f, 0.18530048f, -0.11657656f, -0.14466788f, 
    0.03984768f, 0.00150918f, -0.05663575f, -0.05602210f, 0.07146535f, 0.06834767f, 0.00217959f, 0.03130922f, 
    -0.16455072f, -0.10330110f, -0.10551588f, 0.33246297f, -0.15044956f, 0.05843648f, 0.08548904f, 0.07490560f, 
    -0.03812303f, -0.03345510f, 0.13342416f, -0.07882313f, 0.04636414f, -0.00236274f, 0.04930409f, 0.05435070f, 
    0.23780559f, -0.06562940f, -0.11365070f, 0.05371305f, -0.06448241f, 0.14390194f, -0.07336961f, -0.10962243f, 
    -0.00389751f, -0.24099174f, 0.01131440f, -0.07088216f, -0.05080834f, -0.05578123f, 0.09253676f, 0.10193319f, 
    -0.14669836f, 0.05460631f, -0.08900061f, 0.03268704f, 0.11222174f, 0.05289248f, 0.18688920f, -0.08663695f, 
    -0.09238897f, -0.03145183f, 0.00786525f, 0.03803771f, -0.00344793f, 0.09670109f, 0.15918170f, 0.11245265f, 
    -0.03046287f, -0.00067655f, -0.02041670f, -0.01018321f, 0.04030590f, 0.15560053f, 0.15379031f, 0.09308819f, 
    -0.01393585f, -0.09558235f, 0.00408571f, 0.06524877f, 0.04547985f, 0.10100894f, 0.09335312f, 0.02164778f, 
    -0.01736310f, -0.10189006f, -0.10340837f, 0.13710028f, 0.13836545f, -0.09477685f, 0.14144005f, 0.02973847f, 
    0.05837797f, -0.06384166f, 0.02524727f, 0.08447661f, -0.09438989f, 0.16146481f, -0.16786593f, 0.10252094f, 
    0.00852627f, -0.00337092f, -0.04057736f, 0.04542750f, 0.03182354f, 0.09099052f, -0.17937571f, 0.13413800f, 
    0.04548758f, 0.18585652f, -0.40376520f, -0.06165842f, 0.16388635f, -0.02161347f, 0.14873083f, -0.07571477f, 
    0.05104273f, -0.03145177f, -0.03269705f, 0.05852650f, 0.17109151f, -0.31310844f, 0.19171824f, 0.13435997f, 
    -0.03242355f, 0.10697907f, 0.07346951f, 0.02803776f, 0.07363103f, 0.11739206f, -0.24770693f, -0.00968081f, 
    0.17778862f, 0.08297446f, -0.15872861f, -0.10647959f, 0.01400135f, 0.02532522f, 0.15904841f, 0.03389165f, 
    0.09262660f, -0.07711107f, -0.03348459f, 0.12336988f, -0.18381438f, -0.02920702f, -0.02642807f, -0.01140266f, 
    0.03302521f, 0.04803558f, 0.05292479f, 0.01394016f, -0.08982561f, -0.04633566f, -0.08470178f, 0.02598277f, 
    -0.11358821f, -0.03588966f, 0.10161263f, 0.05651386f, 0.03346118f, -0.03459484f, 0.00996433f, 0.08680332f, 
    -0.13458388f, -0.03691058f, 0.00764303f, 0.01610888f, 0.35674816f, -0.06034811f, -0.04963809f, 0.02038275f, 
    0.05976914f, -0.04133152f, -0.00096132f, -0.08087137f, 0.03765809f, 0.09173851f, -0.11696391f, 0.06512093f, 
    0.00192185f, 0.21457465f, 0.08966761f, 0.06338182f, -0.07611403f, 0.09141480f, 0.12476460f, -0.05311830f, 
    0.02733642f, 0.06644236f, 0.04326713f, 0.01977181f, 0.60219336f, 0.13625297f, -0.07709200f, -0.13433303f, 
    0.03476689f, 0.08999947f, -0.15635544f, 0.05572412f, 0.01236763f, -0.19850633f, -0.00851877f, -0.10885640f, 
    -0.06412441f, 0.19979982f, 0.11535406f, 0.21317984f, -0.12940896f, -0.10311082f, 0.05767327f, -0.21104045f, 
    0.07767704f, -0.07536598f, 0.02356717f, 0.01414679f, -0.02887742f, -0.05442963f, 0.21847685f, 0.38562536f, 
    -0.14050335f, -0.00648409f, 0.00988526f, 0.06234569f, -0.03808630f, -0.08742377f, 0.04598072f, 0.18764652f, 
    -0.10699853f, -0.08941142f, 0.04427272f, 0.06725375f, -0.05671152f, -0.00083310f, 0.03132236f, 0.12994087f, 
    0.02761043f, -0.09098847f, -0.03006372f, -0.00834447f, 0.14840370f, 0.02425088f, 0.04375668f, -0.03267188f, 
    0.00437928f, -0.05856788f, -0.00816565f, 0.00476560f, -0.00024622f, -0.04512753f, 0.02469085f, -0.03273665f, 
    0.03671365f, 0.03530492f, -0.23576853f, -0.10211591f, -0.10171464f, 0.15917127f, 0.05353113f, -0.00048435f, 
    0.06440602f, 0.07502095f, 0.07717550f, 0.07239147f, -0.04171703f, 0.17467403f, 0.03198991f, 0.01059696f, 
    -0.06932855f, 0.10945618f, -0.20681086f, 0.05998275f, -0.08774071f, -0.01179461f, 0.06929985f, 0.07411848f, 
    -0.00758053f, 0.00107165f, -0.02226469f, 0.02509986f, -0.01529587f, 0.00898625f, -0.00126891f, -0.00668548f, 
    0.02068630f, -0.03831313f, -0.04370278f, 0.00864454f, 0.01313502f, 0.00796904f, -0.03519294f, 0.01841514f, 
    -0.03045974f, -0.00860487f, -0.00842898f, -0.01854972f, 0.02726467f, 0.01150933f, -0.04244360f, -0.00561105f, 
    -0.04333806f, -0.02957737f, -0.01488376f, 0.02587040f, -0.01616973f, 0.01242361f, -0.03084628f, -0.03424549f, 
    -0.02721104f, 0.00536102f, 0.03126713f, -0.00229382f, -0.02738271f, 0.03063089f, 0.02890586f, -0.03239145f, 
    -0.02183332f, -0.01916412f, -0.01106855f, 0.00878482f, -0.02102780f, 0.02219237f, -0.01916868f, -0.00297372f, 
    0.02335873f, 0.03748794f, -0.00592923f, 0.03105282f, -0.02432442f, 0.02882404f, -0.03024457f, -0.00386624f, 
    -0.02488168f, -0.02970884f, 0.00572166f, -0.02010898f, -0.00762114f, -0.00338540f, 0.03217902f, 0.00125174f, 
    -0.01557161f, -0.02468606f, 0.02049007f, -0.03236795f, -0.03178343f, -0.02963660f, -0.01003507f, 0.00513390f, 
    -0.02842897f, -0.01786269f, -0.01312246f, 0.00169252f, 0.00459706f, -0.03298284f, 0.02233031f, -0.00719952f, 
    -0.00710781f, 0.00532961f, 0.01389479f, -0.03047115f, 0.01072071f, 0.01512765f, 0.01640226f, -0.00313149f, 
    0.00936505f, -0.02044577f, -0.03307180f, 0.02832581f, -0.02459025f, 0.01066854f, -0.02116329f, 0.00603661f, 
    -0.04077898f, 0.01297813f, -0.02038220f, -0.00315883f, 0.00903903f, 0.00006804f, -0.02762949f, -0.02712771f, 
    0.02443897f, -0.01294416f, 0.01039016f, 0.02127611f, -0.00131595f, 0.02345003f, -0.01286741f, -0.00023293f, 
    -0.01636242f, 0.00519754f, 0.02681718f, 0.01851763f, -0.00581812f, -0.02350353f, -0.02497671f, -0.02780304f, 
    -0.01910489f, 0.01556938f, 0.03023561f, -0.00642687f, 0.01626535f, -0.00744190f, 0.01840208f, -0.03276253f, 
    -0.00740076f, 0.01036703f, 0.01287265f, -0.03063838f, -0.03959660f, 0.00455436f, 0.01130721f, -0.01822475f, 
    -0.02422791f, -0.03911209f, -0.03109444f, -0.03493605f, -0.02401341f, 0.00228959f, -0.01155667f, 0.01043393f, 
    -0.02049956f, -0.01790712f, 0.00804613f, -0.03213513f, -0.01671685f, -0.03494577f, -0.03252771f, -0.00834932f, 
    0.00445537f, -0.04126512f, -0.01574525f, -0.01487307f, -0.01563278f, -0.02293248f, -0.03781829f, -0.01615359f, 
    -0.00515863f, 0.01233849f, -0.01900122f, -0.03234166f, -0.01816207f, -0.02126449f, 0.01460177f, -0.00755109f, 
    0.00446670f, -0.00761802f, -0.02431150f, -0.04195176f, 0.02536415f, -0.03522601f, -0.03375590f, 0.00300105f, 
    0.02367006f, -0.00912383f, 0.00818386f, -0.01125051f, 0.02877560f, 0.00956277f, 0.01098952f, 0.00743889f, 
    0.00894381f, -0.00448925f, 0.02530440f, -0.03179383f, -0.00108066f, -0.02492354f, -0.01931532f, -0.01421147f, 
    0.01284741f, -0.01162297f, -0.02290922f, -0.00559696f, -0.03426791f, -0.00237781f, -0.02312359f, -0.01343533f, 
    -0.01510245f, 0.01733314f, -0.01909839f, 0.01139053f, -0.02438081f, -0.02948600f, -0.00926927f, -0.00535070f, 
    0.03228262f, 0.01363666f, 0.02717126f, -0.02107303f, -0.02339017f, -0.03565380f, 0.02756553f, -0.03402765f, 
    0.01473545f, -0.01914528f, -0.01895892f, 0.01923165f, -0.00359624f, -0.00960544f, 0.00054459f, -0.00513191f, 
    -0.02639269f, 0.02188700f, 0.01028580f, 0.02202210f, -0.03996487f, 0.02750106f, -0.01707227f, -0.01986639f, 
    -0.03094461f, -0.00368966f, 0.01808315f, 0.02163705f, -0.01601107f, -0.00653114f, 0.01191388f, 0.02152373f, 
    -0.01420646f, 0.01952289f, -0.01579478f, -0.03758237f, 0.00814722f, 0.00257379f, 0.02910977f, 0.02157801f, 
    -0.00624238f, -0.03943196f, 0.02588999f, 0.01689610f, 0.00231595f, -0.03015557f, 0.02747627f, -0.00094269f, 
    -0.01799170f, -0.04206643f, -0.00221971f, -0.03176580f, -0.03554624f, -0.02708488f, -0.01240661f, -0.02851055f, 
    -0.03768231f, 0.00143225f, -0.02992131f, 0.03243431f, -0.04365952f, 0.01413684f, -0.00253133f, -0.00823104f, 
    0.03202084f, -0.00303520f, 0.00759748f, 0.00675035f, -0.00332871f, 0.00564630f, -0.04051933f, -0.02353330f, 
    -0.02217937f, 0.01642377f, 0.02464662f, 0.01152832f, -0.00422473f, 0.01816412f, -0.00068631f, -0.01758474f, 
    0.01177120f, 0.01013795f, -0.01879563f, 0.01270289f, 0.00894076f, 0.02491481f, -0.02222544f, 0.01286250f, 
    -0.03822130f, 0.01651503f, -0.03597040f, -0.03256157f, -0.00535616f, 0.01861794f, -0.04334453f, 0.00770089f, 
    0.02477526f, 0.00998369f, 0.02357916f, -0.01900401f, -0.01651802f, -0.02707704f, -0.02261658f, -0.01692794f, 
    -0.00075977f, 0.02747999f, 0.00257772f, 0.01909876f, -0.03516648f, -0.00204636f, 0.00824036f, -0.02139751f, 
    -0.01058593f, -0.01952049f, 0.01866547f, -0.03039657f, 0.00460144f, -0.01670519f, 0.02361086f, -0.00764879f, 
    0.01601519f, -0.02366593f, -0.03933721f, 0.02407261f, -0.01370905f, -0.02770204f, -0.03922342f, -0.02320596f, 
    -0.01752694f, -0.02821523f, -0.02665254f, 0.01005925f, -0.00235488f, 0.01746361f, -0.01796080f, 0.01508605f, 
    -0.00413056f, 0.01062422f, -0.02964764f, 0.01982394f, 0.01352100f, -0.03730767f, -0.00848877f, 0.01615100f, 
    -0.00569909f, 0.01070680f, -0.01540008f, 0.02432700f, -0.02123940f, 0.02151693f, -0.01548632f, -0.00726144f, 
    -0.01255990f, -0.00352035f, -0.02140852f, 0.00557063f, -0.04076594f, 0.00786063f, -0.00042254f, -0.02046872f, 
    0.01690396f, -0.02244333f, 0.00151716f, -0.02452922f, -0.04006186f, -0.03012322f, 0.01548256f, 0.02673581f, 
    0.00418304f, 0.01080665f, -0.00714080f, -0.01109986f, 0.01433017f, -0.00038348f, 0.00538531f, -0.00404959f, 
    0.01841121f, 0.00109742f, 0.00728879f, -0.01163041f, 0.00196488f, 0.01703909f, -0.03629752f, -0.01532365f, 
    -0.00995488f, 0.02914583f, -0.02575272f, -0.00740361f, -0.02569898f, 0.02384130f, -0.01147687f, 0.01850372f, 
    -0.03495237f, 0.00931480f, 0.01973832f, -0.03222533f, 0.01950566f, -0.01270972f, 0.00326633f, -0.00747338f, 
    0.01681295f, -0.02402533f, -0.01278431f, -0.02659520f, -0.00680194f, -0.02890812f, -0.03673786f, 0.00926240f, 
    0.00337621f, -0.02899701f, -0.00722341f, 0.02517157f, 0.00860279f, 0.01533172f, 0.04342258f, 0.00214146f, 
    0.00895264f, 0.02300771f, -0.01430927f, 0.01645524f, -0.00694773f, -0.00227527f, 0.00446623f, -0.00699267f, 
    -0.00575603f, -0.00698400f, 0.02856503f, -0.00959340f, -0.00062538f, -0.00320935f, -0.02932839f, -0.00302300f, 
    -0.02048586f, 0.00786105f, -0.03066152f, 0.02386559f, -0.01448156f, 0.00200000f, -0.00067003f, 0.01922816f, 
    0.01749465f, -0.00572087f, -0.03829557f, -0.01558959f, -0.04062689f, -0.02059781f, 0.02870535f, 0.02759243f, 
    -0.03111460f, -0.01549190f, -0.01332127f, 0.02163842f, -0.03192195f, 0.00779675f, 0.01610145f, -0.01049477f, 
    -0.02007482f, 0.00422248f, 0.01178984f, -0.02621695f, -0.03177121f, -0.01707098f, -0.00911193f, -0.03351212f, 
    -0.03624535f, 0.02126730f, 0.00391394f, -0.00599378f, -0.02767666f, 0.02958229f, -0.00657095f, 0.00600166f, 
    -0.03346028f, 0.02194645f, -0.02405565f, 0.02498667f, 0.00599707f, -0.01754479f, -0.03688364f, 0.02939744f, 
    -0.02874241f, -0.02775989f, 0.00905529f, -0.01210526f, -0.02547581f, -0.03935852f, -0.00408699f, 0.00598182f, 
    0.00251116f, 0.01315525f, -0.01683714f, -0.01119345f, -0.02788861f, 0.02505010f, 0.01099109f, -0.03215014f, 
    -0.02636292f, 0.00567337f, 0.02552992f, 0.03061515f, 0.01210312f, 0.00884831f, -0.01771599f, -0.00805288f, 
    0.00305981f, 0.02128939f, 0.00045379f, -0.01674886f, 0.00972500f, -0.02602837f, 0.01621949f, -0.01896855f, 
    -0.00007851f, 0.03565701f, 0.02016901f, -0.01712774f, -0.01311136f, -0.01748382f, -0.00836088f, 0.01548437f, 
    -0.03646234f, 0.02387461f, 0.01458376f, 0.02351288f, 0.00637580f, -0.00608283f, 0.00151178f, -0.00632320f, 
    -0.01904916f, -0.02964283f, 0.02465213f, 0.01716774f, 0.01250180f, 0.01530293f, 0.02624379f, -0.03060767f, 
    0.02745770f, -0.01498191f, 0.00657726f, -0.01317276f, 0.01447505f, 0.03009210f, -0.02797943f, -0.01798838f, 
    -0.00397220f, 0.01216479f, -0.01108695f, -0.02841598f, 0.00666157f, 0.01974527f, -0.03354441f, 0.02230218f, 
    0.00758013f, -0.00316291f, -0.01780195f, -0.00536943f, -0.00826692f, 0.02348696f, -0.03105924f, 0.01760921f, 
    0.03389276f, 0.01233263f, 0.01465333f, 0.01609450f, -0.04236719f, 0.01639931f, 0.00405948f, 0.01036245f, 
    0.03359380f, 0.01975050f, 0.00100713f, -0.02633829f, -0.03707137f, 0.01230901f, -0.02418128f, -0.02879553f, 
    -0.02656239f, 0.01211295f, -0.02821662f, -0.02570014f, -0.00988972f, 0.00584236f, -0.02669546f, 0.02809518f, 
    0.00090146f, -0.03548373f, 0.02093662f, -0.00033356f, -0.00619043f, -0.01383560f, -0.02262196f, 0.01504127f, 
    0.00114421f, 0.01547749f, -0.00957439f, -0.02721872f, 0.01571988f, 0.00808728f, -0.00835837f, 0.01157363f, 
    -0.03233796f, -0.00956580f, 0.00990977f, -0.02360494f, -0.03840990f, 0.00856996f, -0.02614489f, -0.02602730f, 
    -0.03388721f, -0.03933829f, -0.02324196f, -0.00156441f, 0.01212081f, -0.02014259f, -0.00441461f, 0.02382728f, 
    0.01213633f, -0.00732477f, 0.00426051f, 0.00733690f, -0.02732234f, 0.00592947f, -0.01406336f, -0.03838138f, 
    -0.01978881f, 0.01768700f, -0.03883050f, 0.01906910f, -0.01815165f, -0.01889625f, -0.02701510f, -0.01852305f, 
    -0.02011638f, -0.00644365f, 0.01868250f, -0.01374031f, 0.01834156f, 0.01337378f, 0.01874275f, -0.03708395f, 
    -0.03795025f, -0.00012363f, -0.00095793f, -0.01730793f, 0.00576024f, 0.02375004f, -0.00454153f, 0.03280860f, 
    0.02257954f, 0.00793751f, 0.02707643f, 0.00813597f, -0.02325773f, 0.00682440f, 0.02209684f, 0.02705128f, 
    0.01905645f, -0.02826050f, 0.00591902f, 0.01963842f, 0.02854359f, -0.02593408f, 0.02157574f, 0.00287149f, 
    0.02279918f, 0.02552248f, -0.01985864f, -0.03478117f, -0.01688593f, -0.03612342f, -0.00679102f, -0.02731560f, 
    0.00865591f, -0.01251829f, 0.01749078f, -0.01166701f, -0.00718072f, -0.02470688f, -0.01133668f, -0.00509980f, 
    -0.00530001f, -0.03189157f, -0.01550554f, -0.01133783f, 0.02326303f, -0.03972757f, 0.01454488f, -0.01978416f, 
    0.03124327f, -0.02541685f, 0.01581950f, 0.02271431f, 0.02033826f, 0.03517291f, -0.02639107f, -0.03074269f, 
    -0.03498264f, 0.00528456f, 0.01331616f, -0.03522100f, -0.02153480f, -0.02498768f, -0.03057518f, -0.00150175f, 
    -0.04103979f, -0.02580200f, -0.03200227f, 0.01986699f, 0.01333838f, -0.03337136f, 0.00652314f, 0.02291246f, 
    -0.01207465f, -0.02600083f, 0.02266694f, -0.02649188f, -0.02233988f, 0.01496940f, -0.02172288f, 0.02034506f, 
    -0.01554491f, -0.02472450f, 0.02884989f, 0.01343036f, -0.01791558f, -0.00767814f, 0.00091358f, 0.00830957f, 
    0.00599239f, 0.01654523f, -0.01457739f, 0.02720412f, -0.01127624f, -0.00372699f, 0.00849794f, -0.01027953f, 
    -0.00500123f, 0.02222294f, -0.02401172f, 0.01801107f, 0.02216621f, -0.03834901f, 0.01903935f, -0.02726400f, 
    0.00544676f, 0.01674169f, -0.03250720f, -0.01597210f, -0.04266430f, 0.02097477f, -0.02032533f, 0.00909920f, 
    -0.01633607f, 0.00261183f, 0.00181217f, -0.02212390f, -0.02453985f, 0.01451976f, -0.01814366f, 0.02168180f, 
    0.46649414f, 0.03547503f, -0.19286102f, -0.12394504f, 0.02043581f, 0.08095788f, -0.07706427f, 0.03333051f, 
    -0.05501672f, -0.02222225f, -0.17641823f, -0.00822047f, -0.12638471f, 0.31417346f, 0.25386220f, 0.07237621f, 
    -0.17705122f, -0.08326150f, -0.13019262f, -0.20857294f, 0.08924274f, 0.01175621f, 0.11991076f, 0.05867110f, 
    0.13745940f, -0.01484699f, 0.00202210f, 0.08267182f, 0.02908115f, 0.00618456f, 0.06164780f, 0.12181551f, 
    -0.03535357f, 0.21269880f, -0.12167659f, 0.05770318f, -0.26519346f, 0.43006995f, 0.34919918f, 0.20959346f, 
    0.02440486f, -0.02824738f, -0.03223233f, -0.01356971f, -0.07517251f, 0.04265745f, 0.04880413f, -0.11463659f, 
    -0.07117859f, -0.18443415f, -0.00128167f, 0.05886880f, -0.12790440f, -0.17930636f, -0.05827975f, -0.02041921f, 
    -0.00681213f, 0.05070872f, 0.13857086f, -0.09442588f, 0.01986934f, 0.12538286f, 0.07368930f, 0.15775615f, 
    -0.04488662f, -0.06990585f, 0.07319956f, 0.02572381f, -0.01808398f, -0.24058305f, 0.12041153f, 0.16672286f, 
    -0.24715599f, 0.01235077f, 0.47434905f, 0.04255727f, -0.05480324f, 0.07606677f, -0.02480564f, -0.02740933f, 
    0.07620800f, 0.00261650f, 0.30214542f, 0.16320197f, -0.08847626f, -0.12992276f, -0.13227130f, -0.00946140f, 
    0.02612103f, 0.02761625f, 0.01915463f, 0.01225039f, -0.06808865f, -0.02535417f, 0.05127684f, -0.19764765f, 
    -0.03912446f, -0.02995599f, -0.06964000f, 0.20143940f, -0.05765513f, -0.01447233f, -0.03127407f, 0.03735269f, 
    0.01854854f, 0.23558272f, 0.13156502f, 0.10259897f, 0.05989072f, 0.11966704f, -0.08599764f, 0.04517563f, 
    -0.01599987f, 0.12425479f, 0.01470645f, -0.10005531f, -0.03741001f, -0.11430430f, 0.02923075f, 0.04123165f, 
    -0.18538974f, -0.04692980f, -0.00214485f, -0.19686601f, -0.22289829f, -0.04167713f, 0.00985755f, -0.07272810f, 
    0.08868800f, -0.01043486f, 0.05559704f, 0.02827733f, 0.21757573f, 0.03302640f, 0.02090924f, -0.10850437f, 
    0.08973399f, -0.03067266f, 0.20127302f, -0.09434003f, 0.10546561f, 0.09283551f, -0.21243842f, 0.01474710f, 
    0.03763524f, -0.13088402f, 0.14660376f, 0.19216755f, 0.01569774f, 0.09657943f, 0.02852783f, -0.00970382f, 
    -0.00305255f, -0.03992869f, 0.02926406f, 0.00839633f, 0.07429121f, -0.01463013f, -0.14532584f, 0.19846380f, 
    -0.05279915f, 0.00518927f, -0.00589709f, 0.01083125f, 0.06071785f, 0.00833831f, -0.06659248f, 0.09198661f, 
    0.35832560f, 0.05446516f, 0.08143491f, -0.50784600f, -0.00171473f, -0.06706575f, 0.06584454f, 0.05159669f, 
    0.10314331f, 0.35285911f, -0.01523359f, -0.14995614f, -0.34810761f, -0.29545653f, 0.44746518f, 0.37725765f, 
    0.22332884f, -0.00881013f, -0.12860176f, 0.09731108f, 0.11300851f, -0.02873705f, 0.09248047f, -0.06060686f, 
    0.17714277f, 0.23737018f, -0.18706051f, 0.07869979f, 0.06666581f, 0.11244569f, 0.02923044f, 0.05970751f, 
    -0.04143409f, -0.06988650f, 0.08777958f, 0.02088175f, -0.19208671f, 0.06167924f, -0.15031494f, -0.11220645f, 
    0.21309420f, 0.09782103f, -0.16131872f, 0.19885245f, 0.12807433f, 0.19085357f, -0.39697915f, 0.10673670f, 
    -0.16035642f, 0.36414191f, 0.25462350f, 0.04926170f, -0.10296311f, -0.10941605f, 0.05367054f, -0.02407329f, 
    -0.10139606f, -0.00871230f, -0.20506077f, 0.11558641f, 0.11044338f, 0.03877775f, -0.08251940f, -0.02114014f, 
    0.14590977f, 0.04724968f, 0.19509220f, -0.03737849f, -0.05640322f, -0.03062275f, -0.00075353f, -0.01215401f, 
    -0.11018584f, -0.13586634f, -0.05140744f, -0.01601516f, -0.14837261f, -0.14951548f, -0.01172963f, -0.15244524f, 
    0.04584884f, 0.25094160f, -0.09897731f, -0.04414452f, -0.00675062f, -0.06317362f, -0.05221984f, 0.40325165f, 
    -0.08131006f, -0.16859044f, -0.12499734f, 0.09953820f, 0.01698503f, -0.14133348f, -0.01921757f, 0.04687634f, 
    -0.01191965f, -0.05609135f, -0.01408354f, -0.03343265f, -0.04638694f, -0.07850010f, -0.17397964f, -0.04549344f, 
    0.11653899f, 0.04315292f, -0.01043355f, 0.03612075f, 0.11903141f, 0.02482340f, -0.04222043f, -0.09202799f, 
    -0.10374389f, -0.20492114f, 0.41830552f, -0.04956885f, -0.02956502f, 0.02125107f, -0.17039789f, 0.00035190f, 
    0.03229453f, 0.01758833f, 0.11455646f, -0.36550561f, 0.03889746f, -0.04013670f, -0.09156066f, -0.16552031f, 
    -0.04866028f, 0.12948030f, 0.20940523f, 0.15550162f, -0.16362424f, -0.34483111f, -0.18385881f, 0.06347506f, 
    0.07727487f, -0.25651783f, 0.05350981f, -0.09076236f, 0.03384162f, -0.10841826f, 0.04463817f, -0.14419252f, 
    0.19260612f, 0.00327777f, 0.09008621f, -0.02942331f, 0.03200694f, 0.01942437f, 0.03281875f, -0.03484375f, 
    0.08560840f, 0.01380699f, -0.05631381f, -0.03861840f, 0.04860675f, 0.02087497f, 0.20504087f, -0.19103201f, 
    0.01613859f, -0.08947631f, 0.00776744f, 0.04323030f, 0.02195939f, 0.16860226f, 0.25167871f, 0.19134922f, 
    0.05294820f, 0.13311951f, 0.07911544f, 0.01609929f, 0.15426491f, 0.12671860f, -0.02152430f, 0.18306321f, 
    0.00752034f, 0.00358145f, -0.11550221f, -0.10626255f, -0.00513125f, 0.07204834f, -0.00671930f, 0.02885365f, 
    0.21868928f, -0.01734945f, -0.06955810f, 0.11374071f, -0.20017794f, -0.11700749f, -0.22216955f, -0.16471131f, 
    -0.11692952f, 0.05375997f, -0.14499278f, 0.08435427f, 0.31114733f, 0.04634960f, -0.08846170f, -0.03191246f, 
    -0.01958114f, 0.00438914f, -0.05517817f, 0.00895537f, 0.02054541f, 0.39410824f, 0.11411826f, 0.15760401f, 
    -0.10124143f, -0.01223047f, 0.03920918f, -0.11429572f, 0.07926856f, 0.16464293f, 0.16324051f, 0.24382766f, 
    0.13832170f, 0.12576376f, -0.00005125f, -0.15261602f, -0.02264059f, 0.05001858f, -0.00609431f, -0.20408595f, 
    0.11024249f, 0.11664310f, -0.15725237f, 0.09108932f, -0.14055976f, -0.05087424f, 0.09793910f, -0.05791860f, 
    -0.24976957f, -0.07098573f, -0.06171314f, -0.03605195f, 0.02956948f, -0.08381820f, -0.00532794f, -0.03308339f, 
    -0.10843470f, -0.06436228f, 0.44734019f, 0.02067406f, -0.10078161f, -0.09415343f, 0.22653385f, -0.01616323f, 
    -0.04273372f, -0.17489989f, 0.22661850f, 0.14140287f, -0.34415936f, -0.09536170f, 0.17890455f, 0.29915920f, 
    0.07154672f, 0.05086935f, -0.05900139f, 0.00885879f, -0.07408976f, -0.10149711f, 0.12846318f, -0.00348586f, 
    0.03622654f, -0.14547326f, -0.12802568f, 0.13497511f, -0.00589619f, 0.29872489f, 0.07268874f, 0.06118215f, 
    0.01763632f, 0.22197744f, -0.01993446f, 0.10135277f, -0.11675381f, 0.08753182f, 0.32546195f, -0.03476726f, 
    -0.15724950f, -0.03296466f, -0.04978165f, -0.00789061f, -0.02548981f, 0.08578773f, 0.03242852f, 0.14715870f, 
    0.27310583f, -0.12222497f, -0.03143917f, -0.12803084f, -0.00632188f, 0.02202825f, 0.23305491f, -0.07317126f, 
    -0.03752495f, -0.02150234f, -0.00366992f, -0.01299646f, 0.05752127f, 0.04365535f, 0.00492728f, 0.01358095f, 
    -0.06356366f, 0.00239119f, 0.16144750f, 0.08717967f, 0.03032583f, -0.06565128f, -0.08150430f, 0.04172000f, 
    -0.02389239f, 0.23793642f, 0.36507085f, -0.36667612f, -0.07279565f, 0.03028814f, 0.01154738f, -0.13501751f, 
    0.03851780f, -0.11213426f, 0.21184084f, -0.08644382f, 0.20039029f, -0.13147944f, 0.04675276f, -0.28177217f, 
    0.06718790f, 0.20377778f, 0.04551269f, 0.08280005f, 0.01417663f, 0.04356253f, -0.08895293f, -0.06536356f, 
    -0.01992279f, 0.11543368f, -0.01812418f, -0.00538507f, -0.12899548f, 0.07309959f, -0.04989339f, 0.00073248f, 
    0.23461288f, -0.13801527f, 0.08349344f, 0.06369740f, -0.17896158f, -0.00307109f, 0.19293050f, 0.02955139f, 
    0.02819251f, -0.13020869f, -0.09024707f, -0.00422748f, -0.09252191f, -0.06654865f, 0.00547497f, -0.08909248f, 
    0.21102950f, -0.06569374f, -0.02185121f, -0.30236199f, 0.10133664f, -0.01653448f, 0.20627706f, 0.09171412f, 
    0.13340209f, 0.11220884f, 0.17013495f, 0.08666330f, -0.02800848f, -0.06491347f, -0.01228323f, 0.33879098f, 
    0.02375730f, -0.12893744f, -0.05505931f, -0.13228278f, 0.02732406f, 0.09018348f, -0.16082135f, -0.02043388f, 
    0.04424249f, -0.04372792f, 0.01649222f, 0.03456075f, 0.05851854f, -0.08667964f, -0.08950416f, 0.06107967f, 
    -0.00472244f, -0.14574656f, -0.06870346f, -0.00121837f, -0.08761827f, 0.00874446f, 0.23803657f, -0.17240654f, 
    -0.26626116f, -0.22428459f, -0.00021033f, -0.13297056f, -0.04266680f, -0.02321600f, -0.05312891f, -0.10810095f, 
    -0.00317357f, -0.04634908f, -0.07915909f, -0.01865647f, 0.00547995f, 0.22367528f, -0.05898259f, 0.07671278f, 
    -0.00292453f, -0.04595516f, -0.06633596f, -0.08612221f, 0.01689215f, -0.10131013f, 0.15700746f, -0.04523853f, 
    0.07690562f, -0.02641764f, -0.07929938f, 0.07619134f, 0.10192237f, 0.16670865f, -0.01723322f, -0.11682612f, 
    0.47262248f, -0.04548271f, 0.20519492f, -0.34360892f, 0.07677003f, 0.02524241f, 0.05713332f, 0.02718125f, 
    -0.06565967f, 0.03283424f, -0.10811957f, -0.10236254f, 0.05314329f, -0.21710835f, -0.02331044f, 0.01501236f, 
    0.07109433f, -0.00370986f, 0.20616302f, -0.02700584f, 0.15582997f, 0.09227215f, 0.20813586f, -0.02205012f, 
    -0.01486146f, -0.06223123f, 0.14340635f, -0.00896209f, 0.16828844f, 0.06370044f, -0.10984297f, 0.03739313f, 
    0.06430438f, -0.05382710f, 0.03535010f, 0.16712074f, -0.02472846f, 0.08122337f, -0.00921952f, -0.06035567f, 
    0.15017349f, 0.08845998f, 0.00114629f, -0.03483808f, 0.08245350f, 0.18266159f, 0.34282878f, 0.19208881f, 
    0.07792343f, 0.05733279f, -0.11256896f, 0.12535678f, -0.06680734f, -0.01927416f, 0.24171448f, -0.00144060f, 
    0.09040972f, 0.03388974f, -0.09415717f, -0.00557030f, 0.20362361f, 0.10547350f, 0.21111603f, -0.07286172f, 
    -0.01384418f, -0.01368695f, 0.01291627f, 0.09546734f, -0.08716065f, -0.03251810f, -0.08440194f, -0.20523015f, 
    -0.01641590f, 0.17793900f, 0.14260572f, -0.13108505f, -0.17779368f, -0.00461172f, 0.07971494f, -0.20298657f, 
    0.03010799f, 0.07268869f, 0.13953792f, 0.00299005f, 0.12916467f, -0.03539260f, -0.01071219f, 0.09382507f, 
    0.01057307f, 0.03152595f, 0.13793358f, -0.18003693f, 0.01590380f, 0.18638195f, 0.06426543f, 0.31663916f, 
    -0.25752884f, -0.15512665f, -0.14243527f, 0.19639850f, 0.08427282f, -0.21548340f, -0.15818872f, 0.04355003f, 
    0.05083048f, -0.06174628f, -0.07418513f, -0.17768618f, -0.07462560f, -0.02863711f, -0.15599616f, 0.40656465f, 
    0.05396226f, 0.03376180f, -0.03258177f, 0.03662865f, -0.06478298f, 0.09925030f, 0.02866729f, 0.08016969f, 
    -0.06172042f, -0.17454086f, -0.09309749f, -0.04398206f, 0.16967522f, 0.04139933f, 0.06079651f, 0.06496789f, 
    -0.07389252f, -0.05372218f, -0.00670544f, -0.02812210f, 0.12724531f, -0.05711930f, -0.06212734f, 0.10558470f, 
    -0.06148963f, 0.02946729f, -0.00079779f, 0.00594007f, 0.06942116f, 0.30752498f, 0.04462078f, 0.22827098f, 
    -0.03097195f, -0.05903939f, -0.05459487f, -0.29322940f, -0.11689425f, -0.13107511f, -0.18033193f, -0.23988028f, 
    0.00921745f, 0.02618824f, -0.08683763f, -0.04368840f, 0.19591455f, 0.10616239f, -0.13202614f, -0.03247407f, 
    -0.10252441f, -0.11669946f, 0.07623148f, -0.03514487f, 0.09874759f, -0.00425081f, -0.20678711f, -0.09929062f, 
    -0.02749408f, 0.01461972f, -0.02399325f, -0.02674282f, -0.03458778f, 0.00703732f, 0.02804025f, 0.01396413f, 
    0.00425116f, -0.01064146f, 0.02274398f, 0.02166552f, -0.01306626f, -0.03718734f, 0.01674203f, -0.02146153f, 
    0.00133089f, -0.00576108f, -0.03565737f, 0.02912070f, 0.00507242f, 0.00415141f, -0.00885679f, -0.01588664f, 
    0.00276084f, -0.03449854f, 0.02811171f, 0.00263208f, -0.00529662f, -0.00866767f, -0.03685357f, 0.00062731f, 
    -0.01164142f, -0.01917179f, 0.00272208f, 0.01213894f, 0.00439328f, -0.03190585f, -0.00731698f, -0.01005220f, 
    0.02949811f, 0.02431739f, -0.00750966f, 0.02374341f, 0.02048935f, -0.00519151f, 0.02092389f, 0.01119735f, 
    -0.00037056f, 0.01764569f, -0.03069883f, -0.01202753f, -0.01098186f, 0.00094870f, 0.02962527f, -0.01043891f, 
    0.01628934f, -0.00375809f, -0.00158688f, -0.00779201f, 0.02401303f, 0.01745352f, -0.02429899f, -0.03141065f, 
    -0.01992839f, -0.02998985f, -0.00700279f, -0.04069621f, -0.02578603f, -0.01983446f, 0.01589233f, -0.03911871f, 
    0.00875605f, -0.03780882f, -0.01489292f, -0.00970077f, -0.01804086f, -0.01942698f, 0.02127429f, -0.03077156f, 
    -0.01559025f, 0.00948124f, -0.03549291f, 0.01530899f, 0.00824706f, -0.01303012f, 0.00908418f, 0.00757812f, 
    -0.00760855f, 0.00623323f, -0.02690070f, 0.02309822f, 0.00062650f, 0.02622391f, 0.01199311f, 0.00372382f, 
    -0.01234172f, -0.02422286f, -0.00489443f, 0.00168742f, -0.02897766f, -0.00381034f, -0.01862167f, 0.00139874f, 
    -0.01861299f, -0.00734092f, 0.01876668f, 0.00328612f, 0.00027966f, -0.00085546f, -0.01600991f, 0.02168650f, 
    0.00283774f, -0.00430616f, -0.00727467f, 0.00146056f, -0.03949405f, -0.03498044f, 0.02473118f, 0.02902692f, 
    0.00426098f, 0.01410168f, -0.02256360f, 0.02401301f, -0.02518822f, 0.00888097f, -0.00056707f, 0.01611000f, 
    -0.02657209f, -0.02937884f, -0.04201957f, -0.03685845f, 0.00190796f, -0.04133996f, 0.01679733f, 0.02543688f, 
    0.01603268f, 0.01902596f, 0.01631258f, 0.01010562f, 0.00040944f, -0.02297281f, 0.00571465f, -0.02663336f, 
    -0.02417535f, -0.00866051f, -0.03167959f, 0.01205971f, -0.00896355f, 0.01561879f, 0.02532405f, -0.03274165f, 
    -0.02505410f, -0.04071810f, -0.00775304f, 0.01267095f, 0.01475663f, -0.00235016f, -0.01952063f, -0.01471722f, 
    0.00146738f, -0.01502734f, -0.03551751f, 0.01240241f, -0.00059357f, 0.02950762f, -0.01153913f, -0.01544580f, 
    0.00109803f, 0.02794847f, -0.04199845f, 0.00868396f, -0.00058784f, 0.00830034f, -0.03272979f, 0.00962241f, 
    0.00229812f, -0.03622793f, -0.01080928f, 0.02677625f, -0.00107987f, 0.00044963f, 0.01771564f, -0.01959696f, 
    0.02097682f, 0.00242386f, 0.01911794f, 0.01145709f, -0.01368068f, -0.00663609f, 0.00132694f, -0.00196333f, 
    0.00643932f, -0.03969096f, -0.01174622f, -0.02339944f, -0.01696968f, 0.00613603f, -0.02839187f, -0.01054170f, 
    0.00508683f, 0.00687640f, -0.00339609f, -0.00777724f, -0.03141790f, 0.01799870f, -0.03102875f, -0.03990873f, 
    -0.03143842f, 0.00585732f, 0.01939731f, -0.03434003f, -0.00060462f, -0.01176418f, -0.00329555f, -0.02743968f, 
    0.00434776f, 0.02973680f, -0.03589059f, -0.01368568f, -0.00620371f, 0.00959182f, -0.04099392f, -0.00375312f, 
    0.01882827f, 0.01774626f, 0.01312782f, -0.00791671f, -0.02424388f, -0.00737186f, -0.03097282f, 0.00414925f, 
    -0.00001844f, 0.00710666f, 0.02414813f, -0.03659606f, -0.01051402f, -0.01949923f, -0.00432836f, 0.02092737f, 
    0.00202919f, -0.02361183f, -0.00060199f, -0.01897809f, 0.01032027f, -0.02620347f, -0.01812132f, -0.03198654f, 
    -0.02864968f, -0.00464614f, 0.03657822f, 0.02152546f, -0.00068181f, 0.02110907f, 0.01656177f, -0.00573855f, 
    0.00948146f, 0.00477401f, 0.00234724f, 0.01516088f, 0.01607571f, -0.00925757f, 0.01871002f, -0.02657242f, 
    -0.02148659f, 0.02513365f, -0.00434553f, 0.02291443f, -0.00257372f, 0.00160787f, 0.01774502f, -0.01685080f, 
    0.00277425f, 0.01457476f, -0.02159854f, -0.02323079f, -0.00963399f, -0.01338781f, 0.02532185f, 0.02939734f, 
    -0.01115038f, -0.03234202f, -0.03298341f, 0.02755637f, 0.00316640f, -0.01193430f, -0.01724298f, -0.04166990f, 
    0.02993067f, 0.02681920f, -0.02697454f, 0.01260732f, -0.02866198f, -0.01449004f, -0.04178842f, 0.00822998f, 
    -0.00072408f, 0.01426631f, -0.04037855f, 0.02522304f, -0.02189887f, 0.01550831f, -0.01641699f, -0.03201615f, 
    0.02806065f, -0.00407023f, -0.02758572f, 0.00886158f, -0.01421260f, -0.00065843f, -0.02428121f, 0.01153637f, 
    -0.03456727f, -0.02528718f, 0.02314340f, -0.01396496f, -0.02180464f, -0.01549092f, -0.01753009f, -0.02950019f, 
    0.02662744f, 0.02994064f, -0.03658567f, 0.00289388f, -0.02196002f, -0.03928098f, -0.01943491f, 0.00707017f, 
    0.01288380f, 0.02208045f, 0.00934661f, -0.02698710f, 0.00317603f, -0.01803865f, -0.02048105f, -0.00479870f, 
    -0.00433367f, -0.00427565f, -0.04094877f, -0.03507450f, 0.02223593f, 0.00940266f, -0.00611763f, -0.03046402f, 
    0.00955749f, 0.00953260f, -0.00022544f, 0.01556103f, -0.01828376f, -0.01274938f, -0.03381337f, -0.01966283f, 
    -0.00597965f, 0.01902237f, 0.02946663f, -0.00577379f, 0.02017305f, -0.00812107f, -0.02524727f, 0.02036976f, 
    0.00549006f, 0.01767646f, -0.01645897f, -0.00343637f, 0.01176823f, -0.00130757f, -0.00772391f, -0.02515222f, 
    -0.03550290f, -0.00492989f, 0.01756385f, 0.01681519f, -0.01682459f, -0.01852641f, -0.02840763f, -0.01201711f, 
    -0.02992502f, 0.02471851f, -0.01110428f, -0.00132299f, -0.01017895f, -0.02050522f, -0.03038765f, -0.01243291f, 
    0.00831627f, -0.00822809f, 0.02900313f, 0.01940574f, -0.02186276f, 0.00260069f, -0.03716563f, 0.02986683f, 
    -0.01637123f, -0.03075300f, -0.01924466f, -0.00637951f, -0.02391245f, 0.02133411f, -0.00478919f, -0.01486193f, 
    -0.04036960f, 0.02117990f, 0.02567749f, -0.03725011f, -0.00945632f, -0.01040426f, -0.01066717f, 0.02676296f, 
    -0.03253455f, 0.02637281f, 0.00981257f, -0.00553787f, -0.03980635f, -0.03950743f, -0.01796406f, -0.02465353f, 
    -0.02602695f, -0.02804069f, 0.01114152f, -0.03523419f, -0.00307215f, 0.01846489f, -0.00996716f, -0.02861908f, 
    -0.01740180f, 0.02704677f, -0.03356490f, -0.01621176f, 0.00387110f, 0.00687619f, 0.01117263f, 0.02486512f, 
    -0.00612837f, 0.01887750f, -0.00209445f, -0.00700245f, 0.01167257f, 0.02118442f, 0.00398260f, -0.01289522f, 
    0.01423792f, 0.02860779f, -0.04112384f, -0.00207708f, 0.01556280f, 0.00233289f, -0.01349558f, 0.00784737f, 
    0.01675092f, 0.01954505f, -0.03397684f, 0.01587055f, -0.04100219f, -0.00248578f, 0.02188333f, 0.01407102f, 
    -0.04115324f, 0.02764448f, -0.00245068f, 0.02392730f, -0.03538782f, 0.01902180f, -0.01669025f, -0.03927343f, 
    0.02171540f, -0.00769562f, -0.01452314f, -0.01425480f, -0.00288638f, -0.01795714f, 0.02016332f, 0.00591120f, 
    0.01725711f, -0.02536977f, -0.03194257f, 0.01583403f, -0.02800102f, -0.02616303f, 0.00376311f, 0.00913531f, 
    -0.01925145f, -0.01043704f, -0.01327006f, -0.01149911f, 0.01990542f, 0.03606775f, -0.03224729f, 0.00967696f, 
    0.02042840f, -0.00804653f, 0.02306501f, -0.01908526f, 0.01913815f, -0.03461683f, -0.00196548f, -0.02582526f, 
    -0.03254956f, 0.01913524f, 0.02568675f, 0.00271947f, -0.02943468f, 0.00564583f, 0.00716881f, -0.00852172f, 
    0.02995702f, -0.00610864f, -0.01336832f, 0.01012806f, 0.00111203f, -0.01986114f, -0.02187788f, -0.01292639f, 
    0.00081944f, -0.01091260f, -0.00009115f, -0.00190998f, -0.03220626f, -0.02407093f, -0.02942823f, -0.02499362f, 
    0.01819018f, 0.01694978f, -0.00978567f, -0.00833597f, -0.02810549f, -0.00836631f, 0.02428391f, 0.00069292f, 
    -0.01341180f, -0.02006701f, 0.02951374f, -0.01420422f, -0.02443299f, -0.03833359f, -0.02188816f, 0.01562569f, 
    -0.01073819f, -0.03380331f, -0.01397579f, 0.01348772f, 0.01607319f, -0.03658891f, 0.02426285f, -0.02706943f, 
    0.01082417f, -0.01394363f, 0.00030704f, -0.02152182f, -0.01512246f, -0.02591798f, -0.01611832f, -0.01932734f, 
    -0.00091539f, -0.01470138f, -0.00074209f, -0.01808812f, 0.00806727f, -0.00551155f, 0.01209467f, 0.00541062f, 
    0.02987661f, -0.00450661f, -0.01657960f, 0.00339375f, -0.02848503f, 0.01189382f, -0.02644918f, 0.00852081f, 
    0.01930946f, -0.01866485f, -0.00159437f, 0.00218023f, -0.03166533f, -0.03339269f, 0.00226149f, -0.03375757f, 
    0.01281966f, -0.03449020f, -0.02451907f, -0.03845879f, 0.02720966f, -0.01730610f, 0.00524842f, 0.01207445f, 
    -0.02687271f, 0.00022024f, -0.03106012f, 0.01274549f, -0.00386359f, -0.00658948f, -0.01090452f, -0.01879662f, 
    0.01734238f, -0.01537743f, 0.02862943f, -0.02558347f, -0.01391955f, -0.02948697f, -0.01790822f, 0.00947566f, 
    0.00127880f, -0.00431608f, 0.01050581f, 0.01191123f, 0.00572899f, -0.00814523f, 0.01975444f, 0.03324421f, 
    -0.03666521f, -0.02287756f, -0.02553761f, -0.01637430f, 0.00296718f, 0.02784806f, 0.00865737f, -0.02928172f, 
    0.01958407f, -0.00088113f, 0.01556438f, -0.00208026f, -0.01772620f, -0.03359010f, -0.01778461f, -0.03175313f, 
    -0.00656085f, -0.02044697f, -0.03355415f, -0.03056409f, 0.00969097f, -0.03739467f, -0.00559962f, -0.00734034f, 
    0.00468809f, -0.01275940f, -0.01869913f, -0.02246618f, -0.02377665f, -0.03661381f, -0.00831517f, -0.00756202f, 
    -0.00434394f, -0.03404852f, -0.01328905f, -0.02887223f, -0.02606909f, -0.03679893f, -0.01152229f, -0.02236441f, 
    -0.02607472f, -0.01432099f, 0.01223656f, 0.01174594f, -0.04061665f, -0.00567277f, 0.00685130f, 0.01463192f, 
    -0.03626228f, 0.03139839f, -0.01768001f, -0.03119692f, -0.01952383f, -0.01844387f, -0.00099838f, 0.01784470f, 
    0.00756389f, -0.04047216f, -0.01852184f, -0.03559266f, -0.00776601f, -0.02580898f, -0.03760593f, 0.00766584f, 
    -0.00707023f, -0.02289407f, -0.03745876f, 0.00717957f, 0.00615697f, -0.03295175f, 0.02411282f, 0.00073969f, 
    0.00356558f, 0.01189440f, -0.01995750f, 0.02056876f, -0.02892866f, -0.01749719f, -0.03342334f, -0.04053694f, 
    0.02916907f, 0.01863996f, -0.00703443f, 0.01970220f, 0.02127265f, 0.01232122f, -0.01956137f, -0.03580898f, 
    -0.01796044f, 0.01257154f, 0.02817071f, -0.02414414f, -0.00520044f, -0.00558220f, -0.01278321f, -0.03373214f, 
    0.02690209f, -0.03855214f, -0.01357296f, -0.02498182f, -0.03934861f, -0.00801001f, 0.01032213f, 0.02475384f, 
    0.02790205f, -0.02541208f, -0.02093303f, -0.03550500f, -0.03535347f, -0.00067653f, 0.00367533f, -0.00337390f, 
    -0.01255702f, -0.03801750f, 0.00950183f, -0.03053398f, -0.00260145f, 0.03000864f, -0.00406308f, 0.00670858f, 
    -0.03158942f, -0.03949984f, -0.01431968f, 0.02492644f, -0.00233315f, -0.03825832f, 0.01048790f, -0.00873651f, 
    -0.03251886f, 0.00206831f, -0.03582013f, -0.00890906f, 0.00267005f, 0.00032566f, -0.02816074f, 0.00671670f, 
    -0.04047300f, -0.02905684f, 0.02359171f, -0.03821312f, 0.02363794f, 0.01084103f, -0.01053983f, 0.01806964f, 
    -0.03970478f, -0.03284489f, -0.01954392f, 0.01152698f, 0.02820442f, 0.00567424f, 0.01674947f, 0.00484649f, 
    0.01026464f, -0.00834625f, 0.02465067f, 0.02646267f, 0.03132237f, 0.00362681f, 0.00877732f, -0.03874819f, 
    -0.35588801f, -0.05557742f, 0.04277435f, -0.05981775f, 0.00253361f, 0.01243164f, -0.04791029f, -0.11096729f, 
    0.06364322f, -0.01582273f, 0.04743486f, 0.08791056f, -0.08510419f, -0.32912156f, 0.06349804f, 0.30914670f, 
    0.03939215f, -0.06102859f, -0.03464939f, 0.19085154f, 0.03625585f, 0.00955050f, 0.15131812f, 0.11334110f, 
    -0.22426835f, 0.04048268f, -0.11228977f, -0.27159944f, 0.01513235f, 0.12004656f, 0.06431520f, 0.07996657f, 
    0.03955727f, -0.10605448f, 0.02735260f, -0.01546489f, 0.40719700f, -0.05688899f, 0.13604920f, 0.25626436f, 
    0.01563758f, -0.12203739f, 0.02967601f, 0.16992573f, -0.08137691f, 0.02989474f, 0.13047896f, 0.01099996f, 
    -0.28098664f, -0.15905362f, -0.10961069f, 0.05405933f, -0.04660650f, 0.03557611f, -0.02946572f, 0.12947839f, 
    0.02856082f, 0.11516353f, 0.08321625f, 0.01573980f, -0.30685413f, 0.13431229f, -0.01956279f, -0.01420618f, 
    -0.12407186f, -0.01924806f, -0.02192297f, 0.26222259f, -0.05948846f, -0.04169154f, -0.15420350f, 0.04402880f, 
    -0.25653034f, -0.15376435f, -0.08175390f, -0.02772287f, 0.02644062f, -0.03694998f, 0.09033213f, 0.01955801f, 
    0.12966135f, 0.03723989f, 0.05342548f, 0.09809514f, -0.02150797f, -0.01297975f, -0.11616277f, -0.37565967f, 
    0.07454801f, 0.00093374f, -0.13047089f, 0.03045781f, -0.18389785f, -0.06462702f, 0.00772720f, -0.04892370f, 
    -0.06589700f, 0.08663110f, -0.06077232f, -0.40487376f, -0.03024005f, 0.04123793f, -0.03232488f, 0.00350544f, 
    0.27127537f, 0.05387901f, -0.05190231f, 0.09180512f, 0.30149332f, -0.05885527f, -0.15115725f, -0.18173008f, 
    -0.06123871f, 0.04095862f, 0.09838846f, -0.08594970f, 0.03567590f, -0.06870227f, 0.08065625f, 0.06460926f, 
    -0.19808534f, -0.05566436f, 0.09048336f, 0.20327309f, 0.05539399f, 0.09035982f, 0.11001579f, 0.08715298f, 
    0.12539907f, 0.09728544f, 0.07198801f, -0.06650674f, 0.14246814f, 0.23324968f, -0.09417703f, -0.07786709f, 
    -0.00693855f, -0.10069634f, -0.02826615f, 0.13871494f, 0.01705290f, -0.06791513f, 0.07702185f, -0.02033383f, 
    -0.03092464f, -0.13864625f, -0.13827859f, -0.15534700f, -0.06460144f, -0.12860091f, 0.04563452f, 0.03562564f, 
    0.04305840f, 0.09603951f, -0.15603116f, -0.09325580f, -0.02116438f, -0.01606062f, 0.02754448f, -0.04772144f, 
    0.04154013f, -0.01337072f, -0.02691677f, -0.09224435f, -0.09852184f, -0.16048655f, -0.11701782f, 0.01271302f, 
    -0.19116101f, 0.46998560f, 0.06088299f, 0.19521441f, 0.01840498f, -0.06210291f, -0.00323911f, -0.03254579f, 
    -0.00927831f, 0.13715798f, 0.11161566f, 0.00583182f, -0.26725030f, 0.25001559f, -0.08720508f, -0.11233781f, 
    0.15029982f, 0.13116442f, -0.11448347f, -0.09209426f, -0.33715028f, 0.19591847f, 0.09113838f, 0.05324698f, 
    -0.17578217f, -0.04550134f, -0.07976944f, -0.13807015f, 0.01090270f, -0.11443456f, 0.03928604f, 0.00321385f, 
    0.05407191f, -0.04957483f, -0.10769848f, 0.03015807f, 0.05345768f, 0.16000526f, 0.25520635f, 0.35814464f, 
    0.11727096f, -0.13082816f, 0.24151468f, -0.15396583f, 0.02078875f, 0.05776870f, 0.03070338f, -0.00195431f, 
    0.17163406f, 0.18761641f, 0.25809866f, 0.30239886f, 0.04705493f, -0.09261279f, -0.06066415f, 0.05088494f, 
    0.13535365f, -0.07166369f, -0.14958879f, -0.02258150f, -0.06712586f, -0.13103077f, 0.02476539f, 0.26460835f, 
    0.13352527f, 0.06617746f, 0.07580199f, -0.01574233f, 0.07806282f, -0.08842587f, -0.19404808f, 0.01791794f, 
    -0.06551964f, -0.12980616f, 0.18840526f, 0.28591877f, -0.04351996f, 0.05861213f, 0.04309968f, 0.00198178f, 
    -0.01040111f, 0.09613495f, 0.00945931f, -0.09850820f, 0.03164930f, 0.15149038f, -0.06386936f, 0.28826639f, 
    0.03034758f, -0.06437314f, 0.00587450f, 0.10098357f, 0.12531382f, 0.12112521f, -0.00330108f, -0.02365051f, 
    -0.12803657f, 0.10082541f, 0.19224298f, 0.50641590f, 0.09271301f, 0.12459812f, -0.02041715f, 0.18894678f, 
    0.10877672f, 0.00063798f, -0.02899515f, 0.02346235f, -0.13203496f, 0.25044194f, 0.26094961f, 0.36247689f, 
    0.12995264f, 0.01665766f, 0.04204512f, 0.16985770f, -0.04562427f, 0.01132535f, -0.11062439f, -0.14413965f, 
    -0.14310890f, 0.08679070f, -0.01006764f, -0.00394480f, -0.03393161f, -0.08784581f, 0.09319767f, 0.08424489f, 
    0.04976139f, 0.13169971f, 0.05093239f, 0.22542576f, -0.01522752f, 0.08570885f, -0.05592718f, 0.25243771f, 
    -0.03793421f, -0.04418900f, -0.02817260f, -0.10446673f, -0.05559331f, 0.07031965f, -0.03116629f, 0.13912030f, 
    0.10838328f, -0.16014658f, -0.16770662f, -0.06471512f, -0.12962723f, -0.02222507f, 0.03333933f, -0.03131517f, 
    -0.07131577f, -0.03401297f, 0.06123702f, -0.03324887f, 0.29670295f, 0.12011918f, 0.10223097f, 0.10724923f, 
    -0.09245787f, -0.01406691f, 0.06107197f, -0.03138918f, 0.30304310f, 0.10401651f, 0.10402351f, 0.01987011f, 
    -0.09490623f, 0.00123370f, 0.06286294f, 0.17467952f, -0.07108998f, -0.03479104f, -0.08131376f, 0.03390756f, 
    -0.02170202f, -0.05543808f, -0.14659563f, -0.04473386f, 0.04114276f, 0.09805547f, -0.10367445f, 0.17844030f, 
    -0.02726263f, -0.01557686f, 0.01557206f, -0.00388155f, -0.04850122f, -0.09250329f, 0.03297490f, -0.03729850f, 
    -0.13165025f, 0.14445396f, 0.02334617f, 0.18903586f, 0.19762322f, -0.01972281f, -0.04032017f, 0.06847244f, 
    -0.00578150f, -0.14091551f, -0.16172285f, -0.14550377f, -0.08439365f, 0.08581844f, -0.00675686f, 0.12325230f, 
    -0.00750923f, -0.08214394f, 0.01388197f, 0.28614533f, -0.01400001f, 0.07202319f, -0.17111154f, 0.11621939f, 
    -0.19750400f, 0.27199322f, 0.01782433f, 0.40576348f, -0.02861523f, -0.05870136f, -0.03164978f, 0.04785081f, 
    -0.07598209f, -0.03376288f, -0.08591953f, 0.01334869f, -0.12482663f, -0.07545008f, -0.00202010f, 0.36848381f, 
    -0.02632670f, 0.02324394f, -0.13851769f, 0.04113721f, -0.06120330f, -0.08280663f, -0.03298842f, -0.05407710f, 
    -0.21116781f, 0.06670605f, 0.06532658f, 0.13528541f, 0.00659021f, -0.07954457f, -0.04424899f, 0.09578064f, 
    0.08655476f, 0.07718231f, -0.00889504f, 0.06989926f, 0.53098100f, -0.01564649f, -0.16938032f, -0.04775781f, 
    0.04489755f, 0.02008377f, 0.12872919f, 0.06766092f, -0.07003044f, 0.00717703f, 0.04273565f, -0.04815057f, 
    -0.54092050f, 0.21729730f, 0.00033274f, 0.23885585f, 0.09602825f, 0.22540511f, -0.14837997f, 0.04358565f, 
    -0.09181868f, 0.02228462f, 0.01953920f, 0.16856828f, 0.13219535f, 0.06628976f, 0.25735995f, 0.25428891f, 
    0.02605464f, -0.07459500f, -0.01425967f, 0.01121394f, 0.10818134f, -0.03416144f, 0.03116534f, -0.18355447f, 
    0.10009657f, -0.16985190f, -0.11739830f, 0.32247439f, -0.04653809f, 0.08037627f, 0.07541190f, 0.08712201f, 
    -0.07466780f, -0.01088168f, -0.06052610f, 0.00227552f, -0.00997858f, -0.14812896f, 0.08399482f, -0.03041711f, 
    -0.10041712f, 0.02283548f, 0.02616630f, 0.06888637f, 0.04247857f, 0.09552445f, -0.14524955f, -0.10406891f, 
    -0.42626077f, 0.35697004f, 0.33605182f, 0.20348832f, 0.06715290f, 0.00344696f, -0.09549868f, 0.02595720f, 
    -0.20659682f, -0.07724556f, 0.06234552f, 0.05840282f, 0.43128803f, 0.03996741f, -0.22473463f, 0.04575234f, 
    -0.06108708f, 0.10245198f, 0.02036642f, -0.15875801f, -0.06443205f, -0.18062258f, 0.04609521f, -0.03217940f, 
    -0.01556038f, 0.05716608f, 0.04797205f, 0.19998759f, 0.03850958f, -0.08458342f, 0.00260759f, -0.24277152f, 
    0.17572160f, -0.10544981f, -0.18330359f, 0.32821512f, 0.02826157f, -0.03391648f, 0.07262749f, 0.20096986f, 
    -0.00877520f, -0.15662013f, -0.29902008f, 0.02655593f, 0.07069296f, -0.00063291f, -0.06033691f, -0.12677665f, 
    -0.07071011f, 0.45795235f, 0.02194089f, 0.03708115f, -0.03208181f, -0.08923288f, -0.05945208f, 0.06611756f, 
    0.13426034f, 0.14685856f, -0.02553270f, 0.03381856f, -0.16410799f, -0.39097705f, -0.01039993f, 0.07648856f, 
    0.02568555f, -0.08866051f, 0.02932144f, 0.08628447f, 0.04895632f, 0.08260643f, 0.10927512f, 0.08984189f, 
    -0.02076103f, -0.01305058f, -0.02015641f, 0.11245060f, 0.02017770f, 0.03156153f, 0.00263562f, 0.08525509f, 
    0.05667381f, -0.10620350f, 0.05632498f, -0.14119092f, -0.20014134f, -0.18743964f, -0.08618768f, 0.33061066f, 
    -0.00417541f, -0.14230187f, -0.12250699f, 0.06884360f, 0.01045040f, 0.00148755f, -0.02265756f, -0.00655277f, 
    -0.04046702f, -0.03479013f, 0.21376306f, 0.01649587f, 0.04146700f, 0.03949170f, 0.07710803f, 0.19420931f, 
    -0.13754040f, -0.06339373f, -0.06496719f, -0.14499949f, 0.24312505f, -0.07174929f, -0.16486867f, -0.17351344f, 
    -0.14332123f, -0.00646921f, 0.00875962f, -0.04930126f, -0.04783319f, 0.08621892f, 0.02138315f, -0.12650509f, 
    -0.11049880f, 0.08830950f, 0.17309816f, -0.17588405f, -0.03008077f, -0.06523751f, -0.12248828f, 0.08014415f, 
    0.02125970f, -0.00567144f, 0.11378600f, -0.20440002f, -0.55082077f, 0.16411698f, -0.07220015f, 0.13699184f, 
    0.01306029f, 0.20589127f, 0.02783237f, -0.05662441f, 0.05583324f, 0.07244615f, 0.00038648f, 0.02846491f, 
    -0.04850974f, -0.05257669f, 0.06384568f, 0.19148070f, 0.00536399f, -0.02664353f, -0.01636116f, 0.10620527f, 
    0.06106769f, 0.15322891f, -0.02603453f, 0.08189458f, 0.15245299f, 0.09620517f, 0.08204109f, 0.09152838f, 
    0.00890642f, -0.00449522f, 0.09681017f, -0.08298659f, 0.01608969f, 0.16628595f, 0.08345678f, 0.34463331f, 
    0.15223518f, 0.10180398f, 0.11796397f, 0.12876584f, -0.07869560f, -0.08267232f, 0.08056765f, 0.30978438f, 
    -0.21474329f, 0.07687441f, -0.03477255f, -0.16760348f, -0.25837231f, -0.06751282f, 0.05886095f, -0.07100619f, 
    0.03190568f, -0.00280429f, -0.04524846f, -0.04951895f, -0.00763040f, -0.02510452f, -0.08419684f, -0.10420987f, 
    -0.07919677f, 0.00058986f, 0.10535222f, 0.24616666f, -0.01438578f, -0.03344187f, 0.05650577f, 0.09239794f, 
    0.04546978f, 0.14681257f, -0.10815901f, -0.01415149f, -0.40229517f, 0.33858785f, 0.13688931f, 0.13009994f, 
    -0.02401190f, 0.07576165f, 0.09709017f, 0.05451341f, -0.12107363f, 0.07609220f, -0.02440540f, 0.06586864f, 
    0.02724284f, -0.12410767f, 0.13495696f, 0.08782406f, -0.07843123f, -0.06150104f, -0.11034158f, 0.02272407f, 
    0.00740423f, 0.05685820f, -0.00305093f, -0.05881880f, 0.03783245f, 0.07539146f, -0.03568714f, -0.35320622f, 
    0.02826324f, 0.00453683f, -0.02354489f, 0.10012539f, 0.05495685f, 0.01796627f, -0.01925801f, 0.02873694f, 
    0.23262863f, 0.08110501f, -0.11812325f, -0.07668483f, -0.06095581f, -0.02383912f, 0.06372844f, 0.13889621f, 
    -0.08714197f, -0.08778327f, -0.08936531f, -0.21888344f, -0.24077663f, -0.03566778f, -0.15346777f, -0.17458196f, 
    0.01046130f, -0.11330776f, 0.09393872f, 0.17156839f, -0.01733407f, 0.08726048f, 0.13531773f, 0.11295531f, 
    0.01476036f, 0.06082277f, 0.17984805f, 0.31746531f, 0.13061173f, 0.07033763f, 0.07562295f, 0.07860406f, 
    0.05419986f, -0.00678213f, 0.00223615f, -0.22134821f, -0.06036711f, 0.15543219f, 0.26206735f, 0.13693145f, 
    0.03936009f, 0.01551406f, 0.01983557f, 0.14259194f, -0.07127585f, -0.09943660f, 0.01946195f, -0.06333554f, 
    -0.00234110f, -0.02891115f, 0.02393528f, -0.01437689f, -0.02013762f, 0.01723121f, 0.02601136f, -0.03687279f, 
    -0.01259424f, -0.03978730f, -0.01970119f, 0.00768975f, 0.01894034f, -0.03399356f, 0.01678609f, -0.02098504f, 
    -0.00678305f, -0.00975554f, -0.01907633f, -0.03675568f, 0.01032622f, 0.02334169f, -0.02818243f, -0.02614588f, 
    0.02830165f, -0.03653184f, 0.00928537f, -0.00164562f, -0.00582853f, -0.02300579f, -0.02727254f, -0.00066137f, 
    -0.03144905f, 0.01364577f, -0.01398567f, -0.01264744f, -0.03653102f, 0.01961431f, -0.02512377f, -0.03512907f, 
    -0.02668555f, -0.03691145f, -0.00470679f, 0.00515573f, -0.00416540f, -0.02687001f, -0.03279132f, -0.03300521f, 
    -0.03662889f, -0.04172799f, -0.03518096f, 0.02611641f, 0.00992628f, 0.01179275f, 0.01714385f, -0.03652070f, 
    -0.01643464f, 0.00960635f, -0.00849156f, -0.03725865f, -0.02895046f, -0.01010940f, -0.02954018f, 0.02719913f, 
    0.00180370f, -0.01713218f, 0.02003959f, -0.02837621f, 0.02207801f, -0.00208099f, 0.00851543f, -0.00522151f, 
    -0.02215592f, 0.02645467f, -0.02987951f, 0.03282975f, -0.03957818f, 0.01055758f, -0.00140146f, 0.02010137f, 
    -0.00940780f, -0.01044485f, -0.03886044f, 0.02502543f, -0.02350526f, 0.02661691f, -0.02901964f, 0.00450417f, 
    -0.02755708f, 0.00624539f, -0.00619509f, -0.01243804f, -0.01309305f, -0.03594982f, -0.02620188f, -0.03602673f, 
    0.01507082f, 0.01041358f, -0.03618671f, -0.03629351f, -0.00893283f, -0.00527888f, 0.02123154f, -0.00891561f, 
    -0.03969900f, 0.01556179f, 0.01097637f, -0.02029748f, -0.03553038f, 0.01277114f, 0.02116530f, 0.00871442f, 
    0.00986757f, -0.01178871f, 0.01147500f, 0.00478982f, -0.00122087f, -0.01123182f, -0.04165876f, -0.03138349f, 
    -0.03695026f, -0.00034965f, 0.02632881f, -0.02997187f, -0.01482537f, -0.00899481f, 0.02640093f, 0.02819777f, 
    -0.03374005f, 0.00416331f, -0.03161021f, 0.00358935f, -0.04180863f, 0.02977495f, -0.03013999f, -0.00773133f, 
    0.01801054f, -0.03162656f, 0.02523529f, -0.03272959f, -0.04011425f, -0.01180116f, -0.02792707f, -0.02702451f, 
    0.02997004f, 0.00391957f, -0.04158963f, 0.01953111f, -0.03277728f, 0.01017019f, 0.00903528f, 0.00955126f, 
    0.02810062f, 0.00765884f, 0.02875968f, 0.01078297f, -0.00494439f, 0.01158041f, -0.02252966f, 0.01144292f, 
    0.01323519f, 0.02605336f, -0.02721126f, -0.02160537f, 0.00573062f, -0.03029195f, 0.00092076f, -0.02149062f, 
    -0.00840475f, 0.01766087f, -0.01029421f, 0.01485112f, -0.02052088f, 0.02651455f, -0.03807512f, -0.03020553f, 
    0.02892371f, -0.03084575f, -0.01583504f, -0.00749837f, 0.00263540f, 0.01741786f, 0.01690050f, -0.01323467f, 
    0.00617246f, 0.02975151f, -0.03765782f, -0.01514909f, -0.01637533f, 0.01117146f, 0.00383535f, -0.04078137f, 
    0.00574612f, 0.00788748f, 0.01314281f, 0.00774970f, 0.01042980f, -0.00323712f, 0.02585505f, -0.03235116f, 
    -0.03192711f, 0.02361825f, -0.04135217f, -0.01119993f, 0.01622355f, 0.02677167f, -0.03792403f, 0.00230402f, 
    0.01200093f, 0.02044328f, -0.03429510f, 0.01972782f, -0.01676698f, -0.02933288f, -0.02700450f, -0.01780026f, 
    -0.00793886f, 0.01167863f, 0.01176648f, -0.03971627f, -0.00960699f, 0.00127962f, 0.02094839f, 0.01885621f, 
    0.02805566f, -0.01864371f, 0.02947637f, 0.01340710f, -0.01861774f, 0.01505054f, -0.00876382f, -0.02681371f, 
    -0.02585470f, -0.01920881f, 0.02350706f, 0.01755143f, -0.00965650f, -0.03118923f, -0.03127298f, 0.02405914f, 
    0.01306281f, -0.03799270f, 0.00921923f, 0.01473646f, -0.02151512f, 0.01534965f, -0.01158242f, -0.03977607f, 
    -0.01823945f, 0.02690693f, -0.02700486f, 0.00457546f, -0.01156582f, -0.00835822f, -0.00665490f, -0.02027853f, 
    0.02870521f, -0.03068623f, -0.03791480f, 0.00003601f, -0.03920568f, 0.01211722f, -0.01931579f, -0.00500053f, 
    -0.03380893f, -0.03367963f, -0.03665309f, -0.01606309f, -0.02306711f, -0.03313280f, -0.01955066f, -0.00106868f, 
    0.02628504f, 0.00602757f, 0.02972512f, -0.01297586f, -0.03559504f, -0.03690427f, 0.00401608f, -0.00793729f, 
    -0.03499223f, -0.03842248f, -0.03866944f, -0.02663822f, 0.02199628f, 0.02059976f, 0.02206924f, -0.03323517f, 
    -0.04036701f, -0.01133917f, -0.00058290f, -0.03587574f, -0.01639493f, 0.01466654f, 0.00536344f, -0.02878005f, 
    0.00425197f, -0.02629316f, -0.02302392f, -0.00786983f, -0.04152472f, 0.02805954f, -0.03815818f, -0.00018027f, 
    -0.00190260f, 0.01319171f, 0.01996051f, 0.03748874f, -0.01387439f, -0.01220982f, -0.02665661f, -0.00869780f, 
    -0.00062505f, -0.03653727f, -0.01948006f, -0.03115403f, 0.00994554f, 0.00261404f, -0.01162081f, 0.02509545f, 
    0.01195064f, -0.04090127f, 0.02106489f, -0.00876052f, -0.00467868f, 0.00419903f, 0.02325084f, -0.02359861f, 
    -0.00220817f, 0.01620735f, -0.01969300f, -0.00209471f, 0.02089544f, -0.02351203f, -0.00595429f, -0.00811654f, 
    -0.00320986f, 0.02851464f, 0.01387133f, -0.00237564f, 0.00217013f, 0.00132532f, 0.02239564f, 0.02228003f, 
    0.01517380f, -0.02550912f, -0.03760667f, 0.02428847f, 0.02964457f, -0.02938989f, 0.01419078f, 0.02601456f, 
    0.02933612f, -0.03549451f, -0.03151011f, 0.02738222f, -0.00818586f, -0.01279686f, 0.02418754f, -0.01294564f, 
    -0.01408652f, -0.03888889f, -0.01360982f, 0.01529527f, -0.01677531f, -0.03115756f, 0.02304485f, -0.01459847f, 
    -0.02744536f, -0.01904804f, -0.03715999f, 0.02397027f, 0.00263967f, -0.04158916f, -0.00103637f, -0.03364252f, 
    -0.02436543f, -0.00383390f, 0.01942043f, 0.02665855f, 0.01537244f, -0.00118156f, -0.03022199f, -0.01201867f, 
    0.01176547f, -0.00450132f, -0.02844354f, 0.02727074f, 0.00317434f, -0.03787392f, -0.04007120f, -0.01460460f, 
    -0.04065650f, 0.01467553f, 0.02191896f, 0.00493557f, -0.00475169f, -0.02219678f, -0.01317087f, -0.03017094f, 
    0.02031195f, 0.01086506f, 0.02878791f, -0.01278978f, 0.01106381f, -0.00199856f, -0.04182317f, -0.00424396f, 
    -0.03466879f, 0.00941846f, -0.01748136f, -0.00544825f, 0.00360045f, -0.03894055f, -0.01449786f, 0.00523479f, 
    0.02338921f, 0.01742572f, 0.01578705f, -0.00483833f, -0.02044373f, -0.00547267f, 0.03148660f, 0.03523152f, 
    0.01223142f, 0.01744915f, 0.02926534f, 0.00310952f, -0.03768790f, -0.03728312f, -0.03622346f, -0.03597040f, 
    0.01833798f, -0.02193445f, -0.04029946f, -0.04068981f, 0.00717983f, -0.02134127f, -0.00392570f, -0.02455527f, 
    -0.01222831f, -0.00833836f, -0.02029245f, -0.04007035f, -0.02754398f, -0.02691743f, 0.02355204f, -0.01497587f, 
    -0.01057864f, 0.00633366f, -0.02552324f, 0.01732983f, 0.02660566f, 0.00259257f, 0.02368176f, -0.00886845f, 
    -0.01481250f, -0.02128652f, -0.02195645f, 0.01104491f, -0.03416111f, -0.02917651f, -0.04100277f, 0.02320579f, 
    -0.01406148f, -0.03170215f, 0.00494754f, -0.04182142f, -0.01985859f, 0.01091955f, 0.01451113f, 0.01588688f, 
    0.02782735f, 0.02367616f, -0.03232953f, -0.01321839f, 0.00742614f, -0.00549310f, -0.02599575f, -0.00653004f, 
    -0.03937211f, 0.01081543f, -0.02650720f, 0.00577729f, 0.03876494f, -0.01393620f, 0.02225871f, -0.01499917f, 
    -0.02848886f, 0.02421634f, 0.02668790f, -0.00965635f, -0.01254635f, 0.01672162f, -0.03988906f, 0.01703858f, 
    0.02867956f, -0.02472459f, -0.00522236f, 0.00417782f, -0.01430019f, -0.02438334f, -0.00889310f, 0.02081148f, 
    -0.03000818f, -0.00081240f, 0.02284942f, -0.02383462f, -0.02261696f, -0.01889268f, -0.03464771f, -0.00980550f, 
    -0.03979043f, 0.00465690f, -0.03187097f, -0.01914796f, -0.00046159f, 0.00999763f, -0.02392889f, 0.00717360f, 
    -0.00607407f, -0.00489016f, -0.02466018f, 0.00795375f, -0.04124322f, -0.02109875f, 0.02643587f, -0.03938991f, 
    -0.01770172f, 0.00462123f, -0.02232413f, 0.01028746f, 0.00854447f, 0.00108824f, -0.01932235f, -0.03036289f, 
    -0.00429922f, -0.01714947f, -0.01707677f, -0.01550179f, 0.00250581f, 0.01825908f, -0.01601311f, 0.01920286f, 
    -0.02346946f, -0.01062602f, -0.01345538f, 0.00958184f, -0.00901777f, 0.01335209f, -0.01380273f, -0.00402620f, 
    -0.03851561f, -0.02066753f, 0.00379826f, -0.00510121f, -0.02167004f, -0.03134500f, 0.00428670f, -0.02282765f, 
    0.01963600f, 0.02226499f, 0.01397607f, -0.00171081f, -0.02911144f, -0.01308226f, 0.01407520f, 0.03005842f, 
    -0.03475326f, -0.03166897f, 0.01870509f, -0.00028419f, 0.00679254f, -0.03665615f, 0.00741563f, -0.00971558f, 
    0.01201374f, 0.02716462f, 0.01469977f, -0.03337283f, 0.01483675f, 0.01174652f, 0.00624826f, 0.01895740f, 
    0.02304832f, -0.03122728f, -0.00042593f, 0.00385491f, -0.02681753f, 0.01227671f, 0.01890813f, 0.01252940f, 
    -0.02971181f, -0.00916199f, -0.00041926f, -0.01560469f, -0.03448778f, -0.03406781f, 0.00545084f, 0.02530873f, 
    -0.00813007f, -0.04042493f, -0.00296800f, -0.02290329f, -0.00817187f, 0.01136003f, 0.01825392f, 0.01420072f, 
    0.03002547f, 0.02962806f, -0.02646993f, 0.00380886f, 0.01979420f, -0.00412784f, 0.01932026f, -0.01830458f, 
    -0.00255475f, 0.00713928f, -0.02264672f, -0.01257977f, 0.00828090f, 0.00576029f, -0.00951766f, 0.02739671f, 
    -0.00859257f, 0.00280647f, -0.00910913f, 0.01289165f, -0.01978233f, -0.01723179f, -0.01856340f, 0.00335483f, 
    -0.03314642f, -0.00636647f, -0.03353455f, 0.00011951f, -0.03159272f, 0.00411167f, 0.01091595f, -0.02443672f, 
    0.00390588f, -0.01250403f, -0.00111987f, 0.02025141f, -0.03480301f, -0.01627066f, -0.03289995f, 0.02950115f, 
    -0.03489885f, 0.02515824f, -0.00637164f, -0.03936005f, 0.02524057f, 0.01402178f, -0.01827961f, -0.03308264f, 
    0.00916572f, 0.02030115f, 0.02026655f, -0.00216512f, 0.01447807f, -0.02405610f, -0.03723842f, -0.00769460f, 
    -0.04133978f, -0.01589310f, 0.00974574f, -0.01499356f, -0.03412392f, -0.01310768f, -0.01661128f, -0.00075238f, 
    0.01782500f, -0.01413913f, -0.00888553f, -0.01613812f, -0.01143100f, -0.02577564f, 0.01996920f, -0.03033802f, 
    -0.02184252f, -0.00364017f, -0.01046350f, -0.01539998f, -0.02084499f, -0.03240657f, -0.01863731f, -0.01158668f, 
    0.00417166f, 0.01851133f, 0.02195807f, -0.01570862f, -0.00768828f, -0.01885068f, 0.00061433f, -0.02400831f, 
    -0.00866197f, -0.03569640f, 0.01329732f, -0.02252390f, -0.00487887f, 0.01258121f, -0.00117956f, -0.00162318f, 
    -0.03954827f, -0.02379766f, -0.03016052f, 0.02433212f, 0.01830926f, 0.01057517f, 0.02070626f, -0.02312883f, 
    -0.03928205f, -0.03344830f, -0.01211078f, -0.03349404f, 0.01784204f, -0.01688606f, -0.00528526f, 0.01171017f, 
    0.01591744f, 0.00807051f, 0.01451059f, -0.00020843f, -0.00623164f, 0.00006787f, 0.01570259f, -0.01453661f, 
    0.01779473f, -0.03770453f, 0.02135859f, -0.01975849f, -0.02007453f, -0.01678791f, -0.02206423f, -0.04055692f, 
    -0.03358187f, 0.02992339f, 0.00489604f, -0.02045656f, 0.01723718f, -0.02152501f, 0.01845223f, 0.02973174f, 
    0.02699338f, 0.00449391f, 0.02084599f, -0.03208608f, -0.03608432f, -0.01998336f, -0.02324767f, 0.00757473f, 
    -0.01065849f, 0.01849086f, 0.01644539f, 0.01971593f, 0.00866752f, -0.01256762f, 0.02477654f, -0.00645935f, 
    0.02870217f, -0.01088652f, 0.02384713f, 0.01877367f, 0.02997394f, -0.01258555f, 0.00249594f, -0.02537458f, 
    0.20927492f, 0.12978062f, 0.22087936f, -0.04966954f, -0.00774964f, -0.09176949f, -0.11340667f, 0.00247054f, 
    -0.03428546f, -0.04697538f, -0.17145406f, -0.03630966f, 0.27027854f, -0.15082574f, 0.04883448f, 0.25127840f, 
    0.06421913f, -0.02822790f, -0.08244549f, -0.18455608f, 0.00900519f, -0.01684439f, 0.03402218f, 0.03815142f, 
    0.13330054f, 0.02039730f, 0.05108082f, 0.09679165f, 0.05487542f, 0.06616305f, 0.00393830f, -0.01040554f, 
    0.01889309f, 0.02034594f, -0.06181087f, -0.02301587f, 0.38889840f, -0.03985452f, 0.10866490f, 0.15050021f, 
    0.14504185f, -0.14124335f, 0.00619962f, -0.12461047f, -0.15519245f, 0.04688407f, 0.08882087f, -0.00169147f, 
    -0.12655276f, -0.16797183f, -0.16772597f, 0.12281561f, 0.04738059f, 0.02508065f, 0.06363368f, 0.03013982f, 
    -0.03301690f, 0.15857866f, 0.03249297f, 0.00878744f, -0.27093682f, 0.35261980f, 0.13449082f, 0.15540767f, 
    -0.09406734f, -0.06984250f, -0.07371213f, 0.00227775f, -0.09570381f, -0.01457991f, 0.09696279f, -0.00228799f, 
    -0.12385551f, -0.03333463f, 0.01851455f, 0.13315053f, 0.01847048f, 0.02646580f, 0.00675902f, 0.02258017f, 
    0.02081188f, 0.09396005f, 0.12125359f, 0.14286958f, 0.07469957f, 0.17423606f, 0.15577191f, -0.01589389f, 
    -0.01842296f, -0.00178520f, -0.03351641f, -0.01413794f, -0.09423084f, 0.00464394f, 0.00949562f, -0.05948673f, 
    -0.00559926f, 0.13796833f, -0.01040090f, -0.20342734f, -0.06391836f, -0.00696940f, -0.04072554f, -0.03960523f, 
    0.13702300f, 0.02781401f, -0.11624406f, -0.15241474f, 0.45004699f, -0.08074130f, -0.01537131f, -0.15239237f, 
    0.01766777f, 0.12094763f, -0.03270831f, 0.00705625f, -0.07262380f, -0.04858219f, -0.01086532f, -0.12653358f, 
    -0.20044851f, -0.12217370f, -0.03398930f, 0.02848363f, 0.06882239f, 0.05384502f, 0.10632747f, 0.17196880f, 
    0.11697661f, 0.06534447f, -0.02462185f, -0.03435350f, 0.01470490f, -0.05292950f, 0.04036219f, 0.15189020f, 
    0.07848532f, 0.08063240f, 0.02307589f, -0.09114658f, -0.14827263f, 0.04996139f, -0.12204042f, 0.01522591f, 
    0.00038174f, 0.09183253f, -0.07842969f, 0.00573404f, -0.14744905f, -0.05210829f, -0.14571518f, -0.24642625f, 
    0.06099231f, 0.10232756f, -0.05018204f, 0.05757692f, 0.25003907f, 0.16022694f, 0.00922733f, 0.10498730f, 
    0.02790098f, -0.01776993f, -0.04538539f, -0.08624881f, 0.01824367f, 0.14323014f, -0.12651820f, 0.13282551f, 
    0.19038409f, 0.26614398f, 0.30595607f, 0.01916166f, 0.01734084f, -0.09963734f, 0.04045605f, -0.01374644f, 
    0.11634586f, 0.19487609f, 0.09679387f, 0.04694846f, -0.37001190f, 0.35524711f, -0.14967543f, -0.01645602f, 
    0.30657417f, 0.10680851f, -0.06880062f, -0.00470890f, -0.15743968f, 0.05031397f, 0.02825380f, -0.03909747f, 
    0.20480390f, 0.09126113f, -0.14890167f, -0.12590259f, -0.12644161f, -0.02228256f, -0.13915174f, 0.00845826f, 
    0.04813315f, 0.00258350f, 0.08734474f, -0.00071480f, 0.04085272f, -0.01979553f, 0.08149404f, 0.22465700f, 
    0.11467732f, -0.08645441f, 0.10910758f, 0.03679113f, -0.02067046f, 0.06624482f, -0.13986151f, 0.00947755f, 
    -0.02650931f, -0.03223616f, 0.08430696f, 0.06360906f, -0.03918205f, -0.10432790f, -0.08775660f, 0.03966854f, 
    -0.05649139f, 0.03562580f, 0.00851438f, 0.03139609f, 0.02320892f, 0.00782651f, -0.13057694f, 0.06036681f, 
    0.02889286f, 0.07086492f, -0.00755967f, -0.13508439f, -0.07075527f, -0.13543755f, 0.10691822f, 0.07801238f, 
    -0.27839589f, -0.06274376f, -0.06108138f, 0.35523307f, -0.00591306f, -0.02027197f, 0.06734414f, 0.10961815f, 
    -0.04048500f, 0.13568483f, -0.00281460f, 0.16099945f, -0.02665192f, -0.16123323f, -0.11773050f, 0.13298531f, 
    -0.06179992f, -0.04886464f, 0.03860691f, 0.19087118f, 0.10481869f, 0.08133115f, 0.07474266f, -0.06035387f, 
    -0.13490099f, -0.24193369f, 0.02210872f, 0.19281685f, 0.08157830f, 0.13054888f, -0.05284843f, 0.10025091f, 
    0.19042955f, -0.05783606f, -0.06207346f, 0.05671162f, 0.19498645f, 0.03030648f, 0.05311106f, 0.20838928f, 
    0.00248852f, -0.15436426f, 0.19392155f, -0.05318961f, -0.03106904f, -0.04863657f, -0.18780704f, -0.03597422f, 
    0.06594386f, -0.05882988f, 0.09114044f, 0.02164204f, -0.03571258f, -0.05417017f, 0.02187637f, 0.03763982f, 
    -0.00111237f, 0.11041193f, 0.07512312f, 0.19593415f, 0.00396266f, -0.03802852f, -0.13912126f, 0.07714178f, 
    -0.08266482f, -0.04441107f, 0.01472205f, -0.00908636f, -0.08667600f, 0.10160195f, 0.05544021f, -0.02523696f, 
    0.01674280f, 0.01285413f, 0.06209145f, -0.16321497f, -0.08105145f, 0.14892952f, -0.06488402f, -0.09533220f, 
    0.03780432f, -0.00259750f, 0.03116499f, -0.07475393f, 0.04016326f, -0.01841111f, 0.21595450f, -0.13593715f, 
    -0.14749596f, -0.04680814f, -0.00640692f, -0.00951103f, 0.05939559f, 0.25661725f, -0.00448262f, 0.17842007f, 
    -0.02443426f, 0.04510446f, 0.01899528f, 0.08548006f, 0.05441389f, 0.03266604f, 0.03119989f, -0.00503433f, 
    0.02746167f, -0.08940318f, -0.12601399f, -0.12995978f, 0.04637167f, 0.11939850f, 0.09087694f, 0.14119887f, 
    -0.03026909f, -0.04469291f, -0.01792756f, -0.02458217f, -0.13145266f, 0.08882637f, -0.10536476f, -0.12513150f, 
    -0.21333572f, 0.36925593f, 0.01459868f, 0.43318418f, 0.15514684f, -0.06309365f, -0.04445688f, -0.12366784f, 
    0.07252390f, -0.08063079f, 0.08161097f, 0.04750006f, -0.03421078f, 0.09990703f, -0.11655218f, 0.04076874f, 
    -0.15089904f, -0.05448708f, -0.02144298f, -0.11158951f, -0.02030812f, -0.00557179f, 0.00632812f, 0.04753152f, 
    0.07016525f, 0.02664301f, -0.00513378f, 0.14508799f, 0.03145027f, -0.05303345f, -0.03969657f, 0.02880588f, 
    0.01796898f, -0.09401249f, -0.02168231f, -0.04298697f, -0.27679127f, 0.01971431f, -0.16087633f, 0.21669695f, 
    -0.09134418f, 0.00486890f, -0.09607015f, -0.02072721f, -0.04471713f, -0.05591324f, -0.04202548f, -0.00696450f, 
    -0.21395312f, -0.06108636f, 0.10415912f, 0.11568050f, -0.04010996f, -0.00173759f, 0.01514462f, 0.14778532f, 
    0.00118753f, 0.12681995f, 0.06829000f, 0.07011580f, 0.18735966f, 0.15694840f, -0.09946982f, 0.04078560f, 
    0.14000815f, -0.04240839f, -0.03847575f, 0.03667645f, -0.20429924f, 0.03409746f, 0.04880102f, 0.03493817f, 
    -0.38277042f, 0.37077045f, -0.24191028f, 0.10938083f, 0.08265258f, 0.22299351f, -0.13233745f, 0.12444008f, 
    -0.05804828f, 0.09696542f, 0.08059892f, 0.10954925f, -0.10831773f, -0.15719919f, 0.01507565f, 0.02392375f, 
    -0.06451251f, 0.02653226f, 0.00050915f, -0.09749071f, 0.00644393f, 0.10625269f, 0.02213550f, 0.00779676f, 
    0.16237810f, -0.19107200f, -0.05034650f, -0.05233572f, -0.13519426f, -0.01047341f, 0.06848419f, 0.08283542f, 
    -0.13414627f, 0.01661969f, -0.02672057f, 0.05631126f, 0.26086897f, 0.04632817f, 0.08541986f, -0.06870414f, 
    -0.21814398f, -0.11706339f, 0.09612060f, -0.05660467f, 0.03624754f, 0.00507896f, 0.02894039f, -0.14833920f, 
    -0.01038796f, 0.12841286f, 0.12641062f, 0.17946650f, 0.10276144f, 0.02030164f, 0.11275554f, 0.01672820f, 
    -0.06240159f, -0.15025309f, 0.04520275f, 0.01926440f, 0.43641567f, 0.06728248f, 0.04730573f, -0.04603574f, 
    0.02179329f, 0.06249976f, -0.14935713f, -0.03905391f, -0.08367573f, 0.00995344f, -0.09787619f, 0.03429555f, 
    0.14495781f, 0.06764657f, 0.06775033f, -0.03992386f, -0.04007467f, 0.09595101f, -0.04184766f, -0.01825601f, 
    0.06422833f, -0.04561632f, 0.12920982f, 0.09515153f, -0.15876962f, -0.00256101f, -0.04121013f, 0.04669261f, 
    0.02997717f, -0.14911348f, -0.11528278f, 0.15619716f, -0.06777165f, -0.02647614f, -0.03745948f, -0.11666825f, 
    -0.04451621f, 0.34367734f, -0.12306130f, 0.07151847f, -0.11802527f, 0.11581784f, 0.13694230f, 0.01419628f, 
    0.19887847f, 0.24691150f, -0.00843193f, 0.09950208f, -0.01072972f, -0.22435082f, -0.02874490f, 0.10368997f, 
    0.12970716f, 0.05350780f, 0.07402220f, -0.01152802f, -0.06168875f, 0.13903829f, 0.04420202f, 0.06046459f, 
    0.08893190f, -0.07469600f, -0.16178398f, -0.10766824f, 0.14323577f, -0.04123804f, -0.01278451f, 0.06135776f, 
    -0.06890601f, -0.14549901f, -0.00824028f, -0.07697141f, 0.00016838f, -0.18438387f, -0.01744435f, 0.15526842f, 
    -0.05809346f, -0.09415863f, -0.09447707f, -0.01910122f, -0.13250613f, 0.04840961f, -0.09180304f, -0.11672909f, 
    0.05567137f, -0.09004693f, 0.12630866f, 0.04889050f, -0.04102858f, 0.00609978f, -0.05234743f, -0.03401048f, 
    -0.13301548f, -0.15355906f, -0.07384928f, -0.08645069f, 0.13831119f, -0.13971809f, 0.07652985f, -0.01002429f, 
    -0.03056841f, -0.11238189f, 0.05415713f, -0.15069142f, -0.01406564f, 0.18313231f, -0.02504502f, -0.01118048f, 
    0.45863613f, 0.03724194f, 0.60138869f, -0.23959742f, -0.09471438f, -0.12902454f, -0.09453911f, -0.13150686f, 
    0.03342410f, 0.14587100f, 0.01528824f, 0.02230312f, -0.46970904f, 0.25801054f, 0.06183757f, 0.05420351f, 
    0.14936756f, 0.14795101f, -0.08105585f, -0.05511823f, -0.00075962f, -0.00836939f, 0.23262709f, -0.07045483f, 
    -0.18545078f, -0.08933173f, 0.15810460f, -0.00958872f, -0.07453924f, -0.00530707f, -0.04843677f, -0.03579373f, 
    0.02719526f, 0.08475658f, -0.00366484f, 0.09342408f, 0.00292548f, 0.18572022f, 0.10559589f, -0.07322215f, 
    -0.07366049f, 0.07900442f, 0.05529983f, 0.07352945f, -0.01868758f, 0.09593628f, 0.07771856f, 0.15412886f, 
    0.08230323f, 0.13928322f, -0.11671203f, -0.06714360f, -0.11666884f, -0.14417432f, -0.08367557f, 0.06405900f, 
    -0.02173732f, -0.00513443f, -0.10354867f, 0.04699164f, 0.20103815f, 0.09821096f, 0.22934256f, -0.04853776f, 
    0.08725382f, -0.06748773f, -0.04872179f, -0.06640072f, -0.00363583f, 0.08259351f, -0.07348514f, -0.13381110f, 
    -0.25804341f, -0.13123275f, -0.00676008f, 0.02685595f, -0.00231960f, -0.04362796f, -0.01472498f, 0.07091976f, 
    0.10881981f, 0.07120802f, 0.07346178f, -0.02657565f, -0.41296116f, 0.18023624f, 0.04790098f, 0.05514814f, 
    -0.10720281f, 0.12014928f, 0.03430740f, -0.03989413f, -0.02420898f, 0.06231270f, 0.13478121f, 0.05597287f, 
    -0.19172458f, -0.15367369f, -0.04038854f, -0.00472255f, 0.07457485f, -0.09786771f, -0.09040985f, 0.17824072f, 
    -0.06785993f, 0.18081547f, -0.08511405f, -0.01507416f, -0.01078203f, 0.27381659f, -0.11960238f, -0.23525412f, 
    0.06814315f, 0.03204419f, 0.01567565f, 0.03730218f, -0.08613142f, 0.08218943f, 0.02036998f, 0.02489497f, 
    0.16505881f, 0.13843705f, -0.06286220f, -0.08453194f, -0.00811927f, 0.01467371f, 0.01405166f, -0.15682939f, 
    -0.08113275f, -0.09319656f, -0.00225273f, -0.12732193f, -0.01196145f, -0.04566121f, -0.05804338f, -0.03631974f, 
    -0.09266889f, -0.02069654f, -0.02828526f, 0.02559691f, 0.04436756f, 0.23265477f, 0.06326534f, 0.12069991f, 
    0.05489230f, -0.16482370f, 0.12572989f, -0.02852856f, -0.04535186f, -0.04287450f, 0.06293461f, -0.10183164f, 
    -0.06089058f, -0.03678237f, -0.08662681f, -0.05624967f, 0.09767990f, 0.11421870f, 0.03507984f, 0.03892457f, 
    -0.01342962f, 0.04495081f, 0.05224266f, -0.05607967f, 0.03982355f, -0.05243241f, 0.06258635f, -0.18643917f, 
    -0.03280920f, -0.01772138f, 0.00161472f, 0.01896654f, -0.03190963f, -0.02602934f, 0.01595688f, -0.01006503f, 
    -0.03137583f, -0.00584986f, -0.02038955f, 0.01979882f, 0.00604867f, -0.02792240f, -0.01663818f, 0.01160726f, 
    -0.02931538f, -0.01101136f, 0.03747469f, 0.02816345f, -0.01484178f, -0.03064488f, 0.03828431f, -0.00152999f, 
    -0.01723555f, 0.02718061f, 0.02341795f, 0.01391985f, -0.03459496f, 0.01867261f, 0.00259209f, -0.00758473f, 
    -0.02094823f, -0.00169970f, 0.02502726f, -0.01147004f, -0.00329546f, -0.03988523f, -0.02285964f, 0.02546734f, 
    0.02022815f, 0.00970393f, 0.01079594f, 0.00873646f, -0.04149951f, 0.00090377f, -0.01240628f, 0.02443436f, 
    -0.03866833f, 0.02573011f, -0.00432296f, 0.03128733f, 0.00701983f, 0.00987713f, -0.02552029f, 0.03551836f, 
    0.01691125f, -0.03269677f, 0.00722997f, -0.01383439f, 0.02767739f, 0.02065458f, 0.01093142f, 0.02095866f, 
    -0.03387504f, 0.01175062f, -0.02897996f, 0.01205943f, -0.04389802f, 0.00590308f, -0.03368291f, -0.00516008f, 
    0.02030938f, -0.02054146f, 0.00646914f, 0.03295997f, -0.03326809f, -0.01990104f, 0.00793259f, 0.01313417f, 
    -0.03053589f, -0.02376117f, -0.02827381f, 0.02992697f, 0.01545043f, -0.01886592f, 0.01831144f, 0.01013516f, 
    -0.01242049f, 0.01196517f, 0.00180846f, -0.01852629f, 0.02381561f, 0.01748380f, -0.01179217f, 0.02811441f, 
    -0.02381565f, 0.00187875f, 0.03462834f, -0.01371564f, 0.02046168f, -0.03612910f, -0.01120872f, -0.02828317f, 
    0.01354576f, 0.01254261f, 0.02015428f, 0.01472371f, 0.01520772f, -0.01244941f, -0.00152013f, -0.01733753f, 
    0.00001636f, -0.00795512f, 0.01993477f, 0.02438135f, 0.00276757f, 0.01546794f, -0.02868862f, -0.01539813f, 
    0.02824598f, -0.00488509f, -0.03026734f, -0.00620905f, 0.03032910f, -0.02137144f, -0.00984248f, 0.00685320f, 
    -0.01412838f, 0.03338270f, 0.01926162f, 0.02261513f, -0.02509774f, -0.03686289f, -0.02386124f, -0.03979419f, 
    0.02585959f, 0.00098230f, -0.00282849f, -0.00398851f, -0.00832887f, 0.00736263f, 0.02499129f, -0.00282258f, 
    -0.01765904f, -0.04315789f, -0.02641058f, 0.03430780f, 0.00387725f, -0.02241152f, 0.01069019f, 0.00516786f, 
    0.01309429f, -0.01905502f, -0.02222865f, -0.01745495f, 0.03687422f, 0.03667299f, 0.01292190f, -0.01345445f, 
    0.00313954f, 0.02682167f, 0.02336704f, -0.00308525f, -0.02116114f, 0.00264132f, -0.03798568f, -0.03446938f, 
    -0.00989281f, 0.01261772f, -0.00295092f, -0.03786690f, -0.03093535f, 0.01589202f, -0.03241070f, -0.00617164f, 
    -0.02985685f, 0.00170750f, -0.03595506f, -0.02643843f, 0.01064729f, -0.00290851f, 0.02438409f, 0.00300803f, 
    -0.02346634f, 0.02942729f, -0.03073820f, 0.00903987f, -0.03405879f, -0.03673566f, -0.03014764f, -0.00293593f, 
    0.02950167f, -0.01966670f, -0.01331222f, -0.02262177f, 0.02412821f, -0.02155442f, 0.00209556f, -0.03751699f, 
    -0.00243436f, -0.00148400f, 0.02364998f, 0.01506669f, -0.02006654f, 0.00537813f, -0.01431146f, 0.01510975f, 
    -0.02568452f, -0.03573981f, 0.00048722f, -0.00717503f, 0.00246646f, 0.01922322f, 0.01131539f, 0.01715444f, 
    0.00828794f, -0.00430879f, 0.01375988f, -0.01045492f, -0.03499198f, -0.02001712f, -0.00258327f, -0.00907675f, 
    -0.03335698f, 0.00497832f, 0.00617286f, -0.03306918f, 0.02903992f, -0.04173401f, 0.02146525f, 0.01386866f, 
    -0.03479365f, -0.01965156f, 0.02175779f, -0.03483442f, -0.02218162f, -0.04108088f, -0.00104855f, -0.03057013f, 
    -0.00955310f, 0.00411847f, -0.02342964f, 0.00929142f, 0.00793080f, -0.01659631f, -0.02271156f, -0.02781170f, 
    0.01436465f, 0.01756137f, -0.00693719f, -0.02272183f, -0.00911501f, 0.01223017f, 0.02749582f, -0.02600306f, 
    -0.03640507f, 0.02815905f, -0.03741856f, 0.00669850f, 0.00718161f, -0.03322647f, -0.01949438f, -0.02962135f, 
    -0.01977979f, 0.02668011f, -0.00202449f, 0.01745252f, 0.01112850f, 0.01269808f, -0.01912075f, 0.02542252f, 
    -0.00199233f, -0.00271306f, 0.00892475f, -0.00025488f, 0.02205899f, -0.02056439f, 0.02550027f, -0.01753969f, 
    0.02243839f, 0.00089103f, -0.01633192f, -0.01672254f, -0.03780920f, 0.02351910f, -0.04172689f, -0.00017828f, 
    -0.02752372f, 0.02159291f, 0.02632350f, -0.00042652f, -0.02949623f, 0.02886406f, -0.03271837f, -0.01283712f, 
    0.02450954f, -0.01064131f, -0.02369264f, -0.02467878f, 0.01776681f, 0.02096527f, 0.02038007f, -0.01887005f, 
    0.01684392f, -0.03524286f, -0.00193593f, 0.00917495f, -0.00822154f, -0.03418947f, -0.00284140f, 0.01948561f, 
    -0.03016420f, -0.03412706f, -0.02582081f, 0.00896567f, 0.01003611f, 0.01229270f, 0.00060685f, -0.00393713f, 
    0.02355680f, 0.02690494f, 0.00009009f, -0.02362346f, -0.03806422f, 0.01125864f, 0.01195241f, 0.00815060f, 
    -0.01954176f, -0.03105088f, -0.00940503f, 0.01322839f, -0.02286615f, 0.00544343f, -0.00507139f, -0.00671304f, 
    0.01262009f, -0.00361824f, -0.03121573f, -0.02099129f, -0.03432950f, -0.04364221f, 0.00553875f, -0.03649083f, 
    -0.00882182f, -0.00682822f, -0.01823216f, -0.03792914f, -0.04117317f, -0.03290261f, 0.02497437f, -0.03897176f, 
    0.02194965f, 0.02297099f, -0.02756952f, -0.00797274f, 0.00646346f, -0.02577816f, 0.00928436f, -0.00041254f, 
    -0.01440690f, -0.01467559f, -0.03337537f, -0.01316884f, 0.02502581f, 0.00428410f, -0.01297211f, -0.03700224f, 
    -0.01102586f, 0.02406242f, -0.02822050f, -0.00859577f, 0.02079370f, -0.00253429f, 0.00556196f, 0.00454906f, 
    0.01070296f, 0.02593917f, -0.01366886f, -0.02924225f, -0.03428440f, 0.01695029f, 0.01636572f, 0.01567543f, 
    0.01969902f, -0.02891105f, 0.01224002f, -0.02915715f, -0.03706129f, -0.00979921f, -0.02805238f, 0.01816623f, 
    -0.03161674f, 0.02745975f, -0.04029938f, 0.01859802f, -0.01379550f, 0.00702873f, -0.03284236f, 0.02347419f, 
    -0.00834403f, -0.01706938f, -0.00623072f, 0.00685936f, 0.00762736f, -0.02121106f, 0.02785752f, -0.01814435f, 
    0.00530288f, -0.00970906f, 0.01920908f, -0.01717262f, 0.00318416f, 0.00340708f, -0.02743031f, 0.01001150f, 
    0.03355200f, 0.00498258f, -0.02967770f, -0.02430645f, -0.03619330f, 0.01658958f, 0.00868767f, 0.00562781f, 
    0.01997901f, -0.02513579f, -0.00652274f, -0.03678407f, 0.01000738f, 0.00204001f, -0.02487044f, 0.01410003f, 
    0.02252967f, 0.01611091f, -0.01217542f, 0.02224546f, -0.02929878f, -0.00780953f, -0.00857738f, -0.02239686f, 
    -0.03259046f, 0.01586874f, -0.01100666f, -0.02275831f, 0.01540183f, -0.02055636f, 0.01085912f, 0.01869333f, 
    -0.02000776f, -0.03483573f, 0.02517475f, -0.00043538f, 0.01871611f, -0.01452970f, 0.02355726f, 0.02908823f, 
    -0.01258875f, -0.02494575f, -0.01260240f, -0.00418286f, -0.00143829f, -0.01767989f, -0.01148907f, 0.01199330f, 
    -0.03912319f, -0.00257651f, -0.01514016f, 0.00346444f, -0.02963085f, 0.00808027f, -0.03018550f, -0.01587901f, 
    0.02270691f, -0.04155232f, 0.00454281f, 0.02144779f, 0.01176431f, -0.03665435f, 0.01180585f, -0.01034985f, 
    0.02531511f, -0.02363720f, -0.01608501f, 0.02041515f, 0.01074454f, 0.01640873f, -0.02637082f, -0.00590899f, 
    -0.02911147f, 0.01973240f, 0.02254771f, -0.03943937f, -0.03185830f, 0.02105746f, -0.01315315f, -0.02906928f, 
    0.00520500f, 0.00129015f, 0.02925607f, 0.02913492f, -0.01151248f, -0.03283677f, -0.01157608f, 0.00965094f, 
    -0.03244923f, 0.02094141f, 0.00838633f, -0.02099993f, -0.00917859f, -0.02569074f, 0.01039634f, -0.03731577f, 
    -0.02865007f, 0.02557077f, 0.01388648f, -0.04268864f, 0.01916529f, -0.00525319f, -0.02572839f, 0.02240375f, 
    -0.00011305f, 0.01573199f, -0.02858721f, -0.03135348f, 0.02417869f, -0.03593252f, -0.01094863f, 0.02380893f, 
    0.00311071f, -0.02098149f, 0.00097001f, 0.00890441f, 0.02415148f, -0.02047858f, -0.03027106f, -0.02628074f, 
    0.03841823f, 0.03637188f, -0.00138284f, -0.02104646f, -0.03108243f, 0.02692029f, -0.02626139f, -0.01917068f, 
    0.00591617f, -0.04056776f, -0.00080123f, 0.00294241f, -0.01061729f, 0.01713978f, 0.03155269f, -0.02946127f, 
    0.00523062f, -0.03255154f, 0.02621572f, -0.00634309f, 0.00099745f, -0.02212427f, -0.02711611f, -0.01143070f, 
    -0.01958167f, -0.02401143f, -0.02773379f, 0.02241320f, 0.01302606f, -0.00790928f, 0.01775989f, 0.00910658f, 
    0.00811317f, -0.00820496f, 0.03454987f, -0.00044901f, -0.00518911f, 0.00171100f, -0.02782076f, 0.00644710f, 
    -0.03561308f, -0.02635695f, -0.00850428f, -0.01071601f, -0.01162881f, -0.01332868f, -0.01966468f, 0.01906429f, 
    0.00260830f, 0.00782646f, -0.00168938f, 0.00103283f, -0.03375403f, -0.02968347f, 0.01307655f, -0.03121055f, 
    -0.04163938f, 0.00210901f, -0.01700872f, -0.00500941f, 0.04117693f, -0.01187837f, -0.01960615f, 0.01917654f, 
    -0.01992132f, -0.02480451f, -0.01600671f, 0.02929546f, 0.00744723f, 0.02855281f, 0.02019682f, -0.00910531f, 
    -0.03351804f, -0.03446198f, -0.03087436f, 0.00846087f, -0.01462466f, 0.00290667f, -0.00561153f, 0.00580143f, 
    -0.03757429f, -0.01173118f, 0.02123854f, -0.01966309f, -0.02141550f, 0.02215873f, -0.02503688f, 0.00673569f, 
    0.00867561f, 0.02738037f, 0.00851141f, 0.01049930f, -0.02956780f, 0.00577646f, -0.00764029f, 0.02259931f, 
    0.02402912f, -0.01133689f, -0.02627752f, 0.02573774f, -0.02377835f, -0.02993216f, -0.00794092f, 0.02146784f, 
    -0.00491944f, 0.01964301f, 0.02241538f, -0.00119986f, -0.03097479f, 0.03008412f, -0.00915830f, -0.00607394f, 
    -0.01635141f, 0.00339976f, -0.01088677f, 0.01073821f, -0.00493996f, -0.03381839f, -0.01460651f, -0.01527005f, 
    -0.02949259f, -0.01402988f, -0.00041842f, 0.01473671f, -0.02824738f, 0.01337169f, 0.00806427f, -0.03488414f, 
    0.01427565f, -0.04118781f, -0.02823229f, 0.01420308f, -0.01477580f, -0.03387858f, 0.00843741f, -0.00491105f, 
    -0.01460086f, 0.02279358f, 0.00446616f, 0.02046229f, 0.00367454f, -0.03920727f, 0.01811179f, 0.00876127f, 
    0.03042744f, -0.00210625f, -0.02683521f, -0.01608323f, 0.00201150f, 0.01455139f, 0.00294976f, 0.02435407f, 
    0.02465120f, 0.00018668f, -0.03938248f, -0.00356297f, 0.03031796f, 0.01694852f, -0.01338046f, 0.01238599f, 
    -0.02622180f, 0.01136649f, -0.03930934f, -0.01887190f, 0.00943813f, -0.00615190f, -0.02016814f, 0.02473251f, 
    -0.03933584f, 0.01293667f, -0.01327517f, -0.01440110f, 0.00741752f, -0.01208363f, 0.00374561f, 0.02235155f, 
    -0.01174266f, -0.03604633f, -0.01790152f, 0.02556018f, -0.00659940f, -0.01409322f, -0.01538076f, -0.01066731f, 
    -0.02548100f, -0.01978447f, 0.01976146f, -0.02447884f, 0.02010369f, -0.04198616f, -0.01918667f, -0.00200611f, 
    0.01667000f, -0.02467904f, 0.02444891f, -0.01774298f, 0.00708920f, 0.00528436f, -0.00346681f, -0.02895851f, 
    -0.01307614f, -0.03689567f, -0.01030073f, -0.03951506f, 0.00446898f, 0.00622036f, 0.01216200f, -0.03602709f, 
    0.02084347f, 0.01819368f, 0.02331733f, 0.01690993f, -0.00552794f, -0.01172651f, -0.02845727f, 0.03075831f, 
    -0.01936836f, 0.00581201f, -0.03486009f, 0.02610076f, -0.00122616f, -0.01880702f, 0.00313510f, 0.02102177f, 
    0.00901253f, 0.02969986f, -0.00169802f, -0.03306411f, -0.01554704f, 0.01315974f, -0.03442675f, 0.00860213f, 
    0.18818723f, 0.29486760f, 0.20049302f, 0.21877867f, -0.00442972f, 0.00201217f, 0.03495320f, 0.04059486f, 
    0.00689948f, 0.10538147f, 0.00375337f, -0.12010443f, -0.20069338f, -0.35415557f, -0.51607198f, -0.18845087f, 
    -0.01024229f, -0.04229527f, 0.06392064f, 0.18903397f, -0.10287926f, -0.07290416f, -0.20849453f, -0.24169879f, 
    0.15384738f, 0.09730755f, 0.11176673f, 0.04642565f, -0.02159551f, 0.00961372f, 0.02309678f, -0.04574170f, 
    0.15703344f, 0.00528778f, 0.01754895f, -0.06117022f, -0.17899172f, -0.42104894f, -0.51514375f, -0.28583828f, 
    -0.07126756f, -0.08127680f, 0.02712928f, -0.00435334f, -0.11045942f, 0.02184795f, -0.08825016f, 0.05154759f, 
    -0.00456107f, -0.26954427f, -0.11528460f, -0.06115736f, 0.01443856f, -0.00951529f, 0.03340362f, 0.04358910f, 
    -0.06700664f, -0.12757722f, -0.10278015f, 0.12125223f, 0.19851008f, -0.33725804f, -0.21555604f, -0.04805576f, 
    -0.04313481f, 0.00138517f, 0.00910254f, 0.04311290f, 0.00476145f, 0.11521617f, 0.22892989f, -0.07915557f, 
    -0.13777013f, -0.18588749f, -0.46634871f, -0.49677196f, 0.07139689f, 0.09624144f, 0.07291389f, -0.04280720f, 
    -0.17458937f, 0.00980863f, -0.10320996f, 0.07141049f, 0.34848270f, 0.25502017f, 0.16833617f, 0.07559324f, 
    0.04467356f, -0.05220163f, 0.05011409f, 0.00949917f, 0.06736139f, 0.00569616f, -0.10599679f, -0.10668124f, 
    0.16948752f, 0.13445722f, 0.01955704f, -0.19207747f, 0.06476957f, 0.00024001f, 0.01080592f, -0.02548804f, 
    -0.16687977f, -0.05000000f, 0.07651850f, -0.06833614f, 0.14966007f, 0.04861371f, 0.10131306f, 0.04819931f, 
    -0.00002490f, 0.03897213f, -0.00533560f, -0.03606124f, -0.03652423f, 0.10883354f, -0.00712391f, -0.10740734f, 
    -0.05263135f, -0.14766754f, -0.08435909f, -0.05628179f, -0.03150317f, 0.10849120f, -0.03931507f, -0.09373192f, 
    -0.06944712f, -0.12897377f, -0.03910322f, 0.04094137f, 0.28913340f, 0.11919083f, 0.22019993f, 0.13258161f, 
    0.08519714f, 0.16477610f, -0.06460764f, 0.11541875f, 0.14293791f, 0.22764109f, 0.23764394f, -0.10690369f, 
    0.20275493f, 0.24685682f, 0.16174313f, -0.02625236f, -0.03101158f, -0.07147992f, -0.08782803f, -0.02729562f, 
    0.04414918f, 0.04925098f, -0.00590201f, 0.09414702f, 0.15065612f, 0.28516471f, 0.20738833f, 0.02583530f, 
    0.02776860f, 0.03627992f, -0.00924559f, 0.03170334f, 0.10386452f, 0.08230595f, 0.02287556f, -0.02328293f, 
    0.12244979f, 0.20863880f, 0.00281066f, 0.23343720f, 0.00987848f, 0.08104435f, 0.16624753f, -0.01108943f, 
    0.07205370f, 0.08602932f, 0.22775128f, 0.11072724f, 0.46136731f, 0.07987697f, 0.02371172f, -0.47138304f, 
    0.12050629f, 0.13930666f, 0.00108541f, -0.05242660f, -0.07633264f, 0.05175682f, -0.02275610f, 0.00422797f, 
    0.17077352f, 0.19955675f, 0.17895725f, 0.18140490f, -0.08095580f, -0.09618215f, 0.02547231f, -0.05554122f, 
    0.08496118f, 0.04147543f, 0.02212005f, 0.01430574f, -0.16271248f, -0.35406443f, -0.16457875f, 0.24444036f, 
    0.07178490f, 0.07568546f, 0.13530421f, 0.05887331f, -0.17095235f, -0.28946221f, 0.32000643f, 0.03304448f, 
    -0.20619442f, -0.56160522f, -0.25246844f, -0.18763015f, -0.00107131f, 0.00416095f, -0.00196718f, 0.10249824f, 
    0.10358851f, -0.00487399f, 0.14701203f, 0.00125738f, -0.01047999f, 0.21087424f, 0.05839974f, 0.06912555f, 
    -0.06262258f, 0.13360721f, 0.07638925f, 0.00628614f, -0.00707616f, 0.00066689f, 0.08597019f, -0.09323490f, 
    -0.20531355f, 0.24297184f, 0.06535861f, -0.01986496f, 0.02580982f, 0.00218349f, 0.15869312f, 0.05386728f, 
    -0.05536844f, -0.02033709f, 0.04480071f, 0.06723852f, -0.14876978f, -0.15794086f, -0.19132331f, -0.05180050f, 
    0.00098944f, 0.06136030f, 0.02931568f, 0.11421209f, 0.16004124f, 0.26290831f, 0.02767869f, -0.07586871f, 
    -0.09558544f, -0.09209286f, -0.05252367f, -0.01729829f, 0.04925513f, 0.12543930f, 0.01920476f, -0.14941221f, 
    -0.12003364f, 0.00838822f, -0.03539174f, -0.05829073f, 0.07249521f, 0.03813566f, 0.04630986f, -0.03812510f, 
    -0.02191925f, 0.15765043f, 0.18133724f, 0.03132497f, -0.01016842f, 0.00015613f, 0.09671027f, -0.06403753f, 
    -0.08816449f, -0.09348252f, -0.23466238f, 0.28072134f, -0.04992925f, -0.04098210f, -0.08445304f, -0.04293248f, 
    -0.05959160f, -0.09309681f, 0.07834978f, -0.08107278f, 0.05589274f, -0.23793349f, 0.14668392f, 0.02144055f, 
    -0.01707200f, 0.04684725f, 0.04932698f, -0.10789474f, -0.09225378f, 0.06894736f, -0.14901815f, -0.01759075f, 
    0.17692642f, -0.07478119f, 0.04120549f, 0.05553737f, 0.06165687f, 0.01377133f, 0.02014601f, 0.07628156f, 
    0.00024011f, 0.10482865f, 0.09931118f, -0.02437691f, 0.01773722f, -0.04071439f, -0.04951810f, -0.04637648f, 
    -0.09896629f, -0.09406751f, 0.00369740f, -0.00240172f, 0.06907401f, 0.05053591f, 0.11594335f, -0.02160459f, 
    -0.01169383f, -0.06235076f, 0.05440557f, -0.00191332f, 0.03838787f, 0.01313809f, -0.04093412f, 0.04644791f, 
    -0.04279580f, 0.11893931f, 0.05038485f, 0.02457395f, 0.03135109f, -0.03796866f, -0.02208397f, -0.03757203f, 
    -0.08065419f, 0.02208893f, 0.14336143f, 0.03479954f, 0.02551466f, 0.06525315f, 0.03091639f, -0.08026958f, 
    0.27156833f, 0.28995150f, 0.06657571f, 0.16553150f, 0.00138731f, -0.04279429f, 0.10400724f, -0.09834611f, 
    0.04656618f, -0.03243439f, -0.00337400f, 0.05884043f, -0.30802679f, -0.39017129f, -0.24114600f, -0.30191943f, 
    -0.08991466f, -0.00373890f, 0.00784915f, 0.21711123f, -0.10521047f, -0.13949880f, 0.02169470f, -0.11488626f, 
    0.03643420f, -0.10021811f, -0.16949856f, 0.00468719f, 0.03185280f, 0.06411451f, -0.01861546f, 0.14706801f, 
    -0.04168850f, -0.01117030f, -0.05834199f, -0.08661105f, 0.03014418f, -0.12795742f, -0.08257062f, -0.00355510f, 
    0.04004776f, 0.05734313f, 0.09227471f, 0.04889304f, -0.06872794f, -0.07978242f, -0.02819962f, -0.01463935f, 
    -0.28105763f, -0.27512762f, -0.24133819f, -0.15222746f, -0.07318213f, -0.09170851f, 0.05358436f, 0.06618973f, 
    0.00426389f, 0.11820657f, -0.00604665f, 0.03810415f, 0.34582990f, -0.20378748f, -0.21456067f, -0.43997565f, 
    -0.09203732f, -0.01661737f, -0.03618833f, 0.11324452f, -0.09940143f, 0.03446812f, -0.00334449f, -0.15640019f, 
    0.26643935f, 0.12954776f, 0.09975725f, 0.10953809f, 0.01651524f, 0.13146302f, 0.20599514f, 0.16533205f, 
    0.04667136f, 0.16144677f, 0.13226168f, -0.01569781f, -0.30244720f, -0.22517744f, -0.37982607f, -0.09401925f, 
    -0.10097198f, 0.02293215f, 0.04431660f, 0.03267198f, -0.00306385f, -0.09801950f, 0.07943078f, 0.00946954f, 
    0.10967987f, 0.13974904f, 0.16267343f, 0.04561419f, -0.07411513f, -0.08127867f, -0.05872638f, -0.04822036f, 
    -0.03481179f, 0.02410157f, 0.06370942f, -0.05255437f, 0.21010931f, 0.14799039f, 0.13663337f, 0.14001700f, 
    -0.02430866f, 0.03642926f, 0.01604475f, -0.07534986f, 0.02162143f, 0.08146002f, 0.09079009f, -0.03685633f, 
    -0.23510484f, -0.07344784f, -0.49525937f, 0.22236402f, 0.11452430f, 0.09837593f, 0.31344223f, 0.19226182f, 
    -0.08636376f, 0.04811334f, -0.03619921f, -0.01117377f, -0.01345534f, -0.02344043f, 0.12436555f, 0.05335457f, 
    -0.05786340f, 0.31253222f, 0.30858341f, 0.09873386f, -0.10217374f, -0.03856843f, 0.19718081f, -0.06282078f, 
    0.04357302f, -0.05543454f, 0.00106883f, 0.05392217f, 0.01955804f, 0.15208328f, 0.10553924f, 0.28158787f, 
    -0.13767882f, 0.33710176f, 0.26585671f, -0.05511107f, 0.09447356f, -0.29619086f, -0.26113141f, -0.23208866f, 
    -0.09085592f, 0.15933301f, 0.00601857f, -0.16464123f, -0.01054734f, 0.02934740f, -0.00372700f, -0.03912473f, 
    0.07668632f, 0.13932630f, 0.19308738f, 0.10954800f, -0.05790293f, 0.05908572f, 0.11734330f, -0.05142708f, 
    0.19242933f, 0.19133519f, 0.07689812f, 0.04677312f, -0.26227140f, -0.42981279f, 0.15214069f, -0.14667535f, 
    0.00008082f, -0.09353105f, 0.00119009f, 0.06049551f, -0.08364832f, -0.15919854f, 0.02679461f, 0.08988993f, 
    0.04839010f, 0.00949081f, -0.02437123f, -0.04107060f, -0.10279147f, -0.12006520f, -0.07949046f, -0.10903109f, 
    -0.17680877f, 0.07101023f, -0.00342534f, 0.00890856f, -0.16778879f, -0.20276265f, -0.19950585f, -0.14741646f, 
    0.17071433f, 0.13048391f, -0.01715535f, -0.17311865f, -0.05387460f, -0.03855223f, -0.06322477f, -0.01845863f, 
    0.05681763f, 0.00937288f, -0.01359923f, 0.02065691f, 0.00956916f, -0.02283762f, -0.03201135f, -0.22775961f, 
    -0.05458969f, 0.04579619f, -0.03200502f, 0.01806875f, 0.00942060f, 0.09934486f, 0.08755634f, -0.00683029f, 
    -0.01824099f, 0.03092717f, 0.06568296f, 0.03539196f, 0.04179163f, -0.05280565f, 0.08891368f, 0.07743003f, 
    0.31199074f, 0.20178397f, 0.01204040f, 0.08662455f, -0.14182249f, 0.00955073f, -0.01433458f, -0.10974520f, 
    0.02899365f, 0.11539508f, -0.02812123f, 0.08851947f, 0.20806085f, 0.07172857f, -0.25971934f, -0.16038623f, 
    0.15021919f, 0.02061181f, 0.17216517f, 0.00823468f, -0.12707455f, -0.01441076f, 0.03253128f, 0.08440723f, 
    0.06964308f, -0.11657443f, 0.03946421f, 0.01498311f, -0.02487129f, 0.10459686f, 0.01744158f, 0.20090558f, 
    0.18705165f, 0.11684487f, 0.15254265f, -0.00900169f, -0.23059459f, -0.20283574f, -0.11311003f, -0.04025784f, 
    -0.06071165f, 0.01098855f, 0.04524115f, -0.01899027f, 0.04580892f, 0.14263092f, -0.00548948f, -0.07334130f, 
    0.23501731f, -0.05587541f, 0.11817161f, 0.05877178f, -0.02354558f, 0.18750182f, -0.00268930f, -0.09631529f, 
    0.03453215f, 0.08123460f, -0.06365129f, 0.01641741f, 0.22995299f, 0.21812572f, 0.09080498f, 0.12215003f, 
    0.04025709f, 0.04572447f, 0.06006220f, -0.06612393f, 0.07327665f, 0.13783301f, 0.05706618f, 0.00934212f, 
    -0.33557498f, -0.14003009f, -0.11991696f, -0.07320953f, 0.03655694f, 0.01551099f, 0.05993477f, -0.08448160f, 
    0.08350673f, -0.02962990f, -0.00593395f, -0.05811290f, 0.20501840f, -0.11522381f, -0.12988339f, 0.14027125f, 
    -0.07953696f, -0.02623008f, 0.20677894f, 0.07281672f, 0.16164795f, 0.04278460f, -0.04299520f, 0.10373507f, 
    0.22304744f, -0.45737883f, -0.03663849f, -0.19647932f, -0.18609291f, 0.07758253f, 0.02726637f, -0.16656268f, 
    0.00495471f, 0.04512286f, -0.09348258f, 0.03514999f, 0.38759032f, -0.00463773f, 0.10358887f, -0.26577318f, 
    0.05193164f, 0.01422994f, -0.04573746f, 0.00962962f, 0.11315642f, 0.00246216f, -0.01656172f, 0.05238332f, 
    0.12833820f, 0.06966558f, -0.00531960f, 0.08460544f, -0.12531503f, 0.01622592f, 0.05942538f, -0.05598955f, 
    -0.04778950f, -0.02330104f, -0.09875218f, -0.06965637f, 0.06479329f, 0.09902633f, 0.08759198f, 0.01487299f, 
    0.02051972f, 0.04005342f, -0.00018713f, -0.02201269f, 0.13190202f, -0.07678039f, 0.04717825f, -0.04412983f, 
    -0.17534731f, -0.01536653f, -0.08621909f, 0.02846180f, 0.06494372f, 0.01969042f, 0.00820967f, 0.01883072f, 
    -0.12163156f, -0.00871345f, -0.03615277f, -0.01988191f, 0.07961927f, 0.02750075f, -0.00767328f, 0.02806504f, 
    -0.01073953f, 0.00516451f, 0.01411448f, -0.00995492f, -0.01125237f, 0.04204511f, 0.07326880f, 0.03829778f, 
    -0.04832942f, 0.15910760f, -0.26585191f, -0.16066286f, 0.10457369f, -0.04301169f, -0.01003254f, -0.19478057f, 
    0.14613138f, -0.05581804f, 0.10142503f, 0.22090510f, -0.55971640f, 0.02887039f, 0.01580057f, -0.02307862f, 
    -0.05334412f, -0.10698122f, 0.10948828f, 0.21883021f, 0.03950323f, -0.22588933f, 0.12596616f, 0.21304177f, 
    -0.04279440f, -0.00891628f, -0.19652776f, -0.33906510f, 0.11951927f, -0.06385597f, 0.16015951f, 0.06261522f, 
    0.15946339f, 0.07693723f, -0.00985027f, 0.05038938f, -0.16730165f, 0.05830826f, 0.11829920f, -0.00328173f, 
    -0.06185975f, -0.03853579f, -0.01459880f, 0.16295549f, 0.11244943f, -0.14833173f, 0.02355079f, 0.07481284f, 
    -0.20763701f, -0.04881316f, 0.19898526f, -0.02949795f, -0.04303621f, -0.05165704f, 0.00412429f, 0.16367531f, 
    0.12638235f, -0.05548784f, 0.03269993f, 0.19713439f, 0.35556811f, -0.29051149f, -0.05712774f, -0.07863736f, 
    -0.10257948f, -0.04083677f, -0.02836036f, 0.03415827f, 0.12782641f, -0.01453111f, -0.10254399f, 0.02187230f, 
    -0.21933775f, -0.05418504f, 0.10169070f, -0.02944698f, 0.00352629f, -0.03620558f, 0.03884835f, 0.04138562f, 
    0.16261847f, -0.12981650f, 0.06417567f, 0.11224969f, 0.06070931f, 0.01264353f, -0.14590025f, -0.20373453f, 
    0.03491282f, -0.14106201f, -0.17169045f, -0.11937377f, -0.14414223f, -0.12202503f, 0.05685570f, -0.06511402f, 
    0.07576894f, -0.17500389f, -0.18357560f, 0.06640400f, -0.09286302f, -0.04049893f, -0.09055063f, 0.13922612f, 
    0.05316538f, 0.14763942f, 0.21287048f, 0.15130673f, -0.05803707f, -0.03284129f, -0.28543237f, 0.23154067f, 
    0.09959426f, -0.03591305f, -0.09566853f, -0.06910329f, 0.21620882f, -0.05891003f, -0.01504761f, 0.13967037f, 
    0.00116258f, 0.18770739f, 0.11467234f, 0.11623257f, 0.04649829f, 0.12085015f, 0.07873099f, 0.04151621f, 
    0.07256407f, 0.02303872f, 0.09123491f, 0.01593729f, 0.20895001f, 0.19923225f, -0.13977705f, -0.41946855f, 
    0.08977969f, -0.02216050f, 0.08440014f, -0.04099061f, 0.34545055f, -0.14314249f, 0.18335368f, 0.06157606f, 
    -0.02302228f, -0.36148289f, 0.27965996f, -0.11799330f, 0.13186459f, -0.11181618f, -0.05670657f, 0.21443477f, 
    0.03259059f, 0.03603171f, -0.09769262f, 0.02229448f, 0.06729533f, -0.17133842f, 0.10902631f, -0.21385692f, 
    -0.00657233f, -0.01213153f, -0.05578069f, 0.02413105f, 0.06737428f, -0.08783253f, 0.05720175f, 0.13217035f, 
    -0.16119380f, 0.50408083f, -0.41762689f, -0.24652822f, 0.07972525f, 0.04898740f, -0.01379948f, -0.02905285f, 
    0.00315255f, 0.08616012f, 0.14014916f, 0.07280109f, 0.15244929f, -0.28837031f, 0.35829169f, -0.06291504f, 
    -0.17690575f, -0.02344466f, -0.08016919f, -0.00169692f, 0.10520370f, 0.08627678f, 0.10603282f, 0.07376497f, 
    -0.14574103f, -0.15022917f, 0.02029640f, 0.12323537f, 0.27258295f, -0.17779361f, 0.00569703f, -0.01189159f, 
    0.00734383f, -0.07596780f, -0.15186983f, 0.05517662f, -0.06083780f, 0.34149420f, -0.03199479f, 0.04909335f, 
    0.00054101f, 0.03732411f, 0.05394655f, 0.03759092f, 0.13656004f, -0.01070148f, 0.04860545f, -0.07910644f, 
    0.19166888f, 0.28415328f, 0.15621582f, 0.09507874f, -0.10780013f, -0.10779306f, 0.10207850f, -0.05582524f, 
    0.18124242f, -0.00584666f, 0.01104186f, -0.00426647f, 0.01365429f, -0.11140823f, 0.05031796f, -0.07178622f, 
    0.20743437f, 0.00056171f, -0.02534558f, 0.03130738f, 0.16549461f, -0.12912308f, -0.39838964f, -0.27200580f, 
    0.24397275f, -0.11398464f, 0.29951435f, -0.20029220f, 0.06158557f, -0.07633161f, -0.04566620f, 0.11190357f, 
    0.12259896f, 0.13138951f, 0.05976936f, -0.14241974f, 0.08753844f, -0.01114322f, 0.15225595f, 0.01476251f, 
    0.03821695f, -0.05259300f, 0.07466346f, 0.07601003f, 0.00003999f, 0.06298926f, -0.04067523f, 0.04260390f, 
    -0.18979599f, 0.15599914f, 0.12621988f, 0.11153194f, -0.01767514f, 0.10581159f, 0.10276581f, -0.01535280f, 
    0.10835019f, -0.09773662f, 0.06527361f, -0.03019333f, -0.25923440f, 0.07079302f, -0.09854660f, -0.06414583f, 
    0.00802691f, 0.09738471f, 0.02425875f, -0.01261716f, -0.04023184f, -0.05983358f, -0.10348488f, -0.16721249f, 
    -0.22705536f, 0.20100969f, -0.15739423f, -0.01117144f, -0.02954127f, -0.01578284f, 0.14254370f, 0.11958084f, 
    0.11378923f, 0.09540008f, 0.16524820f, 0.21665311f, 0.06170956f, -0.15624267f, 0.16202541f, 0.24337232f, 
    0.07702324f, 0.11946429f, -0.07486396f, -0.05240114f, -0.02293772f, -0.19535916f, -0.11077511f, 0.04650020f, 
    0.02603792f, -0.04378770f, -0.35937840f, 0.19711968f, 0.01439143f, -0.09151585f, -0.09464207f, 0.00567947f, 
    0.05302041f, 0.11079402f, 0.04783113f, 0.01969615f, 0.17066813f, 0.14634483f, -0.31657794f, -0.01330687f, 
    0.01883776f, 0.08373258f, 0.12133613f, -0.01354390f, 0.31002969f, -0.03658904f, 0.33744439f, -0.04274383f, 
    -0.12018275f, -0.09613884f, 0.31978232f, -0.27900776f, -0.01773595f, 0.05339995f, -0.04928828f, -0.02792197f, 
    0.04752348f, 0.00075734f, -0.22951595f, -0.01924993f, -0.02209567f, 0.05359342f, -0.03830697f, -0.08124242f, 
    0.05360578f, -0.06358872f, -0.07986276f, -0.00229023f, -0.00097667f, -0.28742939f, -0.04970282f, 0.01988297f, 
    0.14836372f, -0.01711626f, 0.01460825f, -0.19322608f, 0.21999617f, -0.09711505f, -0.04410436f, 0.09037259f, 
    -0.17965601f, 0.01229440f, -0.25364006f, -0.13833332f, -0.01811586f, 0.02563006f, 0.15203388f, 0.23058711f, 
    -0.07001460f, 0.03152144f, 0.13130771f, 0.31014681f, 0.03109476f, 0.04519239f, 0.05816593f, 0.16165397f, 
    -0.15564398f, 0.21978642f, -0.10712717f, -0.11463685f, -0.04935786f, 0.11949984f, -0.00616155f, -0.01435825f, 
    0.04459440f, 0.09302907f, -0.04826538f, 0.06633606f, -0.00676384f, -0.06170080f, 0.21860313f, 0.07778601f, 
    0.06231438f, -0.02272870f, 0.07456969f, 0.09002838f, -0.05819767f, -0.06895601f, -0.02990868f, 0.00365244f, 
    -0.07574027f, 0.15321417f, 0.11521962f, -0.01685004f, 0.00632366f, -0.00189912f, 0.00058894f, 0.02541558f, 
    0.17502135f, 0.00993706f, 0.05175837f, 0.06733858f, 0.15011527f, -0.38397348f, 0.06047623f, 0.30652621f, 
    0.01117369f, -0.03128213f, -0.19752358f, 0.03952453f, 0.11681453f, -0.24064213f, -0.07108435f, -0.04253985f, 
    -0.05097414f, -0.21594235f, 0.39479837f, -0.07869979f, -0.02650346f, -0.04039795f, 0.02222275f, 0.13173535f, 
    0.12267514f, 0.07826051f, 0.05097294f, 0.03612234f, 0.21600886f, 0.27449548f, 0.22773938f, 0.01514530f, 
    -0.00318324f, -0.17701334f, 0.12609640f, 0.08341710f, 0.10660765f, 0.02101517f, -0.00442231f, 0.09377254f, 
    -0.07631136f, 0.04736100f, 0.04327096f, 0.41283834f, 0.04828975f, 0.09229232f, -0.00060803f, -0.02433762f, 
    0.09070803f, -0.01496020f, -0.02060200f, -0.07356253f, -0.23336567f, -0.12232742f, -0.17259547f, 0.09728482f, 
    0.23982753f, 0.09308363f, -0.13885477f, 0.08215805f, 0.09047411f, 0.19913998f, -0.08340371f, 0.10846917f, 
    -0.55900002f, 0.33663207f, 0.02997369f, -0.23544079f, 0.04433483f, -0.05195089f, -0.02164710f, -0.08043530f, 
    -0.11269008f, -0.03227727f, 0.11058820f, 0.02890427f, 0.01029936f, 0.16568744f, -0.22679090f, 0.22676775f, 
    0.02093307f, 0.26102111f, 0.09709148f, -0.02397719f, 0.14125039f, -0.15822515f, 0.11855438f, -0.01972710f, 
    -0.09582519f, 0.06196936f, -0.00669505f, 0.05084186f, 0.17829797f, 0.06075302f, -0.04849261f, -0.14097668f, 
    0.10157378f, 0.06632455f, -0.06592663f, 0.14821680f, -0.03966889f, -0.15432909f, 0.13063501f, 0.11020463f, 
    0.00572447f, 0.05458079f, 0.02845326f, -0.08530460f, -0.05148932f, -0.13830961f, -0.13821024f, -0.16116858f, 
    0.05493736f, -0.06245397f, -0.11171746f, -0.25548568f, 0.10209722f, 0.03877815f, 0.14467078f, -0.01206534f, 
    0.02625385f, 0.11704615f, 0.08418910f, -0.06913984f, -0.18134236f, -0.11184905f, 0.15013330f, 0.02995111f, 
    -0.04091027f, -0.08091795f, 0.04551022f, 0.07895410f, 0.11067797f, -0.05242543f, 0.08462902f, 0.20107992f, 
    -0.10511845f, -0.00556172f, 0.03674334f, 0.14963236f, 0.08267958f, 0.07290984f, 0.06787407f, 0.12835750f, 
    0.11898638f, -0.24404742f, -0.28140461f, -0.30192968f, -0.23531838f, 0.03707911f, 0.21728896f, 0.01196695f, 
    0.05485680f, -0.00787212f, 0.08398768f, 0.05184245f, 0.05798154f, -0.15720259f, -0.00534691f, 0.00454887f, 
    -0.16697180f, 0.09513062f, -0.03241430f, -0.19432694f, 0.16264370f, 0.06955028f, 0.02456455f, -0.00351808f, 
    -0.16849613f, 0.03409336f, -0.20966056f, -0.09750002f, -0.02992628f, 0.03826314f, -0.11592410f, -0.08951602f, 
    -0.01112816f, -0.04683240f, -0.17121051f, 0.04118553f, 0.03489738f, 0.02738881f, 0.01529997f, 0.03554315f, 
    -0.21452291f, 0.43310267f, -0.59818059f, 0.13282099f, 0.23183420f, -0.00281559f, -0.16369590f, 0.05574055f, 
    -0.12955733f, -0.08177041f, -0.08576405f, -0.19741811f, -0.03949046f, -0.17241526f, 0.20318939f, -0.13769643f, 
    -0.12099577f, -0.06277061f, 0.14310618f, 0.12700760f, 0.08118407f, 0.19928981f, 0.02630257f, -0.06175024f, 
    0.00119426f, -0.00796860f, -0.22144794f, 0.21002978f, 0.14370807f, 0.18744355f, 0.08632607f, -0.01944438f, 
    0.08739530f, 0.14193554f, 0.06834077f, 0.07735357f, -0.01564864f, -0.04075732f, -0.14610060f, 0.33296922f, 
    0.09576341f, -0.07760619f, 0.17025255f, -0.26174340f, 0.17462248f, 0.19215326f, 0.21029839f, 0.06174539f, 
    0.11005339f, -0.07262124f, -0.12810779f, 0.39329568f, 0.02841391f, 0.05330158f, -0.02381157f, -0.01686022f, 
    -0.26904741f, -0.02133193f, -0.02381141f, -0.21883798f, -0.17785566f, 0.05899537f, -0.19423835f, -0.10013191f, 
    0.00959754f, -0.12435988f, -0.17637636f, -0.09231734f, 0.02763557f, 0.04932297f, 0.01212661f, 0.13221306f, 
    0.10605078f, 0.12026989f, 0.03327886f, 0.14582148f, -0.09712838f, -0.02496091f, 0.08600920f, 0.05880156f, 
    0.06658162f, 0.09132676f, -0.05493595f, 0.09633046f, 0.29102495f, 0.17673764f, 0.08734044f, -0.08784014f, 
    -0.09846140f, 0.01515466f, -0.01218230f, -0.06697014f, 0.04898354f, 0.13410479f, 0.06819485f, 0.08339097f, 
    0.02356581f, -0.02554169f, 0.07545234f, 0.17612523f, 0.02613109f, 0.11830346f, 0.04243906f, -0.09849023f, 
    0.03071692f, -0.09427934f, -0.10723731f, 0.01146458f, 0.22386950f, -0.24603242f, 0.02272516f, 0.03946192f, 
    -0.13420948f, -0.04668662f, -0.16361882f, 0.06802291f, 0.20048785f, 0.04778492f, 0.05192880f, 0.03952531f, 
    -0.04645148f, 0.11434507f, -0.27373132f, 0.16345070f, 0.01625041f, -0.04975852f, -0.17700340f, -0.02541647f, 
    -0.26763481f, -0.27453178f, -0.30611855f, -0.18325524f, 0.15075275f, -0.45632565f, -0.01422478f, -0.36575878f, 
    0.15457258f, -0.17249224f, -0.00964893f, -0.06920012f, 0.18797192f, 0.00048852f, 0.16850571f, -0.02810773f, 
    -0.04524676f, 0.32958046f, 0.03820376f, 0.37098670f, 0.17769964f, 0.04679120f, 0.08321870f, 0.24051419f, 
    -0.00156716f, -0.06814927f, 0.00341684f, -0.09159566f, -0.06161954f, 0.14101042f, -0.12978491f, -0.20788723f, 
    0.13554090f, -0.06388836f, -0.03031777f, 0.03797346f, -0.09854004f, 0.03603650f, -0.19608110f, -0.16831267f, 
    -0.15227784f, -0.23018324f, -0.07332732f, -0.11750197f, -0.06703082f, -0.06844305f, 0.00762864f, -0.03039152f, 
    0.06462021f, 0.02517817f, 0.07711745f, 0.08368860f, 0.20567267f, 0.21688551f, -0.01543643f, 0.20719610f, 
    0.22703916f, 0.06720964f, 0.00900293f, 0.04463523f, -0.12293795f, 0.00463005f, -0.14147250f, 0.09453978f, 
    -0.08424666f, -0.14946106f, -0.12593931f, -0.07160821f, -0.07856101f, -0.07578640f, -0.04348176f, 0.01937736f, 
    0.01386362f, 0.01599784f, -0.01946680f, -0.12515976f, 0.06539277f, 0.22223464f, 0.13005246f, 0.19514352f, 
    0.16388436f, 0.17079404f, 0.12689123f, 0.03245605f, 0.06577116f, -0.02855333f, -0.06520803f, -0.06425143f, 
    0.16844864f, 0.17125030f, -0.05487756f, -0.01887054f, 0.08428380f, 0.20447989f, 0.09385053f, 0.15188694f, 
    -0.04062431f, -0.14488183f, -0.11226442f, -0.01712578f, -0.14615947f, -0.01459250f, 0.18340543f, -0.00292094f, 
    0.05341152f, 0.07996729f, -0.02814238f, 0.02808532f, 0.10987509f, -0.01679775f, -0.16539872f, -0.14797583f, 
    0.31547761f, 0.07151996f, 0.16860743f, 0.08992515f, -0.16768800f, 0.00965159f, -0.00227893f, 0.11144967f, 
    -0.15984197f, -0.02575689f, -0.16523729f, -0.04072247f, -0.05634835f, -0.03890928f, -0.01927495f, -0.10755900f, 
    -0.05044744f, 0.02062540f, -0.02640249f, 0.01630611f, 0.08286849f, 0.03696214f, 0.15334365f, 0.22422703f, 
    -0.11173563f, -0.01818604f, -0.15740933f, -0.12473197f, -0.00429674f, -0.01486495f, 0.07827734f, 0.06521454f, 
    -0.26727489f, -0.11883895f, -0.03519757f, 0.03528437f, -0.21511972f, -0.06039662f, 0.07908279f, 0.04880234f, 
    0.09161564f, -0.25477079f, 0.02784725f, 0.06230101f, 0.06386501f, -0.04956826f, 0.04762117f, 0.07319276f, 
    0.12024186f, 0.13780098f, 0.15073949f, 0.13962136f, 0.14487118f, 0.15840495f, 0.06520999f, 0.02461419f, 
    -0.05562771f, -0.03614484f, -0.06360304f, 0.04727603f, -0.18475778f, -0.03733482f, -0.04648139f, 0.05647210f, 
    -0.02260846f, -0.10415974f, -0.05089818f, -0.33387509f, 0.01935774f, 0.06005602f, 0.00163584f, 0.18397322f, 
    -0.35734525f, 0.07440504f, -0.02016792f, -0.05031802f, -0.09723849f, -0.03350502f, -0.04429695f, 0.10651948f, 
    0.04415333f, -0.07750538f, 0.05819281f, 0.02504480f, -0.06302468f, 0.00475258f, -0.13446057f, -0.18743835f, 
    0.02167042f, -0.06137438f, 0.01009822f, 0.06474376f, 0.03515446f, -0.10922768f, 0.13935934f, -0.02632533f, 
    -0.24423692f, -0.34398797f, 0.01812843f, -0.05283004f, 0.03951690f, 0.02524447f, -0.17839265f, -0.25329500f, 
    -0.06484911f, -0.03239397f, -0.01293778f, -0.15173934f, 0.13545378f, 0.13477257f, 0.01841562f, -0.26585540f, 
    -0.23220426f, -0.00330045f, 0.08908811f, 0.01964906f, 0.04632741f, -0.09236118f, -0.15025163f, -0.07112294f, 
    -0.23650995f, -0.12926856f, -0.10377879f, -0.00568874f, -0.03389614f, -0.08009255f, -0.10420953f, -0.03556114f, 
    -0.03494503f, 0.01176239f, 0.00269631f, 0.04692858f, 0.27447626f, -0.09609846f, 0.07000883f, 0.13580690f, 
    -0.01874020f, 0.15095367f, 0.03444728f, 0.16165453f, -0.00703131f, -0.17665565f, 0.10453524f, -0.02033310f, 
    0.15802148f, 0.00041633f, -0.08200055f, 0.30360684f, 0.02674323f, 0.18635486f, 0.15909243f, 0.01671468f, 
    0.09602344f, 0.06824431f, -0.21086074f, -0.23088957f, -0.17743358f, -0.06892858f, 0.01471205f, 0.01154076f, 
    -0.09739059f, -0.18359974f, -0.14077251f, -0.13023946f, -0.05458802f, 0.01709949f, 0.02729589f, 0.00324692f, 
    0.24624531f, 0.17780766f, 0.02810549f, -0.15230329f, 0.15180941f, 0.08011143f, 0.11022122f, 0.06821725f, 
    0.06258893f, 0.00825182f, 0.02131279f, 0.00680495f, 0.38047245f, 0.09860587f, -0.01575823f, 0.04614723f, 
    0.18815801f, 0.26798064f, 0.22429129f, 0.00744276f, 0.09684074f, -0.20011258f, -0.03390368f, -0.06701870f, 
    -0.02418863f, 0.11196747f, 0.23040582f, 0.02834925f, -0.00283727f, 0.11883247f, 0.02471717f, 0.14352442f, 
    0.05007799f, 0.01071816f, 0.02413164f, 0.08451054f, -0.22390032f, 0.13232049f, 0.03404897f, 0.28701359f, 
    0.01303572f, -0.16810198f, -0.26026455f, -0.06990001f, -0.01702884f, 0.09246862f, 0.05783058f, 0.00162667f, 
    0.14979769f, -0.03452690f, 0.12081343f, 0.28730339f, 0.06275248f, 0.10095215f, 0.03265280f, -0.04042567f, 
    0.13141289f, -0.09256982f, -0.00523774f, -0.11290698f, 0.19803542f, 0.26186335f, 0.17407717f, -0.00995579f, 
    0.17260854f, 0.16595568f, -0.09451732f, 0.04349805f, -0.03718782f, -0.06603462f, -0.00663742f, -0.05230568f, 
    -0.29667723f, -0.15254357f, 0.12765466f, 0.03404561f, -0.00768161f, 0.01879509f, -0.18160655f, -0.04701924f, 
    0.03411958f, -0.00619412f, 0.04473918f, -0.02936549f, -0.06521530f, -0.12481674f, -0.10210074f, -0.00934897f, 
    -0.02020252f, -0.07221889f, -0.05000295f, 0.00654818f, -0.00776900f, -0.15329009f, -0.02710897f, 0.04908285f, 
    -0.07838475f, -0.03900606f, -0.08886635f, 0.12441131f, -0.06358264f, 0.06796820f, -0.13530806f, 0.00653108f, 
    0.05532315f, 0.02501797f, 0.10400575f, 0.03283339f, -0.00907787f, 0.05539029f, -0.02015946f, 0.09052547f, 
    0.02603554f, 0.10767598f, -0.13969545f, -0.10437669f, 0.08787734f, -0.00307318f, 0.09696747f, 0.05638066f, 
    0.01779921f, 0.05640519f, 0.06232891f, -0.01051580f, -0.13470253f, -0.07364397f, 0.04451402f, 0.12014903f, 
    0.04793585f, 0.00428075f, 0.03716999f, 0.10007822f, 0.02331480f, 0.03950607f, 0.01610770f, 0.32796061f, 
    0.25657505f, 0.20950802f, 0.21758808f, 0.04905193f, 0.03114533f, 0.02687260f, -0.25974441f, -0.07081501f, 
    -0.08770020f, -0.13529947f, -0.00373519f, 0.14173383f, 0.11402174f, 0.09413427f, 0.03969252f, -0.08249276f, 
    0.02863182f, -0.13175395f, -0.01740146f, -0.06467351f, 0.21217653f, 0.34835923f, 0.11602175f, 0.01762674f, 
    0.16862053f, 0.26741058f, 0.15802467f, 0.01486954f, -0.05999031f, 0.03590159f, 0.06870858f, -0.05740800f, 
    0.28909007f, 0.16630511f, -0.01430137f, 0.08566207f, 0.06837583f, 0.13460344f, 0.01550436f, 0.06407245f, 
    -0.00344893f, -0.12915769f, -0.21936928f, -0.12616380f, -0.06415990f, 0.26637724f, 0.07605655f, 0.03593715f, 
    -0.02365619f, 0.08134939f, 0.08315776f, -0.01396767f, -0.01240957f, 0.00133411f, -0.22256912f, -0.03303572f, 
    0.25720909f, 0.19294192f, 0.08991141f, -0.11319425f, -0.04334829f, -0.28177735f, 0.00915680f, -0.14177167f, 
    -0.06481259f, 0.13867494f, -0.06674842f, -0.00496198f, 0.19441287f, 0.10452086f, -0.09587149f, 0.15091865f, 
    0.14873205f, 0.11704195f, 0.18661754f, 0.15156652f, 0.11461403f, 0.06864924f, -0.15932931f, -0.11149830f, 
    -0.39108041f, 0.21166906f, 0.51706672f, 0.05712668f, 0.07892903f, -0.02451077f, -0.18953373f, -0.11326365f, 
    -0.02250876f, -0.01024613f, 0.04985979f, -0.02148458f, -0.23006843f, -0.09415659f, -0.06337995f, -0.08076505f, 
    0.00731519f, -0.07562671f, -0.09810317f, -0.00453313f, -0.02800068f, 0.00026128f, -0.04555399f, 0.01796965f, 
    0.30016437f, 0.04968580f, 0.13071004f, 0.16732022f, -0.09413286f, -0.04829895f, -0.15714693f, -0.16849476f, 
    -0.02415073f, 0.15003023f, 0.03128254f, -0.05790921f, 0.13365398f, -0.15845464f, 0.21105760f, 0.04155676f, 
    0.04751901f, -0.16002437f, -0.14055279f, -0.03710081f, -0.05890406f, 0.06577971f, 0.01435001f, 0.07767600f, 
    -0.15011847f, 0.02729853f, -0.05099775f, 0.13249101f, 0.10518950f, -0.11587714f, -0.10595217f, -0.02366407f, 
    0.04891730f, -0.00863212f, -0.13625666f, -0.26529992f, 0.32936972f, 0.37956479f, 0.12473104f, 0.14677539f, 
    -0.09044441f, 0.33578196f, 0.17864931f, 0.14585347f, 0.03343467f, 0.03477590f, 0.03802726f, 0.04495119f, 
    -0.06996508f, -0.09773786f, 0.11628685f, -0.05191056f, 0.06666590f, -0.08564354f, -0.09087441f, 0.01049527f, 
    -0.17769410f, 0.00224335f, 0.16818734f, 0.05963979f, 0.23552273f, 0.24332702f, -0.06851867f, 0.09286105f, 
    0.07659169f, 0.09165629f, 0.10457687f, 0.19243725f, -0.08665685f, -0.16297068f, -0.03940253f, 0.07919874f, 
    -0.04827505f, 0.00834472f, 0.01437262f, 0.03800532f, -0.06396971f, 0.16991924f, -0.08619315f, -0.02422163f, 
    -0.02367163f, 0.06325301f, 0.02046905f, 0.02216488f, 0.36101311f, 0.13470703f, 0.04675012f, 0.08401839f, 
    0.33706436f, 0.15193565f, 0.27105677f, 0.07199509f, -0.01290215f, -0.05179850f, -0.00637835f, 0.04813072f, 
    0.03522076f, 0.13053855f, 0.07037413f, 0.07099020f, -0.00044216f, -0.18413125f, -0.11301807f, 0.03659155f, 
    0.03119075f, 0.06926436f, 0.01135198f, 0.03737697f, -0.10443196f, -0.07327150f, -0.01933057f, 0.01789000f, 
    -0.03779979f, 0.08374553f, 0.01850716f, 0.04033446f, 0.00179497f, 0.05945661f, 0.05787338f, 0.03163761f, 
    0.04930633f, -0.16424021f, 0.18987800f, 0.05824922f, -0.14910187f, 0.01876778f, -0.10977522f, 0.04197621f, 
    0.01227245f, -0.01788361f, 0.04713248f, 0.01786170f, 0.16455945f, 0.29384717f, 0.04977329f, 0.07105434f, 
    -0.07743055f, -0.11551035f, -0.06195758f, -0.00702975f, 0.02200063f, -0.00607390f, -0.16945499f, 0.17271899f, 
    -0.04805224f, 0.06866033f, -0.01541472f, -0.07264826f, -0.03780027f, 0.16841450f, -0.06856456f, -0.00572549f, 
    -0.01097448f, 0.00077456f, -0.04977787f, -0.19647631f, 0.06570497f, -0.12430176f, 0.13880473f, -0.05972250f, 
    -0.03414331f, -0.00927065f, 0.02721392f, 0.00849286f, 0.04146446f, -0.10664047f, 0.02722485f, -0.04691862f, 
    -0.15028259f, 0.06548512f, 0.10011636f, 0.08369642f, -0.02099846f, 0.02032823f, -0.01310898f, -0.03416090f, 
    0.01330974f, 0.06185283f, 0.03447917f, 0.09471667f, -0.09854882f, -0.09271331f, -0.26361209f, -0.12719770f, 
    -0.04911616f, 0.00440418f, -0.04759824f, 0.04617751f, 0.07716385f, -0.09035754f, 0.16538192f, 0.06469934f, 
    0.32250825f, 0.05284699f, -0.01115124f, 0.15926166f, 0.27870333f, 0.23436387f, 0.08915185f, 0.07310797f, 
    0.04391675f, -0.07317830f, -0.19386944f, -0.00755434f, -0.18568929f, 0.17857234f, -0.21682958f, 0.11302648f, 
    -0.04101671f, 0.03466136f, -0.01396861f, 0.02376570f, 0.08731269f, -0.04449055f, -0.11297457f, 0.03346462f, 
    0.39839262f, 0.31978139f, -0.11964540f, -0.09368017f, 0.13519603f, 0.30720124f, 0.18114093f, 0.08477914f, 
    -0.00124199f, 0.05822716f, -0.04464826f, -0.03866107f, -0.15222712f, 0.08743238f, -0.14786394f, -0.11409459f, 
    -0.01928448f, 0.07862034f, -0.02725624f, 0.01510203f, 0.12324336f, 0.02928201f, -0.09596647f, 0.00695516f, 
    -0.00411249f, 0.04456832f, 0.11962218f, 0.04816750f, 0.03217211f, 0.00278390f, 0.04167911f, -0.00941710f, 
    0.04204278f, 0.02995707f, 0.06312003f, 0.18399577f, -0.20080073f, -0.07930949f, -0.03001535f, -0.07491325f, 
    0.01417188f, -0.01457702f, -0.07682558f, -0.00655688f, -0.08627883f, -0.04148636f, -0.05681148f, -0.13691181f, 
    0.20720822f, 0.09792408f, 0.30154043f, 0.10070565f, 0.13399938f, 0.01203968f, -0.05021342f, 0.13546361f, 
    -0.07579200f, -0.03123590f, -0.03985250f, 0.00491244f, -0.18971840f, -0.03826133f, 0.02429806f, 0.03367004f, 
    0.05453041f, 0.11005914f, -0.10254904f, -0.06836220f, -0.12985697f, 0.09687433f, 0.11905119f, 0.11567099f, 
    0.00445776f, -0.08879270f, 0.32859311f, -0.13378474f, -0.07824676f, -0.16820553f, -0.01848252f, -0.00518759f, 
    -0.18403338f, 0.07049301f, -0.06397365f, -0.00386815f, 0.25889185f, 0.11815616f, -0.04638893f, 0.26771486f, 
    0.11985391f, 0.10025559f, 0.03295815f, -0.07720567f, -0.03880019f, 0.08763565f, -0.19994985f, -0.26339790f, 
    -0.07043181f, -0.01998621f, 0.06049676f, -0.07793803f, -0.19471113f, -0.02938952f, -0.09966812f, -0.10515052f, 
    -0.01881243f, 0.09546297f, 0.05466563f, 0.08360796f, 0.02284778f, 0.03954149f, 0.26423794f, 0.19914426f, 
    0.03037992f, 0.08435682f, 0.10732844f, -0.03672598f, 0.06510188f, 0.17472909f, 0.01810239f, 0.08313604f, 
    0.10237282f, -0.08711341f, -0.25157735f, 0.02733519f, 0.07257747f, -0.01008730f, 0.00367943f, -0.01707058f, 
    -0.03687232f, -0.00446504f, -0.02448443f, 0.01342124f, -0.25670925f, 0.27422380f, 0.13276540f, -0.01150930f, 
    -0.03985618f, 0.10039403f, 0.04731033f, -0.16317385f, 0.03389139f, 0.06458697f, 0.13940914f, 0.08596171f, 
    0.08477796f, 0.08469005f, 0.09041914f, 0.05317557f, 0.03282245f, 0.14081430f, 0.02647851f, -0.01272841f, 
    0.00663206f, 0.15879139f, -0.02051998f, -0.10044574f, 0.00311016f, 0.07369208f, -0.06347223f, -0.16138712f, 
    -0.08628108f, -0.13408391f, -0.04142363f, -0.05673726f, 0.01459179f, 0.04616849f, 0.03804111f, 0.15381421f, 
    0.17745015f, 0.15991560f, -0.12250621f, -0.30456880f, -0.07909743f, -0.15375896f, -0.05653806f, -0.08242589f, 
    -0.07415351f, -0.04148868f, -0.00436314f, -0.19948861f, 0.36121595f, -0.00205700f, 0.13483880f, -0.19827020f, 
    -0.09055469f, -0.09288587f, 0.00296896f, 0.06163904f, -0.11381519f, -0.00778716f, 0.03417829f, -0.08065061f, 
    -0.18770245f, -0.20683841f, -0.31008053f, -0.11417497f, -0.02132456f, 0.09559875f, -0.04033782f, -0.11328864f, 
    0.05966197f, -0.03618386f, -0.01219818f, 0.12498789f, -0.04114686f, 0.01585125f, 0.04697931f, 0.24271676f, 
    -0.00965232f, 0.08377592f, 0.08833141f, -0.13852179f, -0.04797513f, 0.15179892f, -0.08002123f, 0.06187906f, 
    -0.12936459f, 0.21119006f, -0.17110077f, -0.21361774f, -0.14768475f, -0.11537696f, -0.13820428f, -0.19777183f, 
    0.00958330f, 0.00177179f, -0.05219254f, -0.01419811f, 0.03286026f, 0.24258292f, 0.05513483f, 0.08118731f, 
    -0.01816284f, -0.08782629f, -0.01962570f, -0.11199046f, -0.05789144f, 0.04429884f, 0.14029804f, 0.01513430f, 
    0.18859158f, -0.27770403f, 0.34315291f, 0.03842729f, 0.06359516f, -0.06615544f, -0.06913447f, -0.00693345f, 
    -0.01574916f, 0.02228174f, 0.04272171f, 0.00267249f, 0.07578777f, 0.40476999f, -0.08351786f, -0.22670740f, 
    0.16383788f, -0.00874999f, 0.07487380f, 0.13127515f, 0.14602606f, 0.17178245f, -0.08208396f, 0.17376478f, 
    -0.10128350f, 0.04049105f, -0.00249252f, 0.00723155f, -0.14479862f, -0.14809518f, -0.13043900f, -0.07710781f, 
    -0.16662639f, -0.08207713f, -0.02484804f, -0.07292011f, 0.10809701f, -0.35221872f, -0.12111136f, 0.11179551f, 
    0.13862297f, 0.01906904f, -0.01001568f, 0.24747980f, 0.04014939f, -0.02110087f, 0.17842682f, 0.06644648f, 
    -0.15322779f, 0.02512681f, -0.03363730f, 0.00682685f, -0.02907653f, 0.15211716f, 0.05028429f, 0.18396749f, 
    0.09513845f, 0.15730709f, -0.01680719f, -0.00509501f, -0.28627482f, -0.05425254f, -0.13681382f, -0.11618553f, 
    -0.09260927f, 0.01478438f, 0.02596040f, -0.21557514f, -0.25129366f, 0.02249617f, 0.20000318f, 0.09554800f, 
    -0.27625376f, 0.14893809f, -0.18252239f, 0.15984198f, 0.00891947f, 0.01120097f, 0.09386735f, -0.08630960f, 
    0.00065321f, -0.04551890f, -0.04760508f, 0.18971185f, 0.05873249f, -0.26978692f, -0.00624673f, -0.10184927f, 
    -0.06030145f, 0.13412739f, 0.08721989f, 0.18820201f, 0.08072152f, 0.03335029f, -0.06446692f, 0.00036451f, 
    -0.23278528f, -0.31455490f, -0.19678484f, -0.19558109f, 0.07770296f, -0.00296516f, -0.06354332f, -0.20049831f, 
    0.05346150f, -0.02422158f, -0.14814562f, 0.04408945f, -0.13060634f, -0.04849704f, 0.09422763f, -0.04845342f, 
    0.11618090f, -0.10865232f, 0.05566652f, -0.20527181f, -0.04538147f, -0.03591792f, -0.00441190f, 0.02438092f, 
    0.28149059f, -0.14972460f, 0.14647698f, 0.24341409f, 0.08908331f, 0.13912150f, -0.00264996f, -0.02326286f, 
    -0.05818068f, -0.06729160f, -0.07995505f, -0.15304728f, 0.00726702f, -0.04967111f, -0.16710299f, -0.12457436f, 
    0.07237087f, -0.04815149f, 0.00830772f, 0.17319106f, 0.03429276f, 0.13063680f, 0.07369311f, 0.07996275f, 
    -0.00889623f, -0.00349702f, 0.14083837f, -0.14378875f, -0.00773834f, -0.02717780f, -0.04364445f, -0.05758223f, 
    0.08625529f, 0.01416127f, -0.03571663f, -0.00571965f, -0.14357270f, -0.09822883f, 0.23424609f, -0.09997784f, 
    -0.02315488f, -0.01305934f, 0.01386190f, 0.02598227f, -0.19223037f, 0.15602492f, -0.22992404f, 0.00851257f, 
    -0.03083892f, 0.00724922f, -0.09031196f, 0.12958622f, 0.14679112f, -0.04060298f, 0.13444987f, 0.20720179f, 
    -0.04804862f, -0.07653993f, 0.13627508f, 0.01992238f, -0.13227636f, 0.01368040f, 0.01762856f, 0.08691083f, 
    0.01061710f, -0.03043335f, 0.04733574f, -0.04745359f, -0.10050049f, 0.18747906f, -0.03329062f, 0.03128974f, 
    -0.10391140f, 0.22756608f, -0.07366721f, 0.20643608f, -0.10282019f, -0.13239747f, 0.05501720f, -0.17411457f, 
    -0.02617945f, -0.06087528f, 0.11701779f, 0.06466603f, 0.03073277f, 0.24403538f, -0.18610822f, 0.10821377f, 
    0.01824794f, 0.16193378f, 0.08889842f, -0.03313068f, 0.05236685f, -0.00019018f, 0.01559591f, -0.06035244f, 
    0.18857318f, -0.22409685f, -0.11773401f, 0.16011924f, 0.13781913f, 0.00413193f, 0.07103615f, 0.13111034f, 
    0.00226889f, -0.06347386f, 0.03902870f, 0.03570785f, -0.15353313f, 0.11660741f, -0.21497020f, 0.09153499f, 
    0.02896832f, 0.07021465f, 0.12092838f, -0.00658104f, 0.05635507f, -0.06004803f, -0.05979613f, 0.03780359f, 
    -0.01672875f, -0.05320248f, 0.19399841f, 0.01912467f, 0.09632026f, 0.11440782f, 0.15734090f, 0.11433887f, 
    0.02422502f, 0.03627253f, 0.10763101f, 0.06626337f, 0.00859482f, 0.02649226f, -0.20456529f, -0.30774391f, 
    -0.09638431f, -0.00085284f, -0.11335723f, 0.17738703f, 0.01726189f, 0.16966769f, 0.04870725f, 0.14383826f, 
    0.35144100f, 0.14930454f, -0.09136171f, 0.01023254f, -0.02703621f, 0.01212307f, 0.17391868f, -0.04953127f, 
    0.02516694f, 0.01123712f, 0.08348222f, 0.04611583f, -0.08574449f, -0.11986739f, 0.01296759f, -0.08246651f, 
    -0.11420964f, 0.16745166f, 0.05117156f, 0.06885388f, 0.05734454f, 0.08983054f, -0.04035872f, -0.03135749f, 
    -0.01978082f, 0.04603018f, 0.11195368f, -0.29108411f, 0.00451645f, 0.06360474f, 0.02411571f, 0.00292219f, 
    -0.02204281f, 0.00952997f, -0.09047084f, -0.02056323f, 0.02143484f, 0.06040467f, 0.15458763f, -0.22771607f, 
    -0.14015138f, -0.06759836f, -0.04771464f, -0.16477789f, -0.09785238f, -0.12570331f, -0.00216206f, -0.13146308f, 
    0.20486541f, -0.09205316f, 0.29782888f, 0.28266037f, 0.04117576f, 0.07355434f, 0.09946752f, 0.07939825f, 
    0.04702409f, -0.00103933f, -0.06383508f, -0.02214463f, 0.10420210f, 0.06353839f, 0.26146770f, 0.03331363f, 
    0.05285918f, 0.05331370f, -0.03218885f, 0.09974131f, -0.03079636f, 0.29873419f, -0.13445888f, 0.24615741f, 
    0.02017174f, -0.13215649f, -0.09343580f, -0.05191001f, -0.02741612f, 0.14111124f, 0.01418071f, 0.15006894f, 
    -0.09668034f, -0.02259964f, 0.08943351f, -0.13821730f, -0.15388492f, 0.09659483f, -0.20058319f, -0.03158344f, 
    -0.00786809f, 0.09522255f, 0.08786255f, 0.09640001f, -0.02998741f, 0.02852478f, 0.01667801f, 0.06460106f, 
    -0.07036247f, 0.00836161f, -0.00851939f, 0.20001259f, -0.01819030f, 0.04314015f, 0.03836045f, 0.00556633f, 
    0.07782716f, 0.06523731f, 0.08384812f, 0.05614719f, 0.20762531f, -0.05029288f, -0.10546473f, 0.16465023f, 
    0.13396548f, 0.05157234f, -0.02596273f, -0.00697759f, -0.02978308f, 0.02554429f, -0.01117283f, -0.05895775f, 
    -0.11730226f, -0.39762452f, -0.23775533f, -0.10778356f, -0.03096721f, -0.12869340f, -0.18833920f, -0.08445311f, 
    -0.21699992f, 0.08099452f, 0.02162267f, 0.06599240f, 0.04729780f, -0.19319902f, -0.10825134f, -0.07053704f, 
    -0.03608260f, -0.17517659f, 0.02426921f, -0.18262628f, -0.02197252f, 0.01924753f, -0.06728486f, 0.03858232f, 
    0.04739370f, -0.01799977f, 0.01978855f, 0.03912924f, 0.00516939f, -0.02289974f, -0.00544079f, -0.11576822f, 
    0.06788788f, -0.08915278f, 0.08442745f, 0.03020628f, -0.03989932f, -0.03492517f, 0.02897498f, -0.02445586f, 
    0.01640427f, -0.10027610f, 0.12465948f, -0.02566464f, 0.01183966f, 0.13104610f, 0.08094546f, 0.18626517f, 
    0.16212392f, -0.10730104f, 0.46729717f, -0.18251491f, -0.13247615f, -0.11127092f, 0.08697911f, -0.15467770f, 
    -0.10405218f, 0.00156938f, 0.02490934f, 0.06507673f, 0.15658298f, 0.27931184f, -0.08004088f, 0.11092182f, 
    0.10610538f, 0.14022927f, 0.00381596f, -0.07745837f, 0.10488957f, -0.08941139f, 0.18104042f, 0.01352937f, 
    -0.06669348f, 0.05689169f, 0.05335571f, -0.21077575f, -0.06261799f, 0.20654671f, -0.11492992f, -0.06037751f, 
    0.01947740f, -0.18880387f, 0.04902245f, -0.07115372f, 0.04999300f, -0.05670291f, 0.08321751f, -0.20510189f, 
    -0.02935413f, 0.18985561f, 0.13154629f, 0.16838774f, -0.08608582f, 0.01498423f, -0.00235518f, -0.29216972f, 
    0.01537387f, 0.20529766f, -0.10854901f, -0.12112061f, -0.07287997f, -0.01384672f, 0.02154815f, -0.01615082f, 
    0.24223323f, -0.00824508f, 0.07128637f, 0.11418688f, 0.12670073f, 0.11578574f, 0.08749583f, 0.00334129f, 
    -0.08071864f, -0.08075028f, -0.03390644f, -0.06072500f, 0.05728961f, -0.00457566f, 0.12704556f, -0.06209486f, 
    -0.03776786f, -0.05846966f, -0.00030311f, -0.08882783f, 0.09112766f, 0.10176312f, 0.06327716f, 0.07752091f, 
    0.07001456f, -0.02426853f, 0.02787693f, -0.10828466f, -0.08681008f, 0.39162669f, -0.06399982f, 0.23726423f, 
    -0.02217818f, 0.07845023f, 0.05725420f, 0.03793876f, 0.21749252f, -0.02298314f, 0.15039346f, -0.02145704f, 
    -0.05800002f, 0.03069763f, -0.23065148f, -0.07855403f, -0.01756145f, 0.06516680f, 0.03778088f, 0.18668520f, 
    -0.06117199f, 0.07059135f, 0.13034791f, 0.00709176f, 0.12610142f, 0.16364950f, -0.19012691f, -0.18706520f, 
    -0.04636965f, -0.03058971f, -0.00566247f, -0.00713351f, 0.05727825f, 0.11835597f, 0.18303537f, 0.17674792f, 
    0.05277653f, -0.02093668f, -0.03405944f, -0.11463653f, 0.00414179f, 0.04880880f, 0.09716513f, -0.08278156f, 
    0.12254238f, 0.08160110f, 0.17085283f, 0.10228246f, -0.11868417f, 0.06989092f, -0.02380482f, -0.10800495f, 
    -0.13774297f, -0.05044224f, -0.07203905f, -0.12518205f, -0.10726313f, 0.12053906f, 0.12253973f, 0.18875730f, 
    -0.13080780f, -0.33318412f, 0.05147729f, -0.43783501f, 0.00143060f, 0.05094745f, -0.02535770f, -0.27471131f, 
    -0.11380398f, -0.03193640f, -0.01899363f, 0.13270363f, -0.14028564f, -0.12678558f, -0.18720976f, 0.11693786f, 
    -0.02697897f, 0.08725700f, -0.03885661f, -0.04797634f, -0.00350539f, 0.04458867f, 0.07772002f, 0.07459710f, 
    0.03323093f, -0.00621606f, 0.03143692f, -0.00362742f, -0.00277551f, 0.01207574f, 0.02160471f, -0.01851614f, 
    0.02200234f, -0.03009162f, 0.01349299f, -0.03880316f, -0.04075007f, 0.01602138f, -0.00596231f, -0.02259015f, 
    0.02194375f, -0.03448283f, 0.02304635f, 0.01279567f, -0.03079412f, -0.02920199f, 0.01056475f, 0.00950518f, 
    0.01174977f, 0.02520024f, -0.00401845f, -0.00133326f, -0.04062611f, -0.03145627f, 0.02610613f, -0.03570357f, 
    0.01379743f, 0.02944175f, -0.01332501f, 0.01989354f, -0.00971859f, -0.00185718f, -0.03095133f, 0.02203660f, 
    0.02453277f, 0.01492446f, -0.01268359f, 0.01305406f, -0.00207611f, -0.00888538f, -0.00792751f, 0.00822524f, 
    0.00453001f, -0.01246892f, -0.01529489f, 0.02401541f, -0.04266689f, 0.02534159f, -0.02233803f, -0.02195830f, 
    -0.01654064f, -0.02419596f, 0.00836752f, 0.00746323f, -0.00095331f, -0.01619317f, -0.02265396f, 0.02517713f, 
    -0.01358079f, 0.02041760f, 0.00293891f, -0.00264811f, -0.02062844f, -0.03357038f, 0.03010134f, -0.00860775f, 
    -0.00713872f, -0.03945585f, -0.02130516f, 0.00975186f, -0.02162699f, -0.02079523f, -0.00262287f, -0.03656753f, 
    0.01667678f, -0.00610932f, -0.00912628f, 0.01831561f, -0.00583176f, 0.02398901f, 0.03333419f, 0.03290933f, 
    0.01818728f, -0.01679823f, 0.01604657f, -0.03839560f, 0.00744156f, -0.01201742f, -0.02090234f, 0.01187046f, 
    0.00765519f, 0.00803432f, 0.02281702f, 0.03149934f, -0.02344278f, -0.03103864f, 0.00959801f, -0.02798017f, 
    0.01862894f, 0.00897299f, -0.03338559f, 0.02675616f, 0.01404694f, 0.01362997f, 0.01512993f, 0.00562968f, 
    0.00697516f, 0.01010276f, -0.02347856f, 0.00593672f, -0.03318944f, -0.02636394f, -0.03200782f, -0.02238598f, 
    -0.02544128f, 0.02601811f, -0.00344458f, 0.02484136f, -0.01803292f, -0.00131004f, -0.03597918f, 0.02549246f, 
    -0.03770312f, 0.01220384f, 0.01886537f, -0.01695612f, -0.02476971f, -0.01333051f, -0.02035848f, -0.01729527f, 
    0.02835549f, -0.02135681f, 0.01238144f, -0.01226550f, -0.01901063f, 0.00285255f, -0.03752848f, -0.01530491f, 
    -0.03023114f, 0.02803751f, 0.01965415f, -0.01850353f, -0.00385323f, -0.00706036f, -0.01480881f, 0.01635021f, 
    0.02734941f, 0.01042117f, 0.00889273f, 0.00656858f, -0.00951606f, 0.02287518f, -0.02527074f, -0.02765794f, 
    0.00470849f, 0.02014453f, 0.02047005f, -0.02332425f, -0.00735604f, 0.02474370f, -0.01491649f, -0.03964485f, 
    0.01303429f, 0.00392288f, -0.01626645f, -0.01929162f, -0.02570716f, 0.02176020f, -0.02560463f, 0.01639289f, 
    0.02772858f, -0.02058159f, -0.03592323f, -0.04006816f, -0.00902790f, -0.01485398f, -0.01386374f, 0.01079967f, 
    0.02344672f, -0.01418898f, -0.01628014f, -0.00881249f, -0.03255436f, -0.03525566f, -0.01413916f, 0.00576488f, 
    -0.01858825f, -0.01829069f, -0.01962320f, 0.03193871f, -0.03230639f, 0.01142201f, 0.03271240f, -0.02524674f, 
    0.02987761f, 0.01664041f, 0.02650265f, 0.00330853f, -0.02142042f, -0.03359652f, -0.03471510f, -0.03600607f, 
    0.00998424f, -0.00329253f, -0.01304836f, -0.01677827f, -0.03257637f, -0.02317416f, 0.01305055f, -0.00757640f, 
    0.02225544f, -0.01043793f, 0.00083381f, -0.00404590f, -0.01819379f, -0.04166991f, -0.01003745f, 0.00487628f, 
    -0.03711048f, 0.01377467f, -0.00853549f, 0.01810880f, -0.03269585f, 0.01181957f, 0.00778204f, -0.01043031f, 
    -0.03467256f, -0.00898694f, -0.00439319f, -0.00349987f, 0.01037629f, -0.04364999f, -0.01123309f, -0.00116758f, 
    -0.03237621f, 0.01818220f, -0.01659928f, 0.02133116f, -0.00729615f, 0.00900657f, -0.00712196f, -0.01695008f, 
    -0.01289027f, -0.03353392f, -0.03783789f, 0.00096633f, -0.02022506f, -0.00181006f, 0.02727494f, -0.00270665f, 
    -0.01627705f, -0.03925887f, 0.02585206f, -0.00227187f, -0.02965659f, -0.03723021f, 0.00344444f, 0.01407372f, 
    0.02511951f, -0.02898677f, 0.00490579f, -0.04158483f, 0.01610981f, -0.03904944f, 0.00704946f, -0.01835083f, 
    -0.03394708f, 0.01693775f, -0.03604152f, -0.02835052f, -0.03214445f, 0.00048167f, 0.02429142f, 0.02686498f, 
    0.01192592f, 0.01204233f, -0.01312899f, 0.01358983f, 0.00718376f, -0.03101931f, -0.00883809f, -0.00785945f, 
    0.01924977f, -0.04028228f, -0.02334209f, -0.01005121f, -0.01936168f, -0.00817669f, 0.02402656f, -0.03803351f, 
    -0.01148666f, -0.01335102f, -0.03604241f, 0.01917544f, -0.00946376f, 0.00330571f, -0.04293237f, -0.01948248f, 
    -0.01832089f, 0.00898277f, -0.01449618f, -0.02676144f, -0.02039363f, -0.02026416f, -0.04172332f, 0.01133811f, 
    -0.01753808f, 0.01639390f, 0.00515027f, -0.01968551f, -0.02628713f, -0.03241961f, 0.02955989f, -0.01596486f, 
    -0.03070455f, 0.00298068f, 0.02713458f, -0.01626691f, -0.00678346f, 0.01629491f, 0.00737737f, 0.02448030f, 
    0.02356148f, 0.01841000f, -0.01406134f, 0.01158165f, -0.01552900f, 0.02664822f, 0.02206853f, 0.02806436f, 
    -0.02097068f, -0.01752682f, -0.03676814f, -0.02934768f, -0.03213256f, 0.01394735f, 0.01110262f, -0.00086168f, 
    -0.00270710f, -0.00713737f, 0.01128475f, -0.00223541f, 0.00716123f, 0.01259774f, -0.02402778f, -0.00179618f, 
    0.01221335f, 0.01060413f, -0.04397584f, -0.04010477f, -0.04256178f, -0.02949330f, 0.00145031f, -0.03147196f, 
    0.00571153f, 0.01157672f, -0.01395673f, 0.00512714f, 0.02537072f, -0.02417530f, -0.03858905f, 0.02425892f, 
    0.00746971f, -0.02386574f, -0.00371721f, -0.01382266f, -0.01805609f, -0.03205505f, 0.02426297f, 0.01939883f, 
    0.01590586f, 0.00052831f, -0.04125906f, 0.01065257f, 0.01770534f, -0.00571043f, -0.00261458f, 0.00877006f, 
    -0.00126156f, -0.02389894f, 0.02630742f, 0.02178527f, -0.00741473f, 0.00932769f, 0.02113948f, -0.02628621f, 
    -0.02133679f, 0.01734465f, 0.00803612f, 0.00974989f, -0.02441274f, -0.04137469f, -0.03255482f, 0.00085504f, 
    -0.00086278f, 0.01212487f, 0.01517161f, 0.01269111f, -0.03000029f, -0.01258890f, -0.00893008f, -0.00893491f, 
    -0.00849216f, 0.01622809f, 0.00353812f, 0.02504121f, 0.02626759f, -0.04073671f, -0.00424164f, -0.03796997f, 
    -0.02449256f, -0.00657949f, 0.00968573f, -0.04182989f, -0.03488681f, -0.00537866f, 0.01547761f, -0.00970513f, 
    -0.00668288f, -0.01084679f, 0.00857239f, 0.02640119f, 0.01123668f, 0.03049838f, 0.02752556f, 0.02491435f, 
    0.00971810f, -0.03260255f, -0.00230572f, 0.00417165f, -0.02091223f, 0.00120417f, -0.04146194f, 0.01160232f, 
    0.02019309f, -0.01888501f, -0.00393590f, -0.00844113f, 0.00169271f, -0.01135290f, -0.02654133f, -0.00080647f, 
    0.01070415f, -0.02752029f, -0.03805349f, -0.02750766f, 0.01010558f, -0.02476797f, -0.00724411f, -0.00779109f, 
    -0.00806741f, -0.00651938f, -0.01024187f, -0.03135623f, 0.00335559f, 0.00195862f, -0.02986639f, 0.00754955f, 
    0.02088732f, -0.00322595f, 0.00557159f, -0.00788508f, 0.01415233f, 0.02269265f, -0.01102338f, 0.03755267f, 
    -0.03533878f, 0.03537633f, 0.00058036f, -0.00568189f, 0.00047559f, -0.00986753f, -0.02133877f, -0.02235648f, 
    -0.00772453f, -0.03776453f, -0.01498124f, -0.00240930f, -0.03361733f, 0.01569489f, 0.00956153f, 0.01456364f, 
    -0.03051619f, -0.02575005f, -0.02718551f, -0.02419331f, 0.02677140f, 0.02191102f, -0.02231964f, 0.00702364f, 
    0.02775771f, 0.02592226f, -0.01208681f, 0.00391718f, -0.02234681f, -0.02625367f, -0.04117272f, 0.02473831f, 
    -0.00942009f, -0.00212612f, 0.01124763f, -0.03780781f, 0.00597446f, 0.01341801f, 0.00212855f, -0.02417972f, 
    0.03414056f, 0.01173087f, 0.02648856f, 0.02179849f, -0.02298864f, -0.03757349f, -0.04502993f, 0.01051169f, 
    0.01677685f, -0.03285870f, -0.02080243f, 0.02269646f, -0.03259760f, -0.04401159f, 0.01506832f, -0.02273705f, 
    -0.00483431f, -0.00137098f, -0.01356366f, 0.01906293f, -0.02895007f, 0.02614328f, -0.02761442f, 0.01967800f, 
    0.01152380f, -0.04445441f, -0.02833651f, -0.02745334f, -0.01280716f, 0.02289165f, -0.03001772f, -0.02790444f, 
    0.02445495f, 0.00207112f, 0.00184474f, -0.02277043f, -0.02209840f, -0.02747622f, 0.00821451f, -0.03269823f, 
    -0.00862247f, 0.00749893f, 0.01535502f, -0.00199400f, -0.01226248f, 0.02003562f, -0.02299801f, 0.02373741f, 
    -0.02712752f, -0.01858513f, -0.04442495f, -0.03248433f, 0.00332574f, 0.02002149f, -0.03962956f, -0.03588645f, 
    -0.00530551f, 0.01202014f, -0.01983667f, 0.01676702f, 0.00505029f, 0.02363088f, 0.02479218f, 0.01243258f, 
    -0.00225592f, 0.01239676f, 0.00293562f, 0.03028001f, 0.01658840f, 0.00998394f, -0.03105763f, -0.01092331f, 
    0.00345719f, -0.01581331f, -0.03441343f, 0.01556432f, 0.02722468f, 0.00169238f, -0.02422473f, -0.00544048f, 
    -0.02725052f, -0.04412938f, 0.02481044f, -0.03108000f, -0.02477887f, 0.02170462f, 0.00052724f, 0.02920319f, 
    -0.00445579f, -0.01086430f, -0.03053015f, 0.01065981f, 0.02185737f, -0.02319275f, -0.01347353f, -0.01759750f, 
    0.02669143f, -0.00628433f, -0.01179008f, -0.03497089f, 0.01891925f, 0.01586812f, -0.01371343f, -0.03570834f, 
    0.01042798f, -0.01174783f, -0.03989005f, 0.00798808f, 0.03056387f, -0.02019626f, 0.03795281f, -0.03909444f, 
    -0.00619003f, -0.03017688f, -0.00702961f, -0.00592179f, 0.01531426f, -0.00036032f, 0.02883271f, -0.00678141f, 
    0.02776664f, -0.01963033f, 0.00887928f, -0.03664260f, -0.01088151f, -0.04150116f, -0.03142232f, 0.00807357f, 
    0.00242834f, 0.00246460f, 0.00976686f, -0.01860418f, 0.00210638f, -0.03882964f, -0.03667229f, -0.03450302f, 
    -0.03151104f, 0.02260683f, -0.03011581f, 0.02238245f, -0.01516959f, -0.03565451f, -0.01213071f, -0.00760675f, 
    -0.00660397f, -0.04286842f, -0.02696371f, 0.01425567f, 0.00723890f, -0.02405313f, 0.03413075f, 0.03076448f, 
    0.00191940f, 0.02846500f, 0.02252214f, 0.01507744f, -0.03871873f, -0.02095683f, 0.02471540f, -0.01449581f, 
    -0.02029140f, 0.01839082f, 0.00598039f, 0.01254511f, -0.00487397f, -0.00166847f, -0.02193782f, -0.03902513f, 
    -0.00726493f, -0.01820556f, -0.00715986f, 0.02023294f, -0.01870435f, -0.02589118f, -0.02521703f, -0.02761931f, 
    -0.00265458f, 0.01609091f, -0.01522182f, 0.02465425f, -0.00261435f, 0.02734830f, 0.01105232f, 0.03096453f, 
    -0.01142874f, -0.00369832f, -0.03506471f, -0.03018683f, -0.00203959f, -0.03722562f, -0.00458787f, 0.01850287f, 
    0.00711985f, 0.00117783f, -0.00665956f, 0.02071638f, 0.00012409f, 0.03142113f, 0.02480343f, -0.00783550f, 
    0.00502861f, 0.02319286f, -0.01692410f, 0.01426611f, -0.01545187f, -0.01600534f, 0.03824300f, 0.02040819f, 
    -0.04335241f, -0.00584242f, -0.03808938f, -0.01573287f, 0.00352165f, -0.00915068f, -0.04484791f, -0.04159822f, 
    0.00409337f, -0.04085481f, -0.04058830f, -0.00523881f, -0.03617530f, -0.03675636f, -0.00445866f, 0.00970446f, 
    0.01952502f, 0.00867740f, -0.03987062f, -0.00281189f, -0.00918515f, -0.03051312f, 0.02571766f, 0.00423788f, 
    -0.03097186f, -0.02975510f, 0.00535297f, -0.04519678f, -0.02848072f, -0.00326173f, -0.00202511f, -0.01849121f, 
    -0.03062848f, 0.02774736f, -0.01597014f, -0.00477083f, 0.01223382f, -0.02855317f, -0.02010606f, -0.01050014f, 
    0.02176687f, -0.00313276f, 0.03013163f, 0.02397985f, 0.01258246f, 0.02090990f, -0.01995257f, -0.03906530f, 
    -0.31803480f, -0.00144987f, 0.15107438f, 0.00372881f, -0.11490908f, -0.01634851f, -0.01505127f, -0.01985327f, 
    0.02686414f, 0.04174715f, 0.17100039f, 0.20691817f, -0.23051324f, -0.26273167f, -0.12776870f, -0.05479816f, 
    -0.11891040f, -0.12531595f, 0.17303391f, 0.11713453f, -0.10828532f, -0.09169172f, -0.03886114f, -0.05719925f, 
    -0.23755918f, -0.07272271f, 0.03402555f, -0.10411499f, -0.09360535f, 0.02818837f, -0.04184540f, 0.03421978f, 
    0.13625929f, 0.07022268f, 0.21766320f, 0.20939758f, -0.19359300f, -0.17485769f, -0.02420727f, 0.02388913f, 
    -0.12934832f, 0.05675471f, 0.08701713f, 0.21093799f, 0.11617235f, 0.00731655f, 0.07073892f, 0.14110401f, 
    -0.22994575f, -0.07522120f, 0.06754675f, -0.08242965f, -0.03959220f, -0.07465368f, 0.07710433f, -0.04322366f, 
    0.15889585f, 0.10114255f, 0.02440782f, 0.12996309f, 0.03324632f, -0.09796055f, 0.04283066f, -0.12342736f, 
    -0.03039459f, 0.06181910f, -0.01582400f, 0.04796238f, 0.11288488f, 0.10089030f, -0.13968897f, 0.02904930f, 
    -0.14394774f, -0.08831249f, -0.19422178f, -0.01121459f, 0.22880565f, -0.09492986f, 0.08409091f, 0.04624406f, 
    0.13614646f, 0.07878842f, -0.08814851f, -0.33259955f, -0.14079921f, -0.06813754f, -0.10500257f, -0.12148980f, 
    -0.15110712f, -0.08221113f, -0.05323788f, -0.09229009f, -0.02570650f, -0.02206709f, 0.01949834f, 0.16271019f, 
    0.09426490f, -0.09143912f, 0.00330767f, -0.14413959f, -0.04645810f, -0.06347783f, -0.08402245f, -0.07917584f, 
    0.05049055f, -0.04693656f, 0.05573759f, -0.05014163f, 0.07132427f, 0.08686736f, -0.05891309f, -0.10897777f, 
    -0.03229627f, 0.07871782f, 0.03833902f, -0.00915397f, 0.04501346f, 0.00714859f, -0.03516182f, 0.09190338f, 
    -0.09288877f, -0.01992282f, -0.04484669f, 0.16687655f, 0.10109212f, 0.06965444f, 0.11160851f, -0.00425738f, 
    0.06710432f, 0.02240501f, 0.02989846f, 0.03058927f, -0.09491516f, 0.10746245f, -0.00111603f, 0.10401787f, 
    0.01564498f, 0.07108615f, -0.00940699f, 0.22988337f, 0.05578692f, -0.17271206f, 0.04290863f, 0.18649475f, 
    0.08972746f, -0.09604100f, 0.00595330f, -0.20125288f, -0.07081319f, -0.01697754f, 0.04824907f, 0.01730643f, 
    -0.02874643f, -0.09496590f, -0.08695965f, -0.12048346f, -0.19520283f, -0.00935546f, 0.21902822f, -0.11839978f, 
    -0.07817338f, -0.07017601f, -0.02406701f, -0.11618536f, 0.02223005f, -0.17721224f, 0.12964869f, 0.08349460f, 
    -0.33301321f, 0.20756859f, 0.10414503f, 0.13541117f, -0.08850372f, -0.04053541f, 0.01364033f, 0.20696884f, 
    -0.00537046f, -0.23202948f, -0.02071821f, 0.03852533f, 0.00694946f, 0.29468104f, -0.11823737f, 0.17972948f, 
    -0.05907742f, -0.02015885f, 0.09110745f, 0.20771948f, 0.07557654f, 0.00461586f, 0.26254001f, 0.32806143f, 
    -0.17493871f, -0.02278871f, 0.05333013f, -0.16567093f, -0.07354433f, -0.03082827f, 0.03980234f, -0.01058976f, 
    -0.08466056f, -0.05678432f, -0.12985381f, -0.03201929f, -0.07781834f, 0.19135892f, 0.08175144f, 0.02836380f, 
    -0.14147612f, -0.12766643f, 0.13223691f, 0.02666930f, 0.08447348f, 0.11552493f, 0.19742660f, 0.07166984f, 
    -0.18311922f, 0.02672791f, 0.05119210f, 0.02776619f, -0.08123313f, -0.01727157f, 0.02651574f, 0.00323429f, 
    0.19092934f, 0.06064836f, 0.07714625f, -0.03860989f, -0.11281080f, -0.10004240f, 0.05780511f, -0.06671773f, 
    0.11034086f, 0.06496622f, 0.07169283f, 0.10109836f, 0.01728036f, 0.06942216f, -0.04452249f, 0.04844850f, 
    -0.14797172f, 0.08945125f, 0.18188031f, 0.01291834f, 0.13385618f, 0.20651890f, -0.00129218f, 0.12736790f, 
    0.04408133f, -0.10326084f, 0.12359191f, -0.00703472f, -0.22824313f, -0.20954207f, 0.18615054f, -0.14570704f, 
    -0.04790751f, -0.00740612f, -0.02331331f, 0.04992126f, -0.03910260f, 0.03867343f, 0.03585820f, -0.08178279f, 
    -0.26498669f, 0.01350705f, -0.01714407f, 0.00575936f, -0.02093435f, -0.12476818f, 0.05019186f, -0.05158634f, 
    -0.07463250f, -0.13439965f, -0.02212240f, -0.13425136f, -0.32667071f, -0.08342232f, 0.09655786f, 0.02935473f, 
    0.13681008f, 0.07327010f, -0.13965033f, 0.30583137f, 0.02027426f, -0.00957497f, 0.05046488f, -0.01146354f, 
    -0.11792260f, 0.04148842f, -0.07272859f, 0.14856097f, -0.00641426f, 0.02528652f, 0.16786933f, 0.31761843f, 
    0.02209729f, 0.12079851f, -0.15359625f, -0.16464165f, 0.21485539f, 0.06855392f, 0.02515867f, 0.19067316f, 
    0.08825033f, 0.19706050f, -0.04712323f, 0.32833639f, 0.09272818f, 0.18390760f, 0.11447401f, 0.34880239f, 
    -0.10660815f, 0.18961197f, -0.07393864f, 0.08292735f, 0.04150820f, -0.10771473f, 0.05501929f, 0.00844864f, 
    0.00740646f, 0.02994449f, 0.07068987f, 0.10962410f, 0.05147442f, 0.08697434f, -0.13721037f, 0.14962576f, 
    0.02024329f, 0.11587350f, 0.11279103f, 0.07111496f, 0.10835571f, -0.13046631f, -0.15953568f, -0.35543770f, 
    -0.10398234f, -0.04898518f, 0.03078063f, -0.09318879f, 0.08322036f, 0.06537917f, 0.17291492f, 0.06653830f, 
    0.08417037f, 0.10407393f, 0.08355302f, 0.12663466f, -0.08926054f, -0.09053576f, 0.01002125f, -0.04750835f, 
    -0.00021797f, 0.08851490f, 0.07001053f, -0.00429939f, 0.16536194f, 0.15253201f, 0.15331638f, 0.13373904f, 
    0.15998484f, 0.03526466f, -0.05607553f, -0.24552111f, -0.32155567f, 0.19089796f, 0.06641165f, 0.07222450f, 
    -0.01891484f, -0.00032984f, 0.06784384f, -0.08575301f, 0.15698963f, -0.14379074f, -0.01674398f, -0.09787069f, 
    0.05667854f, -0.07352448f, 0.01459710f, 0.24831793f, -0.02828638f, 0.02184842f, 0.03480069f, -0.03617306f, 
    -0.19726180f, 0.07157417f, 0.05474141f, -0.07073010f, -0.06693671f, -0.07156382f, 0.09906963f, 0.11211760f, 
    -0.05125155f, -0.00367331f, -0.01186911f, 0.03774848f, 0.14016034f, 0.00734079f, -0.05395079f, 0.05567009f, 
    0.14617781f, 0.07154658f, 0.08730352f, 0.10625910f, 0.00617120f, -0.01516141f, -0.00415159f, 0.03333471f, 
    -0.16427673f, 0.03535713f, -0.10830680f, -0.04747437f, 0.11641617f, 0.16186318f, 0.06714936f, 0.11198039f, 
    0.12317279f, 0.10115772f, -0.05638906f, 0.04944357f, -0.01628228f, -0.32760108f, -0.14356565f, 0.14165537f, 
    -0.11976672f, -0.01937499f, -0.02434724f, -0.06805032f, 0.20055251f, 0.04028004f, 0.00872667f, 0.11242834f, 
    -0.31233448f, 0.12442929f, 0.10084378f, -0.06984171f, 0.05365774f, 0.02827072f, 0.01482597f, 0.16552125f, 
    0.22243987f, -0.12868983f, 0.01970802f, -0.02293401f, -0.02255444f, 0.00948799f, 0.09916341f, -0.02516745f, 
    -0.07197531f, -0.10983572f, 0.00040566f, 0.08987448f, 0.12907743f, -0.11630261f, 0.01669051f, -0.09738692f, 
    0.10607106f, -0.07654242f, 0.05495769f, 0.25418237f, 0.25492579f, 0.15619518f, 0.11609325f, 0.22784108f, 
    0.04155752f, -0.06225024f, -0.01322291f, 0.02353504f, -0.22582604f, -0.01750824f, -0.00266332f, -0.03465072f, 
    0.02867061f, -0.06525133f, -0.02827395f, 0.05483231f, 0.01935760f, 0.00618138f, -0.00481023f, -0.02421093f, 
    -0.21985504f, 0.01815477f, 0.04545987f, 0.07221855f, -0.02916490f, -0.01600808f, -0.07126930f, 0.14920226f, 
    -0.05373017f, 0.06560450f, -0.14222069f, -0.03736702f, -0.10701960f, 0.34624556f, -0.06453944f, 0.32826868f, 
    0.07079012f, -0.06560095f, 0.12675208f, 0.10144592f, 0.03732285f, 0.11431286f, 0.26961544f, 0.23683140f, 
    0.03128358f, -0.10617241f, -0.02588881f, -0.07588221f, 0.01560948f, -0.09746289f, 0.06070911f, -0.03622268f, 
    -0.10787445f, 0.13236983f, -0.17607313f, -0.05288706f, -0.05541206f, -0.15492328f, -0.11056640f, 0.05637176f, 
    0.13014902f, 0.06758153f, 0.10473052f, 0.12767547f, 0.04869293f, 0.02870360f, -0.01163742f, 0.05619760f, 
    -0.08771420f, 0.01486124f, 0.01915895f, 0.19321042f, 0.09706143f, -0.01122451f, -0.03170308f, 0.02850354f, 
    -0.01188121f, -0.06939325f, 0.02618102f, -0.04542928f, -0.22057864f, -0.13119283f, 0.17598477f, -0.17744835f, 
    -0.05676647f, -0.05185784f, 0.01221032f, -0.02746271f, 0.15209650f, 0.06847048f, 0.12926738f, 0.01519829f, 
    -0.05098711f, -0.14913468f, -0.06105536f, -0.08717742f, 0.05880555f, 0.06656720f, 0.13622759f, 0.10829774f, 
    0.02053509f, 0.02826314f, 0.07583184f, -0.02756018f, -0.45075995f, -0.21123028f, -0.10924879f, -0.09092303f, 
    0.03056617f, 0.09143122f, -0.02477129f, 0.06666817f, 0.09464907f, -0.03122829f, 0.00373551f, 0.06127321f, 
    -0.06895277f, 0.03334357f, 0.03107235f, -0.08673137f, 0.14230384f, 0.07657154f, 0.15949775f, 0.03619157f, 
    0.06543824f, 0.05959699f, 0.05580911f, 0.01211119f, 0.11332658f, 0.09134872f, -0.00396443f, -0.02021806f, 
    -0.01040075f, -0.05228130f, 0.07998414f, -0.09067727f, 0.01596615f, 0.04257051f, 0.13071375f, 0.16913633f, 
    -0.27609774f, 0.12052184f, -0.07455406f, 0.27254468f, 0.02459889f, -0.05834911f, -0.00852346f, 0.10274843f, 
    -0.04901841f, -0.09335813f, 0.03914908f, 0.03148523f, -0.02650669f, -0.02816977f, 0.07739502f, 0.03149169f, 
    -0.00642734f, 0.10516448f, -0.03498545f, 0.29136312f, 0.07881624f, 0.12664554f, 0.15446763f, -0.14243142f, 
    0.04201581f, 0.03925739f, -0.17141449f, 0.11775074f, 0.09743385f, -0.00529508f, 0.06534325f, 0.11305926f, 
    0.00861840f, -0.03090815f, -0.05263825f, -0.13650194f, 0.21162637f, 0.20275548f, -0.09239777f, 0.17422152f, 
    0.10388318f, 0.05928602f, -0.02980536f, 0.08457834f, 0.15592200f, -0.04374391f, -0.24030560f, -0.24485156f, 
    0.10649318f, -0.00127421f, -0.03691645f, 0.07801830f, 0.16146581f, 0.03415689f, -0.03432301f, 0.04579565f, 
    0.07717714f, 0.00746844f, 0.24489021f, 0.06785215f, -0.34438252f, 0.05248737f, 0.01986977f, 0.06301495f, 
    -0.08518846f, -0.01952084f, -0.04532083f, -0.02735668f, 0.10664755f, 0.07263879f, 0.12852097f, 0.17155272f, 
    -0.01242077f, -0.04711730f, 0.05510398f, 0.16042906f, 0.10512739f, -0.01822474f, 0.08201163f, 0.20421380f, 
    -0.10521548f, -0.01319578f, -0.05829249f, -0.05020827f, 0.27671745f, 0.16032904f, 0.27881876f, 0.03442976f, 
    0.08086431f, 0.08830179f, -0.12693954f, 0.10198947f, 0.14977893f, 0.09508944f, 0.01474030f, -0.20372964f, 
    -0.08695273f, -0.06096582f, 0.00539588f, 0.03049183f, 0.01568638f, 0.09264462f, -0.01886638f, 0.03746181f, 
    0.02361663f, 0.02167425f, 0.11610778f, 0.12677900f, 0.00556281f, -0.08250976f, 0.13834189f, -0.11668504f, 
    -0.01859625f, -0.03964008f, -0.03838193f, -0.07189117f, 0.20962454f, -0.00655360f, 0.13704352f, 0.14469832f, 
    0.12278182f, -0.00743933f, -0.06690318f, -0.06192218f, 0.04500724f, 0.00095870f, -0.02560680f, -0.03409870f, 
    0.08739258f, 0.14736113f, 0.04389021f, 0.08117228f, -0.14724047f, -0.01828118f, 0.02489277f, -0.11228670f, 
    0.02423378f, -0.05786624f, -0.04941056f, -0.06783965f, 0.12390952f, -0.06950385f, 0.20597330f, 0.09565940f, 
    -0.07170133f, 0.04703261f, 0.04161438f, 0.23822379f, 0.17993969f, 0.04438193f, 0.18767430f, 0.06504647f, 
    0.13078332f, 0.00512880f, 0.02021202f, 0.00012212f, 0.02237953f, -0.19356728f, 0.08104970f, 0.03155217f, 
    0.11527097f, 0.07091823f, -0.01938940f, 0.09623667f, -0.01099014f, 0.03176311f, 0.13545464f, 0.07344011f, 
    0.05424646f, -0.23020631f, -0.20944141f, -0.10514355f, 0.07139205f, -0.03556082f, -0.08764109f, -0.09657538f, 
    0.01206179f, -0.00344226f, 0.07066742f, -0.09344181f, 0.10840400f, 0.18664274f, 0.10507703f, 0.10285835f, 
    0.06968998f, -0.15621628f, -0.03151539f, 0.01696055f, -0.04449769f, -0.08081888f, -0.05374102f, -0.10133661f, 
    0.00055674f, -0.11568420f, -0.15354787f, -0.04594636f, 0.08667715f, -0.03316657f, -0.00797447f, -0.03657865f, 
    0.08585680f, 0.02377080f, 0.07717177f, 0.04221874f, 0.33677170f, 0.05532602f, -0.23551653f, -0.13846026f, 
    0.15471455f, 0.00898408f, 0.18969683f, -0.01128819f, -0.05733582f, -0.08152692f, 0.13782163f, -0.11020426f, 
    -0.09862114f, 0.11613367f, 0.25564143f, 0.42029986f, 0.13279876f, 0.03987227f, 0.01586924f, 0.06932174f, 
    0.02739639f, 0.08469307f, 0.00208299f, 0.09863646f, 0.15596922f, -0.05553858f, -0.18961205f, -0.09877617f, 
    -0.03277952f, -0.03654028f, -0.11490355f, 0.06996801f, -0.05019378f, 0.05563098f, 0.11112902f, -0.02958915f, 
    -0.10274696f, 0.25022292f, -0.00050520f, 0.22310349f, 0.11579174f, 0.04347128f, -0.04290569f, 0.20239152f, 
    -0.00409299f, 0.02994823f, -0.01824079f, -0.00302780f, -0.11237291f, -0.27512324f, -0.03703925f, 0.07947087f, 
    -0.07736078f, 0.03023955f, -0.07426010f, -0.11014500f, 0.01883933f, -0.01115119f, -0.13821533f, -0.00810227f, 
    -0.33277410f, -0.18199146f, 0.00994126f, -0.07870315f, -0.00911985f, -0.00541853f, -0.01881878f, -0.07969208f, 
    -0.04772882f, -0.13632002f, -0.25444427f, -0.04393089f, -0.33593205f, -0.32048821f, -0.07111382f, -0.04315196f, 
    -0.04884482f, -0.07207054f, -0.04116743f, -0.03996934f, -0.00699775f, 0.10123118f, 0.02418093f, -0.11749068f, 
    0.26288906f, 0.32643422f, 0.52574891f, 0.36878806f, -0.05189948f, -0.04764464f, 0.03003222f, 0.12262597f, 
    -0.05355995f, -0.10701281f, -0.04625996f, 0.04236477f, 0.03838607f, -0.08489321f, 0.00503722f, 0.05229127f, 
    0.04765378f, -0.05301823f, 0.07626203f, 0.10409201f, -0.10719921f, 0.03320400f, 0.07999922f, -0.01575940f, 
    -0.23070402f, -0.15517162f, -0.10089230f, -0.07697056f, -0.06848884f, -0.06715194f, -0.08187503f, -0.17889479f, 
    0.03629363f, -0.08250573f, -0.00610191f, -0.01631888f, 0.08002986f, -0.21713127f, -0.14720076f, -0.18815856f, 
    -0.05647054f, -0.03020465f, -0.05186278f, -0.08768099f, -0.01937532f, -0.02734459f, 0.01811628f, 0.03304674f, 
    0.24547978f, -0.14002825f, -0.44651267f, 0.03131103f, -0.10339545f, -0.04478346f, 0.13190804f, -0.00590618f, 
    0.14478688f, -0.01618369f, -0.02809779f, 0.12036975f, -0.18673195f, -0.02544655f, -0.01615782f, 0.13567387f, 
    0.06988924f, 0.09184697f, 0.05797580f, -0.02966025f, 0.01504066f, -0.09160481f, 0.05872817f, 0.03115234f, 
    -0.14719875f, -0.39020172f, -0.18642719f, -0.19431999f, -0.07807643f, 0.00088366f, -0.11732664f, -0.02866799f, 
    0.04868904f, -0.02099587f, 0.02589361f, -0.02036492f, 0.01328467f, 0.23638079f, 0.40874711f, 0.12743212f, 
    -0.03323081f, -0.05420009f, 0.11259343f, 0.13090964f, -0.03107040f, -0.03623339f, -0.00805063f, 0.09753031f, 
    0.17749275f, -0.07205263f, -0.02605143f, -0.02083441f, 0.07485544f, -0.03758331f, -0.03124370f, 0.00637407f, 
    0.07577002f, 0.17277934f, 0.20751446f, 0.08503855f, 0.29027969f, -0.10164949f, -0.03546099f, -0.13011074f, 
    0.12047246f, 0.14689583f, -0.04396474f, 0.07962761f, -0.04826494f, -0.07163728f, 0.08371931f, 0.02916861f, 
    0.18795872f, 0.02691651f, 0.14917479f, 0.07790753f, -0.01366419f, 0.14413485f, 0.13415581f, 0.22256128f, 
    -0.06261899f, -0.08315895f, 0.03636286f, 0.09784607f, -0.03469459f, 0.32191339f, 0.21571735f, 0.29705733f, 
    0.01588325f, -0.01451869f, 0.01619076f, 0.07774287f, 0.06275106f, 0.07461372f, 0.06995510f, -0.03987548f, 
    0.29161492f, 0.27976024f, 0.15716662f, 0.17847009f, -0.04365625f, -0.14937638f, 0.00254348f, 0.18294924f, 
    -0.16356038f, -0.11719172f, -0.01708148f, 0.00941335f, 0.48063251f, 0.19860688f, -0.00240519f, -0.03241553f, 
    0.03884796f, 0.03285813f, 0.08790547f, 0.19765972f, -0.02622685f, 0.01299665f, -0.01786902f, -0.03597774f, 
    0.29412436f, 0.05866056f, 0.02133796f, 0.10579535f, 0.02346784f, -0.06652328f, 0.00157661f, 0.11616413f, 
    -0.03449634f, -0.12159908f, -0.06650818f, 0.08383229f, -0.12523250f, 0.18697862f, 0.19652873f, 0.39588547f, 
    -0.14715782f, -0.07945152f, 0.05750481f, 0.08807364f, -0.03127897f, 0.02668809f, -0.03263899f, 0.02108359f, 
    -0.16839959f, -0.35346293f, -0.08587974f, -0.14227486f, -0.03221524f, -0.07433303f, 0.00902921f, -0.08458349f, 
    0.12585275f, -0.01253352f, 0.02467882f, 0.07289591f, 0.07937055f, 0.06566950f, 0.02631132f, 0.08943255f, 
    -0.05829696f, -0.07435086f, -0.04302440f, 0.06260521f, -0.13626538f, -0.24864589f, 0.02028267f, -0.03596815f, 
    0.14611214f, -0.03281708f, -0.13357995f, -0.08582138f, -0.08114655f, 0.05220711f, 0.07660829f, -0.05063020f, 
    0.04487210f, 0.02190784f, 0.05826196f, 0.01427668f, 0.13483380f, 0.07467292f, 0.01156564f, -0.06481560f, 
    0.05779729f, 0.03239941f, 0.03511324f, -0.02088072f, 0.00110220f, 0.09748831f, -0.02879328f, 0.02895948f, 
    -0.08111922f, -0.15308012f, 0.15354142f, -0.05423010f, 0.07892850f, 0.03659463f, -0.14631981f, -0.02822795f, 
    0.00473579f, -0.05738365f, -0.01426618f, 0.02961162f, -0.05393700f, -0.18865891f, -0.07450756f, -0.22408885f, 
    0.06116112f, -0.05928931f, -0.10546028f, -0.01905511f, 0.01951087f, 0.00051180f, -0.03964633f, 0.02010323f, 
    -0.06493340f, -0.24487151f, 0.04611791f, -0.14982505f, -0.06870291f, -0.09256181f, -0.03676317f, 0.05146821f, 
    0.09876939f, -0.00568961f, 0.13452184f, -0.01211466f, 0.06938231f, 0.10276006f, 0.17149332f, 0.10570025f, 
    -0.03855774f, -0.02911130f, 0.01668512f, 0.07750404f, -0.04622906f, 0.03954713f, -0.05580816f, -0.09782660f, 
    0.11329243f, 0.13430080f, 0.01979424f, 0.13776439f, 0.04551323f, -0.00706628f, 0.03599180f, 0.10878242f, 
    0.05467132f, 0.07970803f, -0.00269108f, -0.08004776f, 0.01784496f, 0.18062016f, -0.03651791f, 0.05513643f, 
    0.10511000f, -0.00812950f, 0.09967265f, -0.01770100f, 0.01844751f, -0.02887912f, 0.15033120f, 0.06846317f, 
    -0.36924925f, 0.01793273f, 0.14318937f, 0.02824460f, -0.03674375f, 0.05984358f, -0.11966358f, 0.15661542f, 
    0.03498747f, 0.05365264f, -0.08926370f, 0.07311612f, 0.07977998f, -0.10789380f, -0.20541511f, 0.07396351f, 
    0.09538051f, 0.01008645f, -0.00462620f, -0.09836067f, 0.04362544f, 0.03569264f, 0.20148470f, -0.06230191f, 
    0.13729183f, -0.12307376f, -0.25828329f, 0.01564765f, 0.03750207f, 0.03078591f, -0.04718202f, 0.09274359f, 
    -0.03704017f, -0.01954210f, -0.08599095f, -0.06262855f, 0.06976615f, -0.20855315f, -0.22130086f, -0.05517974f, 
    -0.12949997f, -0.00015067f, -0.04833767f, 0.01443289f, 0.06375468f, 0.01937972f, 0.06271030f, -0.03451047f, 
    0.35176575f, 0.23944861f, -0.13673840f, 0.08284003f, 0.18331544f, 0.04479646f, 0.02550067f, 0.13221525f, 
    -0.04741564f, -0.11827189f, -0.01227335f, 0.06390233f, 0.12734464f, -0.06114256f, 0.11426523f, 0.06860036f, 
    0.05025468f, -0.04844786f, 0.08775941f, -0.03912345f, 0.09877993f, 0.04633999f, 0.01304381f, -0.15173359f, 
    0.05162200f, 0.01908047f, -0.00562951f, -0.06814150f, -0.10174189f, -0.04335857f, 0.02264859f, 0.04144424f, 
    -0.05897267f, -0.02619599f, -0.00078216f, -0.01637906f, 0.08075556f, 0.30486867f, 0.38365209f, 0.31144759f, 
    -0.06451812f, -0.01867654f, 0.01637819f, 0.04493873f, -0.02673062f, 0.02132651f, -0.00043959f, -0.02064107f, 
    0.10555860f, -0.01281854f, 0.05588770f, 0.07123517f, -0.10570403f, -0.06433553f, 0.06916086f, 0.12727235f, 
    -0.02903757f, -0.10530798f, -0.03020971f, 0.15632802f, -0.14277671f, -0.02450076f, 0.27786991f, 0.22692369f, 
    -0.01698759f, 0.10164330f, -0.01907057f, 0.13599731f, 0.03508135f, 0.03560655f, 0.04688784f, 0.10744275f, 
    0.04804305f, 0.22264206f, 0.09374599f, 0.02104062f, 0.16450687f, 0.13057613f, 0.22810099f, 0.15233476f, 
    0.04219176f, 0.02833746f, -0.01963486f, 0.02395250f, 0.20604917f, 0.34835386f, 0.49167553f, 0.65182024f, 
    -0.02298646f, -0.00628458f, 0.02062430f, 0.15649226f, 0.03391349f, 0.02719484f, 0.05245956f, 0.05183193f, 
    0.04707703f, -0.04482463f, -0.02183268f, 0.02740711f, 0.02637182f, 0.02205270f, 0.07718460f, 0.01072828f, 
    -0.07043120f, -0.04908209f, -0.01516778f, -0.01652647f, -0.18880358f, -0.05636370f, -0.20618954f, -0.06906649f, 
    -0.01770709f, -0.01620121f, -0.05136436f, -0.19357781f, 0.04813600f, 0.02627562f, 0.00135644f, 0.03302352f, 
    0.19276507f, -0.13712186f, -0.32598108f, -0.10614992f, -0.12734468f, -0.04217748f, 0.04694672f, -0.15177912f, 
    0.04657056f, -0.03256292f, -0.00545168f, 0.09498777f, -0.32648236f, -0.01401212f, 0.09689004f, 0.05930316f, 
    -0.07223937f, 0.15703267f, -0.09788634f, 0.03120618f, 0.01032509f, 0.04947614f, -0.09963808f, 0.05024645f, 
    0.13567318f, -0.04904681f, 0.02716719f, 0.03351701f, -0.12452736f, -0.11687061f, 0.02353222f, 0.01501642f, 
    -0.10368904f, -0.17003900f, -0.07966267f, -0.08541653f, -0.11249848f, 0.17548123f, 0.09327631f, 0.11867858f, 
    0.05153084f, -0.14615244f, -0.06357027f, 0.04889748f, -0.20076817f, -0.18237208f, -0.11887623f, -0.01428438f, 
    -0.05149547f, 0.03230777f, 0.06627226f, -0.03311971f, 0.10964874f, 0.00872015f, -0.02973048f, -0.01362490f, 
    -0.12706637f, 0.10382926f, -0.05506971f, 0.05564943f, 0.09495544f, -0.35103497f, -0.17014699f, -0.12897670f, 
    0.04830797f, -0.01403195f, -0.07353850f, -0.02869970f, 0.01502776f, 0.04932772f, -0.01487373f, 0.00712931f, 
    0.00765824f, 0.14377557f, 0.14964852f, 0.31595719f, 0.09309047f, 0.04047582f, -0.03368468f, 0.04633139f, 
    -0.00223934f, 0.04563985f, 0.01102183f, 0.02624991f, 0.26714158f, -0.35488337f, 0.11061276f, -0.29101452f, 
    -0.02293847f, -0.02905338f, -0.08764151f, 0.07668082f, -0.19434345f, -0.00246381f, -0.05202546f, -0.11830923f, 
    -0.13301818f, 0.17227045f, 0.27119508f, 0.46254781f, -0.00237441f, -0.20643595f, 0.06147245f, 0.14586656f, 
    0.00574995f, 0.04931201f, -0.09056583f, 0.18353440f, -0.30955175f, -0.18601580f, 0.05012212f, -0.06406535f, 
    -0.05942896f, 0.03009698f, -0.06591035f, -0.02619990f, -0.10190679f, 0.00971381f, -0.20469615f, 0.07063048f, 
    -0.13789733f, 0.00831823f, 0.02360361f, 0.08349289f, 0.06163860f, -0.03421905f, 0.07681855f, -0.02890468f, 
    -0.00063891f, -0.04096995f, -0.02364482f, -0.04252170f, -0.10108307f, -0.20898832f, -0.11422639f, -0.17372070f, 
    -0.01250627f, -0.13355468f, -0.03089538f, -0.06657156f, 0.05041283f, 0.00515204f, -0.00003632f, -0.00921891f, 
    0.26610160f, 0.14749976f, 0.05051708f, 0.33199888f, -0.00297507f, 0.03130569f, 0.14584526f, 0.14194535f, 
    0.02663353f, -0.03604397f, -0.04388523f, 0.00286601f, 0.05352947f, 0.05261991f, 0.17321733f, 0.08797471f, 
    0.06687716f, -0.01409438f, 0.04361159f, 0.12836257f, 0.04181296f, 0.04519664f, 0.12534238f, 0.04583709f, 
    0.01963781f, -0.01510528f, -0.00574545f, 0.02433996f, 0.00594670f, 0.00317065f, -0.00027024f, 0.00466705f, 
    -0.00529526f, -0.00893669f, -0.01307037f, 0.02283957f, -0.01033402f, -0.00096271f, 0.02010474f, 0.00237516f, 
    -0.01992367f, -0.00447015f, -0.02287281f, -0.00264232f, 0.01546363f, -0.02181848f, -0.02928830f, -0.03034952f, 
    0.01564872f, 0.00828435f, 0.02531818f, -0.03882667f, 0.01456629f, 0.00585848f, 0.02781880f, 0.00809359f, 
    0.00406682f, 0.00684825f, -0.02733887f, 0.02849989f, -0.02479420f, 0.02074027f, 0.00042801f, -0.01626696f, 
    0.01027786f, 0.00101920f, 0.01779503f, 0.01596313f, 0.00003304f, -0.01755242f, -0.03124996f, 0.02334484f, 
    0.01617110f, -0.02747952f, -0.01806117f, -0.00346315f, -0.01721728f, 0.01265278f, -0.03473661f, -0.02557312f, 
    0.02604107f, -0.03854674f, -0.04319574f, -0.02240591f, -0.01311053f, -0.00437310f, -0.02465801f, 0.00071635f, 
    -0.01731978f, 0.00772176f, 0.01831334f, -0.03428973f, 0.03082704f, 0.00019111f, 0.00521831f, -0.00583969f, 
    -0.03045171f, 0.01894408f, -0.01193608f, 0.03007957f, -0.04162565f, -0.00814096f, -0.04243543f, -0.01576062f, 
    0.02571155f, -0.03715198f, 0.00552937f, 0.00984871f, -0.00587802f, -0.00620164f, 0.01681876f, 0.01907140f, 
    -0.02446522f, 0.01790102f, -0.01942714f, -0.00369602f, -0.04340583f, -0.00606406f, -0.02534634f, 0.01979784f, 
    -0.01257007f, -0.01027120f, -0.01282959f, 0.00404546f, -0.02122661f, -0.00539677f, 0.00385460f, -0.03440522f, 
    -0.00468869f, -0.02920140f, 0.02405493f, 0.02696904f, -0.01305485f, 0.01763923f, -0.00380451f, -0.00225106f, 
    0.02939090f, -0.00404334f, -0.01224216f, -0.03125834f, 0.02547740f, -0.02038067f, 0.02095893f, 0.03226122f, 
    0.01720813f, -0.01296593f, 0.00431224f, 0.01664576f, -0.03454682f, 0.00812964f, -0.01661416f, -0.03616833f, 
    -0.01876267f, 0.01421044f, -0.01384272f, -0.00636114f, -0.03519621f, -0.01913117f, -0.00981514f, -0.03640185f, 
    0.00915578f, 0.00320222f, -0.03159005f, 0.00754251f, -0.04415651f, -0.00967297f, 0.00856314f, -0.01120411f, 
    0.02329003f, -0.00690528f, -0.01642922f, 0.02190606f, -0.01680303f, -0.02090611f, -0.03783955f, 0.02687445f, 
    -0.00348624f, -0.03642105f, -0.00907827f, -0.03876807f, -0.00676735f, -0.00136982f, -0.03070659f, -0.04135214f, 
    -0.04310418f, -0.02158580f, 0.00589913f, -0.04080092f, 0.01787172f, 0.02360553f, 0.00915183f, 0.00123876f, 
    -0.01182528f, 0.02465738f, 0.01646551f, -0.00675959f, 0.00656270f, -0.01424333f, -0.00492028f, -0.01277193f, 
    0.01179058f, -0.01092625f, 0.02283112f, -0.00349858f, 0.00425142f, -0.00098681f, -0.00380089f, 0.02066245f, 
    -0.00619706f, -0.01241594f, 0.02650866f, -0.02824595f, -0.00702667f, 0.02569498f, -0.04125232f, -0.00433561f, 
    -0.01218966f, 0.03316274f, 0.02291179f, -0.03734011f, 0.01195431f, -0.02136512f, 0.02282906f, -0.03599428f, 
    0.03521293f, -0.02959330f, -0.02172580f, -0.02990051f, -0.03915712f, -0.02215947f, -0.03609256f, 0.02539437f, 
    0.02370735f, -0.00210054f, 0.02442176f, -0.04286961f, -0.02072945f, -0.02245107f, 0.02092663f, -0.03415377f, 
    -0.01670224f, -0.03495650f, -0.00972696f, -0.04094205f, -0.03059523f, -0.01348506f, -0.03035030f, 0.01739505f, 
    -0.03889433f, -0.00949204f, 0.01648715f, -0.03659068f, -0.03477182f, -0.02428373f, -0.01623479f, 0.02653143f, 
    -0.02458910f, -0.00368874f, 0.03094619f, -0.02780131f, 0.00765983f, -0.03825603f, 0.02497946f, -0.00875584f, 
    0.00243869f, 0.04076748f, 0.00438917f, -0.02442452f, 0.00770293f, -0.02080225f, -0.04019590f, -0.00653660f, 
    -0.03620251f, 0.00058724f, 0.01667715f, -0.02362576f, -0.03305740f, -0.04426214f, -0.02512419f, 0.01756886f, 
    -0.00904927f, 0.01910337f, 0.00646029f, 0.00722341f, 0.00638279f, 0.01887646f, -0.01652769f, -0.02149793f, 
    0.01982064f, 0.00618299f, 0.00074389f, -0.02419324f, -0.01010724f, 0.03296798f, 0.00687374f, -0.01341929f, 
    -0.01953375f, -0.03456407f, 0.02015846f, -0.03593833f, -0.00268497f, -0.02216487f, -0.00484616f, 0.02529322f, 
    -0.03425054f, -0.01877101f, -0.00653598f, 0.02299598f, -0.04100985f, 0.01107752f, -0.01831285f, -0.04426472f, 
    0.01277906f, -0.04420138f, -0.00714198f, -0.03990308f, -0.01086591f, 0.01428002f, 0.00291341f, -0.04041810f, 
    -0.03823461f, 0.00347378f, -0.01921568f, -0.03250616f, -0.03801912f, -0.01918408f, -0.00735734f, -0.03610210f, 
    0.01293914f, 0.00263569f, -0.01439449f, 0.01384409f, -0.04272282f, 0.02770534f, 0.00270438f, 0.02687649f, 
    -0.02310736f, -0.04467072f, 0.00563354f, 0.01420320f, -0.00300867f, -0.02369745f, -0.00400209f, 0.01469150f, 
    -0.03367142f, 0.00696005f, -0.02347615f, -0.03105400f, 0.00671342f, -0.03251757f, 0.01862630f, 0.02209127f, 
    0.02546708f, 0.01636099f, 0.02277870f, 0.02328509f, 0.00723355f, 0.02197700f, -0.00618793f, 0.01775835f, 
    -0.01617782f, -0.00785546f, 0.00604569f, 0.01148520f, 0.02040884f, -0.03243770f, -0.02531268f, -0.00953474f, 
    -0.01226781f, -0.03048090f, 0.01395669f, -0.00449026f, 0.01669765f, 0.01445687f, 0.01663384f, -0.00880032f, 
    0.02740516f, 0.02286847f, -0.03902644f, -0.02730263f, 0.02255185f, 0.00777718f, -0.01317772f, 0.01603866f, 
    0.02642015f, -0.01973389f, -0.02735484f, 0.02282238f, -0.00050494f, -0.02243858f, -0.02764592f, -0.01602266f, 
    -0.03986653f, 0.00994143f, -0.00454892f, 0.00838194f, -0.04007547f, 0.01065793f, -0.04046553f, 0.02153167f, 
    -0.02472611f, -0.00106562f, -0.03142959f, 0.02242600f, -0.03858131f, 0.01748110f, 0.01557190f, 0.02247353f, 
    0.00702554f, -0.00276447f, -0.03240543f, 0.00828762f, 0.00751528f, 0.00848206f, -0.02899008f, 0.01977167f, 
    0.00807327f, 0.01237786f, 0.02037082f, 0.00423829f, -0.03911914f, 0.00026261f, -0.02726453f, -0.00905234f, 
    0.01542042f, 0.01260592f, 0.02647275f, 0.01755205f, -0.02635756f, -0.02519011f, -0.01888947f, -0.00586420f, 
    -0.04328295f, -0.01463742f, -0.02189875f, -0.00954321f, -0.00015442f, -0.01061580f, -0.03024480f, 0.01141675f, 
    0.02363333f, -0.03415558f, 0.01021011f, -0.00751746f, 0.01925978f, -0.01149247f, -0.01732026f, 0.02562429f, 
    -0.00323275f, 0.00267916f, 0.01680711f, -0.03681644f, -0.01028667f, 0.01232736f, 0.02688822f, -0.03836651f, 
    -0.00296620f, 0.03412754f, 0.00625864f, -0.03018862f, 0.00907569f, -0.03241196f, -0.00943824f, 0.00862113f, 
    0.00871151f, -0.01919789f, -0.00324293f, 0.02127695f, 0.01150203f, 0.00449074f, -0.03238684f, 0.01835287f, 
    0.01317734f, -0.00564403f, 0.00101175f, 0.02314768f, 0.00220599f, 0.00954757f, -0.02453756f, 0.02957131f, 
    0.01309957f, -0.04035494f, 0.00322736f, -0.01507992f, 0.01282490f, -0.01392450f, -0.00228674f, 0.02119679f, 
    -0.00218399f, -0.03929835f, -0.02639225f, 0.01509995f, 0.02795277f, -0.01089905f, 0.00251170f, 0.00791643f, 
    -0.03156845f, 0.00724617f, -0.03280035f, -0.02907505f, -0.00418252f, 0.02815161f, 0.01563949f, -0.03174043f, 
    0.00331209f, -0.03182588f, 0.00341263f, 0.01920654f, -0.01753407f, -0.01750181f, 0.02312822f, -0.03563376f, 
    -0.02841055f, 0.00189003f, 0.02789167f, 0.00279728f, -0.00908919f, 0.01285594f, 0.00198191f, -0.02779162f, 
    0.00235698f, -0.03655052f, 0.01287831f, -0.04263463f, 0.02885206f, 0.01583988f, -0.02619644f, -0.04287726f, 
    -0.02024074f, 0.00483791f, -0.03511459f, -0.03877023f, -0.00261277f, -0.01168091f, -0.03570005f, 0.00332646f, 
    0.03023334f, 0.00821857f, -0.00132633f, 0.01086214f, -0.02641703f, -0.03730045f, 0.02613918f, -0.00460519f, 
    -0.00088540f, -0.02080672f, -0.01871295f, 0.01237819f, -0.03997157f, -0.03046109f, -0.03024432f, -0.03049581f, 
    0.02442993f, -0.00958223f, -0.03648444f, -0.04219446f, -0.04293292f, 0.00358620f, -0.03642879f, 0.01479136f, 
    -0.01820072f, -0.03351468f, 0.02552782f, -0.03789885f, -0.03015084f, 0.01339770f, -0.03845853f, 0.02669544f, 
    -0.01805883f, -0.03302883f, 0.00894152f, -0.03151414f, -0.01903394f, -0.00968162f, -0.00205411f, 0.00034398f, 
    0.01780958f, -0.01534305f, -0.02605519f, -0.02397471f, -0.02711586f, 0.00600947f, -0.01660057f, -0.02963754f, 
    -0.00429595f, 0.00305792f, 0.02878707f, 0.02758311f, -0.00004374f, -0.00390442f, -0.01144335f, -0.02146013f, 
    -0.01697287f, -0.02754230f, 0.01724912f, -0.02482282f, -0.04210718f, -0.00534982f, -0.00806803f, -0.01689028f, 
    -0.00077680f, -0.02733273f, 0.02688137f, -0.02561502f, 0.01790894f, -0.01296456f, 0.00849288f, 0.02402787f, 
    -0.00613287f, 0.02565977f, 0.02307539f, -0.03726045f, 0.02917805f, 0.02662252f, -0.01106986f, 0.01039256f, 
    0.01542505f, -0.00067592f, -0.00545297f, -0.03136431f, -0.02512078f, 0.01873081f, -0.00250648f, 0.00410451f, 
    -0.00448254f, -0.00309051f, -0.03427993f, 0.02293774f, 0.00374566f, 0.00978076f, 0.00429609f, -0.02825577f, 
    -0.00078658f, -0.03156467f, -0.04249304f, -0.02029076f, -0.01005555f, -0.01031592f, -0.03299536f, -0.03640985f, 
    0.00242061f, 0.02663899f, -0.00676649f, -0.02634195f, -0.00098884f, -0.03114382f, 0.00617833f, -0.00378279f, 
    -0.02310444f, 0.02052786f, -0.03024809f, -0.02900945f, -0.01188465f, -0.02420303f, -0.03091571f, -0.01486215f, 
    0.00148273f, -0.03322474f, 0.00564170f, -0.04006980f, 0.00105556f, 0.01091895f, -0.03946069f, 0.02347070f, 
    -0.03723580f, -0.03454488f, 0.01519447f, 0.00390390f, -0.03558759f, -0.02865858f, 0.00821843f, 0.01430490f, 
    -0.02818161f, 0.02405685f, -0.02607895f, -0.03480718f, 0.00887073f, -0.02581994f, -0.04414259f, -0.02713864f, 
    -0.04027883f, -0.03590396f, -0.04101998f, -0.00631951f, -0.00832358f, 0.02202555f, 0.02547782f, -0.00875524f, 
    0.00710138f, 0.02502501f, 0.02236082f, -0.02897232f, -0.04174148f, 0.00133231f, -0.02043415f, -0.01925978f, 
    -0.02073474f, 0.01492008f, 0.01352278f, 0.00119649f, -0.02471582f, -0.01186647f, -0.04223983f, 0.01622895f, 
    0.00608306f, 0.01051422f, -0.00283426f, -0.01000525f, -0.01549687f, -0.02130335f, -0.02300709f, -0.01114645f, 
    0.02563728f, 0.01300017f, 0.01188400f, -0.04090147f, 0.00937849f, 0.01965806f, -0.02545392f, -0.00959431f, 
    0.03099753f, 0.00094746f, -0.02752971f, 0.01957811f, -0.00511324f, -0.02673609f, 0.02453312f, -0.01493627f, 
    0.01491158f, 0.00982700f, -0.03800539f, -0.01785948f, 0.01828386f, -0.02558314f, 0.00815637f, -0.02485195f, 
    -0.04096482f, 0.02595291f, 0.02562475f, -0.04368040f, -0.02039947f, 0.02243770f, -0.02784526f, 0.01557176f, 
    0.00521771f, 0.02451290f, 0.00739367f, -0.02517355f, -0.01414779f, -0.03591185f, 0.00056081f, -0.02562064f, 
    -0.04144666f, -0.04018597f, -0.00279168f, -0.02651878f, -0.00817696f, -0.03856219f, -0.02687344f, 0.02994095f, 
    -0.04218801f, 0.01985033f, -0.01055605f, -0.01100160f, -0.00467525f, -0.01952184f, 0.01457460f, 0.00348516f, 
    -0.02734375f, -0.00610664f, 0.01246240f, 0.02610107f, -0.02973779f, -0.01332006f, 0.01552873f, 0.01606314f, 
    -0.02978756f, -0.04112591f, 0.00474998f, -0.03419930f, 0.01269075f, -0.03288788f, 0.02285674f, -0.02660420f, 
    -0.00651108f, 0.02210874f, -0.00465761f, 0.01093950f, 0.02719285f, 0.02087908f, -0.00608260f, 0.02315733f, 
    -0.01077044f, 0.00566851f, -0.00166511f, -0.01744128f, -0.02391557f, -0.01914226f, 0.02015438f, 0.01722849f, 
    0.00448751f, 0.02755624f, -0.03262859f, 0.01563925f, 0.00004054f, -0.02407884f, 0.01971768f, 0.00696073f, 
    -0.00691883f, -0.00649592f, -0.03683970f, 0.03386156f, -0.00369159f, 0.02845947f, -0.02861403f, 0.00317258f, 
    -0.01454027f, 0.00522177f, -0.00296403f, 0.02900103f, -0.02880789f, -0.01042704f, -0.01278562f, -0.01055540f, 
    0.00908626f, 0.01479805f, 0.01975901f, -0.01474521f, -0.04159676f, -0.03042788f, 0.02525080f, -0.00859844f, 
    0.01071163f, -0.03139595f, -0.03739733f, 0.00891265f, 0.02882454f, 0.02329892f, -0.02893235f, 0.00570271f, 
    -0.02868365f, -0.00138341f, -0.01892577f, 0.00772097f, 0.02604422f, -0.03781396f, -0.00287701f, -0.01620016f, 
    0.00878476f, -0.03025678f, -0.02736000f, 0.01277420f, 0.00361660f, -0.04014607f, 0.02793599f, 0.01345187f, 
    0.01789888f, -0.02937242f, -0.03065544f, -0.03725958f, 0.01438781f, 0.02227339f, 0.00023679f, -0.03663876f, 
    0.00382545f, -0.01118812f, 0.01725278f, -0.00024485f, -0.01691079f, -0.03602285f, -0.00283006f, -0.03270143f, 
    -0.00189539f, -0.02022947f, -0.02329790f, 0.01615228f, 0.01994492f, 0.00014526f, 0.01618752f, 0.00234978f, 
    -0.03860817f, -0.03035636f, -0.01997069f, -0.01324033f, -0.00500326f, -0.01750361f, -0.01434513f, -0.03972714f, 
    0.02713831f, 0.02749171f, -0.00929054f, -0.00687911f, -0.02110448f, 0.00683035f, 0.01435169f, -0.02570730f, 
    -0.03965644f, -0.01236198f, -0.02458911f, -0.04008686f, -0.02770930f, -0.03220221f, -0.01060724f, -0.01838244f, 
    -0.02289743f, -0.02334642f, -0.03411744f, -0.01167897f, -0.02189825f, 0.02431778f, -0.01179015f, 0.01579091f, 
    -0.02391309f, 0.02298447f, -0.01609395f, -0.02029793f, -0.00599230f, -0.00859367f, 0.01236332f, -0.03849480f, 
    -0.03583045f, -0.01896071f, -0.02840261f, 0.02588670f, 0.01457052f, -0.02296695f, -0.00516680f, -0.03062803f, 
    0.00595672f, 0.02634184f, -0.03899140f, -0.02221350f, 0.00672249f, -0.02267699f, 0.02654204f, -0.02442756f, 
    -0.02243790f, -0.00792774f, -0.02194001f, 0.02305429f, -0.01252582f, -0.03074374f, 0.00708724f, 0.00573758f, 
    0.02647847f, 0.02363373f, -0.00186483f, 0.01544925f, -0.04106747f, -0.03843143f, 0.00859704f, -0.02511410f, 
    -0.02300316f, 0.02114916f, -0.01077546f, 0.00047400f, -0.03068123f, 0.01557039f, -0.03851655f, -0.04196944f, 
    -0.02980471f, -0.00317603f, -0.01673130f, -0.00742304f, 0.02230274f, -0.01449740f, -0.00919333f, 0.01641202f, 
    -0.00021347f, -0.00098622f, 0.00238877f, 0.00925051f, -0.00886405f, -0.03555916f, -0.01947719f, 0.01477460f, 
    -0.03203373f, 0.00191200f, -0.00923729f, -0.01606126f, 0.02915842f, -0.00101675f, -0.03280822f, 0.00454825f, 
    -0.02729381f, -0.00230990f, -0.02813225f, -0.02224793f, -0.02173014f, 0.00470107f, -0.00567712f, -0.03353102f, 
    0.02943254f, -0.00200244f, 0.01178802f, 0.00016088f, 0.02819637f, 0.01259083f, -0.00485366f, -0.00640199f, 
    -0.02233726f, 0.02594005f, 0.00434330f, 0.01652413f, 0.00025521f, -0.03587357f, 0.00418529f, -0.03696613f, 
    0.01197541f, 0.01951638f, -0.03855053f, -0.03269714f, -0.02037030f, -0.03529901f, 0.00694640f, 0.02398821f, 
    0.01870787f, -0.03787102f, 0.00993094f, 0.00523963f, -0.02693781f, 0.02022827f, -0.03144995f, -0.00607176f, 
    0.00522870f, -0.02533907f, -0.02081741f, 0.01669716f, -0.04170982f, -0.01227699f, -0.00957012f, 0.02789511f, 
    -0.02973172f, -0.01607678f, -0.03221079f, -0.00688047f, -0.00033960f, -0.01815401f, -0.02779766f, -0.00549789f, 
    -0.03811249f, 0.02546843f, -0.03106133f, 0.01282013f, -0.02532544f, -0.03130561f, 0.02945049f, 0.02580798f, 
    0.00860568f, -0.01630811f, -0.02485194f, -0.02081905f, 0.00727769f, 0.00653762f, -0.01865463f, 0.01744778f, 
    -0.02616815f, -0.01723283f, -0.03575063f, -0.03755337f, 0.01557667f, 0.00436159f, -0.02149265f, -0.04060078f, 
    0.01905821f, 0.00091620f, 0.01178376f, -0.02080051f, -0.00736839f, -0.03354625f, -0.03066809f, 0.02014005f, 
    -0.01506716f, 0.00490144f, -0.02123359f, 0.01405306f, -0.02103284f, 0.02447313f, -0.02299363f, -0.02846207f, 
    -0.02589244f, -0.02192401f, 0.02235886f, -0.01430852f, -0.02329913f, -0.00520911f, 0.03086705f, -0.03304138f, 
    -0.02257303f, 0.02550222f, -0.00363649f, -0.00832130f, 0.01567720f, -0.04181737f, -0.02652848f, -0.02928626f, 
    0.00916217f, -0.00765411f, -0.01043008f, -0.03453283f, -0.00381346f, -0.01416890f, -0.02681604f, -0.02560149f, 
    0.00990951f, -0.00699920f, 0.02887196f, 0.01144128f, 0.00197373f, 0.00074608f, -0.02283472f, -0.00257974f, 
    0.00131589f, 0.00810330f, 0.01526697f, -0.03149603f, -0.02128492f, -0.03499316f, -0.00689505f, 0.00771316f, 
    0.00789924f, -0.02929084f, -0.02354912f, -0.00660055f, -0.03305393f, 0.01191187f, -0.04126506f, 0.01017771f, 
    0.02100867f, 0.02308667f, -0.00776636f, -0.02704879f, -0.03610750f, -0.02324726f, -0.01640397f, 0.02756426f, 
    -0.04044311f, 0.00454650f, 0.00421208f, 0.00953546f, 0.02483972f, -0.00203654f, 0.01522161f, 0.00333477f, 
    0.01529724f, -0.03378742f, 0.02824922f, 0.00205298f, -0.01074500f, -0.00537745f, -0.01265625f, 0.02434978f, 
    0.01824700f, 0.00753864f, -0.00435595f, -0.02167349f, -0.00158236f, -0.01406987f, -0.00446161f, 0.01759584f, 
    0.00591509f, -0.03296955f, -0.01612396f, -0.03211061f, 0.00450722f, -0.03054551f, 0.01375762f, -0.01768924f, 
    -0.02644342f, -0.00322263f, -0.01381162f, -0.01341400f, 0.01767956f, -0.00148729f, 0.00641674f, 0.02157707f, 
    -0.00633424f, -0.03089511f, 0.00403196f, -0.03435045f, 0.02332142f, -0.01694322f, -0.02710743f, 0.01450755f, 
    -0.03085442f, 0.00352887f, 0.02303721f, -0.00026905f, -0.03485687f, 0.02886418f, 0.02521991f, -0.01987461f, 
    -0.01202126f, -0.00800236f, -0.01928902f, 0.01296713f, -0.00719492f, -0.00755774f, -0.01016748f, 0.00389675f, 
    0.02452054f, -0.00391552f, -0.01773909f, -0.03005211f, -0.00094997f, -0.00873378f, -0.00113416f, 0.01668817f, 
    -0.01448159f, -0.02719316f, -0.02196017f, -0.00910343f, -0.00512695f, 0.02699064f, -0.01705359f, -0.02882293f, 
    -0.02990964f, -0.03752368f, 0.01443815f, -0.00118864f, -0.00298323f, -0.03217977f, -0.04052312f, 0.01010776f, 
    0.00627423f, -0.00072457f, 0.01917334f, -0.01184484f, -0.00556848f, 0.01772773f, -0.02305827f, -0.02723439f, 
    0.01352922f, -0.01670808f, 0.00525554f, -0.01774079f, -0.03201310f, 0.00682588f, -0.03310731f, -0.04118697f, 
    0.02851854f, -0.03927327f, 0.02185358f, 0.02326834f, -0.02718621f, -0.03461387f, -0.03643509f, -0.00963814f, 
    -0.01748362f, 0.00179864f, -0.01590823f, -0.01938606f, -0.02671009f, -0.02876276f, -0.00845181f, -0.00782070f, 
    -0.03751502f, -0.04121322f, 0.00348246f, -0.04074316f, -0.00033736f, 0.00717464f, -0.03790227f, 0.01490842f, 
    -0.03893173f, -0.00196432f, -0.02877417f, 0.02370895f, -0.00325399f, 0.00951652f, -0.02413145f, -0.00716401f, 
    -0.01080645f, -0.00187909f, 0.02164154f, 0.01916254f, -0.02138957f, -0.03224586f, 0.01180875f, -0.00067619f, 
    0.00361187f, 0.00364449f, 0.01848553f, -0.00477333f, 0.01519664f, -0.00192065f, -0.01293249f, 0.00669289f, 
    -0.03718141f, 0.02613547f, -0.00946238f, 0.02114779f, 0.02518495f, -0.01379713f, -0.00287192f, -0.01065688f, 
    -0.01122318f, 0.02543564f, 0.01220529f, 0.02820797f, -0.03380438f, 0.02830512f, 0.01585329f, 0.02119119f, 
    -0.03359148f, 0.00553203f, -0.02423926f, -0.02485170f, -0.03427453f, -0.03948894f, 0.01917063f, -0.00558782f, 
    -0.03635047f, 0.01044009f, -0.00347290f, -0.01386826f, -0.02820072f, -0.02292182f, -0.01002467f, -0.01700620f, 
    -0.01809152f, -0.02144008f, -0.01100914f, -0.00641289f, -0.02318214f, -0.04086311f, -0.01755334f, -0.02573164f, 
    -0.03953024f, -0.01422995f, 0.02078287f, -0.03693832f, 0.02359913f, 0.00085772f, 0.02784140f, -0.02768097f, 
    0.02835939f, -0.01286326f, -0.01975034f, -0.00814227f, 0.02258059f, 0.00003454f, 0.02679629f, 0.00849054f, 
    -0.00962602f, 0.00203337f, 0.00322862f, 0.02965585f, -0.00893595f, 0.02467598f, 0.00346151f, -0.03199438f, 
    -0.01579665f, 0.02995358f, -0.01484781f, -0.02852526f, 0.03579651f, -0.02598658f, 0.01615934f, 0.02130793f, 
    0.00590163f, 0.00744704f, -0.00872548f, 0.02885822f, -0.00391743f, 0.02208166f, 0.00672990f, -0.02608761f, 
    0.00012423f, -0.01951656f, -0.00030639f, 0.00313718f, -0.02533620f, 0.00715142f, -0.01331431f, -0.02017135f, 
    0.01797236f, -0.01758287f, -0.00510542f, -0.02757230f, -0.01926203f, 0.02855613f, 0.02404330f, 0.01019767f, 
    0.00364506f, 0.02738228f, 0.02371135f, 0.02647256f, -0.03466727f, 0.02379813f, -0.02343586f, -0.02466145f, 
    -0.03685194f, -0.02663034f, 0.00038740f, 0.02451156f, -0.02899620f, -0.01783461f, 0.00490930f, -0.01278133f, 
    -0.01837121f, -0.03025595f, -0.01423642f, -0.01506293f, 0.01503491f, -0.04120237f, 0.02053557f, -0.00412999f, 
    -0.02693375f, -0.03194823f, -0.03303595f, -0.00761198f, -0.00401279f, -0.03737735f, -0.00866517f, -0.01060354f, 
    0.02982549f, -0.03336772f, -0.02675996f, -0.02974958f, -0.04039059f, 0.02004527f, -0.02012819f, -0.01866350f, 
    0.02520715f, -0.03572504f, 0.02049339f, 0.01102704f, 0.02096792f, -0.01954505f, 0.02685512f, 0.01629870f, 
    -0.04042817f, 0.00463409f, -0.01205137f, -0.02670894f, -0.04052145f, 0.01264419f, -0.00694048f, 0.02299680f, 
    -0.04184977f, -0.00215352f, -0.01171592f, -0.02170430f, 0.02804322f, -0.03692110f, -0.01858341f, -0.02547113f, 
    0.01326295f, -0.00301898f, -0.01786956f, -0.00167374f, 0.00408019f, -0.03813537f, 0.02785841f, 0.02822078f, 
    0.02975880f, -0.00104843f, -0.04158906f, 0.01570112f, 0.02161841f, -0.03155079f, 0.01932729f, 0.02821466f, 
    -0.01281281f, -0.00992846f, -0.03783456f, 0.01381328f, 0.00583354f, -0.03336274f, 0.01299909f, 0.00581491f, 
    0.02940232f, -0.00975166f, -0.01091854f, 0.02534726f, 0.02791160f, -0.00305439f, -0.02773813f, 0.01398329f, 
    -0.03621072f, -0.01686186f, -0.03821889f, -0.03225082f, 0.01290771f, 0.00127534f, 0.01293978f, -0.02912539f, 
    -0.01198965f, -0.02773084f, -0.00075364f, -0.03929730f, -0.00675210f, -0.01968556f, 0.02782618f, 0.01911909f, 
    0.00786366f, -0.01765777f, -0.00586224f, -0.02652592f, -0.02542976f, 0.02770651f, -0.03455060f, 0.00094322f, 
    0.02144163f, 0.03005745f, 0.02658652f, 0.00328018f, 0.01550096f, -0.03373271f, -0.01066523f, 0.01995831f, 
    -0.01456445f, -0.01114832f, -0.02141414f, 0.02498977f, 0.00552013f, -0.02422855f, -0.03053847f, 0.01318457f, 
    -0.01130447f, -0.04110853f, -0.01108525f, -0.04098161f, -0.02583780f, 0.00942085f, -0.03033895f, -0.01330963f, 
    -0.02120431f, -0.01417561f, -0.02726901f, -0.00206287f, -0.00094320f, 0.02982725f, 0.02195548f, 0.02261991f, 
    0.01512838f, 0.02770675f, -0.02809923f, -0.00209897f, -0.00227185f, 0.02051143f, -0.01590814f, -0.03993830f, 
    0.01917027f, 0.00897972f, -0.03521278f, -0.02039222f, -0.02904812f, 0.01894476f, -0.00257711f, -0.00170362f, 
    -0.01151375f, -0.00328311f, -0.01662279f, -0.03958451f, -0.00538018f, 0.00131266f, -0.00095489f, -0.01190455f, 
    0.10198665f, 0.02632754f, -0.23773175f, 0.20149864f, -0.13701929f, 0.12411476f, -0.19276844f, 0.07668291f, 
    -0.01656783f, 0.08155954f, 0.02359589f, -0.00318457f, 0.25843042f, 0.15856038f, -0.08306913f, -0.21176992f, 
    0.10279174f, 0.16456641f, 0.08190700f, -0.00756313f, -0.10058513f, -0.06184385f, 0.07411581f, 0.05074526f, 
    -0.13578758f, -0.08315142f, -0.16097003f, 0.16213003f, -0.04903505f, 0.07125069f, 0.01285393f, 0.07481261f, 
    0.02436393f, 0.12505589f, 0.03370443f, 0.06986696f, -0.43877777f, 0.17434648f, -0.18896443f, -0.02693065f, 
    0.08589666f, 0.20682712f, 0.00726446f, 0.04576989f, 0.05082162f, -0.02103447f, 0.11547290f, -0.06031103f, 
    0.19738597f, 0.10463935f, 0.15778486f, -0.17808507f, -0.04914918f, 0.06695412f, 0.03434940f, -0.11359662f, 
    -0.08846646f, -0.13564125f, -0.06503090f, -0.04952446f, -0.18236284f, -0.16789207f, -0.00813191f, 0.13401410f, 
    0.05191899f, -0.01397901f, -0.02190641f, 0.12469448f, 0.05098882f, -0.03474921f, -0.14433804f, 0.02584809f, 
    0.27020317f, -0.04470263f, 0.16893120f, -0.07561875f, -0.04575445f, -0.01825542f, 0.03597844f, 0.02332006f, 
    -0.08542050f, -0.00891449f, -0.05217925f, -0.05746001f, -0.10518681f, 0.03537925f, -0.13061561f, -0.10935966f, 
    -0.02201797f, -0.01950900f, -0.06296192f, -0.05163138f, 0.00220950f, -0.09463045f, -0.09042866f, -0.11740001f, 
    -0.13198802f, -0.17025615f, -0.31740820f, -0.01270972f, -0.04050699f, -0.00499827f, -0.00591889f, -0.06431103f, 
    -0.05416616f, 0.03488983f, 0.24062002f, 0.05230771f, 0.02673701f, 0.30850425f, -0.08862785f, -0.02599845f, 
    0.07009474f, -0.03534175f, 0.02349500f, 0.01256197f, -0.05198666f, 0.02580315f, -0.01669832f, 0.07816717f, 
    0.16053434f, -0.12195711f, 0.09922364f, -0.07571031f, -0.06619103f, 0.05123788f, -0.02780139f, -0.02579242f, 
    -0.08538895f, -0.02963557f, 0.00815857f, 0.01990913f, 0.22573449f, -0.10622173f, 0.05421406f, 0.02509765f, 
    -0.09431683f, 0.10118669f, -0.15773185f, 0.15580320f, 0.12480044f, -0.07121553f, -0.04795688f, 0.01570003f, 
    0.27887914f, 0.15649360f, 0.12675041f, 0.22465828f, -0.07305786f, -0.04235195f, -0.11472397f, 0.04336865f, 
    -0.13740468f, -0.04234039f, -0.01635248f, -0.01540563f, -0.16516376f, 0.11386600f, -0.26037997f, 0.22695045f, 
    -0.03697875f, -0.06094705f, 0.00923641f, 0.02775279f, 0.02815204f, -0.04846232f, 0.09546502f, 0.05135683f, 
    -0.18047646f, -0.11475547f, 0.17009978f, -0.21244235f, 0.05835997f, 0.06329148f, -0.03383757f, 0.11779421f, 
    0.01635521f, -0.02793456f, 0.11941970f, -0.14737314f, -0.14907496f, -0.00592837f, 0.03125974f, 0.13499962f, 
    0.04701486f, 0.01206269f, 0.11514618f, -0.07155424f, 0.09129030f, 0.01108404f, 0.12417163f, 0.04139784f, 
    0.03005780f, 0.32841343f, -0.15498906f, -0.01124700f, -0.02530096f, -0.01686672f, 0.01405516f, -0.08399595f, 
    -0.01283034f, 0.01473385f, 0.02264381f, -0.08456910f, 0.08830556f, -0.10632943f, -0.05512553f, 0.03920241f, 
    -0.01840332f, 0.13140164f, 0.09338918f, 0.07716936f, -0.12529947f, 0.07913022f, -0.12741174f, 0.00322146f, 
    -0.30718932f, -0.19526885f, 0.04535160f, 0.14140531f, -0.05778371f, -0.00217776f, 0.10260868f, 0.01139386f, 
    0.03824822f, 0.06403859f, -0.04395587f, -0.16209395f, -0.11262477f, 0.14230008f, -0.10996426f, 0.10617401f, 
    -0.06932762f, 0.01503705f, 0.21321332f, 0.09598378f, 0.02884980f, -0.01334589f, -0.07114857f, -0.05098393f, 
    -0.11928526f, 0.25634009f, -0.05295701f, 0.20861228f, -0.04523748f, -0.13149537f, 0.11837730f, -0.10317379f, 
    0.00739400f, 0.01356610f, 0.14522521f, -0.02507767f, -0.16134003f, 0.06810853f, -0.20717770f, 0.23234573f, 
    0.01191897f, 0.01470544f, -0.02735343f, 0.04462561f, 0.05710202f, 0.05352274f, -0.02037771f, -0.06251892f, 
    0.01673434f, -0.09837924f, 0.04967357f, -0.05418802f, -0.16154550f, -0.04740175f, -0.16144598f, 0.01437703f, 
    0.16145428f, 0.02260976f, 0.08662291f, 0.03104777f, -0.13278082f, -0.07300555f, -0.01354919f, 0.21849798f, 
    0.00910481f, 0.05390421f, 0.10483450f, 0.19694537f, 0.00968109f, -0.03145034f, 0.04455441f, 0.04444880f, 
    -0.00991435f, 0.03426959f, 0.18820688f, -0.07720432f, -0.11447421f, 0.07514609f, -0.12202553f, -0.04656419f, 
    0.13551953f, -0.01580232f, 0.00608675f, -0.06440377f, 0.31105778f, -0.13066576f, 0.36077267f, -0.00675042f, 
    0.18599829f, -0.00398065f, 0.12235175f, 0.01192396f, 0.03588289f, -0.02647011f, 0.15575105f, -0.04196376f, 
    0.20254107f, 0.02341341f, 0.19007801f, 0.12029673f, 0.06265523f, -0.09274465f, 0.04376137f, 0.01908905f, 
    -0.15334909f, -0.03765692f, -0.06747014f, 0.13255149f, 0.08910653f, -0.01155992f, 0.03422307f, -0.19664104f, 
    0.13664576f, -0.01014198f, -0.08933575f, -0.03550253f, 0.02802380f, 0.09046063f, 0.05159829f, -0.03300837f, 
    -0.14944953f, -0.07724987f, -0.03118769f, 0.05680811f, 0.09913763f, 0.16617465f, -0.19342925f, 0.06938290f, 
    -0.03075101f, -0.05008015f, -0.07279807f, 0.04218179f, -0.11422746f, -0.19894941f, 0.03240351f, 0.00339492f, 
    0.07690394f, 0.14497311f, -0.18145350f, 0.13348895f, -0.06264763f, -0.01554470f, -0.05030844f, -0.16073304f, 
    0.22985549f, 0.33022657f, -0.29400545f, -0.00043337f, -0.16786163f, 0.02991482f, 0.00892367f, 0.00518058f, 
    0.04002622f, 0.05377741f, -0.06959708f, -0.07165164f, 0.17471395f, -0.13307291f, 0.08078311f, -0.13429609f, 
    0.12388695f, 0.06435582f, 0.03977270f, 0.14890520f, -0.02452883f, 0.07660872f, 0.13101758f, 0.00660011f, 
    -0.21475288f, -0.10092718f, -0.08375380f, -0.06133909f, -0.02265473f, 0.06243137f, -0.07048775f, 0.11830247f, 
    0.07299544f, -0.05225498f, -0.13088360f, -0.07897998f, 0.40621200f, 0.23921221f, 0.22281191f, -0.00724345f, 
    -0.04924726f, 0.13298835f, 0.14921667f, -0.01293738f, 0.03087327f, 0.04711125f, -0.04158965f, -0.08394501f, 
    -0.00213717f, -0.03875903f, 0.03672942f, 0.02440391f, -0.05214331f, 0.02768856f, -0.01344809f, -0.06448285f, 
    -0.02484364f, -0.03631603f, -0.13030413f, 0.08617833f, -0.47242770f, -0.27625760f, 0.00405101f, 0.06470655f, 
    0.14053316f, 0.08752068f, -0.03812208f, -0.11462733f, -0.07630657f, -0.03543722f, 0.04249607f, 0.06274403f, 
    -0.10189900f, 0.35213426f, -0.35584468f, 0.21462218f, -0.07128006f, 0.01783970f, 0.23649502f, 0.06736394f, 
    0.03130093f, -0.04258708f, -0.02330512f, -0.00292126f, -0.22999771f, 0.19005230f, -0.18016048f, -0.03028281f, 
    -0.10221766f, -0.08495421f, 0.05661663f, 0.03845178f, 0.11006445f, -0.01387036f, -0.03669912f, -0.00122233f, 
    0.30076435f, 0.15851781f, 0.46706912f, 0.04482346f, -0.00442727f, -0.04173232f, -0.02223009f, 0.00294470f, 
    -0.09324372f, 0.08488027f, 0.05205088f, 0.02188023f, -0.15944080f, 0.06238670f, 0.16428702f, 0.12022618f, 
    0.14056332f, -0.19750091f, 0.06571431f, -0.09680876f, 0.05185203f, -0.09364305f, -0.00429195f, 0.00608383f, 
    0.11918599f, 0.09260935f, -0.00951571f, 0.06486931f, -0.00018354f, 0.19961822f, -0.01718011f, 0.05709052f, 
    -0.01491788f, 0.03265097f, -0.02147297f, -0.04919431f, 0.17294234f, -0.26260650f, 0.33550149f, -0.11712122f, 
    0.15855333f, 0.11488288f, 0.08750087f, 0.14616676f, -0.04664391f, 0.07611602f, 0.16108127f, 0.08713374f, 
    -0.10456924f, -0.23469310f, 0.08815627f, 0.06956081f, 0.02735853f, -0.09280112f, 0.21331559f, 0.09719614f, 
    0.03273218f, 0.11162702f, -0.00374211f, -0.20044990f, 0.30975682f, -0.01707118f, 0.21534634f, -0.02820296f, 
    -0.00230836f, 0.19737987f, -0.08107955f, -0.01086985f, -0.02329975f, -0.08305918f, -0.06696983f, -0.17337130f, 
    0.06638741f, -0.02935694f, 0.17028323f, -0.14034422f, 0.07023358f, -0.14971153f, 0.06776393f, 0.03728285f, 
    0.04644619f, 0.13445811f, 0.30898017f, -0.07431959f, 0.02031361f, 0.21645960f, 0.03920065f, -0.09714542f, 
    0.09603225f, -0.02066011f, 0.13951004f, -0.07845198f, -0.05847304f, -0.09464765f, -0.09220579f, -0.01147287f, 
    0.06187858f, 0.04464197f, -0.00394090f, -0.09715682f, -0.01136861f, 0.04069126f, -0.04595612f, 0.16294646f, 
    -0.01363328f, -0.03713758f, -0.04178015f, -0.09361758f, 0.04287933f, 0.17743175f, 0.04591639f, -0.11197363f, 
    -0.01905558f, 0.14751121f, -0.08655128f, -0.27277565f, -0.05890819f, -0.08158394f, -0.06968737f, -0.17196387f, 
    0.03738470f, 0.10711074f, 0.04901093f, 0.04071708f, -0.01685113f, 0.11157063f, -0.07355170f, -0.10375460f, 
    0.03632725f, 0.05170379f, -0.15389912f, -0.02800731f, 0.06996172f, -0.21183020f, 0.22959858f, -0.14932205f, 
    0.03213188f, 0.11674757f, -0.15031911f, 0.22653946f, -0.05310673f, 0.08163790f, 0.15746689f, -0.02972620f, 
    0.37547284f, -0.21717021f, 0.31541297f, 0.04560115f, -0.00451130f, 0.01134732f, -0.21559399f, 0.04500559f, 
    -0.06980006f, 0.08950386f, -0.09655328f, 0.07042348f, -0.05965932f, 0.22685421f, -0.17235784f, 0.08598918f, 
    0.02046173f, -0.12316917f, 0.26568413f, 0.05764307f, 0.04244863f, 0.14546895f, -0.02078097f, 0.03746147f, 
    0.05146569f, -0.17374897f, 0.24284112f, 0.14926885f, 0.15537116f, 0.01963358f, 0.06397432f, 0.10050262f, 
    0.00288280f, 0.01475724f, 0.06997328f, 0.03205656f, 0.14586087f, -0.10351649f, 0.01814857f, -0.14349262f, 
    0.12918682f, 0.06710976f, -0.03427396f, -0.02303296f, 0.11696551f, -0.04969743f, 0.05972964f, 0.05263426f, 
    0.36670181f, -0.05952964f, 0.12911303f, 0.09851630f, 0.08211613f, -0.00068484f, -0.01153529f, 0.05161234f, 
    0.11868260f, -0.03073014f, 0.09313951f, 0.02081553f, -0.04505481f, 0.00729792f, -0.00732799f, 0.06255415f, 
    -0.08940525f, 0.00000196f, -0.02812679f, 0.09179429f, -0.08495438f, 0.00725000f, 0.02982844f, 0.05299088f, 
    0.18464032f, 0.08804113f, -0.06322642f, -0.15005773f, 0.07057779f, 0.01214651f, 0.09744711f, -0.05069381f, 
    0.04246623f, -0.04582509f, 0.05708925f, -0.09085884f, 0.04793510f, -0.26950434f, -0.10396412f, 0.35917342f, 
    -0.01927778f, -0.00685181f, 0.13550010f, 0.11556012f, 0.15388764f, 0.09560363f, -0.10866660f, 0.03116014f, 
    0.25774556f, -0.20662025f, 0.16546638f, 0.02642621f, 0.13061692f, 0.18427821f, -0.01503064f, -0.02103647f, 
    0.06695669f, 0.00793070f, 0.07039761f, -0.23114525f, -0.24673246f, 0.00773138f, -0.14704779f, 0.00275769f, 
    0.04521814f, -0.03313818f, 0.00044804f, 0.00531055f, 0.06936518f, 0.03040194f, 0.04542798f, 0.10822885f, 
    0.08138466f, -0.11518623f, 0.15956242f, -0.08654387f, 0.14070976f, -0.08664791f, -0.19713402f, 0.08693632f, 
    -0.11716077f, 0.07564190f, -0.15841268f, 0.03041682f, -0.12546447f, 0.08906002f, -0.40849081f, 0.31281728f, 
    -0.03061367f, 0.13961005f, -0.06835986f, 0.08381999f, -0.02802118f, 0.03656392f, 0.02882255f, 0.09605973f, 
    0.10339605f, 0.04089367f, 0.31230557f, 0.09402131f, 0.07426471f, -0.14309874f, -0.05878462f, -0.11177284f, 
    -0.01639775f, 0.06885191f, -0.02773419f, -0.08836965f, 0.11022618f, -0.05727297f, 0.15950420f, -0.01980981f, 
    -0.00475105f, -0.03506772f, 0.24212840f, 0.14307278f, -0.00805178f, 0.02206293f, -0.12825200f, -0.12045562f, 
    0.43257189f, -0.04378674f, 0.09710370f, -0.00158662f, 0.00922438f, -0.19867523f, 0.13065562f, -0.00186978f, 
    0.00694981f, -0.01121435f, -0.09001861f, 0.04629769f, -0.42568475f, 0.24401018f, 0.14291842f, 0.20688301f, 
    -0.06949891f, -0.06622082f, -0.07108303f, -0.15931173f, -0.10213637f, -0.00405552f, -0.25702599f, -0.13815130f, 
    0.16633232f, 0.05941275f, 0.03087774f, 0.05314445f, -0.02697740f, -0.09479064f, -0.00024541f, 0.04646331f, 
    0.06099042f, 0.02132051f, -0.12775609f, 0.07521798f, -0.20762233f, 0.24499992f, 0.43517417f, 0.04574628f, 
    -0.08966967f, -0.07452459f, 0.03253786f, 0.09736451f, -0.07735656f, 0.07481634f, -0.15032455f, -0.07488032f, 
    -0.05605563f, -0.03025370f, -0.07299673f, 0.10716142f, 0.02731026f, -0.01083248f, -0.03405463f, 0.07267553f, 
    -0.01091156f, 0.01920704f, 0.02230798f, 0.03462917f, 0.21661496f, 0.34721673f, 0.11210165f, -0.05720787f, 
    -0.09260754f, 0.06646443f, 0.03289398f, -0.06298371f, 0.00204534f, 0.03526757f, 0.23386779f, 0.04087644f, 
    -0.19421950f, 0.13649796f, 0.26152933f, 0.04213971f, -0.05954616f, 0.05502017f, 0.01301172f, 0.03815414f, 
    -0.01031099f, 0.00753379f, -0.04434483f, 0.01867549f, 0.08019690f, 0.03944757f, -0.01116446f, 0.08797342f, 
    -0.10741907f, 0.01183805f, 0.07404504f, 0.03347195f, 0.03519990f, -0.02467753f, 0.10736141f, 0.03942121f, 
    0.00930482f, 0.02175079f, 0.15951003f, 0.06739447f, -0.06923637f, -0.02393825f, 0.04877346f, 0.09467193f, 
    -0.00887702f, -0.06929187f, -0.09912071f, -0.01059099f, -0.06691626f, -0.18168449f, 0.02993350f, 0.16986400f, 
    -0.07904415f, 0.06075045f, 0.08566019f, 0.02485349f, -0.04922383f, 0.00107411f, 0.06593493f, 0.09090140f, 
    -0.14984125f, 0.10749476f, -0.09510569f, -0.00909962f, -0.02673710f, 0.05181401f, -0.00836346f, -0.10701056f, 
    0.08099312f, -0.09473282f, -0.06561542f, -0.00775787f, 0.09777006f, 0.13591065f, -0.02217786f, 0.20117159f, 
    0.09783697f, -0.06962138f, 0.23028265f, -0.14766447f, -0.08487498f, 0.08112431f, 0.05247584f, 0.07739315f, 
    -0.29684222f, 0.00888580f, 0.07222141f, -0.14989601f, -0.09512419f, 0.06617105f, -0.05307563f, -0.05351780f, 
    0.08388729f, -0.02250449f, 0.07149166f, -0.01279540f, 0.26925436f, 0.08308040f, 0.18765712f, 0.08048658f, 
    -0.05539672f, -0.02714344f, -0.00544925f, 0.05489424f, 0.11726614f, -0.02716618f, 0.01460323f, 0.07091452f, 
    0.52262670f, -0.19034582f, -0.09040873f, -0.05096881f, 0.00916808f, -0.14029950f, -0.01953606f, 0.01734337f, 
    0.06767155f, 0.18144247f, -0.01567651f, 0.11699723f, -0.05434861f, -0.23726282f, 0.29277366f, 0.11466908f, 
    0.14079304f, 0.05598748f, 0.10927901f, 0.12400564f, 0.11122245f, -0.10451876f, 0.08863840f, 0.06552944f, 
    0.13982613f, -0.03252210f, 0.05026802f, 0.19089073f, -0.08147942f, -0.06576858f, -0.00455410f, 0.06006500f, 
    -0.07170512f, -0.00254015f, -0.00991112f, -0.01237977f, 0.05140596f, -0.13523899f, 0.00812445f, -0.22195877f, 
    0.05925810f, -0.04648723f, -0.03958829f, 0.16961150f, 0.12788680f, -0.12742199f, 0.07377139f, 0.05185358f, 
    -0.00854676f, 0.34390360f, 0.08237055f, -0.10072380f, -0.17071636f, -0.03545507f, -0.03169017f, 0.01752695f, 
    -0.03877639f, -0.00686197f, 0.03360375f, -0.01473594f, 0.04161155f, -0.04268918f, 0.02953847f, -0.08719504f, 
    0.08423474f, -0.07679690f, -0.04472350f, 0.01286174f, -0.17812270f, -0.03935674f, 0.06036862f, 0.02817215f, 
    0.00551135f, -0.33644307f, -0.03656702f, -0.20215364f, 0.12023173f, 0.09835690f, -0.04577063f, -0.06627669f, 
    0.05723186f, 0.14506710f, -0.06097522f, 0.02541971f, 0.10887545f, 0.07397781f, 0.25515458f, -0.14619417f, 
    -0.07361355f, 0.03988795f, -0.05635970f, 0.12691218f, 0.04212632f, -0.01674573f, -0.04647975f, -0.06487689f, 
    -0.16995814f, -0.02144476f, -0.20278601f, -0.22237283f, 0.19932425f, -0.16171129f, -0.05722113f, -0.22323948f, 
    -0.07682280f, -0.01773963f, -0.05719488f, 0.00902033f, 0.20755339f, 0.10875072f, -0.01562813f, -0.26011050f, 
    -0.03126375f, -0.04220745f, -0.04859398f, -0.04414820f, -0.08472321f, 0.02079220f, -0.01916537f, -0.02780200f, 
    0.30490455f, 0.06254070f, 0.07524604f, -0.05451779f, 0.05360394f, -0.08475494f, 0.08924245f, -0.07078582f, 
    0.02258382f, -0.04980639f, -0.04936507f, 0.00019715f, -0.28195688f, 0.05540793f, -0.28243175f, -0.10164503f, 
    -0.03020074f, 0.03051898f, 0.05223944f, 0.04358060f, -0.08426708f, -0.15669833f, -0.11331286f, -0.02873309f, 
    0.03931095f, -0.13264263f, 0.09642740f, -0.04496955f, -0.01386083f, 0.10791498f, 0.10506751f, 0.03917775f, 
    0.14647052f, 0.01843224f, 0.06898785f, 0.06269631f, -0.04163803f, -0.10073324f, 0.08261183f, -0.02810867f, 
    -0.04997792f, -0.17506127f, 0.18176946f, 0.00074620f, -0.02466395f, -0.16796575f, 0.07056081f, 0.06292904f, 
    0.10949013f, 0.15793784f, -0.02697054f, -0.04439510f, -0.05477209f, -0.03741053f, -0.00074007f, 0.16288774f, 
    0.03827459f, 0.11666456f, 0.07996942f, -0.16582744f, 0.03228823f, 0.25865698f, 0.04097211f, 0.04982896f, 
    0.02765288f, -0.06275504f, -0.01372057f, 0.00263068f, -0.10096585f, 0.08030311f, -0.06907920f, -0.00723222f, 
    -0.12786980f, -0.32426110f, 0.22472483f, 0.00598552f, 0.17003474f, -0.04246466f, -0.01739306f, 0.05470428f, 
    -0.03010176f, 0.00390679f, -0.02913538f, 0.10070506f, -0.27681810f, 0.41274819f, -0.02555378f, 0.15983813f, 
    -0.08082803f, 0.03896853f, -0.00442549f, -0.12783869f, 0.13031773f, 0.04053211f, -0.06205077f, 0.08035153f, 
    0.24133463f, 0.07560240f, -0.00035325f, -0.10078856f, 0.05267173f, 0.00640298f, 0.01615627f, 0.00269015f, 
    0.08107639f, 0.06380327f, -0.06809714f, 0.03174628f, -0.38699627f, -0.13948682f, -0.10984712f, -0.09094092f, 
    0.01458346f, -0.00761028f, 0.03136865f, 0.04335613f, -0.07673524f, -0.08929492f, 0.02772653f, 0.05211905f, 
    0.18726987f, 0.18326828f, 0.26264042f, -0.03736349f, 0.00857782f, -0.06259063f, 0.02181618f, 0.13029878f, 
    0.03464931f, -0.04009451f, 0.09696877f, -0.09347098f, -0.27239481f, 0.21086934f, 0.19205578f, -0.00790515f, 
    -0.11389283f, -0.05416286f, 0.01311303f, 0.02408345f, -0.10798603f, -0.11841493f, 0.09174979f, -0.06571639f, 
    0.46304622f, -0.43403047f, 0.26988891f, -0.01804254f, 0.03587522f, 0.13504457f, 0.07765899f, 0.02661446f, 
    0.03628754f, 0.15664667f, 0.10055414f, 0.00294201f, -0.06176396f, -0.03017117f, 0.32487145f, -0.05460993f, 
    -0.15148337f, -0.01838689f, -0.04833376f, 0.06288447f, -0.01402832f, 0.16541967f, 0.04275237f, 0.02473910f, 
    -0.15080756f, 0.01169216f, -0.15805216f, -0.20895022f, 0.00154608f, 0.08854498f, 0.02342569f, 0.01901886f, 
    0.03606602f, -0.03919305f, 0.04725917f, -0.05396171f, 0.13957800f, -0.06306163f, -0.06966397f, -0.06516478f, 
    -0.09759647f, 0.04754759f, 0.00878133f, 0.01496916f, -0.00228418f, 0.03993722f, -0.04044402f, 0.01032053f, 
    0.03915878f, 0.01550571f, 0.37847176f, -0.16865070f, 0.00608496f, -0.05183956f, 0.14445201f, -0.08580988f, 
    0.02972485f, 0.04076737f, 0.07454643f, -0.14996591f, 0.00691066f, -0.12577543f, 0.01032152f, -0.03184429f, 
    0.12031447f, 0.18725234f, -0.01986776f, 0.17420062f, 0.08095358f, 0.00901336f, -0.07100880f, 0.22297472f, 
    0.10950669f, 0.34152055f, -0.20009677f, -0.11561090f, -0.00651324f, 0.06484706f, -0.06277309f, 0.07391029f, 
    0.05185318f, 0.00427196f, 0.09719761f, -0.00886144f, -0.28624037f, 0.22123289f, -0.02306462f, 0.05044354f, 
    -0.13748829f, -0.02590466f, 0.12905060f, 0.01733441f, -0.11201251f, 0.00386336f, 0.06384693f, -0.04623669f, 
    0.08073461f, -0.17463464f, 0.09016776f, 0.01729472f, 0.07013097f, 0.09489008f, -0.02546726f, 0.10953895f, 
    0.06085199f, -0.21577798f, -0.00896153f, 0.34585288f, 0.00852726f, -0.01912417f, 0.00146611f, 0.21595025f, 
    -0.08848214f, 0.08180596f, -0.01983313f, 0.10154410f, 0.00067076f, -0.04792253f, -0.00389992f, 0.03102564f, 
    -0.18066584f, -0.17185247f, -0.03415804f, 0.03567907f, -0.01625393f, 0.01427701f, -0.05841061f, -0.08763047f, 
    -0.16040136f, -0.02758827f, -0.03241928f, 0.04621465f, -0.00459401f, -0.01025408f, 0.14369233f, -0.00659733f, 
    -0.07639215f, -0.20537764f, 0.06405787f, 0.00037688f, -0.09041335f, -0.01001362f, 0.01288905f, 0.03520574f, 
    -0.01258562f, -0.02075703f, -0.09971621f, 0.09226133f, -0.10496952f, 0.00928410f, 0.15953353f, 0.01405471f, 
    0.02095171f, -0.04377734f, 0.11804891f, -0.01660855f, -0.12129284f, 0.13669595f, 0.06793457f, 0.08619550f, 
    -0.02323944f, 0.07947203f, 0.15133379f, 0.02232820f, 0.08812007f, 0.05240574f, 0.07994603f, 0.16222322f, 
    0.14476193f, 0.04446223f, -0.14906938f, -0.12787855f, -0.04263790f, -0.06391902f, 0.17697577f, -0.00589585f, 
    -0.02008850f, -0.01168883f, -0.03368198f, 0.00056839f, 0.25131255f, -0.12235199f, 0.18012825f, 0.11207245f, 
    0.07640953f, 0.21045056f, 0.03237499f, 0.06010292f, 0.16174059f, 0.03970257f, 0.04542059f, -0.08323251f, 
    -0.08111478f, 0.17303438f, -0.12466289f, -0.24947166f, 0.06066147f, 0.14655493f, -0.02129312f, -0.07663208f, 
    0.20016792f, -0.02511964f, -0.08787306f, -0.04293161f, -0.20205569f, -0.18300071f, 0.08375516f, -0.17018481f, 
    -0.00053511f, 0.05675878f, 0.07020976f, 0.01280819f, -0.10656607f, 0.05612274f, -0.00028026f, -0.06633321f, 
    -0.25040796f, 0.15563478f, -0.02615101f, 0.00825181f, -0.08306493f, 0.14894599f, 0.26635638f, -0.26395684f, 
    -0.10088672f, 0.12849313f, 0.01361470f, 0.05988220f, 0.33410224f, 0.06320362f, 0.03309910f, -0.04699172f, 
    0.01818632f, -0.04085479f, -0.00390002f, 0.03037342f, 0.07737996f, -0.05077915f, -0.05642205f, -0.02647832f, 
    -0.09111036f, 0.01036671f, 0.16861498f, -0.00964419f, -0.12114375f, 0.02898838f, 0.00006675f, 0.00225570f, 
    0.06385805f, 0.05127412f, -0.03627275f, 0.00097223f, 0.19092333f, 0.43903315f, -0.10119360f, -0.08416210f, 
    -0.01090988f, 0.12842211f, 0.01440762f, -0.03721243f, 0.06114245f, 0.00285376f, 0.00676169f, 0.04138405f, 
    -0.14339477f, 0.36064065f, -0.09995658f, 0.14894137f, -0.09918077f, -0.00735282f, 0.10007774f, 0.03185658f, 
    -0.03275901f, -0.04911046f, -0.00133344f, 0.03469769f, 0.01671794f, 0.07089300f, 0.15491401f, 0.42810240f, 
    -0.08012287f, 0.05465931f, 0.02247917f, 0.07163569f, 0.08163289f, 0.06956366f, 0.20486654f, 0.10256897f, 
    -0.19284728f, -0.04000346f, 0.03915494f, -0.03237467f, -0.02184017f, 0.14338326f, 0.19273868f, -0.06460438f, 
    -0.06890447f, -0.09546944f, 0.10665569f, 0.04971891f, 0.06545286f, -0.01847921f, 0.23126201f, -0.07163349f, 
    0.00241888f, -0.03178034f, 0.00592800f, -0.01288904f, 0.03610533f, 0.08752175f, 0.04308151f, 0.18544419f, 
    -0.03327014f, -0.05047378f, -0.14111362f, -0.38128430f, -0.08321290f, 0.12589401f, 0.00914129f, -0.00688704f, 
    -0.03108213f, -0.07586611f, -0.05391107f, 0.04827192f, -0.17024744f, 0.16615199f, -0.11228929f, 0.09696206f, 
    -0.07909298f, 0.10576086f, -0.08510693f, -0.14649916f, -0.02799080f, 0.06476463f, 0.03700620f, 0.02296320f, 
    -0.02050572f, -0.03140456f, 0.00196030f, -0.01769703f, -0.02712653f, -0.03175975f, -0.00436533f, -0.01786526f, 
    -0.02176023f, 0.01611547f, 0.00003318f, 0.00255460f, -0.00743915f, 0.01915029f, 0.01048613f, 0.00521047f, 
    -0.03641881f, -0.02919075f, 0.00793893f, -0.00768271f, 0.01339871f, 0.02482076f, 0.00753050f, 0.04085148f, 
    -0.00504749f, 0.02064957f, -0.03271258f, -0.01740395f, -0.02376405f, 0.00766717f, -0.03648710f, 0.00811794f, 
    -0.03084223f, 0.00403681f, -0.00141621f, 0.02366331f, -0.00830777f, -0.03682916f, 0.02164627f, 0.02070224f, 
    -0.01620892f, 0.03073514f, -0.00363569f, 0.01562403f, -0.01914135f, 0.01838893f, -0.03883465f, -0.02933282f, 
    -0.01515013f, -0.02507442f, 0.03936453f, -0.02053946f, 0.02968237f, -0.01724963f, -0.01745623f, -0.01007180f, 
    0.02707223f, 0.01403861f, -0.03414023f, 0.01933602f, -0.03141598f, -0.02346190f, 0.02774305f, 0.00522714f, 
    -0.03485163f, 0.00931641f, 0.00141076f, -0.03663502f, 0.03517678f, 0.02688794f, -0.01231517f, 0.01350535f, 
    0.02138854f, -0.01347823f, 0.01510693f, 0.01953134f, 0.02321952f, -0.01652271f, -0.00929650f, -0.02691345f, 
    -0.00897908f, 0.00891102f, -0.03559152f, 0.03044334f, 0.00517239f, -0.00481694f, -0.04280918f, -0.00053314f, 
    0.02363699f, 0.00424408f, 0.02425058f, -0.01389713f, -0.02495224f, 0.00039995f, 0.01685306f, -0.00484396f, 
    -0.02002465f, -0.02801550f, -0.01927505f, 0.01113017f, 0.00048141f, 0.01114895f, 0.00170697f, -0.04091866f, 
    -0.03504912f, 0.02844843f, 0.02312629f, -0.00386793f, -0.03634703f, 0.02527393f, -0.03513720f, 0.02346200f, 
    0.02028061f, -0.01878597f, -0.02067499f, 0.00973354f, 0.00950916f, 0.02065526f, 0.00941591f, -0.03133372f, 
    0.01213502f, -0.01006819f, 0.01627977f, -0.01953505f, -0.02218580f, -0.02980487f, -0.02525768f, 0.01471822f, 
    0.02406023f, -0.02747504f, 0.00353221f, 0.00172447f, -0.00582593f, 0.01611254f, 0.02361164f, -0.02412666f, 
    -0.02980761f, -0.02623961f, 0.02267522f, 0.02215012f, -0.01359134f, 0.02645136f, -0.02382460f, 0.02656969f, 
    0.00864455f, -0.02377738f, 0.02056129f, -0.00073262f, 0.00982316f, 0.00096645f, 0.01042328f, -0.01105543f, 
    -0.01390056f, -0.03772420f, 0.02842545f, 0.02020017f, -0.01526688f, 0.01377080f, -0.01318572f, -0.02414551f, 
    -0.01029864f, -0.03273793f, -0.03453549f, -0.01971360f, -0.00479920f, -0.00718527f, 0.02916911f, 0.00443965f, 
    -0.02273428f, -0.02691205f, -0.01930769f, -0.02965587f, -0.00817286f, -0.01301627f, -0.00186437f, 0.00231933f, 
    0.03351917f, 0.00389929f, 0.01118093f, 0.01215911f, -0.01995333f, 0.03128242f, -0.00819989f, 0.01072304f, 
    0.01505284f, 0.00069704f, -0.02606006f, 0.00593680f, -0.01217708f, 0.00830624f, 0.01692562f, 0.01007638f, 
    -0.03845484f, -0.01048406f, 0.01742615f, 0.00533207f, 0.01006452f, -0.02647685f, -0.00482176f, 0.02662339f, 
    0.00226606f, 0.00471896f, -0.03201180f, -0.01539508f, -0.02884893f, 0.01731734f, -0.01110855f, -0.02039752f, 
    -0.03401324f, -0.01859727f, -0.02868008f, 0.01266678f, 0.02941314f, 0.00305760f, 0.02152836f, -0.02379110f, 
    0.01383869f, 0.00884383f, 0.03067936f, -0.02435598f, -0.01492735f, -0.04084746f, 0.00312262f, -0.03052278f, 
    0.02719908f, 0.00328934f, 0.02646180f, -0.02456074f, -0.00804357f, -0.01716640f, -0.01040424f, -0.02472322f, 
    -0.00624841f, 0.02683987f, 0.01491316f, 0.00380081f, -0.01453797f, 0.00597645f, -0.02356968f, -0.02645105f, 
    0.02542888f, 0.02800724f, -0.02963111f, -0.03268068f, -0.02666469f, -0.00957124f, 0.02417359f, 0.01745174f, 
    0.00974527f, -0.01273739f, 0.01409106f, -0.00769303f, 0.01947931f, -0.03106129f, 0.01104469f, 0.01408440f, 
    -0.01725185f, -0.02742673f, 0.00118317f, -0.00432785f, -0.02220047f, -0.00531518f, 0.00106390f, -0.00456896f, 
    -0.01952476f, 0.01226926f, -0.03465451f, -0.01901030f, 0.02170031f, -0.00248708f, 0.02127817f, -0.00136197f, 
    -0.03494510f, -0.03672001f, -0.02420588f, -0.03519177f, 0.00668643f, 0.01674729f, 0.02924088f, -0.01462843f, 
    -0.03425601f, 0.01605429f, -0.01339160f, -0.00316811f, -0.01852377f, 0.00021319f, 0.02062283f, 0.01911179f, 
    -0.02304736f, -0.01090050f, -0.00946683f, 0.04055365f, -0.00124925f, 0.01207944f, 0.04017208f, 0.01649838f, 
    0.00647625f, -0.03834788f, -0.00534188f, 0.01968281f, 0.03216543f, 0.02284922f, 0.02208031f, -0.00653426f, 
    -0.01616515f, 0.02584534f, -0.02743459f, 0.01466405f, -0.03871856f, 0.01049354f, -0.02849743f, -0.01682164f, 
    -0.01116063f, -0.02942299f, -0.03523720f, -0.03597914f, 0.00435608f, 0.00974899f, -0.03116214f, 0.01062015f, 
    -0.02569370f, -0.01477084f, -0.01638722f, 0.01557081f, 0.02127383f, -0.03744605f, -0.01986603f, 0.00973885f, 
    0.01680434f, 0.00063398f, -0.03725994f, 0.00792373f, 0.01974129f, 0.03891492f, 0.02081866f, -0.01976218f, 
    -0.03202429f, 0.00047788f, 0.00246536f, -0.03577661f, 0.01826407f, -0.00917325f, -0.02142691f, -0.00926364f, 
    -0.00621525f, 0.01901408f, 0.01075525f, -0.01371260f, -0.03508926f, -0.00615672f, -0.01004658f, -0.04008302f, 
    -0.01680624f, -0.02328538f, -0.02119655f, -0.01363956f, 0.02311319f, 0.00557227f, -0.03540405f, -0.02275700f, 
    -0.01520201f, 0.02427254f, -0.02136648f, -0.02281440f, 0.01527023f, 0.00156951f, 0.01885965f, 0.01223925f, 
    -0.01109045f, 0.00493256f, 0.02716803f, -0.02809760f, -0.03594613f, 0.00044705f, -0.01440146f, 0.00692870f, 
    -0.00794517f, 0.01971110f, 0.03075293f, 0.03283255f, 0.00689381f, 0.00866734f, 0.04115984f, 0.03152214f, 
    0.01990731f, 0.01821752f, 0.00977275f, -0.03749350f, -0.01080850f, -0.03680762f, -0.01089557f, -0.02705237f, 
    0.01961547f, -0.02278744f, -0.02761771f, -0.04157120f, -0.04146510f, -0.03238581f, 0.00365984f, 0.02466028f, 
    -0.01453553f, -0.00259183f, -0.02031464f, 0.03725093f, -0.00853560f, 0.00421767f, 0.01328279f, -0.01340883f, 
    0.00389282f, -0.01496249f, -0.01939031f, 0.01575979f, -0.02411652f, -0.02140416f, -0.01167041f, 0.02417610f, 
    0.03805844f, -0.02594594f, 0.01141388f, -0.00491339f, -0.02152303f, 0.02493119f, -0.01534306f, -0.04301517f, 
    -0.04399095f, -0.02977972f, -0.02816193f, 0.01901242f, -0.01493840f, 0.01547374f, -0.00777133f, -0.01024627f, 
    -0.00678175f, -0.01988304f, 0.02323035f, -0.03305841f, 0.01702518f, -0.03774613f, 0.02876769f, 0.00719212f, 
    0.02460944f, -0.03829982f, 0.01464468f, -0.03204191f, 0.01076786f, 0.01019506f, 0.01075495f, 0.02185168f, 
    0.01348961f, -0.00793544f, 0.01847725f, -0.03842566f, -0.01692051f, 0.00801970f, 0.01333202f, 0.02082439f, 
    -0.01822735f, -0.01185625f, 0.01360567f, 0.02910397f, 0.01027442f, -0.04119161f, -0.03261222f, -0.04059631f, 
    -0.01357618f, -0.03742308f, -0.02878339f, -0.03370562f, -0.02466787f, -0.00043846f, -0.02280886f, -0.03644425f, 
    -0.04092723f, -0.03621706f, -0.01083283f, 0.01272939f, 0.01343495f, 0.00290725f, -0.02193377f, -0.04084128f, 
    0.01628515f, -0.01838129f, -0.03862211f, -0.02053711f, 0.02231823f, 0.00345428f, -0.00115961f, 0.00158521f, 
    0.00043801f, 0.00454676f, 0.00061910f, 0.00487970f, -0.02432555f, 0.02305651f, -0.01289073f, -0.00155156f, 
    -0.01568283f, -0.00210671f, -0.01776533f, 0.02152364f, 0.01963746f, 0.00813274f, 0.02428635f, -0.02428319f, 
    -0.00531381f, -0.00861963f, -0.01994728f, -0.00806528f, 0.01707245f, -0.02393124f, -0.03557651f, 0.00828367f, 
    -0.03811186f, 0.01731855f, 0.01030377f, -0.03925911f, 0.00161722f, 0.02166226f, -0.01863594f, 0.02546658f, 
    0.00163676f, -0.02524007f, 0.00559465f, -0.02394211f, -0.02397677f, 0.02687810f, -0.00315439f, -0.02899131f, 
    -0.01945914f, -0.04219870f, -0.02194854f, -0.02515271f, -0.01629092f, -0.02418751f, -0.02444654f, 0.02588598f, 
    0.02119667f, -0.00250656f, 0.02008022f, -0.00583545f, -0.00543834f, 0.01348759f, 0.00204340f, -0.00386747f, 
    -0.01031984f, -0.00245133f, -0.00700327f, 0.03259713f, -0.02527245f, -0.02368520f, -0.01539447f, 0.02046564f, 
    0.00618208f, 0.01113827f, 0.00174253f, -0.03805161f, -0.02410674f, -0.03000521f, -0.01424215f, -0.01957370f, 
    -0.03350736f, 0.00747115f, -0.01670598f, 0.02463127f, -0.01031635f, -0.00351709f, -0.01828757f, -0.03803377f, 
    -0.00710079f, -0.01263835f, 0.02992949f, 0.00719774f, 0.02661216f, 0.00078273f, 0.01346808f, 0.00585726f, 
    -0.00000515f, 0.01025256f, -0.01776500f, -0.03518360f, 0.02626972f, -0.03431932f, -0.03842968f, 0.00161316f, 
    -0.02539232f, -0.03741457f, 0.00701457f, 0.01068983f, -0.02857531f, 0.02127349f, -0.03522158f, -0.00325176f, 
    0.02804526f, 0.00347199f, -0.04155071f, 0.02239177f, -0.02149943f, -0.00722224f, -0.02140075f, 0.00323747f, 
    -0.01183356f, 0.02057105f, 0.00222777f, 0.02767612f, 0.01764175f, -0.03661966f, -0.02141559f, -0.03146088f, 
    -0.00456202f, -0.03148978f, 0.02446652f, 0.00083634f, -0.02841105f, -0.01159601f, 0.02767251f, -0.00832968f, 
    0.02317691f, 0.02002626f, -0.00695619f, -0.00884820f, 0.00000980f, 0.03563753f, -0.00697245f, 0.01086876f, 
    0.01291126f, -0.03146166f, 0.02639980f, -0.00080577f, 0.00223748f, 0.02316034f, -0.03244581f, 0.01723274f, 
    -0.02433926f, 0.01109010f, -0.02660442f, -0.01216795f, -0.03502082f, 0.01877593f, 0.01670466f, 0.02421666f, 
    -0.00647076f, 0.00804996f, 0.00808690f, 0.02508524f, -0.00848586f, -0.02085051f, -0.01743656f, -0.00285121f, 
    -0.02688992f, -0.00169330f, -0.00722966f, 0.00120390f, 0.01499947f, 0.00680184f, -0.01995089f, 0.01479443f, 
    -0.02795128f, -0.04127192f, 0.02417540f, -0.00766367f, -0.00341606f, 0.00539171f, -0.01107649f, 0.01609259f, 
    -0.01322453f, 0.00334517f, -0.00234955f, -0.00491018f, -0.03683037f, -0.01003840f, 0.00043911f, -0.04169201f, 
    -0.01342086f, 0.01059665f, 0.00595198f, -0.01492916f, -0.03418339f, -0.01581621f, 0.01230598f, 0.02326739f, 
    0.00263938f, -0.03885989f, -0.00969242f, -0.03491277f, 0.02369076f, -0.03121436f, 0.01650234f, -0.02450330f, 
    -0.00573831f, -0.02990474f, -0.04230999f, 0.01678394f, -0.02667448f, 0.03258846f, -0.00691757f, 0.02112675f, 
    -0.02235281f, 0.00991868f, -0.00077235f, 0.02449139f, -0.03140296f, 0.01476720f, -0.01533520f, 0.02596502f, 
    0.01758371f, -0.01627284f, -0.03096031f, -0.03183986f, -0.00386287f, -0.00999816f, 0.00420173f, -0.01377155f, 
    0.00588204f, 0.00343709f, 0.00937370f, 0.02725894f, 0.01167971f, -0.01915201f, 0.01799266f, 0.00624915f, 
    0.00387108f, 0.02221816f, -0.01931261f, 0.01431774f, 0.00618372f, 0.02504756f, -0.02972428f, 0.01277150f, 
    -0.01532827f, 0.01550804f, -0.02029634f, -0.04151713f, -0.01839783f, -0.00779018f, 0.01090650f, 0.02654585f, 
    -0.02634086f, -0.03192580f, 0.01842808f, -0.02943141f, 0.02410579f, -0.03399377f, -0.01356736f, 0.00429154f, 
    0.03966391f, -0.01461854f, 0.02817391f, 0.03829136f, -0.01647858f, 0.00967921f, -0.02947219f, -0.03557513f, 
    -0.00998302f, 0.02175908f, -0.01708438f, 0.00698676f, -0.00033017f, -0.00528432f, 0.02128783f, -0.00479452f, 
    -0.03350862f, -0.01758652f, -0.00320745f, -0.00477302f, -0.01534077f, -0.03341256f, -0.02918254f, 0.02671392f, 
    -0.34928003f, 0.07772212f, 0.00050929f, 0.06889534f, 0.04919814f, -0.00027895f, -0.00996060f, -0.02379510f, 
    -0.05407171f, -0.11828417f, 0.24418248f, 0.11746570f, 0.24012893f, -0.22355415f, -0.17627452f, -0.11256766f, 
    0.12668262f, 0.18184750f, 0.12137883f, 0.18720511f, -0.14897564f, -0.08231418f, 0.17752771f, -0.10903002f, 
    -0.24602637f, 0.00825810f, -0.09820844f, -0.06238885f, 0.05769996f, 0.05054632f, -0.07910116f, -0.16286710f, 
    0.06585583f, -0.04152873f, 0.16624545f, -0.04648221f, -0.00517213f, -0.09386828f, -0.06975717f, -0.05115775f, 
    -0.02312756f, 0.00079953f, 0.07408359f, 0.23213248f, 0.01684887f, 0.03456063f, 0.17743868f, 0.09382986f, 
    0.10292534f, 0.16685802f, -0.00595617f, -0.30776456f, 0.03390279f, 0.17090656f, 0.04947682f, -0.07535725f, 
    -0.00730795f, -0.04046058f, 0.00262546f, 0.07844125f, -0.04128531f, 0.26332706f, -0.11365540f, -0.03224024f, 
    -0.02959532f, -0.13907138f, -0.15028399f, 0.09413688f, 0.08936133f, 0.04545999f, -0.07801979f, -0.02474854f, 
    0.24962705f, -0.01906760f, -0.36613810f, -0.09231694f, -0.02604528f, 0.10942134f, 0.02438769f, 0.03130713f, 
    -0.03902519f, -0.11655783f, 0.02532688f, 0.09153264f, -0.14630635f, -0.12457889f, 0.19420014f, 0.16313811f, 
    -0.04402029f, -0.09757297f, -0.15324198f, 0.00761815f, -0.06457220f, -0.01526010f, -0.07373179f, 0.16157688f, 
    -0.26287663f, -0.06003306f, 0.17732616f, 0.09153710f, 0.05105506f, 0.06897484f, -0.07601738f, -0.02078795f, 
    0.22734165f, 0.04522273f, -0.01020239f, 0.14087437f, -0.25136036f, 0.04033085f, -0.06309526f, 0.15400648f, 
    -0.13636406f, -0.01124991f, 0.01214944f, 0.03153306f, -0.00216019f, -0.04926953f, 0.04759568f, -0.00362620f, 
    0.33399585f, 0.11830854f, 0.00623718f, -0.08859425f, 0.08324109f, -0.02370895f, 0.09087115f, -0.02684187f, 
    -0.07817851f, 0.04514074f, 0.08157878f, -0.05565155f, 0.05541116f, -0.17681773f, -0.23517357f, -0.20234178f, 
    -0.00026846f, 0.03510443f, -0.02037866f, 0.28226024f, 0.10300216f, -0.05666229f, 0.17014511f, -0.12146694f, 
    0.03913686f, -0.23482420f, -0.31960681f, 0.18614215f, 0.03333530f, 0.08309625f, 0.14178011f, 0.01292666f, 
    -0.14049721f, -0.00865433f, -0.10667959f, -0.12998414f, -0.21367952f, -0.09592009f, -0.03220469f, 0.20138073f, 
    0.02520132f, -0.04527986f, -0.02985733f, -0.07745199f, 0.02327791f, 0.07673628f, 0.14317048f, 0.01973918f, 
    -0.08081317f, -0.15331134f, -0.10990148f, 0.07299910f, -0.11577810f, -0.02657204f, 0.17932662f, -0.00133800f, 
    -0.01112210f, -0.04765470f, 0.01771827f, 0.14656375f, -0.07293394f, 0.18685217f, 0.03167538f, 0.05468779f, 
    0.05820610f, -0.16656035f, -0.00169000f, -0.04216329f, -0.15578653f, 0.05376200f, 0.12416670f, 0.24355985f, 
    -0.20681259f, -0.19245885f, -0.05394071f, 0.01453469f, 0.12014627f, 0.12557928f, 0.13384818f, -0.07401361f, 
    -0.14277588f, -0.10523313f, -0.14630765f, -0.11620279f, 0.30067188f, 0.21775697f, 0.19214545f, -0.19603297f, 
    -0.06042235f, -0.03263970f, 0.06342527f, -0.08390544f, 0.09598462f, 0.22411558f, 0.03666960f, -0.06652202f, 
    -0.04956621f, 0.09103871f, 0.20582792f, 0.06368402f, -0.08784518f, -0.13203381f, -0.20346287f, -0.05217536f, 
    -0.07150961f, 0.02039134f, 0.13585366f, -0.09867053f, 0.00921967f, -0.30813578f, -0.15667269f, 0.06399785f, 
    0.18794991f, 0.19079642f, 0.16309838f, 0.06077334f, -0.01436533f, 0.01307533f, -0.28364465f, -0.05776905f, 
    0.05972317f, -0.13963856f, 0.03203318f, 0.16607547f, 0.13788046f, 0.10579842f, 0.03835044f, -0.06227238f, 
    0.07107294f, 0.12237877f, 0.03927216f, -0.04498948f, -0.18755250f, 0.50818461f, 0.10627687f, -0.18783353f, 
    -0.11521804f, -0.01238323f, -0.07659624f, -0.00737679f, -0.02359688f, 0.21272567f, -0.02644916f, 0.07609425f, 
    0.12469871f, -0.13960099f, -0.11623360f, 0.12270098f, -0.10831976f, -0.00286182f, 0.17808697f, 0.12347596f, 
    -0.11450307f, -0.03918223f, 0.04954496f, 0.09258091f, -0.01057827f, -0.37844652f, -0.25939545f, 0.11832324f, 
    0.20096137f, 0.11325542f, 0.08334953f, -0.02456565f, -0.05450827f, -0.00416172f, 0.02863333f, 0.03896272f, 
    -0.12828815f, -0.07322983f, -0.05483920f, -0.09612665f, -0.09076811f, -0.01682405f, 0.12496383f, 0.03251168f, 
    0.05980404f, 0.04678465f, 0.10526939f, 0.05344953f, 0.21013258f, 0.20429121f, 0.03480546f, -0.31812331f, 
    -0.00065247f, 0.03390736f, 0.07734644f, -0.08878437f, -0.02087033f, 0.03351607f, -0.05338809f, 0.00633274f, 
    0.23393847f, 0.09532657f, -0.37547505f, 0.11915956f, -0.08492536f, -0.08476418f, 0.19353607f, 0.02830234f, 
    -0.07004707f, -0.01788083f, 0.00622490f, -0.07238442f, -0.11787548f, -0.08381120f, -0.17283471f, 0.16577105f, 
    0.06580216f, 0.10423192f, 0.09276792f, 0.16699803f, 0.03156900f, 0.12072121f, -0.01309757f, -0.07534048f, 
    0.08544692f, -0.06814991f, -0.27604043f, -0.02060928f, -0.06237637f, -0.09052134f, -0.03526047f, -0.17288868f, 
    -0.03303476f, -0.09356539f, -0.06612334f, 0.09616772f, -0.02544198f, -0.08774649f, -0.07128632f, 0.03247982f, 
    -0.00512121f, -0.16133481f, -0.11339498f, -0.05905763f, 0.16426532f, 0.09992452f, 0.04123266f, 0.06230336f, 
    -0.13969283f, -0.12152722f, 0.05287736f, -0.04277686f, 0.12536299f, 0.14645325f, -0.05600688f, 0.03524613f, 
    -0.02010821f, -0.03510414f, -0.10265017f, 0.08854398f, 0.08719562f, -0.17099863f, 0.05513954f, -0.16900916f, 
    0.13315915f, -0.03414855f, -0.01388473f, 0.17694010f, 0.02160735f, 0.04581379f, -0.00101322f, -0.02888105f, 
    0.09797607f, 0.09700014f, -0.12987658f, 0.00027691f, -0.05867252f, -0.05306655f, 0.03701868f, 0.10445256f, 
    0.02553771f, 0.06968756f, -0.10942195f, -0.02222584f, 0.32009611f, 0.03569130f, 0.00326284f, 0.01879587f, 
    0.08334744f, -0.03204088f, -0.05527194f, 0.06229066f, -0.02979346f, 0.03867228f, -0.04336917f, 0.05704100f, 
    0.00536234f, 0.15167511f, -0.27367142f, -0.03724489f, 0.04286940f, 0.09454066f, -0.16279814f, -0.05842256f, 
    -0.05885386f, 0.10286744f, 0.07920515f, 0.00184357f, -0.13326731f, -0.02951069f, 0.12975179f, 0.17895080f, 
    -0.04759784f, -0.04920533f, 0.07211744f, -0.07022278f, 0.04303457f, 0.02707731f, 0.12342384f, -0.05010932f, 
    -0.19054130f, 0.07461333f, 0.03531881f, 0.03466919f, 0.20324993f, -0.01194168f, -0.18811649f, -0.06673840f, 
    0.06631461f, 0.02296469f, 0.06439172f, 0.03639209f, -0.34521785f, 0.28610441f, 0.11820606f, -0.01259243f, 
    -0.04887013f, -0.14250144f, -0.08555488f, 0.00777696f, -0.07381720f, 0.00953882f, -0.02410952f, -0.12916079f, 
    0.11818448f, -0.08111344f, -0.24413924f, -0.01950101f, 0.05817416f, 0.24046454f, 0.17508937f, 0.07968897f, 
    -0.02013409f, 0.01099214f, -0.01834214f, 0.06810073f, -0.02583339f, -0.19013333f, -0.24795556f, 0.10276392f, 
    0.07026518f, -0.02316160f, 0.03373569f, -0.20964983f, -0.04952069f, 0.10984646f, 0.03978660f, -0.02628851f, 
    0.16628081f, -0.11861791f, -0.35516617f, -0.14713942f, 0.07126058f, 0.14711763f, -0.15689485f, 0.08032973f, 
    0.05702625f, 0.08367120f, 0.01007974f, 0.04355349f, 0.16983028f, 0.20552137f, -0.37576303f, 0.12304886f, 
    -0.16609979f, -0.05201210f, 0.01703097f, 0.14715862f, 0.01571523f, -0.01529631f, 0.13967332f, -0.09693374f, 
    0.00413025f, -0.05586280f, -0.03843043f, 0.08240583f, -0.00682699f, 0.06809442f, 0.12571502f, -0.04244304f, 
    0.10505180f, -0.09354725f, -0.13814959f, 0.02384713f, 0.11492116f, -0.03669212f, 0.03211867f, -0.09261535f, 
    -0.01379278f, -0.05012591f, -0.05344503f, -0.10562883f, -0.07759867f, -0.11440547f, -0.02155921f, 0.03112458f, 
    -0.09360562f, 0.01243794f, 0.02383535f, 0.12920450f, 0.13197275f, 0.18167073f, -0.10486409f, 0.15703817f, 
    0.00227329f, 0.08076120f, 0.00396336f, -0.04908029f, 0.02077092f, 0.09063550f, -0.04394531f, -0.38323936f, 
    0.07639863f, 0.12603505f, 0.05503286f, -0.15450250f, -0.02562795f, 0.00136637f, 0.09789857f, 0.08256074f, 
    -0.01323665f, 0.11054148f, -0.07597837f, -0.19346115f, -0.10833202f, -0.00622530f, 0.10732326f, 0.02946308f, 
    0.13240407f, -0.09047727f, -0.13943879f, -0.07158476f, 0.05955522f, 0.07075269f, -0.26925623f, -0.11340946f, 
    0.09496540f, 0.05171861f, -0.13458495f, -0.07238989f, -0.07731360f, -0.06474356f, -0.03986342f, 0.00756240f, 
    -0.25516045f, -0.05912210f, -0.03951999f, -0.02086679f, 0.14176612f, 0.08260237f, -0.00872468f, -0.13124543f, 
    -0.00421575f, -0.03722358f, -0.02266436f, 0.01009248f, -0.01795124f, 0.19019677f, -0.11984255f, -0.04667014f, 
    -0.06567881f, 0.01271736f, -0.08829696f, 0.01739786f, 0.05009563f, -0.00585127f, 0.00952725f, 0.06712220f, 
    -0.34481758f, -0.12844226f, -0.15779930f, 0.09920800f, 0.11492307f, 0.07334007f, -0.00606108f, 0.00922479f, 
    -0.03042495f, -0.05761067f, 0.01962815f, 0.01509932f, -0.11409685f, 0.25174752f, 0.12849541f, 0.11282791f, 
    0.15921080f, -0.02676373f, -0.09927613f, 0.03995227f, 0.05998661f, 0.13279571f, -0.10039772f, 0.10862326f, 
    0.05772087f, -0.16088438f, -0.11451366f, 0.10923599f, 0.05516235f, 0.14265443f, 0.17470577f, 0.16469784f, 
    0.00507471f, 0.15023485f, -0.11500470f, -0.05197640f, -0.05851692f, 0.08867936f, 0.00361605f, 0.06542683f, 
    -0.01322336f, 0.06756126f, -0.12939142f, 0.10140949f, 0.16633543f, -0.16161834f, -0.16386765f, 0.10351419f, 
    0.02213405f, -0.40205944f, 0.08616158f, -0.07906933f, 0.08362012f, 0.10846651f, 0.10768346f, 0.17920816f, 
    0.02891168f, -0.01789634f, 0.04668415f, 0.00407270f, -0.06855626f, -0.06360707f, -0.13697748f, 0.24857944f, 
    -0.04339259f, -0.07304633f, 0.03670555f, -0.12395547f, 0.10529135f, 0.06005211f, -0.10509250f, 0.08611689f, 
    -0.02268724f, 0.15956900f, 0.14529620f, -0.08349609f, 0.01418848f, -0.04591510f, 0.08429461f, 0.06964498f, 
    -0.06690356f, -0.09512797f, -0.06208452f, 0.01510196f, 0.11357905f, -0.12955844f, -0.03977708f, 0.10353089f, 
    0.04964791f, -0.12402271f, 0.01563627f, 0.05563328f, 0.06410927f, 0.00030249f, 0.13674071f, -0.13194649f, 
    0.10036734f, -0.07551601f, 0.38053724f, -0.21700940f, -0.02267128f, 0.02212120f, 0.07430395f, -0.13818942f, 
    -0.02589603f, -0.08031239f, 0.24476796f, 0.01294979f, -0.00640887f, 0.07313558f, 0.32363793f, 0.11835580f, 
    -0.01605994f, -0.04302333f, -0.07469526f, 0.05005962f, 0.10660799f, 0.08748612f, 0.05816415f, 0.16306008f, 
    -0.09042630f, -0.01916414f, -0.05421395f, -0.02238799f, -0.11688372f, -0.07029378f, -0.02469527f, 0.04748365f, 
    0.02827416f, -0.02254001f, -0.06954609f, -0.02521155f, -0.15498249f, 0.09843542f, -0.16919583f, -0.05040535f, 
    0.08711485f, -0.10683099f, 0.00506896f, 0.09191244f, 0.14159146f, 0.03598127f, 0.09340991f, -0.09182025f, 
    0.10975856f, -0.09132550f, -0.08650770f, 0.13958542f, -0.03889235f, 0.05076790f, 0.28881532f, 0.03699793f, 
    0.00728852f, 0.02589935f, 0.04587171f, 0.00488356f, 0.31915951f, 0.19749050f, 0.18759923f, -0.00447199f, 
    -0.08217670f, -0.03469222f, -0.03198438f, 0.17014289f, -0.03510508f, -0.00233924f, 0.02355313f, -0.13309680f, 
    0.32607663f, 0.18035930f, 0.03078174f, 0.12671295f, 0.00680292f, 0.02321769f, -0.08711989f, 0.10572658f, 
    -0.03273623f, -0.04409606f, 0.02633897f, -0.11542806f, 0.01737394f, 0.00542690f, 0.34726256f, 0.04052602f, 
    -0.24869344f, -0.16716391f, 0.09784779f, -0.10543402f, 0.05319890f, -0.00221639f, 0.23580967f, 0.08430365f, 
    0.08814072f, 0.03640418f, -0.01751445f, 0.12668815f, 0.07406961f, 0.05604690f, -0.03895618f, -0.00637937f, 
    0.04192563f, -0.03445403f, 0.01151951f, -0.03490137f, -0.13077226f, 0.00451817f, 0.15962723f, -0.09228498f, 
    -0.06747782f, -0.25521019f, -0.00947165f, 0.00570778f, -0.21597739f, -0.10768459f, 0.01394406f, -0.02462861f, 
    -0.11197498f, -0.18302776f, -0.16673017f, 0.04960104f, -0.08954962f, -0.03771296f, -0.06253389f, 0.01010829f, 
    -0.00631472f, 0.13099203f, 0.09109957f, 0.04771487f, 0.09004050f, 0.08102775f, -0.02627578f, 0.07432174f, 
    -0.07637220f, -0.09341400f, -0.08224129f, 0.01636469f, -0.09187374f, -0.08284922f, 0.01376174f, 0.01497706f, 
    -0.21967658f, -0.10593255f, -0.00158967f, -0.04529321f, -0.05748934f, -0.02742147f, 0.01750191f, -0.03457269f, 
    -0.04209412f, 0.00436553f, 0.17688526f, 0.26267233f, 0.16210334f, 0.07916804f, 0.04748161f, 0.06055163f, 
    -0.03323679f, -0.01998436f, -0.01542132f, -0.07299035f, -0.04453466f, 0.02404295f, -0.06602386f, -0.10073528f, 
    -0.03602686f, 0.04586403f, 0.10245819f, 0.15297659f, 0.04179697f, 0.00444384f, -0.05448160f, -0.01560659f, 
    0.21137923f, -0.01372192f, 0.02018035f, 0.00819852f, 0.00377348f, 0.03854106f, -0.08705408f, 0.13181232f, 
    0.00891021f, 0.12189617f, 0.02245576f, -0.02976775f, -0.00709635f, 0.05538376f, 0.01063310f, -0.07719655f, 
    -0.15048268f, -0.22527140f, -0.15387556f, -0.20582831f, 0.01971130f, -0.10090617f, 0.04312267f, 0.03714497f, 
    0.11680768f, 0.08966468f, 0.01336735f, 0.02575533f, 0.22012727f, 0.01961968f, 0.08355585f, 0.07953527f, 
    -0.02694009f, 0.13052131f, 0.06208256f, 0.00737782f, -0.08686144f, 0.08969167f, 0.02004691f, -0.12837917f, 
    0.20698209f, 0.04600543f, -0.08733395f, 0.16372260f, -0.01372231f, -0.02676162f, -0.03114143f, 0.01281688f, 
    -0.05243765f, 0.02878570f, 0.00424308f, -0.10202110f, 0.11455711f, 0.01303392f, 0.03219006f, 0.13732593f, 
    -0.02998656f, 0.03210449f, 0.02840397f, -0.01404274f, 0.08121133f, 0.11049321f, -0.02133573f, 0.02415882f, 
    0.54517066f, 0.13029298f, 0.22972941f, -0.12571612f, -0.06013422f, -0.01616705f, 0.15389884f, 0.07996927f, 
    0.26159048f, 0.11840066f, 0.06356432f, 0.19749816f, -0.11160513f, -0.12271916f, 0.06385167f, 0.48784879f, 
    0.31256250f, 0.03614234f, -0.10265970f, 0.11712582f, 0.09313074f, 0.02799404f, 0.20566322f, 0.02501635f, 
    0.22372618f, 0.15438344f, -0.05046894f, -0.01453812f, -0.04077391f, 0.07206873f, 0.02505069f, 0.00238086f, 
    0.01486882f, 0.02267415f, 0.10950873f, -0.02163610f, -0.06863517f, -0.01955526f, 0.05599617f, -0.15465531f, 
    -0.02432437f, -0.06116332f, 0.13177353f, -0.06844957f, -0.01668075f, -0.00634635f, -0.00271372f, 0.01246925f, 
    -0.14574336f, 0.02298027f, 0.17164515f, -0.14688113f, -0.19700572f, -0.19044542f, -0.11290506f, 0.12324254f, 
    -0.05056168f, 0.09073564f, 0.06416115f, -0.02119114f, 0.16198109f, 0.04688620f, 0.04295056f, 0.00530213f, 
    0.05085392f, 0.08595978f, 0.06348058f, 0.00770237f, -0.03524324f, -0.13183782f, -0.05900942f, -0.01233627f, 
    -0.18401569f, -0.23335946f, 0.13382772f, 0.15019898f, 0.02228046f, 0.03773260f, 0.03481062f, 0.09597147f, 
    -0.01619839f, 0.05942050f, 0.11084110f, -0.09370507f, -0.30613798f, 0.05523927f, 0.11852521f, -0.02752647f, 
    -0.15492254f, -0.13837664f, -0.10518905f, 0.05357267f, -0.01030621f, 0.21991467f, -0.06515533f, -0.06644290f, 
    0.05048108f, -0.18801251f, -0.10532205f, 0.10251879f, -0.01563300f, -0.07565532f, 0.04013036f, -0.05048328f, 
    0.18019706f, -0.03539368f, 0.02809058f, 0.05771473f, 0.37215340f, -0.02620827f, -0.00226882f, -0.07032109f, 
    -0.03102208f, 0.04106263f, 0.09562626f, -0.01471630f, -0.03712596f, -0.13492647f, -0.08097220f, 0.03529150f, 
    -0.03733456f, -0.02293483f, 0.07425050f, -0.26538381f, -0.01766288f, -0.06280188f, 0.20677672f, 0.13032816f, 
    0.05322722f, 0.07337563f, 0.16746531f, 0.16752341f, -0.23726155f, -0.19052649f, -0.17911045f, 0.04858989f, 
    -0.12223310f, -0.07874478f, 0.13523245f, -0.13028006f, 0.09637399f, -0.00342410f, 0.02964906f, -0.00315098f, 
    0.36155829f, 0.04606152f, -0.03632143f, -0.03867145f, -0.04469080f, 0.08570790f, 0.15642849f, 0.05347821f, 
    -0.01703311f, 0.01280950f, 0.02650908f, -0.10219494f, -0.00624801f, -0.02949541f, 0.20307745f, -0.21540102f, 
    -0.01263757f, 0.05231277f, 0.11530978f, 0.03188067f, 0.09254476f, 0.26615238f, 0.19998877f, 0.19802162f, 
    0.11103889f, 0.04672395f, -0.04394684f, -0.03239987f, 0.09273881f, 0.01189517f, 0.01372851f, -0.02628468f, 
    0.03493772f, -0.11842186f, -0.18773735f, -0.07899352f, 0.12014681f, 0.07223924f, 0.12225008f, -0.13892083f, 
    -0.02631110f, -0.05394661f, -0.02070749f, 0.06220296f, -0.04378413f, -0.00672928f, -0.25926855f, -0.15881841f, 
    -0.03841846f, 0.05322584f, 0.14146195f, 0.05071343f, 0.09559081f, 0.14616013f, -0.12815613f, 0.00132852f, 
    0.03046699f, 0.03158852f, 0.01007630f, -0.01383750f, -0.02106931f, 0.26259997f, 0.06236066f, -0.13489527f, 
    -0.15751348f, -0.13535526f, 0.02344338f, 0.04062792f, -0.06615587f, 0.04214230f, 0.18753244f, 0.15096834f, 
    0.18529710f, 0.20586276f, -0.08315050f, -0.17576845f, -0.01413204f, -0.03730796f, 0.14886759f, -0.06348474f, 
    0.17061225f, 0.05302334f, -0.10878529f, 0.01079976f, -0.08778975f, -0.14663984f, -0.05593608f, -0.02238875f, 
    -0.23403060f, -0.01318499f, -0.07263355f, 0.14399962f, -0.01437381f, 0.02900388f, 0.02301432f, -0.03126882f, 
    -0.25758699f, -0.09430955f, 0.06387910f, -0.13376065f, -0.05331514f, -0.12057947f, -0.02410630f, 0.16514465f, 
    -0.09438899f, 0.01563368f, 0.10573059f, 0.10648479f, -0.15735990f, 0.02414460f, 0.20065731f, 0.22374168f, 
    0.00317293f, -0.17940715f, -0.08753605f, -0.04419592f, -0.11267008f, -0.14513001f, 0.05637155f, -0.20149605f, 
    -0.19805039f, 0.10646851f, 0.03511997f, 0.18957768f, 0.10385920f, 0.24520792f, 0.00796638f, 0.27971113f, 
    0.03056188f, 0.09922934f, 0.18139042f, -0.01279148f, -0.35249546f, 0.00201452f, 0.18713334f, -0.08623984f, 
    -0.09738079f, -0.09086305f, -0.10867607f, 0.10100485f, -0.01460963f, 0.13587441f, 0.13918975f, 0.10093416f, 
    0.40524194f, -0.12176298f, -0.19228129f, -0.07698474f, -0.06325804f, 0.05222502f, 0.05982760f, 0.10655551f, 
    -0.06144332f, 0.01032388f, 0.00729058f, 0.05719747f, 0.28111172f, -0.01498588f, -0.01711467f, 0.01162306f, 
    -0.15273941f, -0.04701661f, 0.14497110f, -0.05525913f, 0.04686918f, -0.04350248f, 0.06813318f, -0.00481679f, 
    -0.04710189f, -0.03505237f, -0.00951750f, -0.24711356f, -0.08509138f, 0.03681458f, 0.19660859f, 0.04430017f, 
    -0.01310360f, -0.12061008f, 0.07888024f, 0.13508333f, 0.27100283f, 0.05327586f, 0.00840734f, -0.01142344f, 
    -0.07291620f, 0.16079232f, 0.08724699f, -0.01143406f, 0.06889705f, 0.08259140f, -0.06583327f, -0.06969121f, 
    0.16276267f, 0.09002420f, -0.09013391f, -0.02391179f, -0.13897148f, 0.19298930f, 0.20713933f, -0.04608202f, 
    0.18960345f, 0.06395984f, 0.20686458f, 0.28534770f, -0.15064162f, -0.12887134f, 0.06977568f, -0.08035816f, 
    0.06576291f, -0.23351946f, -0.06122893f, 0.09849063f, 0.01140703f, -0.08056753f, -0.02794397f, -0.09033584f, 
    0.05247151f, -0.00472350f, 0.02737356f, -0.07800760f, 0.07349998f, 0.07801396f, 0.22699867f, 0.13833885f, 
    0.15390828f, 0.17038253f, 0.13544391f, 0.08114172f, -0.15605497f, -0.18661213f, -0.05477566f, -0.12743299f, 
    -0.00611330f, -0.05848333f, -0.10229789f, -0.01319325f, 0.04599163f, 0.07500522f, 0.08694594f, 0.04734402f, 
    -0.09606729f, -0.07069672f, -0.07235231f, -0.05717344f, 0.03387829f, -0.09231503f, 0.05556405f, -0.09641666f, 
    -0.09551891f, -0.17321941f, -0.16768961f, -0.12125542f, -0.21884796f, -0.27760515f, -0.18857270f, -0.35068515f, 
    -0.15171835f, -0.15807885f, -0.27690575f, -0.06837231f, -0.05002590f, 0.01948879f, -0.01455172f, -0.14844388f, 
    0.01728722f, -0.08430473f, 0.02720499f, -0.05465993f, -0.00114102f, 0.07538665f, -0.00862863f, -0.00485989f, 
    -0.11267610f, -0.13032173f, -0.11907439f, -0.03313602f, 0.09872306f, 0.05118668f, 0.05970644f, 0.04102355f, 
    -0.04879973f, 0.04206254f, -0.00459546f, 0.02807192f, 0.07942450f, 0.13373108f, -0.11500556f, -0.16109674f, 
    0.46632728f, 0.12745427f, 0.20557195f, -0.11113900f, 0.04989047f, -0.07033892f, 0.03902874f, -0.01073587f, 
    -0.03857977f, 0.14560178f, -0.06133180f, -0.01884984f, -0.13962410f, 0.03724365f, 0.11299085f, 0.04033787f, 
    -0.04757861f, 0.27874225f, 0.00706367f, 0.15366732f, 0.12261214f, -0.05199596f, 0.29309276f, 0.03197853f, 
    0.02151822f, -0.08004353f, 0.08877532f, -0.07036414f, 0.07546424f, -0.05407754f, 0.18843932f, 0.08934546f, 
    0.21061338f, 0.02857928f, 0.02009197f, 0.31383967f, -0.10992450f, -0.04410533f, -0.05958390f, -0.10161938f, 
    0.01627669f, 0.15141605f, 0.06834459f, 0.02835473f, -0.05440144f, 0.16009888f, 0.10995874f, 0.19679591f, 
    0.11936788f, 0.01954066f, -0.14023048f, -0.04774097f, -0.03951599f, 0.12533650f, 0.11494238f, 0.01560828f, 
    0.00588322f, -0.05046563f, 0.01645781f, -0.11432039f, 0.21302718f, 0.09955370f, 0.10245986f, -0.06634670f, 
    0.03271227f, -0.06725221f, 0.03036131f, 0.01392357f, -0.03151413f, 0.03760211f, -0.05552691f, -0.05779195f, 
    -0.40327176f, 0.07791234f, 0.03404934f, -0.25155109f, 0.01534862f, -0.16771866f, 0.12050337f, 0.12077992f, 
    -0.01730140f, 0.08866020f, 0.18058027f, -0.01882091f, 0.05142117f, -0.00651959f, 0.05779171f, 0.03753854f, 
    -0.04033028f, -0.03805877f, 0.12677452f, 0.06308141f, -0.04016278f, 0.15389474f, 0.17016862f, 0.16580085f, 
    -0.27728319f, -0.17863512f, 0.05359752f, -0.03856852f, 0.03216672f, -0.20244007f, -0.12926061f, 0.07990509f, 
    -0.01861650f, 0.04061104f, 0.02301572f, -0.14564157f, 0.10350662f, 0.06026667f, 0.11077341f, 0.30557418f, 
    0.02546443f, 0.03162443f, -0.01247064f, 0.04351625f, 0.02297053f, 0.05123754f, 0.08711165f, -0.05652166f, 
    0.00989972f, -0.00014003f, -0.00398478f, -0.06735386f, 0.00609345f, -0.05680105f, 0.03765168f, -0.08697090f, 
    -0.11226707f, -0.03505991f, -0.06617661f, -0.19009879f, 0.06629828f, -0.00730843f, -0.09698407f, 0.10231773f, 
    -0.00277113f, 0.09988990f, -0.01897654f, 0.07039968f, 0.09297887f, 0.19239219f, -0.01447594f, -0.10733806f, 
    -0.00729212f, -0.36300009f, -0.14953767f, -0.18068893f, -0.19611451f, -0.06760116f, 0.16419695f, -0.17901760f, 
    -0.03802865f, -0.03325134f, 0.01058648f, 0.06788709f, 0.07661077f, 0.07906099f, 0.07839297f, -0.06895286f, 
    -0.08928610f, -0.06068762f, 0.15453999f, 0.08135313f, 0.02206086f, -0.16113263f, -0.05680987f, -0.13750920f, 
    -0.02767137f, -0.01559629f, -0.02604684f, 0.03356603f, -0.03545819f, -0.01280511f, 0.00274048f, -0.02699783f, 
    -0.03702694f, -0.02296064f, -0.01630593f, 0.02498186f, 0.02793760f, -0.00722041f, 0.00601787f, -0.03263274f, 
    -0.01028928f, 0.00298078f, 0.01000771f, 0.00238482f, -0.02154090f, 0.00229104f, -0.01842760f, 0.01335021f, 
    -0.01575316f, -0.02217172f, 0.02703672f, 0.00121410f, -0.01896544f, -0.01844092f, -0.03021739f, -0.04039689f, 
    0.00627906f, -0.02903782f, 0.02093046f, 0.03205715f, 0.03293766f, 0.00398766f, -0.01822768f, 0.01187853f, 
    -0.02435950f, -0.01999509f, 0.02978312f, -0.02929174f, 0.00503832f, -0.02709264f, 0.00883252f, -0.03262530f, 
    -0.03009997f, -0.01043492f, 0.03065693f, -0.03613451f, 0.01078709f, -0.03148261f, -0.02026085f, 0.03055483f, 
    -0.01856485f, -0.03145471f, 0.00314929f, -0.02691447f, -0.03372275f, -0.01380202f, -0.02779763f, 0.01729124f, 
    -0.00315239f, -0.02839378f, -0.02103823f, 0.00677109f, -0.00081229f, 0.02517923f, -0.01436226f, -0.03966716f, 
    -0.00311814f, 0.00826829f, 0.02647289f, 0.02467798f, -0.01532815f, -0.02673805f, -0.01747996f, -0.01304581f, 
    0.02527868f, -0.02242086f, -0.00221187f, 0.02616141f, 0.01237069f, -0.01257274f, -0.00573726f, -0.01756810f, 
    -0.00900841f, 0.00296873f, -0.01347339f, 0.01091581f, 0.02073473f, -0.03267303f, 0.01788375f, 0.02647022f, 
    -0.01395540f, -0.01414469f, 0.00097246f, 0.02362788f, 0.01729648f, -0.02807398f, 0.01730581f, -0.00392586f, 
    0.02924035f, 0.00870702f, -0.01389108f, -0.02262833f, 0.02967756f, 0.03102384f, 0.01214670f, 0.00799779f, 
    -0.02232022f, 0.02375959f, 0.01218042f, -0.01777109f, 0.02284980f, -0.01189775f, -0.01938910f, -0.04402291f, 
    -0.01185973f, -0.03785690f, 0.00710968f, 0.01740743f, -0.00259058f, 0.00169959f, -0.00263300f, -0.03328277f, 
    0.01130619f, -0.01620996f, 0.00128549f, 0.01464464f, 0.00107157f, -0.00434585f, -0.00867715f, -0.04183363f, 
    -0.03952603f, -0.00536513f, 0.01561388f, -0.02801240f, -0.01568281f, 0.01464284f, -0.03288428f, 0.00701074f, 
    -0.02110885f, 0.03009394f, -0.02622431f, -0.01706258f, -0.02681657f, -0.03942772f, -0.04200801f, -0.04153296f, 
    0.02345638f, -0.00043888f, 0.02062430f, -0.01179963f, -0.00482706f, -0.01137565f, 0.01815844f, 0.01693391f, 
    0.02495924f, 0.01953168f, 0.01913827f, -0.02780578f, -0.03150808f, -0.03406928f, 0.00426559f, -0.04079370f, 
    0.00842260f, -0.03957177f, 0.01139332f, -0.00819306f, -0.01187898f, 0.00162190f, 0.02356277f, -0.04193936f, 
    0.00676461f, -0.00127837f, -0.00165018f, -0.00004096f, -0.02618422f, -0.00651606f, 0.03172764f, 0.00497376f, 
    -0.02264096f, 0.00965210f, 0.01000544f, -0.00202320f, -0.04025576f, -0.02210521f, 0.01833633f, -0.00916719f, 
    -0.03095688f, -0.00233510f, -0.00176473f, -0.00335395f, 0.00429405f, -0.03699246f, -0.02507964f, 0.00269570f, 
    0.00639490f, -0.03249614f, -0.02978152f, -0.01572914f, 0.01746108f, 0.02105703f, -0.03207972f, -0.02216981f, 
    -0.00461807f, 0.02347765f, -0.00683099f, -0.01787524f, 0.02055398f, -0.00520162f, -0.03951858f, -0.03410662f, 
    -0.00548372f, 0.02820250f, 0.02491172f, -0.01896764f, -0.03822102f, -0.02996377f, -0.00361491f, -0.03466325f, 
    -0.00814489f, 0.03316595f, -0.01520087f, -0.00212495f, 0.01581792f, 0.02234788f, -0.03305078f, 0.01364654f, 
    -0.03208040f, -0.00334780f, 0.03046268f, -0.00941662f, -0.03120907f, 0.02392905f, -0.04079606f, -0.00809563f, 
    0.00046068f, -0.00567094f, 0.00023212f, -0.03206735f, -0.03688039f, -0.00475847f, -0.00589822f, 0.02651020f, 
    -0.00452974f, 0.01256670f, 0.01068444f, -0.03761067f, -0.00320460f, 0.00051863f, -0.03094351f, -0.00712123f, 
    -0.01562515f, -0.01896564f, -0.00554602f, 0.02523268f, -0.01289106f, -0.00206575f, -0.02997691f, 0.00489566f, 
    -0.02614530f, -0.01105861f, -0.02051077f, -0.03071623f, 0.03453655f, 0.00774871f, -0.02574801f, 0.01435085f, 
    0.02321942f, -0.00207798f, -0.02484723f, -0.01025752f, -0.02849834f, -0.04238151f, 0.02325233f, -0.02156130f, 
    -0.02398747f, 0.00684528f, -0.03280739f, -0.00902193f, -0.04429580f, -0.03829329f, 0.01705171f, -0.03043141f, 
    -0.01780432f, 0.02608988f, 0.01755038f, -0.01694564f, -0.03729484f, 0.00719485f, -0.02630646f, -0.01680821f, 
    -0.00762712f, -0.03289396f, 0.02899956f, -0.01661447f, 0.01900369f, 0.01021882f, -0.02642220f, -0.03554907f, 
    0.01950815f, 0.01412517f, -0.00885315f, 0.01945145f, 0.03038454f, -0.03398979f, -0.01430349f, -0.04020140f, 
    -0.01729466f, -0.02401318f, -0.04145010f, -0.00112012f, 0.01089141f, -0.00940636f, 0.00489102f, 0.01323489f, 
    0.01376627f, 0.03143791f, -0.03079133f, 0.01259064f, -0.00620446f, 0.02633038f, -0.02360572f, 0.01885600f, 
    0.02615741f, 0.01409692f, -0.00744756f, -0.02370544f, 0.02602215f, -0.01903220f, -0.02305556f, -0.02256506f, 
    -0.00874453f, -0.01062124f, 0.01616180f, 0.01681476f, 0.01185839f, 0.00985111f, -0.02096354f, -0.03438205f, 
    -0.02253344f, -0.04227656f, -0.02074487f, -0.00204022f, -0.03225691f, 0.01094392f, -0.00647263f, 0.00968957f, 
    -0.03018014f, 0.01804313f, -0.02633575f, 0.01848222f, 0.01091862f, -0.00783663f, -0.02815893f, -0.02619237f, 
    -0.00504568f, 0.00846269f, 0.00308996f, -0.01558778f, 0.01212755f, 0.00862835f, -0.03169006f, -0.00466536f, 
    0.02382688f, 0.01267276f, 0.00792584f, -0.02098473f, -0.00277545f, 0.02330650f, 0.02005237f, -0.02512768f, 
    0.01659496f, 0.01054871f, -0.01077804f, 0.01599845f, 0.00612831f, -0.02629250f, -0.00933440f, -0.03985364f, 
    -0.01314909f, 0.00981058f, -0.01280800f, -0.02373356f, 0.01938650f, -0.01608377f, 0.03089906f, 0.00015988f, 
    -0.01031823f, 0.01870103f, -0.01787461f, -0.01074307f, -0.01684523f, 0.01079435f, 0.01074024f, -0.02345343f, 
    0.01233828f, 0.03074968f, -0.02965657f, 0.02733201f, 0.02843073f, 0.01654697f, 0.00116604f, -0.03478884f, 
    -0.02589241f, 0.01691810f, -0.01201881f, -0.01932099f, -0.03230128f, 0.00959055f, 0.00049965f, 0.00587122f, 
    0.00353640f, 0.00386143f, 0.01667033f, -0.02062884f, 0.00964988f, -0.00738466f, 0.02070411f, -0.02313245f, 
    -0.00514968f, -0.00822390f, -0.00500217f, 0.00742445f, 0.01800066f, -0.02551929f, -0.00038542f, -0.02081934f, 
    0.00551193f, 0.00903499f, -0.01493268f, -0.01856494f, -0.02179996f, -0.03837400f, -0.00647674f, -0.01479896f, 
    0.01665849f, -0.02538337f, 0.00761161f, 0.01049469f, -0.03170017f, 0.02570217f, -0.01384865f, -0.02198492f, 
    0.00818424f, 0.00529389f, -0.01042626f, -0.02103186f, -0.00048028f, -0.02687630f, -0.02484594f, -0.01961004f, 
    0.00675650f, -0.00066771f, 0.02189257f, -0.02964456f, 0.00562895f, 0.02033965f, 0.01930808f, 0.02641938f, 
    -0.01198490f, 0.02880750f, 0.01783500f, -0.03904606f, -0.01513955f, -0.03161765f, -0.02475401f, 0.01462595f, 
    -0.03768542f, 0.02363201f, -0.03836166f, -0.03310146f, 0.02667579f, 0.01240047f, 0.01085401f, 0.01033208f, 
    -0.03125925f, -0.01974228f, 0.02279829f, -0.03221933f, 0.03617662f, 0.02043786f, 0.01607060f, -0.02845838f, 
    -0.02268108f, 0.01150899f, -0.00923498f, -0.00745897f, 0.00178975f, 0.02072442f, -0.01521162f, 0.01522275f, 
    -0.04104705f, 0.00766530f, 0.01644977f, -0.00540662f, -0.01458536f, -0.00939044f, -0.01989897f, -0.00544048f, 
    -0.00415766f, -0.00842513f, -0.00285647f, -0.02506389f, -0.01967885f, -0.01966512f, -0.02115842f, 0.02289495f, 
    0.00692021f, -0.00878820f, 0.03199911f, 0.02109617f, -0.01109485f, -0.02860723f, 0.02021538f, -0.02184832f, 
    0.03192657f, -0.03414709f, -0.00768080f, 0.01082926f, 0.01952108f, -0.03367060f, 0.02039118f, -0.02667816f, 
    -0.01563665f, -0.03915558f, -0.01871345f, 0.00921837f, 0.00021088f, -0.03170551f, 0.01411663f, 0.02519600f, 
    0.01265697f, -0.00060648f, -0.00059840f, -0.02175941f, 0.01484239f, -0.01090493f, 0.00836605f, -0.04019077f, 
    -0.00012486f, -0.01165723f, -0.03631693f, -0.00390631f, -0.00039540f, -0.03406001f, 0.02845121f, 0.01849481f, 
    0.01159179f, 0.01916961f, 0.00628061f, 0.01588563f, -0.00908207f, 0.01374047f, 0.01211595f, 0.01856924f, 
    0.01097029f, 0.01907102f, -0.01496897f, 0.01128221f, -0.01576032f, -0.02685590f, 0.00348386f, -0.02413769f, 
    -0.00405791f, 0.00943596f, -0.00015292f, 0.02189695f, 0.01642855f, -0.03513566f, 0.01431363f, -0.02887936f, 
    0.01706400f, 0.02747123f, -0.01454351f, -0.01306081f, 0.02423315f, -0.02646244f, -0.02920315f, 0.02468759f, 
    0.01465218f, 0.02307894f, -0.02232037f, 0.02821746f, -0.01188815f, 0.00396766f, -0.04465138f, -0.02970801f, 
    0.02917192f, -0.01291734f, -0.01999120f, 0.00263527f, -0.02688110f, -0.03805386f, 0.00876829f, -0.03090091f, 
    0.00695843f, -0.00169879f, 0.01066069f, 0.00411127f, 0.01071127f, -0.04131471f, -0.03964964f, -0.00303178f, 
    -0.01710945f, 0.00307241f, -0.02902235f, 0.02052068f, -0.00330616f, 0.01874565f, 0.01505392f, -0.02227494f, 
    -0.01801727f, -0.03880444f, -0.00293679f, -0.00748058f, -0.03028546f, 0.00254921f, 0.00901681f, -0.00894011f, 
    0.00093723f, 0.01418240f, -0.02744870f, -0.00709824f, 0.01727910f, -0.01799659f, 0.01479973f, 0.00706173f, 
    -0.01073622f, -0.00669192f, -0.01267694f, -0.00431071f, -0.00221609f, -0.02118118f, 0.02489667f, 0.00571289f, 
    -0.03822571f, -0.02228103f, -0.02641115f, 0.00044047f, -0.01558751f, -0.01888492f, 0.00184833f, -0.02093114f, 
    -0.02905199f, -0.02992491f, 0.00201151f, -0.04285077f, 0.00225511f, 0.01277935f, -0.01845648f, -0.03660617f, 
    -0.01450281f, 0.01467357f, 0.01044628f, 0.01834118f, 0.02527945f, -0.00515857f, -0.02551673f, -0.02808398f, 
    0.01091383f, 0.01676835f, 0.00391245f, 0.02361709f, -0.03301799f, -0.02021662f, -0.01773928f, 0.03217937f, 
    0.00802328f, 0.01212772f, -0.01115345f, -0.00129739f, -0.01534885f, -0.03859680f, 0.01293524f, 0.03261576f, 
    -0.02252616f, -0.00562765f, -0.00346689f, 0.01102330f, -0.02808905f, -0.04201553f, -0.01029308f, 0.00606908f, 
    -0.04215010f, -0.02269165f, -0.00080036f, -0.02007677f, 0.03487189f, 0.02455264f, 0.00323544f, 0.03525197f, 
    -0.00794035f, -0.03465528f, 0.01289701f, -0.03237977f, -0.02141120f, 0.01027756f, 0.01041182f, 0.03244106f, 
    -0.03571525f, 0.02546951f, 0.02802857f, -0.02091162f, 0.02496300f, -0.03165467f, -0.03090814f, 0.00504015f, 
    0.01616058f, -0.00859567f, 0.01734763f, 0.00705467f, -0.02032201f, 0.01310963f, -0.01639243f, -0.03386011f, 
    0.03038293f, -0.00226444f, -0.03864123f, -0.01466955f, 0.00387261f, 0.01851095f, -0.01028199f, -0.02950249f, 
    0.01577309f, -0.00269613f, -0.00754759f, 0.02554214f, -0.00922918f, 0.02685839f, 0.00477606f, -0.01675720f, 
    -0.01662325f, 0.01632572f, 0.01763125f, 0.00149865f, 0.01426439f, 0.01201077f, -0.01985149f, -0.01085421f, 
    0.02685954f, -0.02600552f, 0.02762792f, -0.00758766f, 0.02200682f, -0.04163654f, -0.04027239f, 0.01010395f, 
    -0.03071479f, -0.03518903f, -0.00055192f, 0.01907379f, 0.00392620f, 0.02119769f, -0.02268239f, -0.03747442f, 
    0.02905226f, -0.03378419f, 0.00856987f, 0.00601413f, 0.00027527f, 0.00760285f, 0.02485138f, -0.00821326f, 
    0.06905470f, 0.07591509f, 0.06093069f, 0.02670237f, -0.04142436f, 0.05462433f, -0.16577263f, 0.00244770f, 
    0.03205472f, 0.01940108f, 0.01024291f, 0.25766405f, 0.25160775f, 0.03299868f, -0.12140532f, -0.12533528f, 
    -0.00518693f, -0.01031639f, 0.13169087f, -0.13477361f, -0.09961108f, -0.12022845f, 0.05079220f, -0.02697130f, 
    -0.03697947f, -0.02565029f, 0.05868579f, 0.10639332f, 0.03395140f, 0.02252953f, -0.02355470f, 0.01604231f, 
    0.14637777f, 0.25825810f, 0.04673266f, 0.18865156f, -0.29696482f, 0.08264177f, -0.03658213f, 0.01256015f, 
    0.16490182f, 0.14428478f, 0.06082220f, 0.02525110f, -0.00405303f, -0.08654509f, 0.12291764f, 0.13011903f, 
    0.03365868f, -0.00735130f, -0.01305750f, -0.01593663f, 0.08810828f, -0.00056085f, 0.05140981f, -0.06870095f, 
    0.05107849f, 0.09577405f, 0.00754952f, 0.06804489f, 0.04976232f, 0.07007410f, 0.17793201f, -0.03959782f, 
    -0.01958601f, 0.00954547f, -0.07294531f, 0.05431770f, 0.11753397f, -0.05503818f, -0.03834230f, -0.04848143f, 
    0.13307112f, 0.01903457f, -0.03612118f, 0.17923991f, -0.06084664f, -0.01094063f, -0.03317768f, 0.10484859f, 
    0.00301779f, 0.05701681f, 0.11327494f, -0.04606551f, -0.07465923f, 0.08081884f, 0.18416430f, 0.19776340f, 
    -0.12209193f, -0.05262675f, -0.08435901f, -0.08070774f, 0.01598801f, 0.03021323f, 0.01343784f, 0.11393216f, 
    -0.11245463f, -0.14275613f, -0.03740410f, 0.12601769f, -0.03960947f, -0.03043598f, -0.10280330f, -0.02676598f, 
    -0.15445402f, -0.10486160f, 0.00425169f, -0.17643060f, -0.06442244f, 0.14690782f, -0.00277090f, 0.07386649f, 
    0.04461513f, -0.09891181f, -0.10236289f, 0.10220511f, 0.03637381f, -0.02939453f, -0.03024724f, 0.03097627f, 
    0.02898589f, -0.02082921f, -0.00243485f, -0.03758156f, 0.02817995f, 0.06079658f, 0.01634880f, -0.01940967f, 
    -0.03976611f, -0.06150881f, 0.01136783f, 0.08633550f, -0.04657537f, -0.06044870f, -0.01565358f, 0.01176023f, 
    0.07572273f, 0.15473285f, 0.04511151f, 0.01027763f, 0.00850681f, 0.08914322f, -0.14061102f, 0.12965393f, 
    0.08829588f, 0.10227978f, 0.07723784f, 0.19006541f, -0.05864453f, 0.00744947f, -0.02885162f, -0.04530264f, 
    -0.00628170f, -0.02689547f, -0.04461802f, 0.00543360f, -0.00486976f, 0.11901285f, -0.07987306f, 0.13491550f, 
    -0.09096821f, -0.06292258f, -0.00570808f, -0.04172193f, 0.08911515f, 0.06825603f, 0.12961498f, 0.25043669f, 
    -0.04640853f, -0.17452495f, 0.12148021f, -0.16297834f, -0.01853006f, 0.00879078f, -0.00410740f, 0.04878322f, 
    0.03257108f, 0.05737599f, 0.01494393f, -0.04056579f, -0.10589150f, 0.33423293f, 0.05621403f, 0.06067703f, 
    0.06212324f, -0.09108642f, 0.02799002f, 0.15116206f, 0.05834239f, -0.24530415f, 0.07513401f, 0.22892462f, 
    -0.01730295f, 0.07570139f, 0.01699935f, 0.06725459f, -0.01422456f, 0.02637985f, -0.07112883f, -0.01430108f, 
    -0.08827278f, 0.01513398f, 0.05792552f, -0.03610488f, 0.10560191f, 0.05723430f, -0.12750301f, -0.09602839f, 
    -0.06552688f, -0.03742026f, -0.12655616f, 0.17969175f, 0.08363443f, 0.33860859f, -0.04660868f, 0.08676378f, 
    -0.30802721f, 0.01236126f, -0.05258602f, -0.09221045f, -0.10728039f, -0.01752281f, 0.06883172f, 0.03415737f, 
    0.13141467f, 0.15435764f, 0.04306316f, -0.12115199f, 0.00335083f, -0.03952320f, -0.06639788f, -0.03943140f, 
    0.20329855f, 0.13791910f, -0.04044818f, -0.02814467f, -0.05345883f, -0.00115343f, 0.00460171f, 0.00667125f, 
    -0.11536646f, 0.12479401f, -0.09846456f, 0.06815883f, 0.03963779f, -0.00034013f, 0.08361328f, 0.04990364f, 
    0.09615994f, 0.14741300f, -0.03564249f, 0.19752608f, -0.19808997f, -0.28242654f, 0.07223071f, -0.15672627f, 
    -0.11864176f, 0.04100614f, 0.08926351f, 0.10529409f, 0.06501943f, -0.04110659f, -0.02563336f, 0.00218550f, 
    -0.15122721f, -0.30698732f, 0.01238948f, -0.04478082f, -0.19518723f, 0.00137597f, 0.04365380f, -0.14582947f, 
    -0.00440481f, -0.11639484f, -0.01675254f, 0.00316022f, -0.15763363f, -0.25437036f, -0.18560259f, 0.16878085f, 
    0.12451903f, -0.01238508f, 0.13211529f, -0.06787560f, -0.03535451f, -0.03805630f, -0.03361066f, 0.03555634f, 
    0.17536929f, -0.04688863f, 0.09579789f, 0.10519531f, 0.03452060f, 0.12885158f, 0.06824254f, 0.05632668f, 
    -0.02203926f, 0.00060639f, 0.01879032f, -0.21064273f, 0.26285762f, -0.14980817f, 0.06065920f, -0.06832607f, 
    0.06441637f, 0.07205057f, -0.02507141f, 0.24801412f, -0.00133652f, -0.04861899f, 0.19970153f, 0.00179930f, 
    -0.01531223f, 0.13126552f, 0.06350765f, 0.08230162f, 0.01224624f, 0.00397195f, -0.05377323f, 0.03287391f, 
    0.05503839f, -0.00322898f, -0.09661133f, 0.03499599f, -0.09777520f, -0.16240498f, 0.04347102f, -0.03838619f, 
    0.03588444f, 0.11616939f, 0.00673622f, 0.16933967f, -0.06663728f, 0.13041319f, -0.15651014f, -0.10113269f, 
    -0.00624230f, 0.01266081f, -0.07804602f, -0.02360907f, 0.21733400f, 0.20233493f, 0.05601310f, -0.03657609f, 
    -0.03172518f, -0.02847509f, 0.05264470f, 0.03364002f, -0.01471919f, -0.01588921f, 0.02820395f, -0.05371312f, 
    0.10619392f, 0.04128847f, -0.18264113f, -0.05609878f, -0.01949131f, 0.17366478f, -0.01518313f, 0.03098546f, 
    0.11695307f, 0.21396026f, -0.06606346f, 0.07237759f, -0.09336671f, -0.02525840f, 0.04533750f, -0.06385576f, 
    -0.04823858f, 0.03781607f, -0.00158042f, 0.11743579f, 0.16729857f, -0.17045888f, -0.06707660f, -0.02050689f, 
    0.08777247f, 0.10262283f, 0.08152828f, -0.09538335f, -0.05678555f, 0.02710322f, 0.21127641f, -0.02554521f, 
    -0.00173734f, -0.12339818f, -0.05077820f, -0.12276626f, -0.03684614f, 0.05698961f, 0.09048007f, 0.05986558f, 
    0.18136306f, 0.00066070f, -0.05818175f, -0.05207871f, 0.15794742f, 0.19266741f, -0.15331420f, -0.05356364f, 
    0.02773459f, 0.04756380f, 0.11967313f, -0.04422855f, 0.02584535f, -0.01163348f, -0.01494561f, -0.05924611f, 
    -0.10225891f, -0.03627989f, 0.06724527f, 0.03601356f, -0.00265958f, 0.22066395f, 0.07782950f, 0.01313862f, 
    0.05363550f, -0.04720505f, 0.02801122f, 0.07116164f, -0.35249791f, -0.17406355f, 0.08329006f, 0.21657653f, 
    0.10699934f, -0.03019991f, -0.10671366f, 0.02074008f, 0.01784578f, -0.13525607f, 0.00950846f, 0.18420506f, 
    -0.11423840f, 0.37878758f, -0.17777306f, -0.12731637f, -0.03484636f, 0.10815872f, -0.03117706f, 0.14810140f, 
    0.14347440f, -0.03131599f, -0.05261280f, -0.01363370f, -0.35935929f, 0.04432050f, -0.00260262f, -0.15939994f, 
    -0.08130917f, 0.02555313f, 0.04246635f, 0.03918644f, 0.07983514f, 0.00830587f, -0.07761670f, -0.03809675f, 
    0.07643282f, -0.08908407f, 0.12926438f, -0.06514635f, 0.11254307f, 0.01828454f, 0.17129853f, 0.07988837f, 
    -0.07867390f, -0.08845044f, 0.00774790f, 0.05071500f, -0.09626143f, 0.04179422f, -0.01151361f, 0.05134618f, 
    0.01010877f, -0.10283211f, 0.02674778f, -0.03497060f, 0.05473869f, -0.05803233f, 0.06485818f, -0.03816833f, 
    0.28222066f, -0.11345599f, -0.19456306f, -0.17599015f, 0.09058476f, 0.09381250f, -0.04354421f, 0.08696933f, 
    -0.01788915f, -0.09278272f, 0.08289396f, -0.11081737f, 0.13077486f, 0.13287705f, 0.01249277f, 0.04408047f, 
    0.21753745f, 0.00931179f, -0.05088761f, 0.21669953f, 0.11261445f, 0.23671262f, 0.03603320f, 0.10651466f, 
    -0.07897349f, -0.07103473f, -0.00551404f, -0.07296459f, -0.10819874f, 0.16275799f, -0.10784117f, 0.16010174f, 
    -0.08974330f, -0.06306450f, 0.03002722f, -0.35119224f, -0.02192466f, -0.05146317f, -0.05389201f, -0.08261684f, 
    0.12799563f, 0.07285389f, 0.19791716f, 0.13732609f, -0.14443631f, -0.10403667f, 0.00939081f, -0.01709139f, 
    -0.00076340f, -0.05638740f, -0.03092473f, -0.01542447f, 0.10332612f, 0.10707971f, 0.04624448f, -0.02082548f, 
    0.06850118f, 0.23882990f, 0.08059517f, -0.05399983f, -0.04118013f, 0.06510957f, -0.00538274f, -0.11370337f, 
    0.07259291f, 0.06885529f, 0.11426983f, -0.11019523f, 0.05270257f, 0.09232459f, -0.00637957f, 0.03468334f, 
    0.04159354f, -0.10475871f, -0.13776042f, -0.15926333f, 0.18737990f, 0.20600563f, 0.16722424f, 0.27778992f, 
    -0.00878954f, -0.07566281f, -0.07402666f, -0.09743433f, -0.09086608f, -0.07141753f, -0.03005066f, -0.19526185f, 
    0.09265320f, 0.15734302f, 0.16534699f, -0.07576791f, -0.02875078f, -0.03955346f, -0.06021028f, 0.02634426f, 
    -0.07946169f, 0.02862110f, -0.03893684f, -0.00097778f, 0.11144251f, -0.04450252f, -0.10231032f, -0.20459644f, 
    0.06292340f, -0.01395132f, 0.02546708f, 0.10216852f, -0.02047986f, -0.00297305f, 0.17909621f, -0.00474517f, 
    0.08922430f, -0.03734291f, -0.00991556f, -0.02281145f, 0.04362567f, 0.15255764f, 0.04904589f, 0.28010842f, 
    0.17204925f, 0.03868353f, 0.33677316f, 0.21084605f, 0.08277036f, -0.07306957f, -0.03415390f, -0.09575263f, 
    -0.07868578f, -0.00755854f, -0.05993043f, 0.14278965f, -0.03524344f, 0.23075691f, 0.07794476f, 0.00517088f, 
    -0.04349537f, -0.02313708f, -0.09090865f, 0.11990447f, 0.01008581f, 0.01973863f, 0.17677784f, -0.06084071f, 
    -0.10399070f, -0.14134543f, -0.04835733f, 0.09352753f, 0.10532966f, 0.16116576f, -0.01305265f, -0.05542686f, 
    -0.03028233f, -0.16026828f, -0.10085037f, -0.14971669f, 0.06667124f, 0.17374918f, 0.00963968f, 0.05611028f, 
    0.14152727f, 0.08008848f, -0.01795244f, 0.06659896f, 0.10649743f, -0.20049411f, -0.04129851f, -0.40282959f, 
    0.06506536f, -0.10962093f, -0.12615587f, 0.08008472f, 0.07022523f, -0.06965446f, -0.00641074f, 0.04167479f, 
    0.09718597f, -0.05619806f, 0.11445540f, 0.13490707f, 0.05438637f, 0.03471668f, 0.03345991f, 0.12826453f, 
    -0.02615916f, -0.09349551f, -0.04678838f, 0.01514292f, 0.08331317f, 0.06860539f, 0.05876968f, 0.20590302f, 
    0.01310237f, 0.01831056f, -0.00330652f, -0.06511557f, 0.14451107f, 0.10078318f, -0.01626159f, 0.05280647f, 
    0.00657658f, -0.07326804f, -0.01945315f, -0.04058985f, 0.16860716f, -0.14093393f, -0.05435793f, 0.06133687f, 
    -0.04835848f, 0.02102797f, -0.03232514f, -0.07415716f, 0.11621823f, 0.02427474f, 0.17607033f, -0.12819774f, 
    -0.14961179f, -0.20108192f, -0.06458578f, -0.00488505f, 0.12435504f, 0.05176232f, 0.03625578f, 0.14105260f, 
    -0.03288347f, 0.07712752f, 0.09847116f, 0.09442220f, -0.03643312f, 0.12359556f, 0.07184270f, 0.09062335f, 
    -0.03802597f, -0.02251529f, -0.05080603f, 0.03782435f, 0.12488057f, 0.10145348f, -0.02062034f, 0.09062958f, 
    0.02438973f, 0.03467469f, -0.04234879f, 0.00419676f, 0.13319409f, -0.19954066f, -0.14499921f, -0.14692016f, 
    0.05565922f, 0.05657381f, 0.06791981f, 0.08938389f, 0.02487029f, 0.00442855f, -0.09613322f, 0.01670317f, 
    -0.04873956f, -0.01155587f, -0.00446395f, -0.00077554f, 0.22053342f, 0.21889393f, 0.08866562f, 0.24019846f, 
    0.06130281f, -0.19561230f, 0.12566854f, -0.11399462f, 0.04706880f, -0.06938784f, 0.08515563f, -0.06980820f, 
    -0.08376542f, -0.03464596f, -0.04254313f, 0.02509231f, 0.16658813f, 0.01162448f, -0.17207415f, -0.12543763f, 
    0.08931001f, 0.04074155f, 0.09735257f, 0.01063563f, 0.05671866f, 0.05243451f, 0.02254745f, -0.09121763f, 
    -0.16210613f, 0.05778590f, -0.00927965f, 0.02516416f, 0.19314478f, 0.03108594f, 0.08125435f, -0.05689004f, 
    -0.05023003f, -0.21625745f, 0.03128510f, -0.07936808f, 0.26101020f, -0.11647595f, 0.14451291f, -0.08473208f, 
    0.11750545f, 0.22740172f, -0.06916697f, 0.14425367f, 0.08855665f, 0.02589512f, 0.23354760f, 0.25036335f, 
    0.02896558f, 0.04472074f, 0.04964077f, -0.09524632f, 0.08808509f, 0.00736360f, -0.06232795f, -0.02313636f, 
    -0.17833655f, -0.04626802f, 0.01227210f, -0.18816474f, 0.41901547f, -0.22261411f, -0.11115089f, 0.11571261f, 
    0.06220821f, -0.00559770f, 0.00592457f, -0.11806320f, -0.05966075f, -0.07095387f, -0.02868215f, 0.01977788f, 
    0.21070458f, 0.14198576f, 0.05577022f, -0.01874538f, 0.07474716f, 0.08046038f, -0.02034514f, 0.11207683f, 
    -0.01784430f, -0.01208680f, 0.15731882f, 0.04005097f, 0.06177977f, -0.03496101f, -0.21729311f, 0.12043133f, 
    -0.09898365f, -0.07861278f, 0.24584046f, -0.20478627f, 0.01820031f, -0.05920754f, -0.08633588f, 0.06630026f, 
    0.20303704f, 0.03497519f, -0.12536357f, -0.01390112f, 0.18503094f, 0.17357098f, 0.14445499f, 0.01749896f, 
    0.13629811f, -0.11611578f, 0.11364770f, 0.34495556f, 0.11589401f, 0.07386173f, 0.18829674f, 0.11662446f, 
    0.12565294f, 0.02865448f, -0.14166856f, -0.27726343f, -0.29673225f, 0.00608200f, 0.11554986f, 0.00062593f, 
    -0.01207861f, 0.12933622f, 0.06342865f, 0.09920271f, 0.00486549f, 0.00934720f, -0.01487095f, 0.00120022f, 
    0.18294291f, 0.22279389f, 0.07972896f, 0.16961679f, 0.10648312f, -0.08616642f, 0.02047774f, 0.02597982f, 
    0.06737420f, 0.05246755f, -0.14711416f, -0.16095205f, 0.14548138f, -0.12315812f, 0.00514074f, 0.03044331f, 
    0.22900878f, 0.11424215f, 0.13150349f, -0.00812621f, 0.01143229f, -0.15934120f, 0.12083698f, 0.17312114f, 
    0.08054429f, 0.19989029f, 0.07692757f, -0.11405884f, -0.18822379f, -0.20220558f, 0.00307074f, -0.13059255f, 
    -0.02224198f, -0.00457396f, 0.01595798f, 0.05073009f, -0.15813830f, -0.01369200f, -0.04858334f, -0.07812212f, 
    0.14734441f, -0.11123302f, 0.08379254f, 0.16497186f, 0.13203946f, 0.14318281f, 0.08287410f, -0.19271484f, 
    -0.05245470f, 0.16716652f, 0.04600558f, -0.06755260f, -0.01072662f, -0.11403424f, 0.20220341f, -0.00962848f, 
    -0.07940055f, 0.18081325f, 0.07052995f, -0.15831688f, -0.17667834f, 0.23470293f, -0.09649014f, -0.00412817f, 
    -0.23980683f, 0.20889570f, 0.00596211f, 0.21462017f, 0.05109761f, -0.01768058f, 0.05478756f, -0.10867701f, 
    0.03194635f, 0.13962120f, 0.14208764f, 0.24003148f, 0.21402006f, -0.17545427f, -0.05779713f, -0.01160978f, 
    0.01123817f, 0.03940461f, -0.12001611f, -0.00169153f, -0.02382089f, 0.08113960f, -0.07431478f, 0.00411309f, 
    0.13110299f, -0.13957284f, 0.13595910f, 0.01237576f, 0.04623009f, 0.09289137f, 0.12465050f, -0.07303248f, 
    -0.04076261f, -0.00765152f, -0.04413917f, 0.17892948f, 0.04497429f, 0.12472696f, 0.08306909f, 0.12992771f, 
    0.06702299f, 0.11187002f, 0.07141060f, -0.15531226f, -0.02748764f, 0.06190244f, -0.13704167f, -0.06410838f, 
    0.51679450f, -0.07398234f, 0.03048454f, 0.01988200f, 0.16766979f, -0.02915696f, -0.05972040f, -0.06158724f, 
    -0.10016993f, -0.01366662f, -0.15962799f, 0.12147290f, 0.03957929f, -0.05935584f, 0.21481992f, 0.05569122f, 
    -0.11333254f, -0.00641931f, -0.02496276f, -0.09601191f, -0.11917211f, -0.07737796f, -0.25546983f, -0.04302381f, 
    0.27374199f, 0.04621375f, 0.09405278f, 0.08495329f, -0.00736530f, 0.08227898f, 0.02474743f, 0.12588727f, 
    0.01577617f, 0.19557706f, -0.08205361f, -0.19178896f, 0.27492988f, 0.32103351f, -0.00723211f, 0.09532005f, 
    -0.02431130f, -0.15555927f, -0.01458601f, -0.27915868f, 0.03710833f, -0.03315928f, -0.06039721f, 0.08818463f, 
    0.50367582f, 0.15891209f, 0.14163512f, 0.01699459f, 0.02011758f, 0.12679151f, 0.12904803f, 0.31358236f, 
    0.10779434f, 0.14551182f, 0.01805564f, -0.02674530f, 0.19387117f, 0.06443059f, 0.04273078f, -0.16385983f, 
    -0.14797890f, -0.03632531f, 0.06557609f, 0.08456206f, -0.17215364f, -0.11417824f, -0.15667014f, -0.13817906f, 
    -0.30745348f, 0.01972280f, -0.05344341f, -0.01328716f, 0.03604301f, -0.05574776f, 0.08165754f, 0.12743740f, 
    0.01924003f, 0.15081720f, 0.17961499f, 0.30725101f, 0.00738551f, 0.12450805f, 0.14075325f, -0.05688238f, 
    0.00458135f, -0.02340342f, -0.00689117f, -0.16576450f, -0.03867998f, -0.08292277f, -0.09777343f, -0.12431672f, 
    -0.16701365f, -0.21636009f, -0.05706011f, -0.12014288f, -0.06329696f, 0.16329850f, 0.00021861f, -0.09182036f, 
    -0.12362128f, -0.08438803f, 0.09989282f, 0.00142400f, -0.11287022f, 0.06309077f, -0.05392003f, 0.14875323f, 
    -0.04475020f, 0.11058051f, 0.09423051f, 0.14351027f, 0.16218242f, 0.25623789f, 0.09876808f, 0.37655100f, 
    -0.05154938f, -0.10952017f, -0.10412768f, -0.11776258f, -0.03688447f, 0.03342169f, 0.01277850f, -0.15514335f, 
    -0.11882405f, -0.19999863f, -0.30043736f, -0.41992426f, -0.08574078f, -0.16402301f, -0.12889688f, -0.10253821f, 
    0.02042530f, 0.00075641f, -0.03207277f, -0.06918831f, -0.09415565f, -0.23487127f, -0.27835250f, -0.13332623f, 
    -0.04854873f, -0.08487027f, 0.21554972f, 0.03656733f, 0.25417277f, -0.07053325f, -0.08344619f, -0.16445580f, 
    -0.09959697f, -0.03518779f, -0.20350671f, -0.15068069f, 0.05105866f, -0.11480615f, 0.16205925f, -0.08827701f, 
    0.05178727f, 0.02538265f, -0.06094671f, -0.19132304f, 0.04151595f, 0.07420997f, 0.00005173f, 0.22190617f, 
    -0.30588892f, 0.07451739f, 0.02849485f, 0.01751889f, -0.10329289f, -0.03508794f, -0.01347441f, -0.19408214f, 
    -0.05698650f, 0.08530477f, -0.00166473f, 0.12476669f, 0.28464669f, 0.06221898f, 0.07993531f, -0.19039950f, 
    0.05100637f, -0.03370263f, -0.13147989f, 0.04573354f, -0.11002495f, -0.01106297f, -0.17691615f, -0.09315734f, 
    0.16514662f, -0.03377125f, -0.21672557f, 0.09880771f, -0.04930968f, -0.01974326f, 0.07418837f, 0.03177191f, 
    0.02373062f, 0.00214434f, 0.09783175f, 0.04600438f, 0.43064976f, 0.36786392f, 0.22196351f, -0.04666750f, 
    0.29160339f, 0.09734848f, 0.03350789f, -0.39975774f, 0.01976794f, -0.11033902f, -0.04629331f, -0.13169578f, 
    0.06525355f, -0.11225167f, 0.03671414f, 0.07377852f, 0.02317284f, 0.06373716f, 0.07959422f, -0.06258401f, 
    0.06610805f, 0.01135687f, 0.22953685f, 0.14203800f, 0.46673426f, -0.06545562f, -0.08765898f, 0.16196662f, 
    0.15156581f, 0.04512815f, -0.03876982f, -0.13265637f, 0.02024996f, 0.05621699f, 0.02086266f, -0.00716575f, 
    0.00613764f, 0.24362174f, -0.10839784f, 0.20395261f, -0.01211904f, 0.08631467f, 0.04515689f, -0.05070208f, 
    -0.05065372f, -0.06490029f, -0.11446010f, 0.04178696f, -0.13384609f, -0.18957238f, -0.03613160f, 0.06876391f, 
    -0.21008141f, 0.23815559f, 0.15849482f, 0.19853209f, -0.14990450f, -0.01317451f, 0.03947018f, -0.10431900f, 
    -0.11471164f, -0.26328820f, -0.29547474f, 0.08216754f, 0.04710125f, 0.10682654f, 0.12163267f, 0.18502235f, 
    -0.04184252f, -0.15948826f, 0.02007833f, 0.20059285f, -0.18576390f, -0.00984077f, -0.07097980f, 0.05379174f, 
    -0.07817500f, 0.06640525f, -0.14110266f, -0.16622457f, -0.08640911f, -0.19461747f, -0.06283326f, 0.08554415f, 
    -0.05651769f, 0.11222922f, -0.00916545f, -0.26489714f, -0.08212736f, 0.05133190f, 0.12521398f, -0.06967159f, 
    0.27599508f, -0.20954317f, -0.00899504f, 0.44784200f, 0.18415785f, -0.03829121f, 0.02094404f, -0.16961554f, 
    0.12721498f, -0.08317403f, -0.03157105f, -0.05598231f, -0.01970006f, -0.18523942f, -0.20421749f, -0.22236322f, 
    -0.18284392f, -0.05560950f, -0.17717563f, -0.05549102f, 0.00840556f, 0.00648241f, 0.03887300f, 0.02903412f, 
    0.02206653f, 0.13256811f, -0.16151820f, 0.06704339f, 0.25544795f, 0.17818788f, -0.11657567f, -0.04404935f, 
    0.01120492f, 0.03376869f, 0.01673615f, 0.06892930f, 0.06999040f, 0.12087629f, 0.10899320f, 0.08243822f, 
    -0.04094139f, 0.35204825f, -0.09133895f, -0.02449168f, -0.06652789f, -0.12811916f, 0.11139742f, -0.19610645f, 
    0.05711298f, -0.01781347f, -0.13091241f, -0.39758754f, 0.30029210f, 0.22195970f, -0.09405439f, -0.00783159f, 
    0.09134093f, 0.09594469f, -0.14742218f, 0.15728374f, -0.02425483f, 0.07733778f, -0.00153173f, -0.11319799f, 
    -0.01633476f, -0.00807052f, -0.05783692f, -0.07195888f, 0.06483366f, -0.01564126f, -0.10585128f, 0.15784408f, 
    -0.20988110f, -0.22797601f, -0.27360466f, -0.52858287f, 0.11635120f, -0.04293859f, -0.03024709f, 0.02486907f, 
    -0.02338986f, -0.10815176f, -0.13478948f, -0.24843185f, 0.02732729f, -0.03565409f, -0.14564089f, -0.16240059f, 
    -0.30733043f, 0.19313091f, -0.08005188f, 0.23140334f, 0.16198277f, -0.06752876f, -0.01961378f, 0.01989498f, 
    0.01592596f, -0.05510299f, 0.01044251f, -0.35040355f, 0.09737629f, -0.12493305f, -0.06749626f, -0.23823680f, 
    -0.00504149f, 0.02075297f, 0.12866622f, -0.02185887f, 0.14031893f, -0.09165046f, 0.16295646f, 0.21794261f, 
    -0.09927566f, 0.00753878f, 0.21000248f, -0.09771696f, 0.04365928f, -0.04925624f, 0.14821129f, 0.28646833f, 
    0.15485409f, 0.21416856f, 0.01844991f, 0.20974693f, 0.01563206f, 0.14796546f, -0.01840625f, 0.15459898f, 
    -0.06526197f, -0.08695886f, 0.07378913f, 0.09715259f, 0.06842776f, 0.27617487f, 0.10796522f, 0.41551599f, 
    -0.13215819f, -0.01219995f, 0.25961155f, -0.22935554f, 0.08594730f, -0.10192187f, 0.06692109f, 0.09564769f, 
    -0.16470782f, -0.06719708f, -0.41327888f, -0.41877419f, -0.06673201f, 0.00035108f, 0.02366893f, -0.03142447f, 
    0.04295849f, 0.09403039f, -0.08361941f, -0.08433549f, -0.06582284f, -0.00416239f, -0.11439626f, -0.14487126f, 
    0.14553811f, 0.05783161f, -0.02807140f, -0.01047140f, -0.08809008f, -0.08289144f, 0.04148681f, 0.00768361f, 
    0.12320740f, 0.15101165f, -0.08469745f, 0.07696677f, -0.30814233f, -0.22849192f, 0.20323673f, -0.04188044f, 
    0.03037810f, -0.15452953f, 0.12142862f, -0.15342566f, -0.08092926f, 0.05950541f, 0.02849866f, 0.28774148f, 
    0.18682943f, 0.13848147f, 0.14417811f, -0.17659451f, 0.04319884f, -0.13888831f, 0.03312565f, -0.02462988f, 
    -0.10476146f, -0.08108281f, 0.02010803f, -0.15804373f, 0.17319182f, 0.11836239f, 0.07444692f, -0.04884536f, 
    0.03498982f, -0.04709109f, -0.04036688f, -0.32313934f, 0.01855751f, 0.10367987f, 0.05976500f, -0.02080175f, 
    -0.13970584f, 0.04956136f, 0.04560060f, 0.05743443f, 0.10147850f, -0.01594251f, -0.07774807f, -0.07960039f, 
    -0.15952188f, -0.28056914f, -0.19600011f, -0.47150370f, 0.09995415f, -0.22487104f, 0.10495910f, -0.13052204f, 
    0.04604585f, -0.01772940f, 0.05875669f, -0.33560273f, 0.01735264f, 0.17257243f, -0.00054790f, -0.04866344f, 
    0.08656655f, 0.27840137f, -0.13710605f, 0.17962897f, -0.06343341f, 0.00469208f, 0.01592527f, 0.18515728f, 
    -0.07195825f, -0.00124128f, 0.02720924f, -0.13441548f, 0.06452692f, 0.12585691f, -0.06598770f, -0.26658854f, 
    -0.06329726f, -0.11176287f, 0.06794068f, -0.02140546f, -0.07368539f, 0.05399577f, -0.23552586f, -0.41918379f, 
    0.13032410f, -0.21621566f, -0.13825618f, -0.24528350f, 0.01310262f, -0.03024633f, -0.06641195f, 0.03161958f, 
    -0.10634664f, -0.10273456f, -0.30307895f, -0.06754303f, 0.36561042f, 0.38298550f, 0.30978897f, 0.20497145f, 
    0.18232450f, 0.03162044f, 0.01141144f, 0.05703308f, 0.05626417f, 0.09259935f, -0.06190366f, 0.22630431f, 
    0.17995720f, -0.05221475f, 0.01548611f, 0.06424245f, -0.12914087f, -0.22385649f, 0.04996894f, 0.11763769f, 
    -0.13023756f, 0.05088969f, -0.13026109f, 0.00878493f, 0.53012478f, 0.31916064f, 0.26681241f, 0.18002111f, 
    0.17956677f, 0.00259233f, 0.05635705f, -0.11069521f, -0.00859287f, -0.05317640f, -0.04273452f, -0.02054300f, 
    0.14278868f, 0.00257503f, -0.03633607f, 0.19208372f, 0.06358133f, 0.01476084f, -0.01012018f, 0.10784414f, 
    -0.03324333f, -0.02073173f, -0.01108937f, -0.10245816f, -0.10980956f, 0.15735194f, 0.22826944f, 0.19693391f, 
    -0.00264388f, -0.00948805f, 0.02387779f, -0.14643779f, -0.06452602f, -0.03822433f, 0.11552797f, 0.00685211f, 
    0.17898199f, 0.17162822f, 0.31784219f, 0.27064306f, 0.09779561f, 0.05213234f, -0.01477129f, 0.06734908f, 
    0.05610705f, 0.01699992f, 0.06173091f, 0.14837289f, -0.12795570f, -0.10310633f, 0.06284080f, 0.09070174f, 
    0.23754434f, 0.16866021f, -0.04571282f, -0.01392909f, -0.19710559f, -0.08779053f, 0.03802522f, -0.06483514f, 
    -0.05889338f, 0.03544769f, -0.16683872f, 0.03444783f, -0.00475209f, -0.13452967f, -0.03007284f, 0.02315121f, 
    -0.09177892f, 0.09202604f, 0.01256801f, 0.00753442f, 0.06523276f, -0.28540161f, 0.01281666f, -0.09820976f, 
    0.13085784f, 0.00623720f, -0.11684784f, -0.09697554f, 0.04006621f, -0.08535829f, -0.12531781f, -0.11312631f, 
    -0.03879472f, 0.04336794f, 0.02958223f, -0.04673452f, 0.01794392f, -0.00517364f, 0.01272032f, 0.05809199f, 
    0.05602951f, 0.03155266f, 0.01203163f, 0.06758631f, -0.47857955f, -0.26868370f, -0.04913010f, 0.08603883f, 
    -0.04279103f, 0.05110822f, 0.05626139f, -0.29413083f, -0.10491438f, 0.02084305f, -0.24395005f, 0.08768307f, 
    -0.61460835f, -0.19417365f, 0.22533606f, 0.02589358f, -0.07539698f, -0.01391068f, -0.36836785f, -0.20298833f, 
    0.05163029f, -0.00315682f, 0.03837591f, 0.03062108f, 0.03656420f, -0.18341926f, -0.09572881f, -0.22925296f, 
    -0.02261023f, -0.07599436f, -0.07820145f, -0.00835472f, -0.15401068f, 0.08404718f, -0.09673537f, -0.03435295f, 
    -0.11913998f, -0.17921792f, 0.03937014f, -0.16847211f, 0.05197133f, 0.03601072f, -0.07042949f, -0.18979278f, 
    0.01168524f, 0.14712201f, 0.08658984f, -0.03277381f, 0.06738192f, 0.10275970f, 0.14960746f, -0.01451592f, 
    0.10343975f, -0.03325124f, -0.11443306f, 0.00746079f, 0.05385943f, -0.06713091f, -0.18173030f, -0.13062008f, 
    -0.13769184f, -0.28748980f, -0.12828892f, -0.00967445f, -0.05636519f, -0.12427662f, -0.26631013f, 0.06616812f, 
    -0.08771748f, 0.02031583f, 0.08290169f, 0.04086317f, 0.10496901f, 0.00122290f, -0.09061243f, 0.08230046f, 
    0.00240355f, 0.07404384f, -0.04895990f, 0.14209096f, -0.09093063f, 0.01162812f, -0.10395414f, 0.19170681f, 
    0.36444342f, 0.14627828f, 0.05307657f, 0.09420837f, -0.05946835f, -0.06528558f, 0.14051712f, 0.03461733f, 
    -0.10033732f, 0.02235748f, 0.00542843f, 0.14394639f, -0.35918260f, 0.07417909f, -0.22772759f, -0.19834800f, 
    -0.14615040f, -0.15949708f, -0.11087234f, -0.02432527f, -0.10906152f, -0.10778185f, 0.23640467f, -0.02907229f, 
    0.08074560f, 0.13490878f, -0.09095035f, 0.07232121f, -0.04117432f, -0.07564103f, 0.02652080f, 0.17691682f, 
    0.04842924f, -0.03217496f, -0.02740673f, 0.12891905f, 0.45667726f, -0.14892358f, 0.12927559f, 0.20134427f, 
    0.04989882f, -0.00654568f, 0.07993404f, 0.03715518f, 0.08604665f, -0.16543472f, 0.12280177f, 0.04927651f, 
    0.00442043f, -0.13736656f, 0.05034031f, -0.09311053f, 0.07513425f, 0.20541158f, -0.01594378f, 0.13180895f, 
    0.20503680f, 0.08349373f, 0.03301487f, 0.04563174f, -0.14694987f, -0.03880467f, -0.10827626f, -0.09148715f, 
    -0.15943858f, -0.08423749f, 0.13307942f, -0.05862140f, -0.02629615f, 0.03938029f, -0.10740823f, -0.14246656f, 
    0.14108688f, 0.12248376f, 0.10041281f, 0.06465352f, 0.07222512f, 0.03575636f, -0.05723547f, -0.08068682f, 
    0.03999083f, 0.08636606f, 0.00908122f, 0.07899340f, 0.00572665f, 0.01837750f, -0.02046729f, 0.10142748f, 
    0.03229088f, 0.07244138f, -0.07104629f, 0.10763401f, -0.06679043f, -0.12731203f, 0.12697327f, -0.07046419f, 
    -0.58296335f, -0.16787575f, 0.28027406f, -0.28248641f, -0.01186609f, 0.22350951f, -0.24501616f, -0.22099669f, 
    0.03176159f, 0.02603470f, -0.12321343f, 0.12632670f, -0.16596185f, -0.15189065f, 0.07964990f, -0.10981616f, 
    -0.00406056f, -0.02436377f, -0.05438906f, -0.00355303f, 0.04349361f, 0.17650573f, 0.05610770f, 0.26721320f, 
    -0.16357790f, -0.08539299f, -0.03234556f, -0.01407987f, -0.01616201f, 0.08742154f, -0.01540630f, 0.04354115f, 
    -0.02473624f, -0.05990633f, -0.09418513f, -0.29759848f, -0.05021479f, -0.00569208f, 0.03656261f, -0.00795059f, 
    0.06976435f, 0.12569734f, -0.08236133f, -0.05656615f, -0.19624491f, -0.16946888f, -0.07424778f, -0.08342931f, 
    -0.22538282f, 0.22226056f, 0.06357358f, 0.18159944f, 0.11069731f, -0.17157799f, 0.04879531f, -0.03633666f, 
    -0.11212057f, -0.01456691f, -0.02050885f, -0.07829659f, 0.07039214f, 0.33403894f, 0.07418226f, 0.33484969f, 
    -0.06880766f, 0.15789086f, 0.15516603f, -0.06508981f, 0.00516632f, 0.05959356f, 0.10573361f, 0.18809451f, 
    -0.01960763f, -0.09101226f, 0.19688573f, -0.03013138f, 0.00842876f, 0.08333292f, 0.03135738f, 0.00559462f, 
    0.08059589f, 0.03498595f, 0.18104167f, 0.10348529f, -0.16019611f, 0.05464317f, -0.01470823f, 0.10964004f, 
    -0.12339483f, -0.02586069f, 0.04403876f, -0.06966656f, 0.05127173f, 0.05293163f, 0.00785893f, -0.05033048f, 
    0.22238283f, 0.05526846f, 0.17986614f, 0.13896342f, -0.03953798f, -0.06940365f, 0.13032699f, 0.07853089f, 
    0.06194878f, -0.06030284f, 0.07796676f, -0.01072538f, 0.39441293f, 0.41695184f, 0.14515580f, 0.15827943f, 
    0.12226998f, 0.06775940f, -0.09571521f, 0.02665422f, -0.08689677f, 0.06828716f, -0.15922952f, 0.10509671f, 
    0.17927760f, 0.16303156f, -0.02959251f, -0.11695604f, -0.04720801f, -0.09359743f, 0.05436147f, 0.05536766f, 
    -0.03978412f, 0.07655259f, 0.00047083f, 0.10519037f, 0.42444918f, -0.07907179f, -0.05012873f, 0.02839408f, 
    0.06258408f, -0.00137340f, 0.07018228f, -0.08050334f, 0.01181907f, 0.10052259f, 0.13265297f, 0.10745323f, 
    -0.27532691f, -0.07274371f, 0.17630991f, -0.01252860f, -0.00960893f, -0.01122958f, -0.09601659f, -0.05832804f, 
    0.03667374f, -0.00919455f, 0.02191289f, -0.02256409f, -0.43358517f, -0.16240607f, -0.08251482f, -0.20548135f, 
    -0.23242305f, 0.00220981f, -0.05864813f, 0.00749429f, -0.02159601f, -0.03947652f, -0.00760789f, 0.08365892f, 
    0.24903651f, 0.14910387f, 0.16480994f, 0.15297841f, 0.07344282f, -0.00038755f, 0.21725404f, 0.01840170f, 
    0.00547690f, -0.15333161f, 0.05960244f, 0.03973112f, -0.01523448f, -0.12273999f, 0.30807355f, -0.00514464f, 
    -0.02033611f, -0.03382990f, -0.22545357f, -0.18676332f, 0.07389705f, 0.04058662f, -0.10458148f, 0.24695706f, 
    -0.13310772f, 0.08292434f, -0.06911100f, -0.15426432f, 0.03309475f, 0.12071101f, 0.01392097f, 0.07171077f, 
    0.11385637f, 0.07989293f, 0.18559594f, 0.09910968f, 0.05033959f, 0.17465340f, 0.05913039f, 0.03791904f, 
    -0.00425944f, -0.02612119f, 0.01563017f, 0.11725014f, -0.04224488f, 0.00742658f, -0.07340492f, -0.23453408f, 
    -0.17556085f, -0.11964545f, -0.13580431f, 0.03326397f, -0.14935988f, -0.06157722f, 0.18260363f, -0.03941749f, 
    0.05037854f, 0.09120435f, 0.11483569f, 0.23978230f, 0.21386556f, 0.18227607f, -0.14052795f, 0.24085186f, 
    0.06104985f, 0.06414877f, -0.01285603f, 0.03548539f, -0.08133996f, 0.00536727f, -0.10643460f, -0.01671518f, 
    0.16872917f, 0.07718856f, 0.10229914f, 0.08424331f, 0.07729047f, -0.00028279f, -0.07282850f, -0.11889596f, 
    0.02393222f, 0.05859334f, 0.06041422f, -0.08552579f, 0.31197214f, 0.12710953f, 0.15698104f, 0.06735106f, 
    0.00284657f, -0.02485655f, 0.14327031f, 0.05593453f, -0.00324092f, -0.05156461f, -0.06872392f, -0.06845369f, 
    -0.03908721f, -0.05334562f, -0.11015306f, -0.03701321f, -0.10339519f, -0.09510213f, -0.07295310f, 0.14536089f, 
    -0.03965137f, -0.19667938f, -0.12456906f, -0.25955307f, -0.12223141f, -0.37674204f, 0.07601795f, 0.11764547f, 
    0.03943756f, -0.09679752f, -0.07329979f, -0.13412558f, 0.01074512f, 0.02966595f, -0.10226964f, 0.05714054f, 
    0.00354702f, -0.32154694f, 0.14444776f, -0.00207008f, -0.09157025f, -0.13384500f, -0.00255094f, -0.25113922f, 
    -0.03535616f, -0.06062139f, -0.10119768f, -0.11583064f, -0.03208959f, 0.09341185f, 0.11793568f, -0.05844339f, 
    0.01130996f, -0.08465419f, 0.01277418f, -0.03751182f, 0.01546742f, -0.04469134f, 0.18818977f, 0.11080149f, 
    -0.28169858f, 0.05850042f, 0.05623293f, -0.20888126f, 0.01141445f, 0.06196078f, -0.05788296f, -0.07218444f, 
    0.03919985f, 0.10590496f, 0.10690075f, 0.19882150f, 0.09858824f, 0.06666087f, 0.05781099f, 0.04525098f, 
    0.00439123f, -0.00943444f, 0.04079740f, 0.03392855f, -0.00431495f, 0.04872908f, 0.16951926f, 0.10940745f, 
    -0.19391727f, 0.16860472f, -0.15794285f, -0.01004375f, -0.03756121f, -0.14498745f, -0.09885794f, -0.07244766f, 
    0.04427709f, 0.04596195f, -0.19705330f, -0.09485570f, -0.03086977f, -0.14980076f, -0.05341479f, -0.36356893f, 
    -0.03324682f, 0.07198904f, -0.12931655f, 0.03690670f, -0.16557677f, -0.02683514f, 0.03111566f, -0.08345333f, 
    0.16870739f, 0.01207388f, 0.01528339f, 0.11536463f, 0.05072135f, 0.06455903f, -0.04264749f, -0.00818532f, 
    0.11700200f, 0.07039016f, 0.03570802f, 0.10101928f, -0.40831605f, -0.00740466f, -0.02508983f, -0.02240646f, 
    -0.10825735f, -0.05176640f, 0.11025066f, -0.10042740f, -0.00767406f, 0.01897624f, 0.07182384f, 0.21051174f, 
    0.06350742f, 0.25795180f, -0.18869686f, 0.06928314f, 0.08453500f, 0.01183654f, 0.00037786f, 0.21279418f, 
    0.03817872f, 0.09820203f, -0.21740937f, -0.04866073f, -0.13316712f, 0.12437495f, -0.35706034f, -0.01698041f, 
    0.06296591f, 0.00617220f, 0.01924007f, -0.12882258f, -0.12965040f, 0.01617735f, -0.03454306f, -0.02230466f, 
    -0.12270274f, -0.01027045f, 0.07367874f, 0.10884044f, 0.21405257f, 0.04617225f, -0.00561551f, -0.28250989f, 
    -0.14915144f, -0.09967321f, 0.01052172f, -0.11012288f, 0.06308629f, -0.31606182f, 0.12911548f, -0.11795132f, 
    -0.16593914f, 0.01754089f, -0.10020704f, -0.10797903f, -0.07437347f, 0.19506887f, -0.10361532f, 0.02597607f, 
    -0.01554922f, -0.03322566f, 0.00282226f, -0.10588486f, 0.03069163f, -0.08481165f, -0.06868035f, -0.02065123f, 
    -0.09594147f, -0.01811394f, -0.01754594f, 0.00132682f, -0.10012947f, -0.05733560f, -0.26142925f, -0.19092876f, 
    -0.03632206f, -0.02434593f, 0.02438626f, -0.12108122f, -0.01330342f, -0.02513387f, 0.00256046f, -0.07720075f, 
    -0.01576462f, -0.00072946f, -0.02994497f, -0.01749092f, -0.00506085f, -0.00288592f, -0.04087854f, 0.02840795f, 
    0.00196635f, 0.00080588f, -0.02524721f, 0.01649803f, 0.01106328f, 0.02237473f, 0.01274609f, -0.03039996f, 
    -0.00144536f, -0.01408340f, -0.02505370f, 0.00821550f, -0.00492102f, -0.02975933f, -0.00183619f, -0.01103961f, 
    0.00657779f, -0.02362920f, -0.02838112f, 0.01999626f, -0.01983876f, -0.01240940f, 0.01229418f, -0.02829751f, 
    -0.03175338f, -0.00420651f, -0.03692149f, -0.02098633f, -0.03936668f, -0.00993488f, 0.00840940f, -0.03861260f, 
    -0.00919269f, -0.04148489f, -0.01092418f, -0.01146903f, -0.00729859f, -0.02690128f, -0.04182428f, 0.00102942f, 
    -0.00932965f, -0.02332265f, -0.01103765f, -0.03759610f, -0.00648330f, 0.01099823f, -0.00402904f, 0.01936710f, 
    0.01184298f, 0.02938015f, -0.00170497f, -0.00376549f, 0.01399089f, -0.00154217f, -0.03525430f, -0.03227133f, 
    -0.01657747f, 0.02262117f, -0.00740787f, -0.03845154f, -0.02008756f, 0.02844932f, 0.01462622f, -0.02548134f, 
    -0.01063424f, 0.00670271f, -0.03205924f, -0.01918904f, -0.01879022f, -0.00035211f, -0.03543809f, -0.02411736f, 
    0.00340822f, 0.02642022f, 0.01887391f, 0.01239044f, -0.04110986f, 0.01540431f, -0.03172835f, -0.00026432f, 
    -0.00141387f, -0.00535213f, 0.02579271f, -0.03506722f, 0.01378036f, -0.03585889f, 0.02630343f, -0.01545344f, 
    0.01590041f, -0.01962124f, 0.00775487f, 0.00868062f, -0.02407326f, 0.00195925f, -0.02044263f, -0.00072325f, 
    -0.04088243f, -0.00455704f, 0.02996738f, 0.02562168f, 0.01010522f, -0.02959931f, 0.01914655f, 0.02319039f, 
    -0.02840352f, 0.00954512f, 0.00244134f, -0.03419496f, 0.01205372f, 0.02589575f, -0.01553512f, -0.03547576f, 
    -0.01442930f, -0.01608494f, -0.00707999f, 0.00926844f, -0.02800271f, 0.02640927f, -0.03777497f, -0.02465046f, 
    -0.02094790f, 0.01635838f, 0.02629220f, -0.03916938f, -0.02995194f, 0.01048745f, -0.00890454f, -0.02236917f, 
    0.02319204f, -0.01344912f, -0.01989498f, 0.02611135f, -0.02330089f, -0.03000921f, 0.00231198f, -0.02726383f, 
    -0.00787460f, -0.04081683f, -0.04054983f, -0.03775662f, -0.02755456f, -0.00403763f, 0.01277846f, 0.01968806f, 
    -0.00671615f, -0.01717943f, -0.00344154f, -0.03211069f, -0.01518846f, -0.02234064f, -0.03155728f, -0.02531982f, 
    0.00149619f, 0.01384556f, -0.01099222f, -0.03401377f, -0.03093131f, -0.00260566f, 0.02632165f, -0.03899911f, 
    -0.00345583f, 0.02018083f, 0.02062250f, 0.00376732f, -0.02281782f, -0.00360244f, -0.00548943f, 0.02117673f, 
    -0.02478541f, 0.02389435f, 0.00579306f, -0.02429394f, 0.02296730f, -0.01984534f, -0.03265873f, -0.01862629f, 
    -0.03653454f, -0.02358451f, -0.00986663f, 0.01773018f, -0.03075197f, 0.00189006f, 0.01396756f, -0.00238296f, 
    -0.03685087f, -0.04058282f, 0.02519918f, 0.01827178f, -0.02390509f, -0.00979332f, 0.00068312f, -0.00342492f, 
    0.02026098f, -0.03648574f, -0.00199129f, -0.00464649f, -0.00857061f, -0.02724924f, -0.02859501f, 0.02338454f, 
    0.00519072f, -0.03381238f, -0.02157949f, -0.01916812f, 0.00030479f, 0.02259652f, -0.01501910f, -0.02243567f, 
    -0.03755676f, -0.02205648f, -0.00780748f, 0.01312215f, -0.02054365f, -0.01748561f, -0.02442938f, -0.00006228f, 
    0.01081510f, 0.02191312f, -0.01110486f, -0.01118234f, -0.01730241f, 0.01684575f, -0.01323065f, 0.02760783f, 
    0.00470526f, 0.02848959f, 0.01473937f, 0.02264591f, -0.00934901f, 0.00747886f, -0.03101666f, -0.00696282f, 
    0.00092375f, -0.02404328f, -0.00657455f, 0.00826906f, -0.00353371f, -0.04069295f, 0.01184364f, 0.00854846f, 
    -0.01262562f, 0.00851997f, 0.00310513f, 0.00742679f, 0.00051082f, 0.01862283f, -0.02553492f, -0.03635352f, 
    0.02764279f, -0.00804214f, 0.01260015f, -0.01173329f, -0.02742774f, -0.01235683f, -0.03936901f, -0.03654834f, 
    0.02938915f, -0.01521042f, -0.02146307f, -0.03127265f, 0.01206503f, -0.02111455f, -0.02704836f, 0.02167879f, 
    -0.01093766f, 0.00726555f, 0.02040593f, 0.00337459f, -0.02681260f, -0.02746882f, -0.02181761f, 0.02973687f, 
    0.01481460f, 0.00718370f, -0.03386169f, -0.00242754f, -0.03437391f, 0.02503185f, 0.00665843f, 0.02364041f, 
    -0.00739995f, -0.01507880f, -0.01078136f, -0.01492243f, -0.02757890f, -0.03066713f, -0.02385193f, -0.03580543f, 
    0.01384612f, -0.02446561f, 0.01810084f, -0.01648084f, -0.01265956f, -0.01655246f, 0.00510393f, -0.00549861f, 
    -0.02099273f, -0.03674861f, 0.00640618f, -0.01089705f, 0.01526214f, 0.01956259f, -0.03674811f, -0.00783199f, 
    -0.02470855f, -0.01219673f, 0.01401871f, 0.02534696f, -0.00083549f, -0.02647783f, 0.02228553f, -0.03284322f, 
    0.02395489f, 0.00887945f, 0.02914272f, -0.02553856f, 0.01305311f, 0.02026781f, 0.00675583f, -0.02192893f, 
    0.00154317f, -0.00632180f, -0.02354758f, 0.02245597f, 0.02314311f, -0.02206951f, 0.01442141f, -0.01456686f, 
    0.01544304f, 0.00642106f, 0.00219969f, -0.02080293f, -0.01191435f, 0.02682759f, -0.00953326f, -0.01221441f, 
    -0.03420391f, -0.02359869f, 0.01341700f, -0.01091368f, 0.02934776f, -0.00279985f, 0.01866408f, 0.00465218f, 
    -0.00184711f, -0.03872844f, -0.00900286f, -0.03278827f, -0.01383307f, -0.02541822f, 0.00265847f, -0.02813642f, 
    0.00503023f, 0.02196052f, -0.01466377f, 0.00960827f, -0.02469213f, -0.00869657f, -0.00562782f, -0.03754350f, 
    0.01658216f, -0.01958309f, 0.00033235f, -0.01104411f, -0.01053758f, 0.02179767f, -0.02868181f, -0.02566514f, 
    0.02406803f, -0.02816076f, -0.02539022f, -0.00807724f, -0.00516676f, 0.02389113f, -0.02541534f, -0.04127898f, 
    -0.01655990f, -0.01904993f, 0.01048065f, 0.01502752f, 0.00427773f, 0.00086607f, 0.00806334f, -0.02765052f, 
    -0.02427147f, -0.04140027f, 0.01317130f, -0.00265962f, 0.01785254f, 0.02454695f, 0.00050826f, -0.00894332f, 
    0.01739352f, 0.00933264f, 0.02042203f, -0.00837052f, -0.03592806f, -0.00257973f, -0.00555209f, 0.00982224f, 
    0.01874595f, 0.01253482f, 0.02570957f, 0.00427911f, 0.01148903f, 0.00426114f, -0.00743462f, -0.01826100f, 
    0.01798381f, -0.02091016f, -0.03055798f, -0.03661327f, -0.02501441f, 0.01805710f, 0.00521458f, -0.03678022f, 
    -0.03800439f, -0.02152618f, -0.00483970f, -0.00704241f, -0.01169712f, -0.00785267f, -0.00309944f, 0.00072503f, 
    0.01532872f, 0.02218289f, -0.02074630f, -0.02053991f, 0.02400170f, 0.02002884f, -0.03030031f, -0.03106107f, 
    -0.02935557f, 0.00726376f, 0.02604262f, 0.02740565f, 0.02451768f, 0.01911039f, 0.00342571f, -0.03653769f, 
    -0.01912942f, 0.00458160f, 0.01635112f, 0.02285209f, -0.02632457f, 0.00544766f, -0.00542926f, -0.00153275f, 
    0.00306881f, -0.03083605f, -0.00183698f, -0.01787339f, 0.01846717f, 0.02130545f, -0.03579647f, 0.02204672f, 
    -0.03491333f, -0.00555942f, -0.01459466f, 0.02671699f, -0.00375325f, 0.01683815f, -0.04142398f, 0.00941395f, 
    -0.03052871f, 0.02098058f, 0.02345399f, 0.00979313f, -0.00187658f, -0.03425362f, -0.03665136f, -0.00636112f, 
    0.02814778f, -0.03024975f, 0.02701385f, 0.02188957f, -0.02795965f, 0.00155608f, -0.01613118f, -0.00652887f, 
    0.01883311f, -0.01983442f, -0.01788552f, -0.01951731f, -0.03310169f, -0.00962024f, 0.01082672f, 0.00858240f, 
    -0.00135185f, 0.00549195f, -0.03330218f, -0.01419309f, -0.01573835f, -0.00255925f, -0.01002908f, 0.02528103f, 
    -0.02004946f, 0.02562897f, 0.00337657f, 0.00933670f, 0.01894521f, -0.00206346f, 0.02888799f, -0.03969960f, 
    -0.01074508f, 0.02805276f, -0.03247736f, 0.01984197f, -0.01923133f, 0.01151225f, 0.00995315f, -0.03697456f, 
    -0.03785300f, -0.03012056f, -0.00753915f, -0.02600358f, 0.02085017f, -0.04042259f, 0.01960194f, -0.00037636f, 
    -0.02642241f, 0.00476070f, 0.00408377f, -0.01227979f, -0.00055098f, -0.03579982f, -0.01675271f, 0.02240173f, 
    -0.03914159f, 0.01607234f, -0.00017054f, 0.01605026f, 0.00571411f, 0.02084547f, 0.00248430f, 0.00767437f, 
    -0.01657610f, 0.02692131f, 0.00722788f, 0.02988601f, -0.01977635f, -0.01239428f, 0.02373980f, 0.00702447f, 
    -0.02602891f, 0.00939342f, -0.01531320f, -0.02651935f, -0.01158130f, 0.00658932f, -0.01511828f, 0.02430282f, 
    -0.01943592f, -0.00120182f, -0.04025208f, 0.00808962f, 0.01732989f, -0.02171683f, -0.01508270f, -0.03583786f, 
    -0.00578378f, 0.00240449f, -0.01128065f, 0.01756761f, -0.00621405f, -0.00248428f, 0.01620304f, -0.00262650f, 
    -0.00296462f, 0.02272998f, -0.01462574f, -0.00408226f, -0.03497997f, 0.01958608f, -0.01717205f, -0.03808111f, 
    -0.03190251f, 0.01755568f, 0.00277658f, -0.03067110f, -0.04106776f, -0.03432547f, -0.01105565f, -0.00436733f, 
    -0.00909937f, -0.01523961f, -0.01810852f, -0.03146614f, 0.02835459f, -0.00163929f, -0.03525732f, 0.00348577f, 
    -0.04119468f, -0.02683679f, -0.00395369f, -0.03450725f, 0.00950820f, -0.03922887f, 0.02422503f, -0.00443684f, 
    -0.02612119f, -0.02672607f, -0.01309858f, 0.02744288f, 0.00446144f, 0.01855457f, -0.01344914f, -0.01565291f, 
    -0.01521819f, -0.01383525f, -0.02069073f, -0.01475830f, 0.00622843f, 0.02818687f, 0.02340258f, -0.02324316f, 
    -0.00408862f, -0.00475452f, 0.01075630f, -0.01497233f, -0.02094656f, -0.02610144f, 0.02399232f, 0.02733914f, 
    0.01313536f, -0.03723793f, 0.00181477f, 0.02378883f, -0.01358812f, -0.01652338f, -0.03101784f, 0.01417959f, 
    0.00134962f, -0.01992937f, -0.02106255f, 0.02195909f, -0.02917770f, -0.01803072f, -0.03726140f, 0.01555520f, 
    -0.01684318f, -0.04190485f, 0.01799069f, 0.01073987f, -0.01722361f, -0.00501194f, -0.01107216f, -0.02473226f, 
    -0.00506904f, -0.03704622f, -0.00629538f, -0.04157343f, -0.01522952f, 0.01418347f, -0.00345388f, -0.02150742f, 
    -0.02010097f, -0.00841066f, -0.02371739f, -0.01491444f, -0.00109129f, 0.02353799f, -0.03970503f, -0.01486121f, 
    -0.02458281f, -0.02389729f, -0.00407732f, -0.01078191f, -0.00059265f, -0.02923446f, -0.00475820f, 0.02383875f, 
    -0.00003866f, 0.02875128f, 0.02005144f, -0.00445295f, -0.00901020f, -0.02794190f, -0.01562904f, 0.02099951f, 
    -0.03143470f, 0.03006298f, -0.01472475f, -0.04030719f, 0.00182491f, 0.00080024f, 0.00187702f, -0.00652179f, 
    -0.00451211f, -0.00068166f, -0.02551953f, 0.00320370f, -0.04196852f, -0.04083517f, -0.00706462f, -0.00711920f, 
    0.01966223f, 0.00489807f, 0.01835034f, 0.00004892f, -0.03863393f, -0.03377294f, -0.03619549f, -0.00237241f, 
    0.00920576f, 0.01325675f, -0.03378021f, 0.01444272f, -0.03520267f, -0.02260341f, -0.00764306f, -0.01820692f, 
    -0.03342496f, -0.00726402f, -0.01189099f, 0.01924252f, -0.02785175f, 0.00262327f, -0.02070805f, -0.02822837f, 
    0.01906672f, -0.03710428f, -0.00528958f, 0.01770129f, -0.01283116f, -0.03165476f, -0.01266185f, -0.03560709f, 
    0.00778449f, -0.02253895f, 0.02740080f, -0.03197370f, 0.02512202f, -0.00359419f, -0.01133412f, -0.00046658f, 
    -0.00808287f, -0.03172951f, 0.01620501f, 0.02249791f, -0.02140605f, -0.03438542f, 0.01126112f, 0.00648463f, 
    -0.04139769f, -0.01724221f, -0.00806231f, 0.00971586f, 0.01114548f, -0.02651168f, -0.01481145f, -0.02603864f, 
    0.00009000f, -0.02107338f, -0.04155686f, -0.03859660f, 0.00576867f, -0.00018636f, 0.02748248f, 0.00760512f, 
    0.03846177f, -0.00019185f, 0.02732632f, 0.03865528f, 0.03652126f, -0.00126172f, 0.05830350f, 0.01583621f, 
    -0.00322192f, -0.08888653f, -0.00413438f, 0.04176217f, -0.27453890f, -0.11766520f, 0.11229903f, -0.04022062f, 
    -0.04122857f, -0.06116462f, -0.17870308f, -0.05254294f, -0.03982816f, -0.00085502f, -0.09841031f, 0.03440828f, 
    0.07416592f, 0.09467003f, 0.10908242f, 0.04824446f, -0.05424523f, -0.02418544f, -0.10124524f, 0.02695024f, 
    0.02186342f, 0.00191423f, 0.05110617f, -0.02813972f, 0.20632111f, 0.03229442f, 0.17550038f, 0.08290623f, 
    -0.07233207f, -0.10222922f, -0.08453882f, -0.06539270f, 0.06526031f, -0.08397161f, -0.19666864f, -0.02997697f, 
    -0.06729635f, 0.04103597f, -0.06833386f, -0.09722518f, 0.06847580f, 0.09757348f, -0.02174483f, 0.14121284f, 
    0.00481543f, 0.01472380f, 0.01462059f, -0.05700586f, 0.19786671f, 0.29075453f, 0.19158138f, -0.00130269f, 
    -0.04318086f, -0.17006204f, -0.04516754f, 0.03386471f, 0.05986478f, 0.18808874f, -0.04726457f, -0.00943275f, 
    0.00488876f, -0.02987739f, -0.10760094f, -0.01205833f, 0.08370909f, -0.05489904f, 0.01012764f, 0.15555750f, 
    -0.02126828f, 0.01062725f, -0.07038056f, 0.08196957f, 0.00812646f, -0.05319287f, 0.17070656f, 0.26181334f, 
    -0.02127869f, 0.01877855f, -0.03367377f, -0.09606885f, -0.05615759f, -0.09431895f, -0.02976069f, 0.05771525f, 
    -0.09207239f, -0.02007919f, 0.24134797f, 0.21982560f, -0.04638835f, 0.03489584f, -0.01914702f, 0.00019685f, 
    0.25667951f, -0.01066598f, -0.09118094f, 0.16387130f, -0.22300929f, -0.15006480f, 0.02536477f, 0.00509556f, 
    -0.05339795f, 0.17336915f, 0.06205070f, -0.10219134f, 0.06517984f, -0.07079601f, -0.06604347f, 0.13601133f, 
    0.13153630f, 0.11799832f, 0.11837073f, -0.00086859f, 0.12424520f, -0.09748182f, 0.09172907f, 0.14571202f, 
    0.02447956f, 0.04898134f, 0.01567290f, -0.07544525f, -0.21884404f, -0.02719256f, -0.12164386f, 0.06316723f, 
    -0.04889845f, -0.04841583f, 0.12538762f, 0.12522085f, -0.04629013f, -0.05127037f, 0.02327472f, 0.05814551f, 
    -0.13470179f, -0.11239626f, -0.14108378f, 0.16219318f, 0.00398950f, 0.03883318f, 0.04980912f, -0.02050049f, 
    -0.03685264f, -0.08014238f, -0.00629705f, -0.05571271f, 0.15358961f, -0.05406599f, 0.17849031f, 0.08292401f, 
    -0.06381772f, 0.01366547f, -0.02512933f, -0.00338118f, -0.01347216f, 0.03401777f, 0.01652499f, 0.08052251f, 
    0.10420460f, -0.08517816f, -0.06251829f, 0.10118441f, -0.03868139f, -0.14799634f, -0.02945616f, 0.04139905f, 
    -0.05522697f, 0.13488674f, -0.02613423f, 0.08160467f, 0.03299356f, -0.17002550f, 0.00062367f, 0.40359646f, 
    0.01766094f, 0.13263302f, 0.00171941f, -0.09101330f, 0.06994288f, -0.09054234f, 0.09334513f, 0.07401936f, 
    -0.02513279f, -0.20819420f, 0.08895212f, 0.08303688f, 0.06041227f, 0.06964826f, 0.07699109f, -0.00145621f, 
    0.00038421f, -0.04209376f, -0.12605859f, 0.05243235f, 0.03620632f, 0.11796764f, 0.25054988f, -0.25182852f, 
    -0.00096824f, -0.02748050f, 0.00417373f, -0.14210054f, 0.04230632f, -0.03482358f, 0.01032711f, -0.01809538f, 
    0.37150213f, 0.29834193f, 0.20463866f, 0.05459273f, -0.00404503f, -0.11006967f, -0.17323899f, -0.08406840f, 
    -0.12747315f, -0.09742503f, 0.09183753f, -0.05129426f, 0.14189729f, -0.08825091f, -0.01604865f, 0.01356057f, 
    0.16152056f, 0.02111573f, -0.05231854f, 0.12141302f, 0.00901276f, 0.00776266f, -0.09921166f, -0.08124074f, 
    0.25304660f, -0.40934676f, -0.05598628f, 0.06784004f, 0.07552459f, 0.19087772f, -0.08899609f, 0.02096903f, 
    0.09249721f, 0.01325077f, 0.14491518f, -0.04486966f, 0.09600712f, 0.40722302f, 0.08405735f, -0.07432522f, 
    0.04241357f, -0.14298968f, -0.15220703f, -0.05213184f, -0.05921017f, -0.10944521f, -0.04141521f, 0.05127237f, 
    0.05164289f, 0.13014416f, -0.14494532f, -0.01070234f, 0.15610336f, -0.08685428f, 0.07673889f, 0.13553075f, 
    -0.08716579f, 0.07232083f, 0.01059952f, -0.09514675f, 0.22967285f, 0.12005302f, -0.07047894f, -0.08917765f, 
    0.00919027f, 0.12620777f, -0.19266455f, 0.19775794f, -0.07067513f, 0.03496064f, -0.05085981f, -0.14384392f, 
    0.04677504f, -0.02562559f, 0.01666405f, -0.24200939f, 0.05058454f, -0.14670919f, -0.04875902f, 0.07554201f, 
    0.04110650f, 0.06211580f, 0.01229310f, 0.11367334f, -0.14026186f, 0.35619760f, -0.11955561f, -0.16228136f, 
    0.01734061f, 0.09372937f, 0.12216898f, -0.00343706f, -0.04354979f, -0.10437645f, -0.06480765f, -0.00590830f, 
    -0.11052991f, 0.06467708f, -0.10843547f, -0.06849693f, -0.05679051f, 0.04519317f, 0.10229994f, -0.00649408f, 
    -0.01301248f, 0.03292223f, 0.05596716f, 0.12511334f, -0.00901072f, -0.11095206f, -0.06918426f, 0.08258027f, 
    -0.00621367f, -0.08959858f, 0.10956197f, -0.09380852f, 0.12523752f, -0.13855767f, 0.11204728f, 0.18601206f, 
    0.06208642f, 0.12479920f, -0.09531200f, -0.03542917f, -0.18098062f, -0.01169309f, 0.09057092f, 0.07541940f, 
    -0.04050133f, 0.00858974f, -0.01458315f, -0.12107723f, -0.00712638f, 0.09165043f, -0.06386207f, -0.09733102f, 
    0.04467227f, -0.01753867f, 0.01978520f, -0.12894556f, 0.02160615f, -0.08295204f, -0.00791155f, -0.04374003f, 
    0.04148683f, -0.46887985f, 0.36986569f, 0.01484492f, 0.09172384f, 0.20252658f, -0.14474973f, 0.10231625f, 
    -0.04447018f, -0.11394664f, -0.03275660f, -0.05173492f, -0.03237726f, 0.25642905f, 0.14759228f, -0.00762833f, 
    -0.09196404f, -0.17237359f, -0.18048516f, -0.08522604f, 0.07366131f, 0.08439373f, 0.02482844f, -0.02630307f, 
    0.02609793f, 0.18652421f, 0.08631912f, -0.03848698f, -0.05374986f, -0.11968761f, -0.01856446f, 0.06574742f, 
    -0.05366736f, 0.15798007f, 0.05948568f, -0.04225186f, -0.14278017f, -0.20790854f, 0.02728617f, -0.01503074f, 
    0.15036784f, 0.01803864f, -0.03607463f, 0.05198748f, -0.08856715f, -0.01334530f, 0.00007959f, -0.03305249f, 
    0.19886245f, 0.09763104f, -0.17978266f, -0.00586654f, 0.03510976f, -0.14084251f, -0.11639082f, 0.14291900f, 
    0.04754316f, 0.03297241f, -0.02644148f, -0.17047383f, -0.18300080f, 0.28796414f, 0.12235205f, 0.23604247f, 
    -0.16766723f, -0.02789304f, 0.04713236f, -0.22467636f, -0.03946482f, -0.20583530f, -0.10489994f, -0.05319190f, 
    0.09784764f, -0.37740514f, 0.25523019f, 0.05545007f, -0.06461399f, 0.10669127f, -0.32057282f, -0.14280476f, 
    0.16108046f, 0.01622556f, 0.07541782f, 0.11206594f, 0.24212086f, 0.06521699f, 0.27517787f, 0.13758002f, 
    -0.00528371f, -0.10174924f, -0.19622239f, -0.02886373f, 0.00744664f, 0.02353660f, 0.11411259f, -0.02818255f, 
    -0.10155358f, 0.03525029f, -0.18918619f, -0.00339568f, 0.02871866f, 0.07231002f, 0.20855841f, 0.07180489f, 
    0.00360448f, -0.10968287f, -0.05408669f, -0.02070683f, -0.01455949f, -0.18453331f, -0.22395262f, -0.06006816f, 
    -0.09094368f, 0.00596358f, -0.07244856f, 0.10016565f, 0.01875862f, 0.10603438f, -0.14761302f, 0.04809447f, 
    -0.08688473f, -0.09588132f, 0.12222479f, -0.07104474f, 0.13249941f, -0.09354724f, -0.12791124f, -0.09109645f, 
    -0.00477825f, 0.03464428f, -0.07134777f, -0.11597526f, -0.11320215f, 0.20858319f, -0.21451963f, 0.00056019f, 
    0.13756846f, -0.14176199f, 0.13317665f, -0.08847087f, 0.05208752f, -0.14158131f, -0.06394175f, 0.07058742f, 
    -0.01903355f, 0.20046641f, -0.14644669f, -0.12257096f, 0.02159784f, -0.14069498f, 0.04088821f, -0.02945725f, 
    0.06549832f, 0.15029228f, -0.21222869f, 0.14992429f, -0.02937836f, 0.20682648f, 0.10920684f, 0.12392892f, 
    -0.03632225f, -0.01966199f, 0.05551142f, 0.00619885f, -0.06010565f, -0.07783886f, -0.00523946f, -0.05135126f, 
    -0.04060827f, -0.12321416f, 0.03550914f, 0.01777442f, 0.08094823f, 0.11575368f, -0.09175768f, 0.01173308f, 
    0.04409280f, -0.10994846f, -0.03781416f, 0.23987955f, 0.05492193f, -0.01641040f, -0.14767338f, -0.03441982f, 
    -0.09369097f, 0.10195178f, -0.01235001f, 0.04529501f, 0.03689367f, 0.03349556f, -0.01291479f, -0.01931775f, 
    -0.08105628f, 0.14336516f, -0.02546885f, -0.00934387f, -0.01232534f, 0.07711795f, 0.15666546f, -0.02627063f, 
    0.08972891f, -0.06364517f, -0.07411199f, -0.07116485f, 0.01914966f, 0.02658052f, -0.11182569f, 0.06900740f, 
    0.01360829f, -0.03606468f, 0.00960514f, 0.23265862f, 0.02215150f, -0.02472510f, -0.00911624f, 0.00125328f, 
    -0.08706372f, -0.08068622f, -0.02560678f, 0.06099093f, 0.05761843f, 0.12460136f, 0.15484002f, 0.16121086f, 
    -0.02124575f, -0.07326101f, -0.03670670f, -0.12198090f, -0.04284887f, 0.19887286f, -0.10866452f, 0.11751053f, 
    0.00393396f, -0.01292292f, 0.03692524f, -0.05948130f, 0.04999265f, 0.02744536f, 0.02765914f, -0.09761440f, 
    -0.11684857f, 0.08697984f, -0.11458964f, 0.20171413f, 0.13224365f, 0.03920748f, 0.06785185f, 0.07236102f, 
    0.06723822f, -0.10901831f, 0.03255301f, -0.16035753f, 0.10522360f, -0.20854473f, 0.17999059f, 0.10113367f, 
    -0.06690411f, 0.10539396f, -0.17075141f, 0.02066351f, 0.15279405f, 0.01320521f, -0.00784718f, 0.05060605f, 
    -0.04288494f, 0.01451330f, -0.14999186f, -0.11009299f, -0.01269342f, -0.18480505f, 0.10282315f, 0.01012394f, 
    0.06755213f, 0.20592989f, -0.05910035f, -0.10812403f, -0.06880164f, -0.01084424f, 0.12368627f, -0.05663648f, 
    -0.01968602f, -0.10401317f, -0.07777270f, -0.02586794f, -0.02938435f, -0.04725688f, -0.07126050f, 0.22689661f, 
    -0.31932837f, -0.06481736f, 0.14250483f, 0.01518078f, 0.20403849f, 0.08183464f, -0.00361710f, 0.09490959f, 
    -0.18944012f, -0.08238841f, -0.02155647f, -0.02503968f, 0.07093203f, -0.05527537f, 0.06077333f, 0.05659362f, 
    0.01479809f, -0.00632705f, -0.03805302f, -0.05986685f, 0.04771419f, -0.02405376f, -0.11512333f, 0.04763806f, 
    0.06707924f, 0.09592509f, 0.10931166f, 0.06982277f, -0.08382700f, 0.02584459f, -0.10468218f, 0.05751509f, 
    0.02619279f, -0.02001344f, -0.00520155f, 0.08726739f, 0.07353292f, 0.12744993f, 0.11002283f, -0.21630505f, 
    -0.04354310f, -0.05625543f, -0.05187206f, 0.15570590f, -0.07619903f, 0.06765790f, -0.04122415f, 0.02253055f, 
    -0.00464614f, 0.39282748f, 0.07341663f, -0.04892994f, -0.02262908f, -0.03662024f, 0.04837687f, -0.03013609f, 
    0.01804881f, -0.14810587f, -0.01390597f, 0.06020474f, -0.05173932f, 0.25720814f, 0.32247627f, 0.39884618f, 
    -0.13541786f, 0.01322991f, 0.01170528f, -0.11791194f, -0.01085267f, 0.03073095f, 0.07779983f, -0.01356677f, 
    -0.13959295f, -0.09973624f, 0.01966889f, 0.01506947f, 0.04769734f, 0.10542022f, 0.06899935f, -0.00333410f, 
    -0.02856385f, -0.12398202f, -0.04160403f, -0.06411345f, 0.05967024f, 0.00577336f, 0.12794814f, -0.02891108f, 
    -0.02847364f, -0.03291538f, -0.00626707f, 0.00382373f, -0.01863589f, 0.04427927f, -0.02866898f, -0.05104489f, 
    0.11210366f, 0.01401499f, -0.18736723f, 0.00554394f, -0.03950991f, 0.14638570f, 0.12274840f, 0.17093012f, 
    0.05637567f, -0.03549966f, -0.03388249f, -0.05652014f, -0.01448997f, 0.08942410f, 0.11968995f, -0.01701578f, 
    -0.08072769f, 0.04801723f, -0.08752262f, -0.05235673f, -0.05297462f, -0.13725053f, -0.08545566f, -0.06690121f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03508727f, -0.03548688f, 0.00494284f, -0.03153358f, 0.13795182f, -0.01196183f, 0.07817873f, -0.00937334f, 
    -0.05526488f, 0.01341282f, 0.05434956f, 0.01904545f, 0.04975273f, 0.00946787f, 0.01306573f, 0.11361694f, 
    -0.03601243f, 0.09681763f, -0.02016006f, 0.02347991f, -0.02623319f, 0.04833434f, 0.14124610f, 0.00452823f, 
    0.05040024f, 0.12599780f, 0.00112220f, 0.12488560f, -0.08191764f, -0.04673925f, -0.02127352f, 0.07177956f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.12942201f, 0.15175097f, 0.32357049f, -0.01353616f, -0.15062796f, 0.13727678f, -0.10372674f, 0.14287846f, 
    -0.37167433f, 0.11005909f, -0.53694493f, 0.00234327f, -0.14255267f, -0.21920766f, 0.26782998f, -0.11978994f, 
    0.15755048f, -0.40339980f, 0.01740921f, -0.01843700f, -0.14854014f, 0.10621072f, 0.00383908f, -0.11494077f, 
    0.21482500f, 0.10101085f, -0.06492867f, -0.10723049f, 0.35217136f, 0.20670719f, -0.06581868f, 0.18332607f, 
    0.01400756f, 0.13438845f, 0.30066186f, 0.12880722f, 0.08230430f, 0.03781483f, 0.14890639f, 0.08816442f, 
    -0.64723718f, 0.12629777f, 0.09264174f, -0.04539773f, 0.16441742f, -0.44285488f, 0.13566281f, 0.24363074f, 
    0.06184927f, -0.23758109f, 0.25058940f, 0.16486107f, -0.10825072f, -0.09753589f, 0.28484935f, -0.13713478f, 
    -0.46968994f, 0.13657245f, 0.07379454f, 0.14625125f, -0.55528015f, 0.29200354f, -0.14670350f, -0.03771581f, 
    -0.01261448f, -0.13955213f, -0.34263396f, -0.00666211f, -0.10838056f, -0.08559600f, 0.30065259f, 0.14558990f, 
    -0.00997964f, 0.11056004f, 0.05030091f, -0.06810626f, -0.46935782f, 0.34010345f, 0.07693086f, 0.13938953f, 
    0.17995685f, -0.04044044f, -0.47232547f, 0.12458591f, 0.01229159f, -0.06855825f, 0.40524775f, 0.08928469f, 
    -0.52121264f, -0.04915074f, 0.06608525f, 0.05592266f, -0.44483393f, 0.32069919f, -0.02837061f, 0.11955736f, 
    -0.05239178f, -0.15534483f, -0.17046645f, -0.02008149f, -0.66162801f, 0.10278761f, -0.11093764f, -0.11353546f, 
    0.33732370f, 0.06218772f, 0.57350779f, 0.16003697f, -0.18399750f, -0.09196337f, 0.08928779f, 0.03680583f, 
    -0.15427268f, -0.12154306f, 0.13698600f, -0.03317963f, 0.14478672f, 0.00200135f, -0.52230805f, 0.11703183f, 
    0.01870054f, -0.17010811f, 0.16353816f, 0.19154130f, 0.00229545f, 0.22933595f, -0.08729639f, -0.11251559f, 
    -0.21413991f, 0.07209789f, -0.07438470f, -0.17814356f, 0.16081996f, 0.01425768f, 0.01299746f, 0.03532635f, 
    0.36565170f, 0.05528443f, -0.23330286f, 0.02067353f, 0.20072331f, 0.36726630f, 0.03751184f, -0.49712753f, 
    -0.01041357f, -0.16784640f, 0.19444346f, -0.04898695f, -0.03827588f, -0.06485161f, -0.02820262f, -0.03551659f, 
    -0.04953735f, -0.63673592f, -0.07220176f, -0.23285016f, 0.10738529f, 0.05006976f, 0.12939180f, 0.15742394f, 
    -0.21061328f, 0.12460852f, 0.30414036f, -0.02342341f, 0.26013038f, 0.15572035f, -0.20155191f, 0.17732953f, 
    -0.23959722f, -0.08775410f, -0.52595109f, 0.08618867f, 0.01669993f, 0.27479067f, 0.09685295f, -0.29043511f, 
    -0.11190460f, 0.16883865f, 0.20269728f, 0.05869024f, -0.01910226f, 0.11936577f, -0.10522503f, 0.09095296f, 
    0.21044154f, -0.34457168f, 0.11157961f, 0.22360605f, -0.53037179f, -0.18629232f, -0.16468723f, -0.00323612f, 
    -0.45265561f, 0.11405312f, -0.51471639f, -0.08133522f, 0.30096850f, -0.06070104f, 0.21227327f, -0.13852233f, 
    0.19762518f, 0.02139387f, 0.19410768f, -0.12731463f, -0.12658170f, 0.02837154f, -0.36988464f, 0.24803883f, 
    0.09940213f, -0.17504957f, -0.58502442f, -0.11514956f, -0.04364005f, -0.22950001f, 0.24935368f, -0.02077471f, 
    0.32888946f, 0.23270372f, -0.10383649f, -0.01028435f, -0.23032992f, -0.71505320f, 0.15181039f, -0.11166814f, 
    0.17752664f, 0.10408777f, 0.11166867f, -0.13590956f, -0.17480730f, -0.15002578f, -0.23071574f, -0.08295062f, 
    0.24038009f, -0.15572214f, 0.01498151f, 0.07983585f, 0.29646301f, 0.27723834f, -0.16050600f, 0.06901202f, 
    0.11960254f, 0.12515084f, -0.00375765f, 0.02927025f, -0.13548411f, -0.36391822f, -0.00263719f, 0.08463693f, 
    -0.53615475f, -0.01746448f, 0.11686374f, -0.37240353f, 0.33266771f, -0.40673846f, 0.10900525f, -0.21820427f, 
    0.31534785f, 0.16656357f, -0.22793154f, 0.16200706f, -0.21467406f, 0.07425240f, -0.17466478f, 0.11772508f, 
    -0.08012385f, 0.13592218f, -0.15632467f, -0.11036479f, 0.02644105f, -0.28508997f, 0.06364480f, 0.37749293f, 
    0.14997727f, 0.38700375f, -0.62182128f, 0.01631159f, -0.05609379f, 0.12367190f, -0.28661156f, -0.03154282f, 
    -0.07552607f, -0.35596314f, 0.00236437f, 0.23275076f, -0.33338028f, -0.40281630f, -0.02564414f, -0.49645627f, 
    0.32516044f, 0.03945910f, -0.17157812f, -0.02090567f, 0.24571733f, -0.11387346f, 0.15930128f, -0.01090928f, 
    -0.04932098f, -0.10425521f, -0.02033571f, -0.09525812f, -0.45097175f, 0.08504836f, -0.39822251f, -0.52890551f, 
    0.09217966f, 0.06967422f, 0.14944752f, -0.13606301f, 0.15325874f, -0.50997192f, 0.08434356f, -0.11508375f, 
    0.10859087f, 0.13950944f, 0.06120551f, -0.01624044f, 0.31136218f, -0.06044552f, -0.11462169f, 0.35555223f, 
    0.15776274f, -0.17296213f, -0.20019190f, 0.04613070f, 0.05162859f, 0.07225719f, -0.47823232f, 0.02061452f, 
    0.30980158f, -0.10884744f, 0.19804157f, 0.13932388f, -0.33856449f, -0.59390181f, 0.02297408f, 0.22317335f, 
    -0.09712017f, 0.20372280f, 0.14026457f, -0.07895396f, -0.13382515f, -0.24298099f, 0.30449909f, -0.15453053f, 
    0.10156257f, -0.13470279f, -0.16460289f, -0.07316643f, -0.46324614f, -0.14838816f, -0.08879809f, 0.28146449f, 
    -0.36462289f, 0.16540125f, 0.07692596f, 0.08726419f, -0.31456268f, 0.13480125f, 0.31390402f, -0.12816887f, 
    0.22895782f, 0.02360109f, 0.25808588f, 0.15822570f, -0.02003527f, -0.28565663f, -0.32402015f, -0.09020943f, 
    0.15518098f, -0.03059037f, 0.07526433f, 0.16122317f, -0.15844391f, 0.58249468f, -0.44417834f, -0.13674298f, 
    -0.16822277f, 0.36560103f, 0.11452298f, 0.04434304f, -0.16963156f, -0.30693465f, 0.13429376f, -0.31033024f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.08783541f, -0.04344852f, -0.02967317f, -0.13020007f, -0.22776142f, 0.11221474f, -0.19280778f, -0.21315078f, 
    0.05359007f, 0.07332095f, -0.31742248f, 0.00301080f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
