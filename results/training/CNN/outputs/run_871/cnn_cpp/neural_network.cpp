#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.34999365f, -0.80633038f, -0.62094349f, -1.18610227f, 0.52016020f, -0.09563868f, 0.51469165f, 0.45686051f, 
    0.30006188f, 0.78265661f, -0.58239192f, 0.47698468f, 0.48393640f, -1.35538721f, 0.20203272f, -0.49842975f, 
    -0.14707895f, -0.34448045f, -0.65495098f, -0.93262780f, -0.56590921f, -0.57939482f, -0.16534677f, -0.18843369f, 
    -0.31918785f, 0.14831239f, -0.45108351f, -0.40553609f, 0.89614195f, -0.11865172f, 0.89576268f, -0.37693959f, 
    -0.53908527f, -0.07207948f, -0.02226471f, 0.10683210f, 0.41090679f, 0.29857194f, 0.41507518f, 0.17845304f, 
    -0.52704883f, -0.45400891f, 0.60877377f, 0.19515188f, 0.54990292f, 0.96637875f, 0.86659175f, 0.87719905f, 
    -0.42902195f, 0.48209542f, -0.17864370f, 0.28669304f, 0.02937747f, -0.33787572f, -0.03117643f, -0.62703490f, 
    -0.96137702f, -0.00691156f, -0.45099726f, 0.35530603f, -0.49315014f, 0.07894236f, 0.29754937f, -0.82353073f, 
    -0.45636293f, -0.51905102f, 0.71385223f, -0.06012266f, -0.53636551f, 0.12608829f, -0.29948071f, -0.45381474f, 
    -1.01328564f, 0.83057833f, -0.24912082f, 0.30587021f, 0.07502586f, -0.31797859f, -0.19754665f, 0.01403786f, 
    -0.59101325f, 0.78869909f, 0.23451734f, -0.94903487f, 0.60161084f, 0.93223494f, -0.23044375f, 0.32974827f, 
    -0.13684340f, -0.23217262f, -0.94011837f, 0.70298904f, -0.23355657f, -0.79517370f, -0.45563996f, -0.83525062f, 
    -0.32668099f, 0.01537215f, 0.35956767f, -0.61523181f, -0.75545263f, -0.68524206f, 0.24465792f, 0.46149826f, 
    0.99322730f, -0.20085399f, -0.04678808f, -0.31745502f, 1.01942980f, 0.28370172f, 0.68536824f, -0.16209127f, 
    0.19319269f, 0.00175562f, -0.14615962f, -0.22869396f, 0.61490703f, 0.93721616f, 1.10092270f, -0.29514667f, 
    -0.37433052f, -0.35698795f, 0.05181802f, 0.21438217f, 0.41809255f, -0.07240025f, -0.15864868f, -0.78887707f, 
    0.43741715f, 0.75128818f, -0.14844088f, 0.58614391f, 0.47774154f, -0.17050679f, 0.38918099f, 0.34274197f, 
    -0.22708797f, 1.05506718f, 0.64714485f, 0.56475854f, 0.78686321f, -0.06474921f, -0.43573594f, -0.18951529f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.07689297f, 0.12032207f, -0.37834507f, -0.39640573f, 0.29546604f, 0.33647239f, 0.20727687f, 0.40053242f, 
    -0.12877530f, 0.07296170f, 0.59388536f, -0.10939202f, 0.25014734f, -0.28190485f, -0.07605793f, -0.00962702f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.05999823f, -0.01364199f, 0.15329744f, -0.17670396f, -0.13654932f, 0.03673716f, -0.39207998f, 0.15691184f, 
    -0.22969587f, 0.10876150f, 0.14689396f, -0.01224730f, -0.12410420f, -0.03085523f, 0.01225784f, -0.04277251f, 
    -0.18329115f, -0.05398731f, -0.03929862f, -0.09664783f, 0.46209759f, 0.14338952f, -0.03291645f, -0.02146040f, 
    -0.10349914f, -0.05341044f, 0.18379220f, 0.44618365f, 0.27064896f, -0.13316895f, 0.04296727f, -0.02390111f, 
    -0.09987848f, 0.04312572f, 0.17364021f, 0.04294870f, -0.16672376f, -0.15045096f, -0.01949198f, -0.05671037f, 
    0.17860274f, -0.10362499f, -0.22992320f, -0.01202666f, -0.10802939f, -0.22535019f, 0.23279403f, 0.33453399f, 
    -0.00687783f, -0.12843689f, -0.09970595f, -0.19786291f, -0.24594684f, -0.05759750f, 0.05607707f, -0.16955160f, 
    0.26985765f, -0.11925581f, -0.10609519f, -0.16289978f, -0.01931446f, -0.03404579f, 0.11820099f, 0.04812536f, 
    0.03007110f, -0.19239263f, 0.17273901f, 0.04286550f, 0.14363967f, 0.15849857f, -0.06742675f, 0.15707335f, 
    0.44336709f, 0.08038704f, -0.01086713f, -0.11995955f, -0.09744299f, -0.02209897f, 0.06647372f, 0.01211374f, 
    0.05606535f, -0.04887633f, -0.06180101f, -0.02727256f, 0.07981370f, -0.08678225f, 0.08118660f, 0.00537495f, 
    0.16815469f, -0.16245504f, 0.05324331f, 0.01142124f, -0.12320282f, 0.26585448f, -0.07594804f, -0.36193296f, 
    -0.05815923f, 0.20518561f, 0.19376811f, -0.04082068f, 0.01129484f, 0.25963333f, -0.05721568f, 0.05018230f, 
    0.23167589f, 0.15641709f, -0.09260812f, 0.05471445f, 0.02482240f, 0.10932123f, 0.00822797f, -0.01690230f, 
    0.22492030f, -0.14364633f, 0.07612088f, 0.20690040f, 0.09816168f, -0.37379068f, 0.26319152f, -0.16571145f, 
    -0.09909472f, 0.27310142f, -0.11391042f, 0.08564067f, 0.20199418f, -0.15726048f, 0.35989887f, -0.23281568f, 
    -0.00963104f, -0.02435598f, -0.08362632f, 0.11908116f, 0.01798258f, -0.02273639f, -0.27497938f, -0.00602884f, 
    -0.31083775f, -0.11588311f, 0.09007564f, -0.10177469f, 0.30320704f, 0.12661929f, 0.05512589f, -0.25530705f, 
    0.22625105f, 0.03901308f, 0.04172290f, 0.04588522f, -0.16241063f, 0.14540280f, 0.18914096f, -0.00830526f, 
    0.16798934f, -0.47441161f, 0.24531932f, 0.04736296f, 0.11212999f, 0.17284870f, 0.06796159f, -0.01203362f, 
    -0.15285055f, 0.03373745f, -0.21118698f, -0.23997113f, 0.39474979f, 0.17036703f, 0.27407646f, 0.06524723f, 
    -0.05524328f, -0.04144995f, -0.18784800f, -0.04419437f, 0.08299220f, -0.01978609f, -0.12824184f, 0.02676681f, 
    -0.02358816f, 0.03285577f, 0.05541310f, 0.04561322f, -0.05192570f, 0.03770311f, 0.32535097f, -0.10436711f, 
    0.02357792f, -0.08539952f, 0.06417693f, 0.02976883f, 0.16853258f, -0.03814339f, 0.36417097f, 0.23204155f, 
    0.12989600f, 0.12917793f, 0.22860211f, 0.21889445f, 0.14275306f, -0.14997490f, -0.29695299f, -0.40866306f, 
    -0.24759763f, -0.16681671f, 0.06648284f, 0.00007218f, -0.00293423f, -0.24890074f, 0.18737110f, 0.41281316f, 
    -0.14946893f, -0.12786603f, -0.03995676f, 0.03348473f, -0.16253798f, -0.05935606f, 0.11010249f, -0.21647348f, 
    0.16554396f, -0.21819544f, -0.25310951f, 0.01031656f, 0.10193510f, 0.07710221f, 0.07692686f, -0.07303700f, 
    0.23567931f, -0.22615372f, -0.63807368f, 0.07674620f, -0.19036353f, -0.06439445f, -0.29188219f, 0.01108275f, 
    -0.08380686f, 0.09136515f, -0.09870567f, 0.00615545f, -0.15876247f, -0.01902201f, 0.04429273f, 0.12223918f, 
    -0.17066351f, 0.15208538f, -0.05916927f, 0.10993194f, -0.39184949f, -0.06675220f, 0.14580250f, -0.11148515f, 
    0.11761617f, 0.10081868f, -0.04329411f, 0.17307515f, 0.03864897f, 0.28549984f, 0.23790722f, 0.04204522f, 
    0.01778737f, -0.08302496f, 0.02718973f, 0.04291636f, 0.23716541f, -0.47442701f, -0.27311423f, -0.08693784f, 
    -0.28233680f, -0.08238535f, -0.07420908f, -0.08307856f, -0.12430387f, -0.04313948f, -0.23816532f, 0.21253419f, 
    -0.12310656f, 0.05646141f, 0.11004269f, -0.30977744f, 0.00210866f, -0.16728050f, -0.20054384f, -0.10752910f, 
    0.30705738f, 0.10229649f, 0.18340309f, 0.17880861f, -0.05652208f, 0.06872215f, -0.09376024f, 0.00562080f, 
    -0.03289458f, -0.04343788f, -0.04693642f, -0.06602851f, -0.00324299f, -0.02938824f, -0.04437981f, -0.03097281f, 
    -0.00113265f, -0.06200897f, -0.05890935f, -0.04064608f, -0.03900744f, 0.07180621f, 0.06424019f, -0.08729336f, 
    0.02151079f, 0.00752184f, 0.07222343f, -0.05160414f, -0.04480501f, 0.04819515f, -0.06652088f, 0.00186198f, 
    -0.06153278f, 0.02985430f, -0.02966969f, -0.06080389f, 0.08120698f, -0.02317346f, -0.01450345f, -0.01906119f, 
    -0.03859176f, 0.01550906f, -0.03335798f, -0.01854702f, -0.08588491f, -0.03962158f, -0.00034937f, -0.00624640f, 
    -0.07501420f, -0.00026534f, -0.09132502f, -0.00495785f, -0.03191669f, -0.08400320f, -0.07631403f, -0.00455696f, 
    -0.00692519f, 0.00080026f, 0.04128507f, 0.05101043f, -0.03450353f, -0.06901054f, 0.04823990f, -0.08255666f, 
    -0.04232462f, 0.04688999f, -0.03214535f, -0.05700218f, -0.07376385f, -0.09517439f, 0.06054273f, -0.05022625f, 
    -0.08274718f, 0.07481961f, -0.08989072f, -0.00311025f, -0.01485635f, 0.03881644f, -0.06695755f, 0.05052814f, 
    0.01783801f, -0.08114868f, -0.07733919f, -0.02927873f, 0.01123310f, -0.07799233f, -0.08312595f, -0.01926875f, 
    -0.07049441f, -0.05954222f, -0.06242245f, -0.00366736f, 0.02478765f, 0.05310273f, 0.01860302f, -0.04218473f, 
    -0.09185787f, 0.07171387f, -0.01905584f, -0.00633784f, 0.03585270f, -0.01741489f, 0.01594464f, 0.00827904f, 
    0.03228971f, -0.07685457f, 0.03424998f, 0.01826127f, -0.07606616f, -0.06379838f, -0.00169445f, -0.02233997f, 
    0.00342494f, 0.00484397f, 0.03635843f, 0.07095841f, 0.04508151f, -0.07742148f, 0.05731602f, 0.04511383f, 
    -0.04194626f, -0.09083670f, 0.02920621f, 0.06721047f, 0.07534456f, -0.05058001f, 0.01744155f, 0.05758678f, 
    0.06554686f, -0.05519688f, -0.04867342f, 0.03716504f, -0.01779755f, 0.04080684f, 0.02265105f, -0.04209539f, 
    -0.09120095f, -0.09584817f, 0.01127362f, -0.06242802f, -0.04603149f, 0.02258666f, -0.09154092f, -0.00839163f, 
    0.05990934f, 0.03197522f, -0.06981023f, 0.00300749f, -0.01908980f, 0.01435940f, -0.07420444f, 0.02803014f, 
    -0.34293309f, 0.33611414f, -0.31039333f, 0.17809242f, -0.10430294f, 0.06718101f, 0.14895459f, 0.05792829f, 
    -0.23612683f, 0.27612796f, -0.74406731f, -0.26601925f, -0.18446602f, -0.08219613f, 0.14907651f, -0.10774419f, 
    -0.02612814f, -0.10901619f, 0.01622210f, 0.18278944f, 0.11979536f, 0.20520376f, -0.28148353f, -0.45209664f, 
    0.00761994f, 0.27178457f, -0.06473494f, 0.17374070f, -0.12312484f, 0.31325358f, -0.11943576f, -0.08923752f, 
    -0.12614590f, 0.18453723f, 0.00985724f, -0.09018145f, -0.07237321f, -0.22767131f, 0.20661598f, 0.08139376f, 
    -0.21771002f, 0.14970417f, 0.07304290f, -0.02653081f, -0.01604021f, -0.31611112f, -0.09659845f, 0.16849683f, 
    -0.13237096f, -0.15454982f, 0.28810599f, 0.23938160f, 0.00458341f, 0.11077353f, 0.52706909f, 0.14564061f, 
    0.24971162f, -0.01987161f, -0.01614257f, -0.08539493f, 0.16956155f, 0.16936526f, 0.06389333f, 0.07509923f, 
    0.24966437f, -0.14727362f, 0.03137502f, 0.17913654f, -0.00581571f, 0.05210879f, -0.06967610f, -0.08199863f, 
    0.36176902f, 0.08468219f, 0.08709083f, 0.07702817f, -0.06496484f, 0.07045455f, -0.15944359f, 0.35540023f, 
    0.16111432f, -0.17715305f, -0.18810806f, -0.12170088f, -0.09769642f, -0.08224714f, -0.24433216f, -0.17285790f, 
    0.12780456f, 0.07918373f, -0.24012858f, -0.22182013f, 0.08614436f, -0.12127537f, -0.08430283f, -0.05623367f, 
    -0.18110137f, -0.12602021f, -0.06551731f, 0.26855025f, 0.52505273f, 0.20284869f, 0.25906441f, -0.10735011f, 
    -0.04263002f, -0.21369588f, 0.25211725f, 0.23797114f, 0.47193587f, -0.06558431f, -0.14806269f, -0.27811748f, 
    -0.11425541f, 0.04701526f, -0.11547747f, 0.01363718f, 0.11894258f, 0.23005840f, 0.32661536f, 0.01921551f, 
    0.07002778f, 0.04511794f, 0.08511829f, -0.05445530f, -0.06980873f, -0.10961019f, 0.09715995f, -0.15696350f, 
    -0.26137444f, 0.03422487f, 0.34805220f, 0.08245546f, -0.08889428f, -0.03260563f, -0.29993448f, -0.41492802f, 
    0.20167620f, -0.14092670f, 0.22416545f, -0.24034433f, -0.00327207f, -0.02351808f, 0.16163042f, 0.18298520f, 
    -0.06353351f, -0.13841547f, 0.08255933f, 0.05725278f, -0.23410191f, 0.09496283f, 0.12609239f, -0.02943327f, 
    -0.05659821f, 0.05000848f, 0.29934737f, 0.19310632f, -0.00583066f, -0.01247100f, -0.03705389f, 0.16419692f, 
    0.18622005f, 0.08886453f, -0.33054462f, -0.07111523f, -0.21159689f, -0.28795514f, 0.08777715f, 0.24050598f, 
    0.06481295f, 0.04008976f, -0.17519319f, -0.36072677f, -0.30540660f, 0.02890562f, 0.11409549f, 0.00618234f, 
    0.05662836f, -0.02329434f, -0.01921563f, 0.02991803f, -0.02627286f, 0.43714792f, 0.26397640f, 0.02774913f, 
    -0.00089126f, -0.23531973f, 0.18961132f, 0.16059640f, 0.07117212f, 0.31277868f, -0.06949863f, 0.01319807f, 
    -0.01444745f, -0.02379917f, 0.03757776f, -0.11435313f, 0.20204712f, -0.13554324f, -0.50861251f, 0.20044573f, 
    -0.11741471f, 0.09819569f, -0.03959689f, 0.02753688f, -0.04093086f, -0.08086511f, -0.11718175f, -0.01113448f, 
    -0.18667844f, -0.00734697f, 0.10333521f, 0.07760990f, 0.13632397f, 0.04830952f, 0.19256446f, -0.22501223f, 
    -0.26494202f, -0.23955630f, -0.02095214f, 0.10627562f, 0.07083175f, -0.22747876f, 0.04104789f, -0.24900065f, 
    0.03530471f, -0.13877681f, -0.08173161f, -0.42357796f, -0.09396499f, 0.03408856f, -0.01249185f, 0.11361393f, 
    0.01747271f, 0.14580046f, -0.06008107f, -0.32951930f, -0.41266766f, 0.27473867f, -0.00243330f, 0.26458418f, 
    0.08530593f, 0.07025499f, -0.08322793f, 0.42426699f, -0.09025447f, -0.62698501f, 0.13732931f, -0.22866891f, 
    -0.03409878f, 0.20442957f, -0.14253339f, -0.07668813f, -0.10428262f, -0.01446746f, -0.07638492f, 0.10329540f, 
    -0.03625344f, 0.06894423f, -0.00602210f, 0.25595489f, 0.10219030f, 0.36417761f, 0.27080765f, -0.19167514f, 
    0.09168638f, -0.08806846f, 0.11873827f, -0.17818490f, -0.08920878f, 0.20430328f, 0.03128988f, 0.31447512f, 
    0.02671656f, -0.01585258f, 0.08314804f, 0.03038401f, 0.12395228f, -0.07333581f, 0.15147993f, 0.11172703f, 
    0.22628042f, 0.23587197f, -0.16972232f, -0.26165101f, -0.21662730f, 0.08109469f, 0.10133216f, -0.07243199f, 
    0.79676032f, -0.07956732f, -0.13952370f, -0.11335027f, 0.14775527f, -0.00428105f, -0.21977569f, -0.02932384f, 
    -0.16963263f, -0.84405088f, 0.15791257f, 0.07741899f, 0.16784863f, 0.05102219f, -0.08844803f, -0.15450425f, 
    -0.13638072f, 0.10585354f, -0.37026766f, -0.48962456f, -0.22744328f, -0.07951434f, 0.22720502f, 0.02371437f, 
    0.00850167f, 0.02292955f, 0.27832618f, 0.29721615f, -0.01033862f, -0.06396230f, -0.23964156f, -0.07710059f, 
    -0.13521263f, -0.10217506f, -0.22437656f, -0.10633155f, 0.06338122f, 0.09694092f, 0.11008693f, 0.09958092f, 
    0.13942918f, -0.16722538f, 0.05673934f, 0.16805786f, 0.02135619f, -0.29057944f, 0.22542988f, 0.01112164f, 
    0.15956607f, -0.04020231f, 0.16445494f, 0.16836528f, -0.22069339f, 0.02333413f, 0.03511255f, -0.47137231f, 
    0.20776388f, -0.20204216f, 0.15291314f, 0.06532922f, 0.17454357f, -0.15996774f, -0.00492856f, 0.06441795f, 
    -0.10515214f, 0.09274399f, 0.23871681f, 0.17961577f, -0.28142154f, 0.05815702f, 0.07003374f, -0.06153446f, 
    0.22259027f, -0.33667278f, -0.35545275f, -0.33758464f, 0.14642850f, -0.01480763f, -0.00345835f, 0.09908507f, 
    -0.10422537f, 0.34154326f, -0.12978718f, -0.06885524f, -0.51672745f, -0.21570049f, 0.26534787f, -0.04334809f, 
    -0.02253553f, -0.03954471f, 0.07971399f, -0.07720103f, -0.31943914f, 0.02999832f, 0.14954402f, -0.07597442f, 
    0.06272468f, 0.15862608f, -0.09488598f, 0.64407557f, 0.14232765f, 0.16047351f, -0.02464265f, -0.04530750f, 
    -0.15609936f, 0.06160794f, -0.03735274f, 0.15217420f, -0.48952293f, 0.19308558f, -0.02680989f, 0.06839526f, 
    0.17289869f, 0.21926081f, -0.01354218f, 0.03821652f, -0.01277214f, 0.32596669f, 0.09349666f, -0.03716816f, 
    -0.00154159f, -0.03352511f, 0.28133321f, -0.08409423f, 0.01535162f, -0.04347036f, 0.29921982f, 0.24917266f, 
    0.28223258f, -0.06913366f, -0.28938523f, -0.18433833f, 0.07218347f, -0.09424254f, -0.03982025f, -0.53079569f, 
    -0.08989581f, 0.02681383f, 0.03044325f, 0.07126427f, 0.02669962f, 0.20114174f, 0.15731163f, 0.07976059f, 
    -0.35408011f, 0.15012382f, 0.13786446f, -0.02950877f, 0.06695583f, 0.19377126f, -0.00026760f, -0.06794901f, 
    -0.01778840f, 0.14861512f, 0.09402322f, -0.18182661f, 0.08433780f, 0.21275939f, -0.00985904f, 0.05675886f, 
    -0.04616715f, 0.00845152f, 0.04171197f, 0.17103612f, 0.28836733f, 0.09283836f, -0.05256341f, -0.16613249f, 
    0.06359623f, 0.03205774f, 0.09999014f, -0.50658739f, -0.24323288f, -0.68367940f, -0.23848598f, -0.07332357f, 
    -0.04742624f, 0.15416029f, 0.11626650f, 0.24720351f, 0.17604715f, 0.18523383f, -0.16703044f, -0.00711631f, 
    -0.01657929f, -0.15204193f, -0.08288847f, -0.03933816f, -0.04702656f, -0.11772180f, -0.16423033f, 0.08573142f, 
    0.19157997f, -0.08520654f, 0.08563215f, -0.00737201f, 0.03358727f, 0.08003928f, -0.15316704f, 0.22486781f, 
    0.13444752f, -0.25903627f, -0.25628573f, 0.10955567f, 0.04054834f, -0.04045267f, -0.07788342f, 0.06713285f, 
    -0.22972493f, 0.40407205f, -0.07581813f, -0.06159319f, 0.00743402f, 0.01864534f, 0.19849500f, 0.22931705f, 
    -0.35487595f, -0.13772231f, -0.72877407f, 0.21769439f, 0.10805116f, -0.05201061f, 0.10214595f, 0.14543241f, 
    -0.19355263f, 0.28999150f, 0.08073310f, -0.09620135f, -0.04227825f, 0.04353362f, -0.14950749f, -0.12795790f, 
    0.16868515f, 0.15744612f, -0.68122602f, -0.40564275f, -0.41821656f, 0.28444180f, -0.01011367f, -0.09597731f, 
    -0.03333522f, 0.16778761f, 0.03770377f, -0.12380212f, -0.22487417f, 0.42217475f, 0.08241857f, 0.17171185f, 
    0.03384003f, -0.15969960f, -0.08728189f, 0.10142774f, -0.18128040f, 0.02813331f, -0.24729395f, 0.14875144f, 
    -0.09133208f, -0.12606686f, 0.11711250f, -0.06841046f, 0.06275445f, -0.05328459f, 0.29703343f, -0.04540173f, 
    -0.11123880f, -0.16432562f, -0.21031488f, 0.15596847f, -0.23868886f, 0.02214539f, 0.25158405f, 0.23434561f, 
    0.08248930f, -0.15832931f, -0.03207580f, 0.11372949f, -0.17328197f, -0.05759216f, 0.13498141f, 0.28086111f, 
    0.45062184f, 0.26042345f, 0.07909794f, -0.10840061f, -0.08770094f, 0.12950435f, 0.16057521f, -0.01518216f, 
    0.18608710f, -0.18946165f, 0.18523014f, -0.09574107f, 0.06405799f, -0.02764058f, 0.09226511f, -0.10154443f, 
    -0.09766077f, 0.50578362f, 0.18070596f, -0.15683536f, -0.10276553f, -0.06068118f, 0.11658685f, -0.21615493f, 
    -0.12470630f, -0.18577276f, 0.32615149f, -0.08663414f, 0.46175629f, 0.17562810f, 0.27251804f, 0.07608121f, 
    -0.09546756f, 0.15324111f, 0.09238649f, -0.00538409f, 0.01997866f, -0.19547762f, -0.23243746f, -0.14681014f, 
    0.12176339f, -0.13396171f, -0.06932421f, 0.01294117f, -0.12153785f, -0.09682149f, -0.10399444f, -0.07248628f, 
    -0.07084475f, -0.23428823f, -0.10688332f, -0.23076169f, -0.17217429f, 0.15213026f, -0.37269261f, -0.26074383f, 
    0.00023633f, -0.15340878f, 0.15121341f, 0.14262451f, -0.05638459f, 0.01479143f, 0.34548950f, -0.08812428f, 
    0.42375991f, 0.28231338f, 0.20194282f, -0.05251217f, -0.04565071f, -0.05661004f, -0.16821100f, -0.29133731f, 
    -0.21139182f, 0.20913343f, 0.10409254f, 0.04339312f, -0.10738079f, -0.06278512f, 0.03365935f, 0.21534532f, 
    -0.22118609f, -0.03036889f, -0.04248294f, 0.01833666f, -0.22946025f, 0.30537310f, -0.05573844f, -0.19540621f, 
    0.07164747f, -0.43446800f, 0.13351002f, 0.14262336f, -0.01991160f, -0.05045160f, -0.13765807f, 0.09911606f, 
    0.11592351f, 0.00243331f, -0.13577151f, -0.16063228f, -0.14204866f, -0.07920405f, -0.15004355f, 0.01504210f, 
    -0.10127658f, 0.05111576f, 0.01414275f, 0.35397458f, -0.25125787f, 0.28119937f, 0.04699628f, 0.05343320f, 
    0.16854572f, -0.01955451f, 0.21072972f, 0.20861316f, 0.32309768f, 0.01530830f, -0.16229063f, -0.04491813f, 
    0.06170326f, -0.03299128f, -0.08033931f, -0.32456642f, -0.01579241f, -0.37021297f, 0.44424132f, -0.03805765f, 
    0.10252763f, -0.00529466f, -0.24872118f, 0.02433845f, 0.17624390f, 0.22909041f, -0.17683168f, 0.11525250f, 
    -0.34795904f, 0.29004002f, 0.26283172f, -0.06887516f, 0.19774550f, -0.23845188f, -0.10557218f, 0.13843089f, 
    0.06885161f, 0.21620750f, 0.31507370f, 0.22883318f, 0.11133790f, -0.09275356f, -0.09715313f, 0.07688581f, 
    -0.45905313f, 0.11915400f, 0.36378297f, 0.10852472f, -0.14700061f, 0.10261524f, 0.11888659f, 0.04363396f, 
    0.28989738f, 0.03756090f, -0.24816851f, 0.24006894f, -0.04744761f, 0.04973610f, -0.18842755f, -0.25302568f, 
    0.04099286f, -0.08015813f, 0.15202841f, -0.26757187f, 0.25031805f, 0.11577035f, -0.22071125f, 0.10703642f, 
    -0.32620630f, 0.05796601f, -0.02614064f, -0.30431253f, -0.32493669f, -0.26371837f, -0.04969050f, -0.02897124f, 
    -0.17688510f, -0.02014144f, 0.02598048f, -0.10930149f, -0.16458714f, -0.33501601f, -0.28508586f, -0.10739332f, 
    -0.03483349f, 0.01419412f, 0.00429127f, 0.08135232f, 0.05881312f, -0.39568624f, -0.02193508f, -0.06348061f, 
    0.00286116f, 0.06147546f, 0.15177770f, -0.06550735f, 0.08490577f, 0.27796742f, 0.09123927f, 0.36655340f, 
    -0.16280335f, -0.16266865f, 0.23622718f, 0.17872889f, 0.11499254f, -0.13408518f, 0.35404930f, 0.37507018f, 
    0.29249871f, 0.30972564f, 0.08984751f, -0.03016989f, 0.16822414f, 0.24591997f, 0.20350119f, -0.16693662f, 
    0.05171022f, -0.01016097f, -0.03692716f, 0.29395926f, 0.08755142f, 0.12296729f, 0.18927880f, 0.11039925f, 
    -0.19973253f, 0.21499690f, -0.12151661f, 0.21120726f, -0.11569195f, 0.13567416f, -0.17136014f, 0.17637117f, 
    0.19330293f, 0.06514394f, 0.41611230f, 0.09818472f, -0.17811041f, 0.06131000f, -0.03634712f, 0.17900294f, 
    -0.14912507f, -0.05015859f, -0.16437539f, 0.35813320f, 0.16570601f, 0.04811095f, 0.15083902f, 0.16857016f, 
    0.01905217f, -0.15505973f, 0.11413241f, 0.08908698f, -0.42473507f, -0.24701431f, -0.14315122f, 0.08751196f, 
    -0.07188378f, 0.03944715f, -0.22082965f, 0.00723616f, 0.07467177f, -0.50314403f, -0.36802235f, 0.00310570f, 
    -0.18779692f, -0.15078132f, -0.02079503f, -0.13674009f, -0.11865766f, 0.06418145f, 0.35667005f, 0.09215753f, 
    0.00674961f, 0.03913406f, -0.08427144f, -0.08592161f, -0.08844025f, 0.11188127f, 0.10079774f, 0.07272182f, 
    0.15645134f, -0.02013511f, 0.06081770f, 0.05365890f, -0.15595713f, 0.21390885f, 0.12027918f, 0.02399652f, 
    -0.07576425f, -0.03349493f, 0.04247541f, -0.08377598f, -0.07915951f, -0.00829534f, 0.01104240f, 0.01127841f, 
    -0.08669539f, -0.01075319f, -0.05597007f, -0.04375830f, -0.05277613f, -0.02486308f, -0.06520770f, -0.07100553f, 
    0.03729780f, -0.05493709f, -0.08600245f, -0.06340321f, -0.06381072f, 0.06631830f, 0.04115449f, -0.05691392f, 
    0.02730483f, 0.05050828f, -0.06161674f, -0.00939729f, 0.06928625f, 0.02893464f, -0.03718116f, -0.06793917f, 
    0.02576574f, 0.04619815f, -0.08986957f, 0.04105757f, -0.02002806f, 0.06196300f, -0.00862685f, 0.02376732f, 
    -0.06296903f, -0.02957045f, 0.00229335f, -0.03696604f, -0.05852164f, 0.06575475f, 0.03189760f, -0.05235777f, 
    0.00635717f, 0.00212342f, -0.00678584f, 0.05574266f, 0.02068409f, -0.07756327f, 0.07040647f, 0.00317721f, 
    0.02293060f, -0.00592815f, -0.01370035f, -0.00108066f, -0.03062928f, -0.07608749f, -0.00422383f, 0.04726528f, 
    0.04036225f, -0.03949028f, -0.01522589f, -0.08561509f, 0.01960046f, -0.04627811f, -0.08582245f, -0.08951071f, 
    0.02390249f, -0.02345276f, -0.01722336f, 0.06922565f, 0.02325688f, 0.05039942f, -0.00984425f, 0.01316559f, 
    -0.05243723f, -0.03172746f, 0.06842431f, 0.00523760f, 0.07649301f, -0.05127124f, -0.01155877f, 0.04242363f, 
    -0.04034511f, -0.01459397f, 0.00220863f, -0.01980618f, -0.09028652f, -0.00366679f, -0.09437458f, 0.03895025f, 
    -0.00816787f, 0.02288305f, 0.01830083f, 0.06245457f, -0.07307839f, 0.00010456f, -0.08247420f, -0.02857123f, 
    0.01045665f, -0.07028145f, 0.04410943f, 0.06079092f, -0.00860721f, -0.01857517f, 0.03368019f, -0.01805800f, 
    -0.04962779f, -0.04357720f, -0.03459265f, 0.05956857f, 0.06606424f, 0.04543115f, 0.03712289f, -0.01669810f, 
    -0.07303486f, -0.02680744f, -0.01111634f, -0.07561407f, 0.03768195f, -0.06697907f, 0.04237275f, -0.02395271f, 
    -0.05056548f, 0.04327337f, 0.05958289f, -0.02487737f, -0.00344109f, -0.01028222f, 0.01211236f, -0.07007617f, 
    -0.06654364f, 0.00222452f, 0.00536394f, 0.05357143f, 0.00993848f, -0.03057048f, 0.04662180f, -0.02281014f, 
    -0.10611540f, -0.03613292f, 0.07020677f, 0.15383700f, 0.30030751f, 0.06176235f, 0.21282965f, 0.02750690f, 
    0.05298224f, -0.19618759f, 0.06393667f, -0.25206190f, 0.12893812f, 0.22159125f, 0.10342132f, 0.05595727f, 
    0.10795438f, 0.24724342f, 0.10463079f, 0.24148817f, -0.05469129f, -0.05812039f, -0.25876519f, -0.21431808f, 
    -0.24415027f, -0.02557124f, 0.06071095f, -0.01742581f, -0.58364493f, 0.01262106f, -0.11640185f, -0.04495272f, 
    -0.13156500f, -0.07335334f, -0.05039125f, -0.02631730f, -0.31187111f, 0.09856972f, 0.28789243f, 0.15259801f, 
    -0.11447287f, -0.05550604f, 0.03857253f, 0.17795536f, 0.06030409f, 0.34468722f, 0.11773879f, -0.05027954f, 
    0.02533180f, 0.06259716f, 0.13119800f, 0.26981023f, -0.03677965f, -0.09440590f, 0.42137283f, -0.16001666f, 
    -0.12067563f, -0.02024735f, 0.03336491f, 0.16029796f, 0.07011258f, 0.22355844f, 0.09721447f, -0.16789792f, 
    0.01335905f, 0.22172745f, -0.09650540f, -0.07552043f, -0.01614263f, -0.15145628f, 0.16944608f, -0.03834697f, 
    0.22334646f, 0.16971102f, 0.13819349f, -0.17164025f, -0.06547347f, 0.14116505f, -0.04427048f, 0.17002986f, 
    0.07975728f, -0.29838443f, -0.11548759f, 0.25055400f, 0.18823621f, 0.20286652f, 0.02114344f, -0.02250441f, 
    -0.00070112f, 0.00294842f, -0.00404375f, 0.27245277f, 0.37759483f, -0.24868199f, 0.14768554f, -0.23940900f, 
    0.26900226f, -0.03399159f, 0.30423602f, -0.37966785f, -0.09123781f, 0.15972063f, 0.02371551f, 0.15652184f, 
    -0.13973050f, -0.06252564f, -0.11705045f, 0.12998658f, 0.28080186f, 0.27647060f, -0.32531697f, 0.20527667f, 
    -0.09529077f, 0.43038535f, -0.05740434f, 0.18350366f, -0.19279884f, 0.23992470f, 0.08245865f, -0.24068604f, 
    0.15356413f, 0.07902772f, -0.13208455f, -0.07900155f, 0.07709351f, 0.01948940f, -0.10337938f, 0.01457204f, 
    -0.02200030f, 0.30191347f, 0.07818902f, 0.18071961f, 0.02349840f, -0.30899996f, 0.01681248f, -0.45085093f, 
    -0.10824563f, -0.38019961f, 0.27920640f, 0.20762911f, 0.37902457f, 0.02062997f, 0.01926861f, -0.35665548f, 
    0.02855309f, 0.16823009f, -0.34710240f, 0.13971099f, -0.09158997f, 0.05519759f, 0.08495964f, -0.14698380f, 
    0.30830482f, -0.04982257f, 0.06760462f, 0.05359832f, 0.11014012f, -0.08926126f, 0.07345266f, 0.01237856f, 
    -0.00305714f, -0.10738100f, 0.60436863f, 0.46839595f, -0.35101467f, 0.21129462f, 0.15438843f, 0.08947691f, 
    -0.02170782f, -0.10867505f, 0.05959711f, -0.70349658f, -0.27212799f, -0.09088820f, 0.07199018f, 0.09182934f, 
    -0.08183156f, 0.01989980f, -0.24419159f, 0.20502327f, 0.33203721f, -0.20383954f, 0.11840636f, 0.15240353f, 
    0.03400391f, 0.08638584f, 0.43585455f, 0.13920690f, 0.10129721f, 0.13256280f, -0.35376963f, 0.12783091f, 
    0.24356331f, 0.05288254f, -0.07283865f, -0.09338395f, 0.03381924f, 0.25144097f, 0.32774627f, 0.17632358f, 
    -0.10840106f, -0.03261247f, -0.16049975f, 0.10373066f, 0.10601652f, 0.12986195f, -0.11284691f, -0.16643836f, 
    0.19213210f, -0.14467296f, -0.18522479f, -0.01126986f, 0.06868377f, -0.23716190f, 0.20430338f, -0.02512107f, 
    -0.61364150f, -0.07240447f, -0.16489583f, -0.00608546f, -0.01844403f, 0.06638803f, 0.02783596f, 0.02175461f, 
    -0.11269375f, 0.09305717f, -0.31260422f, 0.07706726f, 0.06344713f, 0.01447045f, -0.07613104f, 0.15613572f, 
    0.16512690f, -0.08108443f, -0.19516674f, 0.08613911f, -0.25444505f, 0.12619755f, 0.16469029f, 0.04882991f, 
    -0.09604257f, -0.17442755f, -0.27284914f, -0.26400536f, 0.16866116f, 0.09254283f, -0.10715523f, 0.01818231f, 
    -0.12332261f, -0.05870521f, -0.14260641f, 0.01339318f, -0.04487031f, 0.06154342f, 0.16668889f, 0.22669497f, 
    -0.05518378f, 0.08747511f, -0.15959518f, 0.11779738f, 0.03503178f, 0.60775954f, -0.03371397f, -0.18095304f, 
    0.09940668f, -0.12550358f, -0.04737206f, -0.01120865f, -0.19286409f, 0.05842122f, -0.42263034f, 0.18365735f, 
    0.16207173f, -0.01177309f, -0.06477124f, 0.18069138f, 0.08736090f, -0.05341154f, 0.04826984f, 0.30993798f, 
    0.01346397f, -0.13543795f, -0.08766132f, -0.09459156f, -0.38168809f, -0.00617984f, -0.10801252f, -0.15589562f, 
    -0.14944869f, 0.04074433f, -0.00226341f, -0.06925432f, -0.13329336f, -0.15456453f, 0.06937818f, 0.16832331f, 
    -0.04078430f, -0.14692621f, -0.09576066f, -0.10949820f, 0.17592213f, 0.01419610f, 0.01964893f, 0.17523091f, 
    0.06571854f, -0.11130577f, -0.23728651f, -0.04367061f, 0.12043761f, 0.10493468f, 0.06443187f, -0.18918432f, 
    -0.08439982f, -0.09630226f, -0.00992314f, 0.55870050f, -0.64434403f, -0.26765278f, -0.03377828f, -0.23008016f, 
    -0.10414683f, 0.09176536f, 0.07063363f, -0.16594785f, 0.10448271f, -0.29392532f, 0.27602804f, 0.17249800f, 
    -0.03613592f, 0.09241197f, 0.11377130f, 0.00067765f, 0.23339097f, -0.41096020f, -0.25505039f, 0.07523264f, 
    0.31758925f, 0.11238697f, 0.01879633f, -0.01361614f, -0.15875429f, -0.03676658f, 0.38701794f, -0.09110147f, 
    0.07025222f, -0.13933344f, -0.04358016f, 0.08476526f, 0.05937993f, 0.24222010f, 0.00681402f, -0.10006043f, 
    -0.04142167f, -0.16597161f, 0.01524869f, 0.08510134f, -0.02500772f, -0.03521224f, 0.09057513f, 0.08133736f, 
    0.33866274f, -0.16164772f, -0.06545707f, -0.02786112f, -0.10715410f, 0.05417441f, 0.03077045f, -0.10365940f, 
    0.09825905f, -0.03778199f, 0.17336039f, -0.22334021f, 0.03137591f, -0.08678161f, -0.00907868f, -0.07897370f, 
    0.07208302f, 0.00633144f, 0.21540502f, 0.09571033f, 0.09120101f, 0.06123102f, -0.16238722f, 0.01653244f, 
    0.17111322f, 0.06632050f, -0.05183495f, 0.23913871f, 0.17515616f, 0.03742444f, -0.02595264f, -0.06270994f, 
    0.03750559f, 0.10773667f, 0.21329477f, -0.03841032f, -0.41074550f, -0.51507026f, -0.01537865f, 0.11462325f, 
    0.04138993f, 0.19009939f, 0.08414269f, 0.05478270f, -0.13595857f, -0.01828031f, -0.32052386f, -0.18948187f, 
    -0.03363260f, 0.18546146f, -0.32796606f, 0.03892847f, -0.02042229f, -0.01528443f, 0.50478101f, 0.22086005f, 
    -0.26822546f, -0.02092883f, -0.00130957f, -0.02596964f, -0.04073101f, 0.16147034f, -0.01577672f, -0.25375426f, 
    -0.39863390f, 0.19914261f, -0.13914685f, -0.11347759f, 0.02485514f, -0.10922201f, 0.18178202f, -0.05495411f, 
    -0.49581587f, -0.00851265f, -0.09249066f, 0.15495463f, -0.13192849f, -0.11741550f, 0.12694867f, -0.09173685f, 
    -0.08515359f, -0.00228892f, 0.07557445f, -0.25071350f, -0.17463888f, -0.01327460f, 0.03674200f, 0.11516321f, 
    0.04859969f, 0.11801796f, -0.40011293f, 0.45418623f, -0.02711572f, 0.14065488f, 0.16961001f, 0.04501590f, 
    0.06259396f, -0.03843701f, -0.23722430f, -0.23245135f, -0.21426512f, 0.09234013f, -0.03423496f, 0.32893959f, 
    0.18835931f, -0.11503489f, -0.01897030f, -0.11262918f, 0.30274868f, 0.26085088f, -0.09488232f, 0.04947403f, 
    -0.01408435f, -0.06748842f, 0.08724257f, 0.07678004f, 0.18899696f, -0.32083896f, 0.19798920f, 0.49632576f, 
    0.20474716f, 0.14412133f, 0.02343249f, -0.01791457f, 0.03408494f, 0.19650210f, -0.52781266f, -0.41582775f, 
    0.19867706f, 0.05574571f, 0.00684620f, -0.24201278f, -0.02973502f, -0.14286114f, 0.25167233f, -0.33195764f, 
    -0.02677494f, -0.25341767f, -0.00307134f, 0.24153969f, 0.09155862f, 0.17519906f, 0.17611052f, 0.07296409f, 
    0.06573370f, -0.54834539f, 0.09837250f, -0.09040795f, -0.06241414f, -0.12294481f, -0.10972179f, -0.22757119f, 
    0.02251149f, -0.29986894f, 0.12541273f, 0.33815226f, 0.24800487f, -0.09728074f, -0.02965562f, 0.26123208f, 
    0.13070931f, -0.05671746f, 0.50170213f, -0.29161346f, 0.09828965f, -0.03726144f, 0.32860368f, 0.10915807f, 
    0.09292886f, 0.17609972f, 0.20120321f, -0.13610627f, -0.36974904f, -0.44700375f, 0.10689521f, 0.13173591f, 
    -0.04704715f, 0.19341256f, -0.21455567f, -0.05810853f, -0.20637350f, 0.22931001f, 0.21587184f, 0.09860197f, 
    0.04194469f, 0.14670445f, -0.00462600f, 0.05843720f, 0.01374559f, -0.23868074f, 0.05497498f, 0.19750980f, 
    -0.05136875f, -0.17677918f, -0.16431050f, -0.24592881f, 0.00188264f, 0.03223677f, 0.07742758f, -0.42045692f, 
    -0.30250871f, 0.00406362f, -0.07282262f, -0.15080602f, -0.26340857f, -0.08983783f, -0.04300647f, 0.66142869f, 
    -0.19396624f, -0.34784582f, 0.00743639f, 0.06926095f, 0.18812925f, 0.20912108f, -0.00186192f, 0.23126805f, 
    -0.13878064f, -0.06721288f, 0.17975833f, 0.11693171f, 0.00727377f, -0.28762603f, 0.07357080f, -0.13976371f, 
    0.05358930f, 0.01280020f, -0.47686869f, -0.09911893f, 0.06299929f, -0.01828937f, 0.10805655f, -0.16300210f, 
    -0.06090240f, -0.14274515f, 0.16854875f, 0.01027642f, 0.33327344f, 0.03766027f, -0.03277659f, -0.12991461f, 
    -0.07691251f, 0.06709304f, -0.04346494f, 0.68546772f, 0.06163621f, -0.00800588f, -0.31021300f, -0.31811535f, 
    -0.06954668f, 0.13693333f, -0.03545124f, 0.00208793f, -0.19988008f, -0.03548688f, -0.18390219f, 0.21636723f, 
    -0.04446461f, 0.10784680f, 0.09548561f, -0.04052869f, -0.06936725f, -0.52606076f, 0.21333157f, -0.25930038f, 
    0.19469887f, 0.26580536f, 0.04515965f, -0.26328209f, 0.10642558f, -0.05095520f, 0.25287691f, 0.22840583f, 
    -0.09822695f, -0.23768727f, 0.10431371f, -0.00069687f, -0.08855928f, -0.10004936f, -0.06562783f, 0.00971754f, 
    0.18302986f, 0.20282619f, -0.03764598f, 0.07340448f, 0.02234677f, 0.13779216f, -0.12264230f, -0.03696949f, 
    0.31523278f, 0.16304678f, -0.04342460f, -0.07923703f, 0.13930111f, 0.19806871f, -0.16825616f, -0.19922853f, 
    -0.08817647f, 0.04996237f, -0.29572979f, -0.01408326f, -0.05788504f, 0.02716411f, -0.09945677f, -0.07024334f, 
    -0.10504260f, 0.03409120f, 0.14474066f, -0.02267270f, -0.04391756f, 0.00449777f, 0.08577554f, 0.08293863f, 
    -0.24595040f, 0.00421075f, -0.07511241f, 0.43503785f, 0.19008334f, 0.36985227f, -0.05049518f, 0.21020100f, 
    -0.25820386f, -0.02268382f, 0.13324900f, 0.10466636f, -0.11084784f, -0.27524137f, 0.04118143f, 0.06939895f, 
    -0.02051566f, 0.11623099f, 0.01816571f, -0.22523397f, 0.07548742f, 0.06897803f, -0.31256020f, -0.05707746f, 
    0.11374321f, 0.04437903f, -0.10216250f, 0.12880675f, -0.04810917f, -0.30892020f, 0.14602901f, -0.08501597f, 
    0.01703160f, -0.09427004f, -0.05370009f, -0.00040084f, 0.06073705f, 0.40104479f, 0.25988182f, -0.33841723f, 
    -0.10609466f, -0.04426288f, 0.31875405f, 0.05006735f, -0.01937046f, -0.34701446f, -0.01881021f, 0.18673708f, 
    0.06476410f, -0.14379098f, -0.32709157f, 0.07815281f, 0.17910315f, -0.02345559f, 0.07589354f, -0.32232264f, 
    -0.32471922f, 0.31461143f, 0.07092779f, 0.10959232f, -0.06543633f, 0.00673719f, 0.10462166f, 0.15939184f, 
    0.16545898f, 0.13550971f, 0.04332009f, 0.11495522f, -0.00203117f, 0.08832335f, -0.09977863f, -0.00857216f, 
    -0.02940016f, 0.08103276f, -0.04733341f, -0.40438634f, -0.02723238f, -0.18339616f, -0.05121246f, -0.16539587f, 
    -0.19368875f, 0.20165597f, -0.14622283f, 0.19844608f, 0.12082199f, -0.02565365f, -0.05634990f, 0.01847559f, 
    0.28003863f, 0.11152723f, 0.04447876f, 0.06890015f, -0.08965185f, 0.52614486f, 0.23488046f, 0.14149018f, 
    -0.29318851f, -0.19435945f, -0.03349260f, 0.14782086f, 0.04948878f, -0.06595691f, -0.16889045f, 0.09870192f, 
    -0.23474549f, -0.03929907f, -0.06106051f, -0.01881776f, -0.02555990f, -0.20557077f, 0.05932963f, -0.11702070f, 
    0.02128885f, 0.02819692f, 0.25396132f, -0.01890301f, 0.08211123f, 0.27047729f, 0.02846364f, -0.03203192f, 
    -0.39824620f, -0.11027336f, 0.03817840f, 0.00760994f, -0.20632054f, -0.13414490f, -0.25869104f, 0.18245757f, 
    0.11674382f, -0.08218767f, -0.28678295f, 0.26408198f, 0.11963736f, -0.13843919f, -0.02207297f, -0.11522959f, 
    -0.01619624f, 0.00060250f, -0.17153436f, 0.09387467f, -0.01349363f, 0.11637674f, -0.01471672f, 0.03119430f, 
    -0.09398261f, 0.11388806f, 0.15546595f, 0.07472212f, -0.24014771f, -0.54698825f, 0.23568060f, 0.10788579f, 
    0.25098726f, -0.11342324f, 0.06864566f, 0.03142716f, 0.21019731f, 0.16118941f, 0.21786298f, -0.24039215f, 
    -0.12012197f, -0.05108446f, 0.00660492f, -0.10743114f, -0.15232572f, 0.45837450f, 0.20998810f, 0.09149653f, 
    -0.19993223f, -0.21606451f, -0.37821949f, -0.08244936f, -0.02715321f, -0.06180235f, -0.02560954f, -0.15533952f, 
    -0.19544150f, 0.18965620f, 0.33682510f, 0.04082815f, -0.06507371f, -0.17936887f, -0.24424782f, 0.35490844f, 
    -0.18116038f, 0.53771096f, 0.09192461f, -0.04393335f, 0.11026589f, 0.15571646f, -0.04854017f, 0.06825880f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.10045190f, 0.12665424f, -0.07566001f, -0.14898916f, 0.17231587f, 0.16701815f, -0.00924649f, -0.07215643f, 
    0.18797749f, -0.02059413f, 0.20260465f, 0.15589309f, 0.10280275f, 0.30232790f, 0.01397088f, -0.00814714f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.11142964f, -0.28481022f, -0.13349098f, 0.09827007f, -0.52180141f, -0.50085789f, 0.42064926f, 0.62831312f, 
    0.20416899f, -0.03484875f, 0.35578525f, -0.33935055f, 0.06779597f, 0.51101726f, -0.15873963f, -0.37732634f, 
    0.61106014f, -0.35781106f, -0.05528572f, -0.19502498f, -0.05627147f, -0.20138417f, 0.09624021f, 0.43818140f, 
    -0.47018829f, -0.21407066f, 0.07988264f, -0.38284189f, -0.02186119f, 0.74529755f, 0.37919125f, 0.11299491f, 
    0.37794751f, 0.12820224f, 0.05506612f, 0.47287488f, 0.45205879f, 0.27371761f, 0.88142312f, 0.20775440f, 
    -0.08504605f, -0.02697017f, -0.13397327f, -0.02117658f, 0.03149236f, -0.31530356f, 0.32539845f, -0.28324786f, 
    -0.19916679f, -0.65391964f, 0.04230881f, -0.04782613f, -0.18937919f, 0.01259952f, 0.41469401f, 0.50092781f, 
    0.51489639f, -0.08719328f, 0.23253036f, 0.30884480f, -0.02113937f, -0.45662382f, 0.59475821f, -0.81466717f, 
    0.02316447f, 0.04004457f, 0.05517461f, 0.58252573f, -0.37197798f, 0.15563861f, -0.27847403f, 0.03058885f, 
    -0.02489458f, -0.10280737f, 0.15012062f, 0.14365205f, -0.02950270f, -0.30011240f, -0.77946842f, 0.69288182f, 
    -0.01789279f, 0.40502948f, -0.06098906f, 0.06521703f, 0.03172233f, -0.39301914f, -1.06609213f, -0.52660006f, 
    0.21486737f, -0.11150309f, 0.34066215f, 0.32173592f, 0.34841669f, 0.18704401f, 0.01112912f, 0.16284458f, 
    -0.55827683f, -0.29726580f, -0.24134740f, 0.31795597f, 0.66715103f, -0.04828295f, 0.47477192f, 0.39392063f, 
    0.31852630f, 0.21752363f, -0.36005333f, 0.45524514f, 0.15305647f, 0.07464294f, 0.23518914f, 0.04837564f, 
    -0.19383627f, 0.15123017f, -0.12674156f, 0.02301871f, -0.04988203f, -0.25980997f, 0.18447751f, -0.02664345f, 
    -0.03681325f, 0.14136207f, -0.15141283f, -0.19119845f, -0.20801926f, -0.17699663f, -0.05722682f, 0.07646989f, 
    0.55811328f, 0.34347489f, -0.09457892f, 0.73110104f, -0.69829917f, -0.33850160f, 0.19733410f, 0.36092642f, 
    0.04452850f, -0.11173608f, -0.04368129f, -0.45979032f, 0.41147533f, -0.14315341f, 0.69887882f, -0.11915697f, 
    -0.12134372f, 0.20920111f, -0.19953164f, 0.47342968f, -0.32854012f, -0.58304155f, -0.06037233f, -0.54164743f, 
    -0.09411711f, -0.07144369f, 0.21473025f, 0.34973311f, -0.06144769f, 0.63748181f, -0.22531354f, 0.29832241f, 
    0.10644978f, 0.71920449f, -0.20660621f, -0.13352999f, -0.33473790f, 0.45442238f, -0.15615520f, 0.38589361f, 
    -0.20079507f, -0.06846885f, 0.31397659f, 0.53251046f, 0.24832620f, -0.15684414f, 0.31658858f, -0.47098938f, 
    0.42885488f, 0.01073241f, 0.15183392f, -0.40756032f, -0.18050824f, 0.26012242f, -0.12703151f, -0.32040915f, 
    0.22400241f, -0.00865020f, 0.38994789f, -0.73902243f, -0.31088564f, 0.25708094f, -0.60913008f, 0.45354035f, 
    0.15192126f, 0.52370596f, 0.12056823f, 0.74481881f, 0.17001905f, -0.38705266f, -0.21299414f, 0.36350632f, 
    0.42375180f, -0.12138607f, 0.13577451f, -0.19445455f, -0.20367649f, -0.28879324f, -0.28343940f, 0.15683950f, 
    -0.10734437f, -0.73726290f, 0.24164604f, -0.18704163f, -0.08984182f, -0.01351068f, 0.03875695f, -0.13071729f, 
    0.25389692f, 0.11506739f, 0.22489843f, 0.16805173f, -0.39996812f, 0.43524572f, -0.57221276f, 0.48321590f, 
    -0.50677091f, -0.02278939f, -0.09515771f, 0.38950250f, 0.16246876f, -0.11371592f, 0.94010407f, 0.66579145f, 
    -0.12015653f, 0.12458887f, 0.16281293f, 0.35380825f, -0.55735332f, 0.20766085f, 0.07044643f, -0.05795054f, 
    0.18671030f, -0.18620744f, -0.01994494f, -0.13443235f, -0.08641121f, 0.05253148f, -0.00094616f, -0.11911330f, 
    0.09347603f, 0.01882982f, -0.12478912f, -0.15046880f, 0.00395596f, -0.22500268f, -0.03041458f, -0.07614619f, 
    -0.34945464f, 0.48749560f, 0.23462662f, 0.03686588f, 0.44045705f, 0.26142660f, -0.39542016f, -0.39914185f, 
    0.43786430f, -0.16269475f, -0.32417116f, -0.09250288f, -0.48777187f, 0.39658231f, 0.38671511f, -0.25557715f, 
    -0.59982705f, -0.35463312f, -0.11906739f, 0.05985860f, 0.13888274f, 0.07829200f, 0.14217140f, -0.09547478f, 
    -0.43374830f, -0.09467805f, 0.44915003f, 0.85157239f, -0.05175204f, 0.01500865f, 0.22334199f, -0.26891160f, 
    0.24002913f, -0.54283297f, 0.12547402f, 0.76781732f, -0.04152376f, 0.33936271f, -0.37216336f, 0.70368326f, 
    -0.39941660f, 0.02981597f, 0.16252255f, -0.25827718f, -0.37945810f, 0.15067330f, -0.42096624f, 0.52629590f, 
    -0.15925381f, -0.04395116f, -0.18106066f, -0.07539899f, 0.57639724f, -0.03221034f, 0.02255144f, 0.14258651f, 
    0.46299568f, -0.14016597f, 0.10642210f, -0.49724618f, -0.18413511f, -0.24318185f, -0.03543049f, -0.02127297f, 
    -0.10746285f, -0.61381853f, -0.01605049f, -0.27988595f, -0.23445208f, -0.08504488f, -0.31756428f, 0.36719301f, 
    0.33646989f, -0.09553161f, 0.36831161f, -0.39741808f, 0.72091943f, 0.14137658f, 0.25549909f, -0.26872030f, 
    0.57680559f, 0.42473051f, 0.14987600f, 0.48468617f, -0.03712523f, 0.30062413f, -0.29028115f, 0.27411672f, 
    0.04204997f, -0.05888224f, 0.36473244f, -0.40134957f, 0.08161706f, -0.54712266f, -0.04660004f, -0.10419036f, 
    0.40218866f, 0.28842822f, -0.05158905f, -0.48825786f, -0.33792818f, 0.51657289f, -0.20021065f, -0.37283060f, 
    0.48818317f, 0.14412060f, 0.34905726f, -0.30690563f, 0.68943000f, -0.04866775f, 0.31004855f, -0.54295635f, 
    0.06300922f, 0.45716208f, 0.07167648f, -0.39935073f, 0.38225389f, 0.37876931f, -0.47403541f, -0.50269020f, 
    0.55854517f, 0.25163898f, -0.00106733f, -0.19776696f, -0.20826133f, 0.27923501f, 0.18495512f, 0.15329154f, 
    0.14851347f, -0.11269316f, -0.24968423f, 0.22104950f, -0.20525615f, 0.06099017f, -0.23499316f, 0.02074400f, 
    -0.18098925f, 0.05113789f, -0.20109345f, -0.06153183f, -0.19136940f, 0.02254036f, -0.21189250f, -0.18520629f, 
    0.26043558f, 0.34311122f, 0.17398264f, 0.16751045f, 0.28966698f, 0.01104342f, 0.39511475f, 0.15282892f, 
    0.06006080f, 0.22537459f, -0.32508042f, 0.42843470f, -0.77903020f, 0.43121627f, 0.00938058f, 0.49261665f, 
    0.05910931f, -0.42665347f, 0.18453154f, -0.04399193f, 0.00867247f, 0.62214965f, 0.47238335f, 0.25112632f, 
    -0.20026237f, -0.18536028f, 0.31710207f, 0.12921466f, 0.69837153f, -0.06684225f, 0.28618810f, -0.33819604f, 
    0.47290173f, -0.17241609f, 0.16280031f, -0.32317221f, -0.04371401f, 0.47361961f, 0.31193382f, -0.09049109f, 
    -0.22088976f, -0.02947601f, 0.07250205f, 0.06444873f, -0.15824495f, 0.21499753f, -0.49549520f, 0.29061010f, 
    0.08935815f, -0.57955205f, -0.21322896f, -0.32349655f, 0.20883295f, 0.21494955f, -0.04293383f, 0.46386233f, 
    -0.40858856f, 0.19293776f, 0.28547379f, 0.07960106f, -0.05571048f, -0.17855670f, -0.21560000f, -0.10184405f, 
    -0.07853489f, 0.11547444f, -0.09773183f, -0.05692830f, -0.06103859f, -0.16524303f, 0.09585671f, 0.08825922f, 
    -0.17935684f, -0.06667480f, -0.15600567f, 0.01407233f, 0.04917119f, 0.09284656f, -0.08318798f, -0.05823502f, 
    -0.32994434f, -0.36987430f, 0.01585519f, -0.03683204f, 0.49858046f, 0.08953080f, 0.47093844f, -0.64950663f, 
    0.46492121f, 0.11265755f, -0.07476571f, 0.69247472f, 0.07657683f, -0.10776756f, 0.09337611f, 0.19826320f, 
    -0.44484922f, -0.23821108f, -0.06442713f, 0.31821632f, -0.04960553f, 0.23329319f, -0.71757275f, -0.11672417f, 
    -0.16311552f, -0.22316733f, 0.44613001f, -0.09320141f, 0.21588477f, 0.13778272f, -0.16389993f, -0.19398372f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13942374f, -0.10993800f, -0.17199762f, -0.08479869f, 0.02872990f, 0.08275989f, 0.05798216f, -0.05052965f, 
    -0.17808428f, 0.49206993f, 0.22064276f, 0.54562461f, 0.19117120f, 0.38315013f, 0.05992387f, -0.21810654f, 
    0.46363801f, 0.13243847f, 0.20941378f, 0.17274463f, 0.15909068f, 0.09955690f, -0.01091514f, 0.40559089f, 
    0.19558106f, -0.12365216f, 0.27084675f, 0.38568935f, -0.36350161f, -0.24360399f, 0.18678527f, 0.24963695f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.02122641f, -0.48190269f, 0.07150321f, -0.71340197f, 0.42906749f, -0.07786585f, 0.22947569f, 0.01536658f, 
    -0.34801525f, -0.40524873f, -0.67566800f, 0.24808408f, 0.44950235f, 0.14892487f, -0.06875118f, 0.09342784f, 
    -0.16316518f, -0.68482167f, 0.40111455f, 0.49417165f, 0.21656756f, 0.34122831f, -0.26387596f, -0.10621855f, 
    -0.07440921f, -0.20573916f, -0.20414387f, -0.01811368f, -0.69298208f, -0.00292521f, 0.07472693f, -0.06026065f, 
    -0.82983702f, -0.60320002f, 0.04816903f, 0.87186247f, -0.09478229f, -0.08715060f, 0.28826639f, -0.02105663f, 
    0.12478552f, -0.14118795f, 0.03358908f, 0.20057455f, 0.02711941f, -0.08572442f, 0.23362657f, -0.03610223f, 
    0.45746142f, -0.15933657f, -0.33367541f, 0.35003591f, -0.66784036f, -0.02128695f, -0.36686829f, 0.20974520f, 
    -0.16717039f, 0.31047034f, -0.40289262f, 0.13721369f, -0.31771511f, -0.16942820f, 0.17519273f, -0.78303611f, 
    -0.76704448f, 0.22871101f, 0.18696046f, -1.93594360f, 0.17333044f, -0.90421480f, -0.38204542f, 0.16710994f, 
    -1.20905197f, -1.06309319f, 0.38901007f, 0.19051753f, -0.66390353f, -0.00941567f, -0.08522782f, -0.11823778f, 
    0.02388547f, -0.18991588f, 0.66185468f, -0.13886520f, -0.32250163f, 0.14146514f, 0.10179152f, 0.04414636f, 
    0.03587906f, 0.02700087f, 0.55650014f, 0.39467722f, 0.21462229f, -0.11045795f, -0.32951662f, 0.21615726f, 
    0.11735439f, 0.37035659f, 0.20054927f, -0.17324062f, -0.74751425f, 0.27490169f, -0.29562429f, -0.05187196f, 
    0.47010857f, -0.26673880f, 0.22907673f, -0.09967648f, -0.03736234f, -1.09770477f, -0.56787497f, -0.04996873f, 
    0.04630437f, -0.00054219f, -0.99920338f, 0.06501481f, 0.23126444f, 0.32996988f, 0.43938479f, -0.00741295f, 
    0.13168764f, -0.64409661f, 0.22069599f, -0.30612400f, -0.22646050f, 0.10253192f, -0.07603373f, -0.17378418f, 
    0.47098741f, 0.07686949f, -0.11861636f, -0.77819335f, 0.16832168f, -0.14197041f, -0.57616204f, 0.08355848f, 
    0.44225726f, 0.23602489f, 0.23298469f, 0.31642631f, -0.05334175f, -0.09691481f, 0.06133865f, -0.15441360f, 
    -0.22723059f, -0.25612432f, -0.19174661f, -0.24726850f, 0.00379724f, 0.12680045f, 0.25666371f, -0.05960519f, 
    -0.09016387f, -0.16949192f, -0.09875476f, 0.08619597f, 0.13571495f, 0.04681772f, -0.13150746f, -0.25539073f, 
    -0.27870017f, 0.28882220f, -0.37340659f, -0.20187785f, -0.17943069f, 0.27755287f, 0.18134513f, 0.13501081f, 
    0.34953922f, 0.28166887f, -0.10794114f, -0.11615097f, 0.18650009f, 0.08617333f, 0.14122753f, -0.16057612f, 
    0.58917111f, 0.32232347f, -0.14010079f, 0.03049150f, -0.41448194f, -0.27927694f, -0.23851418f, 0.05975541f, 
    0.14703459f, 0.04892744f, -0.64482594f, -0.31475258f, -0.31432495f, -0.09622149f, -0.00302914f, 0.21586426f, 
    -0.29615521f, 0.17142628f, -0.74069470f, -1.30256903f, 0.49282962f, 0.43090159f, -0.30379674f, 0.02793149f, 
    -0.64228380f, 0.29608470f, -0.22062308f, 0.35634166f, -0.02534649f, 0.24986415f, -0.45623997f, -0.16321188f, 
    -0.26460186f, -0.44794253f, 0.11311188f, -0.33810514f, -0.28977978f, -0.01775776f, -0.10028915f, 0.09375899f, 
    -0.16176049f, 0.12736785f, -0.54868031f, 0.16059779f, -0.68825036f, -0.15118109f, -0.16568610f, 0.01716240f, 
    0.32391560f, 0.23580723f, 0.24898919f, 0.35366213f, -0.08652917f, -0.54916102f, 0.37044576f, -0.03599718f, 
    0.42269418f, -0.71563995f, 0.26038593f, -1.37547994f, 0.37245134f, -0.87284654f, 0.30873427f, -0.00389637f, 
    -0.18753445f, -0.64825231f, 0.14382331f, -0.00791795f, -0.07214422f, 0.27654326f, -0.11477180f, -0.44353774f, 
    0.09161452f, 0.26844299f, -0.08929938f, -0.47362587f, -0.01649041f, -0.08765922f, -0.73159730f, -0.65820235f, 
    -0.46258077f, -0.35334077f, 0.48660949f, -0.44900876f, -0.14625372f, -0.38686270f, 0.68346000f, -0.05991887f, 
    -0.17913717f, 0.07535317f, -0.29479504f, -0.75570911f, -0.38524792f, 0.08449634f, 0.36582211f, 0.15271582f, 
    -0.17423619f, 0.65949416f, -0.41745189f, -0.32460329f, -0.82310939f, -0.72473252f, -0.64717501f, -0.27677464f, 
    0.10068326f, 0.17382552f, 0.32357347f, 0.12980053f, -0.39749959f, -0.07511214f, 0.58413970f, -0.64690757f, 
    0.44848594f, 0.71011448f, -0.33210337f, -0.21659845f, -0.45041183f, -0.41139463f, 0.21351922f, -0.02078948f, 
    0.20972805f, 0.25853306f, -0.58770514f, 0.28324309f, -0.49568069f, 0.39361539f, 0.29210737f, -0.06634430f, 
    -0.33451572f, -0.13442694f, 0.16580272f, -0.06723105f, 0.48916623f, -0.51399112f, -0.42557496f, -0.20230496f, 
    0.08270681f, 0.03828538f, -0.09842219f, 0.19467834f, -0.40719196f, -0.18511465f, -0.23856707f, 0.03729029f, 
    -0.01491292f, -0.56987190f, -0.33046022f, 0.74409503f, -0.76315141f, -0.03743739f, 0.31923211f, 0.07265265f, 
    -0.74467939f, -0.90573871f, 0.37906662f, -0.02450798f, -0.50761831f, -0.04563036f, -0.39690033f, -0.07403947f, 
    0.48159385f, -0.10612989f, -1.24703085f, 0.32016134f, 0.37982935f, -0.21649988f, 0.56363600f, 0.29473361f, 
    -0.13728337f, -0.42296919f, 0.33614844f, -0.05164804f, 0.39913738f, 0.03297414f, 0.16156751f, -0.01405587f, 
    0.07799418f, -0.46326205f, -0.32479599f, -0.44655752f, 0.39985368f, 0.23348321f, -0.09151924f, 0.05489485f, 
    -0.52202481f, 0.22473092f, 0.38998032f, -0.25742170f, -0.12440722f, -0.08981180f, 0.11793819f, 0.04020630f, 
    -0.87829584f, 0.82495064f, 0.27823380f, -0.31198981f, -0.09000167f, 0.20191933f, -0.27930623f, -0.48330981f, 
    -0.01565119f, -0.45868102f, 0.25412908f, -0.10934805f, 0.67349118f, -0.06210752f, -0.15201454f, 0.52238816f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.15255758f, 0.07749417f, 0.01147969f, 0.05164291f, -0.00976234f, 0.15319747f, 0.11315853f, -0.78800327f, 
    -0.15856028f, -0.17597912f, 0.23718195f, -0.18281871f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
